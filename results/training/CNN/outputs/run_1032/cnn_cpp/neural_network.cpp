#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.15629664f, 0.23256411f, -0.39947173f, 0.02236438f, 0.41386417f, 0.16087113f, 0.01823146f, -0.21780154f, 
    -0.37646559f, 0.06812371f, 0.27045792f, -0.15368839f, -0.08644828f, 0.12761167f, -0.05911785f, 0.21547312f, 
    -0.39156646f, 0.22324769f, -0.18454371f, -0.21854873f, -0.25174406f, 0.19846441f, 0.24389841f, 0.17039095f, 
    0.37338287f, 1.16732562f, -1.12382424f, -0.04084848f, 0.44214433f, -0.35721397f, -0.10211455f, 0.37264764f, 
    0.15112185f, -0.91209036f, -0.63669717f, -0.19322352f, -0.23388763f, -0.17505057f, -0.35202944f, 0.37101251f, 
    -0.24069306f, 0.15429783f, -0.11489715f, -0.28618604f, 0.03693476f, 0.05129109f, -0.19184759f, 0.00737176f, 
    0.24559544f, -0.16381966f, -0.63365495f, 0.90231484f, 1.00413764f, 0.26822600f, -0.41108415f, -0.47194096f, 
    -0.62537283f, -0.43565884f, 0.15306096f, 0.01478354f, -0.34329376f, -0.29398209f, -0.13773838f, 0.16063975f, 
    0.11227477f, 0.24377383f, 0.16666241f, -0.07905594f, -0.08044618f, 0.27155495f, -0.02602391f, -0.02592615f, 
    -0.07536266f, -0.16018616f, -0.39962411f, 0.25711170f, 0.08521856f, 0.06086877f, 0.48849219f, -0.40644741f, 
    0.05344361f, -0.03380226f, 0.02478004f, -0.12858500f, -0.19648126f, -0.12314916f, 0.18146551f, -0.02823137f, 
    -0.07888614f, 0.24698037f, -0.19303933f, -0.12267237f, -0.09782163f, -0.13934219f, 0.21975116f, 0.17739312f, 
    0.02028777f, 0.03980801f, 0.03123025f, 0.04114761f, 0.09055130f, 0.39654443f, 0.07112461f, -0.14756858f, 
    -0.12769836f, 0.14257693f, -0.18081237f, 0.29344743f, -0.13609473f, -0.06491993f, -0.11454400f, 0.38061699f, 
    -0.40419456f, 0.33826414f, -0.10817582f, 0.06852519f, 0.05396758f, -0.44957244f, -0.00504652f, 0.20988087f, 
    0.15160784f, 0.40577438f, 0.36632159f, 0.31618726f, 0.17724709f, 0.56624091f, 0.21137750f, 0.05782112f, 
    -0.43761462f, 0.01902360f, 0.05582143f, 0.34653035f, -0.31171170f, 0.18523227f, 0.26369271f, 0.13007767f, 
    0.12176483f, -0.20123476f, -0.34315476f, 0.24210487f, 0.07507218f, -0.14135231f, -0.02926655f, -0.04769270f, 
    -0.17102028f, -0.21402378f, 0.40305617f, 0.23256353f, -0.38665617f, 0.09903927f, -0.98290914f, -0.14163621f, 
    -0.86470908f, -0.30247417f, -0.18993215f, 0.27589273f, -0.02613281f, 0.03363068f, 0.44863895f, 0.41628519f, 
    0.30744249f, 0.08773363f, 0.03755254f, -0.09855462f, 0.12794463f, -0.00991542f, -0.07539766f, -0.07564573f, 
    0.25380963f, 0.06731488f, -0.07766034f, -0.05157152f, -0.23099573f, -0.20854241f, -0.21024622f, -0.46444488f, 
    -0.47851795f, -0.49417689f, -0.56043285f, -0.34026283f, 0.11756860f, -0.44839039f, -0.44643492f, -0.23203650f, 
    0.34179664f, -0.42205516f, 0.04281492f, 0.18514684f, 0.27380547f, 0.03160346f, 0.01687107f, -0.06905028f, 
    -0.15637097f, 0.29129064f, -0.08859213f, 0.28250590f, 0.27146277f, 0.30982095f, 0.06892724f, 0.35424137f, 
    -0.65598714f, 0.49035874f, 0.74821168f, -0.41785032f, -0.64036489f, -0.37192491f, 0.28994864f, 0.55104488f, 
    -0.10235482f, -0.09231982f, -0.05018296f, -0.35402161f, 0.57263559f, -0.62195706f, -0.21372190f, 0.08668040f, 
    0.32704738f, -0.04162112f, -0.12566312f, 0.06147730f, -0.10344213f, -0.23609918f, -0.31758574f, 0.12677854f, 
    0.48309949f, -0.46539685f, -0.11854246f, -0.32903561f, -1.04124033f, -0.94438416f, 0.14042355f, 0.31386837f, 
    0.63153124f, 0.29882652f, 0.12626567f, -0.21724284f, -0.31513935f, -0.16335753f, -0.33169755f, 0.01462129f, 
    -0.17247343f, 0.07923689f, -0.38391969f, -0.20892301f, 0.33503354f, -0.01467093f, 0.06543569f, -0.06398702f, 
    -0.15188912f, 0.10499407f, 0.15073545f, -1.29515851f, -0.88925064f, 0.19248168f, 0.29907426f, 0.40432775f, 
    0.74068654f, 0.56809372f, 0.00508695f, -0.18331686f, 0.10925008f, 0.16657495f, 0.09797451f, -0.28940883f, 
    -0.01256710f, -0.05855855f, 0.19642197f, 0.00453383f, -0.47332591f, -0.18785307f, 0.14072655f, 0.08543736f, 
    0.28730759f, 0.25216147f, -0.10394330f, 0.87654477f, 0.16814828f, -0.32251513f, -0.87364364f, -0.65839696f, 
    0.79649007f, -0.27800474f, -0.11455535f, -0.42393842f, -0.58897603f, 0.32278994f, -0.25025135f, 0.39787868f, 
    -0.03541033f, -0.41277096f, -0.38487855f, -0.29851580f, 0.30427444f, -0.43108487f, -0.35021231f, 0.26915494f, 
    0.07052753f, -0.18719274f, 0.12663616f, 0.13564943f, 0.50631136f, 0.27680412f, 0.29072085f, 0.30790251f, 
    -0.28595549f, 0.04572921f, -0.01073275f, 0.15434775f, 0.16205688f, 0.01392219f, 0.23717119f, -0.03209360f, 
    -0.30985111f, -0.46039784f, -0.07036958f, -0.26091069f, 0.03498096f, 0.21177506f, -0.22791304f, -0.33187357f, 
    -0.40501761f, -0.27493113f, -0.44480395f, -0.45953080f, -0.58264548f, 0.33038709f, -0.06531419f, -0.78741354f, 
    -0.28711584f, -0.72280169f, 0.11628058f, 0.20969880f, 0.21974564f, 0.30898261f, -0.04059755f, -0.34066495f, 
    -0.64991105f, -0.34525749f, 0.03588147f, 0.22213563f, 0.15475899f, 0.28873479f, 0.00416600f, -0.12090359f, 
    -0.40615931f, -0.53541350f, -0.27330574f, 0.01451508f, -0.20553955f, -0.65731329f, -0.78249598f, -0.22946049f, 
    -0.24719079f, 0.37538952f, 0.36041221f, 0.35020345f, 0.25246722f, -0.14313962f, 0.03465569f, -0.29796520f, 
    0.35072336f, -0.03616629f, 0.13687137f, 0.22590521f, 0.05853057f, -0.04572435f, -0.32764322f, -0.03279314f, 
    0.19308804f, -0.18256779f, -0.09285968f, -0.10111491f, -0.02814500f, -0.13156936f, -0.34700567f, 0.65902001f, 
    0.44811648f, 0.39547846f, 0.13636872f, -0.07852092f, -0.52964729f, -0.32919684f, 0.00095998f, 0.30798420f, 
    -0.44480610f, -0.18879515f, 0.13418496f, 0.10617499f, -0.28912136f, -0.27338982f, -0.15030427f, -0.15991600f, 
    0.18470255f, 0.00083502f, 0.00889256f, 0.05682638f, 0.01679172f, 0.06755517f, 0.00195718f, -0.12448742f, 
    -0.88599390f, -0.74400324f, -0.38306364f, 0.87787241f, 0.39207593f, -0.64925283f, -0.45198569f, -0.58701950f, 
    -0.43551829f, 0.24070542f, 0.49364102f, 0.12093773f, 0.31354320f, 0.56962830f, 0.00387544f, -0.02569484f, 
    -0.09290231f, -0.21883449f, -0.35679448f, -0.24012154f, -0.02106080f, 0.19583540f, 0.02199001f, 0.06084461f, 
    -0.13898715f, -0.38445315f, -0.10748436f, 0.24070872f, 0.45742300f, 0.02379200f, -0.30633444f, -0.27755636f, 
    0.57375908f, 0.31615815f, 0.08374761f, -0.74374348f, -0.42970335f, 0.36103228f, 0.09613557f, 0.30195326f, 
    0.52404696f, -0.28929102f, -0.40943933f, 0.08799130f, 0.15730880f, -0.48508567f, -0.43739313f, -0.11263290f, 
    0.35534206f, 0.15046535f, -0.85383111f, -0.40885502f, -0.03619208f, 0.05454532f, 0.65999550f, -0.17352416f, 
    -0.12263775f, -0.55932492f, -0.63057578f, -0.46208596f, -0.19855414f, -0.35190028f, -0.02729124f, -0.02824693f, 
    -0.14640754f, -0.17952791f, 0.03016215f, 0.24564563f, 0.33268940f, -0.04045198f, 0.21769819f, 0.02187866f, 
    -0.05038620f, 0.17358062f, 0.09865573f, -0.18790734f, -0.36593822f, -0.25220895f, -0.36307532f, -0.34369680f, 
    -0.64712363f, -0.72448635f, -0.62472314f, -0.71446455f, -0.86098146f, 0.65869832f, 0.30395848f, 0.49993581f, 
    -0.18304217f, 0.16869552f, -0.08082031f, 0.07035331f, 0.19493686f, -0.13593964f, -0.11373966f, -0.03849813f, 
    0.04379544f, 0.19494177f, 0.09084350f, -0.11029895f, -1.15955734f, 0.08689900f, -0.15188541f, -0.86348462f, 
    -0.31904575f, -0.25171086f, -0.22206816f, 0.01251788f, 0.16155060f, 0.17675962f, -0.46906987f, -0.39592788f, 
    -0.16715614f, -0.60495770f, -0.35252148f, -0.00256486f, 0.14951916f, -0.06394393f, 0.34242550f, 0.12402909f, 
    -0.15571818f, 0.08948013f, -0.05106347f, -0.26874596f, -0.33333939f, 1.05953622f, -0.17414127f, -0.81154162f, 
    -0.11424891f, -0.47732672f, -0.11954512f, 0.26454794f, 0.32339123f, 0.40137345f, -0.14899369f, 0.07690553f, 
    0.48538965f, 0.26662543f, -0.26820600f, -0.02328367f, 0.02021956f, -0.23428448f, 0.03853295f, 0.04218842f, 
    -0.37556463f, 0.33347055f, 0.01586128f, 0.25573900f, -0.00309705f, -0.13155523f, 0.06966798f, 0.16457574f, 
    0.56885141f, 0.50517446f, 0.48578385f, 0.06948348f, 0.42799413f, 0.10413083f, -0.35523468f, -0.48278522f, 
    0.15998407f, 0.25156465f, 0.07759498f, 0.07440337f, 0.35833555f, -0.15335180f, -0.22161321f, -0.00253127f, 
    0.17798410f, 0.15662375f, 0.26923016f, -0.03672209f, 0.14954840f, -0.09606169f, -0.12015408f, 0.77740026f, 
    0.61807948f, -0.47148126f, -0.28881240f, -0.67527270f, -0.54973918f, -0.38633251f, 0.26336855f, 0.37516531f, 
    0.44381407f, 0.17994043f, 0.06109656f, -0.11452188f, 0.13623513f, 0.04725623f, -0.19955194f, -0.03006692f, 
    -0.10659461f, -0.18908310f, 0.18683495f, 0.22317719f, -0.23532832f, -0.02546972f, -0.06044754f, 0.11645954f, 
    0.94208825f, 0.83130646f, 0.26932758f, -0.27242893f, -0.82239348f, 0.20389272f, 0.05138433f, -0.00283654f, 
    -0.15211618f, 0.12631002f, 0.24786755f, -0.34417868f, 0.02249182f, 0.18503894f, -0.49590862f, -0.03944663f, 
    -0.10320758f, 0.07411873f, -0.09773965f, 0.12983194f, 0.08628936f, 0.08293182f, -0.24303272f, -0.03058552f, 
    0.17027541f, 0.04925979f, -0.22431232f, 0.16174521f, -0.01180309f, -0.21515819f, 0.72714031f, -0.45003274f, 
    -0.59045261f, -0.08172200f, 0.71205920f, -0.15180424f, 0.06483900f, -0.30008247f, 0.19024071f, 0.36776370f, 
    -0.24246880f, 0.12065258f, 0.14116371f, -0.03526932f, -0.43510848f, 0.05497247f, 0.02520842f, 0.10617208f, 
    0.41012219f, -0.21096426f, -0.76826102f, -0.62124586f, -0.49706823f, -0.53584486f, -0.67466873f, 0.45246652f, 
    0.44967356f, 0.51478136f, 0.33988729f, 0.34829125f, 0.31256205f, 0.21664126f, 0.29577160f, -0.17597495f, 
    0.13484280f, 0.05974093f, 0.16285478f, -0.08242346f, -0.26368010f, -0.14324529f, -0.16953050f, -0.16710761f, 
    -0.15212347f, 0.22051628f, 0.13138716f, 0.19927341f, -0.33886090f, -0.36216953f, -0.43513361f, -0.61863244f, 
    -0.37812519f, -0.33634564f, -0.45058885f, -0.33904958f, 0.07170815f, -0.22873434f, -0.08943534f, -0.15009218f, 
    -0.30760038f, 0.21484047f, -0.22484556f, 0.14012189f, -0.06154287f, 0.11432899f, -0.29136649f, -0.40571558f, 
    -0.21824768f, -0.12489022f, -0.38445559f, -0.43029910f, 0.70708615f, 0.28150749f, -0.07678676f, 0.12823126f, 
    0.14218961f, 0.13799062f, -0.28778380f, 0.14926928f, 0.09549291f, -0.24086763f, -0.18380426f, 0.56278676f, 
    -0.18011925f, -0.16554964f, -0.11097316f, 0.02445852f, 0.13584542f, 0.02336544f, -0.02541966f, -0.18017471f, 
    -0.39239606f, 0.31947008f, 0.34299248f, -0.06104727f, -0.18861985f, -1.00271285f, -0.15828098f, 0.33095703f, 
    0.44207865f, 0.61658239f, 0.36890694f, 0.45298275f, 0.17934294f, 0.03487288f, -0.07480434f, -0.32149535f, 
    -0.01541987f, -0.02587082f, 0.23973285f, 0.21043299f, -0.10755966f, -0.09756722f, -0.33357608f, -0.14906853f, 
    0.13042772f, -0.05708568f, -0.15237890f, 0.28896147f, 0.15866658f, -0.19929311f, 0.07874674f, -0.41272989f, 
    -0.22427310f, 0.15084115f, 0.25205937f, -0.24331746f, -0.12850770f, -0.14084738f, 0.05618199f, -0.06182053f, 
    0.40343308f, -0.17090291f, -0.13627662f, 0.53381890f, 0.00494823f, -0.20847408f, 0.03305661f, 0.03118605f, 
    -0.26497665f, -0.34365496f, -0.25257167f, 0.33589303f, 0.37626314f, 0.33534712f, 0.15357804f, -0.64957505f, 
    -0.39654863f, -0.07150338f, 0.45771569f, 0.65090460f, -0.39875934f, -0.48927709f, 0.12017997f, 0.63277572f, 
    0.47951132f, 0.22915870f, -0.24210860f, -0.56067073f, -0.00579958f, 0.48389915f, 0.19954230f, -0.18035929f, 
    -0.11182574f, 0.17319661f, -0.05996669f, -0.17674001f, -0.21740872f, 0.37633669f, -0.09655899f, -0.02962935f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00897560f, 0.10107620f, 0.21979390f, 0.19728667f, -0.01172851f, 0.40697777f, 0.11044291f, 0.07905843f, 
    0.39395472f, 0.07078949f, 0.26465082f, 0.13282014f, 0.08305711f, -0.14293550f, 0.19221681f, 0.21152361f, 
    0.38911259f, 0.27528530f, 0.26677781f, -0.10967996f, -0.18838251f, 0.16809495f, -0.15598577f, 0.28577891f, 
    0.24807106f, 0.32817757f, 0.24443240f, -0.31050932f, -0.03703835f, 0.33611083f, 0.17605959f, 0.39824200f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02741509f, -0.03978093f, -0.04071271f, -0.01734806f, 0.03230597f, -0.03508295f, -0.05106327f, -0.05578550f, 
    0.01137629f, -0.01514732f, -0.04369864f, 0.03923760f, -0.03005491f, -0.01509969f, -0.00703481f, 0.03521053f, 
    -0.05260537f, 0.03182472f, -0.04069418f, 0.00213490f, 0.02812237f, -0.01078872f, -0.00412662f, -0.02876665f, 
    -0.03769369f, 0.00430842f, -0.02948247f, 0.00941063f, -0.01580909f, -0.03278396f, -0.00860806f, -0.04319061f, 
    0.03832841f, 0.02420303f, 0.02450853f, 0.00862105f, 0.02511921f, -0.03024623f, 0.03646855f, -0.04008614f, 
    -0.00554325f, -0.03768495f, 0.03439029f, -0.00145582f, -0.00757957f, 0.01458370f, -0.02962311f, -0.01782086f, 
    0.01269649f, 0.03814685f, -0.00778445f, -0.01087214f, 0.05171951f, -0.03801980f, -0.01341394f, 0.02705394f, 
    -0.00960059f, -0.00922730f, 0.03611310f, 0.02624183f, -0.00238040f, -0.03235396f, -0.04926882f, -0.00977741f, 
    -0.05278138f, -0.00982104f, -0.02189635f, -0.00933247f, -0.00312607f, 0.04119874f, 0.03394207f, 0.01618392f, 
    0.00909007f, 0.00340738f, -0.04701853f, 0.02409378f, -0.02289660f, 0.02697570f, -0.03460113f, 0.01968293f, 
    -0.04470792f, 0.04500431f, 0.03092356f, 0.03732172f, 0.02300922f, 0.02361291f, -0.03264855f, -0.03993903f, 
    0.02267226f, -0.03883230f, -0.05640820f, -0.00326724f, 0.03271407f, -0.03034365f, 0.02397057f, -0.01414970f, 
    0.00217705f, 0.02367873f, -0.05389479f, -0.01908390f, -0.00944235f, 0.00614437f, 0.02541743f, -0.05544006f, 
    -0.04412619f, -0.01272496f, -0.04107200f, 0.02141002f, -0.02292192f, -0.03091769f, -0.00689193f, -0.04833492f, 
    0.02653167f, -0.01457518f, -0.03833030f, -0.04677223f, -0.03509257f, -0.03694075f, -0.01298066f, -0.03966406f, 
    -0.05156353f, 0.02095708f, 0.03078161f, 0.04039820f, 0.01611190f, -0.00713768f, 0.04031809f, 0.02526061f, 
    0.00310491f, -0.05572378f, 0.01140301f, 0.01759345f, -0.02897852f, 0.02429278f, -0.05543543f, 0.00530454f, 
    0.01765733f, 0.02607210f, -0.05454537f, -0.00977258f, -0.04934104f, -0.01531178f, -0.03313498f, -0.03843442f, 
    -0.01488398f, 0.01187450f, 0.03318004f, -0.00176129f, -0.00810032f, 0.00761840f, 0.03618404f, 0.02744794f, 
    -0.05382600f, 0.03388228f, -0.01769771f, -0.05384147f, 0.00671500f, 0.04393439f, -0.04135860f, -0.04202494f, 
    -0.04303025f, -0.04794014f, -0.04079597f, -0.00983193f, 0.04497119f, -0.00240838f, 0.00560556f, -0.02834226f, 
    0.01894446f, -0.03719183f, 0.01896982f, -0.00689621f, -0.01135436f, -0.04855778f, -0.04727597f, -0.03225580f, 
    -0.03755591f, -0.03011505f, -0.02277293f, -0.05249913f, -0.01407976f, -0.01200741f, 0.04694327f, 0.03869577f, 
    -0.01696618f, -0.03623376f, -0.02671653f, -0.00982930f, 0.04441136f, -0.02395651f, -0.00704682f, -0.00359600f, 
    0.04384045f, -0.00599193f, -0.03022649f, -0.05290911f, -0.00048563f, -0.02855938f, 0.01672578f, -0.03881260f, 
    0.04325975f, 0.03349684f, 0.00181784f, -0.03084507f, -0.05357426f, -0.01707273f, 0.00987678f, -0.03479030f, 
    0.01219701f, 0.02826534f, -0.03394537f, 0.01319036f, -0.00409103f, 0.02368423f, 0.00776946f, -0.01061416f, 
    -0.04410553f, 0.01255778f, -0.04327266f, -0.04981298f, -0.00459678f, 0.02739963f, -0.04538725f, -0.03846608f, 
    -0.02978562f, -0.01033048f, -0.01047972f, 0.01219202f, 0.01606270f, -0.00231743f, 0.03276459f, 0.04022212f, 
    0.01788513f, -0.05416509f, -0.02814168f, -0.03963871f, -0.01305692f, -0.00602385f, 0.03660195f, 0.01888898f, 
    -0.00662635f, -0.01113182f, -0.02832278f, -0.01847382f, 0.04368381f, -0.01340715f, 0.03383728f, -0.02283502f, 
    0.01803829f, -0.03543938f, 0.04123334f, -0.00025211f, -0.02710512f, -0.03519711f, -0.00233984f, 0.02111465f, 
    -0.04213690f, -0.01823158f, 0.01681590f, 0.01340599f, 0.02064420f, 0.01591106f, 0.03677743f, 0.03247580f, 
    -0.01167662f, -0.04467842f, 0.01940883f, 0.00981251f, -0.04499314f, 0.00314670f, -0.01129600f, 0.02139659f, 
    -0.02128326f, 0.04063729f, 0.02508529f, -0.02933811f, -0.05047891f, -0.05093465f, 0.01394816f, -0.00506054f, 
    -0.04846803f, -0.00120725f, 0.03924770f, -0.03464847f, 0.02208854f, 0.00586453f, -0.02259950f, 0.01560829f, 
    0.02727501f, 0.02560654f, -0.03886252f, 0.04262735f, -0.05462864f, -0.04068275f, -0.03107625f, -0.02238884f, 
    -0.03256469f, -0.00753280f, 0.02098428f, -0.05241295f, -0.03445811f, -0.02716475f, -0.02524312f, -0.05694228f, 
    -0.00009907f, -0.04851580f, -0.00706333f, 0.02490484f, -0.03991773f, -0.02609673f, -0.04673139f, -0.00855150f, 
    0.04222208f, -0.04547689f, 0.02387936f, 0.01189178f, -0.05266585f, -0.00496088f, -0.05408513f, 0.04125709f, 
    -0.01797091f, -0.05277552f, 0.02197156f, -0.01305029f, -0.02111042f, -0.03834061f, 0.00779798f, -0.04136578f, 
    0.04080673f, -0.02763776f, 0.01827440f, 0.00440384f, -0.00884762f, -0.04164539f, -0.05455815f, 0.03240943f, 
    0.00447357f, -0.05570706f, 0.03360304f, 0.02084523f, 0.04113787f, -0.00351428f, -0.04153366f, -0.00869327f, 
    -0.05460509f, -0.02096767f, 0.02775238f, -0.00712394f, 0.00872280f, 0.02516521f, 0.04438651f, 0.04493644f, 
    -0.03522052f, -0.00146936f, 0.01632595f, 0.00032866f, -0.00931768f, 0.03694553f, -0.02191759f, 0.05018506f, 
    0.00199849f, 0.01734134f, 0.04160798f, 0.01612141f, -0.01129934f, -0.03129739f, -0.00993690f, 0.03912699f, 
    0.02380492f, 0.02948697f, -0.03212694f, 0.02768172f, 0.02689245f, -0.03363201f, 0.02768295f, -0.03490597f, 
    0.00581327f, 0.03201914f, 0.03228989f, -0.05073215f, -0.02728462f, -0.01027057f, 0.00288987f, 0.00784080f, 
    0.01828569f, 0.06188962f, -0.10240079f, 0.08327626f, 0.02384217f, -0.08715598f, -0.07166287f, 0.19233161f, 
    -0.02736758f, -0.00691645f, 0.00134965f, -0.03940710f, -0.16078930f, 0.32059523f, 0.08327398f, 0.12573326f, 
    -0.10796545f, 0.13832089f, 0.25410900f, 0.15129653f, 0.02798997f, -0.03347651f, 0.03573638f, 0.01482899f, 
    0.14040673f, -0.36253351f, 0.04779375f, 0.16564184f, -0.04631955f, 0.17615499f, -0.01774282f, -0.00122358f, 
    0.05597650f, 0.03108131f, -0.02941884f, -0.07757152f, 0.02978612f, 0.05880337f, -0.09738416f, 0.05830375f, 
    0.10726053f, -0.02144808f, 0.11522245f, 0.01527096f, 0.01036834f, 0.02526774f, -0.09829987f, -0.07745612f, 
    0.15918347f, -0.06812152f, 0.09966557f, -0.07583240f, 0.08968693f, 0.07870390f, -0.08106215f, -0.03273150f, 
    -0.04679780f, -0.03490102f, -0.01168640f, -0.13744484f, 0.26655430f, -0.03371095f, 0.00711137f, 0.02934604f, 
    0.02683686f, 0.05327494f, -0.02549757f, 0.08485003f, 0.02097980f, -0.04790094f, 0.11077208f, -0.05560533f, 
    -0.17987716f, 0.17979661f, -0.00724252f, 0.10354993f, -0.03915782f, -0.07495532f, 0.02023370f, 0.05919424f, 
    0.02538891f, 0.06630953f, 0.07274869f, 0.01144505f, -0.08265038f, 0.11636174f, 0.13380016f, 0.20312570f, 
    -0.02511838f, -0.02246659f, -0.11282514f, 0.01502988f, 0.06221697f, 0.03844420f, -0.03842129f, -0.04621626f, 
    0.34334308f, -0.07808596f, 0.33822328f, -0.02816717f, 0.07369915f, -0.00571586f, 0.07094701f, 0.03386519f, 
    0.00576637f, 0.00000358f, 0.14689448f, 0.03031737f, -0.09492912f, 0.13615629f, 0.26550728f, 0.09227622f, 
    -0.00742136f, 0.02355088f, 0.05906842f, -0.06032514f, 0.12268249f, 0.05147455f, -0.06535818f, 0.02935318f, 
    -0.21355388f, 0.19150324f, 0.11718564f, -0.18680458f, -0.15225063f, 0.06693182f, -0.08985616f, 0.16185340f, 
    0.04745081f, 0.07438582f, 0.12131482f, -0.05155461f, -0.00840219f, -0.02681037f, 0.50798845f, 0.04782683f, 
    0.05762768f, -0.16091821f, 0.01830618f, -0.03407591f, 0.11287954f, 0.11144538f, 0.08648609f, 0.03822944f, 
    0.20840439f, 0.22148624f, -0.08058065f, 0.00510960f, 0.01653738f, -0.12891540f, -0.01318910f, -0.06437469f, 
    0.03579542f, 0.04334508f, 0.09224916f, 0.03242747f, -0.27295277f, 0.26448724f, 0.04508644f, -0.11858134f, 
    -0.07893650f, -0.02640841f, 0.03697151f, 0.00730689f, -0.08286052f, -0.06596794f, 0.01685879f, 0.10199382f, 
    -0.23539385f, -0.01053753f, 0.05850980f, 0.04693247f, 0.06875861f, -0.04472981f, 0.02320806f, 0.03513450f, 
    -0.02793827f, 0.13607460f, 0.02262012f, 0.08298128f, 0.47446945f, 0.08628477f, 0.35934538f, -0.12548602f, 
    -0.04869252f, -0.02410589f, 0.02480487f, -0.01265428f, -0.03718654f, 0.02699367f, -0.04866496f, -0.06571380f, 
    -0.30518836f, -0.08043075f, 0.01417220f, 0.35272315f, -0.03445115f, -0.04332652f, -0.00874108f, 0.15138231f, 
    -0.10193965f, 0.05248161f, 0.08959007f, -0.01141234f, 0.03036501f, -0.26007307f, 0.07204515f, -0.14527872f, 
    -0.16025321f, 0.05788200f, 0.02544831f, 0.09787593f, -0.09192692f, 0.07951582f, -0.09703797f, 0.05059923f, 
    -0.23491858f, -0.14248005f, 0.13686074f, 0.28632444f, -0.06313226f, 0.00134476f, -0.05656943f, -0.06835225f, 
    -0.06866109f, 0.03759110f, -0.03129936f, -0.02384986f, -0.08093912f, -0.10332393f, 0.35484183f, 0.30347094f, 
    -0.18596733f, -0.03156691f, -0.11929332f, -0.21976697f, -0.00561343f, 0.01198936f, -0.00144847f, -0.01569782f, 
    -0.11098126f, -0.29596126f, 0.01824001f, -0.00415799f, -0.13451478f, -0.19611096f, 0.02693141f, -0.03876225f, 
    -0.01025308f, 0.03349561f, 0.08425163f, -0.02885260f, 0.41262457f, 0.16706733f, -0.06221678f, 0.13727392f, 
    -0.10959668f, 0.02335535f, 0.03995147f, -0.06110318f, -0.08495785f, 0.01585972f, 0.28011459f, -0.19708613f, 
    -0.05151662f, -0.02830823f, -0.17578436f, 0.03905345f, 0.12615313f, -0.14047456f, 0.01333534f, 0.01700671f, 
    -0.01386656f, -0.13513735f, -0.08537897f, -0.00827143f, 0.38259718f, -0.22844018f, 0.12994918f, 0.18300961f, 
    0.14838575f, 0.05718679f, 0.02558540f, 0.11181008f, 0.03615652f, -0.05330774f, 0.07224777f, -0.02029440f, 
    0.74018961f, -0.28831351f, 0.17511483f, -0.12715262f, 0.06761538f, -0.04571636f, -0.15048413f, -0.06696430f, 
    0.00675518f, 0.02788766f, -0.06608219f, -0.11918280f, -0.37641275f, 0.48172188f, -0.34019482f, 0.46026877f, 
    0.21888827f, 0.08379919f, 0.21650583f, 0.03410882f, -0.04766008f, 0.03068109f, -0.00425049f, 0.01696166f, 
    -0.04456266f, 0.23315306f, 0.19498998f, 0.01624960f, 0.01907810f, -0.06548814f, 0.08323321f, -0.03253116f, 
    -0.00589481f, 0.01241368f, 0.03632950f, -0.03002218f, -0.16177924f, -0.02724969f, -0.02086993f, 0.14485727f, 
    -0.14944766f, -0.01218069f, -0.05513161f, -0.18203886f, 0.09140158f, 0.18881428f, 0.05537217f, 0.04142712f, 
    0.13224296f, -0.02295525f, 0.01648024f, 0.03255273f, 0.00429972f, 0.05521127f, -0.00102901f, -0.09825978f, 
    -0.01903076f, 0.00234608f, -0.04347097f, -0.00382959f, -0.23478392f, -0.21722226f, -0.10363960f, -0.05517646f, 
    0.08907200f, 0.01742741f, 0.06106047f, -0.02624463f, -0.05716787f, 0.07339596f, -0.13677987f, 0.07346906f, 
    -0.08329335f, 0.03763987f, 0.05087828f, 0.22906865f, -0.19437665f, 0.10177618f, 0.03022913f, 0.09431062f, 
    -0.04842957f, -0.10556159f, 0.04245109f, -0.09691579f, -0.13341765f, -0.14997780f, -0.41040319f, 0.24914514f, 
    -0.16254085f, 0.03080272f, 0.07272205f, 0.13771309f, -0.12586719f, 0.04808480f, -0.10140630f, 0.08630759f, 
    -0.05620363f, -0.03223075f, 0.01079282f, 0.06635694f, 0.01963144f, 0.06085985f, -0.04923637f, -0.03570571f, 
    -0.13503167f, 0.08682303f, -0.11139442f, -0.02993215f, 0.42461428f, -0.25047785f, 0.23842232f, -0.38471195f, 
    -0.05195073f, 0.10091264f, -0.11988229f, 0.15652949f, -0.04283000f, -0.01277301f, 0.19296120f, 0.17442396f, 
    -0.12526283f, -0.17552304f, -0.10572067f, -0.19618295f, 0.13169985f, 0.00881443f, 0.01062737f, 0.12624276f, 
    -0.00312769f, -0.02088154f, 0.10841863f, -0.00874582f, 0.12756550f, 0.07337527f, 0.00461984f, 0.00130994f, 
    0.01574812f, 0.04703041f, 0.04880619f, -0.06355977f, -0.02104444f, -0.01707767f, 0.04041934f, 0.03116522f, 
    0.06469525f, -0.11594728f, 0.03551761f, 0.00286853f, 0.01374347f, 0.07793407f, -0.16158471f, -0.01071819f, 
    -0.26214546f, -0.15445440f, -0.00119121f, -0.04759591f, 0.30482900f, -0.05351681f, 0.29373339f, 0.20414451f, 
    0.01404971f, -0.03147280f, 0.06188925f, 0.09083136f, -0.07559796f, 0.14134584f, 0.04838641f, -0.07414156f, 
    -0.23421775f, 0.13996716f, -0.04317618f, -0.13175656f, -0.06032185f, 0.10493880f, -0.01502944f, -0.09023702f, 
    0.12354004f, 0.02457830f, 0.01522401f, -0.04365989f, 0.09719411f, 0.19488890f, -0.02088017f, -0.14322302f, 
    0.02604418f, -0.07151643f, -0.00487684f, 0.08917049f, -0.21362314f, -0.16342874f, -0.12648799f, -0.04236945f, 
    -0.25815314f, -0.15673706f, 0.21005495f, -0.22218987f, -0.01781006f, 0.07501481f, 0.21332382f, 0.09824141f, 
    0.09040976f, 0.09851918f, 0.00172650f, -0.06031852f, -0.08574177f, 0.07241604f, 0.12638536f, -0.26891017f, 
    0.06059951f, 0.09068666f, -0.09511037f, 0.05192802f, -0.03979220f, -0.02960479f, 0.01436883f, -0.15199219f, 
    0.08743075f, -0.12666294f, 0.04595946f, 0.13318993f, -0.06748886f, -0.01254846f, -0.12575105f, -0.01238126f, 
    0.09566107f, 0.05233239f, 0.10268440f, 0.09278109f, 0.36674619f, -0.42937174f, -0.13224946f, -0.11489796f, 
    -0.04077109f, -0.12336476f, 0.02234312f, 0.18124668f, 0.04619335f, 0.06333810f, -0.06950696f, 0.22568804f, 
    0.05357789f, 0.12145225f, 0.15432961f, 0.07204022f, -0.05913639f, 0.05083424f, 0.04038974f, 0.01277934f, 
    -0.15249462f, -0.14115864f, 0.16916430f, 0.06547950f, 0.15613359f, 0.14275952f, 0.18549399f, 0.01046997f, 
    0.11990950f, 0.00659924f, 0.00266635f, 0.07476934f, -0.00515525f, 0.16264458f, -0.01845323f, -0.03230348f, 
    -0.02765470f, -0.10714415f, 0.03480337f, 0.30053854f, -0.00634564f, -0.10611463f, 0.03747543f, 0.08122034f, 
    0.07543813f, 0.09914590f, 0.01120882f, 0.04110248f, 0.31939751f, 0.28992087f, 0.00721551f, -0.00985488f, 
    -0.00571569f, 0.07677198f, 0.01347368f, -0.03603315f, -0.14554872f, 0.03683807f, 0.04466448f, 0.08381518f, 
    -0.28252587f, 0.22448389f, 0.04095088f, -0.12152773f, -0.01128129f, 0.02460556f, 0.11303992f, -0.14338724f, 
    0.13842194f, 0.07146188f, 0.06713708f, 0.00435996f, -0.05408251f, 0.00987191f, 0.51674187f, 0.13792191f, 
    0.11580957f, -0.06652848f, 0.10174984f, 0.00547753f, 0.13808720f, 0.06130290f, -0.04616387f, 0.01455728f, 
    0.19348331f, -0.10035180f, -0.01319613f, -0.04138649f, 0.05899573f, -0.07214747f, 0.06020021f, -0.03290332f, 
    -0.04223246f, 0.00560060f, 0.05593880f, -0.05662483f, 0.07268964f, 0.03928632f, 0.05419398f, -0.06213041f, 
    -0.19545932f, -0.05302928f, -0.08602234f, -0.07042639f, -0.06860232f, 0.04278285f, -0.04057782f, -0.02364604f, 
    -0.08946552f, 0.22072025f, 0.11400651f, -0.06709433f, -0.05329847f, 0.06655640f, -0.04370372f, -0.05250078f, 
    -0.07199048f, -0.01395939f, -0.12786047f, -0.16534609f, 0.33344361f, 0.07738810f, 0.09109264f, -0.08688676f, 
    -0.05685025f, 0.04921957f, -0.06329713f, 0.17169960f, -0.02662170f, 0.00027459f, -0.07292241f, -0.06805898f, 
    0.10178175f, 0.05869689f, 0.13407028f, 0.04498176f, -0.03970683f, -0.01727661f, -0.10115087f, -0.04649891f, 
    -0.04976035f, -0.03351828f, 0.02197097f, -0.02045581f, 0.27040046f, -0.20334564f, 0.30062059f, -0.09643483f, 
    0.06790935f, 0.00351675f, 0.21504088f, 0.18968290f, 0.07769665f, -0.06938687f, 0.16415684f, -0.00018185f, 
    0.37993234f, -0.11970618f, 0.29841465f, 0.04393341f, -0.11872924f, -0.15690179f, 0.14036401f, 0.02912532f, 
    -0.15684544f, 0.00152986f, -0.02737091f, 0.03404308f, 0.22078702f, 0.16830243f, -0.18762533f, 0.21179995f, 
    -0.01460654f, -0.05094976f, 0.12792867f, -0.03500947f, -0.00948719f, -0.02343169f, 0.19470118f, -0.06473032f, 
    0.00564204f, -0.00760241f, -0.10064559f, -0.21958686f, -0.08832572f, -0.05604707f, -0.07493885f, 0.01059226f, 
    -0.01092403f, 0.07422045f, 0.16311014f, -0.18651378f, 0.17505452f, 0.24665071f, -0.01719276f, -0.11607751f, 
    0.00949619f, -0.00632887f, 0.07377536f, 0.05380838f, 0.00256790f, 0.11572542f, 0.00242633f, 0.01553663f, 
    0.22040686f, 0.05607641f, 0.01845203f, 0.12735753f, -0.01499135f, 0.05442059f, 0.09954949f, 0.05647441f, 
    -0.17910345f, 0.04918170f, -0.08723161f, -0.03723080f, 0.00932666f, -0.23662761f, 0.21995641f, 0.15028977f, 
    -0.00150831f, 0.02050552f, 0.01781616f, 0.02837882f, 0.07397775f, 0.09809098f, 0.10644413f, 0.03256179f, 
    0.05312063f, 0.17545681f, -0.16503149f, -0.15356691f, 0.01001613f, 0.07080278f, -0.06209880f, 0.09726684f, 
    -0.05648932f, -0.00874221f, -0.03315562f, -0.04023540f, -0.31299031f, 0.36293772f, -0.00852494f, 0.29183906f, 
    0.01930586f, 0.10012715f, 0.06067323f, 0.06273940f, 0.00956820f, 0.00884300f, 0.06651849f, 0.11119295f, 
    -0.10201142f, 0.06779824f, -0.17930849f, 0.03910133f, 0.09795879f, 0.12840231f, 0.04406340f, -0.03699607f, 
    0.07897776f, 0.12569068f, 0.15184879f, 0.10473089f, -0.27457348f, 0.20409150f, -0.13098089f, 0.40891939f, 
    0.00967850f, 0.00248452f, -0.06244758f, 0.02701239f, 0.12845533f, 0.02654946f, 0.01365321f, 0.10644872f, 
    0.16659537f, -0.08061591f, 0.59664190f, -0.22473882f, 0.10737261f, -0.07116801f, 0.16303618f, 0.11592325f, 
    -0.10103476f, 0.06973318f, -0.07335623f, -0.11649101f, -0.12431307f, 0.08135479f, -0.05354088f, -0.01854493f, 
    -0.02210280f, -0.01115544f, 0.04712751f, -0.08536524f, 0.04362330f, 0.04046214f, 0.01623759f, 0.15258744f, 
    -0.06184675f, -0.11788402f, 0.10151532f, -0.02243795f, 0.12233441f, 0.07603217f, -0.09743248f, -0.02063560f, 
    -0.02808818f, 0.12157187f, 0.09174304f, 0.09974625f, -0.11861899f, 0.21558174f, -0.01748511f, 0.20252350f, 
    -0.07284550f, 0.02566491f, -0.04165626f, 0.01839340f, -0.03392398f, 0.12110481f, 0.11645399f, 0.25273791f, 
    -0.06888212f, 0.11056164f, -0.03071035f, 0.04914206f, 0.11166098f, 0.04085004f, 0.06734243f, 0.08630814f, 
    -0.19620977f, 0.13241573f, 0.10597572f, -0.15735179f, -0.04339408f, -0.02337157f, -0.04740078f, 0.11275031f, 
    0.29299894f, 0.08260688f, 0.03236767f, -0.07987283f, -0.10886885f, 0.01356750f, -0.03450955f, -0.11381695f, 
    0.45286387f, 0.00359227f, 0.54068738f, 0.07634441f, 0.13349472f, 0.14037938f, -0.12346353f, 0.14717008f, 
    0.04522099f, 0.04669846f, 0.21925014f, 0.15839919f, 0.49690756f, 0.01124803f, 0.25481129f, 0.28242975f, 
    0.06526539f, 0.14152360f, 0.03329859f, -0.01567412f, 0.02262398f, 0.10367007f, 0.07385691f, -0.00663145f, 
    -0.52211100f, 0.24411599f, -0.18968149f, 0.01654586f, -0.01373958f, -0.02818029f, -0.00745891f, 0.05383334f, 
    0.06329639f, 0.05404462f, 0.14424363f, -0.04301950f, -0.21526642f, -0.08012310f, -0.06213148f, 0.25914288f, 
    0.21608724f, 0.29718328f, 0.04723537f, -0.05682167f, 0.06728900f, 0.11391755f, 0.08722058f, 0.02630128f, 
    -0.31623602f, 0.00924806f, -0.26701507f, -0.05668643f, -0.03668324f, -0.09552869f, -0.14922670f, -0.01054063f, 
    0.06419615f, 0.06688922f, -0.18002293f, -0.06495217f, 0.05591324f, -0.01684458f, 0.07351604f, -0.03626170f, 
    -0.06622388f, 0.11734417f, 0.15083532f, 0.02589315f, -0.02201066f, -0.05227503f, -0.17090702f, -0.18656488f, 
    -0.22696200f, 0.07438116f, -0.19315186f, -0.18039775f, -0.10545668f, -0.03054837f, -0.06624507f, -0.04158916f, 
    -0.02136314f, -0.06769182f, 0.11968452f, 0.00573570f, 0.04452366f, 0.05587609f, 0.48895833f, 0.03613682f, 
    -0.10844386f, -0.09153983f, -0.17741172f, -0.04113942f, -0.12616007f, 0.03016458f, -0.14572135f, 0.00077062f, 
    0.02683128f, 0.02061055f, -0.30143654f, -0.14818245f, 0.17681333f, 0.04251241f, 0.11941982f, 0.17370261f, 
    0.05773365f, -0.05274967f, 0.07847753f, 0.00886531f, 0.36686587f, -0.07180249f, 0.22880690f, -0.20673315f, 
    -0.04323212f, -0.11308816f, -0.08198924f, -0.06425820f, 0.22063302f, -0.10705976f, 0.07761989f, 0.13953169f, 
    0.14584632f, 0.25509608f, -0.12990731f, -0.06326694f, -0.08207384f, 0.06626862f, 0.14595866f, -0.05074478f, 
    0.00792973f, 0.02649003f, 0.00156531f, 0.09501955f, -0.07743970f, -0.28576103f, -0.24269615f, -0.19106755f, 
    0.06989759f, 0.01160142f, 0.00589032f, -0.22100212f, -0.02696011f, 0.00081535f, 0.02468600f, 0.01083590f, 
    0.37076038f, 0.03676997f, 0.05479194f, 0.02793254f, 0.09288268f, 0.15241329f, 0.09872518f, 0.07437743f, 
    -0.08618803f, 0.04461525f, 0.09459554f, -0.05455499f, -0.30615354f, 0.03885748f, -0.14546390f, 0.30446315f, 
    -0.05270183f, 0.12188834f, 0.08393919f, 0.07503551f, -0.08227189f, 0.16166386f, 0.10927238f, 0.08014956f, 
    -0.20401295f, 0.06113789f, -0.15735111f, -0.13612516f, -0.12500319f, -0.02772987f, 0.05313550f, -0.11367126f, 
    -0.03108936f, 0.01833546f, -0.06548124f, 0.11156777f, 0.41287255f, 0.08232981f, 0.01406855f, 0.31378782f, 
    0.06785338f, 0.11763000f, 0.00721448f, 0.06009466f, -0.12829797f, 0.05884738f, 0.03866055f, 0.21313804f, 
    -0.44768664f, -0.15881531f, 0.42082113f, 0.11459500f, -0.09901842f, -0.07180034f, -0.15989764f, -0.00451802f, 
    -0.10574461f, 0.05908256f, 0.06451156f, -0.02925161f, -0.24936879f, 0.10271355f, -0.01835417f, 0.18107845f, 
    0.14947951f, 0.09786616f, 0.04790893f, 0.03787460f, 0.06004616f, 0.07700896f, -0.00210978f, 0.22643167f, 
    -0.37034315f, -0.03091501f, 0.10621957f, 0.12092372f, 0.00112640f, 0.07348643f, 0.05315056f, 0.13519888f, 
    0.15808025f, -0.00544070f, -0.05202085f, -0.02975079f, -0.17117071f, -0.10230203f, -0.17472117f, -0.03144817f, 
    0.06017321f, -0.04521407f, -0.05704193f, -0.03222987f, -0.08586142f, 0.05057216f, -0.15744913f, -0.13937369f, 
    -0.12346388f, 0.01042360f, -0.00051354f, 0.01177478f, -0.11431235f, 0.04985916f, -0.18453997f, 0.06713609f, 
    -0.03010279f, 0.12643044f, 0.03981681f, 0.09384175f, -0.22631302f, 0.05833540f, -0.26033089f, -0.35512099f, 
    -0.06382200f, 0.02738312f, 0.06688005f, -0.00979810f, 0.13808648f, 0.09280554f, 0.14682418f, 0.15218225f, 
    0.04556076f, 0.08961322f, -0.14958096f, -0.07452007f, 0.06526218f, 0.04812120f, -0.05384137f, -0.11078477f, 
    -0.01314893f, 0.09135123f, 0.03732496f, 0.12018279f, 0.06235841f, 0.12991484f, -0.25903469f, -0.10486855f, 
    -0.03740171f, 0.08061517f, 0.07214470f, 0.01314771f, 0.17539199f, -0.08724771f, 0.16991739f, 0.17854202f, 
    -0.04758238f, -0.02739675f, 0.00778938f, 0.02651085f, -0.00929400f, 0.05036992f, 0.03568523f, -0.00911014f, 
    0.02179425f, -0.00666653f, -0.02421029f, 0.02888318f, -0.05688712f, -0.00410709f, -0.01828220f, -0.03207578f, 
    -0.03946562f, -0.00287965f, -0.04889769f, 0.02109883f, -0.03394150f, -0.05112551f, -0.02820113f, 0.02158207f, 
    0.00341014f, 0.03681555f, -0.01821039f, 0.04125141f, 0.01204854f, 0.01155522f, -0.02999236f, 0.01263483f, 
    -0.00530837f, 0.01776860f, -0.05316663f, -0.03718041f, 0.03709531f, 0.00763041f, 0.01135737f, -0.04692103f, 
    -0.04026219f, 0.01084190f, 0.00767903f, 0.02548538f, -0.02968195f, -0.03874386f, 0.01998492f, 0.01138506f, 
    -0.01329906f, 0.02857758f, 0.03143229f, 0.01439563f, -0.05378744f, -0.04943231f, -0.01963585f, -0.05640705f, 
    -0.01225449f, 0.00691145f, -0.00402320f, -0.04508096f, 0.03259769f, -0.03254950f, -0.00385098f, -0.02099180f, 
    -0.05427466f, -0.01801453f, -0.01459498f, 0.00276708f, -0.00854903f, -0.03326301f, -0.03564978f, -0.03018566f, 
    -0.05106939f, 0.02463266f, 0.02429358f, -0.05434245f, 0.04153198f, -0.00971197f, -0.01436408f, 0.02129179f, 
    -0.00873532f, 0.00587143f, -0.04616193f, 0.03456375f, -0.01887855f, 0.03645880f, 0.02654292f, -0.04652713f, 
    -0.00565889f, -0.02886938f, -0.00682995f, -0.04929922f, -0.04078712f, -0.03134372f, 0.00787516f, -0.02646717f, 
    0.00093069f, 0.03239501f, -0.01818388f, -0.00484244f, 0.00221239f, -0.04628492f, -0.02741440f, -0.05350788f, 
    0.02567340f, 0.03908642f, -0.03261985f, -0.03422948f, 0.01221526f, -0.04435274f, -0.00748707f, -0.04508783f, 
    -0.00913743f, -0.04478689f, 0.02435261f, 0.03822752f, -0.02850799f, -0.01241465f, -0.01492098f, -0.03602240f, 
    -0.02230287f, -0.03777968f, 0.03186423f, -0.05283565f, -0.01290887f, -0.04788824f, -0.02051841f, -0.04335462f, 
    -0.03247640f, -0.03707690f, 0.04080003f, -0.05303022f, -0.04533236f, -0.02439233f, -0.03193592f, 0.04328622f, 
    0.02005098f, 0.00238291f, 0.04023965f, -0.04243905f, -0.03785228f, 0.00245810f, -0.00557092f, -0.01976957f, 
    0.00118172f, -0.00087251f, -0.00358113f, -0.03971018f, -0.01212109f, 0.03237462f, 0.01525998f, -0.02891967f, 
    -0.01415863f, -0.05467239f, 0.03899440f, 0.01923795f, -0.02051869f, 0.00977273f, 0.00830105f, -0.00194252f, 
    -0.00364508f, -0.00657110f, -0.01685744f, -0.01204984f, 0.01302281f, 0.03386794f, 0.03922908f, 0.02101498f, 
    -0.04185219f, 0.03521588f, 0.01812918f, -0.04729085f, -0.03963095f, -0.02475133f, -0.05533633f, 0.02459401f, 
    0.04397002f, -0.02827526f, -0.01084302f, -0.03154372f, 0.01571157f, -0.00985904f, 0.01421552f, 0.01378308f, 
    -0.02477283f, 0.00259300f, -0.01513398f, 0.02226269f, -0.02495134f, -0.01786410f, -0.02206835f, 0.02905411f, 
    -0.02258219f, -0.00310723f, -0.00794014f, -0.04408031f, 0.03837065f, 0.03709407f, 0.03074079f, 0.03980210f, 
    0.00503647f, 0.00407067f, 0.03684524f, 0.02913632f, 0.00071605f, -0.04729940f, 0.01953113f, -0.01011321f, 
    0.02553899f, -0.03930584f, 0.02665054f, 0.01377311f, -0.00233911f, -0.02068969f, 0.00379285f, -0.01187964f, 
    -0.00551090f, -0.05587000f, -0.02219962f, 0.01913210f, -0.03133118f, 0.03348495f, -0.02865329f, -0.03680118f, 
    0.04435516f, -0.01158637f, 0.02488790f, -0.04950806f, 0.04089138f, -0.01271093f, 0.04197083f, -0.01940122f, 
    -0.04317474f, 0.02477539f, -0.03683227f, 0.02518983f, 0.00932414f, -0.05516920f, -0.00200386f, -0.00402939f, 
    -0.04473531f, 0.02631016f, 0.01734191f, 0.01717849f, -0.04790609f, -0.05026751f, -0.02043704f, -0.01361614f, 
    0.00664689f, -0.02544058f, -0.02550266f, 0.02423312f, -0.03876850f, -0.01978663f, 0.00215332f, -0.02581475f, 
    -0.04215793f, 0.04278430f, -0.05338883f, -0.05236469f, 0.00756113f, -0.05277208f, -0.00581871f, -0.00069119f, 
    -0.02396902f, -0.03518653f, -0.00737831f, -0.04396569f, 0.04265127f, -0.03192167f, 0.02219587f, -0.03428825f, 
    -0.02645776f, 0.02906301f, 0.01291978f, 0.00142414f, -0.02696846f, 0.03566389f, 0.01863460f, -0.02828005f, 
    0.03398993f, -0.01153773f, 0.01171869f, 0.03164549f, -0.05663962f, 0.01076652f, 0.04172755f, 0.02715477f, 
    -0.00676492f, -0.03565272f, 0.01538914f, -0.02910339f, -0.03042693f, 0.00548663f, 0.02175783f, 0.04026937f, 
    0.03466909f, -0.00086245f, -0.02915220f, 0.04054626f, -0.03563076f, 0.01357059f, -0.00265747f, -0.05494539f, 
    -0.01837512f, 0.03087513f, 0.00294475f, 0.03330188f, 0.02343916f, -0.02267204f, -0.00664862f, 0.04193713f, 
    0.01959024f, -0.01289947f, 0.02081983f, -0.01418963f, 0.00992166f, 0.01896818f, -0.02415894f, 0.01422249f, 
    0.01215473f, -0.03397155f, -0.00990612f, 0.03814938f, -0.02531865f, -0.04048155f, 0.00030103f, 0.03121766f, 
    0.04129395f, -0.04635259f, 0.00998376f, -0.01978625f, 0.04441113f, -0.00755396f, 0.01591339f, -0.01996330f, 
    -0.03926565f, 0.01521069f, 0.03124481f, -0.01411119f, 0.03858169f, -0.02108601f, -0.02220185f, 0.03507580f, 
    -0.00237401f, -0.03381607f, -0.05053992f, -0.01475220f, -0.00974311f, -0.00296822f, -0.04386630f, -0.03045975f, 
    -0.03947354f, 0.02637359f, 0.00369964f, -0.02933540f, 0.02902807f, -0.04155821f, 0.03663678f, 0.00657760f, 
    0.00913462f, -0.05078590f, 0.02417261f, -0.02163634f, 0.03174568f, -0.05274106f, 0.02036274f, 0.03208914f, 
    -0.03425805f, -0.02349153f, -0.03976125f, 0.03715225f, -0.02454630f, -0.04681994f, -0.00088007f, 0.00984116f, 
    -0.04200484f, 0.02907889f, -0.01520930f, -0.05331329f, -0.02843450f, -0.05615016f, -0.02861067f, -0.01085906f, 
    0.14363725f, 0.02954978f, 0.00685627f, 0.03080130f, 0.08545072f, -0.03165837f, 0.04435634f, -0.19880006f, 
    0.10589129f, -0.06251744f, 0.06731234f, 0.12640308f, -0.27300599f, 0.11737406f, -0.17468920f, 0.36255088f, 
    0.29542437f, -0.00227077f, 0.03946147f, 0.15468808f, 0.00098512f, 0.01089371f, -0.04330291f, -0.11538380f, 
    -0.16616915f, 0.12592356f, -0.09041616f, 0.16764608f, -0.10821623f, 0.08508190f, 0.18215679f, 0.02892553f, 
    0.03413730f, 0.01923724f, -0.10352052f, -0.00231102f, -0.04496142f, -0.27122617f, -0.00350152f, 0.04542509f, 
    0.04488286f, 0.12520714f, -0.11895981f, -0.07872380f, 0.01670723f, -0.17431991f, 0.01493002f, -0.02361589f, 
    -0.08326901f, 0.12399896f, -0.10216469f, 0.07347183f, -0.00236605f, -0.03073166f, 0.05008236f, -0.05710268f, 
    0.16612706f, 0.11086573f, 0.00406030f, -0.07424283f, 0.13285674f, 0.19819000f, -0.28410244f, -0.09176371f, 
    -0.03352960f, -0.12537715f, 0.04625938f, -0.00388992f, 0.05883108f, -0.04897789f, 0.07565473f, 0.09122308f, 
    -0.13555865f, -0.04829771f, 0.09301592f, -0.03916178f, -0.01747828f, -0.05357923f, 0.06377876f, 0.10714072f, 
    -0.04908178f, 0.03712882f, 0.17164335f, 0.01243698f, -0.14026970f, -0.02109352f, 0.02285885f, -0.02633484f, 
    0.10509130f, 0.04216793f, 0.11553008f, -0.05986758f, 0.01767584f, 0.08501345f, -0.00962760f, 0.05650682f, 
    0.15245116f, -0.08327707f, 0.00295941f, 0.33839875f, -0.02722914f, -0.03257272f, -0.02812276f, -0.07006548f, 
    -0.12043867f, 0.04593859f, -0.12106088f, 0.18741019f, 0.15384512f, -0.19242661f, -0.08130886f, 0.07126445f, 
    0.07960138f, 0.00897240f, 0.04020967f, 0.07839154f, 0.08152451f, 0.03535667f, 0.09166719f, 0.09799715f, 
    0.07733712f, 0.49442968f, 0.01568295f, 0.08156167f, 0.14376375f, -0.11373977f, -0.08937427f, -0.09334026f, 
    -0.12178419f, 0.11998665f, -0.02664333f, 0.15878920f, 0.02595854f, 0.19914769f, -0.07973762f, 0.13878466f, 
    0.08125629f, 0.13150546f, -0.06176263f, -0.01733132f, -0.01333068f, -0.09785683f, 0.04275671f, -0.08759151f, 
    0.07990975f, -0.09084309f, -0.06954408f, 0.07922457f, -0.03260445f, 0.01423096f, 0.04884467f, 0.02702562f, 
    0.05397586f, 0.18534300f, 0.00492529f, -0.02244894f, 0.15695123f, -0.00576804f, -0.19773136f, -0.00176073f, 
    -0.07498472f, 0.06358010f, -0.05044487f, 0.08394290f, 0.14729396f, 0.01948508f, 0.05776413f, -0.02674301f, 
    -0.07335637f, 0.37638143f, 0.26579887f, -0.17825572f, 0.03997297f, 0.03306244f, -0.14762606f, -0.06710900f, 
    0.08785912f, -0.07187559f, 0.04082036f, -0.04376998f, -0.28066370f, -0.14254560f, -0.20468618f, 0.11003027f, 
    0.00535265f, 0.00902916f, 0.08724294f, 0.02745896f, 0.08143745f, -0.01574545f, -0.10638501f, 0.00173205f, 
    0.10480542f, 0.13961329f, 0.07249936f, -0.03333407f, 0.14681166f, 0.17593898f, -0.05862216f, 0.22052784f, 
    0.04080556f, -0.10665090f, -0.14272873f, 0.01821479f, -0.11991820f, 0.37473664f, -0.07888722f, 0.03660104f, 
    -0.08698326f, -0.20182861f, -0.19022320f, 0.02569864f, 0.02251668f, -0.11183649f, 0.02516374f, 0.16660559f, 
    -0.18639269f, 0.01879808f, -0.02646726f, 0.09023208f, 0.08837839f, 0.16569963f, 0.11828573f, 0.03282057f, 
    -0.06065857f, -0.00392070f, 0.03686058f, 0.13790822f, 0.04266811f, -0.03280027f, -0.03805691f, 0.00813327f, 
    0.25663924f, 0.15607980f, 0.11534719f, 0.07355871f, -0.02055528f, -0.05508163f, -0.03116988f, 0.06439181f, 
    0.05052905f, -0.14713447f, 0.03670177f, -0.01300897f, 0.01100355f, -0.02576420f, 0.07503381f, 0.14787240f, 
    0.03290097f, 0.06869216f, 0.02638305f, 0.04029213f, 0.07131936f, 0.34747422f, 0.03637395f, -0.06885959f, 
    0.00124278f, -0.07147545f, -0.14078639f, -0.05236875f, 0.13484287f, 0.08031152f, 0.03698400f, -0.07147639f, 
    -0.26606956f, -0.39265651f, 0.05879014f, 0.05805539f, 0.17522724f, 0.18709192f, 0.12184054f, 0.00192952f, 
    0.03223063f, -0.06330316f, -0.17062151f, -0.04087310f, 0.40779385f, 0.46395409f, -0.37655261f, -0.10066642f, 
    -0.28633562f, -0.11956134f, 0.12015607f, -0.05683888f, 0.09809384f, 0.02713865f, -0.01983544f, -0.12475173f, 
    -0.08527124f, 0.20772263f, -0.50912178f, 0.24035068f, -0.06766394f, -0.08438928f, 0.12986797f, -0.22487253f, 
    0.15288888f, 0.01858101f, -0.04593833f, -0.07703812f, 0.18017225f, -0.22686230f, 0.09235813f, -0.12827575f, 
    -0.07059231f, 0.10377275f, -0.06236855f, -0.09722982f, 0.26787779f, -0.07911459f, -0.02627328f, 0.16561574f, 
    -0.07510130f, 0.04715402f, 0.05897982f, 0.05852073f, 0.01894248f, 0.02423146f, -0.16366035f, 0.07606311f, 
    0.03811050f, 0.08344020f, 0.04882105f, 0.15758818f, -0.03666134f, -0.04109074f, -0.04184576f, 0.12179518f, 
    0.05225255f, 0.04103807f, 0.01242433f, 0.04726572f, 0.04834231f, 0.02714947f, 0.00259620f, 0.01511539f, 
    -0.15725578f, -0.32657710f, -0.16222262f, -0.04952927f, 0.04970912f, 0.11475727f, -0.17096126f, -0.02917929f, 
    0.09586605f, -0.14095527f, 0.09132139f, 0.00275717f, -0.01660044f, 0.71767926f, 0.21264037f, 0.12303687f, 
    -0.02301273f, -0.08035718f, -0.19212434f, 0.01038900f, 0.04195137f, -0.05330856f, 0.02976650f, -0.00406715f, 
    0.06849898f, -0.00687248f, 0.07259773f, -0.02882112f, 0.09456913f, -0.03680065f, 0.05658916f, 0.00665942f, 
    0.00047033f, 0.02695922f, 0.04405061f, -0.03252767f, -0.07753105f, -0.00447658f, 0.23510745f, 0.02271712f, 
    -0.10210606f, -0.03247708f, -0.05957479f, 0.10483168f, 0.16845982f, -0.00871656f, 0.06455960f, -0.13792929f, 
    0.10718344f, -0.26659322f, 0.14265262f, -0.17713079f, -0.05171119f, 0.06159935f, 0.04970587f, -0.12173876f, 
    -0.01402741f, 0.00998531f, -0.03171313f, 0.04694470f, 0.30485797f, -0.20914742f, 0.21391124f, -0.14744332f, 
    0.05606181f, -0.01160477f, -0.26212543f, -0.08748751f, 0.02283986f, -0.01274865f, 0.07367386f, -0.00566252f, 
    -0.24535678f, 0.21980134f, -0.25586200f, -0.16183621f, 0.10692258f, -0.13988629f, 0.13193485f, 0.20665875f, 
    -0.10281595f, 0.04067057f, 0.02682669f, -0.03240994f, 0.12370728f, -0.04048685f, -0.02323596f, -0.09483024f, 
    -0.12520206f, -0.07983030f, -0.20260264f, -0.05157988f, -0.02199426f, 0.04681129f, 0.03225141f, -0.00075903f, 
    -0.02730487f, -0.05230916f, -0.17928861f, -0.02635590f, 0.05963045f, 0.02949254f, 0.05811430f, -0.01441264f, 
    0.03416972f, 0.03319890f, -0.03779295f, 0.08837611f, 0.25674912f, 0.19773532f, 0.26265913f, -0.02088910f, 
    -0.07333227f, -0.00529041f, -0.06903473f, -0.06195455f, 0.22393571f, 0.24394058f, -0.02776930f, 0.08265153f, 
    -0.08422501f, -0.09887598f, 0.09994321f, -0.00542589f, -0.18333000f, -0.08633688f, -0.08416347f, -0.00189201f, 
    0.02719828f, -0.11440554f, 0.04335445f, 0.07458223f, -0.14049359f, -0.25344712f, 0.19596346f, 0.01495155f, 
    -0.02246604f, 0.08203135f, 0.05021367f, 0.16623570f, -0.05373342f, -0.00899994f, -0.03903120f, -0.00236459f, 
    -0.03097592f, 0.14851364f, -0.38844076f, 0.15390183f, 0.16192302f, 0.08434451f, 0.11647107f, -0.04409739f, 
    0.08834518f, 0.07695055f, -0.09363756f, 0.15776214f, -0.10932116f, 0.42629007f, -0.07182162f, -0.01754991f, 
    -0.07038344f, 0.01028021f, 0.01597924f, 0.04473599f, 0.01304737f, -0.02564046f, -0.08510195f, 0.02729391f, 
    0.28944585f, -0.16987044f, 0.49922663f, 0.20020272f, -0.01708090f, -0.04557166f, 0.04338060f, -0.02673239f, 
    0.20103724f, 0.05226362f, 0.16227555f, 0.15416671f, 0.20858625f, 0.16818158f, 0.13043231f, -0.43661243f, 
    -0.08933168f, 0.01574239f, 0.10812992f, 0.28688979f, 0.08671342f, -0.13507277f, -0.01795363f, 0.10868102f, 
    0.11525852f, -0.01068290f, 0.27502552f, 0.01493517f, -0.05127464f, 0.05857885f, -0.01597677f, -0.06271621f, 
    0.01903241f, -0.13493462f, -0.16192633f, -0.18605925f, 0.22744934f, 0.04356016f, 0.16137637f, 0.05332399f, 
    0.15708128f, -0.00557000f, 0.09375864f, -0.02981320f, 0.01902649f, -0.03835615f, -0.03290811f, -0.37317225f, 
    0.08983965f, -0.06890569f, 0.01442061f, -0.07515541f, -0.02956760f, -0.05497953f, -0.00824072f, -0.06318720f, 
    -0.06492454f, 0.01900682f, 0.07336528f, -0.12250239f, 0.04143561f, 0.16318758f, -0.23162065f, 0.12618452f, 
    -0.08484302f, -0.02386457f, -0.07536827f, -0.17259997f, 0.01496915f, -0.05399799f, -0.01420255f, -0.05512405f, 
    -0.13682403f, -0.45707035f, -0.08778383f, 0.19581631f, 0.16028157f, -0.03664069f, 0.11623693f, 0.10067634f, 
    0.06201610f, -0.06945661f, 0.11204731f, -0.02071129f, 0.18624261f, 0.33456573f, -0.46278146f, 0.59523606f, 
    0.07664927f, -0.04157176f, 0.00746631f, -0.24048004f, 0.22857471f, 0.17314526f, 0.06958971f, -0.04774390f, 
    -0.29089820f, -0.05816865f, 0.15512528f, -0.00455829f, 0.06714643f, -0.16468515f, 0.18732361f, 0.19882692f, 
    0.04548383f, -0.00471539f, 0.08774053f, 0.04877466f, -0.36951175f, -0.12081671f, 0.03666292f, -0.05947351f, 
    -0.03214825f, -0.07212218f, 0.11308505f, 0.05033148f, -0.04785697f, -0.02925672f, -0.03690471f, -0.01529466f, 
    -0.39509469f, 0.25149578f, -0.01645937f, 0.23671570f, 0.01700437f, -0.31533575f, -0.07913398f, 0.02078661f, 
    -0.09997437f, -0.03441182f, -0.11028296f, 0.10891239f, 0.07839242f, 0.24939287f, 0.31358963f, -0.31891829f, 
    -0.02363188f, -0.07295130f, -0.11143474f, -0.06901582f, 0.34641299f, 0.10550033f, -0.00039734f, 0.10243646f, 
    0.11776979f, -0.00728071f, 0.01946005f, -0.11438372f, -0.06999283f, -0.01993255f, -0.11665975f, -0.09305456f, 
    0.01965630f, 0.03473988f, 0.02605357f, -0.06208561f, -0.08754951f, 0.59276694f, 0.06371333f, -0.17231783f, 
    0.10989422f, 0.07801301f, 0.03575948f, -0.02323839f, 0.18424116f, 0.17843929f, -0.02162460f, 0.20557649f, 
    0.21849290f, 0.33577353f, 0.00845123f, -0.23824653f, -0.09427229f, -0.10604500f, -0.07414579f, 0.00472871f, 
    -0.07322652f, -0.00596632f, -0.04172894f, 0.08622543f, 0.32003304f, -0.20557413f, 0.42677081f, -0.19035403f, 
    -0.15657742f, 0.07897896f, -0.00900320f, 0.09443601f, 0.16603662f, 0.11493310f, 0.18250778f, 0.09248643f, 
    0.10382139f, 0.02850006f, -0.04212293f, -0.03674077f, -0.06633483f, -0.04610379f, -0.05989469f, 0.00358544f, 
    0.12270620f, 0.04965300f, 0.05763943f, 0.02888499f, -0.04323672f, -0.13565525f, 0.25031298f, -0.10870364f, 
    -0.01747377f, 0.11108874f, 0.07540388f, 0.13147607f, 0.02552032f, 0.01930315f, -0.00955129f, -0.06173668f, 
    -0.00787168f, -0.10799871f, 0.07663639f, -0.10148288f, -0.01779537f, -0.11817961f, 0.01080618f, -0.02670102f, 
    -0.00431283f, -0.05514079f, -0.08565655f, 0.04369999f, 0.24697101f, 0.15876812f, 0.12929001f, 0.34180188f, 
    -0.13495083f, -0.08300468f, -0.09085168f, -0.07903639f, 0.13716444f, 0.09331681f, 0.24093615f, -0.09878027f, 
    -0.04081248f, -0.16699505f, -0.06936113f, -0.03333253f, 0.14468764f, -0.16317916f, 0.28967926f, 0.12728474f, 
    -0.01308468f, 0.03163607f, 0.13497004f, 0.08456255f, 0.01349488f, -0.10735672f, 0.16594222f, 0.23167817f, 
    0.11264652f, -0.03305536f, -0.00911889f, -0.13149770f, 0.06945346f, 0.30190232f, 0.11898562f, 0.13483968f, 
    0.11035597f, 0.17998090f, 0.22133180f, -0.04375336f, -0.00133964f, -0.06452584f, -0.03834753f, 0.07952335f, 
    0.01289264f, -0.14098340f, -0.03389150f, 0.03180774f, 0.44532308f, -0.20150582f, 0.10702881f, -0.26335880f, 
    0.10576431f, 0.07371999f, 0.04344989f, -0.11297040f, -0.05963849f, -0.04750413f, 0.16396864f, -0.07674828f, 
    -0.26572958f, -0.03394416f, -0.19951484f, 0.30605331f, -0.01697898f, -0.02456005f, -0.04632512f, 0.02327905f, 
    0.08405668f, 0.08163194f, 0.14241344f, -0.04426463f, 0.07640107f, -0.01759635f, 0.04203862f, 0.21643935f, 
    0.00438070f, 0.00880025f, 0.02988615f, 0.00047574f, -0.08071295f, 0.04256843f, -0.03917625f, -0.06258255f, 
    0.08386518f, 0.13798316f, -0.07495555f, 0.17340051f, -0.08109765f, -0.07111029f, 0.04721462f, -0.04658405f, 
    0.05423369f, -0.04933159f, -0.16375126f, -0.05820419f, 0.11694515f, 0.03759539f, -0.16467164f, -0.05702778f, 
    0.08507491f, 0.07703242f, 0.05165883f, 0.08209909f, 0.14900884f, -0.12445252f, -0.05297120f, -0.15179463f, 
    -0.03290024f, -0.02483812f, -0.03772900f, -0.14565863f, -0.07649623f, 0.03463758f, 0.09635598f, 0.13780028f, 
    0.08424336f, -0.22091079f, 0.00078193f, 0.00806600f, 0.12045105f, 0.00672345f, 0.07686497f, -0.22755916f, 
    0.01351666f, 0.02041747f, -0.04739090f, 0.11051276f, 0.10134758f, 0.04904623f, 0.03076824f, 0.00049106f, 
    -0.24203263f, 0.26420933f, -0.45293564f, 0.11071482f, -0.00386431f, -0.05932650f, -0.06688323f, 0.02176987f, 
    -0.04264117f, -0.03261288f, -0.07794163f, 0.00363900f, -0.32548061f, -0.09900042f, -0.32367924f, -0.12832075f, 
    0.07419656f, -0.06542880f, -0.11451058f, 0.03852722f, -0.06239114f, -0.08437131f, -0.03235002f, 0.16536711f, 
    0.49311316f, -0.23703279f, -0.10196984f, -0.20817636f, 0.10109548f, -0.03680398f, -0.03912089f, -0.08513863f, 
    0.17488839f, 0.08259424f, 0.01092293f, 0.01283523f, 0.13863730f, 0.03540422f, -0.04163137f, -0.19568001f, 
    -0.15203564f, -0.03644388f, -0.03641366f, -0.15322657f, -0.09345005f, -0.30429080f, 0.01801137f, -0.12572104f, 
    0.23222506f, -0.06188001f, -0.00965030f, -0.04924313f, 0.09540272f, -0.00033731f, 0.02607385f, -0.00061852f, 
    0.09234499f, -0.14243038f, -0.04465484f, 0.07552336f, -0.02432621f, -0.10389926f, -0.07384837f, -0.08497301f, 
    0.01657905f, -0.07552195f, -0.13515399f, 0.01084564f, 0.07751663f, -0.17313066f, 0.04848179f, 0.03704047f, 
    0.12697229f, -0.12722029f, 0.11180261f, -0.11073459f, 0.10159259f, 0.02568660f, 0.02951621f, -0.00145313f, 
    0.14966905f, 0.03767553f, -0.07040074f, 0.13304293f, 0.02622567f, 0.11041981f, -0.34883532f, 0.05759045f, 
    0.04139026f, 0.06192274f, 0.04121159f, -0.08232153f, 0.06809814f, 0.07419698f, 0.04312754f, -0.05993568f, 
    0.35011113f, 0.05312974f, 0.58588928f, 0.03710633f, -0.14803158f, 0.05960535f, 0.09397356f, -0.01573838f, 
    0.05691480f, 0.11089288f, 0.03079880f, 0.03454357f, -0.08454202f, -0.44733131f, 0.14801344f, 0.11437058f, 
    0.07828001f, 0.05719146f, 0.03159707f, 0.12137035f, -0.17694341f, 0.04100795f, -0.03257204f, 0.12894559f, 
    0.31212369f, 0.13513444f, 0.34309965f, -0.01204882f, 0.08680200f, -0.07316160f, -0.00511636f, 0.17399566f, 
    0.00461702f, -0.03834871f, -0.05389175f, 0.02190939f, 0.28641129f, 0.46696302f, 0.22837232f, 0.19109038f, 
    0.12411658f, -0.02069336f, 0.00259626f, 0.08357688f, 0.06932756f, 0.05785353f, 0.09438872f, -0.03251857f, 
    -0.29220465f, 0.21856697f, -0.01034732f, 0.06013770f, 0.04742638f, -0.00974236f, 0.06013883f, 0.13825515f, 
    0.00140238f, -0.16142552f, -0.04202312f, 0.10191104f, 0.47283730f, -0.12877886f, -0.08455044f, -0.21158648f, 
    0.07941621f, -0.08526088f, -0.00568777f, -0.06467146f, 0.20119482f, -0.10489581f, -0.06536844f, -0.09001681f, 
    0.15738958f, 0.01468381f, 0.09845205f, 0.32290244f, 0.18700020f, 0.06824348f, 0.01926284f, 0.02978605f, 
    0.07900906f, 0.05272267f, 0.02698433f, 0.02751178f, 0.18675074f, -0.24855006f, -0.16940497f, -0.03174821f, 
    -0.06534007f, -0.16586718f, -0.03655832f, 0.09739479f, 0.03363929f, -0.02075814f, 0.06993107f, -0.11846960f, 
    0.40705669f, 0.05498207f, -0.18945572f, 0.12564436f, 0.22651371f, 0.07684855f, -0.02829885f, -0.04109238f, 
    0.03330445f, 0.03877223f, 0.04998964f, 0.10755171f, 0.29952699f, -0.14248084f, 0.13977858f, -0.26056746f, 
    -0.20095736f, -0.02089638f, 0.00784979f, 0.23793311f, 0.15213639f, 0.00407459f, 0.08871187f, -0.20015275f, 
    -0.02476436f, -0.06097992f, -0.29672509f, -0.09438469f, 0.00365714f, 0.01817907f, 0.05607802f, 0.12139461f, 
    0.08830460f, -0.10568453f, 0.04711143f, 0.02473324f, 0.23740290f, 0.20514855f, 0.26029569f, 0.06222134f, 
    0.02191480f, 0.13047338f, 0.12890546f, 0.03927266f, -0.02452049f, -0.19060105f, 0.04916913f, 0.04108732f, 
    0.10806497f, 0.13186723f, 0.06852955f, -0.05114215f, 0.08717617f, 0.01345229f, 0.07381153f, -0.09895482f, 
    0.14286934f, -0.07155338f, 0.00218635f, -0.05782729f, 0.32778981f, -0.19671740f, 0.17842816f, 0.18353710f, 
    0.01138803f, -0.02569300f, -0.07491627f, -0.07007657f, 0.13655263f, -0.08362059f, -0.07351259f, -0.05282147f, 
    0.16409278f, 0.08826980f, 0.23942313f, -0.02799736f, 0.08172552f, 0.07822475f, -0.04739599f, -0.04414634f, 
    0.02061660f, -0.04395659f, 0.00524592f, -0.12563023f, 0.09302630f, -0.19826512f, 0.25319406f, -0.07642256f, 
    0.02634099f, -0.16884457f, -0.03928304f, 0.09099688f, -0.03935043f, -0.06639839f, -0.12402113f, -0.06929512f, 
    -0.11267821f, -0.02422971f, -0.06755031f, -0.14804548f, -0.07680374f, 0.15149184f, -0.00999960f, -0.14564624f, 
    0.21917655f, 0.07946128f, 0.12820251f, 0.11635088f, 0.29476330f, -0.04973240f, 0.03373420f, 0.28087687f, 
    0.15791573f, 0.07011686f, 0.03978978f, 0.09170589f, 0.00803406f, 0.09767660f, 0.03744335f, 0.02114411f, 
    -0.01373393f, 0.16680777f, 0.41909969f, 0.06940487f, 0.25851741f, -0.15511611f, 0.03898961f, 0.22969361f, 
    -0.18521790f, -0.02781376f, -0.01522400f, -0.15240498f, -0.07727868f, -0.11022338f, -0.08224559f, 0.10382731f, 
    -0.09178201f, -0.06479140f, -0.14927384f, -0.04216195f, 0.01126665f, 0.09656408f, -0.01363535f, 0.05249911f, 
    -0.09602298f, -0.02132373f, -0.18129717f, -0.02836363f, 0.03198505f, 0.01690005f, -0.15756395f, -0.18095334f, 
    0.04450386f, 0.17849377f, -0.01047316f, 0.10537562f, -0.11959465f, 0.18709047f, -0.17628324f, 0.06223285f, 
    -0.01157213f, -0.02990044f, -0.12556098f, 0.00558143f, 0.16389142f, 0.02722019f, -0.03345315f, 0.15222670f, 
    -0.18818256f, -0.15471655f, -0.24842785f, -0.05010600f, 0.09247345f, -0.03650479f, 0.04627933f, 0.05111349f, 
    -0.04126225f, 0.06901447f, 0.04203822f, -0.16585670f, 0.04113474f, -0.20764032f, 0.03444453f, -0.02390558f, 
    0.15989333f, 0.17553963f, 0.08897479f, 0.18943466f, -0.00630392f, 0.04448823f, 0.01811536f, -0.03659675f, 
    0.09734695f, 0.15629765f, -0.17218331f, 0.28395441f, 0.29716501f, 0.07742369f, -0.09063581f, 0.09251103f, 
    0.04990826f, -0.18507700f, 0.03320635f, 0.19530237f, 0.14708221f, 0.09458004f, -0.24304196f, 0.16505827f, 
    0.17656595f, 0.05471861f, 0.01817891f, -0.01191771f, -0.08428849f, 0.03098164f, -0.03024362f, 0.22141390f, 
    0.03561441f, -0.51545054f, -0.14335108f, -0.04076044f, 0.00390642f, 0.00339329f, 0.08295687f, -0.15671638f, 
    0.21470892f, 0.02114992f, 0.08575830f, 0.06023697f, -0.08500472f, 0.14074470f, -0.22891140f, 0.03671407f, 
    0.00317894f, 0.45095560f, 0.02325843f, 0.02834886f, 0.00545603f, -0.06447560f, 0.06018662f, -0.13791262f, 
    -0.03405995f, 0.00182972f, -0.06510372f, 0.07258023f, 0.03386863f, 0.05060156f, -0.03797563f, -0.02619513f, 
    -0.05428183f, -0.12619032f, -0.19466683f, -0.07390007f, 0.03811358f, -0.14982332f, 0.04928557f, -0.13655889f, 
    0.01519823f, -0.04944412f, 0.07333586f, -0.00664594f, -0.04627772f, 0.00825998f, -0.16582532f, -0.33638921f, 
    0.08029188f, 0.02736815f, -0.15253767f, -0.24078047f, -0.04011144f, -0.05742820f, -0.00665629f, -0.04305118f, 
    -0.07110170f, 0.10652231f, -0.01424641f, 0.01709033f, 0.11661786f, 0.22750057f, 0.18644989f, 0.40733695f, 
    0.04025998f, -0.04782483f, -0.22230016f, -0.12307339f, 0.02989921f, -0.09153383f, -0.07803684f, -0.04497240f, 
    0.63101739f, 0.10730012f, 0.20339383f, -0.08514281f, 0.07562990f, 0.03931201f, 0.23007447f, 0.10432467f, 
    0.05209348f, -0.06459442f, 0.10486117f, 0.08480706f, 0.28797624f, -0.19205181f, 0.08319153f, 0.14005135f, 
    0.03869095f, -0.15791781f, -0.18858443f, -0.10961181f, 0.11708272f, -0.11069599f, -0.04434577f, 0.07156616f, 
    0.34611896f, 0.47418743f, 0.33381540f, -0.10955904f, 0.10714121f, 0.03485506f, 0.13770869f, 0.21816367f, 
    0.10774142f, 0.08867167f, 0.10059436f, 0.04739366f, 0.34161445f, 0.29190552f, 0.15179971f, 0.07871759f, 
    0.22636618f, 0.19185582f, 0.15303588f, 0.12863937f, -0.06681054f, 0.02738888f, 0.03833469f, 0.05027651f, 
    0.06945093f, 0.30850595f, 0.25455105f, 0.14962196f, 0.08039302f, -0.06195195f, 0.16475354f, 0.12606695f, 
    -0.01446591f, -0.03541512f, 0.02631725f, 0.00980394f, -0.11780974f, -0.24209209f, -0.13459361f, -0.10052273f, 
    0.01043946f, 0.02575109f, -0.06520282f, -0.11587638f, 0.29255262f, 0.01159916f, -0.08425265f, 0.08076420f, 
    0.15721634f, -0.03385954f, -0.01016955f, -0.00219931f, -0.15522859f, -0.21166274f, -0.01475204f, -0.07570274f, 
    -0.00805346f, -0.01452300f, -0.06970511f, 0.05671727f, -0.05007431f, -0.04622296f, 0.08816636f, 0.06808264f, 
    0.05802932f, 0.04136121f, -0.25995439f, 0.02558307f, -0.07816993f, -0.03513944f, 0.04468610f, 0.15611246f, 
    -0.05876297f, 0.19686875f, -0.03984509f, 0.26631051f, 0.04546274f, 0.03935727f, -0.27281708f, -0.00190808f, 
    -0.14357620f, -0.09520933f, -0.03551510f, 0.05660748f, -0.12940881f, -0.22941928f, 0.11831241f, -0.21290797f, 
    -0.06107579f, -0.07706135f, -0.02627581f, 0.15476345f, 0.19964579f, 0.07593971f, 0.04417519f, 0.15331265f, 
    -0.28729001f, -0.48577932f, -0.50000077f, -0.13532345f, 0.05483432f, 0.08262783f, 0.03962093f, 0.00946447f, 
    0.27960318f, -0.11592461f, -0.04115899f, 0.07641159f, 0.21647935f, 0.06369349f, 0.27165002f, 0.17192294f, 
    0.14623675f, -0.01340667f, -0.06128600f, 0.15806437f, -0.12912984f, -0.12260558f, -0.02234471f, -0.17967887f, 
    -0.21115196f, 0.12573674f, -0.01495015f, 0.04041345f, 0.04890999f, -0.00035851f, -0.10105304f, -0.17824009f, 
    0.16106577f, 0.09612098f, -0.01314918f, 0.09825171f, -0.00884883f, -0.06364059f, 0.08023363f, 0.01432656f, 
    -0.09564301f, -0.16597396f, -0.03773269f, -0.02609668f, 0.17018749f, 0.01657984f, 0.08144902f, 0.10561514f, 
    0.03771314f, -0.12382594f, 0.13688505f, -0.02145537f, 0.14797120f, 0.02688963f, 0.06722306f, 0.01060367f, 
    -0.01828531f, 0.12377574f, 0.06376023f, 0.13756025f, 0.12792344f, -0.08483393f, 0.17037210f, -0.12345455f, 
    -0.01212980f, -0.19220826f, -0.05514846f, -0.11651600f, 0.09762414f, 0.15841943f, 0.12569837f, 0.13199416f, 
    -0.00382759f, 0.00487374f, 0.03896982f, -0.00951011f, -0.06216535f, 0.01242264f, -0.00934806f, 0.00020097f, 
    -0.03010653f, -0.02614089f, 0.00731778f, 0.01062091f, -0.00285394f, 0.00856848f, 0.02641791f, -0.03292811f, 
    -0.05801410f, 0.01630741f, 0.01114383f, -0.05090198f, -0.01062808f, -0.05684847f, -0.01869177f, 0.01317990f, 
    -0.00231343f, -0.01573664f, 0.00999924f, -0.04228820f, -0.05886791f, 0.00434004f, -0.06690755f, -0.00993691f, 
    0.02209310f, -0.02210232f, -0.01258454f, 0.03674997f, -0.02308145f, -0.04263487f, -0.00248147f, 0.00447368f, 
    0.00801556f, 0.00713973f, -0.05115496f, 0.01749352f, -0.00881551f, -0.01123187f, 0.00516219f, -0.02110525f, 
    -0.00551198f, -0.03536155f, -0.02894885f, -0.04777446f, -0.01466282f, -0.00795429f, 0.00736531f, 0.03737517f, 
    0.01595863f, -0.03039522f, 0.00203645f, 0.02540348f, -0.01874130f, 0.00311052f, -0.05540700f, -0.05201485f, 
    0.00761912f, -0.05828241f, -0.05481369f, -0.05887474f, 0.00576152f, 0.03619586f, -0.03793780f, -0.05740766f, 
    0.04260394f, -0.03914920f, -0.01722556f, 0.00068492f, -0.04248874f, -0.01478643f, 0.03227699f, 0.02249108f, 
    -0.06083305f, -0.04233335f, -0.00173926f, 0.00755575f, -0.05007267f, -0.05506552f, -0.01198238f, -0.03469276f, 
    -0.03553160f, -0.05384173f, 0.02145836f, -0.00760394f, 0.03579781f, 0.00849072f, -0.04386479f, 0.01772949f, 
    -0.05245794f, -0.02640158f, -0.00406013f, 0.00837672f, -0.01416804f, 0.01557676f, -0.00072190f, 0.01721580f, 
    0.03515556f, -0.00151884f, 0.03550539f, 0.01693837f, -0.04470363f, -0.00170399f, 0.00236818f, 0.00404588f, 
    -0.02655064f, -0.02410817f, 0.02838880f, -0.00939239f, -0.06364938f, -0.03005819f, 0.03456799f, 0.01542416f, 
    0.03789257f, -0.00165329f, -0.05737409f, 0.00101653f, -0.02999730f, -0.00188060f, -0.02337866f, -0.02688399f, 
    0.01907382f, -0.05032936f, -0.02060797f, -0.04884088f, -0.05722033f, -0.03909799f, 0.02516182f, -0.04988194f, 
    0.02226937f, -0.02363281f, -0.00523875f, -0.03997429f, 0.00928542f, 0.01269553f, -0.04713187f, -0.02151445f, 
    0.01427906f, -0.01309067f, 0.03252162f, -0.03764115f, -0.00651113f, -0.05219140f, -0.02075574f, -0.03218639f, 
    0.03059217f, -0.00092418f, 0.00823423f, 0.00147921f, -0.05116045f, -0.00212402f, -0.00377781f, -0.02902381f, 
    0.03222020f, -0.04485855f, -0.01931801f, 0.01649031f, -0.02318409f, -0.05570827f, 0.01050380f, 0.02761000f, 
    0.01229325f, -0.04640388f, 0.03589315f, 0.02160570f, -0.00513079f, -0.01218928f, -0.03853969f, -0.03578762f, 
    -0.02790981f, 0.02201688f, -0.05760578f, -0.02282524f, -0.03661240f, -0.04205222f, -0.03010569f, -0.04205310f, 
    -0.02125731f, 0.00453318f, 0.02928462f, 0.01098659f, 0.01540647f, -0.00190751f, -0.01648607f, 0.02004287f, 
    -0.03140169f, -0.05521949f, 0.01215738f, 0.02111453f, -0.01037823f, -0.01318436f, 0.03564506f, 0.01033307f, 
    -0.00872691f, -0.00638079f, 0.02364407f, 0.00201464f, -0.03974564f, 0.02431536f, 0.03106784f, -0.02134362f, 
    -0.00896141f, 0.00725065f, -0.00681383f, -0.05406209f, 0.00975203f, 0.01443103f, -0.02231147f, 0.01122802f, 
    0.00355675f, 0.02126661f, -0.01706499f, -0.01654878f, -0.03028603f, -0.03815167f, 0.01039941f, 0.02124830f, 
    -0.04589585f, -0.03192158f, -0.04930918f, -0.02304404f, -0.03586946f, 0.00507668f, -0.03179437f, -0.03159867f, 
    -0.02366507f, -0.04224097f, 0.00295385f, 0.01732128f, 0.04453189f, 0.00815764f, 0.03917455f, -0.00973100f, 
    -0.06192631f, -0.05053953f, 0.00725574f, -0.05124950f, 0.01804094f, -0.00668793f, -0.00363774f, -0.04300370f, 
    -0.00092539f, 0.01730545f, -0.02349451f, 0.02209694f, 0.00657752f, 0.02731485f, 0.00354034f, -0.00614895f, 
    0.03632795f, -0.04285176f, -0.00720982f, -0.00982504f, 0.00832544f, -0.05766884f, 0.03339108f, 0.02408575f, 
    -0.02836260f, 0.00131951f, 0.00081676f, -0.01993313f, -0.02593543f, 0.02821637f, 0.00583525f, 0.00192385f, 
    -0.01747197f, 0.02347458f, -0.01401127f, 0.01914323f, 0.00940818f, -0.04628857f, -0.04976861f, -0.04305184f, 
    0.02914963f, 0.02967713f, -0.02250370f, -0.01273252f, 0.01079773f, -0.01296410f, -0.03294626f, -0.05228367f, 
    0.00175768f, -0.05381606f, -0.00623850f, -0.00050971f, 0.03319356f, -0.05399494f, 0.02792885f, 0.01424562f, 
    0.02841004f, -0.03700081f, 0.00731780f, 0.00211712f, -0.05621775f, 0.01682658f, 0.04398946f, -0.05454901f, 
    -0.00052547f, -0.03191788f, -0.00365932f, -0.05100297f, -0.01985093f, -0.00520438f, 0.01607479f, 0.02865296f, 
    -0.02708875f, -0.00609542f, -0.03315613f, -0.06028138f, -0.03147460f, -0.00064065f, -0.03016781f, 0.02948008f, 
    -0.03381024f, -0.03416718f, 0.03181177f, -0.00616733f, -0.00530993f, -0.00944405f, -0.04693960f, 0.02652901f, 
    -0.02829400f, 0.03415093f, -0.00829456f, 0.01668904f, -0.05324871f, -0.04009239f, -0.00141600f, 0.03408334f, 
    -0.04368776f, -0.03982135f, 0.03046250f, 0.03214599f, -0.05104058f, 0.01926491f, -0.01041736f, -0.04790961f, 
    0.02508421f, 0.02543303f, -0.00003395f, 0.01648099f, 0.00979504f, 0.03944558f, 0.02003216f, 0.02252512f, 
    -0.05917605f, -0.01180057f, -0.01560805f, -0.02559562f, -0.01864985f, -0.04897748f, -0.06924285f, -0.04038852f, 
    0.00527519f, -0.04500823f, -0.04036578f, -0.04447392f, -0.00032034f, 0.03117393f, 0.03785921f, -0.04944125f, 
    0.02976300f, 0.00399691f, -0.03058317f, 0.02730671f, -0.04181448f, 0.02299528f, 0.02537144f, 0.03100043f, 
    0.03964894f, -0.01279804f, -0.04506587f, -0.00114168f, 0.01826554f, -0.04363517f, 0.02751040f, -0.02431289f, 
    0.07406244f, 0.00018366f, -0.04566893f, -0.07143197f, -0.08737309f, -0.03811722f, 0.04855522f, 0.06111918f, 
    0.10493384f, 0.03408077f, 0.05149867f, -0.03661697f, -0.54363459f, 0.43469703f, -0.03371459f, 0.41506031f, 
    0.08476496f, 0.09873524f, 0.34428543f, 0.14007530f, 0.08697639f, 0.05795114f, -0.05842739f, 0.05968526f, 
    0.32723492f, -0.12300029f, -0.07390162f, 0.20299594f, -0.06877878f, 0.29341438f, 0.33057979f, -0.06816647f, 
    -0.11143813f, 0.07600556f, 0.06251865f, 0.11837448f, -0.02788107f, 0.00253837f, -0.00991375f, -0.09427194f, 
    0.07256190f, 0.13571583f, 0.04901133f, -0.07623589f, 0.00911561f, 0.04562678f, -0.02247598f, -0.03144176f, 
    0.00134116f, 0.04644465f, -0.05575522f, -0.14326285f, 0.07043413f, 0.23807850f, 0.18816178f, -0.00490545f, 
    0.04507893f, 0.04622059f, 0.13421418f, -0.01496390f, -0.11320196f, 0.11914115f, 0.17892274f, -0.09096643f, 
    -0.01181344f, -0.00387564f, 0.04124676f, -0.07743952f, 0.11126890f, -0.08258500f, 0.21574177f, 0.23128685f, 
    0.16273002f, -0.20204931f, 0.02271978f, -0.08544770f, 0.05074983f, -0.08871816f, -0.06833040f, 0.05484330f, 
    -0.06251405f, 0.12377347f, -0.03417178f, 0.10930531f, -0.25622275f, -0.29557934f, -0.16606946f, 0.06144327f, 
    -0.02323161f, -0.03858117f, 0.01356048f, -0.05262354f, 0.01414892f, 0.10142746f, -0.02350759f, -0.00714316f, 
    0.23293756f, 0.14866565f, 0.10571080f, 0.48907435f, 0.09819381f, 0.17197460f, -0.02259614f, 0.00463604f, 
    -0.04165643f, -0.12092132f, 0.21576272f, 0.22003345f, 0.08293524f, -0.25037849f, 0.09151950f, 0.16805609f, 
    -0.03135497f, 0.12795793f, 0.25262734f, 0.16038322f, 0.04624556f, 0.10874934f, 0.05971225f, 0.05893863f, 
    -0.22895585f, 0.48233128f, 0.15193181f, -0.00573057f, -0.00209524f, 0.04483408f, 0.02533190f, 0.09056340f, 
    -0.10876409f, 0.13136965f, 0.10696755f, 0.29707482f, -0.37026370f, 0.32890987f, 0.60420811f, 0.31154430f, 
    0.19184391f, -0.00675222f, 0.15321724f, 0.10692874f, 0.04839018f, 0.30929610f, 0.22243331f, 0.16002373f, 
    0.04797925f, 0.20444159f, 0.14465976f, -0.00573303f, -0.01163758f, -0.04399944f, -0.03542656f, -0.06079301f, 
    0.32086533f, 0.18197705f, 0.13435504f, -0.10300844f, -0.01278539f, 0.24285822f, 0.04236790f, 0.32864779f, 
    -0.23757073f, -0.06048940f, 0.15900356f, 0.31633332f, 0.04535571f, 0.07367809f, 0.09333097f, 0.05162533f, 
    -0.03279052f, 0.04289155f, 0.05074222f, -0.23009318f, -0.09545053f, 0.07763179f, -0.02072017f, -0.07396707f, 
    0.05253717f, 0.01024882f, -0.01757582f, -0.11140632f, -0.04144483f, 0.01026019f, 0.08785442f, -0.04268910f, 
    0.02653631f, 0.00318774f, -0.01671356f, 0.01978649f, 0.03774312f, -0.02060679f, -0.07241902f, -0.03612361f, 
    0.06963632f, -0.23905514f, -0.23284826f, 0.34035647f, 0.21470290f, 0.05761042f, -0.14700840f, 0.09927121f, 
    -0.25541219f, 0.09572919f, 0.15526718f, 0.05730096f, 0.39001423f, 0.29522210f, -0.34790960f, -0.15151240f, 
    -0.10474296f, 0.02535581f, -0.10768268f, -0.02234011f, 0.05262159f, 0.09513286f, 0.07663861f, 0.15854733f, 
    -0.32388639f, -0.17221981f, -0.06476776f, 0.28969285f, -0.11895616f, 0.11737055f, -0.18078540f, -0.14239901f, 
    -0.00822785f, -0.02509027f, -0.10144671f, 0.03266636f, -0.31460333f, -0.42590275f, 0.00129226f, 0.19980027f, 
    0.05648821f, 0.00068328f, -0.01930222f, -0.02199345f, -0.04838948f, -0.02690788f, -0.04299575f, -0.05036937f, 
    0.08409653f, -0.46381679f, -0.17505963f, -0.07263789f, 0.08265354f, -0.07323279f, 0.14670283f, 0.02212728f, 
    -0.05523681f, -0.01981894f, 0.03729582f, 0.07932974f, -0.26222795f, 0.28253621f, 0.26407960f, 0.19133103f, 
    0.00236021f, 0.02208611f, 0.05216641f, -0.07048132f, -0.10090148f, 0.06746553f, 0.38468558f, 0.23140183f, 
    -0.06902672f, 0.05402435f, -0.00151944f, -0.15397310f, -0.03095201f, 0.06156418f, 0.02794569f, -0.02204832f, 
    0.06879210f, 0.02000727f, -0.09687649f, -0.02395797f, 0.04205037f, 0.33661538f, -0.06706893f, 0.10400242f, 
    0.11071184f, 0.06987985f, 0.21255471f, 0.07323149f, 0.09626902f, 0.11181723f, 0.18621291f, 0.11628859f, 
    -0.10676697f, 0.03028913f, 0.13294922f, 0.18380414f, -0.10948452f, -0.01483489f, 0.08218804f, -0.06419674f, 
    0.05110918f, 0.09425898f, 0.06653110f, -0.02756683f, -0.04901837f, 0.07770238f, 0.21784900f, -0.00283661f, 
    0.15038531f, 0.05949731f, 0.02947127f, -0.05277202f, -0.05431299f, 0.22447117f, -0.03138104f, 0.00377944f, 
    0.07309095f, 0.17630482f, 0.20544466f, 0.12604085f, -0.09526142f, -0.03756690f, -0.00946917f, -0.01332405f, 
    0.09943015f, 0.09985198f, 0.15548477f, 0.14848015f, -0.32546401f, -0.22364819f, -0.18928960f, 0.06992869f, 
    -0.07824684f, 0.01481409f, 0.12291882f, -0.03710471f, 0.08009577f, 0.03566689f, 0.04982271f, 0.01104695f, 
    -0.11240420f, 0.04825616f, 0.10199825f, -0.05263143f, -0.06730898f, -0.00769671f, -0.03217442f, -0.00523715f, 
    0.00222200f, -0.06826786f, -0.04831408f, 0.00020982f, 0.13143334f, 0.37500784f, -0.16503137f, -0.17376615f, 
    -0.06855839f, 0.03626521f, -0.04556463f, -0.04797554f, 0.13774517f, 0.10827220f, 0.02819883f, 0.11289237f, 
    -0.09582948f, -0.14966886f, -0.09659141f, 0.17559443f, 0.01636442f, -0.04454640f, 0.13766457f, 0.34939343f, 
    -0.00119995f, 0.21742149f, 0.08279374f, 0.11739016f, 0.71582776f, -0.26465845f, -0.16598935f, -0.08770009f, 
    0.06873057f, 0.01412559f, -0.04472346f, -0.12346720f, 0.03644244f, 0.16049324f, 0.11883149f, -0.05252700f, 
    0.09504165f, 0.01287072f, 0.02015882f, 0.05013435f, 0.01196476f, 0.00124918f, 0.03701362f, -0.17136762f, 
    -0.21421586f, -0.06001120f, -0.00262508f, -0.35708296f, 0.10826197f, 0.15752031f, 0.21672057f, 0.08728207f, 
    -0.20231511f, -0.11044750f, 0.07522964f, 0.02747892f, -0.09134488f, 0.05253715f, -0.12131611f, -0.11209841f, 
    0.16666998f, 0.39219618f, 0.05138351f, -0.08373751f, 0.07860132f, -0.00288126f, 0.05112698f, -0.03404516f, 
    -0.02240526f, 0.01691963f, 0.08271958f, 0.15758424f, 0.14923620f, 0.30384880f, 0.03031228f, -0.12239675f, 
    0.05076848f, -0.28475589f, -0.20583084f, 0.03918340f, -0.23969515f, -0.00955526f, -0.22837678f, -0.29567903f, 
    0.18297474f, -0.09481039f, -0.03514816f, -0.15410990f, 0.19482175f, -0.04663066f, 0.04157826f, 0.06824321f, 
    -0.23796156f, -0.35476306f, -0.31260121f, -0.14420500f, 0.11879098f, -0.15865782f, 0.16329052f, 0.00646597f, 
    -0.05538064f, -0.01229331f, -0.17368235f, -0.14678083f, -0.06758981f, -0.05363415f, -0.16764176f, -0.09400173f, 
    0.70346493f, -0.02758674f, -0.08151595f, 0.24697764f, -0.08648062f, 0.00028956f, -0.20642911f, -0.22450316f, 
    0.15556958f, 0.01890811f, -0.09637807f, 0.13242531f, 0.23528883f, 0.13891596f, 0.06543878f, 0.33430493f, 
    -0.18323064f, 0.06353482f, -0.00615036f, 0.05909799f, -0.03650821f, -0.07919828f, 0.05500042f, -0.07237247f, 
    0.21978812f, -0.06076604f, 0.00877406f, -0.19794977f, 0.00903011f, -0.07466298f, 0.01289040f, -0.08441129f, 
    0.02549307f, 0.09632733f, -0.07873508f, -0.16270706f, 0.16666947f, 0.27992156f, 0.18105170f, 0.01123953f, 
    -0.01377564f, 0.13236259f, -0.00714557f, -0.01275186f, 0.01596815f, 0.01698199f, -0.05999222f, 0.10402664f, 
    0.48569149f, -0.03549883f, 0.21128626f, -0.01733152f, -0.05267989f, -0.08310639f, 0.28026262f, -0.09662969f, 
    0.10503469f, -0.07059275f, -0.16422498f, 0.03871334f, 0.15939923f, 0.17136721f, 0.11822360f, 0.28215715f, 
    -0.00946127f, -0.01911978f, 0.04738298f, 0.13993600f, -0.00694813f, 0.17877680f, 0.15820518f, -0.06827385f, 
    0.08663721f, -0.05705883f, 0.39187205f, 0.03709023f, -0.25366339f, 0.00857047f, -0.07543733f, -0.11986810f, 
    -0.01129941f, 0.09418457f, 0.08718260f, 0.25043660f, -0.04454185f, -0.03757306f, 0.17574920f, 0.28930315f, 
    0.13345064f, 0.01226202f, 0.11483150f, -0.07266845f, 0.04297776f, 0.11630695f, 0.00911319f, 0.33769414f, 
    0.39092833f, -0.14314383f, -0.15059194f, 0.03201164f, -0.09887812f, -0.10350882f, 0.04607553f, 0.03490335f, 
    -0.10389235f, 0.08440696f, 0.10151123f, 0.14919236f, 0.06286068f, 0.00335915f, 0.22481300f, -0.03954606f, 
    -0.08137871f, -0.12788902f, -0.18527283f, -0.06274427f, 0.01392337f, 0.05411260f, 0.04003703f, -0.00454810f, 
    0.00103305f, 0.06541551f, -0.03675701f, 0.13689931f, 0.16029865f, 0.00792211f, 0.11379372f, 0.00926672f, 
    -0.14181618f, 0.04410895f, 0.02975161f, -0.00804858f, -0.14455687f, 0.19894782f, -0.33239040f, -0.02298515f, 
    -0.17026429f, 0.14613703f, 0.23731789f, -0.18350020f, -0.04760735f, 0.17012976f, 0.00255197f, -0.28617683f, 
    -0.02306132f, 0.01130224f, 0.05171381f, -0.02679269f, -0.02466333f, -0.01919702f, -0.03373171f, 0.06358582f, 
    -0.08479365f, -0.11662217f, -0.00207862f, -0.18402830f, 0.04640080f, 0.19322254f, 0.02161685f, 0.25328290f, 
    0.02440713f, 0.13661315f, 0.19603547f, 0.34659302f, -0.00347280f, 0.06753080f, 0.02316746f, -0.07668646f, 
    0.30947930f, 0.17797802f, 0.07223754f, 0.15539864f, 0.03843952f, 0.04041447f, -0.13229239f, 0.02746922f, 
    -0.00369180f, -0.09790839f, -0.01940274f, 0.10968151f, -0.02563825f, -0.12606597f, -0.06075613f, 0.04982101f, 
    -0.06392372f, -0.08875217f, 0.05044132f, -0.05175397f, -0.05446427f, -0.00624774f, 0.02353291f, 0.07039440f, 
    0.34277898f, 0.44741309f, 0.09123137f, 0.01681613f, -0.11000076f, -0.12124131f, -0.11909164f, -0.02754073f, 
    -0.07204507f, 0.00546929f, 0.18221146f, 0.07967333f, -0.62130719f, -0.20115717f, 0.40127489f, -0.07458707f, 
    0.05270766f, 0.20211804f, -0.25918210f, -0.17349981f, -0.00871495f, -0.01227728f, -0.09824917f, 0.12904027f, 
    0.01884814f, 0.02229476f, 0.22879979f, -0.19979137f, -0.03889293f, 0.11350117f, -0.28713775f, 0.26356882f, 
    0.02749584f, 0.09164784f, 0.14580092f, -0.08909105f, 0.07021518f, 0.06815968f, 0.14114387f, -0.14943421f, 
    0.08946867f, -0.06377219f, -0.27219370f, -0.06752492f, -0.26970959f, -0.13563274f, 0.11057482f, -0.05954126f, 
    0.56501395f, -0.13763927f, -0.03483306f, 0.00984668f, -0.00198546f, -0.07241856f, 0.05584350f, -0.13519295f, 
    -0.03307603f, -0.01247753f, -0.10266200f, 0.10962412f, -0.03349397f, 0.01431450f, 0.12239016f, 0.26557678f, 
    0.04833286f, 0.19404691f, 0.09960607f, 0.17182401f, 0.00495566f, 0.11450751f, 0.00556230f, 0.12549937f, 
    0.14304850f, 0.17639112f, 0.14316435f, 0.10403500f, 0.05612483f, -0.25527021f, -0.04206036f, -0.05810638f, 
    -0.19459103f, -0.05727896f, -0.22839223f, 0.04915130f, 0.29928029f, 0.00392618f, -0.02120411f, 0.06514950f, 
    -0.02034910f, -0.14947759f, 0.06235100f, -0.10826282f, -0.17814881f, 0.05316853f, 0.05929704f, 0.03437510f, 
    -0.09744915f, 0.06052426f, -0.00811475f, 0.15660991f, -0.01983004f, 0.11567006f, 0.16523762f, 0.08537108f, 
    -0.15649307f, -0.15040925f, 0.09205811f, -0.06784879f, 0.02927044f, 0.04966583f, -0.04956579f, -0.12012035f, 
    0.10446430f, 0.00105943f, -0.10241931f, -0.33994946f, -0.02853174f, 0.10684308f, -0.11339415f, 0.09338761f, 
    -0.01698077f, -0.01364433f, -0.00415063f, 0.04505914f, -0.05086561f, 0.03483042f, 0.02292226f, -0.01832883f, 
    0.02657984f, -0.05476708f, -0.00879027f, 0.00489429f, 0.01823532f, -0.03045628f, 0.02005725f, 0.03220893f, 
    -0.03046128f, -0.05094694f, -0.01145386f, -0.03300329f, -0.00088296f, 0.02137142f, -0.01522752f, 0.01586962f, 
    0.02663539f, -0.02742116f, -0.03780993f, -0.06448436f, -0.01578538f, 0.00623582f, 0.03894201f, 0.02715630f, 
    0.01030838f, -0.01882523f, 0.00599810f, -0.04713715f, -0.02049497f, -0.05770659f, -0.05928264f, 0.00883817f, 
    0.04196117f, 0.02958791f, 0.01779759f, -0.04399681f, 0.03822990f, 0.00069413f, 0.03705646f, -0.03931401f, 
    0.00862942f, -0.00341752f, 0.03135862f, -0.00606133f, -0.02080008f, -0.00310109f, -0.05134901f, 0.04179443f, 
    -0.04906383f, -0.05321471f, -0.02202565f, 0.01938245f, 0.02113480f, 0.01038847f, 0.00321328f, 0.02596052f, 
    -0.04160403f, -0.03924458f, 0.02259923f, 0.03794698f, -0.00610588f, -0.04391572f, 0.01820717f, 0.02133146f, 
    -0.03091367f, 0.02048765f, -0.00155180f, -0.04374456f, -0.04908802f, -0.00735885f, -0.03532546f, 0.00313084f, 
    -0.00526764f, 0.03818728f, 0.03290133f, 0.03520938f, -0.01734481f, -0.02488328f, -0.01499609f, -0.02535503f, 
    0.00060209f, -0.01153620f, -0.00340916f, 0.03062931f, 0.02815027f, 0.01262115f, 0.02713454f, -0.03691801f, 
    0.01239419f, -0.01444575f, -0.04393284f, 0.01231199f, 0.03448793f, -0.03303235f, 0.03308471f, -0.01997304f, 
    -0.04373257f, -0.03228803f, -0.05679801f, -0.03452659f, 0.03588910f, -0.01937439f, -0.01315958f, -0.05531785f, 
    0.02430916f, -0.00505021f, 0.02681989f, 0.03242221f, 0.00390236f, 0.00182296f, 0.00557881f, -0.05096366f, 
    -0.03538447f, -0.02916893f, -0.04398258f, 0.00551771f, -0.03086681f, -0.02740652f, -0.05306178f, 0.02802434f, 
    -0.00912509f, -0.05911916f, 0.00851351f, -0.02179525f, -0.04301949f, 0.00383188f, 0.00917647f, 0.02238813f, 
    -0.04193257f, -0.03420794f, -0.01275705f, 0.00780332f, -0.00370492f, 0.01493759f, -0.05750011f, -0.06361471f, 
    -0.01686713f, -0.06017488f, -0.04693185f, 0.01824263f, -0.01977091f, -0.03805913f, -0.03116633f, 0.00755358f, 
    0.00449523f, 0.02754173f, 0.00840878f, 0.00653253f, -0.00954402f, -0.03207838f, -0.00552784f, -0.00014821f, 
    -0.00128543f, -0.01891624f, -0.03329868f, 0.00230130f, 0.02802429f, -0.02573897f, -0.05414819f, -0.04400658f, 
    0.03726598f, 0.02432286f, -0.01687638f, -0.04038209f, 0.00821098f, 0.01022059f, 0.01272339f, -0.05301520f, 
    0.01666239f, -0.00188065f, 0.03380052f, -0.02206926f, -0.00273516f, -0.00661288f, -0.04602155f, 0.02305970f, 
    -0.04997021f, -0.05524260f, 0.03383993f, 0.03825162f, -0.01389019f, -0.02696886f, 0.01979365f, -0.04925128f, 
    0.02874399f, -0.00488563f, 0.01115724f, 0.02549313f, -0.00248072f, -0.04000718f, -0.05780031f, -0.05751594f, 
    -0.01049342f, -0.01340303f, -0.04592671f, -0.05005432f, 0.00181120f, 0.00988402f, -0.06078070f, 0.02021371f, 
    -0.02576695f, 0.01404043f, 0.02332625f, -0.05853088f, -0.00205389f, -0.04445435f, 0.03131517f, -0.05344969f, 
    0.00269964f, -0.00911915f, -0.00083480f, -0.04206928f, -0.01187845f, -0.03128295f, 0.03437057f, -0.02498423f, 
    0.03185944f, 0.00778660f, -0.02772045f, 0.03020027f, 0.05677858f, -0.04083696f, -0.02000599f, 0.02467403f, 
    -0.01567332f, -0.04870276f, 0.02021823f, 0.01605601f, 0.03527180f, -0.01136752f, -0.06037787f, 0.03667894f, 
    -0.02593275f, -0.02689963f, 0.02013068f, -0.02202467f, -0.03277440f, -0.02966659f, -0.05884877f, -0.01354551f, 
    0.01834270f, -0.04504027f, 0.00572320f, 0.01130290f, 0.00654667f, 0.03160304f, 0.01421704f, -0.02340671f, 
    0.00249328f, -0.05289403f, -0.02626471f, 0.02489571f, -0.00359707f, 0.00219527f, 0.00287268f, -0.03456069f, 
    0.04629657f, -0.01933599f, 0.02754376f, -0.04129721f, 0.00935121f, -0.05086790f, 0.00223693f, -0.02818341f, 
    0.01590461f, -0.01325932f, -0.02568152f, -0.03460526f, -0.00624275f, -0.01006237f, -0.01130108f, 0.02251848f, 
    0.00020500f, 0.02669164f, -0.00856355f, -0.00336192f, -0.03114604f, -0.03027529f, -0.00997931f, -0.02606087f, 
    -0.04539618f, 0.02494187f, 0.03970306f, -0.05107012f, 0.04152485f, -0.01306448f, -0.01370530f, -0.02040154f, 
    0.03607446f, -0.04550092f, 0.00133669f, 0.02557171f, -0.00734637f, -0.02853792f, 0.00644374f, 0.02679559f, 
    0.00130371f, 0.01592978f, 0.03853159f, -0.04375783f, -0.00207230f, 0.01781389f, 0.03793864f, -0.05191704f, 
    -0.03253853f, -0.02961813f, -0.01951673f, -0.01279074f, 0.03291111f, -0.03701195f, 0.02727817f, -0.01408055f, 
    0.01534137f, -0.02308363f, -0.03087795f, -0.00791440f, -0.03237295f, 0.03482328f, -0.00150247f, -0.02855746f, 
    -0.03422504f, 0.02302315f, -0.01880484f, -0.02556258f, 0.00639585f, 0.03683864f, -0.05879256f, 0.03038313f, 
    0.04102014f, 0.04408949f, -0.02813426f, -0.01025491f, -0.04528418f, -0.05124427f, 0.02443738f, 0.00764870f, 
    -0.00365754f, 0.01514717f, 0.02146704f, -0.03740092f, -0.04290635f, -0.01971197f, 0.03498551f, -0.00174920f, 
    -0.05514320f, -0.00279196f, -0.05234936f, -0.02286652f, -0.02850913f, 0.02562030f, 0.01717819f, 0.04075374f, 
    0.03560160f, -0.00597491f, 0.00662119f, 0.01428983f, -0.04255314f, -0.05115742f, 0.02992516f, 0.02806967f, 
    0.00469195f, -0.05699662f, -0.00256788f, 0.02547606f, -0.06270982f, -0.03866561f, 0.03523459f, -0.03435606f, 
    -0.04682194f, 0.01124525f, 0.01785189f, -0.01274630f, -0.05209871f, -0.00496741f, -0.03281901f, 0.03547907f, 
    -0.16170382f, 0.27834669f, -0.08606589f, -0.12473613f, 0.11208199f, 0.18197963f, 0.06211748f, 0.00095242f, 
    -0.02871918f, -0.27906388f, -0.15214439f, -0.06066093f, 0.21182574f, 0.01042931f, 0.06081041f, -0.13167390f, 
    0.11410290f, -0.03687759f, 0.07952584f, 0.12600572f, -0.10021198f, 0.14500509f, -0.12526995f, -0.08085342f, 
    -0.35432157f, 0.09999299f, 0.29305890f, -0.03730455f, 0.08208344f, -0.05497680f, -0.00700479f, 0.10994029f, 
    0.01215044f, 0.12149804f, 0.07610054f, 0.02367111f, 0.01868616f, 0.02894541f, -0.15730315f, -0.00398440f, 
    -0.14559931f, -0.04201503f, 0.01998069f, 0.09357291f, -0.12886149f, -0.08111475f, -0.18530525f, -0.15116023f, 
    -0.12971979f, -0.15730087f, -0.18582696f, -0.03033686f, -0.19411276f, 0.03545140f, 0.02921463f, 0.09551293f, 
    -0.03370924f, 0.01953178f, -0.34321043f, -0.11467443f, 0.02562887f, 0.02924650f, -0.26666492f, 0.25028971f, 
    -0.02184429f, -0.03814518f, -0.03910764f, 0.06065446f, 0.08612208f, -0.11779147f, 0.05138472f, 0.03991069f, 
    0.24755816f, 0.06635758f, -0.02262353f, 0.03377755f, 0.06810869f, -0.09975488f, 0.04807384f, 0.16429769f, 
    0.10905025f, 0.01614921f, 0.10695073f, 0.13396825f, 0.06471301f, 0.10700580f, 0.11058723f, -0.19140528f, 
    0.20999143f, 0.15779491f, 0.05315840f, 0.03302285f, 0.02356391f, -0.08395268f, -0.09293751f, 0.02662659f, 
    0.11410414f, 0.20741734f, 0.15713945f, -0.11362831f, 0.20572180f, 0.04759734f, -0.02655330f, 0.14548460f, 
    -0.12159255f, 0.04841288f, 0.04466185f, 0.13748214f, 0.04672379f, 0.16589995f, -0.07275234f, -0.13617565f, 
    0.08779240f, 0.07707953f, -0.03208346f, 0.01030741f, 0.00468585f, -0.04601359f, -0.17517374f, 0.16026905f, 
    0.16656901f, -0.30042666f, -0.20329843f, -0.07447278f, 0.16201937f, -0.01939854f, 0.19046248f, -0.10154673f, 
    -0.11774389f, -0.01244194f, -0.01591822f, -0.19222996f, -0.04710786f, 0.14232305f, -0.25095206f, -0.12493100f, 
    -0.07068460f, 0.14145944f, -0.06163966f, -0.15193380f, -0.11244632f, -0.03879536f, 0.09833339f, 0.04968497f, 
    0.01436589f, -0.26999870f, -0.21266980f, 0.07465925f, 0.01900612f, 0.01188077f, 0.07242240f, 0.09573974f, 
    0.10189996f, -0.02553249f, -0.04042261f, 0.26465911f, 0.16467384f, -0.11803252f, 0.11959802f, -0.04514494f, 
    0.00349630f, -0.03907147f, 0.14290933f, 0.08557992f, 0.09095903f, -0.02540109f, 0.13113664f, 0.10176386f, 
    0.23490344f, 0.16659229f, -0.11687306f, 0.00345905f, 0.01522166f, -0.17231499f, 0.05192649f, 0.04257676f, 
    0.09979144f, 0.04954396f, 0.18580660f, 0.03519473f, 0.14099640f, -0.11997886f, 0.05443467f, 0.04017631f, 
    -0.03352918f, -0.05402299f, -0.22838557f, 0.13129038f, 0.00599458f, -0.09696598f, -0.02541679f, -0.14302520f, 
    0.36705106f, 0.16771153f, 0.37713671f, -0.00853034f, 0.09681398f, 0.00799316f, -0.05336958f, -0.04460690f, 
    0.06452250f, -0.10367984f, -0.09096114f, -0.05808619f, 0.07234375f, -0.31948623f, 0.15949430f, 0.11031202f, 
    0.00062962f, -0.00117727f, -0.05707635f, -0.03858024f, -0.04468181f, 0.04253889f, -0.04349744f, 0.06329583f, 
    0.30673379f, 0.34366646f, 0.16044877f, -0.22508302f, 0.04644528f, 0.01914734f, 0.03697350f, 0.26418880f, 
    -0.13700978f, -0.00871168f, 0.06270900f, -0.09646501f, 0.29412109f, 0.27173236f, -0.06767115f, -0.16811940f, 
    0.27056894f, 0.06210546f, 0.08954706f, -0.02843876f, 0.02236072f, -0.05695113f, 0.01369334f, -0.09896796f, 
    0.07475888f, 0.45562389f, 0.19224034f, 0.06317317f, 0.09497973f, 0.12015413f, 0.12158182f, 0.20295791f, 
    0.04004870f, -0.01178416f, -0.00677516f, 0.11101662f, 0.00810243f, -0.29826471f, -0.48916432f, 0.16520797f, 
    0.00641125f, 0.01117499f, 0.20614745f, -0.03574565f, 0.04933154f, -0.04857764f, -0.08603822f, -0.03420964f, 
    0.17819707f, 0.49350202f, -0.27713048f, 0.07535990f, 0.02724737f, -0.20951191f, 0.13548318f, 0.04608115f, 
    -0.06169920f, 0.16047521f, -0.11017779f, -0.01097825f, 0.25193614f, -0.31290215f, -0.12869751f, 0.11857881f, 
    -0.12980613f, 0.00265786f, -0.03164970f, -0.10626519f, -0.01978446f, 0.10322406f, -0.05386917f, 0.05802941f, 
    0.06855492f, -0.12722299f, 0.18020426f, -0.07647237f, 0.09813122f, -0.02823394f, -0.13850465f, 0.05868537f, 
    0.00663407f, -0.12665756f, -0.02720576f, 0.11425068f, 0.02571394f, 0.07083312f, 0.18253784f, -0.02890385f, 
    0.06048289f, -0.14746642f, -0.16240399f, 0.04709168f, 0.12714241f, 0.03447206f, -0.11221869f, 0.05534473f, 
    -0.01991916f, -0.13885333f, -0.09761567f, -0.16335385f, -0.10510027f, 0.06366131f, 0.00428716f, 0.03030953f, 
    0.04014014f, -0.09725145f, 0.01848193f, 0.07771121f, 0.20658801f, 0.12070756f, 0.12049494f, -0.00785649f, 
    0.20831227f, -0.03097280f, 0.04427444f, 0.13133365f, -0.08893998f, -0.05607487f, 0.00755110f, 0.01906629f, 
    0.16431765f, -0.09204812f, 0.02329171f, 0.06174879f, 0.05809747f, 0.02024628f, -0.08996546f, 0.18614048f, 
    -0.03581291f, -0.16295323f, 0.00070157f, -0.21567993f, 0.04527737f, -0.09017562f, -0.25518364f, 0.09971141f, 
    -0.01234071f, -0.11908046f, 0.18623345f, -0.07949005f, -0.05826398f, 0.12074212f, 0.00799221f, -0.03061903f, 
    0.03010092f, 0.09191824f, 0.19183865f, -0.05683042f, 0.11378793f, 0.15582186f, 0.01117933f, -0.20971099f, 
    -0.04717023f, -0.13506182f, -0.05486467f, -0.21454433f, 0.07658286f, -0.18993524f, 0.29672495f, 0.10621080f, 
    -0.11316082f, 0.04113660f, -0.09343323f, -0.02679916f, 0.09708116f, 0.15657593f, -0.05447165f, 0.03589310f, 
    0.02163666f, -0.11325593f, 0.14857982f, 0.05903835f, 0.07097233f, 0.05514120f, 0.02797689f, -0.08472225f, 
    -0.20936249f, 0.00424923f, -0.07283476f, -0.14712250f, 0.16189609f, 0.00578386f, 0.14534211f, -0.32966504f, 
    -0.09142492f, 0.06948413f, -0.10961482f, 0.11643576f, -0.07008383f, 0.02934273f, 0.01343145f, -0.07271682f, 
    0.05563828f, 0.16937262f, -0.48124614f, 0.12030226f, 0.16654544f, 0.04238022f, -0.09814779f, 0.00479530f, 
    0.07930534f, -0.06738085f, -0.00977250f, 0.04247137f, -0.21074350f, -0.09358194f, -0.03823839f, -0.04451780f, 
    0.05840844f, 0.11099251f, -0.10604475f, 0.06486527f, -0.04875550f, 0.00994705f, -0.01689429f, -0.08587427f, 
    0.05324074f, -0.06651480f, -0.00005415f, 0.00255361f, 0.12195250f, 0.03272843f, 0.07887381f, -0.00192596f, 
    0.01174404f, -0.27043459f, 0.00421481f, -0.00878117f, 0.00096839f, -0.42417857f, 0.06588589f, -0.22798625f, 
    -0.05923074f, -0.02421406f, 0.07967017f, -0.13254179f, -0.07166719f, 0.00127911f, -0.19401927f, 0.06033341f, 
    0.20151652f, 0.19456463f, 0.19164297f, 0.23172475f, -0.07464705f, -0.00060139f, -0.12562095f, -0.13384062f, 
    0.08273042f, 0.02308027f, -0.05704697f, 0.10617381f, 0.18451677f, 0.28338230f, 0.22185443f, 0.16915005f, 
    -0.18354850f, -0.00398202f, 0.10591926f, 0.22591969f, -0.03285563f, -0.03662873f, -0.00377698f, -0.00916919f, 
    -0.16724728f, -0.03152645f, -0.12940325f, -0.14260097f, -0.03898381f, -0.08661747f, 0.13595903f, -0.02415343f, 
    0.10966211f, 0.01750464f, -0.13175674f, -0.28419599f, -0.00066295f, 0.30701360f, 0.22438854f, 0.02255508f, 
    -0.02385549f, -0.02903135f, 0.05033225f, -0.06467686f, 0.00352901f, -0.03247608f, 0.00446860f, -0.02398941f, 
    0.42839468f, -0.00553095f, 0.27254346f, 0.23491012f, -0.03954992f, -0.08784843f, -0.06126000f, -0.06608697f, 
    0.08099313f, -0.08025368f, 0.03942496f, 0.06568930f, 0.32452554f, 0.03878846f, 0.11604460f, 0.05610254f, 
    -0.02433823f, -0.05153358f, -0.00326557f, 0.09225202f, 0.02293540f, 0.02078015f, 0.00818890f, 0.01888112f, 
    -0.05263295f, -0.07703134f, 0.13261163f, -0.12470293f, -0.11154375f, -0.04326216f, 0.00287952f, -0.07770565f, 
    -0.02130026f, 0.04671430f, 0.20550460f, 0.15796681f, 0.09859443f, 0.21690923f, 0.08077315f, 0.09257308f, 
    0.12911353f, 0.05745400f, 0.00256176f, -0.09532410f, 0.06285038f, 0.12088472f, 0.00117803f, 0.25980264f, 
    0.11030319f, -0.12305428f, 0.15247396f, 0.24039708f, 0.03995112f, -0.03893256f, 0.00989906f, 0.01329015f, 
    -0.05678149f, 0.06410865f, 0.10764338f, 0.13522710f, -0.37199596f, -0.21474998f, -0.38745686f, 0.00695984f, 
    -0.03357825f, 0.10921084f, 0.07495035f, -0.03204697f, 0.09426288f, -0.08774873f, 0.03760348f, -0.07020830f, 
    0.08403567f, 0.30106708f, 0.12942326f, 0.21525268f, -0.04700792f, 0.09392128f, -0.05474089f, -0.02320355f, 
    -0.04012843f, 0.02843665f, 0.07327136f, 0.03146851f, -0.33384791f, 0.21420838f, -0.13439935f, 0.18811078f, 
    0.08227817f, 0.00651322f, 0.05474575f, -0.05669586f, -0.04675932f, 0.08317143f, -0.03652022f, -0.11287643f, 
    -0.07472374f, -0.09140190f, 0.12125855f, 0.09526185f, -0.01072478f, 0.11589859f, -0.01715312f, 0.13872816f, 
    0.03479781f, -0.06938373f, -0.05431729f, -0.14602520f, 0.11951648f, 0.20281775f, 0.23384246f, 0.18468973f, 
    -0.15421337f, 0.01185864f, 0.08501483f, 0.32031119f, 0.03037818f, 0.08799574f, 0.08209000f, 0.03742347f, 
    -0.05900939f, 0.08039610f, 0.06004137f, 0.15162355f, -0.09579264f, -0.05004376f, -0.07740407f, 0.00267500f, 
    -0.01500379f, 0.03015265f, -0.03358786f, 0.01623682f, -0.13571140f, 0.02479563f, 0.30868515f, -0.32995540f, 
    -0.07316726f, -0.16415979f, -0.01683583f, -0.10064942f, 0.00591672f, -0.14019352f, -0.08339085f, -0.00968459f, 
    -0.03501589f, -0.20431815f, 0.10955262f, -0.15110318f, 0.07528577f, -0.01155533f, -0.12031794f, 0.01818002f, 
    0.01713667f, 0.06029757f, 0.09017968f, -0.00131695f, -0.66258067f, 0.18995327f, 0.19805937f, -0.31870604f, 
    0.03404114f, 0.09619150f, -0.01671088f, -0.07723830f, 0.06427994f, -0.05483073f, -0.07004058f, 0.11989690f, 
    -0.19957185f, -0.06569343f, -0.32491788f, -0.20985706f, 0.07069726f, 0.07474522f, 0.04526201f, 0.05698235f, 
    0.04341102f, -0.04272135f, -0.09270024f, 0.02052921f, 0.03079127f, -0.08021239f, -0.04658830f, -0.10248391f, 
    -0.03779753f, 0.01202538f, -0.13270627f, -0.12257579f, -0.18182825f, -0.27030301f, 0.04921168f, -0.02371174f, 
    0.56180918f, 0.27613592f, 0.23682362f, 0.16759312f, -0.03748044f, -0.03092538f, -0.04040061f, -0.01086020f, 
    -0.09574211f, 0.05204015f, 0.15032957f, -0.00947669f, 0.22564434f, 0.19702876f, 0.27313218f, 0.09894161f, 
    0.00719791f, 0.01277581f, 0.07667833f, 0.10464781f, 0.02272896f, 0.09676579f, 0.10319646f, 0.01591915f, 
    -0.31043705f, -0.38399956f, -0.23256427f, -0.15672554f, 0.06531900f, -0.00769435f, 0.09985314f, -0.10717823f, 
    -0.06953418f, -0.10051213f, 0.01174335f, -0.01403286f, -0.08783888f, -0.10615673f, 0.18613480f, 0.17094429f, 
    0.02273569f, -0.04549576f, -0.09307468f, 0.02666431f, -0.11063697f, 0.06402250f, 0.05360302f, 0.01185585f, 
    0.10137302f, 0.18560892f, 0.00524762f, 0.17693095f, 0.07310901f, 0.11971747f, 0.12711249f, 0.14227208f, 
    -0.14717640f, -0.12591481f, 0.00152701f, -0.08787125f, -0.30029857f, 0.02269372f, 0.00135216f, 0.03651789f, 
    -0.00099217f, 0.12890542f, -0.00266434f, -0.04670548f, -0.01858950f, 0.02649326f, -0.06246516f, 0.12438846f, 
    -0.07860035f, -0.11201271f, -0.00237025f, -0.15316185f, -0.09391019f, 0.05114739f, 0.05142076f, -0.02587391f, 
    0.13050120f, -0.02038137f, -0.04036942f, 0.09406622f, 0.30818370f, -0.20648529f, 0.10090695f, -0.08108384f, 
    0.07048701f, 0.00624658f, 0.00320787f, -0.16939843f, 0.03420164f, -0.03687426f, 0.08718237f, 0.07385632f, 
    -0.37234280f, -0.19314784f, 0.13516673f, -0.24599063f, 0.15280561f, 0.01662676f, 0.14460534f, 0.37600309f, 
    -0.14102840f, 0.06260563f, 0.06496381f, -0.02175934f, 0.13916445f, 0.02261336f, -0.09938276f, 0.01376916f, 
    -0.07064715f, -0.11700062f, 0.07156280f, -0.03386325f, 0.00908120f, 0.04995829f, 0.04822462f, 0.06885993f, 
    -0.11935151f, -0.10789778f, -0.19098826f, -0.07943178f, -0.18671732f, 0.05180443f, -0.14336310f, -0.04577459f, 
    -0.08620121f, 0.03067476f, -0.06161936f, 0.06083069f, 0.34025499f, 0.19901353f, 0.14925446f, 0.24292642f, 
    -0.04683154f, 0.04591116f, 0.00209654f, 0.04509415f, 0.13710476f, 0.02460312f, 0.08259306f, -0.13924292f, 
    -0.38760495f, -0.02332214f, -0.17047849f, -0.20701917f, -0.05373875f, -0.06622073f, -0.03803416f, 0.06533078f, 
    -0.04573324f, 0.00720853f, 0.13081741f, 0.01869986f, -0.18743819f, -0.17850207f, 0.06124895f, -0.08976345f, 
    0.22030070f, 0.10972920f, -0.06208445f, -0.06426816f, -0.10868566f, -0.03637679f, -0.11433415f, 0.00550091f, 
    0.03699235f, 0.19496715f, 0.04606794f, 0.05794778f, 0.21703599f, 0.21762796f, 0.05951593f, 0.08583307f, 
    0.00267606f, 0.17682286f, 0.14578077f, 0.28505266f, -0.03951579f, 0.17275040f, -0.12652506f, -0.07745703f, 
    0.07645694f, -0.00565991f, -0.00641768f, 0.06690014f, -0.00389959f, -0.07304013f, 0.00725970f, 0.07499827f, 
    -0.13760097f, -0.10487011f, -0.02053972f, -0.03286537f, -0.03792621f, -0.01300367f, 0.00701875f, -0.00410967f, 
    0.06196871f, 0.11995675f, 0.21670268f, -0.01520213f, 0.11205063f, 0.04635779f, -0.07568517f, -0.44141027f, 
    -0.00451927f, 0.05506534f, 0.09728602f, -0.04302286f, 0.15540555f, -0.00015465f, 0.07707978f, 0.22972980f, 
    0.10571612f, 0.09728620f, 0.10242641f, 0.14682227f, 0.01894413f, 0.06488261f, -0.02581290f, 0.07917892f, 
    -0.05060377f, -0.12199133f, -0.05987256f, -0.16358684f, 0.19502127f, -0.03852852f, 0.25982511f, -0.16853893f, 
    0.00123841f, 0.04002558f, 0.07621793f, 0.13496485f, -0.02129879f, -0.06965713f, 0.02258035f, -0.27879605f, 
    -0.04701359f, 0.01432918f, -0.05047330f, -0.16277835f, 0.01017793f, -0.02523878f, -0.04392221f, 0.01360455f, 
    -0.02563304f, 0.00963181f, 0.00795893f, -0.12135468f, 0.32215813f, 0.15600638f, 0.14720184f, -0.10284210f, 
    0.03654084f, -0.07002907f, -0.09134617f, -0.09902058f, -0.04721100f, 0.02308724f, -0.11743512f, 0.02054244f, 
    -0.15881331f, -0.24799353f, 0.10948616f, -0.02069813f, -0.00403108f, -0.15351714f, 0.18670140f, 0.09557863f, 
    0.16644908f, -0.13081351f, 0.04350698f, 0.00388904f, 0.41308495f, -0.26480839f, 0.22323927f, 0.28910425f, 
    0.00806878f, -0.04497216f, -0.06783258f, -0.08811723f, 0.08290096f, 0.04313636f, 0.01584346f, 0.19913493f, 
    0.02830608f, 0.19355103f, 0.06828764f, -0.01152249f, 0.04029090f, -0.17234263f, 0.19462287f, 0.07342491f, 
    0.03021217f, 0.00527152f, 0.09845655f, 0.09185660f, -0.07780396f, -0.07100799f, -0.08884473f, -0.15936248f, 
    0.07879332f, 0.02752744f, -0.03928456f, -0.26272136f, -0.09727309f, -0.15229778f, -0.04816103f, 0.00260485f, 
    -0.13363804f, 0.37005994f, 0.07498243f, 0.09184530f, 0.01455780f, 0.07188481f, 0.02939698f, 0.02481536f, 
    -0.08413745f, 0.02611901f, -0.08848505f, 0.02870058f, 0.45713538f, 0.05035980f, -0.25525662f, 0.03486878f, 
    -0.04551049f, -0.01075368f, 0.00266274f, 0.16034213f, 0.01823826f, 0.09453014f, 0.04654593f, 0.02757609f, 
    0.08779622f, 0.13910164f, -0.11692626f, 0.04117955f, -0.10658012f, -0.16316496f, -0.00249356f, -0.10020989f, 
    -0.15699731f, -0.02917267f, -0.06854005f, -0.07116356f, 0.95331544f, -0.10192639f, -0.02216478f, 0.14188880f, 
    0.01264034f, -0.04094218f, 0.10504713f, 0.16312343f, 0.13420030f, 0.11180281f, -0.00480059f, 0.06543798f, 
    0.51647735f, 0.10444655f, 0.47511965f, -0.20479310f, -0.00467756f, -0.08065876f, -0.02877953f, -0.03888093f, 
    -0.12526512f, -0.01878605f, -0.01248368f, 0.04717052f, 0.23579538f, -0.01060337f, 0.23321649f, 0.04053689f, 
    -0.03171882f, -0.05534635f, 0.12889548f, 0.17625707f, 0.26256353f, 0.25270632f, 0.17344233f, 0.01237918f, 
    -0.45692250f, -0.13011119f, -0.28347978f, -0.31940356f, -0.09992287f, 0.00442511f, -0.09496303f, -0.06674002f, 
    0.12372021f, -0.00653337f, 0.13446508f, 0.01469778f, 0.00279901f, -0.03264765f, 0.01917670f, -0.17697369f, 
    0.01449627f, -0.03791007f, 0.03563124f, 0.06160540f, -0.07661314f, -0.09131903f, -0.02913890f, -0.00316455f, 
    0.21555948f, 0.07854986f, 0.16854906f, 0.01384627f, -0.03658596f, 0.05090240f, -0.06564983f, 0.00801381f, 
    -0.07824557f, -0.09544748f, -0.09240624f, -0.05823857f, 0.01705024f, -0.10150257f, -0.08332689f, 0.24026190f, 
    -0.02092967f, -0.00027491f, -0.09756076f, -0.07814312f, 0.10272243f, 0.12374789f, 0.10810277f, -0.06072855f, 
    -0.11082280f, -0.00688533f, -0.01762922f, -0.10838599f, -0.01949359f, -0.04529667f, 0.05342746f, -0.01282551f, 
    0.05841489f, 0.11246039f, 0.04307661f, 0.02777140f, 0.23968564f, -0.01493047f, 0.12176502f, 0.28967682f, 
    0.05699450f, -0.01941078f, -0.03045230f, 0.14090613f, 0.13249393f, 0.20596133f, 0.04904772f, 0.08329709f, 
    -0.09075069f, -0.03710708f, 0.06792191f, -0.01489543f, -0.04549421f, 0.02347258f, -0.03288569f, 0.04201659f, 
    -0.02529525f, 0.09026597f, -0.11270566f, 0.04060819f, 0.43310058f, -0.04293614f, 0.32389233f, -0.28782088f, 
    0.16689156f, 0.15440251f, -0.05521999f, 0.29362205f, -0.11110473f, -0.10348108f, 0.26278269f, 0.05556061f, 
    -0.20855448f, -0.27665764f, -0.35495314f, -0.03640485f, 0.09303524f, 0.16891491f, 0.06555616f, 0.17618337f, 
    -0.07844095f, 0.01509092f, -0.05996427f, -0.00599813f, 0.12524033f, -0.01269278f, -0.03885511f, 0.01571916f, 
    0.03569397f, 0.01800293f, -0.00129928f, -0.02166778f, -0.01618955f, 0.03963360f, 0.02206094f, 0.02069054f, 
    0.01782487f, -0.03877407f, -0.03009059f, -0.00218283f, -0.05325437f, -0.01918252f, -0.01067721f, -0.08760288f, 
    -0.00314730f, -0.03200242f, 0.02231701f, -0.05472503f, 0.36332253f, 0.01073928f, 0.22366814f, 0.09968463f, 
    -0.01358281f, -0.08083972f, 0.04227025f, -0.00868484f, 0.10843403f, 0.01037076f, 0.05565020f, -0.08474573f, 
    -0.24687178f, 0.04317144f, -0.00230036f, -0.20767191f, -0.14027335f, -0.03149126f, -0.08256828f, -0.02271037f, 
    0.16998391f, -0.09547392f, -0.05291408f, -0.05702395f, -0.08446833f, 0.10602055f, 0.15017840f, -0.08364046f, 
    0.02803756f, 0.01498013f, -0.02629264f, 0.11129443f, -0.04661092f, -0.05468998f, -0.09166339f, -0.04144751f, 
    -0.24612875f, -0.02686692f, -0.02741632f, 0.00522398f, 0.01121614f, 0.10127891f, 0.24023913f, 0.12016395f, 
    0.06588032f, -0.02322193f, -0.00508588f, 0.06372797f, -0.26141414f, 0.05514008f, -0.07794550f, -0.22396608f, 
    -0.03860397f, -0.01462213f, 0.02625389f, 0.05021997f, 0.05433096f, -0.05135508f, 0.01417664f, -0.11626805f, 
    0.23215470f, -0.27091795f, 0.06304464f, 0.14679791f, -0.11493539f, -0.07412060f, -0.17190836f, 0.02499859f, 
    0.17071545f, 0.05885483f, 0.21563908f, 0.12026170f, 0.36594769f, -0.18121389f, 0.21301712f, -0.12693113f, 
    -0.09783331f, -0.16662103f, 0.01619698f, 0.25145259f, 0.04557649f, -0.13188629f, -0.09578055f, 0.10013115f, 
    0.38720450f, 0.14749561f, 0.18250257f, 0.12378981f, -0.01042692f, -0.02217922f, 0.02251610f, -0.01502904f, 
    -0.13801908f, -0.24961816f, 0.13840081f, -0.12044176f, 0.01035788f, 0.13678657f, -0.08959468f, -0.12477506f, 
    0.04860095f, 0.02046350f, 0.02847713f, 0.14338563f, -0.01122755f, 0.00469401f, 0.00855199f, -0.22851582f, 
    0.02332925f, -0.10059589f, 0.10550539f, 0.20026536f, -0.03504586f, -0.02686982f, 0.01108246f, -0.01868925f, 
    0.18082081f, 0.11670489f, -0.12337073f, 0.00629486f, 0.38968137f, 0.22099911f, -0.31504187f, -0.03691903f, 
    -0.01202714f, -0.00057682f, 0.07711434f, -0.07244266f, -0.07551270f, -0.03615860f, 0.04037161f, -0.02702275f, 
    -0.25897250f, 0.05963295f, 0.23241964f, 0.12370600f, -0.05171704f, 0.02916522f, 0.08868162f, -0.03346331f, 
    0.10988683f, 0.10697154f, -0.01674311f, 0.04068741f, -0.13682708f, -0.05565393f, 0.24697420f, 0.31372711f, 
    -0.01863523f, -0.08666492f, -0.07972497f, -0.08379292f, 0.10615939f, 0.11936809f, -0.18277630f, 0.15727262f, 
    -0.07130750f, -0.10227340f, 0.18820439f, 0.16680126f, 0.12113222f, 0.01647806f, 0.08826467f, 0.11636809f, 
    -0.02119527f, 0.06543089f, -0.02725577f, 0.00425928f, -0.06349425f, 0.05521587f, 0.27681720f, 0.20784812f, 
    -0.04935163f, -0.03841828f, -0.08021934f, 0.01442117f, -0.06217260f, -0.03285018f, 0.02409598f, -0.00941711f, 
    -0.38726759f, 0.09945305f, -0.00073090f, -0.00936067f, -0.09764289f, -0.16863027f, -0.02624018f, -0.05308435f, 
    -0.06005002f, 0.07210927f, -0.05557582f, -0.09350248f, 0.55776989f, 0.03211310f, 0.23686275f, -0.23852879f, 
    0.00137277f, -0.12202889f, -0.13802536f, 0.01521147f, 0.19447823f, 0.01334378f, -0.00577694f, -0.06525860f, 
    0.01661852f, -0.14487496f, -0.02431911f, 0.01519695f, -0.00516598f, -0.01409844f, -0.07365432f, -0.05948610f, 
    -0.00641739f, -0.03150938f, 0.00084098f, -0.02256713f, 0.48574874f, -0.13994303f, 0.13867396f, -0.29617998f, 
    0.12473465f, -0.08680794f, 0.23540820f, 0.21122046f, 0.27677634f, -0.04221528f, 0.14355581f, -0.03586584f, 
    0.81496066f, -0.00339238f, -0.08000023f, 0.11175862f, -0.10934243f, -0.12092565f, 0.11329225f, -0.05902044f, 
    -0.08348797f, -0.02405377f, -0.13725814f, -0.00742333f, 0.25283223f, 0.21833906f, -0.13713470f, 0.21551535f, 
    -0.08056690f, 0.03272848f, 0.09725875f, -0.03260077f, 0.12632719f, 0.08156791f, 0.15722628f, -0.12119719f, 
    -0.01675912f, 0.11857528f, -0.10218566f, -0.17362835f, -0.11872452f, -0.10512797f, -0.17995512f, -0.11734126f, 
    0.06991901f, 0.10590407f, 0.14579113f, -0.07528391f, 0.16785309f, 0.24330258f, 0.06997423f, -0.07775144f, 
    -0.08625010f, -0.05640710f, 0.09917254f, 0.12035146f, 0.02783796f, -0.00450170f, 0.03909098f, -0.07159898f, 
    0.18246943f, -0.00068342f, -0.03232753f, -0.00153258f, 0.04921464f, 0.05492947f, 0.04466417f, -0.04051930f, 
    -0.02897526f, -0.16562916f, 0.00959950f, -0.06524412f, -0.03136221f, -0.28284571f, 0.17005284f, 0.29081315f, 
    -0.03604018f, 0.01345583f, -0.13692690f, -0.09345229f, 0.18267834f, 0.09523664f, 0.13667233f, -0.02897622f, 
    -0.00691231f, 0.08171377f, -0.02662208f, 0.00785422f, -0.04220710f, 0.05316292f, 0.04683195f, 0.12382333f, 
    -0.00655484f, 0.01751307f, 0.04176122f, -0.00323023f, -0.23617494f, 0.00587439f, 0.06637166f, 0.32092595f, 
    -0.17262073f, -0.04935609f, -0.04457697f, -0.01442023f, 0.02077939f, 0.08730668f, -0.03531547f, 0.05494175f, 
    -0.12755047f, -0.10955331f, 0.04912656f, -0.00640114f, 0.19739294f, -0.18212353f, -0.19817653f, -0.04731209f, 
    -0.32921687f, -0.10000648f, -0.02538256f, -0.44794232f, -0.17909017f, -0.05255470f, -0.04435392f, 0.01812524f, 
    -0.00431577f, -0.13556390f, 0.36630967f, -0.19927873f, 0.02732171f, -0.06367485f, -0.13885076f, 0.11975864f, 
    0.21104783f, 0.34783962f, 0.04823519f, -0.06845476f, 0.18446727f, 0.21968180f, 0.19529347f, -0.17520066f, 
    0.11070622f, -0.10170536f, 0.26569584f, 0.12404804f, 0.02540056f, 0.15434390f, 0.09816743f, -0.00996382f, 
    0.21122739f, 0.02802640f, 0.01247176f, -0.22435856f, -0.47770813f, -0.48977134f, -0.31326172f, -0.23597379f, 
    -0.19541562f, 0.10361308f, 0.00378117f, -0.09563784f, 0.29090807f, 0.00964343f, -0.12797931f, 0.04589215f, 
    -0.38847351f, -0.45437074f, -0.41656268f, -0.43571097f, -0.00371419f, -0.12485195f, 0.09169681f, 0.13873439f, 
    0.03953553f, 0.18017787f, -0.16146128f, -0.09448870f, -0.11923249f, -0.04289577f, 0.05175592f, -0.01483695f, 
    0.48845536f, -0.04775475f, 0.21118842f, 0.22777081f, -0.03505183f, 0.09313308f, -0.01686290f, -0.15740822f, 
    0.20388590f, 0.13319600f, 0.09784554f, 0.28514835f, 0.05907007f, -0.06986888f, -0.24846114f, -0.06081151f, 
    -0.07257820f, -0.06688116f, -0.01019643f, -0.06314467f, -0.02817566f, -0.21943891f, -0.25661382f, -0.17651923f, 
    -0.13320069f, 0.21119937f, -0.03249892f, -0.13969158f, 0.00352120f, -0.25350496f, 0.07476923f, 0.11612465f, 
    -0.05216692f, 0.26340252f, 0.06626105f, -0.18814774f, 0.05512275f, -0.00260234f, 0.07787761f, 0.26511568f, 
    -0.00304332f, 0.03442013f, 0.15521844f, 0.10070448f, -0.04051191f, 0.01935426f, 0.27416462f, 0.21967706f, 
    -0.15835002f, 0.36057511f, 0.02068004f, 0.04299039f, 0.08917128f, -0.05946069f, -0.03969710f, -0.15359065f, 
    -0.02227511f, 0.06467772f, -0.02960910f, 0.02477831f, -0.12002756f, 0.24772283f, 0.21199787f, 0.05943776f, 
    0.06933720f, 0.05354696f, 0.18925092f, -0.06903270f, -0.02638341f, 0.42527583f, 0.07907292f, 0.04647592f, 
    -0.15497723f, -0.01160599f, 0.13947229f, -0.04632872f, -0.40217608f, -0.10149845f, -0.00150394f, -0.04133771f, 
    0.29047057f, 0.54763579f, 0.32041329f, 0.32762152f, -0.01557320f, -0.16619697f, 0.17626031f, 0.38486841f, 
    -0.02054848f, 0.13248327f, 0.05882220f, 0.06324809f, 0.26917097f, 0.21623212f, 0.25482249f, 0.56336176f, 
    -0.04258290f, 0.01765869f, 0.01411630f, -0.02284428f, -0.13856453f, -0.10543372f, -0.07480270f, -0.02605616f, 
    0.02605469f, 0.00576050f, 0.25267914f, 0.11285794f, 0.04110820f, -0.07105815f, 0.29073194f, -0.02264100f, 
    0.09920186f, 0.18304971f, 0.16498969f, -0.15786557f, -0.10679763f, 0.00643525f, -0.11280338f, 0.07168650f, 
    0.07066170f, -0.03612621f, -0.14859566f, 0.01412742f, -0.06808668f, -0.13274516f, -0.05765517f, -0.08375712f, 
    -0.12498140f, 0.04965441f, -0.02000546f, -0.09961089f, 0.13635875f, 0.34366953f, -0.12844560f, -0.09125443f, 
    0.03239094f, 0.03514968f, 0.19341834f, 0.27189094f, 0.00698793f, 0.03494053f, 0.32392776f, 0.02353828f, 
    0.07954129f, -0.02154928f, -0.16263352f, -0.03006247f, 0.12959951f, 0.03265322f, -0.06983538f, -0.15824430f, 
    -0.18214983f, -0.17799892f, -0.19874957f, -0.16338529f, 0.00692374f, -0.01799681f, -0.25652352f, -0.11407861f, 
    -0.01130990f, -0.04541905f, 0.05140378f, 0.14599666f, -0.00786268f, 0.01727488f, -0.11194754f, -0.23963168f, 
    0.28054571f, -0.02804599f, -0.07147828f, -0.13436139f, 0.18093665f, 0.28104013f, 0.07771271f, 0.02365276f, 
    -0.13923959f, -0.12592663f, 0.12443361f, 0.29061696f, -0.08099684f, 0.12566397f, -0.09168264f, 0.27711073f, 
    -0.05641823f, -0.11347284f, 0.17111339f, -0.03479369f, -0.10341144f, 0.28112066f, -0.08416349f, 0.00901815f, 
    0.00196541f, 0.29767984f, 0.03975951f, -0.05670774f, 0.13213125f, 0.09703968f, -0.26004604f, -0.19362456f, 
    -0.17733772f, -0.21435842f, -0.01096705f, -0.01686554f, 0.03286967f, 0.01940187f, -0.03501916f, 0.29390466f, 
    -0.00661602f, 0.15041156f, 0.05643855f, -0.03609956f, -0.05865062f, 0.17314474f, -0.04860079f, -0.00898188f, 
    -0.35840994f, 0.13970944f, 0.40154070f, -0.23743671f, 0.08992141f, 0.17661190f, 0.07825151f, 0.01535776f, 
    -0.08809655f, 0.09562317f, 0.29072025f, -0.04066565f, 0.25243422f, -0.30201414f, 0.06921329f, -0.14719768f, 
    0.03602117f, 0.10739989f, -0.17121464f, -0.14479391f, -0.13837202f, -0.16400924f, -0.06161593f, 0.03145692f, 
    0.15891130f, 0.21908432f, 0.20849216f, 0.18937720f, -0.05161026f, -0.02130064f, 0.13132311f, -0.07209463f, 
    -0.00574837f, 0.16928943f, 0.04088628f, 0.06830506f, -0.04503469f, -0.13807794f, -0.06697077f, 0.05513370f, 
    -0.04069807f, 0.16994153f, 0.17683113f, 0.03086060f, 0.05943013f, 0.07087252f, 0.21176502f, 0.30694830f, 
    0.12387429f, 0.16855034f, 0.10483023f, -0.03460288f, 0.04482976f, 0.00308716f, -0.09537830f, 0.22030212f, 
    -0.17464879f, -0.17636679f, -0.19210671f, -0.17477247f, 0.19502221f, 0.20277715f, -0.19362693f, -0.20640579f, 
    0.09038620f, 0.02040856f, -0.06025472f, 0.04767221f, 0.05561128f, -0.07605922f, 0.21791898f, 0.25001127f, 
    -0.05845094f, -0.10407978f, 0.01748142f, 0.01252189f, -0.06169313f, -0.01639042f, -0.07384716f, 0.08169328f, 
    -0.04222605f, -0.19764201f, -0.18638216f, -0.35323980f, 0.46253958f, 0.17799325f, 0.04631792f, -0.10022616f, 
    0.07021594f, 0.05752797f, -0.07027691f, 0.06599516f, 0.10942107f, -0.01034165f, 0.34322208f, 0.03131993f, 
    0.02930514f, 0.03442336f, 0.03633776f, -0.00508580f, 0.00769408f, 0.00257116f, 0.02218754f, -0.05393475f, 
    0.03481564f, -0.00526435f, 0.02965561f, 0.00674343f, -0.04022893f, 0.00942194f, -0.05684097f, -0.02173541f, 
    0.00813176f, -0.02936191f, 0.03988212f, -0.05112477f, -0.05110860f, 0.00358038f, -0.01389255f, -0.04271209f, 
    -0.03155333f, 0.03429489f, 0.02569924f, -0.01350006f, -0.01021822f, 0.02825812f, -0.04219276f, -0.03842134f, 
    -0.03536357f, -0.04010988f, -0.01965884f, 0.04320917f, -0.04452737f, -0.00586347f, -0.02553017f, -0.00489175f, 
    0.01112352f, -0.00648177f, -0.05146144f, 0.02512055f, 0.04350425f, 0.02995537f, 0.02476243f, -0.01475378f, 
    -0.00124008f, 0.03805649f, -0.04945073f, -0.04617127f, -0.03095735f, -0.02118091f, -0.04616252f, -0.04354281f, 
    -0.00248696f, 0.03710339f, 0.00522963f, -0.01842969f, 0.04170714f, -0.03261689f, 0.01706290f, -0.03779542f, 
    -0.00448203f, 0.02960016f, -0.04856548f, 0.04029791f, 0.02054526f, 0.01656340f, -0.04244094f, -0.01638917f, 
    0.03604037f, 0.01176332f, 0.04009783f, -0.01542724f, 0.03734259f, -0.01766709f, 0.02746110f, 0.03135100f, 
    -0.05061210f, 0.00491978f, 0.03732846f, -0.00420857f, -0.00528448f, -0.03342897f, -0.03906275f, -0.02630962f, 
    -0.05446015f, -0.02527115f, -0.05263821f, -0.02965731f, -0.05257654f, -0.01110440f, -0.03968260f, -0.00217229f, 
    0.03877137f, 0.01575547f, -0.03676322f, 0.01830660f, 0.03215614f, 0.03389249f, -0.00796242f, -0.00809652f, 
    -0.01073041f, 0.00831663f, -0.04645432f, 0.01656605f, 0.00973019f, -0.00092372f, 0.02431378f, -0.05140929f, 
    -0.02697827f, -0.04793640f, -0.02564468f, 0.02374518f, -0.01674064f, -0.00011743f, -0.05591610f, 0.04475379f, 
    -0.01804915f, -0.03618945f, -0.04697960f, 0.03239120f, -0.03156934f, -0.00006295f, -0.04449550f, 0.00497301f, 
    -0.04118006f, -0.02807418f, 0.03841380f, -0.04410945f, -0.04174172f, 0.02948760f, -0.00491521f, 0.03173959f, 
    0.00434271f, 0.03174215f, 0.02903744f, -0.01349347f, 0.01579706f, 0.00128245f, -0.03507474f, -0.03368120f, 
    -0.00275710f, 0.01159985f, -0.02752012f, -0.01868532f, 0.01930562f, -0.03809696f, 0.01365994f, -0.01299050f, 
    0.04048457f, -0.04814200f, 0.01447076f, 0.02977916f, -0.03896395f, 0.02405964f, 0.00121611f, -0.01254370f, 
    -0.00782296f, 0.04139231f, -0.03557523f, 0.02237513f, 0.02798472f, -0.02417379f, 0.04460820f, -0.01297165f, 
    -0.05477186f, 0.01076518f, -0.01671600f, -0.02450018f, -0.05207677f, -0.03862640f, -0.02127032f, 0.00137611f, 
    0.02609744f, -0.00139889f, -0.00705171f, 0.02107936f, 0.03488101f, 0.00622434f, -0.02208626f, -0.00162676f, 
    0.02224441f, -0.02393260f, -0.05255180f, -0.05661798f, 0.02844846f, 0.00113944f, -0.03805558f, 0.02399525f, 
    0.04414439f, -0.02499874f, 0.00466153f, -0.02067690f, 0.01546555f, -0.01564936f, 0.03472277f, 0.03172067f, 
    0.00398057f, 0.01305448f, -0.02618036f, -0.01603381f, 0.04090879f, 0.02142126f, -0.02303077f, 0.02412421f, 
    -0.03720723f, 0.01145133f, 0.02455748f, -0.04290580f, 0.04461205f, 0.03687033f, -0.01563409f, -0.01313988f, 
    0.03132668f, 0.04146293f, -0.05110113f, 0.00639125f, -0.04335946f, 0.01343152f, -0.05177421f, 0.04476826f, 
    -0.01313378f, 0.01798835f, -0.02113945f, 0.00805938f, -0.04614620f, -0.05644646f, 0.02998118f, 0.01510294f, 
    -0.03424055f, 0.00760763f, -0.05565881f, -0.02463916f, 0.01400325f, -0.03770487f, -0.05032463f, 0.00790510f, 
    0.02086650f, -0.00872971f, -0.02812536f, 0.02218841f, 0.01462657f, 0.02984722f, -0.05460774f, -0.00067588f, 
    0.04341928f, -0.02388908f, 0.02459757f, 0.02120852f, -0.03715644f, -0.04988148f, 0.04233459f, -0.01939128f, 
    -0.04514760f, -0.05290242f, -0.00512301f, -0.02958416f, -0.00988818f, -0.01376055f, -0.02560799f, 0.01568320f, 
    -0.05122634f, -0.04253219f, 0.01459572f, 0.04836448f, -0.01911531f, 0.00632235f, 0.03476935f, 0.00944165f, 
    0.02508622f, -0.04026635f, -0.05662769f, -0.03192008f, 0.03675091f, 0.04072995f, 0.00708670f, 0.00200142f, 
    -0.02493821f, -0.04281908f, 0.00089061f, 0.03631005f, -0.05277557f, -0.04994582f, -0.01179179f, 0.00098294f, 
    0.00880727f, -0.02731785f, -0.05517475f, 0.01549091f, -0.02131576f, -0.04312387f, -0.01699029f, 0.03792195f, 
    0.02735104f, -0.02401822f, 0.02940911f, 0.01127297f, 0.00206672f, -0.04600466f, -0.05450076f, -0.04448811f, 
    0.00974661f, 0.02125208f, 0.00420367f, -0.03616205f, -0.03782287f, -0.02813798f, -0.04157862f, -0.03048024f, 
    -0.00456036f, -0.01822533f, 0.01418940f, -0.04824881f, -0.04021001f, 0.03021716f, 0.04332834f, 0.01227857f, 
    -0.05497228f, 0.02191216f, -0.02630635f, -0.03193321f, -0.05657802f, -0.01725730f, -0.01304059f, 0.02328332f, 
    0.03652987f, 0.04190701f, 0.02323930f, -0.01942704f, 0.02293801f, -0.03344576f, -0.00360594f, -0.01338852f, 
    0.02329290f, -0.00780220f, -0.02684900f, 0.02213178f, 0.03646981f, 0.04268832f, -0.01548697f, 0.00660475f, 
    0.03285168f, -0.02126264f, 0.03850039f, 0.03827776f, -0.01264242f, -0.05545815f, -0.03974951f, 0.02085514f, 
    0.03844013f, 0.01439109f, 0.03240678f, -0.00820582f, -0.02919138f, -0.00654577f, -0.00788795f, -0.03822230f, 
    0.03742644f, -0.01661141f, 0.01141850f, -0.03629260f, -0.02599060f, 0.00896066f, -0.04462858f, -0.02886202f, 
    -0.03072073f, -0.02754153f, -0.03166547f, -0.00741124f, 0.02593059f, -0.02771725f, -0.05242125f, -0.00222498f, 
    -0.03223662f, -0.02206483f, -0.03267305f, -0.04328407f, 0.03329503f, 0.01690134f, -0.03739493f, 0.03162148f, 
    -0.01255731f, 0.07222458f, 0.00789136f, 0.03860397f, 0.01721761f, -0.15769392f, 0.02146314f, -0.01348389f, 
    -0.05725754f, 0.16907865f, -0.00401606f, -0.06661193f, -0.08605213f, 0.22334729f, -0.00031449f, 0.34414980f, 
    -0.16297315f, -0.07010812f, -0.01439930f, -0.08615573f, -0.00677806f, -0.00182808f, -0.14430165f, 0.14116490f, 
    0.18293983f, 0.05586702f, 0.37037942f, -0.32340652f, 0.13385046f, -0.07348451f, 0.15057866f, -0.00679109f, 
    -0.12661175f, -0.02039595f, 0.09950608f, -0.08584025f, 0.09189831f, 0.07961336f, -0.00050798f, -0.06251141f, 
    -0.06903347f, -0.10308821f, -0.02446551f, -0.11886270f, 0.00024263f, -0.06411622f, 0.02022877f, 0.00050480f, 
    -0.03837798f, -0.07170448f, 0.06904720f, 0.01458243f, 0.30831328f, 0.03339151f, -0.08315177f, 0.02831402f, 
    -0.14838974f, -0.06921500f, 0.14518844f, -0.00707647f, 0.03360932f, 0.05188566f, 0.22684315f, 0.08771235f, 
    -0.03557911f, 0.06386636f, -0.03816957f, -0.01405267f, -0.09346390f, 0.05800278f, 0.08006983f, -0.05379098f, 
    0.06705445f, -0.10567720f, -0.17893784f, -0.04916587f, 0.08596108f, 0.02698715f, 0.00227660f, 0.09431166f, 
    -0.21650089f, 0.08557860f, 0.11638757f, -0.15968968f, 0.00239386f, -0.03968960f, -0.00017469f, 0.21675216f, 
    0.15660283f, 0.02374275f, 0.01779146f, -0.07777744f, -0.12776984f, -0.01461267f, 0.01912438f, -0.02916228f, 
    0.34713686f, -0.00596493f, 0.23398572f, 0.03202714f, 0.15043911f, 0.08741926f, 0.16508640f, -0.24531709f, 
    0.04579547f, 0.28585106f, -0.12290791f, 0.13252783f, 0.37402788f, -0.08640055f, 0.09126702f, 0.10139640f, 
    0.22039723f, 0.16864204f, -0.01073789f, 0.02612102f, 0.00885416f, 0.14781518f, 0.03144432f, 0.00870662f, 
    -0.03838312f, 0.38820001f, -0.08849026f, -0.09568830f, -0.08734950f, 0.00362619f, 0.12240285f, 0.22704354f, 
    -0.18988223f, 0.04312388f, 0.09354474f, 0.04579600f, 0.02719018f, -0.12559536f, 0.09709957f, 0.27844611f, 
    0.04640741f, 0.08458333f, 0.14725290f, 0.16215330f, 0.12135157f, 0.07224027f, -0.05527518f, 0.20552973f, 
    -0.10445908f, 0.11923099f, 0.26168886f, 0.02388207f, -0.07708479f, -0.00981777f, -0.08885006f, 0.06327598f, 
    -0.08439866f, 0.10598012f, 0.00390189f, -0.23531887f, -0.04250730f, -0.12893431f, 0.26083094f, 0.21481618f, 
    0.11892154f, 0.11635584f, -0.01660678f, 0.13873075f, 0.17133813f, 0.15797843f, -0.02293601f, -0.14740106f, 
    -0.07566315f, 0.04877117f, -0.17571087f, -0.16463445f, -0.09384932f, 0.00918237f, 0.03694693f, 0.08343987f, 
    -0.26435480f, -0.07225048f, -0.04295607f, 0.00712703f, 0.29997334f, 0.08200093f, 0.52874410f, -0.02309049f, 
    -0.03835049f, -0.06532747f, -0.16612470f, -0.12379062f, -0.01313192f, 0.05951139f, -0.01906721f, 0.12197854f, 
    -0.20345333f, -0.12907232f, -0.40904742f, 0.03197607f, 0.06574418f, -0.01423089f, 0.32331708f, 0.25389907f, 
    0.12064587f, 0.01627918f, 0.16156888f, -0.03458640f, 0.34517604f, 0.25883299f, -0.00118889f, -0.04505821f, 
    0.02787327f, -0.02964692f, -0.00416092f, -0.08643079f, 0.17821434f, 0.06448378f, 0.10646529f, -0.03589651f, 
    -0.02884051f, 0.10490745f, -0.09426117f, 0.07088924f, -0.13661709f, -0.03666202f, 0.02048535f, -0.16933858f, 
    0.05490692f, -0.00133252f, 0.03175949f, 0.01893511f, -0.08311380f, -0.16789304f, -0.08146095f, 0.06188342f, 
    -0.08832448f, 0.05006633f, 0.08136798f, 0.01194837f, -0.03508012f, -0.00130411f, -0.05255727f, 0.07261526f, 
    0.35931152f, -0.10838968f, -0.04268167f, -0.00327611f, 0.07691690f, 0.03300555f, -0.08944864f, -0.16386241f, 
    -0.02801942f, 0.08401380f, -0.05662681f, -0.01830506f, 0.17847592f, -0.07048689f, -0.16344383f, 0.03484298f, 
    -0.06891325f, 0.05928911f, 0.03039430f, 0.06506037f, -0.05672711f, 0.23257625f, 0.06148045f, 0.06688964f, 
    0.04082772f, 0.12867908f, 0.02033346f, -0.08579438f, -0.17202500f, -0.07737192f, -0.04382148f, -0.05749209f, 
    -0.05378776f, -0.08804902f, 0.08413233f, 0.06935602f, 0.00122148f, -0.10023584f, 0.21902098f, 0.07187275f, 
    0.05305923f, 0.12535211f, 0.12159733f, 0.07914218f, 0.02198312f, -0.18043171f, 0.10801364f, 0.07338592f, 
    -0.11086324f, 0.03364920f, 0.42592764f, 0.27158162f, -0.09376979f, -0.09910766f, -0.03265270f, -0.05205795f, 
    -0.01544346f, -0.03143502f, 0.14606749f, -0.01353255f, -0.08621402f, 0.09218597f, 0.23101814f, -0.10939144f, 
    0.07790935f, 0.17489256f, 0.08092613f, 0.16795217f, -0.04151581f, 0.07673322f, 0.07251842f, 0.03733437f, 
    0.01328573f, -0.35091358f, -0.18717150f, -0.16952771f, 0.07919769f, 0.03476582f, 0.03373664f, 0.05073946f, 
    -0.00487381f, 0.14325589f, -0.09385936f, -0.17683557f, -0.10325159f, -0.18598177f, -0.14482649f, 0.03814701f, 
    -0.03548857f, -0.03524840f, 0.02349788f, 0.05501683f, 0.23916635f, 0.11310230f, -0.03161753f, 0.06135077f, 
    0.01837198f, 0.10575754f, 0.17252985f, -0.06426019f, -0.06040529f, -0.13052869f, -0.12877090f, 0.11783796f, 
    -0.16517346f, 0.12104622f, -0.00926089f, 0.14296553f, 0.04662866f, 0.29520872f, -0.08921380f, -0.17773129f, 
    -0.03892832f, 0.06697385f, 0.01784622f, -0.00167734f, -0.11179619f, 0.14511421f, 0.09812678f, 0.04980515f, 
    -0.11566825f, 0.08632302f, -0.00205191f, 0.07556183f, -0.12154792f, -0.15315400f, 0.12168714f, 0.35077146f, 
    -0.08043595f, 0.03948731f, 0.16196860f, 0.02998164f, 0.15679894f, 0.07847957f, -0.10988661f, -0.05812129f, 
    0.21296072f, 0.14929721f, -0.01845333f, -0.04565579f, 0.09674816f, -0.01999840f, 0.19670029f, 0.08751509f, 
    -0.04685858f, 0.02982723f, -0.02226681f, -0.05048611f, 0.04032114f, -0.02599302f, 0.00546986f, -0.04421935f, 
    0.02967677f, 0.02596570f, -0.05744554f, -0.05716663f, -0.00203382f, 0.03420607f, -0.05609577f, -0.01693804f, 
    -0.03709714f, -0.00388534f, -0.02306426f, -0.04281209f, -0.02520459f, 0.03836107f, -0.01729846f, 0.00537454f, 
    0.03708447f, -0.02699328f, 0.00235896f, 0.01749570f, -0.01500803f, -0.01785375f, 0.04232784f, -0.05553181f, 
    -0.05364785f, 0.00315632f, -0.04135397f, -0.01696668f, 0.02235924f, 0.00467019f, -0.02513564f, 0.02384053f, 
    -0.05564753f, -0.03026959f, 0.02297632f, -0.04239040f, -0.04311202f, -0.03727718f, 0.00953519f, -0.04190680f, 
    -0.04222084f, 0.00210975f, -0.04192455f, 0.02209523f, -0.00785465f, -0.00324610f, 0.02757991f, 0.04241171f, 
    -0.04327252f, -0.03023003f, 0.02626618f, 0.04149731f, 0.00144901f, -0.04396516f, -0.00080289f, -0.03426754f, 
    -0.03686286f, 0.02250533f, 0.03169634f, 0.03901669f, -0.03455484f, -0.02580419f, -0.00864931f, 0.03930949f, 
    0.00497916f, 0.04256571f, -0.00711949f, 0.02394777f, -0.05034578f, 0.01069983f, -0.02818093f, 0.01773896f, 
    0.00795335f, -0.04161121f, -0.02117758f, 0.03196193f, 0.03785410f, 0.02333144f, 0.01000060f, 0.00616957f, 
    -0.02163580f, 0.02148745f, -0.01128224f, -0.01141826f, 0.04364900f, 0.04192768f, 0.01795069f, 0.03780992f, 
    -0.05040448f, -0.04368750f, -0.02995945f, 0.01493277f, -0.05121729f, -0.01033924f, 0.00665737f, -0.00719078f, 
    -0.05701406f, -0.02533554f, 0.04034697f, -0.01157806f, -0.00637132f, -0.03350538f, -0.02676805f, 0.01837466f, 
    -0.01925594f, -0.05687876f, 0.03201948f, -0.03765354f, -0.05260413f, -0.02794792f, 0.03049472f, 0.04079111f, 
    -0.04208349f, 0.02166401f, -0.04214566f, -0.01623624f, 0.00233753f, -0.03501495f, -0.02413960f, -0.00941288f, 
    -0.05551565f, 0.01718838f, -0.05051030f, -0.05859276f, -0.02076658f, -0.05047948f, -0.01499395f, 0.00972407f, 
    0.01099395f, -0.04513638f, -0.01348550f, -0.03006602f, 0.04015522f, 0.01116132f, 0.00138358f, -0.03638469f, 
    -0.04364629f, -0.04046284f, -0.01630436f, 0.01731159f, 0.01652784f, 0.01393259f, -0.02612473f, -0.03433528f, 
    -0.01217969f, -0.02346908f, 0.01704220f, 0.00520550f, -0.00065110f, -0.00360413f, -0.01997267f, -0.04910643f, 
    -0.02069266f, -0.02419050f, -0.02088304f, -0.03751339f, 0.02134189f, -0.04308024f, -0.01552976f, 0.01059777f, 
    0.03338546f, 0.03926710f, 0.00524564f, -0.02561647f, -0.03098343f, -0.00642479f, -0.02156078f, 0.00479846f, 
    -0.01228708f, 0.01053963f, -0.02957888f, -0.05446116f, 0.00258720f, -0.03187788f, 0.00701220f, -0.00908011f, 
    0.00966052f, 0.03360388f, 0.03723019f, -0.03036321f, 0.01785093f, 0.02977241f, -0.00200786f, -0.05332649f, 
    -0.05147502f, -0.05033598f, 0.02265798f, -0.03487306f, -0.03438442f, -0.00483434f, 0.01450496f, 0.00445816f, 
    -0.04902273f, 0.01327757f, -0.03325617f, 0.00038547f, -0.00791777f, -0.01906259f, 0.00055461f, -0.02353061f, 
    -0.05698404f, -0.04892544f, -0.00331567f, 0.03499478f, -0.01880027f, -0.01133834f, 0.01879873f, 0.02275926f, 
    -0.02603689f, 0.02337969f, -0.05618085f, 0.04109921f, -0.05531370f, 0.03551945f, -0.05613254f, -0.04905408f, 
    -0.05974275f, 0.04011011f, 0.02675793f, -0.00975877f, 0.01371119f, -0.01977875f, -0.04804218f, 0.04117798f, 
    -0.00297603f, -0.02730500f, 0.04211854f, 0.00940133f, -0.03380742f, -0.02891840f, -0.04588803f, -0.02067049f, 
    -0.00562439f, -0.01895492f, 0.02087921f, 0.03671807f, -0.03924901f, 0.04157095f, -0.01433667f, 0.01584895f, 
    -0.02025202f, 0.00116230f, -0.04013356f, -0.02219869f, -0.04821143f, 0.01746155f, -0.00128715f, -0.03209103f, 
    0.03016136f, 0.03213776f, 0.00484693f, 0.00686013f, 0.02382374f, 0.03569642f, -0.03031815f, 0.03524049f, 
    -0.05606677f, -0.00850734f, -0.04019589f, 0.03676407f, -0.01753187f, 0.02887892f, 0.02222566f, -0.02011992f, 
    0.02747375f, 0.03467210f, -0.00687991f, 0.01860798f, -0.03938459f, 0.03078150f, -0.00370279f, -0.05674019f, 
    -0.02642671f, -0.04108039f, -0.03120383f, 0.01476569f, -0.00485609f, -0.04422932f, 0.00814414f, 0.03722700f, 
    0.03715382f, -0.01858897f, 0.00798651f, -0.05072894f, 0.02858977f, -0.03491250f, 0.02106857f, -0.00039326f, 
    -0.01434020f, 0.02774309f, 0.02860814f, -0.03709166f, 0.03485903f, -0.05297161f, 0.01744815f, -0.04321171f, 
    0.02877687f, 0.03615372f, 0.03428559f, -0.00334254f, -0.00777365f, -0.01111471f, -0.05042094f, -0.05174578f, 
    0.00901605f, -0.00872689f, 0.02291910f, -0.05185986f, -0.00636838f, 0.01733835f, -0.00493378f, 0.00039140f, 
    -0.05071404f, 0.02704645f, -0.04861532f, -0.04856839f, 0.03305780f, 0.03840277f, -0.04960887f, 0.02899342f, 
    -0.04461125f, -0.02741490f, 0.03119431f, -0.01612169f, -0.02921334f, -0.00345037f, 0.00185627f, -0.01719698f, 
    -0.05602054f, 0.00332782f, -0.02931965f, 0.03070643f, 0.01738634f, 0.01758024f, 0.03453860f, -0.05661521f, 
    0.04203887f, -0.04541441f, -0.01842197f, 0.03203672f, 0.00914366f, -0.00726992f, 0.01403759f, 0.00481112f, 
    -0.05762800f, 0.01107998f, -0.04750813f, -0.01566936f, 0.02723975f, -0.01164158f, 0.03216299f, -0.01690401f, 
    -0.02488267f, -0.02065943f, 0.00833761f, -0.05376231f, 0.04086316f, 0.03011284f, 0.00801728f, -0.03284581f, 
    0.00963476f, -0.03199738f, 0.02231664f, -0.00486992f, 0.03898822f, -0.01952454f, 0.02548983f, 0.03651951f, 
    0.01124766f, 0.01543673f, 0.03946856f, -0.03318728f, -0.05240149f, 0.00780710f, 0.01708610f, -0.04666770f, 
    -0.04389066f, 0.03442387f, -0.03454708f, 0.01854872f, -0.02022203f, 0.03653557f, -0.01611116f, 0.00595109f, 
    0.02986697f, -0.03205558f, 0.02722669f, 0.03985574f, -0.05713698f, -0.03193873f, 0.00291613f, -0.05036610f, 
    -0.01153981f, -0.05449952f, 0.04325176f, -0.05427188f, -0.00120522f, -0.01944638f, -0.05035236f, 0.00731471f, 
    -0.01626900f, -0.01812984f, -0.02590691f, -0.00653185f, -0.03005550f, 0.03671656f, 0.01233599f, 0.00151680f, 
    0.00709662f, 0.01808428f, 0.03417348f, -0.01019558f, -0.04374692f, -0.00921401f, -0.04652978f, 0.01174985f, 
    -0.03346384f, -0.01164082f, 0.02004178f, -0.01298709f, 0.01748434f, 0.01842036f, 0.03302208f, 0.03850295f, 
    0.03673230f, -0.02479166f, -0.04257064f, -0.03732143f, -0.00016401f, -0.04737949f, 0.03923768f, 0.00328735f, 
    0.03192565f, -0.01140918f, -0.03662352f, -0.01755717f, -0.01170312f, 0.00146666f, -0.02919056f, -0.03019030f, 
    -0.00390380f, -0.01768928f, -0.03258931f, 0.00407228f, -0.01385322f, -0.05485718f, -0.00816820f, 0.02189566f, 
    0.04202522f, 0.02497573f, 0.02804314f, -0.00173943f, 0.01032825f, -0.01295121f, -0.04051696f, -0.05450695f, 
    0.02079826f, -0.03326347f, 0.04312535f, -0.03917225f, -0.02933925f, -0.02358614f, -0.04326586f, -0.00497548f, 
    -0.03363189f, -0.00248033f, 0.04016659f, -0.01204541f, 0.02974431f, -0.05614143f, -0.04998245f, -0.05188187f, 
    -0.02793314f, -0.04621914f, 0.02338406f, -0.03423297f, 0.01362562f, -0.04797530f, -0.03913619f, 0.02946412f, 
    -0.03053171f, 0.01934662f, -0.00816890f, 0.00034307f, -0.00122411f, -0.03004969f, -0.01545436f, -0.01343309f, 
    -0.05650000f, 0.04185520f, -0.04030756f, 0.02727546f, 0.01820468f, 0.02725840f, -0.03837722f, -0.05021810f, 
    -0.00108450f, -0.04118925f, -0.04434290f, 0.00461803f, 0.02437486f, -0.04254885f, -0.00634925f, -0.05503706f, 
    -0.02911072f, -0.01528682f, 0.00460957f, -0.02500474f, 0.01057890f, -0.00766822f, 0.01707141f, 0.01059964f, 
    -0.01900585f, -0.01253550f, -0.03907755f, -0.03201525f, 0.00851187f, -0.04165479f, -0.03289693f, -0.00221377f, 
    0.02283836f, 0.01815377f, -0.03192277f, -0.00950607f, -0.05624741f, 0.01063552f, -0.00861771f, -0.04778435f, 
    -0.03286549f, -0.00959113f, -0.04308059f, -0.01144466f, -0.02908629f, 0.04349126f, 0.02161289f, -0.03992810f, 
    0.04061099f, 0.02471305f, -0.05027787f, 0.00636208f, -0.02389899f, -0.03878374f, -0.00660083f, 0.02890798f, 
    -0.04132866f, -0.04518415f, -0.02082550f, -0.05532429f, 0.01157190f, 0.03685217f, 0.03616229f, -0.00008264f, 
    -0.00025684f, 0.02275981f, -0.04597816f, 0.01709093f, 0.02800567f, 0.00713244f, -0.04280347f, -0.05312055f, 
    0.04079485f, -0.00382891f, 0.03234804f, 0.00004689f, 0.01059045f, -0.05057045f, 0.03558209f, 0.02441519f, 
    0.04039587f, -0.00256897f, -0.04187192f, 0.04227181f, -0.01255194f, -0.04264143f, 0.03061740f, -0.01219553f, 
    0.03836224f, -0.01951363f, -0.05813138f, 0.01649816f, 0.00047772f, -0.05805188f, 0.01303006f, -0.01318533f, 
    -0.00261566f, -0.01012888f, -0.05014175f, -0.01371845f, -0.04728800f, 0.01753657f, -0.00948259f, -0.00287958f, 
    -0.00192262f, 0.02925260f, 0.00868819f, -0.03475910f, 0.03849554f, -0.00226505f, 0.03994617f, -0.01331732f, 
    0.02279107f, 0.03355703f, 0.02505216f, -0.01124159f, 0.01051708f, -0.04158298f, -0.02221872f, -0.02786300f, 
    -0.05015794f, 0.00833399f, 0.03057874f, 0.02933873f, 0.03603302f, 0.01960629f, -0.00107342f, -0.05159957f, 
    0.00847418f, 0.02384834f, -0.04714947f, -0.04982865f, -0.02447915f, 0.03897045f, 0.02787559f, -0.04889401f, 
    -0.05016090f, -0.00721472f, -0.04340038f, 0.02676802f, 0.00376506f, -0.03498656f, -0.03255285f, -0.03556248f, 
    -0.01810245f, -0.03360676f, 0.03471139f, -0.00073528f, -0.02184491f, -0.05767746f, -0.01625383f, -0.05650469f, 
    0.03546326f, -0.02965883f, 0.01931207f, 0.05328507f, -0.01016183f, -0.04324713f, -0.01973584f, -0.04543150f, 
    0.01021733f, -0.04487902f, 0.04163598f, -0.04135590f, -0.03827383f, 0.02527087f, 0.04068001f, 0.00196119f, 
    0.00377233f, -0.03332143f, -0.03620169f, -0.01159335f, -0.03325773f, -0.04565011f, 0.02552567f, 0.02925252f, 
    -0.02357464f, -0.03127264f, 0.00659669f, 0.01082552f, -0.02339930f, -0.00883067f, 0.01386359f, -0.01588826f, 
    0.02227914f, 0.01633283f, -0.05002240f, -0.05637575f, 0.00737784f, 0.00533443f, -0.03180491f, -0.04086152f, 
    0.02913137f, -0.01067182f, -0.01689469f, 0.03890998f, 0.03639866f, -0.04956415f, 0.01106729f, 0.03403081f, 
    -0.05551697f, -0.01292952f, 0.02318867f, 0.02341861f, 0.00521024f, 0.01325288f, -0.05189374f, -0.05368043f, 
    -0.03322064f, 0.03159530f, 0.02714752f, 0.01773482f, -0.00445375f, 0.03009328f, 0.04022355f, 0.02219679f, 
    0.01100064f, -0.04313318f, -0.00082990f, 0.02936194f, 0.04142757f, -0.03158195f, 0.02713547f, -0.03932555f, 
    -0.04870444f, 0.04246629f, 0.03161566f, -0.05464511f, 0.02438602f, 0.00356401f, -0.00420177f, 0.01251236f, 
    0.00748463f, -0.04002507f, -0.03502005f, 0.01996598f, 0.00807659f, 0.00261022f, -0.04424128f, 0.00006451f, 
    0.02568326f, -0.04481857f, -0.05698548f, 0.01411964f, -0.00383196f, -0.02774553f, -0.05024489f, -0.01894298f, 
    -0.04005141f, -0.00456096f, -0.03677067f, -0.05106073f, -0.03857379f, -0.03164232f, -0.03275484f, 0.01689085f, 
    0.01915298f, -0.05855826f, -0.05016512f, -0.00459912f, 0.00061251f, 0.00530313f, -0.05863467f, 0.03596575f, 
    0.03628380f, -0.03359396f, 0.01430515f, -0.03098090f, 0.02604998f, 0.01018427f, -0.03401764f, -0.04407433f, 
    -0.03231803f, -0.07060723f, 0.00491697f, 0.05125059f, -0.07641299f, 0.05037444f, 0.08241543f, -0.15304826f, 
    -0.03971703f, 0.16865660f, 0.09244118f, 0.21991232f, 0.26594764f, -0.13089311f, 0.02098769f, 0.01860568f, 
    0.02916040f, 0.23612864f, -0.12540857f, 0.05655821f, -0.13226807f, -0.01156802f, -0.02490600f, 0.02313545f, 
    -0.13115773f, 0.13209446f, 0.25474578f, -0.08277554f, 0.08513023f, 0.00621567f, -0.17582977f, 0.18043195f, 
    -0.00998862f, 0.01345218f, 0.01889292f, -0.01568571f, -0.24963933f, -0.04566236f, -0.05851823f, 0.02605775f, 
    0.05931163f, 0.00410589f, -0.09635133f, 0.05192874f, -0.02641186f, 0.08409068f, 0.04940564f, 0.06787945f, 
    -0.00729995f, -0.04779981f, -0.03464568f, 0.00308328f, -0.16417019f, -0.03558781f, -0.09824125f, -0.09379143f, 
    -0.07407673f, 0.06529061f, 0.04269670f, 0.20885411f, -0.09394874f, -0.14854303f, 0.15750803f, 0.02907217f, 
    -0.03611942f, -0.07023125f, 0.08785053f, 0.10558803f, 0.02184093f, 0.19315329f, -0.16208375f, 0.08493904f, 
    0.10454325f, 0.25254112f, -0.10571079f, 0.21255803f, 0.18378855f, 0.12939882f, 0.15674704f, 0.11718665f, 
    -0.04959439f, 0.09288932f, -0.04563495f, -0.05667805f, 0.30262744f, 0.17385408f, 0.21036933f, 0.35727045f, 
    -0.05384514f, 0.13957015f, 0.12834343f, 0.28092659f, -0.06464957f, -0.05009228f, 0.08830742f, 0.00272507f, 
    0.33664608f, -0.12627998f, 0.27942637f, -0.10816638f, 0.08343314f, 0.05075083f, 0.01080449f, 0.02790059f, 
    0.07618131f, -0.02283601f, 0.00987780f, -0.07062767f, 0.14548084f, 0.31461078f, 0.20134297f, 0.37045333f, 
    -0.05592123f, 0.15145488f, -0.00627159f, 0.06765221f, -0.07391061f, -0.09279028f, -0.12753648f, 0.03677729f, 
    0.21005641f, -0.22596593f, 0.05697220f, -0.11797233f, -0.09298211f, 0.03032745f, 0.18877757f, -0.09447027f, 
    0.23939821f, -0.06314563f, -0.10373612f, -0.03845989f, 0.32324338f, -0.22987728f, -0.46026194f, 0.07874547f, 
    0.23845778f, 0.27266416f, 0.07207684f, 0.15562141f, -0.03907258f, -0.23712783f, 0.16350259f, 0.21186019f, 
    -0.36410144f, -0.06166639f, -0.12163980f, -0.12509072f, -0.03251346f, -0.08465897f, -0.07624667f, -0.00154319f, 
    -0.17923871f, -0.15116705f, -0.22648785f, 0.08143236f, -0.04578516f, -0.10636736f, 0.18774348f, -0.17463182f, 
    0.01078732f, 0.09121573f, 0.15927191f, -0.06001838f, 0.16263069f, 0.13323444f, 0.00139854f, -0.02853974f, 
    0.17039609f, -0.01258753f, -0.11319489f, -0.07102831f, -0.05837664f, -0.05464730f, 0.06737360f, 0.17480999f, 
    -0.19810514f, 0.15092489f, 0.05436079f, -0.05234605f, -0.37778154f, 0.16896911f, 0.26458043f, -0.02244354f, 
    -0.04989500f, -0.02049442f, -0.15477891f, 0.13310331f, 0.00748418f, -0.05384274f, 0.02909756f, 0.00287496f, 
    0.12487072f, 0.31233311f, -0.06520195f, -0.17599919f, -0.00186642f, 0.11826979f, 0.07101384f, 0.05297158f, 
    -0.00436820f, -0.09072043f, -0.05403293f, -0.00745325f, -0.02226618f, -0.07274760f, -0.07327617f, 0.09453836f, 
    -0.08435869f, 0.05064883f, -0.07481474f, -0.08401172f, 0.08726910f, -0.01076367f, -0.07993780f, -0.10755427f, 
    0.25360951f, 0.08286560f, -0.11194267f, -0.15990303f, 0.05103925f, 0.12620713f, 0.18874145f, 0.25227976f, 
    -0.04359194f, -0.00650531f, 0.06463376f, -0.05138323f, 0.05222576f, 0.04234973f, -0.13876963f, -0.05893865f, 
    0.04433888f, 0.11686984f, 0.06592247f, 0.24067909f, -0.07569795f, -0.07238685f, 0.08054823f, 0.13120660f, 
    0.13292561f, 0.38747674f, 0.07981791f, 0.35117906f, 0.06388655f, 0.19725320f, -0.13815697f, 0.20246029f, 
    -0.02895643f, -0.05005454f, -0.11205631f, -0.05409215f, -0.28893125f, -0.06794379f, -0.16314933f, -0.10825996f, 
    -0.08271340f, 0.09281255f, -0.06602866f, 0.02729997f, 0.06573444f, -0.07234935f, -0.20531584f, 0.02392049f, 
    -0.03686212f, -0.10445593f, -0.06229000f, -0.01012936f, -0.08713932f, -0.24047323f, 0.03094922f, 0.03527041f, 
    -0.07939655f, 0.07790038f, 0.03764774f, 0.06970707f, -0.53217679f, 0.07445475f, 0.12705703f, 0.10430972f, 
    0.05344769f, 0.16181752f, -0.28855562f, -0.05725746f, 0.08478556f, -0.00984421f, 0.00005845f, 0.18746234f, 
    -0.30907649f, 0.08821310f, -0.02435691f, -0.08550058f, -0.00212740f, -0.04091328f, -0.15979129f, 0.16962045f, 
    0.00932261f, -0.04674434f, -0.07544654f, 0.02807947f, -0.06302088f, 0.02182451f, -0.05187652f, 0.12385217f, 
    0.04273090f, 0.03345359f, -0.11823920f, 0.18413652f, -0.06084136f, -0.12258070f, 0.09695088f, 0.20925708f, 
    0.21466041f, -0.03720098f, -0.02354911f, 0.10557240f, 0.13984287f, 0.16415069f, 0.19875765f, 0.09958854f, 
    0.11591323f, -0.02058517f, -0.08769801f, 0.05556756f, -0.01295762f, 0.14137557f, 0.12241403f, 0.02501807f, 
    0.27677557f, 0.22110265f, 0.02706415f, 0.03466278f, -0.11089980f, -0.14378162f, -0.14146635f, 0.04277868f, 
    -0.27556321f, -0.13980052f, 0.06161650f, -0.12135063f, 0.00715177f, -0.09235799f, 0.05870345f, -0.07823738f, 
    -0.07417560f, 0.11171204f, -0.05825179f, 0.05547760f, 0.17976682f, -0.23195049f, 0.05342460f, -0.09972414f, 
    -0.10980669f, -0.02299223f, 0.13153380f, 0.08336566f, -0.00155233f, 0.16248912f, -0.05995774f, -0.08006326f, 
    -0.00061818f, 0.18264897f, -0.08950230f, -0.00088065f, 0.04214469f, 0.20986232f, 0.10718688f, -0.25686958f, 
    -0.01145067f, 0.01426897f, 0.02062991f, 0.09703284f, -0.25418609f, 0.34476915f, -0.07914006f, -0.13696745f, 
    0.02336723f, 0.06784052f, 0.11753628f, 0.13546364f, -0.04889212f, 0.03802897f, -0.19297175f, 0.14080720f, 
    -0.05306602f, -0.03239013f, -0.04714391f, -0.00994058f, 0.02714178f, -0.04736117f, -0.03322446f, -0.03321030f, 
    -0.01097595f, 0.03458700f, 0.01714729f, 0.01539344f, -0.01673223f, -0.04224649f, -0.03410409f, 0.03348885f, 
    -0.00537505f, -0.00242708f, -0.00633674f, -0.05864309f, -0.03374798f, -0.00659782f, -0.02718584f, -0.05991029f, 
    -0.03062052f, -0.02543068f, 0.01262783f, -0.05877278f, -0.02252794f, 0.01949072f, 0.00028139f, -0.04364482f, 
    0.00934049f, -0.00305564f, -0.05812512f, 0.01670172f, 0.00931942f, -0.04018404f, 0.03062352f, 0.03785752f, 
    -0.03719136f, 0.02312896f, -0.00980402f, -0.00777701f, 0.01662479f, 0.00843231f, -0.01845345f, -0.04705561f, 
    0.03414760f, -0.01330336f, -0.03049878f, 0.00903565f, -0.02019534f, -0.04035683f, 0.00420887f, -0.00250432f, 
    0.00474063f, -0.02167122f, 0.02329356f, 0.01617946f, -0.04603942f, 0.02831811f, -0.00558795f, -0.03016623f, 
    -0.04382826f, -0.00620420f, -0.05748618f, -0.05733571f, -0.00751437f, -0.00370734f, 0.00256076f, 0.02683721f, 
    -0.03444677f, 0.03686392f, -0.04826760f, -0.04361157f, -0.06400315f, 0.01789858f, 0.01137593f, -0.01524256f, 
    0.01947252f, -0.06316390f, 0.01895879f, 0.02118752f, -0.04726028f, -0.02149643f, -0.00933925f, -0.04063175f, 
    0.02360416f, 0.02014159f, 0.01092558f, -0.00606134f, 0.04354379f, -0.05220536f, 0.04018674f, -0.04614268f, 
    -0.03196226f, -0.04948735f, 0.02769210f, -0.05286143f, -0.03866088f, -0.01147598f, 0.02094632f, -0.02802190f, 
    -0.01485884f, -0.02030469f, -0.01451743f, 0.01944893f, -0.01597388f, -0.05707351f, 0.00672399f, 0.00405478f, 
    -0.06076327f, -0.03296505f, 0.00167188f, 0.03238715f, -0.03311653f, -0.01078609f, -0.04330134f, 0.03055145f, 
    -0.03726081f, 0.02295353f, -0.06196755f, 0.03401280f, -0.05358696f, -0.06277642f, -0.06297787f, -0.04833448f, 
    -0.05520924f, -0.01069513f, -0.02848588f, -0.02761213f, -0.00105008f, -0.02784790f, -0.03573526f, -0.02147233f, 
    -0.02737650f, -0.05262719f, 0.00447367f, -0.02569095f, -0.04899208f, 0.02831078f, -0.01130091f, -0.01742981f, 
    0.01988594f, -0.00673373f, 0.02939403f, -0.04644493f, 0.01555557f, -0.00529701f, -0.03245183f, -0.03818211f, 
    -0.02893314f, 0.00705629f, 0.01757495f, -0.00783071f, -0.03481993f, -0.04180457f, 0.00123436f, 0.03495241f, 
    -0.06177218f, 0.02368827f, 0.03053246f, -0.04118455f, 0.03715368f, -0.00371711f, -0.00665452f, 0.01140889f, 
    0.01339714f, 0.01133016f, -0.04826778f, -0.04066543f, 0.00714818f, 0.01833884f, -0.05469404f, -0.01739337f, 
    -0.03217781f, 0.00511731f, -0.02891933f, 0.02975183f, -0.03669288f, 0.02993190f, -0.01306013f, 0.02284415f, 
    0.02787506f, 0.03710458f, -0.02795435f, -0.03628734f, -0.01821613f, -0.02322038f, -0.01195793f, 0.00417336f, 
    0.01232846f, 0.01101481f, 0.00186616f, -0.03709923f, -0.04951578f, -0.01852243f, 0.03157316f, 0.01095780f, 
    -0.04685381f, -0.01026707f, -0.01151376f, -0.04700110f, 0.00254761f, 0.02172563f, -0.06205009f, 0.03289126f, 
    -0.01123432f, -0.04558833f, -0.02578955f, -0.05158411f, -0.04655418f, 0.03071942f, 0.02074144f, 0.03203324f, 
    -0.03666651f, -0.04726650f, -0.03861617f, -0.03279631f, 0.03611109f, 0.02229539f, 0.01843354f, -0.03987150f, 
    -0.02006924f, -0.00563871f, -0.03220646f, 0.02151381f, -0.02242572f, 0.03225144f, -0.04495968f, -0.00827043f, 
    0.03118409f, -0.01686988f, 0.01004794f, -0.03990202f, 0.01687450f, 0.00848279f, -0.00248648f, -0.02724061f, 
    0.04996854f, 0.04542008f, 0.00998556f, -0.00621585f, -0.05258389f, -0.01387137f, -0.00951589f, -0.00816761f, 
    -0.05508438f, 0.02310752f, -0.00849171f, 0.03522524f, -0.02923158f, 0.03309795f, -0.04248743f, 0.03641967f, 
    -0.03388074f, 0.02892101f, -0.00388676f, -0.03541013f, -0.05334119f, -0.05867311f, 0.03799859f, -0.02365087f, 
    -0.02956657f, 0.01988383f, 0.01055442f, 0.00689783f, 0.00949610f, -0.02750686f, 0.01800399f, 0.01952845f, 
    -0.02901652f, 0.01003549f, 0.01594174f, -0.02679302f, 0.00896713f, -0.00607971f, -0.03737519f, 0.03644513f, 
    -0.00460258f, -0.04414655f, -0.04466649f, 0.01100266f, 0.01154751f, -0.02241718f, 0.00724481f, 0.02098537f, 
    -0.04226205f, -0.03608947f, -0.00995104f, 0.00375069f, -0.05515762f, -0.04368474f, 0.01136099f, 0.00074999f, 
    -0.02498627f, -0.00255135f, -0.05975343f, 0.03255558f, -0.04905579f, 0.02675493f, -0.00435701f, 0.03219259f, 
    0.02398773f, 0.03647645f, -0.02914213f, -0.00531739f, -0.02447304f, 0.01796885f, 0.00697996f, -0.03636521f, 
    -0.05813066f, -0.02905334f, -0.00012261f, 0.02628671f, 0.03265389f, 0.02038407f, -0.05018862f, -0.05401384f, 
    0.01277651f, -0.05578239f, 0.02638852f, -0.00926344f, -0.02391490f, 0.00741558f, 0.02029856f, -0.01290278f, 
    0.03696229f, 0.00550855f, 0.00409058f, -0.03632411f, -0.04153316f, 0.00408452f, -0.04162654f, -0.04834289f, 
    -0.01683682f, -0.04768242f, 0.02363313f, 0.03385897f, 0.02345343f, 0.01733969f, 0.03711795f, 0.01948842f, 
    0.03969815f, -0.03191758f, -0.02980765f, 0.04190996f, 0.02573619f, 0.01103334f, -0.04121624f, -0.03993196f, 
    -0.03121250f, 0.04030313f, -0.05267634f, 0.00913031f, 0.01815194f, 0.02508638f, -0.02322923f, -0.04373663f, 
    -0.00117931f, 0.03224884f, -0.02735153f, 0.02223154f, 0.01179573f, 0.00804842f, -0.01474955f, 0.00256221f, 
    0.03230814f, 0.04074478f, 0.01115603f, -0.01729170f, 0.03141046f, -0.05100867f, -0.02831945f, -0.05172273f, 
    -0.02584720f, 0.01686377f, 0.00205664f, -0.06037216f, 0.02068239f, -0.03154873f, -0.04537642f, 0.02192462f, 
    0.01308864f, 0.08323780f, -0.04130062f, 0.06184990f, -0.04944984f, 0.00551877f, 0.05703514f, -0.14315459f, 
    0.00394076f, 0.04359778f, 0.10196134f, 0.15931512f, 0.27606189f, 0.05923234f, 0.03581593f, 0.18990000f, 
    0.19818960f, -0.09719522f, 0.03784861f, 0.18018192f, -0.14782360f, -0.01649147f, -0.02361968f, -0.03285738f, 
    -0.09994769f, 0.28191188f, 0.16531268f, -0.18624920f, -0.15571475f, 0.05111283f, 0.07656202f, 0.12760089f, 
    -0.03471337f, -0.00307625f, -0.04861657f, -0.05866431f, 0.13316420f, -0.15007184f, -0.12794015f, -0.11520053f, 
    -0.07916573f, -0.03966387f, -0.05530863f, 0.01139487f, -0.04206788f, -0.02226953f, 0.06947454f, -0.04121693f, 
    0.02143129f, -0.07840513f, -0.02368265f, -0.04238070f, 0.09124639f, 0.02282308f, 0.03328033f, 0.05272758f, 
    0.01498498f, 0.05918720f, 0.06513993f, 0.00802681f, -0.01273192f, -0.27046859f, -0.12055077f, -0.12288983f, 
    -0.12389985f, -0.11022437f, -0.02451947f, -0.03359629f, -0.11160076f, 0.01020723f, 0.01431593f, -0.18897395f, 
    0.05223431f, -0.00101497f, -0.09027177f, -0.18307194f, 0.06426964f, 0.00808113f, -0.05378788f, -0.11362716f, 
    -0.06257699f, -0.01061006f, 0.10943713f, -0.02458382f, 0.12389734f, 0.18310462f, 0.14361313f, -0.04689148f, 
    0.12553573f, -0.03633779f, 0.04438236f, 0.01720269f, -0.03716108f, -0.05913598f, 0.01800417f, -0.00510348f, 
    -0.01231904f, -0.12693761f, 0.19690926f, 0.03752776f, -0.12723699f, 0.06832660f, 0.01397387f, -0.02943066f, 
    0.04023983f, 0.09697278f, -0.04664173f, 0.06539369f, 0.42420480f, 0.05390480f, -0.02305594f, -0.11906993f, 
    0.13383012f, 0.11356016f, 0.00292246f, 0.04031101f, -0.00971653f, 0.02576474f, 0.12082034f, -0.07562336f, 
    0.17057237f, 0.50537503f, -0.25782427f, 0.26526669f, 0.14310592f, -0.03032086f, 0.01617162f, -0.02482004f, 
    -0.02570518f, 0.15699321f, 0.02087314f, 0.06986121f, 0.47552037f, -0.04042150f, -0.21969220f, 0.32027817f, 
    -0.14359561f, 0.06167884f, 0.15418844f, 0.11918853f, 0.01254730f, -0.12729301f, -0.08048689f, 0.24088545f, 
    -0.21613884f, -0.26832333f, 0.02640796f, 0.12616481f, -0.04898685f, -0.04009206f, -0.02845448f, 0.02751715f, 
    -0.16927150f, 0.04385884f, 0.08590517f, -0.09168458f, 0.42721742f, -0.12193983f, 0.00861370f, 0.04014931f, 
    0.05045795f, 0.03759735f, -0.00908211f, 0.19107124f, 0.01673271f, 0.16094981f, 0.01302691f, 0.02639540f, 
    -0.10086484f, 0.07032675f, -0.17629355f, -0.01703600f, -0.06064863f, 0.04517351f, -0.03343762f, -0.02673723f, 
    -0.12166071f, -0.19671208f, 0.06493038f, 0.04611225f, -0.14734133f, -0.41026977f, -0.48730943f, -0.09153976f, 
    -0.16916493f, -0.05712101f, -0.13591410f, 0.00634726f, 0.02457078f, 0.03258666f, 0.01761618f, -0.00247258f, 
    -0.05072244f, 0.45279309f, 0.20529062f, -0.07318437f, 0.10768430f, 0.01748258f, 0.09853003f, 0.23826198f, 
    0.06708944f, -0.07151882f, -0.04487728f, -0.07886603f, -0.32243007f, 0.24029005f, 0.22744191f, -0.15605690f, 
    0.01578820f, -0.07343626f, 0.00583411f, -0.13806349f, 0.01250882f, -0.14025237f, -0.10067689f, 0.02405249f, 
    0.13636534f, 0.18513514f, 0.03518755f, 0.06664658f, 0.01094578f, 0.04571364f, 0.12984082f, 0.06226741f, 
    -0.04300720f, -0.01092930f, -0.01908135f, 0.00040469f, 0.28717303f, 0.24110052f, 0.11068942f, 0.03868964f, 
    0.15462500f, 0.11661391f, 0.10122246f, 0.23478119f, -0.03968203f, 0.00856113f, -0.02798594f, 0.06448281f, 
    0.29284391f, 0.29701117f, 0.23805456f, 0.01261349f, 0.06874632f, 0.15931089f, -0.02364055f, 0.04314741f, 
    -0.08311503f, 0.07697432f, 0.02221633f, 0.01613369f, 0.31822464f, -0.21844307f, -0.07152131f, 0.11278073f, 
    0.00726755f, 0.02005275f, -0.00983981f, 0.07139762f, -0.00613710f, 0.10265580f, -0.09640928f, -0.00337089f, 
    -0.12616903f, -0.22270885f, 0.00690666f, -0.10817040f, -0.00575111f, 0.14189868f, -0.05299094f, -0.02916335f, 
    0.02577747f, 0.00008271f, 0.13462652f, 0.06345208f, 0.30784905f, -0.27998924f, -0.00696620f, -0.12440310f, 
    -0.22809815f, -0.03623794f, 0.15211529f, -0.06703154f, 0.09514096f, -0.10622731f, 0.04890110f, -0.02693887f, 
    -0.01660092f, -0.41279984f, -0.55444700f, 0.16925471f, -0.17162450f, -0.12660936f, 0.15894715f, -0.05059497f, 
    -0.00888371f, 0.02118086f, 0.06633312f, -0.05747355f, 0.23122922f, -0.12542845f, 0.14555272f, -0.26750082f, 
    -0.15182468f, -0.04669410f, 0.00351541f, -0.07600840f, -0.03550674f, 0.03240613f, 0.18933278f, 0.02913461f, 
    0.15765491f, -0.20051041f, -0.18008362f, -0.09389874f, 0.10735232f, 0.02994836f, -0.11527795f, -0.10539605f, 
    0.01315286f, 0.18639785f, 0.01415961f, -0.00922166f, 0.29270715f, 0.18744580f, 0.09329043f, 0.11837714f, 
    0.14130658f, 0.01656034f, 0.13251932f, 0.22095253f, -0.00790611f, -0.00563763f, -0.02415220f, 0.07794541f, 
    0.09064726f, -0.26241732f, -0.15082388f, -0.01585099f, -0.01255277f, -0.04317749f, -0.07742336f, 0.08014033f, 
    -0.15522236f, 0.09961037f, 0.03757062f, 0.00573419f, -0.22415301f, 0.22496377f, 0.11358729f, -0.03230844f, 
    0.07604057f, -0.02439377f, -0.08148111f, -0.09666131f, -0.01926602f, -0.05912131f, 0.10981885f, -0.03294873f, 
    0.14622536f, 0.25889701f, 0.04062305f, -0.02344200f, -0.07797990f, 0.04024838f, 0.12268768f, 0.06341954f, 
    -0.00176908f, 0.14336988f, -0.01928525f, -0.00546262f, -0.45575163f, 0.00553883f, 0.18615812f, -0.12883730f, 
    0.01817663f, 0.03700076f, -0.09840292f, -0.04483301f, 0.07039189f, -0.04184525f, 0.05467900f, -0.04748626f, 
    -0.07341322f, -0.17768383f, 0.13937072f, 0.07487987f, 0.08786654f, -0.04391688f, 0.03168848f, 0.06332970f, 
    -0.13636234f, 0.01753000f, 0.05086030f, -0.13155937f, 0.15307003f, -0.14631055f, 0.10944713f, -0.19846290f, 
    -0.17998239f, -0.11200571f, 0.01525366f, -0.36054590f, -0.02452704f, -0.00116820f, -0.05044676f, 0.05107871f, 
    -0.00995903f, 0.04467527f, -0.17014335f, -0.31570309f, 0.01359977f, 0.06258226f, -0.10030516f, 0.00571289f, 
    0.04117845f, -0.06591001f, 0.08745154f, 0.01813981f, 0.10512732f, 0.08253829f, -0.09390632f, 0.00137423f, 
    -0.04361880f, -0.05265633f, 0.01887693f, 0.01912668f, -0.07250118f, -0.05959500f, -0.03952660f, -0.02366965f, 
    0.11355364f, -0.01463052f, -0.02436583f, 0.00315214f, 0.11414821f, 0.07488611f, -0.01080610f, 0.03905090f, 
    -0.03173640f, -0.08241138f, -0.11345641f, 0.01630054f, 0.37004068f, -0.17459467f, 0.23778497f, 0.07624635f, 
    0.02756598f, 0.10165292f, -0.00497416f, 0.10270453f, -0.02675626f, 0.12485895f, -0.08571517f, -0.10027234f, 
    -0.02849041f, 0.16611117f, 0.18538602f, 0.19327226f, -0.11004203f, -0.04790557f, -0.16874179f, -0.00137748f, 
    0.09515454f, 0.11166093f, 0.04362595f, 0.16603145f, 0.13208671f, 0.08383013f, 0.04139009f, 0.19031291f, 
    -0.10251161f, -0.06381267f, -0.07890394f, 0.09984647f, -0.09419073f, -0.12779805f, 0.03883107f, -0.02536414f, 
    -0.00519884f, 0.05024280f, -0.07177587f, -0.33616540f, -0.13791858f, 0.07483770f, 0.31630129f, 0.00010000f, 
    0.09673718f, 0.21320082f, -0.18894078f, -0.15749960f, -0.09950205f, 0.41806149f, 0.26870820f, 0.17956550f, 
    -0.24707039f, -0.07326219f, 0.08401618f, 0.05848080f, 0.02167905f, 0.01643173f, -0.04131808f, -0.00969599f, 
    0.16088037f, -0.06075726f, 0.40455839f, -0.10336182f, -0.18873027f, -0.01631055f, 0.07234822f, 0.00190151f, 
    0.01582494f, -0.15221456f, -0.04868582f, -0.04521644f, 0.23611885f, -0.03907936f, 0.17170182f, -0.36974704f, 
    0.07910531f, -0.12424395f, 0.13951027f, -0.06015585f, 0.10736968f, 0.32277015f, -0.03409941f, 0.10217927f, 
    0.04305492f, 0.02598429f, 0.05658123f, -0.04499479f, -0.05111758f, -0.03370466f, 0.00540099f, 0.00983753f, 
    -0.18302897f, 0.18325704f, 0.14186886f, 0.22867295f, -0.05725192f, 0.12923653f, 0.34554896f, -0.06851340f, 
    0.08310375f, -0.06351538f, -0.03277497f, -0.24323663f, 0.00673698f, 0.22114223f, 0.07363843f, 0.25076419f, 
    -0.05643027f, -0.02999388f, 0.12749630f, 0.20833968f, -0.04197636f, -0.04870514f, -0.00518391f, 0.12959358f, 
    -0.02702508f, 0.06582136f, 0.13190727f, 0.11464812f, 0.17389941f, 0.07882074f, 0.25005102f, -0.11315108f, 
    -0.01493255f, 0.07939007f, 0.06756599f, 0.00498848f, -0.00882472f, -0.05659550f, -0.03297353f, 0.09242103f, 
    -0.41012725f, -0.22884558f, -0.21180573f, 0.16729636f, -0.01735322f, -0.18714565f, -0.06061232f, -0.06550843f, 
    -0.10054988f, -0.19389166f, 0.05368601f, -0.04185226f, -0.10217424f, 0.28289884f, -0.17005585f, 0.03817113f, 
    -0.01753659f, 0.05025394f, 0.16158631f, -0.02883560f, 0.01476743f, -0.00675196f, 0.06382279f, -0.06040485f, 
    -0.17321226f, -0.26140818f, 0.01527399f, -0.01686956f, 0.08314413f, -0.09011778f, 0.03701744f, -0.06976159f, 
    -0.02987375f, -0.06342577f, 0.01849832f, -0.04261182f, -0.20256716f, -0.03717285f, 0.05677134f, -0.06577656f, 
    -0.27952719f, -0.04011595f, -0.03264872f, -0.01298194f, -0.06512636f, -0.07342363f, -0.00026205f, -0.04087991f, 
    -0.08292823f, 0.08158085f, 0.07345062f, 0.19541149f, -0.13541317f, -0.05337210f, -0.16670692f, -0.12841940f, 
    0.00664153f, -0.02683784f, -0.05203591f, -0.11449271f, 0.22918832f, 0.18309768f, -0.01865347f, -0.19161870f, 
    -0.06665096f, 0.05820523f, 0.01611950f, 0.02840962f, 0.03056279f, 0.06353437f, -0.04786422f, -0.05482490f, 
    0.10980875f, 0.05503039f, 0.02813856f, 0.07579790f, -0.03004648f, -0.07747729f, -0.06563269f, 0.02491825f, 
    -0.08841904f, -0.04701779f, 0.08795980f, -0.00539699f, -0.01634997f, 0.14023635f, 0.25843874f, -0.12193407f, 
    0.10478950f, 0.22174482f, 0.07207227f, 0.16295382f, 0.32777962f, 0.05743021f, -0.04762036f, 0.05852610f, 
    0.27905345f, 0.11107881f, 0.39073539f, -0.50652945f, -0.07446569f, -0.03041686f, 0.02550216f, 0.09834662f, 
    0.07931212f, 0.01529808f, -0.01790898f, -0.01126150f, 0.05822984f, 0.00978169f, -0.17690372f, 0.27515101f, 
    0.22812447f, 0.06571686f, 0.08391185f, 0.07383835f, -0.04194421f, 0.00130491f, 0.05493611f, -0.10542444f, 
    0.15201181f, 0.29234874f, 0.31446147f, 0.10976460f, -0.13309720f, -0.06427841f, 0.07877867f, -0.11906791f, 
    -0.23134872f, 0.01915779f, 0.05903084f, 0.02973493f, -0.09377428f, -0.00822582f, 0.02877986f, -0.02070501f, 
    -0.06351782f, 0.16912672f, 0.04467703f, 0.02103126f, 0.00894267f, 0.14718969f, 0.04729341f, 0.00209765f, 
    0.17291369f, -0.03627699f, 0.04559616f, -0.00668373f, 0.04522587f, -0.03858839f, 0.10182175f, -0.02998699f, 
    -0.09931401f, -0.01297564f, -0.14873174f, 0.07743175f, -0.01405167f, -0.08951135f, 0.15617990f, 0.22743112f, 
    0.01028478f, 0.01436353f, 0.02317085f, 0.06347676f, -0.01405343f, 0.03813073f, 0.11926712f, 0.05680467f, 
    -0.01544262f, -0.11711940f, 0.04122517f, 0.11776868f, -0.03486804f, -0.02731845f, 0.17182472f, 0.02976434f, 
    -0.04303638f, -0.11032050f, 0.08134651f, -0.12033780f, -0.00008047f, 0.02122609f, -0.09679652f, 0.31717107f, 
    0.10173249f, 0.07049344f, -0.03793735f, 0.08683688f, 0.02503367f, 0.08152628f, 0.12097687f, 0.23694989f, 
    -0.08351623f, 0.01474702f, -0.02190069f, 0.04422803f, 0.07574511f, 0.07927988f, -0.13097216f, -0.03082245f, 
    -0.12805623f, 0.11299649f, -0.00093071f, -0.00121703f, 0.20676450f, 0.12140205f, 0.18956783f, -0.22249113f, 
    -0.05619529f, 0.07685108f, 0.06809031f, 0.22492664f, -0.05466622f, 0.00983876f, 0.12822881f, 0.08364312f, 
    0.32497233f, -0.02684817f, 0.07394053f, 0.00170660f, 0.11583779f, -0.04041462f, 0.02177829f, 0.15025997f, 
    0.04449604f, -0.06658119f, -0.07874987f, -0.01648060f, 0.09811050f, 0.12606344f, 0.01561731f, -0.01401993f, 
    0.06186121f, -0.01182969f, -0.01439707f, 0.01796041f, -0.00696161f, -0.00708245f, 0.03065130f, -0.01966421f, 
    0.08388076f, -0.01303781f, 0.09950841f, 0.05956853f, 0.28680965f, 0.17824338f, -0.09489203f, 0.00513679f, 
    -0.11197423f, -0.03410611f, 0.07798559f, -0.01848376f, -0.03997094f, 0.03871172f, 0.09120737f, 0.01636057f, 
    -0.02527887f, 0.03602408f, 0.02993894f, 0.00890872f, -0.12504107f, 0.15812960f, 0.09851851f, 0.04217739f, 
    -0.04048026f, -0.19050896f, -0.14862590f, -0.11356536f, -0.02180533f, -0.00731818f, -0.02054984f, -0.07961284f, 
    0.08542956f, 0.01452111f, -0.13587339f, -0.15170187f, 0.07690515f, 0.13870607f, -0.07226932f, -0.06415390f, 
    -0.10809575f, -0.04665968f, 0.08887601f, 0.00959584f, -0.05191554f, -0.04210461f, -0.07953706f, -0.09564116f, 
    -0.20921168f, -0.13861153f, 0.10208898f, -0.12167614f, -0.01208806f, -0.03938729f, -0.00770611f, 0.17618853f, 
    0.14164917f, -0.08871667f, 0.08228728f, -0.09191993f, 0.02003029f, -0.17392150f, 0.15368545f, -0.27407426f, 
    0.05932799f, -0.04715262f, 0.04264513f, 0.05434163f, -0.09468204f, -0.01249167f, 0.02717202f, -0.12255661f, 
    -0.02153774f, -0.34146267f, -0.11821857f, 0.10293186f, -0.11725193f, 0.03685278f, -0.03180271f, 0.03519095f, 
    0.10998657f, 0.00434856f, 0.01788790f, 0.07796966f, 0.06084798f, -0.27495006f, 0.15081742f, 0.28061804f, 
    -0.16501477f, 0.02903625f, 0.07050627f, 0.20133574f, -0.09301541f, 0.11121941f, 0.02845928f, 0.10887501f, 
    0.09580696f, 0.01972512f, 0.02183317f, 0.01750432f, -0.02814795f, -0.01905165f, -0.02521882f, -0.00407916f, 
    -0.03611720f, -0.08875352f, 0.16760513f, 0.00418541f, -0.02972998f, 0.13960148f, -0.00069911f, -0.00258577f, 
    0.02218830f, -0.07182629f, 0.02960571f, 0.11839265f, -0.00448145f, 0.15960863f, -0.05499929f, -0.05242002f, 
    -0.04922697f, -0.15228218f, -0.15170968f, 0.15475819f, -0.04607359f, -0.06715576f, -0.04465903f, 0.02316277f, 
    0.04888226f, 0.05825663f, -0.03923445f, 0.14515974f, 0.36232391f, 0.26070705f, 0.17958561f, 0.26294899f, 
    0.01689376f, -0.03660654f, -0.04636689f, 0.06096423f, -0.08670513f, -0.00340349f, -0.05322540f, 0.01528854f, 
    0.04760084f, 0.18770662f, -0.09941539f, 0.08315898f, -0.04038520f, 0.00435718f, 0.01831770f, -0.04942628f, 
    0.04608545f, 0.16378202f, 0.05210490f, 0.03288705f, 0.07067616f, -0.01836728f, 0.33201092f, -0.15242462f, 
    0.12069139f, -0.05784944f, -0.03107787f, -0.01615063f, 0.25677234f, 0.05905470f, -0.04049466f, -0.07606168f, 
    0.11359690f, -0.11660273f, 0.09014811f, 0.08511563f, -0.02862737f, -0.01253575f, -0.00281895f, -0.01909243f, 
    0.04331158f, 0.02517965f, 0.00027564f, -0.04119603f, 0.11070090f, 0.17163560f, 0.27175945f, 0.19468163f, 
    -0.22330619f, -0.06248828f, -0.00196736f, 0.14550731f, -0.03914864f, 0.05817568f, -0.05119896f, 0.02891434f, 
    0.06409531f, -0.13502464f, 0.00367767f, -0.22489022f, 0.03655532f, -0.03683380f, 0.01726695f, -0.18253905f, 
    -0.01870885f, 0.06169446f, 0.05307614f, -0.02342164f, 0.00664651f, -0.18524975f, 0.19639103f, -0.04244611f, 
    -0.01405335f, 0.12513199f, 0.02649725f, 0.11347002f, -0.10819918f, -0.00690116f, 0.00163613f, -0.06470369f, 
    0.11435261f, 0.10383037f, 0.15875742f, -0.03285821f, 0.00416433f, -0.03230458f, -0.06448837f, -0.01808248f, 
    0.06041749f, -0.03877823f, 0.12068309f, 0.10411968f, -0.33797801f, -0.29619935f, 0.49621379f, -0.00507233f, 
    0.24125130f, 0.01765448f, 0.02519003f, 0.11315761f, -0.10582167f, 0.00071928f, 0.13269180f, 0.06779048f, 
    0.10902342f, 0.04321226f, 0.23612291f, 0.40430534f, -0.12720022f, -0.00732509f, 0.00687666f, 0.07356179f, 
    -0.19872400f, -0.00088452f, -0.06136855f, 0.02218656f, -0.15478647f, 0.09419909f, -0.25785357f, 0.11610556f, 
    0.10543402f, 0.01127391f, 0.13466132f, -0.10962647f, -0.15181123f, 0.11683854f, -0.01299481f, -0.03664709f, 
    0.00312505f, -0.28670594f, -0.30903098f, -0.12763260f, 0.04254531f, 0.01079017f, -0.00917149f, 0.01540828f, 
    0.04398976f, 0.06096650f, -0.00491568f, -0.19719064f, 0.12895221f, 0.17904840f, 0.01504863f, 0.00965325f, 
    0.00229625f, -0.10734723f, 0.01149556f, 0.07765035f, 0.13480181f, 0.12120061f, 0.01889080f, 0.12406854f, 
    0.08697994f, 0.15855929f, 0.01152822f, 0.12339968f, 0.09042631f, 0.04354142f, 0.07111334f, 0.02157195f, 
    -0.07535478f, 0.17227902f, 0.04440564f, -0.05174180f, -0.08457498f, -0.10609645f, 0.09102404f, -0.07136077f, 
    0.01782006f, -0.05704638f, -0.02157371f, -0.06589293f, 0.10183883f, -0.03847095f, 0.05760868f, 0.16947466f, 
    0.10487878f, 0.00512674f, -0.19578445f, -0.00672256f, 0.00531619f, 0.03906585f, -0.00944022f, 0.06226083f, 
    -0.06874800f, 0.04266421f, -0.14043681f, 0.01437964f, -0.01528868f, 0.15856469f, -0.05049892f, -0.08235935f, 
    0.02016199f, -0.01027124f, 0.07763641f, -0.08744619f, 0.04105006f, -0.03231516f, 0.06825410f, 0.17019001f, 
    0.07832597f, 0.03035962f, 0.03627240f, -0.19464731f, 0.01074819f, 0.02234944f, -0.10680134f, -0.08107895f, 
    -0.05081531f, -0.31960273f, -0.07982490f, -0.17561191f, -0.18105918f, 0.22065096f, 0.01574569f, -0.09476685f, 
    0.19410911f, 0.04768118f, 0.22453783f, 0.31317812f, -0.06586485f, 0.09551519f, -0.14208151f, 0.07637596f, 
    -0.03832132f, 0.18759921f, -0.12555297f, 0.57304883f, 0.08764531f, 0.04563231f, 0.11730625f, 0.04410525f, 
    0.08138885f, -0.08227943f, -0.04886876f, -0.01129429f, -0.11664058f, -0.09028026f, -0.06819989f, -0.03700053f, 
    -0.02268196f, 0.09736769f, -0.03292853f, 0.01927900f, -0.11892941f, -0.07511738f, -0.18741485f, -0.15135504f, 
    -0.27457657f, 0.06802782f, -0.12505333f, -0.05683678f, -0.08479537f, 0.01386872f, 0.06094615f, -0.09550312f, 
    0.22419263f, 0.01554784f, -0.12566169f, -0.27578157f, -0.20443742f, 0.02130343f, -0.23629084f, -0.06242564f, 
    0.03881313f, 0.04545284f, 0.04440611f, -0.14596249f, 0.17915247f, -0.13388012f, 0.18357204f, 0.18537614f, 
    0.11519273f, -0.21692881f, 0.22992249f, 0.05628451f, -0.04098359f, -0.12061504f, 0.01382161f, 0.22245990f, 
    0.16069818f, -0.08220567f, 0.03253546f, 0.11738187f, -0.04857012f, 0.01392832f, 0.15743220f, -0.12987071f, 
    -0.04846268f, -0.04755734f, 0.08182766f, 0.09675992f, 0.05733469f, -0.08062872f, -0.23724741f, 0.00685397f, 
    -0.01873342f, 0.27550712f, -0.18777578f, 0.10099820f, 0.16829054f, -0.19400340f, -0.00819821f, 0.12246918f, 
    -0.14278457f, 0.01721920f, 0.01279164f, 0.06247128f, -0.24791227f, -0.10309938f, 0.00971177f, -0.12963973f, 
    -0.00273200f, -0.09184583f, 0.16725484f, 0.19276148f, -0.06259712f, 0.06812396f, -0.00584663f, 0.18942936f, 
    -0.11840835f, -0.20631881f, 0.07924989f, 0.13188295f, 0.15715049f, -0.00728292f, -0.06050012f, 0.00180787f, 
    -0.03568932f, 0.05637207f, 0.10482480f, -0.18595268f, -0.34586447f, 0.46815044f, 0.43939498f, -0.01577104f, 
    -0.18220799f, 0.09038725f, 0.15247142f, -0.03961080f, -0.11029453f, -0.02363063f, 0.03505019f, -0.15801229f, 
    0.09125047f, -0.22210398f, -0.27140111f, -0.04429521f, -0.00543483f, 0.10901094f, 0.18088022f, 0.06139819f, 
    0.31687641f, 0.13004181f, 0.20573334f, 0.18845201f, -0.07440704f, 0.05182656f, -0.21582338f, 0.09239678f, 
    -0.05337738f, -0.04158879f, 0.18184729f, 0.22763367f, 0.11991918f, -0.06509509f, 0.20039985f, 0.16395512f, 
    0.09902266f, 0.00873943f, 0.14009912f, 0.11171066f, -0.01775770f, 0.00978313f, -0.07605831f, -0.05503643f, 
    0.30179104f, -0.03904832f, 0.05179369f, 0.00415578f, 0.09254069f, -0.14993702f, -0.21685831f, 0.25663877f, 
    0.10170828f, 0.13464332f, -0.02066243f, 0.14058836f, 0.08921871f, -0.19229905f, 0.05344184f, -0.12522747f, 
    0.47402403f, -0.05886236f, 0.25862697f, 0.35973874f, -0.04153671f, 0.01991415f, -0.03671259f, 0.03883563f, 
    0.06694669f, -0.06747752f, -0.18790056f, -0.06234530f, 0.13463777f, -0.23768276f, -0.24853735f, 0.23283631f, 
    0.08093571f, -0.10960344f, -0.11209829f, 0.11730264f, 0.05356355f, 0.15766600f, 0.10646532f, 0.25423154f, 
    -0.15188482f, 0.00491009f, 0.21213734f, 0.13736893f, -0.01929559f, 0.04492373f, -0.10214849f, 0.20950592f, 
    -0.06578928f, 0.04322507f, -0.06743647f, -0.00917578f, 0.03317458f, 0.07472883f, 0.19653082f, 0.14620376f, 
    0.06447741f, -0.08924641f, 0.04085398f, 0.08746522f, 0.01988793f, 0.06454553f, 0.00087216f, -0.20299727f, 
    -0.30770990f, -0.15572640f, -0.02877176f, -0.11595438f, 0.02722326f, -0.21401890f, 0.28572506f, 0.17424850f, 
    0.10329301f, -0.02155682f, 0.23268045f, 0.28552407f, -0.15805314f, -0.14554292f, 0.14194050f, 0.01150913f, 
    0.11998115f, -0.06988902f, 0.16496393f, -0.13227931f, 0.00347473f, 0.11794383f, 0.02607634f, -0.30258846f, 
    -0.06697584f, 0.08852336f, -0.21346343f, -0.34114262f, 0.12225533f, 0.00684318f, 0.18726084f, 0.22108506f, 
    0.03509077f, 0.06915434f, -0.23499011f, -0.05645886f, -0.06090548f, 0.04834794f, -0.18471578f, 0.02289336f, 
    0.05612290f, -0.06076374f, 0.08761327f, -0.11911174f, -0.13635530f, 0.17635596f, -0.07557284f, -0.05795398f, 
    -0.03643439f, -0.02949662f, -0.11415453f, 0.05159717f, 0.05574566f, 0.14304520f, 0.02235475f, -0.17400439f, 
    0.04116957f, -0.02853107f, -0.14446479f, 0.13028809f, 0.03021232f, -0.04127260f, 0.10032390f, -0.07270976f, 
    -0.07656559f, 0.01883283f, -0.04329785f, -0.19451828f, 0.10636903f, 0.03714529f, -0.31464693f, 0.08296855f, 
    0.09803421f, 0.06019469f, 0.19862759f, 0.05669266f, -0.12425709f, -0.09181570f, -0.03850245f, 0.15971027f, 
    0.04944637f, -0.01606799f, -0.01337558f, 0.07463530f, -0.04654386f, 0.06265008f, 0.08152638f, 0.02606817f, 
    0.01635231f, -0.04222299f, 0.12713993f, 0.05285292f, 0.13918087f, 0.08818971f, 0.07876730f, 0.14904965f, 
    0.00226588f, -0.16962121f, -0.24493179f, 0.00754375f, 0.10653321f, 0.25154454f, -0.11309081f, 0.05068356f, 
    0.23244052f, -0.24150938f, 0.23539682f, -0.14959925f, -0.10933740f, -0.01491078f, -0.25722361f, 0.12414552f, 
    -0.05537354f, -0.12001382f, -0.06947846f, -0.11934634f, 0.06626885f, 0.06068859f, 0.07382290f, 0.08723860f, 
    0.05721268f, -0.20822221f, 0.29352325f, 0.20760129f, 0.01559162f, -0.01532338f, -0.09286469f, -0.01944754f, 
    -0.04450344f, -0.16001286f, -0.05438272f, -0.27161238f, 0.22625491f, -0.43733540f, 0.18837175f, 0.22578605f, 
    -0.20086993f, -0.01990141f, -0.09885494f, -0.04245541f, 0.18525994f, 0.03703988f, 0.10160828f, 0.03262899f, 
    -0.08519766f, -0.04757936f, -0.01072060f, -0.08963922f, 0.02347307f, 0.07631314f, 0.04429874f, 0.01169529f, 
    0.01677259f, -0.09225167f, 0.00368235f, 0.02019615f, 0.02331425f, -0.38973293f, -0.14809254f, -0.33976030f, 
    0.30140319f, 0.11788996f, -0.06622086f, 0.14924628f, 0.05324182f, 0.01876398f, 0.04944049f, -0.00084274f, 
    -0.24022475f, -0.00307862f, -0.34357706f, 0.27166253f, 0.05967109f, 0.12832567f, 0.02097483f, 0.08042689f, 
    -0.00566904f, 0.02034067f, -0.06484799f, -0.03076617f, -0.11275049f, -0.16535257f, -0.02930435f, 0.05531459f, 
    0.01985073f, 0.08766519f, 0.04607115f, 0.07426656f, -0.01901367f, -0.09582599f, 0.02532263f, -0.01544094f, 
    -0.04299440f, -0.01665616f, -0.06557491f, 0.04043214f, -0.24301542f, -0.04950779f, 0.05971753f, -0.02865655f, 
    0.10146050f, -0.01868130f, -0.01440684f, 0.00896137f, 0.09297102f, -0.02358940f, -0.13733967f, -0.03948962f, 
    0.00842504f, -0.08548786f, 0.10908806f, 0.05647551f, 0.06095603f, -0.04796611f, 0.04829405f, 0.20774983f, 
    -0.18935741f, 0.17166692f, 0.31079492f, 0.06677612f, -0.05262537f, 0.03388663f, 0.06857812f, -0.05309766f, 
    0.10157029f, -0.00180418f, 0.09344131f, 0.16574487f, -0.07832380f, 0.09924687f, 0.04700066f, -0.36946583f, 
    0.07503566f, 0.03457619f, 0.12639022f, 0.06627313f, 0.01487903f, 0.07707268f, 0.00308681f, 0.05798282f, 
    -0.28486922f, 0.06712472f, -0.13776658f, 0.06502706f, 0.02218432f, -0.02314529f, 0.03961001f, 0.18946353f, 
    -0.00037228f, -0.07816527f, 0.11204819f, 0.16849700f, -0.19806875f, 0.06904160f, -0.08513410f, -0.04826457f, 
    -0.07575567f, -0.10803559f, -0.00337449f, -0.03976445f, 0.12623870f, 0.02505475f, 0.15554231f, 0.02496878f, 
    -0.09985972f, 0.06559893f, 0.14746125f, 0.40386441f, 0.16605689f, -0.01850844f, -0.16125222f, -0.17521279f, 
    0.11879098f, -0.05219479f, 0.04769848f, -0.09492873f, 0.04985334f, 0.09599517f, -0.33215073f, -0.40335906f, 
    0.01078095f, 0.07043263f, -0.09282016f, -0.04896999f, 0.11296963f, 0.17065734f, -0.00221309f, -0.18018322f, 
    0.03827511f, 0.01107451f, -0.15419121f, 0.08131289f, 0.02433120f, 0.06042454f, 0.09706447f, 0.08175720f, 
    0.12038904f, 0.15545143f, 0.14471953f, 0.28399354f, 0.24344669f, 0.15321048f, -0.30972162f, -0.11217133f, 
    0.00264276f, -0.01153104f, 0.10904658f, -0.00591163f, -0.03122184f, -0.12950000f, 0.08899358f, 0.04263338f, 
    -0.04258298f, 0.05267583f, 0.23518656f, 0.18151683f, 0.00767512f, -0.02379176f, -0.02400650f, -0.09419336f, 
    0.25801590f, 0.00402344f, 0.09610812f, 0.02989813f, -0.27106535f, -0.12850899f, -0.48576671f, 0.12720087f, 
    0.05710632f, 0.14237915f, 0.11849602f, 0.07884540f, -0.04960927f, -0.08279608f, -0.01748591f, -0.01774807f, 
    0.16608918f, 0.21598628f, 0.38370630f, -0.20687938f, -0.04052145f, -0.01166393f, -0.13460638f, 0.02668818f, 
    0.05935807f, -0.01812622f, -0.12086204f, 0.05739693f, -0.18890694f, 0.16712040f, 0.14034761f, 0.25120866f, 
    0.02685710f, -0.02749014f, -0.07999812f, 0.18647972f, 0.08511949f, -0.00736610f, 0.07103180f, 0.28078854f, 
    0.05497880f, -0.00639195f, -0.11268040f, -0.25149953f, 0.15849167f, 0.12508774f, 0.15602501f, 0.14944540f, 
    -0.02648678f, 0.09964783f, 0.02779684f, 0.12252949f, 0.13056417f, 0.12257951f, -0.14409447f, -0.41730672f, 
    0.09728096f, -0.03983397f, -0.03743956f, -0.16352804f, 0.01732536f, -0.03936158f, 0.01921296f, -0.08076947f, 
    -0.42084357f, 0.15565285f, 0.00978477f, -0.04875261f, -0.05443286f, 0.01394514f, 0.12652622f, 0.13858365f, 
    0.08538026f, 0.07200366f, 0.14344873f, 0.01162331f, -0.04535881f, 0.18614049f, 0.27104807f, 0.06908395f, 
    0.06958599f, -0.09613805f, -0.12711206f, -0.10057326f, 0.22199602f, 0.03049723f, -0.11329092f, -0.04854272f, 
    -0.14635800f, -0.21724544f, -0.00081658f, 0.07226293f, 0.10167494f, 0.07399090f, -0.05074192f, 0.01681724f, 
    -0.04605362f, -0.03352731f, -0.17027904f, -0.08190522f, 0.33262327f, 0.31500852f, -0.24951540f, -0.06222570f, 
    -0.12419482f, -0.16806327f, 0.07650193f, -0.07387871f, 0.01614069f, 0.11414339f, -0.00972194f, -0.00427718f, 
    -0.01913104f, 0.05656400f, -0.32949778f, -0.21276963f, 0.03221725f, 0.05790310f, 0.04066915f, -0.01438981f, 
    0.00428838f, -0.02078291f, -0.16677599f, 0.13749640f, 0.14171447f, -0.19467317f, -0.16426951f, 0.20402208f, 
    -0.10668541f, -0.00200624f, 0.00756769f, -0.10962561f, 0.13195144f, -0.09234469f, 0.03288070f, 0.16268826f, 
    -0.01990511f, 0.41057578f, 0.21407308f, 0.13096267f, -0.04875119f, -0.00810465f, -0.09154603f, -0.00686075f, 
    0.01706436f, -0.00580924f, 0.01617287f, 0.12499487f, 0.17971200f, 0.21482117f, 0.00467156f, -0.19063409f, 
    0.07734627f, -0.06746279f, 0.00386309f, 0.03142091f, -0.00690553f, -0.05723386f, 0.04053374f, -0.13007745f, 
    -0.14463905f, -0.13545677f, -0.25964814f, 0.04084777f, 0.06317145f, 0.14585480f, 0.06314945f, -0.03190829f, 
    0.06896803f, -0.18901512f, 0.04083965f, -0.13123423f, -0.35437864f, 0.05372550f, 0.17654388f, 0.37275758f, 
    -0.00932709f, -0.02781946f, -0.08045156f, 0.00162786f, 0.18196753f, -0.05153767f, 0.13618039f, 0.06905644f, 
    0.13785402f, 0.02685581f, 0.08273070f, -0.08449946f, 0.15742216f, 0.01825155f, -0.21385388f, -0.07332805f, 
    0.07140942f, -0.01065542f, -0.09687660f, -0.06858804f, -0.17400117f, 0.12303354f, 0.21192832f, 0.21693207f, 
    -0.07552421f, -0.06694108f, 0.08978219f, 0.14427105f, 0.08420407f, -0.01793688f, 0.16393425f, 0.06227747f, 
    0.04435086f, 0.06651439f, -0.10936335f, 0.03324864f, 0.21692502f, 0.07901357f, -0.23776878f, 0.04210554f, 
    -0.06751598f, -0.20411260f, -0.15769614f, -0.16259888f, -0.15664846f, 0.14778925f, -0.05476177f, 0.04257717f, 
    0.06422102f, -0.06286392f, 0.18690652f, 0.25358588f, 0.03026510f, 0.03281990f, -0.07403032f, 0.01707213f, 
    0.38427040f, 0.03310487f, 0.00052405f, 0.25457567f, 0.13053791f, -0.00622067f, 0.03772921f, 0.01007843f, 
    0.07634722f, -0.04269406f, -0.03309073f, -0.09053849f, 0.08876657f, 0.05019935f, -0.01429173f, 0.02909673f, 
    0.12979662f, 0.00460792f, 0.01559567f, 0.05613171f, -0.02455196f, -0.13002780f, -0.12451367f, -0.10618518f, 
    0.05073421f, 0.01763353f, 0.08590454f, -0.01068374f, 0.19699654f, 0.18385331f, -0.07520121f, 0.05508354f, 
    0.10056771f, -0.05477473f, -0.10828170f, -0.22556043f, 0.01107731f, -0.02934433f, -0.28761867f, -0.14187840f, 
    -0.01672522f, 0.08009008f, -0.02032045f, 0.00093693f, -0.09182946f, 0.01929301f, 0.10703520f, 0.05359108f, 
    -0.12467026f, 0.05278131f, 0.24876162f, 0.11502292f, 0.02056116f, -0.12893508f, -0.04008365f, -0.01618277f, 
    0.08188749f, 0.10020514f, 0.04706620f, 0.06873427f, 0.18676108f, 0.22254033f, 0.03826514f, 0.04042967f, 
    0.01978420f, -0.06872850f, 0.06970648f, -0.05546304f, 0.13639128f, -0.05644976f, -0.10396636f, -0.05315400f, 
    0.03949683f, 0.12001465f, -0.10037600f, -0.18769635f, 0.04786088f, -0.30759019f, 0.06804580f, 0.08170144f, 
    0.03668388f, -0.00710772f, 0.05166091f, -0.22070046f, 0.01413333f, 0.04020716f, 0.11479817f, -0.17854823f, 
    0.12443916f, -0.07292072f, 0.06432999f, 0.03580697f, -0.05908636f, 0.01426583f, 0.05521717f, 0.18161845f, 
    -0.25181895f, 0.00918062f, 0.15816355f, 0.25151476f, 0.13536048f, 0.02045912f, -0.12234704f, 0.11683255f, 
    -0.15489332f, -0.07717964f, 0.04882364f, 0.01853465f, -0.14365861f, 0.03727037f, 0.13585426f, -0.01500422f, 
    -0.14604123f, 0.06952728f, 0.00841151f, -0.02255600f, 0.02521678f, 0.16372758f, 0.10155984f, 0.01634629f, 
    0.10178177f, -0.09577177f, -0.25429758f, 0.03276851f, -0.02099833f, 0.02964157f, 0.07127793f, -0.06015025f, 
    0.14547078f, 0.24466640f, 0.27426374f, 0.34090450f, 0.04949094f, 0.20434187f, -0.10481036f, -0.01430792f, 
    0.08564471f, -0.07242063f, -0.00906501f, 0.16626839f, 0.00253395f, 0.07232977f, 0.09758128f, 0.34244481f, 
    -0.25232765f, -0.12532130f, 0.12327667f, 0.33696768f, 0.08807137f, -0.01226005f, -0.06332268f, -0.08954579f, 
    0.09599567f, 0.00585780f, 0.13971008f, 0.21078974f, 0.38490716f, -0.17346244f, 0.05990989f, 0.21090010f, 
    -0.07082530f, 0.08863371f, 0.13034312f, 0.10785308f, 0.06175842f, -0.14039692f, -0.02968863f, -0.10446378f, 
    0.08346430f, 0.17902212f, 0.16626202f, 0.34695795f, 0.05794364f, -0.06166422f, -0.06444417f, 0.08157614f, 
    -0.00652971f, -0.05260568f, -0.04866838f, -0.02990301f, -0.02595780f, -0.03547670f, 0.11465436f, -0.30630699f, 
    0.08530159f, -0.07591477f, 0.00564196f, 0.05401607f, 0.00443964f, 0.11792645f, 0.09570657f, -0.01733862f, 
    0.04278179f, -0.06829978f, 0.16377842f, 0.22320312f, -0.02046663f, 0.14320941f, -0.01650675f, -0.09773392f, 
    -0.01440053f, -0.02619246f, -0.04738012f, -0.05602489f, 0.17067358f, 0.24355158f, 0.32379544f, 0.10820999f, 
    -0.06872073f, -0.04952701f, 0.07042786f, -0.03018807f, -0.04778390f, 0.03536486f, -0.08109539f, -0.15286018f, 
    0.10286137f, -0.24014889f, 0.09689879f, -0.16204144f, -0.03673128f, -0.23792456f, 0.13532811f, -0.08996211f, 
    0.06857284f, 0.03322428f, 0.18809932f, 0.11194405f, 0.00936564f, -0.01350389f, 0.37561238f, 0.03628324f, 
    0.04902669f, 0.01299578f, 0.02545318f, 0.03995029f, 0.00241363f, 0.09100410f, 0.24205740f, -0.16236758f, 
    -0.05278638f, 0.02478537f, 0.04337984f, -0.03221705f, 0.19017582f, 0.13464290f, -0.12546189f, 0.01759815f, 
    0.07308082f, -0.07016578f, -0.09147035f, -0.03431429f, -0.08683619f, 0.00775977f, 0.11042930f, -0.17596577f, 
    0.16204937f, 0.07519627f, -0.13149926f, 0.09189518f, -0.04244270f, 0.09681131f, 0.07892805f, -0.01777931f, 
    0.24919672f, -0.06584388f, -0.00173168f, -0.09610350f, -0.04694353f, 0.01668602f, 0.01665254f, -0.00483399f, 
    0.01064260f, -0.00371813f, -0.08264767f, -0.02141418f, -0.27516592f, 0.24789502f, -0.41384131f, 0.18205267f, 
    0.13432348f, -0.07350710f, 0.15172864f, -0.28156072f, -0.04620509f, 0.04380302f, -0.28507662f, 0.05247814f, 
    -0.01419556f, 0.22697873f, 0.18912406f, 0.02219599f, 0.01225341f, -0.10548075f, 0.06423233f, 0.03201225f, 
    -0.12490042f, -0.06562871f, 0.03995837f, -0.01146179f, 0.16093910f, 0.11810168f, 0.14030391f, 0.19498189f, 
    -0.09840720f, -0.10376743f, -0.04935300f, -0.01453666f, 0.14610872f, 0.19416112f, 0.12957753f, 0.18006928f, 
    0.14961778f, -0.02259309f, -0.23003070f, 0.14831161f, 0.03292735f, 0.12003028f, 0.04853067f, -0.01112851f, 
    0.03043942f, -0.04556470f, 0.07419362f, -0.14695930f, -0.45668885f, -0.11883280f, 0.04292772f, 0.11766706f, 
    0.19294493f, 0.01265933f, -0.09406734f, -0.10651503f, -0.12010890f, -0.06837609f, 0.03188165f, 0.07839711f, 
    0.22716242f, 0.07578716f, 0.09167605f, 0.20361197f, 0.07833646f, 0.03000814f, -0.10240737f, 0.10211641f, 
    0.01686539f, -0.15791295f, -0.10917146f, -0.16543554f, -0.23684327f, -0.06299677f, -0.10636009f, 0.17684986f, 
    -0.01456770f, -0.05191736f, -0.05065914f, -0.02430511f, 0.09591416f, 0.01978017f, 0.11260168f, 0.06951685f, 
    -0.05163377f, 0.00177381f, -0.05089521f, -0.01257613f, -0.06081461f, -0.01534827f, -0.05542698f, -0.00900717f, 
    -0.04664975f, 0.03084113f, -0.03401308f, -0.03472774f, 0.01366870f, -0.05735765f, 0.02511042f, 0.01893298f, 
    0.03111592f, 0.01931240f, -0.04880785f, -0.05499787f, 0.00165503f, -0.02282901f, 0.04362389f, -0.05792721f, 
    -0.03459467f, 0.04132793f, 0.00812006f, 0.02880467f, -0.05497732f, -0.00799352f, -0.01823761f, -0.02195590f, 
    0.01329565f, -0.01895189f, -0.02302428f, 0.00543494f, -0.00751172f, -0.00583976f, -0.02160141f, -0.00753493f, 
    0.01503658f, 0.03199917f, 0.01107369f, -0.00661812f, 0.01547656f, -0.01776409f, -0.02071379f, -0.03029449f, 
    -0.03412420f, -0.05317824f, 0.03890757f, -0.00732037f, -0.03091197f, -0.04262958f, -0.03273692f, -0.01589845f, 
    0.03421368f, -0.01716271f, 0.01141226f, 0.04323024f, 0.03700382f, -0.01098616f, -0.06457887f, 0.01232766f, 
    0.00015330f, -0.00798156f, 0.02508083f, 0.03477019f, -0.05582407f, -0.00868827f, -0.00056257f, -0.04967020f, 
    0.02149873f, 0.04085757f, -0.00387637f, 0.00793712f, -0.05220735f, -0.02902332f, 0.04251101f, -0.00649016f, 
    -0.01088914f, 0.00501600f, 0.03059604f, -0.05512195f, 0.00425115f, 0.00639493f, -0.01244169f, 0.02425754f, 
    0.00436759f, -0.04280433f, 0.01156784f, -0.03386137f, -0.01829137f, 0.01572648f, -0.01223648f, -0.00882384f, 
    -0.04200262f, 0.02336780f, -0.00681338f, -0.04020321f, -0.04770955f, -0.03468367f, 0.00063925f, -0.05412348f, 
    0.00398027f, 0.00520534f, -0.01218516f, -0.01631416f, -0.03545741f, -0.01544436f, -0.04387751f, 0.02411668f, 
    0.01358593f, -0.00253307f, -0.01862358f, -0.03310457f, -0.05015599f, -0.00185519f, -0.05338497f, 0.01103804f, 
    0.03916566f, -0.04716591f, -0.00299503f, -0.02315130f, 0.01836889f, -0.04252021f, -0.00771730f, 0.03628815f, 
    0.03274726f, -0.01624828f, 0.00080302f, -0.00793767f, 0.02467747f, 0.01632866f, 0.04088009f, -0.03408087f, 
    0.04215403f, -0.01525787f, 0.04050439f, 0.03498837f, 0.04459815f, 0.00282466f, 0.03625729f, -0.03915074f, 
    0.01949478f, 0.02967608f, 0.03303224f, -0.00536551f, -0.01014522f, -0.05127455f, -0.04639748f, -0.05686596f, 
    0.03911397f, -0.01609340f, -0.05559653f, -0.03675140f, -0.02948942f, 0.02113841f, -0.03998181f, -0.05572304f, 
    0.03962544f, -0.00424110f, -0.03394798f, -0.04748509f, 0.00231223f, -0.05036586f, -0.02421968f, -0.02164652f, 
    0.01009210f, -0.04156724f, 0.01092924f, -0.03498214f, 0.01569128f, -0.02669186f, -0.05726572f, 0.01174646f, 
    0.01546190f, -0.00166631f, -0.02825603f, 0.00611047f, 0.03160869f, -0.02652232f, 0.04546866f, -0.03753255f, 
    -0.03932603f, -0.03391285f, 0.01750675f, 0.03368132f, -0.03340041f, -0.06386665f, -0.02853068f, -0.04693216f, 
    -0.04629676f, 0.00810811f, -0.05012975f, 0.03490765f, -0.04669245f, 0.02237672f, -0.00831690f, -0.02917431f, 
    0.00238175f, -0.01162447f, -0.05185283f, -0.03360482f, -0.05529555f, -0.04529999f, -0.01766141f, 0.03662422f, 
    -0.03148127f, 0.00410717f, -0.04165839f, -0.05325832f, 0.04058702f, 0.00221675f, -0.05191956f, 0.02303480f, 
    0.01426575f, 0.02216589f, -0.03965154f, 0.03541664f, -0.04993685f, 0.04126601f, 0.00409412f, -0.05010512f, 
    0.04466869f, -0.05456185f, 0.03330728f, -0.00388291f, 0.04009620f, 0.02441944f, -0.05667404f, 0.01133748f, 
    0.01979055f, 0.01145219f, 0.04178595f, -0.03058437f, -0.04728312f, -0.05286834f, -0.01371304f, -0.05127158f, 
    -0.05394952f, -0.04284407f, 0.00283924f, -0.05447947f, 0.02661824f, 0.03329659f, -0.00538434f, 0.00493566f, 
    0.02301523f, -0.01349487f, -0.04943131f, -0.02842684f, 0.03850694f, 0.02099095f, -0.02452204f, 0.00459476f, 
    -0.02859231f, 0.00971430f, 0.01697684f, -0.02913806f, -0.03537625f, -0.04280119f, 0.01184320f, -0.01305677f, 
    -0.02710043f, -0.00118861f, -0.05605658f, -0.05809077f, -0.03979955f, -0.02362356f, -0.03692441f, 0.00330636f, 
    0.03568896f, 0.03680864f, -0.01868552f, -0.03004865f, 0.00070973f, -0.01515370f, -0.05433534f, 0.01625077f, 
    0.02796502f, 0.02554861f, -0.05666286f, -0.04876605f, -0.01436533f, -0.03402660f, 0.02268584f, 0.01490979f, 
    -0.03030279f, 0.01041133f, -0.00051203f, 0.02246244f, -0.01019572f, -0.02171892f, 0.00239055f, 0.04612084f, 
    -0.03454294f, 0.02551687f, -0.02649753f, -0.01482546f, 0.03857604f, -0.05801880f, -0.02017746f, -0.00445947f, 
    -0.04924849f, -0.03557707f, -0.02101232f, -0.04033503f, 0.00617409f, -0.05789586f, 0.03698079f, 0.03004843f, 
    0.00215448f, -0.05082027f, -0.05295060f, -0.04734185f, 0.02928187f, -0.03691176f, 0.02033625f, -0.03742404f, 
    -0.01542773f, -0.00441395f, -0.01693757f, -0.03113347f, 0.03673272f, 0.03459173f, -0.00423853f, 0.01167754f, 
    0.00042163f, -0.03015095f, -0.04688982f, -0.00236459f, -0.03355796f, 0.02890773f, 0.02705085f, -0.03109409f, 
    -0.03540443f, -0.02892773f, 0.02455746f, -0.04472423f, 0.03079348f, 0.01491290f, 0.03877777f, -0.04130781f, 
    0.04569011f, -0.04158520f, 0.03725829f, 0.00800280f, 0.00542112f, -0.01652480f, 0.00327169f, -0.00504599f, 
    -0.03738618f, 0.01870291f, -0.02060948f, 0.04937955f, -0.02393559f, 0.03509020f, -0.04468964f, 0.01928612f, 
    0.00354184f, -0.00336397f, -0.01475690f, -0.04314126f, -0.03650013f, -0.04464759f, -0.02443731f, 0.03806919f, 
    0.00208569f, -0.06132616f, -0.02715959f, 0.03620747f, -0.02751060f, 0.00980803f, -0.04677887f, 0.03764118f, 
    0.03609838f, 0.01807577f, -0.01550574f, 0.00187621f, -0.01706945f, -0.05354546f, -0.02553741f, 0.04282084f, 
    0.03350563f, 0.11454905f, 0.02593660f, 0.10303833f, 0.04104256f, -0.04519487f, 0.01416853f, 0.19212142f, 
    -0.11156620f, -0.17090176f, -0.02560476f, -0.00085047f, -0.32729274f, 0.25110459f, -0.13346986f, 0.24497996f, 
    0.12380196f, 0.26647058f, -0.02022002f, 0.16473445f, 0.08690047f, 0.02706902f, 0.04583934f, -0.00471320f, 
    0.01343177f, -0.39817598f, -0.10164075f, 0.38672262f, -0.08535154f, 0.20966640f, 0.03997382f, -0.10156381f, 
    0.02405530f, -0.01570183f, -0.11128085f, -0.03837336f, -0.26168692f, -0.11447066f, -0.01581068f, 0.12594205f, 
    0.10595604f, 0.12257777f, 0.07598394f, -0.07352399f, 0.03683304f, 0.04384235f, -0.04586733f, -0.09702888f, 
    0.04902606f, 0.12293703f, 0.06009681f, 0.04120976f, -0.10131490f, -0.07455882f, 0.04329703f, -0.04875565f, 
    0.15560418f, 0.05007917f, -0.18220726f, -0.21566328f, 0.07022723f, 0.12081957f, -0.20037307f, -0.00410519f, 
    0.10802513f, -0.06697030f, 0.08817859f, 0.20381136f, 0.16169870f, 0.02196061f, 0.05101177f, 0.21054356f, 
    -0.08433448f, 0.28692949f, 0.21876815f, 0.18373120f, -0.08217502f, -0.12121615f, 0.11833511f, 0.20313260f, 
    -0.00347223f, 0.00911428f, -0.00556816f, 0.00554459f, -0.16024898f, 0.08611821f, 0.01408647f, 0.10232048f, 
    -0.01869686f, 0.02932280f, 0.01692638f, 0.01324922f, -0.01104893f, 0.04169643f, -0.00022024f, -0.08858154f, 
    0.27206892f, -0.03784939f, 0.14526010f, 0.29680550f, 0.06031807f, -0.00948036f, 0.04978427f, -0.01092418f, 
    -0.04979714f, -0.10856798f, 0.14903566f, 0.14129381f, -0.04789557f, 0.03910192f, 0.21395755f, 0.38634324f, 
    -0.07280619f, -0.02778059f, 0.01609991f, -0.00281202f, 0.16898006f, 0.04784004f, 0.02281848f, 0.12185699f, 
    -0.03546649f, 0.21084082f, 0.15213118f, -0.15142764f, -0.21133851f, -0.12164232f, -0.11761186f, 0.03626143f, 
    0.06682591f, 0.01777945f, -0.09010081f, 0.01295615f, -0.06615685f, 0.24728477f, 0.18325977f, 0.04187168f, 
    0.13551301f, -0.05743337f, -0.06389619f, 0.00109024f, -0.04014939f, -0.16593061f, 0.05160023f, 0.07356151f, 
    0.03972511f, 0.01197158f, -0.52787316f, -0.13160653f, 0.19043642f, -0.18759882f, -0.03880262f, 0.00999869f, 
    0.25638795f, 0.18107480f, 0.05726363f, 0.07963420f, -0.16478610f, 0.16492279f, -0.19618775f, -0.14817540f, 
    -0.04468479f, 0.04555145f, 0.00953761f, 0.01208929f, 0.11795855f, -0.03087567f, 0.10318110f, 0.15579942f, 
    -0.17558125f, 0.22290500f, 0.27418745f, -0.19091135f, 0.06014369f, -0.01764930f, -0.00133916f, 0.00042901f, 
    0.15710665f, 0.13082339f, -0.08200090f, -0.03104298f, -0.14220616f, -0.06888086f, 0.11728827f, -0.09496606f, 
    -0.09775025f, -0.15099479f, 0.07193542f, 0.01499682f, 0.01207149f, -0.14699510f, 0.01689987f, -0.03471595f, 
    0.00728106f, 0.06386862f, 0.07253736f, 0.05663180f, 0.02512757f, 0.14180106f, -0.11616872f, 0.12171182f, 
    -0.05098918f, 0.10348023f, -0.11258394f, 0.06057202f, 0.01820116f, -0.01251500f, 0.02902631f, -0.18668886f, 
    -0.29903114f, -0.00511948f, -0.08906949f, 0.15306516f, -0.07374933f, 0.13030243f, 0.19353619f, 0.20321129f, 
    -0.30758843f, -0.01854835f, -0.02988217f, 0.09378953f, 0.06463177f, 0.20927693f, 0.04931399f, 0.03553560f, 
    -0.12437807f, 0.09247258f, -0.10121478f, 0.02680914f, -0.00941847f, -0.16320869f, 0.14497192f, 0.06652666f, 
    0.13820252f, 0.03497742f, -0.07958711f, -0.12892599f, 0.03598072f, -0.06831770f, 0.02331213f, 0.06063298f, 
    -0.14341201f, -0.23608220f, -0.08437120f, 0.15663692f, 0.05931794f, -0.05952007f, 0.12609892f, 0.21725291f, 
    0.00851774f, 0.07597532f, 0.06502116f, -0.07391295f, 0.07648835f, 0.28865829f, -0.08833961f, -0.09472086f, 
    -0.15895426f, 0.02546757f, 0.14022733f, -0.06635194f, 0.08928026f, -0.01264582f, 0.09036882f, -0.08333312f, 
    -0.53003311f, -0.53060412f, -0.37727439f, 0.11319904f, 0.21320575f, -0.15923263f, 0.10581286f, 0.06103620f, 
    0.00042238f, -0.06210135f, -0.24675646f, 0.02188367f, 0.26468980f, 0.35009724f, -0.44313726f, 0.05638923f, 
    -0.19094712f, 0.08345246f, 0.00461298f, 0.06402031f, 0.05178995f, -0.01925217f, 0.09253503f, 0.01310430f, 
    0.15643683f, -0.04316005f, -0.35547331f, 0.06261832f, 0.11323012f, -0.12842192f, -0.17990460f, -0.17586266f, 
    0.14162682f, -0.03763906f, -0.16575390f, 0.06578889f, -0.16878270f, 0.17253236f, -0.24176516f, 0.25747091f, 
    0.10473787f, 0.17041028f, 0.05450325f, 0.12109938f, 0.14438485f, -0.02315774f, -0.09004810f, 0.06625386f, 
    0.06398252f, 0.47980744f, 0.38080263f, 0.23990995f, -0.24355675f, -0.12649180f, -0.06973171f, 0.07369738f, 
    0.03595446f, -0.02619351f, 0.01163702f, 0.08630791f, -0.10911234f, 0.06989609f, -0.00655721f, 0.15051310f, 
    0.07707558f, 0.09108114f, -0.00281977f, -0.05997092f, 0.11692103f, 0.03459266f, 0.02717866f, 0.02866220f, 
    -0.31020886f, -0.21771562f, -0.06740217f, -0.04181676f, -0.11511326f, -0.04925727f, -0.17209092f, -0.34529746f, 
    0.09780320f, -0.15279388f, 0.08159199f, 0.16134825f, 0.00008696f, 0.04381335f, 0.04854211f, -0.13421015f, 
    -0.16672248f, -0.06877132f, 0.04772913f, 0.07934189f, 0.10286958f, 0.07999864f, -0.03968873f, 0.05805080f, 
    0.04181874f, -0.03452382f, 0.11103076f, 0.05681504f, 0.02552968f, 0.12955935f, -0.02654145f, -0.04356193f, 
    -0.01529817f, -0.13656433f, -0.02278575f, -0.12226953f, -0.10228755f, -0.23195784f, -0.32446501f, 0.01198213f, 
    -0.32486480f, -0.00552389f, 0.08685447f, 0.22234286f, 0.00626607f, -0.00794278f, 0.01560293f, 0.01095580f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04206391f, 0.10100821f, 0.14553827f, 0.02122871f, -0.00541502f, 0.08410093f, 0.19061202f, 0.03027841f, 
    0.11212088f, -0.04934489f, 0.01544607f, -0.04018916f, -0.04607244f, -0.04555012f, -0.06296989f, 0.20312139f, 
    0.12103620f, -0.04264035f, -0.04920650f, 0.07164923f, 0.00458589f, 0.00438710f, 0.09592142f, 0.00943607f, 
    -0.02073340f, 0.12528281f, -0.01204963f, 0.01282266f, 0.06720915f, 0.06149296f, 0.03675484f, 0.10178623f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09275755f, -0.59336108f, 0.19816427f, -0.06066098f, -0.06824379f, -0.10633050f, -0.51805460f, 0.17027038f, 
    0.08854164f, 0.15189673f, -0.35320243f, 0.16145447f, -0.17538866f, 0.36723286f, 0.12149137f, -0.18256043f, 
    -0.24185817f, 0.19050385f, -0.14245138f, -0.29408285f, -0.04114635f, 0.12976781f, 0.33258298f, 0.09358373f, 
    0.29388255f, -0.02017788f, -0.03206646f, -0.31932825f, 0.12429609f, -0.04172469f, -0.03490598f, -0.28275323f, 
    0.06865785f, 0.11850456f, 0.33536604f, -0.21656582f, 0.10995821f, -0.30770779f, 0.21331719f, 0.12616292f, 
    0.12376167f, 0.01173705f, -0.14142999f, 0.25265139f, 0.11579199f, -0.19394420f, 0.18047090f, 0.16138636f, 
    0.33072561f, -0.29097304f, -0.16062988f, 0.11595641f, -0.08760868f, 0.00821661f, 0.17923056f, 0.00363093f, 
    0.21852310f, 0.24188390f, 0.11036960f, -0.84428650f, -0.19473438f, -0.18089415f, 0.07109962f, -0.50484121f, 
    -0.09393167f, 0.10833120f, -0.20297317f, 0.18287006f, 0.04084738f, -0.14511485f, 0.27808523f, -0.18050197f, 
    -0.16371976f, 0.12525436f, 0.10116828f, 0.20690992f, 0.06808411f, 0.03267481f, 0.08495376f, -0.01733954f, 
    -0.29082876f, 0.01638349f, -0.09385875f, -0.13823830f, -0.03244105f, 0.11447760f, 0.24797745f, -0.11721612f, 
    -0.70504576f, 0.36670753f, -0.72080749f, 0.01115067f, 0.07990390f, -0.09956945f, 0.14063303f, 0.35286635f, 
    0.10420930f, 0.06401843f, -0.73517871f, 0.18969823f, -0.12702492f, 0.33826497f, -0.40663046f, -0.30062923f, 
    0.09744894f, 0.12293585f, 0.24395861f, 0.19959636f, 0.16945054f, -0.09737854f, -0.12107862f, -0.41927832f, 
    -0.80768430f, 0.23843981f, -0.03515614f, 0.21774288f, 0.16489363f, -0.04916038f, 0.00521914f, -0.05207080f, 
    0.17976043f, -0.33670345f, -0.18581691f, -0.02170610f, -0.28711033f, 0.17043275f, 0.06763062f, 0.12788536f, 
    0.05570868f, 0.28511682f, -0.19429937f, -0.35997549f, -0.05416870f, -0.15611599f, -0.38336891f, 0.31044969f, 
    0.05014618f, 0.03774081f, -0.00040456f, 0.17585641f, 0.10436147f, -0.10216392f, 0.29064912f, -0.51721507f, 
    0.01189385f, -0.00487605f, 0.02371712f, -0.30291757f, -0.10001031f, -0.09514620f, 0.01313905f, 0.03778951f, 
    -0.13158214f, 0.02610207f, 0.12714244f, 0.20970283f, -0.01191858f, 0.30679035f, -0.13890660f, 0.29075968f, 
    0.07044311f, 0.01319855f, -0.10893908f, -0.06450036f, -0.05074475f, 0.21049166f, 0.03049532f, 0.31043428f, 
    0.31632343f, -0.11788701f, -0.05753353f, -0.45363972f, 0.01780754f, 0.26281583f, -0.22653514f, 0.13549919f, 
    0.19435592f, -0.64812219f, -0.00680051f, -0.18913768f, -0.14332703f, -0.02135541f, 0.00097423f, -0.06398033f, 
    0.09926028f, -0.54397601f, -0.17502049f, 0.26719287f, 0.27777624f, -0.02457742f, -0.08234848f, 0.13007565f, 
    -0.12190210f, 0.34029600f, 0.12180740f, -0.05527949f, -0.06596591f, 0.14840828f, -0.14451343f, 0.02400942f, 
    -0.78231061f, 0.14213338f, 0.17635980f, -0.91187489f, -0.09725619f, -0.58028346f, -0.52123898f, 0.12844062f, 
    0.21691787f, 0.33745661f, -0.10942252f, -0.16317435f, -0.14035156f, -0.01454802f, -0.33956385f, -0.10937645f, 
    -0.65035552f, 0.19062574f, -0.48462337f, -0.12401129f, 0.25152168f, -0.07877807f, 0.11331191f, 0.49545643f, 
    -0.16729854f, -0.15255523f, -0.34611425f, -0.31737626f, 0.15332404f, -0.23586145f, 0.18392582f, 0.24237251f, 
    -0.08383864f, 0.16605300f, 0.33652541f, 0.46316475f, -0.04784286f, 0.28568235f, -0.62321579f, 0.01328555f, 
    0.03240815f, 0.23636530f, -0.08419681f, -0.03849580f, -0.09524230f, -0.04887884f, -0.17135143f, -0.16434544f, 
    -0.29450813f, -0.22065549f, -0.11825826f, 0.53074419f, -0.56493384f, -0.60639143f, 0.15760340f, -0.40061364f, 
    0.16416936f, -0.47337863f, -0.07015160f, 0.36979434f, 0.11608343f, -0.28038865f, 0.09272981f, -0.19959544f, 
    0.51736909f, 0.01393728f, 0.24246956f, -0.43318927f, -0.03235322f, -0.51626337f, -0.34024158f, -0.02620706f, 
    -0.27658865f, 0.05018790f, -0.11391207f, 0.18703690f, -0.13732235f, -0.10829040f, 0.28258210f, -0.06010609f, 
    -0.72489744f, -0.20789491f, 0.30037048f, -0.15004689f, -0.11666179f, -0.59971148f, -0.09996133f, -0.46143949f, 
    0.06264003f, -0.55712348f, 0.05905771f, -0.49288070f, -0.11436748f, 0.24028732f, 0.31467053f, -0.05832845f, 
    -0.35610896f, -0.16235159f, 0.06534054f, -0.14312311f, -0.15311284f, -0.36293742f, 0.31534576f, -0.25778309f, 
    0.13317695f, 0.20889878f, -0.03499950f, -0.36416489f, -0.16190447f, -0.12638654f, -0.39783472f, -0.12752573f, 
    0.12782581f, 0.14018783f, 0.00395347f, 0.42388856f, 0.40942138f, 0.29391545f, -0.00985593f, -0.33132407f, 
    -0.04395760f, 0.32197422f, 0.18443373f, 0.21296787f, 0.11684182f, 0.31683803f, -0.24717380f, -0.80601341f, 
    -0.18677525f, -0.14465310f, 0.21361923f, -0.39183897f, -0.00409001f, -0.65074921f, 0.05310540f, -0.28552318f, 
    0.29967037f, -0.73338807f, 0.12113807f, 0.11308552f, 0.16140394f, -0.09816949f, 0.15536867f, 0.03236871f, 
    0.25123608f, -0.51814014f, 0.22814819f, -0.31640208f, -0.02182414f, -0.12867750f, 0.16807157f, 0.38972822f, 
    -0.01514505f, 0.50964451f, 0.20070097f, 0.26904961f, 0.07334578f, -0.66247815f, -0.31558666f, -0.35959533f, 
    -0.14089461f, 0.05515326f, 0.10962160f, -0.11408262f, -0.00412001f, 0.12420566f, -0.51606268f, 0.09484926f, 
    -0.01174996f, 0.08471680f, 0.16464983f, 0.10873519f, 0.01080607f, 0.14963450f, -0.49237218f, 0.16749786f, 
    -0.02093282f, 0.06965934f, 0.31754166f, 0.14280254f, -0.23796175f, 0.43404660f, 0.15555535f, -0.57916462f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.32955331f, -0.02252180f, 0.16898128f, -0.04371619f, -0.10323397f, -0.06430508f, 0.08273537f, -0.05557664f, 
    0.12896836f, -0.03061173f, 0.13146389f, 0.12377158f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
