#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.38412520f, 0.12136438f, -0.10592484f, -0.06060343f, -0.42389947f, -0.45437789f, -0.46298796f, -0.03570427f, 
    0.37196079f, 0.01991560f, 0.00878965f, 0.07538793f, 0.27481249f, 0.39860323f, -0.11230145f, -0.17424513f, 
    -0.00351521f, -0.05117343f, -0.20525943f, -0.38838291f, -0.52108747f, -0.33121735f, -0.26396960f, -0.55941910f, 
    -0.47975200f, -0.73391175f, 0.01332561f, -0.48730627f, -0.20893098f, -0.55628920f, 0.28736150f, -0.12103540f, 
    0.09736581f, 0.25723246f, 0.18705066f, -0.08455145f, 0.07098915f, -0.07415629f, 0.18688592f, 0.12807581f, 
    0.21070850f, -0.14989884f, 0.18954310f, -0.10142418f, 0.09057367f, -0.15261923f, 0.06331012f, -0.21847440f, 
    -0.02323869f, -0.30610198f, -1.02904904f, -0.63785356f, 0.07736327f, 0.12930274f, -0.64113152f, 0.18345866f, 
    -0.30604503f, -0.63644415f, 0.04200466f, 0.48531309f, 0.13383983f, 0.13206404f, -0.33132818f, -0.47188261f, 
    -0.45597354f, 0.23357455f, 0.37477168f, 0.08982870f, 0.14035359f, 0.25824353f, -0.15662774f, -0.38340235f, 
    -0.24827974f, 0.02220558f, -0.12908445f, -0.54990405f, -0.23085718f, -0.07019193f, -0.08384535f, -0.29712716f, 
    -0.18832050f, -0.55222148f, -0.61140412f, -0.62408835f, -0.68448699f, 0.09069877f, -0.01121893f, 0.35782650f, 
    -0.57326496f, -0.21147473f, 0.04634349f, -0.06687165f, 0.15717310f, 0.29229414f, 0.26110280f, -0.04431886f, 
    0.15117390f, -0.12253862f, -0.23015390f, 0.25043043f, -1.20910919f, -0.32384202f, -0.20772982f, 0.57484388f, 
    0.49554136f, -0.30961874f, 0.43501306f, 0.19630460f, 0.18043925f, 0.22329718f, 0.15554486f, 0.10329540f, 
    0.20650746f, -0.01914079f, -0.37875140f, -0.15218391f, -0.14877094f, 0.12920299f, -0.08311888f, 0.25225484f, 
    -0.03894554f, 0.02709286f, -0.02922086f, 0.22248322f, -0.20672812f, -0.47984973f, -0.45195004f, -0.51789463f, 
    0.02163679f, 0.63649976f, 0.33670300f, -0.07621086f, -0.11284464f, 0.26265481f, 0.44358972f, -0.04205569f, 
    -0.19398420f, -0.41886574f, 0.00874653f, 0.30018991f, 0.14415221f, -0.08347178f, -0.32744610f, 0.01233655f, 
    -0.29654676f, -0.26893482f, -0.00154538f, -0.31750527f, -0.46834868f, -0.57934731f, 0.56490791f, 0.23641379f, 
    0.17421953f, 0.02238825f, -0.32680917f, 0.18598378f, 0.14154638f, -0.14276032f, -0.05040072f, -0.16905913f, 
    0.24300583f, -0.15605547f, 0.05886939f, -0.11294191f, 0.03238207f, -0.37992319f, 0.04195840f, 0.22429341f, 
    -0.15987884f, 0.12633146f, 0.20926534f, 0.02203796f, -0.29621625f, 0.09420856f, -0.23225746f, 0.32567906f, 
    0.16091198f, 0.20220645f, 0.12698433f, 0.15477359f, -0.40030497f, 0.02881596f, 0.36125451f, 0.05965573f, 
    0.08670821f, -0.22594406f, 0.31006235f, 0.26241538f, 0.02012822f, -0.40287820f, 0.01174968f, -0.21000943f, 
    -0.31559798f, -0.26299840f, 0.09630299f, -0.13022934f, 0.46557212f, 0.20682757f, -0.32033563f, -0.25043234f, 
    0.41542080f, 0.62720627f, 0.48134655f, -0.14421281f, 0.44618604f, -0.55675411f, -0.42165050f, -0.02121257f, 
    -0.18855874f, -0.10735733f, -0.17699771f, 0.01375572f, -0.20183134f, 0.02717733f, -0.05974825f, 0.14966334f, 
    0.27381003f, -0.18761985f, 0.01639065f, 0.12208987f, -0.32828617f, 0.19114962f, -0.01063148f, 0.13243853f, 
    -0.31990644f, 0.14915502f, -0.66736263f, -0.21482924f, 0.09918361f, -0.14507553f, -0.21144424f, -0.13834924f, 
    0.41286856f, 0.41500917f, -0.09485248f, 0.16588725f, -0.02582766f, 0.26425633f, -0.16477901f, 0.08890075f, 
    -0.02359587f, -0.19722308f, -0.02920474f, -0.15437429f, 0.17807589f, 0.35238308f, -0.35069883f, -0.13316958f, 
    0.16166855f, -0.13990413f, -0.77625006f, 0.17983477f, -0.44848788f, -0.25325641f, 0.17478353f, 0.18554495f, 
    0.17922227f, 0.17647998f, -0.24018395f, 0.13733757f, 0.35071346f, 0.48919603f, -0.13352492f, -0.22174823f, 
    0.02388246f, -0.50566137f, -0.23617366f, -0.21252906f, -0.16506360f, 0.33993569f, 0.28030008f, 0.38232824f, 
    0.22738102f, -0.14096841f, 0.09540786f, 0.35810053f, 0.27138308f, -0.06961355f, 0.22384462f, -0.09965302f, 
    0.04986132f, 0.19742045f, -0.01897385f, 0.30152649f, 0.31529728f, -0.06058907f, -0.26030666f, -0.32335445f, 
    -0.29582441f, -0.23585267f, 0.21541654f, -0.02853584f, -0.17023811f, 0.10386651f, -0.32361439f, -0.29137355f, 
    0.01739399f, 0.29762298f, 0.08621615f, -0.31023157f, -0.10983510f, -0.77816224f, 0.01803755f, 0.86418021f, 
    0.62894410f, -0.04243352f, -0.11231253f, -0.54071933f, -0.52512318f, -0.14585207f, 0.33431855f, 0.26734793f, 
    0.12730916f, 0.13217254f, 0.01405625f, 0.08599240f, -0.03788475f, -0.25727215f, 0.07889420f, -0.22185026f, 
    0.05227637f, 0.19636039f, -0.06915807f, 0.02067542f, -0.32264134f, 0.39895901f, -0.63982284f, -0.48035586f, 
    -0.12916592f, 0.54214299f, -0.00124501f, -0.16683492f, -0.01041877f, 0.17512791f, -0.06263424f, -0.29192108f, 
    0.10255627f, 0.05549235f, -0.14324416f, -0.00958397f, 0.05393897f, 0.03921683f, -0.30192265f, -0.02455138f, 
    -0.24444605f, 0.24548751f, 0.26568088f, 0.21287188f, 0.07718390f, 0.28468370f, 0.08086061f, -0.52009839f, 
    -0.01345343f, -0.02896849f, 0.34653622f, 0.30329695f, -0.09472243f, -0.53703463f, -0.53135109f, 0.73836738f, 
    0.00086167f, 0.18240054f, -0.23301183f, 0.24902068f, -0.25282782f, 0.21230233f, -0.31303367f, 0.16080371f, 
    0.20861928f, -0.44643003f, -0.15522374f, 0.03266777f, 0.04321384f, 0.18911700f, 0.19340961f, -0.60756469f, 
    -0.44196406f, -0.45077765f, -0.44077849f, -0.46452218f, -0.94848907f, -0.76084518f, -0.47577599f, -0.39782664f, 
    -0.66464734f, 0.31991196f, -0.02969581f, 0.33484176f, 0.36192536f, 0.25704721f, 0.09488001f, -0.33564919f, 
    0.14413694f, -0.12376890f, -0.29438344f, 0.04165910f, 0.44045421f, 0.00372669f, 0.02282294f, 0.59756225f, 
    0.47702542f, 0.07237938f, -0.79512972f, -0.91238439f, -0.47316858f, 0.11941756f, -0.03231411f, 0.21260574f, 
    0.12610336f, -0.06750760f, 0.18689364f, 0.17523223f, 0.32885125f, -0.12362956f, -0.03642701f, -0.39915499f, 
    -0.13154666f, -0.26055136f, -0.05756951f, -0.04103849f, 0.02840754f, -0.12174927f, -0.19861564f, 0.48043454f, 
    0.47847059f, 0.29281694f, -0.09875791f, -0.01180803f, -0.08543021f, -0.17034492f, 0.12752564f, 0.35494739f, 
    0.55804133f, 0.24802360f, 0.17696361f, -0.45532748f, 0.25333929f, -0.20707479f, -0.07476779f, -0.09632906f, 
    0.05942380f, -0.37189120f, 0.22005993f, -0.42483473f, -0.28265980f, 0.24420342f, -0.22583430f, -0.40531877f, 
    0.19583564f, 0.32907996f, 0.59113693f, 0.53812766f, -0.16534962f, 0.14130203f, -0.51792616f, -0.50792277f, 
    -0.29034188f, -0.34969282f, -0.21546403f, -0.26593065f, 0.17207302f, -0.14373884f, 0.13189816f, 0.00354226f, 
    0.30008900f, -0.08855775f, 0.17113112f, 0.19221243f, 0.17903069f, -0.04368007f, 0.09157176f, -0.01755650f, 
    0.11987445f, -0.28702676f, 0.02947885f, -0.02866570f, -0.75441372f, -0.63366425f, 0.40861386f, 0.78471124f, 
    -0.51185751f, 0.12993951f, -0.32975450f, 0.10826264f, -0.37865865f, -0.30901346f, -0.37156880f, -0.17133869f, 
    -0.29916036f, 0.06309319f, 0.05195118f, 0.16518553f, -0.18126300f, 0.27905124f, 0.16714363f, 0.20916913f, 
    0.02936606f, 0.04726902f, -0.11887086f, 0.20974539f, 0.76311082f, -0.65150392f, -0.15273766f, -0.40252152f, 
    -0.57039177f, -0.09452663f, 0.44490775f, -0.08041541f, -0.02881003f, -0.25044358f, 0.81711531f, -0.70591247f, 
    -0.22696286f, 0.05976268f, -0.06664144f, -0.27251622f, -0.39998040f, -0.12173160f, 0.38595372f, 0.10679182f, 
    -0.46149313f, -0.03832858f, -0.11933503f, -0.15721825f, 0.32386449f, -0.74873590f, -0.42921802f, -0.06505930f, 
    -0.53346384f, -0.52719873f, -0.46618322f, -0.17551237f, -0.02658996f, -0.25567710f, -0.44770953f, -0.27985230f, 
    -0.27349192f, -0.30856991f, -0.09817846f, -0.25255191f, 0.03332864f, -0.17929634f, -0.22654781f, -0.27924478f, 
    -0.25533456f, 0.07917703f, 0.25424945f, -0.06010468f, 0.16241436f, 0.20033586f, -0.82627189f, -0.69209290f, 
    0.39567679f, 0.43143639f, 0.46303561f, 0.69423687f, 0.71603513f, 0.00377630f, -0.43824714f, -0.52754486f, 
    -0.29823554f, 0.26907334f, -0.23724538f, 0.34858063f, -0.36197233f, 0.06970917f, -0.04883128f, -0.22740410f, 
    -0.23089513f, -0.13211843f, -0.00497155f, -0.00115283f, 0.03993050f, 0.24787755f, 0.19894488f, -0.43528923f, 
    -0.08421697f, -0.42490786f, -0.64437050f, -0.71496290f, 0.41104740f, 0.38949487f, -0.09979568f, -0.18487118f, 
    0.64181685f, 0.11175203f, 0.39354026f, 0.24690565f, 0.05536764f, 0.18343724f, -0.06329710f, 0.12595809f, 
    0.06886400f, -0.21458122f, -0.06069687f, 0.00424608f, -0.04297477f, 0.07645225f, -0.04451308f, -0.08425131f, 
    -0.02083813f, -0.60884464f, -0.77873689f, -0.47975251f, -0.57798648f, -0.06010983f, -0.19773021f, 0.20632181f, 
    0.27037629f, 0.04742993f, 0.21963093f, 0.12482113f, 0.13760002f, -0.27382120f, 0.13413404f, -0.23933360f, 
    -0.01198548f, -0.02821460f, -0.09526210f, -0.39541137f, -0.33072817f, -0.18904138f, -0.06303281f, -0.22371203f, 
    -0.46835887f, -0.04090935f, 0.38134646f, 0.45255148f, 0.10250250f, 0.01013471f, -0.32431346f, -0.17957601f, 
    0.08804224f, 0.05034747f, -0.10384678f, -0.15781912f, -0.05309312f, 0.10610250f, 0.20353468f, -0.21863502f, 
    0.24726914f, -0.14783920f, 0.24036366f, 0.10184387f, -0.16490452f, 0.33229804f, -0.10166072f, -0.22169606f, 
    -0.33018890f, -0.44161639f, 0.55177826f, 0.77131957f, -0.74946028f, -0.22881830f, -0.26962665f, -0.33286205f, 
    0.24230644f, 0.11366982f, 0.36836976f, -0.24521673f, -0.22963956f, -0.15458484f, -0.10223196f, 0.35578594f, 
    -0.18076657f, 0.49089903f, -0.16032408f, -0.35939115f, 0.35757026f, -0.31206286f, -0.23663729f, 0.07509864f, 
    -0.09522553f, -0.23225492f, -0.23020843f, -0.62444639f, -0.09255195f, 0.23918431f, 0.28293329f, -0.03371044f, 
    0.54335570f, 0.11806244f, -0.31175551f, -0.12353192f, 0.12090015f, -0.49537024f, 0.27156553f, -0.33572564f, 
    0.31210691f, 0.04804889f, -0.32704440f, 0.02255718f, -0.03845293f, 0.04524498f, 0.32806695f, -0.22593993f, 
    0.03258148f, 0.09545657f, 0.33727923f, -0.04366485f, -0.91396028f, -0.03690767f, 0.61773592f, -0.29116100f, 
    -0.43060216f, 0.10861285f, 0.24117410f, 0.08031722f, 0.21402979f, 0.34171733f, -0.11301986f, -0.20156156f, 
    0.40177172f, -0.28786740f, 0.04879812f, -0.02067652f, -0.26645067f, -0.06493720f, -0.26026970f, 0.13965170f, 
    0.04776407f, 0.23704737f, 0.19438721f, 0.11992899f, -0.05333041f, 0.26375601f, -0.42937201f, -0.03889208f, 
    -0.57468921f, -0.52710283f, 0.42106026f, 0.33333579f, 0.06317547f, 0.15589894f, 0.31893936f, 0.22049397f, 
    0.28499004f, -0.16053726f, 0.09762693f, 0.23147322f, -0.22440997f, -0.00867941f, -0.20831634f, -0.20385087f, 
    0.12285174f, -0.11637526f, 0.00475426f, -0.16229892f, 0.24700071f, -0.03614214f, -0.42231807f, 0.67522794f, 
    0.34534150f, 0.72552443f, 0.14884394f, -0.32877707f, -0.54060251f, -0.38720223f, -0.37621820f, -0.07440026f, 
    -0.17493834f, 0.19772474f, 0.12089455f, 0.02470708f, 0.16692080f, 0.09505958f, -0.05969748f, -0.06963541f, 
    0.11380041f, 0.16061117f, 0.01106745f, -0.06466009f, -0.00767239f, 0.00768255f, -0.07359095f, 0.23781928f, 
    0.49633414f, 0.12614422f, -0.31737188f, 0.15518543f, -0.37961972f, -0.10637759f, 0.32211852f, -0.27540410f, 
    -0.14683414f, -0.39232817f, 0.54592919f, 0.07308380f, -0.19786638f, -0.06339370f, 0.29254377f, 0.23347391f, 
    -0.05694697f, -0.05482296f, -0.29112163f, -0.01674152f, -0.18589543f, -0.10816116f, -0.00181483f, 0.38053757f, 
    0.42553911f, 0.05476692f, -0.39595699f, -0.06705292f, 0.08622551f, -0.01291915f, 0.19582815f, -0.23600730f, 
    -0.14940803f, 0.17201109f, 0.07801430f, 0.65963107f, -0.29535943f, -0.32750461f, 0.24529251f, -0.09369793f, 
    -0.17365268f, 0.26424989f, -0.27404374f, -0.12058471f, 0.00117244f, -0.04284256f, 0.12886502f, 0.12205363f, 
    0.12659641f, 0.06899210f, 0.57574022f, 0.70049804f, -0.50647670f, -0.64756125f, -0.25312668f, 0.31073964f, 
    0.25166950f, 0.23680313f, -0.53873819f, -0.38538489f, -0.31581759f, 0.03016849f, -0.08321629f, 0.19118461f, 
    0.49956891f, 0.01544971f, -0.07656202f, -0.20361444f, 0.18872544f, -0.22184381f, -0.05200744f, -0.35244510f, 
    -0.14602001f, 0.15142351f, -1.24808717f, -0.12544823f, -0.34447598f, 0.03398925f, 0.35500932f, 0.00641003f, 
    -0.06846445f, 0.16842477f, 0.48993123f, -0.10109765f, 0.33370322f, -0.32993370f, 0.40307453f, -0.61187446f, 
    -0.19695331f, 0.12669939f, -0.06248987f, 0.28515399f, 0.03192848f, 0.03903955f, -0.20814790f, 0.19544627f, 
    -0.09149431f, -0.32666644f, 0.45311084f, 0.87783158f, 0.45306641f, 0.04257519f, -0.29553154f, 0.03594878f, 
    -0.32167992f, 0.14658773f, -0.62874329f, -0.91009587f, -0.98154551f, 0.02822443f, -0.11845627f, -0.03109889f, 
    -0.26924837f, 0.00920448f, 0.07653850f, -0.37960091f, -0.06440502f, 0.13108619f, 0.09616772f, -0.18774465f, 
    0.12205769f, -0.02774280f, -0.21337785f, -0.15708242f, -1.24676371f, -0.72181988f, -0.07021874f, -0.23807006f, 
    -0.22972746f, 0.85274476f, 0.28858677f, -0.29049280f, 0.30238605f, 0.39393067f, -0.10506915f, -0.45721185f, 
    -0.11358120f, 0.47431040f, -0.28949341f, -0.02033597f, -0.10562724f, -0.39858615f, -0.26801202f, -0.31081867f, 
    -0.23418877f, 0.03858295f, -0.02881268f, 0.22878039f, -0.41023678f, -0.65803403f, -0.68151397f, -0.62245524f, 
    -0.27273497f, -0.47620311f, 0.34244743f, 0.16729839f, -0.51245070f, -0.43072006f, 0.34938720f, 0.24718013f, 
    -0.53982037f, -0.04970053f, -0.14463374f, -0.29622072f, 0.03294162f, 0.20185126f, -0.29226863f, -0.32940689f, 
    -0.14785720f, -0.36229813f, 0.05164175f, 0.28184932f, 0.31811428f, -0.33394405f, -0.46100286f, 0.22650157f, 
    0.37273407f, 0.26032907f, 0.28495559f, -0.00575911f, -0.59083891f, -0.43307525f, -0.09764325f, -0.10838180f, 
    -0.13932778f, -0.17816801f, -0.08526841f, -0.11100744f, -0.14504094f, -0.07071772f, -0.21798094f, -0.20355885f, 
    -0.25770211f, -0.22405951f, 0.06642739f, 0.19731483f, -0.04470354f, -0.21413387f, -0.35712186f, -0.13132800f, 
    -0.22038913f, 0.15481994f, 0.08252523f, 0.23432538f, -0.17671131f, -0.41515690f, 0.35586885f, 0.11982820f, 
    0.08266457f, -0.28543276f, -0.14754714f, -0.13499206f, -0.13083553f, 0.11401952f, 0.23378776f, -0.20888346f, 
    0.04971688f, 0.05379033f, -0.11533655f, -0.23759502f, 0.17107677f, -0.07023149f, 0.10361739f, 0.18512222f, 
    0.16553897f, 0.38917699f, -0.10300764f, 0.14826144f, -0.28636459f, -0.35222590f, -0.22060110f, 0.00807158f, 
    0.25623924f, 0.25124678f, 0.35838169f, -0.25047195f, -0.11063759f, -0.19608404f, -0.26674968f, 0.17850941f, 
    0.11139975f, -0.04023930f, 0.22662249f, -0.10974565f, -0.16232339f, -0.05468109f, -0.16365787f, 0.11390191f, 
    0.23131396f, 0.29072988f, -0.79876411f, 0.10313991f, 0.49754754f, 0.19271088f, -0.33166197f, -0.30155900f, 
    -0.39682311f, 0.02080639f, 0.35478684f, -0.33872604f, 0.43117496f, 0.41231671f, -0.37473282f, 0.03156702f, 
    -0.26226559f, 0.15478086f, -0.16410415f, -0.00619914f, -0.06105593f, 0.21401313f, -0.28529608f, -0.29720384f, 
    -0.03157178f, 0.26246208f, 0.46262893f, 0.94042200f, -0.17066596f, -0.74493438f, -0.05621224f, 0.37395930f, 
    0.09012251f, -0.05345276f, -0.59764254f, -0.56110930f, -0.03756905f, 0.27127242f, 0.04643834f, 0.03925032f, 
    0.20056832f, 0.40550098f, 0.14409052f, 0.08876727f, -0.18958792f, -0.35324490f, -0.19740140f, 0.09351108f, 
    -0.03560358f, 0.03666047f, 0.11998633f, -0.28831086f, -0.58399230f, 0.26557603f, 0.88077956f, 0.34122658f, 
    -0.47194171f, -0.38468054f, -0.36530289f, -0.17708790f, 0.02451715f, 0.17952269f, 0.06004056f, -0.13807207f, 
    0.03546454f, 0.43533537f, -0.02037992f, -0.06863303f, -0.02072578f, -0.12285452f, -0.24393919f, -0.08235512f, 
    0.11941899f, -0.07706739f, 0.11968764f, 0.04770566f, -0.81939602f, 0.14995761f, -0.02148922f, 0.40278289f, 
    0.04618197f, -0.53868812f, -0.36260056f, 0.39477450f, 0.65916628f, -0.12652935f, 0.10719771f, -0.35720974f, 
    -0.00986999f, 0.11036509f, 0.28042153f, 0.09553590f, -0.06847385f, -0.20113932f, -0.19064103f, 0.19900043f, 
    -0.23364492f, -0.20439176f, 0.30764109f, 0.09291009f, -0.12529589f, 0.72605890f, 0.12840682f, -0.15506648f, 
    0.05894125f, -0.12738165f, -0.11253729f, 0.04896438f, 0.46742824f, -0.03609203f, -0.42435583f, -0.46884039f, 
    -0.21434984f, 0.10581900f, 0.04119297f, -0.23688841f, 0.02426882f, -0.05889909f, 0.21678324f, -0.21632226f, 
    -0.25371265f, 0.07928693f, 0.04149453f, 0.04897605f, 0.20861398f, -0.16395096f, 0.31156325f, 0.12337369f, 
    0.36750674f, 0.44186532f, 0.38334605f, 0.24765521f, 0.03786221f, 0.40054017f, 0.28300810f, 0.29347184f, 
    -0.02674468f, 0.26012650f, -0.15577833f, -0.08574081f, 0.20477587f, -0.02911083f, 0.12488479f, -0.04416899f, 
    -0.25986743f, -0.06899069f, -0.16710140f, 0.23639812f, 0.02204132f, 0.07460070f, -0.17607500f, -0.78215587f, 
    0.83602047f, 0.37426203f, -0.67308915f, -0.00266202f, -0.30816954f, 0.15050365f, 0.01187908f, 0.08948981f, 
    0.33069116f, -0.13925095f, -0.24036239f, -0.51507032f, -0.30298641f, 0.41024113f, -0.10148315f, -0.11465767f, 
    -0.04680806f, 0.01106975f, 0.03185441f, -0.40038598f, -0.36015847f, -0.39073014f, -0.39278704f, -0.82946497f, 
    -0.28089517f, -0.18639550f, -0.22468817f, -0.63755625f, -0.53611439f, -0.53677195f, -0.47926524f, -0.79597145f, 
    -0.64399666f, -0.76620400f, 0.03439951f, 0.20988469f, 0.04683096f, -0.18952313f, -0.02852628f, 0.04068394f, 
    0.09852710f, -0.02743926f, -0.27144334f, -0.23873629f, -0.38051045f, 0.12521020f, -0.19359951f, -0.05191649f, 
    -0.40371025f, -0.21123612f, -0.32366833f, -0.13999014f, 0.12203860f, -0.30705625f, 0.38300949f, -0.18310688f, 
    -0.13323341f, 0.13902520f, 0.61877501f, 0.16641004f, -0.10341336f, -0.15052935f, -0.21112001f, 0.26342866f, 
    -0.48096654f, 0.13595754f, 0.35425153f, 0.15161219f, -0.48995441f, 0.09603773f, 0.04265547f, 0.01075183f, 
    -0.15657946f, 0.41111505f, 0.49079502f, 0.01474321f, 0.01645296f, -0.16706312f, -0.22567101f, -0.24809425f, 
    0.05115844f, 0.28641227f, 0.02216894f, -0.20333581f, 0.02508567f, -0.32822287f, 0.19074047f, 0.40402794f, 
    -0.17609252f, -0.35292634f, 0.12935673f, 0.26090509f, -0.35936701f, -0.12595002f, 0.04883510f, 0.23397738f, 
    0.29998890f, 0.14845578f, -0.18699567f, -0.64080662f, -0.53747600f, -0.90918791f, -0.85858333f, -0.70434803f, 
    0.53795612f, 0.33549714f, 0.37809548f, 0.21640927f, 0.28056028f, -0.04756586f, 0.02882644f, -0.41344795f, 
    -0.24952760f, -0.03829868f, -0.46698475f, 0.10954443f, -0.03572962f, -0.06199634f, -0.34216231f, -0.09176321f, 
    -0.08901797f, -0.09959556f, 0.21884805f, 0.19259219f, 0.21817714f, -0.04365242f, 0.03971737f, 0.09872647f, 
    0.00841619f, 0.31137672f, -0.15443084f, -0.20648895f, 0.24905153f, -0.18394616f, -0.02359836f, 0.11304256f, 
    -0.23123351f, -0.01230832f, -0.08164570f, 0.21508257f, -0.00841082f, 0.27109736f, 0.30814698f, 0.25737688f, 
    0.17932609f, 0.16371715f, -0.07895617f, -0.19123656f, 0.04788236f, 0.64629745f, -0.08987866f, 0.14959693f, 
    0.20282656f, -0.32444984f, -0.19404706f, -0.29473311f, 0.29845735f, -0.03132419f, -0.32850918f, 0.16954298f, 
    -0.04307819f, 0.12050528f, -0.35866228f, -0.31050134f, -0.17665096f, 0.29394385f, -0.16519323f, 0.03408778f, 
    -0.33344495f, -0.50061566f, -0.20375641f, -0.46526036f, -0.32179993f, -0.25163552f, -0.52182168f, -0.68287700f, 
    -0.13757679f, 0.39894193f, 0.04358653f, -0.33540908f, -0.62923378f, -0.61253667f, -0.13502647f, -0.19582510f, 
    0.08801992f, -0.17267878f, -0.43192774f, 0.16553690f, -0.24388306f, -0.31691173f, -0.08360624f, 0.14161760f, 
    -0.20995888f, -0.30172345f, -0.25019804f, 0.11252775f, 0.13986272f, 0.01051820f, 0.25225669f, -0.11390638f, 
    -0.17829686f, 0.27271914f, 0.38473192f, 0.18665636f, 0.09975296f, 0.47760588f, 0.41365188f, 0.07792182f, 
    0.45344862f, 0.24470572f, 0.10727905f, 0.04087144f, -0.22960350f, -0.20746578f, 0.09675899f, -0.27289182f, 
    0.04555963f, 0.19015127f, -0.13868558f, -0.09768827f, -0.39561582f, -0.03375243f, 0.04550463f, 0.32835579f, 
    0.69488257f, 0.35296831f, 0.27622369f, -0.01138624f, -0.35946080f, -0.36240432f, 0.13802020f, 0.00752495f, 
    0.46556970f, -0.56143773f, -0.51189196f, 0.12479249f, -0.12884052f, -0.02123522f, -0.15810649f, 0.04275652f, 
    0.01470851f, -0.05452474f, -0.15179294f, 0.14678474f, 0.13972379f, -0.12202615f, 0.03450714f, -0.34832975f, 
    0.14954528f, 0.67395592f, 0.06143452f, -0.73489070f, -0.66943502f, -0.36485395f, 0.44639656f, 0.50123513f, 
    0.65969735f, -0.34686235f, -0.07863372f, -0.32445994f, 0.06745519f, -0.30170789f, -0.14432095f, 0.13429545f, 
    -0.02855052f, -0.14879768f, 0.29535797f, 0.11838923f, 0.00442512f, -0.15310948f, -0.32932594f, 0.15413181f, 
    0.03857108f, 0.17775759f, -0.35191843f, 0.18637066f, 0.11776186f, -0.04688941f, 0.01025833f, -0.15314019f, 
    0.31421742f, -0.17909668f, -0.22862183f, -0.26743174f, 0.63047707f, 0.23203044f, -0.29749718f, -0.00701508f, 
    0.02369097f, 0.35757130f, 0.06266007f, -0.13138747f, 0.11626950f, -0.24716809f, 0.13497557f, 0.28479615f, 
    -0.19888151f, 0.05989280f, -0.06015364f, 0.65790725f, -0.20692672f, 0.34051719f, -0.12065268f, -0.01253379f, 
    0.11630388f, 0.28865427f, 0.16166021f, -0.49116597f, -0.45116079f, 0.47332653f, -0.34048900f, -0.31201774f, 
    -0.19831230f, 0.11551181f, -0.47874171f, 0.02816578f, 0.19376995f, 0.25496346f, 0.01608498f, 0.13527125f, 
    -0.04510925f, -0.00665458f, 0.01747419f, -0.36209726f, 0.52559453f, 0.41193277f, -0.07751145f, -0.18054716f, 
    -0.31424430f, -0.46493533f, 0.03919696f, 0.14890897f, -0.15136392f, -0.07427402f, -0.09970973f, 0.34581643f, 
    0.15387248f, -0.05260379f, 0.11314689f, -0.09962005f, -0.31071770f, 0.10805344f, 0.17674495f, 0.11543780f, 
    0.36736968f, -0.29981762f, -0.20196955f, 0.16314366f, -0.12048109f, 0.61571205f, -0.86004913f, -0.60993928f, 
    -0.02014785f, -0.03419406f, 0.48282516f, 0.53980529f, 0.53267068f, -0.30599791f, -0.34054413f, -0.33071196f, 
    -0.04502737f, 0.20965593f, -0.11595289f, 0.01591372f, 0.19982728f, -0.26462069f, 0.27429289f, 0.12527579f, 
    -0.20851764f, 0.14882389f, 0.07797632f, -0.02053127f, -0.08951231f, -0.13267900f, -0.43005928f, -0.13327181f, 
    0.39986596f, -0.29148722f, 0.26763055f, 0.31152904f, -0.13410702f, -0.27034169f, -0.05223525f, 0.24452165f, 
    -0.04639410f, -0.05760389f, 0.18303378f, 0.36852232f, -0.34133649f, -0.14304785f, 0.12702468f, -0.21427855f, 
    0.14263900f, -0.20567916f, 0.10067845f, 0.38748673f, 0.13024250f, -0.12866591f, -0.31494075f, 0.60078543f, 
    -0.03427532f, 0.07812325f, 0.03419191f, -0.24538195f, -0.29519945f, -0.25585356f, -0.69600129f, -0.56894410f, 
    -0.10179197f, 0.24322549f, 0.07337370f, -0.20259959f, 0.30874977f, 0.30263755f, -0.10082196f, 0.17586622f, 
    0.19081628f, 0.18511450f, -0.30836022f, -0.19099775f, -0.04242512f, 0.01405726f, 0.29111972f, -0.16719726f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03474917f, -0.04475582f, -0.07894433f, -0.15986618f, 0.07811759f, -0.07470591f, 0.41638896f, 0.22172821f, 
    0.12369628f, 0.20711415f, 0.24464184f, 0.16135797f, 0.07139197f, 0.12123777f, 0.20055090f, -0.11613643f, 
    0.56865847f, 0.22334246f, 0.21906292f, 0.13642648f, 0.16516332f, 0.04847118f, 0.42771447f, 0.22108732f, 
    -0.22050945f, 0.11457376f, 0.17003751f, 0.08878842f, 0.08491412f, 0.12175638f, 0.13228434f, 0.16206306f, 
    0.24429426f, 0.13839298f, 0.11700428f, -0.09918900f, -0.01932747f, 0.03079810f, -0.06523996f, 0.12563691f, 
    0.32318982f, 0.31593800f, 0.27074453f, 0.24086595f, 0.24263863f, 0.33570579f, -0.17831157f, 0.04783609f, 
    -0.40344113f, 0.29131225f, 0.27672684f, -0.11230644f, -0.02860317f, -0.06494395f, 0.31791642f, 0.05448544f, 
    0.34384865f, 0.28598487f, 0.11439113f, 0.20529486f, 0.21456447f, 0.08411264f, 0.20524302f, 0.08914705f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07570447f, -0.01027109f, 0.05336319f, -0.03802089f, -0.07682279f, -0.03105647f, -0.00396662f, 0.02428899f, 
    -0.03714320f, -0.01460047f, -0.00155184f, 0.08017936f, 0.13513808f, 0.02177551f, 0.10327323f, -0.02837126f, 
    0.03784926f, 0.15308048f, -0.06412669f, -0.10161883f, 0.02511784f, 0.06585573f, -0.03567659f, 0.07580349f, 
    0.43667772f, 0.36425582f, 0.13510276f, -0.27688980f, 0.23598754f, 0.16807814f, 0.13649452f, 0.06221269f, 
    0.04058031f, 0.03033309f, 0.01785450f, -0.05338760f, 0.44226131f, 0.33071247f, -0.14710896f, -0.18076146f, 
    0.08166061f, 0.08963055f, 0.09417321f, 0.04090847f, 0.05019415f, -0.00187047f, 0.03498348f, -0.06865048f, 
    0.38675919f, 0.24214324f, 0.13069274f, -0.19374880f, 0.07159999f, -0.01411479f, 0.06332219f, -0.01663185f, 
    -0.09169509f, -0.02945361f, 0.07109552f, -0.07567290f, -0.02077495f, 0.13643798f, 0.06896362f, 0.03884465f, 
    -0.02689912f, 0.06101007f, 0.07270139f, -0.01189398f, 0.02759683f, 0.17574976f, 0.16926016f, 0.08171682f, 
    -0.26720968f, -0.27252167f, -0.23412079f, 0.02497527f, -0.00608700f, 0.00756695f, -0.02552034f, 0.00230242f, 
    -0.06350996f, -0.05139706f, -0.06595352f, -0.00850576f, -0.58208060f, -0.26423842f, -0.06123050f, 0.25327846f, 
    0.06388932f, 0.02025861f, 0.02751717f, 0.00883003f, 0.00198261f, -0.04871162f, 0.02884001f, 0.02293825f, 
    -0.20429535f, 0.10154302f, 0.02973622f, 0.04435361f, 0.02867469f, 0.04205385f, -0.03520663f, -0.00431713f, 
    -0.02475019f, 0.00510909f, 0.01485704f, 0.01314605f, -0.00764422f, -0.01249577f, 0.00773209f, -0.04381916f, 
    0.01807502f, -0.00405283f, 0.05782471f, -0.06949969f, -0.28595242f, -0.08222549f, 0.01247520f, 0.08672085f, 
    -0.00055151f, 0.13798434f, -0.14622837f, -0.01271825f, 0.02342851f, 0.07539111f, 0.07500951f, -0.02646151f, 
    -0.28469095f, -0.13502835f, -0.10722084f, -0.11888071f, -0.58968890f, 0.04686116f, 0.00967503f, -0.04361290f, 
    -0.01539804f, -0.03418707f, 0.03798933f, 0.06423667f, -0.01128927f, -0.05913125f, -0.00721120f, 0.15427777f, 
    0.16557835f, 0.21579115f, 0.04283705f, -0.13607451f, -0.14128263f, 0.03971248f, 0.07245593f, -0.10806806f, 
    0.04760557f, 0.04144615f, -0.04297601f, -0.11746686f, 0.07854759f, 0.14304461f, -0.11015026f, -0.03951128f, 
    0.15496874f, -0.03856747f, 0.06667196f, -0.10844681f, -0.05222367f, -0.08144647f, -0.06081142f, -0.08085193f, 
    0.12735544f, 0.20660962f, -0.03999325f, 0.01456067f, -0.00047665f, -0.08902187f, -0.01257339f, -0.22739436f, 
    -0.05964978f, -0.05518048f, -0.05405219f, -0.07058328f, 0.28220978f, 0.21274991f, 0.00600498f, -0.29001665f, 
    0.00760447f, 0.03414851f, 0.12267707f, -0.18725570f, -0.03958746f, -0.04089573f, -0.00612176f, -0.05840840f, 
    0.18793371f, -0.06215151f, -0.27027509f, -0.06422546f, 0.06408202f, -0.06675627f, -0.21268062f, -0.15524624f, 
    -0.06766815f, -0.20113038f, -0.06395973f, -0.05065402f, -0.50423467f, -0.63034755f, -0.10918941f, 0.14597581f, 
    0.01987493f, 0.03243166f, 0.03726511f, -0.00954332f, -0.18483233f, -0.00835131f, -0.03100074f, -0.21859269f, 
    0.14821987f, -0.02820866f, 0.01253536f, -0.02073707f, -0.01543343f, 0.00606178f, 0.16652055f, 0.13266416f, 
    0.02519635f, 0.02192735f, -0.02685298f, -0.02378831f, 0.24027249f, 0.02029145f, 0.18730681f, -0.21580033f, 
    0.14724685f, 0.03765845f, 0.12305369f, -0.07870079f, -0.05896801f, 0.03847384f, -0.01744530f, -0.01534800f, 
    0.12431283f, -0.11401961f, -0.18248220f, -0.09228025f, 0.04393752f, -0.30152744f, -0.11547284f, -0.08219397f, 
    -0.07242763f, 0.00896631f, -0.23128651f, -0.03309887f, 0.15705493f, 0.14990690f, 0.02918535f, -0.07681151f, 
    0.10488711f, 0.16322073f, 0.07085792f, 0.08992880f, -0.05366511f, -0.09249198f, -0.01477803f, -0.07123674f, 
    0.32362697f, -0.24852537f, -0.13294071f, -0.20642872f, -0.08673175f, -0.14270738f, 0.11584961f, 0.00435606f, 
    -0.03711931f, -0.08537857f, 0.03162409f, -0.16546164f, 0.18794586f, -0.02308123f, -0.04828002f, 0.02918565f, 
    0.09614256f, 0.10089492f, -0.04558944f, -0.14472023f, 0.04766296f, 0.00749024f, 0.02515629f, -0.00216592f, 
    0.27114719f, 0.09121344f, -0.08259445f, -0.03365195f, 0.19549587f, 0.12078920f, -0.02535805f, -0.12354825f, 
    -0.07613069f, 0.04258933f, -0.00598515f, 0.20460555f, -0.16332327f, -0.04680812f, 0.04634952f, 0.07759026f, 
    -0.01934838f, 0.07730919f, -0.04911806f, -0.00927193f, 0.05052650f, -0.03970252f, -0.07272854f, 0.01833771f, 
    -0.25822848f, -0.24823736f, -0.01500098f, 0.04770831f, -0.04350891f, 0.06671711f, -0.00462613f, -0.06943836f, 
    -0.01616003f, -0.15436098f, -0.31545243f, -0.06884740f, 0.19018321f, -0.12213182f, -0.08297861f, 0.04568954f, 
    -0.13645490f, -0.10195126f, -0.01048690f, -0.01345491f, -0.17913656f, -0.03498739f, -0.10453935f, -0.15356942f, 
    -0.05731945f, -0.10495853f, 0.13529742f, -0.11957917f, 0.01432591f, 0.05032892f, 0.01910875f, 0.04311080f, 
    -0.14720424f, -0.15178163f, -0.13338912f, -0.09152838f, 0.02006887f, -0.23109667f, -0.04628749f, 0.08475778f, 
    -0.00161340f, -0.01487225f, -0.00043875f, 0.02505344f, 0.00331365f, -0.10325497f, -0.16666616f, -0.07341869f, 
    -0.01260443f, 0.11003487f, -0.01407520f, -0.04295208f, -0.00925017f, -0.01120708f, -0.18726104f, -0.02356883f, 
    -0.03715853f, 0.04342765f, 0.04052337f, 0.02636993f, -0.15278098f, 0.00749088f, -0.09869578f, -0.01403245f, 
    -0.10132709f, -0.05860308f, 0.03552673f, 0.05581914f, -0.08064015f, 0.07118381f, -0.00222723f, -0.03665112f, 
    -0.03194756f, -0.00905304f, -0.10852401f, 0.01399701f, -0.02045311f, 0.00407201f, -0.07906514f, -0.04036250f, 
    -0.11041991f, -0.12034428f, -0.08081829f, -0.08830904f, -0.45208940f, -0.51620799f, 0.34225869f, 0.00579125f, 
    -0.07768280f, 0.03187835f, -0.26080728f, -0.00420234f, -0.00938383f, -0.07380644f, 0.06929129f, -0.13759139f, 
    0.25823203f, 0.26350361f, 0.21437530f, -0.33780232f, 0.02901237f, 0.09249965f, 0.04517623f, 0.01533850f, 
    0.04978354f, 0.02908377f, 0.08001500f, -0.20530704f, 0.08511394f, -0.01279450f, -0.37795916f, 0.03100691f, 
    0.06302672f, -0.03155129f, 0.13349393f, 0.03615054f, -0.06437142f, 0.05378035f, -0.01203077f, -0.03094893f, 
    0.30225411f, 0.03949436f, -0.04782466f, -0.09695118f, 0.05341757f, 0.12742761f, -0.00989826f, -0.05731965f, 
    0.10073457f, 0.09681646f, -0.03995823f, 0.11655424f, 0.28845200f, 0.11545928f, -0.09746330f, -0.11728678f, 
    0.17438076f, 0.03606555f, -0.04928318f, -0.15513243f, -0.04650623f, 0.03788419f, -0.05753478f, 0.00480859f, 
    0.01903540f, 0.20624362f, 0.04753115f, -0.00288246f, -0.04390676f, -0.10092887f, -0.07603361f, 0.06748844f, 
    -0.01429400f, -0.00685960f, -0.00464379f, -0.02348201f, -0.10262404f, 0.13808139f, 0.16889548f, -0.26651344f, 
    -0.15449549f, -0.06594881f, 0.04797755f, -0.00414698f, -0.01574625f, -0.03522163f, -0.00568906f, -0.01933036f, 
    -0.14624974f, -0.09579573f, -0.02408112f, -0.12038482f, -0.05358364f, 0.03338073f, -0.04041414f, -0.05848791f, 
    -0.05414183f, -0.17007966f, 0.04276557f, -0.01576668f, -0.28514248f, 0.26728907f, 0.01262454f, -0.42171830f, 
    -0.09184759f, 0.01291486f, 0.03739432f, -0.08088071f, 0.01173597f, -0.05841379f, -0.03874600f, -0.07566573f, 
    0.17033134f, -0.20928189f, -0.29783693f, 0.11826820f, -0.07362171f, -0.17533576f, -0.04406223f, -0.08998510f, 
    -0.08810426f, 0.09151029f, -0.01558913f, -0.01717103f, -0.07886521f, 0.09948653f, 0.19372685f, -0.41592640f, 
    -0.09503131f, 0.02880783f, 0.02826924f, -0.05757298f, 0.03854989f, -0.01775191f, -0.02232865f, -0.08960263f, 
    -0.12042236f, -0.22810003f, 0.23793949f, -0.10177147f, -0.02733386f, -0.04660784f, 0.07171749f, 0.02207501f, 
    -0.05618960f, -0.09566171f, -0.05410372f, -0.02925665f, -0.23059966f, -0.39483109f, 0.03780114f, 0.07147439f, 
    0.01711069f, -0.02715222f, -0.03565056f, 0.03903215f, 0.06592584f, -0.04865965f, -0.02903179f, -0.01782632f, 
    -0.14960402f, 0.01952802f, 0.02064843f, 0.06226412f, 0.06988926f, 0.07370050f, 0.08584379f, 0.03934107f, 
    -0.00637131f, 0.04217314f, 0.00902246f, -0.08151681f, -0.58437747f, 0.14396568f, 0.08003502f, 0.04655618f, 
    -0.05512528f, 0.06978068f, 0.02509237f, -0.01145238f, 0.08039192f, -0.02799573f, 0.05590431f, 0.06566419f, 
    0.32997984f, 0.25254902f, -0.04879684f, -0.12009546f, 0.11824813f, 0.06740119f, 0.00090351f, 0.09131926f, 
    -0.07900344f, -0.07108986f, -0.00754650f, 0.01140404f, -0.06545667f, 0.02336183f, -0.00327323f, -0.04431520f, 
    -0.00889904f, 0.02765676f, 0.01543797f, -0.12008116f, 0.08563859f, -0.01422365f, -0.10043050f, -0.06982534f, 
    -0.19083209f, -0.11384051f, 0.02443074f, 0.05276747f, -0.14979376f, 0.01444352f, -0.07790124f, -0.02637372f, 
    0.07204796f, -0.03969003f, -0.03678818f, -0.06381660f, 0.20465817f, -0.07389311f, -0.11773333f, -0.01981202f, 
    0.14515194f, 0.23030552f, -0.10923113f, -0.00996858f, -0.03502373f, 0.02345654f, -0.00079323f, -0.04816652f, 
    0.00941655f, -0.00116214f, 0.05233136f, 0.05091790f, -0.20831251f, -0.02016494f, -0.08072498f, 0.02152054f, 
    -0.00463185f, 0.05392610f, 0.02192204f, -0.03054481f, -0.12060320f, -0.30393156f, -0.06316556f, -0.13765781f, 
    -0.01990459f, -0.01732033f, -0.06172110f, -0.06813172f, -0.18870252f, 0.05775247f, -0.00344409f, 0.19698945f, 
    0.25300515f, 0.19233094f, 0.10332524f, -0.35603541f, 0.09559037f, 0.02292463f, 0.01639435f, -0.14497447f, 
    -0.00344039f, -0.08775744f, -0.03217429f, -0.03018440f, -0.16213748f, -0.04800412f, -0.02343488f, -0.01367272f, 
    0.03021844f, 0.00600030f, 0.08252756f, 0.03003575f, -0.03636639f, -0.14349060f, -0.12943704f, 0.08306523f, 
    -0.46560705f, -0.44265953f, 0.03481096f, -0.06891309f, -0.04549811f, 0.00876617f, -0.09989876f, 0.00669986f, 
    0.03663524f, -0.02044499f, 0.03164893f, -0.05988293f, -0.02311064f, -0.08423317f, -0.24041326f, 0.12667163f, 
    -0.02611124f, 0.03963178f, -0.08560940f, -0.06846868f, 0.06189838f, -0.02099685f, -0.04337967f, -0.05188924f, 
    -0.00365664f, 0.03440224f, 0.03553883f, 0.02041564f, -0.15436706f, 0.02410766f, -0.21893868f, -0.11129376f, 
    -0.08213434f, -0.02519984f, -0.05977229f, -0.06079738f, -0.00083641f, -0.86115968f, -0.38021898f, -0.05131126f, 
    -0.05367206f, -0.18153223f, -0.02391484f, -0.03723196f, -0.03234378f, 0.04730988f, -0.02607059f, 0.13344206f, 
    -0.15097339f, -0.09044918f, -0.05358726f, 0.01728508f, -0.04943598f, -0.03534921f, -0.10231718f, -0.09597117f, 
    0.00031736f, 0.05605851f, -0.04775997f, -0.10312318f, 0.17955026f, -0.13368562f, -0.10041618f, 0.06360166f, 
    0.06150333f, 0.01483549f, 0.15283217f, -0.17361695f, -0.00787296f, -0.01014281f, -0.08532820f, -0.00295366f, 
    0.03237382f, 0.03597518f, -0.04894621f, 0.00957830f, -0.18740682f, 0.07686945f, -0.02340242f, 0.01256964f, 
    -0.05123438f, -0.05207731f, -0.11765189f, -0.02303471f, 0.18087943f, 0.12380771f, -0.10525098f, -0.09847163f, 
    0.12347078f, -0.02585481f, -0.06862204f, -0.13341099f, -0.00286238f, 0.02921038f, 0.05296648f, 0.03267070f, 
    -0.11236899f, -0.05929120f, -0.03091380f, -0.10135531f, 0.00608489f, 0.09308687f, 0.05084739f, 0.01647702f, 
    -0.11734068f, -0.10473972f, -0.28073400f, -0.09835747f, -0.25767991f, 0.12084038f, -0.03053573f, 0.01024120f, 
    0.07034659f, 0.05715628f, -0.14504057f, -0.27871412f, 0.01571742f, 0.03707201f, 0.00026136f, -0.18331605f, 
    0.29249817f, 0.28387564f, 0.00394569f, -0.12094241f, -0.03114268f, -0.02058733f, -0.25048929f, -0.01150978f, 
    0.04783402f, -0.11390269f, -0.15240577f, 0.05712172f, 0.03383862f, 0.01315855f, -0.08649312f, -0.01969666f, 
    -0.19391634f, -0.04222970f, -0.15482219f, -0.16235329f, -0.02578845f, -0.00614088f, 0.02981090f, 0.03877174f, 
    -0.12356355f, -0.14979747f, -0.12603627f, 0.00218588f, -0.00908116f, 0.00739371f, 0.04050358f, -0.01512459f, 
    -0.08535812f, -0.00939194f, -0.12971584f, 0.12559435f, -0.07018269f, 0.09422100f, -0.16919394f, 0.05029093f, 
    0.01553750f, -0.04795042f, -0.05769924f, 0.01427539f, -0.37733194f, -0.03752519f, -0.21069819f, -0.24910539f, 
    0.25668439f, 0.05835622f, 0.07232588f, 0.03814382f, -0.03756959f, -0.05423124f, -0.03106117f, -0.00549988f, 
    0.02655706f, -0.04295521f, 0.02557457f, 0.07867759f, 0.36664385f, 0.21226507f, 0.26482961f, 0.06504414f, 
    0.01861225f, 0.00797844f, -0.00142469f, 0.05069615f, -0.01401845f, 0.01243737f, -0.10805499f, 0.01000679f, 
    0.05724265f, 0.04249416f, 0.02358546f, 0.04820081f, 0.02778205f, -0.19784798f, -0.05423080f, 0.04682188f, 
    -0.04511875f, -0.00532266f, 0.00276345f, 0.03405806f, -0.00463124f, -0.02756683f, -0.04260706f, 0.02664562f, 
    -0.02410925f, 0.06048220f, 0.03926245f, -0.18966602f, 0.16300039f, 0.09239200f, -0.01612427f, 0.08317022f, 
    -0.05466158f, -0.15335543f, -0.18726927f, -0.04703945f, 0.11688207f, -0.02841495f, 0.00399401f, 0.10209322f, 
    -0.12610871f, 0.09479614f, -0.17828213f, 0.11910375f, 0.10254013f, 0.31383011f, 0.38096970f, 0.15160853f, 
    -0.04069931f, -0.03055060f, 0.02891394f, -0.03214438f, -0.04527513f, 0.06447327f, 0.05470799f, 0.07533772f, 
    -0.16209939f, 0.07648302f, -0.23524943f, 0.00878931f, -0.19380234f, -0.01727549f, 0.08464357f, 0.13400355f, 
    -0.16111191f, -0.05008233f, 0.04868666f, 0.04220920f, 0.07910587f, 0.13845663f, -0.17520812f, 0.20439821f, 
    -0.12962946f, -0.04699613f, -0.00623011f, 0.04641109f, -0.08310976f, 0.07013928f, 0.01454592f, -0.07640559f, 
    0.19774616f, -0.02179668f, -0.19610907f, 0.18973629f, -0.07346661f, -0.05906528f, 0.08286516f, -0.09321184f, 
    -0.04568499f, -0.06376023f, -0.00731754f, 0.05968926f, -0.15073802f, 0.16285914f, 0.14375779f, 0.10932302f, 
    -0.11304262f, 0.15455411f, -0.01928293f, -0.08232856f, -0.02713522f, 0.07036117f, 0.02349148f, -0.02194089f, 
    0.05618325f, -0.25779054f, -0.11336117f, -0.09370182f, 0.12474992f, 0.22206485f, 0.15835598f, 0.13946855f, 
    0.11325424f, 0.14431122f, -0.03566283f, -0.00633255f, 0.42864630f, 0.15505175f, 0.36077055f, -0.00886062f, 
    -0.08804499f, 0.02598189f, 0.01586638f, 0.02381212f, 0.19189848f, 0.05384015f, -0.12842868f, -0.05344344f, 
    -0.00312042f, -0.05119728f, -0.00392075f, -0.14506294f, -0.05132660f, -0.11357862f, -0.04038523f, -0.18860184f, 
    -0.09847230f, -0.00618291f, 0.04343097f, 0.07095500f, -0.12442915f, 0.10860015f, -0.00671884f, 0.01423746f, 
    0.04726300f, -0.01977305f, 0.04049450f, -0.06892072f, -0.02680933f, -0.07203073f, -0.04916018f, -0.12105803f, 
    0.13286091f, 0.00955777f, -0.15139478f, -0.41324589f, 0.09871046f, 0.07929878f, 0.10710008f, 0.13087918f, 
    0.03427517f, -0.19669294f, 0.03934851f, -0.33237779f, 0.05607869f, 0.22257149f, 0.26142466f, 0.15317027f, 
    0.07593842f, 0.05897830f, 0.03158729f, 0.11047947f, 0.01254215f, 0.00667462f, -0.00222305f, 0.01133092f, 
    0.02449831f, -0.49938419f, 0.29497185f, 0.18071572f, -0.12292691f, -0.00228781f, 0.09890475f, 0.00228228f, 
    0.14068510f, 0.12706043f, 0.10513639f, 0.14024185f, -0.05709246f, -0.20249949f, -0.07720272f, -0.11705738f, 
    0.01576917f, 0.03939518f, -0.10462426f, 0.00549880f, 0.02854966f, -0.04379246f, 0.02057676f, -0.06639515f, 
    -0.12210088f, 0.07740266f, -0.00445310f, -0.07052682f, 0.01197789f, 0.12756269f, -0.04156689f, -0.10091165f, 
    0.00139302f, -0.02927125f, -0.00061447f, 0.03092884f, 0.02980041f, -0.01778874f, 0.02279679f, 0.01521984f, 
    -0.01905429f, 0.00655873f, -0.02706355f, 0.01706558f, -0.00408795f, 0.00035761f, 0.09922965f, -0.05498301f, 
    -0.07759281f, -0.13129914f, 0.04926031f, 0.08412057f, 0.07991862f, -0.12157309f, -0.14764872f, 0.01261890f, 
    -0.05175975f, -0.12367894f, -0.03927676f, 0.16431461f, -0.09697406f, -0.04114488f, -0.02744869f, -0.02522239f, 
    0.11407255f, -0.08921798f, -0.05427620f, 0.08498777f, 0.18441725f, -0.04790159f, 0.05536382f, 0.12714492f, 
    -0.09609196f, 0.10602538f, -0.00744967f, -0.01362132f, -0.03751736f, -0.00993811f, -0.00127870f, 0.06367316f, 
    -0.22903919f, 0.12719347f, -0.03367072f, 0.12970823f, 0.24462073f, -0.24184760f, -0.25080800f, -0.25455815f, 
    -0.00411750f, 0.03730489f, -0.01000824f, -0.03851657f, 0.01827778f, 0.06075025f, 0.12936543f, -0.06273091f, 
    -0.13031211f, 0.06883777f, -0.10404439f, -0.07768613f, -0.04148676f, -0.19252302f, -0.02124461f, -0.00472106f, 
    -0.09811262f, 0.00115781f, 0.08314201f, -0.02378278f, 0.21952543f, -0.13316037f, 0.07780640f, -0.11432498f, 
    -0.00420618f, -0.01755243f, 0.06166110f, -0.19798073f, 0.10822380f, 0.00843543f, 0.05395474f, 0.07709182f, 
    0.07139847f, -0.01296377f, 0.03681706f, 0.03921269f, -0.02661120f, -0.02521749f, -0.03720285f, 0.04610032f, 
    0.02947692f, -0.00724771f, -0.20239417f, 0.12195519f, 0.11093049f, -0.11773151f, 0.18275161f, -0.07806747f, 
    0.03987924f, -0.11317673f, 0.01612855f, -0.02855934f, 0.16738832f, 0.16508526f, -0.22924937f, -0.22581068f, 
    -0.47858948f, 0.13745317f, -0.43740943f, -0.14113154f, -0.17041065f, -0.02288929f, -0.04539870f, -0.28874570f, 
    0.04649331f, 0.06003921f, -0.19301528f, 0.03021124f, 0.38027683f, -0.30383888f, -0.33644027f, -0.42039379f, 
    -0.26762947f, -0.16569310f, -0.21644051f, -0.01768554f, -0.11895238f, -0.02881873f, -0.00009403f, 0.07965398f, 
    0.30933574f, 0.04164906f, -0.02833655f, -0.06592451f, 0.05441393f, -0.08021125f, 0.02541476f, -0.03988408f, 
    -0.08373097f, -0.15459935f, -0.01187445f, -0.27603352f, 0.40560341f, 0.08144763f, 0.05912446f, -0.07340281f, 
    0.05495735f, -0.05979850f, 0.17054546f, 0.09083790f, -0.00434432f, -0.01385450f, -0.00825836f, -0.05810545f, 
    -0.20916367f, -0.10880154f, -0.50688607f, -0.10854455f, 0.08447169f, -0.05331371f, -0.02868032f, 0.12138812f, 
    -0.03887286f, 0.07076177f, 0.03667120f, -0.14129896f, -0.12122351f, 0.14400069f, -0.04754066f, -0.02202284f, 
    -0.12062076f, 0.00836089f, 0.03541522f, 0.00394913f, -0.03244745f, 0.07520898f, -0.03449015f, -0.01311047f, 
    -0.14856260f, 0.08818290f, 0.13208464f, -0.09345105f, -0.01088648f, 0.01211374f, 0.00593008f, -0.09271888f, 
    0.08659717f, -0.10653892f, -0.02772708f, 0.08671243f, -0.10240678f, 0.26436135f, -0.24083574f, 0.19245574f, 
    0.02413989f, 0.14403279f, -0.03312930f, -0.16829972f, 0.07770824f, 0.02008086f, -0.09756256f, 0.06799618f, 
    0.13521163f, -0.31619862f, -0.06370512f, 0.04842425f, -0.05566609f, -0.11175846f, 0.06574845f, -0.26542211f, 
    0.03688953f, 0.17559457f, -0.07439132f, 0.06905071f, -0.50561213f, 0.03271905f, -0.11725382f, -0.06036490f, 
    -0.12087248f, 0.02637734f, 0.05690248f, 0.10636544f, -0.07779244f, 0.03810946f, 0.02573619f, -0.05117308f, 
    -0.36130011f, 0.05658097f, -0.00023172f, 0.04390514f, 0.11783266f, 0.03954741f, -0.07467205f, 0.02503842f, 
    0.10371240f, 0.13847695f, -0.00712764f, 0.03536575f, 0.47188401f, 0.22464272f, 0.24315566f, 0.12759833f, 
    -0.05813882f, -0.05287974f, -0.02681761f, 0.00846436f, -0.07462026f, 0.01007118f, -0.00210163f, 0.05425183f, 
    0.20222962f, 0.14650188f, 0.22062588f, 0.11990382f, -0.03166313f, -0.05371808f, -0.04591881f, 0.00956106f, 
    -0.02125902f, 0.07845818f, -0.04229370f, 0.03776508f, -0.03355925f, -0.06565461f, 0.08654461f, -0.07828470f, 
    0.06838521f, -0.03842152f, -0.14916021f, -0.01571296f, -0.27456814f, -0.01343087f, -0.18031119f, -0.33924955f, 
    0.02740767f, -0.00050434f, 0.02884735f, 0.16176039f, -0.14235613f, 0.00285015f, -0.28328788f, 0.15721238f, 
    -0.02203503f, 0.09273532f, -0.02399914f, 0.05588555f, -0.09955615f, 0.20833576f, 0.01523491f, -0.44381824f, 
    -0.02960292f, 0.03854609f, -0.07028890f, 0.01644419f, -0.04966130f, 0.04589027f, -0.02796136f, -0.14340328f, 
    0.12860520f, -0.00951356f, 0.06175476f, -0.06080224f, -0.12320757f, -0.00293308f, 0.03623618f, 0.06662556f, 
    -0.11872926f, -0.02254099f, 0.05790820f, 0.02757182f, 0.31757933f, 0.20196053f, 0.04298437f, -0.25683787f, 
    0.00584505f, 0.03667302f, 0.04281609f, -0.04946462f, 0.07968099f, 0.04138109f, -0.14205398f, -0.07517886f, 
    -0.02188521f, -0.03364924f, -0.00582277f, -0.01131485f, -0.03776873f, 0.03193339f, 0.07394989f, 0.09421111f, 
    -0.03526435f, -0.09947832f, -0.05177365f, -0.00882165f, 0.15744501f, 0.07578021f, 0.12510934f, -0.10886063f, 
    -0.00335139f, -0.01123834f, -0.11510060f, -0.03739452f, 0.01128524f, -0.34888270f, -0.32953706f, 0.17104623f, 
    -0.10607294f, 0.08159308f, -0.04631066f, -0.01625558f, 0.13730764f, -0.03277221f, 0.07873841f, 0.10250176f, 
    0.05020170f, -0.00936849f, 0.03145628f, 0.03882165f, 0.15324752f, 0.14272544f, 0.10239875f, 0.08930064f, 
    -0.10166942f, 0.03524625f, -0.00583639f, -0.09962898f, 0.16791025f, 0.06209009f, 0.08063462f, 0.09588861f, 
    0.47748381f, 0.21255095f, 0.09110401f, -0.13484932f, -0.03895389f, -0.03076242f, -0.02487651f, -0.02577834f, 
    -0.03587344f, 0.05207623f, -0.01875314f, -0.02611435f, 0.51743215f, -0.07535211f, 0.01517852f, -0.04389774f, 
    0.06225434f, -0.07658380f, 0.08051894f, -0.16795392f, 0.07919305f, -0.00346103f, -0.03862076f, -0.18794383f, 
    -0.08999492f, -0.13846350f, 0.04913056f, 0.02281034f, -0.02422179f, 0.20311768f, -0.06578726f, 0.12168901f, 
    -0.09867635f, -0.07364018f, 0.06584422f, 0.08105943f, 0.38251024f, 0.02159485f, 0.23238370f, -0.15010779f, 
    -0.00399444f, -0.18310034f, -0.06084636f, -0.05808366f, 0.02363176f, -0.12575324f, 0.08480412f, 0.01848353f, 
    0.10387458f, -0.05917558f, 0.14405143f, -0.03321965f, 0.07779755f, 0.07908869f, -0.08032723f, -0.00579439f, 
    0.02467945f, -0.10805508f, 0.05813665f, 0.20425585f, 0.56816918f, -0.15337317f, 0.10971622f, 0.07351627f, 
    -0.02760035f, 0.04173905f, -0.15365802f, -0.13922800f, 0.00939571f, -0.11493643f, -0.02624561f, -0.05897047f, 
    -0.06674663f, -0.07077392f, -0.03520538f, 0.16200645f, 0.08943346f, -0.01418833f, -0.01698229f, 0.15909369f, 
    -0.18931840f, -0.13379928f, 0.04756821f, 0.00570551f, 0.01476825f, 0.00123471f, -0.12708162f, -0.21931186f, 
    -0.28476164f, -0.19126268f, -0.00754612f, 0.03265389f, -0.01533741f, -0.02771122f, 0.04126367f, 0.08824381f, 
    -0.12440962f, 0.02090328f, -0.01552327f, 0.08261158f, -0.04226257f, -0.01661107f, 0.02031734f, -0.10486116f, 
    0.13960885f, -0.00659984f, 0.20286213f, 0.17148636f, 0.16974843f, 0.08986299f, 0.15093260f, 0.19487187f, 
    -0.00395593f, -0.08683088f, 0.06667247f, 0.07056496f, -0.00801675f, 0.01554899f, 0.08066855f, 0.09763408f, 
    0.14847098f, 0.10337413f, 0.02560376f, 0.21465468f, 0.06146215f, 0.02170588f, -0.00903527f, 0.07555251f, 
    -0.02384861f, -0.00061000f, -0.07766201f, 0.11237298f, -0.64826143f, -0.33615080f, -0.15706003f, -0.29108527f, 
    -0.02820535f, 0.00315506f, -0.10839857f, -0.00244192f, -0.01487178f, -0.01340845f, 0.03029225f, -0.05396566f, 
    0.08494599f, -0.17588627f, -0.12192199f, 0.07781889f, 0.06086021f, -0.03343223f, 0.06215343f, 0.15111178f, 
    -0.01658854f, 0.01960604f, 0.05946209f, -0.15296163f, 0.01903385f, -0.16687493f, 0.06595590f, 0.13923061f, 
    0.04821758f, -0.01183153f, -0.01988772f, -0.03862405f, 0.09617444f, 0.12713787f, -0.04343086f, 0.08670300f, 
    -0.08928898f, 0.14944586f, 0.02355832f, -0.26490036f, 0.06416921f, -0.04590846f, 0.03239948f, 0.03100394f, 
    0.02917246f, 0.05183218f, 0.00969526f, 0.04344318f, 0.04747827f, -0.21930136f, -0.21606010f, -0.01091202f, 
    -0.00381043f, 0.04723289f, 0.04811959f, 0.03048500f, 0.00858374f, -0.10159109f, -0.00247303f, 0.09117292f, 
    -0.09552222f, -0.11257509f, 0.13705286f, -0.06003715f, 0.00105884f, 0.00220266f, 0.05599072f, 0.06708294f, 
    -0.05317865f, -0.04479529f, -0.05967629f, 0.09626442f, -0.02554638f, 0.09412732f, -0.00807484f, 0.09020864f, 
    -0.02807889f, 0.00178793f, 0.03358489f, 0.03356897f, -0.09432530f, 0.13985913f, 0.00993698f, 0.06256677f, 
    0.17998327f, -0.05414011f, -0.06380423f, -0.03395052f, 0.13242221f, -0.05024401f, 0.05295639f, -0.00683595f, 
    0.09718373f, -0.07109741f, -0.28560871f, -0.06346489f, -0.21074119f, -0.25049421f, 0.06798109f, -0.21390490f, 
    0.01032415f, 0.00989181f, 0.01119844f, -0.01830119f, 0.03164166f, -0.07389501f, 0.00099673f, 0.06926496f, 
    0.00104279f, 0.19750899f, -0.28439865f, 0.13088520f, 0.04970621f, -0.22750853f, -0.02770992f, 0.11836187f, 
    0.00025809f, -0.04229525f, 0.06233296f, -0.14712274f, -0.01636609f, -0.06531926f, -0.07297998f, 0.12464261f, 
    0.00224828f, 0.09390268f, 0.07248313f, -0.03243515f, 0.02582785f, -0.02152777f, -0.07184283f, -0.01313683f, 
    -0.14598712f, -0.14376782f, 0.06830738f, 0.02409471f, -0.06652742f, 0.12401851f, -0.15295933f, 0.09764162f, 
    0.02455656f, -0.15396728f, 0.20584944f, -0.09919697f, -0.55826920f, -0.38231945f, -0.47975683f, -0.19294947f, 
    0.02075079f, 0.03923037f, -0.17542189f, -0.22726086f, 0.00923360f, -0.00790961f, -0.01464519f, -0.03467574f, 
    -0.08133808f, 0.32970226f, 0.05790072f, -0.05823375f, -0.02886549f, 0.07892534f, 0.04885275f, -0.14196609f, 
    -0.05096894f, 0.03623980f, -0.06526617f, 0.01399654f, -0.01258644f, -0.01394646f, -0.02089399f, -0.05671737f, 
    -0.02906212f, -0.02925730f, -0.00844134f, 0.05203433f, -0.11686722f, -0.05742710f, -0.01216644f, 0.14211181f, 
    -0.28727621f, -0.01846520f, 0.13132998f, 0.02559038f, 0.02985091f, 0.05732319f, -0.24510549f, -0.13402946f, 
    0.08500667f, -0.03037812f, 0.01955966f, -0.02299575f, 0.00913076f, -0.09924037f, -0.06852070f, 0.29090786f, 
    -0.01801198f, 0.01452734f, 0.05147396f, 0.15286958f, 0.05100089f, -0.00374931f, -0.03248978f, -0.01187306f, 
    -0.53786129f, 0.38433853f, 0.22971874f, -0.33343965f, -0.12151985f, 0.09390063f, -0.02811754f, -0.03568575f, 
    0.12581465f, -0.02291241f, 0.11257625f, -0.05962881f, -0.11054575f, 0.11048238f, -0.01741711f, 0.01234573f, 
    -0.10199638f, 0.06300596f, 0.00499025f, -0.08932906f, -0.05361342f, -0.07825843f, -0.03455028f, 0.00897524f, 
    0.16351226f, 0.03367120f, -0.10776504f, 0.03071895f, 0.04915841f, -0.09021431f, 0.06129488f, 0.02911096f, 
    -0.07736871f, 0.02862604f, -0.13983856f, -0.07664167f, 0.26949874f, 0.07593362f, 0.25901768f, 0.21152267f, 
    -0.03911087f, -0.03058629f, 0.02510961f, -0.25343123f, -0.00272579f, 0.06156431f, 0.03901348f, 0.02498632f, 
    -0.23471136f, 0.23693925f, 0.17785513f, 0.17675041f, -0.11258166f, -0.04440422f, 0.10828521f, -0.08142969f, 
    -0.09314788f, -0.01175022f, 0.01767057f, -0.00485262f, 0.00205395f, -0.00312914f, -0.03102146f, -0.00575897f, 
    -0.02160167f, 0.01537188f, -0.14795963f, 0.02564284f, -0.04029170f, -0.08879549f, 0.03431450f, -0.01550682f, 
    -0.02551770f, -0.03179049f, -0.01337732f, 0.02313753f, 0.01947721f, 0.00977120f, 0.04107700f, -0.14316215f, 
    -0.00148144f, -0.10322111f, 0.16488035f, 0.04208450f, 0.02147886f, 0.12047041f, -0.01926961f, 0.04377297f, 
    0.15325268f, -0.06845519f, 0.03199255f, 0.06729329f, -0.13225910f, 0.05960298f, 0.05011422f, -0.03462961f, 
    0.30789250f, -0.05956018f, -0.00701862f, 0.10811220f, 0.08911084f, -0.00662377f, 0.00985565f, 0.03208224f, 
    -0.09037811f, -0.09042988f, 0.07700093f, -0.03027154f, -0.07690857f, 0.29849333f, 0.20760474f, 0.02404879f, 
    -0.04557778f, -0.04408312f, 0.02575073f, -0.03114975f, -0.03717990f, 0.05190773f, -0.04977508f, 0.12257102f, 
    -0.06993049f, -0.00115520f, -0.01111293f, -0.01879934f, 0.02776819f, -0.18041828f, -0.19251536f, 0.00803853f, 
    0.03114482f, 0.04892681f, 0.00810656f, -0.01583931f, 0.00428701f, -0.16257590f, 0.05383398f, -0.00255010f, 
    -0.18007934f, 0.06170389f, -0.02011517f, 0.02460018f, 0.03336509f, 0.02654981f, -0.10055960f, 0.01336996f, 
    -0.15173866f, -0.17429641f, -0.05375591f, -0.03402356f, -0.00831215f, 0.00120417f, -0.11472476f, -0.00105620f, 
    -0.00355989f, 0.05872462f, -0.01257798f, 0.09606574f, 0.15745185f, -0.05346217f, -0.32159519f, -0.30718258f, 
    0.01234255f, -0.01562969f, -0.16188815f, 0.01080900f, -0.11932413f, 0.01026491f, -0.07804476f, 0.02223821f, 
    -0.12780072f, 0.04389821f, -0.53578603f, 0.21448340f, 0.10512184f, 0.01426446f, -0.23156491f, 0.13981687f, 
    0.03835730f, 0.02462476f, 0.00022042f, 0.01753553f, -0.60442024f, -0.10544278f, 0.20274433f, -0.44820663f, 
    -0.22424771f, -0.03662904f, -0.25188309f, -0.17765227f, 0.02967713f, -0.02495056f, 0.02209342f, -0.04043235f, 
    0.05442580f, 0.00549032f, 0.63479024f, 0.45673448f, -0.04650651f, 0.01517485f, 0.02853014f, 0.07545789f, 
    0.14762327f, -0.17858976f, 0.19574009f, -0.06697481f, -0.19239008f, 0.01573643f, 0.49933541f, 0.33935037f, 
    -0.02308349f, -0.03866836f, 0.08719402f, 0.02603183f, 0.01789279f, -0.02311417f, -0.00925012f, 0.03788574f, 
    0.12126429f, 0.29327670f, -0.10101257f, -0.22669807f, 0.05663120f, 0.01132939f, -0.00724589f, 0.00880220f, 
    0.01676004f, -0.00137035f, -0.00160463f, -0.06983107f, -0.00802628f, -0.04680293f, -0.17385940f, 0.23955676f, 
    -0.02876154f, 0.06700272f, 0.00198529f, 0.04129018f, -0.01964881f, 0.00884647f, 0.05583126f, 0.02401195f, 
    0.02907273f, 0.07935992f, 0.09376100f, -0.06837198f, 0.06760956f, 0.05714171f, -0.00443861f, 0.07633653f, 
    -0.09110471f, 0.00948146f, 0.02229073f, 0.02082767f, 0.14679517f, 0.21444277f, -0.12683892f, -0.04376682f, 
    0.01345397f, 0.09482612f, -0.17734082f, 0.09918400f, 0.05268862f, -0.05571078f, 0.02613999f, -0.07771808f, 
    0.03735214f, -0.28407583f, 0.17347600f, -0.09733026f, 0.05480544f, -0.08987971f, -0.19102313f, -0.16981921f, 
    0.04098501f, -0.07073433f, -0.01847238f, 0.03589212f, -0.13193476f, 0.22913623f, -0.19845919f, 0.21163540f, 
    -0.02684387f, -0.16549902f, -0.08636671f, 0.01177092f, -0.02758023f, 0.02542108f, 0.00110656f, 0.02404428f, 
    0.12462483f, -0.04175891f, -0.19983931f, 0.07274989f, -0.02786615f, 0.10517680f, 0.05048249f, -0.04737899f, 
    -0.11168102f, 0.10672469f, -0.03865257f, 0.02139869f, -0.12601925f, -0.03476578f, 0.11089991f, 0.05169135f, 
    -0.01239580f, -0.00392588f, 0.01619086f, -0.03619614f, 0.00538706f, -0.02368659f, 0.05526011f, -0.06139287f, 
    -0.15700920f, -0.13882238f, -0.10510772f, 0.04200250f, -0.02885687f, -0.00325614f, 0.00183476f, -0.00529512f, 
    -0.07469535f, -0.02034198f, -0.05722689f, 0.12101072f, 0.15840279f, -0.10614118f, 0.07032040f, 0.04627096f, 
    0.03801157f, -0.01651924f, -0.02300136f, -0.08220133f, 0.01979308f, 0.25837079f, -0.05446964f, 0.08834992f, 
    -0.90022707f, -0.56481689f, -0.12583278f, -0.54544479f, -0.07957990f, -0.00169362f, -0.14030410f, -0.15356852f, 
    -0.00059908f, 0.01444114f, -0.00607287f, -0.03465946f, -0.10871211f, 0.12740396f, 0.18777667f, 0.10062102f, 
    0.13559744f, 0.19342417f, -0.20941487f, 0.04851157f, -0.15893903f, -0.05896395f, -0.05644473f, 0.11707240f, 
    -0.13042893f, -0.01882667f, -0.00615398f, -0.00032767f, -0.07291386f, -0.07775132f, 0.05021357f, -0.08498351f, 
    0.00398963f, -0.09633680f, 0.08965620f, 0.00636483f, -0.13866358f, 0.54336470f, 0.52912045f, 0.26735669f, 
    -0.15102719f, -0.01678221f, 0.10309398f, -0.02239214f, -0.02614152f, -0.02671473f, -0.12063111f, -0.08758881f, 
    -0.01765976f, 0.07306094f, -0.03411119f, -0.07458299f, -0.11687784f, -0.04346339f, -0.13428724f, 0.13764800f, 
    -0.06435615f, 0.03412649f, -0.00478817f, -0.03087791f, -0.22715694f, 0.06188558f, -0.07173820f, 0.07322791f, 
    -0.05419859f, -0.04725526f, -0.05249522f, -0.06437600f, 0.06161372f, 0.02560958f, 0.07412075f, 0.13178255f, 
    -0.20776364f, -0.10033301f, 0.03028493f, -0.00234281f, 0.10379260f, -0.05857691f, -0.01264264f, 0.13274750f, 
    -0.01584476f, 0.00310990f, 0.01020365f, -0.03604623f, -0.06867212f, -0.07972838f, -0.03437922f, -0.04404557f, 
    -0.03751532f, 0.04652819f, -0.02795202f, 0.06823466f, -0.12238817f, -0.07321368f, 0.13077146f, -0.14636767f, 
    -0.20299968f, 0.03356262f, 0.13185239f, -0.10810471f, 0.01091099f, 0.02300628f, -0.06765912f, 0.03268550f, 
    -0.04458696f, -0.02631163f, -0.06543393f, 0.01634699f, -0.07554452f, 0.21264446f, 0.38065615f, -0.13728733f, 
    0.00051540f, -0.02940374f, -0.03949057f, -0.20480530f, 0.00183016f, 0.06405088f, 0.00795726f, -0.07472802f, 
    -0.00793834f, -0.06267841f, -0.04740230f, 0.01426666f, 0.00417726f, 0.00574395f, -0.09542873f, 0.11547023f, 
    0.09823533f, -0.09612051f, -0.05569720f, 0.09899952f, 0.21185501f, 0.02449987f, -0.11622225f, -0.20537919f, 
    0.04980112f, -0.08728243f, 0.09208449f, 0.10743622f, 0.06625866f, 0.03760996f, -0.05235192f, 0.11561701f, 
    -0.15970418f, 0.02213267f, 0.11863482f, -0.01360446f, -0.02340816f, 0.01942952f, -0.10540819f, 0.03675373f, 
    0.06122910f, -0.03174966f, -0.02519190f, 0.05968850f, -0.06326787f, 0.05039162f, 0.29360491f, -0.01125020f, 
    -0.07411394f, 0.01045297f, 0.08525987f, 0.00592231f, 0.07805742f, -0.06069402f, 0.11570283f, -0.05870812f, 
    0.12662002f, -0.20909040f, 0.04354538f, 0.07696521f, 0.10712539f, -0.12745526f, 0.12275757f, 0.05171986f, 
    0.05834110f, -0.06357279f, 0.12206300f, -0.04312837f, -0.33996165f, -0.12732905f, 0.09891061f, -0.02652087f, 
    0.06068742f, -0.02586265f, -0.17631043f, -0.08179907f, 0.11544223f, -0.00783478f, 0.04847813f, 0.01886121f, 
    -0.04445346f, -0.09480089f, 0.00775249f, 0.03457582f, -0.06951247f, 0.05567548f, -0.02845477f, 0.11052623f, 
    -0.01283878f, 0.05109556f, 0.03497553f, 0.02654732f, 0.22069834f, -0.06118059f, -0.01885971f, 0.13207538f, 
    0.06695031f, 0.03199673f, 0.08722081f, -0.06481769f, -0.12715535f, -0.06197343f, 0.09169684f, 0.03852745f, 
    -0.09215412f, 0.02470802f, 0.01646034f, 0.08364932f, 0.03421442f, -0.03079347f, -0.01968997f, -0.01810826f, 
    -0.03162366f, 0.13697547f, -0.01673356f, 0.13621366f, -0.15666892f, -0.14415129f, -0.02330782f, 0.14209862f, 
    0.05761851f, 0.01396097f, -0.03064363f, 0.06643054f, -0.10083081f, -0.05868102f, -0.10499061f, 0.01811736f, 
    -0.21633774f, 0.33797243f, -0.22901157f, -0.90542620f, 0.15537599f, 0.11890718f, -0.00250796f, -0.09328885f, 
    -0.17398497f, -0.00623676f, -0.02274785f, -0.02723781f, 0.27133331f, 0.02114300f, -0.31352037f, -0.13196759f, 
    0.03983776f, 0.00588884f, -0.09991544f, 0.04796104f, -0.15827839f, 0.03335803f, -0.05528124f, -0.01772643f, 
    -0.44881555f, -0.07715556f, -0.21722399f, -0.01587290f, -0.11600802f, -0.11067745f, -0.02264990f, -0.10595284f, 
    0.05173003f, 0.03620006f, -0.04958014f, -0.02771380f, -0.17506605f, 0.02265256f, 0.00373220f, -0.18723054f, 
    -0.12361537f, -0.16579831f, -0.24131228f, 0.08404217f, -0.08320976f, 0.03667492f, -0.00392833f, -0.11524194f, 
    -0.11094881f, -0.13553411f, 0.48251447f, 0.01716624f, -0.36544344f, -0.15433723f, -0.06290080f, 0.07398411f, 
    0.13810830f, 0.02583088f, 0.12700975f, 0.05614365f, -0.14846754f, -0.13467269f, -0.05340611f, -0.21822134f, 
    0.05681864f, -0.04271614f, -0.07136571f, -0.01599981f, -0.07614170f, 0.02650175f, -0.06331970f, -0.16469839f, 
    0.15194811f, -0.13366163f, -0.20745498f, 0.07866281f, 0.07881384f, -0.03608822f, -0.06129693f, -0.05839783f, 
    -0.12839340f, 0.01372521f, -0.02248982f, -0.06165973f, -0.26579601f, -0.05174810f, -0.09103635f, -0.04048505f, 
    0.08977628f, 0.18859413f, 0.00351965f, 0.07830542f, -0.17347895f, -0.02661094f, 0.05112813f, 0.07085249f, 
    -0.05740548f, 0.41295132f, -0.52826393f, 0.35274911f, 0.10971242f, -0.00618377f, 0.03212886f, 0.17094645f, 
    0.04277542f, -0.19894272f, 0.04110125f, 0.20646583f, -0.05574319f, 0.31558108f, -0.02777400f, 0.07445300f, 
    -0.03692912f, -0.04762611f, -0.05420714f, -0.23584835f, 0.05434762f, 0.21240312f, 0.04277490f, -0.06019920f, 
    -0.20696206f, -0.09046204f, -0.22338639f, 0.03059724f, 0.05775012f, -0.13403606f, -0.03560856f, -0.25098658f, 
    -0.16801719f, -0.05833858f, 0.10215928f, -0.03272391f, 0.06820513f, -0.14155617f, -0.02378441f, 0.11118744f, 
    0.05198199f, 0.08566411f, -0.02538192f, 0.07072098f, 0.00379780f, 0.03765866f, 0.08812611f, -0.16422459f, 
    -0.07593418f, 0.02480643f, 0.04717152f, 0.36711976f, 0.03337936f, -0.00008279f, 0.05601455f, -0.04570332f, 
    -0.04328673f, 0.05997597f, 0.05211500f, 0.07183184f, 0.13819143f, -0.03794201f, 0.07588663f, 0.01979391f, 
    0.37358874f, -0.05921308f, 0.08919159f, 0.13826226f, -0.18300775f, 0.06132706f, 0.12992176f, 0.04050201f, 
    -0.15547824f, -0.14328755f, -0.03553424f, 0.08049891f, -0.02718661f, 0.20481206f, -0.06554954f, -0.06014721f, 
    0.02472148f, -0.07637480f, -0.01102199f, -0.00671127f, 0.02528537f, 0.35370672f, -0.28230849f, 0.12068617f, 
    -0.00033619f, -0.10208987f, -0.06893332f, -0.12169699f, 0.02395114f, 0.01075241f, 0.05944407f, -0.02638730f, 
    -0.53658706f, 0.08739120f, -0.13765125f, 0.12927163f, -0.03909168f, 0.14932054f, 0.03978389f, -0.08114202f, 
    -0.03331873f, -0.14379014f, -0.01996811f, 0.01612293f, 0.07411421f, -0.08875910f, 0.02140761f, 0.11013746f, 
    -0.00341736f, -0.02762410f, -0.02662130f, 0.00528894f, -0.04364345f, 0.00402813f, -0.05775486f, -0.02890091f, 
    -0.44889420f, 0.73736060f, -0.36953345f, -0.31079528f, 0.15542217f, -0.01521448f, -0.11632156f, 0.03117085f, 
    -0.46214774f, -0.13286926f, -0.07687214f, 0.06010910f, -0.08443306f, -0.29748946f, -0.01980519f, 0.24034382f, 
    0.11549539f, -0.01340658f, -0.00193668f, -0.05671988f, -0.08124977f, 0.00530890f, -0.10620783f, 0.07585166f, 
    -0.13433900f, -0.08882571f, -0.06655177f, 0.16914751f, 0.11369508f, 0.01015171f, -0.04139419f, -0.06408985f, 
    0.06596553f, 0.09003430f, -0.02529824f, 0.14788090f, 0.08528176f, -0.01747462f, 0.30094475f, 0.03855331f, 
    -0.10292634f, -0.02350470f, 0.05511786f, 0.02395289f, 0.12762906f, 0.03291149f, 0.14332354f, 0.08611698f, 
    0.17954890f, 0.01069423f, 0.16003585f, 0.13610624f, -0.09937923f, -0.03178444f, -0.11544840f, 0.14811280f, 
    -0.09316898f, -0.11764943f, 0.19968681f, 0.02023639f, -0.32291645f, 0.74886197f, -0.02672982f, -0.13053705f, 
    -0.03193402f, 0.15780079f, -0.10784267f, 0.01006840f, -0.41610572f, -0.11608319f, 0.10064834f, -0.04503488f, 
    0.70670176f, 0.08082169f, 0.24979052f, 0.06070980f, 0.18015009f, -0.04273625f, -0.20159280f, 0.10191388f, 
    0.01960480f, 0.14013179f, 0.00842049f, 0.09313519f, -0.31722605f, -0.03355626f, -0.06776039f, 0.20982921f, 
    0.01341663f, -0.03233081f, 0.00091559f, 0.03566166f, 0.03422427f, 0.00705603f, -0.02312555f, 0.00085381f, 
    0.08096757f, 0.35127813f, 0.08887095f, 0.03277579f, -0.00945147f, 0.06061855f, -0.05452317f, -0.08812913f, 
    0.00740612f, -0.05549797f, -0.06715651f, 0.10988422f, -0.06489290f, 0.27285907f, 0.46389461f, -0.15923090f, 
    -0.14790930f, 0.07098227f, -0.14971362f, -0.15104274f, -0.06756406f, -0.01852135f, 0.00482378f, 0.02280711f, 
    -0.12805730f, 0.00115654f, -0.18798721f, -0.07223541f, 0.04780464f, -0.08811111f, 0.02931922f, -0.20359141f, 
    0.07226626f, 0.16972989f, 0.23366246f, -0.28050235f, 0.60229003f, -0.27919826f, 0.41795519f, 0.00796586f, 
    -0.26593101f, -0.02432227f, -0.13985653f, 0.01505488f, -0.02232169f, 0.02789595f, 0.16290583f, 0.01624937f, 
    0.31001222f, -0.19986574f, -0.20273234f, -0.30042759f, 0.15559164f, -0.06615135f, -0.08136704f, 0.04043740f, 
    -0.04523482f, -0.03102694f, -0.00991965f, 0.00575229f, -0.13679816f, -0.00981815f, 0.24248478f, 0.30017829f, 
    0.16148451f, 0.14545690f, -0.02138475f, 0.10255647f, 0.07930734f, -0.04087640f, 0.03768364f, -0.03909893f, 
    0.04699584f, 0.02521191f, 0.04394767f, 0.03761460f, 0.02601937f, 0.18862830f, 0.00452700f, -0.06611083f, 
    -0.09162992f, 0.01722650f, 0.06423103f, 0.00087387f, -0.13949673f, -0.08119941f, 0.00236753f, 0.06347343f, 
    0.01522792f, 0.09300926f, -0.05978719f, -0.15147859f, 0.07443067f, -0.04043867f, -0.04767919f, 0.11951407f, 
    0.03204479f, 0.08276008f, 0.16890976f, -0.03470807f, -0.13066624f, 0.02805905f, -0.00214854f, 0.03136249f, 
    -0.09090711f, 0.06550966f, -0.03835574f, 0.00249993f, 0.12385273f, -0.02424548f, -0.03817342f, -0.15819895f, 
    0.01201711f, -0.13872895f, -0.03315031f, 0.00560377f, 0.04709776f, -0.06722349f, 0.11942705f, -0.12044966f, 
    0.05197739f, -0.00652054f, 0.02737697f, -0.14063717f, -0.15636665f, -0.01248531f, -0.04072621f, 0.00929942f, 
    -0.05119016f, -0.06468341f, -0.04949046f, -0.26216248f, -0.23552816f, 0.13636048f, -0.27079439f, 0.06318790f, 
    -0.05703411f, -0.31089786f, -0.01593077f, -0.15110280f, -0.07022980f, 0.15182154f, -0.35034582f, 0.04503107f, 
    -0.34083438f, -0.10206179f, 0.43971729f, 0.18962996f, 0.08756881f, -0.02988894f, -0.13380003f, -0.01950072f, 
    -0.11784934f, -0.02737272f, -0.06572634f, -0.12113282f, 0.28078678f, 0.12359708f, -0.26246354f, 0.11679713f, 
    0.03014137f, -0.19666056f, 0.03403759f, 0.05183473f, -0.04597310f, -0.01731133f, -0.04173787f, 0.11729682f, 
    0.44010180f, 0.02890306f, -0.05185006f, -0.55410874f, 0.03120084f, -0.21239124f, -0.11890142f, -0.06378142f, 
    -0.06247835f, -0.16143882f, 0.05214168f, -0.20752908f, -0.03051701f, -0.03896288f, -0.04617520f, 0.07082888f, 
    0.00009016f, -0.04538685f, -0.08186426f, 0.08120141f, -0.02453656f, 0.09390397f, 0.02026441f, -0.00273273f, 
    -0.46352789f, -0.61898273f, -0.09304850f, -0.09543152f, -0.00066950f, 0.02309027f, -0.04113370f, 0.00364960f, 
    -0.20096773f, 0.11360037f, -0.05407342f, 0.02910982f, 0.66610903f, -0.14753601f, 0.05899592f, -0.20613153f, 
    -0.12905601f, 0.10709437f, 0.04111662f, -0.11537931f, -0.01611134f, -0.04147182f, -0.03860622f, 0.04631056f, 
    -0.01085400f, -0.21299849f, 0.03572758f, 0.12891473f, 0.04097741f, 0.10667431f, 0.11229588f, 0.17857936f, 
    0.05523344f, 0.06721317f, -0.12929943f, 0.00530361f, -0.03301749f, -0.30434236f, 0.08584537f, -0.09195607f, 
    0.11016048f, -0.00505261f, -0.10629284f, -0.07567770f, -0.05277216f, -0.04381337f, 0.00504315f, -0.04914116f, 
    -0.06200618f, -0.21512374f, -0.03430156f, 0.20812607f, -0.01500656f, -0.24528800f, -0.06291316f, -0.09968058f, 
    0.05478739f, 0.00946032f, -0.09628715f, 0.11023512f, 0.08273577f, -0.10308082f, -0.01542693f, 0.13349853f, 
    0.18141542f, -0.01285123f, 0.06640492f, -0.01518807f, 0.01537830f, 0.09344327f, 0.05048458f, 0.16835083f, 
    0.06424426f, 0.19701160f, -0.07801186f, 0.10702060f, -0.25995383f, 0.02927339f, -0.17677553f, -0.02728425f, 
    0.17628740f, -0.17010258f, -0.02326919f, -0.05468245f, -0.39281422f, 0.01575175f, 0.04803605f, 0.18703587f, 
    -0.12164440f, 0.02688166f, -0.08668602f, 0.10637809f, 0.03539499f, 0.11022536f, -0.08067051f, -0.00763652f, 
    -0.04913177f, 0.02139621f, -0.09072651f, 0.09860617f, -0.01597589f, 0.00903327f, -0.02000409f, 0.00044213f, 
    -0.17867613f, 0.01457639f, 0.06726810f, -0.06674431f, -0.42042044f, -0.06404595f, -0.28123918f, -0.16137785f, 
    0.21108317f, -0.07731099f, 0.13614111f, -0.06640825f, 0.02697611f, 0.00512511f, 0.00379535f, -0.25264296f, 
    -0.02904934f, -0.33389696f, 0.30732763f, -0.35608977f, -0.02851588f, 0.09573606f, -0.03805494f, 0.07676914f, 
    -0.06786942f, 0.03451173f, 0.03061799f, 0.00873664f, 0.12937187f, -0.10292284f, -0.16872858f, 0.28826967f, 
    0.08268366f, -0.02522092f, 0.01654624f, 0.01968540f, 0.02841481f, -0.14257716f, 0.16603427f, 0.03796487f, 
    0.13310011f, -0.11079440f, -0.22572386f, -0.13308604f, -0.01180138f, 0.04340851f, 0.06897718f, -0.00205746f, 
    0.13660561f, 0.06289364f, 0.14544445f, -0.05727530f, -0.60576105f, 0.36309326f, -0.06471699f, 0.29985049f, 
    -0.27593729f, 0.06454188f, -0.16268721f, -0.03666580f, 0.08211483f, 0.12677570f, 0.04920210f, 0.07030068f, 
    -0.22610618f, 0.06048168f, 0.14695378f, 0.05408980f, -0.03757387f, -0.06927613f, -0.06822910f, -0.02854808f, 
    -0.04277695f, -0.04609149f, 0.11319946f, -0.09097043f, -0.07472292f, 0.73405719f, -0.14678638f, 0.19135581f, 
    0.18311235f, 0.13687657f, -0.08733927f, -0.02187121f, -0.00329117f, 0.04087139f, 0.13096961f, -0.09508798f, 
    0.07563777f, 0.00661880f, -0.00313665f, -0.17893319f, -0.05514490f, -0.05943206f, -0.22226033f, 0.07915910f, 
    0.02916975f, -0.15395020f, -0.01391333f, -0.03186541f, -0.15717275f, -0.25379336f, -0.05429748f, 0.26034960f, 
    -0.05863706f, -0.00140231f, 0.13545248f, 0.06067842f, 0.06556649f, 0.04830407f, -0.09655296f, 0.12115982f, 
    -0.06026206f, 0.03656417f, 0.10426778f, 0.07822613f, 0.03129315f, -0.00103103f, 0.01259373f, -0.11091115f, 
    0.04834050f, 0.19883484f, 0.16796759f, 0.29609352f, -0.08680800f, -0.03933534f, 0.08154421f, 0.08557015f, 
    -0.07534207f, -0.07022841f, -0.07813132f, 0.00218173f, 0.01077957f, 0.01165736f, -0.06002997f, 0.09851561f, 
    -0.07115079f, -0.18495892f, -0.11708856f, 0.14525779f, -0.14356473f, -0.14757273f, 0.08550544f, -0.02765922f, 
    -0.04271859f, -0.00083836f, 0.06541521f, -0.02607165f, 0.01140477f, 0.09981494f, 0.14919038f, 0.09018454f, 
    -0.03999391f, -0.09703037f, 0.03847918f, -0.00419432f, 0.03913944f, 0.01078596f, -0.00555263f, -0.03810564f, 
    0.05777333f, -0.29122108f, 0.02040203f, 0.09470847f, -0.17649087f, -0.11773986f, -0.08000032f, 0.01352444f, 
    -0.04872302f, 0.05964814f, -0.01081902f, -0.03749358f, -0.08223462f, -0.04811712f, -0.09078694f, -0.02661706f, 
    -0.11376175f, 0.01184921f, -0.03226297f, 0.02018713f, 0.23783875f, 0.08005346f, 0.07534485f, 0.23568371f, 
    0.03411253f, -0.05524120f, -0.01055186f, 0.02459256f, 0.17498164f, -0.03873490f, -0.02198816f, -0.06870389f, 
    0.03065446f, -0.00405934f, -0.04427252f, -0.03071863f, -0.22481512f, -0.63100100f, -0.12271425f, -0.41140062f, 
    -0.03269726f, 0.01106764f, 0.07122351f, -0.08621930f, 0.04810540f, -0.03680001f, 0.04176976f, -0.04703475f, 
    0.29620746f, 0.18612492f, -0.09955987f, 0.21562204f, -0.02525898f, 0.12441485f, 0.02266395f, -0.07587341f, 
    0.11980575f, -0.04926307f, 0.01119600f, -0.07110013f, 0.02282190f, -0.00862048f, -0.03265730f, -0.07053995f, 
    -0.08082093f, 0.02471289f, -0.05905024f, 0.07667228f, 0.03233252f, 0.15028965f, -0.19823597f, 0.00703352f, 
    0.13104226f, 0.12799068f, 0.09577759f, -0.14551789f, 0.01395064f, -0.00298701f, -0.01406694f, -0.15111193f, 
    0.08973213f, -0.21375699f, -0.06875321f, 0.04583098f, -0.10273080f, -0.52785701f, -0.37994680f, -0.39264679f, 
    0.03479092f, 0.05882280f, 0.03249021f, 0.01011453f, 0.09201307f, 0.00385559f, -0.09981482f, -0.03171558f, 
    0.11736420f, -0.27417618f, 0.51228064f, 0.05552556f, 0.03471163f, -0.16403928f, -0.10352819f, 0.04763855f, 
    0.01222291f, 0.06345534f, -0.04626492f, 0.15888117f, 0.11506431f, -0.18714802f, 0.14409778f, -0.08719636f, 
    -0.06274244f, 0.03612278f, -0.09391654f, 0.10135234f, 0.00772511f, -0.13510403f, -0.10702684f, -0.05995255f, 
    -0.11034187f, 0.08773471f, -0.09737966f, -0.04410065f, 0.00095073f, 0.01283755f, -0.03378634f, 0.02558505f, 
    -0.09576362f, 0.05725116f, -0.10729563f, -0.09001361f, 0.05929296f, 0.19831954f, 0.25751334f, 0.26944578f, 
    -0.08439492f, -0.09205785f, 0.03316119f, 0.22526895f, 0.07762162f, 0.01220543f, 0.04686739f, 0.00459796f, 
    -0.05506080f, 0.00478885f, 0.05404212f, 0.07134227f, -0.07462259f, -0.08507842f, -0.25581139f, -0.03411267f, 
    -0.08254018f, -0.07010150f, 0.06493869f, -0.03604340f, -0.08533270f, 0.08283651f, -0.12894177f, -0.18893757f, 
    0.03651168f, 0.02813907f, 0.00916676f, 0.06984808f, -0.11677011f, -0.19767892f, 0.01140924f, -0.18096358f, 
    -0.01209475f, 0.15216719f, 0.13508235f, 0.15131527f, 0.07866239f, -0.08085517f, 0.00973914f, 0.02033247f, 
    0.05515734f, -0.03870595f, -0.00727993f, -0.06956357f, -0.12851700f, -0.12734737f, 0.17535982f, -0.11013101f, 
    -0.15497075f, 0.14881307f, -0.27510285f, -0.01536575f, -0.01922281f, -0.03169288f, -0.08187658f, -0.06155873f, 
    -0.05138391f, 0.12381871f, 0.22946207f, 0.01327616f, -0.12387172f, -0.14327379f, -0.17672735f, 0.08450302f, 
    -0.07219749f, -0.03194663f, -0.13287979f, -0.12905580f, -0.06309057f, -0.03306873f, -0.01370068f, 0.03163121f, 
    0.00554337f, -0.00328842f, 0.00396793f, -0.12879363f, 0.02949991f, 0.01592079f, 0.01855061f, 0.02196819f, 
    0.28873301f, -0.51080656f, 0.17087962f, 0.05203755f, 0.03866754f, 0.13417563f, -0.00993952f, -0.12621731f, 
    -0.03754243f, 0.06366813f, -0.05423656f, -0.18306366f, 0.10946369f, 0.29091272f, 0.06089321f, 0.07458926f, 
    0.00223668f, -0.05180552f, 0.01568212f, 0.00534815f, 0.04257331f, -0.09760432f, 0.08377270f, 0.00224272f, 
    0.09425295f, 0.07598472f, 0.14658056f, 0.17260563f, -0.04499069f, -0.07646321f, 0.05825550f, 0.07406040f, 
    0.19733310f, 0.03026471f, 0.13296914f, 0.18158256f, 0.04648047f, -0.09130097f, 0.00227670f, 0.11037692f, 
    0.03871958f, -0.09885991f, 0.03700166f, -0.14609940f, 0.09178580f, -0.13142970f, -0.00033160f, 0.12739034f, 
    -0.24734780f, 0.05612345f, -0.10080991f, -0.03617651f, 0.10810975f, 0.04478222f, -0.20890024f, -0.18316713f, 
    0.01003459f, -0.01781090f, -0.00996645f, 0.08623220f, 0.15958470f, -0.28209689f, 0.03016436f, 0.01408177f, 
    0.02909831f, 0.05283188f, 0.11169288f, -0.14700715f, 0.01596719f, -0.03476991f, -0.04212591f, -0.01672381f, 
    0.10221137f, 0.11874339f, -0.20729722f, -0.12394312f, -0.07133953f, 0.00993523f, 0.06171044f, -0.09236106f, 
    0.00805098f, -0.26116699f, -0.06499623f, -0.08183206f, -0.08639448f, 0.14738031f, -0.02939184f, 0.05957066f, 
    0.03288556f, 0.00979166f, 0.01097813f, -0.01052698f, -0.10796375f, -0.10240930f, -0.03348329f, 0.00744961f, 
    0.12366777f, 0.05317123f, 0.13703677f, 0.24011821f, -0.00694332f, 0.04252572f, 0.09676132f, -0.01884566f, 
    0.03807374f, -0.02325132f, -0.05620380f, -0.01833595f, 0.09800676f, 0.02773769f, -0.23359163f, 0.03035799f, 
    -0.10414256f, -0.08041844f, -0.04376001f, 0.10710739f, 0.04504243f, -0.05993976f, -0.02679942f, -0.23192014f, 
    -0.01236977f, 0.00885871f, -0.02826872f, -0.04237673f, 0.11299223f, -0.02343445f, 0.07742066f, -0.09767626f, 
    -0.16871372f, -0.01143705f, -0.01689542f, -0.03791805f, -0.10614124f, 0.35119292f, -0.48186839f, 0.01041456f, 
    0.10315455f, -0.01313477f, -0.04861127f, -0.17975770f, -0.08439632f, 0.01591161f, -0.03039001f, -0.08156680f, 
    -0.08664839f, -0.22535039f, -0.03514801f, 0.13399915f, -0.22302273f, -0.02199563f, -0.08689831f, 0.05967150f, 
    0.00493045f, -0.04878235f, 0.04324790f, -0.18247350f, 0.09229215f, 0.36215886f, 0.09541587f, 0.09580261f, 
    0.15557548f, 0.01761683f, 0.08604120f, -0.06350743f, 0.00869891f, -0.01312308f, 0.03128771f, 0.00546473f, 
    -0.05499795f, 0.04696937f, 0.01180903f, 0.14611888f, -0.13103883f, -0.13008761f, 0.06540079f, 0.02146326f, 
    0.09626193f, -0.08066624f, -0.01473088f, 0.00775118f, 0.01947405f, 0.07846512f, -0.01843018f, 0.06261171f, 
    -0.10261560f, -0.15271804f, -0.07502156f, 0.00460499f, -0.03117461f, -0.03283931f, 0.03553839f, -0.03296169f, 
    0.09799239f, -0.20902511f, -0.04209386f, 0.16242190f, -0.00324234f, -0.01863949f, 0.11021587f, -0.07032946f, 
    0.04722343f, -0.08532489f, 0.06449375f, 0.12789369f, -0.19461475f, -0.01821353f, -0.08298848f, 0.04478918f, 
    0.01737184f, 0.07065878f, 0.01482360f, 0.05517573f, -0.00855835f, 0.00333752f, -0.04745997f, -0.08617676f, 
    -0.15103991f, -0.17665881f, -0.13099273f, -0.06310669f, -0.00855674f, -0.00579436f, -0.02526490f, 0.21613370f, 
    0.06894188f, 0.14095919f, -0.05581838f, -0.09569004f, 0.20473471f, -0.17619996f, 0.15754765f, -0.23836768f, 
    0.12719777f, -0.08550281f, -0.10126086f, 0.08226243f, -0.10055239f, 0.02307038f, 0.00158553f, -0.21695724f, 
    0.14066264f, 0.28360820f, -0.31043047f, 0.09517179f, 0.06736105f, 0.23013653f, 0.05945585f, 0.01310006f, 
    0.02642214f, 0.00040636f, 0.10434748f, -0.05438734f, -0.13131846f, -0.04968232f, 0.26501709f, 0.17949317f, 
    -0.10855229f, -0.09399414f, -0.03399107f, -0.01106657f, -0.07765138f, -0.02813103f, -0.15728442f, -0.02229565f, 
    -0.22994874f, -0.11830276f, -0.06549056f, -0.06442840f, -0.17451131f, 0.05500549f, -0.03705708f, 0.05230329f, 
    -0.15835048f, -0.16669025f, -0.04740185f, 0.15086241f, -0.30951342f, -0.09405121f, -0.22059199f, -0.21401092f, 
    0.03185863f, 0.02094069f, 0.02309752f, 0.04899114f, 0.01178267f, -0.06052181f, -0.04661709f, -0.09222484f, 
    0.01485576f, -0.05045564f, -0.10528737f, -0.04186356f, 0.07712922f, 0.07131144f, 0.02437554f, 0.05034866f, 
    0.11366089f, -0.00540877f, 0.02524506f, -0.00071504f, 0.05377515f, 0.00049325f, -0.34932020f, 0.10279984f, 
    0.03025905f, -0.07755733f, -0.00182922f, -0.11334106f, 0.13789314f, -0.07274494f, 0.18579452f, 0.37060669f, 
    0.05289999f, 0.20623867f, 0.14358865f, 0.18024895f, -0.04114879f, 0.00671548f, 0.06603400f, 0.09203366f, 
    -0.00605857f, -0.01615240f, 0.09159760f, 0.02767389f, 0.06756467f, 0.20717889f, -0.15210937f, 0.08206055f, 
    -0.04715174f, -0.10170789f, -0.01916676f, -0.06971309f, -0.15363218f, -0.05868425f, -0.11513953f, -0.06470536f, 
    -0.05380260f, -0.03612744f, 0.04299618f, 0.00031544f, -0.17622559f, 0.01187885f, 0.06346279f, 0.03976766f, 
    -0.02091614f, -0.03814545f, -0.02787274f, -0.07388976f, -0.01855862f, 0.05468824f, 0.08140795f, 0.13950999f, 
    -0.11824019f, -0.09811515f, 0.06612471f, -0.06525048f, -0.06184036f, 0.04571575f, -0.01258014f, 0.03066241f, 
    0.09360624f, 0.04158237f, 0.09061301f, 0.13215353f, 0.20030423f, -0.06078533f, 0.04940661f, 0.02820921f, 
    0.06083178f, -0.07278976f, -0.10340143f, -0.02089695f, 0.13995713f, -0.00705765f, 0.09878572f, -0.13215211f, 
    0.01132837f, -0.01353133f, -0.03781750f, -0.05556469f, 0.09102943f, 0.03108417f, 0.08178395f, 0.01499558f, 
    0.01083678f, 0.02482124f, 0.06824792f, 0.04781979f, -0.11342467f, -0.04870091f, -0.06129405f, -0.04735205f, 
    -0.09114124f, 0.00880041f, -0.06672453f, -0.02384999f, 0.10230614f, -0.09313623f, -0.11201404f, -0.03674218f, 
    -0.00444478f, 0.03758398f, 0.02427541f, 0.10987501f, -0.16094263f, -0.11467378f, -0.14907564f, -0.09035596f, 
    -0.00583455f, 0.01545869f, -0.39545229f, -0.04084410f, 0.05517348f, 0.02882454f, -0.01331430f, 0.03965351f, 
    0.07474457f, -0.00583852f, -0.00899912f, -0.03170327f, -0.41349110f, 0.08529311f, -0.10106247f, -0.08497887f, 
    0.06496086f, 0.05818682f, -0.13474387f, -0.07250509f, -0.10743134f, 0.07351383f, 0.03655196f, -0.00065416f, 
    0.08424839f, 0.06258342f, 0.07417428f, 0.07689638f, 0.04089057f, -0.22520287f, 0.06601759f, 0.01781408f, 
    0.04173917f, 0.03628640f, -0.09429804f, -0.07388603f, -0.01781579f, 0.27578408f, -0.14848475f, 0.11211366f, 
    0.15069093f, 0.02175591f, 0.01200883f, -0.06526285f, -0.00769107f, 0.00473593f, -0.00774055f, -0.13466717f, 
    -0.06123246f, 0.00570787f, -0.11260949f, -0.00672780f, 0.10682485f, -0.03240445f, 0.04793998f, -0.11102290f, 
    0.15865695f, 0.05003647f, -0.12239522f, -0.09209295f, -0.26680881f, -0.31143424f, 0.00466303f, -0.09939002f, 
    -0.19037345f, -0.00186145f, -0.11538817f, -0.18217328f, 0.05643352f, 0.00059651f, -0.06010047f, 0.11075279f, 
    -0.02665861f, 0.12365367f, -0.14347184f, -0.03018527f, -0.01856600f, -0.09350571f, 0.04754913f, -0.28542024f, 
    0.07134166f, 0.03599614f, -0.09640772f, -0.02766453f, 0.07136563f, 0.25854239f, 0.11304556f, 0.13439226f, 
    -0.03235422f, 0.06160725f, 0.08467982f, 0.07617274f, -0.01358833f, -0.05242616f, -0.09674623f, -0.05516933f, 
    0.15249987f, -0.02178456f, -0.09537006f, 0.11955690f, 0.05083818f, -0.00818659f, -0.02933216f, 0.02009915f, 
    -0.08941204f, -0.24496506f, -0.01883299f, -0.51366723f, -0.09673988f, -0.06160448f, -0.12741594f, -0.22335060f, 
    0.00976309f, -0.05087836f, 0.04942630f, 0.11534508f, -0.02064760f, -0.21698087f, -0.00319740f, -0.07253151f, 
    -0.20577648f, -0.17254040f, 0.14161408f, -0.01240570f, -0.00407208f, 0.05023468f, 0.02389823f, -0.03162624f, 
    -0.08071846f, 0.01901281f, 0.10658886f, 0.04060737f, 0.06254455f, 0.10755039f, 0.17284656f, 0.05700951f, 
    0.16525304f, 0.21702197f, 0.15296337f, 0.12311668f, -0.03172024f, 0.04612431f, 0.04235419f, 0.12992099f, 
    -0.30294707f, -0.11214230f, 0.11115160f, 0.34352738f, -0.10154571f, 0.04497336f, -0.06647528f, 0.13002008f, 
    0.15135370f, -0.12980874f, 0.13778047f, -0.02173636f, -0.23526043f, -0.08932237f, 0.19809367f, -0.19958842f, 
    -0.00737963f, -0.00859813f, 0.08937715f, -0.00761309f, -0.01045647f, -0.27178580f, -0.16162723f, -0.24361980f, 
    -0.04382452f, -0.17784417f, -0.27963549f, 0.00647256f, 0.05608191f, 0.13410658f, -0.03465237f, -0.03226255f, 
    -0.03451360f, -0.08101116f, 0.05059812f, -0.14825244f, -0.24661475f, -0.29236856f, -0.06965817f, 0.39115736f, 
    0.03212921f, -0.01916204f, 0.06646599f, -0.04735583f, 0.06329815f, 0.07957502f, 0.13414578f, 0.06943577f, 
    -0.34801972f, -0.21985729f, 0.01365833f, -0.00426405f, 0.10109585f, 0.05756510f, -0.02277466f, -0.07879657f, 
    0.06569932f, -0.01180698f, 0.00978683f, -0.08826256f, 0.10985658f, -0.14356004f, -0.05568455f, -0.02340786f, 
    0.10091481f, -0.04668949f, 0.05061653f, 0.14065380f, -0.01899196f, -0.16361697f, 0.19441667f, -0.06128072f, 
    -0.26661965f, 0.00250117f, -0.11631372f, -0.02177533f, -0.18321043f, -0.09822673f, -0.10853527f, -0.05852623f, 
    0.28909066f, 0.08220895f, 0.19171679f, -0.04567654f, 0.44578901f, -0.25981888f, -0.48394629f, 0.03127776f, 
    0.01041516f, -0.01808988f, 0.00162352f, 0.02504677f, 0.06708661f, -0.07269352f, -0.01506260f, -0.12633185f, 
    0.21220587f, -0.02102329f, 0.31149146f, -0.39565942f, 0.17133458f, -0.06230439f, -0.01181065f, -0.11310204f, 
    0.00821774f, -0.10566758f, -0.13588937f, -0.03557257f, -0.08169752f, -0.01293421f, 0.25853649f, -0.17865667f, 
    0.08110044f, 0.15249550f, -0.03917394f, -0.00997964f, 0.11833382f, -0.02391531f, 0.01242355f, 0.10585714f, 
    -0.16246653f, 0.03601488f, 0.29111943f, -0.20187272f, 0.08826645f, 0.04472005f, -0.00850040f, 0.17725521f, 
    0.19116001f, 0.00754986f, -0.02475526f, 0.16598368f, 0.07709671f, 0.01920697f, -0.03860220f, -0.01798819f, 
    0.23342918f, 0.20259416f, 0.15288997f, -0.00944992f, 0.04648399f, -0.03612562f, -0.03393245f, 0.09205045f, 
    -0.04720589f, 0.04106291f, -0.04463632f, -0.13027535f, -0.10057475f, 0.05209038f, -0.10583857f, -0.02865350f, 
    0.11698955f, -0.00622611f, -0.08585353f, -0.00620564f, -0.49745393f, -0.41674182f, -0.34397963f, -0.07005464f, 
    0.11242084f, -0.07327492f, 0.01352734f, -0.04377241f, 0.15926081f, -0.15724559f, -0.07417461f, 0.17652129f, 
    0.11641179f, 0.04708787f, -0.14272925f, -0.01926731f, 0.00060616f, 0.12372001f, 0.05225351f, 0.15081920f, 
    0.00497227f, 0.07269065f, -0.00110466f, -0.00741582f, 0.04781698f, 0.01705094f, 0.15823725f, 0.02214411f, 
    0.09110812f, 0.06383678f, 0.07922538f, 0.19775854f, -0.00787015f, -0.00042964f, 0.04940794f, 0.12918252f, 
    0.37043199f, -0.06847763f, -0.21782954f, 0.07685381f, 0.11195161f, 0.06140084f, 0.05147784f, -0.26449126f, 
    0.08024260f, 0.14206372f, -0.07757072f, 0.30148372f, 0.05177569f, 0.10094669f, -0.02479221f, -0.06965283f, 
    0.16595063f, 0.03067910f, 0.11044349f, 0.09853315f, 0.02794084f, 0.01317759f, 0.05021815f, 0.01743741f, 
    -0.09868456f, 0.25841585f, -0.10728094f, -0.04817713f, 0.03686960f, -0.17604628f, 0.00059935f, -0.00640723f, 
    0.09577171f, -0.14337425f, -0.00186886f, 0.11229122f, -0.31177390f, -0.04624806f, -0.15715238f, -0.17429604f, 
    -0.01307889f, -0.00319094f, 0.11178077f, 0.18605667f, 0.03139990f, 0.00182883f, 0.02401016f, -0.10823879f, 
    0.18498671f, -0.10119356f, -0.05104432f, -0.16860479f, -0.03047785f, -0.05353107f, -0.02726233f, 0.09350024f, 
    -0.10451327f, -0.28658184f, 0.02150716f, -0.32969081f, -0.11886997f, -0.07384524f, 0.01122221f, 0.05828866f, 
    0.03622718f, -0.10119428f, 0.01540339f, 0.03531829f, -0.09563229f, 0.09958907f, -0.11814113f, -0.26827028f, 
    0.45644107f, 0.09556645f, -0.23557113f, -0.16902660f, -0.09117876f, 0.08850558f, 0.23389192f, -0.02821093f, 
    0.21255361f, 0.10337118f, -0.05772685f, -0.42001987f, 0.03287260f, -0.30941626f, 0.07088647f, 0.13789149f, 
    -0.17371751f, -0.11052793f, 0.04073960f, -0.04037517f, 0.13943872f, 0.08512276f, -0.05659337f, -0.17731480f, 
    -0.32130894f, -0.30219486f, 0.00084939f, 0.08945175f, 0.06190008f, -0.15512706f, 0.01902558f, -0.00913460f, 
    0.21911114f, 0.06091132f, -0.01867687f, -0.16054434f, -0.12209009f, -0.32834908f, -0.05203584f, -0.04780587f, 
    -0.01177549f, -0.02556786f, -0.02673917f, 0.07833158f, 0.16233918f, 0.07643948f, 0.07706591f, -0.07169617f, 
    -0.15280536f, -0.21911442f, 0.10411410f, -0.04782686f, 0.05480713f, -0.02011655f, -0.03068944f, 0.10947542f, 
    0.01992799f, -0.01962679f, -0.00224854f, -0.09248351f, -0.14708653f, 0.07293450f, -0.21877553f, 0.17634268f, 
    0.34727407f, 0.04814367f, -0.14013697f, 0.05371381f, -0.10668938f, -0.00017560f, 0.06709053f, 0.20132028f, 
    -0.02778193f, 0.04893118f, -0.04209165f, -0.22263759f, 0.00575472f, 0.02324837f, 0.00806914f, 0.08960186f, 
    0.09936811f, -0.05955532f, 0.14353184f, 0.04531595f, -0.14539678f, 0.03070049f, -0.61958504f, 0.15562719f, 
    0.07915995f, -0.01132596f, 0.03226690f, 0.07405881f, 0.01786795f, -0.20707060f, 0.06114627f, 0.26271135f, 
    -0.14066009f, -0.05504322f, 0.20606218f, 0.23022988f, 0.08198544f, 0.10168131f, 0.17720617f, 0.06807041f, 
    -0.11345869f, -0.00144351f, 0.05573241f, 0.35550037f, -0.03765969f, 0.11410587f, -0.24910951f, -0.06765153f, 
    0.11951116f, 0.03252147f, 0.11225147f, 0.05359610f, 0.04222386f, -0.01708850f, -0.09950293f, -0.06417551f, 
    -0.57449126f, -0.13472332f, -0.01018327f, -0.19645891f, 0.01007928f, 0.02562474f, -0.04111218f, -0.10786097f, 
    -0.00353967f, 0.08903080f, -0.11991540f, 0.00071760f, -0.18607251f, -0.03034925f, 0.04631171f, -0.05377141f, 
    0.01752682f, 0.13907827f, 0.07131863f, -0.03375031f, 0.02234404f, -0.02524952f, -0.02083084f, 0.04299180f, 
    -0.07133932f, -0.07997020f, 0.39752081f, 0.03229024f, -0.00136903f, 0.02656196f, -0.00267434f, 0.02519637f, 
    0.01571547f, -0.02253762f, -0.01438476f, 0.02062122f, 0.16500019f, -0.17230952f, 0.26700181f, -0.06173727f, 
    0.21747912f, 0.05562148f, -0.00693576f, -0.03362960f, 0.00929711f, -0.03483899f, 0.00731861f, 0.09216222f, 
    0.30081016f, 0.03377741f, -0.12273374f, 0.21188614f, 0.13258398f, -0.08380414f, -0.08355457f, -0.07501747f, 
    -0.01780182f, 0.05070832f, 0.05897689f, 0.00737989f, 0.22855638f, -0.39678982f, 0.32305220f, 0.07814037f, 
    -0.12448675f, 0.00936809f, -0.00470153f, 0.19438285f, 0.01589773f, -0.03931917f, 0.24550861f, 0.05660046f, 
    -0.14271180f, 0.40413582f, -0.50230438f, -0.34745911f, 0.06575917f, 0.07867260f, -0.11903717f, 0.13025233f, 
    0.05925396f, -0.26213855f, 0.00958394f, 0.03855062f, 0.32024488f, -0.19537106f, 0.26175475f, -0.01686486f, 
    0.08411872f, 0.08863915f, 0.08252466f, -0.01948892f, 0.08563402f, -0.05043273f, -0.03375603f, 0.12827817f, 
    -0.00410698f, -0.07269758f, 0.03292223f, 0.24356344f, -0.13207060f, -0.06432308f, 0.00934421f, -0.04628805f, 
    0.07338103f, -0.00709323f, -0.11782334f, -0.00090624f, 0.02522911f, -0.16077906f, -0.20927082f, -0.10948323f, 
    0.05768389f, 0.10364525f, -0.07209834f, -0.00020685f, 0.06690240f, -0.02305018f, 0.00964593f, 0.00635665f, 
    -0.14205167f, -0.17032328f, -0.08402519f, 0.06491160f, 0.00918860f, 0.01522090f, -0.04030541f, -0.01623523f, 
    0.07665810f, -0.13061966f, 0.11757405f, -0.04701716f, -0.42306119f, 0.13268824f, 0.04544667f, 0.02714996f, 
    -0.00536303f, -0.01130573f, -0.00072389f, 0.06158543f, -0.04715304f, -0.08758521f, -0.39439404f, -0.48108283f, 
    -0.00408133f, 0.22707109f, 0.17555793f, -0.04977028f, 0.15709497f, -0.05783898f, 0.08721276f, -0.23873492f, 
    0.01156857f, -0.06692872f, 0.03406076f, -0.08457571f, -0.07647552f, -0.31790340f, -0.10564309f, 0.08045130f, 
    -0.11035268f, -0.06085955f, 0.01900797f, 0.15112595f, 0.11023940f, -0.09352694f, 0.23050815f, 0.12149075f, 
    0.01662011f, -0.08975258f, -0.17167178f, 0.05415358f, 0.23872179f, 0.14501306f, -0.17364232f, -0.05743762f, 
    0.04703798f, 0.10396475f, -0.02971032f, -0.07609305f, -0.34818172f, -0.18962893f, -0.33289737f, -0.24973607f, 
    -0.05380498f, 0.01573361f, -0.08667820f, -0.02755995f, 0.04600170f, -0.17846678f, 0.05782834f, 0.03663458f, 
    -0.00059304f, -0.07332227f, -0.07884537f, -0.03311818f, 0.10090832f, -0.04901827f, 0.02538778f, -0.05452351f, 
    -0.00201946f, 0.13898298f, 0.07944417f, -0.00037769f, 0.13424180f, -0.13022007f, -0.25239146f, 0.07749092f, 
    0.07286464f, 0.03423401f, 0.03965166f, -0.02399713f, -0.15384173f, -0.10623571f, 0.00688803f, -0.42935202f, 
    0.16453259f, 0.06008381f, 0.20323560f, 0.09755877f, 0.00034661f, 0.12888438f, 0.15423340f, 0.02181590f, 
    0.13824552f, 0.03360345f, 0.02018920f, 0.04315004f, 0.03868880f, -0.04807326f, -0.09419557f, 0.07993829f, 
    0.06545484f, -0.10762823f, -0.05499148f, 0.01538172f, -0.10433421f, -0.05116633f, -0.03457029f, 0.18601267f, 
    0.02302228f, -0.28488618f, -0.33929640f, 0.42856643f, 0.02723596f, 0.03654798f, 0.07045593f, 0.00030792f, 
    0.06762102f, -0.03521417f, 0.00931849f, 0.03198668f, -0.12664975f, 0.00600812f, -0.28859851f, -0.35744500f, 
    0.00144768f, 0.01760731f, -0.06650872f, 0.14071575f, 0.04929138f, -0.09578195f, 0.00503003f, 0.18561310f, 
    0.06048336f, 0.17591988f, -0.02471661f, -0.13908023f, 0.14084554f, -0.12452079f, 0.08590572f, -0.08383132f, 
    -0.03018679f, -0.01503314f, -0.00453846f, 0.02127935f, -0.03038431f, -0.17122337f, -0.42769817f, -0.08386891f, 
    0.11405268f, 0.13068616f, -0.06889047f, 0.14682913f, -0.01424331f, 0.05172660f, -0.13935064f, -0.14793937f, 
    0.07116002f, -0.10314484f, -0.26646832f, 0.05922247f, -0.04172342f, -0.06455813f, 0.01112733f, -0.02960176f, 
    -0.15452123f, -0.04525581f, -0.00601305f, -0.20971256f, -0.09723432f, 0.07494364f, -0.26836893f, -0.32017285f, 
    0.07521221f, -0.06744125f, 0.09231380f, 0.02940833f, -0.13926037f, 0.13384010f, 0.03777405f, -0.07770552f, 
    -0.14740565f, -0.10962857f, 0.19809954f, -0.15788193f, 0.05062068f, -0.07657432f, 0.09044302f, -0.05261561f, 
    0.18254718f, 0.13791949f, 0.10387125f, -0.01241904f, -0.04035578f, -0.05213241f, 0.07560489f, -0.19766663f, 
    0.15396459f, 0.05751977f, -0.05032951f, -0.08926975f, -0.05494962f, 0.01557317f, 0.09704413f, -0.04662250f, 
    0.13754743f, 0.11764213f, -0.06824630f, -0.11595745f, -0.01539954f, 0.06416793f, 0.01317404f, 0.02417548f, 
    0.08283700f, 0.06608996f, -0.04321388f, 0.08026366f, -0.22287332f, 0.02158299f, -0.00362741f, 0.04707526f, 
    -0.04602167f, 0.09179313f, 0.09923369f, 0.10560483f, 0.06745268f, 0.03693664f, -0.02617561f, 0.05803612f, 
    -0.42884582f, -0.55804640f, -0.04971400f, 0.24407850f, -0.17739435f, 0.04296231f, 0.08793078f, 0.02810055f, 
    -0.00266917f, 0.05416508f, 0.09572275f, -0.18587488f, -0.43964732f, -0.54092175f, -0.38446239f, 0.14571296f, 
    0.03477639f, -0.02056398f, -0.10968965f, -0.54506671f, -0.01107422f, -0.02280476f, -0.03431920f, 0.00567711f, 
    -0.14163716f, 0.03600906f, 0.23666409f, -0.08509230f, -0.07426847f, 0.01461249f, -0.04386838f, 0.01215626f, 
    0.00689796f, 0.14252584f, 0.02863269f, -0.05539799f, 0.00417411f, 0.02707277f, -0.03041912f, -0.00034673f, 
    -0.00774246f, 0.01641482f, -0.02672975f, 0.12386011f, 0.11975615f, 0.08159593f, 0.24818003f, 0.06064793f, 
    0.18373434f, -0.09673775f, 0.01109692f, -0.02930589f, 0.04779058f, 0.04838697f, 0.08916063f, -0.00379176f, 
    -0.01656923f, -0.03037365f, -0.04311157f, -0.00819496f, 0.08817466f, 0.09115186f, -0.18880455f, -0.30620134f, 
    -0.00574170f, -0.04079397f, -0.03737756f, 0.04076713f, -0.08676814f, -0.03863886f, 0.01376793f, -0.12355105f, 
    0.01517413f, -0.16468285f, -0.18592700f, -0.12980780f, -0.05798468f, 0.16661520f, 0.06222723f, 0.02041676f, 
    -0.08148737f, -0.03315797f, 0.01783968f, -0.01312245f, -0.02772399f, 0.30503288f, -0.08706605f, 0.03028950f, 
    -0.09504645f, 0.10508891f, -0.01969326f, -0.06677443f, 0.01839802f, -0.00695954f, 0.07226151f, -0.00755026f, 
    -0.48850885f, 0.01363547f, 0.35772902f, 0.20662071f, -0.04618191f, -0.04708129f, -0.16280857f, -0.09943251f, 
    -0.06950799f, -0.24734369f, 0.09601384f, 0.05308688f, 0.04350927f, 0.05157544f, -0.02722666f, -0.11292166f, 
    -0.03121369f, 0.02849597f, -0.03937565f, 0.05732573f, -0.05746391f, -0.01061290f, -0.00176139f, -0.16836900f, 
    -0.24367239f, -0.28544605f, 0.01122099f, 0.17791946f, 0.15420605f, 0.12563628f, -0.04878487f, 0.00329294f, 
    0.07370987f, 0.05033482f, 0.02183608f, -0.03307545f, -0.17369959f, -0.15454637f, -0.15763523f, -0.12650572f, 
    -0.06381925f, -0.17701340f, -0.04144675f, 0.09749479f, -0.03499488f, -0.01176827f, -0.02287481f, -0.03371176f, 
    0.08341695f, -0.34531146f, -0.14338735f, 0.13350445f, 0.07496011f, -0.17549977f, 0.18736015f, 0.18570001f, 
    -0.00236447f, 0.19445209f, -0.15835954f, -0.10788234f, -0.92796892f, -0.75566316f, -0.54027545f, -0.58464110f, 
    -0.30146566f, -0.58617526f, -0.19816618f, -0.35628316f, -0.05940485f, -0.00651231f, -0.02734006f, 0.00193650f, 
    0.27043658f, 0.28575227f, -0.14130573f, 0.16288589f, -0.07076666f, -0.25069755f, -0.01542288f, 0.06254121f, 
    0.07747948f, -0.00267423f, -0.03907485f, -0.06790152f, -0.00772436f, -0.00086415f, 0.09549475f, 0.05135157f, 
    0.01978905f, -0.00578610f, 0.01395234f, -0.02597550f, -0.00389791f, 0.16107276f, 0.04504164f, 0.05152444f, 
    0.36700603f, -0.18663287f, -0.25620231f, -0.05969713f, -0.04311367f, 0.15124746f, 0.23656636f, 0.00891656f, 
    0.05197418f, -0.09160743f, -0.03823077f, -0.01775699f, -0.20583807f, -0.20159130f, -0.42557469f, 0.57864702f, 
    -0.09080181f, -0.02288009f, -0.13641739f, 0.04922739f, 0.01426371f, -0.03437442f, 0.05781320f, 0.01753390f, 
    -0.02449944f, 0.42582697f, 0.01306839f, 0.13878052f, 0.04461628f, -0.09152332f, -0.03542218f, -0.13754810f, 
    0.00703872f, -0.11831520f, 0.16275428f, 0.07332412f, -0.47428378f, -0.59263080f, -0.53286052f, -0.41348910f, 
    -0.11689097f, -0.28478795f, -0.07995684f, -0.23544224f, -0.01576069f, -0.04371799f, 0.03042124f, -0.05059431f, 
    -0.05208792f, -0.30027825f, 0.14067030f, -0.01420875f, -0.06242706f, -0.08072834f, -0.09320538f, -0.04929123f, 
    -0.00053116f, 0.02817097f, 0.10062537f, 0.02057537f, 0.15484142f, 0.15423594f, 0.20121974f, 0.06554805f, 
    0.01745238f, -0.01085739f, -0.06157092f, 0.10337815f, -0.09874328f, 0.06080119f, -0.02598106f, 0.01805443f, 
    -0.29728264f, 0.27558985f, -0.20187543f, -0.15221335f, -0.12788419f, 0.04206103f, -0.07262975f, 0.01422347f, 
    -0.00355286f, 0.09539668f, 0.04208516f, 0.03780200f, 0.05899900f, -0.06752663f, -0.10774534f, -0.05209719f, 
    -0.01396853f, 0.09729395f, 0.12138101f, -0.01300408f, -0.02063993f, 0.02771256f, -0.03907017f, 0.00844173f, 
    0.26789156f, 0.31798968f, -0.07079365f, -0.04965461f, 0.01812616f, 0.02876704f, 0.07536858f, 0.14640722f, 
    0.05210585f, 0.11801422f, 0.27668604f, -0.06365333f, -0.06733324f, -0.17724738f, 0.03317813f, 0.13235694f, 
    -0.14794055f, 0.10938643f, -0.03376323f, 0.03481719f, -0.05214586f, -0.06098294f, -0.04022254f, 0.04440530f, 
    -0.04417512f, -0.04456815f, 0.23752470f, 0.22145444f, -0.00019978f, -0.00042430f, -0.05813197f, -0.02240881f, 
    -0.02375577f, -0.09791723f, -0.02682362f, 0.21123202f, 0.18622091f, 0.29193658f, 0.11629567f, 0.22962093f, 
    0.01167170f, -0.06213696f, -0.04941391f, 0.07293474f, -0.05297979f, -0.06587183f, 0.15993063f, 0.12261530f, 
    -0.23446824f, -0.32998356f, -0.40025318f, 0.16121149f, -0.02610254f, 0.22396910f, 0.20334494f, 0.03459153f, 
    0.00864059f, -0.03963961f, 0.03330872f, 0.02805877f, 0.08720466f, -0.00881183f, -0.12762009f, -0.30675977f, 
    -0.03642362f, -0.04771893f, 0.10087745f, 0.08519570f, -0.07827248f, -0.01201372f, -0.10214443f, 0.00631823f, 
    0.18300825f, 0.03539398f, -0.02265050f, 0.04185024f, 0.09212360f, -0.07466206f, 0.03439014f, 0.05533359f, 
    0.00584928f, 0.05187346f, -0.05338980f, -0.10953281f, 0.17175665f, -0.03016995f, 0.22136824f, 0.00322766f, 
    -0.04773039f, 0.04994198f, 0.13461381f, -0.26175627f, 0.02383367f, 0.04030816f, 0.06404118f, 0.08210199f, 
    -0.14575437f, -0.04446292f, 0.64827859f, 0.15688297f, -0.19015856f, -0.33343804f, 0.16089368f, 0.01442551f, 
    -0.14486824f, 0.05199676f, 0.08871434f, -0.15012626f, -0.44743365f, -0.65426666f, -0.13703665f, 0.17515661f, 
    0.19169840f, 0.10536984f, 0.15756519f, -0.25230673f, -0.00417961f, -0.01937349f, 0.03438842f, 0.07081913f, 
    -0.08108731f, -0.12622075f, 0.32871634f, -0.43381417f, 0.00800280f, 0.02470949f, -0.02489883f, 0.06939122f, 
    0.05386792f, 0.19460703f, 0.07014059f, 0.18405993f, -0.22071609f, -0.38723823f, -0.00337130f, -0.18631177f, 
    -0.11757556f, -0.03703268f, -0.13955346f, 0.04755142f, -0.03095951f, -0.01321558f, 0.03336391f, -0.02311900f, 
    -0.07517096f, -0.17913662f, -0.28901765f, -0.02676362f, -0.02564647f, 0.11918988f, -0.03406812f, -0.10628229f, 
    0.02990978f, -0.02801188f, 0.08380633f, 0.06749773f, 0.02778420f, -0.03047841f, -0.12320084f, 0.03953861f, 
    -0.00739358f, -0.00744435f, 0.03339773f, 0.08072998f, -0.04281132f, -0.02977250f, 0.05463730f, 0.01568043f, 
    0.12918922f, -0.06900613f, -0.02157059f, 0.07665249f, 0.03965171f, 0.01567034f, 0.07336350f, 0.13031042f, 
    0.02014912f, 0.12778132f, -0.06373665f, -0.15133356f, -0.07729522f, -0.05694608f, -0.06777945f, 0.08118595f, 
    -0.12050745f, -0.04331908f, 0.18795341f, 0.19377060f, 0.04387232f, 0.07879066f, -0.06767438f, 0.03894585f, 
    0.25870129f, -0.06298663f, 0.09001212f, -0.18094625f, 0.05822687f, -0.03975177f, 0.01265677f, -0.07371557f, 
    0.04849403f, -0.01260479f, 0.02247018f, -0.00911227f, -0.27182156f, -0.50883025f, -0.10945378f, 0.09507667f, 
    -0.03039750f, 0.13655546f, 0.05057181f, 0.03401339f, -0.00610747f, -0.01157925f, 0.01072646f, -0.05660144f, 
    -0.07063051f, 0.13510366f, -0.15848042f, 0.11131677f, -0.14725485f, 0.08227959f, -0.05606644f, 0.09762599f, 
    -0.01054624f, -0.11270058f, 0.09857329f, -0.10310170f, -0.21526565f, 0.06045970f, 0.05483494f, -0.38993615f, 
    -0.01293978f, 0.04892288f, 0.03449931f, -0.00207860f, 0.00034957f, 0.04742210f, -0.06504297f, 0.04662951f, 
    -0.02192770f, 0.03850023f, -0.12445229f, -0.04611895f, -0.02974934f, 0.03870629f, -0.06237106f, 0.04983769f, 
    -0.09814385f, -0.19277628f, -0.13770829f, -0.17076881f, 0.06315123f, -0.11787043f, -0.05003225f, 0.02230906f, 
    -0.08060978f, 0.08892531f, 0.04245058f, 0.09498673f, 0.03346601f, 0.07828867f, 0.31906262f, 0.12217007f, 
    -0.54311687f, -0.61755967f, -0.54708701f, -0.12742361f, -0.21090853f, 0.07197550f, -0.20607953f, -0.37871781f, 
    0.01400627f, -0.05864651f, 0.03486660f, 0.03290654f, -0.20621826f, 0.02211037f, 0.13005832f, 0.35006568f, 
    -0.04007232f, -0.14245822f, 0.23723674f, 0.04452958f, -0.04148716f, 0.06630594f, 0.03207369f, -0.05329985f, 
    0.15040208f, 0.09310431f, -0.10083238f, -0.19780107f, 0.06696735f, -0.03521229f, -0.01793835f, 0.02057110f, 
    0.02756910f, -0.03577825f, -0.08474257f, 0.03591911f, -0.66259515f, 0.14243768f, 0.19932853f, 0.42804337f, 
    -0.07933293f, -0.15092012f, 0.00985126f, 0.04120576f, -0.05653398f, 0.05732381f, 0.06741250f, -0.01413034f, 
    -0.05433684f, 0.02848209f, -0.04265174f, 0.01515832f, -0.02705470f, 0.10496216f, 0.11171105f, -0.16909535f, 
    0.05184726f, -0.02703560f, 0.00697875f, 0.02660751f, 0.07868201f, 0.11649573f, -0.08631631f, -0.20407155f, 
    0.00824564f, -0.05277739f, 0.05893312f, 0.03077272f, 0.10991129f, 0.26029778f, 0.05216334f, 0.09472509f, 
    -0.27944598f, -0.55211568f, -0.57149488f, 0.01432433f, -0.22333577f, -0.23012173f, -0.08734509f, -0.26886305f, 
    -0.08617816f, -0.01666280f, -0.00571918f, -0.04013802f, 0.02401297f, 0.05147597f, 0.09521773f, 0.05309194f, 
    0.03736945f, -0.06890728f, -0.01453714f, 0.05291637f, -0.07538020f, -0.09113242f, -0.00342107f, 0.00735690f, 
    -0.13894793f, 0.16277225f, 0.29279143f, -0.18747310f, 0.02381576f, 0.00496992f, 0.10188013f, -0.07055907f, 
    0.00207651f, -0.00778750f, -0.00738670f, -0.02755135f, 0.08630079f, 0.02581461f, 0.04783209f, 0.11308232f, 
    -0.04663392f, 0.03795134f, -0.00925795f, 0.11163676f, 0.05133260f, -0.03339607f, 0.01011609f, -0.04704605f, 
    0.00399764f, -0.11446203f, 0.15835819f, -0.04168367f, 0.01431095f, -0.09871214f, -0.01075016f, -0.16806893f, 
    -0.06479224f, -0.03259182f, 0.00893583f, -0.10366488f, -0.04892157f, 0.00653537f, 0.04748397f, -0.01376006f, 
    0.19560464f, 0.13542752f, 0.00029829f, -0.13521554f, 0.05428671f, -0.01696713f, 0.00067389f, 0.08534767f, 
    0.28627589f, 0.05297406f, -0.06810750f, -0.13249072f, -0.05484968f, -0.04901565f, 0.16554902f, -0.08236121f, 
    0.02598959f, -0.02546097f, -0.03235415f, 0.02526033f, -0.25898442f, 0.40733671f, -0.09156597f, -0.07320029f, 
    -0.00543761f, 0.05141459f, -0.02836581f, -0.08825596f, 0.00478579f, 0.13240102f, -0.08131594f, -0.00922850f, 
    0.03016037f, -0.03393026f, 0.08025038f, -0.15251216f, 0.11338049f, 0.09614572f, -0.17105955f, 0.04872789f, 
    0.01584742f, 0.12751868f, -0.03072534f, 0.13045944f, 0.22054304f, -0.29563352f, -0.39445344f, -0.11330849f, 
    -0.08293134f, 0.08445042f, 0.14323497f, -0.16245086f, 0.03941172f, -0.02091796f, -0.02746031f, -0.03021326f, 
    -0.03854416f, -0.21205163f, -0.07198736f, 0.00745847f, -0.02030801f, 0.02842372f, 0.04414833f, 0.01954167f, 
    0.03752182f, 0.03823349f, 0.00113135f, -0.06122011f, 0.27371484f, -0.25245380f, -0.07053433f, -0.22495043f, 
    -0.11614235f, -0.07956786f, -0.06018918f, 0.01799069f, 0.15190443f, 0.01334876f, 0.02842893f, 0.01308197f, 
    0.10239168f, -0.42288041f, 0.15777017f, -0.04829280f, -0.10138151f, 0.03302316f, -0.06727348f, 0.18336929f, 
    -0.00200051f, 0.01197711f, -0.05760436f, -0.01755369f, -0.33883905f, -0.22191949f, 0.13376810f, -0.07443919f, 
    0.14726943f, -0.01091732f, -0.03260637f, 0.16476305f, 0.00145848f, -0.07564489f, -0.04643721f, -0.05734551f, 
    0.41784063f, 0.22532415f, -0.25544813f, -0.26008549f, 0.06772503f, -0.08534516f, -0.03436768f, -0.07770769f, 
    -0.15786569f, 0.10716787f, -0.11756287f, -0.16268699f, 0.29287028f, -0.38187256f, 0.07890849f, -0.20087351f, 
    0.01041069f, 0.00637179f, -0.04478705f, -0.10591868f, 0.12099818f, -0.07531592f, 0.02057088f, -0.04114511f, 
    -0.00549711f, 0.09518853f, 0.04374538f, -0.05781421f, -0.08832035f, 0.02385057f, -0.02758119f, -0.02583799f, 
    -0.02294742f, 0.01882431f, 0.00632097f, -0.02169310f, -0.07783259f, -0.04575790f, -0.14514360f, -0.02822230f, 
    0.02786765f, -0.03295568f, 0.03890576f, -0.03721346f, 0.06709596f, -0.00041271f, -0.06095136f, -0.06467215f, 
    -0.02687436f, 0.02193076f, -0.06846674f, -0.05586570f, -0.01167028f, -0.00206516f, -0.02700418f, -0.09853365f, 
    0.02832407f, 0.02277089f, 0.03455023f, -0.00719172f, 0.00501099f, -0.01068539f, -0.06739919f, -0.00975629f, 
    -0.01356695f, 0.01441431f, -0.00179545f, -0.09048694f, -0.18556751f, -0.02298956f, -0.12707798f, 0.07970990f, 
    0.33403111f, 0.05144151f, -0.11200240f, 0.05107202f, 0.10348812f, 0.01985659f, 0.05895337f, -0.07135107f, 
    -0.05904620f, 0.01797558f, 0.10050865f, 0.00415091f, 0.00807713f, 0.01286654f, 0.04087823f, -0.03507468f, 
    0.09414361f, 0.01621941f, -0.04738807f, -0.02162414f, 0.04154232f, -0.03076204f, 0.01614051f, -0.00928299f, 
    -0.00143902f, -0.33278075f, 0.09713959f, -0.05544060f, 0.00542591f, 0.18626858f, 0.13391177f, 0.01275718f, 
    0.11557039f, -0.02212768f, -0.02621253f, 0.04386603f, 0.02291161f, -0.07667393f, 0.15824142f, -0.02965021f, 
    0.02168463f, -0.18287283f, 0.13610655f, 0.01992122f, 0.04408127f, 0.00815636f, -0.00040541f, -0.01686774f, 
    0.03298241f, -0.12190866f, 0.21007766f, -0.20896553f, -0.12536319f, 0.07626355f, 0.02502775f, -0.17718095f, 
    -0.00191342f, -0.03568604f, -0.04772593f, -0.02189113f, -0.37176412f, -0.25822580f, -0.25773346f, 0.47531998f, 
    0.00386599f, 0.07484826f, 0.06819101f, -0.00127005f, -0.00194913f, 0.02159297f, 0.00891415f, 0.04069447f, 
    -0.52421725f, -0.10193162f, -0.38643265f, -0.03047588f, -0.07145069f, -0.06842278f, 0.04756105f, -0.04298860f, 
    -0.10096624f, -0.01570960f, 0.01359857f, 0.03970879f, -0.00195603f, 0.01944926f, -0.06603303f, -0.01462086f, 
    -0.00431123f, 0.01984708f, -0.01055614f, -0.00338189f, -0.10083301f, -0.03035048f, -0.11883979f, -0.01889107f, 
    -0.15271428f, -0.01814529f, -0.01649147f, 0.01836335f, -0.03325202f, -0.09005925f, -0.08115834f, -0.00992232f, 
    -0.01738965f, -0.00321738f, 0.03966790f, 0.01464023f, 0.01222162f, -0.46935430f, 0.10369809f, -0.33368334f, 
    0.14617839f, -0.15828599f, 0.02767532f, 0.04080079f, -0.02210838f, 0.04537027f, -0.04037414f, 0.03390336f, 
    0.08246008f, -0.01093765f, 0.10175674f, 0.02769164f, 0.07385211f, -0.22778980f, 0.06429316f, -0.12524302f, 
    -0.23577170f, 0.16116589f, -0.01619865f, -0.01234367f, -0.24006271f, -0.25190860f, -0.27458915f, 0.31395072f, 
    0.05538232f, 0.03799669f, -0.11503013f, 0.03500259f, 0.03166767f, -0.00357735f, -0.05430066f, -0.02904028f, 
    0.18229665f, 0.11912496f, -0.08443243f, -0.16303022f, -0.00523172f, 0.01773202f, -0.00068971f, 0.05640146f, 
    -0.01791635f, 0.10332375f, 0.00399097f, -0.11174921f, 0.14009489f, -0.24037221f, -0.18435375f, -0.12907280f, 
    0.00181111f, 0.06399001f, -0.04427793f, -0.04354991f, 0.15939514f, -0.03970868f, 0.06403883f, 0.04170023f, 
    -0.07690044f, -0.43300429f, -0.29604152f, -0.15456194f, -0.14218852f, -0.03544087f, 0.07397815f, 0.00761346f, 
    0.16861930f, 0.04387403f, 0.06528389f, -0.00356729f, 0.03307287f, 0.09829323f, -0.02119386f, -0.00499531f, 
    -0.03611841f, -0.02137992f, 0.04445365f, -0.04128474f, -0.02387444f, 0.05037060f, -0.00000894f, 0.04486804f, 
    -0.38514626f, 0.12856880f, -0.05208633f, 0.22854988f, -0.04876423f, -0.10549494f, 0.03957143f, 0.01163766f, 
    -0.07436855f, -0.08403759f, -0.01152376f, -0.02321154f, 0.09813137f, 0.00523998f, 0.03497994f, -0.25166366f, 
    -0.09045617f, 0.10143312f, 0.01356881f, -0.02563559f, -0.07613894f, 0.03832691f, 0.04533404f, -0.15327744f, 
    0.13895802f, 0.05165880f, -0.13152206f, -0.07799669f, 0.00684671f, 0.07688112f, 0.00541064f, 0.00612763f, 
    -0.07587446f, -0.01859975f, 0.16922735f, 0.03138851f, -0.09272663f, -0.27897733f, -0.08768412f, -0.09723379f, 
    0.02527817f, 0.00128383f, -0.01521203f, -0.03487453f, 0.07749891f, -0.05636720f, -0.09208020f, -0.00821517f, 
    -0.02050372f, -0.14576074f, -0.08898699f, 0.04091012f, -0.07429133f, -0.07009065f, 0.05227410f, 0.03210727f, 
    -0.03472362f, 0.01478381f, 0.00953071f, 0.00640459f, -0.06214488f, 0.10922906f, -0.14585522f, 0.04479457f, 
    0.00507723f, -0.09631442f, -0.01092951f, -0.03791654f, -0.01870266f, 0.03683460f, 0.00126010f, -0.00972647f, 
    -0.01414004f, -0.07088397f, 0.09556419f, -0.02481648f, 0.00867595f, -0.04060539f, -0.04272445f, -0.01049308f, 
    0.00232376f, -0.13150540f, 0.02694991f, -0.03531979f, -0.03105248f, 0.30171168f, -0.26293641f, 0.28464758f, 
    -0.02497846f, 0.14689158f, -0.04287048f, -0.03623237f, -0.18124177f, -0.00654863f, -0.10703261f, 0.02761612f, 
    0.48172429f, 0.00429826f, -0.20150027f, -0.12053175f, -0.17389287f, 0.01973238f, -0.12294773f, 0.08626436f, 
    0.01535852f, -0.07032446f, -0.06276587f, -0.07643194f, -0.64927322f, 0.55349755f, 0.27937478f, 0.06608171f, 
    0.09183440f, -0.21244062f, 0.00895382f, 0.13408519f, 0.03003927f, 0.05864136f, 0.00006442f, 0.02941931f, 
    0.52656794f, -0.39988831f, -0.50775099f, -0.70660317f, -0.07319189f, -0.02350431f, -0.23198763f, 0.10834786f, 
    0.11009964f, 0.12090515f, -0.04964083f, 0.06742521f, 0.02843727f, -0.34616262f, -0.14769647f, -0.23657714f, 
    -0.12784711f, -0.12533244f, -0.05642775f, 0.00178490f, 0.00534209f, 0.04431009f, -0.02203768f, -0.02161978f, 
    0.08235432f, 0.03805596f, -0.03452923f, -0.01530523f, -0.07922947f, -0.06024045f, -0.06085198f, 0.00218715f, 
    0.03974850f, 0.02600316f, -0.05739900f, 0.00291229f, 0.09082028f, -0.03883607f, -0.06358375f, 0.01533324f, 
    0.13893297f, -0.03966195f, -0.00752380f, -0.02876481f, -0.00304680f, -0.03266644f, -0.00495360f, 0.01655886f, 
    -0.05881524f, -0.01559880f, 0.13627379f, -0.08635652f, -0.07982726f, 0.03899921f, -0.07051917f, -0.05482807f, 
    -0.13808802f, 0.00458725f, 0.00305798f, 0.02647866f, -0.21667930f, -0.06600401f, 0.16155848f, -0.18390031f, 
    -0.06667777f, -0.09765115f, -0.01679388f, -0.05843194f, 0.00236344f, -0.00697389f, -0.00702413f, -0.03359070f, 
    -0.30399573f, 0.25744835f, 0.21922857f, 0.18726011f, -0.03048600f, -0.06703134f, 0.16451733f, 0.14658852f, 
    -0.01736763f, -0.04107968f, 0.03338145f, 0.04878870f, 0.06992015f, -0.39620909f, 0.07156319f, 0.05320083f, 
    0.04392982f, 0.13090628f, 0.03361049f, -0.05636812f, 0.03505682f, -0.01280236f, -0.05786252f, -0.02571297f, 
    0.24177386f, 0.04877478f, 0.00408912f, 0.01760462f, 0.05798556f, -0.07493661f, -0.02757613f, -0.10724986f, 
    -0.12679157f, 0.06189152f, 0.00433567f, -0.06510333f, 0.03003247f, 0.03553731f, -0.11960955f, 0.10466670f, 
    0.05375684f, 0.01199416f, 0.05422953f, -0.03463484f, 0.03535938f, 0.00886547f, -0.01775278f, -0.01570236f, 
    0.05664730f, -0.04479612f, 0.04270429f, -0.06341216f, -0.01372747f, -0.00736484f, 0.00642416f, -0.03711928f, 
    0.05172115f, -0.06139304f, -0.03205416f, -0.08105978f, 0.09940448f, -0.07841478f, 0.03786348f, 0.08813265f, 
    0.04410317f, -0.01647390f, -0.03642659f, -0.08236399f, 0.08945363f, -0.12612680f, -0.00604215f, 0.12837659f, 
    -0.29801890f, -0.32878223f, -0.05932181f, 0.29265127f, 0.19407304f, 0.11881335f, 0.15525535f, 0.15224528f, 
    -0.01412533f, -0.08265372f, -0.05610894f, -0.04838533f, 0.28107467f, -0.56632239f, 0.10434879f, -0.43466219f, 
    -0.05550821f, 0.16309731f, -0.04587967f, 0.02712729f, 0.05838411f, 0.03393403f, -0.06661847f, -0.17562845f, 
    -0.01273490f, 0.07036342f, 0.01212580f, 0.10854042f, 0.03345837f, -0.04593532f, 0.07429162f, -0.01276448f, 
    -0.00223767f, -0.02910383f, -0.00098442f, -0.04427984f, 0.08844648f, -0.49075758f, -0.45420697f, -0.46536767f, 
    -0.01275457f, -0.01496204f, 0.00526519f, 0.11930302f, 0.06490866f, 0.03193880f, 0.06649545f, -0.00279295f, 
    -0.00207667f, -0.01417734f, 0.07632526f, -0.04431348f, 0.05606081f, -0.00909709f, -0.02277310f, -0.08554517f, 
    0.01411202f, 0.01137412f, 0.02663636f, 0.06801329f, 0.08392756f, 0.03198216f, -0.03303710f, -0.00905155f, 
    0.00385557f, -0.08216826f, 0.03613465f, -0.03413000f, 0.06133596f, 0.03527263f, 0.02613593f, 0.01458133f, 
    -0.06977710f, -0.43918738f, 0.42578274f, 0.25820199f, -0.06980678f, -0.01142527f, -0.20873788f, 0.01891881f, 
    -0.00360371f, 0.00824822f, -0.01791816f, -0.08005598f, 0.04313016f, 0.07793143f, 0.04728590f, -0.11632942f, 
    0.01293784f, 0.04255099f, -0.02808044f, -0.05345747f, -0.06084183f, -0.00935173f, -0.09822912f, -0.25438163f, 
    -0.09954030f, 0.13522759f, -0.20786300f, -0.03799177f, 0.00183419f, -0.02953468f, 0.04683224f, -0.04632797f, 
    -0.00518169f, 0.08716422f, -0.01935573f, -0.03084051f, -0.28271228f, 0.23220389f, -0.12287340f, 0.21333241f, 
    0.01813751f, 0.01760527f, 0.21091008f, -0.00335506f, -0.06081082f, 0.02097035f, -0.05051382f, -0.01531582f, 
    0.02613225f, 0.06776956f, -0.04428047f, 0.08874149f, 0.05552108f, 0.03348896f, 0.06081135f, -0.08489098f, 
    0.00614398f, 0.00413925f, -0.03011450f, -0.00483033f, -0.04319932f, 0.11694323f, 0.04716456f, -0.05541164f, 
    -0.11951407f, 0.06674305f, 0.02460538f, 0.01185172f, 0.05954889f, 0.03697279f, 0.06809743f, -0.03055689f, 
    -0.05531377f, 0.12749097f, -0.08620986f, -0.00117304f, -0.04763037f, -0.07792510f, 0.04203444f, 0.05872387f, 
    -0.03338264f, 0.16643997f, 0.01911267f, 0.01075632f, -0.19013466f, 0.13387512f, -0.06715875f, 0.05111479f, 
    0.07829517f, -0.16837382f, 0.22063835f, 0.09063767f, 0.02762155f, -0.02777223f, 0.05184370f, 0.05162234f, 
    0.15142414f, 0.00413386f, 0.09003172f, -0.12504853f, -0.17669240f, 0.04773597f, -0.18161386f, 0.07047860f, 
    -0.01515181f, -0.02692031f, -0.02683443f, -0.07929386f, -0.31969833f, -0.14103621f, 0.07950438f, -0.02773968f, 
    0.00321446f, 0.06702307f, -0.12322465f, 0.05073861f, -0.03128042f, -0.00056876f, -0.01872598f, 0.00189368f, 
    -0.03643873f, -0.04515387f, -0.07871666f, 0.01355994f, 0.05917225f, 0.03176770f, 0.00707559f, 0.02210655f, 
    -0.17453280f, -0.13532259f, -0.29877257f, -0.33301073f, -0.08322878f, -0.13700779f, -0.12190919f, -0.02942748f, 
    0.13384870f, 0.04502118f, 0.01892341f, 0.12006983f, -0.09987477f, -0.09388793f, -0.26193893f, -0.15361822f, 
    -0.07241563f, -0.09166154f, -0.15717195f, 0.01744652f, 0.22562292f, 0.06122614f, 0.08287297f, -0.05643651f, 
    -0.03990516f, -0.04407168f, -0.15127684f, -0.08557579f, 0.16865517f, 0.05110771f, -0.17522934f, -0.05854415f, 
    -0.02384393f, -0.10200024f, -0.09343525f, -0.10531396f, -0.03511666f, 0.03145493f, -0.00338275f, 0.03333598f, 
    0.26879123f, -0.07189209f, -0.22649834f, -0.22446540f, -0.12002441f, -0.04565282f, 0.00883646f, -0.06063025f, 
    0.25240943f, -0.02651320f, 0.10618395f, 0.06397494f, -0.09219249f, -0.07613178f, -0.00751392f, -0.17796853f, 
    0.06358515f, 0.04018867f, 0.02968325f, 0.00222855f, -0.03415630f, 0.05390188f, -0.00571914f, -0.36767775f, 
    -0.20815250f, 0.06398881f, 0.05431015f, 0.13877447f, -0.00183221f, 0.02011874f, -0.01769901f, 0.05045883f, 
    -0.11680385f, 0.03019532f, 0.00826715f, 0.02276450f, -0.05538047f, 0.20989858f, -0.08154862f, -0.09985830f, 
    -0.02231580f, 0.02667549f, -0.04362991f, -0.09377174f, -0.04513410f, -0.00408482f, -0.10741438f, 0.16058138f, 
    -0.18804735f, 0.12922458f, 0.09048259f, 0.02314219f, 0.03422389f, -0.07515219f, -0.05999542f, -0.07560050f, 
    -0.02540789f, -0.01759608f, 0.04525175f, -0.01628434f, 0.00858991f, -0.03087674f, -0.05627185f, -0.03870306f, 
    -0.01442803f, 0.09568522f, 0.07693823f, -0.01015629f, 0.08164440f, -0.04472540f, 0.05546959f, 0.02761928f, 
    -0.02628512f, -0.21236418f, -0.00204531f, -0.07524481f, -0.13457863f, 0.04286050f, 0.16008976f, -0.00498491f, 
    -0.00869232f, 0.13022064f, 0.14280587f, 0.03576209f, -0.15484881f, 0.26234248f, 0.10422719f, -0.14550707f, 
    -0.11580198f, -0.02544004f, -0.03575944f, -0.05322067f, -0.02720303f, 0.02394244f, -0.19135721f, -0.01202508f, 
    0.28943026f, -0.00916088f, -0.03886952f, -0.26889101f, -0.22364214f, -0.04993827f, -0.12925354f, -0.20866188f, 
    -0.02231611f, 0.16287927f, -0.05382795f, -0.00139336f, 0.11089577f, -0.21314202f, -0.06475531f, -0.08964785f, 
    0.06775511f, -0.13118497f, -0.01347125f, -0.11274810f, -0.00098748f, 0.17119527f, 0.12529553f, 0.21085095f, 
    0.31121635f, -0.14341247f, 0.07171863f, -0.01634049f, 0.04190202f, 0.02988062f, -0.02911079f, 0.02430026f, 
    -0.03248067f, 0.12999806f, 0.04047254f, -0.02165430f, -0.26907152f, -0.55974537f, -0.36542729f, -0.17186980f, 
    0.16427600f, -0.04910647f, 0.03401785f, 0.20359284f, 0.04949512f, 0.04503222f, 0.01894042f, 0.04339723f, 
    -0.27895775f, -0.13687222f, 0.09952018f, 0.23915607f, 0.13158287f, -0.02928055f, 0.17756420f, 0.02119399f, 
    0.04035678f, 0.00995214f, 0.16865024f, 0.06672484f, -0.14626692f, -0.03353652f, 0.03966035f, -0.02344149f, 
    -0.05047574f, 0.00819009f, -0.04807089f, -0.00742071f, 0.05160993f, 0.03305382f, 0.10929050f, -0.01962678f, 
    -0.19238998f, -0.04418211f, 0.03194807f, 0.12300325f, 0.04761650f, 0.02181646f, -0.18465985f, -0.05683475f, 
    0.00901070f, -0.00184993f, 0.00687999f, -0.00683546f, 0.36896077f, 0.02384286f, -0.16455753f, -0.17178796f, 
    -0.13372634f, 0.00154303f, 0.09404277f, -0.16286469f, -0.02020897f, 0.03752625f, 0.01921506f, 0.08319369f, 
    0.07559050f, -0.07103340f, 0.33155063f, 0.15374251f, 0.18319061f, 0.10360266f, 0.03069790f, 0.10329735f, 
    0.10575727f, 0.10873847f, 0.02232116f, -0.00861732f, -0.10922092f, -0.37621331f, -0.31533581f, -0.13279755f, 
    -0.01359911f, -0.05975087f, -0.12523423f, 0.05761859f, 0.03690119f, 0.02386170f, -0.01703099f, 0.09268293f, 
    0.05250990f, 0.05830787f, -0.20602620f, -0.14039342f, -0.21544325f, 0.04392613f, -0.06974787f, 0.07002890f, 
    0.12266689f, 0.07344192f, 0.09702538f, 0.16010353f, -0.30991712f, -0.35893470f, -0.12229285f, 0.07889356f, 
    -0.03954768f, 0.07708964f, 0.06320703f, 0.11860732f, 0.03748379f, -0.03064910f, -0.09989289f, -0.05428378f, 
    -0.07214057f, -0.22641304f, -0.15237714f, -0.03975328f, 0.08324775f, 0.04589997f, 0.11863388f, 0.12905227f, 
    -0.26187029f, -0.17852890f, -0.38813099f, -0.21635295f, -0.07905316f, 0.04267240f, 0.05584143f, -0.03096583f, 
    -0.07847075f, 0.01015262f, -0.04045063f, -0.13466163f, -0.11833223f, -0.00444218f, -0.12224864f, -0.04110334f, 
    -0.38442108f, -0.10836960f, 0.09275393f, 0.04624211f, -0.00397394f, 0.14389417f, -0.08327331f, 0.05585922f, 
    -0.16467950f, -0.06114026f, -0.10440185f, -0.01736107f, 0.08781844f, 0.14759567f, -0.09377092f, -0.01844906f, 
    0.03166699f, -0.03598801f, -0.01128747f, 0.02727311f, 0.08653566f, 0.02686583f, 0.05702960f, 0.15647164f, 
    -0.12269825f, 0.01893530f, -0.11587250f, 0.12676419f, -0.02310678f, 0.05833261f, -0.00940039f, -0.01513589f, 
    0.14993235f, 0.07225327f, 0.04835407f, 0.07008149f, -0.33575416f, -0.04911333f, -0.00524254f, 0.01755089f, 
    -0.02510361f, 0.10069747f, 0.01020609f, 0.01529168f, -0.01251190f, -0.04051679f, 0.00605237f, -0.03404466f, 
    0.26481783f, -0.02076936f, 0.06916215f, -0.02367308f, 0.04677323f, -0.00086024f, -0.06519394f, -0.03018271f, 
    -0.00122267f, 0.05011091f, -0.01167838f, -0.04502179f, -0.18966301f, -0.04965452f, 0.06694636f, 0.09206790f, 
    0.01239605f, 0.04982178f, 0.00964001f, 0.07658392f, -0.03698079f, -0.04665913f, -0.01700503f, -0.01999504f, 
    -0.21782935f, -0.06794937f, 0.03208971f, -0.01219891f, -0.01752475f, 0.03323232f, 0.03058546f, 0.02240830f, 
    0.00291294f, 0.04984643f, 0.07592279f, 0.05419547f, -0.39336908f, -0.03866421f, 0.17050287f, 0.18907939f, 
    0.04800275f, -0.09316313f, -0.13422143f, 0.04265672f, -0.15313722f, 0.05220718f, 0.12312192f, -0.08835723f, 
    0.30287573f, 0.10113890f, -0.45678219f, -0.41447356f, 0.11356210f, -0.16531278f, 0.08290049f, 0.09613340f, 
    0.03356413f, 0.10809860f, -0.04975440f, 0.05775944f, -0.36310551f, -0.14608310f, -0.05660747f, 0.04614998f, 
    0.00766097f, 0.08278509f, -0.15569517f, -0.33679834f, -0.15075693f, -0.02399574f, 0.01911072f, 0.02770511f, 
    -0.28401715f, -0.36838859f, -0.17553814f, -0.24767067f, 0.07220494f, 0.10124685f, 0.13849296f, 0.03582822f, 
    -0.06478655f, 0.05818789f, -0.02401277f, -0.27897251f, -0.01292485f, -0.22110464f, -0.14586690f, -0.10418447f, 
    0.09349895f, 0.11426675f, 0.04963005f, 0.07862034f, 0.01435242f, 0.04468868f, -0.04618334f, 0.01646296f, 
    0.08587646f, 0.08841869f, 0.01337320f, -0.27546436f, 0.00225748f, -0.06056294f, -0.04177696f, -0.02134719f, 
    -0.05275857f, 0.04077010f, -0.04288547f, 0.09206355f, 0.28278470f, 0.11383167f, -0.05282304f, 0.00091802f, 
    0.02359037f, -0.03771844f, -0.04216680f, -0.05494095f, 0.07414874f, 0.07731957f, 0.02610611f, 0.03810291f, 
    -0.08454183f, 0.03063703f, 0.03626313f, 0.00306599f, 0.01986464f, -0.01594935f, -0.02682095f, 0.04122913f, 
    0.02705432f, -0.04826189f, -0.00223035f, 0.02690357f, 0.66448241f, -0.06087308f, -0.19137509f, -0.03280767f, 
    0.18146755f, 0.09229704f, 0.07405045f, -0.18221812f, 0.12159415f, 0.06789017f, 0.11571111f, 0.04195103f, 
    -0.44068575f, -0.09363031f, 0.09115005f, 0.10173566f, -0.07118409f, -0.11550103f, -0.06230715f, 0.12495770f, 
    0.08398119f, 0.00532507f, -0.12172130f, 0.05345906f, 0.44574440f, 0.06037126f, 0.00424147f, -0.29801255f, 
    0.04561739f, -0.03793966f, -0.00518909f, -0.06319679f, 0.08600287f, 0.05707471f, 0.15087880f, 0.05559472f, 
    0.41520393f, 0.02021254f, -0.09957213f, -0.14229436f, 0.12111255f, 0.06621367f, 0.00916136f, 0.00116117f, 
    0.12933534f, -0.07844391f, 0.10825665f, 0.04539565f, -0.36128885f, 0.08743347f, 0.14021787f, 0.11028726f, 
    0.00333551f, -0.08942630f, -0.06218391f, -0.06400177f, 0.03639420f, -0.01336049f, -0.03735881f, 0.01885094f, 
    -0.15574132f, 0.10879350f, -0.04282928f, -0.23134297f, -0.06943318f, -0.03476178f, 0.01477252f, -0.02553607f, 
    -0.04364668f, 0.00320422f, -0.00214995f, 0.06817721f, -0.00514274f, -0.00284012f, 0.07083252f, -0.08334767f, 
    0.07674652f, -0.02357073f, -0.08472034f, 0.01189027f, -0.12457497f, 0.01477221f, -0.03553962f, -0.26990783f, 
    -0.24285595f, -0.31824270f, -0.34706587f, -0.30537653f, -0.06060474f, -0.05512087f, -0.05276050f, -0.01381479f, 
    -0.08031322f, 0.00546213f, -0.04319891f, -0.02608903f, -0.10665698f, -0.10866605f, -0.19399625f, 0.25463989f, 
    0.19502588f, -0.13847201f, 0.07362389f, 0.10486101f, 0.08171710f, 0.00801220f, 0.06160094f, 0.18845518f, 
    -0.29719692f, 0.17399627f, 0.02518477f, -0.00784012f, 0.10036471f, 0.02913757f, -0.10097636f, 0.01885927f, 
    -0.00247253f, 0.13677005f, 0.01018515f, 0.17780077f, -0.58327335f, -0.35380268f, -0.23063004f, 0.33147931f, 
    0.06307706f, 0.10721904f, 0.11359902f, 0.16211805f, 0.05895668f, 0.03110775f, 0.15565631f, 0.15494178f, 
    -0.05904972f, -0.00050051f, 0.02209692f, -0.01485786f, 0.04699549f, 0.04103312f, 0.04333827f, 0.01567962f, 
    -0.04907788f, 0.02194333f, -0.01691219f, 0.01397704f, -0.03217681f, 0.11066474f, -0.09200948f, 0.11808481f, 
    -0.00625503f, 0.06023699f, -0.04639064f, -0.01583268f, -0.05050731f, -0.11422959f, -0.15774535f, -0.25792038f, 
    0.09355073f, -0.06173510f, -0.19314252f, -0.20346518f, 0.09113380f, -0.22060625f, -0.00115101f, 0.07978611f, 
    0.01656964f, 0.02765734f, 0.00919650f, 0.15098870f, 0.10015506f, -0.11707482f, -0.10748016f, -0.17104279f, 
    -0.07059525f, -0.02948335f, -0.01251566f, -0.01278417f, 0.07732986f, 0.01499332f, 0.19235842f, 0.05047047f, 
    -0.43568543f, 0.15363561f, 0.16929993f, 0.09427542f, 0.01845117f, -0.06991912f, -0.15290928f, -0.14798659f, 
    -0.06328732f, -0.06992192f, -0.00630822f, 0.07009501f, -0.21461655f, -0.24036688f, 0.29540575f, 0.17755027f, 
    -0.19228110f, 0.05270376f, 0.02512097f, 0.03402688f, -0.01983531f, 0.02274333f, 0.02195435f, 0.05407172f, 
    0.03010071f, 0.00952902f, 0.00425839f, -0.03354020f, -0.02441016f, -0.00680731f, -0.07807909f, 0.09781710f, 
    -0.04022743f, 0.12808205f, -0.03801075f, -0.00842858f, -0.16016953f, 0.06226644f, 0.13483858f, -0.05232111f, 
    -0.03785111f, -0.10371536f, -0.19793987f, 0.11335506f, -0.19127454f, 0.01474986f, -0.07908644f, -0.06701124f, 
    -0.10860994f, -0.06787857f, 0.10422562f, 0.02908261f, -0.04147378f, 0.09093182f, -0.03798698f, 0.05908583f, 
    -0.12811370f, -0.09214803f, -0.02038455f, 0.01181930f, -0.04786093f, -0.25698996f, -0.08577027f, -0.00764959f, 
    -0.02941866f, 0.04489197f, 0.08216470f, 0.06516505f, -0.05773290f, 0.03088240f, -0.10601684f, 0.10644630f, 
    0.08744009f, -0.02821460f, -0.07792860f, -0.11427877f, 0.01418836f, 0.02507118f, -0.06781607f, 0.05029394f, 
    -0.03861271f, 0.14371039f, -0.00406478f, 0.13001221f, -0.01623908f, -0.10734172f, 0.10792040f, 0.05978412f, 
    0.08021680f, -0.11794695f, 0.04172930f, -0.00775264f, 0.01529149f, 0.02639129f, 0.01736140f, 0.01307805f, 
    0.06080328f, 0.11685717f, 0.03819556f, 0.07256518f, -0.05242144f, -0.11973292f, 0.08152854f, 0.05533702f, 
    0.15219936f, 0.18344590f, 0.17691091f, 0.15656532f, -0.00236702f, 0.12542221f, -0.01267523f, -0.04034809f, 
    -0.15560852f, -0.05821780f, -0.09860636f, -0.17108433f, 0.12615655f, -0.01196578f, 0.04802137f, 0.14655736f, 
    -0.35924464f, -0.18523498f, 0.11811433f, -0.09996805f, 0.05232303f, -0.04357625f, -0.11803570f, -0.13124679f, 
    0.15300578f, 0.04450181f, 0.01634715f, 0.09696415f, -0.31140375f, -0.16355935f, 0.08224767f, -0.18899098f, 
    -0.17437173f, 0.02187306f, 0.02512467f, 0.18014437f, 0.08747564f, -0.00876132f, -0.01862978f, -0.00009616f, 
    -0.35183123f, -0.03558360f, 0.31076673f, 0.47228068f, 0.11504919f, -0.14198270f, -0.09469262f, -0.00383878f, 
    0.01437221f, -0.16818929f, -0.14973262f, 0.11233540f, 0.18281761f, 0.01693209f, 0.31518146f, 0.33534208f, 
    -0.03342272f, -0.00593071f, -0.04468941f, -0.09924458f, 0.10541748f, 0.02016450f, 0.09408677f, 0.08258324f, 
    -0.04437359f, 0.01623264f, 0.00296215f, -0.04379116f, -0.07451486f, 0.15936910f, 0.06514730f, 0.02162682f, 
    0.10444380f, 0.02738765f, -0.01749135f, 0.10267004f, -0.31701872f, -0.04057710f, -0.03888351f, 0.17682409f, 
    0.15811215f, 0.07910803f, 0.06781104f, -0.02491163f, 0.12595500f, 0.05064438f, -0.03985308f, 0.03495083f, 
    0.01000616f, -0.21033604f, -0.65095907f, 0.08576859f, 0.17768255f, 0.05582614f, 0.12403191f, 0.09739904f, 
    0.03210197f, -0.11606326f, -0.00875128f, -0.05805425f, 0.02407565f, -0.06359123f, 0.32595348f, 0.03755046f, 
    0.10737662f, -0.13731124f, -0.12068059f, 0.01164662f, 0.02877547f, 0.05126163f, 0.03481328f, -0.00360844f, 
    -0.11844636f, 0.26829049f, 0.35164368f, 0.00728923f, 0.15092979f, -0.06686822f, -0.13615200f, -0.08874884f, 
    0.00218876f, -0.00982728f, 0.00918607f, 0.00917390f, -0.08130892f, -0.03181680f, -0.12684678f, 0.18098225f, 
    0.00003277f, 0.06005459f, 0.05981997f, -0.00998567f, -0.01452501f, 0.00504247f, 0.06019757f, 0.04898272f, 
    0.15104145f, -0.62449217f, 0.12478881f, 0.03982794f, 0.07013902f, 0.13748457f, -0.16467094f, -0.00560391f, 
    0.02484319f, 0.07655867f, -0.07973761f, -0.04991708f, 0.12454373f, -0.16509329f, 0.07880793f, -0.05623276f, 
    0.05704452f, -0.14936146f, 0.08108390f, 0.02412383f, -0.03381798f, 0.08595715f, -0.14122301f, -0.13765128f, 
    0.08503177f, -0.64011514f, 0.31677940f, -0.10800527f, -0.04410318f, 0.08148694f, -0.17209677f, -0.05049603f, 
    -0.01973202f, -0.02544897f, -0.12826382f, -0.01328954f, -0.13687570f, 0.20270291f, -0.02071141f, -0.03095893f, 
    -0.14961328f, -0.26311716f, 0.13434753f, 0.15222991f, -0.01617810f, 0.04525936f, 0.01273998f, -0.00926453f, 
    0.06720465f, 0.29355192f, 0.38359562f, -0.74043620f, 0.03107592f, -0.22549427f, 0.07363233f, -0.04710396f, 
    -0.24944106f, -0.03588158f, 0.02924629f, 0.06856116f, 0.14796411f, 0.19566357f, 0.02231479f, 0.07845288f, 
    0.00451025f, -0.11073089f, -0.09096351f, -0.11979914f, -0.01808269f, 0.14046325f, -0.08630436f, -0.14121039f, 
    0.16404754f, 0.30957323f, -0.16847986f, -0.10541487f, 0.04692113f, -0.07846529f, 0.01528732f, -0.05006139f, 
    -0.02309502f, 0.04226931f, -0.06083615f, -0.02925552f, -0.24568076f, -0.29569995f, 0.13468215f, -0.39830393f, 
    0.04666027f, -0.08993259f, 0.04878421f, 0.11632517f, 0.02150975f, -0.01106253f, 0.04179204f, 0.04805884f, 
    0.12064799f, -0.50059664f, 0.06434058f, -0.57069010f, 0.01036923f, -0.05018404f, 0.05644146f, 0.05636624f, 
    -0.08802652f, -0.01168000f, -0.00505924f, -0.09061228f, -0.41322532f, 0.03863786f, -0.09014650f, -0.03833932f, 
    -0.06470241f, -0.08350239f, -0.00816462f, 0.09205217f, 0.01985633f, 0.01959829f, 0.06641354f, -0.05303589f, 
    -0.40945637f, 0.15051861f, 0.10348504f, 0.18023589f, 0.13891010f, 0.18648021f, -0.27060080f, 0.09943344f, 
    -0.09073534f, -0.02568682f, -0.08701529f, -0.17259724f, 0.00512312f, 0.24850546f, 0.16757260f, -0.43223119f, 
    -0.12870695f, -0.09353857f, -0.11733170f, -0.12016760f, 0.04656712f, 0.02932968f, 0.02560351f, 0.09236564f, 
    0.14155072f, 0.00762396f, 0.40216869f, -0.15060757f, 0.00101726f, -0.11449627f, -0.07165270f, -0.04054089f, 
    0.03148015f, 0.08016873f, 0.00476602f, -0.01421956f, -0.11363462f, 0.09371094f, -0.18490086f, 0.09630238f, 
    0.11224078f, 0.11440426f, 0.10844518f, 0.10033637f, 0.12720132f, 0.00373315f, -0.11342143f, 0.04395732f, 
    -0.37648532f, 0.13102007f, -0.05164877f, -0.36779717f, 0.07326923f, -0.23983465f, 0.00249148f, -0.04456621f, 
    0.01122215f, 0.13756098f, -0.05319089f, 0.14271337f, -0.14162420f, -0.05074916f, 0.00987509f, -0.21752168f, 
    -0.08629929f, 0.06439843f, -0.11422939f, -0.04894068f, -0.01090194f, -0.22030595f, -0.03115032f, -0.01869601f, 
    -0.20722908f, 0.24395134f, -0.26080492f, 0.00317755f, -0.25130269f, 0.03258444f, -0.10415843f, 0.02100385f, 
    0.04232497f, -0.17658065f, -0.09352696f, -0.12351955f, 0.11701384f, 0.15728129f, 0.35194626f, -0.12879890f, 
    -0.00171042f, -0.05196883f, -0.10034835f, -0.19630627f, -0.08896831f, 0.02163012f, 0.06679555f, 0.04929069f, 
    0.18912719f, 0.02244453f, -0.16262479f, -0.11967044f, 0.09501743f, 0.08034004f, 0.07942946f, -0.01283573f, 
    0.01717907f, -0.14270467f, -0.04939896f, -0.07264667f, -0.39968124f, 0.18191040f, -0.19188292f, -0.07041512f, 
    0.25560451f, -0.11762742f, 0.12345133f, 0.05821916f, 0.04713217f, -0.17448959f, -0.07383164f, -0.22739868f, 
    0.09648229f, -0.20063871f, 0.20357691f, -0.26568091f, -0.02072432f, -0.07659271f, -0.01237887f, 0.00928041f, 
    0.03863643f, 0.00237264f, -0.13151312f, 0.00363652f, -0.56783038f, 0.21379678f, -0.38665020f, -0.03669716f, 
    0.01987200f, -0.05415327f, 0.06912419f, 0.24177708f, 0.14911160f, 0.01805340f, 0.03829080f, 0.10730272f, 
    -0.23871718f, 0.03204464f, 0.13064471f, 0.23652093f, 0.07638427f, -0.11175165f, 0.00707398f, -0.15184073f, 
    0.18134195f, -0.00040164f, -0.20348708f, -0.03052153f, 0.33490780f, -0.16913915f, 0.14919591f, -0.36771020f, 
    -0.06924821f, -0.03791518f, 0.14270882f, 0.13059236f, 0.09546791f, -0.00804877f, -0.04185172f, -0.02622641f, 
    -0.01876013f, 0.16155103f, -0.32209781f, 0.46398506f, -0.18607002f, 0.06505542f, -0.04278788f, -0.07960203f, 
    -0.03512090f, -0.11571360f, 0.00749854f, 0.00434181f, 0.00067003f, 0.04314901f, 0.05484130f, -0.17715228f, 
    -0.13957654f, 0.07685503f, -0.12040629f, 0.08757417f, 0.04817944f, -0.00201576f, 0.04673488f, -0.06778017f, 
    -0.02946451f, -0.17728652f, -0.01318553f, 0.27515820f, 0.09927402f, 0.15221643f, 0.05600752f, 0.04110564f, 
    0.04676759f, 0.01066122f, -0.00204581f, 0.00274797f, -0.17142595f, -0.26123804f, -0.26326084f, 0.01507677f, 
    0.08351667f, -0.06006286f, 0.05921380f, 0.07023126f, 0.04624282f, -0.03754315f, -0.09141792f, -0.14258617f, 
    -0.11335335f, 0.08764561f, -0.31334588f, -0.03358744f, -0.03750854f, 0.05929311f, 0.09288771f, -0.11080990f, 
    0.01220374f, 0.00009117f, -0.03330079f, 0.00660521f, -0.20603599f, -0.35965475f, 0.07002526f, 0.00163469f, 
    0.08853374f, 0.02163450f, 0.01349097f, -0.23123167f, 0.01483077f, -0.03850469f, 0.07371002f, 0.00044382f, 
    -0.19538663f, 0.33921406f, 0.05227258f, -0.29596004f, -0.01429222f, -0.03818688f, 0.10896870f, 0.13936654f, 
    0.07169154f, 0.03521040f, -0.01788413f, -0.11370855f, 0.17527416f, -0.49855918f, -0.09351851f, -0.05553109f, 
    0.07830516f, 0.02613599f, -0.09936241f, -0.04095077f, -0.08664987f, -0.00883242f, -0.04858604f, -0.10753449f, 
    -0.16464517f, 0.19246598f, 0.01353625f, 0.09188448f, 0.13711838f, -0.16227610f, -0.09264127f, -0.08096622f, 
    0.10262495f, -0.07278398f, 0.10851863f, -0.05775329f, -0.10510414f, -0.09442271f, -0.11483779f, 0.15418099f, 
    0.11884587f, -0.09093194f, 0.11117087f, 0.03570959f, 0.01110149f, -0.07670494f, -0.04118418f, -0.08301091f, 
    -0.04012556f, 0.03434663f, -0.08795870f, 0.04554135f, 0.01495233f, 0.10254253f, 0.06590491f, -0.00173431f, 
    0.13039511f, 0.00680702f, 0.16381671f, -0.01239536f, -0.15961787f, -0.09421428f, -0.04626121f, 0.05156252f, 
    -0.03022715f, 0.02583115f, 0.05255021f, -0.08339244f, 0.11244322f, -0.08166424f, 0.25531581f, 0.21761371f, 
    -0.24662645f, 0.13966528f, 0.14879631f, -0.16395240f, 0.03285713f, 0.03123147f, 0.13752392f, 0.20292020f, 
    0.04415765f, 0.10121783f, 0.05221726f, -0.04625221f, 0.47760871f, -0.19358896f, 0.35942796f, -0.16474146f, 
    -0.06758611f, -0.11433335f, -0.07986177f, -0.19045304f, 0.16009863f, 0.04850870f, -0.15049447f, 0.05286678f, 
    -0.05128351f, -0.03939859f, -0.17059599f, -0.01011260f, 0.13486120f, -0.09040564f, 0.14678288f, 0.00702105f, 
    0.12081552f, -0.08088219f, -0.12821642f, -0.17381534f, 0.32617059f, -0.11366958f, 0.18036452f, -0.19965123f, 
    0.01142433f, -0.17067030f, -0.13540868f, -0.08428808f, -0.05483491f, -0.00657773f, 0.09411070f, 0.01875048f, 
    0.08164799f, -0.25448015f, -0.06858027f, -0.06962667f, 0.02094128f, 0.06181057f, 0.05786601f, -0.01563328f, 
    0.12882987f, -0.03712898f, -0.04735361f, -0.00566749f, -0.03722982f, -0.03936030f, 0.00587174f, 0.01940073f, 
    0.10472971f, 0.06826510f, 0.13571940f, 0.06488318f, 0.07543255f, 0.03097669f, 0.07057813f, 0.01619132f, 
    -0.27108246f, -0.25854453f, 0.00964668f, 0.09105720f, 0.02800782f, -0.13103236f, -0.02632274f, 0.11301542f, 
    -0.00443221f, 0.01269594f, 0.07230031f, 0.02294243f, -0.03436759f, -0.22878329f, 0.14614172f, 0.24754097f, 
    -0.00476034f, 0.06713095f, -0.08226896f, 0.00318609f, 0.04649677f, 0.17010157f, 0.03304667f, -0.08405034f, 
    -0.34831798f, -0.18762074f, -0.45881370f, -0.07319406f, 0.12905984f, -0.04383180f, 0.06388295f, 0.06543864f, 
    0.08459423f, -0.01061870f, 0.00111636f, 0.01181323f, -0.07304318f, -0.20267755f, 0.12343553f, -0.46910185f, 
    0.05180550f, -0.10189003f, 0.06049680f, 0.00104493f, -0.09908335f, 0.02323034f, -0.02515909f, 0.04843354f, 
    -0.13247809f, -0.00627021f, -0.12601781f, -0.00657262f, 0.03471722f, 0.06642400f, 0.06708627f, -0.10505439f, 
    0.11748048f, 0.04958650f, -0.17581122f, -0.10335101f, -0.11626706f, -0.61168236f, 0.03576785f, -0.40818948f, 
    -0.17895877f, 0.09695354f, 0.06289116f, 0.03136030f, 0.00024858f, -0.00589610f, 0.02258807f, 0.02253599f, 
    -0.23788041f, 0.21651676f, -0.01676091f, -0.19158675f, 0.00119210f, 0.04962740f, 0.05586175f, 0.06336384f, 
    0.08531603f, 0.09664065f, -0.05280232f, 0.00826379f, -0.03610479f, -0.27257660f, 0.06539344f, -0.07331938f, 
    0.06910605f, -0.05470568f, 0.00322078f, 0.18813680f, -0.04728066f, 0.03203936f, -0.10107902f, 0.20638348f, 
    -0.09102348f, -0.09358335f, -0.14181912f, 0.24461421f, -0.03396901f, 0.10184886f, -0.07349766f, -0.10838205f, 
    0.04852570f, -0.15736331f, -0.13952512f, -0.11049575f, 0.38209957f, -0.00576032f, 0.00769681f, -0.11484201f, 
    0.03958579f, 0.00881476f, -0.01983332f, 0.12235130f, -0.07401869f, 0.10718763f, -0.15333521f, -0.02196741f, 
    -0.13496169f, 0.23342110f, -0.14373991f, -0.08141033f, 0.02699156f, -0.16085835f, 0.01209298f, 0.01321939f, 
    -0.17192774f, -0.19474348f, -0.35193992f, -0.26977232f, 0.09816641f, 0.04524747f, -0.18729474f, 0.04579185f, 
    0.03219443f, 0.05899833f, 0.10192288f, 0.12890072f, -0.08124541f, 0.06664032f, -0.02016322f, -0.14038444f, 
    -0.19337977f, -0.11328954f, -0.23369394f, -0.10738274f, 0.09203833f, 0.18187457f, -0.05835603f, -0.12011801f, 
    -0.08464208f, -0.12065259f, -0.00544214f, -0.13951436f, -0.19031020f, -0.48606122f, 0.12801129f, -0.08824061f, 
    0.00930524f, 0.15090278f, -0.08776248f, 0.03122007f, -0.05548016f, 0.03511915f, 0.12342641f, 0.01021853f, 
    -0.31162661f, 0.04545901f, 0.21016936f, -0.24822576f, -0.12850653f, 0.13155136f, -0.13664798f, -0.12040092f, 
    -0.01424832f, -0.05210093f, -0.07290088f, -0.09410480f, -0.25971952f, 0.27241644f, -0.16158915f, -0.05488795f, 
    -0.11278641f, 0.00927042f, -0.00952875f, -0.03745297f, -0.14941734f, -0.15128931f, -0.17764968f, -0.39001891f, 
    0.02637173f, -0.00391945f, 0.09930839f, 0.18859786f, -0.02237353f, -0.04315065f, -0.00356159f, -0.02412298f, 
    -0.03662990f, 0.02603319f, -0.00445381f, 0.05206731f, -0.31391594f, -0.03699529f, 0.02731061f, -0.21052022f, 
    -0.09331672f, -0.22446196f, 0.00267567f, 0.11679880f, -0.16101727f, 0.02914003f, -0.02177733f, 0.00675547f, 
    0.08549724f, -0.23123302f, -0.07419654f, -0.11670919f, -0.25230289f, -0.12346800f, 0.07445249f, 0.01758369f, 
    -0.17533082f, 0.17365731f, -0.00735340f, -0.08196240f, -0.45571056f, 0.27463108f, 0.06741100f, -0.02106923f, 
    -0.09052084f, 0.03333009f, -0.35939702f, 0.10327645f, 0.01728169f, -0.18027925f, -0.05884217f, -0.04555971f, 
    0.23269279f, -0.10075637f, 0.32481217f, -0.09808109f, -0.21007895f, 0.02211783f, 0.11341822f, 0.30065110f, 
    -0.08501622f, 0.02249655f, 0.11056694f, 0.04526275f, -0.15739222f, 0.04627972f, 0.13944574f, -0.14145501f, 
    -0.07367857f, 0.08362540f, -0.07456078f, -0.07238083f, 0.02512900f, 0.07382320f, -0.08337739f, -0.00089698f, 
    -0.57222962f, -0.10525294f, -0.20453891f, -0.02748848f, -0.00910414f, 0.20000599f, -0.12983012f, -0.08983798f, 
    0.03223188f, -0.02077491f, 0.01615009f, -0.06656250f, -0.24459369f, 0.18329798f, -0.13536507f, 0.11807869f, 
    -0.10598157f, 0.09365226f, 0.05164459f, 0.06880942f, 0.04900496f, 0.04109059f, 0.11554524f, 0.16923016f, 
    -0.30455962f, 0.32595304f, 0.04506272f, 0.01954352f, 0.00100374f, 0.22133015f, 0.10652756f, -0.11953586f, 
    0.00653264f, 0.12472214f, 0.06077191f, 0.12004409f, -0.13961618f, -0.14064148f, -0.03168155f, 0.02368486f, 
    -0.10353214f, 0.05640706f, -0.05301757f, -0.10421506f, 0.00926575f, 0.13612065f, 0.06944240f, 0.21798994f, 
    0.10880164f, -0.04623894f, 0.04053924f, 0.20894769f, -0.12567280f, -0.05182923f, 0.00557195f, -0.04124955f, 
    0.16347042f, -0.08365643f, 0.09866068f, 0.04925902f, -0.10262311f, 0.09197716f, 0.12859802f, -0.00243392f, 
    0.00158562f, 0.02105858f, -0.14925133f, 0.04290770f, 0.00087974f, -0.27806333f, 0.15901117f, -0.01491939f, 
    -0.08436374f, -0.02142965f, 0.12107580f, 0.20579344f, 0.07384624f, -0.08845225f, 0.07657907f, -0.10707297f, 
    -0.01334611f, -0.05862994f, -0.03598988f, 0.10246060f, -0.38135421f, 0.18298601f, 0.02862978f, 0.15128025f, 
    -0.14305560f, 0.10668453f, -0.15332070f, -0.06904743f, -0.09169623f, -0.01213158f, 0.03333150f, -0.00490893f, 
    -0.00426041f, -0.00031468f, 0.29959533f, 0.47058275f, -0.17605932f, -0.07836079f, -0.10771022f, 0.22490484f, 
    0.02710580f, 0.06585964f, -0.27176279f, -0.03338156f, 0.01705256f, 0.02106558f, -0.06681806f, 0.08455333f, 
    -0.25917068f, 0.01810555f, -0.01660957f, 0.06577785f, 0.06215994f, 0.06018816f, 0.04531979f, 0.13738190f, 
    0.15207449f, 0.42292571f, 0.16190667f, 0.15872039f, 0.07423751f, -0.03289472f, -0.02293264f, 0.11370595f, 
    0.03946028f, 0.01445577f, 0.14689200f, 0.13562283f, 0.06679789f, 0.14850697f, 0.04669460f, 0.02846111f, 
    0.06934255f, -0.11534107f, -0.00473326f, 0.09938392f, -0.20607270f, 0.01506535f, -0.00088266f, 0.00369314f, 
    -0.30865023f, 0.04894974f, -0.21646923f, 0.04169576f, 0.01342976f, -0.14923581f, -0.15860561f, 0.13870566f, 
    -0.07986406f, -0.13383269f, -0.43632334f, -0.29484090f, -0.03285594f, -0.09685412f, -0.10900422f, -0.30482021f, 
    -0.22170238f, -0.17059194f, -0.14305829f, 0.08085066f, -0.09487799f, 0.06848957f, -0.22907971f, 0.12155724f, 
    0.06022871f, 0.05412508f, 0.27957618f, 0.06498016f, 0.00750851f, -0.03616379f, 0.12196147f, 0.03478132f, 
    0.00954608f, 0.10368194f, -0.42627987f, -0.10796775f, -0.12144618f, 0.24702922f, 0.11316719f, 0.22487992f, 
    0.08065214f, 0.05313572f, -0.00890652f, -0.10626129f, 0.00837739f, 0.19756755f, 0.32825428f, 0.10946566f, 
    0.38125488f, -0.17101446f, 0.43531051f, -0.19919226f, -0.02872768f, -0.07239942f, 0.04491307f, 0.04245860f, 
    -0.05573203f, 0.07771195f, 0.09285653f, 0.06063036f, -0.08614447f, 0.19923763f, 0.06619105f, -0.14534096f, 
    -0.02026884f, -0.06947371f, 0.11877526f, 0.03843419f, -0.21347488f, 0.00699450f, 0.04916222f, -0.23532145f, 
    -0.21255296f, -0.33387044f, 0.03244071f, -0.17663051f, -0.20255622f, 0.19861892f, 0.13962024f, 0.03630402f, 
    0.01772245f, -0.03369298f, -0.01289223f, -0.01718010f, -0.03937354f, -0.15130155f, 0.21139964f, 0.03769037f, 
    -0.01315887f, 0.05038388f, 0.10902739f, 0.09655693f, -0.25590399f, 0.08154235f, -0.04730395f, -0.03251613f, 
    -0.06599280f, 0.19588369f, 0.21552713f, 0.11368494f, -0.09100284f, -0.06687867f, 0.03844839f, -0.01035000f, 
    -0.08488610f, -0.08622549f, 0.22905596f, 0.20894115f, 0.33596477f, -0.21981275f, 0.33702976f, -0.12316929f, 
    -0.18759339f, 0.03419866f, 0.12362213f, 0.05976339f, -0.15474492f, -0.14462394f, -0.08628610f, -0.11871578f, 
    0.20027007f, -0.08721673f, 0.36636719f, 0.18009493f, -0.12144981f, 0.14257115f, 0.22583255f, 0.14914361f, 
    -0.12075629f, -0.14020245f, 0.06334648f, -0.02324932f, 0.04028596f, -0.27948621f, 0.06069464f, 0.25426513f, 
    0.00771462f, 0.00681480f, -0.13176133f, 0.12415756f, 0.12642874f, -0.09948885f, -0.04099454f, -0.12094560f, 
    0.09938871f, 0.38946807f, -0.25119790f, -0.25673515f, 0.13516764f, -0.12755522f, 0.02274606f, -0.01317268f, 
    -0.11004583f, 0.04099820f, -0.36036950f, -0.27007270f, -0.24837920f, -0.10048348f, -0.16965684f, 0.11462629f, 
    0.02165654f, -0.09566943f, -0.08997564f, 0.00544476f, -0.00848596f, 0.03680032f, 0.03746387f, 0.03558164f, 
    -0.02744596f, -0.15810971f, -0.12035498f, 0.04739862f, -0.20689912f, 0.03709916f, -0.01404659f, -0.04392176f, 
    0.04344124f, -0.01454681f, -0.16809610f, 0.02684694f, -0.14935641f, -0.06337593f, 0.12249569f, 0.17814015f, 
    -0.23234546f, 0.08295370f, 0.10065249f, -0.01302757f, -0.02592234f, 0.01012414f, 0.01040366f, 0.02479551f, 
    0.07305136f, 0.09851464f, -0.19099212f, 0.06100615f, -0.09214139f, 0.06100443f, 0.11902985f, -0.18436512f, 
    0.05510037f, 0.07783096f, -0.04495284f, 0.10115149f, -0.69585264f, 0.18552700f, 0.13948674f, 0.14045610f, 
    -0.08196272f, 0.12212316f, -0.24857549f, 0.03851670f, -0.14112310f, -0.10527167f, 0.08729382f, 0.03311913f, 
    0.10141181f, -0.43094563f, 0.20333295f, 0.08326260f, -0.07814435f, -0.19018689f, 0.15951206f, 0.05319559f, 
    -0.21957560f, -0.23172921f, 0.02868707f, 0.06868035f, -0.46230021f, 0.09677087f, -0.12739171f, 0.01426194f, 
    0.01107897f, 0.06704382f, -0.07143106f, -0.11609264f, 0.01439822f, 0.05674003f, 0.01711846f, -0.04938054f, 
    -0.16757490f, 0.18329112f, 0.04506703f, -0.27456743f, -0.13379070f, 0.24202754f, 0.22058353f, 0.19339339f, 
    -0.10845774f, -0.02292841f, -0.12386737f, 0.04442674f, -0.17888100f, -0.08441863f, -0.12314388f, 0.04632033f, 
    -0.17208746f, 0.06988673f, -0.10867785f, 0.12209904f, 0.03938944f, 0.04296625f, -0.02676289f, 0.17260998f, 
    -0.30077091f, -0.30121559f, -0.29392493f, -0.39025310f, -0.10378073f, -0.08626412f, 0.02952490f, -0.13848887f, 
    -0.06799354f, 0.10518205f, 0.14835636f, 0.01477057f, 0.17867263f, 0.04384015f, 0.22730871f, -0.01700458f, 
    -0.12317495f, 0.04094453f, -0.03960012f, 0.03167928f, -0.04162902f, -0.02919305f, -0.13332745f, -0.24996363f, 
    -0.00423254f, -0.27796486f, -0.18355574f, -0.09029514f, -0.05644026f, -0.19314148f, 0.03281598f, -0.03267850f, 
    0.10146095f, 0.07963512f, -0.05621246f, -0.04509283f, -0.12622429f, 0.23933771f, -0.17701735f, 0.11351457f, 
    0.02572703f, 0.05292144f, 0.11977174f, -0.04785686f, -0.08412077f, 0.01416425f, 0.02965082f, 0.04846105f, 
    -0.01555940f, -0.00520026f, -0.08868054f, 0.02849079f, -0.10137058f, 0.01849064f, -0.02743104f, 0.12192859f, 
    -0.04406594f, 0.12173165f, 0.01510800f, 0.11883102f, 0.12357830f, -0.11274906f, -0.00994683f, 0.02464353f, 
    -0.08744006f, -0.02112070f, -0.05804785f, 0.01563505f, 0.03979373f, 0.11231031f, -0.05715747f, -0.19209465f, 
    -0.06972213f, 0.16343580f, -0.15756142f, 0.03042061f, 0.00514178f, -0.19174655f, 0.00901478f, -0.11882487f, 
    -0.16059017f, 0.02597735f, 0.02790610f, 0.05323248f, -0.08135740f, 0.12081320f, 0.08231381f, 0.04617020f, 
    0.07786430f, -0.06724852f, 0.00139099f, 0.07679334f, -0.22969078f, -0.05022173f, -0.01982725f, -0.44618478f, 
    -0.32185280f, 0.25210142f, -0.36057970f, 0.13834810f, -0.03000793f, 0.12230261f, -0.04073909f, -0.03190538f, 
    -0.08457054f, 0.15000300f, -0.00215626f, 0.10817691f, -0.36060050f, -0.11009260f, 0.10825218f, -0.23801112f, 
    0.00479193f, -0.07785429f, -0.12788858f, -0.01641922f, 0.12210874f, -0.14652567f, -0.17283812f, 0.02058442f, 
    -0.11143614f, 0.38156492f, 0.25859663f, 0.13031709f, -0.08010282f, -0.06777259f, -0.08531125f, 0.02699125f, 
    -0.08003071f, 0.02362619f, 0.06848878f, 0.06158286f, 0.03411863f, -0.03941041f, 0.16376525f, 0.17757045f, 
    0.04780946f, 0.05872090f, 0.07829609f, -0.11492354f, 0.07500535f, 0.06938230f, -0.04082711f, 0.01453868f, 
    0.06545249f, -0.13951401f, 0.16662775f, 0.10054470f, -0.16647418f, -0.06022686f, 0.12488670f, 0.07626905f, 
    -0.03452529f, 0.15893531f, 0.19799031f, 0.08522390f, -0.10288445f, 0.03453150f, 0.07728803f, 0.38371256f, 
    -0.00029214f, -0.00163494f, 0.04817607f, 0.27788174f, -0.06789640f, 0.00734639f, -0.16185464f, -0.14789328f, 
    -0.08011383f, -0.11008416f, 0.09884802f, -0.02993411f, -0.11986697f, -0.04082959f, -0.00729835f, 0.12630334f, 
    0.02279220f, -0.04514721f, 0.12166794f, -0.14071420f, -0.25849074f, -0.08898835f, -0.01880855f, 0.14631119f, 
    -0.03024928f, -0.09218577f, -0.08021525f, 0.15732834f, -0.03678672f, 0.08746968f, 0.03979176f, 0.17470199f, 
    -0.04671305f, 0.28574929f, -0.18032755f, 0.02297363f, -0.02009548f, 0.00393720f, 0.13572524f, 0.01109670f, 
    -0.11762711f, 0.33689669f, -0.00287479f, 0.13347782f, -0.19509296f, 0.04173858f, -0.01122337f, 0.01763031f, 
    0.09391126f, 0.03711072f, -0.07234531f, 0.08494848f, -0.01048268f, -0.04821373f, 0.04357134f, -0.10792310f, 
    0.04047125f, -0.22854885f, 0.02383189f, -0.13283750f, 0.11125104f, 0.00291215f, -0.00341636f, 0.07759272f, 
    -0.04683652f, 0.04615317f, 0.10670929f, 0.05148238f, 0.16274536f, -0.08099574f, 0.22514655f, -0.16646023f, 
    -0.08251952f, -0.15342766f, -0.06506795f, 0.02643240f, 0.01993926f, 0.04647594f, 0.05498573f, -0.08128709f, 
    -0.01704283f, 0.11786544f, -0.11337461f, -0.01688556f, 0.04191341f, -0.10310668f, 0.20891489f, -0.13905460f, 
    -0.00315518f, -0.00120734f, 0.07514237f, 0.06000578f, -0.04921612f, -0.16062170f, -0.03853774f, 0.12798955f, 
    -0.16861258f, -0.25569057f, -0.02708721f, -0.13492683f, 0.01497004f, -0.00559804f, -0.16149861f, -0.10333608f, 
    -0.32169780f, -0.13108629f, -0.46909052f, 0.20262592f, 0.26729438f, 0.15674165f, 0.05050272f, 0.06894284f, 
    0.05932032f, 0.10012695f, 0.16845381f, 0.03562374f, -0.08570033f, 0.11942990f, -0.14880960f, 0.21332479f, 
    0.01251106f, -0.06581192f, -0.03610834f, -0.01212071f, 0.07031985f, 0.03572640f, 0.18032868f, 0.19490732f, 
    -0.01835239f, 0.06963839f, 0.07644794f, 0.02357613f, -0.09909254f, -0.10034801f, 0.05316933f, -0.07416132f, 
    -0.01347205f, 0.06268387f, -0.00687875f, 0.08654300f, 0.30224788f, 0.22467446f, 0.22322699f, -0.13961133f, 
    -0.02860717f, 0.12861311f, -0.02099528f, 0.12404516f, -0.09123665f, 0.00230714f, 0.07458740f, -0.11992819f, 
    0.53204197f, 0.20301576f, 0.21031058f, -0.11534739f, -0.04924380f, 0.10432991f, -0.12906446f, 0.08514931f, 
    -0.09307827f, 0.03004603f, -0.02684281f, -0.02341766f, -0.08172959f, -0.21402752f, 0.07824705f, 0.00599483f, 
    0.07908458f, -0.04760793f, 0.10486042f, 0.13854650f, 0.02692284f, 0.09991868f, 0.01038517f, -0.12748115f, 
    -0.29616779f, 0.04890432f, -0.24801300f, 0.13819177f, -0.14152093f, 0.12051515f, -0.06560116f, 0.12939632f, 
    -0.12824175f, -0.10542865f, -0.04895331f, -0.28559780f, 0.04712571f, -0.05998672f, -0.09448357f, 0.22070903f, 
    0.03501140f, -0.06600016f, -0.05406359f, -0.07512034f, -0.10584016f, 0.03319489f, 0.06987246f, 0.03480836f, 
    -0.34089744f, 0.25806987f, -0.25002554f, 0.07931504f, -0.11921865f, -0.06856325f, -0.01260725f, 0.00162885f, 
    0.06331220f, -0.09975845f, 0.06944132f, -0.00505268f, -0.26659811f, -0.09513765f, -0.03136184f, 0.05623458f, 
    0.00895032f, 0.11286847f, -0.10491357f, 0.06493891f, -0.11203660f, -0.21984245f, -0.02202518f, -0.25465477f, 
    -0.39485976f, 0.53589159f, -0.29629993f, 0.21300146f, 0.05955312f, -0.18178250f, 0.11075494f, -0.00798391f, 
    -0.15467060f, -0.02358656f, -0.04065751f, -0.08925439f, 0.04068708f, -0.20447631f, -0.12308357f, -0.30489427f, 
    -0.07698366f, -0.25459048f, -0.29260668f, -0.06823810f, -0.02203490f, -0.05598727f, 0.00673107f, -0.08307279f, 
    -0.12926006f, -0.38442066f, 0.30344066f, -0.22920462f, -0.03104659f, -0.05476266f, -0.01172985f, 0.24058251f, 
    -0.11268910f, 0.00120665f, -0.12251277f, -0.08008602f, -0.13425367f, -0.17580721f, -0.20553778f, 0.02565300f, 
    -0.00413992f, -0.09727018f, 0.02218432f, -0.03750361f, -0.24447592f, 0.03809755f, 0.01480545f, 0.08478210f, 
    0.13370839f, 0.07949004f, 0.20486999f, 0.01395741f, 0.07008235f, -0.07275941f, 0.00391639f, 0.01937464f, 
    -0.05034441f, -0.07572471f, 0.00361969f, -0.06516027f, -0.17258406f, -0.22791328f, 0.01750122f, 0.15815942f, 
    0.03503688f, 0.05271299f, 0.07587761f, -0.08925764f, 0.06337821f, 0.03716363f, 0.02693025f, -0.01389489f, 
    -0.16588953f, -0.25863734f, -0.02203334f, 0.47181109f, -0.11944349f, 0.08743797f, 0.13193491f, 0.08807322f, 
    -0.03888588f, 0.02636228f, 0.17013410f, 0.25397834f, 0.12444864f, -0.24032082f, 0.11209311f, -0.16196150f, 
    -0.17051245f, -0.19493075f, 0.01690723f, -0.22917815f, 0.00661305f, -0.02095757f, -0.03121282f, -0.09048010f, 
    -0.52184641f, 0.10726702f, -0.21047157f, 0.00988550f, 0.16256087f, 0.06056064f, 0.09320316f, -0.08750714f, 
    -0.05724270f, -0.15066147f, 0.00435723f, -0.02263032f, -0.44923040f, 0.29255351f, -0.27715078f, -0.02336009f, 
    -0.10124154f, -0.06167187f, -0.00929673f, -0.10653695f, 0.07545385f, 0.01004210f, -0.16054022f, -0.02567434f, 
    -0.16489568f, -0.29256144f, -0.30177876f, -0.26419780f, -0.07580606f, -0.17319579f, -0.01126951f, -0.00301790f, 
    -0.03347711f, 0.15782464f, -0.01245264f, -0.03279443f, 0.17663290f, 0.00150249f, 0.15709071f, -0.17022586f, 
    0.07284295f, 0.05567532f, 0.00155444f, 0.05978014f, -0.10612096f, 0.04017496f, 0.08503392f, 0.06906212f, 
    0.30101478f, -0.24483430f, 0.09341320f, -0.03903814f, -0.03580762f, 0.06022587f, -0.13062806f, 0.11480075f, 
    0.00907672f, 0.07240503f, 0.08962364f, 0.12829681f, -0.26467207f, 0.07493027f, -0.12800650f, 0.06793427f, 
    0.21472228f, 0.12738512f, 0.12525564f, -0.00438750f, -0.14149612f, -0.02103668f, -0.18514349f, 0.07010481f, 
    -0.22445847f, -0.07461646f, -0.05853634f, -0.23036209f, 0.15215461f, 0.05602068f, 0.09761577f, -0.14358714f, 
    0.04203384f, -0.03998771f, -0.05227888f, -0.13805068f, -0.26938388f, 0.04583073f, -0.06709298f, 0.06297847f, 
    -0.00068150f, -0.05957348f, 0.08902666f, -0.01427543f, 0.02316554f, -0.05060245f, -0.31486174f, 0.14453775f, 
    0.34866089f, 0.30184972f, 0.18210995f, -0.11492082f, 0.10025312f, -0.08889610f, -0.10320710f, 0.00417863f, 
    -0.10736112f, 0.03852465f, -0.09597013f, 0.09355063f, 0.35505307f, 0.07735402f, 0.18128787f, 0.10898034f, 
    -0.03305202f, 0.08558928f, -0.08323276f, 0.13566686f, -0.13905767f, 0.14593162f, 0.06668714f, -0.00455253f, 
    0.01723817f, 0.15609972f, -0.23397158f, 0.39669579f, -0.00868209f, 0.10610095f, -0.06044597f, 0.11938941f, 
    -0.22240858f, 0.04202132f, 0.02058092f, -0.10178566f, 0.15786116f, -0.09808725f, 0.25560269f, -0.36002356f, 
    0.05201011f, -0.05648042f, 0.12359664f, 0.01620479f, 0.19663790f, -0.04349654f, 0.03490936f, 0.03146725f, 
    0.00893872f, -0.21554174f, 0.05567010f, -0.10991506f, 0.11223997f, 0.17785178f, -0.15611568f, 0.11933155f, 
    0.02412273f, 0.03631766f, 0.20439677f, -0.16989988f, 0.03095049f, 0.04762538f, 0.29162621f, -0.07552300f, 
    -0.30380547f, 0.09359477f, -0.28258395f, 0.02686325f, 0.04642895f, 0.11123494f, 0.13386746f, 0.05734677f, 
    -0.25520554f, 0.01654554f, -0.17028421f, 0.26062617f, 0.05353077f, -0.15566027f, 0.05545898f, -0.03207003f, 
    -0.11014535f, 0.04361044f, 0.07132729f, 0.19900349f, -0.11867129f, 0.33009690f, -0.13361709f, 0.13772777f, 
    -0.16053507f, -0.09855222f, -0.09011086f, -0.02622815f, -0.01234591f, 0.08269525f, 0.01333397f, -0.04294524f, 
    -0.09351367f, 0.08635297f, 0.05319316f, -0.11128583f, 0.08224437f, 0.01329325f, -0.05641441f, -0.11024283f, 
    0.03901546f, 0.03065102f, 0.04331126f, -0.03205315f, 0.30494824f, -0.12822637f, 0.05838079f, -0.02508414f, 
    -0.07581078f, -0.07549428f, 0.00045217f, 0.05502279f, -0.07069435f, -0.10828804f, -0.00732986f, -0.03175032f, 
    0.14233324f, -0.04571015f, 0.07991509f, 0.07761425f, -0.08991262f, -0.10112651f, -0.10074923f, 0.00588074f, 
    -0.10985858f, -0.00743111f, -0.04291831f, -0.07994694f, -0.02022056f, -0.00751146f, -0.10615459f, 0.29719767f, 
    -0.00834940f, -0.19749089f, 0.14696564f, 0.05542142f, -0.14657256f, 0.08197211f, -0.16667102f, 0.00718591f, 
    0.07956436f, 0.06328300f, 0.27863246f, -0.20106715f, -0.15343091f, 0.19797669f, -0.24931413f, 0.09287986f, 
    0.00523884f, 0.13798815f, 0.15382041f, -0.04609438f, 0.05401720f, 0.34202877f, -0.33704022f, 0.00590070f, 
    0.04718318f, -0.11923277f, 0.00656571f, 0.00454211f, 0.05509538f, 0.00930526f, 0.14956418f, -0.13146687f, 
    0.21455197f, -0.23788814f, 0.13876654f, 0.07436824f, 0.11012166f, 0.04744536f, 0.00648686f, 0.10372421f, 
    0.00338073f, 0.00994707f, 0.05771528f, 0.08127758f, 0.35268518f, 0.01150040f, 0.05320824f, -0.10805842f, 
    -0.08710647f, -0.09406190f, -0.08331801f, 0.07115962f, -0.09990929f, 0.06963859f, -0.07418802f, -0.07288615f, 
    0.01764240f, 0.16779326f, -0.21357770f, 0.04284031f, 0.03847959f, 0.00810462f, 0.03887049f, 0.06646904f, 
    -0.05706605f, 0.05111365f, -0.07359523f, -0.15825643f, 0.12000458f, 0.10254708f, -0.07820901f, -0.09206478f, 
    0.03823036f, 0.10791580f, 0.02671274f, 0.14206269f, 0.10486838f, 0.11540816f, -0.01338832f, 0.08258756f, 
    -0.21101372f, -0.29618135f, -0.05256225f, -0.11616073f, -0.07235351f, -0.29559198f, -0.04600387f, -0.19128534f, 
    0.03336338f, 0.06778457f, -0.03947714f, -0.05041442f, -0.28129604f, 0.18446417f, -0.45170629f, 0.18829201f, 
    0.04125097f, -0.04530064f, 0.22228791f, -0.10414773f, 0.03863118f, -0.00596924f, 0.04734836f, -0.03537896f, 
    0.22918791f, -0.11913357f, 0.18073870f, -0.00938299f, -0.02047382f, 0.03981783f, 0.02556122f, -0.06019528f, 
    -0.00671453f, 0.03380930f, 0.04482250f, 0.01511584f, -0.31347218f, 0.05594298f, -0.27777851f, -0.60715324f, 
    -0.00413158f, -0.04292928f, 0.03906903f, 0.03608545f, -0.20582771f, -0.01291082f, -0.01265336f, -0.01965658f, 
    -0.04700500f, 0.00153178f, 0.16410971f, 0.15832752f, -0.02912927f, 0.06956202f, -0.06096375f, -0.03901963f, 
    -0.11669877f, -0.15315205f, -0.10930040f, 0.02863181f, 0.09706149f, 0.05014329f, 0.19480535f, 0.00836074f, 
    0.04463214f, -0.01417975f, 0.03070155f, 0.15925547f, 0.01381676f, 0.24460469f, 0.16940804f, 0.17598170f, 
    -0.04959202f, -0.22637025f, -0.09693152f, 0.22463691f, -0.11355668f, -0.09682360f, -0.14825001f, -0.12224168f, 
    0.04568451f, -0.01209278f, 0.03071079f, -0.03950516f, -0.27090585f, 0.01832217f, -0.27482295f, -0.10513674f, 
    -0.00847131f, -0.08352118f, 0.06601280f, -0.07674185f, 0.03889073f, 0.17741834f, 0.02924313f, 0.06919029f, 
    0.42216122f, -0.21279848f, 0.16801387f, 0.08730423f, -0.04120627f, -0.10231470f, -0.03368304f, 0.08033875f, 
    -0.05639905f, -0.05692306f, 0.02332626f, -0.02516393f, -0.28289199f, 0.25088301f, 0.06032568f, 0.06862448f, 
    -0.04037790f, 0.06591069f, -0.04632451f, 0.12765537f, -0.27154857f, -0.02934202f, -0.03909329f, 0.05905644f, 
    -0.08831785f, 0.18404579f, -0.06197980f, 0.07442392f, -0.11439519f, 0.02238439f, 0.10846885f, -0.03819555f, 
    -0.05613174f, -0.08346841f, 0.12475260f, -0.23983270f, -0.12137897f, 0.28953329f, 0.13587920f, 0.21624143f, 
    -0.18918927f, 0.01737612f, 0.15438195f, -0.15802616f, 0.02624241f, -0.08255861f, 0.06969191f, 0.14397706f, 
    0.12988900f, -0.09933719f, 0.13898136f, 0.14625336f, -0.02261277f, 0.07764270f, 0.01713539f, 0.12266771f, 
    -0.15785095f, 0.09556588f, -0.05128368f, 0.11351699f, -0.31969053f, 0.12028231f, 0.05959290f, 0.18518509f, 
    -0.11131596f, 0.08642820f, 0.00815019f, 0.14877497f, -0.18996513f, -0.09844471f, 0.02498643f, -0.20459539f, 
    -0.18775022f, 0.03002130f, 0.02095594f, 0.06137782f, -0.00325311f, 0.01968939f, 0.14657247f, -0.19265531f, 
    0.00709184f, -0.20553321f, -0.05353616f, 0.00516728f, 0.01290438f, 0.20457584f, 0.01032008f, 0.30999747f, 
    0.05993053f, 0.00063364f, 0.01564781f, 0.02532062f, -0.05625954f, 0.04129642f, 0.07254894f, 0.00234427f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14808457f, 0.09390702f, 0.05420075f, -0.08213352f, -0.05477269f, 0.05093120f, 0.04529851f, -0.11145977f, 
    0.08949892f, 0.02391980f, 0.00176631f, -0.00573272f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
