#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.22005457f, 0.49005330f, 0.01209934f, 0.22062896f, 0.69794917f, -0.91288006f, -0.32264581f, -0.06646353f, 
    0.00868556f, -0.82731259f, 0.05966901f, 0.18842456f, -0.09610460f, -0.74232835f, -0.25192153f, -0.02679739f, 
    -0.12702329f, -0.46220055f, -0.23168081f, -0.22292957f, 0.33001316f, -0.43803704f, -0.41956791f, -0.56306148f, 
    0.41565999f, -0.24443348f, 0.60699642f, -0.14493243f, 0.04745530f, 0.88479912f, 0.08286867f, -0.34449413f, 
    0.26287061f, 0.22151382f, -0.46980071f, 0.08473746f, 0.51535982f, 0.48059168f, -0.32118690f, -0.43465188f, 
    -0.58293849f, -0.43412417f, 0.16633520f, 0.17912771f, 0.35845363f, 1.02829671f, -0.04956980f, -0.41973567f, 
    -0.25288349f, -0.16745883f, 0.21569130f, -0.08640571f, 0.45513883f, -0.38233590f, -0.06836010f, 0.24337083f, 
    0.11376212f, 0.59981978f, 0.37409192f, 0.69537306f, -0.15469603f, 0.54558283f, -0.52456862f, -0.76819503f, 
    0.75595558f, -0.57199001f, -0.12030575f, 0.57436961f, 0.14710577f, 0.32026404f, 0.27954918f, 0.04380516f, 
    -0.41779223f, -0.48551303f, -0.54884225f, -0.35037571f, -0.28696245f, -0.00771913f, 0.05881592f, -0.32030228f, 
    -0.11929704f, -0.62665170f, -0.44810939f, -0.08752163f, 0.64682269f, 0.44467917f, -0.28279781f, -0.25285485f, 
    -0.28877032f, -0.50457305f, 0.61200023f, -0.69178289f, 0.21033958f, -0.41247478f, -0.15194643f, 0.31458262f, 
    -0.46915728f, -0.14297092f, 0.58832121f, -0.36458173f, 0.08412701f, -0.64251304f, -0.06389137f, -0.26833478f, 
    -0.45339668f, -0.46359718f, -0.17645358f, 0.00231621f, 0.64328957f, -0.55070716f, 0.84407544f, -0.03356536f, 
    0.09883673f, 0.07596368f, 0.25680095f, 0.38389379f, 0.41366428f, -0.79547399f, -0.38330379f, -0.23748222f, 
    0.27425346f, -0.15643606f, 0.54555392f, 0.05660411f, -0.17243810f, 0.12911808f, 0.61454344f, -0.58606863f, 
    -0.49527597f, -0.40961775f, -0.05559454f, -0.49153808f, -0.27276286f, 0.01130166f, 0.25849259f, -0.64980567f, 
    0.06907115f, 0.06371843f, 0.19498733f, -0.17164524f, -0.34564972f, 0.45043227f, 0.58808237f, 0.47568122f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06593242f, -0.30927852f, -0.11040983f, 0.38663468f, -0.14667436f, -0.02935006f, -0.17820153f, -0.10686520f, 
    0.24220704f, 0.33356789f, -0.10771070f, -0.31159088f, 0.56066728f, 0.12224460f, 0.01643263f, 0.42029881f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.03628932f, 0.02582591f, 0.02793542f, -0.03008349f, -0.07583330f, -0.07384837f, 0.05710657f, 0.04307805f, 
    0.06537312f, 0.01058663f, 0.06503765f, -0.07144916f, -0.07798936f, -0.03473566f, 0.01840827f, -0.07444754f, 
    0.02569239f, -0.04430113f, -0.00538142f, -0.00350319f, 0.00185334f, -0.09189761f, -0.03165541f, 0.05331498f, 
    -0.05628705f, 0.00902793f, -0.08057140f, -0.00711290f, -0.01055811f, -0.00698789f, 0.04393602f, 0.03072770f, 
    -0.03261108f, 0.04051165f, -0.07571092f, 0.05007557f, -0.03718565f, -0.08805964f, 0.07130400f, -0.07130209f, 
    -0.05188432f, -0.01019037f, -0.02973867f, 0.01815187f, -0.05725159f, -0.07444691f, -0.02126190f, -0.01725099f, 
    -0.06581011f, -0.03620068f, 0.00567840f, 0.06756011f, 0.01735030f, -0.01828384f, -0.04963313f, -0.04334533f, 
    0.06680534f, -0.06292021f, -0.07488303f, -0.06534582f, 0.02618735f, -0.02512692f, -0.04600585f, 0.06405903f, 
    0.05746362f, -0.02939966f, -0.02514219f, -0.03043300f, -0.05994016f, 0.06517533f, -0.01066928f, 0.05610200f, 
    -0.00810149f, 0.03904509f, -0.00326034f, -0.04042833f, -0.00517799f, 0.06904288f, -0.08517859f, -0.07794518f, 
    0.01994021f, 0.00133288f, 0.00885323f, -0.02077705f, -0.07570137f, -0.06749955f, 0.06124171f, -0.06120415f, 
    -0.07500376f, 0.04737054f, 0.04112495f, -0.06192730f, -0.02815816f, -0.04995401f, -0.02890318f, -0.04339852f, 
    0.05086799f, -0.05733884f, -0.04790283f, 0.01263466f, -0.03261222f, 0.01128337f, 0.02930637f, 0.04407192f, 
    -0.05489868f, 0.04659710f, 0.02238129f, 0.03705980f, 0.03278724f, 0.05105006f, 0.00405702f, -0.06306446f, 
    -0.07501353f, -0.07275631f, -0.08155544f, -0.06996515f, 0.00721429f, 0.07266146f, 0.03393364f, 0.00674446f, 
    0.05791579f, -0.08517348f, -0.07331622f, -0.04952683f, -0.01645474f, 0.02725496f, -0.05201645f, 0.01332174f, 
    -0.01023006f, -0.01241187f, -0.04589010f, 0.07189275f, 0.00414853f, -0.01167637f, -0.08381332f, -0.03526027f, 
    -0.01907097f, 0.06266975f, 0.00438953f, -0.07493091f, 0.02537721f, -0.03922267f, -0.03955146f, -0.05942544f, 
    -0.80209970f, -0.24641208f, 0.24458595f, -0.29064882f, -0.12936901f, -0.31615144f, 0.03747130f, 0.03147677f, 
    0.03509354f, -0.23467223f, 0.04175581f, 0.00508405f, -0.19679910f, -0.09050455f, -0.15654032f, 0.12594239f, 
    0.02740873f, 0.17202140f, 0.18477292f, 0.15172011f, 0.23556952f, -0.02084523f, 0.06915200f, -0.19778067f, 
    -0.09570054f, -0.00036420f, -0.04226363f, -0.36454213f, -0.29223821f, 0.13377076f, -0.02875903f, 0.13209745f, 
    0.05150595f, -0.11632375f, 0.10564206f, 0.04713773f, 0.26083502f, 0.15807992f, -0.23647456f, -0.13802162f, 
    0.00204412f, 0.05922091f, -0.09147476f, -0.08681466f, -0.26873747f, -0.34764373f, -0.23899771f, -0.46730646f, 
    -0.05710408f, -0.05439012f, -0.00710135f, 0.08333720f, 0.17974934f, -0.08322819f, 0.24128123f, 0.48786944f, 
    0.00208085f, -0.04610149f, -0.15509439f, -0.18370247f, 0.15120409f, 0.11558764f, 0.03661723f, -0.41681781f, 
    0.04900667f, 0.04794915f, -0.46012264f, 0.13512844f, 0.02203040f, 0.17560652f, 0.04166741f, -0.05994901f, 
    0.02345538f, -0.17981735f, 0.23784246f, 0.06065755f, -0.06702232f, -0.02501920f, 0.22280805f, -0.09941281f, 
    0.07541148f, -0.34304425f, -0.10501889f, 0.09033990f, 0.03839276f, 0.02710983f, -0.01294672f, 0.12298904f, 
    0.01999534f, 0.15060197f, -0.42270014f, 0.35951838f, -0.43417609f, -0.05331756f, -0.03186548f, 0.15666331f, 
    -0.00175818f, 0.11443263f, 0.04004607f, 0.02898760f, 0.16659555f, -0.08908720f, -0.10689288f, 0.12190295f, 
    -0.07037292f, 0.13964108f, -0.09101534f, -0.01268729f, 0.06555755f, -0.15677238f, -0.20409223f, 0.02217256f, 
    0.10042391f, 0.11732110f, 0.16704614f, -0.17767258f, -0.17895971f, 0.19941747f, 0.17328838f, 0.16717537f, 
    0.00751483f, -0.08154110f, -0.29010165f, 0.12333483f, -0.13899668f, 0.04559809f, 0.08723390f, 0.21939830f, 
    0.00924146f, 0.05810872f, 0.08225016f, -0.02106562f, -0.03582745f, 0.01067846f, 0.01291253f, 0.18510944f, 
    -0.07746748f, 0.06008036f, -0.00974078f, 0.04018068f, -0.03396798f, 0.11778777f, 0.03021014f, 0.05359541f, 
    0.04390962f, 0.11724271f, 0.02891972f, 0.00614595f, 0.10571043f, -0.18779752f, -0.03000193f, 0.16385065f, 
    -0.06602906f, 0.30085918f, -0.01299171f, -0.02843582f, 0.09242213f, -0.00279548f, -0.09849744f, -0.16366680f, 
    0.02311891f, 0.09487204f, -0.08074439f, -0.05866538f, -0.01130523f, 0.06980805f, 0.09994445f, -0.04608462f, 
    -0.12059032f, 0.07681545f, -0.09910070f, -0.07522736f, 0.06360494f, 0.06007656f, -0.14162403f, 0.18656407f, 
    -0.06049690f, 0.27031851f, 0.03566702f, 0.13799104f, -0.10307661f, 0.27307427f, 0.09191813f, -0.04376883f, 
    0.04760163f, 0.05217054f, -0.06140761f, -0.02205784f, -0.04020553f, 0.26895729f, -0.30211076f, 0.04648397f, 
    -0.02881059f, -0.11309836f, 0.26810333f, 0.07084283f, 0.09038472f, -0.10604858f, 0.19273271f, 0.33341590f, 
    0.17623280f, -0.20537294f, -0.10170770f, 0.05148935f, 0.01658208f, 0.05216364f, -0.15657233f, 0.41468951f, 
    0.24031323f, -0.30955964f, 0.05014195f, -0.00851975f, -0.05290771f, 0.11145228f, -0.03272418f, -0.01200033f, 
    0.26828188f, -0.20798659f, -0.42120191f, 0.08604618f, -0.10596164f, -0.09485506f, -0.02853398f, -0.03289331f, 
    -0.24379890f, 0.15042384f, -0.31410486f, -0.10134582f, -0.17936309f, -0.10503821f, -0.15411763f, 0.01694593f, 
    0.05578185f, -0.05516986f, -0.38259858f, -0.13851877f, -0.18844803f, 0.13536327f, 0.14685161f, 0.07982802f, 
    -0.11852414f, 0.23516972f, -0.23081106f, 0.08830953f, 0.01443102f, -0.04055605f, -0.06965028f, 0.08446598f, 
    -0.00518252f, -0.04550012f, -0.31194431f, 0.29502973f, 0.09750650f, 0.03530051f, 0.16259651f, -0.04832866f, 
    -0.01831729f, 0.17662920f, 0.02335041f, 0.02901623f, -0.04125941f, 0.50390273f, -0.20081872f, -0.12509449f, 
    0.02943843f, -0.06463744f, -0.25571838f, 0.05217178f, 0.09391451f, -0.20687078f, -0.58602947f, 0.19283998f, 
    0.26884755f, -0.21612339f, 0.03556634f, 0.22385968f, 0.15226610f, -0.09538642f, -0.06571009f, 0.38825500f, 
    -0.11227337f, 0.05712111f, -0.11222973f, 0.00681075f, 0.04902833f, -0.11781994f, -0.06190559f, 0.05533325f, 
    0.07449670f, 0.30503494f, 0.15894577f, -0.04494722f, -0.14266887f, -0.43165773f, 0.14186761f, 0.01771664f, 
    -0.15490499f, -0.03418163f, -0.31381941f, 0.31675455f, -0.28299367f, -0.21710022f, 0.04435019f, -0.15832967f, 
    0.06067722f, -0.01145653f, -0.49983987f, 0.21859159f, 0.26323399f, -0.15496509f, 0.01523011f, -0.12003084f, 
    0.15221637f, -0.04121178f, 0.03841320f, -0.13438118f, 0.37437585f, 0.22092184f, 0.07013785f, 0.14522247f, 
    0.03536699f, 0.20682153f, 0.15065765f, 0.03677665f, -0.21315110f, 0.09320046f, -0.20008086f, -0.03824728f, 
    -0.14438722f, -0.06872142f, 0.09212070f, -0.03396226f, 0.09568349f, 0.05691416f, -0.19704001f, 0.60652405f, 
    0.13334697f, 0.01487642f, 0.42388949f, -0.15117325f, 0.00085155f, 0.05958080f, -0.04218005f, -0.04409115f, 
    0.13963296f, 0.02348246f, -0.10869253f, -0.05008246f, -0.02093935f, -0.08953910f, 0.21155168f, -0.45088691f, 
    -0.64884096f, -0.25968498f, -0.13577746f, -0.11385987f, 0.11911473f, 0.04893789f, -0.03943738f, 0.06681313f, 
    0.04231043f, 0.01892005f, -0.09535141f, -0.15471703f, -0.05762793f, 0.09622975f, 0.04191361f, 0.03622359f, 
    0.13045232f, 0.11163548f, -0.48655865f, -0.10851013f, 0.11212702f, 0.24160331f, -0.17138411f, -0.09574483f, 
    0.05800402f, 0.05764927f, -0.17259565f, 0.16056518f, -0.06975122f, 0.08774672f, -0.17043030f, 0.05978940f, 
    0.11102683f, 0.05072274f, -0.00957764f, 0.59605396f, -0.34622866f, -0.11988704f, -0.22940563f, -0.12650709f, 
    -0.06655043f, 0.14646429f, -0.02843250f, -0.17588358f, 0.33987528f, 0.09405141f, -0.05526036f, -0.03216856f, 
    0.09137512f, 0.05059460f, 0.05777435f, -0.05645628f, -0.06166397f, 0.03427327f, 0.22819233f, -0.54148245f, 
    0.00092597f, -0.09244703f, 0.07026748f, -0.04629539f, 0.06365962f, -0.14818293f, 0.09526379f, -0.16437207f, 
    0.10828415f, -0.07545424f, -0.04349229f, 0.31226864f, 0.05514317f, -0.03755092f, -0.13295695f, -0.30161524f, 
    -0.34665617f, 0.01501931f, 0.06681602f, 0.06994949f, -0.05514838f, -0.01923878f, 0.17385451f, -0.10299758f, 
    -0.09108278f, -0.14721859f, -0.00892979f, -0.05569126f, 0.15888211f, -0.04320002f, -0.05137338f, -0.06280198f, 
    0.08605750f, -0.06362722f, -0.11287977f, -0.32753268f, -0.22592770f, -0.12931472f, -0.12292873f, -0.03179485f, 
    0.10981905f, 0.04929635f, -0.34413931f, -0.74324518f, -0.26332417f, 0.01809665f, -0.13257527f, -0.28719050f, 
    -0.07693239f, -0.10140090f, 0.06535648f, 0.31255901f, 0.31522706f, -0.08578788f, 0.24416406f, -0.06716011f, 
    0.00699245f, -0.02852586f, 0.01771334f, 0.13019735f, 0.10415960f, -0.32952306f, -0.09440603f, -0.07892917f, 
    0.15622130f, -0.05784939f, 0.02858862f, -0.04381552f, -0.01169567f, 0.25372896f, 0.27032471f, -0.09112575f, 
    -0.02501697f, -0.10365465f, 0.00052756f, -0.02547069f, -0.11481522f, 0.16001885f, -0.25104010f, -0.05234512f, 
    0.06006527f, 0.05619390f, 0.12135379f, -0.00744052f, -0.14539047f, 0.10631014f, 0.12792966f, -0.27674559f, 
    -0.04666753f, 0.30591306f, 0.02509383f, 0.14822333f, -0.08467177f, 0.08330798f, -0.13004716f, -0.05922387f, 
    -0.19657950f, 0.02729818f, 0.06864327f, 0.09401046f, 0.31920657f, 0.02966075f, 0.06023140f, -0.01832804f, 
    0.07967363f, 0.06125950f, -0.00768453f, 0.10739253f, -0.01986765f, -0.00730415f, 0.16812633f, 0.01015948f, 
    0.02305333f, -0.03601762f, 0.06401861f, 0.08880868f, 0.14792402f, -0.07252201f, 0.07237001f, -0.16958028f, 
    0.02766479f, 0.15057954f, -0.11825777f, -0.03627571f, -0.31766436f, -0.03440456f, -0.14673957f, 0.04011829f, 
    0.06590676f, -0.14036047f, 0.11610992f, 0.04997557f, 0.38482583f, 0.26617315f, -0.22267401f, -0.08944734f, 
    -0.00775304f, 0.18964535f, 0.09056653f, -0.04712782f, -0.00279267f, -0.33743650f, -0.19302428f, 0.13900740f, 
    0.09913245f, 0.22073501f, 0.20804697f, -0.25574192f, 0.03377238f, -0.00301974f, -0.51099348f, -0.15167619f, 
    -0.21945764f, 0.04511997f, -0.02102553f, -0.12725542f, 0.06908586f, -0.01107269f, -0.06767578f, -0.25253278f, 
    -0.02320983f, -0.01593658f, -0.02397378f, 0.10149295f, 0.01859306f, 0.10203825f, 0.05319255f, 0.02553807f, 
    -0.34299797f, -0.18599930f, -0.05402096f, -0.22077358f, -0.01219463f, 0.21751073f, 0.08336280f, 0.13418396f, 
    -0.00228013f, -0.00901729f, -0.31457502f, 0.31927517f, -0.00058502f, 0.05850790f, 0.08923683f, -0.00173844f, 
    0.20637670f, -0.18722939f, 0.19356456f, -0.33549181f, 0.09567612f, -0.00531282f, -0.15132283f, -0.19546713f, 
    -0.10526180f, -0.09428029f, 0.06313507f, 0.25986621f, 0.10945593f, -0.14214303f, -0.29248479f, 0.19647890f, 
    0.16723108f, -0.01825042f, 0.07377706f, -0.06766274f, 0.13747510f, 0.16631837f, 0.06149767f, -0.18858576f, 
    0.01728423f, -0.00800691f, -0.16659598f, 0.05281761f, -0.12139273f, 0.55734587f, -0.29133359f, -0.17978303f, 
    0.10606024f, -0.09026324f, 0.12091941f, -0.01887748f, -0.21646082f, 0.19363672f, -0.18278565f, 0.03592967f, 
    0.00581540f, 0.01397872f, -0.15863425f, -0.12556666f, 0.08510346f, 0.07173963f, 0.00495805f, -0.06495233f, 
    0.05599260f, -0.38652667f, -0.06808693f, -0.23465395f, 0.00146290f, 0.10847002f, 0.13409904f, -0.03475685f, 
    -0.01785757f, 0.23313819f, 0.04238640f, 0.02067879f, 0.04501634f, -0.02282768f, 0.02308703f, 0.04087998f, 
    0.19815361f, -0.31487086f, 0.19237565f, 0.16925795f, 0.01762332f, 0.18300690f, 0.17795332f, 0.15030655f, 
    0.06685778f, 0.07024563f, 0.44261575f, -0.55019826f, -0.31821272f, 0.04786105f, -0.23442300f, 0.06205108f, 
    0.19682211f, 0.24669355f, -0.06094957f, 0.01014815f, 0.06948122f, 0.15658826f, 0.00833966f, -0.10815819f, 
    -0.09287573f, 0.09043325f, -0.14915423f, 0.18321542f, -0.00885019f, -0.33122891f, -0.25603852f, 0.03630501f, 
    0.04259253f, 0.00645456f, 0.19362520f, 0.09963284f, 0.24807762f, -0.21059556f, 0.13378480f, -0.01170917f, 
    0.05566146f, -0.05035263f, -0.05988259f, 0.07215796f, -0.01361182f, -0.00212446f, 0.23802930f, -0.09369124f, 
    0.05355600f, 0.07443950f, 0.07001830f, -0.16943118f, 0.01372034f, -0.07622014f, -0.11114819f, 0.17741792f, 
    -0.41238067f, 0.17743206f, 0.15237407f, 0.05968425f, -0.05958301f, 0.20563325f, 0.07978936f, 0.14478321f, 
    -0.23204854f, -0.41882607f, 0.09233662f, 0.10305078f, 0.04363897f, -0.13429262f, 0.09381382f, 0.07160687f, 
    0.04962916f, -0.06503645f, -0.08228967f, -0.58842230f, 0.00100487f, 0.00680136f, -0.17699547f, 0.09556557f, 
    -0.11062223f, 0.12919785f, -0.06585477f, -0.68621236f, -0.02103242f, -0.08518869f, -0.06283633f, -0.23596549f, 
    -0.04466734f, -0.00263937f, -0.17271638f, 0.20625542f, 0.27189785f, 0.00623041f, 0.20193575f, 0.11049099f, 
    0.01168334f, 0.04982935f, 0.22184017f, 0.06238769f, 0.20378278f, -0.29185653f, -0.28982413f, 0.07371893f, 
    0.06451984f, 0.01064246f, 0.09472582f, 0.01538226f, -0.26311779f, -0.14532995f, 0.24249907f, -0.43298873f, 
    -0.09422945f, 0.06831320f, 0.11265760f, 0.33408904f, -0.09062023f, 0.05494631f, -0.02343122f, -0.02589833f, 
    -0.18221626f, -0.29045454f, -0.09714485f, -0.08266709f, 0.06162254f, 0.05322009f, 0.03907027f, -0.26651111f, 
    0.13808626f, 0.16486692f, -0.20033866f, -0.06486195f, -0.10988054f, 0.02536918f, -0.02758501f, 0.13900703f, 
    0.04508933f, 0.16747089f, 0.27429876f, 0.15119846f, 0.01562293f, -0.01361526f, 0.01109681f, -0.02770784f, 
    -0.03325456f, 0.13989037f, -0.03782905f, 0.18519808f, 0.01352018f, -0.15659681f, -0.02728925f, 0.06258482f, 
    0.16233501f, 0.22605892f, -0.27790612f, 0.15257056f, -0.24425010f, -0.11306126f, -0.14447252f, 0.06854045f, 
    0.10265612f, 0.07001210f, 0.17199713f, -0.10765184f, -0.50212073f, -0.31773141f, 0.07730430f, -0.07673144f, 
    -0.20317079f, -0.13315530f, -0.10628204f, -0.02626441f, 0.19569500f, -0.03648703f, -0.22498667f, 0.02255747f, 
    -0.02274851f, 0.28002039f, 0.03045656f, -0.08102017f, 0.01534877f, -0.18125704f, 0.01145615f, 0.27584356f, 
    -0.00796086f, 0.16246368f, -0.00495780f, -0.05972278f, -0.11344836f, 0.17336364f, -0.08824393f, -0.19978286f, 
    -0.61480391f, -0.02095988f, -0.07686198f, -0.10562319f, 0.10990681f, 0.05272193f, -0.14424056f, -0.17417538f, 
    0.15931615f, 0.11424257f, 0.01133530f, 0.05354737f, 0.00398096f, 0.13800129f, 0.03612031f, 0.07895350f, 
    -0.22109908f, -0.07369272f, -0.35487407f, -0.03734745f, -0.06730304f, 0.06936379f, 0.01327466f, 0.01153174f, 
    0.05326188f, 0.09682541f, 0.07331500f, 0.12959090f, -0.05831579f, -0.14435314f, -0.29968590f, 0.10262015f, 
    -0.00282524f, 0.14123780f, 0.17716919f, 0.33291999f, 0.29480347f, -0.12116380f, 0.14743499f, -0.12423780f, 
    -0.12477119f, 0.05263619f, -0.02458527f, -0.31969938f, -0.30581245f, -0.09450287f, -0.00038469f, 0.03913277f, 
    0.07357535f, -0.04254844f, -0.07364818f, -0.15091546f, -0.24729346f, -0.24308702f, -0.07928434f, -0.04991250f, 
    0.11547378f, -0.03015041f, 0.13488168f, -0.04791647f, 0.18197043f, -0.16886684f, 0.10489329f, -0.53626281f, 
    0.15461572f, 0.07812074f, -0.02753657f, -0.05610322f, 0.09393597f, -0.11559844f, -0.05328450f, 0.13218823f, 
    -0.17306007f, 0.05623058f, -0.20129760f, -0.31195337f, -0.03894950f, 0.00524902f, 0.01512556f, -0.28339303f, 
    -0.09588195f, -0.08646100f, -0.27412507f, 0.00150631f, 0.20613244f, 0.02816757f, 0.27182606f, 0.04175163f, 
    0.18914533f, 0.17868689f, 0.17786658f, -0.11743607f, -0.07857026f, 0.29569206f, -0.01128340f, 0.02583865f, 
    -0.12437085f, 0.45234928f, -0.03173932f, 0.05514824f, -0.01251826f, -0.01563912f, 0.09808111f, -0.06280423f, 
    0.07873550f, -0.12376356f, -0.09068408f, -0.00419356f, -0.15355000f, 0.01487956f, 0.09120543f, -0.11173421f, 
    -0.13524894f, -0.01664758f, 0.00234218f, 0.06918051f, 0.31111544f, 0.27369466f, -0.22284484f, 0.04329363f, 
    0.04596430f, 0.25037342f, -0.09834063f, 0.01133952f, 0.08987683f, 0.02076177f, -0.05491436f, 0.11352558f, 
    -0.01814103f, -0.18534817f, 0.05690895f, 0.01955234f, 0.11891238f, 0.10161625f, 0.20720945f, -0.01247713f, 
    -0.07502595f, 0.02448846f, 0.00151827f, 0.02799894f, 0.15838775f, -0.00205417f, 0.12519942f, 0.26925567f, 
    0.19113721f, -0.02296382f, -0.12481326f, 0.13292705f, -0.00535528f, -0.06593399f, -0.16669236f, 0.24841839f, 
    0.18872078f, 0.16524844f, 0.10705560f, 0.12275632f, 0.10584554f, 0.04144108f, 0.13930662f, 0.19777778f, 
    0.00205151f, -0.08374885f, -0.01938409f, -0.04202180f, -0.00991419f, -0.08561368f, -0.07549638f, -0.08256765f, 
    -0.07325443f, 0.05103378f, -0.04020851f, 0.06080299f, 0.00142528f, 0.04275431f, 0.02689141f, -0.07845104f, 
    0.03351354f, -0.04786974f, -0.05036777f, -0.05434293f, -0.02982389f, -0.03234596f, -0.00722801f, -0.04503036f, 
    -0.07613377f, 0.03360125f, -0.05622193f, -0.01221380f, -0.04677851f, -0.04953765f, -0.03090907f, 0.04183391f, 
    -0.04537354f, -0.08917808f, 0.03824668f, -0.05881679f, 0.00252938f, 0.06136563f, 0.02580476f, -0.07546423f, 
    -0.04347038f, 0.01040492f, -0.08164224f, -0.08907361f, -0.00403476f, -0.02547025f, -0.07546517f, 0.04024080f, 
    0.05629171f, -0.02802679f, 0.05901938f, 0.02704395f, 0.00974267f, 0.02333987f, -0.03870738f, 0.06819125f, 
    0.00621608f, 0.04662795f, -0.06586733f, 0.01824497f, -0.05451345f, -0.04687116f, 0.00263619f, -0.00789565f, 
    -0.06415099f, 0.01888766f, -0.03046526f, 0.05945179f, -0.04067902f, 0.01348386f, 0.02713061f, -0.00587418f, 
    0.06825844f, 0.02009237f, 0.04978355f, -0.03633158f, -0.02806309f, -0.02354524f, 0.00290054f, 0.00756744f, 
    -0.00280843f, 0.03862263f, -0.01897567f, 0.04772323f, -0.01381795f, 0.04086807f, 0.03753212f, -0.06457860f, 
    -0.01985538f, 0.07196071f, -0.05768726f, 0.06958125f, -0.03892881f, -0.03557227f, 0.05591468f, -0.08832596f, 
    -0.00443989f, 0.06049475f, 0.05144079f, -0.02988882f, -0.07956352f, -0.03709809f, -0.08245200f, 0.05628090f, 
    0.06114979f, -0.08266258f, -0.00411530f, 0.05667701f, 0.00815695f, -0.08634461f, -0.02085420f, -0.01873177f, 
    -0.08860129f, -0.08075613f, -0.01599301f, -0.04168887f, -0.03409653f, -0.03832822f, 0.00610691f, 0.04144682f, 
    -0.08438259f, 0.05097466f, 0.05553870f, -0.04113849f, -0.01145003f, -0.01664199f, -0.02375321f, -0.06587172f, 
    0.05635539f, 0.05715833f, -0.04127830f, 0.03507571f, 0.02741623f, 0.02311958f, -0.01831279f, 0.00278129f, 
    0.05062275f, -0.05702236f, -0.04799605f, -0.03635404f, -0.05026814f, -0.09488544f, -0.07379557f, -0.01755363f, 
    -0.05625414f, -0.04684123f, -0.02827683f, 0.01006693f, -0.06331839f, 0.00422801f, -0.05874261f, -0.07137343f, 
    0.00459428f, -0.00577257f, 0.03355791f, -0.04939073f, 0.05397470f, -0.01430307f, -0.04953534f, -0.02780687f, 
    -0.02040933f, -0.03347139f, -0.08907238f, 0.01632828f, -0.03802907f, -0.01237224f, -0.08825765f, 0.00894670f, 
    -0.05408120f, -0.02310303f, -0.02803045f, 0.06808424f, -0.06289955f, -0.06614629f, 0.05194279f, 0.06527920f, 
    -0.04624569f, -0.01571679f, -0.05570106f, -0.01951766f, 0.06705545f, 0.04755718f, 0.07471814f, -0.00325725f, 
    0.04990973f, 0.04626177f, -0.08309537f, 0.07019743f, -0.06566875f, 0.00846389f, -0.08079408f, 0.06010947f, 
    0.02977793f, 0.07110941f, -0.06096964f, -0.07471278f, -0.02111132f, -0.03703323f, -0.06874131f, 0.07171824f, 
    -0.08448474f, -0.03834087f, -0.03553711f, -0.00673119f, -0.03976411f, 0.01322398f, 0.00962665f, -0.08506633f, 
    -0.05699202f, -0.04465628f, 0.01690272f, 0.03570105f, 0.05443662f, -0.04983431f, -0.04860827f, -0.02756273f, 
    0.06456217f, 0.04218438f, -0.06113486f, 0.02899990f, -0.01827161f, -0.01218160f, 0.05942155f, -0.04513057f, 
    0.06189411f, -0.03028542f, 0.02556419f, -0.08857036f, -0.08116207f, -0.08076626f, 0.04625115f, -0.03111959f, 
    -0.07509191f, -0.08212183f, -0.01257249f, -0.04413679f, -0.04753941f, -0.03217865f, 0.06627558f, 0.03117003f, 
    0.06068901f, -0.08889815f, 0.07646814f, -0.04825371f, -0.03257943f, -0.07760616f, -0.01524631f, -0.06208937f, 
    0.06672215f, -0.06646345f, 0.02144478f, 0.02806764f, 0.07517993f, 0.01805351f, -0.00372813f, -0.06506906f, 
    -0.00898394f, -0.01054122f, -0.02870704f, -0.08833097f, 0.02727362f, -0.02527610f, -0.00391984f, 0.03016675f, 
    -0.03697990f, -0.04125777f, -0.07119509f, 0.04959623f, -0.01577478f, 0.01328811f, 0.01103491f, 0.01358994f, 
    -0.00078071f, -0.01873644f, -0.08348129f, -0.02156161f, -0.07337851f, 0.06298171f, -0.02234324f, 0.05142792f, 
    -0.04868614f, -0.08618947f, -0.05064851f, 0.04736640f, -0.06478545f, 0.02830440f, -0.05327259f, -0.07077426f, 
    -0.15566392f, 0.29928997f, -0.01891096f, 0.01711434f, 0.15065777f, 0.15034270f, 0.02995552f, 0.27910718f, 
    0.11373489f, -0.13830459f, -0.15444100f, -0.27036646f, 0.20959604f, 0.03180955f, 0.13081212f, 0.02269824f, 
    -0.09403896f, -0.04522204f, -0.00099595f, 0.08229357f, -0.29982507f, -0.14212708f, 0.10582979f, 0.05124789f, 
    0.07714623f, 0.00912989f, -0.00900359f, 0.09449529f, 0.35483319f, 0.11312047f, 0.05291522f, -0.07516935f, 
    0.07845400f, -0.03914891f, 0.03181149f, -0.12058444f, -0.18686438f, -0.08908773f, -0.09338041f, -0.09620261f, 
    0.08071325f, 0.10751441f, 0.13738243f, 0.17358437f, 0.13448307f, -0.04116523f, -0.31356192f, 0.43654749f, 
    0.06092640f, 0.12117368f, -0.01014062f, -0.09479645f, 0.10616909f, -0.13129607f, -0.25791162f, -0.23497011f, 
    -0.18915181f, 0.21642829f, 0.13720578f, 0.01034432f, -0.07303757f, -0.04426228f, -0.11531019f, -0.22465089f, 
    0.39954636f, 0.21591987f, 0.06824630f, 0.12620319f, -0.14395867f, 0.00798612f, 0.30628502f, -0.03573608f, 
    -0.05766747f, 0.03671496f, 0.14773183f, -0.03989492f, -0.02880052f, -0.02347059f, -0.06411551f, -0.04613854f, 
    0.00198812f, 0.08290961f, 0.10853803f, -0.09870069f, 0.16406424f, -0.04115804f, -0.03458773f, -0.21276796f, 
    -0.18021367f, -0.16767065f, -0.21927214f, 0.06201977f, 0.49261770f, -0.09563778f, 0.09622911f, -0.03558271f, 
    -0.08794049f, -0.25709400f, 0.42066953f, -0.09222053f, 0.12099510f, 0.10137210f, 0.11030909f, 0.05003918f, 
    0.00763502f, 0.07453331f, -0.06783297f, 0.01758135f, -0.20635647f, 0.34183434f, 0.11284585f, -0.07089929f, 
    -0.06955224f, 0.13618071f, 0.03466463f, 0.18573318f, 0.23389894f, -0.05204197f, -0.01862320f, 0.14502880f, 
    0.06340326f, -0.05196315f, -0.09350608f, -0.05982471f, -0.21280560f, -0.11550446f, 0.23003955f, -0.21665002f, 
    0.20096298f, 0.13930023f, 0.02255419f, -0.05096182f, -0.07093066f, 0.06249293f, -0.08964156f, -0.06067963f, 
    0.24674569f, 0.14527446f, 0.09934258f, -0.01930733f, -0.21092679f, 0.03812503f, 0.19691604f, 0.22931316f, 
    -0.22602074f, -0.12004476f, -0.15542431f, 0.05334634f, -0.09134665f, 0.14125416f, 0.05545386f, 0.06274451f, 
    0.00806132f, -0.11626954f, -0.21747896f, -0.09707930f, 0.01024572f, -0.09083975f, 0.16154742f, 0.04010890f, 
    0.10284673f, -0.13226071f, 0.05989804f, 0.14663287f, -0.08953875f, 0.05081230f, -0.07410494f, -0.07031696f, 
    -0.00885037f, 0.07983469f, 0.05382065f, 0.14827882f, -0.26717928f, 0.05980456f, 0.11073951f, -0.07143687f, 
    0.09167919f, -0.14865287f, 0.02237365f, -0.15198360f, -0.34836674f, -0.27424690f, -0.28418654f, 0.02025824f, 
    -0.11558844f, 0.39722511f, 0.12757157f, 0.14064862f, -0.23218296f, -0.02893736f, 0.08626089f, -0.05935828f, 
    0.18568818f, 0.20359860f, -0.10463308f, 0.07397266f, -0.12537323f, -0.03111274f, -0.30103064f, -0.20150772f, 
    -0.26815298f, 0.11907860f, 0.27380911f, 0.05469735f, -0.16320539f, -0.16508283f, -0.00018989f, 0.12168010f, 
    -0.07801846f, -0.17852093f, 0.07038595f, -0.17691898f, 0.13564630f, -0.09797745f, 0.00429107f, 0.12425062f, 
    0.17351161f, 0.16333114f, -0.05880585f, -0.05166390f, -0.15429905f, -0.13710883f, -0.14640227f, 0.06805894f, 
    0.17521733f, -0.09521770f, 0.16751359f, 0.00368356f, 0.16746083f, -0.01935550f, 0.24773827f, -0.09390447f, 
    -0.22218901f, -0.27749357f, 0.61500710f, 0.20523284f, -0.25584859f, 0.20657325f, 0.10316927f, 0.02491221f, 
    0.20330369f, -0.07949821f, -0.16875257f, -0.30349535f, 0.12611058f, 0.20992355f, 0.01622964f, 0.04253155f, 
    -0.05080346f, 0.12592724f, 0.00232630f, -0.04647979f, -0.03019607f, -0.09785917f, -0.44292665f, 0.19020694f, 
    -0.01174959f, -0.12151808f, 0.14684696f, 0.21558759f, 0.16475403f, 0.02730602f, 0.21501856f, 0.22569619f, 
    0.08291050f, -0.08793981f, -0.13598411f, -0.01389558f, -0.02489984f, -0.07208914f, 0.02996979f, 0.12575883f, 
    -0.03734357f, 0.19732989f, 0.04791925f, 0.19149102f, -0.03541823f, -0.04299931f, -0.10015449f, 0.03784957f, 
    -0.03305011f, 0.26777992f, -0.23508012f, -0.21906352f, -0.02611016f, 0.30303842f, 0.17782296f, 0.28971347f, 
    -0.19214876f, 0.16342421f, 0.47799781f, 0.09049148f, 0.11536518f, -0.02916539f, 0.05432746f, 0.08319604f, 
    -0.04838946f, -0.31796449f, -0.15940054f, 0.36917242f, -0.05291839f, 0.09329899f, -0.04311090f, 0.13203402f, 
    0.15784860f, -0.03426749f, -0.19272897f, 0.16145314f, 0.04782468f, -0.07746840f, 0.08555219f, 0.01527071f, 
    -0.07069117f, 0.16145918f, -0.05406608f, -0.22670577f, 0.47276640f, 0.03731561f, 0.02126046f, 0.10798909f, 
    -0.02860716f, -0.15573519f, 0.31766725f, 0.14181268f, -0.18927015f, -0.59351623f, -0.32569295f, 0.07273238f, 
    -0.06597889f, 0.16174589f, 0.08818948f, 0.01138779f, 0.18931292f, 0.37318796f, -0.28259453f, 0.04763807f, 
    0.07664351f, -0.18798925f, 0.02774338f, -0.04799979f, 0.03974280f, 0.14120513f, 0.16324487f, 0.12300577f, 
    0.32779819f, -0.22273730f, -0.00837253f, -0.44156808f, 0.11095241f, -0.19869410f, 0.04634706f, 0.10039628f, 
    -0.22026744f, -0.07428765f, -0.09468825f, 0.08062231f, -0.15186441f, 0.11153870f, 0.00027993f, -0.19156136f, 
    -0.37039760f, 0.04730739f, -0.49342531f, -0.13698600f, 0.00087843f, -0.05983521f, -0.05606758f, 0.05388700f, 
    0.05582195f, -0.00856270f, -0.19610828f, -0.19259542f, 0.05353238f, 0.10380831f, -0.11147850f, -0.02148198f, 
    -0.21293147f, -0.14146017f, 0.31020817f, -0.04916520f, 0.03155157f, 0.08344302f, -0.12201545f, -0.03242606f, 
    0.11011303f, 0.16201589f, -0.12183467f, 0.23043109f, 0.13955176f, -0.24573518f, -0.06540415f, -0.09714723f, 
    -0.17216671f, 0.09705235f, 0.13929252f, 0.11415872f, 0.20158622f, 0.23779176f, 0.22125235f, -0.06068806f, 
    -0.23645614f, 0.07504380f, -0.02575493f, 0.02361541f, 0.30007696f, -0.13215993f, -0.29364264f, -0.18486738f, 
    0.09738287f, -0.15547569f, 0.07393244f, 0.13882931f, -0.05351150f, -0.10251843f, 0.01668200f, 0.10843298f, 
    -0.27947941f, -0.00810128f, 0.05325465f, 0.00623899f, -0.19042039f, 0.02941345f, 0.05434753f, -0.18403317f, 
    0.07449574f, 0.08704844f, 0.01801451f, 0.14618985f, 0.11937904f, 0.01402349f, 0.13257124f, 0.22329120f, 
    0.45721558f, 0.05273629f, -0.05623738f, -0.03603333f, -0.16840714f, 0.12209653f, -0.02855716f, 0.14398928f, 
    -0.00209652f, 0.23572247f, 0.20481849f, 0.20861498f, 0.04414938f, -0.00274504f, -0.05039128f, 0.08307529f, 
    -0.01571813f, 0.23256415f, 0.12707506f, -0.04501164f, 0.00086854f, 0.10720611f, 0.11432216f, 0.29724744f, 
    -0.13374305f, -0.07732657f, -0.15061350f, 0.46632883f, 0.07584502f, 0.04659942f, -0.07027630f, 0.23078449f, 
    -0.01627665f, 0.21160507f, 0.13794681f, -0.20256341f, 0.08876270f, 0.44873935f, 0.19017568f, -0.03658469f, 
    0.01510160f, -0.18460357f, -0.11097524f, -0.06411082f, -0.12470441f, -0.04613083f, 0.35013145f, 0.12527977f, 
    -0.11090273f, -0.06863540f, 0.09189139f, 0.31956252f, 0.07728918f, 0.16796108f, -0.10184666f, -0.24448381f, 
    0.11278684f, -0.00439366f, 0.07607909f, 0.24954119f, -0.06239081f, -0.13091721f, -0.09414493f, -0.12420405f, 
    0.07489676f, 0.00301135f, 0.10561949f, 0.09784195f, 0.06629278f, -0.14131944f, 0.02309050f, 0.16243424f, 
    0.16668180f, -0.13148528f, 0.08485660f, 0.04882867f, -0.01599851f, 0.10661787f, 0.02988175f, 0.12670791f, 
    0.06916906f, -0.07485702f, -0.07116951f, -0.12241608f, -0.09340284f, 0.05779755f, 0.11401828f, 0.08681626f, 
    0.07921272f, 0.24151316f, -0.32881129f, 0.13537593f, -0.27673939f, 0.07956000f, 0.12327167f, -0.02285005f, 
    0.05808000f, 0.17895900f, 0.06702276f, 0.17018653f, -0.02389301f, 0.15481533f, 0.09540303f, -0.06077764f, 
    -0.16796076f, -0.00379367f, -0.02285572f, 0.20988551f, 0.27535897f, -0.13184795f, -0.08856549f, -0.05058796f, 
    -0.01752791f, 0.09506738f, -0.00683243f, 0.11176287f, -0.14136451f, 0.05519341f, -0.15875086f, 0.21308778f, 
    0.07009409f, -0.08184140f, 0.27529851f, 0.02608435f, 0.03903171f, 0.16178007f, -0.24478620f, 0.02963971f, 
    0.16929990f, -0.00275647f, 0.14460908f, 0.00720226f, -0.13929680f, 0.21466537f, -0.09466824f, 0.08384884f, 
    -0.12327560f, 0.03861849f, 0.14041516f, 0.13555968f, 0.06769175f, -0.01162832f, -0.26391414f, -0.31504053f, 
    -0.01012299f, -0.23890558f, -0.03855513f, -0.20896478f, 0.09616781f, -0.12400299f, 0.17698595f, -0.09088592f, 
    -0.05689094f, 0.60128820f, -0.03587757f, -0.31952539f, 0.08135950f, -0.19396001f, 0.18387331f, -0.04212811f, 
    -0.00096784f, -0.06694496f, 0.35626930f, 0.03088001f, -0.24561384f, -0.12235272f, -0.16699153f, -0.08081315f, 
    -0.01154884f, 0.09769680f, 0.02021543f, -0.10178891f, 0.12849033f, -0.02057613f, -0.07448746f, 0.02074376f, 
    0.15764806f, 0.09567974f, -0.13587114f, 0.02929980f, -0.07656038f, 0.08446410f, 0.05350899f, -0.28843406f, 
    -0.05803335f, 0.06757164f, -0.01274093f, -0.01374563f, -0.00300713f, -0.33249760f, -0.16579022f, 0.18855053f, 
    -0.07185721f, -0.18611147f, 0.02022910f, 0.05645865f, -0.06163425f, 0.17172982f, -0.15937953f, -0.13243030f, 
    0.28627810f, -0.26346791f, 0.16223668f, -0.00082702f, 0.01286466f, 0.11085937f, 0.00187308f, -0.27457365f, 
    -0.30924618f, -0.49907759f, -0.02287495f, 0.01679783f, -0.03007240f, 0.13461913f, -0.03176661f, -0.01649924f, 
    0.17347507f, 0.00089236f, -0.26168948f, -0.03715594f, 0.08722392f, -0.05447546f, -0.03828618f, 0.03517856f, 
    -0.05648437f, 0.24192466f, 0.06184606f, -0.03833269f, 0.08018140f, 0.12156740f, 0.01131531f, 0.12077702f, 
    0.09288333f, -0.05356769f, 0.08760725f, 0.31397226f, -0.50708807f, 0.06757779f, -0.09172731f, -0.02848009f, 
    0.05001619f, -0.04342559f, 0.08883719f, 0.19852206f, -0.11380519f, -0.10231203f, 0.13517413f, -0.10607211f, 
    -0.13020964f, -0.08202064f, 0.06936661f, 0.07599390f, 0.07056110f, -0.14804077f, -0.57981050f, 0.15219593f, 
    0.01341918f, 0.02264357f, 0.14130309f, 0.06348474f, 0.01689881f, 0.33714059f, 0.06285539f, -0.26794422f, 
    0.07302867f, -0.01456484f, 0.03874884f, 0.04420239f, -0.10522862f, 0.04960957f, 0.13624065f, -0.00293331f, 
    -0.13519534f, -0.13993056f, 0.17105052f, -0.32327560f, 0.07163106f, -0.01027579f, -0.04249027f, 0.18493912f, 
    -0.00367914f, -0.13607410f, 0.01987556f, 0.03145729f, 0.05350187f, 0.09338891f, -0.03258492f, 0.07653358f, 
    0.18947802f, 0.10885958f, -0.06701011f, 0.01235175f, -0.03951844f, -0.02139333f, -0.11950763f, 0.14276092f, 
    0.04887301f, 0.22078167f, 0.23488775f, -0.06258620f, -0.01732474f, -0.10879262f, 0.06557211f, 0.09784891f, 
    -0.18817586f, 0.00965017f, -0.24770051f, -0.06070217f, -0.05495120f, 0.22080599f, -0.05044549f, -0.16387421f, 
    0.07064727f, 0.01464655f, 0.11628413f, 0.12708452f, 0.30125821f, -0.02217725f, 0.03057102f, -0.02752535f, 
    -0.08900764f, -0.07578669f, 0.02590798f, -0.03084113f, 0.15524121f, 0.08299287f, 0.05655194f, 0.14710830f, 
    -0.00266507f, -0.11936931f, -0.08296886f, 0.00048448f, 0.10349079f, -0.04655263f, -0.04802218f, 0.26693317f, 
    0.00997649f, 0.12781778f, 0.13087390f, -0.15931448f, -0.04997963f, 0.14774716f, 0.25772864f, 0.14898540f, 
    -0.01554100f, 0.09032093f, 0.04124212f, -0.00253361f, -0.08082525f, -0.23560490f, -0.18966521f, 0.10573389f, 
    -0.07009039f, -0.13886857f, 0.04886349f, 0.15306954f, 0.11683396f, -0.16999303f, 0.15644364f, 0.06621635f, 
    0.07828746f, -0.23382913f, -0.14971860f, 0.10775546f, 0.02828215f, 0.02439462f, -0.02224379f, -0.16376427f, 
    0.13258003f, -0.20396362f, -0.09022655f, -0.27387980f, -0.10920229f, -0.03310279f, 0.17324945f, 0.15528025f, 
    0.16578947f, 0.19550896f, 0.05245922f, 0.06565264f, 0.19796839f, -0.05885187f, 0.05890486f, 0.17895035f, 
    0.13459843f, -0.01969128f, 0.03669634f, -0.08831783f, -0.04392689f, -0.03255652f, 0.17416757f, -0.14632267f, 
    0.00699203f, 0.19183032f, -0.11233494f, 0.06693362f, 0.11361763f, -0.02301212f, -0.07326668f, -0.04994451f, 
    0.01644797f, 0.05486996f, 0.10161548f, -0.27148005f, -0.15179716f, 0.10425589f, -0.20924275f, -0.11309071f, 
    0.04351980f, -0.04355358f, 0.12061651f, -0.19708650f, -0.15344851f, 0.17257799f, -0.06077031f, -0.00712184f, 
    0.08740617f, -0.05508371f, 0.03933551f, 0.01368961f, -0.22220097f, 0.06353866f, -0.14565955f, -0.12047057f, 
    -0.09746284f, -0.15627731f, 0.22564915f, 0.20833199f, -0.15840709f, -0.04940617f, 0.06038714f, -0.21979623f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.07992158f, 0.17525764f, -0.11927518f, 0.27704161f, 0.18898365f, 0.33763278f, 0.11150984f, -0.03480879f, 
    -0.07987321f, 0.00260860f, 0.09770730f, 0.16802174f, 0.02355999f, 0.05505579f, -0.00130991f, 0.02665273f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05130076f, -0.35125801f, -0.12619938f, -0.50360519f, 0.00835401f, 0.18676671f, 0.37786278f, -0.00560442f, 
    0.13950239f, -0.19191378f, 0.22619177f, 0.23632017f, -0.12700360f, 0.20432283f, -0.25393945f, -0.47189656f, 
    0.06570828f, -0.23854895f, -0.75120461f, -0.59235138f, 0.03016088f, -0.39461258f, -0.16247553f, 0.40815851f, 
    0.19990641f, -0.11796051f, -0.06865636f, 0.14155330f, -0.07799580f, -0.05965014f, 0.55876642f, -0.19578268f, 
    -0.13663018f, 0.20660871f, -0.31907973f, -0.11906235f, 0.33426660f, -0.05427746f, 0.50813043f, -0.39066875f, 
    -0.13424896f, 0.19201177f, 0.20849821f, -0.00175541f, -0.02834191f, 0.08135412f, -0.13204619f, 0.17579030f, 
    -0.10894570f, 0.08533240f, -0.37037468f, 0.34298554f, -0.09284850f, 0.45252040f, 0.04719213f, 0.20009555f, 
    0.11054269f, -0.10744548f, -0.03609065f, 0.33097133f, 0.22431228f, -0.38394859f, -0.44227076f, -0.12782407f, 
    0.14804828f, -0.05992740f, -0.42318854f, 0.28830290f, 0.39157459f, 0.26299939f, 0.22797523f, -0.27996296f, 
    -0.03834862f, -0.22075552f, 0.02329917f, -0.06936223f, -0.06138618f, 0.18256220f, -0.01925132f, -0.18431215f, 
    0.14230517f, 0.42824176f, 0.14822933f, 0.82683778f, 0.06363546f, 0.23189905f, -0.17120950f, 0.22488438f, 
    -0.02358985f, -0.05151555f, -0.31156644f, -0.20334537f, -0.47553939f, 0.04247584f, -0.05782485f, 0.31603557f, 
    -0.13300130f, 0.21131068f, -0.14411613f, -0.05470836f, 0.00422254f, -0.21432441f, -0.23964371f, -0.17800559f, 
    0.15446669f, -0.11575484f, -0.15656582f, 0.17744152f, -0.06312417f, -0.13688087f, -0.07581171f, 0.08977535f, 
    -0.07795791f, -0.07024337f, 0.22197838f, 0.17657386f, -0.20431556f, 0.03721178f, 0.40211123f, -0.23740175f, 
    0.20872770f, -0.12581806f, 0.22454441f, -0.37313879f, -0.17771000f, 0.20709677f, 0.62090445f, 0.02197525f, 
    0.03067753f, -0.07003377f, 0.21913262f, -0.18486097f, -0.01691268f, 0.19826132f, 0.23870413f, 0.10377549f, 
    -0.16728246f, -0.23827015f, -0.35200647f, 0.20766348f, 0.33695120f, -0.10842162f, 0.53572607f, -0.02494070f, 
    0.25571188f, 0.41414714f, -0.10330603f, -0.38670248f, -0.00770318f, 0.36516705f, 0.41820458f, 0.21343032f, 
    -0.19952485f, 0.20839010f, -0.13326934f, 0.26151785f, -0.00995399f, 0.22537367f, 0.26871979f, 0.00551971f, 
    -0.09579764f, -0.30796188f, -0.05662310f, 0.33462536f, -0.31170359f, 0.03465070f, -0.43268895f, 0.09805668f, 
    0.21914291f, -0.16466373f, 0.30634880f, 0.00573634f, 0.12183565f, 0.06155854f, 0.08255210f, -0.17068912f, 
    -0.00976888f, 0.52578771f, 0.20223068f, -0.05377131f, -0.71990168f, 0.21851955f, -0.27418011f, -0.12036809f, 
    0.09453148f, -0.09465656f, -0.03743124f, -0.09881599f, -0.11927434f, 0.15173888f, -0.29706001f, 0.46641347f, 
    0.21809375f, 0.12995495f, 0.40443698f, -0.05783663f, -0.43333998f, 0.13908362f, -0.01615861f, 0.02933870f, 
    0.17147964f, 0.13772573f, 0.10323695f, 0.08250596f, -0.29875261f, 0.23499738f, -0.33976474f, -0.45747468f, 
    -0.23123968f, 0.08712691f, -0.18124533f, 0.19636741f, -0.13867326f, -0.33705008f, 0.05861339f, 0.36117405f, 
    -0.11171983f, 0.24075584f, -0.25718313f, -0.02460190f, -0.59442270f, 0.22023486f, 0.78599668f, 0.38971198f, 
    -0.13507092f, -0.04856150f, -0.21379454f, -0.09140930f, 0.13334256f, -0.03831316f, -0.14762677f, -0.14350682f, 
    -0.18649122f, 0.22755989f, -0.24515662f, -0.11350855f, -0.10086535f, -0.00808661f, 0.16437398f, 0.05181899f, 
    0.23571241f, 0.53402567f, 0.31267440f, -0.35020560f, 0.15011206f, 0.37773573f, 0.52685404f, -0.25786749f, 
    -0.11489010f, 0.12395542f, -0.35865030f, -0.12714432f, -0.54417199f, 0.24058776f, -0.23564164f, 0.39636904f, 
    -0.09883636f, 0.15078536f, -0.24693082f, 0.43563113f, -0.04804853f, 0.19551730f, -0.40916637f, 0.49877775f, 
    -0.01750341f, 0.02188832f, 0.16180985f, 0.30124223f, -0.08999264f, -0.23921220f, 0.34168306f, -0.14192829f, 
    0.15938720f, 0.10280829f, -0.01241285f, 0.42113733f, 0.14645015f, 0.05416571f, -0.34970671f, -0.08425323f, 
    0.22815531f, -0.09180966f, 0.39715013f, 0.07995181f, 0.00431060f, -0.24657491f, -0.07937023f, -0.00843432f, 
    0.17077021f, 0.18754713f, -0.18630554f, -0.01030289f, -0.19856055f, -0.26949072f, -0.39228076f, 0.47971979f, 
    -0.23281172f, 0.15629576f, 0.25984794f, 0.18466301f, 0.32496727f, -0.14336212f, 0.14482979f, 0.17219837f, 
    0.15272827f, 0.02245656f, 0.40359357f, -0.12465412f, 0.02353773f, -0.20224592f, 0.23189826f, 0.11926411f, 
    -0.13840094f, 0.11056935f, -0.10544416f, 0.23296364f, 0.38448137f, -0.04460529f, 0.31554163f, -0.24411403f, 
    0.10574499f, -0.32050014f, -0.03695157f, -0.48474598f, -0.05458610f, 0.52004188f, -0.05214689f, 0.11527288f, 
    -0.06147379f, -0.18858138f, -0.21955261f, 0.41517457f, -0.12132127f, -0.08962090f, -0.17580235f, -0.43133089f, 
    -0.13337436f, -0.40439957f, 0.00398142f, 0.79813993f, 0.41807547f, 0.37801781f, -0.22460033f, -0.20268466f, 
    0.14874366f, 0.14672303f, 0.11644897f, 0.31372246f, -0.09605251f, -0.10837243f, -0.12255814f, 0.39052385f, 
    -0.21806373f, 0.27829614f, 0.21261679f, 0.26634711f, -0.36583951f, -0.33292827f, -0.10383576f, 0.46003294f, 
    0.19778518f, 0.05963083f, 0.02227190f, 0.14979409f, 0.09074509f, 0.04193678f, 0.26276049f, -0.06453161f, 
    0.03583209f, -0.08789627f, -0.34308749f, 0.06121618f, 0.35176003f, 0.04841007f, 0.34063277f, -0.04649127f, 
    0.04996525f, 0.05492968f, 0.14372009f, -0.07794156f, -0.56563497f, 0.17397618f, -0.12818876f, 0.10913607f, 
    -0.23707786f, -0.58660656f, 0.23910639f, -0.42305550f, 0.20964643f, 0.06378697f, 0.09436308f, 0.08338839f, 
    0.06704122f, 0.03511107f, -0.12175500f, 0.31408852f, 0.20663221f, 0.18395048f, -0.19556658f, -0.39162141f, 
    0.24170260f, -0.31677580f, -0.32567766f, -0.01392302f, 0.31290653f, 0.22834538f, 0.15061919f, -0.21102619f, 
    0.23751202f, -0.22987086f, 0.32975796f, 0.40555382f, -0.05888878f, -0.21614677f, 0.23839128f, -0.13837564f, 
    -0.16656262f, 0.11341409f, 0.39757612f, 0.34756926f, -0.11874598f, -0.20286885f, -0.23000476f, 0.28747535f, 
    -0.19490778f, 0.16716722f, -0.01843188f, 0.12006986f, -0.00991592f, -0.08203060f, 0.61701989f, 0.19558041f, 
    -0.19620326f, 0.47317371f, -0.26993889f, -0.01549268f, -0.31304774f, -0.01377916f, -0.23103964f, 0.31505859f, 
    -0.16778681f, -0.20945066f, 0.30875298f, 0.39879975f, -0.04534195f, -0.30970147f, 0.02355713f, 0.31025511f, 
    0.00222626f, -0.28201675f, 0.22829536f, 0.03459459f, -0.47895724f, 0.01341737f, -0.16837297f, -0.32338291f, 
    0.22195572f, 0.14106332f, -0.08039472f, 0.28707552f, 0.03868028f, 0.33018970f, 0.03273945f, -0.29489657f, 
    0.05735751f, -0.19005521f, -0.01113795f, 0.32510275f, 0.36022741f, -0.13151263f, 0.26708630f, -0.37971023f, 
    -0.23053423f, 0.15379418f, 0.20273389f, 0.03068006f, -0.14787006f, 0.32807210f, -0.05971715f, 0.20392771f, 
    0.05631253f, 0.38166025f, 0.11306244f, -0.44986588f, -0.50233322f, 0.35730073f, -0.03475641f, 0.37855619f, 
    -0.12683339f, 0.11058856f, 0.07101983f, 0.26765558f, -0.40390992f, 0.18403780f, -0.43049866f, -0.41402972f, 
    0.13366079f, -0.07200682f, -0.12465045f, -0.16913825f, -0.00217137f, 0.04013784f, 0.09809295f, 0.04791654f, 
    -0.20697072f, -0.03641796f, -0.09351557f, -0.21813123f, 0.02691863f, -0.04963123f, 0.04422002f, -0.26742244f, 
    -0.11403993f, 0.67460656f, -0.22809581f, -0.07264194f, -0.10255239f, 0.04666838f, 0.00626364f, 0.19778821f, 
    0.17811544f, 0.11662555f, -0.31006575f, 0.26442242f, -0.09938467f, -0.10909021f, 0.02443070f, 0.37961465f, 
    -0.02856104f, -0.51601177f, -0.25045446f, 0.30880278f, 0.16274402f, 0.20621391f, 0.22335754f, -0.02533877f, 
    -0.13483520f, 0.06570462f, -0.00689611f, 0.32582223f, 0.26589286f, -0.17892233f, 0.34690908f, -0.31254914f, 
    -0.17093465f, 0.25555226f, -0.51520252f, 0.05346438f, 0.18872781f, 0.26589847f, 0.27391899f, -0.43479615f, 
    0.22029346f, -0.23496567f, 0.13119775f, 0.03865530f, -0.11005058f, 0.13961776f, -0.01130882f, 0.04605267f, 
    -0.10564740f, -0.10523964f, 0.33746514f, 0.37152973f, -0.09941334f, -0.28090939f, -0.17073929f, 0.29193085f, 
    -0.19864547f, -0.03571725f, -0.27832231f, 0.14994828f, 0.04617586f, 0.27382055f, 0.21209294f, 0.14368954f, 
    -0.08501627f, 0.38623863f, 0.09323133f, 0.22663856f, -0.17469431f, 0.48118269f, 0.20805573f, 0.15329193f, 
    -0.21181938f, 0.00545275f, 0.02857334f, 0.24159670f, -0.32960263f, 0.22616571f, -0.48904476f, -0.07938195f, 
    0.13850476f, 0.45194358f, -0.00269304f, 0.66052151f, 0.16866678f, 0.15417036f, 0.09639561f, -0.20666879f, 
    0.22483276f, -0.18309976f, 0.23535383f, -0.15098937f, -0.41011125f, 0.14535944f, -0.52574611f, 0.37226889f, 
    -0.11258894f, -0.21879230f, -0.02038397f, 0.08609673f, -0.10796065f, 0.01300980f, -0.18134430f, -0.01365213f, 
    0.01106873f, 0.10432008f, 0.17574945f, -0.13514920f, -0.01827359f, -0.05973396f, -0.09158413f, -0.19710365f, 
    -0.06178603f, -0.12196027f, 0.15311964f, 0.06274138f, -0.28006968f, 0.00623114f, 0.27112740f, -0.38268611f, 
    -0.13414200f, 0.10060962f, -0.14411962f, 0.14460222f, -0.41638318f, 0.40053940f, -0.06996895f, 0.24979337f, 
    -0.15221494f, 0.00135204f, -0.16136368f, -0.09694567f, 0.09761757f, -0.20634037f, 0.11558922f, -0.24020350f, 
    0.18803191f, -0.00807694f, -0.16219015f, -0.13928434f, -0.10642135f, 0.12165994f, 0.17579025f, -0.12302047f, 
    -0.21129873f, 0.06681700f, -0.10064666f, 0.08319183f, 0.00105541f, -0.22227156f, 0.11699013f, -0.22206731f, 
    -0.12043321f, 0.01219493f, -0.10018769f, -0.24303082f, -0.20640907f, 0.10273884f, -0.08276024f, -0.18079981f, 
    0.06782290f, 0.19869724f, -0.08032918f, 0.00376153f, -0.21799541f, -0.06316793f, 0.17605001f, -0.24439201f, 
    0.13586205f, -0.09451061f, 0.04163948f, -0.16279528f, 0.00918400f, -0.20249602f, -0.03716093f, -0.23113897f, 
    0.19829561f, 0.69039226f, 0.25322443f, -0.26287127f, 0.04815273f, -0.04920420f, 0.32737869f, 0.00671103f, 
    -0.14014080f, -0.04622719f, -0.24512275f, -0.25794223f, 0.17106253f, 0.28467456f, -0.44943151f, 0.32943803f, 
    -0.09677167f, 0.37658590f, -0.16399685f, 0.11688041f, 0.31649452f, 0.02741078f, 0.05461552f, 0.11955027f, 
    -0.09660851f, 0.02051920f, 0.00389106f, 0.08928210f, -0.34508574f, 0.04775466f, 0.80939841f, 0.12662460f, 
    0.18831578f, -0.12469184f, -0.45672995f, -0.03240052f, -0.26118502f, 0.15462922f, -0.11734721f, -0.05648329f, 
    0.01646659f, 0.05021226f, 0.04556880f, 0.51795477f, -0.35014495f, 0.12661894f, 0.54015827f, -0.16627488f, 
    0.09831974f, -0.30773640f, -0.35494146f, -0.56288260f, -0.04225011f, 0.29314965f, -0.16278827f, 0.05014860f, 
    0.04166731f, 0.24643722f, 0.23697767f, 0.04344082f, 0.08783891f, 0.13011755f, -0.04087405f, -0.13918452f, 
    -0.12062395f, -0.01844760f, -0.19006200f, -0.09408127f, 0.39444810f, 0.29302782f, 0.41842249f, -0.00813642f, 
    -0.12401581f, -0.13107640f, 0.05329377f, 0.22496526f, -0.25967705f, 0.01136933f, -0.67390108f, 0.19323133f, 
    -0.06549386f, 0.24105102f, -0.44270903f, -0.40132779f, -0.03137101f, 0.33268142f, 0.30331656f, 0.01265229f, 
    0.07677706f, 0.25457153f, -0.17578061f, 0.26029703f, -0.52128434f, 0.18734364f, 0.08231702f, -0.13069114f, 
    -0.22899060f, 0.71252519f, -0.17030558f, -0.22923116f, -0.04858033f, -0.20395137f, -0.15068522f, 0.48396131f, 
    0.09843704f, -0.06691960f, 0.21888308f, 0.20256905f, -0.02140744f, -0.13651857f, -0.53978598f, -0.06604145f, 
    -0.23476464f, 0.27508929f, 0.14455722f, 0.42127943f, 0.28074470f, 0.26022130f, -0.13284507f, 0.07873540f, 
    -0.08767983f, -0.06328592f, 0.16177119f, -0.06908024f, -0.20110439f, -0.13873212f, -0.78528267f, 0.00209100f, 
    -0.04986945f, 0.42543948f, -0.27157763f, 0.04089477f, -0.42743537f, -0.10854328f, -0.15197998f, 0.37025723f, 
    0.10947731f, 0.03238669f, 0.20464544f, 0.09721526f, 0.09249233f, -0.19071229f, 0.39465776f, 0.00291440f, 
    -0.15646140f, -0.40923688f, 0.12813081f, 0.51953393f, 0.09196530f, -0.01323237f, -0.19087505f, -0.01058110f, 
    0.22642507f, -0.16962534f, 0.31343886f, 0.06730768f, -0.19190900f, 0.05517222f, -0.09904117f, -0.18057656f, 
    0.05208361f, 0.22830062f, -0.17567044f, 0.08989365f, -0.15101960f, -0.06027912f, -0.24480778f, -0.20898329f, 
    0.09406969f, -0.21868044f, -0.20559627f, -0.22310793f, -0.05953154f, -0.23525308f, 0.18262795f, -0.23457074f, 
    0.23372605f, 0.33024684f, 0.11285929f, -0.30772689f, -0.53115261f, -0.10210678f, 0.16900058f, 0.44697461f, 
    -0.13166080f, 0.12163733f, 0.41644600f, -0.14405578f, -0.15916912f, -0.10112588f, 0.18686743f, -0.29375765f, 
    -0.22109073f, -0.20220961f, 0.07890366f, 0.21128388f, 0.42698771f, -0.10957772f, -0.37964576f, -0.27819675f, 
    0.23487273f, -0.04168427f, 0.37296495f, 0.28939834f, -0.19881107f, -0.05932343f, 0.44639909f, 0.33422223f, 
    -0.00068931f, 0.63281846f, 0.09049719f, -0.07819817f, 0.10691477f, 0.31689766f, 0.15787202f, 0.28198677f, 
    0.07525794f, -0.20071062f, -0.22911866f, 0.11630842f, -0.14903094f, 0.15917443f, -0.54212111f, 0.16540122f, 
    0.04468088f, -0.09295454f, -0.14896698f, 0.32772902f, -0.21762013f, 0.17265439f, -0.38133362f, 0.05651181f, 
    0.14474794f, 0.02942361f, -0.33737713f, 0.29990253f, -0.20604938f, 0.29264066f, 0.68856543f, 0.03112963f, 
    -0.09787683f, -0.13297468f, -0.34337768f, -0.03631866f, -0.13828787f, 0.37156788f, -0.07937563f, 0.03003054f, 
    -0.17630132f, 0.16744673f, 0.26114029f, 0.16440913f, -0.27442965f, -0.07584155f, -0.32579249f, -0.29338914f, 
    -0.17693169f, 0.49628204f, 0.05636915f, -0.20405425f, 0.14793508f, -0.17126124f, 0.37051830f, 0.11439385f, 
    -0.04740416f, 0.02823817f, 0.18992035f, -0.20006867f, 0.08854128f, 0.10805665f, -0.64497995f, 0.21569526f, 
    0.21498972f, -0.12850350f, 0.00699441f, -0.08939295f, -0.13193975f, 0.02816068f, 0.09133580f, 0.14702152f, 
    -0.14004797f, -0.23050922f, -0.21239144f, 0.03326076f, -0.16277516f, -0.07749644f, -0.25078252f, -0.02294133f, 
    -0.24113706f, 0.29895198f, 0.27576259f, 0.61985016f, -0.25664863f, 0.03393349f, -0.18472733f, 0.38712204f, 
    -0.03058632f, 0.23083644f, -0.23810114f, 0.03883335f, -0.02927138f, 0.07052904f, 0.13291970f, 0.32266223f, 
    -0.19920658f, -0.21922226f, -0.46806711f, 0.36481082f, 0.15304290f, 0.19455054f, -0.02644088f, -0.13437220f, 
    -0.21264614f, 0.03674075f, 0.22474553f, 0.21657400f, -0.52084661f, 0.22593485f, 0.23689964f, -0.07950407f, 
    -0.02473408f, -0.29992861f, 0.24788661f, -0.24530534f, -0.43158239f, -0.20240159f, -0.25865248f, 0.10240678f, 
    -0.01065630f, -0.24836993f, 0.27579537f, -0.15449743f, 0.10881875f, 0.33893684f, 0.20520079f, -0.34667304f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.34341180f, -0.34781373f, 0.39843190f, 0.26715562f, -0.03464461f, -0.11917624f, -0.26105011f, 0.18828019f, 
    0.23267300f, 0.10020727f, 0.19305280f, -0.12012804f, 0.30088669f, 0.08107188f, 0.03938406f, 0.34375715f, 
    0.00610225f, 0.29800010f, -0.18834320f, -0.21392283f, 0.19266929f, 0.26485765f, -0.27445954f, 0.50373745f, 
    -0.29887712f, 0.09590049f, -0.34796825f, -0.06515379f, -0.07646731f, 0.12585761f, 0.37957975f, -0.00027794f, 
    -0.25764021f, 0.37592161f, 0.22086734f, -0.19613180f, 0.21874863f, 0.29063466f, -0.13568935f, 0.39670393f, 
    -0.09312681f, 0.06148500f, -0.21007723f, -0.00988523f, 0.16505550f, 0.15087913f, 0.13035922f, 0.03644817f, 
    0.23609662f, 0.20552567f, 0.22581333f, -0.23772396f, 0.15650463f, 0.05820611f, 0.28615224f, -0.37230280f, 
    0.37401927f, 0.19915687f, 0.45157507f, -0.07442123f, -0.22846630f, -0.02100168f, 0.49147174f, -0.35827255f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02235442f, 0.06182577f, 0.01776401f, 0.09530712f, 0.04624015f, 0.02214776f, 0.11296664f, -0.07271422f, 
    -0.09090628f, -0.08371826f, -0.06518493f, -0.11029795f, -0.01711026f, 0.04262313f, 0.06962653f, -0.09799704f, 
    0.03448847f, -0.10314882f, 0.09495015f, -0.13609356f, 0.06117347f, -0.14670953f, -0.11635481f, -0.07022336f, 
    0.05950837f, 0.08077505f, 0.11494914f, 0.08096091f, -0.10374927f, 0.03627067f, -0.09492760f, -0.05221877f, 
    -0.02893618f, 0.00727609f, -0.04939402f, 0.04246635f, -0.09690043f, 0.01303362f, 0.08147696f, -0.00071305f, 
    -0.03452083f, 0.12043406f, 0.10645439f, 0.07792933f, -0.03558700f, 0.00198525f, -0.02599948f, -0.08054877f, 
    -0.04210489f, 0.04088914f, 0.07825983f, 0.04160390f, -0.02555490f, 0.07570828f, -0.03278839f, -0.07047946f, 
    0.03241692f, -0.08431386f, 0.00317171f, 0.04196848f, 0.00215188f, -0.00283180f, -0.11438576f, -0.00573536f, 
    0.02399069f, -0.09747006f, -0.00417041f, 0.07997353f, -0.06336898f, -0.12316874f, 0.05015446f, 0.07792164f, 
    0.00700803f, -0.08241567f, -0.04251732f, 0.03947257f, 0.02017152f, -0.08979021f, 0.05747561f, -0.02569187f, 
    -0.12364359f, -0.09738156f, -0.08274151f, -0.05229867f, 0.07301460f, -0.07929865f, 0.08113822f, 0.00949693f, 
    0.09055324f, -0.00482919f, 0.01040782f, 0.06377921f, 0.01249813f, -0.07780214f, 0.05694318f, -0.00295949f, 
    -0.01345457f, -0.07362895f, -0.05536466f, -0.13012895f, -0.12115255f, 0.01805317f, -0.05695656f, -0.15329626f, 
    -0.03852288f, 0.05726713f, -0.08354351f, -0.09562162f, -0.14241576f, -0.11814243f, -0.11074736f, -0.10202052f, 
    -0.08626462f, 0.06202129f, -0.03912608f, 0.07168427f, 0.06410885f, 0.09375857f, -0.12306605f, -0.10175559f, 
    -0.00691068f, 0.02338140f, -0.09846793f, 0.03761576f, -0.05186407f, -0.10119512f, 0.06603828f, -0.10451212f, 
    0.27046928f, -0.67766100f, 0.23409528f, 0.25919193f, 0.27616069f, -0.20164500f, -0.08690792f, 0.03548358f, 
    -0.20713437f, 0.02445266f, 0.15667433f, 0.00348077f, -0.02212439f, -0.20311947f, 0.06858768f, -0.25830698f, 
    0.16935177f, 0.13257949f, -0.00697871f, 0.01320614f, 0.26535568f, 0.15892109f, -0.21018153f, -0.14005695f, 
    0.13458274f, 0.11750532f, -0.34580377f, 0.15180326f, 0.40969315f, 0.05759645f, 0.13494666f, 0.05282973f, 
    -0.20220788f, 0.00741985f, 0.15744591f, -0.10241048f, 0.13519381f, 0.22292237f, -0.03549992f, 0.27781990f, 
    -0.00275980f, -0.06242844f, -0.08906138f, -0.20556474f, -0.04189504f, 0.24677043f, 0.35991707f, 0.21133363f, 
    -0.15632838f, 0.12943348f, -0.06460835f, -0.12526828f, 0.20826462f, 0.06864899f, 0.07124219f, 0.23073114f, 
    0.02360206f, -0.00648124f, 0.32135725f, 0.03431383f, -0.06551830f, -0.18990079f, 0.36361846f, -0.02796866f, 
    -0.09754884f, 0.10146365f, -0.00517030f, 0.11307253f, -0.10581233f, -0.07374434f, -0.01604991f, 0.04979279f, 
    0.06288563f, -0.05224603f, 0.10491534f, -0.12027571f, -0.08416668f, -0.11244738f, -0.06010630f, -0.04828317f, 
    -0.07877801f, -0.04598770f, 0.08410265f, -0.10368834f, 0.02396026f, 0.01514082f, 0.02286181f, 0.07051688f, 
    -0.10555165f, 0.03012058f, -0.02463469f, -0.09183206f, 0.08937282f, -0.07218768f, -0.10326804f, -0.03927168f, 
    -0.05240336f, -0.12670897f, -0.07549234f, -0.07413232f, -0.05838897f, -0.04852697f, 0.04737839f, 0.08714940f, 
    0.01616925f, -0.04727629f, 0.05962963f, 0.05154651f, 0.05335437f, 0.01329455f, 0.09937735f, 0.07529805f, 
    0.05092200f, -0.10726608f, -0.07273719f, -0.05303304f, 0.06881674f, -0.00055914f, -0.09604187f, -0.05222580f, 
    -0.00629872f, 0.02476311f, 0.07347106f, -0.09039167f, -0.06616984f, -0.00294400f, -0.11230344f, 0.10089870f, 
    -0.03589283f, -0.09497286f, 0.07159156f, 0.08879866f, -0.02149144f, 0.11909260f, 0.02223369f, 0.10551669f, 
    -0.09592654f, -0.08890674f, -0.08959045f, -0.02292797f, 0.09236400f, -0.00553451f, 0.04437643f, -0.02017883f, 
    0.05043221f, -0.03280798f, -0.03163020f, -0.07815084f, 0.06300609f, -0.12747104f, 0.01887244f, -0.08775583f, 
    -0.01091561f, -0.03259708f, -0.01457061f, -0.01378198f, 0.06057054f, -0.01336840f, -0.03810454f, 0.10260414f, 
    -0.02218388f, 0.08877578f, 0.02269658f, 0.07853211f, 0.07132058f, -0.00464545f, 0.05709897f, -0.01552731f, 
    -0.09563937f, 0.06251414f, 0.11312900f, 0.01395905f, -0.08726563f, 0.00394668f, 0.01173383f, -0.13076964f, 
    0.00944859f, -0.02597296f, -0.01140679f, -0.05534910f, -0.02366902f, 0.07508260f, -0.12046055f, -0.12295538f, 
    0.04610195f, -0.08992727f, -0.10938185f, 0.06363332f, 0.04636489f, -0.09612367f, -0.11381978f, -0.09380509f, 
    0.04017212f, -0.10142830f, -0.21165247f, -0.21457452f, -0.12497690f, -0.04023476f, -0.07976735f, 0.23512155f, 
    0.01003425f, -0.37063417f, -0.02048533f, -0.33181936f, -0.41494009f, 0.04986533f, 0.02297381f, -0.19851381f, 
    -0.52361619f, -0.01119621f, -0.00848682f, 0.00616954f, -0.18451531f, -0.08737759f, 0.09277306f, -0.01874400f, 
    0.05474353f, -0.55054677f, 0.32061410f, -0.35935110f, -0.04669775f, -0.00508451f, -0.25961024f, -0.11682723f, 
    0.09355859f, -0.19957756f, -0.15871997f, 0.18967995f, -0.36633375f, 0.22537275f, -0.13599467f, -0.01774795f, 
    0.08268705f, 0.11063726f, 0.11029598f, 0.01716305f, -0.25656492f, -0.16355361f, -0.03904595f, -0.35430405f, 
    -0.00192885f, -0.14007318f, 0.18806615f, -0.27836728f, 0.07718386f, 0.08688332f, 0.62393790f, -0.02987866f, 
    -0.18798228f, -0.88924974f, -0.03529486f, 0.04541842f, 0.11042452f, 0.19572459f, -0.14157335f, 0.10010778f, 
    -0.22078687f, -0.59490150f, 0.03043368f, 0.13615146f, -0.14833343f, 0.23164122f, -0.05812675f, -0.17488691f, 
    0.01230397f, 0.12380015f, -0.05461672f, 0.56367099f, 0.10573125f, 0.00337784f, 0.03059107f, 0.24781127f, 
    0.05580071f, 0.05877846f, 0.19758144f, -0.09109870f, -0.25183034f, -0.04666610f, 0.05301187f, -0.11605277f, 
    -0.10279412f, -0.19303165f, 0.05530853f, 0.35658482f, -0.06797951f, -0.13806787f, -0.03333467f, -0.10198361f, 
    0.34978449f, -0.21615870f, 0.00120131f, 0.06192786f, 0.09081353f, 0.17873465f, -0.06571764f, 0.03815156f, 
    -0.04656304f, 0.05021690f, 0.08898988f, 0.29670072f, 0.01307406f, -0.14498159f, -0.08155476f, 0.16709577f, 
    -0.08931176f, 0.23644604f, 0.15977240f, 0.27307129f, -0.20488882f, -0.01369403f, -0.05796378f, -0.03764234f, 
    0.25829977f, -0.12204592f, -0.19323941f, 0.15122794f, 0.00435352f, 0.16970263f, -0.14035793f, -0.14715885f, 
    0.00398436f, 0.07200301f, -0.03493978f, 0.03367918f, 0.04847660f, 0.12162223f, 0.05188413f, -0.07265291f, 
    0.08893044f, -0.07542007f, -0.12967312f, -0.03486617f, -0.04730913f, 0.01875894f, -0.08077346f, -0.01701601f, 
    0.08747846f, -0.11346167f, 0.02656429f, -0.01062515f, 0.06260491f, -0.08556707f, -0.13408181f, 0.03490800f, 
    0.05002509f, 0.08079081f, -0.11922698f, -0.12955676f, 0.04096978f, 0.05122507f, 0.05231977f, -0.05977425f, 
    0.09791960f, -0.01360036f, -0.12402044f, 0.08589695f, -0.05892046f, -0.00443299f, 0.11876605f, -0.04385599f, 
    -0.09581955f, 0.02199213f, -0.04621285f, 0.09034391f, -0.11516666f, 0.02923270f, -0.06681328f, -0.10372896f, 
    0.12157060f, 0.02573370f, 0.02240166f, -0.08570416f, -0.05976803f, 0.08887170f, -0.13849506f, 0.10351454f, 
    -0.13737948f, -0.07022122f, -0.09177673f, -0.10611542f, -0.03513829f, -0.06942053f, 0.04879095f, -0.02956063f, 
    -0.09761319f, -0.83981740f, 0.08284811f, 0.10597533f, 0.14714359f, 0.07456245f, 0.05149284f, 0.15704851f, 
    -0.05510423f, -0.09212234f, -0.07390748f, 0.42683345f, 0.34642699f, -0.26014408f, 0.04817881f, 0.57720345f, 
    0.06480731f, 0.19000758f, -0.14593925f, -0.31186402f, 0.04470286f, -0.07940755f, -0.03015148f, 0.25277081f, 
    -0.52438533f, -0.27147076f, -0.20271380f, -0.10928573f, -0.24440736f, 0.00310877f, 0.18885544f, 0.12882537f, 
    -0.07948299f, -0.04069735f, 0.10213469f, -0.28375795f, 0.04388089f, 0.30600914f, -0.00763489f, 0.10951207f, 
    0.08802058f, 0.04819790f, 0.06435797f, 0.05982186f, 0.04250471f, -0.01761561f, -0.06466330f, 0.14727591f, 
    0.10073712f, -0.01834746f, 0.32934400f, -0.02558310f, -0.02950449f, -0.09611119f, -0.00034016f, -0.33604923f, 
    0.22367306f, -0.11758311f, 0.29255450f, 0.04369481f, -0.05050890f, 0.15285181f, 0.06607286f, -0.25331974f, 
    0.31711331f, -0.38773838f, -0.21102895f, 0.30236489f, -0.00198006f, -0.18679604f, 0.09016240f, -0.15530314f, 
    0.10075580f, 0.16245650f, 0.06476973f, -0.20424445f, 0.19845580f, -0.24256811f, -0.12397766f, -0.12923440f, 
    0.10855430f, -0.00920455f, -0.23003963f, -0.06319135f, 0.49776843f, 0.17531829f, -0.19443840f, 0.03358847f, 
    0.36954942f, 0.31842503f, -0.30461511f, 0.07523274f, 0.31788623f, -0.17240795f, 0.17668720f, -0.03509279f, 
    -0.42322400f, 0.30122542f, -0.09908134f, -0.20234837f, 0.07424940f, -0.11206067f, 0.00241909f, 0.19229691f, 
    -0.10405695f, 0.06509069f, -0.01082362f, -0.39759260f, -0.14879024f, 0.09111075f, 0.34809598f, 0.13723554f, 
    0.10175800f, -0.28743184f, 0.05950918f, -0.31152093f, 0.18634638f, -0.04509403f, -0.15196002f, -0.07662696f, 
    -0.09301735f, 0.14745495f, 0.20825146f, -0.38416371f, -0.04696123f, -0.17970483f, 0.19327672f, 0.08024643f, 
    -0.08935273f, -0.10369198f, -0.04350652f, 0.09976883f, -0.13018601f, 0.07273512f, -0.03191535f, 0.05808226f, 
    -0.06089455f, -0.06569092f, -0.00534141f, 0.03925589f, -0.11952650f, 0.03803701f, -0.05398507f, -0.11384376f, 
    0.01693297f, 0.06863623f, 0.02282932f, -0.04216440f, 0.04185082f, -0.04448554f, -0.10289294f, 0.02556165f, 
    -0.05466940f, -0.07976025f, -0.08185435f, 0.08398815f, -0.05251271f, 0.01899963f, -0.12104706f, -0.04820971f, 
    0.01235787f, 0.09880499f, 0.08427116f, -0.06855856f, 0.11221077f, -0.02109026f, -0.11232533f, 0.06405032f, 
    0.00662076f, -0.05377035f, -0.05703087f, -0.05588259f, -0.07670133f, -0.11995600f, 0.05766583f, -0.04252176f, 
    -0.11646557f, 0.05240630f, -0.12761264f, 0.02732981f, -0.03275337f, -0.00655158f, 0.03093218f, -0.11404123f, 
    -0.13086972f, -0.09038772f, 0.08708601f, -0.02753001f, 0.08351353f, 0.05537423f, 0.10507149f, -0.05740517f, 
    -0.13406244f, 0.71541047f, 0.06364457f, -0.07275033f, 0.11657561f, 0.48018658f, -0.04251423f, -0.00441433f, 
    -0.44660503f, -0.06020796f, 0.11280158f, 0.08521575f, 0.07391222f, 0.19761121f, 0.02838355f, -0.28448194f, 
    0.14418247f, 0.24727935f, -0.00964548f, -0.43850189f, -0.16516936f, 0.23483413f, 0.08274642f, 0.13693562f, 
    -0.56359017f, 0.06706508f, -0.00250121f, 0.26582968f, 0.03551658f, 0.09852502f, 0.10382012f, 0.08125330f, 
    0.52165103f, 0.05895832f, 0.07428576f, -0.03962008f, 0.01430007f, 0.40913010f, 0.05349040f, -0.02923711f, 
    0.06390509f, -0.04281698f, -0.02471463f, -0.27106878f, 0.02354185f, 0.15299197f, -0.04239085f, -0.08972589f, 
    -0.15149419f, 0.06628121f, 0.05116196f, 0.31925696f, 0.12095349f, -0.04604548f, 0.15565190f, 0.47740439f, 
    -0.04652275f, -0.00514111f, 0.08046384f, -0.24816625f, -0.10769159f, 0.23337424f, 0.26679015f, -0.08195294f, 
    0.37043428f, -0.47903880f, 0.09105849f, 0.46787950f, 0.04229039f, -0.41518319f, 0.01120392f, 0.00829586f, 
    0.16069457f, 0.11343198f, -0.03280660f, -0.21273801f, 0.02212185f, -0.44590408f, 0.11465126f, 0.27959546f, 
    -0.18244934f, -0.19876888f, -0.15172341f, -0.15079060f, 0.40851790f, 0.08376534f, -0.12585440f, 0.17692906f, 
    0.23289335f, 0.26914108f, -0.32844955f, -0.18075724f, -0.10366109f, -0.04740370f, 0.18139336f, -0.08752269f, 
    -0.21280374f, 0.22971512f, 0.11447510f, -0.28992862f, 0.18356553f, 0.15243141f, 0.04767176f, 0.34020743f, 
    -0.01484230f, 0.09995079f, -0.02635230f, 0.03420765f, -0.03715074f, 0.14954749f, 0.49573371f, 0.25570729f, 
    0.16057901f, -0.10563279f, -0.01111715f, -0.16585575f, -0.04559212f, -0.01582168f, 0.16118734f, -0.67820036f, 
    0.23427704f, -0.01642849f, 0.19976230f, 0.10389859f, 0.05968887f, -0.01350760f, 0.09959148f, -0.00428122f, 
    -0.09564175f, 0.08980438f, -0.02621069f, 0.10139808f, 0.01571198f, -0.00003379f, -0.07030745f, -0.06671993f, 
    -0.11188075f, -0.05910428f, 0.09453682f, 0.11611198f, 0.09729798f, 0.06125418f, 0.07468824f, 0.07255679f, 
    -0.12094936f, -0.05347133f, 0.08886961f, -0.09699163f, -0.07836917f, 0.05874721f, -0.02289853f, 0.02105355f, 
    -0.05919600f, 0.03998377f, -0.10984194f, 0.04624673f, -0.03589949f, -0.04197641f, -0.10604993f, -0.11671019f, 
    0.01782588f, -0.11070533f, -0.07014225f, -0.02750331f, -0.04944621f, 0.05743165f, 0.08720519f, -0.02283346f, 
    -0.01256447f, -0.07533041f, -0.12062627f, -0.11220036f, -0.12944749f, 0.05763553f, -0.00191393f, 0.01648639f, 
    -0.13071983f, 0.04775951f, -0.07151434f, -0.01741709f, -0.03113378f, 0.00976846f, 0.07735328f, 0.01538464f, 
    0.01786989f, 0.04124350f, -0.10838737f, -0.04613708f, -0.07513861f, 0.05183509f, -0.03510910f, 0.04844452f, 
    -0.43718353f, -0.01091561f, -0.05814892f, 0.03699860f, -0.20000480f, 0.77530009f, -0.10681428f, -0.14040330f, 
    0.22437164f, -0.07391359f, -0.02402338f, 0.46505418f, 0.07908567f, -0.21298902f, 0.03654767f, 0.10283008f, 
    -0.00859253f, 0.15214971f, 0.10828613f, -0.03950623f, 0.09552362f, 0.20782970f, 0.07340414f, -0.11177576f, 
    0.07358661f, -0.03767030f, 0.36406606f, -0.05421444f, -0.23990594f, -0.11554062f, -0.47223100f, -0.03816867f, 
    -0.03523168f, 0.04833796f, -0.23459888f, -0.00520298f, 0.00450543f, 0.00706004f, -0.02134779f, -0.27034989f, 
    -0.08436882f, -0.00228147f, -0.01780020f, -0.06558236f, 0.03694925f, -0.33016768f, -0.40485618f, 0.01684756f, 
    -0.16687045f, 0.01613198f, 0.19728005f, -0.35400036f, 0.00931797f, 0.03342028f, 0.13685010f, 0.16489691f, 
    0.09294294f, -0.16848651f, 0.00993457f, 0.07539751f, 0.00796758f, 0.09854015f, -0.53097928f, -0.16876194f, 
    -0.08063100f, -0.89579910f, -0.21368764f, 0.75296116f, -0.09873244f, -0.30961785f, 0.01617771f, -0.13119335f, 
    0.13069497f, -0.01948654f, -0.00688271f, 0.66517115f, 0.29455003f, -0.13265206f, -0.03679693f, -0.27475214f, 
    0.34015092f, -0.02148817f, 0.21172695f, 0.01495455f, 0.00753038f, 0.15412951f, 0.04701240f, -0.47698382f, 
    -0.11181437f, -0.17524822f, -0.15650819f, 0.52606416f, -0.03530405f, -0.12056280f, 0.28669035f, -0.10544390f, 
    -0.02479089f, 0.09391928f, -0.01948532f, 0.04571262f, 0.21035935f, 0.05167849f, -0.00869269f, -0.04269836f, 
    0.02227019f, 0.11660225f, 0.07643990f, 0.17645787f, -0.08389089f, -0.00019033f, 0.11959722f, 0.00710251f, 
    -0.24335645f, 0.06075414f, 0.02983568f, 0.35453579f, 0.00513134f, 0.03625296f, 0.43373752f, -0.26059890f, 
    0.21956348f, 0.11029804f, -0.02122783f, 0.10080053f, -0.01804719f, 0.40062559f, -0.18499255f, -0.21262789f, 
    0.19409002f, -0.53028369f, -0.20751925f, 0.15549894f, -0.13064548f, 0.43920088f, 0.01751421f, -0.21745735f, 
    -0.12238199f, 0.18836470f, -0.07210927f, 0.30070877f, 0.57529181f, -0.07183793f, 0.07408762f, 0.17448065f, 
    -0.03819805f, -0.37266925f, -0.35137692f, -0.32141858f, 0.54500091f, -0.06520043f, -0.14211361f, 0.17093243f, 
    0.19350018f, -0.04658861f, -0.49400520f, 0.05333440f, 0.37837595f, -0.03194217f, 0.42466033f, -0.02231099f, 
    0.23174338f, -0.11594575f, 0.00449587f, -0.21693492f, 0.18140471f, 0.06847347f, 0.09479272f, 0.21931352f, 
    -0.10833360f, -0.09248284f, -0.11068195f, -0.12637857f, -0.00494426f, 0.24628679f, 0.25633830f, 0.10065094f, 
    0.54934525f, -0.06545623f, 0.13888241f, -0.33773518f, -0.00118259f, -0.05919175f, -0.10352418f, -0.35715312f, 
    0.10386904f, 0.23625290f, 0.38763073f, -0.28728190f, 0.09838404f, 0.07646061f, 0.31056657f, 0.02565306f, 
    0.09980664f, -0.32364616f, -0.51697177f, -0.12027416f, -0.10209329f, -0.03466232f, -0.09153856f, -0.07731515f, 
    -0.08620689f, -0.06657494f, 0.28721973f, 0.73451775f, 0.31934071f, -0.32283953f, 0.12041600f, 0.06410123f, 
    -0.08971575f, 0.05600701f, -0.02076459f, -0.13408911f, 0.11896311f, 0.19440964f, 0.20891704f, -0.26062462f, 
    0.02174725f, 0.15309861f, 0.22569855f, 0.12163828f, 0.68188816f, -0.12695858f, -0.18191813f, 0.06036913f, 
    -0.26533490f, -0.07809699f, -0.13162169f, 0.19885997f, 0.17733790f, -0.02295111f, -0.07770570f, 0.45062521f, 
    0.08056229f, 0.00346665f, 0.06669159f, -0.33713380f, -0.08681012f, -0.01337355f, -0.29655212f, 0.03056239f, 
    -0.45616555f, -0.15354802f, 0.14356329f, -0.10772675f, 0.24597630f, 0.01539239f, -0.50349641f, 0.28185582f, 
    0.14704257f, 0.17285681f, -0.23594595f, -0.13936679f, -0.00637527f, 0.15841281f, -0.07934723f, 0.20308711f, 
    0.04024462f, -0.10124826f, 0.08275022f, 0.09423152f, -0.08822151f, -0.09336433f, -0.09334753f, 0.06073935f, 
    0.00371825f, -0.09456581f, -0.10552585f, -0.10222157f, -0.01328850f, -0.05465593f, -0.12228937f, -0.12343161f, 
    0.08294454f, -0.03313734f, 0.02726645f, 0.09683003f, -0.02649437f, -0.04856618f, -0.02561629f, -0.04231397f, 
    -0.09262462f, -0.04075334f, -0.05928409f, -0.01399347f, -0.05921428f, 0.03986849f, 0.01009151f, 0.02998435f, 
    -0.02782973f, 0.00853740f, 0.11043683f, 0.10954647f, -0.12400662f, 0.00336159f, 0.09491344f, -0.03495788f, 
    0.06991331f, -0.11794700f, 0.04251963f, -0.05106154f, 0.06405425f, 0.08293422f, 0.02933189f, -0.11689327f, 
    -0.03638376f, -0.00441257f, -0.08071681f, -0.11299877f, 0.02484122f, 0.09403925f, -0.09573173f, -0.04586429f, 
    0.05745531f, -0.10312158f, -0.10309561f, -0.12743860f, -0.03302188f, -0.06669733f, 0.05647475f, -0.00791277f, 
    0.16555238f, -0.55482560f, 0.35017052f, -0.14940812f, 0.17190370f, 0.69502020f, 0.09339527f, 0.05496347f, 
    -0.36177620f, 0.12973735f, -0.35890746f, 0.56788123f, 0.26932207f, 0.11867421f, 0.00700125f, 1.11271167f, 
    -0.18536933f, -0.20078124f, -0.42775649f, -0.47067767f, 0.19808571f, -0.09850278f, -0.37041587f, 0.55050981f, 
    -0.19049586f, -0.15324467f, -0.55287033f, -0.12974741f, 0.04374522f, 0.03896716f, 0.27510014f, -0.06324077f, 
    0.28054389f, -0.27228215f, 0.18563941f, -0.34507221f, 0.10273567f, 0.41301560f, -0.01301937f, 0.73682088f, 
    0.02523782f, 0.00831835f, -0.06705435f, 0.45369521f, 0.16500796f, 0.23723786f, -0.01123620f, 0.11746298f, 
    0.59876221f, 0.09768925f, 0.19225453f, -0.18469051f, -0.10237016f, 0.13202675f, -0.09572814f, -0.34823781f, 
    0.12087893f, 0.24264152f, 0.23352933f, 0.07469212f, 0.07735006f, -0.11198240f, 0.32369077f, -0.29809001f, 
    -0.01245059f, 0.83875418f, -0.05007148f, 0.47384959f, 0.00287956f, -0.30929509f, -0.05189745f, -0.44077209f, 
    0.09029676f, 0.11020377f, -0.02689943f, -0.45708933f, -0.34536502f, 0.12832633f, 0.02011132f, -0.55517083f, 
    0.35392770f, -0.05832625f, 0.15466569f, -0.02741546f, 0.19327052f, 0.06225669f, 0.12911664f, 0.06432734f, 
    0.05421520f, 0.47814038f, 0.14841308f, 0.19146727f, -0.08374418f, 0.00146279f, 0.00413777f, 0.06634358f, 
    0.08210715f, 0.16672814f, 0.07278273f, -0.12001973f, -0.12538907f, -0.37623307f, 0.04118024f, -0.26200083f, 
    0.03925890f, 0.04954432f, 0.02674253f, -0.59001821f, 0.21092644f, 0.30075395f, 0.08206752f, -0.01515940f, 
    0.02890119f, 0.01057745f, -0.24319296f, 0.21817869f, -0.02397712f, -0.00316421f, -0.09335826f, 0.26767495f, 
    0.01024855f, 0.24035837f, 0.05702204f, -0.35976881f, -0.13384596f, -0.06358557f, 0.08425134f, -0.30805627f, 
    -0.00704713f, -0.19904897f, 0.18569417f, -0.00249676f, 0.10193647f, 0.17390648f, 0.09987698f, 0.03243684f, 
    0.03583751f, 0.13901763f, -0.06341647f, 0.48859096f, -0.30816045f, 0.24311371f, 0.08992718f, 0.30709636f, 
    -0.09421553f, -0.08609351f, 0.00616820f, -0.02824526f, -0.71244681f, 0.16180752f, 0.02520979f, -0.10962780f, 
    -0.32927740f, -0.17882454f, -0.16022740f, -0.31591943f, -0.27714896f, -0.06951421f, -0.44321293f, -0.02734056f, 
    0.19740339f, -0.01093657f, 0.08696417f, 0.01547804f, 0.06581382f, 0.25442666f, 0.09030630f, -0.10720745f, 
    0.00409367f, -0.03190992f, -0.09948581f, 0.22739510f, 0.24829535f, -0.50830907f, -0.00398418f, 0.26860797f, 
    -0.52386659f, -0.15329126f, 0.22329116f, -0.01128919f, 0.01424966f, 0.11129373f, -0.39819098f, -0.15095240f, 
    0.30118674f, -0.12657073f, -0.55390519f, 0.06073800f, -0.06825627f, 0.55082536f, -0.33965689f, -0.32224214f, 
    0.07496698f, 0.59520906f, -0.13150556f, 0.64500767f, 0.06655733f, -0.08892911f, 0.08794550f, 0.13465001f, 
    0.17664519f, -0.09200611f, 0.03580084f, -0.45475018f, 0.08811389f, -0.21370721f, 0.06595705f, -0.40267617f, 
    0.38230878f, -0.01279883f, 0.02267635f, 0.00180612f, 0.44237676f, 0.14740580f, -0.02288706f, -0.16497502f, 
    0.09007473f, 0.24160437f, 0.09563687f, 0.15305685f, 0.18060727f, 0.03704658f, 0.14379758f, -0.05072375f, 
    -0.11748289f, 0.28192288f, 0.06840701f, 0.09393603f, 0.06392560f, 0.02648554f, -0.11264186f, 0.06535979f, 
    0.00806452f, 0.09365465f, 0.11007650f, -0.22366272f, 0.08379290f, 0.35591322f, 0.21015809f, -0.02799156f, 
    0.13917793f, -0.20263112f, 0.10759299f, 0.01166055f, 0.16760337f, 0.04970190f, 0.06740587f, 0.03539591f, 
    -0.10758375f, 0.49252436f, 0.20918930f, -0.10878305f, -0.10344809f, 0.21990067f, 0.30505368f, 0.00028865f, 
    0.01884163f, -0.68836802f, 0.05252452f, 0.70897174f, 0.06492251f, 0.19684318f, 0.00638203f, -0.13594772f, 
    -0.19629180f, -0.05430900f, 0.25578201f, 0.32940078f, 0.30291501f, -0.30969998f, 0.01523173f, -0.39959410f, 
    0.32796794f, 0.35244584f, 0.20724319f, -0.03249640f, -0.04159935f, 0.18669985f, 0.08948000f, -0.18377794f, 
    -0.16721520f, 0.12762989f, -0.14041390f, 0.38758388f, -0.07038374f, 0.11265938f, 0.15749426f, -0.04515673f, 
    0.41519716f, -0.12054371f, 0.05765654f, 0.02661824f, 0.13813043f, 0.21920827f, -0.01849544f, -0.12269602f, 
    -0.04667057f, 0.03559741f, 0.07557663f, 0.09342242f, -0.04722982f, -0.10598498f, -0.04257926f, 0.02888135f, 
    -0.07269483f, 0.08720616f, 0.34379584f, 0.20001625f, 0.25528765f, -0.11155265f, 0.18041424f, 0.15927321f, 
    -0.01528838f, -0.14898315f, 0.28065604f, -0.01333104f, -0.10788297f, 0.20388293f, -0.15704942f, -0.00509519f, 
    -0.06148797f, -0.04745926f, -0.03002153f, 0.06211761f, -0.05379694f, -0.08866411f, 0.08137450f, -0.12687147f, 
    -0.00338320f, -0.14294189f, -0.09601463f, -0.12260897f, -0.01670706f, 0.07121328f, -0.11730224f, -0.03816268f, 
    -0.07808933f, 0.00666023f, -0.15481299f, 0.08986625f, -0.03688547f, -0.14973405f, -0.04658453f, -0.06574550f, 
    0.06912981f, 0.00832725f, -0.07856957f, 0.07180998f, -0.06080262f, 0.07084486f, 0.10415113f, 0.05303922f, 
    -0.11254974f, 0.04623008f, -0.10586222f, -0.14582536f, 0.08397628f, -0.07460053f, 0.06379639f, 0.00972292f, 
    0.06436077f, -0.05445278f, -0.06979063f, -0.07843543f, -0.11583089f, 0.10222878f, -0.00482742f, -0.06321277f, 
    0.03035985f, -0.08537932f, 0.05101364f, 0.11217164f, -0.12494056f, 0.04933526f, -0.10372350f, -0.13769875f, 
    -0.15653029f, -0.11487070f, -0.04506861f, -0.04404381f, 0.04902524f, 0.04959968f, -0.10060300f, 0.05068600f, 
    -0.05560570f, 0.31278247f, -0.77302086f, 0.15372762f, -0.21162619f, 0.23068008f, 0.01467721f, -0.23713544f, 
    0.10319521f, 0.23647001f, 0.04463464f, -0.03616239f, 0.11196913f, 0.27021357f, -0.10003319f, -0.10892750f, 
    0.29984325f, -0.27585539f, 0.11251842f, -0.01478362f, 0.36383244f, -0.42728412f, 0.13852505f, -0.16476569f, 
    -0.08214588f, -0.16260915f, 0.20491281f, 0.23742025f, -0.02199469f, -1.05558348f, 0.21350154f, -0.09321328f, 
    0.11643919f, -0.21405615f, 0.02625388f, 0.01769945f, -0.03726816f, -0.39708880f, -0.11442674f, -0.35818306f, 
    0.04293314f, -0.09558026f, 0.02854508f, -0.11163227f, -0.02600653f, 0.17755851f, -0.05132778f, -0.12863465f, 
    0.14154328f, 0.25756231f, -0.29736012f, 0.22633061f, -0.28964004f, -0.06307196f, 0.21505252f, -0.51560426f, 
    0.13151573f, 0.23726590f, 0.08568902f, -0.36787164f, 0.03708550f, 0.25761312f, -0.05572219f, 0.00137249f, 
    -0.11299559f, 0.02483637f, -0.08555605f, 0.12973657f, -0.07003265f, -0.09972549f, 0.09358607f, -0.13170174f, 
    0.07699385f, -0.11444102f, -0.09995203f, 0.09691431f, 0.04791545f, 0.01879423f, 0.06035936f, 0.02490731f, 
    -0.05138227f, -0.02512726f, -0.04545994f, -0.04884149f, -0.03742563f, -0.00791686f, 0.08608928f, -0.06972999f, 
    -0.00475543f, -0.06560569f, -0.04256864f, 0.03462663f, -0.03579907f, 0.03508708f, -0.12193953f, 0.09351663f, 
    0.04093255f, -0.07469313f, 0.11619207f, -0.11528151f, 0.11749205f, 0.10767192f, 0.11389846f, -0.07756991f, 
    0.03288274f, -0.03779047f, -0.03691369f, 0.08306279f, 0.00589590f, 0.06708053f, -0.00167724f, -0.11343816f, 
    -0.06981297f, 0.05118030f, -0.01199726f, 0.00709293f, 0.03358063f, 0.02473155f, 0.03994198f, 0.08426366f, 
    -0.03106549f, 0.00431397f, 0.00319221f, -0.10561141f, 0.07839154f, -0.08076034f, 0.06994607f, 0.07715382f, 
    -0.10432145f, 0.03041856f, -0.09352887f, 0.06885029f, 0.02322994f, 0.05331025f, 0.09018065f, 0.00785632f, 
    -0.07789018f, 0.04905241f, -0.02196209f, -0.00479956f, 0.05263625f, -0.02112873f, -0.00387913f, -0.02574114f, 
    -0.15319201f, -0.12439294f, -0.03110830f, 0.06607272f, -0.08838771f, 0.02291353f, -0.11417307f, 0.04131268f, 
    -0.13503624f, -0.09025982f, -0.05658173f, 0.08817008f, -0.03695509f, -0.15492825f, -0.09592028f, 0.04868206f, 
    0.05977722f, -0.11969869f, -0.00715271f, -0.00331401f, -0.11320358f, -0.01874374f, 0.07130980f, -0.13352902f, 
    -0.10434702f, -0.11613140f, 0.05586846f, -0.13948610f, -0.10621604f, -0.11801653f, 0.12150446f, -0.12796035f, 
    -0.10366431f, 0.05854109f, 0.04815745f, 0.06538022f, 0.05381481f, 0.05396798f, -0.05357344f, -0.11025121f, 
    -0.10775587f, 0.04644665f, -0.10109831f, -0.02047342f, -0.10706849f, 0.06268659f, 0.02984653f, 0.06480063f, 
    -0.09036876f, 0.06145608f, -0.11501586f, -0.10728054f, -0.00841600f, 0.02132230f, -0.05530988f, 0.00697343f, 
    0.03135136f, -0.03058500f, 0.04529575f, 0.06614042f, -0.00256551f, -0.03218508f, -0.00155862f, 0.01120289f, 
    -0.05910493f, -0.15302089f, -0.17691174f, -0.18001552f, -0.13236548f, -0.02350709f, -0.16009961f, 0.01415359f, 
    0.03520329f, -0.14455307f, -0.09387992f, 0.01433814f, 0.02023196f, -0.13254246f, 0.09742233f, -0.09333223f, 
    0.09329620f, -0.08776790f, 0.00953927f, -0.08251016f, -0.11206965f, 0.10450818f, 0.04746868f, -0.07250101f, 
    0.06003030f, 0.01132189f, 0.11911003f, 0.00880854f, -0.01125852f, 0.00388230f, 0.03847303f, -0.13805588f, 
    -0.09212898f, -0.04327588f, -0.02324851f, 0.07058700f, 0.04503833f, -0.00515647f, -0.05333975f, -0.07790214f, 
    -0.03019579f, 0.16400011f, -0.08417139f, 0.08592850f, 0.02140343f, -0.00378685f, -0.05607349f, -0.03258211f, 
    0.08466413f, -0.35436496f, 0.19189456f, -0.31049314f, 0.21926738f, 0.34105116f, 0.00812095f, 0.28123981f, 
    -0.23178574f, 0.14268506f, -0.17515099f, -0.24347429f, 0.10041351f, 0.01138493f, 0.05904527f, 0.58422440f, 
    -0.04814884f, -0.15519702f, -0.38226929f, -0.47428140f, 0.01000365f, 0.02015859f, -0.47378781f, 0.60430133f, 
    -0.41543132f, 0.15831056f, -0.12391712f, -0.22133951f, -0.38855833f, 0.15955974f, 0.19068146f, -0.00390359f, 
    -0.02704851f, -0.04226428f, 0.25353593f, -0.29260874f, 0.04452676f, 0.41278720f, 0.03303031f, 0.29302299f, 
    -0.08053213f, 0.10876806f, -0.05351850f, -0.09229465f, 0.06048966f, 0.13437463f, -0.00254317f, 0.06680610f, 
    0.34000221f, -0.25818187f, 0.05897372f, -0.19738483f, -0.04632411f, -0.00301512f, -0.21040924f, -0.02455262f, 
    0.07780695f, 0.04544637f, 0.20657967f, -0.05300071f, 0.02340630f, 0.01684037f, 0.47894719f, -0.38112214f, 
    -0.20594868f, -0.29578930f, -0.07338603f, 0.18713897f, -0.07436354f, 0.32910964f, -0.00618106f, -0.12637420f, 
    -0.01747725f, -0.00217045f, -0.00061230f, 0.64608091f, 0.37674183f, -0.09805068f, -0.12188399f, 0.09878516f, 
    0.04809491f, 0.23816954f, 0.00941662f, 0.07846477f, 0.09750205f, 0.06900018f, 0.00765824f, -0.31383255f, 
    0.01177427f, 0.01109539f, -0.01881908f, 0.04175513f, 0.02015352f, 0.13830318f, 0.13986658f, -0.05747842f, 
    0.09461731f, -0.10757838f, 0.05841469f, -0.06418037f, -0.01569559f, -0.09076364f, -0.11860623f, 0.06739091f, 
    -0.05278166f, -0.10635452f, -0.01777163f, -0.02427129f, -0.13703625f, -0.10411372f, -0.18167888f, -0.03020038f, 
    -0.01446482f, -0.01637428f, 0.23693192f, -0.06981662f, -0.04584391f, 0.03541604f, -0.00432884f, 0.27824003f, 
    0.01812354f, 0.17165790f, 0.00110343f, 0.02250975f, 0.11740038f, 0.08514273f, -0.08248468f, -0.03899373f, 
    -0.03437715f, -0.50281936f, 0.14460965f, 0.38778573f, -0.01269161f, 0.14108996f, 0.09416589f, 0.13224369f, 
    -0.02013230f, 0.05480338f, 0.24115969f, 0.09813484f, -0.07507829f, -0.43154201f, -0.09800386f, -0.11713824f, 
    -0.00596641f, 0.41196659f, 0.15243024f, 0.07781275f, -0.13540852f, 0.28204751f, 0.02961901f, 0.03599539f, 
    -0.33594850f, 0.13447189f, -0.04623704f, 0.32477999f, -0.15644254f, 0.16801594f, -0.06187105f, -0.08260827f, 
    0.04119518f, 0.19172062f, 0.14298998f, -0.35123003f, 0.15550071f, 0.29317734f, 0.15547146f, -0.20684184f, 
    -0.09712291f, -0.10968076f, 0.02954160f, -0.21531603f, -0.04096607f, -0.08919974f, 0.08692557f, 0.14742348f, 
    -0.20512176f, 0.33621562f, 0.32194167f, 0.12475650f, 0.30137455f, 0.05045150f, -0.00532316f, 0.35425359f, 
    0.11645173f, -0.16899282f, 0.22814578f, 0.16661327f, -0.00608920f, -0.10807614f, -0.02913433f, -0.13830116f, 
    -0.27404246f, 0.05464381f, -0.09680762f, 1.00436139f, 0.10703696f, 0.76249707f, -0.08513102f, -0.08146255f, 
    0.03645135f, -0.13381788f, 0.18074447f, 0.47070202f, -0.18904381f, -0.25234982f, -0.07255846f, -0.23955171f, 
    -0.16869435f, 0.03688079f, 0.14765973f, 0.04694045f, -0.45001397f, 0.28465876f, 0.05914835f, -0.44682500f, 
    0.00716328f, -0.10213570f, 0.23055704f, -0.42957029f, 0.08645346f, 0.02296314f, -0.59100503f, -0.03149284f, 
    0.29463875f, 0.18066318f, -0.00973773f, 0.25503379f, -0.14383765f, 0.19503833f, 0.03764737f, -0.09325572f, 
    -0.01737770f, 0.10784578f, -0.08467267f, 0.03931727f, -0.12522088f, -0.42115435f, 0.09252311f, -0.06739371f, 
    -0.22709282f, -0.47998443f, 0.09450763f, -0.70495671f, 0.07978689f, 0.09379551f, -0.69522297f, 0.07848739f, 
    -0.00494658f, 0.43434069f, 0.10649850f, -0.05575432f, -0.01934864f, 0.33718193f, -0.13020591f, 0.02155694f, 
    0.21027701f, -0.63215637f, 0.13576274f, 0.98066336f, 0.19265571f, -0.29862076f, 0.06834253f, -0.05096298f, 
    0.03298734f, 0.23705342f, 0.06887421f, 0.00190693f, 0.20426039f, -0.44271865f, -0.10356726f, 0.10265028f, 
    -0.06247989f, -0.16641824f, 0.03205737f, 0.08417269f, 0.28333297f, -0.04259631f, 0.07481126f, -0.04722927f, 
    0.13359192f, -0.10794507f, -0.46089661f, -0.08087571f, -0.17592411f, -0.04860739f, 0.03165099f, 0.13985541f, 
    0.15507126f, 0.12770985f, 0.06213656f, -0.13139994f, 0.17796116f, -0.14863679f, 0.04262884f, -0.27150446f, 
    0.01533582f, 0.04337336f, 0.07909764f, 0.19414067f, -0.04308716f, -0.16735251f, 0.19419126f, 0.09736242f, 
    -0.00498955f, 0.06307318f, -0.05297129f, -0.11854786f, -0.03165182f, -0.10693394f, 0.30970249f, -0.61971325f, 
    0.29158223f, -0.12269396f, 0.15152115f, 0.14509766f, -0.12729311f, 0.02660788f, -0.10760020f, -0.11644360f, 
    -0.01185931f, -0.11189678f, 0.12199262f, 0.24975973f, 0.12560175f, 0.35006523f, 0.01006751f, 0.09217803f, 
    0.17979112f, 0.05860537f, -0.18127313f, -0.00091207f, -0.31357720f, -0.30206835f, -0.03076483f, 0.25271752f, 
    0.08833650f, 0.11466656f, -0.05815247f, -0.02809606f, -0.68887109f, 0.19411895f, -0.11298759f, -0.09199667f, 
    -0.01322576f, 0.08127398f, 0.03986430f, -0.61423081f, -0.73389047f, -0.06800006f, -0.41061413f, 0.05879701f, 
    0.22137572f, 0.19158754f, 0.02394890f, 0.12483826f, 0.15734704f, 0.30994120f, 0.02711786f, -0.16620061f, 
    -0.03532800f, -0.04636136f, 0.07767697f, 0.14026676f, 0.20149341f, -0.76769507f, -0.12449929f, 0.17591274f, 
    -0.36765185f, -0.26549789f, 0.19919538f, -0.43417636f, 0.07568187f, 0.05942012f, -0.33033815f, -0.11689322f, 
    0.16942923f, -0.27426124f, -0.56761849f, 0.13378832f, -0.01574102f, 0.04464178f, -0.22753373f, -0.47974402f, 
    -0.24524994f, -0.05593678f, -0.02642219f, -1.10238445f, 0.04422266f, 0.30395824f, -0.05612577f, 0.23747963f, 
    0.08281562f, 0.19734809f, -0.07816837f, 0.44810399f, 0.40137169f, 0.57237971f, 0.10580941f, 0.69022524f, 
    -0.24934673f, 0.08507883f, -0.01654796f, 0.11059434f, -0.20713048f, 0.05474049f, 0.15455806f, 0.25117013f, 
    0.02367795f, -0.25565228f, 0.15025324f, -0.29311725f, 0.16189095f, -0.04461461f, 0.03278161f, 0.02659401f, 
    -0.34181988f, -0.07350013f, 0.09760974f, 0.00058282f, 0.21727541f, -0.00446768f, 0.06650718f, 0.18152921f, 
    -0.04675692f, -0.02034983f, 0.01464428f, 0.20337895f, 0.21765779f, -0.03712388f, -0.31282172f, -0.00078042f, 
    0.20654491f, -0.02490984f, -0.00355204f, -0.10892223f, -0.03326681f, -0.09896307f, 0.03034366f, -0.10239267f, 
    0.09810194f, 0.25541645f, -0.34083730f, 0.06417594f, 0.06556964f, 0.30879274f, -0.12332083f, 0.17788950f, 
    0.01835934f, 0.12203329f, 0.09498934f, 0.15995406f, 0.06289714f, 0.51670986f, -0.01723528f, -0.13855210f, 
    -0.08973896f, 0.06905787f, -0.27057612f, -0.15175788f, -0.15798753f, -0.50574487f, -0.06891773f, 0.12602715f, 
    0.14589830f, -0.04524725f, -0.23206560f, -0.35189521f, 0.36821315f, 0.09437515f, -0.25371861f, 0.12513784f, 
    -0.16356848f, 0.12690756f, 0.08823797f, 0.04922047f, 0.02052801f, 0.15668339f, 0.17342718f, -0.08221284f, 
    0.40065503f, 0.06631071f, 0.10196707f, -0.10052165f, 0.01960763f, 0.20134370f, -0.02897310f, 0.24906844f, 
    -0.05374954f, -0.00395704f, 0.10670592f, -0.41624114f, 0.06873971f, 0.22997411f, -0.15835059f, 0.12843443f, 
    0.12166894f, 0.01672845f, 0.19667868f, -0.09171725f, -0.04565886f, 0.03977286f, -0.31854698f, 0.42263493f, 
    0.12213497f, -0.00981992f, 0.06659743f, -0.16689511f, 0.09605654f, -0.04879479f, 0.11464128f, -0.63876569f, 
    0.20022255f, -0.26988992f, 0.18838510f, -0.47700697f, 0.12402196f, -0.32112765f, 0.05186005f, 0.17023617f, 
    0.20584790f, 0.25017315f, -0.00848561f, 0.30442294f, -0.24165824f, 0.03032532f, -0.13182966f, 0.44088295f, 
    -0.19854395f, 0.05223457f, -0.06167833f, 0.16971853f, -0.05370807f, 0.16747169f, -0.20756856f, 0.28109807f, 
    -0.06263295f, 0.37588891f, -0.12844622f, -0.17810974f, 0.12448255f, 0.09349484f, -0.09322085f, 0.12677981f, 
    -0.50807047f, 0.13702665f, 0.26595929f, -0.09866192f, 0.19494995f, 0.20659499f, -0.00936307f, 0.63776433f, 
    -0.03311977f, -0.10370822f, 0.10392135f, -0.04994178f, 0.06940414f, 0.25879800f, -0.16230117f, 0.20141566f, 
    0.02741443f, 0.11788651f, 0.05067791f, -0.31190777f, 0.05415547f, 0.01915839f, -0.75782031f, 0.04098476f, 
    0.14081094f, 0.18524688f, -0.23763920f, -0.02748720f, 0.13383387f, 0.06688823f, 0.23951583f, -0.17044277f, 
    -0.06636903f, -0.70172876f, -0.29648978f, 0.41391385f, 0.03390140f, 0.25557777f, -0.01426721f, -0.29152641f, 
    0.34950355f, 0.08235110f, -0.19151773f, -0.14097942f, -0.50551248f, -0.09982526f, 0.01124951f, 0.19565079f, 
    0.12768571f, 0.01701349f, 0.08019338f, 0.07573729f, 0.32852978f, 0.26013002f, 0.01111251f, -0.33194205f, 
    0.04593647f, 0.21371552f, 0.34699383f, 0.14149992f, 0.02507933f, -0.21855000f, -0.01278491f, 0.04918885f, 
    -0.13071491f, 0.22454111f, -0.03681051f, 0.34317771f, 0.02309697f, -0.14389959f, 0.04235733f, 0.13745567f, 
    0.03296259f, -0.04576121f, 0.06811225f, -0.16296011f, 0.25247821f, 0.32672209f, -0.06178255f, 0.10256851f, 
    0.04488013f, -0.02482376f, -0.09023651f, 0.11028865f, -0.09593902f, -0.02896112f, -0.63180506f, 0.15378483f, 
    0.11644367f, 0.54031134f, -0.12353895f, -0.18798825f, -0.07329199f, 0.43890846f, 0.17871132f, -0.43767586f, 
    0.36823630f, 0.38676834f, 0.40579686f, -0.19449425f, 0.12605013f, -0.27734089f, -0.02421159f, 0.29296827f, 
    -0.06119067f, 0.09635407f, 0.07389653f, -0.23287135f, -0.15796784f, -0.31608772f, -0.10324533f, 0.02488983f, 
    -0.13613035f, 0.16008522f, -0.05482630f, -0.03491417f, 0.04185965f, -0.02165117f, -0.15989009f, 0.52516973f, 
    -0.04929506f, 0.28665209f, -0.39472523f, 0.07978569f, 0.07129744f, 0.26243797f, 0.01680834f, -0.08037238f, 
    -0.13074549f, 0.09881112f, 0.24946970f, -0.28532586f, 0.11260286f, 0.20624928f, 0.08491023f, 0.42905995f, 
    0.05753325f, -0.10288674f, 0.08981307f, -0.17019525f, 0.03217469f, 0.20431711f, 0.38342956f, 0.28785878f, 
    0.05521275f, -0.04375334f, -0.05515123f, -0.05980139f, 0.07618760f, 0.02783313f, 0.12194295f, -0.00658693f, 
    0.05924101f, -0.09652352f, 0.15345483f, 0.15783688f, 0.15925069f, -0.34258601f, 0.40137765f, 0.14043215f, 
    -0.00801673f, -0.06392509f, 0.04202364f, 0.00580959f, -0.03911333f, 0.01561317f, 0.12167448f, 0.00846750f, 
    -0.12616271f, -0.05409688f, -0.09075760f, -0.12127441f, -0.11133566f, -0.00897260f, -0.03002290f, 0.03803914f, 
    0.07279576f, -0.10424890f, -0.09604454f, 0.07803847f, 0.07000180f, -0.12557752f, -0.09079834f, -0.14026611f, 
    -0.11775760f, -0.01723184f, -0.09512831f, -0.01765506f, 0.10523393f, 0.07131498f, 0.00167403f, 0.03783962f, 
    0.00682130f, 0.03530838f, -0.00997858f, -0.12634197f, -0.11561871f, 0.09938561f, 0.07534778f, -0.07481629f, 
    -0.08682753f, -0.01479189f, -0.04335962f, -0.10904066f, 0.06990172f, -0.07453018f, -0.08362785f, 0.07296090f, 
    -0.09205104f, -0.02968984f, -0.10028594f, 0.05023810f, 0.04093406f, -0.05419700f, -0.01602904f, 0.03108920f, 
    0.10304245f, 0.02242178f, 0.07610722f, 0.04159912f, 0.00791579f, 0.01349332f, -0.08704988f, 0.09091272f, 
    0.19572811f, -0.19457924f, -0.16240385f, -0.44892439f, 0.02781913f, 0.19635671f, -0.07860281f, 0.10069413f, 
    0.02103478f, 0.12273613f, 0.33632678f, -0.08736318f, 0.40178692f, 0.41977304f, 0.06414597f, -0.15933114f, 
    0.29356629f, -0.13141772f, 0.07884642f, -0.06144169f, 0.10787422f, -0.13761972f, 0.33677983f, 0.16372859f, 
    -0.05122170f, 0.00902193f, 0.06239861f, 0.21666965f, 0.22841500f, -0.18920940f, 0.25027141f, 0.09982391f, 
    -0.50866181f, 0.03296468f, -0.04956198f, 0.11650620f, 0.06288029f, -0.13471009f, 0.07986457f, -0.05998425f, 
    -0.08394761f, 0.04339491f, -0.06183578f, -0.21221779f, 0.17014946f, 0.06941286f, 0.01700669f, -0.11106025f, 
    0.00576993f, 0.10204182f, -0.01593189f, -0.02724484f, 0.19095291f, -0.07759282f, 0.36220026f, 0.04290117f, 
    0.19794309f, 0.50907362f, -0.05381197f, -0.27166215f, 0.02355299f, 0.21543366f, 0.32092696f, 0.26303270f, 
    -0.09062805f, -0.36131114f, 0.02193908f, 0.03346140f, 0.07102094f, 0.88741344f, 0.05558945f, 0.14530167f, 
    -0.21552244f, -0.16087188f, 0.09284104f, -0.13529596f, 0.10235312f, 0.19204526f, 0.05071244f, -0.04618324f, 
    0.24646652f, 0.24675372f, -0.24614674f, -0.04723679f, -0.42222854f, 0.33097821f, -0.19087979f, 0.22374444f, 
    -0.21250960f, -0.04781818f, 0.19639066f, -0.36406198f, -0.43663001f, 0.20649226f, -0.17792688f, -0.00913564f, 
    -0.05210315f, -0.12082820f, 0.14712214f, 0.21249531f, -0.00729214f, 0.48681900f, -0.07142408f, -0.23196992f, 
    0.03777094f, 0.02068375f, 0.00820583f, -0.08370934f, 0.05320912f, -0.16456662f, -0.17821038f, 0.17030065f, 
    -0.16193999f, -0.44669238f, 0.33596039f, -0.19691707f, 0.24978274f, 0.00209817f, -0.23453766f, 0.26583976f, 
    0.04054397f, 0.36836144f, 0.07530828f, -0.10120732f, 0.06909295f, 0.36366227f, 0.13956913f, -0.29612961f, 
    -0.05577690f, -0.19768736f, 0.08830789f, 0.65299189f, -0.06240199f, 0.13774438f, 0.07372141f, -0.37216276f, 
    -0.23938683f, -0.04921427f, -0.06636506f, 0.10084011f, -0.00531684f, -0.46426234f, 0.07060079f, 0.07187749f, 
    0.07862177f, 0.18268450f, 0.06212552f, -0.33364010f, -0.01318249f, 0.15383030f, -0.02936631f, 0.12670061f, 
    -0.55639625f, 0.21576045f, -0.14687590f, 0.35612747f, -0.37588370f, -0.14192656f, 0.05781367f, -0.07878338f, 
    0.32079870f, -0.21514319f, -0.02515272f, -0.39391929f, 0.14262863f, 0.42911518f, -0.10143052f, -0.11635078f, 
    0.04091654f, -0.08111423f, -0.03206453f, -0.19376931f, 0.11378207f, -0.08239698f, 0.05576892f, 0.24607921f, 
    0.04923177f, 0.31468076f, 0.43258241f, 0.12625153f, -0.01257717f, -0.03630760f, 0.04916573f, 0.03552046f, 
    0.18231618f, -0.31786829f, 0.30837464f, 0.02037618f, 0.08814971f, 0.03052201f, 0.07548628f, -0.35417697f, 
    0.08546168f, -0.71623027f, 0.24031754f, 0.67184114f, 0.11982328f, -0.11875077f, 0.00105732f, -0.24294093f, 
    0.07212040f, 0.16841015f, -0.24470754f, 0.48482633f, 0.30794138f, -0.24424586f, 0.12549815f, 0.61287832f, 
    -0.11980121f, -0.18272331f, -0.21849009f, -0.09862329f, 0.15007994f, -0.20391974f, -0.11600660f, 0.12972471f, 
    -0.22992513f, -0.12163115f, -0.51865673f, 0.12218858f, -0.18456843f, -0.10783719f, 0.27043647f, 0.12555599f, 
    0.33336633f, -0.02335286f, 0.16564211f, -0.36191058f, 0.09198534f, 0.12163323f, -0.06067289f, 0.09584792f, 
    0.03872260f, 0.03415676f, 0.09173329f, 0.35885093f, 0.07643410f, 0.00998226f, 0.11102438f, 0.14228342f, 
    0.28730953f, 0.23592298f, 0.23331286f, -0.12568569f, -0.30123943f, -0.02878208f, 0.10964697f, -0.63017774f, 
    0.23208442f, -0.27218938f, 0.22552733f, 0.13521701f, -0.05804496f, -0.17233640f, 0.07833048f, -0.26603615f, 
    -0.15150636f, 0.45550433f, 0.03846435f, 0.40875852f, -0.08899066f, 0.06283429f, -0.09350090f, -0.03876472f, 
    0.04384303f, 0.04746197f, 0.04685986f, 0.66504437f, 0.35960168f, 0.26101282f, 0.07136303f, -0.03741230f, 
    0.22305714f, -0.01589796f, 0.14788409f, 0.11568400f, 0.01922602f, -0.10698881f, 0.16417594f, -0.17328419f, 
    -0.01402576f, -0.42213532f, 0.17155795f, 0.22112091f, 0.02935292f, 0.09766539f, 0.26796716f, 0.02586898f, 
    0.60619342f, 0.00031732f, -0.12671919f, 0.37841254f, 0.04811803f, 0.00552957f, -0.06225524f, -0.14941178f, 
    -0.03373790f, -0.09244025f, -0.02615847f, 0.20563304f, -0.14762005f, -0.14660192f, -0.12188721f, -0.02980555f, 
    0.12324909f, 0.15628977f, 0.04724274f, 0.18241003f, -0.09503234f, 0.06282885f, 0.31862244f, -0.34718055f, 
    0.20090418f, 0.07424151f, -0.13749468f, 0.09193453f, -0.03653137f, 0.32566398f, -0.15563685f, -0.05046837f, 
    -0.00324687f, -0.11502397f, 0.05192880f, -0.01979226f, -0.08750259f, -0.05247126f, -0.08404532f, -0.08364587f, 
    -0.10812715f, -0.08446528f, -0.13337998f, -0.11407369f, 0.06427678f, -0.02149610f, -0.07951865f, 0.00169898f, 
    -0.04753362f, -0.02242426f, -0.03284933f, -0.05331480f, 0.07296132f, -0.08545278f, -0.04200329f, -0.08650135f, 
    -0.01801765f, -0.10181149f, 0.01905452f, 0.07613372f, -0.02506455f, -0.04029651f, -0.14170007f, -0.11721368f, 
    0.08242720f, -0.08434480f, 0.07829080f, -0.10200381f, -0.12311447f, -0.05376210f, 0.00969957f, 0.03822648f, 
    -0.10565437f, 0.04948801f, -0.11019552f, 0.08116643f, 0.02267108f, -0.09893648f, -0.00947286f, 0.02740785f, 
    -0.10141086f, 0.06109626f, 0.07064109f, 0.09540018f, 0.06054827f, 0.09363855f, 0.04610383f, -0.08074855f, 
    0.02686522f, -0.05408514f, 0.08865967f, -0.03656174f, 0.06827651f, -0.07676766f, -0.10192317f, -0.05964911f, 
    -0.26044106f, -0.06035043f, 0.14743437f, -0.05619136f, -0.10426059f, -0.51530242f, -0.09514153f, 0.17432870f, 
    -0.13097192f, -0.37306318f, -0.29830495f, -0.07446352f, -0.33200005f, -0.02072372f, -0.04140864f, 0.47222802f, 
    -0.07107344f, 0.24452716f, -0.18187234f, 0.14835469f, -0.01530309f, 0.10760751f, 0.00438581f, 0.05664894f, 
    -0.09212811f, -0.10544602f, 0.21108975f, -0.18663034f, -0.41477820f, 0.00680593f, -0.05868910f, 0.10939837f, 
    0.07156052f, -0.21228984f, -0.28052813f, -0.10395856f, -0.44948241f, 0.27238488f, -0.07870896f, -0.13069433f, 
    0.01470001f, -0.04995951f, -0.09516451f, -0.07054163f, -0.11125241f, -0.15737273f, -0.46286538f, -0.11539751f, 
    0.04142238f, -0.37735787f, 0.30511698f, 0.08153131f, 0.01540709f, 0.01736188f, -0.52761477f, 0.25359926f, 
    -0.11514252f, -0.11899312f, -0.07517105f, 0.11439780f, 0.00813478f, 0.23722045f, -0.39663833f, -0.16831908f, 
    0.12764159f, 0.32705542f, -0.10302661f, -0.51603746f, -0.01317488f, 0.47104281f, 0.03965729f, 0.19667178f, 
    -0.30456057f, -0.10313430f, 0.02352200f, -0.20127779f, 0.40580475f, 0.47665390f, 0.02533466f, -0.02100031f, 
    0.03810158f, -0.11564682f, -0.20706300f, -0.46339712f, -0.00671024f, -0.14530420f, 0.01679936f, 0.36969644f, 
    -0.30930629f, 0.07129726f, 0.08846071f, 0.02297859f, 0.10349522f, -0.05450808f, 0.18683973f, 0.04462021f, 
    -0.09436298f, -0.19797820f, -0.10603489f, -0.07517802f, 0.12686695f, 0.25275040f, 0.10527564f, 0.29568630f, 
    0.08153855f, -0.11640836f, -0.09670357f, -0.26667833f, 0.10602961f, 0.22206555f, -0.10120583f, 0.07660162f, 
    0.09798674f, -0.02163074f, 0.10459646f, -0.12705602f, 0.01676791f, -0.05707671f, 0.13337143f, 0.17541300f, 
    0.11743671f, 0.31214398f, 0.30602020f, -0.18638046f, 0.13937178f, -0.06055843f, 0.48098001f, -0.18728675f, 
    -0.36975971f, -0.00670579f, -0.21979596f, 0.12628390f, 0.04523818f, 0.20269984f, -0.01584078f, 0.08708914f, 
    0.03171821f, -0.17714290f, -0.24418741f, -0.55152756f, -0.53090078f, 0.23793238f, 0.02858919f, -0.05145030f, 
    -0.07577604f, 0.04547748f, -0.21900579f, -0.09222616f, -0.03830718f, 0.09876739f, -0.10223158f, -0.15129845f, 
    -0.04340642f, -0.15164001f, 0.08613688f, -0.04979052f, -0.11356723f, 0.03643835f, -0.26440337f, -0.03986415f, 
    -0.04058858f, 0.06078209f, -0.25176093f, -0.03481647f, -0.08411932f, 0.34364426f, 0.04022324f, -0.26952395f, 
    -0.08083013f, 0.08426782f, -0.05429627f, 0.03538240f, -0.17598708f, 0.10267039f, -0.17940828f, -0.24384166f, 
    0.11184650f, -0.25963366f, 0.32862392f, -0.05104709f, 0.03699734f, -0.11897652f, 0.00568089f, 0.02154251f, 
    -0.09122831f, -0.12384629f, -0.03734598f, -0.01790057f, 0.07094005f, 0.38176054f, -0.26185262f, -0.16751873f, 
    0.13065839f, 0.15117125f, -0.58655405f, 0.16977537f, -0.10225053f, -0.07958737f, 0.00915247f, -0.30379897f, 
    -0.22279400f, -0.04106603f, 0.02271248f, -0.14120443f, 0.08736663f, 0.16265714f, 0.07715987f, -0.31526598f, 
    0.39270034f, 0.14161362f, 0.22655283f, -0.20482811f, 0.17162944f, -0.25288099f, 0.16562630f, -0.19196792f, 
    -0.35256377f, -0.08316956f, 0.06969047f, 0.27583879f, 0.11510383f, -0.64122510f, 0.23675880f, -0.11767898f, 
    0.09983325f, -0.05658641f, 0.03455845f, -0.28151673f, -0.07132922f, -0.26914251f, -0.12525856f, -0.23364651f, 
    0.02885053f, 0.04505201f, 0.08011065f, -0.25236538f, 0.07303168f, 0.29555222f, 0.11536876f, -0.14377083f, 
    0.15287016f, 0.28068745f, -0.10922614f, 0.46009338f, -0.06686877f, 0.06347087f, 0.54089326f, -0.22425544f, 
    -0.03385873f, 0.01556594f, 0.23490915f, -0.26021680f, 0.03442610f, 0.07908927f, 0.10462454f, 0.15163727f, 
    -0.10022462f, 0.45388654f, -0.05245407f, -0.21476150f, -0.11163635f, -0.37146935f, 0.12951024f, 0.25860766f, 
    -0.02633442f, -0.02343365f, 0.29170275f, -0.14379595f, -0.04923872f, 0.28927597f, -0.08125779f, -0.34953502f, 
    0.02162064f, 0.21733057f, 0.09994400f, 0.07691247f, -0.41932610f, -0.16024062f, 0.37269264f, 0.31825674f, 
    -0.16185506f, -0.13576566f, 0.11876599f, 0.22140636f, -0.37928087f, -0.09364645f, -0.11087443f, -0.02341485f, 
    -0.54239422f, -0.11805332f, -0.04312182f, 0.02012540f, -0.10602053f, 0.18230931f, 0.05442306f, -0.26646829f, 
    0.00300694f, 0.05240932f, 0.00787410f, -0.03492434f, 0.14437431f, -0.11021522f, 0.10768135f, -0.08347038f, 
    -0.36672750f, 0.21983564f, 0.03479394f, 0.20223469f, 0.07281043f, -0.02104136f, 0.27277398f, -0.39956447f, 
    -0.11748460f, -0.14597087f, 0.02253553f, 0.10839126f, 0.04581387f, 0.23962051f, 0.00986051f, 0.23195866f, 
    0.21232878f, -0.40444341f, 0.24243903f, 0.59579027f, 0.17103845f, -0.07464589f, -0.04953615f, 0.19762418f, 
    -0.02505619f, 0.19408458f, 0.04042086f, 0.23557320f, -0.04870743f, -0.39827991f, -0.02867878f, 0.29229701f, 
    0.04865604f, 0.13314924f, 0.06298544f, -0.08472136f, 0.05840110f, -0.02995634f, -0.08986601f, 0.03099909f, 
    -0.44449183f, -0.06287780f, -0.32102352f, 0.19928786f, -0.43712449f, 0.02053303f, -0.10566267f, -0.05418809f, 
    0.15218362f, 0.10118660f, 0.06059215f, -0.28423223f, 0.19531226f, 0.19609021f, 0.11630710f, -0.07424943f, 
    0.09215259f, -0.12286251f, 0.02994105f, 0.22536485f, 0.10896921f, -0.15201935f, -0.00363424f, -0.01176992f, 
    -0.22786483f, 0.10613730f, 0.16473058f, 0.20368481f, 0.04753904f, 0.11945128f, 0.19939226f, -0.49011189f, 
    0.19176209f, -0.30741829f, 0.10817228f, 0.21546501f, -0.00524187f, 0.07352110f, -0.10383186f, -0.22692366f, 
    -0.21750851f, -0.09035221f, 0.02988312f, 0.00207158f, 0.02479910f, 0.33902889f, -0.02519680f, -0.18540408f, 
    0.04795514f, 0.14116660f, -0.04949357f, 0.77106351f, 0.05120626f, 0.08466452f, 0.00048001f, 0.41112250f, 
    -0.11143702f, -0.06665158f, 0.22793545f, 0.03457870f, -0.06409100f, -0.05662230f, 0.04425393f, -0.19339685f, 
    0.03830229f, -0.20574379f, -0.03428899f, 0.07382976f, -0.03320574f, 0.01384338f, 0.14358988f, -0.01793637f, 
    0.49932441f, -0.12309786f, 0.06346952f, 0.12351954f, 0.11474907f, -0.05343575f, -0.09727003f, 0.08602536f, 
    0.02081881f, 0.01161674f, -0.05303092f, 0.25192833f, -0.05447011f, -0.20897400f, -0.12595335f, 0.06770293f, 
    0.15009268f, 0.28289789f, 0.05310634f, -0.00289099f, -0.17243430f, -0.00133129f, -0.00088941f, -0.16081661f, 
    0.13677827f, -0.13718404f, -0.24221954f, 0.15889585f, -0.01312391f, 0.14584750f, -0.17713048f, -0.05259443f, 
    0.04138014f, 0.41810241f, 0.07991379f, 0.42433694f, 0.25816599f, -0.38015768f, -0.07400088f, 0.01517456f, 
    -0.15980145f, -0.10073371f, 0.24577762f, -0.16539931f, 0.12013591f, -0.56074244f, -0.08202059f, -0.45982477f, 
    0.18352138f, 0.29194909f, 0.01965710f, -0.41322139f, 0.06047656f, 0.30781043f, -0.20057173f, 0.09251226f, 
    -0.16458699f, 0.37366104f, -0.15246488f, 0.16346325f, 0.16692375f, 0.26192936f, 0.13101578f, -0.06586830f, 
    -0.01851230f, 0.29935023f, 0.08389656f, -0.20002115f, 0.11066259f, 0.30391112f, -0.09281100f, 0.06326460f, 
    -0.05442983f, -0.03166496f, 0.10087377f, -0.54720247f, 0.09063727f, 0.18264312f, 0.16602096f, 0.08098834f, 
    -0.24471864f, 0.12849309f, 0.16642234f, -0.06852904f, 0.22178906f, -0.05293272f, 0.15195803f, 0.33311397f, 
    -0.09671257f, -0.09533460f, 0.42405841f, -0.20509140f, 0.15546106f, -0.06480957f, 0.41377720f, -0.15081879f, 
    0.17919847f, 0.82805061f, -0.22232251f, 0.09049551f, -0.04164840f, -0.42179486f, 0.00128596f, 0.04750471f, 
    0.37344342f, 0.20578194f, 0.04907803f, -0.09200592f, 0.01949837f, 0.13954493f, -0.02538818f, -0.06485707f, 
    0.08337548f, -0.30313694f, -0.02367655f, 0.05900556f, 0.34846571f, -0.00272672f, 0.12601557f, 0.00979937f, 
    0.03451053f, -0.18299414f, 0.08851591f, -0.17848617f, 0.22092164f, 0.00815055f, 0.11432177f, -0.05254348f, 
    -0.37954032f, 0.20229337f, 0.02958795f, 0.30777609f, -0.06474139f, -0.24957754f, -0.04103153f, 0.29430789f, 
    0.00214517f, -0.08905118f, -0.11165133f, 0.09095290f, 0.03178011f, 0.05737128f, 0.11012910f, -0.05707342f, 
    0.01299581f, -0.25405481f, -0.28307742f, 0.09170920f, -0.24142331f, -0.09690810f, 0.07520959f, -0.52842999f, 
    -0.02553342f, 0.18200046f, 0.05471558f, -0.20484777f, -0.11446713f, 0.20960575f, 0.17930357f, 0.09672420f, 
    0.07898200f, 0.25057304f, -0.01481361f, 0.61158586f, 0.09323635f, -0.06848582f, -0.00059696f, -0.10056693f, 
    0.27928796f, 0.06611029f, -0.09573812f, -0.44299436f, -0.29896423f, -0.29002675f, 0.08477364f, -0.17862567f, 
    0.11064210f, 0.04614979f, 0.11143807f, -0.04557835f, 0.20691893f, 0.20223217f, -0.02802029f, -0.13609847f, 
    -0.20556661f, 0.23964201f, -0.12206483f, 0.12079673f, -0.27139118f, -0.02902862f, -0.03740180f, 0.14843018f, 
    0.26560563f, 0.16236818f, -0.04933769f, 0.05364531f, 0.13827062f, -0.10547035f, -0.11788616f, -0.15045816f, 
    -0.08057638f, 0.01293240f, 0.01790972f, -0.08188047f, 0.08500473f, 0.12384094f, 0.00345463f, 0.09971451f, 
    0.01632882f, 0.00132379f, 0.14882176f, 0.13279313f, -0.13273379f, -0.06708145f, -0.05175190f, -0.15096180f, 
    0.13631082f, 0.13787208f, 0.12280254f, -0.17031287f, -0.10765182f, 0.15652505f, -0.05045199f, -0.55954349f, 
    0.49923590f, -0.01698327f, 0.13154897f, -0.17310807f, 0.10274085f, 0.03109576f, 0.11561012f, 0.24056707f, 
    0.13595219f, 0.13689190f, 0.03430288f, -0.51323485f, -0.24555685f, -0.47193173f, 0.06478600f, 0.18075196f, 
    -0.23337500f, -0.14326099f, -0.15580975f, 0.09146244f, -0.04314133f, 0.09841777f, -0.13143849f, 0.36283869f, 
    0.23284945f, 0.18981615f, 0.11309522f, -0.43510208f, 0.01877235f, 0.18446046f, -0.34622243f, 0.01553319f, 
    -0.77157694f, 0.15897392f, 0.10738523f, 0.04001452f, 0.06390548f, 0.04818400f, -0.05074879f, 0.12103307f, 
    -0.09815907f, 0.01669689f, -0.04966305f, 0.08582167f, 0.14680074f, 0.03052479f, 0.33052483f, 0.04592036f, 
    0.19458109f, -0.24368668f, -0.10221026f, -0.40338266f, 0.24676080f, -0.11487545f, -0.34170839f, 0.26101014f, 
    -0.05778350f, -0.05108739f, -0.15352848f, 0.17566788f, 0.05349829f, -0.24264905f, 0.17706953f, 0.00151828f, 
    -0.15344955f, -0.08012626f, 0.02414562f, 0.12021701f, -0.00566423f, -0.01790542f, 0.02427725f, -0.10717868f, 
    -0.09663703f, -0.12193758f, 0.04135465f, -0.00456142f, -0.00705844f, 0.10570992f, -0.05184847f, -0.01729565f, 
    -0.03051044f, -0.03010867f, 0.00853833f, 0.05482332f, 0.10847895f, -0.10829192f, -0.13317952f, -0.13794585f, 
    0.00544365f, -0.08330951f, -0.02860644f, 0.06614108f, -0.06002679f, -0.15049626f, -0.06835737f, -0.06330906f, 
    -0.04430193f, -0.09529636f, 0.01911840f, -0.01868086f, -0.00304093f, 0.06923573f, -0.01442699f, -0.05094407f, 
    -0.04405145f, -0.01239206f, -0.02780889f, -0.06930602f, 0.01111760f, -0.10442571f, -0.06098467f, 0.04388900f, 
    0.03888320f, 0.04097010f, -0.13802579f, 0.09025892f, 0.02135464f, 0.04846837f, -0.02532555f, -0.02675354f, 
    -0.02203984f, -0.02351213f, 0.10920732f, 0.02127682f, -0.00469801f, -0.07484306f, -0.01637165f, 0.06992001f, 
    0.03239348f, 0.63157582f, -0.31518877f, -0.82144815f, -0.18213509f, 0.24129654f, -0.09013475f, 0.13356891f, 
    -0.04291391f, 0.18985100f, 0.04232434f, 0.66375721f, 0.26130196f, 0.61506808f, 0.11290610f, 0.12232038f, 
    0.00256233f, -0.45940468f, 0.03302665f, -0.10039110f, -0.06512797f, -0.25539142f, 0.21289027f, 0.11961859f, 
    0.00804321f, -0.53637564f, 0.24337779f, 0.13718736f, 0.40967807f, -0.20321462f, 0.28247395f, -0.07232988f, 
    0.05412906f, -0.32480037f, -0.13255432f, 0.47030544f, 0.19847146f, 0.03488209f, 0.07345013f, 0.34471986f, 
    -0.04324920f, 0.11034299f, -0.06832682f, 0.04933023f, 0.12662214f, 0.26680633f, -0.05873495f, -0.21248175f, 
    0.01881504f, -0.02740507f, -0.25822094f, 0.13674286f, -0.10968728f, -0.01250032f, 0.08125718f, -0.13546568f, 
    0.16838075f, 0.50818956f, -0.03213982f, -0.13653222f, 0.10948573f, 0.43082538f, 0.26304096f, 0.29180104f, 
    0.13221183f, 0.75985175f, 0.09840848f, 0.09646685f, -0.11365554f, -0.42328048f, 0.12669575f, -0.00639750f, 
    -0.22500701f, 0.16305055f, 0.17771967f, -0.28322834f, -0.16853288f, 0.17391770f, 0.06991342f, -0.68183941f, 
    0.34899151f, 0.14760876f, 0.28598553f, -0.13360393f, -0.12723467f, -0.15042499f, 0.03847673f, 0.00739422f, 
    -0.12333764f, 0.30027246f, 0.07211659f, 0.38153407f, -0.08027337f, -0.06238136f, 0.03076538f, 0.08815973f, 
    -0.06180127f, 0.06363099f, 0.06308050f, -0.19602866f, 0.07383920f, -0.22307800f, 0.06434741f, -0.34617168f, 
    0.04734911f, 0.02984984f, 0.03068629f, -0.54105282f, 0.20439880f, 0.07534052f, 0.29767907f, -0.11292425f, 
    -0.21512501f, 0.21875414f, -0.14096573f, 0.31647465f, -0.07425733f, 0.04667834f, 0.43529904f, 0.30734962f, 
    -0.04963399f, 0.10778967f, 0.16193627f, -0.15943868f, 0.07914793f, 0.09958777f, 0.22276036f, 0.12125825f, 
    -0.02868072f, -0.04016548f, -0.00926143f, -0.03701454f, -0.09556071f, 0.09059224f, -0.04957426f, 0.02669166f, 
    -0.07495297f, -0.06028553f, 0.08421045f, 0.01879164f, 0.04705125f, 0.09168961f, 0.01407689f, -0.13697915f, 
    -0.12519452f, 0.01324336f, -0.08517095f, -0.08211416f, 0.02651032f, -0.09644336f, -0.08133238f, 0.00835528f, 
    -0.00666544f, -0.10224712f, -0.12941457f, -0.09068194f, 0.02782112f, 0.07211851f, 0.06851941f, 0.07049331f, 
    0.08047967f, -0.00332343f, -0.11190084f, -0.14718677f, -0.16282161f, 0.06137858f, -0.03840731f, 0.03804898f, 
    -0.07969929f, -0.07260469f, -0.12095805f, 0.01465481f, -0.13954765f, -0.13514589f, -0.05906706f, -0.18022384f, 
    -0.01868391f, -0.07165477f, 0.05108302f, 0.07618031f, -0.08446629f, 0.08038869f, 0.00781881f, -0.07962601f, 
    0.04872875f, 0.00347584f, 0.08153111f, -0.05702968f, 0.11201975f, 0.07724876f, 0.06584214f, 0.06863384f, 
    -0.26865366f, 0.57079524f, -0.22988908f, -0.45921221f, 0.01094918f, 0.34547549f, -0.01085798f, 0.04083642f, 
    -0.25893205f, -0.02545760f, 0.23192136f, 0.12235626f, 0.17315057f, 0.26201501f, 0.04964082f, -0.63002312f, 
    0.24173366f, 0.03010372f, 0.27408233f, -0.12960686f, -0.31856343f, 0.03507269f, 0.13024063f, 0.13726586f, 
    0.03708953f, -0.07242382f, 0.27305683f, 0.19767055f, -0.10261842f, 0.05593102f, -0.11907317f, -0.12068818f, 
    -0.12087034f, -0.08874989f, 0.01202833f, 0.15028723f, -0.08914202f, 0.18543071f, -0.00421120f, -0.16652937f, 
    -0.01034068f, 0.10174686f, -0.09713423f, -0.00525761f, 0.05198330f, -0.12482137f, -0.02611651f, -0.16585602f, 
    -0.23783660f, -0.05530836f, 0.07259888f, 0.20522420f, 0.20962422f, 0.10245876f, 0.36036164f, 0.49083668f, 
    -0.00905111f, 0.13247783f, 0.10879275f, 0.16929670f, -0.05522329f, 0.27506748f, 0.15704617f, 0.19760890f, 
    0.03189748f, -0.22657700f, 0.23827556f, -0.46852463f, 0.13100387f, 0.58680344f, -0.10444881f, 0.09825106f, 
    0.02968409f, 0.10236440f, -0.06905118f, 0.05817690f, -0.39161074f, 0.27540407f, -0.08759091f, 0.70576775f, 
    -0.09055988f, 0.10975380f, 0.10811502f, -0.07980137f, -0.36079144f, 0.13220935f, -0.05293599f, 0.22865756f, 
    -0.03792250f, 0.16864243f, -0.19239415f, -0.10596293f, -0.10850659f, 0.00373208f, -0.04211742f, -0.09588835f, 
    0.23053654f, 0.17315245f, 0.11270784f, -0.17881715f, 0.03484908f, 0.00969115f, 0.09429815f, 0.10184105f, 
    -0.00576626f, -0.03342959f, -0.03807768f, 0.14682731f, 0.28950885f, -0.01160087f, -0.16959268f, 0.22030668f, 
    -0.02344104f, 0.21127300f, 0.11369214f, 0.19952126f, -0.03409235f, -0.12447572f, -0.32606253f, 0.06103387f, 
    0.10773349f, -0.31906003f, -0.10384372f, -0.05105333f, -0.10304513f, 0.02806466f, 0.00917694f, -0.16460815f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03034961f, -0.03917917f, 0.38052300f, 0.11121670f, -0.03681075f, -0.23792310f, 0.11216854f, 0.00265153f, 
    0.05712115f, 0.13868520f, -0.09151278f, -0.07966429f, 0.49576533f, 0.10073368f, 0.11069894f, 0.41581544f, 
    0.17209287f, -0.07083890f, -0.00621549f, 0.17280161f, -0.03482572f, 0.23969544f, 0.23848368f, 0.01748055f, 
    -0.02680513f, -0.18655960f, -0.11529817f, 0.03135736f, -0.06235345f, 0.22068542f, -0.16790082f, 0.16241330f, 
    0.13573281f, 0.28734356f, 0.27664727f, -0.00101180f, -0.23995367f, 0.01638357f, 0.13215455f, 0.33293974f, 
    -0.05044518f, 0.29668632f, -0.05104974f, 0.01596971f, 0.28537157f, -0.02329481f, -0.11114773f, 0.10376382f, 
    0.13456467f, 0.10723224f, -0.09663134f, 0.23687337f, 0.40169623f, -0.06376957f, 0.22164090f, 0.23574975f, 
    0.29944497f, 0.22969399f, -0.11228718f, 0.14075914f, 0.23619704f, -0.13528444f, -0.35301089f, -0.06180879f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.12390535f, -0.01842232f, -0.33351153f, -0.03511353f, -0.03485106f, 0.11950910f, -0.12627473f, -0.12112110f, 
    -0.58437794f, -0.40843457f, 0.07303835f, 0.17992856f, -0.61551780f, -0.06509858f, -0.36692247f, -0.04466599f, 
    -0.09249523f, -0.55529684f, 0.11049384f, -0.30284798f, 0.28973171f, -0.30344000f, 0.05122430f, -0.14973618f, 
    -0.01782479f, 0.22612435f, -0.12600870f, 0.01347139f, 0.00960782f, -0.67548448f, -0.31010735f, -0.49963388f, 
    -0.24426235f, -0.32789794f, -0.62395936f, 0.00343355f, -0.23531049f, -0.18029463f, -0.13719985f, -0.34877074f, 
    0.00741164f, 0.04559296f, -0.35658273f, -0.41369295f, -0.60604119f, 0.14867933f, -0.13990733f, -0.21012095f, 
    0.12344337f, -0.29006723f, 0.19192925f, 0.19495945f, -0.40728620f, -0.00375006f, -0.64468181f, 0.20202965f, 
    -0.14676896f, -0.03292001f, -0.00373826f, 0.28137234f, 0.20804468f, -0.07368560f, 0.18225592f, -0.11556605f, 
    -0.08490423f, 0.10026920f, 0.03791124f, 0.06439275f, -0.03186629f, 0.25332013f, -0.28298673f, 0.04540663f, 
    -0.32041067f, 0.16372852f, -0.04775368f, -0.48454499f, 0.23022464f, 0.12423313f, 0.04716785f, 0.19656208f, 
    -0.01594821f, -0.46461868f, -0.10290639f, -0.78592390f, 0.20801491f, 0.27275610f, 0.16127495f, -0.01680647f, 
    -0.02896570f, 0.20489277f, 0.09080737f, -0.09791834f, 0.07596438f, -0.32269794f, -0.19860944f, -0.10162172f, 
    0.15513350f, 0.34530005f, 0.33236569f, -0.42356253f, -0.32786155f, -0.35256305f, 0.10333879f, -0.00405876f, 
    0.09250576f, -0.01306842f, 0.43326399f, -0.17243294f, 0.00846866f, -0.01321361f, -0.04446643f, 0.46868381f, 
    -0.24331485f, 0.28126478f, 0.34700593f, 0.13170490f, 0.08922484f, -0.19896355f, 0.03305523f, 0.22630663f, 
    0.26636410f, 0.09321482f, -0.04887374f, -0.16987510f, 0.17069162f, -0.10356062f, -0.13807470f, -0.25835159f, 
    0.05720254f, -0.08475976f, 0.03109609f, 0.00736958f, -0.00947086f, 0.36433345f, -0.58918446f, -0.13423446f, 
    0.10980171f, 0.23770656f, -0.01633691f, -0.63825947f, 0.32812053f, 0.07790798f, -0.10650700f, -0.38060126f, 
    0.26199853f, -0.46707785f, -0.04235803f, 0.46241832f, -0.52219379f, -0.72831160f, 0.04905733f, -0.31714243f, 
    0.04476564f, -0.64295560f, -0.13605329f, -0.02613315f, -0.18266717f, 0.25566328f, -0.25532606f, -0.11768824f, 
    0.20790106f, 0.11344998f, -0.78787386f, -0.11343550f, 0.21464247f, 0.04444801f, -0.05680081f, 0.25105542f, 
    0.02421295f, -0.03959906f, -0.39325023f, -0.05831186f, 0.23916997f, -0.25331432f, -0.18059956f, -0.28021958f, 
    0.12090674f, -0.05340089f, -0.84152931f, 0.20638965f, -0.11284771f, -0.13631371f, -0.03045811f, 0.12402608f, 
    0.03660874f, 0.10632720f, 0.02091995f, -0.44751108f, -0.49150309f, 0.03770661f, -0.25562236f, -0.00477467f, 
    -0.01243461f, -0.01466582f, 0.09605479f, 0.00650670f, 0.04231853f, -0.97171062f, -0.23738965f, -0.07889916f, 
    -0.07739834f, 0.18749705f, 0.04149947f, -0.04685821f, -0.08420700f, -0.04866156f, 0.24296831f, 0.05966114f, 
    0.10799776f, 0.20868847f, 0.00419629f, 0.17078096f, -0.16282412f, 0.10869504f, 0.05179147f, -0.11156717f, 
    -0.05231614f, -0.11976372f, 0.07015272f, 0.09835204f, 0.00702188f, -0.01882097f, -0.08118390f, -0.34210759f, 
    -1.69345164f, -0.32488936f, -0.21405265f, 0.22452603f, -0.34543866f, 0.09402453f, -0.06945447f, -0.05986687f, 
    -0.01483141f, 0.26112282f, 0.29932621f, -0.61459392f, -0.26222286f, -0.02257520f, -0.03196856f, -0.17620078f, 
    0.16094446f, -0.19761516f, -0.05913216f, 0.20024838f, -0.36617666f, -0.07846107f, -0.25707582f, 0.19590290f, 
    -0.48485765f, -0.97254211f, -0.06411847f, 0.23927316f, 0.02600004f, 0.09220749f, 0.17536372f, -0.07754839f, 
    -0.13431427f, -0.05675702f, -0.00654856f, 0.04421991f, -0.09093302f, 0.00492679f, 0.28569391f, 0.03747884f, 
    0.16930442f, -0.12273002f, -0.06623374f, -0.11067501f, -0.11331089f, 0.01387145f, 0.07920842f, 0.11226428f, 
    0.18620551f, 0.07279988f, -0.04913787f, 0.19631490f, -0.37339923f, -0.36439395f, -0.09128467f, 0.15018621f, 
    -0.00054846f, 0.13296451f, -0.02554832f, -0.04677698f, -0.14822000f, -0.06011303f, 0.06331208f, -0.07709807f, 
    -0.25604513f, 0.04560393f, 0.03593659f, 0.02260878f, -0.18744412f, -0.56525964f, -0.02759033f, -0.34188756f, 
    -0.08114567f, 0.07979323f, -0.32475933f, 0.00855803f, 0.14587143f, 0.10574261f, -0.03557783f, 0.08731487f, 
    0.05948257f, -0.00998003f, 0.09356584f, -0.14069863f, -0.04781734f, 0.15829833f, -0.46259770f, -0.21250454f, 
    -0.24394275f, 0.09449831f, -0.10851501f, 0.05689428f, -0.18889251f, 0.08581202f, 0.02050059f, 0.03015843f, 
    -0.03904490f, 0.06610364f, 0.18587351f, -0.08043744f, -0.10570168f, -0.59531844f, -0.00790293f, 0.07027832f, 
    -0.08283089f, 0.13216884f, -0.09952678f, 0.01170154f, 0.04659650f, -0.04770612f, -0.67411000f, 0.10454834f, 
    0.20220043f, 0.44945598f, -0.06975874f, 0.02815885f, 0.16422980f, -0.01766262f, 0.15455328f, 0.17761709f, 
    -0.08751511f, -0.23050703f, 0.10672193f, -0.09546416f, -0.15224493f, -0.18198706f, 0.10772746f, -0.00166946f, 
    0.32677588f, 0.09195955f, -0.25513774f, -0.32172364f, 0.12382086f, -0.06437165f, -0.00749952f, 0.06599726f, 
    0.04115809f, -0.09872712f, -0.42635241f, 0.15005150f, 0.20310903f, 0.05755467f, -0.03506720f, -0.93366235f, 
    -0.09323992f, -0.54876339f, -0.00442232f, -0.39667055f, -0.02634200f, 0.04447019f, 0.10958833f, -0.08371165f, 
    0.03484349f, -0.08813212f, 0.09700651f, -0.20287547f, 0.05848373f, -0.09150350f, -0.01858415f, -0.28813675f, 
    0.10102534f, 0.11740839f, -0.15538917f, -0.00708754f, -0.05863042f, -0.26985160f, -0.03174503f, 0.10065378f, 
    0.12630671f, -0.27185735f, 0.06622929f, -0.45055267f, 0.19122995f, -0.08621556f, -0.04415973f, -0.72720051f, 
    -0.65990996f, -0.39935997f, -0.11698395f, 0.40813899f, -0.53859818f, 0.15897931f, -0.72308797f, -0.62296963f, 
    0.04605045f, -0.22462282f, 0.01806073f, 0.00922407f, -0.04956573f, 0.32262129f, -0.26416710f, -0.06094710f, 
    -0.56621593f, 0.19130288f, 0.08016080f, 0.08680623f, 0.13500011f, 0.19230600f, -0.60484540f, 0.30810639f, 
    -0.10610158f, -1.52941072f, -0.20101908f, -0.01214486f, 0.23520444f, -0.38829923f, 0.00146772f, 0.23381273f, 
    -0.64049381f, 0.14578189f, -0.21911044f, -0.00451185f, 0.26017365f, -0.05087146f, -0.18718229f, -0.25800458f, 
    -0.11863104f, 0.30145761f, -0.00336021f, -0.87607014f, -0.26022080f, -0.09060543f, -0.13654569f, 0.27101126f, 
    -0.04114073f, -0.00347276f, -0.55632752f, -0.04641429f, 0.04448588f, -0.47404522f, 0.19893804f, -0.12263558f, 
    0.17780435f, -0.38264167f, -0.12221602f, 0.05139860f, -0.52470773f, -0.00839686f, 0.33929354f, 0.10628127f, 
    0.00877309f, 0.51202667f, 0.07919352f, -0.13201140f, 0.10622197f, 0.10432851f, -0.13089536f, -0.10701509f, 
    -0.03028869f, -0.21516162f, -0.07800009f, -0.03276708f, 0.04381302f, -0.34255788f, 0.08630924f, -0.00133479f, 
    0.07976314f, -0.10826097f, 0.17130074f, 0.15695444f, -0.03649094f, 0.09552053f, 0.33308473f, -0.58314645f, 
    0.00536849f, -0.39916313f, -0.17035477f, 0.24641427f, -0.29465613f, -0.01033242f, 0.01252425f, -0.33671203f, 
    -0.17623590f, -0.38550439f, -0.86637300f, -0.15720701f, -0.28336257f, 0.14790756f, -0.29539347f, -0.01763668f, 
    -0.37491259f, -0.10142054f, 0.05459277f, 0.31759357f, -0.38857979f, 0.04393189f, -0.15448961f, 0.12131460f, 
    -0.07248725f, 0.03518606f, 0.25768432f, -0.00980970f, -0.10435843f, -0.38488072f, 0.20035674f, 0.09331517f, 
    -0.62733829f, -0.07055615f, 0.11420534f, 0.23809776f, -0.09385321f, -0.09515891f, -0.08639742f, -0.14943379f, 
    -0.79086864f, -0.08836725f, 0.12376133f, -0.92549044f, 0.74205536f, -0.06791177f, 0.18604195f, -0.10480111f, 
    -0.12418293f, -0.57775801f, -0.11162645f, -0.07811964f, -0.09734306f, -0.15056899f, -0.18115325f, 0.16995075f, 
    -0.34815800f, -0.46554568f, -0.07383034f, -0.32513872f, 0.27241963f, 0.23275423f, 0.58483344f, 0.13219899f, 
    -0.01067075f, -0.00168152f, 0.00991435f, 0.04775926f, -0.70193702f, -0.47198716f, -0.14928372f, -0.09910481f, 
    -0.21140739f, -0.04567997f, -0.18410811f, -0.08394454f, -0.06194242f, -0.39581862f, 0.09073841f, -0.33079025f, 
    0.24010845f, 0.15440382f, 0.04313567f, -0.57994324f, 0.33669621f, -0.00623758f, -0.14721368f, 0.19451752f, 
    -0.07927634f, 0.07385818f, -0.05140293f, -0.08584394f, 0.05446733f, -0.93355960f, 0.30433995f, -0.01402039f, 
    0.18708566f, -0.26495579f, -0.08584915f, -0.01302842f, 0.11644926f, -0.07823489f, -0.15325963f, 0.12093362f, 
    0.02905787f, -0.50091350f, 0.11235459f, 0.28764158f, -1.08439493f, 0.05448048f, -0.23247634f, -0.20653689f, 
    0.03067747f, -0.65487558f, -0.05173337f, 0.04326548f, -0.14429313f, -0.00619997f, 0.03189613f, 0.01852223f, 
    -0.50780940f, 0.20975856f, 0.04254499f, 0.15404114f, -0.25540349f, 0.13470627f, -0.23027994f, -0.06125813f, 
    0.06502093f, -0.14176673f, -0.26475388f, -0.06584063f, 0.35336149f, 0.18765639f, 0.08089451f, -0.59147406f, 
    -0.12318156f, -0.03508632f, -0.64872694f, -0.43853763f, 0.17000023f, 0.27466190f, -0.40089601f, 0.22471987f, 
    -0.07938766f, -0.19405138f, -0.00965827f, 0.22378920f, -0.71001357f, -0.04043435f, -1.05337036f, 0.10853898f, 
    0.08812797f, 0.04958253f, 0.12612653f, 0.03627878f, 0.05506944f, -0.45283815f, 0.21778218f, 0.08437114f, 
    0.04347181f, -0.07684325f, -0.12600751f, 0.33068460f, -0.06063796f, -0.05649978f, 0.08877181f, 0.14760986f, 
    -0.58529723f, -0.34293762f, 0.01404395f, -0.64834696f, -0.19153874f, -0.12266613f, -0.11296339f, 0.30619535f, 
    -0.08434162f, -0.55855960f, -0.05700673f, 0.11989716f, 0.02745851f, 0.00290009f, -0.22311680f, 0.27962464f, 
    -0.53122759f, -0.04322692f, -0.42667863f, -0.37653980f, -0.27877527f, -0.33588803f, -0.97093958f, 0.21332432f, 
    -0.08097620f, -0.01578301f, -0.49132475f, 0.34744766f, -0.05102825f, -0.04012464f, -0.00732062f, -0.41249436f, 
    -0.02247271f, -0.25839746f, 0.01100636f, 0.60179693f, 0.29588109f, -0.23693591f, 0.22660938f, -0.64915770f, 
    -0.11200637f, -0.36085480f, 0.08958521f, -0.39816555f, 0.36096808f, 0.03349576f, 0.41239548f, 0.03505067f, 
    0.05005978f, -0.02656397f, -0.06794971f, -0.05161836f, -0.08475216f, -0.45881107f, -0.67922163f, -0.09595421f, 
    0.19382212f, -0.10073558f, 0.05333173f, 0.49242416f, -0.26503643f, 0.02985912f, 0.14040473f, -0.38672987f, 
    0.15114942f, 0.08359226f, -0.09893943f, 0.01319302f, -0.50915599f, -0.13709494f, 0.06671462f, -0.07893308f, 
    -0.04803437f, -0.43443510f, 0.06444332f, -0.01178204f, 0.02157088f, 0.27411222f, 0.04278195f, 0.11680021f, 
    -0.09750912f, -0.59821892f, 0.02203378f, 0.04129042f, 0.39991495f, 0.00029302f, -0.00996965f, -0.02797675f, 
    0.02708790f, -0.12610561f, 0.41191891f, 0.33157182f, -0.39782387f, -0.32668987f, -0.13422598f, -0.80167013f, 
    0.35562867f, -0.05526909f, -0.04578773f, -0.57407129f, -0.09312418f, -0.48873416f, 0.33727801f, -0.22562170f, 
    0.00148669f, -0.02685280f, 0.00198042f, -0.21711652f, -0.70019078f, -0.13355857f, 0.22453865f, 0.02918926f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.19596748f, 0.15110818f, -0.02055116f, 0.19389887f, -0.01440579f, -0.06894224f, -0.19065683f, -0.08184943f, 
    0.20253427f, 0.32459539f, 0.04383506f, -0.32180044f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
