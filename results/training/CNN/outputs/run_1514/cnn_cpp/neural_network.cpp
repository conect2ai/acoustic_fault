#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.61346614f, -0.54096764f, 0.02756189f, -1.16737652f, -0.94024640f, -0.13714868f, 0.63156545f, -0.01189086f, 
    -0.07482927f, -1.59262681f, -0.43214658f, -0.40742025f, -0.75521684f, -0.10013564f, -0.58145809f, -0.19837064f, 
    -0.51273942f, -0.83383620f, 1.23246753f, -1.31111860f, -0.02352385f, -0.57753247f, -0.71164030f, -0.87617040f, 
    -0.90309882f, 0.83620232f, -1.02498531f, 0.44087535f, 1.41503417f, 0.24757366f, -1.38816786f, 0.16990334f, 
    0.04753877f, -0.20189697f, 0.16333166f, 0.13806647f, -0.07436534f, -0.57777345f, -0.70742422f, -0.57095432f, 
    -0.77335477f, 0.68005222f, -0.16425738f, -1.04077435f, 1.15925241f, -0.90865338f, -1.70709836f, 0.11260917f, 
    1.21764839f, 0.22840254f, -0.36495650f, -0.13029510f, -0.66094905f, -0.24205860f, -0.76036257f, -0.60414487f, 
    -1.25935519f, 0.32200396f, 0.65754634f, 0.96149319f, 0.29361543f, 0.80837619f, 0.49114564f, 0.86395562f, 
    0.10077173f, 0.99183702f, -0.74095809f, -0.31084445f, 0.01663978f, 0.62275678f, 0.74911505f, -0.37663656f, 
    0.78975868f, 0.42901164f, -0.84977019f, -0.89146149f, 0.77700949f, -1.10359037f, 0.07574046f, 0.39899704f, 
    0.34082183f, 0.44710416f, -0.24191098f, -0.92762440f, -0.41834599f, 1.53330028f, -0.84022206f, -0.10209530f, 
    -0.20325182f, -0.19953762f, -1.03996015f, 1.04223871f, 0.09952867f, 0.19251445f, 0.38104665f, 0.78376085f, 
    0.31789234f, -0.14353052f, 1.13559628f, -0.54623729f, -0.20426922f, 0.09661472f, -1.10313177f, -1.13580394f, 
    -1.79196846f, 0.11390176f, 0.89199644f, 0.39333999f, 0.37401453f, -0.06571414f, 0.46423340f, 0.49828658f, 
    0.59380484f, 0.50720751f, 1.06901193f, -0.58411556f, -0.44981807f, 1.40942013f, -0.08442281f, -0.18005438f, 
    0.90986902f, 0.55865979f, 1.04511631f, -0.09921392f, 0.44331059f, -0.18567769f, -1.34713662f, 0.20848581f, 
    0.30585000f, -0.77380663f, -0.38346168f, 0.94374967f, -0.86828816f, 0.29262233f, -0.94225067f, -0.53057528f, 
    -0.49706358f, -1.46601784f, 0.54252750f, 0.16810623f, 0.34111366f, -0.60343438f, -0.64342171f, -0.96657813f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17044733f, -0.30408400f, 0.60078597f, 0.58170563f, 0.59429300f, 0.52221876f, 0.60745728f, 0.86293501f, 
    0.43573081f, 0.52195847f, 0.01710954f, 0.48172241f, 0.64154226f, 1.08249617f, -0.13246761f, 0.57408988f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.09400146f, 0.05773778f, 0.13557725f, -0.00411405f, -0.32475215f, -0.17515241f, 0.04337390f, 0.11512396f, 
    0.07300531f, 0.40795657f, -0.02850983f, 0.06475278f, -0.32495394f, -0.14071466f, -0.07181066f, 0.03231942f, 
    0.04027912f, -0.11267374f, -0.36223254f, -0.23403737f, 0.67304212f, -0.15231723f, 0.10825960f, 0.33851513f, 
    -0.17871985f, 0.00342602f, -0.17684226f, -0.14575538f, 0.36482927f, 0.16761070f, -0.10617300f, -0.36293629f, 
    -0.28489518f, 0.23223129f, 0.15358105f, 0.04790904f, 0.02655925f, 0.58652657f, -0.34995985f, -0.08453753f, 
    -0.30205536f, -0.07650630f, 0.09186351f, 0.21056096f, 0.05918951f, 0.47916803f, -0.58392626f, -0.02021213f, 
    0.04460552f, 0.13491777f, -0.19668338f, -0.27859256f, -0.08773693f, 0.01424138f, 0.14590332f, -0.16647346f, 
    -0.91231763f, 0.23762473f, -0.13192078f, -0.11733711f, 0.16622747f, 0.02911389f, 0.09619861f, 0.04509819f, 
    0.19322568f, 0.48653620f, -0.16734754f, 0.11583398f, 0.13678783f, 0.10194919f, 0.38606560f, 0.09999590f, 
    -0.33888382f, -0.08535106f, 0.46162021f, 0.33780298f, -0.06530381f, 0.43129003f, 0.09474736f, 0.07533833f, 
    0.47454351f, -0.19194384f, -0.32224512f, 0.76244140f, 0.15037119f, 0.12516312f, 0.00134109f, -0.20578910f, 
    0.01559911f, -0.52855039f, 0.23827456f, 0.51782173f, -0.37875560f, 0.27394253f, 0.02695629f, 0.03773268f, 
    -0.10365009f, 0.27320966f, 0.10732882f, -0.40201786f, -0.41995192f, 0.70877910f, -0.03972187f, 0.01184271f, 
    -0.03034743f, 0.09152336f, 0.08188885f, 0.31014812f, 0.13687424f, 0.04676747f, 0.42118725f, -0.06167017f, 
    -0.10833967f, -0.01175673f, -0.20556119f, 0.07477381f, 0.12654662f, 0.40917054f, -0.31620288f, 0.10435305f, 
    -0.07897961f, -0.16392353f, 0.13596818f, -0.22237030f, -0.10355021f, -0.05063808f, -0.43968675f, 0.65265936f, 
    -0.74708807f, 0.08128790f, -0.24535288f, -0.16056626f, -0.01371996f, 0.06238057f, 0.42105645f, 0.11469167f, 
    -0.02938722f, -0.93126893f, -0.05049654f, 0.05518129f, -0.03288976f, -0.18664724f, -0.02106403f, -0.00838680f, 
    0.59977919f, 0.25732240f, 0.02927650f, -0.01905326f, -0.37471455f, -0.30820069f, 0.09318063f, 0.04791900f, 
    -0.05352717f, 0.37136984f, 0.19038019f, -0.11152384f, 0.07883679f, 0.11606582f, 0.22909614f, -0.04934214f, 
    -0.04015457f, 0.14107113f, -0.29401439f, 0.25413600f, 0.24558212f, -0.15538844f, -0.09920910f, 0.14627101f, 
    -0.16743284f, -0.07130276f, 0.22080804f, -0.49148980f, -0.56762224f, 0.75760013f, -0.22297730f, -0.00874563f, 
    -0.25638831f, 0.13619563f, 0.29175860f, 0.12862948f, 0.10823550f, 0.12091050f, -0.01276777f, -0.11013316f, 
    -0.08232976f, -0.20122483f, 0.10920528f, -0.16766202f, 0.04705900f, -0.12530249f, 0.20967349f, -0.79074472f, 
    0.29707646f, -0.02984850f, 0.27274930f, -0.20105465f, -0.11032060f, 0.03949151f, -0.51066649f, -0.44918475f, 
    -0.40588778f, 0.04952757f, 0.21866903f, 0.08116032f, -0.16019945f, 0.06153876f, 0.02967247f, -0.13551097f, 
    -0.12792800f, 0.08161242f, 0.00490140f, 0.09893469f, -0.20480004f, 0.13264912f, 0.14653470f, 0.20554294f, 
    -0.22575012f, 0.70558178f, 0.23695758f, 0.09877063f, -0.09509400f, 0.04109709f, -0.08181638f, 0.06462070f, 
    -0.06274698f, 0.32738549f, -0.06311321f, -0.50292051f, -0.06605434f, -0.01491055f, -0.21490325f, 0.05544079f, 
    0.02156110f, -0.12291621f, 0.39110827f, 0.05826136f, 0.16676791f, -0.16170707f, -0.30297926f, 0.10459522f, 
    0.10229990f, 0.28275099f, -0.08111805f, 0.26728985f, 0.23991820f, -0.36813307f, -0.06593443f, -0.13025248f, 
    0.01912980f, 0.01370375f, 0.02550372f, 0.04266071f, -0.16791925f, 0.51063734f, -0.20643638f, -0.16834404f, 
    -0.07888727f, -0.20025361f, 0.03897483f, -0.01378942f, 0.16917758f, -0.18855235f, -0.58064890f, -0.00189964f, 
    -0.03445227f, -0.13015543f, -0.16548073f, 0.04129630f, 0.05045056f, -0.06874309f, 0.25351828f, 0.11988480f, 
    0.22072007f, -0.05991929f, 0.13748254f, 0.17748562f, -0.19506125f, 0.25427639f, -0.07754428f, 0.28335065f, 
    -0.21281336f, -0.19081944f, 0.07694089f, 0.25704351f, -0.04063855f, 0.04651458f, -0.08256084f, -0.04096733f, 
    -0.67774481f, 0.34094167f, 0.02260028f, 0.33461717f, 0.17658910f, -0.16384183f, -0.08160435f, 0.06647646f, 
    -0.12621458f, -0.71087277f, -0.15361728f, -0.10650779f, -0.02876979f, 0.10084081f, 0.00293896f, -0.14596125f, 
    -0.05361927f, 0.11759838f, -0.37526214f, -0.79506463f, -0.45394492f, -0.11092980f, 0.08075407f, 0.36217257f, 
    0.05271580f, 0.12533467f, 0.14328702f, 0.46933603f, -0.14445601f, -0.39719227f, 0.14797033f, 0.00267647f, 
    0.10944766f, 0.20039859f, 0.12659431f, -0.01242154f, -0.02044347f, 0.40875256f, 0.01642045f, -0.16060348f, 
    0.15811561f, -0.39465111f, 0.16808765f, 0.09758087f, -0.25296023f, -0.48037550f, 0.45543626f, 0.65246004f, 
    -0.16170424f, -0.03250040f, -0.21241401f, 0.01474419f, 0.24521001f, 0.42850998f, -0.28110138f, 0.58508873f, 
    0.51750958f, -0.07325093f, 0.06620194f, 0.12334736f, 0.13866305f, -0.09906222f, -0.15741038f, 0.49759701f, 
    -0.04398618f, -0.06844731f, -0.01531165f, 0.03953794f, -0.23837349f, 0.02370578f, -0.06007975f, -0.25229442f, 
    0.74197882f, 0.22319128f, -0.48763308f, 0.08688143f, 0.04744334f, 0.17485780f, -0.17305426f, -0.17851970f, 
    -0.49727792f, -0.37075591f, -0.29053983f, 0.01114073f, -0.02353899f, 0.06709113f, 0.27047324f, 0.27623865f, 
    -0.18633638f, 0.20173322f, -0.40470561f, 0.03579611f, 0.12665753f, 0.05054721f, -0.05431334f, 0.08523025f, 
    -0.14081952f, -0.18726984f, -0.46943724f, -0.22926514f, -0.09818958f, -0.85665864f, -0.28329435f, -0.13139984f, 
    -0.54208821f, -0.21552895f, -0.22739103f, -0.09543272f, 0.10943973f, 0.24754618f, 0.32002851f, 0.09947290f, 
    0.04600929f, -0.04108893f, 0.15493424f, 0.20191629f, 0.31984103f, 0.08031750f, 0.08553317f, 0.06316175f, 
    0.02189078f, -0.08322513f, 0.07355277f, 0.18561432f, 0.10219610f, 0.04163502f, -0.09168727f, -0.05946969f, 
    -0.18078920f, -0.15495482f, -0.22142476f, 0.28545716f, -0.04670586f, 0.06874470f, 0.08500071f, -0.03109527f, 
    0.30794272f, 0.06267871f, 0.15987049f, -0.03802923f, 0.00445587f, 0.13882704f, 0.46843123f, 0.51514715f, 
    0.64564902f, 0.36458182f, -0.37056991f, -0.14318284f, -0.18550284f, -0.29051813f, -0.03211239f, 0.02634591f, 
    0.06456137f, 0.45451042f, -0.04420376f, -0.14379944f, -0.00825024f, 0.03139625f, -0.01962473f, 0.07159987f, 
    0.02904038f, -0.26695973f, -0.01474260f, 0.11917538f, 0.33969855f, -0.06591167f, 0.01862261f, -0.14537035f, 
    -0.09174623f, -0.20134413f, 0.01918969f, -0.70240271f, 0.01943739f, 0.06364753f, -0.08909549f, 0.07986334f, 
    0.02583362f, -0.10359003f, 0.15005776f, -0.03442340f, -0.11471301f, -0.16619891f, 0.22749110f, -0.00050268f, 
    0.04234846f, -0.35999042f, -0.03576501f, -0.16292031f, 0.23904368f, 0.28698528f, -0.15354304f, 0.36753052f, 
    -0.06330618f, 0.13378832f, -0.25824219f, -0.17836399f, 0.16395107f, 0.16268046f, 0.42646590f, 0.35344726f, 
    0.43155542f, -0.12765136f, -0.11360940f, 0.00679054f, -0.07464770f, 0.03388815f, 0.05892219f, -0.13464765f, 
    -0.33030313f, 0.34127203f, 0.16572873f, 0.01105445f, 0.12104681f, -0.05265567f, -0.07373410f, 0.22885372f, 
    -0.61442399f, -0.38808110f, 0.30978474f, 0.03494641f, 0.02466963f, 0.05135931f, -0.16567127f, -0.03918961f, 
    -0.10259143f, -0.32219622f, 0.23232645f, 0.75195307f, 0.03481952f, -0.08044077f, -0.19665486f, 0.07081068f, 
    0.02381851f, -0.16614628f, 0.42519993f, -0.11743148f, 0.04774075f, -0.38910320f, -0.25532824f, -0.13820544f, 
    0.05347151f, 0.36139202f, -0.04848430f, -0.05641377f, 0.12150001f, 0.16390134f, -0.16426419f, 0.01310800f, 
    -0.10980813f, -0.03008404f, -0.10083714f, -0.02010013f, -0.05696572f, -0.16712044f, 0.19233914f, -0.31456393f, 
    -0.19866002f, -0.19259076f, 0.20611849f, -0.04485638f, -0.03119876f, 0.29878294f, 0.12332741f, -0.06230715f, 
    -0.27091601f, -0.43786436f, -0.57760763f, -0.02797613f, 0.09899323f, 0.10552237f, 0.00446031f, -0.10894093f, 
    -0.07284988f, -0.02189568f, 0.00378506f, -0.14125802f, -0.07654018f, 0.02017187f, 0.22656177f, 0.01778272f, 
    -0.13484836f, 0.44765612f, 0.01548396f, -0.04340707f, 0.08228020f, 0.27593786f, 0.22705719f, 0.07061426f, 
    0.13496789f, 0.54517466f, 0.17944257f, -0.26977959f, -0.00182232f, -0.25361231f, 0.04015287f, -0.05515753f, 
    -0.01736850f, 0.59243512f, 0.29330283f, 0.13719533f, -0.03373527f, -0.04460664f, 0.16145687f, 0.18818384f, 
    -0.05762363f, -0.22846270f, -0.76832932f, 0.05683564f, 0.01309438f, -0.28361520f, 0.11855239f, 0.08812719f, 
    0.13088556f, 0.04875987f, 0.06838229f, 0.22353923f, -0.81904286f, 0.02079454f, 0.12559132f, -0.03850222f, 
    -0.14041841f, 0.08643634f, 0.14506844f, 0.14053552f, 0.11559326f, 0.51262540f, 0.08047688f, -0.17631076f, 
    0.18894809f, -0.15938991f, 0.12018633f, 0.02751766f, -0.05678652f, 0.51098812f, -0.16171975f, -0.21772724f, 
    0.02680963f, -0.16311836f, 0.16744360f, -0.03520683f, 0.16884597f, 0.06081755f, 0.05528475f, 0.01829864f, 
    0.00083813f, -0.13612224f, -0.12634461f, -0.03014555f, -0.00468381f, 0.11532744f, 0.18673563f, -0.28709769f, 
    -0.45906237f, 0.41495726f, 0.24460904f, 0.04245128f, -0.16999428f, 0.11485449f, -0.10194102f, -0.09789265f, 
    0.01063014f, -0.13427408f, -1.12855899f, -0.17320469f, 0.08508588f, 0.32390937f, -0.02614245f, 0.02097793f, 
    -0.20837831f, -0.57941651f, -0.07707796f, -0.77353376f, -0.06707106f, 0.06398327f, 0.01563655f, 0.23396674f, 
    0.16665214f, 0.00966891f, 0.47129285f, -0.27593488f, 0.22169067f, -0.38104740f, -0.03201802f, -0.29593042f, 
    -0.06845092f, -0.01082812f, -0.08572233f, 0.51011264f, 0.13483444f, 0.30645823f, -0.15447119f, 0.04154050f, 
    -0.08511821f, -0.02011630f, -0.20785910f, -0.06016673f, -0.06077127f, 0.34030241f, 0.17912179f, -0.20342633f, 
    -0.31249154f, -0.29053533f, 0.24301147f, 0.03123595f, -0.14215308f, 0.19841142f, 0.47697574f, -0.37533668f, 
    -0.21607020f, -0.18000540f, -0.13667165f, 0.17447311f, 0.16916156f, 0.06279375f, -0.03065970f, -0.31920111f, 
    0.39009362f, -0.14060467f, 0.23878373f, -0.33809188f, -0.11256087f, 0.11045641f, 0.11604314f, 0.32632640f, 
    -0.08431059f, 0.10592689f, -0.16108049f, 0.21519630f, 0.12377557f, -0.04604939f, 0.00626793f, 0.04407977f, 
    0.07811812f, -0.03321358f, 0.03657567f, 0.04230890f, -0.02345555f, -0.06049631f, 0.03132959f, 0.04916683f, 
    -0.07502303f, 0.00016772f, -0.04589030f, 0.03823352f, 0.02434890f, -0.02406459f, -0.01559432f, 0.06734296f, 
    -0.00891947f, 0.03973555f, -0.03175799f, 0.04813036f, -0.00671965f, -0.02416730f, 0.07533285f, 0.01233863f, 
    0.03679857f, 0.03770307f, -0.03243333f, -0.07373317f, -0.00147841f, 0.08162456f, 0.01183759f, 0.05807505f, 
    0.03841321f, -0.05148311f, 0.02624816f, 0.00043125f, 0.05494860f, -0.02321617f, 0.01845571f, -0.05197126f, 
    -0.03042413f, 0.05009517f, 0.06476843f, -0.01097127f, 0.02091166f, 0.05978104f, -0.06810603f, -0.05814036f, 
    -0.01424977f, -0.07982102f, -0.00143459f, -0.04869972f, -0.03083271f, -0.02333956f, 0.07987981f, -0.05973275f, 
    -0.05334282f, -0.04704168f, 0.00405731f, -0.07226634f, -0.02446751f, 0.01899195f, -0.04331020f, -0.03095567f, 
    -0.04386947f, 0.00434732f, 0.05475704f, -0.05948627f, -0.08115514f, -0.02364092f, -0.08289197f, 0.02355992f, 
    -0.06579396f, -0.07382882f, -0.05330551f, -0.00552759f, 0.07157263f, -0.06661123f, 0.02389498f, 0.04429847f, 
    -0.01493095f, 0.05217001f, 0.01183494f, -0.07042423f, -0.07065465f, -0.07941732f, -0.08133029f, 0.01118740f, 
    0.02903173f, 0.02570826f, 0.06235619f, -0.06715899f, -0.04344212f, -0.04745644f, 0.06315178f, 0.00810281f, 
    -0.00245827f, -0.04860113f, 0.03856701f, 0.03000268f, -0.04436792f, -0.05975258f, -0.02023870f, 0.06743872f, 
    -0.06428824f, -0.06391387f, 0.05485117f, 0.02195065f, -0.04197577f, -0.04446536f, -0.01727145f, -0.05308308f, 
    0.01085155f, -0.01721256f, 0.00036250f, -0.05686368f, 0.02848738f, -0.05254287f, 0.05808736f, 0.01483415f, 
    -0.02670557f, -0.06139371f, -0.00820462f, -0.05535150f, -0.00069432f, -0.06550800f, -0.02001515f, -0.02863248f, 
    0.00761593f, -0.03780368f, 0.04507845f, 0.06757605f, -0.04913350f, -0.07462531f, -0.04688717f, -0.06296702f, 
    -0.00809023f, 0.03998731f, -0.05340850f, 0.03347419f, -0.02233621f, -0.02763712f, -0.06882064f, -0.06249975f, 
    0.27867857f, -0.30800840f, 0.10585263f, 0.20134626f, -0.08989076f, 0.10694723f, 0.09785623f, 0.01300456f, 
    0.00814193f, -0.58589852f, -0.05073171f, 0.23452094f, 0.04521752f, -0.04600909f, 0.02535281f, 0.02659310f, 
    0.28619477f, 0.18934086f, 0.20889115f, 0.23050055f, 0.37497354f, 0.20791608f, 0.29483080f, -0.05188068f, 
    0.19559039f, -0.12714428f, -0.04760056f, 0.10625081f, -0.47598296f, -0.77828062f, 0.07575287f, -0.02598003f, 
    0.05771575f, -0.12911591f, 0.07242256f, -0.07356684f, 0.21677332f, -0.21952800f, -0.26037341f, 0.26415381f, 
    0.00392381f, -0.01018839f, -0.10444111f, -0.04797775f, -0.09680009f, -0.73346007f, 0.35014668f, -0.09328119f, 
    0.11445954f, 0.06749245f, 0.04025080f, -0.01904817f, -0.19651046f, 0.11789960f, -0.07776893f, 0.09892013f, 
    0.14510831f, 0.10047495f, 0.12645198f, -0.02582474f, 0.19778037f, 0.02652516f, 0.25431588f, 0.16244569f, 
    -0.27513680f, -0.81232792f, 0.12389031f, -0.12124875f, -0.11279774f, 0.04459269f, 0.01514760f, -0.00305958f, 
    0.04768365f, 0.10754774f, 0.09902362f, -0.29994830f, 0.02273209f, -0.02140888f, -0.16124743f, 0.02021444f, 
    0.01366238f, -0.08088993f, 0.50445741f, 0.17735632f, -0.18823092f, 0.06287408f, 0.06486045f, -0.04333222f, 
    0.10844604f, -0.12458534f, 0.24899885f, -0.00564980f, -0.22207178f, -0.14836812f, 0.15031147f, -0.28890714f, 
    -0.07111003f, 0.15252931f, -0.02384244f, 0.25923392f, -0.04014401f, 0.60840952f, -0.06763819f, -0.10509163f, 
    -0.05932665f, -0.18307959f, -0.08641841f, -0.18202217f, 0.09917310f, -0.16719843f, -0.51987082f, 0.36254668f, 
    -0.04208669f, -0.03943863f, 0.00059879f, -0.15267052f, 0.17305963f, -0.23207402f, -0.42515111f, -0.52464628f, 
    0.16104691f, -0.04553126f, -0.12423712f, 0.09457263f, 0.17778581f, 0.16014338f, -0.18024352f, -0.00531742f, 
    -0.10224274f, -0.00111019f, 0.08747181f, -0.04256362f, 0.15559992f, 0.16040139f, -0.17236805f, -0.09386272f, 
    0.18070990f, -0.04673096f, 0.02290714f, 0.00818222f, 0.00095597f, 0.03875511f, 0.06570715f, -0.00505022f, 
    -0.14590062f, 0.40218577f, 0.34684569f, -0.32724249f, -0.22085990f, -0.17411081f, -0.05568914f, 0.11486909f, 
    0.05171547f, -0.27393609f, 0.03074194f, -0.03544129f, -0.02162689f, 0.17696026f, 0.05328677f, 0.09630119f, 
    0.15390529f, 0.04281815f, 0.29323339f, 0.24467875f, 0.50384301f, 0.09041013f, -0.10447551f, 0.12922485f, 
    -0.04461360f, -0.07580397f, 0.07368423f, 0.25884506f, -0.98250538f, -0.30872545f, -0.13045399f, -0.04172486f, 
    0.10973439f, 0.11266328f, 0.22263280f, 0.02829543f, 0.00776029f, 0.25355238f, 0.60121173f, -0.06851422f, 
    -0.24857856f, -0.15482350f, -0.04022384f, -0.31504753f, 0.01843246f, 0.11119212f, -0.55499756f, -0.56293023f, 
    0.04745967f, 0.18976805f, -0.21345332f, 0.06567084f, -0.17280087f, -0.18075377f, 0.27853671f, -0.28012577f, 
    -0.01238944f, -0.07081777f, 0.03220192f, -0.23126562f, 0.08224257f, 0.12557694f, 0.03394730f, -0.29899657f, 
    -0.24986014f, 0.23272164f, -0.02956014f, 0.16601367f, 0.11749879f, -0.13396086f, 0.20696375f, 0.24862237f, 
    -0.64645338f, -0.20105264f, 0.32501453f, 0.06618606f, 0.20780075f, -0.04940543f, 0.02028436f, 0.07323782f, 
    0.04429071f, -0.30812564f, 0.08614748f, 0.65164280f, -0.03303222f, -0.13040657f, -0.40084425f, -0.02325197f, 
    0.06320624f, 0.00412822f, 0.08759759f, -0.12267046f, 0.19392291f, -0.09599003f, 0.13754827f, -0.04566622f, 
    0.10932440f, -0.19794336f, 0.03000878f, 0.07403377f, 0.44011128f, 0.54813868f, 0.06733767f, 0.02052372f, 
    -0.16268632f, -0.03870406f, -0.02171516f, 0.21457669f, -0.12012915f, -0.07565797f, 0.27246812f, -0.19208175f, 
    -0.26952252f, -0.23183104f, 0.02296205f, -0.22178051f, -0.04824808f, 0.07709091f, -0.09831625f, 0.26900914f, 
    -0.12973176f, -0.24055277f, -0.39802235f, 0.16962898f, 0.06458646f, -0.08982082f, -0.57153559f, 0.05636634f, 
    0.34254161f, -0.12201864f, 0.03135813f, -0.01177861f, 0.11172778f, 0.10242739f, 0.03126024f, -0.01594564f, 
    -0.04650407f, -0.43839824f, -0.00946580f, 0.12044996f, 0.06601984f, 0.17229238f, -0.08527958f, -0.30105159f, 
    -0.60114753f, -0.00599366f, -0.04612524f, -0.23563445f, -0.02784950f, -0.10853394f, 0.07630635f, -0.04443738f, 
    0.00592425f, -0.22179368f, -0.24106584f, 0.05839585f, -0.14387324f, -0.22415660f, -0.42743739f, -0.14947423f, 
    -0.16016893f, -0.12433922f, 0.01663918f, -0.70728427f, 0.06096051f, 0.19868681f, 0.41305935f, 0.00707037f, 
    0.14525135f, -0.05140989f, 0.16639435f, -0.32946783f, -0.32341585f, -0.19483484f, -0.01390076f, 0.27336240f, 
    0.01896238f, 0.21982354f, 0.38802937f, 0.09272482f, 0.16592026f, 0.08521977f, 0.12926459f, 0.16874057f, 
    0.07220867f, 0.12437736f, 0.10798579f, 0.08391754f, 0.12808463f, 0.13731988f, -0.20777003f, -0.44847444f, 
    0.03114005f, -0.08818726f, 0.10640626f, 0.17831962f, -0.10043664f, -0.02262581f, 0.23711725f, 0.31106219f, 
    -0.58522993f, 0.13459989f, -0.12570719f, 0.14494103f, 0.16715139f, 0.02078314f, 0.18749090f, -0.07049229f, 
    -0.28004044f, 0.19733499f, 0.30712819f, 0.03437073f, -0.15898108f, -0.00408319f, 0.37894684f, 0.17997436f, 
    0.31460050f, 0.37090763f, 0.52478105f, -0.20650299f, 0.10893361f, -0.21091437f, 0.29198080f, -0.17476894f, 
    0.09191370f, -0.48676315f, 0.61486071f, 0.34668475f, 0.28889540f, 0.13060927f, 0.46368626f, 0.05607867f, 
    0.42934105f, 0.24078256f, 0.30811286f, 0.10738856f, -0.25851041f, -0.59062570f, -0.28694671f, 0.01232521f, 
    0.17557101f, 0.15799925f, 0.09096686f, -0.48135805f, -0.52191538f, -0.00749694f, -0.16176364f, 0.14861874f, 
    0.03799609f, 0.10502190f, -0.08955529f, 0.24815731f, 0.29104209f, 0.21040864f, 0.02677793f, 0.00673066f, 
    -0.14892808f, -0.34366977f, 0.11589175f, 0.18143958f, -0.03962171f, 0.18206437f, 0.13729265f, -0.49613497f, 
    -0.16619602f, -0.12418952f, -0.02450215f, 0.08620941f, 0.03105708f, 0.18287624f, -0.28581703f, -0.51126653f, 
    0.06852044f, 0.03109660f, 0.12583844f, 0.13782154f, 0.05784598f, -0.14373718f, 0.03558964f, -0.11024038f, 
    -0.42050755f, -0.37399700f, -0.13286957f, -0.21030866f, 0.08817313f, 0.03086148f, 0.03701480f, 0.05860173f, 
    0.05381230f, -0.08329752f, 0.04975152f, 0.01399870f, -0.05562305f, 0.07413223f, -0.07067420f, 0.02339989f, 
    0.01053168f, -0.03451217f, -0.03805798f, 0.03362972f, -0.07442257f, -0.07679036f, 0.02990798f, -0.00401835f, 
    -0.02888092f, -0.07684436f, -0.07566746f, 0.01694515f, -0.00324812f, -0.01314722f, 0.01591187f, -0.01688775f, 
    0.01387609f, -0.04263462f, 0.07526534f, 0.03610845f, -0.02254349f, -0.02514844f, 0.08035184f, 0.05303814f, 
    0.08162239f, -0.06448931f, 0.06436808f, 0.03364393f, -0.08053773f, 0.06544289f, 0.00956300f, 0.01596062f, 
    -0.05202126f, 0.01927730f, -0.05780996f, -0.03736213f, 0.04405048f, -0.00321834f, -0.05223941f, -0.00051994f, 
    0.03980140f, -0.00130383f, -0.02393275f, -0.00083050f, -0.02142712f, -0.03145059f, -0.07178682f, 0.01310977f, 
    -0.02806164f, -0.00855142f, 0.06791791f, -0.01386704f, 0.02852917f, 0.01732290f, 0.01888794f, 0.04670001f, 
    -0.06537448f, -0.05934858f, -0.02178980f, -0.08304396f, -0.05893345f, -0.01280308f, -0.03171962f, -0.05399072f, 
    -0.02012207f, -0.04186098f, 0.03992643f, -0.04864245f, 0.07200210f, 0.04775906f, -0.07011567f, 0.01963386f, 
    0.05274861f, 0.01203433f, 0.00081204f, 0.01133319f, -0.07869234f, -0.04545160f, 0.05348701f, 0.07600652f, 
    -0.00119424f, -0.00876864f, 0.05265475f, 0.03059972f, 0.03378906f, -0.05143648f, -0.01789409f, 0.03231883f, 
    -0.00378627f, -0.00555755f, -0.02773352f, -0.08228956f, -0.04520752f, 0.01674016f, 0.03861919f, -0.06012672f, 
    -0.03375689f, -0.04627182f, -0.02694754f, 0.03906078f, 0.06935564f, -0.02563386f, -0.02254510f, 0.06326960f, 
    -0.03034922f, -0.06909022f, -0.03489418f, -0.07404008f, -0.08274312f, -0.03165891f, 0.01323992f, -0.03778654f, 
    0.01528381f, 0.01448277f, 0.00368129f, 0.01449033f, -0.04744981f, -0.04699103f, 0.06770138f, -0.06303589f, 
    -0.08127522f, 0.03458949f, 0.02294752f, -0.06320263f, -0.07977150f, 0.02714982f, -0.00814478f, 0.07200296f, 
    -0.04850142f, 0.06036573f, 0.06407701f, 0.01152620f, -0.05941946f, -0.04974821f, -0.06834935f, -0.05786170f, 
    -0.14157286f, 0.44440618f, 0.15301166f, -0.42056543f, -0.10614409f, -0.34548399f, 0.03057683f, 0.18950957f, 
    0.04180262f, 0.33834007f, 0.17751367f, 0.67441839f, 0.09887917f, 0.00672059f, -0.00175657f, 0.17068988f, 
    -0.24454357f, 0.09800382f, 0.25818381f, 0.00371811f, -0.14917763f, -0.07861550f, -0.07080633f, -0.27328798f, 
    -0.02686173f, -0.15899174f, 0.02489012f, -0.06069057f, -0.66662371f, -1.16109657f, 0.03462449f, 0.10417475f, 
    -0.28591070f, -0.07638033f, 0.12095161f, 0.06476382f, 0.07138763f, 0.33247834f, 0.23952231f, -0.06704189f, 
    0.18133618f, -0.02075789f, 0.15876266f, 0.04161752f, 0.00398189f, 0.57299966f, -0.39199063f, 0.23679915f, 
    0.00044177f, -0.14204015f, 0.30454469f, 0.22926791f, -0.00751837f, 0.26619780f, -0.05055041f, -0.52062130f, 
    -0.37807274f, 0.13872121f, 0.20239267f, 0.40268487f, -0.05019712f, -0.03642226f, 0.22555235f, -0.17626204f, 
    -0.10991108f, -0.04374908f, -0.09091891f, 0.12019819f, -0.13347250f, -0.08540088f, -0.12864171f, -0.02713929f, 
    -0.14691779f, -0.47973225f, -0.49185091f, -0.47339180f, -0.06314217f, -0.24313343f, 0.12216666f, 0.05810288f, 
    -0.14814600f, -0.06942306f, -0.75083017f, -0.42848030f, -0.33808702f, -0.10625712f, 0.10382656f, -0.00286587f, 
    0.28833330f, 0.07360197f, -0.61359948f, -0.08294907f, -0.46247065f, 0.18590581f, 0.00951501f, 0.13486654f, 
    0.21886195f, 0.14578037f, 0.35297647f, 0.29200715f, 0.28970990f, 0.43306029f, -0.45687544f, -0.00047999f, 
    -0.08543497f, -0.20811114f, -0.03149380f, 0.19235411f, -0.62472552f, -0.72275156f, -0.58541816f, 0.00870029f, 
    -0.14325561f, -0.20190902f, -0.05996810f, -0.03165305f, -0.00587060f, 1.54253078f, -0.57627881f, 0.04169863f, 
    -0.09020128f, -0.28673893f, -0.12536344f, 0.07981221f, 0.13921048f, 0.15772463f, -0.63704264f, 0.01470853f, 
    0.38532364f, 0.12416964f, 0.03644184f, -0.12180163f, -0.01514031f, 0.12467641f, -0.04720399f, 0.07663478f, 
    0.18569946f, 0.23570877f, 0.07615691f, 0.04652090f, 0.19231230f, 0.35270035f, -0.05642771f, -0.18872109f, 
    0.14768279f, -0.53984159f, 0.21452788f, -0.18909095f, -0.01012048f, 0.13987646f, 0.10302375f, -0.13459936f, 
    -0.14630276f, 0.56531650f, -0.08274521f, -0.46672356f, -0.07411715f, -0.17806107f, 0.24726611f, -0.06651695f, 
    -0.05915914f, -0.00279559f, 0.55967247f, -0.08006907f, 0.28240156f, 0.10699499f, 0.06953356f, 0.10490282f, 
    0.03378956f, 0.22529370f, -0.01928743f, 0.09550673f, 0.52806461f, 0.39575291f, -0.31360570f, 0.13495407f, 
    -0.10822020f, 0.02816954f, -0.10243684f, -0.06000735f, -0.03755023f, -0.68686998f, -0.39955729f, 0.11651406f, 
    0.08307605f, 0.04932971f, -0.21879983f, -0.19932042f, 0.19845073f, 0.13894019f, -0.13591358f, -0.96527034f, 
    -0.13780354f, -0.04703703f, 0.23178715f, 0.10863001f, -0.06367563f, -0.10830202f, 0.29643485f, -0.65514594f, 
    -0.44334531f, -0.14664860f, 0.21246520f, 0.28389826f, 0.20076875f, -0.11952589f, -0.15106829f, 0.12823467f, 
    0.48809087f, 0.01676158f, -0.07576001f, 0.04211332f, 0.11421812f, 0.09237423f, 0.09404149f, -0.28927085f, 
    -0.64163715f, -0.15779875f, -0.01460398f, 0.11450776f, 0.20017686f, 0.02313951f, 0.22649586f, -0.13679257f, 
    -0.00065011f, -0.20324133f, -0.31473118f, 0.12308474f, 0.08295348f, 0.20642179f, -0.06763355f, 0.04126348f, 
    0.04538193f, 0.04696546f, 0.19395965f, -0.26944602f, -0.18364751f, -0.00454692f, 0.04574813f, -0.10968863f, 
    0.04251987f, -0.30293536f, -0.17106004f, -0.15173934f, -0.29038629f, 0.30813181f, -0.04968152f, -0.09838789f, 
    0.17181666f, -0.08419856f, 0.11259983f, 0.08619282f, -0.20367678f, 0.40701792f, -0.21977110f, -0.14214803f, 
    0.17786261f, -0.26227042f, 0.14529447f, -0.00342223f, -0.10369084f, -0.41262281f, 0.07312664f, 0.29325250f, 
    -0.02444976f, 0.12267270f, 0.05425803f, 0.19249417f, 0.03540253f, 0.01739089f, 0.15693803f, -0.20835888f, 
    -0.21984276f, 0.10148200f, 0.13696541f, -0.01053566f, 0.22138530f, -0.01018432f, 0.05747004f, 0.38962311f, 
    -0.54147887f, -0.26381651f, 0.02117425f, 0.00556766f, 0.16289321f, 0.03904491f, 0.02719911f, 0.07253967f, 
    0.03080005f, 0.06840492f, 0.00659334f, 0.06037876f, 0.01445729f, -0.01503553f, 0.02748017f, -0.01281255f, 
    0.03040754f, 0.04082903f, -0.04270364f, -0.07842660f, 0.00837974f, 0.03763689f, -0.07753962f, -0.02319186f, 
    -0.06925762f, -0.06821755f, -0.07824023f, -0.06744961f, -0.08391641f, -0.06871850f, -0.08761792f, 0.05782257f, 
    -0.05523426f, 0.05627695f, 0.05775220f, -0.05191420f, 0.03170391f, 0.07451900f, -0.06190066f, -0.04544201f, 
    0.06275313f, 0.00353524f, -0.06154139f, -0.06486674f, 0.02343042f, -0.00830333f, 0.01888051f, 0.04352279f, 
    -0.00968351f, 0.02726321f, 0.00591560f, 0.01018849f, 0.01473776f, -0.03088427f, -0.05179797f, 0.04076179f, 
    0.01798390f, -0.00704824f, 0.01913205f, 0.03484488f, -0.06858593f, -0.08144812f, -0.08144403f, 0.00609895f, 
    0.01907367f, 0.03681462f, -0.04313238f, -0.09005795f, -0.06134311f, 0.07353973f, 0.00790015f, -0.07459028f, 
    -0.08309279f, -0.05609524f, 0.02209030f, -0.00771264f, -0.03374853f, 0.01915946f, 0.02849691f, -0.04826292f, 
    -0.00374419f, -0.02283412f, 0.02871622f, 0.04601712f, 0.04106362f, -0.04123652f, -0.00313154f, 0.05568644f, 
    -0.04249710f, -0.04545674f, -0.07835907f, -0.03836932f, -0.00247793f, -0.06084172f, -0.08736365f, 0.03383169f, 
    -0.02673733f, -0.00636528f, 0.00755978f, 0.04487514f, -0.07130870f, 0.06164574f, -0.00501704f, -0.03040033f, 
    -0.01287484f, 0.00838853f, -0.08801429f, -0.06370842f, -0.05927854f, -0.08452490f, -0.01682838f, 0.02166749f, 
    0.05064822f, -0.06671294f, -0.08001018f, -0.04252437f, -0.01909810f, 0.06103134f, 0.05386918f, 0.07395232f, 
    -0.07318671f, -0.09014702f, -0.01528051f, 0.04302400f, 0.01517257f, -0.07700506f, 0.05165946f, 0.04034242f, 
    -0.02515163f, -0.07063769f, 0.05534826f, 0.06725999f, -0.05487124f, -0.03749228f, 0.05077153f, 0.04750982f, 
    0.03707863f, -0.07004077f, -0.05784406f, 0.01513554f, -0.09314968f, 0.00727051f, -0.06266927f, 0.01526468f, 
    0.05386474f, 0.03578806f, 0.01335326f, -0.02465328f, 0.00291880f, -0.04373460f, -0.03130601f, -0.00923263f, 
    -0.19427368f, -0.19340681f, -0.41074300f, -0.07561386f, -0.23483729f, -0.16105777f, -0.11155032f, 0.17939773f, 
    0.09540261f, -0.74745327f, -0.31352973f, -0.18826297f, -0.16385919f, -0.18578936f, 0.01029360f, -0.26803857f, 
    0.08685078f, -0.02027746f, 0.25028899f, -0.07960573f, 0.26410133f, -0.02974366f, -0.03093608f, 0.58391231f, 
    -0.01259506f, 0.06816823f, 0.24485634f, -0.11849766f, -0.30595937f, -0.02264397f, -0.09038493f, 0.00325357f, 
    -0.09100966f, -0.16236302f, -0.02041375f, 0.05160689f, 0.05671506f, 0.18426827f, 0.48762995f, -0.04735406f, 
    0.09868574f, 0.07206953f, 0.26329058f, -0.03923735f, 0.18677518f, -0.10323863f, 0.42812410f, 0.61660111f, 
    0.05935247f, -0.03862348f, 0.36531693f, 0.15351868f, 0.09001921f, 0.03205008f, -0.16192436f, 0.13119464f, 
    0.05020343f, -0.05292482f, -0.05364189f, 0.00464899f, 0.10454503f, 0.20946951f, 0.08414445f, 0.02932216f, 
    -0.28234282f, -0.01056901f, 0.01493490f, 0.19573943f, 0.07523837f, 0.14876875f, 0.32851833f, 0.13716251f, 
    -0.24475907f, -0.15058115f, -0.17414255f, 0.07464482f, 0.11255373f, -0.11042659f, 0.18193492f, 0.20700027f, 
    0.10499937f, 0.01794913f, 0.15313448f, 0.34140313f, 0.12396502f, 0.18684836f, 0.29556611f, 0.35883558f, 
    -0.02076243f, 0.27279240f, -0.03869076f, -0.04495692f, 0.06876602f, -0.11760522f, 0.04617526f, -0.04766865f, 
    0.06509347f, 0.32848227f, 0.23749211f, -0.60103834f, -0.25848544f, -0.19371606f, 0.00161555f, -0.13932015f, 
    -0.19476989f, 0.14339274f, 0.07996102f, 0.23028448f, -0.10201814f, -0.07055511f, 0.02390513f, 0.01527182f, 
    0.22888607f, 0.02705932f, 0.09201542f, 0.27853867f, 0.17405583f, -0.19376129f, 0.04103340f, -0.11727030f, 
    -0.23100853f, 0.25208932f, 0.35025203f, 0.12917022f, 0.01643762f, 0.29218295f, -0.06825881f, 0.03216650f, 
    0.26935369f, -0.20201027f, -0.03670450f, 0.30581185f, 0.22486946f, -0.04168438f, 0.06471472f, -0.14035800f, 
    0.18136419f, 0.52402061f, -0.09187677f, -0.14245050f, 0.14506283f, -0.01216070f, 0.10676001f, 0.02029013f, 
    -0.19814347f, 0.36110893f, 0.10251172f, 0.19035298f, 0.03050214f, -0.20522472f, 0.09586747f, 0.04152757f, 
    -0.25446290f, 0.06120998f, 0.08726145f, 0.19262739f, 0.00264807f, 0.18641692f, -0.49263754f, -0.03530062f, 
    -0.06187808f, -0.04562375f, -0.25315747f, 0.37779799f, 0.70366251f, -0.03177839f, -0.25823334f, 0.12068748f, 
    -0.18387936f, 0.24570216f, 0.25118396f, -0.12035967f, 0.26714668f, -0.08411693f, -0.00732851f, 0.07084563f, 
    -0.06338380f, 0.04992615f, -0.05592435f, 0.03181810f, -0.39006013f, 0.25375494f, 0.18935604f, 0.14262713f, 
    -0.28634149f, -0.13027897f, 0.11219422f, 0.07777019f, 0.01743419f, 0.07700331f, -0.09335689f, 0.16969952f, 
    -0.12370952f, 0.24727909f, 0.13641481f, 0.17330648f, 0.05008474f, 0.13961713f, -0.15724348f, 0.01077144f, 
    0.18339899f, -0.34193805f, -0.03924467f, -0.10097727f, -0.00513133f, -0.30824682f, -0.16940954f, 0.06498400f, 
    0.04366861f, 0.12627180f, 0.17331699f, -0.15632142f, -0.09826121f, 0.03906939f, 0.00504664f, 0.02387161f, 
    0.17150645f, 0.22064753f, 0.14097153f, 0.20357083f, -0.06808580f, -0.42317614f, 0.13208614f, -0.32133925f, 
    0.03658157f, 0.37872547f, -0.08998924f, 0.80236006f, 0.24245630f, 0.08920542f, 0.09604022f, 0.02570053f, 
    0.35734469f, 0.29094356f, -0.25403520f, -0.07833510f, -0.07783881f, 0.06144386f, 0.09616458f, 0.03877304f, 
    0.11145306f, 0.12662175f, -0.17473164f, -0.08465734f, 0.02294132f, 0.30453935f, 0.03062623f, -0.21685837f, 
    -0.13505855f, -0.26429412f, -0.52016461f, -0.02231555f, 0.16188350f, -0.11033503f, 0.29963988f, -0.01346629f, 
    0.30394611f, 0.05617141f, 0.06841219f, 0.03926798f, 0.02398588f, 0.26854968f, -0.15590513f, 0.26706055f, 
    -0.02023742f, -0.03574205f, 0.19156577f, 0.14853086f, 0.08877168f, -0.15033272f, -0.12321416f, 0.03304120f, 
    -0.42724499f, 0.05796136f, 0.03459122f, 0.36502451f, -0.03588344f, 0.04637030f, 0.03614041f, -0.00609587f, 
    -0.06411258f, 0.30008185f, 0.32176596f, 0.20247208f, 0.26555169f, -0.00540862f, 0.27964926f, 0.27481073f, 
    0.25924498f, 0.10955136f, -0.07263324f, 0.11842361f, -0.13595200f, 0.20375304f, 0.13089098f, 0.00090570f, 
    -0.40390575f, 0.07565568f, 0.23840810f, -0.06255775f, 0.01687213f, -0.17200458f, -0.12807794f, 0.10864774f, 
    0.17221329f, -0.26653013f, 0.18819238f, 0.16776195f, -0.72088844f, 0.27182171f, 0.09177708f, 0.28460580f, 
    -0.20534505f, 0.11428072f, -0.31340647f, 0.06918000f, -0.01933607f, 0.25773552f, -0.04123298f, 0.11999191f, 
    0.10162289f, 0.05928658f, -0.27950665f, 0.25211623f, -0.02597836f, 0.41920930f, 0.22035024f, 0.08551364f, 
    0.08181605f, -0.03062326f, 0.02473279f, 0.04043137f, 0.11736406f, -0.25231305f, 0.25013277f, -0.04234625f, 
    0.06399219f, 0.04082279f, -0.06704649f, -0.21336092f, -0.16260490f, -0.09846195f, 0.10883934f, -0.01741073f, 
    -0.01525181f, -0.14001933f, -0.09640091f, -0.02186152f, 0.07423346f, 0.09980043f, 0.16610953f, -0.24970919f, 
    -0.15041056f, 0.06096110f, 0.08611216f, 0.10068879f, 0.05247490f, -0.03036661f, 0.46023712f, 0.32417932f, 
    -0.52937222f, -0.05679463f, -0.16830485f, 0.19044970f, 0.34002718f, 0.39995974f, 0.46211839f, 0.10146554f, 
    0.46203080f, 0.34415060f, 0.04190525f, 0.02108844f, -0.24553248f, 0.33519459f, 0.02022156f, -0.06552840f, 
    0.10300740f, -0.17289080f, 0.08905063f, 0.00299325f, 0.08683652f, -0.03460677f, -0.06323741f, 0.04489499f, 
    0.12644033f, -0.07559843f, 0.16790256f, 0.13263127f, 0.08814804f, 0.15676320f, 0.09811983f, 0.13130327f, 
    0.12651838f, 0.09081309f, 0.12792431f, 0.36457682f, 0.19309410f, -0.06196115f, 0.17961317f, 0.08782946f, 
    0.41163385f, 0.30093867f, -0.35526589f, 0.07971567f, -0.04287076f, 0.32453251f, 0.11916685f, 0.07495008f, 
    0.58735794f, 0.14257914f, -0.02782849f, 0.13110667f, -0.18738808f, 0.05699959f, 0.19997729f, 0.22966121f, 
    0.23799805f, 0.09716275f, -0.15846825f, 0.08509994f, -0.03259188f, -0.00652933f, -0.24147363f, -0.24787088f, 
    0.25478220f, 0.04634056f, -0.12248824f, -0.13104168f, -0.37394688f, -0.03114603f, 0.17685474f, -0.41393688f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.15666564f, -0.17507677f, 0.30794081f, 0.00992285f, 0.01982985f, 0.00238220f, -0.12145863f, -0.12201701f, 
    0.38626423f, -0.02757226f, -0.09853838f, 0.06907505f, 0.02232567f, 0.48680398f, 0.24415937f, 0.44332507f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.17711988f, 0.72967064f, -0.09533001f, 0.16124375f, 0.68964738f, 0.06276929f, -0.76627028f, 0.47259158f, 
    0.09270972f, -0.16420659f, 0.41870636f, -0.03620832f, 0.06951106f, -0.37592295f, -0.42500624f, 0.12650599f, 
    0.21334122f, -0.59332997f, -0.11360472f, -0.39357775f, -0.27284408f, 0.10689628f, -0.29050025f, -0.03307944f, 
    0.01045183f, 0.17445377f, 1.05675447f, 0.21409154f, -0.20555875f, -0.30409256f, 0.00834602f, 0.33526373f, 
    -0.90027612f, -0.69496393f, 0.07910509f, 0.60961318f, -0.46169078f, -0.01710787f, 0.25163478f, -1.06309390f, 
    -0.16527544f, 0.03391653f, -0.75319105f, -0.86106706f, 0.21607609f, 0.46311131f, 0.21247435f, -0.07315750f, 
    0.12509455f, 0.75163084f, -0.49284634f, 0.51292992f, -0.14752412f, -0.06180823f, 0.42604789f, -1.10149992f, 
    -0.59461629f, -0.01278019f, -0.41032496f, 0.14359185f, -0.17692889f, -0.09291973f, 0.34028316f, 0.05987202f, 
    -0.05160238f, -0.53517461f, 0.29608241f, 0.40669739f, 0.09248788f, 0.24532384f, 0.44523230f, 0.67275268f, 
    -0.33199888f, -0.01065508f, 0.09462044f, 0.04224627f, -0.09510357f, -0.19535762f, 0.06351330f, -0.01010829f, 
    0.06191725f, 0.32126087f, -0.24142370f, -0.42968449f, 0.02114240f, 0.04170483f, 0.64119446f, 0.18004552f, 
    0.18510748f, 0.02846280f, 0.02256546f, -0.30713284f, -0.20834753f, 0.04742402f, -0.20079756f, 0.13934353f, 
    -0.69793093f, -0.44125390f, 0.81735790f, -0.25218511f, -1.16545570f, -0.08029011f, -0.58413798f, -0.67062992f, 
    0.70691317f, 0.01012412f, -1.08915961f, -0.30058157f, -0.02160774f, 0.07736285f, 0.36761525f, -0.51686841f, 
    0.64051390f, -0.00495838f, -0.21167433f, 0.35397834f, 0.07111882f, 0.13884911f, 0.10262108f, 0.16432208f, 
    0.62421197f, 0.16055346f, 0.16812465f, 0.54326844f, -0.22288769f, -0.37766904f, -0.06445935f, -0.50781900f, 
    -0.32441345f, -0.35650802f, -0.64701176f, -0.77334732f, -0.46239117f, -0.21456113f, -0.15492991f, -0.09968937f, 
    -0.22935332f, -0.13657427f, -0.68366838f, 1.04287994f, -0.04640329f, 0.40309885f, -0.56740308f, 0.47476676f, 
    -0.54462552f, -0.58838797f, 0.41815171f, -0.70684725f, 1.03689945f, 0.00619185f, -0.25137517f, -0.37440312f, 
    0.01043345f, 0.09955692f, -0.20512861f, 0.18666518f, 0.11292856f, 0.05840500f, 0.26871473f, -0.10494948f, 
    0.30857944f, -0.28711393f, -0.61684960f, 0.25644857f, -0.58374661f, -0.14298472f, 0.14764459f, 1.24366474f, 
    0.00294703f, 0.10116997f, -1.20049858f, -0.97704065f, -0.07761315f, 0.17633520f, -0.00873370f, 0.03104709f, 
    0.66566586f, -0.43490139f, 0.18091539f, -0.93681079f, -0.82882780f, -0.16172242f, -0.42234579f, 0.18508528f, 
    -0.65443707f, -0.12439823f, -0.23468505f, -0.19722134f, 0.10533123f, 0.30937964f, 0.66694927f, -0.49641922f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.46625850f, 0.52927810f, 0.79039556f, -0.38635209f, -0.70341718f, 0.07882626f, -0.22740304f, -0.50330663f, 
    -0.05362773f, 0.15103947f, -0.03519196f, -0.14432226f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
