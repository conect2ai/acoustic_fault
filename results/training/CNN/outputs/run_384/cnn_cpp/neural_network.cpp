#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.79309696f, -0.30533835f, -0.47722369f, -0.25766483f, 0.10534483f, 0.26842636f, 0.01294420f, -0.57608324f, 
    0.26772484f, 0.38854414f, -0.53466362f, -0.18463486f, -0.05613986f, 0.39246562f, 0.25283566f, -0.23489772f, 
    0.18181415f, 0.04016889f, -0.28245351f, -0.32167581f, 0.20046777f, 0.19164704f, 0.14755504f, 0.16202301f, 
    0.11640272f, 0.99466842f, 0.77822572f, -0.76129210f, -0.82977909f, -0.39731055f, -0.06490743f, 0.34368780f, 
    0.40144259f, 0.43707514f, 0.28623238f, 0.02656608f, 0.17828184f, -0.10421235f, -0.24254613f, -0.01600688f, 
    0.02829021f, -0.11285669f, 0.04124171f, 0.00596944f, -0.07032445f, -0.14101212f, -0.02202700f, -0.02914928f, 
    0.02001007f, -0.08412941f, -0.75037199f, -0.47192079f, -0.04498479f, 0.84851146f, -0.03902127f, 0.59003788f, 
    0.46278790f, -0.14760281f, 0.41852465f, -0.16637367f, 0.10878730f, 0.36174196f, -0.03182110f, 0.27338266f, 
    0.03739857f, 0.23848376f, 0.19413397f, -0.53027993f, -0.11487193f, 0.23911490f, 0.01303486f, -0.22054394f, 
    0.39350957f, 0.17899501f, -0.10795827f, -1.08261037f, 0.29154158f, 0.37634492f, 0.07927809f, -0.24605863f, 
    0.11578951f, 0.04984972f, 0.61740863f, -0.57729584f, -0.20104685f, -0.00053298f, 0.22850296f, 0.58572727f, 
    0.15375429f, 0.30768272f, -0.29728031f, -0.25260857f, 0.13121185f, 0.11546535f, 0.00092730f, 0.12477461f, 
    0.07033908f, 0.04935028f, 0.42343128f, -0.10275590f, -0.19993806f, -0.92773497f, -0.51885855f, -0.02217485f, 
    0.50902432f, 0.63974679f, 0.85045028f, -0.20086651f, 0.47018456f, 0.35290959f, -0.16736729f, 0.11129753f, 
    -0.38654804f, 0.16797683f, 0.15705997f, -0.03541884f, -0.00375854f, 0.05240199f, 0.14192574f, 0.14303640f, 
    -0.06491745f, -0.05074697f, -0.09281380f, -0.12546109f, 0.15706751f, 0.70757967f, 0.55182344f, 0.12376124f, 
    0.41425073f, 0.86247468f, 0.50971377f, 0.17312972f, 0.16743012f, 0.44494236f, 0.25345618f, -0.19981886f, 
    0.09792922f, -0.14849946f, 0.01155010f, -0.26903820f, -0.15722708f, -0.21302490f, 0.22189273f, 0.17088017f, 
    -0.22342157f, 0.03126951f, 0.10309679f, 0.06584546f, 0.06648147f, 0.33312735f, -0.43225005f, 0.75934005f, 
    -0.38901052f, -0.50096422f, 0.80495620f, 0.59931862f, -0.68192083f, -0.61463279f, -0.23024902f, -0.13490938f, 
    0.14883497f, -0.34114268f, -0.37802348f, 0.02652548f, -0.40917048f, -0.01751425f, -0.07201575f, -0.39450189f, 
    -0.31553721f, -0.11161552f, 0.20683840f, 0.26757145f, 0.22798185f, 0.01305121f, -0.11305140f, -0.51699215f, 
    -0.55325115f, -0.76550615f, -0.46052435f, -0.33144811f, 0.39201880f, 0.15023209f, -0.21922407f, 0.07544511f, 
    0.11167583f, -0.16205949f, 0.42558441f, 0.21308146f, 0.21720566f, 0.19076794f, -0.04030087f, 0.24822703f, 
    0.25376254f, 0.05088668f, -0.05109920f, -0.15932478f, 0.23437977f, -0.08550917f, -0.36167300f, -0.23588656f, 
    -0.38249844f, -0.43054515f, -0.18814266f, -0.53069448f, 0.29874024f, 0.25254050f, -0.38886449f, -0.82566404f, 
    -0.66375810f, -0.59013671f, -0.08235291f, 0.48590526f, 0.34568581f, 0.31232390f, 0.27780882f, 0.30464408f, 
    0.06561961f, 0.06485657f, -0.11228404f, 0.01976702f, -0.21628594f, -0.01821307f, 0.30728409f, 0.28002548f, 
    -0.14384164f, 0.33644900f, -0.53379172f, 0.60900849f, 0.94647330f, 0.51254487f, 0.63566113f, 0.14339650f, 
    0.13899758f, -0.19845504f, -0.33145860f, 0.06465668f, -0.03542650f, 0.02829365f, 0.03757983f, 0.01689619f, 
    0.02188205f, 0.30140197f, -0.06965157f, 0.01371308f, -0.10278514f, -0.18181759f, 0.07745939f, 0.20771284f, 
    -0.28175139f, 0.28966746f, -0.31416112f, 0.16194631f, 0.10409499f, 0.40024060f, 0.39946675f, -0.86379218f, 
    -0.06634311f, -0.29448375f, -0.44606364f, -0.02191753f, 0.32854179f, -0.14643115f, -0.26993316f, 0.14310901f, 
    -0.08530302f, 0.23550519f, 0.21078254f, 0.15959589f, 0.19535403f, 0.03492030f, -0.42313778f, -0.03331776f, 
    0.29822654f, -0.07862550f, -0.35231328f, -0.44639963f, 0.75799066f, -0.08011135f, -0.38536850f, 0.33343294f, 
    -0.62932384f, 0.53015780f, -0.35031354f, -0.72777689f, -0.06362407f, 0.48740008f, -0.00663557f, 0.11548448f, 
    -0.36550996f, 0.22935279f, 0.08330624f, 0.00744086f, -0.29145825f, 0.03004666f, -0.01506017f, 0.37398490f, 
    0.32032731f, 0.09816779f, 0.27643308f, 0.14129440f, -1.25857317f, 1.00054145f, -0.19988929f, -0.01023607f, 
    0.04494254f, 0.12117384f, 0.67743117f, 0.18912062f, 0.41443881f, 0.62706405f, -0.35025004f, -0.15871046f, 
    0.15778588f, -0.26326069f, 0.14816314f, 0.10403712f, 0.09445024f, 0.00007914f, 0.06416532f, -0.03897250f, 
    0.30820554f, 0.04263123f, 0.04814798f, 0.09324596f, -0.09460165f, -0.30819350f, -0.94243199f, 0.30493817f, 
    0.57128304f, -0.41749823f, -0.05609480f, 0.05282657f, 0.70134044f, -0.54766238f, -0.17350838f, 0.32204184f, 
    -0.01383876f, -0.36407030f, 0.04067874f, 0.39029321f, 0.23935889f, 0.22782762f, -0.33574766f, -0.05719779f, 
    0.08991255f, 0.18926111f, -0.14748825f, -0.04411848f, -0.05794934f, 0.06291873f, -0.19107820f, -0.47840407f, 
    -1.05012870f, -0.83807766f, 0.17069343f, 0.48771510f, -0.17873611f, 0.34534562f, 0.16469842f, 0.31818449f, 
    -0.38939145f, -0.11397471f, -0.47471017f, -0.29321688f, -0.39672574f, 0.15876105f, 0.07350910f, 0.20517318f, 
    0.17418949f, 0.10108586f, -0.35220394f, -0.03554752f, -0.36728746f, 0.24115644f, 0.17837451f, -0.77505487f, 
    -0.61620867f, -0.22224076f, -0.24372934f, -0.60798335f, 0.45856094f, 0.64072543f, 0.00378044f, -0.06422248f, 
    0.41527539f, -0.40602061f, -0.40371710f, 0.21658550f, -0.05488512f, -0.07282943f, 0.06311423f, -0.04368594f, 
    0.12984760f, -0.17389944f, -0.08211525f, 0.25621244f, 0.00533191f, 0.03962233f, 0.09432963f, 0.12522173f, 
    0.67479903f, 0.58980918f, 0.69526577f, 0.72467959f, 0.41609782f, -0.18883282f, 0.20786478f, -0.42143205f, 
    -0.03026644f, 0.53111976f, -0.02770774f, 0.21930557f, 0.21907935f, -0.04188316f, 0.06928273f, -0.51326263f, 
    -0.01472621f, 0.11662469f, -0.37236243f, -0.26074755f, 0.17805833f, -0.04768622f, 0.05007118f, -0.16317585f, 
    -0.18267149f, 0.81195003f, 0.26018828f, -0.43832275f, 0.65517813f, 0.00638495f, 0.72413945f, 0.64725590f, 
    -0.38307643f, -0.02304232f, -0.35410610f, 0.14340627f, -0.12956174f, -0.13576961f, 0.01483609f, -0.32762274f, 
    0.17296138f, 0.24535240f, 0.21264133f, 0.14820465f, 0.13502248f, -0.10442764f, -0.06127428f, -0.23771331f, 
    -0.09729682f, 0.12313977f, 0.60356557f, -0.14719549f, -0.26612154f, -0.14376785f, -0.08207202f, 0.59998071f, 
    0.60730547f, 0.36054704f, 0.55755424f, 0.38280797f, -0.31125909f, 0.24482054f, -0.22959025f, -0.06286037f, 
    0.04754471f, -0.07436979f, -0.25391671f, -0.33790055f, 0.17830190f, -0.04384357f, -0.06628376f, 0.07548053f, 
    0.06086539f, 0.23366216f, -0.05148346f, 1.07062078f, 0.18110010f, 0.13822116f, 0.01300410f, 0.81614977f, 
    0.01404848f, 0.22373867f, 0.22075550f, -0.24922717f, -0.33580467f, -0.33626676f, -0.11626538f, -0.00687355f, 
    0.15538529f, 0.34793207f, -0.00253693f, 0.27434528f, 0.15682721f, 0.34920493f, 0.33833268f, 0.04840967f, 
    0.25634912f, -0.10732599f, 0.00728212f, 0.00154043f, 0.99386728f, 0.24109806f, -0.58529717f, 0.68848217f, 
    -0.12292352f, -0.04729005f, 0.17283361f, 0.13463487f, -0.00527494f, 0.14279284f, 0.36692548f, -0.04167613f, 
    -0.01498759f, -0.31591401f, -0.31391710f, 0.10732485f, -0.07892348f, -0.22041197f, 0.09853668f, -0.09889945f, 
    0.24299866f, -0.06859364f, 0.00335544f, -0.21849023f, -0.07835107f, -0.13765727f, -0.36335841f, -0.36876327f, 
    -0.53260350f, 0.09514356f, -0.41800427f, -0.66477489f, 0.43483844f, 0.36317354f, -0.37499970f, -0.45571423f, 
    -0.15353926f, 0.33342701f, -0.22164449f, -0.43999898f, 0.44659176f, -0.00514568f, 0.22594069f, -0.00751407f, 
    -0.33766606f, -0.14933756f, -0.11566436f, 0.14980666f, -0.11262348f, -0.02639999f, 0.47226718f, 0.89625216f, 
    0.76507753f, 0.33543274f, 0.55166668f, -0.90360916f, -0.04875937f, -0.24917327f, -0.13855895f, -0.07917559f, 
    -0.20393378f, 0.21809272f, 0.20048760f, 0.10225943f, 0.33043161f, 0.16477357f, 0.16853388f, 0.16251351f, 
    0.17549416f, 0.18535921f, 0.11903956f, 0.05652109f, 0.17229211f, 0.04617861f, 0.04861875f, -0.49540630f, 
    -0.80977142f, 0.20523436f, 0.15462145f, 0.00208534f, -0.24573608f, -0.15562893f, -0.29749832f, -0.22525036f, 
    0.17353615f, 0.32676449f, 0.35108271f, 0.14036541f, 0.53445452f, -0.30535951f, 0.19969828f, 0.32909125f, 
    0.52504814f, 0.16109808f, 0.02305518f, -0.34186429f, -0.11455711f, 0.03273039f, -0.44520056f, 0.27012971f, 
    0.00679931f, 1.07569396f, 0.14211793f, -0.24421284f, -1.10728669f, 0.45397857f, -0.48159686f, -0.35147092f, 
    -0.57301044f, -0.05489084f, -0.02331903f, 0.21976414f, 0.11533102f, 0.25265533f, 0.06643619f, -0.02315854f, 
    -0.11694996f, -0.02517636f, 0.17799012f, -0.11467869f, 0.10066357f, 0.14095661f, 0.16130237f, -0.12437662f, 
    0.24513692f, -0.33349761f, -0.89106613f, -0.34626311f, -0.14726110f, -0.04169371f, -0.46903375f, 0.70320582f, 
    -0.02711387f, 0.33758879f, 0.00832101f, -0.25919175f, -0.25720519f, 0.41173154f, 0.03178114f, -0.39089119f, 
    -0.33119050f, -0.01812496f, -0.21060495f, -0.21410172f, -0.18246371f, -0.06428442f, 0.05985691f, -0.27219474f, 
    0.19696335f, 0.17257011f, 1.05828166f, 0.80186141f, 0.65618443f, -0.21133983f, -0.44042274f, 0.13214564f, 
    -0.44264925f, -0.34581903f, -0.30563012f, 0.21176253f, 0.07969811f, -0.29081416f, -0.00623559f, 0.10899347f, 
    -0.21742293f, -0.09283446f, -0.16158943f, 0.02641859f, -0.18791407f, -0.17568615f, -0.24574277f, -0.12434529f, 
    -0.10025734f, -0.36949965f, 0.08514161f, -0.29281843f, -1.09793389f, -0.57558793f, 0.23196094f, 0.38926947f, 
    -0.76716059f, 0.88848472f, 0.62335283f, -0.69576579f, 0.41205031f, 0.25676411f, 0.07808080f, -0.16035534f, 
    -0.23752677f, 0.07915110f, -0.20595939f, -0.03637407f, -0.18464209f, 0.02736466f, -0.29736298f, -0.06224510f, 
    -0.10813449f, 0.04058951f, -0.19886245f, 0.05529569f, 0.38439021f, -0.28534713f, -0.37561744f, 0.12629038f, 
    -0.14726903f, -0.04643974f, -0.73336422f, -0.62236458f, 0.00965165f, -0.57480723f, -0.47269031f, 0.06540526f, 
    -0.13793057f, -0.03890914f, -0.10932016f, -0.07824787f, -0.07886154f, -0.65044039f, -0.18055519f, 0.30641678f, 
    -0.35826746f, -0.04711029f, -0.14675373f, -0.09117980f, 0.06582162f, 0.17025933f, 0.29655859f, 0.50974333f, 
    0.65822220f, 0.08695102f, 0.35577404f, -0.51876789f, 0.01314981f, 0.05633372f, 0.32183397f, 0.39426139f, 
    0.45236930f, -0.29470220f, -0.14224370f, 0.31155178f, 0.18425840f, 0.07817512f, 0.31735677f, 0.09647259f, 
    0.32474330f, -0.26511991f, -0.17703283f, -0.28116375f, -0.11403261f, 0.23481989f, 0.53578252f, 0.21588096f, 
    0.34421054f, 0.90794367f, 0.38879377f, -0.33976880f, -0.21220377f, 0.05569391f, 0.57052565f, 0.12975027f, 
    -0.43958643f, 0.34301373f, -0.48401698f, -0.13981491f, -0.30527610f, -0.10292235f, -0.13880062f, -0.40841004f, 
    -0.02624276f, 0.00467284f, -0.23059368f, -0.04915718f, 0.13814573f, 0.18709008f, -0.06447146f, -0.54292440f, 
    0.00281172f, 0.41772714f, 0.13931142f, -0.74077427f, 0.65210301f, -0.63181287f, 0.09310720f, 0.17965530f, 
    -0.18416151f, -0.00404742f, -0.24924660f, 0.03160582f, 0.12158231f, -0.13178685f, -0.07814359f, 0.17053103f, 
    -0.06792247f, -0.39060742f, 0.22551794f, -0.12470818f, 0.04970534f, 0.40218407f, 0.24607038f, -0.18158051f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16242516f, 0.18882458f, 0.24716814f, -0.02612395f, 0.06315549f, -0.00865829f, 0.12978105f, 0.35611299f, 
    0.25445357f, 0.13957630f, 0.25715551f, 0.14145431f, -0.20923077f, -0.00163433f, -0.13638277f, 0.00319390f, 
    0.05313426f, -0.00285446f, 0.01248327f, 0.17829446f, 0.19786820f, 0.03664874f, 0.00974625f, 0.25476238f, 
    0.28479570f, -0.02969998f, 0.18759562f, 0.19006482f, 0.14117821f, 0.00323720f, 0.00252322f, -0.03911164f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03266866f, -0.05025177f, 0.03817283f, -0.01119075f, 0.01259862f, 0.02200269f, 0.00149653f, -0.05105652f, 
    0.03894871f, 0.01470774f, 0.03442165f, -0.05855246f, -0.03770191f, -0.01044003f, -0.04480017f, -0.01747715f, 
    0.02849070f, -0.01267339f, 0.01771396f, 0.00781389f, -0.02631148f, -0.02598281f, -0.00271461f, 0.01158768f, 
    0.00995496f, 0.02120435f, -0.01388713f, -0.00605278f, -0.04108290f, 0.01761138f, -0.00412333f, -0.01322087f, 
    -0.03313788f, 0.01269564f, 0.03598366f, -0.02527983f, -0.02221665f, -0.03695683f, -0.02533410f, -0.03258432f, 
    -0.03643419f, -0.01496857f, -0.05650833f, -0.03889526f, -0.01798017f, 0.04542270f, -0.01138199f, -0.04494574f, 
    -0.00532345f, -0.04104723f, 0.00075969f, -0.01031235f, -0.05355525f, -0.06326160f, -0.01422280f, -0.04696883f, 
    -0.04246434f, -0.04693381f, 0.02398179f, -0.04045405f, -0.02578094f, 0.00027636f, 0.04640632f, 0.04022222f, 
    0.02632042f, 0.00651744f, -0.05873599f, -0.04068879f, 0.01216439f, 0.02426845f, 0.00461300f, 0.03637981f, 
    0.02305910f, 0.02836611f, 0.00476405f, -0.01097147f, 0.00520270f, 0.03877158f, -0.00282253f, -0.05523190f, 
    -0.03689878f, -0.00142301f, 0.03957894f, 0.00583454f, 0.02252883f, 0.00820932f, 0.01118610f, -0.00630789f, 
    -0.05765283f, -0.01966966f, 0.02409012f, 0.02156743f, 0.03386283f, -0.00181646f, -0.02247542f, 0.01478915f, 
    -0.02842118f, -0.02699886f, 0.03925394f, 0.02881229f, 0.01762416f, 0.01707006f, -0.00710441f, 0.02129767f, 
    0.00156640f, -0.02435172f, -0.05176064f, -0.05530610f, 0.01028193f, 0.01691794f, -0.03708010f, 0.01675183f, 
    0.01560968f, -0.04323920f, 0.00800166f, -0.05860779f, -0.01261993f, -0.01164523f, -0.02903632f, -0.00052357f, 
    -0.00777013f, -0.04769622f, 0.03787716f, 0.02329707f, -0.03305556f, -0.03402319f, -0.00190165f, 0.03206040f, 
    -0.00077185f, 0.00559674f, -0.04994415f, -0.01172971f, -0.01420735f, -0.00462970f, 0.03499493f, 0.03338237f, 
    -0.01577293f, 0.03039114f, -0.05308086f, -0.01755228f, -0.03896760f, 0.00171818f, -0.02203221f, 0.00748838f, 
    -0.04052860f, 0.02015726f, -0.01673367f, -0.03785953f, -0.04345594f, 0.02432320f, 0.01713773f, -0.00371444f, 
    -0.05319318f, -0.02406845f, -0.01338072f, -0.04197900f, 0.01131756f, -0.03325665f, -0.02756456f, 0.03582844f, 
    -0.03762689f, -0.02389606f, -0.02318229f, 0.03085122f, 0.01765392f, -0.01571099f, 0.00385333f, -0.04634565f, 
    -0.01248307f, 0.02666115f, -0.00358642f, -0.03730507f, 0.03742009f, -0.01682381f, -0.04771671f, 0.02245171f, 
    -0.05897379f, -0.01970782f, -0.05501241f, -0.02064777f, 0.00899291f, -0.03547499f, 0.03428651f, 0.02949449f, 
    -0.02121853f, -0.00862287f, 0.02990815f, -0.00670712f, 0.00118934f, -0.01558735f, 0.01552492f, -0.01303948f, 
    -0.01915498f, 0.00581975f, -0.00945080f, -0.00246997f, -0.03499578f, -0.02142060f, 0.03387703f, 0.02640872f, 
    -0.02739848f, 0.02914600f, -0.01610492f, -0.04365463f, -0.03345025f, 0.01699884f, 0.00375960f, -0.04689816f, 
    0.01426824f, 0.02138653f, -0.01509310f, 0.00156834f, 0.00497116f, 0.00083609f, -0.05039102f, 0.03439942f, 
    0.01224614f, -0.05545731f, -0.04431527f, 0.00843961f, -0.02674913f, -0.05655037f, -0.05576687f, -0.00239604f, 
    -0.02288528f, 0.02563343f, 0.03276895f, 0.03008135f, 0.02377846f, 0.02837688f, 0.00865506f, -0.06220140f, 
    -0.01079644f, -0.04156387f, 0.01914089f, -0.01251305f, -0.04528357f, -0.04487917f, -0.05412417f, -0.04795397f, 
    0.01767022f, -0.03491428f, -0.05405558f, -0.03007980f, -0.02273321f, -0.01490613f, -0.02468204f, 0.03911461f, 
    -0.04439740f, -0.00639061f, -0.06050032f, -0.00356805f, -0.02634258f, -0.00358979f, -0.03947515f, -0.01376379f, 
    0.02501864f, -0.00323290f, -0.05894094f, 0.03139438f, 0.03060385f, 0.03708401f, -0.03950243f, -0.01170352f, 
    0.01166385f, 0.01292999f, 0.00794195f, 0.01678727f, -0.03465673f, -0.03846216f, -0.04089968f, -0.04303909f, 
    0.02847830f, 0.00238751f, -0.00277360f, -0.03608270f, -0.02068874f, 0.00279388f, -0.05764763f, -0.03083466f, 
    -0.04204348f, -0.03114412f, -0.03150177f, 0.02935941f, -0.01456640f, 0.02543406f, -0.01132269f, 0.03900165f, 
    0.00784184f, -0.00162089f, 0.01456475f, 0.02278510f, -0.05774417f, 0.00928488f, 0.00288891f, -0.00916521f, 
    -0.03070065f, -0.04369886f, 0.03005021f, 0.03436057f, 0.00447917f, -0.01743207f, -0.00264482f, 0.00564253f, 
    -0.05466282f, 0.00363612f, -0.00521900f, 0.02697781f, -0.00628531f, -0.01090723f, -0.02457443f, 0.00156991f, 
    0.03087513f, 0.00706466f, 0.01002568f, 0.00325421f, 0.02642801f, -0.00167870f, -0.02169088f, -0.00898035f, 
    0.01912112f, -0.03659776f, 0.01304562f, 0.02907697f, -0.01892842f, 0.00790661f, -0.05068843f, 0.02723801f, 
    -0.00786393f, 0.00528878f, 0.02349897f, 0.02477815f, -0.02357429f, -0.05044988f, -0.04510308f, -0.02783536f, 
    0.02406723f, -0.05917649f, -0.06049795f, -0.05665804f, 0.04131160f, 0.02081089f, -0.05171603f, -0.05939241f, 
    0.02767098f, -0.00954081f, -0.02596042f, 0.02821432f, 0.00046483f, -0.02210324f, -0.04043072f, -0.05524982f, 
    -0.03100580f, -0.04694625f, 0.04227607f, -0.01442642f, -0.01766805f, 0.04300140f, -0.03400753f, 0.00349116f, 
    -0.04470224f, -0.01983183f, -0.05769100f, 0.01746079f, 0.03381439f, -0.03904326f, 0.01166592f, -0.01098438f, 
    -0.05446050f, -0.04844439f, -0.04959660f, 0.01090400f, -0.02487079f, 0.03482829f, -0.03707792f, 0.03957996f, 
    -0.06172681f, -0.05727753f, 0.00476481f, -0.00979331f, -0.01011807f, 0.03846785f, 0.02106976f, 0.03022005f, 
    0.01136488f, 0.02350692f, -0.04878302f, 0.00286904f, -0.04990133f, 0.02101967f, -0.01355413f, 0.01663657f, 
    0.02558194f, 0.04078356f, -0.03498765f, -0.00201969f, 0.00348750f, -0.05484957f, 0.01889860f, 0.02266132f, 
    -0.00259459f, 0.02830734f, 0.00811582f, 0.01331521f, -0.00247624f, 0.03013987f, 0.03056103f, -0.01002738f, 
    -0.03116457f, 0.02101681f, -0.05424786f, -0.05489792f, 0.02262737f, -0.02396033f, 0.02414428f, -0.00238400f, 
    -0.03209738f, -0.01373528f, -0.04482939f, -0.05602023f, -0.02889796f, -0.02721112f, 0.04046858f, 0.01709488f, 
    0.00376383f, -0.05228089f, -0.02649810f, -0.02789287f, -0.00373785f, -0.00589904f, -0.01159643f, -0.03464715f, 
    -0.01409161f, 0.03344380f, -0.02761756f, -0.01840198f, -0.02674472f, -0.04794568f, -0.04690683f, 0.00073536f, 
    0.02086209f, -0.05109629f, 0.00859921f, 0.03621339f, 0.03582821f, -0.04258921f, -0.04116341f, 0.03646886f, 
    0.03583780f, -0.04191064f, 0.00930053f, -0.01576312f, 0.03269147f, -0.03530753f, 0.01460908f, -0.00753539f, 
    0.02937031f, 0.04133527f, 0.02462498f, 0.02858598f, 0.01127429f, -0.04823016f, 0.00475016f, 0.03521381f, 
    -0.05651816f, -0.04872201f, 0.00213055f, -0.05283931f, -0.05733476f, -0.02682163f, -0.04430112f, -0.01087666f, 
    0.03256936f, 0.03563538f, -0.01624468f, -0.00529661f, 0.01574524f, -0.03321923f, 0.03772486f, -0.05660862f, 
    0.03411945f, 0.03417267f, 0.01008710f, 0.02311007f, -0.01615868f, -0.03040593f, 0.02268779f, 0.00697750f, 
    0.02629007f, 0.01672811f, -0.03502743f, -0.04539080f, 0.01176998f, 0.03298614f, 0.01666489f, 0.00811176f, 
    0.00307379f, -0.02457361f, -0.03813161f, 0.04266307f, -0.00277848f, 0.00912540f, -0.03777642f, 0.00553737f, 
    -0.02147679f, 0.01391174f, -0.03389535f, -0.00963790f, -0.01298067f, 0.00160498f, 0.01062065f, 0.02381213f, 
    -0.00487768f, 0.02347655f, -0.02390367f, 0.02283199f, -0.05957016f, -0.01051795f, 0.00301413f, -0.00384136f, 
    0.02620256f, -0.03918317f, -0.03682844f, -0.05917309f, -0.05519719f, 0.03137157f, -0.04425853f, -0.04690549f, 
    0.04171043f, -0.03996217f, -0.02643675f, -0.05097148f, -0.01304341f, -0.02274876f, 0.04042652f, 0.03978526f, 
    -0.01292089f, -0.04989658f, 0.00987976f, 0.03545032f, 0.00219274f, 0.02077688f, 0.02234239f, -0.02504642f, 
    0.01448699f, -0.01254003f, -0.03360803f, 0.00093328f, -0.00163679f, 0.02874490f, -0.00491920f, -0.02396560f, 
    0.04009232f, -0.04964288f, -0.02212675f, 0.02605013f, 0.02733276f, 0.02752570f, -0.04528618f, 0.01162540f, 
    -0.02393934f, -0.02127405f, -0.00262670f, 0.03454529f, 0.01132330f, -0.04736641f, 0.04086831f, -0.02356307f, 
    0.00993655f, 0.00200343f, -0.04637790f, -0.01677768f, -0.04441976f, -0.05153644f, 0.01469092f, -0.04922439f, 
    -0.02303880f, -0.05571076f, 0.01265267f, -0.01032680f, 0.01491366f, 0.03158882f, 0.03617431f, -0.03224013f, 
    -0.04852922f, -0.02499461f, -0.02385210f, -0.02147106f, -0.01203836f, 0.02175834f, -0.01433648f, -0.02782836f, 
    0.01844439f, -0.00777988f, -0.03905276f, -0.00771395f, 0.03370064f, -0.01386682f, 0.01804282f, 0.03471990f, 
    0.00991135f, 0.02507723f, -0.04464309f, 0.00868949f, -0.03709928f, -0.00445524f, -0.01587198f, -0.04812795f, 
    -0.02385203f, -0.04483753f, 0.02765832f, -0.05182255f, -0.00776002f, 0.00900644f, -0.02243286f, 0.03044111f, 
    -0.05551327f, -0.03031666f, 0.00860572f, -0.04237748f, -0.00453608f, -0.01293462f, -0.00306773f, -0.05125560f, 
    -0.01779271f, -0.01361078f, 0.03888378f, -0.03674422f, 0.03135289f, 0.03982040f, 0.02217051f, 0.01234867f, 
    0.01535830f, 0.01396124f, -0.02779673f, -0.00216750f, -0.03313708f, -0.00551121f, -0.00164288f, -0.04644679f, 
    0.03533705f, -0.02580052f, -0.01460904f, 0.01715981f, -0.05440301f, -0.03313112f, 0.00582428f, -0.00763481f, 
    0.02673682f, 0.02583511f, -0.02169499f, -0.02029625f, -0.01539840f, -0.05101585f, 0.02105524f, -0.05430354f, 
    -0.03203151f, -0.03327512f, -0.05839622f, -0.02368285f, -0.04486228f, -0.02938312f, 0.00543124f, 0.00918912f, 
    0.01351258f, 0.04067807f, -0.01530529f, -0.00394838f, -0.05873777f, -0.03740264f, -0.00135597f, -0.03379010f, 
    -0.00707885f, 0.03534078f, 0.02842863f, -0.00839139f, 0.02140887f, 0.00425550f, 0.00729495f, 0.03061130f, 
    0.01305308f, 0.00042665f, -0.05526759f, -0.03681966f, -0.04990999f, -0.03481725f, -0.01813728f, -0.01644316f, 
    -0.02966501f, -0.04785032f, -0.00591481f, 0.00118184f, -0.04596807f, -0.02863190f, -0.02606299f, -0.05355138f, 
    -0.00166030f, -0.05625817f, -0.05088480f, -0.04442806f, 0.03285678f, 0.02312840f, -0.01638759f, -0.01569651f, 
    0.01537962f, -0.02248744f, -0.05770682f, -0.02081829f, 0.02787760f, -0.04690647f, -0.01799742f, -0.03782240f, 
    -0.02791563f, -0.00135706f, -0.05435192f, 0.00354004f, -0.05327937f, 0.01417211f, -0.01088233f, -0.03853192f, 
    0.00916109f, -0.04631183f, -0.02683974f, -0.03260870f, -0.05399618f, -0.04883200f, -0.01672334f, 0.01128039f, 
    -0.00978356f, -0.03691205f, 0.02836879f, -0.00526625f, -0.00865897f, -0.01813223f, -0.05515502f, 0.01410302f, 
    0.02532128f, 0.03248739f, 0.01187381f, -0.03664194f, -0.00997194f, 0.00265583f, 0.01421332f, -0.03216770f, 
    0.02325216f, 0.00372377f, 0.02968735f, 0.00728396f, -0.01446699f, -0.01642139f, 0.02649902f, -0.02548135f, 
    0.00304289f, 0.02746622f, -0.02279141f, -0.03690139f, 0.04043698f, -0.02173337f, -0.01419443f, 0.03581773f, 
    -0.03956478f, 0.03581579f, 0.00330849f, -0.01292960f, 0.01173595f, 0.01889707f, -0.02204930f, -0.05188297f, 
    -0.03683972f, -0.04569510f, -0.01733288f, -0.03828564f, 0.00369866f, -0.00131967f, -0.01706053f, -0.01296430f, 
    -0.05439898f, 0.01553924f, -0.05252659f, -0.00120883f, 0.01249710f, 0.03600828f, -0.02062447f, -0.03747885f, 
    0.03461914f, -0.05618343f, -0.01848401f, -0.01521483f, 0.00229098f, -0.00297613f, 0.02719462f, 0.01993919f, 
    0.03887228f, -0.03474210f, -0.02020721f, 0.00354493f, 0.03446760f, -0.00838692f, -0.05678789f, -0.04315834f, 
    0.00143866f, -0.03831967f, -0.00159322f, 0.02951808f, -0.05760221f, -0.02276887f, -0.03765251f, 0.04641091f, 
    0.00561509f, -0.01638009f, -0.04560064f, 0.03319535f, 0.05037746f, 0.03029212f, 0.01082724f, 0.02755141f, 
    -0.05535260f, -0.02114516f, -0.05143961f, 0.03769752f, 0.01011185f, -0.03115994f, -0.02657613f, 0.01084138f, 
    -0.04392793f, -0.00876072f, -0.00001939f, 0.00447507f, 0.00002752f, -0.00983743f, -0.04743502f, 0.04013436f, 
    -0.01859700f, -0.02133889f, 0.01143995f, -0.03750644f, 0.02713367f, -0.02521273f, -0.00200980f, -0.01619801f, 
    0.01484132f, -0.03752683f, -0.02824329f, 0.04478218f, -0.02572455f, 0.03857538f, 0.03203230f, -0.00647543f, 
    0.02095505f, 0.02843043f, -0.01143976f, -0.00871456f, -0.02766184f, 0.03304769f, -0.00032759f, 0.03189679f, 
    0.00900114f, -0.00691502f, -0.01808920f, -0.03905300f, -0.05462116f, -0.03571748f, 0.03537277f, -0.01927260f, 
    0.03627712f, -0.04242529f, -0.01529042f, -0.00607563f, 0.02042756f, -0.00250601f, -0.05646802f, -0.02909895f, 
    0.00714110f, 0.04704676f, 0.00690099f, 0.00527566f, -0.05270067f, -0.00763447f, -0.02028083f, 0.00129749f, 
    -0.01108733f, 0.02926251f, -0.00952510f, -0.04333469f, -0.02365344f, 0.03865940f, 0.00798917f, -0.04544148f, 
    -0.02813802f, 0.02009398f, -0.00310722f, -0.02578019f, 0.00801894f, -0.00906643f, -0.01186415f, -0.01304311f, 
    0.00310295f, 0.03752241f, 0.02640423f, 0.02376201f, -0.04559624f, 0.00961712f, 0.00816647f, 0.03943658f, 
    0.01528009f, 0.00823089f, -0.04240797f, -0.04171950f, -0.05599857f, 0.04257676f, 0.01429121f, 0.02934092f, 
    0.02794528f, 0.03132895f, -0.02445802f, -0.03316214f, -0.05654305f, 0.00675871f, 0.02458270f, -0.05044990f, 
    0.00528173f, 0.01162191f, 0.01642100f, -0.01817709f, -0.02807757f, -0.00559368f, -0.04056594f, 0.04065685f, 
    0.00689480f, -0.00698792f, 0.00636202f, 0.01591409f, -0.03939040f, -0.02094213f, -0.05414798f, -0.05337410f, 
    -0.04145049f, -0.04779173f, 0.03478571f, -0.00423498f, -0.00259816f, -0.05020170f, -0.03736065f, 0.00775679f, 
    0.04551326f, 0.02021296f, 0.04172513f, -0.01733433f, -0.00144408f, 0.00154888f, -0.05392672f, 0.00505010f, 
    -0.02110578f, -0.03874515f, -0.03802159f, 0.02078831f, 0.00383045f, -0.01583206f, 0.04168406f, 0.02345531f, 
    -0.00644468f, 0.01748360f, -0.00391714f, 0.04311338f, -0.00005717f, -0.05482533f, -0.00684764f, 0.03264601f, 
    0.04324218f, 0.03695180f, 0.04247168f, -0.02555162f, -0.04482367f, -0.03847971f, 0.03819156f, 0.02937860f, 
    0.04054134f, 0.03383684f, 0.02776226f, -0.04389668f, -0.01409978f, -0.03113261f, -0.03347924f, -0.02882989f, 
    -0.01981254f, -0.00977803f, 0.00899101f, -0.01058089f, -0.00365459f, 0.04571407f, -0.03892408f, -0.00880587f, 
    0.02953748f, -0.04962587f, -0.03923606f, -0.00824765f, 0.01966943f, -0.04893980f, 0.00047230f, -0.04161059f, 
    0.03186228f, 0.02246141f, -0.00142383f, 0.00519749f, 0.00451216f, -0.00200563f, -0.00722926f, 0.00333790f, 
    0.00355805f, 0.02996343f, -0.04503353f, -0.03352906f, -0.04294878f, 0.03682137f, -0.00704553f, 0.00731976f, 
    0.01654667f, 0.01702492f, 0.02802270f, 0.00398051f, -0.01403382f, -0.02568340f, -0.01399842f, 0.03517850f, 
    0.02194473f, -0.03024164f, 0.03960347f, -0.01322413f, -0.01478453f, -0.03901995f, -0.01231906f, -0.00768668f, 
    0.03910708f, 0.02149518f, -0.03509898f, -0.00157555f, -0.02449979f, 0.02116619f, -0.00805275f, 0.04230302f, 
    0.03174732f, -0.03550989f, 0.00444843f, -0.02565105f, -0.01217309f, -0.00446495f, 0.04087041f, 0.04842725f, 
    -0.00352090f, -0.01071863f, -0.04111467f, -0.02689771f, -0.05627261f, -0.04733590f, -0.02328051f, -0.02746929f, 
    -0.03333033f, -0.05025092f, -0.01832985f, 0.04086971f, 0.03770404f, -0.00210353f, -0.00758527f, 0.03049721f, 
    -0.01756210f, 0.00889850f, 0.02484343f, -0.00204837f, 0.02308197f, -0.02091460f, 0.03591163f, -0.05365974f, 
    0.01238547f, -0.05122995f, -0.03880414f, 0.03216020f, -0.01108139f, 0.02586620f, -0.00704550f, 0.02195762f, 
    0.00165416f, -0.05629916f, -0.00156988f, 0.00201407f, -0.02192246f, 0.03101242f, -0.04157798f, 0.02387335f, 
    -0.02072918f, -0.05362369f, -0.04904046f, -0.00818398f, -0.00052466f, -0.04293140f, -0.05014301f, 0.00848318f, 
    0.01568931f, 0.02938767f, -0.05195475f, -0.04090662f, -0.05299903f, -0.04139425f, 0.01288668f, -0.04068168f, 
    -0.00586263f, -0.03906436f, -0.01354057f, -0.00082854f, -0.02740870f, -0.03375039f, -0.02157109f, -0.00522313f, 
    0.03596566f, 0.04265870f, -0.04128277f, 0.01089625f, -0.03295571f, -0.04377798f, 0.03648006f, 0.01652063f, 
    0.00955844f, -0.03215716f, -0.01773418f, 0.00649262f, -0.00905963f, -0.01297491f, -0.00471083f, -0.02174406f, 
    -0.01584190f, 0.04087845f, -0.03149083f, 0.02581558f, 0.02302047f, 0.03554491f, -0.03532358f, -0.00410857f, 
    0.01119915f, -0.02703691f, -0.04042625f, -0.04688555f, -0.00311398f, 0.02103111f, -0.00350159f, 0.02389793f, 
    -0.05492221f, -0.01262204f, -0.00386452f, -0.02332478f, -0.05355225f, 0.03291809f, -0.01845339f, -0.05770069f, 
    0.03832224f, -0.03672987f, 0.01456358f, -0.04094557f, 0.01432719f, -0.02553792f, 0.02490453f, -0.02513544f, 
    0.01405124f, -0.03793428f, 0.03317032f, 0.01720355f, -0.03277903f, -0.04371826f, -0.01428084f, -0.03941391f, 
    -0.04656841f, 0.02546123f, 0.01112589f, 0.00176456f, 0.01785142f, 0.02689134f, -0.01239003f, -0.02289756f, 
    -0.01345807f, -0.00979837f, 0.02610970f, -0.04757934f, -0.03266814f, -0.03211358f, -0.00913743f, 0.00543523f, 
    -0.03563106f, -0.02487928f, 0.01641513f, 0.00814958f, -0.01343427f, -0.00453578f, -0.04875806f, -0.03830762f, 
    0.03837811f, 0.03215772f, 0.02292453f, -0.01515929f, -0.02672218f, 0.04551843f, 0.03071546f, 0.04437128f, 
    -0.05308941f, -0.01554553f, -0.02117617f, -0.05610175f, -0.01821938f, -0.00973163f, -0.02996401f, -0.03511981f, 
    0.03994317f, 0.01012752f, -0.02869040f, -0.02333821f, -0.01923467f, -0.03406738f, 0.02906270f, -0.05125064f, 
    -0.04081657f, -0.01735554f, 0.04318163f, -0.03099531f, -0.02775000f, 0.00909775f, 0.03299300f, -0.03824016f, 
    0.02133136f, -0.03244496f, -0.04588246f, 0.04268344f, -0.02576525f, -0.04097103f, 0.01727679f, -0.03426603f, 
    -0.01692311f, -0.04174391f, -0.00368781f, -0.00663260f, 0.02361766f, -0.02109945f, -0.03856409f, -0.02811995f, 
    0.01978546f, 0.01686232f, 0.02120719f, 0.03277241f, -0.02983841f, 0.02577874f, -0.01506433f, 0.02246667f, 
    0.01124545f, -0.02050412f, 0.01518887f, 0.00174640f, 0.01999573f, -0.03668505f, 0.00348533f, -0.03181956f, 
    0.02231013f, -0.00114605f, 0.03939884f, 0.00176853f, -0.03010553f, -0.02577303f, -0.00830190f, 0.02090066f, 
    0.00733543f, -0.00030695f, 0.03192738f, -0.04459311f, -0.02320814f, -0.04778101f, 0.03590450f, -0.02228207f, 
    -0.05110279f, 0.03499420f, -0.02050867f, 0.01279337f, 0.04113832f, 0.03771110f, -0.03105234f, 0.03787025f, 
    0.03761882f, -0.02647225f, -0.00068604f, -0.02086820f, -0.01314158f, 0.02077384f, -0.02022831f, 0.03412240f, 
    -0.03218577f, 0.04209687f, 0.01514439f, 0.02963550f, 0.02398030f, -0.02897226f, -0.04400328f, 0.01437037f, 
    0.03701960f, 0.01602652f, 0.04326208f, 0.04159614f, -0.01094242f, 0.02158559f, -0.03014814f, -0.03346478f, 
    -0.01501564f, -0.04521536f, -0.01261816f, -0.01567977f, 0.05414900f, -0.03760385f, -0.02067507f, -0.04080207f, 
    0.00082759f, -0.02449457f, 0.02375670f, 0.02943206f, 0.03043338f, -0.04306571f, -0.03171792f, 0.01045713f, 
    0.00425588f, -0.01237565f, 0.04295111f, 0.02757116f, -0.01103534f, -0.01981057f, 0.04496947f, -0.01365703f, 
    -0.02856741f, -0.01974665f, -0.04953951f, -0.04856125f, -0.02166488f, -0.03618822f, 0.00028663f, -0.05127116f, 
    -0.00766199f, 0.04096089f, -0.02617765f, 0.01713850f, 0.03931061f, -0.01546007f, -0.01275225f, 0.01652140f, 
    0.04644343f, -0.03138034f, -0.02009015f, -0.04424247f, 0.02407776f, -0.01798340f, -0.04153798f, -0.00585505f, 
    0.03428845f, -0.03230695f, 0.04828729f, -0.05147914f, 0.00589568f, 0.03679647f, 0.00928935f, -0.04744695f, 
    0.02359471f, -0.04090784f, 0.04841073f, 0.01030755f, 0.05064816f, 0.02310048f, -0.04409717f, -0.00887153f, 
    0.00294642f, -0.02131720f, -0.00954292f, -0.02958867f, -0.01377476f, 0.02545258f, -0.00561008f, -0.05619267f, 
    -0.00891429f, -0.02856093f, 0.02593875f, -0.02526730f, 0.03598269f, -0.00659032f, 0.02232468f, 0.04150770f, 
    0.02934199f, -0.05053991f, -0.03526254f, -0.02004849f, 0.04002849f, 0.00495084f, -0.02174720f, -0.03898792f, 
    0.04006433f, 0.01592154f, -0.04715993f, -0.02780575f, -0.04973366f, -0.04549807f, -0.00661365f, -0.03323283f, 
    0.02050370f, -0.04387213f, -0.03239619f, -0.00904770f, 0.03744548f, 0.00088465f, 0.01346687f, -0.01660255f, 
    0.01540088f, 0.01480838f, 0.02709284f, -0.00343951f, 0.02068991f, -0.03396971f, -0.05295249f, 0.01282616f, 
    0.00291590f, -0.01599552f, -0.04196861f, 0.00634691f, 0.00590521f, -0.02223512f, 0.03733346f, -0.04231266f, 
    0.01035517f, 0.00956240f, -0.01951515f, -0.03120701f, 0.00166350f, 0.02584155f, 0.02442372f, -0.01461307f, 
    -0.04272772f, -0.00437830f, 0.02918919f, -0.00837252f, -0.03631452f, -0.01858781f, 0.02287816f, -0.05685169f, 
    -0.01215511f, 0.04515802f, 0.03038150f, -0.00407527f, -0.03509851f, -0.01940918f, -0.00864221f, 0.01731234f, 
    -0.01271012f, 0.00259000f, -0.03045747f, -0.02566305f, 0.00257804f, -0.05334871f, -0.03861884f, -0.03606751f, 
    0.00031315f, 0.01405343f, -0.03309388f, -0.01328514f, -0.00420312f, -0.03795528f, -0.01979823f, -0.01639849f, 
    0.04026695f, 0.01963729f, -0.01775189f, 0.01920259f, -0.01212979f, -0.04709609f, -0.00289268f, 0.00147894f, 
    -0.03518653f, -0.05137325f, -0.03419496f, 0.04201703f, -0.01648193f, -0.01019344f, -0.02655048f, -0.02479383f, 
    -0.00856138f, 0.02427913f, 0.04055298f, -0.01123179f, -0.03313727f, -0.04729803f, -0.01438379f, 0.04943275f, 
    -0.01877233f, 0.01320672f, 0.00297854f, -0.02765218f, 0.00459531f, 0.02849420f, 0.02698706f, -0.01633846f, 
    0.03265170f, -0.04933349f, -0.01421816f, -0.02131263f, 0.01130373f, 0.03376349f, 0.04086831f, 0.01494776f, 
    -0.02963204f, 0.02520893f, -0.01348378f, -0.03628451f, -0.00380799f, 0.00660933f, 0.04162201f, -0.04346400f, 
    -0.03913051f, 0.00455028f, 0.05165416f, 0.03702470f, 0.02877419f, -0.03425014f, 0.04012287f, -0.03318650f, 
    -0.02003347f, -0.01320694f, 0.01438635f, 0.02634540f, 0.04712471f, -0.00079037f, -0.02949795f, 0.02436022f, 
    0.00632975f, -0.04823710f, -0.03152964f, 0.00447914f, 0.00024509f, 0.02703993f, 0.03879759f, 0.00711942f, 
    -0.02048505f, -0.00331352f, -0.00845859f, -0.02907618f, -0.04407413f, 0.03289818f, -0.02557743f, -0.03893505f, 
    0.03382469f, 0.03484863f, -0.04192185f, -0.02111992f, 0.02725847f, -0.03362885f, -0.05839811f, 0.01909962f, 
    -0.04910615f, 0.02189553f, -0.00778212f, 0.04694216f, -0.05721622f, 0.01065474f, -0.03687732f, 0.02717408f, 
    -0.05529790f, -0.03568194f, -0.00075932f, 0.01193714f, -0.06395541f, -0.02779189f, -0.01148686f, -0.00159697f, 
    0.01674780f, -0.00157726f, 0.03610653f, -0.01811143f, 0.01711925f, 0.03700083f, 0.04233001f, -0.00867371f, 
    0.03505568f, -0.03893103f, 0.02098547f, -0.03889141f, -0.03896385f, -0.01520202f, 0.01046558f, 0.04317753f, 
    0.00691645f, 0.03431201f, -0.00846135f, -0.04740633f, -0.02476341f, 0.05103182f, -0.03116199f, -0.05220029f, 
    -0.00831613f, 0.03408815f, 0.04987580f, -0.01524137f, -0.00208700f, -0.01181133f, 0.04712899f, 0.01164863f, 
    -0.03218532f, 0.00934713f, 0.03813500f, 0.00263657f, -0.00969541f, -0.03636947f, 0.00013181f, 0.00499814f, 
    0.02268039f, 0.02661592f, -0.00332203f, -0.02892374f, -0.00851442f, 0.03761902f, -0.01299211f, 0.03909978f, 
    0.02128448f, 0.02294533f, 0.03720881f, 0.02394041f, -0.04142678f, -0.02185753f, -0.03552505f, -0.05193748f, 
    -0.06633943f, -0.05335895f, 0.01905612f, -0.00934267f, -0.02539027f, 0.01561632f, -0.01736315f, -0.01050711f, 
    0.01135445f, 0.03821112f, -0.04013010f, -0.04983644f, -0.06898637f, 0.01595986f, 0.04235823f, -0.03116849f, 
    -0.01387801f, -0.02597215f, -0.02156589f, -0.03961282f, -0.01201894f, -0.01233086f, 0.02342690f, -0.00246580f, 
    0.02169064f, 0.04333412f, 0.03677464f, -0.03713508f, -0.02866811f, -0.06697520f, -0.02832427f, -0.00598454f, 
    -0.06025504f, -0.01262915f, 0.00208463f, 0.00625143f, 0.02572222f, -0.03722969f, -0.00394433f, 0.01723685f, 
    0.00510937f, 0.01748795f, -0.02964977f, 0.00114988f, -0.00716423f, 0.02400153f, -0.05997340f, -0.00725496f, 
    0.02269499f, -0.04220380f, -0.01376192f, -0.04303493f, 0.02171209f, -0.01656045f, 0.02345951f, 0.03863362f, 
    -0.00450101f, -0.03338578f, -0.04269731f, -0.01286756f, -0.05297875f, -0.00860794f, -0.00271966f, -0.02779046f, 
    -0.00662565f, 0.04532695f, -0.05015729f, 0.02525874f, -0.01512182f, 0.00588214f, 0.00677254f, -0.02503329f, 
    0.02042678f, -0.05801205f, -0.03824388f, -0.02596362f, -0.04138345f, -0.00926116f, -0.02237469f, -0.01008422f, 
    -0.00015991f, -0.05495836f, -0.00575567f, -0.04801102f, -0.04980670f, -0.01103688f, -0.03274924f, -0.06722516f, 
    -0.02429347f, -0.03912493f, -0.00944263f, -0.03247634f, 0.01433951f, 0.02249368f, 0.02402316f, -0.05861082f, 
    -0.07196762f, -0.05269463f, -0.00802163f, -0.03067583f, -0.04115474f, 0.01503855f, 0.04188114f, 0.01737155f, 
    -0.06372494f, 0.02915457f, -0.02340442f, -0.05362873f, -0.05805178f, -0.01891946f, 0.02417962f, 0.05279965f, 
    -0.02661313f, 0.01368327f, 0.00716598f, -0.00501546f, -0.02150550f, -0.05651174f, 0.00711031f, 0.01625808f, 
    0.03122148f, 0.02696930f, 0.02401033f, 0.00328907f, 0.01911225f, -0.01619664f, 0.02328743f, -0.03765260f, 
    -0.04664250f, -0.01836559f, -0.01563635f, 0.03509006f, -0.00440786f, -0.02441452f, -0.00886701f, 0.03661848f, 
    -0.07099056f, -0.03697169f, 0.02452729f, 0.00472804f, -0.01215632f, -0.02748749f, -0.00443845f, -0.04008698f, 
    -0.04575031f, 0.02855188f, -0.04446148f, -0.01717458f, -0.06317582f, -0.02356409f, -0.00923848f, -0.01768825f, 
    -0.07474902f, 0.02508817f, -0.04427341f, -0.05377768f, -0.05286459f, -0.04257052f, -0.02129584f, -0.04490197f, 
    -0.00358403f, 0.01665644f, 0.00857204f, -0.04439337f, -0.00241891f, -0.00319882f, -0.00130373f, -0.03944112f, 
    -0.05669878f, -0.05389761f, -0.03182871f, -0.02645539f, 0.00265425f, 0.02364080f, 0.01471455f, -0.04233745f, 
    0.01510667f, -0.04967434f, 0.00004737f, -0.02398416f, -0.03749485f, -0.04103130f, 0.04726933f, 0.03874422f, 
    -0.06264503f, -0.00879966f, 0.03326460f, -0.01690585f, -0.04205784f, -0.02041709f, -0.01915743f, -0.04462207f, 
    -0.05905682f, 0.05601597f, -0.02545739f, -0.04100955f, 0.01943541f, 0.04454855f, -0.00802398f, 0.02644578f, 
    0.01005566f, -0.05567080f, 0.03627029f, -0.05909945f, -0.00576455f, 0.00491990f, -0.00356390f, -0.02749671f, 
    0.00088203f, -0.01088926f, -0.01919170f, -0.03150447f, -0.04614176f, -0.02509863f, -0.02530194f, -0.05600420f, 
    0.01362220f, 0.01822910f, -0.03149303f, 0.04963903f, -0.00236400f, 0.01592991f, -0.00381069f, -0.04894581f, 
    -0.05427599f, -0.06019441f, -0.05849448f, -0.00461177f, 0.03186173f, -0.04427453f, -0.02318775f, -0.01052650f, 
    -0.04375990f, 0.00533621f, -0.02255958f, -0.06823657f, -0.03946675f, 0.03527741f, -0.03612085f, 0.01424276f, 
    -0.05192243f, 0.00165261f, 0.02805681f, -0.06164720f, -0.02508421f, 0.02231215f, -0.03741903f, -0.01626537f, 
    0.02873970f, -0.00671621f, -0.01349266f, -0.05701941f, -0.04213662f, -0.01967620f, -0.01381512f, -0.06820099f, 
    0.04294787f, -0.01757399f, -0.03068826f, -0.05920811f, 0.03427451f, -0.00382046f, -0.00490458f, -0.03120231f, 
    -0.02188524f, -0.00513245f, 0.03479677f, 0.04047287f, -0.00200864f, -0.01846745f, 0.02031520f, 0.04934268f, 
    -0.00455193f, 0.00729834f, 0.02706556f, -0.05902573f, -0.00605850f, -0.01632708f, 0.03794004f, -0.02583539f, 
    0.00289979f, -0.00836130f, -0.01380035f, 0.03174920f, 0.02280258f, 0.03737206f, -0.01097875f, 0.04032124f, 
    -0.06612006f, 0.02468336f, 0.02353461f, -0.04045958f, -0.06799650f, -0.02400717f, 0.02452736f, -0.00315430f, 
    -0.05169854f, -0.00021208f, -0.03973702f, -0.05845596f, 0.03908942f, -0.02798375f, 0.04258583f, -0.01046472f, 
    -0.03385135f, 0.01013331f, -0.01438116f, 0.00142149f, 0.02543817f, -0.02205185f, 0.00753643f, -0.02411738f, 
    0.00719344f, 0.02667693f, -0.03459267f, 0.03597543f, -0.03721758f, -0.02573809f, -0.04259650f, -0.02176948f, 
    -0.04355589f, -0.02259454f, -0.02358028f, 0.00231900f, -0.00005997f, 0.03550244f, -0.02677864f, -0.02821422f, 
    -0.04800851f, -0.00112165f, 0.03669191f, -0.03693164f, 0.01000889f, -0.04388397f, -0.00247315f, 0.00540476f, 
    -0.02172825f, 0.00211365f, -0.04127389f, -0.00142920f, 0.00436776f, -0.03843514f, -0.05335437f, 0.01731339f, 
    0.01161565f, 0.02489320f, 0.01831063f, -0.00599151f, 0.01347852f, -0.00389198f, -0.00889853f, 0.01975653f, 
    0.03702687f, -0.03681471f, -0.03277470f, -0.04379361f, -0.04520440f, 0.01719233f, 0.00334764f, 0.01830705f, 
    -0.02948689f, -0.02818429f, 0.01490958f, 0.01652034f, 0.00422927f, -0.02788475f, -0.04233110f, -0.01503065f, 
    -0.03260989f, 0.00261075f, -0.03325085f, -0.04689838f, -0.03297395f, -0.04673798f, 0.02424448f, 0.00856770f, 
    0.00405584f, 0.01278305f, -0.04955580f, -0.04324323f, 0.02723672f, 0.00490840f, -0.00228844f, -0.04586850f, 
    -0.05916223f, -0.03078748f, -0.01930279f, -0.05753127f, 0.01528656f, 0.00073921f, -0.02673782f, 0.02342564f, 
    -0.00508364f, -0.02164921f, -0.05093001f, 0.02113988f, 0.02065962f, -0.02112180f, 0.03301294f, -0.03167083f, 
    -0.00240001f, 0.02472578f, 0.03261967f, -0.03861742f, 0.01989301f, -0.04538663f, -0.00781034f, 0.03907177f, 
    -0.05607103f, 0.04471365f, -0.01080415f, -0.04307653f, 0.04320248f, 0.03064990f, -0.02007743f, -0.05142239f, 
    -0.01106912f, -0.04428816f, 0.01190867f, -0.05688743f, -0.00477822f, -0.01384772f, -0.01020387f, -0.02293974f, 
    0.03400998f, 0.00898196f, -0.00315668f, -0.00866736f, 0.03303001f, 0.01169115f, 0.04396958f, 0.04722451f, 
    -0.01387112f, -0.05019315f, -0.00180582f, -0.00611290f, 0.04301806f, -0.04438723f, -0.04132494f, -0.04372680f, 
    -0.02907591f, -0.00427553f, -0.04964615f, -0.02400948f, 0.03393588f, 0.02242286f, 0.00624772f, -0.03602114f, 
    0.02323125f, -0.02466928f, -0.01988669f, -0.00445185f, -0.02018286f, 0.01532464f, -0.01768653f, -0.03330427f, 
    0.03771360f, -0.03268721f, -0.03068230f, -0.03158886f, -0.03967245f, -0.03343791f, -0.04793118f, 0.00189094f, 
    -0.05604843f, -0.00415486f, -0.04379464f, -0.01758073f, -0.01319994f, -0.02134907f, -0.01494706f, -0.01922128f, 
    -0.01671331f, -0.01595980f, 0.02025575f, -0.04907358f, 0.00588543f, 0.00661433f, -0.05616187f, 0.00526605f, 
    -0.03498478f, -0.03345428f, -0.02528013f, -0.01999348f, -0.05041089f, 0.04220191f, 0.01422086f, -0.01429626f, 
    -0.03175138f, 0.03295544f, 0.03569176f, -0.05513073f, 0.02031689f, 0.00324125f, 0.02966626f, 0.01512724f, 
    -0.01156315f, 0.02804646f, 0.00297998f, -0.00050667f, 0.03574484f, -0.01658603f, -0.00708266f, 0.01836400f, 
    0.01674657f, 0.00045790f, -0.04536054f, 0.00968396f, 0.03414151f, 0.03941412f, -0.00648494f, -0.05388162f, 
    0.01845531f, -0.03196551f, 0.04313942f, -0.03179734f, -0.01857793f, 0.01961670f, 0.02464215f, -0.01270381f, 
    0.02311637f, 0.03857857f, 0.00404241f, -0.04155915f, -0.04634527f, -0.02096533f, 0.03360930f, -0.05524627f, 
    0.02358025f, 0.00390516f, -0.02927251f, -0.01428850f, -0.00462237f, -0.02565183f, -0.03307656f, -0.01403267f, 
    0.03945142f, -0.02583696f, -0.00410253f, 0.01200050f, 0.03473056f, 0.01328285f, -0.00214537f, 0.01149589f, 
    -0.04226609f, -0.03346649f, -0.02687708f, -0.00557261f, 0.02164820f, -0.00001808f, -0.00598884f, 0.02893646f, 
    -0.00868012f, 0.01467691f, -0.01743150f, 0.00494853f, -0.02802635f, -0.02654844f, 0.04966824f, 0.04011767f, 
    -0.04018595f, 0.01561187f, -0.01020430f, -0.02752794f, -0.04038103f, -0.00317403f, 0.04363969f, -0.01094510f, 
    0.02469622f, 0.01573915f, 0.01114740f, 0.00137391f, -0.01761349f, -0.00255405f, 0.02966046f, -0.05316231f, 
    0.02094810f, 0.02626987f, -0.00122799f, -0.04586719f, -0.02362299f, 0.02552901f, 0.04188005f, -0.03158087f, 
    0.04668169f, 0.00191999f, -0.00119122f, -0.01184849f, -0.02423759f, 0.01263077f, 0.01087236f, 0.03385117f, 
    0.04142441f, -0.01038371f, -0.04988046f, -0.02732450f, -0.05624776f, 0.04219003f, 0.01320692f, 0.02591437f, 
    0.03609184f, -0.00589840f, -0.00399579f, 0.04879343f, 0.02710878f, -0.03442768f, -0.00948024f, 0.03090333f, 
    -0.02086820f, -0.00156731f, 0.02886638f, 0.03401641f, -0.04000362f, -0.02631174f, -0.04910491f, 0.03079685f, 
    -0.02600408f, 0.01118875f, 0.00172391f, -0.02328262f, -0.03690165f, 0.00848195f, -0.01597162f, -0.00732014f, 
    -0.01130572f, -0.05168490f, -0.03721254f, -0.02668026f, -0.00743060f, -0.02938486f, 0.00377770f, 0.03199675f, 
    -0.00569482f, 0.02557546f, 0.02282906f, -0.03348447f, -0.02156624f, 0.00078022f, 0.02710821f, 0.03983490f, 
    0.01907413f, -0.01262566f, 0.03836881f, 0.01298322f, 0.00178941f, 0.01446755f, -0.02707311f, -0.01258746f, 
    -0.04717673f, -0.04610274f, -0.01355360f, -0.03945084f, -0.01073563f, 0.01098732f, 0.03126924f, -0.02346132f, 
    -0.04089418f, 0.02244649f, -0.03640364f, 0.01670816f, 0.00179665f, 0.01343016f, -0.00100689f, 0.00473615f, 
    0.04811733f, -0.01145584f, 0.00561498f, 0.02904754f, -0.01690610f, 0.00672788f, 0.00687439f, 0.04996808f, 
    0.00374632f, -0.00002630f, -0.04118087f, -0.04807142f, -0.04094753f, 0.01350867f, 0.03453328f, 0.00272406f, 
    0.31980938f, -0.14587505f, -0.15352868f, -0.27552330f, 0.05575384f, -0.11651307f, 0.13654232f, 0.04402623f, 
    0.02684458f, -0.00043140f, 0.10026897f, -0.08055582f, 0.33928993f, 0.33507997f, -0.11706091f, -0.31003720f, 
    0.18036813f, -0.07032657f, -0.00385685f, -0.21359506f, -0.05230573f, 0.03532078f, 0.03062156f, 0.06641518f, 
    -0.04473661f, 0.02564999f, 0.23500669f, -0.10510057f, 0.03155664f, 0.07210810f, 0.07845718f, -0.15257683f, 
    0.04888634f, 0.03645687f, -0.00200802f, -0.02405013f, -0.39536232f, -0.06185944f, -0.00028774f, 0.25110877f, 
    -0.19214562f, 0.06684950f, -0.01679905f, 0.11768112f, 0.00236373f, 0.00085531f, 0.14067499f, -0.13681482f, 
    0.22176598f, 0.02191189f, 0.20430392f, -0.07579049f, 0.02779918f, -0.00738210f, -0.02026532f, 0.05006218f, 
    0.03379047f, 0.08516934f, -0.07765960f, -0.01022751f, 0.43352643f, -0.14327420f, 0.10485520f, 0.20436221f, 
    0.16871636f, -0.00198786f, -0.03188324f, 0.02668929f, 0.01380947f, -0.05098767f, 0.08034290f, -0.04486540f, 
    -0.26173508f, -0.29024473f, 0.20052277f, 0.18320462f, 0.11586563f, -0.08053468f, 0.22496924f, -0.06396107f, 
    0.15445222f, -0.01188015f, -0.03746233f, -0.00964769f, 0.04787262f, -0.04596465f, -0.03315490f, -0.10542873f, 
    0.13647251f, 0.02677611f, -0.00814628f, -0.11890323f, -0.07183231f, -0.12969415f, 0.05554605f, -0.04015183f, 
    -0.23253965f, -0.04836673f, 0.01571555f, -0.03620270f, -0.08014804f, 0.00513735f, 0.13542129f, 0.01552161f, 
    -0.08094238f, 0.02195257f, 0.05854775f, 0.09115379f, -0.08321057f, -0.07261428f, 0.28214481f, 0.29020444f, 
    -0.11018217f, 0.05585117f, 0.02480385f, -0.09654438f, 0.00851265f, 0.12547152f, -0.03066487f, 0.14051890f, 
    0.26460049f, -0.12351292f, -0.30684802f, -0.11175378f, -0.06032543f, -0.01092082f, -0.12870191f, 0.03198256f, 
    -0.19499277f, 0.00863453f, 0.04367787f, 0.09617789f, 0.16866925f, 0.02929093f, -0.01374723f, -0.02180678f, 
    -0.03882222f, 0.02785003f, 0.07497295f, -0.01786694f, 0.04484416f, 0.06070448f, 0.08445279f, -0.01048050f, 
    -0.06058253f, 0.16638869f, -0.05469577f, -0.09205176f, 0.08153421f, 0.09191786f, -0.03004495f, -0.05839164f, 
    0.06256650f, 0.02957471f, 0.00975319f, -0.00000755f, -0.54509252f, 0.15308373f, -0.08614220f, 0.15413630f, 
    0.06011880f, 0.10538793f, -0.07089485f, 0.01211968f, 0.10175118f, 0.08153524f, -0.05685540f, 0.04570162f, 
    0.47604033f, 0.22088605f, 0.15256119f, -0.16425787f, 0.12890381f, 0.01312356f, -0.01998327f, -0.04763389f, 
    0.03454138f, 0.08842646f, -0.19116174f, -0.03396875f, 0.01055806f, 0.05858157f, 0.08898070f, 0.08363921f, 
    0.06283667f, 0.07571841f, -0.02867662f, 0.01219901f, 0.15882532f, -0.00288747f, 0.04968378f, -0.14710167f, 
    0.62809181f, 0.11799476f, -0.17461263f, 0.12300343f, -0.00648669f, -0.02726558f, -0.00802429f, 0.01384808f, 
    0.08006521f, -0.02199503f, 0.09118606f, -0.07302224f, 0.28028029f, -0.22700824f, 0.33791178f, -0.04120025f, 
    0.00016119f, -0.02226608f, -0.00386115f, -0.03718787f, -0.03044826f, 0.05161675f, -0.06978583f, 0.04054650f, 
    0.22406186f, -0.05478608f, -0.02296888f, -0.03587531f, 0.06122528f, -0.07662487f, -0.00697553f, 0.12218054f, 
    0.01593775f, -0.06345434f, -0.14905280f, -0.00878538f, 0.16748813f, 0.22315085f, 0.04385928f, 0.16057764f, 
    0.09647042f, -0.08556588f, 0.01364601f, -0.00322354f, 0.15792601f, -0.01794687f, 0.00095324f, 0.01468572f, 
    0.29737261f, 0.34828532f, 0.08172920f, 0.14141998f, 0.13089864f, -0.14657855f, -0.09927239f, 0.09672632f, 
    -0.04041277f, -0.00649217f, -0.05632223f, 0.00837908f, -0.19789538f, 0.17667362f, -0.10401730f, -0.16088900f, 
    0.12050453f, -0.02754856f, 0.07066675f, -0.13459207f, 0.06454632f, -0.04943465f, -0.00583586f, -0.03711010f, 
    0.51878077f, 0.33098876f, -0.27439198f, 0.18484066f, -0.09191646f, -0.13239419f, -0.02966316f, 0.11695837f, 
    0.05200183f, 0.04821465f, 0.04605396f, 0.20503207f, -0.10068732f, 0.04350232f, -0.06709698f, 0.06430732f, 
    -0.06491146f, -0.02958396f, 0.02484150f, 0.04946218f, 0.02719121f, -0.21470480f, 0.08425015f, 0.04704975f, 
    0.06834382f, 0.16857235f, -0.09054358f, -0.23685886f, 0.02585711f, 0.07133909f, 0.02864176f, -0.13931213f, 
    0.07079935f, -0.00919196f, 0.10601731f, -0.05347669f, -0.24092242f, 0.08436727f, -0.04954205f, -0.08338448f, 
    0.11198253f, 0.08490089f, 0.03552741f, 0.02682444f, 0.04456563f, 0.00349319f, -0.04236588f, -0.15892997f, 
    0.51329982f, 0.18524295f, -0.10291764f, -0.14657009f, 0.08873381f, -0.10345774f, 0.00577498f, -0.04872895f, 
    0.07878619f, -0.04003846f, 0.02244587f, 0.04942072f, -0.18895493f, 0.33808899f, -0.09783246f, -0.01429306f, 
    -0.06036822f, -0.04497357f, 0.03967207f, -0.05916602f, 0.02665409f, -0.09628581f, -0.02127821f, -0.00004754f, 
    -0.11594340f, -0.20686749f, -0.16634181f, -0.18385816f, -0.01180172f, -0.11397088f, 0.03643329f, -0.01493905f, 
    -0.19266830f, 0.00144199f, -0.09870021f, -0.03209980f, 0.38818654f, -0.09861512f, 0.17167559f, 0.13336675f, 
    0.09010705f, 0.12386356f, -0.04417579f, 0.03433767f, -0.11542276f, 0.13244355f, 0.06506149f, 0.20681199f, 
    0.28898361f, 0.00233120f, -0.26340514f, 0.15367340f, 0.17582305f, -0.08127616f, -0.07692157f, 0.06769785f, 
    -0.00057700f, 0.00471786f, -0.02876204f, -0.12318051f, -0.33296326f, -0.29539251f, 0.10184906f, 0.01472367f, 
    -0.10924041f, -0.03130623f, 0.02078998f, -0.01470304f, -0.05144916f, -0.06841904f, -0.11151789f, -0.08639377f, 
    0.13363117f, -0.18615754f, -0.09691405f, -0.00009191f, 0.00020887f, -0.05499454f, -0.06053326f, 0.03047871f, 
    -0.14861602f, 0.12506783f, -0.01566041f, 0.02482982f, -0.16032884f, -0.23088141f, 0.05341037f, 0.01237375f, 
    0.06393337f, 0.04463195f, 0.05843788f, -0.00028423f, -0.01224338f, 0.13684355f, 0.04764350f, -0.05113643f, 
    -0.06768882f, 0.19849205f, -0.05836145f, -0.15105960f, 0.00584829f, -0.00086822f, -0.12411937f, 0.12920801f, 
    0.00469259f, -0.05267281f, 0.02079635f, -0.11856036f, -0.08219477f, 0.16199917f, 0.03086818f, -0.11505903f, 
    -0.07254918f, -0.06646966f, -0.08059912f, -0.08554788f, 0.06137225f, 0.01685512f, -0.12077139f, -0.02350244f, 
    -0.29328859f, 0.01181887f, 0.22916405f, 0.07534496f, -0.17623921f, 0.04638281f, 0.14802264f, -0.03280480f, 
    -0.10035499f, -0.04594981f, 0.05742829f, -0.15876478f, 0.13071993f, -0.25407806f, -0.18635291f, -0.00157663f, 
    -0.10553421f, -0.07478040f, 0.11199480f, 0.12711707f, 0.07837708f, 0.10958900f, -0.02475045f, 0.00543883f, 
    0.58627850f, 0.06010281f, -0.02962569f, 0.24766278f, -0.10002802f, -0.01168207f, -0.09093783f, -0.03048731f, 
    -0.02827196f, 0.00713671f, 0.16104440f, 0.02634178f, 0.17868873f, 0.05694421f, 0.05527624f, -0.07402959f, 
    -0.06197530f, -0.00609949f, 0.08284888f, -0.00792754f, 0.04610186f, 0.06098427f, -0.19200039f, 0.04656927f, 
    -0.23725018f, -0.10396095f, 0.26422921f, 0.18541907f, -0.00210135f, 0.00371120f, -0.16873087f, 0.15592942f, 
    0.01248096f, -0.17949706f, -0.13311838f, -0.12071177f, -0.01215008f, -0.01154017f, -0.02963805f, -0.00330878f, 
    -0.12827560f, 0.12008193f, 0.03553655f, 0.01536584f, -0.02340991f, 0.05028025f, -0.07646549f, 0.02379278f, 
    -0.01202310f, -0.09771857f, 0.13870339f, 0.15411498f, 0.00496377f, 0.10440680f, -0.13378561f, -0.11027557f, 
    -0.04435698f, -0.06295108f, -0.07034448f, -0.26191607f, -0.15546635f, -0.00408111f, 0.10797077f, 0.21323553f, 
    0.03658971f, -0.08712181f, -0.04571923f, -0.00881127f, -0.15674002f, -0.12966461f, -0.07927018f, -0.18939905f, 
    -0.02888129f, 0.28801295f, 0.10108391f, -0.03122392f, 0.07866964f, 0.04876510f, 0.11794796f, 0.03452212f, 
    -0.05002210f, -0.01176889f, -0.14393808f, 0.01202985f, -0.03265554f, 0.00615717f, 0.19843613f, -0.02742308f, 
    -0.13494489f, 0.20651197f, -0.03132043f, -0.04294112f, -0.04996469f, -0.04466302f, 0.11316703f, -0.17741273f, 
    -0.05559352f, -0.14623500f, -0.15703234f, 0.36730349f, 0.09188212f, -0.18392460f, 0.14713912f, -0.03115024f, 
    -0.06368738f, 0.09297522f, -0.01712464f, 0.07584695f, 0.04314481f, 0.04277492f, 0.14218478f, 0.13981098f, 
    0.03757453f, 0.07486344f, -0.08081426f, 0.17114106f, 0.03869933f, 0.04545055f, -0.05685223f, 0.09421849f, 
    0.14516319f, 0.08763127f, 0.04821530f, 0.04451219f, -0.11364495f, 0.01496659f, 0.04525229f, 0.05218967f, 
    0.04434551f, 0.08110881f, -0.07371434f, 0.04041279f, 0.14552207f, -0.08095212f, -0.07110985f, -0.07835317f, 
    -0.11044369f, 0.02522237f, 0.08481036f, 0.13374656f, -0.11561906f, 0.00885564f, 0.02499202f, 0.04515038f, 
    -0.37280884f, -0.02489596f, -0.02836248f, -0.00604908f, 0.19207057f, 0.01015314f, -0.02437878f, -0.00383202f, 
    -0.06499224f, 0.04476900f, 0.19990280f, -0.08961339f, 0.19679800f, 0.04117679f, 0.09019183f, 0.03189796f, 
    0.03148708f, 0.11713408f, 0.02824240f, -0.00554037f, -0.01990725f, -0.19530779f, -0.00774619f, 0.01019420f, 
    0.32630965f, 0.04744694f, 0.09630807f, -0.05133836f, -0.00991014f, 0.19070433f, 0.07904583f, 0.00094399f, 
    -0.06676491f, 0.00446732f, 0.15473087f, -0.11103897f, 0.19486128f, 0.17366390f, -0.05100680f, 0.27958238f, 
    -0.15093666f, -0.18052053f, 0.08997206f, -0.03821226f, 0.02104088f, 0.14730921f, 0.02147225f, -0.04000283f, 
    0.15621521f, 0.24080049f, 0.03281112f, 0.27030176f, -0.15076402f, -0.06896128f, 0.02553333f, 0.05712949f, 
    0.04392659f, -0.10400893f, -0.16048536f, -0.28970212f, -0.07846709f, 0.03226792f, 0.06546509f, 0.01946690f, 
    0.03332216f, 0.07152431f, -0.06170816f, 0.02953746f, 0.00188304f, 0.13214545f, -0.31618148f, -0.11667987f, 
    0.34401134f, -0.17255422f, 0.04160855f, 0.05978215f, -0.05311625f, 0.13021669f, 0.01777170f, -0.06645350f, 
    -0.01678501f, -0.10567684f, -0.14792491f, -0.02419900f, -0.12759185f, 0.40978795f, -0.02662314f, 0.09069791f, 
    -0.03027287f, -0.17218338f, 0.09312310f, 0.06436411f, 0.07259888f, 0.05584345f, 0.16643640f, 0.09023623f, 
    0.31297582f, -0.02831399f, -0.02158905f, -0.10930782f, -0.18160568f, 0.03723066f, 0.09995613f, 0.09971863f, 
    0.02938236f, 0.08163743f, 0.06072371f, 0.03504612f, -0.29526365f, 0.23811477f, 0.15742932f, 0.03112430f, 
    0.03515354f, 0.06259763f, 0.06447521f, -0.06152352f, -0.04304595f, 0.06620877f, 0.04135976f, 0.13864727f, 
    0.06672604f, 0.06742181f, 0.01760122f, 0.17262150f, 0.12531042f, 0.01110532f, -0.12900393f, 0.08122054f, 
    0.08817849f, -0.09585854f, 0.01682974f, -0.02579787f, -0.00837062f, -0.29657900f, -0.04138654f, 0.06545356f, 
    -0.03452187f, -0.02458984f, 0.11914930f, 0.18045372f, 0.11477717f, -0.04558655f, -0.01759938f, -0.19020104f, 
    0.27725971f, 0.27279282f, -0.07581749f, 0.15969835f, -0.05985875f, 0.17353892f, 0.03422680f, 0.18895222f, 
    0.01850348f, 0.05903862f, 0.16208974f, -0.07959890f, 0.32907328f, 0.01081330f, -0.20718467f, 0.02846681f, 
    -0.00046129f, 0.19155899f, -0.23357092f, 0.07307819f, -0.15529248f, -0.08885688f, -0.12978303f, -0.08816803f, 
    0.04200396f, -0.00369495f, 0.02945472f, -0.03137457f, -0.02754316f, -0.00009391f, -0.03694544f, -0.00082859f, 
    0.04265403f, 0.00696542f, 0.03771749f, -0.02823162f, -0.01256287f, -0.02231490f, 0.00838449f, 0.03078032f, 
    -0.00488948f, 0.02477804f, -0.00311741f, 0.00176187f, -0.03065480f, 0.00095398f, -0.03911190f, 0.02552504f, 
    -0.02367757f, 0.01960565f, -0.01474956f, -0.01686178f, 0.01960719f, -0.03410730f, -0.02085524f, 0.02013565f, 
    -0.01271404f, 0.00036209f, 0.00986359f, -0.04735102f, -0.04170658f, -0.01712902f, -0.00960581f, -0.02557860f, 
    0.00056727f, -0.05010789f, 0.00850741f, 0.00165322f, -0.02422216f, -0.05154882f, -0.03151638f, -0.00517318f, 
    -0.02335675f, -0.00535309f, 0.01934380f, -0.00943685f, 0.02742480f, 0.01143500f, 0.01570197f, 0.01385061f, 
    0.02305489f, -0.04495978f, -0.04981462f, -0.03780277f, -0.01977634f, 0.04806225f, -0.01845245f, 0.02682850f, 
    0.00902188f, -0.05147192f, 0.02178252f, 0.02054515f, -0.03673982f, 0.00456433f, 0.00663273f, -0.03735641f, 
    -0.04536593f, 0.03106865f, 0.04231004f, 0.01510886f, 0.01469185f, 0.02953627f, 0.04473051f, -0.01886558f, 
    0.02254736f, 0.00606853f, 0.03485375f, -0.00606293f, 0.04463707f, 0.01548452f, -0.02838263f, 0.00414082f, 
    0.03383144f, 0.03967971f, 0.02826855f, 0.02422057f, -0.00955399f, -0.01038026f, 0.00854422f, -0.01853703f, 
    0.02644067f, -0.03589800f, -0.04182638f, 0.02619451f, -0.03919034f, -0.02077701f, -0.00902483f, 0.01511082f, 
    -0.00076595f, 0.02677395f, -0.03493576f, 0.03969591f, 0.01192846f, 0.03782595f, -0.05464586f, -0.00884121f, 
    -0.02935683f, 0.00242127f, -0.04888348f, -0.04306700f, 0.03604684f, -0.01064704f, -0.00486950f, 0.00309845f, 
    -0.00570714f, -0.00000583f, -0.05856058f, -0.00631920f, -0.04990034f, 0.01962694f, 0.01381984f, -0.01881812f, 
    -0.00068363f, 0.04367735f, -0.00386990f, -0.00671090f, -0.01850779f, -0.03315751f, -0.01299778f, -0.03203291f, 
    -0.04760194f, 0.00683541f, -0.03662598f, -0.03946611f, 0.01773739f, 0.02034675f, -0.00648446f, 0.03514181f, 
    0.02034641f, -0.01921344f, -0.04921648f, 0.01468731f, 0.02748532f, 0.02241362f, -0.00968261f, 0.02886848f, 
    0.03248383f, -0.03724310f, -0.04456397f, 0.00344782f, -0.02357954f, -0.01225100f, 0.03588571f, -0.05532371f, 
    0.01638281f, 0.01532783f, 0.00766704f, 0.01837450f, 0.03783798f, -0.03221174f, -0.02114961f, 0.02996816f, 
    -0.00682404f, -0.03025735f, -0.00410841f, 0.02976859f, 0.02626934f, 0.02080566f, 0.03060545f, -0.01158477f, 
    -0.02785472f, -0.02799048f, 0.03442758f, -0.04729711f, -0.00731132f, 0.01237127f, -0.05694531f, 0.02121502f, 
    0.02872091f, -0.00655620f, 0.01539657f, -0.04150453f, -0.04190665f, -0.02894520f, -0.00591011f, -0.05882922f, 
    -0.01266853f, 0.00882762f, -0.01232215f, -0.05407839f, 0.01224440f, 0.03253678f, -0.04191944f, 0.00022972f, 
    -0.05394163f, -0.03196552f, 0.00627585f, 0.01137959f, -0.04275985f, 0.01437971f, 0.01718515f, -0.02177260f, 
    -0.03705176f, 0.02260922f, 0.04379131f, 0.01425458f, -0.01286304f, -0.02621850f, -0.05432840f, 0.01845532f, 
    -0.03446194f, 0.00262579f, -0.00802059f, -0.02421488f, -0.00405897f, -0.05598551f, -0.01521266f, -0.00537295f, 
    0.00196857f, 0.00078164f, -0.01389014f, -0.01298370f, 0.00104337f, 0.04728021f, -0.02966147f, 0.00220874f, 
    -0.02954915f, 0.03475779f, 0.03303565f, -0.05075547f, -0.02524475f, -0.05077277f, -0.01622187f, -0.03945093f, 
    0.00592351f, 0.03184952f, 0.01018266f, -0.02022011f, 0.00507001f, -0.04885636f, -0.00706895f, 0.01943824f, 
    0.03659876f, -0.00637336f, 0.01599984f, 0.01629112f, -0.01817300f, 0.00494672f, -0.00288143f, -0.01574178f, 
    -0.05111456f, -0.00297833f, 0.03446517f, 0.00168910f, 0.02527982f, 0.01577073f, -0.05571847f, 0.02123196f, 
    0.00246060f, -0.02040485f, 0.03276963f, -0.00249875f, -0.03663735f, 0.02962018f, -0.05520972f, -0.05055071f, 
    -0.04175213f, -0.04454437f, -0.00200769f, 0.02034581f, -0.03111998f, -0.00050069f, 0.02881842f, 0.03019431f, 
    0.02772933f, 0.03497396f, 0.01423673f, -0.02642994f, -0.03492722f, 0.02554656f, -0.03029450f, -0.05045690f, 
    0.02025817f, -0.04850018f, 0.00771597f, -0.02939871f, -0.01881331f, 0.03872510f, -0.02646316f, -0.03490693f, 
    -0.00044993f, 0.01896325f, 0.01115029f, -0.03964526f, -0.05937995f, -0.05147579f, -0.03946370f, 0.03347746f, 
    -0.02197664f, 0.03332867f, -0.01483382f, -0.00055239f, -0.05173627f, 0.04057071f, -0.04965552f, 0.02301897f, 
    -0.04269166f, -0.03112578f, 0.01187489f, -0.00749342f, -0.05292284f, 0.01391846f, -0.04405056f, 0.02957634f, 
    0.01915427f, -0.00206400f, 0.02525973f, 0.01229519f, -0.03002771f, -0.03535396f, -0.01057341f, 0.00410030f, 
    0.00730892f, -0.02422008f, 0.00950256f, -0.00522371f, 0.01687702f, -0.02592291f, 0.02272328f, -0.00659612f, 
    0.02844500f, 0.00406814f, -0.04544393f, 0.03601832f, -0.05187492f, 0.01136122f, -0.02599479f, -0.01683916f, 
    -0.04364829f, 0.03536757f, -0.02486468f, 0.02707342f, -0.04213421f, -0.01505456f, 0.03664453f, -0.03915091f, 
    -0.00470576f, 0.01701823f, -0.00114700f, -0.02256442f, -0.01309918f, 0.00223800f, 0.03810930f, -0.01503792f, 
    0.02771706f, 0.02084008f, -0.01034693f, 0.01921711f, -0.04946199f, -0.01527671f, -0.03068930f, -0.02748268f, 
    -0.01187047f, -0.05826819f, 0.00127390f, -0.03995857f, -0.02659157f, 0.02655607f, 0.04003297f, -0.03899964f, 
    0.00155444f, 0.03821461f, -0.05810224f, -0.02726231f, 0.01627390f, 0.02939081f, -0.02079079f, 0.02969988f, 
    0.00985118f, -0.01219334f, -0.04529196f, -0.01300022f, -0.02657755f, 0.00095335f, 0.00861693f, 0.02916544f, 
    0.01727875f, 0.03700899f, -0.00487860f, -0.01518326f, -0.05768923f, 0.01943104f, -0.05448432f, -0.01139494f, 
    0.03165038f, -0.01344712f, 0.01642095f, 0.03191199f, 0.02058359f, -0.03917973f, -0.04426438f, -0.04891254f, 
    0.01810771f, 0.02169671f, -0.01728142f, 0.00591551f, -0.00934170f, -0.01083204f, -0.02678503f, -0.04977587f, 
    -0.00167531f, 0.01144013f, -0.03489572f, -0.05276705f, 0.00729319f, -0.00833200f, -0.03113792f, 0.02805494f, 
    0.02314500f, -0.01017975f, 0.03898254f, 0.03656285f, -0.01202657f, 0.03504127f, 0.03448186f, -0.01060671f, 
    0.03660572f, -0.02058596f, 0.00077477f, 0.03859425f, -0.03695064f, -0.06026645f, -0.05508596f, -0.04926529f, 
    -0.02370474f, -0.03787046f, -0.02914002f, 0.00931469f, -0.00278423f, -0.03996342f, 0.01094568f, 0.02547117f, 
    -0.05051985f, 0.00643249f, -0.00435326f, -0.04343589f, -0.04397528f, 0.01473697f, -0.04185338f, -0.02394804f, 
    -0.02608853f, -0.05009342f, 0.02609815f, -0.03981598f, -0.01881748f, 0.03534006f, -0.00894228f, 0.00947190f, 
    -0.05083149f, -0.00438378f, 0.02063592f, -0.01621483f, 0.01460809f, 0.01064237f, -0.01102082f, -0.00176405f, 
    0.00911788f, 0.00317551f, -0.00529700f, -0.04048288f, -0.03240135f, -0.00731204f, -0.01666558f, -0.04008695f, 
    0.02166688f, -0.00622949f, 0.02144269f, -0.00626666f, 0.00702545f, -0.02041341f, 0.00742725f, 0.02575100f, 
    -0.02408089f, -0.01441943f, -0.05279211f, -0.02896509f, -0.03341887f, 0.02400430f, -0.01249913f, 0.00782687f, 
    0.00242451f, -0.01997892f, 0.00276098f, -0.00529662f, 0.01644680f, -0.04445881f, 0.00400694f, 0.02650383f, 
    -0.01842095f, -0.00311996f, -0.04127378f, 0.02404379f, 0.02209577f, -0.01586076f, 0.01872079f, 0.00690323f, 
    -0.05530454f, 0.00598237f, -0.00400876f, -0.04094045f, -0.04704002f, -0.00227827f, 0.00032645f, -0.02825675f, 
    -0.05862638f, -0.04219706f, 0.00034824f, -0.00579620f, 0.03915028f, -0.01197054f, -0.01360245f, -0.03185803f, 
    0.03940113f, -0.01058767f, -0.02757251f, -0.04167686f, 0.01572786f, 0.01809070f, -0.05374087f, 0.04507840f, 
    -0.05262932f, -0.00161227f, -0.05507111f, 0.03888145f, -0.03676700f, -0.04496789f, -0.03980355f, 0.00115771f, 
    -0.05338499f, -0.01414987f, -0.04173406f, -0.03256238f, -0.00884913f, 0.01426472f, -0.02613683f, -0.04843966f, 
    -0.01908298f, -0.02391304f, -0.02026838f, -0.04333181f, -0.04586209f, -0.05431029f, -0.01912573f, 0.03741403f, 
    0.00928498f, 0.02231607f, -0.00106040f, 0.01675670f, -0.02286755f, 0.03325672f, 0.00274695f, 0.02557691f, 
    -0.01449275f, 0.02480638f, -0.04059688f, 0.00469688f, -0.02267117f, -0.04006098f, -0.05403380f, -0.02648317f, 
    0.01640971f, -0.03095274f, 0.02993512f, -0.02626402f, 0.00899526f, 0.00040579f, 0.03939070f, 0.03290021f, 
    -0.02457732f, -0.03408797f, -0.01840955f, -0.00400994f, 0.00912277f, -0.04046509f, 0.00154546f, -0.00116668f, 
    -0.02321402f, -0.00280529f, -0.00409637f, -0.00742890f, -0.03193107f, -0.04330409f, -0.04542228f, 0.03045900f, 
    -0.00962278f, -0.02258831f, 0.00199415f, -0.01003521f, -0.04344404f, 0.01686438f, 0.02058797f, 0.01578121f, 
    0.01345091f, -0.01691838f, -0.04917727f, -0.00347551f, 0.00676199f, 0.03071415f, 0.00231092f, -0.04262615f, 
    0.01777964f, -0.01147261f, -0.00448597f, -0.05052272f, -0.01259044f, -0.03827069f, -0.03042835f, 0.03478283f, 
    -0.03492895f, -0.03621840f, 0.01388532f, 0.03762441f, -0.04901107f, 0.04121547f, -0.01436988f, 0.01788678f, 
    0.03130546f, 0.03530482f, 0.02851526f, 0.01766282f, 0.03706552f, -0.00135582f, -0.02583787f, -0.02738430f, 
    -0.01524246f, -0.05086359f, -0.00578645f, 0.02843534f, -0.04774981f, 0.00529177f, 0.03021297f, 0.01802852f, 
    0.03991531f, -0.04931175f, -0.04736318f, -0.01207513f, -0.04026959f, -0.03914680f, 0.02373675f, 0.04515794f, 
    -0.01940108f, -0.02280486f, 0.00309254f, 0.00358380f, -0.02273167f, 0.01500672f, -0.03739747f, 0.01431428f, 
    0.02037208f, -0.03020602f, 0.01047255f, -0.04891709f, -0.01448913f, 0.02609223f, 0.01798301f, 0.03779297f, 
    -0.01513246f, -0.05145012f, 0.02073677f, 0.04279461f, 0.01293549f, -0.04248862f, -0.01507808f, -0.00967092f, 
    -0.04174228f, 0.03310809f, 0.01532080f, 0.03733604f, -0.03489097f, 0.01245653f, 0.02040442f, -0.04764224f, 
    0.02970126f, -0.02173894f, -0.00378136f, -0.04529206f, -0.05123122f, -0.05807392f, 0.01641957f, 0.00726979f, 
    0.00109385f, 0.04199092f, 0.01836497f, -0.01020054f, 0.03493445f, -0.04627514f, 0.02529128f, -0.00847863f, 
    -0.03948525f, 0.02852120f, 0.01296283f, 0.03451577f, 0.03129055f, -0.03721924f, -0.03750455f, -0.03455017f, 
    -0.05065934f, -0.00018570f, -0.05234664f, -0.05368124f, 0.00348935f, -0.00646660f, -0.02950700f, -0.04479993f, 
    0.01483150f, 0.00617564f, -0.02473350f, -0.00290328f, -0.04155180f, -0.00566097f, 0.03745776f, -0.00165128f, 
    0.01397353f, -0.06081557f, 0.01465828f, 0.03247436f, -0.01315755f, -0.05289138f, -0.03603741f, 0.02797092f, 
    -0.03080638f, -0.00559075f, -0.02274344f, 0.00312516f, 0.01529171f, -0.01899187f, -0.05141496f, 0.03708692f, 
    -0.04198789f, 0.03406315f, -0.02480682f, -0.01620409f, -0.01558345f, -0.02402695f, -0.01680536f, 0.02280466f, 
    -0.05726355f, -0.01036944f, -0.03665907f, 0.03935407f, 0.00497703f, 0.00974687f, -0.00964755f, 0.00425746f, 
    0.00835254f, -0.04924133f, -0.00851683f, 0.00312554f, 0.03558005f, -0.04286536f, 0.00375472f, -0.04383849f, 
    -0.30638230f, 0.20943952f, 0.30334082f, 0.14199245f, 0.12398776f, 0.17891482f, -0.05573327f, 0.03430793f, 
    -0.02810103f, -0.01017717f, -0.06168327f, 0.09642982f, -0.10709296f, 0.38643223f, 0.06561192f, 0.08456062f, 
    0.05101651f, 0.01420887f, -0.02407135f, 0.17472212f, 0.04780887f, -0.08568092f, -0.00517104f, -0.01141969f, 
    0.33246806f, -0.10586999f, 0.05971036f, 0.37771612f, 0.05007225f, -0.01387369f, -0.12905534f, -0.00796577f, 
    -0.00109693f, -0.01510882f, 0.03581406f, 0.01337234f, 0.39378357f, 0.13679731f, -0.03757956f, -0.02327508f, 
    0.17121081f, 0.11053809f, 0.05459790f, -0.05261543f, 0.05683228f, 0.08215327f, 0.07387909f, 0.11261401f, 
    0.28020346f, -0.03342722f, 0.07745182f, 0.16762535f, 0.09463011f, 0.02263984f, 0.13031441f, 0.08847282f, 
    0.06076937f, 0.03486703f, 0.02452585f, 0.09977663f, -0.19460712f, 0.22769402f, 0.00850863f, -0.04262350f, 
    0.12120391f, 0.02554494f, 0.01628545f, -0.14159980f, -0.13535418f, 0.03119965f, -0.00742610f, -0.08031115f, 
    -0.41812265f, -0.05395928f, 0.10099417f, -0.25460422f, 0.01798534f, 0.08925097f, -0.13413939f, -0.02820272f, 
    0.09494077f, -0.05141736f, 0.13931410f, -0.02954287f, 0.14346512f, -0.04241246f, 0.18256809f, -0.01462861f, 
    -0.07271653f, -0.09645758f, -0.00562705f, -0.04678693f, -0.11485394f, 0.02999082f, 0.02450603f, -0.01708884f, 
    0.18511194f, 0.06357611f, -0.28361994f, -0.11978390f, 0.08929474f, -0.01240843f, 0.15727688f, -0.18776634f, 
    0.00491329f, -0.02221395f, -0.08339668f, -0.13847683f, 0.13878049f, -0.09711019f, -0.17618877f, -0.14269325f, 
    0.11987694f, -0.07729428f, -0.07950146f, 0.02400093f, -0.09004848f, -0.02963817f, 0.03098239f, 0.02020084f, 
    0.01678875f, 0.23185930f, -0.02872378f, -0.08916140f, 0.02087307f, 0.01592984f, -0.01314014f, 0.08970843f, 
    0.00374659f, 0.06032418f, 0.16618797f, 0.02522133f, 0.35646102f, -0.01812061f, -0.12738641f, -0.11211479f, 
    0.07895591f, 0.11928599f, -0.00807816f, 0.08347711f, 0.10089831f, -0.03748074f, 0.01151480f, 0.09116328f, 
    0.55933404f, -0.21903890f, -0.13234134f, 0.05484806f, 0.06130429f, -0.01072580f, 0.05447641f, 0.07317367f, 
    -0.04358568f, -0.01094149f, -0.00798882f, 0.00962068f, 0.50767976f, 0.02101113f, -0.01217036f, 0.02077958f, 
    0.09242406f, -0.12296231f, 0.06902185f, -0.00098783f, 0.10880049f, -0.03439402f, 0.07594855f, 0.04319272f, 
    -0.12235521f, 0.15580159f, 0.05729623f, -0.09266400f, -0.16052502f, 0.08171265f, -0.00433144f, 0.09731936f, 
    0.03766183f, 0.03960032f, 0.02759515f, 0.09813555f, 0.50221795f, 0.16897340f, 0.17046072f, -0.20161037f, 
    -0.07215422f, -0.01357582f, 0.08906244f, -0.10896678f, -0.01703476f, 0.10930005f, 0.04166206f, 0.07791538f, 
    -0.11189244f, 0.00311135f, -0.20739315f, -0.16025995f, 0.13499966f, -0.00860551f, -0.03453998f, -0.04302691f, 
    0.02598537f, -0.01953871f, -0.01785341f, -0.06424282f, -0.24263933f, -0.03464287f, -0.05599014f, 0.21602604f, 
    0.05342019f, -0.09637590f, -0.02128663f, 0.00540923f, 0.20594947f, 0.05722222f, -0.02927055f, 0.01542472f, 
    0.20583053f, 0.18738349f, -0.01626617f, 0.10694483f, -0.07564813f, 0.10181766f, 0.06473204f, 0.10703490f, 
    0.00075505f, 0.04515725f, 0.07122529f, -0.02144946f, -0.26290771f, -0.03189403f, -0.31143776f, -0.06958244f, 
    0.02413352f, 0.00133682f, 0.04509468f, 0.11446048f, -0.09262508f, 0.01106262f, -0.07720777f, -0.07265656f, 
    -0.41645962f, -0.04184429f, -0.21901113f, -0.03113067f, 0.15964133f, -0.01073929f, 0.03605594f, 0.04751560f, 
    0.00101559f, 0.08650143f, 0.03379397f, 0.17454609f, -0.12515807f, 0.04129571f, -0.08105975f, 0.01197346f, 
    0.06333462f, 0.00239354f, -0.08729569f, 0.16493450f, 0.02408286f, 0.08875609f, -0.05631497f, 0.03556507f, 
    -0.05321080f, -0.24886851f, -0.11996177f, -0.24865784f, 0.18262848f, 0.07955703f, -0.05683506f, -0.08075359f, 
    -0.04022273f, 0.05505968f, -0.09977979f, -0.00144962f, 0.15994072f, -0.06927165f, 0.06807927f, -0.05385626f, 
    -0.06972338f, -0.11569854f, 0.08498332f, 0.07850240f, -0.04602683f, 0.04465163f, -0.07463037f, -0.07346286f, 
    -0.03164143f, 0.17701152f, -0.01579665f, -0.09796467f, 0.08473174f, -0.02031695f, -0.08505302f, -0.04294862f, 
    -0.02315257f, 0.06048317f, -0.04066919f, 0.04918418f, 0.26789871f, -0.07864214f, 0.20146301f, -0.03568243f, 
    0.00524235f, -0.04473433f, 0.02946533f, 0.02364214f, 0.09526010f, 0.12602243f, -0.06701469f, 0.12911467f, 
    -0.13298087f, -0.07227427f, 0.03888385f, -0.11763392f, 0.12489915f, -0.02530007f, -0.08205525f, -0.00608440f, 
    0.01435619f, 0.00793909f, -0.04493739f, 0.01616517f, 0.48744860f, -0.16224413f, -0.05917763f, 0.22944286f, 
    0.00680427f, -0.03279129f, 0.02562556f, 0.02553507f, 0.04138716f, 0.06449171f, 0.02355103f, 0.01131117f, 
    -0.05929517f, -0.09552778f, -0.01771089f, -0.06699775f, 0.11095177f, 0.00414313f, -0.07007850f, 0.00552717f, 
    0.05623592f, 0.09571705f, 0.07383705f, 0.01654104f, -0.05063407f, 0.23496149f, 0.06955187f, 0.04580132f, 
    -0.00523102f, -0.12965856f, -0.00220354f, -0.11127941f, 0.00749734f, 0.03159346f, 0.00584172f, -0.02107955f, 
    -0.25726691f, -0.13917156f, 0.07371761f, -0.09947555f, 0.03864573f, -0.04185159f, -0.04392906f, -0.13383335f, 
    0.02999944f, -0.10651368f, 0.03492196f, 0.12429073f, 0.14338449f, 0.24727333f, 0.07619131f, 0.09081046f, 
    0.10298293f, -0.01470249f, 0.03445240f, -0.01858105f, 0.07215160f, 0.08349200f, 0.28196973f, 0.05818209f, 
    -0.21599261f, 0.17752959f, -0.00267255f, 0.17424084f, 0.02052921f, -0.03518558f, 0.03040118f, 0.03039918f, 
    -0.07943431f, 0.00162597f, -0.01241608f, 0.07796726f, -0.20249391f, -0.05601334f, 0.12491471f, 0.24063744f, 
    0.06960585f, 0.15427221f, 0.06785417f, 0.08058187f, 0.07539269f, 0.06305633f, 0.08499670f, -0.06959178f, 
    0.08381606f, 0.07172617f, -0.00573428f, 0.11227456f, -0.03876264f, 0.10386473f, -0.02485059f, 0.13249402f, 
    -0.08198997f, -0.05748902f, 0.01363905f, -0.01354218f, -0.07938617f, -0.03846192f, -0.06025730f, 0.06522986f, 
    -0.06506366f, 0.05312452f, 0.02980322f, -0.09506264f, 0.05509094f, -0.01317524f, -0.05639015f, 0.12321675f, 
    -0.08414010f, -0.24847876f, -0.06248439f, 0.11127560f, 0.08482130f, 0.01730772f, 0.13385111f, 0.11760254f, 
    0.04702725f, -0.02837980f, 0.02462004f, -0.06633852f, -0.19845405f, 0.08122063f, -0.04870781f, -0.15875712f, 
    0.01628872f, -0.01096988f, 0.09040013f, 0.14482664f, 0.03315101f, 0.10832500f, -0.01456330f, 0.04123714f, 
    -0.05218690f, -0.12784298f, -0.18701181f, 0.01869242f, -0.05404869f, 0.07802972f, -0.01995675f, 0.05639889f, 
    -0.22063775f, -0.00597467f, 0.17241403f, 0.18235318f, 0.19987804f, -0.14795712f, -0.03345731f, 0.02358410f, 
    0.03963349f, 0.06612683f, 0.02381626f, -0.04688624f, -0.00986514f, 0.09245614f, -0.12674895f, -0.03390625f, 
    0.04447782f, -0.07258726f, -0.12547982f, 0.00607339f, 0.05614539f, 0.00807607f, 0.00292887f, 0.19315588f, 
    -0.04345919f, -0.18225336f, -0.14906760f, 0.03200706f, 0.36960557f, -0.03599418f, -0.13145494f, -0.34498227f, 
    0.08934221f, -0.04065958f, -0.03421776f, 0.09107768f, 0.05449446f, 0.00981434f, 0.01670214f, 0.03499720f, 
    -0.04422646f, 0.16356298f, 0.00640369f, 0.08245742f, 0.12216592f, 0.00969305f, 0.03265301f, 0.00503307f, 
    -0.02135347f, 0.09041999f, 0.03414278f, -0.15057127f, -0.05299321f, -0.24366967f, -0.26485553f, 0.10258005f, 
    -0.02585826f, 0.18237872f, -0.02302392f, -0.00017308f, -0.13585997f, -0.08313136f, 0.10415244f, -0.19255155f, 
    0.00256403f, -0.41978577f, 0.02874511f, 0.21073511f, -0.01495633f, -0.02087595f, 0.16539451f, 0.20246783f, 
    -0.23360808f, -0.01956314f, 0.05434315f, 0.12075097f, -0.07944635f, 0.07952845f, 0.12832542f, -0.00552035f, 
    0.02037806f, 0.09107973f, 0.09169815f, 0.03396773f, 0.03098749f, -0.05325232f, 0.12771100f, -0.05254795f, 
    -0.17677164f, -0.33550346f, -0.25435787f, 0.16517122f, -0.05806720f, -0.03118622f, 0.08197615f, 0.01726015f, 
    -0.02212014f, 0.00137650f, 0.15436159f, 0.02854174f, -0.12300313f, -0.15209417f, -0.20968486f, -0.14078276f, 
    -0.23881027f, 0.03751830f, -0.03417756f, -0.14230736f, 0.05587718f, 0.08325592f, -0.06458331f, 0.15262444f, 
    0.00959735f, 0.27259868f, 0.13574703f, -0.27198789f, 0.04887169f, 0.00273439f, -0.01102059f, 0.10869544f, 
    0.05923239f, 0.06140497f, 0.07413887f, 0.19298656f, -0.13185069f, -0.06380271f, -0.15506059f, -0.15135568f, 
    0.23523197f, 0.09713697f, 0.07568308f, 0.04603846f, -0.04587467f, 0.02583774f, -0.04017235f, -0.20595376f, 
    -0.57192570f, -0.03019347f, 0.05250101f, 0.11692803f, 0.17688821f, 0.01739893f, 0.00519730f, 0.07699458f, 
    0.07512621f, 0.03284397f, 0.14471488f, 0.02298762f, 0.03942737f, 0.11525330f, -0.07877428f, 0.01060792f, 
    0.12292597f, 0.08390807f, 0.12513146f, 0.06479737f, -0.06625729f, -0.05252651f, -0.09074294f, -0.13369115f, 
    -0.24765229f, 0.01695887f, -0.03434803f, -0.04606814f, 0.09265363f, 0.23970617f, 0.15127651f, -0.03801774f, 
    0.16208103f, 0.08116209f, 0.12400531f, 0.10585048f, 0.00201297f, -0.00970007f, -0.21524927f, -0.11288472f, 
    -0.11798695f, -0.09176554f, -0.02870470f, 0.14465809f, 0.00939969f, 0.13393287f, -0.04528172f, 0.00222410f, 
    0.06576923f, 0.19828206f, 0.20187029f, -0.14739054f, 0.01540240f, -0.03781436f, 0.06449237f, -0.04368160f, 
    -0.03295648f, -0.04625668f, -0.08972007f, -0.23064299f, 0.02270892f, 0.27350393f, -0.04818610f, 0.05248893f, 
    0.07992864f, -0.00007740f, -0.03080446f, 0.06458313f, 0.07952369f, 0.15377894f, -0.22322406f, -0.17634642f, 
    0.31699464f, -0.07520749f, 0.19036181f, 0.12312024f, 0.05374502f, 0.16281916f, -0.08930960f, 0.00165954f, 
    0.03330810f, -0.00696301f, 0.01975477f, -0.02964283f, -0.07447103f, -0.07358723f, -0.09195172f, -0.02197096f, 
    -0.02170371f, -0.08021271f, -0.04896371f, 0.01439165f, 0.15165074f, 0.14818574f, 0.07505830f, 0.20224704f, 
    0.22952409f, 0.18666808f, 0.19489519f, -0.07643881f, 0.01878567f, 0.04778885f, -0.00920754f, 0.10748284f, 
    0.18858185f, 0.09734137f, -0.07182351f, 0.00060609f, -0.34971029f, 0.05033069f, -0.25396281f, 0.17952231f, 
    0.11574899f, -0.01951887f, 0.13471836f, 0.10637907f, 0.03416363f, 0.02610608f, 0.20461065f, 0.01825656f, 
    -0.20366098f, 0.23983568f, -0.02046535f, -0.09099866f, 0.12826815f, -0.02622190f, -0.21730718f, 0.03397382f, 
    0.13218446f, -0.05745820f, 0.08393520f, 0.09964036f, 0.19539268f, 0.04835848f, 0.09535617f, -0.24114007f, 
    0.00471365f, -0.09067214f, 0.09878833f, 0.08395884f, 0.14504638f, -0.06741375f, 0.03731899f, -0.07274483f, 
    -0.08064310f, 0.29659206f, 0.13104637f, -0.31635955f, -0.05776022f, 0.13344327f, 0.05256928f, 0.15588918f, 
    0.18486764f, 0.06962294f, 0.14705515f, 0.00172255f, 0.37262583f, 0.00872238f, 0.00095524f, -0.23254003f, 
    -0.01129928f, 0.12140869f, -0.07396746f, 0.08099219f, 0.01786361f, -0.05388802f, 0.05400881f, 0.04732780f, 
    -0.07760496f, 0.07782833f, -0.07070205f, 0.16230687f, -0.01180733f, 0.06697739f, 0.01252864f, 0.06219255f, 
    0.20828015f, -0.01424495f, 0.02066913f, -0.00473853f, 0.11320594f, 0.12095371f, -0.13599965f, 0.26190698f, 
    -0.06984689f, 0.03159994f, -0.00526414f, -0.19915323f, 0.04113012f, 0.01179915f, 0.05472109f, 0.05434968f, 
    0.00182887f, 0.12015524f, 0.26743698f, -0.00294131f, 0.00133020f, -0.14122525f, 0.13368058f, 0.12546694f, 
    -0.04510823f, 0.05935424f, -0.09224141f, 0.23000260f, 0.00820877f, -0.16687711f, -0.03530480f, -0.06351028f, 
    -0.01506999f, 0.13472788f, 0.04503485f, 0.14931841f, -0.05346020f, -0.04338707f, 0.04392965f, -0.11646203f, 
    0.06713591f, 0.18736283f, -0.01773478f, 0.19550352f, 0.00460060f, -0.05391235f, 0.05836979f, 0.09761161f, 
    -0.00244094f, 0.01776375f, -0.09181345f, 0.10744563f, 0.11608752f, -0.09988224f, -0.17985362f, 0.05709885f, 
    0.20765561f, 0.08521944f, -0.06799235f, -0.10246424f, 0.15280743f, -0.03964530f, 0.13844189f, 0.05365284f, 
    -0.10460799f, 0.17036685f, -0.22360638f, 0.12619281f, 0.16498236f, -0.06754081f, 0.14593153f, 0.13243583f, 
    0.03979814f, 0.02891972f, -0.15120861f, 0.10197797f, -0.00807043f, 0.29268670f, 0.04755203f, 0.29363266f, 
    0.03718659f, 0.05869841f, 0.01858136f, -0.06996013f, 0.02709897f, -0.02170919f, 0.19658652f, -0.02087819f, 
    0.29884791f, 0.11230839f, -0.04923623f, 0.05001816f, -0.17320222f, -0.01348024f, 0.07268713f, -0.02536716f, 
    0.03638171f, 0.22353888f, 0.18398815f, 0.21719024f, -0.21951841f, 0.17398444f, 0.11085127f, -0.13749833f, 
    0.12141372f, -0.14724223f, -0.09153003f, 0.04708704f, 0.22055702f, 0.02364976f, -0.03315060f, 0.14927308f, 
    -0.07281474f, -0.08219086f, -0.04710512f, 0.11628229f, 0.13351429f, 0.01821352f, 0.04135877f, -0.00192529f, 
    0.09176268f, 0.06457537f, 0.09414061f, 0.28396788f, 0.12943472f, 0.14487496f, 0.01625231f, 0.12757395f, 
    -0.12256972f, -0.06357526f, 0.13474856f, -0.13184032f, 0.11733849f, 0.15012452f, 0.02634516f, 0.19670160f, 
    -0.35645318f, 0.01827586f, -0.00118853f, 0.15124534f, 0.02861396f, 0.00405114f, -0.01571253f, 0.06638286f, 
    0.08120225f, 0.11232353f, 0.00081934f, -0.00715620f, -0.16167738f, -0.01330539f, -0.06445487f, -0.25772637f, 
    0.09262531f, -0.05936331f, -0.08476976f, 0.03162924f, 0.00910165f, 0.24536513f, -0.16097157f, 0.27339980f, 
    -0.09196055f, 0.11181262f, 0.06240065f, 0.41749188f, 0.10833164f, 0.01369348f, -0.08595490f, -0.03567721f, 
    0.12343166f, -0.10259129f, 0.00962079f, -0.20672667f, -0.39281046f, -0.04417051f, 0.00780944f, 0.43487036f, 
    0.05803285f, 0.04994588f, 0.04387425f, -0.05708950f, 0.05498816f, -0.04437677f, 0.05415439f, -0.12949337f, 
    -0.14771171f, -0.22088923f, 0.08411401f, 0.04705760f, 0.25990853f, 0.17229590f, -0.09028646f, -0.02659027f, 
    0.05793408f, -0.05842811f, 0.07427017f, -0.09224263f, 0.01589272f, 0.22782934f, 0.11663876f, -0.18786667f, 
    0.16579585f, 0.01145002f, 0.09058145f, -0.21368182f, -0.01060645f, -0.02846455f, 0.12663580f, 0.10256088f, 
    -0.08266658f, 0.14187421f, 0.07423364f, 0.13610794f, -0.10238324f, 0.08117253f, 0.05734151f, 0.04905893f, 
    0.07977376f, -0.08057739f, -0.12233943f, 0.00805215f, -0.23914455f, -0.07113071f, 0.11323138f, 0.16236843f, 
    0.12725270f, -0.05501166f, 0.09711079f, -0.06549404f, 0.13027924f, 0.23814848f, 0.14939730f, 0.07074603f, 
    -0.02832357f, 0.03539943f, 0.00286971f, -0.15852931f, 0.18753685f, -0.17703909f, -0.01631978f, -0.08428107f, 
    0.26598224f, -0.08344705f, -0.07281198f, 0.07471846f, 0.03745121f, 0.08043686f, -0.07836585f, 0.05512478f, 
    -0.03584011f, 0.08349817f, 0.08361622f, -0.05427300f, -0.11377161f, -0.19096009f, 0.09063657f, 0.03062003f, 
    -0.08004887f, -0.18387482f, 0.06481830f, 0.17871274f, 0.08283380f, 0.01233139f, 0.04190204f, -0.01577569f, 
    0.13714464f, 0.17949384f, 0.23300050f, 0.24514796f, 0.35739282f, 0.00703422f, 0.14611834f, -0.06139709f, 
    -0.04381527f, 0.13269818f, -0.10554620f, -0.07351705f, 0.08646836f, -0.10377175f, 0.40679449f, 0.18482284f, 
    -0.23625124f, -0.11309900f, -0.07803256f, -0.08057999f, 0.21405359f, -0.01580562f, -0.05802687f, -0.02707446f, 
    0.16498522f, 0.15070280f, 0.19077122f, 0.00120818f, -0.03498933f, -0.16933873f, 0.04729729f, 0.10843313f, 
    0.03756722f, 0.12766932f, -0.12269972f, 0.05995033f, -0.09018908f, -0.14673346f, -0.10264936f, -0.22127144f, 
    -0.39885020f, -0.13491678f, 0.13819689f, 0.09218290f, 0.28883860f, 0.16456057f, -0.03403798f, -0.22096406f, 
    0.07666896f, -0.10815027f, 0.07186638f, 0.08308545f, 0.00398399f, -0.02908273f, -0.01654922f, -0.00607961f, 
    0.07466732f, -0.00890424f, 0.01135128f, 0.10584524f, -0.01519810f, 0.05740785f, -0.10762650f, -0.16921458f, 
    -0.01554160f, 0.22375323f, 0.13718335f, 0.10639279f, 0.02916612f, 0.06254005f, 0.22169115f, -0.03207910f, 
    -0.03391634f, 0.03841793f, -0.07850131f, -0.01356127f, 0.04272049f, -0.07564041f, 0.10300563f, -0.07163816f, 
    0.23222838f, 0.19377476f, -0.09529883f, 0.05961584f, -0.14375478f, -0.01133734f, 0.08791612f, 0.16725633f, 
    -0.07448531f, -0.16964303f, 0.04093268f, -0.18493858f, 0.12610969f, -0.02644764f, -0.02626226f, -0.09598815f, 
    -0.02041592f, 0.15940538f, -0.19112970f, 0.05269595f, -0.18079905f, 0.05534916f, 0.07159583f, -0.20591493f, 
    0.15302238f, -0.07301484f, 0.10023566f, -0.02410891f, 0.13325638f, 0.07705764f, -0.03561875f, 0.03211583f, 
    0.00347301f, -0.03766612f, -0.02059064f, -0.03043504f, -0.05725453f, -0.01250811f, 0.00776156f, -0.04461853f, 
    -0.01138789f, -0.00860488f, 0.01658599f, -0.01838450f, -0.01672212f, -0.04563882f, -0.02639942f, -0.03779689f, 
    -0.00823482f, -0.01936126f, 0.00308248f, 0.03316701f, -0.05123343f, 0.00636702f, -0.04994790f, -0.03150228f, 
    0.02245993f, 0.00104244f, 0.01818532f, -0.04593917f, -0.01724744f, -0.01002386f, -0.01663226f, 0.02787059f, 
    -0.03258442f, -0.00902701f, -0.03387062f, -0.00262743f, 0.02269540f, 0.01447889f, 0.03302530f, 0.00198328f, 
    -0.05079450f, 0.04249973f, -0.00048188f, -0.00948179f, -0.00461900f, -0.04879753f, -0.00080978f, -0.00158987f, 
    -0.05500733f, -0.04029996f, 0.03131151f, -0.05488880f, -0.04514352f, -0.03008891f, 0.02633102f, -0.01023516f, 
    0.03571860f, -0.03591365f, -0.00775834f, -0.03001189f, -0.02084738f, 0.01793465f, -0.00142173f, -0.04947657f, 
    -0.00814707f, 0.00906122f, -0.03306907f, -0.00833410f, 0.03487200f, 0.04052158f, 0.02952436f, -0.01801606f, 
    0.00133147f, -0.04209212f, 0.01536463f, 0.04389538f, 0.02147768f, -0.04559508f, -0.01384385f, -0.03923445f, 
    -0.00806150f, -0.05168087f, 0.00943068f, -0.04073035f, -0.03964196f, -0.03886983f, 0.03522798f, -0.03054256f, 
    0.03342382f, -0.02500829f, 0.01278258f, 0.01842528f, -0.03954346f, 0.03086851f, -0.01835868f, 0.03730445f, 
    0.01331815f, 0.02507154f, 0.01745665f, -0.02740538f, -0.01979598f, -0.05142945f, -0.04060569f, 0.00529673f, 
    0.01104075f, -0.02559181f, -0.03442173f, 0.00860126f, 0.04047424f, -0.00802692f, -0.00046901f, 0.02765837f, 
    -0.01460537f, 0.03563577f, -0.02633375f, 0.02830145f, -0.00096746f, 0.00565983f, -0.02138023f, 0.02382630f, 
    -0.03393822f, -0.04885961f, -0.03111341f, -0.03640264f, -0.01969801f, 0.02276131f, 0.03422215f, 0.02169725f, 
    -0.03570712f, 0.02055236f, -0.04192259f, -0.03563999f, -0.03908809f, -0.05669319f, -0.03947648f, -0.01766624f, 
    -0.02086863f, -0.00218942f, 0.03271148f, -0.01935711f, -0.04176338f, -0.04841291f, -0.04293557f, -0.03715463f, 
    0.03297744f, -0.01217180f, 0.01036205f, -0.04050047f, 0.02950608f, -0.02988232f, 0.03253185f, -0.00652316f, 
    -0.04660368f, -0.04717839f, -0.02709010f, 0.01997996f, 0.00005960f, -0.00749277f, 0.01718361f, 0.01216931f, 
    0.00081073f, -0.03209118f, 0.00907753f, -0.02591498f, -0.01750458f, 0.02351058f, -0.01325066f, -0.01511565f, 
    0.03623818f, -0.02630056f, -0.05461180f, -0.04094268f, 0.02322352f, -0.00811783f, -0.01497870f, 0.03955022f, 
    0.04393396f, -0.02685750f, 0.03811916f, 0.01172802f, 0.02099859f, -0.03483946f, -0.05162492f, -0.01258196f, 
    0.01135942f, 0.00634065f, -0.05535442f, -0.01605457f, -0.03157101f, 0.02921578f, -0.02351971f, -0.04634817f, 
    -0.01853292f, -0.02018627f, 0.00526146f, -0.04665345f, -0.02718594f, -0.05440088f, 0.04014528f, -0.04506342f, 
    -0.03066022f, -0.01591592f, -0.00418891f, -0.04568145f, 0.00401297f, 0.01836361f, -0.02076049f, -0.00880369f, 
    -0.01970908f, -0.04445722f, 0.03384544f, 0.02965701f, -0.00535022f, -0.04240382f, 0.04230573f, 0.02119596f, 
    -0.00885437f, -0.00806442f, -0.04588827f, -0.00894418f, 0.00513662f, -0.02909610f, 0.03507816f, 0.03700432f, 
    -0.03555287f, -0.02671731f, -0.01414218f, -0.03104612f, -0.01423638f, -0.02714136f, -0.02705606f, 0.00057850f, 
    -0.01370655f, -0.04224254f, -0.01909415f, -0.05623809f, -0.00790998f, 0.00588711f, -0.01978710f, 0.00637634f, 
    0.00212518f, 0.00934210f, -0.02415480f, -0.00596074f, -0.05347753f, 0.03152934f, -0.04850513f, 0.04132972f, 
    -0.00206188f, -0.03928581f, -0.04032011f, -0.01976459f, -0.03184372f, 0.03309985f, -0.05158275f, 0.03982665f, 
    0.00528737f, 0.01437746f, -0.00732139f, -0.04179803f, 0.01807969f, -0.02076226f, -0.02850631f, 0.03117573f, 
    -0.04246497f, 0.03972377f, 0.00423709f, -0.01728664f, 0.03030750f, -0.05176893f, 0.03596581f, 0.00079655f, 
    -0.00469894f, 0.03241928f, -0.04681711f, 0.00220761f, 0.01292485f, -0.00292607f, -0.02276551f, 0.01981901f, 
    -0.05257352f, -0.04710312f, 0.01961401f, -0.04464876f, -0.00312714f, -0.01592064f, 0.04336007f, 0.03013076f, 
    -0.03017189f, -0.00531353f, -0.01981583f, 0.01141939f, -0.01824890f, 0.02053597f, -0.03634961f, -0.02238183f, 
    -0.03395639f, -0.03250435f, -0.01756172f, -0.00557613f, 0.01725106f, -0.00225743f, -0.02276817f, -0.02714399f, 
    0.00093297f, 0.00261242f, 0.02781677f, -0.04765642f, -0.03848469f, -0.04331472f, -0.02573036f, -0.03636902f, 
    0.00979886f, 0.01200417f, -0.00772953f, -0.01996969f, -0.00066534f, -0.02073925f, -0.04847783f, 0.02079604f, 
    0.00855270f, -0.05046163f, 0.02814118f, 0.03124308f, -0.05391056f, 0.00859862f, -0.05746302f, 0.03765482f, 
    -0.00892242f, -0.02358416f, -0.00943464f, -0.04038084f, 0.03615912f, -0.03593318f, -0.02610111f, 0.00304813f, 
    0.02921687f, 0.02170619f, -0.04597354f, 0.01905543f, -0.01511616f, 0.02964811f, -0.01545842f, -0.04667961f, 
    0.02577591f, 0.03931246f, 0.02158276f, -0.03732853f, 0.02471965f, 0.00067891f, 0.02856767f, 0.04436329f, 
    0.00096289f, 0.01024363f, 0.01431969f, -0.02443385f, -0.04586120f, -0.04159442f, -0.02823636f, 0.01225998f, 
    -0.03286638f, 0.04018077f, -0.04836619f, 0.00660669f, 0.04795525f, -0.01054318f, 0.00497958f, -0.03720728f, 
    -0.00890012f, -0.05570325f, 0.02090812f, -0.02204097f, -0.04913152f, -0.02669493f, -0.02342051f, -0.05435711f, 
    -0.02873895f, -0.04729700f, 0.03368182f, -0.00137477f, -0.05611839f, -0.04108026f, 0.03965989f, 0.04227202f, 
    -0.03937139f, -0.23371238f, -0.09759372f, 0.17646483f, 0.07135519f, 0.09562035f, 0.09005416f, 0.06449925f, 
    -0.03291671f, 0.12741715f, 0.11987529f, 0.02468901f, -0.34193653f, -0.24522850f, -0.09411821f, -0.07421295f, 
    -0.02517693f, 0.05959648f, 0.02872258f, -0.16034974f, 0.04746930f, 0.04000461f, -0.05078801f, -0.05659623f, 
    -0.09973188f, 0.07772511f, 0.08202720f, -0.06203020f, -0.08142804f, 0.14513749f, 0.17321689f, 0.13605447f, 
    0.06717720f, 0.01331314f, 0.07215469f, 0.03449752f, -0.26345283f, -0.11937521f, -0.02352388f, 0.36675656f, 
    0.03532293f, 0.02914682f, 0.03094802f, 0.03304268f, 0.21169230f, 0.08791437f, 0.02713833f, 0.09333810f, 
    0.05730398f, 0.00469525f, -0.05232166f, -0.17331319f, -0.03030883f, 0.10972529f, -0.02179272f, 0.00863216f, 
    0.06557333f, 0.08463705f, 0.02021252f, -0.00449025f, -0.31990689f, -0.13362572f, 0.15851146f, -0.11688824f, 
    -0.10497592f, 0.05339013f, 0.01410558f, 0.06659941f, 0.07495396f, 0.00003336f, 0.01851557f, 0.01233023f, 
    0.11136418f, -0.06340345f, 0.34439841f, 0.24923724f, 0.06990394f, 0.04913919f, 0.11440649f, 0.07909787f, 
    0.05274747f, 0.04059342f, 0.00361408f, -0.04066775f, 0.05520667f, -0.11217067f, -0.20115456f, -0.08811960f, 
    0.08507920f, -0.00160252f, 0.02355614f, -0.02694894f, 0.01061917f, 0.01039148f, 0.10039114f, -0.04250800f, 
    0.36379868f, -0.00899588f, 0.01187641f, 0.06915484f, 0.05477175f, 0.01923128f, 0.09759161f, -0.04468965f, 
    -0.05010039f, 0.01309881f, 0.18445460f, 0.00056873f, -0.01500759f, -0.02311731f, 0.03508433f, 0.03258745f, 
    -0.11098423f, -0.00922409f, 0.17047688f, 0.02121973f, -0.00869599f, 0.02557288f, 0.12681891f, -0.08225340f, 
    0.13150440f, 0.14738850f, 0.09507928f, 0.02528015f, -0.02833791f, 0.03835618f, 0.09001554f, 0.18345894f, 
    0.05082439f, 0.12117919f, -0.04276966f, -0.03679999f, -0.31619900f, 0.13457644f, 0.08781000f, 0.25718480f, 
    0.19578922f, 0.13043499f, -0.00377333f, 0.01717411f, -0.00976313f, 0.08000520f, -0.05824102f, 0.09013151f, 
    -0.22878984f, 0.05010164f, 0.09288798f, -0.03814772f, -0.00727290f, -0.00548468f, -0.00683381f, -0.12742375f, 
    0.00208786f, 0.06325746f, -0.00137231f, 0.04955703f, -0.27696547f, -0.05736937f, 0.09249509f, 0.23887099f, 
    0.16996340f, 0.03968696f, 0.06329051f, 0.03653019f, 0.12983817f, -0.00129905f, 0.03300247f, 0.04678221f, 
    0.29338357f, 0.04084688f, -0.09000201f, -0.28096652f, 0.07333530f, 0.09476580f, 0.03032446f, -0.13549182f, 
    -0.06353624f, 0.04030845f, -0.07761007f, -0.02224548f, 0.24610475f, 0.11919501f, -0.32885286f, -0.02264454f, 
    -0.11143684f, 0.22822440f, -0.02961004f, -0.04500201f, -0.18752180f, -0.09955583f, 0.07257755f, -0.01107147f, 
    -0.09603767f, 0.09833278f, 0.00951240f, -0.13453960f, -0.03317894f, -0.12824778f, -0.08389731f, 0.06785658f, 
    -0.00976845f, 0.08709693f, 0.11036179f, 0.10427682f, -0.39319769f, 0.02539355f, -0.02249446f, -0.03286464f, 
    -0.02326261f, 0.10395171f, -0.04748219f, 0.05549997f, 0.12213336f, 0.08107768f, -0.01141886f, -0.14998913f, 
    0.02822777f, -0.27720878f, -0.04795025f, -0.24577984f, -0.07084041f, -0.01051142f, 0.00114365f, -0.03607712f, 
    0.01658471f, 0.12734410f, 0.02058188f, 0.08249249f, 0.05936457f, -0.06798274f, 0.23354149f, -0.10471869f, 
    -0.14261423f, 0.04025045f, -0.05902534f, 0.06200730f, 0.06852557f, 0.02675181f, 0.17562363f, 0.09874657f, 
    -0.23617858f, 0.00838972f, 0.04101317f, 0.06703021f, -0.00362242f, 0.19766539f, -0.08771037f, -0.02191683f, 
    0.01327580f, -0.03422930f, -0.01606217f, 0.01476360f, 0.24596743f, 0.15327644f, 0.14479272f, -0.21707110f, 
    0.03703881f, -0.07218404f, 0.05192229f, -0.13944769f, -0.11624163f, 0.03473362f, 0.04352437f, -0.19195248f, 
    -0.11776219f, 0.28649616f, 0.00913749f, -0.26317620f, -0.08847897f, -0.14096051f, -0.01131903f, 0.10967775f, 
    -0.02828128f, 0.03083620f, -0.00327371f, 0.07228909f, -0.07245510f, 0.24649301f, -0.10253592f, -0.01508968f, 
    0.03553668f, 0.01003926f, 0.10872237f, 0.05394093f, 0.02576854f, 0.11993792f, 0.06120263f, 0.03886486f, 
    -0.10027006f, 0.17565082f, 0.14086716f, 0.54024750f, 0.10263426f, -0.08257080f, 0.05019602f, 0.01320980f, 
    -0.07825489f, 0.01746656f, 0.03095719f, -0.01285610f, 0.08723932f, 0.12432601f, -0.18229316f, -0.15490560f, 
    -0.08113975f, 0.10856353f, 0.08635558f, -0.18083145f, 0.01032807f, -0.05085897f, 0.12681760f, -0.10817364f, 
    -0.12756114f, 0.06910931f, 0.10575136f, 0.17052649f, 0.02312297f, 0.00528380f, 0.07647855f, 0.02844701f, 
    0.07336839f, -0.06500436f, -0.07148670f, 0.06766381f, -0.14427894f, 0.16093482f, -0.06292433f, -0.18003787f, 
    0.08143496f, 0.07791921f, -0.07242411f, 0.08083090f, 0.00758540f, -0.13665752f, -0.00272374f, -0.00937628f, 
    0.23297229f, 0.02892555f, -0.01265306f, 0.11291599f, -0.01087410f, -0.04568031f, 0.07860853f, -0.05059087f, 
    0.11671539f, -0.22957450f, -0.21195182f, 0.11731876f, -0.10958975f, -0.00827719f, -0.03011432f, -0.11198368f, 
    0.12204545f, -0.01306668f, 0.09984503f, 0.04965713f, 0.17020264f, 0.15353230f, -0.08506284f, 0.10714943f, 
    0.01745932f, 0.05230707f, -0.02859820f, -0.22481124f, -0.08843441f, -0.07477522f, 0.03744108f, 0.01532393f, 
    -0.02844491f, 0.03515669f, -0.08583513f, 0.02041539f, 0.07842036f, -0.17565191f, -0.00219453f, 0.23131569f, 
    -0.02771035f, 0.04128459f, 0.10002737f, 0.04796205f, -0.06893122f, 0.10132430f, -0.14590433f, 0.02119795f, 
    0.05127493f, -0.03427251f, -0.09353323f, 0.19881146f, 0.02465603f, 0.01446279f, -0.07365544f, 0.12987009f, 
    0.12481616f, 0.01662968f, 0.09823893f, 0.00712848f, -0.10959481f, -0.06047677f, 0.03586023f, 0.21187757f, 
    0.02066221f, 0.16539384f, -0.03223122f, -0.00309382f, 0.05344893f, 0.10412326f, 0.04135828f, 0.01113336f, 
    -0.37986434f, 0.15521941f, 0.05087851f, -0.11995807f, 0.13345830f, -0.00750844f, 0.14512487f, 0.18327099f, 
    -0.03112933f, 0.00720532f, -0.12449047f, -0.07124247f, -0.15481427f, -0.30548471f, 0.09025766f, 0.07952695f, 
    0.02612302f, -0.10621220f, 0.03302797f, 0.08143263f, 0.06574396f, -0.01002994f, -0.07091327f, 0.10686996f, 
    -0.59313643f, 0.30792254f, -0.10350417f, -0.16860478f, 0.11495848f, 0.03785215f, 0.15770482f, -0.08027925f, 
    -0.01576482f, -0.13240410f, -0.07102355f, -0.11832380f, 0.01931474f, 0.07491646f, 0.12598832f, -0.25057012f, 
    0.09738072f, -0.04661626f, 0.08822952f, -0.01261699f, -0.03295064f, -0.08898922f, 0.06226584f, 0.00604620f, 
    0.01829410f, -0.03727505f, 0.17450015f, 0.27537891f, 0.04292293f, 0.03297034f, -0.04323894f, 0.16902639f, 
    -0.05464777f, -0.00625060f, 0.02229927f, 0.12068059f, -0.19440836f, -0.15169698f, 0.03161757f, 0.26347327f, 
    0.13571960f, 0.13043515f, -0.06445111f, -0.06649192f, 0.20620190f, 0.03391769f, -0.03614597f, 0.09238898f, 
    -0.18691926f, -0.11271673f, 0.05319831f, 0.32980540f, -0.09080213f, -0.06439175f, -0.22212453f, 0.08908116f, 
    0.06789467f, 0.04575934f, 0.07071247f, 0.13267493f, 0.18094826f, 0.34663591f, 0.00537052f, -0.06656870f, 
    0.21089695f, -0.12303089f, 0.04704404f, 0.11884664f, -0.05842386f, -0.03382562f, -0.14888287f, 0.10616068f, 
    -0.02812826f, -0.04382230f, 0.15449646f, -0.03206050f, -0.04001885f, 0.00169664f, -0.05011923f, -0.01995173f, 
    0.15534946f, 0.09068742f, 0.02780639f, -0.07464395f, -0.35401174f, -0.27882484f, 0.11265666f, 0.32570991f, 
    0.03468582f, -0.16879767f, -0.01511970f, -0.05367443f, -0.04645781f, -0.11578897f, -0.05503187f, -0.10922524f, 
    0.17674468f, -0.15619358f, 0.25933921f, 0.12916827f, -0.01259786f, 0.09020413f, 0.05408932f, -0.10556948f, 
    -0.07317037f, -0.19230613f, -0.09517136f, -0.01402162f, -0.01972261f, 0.06167888f, -0.12688723f, -0.15686649f, 
    0.08162960f, 0.04915321f, 0.04186457f, 0.05765760f, 0.04271736f, 0.14634654f, 0.07746776f, -0.00056278f, 
    0.25220630f, -0.01759413f, -0.14382453f, 0.07235437f, 0.13850828f, -0.00878754f, 0.09422268f, 0.08382512f, 
    -0.01579253f, -0.08372279f, -0.01420597f, -0.03952345f, -0.26307756f, -0.13739036f, -0.19044143f, -0.00286052f, 
    0.17124079f, 0.17571357f, -0.05772099f, 0.06109145f, 0.01781525f, -0.13428180f, -0.17630333f, 0.10196604f, 
    -0.03431691f, 0.01676632f, 0.27431968f, -0.09806135f, 0.02664006f, -0.04129390f, -0.02990988f, 0.04977769f, 
    -0.06467919f, 0.01858967f, -0.07339989f, 0.02686497f, -0.12842599f, 0.62094921f, -0.13882117f, -0.15132199f, 
    0.11506545f, -0.01512180f, 0.10184051f, -0.07077635f, 0.10220496f, 0.08611406f, -0.01956199f, 0.02752023f, 
    -0.13461213f, 0.13389446f, -0.08268694f, -0.13270256f, 0.16566357f, 0.01242111f, -0.06869097f, -0.02208186f, 
    -0.04814574f, -0.03453832f, -0.00746264f, -0.01083014f, 0.41792443f, 0.21436791f, 0.14011997f, -0.04503803f, 
    0.02789426f, 0.05057787f, 0.07777213f, -0.12055443f, -0.04057097f, -0.15025882f, -0.02116527f, -0.07499247f, 
    -0.05287287f, 0.26428723f, 0.20464583f, -0.05897537f, 0.05632125f, 0.06725325f, 0.04391391f, -0.15384249f, 
    0.09984069f, 0.01902053f, 0.06070000f, -0.08861879f, 0.44635665f, -0.02742157f, -0.23234126f, 0.28198889f, 
    -0.04155768f, 0.12103665f, 0.07963044f, -0.02011055f, -0.05444834f, 0.02487939f, 0.18095440f, -0.05610782f, 
    0.09821872f, -0.05857579f, 0.28764793f, -0.10428394f, -0.11319698f, -0.09713157f, -0.05357800f, -0.03265923f, 
    -0.16364877f, -0.20132762f, 0.07520878f, -0.18620519f, 0.02251188f, -0.04278259f, -0.06194296f, -0.05930568f, 
    0.20986791f, 0.13145979f, -0.10784585f, -0.08633135f, 0.19159733f, 0.22959211f, -0.10283879f, 0.01203812f, 
    -0.02961052f, 0.06768154f, 0.34393492f, 0.13457014f, 0.04212215f, 0.05421210f, -0.08226783f, -0.02149200f, 
    -0.05232240f, -0.07327633f, -0.00175967f, -0.01485765f, -0.52319616f, 0.14202869f, -0.22729698f, 0.11183814f, 
    0.10683489f, 0.14274999f, -0.05739488f, 0.00511161f, -0.08635188f, 0.20237133f, 0.23124139f, 0.08908243f, 
    -0.01234780f, 0.10081539f, 0.21341959f, 0.10755215f, -0.01023794f, 0.10702907f, -0.00142490f, 0.02177730f, 
    0.05482466f, -0.04796157f, 0.08763577f, -0.04739584f, -0.85428578f, 0.19598930f, -0.21067268f, -0.24894480f, 
    0.11250220f, 0.01543700f, -0.01642667f, 0.00997136f, -0.04618918f, 0.04269288f, 0.09498007f, 0.08705357f, 
    0.00693159f, 0.32324278f, 0.07384820f, 0.18156067f, -0.03404323f, 0.03655504f, 0.03957619f, 0.07343594f, 
    0.03977431f, -0.03771986f, 0.07131530f, 0.13595425f, 0.09901232f, -0.11245350f, -0.16764325f, -0.18978414f, 
    0.13193455f, 0.09523878f, 0.05967746f, -0.02486949f, 0.08770356f, -0.07934321f, -0.02819037f, -0.14101601f, 
    -0.00837759f, 0.08203838f, 0.15610436f, -0.16099809f, -0.09529109f, -0.02200968f, -0.01269221f, -0.02528334f, 
    -0.10092211f, 0.04646598f, 0.07025827f, 0.07881429f, 0.22491661f, -0.24740750f, -0.04191474f, 0.06360988f, 
    -0.07830523f, -0.06246353f, -0.15151218f, 0.00390999f, 0.04990404f, -0.00965795f, -0.08495992f, -0.05546173f, 
    -0.06107158f, 0.01741846f, -0.00100409f, 0.02379875f, -0.00789774f, -0.03525894f, -0.04610622f, -0.01347245f, 
    0.02652286f, 0.00883157f, -0.00903009f, -0.02812505f, 0.02765526f, -0.02191016f, -0.05083969f, 0.00096449f, 
    -0.01141488f, -0.01768265f, -0.04246477f, -0.02916823f, -0.04265922f, -0.01110663f, 0.03761092f, -0.00971606f, 
    -0.02540169f, 0.00685561f, 0.03096382f, 0.03449252f, 0.03569264f, -0.01136907f, -0.04082973f, -0.02728486f, 
    0.00698729f, -0.05728646f, -0.03013499f, -0.03821445f, 0.03905872f, 0.02814195f, 0.02342930f, -0.04003063f, 
    0.02284963f, -0.04265698f, -0.00256648f, 0.04518070f, 0.01421950f, -0.03161786f, 0.01718906f, 0.02449907f, 
    0.02556450f, 0.00509482f, -0.02619308f, 0.02919926f, -0.00043058f, 0.02704562f, 0.03615116f, -0.02357157f, 
    -0.04700672f, 0.01233871f, -0.02439281f, -0.05643819f, 0.05243690f, 0.02369937f, -0.02385757f, -0.02931611f, 
    0.02000824f, -0.01805886f, 0.00235054f, 0.03497918f, -0.03394635f, 0.03619127f, -0.03356585f, 0.02216219f, 
    0.04049300f, -0.01783993f, 0.01939650f, -0.00970774f, 0.02458369f, 0.03110488f, 0.03039040f, 0.00703597f, 
    -0.03116284f, -0.03776696f, -0.01607045f, 0.01791381f, 0.01175364f, 0.02793746f, -0.00550847f, -0.05839014f, 
    0.01527935f, -0.03744151f, -0.03886031f, -0.02694479f, 0.02857775f, 0.00640012f, 0.03817680f, -0.04637982f, 
    -0.01537305f, -0.01177078f, 0.03174320f, 0.01890341f, -0.02168364f, -0.03562685f, 0.03924889f, 0.00392332f, 
    -0.04182803f, 0.00960982f, -0.03125402f, -0.02541351f, -0.01322046f, 0.05253838f, -0.00669947f, 0.00909920f, 
    -0.05361627f, -0.04897751f, 0.01870875f, 0.01490449f, 0.03501391f, 0.03523653f, -0.01629725f, -0.03472851f, 
    -0.02059684f, -0.00672680f, -0.01048055f, -0.04545791f, -0.01064959f, -0.03522895f, -0.05038910f, 0.00291516f, 
    0.01631058f, -0.04161660f, -0.02900922f, -0.04947149f, -0.02777872f, 0.02238203f, 0.04122330f, 0.01829192f, 
    0.04727303f, 0.03603534f, -0.02860736f, -0.05299416f, -0.01772982f, -0.02895927f, -0.05223574f, 0.00205198f, 
    -0.03368650f, -0.03066029f, -0.04266005f, 0.00435447f, -0.03390753f, -0.06018588f, 0.00189327f, -0.05649197f, 
    0.03417226f, 0.01946291f, -0.00293484f, 0.02944287f, 0.00080398f, 0.03031882f, -0.03311345f, -0.02465658f, 
    -0.02975818f, -0.04931743f, -0.00991750f, -0.03474478f, -0.02581908f, -0.02660106f, 0.03325661f, 0.00156880f, 
    -0.03028484f, -0.01390372f, -0.02971861f, -0.01316941f, -0.00095729f, -0.02255851f, 0.01163497f, 0.03500153f, 
    -0.01718137f, -0.05233073f, -0.03066923f, 0.01561931f, -0.03374092f, -0.03610258f, 0.01806360f, -0.00917461f, 
    -0.05531304f, -0.03430077f, 0.01833638f, 0.03030334f, 0.02455753f, -0.01844345f, -0.01236830f, -0.01196206f, 
    -0.01651797f, -0.01343604f, 0.05213239f, 0.01482188f, -0.01941447f, -0.02404316f, 0.03958064f, 0.00801862f, 
    -0.00630600f, -0.00862486f, 0.00928026f, 0.02451316f, -0.03735388f, -0.02331774f, 0.02962296f, 0.01178547f, 
    0.03131443f, -0.01177339f, -0.03599955f, 0.01185406f, 0.01389129f, 0.02962166f, 0.02211368f, 0.02671243f, 
    -0.03608300f, 0.01952634f, -0.01169131f, 0.00909418f, 0.01125445f, 0.03580173f, -0.02225246f, 0.02066188f, 
    0.03172226f, -0.03051392f, -0.04974443f, 0.00116973f, 0.00228749f, 0.00890526f, 0.04299463f, -0.04295686f, 
    -0.05097735f, -0.03266355f, -0.00124699f, -0.04576560f, -0.01806793f, -0.05014539f, -0.03549416f, -0.02810609f, 
    -0.01203575f, 0.04765103f, 0.02324141f, 0.00530601f, 0.03247521f, -0.01504326f, 0.01833654f, -0.05354447f, 
    -0.03777312f, -0.04036441f, 0.04549248f, -0.02108336f, -0.00804853f, -0.00660289f, -0.01626620f, 0.00723944f, 
    -0.00651042f, -0.00479357f, -0.02961235f, -0.00190155f, -0.00843648f, -0.01655270f, 0.03800686f, -0.04516369f, 
    -0.01502373f, -0.02755713f, -0.00350844f, 0.01643972f, 0.01007655f, -0.03093616f, -0.04220746f, 0.00356716f, 
    0.02189635f, -0.04001822f, -0.05330515f, -0.01055790f, 0.03915955f, -0.00746480f, -0.02043518f, 0.02727131f, 
    -0.03203604f, -0.03662074f, -0.01511717f, 0.03180420f, -0.02368395f, -0.01159284f, -0.01797796f, -0.04373582f, 
    -0.05625490f, -0.04428919f, -0.04197793f, -0.02134552f, -0.04190309f, -0.02301090f, -0.04113537f, -0.01828814f, 
    -0.05075651f, 0.02066285f, -0.01299639f, -0.03079431f, -0.00889961f, -0.01526533f, -0.01958394f, -0.01195130f, 
    0.01385207f, -0.03616830f, -0.04097729f, 0.00080265f, -0.00658323f, -0.04339395f, 0.02658471f, -0.01551982f, 
    0.03134608f, -0.03711512f, 0.00703373f, -0.03088798f, 0.01568080f, 0.00411413f, 0.02165582f, 0.01872810f, 
    0.02960069f, 0.02543991f, 0.00453133f, -0.00248297f, 0.03458579f, -0.01870074f, -0.02812319f, 0.00405525f, 
    -0.02661191f, 0.04033561f, 0.04624147f, 0.02711473f, 0.03433547f, 0.03715794f, 0.03053846f, 0.03352019f, 
    0.03379674f, 0.02779254f, -0.00516612f, -0.03843576f, -0.03649095f, -0.04709564f, 0.03600313f, 0.04197099f, 
    -0.04803028f, 0.02359724f, -0.04056382f, 0.03979438f, 0.01627914f, -0.05949964f, -0.01289808f, 0.04214583f, 
    0.04593805f, 0.02390730f, -0.00706775f, 0.00486790f, 0.02616482f, 0.01148842f, -0.03309237f, 0.01695003f, 
    -0.03942878f, -0.02335894f, 0.01752412f, -0.00769508f, -0.03316322f, 0.01184405f, -0.00907710f, 0.00667061f, 
    0.02271368f, 0.01404875f, -0.04421485f, 0.01621299f, -0.00926158f, -0.01887823f, -0.01859298f, -0.02099132f, 
    -0.00997948f, 0.02693034f, -0.00541265f, 0.00053881f, 0.01594996f, 0.00015898f, -0.02601487f, -0.04752354f, 
    -0.01271999f, 0.32607362f, -0.07167871f, -0.07510947f, 0.00576406f, 0.07956098f, -0.05899757f, -0.06391808f, 
    0.12836424f, -0.05412020f, 0.07331078f, -0.05501936f, 0.22896974f, 0.28910106f, 0.00959751f, 0.28369120f, 
    0.11576830f, -0.10614733f, -0.06164766f, 0.17442362f, 0.01089236f, -0.00493240f, 0.05863943f, -0.01296377f, 
    -0.15949108f, -0.28420860f, 0.14099945f, 0.10096759f, 0.04117367f, 0.06229778f, 0.14484669f, -0.13701421f, 
    0.00550812f, 0.10740708f, -0.01298665f, -0.01264599f, 0.48311007f, -0.30379793f, 0.18850343f, 0.11250753f, 
    0.16047536f, -0.00113307f, 0.04647291f, 0.13116112f, -0.02530847f, -0.09882395f, -0.07996542f, 0.03097703f, 
    -0.11824503f, 0.00278515f, -0.11505850f, -0.18950877f, 0.11549351f, 0.08048463f, -0.18020211f, -0.02697739f, 
    0.08452839f, -0.08357533f, 0.04147887f, -0.06685933f, -0.12591055f, 0.45887551f, 0.20440924f, -0.01739312f, 
    0.13243753f, 0.04539157f, -0.05071933f, -0.11300163f, -0.02677558f, -0.04267132f, 0.07582711f, 0.05199228f, 
    -0.41105261f, 0.13225825f, -0.19583733f, 0.07387680f, 0.00450177f, 0.07205022f, 0.09704727f, 0.14301834f, 
    -0.14601608f, 0.06642601f, -0.10114995f, 0.01111525f, -0.46825868f, -0.22358440f, -0.05299614f, 0.06487380f, 
    0.06898691f, 0.06857283f, -0.22000125f, -0.00677492f, 0.03778119f, 0.05022341f, -0.01846204f, -0.01193430f, 
    -0.01857995f, 0.09797255f, -0.01608532f, 0.05398645f, -0.00850471f, 0.03896171f, -0.09636251f, 0.02550354f, 
    -0.04707664f, 0.13012110f, 0.05196503f, 0.18761088f, 0.16036865f, 0.05603072f, 0.26296505f, -0.04882835f, 
    0.17828690f, 0.00527270f, 0.05216962f, -0.08427929f, 0.05314485f, -0.05474617f, -0.02986934f, -0.00898725f, 
    0.00092426f, -0.00810847f, 0.02931099f, -0.33928350f, -0.18613471f, -0.00854953f, 0.08121715f, 0.09639769f, 
    0.07318937f, 0.02819626f, 0.00581614f, 0.16915712f, 0.06933481f, -0.18010002f, 0.06454862f, -0.01429847f, 
    -0.03312649f, -0.12569132f, 0.01732520f, 0.14033622f, 0.05917363f, 0.06452263f, 0.02862849f, 0.00643052f, 
    -0.12603815f, -0.22415607f, 0.11897505f, -0.00200395f, -0.04108849f, -0.08058753f, -0.02778333f, -0.03068430f, 
    0.10386291f, -0.18977652f, 0.11347061f, 0.03217261f, 0.51679897f, 0.05184508f, -0.06573823f, -0.03650960f, 
    0.10162911f, -0.13520259f, 0.10719796f, 0.13961387f, -0.06006599f, 0.13006058f, -0.03265225f, -0.03641882f, 
    -0.04207940f, 0.20773008f, 0.18050362f, -0.31012833f, -0.09269527f, 0.22470357f, -0.08629804f, -0.02119746f, 
    0.09631707f, -0.15079670f, 0.03428647f, 0.05488779f, -0.27075714f, -0.17369869f, -0.07365245f, -0.07481195f, 
    0.17176622f, 0.01829431f, -0.02386394f, -0.09413163f, -0.01282215f, 0.00248424f, -0.03164573f, 0.03910843f, 
    -0.04090890f, 0.09502702f, 0.12512918f, -0.16372229f, 0.02363691f, 0.12098833f, 0.04692984f, -0.01092979f, 
    -0.17981051f, -0.01772130f, 0.05620354f, 0.04012296f, -0.12434136f, 0.34571394f, 0.16610186f, 0.14829995f, 
    0.12443811f, -0.03960645f, 0.01571957f, -0.08748683f, 0.16367514f, -0.08202689f, 0.01480892f, 0.05948276f, 
    0.19415601f, 0.05942653f, 0.08483806f, -0.04763047f, -0.02240364f, -0.08606631f, -0.06771001f, -0.02216933f, 
    0.04656911f, -0.06905866f, -0.12023711f, -0.02419321f, -0.03646575f, 0.10815993f, 0.07122859f, 0.08206697f, 
    0.01857644f, 0.00290693f, 0.08628897f, 0.02202791f, -0.06859218f, -0.05915603f, 0.02729596f, 0.15103473f, 
    0.04164023f, 0.26099658f, 0.19425419f, 0.16017695f, -0.12535480f, -0.17480496f, -0.04671176f, 0.03524796f, 
    -0.02600953f, 0.04721210f, -0.02051583f, -0.10283838f, -0.07646440f, -0.24658467f, 0.08835728f, 0.12450378f, 
    0.15984692f, 0.19652237f, -0.03277746f, -0.01279957f, 0.09175762f, -0.02026712f, -0.04316226f, 0.15651524f, 
    0.19936256f, -0.20287010f, 0.08530571f, -0.19542533f, 0.11739044f, 0.19172287f, 0.05759992f, -0.10256750f, 
    -0.12161341f, 0.01749742f, 0.14880879f, 0.04227129f, 0.01707472f, -0.05997722f, -0.05328842f, -0.10989374f, 
    0.09742533f, 0.07573050f, 0.12949798f, -0.12736215f, 0.03314417f, -0.09424948f, 0.20747466f, 0.06497541f, 
    0.05970813f, 0.11381356f, 0.06989018f, 0.17612466f, -0.10926183f, -0.05919962f, -0.01759174f, 0.17678003f, 
    -0.07166686f, -0.02481520f, -0.01997074f, 0.02861292f, 0.02194503f, -0.22887759f, 0.04816681f, 0.04750675f, 
    0.09173293f, 0.16301265f, -0.05587139f, -0.10749546f, -0.13063367f, 0.19973259f, 0.18350162f, 0.12521029f, 
    0.15026218f, 0.10196038f, -0.11006916f, 0.28532630f, -0.08856884f, 0.02901074f, 0.07017580f, -0.00901255f, 
    -0.14077026f, -0.03686402f, -0.01971168f, -0.06890267f, 0.27789015f, -0.35743958f, 0.11015922f, -0.24540065f, 
    0.01617056f, 0.00662437f, -0.01917248f, -0.03489413f, 0.07378309f, 0.00092700f, 0.04611010f, -0.14814393f, 
    0.05728026f, 0.17813462f, -0.03941606f, 0.01037734f, -0.18251804f, 0.00068126f, 0.07462508f, -0.05993750f, 
    -0.07485777f, 0.15653215f, 0.02337816f, 0.11265091f, 0.15850519f, 0.38818923f, 0.00628246f, -0.06842612f, 
    0.02422055f, 0.18092352f, 0.04311324f, -0.03922487f, -0.12327295f, -0.01837065f, 0.01072019f, 0.00359645f, 
    -0.30215374f, 0.03026528f, 0.17754973f, -0.23807147f, -0.07572766f, 0.02052862f, 0.11643773f, -0.16421220f, 
    -0.03715913f, -0.05076443f, 0.02473947f, 0.06556568f, -0.02331339f, -0.00250808f, 0.16838732f, 0.14752388f, 
    -0.01896566f, -0.09851454f, 0.08102650f, 0.08914601f, 0.14068897f, 0.02441718f, 0.08451907f, -0.16162756f, 
    -0.06434300f, 0.05156106f, 0.28877690f, 0.02779877f, 0.04121694f, 0.09455137f, -0.08033435f, 0.01656931f, 
    -0.11167810f, 0.10734094f, -0.05572787f, 0.03879010f, -0.12119666f, -0.04118671f, 0.00898483f, 0.19462039f, 
    0.06354737f, 0.15455846f, -0.05326874f, 0.21220234f, -0.03447745f, 0.13649634f, 0.02003353f, 0.04487142f, 
    0.04485226f, -0.08923703f, -0.09013019f, -0.00393094f, 0.09178060f, -0.02074382f, -0.17314880f, 0.05677143f, 
    0.02339007f, -0.11623975f, -0.00767665f, -0.09619662f, 0.08080456f, 0.17602037f, 0.17153996f, -0.38518953f, 
    0.04757965f, -0.10804453f, -0.00649422f, -0.07468934f, 0.10714748f, -0.05678241f, -0.03699166f, 0.13952236f, 
    -0.30985901f, 0.03308813f, 0.00010815f, 0.09397966f, -0.03614127f, -0.01860511f, 0.04550225f, 0.03119879f, 
    -0.05125306f, -0.04636421f, 0.11165383f, 0.07737736f, 0.13583961f, -0.14629659f, -0.15576421f, 0.02850172f, 
    -0.00715873f, -0.14863123f, 0.11273264f, 0.03117662f, -0.04448528f, 0.06443568f, -0.01071794f, 0.06591303f, 
    0.52930647f, 0.07300784f, -0.05687824f, -0.00378921f, -0.15434712f, 0.01764561f, -0.20308754f, 0.01913695f, 
    -0.15452483f, 0.01656035f, 0.20672789f, -0.05016473f, 0.03646481f, -0.04718189f, 0.13933051f, -0.13598359f, 
    -0.13551240f, -0.01020289f, -0.04184071f, 0.16991962f, 0.01005100f, 0.00964189f, -0.09525759f, 0.05381854f, 
    -0.23356362f, -0.10618334f, -0.03773859f, -0.09690107f, -0.02549878f, -0.00816809f, -0.10292886f, 0.17178586f, 
    0.06080497f, -0.09485049f, -0.21181895f, -0.12696497f, 0.16933262f, -0.03419419f, 0.02577061f, 0.07583399f, 
    0.03244315f, -0.06710712f, -0.00799479f, 0.05570018f, 0.00125655f, -0.10997292f, -0.08397003f, 0.08542335f, 
    -0.23281108f, 0.10827774f, 0.14707692f, 0.04717345f, 0.03793985f, 0.11386609f, 0.09799143f, -0.03071052f, 
    0.01830079f, 0.02482186f, -0.09546252f, -0.22039004f, -0.18731007f, 0.07960647f, 0.01364550f, -0.05522222f, 
    0.10154832f, -0.07078199f, -0.02889782f, 0.05881021f, -0.14218099f, -0.13112746f, -0.00734162f, -0.08122803f, 
    0.48411265f, 0.05921578f, 0.04696362f, 0.10471568f, -0.10963688f, 0.07569771f, 0.09495719f, 0.03888448f, 
    -0.00342978f, -0.00616596f, -0.23168896f, 0.00361292f, 0.14969611f, -0.08624225f, 0.17307349f, -0.26589990f, 
    -0.12245924f, 0.10119403f, 0.10076404f, -0.03039092f, 0.06432796f, -0.15934886f, 0.10408473f, -0.16499418f, 
    -0.42085347f, -0.15294279f, -0.21727884f, 0.16832998f, -0.07687630f, -0.17981923f, 0.06156006f, 0.02486814f, 
    -0.02171881f, 0.12585960f, 0.17901051f, 0.16337426f, -0.02256037f, -0.20866613f, 0.15133372f, -0.36313474f, 
    -0.12063882f, -0.02447467f, -0.03342577f, 0.05068202f, -0.01481237f, 0.01349277f, -0.15973112f, 0.11582097f, 
    -0.00542617f, -0.03146262f, 0.04520089f, 0.20576382f, -0.07950684f, -0.08845633f, -0.09534075f, -0.04627760f, 
    0.14112768f, 0.05959033f, -0.05821770f, 0.06859703f, 0.38411179f, -0.02092892f, -0.21733066f, 0.11443409f, 
    0.00514447f, 0.08900008f, 0.06222079f, 0.13757622f, -0.09276564f, -0.04198483f, 0.07418276f, 0.11005853f, 
    -0.19587290f, 0.09467687f, -0.09164047f, 0.20258573f, 0.12632969f, 0.10041131f, 0.01582512f, 0.05592110f, 
    -0.07502875f, -0.01231375f, 0.26840025f, 0.10753985f, 0.14018573f, 0.07887109f, -0.06582080f, 0.02718114f, 
    0.12449750f, 0.14692771f, 0.03016391f, 0.04935531f, -0.01484969f, -0.08850089f, 0.00780404f, -0.02913591f, 
    0.27917066f, -0.03762504f, -0.04329285f, -0.01982341f, 0.00481512f, 0.11114527f, 0.20487109f, 0.02379015f, 
    -0.08823793f, 0.07943761f, 0.26019198f, -0.03009341f, -0.16630484f, -0.01756320f, -0.13844843f, 0.15598010f, 
    -0.16807388f, -0.10045557f, -0.06074291f, 0.06285643f, 0.09783249f, 0.10830254f, 0.01126855f, 0.12915069f, 
    -0.06455570f, -0.01745088f, 0.20856400f, 0.30651635f, 0.10291391f, 0.16407140f, -0.00555796f, -0.06234503f, 
    -0.01636567f, -0.02114740f, -0.14577731f, -0.26412889f, -0.11293785f, -0.13687819f, 0.13670017f, -0.06871901f, 
    -0.03109654f, 0.03602227f, 0.06022849f, -0.05325997f, 0.01449716f, 0.07130885f, -0.20962265f, -0.06146672f, 
    0.38519567f, -0.08372291f, 0.03038138f, 0.04360148f, 0.01077421f, 0.15977514f, -0.04249324f, 0.02036520f, 
    -0.02713022f, -0.13338917f, -0.09581651f, -0.00029613f, -0.16630156f, 0.22624871f, 0.07250961f, 0.10020296f, 
    -0.07643259f, -0.21733883f, 0.10563670f, 0.04804869f, 0.12313568f, 0.06652123f, 0.08562385f, 0.31521654f, 
    0.05608573f, 0.10799471f, -0.10307075f, 0.06602326f, -0.10459015f, 0.10759340f, -0.09622293f, 0.09279525f, 
    0.06168816f, 0.17611401f, 0.02932483f, 0.00847224f, -0.37429351f, 0.13120979f, 0.02680951f, 0.15447648f, 
    0.03446797f, 0.02176557f, 0.06612180f, 0.01486896f, 0.08855010f, 0.10334850f, 0.10587680f, 0.21167168f, 
    -0.11030027f, -0.03686411f, -0.01537015f, -0.00237825f, -0.03212669f, 0.11163735f, -0.05642187f, 0.07733124f, 
    0.09891462f, -0.00594481f, 0.28428325f, -0.03941835f, 0.03953483f, -0.20441538f, -0.05519430f, 0.18442810f, 
    -0.02628834f, -0.09623695f, 0.08310834f, 0.10213494f, 0.07551327f, -0.15127453f, -0.08501888f, -0.16978034f, 
    -0.07410067f, 0.07578827f, 0.15051290f, 0.29577878f, 0.08201889f, -0.00572143f, -0.02898058f, -0.00729684f, 
    0.03580328f, 0.07211664f, 0.20156489f, 0.18925528f, 0.43364051f, 0.03663912f, -0.09615583f, -0.20287815f, 
    -0.05434117f, 0.12491630f, -0.09330905f, 0.05633526f, -0.09161000f, -0.09593707f, 0.07031594f, 0.15714580f, 
    0.29989076f, -0.20885833f, -0.05689546f, -0.08623251f, 0.04310915f, -0.00632502f, -0.01036253f, -0.04908270f, 
    0.00881026f, -0.04449607f, 0.02653724f, 0.13422637f, 0.28077179f, -0.32301351f, 0.44566137f, -0.54014224f, 
    0.00406645f, -0.01170513f, 0.03941149f, 0.10827101f, -0.08668799f, 0.04110657f, -0.03234732f, 0.11759020f, 
    -0.15125726f, 0.30154741f, -0.35332397f, 0.00471720f, 0.14588556f, -0.04167484f, -0.10741229f, -0.04306880f, 
    0.09930778f, 0.12921479f, 0.11810650f, -0.13683388f, -0.14321674f, 0.26484504f, -0.03703513f, 0.01341987f, 
    0.16111505f, -0.12485786f, -0.13557133f, 0.09392460f, -0.07628936f, -0.03485307f, -0.05596165f, 0.02642082f, 
    0.03767943f, 0.13719217f, -0.20531660f, -0.15532076f, 0.16971624f, -0.04590665f, 0.04816141f, -0.19067709f, 
    0.02836085f, 0.02350468f, 0.05659925f, 0.02541092f, 0.07195888f, 0.11196254f, 0.00240720f, 0.18201976f, 
    -0.10842776f, 0.00043649f, -0.02642074f, -0.00721874f, -0.00509883f, 0.00924401f, -0.04452519f, 0.03281568f, 
    0.24998716f, 0.01917901f, 0.19416182f, -0.19276090f, -0.00565985f, 0.05032589f, 0.02594546f, -0.17357126f, 
    -0.01551199f, 0.00239852f, -0.01137346f, -0.05527546f, -0.07887597f, -0.16174951f, -0.09822550f, -0.00117130f, 
    0.07632805f, -0.01341930f, 0.10511433f, 0.05377800f, 0.00272833f, -0.02096948f, -0.10149065f, 0.09319252f, 
    -0.03878401f, 0.01697487f, 0.18758677f, 0.25709188f, 0.11977938f, 0.01693988f, 0.03626833f, 0.02893079f, 
    0.22492157f, 0.10160650f, 0.01399925f, 0.02466805f, -0.03488415f, 0.20910494f, -0.06464872f, 0.36800003f, 
    0.02860600f, 0.09545223f, 0.06039018f, 0.00298713f, -0.12767754f, -0.04370441f, 0.09121246f, 0.03937302f, 
    -0.02416708f, -0.06092108f, 0.20324305f, 0.12948361f, -0.00017473f, -0.04887637f, -0.00774357f, -0.05898381f, 
    0.23717232f, -0.14813268f, 0.10099001f, -0.01295464f, -0.04611516f, -0.04184610f, 0.18902920f, -0.12654273f, 
    -0.05315530f, -0.03014954f, -0.02451607f, 0.07738190f, 0.10000820f, 0.05627923f, 0.08190667f, 0.04272408f, 
    0.08479670f, 0.12150760f, 0.04801747f, -0.37547240f, 0.06880278f, -0.04871755f, -0.04007909f, -0.08398292f, 
    0.17783585f, -0.01807500f, 0.05467071f, 0.04352804f, 0.09450449f, 0.16231553f, -0.12382558f, 0.27207360f, 
    -0.06701982f, 0.05109459f, -0.06987721f, 0.00963632f, -0.11245602f, -0.15511860f, 0.07510350f, 0.00672270f, 
    0.19395217f, -0.00357847f, 0.14884990f, -0.18338443f, 0.13678706f, 0.09906590f, 0.09799966f, 0.12713858f, 
    0.02472851f, 0.08128586f, 0.05125776f, -0.00201542f, 0.01882037f, 0.05760948f, -0.00472961f, -0.11849951f, 
    0.20259087f, -0.11491904f, -0.00043219f, 0.17131901f, -0.02812788f, 0.04961740f, -0.07194832f, 0.06798894f, 
    -0.07898637f, -0.18159534f, 0.04106471f, 0.20487767f, -0.13829903f, 0.11299232f, 0.15654184f, -0.04454557f, 
    -0.08760896f, 0.04271086f, -0.09160934f, 0.08829565f, 0.00400134f, 0.27773267f, -0.07985003f, 0.15733021f, 
    -0.02826974f, 0.04966277f, 0.05684099f, 0.11993971f, -0.01118682f, 0.00985872f, -0.08645523f, 0.01038211f, 
    0.30047625f, 0.02080913f, 0.02165674f, -0.17065011f, 0.11112848f, 0.01345062f, -0.02209368f, -0.09193728f, 
    0.00696345f, 0.03499075f, -0.03020558f, 0.03795927f, 0.30175889f, 0.01755950f, -0.02520043f, 0.01122935f, 
    -0.10334691f, 0.05290534f, 0.01965564f, 0.08903903f, -0.00724833f, -0.06112394f, -0.13100612f, -0.00183437f, 
    0.08526940f, -0.13589656f, 0.11672270f, 0.14732203f, -0.16219254f, 0.00957451f, -0.04081131f, -0.05096889f, 
    -0.06429017f, -0.07775643f, -0.10895263f, -0.02741528f, 0.15410924f, -0.12485651f, 0.20862794f, 0.16779478f, 
    -0.02611702f, 0.15056951f, -0.08970004f, 0.06943109f, 0.12717572f, 0.07127091f, 0.07082614f, -0.02996001f, 
    0.00560172f, -0.27311981f, -0.02823191f, 0.01334053f, -0.08506148f, 0.00854480f, -0.03225857f, 0.04892007f, 
    0.00167577f, -0.08366905f, 0.00279910f, 0.05553865f, -0.07390227f, 0.10152017f, -0.01459102f, 0.08124447f, 
    0.05951213f, -0.03139435f, 0.11311112f, 0.19411156f, 0.00909459f, 0.14766650f, -0.05946866f, 0.06389080f, 
    -0.28399050f, 0.08873595f, 0.07417446f, -0.16208285f, -0.08200856f, 0.06882188f, 0.20027547f, -0.05366768f, 
    -0.12688611f, -0.00167782f, -0.01798424f, 0.01854043f, 0.03687268f, 0.05863811f, -0.04929101f, 0.20724508f, 
    -0.03891682f, 0.02894775f, 0.08590316f, 0.21414936f, -0.14523153f, 0.00966104f, -0.16372190f, -0.05476393f, 
    0.06607908f, -0.28796473f, 0.06973326f, -0.10599412f, -0.13855959f, -0.06737337f, 0.09194864f, 0.10690144f, 
    -0.12048385f, 0.01073760f, 0.07059067f, 0.06217244f, -0.16547474f, -0.07903308f, 0.09307522f, -0.02350276f, 
    -0.08156195f, 0.01132073f, -0.05237674f, 0.06574442f, -0.08033732f, 0.00772104f, -0.03944366f, -0.06557588f, 
    0.14922185f, -0.07260663f, 0.22792485f, 0.23246863f, -0.03848026f, 0.05605234f, 0.03620815f, 0.04815409f, 
    -0.07046697f, 0.03255425f, 0.04747642f, -0.07032023f, -0.28842098f, -0.10983993f, -0.20169973f, 0.24897762f, 
    -0.09103023f, 0.01244539f, -0.01917032f, -0.00116752f, 0.02137511f, 0.08264831f, 0.15874490f, -0.03274362f, 
    0.19640455f, -0.18849611f, 0.10047062f, 0.38776562f, -0.10495517f, 0.02780148f, 0.04141227f, 0.00885629f, 
    -0.00838441f, -0.16086435f, -0.02467057f, -0.00605940f, -0.23781094f, 0.18762086f, -0.12391715f, 0.26521692f, 
    0.09519601f, -0.04339267f, -0.01945073f, -0.00330078f, 0.00700976f, 0.00046604f, 0.08683231f, -0.05448893f, 
    -0.18044990f, -0.19390596f, 0.17833574f, 0.04480326f, -0.00121401f, 0.10894214f, 0.01888170f, -0.11515266f, 
    -0.15666997f, 0.06783947f, -0.08240876f, -0.04490794f, -0.17983679f, 0.05786377f, -0.13074130f, -0.02180955f, 
    -0.11893169f, -0.08626308f, 0.11476825f, 0.00135831f, 0.06814834f, -0.05935528f, 0.08232374f, -0.04592107f, 
    0.26366517f, -0.04432184f, -0.03056858f, 0.17359674f, -0.11030295f, 0.15200326f, -0.12062301f, 0.03901066f, 
    -0.05219672f, -0.09013889f, 0.04199827f, -0.13136840f, 0.33118320f, 0.11993160f, -0.15060258f, -0.07060252f, 
    0.11705440f, 0.06014226f, 0.00698521f, -0.03935144f, 0.12865362f, 0.10433351f, 0.05671363f, -0.02713152f, 
    0.06694292f, 0.01627449f, 0.27803805f, 0.05381257f, -0.04111432f, 0.08584324f, 0.05046639f, 0.11712975f, 
    0.05778976f, 0.08626923f, -0.01452759f, 0.07315794f, 0.12482283f, 0.04978911f, 0.11045649f, 0.11065888f, 
    -0.01503613f, -0.04979168f, 0.04640115f, 0.08144845f, -0.06096882f, 0.07912052f, 0.01596777f, 0.10586965f, 
    -0.21315959f, -0.17257008f, 0.18855532f, -0.43770975f, 0.04207038f, 0.01566144f, -0.08589844f, -0.15124522f, 
    0.09555177f, 0.03027597f, 0.12105315f, 0.00626845f, 0.26556990f, 0.06304812f, 0.24085535f, -0.13791774f, 
    -0.11609756f, -0.07456852f, 0.07391411f, 0.11384971f, -0.08667719f, 0.12161111f, -0.12023539f, -0.07418750f, 
    -0.11181536f, -0.09850644f, 0.04569099f, -0.44214186f, 0.08221395f, -0.03399471f, 0.06365133f, -0.09469131f, 
    -0.02103532f, -0.13592750f, -0.06692532f, -0.15896724f, 0.12209502f, -0.01171608f, -0.20969702f, 0.03232439f, 
    -0.04454499f, 0.06068820f, -0.02734102f, 0.03154214f, 0.05215983f, 0.01308518f, -0.00768032f, -0.17857641f, 
    0.08242302f, -0.01338542f, -0.04550662f, 0.04157883f, 0.03125082f, 0.02252010f, -0.03769077f, -0.08276275f, 
    -0.12943543f, 0.10509164f, -0.05296238f, -0.08699948f, 0.03709786f, 0.01898416f, -0.07979611f, -0.17078671f, 
    0.06130867f, 0.02664015f, -0.01066326f, -0.01719145f, -0.00328853f, -0.13694847f, -0.08115903f, -0.00605565f, 
    0.76003963f, 0.07551178f, 0.01080174f, 0.26198459f, 0.11432761f, 0.05533487f, 0.11635315f, -0.06493567f, 
    -0.10933923f, 0.02500284f, -0.00726472f, 0.00078463f, 0.30246344f, -0.15638888f, -0.01331439f, 0.02489115f, 
    -0.09894689f, 0.10797977f, -0.01462665f, -0.00174510f, 0.09048453f, -0.10297914f, 0.02008807f, -0.15019521f, 
    -0.04394169f, -0.15891774f, 0.07795651f, 0.05094714f, -0.06181860f, -0.04103596f, -0.03554522f, 0.05652402f, 
    0.00029326f, 0.06862130f, 0.09959459f, 0.19474331f, 0.54449874f, 0.24798314f, 0.27488288f, -0.10256632f, 
    -0.02931185f, -0.12400338f, 0.02329637f, 0.04258485f, 0.04822798f, 0.05844754f, 0.02864355f, 0.20733544f, 
    -0.07375127f, 0.16134098f, 0.04693748f, 0.05417520f, -0.10435311f, 0.00974442f, -0.00966841f, 0.04692349f, 
    -0.06360386f, 0.04705199f, -0.07272276f, 0.01714280f, 0.06554267f, -0.09634646f, -0.04033728f, 0.09675429f, 
    -0.12007926f, -0.07834166f, -0.03558074f, 0.13556382f, 0.00606263f, -0.02537371f, -0.01605968f, -0.09381296f, 
    0.16556287f, 0.12811123f, 0.03842975f, 0.19543140f, -0.12332080f, 0.11262521f, 0.10001297f, 0.07753370f, 
    0.00629314f, 0.12425324f, 0.13063025f, 0.03699297f, 0.09238763f, 0.07396676f, -0.02446460f, -0.17583178f, 
    0.00503479f, -0.01418578f, -0.10155676f, 0.15009362f, 0.06021995f, -0.00686379f, -0.04174909f, -0.09105089f, 
    -0.00197785f, 0.06526413f, -0.06820047f, -0.06780569f, -0.02848715f, 0.09091758f, 0.16565646f, 0.09944375f, 
    -0.10210102f, -0.04897380f, 0.02450562f, 0.07423077f, -0.19746697f, 0.01388782f, -0.07961497f, 0.08626895f, 
    0.01159350f, 0.02231702f, -0.12140040f, 0.05434963f, -0.01146652f, 0.07145077f, -0.13459632f, 0.07080769f, 
    -0.15057404f, 0.16970047f, 0.07406580f, -0.00300044f, 0.01818602f, 0.01905018f, 0.01485043f, -0.01415797f, 
    0.05107163f, 0.01259205f, -0.02858702f, -0.04639041f, 0.16513723f, -0.22725962f, 0.02966118f, 0.09447458f, 
    -0.11350464f, -0.02850027f, 0.03391837f, 0.13788235f, -0.07981075f, 0.22258282f, -0.26031491f, -0.06618103f, 
    -0.25141931f, 0.18357974f, 0.00260914f, -0.20560981f, -0.05771172f, 0.03403192f, 0.11980688f, -0.03408077f, 
    -0.04088797f, 0.00752070f, -0.13641745f, 0.00382254f, 0.22813517f, 0.12069901f, 0.13189353f, -0.18195504f, 
    -0.05729465f, -0.00152720f, 0.02920882f, 0.05369832f, 0.18621391f, -0.07180119f, -0.08763335f, 0.13652582f, 
    -0.50899595f, 0.11076225f, 0.14282037f, -0.17905402f, 0.01561148f, 0.06566310f, -0.05640434f, 0.11006889f, 
    -0.04063486f, 0.05704799f, -0.01232964f, 0.00333947f, 0.53954840f, 0.01345755f, 0.16112916f, 0.16198836f, 
    -0.08901130f, -0.03556681f, 0.00244119f, 0.06268611f, 0.04619979f, 0.05741032f, 0.07593931f, 0.24557999f, 
    -0.16444153f, -0.22996113f, -0.11216099f, -0.11924452f, 0.05309725f, 0.03812420f, -0.13574970f, 0.02995408f, 
    0.10552768f, -0.04171693f, 0.16844527f, 0.02348641f, -0.19098072f, 0.08836059f, 0.11709550f, 0.08648884f, 
    -0.15475591f, -0.19149563f, -0.03119344f, -0.04846859f, 0.06931529f, -0.04402382f, -0.09569048f, -0.11069079f, 
    0.06227906f, 0.07228069f, 0.13151060f, 0.23967572f, -0.00877417f, 0.06323969f, -0.09143680f, 0.10022773f, 
    0.03183230f, -0.04871190f, 0.13989684f, 0.01759985f, 0.08287323f, 0.19997269f, -0.09673282f, 0.00770675f, 
    -0.04756187f, 0.14859675f, -0.09059222f, -0.08069246f, -0.13153549f, -0.01108378f, 0.08499753f, 0.02866947f, 
    0.39835742f, -0.03325636f, 0.08194872f, -0.24204166f, -0.12997262f, -0.03341227f, 0.08330461f, -0.01289703f, 
    -0.04114790f, -0.04178468f, 0.01641108f, -0.01260500f, 0.16762464f, 0.08057948f, 0.02293231f, -0.29411185f, 
    0.20204858f, 0.05898968f, -0.17099592f, -0.02825934f, 0.00043128f, -0.02466305f, -0.16955805f, 0.04277579f, 
    -0.03521027f, -0.04357121f, -0.16903690f, 0.05176711f, 0.16466819f, -0.01842333f, 0.08948579f, -0.13545208f, 
    -0.12398559f, -0.01953900f, 0.00142083f, 0.12131191f, -0.31444490f, 0.05043106f, 0.16338538f, 0.04124512f, 
    -0.09226232f, -0.04826754f, 0.00498617f, -0.11648372f, -0.07073552f, 0.02632901f, 0.15144181f, 0.02207854f, 
    0.23791000f, -0.05731156f, -0.17983992f, 0.09803068f, 0.05630346f, 0.01642136f, -0.06365287f, 0.04371095f, 
    0.04504143f, 0.11758982f, 0.01593271f, 0.00766930f, 0.05935631f, -0.11441219f, -0.03937991f, 0.27596667f, 
    -0.08886459f, 0.00468071f, -0.11241519f, 0.09735007f, -0.01868162f, -0.05385403f, -0.02390787f, -0.05836995f, 
    0.39386082f, -0.07040730f, 0.14668734f, -0.09915720f, -0.04008420f, 0.02327018f, -0.00180062f, -0.02048433f, 
    0.12031561f, 0.07979538f, 0.00896524f, -0.09982105f, 0.13091424f, 0.00298920f, -0.12050138f, -0.15903144f, 
    -0.01616795f, -0.05195223f, -0.00905724f, -0.01951452f, 0.06479407f, 0.03523775f, 0.19236845f, 0.09556843f, 
    -0.02231116f, 0.12056712f, 0.03675924f, 0.01570319f, 0.00043183f, -0.09941497f, 0.23977454f, -0.03227225f, 
    0.18497078f, 0.07044145f, 0.00836125f, -0.01236416f, 0.12262226f, -0.08923725f, 0.16376670f, 0.20223311f, 
    -0.16344035f, -0.08911900f, 0.08995632f, 0.04993143f, -0.01292288f, 0.12165681f, 0.14275846f, 0.04490225f, 
    -0.30077618f, 0.13138153f, 0.04729997f, 0.01690171f, 0.07869864f, -0.13844842f, 0.17088290f, 0.16738562f, 
    0.09926186f, 0.10947045f, 0.00713819f, 0.09250983f, -0.21491815f, 0.22623624f, -0.05650793f, -0.16615930f, 
    -0.00828562f, 0.07913474f, 0.07878415f, 0.03471871f, 0.04919364f, 0.02074480f, 0.01014689f, 0.12119821f, 
    -0.15174823f, 0.13885494f, 0.05901681f, -0.09846058f, 0.08938505f, 0.06249812f, -0.14165246f, -0.01298792f, 
    0.08221659f, 0.11540010f, 0.00914414f, -0.12070417f, -0.43017378f, -0.08823814f, 0.13343281f, 0.18694933f, 
    -0.04191950f, -0.08485419f, 0.02779023f, -0.17696662f, -0.02942649f, 0.06381569f, -0.11794557f, 0.15164606f, 
    0.01985978f, 0.08494699f, -0.03451355f, -0.45048600f, 0.06241817f, -0.07511657f, 0.07262354f, -0.06812539f, 
    0.15759134f, 0.11641997f, 0.03917737f, -0.08032474f, -0.05881020f, -0.09361488f, -0.01950760f, -0.31489259f, 
    -0.18506874f, 0.02636672f, -0.01426803f, -0.00188868f, -0.11534995f, 0.06300777f, -0.02405514f, -0.03878754f, 
    0.28980064f, -0.06763976f, -0.11593726f, 0.47178048f, -0.06406335f, -0.10851416f, 0.06796958f, 0.01745928f, 
    0.07450839f, -0.02984615f, 0.02813613f, 0.00839271f, 0.37444952f, -0.22512294f, -0.12634023f, 0.28392085f, 
    -0.03587499f, 0.08625880f, -0.03506020f, -0.01571569f, -0.10264015f, -0.05542761f, 0.03917922f, -0.00285948f, 
    0.31081426f, -0.20428701f, 0.01826632f, -0.00683737f, 0.08436042f, 0.09730778f, -0.02890513f, -0.10455531f, 
    -0.01169920f, -0.00490733f, -0.01435664f, 0.08347819f, 0.28544942f, -0.02762311f, 0.01631562f, 0.09774922f, 
    -0.11865099f, 0.04145439f, -0.07471754f, 0.09437278f, 0.13197985f, 0.13192108f, -0.02319693f, 0.05735486f, 
    0.30651179f, -0.18459958f, -0.15576077f, 0.44587752f, -0.04851966f, 0.07340661f, -0.10031368f, 0.03877830f, 
    -0.01378387f, 0.05961640f, -0.04744532f, 0.01082083f, -0.09292045f, 0.03057250f, 0.41377285f, -0.48153383f, 
    -0.08225226f, -0.13878924f, 0.09549220f, -0.03988583f, 0.03964546f, -0.01756110f, 0.14623320f, 0.01297655f, 
    -0.00572048f, 0.07798420f, -0.06902846f, 0.18580420f, 0.04636021f, -0.06090388f, -0.01494179f, 0.09262950f, 
    0.14035313f, 0.01876023f, -0.08043227f, 0.23510401f, -0.26857606f, 0.16070752f, 0.04176087f, -0.00509164f, 
    -0.06800683f, -0.13493110f, 0.12925594f, 0.10013669f, 0.07550195f, -0.06844483f, 0.12029166f, -0.03004998f, 
    0.41351807f, 0.07181365f, -0.11061237f, 0.09989447f, -0.06352611f, -0.05829375f, 0.06505743f, 0.07383189f, 
    0.18382128f, 0.10471637f, 0.12154821f, 0.09469991f, -0.12253581f, -0.12864593f, 0.07346084f, -0.11193246f, 
    0.04128303f, -0.01333984f, 0.13659187f, -0.04512927f, 0.01538191f, -0.21321592f, -0.03051927f, 0.00689919f, 
    0.37230471f, 0.10602509f, -0.22542652f, 0.05394315f, 0.01481944f, -0.10154761f, -0.10495515f, 0.09987547f, 
    0.12584849f, 0.02710846f, 0.04338560f, 0.15786462f, -0.37223715f, 0.24584296f, -0.01376912f, 0.02586780f, 
    -0.06866887f, 0.05019779f, 0.09024217f, 0.05462806f, -0.00373869f, -0.07435690f, 0.01724908f, 0.09014314f, 
    0.17451847f, -0.20252855f, 0.01503788f, -0.08822935f, -0.10716364f, 0.02965476f, 0.08615968f, 0.02918865f, 
    0.03258674f, 0.03896149f, 0.10421719f, -0.03874337f, 0.05348375f, -0.18357535f, 0.00654117f, 0.17311364f, 
    0.02130621f, -0.22021015f, -0.04485974f, -0.04229316f, 0.00853660f, 0.00326525f, -0.15810612f, 0.16118857f, 
    0.19086772f, -0.07810468f, 0.01278202f, 0.36770323f, 0.11482300f, -0.08032345f, 0.04902334f, 0.10690796f, 
    0.05885102f, -0.00764678f, -0.17116812f, 0.05877401f, -0.10297019f, -0.20660451f, 0.13613044f, -0.18910348f, 
    -0.07446755f, -0.17771390f, 0.32028469f, 0.04543665f, 0.09673252f, -0.04754231f, -0.05833034f, 0.17341596f, 
    -0.11740652f, -0.05178645f, -0.11017836f, 0.34076294f, 0.00096127f, -0.00921416f, -0.05940757f, 0.03490690f, 
    0.06033979f, 0.05949090f, -0.03770419f, 0.03843251f, -0.16045456f, -0.31640443f, 0.15078193f, -0.00568816f, 
    -0.16396792f, 0.18436986f, 0.08125269f, -0.11568417f, 0.00408442f, 0.11242275f, 0.03774899f, 0.03491183f, 
    -0.09176756f, 0.32122916f, -0.03258855f, -0.10928248f, 0.04960132f, -0.16402812f, -0.05051957f, 0.33340937f, 
    0.02763818f, 0.08579324f, -0.06113198f, 0.02641601f, -0.06875168f, 0.11343854f, -0.09350567f, -0.08758391f, 
    -0.03235945f, 0.11245998f, -0.03385205f, -0.01442618f, -0.01586584f, 0.04654956f, -0.03579262f, -0.00545864f, 
    -0.10790030f, 0.27316949f, -0.01343805f, 0.15384118f, 0.02857930f, -0.10572831f, 0.18223849f, -0.03809337f, 
    -0.07072590f, -0.01697757f, -0.03131968f, 0.00554911f, -0.04213728f, -0.17223902f, -0.30896685f, -0.06717119f, 
    -0.05298152f, 0.00000634f, 0.07394577f, -0.04324197f, 0.11921272f, 0.03517361f, -0.05911522f, -0.00337500f, 
    0.39370251f, 0.29619479f, -0.16042222f, 0.19752176f, 0.12007104f, 0.00445562f, -0.11124543f, 0.00415700f, 
    -0.03561562f, 0.00726703f, 0.00222237f, 0.16225007f, 0.17508154f, 0.31473562f, 0.09962863f, 0.28095704f, 
    -0.01519139f, 0.05630378f, 0.14469044f, -0.01252808f, 0.04701198f, 0.04939822f, -0.00967058f, 0.00179713f, 
    0.13326901f, 0.04676493f, 0.01157014f, 0.28410959f, 0.01436148f, -0.00541959f, -0.07656990f, 0.11960074f, 
    0.04728386f, 0.02169546f, -0.02847202f, 0.02529441f, -0.18688467f, 0.19437166f, -0.20527308f, -0.27505633f, 
    0.07026566f, -0.02464948f, -0.02620501f, 0.11130584f, -0.04379370f, 0.03335043f, -0.07229829f, 0.08213240f, 
    -0.05714525f, -0.05651421f, 0.15796137f, 0.36038649f, 0.16540898f, 0.03756095f, -0.04981015f, -0.12025532f, 
    0.14300057f, 0.01011617f, 0.19124612f, -0.10700107f, 0.01294432f, 0.09156962f, 0.13735804f, 0.16837758f, 
    -0.11186640f, -0.05932713f, 0.00540413f, -0.07561135f, -0.01660322f, -0.00314860f, 0.09669188f, 0.02583652f, 
    -0.27774796f, 0.11026587f, -0.04771594f, -0.02552837f, 0.03294078f, 0.03013212f, 0.02025636f, 0.18326543f, 
    0.00903952f, 0.10502330f, -0.09799983f, 0.06910608f, -0.00686614f, -0.00568531f, -0.04452243f, -0.12751068f, 
    -0.11993062f, 0.08464803f, -0.06002621f, 0.00926890f, -0.03567241f, 0.02187739f, 0.08777737f, 0.17048132f, 
    -0.07856038f, -0.09799518f, 0.07034359f, 0.53926241f, 0.12961319f, -0.13961092f, 0.06875197f, 0.10308909f, 
    -0.05535419f, 0.00174641f, 0.04791143f, -0.07462899f, -0.16189657f, 0.16782388f, 0.02939050f, 0.32960144f, 
    0.06640345f, 0.01985203f, 0.07990607f, 0.10466263f, 0.02611441f, -0.02739596f, 0.02187871f, -0.03316257f, 
    -0.34143481f, -0.32619971f, 0.02486003f, -0.06380172f, 0.15200154f, 0.03367351f, -0.02912940f, 0.03421531f, 
    0.03364212f, -0.05173326f, 0.01518879f, 0.06243708f, -0.19352654f, 0.18576437f, -0.06850450f, -0.18065171f, 
    -0.01934452f, 0.00344319f, 0.06641226f, -0.09344999f, -0.16606870f, 0.09604748f, 0.04819540f, -0.01713469f, 
    -0.41630387f, 0.14099148f, -0.04527903f, 0.01276847f, 0.04914032f, 0.15118298f, 0.05956476f, -0.01379600f, 
    0.06660213f, 0.05498540f, 0.04967980f, -0.07456785f, -0.11368733f, -0.15979970f, -0.07703991f, -0.01945187f, 
    0.00629396f, 0.00958230f, 0.10357123f, -0.02744909f, -0.00513410f, 0.03705546f, 0.00604399f, 0.00619978f, 
    -0.21177381f, -0.16909736f, -0.07025156f, -0.19252774f, 0.14866599f, 0.07623906f, 0.13377827f, -0.27194038f, 
    0.16394316f, -0.07261375f, 0.02683491f, 0.01280652f, 0.33122873f, 0.16157411f, -0.02896668f, 0.28059784f, 
    -0.13637327f, -0.03129619f, 0.04815991f, 0.06767958f, -0.17188238f, 0.05114389f, 0.04834926f, -0.03155209f, 
    -0.31606248f, -0.21396646f, 0.05855953f, 0.09283718f, -0.12979861f, 0.00884425f, 0.03111808f, 0.05165236f, 
    0.13673277f, 0.02553612f, 0.10318018f, -0.00254360f, 0.24795076f, 0.12028705f, 0.09119879f, 0.04940455f, 
    0.08292346f, 0.16309723f, -0.10353941f, 0.13427268f, 0.02874607f, 0.05929060f, 0.01197616f, 0.00813779f, 
    -0.13398500f, -0.30394331f, 0.03460924f, -0.13542265f, 0.12436008f, 0.01362372f, -0.01116395f, -0.12200014f, 
    0.03828727f, 0.11701792f, 0.01833774f, 0.03244916f, 0.02681734f, 0.20610009f, -0.01557755f, 0.20925005f, 
    -0.01956846f, -0.00035675f, -0.05261828f, 0.17078909f, -0.04435455f, -0.06407180f, -0.07081298f, -0.06841525f, 
    -0.25244084f, -0.39669591f, 0.30326161f, -0.12115468f, 0.05200477f, 0.05015000f, 0.03925908f, -0.07549198f, 
    0.09159357f, 0.05690400f, 0.07532045f, 0.05309068f, -0.15585791f, 0.06388768f, -0.02245087f, 0.12169418f, 
    0.04405250f, 0.00625835f, 0.09383003f, 0.13896467f, -0.10776426f, 0.08893083f, -0.06877903f, -0.06640072f, 
    0.18672079f, 0.24786057f, 0.29406625f, 0.31901330f, 0.15502490f, 0.15151520f, 0.00963063f, 0.10425209f, 
    0.10286960f, -0.02905526f, -0.12222166f, -0.03954095f, -0.31235293f, -0.31323701f, -0.09348047f, -0.02076216f, 
    0.11992311f, 0.07145012f, 0.02480189f, 0.14593062f, 0.01215882f, -0.04638196f, 0.02746414f, -0.01084727f, 
    0.03892887f, -0.10531209f, 0.02548332f, -0.07596868f, 0.01277942f, 0.06809210f, -0.05128925f, -0.02862285f, 
    -0.00583930f, 0.11693866f, 0.03326259f, 0.06600190f, 0.11479699f, 0.20984128f, -0.14485665f, 0.05027556f, 
    0.20487238f, -0.01122832f, -0.19568257f, 0.04055357f, -0.04054296f, -0.01183629f, -0.06749916f, 0.03881935f, 
    0.04322475f, 0.08675309f, -0.03897746f, -0.00210764f, 0.07450277f, 0.01909356f, -0.04353951f, -0.08658991f, 
    -0.08487393f, -0.14784548f, 0.00883087f, 0.07517771f, 0.04346469f, -0.00491553f, 0.23345084f, 0.04787170f, 
    0.09549613f, -0.09029243f, 0.07432728f, 0.09123362f, -0.09286250f, -0.05600522f, 0.12428499f, -0.00752241f, 
    0.46161249f, 0.07282442f, -0.04883355f, 0.17154118f, -0.13306791f, 0.08197124f, -0.17784771f, -0.07893233f, 
    -0.01689888f, -0.02870497f, 0.00654117f, -0.01126247f, -0.10685325f, 0.24619010f, -0.16955478f, 0.16190790f, 
    -0.06204440f, 0.01688511f, -0.08186403f, -0.00406488f, -0.03590770f, 0.01202187f, -0.00404366f, -0.12190825f, 
    0.53964305f, -0.38038406f, -0.05088675f, -0.01873526f, 0.14753054f, 0.00264846f, 0.02605083f, 0.08279155f, 
    -0.01347026f, 0.03640384f, -0.08107935f, -0.06596802f, -0.11938423f, 0.08129293f, -0.01953905f, -0.11680771f, 
    0.00594314f, 0.03594100f, 0.00644115f, -0.00858377f, 0.03732256f, 0.10014975f, -0.03330722f, 0.07249139f, 
    -0.11989252f, -0.27436209f, -0.17948471f, -0.16808112f, 0.08327859f, 0.01710231f, 0.03858738f, -0.05400618f, 
    0.00699257f, 0.07043839f, 0.04906096f, 0.09409811f, 0.35981309f, -0.06793275f, -0.09496046f, 0.00582574f, 
    0.02658934f, 0.04930163f, 0.04005866f, -0.02284602f, -0.15516968f, -0.08100902f, -0.10375801f, -0.06692832f, 
    0.23381177f, -0.02405208f, -0.17178218f, -0.02436611f, 0.07583374f, 0.12573385f, 0.12056405f, 0.03778431f, 
    0.00350143f, -0.12516925f, -0.13050455f, -0.03646680f, 0.15137739f, -0.17112419f, -0.04791504f, -0.16900800f, 
    0.07472332f, 0.12140560f, -0.12018330f, 0.00611706f, -0.05432661f, 0.05713107f, 0.13319318f, 0.02541934f, 
    0.26067930f, 0.10950378f, -0.17378701f, -0.03500746f, 0.08704303f, 0.02073494f, -0.04178706f, 0.13360891f, 
    -0.10965361f, -0.08844630f, 0.01412440f, -0.04401490f, 0.38356066f, -0.27128243f, -0.20501137f, -0.23674783f, 
    -0.00233625f, 0.14496835f, -0.02698251f, 0.01168785f, 0.04959847f, 0.03891637f, 0.04033535f, -0.10431255f, 
    -0.05828951f, -0.15671346f, -0.22833566f, -0.13639335f, 0.12658346f, 0.01122851f, 0.03634214f, 0.22612575f, 
    -0.10251576f, -0.02490216f, 0.09445804f, 0.12963715f, 0.04827888f, 0.25778618f, 0.06468477f, 0.19168133f, 
    -0.08239303f, -0.08478879f, -0.03621670f, 0.07955866f, -0.03725576f, -0.06944628f, 0.10042671f, -0.11152314f, 
    0.03287508f, -0.22220263f, -0.09230944f, -0.12414753f, -0.13599764f, -0.05268091f, -0.00542230f, 0.05340961f, 
    -0.00209639f, 0.02393259f, -0.02230800f, 0.07268723f, 0.27963242f, 0.00948356f, -0.25458711f, -0.08794205f, 
    -0.10309934f, -0.06069996f, -0.02555764f, -0.17789893f, 0.09717344f, 0.08043018f, 0.07862230f, 0.07307725f, 
    0.20323579f, 0.28330827f, 0.04587643f, -0.22502278f, 0.01643066f, 0.12617519f, 0.07814041f, -0.06633323f, 
    0.07419945f, 0.00132234f, 0.02608442f, 0.16067591f, -0.02304289f, -0.47220984f, 0.09192834f, -0.06878731f, 
    0.19367760f, 0.01606366f, -0.03419361f, 0.09791185f, -0.08185092f, 0.01413333f, -0.21968602f, -0.16532104f, 
    -0.04458139f, -0.08150690f, 0.14154166f, 0.01214482f, 0.14819854f, 0.00159581f, -0.03230521f, 0.08777709f, 
    0.03565722f, -0.00991978f, 0.05136788f, -0.00052457f, -0.35362402f, 0.00344728f, -0.04266355f, 0.09954444f, 
    0.09820097f, -0.00760228f, 0.07202567f, -0.02805034f, -0.03694518f, 0.01205660f, -0.17465137f, -0.01323690f, 
    -0.21086267f, -0.08748475f, -0.13845453f, 0.03802966f, 0.10885771f, 0.00915786f, 0.11711951f, 0.06205554f, 
    0.06426007f, 0.10226674f, 0.02170466f, 0.11775400f, -0.19315942f, 0.03553787f, -0.10985033f, -0.11310402f, 
    0.07642419f, -0.05686825f, -0.01477448f, 0.15345840f, 0.05886725f, 0.17734809f, -0.00847745f, 0.02680703f, 
    0.08522435f, 0.28877747f, -0.10481039f, -0.12158585f, 0.17821038f, 0.12563662f, -0.02724717f, -0.02933535f, 
    0.02995753f, -0.06500918f, -0.17955555f, -0.14102644f, 0.20724466f, 0.28742653f, -0.18203931f, 0.11226256f, 
    -0.02523099f, -0.10990775f, 0.06783450f, 0.08841997f, -0.06432992f, -0.04410848f, -0.15808399f, -0.09620116f, 
    0.09853469f, -0.01902754f, -0.04183560f, -0.06458985f, 0.03342420f, 0.12567154f, -0.06434442f, 0.00435508f, 
    0.01897431f, 0.05592273f, -0.05277219f, 0.10827412f, 0.37284276f, -0.23052591f, -0.10219859f, 0.04680985f, 
    -0.00906332f, -0.14123794f, 0.09222320f, 0.06493982f, 0.05412324f, 0.12167082f, -0.04464409f, 0.03880154f, 
    0.39151514f, 0.02172940f, 0.00010424f, -0.07688601f, 0.08278620f, -0.08332393f, 0.05176205f, 0.02329408f, 
    0.09895153f, 0.08039229f, -0.04845447f, 0.09526952f, 0.70883870f, -0.13768962f, -0.26133394f, 0.23927157f, 
    0.01992252f, 0.03801632f, 0.12483618f, 0.05167112f, -0.00017540f, -0.00458637f, 0.08535782f, -0.07770459f, 
    -0.13002931f, -0.11751842f, -0.03620326f, -0.16543424f, 0.12792751f, -0.00219280f, -0.10125141f, 0.06115892f, 
    0.08699094f, 0.03498484f, -0.01744730f, 0.05894153f, 0.11974747f, 0.21303779f, 0.17161222f, -0.00543411f, 
    -0.05372151f, -0.03331900f, 0.05006436f, 0.00745355f, 0.01740870f, 0.04231977f, 0.09906036f, -0.03921135f, 
    0.01229835f, 0.14207064f, -0.13090248f, -0.23689918f, 0.01087160f, 0.16736223f, 0.04081649f, 0.03119012f, 
    0.13730451f, -0.03636707f, 0.08007005f, -0.05300992f, -0.16056731f, 0.18921262f, 0.06278669f, -0.08888738f, 
    0.07941803f, 0.18677008f, 0.04371202f, 0.03860672f, 0.00189048f, 0.02265283f, 0.11854265f, -0.02727925f, 
    0.07886219f, -0.13405706f, -0.10282116f, -0.09829579f, -0.06548857f, 0.11832040f, -0.04941124f, -0.04560959f, 
    -0.02835803f, -0.06320118f, -0.00079174f, -0.06815840f, 0.01065601f, -0.32298920f, -0.18082030f, 0.17743428f, 
    0.07393798f, 0.00416400f, 0.11049809f, -0.00558315f, 0.01148639f, -0.05206726f, -0.02646141f, 0.02675253f, 
    0.12814833f, -0.11796238f, 0.10005070f, -0.18673642f, -0.04569599f, -0.00348151f, 0.22059235f, -0.09409638f, 
    -0.03405726f, -0.07242481f, 0.03151517f, 0.10833649f, -0.04467050f, -0.06080848f, 0.14541394f, 0.17228509f, 
    -0.05074755f, -0.05529988f, 0.06964970f, 0.08114240f, 0.05811448f, 0.02584633f, -0.13134845f, -0.15018354f, 
    0.24518190f, -0.19642732f, -0.20342200f, -0.23078708f, -0.06044819f, 0.01351174f, -0.15832207f, 0.06732928f, 
    0.00421375f, -0.00589732f, -0.03556916f, -0.03020022f, -0.17831030f, -0.04527301f, 0.05640623f, -0.15874194f, 
    -0.19727442f, -0.00574682f, -0.01668044f, 0.07946274f, 0.12757553f, -0.06472871f, 0.02132668f, 0.17312232f, 
    0.29710540f, 0.07878169f, -0.11994676f, 0.20391627f, -0.00944889f, -0.01093813f, 0.15980884f, 0.05219309f, 
    -0.03937992f, 0.16267656f, -0.08086876f, 0.00903372f, 0.08641771f, 0.10678293f, -0.26942545f, -0.07319622f, 
    -0.04604062f, 0.07114131f, 0.00004226f, 0.04235186f, 0.04854038f, 0.04342213f, 0.10365257f, 0.06659694f, 
    0.34435493f, 0.09600563f, 0.15699057f, -0.11709201f, -0.02660346f, 0.07883552f, -0.02359315f, 0.02389359f, 
    -0.01739312f, 0.04733413f, 0.06223213f, 0.00389016f, -0.19819646f, -0.20009542f, 0.27744970f, 0.06472709f, 
    -0.11176408f, 0.05457655f, 0.02639515f, -0.02032719f, 0.14696282f, 0.08723436f, 0.07371265f, -0.09828079f, 
    0.19864392f, 0.05483158f, 0.12239070f, -0.01624696f, 0.01064861f, 0.15558569f, 0.07837599f, 0.11464270f, 
    -0.13083263f, 0.03133507f, -0.05907162f, 0.07755386f, -0.10438344f, 0.10087869f, 0.06029227f, 0.06186351f, 
    0.05019688f, -0.01218954f, -0.12112203f, -0.05227682f, -0.01963388f, 0.09003889f, -0.06242377f, -0.10694829f, 
    -0.69958830f, 0.19329719f, -0.07781443f, -0.11656972f, -0.02140723f, 0.01730398f, -0.04289315f, 0.05217030f, 
    -0.03071239f, 0.05120433f, 0.05284269f, -0.00088801f, -0.08079160f, 0.06932950f, 0.25721192f, 0.03150337f, 
    0.00560615f, -0.04562431f, 0.07063913f, 0.01950720f, 0.01599700f, 0.00965583f, -0.11411292f, -0.06735238f, 
    -0.06711127f, 0.07063270f, -0.00987845f, -0.31567803f, -0.10506846f, 0.02067962f, 0.02954254f, -0.09579264f, 
    -0.03093439f, -0.04667774f, -0.07682429f, 0.03228933f, 0.06661604f, 0.00486700f, -0.22668932f, 0.11394849f, 
    -0.14666738f, 0.05686907f, 0.01652420f, -0.06207253f, -0.03456080f, -0.00083198f, 0.18262747f, -0.06262123f, 
    0.01148927f, 0.13820350f, 0.13650769f, 0.01831418f, 0.01203501f, -0.03009990f, -0.00526160f, 0.00507530f, 
    0.01284207f, 0.02537091f, 0.07792933f, -0.00291921f, 0.05894968f, -0.20597303f, 0.15169014f, -0.10902305f, 
    -0.06250988f, -0.00897936f, 0.00739436f, -0.00905092f, -0.01762759f, -0.03664303f, 0.01604409f, -0.03666488f, 
    0.04759743f, -0.32305196f, 0.04587532f, -0.10249925f, -0.09178821f, -0.01831178f, -0.05336878f, -0.03851143f, 
    -0.05565153f, -0.01477941f, -0.04085635f, 0.03438781f, -0.23669642f, -0.11460309f, 0.40868634f, -0.00633769f, 
    0.05972582f, 0.08734712f, -0.08057240f, -0.04664372f, 0.10719813f, -0.08660115f, 0.19801168f, 0.10109517f, 
    0.17029516f, -0.11268164f, 0.16375473f, 0.07385890f, -0.08620067f, 0.06117165f, 0.04984395f, 0.12518273f, 
    -0.03393815f, 0.02530183f, -0.08420595f, -0.06870661f, -0.00980592f, 0.01764205f, 0.19987229f, -0.19795851f, 
    -0.00190600f, -0.17114881f, 0.01642567f, -0.14281672f, -0.01266655f, 0.05593703f, -0.01634116f, 0.06680116f, 
    -0.14176516f, 0.36824661f, -0.00076438f, 0.09839927f, 0.15874028f, 0.11437926f, 0.12964755f, -0.00647721f, 
    -0.03664559f, -0.07517143f, 0.04849434f, 0.06838767f, -0.04811251f, 0.23879224f, -0.10043127f, 0.06746092f, 
    0.00267772f, -0.11728209f, 0.03465393f, -0.03104316f, -0.01266300f, -0.05844674f, 0.11540239f, 0.03286796f, 
    0.11500905f, -0.14399453f, -0.10164130f, 0.47093523f, 0.07646231f, 0.01395568f, 0.03714641f, 0.25406659f, 
    0.05537521f, 0.06188777f, -0.03937539f, 0.05208892f, 0.43922421f, 0.03323217f, -0.14969279f, 0.01222483f, 
    -0.04989275f, 0.01597613f, 0.08695804f, -0.20430076f, 0.05038203f, 0.00699872f, 0.12537955f, -0.05376471f, 
    0.02348099f, 0.11629857f, -0.17220247f, 0.30479869f, 0.02850387f, 0.07079077f, 0.10837360f, 0.01559355f, 
    0.01151704f, -0.03967137f, -0.04188427f, 0.05958927f, 0.53868061f, -0.09560338f, 0.19158551f, -0.21578433f, 
    -0.01483701f, 0.13127378f, 0.09879544f, 0.06865986f, 0.00374447f, -0.09312925f, -0.08078996f, 0.07957824f, 
    0.29196107f, -0.00302657f, -0.02895774f, 0.03143805f, -0.04273921f, -0.02325812f, 0.23764400f, -0.05029771f, 
    0.02485598f, -0.09848041f, 0.01834509f, 0.03143121f, 0.06342900f, 0.10915495f, 0.06456191f, -0.06026698f, 
    0.10714982f, -0.06561565f, 0.07930913f, 0.09252049f, 0.04508692f, 0.01018652f, -0.00244644f, 0.02904009f, 
    -0.04902396f, 0.15634225f, -0.05169666f, -0.18391709f, 0.02005801f, 0.07982597f, 0.11617150f, 0.12141736f, 
    -0.04437228f, 0.15474495f, -0.04910027f, -0.08862907f, -0.05196713f, -0.02247798f, 0.12207932f, 0.06845775f, 
    0.08326735f, 0.01319365f, 0.20537050f, 0.19311018f, -0.06075575f, 0.06175431f, -0.06873299f, 0.02035966f, 
    -0.08795781f, 0.11847870f, 0.01152313f, 0.22098181f, 0.07267775f, 0.07653586f, 0.02120960f, -0.00682607f, 
    0.05624887f, 0.14065441f, 0.05603278f, 0.02191022f, -0.20196372f, 0.23661579f, 0.00554859f, 0.21709609f, 
    0.16768974f, 0.18625396f, -0.06981153f, 0.18633763f, 0.07644521f, 0.14957592f, -0.03926582f, -0.00892661f, 
    0.18069363f, 0.05699884f, 0.20160976f, 0.03170688f, 0.06497942f, -0.02785597f, -0.10366610f, 0.15942515f, 
    0.07372320f, 0.00301345f, 0.02811470f, -0.11700292f, 0.21446542f, 0.16321358f, 0.09420699f, 0.02721268f, 
    0.03267086f, 0.05297457f, 0.03221425f, -0.08489113f, 0.10818895f, 0.11356282f, 0.02194150f, 0.04500050f, 
    -0.09662332f, 0.13991642f, 0.21268584f, 0.05924359f, -0.07767881f, 0.06086508f, 0.12412775f, -0.06194624f, 
    0.02028467f, -0.04428949f, 0.09451199f, -0.06446702f, -0.25577244f, -0.12792063f, -0.21999961f, -0.21985540f, 
    0.10042147f, 0.06304732f, 0.08543777f, -0.04993702f, -0.04888085f, 0.04265723f, -0.09287064f, -0.15737098f, 
    0.23287292f, 0.19219287f, 0.10447877f, 0.41153619f, 0.05834130f, 0.03235655f, -0.15674753f, 0.08002334f, 
    -0.00977224f, -0.00655763f, 0.19002621f, 0.01208099f, 0.20083904f, 0.11601659f, 0.13266775f, 0.05380984f, 
    -0.10190924f, 0.08241948f, -0.01297459f, -0.17898163f, -0.05169997f, -0.04332311f, -0.06029564f, 0.03721019f, 
    0.08986945f, 0.01869140f, -0.05423049f, 0.15997069f, 0.07736976f, 0.02954177f, -0.18059818f, -0.02035508f, 
    -0.05048738f, -0.01302613f, -0.06640190f, -0.13572769f, -0.12883192f, -0.34172854f, -0.03995348f, -0.01936818f, 
    -0.02270091f, 0.01371153f, -0.02251017f, -0.05460241f, -0.12981567f, 0.03340581f, -0.09391538f, 0.12199322f, 
    0.10048051f, 0.11059360f, 0.12951848f, 0.05773232f, 0.03080459f, 0.03013715f, -0.11534470f, 0.04852359f, 
    -0.01066165f, 0.00592759f, 0.06111117f, -0.24772793f, 0.18433324f, -0.01050726f, 0.21302354f, 0.24826719f, 
    0.14518569f, 0.04104845f, -0.10871375f, 0.02374085f, -0.08724634f, -0.08214049f, 0.02750540f, -0.02284636f, 
    0.01904109f, 0.16224234f, -0.00489224f, -0.07365836f, -0.04622809f, 0.04493345f, 0.04613340f, 0.19362123f, 
    -0.07166000f, -0.13281332f, -0.13156717f, 0.04939501f, 0.52937025f, 0.10175178f, 0.21045664f, -0.05924773f, 
    0.05194027f, 0.02277517f, 0.02295716f, 0.01164335f, 0.10817657f, -0.02307411f, 0.23148197f, -0.04837273f, 
    0.02940593f, 0.32460111f, 0.03447850f, 0.13427275f, -0.09918783f, -0.06962088f, 0.08690366f, -0.08062790f, 
    -0.15874907f, 0.09690526f, -0.05349310f, 0.00980868f, 0.39252985f, 0.15862370f, 0.17825806f, 0.08411174f, 
    0.04369634f, 0.17885657f, 0.13195650f, 0.02207514f, 0.03217751f, -0.06711189f, -0.03231631f, -0.02803570f, 
    0.09731973f, -0.07294008f, -0.28072256f, -0.29288232f, 0.18405871f, -0.01223113f, 0.00725324f, -0.07140121f, 
    0.05663164f, 0.03693200f, -0.07383554f, -0.08412790f, -0.23719329f, -0.13435712f, -0.07447243f, 0.01272502f, 
    -0.06609972f, -0.04317456f, 0.13569900f, -0.03704808f, 0.03905582f, 0.13247167f, 0.02529544f, 0.08720090f, 
    -0.29655460f, 0.04284646f, -0.18203177f, -0.05358711f, 0.05894573f, 0.10511196f, 0.12842959f, 0.07792803f, 
    -0.08900262f, 0.01877844f, 0.10198181f, -0.19227603f, -0.43886417f, -0.10198466f, -0.18019629f, 0.02382172f, 
    -0.00195563f, 0.13131440f, 0.13914719f, -0.07112887f, -0.12972902f, -0.14492297f, -0.00939301f, 0.00202708f, 
    -0.22566172f, 0.12730537f, -0.13969967f, -0.22404471f, 0.21498501f, 0.10588384f, 0.09500598f, -0.03906148f, 
    -0.01869527f, 0.04545059f, 0.23129807f, -0.04918432f, 0.10302772f, 0.31102738f, -0.01985164f, 0.38524219f, 
    -0.00140946f, -0.20502953f, -0.03531588f, 0.03082219f, 0.04766662f, 0.14494210f, -0.05387742f, -0.09828765f, 
    0.02651188f, -0.15870105f, -0.19593108f, -0.07695230f, 0.03461616f, -0.00259377f, -0.07932693f, 0.05623515f, 
    -0.07903723f, -0.02411275f, -0.02283319f, -0.15036374f, 0.03942594f, 0.01879799f, 0.20409113f, 0.06209955f, 
    0.00284087f, -0.01041284f, 0.00882701f, -0.14970355f, -0.09475666f, 0.03246383f, -0.21861149f, -0.12954481f, 
    0.37266675f, -0.07043426f, -0.03129976f, 0.18523625f, 0.12289601f, 0.04941535f, -0.06259409f, -0.01919691f, 
    -0.00619032f, -0.12509038f, -0.09289052f, 0.04735130f, 0.08714898f, 0.31432241f, 0.16304761f, 0.05732986f, 
    -0.01937970f, -0.01539759f, 0.09856267f, -0.05334904f, -0.00830964f, 0.21803236f, 0.14161582f, 0.14909686f, 
    0.33581719f, -0.10725004f, -0.15565687f, 0.01348211f, -0.04307602f, -0.01857035f, -0.02120045f, 0.09162822f, 
    0.06801919f, 0.10640073f, -0.03623515f, 0.02410393f, 0.11598480f, 0.08758740f, 0.21760346f, 0.05288546f, 
    0.21264900f, 0.04945627f, 0.03302610f, -0.12548415f, 0.03389249f, 0.15013190f, -0.04018890f, 0.03956133f, 
    0.13901247f, 0.16753197f, -0.00253533f, 0.21264148f, 0.16656750f, 0.04303170f, -0.13618377f, 0.14308020f, 
    0.15904190f, 0.07330776f, -0.00115544f, 0.02581343f, -0.03125647f, -0.01489612f, -0.09876069f, -0.01705165f, 
    0.05294186f, 0.02908179f, 0.14698809f, 0.04175942f, -0.03314054f, 0.09401134f, 0.03233914f, -0.08576475f, 
    -0.15127918f, -0.04584275f, -0.13213554f, -0.30208907f, 0.04395734f, -0.00168435f, -0.08914913f, -0.01065088f, 
    -0.01345340f, 0.05331290f, 0.15938656f, 0.11596005f, 0.34200361f, 0.10932851f, -0.13719319f, 0.26752740f, 
    0.07564449f, 0.08156348f, -0.11420470f, 0.15561366f, -0.07944413f, 0.01052946f, 0.01379242f, -0.04169469f, 
    0.31700724f, -0.12610342f, 0.02257752f, -0.28817713f, -0.05128890f, -0.11924692f, 0.03545579f, -0.03812355f, 
    0.02240792f, -0.09754626f, -0.09840637f, -0.03172200f, 0.44958133f, -0.11888306f, 0.03380623f, -0.25919944f, 
    -0.11398672f, -0.06518070f, 0.14545514f, -0.04539092f, -0.13368054f, -0.04112349f, 0.00208394f, 0.12707563f, 
    0.00996301f, 0.07100924f, -0.08012574f, -0.12724833f, 0.01172438f, -0.09777446f, -0.08869328f, -0.08039554f, 
    0.04468301f, 0.04319825f, 0.02858518f, 0.10454630f, -0.11685649f, 0.17776711f, -0.09095135f, -0.12453201f, 
    -0.09172425f, -0.08692163f, -0.13361770f, 0.19674471f, -0.15125318f, -0.06909341f, -0.00598160f, -0.24300967f, 
    0.24724628f, 0.01365488f, -0.07451162f, -0.02292229f, 0.04320262f, -0.05763925f, -0.14154293f, 0.01135101f, 
    -0.05343576f, -0.02613520f, -0.01581661f, 0.09037364f, 0.52573210f, -0.05639118f, 0.00965070f, 0.25046957f, 
    0.07153318f, -0.00146047f, 0.05790201f, 0.02947049f, 0.13800743f, -0.08130845f, 0.03182698f, 0.12960340f, 
    0.32523978f, -0.02402550f, -0.17828751f, -0.30663976f, 0.05867172f, 0.01589216f, 0.21041317f, -0.11394782f, 
    0.04189522f, 0.06117901f, -0.20430614f, 0.02606394f, -0.07244831f, 0.03911674f, 0.02563013f, -0.00115671f, 
    0.06393378f, -0.03771954f, 0.02526442f, 0.10210074f, 0.03576205f, -0.04621390f, -0.00783292f, 0.08056768f, 
    -0.09517033f, 0.02700281f, 0.18896678f, -0.10532848f, -0.06467980f, -0.04615832f, -0.00470312f, 0.09287582f, 
    0.03919660f, 0.09525160f, 0.03616346f, 0.07841661f, -0.16468109f, 0.10370725f, 0.18656702f, 0.34412110f, 
    -0.04186001f, 0.10256038f, 0.00372931f, 0.01519236f, 0.12554139f, 0.01797911f, 0.01257518f, 0.06151241f, 
    0.01958405f, -0.12883882f, -0.03272950f, 0.14419968f, 0.05545527f, 0.01028040f, -0.02049725f, 0.01640359f, 
    0.04941665f, -0.08420085f, 0.04854026f, 0.17008598f, 0.05901912f, 0.10366168f, -0.03842713f, -0.26294062f, 
    -0.05320917f, -0.11313199f, -0.02988097f, -0.06976031f, 0.09040387f, 0.11954607f, 0.03463719f, 0.06659096f, 
    -0.12558950f, 0.27853939f, -0.04056897f, -0.03932562f, 0.01477184f, 0.07149214f, -0.04749628f, -0.02664970f, 
    0.14499521f, 0.00066033f, 0.02762915f, -0.06887837f, -0.24683869f, 0.03381946f, -0.11165916f, -0.03519312f, 
    -0.07362910f, 0.01601756f, -0.05477810f, 0.01517338f, -0.16390166f, -0.00527368f, -0.08051956f, 0.03812308f, 
    -0.07010972f, -0.19899966f, 0.09137868f, 0.07689327f, 0.12538071f, -0.02161811f, -0.08674802f, 0.09937714f, 
    0.18774404f, -0.00992044f, 0.01368331f, 0.02432655f, -0.23342866f, -0.08054301f, 0.03277008f, 0.04990252f, 
    0.05052336f, -0.26010469f, -0.08100320f, 0.12148628f, 0.10504134f, 0.08267017f, -0.03794165f, -0.15642583f, 
    0.10334975f, -0.09729186f, 0.13176294f, 0.44833454f, -0.02154769f, 0.25233358f, 0.05989718f, -0.00791026f, 
    0.11953218f, -0.01631035f, -0.01888949f, -0.04791541f, 0.57997543f, -0.21528803f, 0.22688724f, -0.01705732f, 
    -0.07362805f, -0.02969255f, -0.05640316f, 0.07150713f, -0.15545554f, -0.09811044f, 0.00409701f, 0.11883014f, 
    0.26636612f, 0.13095604f, 0.10392582f, 0.05133897f, 0.01952414f, -0.00041308f, -0.06226118f, -0.02903692f, 
    0.05416356f, -0.06967304f, -0.07052618f, 0.07734343f, 0.17004554f, 0.11411162f, 0.25575045f, 0.13560478f, 
    0.20412841f, -0.07913462f, -0.04118937f, 0.01694444f, 0.20001151f, 0.04294027f, -0.01829101f, 0.03243687f, 
    0.54765761f, -0.12944372f, 0.09332994f, 0.09922338f, -0.04315876f, -0.08025976f, 0.03511506f, -0.01749176f, 
    -0.00162373f, -0.00484647f, -0.12926151f, 0.01938311f, -0.21291089f, -0.26427284f, -0.03351115f, -0.02008016f, 
    0.01658205f, 0.10332292f, 0.05169161f, -0.05372095f, 0.04857925f, -0.09012389f, 0.09158715f, 0.14603628f, 
    0.06217979f, 0.10689707f, -0.03348413f, 0.52091789f, 0.07509971f, 0.07556410f, 0.12695739f, -0.07863096f, 
    0.07023766f, 0.04609327f, 0.06834619f, 0.16704893f, 0.06554291f, -0.09465470f, -0.00872272f, 0.11181130f, 
    -0.04696486f, 0.04031385f, -0.07228271f, 0.10964151f, -0.00819944f, -0.17349784f, 0.23108542f, 0.12807944f, 
    -0.25437117f, -0.06216808f, -0.16884056f, -0.42896053f, 0.03224678f, 0.11513791f, 0.08705546f, 0.08926219f, 
    0.07487618f, 0.15466233f, 0.03270650f, 0.06260520f, 0.00055374f, -0.07808568f, -0.16699551f, 0.13636668f, 
    0.05582456f, -0.12160271f, -0.03384397f, 0.20653424f, 0.00160711f, -0.05499949f, -0.17295466f, -0.04848093f, 
    -0.06093440f, -0.00720336f, -0.00586043f, -0.04871128f, 0.06759040f, 0.08537787f, 0.13823494f, -0.09298079f, 
    -0.03493495f, 0.00967259f, 0.04568992f, 0.04302397f, 0.15537266f, 0.00427659f, -0.05244086f, 0.07788664f, 
    -0.09424963f, 0.06666276f, 0.02389660f, 0.05802003f, -0.04690184f, 0.00527854f, -0.00749717f, -0.03956273f, 
    -0.11826138f, -0.19045275f, 0.12367924f, -0.15967081f, -0.03080237f, 0.08335746f, 0.17644256f, 0.06577194f, 
    -0.19884408f, 0.06994221f, 0.05834037f, -0.10578422f, 0.11915666f, -0.12151024f, 0.10949462f, 0.24009338f, 
    -0.00325421f, 0.11180758f, -0.11305321f, 0.01503609f, -0.05286416f, -0.07262523f, 0.08917417f, -0.00323999f, 
    0.28815192f, -0.00708435f, -0.04329289f, 0.42116144f, 0.13573590f, 0.10098756f, 0.05699300f, -0.00710044f, 
    -0.00942820f, 0.02767845f, -0.05631419f, -0.02103799f, -0.43741316f, 0.07557277f, -0.02849301f, -0.22337268f, 
    0.03134339f, 0.01291235f, 0.06407384f, -0.05424080f, 0.07465988f, 0.03398008f, -0.00785434f, 0.05719936f, 
    -0.02424169f, -0.02220475f, -0.04794752f, -0.03460122f, -0.05266757f, 0.02552193f, -0.01094720f, -0.01086765f, 
    0.03262839f, -0.00814471f, -0.03929693f, -0.04257448f, 0.00046715f, 0.03101322f, -0.01863826f, -0.05420827f, 
    0.03861129f, -0.04533277f, -0.02734256f, 0.02523969f, -0.04642030f, -0.00372058f, -0.05370840f, 0.01245789f, 
    0.01752740f, -0.00486227f, -0.00914429f, 0.02803786f, -0.03620793f, 0.00391458f, -0.01631890f, 0.02841038f, 
    -0.03075201f, 0.02140218f, 0.01527284f, 0.00315488f, 0.01056319f, -0.02165114f, 0.02040314f, 0.02050099f, 
    -0.04957534f, 0.01368546f, -0.04222804f, -0.03456279f, -0.00296440f, 0.03635753f, 0.04296296f, 0.00614283f, 
    -0.03769883f, -0.02975675f, 0.03689104f, -0.01634418f, -0.03980318f, -0.04781847f, -0.02386955f, -0.04966573f, 
    0.04037324f, 0.00731492f, -0.05686397f, -0.04185754f, 0.01415845f, -0.03291300f, 0.00549229f, -0.03367485f, 
    -0.00195434f, -0.05261653f, -0.03967282f, -0.02877213f, -0.05051636f, -0.04905066f, -0.02383961f, 0.02883706f, 
    -0.01893195f, 0.03214125f, 0.00263573f, 0.03359583f, 0.00940070f, 0.01060950f, 0.04066328f, -0.03478124f, 
    -0.04212820f, -0.03539279f, -0.05817927f, -0.04941884f, -0.00607684f, -0.03053024f, -0.00137122f, -0.05230326f, 
    -0.03066578f, 0.01657148f, -0.05397228f, -0.02705848f, -0.05176518f, -0.05038757f, 0.00175811f, -0.04240449f, 
    -0.03925003f, -0.01982483f, 0.03105259f, -0.04698792f, -0.01483042f, 0.04101881f, -0.01850946f, -0.04059272f, 
    -0.04870937f, 0.02907009f, 0.03078742f, -0.04114792f, -0.00294357f, -0.02592362f, -0.00866633f, 0.01657777f, 
    -0.02046691f, -0.03879272f, -0.04034462f, -0.01984668f, -0.04587202f, -0.01399769f, 0.01415456f, -0.03382976f, 
    -0.05950620f, -0.01630016f, -0.01091598f, 0.02660824f, -0.02624970f, 0.01674913f, -0.02161184f, -0.02090498f, 
    -0.04143776f, 0.00408126f, 0.03220981f, -0.00387816f, 0.00759145f, 0.01767689f, 0.02090454f, 0.03935288f, 
    -0.02483604f, -0.02479002f, -0.01649498f, -0.02760766f, 0.00717133f, -0.05433832f, -0.00377125f, -0.03299240f, 
    -0.04581589f, -0.03724148f, -0.01212581f, 0.01740467f, 0.02903020f, -0.02913363f, -0.01774081f, -0.01055252f, 
    -0.01655406f, 0.02010285f, -0.00299782f, -0.02839137f, 0.00526133f, -0.00800883f, -0.02883918f, -0.01255261f, 
    -0.05022321f, -0.04821490f, 0.02829840f, 0.03612687f, -0.04180230f, 0.03202966f, 0.03984772f, 0.02377752f, 
    -0.04978711f, 0.01848910f, 0.03391195f, -0.00487169f, 0.02946489f, 0.00704343f, 0.04095021f, 0.03569089f, 
    -0.02406090f, -0.00878311f, -0.02114683f, -0.01558075f, -0.01238276f, -0.00961879f, -0.01658502f, -0.02971697f, 
    0.04327780f, -0.04793005f, 0.00007875f, 0.04773406f, -0.03891363f, -0.04994063f, 0.04199793f, 0.01749694f, 
    0.03405950f, 0.02697735f, -0.04548170f, 0.00004819f, 0.01582974f, 0.00911547f, -0.01701327f, -0.04067984f, 
    -0.01950174f, 0.00606623f, -0.03193140f, 0.01752979f, -0.03987641f, 0.04308339f, 0.00366134f, 0.03510997f, 
    -0.05108142f, -0.04949879f, -0.00049293f, -0.04578263f, -0.03206518f, 0.02594332f, 0.00852876f, 0.02648401f, 
    0.01876624f, 0.03278690f, -0.00264030f, -0.02598706f, 0.00537527f, 0.02067144f, -0.05499703f, -0.03513830f, 
    0.02165130f, 0.03956356f, -0.00812208f, -0.03428122f, -0.03221595f, -0.03110524f, -0.02612815f, -0.00271100f, 
    0.02211077f, 0.00314294f, -0.01369657f, 0.03789406f, -0.02603181f, -0.03349579f, 0.01289851f, -0.02115972f, 
    0.00138544f, -0.03020369f, -0.03726328f, 0.01134193f, -0.02969788f, 0.03181240f, 0.01596393f, 0.03390581f, 
    -0.00347355f, 0.00722598f, 0.00682648f, 0.03790564f, -0.04438813f, 0.03864560f, 0.01425745f, 0.01883766f, 
    0.02126851f, -0.00835253f, -0.02986446f, -0.03411210f, 0.00375144f, -0.04528056f, -0.01393537f, 0.01570759f, 
    0.04084494f, -0.01454880f, 0.03829969f, -0.02035818f, 0.03363325f, 0.02087451f, -0.04745055f, 0.01118039f, 
    0.00912858f, 0.04481995f, 0.04030263f, -0.04648366f, -0.00572161f, -0.04550362f, 0.03597992f, 0.02847918f, 
    0.00729754f, -0.00726351f, -0.02378819f, -0.04841050f, 0.01661992f, 0.01406626f, -0.02661179f, -0.00553782f, 
    -0.05120977f, -0.04158805f, 0.02173748f, -0.04727850f, -0.00122431f, 0.02305448f, 0.02030737f, 0.03509885f, 
    -0.05683421f, 0.02040114f, -0.03383717f, 0.02302685f, -0.01516418f, -0.01280600f, -0.00340397f, 0.01522420f, 
    -0.02056584f, 0.02815930f, -0.03443166f, -0.04887771f, -0.00384247f, -0.00359098f, -0.01671607f, 0.01865740f, 
    -0.01852514f, 0.00245507f, -0.05361552f, -0.02625430f, -0.01365029f, -0.03753617f, 0.01703792f, 0.02980834f, 
    -0.01706243f, -0.00446723f, -0.00952449f, -0.01342460f, 0.00067809f, 0.00025045f, -0.03932895f, -0.03115699f, 
    -0.01075954f, 0.02669491f, -0.02691402f, -0.05635986f, 0.01869805f, -0.03849928f, 0.01512478f, -0.01467357f, 
    0.02901050f, 0.02813966f, 0.02281245f, -0.02379883f, -0.05577174f, 0.03729225f, 0.03848873f, -0.04612385f, 
    0.03517105f, 0.04276957f, 0.02025961f, 0.01050327f, 0.03327771f, -0.02805913f, -0.03866561f, 0.03986214f, 
    -0.01026516f, 0.03085635f, -0.00467392f, 0.00951598f, -0.00979316f, -0.05962348f, 0.03139366f, -0.05306499f, 
    -0.02051925f, -0.04731129f, -0.04765412f, -0.04070219f, -0.00771357f, 0.01619257f, 0.01436510f, -0.03100677f, 
    0.01217551f, -0.04218088f, 0.02517450f, -0.00486861f, -0.01736053f, 0.00455432f, -0.04755503f, -0.02688049f, 
    -0.01449405f, 0.03218683f, -0.02105007f, 0.02733803f, 0.00771261f, -0.01474580f, 0.01306714f, -0.04180187f, 
    0.02058883f, 0.11150591f, -0.12284490f, 0.05615586f, 0.05504119f, -0.00340401f, 0.08986323f, 0.04970160f, 
    0.03073505f, 0.02115055f, 0.03429807f, 0.03714179f, 0.22720915f, 0.03716863f, 0.23040247f, -0.13598132f, 
    -0.03592694f, -0.05891544f, 0.03305391f, 0.05267026f, 0.05448215f, 0.04974228f, 0.06765202f, 0.01087787f, 
    -0.30660599f, 0.09879648f, -0.06439758f, 0.06591164f, -0.01838337f, 0.08819153f, -0.05677482f, 0.01935273f, 
    0.08628012f, 0.13775949f, 0.01367465f, -0.14467438f, 0.23150039f, -0.13960300f, -0.07242211f, 0.14757159f, 
    0.16792779f, 0.00828548f, 0.03846947f, 0.06925515f, 0.00148499f, -0.05392819f, -0.03561044f, 0.13910222f, 
    -0.34852961f, 0.12064370f, -0.05425720f, -0.16220093f, 0.14609757f, 0.08835272f, -0.04186017f, -0.03276702f, 
    0.07561101f, -0.03210021f, 0.02575500f, -0.06369046f, 0.09390040f, 0.41800594f, 0.29614684f, 0.11161711f, 
    0.08671513f, -0.04344788f, 0.11354778f, -0.08145069f, -0.08114005f, 0.09109300f, 0.06945902f, -0.07338314f, 
    -0.49384314f, 0.01932375f, 0.10532755f, -0.06211080f, -0.07356194f, 0.09988821f, -0.01091714f, -0.02724625f, 
    -0.06014758f, -0.16152142f, 0.03399806f, 0.05238898f, -0.29534322f, -0.19300425f, 0.08390059f, 0.16234256f, 
    0.17672904f, 0.05258608f, 0.03928594f, 0.00672597f, 0.03114820f, -0.05295504f, -0.07434313f, -0.03351265f, 
    -0.28239915f, -0.06578299f, 0.03707027f, 0.21288733f, 0.06269345f, 0.10418068f, 0.01172781f, -0.01739620f, 
    0.02933152f, -0.01979894f, 0.04272714f, 0.08110976f, 0.24367598f, 0.38735786f, -0.06411518f, -0.05173782f, 
    0.12874542f, 0.12709939f, 0.01890794f, 0.04266659f, -0.14450543f, -0.06086046f, -0.00557053f, 0.04526064f, 
    0.06144695f, -0.21320905f, -0.00395242f, -0.09880258f, -0.21383362f, -0.03966172f, -0.05450361f, -0.12172571f, 
    0.14297070f, 0.03129226f, 0.04153264f, -0.00095921f, 0.09682624f, -0.30963901f, 0.09749411f, 0.05328621f, 
    -0.04704165f, -0.02708850f, 0.08358220f, 0.07794753f, 0.03744341f, -0.06238329f, -0.03543035f, 0.01282226f, 
    0.47611785f, -0.30795148f, 0.16653489f, -0.01197635f, 0.02699454f, -0.01435650f, 0.14716490f, -0.19506669f, 
    0.02740696f, -0.08269048f, 0.09904360f, 0.04078016f, 0.30785015f, 0.12320406f, -0.23942752f, 0.06834360f, 
    -0.03489983f, 0.14770447f, 0.06473691f, 0.11216065f, -0.10183817f, -0.00695337f, 0.02264995f, -0.00156635f, 
    0.22378002f, 0.01669296f, 0.13296330f, -0.04079469f, 0.07587989f, 0.17141882f, 0.02055508f, 0.09983337f, 
    -0.01086482f, -0.05519722f, 0.13521096f, 0.11168621f, -0.07026232f, -0.00632279f, 0.07574824f, 0.06054888f, 
    0.20658989f, -0.04300011f, 0.01355465f, 0.08484996f, 0.00698898f, 0.04846393f, -0.01744019f, 0.05477845f, 
    -0.13736877f, 0.10934564f, 0.16916609f, -0.23869301f, -0.08736874f, 0.04414113f, 0.12750264f, 0.02366761f, 
    -0.14994262f, 0.08799287f, -0.00491209f, 0.12127519f, -0.27274567f, 0.52192056f, 0.04125550f, 0.05697256f, 
    0.13984863f, 0.01718271f, 0.08702402f, 0.10176551f, 0.10261032f, 0.05794275f, -0.05125611f, 0.00085861f, 
    0.16809666f, 0.16927645f, 0.06092769f, -0.03695261f, -0.01855872f, -0.05003726f, -0.05142175f, -0.05244602f, 
    0.01180076f, 0.02488799f, -0.01943051f, 0.00312204f, 0.34416157f, 0.17795858f, -0.14882021f, -0.03618608f, 
    -0.05564526f, -0.02335934f, 0.03761392f, 0.06580472f, -0.14784604f, -0.08079192f, -0.11998094f, -0.02309411f, 
    -0.15650071f, 0.29373738f, 0.22098386f, -0.01468292f, -0.11168692f, -0.03950798f, -0.01419820f, -0.05255715f, 
    -0.00016136f, -0.08114216f, -0.02255347f, -0.01261487f, 0.19631869f, -0.17185107f, -0.09036613f, 0.22228812f, 
    0.03169585f, 0.31572688f, -0.08484787f, 0.12256595f, 0.02530277f, -0.04840905f, 0.04988185f, -0.03309141f, 
    0.24535204f, -0.25213787f, 0.19486257f, -0.26083893f, -0.22983451f, -0.03539525f, -0.01958254f, 0.01741664f, 
    -0.20200780f, -0.03449503f, 0.14479931f, -0.03347832f, 0.09072541f, -0.10900301f, -0.04845016f, -0.05936705f, 
    0.11388686f, 0.14869057f, 0.00482250f, 0.11187555f, 0.09462958f, 0.07433458f, -0.10050880f, 0.02928051f, 
    -0.26771700f, 0.15799510f, 0.16946128f, -0.08684687f, -0.08533941f, -0.03283718f, 0.04814691f, -0.17092142f, 
    -0.23929113f, -0.04611230f, 0.01214682f, -0.09970081f, -0.12064842f, -0.04685377f, 0.04074898f, 0.01713050f, 
    0.13547996f, 0.17530391f, -0.11916732f, 0.09462629f, -0.09760577f, 0.19002505f, -0.00457193f, 0.03172236f, 
    -0.06106423f, -0.04724156f, 0.27832311f, -0.09751973f, -0.11225219f, -0.05195861f, 0.13043642f, 0.06295481f, 
    -0.14771307f, 0.07397555f, 0.03065123f, -0.13320178f, -0.07126386f, -0.16122243f, -0.08896161f, -0.15533409f, 
    0.03279556f, 0.00601899f, -0.13424519f, 0.04483775f, 0.00935226f, 0.00538888f, 0.06307439f, -0.03323930f, 
    -0.07323737f, 0.15618664f, 0.03312827f, 0.12424402f, -0.02640233f, -0.02634213f, -0.05900912f, -0.06829398f, 
    -0.11298155f, -0.00220846f, 0.03625094f, 0.07838574f, 0.02385433f, 0.14858885f, -0.04128237f, -0.11234012f, 
    -0.03346050f, 0.22462882f, -0.05792721f, -0.10404059f, 0.08155569f, 0.03830241f, 0.06227844f, -0.04227018f, 
    0.08702075f, 0.02396979f, 0.14172244f, -0.00791312f, -0.12342767f, 0.06373311f, -0.06995392f, -0.09544430f, 
    -0.05071902f, -0.14446968f, 0.08687302f, -0.00450057f, 0.04025679f, 0.13760984f, -0.05049814f, 0.27113697f, 
    -0.06887253f, -0.04344226f, -0.09139590f, -0.10244918f, 0.07173681f, -0.03167501f, 0.08445286f, -0.12335347f, 
    0.11947186f, 0.26133150f, -0.22689348f, -0.18779624f, -0.17017715f, 0.00337034f, -0.02800207f, -0.08803403f, 
    -0.16010703f, -0.14964475f, -0.00825025f, 0.05714607f, 0.16059136f, 0.01458137f, 0.06307830f, 0.18213999f, 
    0.20934862f, -0.09142229f, 0.04712815f, 0.03585931f, 0.09113149f, 0.05163135f, 0.19580846f, -0.09171055f, 
    -0.03185166f, -0.08219044f, -0.03785884f, 0.08034460f, -0.02959174f, 0.04411436f, 0.04968187f, -0.14625035f, 
    -0.16342251f, -0.07947288f, -0.07306243f, 0.10353562f, 0.20407186f, -0.21675503f, -0.03533920f, 0.21146579f, 
    0.06734558f, -0.00038544f, 0.05964375f, -0.16056845f, -0.10386355f, -0.05527767f, -0.21712038f, -0.06635046f, 
    0.06284318f, -0.27758962f, -0.11401750f, -0.03412162f, 0.10948080f, -0.08312940f, -0.07472796f, 0.02738244f, 
    -0.02786523f, 0.07728583f, 0.01558022f, -0.04278186f, -0.10528181f, 0.32310563f, 0.07076093f, 0.16369972f, 
    -0.08157996f, -0.04400975f, -0.01908970f, 0.04474032f, 0.01120545f, 0.09156951f, 0.00410098f, 0.10288426f, 
    -0.37029606f, -0.04356110f, -0.40800664f, -0.04666060f, -0.04680304f, 0.02060447f, -0.11907671f, -0.06796312f, 
    -0.17234673f, -0.01165651f, 0.09251057f, 0.09804217f, 0.10218403f, 0.17285170f, 0.04886425f, 0.20216337f, 
    0.15436281f, 0.11476185f, 0.07481009f, 0.07625712f, -0.01579707f, 0.16368820f, -0.07438760f, -0.05049574f, 
    -0.11801957f, 0.07954587f, 0.00796547f, 0.01837226f, -0.02367693f, 0.11210176f, 0.05638931f, -0.01302622f, 
    0.02244316f, -0.08799668f, -0.15918121f, 0.04584941f, 0.41980696f, 0.08761899f, -0.02718829f, -0.38189799f, 
    0.03273988f, 0.07715123f, 0.03638493f, 0.04032089f, 0.08662039f, 0.08121823f, 0.09651143f, -0.05308007f, 
    -0.18096054f, -0.10906415f, -0.04713456f, -0.08392695f, -0.02675476f, 0.01995416f, -0.01146503f, -0.01835441f, 
    -0.04660594f, 0.12676069f, -0.01057088f, 0.02702967f, -0.04086921f, -0.23308423f, -0.20692755f, -0.00271760f, 
    -0.17342371f, 0.10741413f, -0.00471316f, -0.04860607f, -0.06444100f, -0.06165348f, 0.07533582f, -0.11494536f, 
    -0.29294032f, -0.33737439f, 0.01905082f, 0.08357084f, 0.15837713f, 0.04145296f, 0.06569434f, 0.10730949f, 
    -0.13900205f, 0.01992759f, 0.20234329f, 0.08797788f, 0.06088731f, -0.00999539f, 0.01541986f, 0.04511654f, 
    -0.12725689f, -0.04963618f, 0.08481015f, -0.00640474f, -0.10832345f, 0.02690496f, -0.07456483f, -0.02343379f, 
    -0.03330440f, -0.16983967f, 0.07658248f, 0.03278741f, 0.08031619f, 0.00512009f, -0.03721152f, 0.10839462f, 
    0.06919685f, 0.03339441f, 0.17905338f, 0.02531485f, -0.34071466f, -0.05576360f, -0.02536352f, 0.23868078f, 
    0.05128757f, 0.07795724f, -0.01463418f, -0.18574893f, 0.06286335f, 0.07783350f, 0.05354801f, 0.17400186f, 
    0.06642091f, 0.33077252f, 0.27204841f, -0.19347730f, -0.06743344f, 0.00701411f, 0.02229388f, 0.04248919f, 
    -0.10972215f, -0.07099166f, 0.12594515f, 0.08241415f, 0.03670797f, 0.18570319f, 0.00061150f, -0.07787854f, 
    0.12312028f, 0.10152419f, -0.00598668f, 0.01875434f, -0.06584593f, -0.06347747f, -0.16179594f, -0.22790951f, 
    -0.18699123f, -0.10705770f, 0.18216747f, 0.00995264f, -0.00058962f, 0.02113024f, -0.23796992f, 0.00260534f, 
    0.20030375f, 0.01269849f, -0.06750656f, 0.00269731f, 0.21834585f, 0.08513603f, -0.05081258f, 0.17678121f, 
    -0.06163928f, -0.04839717f, 0.02772976f, -0.06890427f, 0.03005821f, 0.02356506f, -0.15816982f, -0.01031566f, 
    -0.05041943f, 0.08075502f, 0.04324390f, 0.14844166f, -0.10812009f, 0.08044097f, 0.08895756f, -0.03699771f, 
    0.01107909f, -0.02271891f, -0.09498577f, -0.00774016f, 0.18306820f, -0.04193133f, 0.16281508f, -0.03221371f, 
    -0.00100274f, 0.00498008f, 0.03337542f, 0.09491845f, -0.07245664f, -0.02951263f, -0.05160559f, 0.08648754f, 
    0.15131186f, 0.17049129f, 0.22090152f, -0.01909908f, 0.00739388f, -0.02150516f, 0.03197938f, -0.06350973f, 
    0.00464254f, -0.04864106f, 0.03762169f, -0.03937251f, 0.02753483f, 0.16696206f, -0.04289773f, 0.02864268f, 
    0.18567599f, -0.04132463f, -0.04278915f, 0.06454580f, 0.04479524f, 0.07976848f, -0.02161230f, -0.15589873f, 
    0.34208739f, -0.15979551f, 0.10152868f, 0.19785455f, -0.11208040f, -0.06105821f, 0.00225226f, 0.01901988f, 
    0.04729038f, 0.06507908f, 0.01888535f, -0.01451029f, 0.13219047f, -0.22859325f, 0.13921896f, -0.16404502f, 
    0.12783414f, 0.07024372f, -0.12623905f, 0.00176318f, 0.04085947f, -0.05349906f, 0.17963265f, 0.10090995f, 
    0.26224080f, 0.09239940f, 0.02522376f, 0.03477101f, -0.05239987f, -0.05021803f, -0.02485868f, 0.02833719f, 
    0.05388966f, 0.07424930f, 0.02121585f, 0.01481548f, 0.31884217f, -0.24573912f, 0.03030957f, -0.05630872f, 
    -0.12002597f, 0.02193331f, 0.13092610f, -0.00038547f, 0.02640471f, -0.05372348f, 0.15423769f, -0.01986018f, 
    0.05308117f, 0.21172579f, -0.09792817f, -0.02423667f, -0.09039868f, 0.03790636f, -0.05410456f, -0.05021358f, 
    -0.01131062f, -0.01832362f, 0.05089623f, 0.06839257f, 0.12997124f, 0.27399501f, 0.16457857f, -0.23994300f, 
    -0.06535794f, -0.15050656f, -0.07151327f, 0.03770157f, 0.12937817f, -0.15490651f, -0.11495252f, -0.16781034f, 
    0.07178610f, 0.28050184f, 0.16065656f, -0.13518085f, -0.18426453f, 0.22284794f, 0.08147252f, 0.04804728f, 
    0.03320817f, 0.00364814f, 0.08164525f, -0.16873407f, 0.16549711f, 0.20581661f, 0.16004589f, -0.09728847f, 
    0.06202266f, -0.09587650f, 0.04986767f, -0.05777923f, 0.01386184f, -0.06564990f, 0.11783078f, 0.07208928f, 
    0.04182045f, -0.28841493f, 0.07431294f, -0.01472848f, 0.00746158f, -0.00439470f, 0.08414643f, 0.06283049f, 
    -0.02668047f, 0.05834315f, 0.01677769f, -0.10466145f, -0.09309348f, -0.11740742f, -0.27694088f, -0.01793262f, 
    -0.02225257f, -0.04559524f, 0.04253990f, -0.16850373f, 0.04109112f, -0.09641792f, 0.02938208f, -0.01215509f, 
    -0.13065828f, -0.16483788f, 0.02580599f, -0.11420796f, -0.05365842f, 0.15992022f, 0.15072772f, 0.00165227f, 
    0.07273383f, -0.04215748f, -0.02884440f, 0.08290535f, -0.27406767f, -0.18298553f, -0.07174456f, 0.15234683f, 
    -0.06163800f, 0.02183968f, 0.01868698f, 0.12658525f, 0.17452021f, -0.03737153f, 0.14175853f, 0.03032069f, 
    -0.08849657f, -0.07253419f, -0.04746362f, -0.12131573f, 0.02979575f, 0.08069406f, -0.02192507f, 0.17658342f, 
    0.06065731f, 0.13172407f, -0.01891209f, 0.12785578f, 0.14347105f, -0.15998872f, 0.31673405f, 0.04971292f, 
    -0.13006854f, -0.08927106f, 0.04949816f, 0.16368639f, 0.08103403f, -0.02371944f, 0.15239954f, 0.15250973f, 
    0.05885196f, -0.23558064f, 0.30772296f, -0.13244109f, 0.02142489f, -0.05243896f, 0.19269712f, 0.06137894f, 
    0.14322078f, 0.09221205f, -0.07274595f, 0.02157144f, -0.14218721f, -0.11912873f, -0.09644029f, -0.16546771f, 
    0.04414041f, 0.02325189f, 0.04853748f, 0.09349223f, 0.13196990f, 0.10291868f, 0.16358519f, 0.04590623f, 
    0.03169076f, -0.00105179f, 0.09503656f, -0.27773076f, -0.00598062f, -0.01777207f, 0.06222305f, 0.04422836f, 
    -0.10285176f, -0.04366368f, 0.21559107f, 0.06003343f, -0.02132660f, 0.13985394f, 0.17414770f, 0.17528403f, 
    -0.14933217f, 0.05668499f, 0.09151546f, 0.06596101f, 0.15402636f, 0.03931407f, 0.06183180f, -0.11208788f, 
    0.14520141f, 0.10979943f, -0.05873053f, 0.06803352f, -0.05681383f, 0.02711423f, 0.15878205f, 0.04320428f, 
    0.00201788f, 0.09832215f, -0.10396188f, 0.24488741f, -0.36207578f, 0.15838376f, -0.01381878f, -0.06841113f, 
    0.15982828f, -0.03192415f, 0.07616130f, 0.01613775f, 0.13473330f, 0.03822432f, -0.08295275f, 0.03702142f, 
    0.18365034f, 0.04830502f, 0.08124394f, 0.11018413f, 0.01591441f, 0.02077504f, 0.03354611f, -0.26955271f, 
    0.07327423f, 0.08128669f, 0.01979132f, -0.06850152f, -0.44279391f, -0.14122429f, -0.05614538f, 0.11103383f, 
    0.19349295f, 0.12192402f, 0.11250011f, 0.01583834f, 0.12331321f, -0.00360890f, -0.10983416f, -0.01879339f, 
    0.16377878f, -0.16049953f, -0.11311574f, -0.26793420f, 0.07745213f, 0.07297765f, -0.05899022f, 0.01610360f, 
    0.08849230f, -0.03711632f, 0.04166625f, 0.02991064f, 0.00728166f, -0.10212249f, -0.11377013f, -0.15366843f, 
    -0.03472254f, 0.08425716f, -0.04635601f, 0.03720298f, 0.01380478f, 0.01798688f, 0.10569047f, 0.00284298f, 
    0.06403401f, 0.15788274f, 0.23040794f, 0.14645679f, -0.16495788f, -0.06936362f, -0.03118021f, 0.02792051f, 
    0.09878606f, 0.11528318f, 0.05204086f, 0.07689320f, 0.25644448f, -0.06933288f, 0.03462423f, 0.03891026f, 
    -0.00222554f, 0.04924587f, -0.06157836f, 0.13914117f, 0.13354352f, -0.07247834f, 0.16744021f, -0.05458521f, 
    0.31387368f, -0.12618135f, 0.02884857f, 0.02780382f, -0.08921866f, -0.03204637f, -0.04133169f, -0.00144227f, 
    -0.01388322f, -0.01544972f, 0.01126205f, 0.22216921f, 0.30643368f, 0.13023375f, 0.31668222f, -0.12520802f, 
    -0.01272452f, -0.00945210f, -0.09135570f, 0.11762571f, 0.20373990f, 0.05769456f, 0.19397682f, 0.07696170f, 
    0.25379035f, 0.00082753f, 0.20451084f, 0.13907513f, -0.03174366f, 0.08134062f, 0.00219570f, 0.12207478f, 
    0.02233663f, -0.02688163f, 0.05762721f, 0.05638271f, -0.09848598f, -0.06689948f, -0.01065947f, -0.23234816f, 
    0.03413151f, 0.10776911f, 0.07561211f, -0.17877473f, 0.02601047f, -0.03281639f, 0.02072187f, 0.05827235f, 
    -0.04607416f, 0.40361461f, 0.19207051f, 0.04358880f, -0.07917717f, -0.02803800f, 0.01705927f, 0.04926468f, 
    0.01831814f, 0.04133461f, 0.03325818f, 0.14214961f, -0.08496033f, -0.05232953f, -0.16894235f, 0.02238862f, 
    -0.03493481f, -0.00124676f, 0.07804298f, -0.01267415f, 0.10084600f, 0.06968909f, 0.09467642f, 0.10237473f, 
    -0.28149888f, 0.25748828f, 0.12772793f, 0.10364491f, 0.05077125f, 0.01043767f, 0.17106344f, 0.06616387f, 
    -0.05040257f, -0.00364993f, 0.09578660f, -0.05825227f, -0.10478508f, -0.01442829f, -0.17592590f, -0.16083410f, 
    0.05863007f, 0.08659571f, 0.08433598f, -0.06165393f, 0.12480756f, -0.11112055f, 0.01633605f, 0.00101841f, 
    -0.37135902f, 0.34911129f, 0.05206959f, 0.15212195f, 0.03175439f, 0.09067065f, -0.00253886f, -0.01401891f, 
    0.04568113f, -0.04932515f, -0.04067536f, -0.02605836f, -0.18558089f, 0.24082354f, -0.09345124f, -0.18410015f, 
    0.00981077f, 0.06467837f, -0.04560023f, 0.10725119f, 0.04405452f, -0.02907847f, 0.04746421f, 0.16835988f, 
    -0.01999714f, -0.15867618f, -0.06443479f, -0.16159829f, -0.08587671f, -0.03997616f, 0.15512216f, -0.12672244f, 
    -0.04637980f, -0.12499379f, 0.06004218f, 0.07735574f, 0.09225069f, -0.04643420f, 0.12783673f, -0.00655585f, 
    0.02900639f, -0.00858805f, -0.04407402f, 0.02219227f, 0.16176711f, 0.07142583f, -0.09017808f, 0.11718399f, 
    0.06113339f, 0.18724680f, 0.08510768f, 0.22986810f, -0.01867998f, -0.05126451f, 0.01946439f, 0.09850577f, 
    -0.02948179f, 0.08050726f, -0.03985690f, -0.00488877f, -0.13397245f, -0.29550979f, 0.09879757f, -0.10433824f, 
    -0.09337036f, 0.04092091f, 0.14335568f, -0.04479969f, 0.03448806f, 0.05756581f, -0.14685060f, 0.10195682f, 
    -0.02239480f, 0.02316768f, 0.02946323f, 0.00425392f, 0.02198227f, -0.03728070f, -0.04348734f, 0.04016455f, 
    0.00897975f, 0.00010032f, -0.02243079f, 0.01668836f, -0.05175159f, -0.03827071f, 0.00874873f, -0.04652660f, 
    -0.02408640f, 0.00219524f, -0.04465323f, -0.05604859f, 0.01522051f, -0.01964154f, 0.01735862f, 0.00450580f, 
    0.02578005f, -0.01509243f, 0.00880558f, -0.04756080f, 0.02082917f, -0.03398096f, 0.04078148f, -0.02829927f, 
    -0.01291186f, -0.01852813f, -0.03363372f, -0.00533204f, 0.03402970f, 0.03602773f, -0.00441725f, -0.05306191f, 
    0.02754345f, 0.03078313f, -0.02520514f, 0.00287861f, -0.02899786f, 0.02651529f, -0.04434222f, 0.00083923f, 
    0.03082064f, 0.04155589f, 0.03675246f, -0.04107812f, 0.00314757f, -0.03302728f, -0.00996090f, -0.01820006f, 
    -0.03855766f, -0.03100122f, 0.00661601f, -0.04195717f, -0.04306047f, 0.03290485f, -0.03365786f, -0.05039478f, 
    -0.04419801f, -0.02367455f, 0.02889315f, -0.03083463f, -0.03085635f, -0.00581158f, -0.04948882f, -0.05376209f, 
    -0.01417479f, 0.03030115f, 0.00895159f, 0.00402940f, 0.03432775f, 0.01268433f, -0.01395832f, -0.03948302f, 
    -0.03507473f, 0.01931147f, -0.01284952f, 0.02805040f, 0.01178230f, 0.02025477f, 0.01547661f, -0.01149455f, 
    0.00324144f, -0.04038269f, 0.02525555f, -0.05384580f, -0.05475396f, -0.03002707f, -0.04349211f, 0.03449767f, 
    -0.00548006f, 0.03015134f, -0.00860315f, 0.02180665f, -0.03465509f, 0.02841541f, 0.04426356f, -0.01134319f, 
    -0.02709550f, -0.05443280f, 0.04206021f, -0.00284627f, 0.01123702f, -0.04797725f, 0.00267390f, -0.02478545f, 
    -0.03988923f, 0.03494688f, 0.02644789f, -0.02018401f, -0.02775768f, -0.00965224f, 0.00028249f, 0.01069400f, 
    0.01952826f, -0.03736943f, -0.01840053f, -0.05377286f, 0.01855131f, 0.02554461f, 0.03927322f, -0.04367449f, 
    -0.04604520f, 0.02951645f, -0.00398349f, -0.04667940f, -0.02800930f, -0.00311513f, -0.02765272f, 0.03784227f, 
    -0.04091112f, 0.03678213f, -0.04065029f, -0.01473096f, 0.02058944f, -0.01711332f, 0.00210948f, -0.00715952f, 
    -0.01830464f, 0.04273218f, -0.02217169f, 0.02950007f, -0.05576923f, -0.02121237f, 0.01398857f, 0.03825176f, 
    -0.01652685f, 0.02770737f, 0.04099145f, -0.04028829f, 0.04623298f, 0.00393728f, -0.00084744f, 0.02662319f, 
    -0.00590117f, 0.00827406f, -0.01055217f, -0.02090346f, -0.03534998f, -0.01628360f, -0.05018039f, 0.02945339f, 
    -0.04835043f, -0.00718528f, 0.04077146f, -0.03756328f, 0.04530175f, 0.02345061f, 0.02873154f, 0.03697133f, 
    0.02224962f, 0.01871038f, -0.03788604f, -0.03995658f, -0.01095213f, 0.02792408f, -0.02151595f, -0.05431286f, 
    0.04413749f, -0.02549269f, 0.02977938f, 0.03772437f, 0.03628196f, -0.00363265f, -0.00025081f, -0.04026538f, 
    -0.05050405f, 0.00674208f, -0.00304667f, -0.03986017f, -0.05309442f, -0.00236196f, 0.04567348f, 0.01714142f, 
    0.04314490f, -0.04978331f, 0.00887456f, 0.00210564f, -0.05358960f, -0.01282356f, -0.01015291f, -0.00448802f, 
    -0.04626666f, 0.02444917f, -0.01401968f, 0.03661624f, -0.03184382f, -0.04465526f, -0.05444717f, 0.00511098f, 
    0.02526479f, -0.01734436f, -0.03737114f, 0.01061435f, -0.03723159f, 0.03597875f, -0.03246938f, 0.01963680f, 
    -0.01145496f, 0.01480256f, -0.02686936f, 0.02405997f, -0.01396897f, -0.02111935f, -0.04520194f, 0.03105850f, 
    -0.05192696f, -0.00399421f, -0.02043157f, 0.03561381f, 0.02066076f, 0.00461673f, -0.03029119f, 0.04453747f, 
    0.03800183f, 0.02790282f, -0.02734855f, -0.01640289f, 0.01142925f, 0.00289841f, 0.00135650f, -0.01541887f, 
    0.01098684f, 0.03513571f, 0.04015771f, -0.02681067f, 0.02142269f, -0.03455159f, -0.01839527f, 0.03762442f, 
    -0.01086713f, -0.04281055f, -0.01004058f, -0.04696798f, -0.01321783f, -0.05602527f, -0.05523658f, -0.00014574f, 
    0.01700724f, -0.03138279f, -0.00635981f, 0.04158194f, -0.00002888f, 0.01843033f, -0.03344003f, -0.01969865f, 
    -0.02328737f, -0.04274108f, -0.05350970f, 0.02650109f, -0.00503077f, -0.01581731f, -0.03334366f, -0.01817839f, 
    0.00652170f, 0.01597553f, -0.04124059f, 0.03297228f, 0.01606406f, 0.01391955f, -0.03776912f, 0.00111436f, 
    0.03015654f, 0.03382286f, 0.00480249f, 0.02643338f, -0.03060262f, -0.01855934f, -0.02742090f, -0.01151896f, 
    0.01341795f, 0.00260515f, -0.01199961f, 0.02305288f, -0.02744379f, 0.01187207f, 0.04552026f, -0.02856470f, 
    -0.00016781f, 0.03150377f, 0.02475345f, 0.00748634f, -0.04315621f, -0.03415081f, -0.02921055f, -0.00625583f, 
    -0.02884857f, -0.03234867f, 0.03631632f, -0.00087907f, -0.01558895f, -0.04603286f, -0.01427760f, -0.02154039f, 
    -0.05270860f, -0.02764682f, 0.03852366f, 0.01328019f, 0.03457333f, 0.01449148f, -0.00830265f, -0.03643043f, 
    0.03012305f, 0.00640822f, -0.04002100f, -0.01958038f, 0.01019953f, 0.00041655f, 0.01177861f, -0.02876101f, 
    -0.02581668f, 0.00472667f, -0.04661405f, -0.01434819f, -0.04098972f, 0.02198205f, -0.00488628f, 0.02251128f, 
    -0.01018502f, -0.01390955f, -0.05404609f, -0.05295831f, -0.01528413f, -0.05435709f, 0.00885198f, -0.01739558f, 
    0.01131748f, -0.00038531f, -0.00353564f, 0.03817090f, -0.01079109f, 0.03172046f, -0.01913925f, -0.04466682f, 
    0.01202819f, 0.04322280f, 0.01095182f, 0.00833825f, -0.02805996f, -0.03408489f, -0.05170130f, 0.00372715f, 
    -0.04217419f, -0.00422173f, -0.02958015f, 0.00116248f, 0.02051670f, -0.00812429f, 0.01392756f, -0.04228062f, 
    -0.01332647f, 0.04026617f, -0.01490005f, 0.00157001f, -0.02079872f, -0.00604532f, 0.00831597f, -0.01672098f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02998385f, 0.00157635f, -0.03545144f, 0.03977695f, -0.05987272f, -0.01097227f, -0.00573282f, -0.03002542f, 
    0.04185927f, -0.01983183f, 0.00331679f, 0.07847878f, 0.14825210f, -0.05296461f, 0.06141924f, 0.06430160f, 
    -0.02784570f, 0.00032853f, -0.02156312f, -0.00361045f, -0.09601702f, 0.08918328f, 0.08036137f, 0.10462865f, 
    0.04591929f, 0.00871406f, 0.01498277f, 0.02533071f, -0.10648473f, 0.02573202f, 0.05502071f, -0.01413576f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14159995f, 0.16291060f, -0.04424237f, 0.02228280f, 0.04773305f, -0.12661283f, 0.30395159f, 0.20513794f, 
    0.16679928f, -0.08166467f, -0.02918506f, -0.20817366f, -0.39272922f, 0.04821664f, 0.21597524f, 0.11741749f, 
    0.14214599f, -0.31180394f, 0.13691042f, 0.35858053f, 0.38280368f, 0.28586015f, -0.27724680f, -0.29002312f, 
    -0.34485373f, -0.10455511f, -0.06307691f, -0.12010993f, 0.19172864f, -0.44356370f, 0.21501644f, -0.13871659f, 
    0.05360797f, -0.15620191f, 0.05578272f, -0.07546328f, -0.15073118f, 0.00864634f, 0.27635929f, -0.15192774f, 
    -0.03150708f, -0.17193745f, -0.19016574f, -0.19683112f, -0.01323995f, 0.00217851f, -0.19656119f, -0.60156053f, 
    0.10372349f, 0.04802499f, -0.21629062f, 0.28462151f, -0.07457273f, 0.38236168f, -0.19302109f, 0.25963387f, 
    0.17379284f, -0.48095042f, 0.34370947f, -0.07364865f, -0.03878298f, 0.29492158f, 0.07341263f, -0.13275303f, 
    -0.08726189f, -0.18105987f, 0.11291051f, 0.10547114f, 0.11396262f, -0.15095775f, 0.11170139f, 0.07420886f, 
    -0.10814659f, -0.06983701f, 0.18609175f, -0.10544199f, 0.01278098f, -0.15894596f, -0.52229631f, -0.53947699f, 
    0.04350758f, -0.03841697f, 0.09760807f, -0.27526867f, 0.55466902f, -0.56702530f, -0.10748895f, 0.42150125f, 
    -0.02441424f, 0.01888060f, 0.25914100f, -0.11273438f, -0.03097325f, -0.28692302f, -0.01408389f, -0.08333582f, 
    0.12598099f, -0.01419565f, -0.13321869f, -0.08268207f, 0.02327783f, -0.08135316f, -0.67040133f, 0.35494694f, 
    -0.11292627f, 0.00915195f, -0.12315184f, -0.30108467f, -0.11514635f, -0.05873977f, 0.00414128f, -0.24137679f, 
    -0.09092606f, 0.00517602f, 0.49751991f, 0.33069286f, -0.42457059f, 0.28251946f, 0.13728933f, -0.09949309f, 
    0.41124940f, 0.31707072f, 0.07499528f, -0.01978729f, -0.57202351f, -0.66023839f, -0.29014179f, -0.08891962f, 
    0.10463835f, 0.15331325f, 0.07753745f, 0.15817752f, -0.01546271f, 0.01594975f, -0.32866710f, 0.40540057f, 
    0.10660118f, -0.17269866f, -0.39218515f, 0.16431460f, 0.15424711f, 0.08619830f, -0.12382919f, 0.39283717f, 
    0.17784370f, -0.23870453f, 0.39314714f, -0.07422592f, 0.02784825f, -0.04189250f, 0.31468993f, -0.51252812f, 
    -0.18713145f, -0.15547740f, 0.09521598f, 0.01824195f, 0.03835941f, 0.07245500f, 0.05310303f, -0.01581515f, 
    0.06377333f, -0.10819420f, 0.01198033f, 0.05857429f, -0.07359626f, -0.05764361f, 0.27886841f, -0.18487173f, 
    0.02956411f, -0.01715344f, -0.38897023f, -0.16984949f, 0.15887538f, 0.04034983f, 0.21601373f, 0.37473795f, 
    -0.03356952f, 0.42221060f, -0.36392736f, -0.03854275f, -0.60390264f, -0.04452499f, -0.19642493f, -0.34510148f, 
    0.23424248f, -0.24591427f, 0.05165044f, 0.13066152f, 0.21146166f, -0.11618996f, 0.22051692f, 0.06767388f, 
    0.14853878f, -0.04711832f, -0.04268810f, -0.02692308f, 0.11154615f, 0.06456459f, -0.38588795f, -0.00450296f, 
    -0.14579706f, -0.08261816f, 0.05083397f, 0.35017413f, -0.24548790f, -0.13534886f, 0.20744030f, 0.02318727f, 
    -0.04284756f, 0.23411660f, 0.21284346f, -0.57945943f, 0.27094358f, 0.06193469f, -0.44344065f, 0.16431962f, 
    0.35055542f, -0.09232622f, -0.35564387f, -0.09969840f, -0.06705026f, 0.37444448f, 0.18706487f, 0.15864006f, 
    -0.11016413f, 0.07428916f, -0.12500891f, 0.16977288f, 0.03978567f, -0.17528903f, -0.04024910f, 0.14453070f, 
    -0.15771617f, -0.14041758f, 0.02509528f, -0.66130710f, 0.07326671f, 0.04863720f, 0.02335477f, -0.02021048f, 
    0.00398109f, 0.27658305f, -0.49009573f, 0.02509720f, 0.10946937f, -0.31724393f, 0.21903980f, -0.39439684f, 
    0.13043137f, 0.34685844f, -0.39548221f, -0.04846546f, 0.26893875f, 0.29620102f, -0.58310759f, 0.03493417f, 
    0.05174087f, 0.12239600f, -0.08948133f, -0.01505532f, 0.13400328f, 0.10854364f, 0.25856677f, -0.55539161f, 
    -0.09649184f, 0.06687808f, 0.23089172f, -0.50506639f, 0.28760323f, 0.07743173f, -0.43659151f, -0.34276706f, 
    -0.17843889f, 0.23506244f, 0.31677020f, -0.45933646f, 0.12768593f, 0.37358022f, -0.27482519f, -0.54318237f, 
    -0.22727221f, -0.12643349f, 0.18707523f, -0.01716208f, -0.20062257f, -0.23598537f, 0.09099703f, 0.07287614f, 
    0.08196651f, -0.12950528f, -0.15670642f, -0.12958305f, 0.10484133f, 0.12157809f, -0.41111648f, -0.22493199f, 
    0.06940503f, 0.01154280f, 0.35146865f, 0.31576499f, -0.06222133f, -0.16480929f, -0.29579636f, 0.18999518f, 
    -0.04357791f, 0.33218819f, 0.08387308f, 0.16167071f, -0.03985495f, -0.28256506f, 0.02239015f, 0.25351253f, 
    -0.64208132f, 0.02822207f, -0.25666359f, -0.06597772f, 0.45938414f, 0.19063149f, -0.33653867f, -0.08230651f, 
    0.08662397f, -0.11738901f, 0.14064850f, -0.10518037f, 0.08424542f, -0.14449802f, -0.42504680f, -0.43471733f, 
    0.11815070f, -0.00295133f, 0.21681730f, -0.07429603f, 0.33914831f, -0.10309232f, 0.46707249f, -0.41143581f, 
    0.09066772f, -0.48506650f, -0.60282177f, -0.14504698f, 0.14410397f, 0.00201100f, 0.34635895f, 0.20928963f, 
    0.23142444f, 0.01474908f, -0.18444820f, -0.07200822f, -0.44578880f, -0.37471023f, 0.04589240f, 0.12802462f, 
    -0.08287596f, 0.01623807f, -0.00393124f, -0.06368097f, -0.09226051f, -0.10996208f, 0.49262360f, 0.33694148f, 
    0.11704643f, -0.10264755f, -0.18774813f, 0.37075669f, 0.01775814f, -0.17041801f, 0.01279937f, -0.03570613f, 
    -0.07163882f, -0.31767642f, 0.07856084f, -0.52520496f, -0.68009877f, 0.16386463f, 0.05279391f, 0.37891591f, 
    0.06585652f, 0.22528686f, -0.18156737f, -0.05354122f, -0.49780798f, 0.08813448f, -0.19139493f, -0.04877970f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09280682f, 0.06639650f, -0.03051729f, -0.07120840f, 0.11772905f, -0.09323213f, -0.16680335f, -0.05392455f, 
    -0.02785454f, 0.09131048f, 0.21750018f, -0.20351118f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
