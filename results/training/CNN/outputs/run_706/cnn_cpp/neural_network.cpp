#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.35594821f, 0.36335453f, 0.72503394f, 0.24788828f, 1.02865815f, 0.76749212f, -0.63762194f, -1.27814960f, 
    0.03549991f, -0.67905205f, 0.01133616f, 0.64108962f, 0.41044921f, 0.40975288f, 0.04102623f, 0.06906699f, 
    0.11403340f, 0.25952628f, 0.11768785f, 0.03522052f, 0.39080703f, 0.38210684f, 0.20096281f, 0.28753030f, 
    0.22756760f, 0.67532027f, -1.14236081f, -0.52736050f, -1.05241060f, -0.35526928f, 0.75059432f, -0.80494720f, 
    0.62913293f, 0.64058751f, -0.02030334f, -0.04035597f, -0.18256871f, -0.24923056f, -0.02770768f, -0.45577624f, 
    0.06490146f, 0.12189984f, 0.09530126f, -0.11041245f, 0.27602631f, 0.13733952f, 0.07536768f, 0.12194684f, 
    0.31962770f, -0.12552245f, -1.11149526f, -1.08380508f, -0.62724769f, -0.46700379f, -0.29560792f, 0.27250224f, 
    0.97374970f, 0.20406826f, -0.14350656f, 0.72345632f, 0.35380045f, -0.23437050f, 0.05378348f, -0.60719430f, 
    0.07955796f, 0.15774031f, -0.12000125f, 0.14535664f, -0.29276547f, -0.20349476f, -0.02036449f, -0.14018352f, 
    0.24409276f, 0.12503679f, 0.17872752f, 0.31181166f, -0.02581308f, -0.44560894f, -0.71350950f, -0.73818886f, 
    0.38819852f, 0.95994931f, 0.51201242f, 0.63687068f, 0.29499838f, -0.41394722f, -0.53619272f, -0.70021230f, 
    -0.54085988f, -0.07400740f, -0.01868482f, -0.09238187f, -0.37838787f, 0.34073910f, -0.07343380f, -0.27997220f, 
    -0.16085787f, -0.34897825f, -0.51802939f, -0.04775924f, 0.65534210f, 0.42269662f, 0.81238520f, -0.55704981f, 
    -0.42358661f, 0.47690332f, 0.26787969f, 0.21301493f, -0.66497785f, 0.50231451f, 0.39950687f, 0.36871460f, 
    0.01856421f, 0.24602674f, 0.34729150f, 0.15292726f, -0.34311441f, -0.48709387f, 0.16625300f, 0.08068320f, 
    0.31766906f, 0.34467179f, 0.03764287f, 0.09146816f, 0.42106572f, -0.99024647f, 0.70958310f, 0.51277900f, 
    0.67339951f, 0.68777782f, 0.41474250f, 0.84449959f, -0.06989752f, 0.41343600f, -0.19247247f, -0.56274587f, 
    -0.32558373f, 0.24577343f, 0.09686585f, 0.05786139f, 0.08958679f, 0.07943584f, 0.45357341f, 0.10286133f, 
    -0.14894280f, -0.22213539f, 0.17517149f, -0.21588609f, 0.04223109f, 0.15866657f, -0.92454320f, -0.13895704f, 
    0.09935714f, -0.14975742f, 0.70331669f, 0.16017842f, 0.79885739f, 0.56636685f, 0.05562370f, 0.77548140f, 
    0.07115963f, -0.29826924f, 0.63010198f, 0.34458691f, 0.47293732f, 0.37782684f, -0.01943258f, -0.14437611f, 
    0.32272866f, 0.04625366f, 0.06670980f, 0.05755244f, -0.46132213f, 0.09049427f, -0.09973936f, -0.63852578f, 
    0.99530858f, -0.74527347f, 0.17485458f, 0.49581122f, 0.39281693f, -0.52213067f, -1.03790319f, -0.80134910f, 
    -0.59852666f, 0.10623606f, -0.19145246f, 0.21375909f, -0.12985036f, 0.00306905f, -0.02134341f, -0.32979488f, 
    -0.26913634f, -0.19791976f, 0.12577258f, -0.05738037f, -0.15559708f, -0.07440443f, 0.19581461f, 0.28200594f, 
    -0.99672371f, -0.28134364f, 0.42171055f, 0.27564758f, 0.49271879f, -0.34599596f, 0.98528415f, -0.21159284f, 
    -0.12613319f, -0.51069772f, 0.52482009f, -0.15265690f, 0.38386139f, -0.24196935f, -0.22551787f, 0.26143330f, 
    0.18544690f, -0.16870981f, 0.14374307f, 0.35116401f, -0.03141806f, 0.39854312f, -0.07257553f, -0.13377798f, 
    0.09485170f, -0.98868871f, -0.26130503f, 0.88226181f, 0.02966733f, -0.39551932f, 0.29719585f, 0.73359698f, 
    0.84139276f, -0.40932095f, 0.38345775f, -0.61277306f, 0.17507946f, 0.23808464f, 0.06612103f, -0.40492818f, 
    -0.12933484f, -0.10714836f, -0.32505268f, 0.06335468f, 0.18076102f, 0.23478369f, -0.00155226f, 0.18886630f, 
    0.38065585f, -0.39784250f, -0.32404566f, 0.03858741f, -0.46683913f, 0.29598755f, -0.52766633f, 1.24066269f, 
    1.02352381f, 0.23197700f, 0.96623456f, 0.32899818f, 0.18473835f, -0.52308512f, 0.08316269f, -0.42232847f, 
    -0.22968329f, 0.06405067f, -0.22656529f, 0.12252735f, -0.01836370f, -0.16256469f, 0.09363389f, -0.17805922f, 
    -0.10347147f, -0.22796226f, -0.09221736f, -0.54119402f, 0.76789629f, -0.46789932f, -1.02725303f, -0.88807541f, 
    0.99227315f, -0.25525782f, -0.03515178f, 0.39681563f, 0.41247982f, 0.56109744f, -0.14406209f, 0.13273485f, 
    0.13973694f, 0.15682313f, 0.14646563f, 0.14094202f, 0.21695614f, 0.05946842f, 0.37293312f, -0.34035867f, 
    -0.28205493f, -0.28207025f, -0.25332031f, -0.11802380f, 0.08437798f, -1.46119535f, 0.23743218f, 0.87291473f, 
    -0.34273523f, -0.82666868f, 0.96198672f, 0.08827387f, 0.11709567f, -0.05076844f, 0.15441273f, 0.18393458f, 
    0.18524736f, -0.09999152f, 0.10890218f, -0.67986608f, -0.35491049f, 0.08268965f, -0.24503204f, -0.46872318f, 
    -0.06502171f, 0.13971491f, 0.05122157f, 0.00555498f, 0.02678753f, -1.08334911f, 0.77824986f, 0.43404216f, 
    -0.86358356f, -1.06037009f, 0.54641467f, -0.34188202f, 0.09347019f, 0.63248831f, 0.13696936f, -0.01761806f, 
    0.45746717f, -0.29217198f, -0.15175697f, 0.26777399f, 0.26625568f, 0.32486260f, -0.44258904f, 0.14818548f, 
    0.39291278f, 0.31122160f, -0.04733986f, 0.31027037f, 0.35885888f, 0.22550388f, 0.97060412f, 0.50441062f, 
    0.05731546f, -0.16946377f, 1.20589054f, 0.70713180f, 0.10878474f, 0.62786674f, 0.53322452f, 0.55169100f, 
    -0.49134353f, 0.58747399f, 0.38541830f, 0.26598909f, 0.14477195f, -0.41348532f, -0.04190663f, 0.02902048f, 
    -0.03333594f, -0.16268291f, -0.01889786f, 0.11210545f, 0.03512554f, 0.06438052f, 0.17387713f, 0.79391885f, 
    1.07425010f, 0.99145448f, 0.48063678f, 0.18975015f, -0.17311224f, 0.09999208f, -0.37685803f, -0.11089985f, 
    -0.16515414f, 0.03847731f, 0.12906100f, 0.07621459f, 0.04462890f, 0.16159737f, 0.21739720f, -0.07333267f, 
    0.18680923f, -0.09652840f, -0.42331648f, 0.08272438f, -0.22776811f, -0.11319155f, 0.30145070f, -0.00690373f, 
    0.89409298f, 0.44240695f, 0.49589494f, 0.98446739f, 1.04709792f, 0.10777542f, 0.08725729f, 0.35362047f, 
    0.06319293f, -0.33886036f, -0.51342106f, -0.42609689f, -0.39228505f, -0.02416724f, 0.06273901f, 0.09180982f, 
    -0.05336734f, -0.37678054f, 0.17143035f, 0.26978216f, -0.04428468f, 0.28783336f, 0.08800109f, 0.26893052f, 
    0.07019777f, 1.18514764f, 0.28607336f, 0.78259706f, 0.30172944f, 0.04001558f, -0.01646217f, -0.30931199f, 
    -0.64477271f, 0.74816954f, 0.27233407f, 0.30929077f, -0.10370594f, 0.02314589f, 0.39282945f, 0.03818492f, 
    0.19065374f, -0.27733192f, 0.01573521f, 0.28769308f, 0.48585197f, 0.06336385f, 0.30657795f, 0.32684186f, 
    -0.01077398f, 0.33628026f, 1.02922845f, 0.48096171f, 0.71667558f, -0.50287122f, 0.15001850f, 0.28587523f, 
    -0.79858977f, 0.66646600f, 0.21031547f, 0.21335998f, 0.26207519f, 0.23795016f, -0.66839874f, -0.40969253f, 
    -0.03206554f, 0.61224729f, -0.14688338f, -0.78172785f, -0.15955336f, -0.43725634f, -0.16138655f, 0.05939698f, 
    0.19333161f, 0.07927682f, 0.05032326f, -1.62345624f, 1.09000278f, 0.78638363f, -1.35034788f, -0.09442018f, 
    0.22598913f, 0.54765558f, -0.06065673f, 0.03052484f, -0.68953824f, 0.10636196f, 0.11425564f, -0.21593137f, 
    0.21970050f, 0.02009020f, -0.34768504f, -0.26920310f, -0.14766634f, -0.41265625f, -0.38466582f, 0.14512812f, 
    -0.04077574f, 0.18481645f, 0.38441440f, 0.16763532f, 0.44295248f, -0.66174430f, -0.86896259f, -0.66339630f, 
    0.38269126f, 0.39691061f, 0.41644803f, -0.91361749f, -0.43353331f, 0.12580061f, -0.13226005f, 0.27479157f, 
    -0.05493635f, 0.31043813f, 0.28243297f, 0.01292113f, 0.24271081f, -0.05480350f, 0.33192340f, 0.41115850f, 
    0.04715414f, 0.42459807f, -0.25121430f, -0.43867901f, -0.00798122f, -0.15524778f, -0.60486776f, 0.20035231f, 
    0.82039577f, -0.28152788f, -1.08877850f, -0.27912995f, -0.11035267f, -0.35506511f, -0.56952095f, 0.03599648f, 
    0.25467759f, 0.07679971f, 0.66593808f, -0.08813096f, -0.23841518f, -0.02540370f, -0.25329939f, 0.18329422f, 
    0.40465370f, 0.23922013f, -0.23016515f, -0.10818088f, 0.00624993f, -0.11223759f, 1.27654016f, -0.39920929f, 
    1.18751609f, 0.44468886f, -0.11923608f, 0.75040114f, 0.20248775f, 0.35660058f, 0.36290032f, -0.05691590f, 
    -0.66395223f, -0.34923515f, -0.26731387f, 0.24555740f, -0.10631157f, 0.34936988f, 0.36942744f, 0.09966789f, 
    -0.00578487f, -0.13591814f, -0.28724957f, -0.15312143f, 0.09291580f, -0.11311135f, -0.19503440f, -0.40789270f, 
    -0.64510554f, 1.31141222f, 0.71730840f, -0.95224231f, -0.65320939f, -0.50805664f, 0.14552110f, 0.46595010f, 
    -0.07515124f, -0.00966432f, -0.27089617f, -0.18482652f, -0.69932503f, -0.23915495f, -0.04666984f, 0.25536561f, 
    0.06237717f, -0.18737346f, 0.07744641f, 0.24376583f, 0.10837182f, -0.20250618f, -0.28348333f, -0.34517014f, 
    -0.74413419f, 0.78296411f, -0.46711728f, 0.46578699f, -0.89834404f, 0.67325866f, -0.60905814f, -0.83345723f, 
    -0.09725880f, -0.22866338f, -0.51415151f, -0.03805092f, -0.10651253f, 0.43827674f, 0.30009139f, 0.24755122f, 
    0.41331640f, 0.03769147f, 0.19752760f, -0.18969868f, 0.27554953f, 0.19972514f, 0.24320631f, -0.41385829f, 
    -0.18834235f, 1.32045543f, 0.82448030f, -0.83931500f, -0.51864105f, -0.72650689f, -0.17900817f, 0.34576663f, 
    -0.22215521f, 0.29839149f, 0.41008893f, -0.29088116f, 0.28441688f, 0.45805016f, 0.29914451f, -0.15027657f, 
    -0.19604595f, -0.26401871f, -0.05146097f, 0.45903596f, 0.34701303f, -0.04421351f, 0.02684388f, 0.05788093f, 
    -0.15195592f, 0.19499452f, -0.58566147f, 0.42287999f, 0.31472278f, 1.10353422f, 0.48321083f, 0.92384368f, 
    -0.29455110f, -1.13843703f, 0.21696346f, -0.55775684f, 0.12986836f, -0.31071246f, 0.16872126f, 0.07776152f, 
    -0.58434463f, -0.17789446f, 0.07837566f, 0.00964900f, -0.27312383f, 0.22285001f, 0.01608137f, 0.04659599f, 
    -0.18011358f, -0.10447437f, -0.22843117f, 1.01440692f, 0.95472121f, 0.35792753f, 0.60972083f, 0.59926564f, 
    -0.20421529f, 0.34339362f, -0.33423102f, -0.28330094f, 0.26556429f, 0.18796170f, 0.48420614f, -0.41966030f, 
    -0.04094325f, 0.11863536f, 0.13557817f, -0.10975640f, 0.35937747f, 0.00477509f, 0.17164309f, 0.30575037f, 
    -0.07307626f, -0.15500773f, -0.03580590f, 0.60543615f, -0.67816788f, 0.80759245f, -0.40752479f, -0.69500500f, 
    0.31722778f, -0.86694074f, -0.67993414f, 0.19818553f, 0.05531476f, -0.15237796f, 0.04474691f, -0.24574403f, 
    -0.46512628f, -0.32706025f, -0.05615700f, -0.05736118f, 0.21012747f, -0.19987498f, -0.10998222f, 0.03136487f, 
    0.35066822f, 0.52240169f, 0.03473701f, 0.14624900f, -0.24517411f, -0.62061095f, -0.89548600f, -0.92015922f, 
    -0.57904357f, 0.29048529f, -1.02988923f, 0.69509292f, 0.08698247f, -0.67161924f, -0.05983415f, 0.30309322f, 
    0.18487459f, 0.31728011f, -0.01717604f, 0.13102898f, -0.28901306f, 0.41059405f, 0.34188116f, -0.07954532f, 
    -0.04887093f, 0.09837354f, -0.11268308f, -0.06018913f, 0.25409788f, -0.00827084f, 0.49502307f, 0.71137005f, 
    1.03745592f, 0.35979348f, -0.39368024f, 0.39173487f, -0.52466029f, 0.29117104f, 0.25548962f, 0.20302589f, 
    0.05271799f, -0.29591134f, -0.05580397f, -0.35187933f, -0.13412045f, -0.13594051f, -0.30136928f, 0.09873832f, 
    -0.46228817f, -0.48641402f, 0.07930785f, 0.01539415f, -0.25465128f, 0.06428596f, -0.02939237f, 0.20830113f, 
    1.19296241f, -0.16861011f, -0.59207451f, -0.24969363f, 0.83619356f, 0.06324401f, -0.67990470f, 0.15586774f, 
    0.37983817f, 0.46846035f, -0.35917357f, 0.26859084f, -0.14739273f, -0.55281699f, -0.32038313f, -0.21436790f, 
    0.06564531f, -0.25697103f, -0.16813055f, -0.27242520f, 0.07193732f, 0.09001218f, -0.08865789f, -0.23446649f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27908155f, 0.11578105f, 0.15435876f, -0.07913666f, 0.20230101f, 0.02120255f, -0.05676975f, 0.16716596f, 
    0.10771513f, -0.04438687f, 0.17878968f, 0.12329361f, 0.08222063f, -0.11051021f, 0.04348104f, 0.25905612f, 
    -0.05709219f, 0.33597961f, 0.42045662f, 0.16438693f, 0.53753352f, 0.27118322f, 0.19792482f, 0.17453575f, 
    0.06141500f, 0.10662892f, 0.13615343f, 0.16811173f, 0.47783512f, 0.48382935f, 0.24888009f, 0.02595979f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04490749f, -0.06507710f, 0.30237311f, -0.23386218f, -0.01770826f, -0.07797249f, -0.01044392f, -0.14682253f, 
    -0.10281566f, 0.01961865f, -0.03166574f, 0.01361964f, 0.48800725f, -0.18945311f, 0.07641841f, -0.51690876f, 
    0.03614460f, 0.18006992f, -0.02027557f, -0.19426544f, -0.24641949f, -0.00911673f, 0.08293665f, 0.01881297f, 
    0.17421727f, 0.12274043f, 0.13342504f, -0.50905800f, 0.10847932f, 0.08091207f, -0.10654777f, 0.09401584f, 
    0.03705975f, 0.02132824f, -0.07957655f, 0.11520461f, 0.09283939f, 0.07540481f, 0.10622503f, -0.32776099f, 
    0.12139010f, 0.20027621f, 0.13833529f, -0.04050918f, 0.10202955f, -0.00929137f, -0.02626529f, 0.17862184f, 
    -0.33028749f, -0.04557176f, 0.08707558f, -0.18644887f, -0.06610768f, 0.03625187f, 0.01944616f, -0.10936189f, 
    0.07389268f, 0.02929446f, -0.01355876f, 0.22246179f, 0.01674750f, 0.10198717f, 0.23848416f, 0.10832489f, 
    -0.22809528f, -0.13387084f, 0.15631223f, -0.06072255f, 0.07982743f, -0.12359815f, -0.04534774f, 0.08410963f, 
    0.02176154f, 0.10111558f, 0.00480856f, -0.05577325f, 0.03747719f, 0.18740880f, -0.11952234f, 0.10060810f, 
    0.12285210f, -0.05886913f, 0.04059476f, 0.08361843f, 0.00139328f, 0.10198403f, 0.27291000f, -0.07114194f, 
    -0.12047830f, -0.19300817f, 0.10725022f, -0.02646996f, 0.00274658f, -0.00250644f, 0.04257753f, 0.07849447f, 
    -0.12554382f, 0.00014715f, 0.18149927f, 0.08603653f, -0.09866784f, 0.01444283f, -0.10099529f, 0.16463701f, 
    -0.05796213f, 0.01323143f, -0.10166363f, -0.12501891f, -0.33503786f, 0.17142016f, 0.19311015f, 0.13123548f, 
    0.07333336f, -0.00773265f, 0.01265550f, -0.10760200f, 0.01237144f, -0.13941602f, -0.00173387f, -0.14030604f, 
    0.40829161f, 0.14388011f, -0.02847969f, -0.08801185f, 0.01661631f, 0.22410807f, -0.00637022f, -0.12744445f, 
    -0.02441868f, -0.07558247f, -0.02976472f, 0.07742447f, 0.44813287f, -0.36606261f, -0.36373496f, -0.35285130f, 
    -0.10896154f, -0.00666080f, 0.03537135f, 0.05754376f, 0.02243041f, 0.10325254f, -0.05281776f, 0.00153785f, 
    0.02969601f, -0.11497362f, -0.24776570f, 0.32432213f, -0.04002484f, -0.05034095f, 0.07405707f, -0.22629774f, 
    0.05702109f, 0.12514877f, 0.00155553f, 0.06985202f, 0.25456434f, 0.20762047f, -0.05245699f, -0.01742285f, 
    -0.11509916f, 0.08201774f, 0.04517796f, -0.12840259f, 0.05828890f, -0.08072221f, 0.13480474f, -0.06376716f, 
    0.33005932f, -0.07267905f, -0.00958800f, -0.08214983f, -0.03162098f, 0.10546139f, -0.02067286f, 0.09153496f, 
    0.01418877f, 0.15552005f, 0.14080800f, 0.04634278f, 0.05744078f, 0.07794840f, -0.15507713f, -0.13429597f, 
    -0.16998579f, -0.10462949f, 0.03472778f, 0.04246585f, -0.11818433f, -0.02163481f, -0.17086448f, -0.02628978f, 
    0.35094184f, 0.03622317f, -0.03403196f, 0.26914090f, -0.14654139f, 0.00906294f, -0.08793662f, 0.10132633f, 
    -0.02698360f, -0.15878505f, -0.00589768f, -0.16438179f, 0.21853262f, -0.11444780f, -0.19426918f, -0.02571914f, 
    -0.10809992f, -0.21152203f, -0.11298895f, 0.09173243f, 0.17611620f, -0.07452140f, -0.11721416f, 0.01865015f, 
    0.22335236f, -0.26752353f, 0.18849340f, -0.32732761f, -0.26681229f, -0.10719845f, -0.06515778f, 0.05345281f, 
    0.06154769f, 0.00522023f, 0.17881720f, -0.12627377f, -0.12280488f, -0.01294332f, 0.33981773f, -0.42092681f, 
    -0.02188884f, 0.12507515f, 0.08154024f, 0.00918469f, 0.05071147f, -0.18413979f, 0.01825794f, 0.08174063f, 
    -0.37611938f, -0.39207342f, 0.10689333f, -0.16178262f, -0.13912159f, 0.09910642f, 0.07350305f, -0.21544431f, 
    -0.01897297f, 0.00064428f, 0.13903308f, 0.15990971f, 0.06749942f, 0.09235219f, -0.17325237f, 0.14092545f, 
    0.05851186f, -0.05046255f, 0.06138693f, -0.09586572f, 0.12271655f, -0.13064089f, -0.14255713f, -0.14273284f, 
    0.22798058f, -0.14962015f, -0.18747945f, 0.22871919f, -0.11416753f, -0.12345980f, 0.11109085f, 0.08316498f, 
    -0.05687329f, 0.06898396f, -0.05868788f, -0.11731437f, 0.19451191f, 0.05028668f, -0.14009136f, 0.59357548f, 
    -0.17681071f, -0.07655100f, 0.18342263f, -0.18097506f, -0.03502722f, -0.04926827f, -0.12062796f, 0.00191550f, 
    -0.01038540f, 0.32265583f, -0.29047570f, -0.08624554f, 0.07538155f, -0.04117632f, -0.07520231f, 0.00284696f, 
    0.09604563f, 0.12607385f, -0.07626140f, 0.09631114f, -0.28534147f, -0.27374810f, -0.00537857f, -0.37390104f, 
    0.01762752f, 0.18277575f, 0.00442718f, 0.14355336f, -0.17252958f, 0.01554810f, 0.05280082f, 0.12594804f, 
    -0.13237654f, -0.01643280f, -0.06682118f, 0.20111741f, -0.05125654f, -0.06107855f, -0.05731090f, 0.01442894f, 
    0.08508723f, 0.00862228f, -0.14046615f, 0.08037403f, 0.18416800f, -0.00182941f, 0.15418871f, 0.00193152f, 
    -0.31142044f, -0.08763335f, 0.04693224f, 0.11331572f, -0.03977012f, 0.06066159f, -0.02842866f, 0.02867865f, 
    -0.13328747f, -0.06428186f, 0.01051711f, 0.05740023f, 0.07143111f, -0.00702666f, -0.02090535f, -0.12867095f, 
    -0.02394989f, -0.12994920f, 0.05387719f, -0.06281549f, -0.78407621f, -0.15346444f, -0.15969281f, 0.04653656f, 
    -0.01684957f, -0.16610177f, -0.05953058f, 0.05285135f, -0.01106379f, 0.05274475f, -0.22678497f, 0.01352315f, 
    -0.08707532f, -0.02389969f, -0.02356296f, 0.22411771f, -0.33795995f, -0.07461458f, 0.08295134f, -0.17493069f, 
    -0.18717942f, -0.07047724f, -0.01634162f, -0.12339395f, 0.10927577f, -0.12194785f, 0.25171956f, -0.09674536f, 
    -0.12627599f, 0.13754094f, 0.11687589f, -0.03956741f, -0.01019633f, 0.02945410f, 0.06202474f, -0.05862730f, 
    -0.05488496f, -0.19523682f, 0.18280770f, 0.03517869f, -0.17809053f, 0.01815467f, 0.01061835f, 0.02928725f, 
    0.00588351f, 0.07459032f, 0.04209246f, -0.02504927f, 0.07685083f, -0.36749977f, 0.09999090f, -0.42428234f, 
    0.12465534f, 0.08020627f, 0.05010388f, 0.13215876f, 0.11654276f, 0.13741452f, 0.03281551f, 0.18038739f, 
    0.46153733f, -0.02355665f, -0.21211167f, -0.04901896f, -0.08971740f, 0.01796924f, 0.01603964f, 0.00355237f, 
    0.01954280f, -0.12699473f, -0.11366096f, 0.08599632f, 0.06092124f, -0.19993529f, -0.05357613f, -0.05768647f, 
    0.23505354f, -0.34119603f, -0.14016262f, -0.11794077f, -0.03376608f, 0.03740049f, -0.26314682f, -0.15421765f, 
    0.10514694f, 0.25237542f, -0.09625244f, 0.00805928f, -0.14003852f, 0.03594995f, 0.06065918f, -0.05778300f, 
    -0.14527948f, 0.04868709f, -0.17831783f, -0.08259484f, 0.02970388f, 0.13501526f, -0.26432696f, 0.03247282f, 
    -0.03697064f, 0.16304870f, 0.05277428f, -0.03492817f, -0.01320796f, 0.23751107f, 0.21798736f, -0.12816788f, 
    0.03929939f, 0.11465896f, -0.10009649f, -0.00598364f, -0.10007988f, -0.06675666f, -0.02103954f, -0.07597735f, 
    -0.06070227f, 0.16855368f, -0.13262317f, 0.06923953f, -0.18203074f, -0.15216695f, -0.30087104f, -0.44361576f, 
    0.01647506f, 0.10246890f, -0.09060148f, -0.19523060f, 0.01360018f, 0.12007745f, -0.08849674f, -0.09537765f, 
    -0.05951184f, 0.04690149f, -0.23535359f, -0.21986754f, -0.12088155f, 0.07520454f, -0.04044100f, -0.25757086f, 
    -0.04070819f, -0.02546216f, -0.05037140f, -0.00823821f, -0.18351936f, 0.17748362f, -0.18985651f, 0.04981199f, 
    0.15527003f, -0.07836703f, -0.10610749f, -0.18956295f, 0.02187675f, 0.03255613f, 0.03398207f, -0.04107619f, 
    -0.18233453f, -0.05336756f, 0.00737084f, 0.02615601f, 0.14153145f, 0.11077984f, -0.08986422f, 0.09838157f, 
    0.10026558f, 0.15339354f, -0.11088407f, 0.02798217f, -0.42170009f, 0.01587167f, 0.14807984f, -0.17228781f, 
    0.14805572f, 0.01764404f, 0.02333285f, -0.08108320f, 0.07049470f, 0.12813692f, 0.04340553f, 0.07954964f, 
    0.03456954f, -0.12726079f, -0.05062265f, 0.26032582f, -0.19227245f, 0.08052602f, -0.00451585f, 0.11912088f, 
    0.02751774f, -0.31413677f, 0.01754508f, 0.04631143f, -0.85244906f, -0.24950099f, -0.11338992f, -0.32923213f, 
    0.13952813f, -0.22412957f, 0.02597697f, -0.00349799f, 0.11883100f, 0.20518389f, 0.01711687f, 0.08333391f, 
    0.23929936f, 0.06937973f, 0.02476869f, 0.00603200f, -0.09798864f, -0.12934846f, 0.01322103f, -0.00742166f, 
    0.03069841f, -0.13001615f, -0.09046506f, -0.08033794f, 0.17029937f, 0.09377439f, 0.01031136f, 0.34030867f, 
    -0.14166448f, -0.05312092f, 0.07036126f, -0.06695893f, 0.19041774f, -0.09312681f, 0.03624478f, 0.18182652f, 
    0.12208020f, -0.00364801f, 0.12245020f, 0.44399470f, -0.05762267f, 0.08834354f, 0.07842752f, 0.03312523f, 
    0.08471851f, 0.09108908f, -0.03424667f, 0.20898260f, 0.29369402f, -0.15217590f, 0.22026859f, 0.27731761f, 
    -0.03127789f, -0.15142718f, 0.05119776f, -0.03346945f, -0.11306945f, 0.17084196f, 0.01178693f, 0.09544630f, 
    -0.04198200f, 0.08899431f, 0.24139243f, 0.16645084f, 0.02859215f, -0.00387676f, 0.10924383f, -0.04127860f, 
    -0.03703707f, -0.20401047f, -0.07507804f, 0.03026078f, -0.67208153f, 0.15617332f, -0.30095628f, -0.37263724f, 
    -0.11004424f, 0.03464398f, 0.13177806f, 0.03058819f, 0.06679581f, 0.02186313f, -0.03086231f, -0.02863404f, 
    0.46387514f, -0.01450396f, -0.05211366f, -0.13308498f, 0.02536114f, -0.15044728f, -0.01570581f, 0.21266735f, 
    -0.16393077f, 0.20173511f, -0.04445171f, -0.10360598f, -0.50582790f, -0.14667585f, -0.16847852f, 0.02589512f, 
    -0.11712095f, -0.02657001f, -0.24600951f, 0.01868965f, 0.04435900f, 0.13088867f, 0.15224801f, 0.15400638f, 
    0.51994210f, 0.19510801f, -0.01306927f, 0.05425131f, -0.16994444f, 0.07871708f, -0.08350181f, 0.00161621f, 
    0.17657651f, -0.03258432f, 0.07492333f, -0.19299950f, -0.94876283f, 0.13284801f, -0.18346292f, 0.14517665f, 
    -0.00539982f, -0.28232616f, -0.05649717f, -0.11613498f, -0.13435854f, -0.04879612f, 0.07512169f, -0.09558828f, 
    -0.39574313f, -0.02347486f, -0.15691577f, -0.02699317f, -0.01519607f, -0.15099426f, 0.01998999f, 0.05908149f, 
    0.12461004f, 0.02649609f, -0.17049980f, 0.01040765f, 0.60601771f, -0.03602408f, 0.23715995f, -0.29432732f, 
    -0.04642430f, -0.31125876f, -0.06577643f, -0.00406562f, -0.13072994f, -0.05134271f, 0.03088595f, 0.07257070f, 
    0.13061233f, -0.23358788f, -0.16368096f, 0.07355052f, 0.16226023f, 0.02702935f, -0.04489958f, 0.02174153f, 
    -0.22635092f, -0.03272468f, 0.15995510f, -0.22547726f, 0.23448810f, 0.01354865f, 0.09757446f, 0.18583548f, 
    -0.10032003f, -0.05192548f, -0.01500157f, -0.00437337f, 0.02055955f, -0.01443418f, 0.04947165f, 0.05981585f, 
    0.02117589f, 0.11587249f, -0.07207546f, -0.71596915f, 0.07789666f, -0.01541717f, -0.01965334f, 0.14306553f, 
    0.11547596f, -0.01994072f, -0.11532357f, -0.03489042f, 0.55301201f, -0.04637592f, -0.00532914f, -0.11936328f, 
    0.06972396f, 0.04682985f, 0.04672509f, 0.04588973f, 0.09585165f, -0.12546016f, 0.19211742f, 0.03395786f, 
    0.01964095f, 0.19676648f, 0.04610084f, 0.17961620f, -0.03445415f, -0.07321132f, 0.11959360f, -0.02197373f, 
    0.09115539f, -0.13582845f, 0.05321443f, 0.08851767f, -0.01480639f, -0.01865979f, 0.18632244f, -0.11496096f, 
    -0.11048518f, -0.19135819f, -0.00459822f, -0.10726095f, -0.12456021f, 0.00341942f, -0.06679991f, -0.05578669f, 
    0.20341299f, -0.12122607f, -0.03025277f, 0.02032840f, 0.10231249f, 0.05374370f, -0.10109717f, -0.12179170f, 
    -0.08858474f, 0.03244381f, -0.21078250f, -0.16497417f, -0.79104394f, 0.25811577f, 0.05098315f, 0.30780226f, 
    0.00999583f, -0.02590830f, -0.10363421f, -0.07884908f, -0.00502505f, -0.11876594f, -0.03056211f, 0.15119535f, 
    0.42053518f, -0.01912915f, 0.18626501f, 0.18460727f, -0.09094653f, -0.10789372f, -0.19311792f, 0.14380631f, 
    0.15097383f, 0.04155459f, 0.06113417f, -0.13325779f, 0.13497826f, 0.17397244f, 0.01302517f, 0.28439778f, 
    -0.11104506f, -0.08327437f, 0.16969644f, 0.24146609f, -0.03788183f, -0.02691039f, 0.15984087f, -0.10224490f, 
    -0.14881022f, 0.06423062f, 0.03496678f, -0.18909308f, -0.12668280f, 0.04709170f, 0.09923296f, -0.10309047f, 
    0.04592280f, -0.09999436f, -0.07664843f, -0.08238754f, 0.17390475f, -0.19308010f, 0.01429594f, -0.09593066f, 
    -0.10562438f, -0.01128281f, -0.07966348f, 0.04948457f, 0.00642336f, -0.01852019f, -0.07844447f, 0.10235162f, 
    0.25595328f, 0.04784653f, -0.07526179f, 0.01519953f, 0.10256115f, -0.02403670f, 0.08420503f, -0.07215514f, 
    0.08433232f, 0.03493589f, -0.03187454f, 0.03843079f, -0.24985015f, -0.16593675f, -0.05719097f, -0.37180001f, 
    0.04822731f, -0.10697521f, 0.00990205f, -0.06000060f, -0.11203476f, 0.11652235f, 0.01315832f, -0.05061224f, 
    0.35398158f, -0.17656411f, -0.00762067f, 0.13881916f, 0.03884460f, -0.08224227f, -0.08091871f, -0.02109669f, 
    0.02515349f, -0.12540849f, -0.00979701f, -0.08075874f, 0.47085786f, 0.05720925f, -0.28584027f, -0.05029992f, 
    -0.17377557f, -0.18735535f, 0.14834301f, 0.05561347f, 0.01198501f, 0.14716424f, 0.13795365f, -0.18357797f, 
    0.32054406f, 0.18421054f, 0.14269473f, 0.12940288f, 0.02721507f, -0.13007136f, -0.03902147f, 0.14219676f, 
    0.00526970f, 0.04301405f, 0.03324353f, -0.00783236f, 0.10151253f, 0.31474480f, 0.16492520f, 0.03551427f, 
    -0.11046425f, 0.05013394f, 0.06957322f, -0.03258807f, -0.21565510f, -0.08275760f, -0.01669632f, -0.17819819f, 
    0.49413633f, -0.00498369f, 0.00874533f, -0.16934375f, -0.11675326f, 0.20242719f, -0.00698951f, 0.04893431f, 
    0.16426960f, 0.14177670f, -0.08727492f, -0.22289501f, 0.26395154f, 0.26005504f, 0.10548657f, 0.00948331f, 
    -0.09152324f, 0.10378221f, -0.13111404f, 0.09134861f, -0.12814172f, -0.15952489f, 0.09986784f, -0.06573459f, 
    0.08208568f, 0.05287292f, 0.11679714f, 0.05754483f, 0.04080503f, -0.05237161f, 0.15276840f, -0.02553898f, 
    -0.13321957f, 0.13272092f, -0.08556262f, 0.20800120f, 0.04400169f, 0.11709478f, -0.19700745f, -0.01841855f, 
    0.04723258f, 0.00322734f, 0.01514847f, -0.00425366f, 0.09180439f, 0.03499390f, -0.06820101f, -0.20748894f, 
    -0.22800083f, 0.07723428f, -0.13016891f, 0.10090145f, 0.08493595f, -0.03226623f, -0.02271238f, 0.03046164f, 
    0.13031755f, 0.02814499f, 0.15322347f, -0.00499106f, -0.09198944f, 0.17657840f, -0.07287227f, -0.03541030f, 
    -0.01713531f, 0.07735091f, -0.04580897f, 0.08178287f, 0.03017546f, -0.01388518f, -0.00159032f, -0.06573530f, 
    -0.14425080f, 0.10326351f, 0.00536268f, -0.05849346f, -0.02416462f, -0.11511236f, 0.07735319f, 0.05560626f, 
    0.06235307f, -0.08785099f, 0.19531170f, -0.14199594f, 0.48121047f, 0.03807890f, -0.64425981f, -0.25253543f, 
    0.11706184f, 0.06504580f, -0.21381325f, -0.09672266f, -0.00631086f, -0.09304554f, -0.00634285f, -0.02594374f, 
    -0.03377648f, -0.31299445f, 0.17477785f, -0.22146355f, -0.09983144f, -0.17395435f, 0.20239517f, -0.00782234f, 
    -0.03691031f, -0.25267336f, -0.13502976f, -0.08694512f, 0.32080930f, 0.00014764f, -0.35698742f, -0.13180849f, 
    -0.21782830f, 0.16242719f, -0.13644761f, 0.00928757f, 0.05007108f, -0.05090928f, -0.26822180f, -0.14264205f, 
    -0.63081115f, -0.07457405f, 0.00670865f, -0.14486770f, 0.15588003f, -0.03379545f, 0.11205374f, 0.04004338f, 
    -0.10004054f, 0.09595753f, -0.01695998f, -0.06692287f, -0.19140375f, -0.13421126f, -0.24230646f, -0.04828301f, 
    -0.32492664f, 0.03642889f, 0.06729349f, -0.09101462f, 0.08084890f, 0.01443295f, 0.01416160f, -0.02087270f, 
    -0.14707956f, -0.08437648f, -0.27324015f, -0.52557647f, 0.07286766f, -0.02299382f, -0.05854189f, -0.09228169f, 
    -0.07760643f, -0.14042629f, -0.10615889f, -0.03498479f, 0.09607357f, 0.14782573f, 0.05390648f, -0.17604774f, 
    -0.05271917f, 0.00161564f, 0.15182692f, -0.02033189f, -0.29539418f, 0.11007328f, 0.03267116f, 0.04069621f, 
    0.19327170f, -0.24329461f, -0.06811887f, 0.09223256f, -0.00520291f, 0.14197592f, -0.03949635f, -0.10374249f, 
    -0.13748744f, -0.03389058f, -0.12496415f, -0.02763327f, 0.12690409f, 0.00451084f, 0.03301832f, -0.12289896f, 
    0.13042001f, 0.05598045f, 0.05171956f, -0.01675226f, 0.03159827f, -0.01137632f, 0.07140560f, 0.02127977f, 
    -0.19569135f, -0.44046667f, -0.13755514f, -0.11041537f, -0.02353809f, 0.06191852f, 0.02767303f, -0.20697674f, 
    -0.05663841f, -0.04148439f, -0.06643190f, 0.08232518f, 0.64800584f, -0.12117090f, -0.21902007f, -0.04817796f, 
    -0.07796165f, 0.00852587f, -0.15273504f, -0.04966405f, -0.06791632f, -0.05750596f, -0.11342005f, 0.05380283f, 
    -0.10332419f, 0.03346730f, -0.02144480f, -0.14279535f, -0.11286437f, 0.06725743f, -0.02022161f, -0.06888101f, 
    -0.04400964f, 0.21668224f, -0.03431147f, -0.03431803f, 0.33672261f, -0.05479706f, 0.06423126f, -0.14417601f, 
    0.06859993f, -0.01015162f, 0.15212958f, -0.08316968f, 0.00514184f, 0.01378593f, 0.06709417f, -0.01239831f, 
    0.44189084f, -0.32004827f, 0.15656598f, 0.26268524f, 0.16448440f, -0.02792507f, 0.03860898f, -0.04902434f, 
    -0.07393324f, -0.04797320f, -0.32368314f, -0.12374277f, -0.01041660f, -0.02681968f, -0.15110499f, -0.08411504f, 
    -0.16386700f, 0.12911780f, 0.08053117f, 0.02879762f, 0.02148423f, -0.02005851f, -0.13003454f, -0.04293351f, 
    0.08626494f, -0.04212229f, 0.03862119f, -0.13715337f, 0.02382924f, -0.20425962f, -0.09174225f, -0.02557559f, 
    0.03355849f, -0.18228474f, 0.06558789f, -0.03283524f, -0.42275724f, -0.04047618f, 0.01997790f, -0.03324755f, 
    -0.00303979f, 0.06160145f, -0.06883799f, -0.02053804f, -0.02988464f, 0.07362387f, 0.18781181f, -0.03232799f, 
    -0.14276323f, -0.13878615f, 0.07919538f, 0.03572522f, 0.02933970f, -0.07706085f, -0.01695955f, 0.00072729f, 
    -0.17203620f, 0.02109557f, 0.04991208f, -0.11288771f, 0.07318261f, 0.08814687f, -0.04483261f, 0.18112740f, 
    -0.01054387f, -0.05415724f, -0.01502791f, 0.18282533f, 0.03869759f, -0.20802677f, 0.07645344f, 0.04274725f, 
    -0.06267126f, 0.15335377f, 0.00804126f, -0.10633595f, 0.06799436f, -0.17043811f, -0.02847723f, -0.04467690f, 
    0.13449329f, -0.04732630f, -0.06616700f, 0.01763654f, 0.60935342f, 0.24578713f, 0.02781055f, 0.00755145f, 
    0.04971546f, -0.01147102f, -0.00570766f, 0.22091553f, 0.00772139f, 0.00512882f, -0.06436655f, -0.06491335f, 
    -0.55926073f, 0.28224576f, 0.22527899f, 0.15941396f, 0.06320696f, -0.06040360f, 0.01942246f, 0.11950562f, 
    -0.03979248f, 0.06033622f, -0.04444732f, 0.08730154f, 0.07216473f, 0.15601793f, 0.26011226f, -0.17202204f, 
    0.05653924f, -0.05155172f, 0.00656266f, 0.10975781f, -0.00020976f, -0.10760401f, -0.06848405f, -0.02750060f, 
    -0.29097047f, 0.01413633f, -0.12155700f, -0.31495270f, 0.03489655f, 0.05755902f, 0.04093585f, -0.10473923f, 
    -0.03686445f, -0.06935512f, -0.05276551f, -0.02743424f, -0.10115848f, 0.29310262f, -0.11303532f, -0.16148509f, 
    -0.08434118f, 0.17608185f, -0.17868821f, 0.12264579f, -0.02386360f, -0.14613278f, -0.05973114f, 0.00022460f, 
    0.03111306f, 0.08107136f, -0.08493543f, -0.06638217f, 0.04688364f, 0.02334228f, 0.01648464f, -0.11257169f, 
    0.06433543f, 0.13385597f, -0.00698959f, 0.07863398f, -0.06369264f, -0.02952146f, 0.19491532f, -0.19922288f, 
    0.07349578f, 0.13437453f, 0.08328809f, 0.24290897f, 0.06786411f, -0.12839888f, -0.09700488f, -0.01197063f, 
    -0.51218301f, -0.14511359f, -0.27377877f, -0.21655507f, 0.03829338f, -0.01811315f, -0.12053064f, -0.05469104f, 
    -0.14551261f, 0.15492438f, -0.09656779f, 0.03811433f, -0.46980357f, -0.63043755f, -0.12834361f, 0.15607516f, 
    -0.06282808f, -0.09372570f, 0.16679601f, -0.01054371f, -0.02796925f, -0.01786479f, -0.07770283f, -0.03503043f, 
    -0.53249264f, -0.49100631f, -0.11340143f, 0.08465402f, -0.17907369f, -0.06562904f, 0.00308183f, -0.07193922f, 
    -0.05245521f, -0.27209991f, 0.12337310f, -0.07148661f, -0.30574200f, -0.60399550f, -0.19156277f, -0.03402603f, 
    0.11384452f, -0.03456163f, 0.04843877f, 0.07630284f, -0.06395788f, -0.04611661f, 0.03918630f, -0.17210621f, 
    -0.15970673f, -0.38296857f, -0.49496931f, 0.07699765f, -0.04334842f, -0.03032407f, 0.11467769f, -0.05607937f, 
    -0.03667247f, 0.20180146f, -0.05082847f, -0.08695702f, 0.24666797f, 0.38612226f, 0.35589555f, -0.01976472f, 
    -0.09864707f, 0.03698410f, -0.04998868f, 0.07355404f, -0.02740954f, 0.11619696f, -0.07375491f, -0.16127944f, 
    -0.02620502f, 0.00134475f, 0.00301798f, 0.02474652f, -0.09628852f, 0.09120631f, -0.05929716f, -0.01540857f, 
    -0.05703593f, -0.22131877f, 0.03794911f, 0.07424669f, -0.13955417f, 0.11818589f, 0.27148610f, -0.03989073f, 
    0.02025763f, 0.01467551f, 0.19044384f, 0.00931496f, -0.02906239f, -0.04514858f, -0.03597969f, 0.09382299f, 
    -0.24984409f, -0.32420042f, -0.26319537f, 0.03197436f, -0.16252683f, -0.09517680f, -0.02969164f, -0.00122088f, 
    0.06352807f, -0.04925197f, 0.05445923f, 0.18888846f, -0.00889349f, 0.12392395f, 0.10148837f, -0.01958662f, 
    0.04836664f, -0.00344391f, 0.06489226f, 0.25043306f, -0.08479753f, 0.01771734f, -0.00997446f, 0.00551596f, 
    0.60999346f, 0.13866323f, -0.12153114f, 0.30045444f, 0.05759947f, 0.00598151f, 0.12311672f, 0.14753133f, 
    0.02685393f, 0.01484493f, -0.02006271f, 0.10792565f, -0.02964250f, -0.20341681f, -0.07511967f, -0.01625101f, 
    -0.08498985f, 0.02911888f, -0.02163418f, 0.00343292f, -0.02820608f, 0.06492005f, -0.08333790f, 0.19952188f, 
    0.51875925f, -0.13706724f, -0.06315417f, 0.46749842f, 0.17331009f, 0.08661669f, 0.08846802f, 0.04824323f, 
    -0.07946150f, 0.22456039f, -0.01216507f, -0.03064873f, -0.56126082f, -0.45072654f, -0.11838502f, 0.20724113f, 
    -0.08661677f, 0.00103364f, -0.10457264f, 0.00845482f, 0.00892853f, -0.06534536f, 0.07275812f, -0.02078384f, 
    0.02279509f, 0.19879410f, -0.05792369f, 0.12430582f, -0.01217645f, 0.04187186f, -0.12809035f, -0.10739189f, 
    -0.09186691f, 0.11388928f, -0.16099460f, 0.00217265f, -0.15838602f, 0.19825102f, 0.03201273f, 0.20393732f, 
    -0.12618156f, -0.20521986f, 0.05022868f, -0.04120511f, -0.10295562f, 0.08484485f, -0.24720490f, 0.07249015f, 
    -0.25872824f, -0.66149896f, -0.37911093f, 0.12430425f, -0.08437328f, -0.07763208f, 0.15819767f, 0.08414172f, 
    0.09701592f, 0.03759796f, 0.04332012f, 0.05462636f, 0.20439602f, 0.37453577f, 0.00246430f, -0.07361371f, 
    -0.02205008f, 0.05361548f, -0.13777587f, 0.02114991f, 0.03052186f, -0.02157223f, -0.20193441f, 0.15187398f, 
    -0.28492752f, 0.07568529f, 0.00463241f, 0.06921151f, -0.00793366f, -0.03840660f, -0.28023002f, 0.06100531f, 
    -0.00003943f, -0.12299208f, -0.13976161f, 0.04102636f, -0.35248697f, 0.02243693f, -0.11144700f, 0.41086259f, 
    0.23418361f, 0.02989807f, -0.15955947f, -0.09978191f, -0.03018598f, -0.10043793f, 0.03243507f, 0.02693908f, 
    -0.79601210f, 0.05134965f, -0.12566826f, 0.20902948f, 0.02198891f, 0.01994770f, 0.08804130f, 0.16345072f, 
    -0.03396619f, -0.19755566f, 0.16922458f, 0.05206193f, -0.45791009f, -0.12861694f, 0.36366025f, 0.24465834f, 
    -0.17270227f, -0.04168408f, 0.13481377f, 0.01350459f, 0.03774725f, -0.01044269f, 0.22283581f, 0.11563918f, 
    -0.37038657f, -0.11390097f, -0.10173894f, -0.28630427f, 0.18603282f, -0.15556009f, -0.22318636f, -0.02102503f, 
    0.02243290f, -0.07445537f, 0.11366435f, -0.15922809f, -0.08975841f, 0.30237433f, -0.22127159f, -0.06012199f, 
    -0.03608089f, 0.05951835f, 0.16185561f, 0.02400895f, 0.04540317f, 0.10891560f, -0.11413126f, 0.07747066f, 
    -0.32526633f, 0.11776161f, -0.20726646f, 0.01146528f, -0.15659736f, -0.14897430f, 0.10895082f, 0.08590508f, 
    -0.10272068f, -0.14336798f, 0.06124154f, -0.06510540f, -0.16715217f, 0.17758441f, 0.10951919f, -0.07395345f, 
    0.04216851f, 0.21335503f, -0.09360522f, 0.06760766f, -0.00188024f, -0.18173373f, 0.11264750f, -0.09170742f, 
    -0.61666995f, 0.19489162f, -0.13842037f, -0.06974480f, -0.04925500f, -0.08387505f, 0.10688943f, 0.02341120f, 
    0.07468981f, 0.04978749f, 0.07606621f, 0.02112490f, -0.06563870f, 0.13091697f, 0.05404203f, -0.18225197f, 
    0.04246464f, 0.02633033f, -0.10719103f, 0.19303651f, -0.11985590f, -0.03574048f, -0.01061680f, 0.00517412f, 
    -0.61298233f, 0.01929197f, -0.07206520f, 0.21727754f, -0.03670046f, 0.10490404f, 0.14313641f, -0.03479156f, 
    -0.05992040f, 0.00093645f, 0.16716324f, -0.06578346f, 0.30429211f, 0.06674263f, 0.08594049f, 0.31952569f, 
    0.04903401f, 0.05977898f, 0.09652136f, 0.13291238f, -0.01781378f, -0.00215357f, 0.17696199f, -0.04683211f, 
    -0.66669691f, 0.04169695f, -0.12974174f, -0.20251770f, 0.11574654f, 0.03017767f, -0.02266009f, 0.00606555f, 
    -0.22303821f, -0.02590977f, -0.08876203f, 0.16080469f, 0.63851941f, -0.03987140f, -0.10365827f, -0.21270995f, 
    0.01327761f, -0.15592381f, 0.00344896f, 0.07378010f, -0.03052949f, -0.04846006f, -0.02777148f, 0.02437403f, 
    0.09297092f, -0.43443260f, -0.24650627f, 0.11670645f, -0.04010337f, 0.01233897f, 0.07936130f, -0.00679854f, 
    -0.13596866f, 0.13375887f, 0.02360629f, 0.05195050f, -0.16109759f, -0.01314848f, 0.01201392f, 0.01649260f, 
    -0.10930932f, 0.07203566f, -0.01082566f, 0.08100698f, 0.06096829f, 0.03200107f, -0.01667029f, -0.09841935f, 
    0.47797424f, 0.04995902f, 0.05174394f, 0.14122221f, 0.02556957f, 0.08348558f, 0.07318502f, 0.05114108f, 
    0.08189144f, 0.06864723f, 0.08100053f, -0.07050192f, -0.25022307f, 0.12353291f, 0.01876439f, 0.10672835f, 
    -0.01509858f, 0.01847335f, -0.01130052f, -0.02557619f, 0.07602371f, -0.11676576f, -0.04582708f, -0.14571875f, 
    -0.02983284f, -0.13422789f, 0.04918616f, -0.02235601f, -0.13113135f, 0.06738407f, -0.13748936f, -0.11499690f, 
    -0.00398302f, 0.05362177f, -0.09597249f, -0.14277580f, 0.71858603f, 0.41901281f, -0.11075447f, -0.35592631f, 
    -0.07127110f, -0.15733241f, 0.09049696f, -0.09434538f, 0.10485014f, -0.02745665f, -0.11542047f, -0.03886092f, 
    -0.31136233f, 0.31260446f, 0.07652549f, 0.25366858f, 0.02733273f, -0.01951670f, 0.12076487f, 0.07950431f, 
    0.10351188f, -0.02963417f, -0.06015100f, -0.01097575f, -0.28173813f, 0.01165469f, -0.03388790f, 0.18064074f, 
    0.09897599f, -0.02039248f, 0.01052050f, -0.07538343f, -0.19044347f, 0.06357082f, -0.14335136f, -0.03631640f, 
    -0.07800025f, 0.42710704f, 0.15437569f, -0.24351092f, 0.10142038f, 0.00983705f, -0.09398513f, 0.15018128f, 
    -0.00703458f, -0.02046478f, 0.02580457f, 0.14719115f, -0.09093408f, -0.18929754f, -0.05578854f, -0.33274272f, 
    0.15304390f, 0.30861765f, -0.09516067f, 0.06367859f, -0.01900811f, -0.01818023f, 0.08657783f, 0.03580303f, 
    -0.02257450f, -0.12927611f, 0.19870262f, -0.21925734f, -0.00697347f, 0.15596691f, 0.13951360f, 0.00898883f, 
    0.03660905f, -0.05054099f, 0.20234846f, 0.05618514f, -0.12231780f, -0.28543693f, -0.22547945f, -0.03170099f, 
    -0.12138350f, 0.09100146f, 0.01071736f, -0.05432481f, 0.01405368f, -0.08723777f, -0.11246131f, -0.06545708f, 
    -0.26536986f, 0.37922713f, 0.00450558f, -0.30047068f, -0.00926450f, 0.07206348f, -0.03528715f, 0.10088322f, 
    0.02517650f, -0.16717021f, 0.05906919f, -0.03247090f, -0.18589021f, -0.06813160f, 0.14493461f, 0.16491894f, 
    -0.15182306f, -0.03758304f, 0.02351364f, -0.09074424f, 0.14082251f, -0.07108705f, -0.08329102f, -0.19348677f, 
    0.33349368f, 0.03458276f, -0.13731420f, 0.18906404f, -0.17211494f, -0.10529744f, 0.11006205f, -0.11826490f, 
    0.05690529f, -0.05956655f, 0.07473757f, -0.03774429f, -0.26368272f, 0.11240165f, 0.14368211f, 0.02403546f, 
    -0.03047255f, -0.02538502f, 0.11194704f, 0.12322379f, 0.17122959f, 0.01448335f, -0.08429962f, -0.02882527f, 
    0.07961929f, 0.07874041f, 0.06376929f, -0.15300244f, -0.06980502f, 0.01872850f, -0.03181875f, 0.12009849f, 
    -0.02400696f, -0.05536310f, 0.10276768f, 0.07214279f, -0.26493829f, 0.07117102f, -0.02569534f, 0.15298536f, 
    -0.03818730f, -0.00449769f, 0.04319952f, 0.12652303f, -0.23174728f, -0.02727062f, 0.02845334f, 0.08013200f, 
    0.20016801f, 0.01525396f, 0.02781811f, 0.16034378f, -0.03240234f, 0.03336675f, 0.03047716f, 0.10962772f, 
    0.03551181f, 0.02033317f, 0.13981712f, 0.22166751f, -0.18472573f, -0.44093880f, -0.24264869f, 0.05298460f, 
    -0.03281575f, -0.07539354f, 0.04388828f, -0.06730729f, 0.20375459f, -0.06006634f, -0.04403464f, -0.08399524f, 
    -0.96782827f, -0.19241567f, -0.35413763f, -0.08569938f, 0.16855417f, 0.11645250f, 0.07198995f, -0.04870284f, 
    0.06948276f, -0.12861222f, 0.03303871f, -0.05015030f, 0.44618723f, 0.22075567f, -0.20863797f, -0.06341131f, 
    -0.03157814f, 0.03918587f, -0.29746744f, -0.12349301f, -0.09383541f, 0.07096133f, -0.25336871f, -0.01492012f, 
    -0.03060135f, 0.04639198f, 0.06727920f, 0.00994202f, -0.17080644f, 0.05365175f, 0.04391796f, 0.23653628f, 
    0.02802260f, 0.22914703f, -0.02058425f, 0.06943160f, -0.38900295f, 0.06272549f, 0.46005529f, 0.03014755f, 
    0.15483196f, -0.11525627f, 0.00050901f, -0.12815771f, 0.12047382f, -0.01580032f, 0.02229928f, -0.02308716f, 
    -0.43089774f, -0.00581982f, 0.03945401f, -0.29898512f, 0.14849922f, 0.14107713f, -0.09109158f, -0.01240865f, 
    -0.02338190f, 0.03753166f, 0.03625709f, -0.02811680f, -0.10812504f, -0.05053022f, 0.19854534f, 0.24035315f, 
    -0.31892300f, -0.02222184f, 0.20611323f, -0.16055006f, -0.32354489f, 0.00668867f, -0.00430050f, 0.18220557f, 
    -0.10227534f, -0.22354497f, -0.00194006f, -0.15803686f, 0.18855160f, -0.02765696f, -0.00526280f, -0.06016761f, 
    0.13236833f, 0.11440235f, 0.01153169f, 0.11067781f, -0.36537144f, -0.16895346f, -0.21772747f, -0.24209163f, 
    0.01643282f, -0.14309490f, 0.16113093f, 0.17899193f, -0.09677769f, 0.07154873f, -0.10897149f, -0.11638624f, 
    0.00732274f, 0.33095962f, -0.09761615f, -0.31409836f, 0.05420781f, -0.10028019f, -0.07020476f, -0.16212256f, 
    -0.04291947f, -0.16644603f, 0.00143868f, -0.05605015f, -0.11762580f, -0.15848906f, -0.13260509f, 0.04964696f, 
    0.21642482f, -0.09914482f, -0.20292643f, -0.19616996f, -0.06827402f, -0.06351715f, 0.02092775f, 0.03789449f, 
    -0.58948416f, 0.12409209f, 0.07138710f, -0.15612003f, -0.00755446f, -0.03034166f, -0.14928800f, 0.10434931f, 
    -0.09422985f, -0.14105655f, 0.08855623f, -0.22238980f, -0.18450992f, -0.24883074f, 0.11302084f, 0.20995399f, 
    0.16606899f, -0.18615891f, 0.01510714f, -0.21657911f, -0.05954110f, 0.08313722f, 0.02657627f, 0.16484128f, 
    -0.04397397f, 0.07611922f, 0.43148518f, -0.27171883f, 0.03815982f, 0.02102148f, 0.09238751f, -0.13963452f, 
    0.03205511f, -0.08642778f, 0.04178717f, 0.03636771f, 0.11593116f, -0.01827310f, 0.26097706f, 0.22825259f, 
    -0.05112060f, 0.04443420f, 0.01162745f, 0.00488970f, -0.08342957f, 0.03830267f, 0.05692468f, 0.06626336f, 
    0.05846171f, 0.14923868f, 0.16798592f, -0.21376410f, -0.11988560f, -0.03242185f, 0.05361586f, -0.08754192f, 
    0.02132070f, 0.11626211f, -0.04199478f, 0.10212103f, 0.01054107f, 0.07298519f, -0.06434525f, -0.11774239f, 
    -0.00776775f, 0.05892004f, 0.12842420f, -0.01200348f, 0.01491766f, -0.06610820f, 0.08113255f, 0.15343148f, 
    -0.04724936f, 0.13351703f, 0.01308588f, 0.15035848f, 0.11826370f, 0.01802558f, -0.01864640f, -0.07024540f, 
    0.15720880f, -0.01610661f, -0.30751422f, 0.12163290f, -0.45835257f, -0.45159346f, 0.11001188f, 0.55190665f, 
    -0.11150510f, -0.06350985f, 0.07213561f, 0.10883705f, 0.04941754f, 0.13314423f, -0.03834040f, -0.20380591f, 
    -0.17942208f, -0.15899594f, -0.15532534f, 0.04165388f, 0.08772889f, 0.13050738f, -0.14998567f, -0.06458319f, 
    0.20525262f, 0.13527010f, 0.03828840f, 0.10461060f, 0.32945088f, -0.14974912f, 0.07004568f, 0.12873669f, 
    0.01712943f, -0.03433955f, -0.01000658f, 0.24027926f, -0.17807977f, 0.02816218f, 0.20383443f, 0.12450170f, 
    -0.13454756f, 0.16588621f, 0.19600922f, 0.25053856f, 0.01099761f, -0.16264364f, 0.05943048f, -0.20045382f, 
    -0.07580949f, 0.02341547f, -0.06650101f, 0.09433203f, 0.07833821f, 0.11579444f, 0.00115456f, 0.21035205f, 
    0.12570123f, -0.06796700f, -0.04023989f, 0.26576763f, 0.15717959f, 0.11006428f, 0.05610102f, 0.00869294f, 
    -0.14611946f, 0.16771378f, 0.44354898f, -0.09465913f, -0.04565223f, 0.05797742f, -0.00271892f, -0.06413724f, 
    -0.12490456f, 0.22882938f, 0.14761554f, -0.04645141f, 0.19695252f, 0.14414912f, -0.03802523f, -0.02135101f, 
    -0.12031639f, -0.07906468f, 0.08198829f, -0.06852081f, 0.01552903f, -0.09314265f, 0.10964829f, -0.10530663f, 
    -0.02589817f, -0.06408378f, 0.41191489f, -0.15488222f, -0.24420029f, -0.04415645f, 0.07294339f, -0.16086558f, 
    -0.06344091f, 0.10145122f, -0.08342499f, 0.02323425f, 0.06574871f, -0.14498293f, 0.05425108f, -0.16913973f, 
    -0.15040360f, 0.28276157f, 0.01168067f, 0.07697346f, -0.11208085f, 0.00894368f, 0.05472418f, 0.04992258f, 
    -0.11607177f, -0.16634472f, 0.19598155f, 0.19470595f, 0.04384385f, -0.07365120f, -0.12441387f, 0.24961190f, 
    -0.03090979f, 0.08606438f, -0.24522634f, 0.01379414f, -0.37633929f, -0.27816224f, -0.08594735f, -0.10107215f, 
    0.15037514f, 0.06022891f, 0.05433242f, -0.03171285f, -0.01439140f, 0.13244708f, -0.00339583f, 0.12400626f, 
    0.16089787f, -0.16942382f, -0.00106767f, 0.04424902f, -0.06946476f, 0.10152816f, -0.08312372f, -0.00420937f, 
    -0.07705920f, -0.13611639f, -0.02862962f, -0.18195380f, 0.05382832f, -0.15088888f, -0.13714209f, -0.05027676f, 
    0.06953689f, -0.21674535f, -0.02969053f, 0.07753655f, 0.01353739f, -0.35968110f, 0.06101409f, -0.29107878f, 
    0.01612211f, 0.04940695f, 0.00806696f, -0.30110672f, 0.01060023f, 0.13628513f, 0.01621685f, -0.14967106f, 
    -0.10814333f, -0.04175045f, 0.01275264f, -0.16177881f, -0.31229237f, 0.08588830f, -0.19229160f, -0.15194315f, 
    -0.02531033f, -0.07378793f, 0.25373733f, 0.00562907f, -0.17660338f, 0.02333191f, 0.04590904f, -0.02546766f, 
    0.06264603f, -0.30524719f, -0.25800204f, -0.43915123f, -0.02587824f, 0.03877461f, -0.07536075f, -0.13847822f, 
    -0.05572320f, 0.11871928f, 0.12049626f, 0.24001521f, -0.25160912f, -0.12610309f, -0.20678596f, 0.04613445f, 
    -0.02992288f, -0.01159163f, -0.09697659f, -0.03742532f, 0.04783144f, -0.06454336f, 0.22204393f, 0.11718374f, 
    -0.06172149f, 0.10635694f, 0.04739089f, 0.21248958f, 0.08955809f, -0.01710382f, -0.09024709f, 0.06567903f, 
    -0.04867222f, -0.23123306f, -0.01331570f, -0.22501490f, 0.34471375f, -0.10383309f, -0.06331585f, -0.10374721f, 
    0.03908515f, 0.16191380f, -0.09305231f, 0.14126739f, 0.00507032f, 0.10322318f, -0.24900360f, -0.15675955f, 
    -0.33313897f, -0.59104836f, 0.11683138f, 0.22367747f, -0.07427591f, 0.03895362f, 0.18791208f, -0.06995755f, 
    -0.05896491f, -0.10939283f, -0.21372831f, 0.02382694f, 0.02866535f, 0.07197145f, -0.23115496f, 0.11861590f, 
    0.11535656f, -0.05704032f, -0.07977780f, -0.00083764f, 0.10502456f, -0.02805813f, -0.12794234f, 0.02749080f, 
    0.29035747f, -0.12365360f, -0.06089900f, 0.11353386f, -0.01182527f, 0.06841851f, 0.14980617f, -0.03720189f, 
    0.00222074f, -0.13818732f, -0.04458356f, -0.21940395f, 0.29844156f, -0.76448214f, -0.26445568f, 0.31948814f, 
    -0.09875553f, 0.12798570f, 0.05274605f, -0.20186950f, 0.06602170f, 0.12956572f, 0.04915429f, 0.27495727f, 
    0.17006932f, -0.45875800f, 0.09795541f, -0.00325377f, -0.16809927f, 0.06801460f, -0.03068072f, 0.03649239f, 
    0.09936552f, 0.07833236f, 0.00156680f, 0.23748817f, -0.06021011f, -0.29600674f, -0.38379890f, 0.33423215f, 
    -0.08834868f, -0.06112721f, 0.10432408f, -0.05073897f, 0.06851175f, 0.02802338f, -0.05883872f, -0.09600550f, 
    0.69415730f, -0.09584155f, 0.27461603f, -0.27580041f, 0.00932776f, -0.00591581f, 0.18968818f, -0.07311366f, 
    0.09675227f, 0.06531718f, 0.15496983f, 0.09291681f, 0.09454808f, -0.09283347f, -0.10330806f, 0.44293359f, 
    -0.24098890f, 0.09984944f, 0.02443751f, 0.08515254f, -0.04292649f, 0.10343359f, 0.00621888f, -0.18825601f, 
    -0.45621225f, -0.02131687f, 0.33277375f, 0.22491512f, -0.25677785f, -0.07178140f, -0.00694381f, 0.09940273f, 
    -0.11079258f, 0.08488853f, -0.12258894f, -0.01124902f, -0.04004084f, 0.23618740f, 0.11404619f, -0.20222361f, 
    0.13873488f, -0.02839229f, 0.06094209f, 0.15195127f, 0.00248107f, 0.05692709f, -0.03396050f, 0.10090238f, 
    -0.21407349f, 0.13666977f, 0.21230857f, -0.64460182f, -0.01056149f, -0.10695981f, 0.10382500f, 0.08042288f, 
    -0.16688304f, 0.06604493f, -0.07807132f, -0.07928446f, -0.31298169f, 0.28255147f, 0.16128784f, 0.01532715f, 
    -0.16065264f, 0.13201180f, -0.00885603f, -0.06010869f, 0.07629003f, 0.08478808f, 0.10112555f, -0.25405100f, 
    -0.46979690f, 0.23227057f, -0.09380799f, 0.27575895f, -0.09637276f, 0.07180832f, 0.01447827f, 0.05932070f, 
    -0.14719765f, 0.27131405f, 0.10056041f, 0.09069233f, 0.03653052f, -0.28052184f, -0.12499490f, 0.13619827f, 
    0.04896669f, -0.13283686f, -0.19031458f, -0.12738805f, -0.24240752f, 0.08146841f, -0.08536293f, -0.01561726f, 
    0.07904784f, -0.10407177f, -0.07336523f, -0.03497685f, 0.09878939f, -0.10775539f, 0.04346297f, 0.02221038f, 
    -0.02032456f, -0.12202954f, 0.00062204f, -0.12732314f, -0.04886775f, 0.25281519f, 0.06844133f, -0.19560550f, 
    0.00174708f, 0.03271460f, 0.11866718f, -0.12213644f, 0.01454727f, -0.14171696f, -0.01916561f, 0.01219733f, 
    -0.28085914f, 0.12260219f, 0.07080173f, 0.06567000f, -0.03096075f, 0.09858822f, 0.01634233f, 0.02848835f, 
    -0.01897018f, 0.02618597f, -0.13017930f, -0.06932264f, 0.12785237f, -0.36034840f, 0.17521113f, -0.58979756f, 
    -0.03437223f, 0.09231003f, 0.02294169f, -0.12365710f, -0.14183553f, -0.10705189f, 0.01184734f, -0.07053090f, 
    0.24582881f, 0.12827182f, 0.12267581f, 0.32146999f, -0.10135278f, 0.12832771f, -0.15560712f, 0.03049257f, 
    -0.07884059f, 0.05926735f, 0.15670888f, -0.11714390f, -0.22665842f, 0.00900658f, -0.02475649f, 0.46438649f, 
    0.23959051f, 0.14090054f, -0.06588884f, -0.10274563f, 0.19906589f, -0.00926790f, -0.06830953f, -0.05396762f, 
    0.48333824f, -0.00404782f, -0.14062278f, -0.17414156f, -0.04451532f, 0.00338070f, 0.04078884f, -0.06365025f, 
    0.09428358f, -0.10360812f, 0.04330305f, 0.08524597f, -0.12597078f, 0.23803324f, 0.14962241f, -0.26979333f, 
    0.04840621f, -0.09960911f, -0.02602670f, -0.06072430f, 0.09219630f, -0.16334169f, 0.02872750f, -0.04317583f, 
    -0.45130298f, 0.01585020f, 0.00536776f, -0.24332032f, -0.01749136f, 0.01063557f, 0.14385858f, -0.17818372f, 
    -0.18035130f, 0.05343698f, 0.26007926f, 0.01156248f, -0.26446599f, 0.03176563f, -0.29868042f, -0.08101371f, 
    0.01853045f, -0.03956675f, 0.06051348f, 0.11791083f, -0.05045966f, -0.18906669f, -0.04373413f, 0.08722677f, 
    -0.26503980f, 0.34616870f, 0.12546398f, 0.16018537f, 0.07066611f, -0.15569283f, 0.02888320f, 0.13348387f, 
    -0.03523576f, 0.06268776f, -0.00495182f, 0.17230906f, -0.20439051f, 0.17979586f, -0.26759264f, 0.36399785f, 
    -0.00418003f, 0.16538124f, 0.04807036f, 0.11089946f, -0.00247096f, 0.26582757f, -0.00541087f, 0.26888400f, 
    -0.41377407f, 0.09395638f, -0.25397503f, -0.11146248f, -0.04889521f, -0.16127422f, -0.00943490f, -0.09177130f, 
    -0.12244222f, 0.03438300f, 0.06668042f, -0.04631459f, 0.27453381f, 0.35181370f, 0.03018592f, 0.39229631f, 
    0.16616175f, -0.00736585f, -0.04421863f, -0.02931782f, -0.09837399f, -0.00699632f, -0.02235524f, -0.10108050f, 
    0.05926108f, 0.21719846f, 0.30976263f, 0.21390197f, 0.15499650f, 0.14237696f, 0.17027733f, -0.02624695f, 
    -0.12380771f, 0.10022974f, 0.09172966f, -0.14330584f, 0.13367297f, 0.22646603f, 0.08910817f, -0.01342863f, 
    0.03069615f, 0.06840786f, 0.13026132f, 0.00250245f, 0.02743905f, -0.01573597f, 0.01082904f, 0.03467739f, 
    0.01436581f, -0.28851914f, -0.04399919f, -0.25393078f, -0.00436594f, -0.01900413f, 0.14050241f, -0.05949915f, 
    -0.02654189f, -0.06901838f, -0.04891271f, -0.05887438f, -0.27131039f, -0.03332262f, 0.14408952f, -0.14940852f, 
    0.05044501f, 0.00101998f, -0.01072030f, -0.03341710f, -0.02662837f, 0.08403578f, 0.00674044f, 0.04503407f, 
    0.00545324f, -0.11207537f, 0.13367434f, -0.01989398f, -0.03972460f, 0.05604665f, 0.03092778f, -0.10697831f, 
    0.09078804f, -0.12341235f, -0.01989656f, -0.01533005f, -0.27191129f, 0.07709803f, 0.06201656f, 0.16789450f, 
    -0.13137235f, -0.16955508f, -0.05757935f, 0.04484093f, 0.04973483f, -0.08791286f, 0.04117735f, -0.04058412f, 
    0.23600511f, -0.35909525f, 0.14085837f, 0.01619418f, 0.04454198f, -0.01214914f, -0.10041130f, 0.00026212f, 
    0.01649136f, 0.03881382f, -0.13652198f, -0.12107855f, 0.25758788f, -0.19306891f, 0.09971488f, 0.15218319f, 
    0.29343101f, 0.04737639f, 0.01230465f, 0.08538686f, 0.05963943f, -0.04937519f, -0.00778007f, -0.06638771f, 
    -0.33366251f, 0.10523742f, 0.06282757f, -0.05315039f, -0.08200084f, -0.05997979f, -0.07382225f, -0.00384988f, 
    0.03619757f, 0.04204523f, 0.03324342f, -0.06543810f, 0.04486232f, 0.26808521f, -0.16953713f, 0.30296546f, 
    0.17412482f, -0.10771410f, -0.02658403f, 0.09891137f, -0.05348128f, -0.03122285f, -0.02881777f, -0.12219191f, 
    0.38538074f, 0.00159528f, 0.06268220f, -0.27448523f, -0.10241911f, -0.00544992f, 0.00962721f, -0.02158628f, 
    -0.12327953f, 0.03433449f, -0.12945883f, 0.07774718f, 0.34511092f, 0.25707152f, 0.08041682f, 0.37166774f, 
    0.28709632f, 0.09928043f, 0.11506155f, -0.08510053f, 0.08965378f, -0.01393501f, -0.06821827f, -0.19202210f, 
    0.05887328f, 0.19500548f, -0.11575492f, -0.00417478f, 0.10556457f, 0.05159206f, 0.02011799f, -0.05097558f, 
    -0.03179532f, 0.01711790f, 0.06403307f, -0.22471699f, -0.32541269f, -0.05757027f, -0.17663485f, -0.27366674f, 
    -0.01611587f, -0.05680894f, -0.04204506f, -0.08615410f, -0.06213343f, -0.06435137f, -0.03861786f, -0.04469218f, 
    0.09820902f, -0.06092019f, -0.01847282f, -0.04512238f, -0.06415518f, 0.08480233f, -0.03109682f, -0.13195577f, 
    0.05426399f, 0.02752545f, -0.00082140f, -0.12870388f, -0.27938536f, 0.06566581f, -0.51244044f, -0.17791475f, 
    -0.10140321f, -0.04188433f, -0.04405495f, -0.09803907f, 0.00136501f, -0.04224239f, 0.05214914f, -0.03695858f, 
    -0.26259220f, -0.20623647f, -0.39210388f, -0.20927371f, -0.00105917f, -0.00921120f, -0.15430760f, 0.00299332f, 
    -0.08382697f, 0.01205248f, 0.03795509f, -0.14683612f, 0.35479778f, 0.06292604f, 0.23871617f, 0.32813755f, 
    0.23730589f, 0.03078086f, 0.06970915f, -0.10896361f, -0.15268528f, -0.12443881f, -0.04446410f, -0.08032299f, 
    -0.25533631f, 0.04441061f, 0.07295574f, -0.05317384f, -0.00258486f, 0.02564171f, -0.07791027f, -0.11269058f, 
    -0.06713793f, -0.10485342f, -0.10969076f, -0.14031512f, 0.36999357f, 0.04070007f, -0.01229725f, -0.01972874f, 
    -0.23162995f, -0.01114378f, 0.07248591f, -0.06604925f, 0.07982235f, -0.03547017f, -0.12848721f, -0.08364289f, 
    -0.08438980f, -0.05316401f, -0.12920158f, -0.30729273f, -0.16232963f, -0.01179646f, 0.05481893f, -0.07461935f, 
    0.00730739f, 0.05044480f, -0.10339423f, -0.09659680f, 0.38536581f, 0.03993922f, 0.12755467f, -0.01518159f, 
    0.12578936f, 0.03907867f, 0.02536772f, -0.05742853f, -0.06985722f, 0.07693630f, -0.00500009f, -0.03073623f, 
    -0.00481467f, 0.19169691f, 0.02357195f, 0.36629087f, -0.04260766f, -0.19346079f, -0.02370903f, -0.07267672f, 
    -0.12991993f, 0.11638483f, 0.08303963f, -0.04431725f, -0.25343180f, 0.04238640f, -0.19030055f, -0.09248110f, 
    -0.10233563f, 0.04920553f, -0.01683661f, 0.02969782f, 0.00142552f, 0.08780167f, 0.06216388f, -0.07253776f, 
    -0.71259505f, 0.23144156f, -0.02951299f, -0.06222527f, -0.06928781f, -0.05790594f, 0.03154236f, -0.11659700f, 
    -0.04253053f, -0.10069203f, 0.06511397f, -0.05869781f, -0.26345554f, -0.01160670f, -0.10710134f, -0.18270268f, 
    0.05986762f, -0.14946686f, 0.00136351f, 0.00574963f, -0.06233157f, 0.02072386f, -0.02157893f, -0.16356538f, 
    0.02617647f, 0.11846372f, 0.10094108f, 0.10280327f, 0.12984645f, -0.09865181f, -0.19944791f, -0.11096772f, 
    -0.18543544f, -0.16937289f, -0.00165843f, -0.20699115f, 0.15781122f, 0.04748076f, 0.28306377f, 0.07098380f, 
    -0.03931021f, 0.02760785f, -0.15322292f, -0.18656370f, -0.03888084f, 0.10016101f, -0.10515792f, -0.03207041f, 
    0.10453407f, -0.08182584f, -0.20394805f, -0.42614058f, 0.08203389f, -0.01394961f, -0.09167720f, -0.08381277f, 
    -0.17886668f, 0.01994296f, -0.10446513f, 0.02620487f, -0.18542866f, 0.01752760f, -0.02353180f, -0.07386280f, 
    -0.04964065f, -0.14414641f, -0.02856075f, 0.03101680f, -0.01625104f, 0.05725420f, -0.00213748f, -0.00646170f, 
    -0.08662416f, -0.38338432f, -0.11860363f, 0.11712693f, 0.01327446f, 0.08506288f, 0.01593928f, -0.04870048f, 
    0.21134248f, -0.01074357f, 0.07725933f, 0.01571547f, -0.32108772f, 0.40009639f, 0.14238305f, -0.10832720f, 
    -0.41223821f, 0.07635524f, -0.01990408f, 0.02910554f, 0.09385209f, -0.08513578f, 0.01041438f, 0.12327711f, 
    -0.25535548f, -0.18088464f, 0.25176817f, 0.08915315f, -0.02264029f, 0.05401296f, 0.10208596f, -0.21032210f, 
    -0.06751470f, 0.04006489f, -0.12537493f, -0.04069750f, 0.13298775f, 0.23110655f, -0.17036337f, -0.00343657f, 
    -0.12298855f, 0.07914569f, -0.05674251f, -0.08866569f, -0.07446665f, -0.12047477f, -0.13854259f, -0.16518505f, 
    0.27867657f, 0.09813137f, -0.11890433f, 0.01333002f, 0.08789346f, -0.05040747f, 0.03204338f, -0.08162706f, 
    0.11301941f, 0.10400476f, 0.12742399f, 0.11756428f, 0.19129294f, -0.06584559f, -0.14847115f, 0.15868588f, 
    0.02865269f, -0.19904970f, -0.07430919f, -0.07703757f, 0.09062243f, -0.01285142f, 0.08668558f, -0.01338397f, 
    0.17292711f, -0.10928254f, 0.17351834f, 0.25413829f, -0.02333772f, -0.09859420f, -0.09111631f, -0.08586158f, 
    0.06319984f, 0.05153557f, 0.10796522f, -0.39153844f, -0.31212497f, -0.07158106f, -0.45517993f, -0.06875633f, 
    -0.04870943f, -0.00030184f, -0.22759596f, -0.08893497f, 0.16815166f, 0.03886785f, 0.01568539f, -0.03947020f, 
    -0.17206441f, -0.18291394f, 0.02258440f, -0.07043152f, 0.00290453f, -0.11051630f, -0.06256597f, -0.11841106f, 
    0.06638357f, -0.03926348f, -0.01414631f, 0.11607350f, 0.11119365f, -0.13828173f, 0.19394274f, 0.13750032f, 
    -0.05834005f, 0.06593685f, 0.15797497f, -0.05759185f, -0.09547154f, -0.20943078f, 0.04117794f, -0.17937689f, 
    0.21647856f, -0.04774987f, 0.11957502f, 0.19618294f, -0.15934052f, -0.14663696f, -0.12360734f, 0.03707453f, 
    -0.09440202f, -0.08040230f, -0.09401874f, -0.12959656f, -0.04103393f, 0.36439827f, -0.04516700f, -0.07430165f, 
    0.06508179f, -0.00906778f, -0.27092683f, -0.10102883f, -0.04985543f, 0.00533637f, 0.04810998f, 0.08923096f, 
    0.09754624f, -0.15189956f, 0.08948181f, -0.10408016f, 0.06974385f, 0.08511958f, -0.02910877f, 0.00955003f, 
    -0.13132463f, 0.02559418f, -0.07666796f, -0.14512275f, 0.23621698f, 0.20022811f, -0.08564743f, -0.04488688f, 
    0.07944047f, 0.01465050f, 0.16749099f, -0.04230781f, 0.12701656f, -0.16449869f, -0.17852168f, 0.10753097f, 
    0.15867785f, -0.01098093f, -0.04462431f, 0.08679170f, 0.08698157f, -0.04033015f, -0.06693137f, -0.02026422f, 
    -0.03515996f, 0.01075798f, -0.04331755f, -0.12525743f, 0.12449695f, -0.26075810f, -0.07121295f, 0.15187269f, 
    0.04960529f, 0.06107258f, -0.08690263f, -0.09275212f, -0.12618057f, -0.13942695f, 0.13279377f, 0.03837791f, 
    -0.05684970f, -0.23046134f, 0.10707311f, 0.38082111f, 0.21406308f, 0.01574853f, -0.05280906f, -0.03901921f, 
    -0.05376877f, 0.07330798f, -0.02366006f, 0.01653449f, 0.00360993f, -0.19262010f, 0.00881953f, 0.13819316f, 
    -0.00114910f, 0.18434560f, 0.07395022f, -0.17357303f, -0.07461741f, 0.05814241f, 0.11153817f, -0.06201871f, 
    0.11040463f, 0.28091016f, -0.15685692f, -0.09232163f, 0.15900277f, 0.02940812f, -0.04261672f, -0.11132110f, 
    0.02169753f, 0.00023892f, -0.39332473f, 0.18067807f, -0.02288388f, 0.04622544f, -0.05441063f, -0.13491553f, 
    0.06002624f, 0.16255733f, 0.01301893f, -0.00523935f, 0.04433334f, 0.06179362f, 0.00985197f, 0.15185405f, 
    -0.15137024f, 0.26417401f, -0.07129896f, -0.17767805f, -0.08434078f, -0.15309119f, -0.16895674f, -0.00003639f, 
    0.07258089f, -0.08355824f, 0.07646790f, 0.07638519f, 0.09279147f, -0.27745005f, -0.06144548f, -0.32360277f, 
    0.11722299f, -0.19348605f, 0.01593428f, -0.04979600f, 0.05152681f, -0.05320214f, 0.19059588f, 0.03175345f, 
    0.23192890f, 0.21080855f, 0.18936636f, 0.10352370f, -0.09535733f, -0.00163671f, -0.11986490f, -0.17007555f, 
    -0.00847284f, 0.03127268f, 0.17629783f, 0.14844434f, -0.15819697f, -0.37868127f, 0.12928902f, -0.35217059f, 
    -0.03046767f, -0.04701484f, -0.09162451f, 0.13260156f, -0.01964833f, -0.01787360f, -0.01232017f, 0.03118422f, 
    0.03366358f, -0.42670345f, -0.16318654f, -0.47597560f, 0.05958739f, -0.33949247f, -0.28661567f, -0.05457273f, 
    0.16956227f, 0.01296660f, -0.00239383f, -0.11703602f, 0.13705230f, 0.21715379f, -0.38088641f, 0.04172814f, 
    0.10477626f, -0.10712352f, -0.10340497f, -0.05232626f, -0.01902958f, 0.05467064f, 0.10088796f, -0.08948067f, 
    -0.05413134f, -0.39195985f, 0.05410853f, 0.16864836f, 0.02968869f, -0.10594233f, -0.13799067f, 0.01069406f, 
    0.20525321f, 0.18947782f, 0.07243723f, -0.05642121f, 0.13681361f, -0.11951368f, -0.17007445f, 0.19527617f, 
    0.11840709f, 0.03182035f, -0.06588113f, -0.06374408f, -0.04962312f, -0.05099044f, 0.03314813f, 0.10803974f, 
    -0.33861637f, 0.13313489f, -0.05976557f, -0.46126756f, -0.00357169f, -0.11529378f, -0.05838846f, 0.21949227f, 
    0.03481286f, 0.03694827f, -0.19389397f, -0.01365189f, -0.43408990f, 0.09393292f, -0.05156878f, -0.20484896f, 
    0.00079209f, -0.07709941f, -0.00123246f, -0.26817137f, 0.02228688f, 0.07542028f, 0.06197085f, 0.12866899f, 
    0.01153468f, -0.12155920f, 0.01787988f, -0.02298076f, 0.20241222f, -0.00092065f, -0.14617987f, 0.03430321f, 
    0.15093437f, -0.04916985f, 0.02218581f, -0.21933147f, 0.03884065f, 0.24128191f, -0.20406091f, 0.02259070f, 
    0.25291270f, -0.07253215f, -0.07529832f, 0.04426848f, 0.06373741f, 0.02190529f, 0.05313781f, -0.01006893f, 
    -0.05153157f, 0.58273596f, -0.44552237f, -0.59853166f, -0.04699338f, -0.15720814f, 0.11909378f, 0.08813538f, 
    -0.05774567f, -0.11225117f, 0.01042762f, -0.16774173f, 0.62167031f, 0.08708307f, 0.00806888f, 0.12312311f, 
    0.06163650f, -0.05181699f, -0.09455349f, 0.19822498f, -0.05990969f, -0.09900562f, 0.00482214f, 0.01319219f, 
    -0.02425450f, -0.27851245f, -0.06106988f, 0.07127378f, -0.04567607f, -0.04387802f, 0.00946282f, 0.00801287f, 
    0.05123613f, 0.12711896f, 0.05508175f, -0.09946486f, -0.22793826f, -0.16646641f, -0.05448294f, 0.03329451f, 
    0.11081897f, 0.06683184f, 0.12936236f, 0.19259754f, 0.06321418f, 0.02738403f, 0.01491714f, -0.01431341f, 
    0.33492869f, 0.02660648f, 0.01881496f, 0.13969824f, 0.02933613f, 0.05686616f, -0.00124022f, -0.02599580f, 
    -0.14361535f, 0.02586763f, -0.03424809f, 0.11818637f, 0.35942349f, -0.17707832f, 0.00050825f, 0.07747452f, 
    0.08704655f, -0.00572559f, -0.01043820f, -0.01110491f, -0.16371956f, -0.22092643f, -0.01108438f, 0.01545155f, 
    0.54909468f, -0.51188761f, 0.00851212f, -0.20538940f, 0.12246325f, -0.05326313f, 0.04006865f, 0.01005186f, 
    0.08417019f, -0.14259632f, 0.23309146f, 0.06226692f, 0.05362959f, -0.12270865f, -0.07953142f, -0.29708722f, 
    -0.06506617f, -0.11113179f, -0.02505841f, 0.14236723f, 0.05736034f, -0.00736022f, 0.02387178f, 0.02411304f, 
    0.29813990f, -0.04656028f, -0.11050307f, 0.17465077f, -0.07862635f, 0.05295682f, 0.02502434f, 0.09213880f, 
    -0.11349882f, 0.00228667f, 0.03462089f, 0.04295314f, 0.38276017f, -0.18494008f, 0.21608895f, -0.07629511f, 
    0.02600519f, 0.26419696f, -0.20119323f, -0.08117250f, -0.03675962f, -0.05638386f, -0.04294534f, 0.18080375f, 
    -0.36070168f, -0.09367410f, 0.06184611f, 0.12558185f, 0.05374294f, 0.03704483f, -0.03440111f, -0.11060584f, 
    0.05606480f, 0.05125201f, -0.03716385f, -0.06176932f, -0.63773376f, -0.22951317f, 0.38789907f, -0.38990575f, 
    -0.08957702f, 0.03976542f, 0.10689419f, 0.23193376f, 0.05533910f, -0.17683540f, -0.02358408f, -0.05711549f, 
    -0.22182439f, -0.04270698f, 0.05112555f, 0.05825663f, -0.11658213f, 0.08411958f, -0.04655902f, -0.02108416f, 
    0.10654862f, 0.21987598f, -0.12808798f, 0.11963512f, -0.19409885f, -0.15592462f, 0.11762170f, -0.22130653f, 
    0.12806925f, -0.03089111f, 0.08052227f, 0.16117235f, 0.01236638f, -0.13858464f, 0.00129869f, 0.07332737f, 
    -0.28545240f, 0.47225589f, -0.40400201f, 0.02943243f, 0.13225652f, 0.04934489f, -0.16884878f, 0.00682270f, 
    0.08778740f, -0.03251136f, 0.04320217f, -0.08346766f, -0.09122096f, -0.07813165f, 0.08703491f, -0.27279884f, 
    0.03113334f, 0.05619609f, -0.28935689f, -0.02839565f, -0.14761367f, -0.03127558f, 0.01378549f, -0.18047409f, 
    -0.30896541f, -0.00670105f, -0.42255437f, -0.28978527f, 0.14685652f, -0.07759067f, 0.00396859f, -0.09958837f, 
    -0.14204064f, -0.22262254f, -0.01704516f, 0.01799667f, 0.12177754f, 0.13808835f, 0.17300972f, -0.35022151f, 
    0.03083295f, 0.02904770f, 0.01899423f, -0.07518034f, -0.17394720f, -0.07347176f, -0.12592901f, -0.04243810f, 
    0.49237919f, 0.11716036f, -0.05537266f, -0.07082241f, 0.03964093f, -0.09418463f, 0.00716789f, 0.12571822f, 
    0.00255104f, 0.06074968f, 0.22166739f, -0.07253700f, 0.01099571f, -0.71883583f, 0.03402203f, -0.05132122f, 
    0.16310340f, -0.19084455f, -0.01393708f, -0.01234820f, -0.09262247f, -0.12351330f, 0.22807825f, 0.19487818f, 
    -0.21011288f, 0.25878513f, -0.05061447f, 0.12164692f, 0.17523147f, 0.06779199f, -0.13141818f, -0.07262542f, 
    -0.14217110f, -0.01283677f, -0.08899669f, 0.06212915f, -0.11510064f, -0.02814816f, 0.12096557f, 0.03674229f, 
    0.04831840f, -0.00418618f, 0.02265710f, -0.00676344f, 0.07522278f, 0.00019574f, -0.12335254f, -0.00233275f, 
    0.47704986f, -0.03487494f, -0.09501462f, -0.17969275f, 0.20615879f, 0.07492784f, -0.00071869f, 0.13297246f, 
    -0.00899247f, -0.03043911f, -0.00352207f, 0.07616886f, 0.34815776f, 0.14735284f, 0.11838583f, -0.01996930f, 
    -0.11030336f, -0.05832132f, 0.20066500f, -0.06943130f, -0.07887130f, 0.07531676f, -0.07143892f, 0.02265533f, 
    -0.36475140f, -0.20129730f, 0.06901881f, -0.12322558f, 0.01434259f, 0.09007560f, 0.10790105f, 0.00157087f, 
    -0.10516384f, -0.19996706f, -0.31651556f, 0.12483259f, -0.29168758f, 0.30876449f, 0.48409039f, 0.05998646f, 
    -0.00376969f, 0.05093438f, 0.02322777f, 0.03909611f, 0.11764166f, 0.03688276f, -0.15469022f, 0.11309326f, 
    -0.39029738f, 0.31786934f, -0.12342858f, -0.17118046f, -0.08567978f, -0.11963027f, -0.04807694f, 0.00495024f, 
    -0.02791227f, 0.19297633f, -0.06507131f, -0.01088147f, -0.43799013f, 0.21999504f, -0.06009299f, 0.01286920f, 
    0.12598154f, -0.11425804f, -0.07451330f, -0.11296185f, -0.07981898f, 0.05925236f, 0.05367003f, -0.08593865f, 
    0.19720991f, -0.43769792f, -0.05145076f, 0.04720796f, -0.15059070f, 0.06999142f, 0.05819491f, -0.01901748f, 
    -0.09786675f, 0.03068924f, 0.19771107f, -0.03192252f, 0.00977846f, -0.49052247f, -0.19622716f, 0.28087634f, 
    -0.01102210f, 0.04274505f, -0.08913470f, -0.01855064f, -0.00887948f, 0.11911312f, -0.00221909f, -0.13467526f, 
    0.16223538f, -0.02743618f, 0.24054632f, -0.15492281f, 0.03948807f, 0.09987054f, -0.04049665f, -0.12931235f, 
    0.03359376f, 0.10975630f, 0.05284441f, -0.02856647f, -0.00331234f, 0.00314861f, 0.22985558f, -0.30279925f, 
    -0.16786174f, -0.01798005f, -0.08555602f, -0.14258891f, 0.06044203f, 0.07319925f, 0.08109044f, -0.02923306f, 
    -0.09364485f, 0.07886752f, -0.10208508f, -0.31443253f, 0.19410247f, 0.09095856f, 0.11910607f, 0.13835599f, 
    0.11121895f, 0.13603954f, 0.28058606f, 0.10449070f, -0.06070812f, -0.21313994f, 0.19215915f, -0.00259556f, 
    -0.14096333f, 0.00971880f, -0.02813837f, -0.00784951f, 0.08307417f, 0.11336396f, -0.00677496f, -0.00381165f, 
    0.24190959f, 0.27896759f, -0.03284354f, 0.07431547f, -0.27014330f, -0.14038749f, 0.10112071f, -0.04599674f, 
    -0.00292437f, -0.10705394f, -0.07671586f, 0.01826686f, 0.41920224f, -0.10938945f, -0.03250996f, -0.11740240f, 
    -0.14265589f, -0.10367817f, 0.01490695f, -0.16695271f, 0.01252320f, -0.13593562f, -0.45689878f, -0.24035160f, 
    -0.25147924f, -0.20634712f, 0.00265921f, 0.14202680f, 0.02773533f, 0.01827793f, 0.06013690f, 0.04370786f, 
    0.10242258f, 0.18000405f, 0.02666183f, 0.03960099f, -0.25791591f, -0.10048418f, -0.38135743f, -0.13507245f, 
    0.06469945f, -0.08485596f, -0.13874792f, -0.02889048f, -0.10951386f, 0.14518958f, 0.02242531f, -0.15565677f, 
    0.13597810f, 0.07825265f, -0.07091920f, 0.07944670f, -0.16067784f, -0.05292394f, -0.01098547f, 0.09461699f, 
    -0.16003300f, 0.22764464f, 0.02288050f, 0.02636984f, 0.29762396f, -0.05993773f, -0.08147739f, 0.03763019f, 
    0.11845419f, 0.13880649f, -0.06261838f, 0.07613624f, 0.15110950f, -0.01321543f, -0.04613056f, -0.00940114f, 
    0.16403492f, 0.24075396f, -0.23650286f, -0.11390123f, 0.02633959f, 0.05560726f, -0.01394524f, 0.01902535f, 
    -0.05823508f, -0.04278924f, -0.03460173f, 0.17265312f, -0.26827565f, 0.21734533f, -0.13036391f, -0.06279798f, 
    -0.25925744f, -0.02230687f, 0.04470316f, 0.08749350f, 0.11371282f, 0.03150839f, 0.17411408f, 0.08390037f, 
    0.46924824f, 0.03947074f, -0.15181711f, -0.13587743f, -0.09282144f, -0.00413076f, 0.09454974f, 0.05261570f, 
    0.09386402f, 0.00564841f, -0.08413651f, -0.02822131f, 0.05328279f, -0.06964207f, -0.09722881f, -0.19626662f, 
    0.04376550f, -0.10736968f, 0.11662647f, -0.07060777f, -0.06876845f, 0.06476963f, -0.01833912f, 0.08938705f, 
    0.03184188f, -0.04796847f, 0.04537280f, 0.13494882f, 0.12830926f, -0.10847090f, -0.02562603f, 0.08086310f, 
    -0.06366072f, -0.06176079f, -0.11059143f, -0.13789698f, -0.36137673f, 0.06268334f, -0.08226696f, -0.02483528f, 
    -0.11775534f, -0.04483951f, 0.02265133f, -0.08459786f, -0.02069370f, 0.13900073f, -0.08246849f, 0.11782089f, 
    -0.18001521f, -0.10747222f, -0.13034154f, 0.07082593f, -0.06982692f, 0.09795044f, 0.01091155f, 0.04446314f, 
    0.16865154f, -0.04078329f, 0.02991569f, -0.00988542f, -0.79529852f, -0.11864516f, -0.04378560f, -0.24042125f, 
    0.11424785f, 0.09260386f, -0.21880999f, 0.01179383f, -0.00713595f, -0.00676663f, 0.08478960f, 0.06600406f, 
    -0.45271197f, -0.27945834f, -0.23435046f, -0.51724046f, 0.03962966f, -0.10288922f, -0.01285834f, 0.02340649f, 
    0.01663294f, 0.17803508f, -0.10864160f, 0.08985386f, -0.65150082f, -0.31185687f, 0.20414807f, 0.07532315f, 
    0.22827360f, -0.01935404f, 0.07499953f, -0.00491111f, 0.12417247f, 0.23522677f, -0.00850472f, 0.25215852f, 
    -0.41898882f, -0.14629491f, 0.18073000f, -0.01634915f, 0.11523113f, 0.09368849f, 0.02953794f, 0.00587395f, 
    0.05920476f, -0.03844547f, -0.04655479f, 0.23227578f, -0.51404226f, -0.00436047f, -0.32608992f, -0.29577655f, 
    0.15964971f, 0.10428950f, -0.01403866f, 0.14295028f, 0.12072759f, 0.07492292f, 0.03833340f, -0.05785855f, 
    0.13199730f, -0.02805649f, -0.12984592f, 0.11625635f, 0.05106577f, 0.03486785f, 0.09273417f, 0.13198450f, 
    0.08272596f, 0.16187832f, 0.09179324f, 0.13495682f, 0.30251861f, 0.04632336f, 0.07479631f, -0.01501922f, 
    0.03418551f, 0.16486129f, -0.11282211f, 0.04606276f, 0.01634906f, 0.15689953f, 0.06847519f, 0.17588699f, 
    -1.02642584f, -0.58460569f, -0.03524619f, 0.00805478f, 0.13059419f, 0.10930389f, -0.04955748f, -0.21193787f, 
    -0.09455280f, -0.04328904f, 0.16435845f, -0.09550855f, -0.11823689f, 0.14085463f, 0.00888027f, 0.09370294f, 
    0.13918509f, -0.04215259f, -0.19095205f, -0.02377146f, 0.04722413f, 0.00716655f, 0.03831983f, 0.11291345f, 
    -0.09227604f, -0.08098715f, -0.04723501f, 0.20898952f, 0.04892784f, -0.09625500f, 0.01212569f, -0.15709232f, 
    -0.16634890f, 0.00947732f, 0.09752838f, 0.04377370f, -0.66428322f, -0.39696431f, -0.00833631f, 0.10045302f, 
    0.07075187f, 0.04535299f, -0.08071484f, 0.06877126f, 0.20140889f, 0.01146882f, 0.07989030f, -0.10028632f, 
    -0.08509942f, 0.01442803f, 0.01755560f, -0.16251236f, 0.11451437f, -0.16265126f, -0.06694308f, 0.11584996f, 
    0.10506330f, -0.20667729f, 0.12648544f, -0.00365590f, -0.50118291f, -0.21636276f, -0.17548844f, -0.17010245f, 
    0.06915489f, 0.05697864f, -0.01493004f, 0.00934146f, 0.08064228f, 0.22191256f, 0.11348186f, 0.19128825f, 
    0.06550626f, 0.30879876f, 0.22137821f, -0.03432509f, 0.24216971f, 0.09697890f, 0.19336446f, 0.09156962f, 
    0.10773903f, 0.19154428f, 0.06221212f, 0.14141993f, 0.28351837f, -0.01959390f, 0.00181059f, -0.01764519f, 
    -0.04072887f, 0.14744222f, -0.00130669f, -0.04658262f, -0.02202875f, 0.01560909f, 0.06208692f, -0.07550447f, 
    -0.67157537f, -0.13235343f, -0.08888353f, -0.16753136f, 0.25045666f, 0.01373111f, -0.23144478f, -0.11343003f, 
    0.02626768f, -0.10587320f, -0.21697322f, -0.15364967f, -0.67783451f, -0.31901029f, -0.28073156f, 0.04547302f, 
    0.06360827f, -0.12538508f, -0.02346602f, -0.03307636f, 0.01342587f, -0.14766122f, 0.10622416f, -0.06560660f, 
    0.19994776f, -0.21333559f, 0.05129269f, 0.53756791f, -0.05060288f, -0.00825250f, 0.04122798f, 0.05951121f, 
    0.14736888f, -0.07000221f, -0.10629861f, -0.06240072f, -0.00281226f, 0.07198628f, -0.16043620f, 0.00820740f, 
    0.05290107f, -0.20816749f, -0.20617078f, 0.10767265f, -0.26749533f, 0.02025530f, 0.02785249f, -0.11376990f, 
    0.01436999f, 0.03937979f, 0.18158537f, -0.03602232f, -0.11396746f, 0.11267250f, -0.02017555f, -0.02877507f, 
    -0.07325035f, 0.08739240f, 0.04442088f, -0.24107574f, -0.34062263f, 0.02032631f, -0.04567581f, -0.05333417f, 
    0.12369449f, -0.03239275f, 0.08385192f, 0.10202512f, -0.02949760f, 0.05593207f, 0.15444128f, 0.06405221f, 
    0.34352604f, -0.40842998f, -0.05683496f, 0.14336139f, 0.04337427f, -0.03139429f, 0.09269742f, 0.08756389f, 
    0.05597037f, -0.07056393f, 0.08092038f, -0.10163043f, -0.27751344f, -0.03487615f, 0.11941394f, -0.19498213f, 
    0.03969005f, 0.00649676f, 0.04313519f, 0.13405937f, -0.09999202f, -0.10183559f, -0.01635728f, -0.04079462f, 
    -0.35167769f, 0.07997094f, 0.07426225f, 0.03522068f, -0.03487585f, -0.00808354f, 0.05064655f, 0.14582261f, 
    -0.13335966f, -0.02814466f, 0.07978027f, -0.04314843f, -0.10163141f, -0.24443278f, -0.09679858f, 0.36246687f, 
    0.30879170f, 0.01782689f, -0.05946371f, 0.11088981f, -0.00328244f, -0.11599454f, 0.04269464f, 0.04703220f, 
    -0.04389678f, 0.13810191f, 0.18542145f, 0.00920346f, -0.13912937f, -0.05841966f, 0.04444355f, -0.01663015f, 
    -0.12962247f, 0.13482773f, 0.17714410f, -0.04383091f, -1.04841852f, 0.10682331f, -0.10117605f, -0.17183594f, 
    -0.04796210f, 0.14730535f, -0.07182821f, 0.02928635f, 0.10324553f, 0.04335097f, 0.03974595f, 0.04265352f, 
    -0.09910786f, -0.54525143f, 0.05727700f, -0.08447238f, -0.03672969f, -0.03398824f, 0.05959485f, 0.16792230f, 
    -0.12634261f, -0.06096537f, -0.06180299f, -0.12521091f, 0.04660226f, -0.47637552f, -0.06973683f, 0.15703067f, 
    -0.10635838f, 0.11967956f, -0.04907025f, -0.13143489f, 0.02357364f, -0.01639974f, -0.11634244f, 0.12260970f, 
    -0.38541397f, 0.28992614f, -0.04895121f, -0.01976341f, 0.40405840f, -0.11493817f, -0.14533456f, -0.01359570f, 
    0.01122460f, 0.07660627f, 0.06519052f, -0.01297959f, -0.25158128f, 0.08050825f, 0.01445017f, 0.00212087f, 
    -0.21972701f, 0.28450507f, -0.22981557f, 0.11542577f, -0.15001129f, -0.12200735f, -0.08862737f, -0.25869259f, 
    -0.34500220f, -0.43049955f, -0.17200646f, 0.06401426f, 0.14958997f, 0.07387163f, 0.04453424f, 0.04006272f, 
    0.09514836f, -0.14456774f, 0.01408046f, -0.04023489f, 0.58291876f, 0.12400650f, -0.16350985f, -0.13972880f, 
    0.01957207f, -0.12471005f, -0.07533493f, -0.08490237f, 0.09099973f, 0.06428062f, 0.01102672f, 0.06562835f, 
    -0.11501178f, -0.17567493f, -0.06351312f, -0.28688124f, 0.14867543f, -0.00436059f, -0.06295666f, 0.03672612f, 
    -0.02876270f, -0.13099028f, -0.05099802f, -0.06549185f, 0.54163617f, 0.10580931f, -0.15357327f, -0.10779265f, 
    0.04738737f, -0.00400435f, -0.13575515f, 0.13733648f, 0.00786148f, -0.09992521f, -0.01974255f, 0.06135729f, 
    0.11918505f, -0.02006163f, -0.05471724f, -0.06086287f, 0.11669062f, 0.06037490f, -0.02750705f, 0.14474320f, 
    0.01143101f, -0.05228626f, 0.12019556f, -0.06363020f, -0.32968679f, -0.17337629f, 0.15322468f, 0.46547368f, 
    -0.08601653f, 0.20227264f, -0.22802417f, 0.14084733f, 0.05973345f, 0.03553651f, 0.23516068f, 0.16165088f, 
    0.25222060f, -0.17206845f, 0.02484738f, 0.09660875f, -0.14789648f, 0.00226099f, 0.08741868f, -0.14480881f, 
    -0.06178668f, -0.06605186f, 0.00545587f, -0.08622778f, -0.10530845f, 0.14621919f, 0.01541835f, -0.12208583f, 
    -0.01162896f, -0.01543483f, -0.04551335f, -0.05529252f, 0.17671700f, -0.04767675f, -0.04955438f, -0.23834592f, 
    -0.44344708f, -0.51298320f, -0.16284305f, -0.43178752f, -0.10057158f, 0.02642243f, 0.10406322f, 0.03070654f, 
    0.03397663f, 0.00399384f, -0.01161791f, -0.14683981f, -0.07991754f, 0.08100879f, 0.05370137f, -0.42388254f, 
    0.11556225f, 0.04485849f, -0.12984553f, 0.00545563f, 0.05878409f, -0.08759174f, 0.08962204f, 0.09406616f, 
    0.07645401f, -0.19834439f, -0.05907020f, -0.09381405f, -0.16446748f, 0.17067729f, -0.01873442f, -0.12377072f, 
    0.04986257f, -0.17849684f, 0.02074168f, -0.07448091f, 0.02484646f, 0.22533610f, -0.09788855f, 0.13691051f, 
    0.06565282f, -0.00971875f, -0.18961270f, 0.05562148f, 0.06417954f, -0.06102016f, -0.12485345f, -0.05535435f, 
    0.11824972f, -0.23212549f, 0.02348281f, -0.02580193f, 0.05525408f, -0.06530243f, 0.09666796f, -0.03593099f, 
    0.09836564f, -0.02113644f, 0.07762479f, -0.04252438f, 0.56507593f, 0.12383004f, -0.36506805f, 0.06965160f, 
    0.18340300f, -0.06036002f, 0.03661487f, -0.10358893f, -0.00727934f, -0.02655439f, -0.10380507f, -0.12163095f, 
    0.10832369f, 0.24488573f, -0.07860973f, 0.17578731f, -0.10040777f, 0.01144009f, -0.11150611f, 0.02107212f, 
    0.08577593f, -0.05665277f, -0.08957370f, -0.03100239f, 0.04985751f, 0.24836193f, 0.07441803f, -0.10442615f, 
    0.07813575f, -0.03673010f, 0.08685350f, -0.20630811f, -0.15586209f, -0.04868886f, 0.18166861f, -0.04123260f, 
    0.26510328f, 0.06396455f, 0.05376688f, -0.25517753f, 0.03835316f, -0.06133665f, -0.10636085f, 0.14056464f, 
    0.19419192f, 0.11893901f, 0.03329458f, 0.12770756f, 0.13955152f, -0.32646793f, -0.02516721f, 0.14451665f, 
    0.04563427f, 0.22374880f, -0.07384369f, -0.05820338f, 0.19707714f, 0.09955466f, 0.00622790f, 0.21305388f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11925866f, 0.09602915f, -0.08398192f, 0.00089997f, 0.04929378f, 0.04663197f, -0.00243026f, -0.09583313f, 
    -0.03091830f, 0.06482200f, 0.16649207f, 0.04217550f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
