#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.18978095f, -0.69123179f, -1.26658320f, 0.15215783f, 0.49928963f, -0.27431431f, -0.63277274f, -1.07769656f, 
    0.03616204f, 0.30105257f, -0.10748120f, 1.00468445f, 0.37517041f, 0.29988843f, 0.07707644f, 0.04275064f, 
    0.23266250f, 0.57013494f, 0.30534607f, 0.21261208f, -0.03544113f, 0.16175310f, -0.00794313f, 0.35149008f, 
    0.69752920f, -1.14065504f, 0.86287773f, -0.19933778f, 0.49359715f, -0.19816986f, -1.41880310f, 0.30966526f, 
    -0.43168166f, -0.80384493f, -0.81329459f, 0.46575978f, 0.55081809f, -0.21161887f, -0.23224945f, -0.02961418f, 
    -0.00566699f, 0.08977211f, 0.07739616f, -0.11928927f, -0.11230955f, 0.35341063f, -0.16975753f, 0.19474727f, 
    0.26927859f, 0.43232957f, 0.02183007f, -0.67011321f, -1.35035801f, -1.00110865f, -0.95742893f, -0.74942613f, 
    0.96957785f, 0.34246430f, 0.00432901f, 0.65807420f, 0.74999785f, -0.07878091f, -0.14524123f, -0.37675327f, 
    0.19388017f, 0.16817753f, 0.15898772f, 0.03567571f, 0.41966346f, 0.18351537f, 0.06594762f, 0.44680357f, 
    0.45514929f, 0.17066492f, 0.09936373f, 1.63011694f, -0.13996546f, -1.51914656f, -0.44403276f, 0.03537612f, 
    -0.06852800f, -0.70084959f, 0.27888563f, -0.45747247f, -0.11115352f, -0.01986743f, -0.24898274f, 0.54610008f, 
    -0.07745099f, 0.17499822f, 0.10414841f, -0.12065861f, -0.93485433f, 0.21178570f, 0.47654197f, 0.52005821f, 
    -0.09067289f, 0.55383080f, -0.18954593f, -0.47317663f, 0.90150720f, 0.71972787f, 0.71958858f, 1.34277833f, 
    1.02892232f, -0.56787014f, 0.57223994f, 0.99876434f, -0.10586365f, 0.07543322f, -1.16499662f, -0.71622986f, 
    -0.43215927f, 0.18570684f, -0.25980276f, -0.02613641f, 0.11956589f, 0.54250360f, 0.66869009f, 0.27977556f, 
    0.18958959f, -0.25603074f, -0.12005454f, 0.15713605f, 0.15549603f, -0.78204149f, -2.09878206f, -0.57207400f, 
    0.73843873f, 0.96364367f, -0.74901432f, 1.48449337f, 0.43712983f, -0.27864966f, 0.01346678f, 0.51113766f, 
    0.25360695f, -0.16724737f, 0.16257164f, 0.35505092f, -0.32238248f, 0.09602147f, -0.29047185f, -0.09086400f, 
    -0.08822535f, 0.01394497f, -0.03387012f, -0.06134648f, 0.09135409f, -0.22776489f, 0.54571134f, 0.99706608f, 
    1.48504746f, 0.77642787f, 0.87220937f, -0.80460525f, -0.67106748f, -1.22768819f, -1.12144828f, -0.22526275f, 
    0.54926097f, 0.37063929f, 0.10352325f, 0.19378927f, -0.43885002f, 0.28032154f, -0.27612361f, 0.22823323f, 
    -0.03695942f, 0.17472275f, 0.00334632f, 0.10013157f, 0.06544745f, 0.10918328f, -0.03926407f, 1.11669481f, 
    -0.43640655f, -0.77018625f, 0.20175253f, 0.91200167f, 1.02200377f, 0.26969364f, 0.12681775f, 0.32766241f, 
    0.37169769f, -0.30323535f, -0.08002491f, -0.75725389f, -0.31911057f, -0.17832294f, -0.25548929f, -0.34306696f, 
    0.25664920f, 0.35653019f, 0.08039819f, -0.11037222f, -0.27060387f, -0.49693602f, -0.32674348f, -0.58125085f, 
    0.33593166f, 0.90479410f, 1.13214350f, 0.82752889f, 0.03780638f, -0.50058866f, 0.64825743f, 0.12626876f, 
    -0.55221206f, 0.97938067f, 0.00855801f, -0.15172200f, 0.53956884f, 0.61657465f, 0.46619201f, 0.02357433f, 
    -0.20526403f, 0.13352287f, -0.20777474f, -0.20019479f, 0.71643651f, 0.02816304f, 0.29430744f, 0.45336810f, 
    -0.39390713f, 1.77292848f, 1.60312283f, 0.15355521f, -0.40055951f, 0.15811676f, -0.40047446f, 0.38178411f, 
    -0.16718811f, 0.94848561f, 0.66895229f, -0.27663249f, 0.23239015f, -0.25489339f, -0.38142067f, -0.00170376f, 
    -0.05799430f, -0.03427919f, -0.39783379f, -0.20892948f, 0.09511367f, -0.56324726f, -0.03525361f, -0.00651765f, 
    0.13955174f, -0.05269057f, -1.08235657f, -0.07679474f, -0.65294981f, -0.55679935f, -0.80417681f, 1.27007854f, 
    1.87032259f, 0.00113776f, 0.51125699f, 0.52386045f, 0.00352325f, -0.25033849f, 0.30794325f, -0.38755834f, 
    -0.23993267f, 0.06231857f, -0.01174158f, 0.20794229f, -0.26466364f, -0.39641044f, -0.14413899f, -0.36103386f, 
    0.05476021f, -0.20777521f, 0.03287064f, -0.53656471f, 0.78671324f, -0.62995124f, -1.44531798f, 0.21218541f, 
    -0.11016254f, -1.14082658f, 0.46535942f, 0.84564930f, -0.54459804f, -0.44771203f, -0.56736076f, 0.15270935f, 
    0.25485393f, -0.28194657f, -0.22205330f, 0.04935506f, 0.16615517f, -0.15540850f, -0.32454181f, -0.21719573f, 
    0.03300506f, 0.18094558f, -0.16713163f, -0.03175191f, -1.06025422f, -0.45629492f, 0.12175099f, 1.00802076f, 
    -1.38640511f, 0.47882122f, 0.42653957f, 0.57058388f, 0.08346441f, 0.03197285f, -0.20031179f, -0.74640018f, 
    -0.55105174f, -0.35196039f, 0.17204808f, 0.32848793f, 0.28533915f, -0.42776784f, -0.18762340f, -0.04291377f, 
    -0.37850475f, 0.34199366f, 0.40661994f, 0.64850950f, -0.13396326f, 0.11431905f, -0.32756069f, 0.75774068f, 
    1.12011051f, 1.45747232f, 1.27398396f, 0.49818599f, 0.77297229f, -0.24825460f, -0.27015018f, 0.11532716f, 
    -0.35527822f, -0.66495496f, 0.22472420f, -0.00043371f, 0.06391504f, -0.10351752f, -0.19713365f, -0.16394125f, 
    0.10107142f, -0.02474192f, 0.12098864f, 0.10638972f, 0.01167549f, 0.10216669f, -0.96236837f, -1.39127481f, 
    -1.18944430f, -0.39643401f, 0.32093933f, -1.05137432f, -0.21737306f, 0.74942076f, -0.29123741f, -0.15131868f, 
    0.17638783f, -0.18377288f, 0.20177837f, -0.09928744f, 0.22210738f, 0.05012607f, 0.11304024f, 0.10339856f, 
    -0.34317401f, -0.34711623f, -0.25922379f, -0.36067742f, 0.21356148f, -0.00484869f, 0.24843486f, 0.11493716f, 
    0.64208299f, -0.49829859f, -0.23650606f, -0.72321618f, 1.05683804f, 0.23165567f, -0.94406992f, -0.65193731f, 
    -0.70598108f, -0.71182591f, 0.39914370f, -0.29623953f, -0.13141617f, -0.54640883f, -0.82659054f, 0.00142675f, 
    -0.38028890f, 0.05918304f, -0.54211956f, 0.00643841f, -0.25282335f, 0.22006829f, -0.15403959f, -0.15502328f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.66964179f, 0.49960956f, 0.13976513f, 0.20397833f, 0.03806832f, 0.60619485f, 0.17222489f, 0.15157415f, 
    0.38929382f, 0.36746550f, 0.25943363f, 0.36177874f, -0.02559643f, 0.35148928f, 0.22876157f, 0.29554009f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09513125f, -0.87625992f, 0.37491813f, 0.15515640f, -0.03844140f, -0.06831086f, 0.18911441f, 0.01676563f, 
    -0.08948201f, 0.15291578f, 0.00380222f, -0.06870311f, -0.43986362f, -0.06450803f, -0.07090545f, -0.00922655f, 
    -0.00605951f, -0.16650182f, 0.04650303f, -0.06474928f, -0.04000304f, -0.07376982f, -0.07397778f, -0.13283794f, 
    -0.59748358f, 0.00215147f, 0.05924955f, -0.44831139f, 0.02672953f, 0.02442094f, 0.31156129f, -0.31904328f, 
    -0.04070767f, -0.11874358f, 0.14857171f, 0.10622578f, -0.06198935f, -0.68277085f, 0.13503787f, -0.24468686f, 
    -0.04764562f, 0.00291725f, 0.03415714f, 0.11977984f, -0.61830026f, -0.08941877f, -0.03595173f, 0.19455902f, 
    0.21143624f, -0.05956088f, -0.09260973f, 0.43857056f, -0.24389023f, 0.22665371f, -0.10269754f, 0.00861889f, 
    0.28191823f, -0.16837741f, 0.26072448f, 0.03331378f, -0.41712525f, 0.42995429f, -0.15391162f, 0.04923557f, 
    0.04211648f, 0.05311673f, -0.28984192f, -0.07159511f, 0.06085669f, -0.10895771f, -0.05136845f, 0.03807953f, 
    0.21048999f, 0.04356648f, -0.13124855f, 0.21637493f, -0.44518402f, -0.19631065f, -0.00140910f, 0.11564004f, 
    0.13287522f, -0.00341668f, -0.09166422f, 0.08021400f, 0.21573411f, 0.06979531f, 0.08784115f, 0.27181521f, 
    -0.03233889f, 0.14729312f, -0.09193452f, -0.00640533f, 0.04440386f, 0.00644872f, -0.05696423f, 0.00542937f, 
    0.01538741f, 0.12714152f, -0.26821521f, 0.13636737f, -0.25215468f, 0.01680956f, -0.05136703f, -0.39510515f, 
    -0.15936552f, 0.07394852f, 0.14410539f, -0.04243372f, 0.07743815f, 0.10730881f, 0.00685989f, -0.31469145f, 
    -0.27224207f, -0.35210240f, 0.11755982f, 0.17472851f, 0.00061355f, 0.05758229f, 0.28830162f, -0.14032342f, 
    0.75734854f, 0.51262110f, 0.03736138f, -0.59654701f, 0.05869594f, 0.12288490f, -0.05882632f, -0.04399550f, 
    -0.00625740f, -0.00552763f, 0.03155974f, 0.06696890f, -0.08120740f, -0.23465320f, 0.21189183f, -0.43908092f, 
    -0.03216007f, -0.17416860f, 0.04619106f, -0.24223334f, 0.14427358f, -0.01981289f, 0.07614529f, -0.10762504f, 
    0.30225223f, 0.40121707f, 0.09849204f, 0.18577361f, 0.03986288f, 0.36525807f, 0.12892015f, 0.00167614f, 
    0.09455086f, -0.03816921f, 0.00857404f, -0.04989729f, -0.20736846f, 0.18178582f, 0.21975200f, 0.21701536f, 
    -0.14238881f, 0.24154912f, 0.03533707f, 0.01956679f, -0.05702152f, -0.14265861f, -0.04802107f, -0.15174766f, 
    -0.68582195f, 0.15544203f, -0.26381874f, 0.19632468f, -0.00749575f, -0.07370845f, -0.29720914f, 0.04432965f, 
    0.03681873f, 0.21880633f, -0.27900240f, 0.05538962f, -0.12552790f, 0.31012166f, -0.02776760f, -0.04823711f, 
    -0.10159261f, -0.09555621f, -0.07026735f, 0.14794168f, -0.20018068f, 0.11256966f, -0.04921597f, 0.00659299f, 
    0.37042591f, -0.34165886f, 0.09881527f, -0.15566579f, -0.01659239f, 0.01502227f, -0.15643591f, 0.02937826f, 
    -0.13339671f, -0.04373023f, 0.20490298f, 0.03516876f, -0.62267786f, -0.18237002f, -0.51961917f, -0.45697328f, 
    0.19679832f, 0.20293927f, -0.03532568f, 0.08101702f, 0.06591105f, 0.05931481f, 0.30895853f, 0.16835852f, 
    0.78021538f, -0.32617989f, -0.56582862f, -0.07012043f, -0.04007335f, -0.01185571f, -0.07944342f, 0.12887442f, 
    0.11025005f, -0.02660052f, -0.05811476f, 0.13177657f, 0.30974019f, -0.34063289f, 0.23525514f, -0.44965389f, 
    -0.28910205f, -0.17687997f, 0.18671973f, -0.05518816f, -0.04193226f, 0.17819558f, -0.17573455f, 0.03208698f, 
    0.37906331f, 0.17710529f, -0.13944133f, 0.38253966f, -0.12148593f, 0.00998000f, -0.09584042f, 0.08151686f, 
    -0.16357821f, 0.15554862f, -0.17268895f, -0.08653069f, 0.25016382f, -0.37458870f, -0.10790375f, 0.05538244f, 
    -0.13157131f, 0.16130504f, -0.09029015f, -0.04918000f, 0.10495151f, 0.10155461f, 0.08033199f, -0.06842431f, 
    0.17936477f, -0.23979691f, 0.17454700f, 0.02682469f, 0.01973805f, -0.09338650f, 0.11495769f, -0.08605949f, 
    0.06559848f, -0.01215231f, 0.01086676f, -0.08670586f, 0.51742345f, -0.34395200f, 0.07692420f, 0.02837960f, 
    0.22921389f, 0.00800276f, -0.48215273f, 0.15358351f, 0.15680289f, -0.02929389f, -0.06820704f, -0.08160818f, 
    0.20599414f, 0.23533845f, 0.14760500f, 0.14246477f, -0.14967287f, -0.06242419f, -0.03576796f, 0.08512065f, 
    0.10559901f, -0.01469261f, 0.00208170f, 0.09652228f, 0.63789904f, 0.19518921f, -0.10860219f, 0.18326557f, 
    -0.14831600f, -0.18777253f, 0.15666190f, -0.16305505f, -0.28883249f, -0.07867050f, -0.24958891f, 0.17561398f, 
    -0.24395938f, -0.28340617f, -0.08336592f, -0.19506958f, 0.03659030f, 0.02284158f, 0.13039199f, -0.21166989f, 
    0.06564236f, 0.03335787f, -0.00480324f, 0.07257637f, -0.84543175f, -0.15395884f, 0.12471816f, -0.58500576f, 
    -0.19357240f, 0.00726300f, 0.03454526f, 0.14204082f, 0.04356607f, -0.23031078f, 0.11264007f, -0.02179979f, 
    -0.75428921f, -0.10307164f, -0.24404716f, 0.32631621f, -0.21275896f, -0.13694048f, 0.02971187f, -0.15600497f, 
    0.09716809f, 0.06408414f, -0.16042951f, 0.08323084f, 0.24908566f, 0.07474402f, -0.00770624f, 0.23543349f, 
    -0.18904647f, 0.11474754f, 0.01228813f, 0.00297249f, -0.19479585f, 0.22601098f, -0.00419429f, -0.00453709f, 
    0.33244714f, -0.01928592f, 0.23477891f, 0.11199401f, 0.08653550f, 0.02183085f, -0.09075158f, 0.09768202f, 
    -0.05277778f, -0.26242030f, 0.13424020f, 0.03887677f, -0.13301855f, -0.64199978f, -0.25070065f, -0.16306266f, 
    0.07570349f, -0.16041926f, -0.02306483f, 0.05306247f, -0.08242425f, -0.16880028f, -0.14827122f, -0.16035096f, 
    -0.48582697f, -0.17173782f, -0.04249568f, -0.48965615f, 0.00180744f, 0.06425706f, 0.10999910f, 0.22874998f, 
    -0.14329642f, 0.04320961f, 0.00888333f, -0.14123118f, 0.67611951f, 0.02544102f, -0.75123900f, -0.28701118f, 
    0.08653773f, -0.00846717f, -0.20032914f, -0.15648328f, -0.17153613f, -0.00562425f, -0.09752072f, -0.38769522f, 
    0.08891673f, -0.01299432f, 0.30532718f, 0.46825877f, -0.38345462f, -0.21150786f, 0.04090983f, 0.02245363f, 
    -0.17734767f, -0.25941858f, 0.23026596f, 0.05747045f, -0.43173110f, -0.09350082f, -0.01802666f, -0.38736135f, 
    -0.07943405f, -0.18579108f, 0.04784049f, -0.07369540f, -0.00631281f, -0.02415942f, -0.02535766f, -0.00863147f, 
    -0.32230598f, 0.03244846f, -0.43637985f, 0.09641924f, 0.17664899f, 0.03604152f, 0.08663383f, -0.07225244f, 
    -0.08432449f, -0.18758082f, -0.02510451f, 0.13418353f, 1.10579860f, -0.49055818f, 0.07479014f, 0.07643095f, 
    -0.15473351f, 0.04784169f, -0.23458567f, 0.04748259f, 0.08421552f, -0.16843408f, 0.03975060f, -0.00447357f, 
    -0.02829343f, 0.22633284f, -0.52770489f, 0.27346763f, 0.30814633f, 0.09440630f, -0.08463147f, -0.23330355f, 
    -0.02240766f, 0.05919943f, -0.06820870f, -0.16449392f, -0.06056817f, -0.05786226f, 0.28512329f, 0.04541576f, 
    0.03201354f, -0.05186315f, 0.15286860f, 0.06916416f, 0.19067159f, -0.28117204f, 0.01566918f, 0.03398560f, 
    0.12928899f, 0.19632205f, -0.35901338f, -0.20607148f, -0.11297658f, 0.24009416f, 0.09194950f, -0.28741959f, 
    0.09765030f, 0.07838314f, -0.06847390f, -0.16123398f, 0.33984590f, 0.20024498f, 0.02467832f, -0.19265899f, 
    0.04354444f, 0.03791689f, 0.33216676f, 0.18988530f, -0.14022419f, -0.02565078f, 0.19794890f, -0.24482651f, 
    0.76822168f, 0.17180307f, 0.34833050f, 0.26244009f, -0.03929678f, -0.28769383f, 0.06768563f, 0.26610914f, 
    0.05689093f, 0.00756305f, 0.13499178f, -0.12951465f, -0.86677974f, -0.06964555f, -0.31587553f, 0.00550149f, 
    0.28564945f, 0.04073345f, 0.04334307f, -0.02183129f, -0.01237914f, 0.13659562f, -0.14558142f, -0.23888612f, 
    -0.02905334f, -0.24537012f, 0.06933670f, -0.27369118f, -0.12774713f, 0.00817467f, -0.41923037f, 0.16702315f, 
    -0.01485130f, 0.02425728f, 0.17984354f, -0.19453339f, -0.17644083f, -0.07120014f, -0.02671965f, -0.08337698f, 
    0.12941933f, 0.00053202f, -0.22202331f, -0.07320235f, 0.18171756f, -0.04041434f, 0.03977018f, -0.11159720f, 
    0.80097145f, -0.31264436f, -0.55241865f, 0.34623519f, -0.34290388f, 0.07540734f, 0.00665136f, -0.15743060f, 
    0.03266726f, 0.00356832f, 0.05721121f, -0.05375595f, -0.21242799f, -0.24367839f, -0.11979775f, -1.14009154f, 
    0.00445023f, -0.08165852f, -0.05624896f, -0.15208487f, -0.12390489f, 0.26289204f, 0.10004638f, 0.22276524f, 
    0.23264441f, 0.28198764f, 0.22086281f, 0.30243278f, 0.13722470f, 0.13929750f, 0.06983797f, -0.01805991f, 
    0.04338664f, 0.03672722f, -0.08733179f, -0.11259010f, -0.33921683f, 0.54727715f, 0.16454944f, -0.08780193f, 
    0.25305885f, -0.06684025f, 0.05489718f, 0.08631141f, -0.17873353f, 0.07686001f, -0.18005663f, -0.03478754f, 
    0.04757465f, -0.47574946f, -0.08959164f, -0.26809758f, -0.20819721f, -0.10564534f, -0.06478111f, 0.07846147f, 
    0.13006327f, -0.03540074f, -0.03554929f, 0.21190868f, 0.57906020f, 0.16530955f, 0.09684082f, -0.04913280f, 
    -0.03922974f, 0.20546110f, -0.10932929f, 0.14763756f, 0.05592649f, -0.02759437f, 0.09535778f, 0.00789702f, 
    -0.84439772f, -0.49077538f, -0.01917902f, -0.17096512f, -0.28167322f, -0.16376305f, 0.03551722f, -0.16973296f, 
    -0.10521800f, -0.04905596f, 0.22525808f, 0.00167479f, -0.24203297f, 0.08507419f, 0.17306404f, 0.27559400f, 
    -0.05819149f, 0.03716370f, 0.25944713f, 0.05201174f, -0.09179126f, 0.08069788f, -0.19976282f, 0.03017123f, 
    -0.26053384f, -0.32316875f, -0.03832790f, 0.56011111f, 0.26750979f, 0.22460929f, -0.00727893f, -0.06260215f, 
    -0.05124801f, 0.14273421f, -0.06201825f, -0.19147567f, -0.46640262f, 0.14613719f, 0.04824255f, -0.09168736f, 
    -0.13506308f, 0.18308368f, 0.18329877f, -0.17615932f, 0.19618423f, 0.10599650f, 0.17915787f, 0.23531869f, 
    -1.51036894f, -0.21379548f, 0.19593452f, -0.15514629f, -0.11378167f, -0.09521561f, -0.00009278f, -0.22571146f, 
    0.01463053f, -0.20221242f, -0.11859034f, 0.05019815f, -0.41363868f, -0.53373694f, -0.49821877f, -0.38654640f, 
    -0.21761668f, 0.12271599f, 0.09817889f, 0.09518628f, 0.00209516f, 0.11049850f, 0.04352655f, 0.12971692f, 
    -0.42487314f, 0.20848900f, -0.09850986f, -0.23031279f, -0.04079667f, -0.03722746f, -0.01172171f, 0.04373368f, 
    -0.13058063f, -0.10168929f, -0.11257821f, -0.06895774f, 0.03695327f, 0.21797720f, 0.15717958f, 0.09171577f, 
    -0.07133345f, -0.05358130f, 0.09866015f, 0.01134884f, 0.16054007f, 0.25325522f, -0.12433846f, 0.07986019f, 
    0.39548457f, -0.27245063f, -0.03490899f, -0.33437195f, -0.04927840f, -0.25686568f, 0.08872149f, 0.21963237f, 
    -0.05390823f, -0.25653249f, 0.17084618f, 0.01854290f, -1.04953694f, -0.26208830f, 0.09794504f, 0.08067053f, 
    -0.23843880f, 0.11001509f, -0.00961859f, -0.27965981f, 0.02226587f, -0.18020663f, 0.04465988f, -0.18303515f, 
    0.45667666f, -0.30934617f, 0.00263005f, 0.09990223f, -0.07787592f, -0.30268008f, 0.05642127f, 0.01480548f, 
    0.00692213f, 0.00157044f, -0.09747934f, -0.00469653f, 0.64540511f, 0.22527984f, 0.01647505f, 0.28091273f, 
    -0.26302844f, 0.20638232f, 0.04085013f, 0.19674772f, 0.03889132f, 0.02766763f, -0.15273258f, -0.01834554f, 
    0.02945185f, 0.08277389f, -0.04421664f, 0.65310800f, -0.28582484f, 0.02578755f, 0.07495462f, 0.14767367f, 
    -0.02745489f, -0.19475166f, -0.14857723f, 0.06861717f, -0.18988459f, -0.33580229f, 0.35316274f, -0.04615026f, 
    0.05604007f, 0.06195400f, 0.03823512f, 0.10439296f, 0.08750238f, 0.09449899f, -0.12285960f, -0.00364149f, 
    -0.27730206f, 0.00824195f, 0.07839840f, 0.27726069f, -0.08566941f, 0.18798065f, 0.18084088f, 0.00418118f, 
    -0.14266926f, 0.07521964f, -0.02377962f, -0.07377679f, 0.34101459f, 0.09919616f, -0.25349376f, -0.01425195f, 
    -0.04015255f, 0.11438066f, 0.13933635f, -0.05086064f, -0.04184766f, 0.05044539f, -0.07842699f, -0.23436996f, 
    0.48154896f, 0.49533030f, -0.06618816f, -0.02790767f, 0.16153912f, -0.14190491f, 0.12287770f, 0.06161090f, 
    -0.07658520f, 0.17144158f, -0.03562928f, 0.05085342f, -1.10357523f, 0.22795583f, -0.31431696f, 0.02735845f, 
    -0.00589906f, -0.05073136f, 0.03913811f, -0.10437156f, 0.10305680f, -0.02548836f, -0.09038322f, 0.08090983f, 
    -0.78195179f, -0.03574440f, 0.28639039f, 0.12884554f, -0.09133298f, -0.02944249f, -0.16997515f, -0.02478904f, 
    0.08633756f, -0.07785445f, -0.19864821f, -0.21314621f, -0.06444208f, -0.19101124f, -0.36142606f, 0.01361199f, 
    -0.00884967f, 0.16540641f, 0.31257206f, 0.05723561f, 0.05078658f, -0.09963777f, 0.20754476f, 0.02169910f, 
    -0.50105083f, -0.12936608f, -0.03152255f, 0.25543514f, -0.25037906f, -0.23194964f, -0.12736510f, 0.03984385f, 
    0.16389003f, -0.13661534f, -0.13512862f, -0.06232613f, -0.36899582f, -0.10700527f, 0.24592879f, -0.20931865f, 
    -0.08390485f, -0.04170521f, -0.04510621f, 0.08575110f, -0.02441118f, 0.09038424f, 0.04575447f, -0.05844420f, 
    -0.80894458f, 0.16630262f, 0.02676854f, 0.39460391f, 0.09846761f, -0.18316177f, 0.24099682f, 0.06178392f, 
    0.03725287f, 0.20147680f, 0.16745450f, 0.06958546f, 0.48436305f, -0.09087780f, -0.42471424f, 0.16221063f, 
    -0.04954702f, -0.04463372f, 0.11965398f, -0.19811608f, -0.26462489f, -0.17430940f, 0.02699936f, 0.34216911f, 
    -0.40998307f, -0.57395709f, -0.24462181f, -0.14220595f, 0.18179810f, 0.29267064f, -0.64515287f, -0.02912252f, 
    -0.07600079f, -0.25650963f, -0.20369318f, 0.08779804f, -0.01840362f, 0.17853180f, -0.35074878f, -0.10704623f, 
    0.00536305f, -0.21685863f, 0.12053733f, 0.05214056f, 0.03916926f, 0.05829908f, 0.19074529f, -0.16931608f, 
    -0.10314105f, 0.03953068f, -0.23787390f, 0.09778174f, -0.00293771f, 0.03695241f, 0.23428418f, 0.30757323f, 
    0.05680856f, -0.06861807f, -0.00469306f, 0.07883180f, 0.03908163f, -0.00914746f, 0.21679921f, -0.19376630f, 
    0.37789318f, -0.01811635f, 0.26657858f, 0.10910662f, -0.11109334f, 0.12227859f, 0.13089652f, 0.06848624f, 
    -0.24881174f, -0.20412791f, 0.10402773f, -0.18292585f, -0.02922661f, -0.11859112f, 0.21984677f, 0.03488583f, 
    -0.04207448f, -0.07362864f, 0.19534126f, 0.25972971f, 0.17129192f, -0.08712979f, 0.24714027f, 0.17579953f, 
    -0.13714233f, -0.11972678f, -0.21259087f, 0.16255143f, 0.24641255f, -0.11688173f, -0.04410996f, 0.17348571f, 
    -0.73890465f, -0.36121777f, -0.00418276f, -0.17676498f, 0.16009197f, -0.03742574f, -0.26612407f, 0.00184348f, 
    0.23316607f, 0.10841381f, -0.14584394f, 0.14040805f, 0.13908094f, -0.08917803f, 0.11839532f, 0.26373434f, 
    0.16881914f, -0.19105782f, -0.14282392f, 0.16199054f, 0.18582197f, 0.04649831f, -0.04242991f, -0.16931343f, 
    0.09874553f, 0.00033820f, 0.35341048f, -0.30812097f, 0.07132433f, -0.07493934f, 0.04512323f, -0.05678285f, 
    0.05688738f, 0.01009946f, 0.17457621f, 0.00589353f, -0.75176919f, 0.32283559f, 0.00826487f, -0.60909611f, 
    0.22861412f, -0.07862876f, 0.09404791f, -0.01720041f, -0.13206281f, 0.13377696f, -0.09886444f, -0.10470654f, 
    0.32510701f, -0.02701997f, 0.10304037f, 0.13209149f, -0.17002164f, -0.05714142f, 0.17679794f, 0.10197141f, 
    -0.18302940f, -0.04057215f, 0.13072555f, 0.44807932f, -0.06533790f, 0.11050034f, 0.16964786f, -0.41202244f, 
    0.06028202f, -0.20594160f, -0.42022613f, -0.00072988f, -0.12947322f, -0.02287323f, -0.08363669f, -0.06975307f, 
    0.25672671f, -0.01499885f, 0.16306525f, -0.34423590f, 0.13125697f, -0.04770798f, 0.05336558f, 0.11136614f, 
    -0.10404537f, 0.07456087f, 0.17236577f, 0.00594569f, 0.34377360f, -0.27137825f, -0.02543452f, -0.03412571f, 
    -0.11848049f, -0.00569948f, -0.13844202f, -0.23654778f, -0.07410938f, -0.06876615f, -0.23149435f, -0.00805794f, 
    -0.53065890f, -0.00655813f, -0.19438149f, -0.11636443f, -0.01667202f, 0.02495625f, -0.13837971f, -0.41154334f, 
    0.16764924f, -0.18637455f, -0.00869791f, -0.15162212f, -0.00823958f, -0.26920512f, 0.29221877f, 0.46695951f, 
    0.07985414f, -0.08990150f, 0.06991470f, -0.00030579f, -0.03405508f, 0.01765242f, -0.00640880f, 0.02167772f, 
    -0.01914732f, 0.50154746f, -0.21889415f, -0.17816326f, 0.13337089f, -0.01210886f, 0.35963503f, 0.11310668f, 
    -0.02805302f, 0.01729995f, -0.14600544f, -0.19506373f, -0.36476347f, 0.15794054f, 0.39233243f, 0.16052073f, 
    0.00631211f, 0.06795650f, 0.23939675f, 0.08800522f, 0.18065596f, 0.03105291f, -0.26180732f, 0.13781689f, 
    -0.74138516f, -0.12026035f, -0.13969822f, -0.43866327f, 0.17762104f, 0.15625149f, 0.01197220f, -0.05274886f, 
    0.07672603f, 0.00689919f, -0.01856170f, 0.12406187f, -0.19946425f, -0.02846791f, -0.08829732f, 0.06254682f, 
    0.05348346f, 0.17550248f, 0.15108742f, 0.20389710f, 0.01968735f, -0.28619951f, 0.09235260f, -0.29472828f, 
    0.02201444f, 0.01120615f, -0.24035929f, -0.14267835f, -0.09773286f, 0.07384490f, -0.22995356f, 0.03811831f, 
    -0.10864276f, -0.20410337f, -0.35173848f, -0.02995650f, -0.05187763f, -0.23549362f, 0.15090086f, 0.34864920f, 
    0.08762904f, -0.06073199f, 0.20654698f, -0.05314622f, -0.04652200f, 0.07339200f, -0.12193875f, -0.19122258f, 
    -0.50069565f, -0.04024375f, -0.14918916f, -0.00834643f, -0.06430672f, -0.09486750f, -0.08886631f, -0.09860647f, 
    0.01133822f, -0.15977651f, 0.23765832f, -0.42713439f, -0.17907274f, -0.21480514f, -0.12773557f, -0.28192559f, 
    0.11276836f, 0.16625483f, -0.17548260f, -0.24163784f, 0.19933452f, -0.19774698f, 0.29591820f, -0.07475171f, 
    -0.07905851f, 0.04653756f, 0.51322156f, -0.50608993f, -0.02737853f, -0.13065359f, 0.23408307f, 0.13051321f, 
    -0.00294260f, -0.10322766f, -0.28758690f, 0.10518696f, 0.76889777f, -0.42119956f, 0.18236832f, 0.00967408f, 
    -0.05190694f, 0.08199842f, 0.22549422f, -0.04608605f, 0.07821152f, -0.27259502f, 0.07972631f, -0.09919096f, 
    0.18577401f, 0.32944515f, 0.29472026f, -0.65457088f, 0.13046908f, 0.11207280f, -0.03780160f, 0.10197177f, 
    -0.04055190f, -0.05644159f, -0.23237982f, -0.00966395f, -0.07156488f, -0.22787778f, 0.05035612f, -0.25537226f, 
    -0.20398262f, 0.04312717f, 0.33347157f, 0.24109808f, -0.01732195f, -0.15730035f, -0.06051074f, 0.14955351f, 
    0.16624604f, 0.02394574f, 0.20548281f, -0.04729168f, 0.14282592f, -0.11476497f, -0.10466401f, 0.06481333f, 
    -0.02840461f, 0.16631100f, -0.26116893f, -0.04361855f, -1.21019495f, 0.40315476f, -0.00925311f, 0.40263724f, 
    0.03071386f, 0.10062635f, 0.17628001f, 0.13973816f, 0.24273489f, 0.02342147f, 0.29385373f, 0.11251335f, 
    0.23253287f, -0.69484472f, -0.29915902f, -0.03253998f, -0.10400072f, 0.15796462f, -0.00087989f, 0.07965653f, 
    -0.08143840f, 0.23846583f, -0.03166210f, 0.31864884f, 0.01667190f, -0.05136133f, 0.06760969f, 0.11810816f, 
    0.02957294f, -0.09270398f, 0.09979060f, -0.19367661f, 0.02844495f, 0.03126981f, -0.08086496f, -0.21524970f, 
    0.47135255f, -0.43994290f, 0.32456565f, -0.07962909f, -0.04906195f, 0.22801563f, -0.19215304f, -0.18253243f, 
    -0.00455713f, -0.03439498f, 0.20902681f, -0.03599679f, 0.33238241f, -0.52099824f, 0.24740300f, -0.16909137f, 
    -0.00864000f, -0.12071787f, 0.17897576f, 0.02919343f, -0.10740880f, -0.03239451f, 0.12044442f, 0.07832142f, 
    -0.30941170f, -0.14935611f, -0.11823530f, -0.67169124f, -0.10945546f, -0.02860141f, 0.01268964f, -0.20332399f, 
    0.07499941f, 0.04093704f, 0.06325708f, 0.02524042f, 0.45363343f, -0.29349583f, -0.03161528f, 0.30450380f, 
    -0.10453940f, 0.14755076f, 0.09393206f, 0.00882379f, 0.14192641f, 0.03320909f, 0.08067179f, 0.30272520f, 
    0.05869477f, 0.28467378f, -0.39688221f, 0.06592329f, -0.19174302f, -0.00821211f, -0.12397464f, -0.01304742f, 
    -0.15184073f, 0.12273235f, -0.24782002f, -0.11255357f, 0.35862035f, -0.61639202f, 0.13297430f, 0.10701140f, 
    -0.03731686f, -0.32376340f, -0.04099318f, -0.14612563f, -0.08930252f, -0.03544824f, -0.09402504f, -0.24010836f, 
    0.25880790f, 0.52636003f, 0.47795293f, 0.19919685f, 0.17009664f, 0.15331876f, 0.09928775f, -0.07019170f, 
    -0.07403798f, 0.09807909f, 0.00211399f, -0.21085353f, -0.24545868f, 0.28045991f, -0.15322411f, 0.15300681f, 
    -0.24603711f, 0.11646859f, -0.20837831f, -0.05192037f, -0.04058087f, -0.09000148f, -0.10137101f, -0.17684545f, 
    0.30060092f, -0.33163315f, 0.12908547f, -0.02016668f, -0.12787434f, 0.06022419f, 0.11905986f, -0.04606653f, 
    0.08407864f, 0.02108600f, -0.00918054f, 0.05500506f, 0.14430909f, -0.22221935f, 0.20464015f, -0.40623775f, 
    -0.16974883f, -0.00837047f, -0.00991489f, -0.02282363f, -0.05968250f, 0.16171791f, -0.11514287f, 0.14624584f, 
    -0.35597265f, -0.70281535f, -0.18982162f, 0.08205628f, -0.14826691f, -0.11141603f, -0.02209885f, -0.07002269f, 
    -0.16567174f, 0.03980016f, -0.16568895f, -0.14317435f, -0.03431176f, -0.00210079f, -0.33856443f, -0.11712254f, 
    -0.33429575f, 0.02128148f, -0.09801020f, -0.30130041f, -0.46923146f, 0.12202007f, -0.01459424f, -0.19662346f, 
    0.07920735f, -0.27212882f, -0.16958502f, -0.74027056f, -0.04427863f, 0.04294940f, -0.00275680f, -0.03656765f, 
    -0.07474031f, -0.16387597f, 0.05960873f, -0.05406494f, -0.60362220f, -0.21948415f, -0.03073173f, -0.11823630f, 
    -0.09717212f, 0.13133372f, -0.17694643f, 0.03006053f, -0.17820522f, -0.11804157f, -0.11220693f, -0.13361928f, 
    -0.02194022f, 0.41182685f, 0.23262283f, 0.11966088f, 0.13187894f, -0.01623145f, 0.06476573f, 0.01610771f, 
    -0.03125725f, 0.06092233f, -0.00036843f, -0.01253265f, 0.59152746f, 0.35267586f, -0.04954383f, 0.61026788f, 
    0.36193228f, 0.03807352f, 0.01718786f, -0.11594660f, -0.08809421f, 0.09216185f, -0.01398294f, -0.22050680f, 
    0.06071801f, 0.18506816f, 0.16033013f, 0.19988453f, 0.16416897f, -0.05712352f, 0.08991233f, 0.10424915f, 
    -0.16962016f, 0.02601227f, 0.29094595f, -0.04035527f, -0.31261975f, -0.00166144f, -0.15181698f, -0.27176800f, 
    -0.16637568f, 0.01688617f, -0.05061474f, -0.11241687f, -0.07730714f, -0.03957101f, -0.02248553f, -0.10798422f, 
    0.43922889f, 0.05233208f, 0.47420904f, 0.14169319f, 0.19243561f, 0.13625415f, -0.04772007f, 0.04327679f, 
    -0.09484817f, 0.07473975f, -0.21434866f, -0.04296555f, 0.09938069f, 0.11858889f, -0.02860409f, 0.29397035f, 
    -0.08396435f, -0.17725702f, -0.06247633f, -0.09138865f, -0.04819445f, 0.11698928f, -0.09393565f, -0.00591895f, 
    -0.19338720f, 0.27830878f, -0.07757960f, -0.38385358f, -0.15018752f, 0.01293305f, -0.17320409f, -0.15523711f, 
    0.11822108f, -0.16080651f, 0.14891569f, 0.29248440f, -0.10916222f, 0.13226169f, -0.20152989f, -0.56477314f, 
    -0.07133022f, -0.08567607f, -0.06598015f, -0.31760851f, 0.14596567f, -0.07985053f, -0.10362930f, 0.46574929f, 
    0.09872510f, 0.41559407f, 0.08794740f, 0.00993935f, -0.10275254f, 0.14966868f, -0.06193213f, 0.11697573f, 
    0.05617557f, 0.10814856f, -0.04851690f, 0.26555166f, -0.32282653f, 0.40702164f, -0.08735722f, -0.44385746f, 
    -0.22787380f, 0.10086243f, 0.05438549f, 0.11304760f, 0.37172231f, 0.15464483f, -0.26828822f, 0.16462213f, 
    0.30067039f, -0.17526139f, -0.04616934f, 0.32309464f, 0.14679524f, -0.15875491f, 0.01189683f, -0.17757575f, 
    -0.07548442f, 0.16934955f, 0.20612669f, -0.06538542f, -0.23073424f, 0.00601316f, 0.00564039f, 0.15299836f, 
    -0.08415993f, -0.10630220f, 0.02671887f, -0.00243891f, 0.13919643f, 0.11590053f, -0.04278781f, 0.02854802f, 
    -0.38350108f, -0.30366701f, -0.35492459f, 0.18416092f, 0.27959704f, -0.01381164f, 0.01329412f, -0.10285701f, 
    0.08916954f, -0.02656244f, 0.19227810f, 0.00888448f, 0.13031471f, 0.37829861f, 0.08516967f, 0.23700149f, 
    -0.10917223f, -0.18469481f, -0.22881241f, -0.06864497f, 0.17736126f, 0.10097525f, 0.01053122f, -0.09300892f, 
    0.47690961f, -0.18400535f, -0.16018678f, 0.20840096f, 0.03715860f, -0.01407052f, -0.07984520f, 0.07469463f, 
    0.18658048f, 0.07968872f, 0.32568032f, -0.46376970f, 0.39849681f, 0.03347487f, -0.18302442f, 0.16103972f, 
    0.16561279f, -0.10069471f, -0.22081047f, -0.19035065f, -0.02518141f, -0.09986545f, -0.41670030f, 0.13621801f, 
    0.17760563f, 0.04083194f, 0.22470655f, 0.16030714f, -0.14811881f, -0.18216419f, -0.14591235f, 0.04245628f, 
    -0.08866077f, -0.17333040f, -0.01303559f, -0.09773889f, -0.52784479f, 0.24750140f, 0.00111755f, -0.47681829f, 
    0.14867857f, -0.17203306f, -0.22222695f, 0.29737562f, -0.10949932f, 0.10367131f, 0.12162921f, -0.51139361f, 
    0.12433342f, -0.34324369f, 0.12972444f, -0.39003840f, -0.30703634f, -0.44409913f, 0.37491506f, -0.19790104f, 
    0.07765400f, 0.05238783f, -0.61433470f, 0.24182916f, 0.30381423f, 0.09112903f, 0.03867500f, 0.26119882f, 
    -0.08427254f, -0.09721711f, -0.01629388f, -0.10423897f, 0.18092541f, -0.22434561f, 0.03112486f, 0.23048803f, 
    -0.65718538f, -0.29224941f, 0.30203202f, -0.34898770f, -0.31748351f, 0.09490235f, 0.14938368f, -0.23815016f, 
    0.01206447f, 0.03815186f, 0.11860000f, 0.01706452f, 0.20674041f, -0.05636780f, -0.46369255f, -0.33856559f, 
    0.00322386f, -0.13972236f, 0.10601534f, -0.03649952f, 0.26827723f, -0.42035115f, -0.17371240f, -0.56734627f, 
    -0.44122177f, 0.74436724f, -0.00593350f, -0.14975516f, 0.13498773f, -0.07831430f, -0.00942956f, -0.20330371f, 
    0.09302977f, 0.06899562f, -0.23467553f, -0.24764504f, 0.28833285f, -0.38309199f, -0.06029479f, -0.01109265f, 
    -0.11106380f, 0.11085616f, -0.07567480f, -0.05470427f, 0.02169988f, -0.14509380f, 0.21215762f, -0.23332249f, 
    -0.47044528f, -0.23651041f, -0.04356898f, 0.00886824f, 0.06027858f, -0.13499515f, -0.33684689f, 0.17512062f, 
    -0.19672921f, -0.06058304f, 0.09112380f, -0.07654774f, -0.68142539f, 0.41460350f, -0.10970736f, 0.37681499f, 
    -0.08041820f, 0.20484190f, -0.06448823f, -0.04610779f, -0.26730978f, -0.17293485f, 0.10739712f, 0.11234902f, 
    -0.16870253f, -0.46221814f, -0.13385092f, 0.41118103f, 0.04498607f, -0.00791211f, 0.19096856f, -0.24638274f, 
    -0.02885614f, -0.01484519f, -0.15775253f, -0.04545947f, -0.06061494f, -0.45700669f, 0.10158288f, 0.22942142f, 
    0.09959079f, 0.10327710f, -0.13057840f, -0.04268559f, 0.07425161f, 0.01995350f, 0.09069347f, 0.00974220f, 
    -0.38432714f, 0.27458262f, 0.06466766f, -1.04094291f, -0.04869007f, -0.04170281f, -0.16512972f, -0.01032954f, 
    -0.02303040f, -0.02399519f, 0.06013047f, -0.17752658f, -0.27800369f, 0.74425930f, -0.26989332f, 0.27188656f, 
    -0.06539343f, 0.00118381f, 0.25753450f, 0.01586235f, -0.11331859f, 0.18342240f, 0.19982858f, 0.11690436f, 
    0.20776528f, -0.15687059f, 0.20167862f, -0.13781956f, -0.05169119f, 0.21054232f, 0.08263629f, -0.02981503f, 
    -0.13341603f, -0.06616671f, -0.23775764f, 0.18264374f, 0.12677422f, 0.16522151f, 0.40391618f, 0.10443495f, 
    0.18547669f, 0.07785407f, -0.08926649f, -0.01996782f, 0.00449027f, 0.05258041f, -0.03194052f, -0.08480851f, 
    -0.20884743f, -0.52994847f, 0.22844116f, 0.14737155f, 0.23895486f, 0.04728567f, -0.02808366f, 0.23998713f, 
    0.14440647f, 0.02792560f, 0.00299945f, 0.06476513f, -0.14067878f, -0.38256389f, -0.23294303f, -0.22657655f, 
    -0.26414818f, 0.05405553f, -0.21402408f, 0.37837407f, 0.08727993f, -0.01267731f, -0.07046987f, 0.11437058f, 
    0.24267223f, 0.52589995f, -0.35691118f, 0.31723961f, 0.15907207f, -0.17673612f, -0.01999078f, -0.03108147f, 
    -0.07591373f, 0.22176100f, 0.15295489f, 0.01752271f, 0.36494908f, 0.42262751f, -0.75847793f, -0.63405347f, 
    0.28601804f, 0.01759135f, -0.21533197f, -0.00469991f, -0.07073639f, -0.20349376f, 0.04844503f, 0.19642638f, 
    0.34416389f, 0.04167418f, -0.63020396f, 0.45074072f, -0.01269762f, -0.00012616f, -0.03513088f, 0.06839593f, 
    -0.11182725f, 0.07093970f, -0.11227991f, -0.10579658f, -0.66685730f, 0.23186827f, 0.30546680f, 0.08387580f, 
    0.02862786f, -0.07524729f, -0.32319397f, -0.05476170f, -0.10789531f, 0.17955989f, 0.09922699f, 0.07758105f, 
    0.14014681f, -0.32664818f, -0.12414874f, -0.05215792f, 0.27310413f, 0.17455021f, -0.04804217f, 0.16541475f, 
    0.18668266f, 0.15588672f, 0.37574738f, 0.12146106f, 0.28335038f, 0.46589261f, 0.11980426f, 0.09855682f, 
    0.06125606f, 0.48371670f, 0.01639182f, -0.01588093f, 0.11676881f, 0.22481191f, 0.19410275f, 0.24225943f, 
    0.24627595f, 0.06208556f, 0.06709386f, -0.24597275f, -0.03439179f, 0.12446728f, 0.13448805f, -0.09713504f, 
    0.20405467f, 0.04026059f, -0.12807953f, -0.04698003f, -0.19353339f, -0.59018791f, 0.06775477f, 0.23713845f, 
    -0.00659697f, 0.07113605f, 0.22979526f, -0.09054090f, 0.13685247f, 0.06580057f, -0.07471804f, 0.11172845f, 
    -0.71763533f, -0.27287313f, -0.19484097f, -0.51067793f, -0.01861404f, 0.04507640f, -0.24547288f, 0.14809144f, 
    -0.04292166f, 0.01148256f, 0.07611394f, -0.23929772f, 0.43575767f, -0.00271655f, -0.14561002f, 0.15723836f, 
    0.06811129f, -0.03081562f, -0.10568047f, 0.10443797f, -0.15690742f, -0.12142076f, -0.03741733f, 0.07254759f, 
    -0.11370225f, 0.16527009f, -0.05518326f, -0.45473224f, 0.13191426f, 0.11880034f, 0.06145434f, 0.12227955f, 
    0.11128241f, 0.01166495f, 0.02592502f, 0.20618761f, -0.17500325f, -0.40483388f, 0.03790469f, -0.06347082f, 
    -0.06504270f, -0.10249480f, -0.24186653f, -0.11529446f, 0.03053479f, -0.21179326f, -0.24407224f, -0.22927397f, 
    -1.33885705f, -0.37103984f, -0.16933118f, 0.13253106f, 0.26846439f, 0.23182562f, 0.05870682f, 0.10370998f, 
    0.08246009f, 0.16029763f, 0.17515695f, 0.18599729f, -1.50166082f, -0.96995127f, -0.22952716f, 0.03701857f, 
    0.02789247f, 0.15203625f, 0.07387362f, -0.22357954f, 0.18345381f, -0.01615016f, -0.33667612f, 0.05572524f, 
    0.49261096f, 0.29061019f, -0.30513129f, 0.03953025f, -0.51157624f, -0.20443104f, 0.13410942f, -0.08473703f, 
    -0.04983702f, -0.30454835f, 0.00130340f, -0.38498801f, 0.01782163f, -0.20065486f, -0.05214384f, -0.34171411f, 
    0.13221191f, 0.16408767f, 0.06640977f, -0.13486406f, -0.22174437f, 0.02768719f, -0.27738917f, -0.22584175f, 
    -0.09866989f, 0.02403814f, 0.25573477f, 0.20152113f, -0.13803037f, -0.12574877f, 0.06010558f, 0.06189349f, 
    0.21085931f, 0.16860637f, -0.20110315f, 0.25307760f, 0.05828455f, 0.14135019f, -0.10761666f, -0.37668213f, 
    0.08022654f, -0.29190823f, -0.01817416f, 0.31247884f, -0.07631837f, -0.02555835f, -0.07802626f, 0.06894489f, 
    0.08624285f, 0.16863182f, 0.17893237f, -0.14087345f, 0.03170122f, 0.31607348f, 0.13898183f, 0.17272934f, 
    -0.16337287f, -0.02569926f, 0.07295465f, -0.28062239f, -0.36841196f, 0.08054917f, 0.11993601f, 0.05651816f, 
    -0.01031335f, -0.16773254f, 0.10996304f, -0.13587821f, 0.27196905f, -0.11961067f, -0.21217872f, -0.31965703f, 
    0.00557872f, 0.11894052f, -0.32736972f, 0.05146263f, 0.36951551f, -0.18388867f, 0.01556570f, -0.02761220f, 
    0.16586186f, 0.21884291f, -0.30258188f, -0.00879341f, 0.03795274f, 0.41332027f, -0.39983451f, 0.04126785f, 
    -0.38207594f, 0.05000674f, 0.07186841f, -0.13560718f, -0.16586454f, -0.13198210f, 0.03189963f, -0.11060541f, 
    0.19658680f, 0.37287575f, 0.04404309f, 0.16743685f, 0.34865469f, -0.21550168f, 0.08508938f, -0.03331614f, 
    -0.15961693f, 0.02867659f, -0.10175563f, -0.15153994f, -0.20519513f, 0.41180536f, -0.09218663f, 0.24649960f, 
    0.28337651f, -0.31414342f, -0.08087756f, -0.02301018f, 0.23208106f, -0.00977786f, 0.03986890f, -0.05727788f, 
    -0.78738350f, 0.03994939f, -0.05063337f, -0.46871635f, 0.14368325f, 0.05162533f, -0.06541649f, 0.05242234f, 
    0.14869000f, -0.21739009f, -0.32556626f, -0.13174407f, -0.41942134f, 0.30079997f, -0.08410969f, -0.18058571f, 
    0.23322162f, -0.21542911f, 0.08121399f, 0.25112084f, -0.11739964f, -0.16009729f, 0.20599681f, -0.04627102f, 
    0.70012063f, -0.12560296f, -0.80793160f, 0.25111973f, -0.10811739f, -0.17290929f, -0.00875857f, 0.13204783f, 
    -0.09078931f, -0.03171796f, 0.21184479f, 0.05191345f, -0.10761495f, -0.75156158f, -0.00935605f, 0.14847513f, 
    0.13176259f, 0.16399123f, 0.32031423f, -0.04903121f, 0.04268140f, 0.27589190f, 0.06473995f, -0.00829790f, 
    0.22760645f, -0.06077809f, -0.34915310f, -0.08104626f, -0.01523946f, -0.13313192f, -0.14292513f, 0.09025337f, 
    -0.03780827f, -0.05589668f, -0.04837342f, 0.09488842f, 0.42168769f, 0.11353908f, -0.05215110f, 0.05033985f, 
    0.08643055f, 0.08035491f, -0.04371431f, 0.17398074f, 0.19063357f, -0.01236842f, 0.01748744f, 0.02452698f, 
    -0.15458632f, -0.55272627f, -0.10134044f, 0.10106505f, -0.02682430f, 0.15829323f, -0.04232431f, 0.17757170f, 
    -0.23869844f, -0.04581307f, -0.10204269f, -0.10326290f, 0.24513459f, -0.01789991f, -0.19936097f, 0.30699840f, 
    0.14631109f, 0.25294861f, 0.08308040f, -0.17048526f, 0.09346457f, 0.17499143f, 0.13337247f, 0.05116034f, 
    -0.05506150f, -0.26191497f, 0.43395346f, -0.25910136f, 0.02544129f, -0.27950588f, -0.05149976f, 0.00717673f, 
    -0.14556095f, 0.12644786f, 0.02451827f, -0.27972248f, 0.08407561f, -0.67479980f, 0.16514502f, -0.20112970f, 
    -0.05617953f, 0.11333507f, -0.02789027f, -0.10130749f, -0.25109872f, 0.12106011f, -0.02271363f, 0.09281246f, 
    -0.18615361f, 0.38899839f, 0.14018005f, -0.21462737f, -0.21166447f, -0.17715070f, -0.10680819f, -0.34322554f, 
    0.01576947f, 0.00835742f, 0.12841776f, -0.10142486f, -0.21137732f, -0.18593653f, -0.19674549f, 0.14059918f, 
    -0.06511525f, 0.28885949f, -0.10705476f, -0.38653982f, 0.19366050f, -0.07753277f, -0.00237324f, 0.12349285f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21397673f, -0.03020396f, -0.05613340f, 0.05918335f, 0.09301934f, -0.02294843f, -0.03433607f, -0.22635956f, 
    -0.05716431f, -0.00546787f, 0.19251762f, 0.09584617f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
