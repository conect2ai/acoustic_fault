#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.11008535f, 0.02806449f, 0.03260539f, 0.08405510f, 0.38774672f, 0.47545132f, 0.48776472f, -0.42352474f, 
    -0.21213567f, 0.36749840f, -0.07296868f, -0.12121525f, -0.38721892f, -0.58955610f, 0.27249661f, 0.08715964f, 
    -0.11298929f, 0.18662639f, 0.19733395f, -0.04775880f, 0.12830429f, -0.29127723f, -0.31839743f, -0.13680764f, 
    -0.25859129f, 0.62442535f, -0.53322375f, 0.03767278f, -0.05670718f, -0.19790414f, -0.10059481f, -0.28553414f, 
    -0.24073863f, 0.04142650f, 0.45336735f, 0.44270909f, 0.41830882f, 0.32893488f, 0.44590056f, -0.14724748f, 
    -0.59879279f, -0.36637464f, 0.17772935f, 0.13725360f, 0.20006187f, 0.56441128f, -0.71879894f, -0.48737228f, 
    0.56029010f, 0.09997984f, 0.19656275f, 0.00972662f, -0.00848297f, -0.14968476f, 0.43743956f, 0.36988965f, 
    0.11753546f, 0.20280968f, -0.33321053f, 0.20426066f, -0.00622386f, 0.15470020f, -0.47807023f, 0.27566794f, 
    0.70496523f, -0.61387634f, 0.07060096f, 0.18613312f, 0.06749542f, 0.29488471f, 0.06770600f, 0.28149799f, 
    -0.36329490f, 0.47737330f, -0.34106147f, -0.50778461f, -0.22058092f, 0.43840873f, -0.28244832f, -0.23601505f, 
    -0.39877036f, -0.29912174f, -0.04769792f, 0.20740218f, 0.03341215f, -0.55179173f, -0.65367377f, 0.32091981f, 
    0.26348889f, 0.18383557f, -0.20438530f, -0.32034409f, -0.30654365f, 0.46415681f, 0.20863709f, 0.41805965f, 
    -0.37069517f, -0.22111835f, -0.20837924f, -0.59529674f, -0.39919317f, 0.55810028f, -0.20830870f, -0.04382805f, 
    -0.20718066f, -0.23858595f, -0.36048922f, 0.18868911f, -0.37307280f, 0.20907937f, 0.09700868f, 0.36255875f, 
    0.01754355f, 0.26835445f, 0.02676309f, -0.52184618f, 0.54312819f, 0.60215956f, -0.65792668f, -0.35875180f, 
    -0.44274360f, -0.41364670f, -0.21311411f, -0.10067282f, -0.27261645f, -0.16592515f, 0.67216283f, -0.37998655f, 
    0.48837012f, -0.16140364f, 0.00529181f, -0.02888322f, 0.50617015f, -0.14543201f, -0.20285127f, -0.51389545f, 
    -0.06773297f, -0.66989702f, 0.47591802f, 0.49392590f, 0.45814157f, 0.28140095f, 0.42772612f, 0.21705638f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07596079f, -0.01659179f, -0.09251552f, 0.02116377f, 0.11777192f, 0.10605985f, 0.18041857f, 0.32244411f, 
    0.00873201f, -0.10434933f, 0.01383094f, -0.25691268f, -0.11860076f, -0.25696701f, 0.09726029f, -0.23421393f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.14065523f, 0.06412295f, 0.11928671f, -0.06915449f, 0.02767140f, -0.09924113f, -0.14523210f, -0.11622834f, 
    -0.06873034f, 0.08894020f, -0.01911115f, -0.02062446f, 0.02347180f, 0.17235215f, 0.19635679f, 0.23257004f, 
    -0.00553408f, 0.04404795f, 0.04202142f, -0.18328831f, -0.21594824f, 0.02508203f, 0.07791631f, 0.03716193f, 
    -0.11235613f, 0.04701714f, 0.06684896f, 0.04422257f, -0.16116816f, -0.15372895f, -0.07903665f, -0.13258770f, 
    0.02204214f, 0.13861465f, 0.12669885f, 0.26903957f, -0.06395318f, -0.18099618f, -0.00093536f, 0.08074554f, 
    0.09466234f, 0.23459762f, 0.05466348f, 0.05924335f, 0.22993109f, -0.20930441f, 0.15561071f, 0.08604722f, 
    -0.11579198f, 0.05043157f, -0.02091197f, 0.01353203f, -0.02505685f, -0.15861700f, -0.24735065f, -0.01462674f, 
    0.10445517f, 0.09088384f, 0.14060356f, 0.01133092f, 0.02593831f, 0.03843140f, 0.07148731f, 0.15237181f, 
    0.17855419f, 0.16724275f, 0.06424136f, 0.11995657f, 0.09674469f, -0.05410511f, 0.07404089f, 0.13881803f, 
    -0.05638920f, 0.06630848f, -0.29472736f, -0.02741907f, -0.07283503f, 0.03473939f, -0.14196680f, -0.09403311f, 
    -0.05761677f, 0.02606757f, 0.16190988f, 0.06646609f, -0.03204018f, -0.08193826f, -0.07336921f, 0.05209365f, 
    0.13296610f, 0.00102232f, 0.10555801f, 0.07054099f, -0.23281248f, -0.05716646f, -0.13340877f, -0.13469903f, 
    -0.18417358f, -0.10916246f, -0.14071913f, -0.05974170f, 0.03011581f, 0.03496275f, 0.13584957f, 0.16029139f, 
    0.15311986f, -0.03435340f, 0.02526374f, -0.17740251f, -0.02414031f, 0.01049435f, 0.04703946f, 0.02041383f, 
    -0.03565086f, 0.11156931f, 0.19488113f, 0.04161380f, 0.03667487f, 0.02535651f, -0.02763626f, -0.12360256f, 
    0.03059426f, 0.02849098f, -0.06658809f, -0.00958494f, 0.06780392f, -0.09991536f, -0.06278481f, 0.01928025f, 
    0.06105480f, -0.04190909f, 0.21237260f, 0.09015859f, -0.01585375f, 0.19027798f, 0.25419983f, -0.13839252f, 
    0.00311771f, -0.19353902f, 0.02363610f, 0.07794125f, -0.07580152f, -0.10121471f, -0.12970205f, 0.04477658f, 
    0.11616910f, 0.26599765f, 0.17067899f, -0.22078048f, -0.11428121f, 0.09229337f, -0.09046213f, -0.07917590f, 
    -0.01452770f, 0.22108182f, -0.46078134f, -0.37977764f, 0.01685016f, 0.00078103f, 0.06865266f, 0.00321549f, 
    0.07803315f, -0.06125319f, -0.07650814f, -0.05205196f, -0.23158041f, 0.13500765f, -0.05408230f, 0.03322597f, 
    0.04821923f, 0.06008183f, -0.04925992f, -0.01040574f, 0.02193139f, -0.13608685f, -0.03712239f, 0.16755022f, 
    0.06034917f, -0.05663616f, -0.08080428f, 0.07653593f, -0.04275002f, -0.07582169f, 0.17310746f, 0.05979331f, 
    0.07329851f, 0.07913217f, 0.05258388f, -0.03659654f, 0.07854166f, -0.12843715f, -0.59255075f, -0.09790742f, 
    -0.15933782f, 0.01774844f, 0.07906611f, 0.04145667f, 0.02860369f, -0.12787229f, 0.03869287f, 0.13320024f, 
    0.12211896f, 0.06600910f, 0.06415898f, -0.08496863f, -0.01828403f, 0.08290737f, 0.06909738f, 0.21477617f, 
    0.01963488f, 0.03238734f, -0.05165884f, -0.10934557f, 0.19789107f, 0.11010005f, 0.03923430f, -0.09192903f, 
    -0.08443414f, 0.01275905f, -0.38061193f, -0.07095195f, -0.26200834f, 0.05666296f, 0.00645980f, 0.05227410f, 
    -0.02551275f, -0.13732187f, 0.22448057f, 0.21339780f, -0.05401049f, 0.08183685f, -0.10282555f, -0.00772374f, 
    0.06582004f, 0.19833341f, 0.15956080f, -0.00195004f, -0.15532058f, 0.02813563f, -0.05774804f, 0.05478394f, 
    -0.10510474f, -0.06994978f, -0.04964074f, -0.01710639f, 0.25460646f, 0.11000957f, 0.12261064f, -0.01830343f, 
    -0.07791230f, 0.11292785f, 0.10181955f, -0.05754937f, 0.05925491f, 0.38106436f, 0.24668084f, -0.28029674f, 
    0.00582167f, -0.05416809f, 0.02940375f, -0.02106362f, -0.04982642f, -0.11464874f, -0.12263884f, 0.14243722f, 
    -0.19998717f, 0.08310295f, 0.09986674f, 0.13547373f, -0.04606644f, -0.12780800f, 0.17092362f, -0.33361438f, 
    0.01801134f, 0.03659860f, 0.05966825f, 0.02298555f, -0.12576100f, 0.03384501f, -0.04655052f, 0.30797684f, 
    0.19113258f, -0.57021284f, 0.06096635f, -0.09111980f, -0.00341191f, 0.19679295f, 0.02928046f, -0.01536653f, 
    0.05915440f, 0.03634633f, -0.06386936f, -0.08177589f, 0.06991419f, -0.05268039f, -0.05170722f, 0.04632817f, 
    -0.03123765f, 0.02780071f, 0.00912215f, -0.00760611f, -0.02328117f, 0.01377759f, -0.07143360f, 0.03301455f, 
    0.01075312f, -0.08547369f, -0.05978136f, 0.05632162f, 0.05871016f, 0.02314948f, 0.06466711f, -0.08967962f, 
    -0.02214957f, -0.06061783f, -0.04351054f, 0.05014231f, 0.01538818f, 0.02993971f, 0.02623335f, -0.06438673f, 
    0.01300824f, 0.03963610f, -0.03832434f, 0.06442177f, -0.07649069f, 0.00557468f, -0.03711754f, -0.05139825f, 
    -0.02030572f, -0.03643099f, 0.01122835f, -0.04517685f, -0.06318848f, -0.00758188f, -0.07925729f, -0.07148843f, 
    -0.04966816f, -0.05133438f, -0.02353320f, -0.06634002f, -0.08095821f, -0.01634431f, 0.04532430f, 0.07245747f, 
    0.04906428f, -0.08949766f, -0.07468826f, -0.04819831f, 0.05799946f, -0.08303520f, 0.02926010f, -0.01884361f, 
    0.03264874f, -0.08687013f, -0.05023024f, 0.00290659f, 0.00291173f, 0.02914173f, -0.06376316f, -0.03744381f, 
    -0.04649968f, -0.00206393f, 0.00663801f, 0.00929153f, 0.05441638f, -0.02613973f, -0.07053321f, -0.06925259f, 
    -0.04563845f, -0.06492683f, 0.02455454f, -0.01662117f, 0.01824371f, -0.06765097f, 0.03170208f, -0.01040054f, 
    0.01090947f, -0.08309356f, 0.05830374f, 0.04768451f, 0.07096950f, 0.06972664f, 0.04674995f, -0.08551288f, 
    -0.08568463f, 0.00951573f, 0.05074796f, -0.06373987f, 0.05357509f, -0.01346503f, -0.08831517f, 0.03586226f, 
    0.05851077f, 0.01079346f, 0.01366309f, -0.02861824f, -0.05184490f, -0.01929341f, -0.07026874f, 0.00770659f, 
    0.08121882f, -0.03786842f, -0.07842334f, -0.05822696f, -0.04932933f, -0.04200235f, 0.05881325f, 0.04951335f, 
    0.03990857f, -0.00028237f, -0.04832061f, 0.00050753f, -0.06509050f, -0.08228392f, 0.05504134f, 0.03159133f, 
    -0.07102460f, -0.03225267f, -0.00112932f, 0.03964632f, -0.03502140f, -0.05873719f, 0.02748154f, 0.05241079f, 
    -0.06901750f, -0.00820414f, 0.06250610f, -0.01060137f, -0.04234516f, -0.05520054f, 0.06019742f, 0.00218798f, 
    -0.04658609f, -0.02587181f, 0.22860253f, 0.01549977f, 0.01259013f, -0.13894340f, -0.00779403f, 0.00818237f, 
    0.18675621f, -0.28999925f, -0.12935103f, -0.47209135f, 0.03960034f, 0.11103404f, 0.07851007f, -0.04469559f, 
    0.05464240f, -0.11495521f, -0.15348519f, -0.26993245f, -0.04910308f, 0.00749200f, -0.23789442f, 0.05745925f, 
    -0.03500713f, -0.04990359f, 0.06504537f, 0.03121217f, 0.19410631f, 0.03126220f, 0.02762642f, -0.02600065f, 
    0.04630923f, -0.04260273f, -0.10466284f, -0.03892666f, 0.28617668f, 0.16713254f, -0.30697238f, -0.01351836f, 
    -0.00085472f, 0.02773303f, -0.05676697f, 0.02449764f, 0.05902104f, 0.45290411f, -0.04655276f, -0.16397160f, 
    0.02081428f, -0.07972270f, -0.02472510f, -0.10776170f, -0.07284362f, 0.05403783f, 0.30574128f, -0.24945207f, 
    -0.09693559f, -0.05147206f, 0.21088287f, 0.03860511f, 0.24999966f, 0.08986083f, 0.05366836f, -0.00838090f, 
    0.16411199f, 0.08817553f, 0.01422874f, 0.10170809f, 0.26780653f, 0.12025642f, -0.03239973f, -0.20692161f, 
    -0.30224544f, -0.25503770f, -0.09075471f, 0.04942063f, 0.13076654f, 0.17395319f, 0.06151824f, 0.14570844f, 
    0.02848043f, 0.32079750f, -0.02705874f, -0.15837088f, -0.29103056f, -0.09768203f, -0.20553274f, 0.06380017f, 
    -0.16719384f, -0.13780227f, -0.01005553f, 0.23596700f, 0.27624577f, 0.01755578f, -0.14028543f, -0.12048193f, 
    0.11125325f, 0.02460583f, 0.03427501f, -0.47243589f, -0.12450069f, -0.32569191f, -0.14309458f, -0.05244974f, 
    0.11995235f, -0.07391882f, 0.09611358f, 0.13427681f, -0.10181895f, 0.03252665f, 0.21957453f, -0.23804624f, 
    0.02773162f, -0.10654854f, -0.01492507f, -0.14660536f, -0.22402446f, -0.01144602f, -0.36619800f, 0.04024663f, 
    0.05395900f, -0.12653989f, -0.18745472f, 0.07080349f, -0.01536669f, 0.03537006f, -0.09186442f, -0.30780885f, 
    -0.30338392f, 0.06142588f, 0.07904010f, 0.07422396f, 0.02269944f, 0.12383207f, 0.02931191f, -0.20114796f, 
    0.09848789f, 0.24861315f, 0.03194349f, 0.10670184f, -0.15780891f, 0.13297710f, 0.10234226f, -0.04700290f, 
    0.01282240f, -0.08660721f, 0.14236087f, 0.05199005f, 0.10724688f, 0.02497761f, 0.24988472f, 0.00481851f, 
    0.21966521f, -0.01025730f, 0.09120788f, 0.10919018f, -0.01811233f, 0.08824416f, -0.03508111f, -0.07471480f, 
    0.01260202f, -0.06849948f, -0.01782216f, 0.19397523f, 0.30191946f, -0.01135608f, -0.15984252f, 0.23486207f, 
    0.00796431f, 0.07227883f, 0.01825894f, 0.03401986f, 0.16798776f, 0.19622396f, 0.19764522f, 0.13704295f, 
    0.10958084f, 0.21924073f, -0.20375010f, -0.33390126f, 0.08673158f, 0.08300898f, -0.23720461f, -0.23180830f, 
    -0.05895139f, -0.09274380f, -0.05564739f, -0.11171449f, -0.18778563f, -0.11841609f, -0.06717000f, 0.38645464f, 
    -0.04283456f, -0.06262287f, 0.16702163f, -0.01607240f, 0.06414557f, 0.14428784f, 0.15906453f, 0.08330198f, 
    -0.15374847f, -0.14271100f, -0.03880503f, 0.27972737f, 0.12098161f, 0.01313378f, 0.06220229f, 0.00787409f, 
    -0.07401963f, -0.05792870f, -0.10770330f, 0.01901426f, 0.01987520f, 0.03767921f, 0.09337508f, -0.03079880f, 
    -0.00415008f, -0.04953647f, 0.07494260f, -0.11173625f, -0.12958626f, 0.05910474f, 0.03859046f, 0.06174897f, 
    0.16863973f, -0.02519565f, -0.07824273f, -0.19834934f, 0.24154669f, 0.08178448f, -0.05761592f, -0.09216900f, 
    -0.12008929f, -0.18723418f, -0.10306188f, -0.06327423f, -0.01614184f, -0.11564286f, -0.06183214f, -0.01144440f, 
    -0.16542791f, 0.13511449f, 0.10010008f, 0.18918179f, 0.03971453f, -0.20122886f, -0.08674313f, -0.24840851f, 
    -0.05873395f, 0.05259841f, 0.25356194f, -0.09657548f, -0.19836159f, 0.02797191f, -0.07885627f, 0.11770864f, 
    0.21388021f, 0.15986499f, 0.17646933f, 0.07161889f, -0.23873171f, -0.17026524f, 0.23639254f, 0.14106679f, 
    0.14092986f, 0.10816450f, -0.03593949f, 0.09494195f, -0.10680357f, 0.26459968f, 0.10699052f, -0.15303886f, 
    -0.09518664f, 0.24968760f, 0.04193911f, 0.08162339f, 0.16202773f, -0.00843777f, -0.15777205f, 0.14956401f, 
    0.01731260f, 0.15956837f, 0.00702523f, 0.01872266f, -0.05895792f, -0.16825223f, 0.16286774f, -0.20118181f, 
    -0.10663351f, -0.09946566f, 0.09959604f, -0.15588525f, -0.15282239f, -0.04197539f, 0.07591348f, 0.09683081f, 
    0.04881069f, 0.09701101f, -0.20792998f, 0.20037825f, -0.07785296f, -0.08423340f, 0.04762777f, 0.13932261f, 
    0.14450058f, -0.16788346f, -0.15541705f, 0.10940779f, 0.08794820f, 0.00740160f, -0.00098738f, -0.02604529f, 
    -0.19085474f, -0.11049125f, 0.14443837f, -0.03381821f, 0.27795944f, -0.09373986f, 0.04336210f, -0.06894194f, 
    0.05951152f, 0.03584015f, -0.01959172f, 0.08039682f, 0.25417757f, -0.29529375f, -0.17992151f, -0.02700364f, 
    -0.09909359f, -0.02748947f, 0.04638245f, 0.03363630f, 0.05926083f, 0.03478225f, -0.22405152f, -0.05844334f, 
    -0.02880336f, 0.05277199f, 0.06268863f, 0.02443425f, -0.00443557f, -0.03235530f, 0.10981672f, -0.11025783f, 
    -0.03339961f, -0.05567884f, -0.04004862f, -0.14680542f, 0.04508380f, 0.08950913f, 0.08564561f, 0.35276690f, 
    -0.09737702f, -0.02927971f, -0.04846407f, -0.02448159f, 0.05498257f, 0.04715494f, 0.05392101f, 0.14905068f, 
    -0.01640561f, 0.15358980f, -0.06695098f, 0.02811544f, -0.08013000f, -0.07734074f, 0.09336936f, 0.17707199f, 
    0.09111498f, -0.41509145f, 0.07443873f, 0.12503654f, -0.09875754f, 0.12208736f, -0.23707637f, 0.04332725f, 
    0.01444052f, 0.00606600f, -0.33238593f, 0.11266046f, -0.01730432f, 0.01412325f, 0.04726010f, -0.09729614f, 
    0.11664143f, -0.06324428f, 0.04851208f, -0.32400045f, -0.42024279f, 0.23018359f, -0.29807284f, 0.08322547f, 
    0.07594043f, 0.03855585f, 0.05374928f, 0.15217613f, -0.05375846f, 0.09807576f, 0.20774989f, -0.22464553f, 
    -0.04453553f, -0.09685118f, 0.00425376f, -0.11646325f, -0.05501714f, 0.31017032f, 0.00056576f, -0.09643256f, 
    0.03117149f, -0.02099936f, -0.06009032f, -0.02608815f, -0.12583877f, -0.00117642f, 0.38131261f, 0.32260326f, 
    -0.02131199f, 0.02341039f, -0.10795576f, 0.09177638f, -0.05328010f, -0.04365504f, 0.13841382f, -0.49141493f, 
    0.09872353f, 0.28197551f, -0.12267146f, -0.06515828f, -0.14756529f, 0.01577694f, -0.04007790f, 0.05596222f, 
    0.01926586f, 0.05377648f, 0.00264474f, -0.02075868f, -0.04017233f, -0.04296489f, -0.05001791f, -0.05926931f, 
    0.04737096f, 0.03340399f, 0.01682264f, -0.11105270f, -0.10774897f, 0.04368501f, -0.08960547f, -0.10246698f, 
    0.04401844f, -0.04499096f, -0.01692530f, -0.01703368f, 0.02667470f, -0.06747260f, -0.03556405f, -0.07873888f, 
    0.00169493f, -0.07463153f, -0.04072300f, -0.00995971f, -0.01384090f, 0.00473453f, 0.02976770f, -0.10202764f, 
    0.04334756f, -0.04414441f, -0.03153158f, 0.00208456f, -0.06106126f, 0.00790269f, 0.02938622f, -0.03666370f, 
    -0.09437446f, -0.08629244f, -0.00495611f, -0.02533724f, -0.05041403f, 0.00862219f, 0.00736290f, -0.01697284f, 
    -0.10458242f, -0.00461004f, 0.00028323f, -0.08989950f, -0.00695074f, -0.10672742f, 0.04606994f, 0.01470907f, 
    -0.01456411f, -0.03845478f, -0.01637844f, 0.02367998f, -0.09007151f, 0.03510294f, 0.00547247f, -0.05440572f, 
    -0.05100238f, -0.11141180f, -0.06184117f, -0.08776207f, 0.00599095f, -0.11384460f, -0.02814635f, 0.00330679f, 
    -0.03449116f, -0.00108157f, -0.08710510f, -0.00310916f, -0.07071378f, -0.03610369f, -0.03948963f, -0.03358072f, 
    -0.06415375f, 0.03316445f, -0.02216825f, -0.09154709f, 0.02887720f, -0.06941614f, -0.05051012f, -0.09601234f, 
    0.03300831f, -0.08443514f, -0.09836286f, -0.11718488f, -0.08618683f, -0.05681829f, 0.03874111f, -0.03135187f, 
    -0.05525720f, -0.11851583f, 0.00645903f, 0.01038556f, 0.01206666f, -0.03492039f, -0.03880318f, -0.08224140f, 
    0.02159988f, -0.04692904f, 0.01324991f, -0.08963052f, -0.05480080f, -0.03578403f, 0.00618822f, -0.01220002f, 
    -0.00953415f, -0.02405603f, -0.07993612f, -0.06831390f, 0.01917288f, -0.06966394f, -0.10952479f, -0.08723911f, 
    -0.10960469f, 0.02352865f, -0.08657854f, -0.05547290f, 0.02657916f, -0.09528268f, -0.05719209f, -0.00042473f, 
    -0.07314868f, -0.04937859f, 0.00229779f, 0.04431777f, -0.01422952f, -0.10905021f, -0.09226357f, 0.00406020f, 
    0.00314237f, -0.06401912f, -0.03323516f, -0.08302352f, 0.02971599f, 0.03262629f, 0.01878362f, -0.06947984f, 
    -0.31209901f, 0.19009852f, 0.09599474f, -0.01563842f, -0.02064047f, -0.06360378f, 0.00428670f, -0.18209311f, 
    0.15846319f, -0.37056813f, 0.02745409f, 0.13763432f, 0.02091804f, -0.14902370f, 0.09902430f, 0.01996426f, 
    -0.00340987f, 0.04996371f, 0.02115005f, 0.37874866f, 0.36341867f, -0.00933130f, 0.01687226f, -0.01105926f, 
    -0.00311899f, 0.16168943f, -0.06301846f, 0.11787354f, 0.10050493f, 0.06029730f, -0.05114235f, -0.01488870f, 
    -0.04353240f, 0.07341579f, 0.01665227f, -0.04267297f, -0.63080466f, -0.14681719f, -0.02536497f, 0.03297931f, 
    0.02412323f, -0.13519745f, -0.03357459f, 0.08865299f, 0.17435211f, 0.35582384f, 0.05546629f, 0.27916551f, 
    -0.07689884f, -0.06417198f, 0.10197276f, 0.04163122f, 0.10764729f, -0.00847611f, -0.23887034f, 0.11876947f, 
    0.12550069f, 0.19105971f, -0.08104131f, -0.16404198f, -0.09299333f, 0.09358767f, -0.00851926f, -0.37748638f, 
    -0.08840512f, -0.02725209f, 0.16362712f, 0.17863868f, -0.03782567f, -0.03020672f, -0.00092267f, 0.04767567f, 
    -0.04208646f, -0.06064701f, -0.04313087f, 0.05651490f, 0.07712550f, -0.08856138f, 0.12527530f, 0.02282785f, 
    0.12024460f, 0.02875520f, -0.26475739f, 0.02325582f, -0.00784909f, -0.01245684f, -0.23990351f, 0.00500015f, 
    0.10780887f, 0.03396198f, -0.34115428f, 0.22889838f, 0.24186806f, 0.05971214f, 0.00762664f, 0.12112110f, 
    0.07997537f, 0.03964933f, -0.04686910f, -0.21812379f, 0.12692274f, 0.19100961f, -0.03150472f, 0.17815919f, 
    -0.17938930f, 0.01938589f, 0.15350051f, -0.07141350f, -0.01984918f, -0.05657513f, 0.11203346f, -0.01091149f, 
    -0.12034409f, 0.01206142f, 0.00599079f, 0.14422351f, -0.03905658f, 0.31260285f, -0.20186257f, 0.28813285f, 
    -0.09481832f, -0.12377658f, 0.14808394f, 0.09606466f, -0.04631553f, -0.16483490f, 0.00973784f, -0.09392005f, 
    0.21377982f, -0.14050151f, 0.05645832f, 0.03698992f, 0.18024175f, -0.08684158f, -0.10424460f, -0.27926558f, 
    0.06746587f, 0.13534451f, -0.01429486f, 0.03396441f, 0.03196361f, 0.17292984f, -0.10586269f, 0.00791006f, 
    0.04255402f, 0.03502576f, 0.20006612f, -0.17912972f, -0.03506386f, -0.39105681f, -0.09401072f, -0.09632681f, 
    0.11155058f, -0.18349303f, -0.00954100f, -0.18116356f, -0.07840741f, -0.10155664f, 0.07894073f, 0.01535769f, 
    -0.11956574f, -0.03234906f, 0.21673355f, 0.23873559f, -0.05209284f, -0.06437811f, -0.09067897f, -0.03783427f, 
    -0.06478434f, 0.16835950f, 0.07269301f, 0.14891373f, -0.06151537f, 0.20239981f, -0.02603373f, 0.13302436f, 
    -0.07279344f, 0.14900993f, -0.00771792f, 0.11905193f, -0.19729686f, 0.27210239f, 0.09382418f, 0.05339975f, 
    0.15239924f, 0.21551973f, 0.02788662f, 0.03953052f, 0.01802440f, 0.04708169f, -0.57233346f, 0.06637434f, 
    -0.16829962f, -0.12562999f, -0.15822044f, -0.02015774f, 0.03820319f, 0.04076700f, -0.16539927f, 0.06338635f, 
    0.06774327f, -0.06502486f, -0.03045870f, 0.04460957f, -0.06734113f, -0.11649138f, 0.14247227f, -0.28311467f, 
    0.27393717f, 0.12009696f, -0.12513527f, -0.03712169f, 0.07218957f, 0.18145102f, 0.18943518f, 0.16663660f, 
    -0.07206785f, -0.01128737f, -0.40192893f, 0.08864013f, -0.06590654f, -0.02181713f, 0.10050771f, 0.16605788f, 
    -0.06108772f, 0.27090052f, 0.07449112f, 0.00884622f, -0.01666931f, -0.09781635f, -0.08516555f, -0.00458246f, 
    -0.00412163f, 0.09248868f, 0.16633265f, 0.06650955f, 0.02842798f, -0.00935692f, -0.12063093f, -0.20361397f, 
    -0.00064570f, -0.14088050f, 0.07821479f, 0.40976283f, 0.01939439f, -0.41150203f, 0.01709324f, 0.02500950f, 
    -0.03855413f, -0.05329964f, 0.00666443f, -0.11491387f, 0.02408882f, 0.00536231f, -0.07109571f, -0.03987126f, 
    0.01884503f, -0.15708621f, -0.02427818f, 0.06883827f, -0.14876421f, 0.23841378f, 0.03809420f, 0.15976778f, 
    -0.08857077f, -0.10942540f, 0.04051147f, 0.04647224f, 0.04130568f, 0.00105038f, -0.17465016f, 0.04958424f, 
    0.06289364f, -0.02222319f, 0.13322361f, -0.03204845f, 0.10292694f, 0.18062316f, -0.00383873f, 0.22051281f, 
    -0.25143692f, 0.02572789f, 0.00968552f, -0.16532044f, -0.23887444f, 0.07983436f, -0.09935858f, -0.04105704f, 
    0.05313935f, 0.00855118f, -0.00328632f, -0.04291221f, -0.06319015f, 0.01418445f, -0.05293804f, 0.00413932f, 
    -0.01098657f, -0.03897928f, 0.05574049f, -0.02507239f, -0.02632531f, 0.05934218f, -0.07239697f, 0.05141278f, 
    -0.04642320f, -0.00919578f, -0.06182013f, 0.07376546f, 0.05162014f, 0.02495078f, -0.03054775f, -0.04821289f, 
    0.03321698f, -0.06130459f, -0.03837289f, 0.01187746f, -0.06310463f, -0.05649141f, -0.08277205f, 0.03741401f, 
    -0.07362352f, -0.01663113f, 0.03538417f, -0.01974342f, -0.01288340f, 0.03626924f, 0.01667931f, -0.07115074f, 
    -0.04671085f, -0.08517762f, -0.00267524f, 0.01483508f, -0.00996835f, -0.04326594f, 0.03622530f, 0.07945833f, 
    -0.04432267f, -0.03983096f, 0.03838708f, 0.03467275f, 0.00566392f, -0.02140328f, -0.06749866f, 0.04697275f, 
    0.00480810f, -0.07353237f, -0.05407890f, -0.07374184f, -0.07285938f, 0.02750767f, 0.04972305f, -0.04683961f, 
    -0.02794448f, -0.00856093f, -0.08303396f, -0.00155209f, -0.06588399f, -0.03871470f, -0.02417307f, 0.00465853f, 
    -0.06909149f, 0.07368638f, 0.05395110f, -0.03806026f, -0.07908241f, 0.00300032f, 0.05498844f, -0.00676439f, 
    -0.02768113f, -0.04465564f, -0.00627298f, 0.01710442f, -0.04629931f, 0.00017124f, -0.01378205f, 0.01911809f, 
    0.01917399f, -0.00279924f, 0.01738259f, 0.00552638f, -0.04123732f, -0.02756963f, -0.07197429f, -0.05978858f, 
    -0.02968584f, -0.03908410f, 0.05812344f, -0.02230535f, -0.06456847f, -0.07029303f, -0.07530636f, -0.07552920f, 
    -0.00157721f, 0.06748538f, 0.01018297f, -0.02201366f, 0.03017853f, 0.01024111f, -0.00509971f, -0.02538015f, 
    0.02140609f, -0.03788951f, 0.05574144f, -0.02988989f, -0.05592539f, 0.02871658f, 0.04056630f, -0.07258782f, 
    -0.01954693f, 0.01413184f, 0.08135912f, 0.01582573f, -0.03293855f, -0.03165454f, -0.03288374f, 0.02705551f, 
    -0.06615888f, -0.05893724f, 0.07249255f, -0.04605274f, 0.06387679f, 0.02627508f, -0.04177328f, -0.05564969f, 
    0.05701834f, -0.02214736f, 0.05731046f, 0.04403856f, -0.03300247f, 0.02000391f, 0.02614802f, -0.03714323f, 
    -0.10438073f, 0.12589875f, 0.21108250f, 0.05993159f, -0.20100363f, -0.04231184f, -0.08712817f, 0.11886296f, 
    0.18787704f, -0.10768741f, 0.07300983f, -0.18609275f, 0.01094251f, -0.08818815f, 0.04240971f, 0.09024661f, 
    -0.11919119f, 0.03464596f, -0.19687849f, -0.23231061f, 0.24138653f, -0.06358360f, -0.11757673f, -0.13851456f, 
    0.00217571f, -0.04413563f, -0.00247392f, -0.15451358f, -0.12651460f, 0.09554982f, -0.08895496f, 0.05433228f, 
    -0.01382364f, 0.13665807f, -0.14096294f, -0.07674304f, 0.22404218f, 0.22274549f, -0.15572965f, 0.09167556f, 
    -0.02339227f, 0.01551118f, 0.08000999f, 0.00539460f, 0.03260637f, -0.16673695f, -0.39269781f, -0.01640578f, 
    -0.09415764f, 0.00977773f, 0.08545257f, 0.06135151f, 0.01561439f, 0.07961047f, -0.00074841f, 0.20507395f, 
    0.28946593f, 0.11331881f, -0.10110326f, -0.16127954f, 0.14274612f, 0.15729579f, 0.03817417f, -0.12820929f, 
    0.11135471f, -0.14069037f, 0.07528046f, 0.02676500f, 0.13869458f, 0.07265756f, -0.09456255f, -0.09540852f, 
    0.15856849f, 0.33111748f, -0.16241801f, -0.01724128f, -0.06197839f, 0.04778237f, 0.19037220f, -0.04386219f, 
    0.00007284f, -0.30512613f, -0.39334363f, 0.15592360f, -0.11401063f, -0.01563822f, -0.37729788f, -0.05383640f, 
    0.09856657f, -0.04265228f, -0.00843771f, -0.08317096f, -0.15767315f, 0.08272567f, 0.04090410f, -0.02954094f, 
    -0.21278746f, -0.06453733f, 0.08477584f, 0.09552503f, -0.37530547f, -0.06564512f, -0.14744987f, 0.20613588f, 
    -0.20534684f, 0.09394328f, 0.13266619f, 0.12536240f, -0.03901538f, 0.08433918f, -0.10126938f, -0.11174962f, 
    0.00049395f, -0.05951617f, 0.03051809f, -0.00133654f, -0.14494100f, -0.09728042f, -0.54690355f, -0.27376312f, 
    -0.19187593f, 0.06716634f, 0.16433464f, 0.01502233f, 0.03541311f, 0.04135872f, 0.26236832f, 0.28205678f, 
    0.41463357f, -0.18369991f, 0.06265955f, 0.08957140f, -0.09069525f, 0.03405258f, -0.06427542f, -0.11222661f, 
    -0.12473251f, -0.17794815f, 0.04036593f, 0.05762354f, -0.05326044f, 0.11255707f, -0.01072918f, -0.01388485f, 
    -0.08070469f, 0.00110462f, -0.10582116f, -0.01843950f, 0.06205840f, 0.01359256f, 0.03245106f, -0.04009749f, 
    -0.09157050f, -0.03627547f, 0.00671853f, 0.04383872f, -0.04112782f, -0.11577119f, -0.04915762f, 0.02642777f, 
    -0.07666902f, -0.10190237f, -0.01818732f, -0.04209222f, -0.09561700f, -0.10159099f, 0.01900546f, -0.11544988f, 
    -0.02755309f, 0.02507361f, -0.10601686f, -0.07118756f, -0.08218309f, -0.05907709f, -0.07549603f, 0.03420617f, 
    -0.07696243f, -0.03517824f, -0.00171196f, 0.00348477f, 0.04511801f, -0.04388771f, 0.00389939f, 0.01386485f, 
    0.04379579f, -0.00252541f, 0.00528497f, -0.06646710f, -0.04025884f, -0.04586986f, 0.00252089f, 0.06204057f, 
    -0.00386255f, -0.06963007f, -0.06931734f, 0.03133640f, -0.07999934f, 0.00234891f, 0.02890250f, 0.01720404f, 
    -0.07662097f, -0.04433236f, 0.00081381f, -0.09538918f, -0.11530954f, -0.12978868f, -0.04399588f, -0.07498951f, 
    -0.07030222f, -0.06653561f, 0.00770594f, -0.06160315f, -0.13318956f, -0.08271965f, -0.07838660f, -0.03992956f, 
    -0.04816540f, -0.02925755f, -0.01427130f, -0.00319538f, 0.01992003f, -0.07534038f, -0.04248694f, 0.01405303f, 
    -0.01832284f, -0.02277352f, 0.03588891f, -0.09431588f, 0.04368327f, -0.10420608f, -0.10753794f, -0.01103960f, 
    0.00043759f, -0.15008332f, 0.04265643f, 0.02998834f, -0.06708065f, -0.09853739f, -0.07604733f, -0.05887593f, 
    -0.07635055f, -0.09542499f, -0.03222800f, -0.01290418f, -0.06810713f, 0.00591305f, 0.02270573f, -0.07382352f, 
    0.02486432f, -0.04752354f, -0.00470316f, 0.03382529f, -0.01602730f, 0.04105347f, -0.04550423f, -0.00090619f, 
    -0.01073203f, -0.12872231f, -0.02560958f, -0.02316155f, -0.00018521f, -0.02858831f, -0.01658825f, 0.00341091f, 
    0.00458641f, -0.05606007f, -0.01251949f, 0.02242673f, -0.09367509f, -0.05420287f, 0.02181901f, -0.08790727f, 
    -0.03020040f, -0.03107241f, -0.08703972f, -0.11298780f, -0.08071073f, 0.01898267f, 0.01268168f, -0.07675002f, 
    0.01179650f, -0.00216310f, -0.01386612f, -0.00739266f, -0.04149489f, 0.00695533f, -0.04460658f, -0.04803558f, 
    0.01541161f, -0.06098833f, 0.22287546f, 0.04350673f, 0.25031230f, -0.01644149f, 0.13349031f, -0.12844345f, 
    0.01812220f, 0.03446899f, -0.03510825f, 0.07296286f, -0.03850463f, 0.16109699f, -0.11623623f, 0.00486922f, 
    0.06108721f, 0.16119456f, -0.03508172f, 0.16126496f, 0.08974540f, 0.14524007f, -0.02235349f, 0.06321866f, 
    0.09277072f, -0.17748454f, 0.23808180f, -0.03598619f, 0.02476765f, 0.08686613f, 0.00648236f, 0.07348885f, 
    -0.02705010f, -0.12963514f, -0.04623439f, 0.01332156f, 0.01298459f, 0.17007218f, -0.04669774f, 0.01489696f, 
    0.03812347f, -0.14417164f, 0.00783614f, 0.06052066f, -0.07384374f, -0.39674965f, 0.15883613f, 0.24344154f, 
    0.05162686f, 0.10069612f, 0.11331714f, 0.03010382f, 0.26890999f, 0.08853942f, 0.03160804f, 0.16142781f, 
    -0.04087148f, 0.02875880f, -0.11738770f, 0.13762374f, -0.11369307f, -0.15464039f, 0.16933480f, -0.19403404f, 
    0.11506594f, -0.20238440f, 0.08340820f, -0.01507547f, -0.18982774f, -0.04938664f, -0.09990535f, -0.09563655f, 
    0.27626380f, -0.08681056f, 0.08393218f, -0.10836270f, 0.15237097f, 0.18028371f, -0.00008886f, 0.15828602f, 
    0.05923693f, 0.09505861f, -0.21185657f, -0.15824972f, 0.14227386f, -0.01835289f, 0.00188512f, 0.06420282f, 
    -0.09263021f, -0.06170427f, -0.01099210f, -0.20977108f, -0.06673643f, -0.00035803f, 0.24183650f, 0.29909208f, 
    0.00067510f, 0.23323163f, 0.15862304f, 0.17310508f, 0.11035703f, 0.09207371f, 0.11447576f, -0.04199556f, 
    0.02139143f, 0.08393412f, -0.05948262f, 0.02282244f, -0.08846428f, 0.09462330f, -0.43218243f, 0.07579894f, 
    0.08271757f, 0.08013203f, 0.05888655f, 0.07523487f, -0.02917456f, -0.09810770f, 0.25030875f, 0.05293582f, 
    0.26282194f, 0.11518380f, 0.04361339f, -0.24642175f, 0.19346572f, -0.12585300f, 0.03597733f, 0.09941185f, 
    -0.01117797f, -0.11437219f, 0.08318454f, -0.12815039f, 0.01371290f, 0.01329322f, 0.05757481f, -0.17384471f, 
    -0.18177697f, -0.09843437f, 0.13433501f, -0.05406209f, 0.09023967f, -0.12548515f, -0.05308533f, -0.03709686f, 
    -0.38389376f, -0.24969184f, -0.13534467f, -0.07345915f, -0.20744097f, -0.01070100f, 0.14263718f, 0.14544579f, 
    -0.13666052f, -0.05893686f, 0.18844710f, 0.14402825f, -0.07377776f, 0.02727712f, -0.04119961f, 0.01263688f, 
    0.14133024f, 0.03831825f, 0.05879658f, 0.05290377f, -0.00390610f, 0.02881291f, 0.13737342f, -0.13416252f, 
    -0.06482572f, -0.00885500f, -0.02436605f, 0.18936941f, 0.18253328f, 0.01638000f, 0.07824520f, 0.01795216f, 
    -0.13809679f, 0.12341348f, -0.00134117f, 0.00457996f, -0.22695972f, -0.60385156f, -0.20199628f, -0.09527381f, 
    -0.06112627f, 0.07359815f, -0.03260065f, 0.00250060f, 0.03605283f, 0.55006182f, -0.14555445f, -0.39639539f, 
    0.07838613f, -0.04348493f, 0.03157116f, 0.06544124f, 0.05212242f, -0.04110987f, 0.11148401f, -0.12543714f, 
    -0.03961853f, 0.09954067f, -0.10254657f, -0.05799823f, -0.05508139f, -0.01740010f, 0.06799128f, -0.09848993f, 
    -0.03634217f, -0.32294419f, 0.00846173f, -0.08706292f, 0.14209898f, 0.01613837f, 0.02558985f, -0.05584830f, 
    -0.49709669f, 0.12653607f, 0.19499633f, -0.01954749f, -0.07730707f, 0.00563777f, 0.00595250f, 0.01897383f, 
    -0.08894969f, -0.02154862f, 0.21845870f, 0.33494028f, -0.04591338f, -0.00869358f, -0.05586918f, 0.01255244f, 
    0.01827268f, 0.11764127f, 0.28784275f, 0.03514090f, 0.20225880f, -0.12844932f, -0.07535130f, 0.05619793f, 
    0.16083783f, -0.04078011f, -0.02200303f, 0.28213137f, -0.09174063f, -0.09074973f, 0.00879457f, 0.08075160f, 
    0.16424964f, 0.15532741f, 0.06120394f, 0.07724580f, -0.32371879f, -0.00473631f, 0.06280611f, 0.06324109f, 
    0.03870977f, -0.05160770f, 0.03208769f, 0.09168891f, 0.11435199f, 0.05598449f, 0.30230045f, 0.26680723f, 
    -0.02364749f, -0.05573592f, 0.01543032f, 0.01986223f, 0.05089374f, -0.05854382f, -0.24827839f, 0.10679226f, 
    0.11101355f, -0.00626450f, 0.14780240f, 0.09197035f, -0.01126457f, -0.03867453f, 0.17044882f, -0.06885327f, 
    -0.41412351f, -0.43392867f, -0.02379169f, -0.07875092f, 0.07599594f, -0.05704186f, -0.03823052f, 0.02924171f, 
    -0.20365843f, 0.00371460f, 0.07820243f, 0.02942372f, 0.01417726f, 0.02973972f, -0.04731935f, 0.07258682f, 
    -0.05663650f, 0.19589311f, 0.15790951f, -0.01326343f, -0.14243113f, 0.03783619f, 0.00207808f, -0.06003136f, 
    -0.20527595f, 0.01441104f, -0.07119843f, 0.18143307f, 0.15672605f, -0.10326679f, 0.09253527f, -0.04882486f, 
    -0.07772856f, 0.05645810f, -0.17008130f, 0.23034292f, 0.27530620f, 0.18340927f, -0.03631995f, 0.17417565f, 
    -0.08147073f, 0.14852454f, 0.03010206f, 0.12313607f, -0.25377613f, -0.35543755f, -0.28376335f, -0.02114558f, 
    0.07749137f, 0.07168642f, 0.12508811f, -0.02705101f, 0.06173620f, 0.01074264f, 0.02470895f, -0.16945022f, 
    0.00019729f, 0.05566276f, 0.04368088f, -0.03773959f, -0.00149539f, -0.12528269f, -0.47853360f, -0.24161246f, 
    -0.33710283f, 0.10825805f, 0.02174613f, 0.00120150f, 0.15406521f, 0.01697508f, 0.04566465f, -0.17912321f, 
    -0.07170057f, -0.29168686f, 0.01999653f, -0.00599820f, -0.00590828f, -0.00354333f, 0.15064907f, 0.13851966f, 
    0.02283008f, -0.05799289f, 0.02553389f, -0.02135559f, 0.04715599f, 0.01144563f, -0.00352634f, 0.02937952f, 
    -0.12404411f, 0.18118525f, 0.29913116f, 0.24289286f, -0.07043178f, 0.12176140f, -0.01930264f, -0.06609430f, 
    0.14360127f, 0.07053530f, 0.09373830f, 0.03851716f, 0.02768041f, 0.01500068f, -0.02615898f, -0.02896709f, 
    -0.09466615f, -0.09461293f, 0.09300583f, 0.01836291f, 0.19341773f, 0.07763224f, 0.13553536f, 0.01871812f, 
    -0.06227696f, 0.00822758f, 0.19350262f, 0.04593433f, 0.10684409f, -0.18086144f, -0.30142546f, 0.08596117f, 
    0.02516937f, -0.21789947f, 0.05276008f, -0.17299570f, 0.17621261f, 0.12125114f, 0.07371949f, 0.10934490f, 
    0.16973470f, 0.14911242f, 0.16140550f, -0.00313362f, -0.14545804f, -0.06910443f, -0.20301594f, 0.03349334f, 
    0.03754196f, 0.23305687f, 0.12630852f, 0.18120678f, -0.05498154f, 0.08923132f, -0.02414254f, -0.06962638f, 
    0.03302033f, 0.00981078f, 0.15650360f, -0.14802353f, 0.02848629f, 0.15670991f, -0.06661574f, -0.02942614f, 
    -0.14509138f, -0.05437431f, 0.17217462f, 0.08983319f, -0.02364809f, 0.06982075f, -0.02132459f, -0.06852198f, 
    -0.29183155f, 0.12273914f, -0.04400550f, 0.06240194f, -0.05239177f, 0.08609753f, -0.00025715f, 0.03574732f, 
    -0.00435057f, 0.08690361f, 0.14907859f, -0.04044681f, -0.00014986f, -0.12480822f, 0.18631771f, 0.07739060f, 
    0.14019006f, -0.03240127f, -0.04593209f, -0.06395759f, -0.24136989f, -0.05611553f, -0.22492842f, -0.15066916f, 
    -0.15579124f, 0.09389244f, 0.23290651f, 0.24294570f, -0.12924439f, 0.01430258f, 0.06073749f, 0.08770102f, 
    -0.09455028f, 0.09395278f, -0.04826751f, -0.11180943f, -0.02221591f, 0.18993117f, -0.05540738f, -0.23536827f, 
    -0.08902836f, 0.10322092f, -0.06173736f, 0.03773202f, -0.19023168f, -0.04122502f, -0.13856722f, -0.12847891f, 
    0.00046866f, -0.05806186f, 0.05606749f, 0.02332498f, -0.03041871f, -0.14042747f, 0.06146086f, -0.00419868f, 
    0.11051300f, 0.05644381f, 0.13356332f, -0.07246100f, 0.04985946f, -0.05595022f, 0.27937219f, 0.10105380f, 
    0.09666378f, -0.14480761f, 0.02752910f, -0.12316831f, 0.17114851f, -0.04272471f, -0.11354448f, -0.07891998f, 
    0.05140930f, 0.16789913f, 0.15558593f, -0.05414062f, 0.12445375f, -0.13301811f, 0.10970648f, 0.12852885f, 
    0.17545937f, 0.10269735f, -0.02198354f, -0.11096840f, -0.17789362f, -0.12405207f, 0.02982479f, 0.02687289f, 
    -0.12632738f, -0.23705673f, -0.26823202f, -0.47910535f, -0.06686817f, 0.31367594f, -0.02372672f, -0.13676800f, 
    -0.15060662f, 0.07316809f, 0.10201529f, 0.01596657f, -0.31432939f, -0.24089210f, 0.15445590f, 0.07132545f, 
    0.03474648f, -0.04923150f, -0.19746353f, 0.03506092f, 0.06170136f, 0.12265836f, -0.16465433f, -0.21758395f, 
    0.14642997f, 0.10241608f, 0.14559349f, 0.08631314f, 0.00669642f, -0.00994501f, 0.32371879f, 0.20260966f, 
    -0.01147118f, 0.10531298f, -0.15490147f, 0.03902750f, 0.14564209f, 0.02579134f, 0.00774097f, -0.13682501f, 
    0.09349135f, -0.02322971f, 0.04315416f, -0.00738386f, 0.06859743f, 0.07053617f, 0.28948548f, 0.12087892f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07644561f, 0.02189657f, 0.01148359f, 0.17050825f, 0.15364628f, 0.31174153f, -0.07860692f, 0.02398900f, 
    0.02923827f, 0.03915316f, -0.01470210f, -0.00697755f, 0.06334940f, 0.08462387f, -0.02188141f, 0.02034887f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15289669f, -0.17134556f, 0.01253227f, -0.01308860f, 0.31956840f, -0.44246933f, 0.22851732f, -0.15940815f, 
    0.42820850f, 0.24704397f, -0.19802889f, -0.03689748f, 0.26710275f, -0.28564331f, -0.01679049f, 0.11732536f, 
    -0.06241526f, -0.20458487f, -0.22339869f, -0.03115461f, 0.10083178f, -0.18924107f, -0.01483996f, 0.26491275f, 
    -0.10114920f, -0.20146377f, 0.17064741f, 0.13039687f, 0.33225217f, -0.43156752f, -0.08671421f, 0.11479488f, 
    0.22913758f, 0.27320245f, 0.07220203f, -0.01227279f, -0.14259949f, -0.05833583f, 0.25879705f, -0.26493514f, 
    -0.21956280f, 0.21503001f, 0.40027240f, -0.11043894f, -0.54173076f, -0.46173978f, -0.49370265f, -0.33041540f, 
    0.14366896f, 0.29211554f, -0.14534654f, -0.08945088f, -0.19108330f, 0.03428733f, 0.18202719f, 0.05125850f, 
    -0.01945037f, -0.15880221f, -0.24503078f, 0.20465474f, -0.00544341f, 0.09984659f, 0.11164291f, 0.06230421f, 
    0.01508945f, 0.27428705f, -0.00914466f, 0.42579553f, -0.22882390f, 0.23386206f, 0.18720171f, 0.30706438f, 
    0.25533032f, 0.13922787f, -0.23349276f, 0.11764838f, -0.10055538f, -0.09838490f, -0.22259761f, 0.28315276f, 
    0.13672431f, -0.03946109f, -0.04694459f, -0.54282582f, 0.06911616f, 0.18693605f, -0.08795494f, 0.17240553f, 
    0.17598929f, -0.13648777f, 0.52045721f, -0.06160241f, 0.04036713f, -0.10946629f, 0.00178164f, -0.37922251f, 
    0.36416712f, -0.31534341f, -0.20617115f, -0.37834072f, 0.16646789f, -0.12290023f, 0.08402582f, 0.04466362f, 
    -0.38383758f, -0.01447056f, 0.46307704f, -0.01930705f, -0.00222496f, -0.07050521f, 0.04108769f, -0.03608396f, 
    0.25459224f, -0.15428968f, 0.23793642f, -0.04778582f, -0.07053751f, -0.67759717f, -0.03585378f, -0.15564151f, 
    0.27642280f, -0.10971240f, 0.04114540f, -0.14715071f, 0.14019297f, 0.51546812f, 0.03207782f, -0.18065883f, 
    0.32851213f, -0.12716484f, -0.05489766f, -0.14471413f, 0.15509532f, -0.00994151f, 0.18239233f, -0.24688010f, 
    -0.36779085f, -0.04735848f, -0.23634639f, 0.15963283f, 0.31287575f, 0.02326350f, -0.11300208f, -0.16975109f, 
    0.05971242f, 0.22875892f, -0.18397273f, -0.23958778f, 0.26777789f, 0.27186778f, -0.01036335f, 0.01638824f, 
    -0.50268012f, -0.04941269f, -0.19918652f, -0.01799230f, 0.03982127f, 0.26117784f, -0.13003367f, -0.09926702f, 
    -0.17939594f, 0.44529110f, -0.17144588f, 0.19776171f, 0.19034407f, -0.23338495f, -0.31034005f, 0.13684344f, 
    0.41657391f, -0.17630099f, -0.35864362f, 0.02826233f, 0.10641666f, 0.02735472f, -0.10058205f, -0.26209748f, 
    -0.44287926f, 0.48664477f, 0.10987766f, -0.18190785f, 0.25943601f, 0.35007191f, 0.13412519f, 0.08148111f, 
    0.00429694f, -0.19728425f, -0.00531835f, 0.03127696f, 0.00814973f, 0.25073868f, 0.34790906f, -0.33149904f, 
    0.28738338f, 0.13344221f, -0.04472421f, -0.44667894f, -0.10479566f, -0.07717915f, 0.22868629f, -0.18926077f, 
    0.28931728f, 0.00934858f, 0.15606490f, 0.23923770f, 0.11931731f, 0.37970060f, -0.04849841f, -0.24313128f, 
    0.17804161f, 0.27491879f, 0.00174570f, -0.34550267f, -0.25651765f, 0.13403793f, 0.08551483f, 0.29887611f, 
    0.29905000f, -0.11178831f, 0.10156606f, 0.04166507f, -0.21282114f, 0.11397094f, 0.25596187f, 0.28953528f, 
    0.33804083f, -0.10168849f, -0.11038458f, -0.54948848f, -0.08706228f, 0.34832755f, 0.06089266f, -0.11142275f, 
    -0.02326103f, -0.02943524f, -0.14252752f, -0.07247777f, -0.03261758f, 0.18290745f, 0.11867858f, 0.21789701f, 
    0.22887939f, -0.23881938f, -0.22961721f, 0.24288960f, 0.03863198f, -0.29608110f, 0.02836135f, 0.00266700f, 
    -0.13021508f, -0.09968524f, -0.23206741f, -0.07354917f, 0.05337077f, 0.24738759f, 0.06261383f, 0.01640325f, 
    -0.23782253f, 0.23776914f, -0.24352729f, -0.47666231f, -0.01127013f, 0.30279186f, 0.22134756f, 0.45749563f, 
    0.23446612f, 0.06047321f, 0.34358248f, 0.04053800f, -0.15614371f, -0.00380364f, 0.03553530f, 0.03254613f, 
    0.02128705f, -0.08166713f, -0.14436254f, 0.14679486f, -0.17472170f, 0.40913531f, -0.05262420f, 0.48313895f, 
    -0.04695738f, -0.21335414f, 0.07123164f, 0.19548631f, -0.27991349f, 0.03828924f, 0.19559939f, -0.12334295f, 
    0.07062903f, 0.24985886f, -0.24373017f, -0.34522423f, -0.04256938f, 0.23600456f, 0.13355027f, -0.23971938f, 
    -0.08244766f, -0.07228874f, 0.38976657f, 0.01077271f, 0.05460669f, 0.20682375f, 0.17130022f, 0.03684369f, 
    0.32370582f, -0.11699395f, 0.01043534f, 0.29312256f, -0.03688713f, -0.18476562f, 0.08439290f, -0.35613513f, 
    0.04330160f, 0.19508633f, -0.04880774f, 0.05206124f, -0.46273658f, 0.03677640f, 0.45457706f, -0.02213763f, 
    0.11580247f, -0.04101247f, 0.12526926f, -0.30591732f, 0.04622857f, -0.27200958f, 0.23803246f, 0.12793793f, 
    -0.05265141f, -0.15002927f, 0.10919594f, -0.19850223f, -0.07518965f, -0.08664593f, 0.08473809f, 0.24932407f, 
    -0.32330975f, 0.38242105f, 0.13768961f, -0.29618305f, 0.18806253f, 0.26549980f, 0.01130745f, 0.06757414f, 
    -0.01057918f, -0.02580119f, -0.11558175f, -0.09964229f, 0.19119246f, -0.17922211f, -0.05929615f, 0.13319658f, 
    0.27256334f, -0.38780177f, 0.08258734f, 0.02148548f, 0.00425368f, 0.46497715f, 0.12125681f, -0.19196202f, 
    -0.22225417f, 0.05643335f, 0.43573308f, -0.00589757f, 0.32889265f, -0.14312635f, -0.14332613f, -0.25505686f, 
    0.01646766f, 0.40131286f, -0.00090556f, -0.48663783f, 0.17137989f, 0.23589136f, -0.01945663f, -0.01370007f, 
    0.18376493f, -0.01700515f, 0.30646324f, 0.07800822f, -0.15676335f, 0.15835842f, 0.18924314f, -0.11673762f, 
    0.17552868f, -0.28812280f, 0.22744083f, -0.12882829f, 0.19102122f, -0.02616942f, 0.20360950f, 0.30424803f, 
    -0.03899344f, -0.21153146f, 0.26173738f, -0.20520015f, -0.16289756f, -0.15109116f, -0.09112212f, 0.11270865f, 
    -0.22746396f, -0.07415538f, -0.05404074f, 0.24165422f, 0.29869103f, -0.45893681f, 0.06931360f, -0.24658576f, 
    0.54959369f, -0.19448979f, 0.27477941f, 0.23098165f, 0.08810066f, 0.13171706f, 0.07118191f, -0.16784431f, 
    -0.13120942f, 0.31259519f, -0.10785424f, -0.21631706f, 0.05575379f, 0.38030383f, 0.05110797f, 0.38492706f, 
    0.18520720f, 0.12483981f, 0.30537590f, -0.13999608f, 0.22538379f, -0.19885077f, -0.29672140f, -0.28269032f, 
    -0.04466024f, -0.22113150f, 0.03940922f, 0.00901455f, -0.06766722f, -0.10784605f, -0.11606842f, -0.13550758f, 
    -0.15213314f, -0.03211322f, 0.08407015f, -0.22051790f, -0.16649127f, -0.20400822f, -0.12701976f, -0.23167112f, 
    0.26402390f, -0.09951795f, -0.03032563f, -0.08426400f, -0.20112212f, -0.05349170f, -0.21167590f, -0.12142292f, 
    -0.15105167f, -0.08697677f, 0.37475958f, -0.12285264f, 0.02389698f, 0.48149171f, -0.09574497f, 0.35106188f, 
    0.03288102f, -0.09489715f, -0.25460386f, 0.00629048f, 0.16964535f, 0.02552684f, 0.21874379f, 0.22402538f, 
    -0.02001924f, -0.00189489f, 0.31434456f, -0.02176011f, -0.26694950f, 0.41876972f, 0.11376476f, 0.00064053f, 
    -0.19437669f, 0.03223239f, -0.10413035f, 0.13710639f, 0.02386582f, -0.03963559f, -0.17847885f, 0.01611989f, 
    -0.02238146f, -0.11483838f, -0.24607700f, 0.03557813f, -0.28478804f, -0.02021287f, -0.15838377f, -0.17280108f, 
    0.00460951f, -0.37135270f, -0.05008857f, -0.22626168f, -0.29268080f, 0.17569435f, -0.01031529f, 0.32653067f, 
    0.09587168f, 0.09042036f, 0.05817107f, 0.19383684f, 0.10192260f, 0.38786712f, 0.34423363f, 0.19488879f, 
    -0.06548845f, -0.31450382f, -0.12558569f, -0.12421482f, -0.00534862f, 0.01501107f, -0.23114635f, 0.33744901f, 
    -0.19329615f, -0.17741996f, -0.50173080f, -0.04202498f, 0.34723407f, 0.16956036f, -0.13768527f, -0.31756857f, 
    0.01448128f, -0.14680642f, -0.23190480f, -0.16577876f, -0.20023528f, 0.10668617f, 0.18911132f, -0.16004848f, 
    -0.04857659f, -0.11269149f, -0.13955185f, -0.21050140f, -0.20583418f, 0.11399129f, -0.18265015f, 0.04827690f, 
    -0.08908434f, -0.45131671f, -0.19558105f, -0.16406828f, 0.14603329f, 0.37622884f, -0.21202424f, 0.23963481f, 
    0.02649575f, 0.07892999f, -0.60695148f, -0.16846025f, -0.03735206f, 0.28162915f, 0.18406226f, -0.11687297f, 
    0.23116630f, 0.39694241f, 0.15607727f, -0.16789700f, -0.10913091f, -0.12025413f, 0.07202185f, 0.05616965f, 
    -0.06917576f, 0.06824690f, -0.17428540f, -0.21996509f, -0.10282079f, 0.42787799f, -0.09456500f, -0.03256873f, 
    0.15565869f, -0.17902790f, -0.03520852f, 0.10038338f, 0.04733900f, 0.27531552f, 0.14859474f, 0.16561197f, 
    -0.32021302f, 0.20643535f, -0.20452696f, 0.06079393f, -0.06784411f, 0.29219037f, -0.10557549f, -0.21721363f, 
    -0.13359913f, -0.30417892f, 0.17482376f, 0.23411562f, 0.29091308f, 0.16614845f, 0.17369708f, 0.39777490f, 
    -0.17703101f, 0.06222989f, 0.40136939f, -0.23482969f, -0.10549786f, -0.27559853f, -0.09395950f, 0.07602751f, 
    -0.15196285f, -0.06424843f, 0.14950435f, 0.42258057f, 0.31333262f, 0.39937973f, 0.21043089f, -0.08441093f, 
    -0.30373421f, -0.14176506f, -0.42117989f, 0.18105561f, 0.04771766f, 0.22074424f, -0.20367861f, 0.19467710f, 
    -0.30327508f, 0.21160856f, -0.08057555f, 0.19933501f, 0.29033208f, 0.09504677f, 0.09295509f, 0.22803956f, 
    0.18140435f, -0.12582393f, -0.24816121f, -0.08523515f, -0.07830110f, 0.13323717f, 0.13824630f, -0.31093901f, 
    -0.20993678f, -0.17155354f, -0.20567313f, 0.05287962f, -0.09315093f, -0.25535607f, -0.03794402f, -0.06727363f, 
    -0.13712825f, -0.22695488f, -0.00126738f, -0.16434354f, 0.13063045f, 0.05463270f, -0.18261640f, -0.15863505f, 
    -0.05684270f, 0.08125803f, -0.00711937f, -0.14044102f, -0.29582068f, 0.36137202f, 0.25261641f, 0.15488812f, 
    0.01291329f, -0.11503115f, -0.03721042f, -0.08258656f, 0.04018176f, -0.15334436f, 0.00284965f, 0.31390467f, 
    0.38153902f, -0.51571655f, -0.08138753f, -0.17224786f, -0.25405341f, -0.25487781f, 0.04066562f, 0.11432222f, 
    0.15946533f, 0.06187925f, 0.26817644f, 0.24953295f, 0.14293335f, 0.11967272f, -0.23139399f, 0.29348192f, 
    -0.27766615f, -0.48656338f, 0.24743424f, -0.32856005f, 0.21735731f, 0.23994754f, 0.03181350f, -0.09635444f, 
    0.04427582f, -0.11521336f, -0.63871080f, -0.14294676f, 0.20131035f, 0.33679059f, -0.04940844f, 0.19404219f, 
    0.16243751f, -0.37306145f, 0.13665575f, 0.29310822f, 0.08453526f, -0.21086016f, -0.22028403f, 0.10855386f, 
    0.04530770f, 0.01230100f, -0.54124880f, 0.17123559f, 0.28778842f, -0.19725597f, -0.12158374f, 0.01101358f, 
    -0.13370639f, 0.31983262f, -0.00751727f, 0.16272378f, -0.05363244f, -0.12347755f, -0.17441189f, -0.10216500f, 
    -0.02773911f, 0.09532116f, -0.03816545f, 0.08500428f, 0.14659162f, 0.43901995f, 0.08406098f, -0.11859369f, 
    0.06446034f, -0.22939667f, 0.17035457f, -0.13030487f, -0.10601455f, 0.24556157f, 0.15228352f, -0.18445253f, 
    -0.10567504f, 0.23562750f, -0.05084455f, 0.00222075f, -0.17209750f, 0.06205475f, -0.03016365f, 0.11316425f, 
    0.34405759f, -0.40852460f, 0.18299206f, 0.10167249f, 0.20938142f, 0.14086315f, -0.07788730f, -0.03465853f, 
    -0.17161936f, 0.17081328f, -0.15792745f, 0.05734649f, 0.11964171f, -0.31004000f, 0.08631838f, -0.00637837f, 
    -0.32187372f, -0.25717491f, -0.13904807f, 0.47415099f, -0.12194175f, 0.32467833f, -0.02356800f, -0.11577840f, 
    0.33066952f, 0.06551231f, -0.10669374f, 0.22326952f, 0.01062080f, -0.13579844f, 0.20839588f, -0.03249386f, 
    -0.32636088f, 0.03188866f, -0.14474285f, -0.09615829f, -0.07362378f, 0.52486962f, -0.15923484f, 0.05808958f, 
    -0.30060974f, -0.15807031f, -0.40738121f, -0.17998131f, -0.25349793f, 0.49018881f, 0.38984090f, 0.09718916f, 
    -0.24458079f, 0.16495101f, -0.00971672f, -0.12942988f, 0.12509103f, 0.19977707f, -0.04360276f, 0.03795223f, 
    -0.26722336f, -0.09858605f, -0.20210232f, -0.00877509f, -0.26832908f, 0.10945338f, -0.12338225f, 0.07538328f, 
    0.15530844f, -0.31662610f, -0.24968766f, -0.02390140f, 0.18411684f, 0.18210968f, 0.02159921f, -0.35688114f, 
    -0.19146705f, 0.23256919f, 0.14442827f, 0.03464741f, -0.09148190f, -0.15961580f, 0.30970231f, 0.20623720f, 
    0.00771894f, -0.36500305f, 0.03278765f, -0.36026514f, 0.12568599f, 0.02842458f, -0.22678511f, 0.21098866f, 
    -0.23670189f, -0.08366108f, -0.13190663f, -0.10505100f, 0.01281154f, -0.42565075f, 0.31745383f, 0.14110751f, 
    -0.21030945f, -0.01680617f, 0.18944176f, -0.05511599f, 0.27503747f, -0.14068076f, 0.01012998f, -0.22360545f, 
    -0.05445915f, 0.02692389f, -0.14079319f, 0.15580718f, 0.31710467f, 0.33991045f, -0.00131785f, -0.00372735f, 
    0.18898554f, 0.15540580f, -0.15211518f, -0.19941486f, -0.18430513f, 0.14697850f, 0.19006646f, 0.05377737f, 
    0.00291180f, -0.05538886f, 0.06367640f, 0.20239840f, -0.33535677f, 0.21053350f, 0.29918477f, 0.33768541f, 
    0.37075317f, -0.27404973f, 0.11994731f, -0.21692906f, 0.14283001f, 0.21382459f, 0.21488488f, 0.04196564f, 
    0.10045683f, -0.15827714f, 0.02085016f, -0.23114733f, -0.07917026f, -0.18623506f, -0.05773008f, -0.04690982f, 
    0.34014511f, -0.13677464f, 0.02289806f, 0.10054846f, -0.20289451f, -0.11243396f, 0.13034719f, 0.25590613f, 
    -0.26550165f, -0.13449477f, -0.24248169f, -0.22267121f, -0.13794789f, 0.34159768f, -0.12136102f, 0.01168009f, 
    -0.25647292f, 0.12180780f, 0.02395717f, 0.05993152f, 0.27887744f, 0.14189260f, -0.18541607f, -0.08847059f, 
    -0.06952910f, 0.25168598f, -0.36424556f, -0.09275014f, 0.22129077f, -0.27334568f, -0.04870293f, 0.05591641f, 
    0.10294595f, 0.11305439f, -0.02452665f, 0.19559745f, -0.07816910f, 0.35403186f, 0.12917593f, 0.05300600f, 
    -0.29150572f, 0.17677769f, -0.02059197f, -0.08652293f, 0.24967283f, -0.21670620f, 0.03595509f, -0.35028708f, 
    0.23450948f, 0.17849217f, 0.18186185f, -0.51896203f, -0.14657563f, 0.24046856f, -0.16188565f, -0.14704008f, 
    -0.08795044f, -0.13290609f, 0.21821655f, -0.16621429f, -0.18054707f, 0.34381390f, 0.22593822f, 0.15440367f, 
    -0.29058492f, -0.09614209f, 0.09457756f, 0.11400934f, 0.32713509f, 0.22854254f, -0.17064023f, -0.26937753f, 
    -0.08872652f, 0.03594828f, -0.35447332f, -0.18660066f, 0.27888811f, 0.29455927f, 0.16880584f, -0.10493795f, 
    0.15783244f, -0.21756555f, -0.20325243f, -0.01576132f, -0.23632389f, -0.11669358f, 0.01301536f, 0.18177533f, 
    0.22991949f, -0.18359211f, -0.17320138f, 0.12415220f, -0.10757709f, -0.14723967f, 0.36933193f, 0.30601382f, 
    -0.18437938f, -0.08192267f, -0.22031249f, 0.35660505f, 0.24190004f, 0.23721190f, -0.20061412f, 0.46753985f, 
    -0.17467712f, 0.17209004f, -0.13237822f, -0.01732994f, 0.11518000f, 0.32061371f, -0.12237265f, -0.10405267f, 
    -0.18563206f, 0.19687985f, -0.15384084f, 0.05005507f, 0.11553242f, 0.40945905f, -0.12974268f, 0.33511925f, 
    -0.48447731f, -0.06936089f, 0.18644299f, 0.19720724f, -0.07924132f, -0.19093324f, 0.34482098f, -0.37212777f, 
    0.21942179f, 0.23263320f, -0.04160245f, 0.02530274f, -0.03213664f, 0.37711069f, -0.16002372f, -0.31361708f, 
    -0.19084284f, 0.02625083f, 0.09411735f, -0.19486097f, -0.11487520f, 0.41071832f, 0.03756484f, 0.04433176f, 
    0.20381166f, -0.26331478f, 0.01977582f, 0.24738395f, 0.32342678f, 0.13522223f, 0.07958148f, -0.06537060f, 
    0.06047957f, 0.06380621f, 0.41419435f, 0.00751787f, -0.22924089f, 0.18497522f, -0.48053902f, 0.16330718f, 
    0.10400815f, -0.09953753f, 0.01762497f, 0.19434427f, 0.14156258f, 0.40285102f, -0.17004009f, -0.28890985f, 
    -0.34771717f, -0.04783177f, 0.23660690f, 0.13744192f, 0.34119168f, -0.10207039f, -0.12678812f, -0.21870901f, 
    -0.14940248f, 0.54993904f, -0.14064100f, 0.13985282f, -0.00350572f, 0.10977911f, 0.03916810f, -0.10570022f, 
    0.04974036f, 0.17249960f, -0.04215952f, -0.16987920f, 0.10296122f, 0.24119975f, 0.18764383f, -0.19255847f, 
    -0.33374047f, -0.46434602f, 0.23924294f, 0.14408650f, 0.23803002f, 0.25832558f, -0.10536618f, 0.24172343f, 
    0.03252747f, 0.21712695f, -0.32060555f, 0.19545321f, -0.07273851f, 0.27480286f, 0.43901265f, 0.04090431f, 
    0.07116536f, 0.11572926f, -0.24130706f, 0.17129393f, 0.05815122f, 0.23591106f, 0.01518605f, -0.11381899f, 
    0.04501109f, 0.23333067f, -0.12066804f, -0.14076237f, -0.23475023f, 0.19186552f, -0.11709496f, 0.18289091f, 
    -0.21457885f, -0.08355548f, -0.03765033f, 0.10834717f, 0.23662063f, -0.09757512f, -0.07428162f, 0.08336097f, 
    0.33432963f, 0.06480116f, -0.22800332f, 0.06301239f, -0.02397279f, 0.32678875f, -0.02360861f, 0.04321764f, 
    -0.20642869f, 0.47676229f, 0.10186183f, 0.24588872f, -0.04102533f, 0.15106001f, -0.09146994f, 0.09069743f, 
    -0.09823902f, 0.03469095f, -0.35163987f, -0.05325080f, 0.23718221f, -0.14451803f, -0.19038044f, 0.27991197f, 
    0.15250103f, -0.14715765f, -0.20151596f, -0.49546137f, 0.25714806f, 0.02737154f, -0.13437206f, -0.38915935f, 
    -0.25858277f, 0.15935005f, -0.34990689f, 0.19646674f, 0.27037835f, -0.29290497f, 0.34113428f, 0.10028200f, 
    0.26233137f, -0.04191775f, -0.19260170f, -0.10475260f, -0.15039860f, -0.26371816f, 0.20865326f, 0.26903015f, 
    0.01284698f, 0.03232420f, -0.08017974f, -0.01135470f, -0.22111407f, -0.15239935f, 0.27795306f, 0.13116865f, 
    -0.02869984f, 0.26506186f, 0.21471067f, -0.23534562f, 0.24597360f, -0.16318607f, 0.07269203f, -0.26285535f, 
    -0.08693844f, 0.08678203f, -0.30878505f, 0.22869785f, 0.24659875f, 0.15763958f, -0.33429086f, 0.21490350f, 
    -0.30761749f, 0.18893223f, 0.02784759f, 0.23568080f, 0.19537869f, -0.01741410f, 0.07503507f, -0.22866996f, 
    0.03765912f, -0.08059214f, -0.01506639f, 0.20132279f, 0.23516849f, 0.23830250f, 0.41775182f, -0.20470352f, 
    -0.05834605f, 0.45855388f, -0.08358204f, -0.20962594f, 0.04867276f, 0.46166036f, -0.24631536f, -0.24990159f, 
    -0.11135311f, -0.16576073f, 0.23097306f, 0.15218760f, 0.08422966f, 0.35767254f, 0.25162047f, -0.21083421f, 
    0.01833609f, -0.28355995f, -0.05577610f, 0.10632435f, -0.21576817f, 0.16363126f, 0.09607803f, 0.01850847f, 
    -0.05984573f, 0.08646215f, 0.08951688f, -0.11454785f, -0.00785271f, 0.31287149f, 0.55594981f, 0.30355173f, 
    -0.17387031f, -0.20069425f, 0.07550400f, 0.21747379f, -0.13530491f, 0.22702765f, 0.08531606f, -0.22819459f, 
    0.03304125f, 0.24599037f, -0.11414069f, 0.13280943f, -0.08107723f, -0.06164257f, 0.12021543f, -0.14587726f, 
    -0.32859868f, 0.42860255f, -0.15381368f, -0.52833021f, -0.10198183f, 0.13879804f, -0.00185238f, 0.01270722f, 
    0.02413066f, 0.05272872f, -0.04358016f, 0.10165566f, 0.13118924f, 0.44291964f, -0.09909431f, 0.17468660f, 
    -0.23194885f, 0.20336041f, -0.20949700f, 0.24288952f, -0.08992619f, -0.05321129f, 0.13199624f, 0.44101277f, 
    0.04159043f, -0.08168167f, -0.53020549f, 0.10211166f, 0.07408573f, 0.30229500f, 0.18099488f, -0.16506419f, 
    0.06292822f, -0.22817576f, 0.22120175f, 0.05746621f, 0.30514494f, -0.10922991f, -0.24316441f, -0.26053128f, 
    -0.01434644f, -0.25099123f, -0.26923031f, 0.02994401f, 0.30362457f, 0.28804421f, 0.19042249f, -0.21931073f, 
    -0.06555398f, 0.19368224f, -0.16560245f, -0.05123649f, 0.35738993f, 0.49438551f, -0.18574402f, 0.17368528f, 
    -0.55962551f, 0.03479252f, -0.17195001f, 0.05975253f, -0.05988278f, -0.13253252f, 0.05781054f, -0.07703927f, 
    -0.00200049f, -0.52670950f, 0.03816546f, 0.01392081f, 0.27493584f, 0.13291174f, -0.12918669f, -0.00620800f, 
    0.26058990f, 0.22327404f, -0.11686729f, 0.05374442f, -0.19384357f, 0.26639432f, 0.09839472f, 0.11360295f, 
    -0.04900630f, 0.02514754f, 0.17944056f, -0.33298859f, 0.15790971f, 0.04662418f, 0.05787495f, -0.19571841f, 
    0.14153019f, -0.15433452f, -0.04107938f, 0.20171478f, -0.16519003f, -0.20722140f, 0.11437994f, 0.06173480f, 
    0.08566961f, -0.17283522f, 0.10643826f, -0.36335582f, -0.11448424f, 0.28036842f, -0.15185435f, 0.27756736f, 
    -0.25010306f, 0.22608031f, 0.50579512f, 0.07306695f, 0.14549488f, -0.26303503f, 0.13046357f, -0.23386744f, 
    0.05482690f, 0.09344462f, -0.06115833f, 0.21187854f, 0.18398315f, -0.08862843f, 0.13980660f, 0.24161837f, 
    -0.51677674f, 0.00051675f, -0.27631131f, 0.07263821f, -0.08733349f, -0.20806235f, -0.90200865f, 0.43733236f, 
    -0.21703276f, 0.08846441f, 0.18945992f, 0.12382454f, -0.14538664f, -0.14314240f, -0.14620608f, -0.07354438f, 
    0.08751699f, 0.04551163f, -0.07157710f, -0.05396438f, -0.18271294f, -0.10302505f, -0.21248153f, -0.04024884f, 
    0.30315682f, 0.00540177f, 0.09080303f, 0.07661156f, 0.04587597f, 0.29982957f, -0.04526548f, 0.01189458f, 
    -0.55065775f, 0.09183231f, 0.30190453f, 0.16730179f, 0.06117681f, -0.51386923f, -0.32494870f, -0.09680453f, 
    -0.08496515f, 0.25055945f, 0.24989936f, -0.05871307f, -0.19033186f, 0.18468495f, 0.13907790f, -0.30314130f, 
    -0.15591180f, -0.03017849f, 0.43659115f, 0.12914211f, -0.30448666f, -0.24802756f, -0.15751907f, -0.33888990f, 
    0.15746967f, 0.07898115f, -0.20498224f, -0.48601878f, 0.18104383f, 0.06547251f, 0.06580363f, -0.01341101f, 
    -0.23674606f, 0.07480813f, 0.33643398f, 0.20350572f, 0.18054263f, -0.00933613f, -0.08802819f, -0.60436881f, 
    0.12528190f, -0.02072283f, 0.17988154f, -0.27890235f, 0.19975105f, 0.03969136f, 0.09644032f, 0.23682411f, 
    0.00855346f, 0.07455005f, 0.11264151f, 0.07401188f, 0.17107858f, -0.55973816f, 0.13113126f, -0.20835347f, 
    0.15035628f, -0.26672062f, -0.14706394f, -0.06059767f, 0.13480848f, -0.26864484f, 0.12668040f, 0.23898904f, 
    0.30898023f, 0.07411662f, -0.12297830f, 0.06878524f, -0.16194656f, 0.41629711f, 0.40546444f, 0.16181850f, 
    -0.12777020f, 0.01505577f, 0.04518205f, 0.03160230f, 0.20525831f, 0.25343007f, -0.13274717f, -0.27264100f, 
    -0.38726515f, 0.16923434f, 0.47895390f, 0.06273150f, 0.40002599f, -0.13471869f, -0.08495898f, 0.16609693f, 
    -0.27504221f, -0.15733893f, 0.08310536f, 0.03730743f, -0.01231888f, 0.05396705f, -0.22966576f, 0.18155965f, 
    -0.01832703f, -0.24944064f, 0.00141414f, -0.15470704f, -0.15482128f, -0.06244469f, -0.09158866f, 0.10938242f, 
    -0.18400279f, 0.04645030f, 0.09656160f, -0.18265271f, 0.09854719f, -0.20481776f, 0.17447168f, -0.09720967f, 
    -0.11966715f, -0.10987588f, -0.19810048f, 0.13913558f, -0.22036225f, 0.01731712f, -0.24567917f, 0.18823676f, 
    0.24596499f, 0.00633645f, 0.06005592f, -0.27266526f, 0.16424276f, -0.65587091f, 0.23185976f, 0.26966259f, 
    0.17668322f, -0.15180412f, 0.22488464f, 0.05725249f, 0.07040745f, 0.10796574f, 0.08752489f, -0.26388133f, 
    -0.08341518f, 0.27531022f, -0.20773317f, -0.04264782f, -0.00089969f, -0.08023980f, 0.02312704f, -0.10968447f, 
    0.38239452f, 0.16345033f, -0.19158097f, 0.13796726f, 0.19596620f, 0.31009707f, 0.18249495f, -0.16044299f, 
    0.08178384f, 0.10175677f, 0.20163590f, -0.27500799f, 0.00782334f, 0.35315800f, -0.04048749f, -0.02477149f, 
    -0.30614489f, -0.20169596f, 0.42787725f, 0.08876432f, -0.04093517f, 0.17488810f, -0.00598589f, 0.20293832f, 
    0.28319618f, -0.09335150f, -0.13226140f, -0.32290724f, -0.04220721f, 0.40583134f, 0.18524149f, 0.12508723f, 
    0.23911056f, -0.04484124f, -0.10377282f, 0.15877376f, -0.08696974f, -0.20726550f, -0.25683090f, 0.03027295f, 
    0.02703235f, 0.10204697f, 0.00883655f, -0.31410772f, 0.31009394f, 0.12094062f, -0.17936184f, -0.08843157f, 
    -0.13932106f, 0.09656551f, 0.07790304f, 0.08074825f, 0.45316383f, -0.11742897f, -0.46151540f, -0.17520413f, 
    -0.09423914f, 0.06094007f, -0.02543830f, 0.24725467f, -0.05897336f, -0.08275656f, 0.02390891f, 0.21037941f, 
    0.04551121f, -0.16907977f, -0.36538923f, 0.21392819f, 0.26626605f, -0.10066856f, -0.19835246f, -0.20134394f, 
    -0.23452325f, -0.49689084f, -0.10093455f, -0.12634434f, 0.36142179f, 0.50762761f, 0.01420079f, 0.37003434f, 
    -0.05473631f, 0.14242627f, -0.21510765f, -0.07122918f, 0.05454528f, -0.23959281f, -0.30380520f, -0.27579147f, 
    0.00537236f, -0.18684985f, 0.23024964f, -0.23042379f, 0.00098900f, -0.02892873f, 0.13804775f, -0.01629937f, 
    0.13717835f, 0.06771520f, 0.13569985f, -0.02858806f, -0.18539184f, -0.00667396f, -0.07183933f, 0.04856746f, 
    0.08263679f, 0.07615866f, 0.10585225f, -0.51889127f, -0.10366546f, 0.18418878f, 0.08492226f, 0.10743335f, 
    0.31564200f, -0.17374747f, 0.07354180f, 0.03849676f, -0.18076725f, -0.09052166f, 0.36541727f, 0.09185395f, 
    -0.25318545f, -0.35484314f, 0.11328761f, 0.24545604f, 0.30130184f, 0.53895128f, -0.15443055f, 0.28505456f, 
    -0.46421558f, 0.17798504f, -0.05835193f, 0.00223238f, 0.23957963f, -0.17041051f, -0.18368714f, -0.37728569f, 
    0.20477197f, -0.44538102f, -0.07146649f, -0.24977712f, 0.20585969f, 0.16372630f, -0.19315708f, -0.07039474f, 
    -0.16065884f, -0.17816888f, -0.29267633f, 0.24914531f, 0.11114925f, -0.17794989f, -0.09198847f, 0.31227782f, 
    0.00097297f, -0.15841420f, -0.18071221f, 0.28696099f, -0.07274768f, -0.67520511f, 0.14188799f, 0.18114665f, 
    0.41053504f, -0.10643573f, -0.09161562f, -0.20959404f, 0.18912439f, -0.00141631f, 0.17450921f, -0.04558786f, 
    -0.05764183f, -0.13126716f, 0.17173889f, -0.20164838f, 0.03228980f, 0.07310823f, 0.14420569f, -0.12064829f, 
    -0.21677014f, 0.04467008f, -0.06498420f, -0.21014223f, -0.22627077f, -0.18680367f, -0.12832612f, 0.04165137f, 
    0.06336316f, -0.23609786f, 0.11738484f, 0.31998011f, -0.10435437f, -0.18414731f, 0.06654298f, 0.18000761f, 
    0.35480741f, 0.03801264f, -0.35261422f, 0.03864224f, 0.14378254f, 0.30085069f, 0.03887694f, -0.15316227f, 
    0.26056024f, -0.26716015f, -0.16756029f, 0.22499742f, 0.10072120f, -0.22163716f, 0.05334442f, 0.16079444f, 
    -0.35026938f, -0.12163869f, 0.10628337f, 0.18995683f, -0.08240578f, -0.23948909f, 0.23899849f, 0.15959541f, 
    0.25024092f, -0.24243113f, -0.08254457f, 0.22440951f, -0.05118265f, 0.57848710f, 0.02368537f, 0.18736504f, 
    -0.13834509f, 0.24064621f, 0.25709376f, 0.03122345f, -0.25471172f, 0.34012589f, -0.06244750f, -0.21677351f, 
    -0.06206561f, 0.36567447f, 0.17859758f, 0.22605689f, 0.27482018f, -0.08801962f, -0.23295759f, 0.09748300f, 
    0.02291018f, 0.09229901f, -0.38668963f, -0.15823664f, 0.06005863f, 0.10481944f, -0.11583109f, -0.34982738f, 
    -0.11116773f, -0.43109402f, -0.13395694f, -0.03053274f, -0.11353438f, 0.00424400f, 0.08341455f, 0.35498258f, 
    0.22608350f, 0.12440743f, 0.01703151f, -0.15224361f, 0.05268025f, 0.16430916f, 0.25329342f, 0.11317778f, 
    -0.25233677f, -0.42843014f, 0.06358729f, -0.57063299f, 0.30570826f, -0.45798215f, 0.02129672f, 0.25266603f, 
    0.39293671f, -0.20542224f, 0.31821546f, -0.06236253f, -0.00764147f, 0.00697446f, 0.19452775f, -0.55185968f, 
    0.13402063f, -0.08211160f, 0.01517433f, -0.38227946f, -0.35910007f, -0.25073248f, 0.14509779f, 0.34383178f, 
    0.23253378f, -0.18699192f, 0.41638386f, -0.00660627f, 0.22161928f, -0.44563496f, 0.11713858f, 0.17756097f, 
    -0.04790800f, -0.12918511f, -0.24661165f, -0.11387774f, 0.32664609f, 0.00912651f, -0.06784682f, 0.39058641f, 
    -0.08724174f, 0.08760067f, 0.33844218f, 0.14048991f, 0.12503435f, -0.22180159f, -0.22562738f, -0.34958825f, 
    -0.24285623f, -0.20717674f, -0.05461809f, 0.00852397f, -0.14537826f, -0.04935199f, -0.20849100f, -0.03736556f, 
    -0.14674038f, 0.14325127f, 0.04983824f, -0.14486083f, -0.08980674f, -0.03125364f, -0.06886020f, -0.23780903f, 
    -0.36421463f, 0.03510036f, -0.19828962f, 0.09638232f, 0.30327222f, 0.21068667f, -0.05735543f, 0.23157382f, 
    -0.38574174f, -0.01456513f, -0.07995122f, 0.19268395f, 0.06050120f, -0.30971494f, 0.17611077f, -0.18796818f, 
    -0.00406175f, 0.09547818f, 0.09155452f, 0.12161289f, -0.00144539f, -0.36472830f, 0.03184380f, 0.49429831f, 
    0.15162739f, 0.04487428f, -0.29556352f, -0.07996514f, -0.11824847f, -0.24662021f, 0.02627334f, 0.18872298f, 
    0.20657037f, -0.53564703f, -0.14408895f, -0.34192812f, 0.37648028f, 0.12942158f, 0.14488655f, 0.24500969f, 
    0.21898542f, 0.08903756f, 0.18239945f, -0.13760763f, -0.04083510f, -0.20748244f, -0.26704401f, -0.31097046f, 
    0.01596663f, 0.20244913f, 0.24140605f, 0.15535283f, 0.06048220f, 0.45495960f, -0.10850044f, -0.00926920f, 
    0.35392237f, 0.01596725f, -0.52367419f, 0.02313348f, -0.18228699f, -0.04807815f, 0.37120661f, -0.03689550f, 
    -0.16502704f, -0.39165813f, -0.19286184f, 0.23221754f, 0.04077008f, 0.38444501f, 0.15589981f, 0.39877218f, 
    -0.32669675f, 0.20786414f, -0.02231378f, -0.24003303f, 0.00099586f, -0.17276131f, -0.04480344f, 0.30961150f, 
    -0.26459581f, -0.24446769f, 0.15821253f, -0.07536878f, 0.23839705f, -0.21299860f, -0.00661425f, -0.12316642f, 
    0.15152147f, 0.15536754f, -0.18862371f, -0.10613690f, 0.18426332f, 0.26184672f, 0.03452482f, -0.27148247f, 
    0.23327456f, 0.28059289f, -0.10177388f, 0.20261361f, -0.32897213f, 0.06320935f, 0.23750366f, -0.00198597f, 
    -0.40999824f, 0.18019049f, 0.29472172f, -0.18641680f, 0.17514277f, 0.46217546f, -0.16543874f, -0.35319194f, 
    0.29870483f, -0.37018842f, -0.20503207f, 0.09929226f, 0.08073214f, 0.11753549f, 0.21439938f, -0.06921450f, 
    -0.44988066f, -0.14084324f, 0.54985011f, 0.01979245f, -0.01020856f, 0.16489524f, -0.03218089f, -0.07536979f, 
    -0.03783727f, -0.15278427f, -0.05540007f, 0.09968355f, 0.14203925f, -0.15793729f, -0.17798604f, 0.04479859f, 
    0.26673499f, 0.03603416f, -0.52868885f, 0.23200825f, 0.03778513f, -0.13965975f, -0.17718399f, 0.25829872f, 
    0.13395287f, -0.11176177f, -0.23461473f, -0.31191677f, 0.02844622f, 0.39789861f, -0.18636997f, -0.18291155f, 
    -0.01836639f, -0.06873905f, 0.45191038f, 0.10014312f, 0.13650151f, -0.04672043f, -0.14571029f, -0.10373975f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.42091945f, 0.28616667f, -0.01779861f, -0.18976022f, -0.36468363f, -0.27800405f, -0.01175728f, -0.22991323f, 
    0.44074288f, -0.08750652f, -0.18457958f, -0.33114484f, 0.09002937f, -0.17379241f, 0.49190110f, 0.05736316f, 
    0.13148060f, -0.12714416f, 0.13465828f, -0.26799721f, -0.02592750f, -0.16900693f, 0.40375784f, -0.02267350f, 
    0.28040260f, 0.10235818f, 0.06770851f, 0.03386864f, -0.27303138f, -0.18781334f, 0.09875601f, 0.15421049f, 
    0.37024450f, 0.01519901f, 0.31460348f, -0.11659011f, 0.57440966f, -0.00836581f, 0.40740106f, 0.17877917f, 
    -0.18979810f, 0.30263755f, 0.40152377f, 0.02361215f, 0.33741885f, -0.10795150f, -0.14972824f, 0.29259527f, 
    -0.12220646f, -0.02852297f, -0.26984701f, 0.15439433f, 0.36239082f, -0.07274511f, 0.25192469f, 0.05038623f, 
    0.37851781f, 0.18281382f, 0.28863794f, 0.03247328f, 0.28527755f, 0.40779021f, -0.22408144f, -0.20993119f, 
    0.28228021f, -0.07955729f, 0.20453434f, -0.40161589f, -0.00435155f, 0.42556977f, -0.02946117f, -0.32669771f, 
    0.25203028f, 0.20906599f, 0.14796776f, -0.30054638f, -0.05331779f, 0.12982523f, 0.04614115f, -0.18121938f, 
    -0.10449698f, -0.29496703f, -0.08907875f, 0.28642979f, -0.24633779f, 0.36470950f, 0.05832257f, -0.23891065f, 
    -0.38697666f, 0.18675321f, -0.14098337f, 0.37594345f, 0.17839783f, 0.21233153f, -0.15570298f, 0.10757555f, 
    -0.16071804f, -0.31538841f, -0.10398416f, 0.29489294f, -0.18707880f, 0.29481196f, 0.48426509f, -0.17356695f, 
    -0.12990525f, 0.10134464f, 0.52253962f, -0.34364152f, -0.06249395f, 0.21795599f, 0.39342105f, 0.48368865f, 
    0.14927880f, 0.20996377f, 0.26646906f, -0.11493038f, 0.04699637f, 0.02549440f, 0.15721978f, -0.17749086f, 
    0.34918812f, -0.31946895f, 0.19131023f, -0.05067183f, -0.02306241f, 0.35149255f, 0.25328112f, 0.39667356f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03579810f, -0.00131899f, -0.02923724f, -0.09950081f, -0.12713741f, -0.23058096f, -0.07261123f, 0.01304884f, 
    -0.16546188f, -0.05813282f, -0.05534424f, 0.34537733f, -0.06190098f, -0.11689302f, 0.09073379f, 0.06455606f, 
    -0.13410825f, 0.14213909f, -0.01681586f, -0.27231750f, -0.07966513f, 0.12343302f, -0.17589064f, -0.01878409f, 
    -0.11271561f, 0.09309295f, -0.21397582f, -0.04241614f, -0.05530262f, 0.21183248f, -0.07626096f, 0.15817890f, 
    0.29156151f, -0.07493187f, 0.35924762f, -0.22498043f, 0.19330376f, -0.09410635f, 0.14650875f, 0.15623283f, 
    -0.02559390f, -0.12052768f, -0.21719831f, 0.22895882f, 0.06413447f, 0.17199141f, 0.03740491f, -0.16136494f, 
    0.32338315f, 0.33867824f, 0.02270152f, -0.02634013f, 0.16015130f, 0.18349116f, -0.09054059f, -0.27858630f, 
    -0.00540869f, 0.01465841f, -0.11156381f, 0.14647748f, 0.25376534f, 0.02464114f, 0.36487907f, 0.07406611f, 
    -0.08455418f, -0.19357958f, -0.05366718f, 0.16183466f, 0.39232892f, -0.15777105f, 0.23438308f, -0.12512231f, 
    0.04817943f, -0.25124753f, -0.21253256f, 0.43847400f, 0.13334779f, 0.31602597f, 0.12629591f, 0.16008127f, 
    0.33579618f, 0.18393330f, -0.07120179f, 0.22086133f, 0.07706704f, -0.17720483f, -0.09785631f, 0.03328446f, 
    -0.31361768f, -0.10436233f, -0.20492317f, -0.09193696f, 0.24976398f, -0.02861588f, 0.01999200f, 0.05567533f, 
    0.04104685f, 0.07890607f, -0.03973826f, -0.32075870f, -0.09598149f, -0.14411755f, 0.11240683f, -0.01063733f, 
    0.06686272f, 0.16526379f, -0.09379980f, 0.04521613f, -0.08416522f, 0.08866215f, 0.02199270f, -0.05225436f, 
    -0.03635329f, 0.28186253f, 0.26456919f, -0.39121038f, -0.14172274f, -0.05051390f, 0.09458338f, -0.27002352f, 
    -0.10460293f, -0.01070046f, 0.01327876f, 0.29175729f, -0.03988052f, -0.12474545f, 0.03670285f, -0.07619461f, 
    0.04109801f, 0.01773931f, -0.01575360f, 0.05695122f, -0.03542772f, 0.00058160f, 0.04527533f, -0.06109901f, 
    -0.04630255f, -0.08725180f, -0.02595559f, 0.07172501f, 0.00666493f, -0.08956402f, -0.08493470f, 0.08055232f, 
    0.01625232f, 0.01892309f, 0.02182668f, -0.00400437f, -0.08633995f, -0.07012514f, -0.09347715f, 0.02547076f, 
    -0.00289240f, 0.00762677f, -0.05376447f, -0.01790843f, -0.06668726f, 0.06072992f, -0.00971792f, 0.06767686f, 
    -0.09057657f, 0.00970140f, 0.00193900f, -0.07285204f, 0.00092297f, 0.07003129f, -0.03096494f, 0.03630713f, 
    0.05772940f, -0.01470848f, -0.07196658f, 0.06120737f, -0.05280855f, -0.00311001f, 0.02707582f, 0.02345505f, 
    -0.06867252f, -0.03071371f, 0.07184567f, 0.06451778f, 0.06309589f, 0.01588382f, -0.07325039f, 0.03329002f, 
    0.08349305f, 0.07085539f, -0.08506794f, -0.04096569f, -0.00842667f, -0.05659936f, 0.01659442f, -0.02389861f, 
    0.04022213f, 0.01833889f, -0.08258484f, 0.01315389f, 0.03826419f, -0.03764381f, 0.02025717f, -0.07577734f, 
    0.04355798f, -0.07955266f, 0.07050551f, -0.06136953f, -0.03360603f, -0.06355762f, -0.08024906f, -0.08948079f, 
    -0.07504669f, 0.02005526f, -0.05462636f, 0.04230886f, 0.02713890f, -0.01922437f, -0.07388686f, -0.01339803f, 
    -0.06848156f, 0.01484756f, 0.05214239f, -0.06679202f, -0.06305127f, 0.00976027f, -0.04564305f, -0.07551885f, 
    -0.01461922f, -0.00376015f, 0.02103080f, -0.05672926f, -0.03869376f, -0.04150434f, -0.04550162f, -0.00255226f, 
    -0.00378591f, 0.06467424f, -0.03588207f, -0.03952300f, -0.05606202f, 0.03313561f, -0.06241326f, -0.08099816f, 
    0.00831922f, -0.03465069f, -0.06279867f, -0.04447534f, -0.07697838f, 0.00812699f, 0.00983090f, -0.02299925f, 
    -0.02458810f, 0.02844010f, -0.03256607f, -0.05201248f, 0.04273285f, -0.01589683f, 0.01927178f, -0.03655859f, 
    0.21580884f, 0.18197599f, 0.33610731f, -0.10009705f, -0.05234119f, 0.30749756f, 0.12744732f, 0.22751519f, 
    0.13412523f, -0.37056032f, 0.01831354f, -0.58639920f, 0.31304795f, -0.13539988f, 0.03527484f, -0.10489270f, 
    0.10581232f, 0.06684602f, 0.20916902f, 0.10960291f, -0.19281450f, -0.09707015f, 0.39497104f, 0.08906854f, 
    0.10329734f, 0.58528078f, 0.12674724f, -0.07940845f, 0.05595477f, 0.15576826f, -0.07188480f, 0.15222616f, 
    -0.58137715f, 0.02269022f, -0.73451912f, -0.09227693f, -0.19005235f, 0.01966379f, -0.12015703f, -0.20713857f, 
    -0.10323747f, -0.13447791f, 0.10286073f, -0.25655288f, -0.10937920f, -0.08430545f, 0.02762264f, 0.14509106f, 
    0.57152623f, -0.65304774f, -0.02901572f, 0.11566979f, -0.15153700f, 0.08372647f, -0.02768424f, 0.16039595f, 
    -0.11411159f, -0.04272165f, 0.12905008f, -0.08626934f, -0.11018089f, -0.10184802f, -0.40700173f, -0.39956188f, 
    0.10332092f, 0.10419641f, 0.18162538f, 0.07069285f, -0.06078299f, 0.05695881f, -0.04841772f, -0.23338398f, 
    -0.07057161f, -0.13901517f, 0.03754428f, 0.01733175f, 0.24032576f, 0.09706351f, 0.07228997f, 0.07927407f, 
    -0.94134361f, -0.22005409f, -0.24767408f, 0.21965593f, -0.07991940f, 0.25436202f, -0.39446598f, 0.05226229f, 
    0.00372740f, 0.33662844f, 0.01374673f, 0.07297427f, 0.13016771f, 0.16291697f, -0.02223034f, 0.01341483f, 
    0.00684050f, -0.07823829f, 0.07140260f, 0.07533096f, 0.04114423f, 0.01463076f, -0.68923116f, 0.05948549f, 
    -0.09258999f, -0.40017128f, 0.05884520f, -0.02186099f, -0.03323745f, -0.00243784f, 0.00052043f, 0.21387719f, 
    0.01467912f, 0.03919601f, 0.07373954f, 0.16894245f, 0.07127715f, -0.03524531f, -0.33563191f, -0.28801620f, 
    -0.07491235f, -0.01239293f, -0.11735883f, -0.49427387f, 0.15669705f, 0.34050003f, -0.22446440f, 0.33224964f, 
    -0.07577771f, -0.09497155f, 0.51747721f, -0.10070702f, -0.11140494f, -0.06660578f, -0.06692038f, -0.34686995f, 
    -0.08008503f, -0.19908379f, -0.26799089f, 0.03401262f, -0.18616024f, 0.01512862f, 0.16902691f, -0.03137487f, 
    0.24798954f, 0.09706302f, 0.07947873f, -0.24910058f, 0.04534409f, 0.04711607f, -0.06656432f, 0.14739445f, 
    0.09934775f, -0.25033861f, -0.22824183f, 0.00230426f, -0.00365818f, 0.12121564f, -0.00952682f, 0.25036088f, 
    -0.18291025f, -0.02438366f, -0.03704145f, -0.12616879f, 0.13298722f, 0.06571478f, 0.17597306f, -0.02968480f, 
    0.01813803f, 0.16335221f, 0.06970237f, -0.02771322f, 0.01483107f, -0.11845002f, 0.07850405f, 0.10824536f, 
    0.08423100f, 0.31325760f, -0.04499608f, 0.13038111f, 0.28516138f, -0.12998043f, 0.20888911f, 0.09070610f, 
    0.04200493f, 0.03365875f, -0.05260868f, 0.05378275f, -0.02239614f, 0.19443731f, -0.07295954f, 0.28574488f, 
    -0.01022518f, 0.04393807f, -0.04848931f, -0.19978756f, 0.15220310f, 0.13930900f, 0.00406575f, -0.21375038f, 
    0.07463796f, -0.03747571f, -0.12500499f, -0.26600373f, -0.01582194f, 0.22073466f, -0.09766662f, -0.01106343f, 
    0.05335825f, -0.21111284f, 0.09589767f, 0.08086962f, -0.14112081f, 0.08719375f, 0.40088728f, 0.04887075f, 
    -0.08030256f, 0.04656400f, -0.48199320f, -0.01020102f, 0.03478665f, 0.03568952f, -0.01466272f, -0.04347240f, 
    -0.09138640f, -0.10010367f, 0.16021082f, 0.11568679f, -0.60322773f, -0.20835485f, -0.25303757f, -0.02377933f, 
    0.13533480f, -0.16099682f, 0.17556351f, -0.11746216f, -0.03149012f, -0.02459064f, 0.11491359f, 0.28119919f, 
    -0.18068980f, 0.22394165f, -0.21328463f, -0.13034283f, -0.31389752f, 0.02085864f, 0.08569336f, -0.11181051f, 
    0.13473845f, -0.10014455f, 0.38178825f, -0.25165537f, -0.12396685f, 0.08242317f, 0.01581703f, 0.07836635f, 
    0.25862920f, 0.18699931f, -0.56004786f, -0.04288896f, -0.05976263f, 0.59816366f, 0.08596698f, 0.44631153f, 
    -0.07741572f, -0.02721700f, 0.04844405f, 0.02568385f, 0.30785874f, 0.21651253f, 0.07803307f, -0.00704917f, 
    0.68846071f, 0.19249609f, 0.22878064f, -0.22842902f, 0.12493637f, 0.19978249f, -0.10824587f, 0.17674032f, 
    0.03259879f, 0.30073211f, 0.26847571f, -0.03439349f, -0.14692143f, 0.10033906f, 0.04474644f, 0.09881886f, 
    -0.08987740f, -0.06193054f, -0.07857138f, -0.14140558f, -0.03060219f, 0.08765503f, -0.67031354f, 0.05721348f, 
    -0.04656931f, 0.10548025f, 0.20397328f, -0.02693892f, -0.07362824f, -0.00378480f, 0.08769287f, -0.20678955f, 
    0.02074117f, -0.46260065f, 0.05930123f, -0.30373907f, -0.01775954f, -0.07429971f, -0.01884991f, 0.01223427f, 
    -0.04340827f, -0.16361465f, -0.07345928f, -0.07418223f, -0.15072140f, 0.13264188f, -0.11785099f, 0.01168110f, 
    -0.32703310f, -0.39555493f, -0.25170618f, -0.12201174f, -0.07770660f, -0.22020119f, 0.01546482f, -0.05014351f, 
    0.00391825f, 0.03613508f, 0.06934927f, -0.02441960f, 0.04721521f, -0.03801123f, -0.00278696f, 0.18248683f, 
    0.03375875f, 0.01155672f, -0.18953380f, 0.05062646f, 0.20456947f, 0.28781399f, -0.30281556f, 0.06866809f, 
    -0.15481570f, -0.48847818f, 0.47232777f, 0.17250921f, 0.16687715f, -0.08006332f, 0.00742182f, 0.03652620f, 
    0.30068669f, 0.16993614f, -0.08560790f, 0.14658040f, 0.19310616f, 0.11298853f, -0.03977423f, -0.00320637f, 
    0.24651067f, -0.23969102f, -0.21252325f, 0.25750750f, -0.07949092f, 0.04773636f, -0.14074022f, -0.31043825f, 
    -0.13802280f, 0.23143625f, 0.29536855f, 0.54703218f, 0.32427791f, -0.00267325f, -0.10161849f, 0.13891813f, 
    0.05165204f, -0.27704668f, -0.28046554f, -0.03657821f, -0.07144938f, -0.18582860f, 0.19220565f, 0.11214218f, 
    0.16406097f, -0.00065851f, -0.18775009f, -0.15128234f, 0.30125061f, 0.09118489f, 0.09355765f, -0.12915711f, 
    -0.21533875f, -0.25738260f, -0.06170135f, 0.01120167f, -0.37382379f, -0.11194853f, -0.21140768f, 0.13217589f, 
    0.11537708f, 0.52086014f, -0.50874895f, 0.44464833f, -0.06380228f, -0.20962410f, 0.03548640f, -0.01048953f, 
    0.12320739f, 0.56800973f, -0.13084777f, -0.07667205f, -0.45031881f, 0.28564042f, -0.04167622f, -0.00297626f, 
    0.13537914f, 0.03711826f, 0.16002733f, -0.20891902f, 0.12668879f, 0.42132834f, -0.02504547f, 0.19037309f, 
    -0.05086707f, -0.29968977f, -0.15480910f, 0.15588598f, 0.05394735f, -0.06229702f, -0.05288443f, 0.05570845f, 
    0.02303168f, -0.00757509f, 0.03086206f, 0.14399509f, -0.07740806f, 0.00835505f, -0.00508986f, -0.04124017f, 
    -0.00268081f, -0.10898700f, -0.04056679f, -0.24033894f, 0.07734170f, 0.05350298f, 0.20342614f, 0.07721197f, 
    -0.25280327f, 0.27727261f, -0.09565401f, -0.11483417f, 0.25240526f, -0.06056155f, 0.17979324f, -0.28171504f, 
    -0.12144643f, 0.02330331f, -0.25619674f, 0.11568161f, -0.12511113f, 0.00757655f, 0.00708671f, -0.34955975f, 
    0.22591828f, 0.10352170f, -0.12085751f, 0.26021931f, 0.07536525f, -0.05518744f, -0.57813597f, -0.03659036f, 
    -0.22397298f, 0.09597167f, 0.06310857f, 0.03145611f, 0.21275702f, -0.12899195f, 0.03930271f, 0.08436797f, 
    -0.03218364f, -0.15440157f, -0.20417584f, 0.00871149f, -0.16649613f, 0.08373149f, 0.51495171f, -0.00632042f, 
    -0.07023200f, 0.27043712f, -0.08603075f, 0.25407901f, -0.02240943f, 0.15560938f, 0.16834986f, 0.21317226f, 
    0.04282837f, 0.15208240f, 0.58147430f, -0.12128821f, 0.12591235f, 0.04940759f, 0.06928010f, 0.20588990f, 
    0.16446169f, 0.30177492f, 0.03384452f, 0.14344603f, -0.19076213f, 0.08824394f, 0.03181733f, -0.08581399f, 
    0.21306083f, 0.30900422f, 0.07823122f, 0.06919210f, 0.15243703f, -0.12383545f, -0.00821016f, 0.09914105f, 
    -0.13504755f, -0.27226150f, 0.07634111f, -0.19395906f, -0.15681258f, -0.04756141f, -0.11560114f, 0.12954812f, 
    -0.04113616f, -0.16275871f, -0.57346648f, 0.00271890f, 0.06244171f, 0.01476951f, -0.22833014f, -0.23602682f, 
    0.02073105f, 0.16834453f, -0.13807714f, -0.00841756f, -0.07639236f, 0.01586926f, 0.04091827f, 0.12958626f, 
    0.02348249f, 0.08182864f, 0.02880171f, 0.01653790f, 0.01199245f, 0.30671525f, 0.02030366f, 0.05559316f, 
    -0.02350439f, -0.01466169f, 0.14216453f, -0.03881808f, 0.20644173f, -0.05839182f, 0.02407710f, 0.23378724f, 
    -0.20204479f, -0.38702044f, -0.08100957f, -0.05209184f, 0.19830725f, -0.08883627f, 0.07704567f, 0.05183299f, 
    0.11517399f, 0.11455707f, -0.03598934f, -0.23321098f, -0.09100199f, 0.17098695f, 0.00416386f, -0.02364700f, 
    -0.19942687f, -0.14817481f, -0.13775811f, -0.09382639f, 0.16764691f, 0.03424502f, 0.11853121f, 0.11509048f, 
    -0.03905753f, 0.16452517f, 0.09883618f, -0.08558414f, -0.41544253f, 0.00456785f, -0.01921926f, -0.31349009f, 
    0.06893212f, -0.07842602f, -0.02248091f, 0.17534658f, 0.13500112f, 0.00219383f, 0.14978375f, -0.07926524f, 
    -0.30561978f, 0.11392715f, -0.18628123f, 0.10259445f, 0.08116121f, -0.11298700f, -0.00718898f, 0.02867116f, 
    0.13326856f, -0.07781731f, -0.17481813f, -0.02821712f, -0.34596446f, 0.19037646f, 0.11832995f, -0.08524702f, 
    0.00142652f, 0.02231136f, 0.08577437f, 0.20538163f, -0.03743742f, 0.23070589f, 0.18186465f, -0.22679807f, 
    0.13369992f, 0.18769903f, 0.43024844f, 0.11325344f, 0.06334670f, -0.04228538f, 0.13169174f, 0.08702713f, 
    0.08950930f, 0.03977526f, 0.19158870f, 0.02491564f, -0.13128273f, -0.17991546f, 0.34939998f, -0.23802814f, 
    -0.01357131f, -0.04530632f, -0.03371906f, -0.05078509f, -0.02444506f, -0.00078016f, -0.01008710f, -0.02705506f, 
    -0.05887524f, 0.07891984f, 0.04541444f, 0.02322316f, 0.02063526f, -0.02628072f, 0.04872798f, 0.05765206f, 
    0.01974843f, -0.01054869f, -0.05543946f, 0.02598812f, -0.08520584f, -0.08180498f, 0.07451316f, -0.03487698f, 
    -0.01028878f, -0.01600333f, 0.07494239f, 0.04635378f, -0.03666546f, 0.03409662f, 0.08508246f, -0.03533046f, 
    0.05383395f, -0.02906073f, -0.05134979f, 0.00423149f, 0.04749624f, 0.06611127f, -0.07405023f, -0.08526441f, 
    0.01743484f, 0.02438707f, -0.03278731f, 0.06111170f, 0.05023025f, -0.07840703f, 0.07368053f, -0.00677531f, 
    0.02054262f, -0.00419123f, -0.05637102f, 0.07044104f, 0.03042501f, 0.04211241f, -0.09875374f, -0.08081926f, 
    -0.03418527f, -0.05874635f, 0.02427363f, 0.05371070f, -0.04944612f, 0.03978240f, -0.01989670f, -0.03343835f, 
    0.07242160f, -0.08401378f, -0.08046661f, 0.01780575f, -0.02556875f, -0.06683979f, 0.03285064f, -0.09349116f, 
    0.05714869f, 0.05737364f, -0.01622566f, 0.04347994f, -0.11213283f, -0.03045771f, -0.01683665f, -0.08341981f, 
    -0.08938813f, 0.02150058f, -0.06616287f, -0.00107625f, 0.05787478f, -0.02644324f, -0.06534089f, 0.03630325f, 
    0.00897885f, 0.01327669f, 0.07715657f, 0.04341582f, -0.05981932f, -0.00747014f, -0.06997365f, 0.08098084f, 
    -0.06689852f, -0.09956945f, -0.01323819f, -0.09813752f, 0.05145344f, -0.07725228f, -0.07061689f, -0.02181267f, 
    0.01145438f, -0.02373618f, -0.00276551f, 0.02623724f, -0.04877236f, -0.01250327f, 0.02580533f, -0.08015531f, 
    -0.03027709f, -0.06104401f, 0.00868780f, 0.04756882f, 0.04049442f, 0.00560933f, -0.06302667f, 0.03713382f, 
    -0.03483318f, -0.08931686f, 0.08289390f, 0.06292311f, 0.03962606f, -0.07952668f, 0.03430079f, -0.08953174f, 
    -0.05556044f, 0.04885845f, -0.10750470f, 0.00279996f, -0.07515796f, -0.09816740f, -0.09113538f, 0.00493962f, 
    0.01496858f, -0.01818105f, -0.06019871f, -0.09388389f, -0.00085827f, 0.00253940f, 0.03018434f, -0.08935823f, 
    -0.03057185f, 0.08116981f, 0.03648635f, -0.03647968f, -0.04808979f, -0.08810465f, -0.02987183f, 0.02404693f, 
    -0.00335652f, 0.02371710f, 0.03617159f, -0.00995808f, -0.03958343f, -0.08443853f, 0.04402960f, 0.01252560f, 
    -0.00222717f, -0.03318325f, -0.02852589f, -0.07430570f, -0.01819918f, -0.03955672f, 0.04625465f, 0.01756664f, 
    -0.02146554f, -0.06789281f, -0.03018724f, -0.04232541f, 0.07061049f, -0.07470616f, 0.00706400f, -0.02829282f, 
    -0.04203974f, 0.00676915f, 0.08147154f, -0.04278884f, -0.06423558f, 0.00355540f, 0.02229892f, -0.06346987f, 
    0.00184591f, -0.06076074f, 0.02515842f, 0.00550069f, -0.00701208f, 0.07523743f, -0.07469425f, -0.01763740f, 
    -0.02017171f, -0.06830785f, -0.10206573f, -0.11721209f, 0.05501965f, -0.01469351f, -0.05714191f, -0.02862013f, 
    0.07172447f, -0.08250112f, 0.03454643f, -0.10583437f, -0.03529184f, 0.05728807f, 0.02232981f, -0.09209823f, 
    0.03936499f, 0.03942848f, 0.01395499f, -0.08951502f, -0.00977278f, -0.01625706f, 0.02828721f, 0.01045392f, 
    -0.01148435f, 0.00256841f, 0.04228311f, 0.01704803f, 0.02896732f, 0.02280662f, -0.08665688f, -0.07185636f, 
    0.05131430f, -0.00330369f, -0.06398246f, 0.04106904f, 0.01682337f, 0.04307027f, -0.01766798f, -0.01657929f, 
    -0.08637547f, -0.10054062f, 0.01585915f, 0.02623248f, -0.04604248f, -0.05034772f, -0.07969881f, -0.09146983f, 
    -0.00644669f, -0.00570472f, 0.05722292f, 0.06604630f, -0.05048528f, -0.06197036f, -0.09701797f, -0.10246144f, 
    -0.07260667f, -0.04570978f, 0.03370461f, 0.03228483f, -0.04693421f, 0.06473452f, 0.06378257f, 0.01707863f, 
    0.16726522f, 0.03487818f, -0.30010971f, -0.01071611f, 0.03328351f, -0.09703364f, -0.11179531f, -0.25930667f, 
    -0.32776257f, -0.16445535f, 0.12717764f, 0.14268315f, -0.24130759f, 0.10354517f, -0.05626844f, 0.09689727f, 
    0.24766044f, 0.22984026f, -0.26917404f, -0.64421332f, -0.00630583f, 0.11056452f, -0.22392212f, -0.09720794f, 
    0.08702075f, 0.20806785f, -0.00544052f, -0.06178633f, -0.17498009f, 0.08247942f, 0.03830306f, 0.21489355f, 
    -0.04144655f, 0.06581340f, 0.11054496f, -0.16095649f, 0.12566343f, 0.15854056f, 0.20978774f, 0.32862881f, 
    -0.06558996f, 0.10575490f, -0.23731935f, -0.11749429f, 0.09743587f, 0.17932615f, 0.01470481f, -0.09914406f, 
    0.19486938f, -0.05588067f, 0.03908502f, -0.04328757f, 0.14384867f, -0.00739006f, 0.07470354f, -0.06956130f, 
    -0.11347646f, 0.13197386f, -0.09119847f, -0.10921709f, 0.12487557f, 0.19509825f, 0.31380552f, 0.22316118f, 
    -0.22455159f, -0.24292041f, -0.11467212f, 0.03496851f, 0.22660166f, 0.01426981f, 0.19083062f, 0.03272648f, 
    -0.02506450f, 0.01754164f, -0.06734172f, 0.18522942f, -0.09506562f, 0.21418317f, 0.06980234f, -0.02533457f, 
    0.40418836f, -0.04546402f, -0.06340663f, 0.19375950f, -0.07774758f, 0.04983981f, -0.08856171f, 0.07777864f, 
    -0.45256716f, -0.08318032f, -0.05012771f, -0.00296420f, 0.28561273f, 0.01329421f, -0.01586879f, 0.05840976f, 
    0.07825205f, 0.05951827f, -0.09517578f, -0.16810079f, -0.21395035f, 0.00159393f, -0.12514170f, 0.00397689f, 
    0.14310019f, -0.14861585f, 0.03204564f, 0.12585160f, -0.01867756f, 0.17385580f, 0.10951303f, -0.06867237f, 
    0.12315444f, 0.30422109f, 0.19007486f, -0.27706397f, 0.10526839f, 0.07168108f, 0.11526666f, 0.11253173f, 
    0.00906415f, -0.08928660f, 0.20784922f, -0.03538442f, -0.11520155f, -0.07249802f, 0.17227773f, -0.16147584f, 
    0.18611546f, 0.16492040f, 0.07504434f, -0.26159942f, -0.56555426f, 0.13893738f, 0.11723543f, -0.21144731f, 
    0.38104907f, 0.21267213f, -0.21098246f, 0.05934543f, -0.05836520f, -0.42307654f, -0.01410207f, 0.10076910f, 
    -0.16631727f, 0.08737884f, -0.24919567f, -0.33473477f, -0.06107727f, -0.06934641f, 0.15636276f, -0.11559485f, 
    0.05181457f, 0.02523671f, 0.10458314f, 0.05971984f, -0.43517345f, -0.08360627f, -0.01546212f, 0.04230860f, 
    0.22947502f, -0.06937409f, 0.08132608f, -0.49494657f, 0.21400528f, 0.13147362f, 0.14357555f, 0.11398736f, 
    -0.02922294f, -0.28055158f, -0.07538788f, 0.08901778f, 0.30718037f, -0.22596917f, -0.04752525f, 0.30389029f, 
    -0.32964069f, -0.12772623f, 0.05048836f, -0.10594647f, 0.26399726f, 0.09857125f, -0.34512666f, 0.07872965f, 
    0.00356887f, 0.15620720f, 0.18105929f, -0.23980182f, 0.09164631f, -0.06247449f, 0.11926781f, 0.22210698f, 
    -0.19165979f, -0.05818886f, 0.02834596f, -0.33201343f, 0.06359807f, -0.25002268f, -0.00094261f, -0.52856243f, 
    0.22244893f, -0.12657939f, -0.13795771f, 0.04382126f, -0.19422644f, -0.10725147f, 0.01478149f, -0.22650373f, 
    -0.02010722f, 0.17986308f, 0.18135710f, -0.04667512f, 0.05875347f, 0.29490101f, -0.07217935f, -0.06548057f, 
    0.02195724f, -0.11765864f, 0.51225799f, 0.17722699f, -0.10231574f, 0.07292411f, -0.09320943f, -0.05230473f, 
    -0.04569850f, -0.12851591f, -0.23901294f, -0.02934449f, 0.13614307f, 0.14158915f, 0.73960644f, 0.05670193f, 
    -0.20146413f, 0.59635860f, 0.23546961f, -0.04672636f, 0.01134981f, 0.01573443f, 0.09070614f, -0.07333980f, 
    0.12102692f, 0.01332499f, 0.14068946f, -0.15837440f, 0.36610296f, -0.04644872f, 0.34516123f, -0.29083061f, 
    0.26110801f, -0.13050568f, 0.21165662f, 0.03567369f, -0.27464649f, 0.07958124f, 0.03312181f, -0.03958760f, 
    -0.18521240f, 0.14938988f, -0.11582945f, -0.04525942f, -0.05928504f, 0.14617704f, 0.01545639f, 0.24396940f, 
    0.17027536f, 0.26591030f, -0.02226708f, 0.41793138f, 0.11138225f, 0.02620181f, -0.20311083f, -0.00468185f, 
    0.29558957f, 0.54164332f, 0.31810790f, -0.16068423f, 0.13914263f, 0.12399411f, 0.14413694f, 0.29618916f, 
    0.05343762f, -0.12177404f, 0.25746310f, -0.02734991f, 0.00617004f, -0.03089563f, 0.06719791f, -0.34048465f, 
    -0.15115191f, 0.05978964f, -0.51962912f, 0.01275738f, 0.06140809f, 0.19435404f, -0.10508124f, 0.15663514f, 
    -0.03926110f, -0.01606103f, -0.08986759f, -0.61081660f, -0.10101165f, -0.01618096f, -0.05876805f, 0.08161493f, 
    -0.08190974f, -0.40533596f, -0.01529125f, 0.09013300f, -0.03163892f, -0.09111502f, 0.04658346f, 0.02892589f, 
    0.01252629f, -0.05090238f, 0.11852308f, 0.05899262f, -0.04997799f, -0.09608913f, 0.12160265f, 0.35213166f, 
    0.09517992f, 0.04426369f, 0.14755285f, -0.01202852f, -0.29079124f, 0.03011764f, -0.16317756f, 0.09006034f, 
    -0.02980386f, -0.01379653f, 0.10282703f, -0.02305675f, 0.28004149f, -0.18512575f, 0.01816314f, -0.09094159f, 
    -0.06272143f, 0.02223778f, 0.29238719f, -0.33206505f, 0.02699301f, -0.02290556f, -0.04160376f, -0.03185590f, 
    0.19692425f, -0.36301297f, 0.04539057f, 0.20317970f, -0.26865149f, 0.16511230f, 0.10429429f, -0.05262778f, 
    0.18546465f, -0.01920180f, 0.19458906f, 0.09443003f, 0.18862972f, -0.01028252f, -0.02178145f, -0.06796468f, 
    0.09156138f, 0.23619078f, -0.17060086f, -0.05001084f, -0.03706859f, -0.27711561f, -0.02493709f, 0.02984871f, 
    0.05374952f, -0.29845482f, -0.50062305f, 0.20882782f, 0.21215555f, -0.03094386f, 0.22372104f, 0.09148400f, 
    0.02360411f, -0.10694099f, 0.00790305f, -0.42451999f, 0.15962754f, 0.09506806f, -0.14738019f, 0.00987963f, 
    0.12979795f, -0.04221863f, -0.49661404f, 0.10803021f, -0.22670527f, 0.47607046f, 0.21399245f, -0.40988982f, 
    0.12257824f, 0.06196385f, -0.12250511f, -0.07820148f, 0.30369949f, 0.22229464f, 0.28016531f, -0.09964357f, 
    0.25967625f, 0.09594840f, 0.24143086f, -0.14914590f, 0.18740100f, 0.03302527f, 0.08577625f, 0.18295372f, 
    0.06920300f, -0.17802712f, 0.11273693f, -0.03257911f, 0.00332129f, -0.12204048f, 0.06575206f, -0.00668085f, 
    -0.05422951f, 0.03022164f, -0.16004501f, -0.21316154f, -0.14740659f, -0.37433714f, -0.50566024f, -0.23365232f, 
    -0.06313441f, 0.19789435f, 0.06362653f, 0.05175726f, -0.04089526f, -0.31980348f, -0.04002412f, -0.02388997f, 
    0.28526992f, -0.03912154f, -0.04955187f, 0.07899003f, 0.24764915f, -0.12983023f, 0.06133135f, 0.24701020f, 
    -0.10488214f, -0.00175730f, 0.01615027f, 0.07276280f, -0.16069645f, 0.21320948f, -0.48441660f, 0.17656760f, 
    -0.04746069f, -0.19621749f, 0.01880612f, -0.18176334f, -0.01712799f, -0.03175692f, -0.23492081f, -0.15829562f, 
    0.17647640f, 0.22637738f, 0.02080774f, -0.17757773f, 0.15473831f, 0.04362934f, 0.04643625f, 0.27953240f, 
    -0.21972288f, -0.08561739f, -0.00777222f, 0.01242881f, -0.14988795f, 0.32280833f, -0.18005051f, 0.02405852f, 
    -0.05939098f, -0.39660189f, 0.44666448f, 0.19386549f, -0.01802378f, -0.09237446f, -0.10631048f, -0.05101610f, 
    0.10338890f, -0.08230989f, 0.09666304f, 0.22327082f, 0.37345564f, -0.25455227f, -0.29502359f, -0.03169738f, 
    0.40587774f, 0.07688458f, 0.04007633f, 0.06854407f, -0.00886047f, -0.00107670f, -0.10277949f, -0.19767459f, 
    -0.22047627f, 0.06537110f, -0.76385969f, 0.28878143f, 0.02757495f, 0.06163171f, 0.01549215f, 0.06229749f, 
    0.12743530f, 0.26859504f, -0.11839659f, -0.37512860f, -0.28656828f, -0.14408247f, 0.10853461f, 0.08728058f, 
    0.02423047f, 0.14511833f, 0.45483026f, -0.18916547f, -0.17117365f, 0.32125747f, 0.23561944f, -0.13158084f, 
    -0.00855557f, -0.13656880f, -0.13852455f, -0.25856772f, 0.07197867f, -0.09541314f, -0.05684134f, -0.15256473f, 
    0.08496299f, 0.12571542f, 0.33868662f, -0.01620226f, -0.10213070f, -0.12966435f, 0.34638652f, 0.20028685f, 
    0.10442992f, 0.32278112f, 0.13033651f, 0.04918732f, 0.03742889f, 0.43126413f, 0.04681439f, 0.02301626f, 
    -0.35372224f, -0.07111872f, -0.53671789f, -0.14372908f, -0.07480668f, 0.18033427f, -0.07325113f, -0.31695983f, 
    0.06834646f, -0.11560562f, 0.04191765f, -0.20584813f, -0.14782505f, -0.01459549f, 0.00682932f, 0.15377249f, 
    0.18194316f, -0.69530821f, -0.05306422f, 0.11534705f, -0.06603380f, 0.06987840f, -0.11579043f, 0.01353176f, 
    -0.18823986f, -0.21241558f, 0.11111419f, 0.07833602f, -0.02243374f, -0.17861144f, -0.15150930f, -0.05820302f, 
    0.17587091f, 0.12892751f, 0.10988862f, 0.00136467f, -0.13570610f, 0.04545581f, -0.19708042f, -0.24671921f, 
    -0.03002177f, -0.08579519f, -0.18285416f, 0.14039198f, 0.15994051f, 0.21577375f, -0.04503868f, -0.09135372f, 
    -0.56143165f, -0.03890476f, -0.08348185f, 0.10738229f, -0.07124660f, 0.17136581f, -0.55868977f, -0.06390646f, 
    0.13380682f, 0.53158963f, 0.02966496f, 0.07132974f, 0.06243443f, 0.12094089f, 0.09031712f, -0.03351961f, 
    0.05091181f, -0.31017065f, 0.12861241f, -0.09308263f, 0.03782497f, -0.14396957f, -0.26859745f, -0.01902051f, 
    -0.14843598f, -0.16590111f, -0.00663585f, -0.13479684f, 0.00841717f, -0.20816134f, 0.05830685f, 0.20968419f, 
    -0.04665079f, 0.09588588f, 0.08048714f, 0.14034364f, 0.02952840f, 0.03054354f, -0.20730011f, -0.43370214f, 
    0.14937420f, -0.08205285f, 0.04361229f, -0.39489821f, 0.16011313f, 0.38510612f, -0.37688470f, 0.23524003f, 
    -0.00668702f, -0.05770548f, -0.01666316f, -0.03346500f, -0.09889008f, 0.04251348f, 0.04767215f, 0.01104039f, 
    -0.03557661f, 0.07185617f, -0.01530598f, -0.06461889f, -0.03113206f, 0.00543304f, -0.08195750f, -0.03355694f, 
    -0.03005981f, -0.09389871f, -0.08521238f, 0.02369253f, -0.06105742f, 0.03709825f, -0.09577673f, 0.06884588f, 
    0.04284275f, 0.03412746f, -0.07500515f, -0.06646758f, -0.05899373f, -0.11229113f, -0.05903022f, 0.07044594f, 
    -0.02252051f, -0.08172955f, -0.06071043f, -0.00959939f, 0.02344408f, 0.02696741f, -0.07761377f, -0.10420917f, 
    -0.04715865f, -0.10780089f, 0.04243347f, 0.06591851f, -0.10396893f, 0.00452699f, 0.01500902f, 0.01166008f, 
    -0.01468497f, -0.08804844f, -0.05042647f, 0.02464515f, -0.00066159f, -0.07072594f, -0.10868748f, -0.06980819f, 
    0.02535375f, 0.01508183f, -0.12990451f, -0.10443164f, -0.08361913f, 0.01658569f, -0.00660156f, -0.05789308f, 
    0.03193008f, -0.12254573f, -0.06860644f, -0.04538183f, 0.03780827f, -0.01732029f, 0.03094532f, 0.02543006f, 
    0.04932982f, 0.00188577f, -0.05948364f, -0.03401963f, 0.02645309f, -0.12436015f, -0.00077787f, 0.03126326f, 
    -0.09463364f, -0.01470948f, 0.05984151f, -0.06732775f, 0.05270112f, 0.03451267f, -0.06513758f, 0.08532530f, 
    0.03048369f, -0.04598477f, 0.07438626f, -0.00903490f, -0.00062159f, -0.03562344f, -0.08048461f, 0.03218976f, 
    -0.05342919f, -0.10523151f, 0.06471204f, 0.04588699f, -0.00252816f, -0.05365963f, -0.03883577f, 0.07461365f, 
    -0.08643960f, 0.03267198f, -0.05811517f, -0.04609131f, 0.07960930f, -0.08866353f, 0.02844503f, -0.11517087f, 
    0.02211389f, -0.01323272f, 0.07006489f, -0.00430212f, 0.06271441f, -0.00298275f, -0.07018767f, -0.04998291f, 
    -0.07436645f, 0.02401798f, 0.05948434f, -0.00594802f, -0.03931497f, -0.01513673f, 0.06190542f, -0.05695805f, 
    -0.07522765f, 0.17681675f, -0.15712488f, 0.01491378f, -0.09493755f, 0.17404300f, 0.12737502f, -0.15112512f, 
    0.02324250f, 0.10736417f, -0.16355419f, 0.11048818f, -0.12943588f, 0.08352620f, 0.01397924f, -0.00771773f, 
    0.20678744f, 0.28126201f, -0.10478132f, 0.18937561f, 0.08831073f, 0.10567211f, 0.09576719f, 0.06388040f, 
    -0.01380250f, -0.18363780f, 0.11103047f, 0.08086339f, -0.29319894f, -0.00757692f, -0.04504638f, 0.06935694f, 
    0.07870947f, -0.02429176f, -0.07138249f, -0.17980050f, 0.01436024f, 0.15831989f, -0.07426814f, 0.05857183f, 
    -0.09384901f, 0.06502136f, -0.01617405f, -0.08140023f, 0.04498943f, -0.27872330f, -0.00763317f, 0.16846290f, 
    0.20258775f, 0.12491204f, 0.02884563f, 0.13101941f, 0.24693711f, -0.17861456f, 0.02824770f, 0.00270012f, 
    -0.14267854f, 0.14114076f, 0.12765987f, 0.07961466f, -0.11008979f, 0.22275020f, 0.07357664f, 0.59321946f, 
    -0.15690298f, -0.12314593f, 0.08523224f, -0.07971261f, 0.02310158f, -0.04878573f, -0.08655781f, -0.06888914f, 
    0.20083658f, 0.17420983f, -0.12153812f, -0.04665872f, 0.03997065f, 0.11152737f, -0.02361860f, -0.09923275f, 
    -0.04485114f, -0.19634284f, 0.26545468f, 0.02958744f, -0.18328966f, 0.37825757f, -0.09164377f, -0.05201624f, 
    0.20968705f, -0.27817759f, 0.30860311f, 0.10734152f, 0.08892288f, 0.07199339f, 0.10258159f, 0.00370505f, 
    0.05010787f, -0.08582530f, -0.03379500f, 0.10031451f, -0.00164845f, -0.00070305f, 0.31382692f, 0.01008525f, 
    0.12143668f, 0.39235920f, 0.09123835f, 0.06177048f, -0.07780441f, -0.04340510f, 0.14383267f, 0.07665501f, 
    -0.08803201f, 0.04515957f, 0.09051411f, 0.14441483f, 0.13186701f, -0.08678388f, 0.35805333f, 0.14330387f, 
    0.03534313f, 0.18994313f, 0.24010220f, -0.00780269f, -0.14912589f, 0.03252918f, 0.07598756f, 0.01142883f, 
    -0.03434241f, 0.05351405f, -0.00105003f, -0.07557102f, -0.01514539f, 0.03727129f, -0.05026670f, 0.03297649f, 
    -0.04204958f, 0.00233524f, -0.01013706f, -0.10138584f, 0.04649232f, 0.03956819f, 0.02146789f, -0.05420821f, 
    -0.01694779f, -0.03754943f, 0.01734714f, -0.08740988f, 0.05325886f, -0.02673614f, 0.02287873f, 0.05558762f, 
    -0.05447539f, 0.01198941f, 0.00241871f, -0.03943168f, -0.01817597f, -0.06237355f, -0.07195296f, -0.04783794f, 
    0.01156147f, 0.07596975f, 0.06374686f, -0.01931714f, -0.03499269f, 0.05293665f, 0.00543557f, 0.03313475f, 
    -0.01562244f, 0.01036131f, -0.05563351f, 0.05364498f, 0.02973587f, -0.07762167f, 0.03949288f, 0.01755337f, 
    0.03603600f, 0.01479515f, 0.03974231f, -0.10521412f, 0.03194267f, -0.01341361f, -0.08799648f, 0.03587255f, 
    0.03624857f, -0.01354539f, 0.04406093f, -0.11082325f, -0.02770721f, -0.10586659f, -0.06463377f, 0.04674775f, 
    -0.07168489f, 0.03483552f, -0.03998402f, -0.08311953f, -0.08371380f, -0.00915914f, -0.06209292f, -0.01495285f, 
    0.05189063f, 0.03442007f, -0.07273497f, -0.06567370f, -0.05421738f, -0.04908331f, 0.06615762f, -0.02154925f, 
    0.04948509f, -0.06278976f, -0.10478409f, -0.08313151f, 0.08503646f, 0.04268460f, 0.03955647f, -0.08443835f, 
    0.01404090f, -0.05638497f, -0.00305714f, -0.07229126f, -0.04256109f, -0.10972151f, 0.04839967f, -0.03175251f, 
    -0.03967057f, 0.02875728f, -0.04380866f, -0.09980112f, 0.06381599f, 0.05157184f, -0.09986015f, 0.08607897f, 
    -0.04259165f, 0.01895404f, -0.08194917f, 0.08571307f, 0.08719116f, -0.01729533f, -0.01573524f, -0.00587716f, 
    -0.07996225f, 0.03753485f, -0.03637442f, -0.05856617f, -0.08322346f, 0.01727887f, -0.07498007f, -0.07147283f, 
    -0.01850313f, -0.05683488f, 0.03356099f, -0.07420442f, -0.01265229f, -0.03894284f, -0.01442038f, -0.04500776f, 
    -0.07525158f, -0.08529917f, -0.06007634f, -0.06266535f, -0.00981143f, -0.04872751f, 0.00947421f, 0.03396558f, 
    -0.11651017f, -0.02385996f, -0.03605513f, -0.07490803f, -0.05342350f, 0.03199314f, 0.01002014f, 0.04607417f, 
    0.06078566f, 0.01305732f, 0.06631824f, -0.04159684f, -0.03469846f, -0.03093836f, -0.07077684f, -0.02342954f, 
    -0.05879812f, -0.09962710f, -0.01926481f, -0.04259123f, -0.09032020f, -0.06281741f, 0.07492444f, 0.04753493f, 
    -0.00635233f, -0.01070888f, -0.07201459f, 0.03211702f, -0.01992800f, 0.00456441f, -0.07054574f, -0.04573874f, 
    -0.02418433f, 0.02105252f, 0.01976454f, -0.11559150f, -0.08840859f, -0.01553362f, -0.03462952f, 0.03873906f, 
    0.01258713f, -0.09485402f, 0.05827969f, -0.03549013f, -0.11859571f, -0.08018330f, 0.02281437f, -0.01781190f, 
    0.04874067f, 0.04571030f, -0.03897127f, 0.04574278f, -0.08446975f, -0.10085736f, -0.08162072f, 0.00476763f, 
    0.03147638f, 0.08985607f, 0.02671396f, -0.03232050f, 0.02373704f, -0.08941871f, -0.10482072f, -0.07181891f, 
    -0.10347269f, -0.05497225f, 0.00775633f, -0.05034472f, -0.02501619f, -0.02627098f, -0.04336695f, 0.03547121f, 
    -0.04483060f, -0.05537495f, -0.01943591f, -0.05398324f, -0.08393743f, -0.09425913f, -0.05241888f, -0.02228724f, 
    -0.03191094f, -0.06918620f, -0.02474643f, -0.04671547f, -0.04588708f, 0.05458535f, 0.00839088f, -0.03408712f, 
    0.00865344f, -0.06629249f, 0.02361269f, -0.04693512f, -0.05295044f, 0.04274212f, -0.03176396f, -0.01400989f, 
    0.09064342f, -0.05452249f, -0.04629324f, -0.01126771f, -0.06170951f, 0.03292625f, -0.00152804f, -0.06748255f, 
    -0.08909844f, 0.03276193f, -0.00900100f, 0.04493619f, -0.10472602f, 0.07779633f, -0.00714774f, -0.08292548f, 
    -0.03480673f, 0.02407806f, 0.05243737f, 0.00495105f, -0.01324166f, 0.03853946f, -0.12107871f, 0.03164244f, 
    -0.11688428f, -0.26014799f, -0.49407953f, -0.00148036f, -0.41986194f, -0.26047170f, 0.06212979f, 0.03595711f, 
    0.25455639f, -0.01687767f, -0.55445325f, -0.04100184f, 0.17518601f, 0.12313489f, 0.27721912f, 0.15708050f, 
    -0.20489004f, -0.02537193f, 0.26109681f, -0.06527537f, 0.11759635f, -0.18112965f, 0.10419931f, -0.04590539f, 
    -0.04807069f, -0.16492730f, -0.40553623f, 0.01935282f, 0.30394080f, -0.01384580f, 0.07313492f, 0.15191513f, 
    -0.16626260f, 0.08415060f, -0.04625084f, -0.14243318f, 0.10548345f, -0.30611730f, 0.13637838f, -0.03902355f, 
    0.07688570f, 0.04185661f, 0.23071019f, 0.01457452f, -0.06285638f, -0.01134457f, -0.01101138f, 0.11888473f, 
    0.26195306f, 0.07942013f, -0.07085604f, 0.27217090f, 0.08777273f, 0.09452119f, 0.13121605f, 0.04526943f, 
    0.16939910f, -0.07472348f, -0.05783518f, 0.28686538f, 0.05834191f, 0.11406413f, -0.14126749f, -0.13893877f, 
    0.21924330f, -0.31424493f, 0.07986210f, -0.12882346f, -0.00698929f, 0.06390305f, 0.00084322f, -0.48677996f, 
    0.15915160f, 0.09921424f, 0.12503128f, -0.11097866f, 0.10990780f, 0.17731009f, -0.04164766f, 0.19701575f, 
    -0.15540598f, 0.02854551f, -0.09124364f, 0.09289154f, -0.04665534f, -0.20347728f, -0.65270716f, 0.05301314f, 
    -0.30737200f, -0.31501883f, -0.31059980f, -0.11664497f, 0.12330391f, 0.09290860f, -0.07630363f, 0.06418215f, 
    -0.04891472f, 0.01627638f, 0.19709198f, 0.03490531f, -0.23438853f, -0.50481337f, -0.43526149f, 0.05099016f, 
    0.14134331f, -0.32107419f, 0.24085052f, -0.01145357f, -0.00383774f, -0.03625024f, 0.09016918f, 0.01442276f, 
    -0.36428013f, 0.07566454f, -0.51568949f, 0.03312852f, -0.58949679f, 0.02224611f, -0.14160317f, -0.44056988f, 
    -0.15421404f, -0.12611502f, -0.02303768f, -0.15156738f, -0.19379310f, 0.29368082f, 0.01951754f, -0.05475308f, 
    0.36560237f, 0.07955427f, -0.06913915f, -0.10083430f, -0.02579811f, -0.17221278f, -0.03198840f, 0.29133227f, 
    -0.01872133f, -0.29001647f, 0.07404234f, -0.02682872f, 0.02872728f, 0.03587620f, 0.21531472f, 0.18251893f, 
    0.03141176f, -0.45398295f, 0.00990616f, -0.21543297f, -0.02512501f, -0.04303533f, 0.07924927f, -0.00825452f, 
    0.11623818f, 0.45212957f, -0.03591790f, 0.02821945f, 0.03985540f, 0.10409231f, 0.05815523f, 0.28808752f, 
    -0.03163103f, 0.04066723f, 0.13790298f, -0.21625662f, 0.07263605f, 0.12722330f, -0.07531995f, 0.03461253f, 
    0.03476261f, 0.05104656f, 0.33460256f, 0.20495382f, 0.27389255f, 0.08823272f, -0.02403833f, 0.06599116f, 
    -0.07407095f, -0.21952289f, -0.03616779f, 0.02164468f, 0.17928770f, 0.10075719f, 0.08847919f, -0.05873462f, 
    0.01406022f, 0.07293293f, -0.00318907f, 0.03514258f, 0.12201599f, 0.21263811f, -0.03909181f, -0.17039070f, 
    0.00293015f, -0.03295377f, 0.02727596f, -0.13134727f, 0.07796989f, -0.01066420f, 0.28497186f, -0.05371507f, 
    0.11523529f, -0.00548885f, -0.01232818f, 0.06391941f, -0.09692068f, 0.20955481f, -0.10262855f, 0.02383615f, 
    -0.01408067f, 0.05921882f, -0.32943192f, 0.17719653f, 0.05214546f, 0.06417691f, -0.35508811f, 0.05557179f, 
    -0.34236738f, -0.42162403f, -0.49123058f, 0.02131357f, 0.29687294f, 0.03073713f, -0.02844037f, 0.02282781f, 
    0.20052981f, 0.13531153f, -0.10187609f, 0.02112058f, -0.22525769f, 0.08003096f, -0.12113290f, 0.05676121f, 
    0.08162747f, -0.15691420f, 0.19230258f, 0.41443130f, -0.05457107f, 0.31248721f, 0.03832748f, -0.01949020f, 
    -0.15958120f, 0.30516392f, 0.29281315f, 0.04221062f, -0.04737735f, -0.07563779f, -0.01417493f, -0.21046048f, 
    0.17875582f, -0.40966538f, 0.03616919f, 0.21773942f, -0.22969466f, 0.13154586f, 0.19587338f, 0.00814716f, 
    0.27216861f, 0.03107356f, -0.15083972f, -0.01888051f, -0.22205995f, -0.06512950f, -0.04057045f, 0.26469266f, 
    0.12761925f, -0.03808678f, -0.20402466f, 0.17465310f, 0.26450431f, -0.04445042f, 0.25369212f, 0.02208498f, 
    0.04518732f, -0.13985915f, 0.34104395f, -0.08716722f, -0.08225508f, 0.01607496f, 0.07274920f, 0.08752879f, 
    -0.13137005f, 0.28731936f, 0.03852516f, 0.07571290f, 0.00131314f, -0.08593968f, 0.03278640f, 0.14880043f, 
    -0.31702715f, 0.05963593f, -0.19462767f, -0.20095173f, 0.01024474f, -0.12330213f, -0.00638040f, -0.06757428f, 
    0.05929863f, 0.04264356f, 0.01167842f, -0.14290994f, 0.13204393f, 0.09214655f, -0.03002074f, 0.05177952f, 
    0.16882111f, -0.05245017f, 0.03962637f, 0.24388695f, 0.03119820f, -0.04508326f, 0.01231781f, -0.04270557f, 
    -0.01927174f, 0.05150141f, 0.04906545f, 0.16164714f, 0.07089507f, 0.14559712f, -0.38018045f, -0.08744410f, 
    0.10563391f, -0.20857635f, 0.10993852f, 0.05053068f, -0.04177178f, 0.05585865f, -0.00430315f, -0.18319586f, 
    0.26538917f, 0.04887608f, 0.10539947f, 0.19634052f, 0.38115236f, 0.28408864f, -0.07173508f, 0.14210005f, 
    -0.26322493f, 0.08350305f, -0.01070726f, -0.04235895f, -0.07595825f, 0.09796690f, -0.44496351f, -0.03208978f, 
    -0.30898133f, 0.57189709f, 0.02417381f, 0.12967403f, 0.05520726f, 0.20069379f, 0.01847749f, 0.07363818f, 
    -0.07469496f, 0.12359178f, 0.06788734f, -0.00051376f, -0.22386210f, -0.05259432f, -0.78104621f, -0.06637502f, 
    0.11167163f, -0.53052258f, 0.12697896f, 0.18602444f, -0.05473084f, 0.12405024f, -0.00819550f, 0.04567206f, 
    -0.21072762f, -0.03750927f, -0.20003161f, 0.10825841f, -0.27690226f, -0.07042463f, -0.14492740f, -0.36363342f, 
    -0.13577239f, 0.04576888f, -0.15699476f, -0.06066170f, -0.07888233f, 0.09837042f, 0.07778540f, 0.15904397f, 
    0.03029539f, 0.00255325f, -0.63002104f, -0.06514767f, -0.35633612f, -0.23759845f, -0.06430412f, 0.34360510f, 
    0.05385778f, 0.05893023f, -0.02328489f, 0.24757946f, 0.22649175f, -0.05415766f, 0.21119788f, 0.09774373f, 
    0.00647180f, -0.15113156f, 0.21086988f, 0.11606852f, 0.01411966f, 0.01000979f, -0.04366666f, 0.00481851f, 
    -0.21041399f, 0.02884205f, -0.12949567f, 0.06869742f, 0.37385282f, 0.15117815f, 0.04042260f, 0.25705770f, 
    0.25506979f, 0.05259610f, 0.11876377f, 0.06848759f, 0.15627077f, -0.30587026f, 0.22316450f, 0.18610743f, 
    -0.01729356f, -0.13623922f, 0.19903563f, 0.24932070f, -0.00918369f, 0.40396446f, 0.02898110f, -0.11782613f, 
    -0.35650072f, 0.19723274f, 0.06409126f, -0.11440803f, -0.01963237f, 0.24380735f, 0.04284210f, -0.23290771f, 
    0.28198966f, -0.15738036f, -0.16251476f, 0.20171928f, 0.17654137f, 0.02409560f, 0.22665185f, -0.08251324f, 
    0.14041778f, -0.36955783f, -0.08716744f, 0.07667661f, 0.11857067f, -0.19035558f, 0.27564344f, 0.02874316f, 
    0.01161872f, -0.16304713f, 0.04471936f, 0.19852179f, 0.28237244f, 0.12623744f, -0.03055941f, 0.39218083f, 
    0.24613123f, 0.21717888f, -0.27757195f, 0.04932445f, 0.06582441f, -0.16361742f, -0.39556488f, -0.06574067f, 
    -0.65014887f, -0.58737415f, -0.25687575f, -0.04330559f, 0.28036082f, -0.13223606f, 0.07950886f, -0.03935479f, 
    0.09356222f, 0.27026850f, -0.06698433f, -0.15577982f, -0.13162284f, -0.05057505f, -0.14709926f, -0.06546097f, 
    -0.00835797f, -0.23611233f, -0.04164011f, 0.04752587f, -0.00712786f, 0.22774161f, -0.17077091f, 0.04678541f, 
    0.00204808f, 0.19234788f, -0.05016296f, -0.29065105f, -0.28374508f, -0.02724820f, -0.04194201f, -0.23940915f, 
    -0.04880494f, -0.29152730f, -0.23468453f, 0.15366071f, 0.24541852f, -0.01695429f, 0.01948822f, -0.05273086f, 
    0.00601900f, 0.21794786f, 0.35254559f, 0.00685461f, -0.16706251f, -0.08592679f, -0.00231807f, -0.23728676f, 
    -0.03040610f, -0.05905544f, -0.08609033f, 0.08254886f, -0.09128972f, 0.06149898f, 0.16883053f, -0.03794791f, 
    0.06919865f, 0.22402143f, -0.10978921f, -0.07626921f, 0.06194004f, 0.02820393f, 0.16316628f, -0.02071790f, 
    0.25348425f, -0.17221564f, 0.08466186f, -0.01438235f, -0.14322487f, -0.02891743f, -0.00765408f, 0.03342910f, 
    -0.00428765f, 0.04819763f, 0.05512742f, -0.24929485f, 0.02108486f, 0.14060257f, 0.14044818f, 0.11938719f, 
    -0.07356036f, 0.11276668f, -0.05844248f, -0.08884310f, 0.10827285f, -0.03173846f, 0.04956368f, 0.24714689f, 
    0.36708453f, 0.08080365f, -0.01548954f, 0.18261746f, 0.28507775f, -0.13153119f, 0.09680818f, 0.10612664f, 
    -0.07026319f, 0.11458098f, 0.13440435f, -0.05586202f, -0.02149143f, 0.16122869f, 0.09182268f, 0.34336293f, 
    -0.00776399f, 0.20940998f, 0.17359093f, -0.12311824f, 0.05434467f, 0.12187199f, -0.04270015f, -0.04170512f, 
    0.09289758f, 0.11325797f, -0.16823676f, -0.02615498f, -0.08221818f, 0.11831247f, 0.04726814f, 0.00818213f, 
    0.04443036f, -0.16447051f, 0.27344409f, -0.00332305f, -0.23966868f, 0.25457484f, 0.21161047f, 0.03063143f, 
    -0.00529365f, 0.47149080f, -0.15883592f, 0.18959276f, 0.09027880f, 0.22889829f, 0.05285336f, -0.06234019f, 
    -0.09548252f, -0.19150972f, 0.10478035f, 0.17474486f, -0.34855336f, 0.05995324f, -0.04039039f, -0.04282193f, 
    0.12506825f, 0.15191640f, 0.06885672f, -0.02710809f, -0.03597879f, 0.01136493f, 0.23302069f, 0.36480734f, 
    -0.00146796f, 0.07774266f, -0.17957045f, -0.15100388f, -0.07172569f, -0.00432854f, 0.31856331f, 0.03978224f, 
    -0.00316249f, -0.07620467f, 0.44835415f, -0.03546483f, -0.04904386f, 0.02472480f, 0.11972373f, 0.07084548f, 
    0.16327141f, 0.03879090f, 0.24373579f, -0.05630398f, -0.26883280f, 0.23000047f, 0.28652847f, -0.00728966f, 
    0.14230444f, -0.09353441f, -0.52940953f, -0.25305894f, 0.16698271f, -0.05571320f, 0.27845258f, 0.04800940f, 
    -0.06163159f, -0.15994065f, 0.06031782f, 0.15091674f, 0.01589673f, -0.16013390f, 0.29216900f, -0.10974305f, 
    0.24209447f, -0.04836493f, -0.01608810f, 0.01745976f, 0.16759562f, 0.09696343f, -0.02630091f, 0.10388693f, 
    -0.00376249f, 0.02141311f, 0.09233835f, 0.07309397f, 0.13495584f, 0.01532356f, -0.05518401f, -0.17530833f, 
    0.00945339f, -0.03835286f, 0.26869446f, 0.08567854f, 0.10223569f, -0.33559740f, 0.02932371f, 0.24144839f, 
    -0.08841794f, -0.04261557f, 0.06302982f, 0.18084688f, 0.18650146f, -0.18306470f, 0.07535004f, 0.23868304f, 
    0.34213886f, -0.11237708f, -0.01278281f, 0.15839605f, 0.00612897f, 0.09319439f, -0.23245937f, -0.08170774f, 
    0.09393188f, 0.18337524f, 0.05797257f, -0.54934484f, 0.07325011f, -0.06983434f, -0.10378422f, -0.45103100f, 
    0.11287047f, 0.06366241f, -0.08465350f, -0.18937629f, -0.12485883f, 0.11995691f, -0.06411214f, -0.20562494f, 
    -0.08421792f, -0.04781204f, -0.14350490f, 0.08819161f, 0.15473062f, 0.22135201f, 0.01595664f, 0.03845482f, 
    -0.01996585f, 0.10840832f, 0.14183326f, -0.01146530f, 0.02755626f, 0.04137689f, 0.06372508f, 0.04144968f, 
    0.09706642f, -0.15643385f, 0.10113233f, 0.11791455f, 0.08640583f, -0.12978616f, 0.13041654f, -0.05843787f, 
    -0.00498715f, 0.02294114f, 0.14478660f, -0.15214033f, -0.06164324f, -0.01305080f, 0.18539160f, 0.22969452f, 
    -0.21068996f, 0.10982004f, -0.18187985f, 0.28313053f, 0.12611066f, 0.02322443f, -0.08397535f, -0.05890792f, 
    0.21291591f, -0.23395562f, 0.09550805f, -0.08333630f, -0.05094000f, 0.37015784f, 0.04724393f, 0.16973311f, 
    0.01716603f, -0.06497002f, -0.07048143f, -0.00636204f, -0.06171151f, 0.05584083f, 0.00950920f, -0.05476784f, 
    -0.03091407f, 0.02455449f, -0.03039427f, 0.06519478f, -0.03980584f, -0.05836938f, -0.01180347f, -0.11335247f, 
    -0.08011879f, -0.08877009f, 0.03588409f, -0.08479252f, 0.04818088f, -0.03526693f, -0.03844965f, -0.02355392f, 
    0.03890354f, 0.01158706f, -0.08385815f, 0.03131212f, -0.09487247f, -0.09408303f, -0.04147407f, -0.08445383f, 
    -0.05186473f, 0.05472378f, -0.00021932f, -0.01174095f, 0.04370353f, -0.08943044f, -0.02459827f, 0.04202650f, 
    -0.05727424f, 0.02650925f, -0.02380150f, -0.03315551f, -0.02859916f, -0.04751529f, 0.08012249f, 0.02932760f, 
    -0.08357964f, 0.04660799f, 0.01086739f, 0.01065521f, -0.03313663f, -0.05720649f, -0.06010777f, -0.04624128f, 
    -0.00508406f, 0.02997763f, -0.11309577f, -0.06068299f, -0.01660504f, -0.06281444f, -0.05798728f, -0.02357063f, 
    -0.01800404f, -0.10641026f, 0.01391929f, -0.09104861f, -0.01615230f, -0.02308611f, 0.04890381f, 0.00844704f, 
    -0.03326620f, 0.01666481f, -0.00940938f, 0.02357280f, -0.04650555f, 0.04678072f, -0.02606988f, 0.05989491f, 
    -0.06396836f, -0.05257738f, 0.00238616f, -0.06314319f, -0.07013895f, 0.04555161f, -0.02273953f, 0.04784570f, 
    -0.05069292f, -0.05070569f, -0.07207020f, -0.05931568f, -0.06042553f, 0.02722640f, 0.06715360f, -0.03067177f, 
    -0.08071164f, -0.06118992f, -0.03587811f, -0.08651514f, 0.00906924f, 0.01686467f, 0.03302380f, -0.06769980f, 
    0.02481000f, -0.07204810f, -0.11625764f, 0.03511922f, 0.04513259f, -0.06092966f, -0.02145323f, 0.03658649f, 
    -0.06690896f, -0.01619787f, 0.04922291f, -0.01728798f, 0.05240141f, -0.00926871f, -0.05068005f, 0.00251939f, 
    -0.00363450f, 0.02414765f, -0.03897763f, 0.05361010f, -0.05178731f, 0.07451130f, -0.10886430f, -0.00424600f, 
    0.36803856f, 0.20945337f, 0.06752424f, -0.18836349f, -0.14955187f, 0.08316050f, 0.06621705f, 0.43413284f, 
    0.05792004f, -0.18866454f, -0.07875580f, -0.26333070f, 0.06572882f, -0.37404945f, -0.15967844f, 0.14139147f, 
    -0.36564067f, -0.61060345f, -0.12992975f, -0.21009168f, 0.05859542f, -0.15981251f, 0.25193864f, -0.36627844f, 
    0.01727641f, 0.66246438f, 0.03663173f, -0.01949001f, 0.07899568f, -0.07283103f, -0.03396460f, 0.13029291f, 
    0.10794201f, 0.03514648f, 0.11111217f, -0.24871200f, 0.04529680f, 0.07597980f, -0.11703635f, -0.06891198f, 
    0.06367318f, -0.11923584f, 0.34505111f, 0.15066524f, 0.25942564f, 0.01423522f, 0.05089319f, 0.11404603f, 
    -0.01655240f, -0.27720574f, -0.05277853f, -0.05887441f, 0.08327966f, 0.21500535f, -0.26949921f, -0.19892131f, 
    -0.04161964f, 0.00197653f, 0.00334401f, -0.10548718f, 0.02344948f, 0.07683921f, -0.02349635f, -0.32929361f, 
    -0.25132048f, 0.04898106f, 0.14732529f, -0.28036460f, 0.16237953f, -0.14641622f, 0.12621509f, -0.12094917f, 
    -0.06304247f, -0.21785724f, -0.01885428f, 0.14361531f, -0.25597137f, 0.10020757f, -0.00368965f, -0.08936010f, 
    -0.11085414f, 0.18564740f, -0.36461440f, 0.18698786f, 0.08764933f, 0.16080247f, -0.33676717f, 0.03109156f, 
    -0.22859576f, 0.30479303f, 0.12042699f, 0.05726769f, 0.12597692f, 0.12591882f, 0.00940840f, -0.06567508f, 
    0.18392156f, -0.01878182f, -0.12983426f, -0.08856075f, 0.06489149f, 0.10690445f, 0.03364800f, -0.02040730f, 
    -0.27578354f, 0.07767130f, -0.02236793f, 0.36336336f, -0.05635885f, 0.14864843f, 0.02274174f, -0.24524395f, 
    -0.11711334f, 0.22615901f, 0.41033268f, 0.28237993f, 0.05182693f, -0.02055846f, 0.02655772f, -0.15449534f, 
    0.10650075f, -0.73319280f, 0.03926685f, 0.21789569f, 0.11196025f, 0.14661345f, 0.03312515f, 0.04358621f, 
    0.11481047f, -0.19882521f, -0.13668153f, 0.10742377f, -0.00857982f, -0.01649332f, 0.03446672f, 0.53769463f, 
    0.27488565f, 0.26844817f, -0.01308404f, 0.29921612f, 0.30841663f, 0.07650278f, 0.15760925f, 0.02612315f, 
    0.12285642f, -0.34502909f, 0.19907843f, -0.03343908f, 0.01421844f, 0.12275882f, -0.03278322f, 0.18811797f, 
    -0.03664457f, 0.20252526f, 0.04769167f, 0.02228526f, 0.15690307f, 0.05112696f, -0.00581273f, -0.03608744f, 
    0.06252845f, -0.01316684f, 0.00675293f, 0.08721877f, 0.07239135f, -0.36724582f, -0.09097369f, 0.15956338f, 
    0.01673458f, -0.04020824f, 0.02435045f, 0.08307888f, -0.08492775f, 0.14806734f, -0.06215727f, -0.14444000f, 
    -0.35042423f, 0.02398514f, -0.06103628f, -0.03769273f, -0.17166944f, 0.28270960f, 0.02969173f, -0.04588303f, 
    0.07708002f, -0.01005416f, 0.00125563f, 0.08491848f, 0.13566123f, -0.01752408f, 0.05944936f, -0.18938452f, 
    0.07052586f, -0.06938867f, -0.04689446f, 0.04499973f, 0.00648982f, -0.02843364f, 0.10111479f, 0.04613775f, 
    0.12260748f, 0.01060231f, 0.11873298f, 0.21638471f, 0.19126341f, 0.02128575f, -0.07755248f, 0.23060533f, 
    0.08781602f, 0.19498762f, 0.07588542f, 0.00931171f, 0.18511738f, -0.26218149f, -0.00810063f, -0.08581015f, 
    -0.20643224f, -0.26222602f, 0.04567565f, 0.01206407f, 0.11440556f, 0.14044976f, 0.04063188f, -0.08284091f, 
    0.08607329f, 0.15108280f, -0.05389544f, -0.14446299f, 0.15474659f, 0.08700355f, -0.39499792f, 0.02086863f, 
    -0.01424414f, -0.38149914f, -0.18531843f, 0.16749033f, -0.05526241f, 0.09263998f, -0.01736275f, -0.14580776f, 
    -0.01493360f, -0.11631195f, 0.11125050f, -0.16454399f, -0.03038051f, 0.03357235f, -0.06811587f, -0.04318280f, 
    0.01215245f, -0.08818626f, -0.58399731f, 0.12560521f, -0.03428676f, -0.04524874f, -0.00036157f, -0.04372940f, 
    -0.08940946f, 0.05091006f, -0.01365928f, -0.01572112f, -0.02445232f, -0.05723482f, -0.07194540f, -0.01249000f, 
    -0.06494270f, 0.01033556f, -0.10897675f, -0.07030161f, -0.05794258f, 0.04865913f, -0.04252853f, -0.02246512f, 
    0.03901378f, -0.03565625f, -0.06739172f, -0.08548182f, -0.08890883f, -0.04986811f, 0.02838142f, -0.00334139f, 
    -0.07889970f, -0.07035785f, 0.04606240f, 0.07251595f, -0.08964364f, -0.00090933f, -0.01153010f, 0.03671578f, 
    0.06861446f, -0.02998508f, 0.01350168f, -0.05395715f, 0.04287164f, -0.07824016f, -0.07418491f, 0.00973621f, 
    0.00727460f, 0.00761452f, 0.05473200f, -0.00186020f, -0.08802557f, -0.00615285f, -0.06046115f, -0.02492115f, 
    -0.02162342f, 0.04484435f, 0.02905186f, -0.07840557f, -0.09418540f, -0.09972861f, -0.02642364f, -0.01573867f, 
    -0.09811551f, 0.04325572f, -0.04575572f, 0.04508657f, 0.00012901f, -0.00542405f, -0.05067744f, -0.07937715f, 
    -0.01183778f, -0.01078426f, 0.00800499f, -0.02815889f, 0.01737273f, -0.01930443f, 0.04569628f, -0.06559239f, 
    -0.02694649f, 0.07108844f, 0.07932241f, -0.07748249f, 0.03298589f, -0.09267022f, 0.00757948f, 0.01921266f, 
    0.00160484f, 0.02068763f, 0.07040511f, 0.01851151f, -0.01637455f, 0.00587807f, -0.07891691f, -0.08785995f, 
    0.03425593f, 0.06583565f, -0.00294066f, -0.00679965f, -0.07515176f, -0.03468324f, 0.02148802f, 0.01446784f, 
    0.04507897f, 0.01031723f, -0.08458063f, -0.08631410f, -0.07265700f, 0.05092978f, -0.04576594f, 0.03617490f, 
    -0.03715614f, -0.01186988f, 0.04937444f, 0.05830131f, -0.05979767f, 0.06958476f, 0.01411964f, -0.10044219f, 
    -0.06140925f, 0.04884712f, -0.07615365f, 0.06825878f, -0.08424915f, 0.03339990f, 0.00517255f, -0.04475808f, 
    0.01346860f, 0.05034805f, 0.03810409f, -0.09112946f, -0.04024571f, 0.01094565f, -0.00886717f, -0.06980859f, 
    0.16405486f, 0.18377373f, -0.09943501f, -0.02047833f, -0.39522088f, 0.13631764f, -0.05332624f, -0.14216842f, 
    0.25373766f, 0.19322442f, 0.31406319f, 0.02144785f, 0.01432872f, -0.27171642f, -0.11068868f, -0.08995763f, 
    0.15428567f, -0.17140067f, -0.00395411f, 0.12119354f, -0.10198282f, 0.26882440f, 0.19055942f, -0.07994218f, 
    -0.06048222f, 0.12952684f, 0.25592595f, 0.07185303f, -0.33002302f, -0.12461565f, 0.01424462f, -0.18476060f, 
    0.15132082f, 0.01631639f, -0.35138002f, -0.20063762f, 0.06086003f, 0.13760941f, 0.26265436f, 0.13620840f, 
    0.02215979f, -0.06224208f, -0.22368112f, -0.27917984f, -0.01609602f, 0.11001431f, 0.05624858f, 0.01764284f, 
    -0.21019363f, -0.66632187f, 0.09348725f, 0.06665775f, 0.07130093f, 0.15150683f, -0.32657558f, -0.04949313f, 
    -0.22581208f, 0.28399032f, 0.16048840f, -0.17844895f, 0.06458415f, -0.24950270f, 0.14965571f, 0.00189233f, 
    -0.04346327f, -0.40569946f, 0.28523427f, 0.11490247f, -0.36038005f, -0.13127960f, -0.03201379f, 0.07592370f, 
    0.13541365f, -0.32594034f, 0.15817040f, 0.24430738f, 0.26712778f, -0.24829718f, 0.07659197f, -0.01280711f, 
    -0.06146405f, 0.09436723f, 0.21513297f, -0.18641976f, 0.08324280f, 0.07947381f, -0.51781005f, 0.00650270f, 
    -0.08546314f, -0.55575120f, 0.01705107f, 0.16441476f, -0.30883044f, 0.28976461f, 0.01212974f, 0.08269848f, 
    0.17913257f, 0.15785462f, 0.01582735f, 0.03177531f, 0.34117988f, 0.21953744f, -0.07413094f, -0.06893221f, 
    -0.20872635f, 0.32689905f, -0.02324635f, -0.04634095f, 0.04088764f, -0.06367009f, 0.03918836f, -0.10484628f, 
    0.36691269f, -0.19811457f, -0.45023584f, -0.14771448f, 0.29654944f, 0.07378597f, 0.14981544f, -0.28006351f, 
    0.07627972f, -0.08829389f, 0.00609681f, -0.18932527f, 0.13675599f, 0.01953756f, -0.08942369f, 0.15369047f, 
    -0.20877190f, -0.05381569f, 0.04704553f, 0.04892772f, -0.01578664f, 0.02621450f, 0.01527378f, -0.13818382f, 
    -0.05318366f, 0.10387240f, -0.16498910f, 0.14850079f, -0.07996751f, 0.05742372f, -0.05804263f, -0.09236315f, 
    0.06204646f, 0.31028566f, 0.05356780f, -0.24078304f, -0.01530502f, -0.01879941f, 0.09375124f, 0.22792508f, 
    0.01078659f, -0.11542112f, 0.17592792f, 0.04081512f, -0.15336077f, -0.01150073f, -0.07970190f, -0.01760350f, 
    -0.04183915f, 0.00918887f, -0.11742041f, -0.04790961f, 0.13563216f, 0.12784216f, 0.07285998f, 0.08291525f, 
    -0.08946105f, -0.03786539f, -0.10902885f, -0.26054198f, -0.00072229f, -0.04472949f, 0.01909048f, 0.09057269f, 
    0.22134894f, 0.14478657f, 0.10451346f, -0.00782538f, 0.05183703f, -0.07115451f, -0.04839357f, 0.07814983f, 
    0.07520527f, 0.00985828f, 0.20219129f, 0.04839990f, 0.06406126f, 0.04625775f, 0.16108198f, 0.36074528f, 
    0.02307605f, -0.03970870f, 0.13518935f, 0.01800537f, 0.02139367f, 0.04800611f, -0.08578172f, -0.14273253f, 
    -0.11314565f, 0.04991530f, -0.28795224f, 0.01038946f, 0.22063382f, 0.01882448f, -0.00847481f, 0.00081016f, 
    0.07416500f, -0.10965514f, 0.30707890f, -0.02104134f, -0.05244125f, 0.22872499f, -0.45544633f, -0.06007241f, 
    -0.10388869f, -0.11711229f, 0.13825305f, 0.12843537f, -0.02594499f, -0.03433041f, 0.00894430f, 0.05914801f, 
    0.05719777f, -0.01136743f, 0.09575613f, 0.02771844f, -0.14482056f, -0.06223870f, 0.02139538f, -0.07401107f, 
    0.03824829f, 0.15425587f, -0.09876256f, -0.12519637f, 0.02323790f, -0.08074120f, 0.07145704f, 0.24117295f, 
    0.05050568f, -0.13226065f, -0.02180341f, -0.20669436f, 0.09350330f, -0.03860546f, 0.16523501f, -0.01219337f, 
    0.01120466f, 0.02330700f, 0.17015831f, -0.09420806f, 0.26613903f, 0.03445892f, -0.25520521f, -0.05506334f, 
    0.08438079f, 0.06836060f, -0.05146032f, 0.07227568f, -0.08829342f, 0.04383555f, -0.02234684f, 0.07160322f, 
    0.06337176f, 0.03981892f, -0.05145119f, -0.03426312f, -0.08096401f, -0.07012755f, 0.05589071f, 0.06933183f, 
    0.02641571f, -0.08316931f, -0.06360854f, 0.05650575f, 0.05974045f, 0.01964816f, -0.00845706f, 0.04410635f, 
    0.03091190f, -0.07714353f, 0.03509108f, 0.08602259f, -0.09474508f, -0.02810637f, 0.05167759f, -0.07509302f, 
    -0.04789817f, 0.07944749f, -0.01447274f, -0.03821790f, -0.05603223f, 0.02162197f, 0.03363995f, -0.09576718f, 
    0.08563623f, -0.06594580f, -0.07353635f, -0.07756863f, 0.07005354f, -0.01199175f, 0.07297602f, 0.04838338f, 
    -0.02378770f, 0.06561662f, -0.03784673f, -0.02038888f, 0.02590905f, -0.08170566f, -0.07269038f, 0.05288733f, 
    -0.06402859f, -0.05378461f, -0.04425614f, 0.04889249f, -0.01773754f, 0.06735387f, 0.00925733f, 0.02192861f, 
    -0.00345874f, 0.06909778f, -0.06355739f, 0.07736294f, -0.01500997f, -0.05756547f, 0.03064649f, -0.03671669f, 
    -0.00534015f, -0.01976536f, 0.04663498f, 0.03959000f, -0.07180272f, -0.09199610f, -0.00890386f, -0.09536369f, 
    -0.07740016f, -0.06368360f, 0.01476333f, -0.06592944f, 0.02893503f, -0.04524703f, -0.06436733f, -0.03371965f, 
    -0.09287380f, 0.00451195f, -0.08142252f, 0.02233191f, -0.01712613f, -0.02856549f, 0.05593895f, -0.03870008f, 
    -0.07293826f, -0.08587887f, 0.06455189f, 0.06995924f, -0.08384162f, -0.04482919f, -0.07651617f, 0.02586065f, 
    0.04317277f, 0.00991912f, -0.08191195f, -0.08031119f, -0.02397570f, 0.02763381f, -0.07236648f, -0.05538816f, 
    0.00790419f, 0.00093238f, -0.08449838f, 0.07648058f, 0.06194158f, -0.05592947f, -0.06374361f, 0.00814705f, 
    -0.08236554f, -0.02438236f, 0.01096980f, 0.08726236f, -0.06953863f, 0.01115145f, -0.07378424f, -0.09478510f, 
    0.03385219f, 0.06645832f, -0.01258467f, 0.00421286f, -0.04860151f, 0.07178813f, 0.03413699f, 0.03328050f, 
    0.04905485f, 0.00867806f, -0.01690005f, 0.00443959f, 0.01779954f, 0.06541993f, -0.08649673f, -0.01874279f, 
    0.03271616f, -0.01486407f, -0.04899564f, 0.07426374f, 0.05334935f, -0.02357444f, 0.07098678f, -0.08586112f, 
    0.04658533f, -0.03564653f, -0.01531310f, -0.08426678f, 0.06120860f, -0.08619184f, -0.01065825f, -0.01938822f, 
    -0.04101042f, -0.03670049f, -0.08424946f, 0.00558560f, 0.06883113f, 0.02311921f, -0.05488795f, 0.00947980f, 
    0.04554766f, 0.06657542f, -0.08586150f, 0.02930147f, -0.06337430f, -0.02966580f, -0.04901060f, -0.03759088f, 
    0.04821610f, 0.03350495f, 0.04787614f, 0.04856759f, -0.05155386f, -0.03800882f, -0.04274748f, -0.05485046f, 
    0.02570619f, -0.03443214f, 0.05014155f, -0.06640372f, -0.00103200f, -0.05002077f, -0.03525985f, 0.00567230f, 
    -0.07567084f, -0.05510312f, -0.05900871f, -0.02815472f, -0.01705766f, -0.05752175f, -0.07300562f, 0.04901113f, 
    -0.06558869f, -0.02698103f, -0.04679746f, 0.03364197f, 0.03637122f, -0.04236894f, 0.01547556f, -0.08114595f, 
    0.08693588f, 0.01707685f, -0.00311423f, -0.07949961f, 0.05318832f, 0.08673163f, -0.07688939f, 0.04059729f, 
    0.06748582f, 0.08762880f, -0.06902701f, -0.01379670f, -0.07166566f, -0.07311893f, 0.00997753f, -0.02169579f, 
    0.04304107f, -0.08108702f, 0.01619738f, 0.00100240f, -0.01972404f, 0.08563988f, -0.04190881f, 0.05281743f, 
    -0.01564076f, 0.02704844f, -0.07859185f, -0.06576224f, -0.04394328f, -0.05285624f, 0.02126602f, 0.05490692f, 
    0.08673007f, -0.05525330f, 0.02032461f, -0.07092476f, -0.00097860f, -0.01796213f, -0.08460439f, 0.00979672f, 
    0.04847889f, 0.00620940f, -0.02088490f, -0.07377571f, -0.05149179f, -0.03541939f, -0.04147091f, -0.03854628f, 
    -0.15042943f, 0.06025432f, -0.78701627f, 0.03041017f, -0.10042813f, 0.18825455f, 0.04041616f, -0.51293385f, 
    0.00080053f, -0.03974215f, 0.05099922f, 0.16414388f, -0.24758399f, -0.03611104f, -0.32999855f, 0.02271222f, 
    -0.19133052f, 0.51320571f, -0.02895134f, -0.17450991f, 0.01288341f, 0.04782763f, 0.03288237f, -0.11506324f, 
    0.00241799f, -0.11155540f, -0.01857859f, -0.02024374f, -0.04535942f, 0.16133779f, -0.04300236f, -0.12383992f, 
    0.05543689f, -0.08782183f, 0.10098550f, -0.08288086f, -0.08782766f, 0.30286485f, 0.07654081f, 0.11849737f, 
    -0.00398478f, -0.12001473f, -0.35550779f, -0.11437661f, -0.04510992f, 0.10319480f, -0.08217060f, 0.05228681f, 
    0.44844884f, 0.19340169f, -0.06568248f, 0.10720780f, 0.06212449f, 0.01479546f, -0.11557790f, -0.06109574f, 
    -0.18162616f, 0.01562748f, 0.31210038f, -0.11817868f, -0.03771907f, -0.07913449f, 0.25625131f, 0.45943907f, 
    0.05208063f, 0.11711290f, 0.17541033f, 0.25757477f, 0.17483084f, -0.06750118f, -0.04216790f, -0.06591239f, 
    -0.08626895f, 0.07201438f, -0.24993096f, 0.30656505f, 0.12269751f, -0.01274861f, -0.05037460f, -0.14119574f, 
    0.15070838f, 0.10311943f, 0.28553635f, -0.03683435f, -0.02872944f, -0.09870343f, -0.20541242f, 0.00318864f, 
    0.44033253f, -0.65802044f, 0.15464021f, 0.11916823f, -0.11184745f, 0.24644290f, -0.05150553f, 0.01220390f, 
    0.02636280f, -0.05412391f, 0.18347180f, -0.17048824f, 0.16268057f, -0.05903524f, 0.02550201f, -0.00514443f, 
    -0.05795886f, 0.44546387f, -0.25577462f, -0.05974471f, 0.00365021f, -0.02136910f, 0.25799423f, 0.09201001f, 
    0.03668958f, -0.07214066f, -0.17894363f, 0.04528140f, -0.08429801f, -0.06829239f, 0.14303535f, 0.01332312f, 
    -0.10071832f, 0.07766435f, 0.23617308f, -0.01465084f, 0.08741394f, 0.12017987f, -0.22559342f, -0.05418677f, 
    -0.01310170f, -0.04750824f, 0.01946699f, 0.07213017f, -0.04553195f, 0.02398993f, -0.03311720f, 0.00843717f, 
    -0.02412458f, -0.01129562f, 0.04657320f, 0.05829305f, -0.09162353f, -0.09051649f, 0.07253096f, 0.06592063f, 
    0.01307843f, 0.06015589f, -0.07470477f, 0.02210249f, 0.07806840f, 0.06253348f, 0.02622073f, -0.01561060f, 
    0.05775307f, -0.08256831f, 0.02344607f, -0.04381637f, -0.05511670f, 0.06925023f, 0.02702087f, 0.02337527f, 
    -0.03339728f, 0.05809129f, 0.02631743f, -0.05891137f, -0.00912930f, -0.09352826f, 0.07095216f, -0.05998264f, 
    -0.08104143f, -0.02303011f, -0.04152744f, -0.02419071f, -0.09406527f, 0.01924916f, -0.08098308f, -0.03726041f, 
    -0.01295204f, -0.00094155f, 0.08116765f, -0.01509721f, -0.06986007f, 0.00556364f, -0.05451749f, 0.00978352f, 
    0.04482856f, 0.00976435f, -0.06630173f, -0.00782990f, -0.06434768f, -0.04329907f, -0.06842071f, -0.03358468f, 
    0.01925726f, -0.00364511f, -0.09141032f, 0.03729074f, -0.04159471f, -0.08020675f, -0.03472783f, -0.03374161f, 
    0.00598560f, -0.04860100f, 0.07174077f, -0.01390858f, -0.04313232f, 0.04322084f, -0.05293160f, -0.02826020f, 
    -0.05355294f, -0.04624163f, 0.05632365f, -0.00599030f, -0.08252127f, 0.02532812f, -0.06305915f, 0.07520365f, 
    -0.00738395f, 0.06810880f, 0.02125601f, -0.00880090f, -0.05307959f, -0.06765036f, -0.03728122f, 0.00479870f, 
    -0.07667257f, 0.03978929f, 0.05393549f, 0.03462974f, -0.01798016f, 0.00484096f, -0.05923225f, -0.02353673f, 
    0.07886082f, 0.03253233f, 0.05447487f, -0.05253288f, -0.03165202f, 0.05830707f, 0.02614512f, -0.03704211f, 
    0.07748581f, 0.06288069f, -0.05209367f, -0.07463235f, 0.02259559f, -0.00681013f, -0.00328559f, 0.07119732f, 
    0.02169010f, -0.03478496f, -0.04085425f, 0.07592427f, -0.08317186f, 0.03175325f, 0.07084511f, -0.01011342f, 
    -0.35204098f, 0.04641734f, -0.29958799f, 0.15410352f, 0.05040007f, -0.17869347f, -0.09977268f, -0.43867612f, 
    0.04098307f, 0.05399700f, 0.11763909f, -0.10515187f, -0.51437277f, 0.07635609f, -0.26879129f, 0.05324676f, 
    0.04383816f, -0.22327209f, 0.02805251f, 0.17424844f, 0.03152052f, -0.08517884f, 0.36829793f, -0.37146825f, 
    -0.16568342f, 0.02308015f, -0.30723560f, 0.00395650f, 0.04135527f, -0.19430238f, 0.07994940f, -0.61573809f, 
    0.12918976f, 0.05248137f, -0.18714197f, 0.00258977f, -0.03256937f, -0.01099338f, 0.05217471f, 0.10217097f, 
    0.03183295f, 0.10070143f, 0.20760325f, 0.03863384f, -0.10210487f, 0.08039546f, -0.02846404f, 0.01235298f, 
    -0.07526129f, -0.19673203f, 0.00642351f, 0.09900014f, -0.09776307f, -0.29115734f, -0.00511231f, -0.13900977f, 
    0.00218999f, 0.07392213f, 0.11881486f, -0.02336024f, 0.09563451f, 0.04507347f, -0.35424811f, 0.14807989f, 
    0.12285316f, 0.02389455f, 0.20430569f, 0.08306944f, -0.01668957f, 0.10320552f, -0.30186123f, 0.10392647f, 
    0.04745778f, 0.11168173f, 0.01956899f, 0.20047747f, 0.20616631f, 0.03691798f, 0.00591732f, -0.03981331f, 
    0.19265929f, -0.05444629f, -0.01604746f, -0.74003333f, 0.02238236f, -0.24056990f, 0.00666803f, 0.00425651f, 
    -0.02714462f, 0.03239223f, -0.30735350f, -0.26473856f, -0.22195669f, 0.07503624f, -0.02563689f, 0.06456017f, 
    -0.45854422f, 0.12033395f, -0.05091955f, -0.23539300f, -0.03725480f, -0.04620360f, 0.20016220f, -0.00303852f, 
    -0.14788654f, 0.02673096f, -0.22412984f, 0.06318338f, -0.05879206f, 0.08784842f, 0.09712934f, 0.03806151f, 
    0.05181659f, -0.58790386f, 0.00850337f, -0.05307995f, -0.38625950f, -0.06765946f, 0.03501504f, -0.05028536f, 
    -0.28608739f, 0.14191741f, -0.04462172f, -0.17997371f, 0.03817146f, 0.18984595f, -0.04044849f, 0.02448304f, 
    -0.05372895f, 0.01820926f, -0.25954935f, 0.04124663f, -0.00948474f, -0.18629828f, -0.15148866f, -0.36160535f, 
    0.10525157f, 0.10424660f, 0.04647751f, 0.25533986f, -0.06189271f, -0.02280881f, -0.04423178f, -0.04753032f, 
    -0.10494497f, 0.28793702f, 0.14756532f, -0.28230721f, -0.06544625f, 0.00491823f, 0.07799247f, 0.11401427f, 
    -0.01863062f, -0.33858806f, 0.13327630f, 0.02058668f, 0.01312433f, -0.16681102f, 0.04892827f, -0.26118445f, 
    0.12681614f, 0.07378907f, 0.00794322f, -0.05594832f, 0.11024544f, -0.16728260f, 0.12948412f, 0.17888345f, 
    -0.07618247f, 0.08951410f, -0.17384084f, 0.08749326f, -0.00128685f, 0.01266688f, 0.08812661f, 0.13392261f, 
    0.31587601f, 0.23970361f, -0.02493461f, 0.10677155f, 0.04108443f, 0.07973633f, 0.05300474f, -0.00939417f, 
    -0.14586933f, 0.10354454f, 0.12667894f, -0.03923878f, 0.22818175f, -0.15374334f, 0.16075872f, 0.36225295f, 
    0.04225783f, 0.05073984f, 0.20007855f, 0.10760658f, 0.05610909f, 0.05467693f, -0.15139222f, 0.00359978f, 
    0.20482209f, 0.01213176f, 0.07935271f, 0.10258989f, 0.18787324f, -0.03355506f, -0.03690382f, -0.12046286f, 
    -0.04586666f, 0.09667885f, 0.16720659f, -0.11722910f, -0.20294207f, -0.04872474f, -0.01847295f, -0.04407537f, 
    0.16507967f, -0.26255363f, -0.02447486f, 0.15884750f, -0.16209553f, 0.13330454f, 0.07908356f, -0.06071932f, 
    -0.09517951f, -0.02018585f, 0.08108702f, 0.06504785f, 0.23162805f, -0.03029625f, 0.25256309f, -0.00225334f, 
    0.14506812f, 0.29659873f, 0.02831293f, -0.04569447f, 0.01583415f, -0.16928084f, 0.03311604f, -0.03508929f, 
    0.16752754f, -0.20636480f, -0.08333567f, 0.02642866f, -0.00584248f, 0.03432705f, 0.28474456f, -0.12065806f, 
    0.04917867f, 0.04472258f, 0.05853950f, -0.08892010f, -0.01320424f, -0.14822446f, -0.12140843f, 0.04676253f, 
    0.16282436f, 0.01652272f, 0.77947772f, 0.03067709f, 0.09590250f, -0.23131213f, -0.07572047f, 0.26955429f, 
    -0.02180681f, -0.27753749f, -0.14603741f, -0.08711179f, -0.04785380f, 0.10474315f, 0.13597463f, 0.01453853f, 
    -0.34403846f, -0.07165259f, 0.19045785f, -0.01541937f, -0.06341520f, -0.13670158f, 0.23842607f, -0.04366864f, 
    0.01891310f, 0.09118169f, -0.29542342f, -0.06014002f, 0.11483679f, -0.13744691f, -0.08198210f, 0.32144067f, 
    -0.34817091f, -0.08248886f, -0.21470881f, -0.05966267f, 0.06955124f, -0.14869936f, -0.07053354f, -0.34990236f, 
    0.04356441f, -0.00751639f, 0.09084082f, -0.24622422f, 0.00425977f, -0.17702821f, -0.06591256f, 0.02407514f, 
    0.72945130f, -0.03516454f, -0.02324674f, 0.21639553f, 0.26946303f, -0.06194130f, 0.05589201f, 0.05927780f, 
    -0.12986417f, 0.13772322f, -0.01361659f, 0.17845118f, 0.30330342f, 0.14270316f, -0.21878590f, -0.05146559f, 
    0.17317715f, 0.06335843f, 0.02603918f, 0.02436892f, -0.00265392f, -0.00264090f, -0.10116274f, -0.12560037f, 
    0.43447697f, -0.09012011f, -0.08990809f, -0.16249001f, 0.06551181f, 0.08136435f, -0.00218115f, -0.38925603f, 
    -0.25472182f, -0.09102843f, -0.14240064f, 0.01553388f, -0.06491407f, 0.00158032f, -0.11486733f, 0.02166184f, 
    0.03153783f, 0.13388892f, -0.33906183f, -0.10820044f, -0.01673619f, 0.07635192f, 0.00700032f, -0.00001406f, 
    -0.26352939f, -0.17055826f, 0.12819476f, 0.12105494f, -0.49136174f, -0.26075619f, -0.45234057f, -0.06817724f, 
    0.06002631f, -0.27178901f, 0.22403100f, -0.07923066f, -0.07117207f, 0.01379015f, -0.02461980f, 0.15945676f, 
    -0.25972828f, 0.30649742f, 0.30677584f, -0.18069327f, -0.35049108f, -0.02442830f, 0.00734761f, -0.31801948f, 
    -0.11180945f, 0.06330341f, 0.10448828f, -0.18648450f, 0.03184820f, 0.00943690f, 0.04592416f, 0.12601729f, 
    -0.16322966f, 0.07300082f, 0.21003804f, -0.09753236f, -0.24639283f, -0.06041414f, 0.16032000f, -0.09180754f, 
    0.16304585f, 0.18032207f, -0.33341148f, -0.05552970f, -0.04653355f, 0.01153440f, 0.24630585f, 0.00930590f, 
    0.11920754f, -0.11400608f, 0.18794277f, -0.27237192f, 0.13242410f, 0.10476035f, 0.10427032f, -0.03812682f, 
    0.11907906f, -0.24777350f, -0.01870698f, 0.06863225f, 0.13003871f, 0.07137781f, -0.07830878f, 0.13348638f, 
    -0.08360451f, 0.00860727f, 0.03335294f, -0.02802457f, 0.16607204f, 0.04726669f, 0.11988758f, -0.15911788f, 
    0.08850350f, 0.17220303f, 0.16490351f, 0.02376818f, -0.09611756f, -0.14212926f, -0.07358622f, 0.09937552f, 
    -0.29146114f, 0.17478466f, 0.03244252f, 0.18187484f, 0.10084555f, 0.00371193f, 0.11982672f, 0.08433615f, 
    0.08025843f, -0.01871696f, -0.11333248f, 0.15997188f, -0.08224190f, -0.05733778f, -0.05261040f, 0.01046905f, 
    0.19697195f, 0.29973063f, 0.08017737f, -0.27364409f, 0.09355535f, 0.07773700f, -0.03370121f, -0.07860524f, 
    0.15658708f, -0.01487085f, 0.14419612f, -0.27240190f, 0.02303670f, 0.03626521f, 0.05432318f, 0.09309570f, 
    -0.22477704f, -0.01791784f, 0.09401397f, -0.03171672f, -0.32683551f, 0.17478439f, 0.57975674f, -0.05945663f, 
    0.19402474f, 0.39885998f, -0.16490611f, -0.08878957f, 0.03891497f, 0.20610970f, -0.06713311f, -0.01028470f, 
    -0.10265956f, -0.27391145f, 0.30443370f, 0.02740696f, -0.02837504f, -0.31808025f, -0.16035140f, -0.01118734f, 
    0.06754008f, 0.01802513f, 0.20153347f, -0.24496284f, -0.07881460f, -0.04964956f, 0.13482322f, 0.17421658f, 
    -0.28489423f, 0.02675072f, -0.31484944f, 0.07576175f, -0.12740490f, 0.05519961f, -0.05854722f, -0.20235719f, 
    -0.00863177f, -0.41940930f, 0.19937910f, -0.19974338f, -0.03013637f, 0.37717250f, 0.05627218f, 0.05871040f, 
    -0.16466145f, 0.14040242f, 0.17688975f, -0.10666560f, -0.26358652f, 0.22784044f, 0.22523636f, -0.17303219f, 
    0.01380420f, -0.08495967f, -0.30637011f, -0.09590520f, 0.04373010f, 0.18495996f, 0.31110227f, 0.02412386f, 
    0.32974902f, 0.26792723f, 0.03050467f, 0.22039659f, 0.03719853f, 0.00989411f, 0.19363409f, 0.05953758f, 
    0.24048288f, -0.29564199f, 0.11375518f, -0.08569735f, -0.05600982f, 0.15000594f, 0.04568949f, 0.15199305f, 
    0.06073283f, -0.04136665f, 0.09875490f, -0.18928759f, 0.07561481f, 0.17812787f, -0.13931090f, 0.05228338f, 
    0.02164591f, 0.02738179f, 0.22045209f, -0.02062647f, -0.05940617f, -0.32592714f, 0.03562761f, 0.14039332f, 
    -0.24707077f, 0.13210581f, -0.01947946f, 0.02568769f, 0.28032097f, -0.16902073f, 0.17266636f, 0.09593314f, 
    0.18134657f, -0.19668841f, -0.07985543f, 0.17739642f, -0.05255853f, 0.19894122f, -0.07156922f, 0.27269799f, 
    -0.01613218f, 0.00233202f, -0.05356980f, -0.37885001f, 0.09740151f, -0.13229859f, -0.06684055f, -0.45876104f, 
    0.02891239f, 0.22149619f, -0.16448388f, -0.32546708f, -0.08675952f, 0.10252358f, 0.00043995f, -0.02083267f, 
    -0.00820468f, -0.14133395f, 0.12644720f, -0.00463453f, -0.15450957f, 0.38015139f, 0.25464189f, 0.07070735f, 
    0.01431564f, -0.00240278f, 0.13141762f, 0.08538291f, 0.03900883f, -0.10789965f, 0.05668700f, -0.07555313f, 
    0.05144377f, -0.30859205f, 0.12435582f, 0.15192957f, -0.07587194f, -0.26698083f, 0.30539498f, -0.08807725f, 
    0.17533691f, 0.04602308f, 0.15045723f, -0.09477020f, -0.07574685f, 0.04032779f, 0.02010029f, 0.29740083f, 
    -0.25594625f, 0.09143666f, 0.04858183f, 0.30667967f, 0.13122916f, 0.05580850f, 0.16957542f, -0.13364750f, 
    0.30412298f, -0.20231628f, 0.14850071f, -0.06026068f, -0.18113226f, 0.14269537f, -0.06669468f, 0.01894828f, 
    0.10507374f, -0.18278080f, 0.32704738f, 0.02375928f, 0.02492305f, -0.34689528f, -0.19579849f, -0.23110780f, 
    0.23916301f, 0.12032678f, 0.28877842f, 0.43079427f, 0.13318478f, -0.03532566f, -0.01332331f, -0.00089277f, 
    -0.13879092f, -0.12416670f, 0.29971996f, -0.18518732f, -0.07690486f, 0.12036646f, -0.05114625f, 0.19048475f, 
    -0.16258945f, -0.00051280f, 0.12321615f, 0.04163214f, -0.03613199f, -0.04104005f, -0.08037328f, -0.12188881f, 
    0.11362744f, 0.04812167f, 0.21950617f, 0.25957754f, 0.05620093f, -0.25040814f, 0.26421186f, 0.29645452f, 
    0.06865325f, 0.03919585f, -0.14309289f, 0.24879111f, -0.00694455f, 0.38500565f, -0.05049502f, -0.11336770f, 
    0.21666914f, 0.39397389f, 0.09556249f, -0.06348779f, -0.05590685f, 0.32464781f, -0.03263531f, -0.07038625f, 
    -0.18160570f, 0.16268227f, 0.11676741f, 0.10267990f, 0.35722664f, -0.13803159f, 0.21334976f, -0.10107557f, 
    0.07611655f, -0.11782688f, 0.14982305f, 0.36830318f, 0.14402375f, 0.00635745f, 0.08023548f, 0.18094148f, 
    0.09734239f, -0.17946456f, 0.24130934f, 0.44947463f, 0.52498746f, -0.08688678f, 0.00898063f, 0.19999593f, 
    0.13901588f, 0.27567345f, 0.10817403f, 0.01197573f, -0.13246432f, -0.26406205f, -0.10242655f, 0.02785926f, 
    -0.22042653f, 0.33498192f, -0.19098294f, -0.00547620f, 0.04579599f, 0.13082857f, 0.01558698f, -0.03675981f, 
    -0.01107293f, 0.38136169f, 0.00115652f, -0.09462810f, 0.19550681f, 0.05254001f, -0.14099838f, 0.02975243f, 
    0.06686457f, -0.00869558f, -0.03799720f, -0.14855139f, 0.04173132f, -0.04543442f, -0.10771995f, -0.02810165f, 
    0.29900953f, -0.06519920f, -0.38204902f, -0.24695660f, -0.04317291f, -0.04661872f, 0.00261138f, -0.25166047f, 
    -0.13018315f, -0.03161772f, -0.31752953f, 0.13884598f, 0.21532848f, -0.25375935f, -0.06731839f, -0.03572035f, 
    -0.12449107f, -0.08974431f, -0.03774721f, 0.06293766f, 0.02344360f, -0.02310510f, -0.03938328f, 0.12691754f, 
    0.03358676f, 0.09383705f, -0.05631164f, 0.12936142f, 0.12624422f, 0.00276158f, 0.11293689f, -0.11308564f, 
    0.00184423f, -0.08093457f, 0.06595041f, 0.02876173f, -0.07651260f, 0.01231079f, 0.07697080f, 0.09363523f, 
    -0.04227998f, 0.02690892f, -0.02009244f, 0.04212406f, -0.04727282f, -0.14008601f, -0.06005776f, -0.11033699f, 
    -0.13144162f, -0.01743771f, -0.04462798f, 0.01731829f, -0.03785116f, -0.01452984f, -0.10174631f, -0.05058306f, 
    0.00438773f, 0.03963765f, -0.01550704f, -0.09885147f, -0.17402273f, -0.07588625f, -0.03602523f, -0.13890180f, 
    -0.16130309f, 0.01797059f, 0.00322311f, 0.02305274f, -0.12355455f, 0.09272205f, -0.06259114f, 0.03524101f, 
    -0.10446490f, -0.07692245f, -0.05811817f, -0.01665233f, 0.00960390f, -0.08806297f, -0.18497495f, -0.09650213f, 
    -0.08640730f, -0.05490958f, 0.01500330f, 0.05298735f, -0.07564729f, -0.10290904f, -0.07817288f, 0.02731461f, 
    0.05816484f, 0.05467555f, 0.00408189f, -0.07446769f, 0.03845831f, 0.01840429f, -0.08397003f, 0.08434052f, 
    -0.20874530f, -0.11359584f, 0.04786518f, -0.08771130f, 0.02708448f, 0.05512708f, 0.06067459f, 0.06722265f, 
    -0.03084203f, 0.03560840f, -0.01328416f, 0.05732121f, -0.10622720f, 0.03999354f, -0.04471993f, -0.07632691f, 
    0.00297368f, -0.08357642f, 0.03013169f, -0.00629060f, 0.00356295f, -0.07318245f, -0.02028057f, -0.06297424f, 
    0.07744148f, -0.12699021f, -0.11092182f, 0.00409987f, 0.08510404f, -0.07654113f, -0.01133429f, -0.06813825f, 
    -0.00647107f, -0.18281290f, 0.05325394f, 0.05573798f, 0.03501193f, -0.01543749f, -0.16335924f, 0.01461765f, 
    -0.02537068f, -0.04901976f, -0.02271174f, 0.19290191f, -0.07395531f, -0.07000436f, -0.00172027f, -0.02597233f, 
    0.25200781f, 0.01940163f, 0.24443632f, -0.13526320f, 0.03348264f, 0.07692967f, -0.23727170f, 0.22948210f, 
    -0.32145521f, -0.02150929f, 0.24811904f, 0.49475470f, 0.03980868f, -0.16499287f, -0.11090954f, -0.10871084f, 
    0.12802367f, -0.10388611f, 0.08964641f, -0.12156281f, 0.01713115f, 0.27293241f, -0.41967949f, 0.13491562f, 
    -0.39360553f, 0.42061284f, 0.06641416f, 0.07337884f, -0.29855937f, 0.11940193f, 0.00970684f, 0.09792627f, 
    -0.04673608f, 0.08172958f, 0.06895114f, -0.25054300f, -0.13645975f, -0.19188070f, -0.07045186f, 0.22277054f, 
    0.03295450f, -0.32133064f, -0.39031488f, 0.25531170f, -0.06563794f, 0.29672080f, -0.05447564f, -0.46608639f, 
    0.32915765f, 0.26546589f, -0.00522847f, 0.08335370f, 0.07426529f, 0.27873608f, -0.12991205f, -0.75638717f, 
    -0.46488336f, 0.13520183f, -0.32553113f, -0.10257242f, 0.18153794f, -0.14964887f, 0.20394312f, 0.19215110f, 
    -0.42888522f, -0.57509619f, -0.19220088f, 0.40314889f, 0.28882208f, -0.34639919f, 0.20745513f, 0.12353235f, 
    0.13277416f, -0.33078551f, 0.00501212f, 0.53439623f, 0.21981072f, 0.07972981f, 0.13323477f, 0.28689882f, 
    0.19579259f, 0.32275862f, -0.06973856f, 0.07691741f, 0.12832189f, -0.19341408f, -0.21741623f, 0.04645829f, 
    -0.42114204f, 0.32994741f, -0.05912799f, -0.01897402f, 0.09910842f, 0.00412418f, 0.04190362f, 0.00314753f, 
    0.13883555f, 0.32545429f, -0.03873379f, -0.47570342f, 0.37327066f, -0.08630741f, 0.05101974f, 0.02535469f, 
    -0.00437696f, 0.17584024f, -0.28876069f, 0.11379667f, -0.04850277f, 0.06334485f, -0.35474136f, -0.62015241f, 
    0.00614468f, 0.16993602f, 0.46635067f, -0.09009654f, -0.04127625f, 0.04095626f, 0.15292685f, 0.03733400f, 
    -0.18329719f, 0.08747119f, -0.11172505f, 0.34103990f, -0.38597852f, -0.55977875f, -0.00076476f, -0.23509242f, 
    0.21973743f, 0.05339189f, 0.02840289f, -0.07019849f, -0.20965156f, 0.08159067f, 0.07740767f, -0.35558897f, 
    -0.19877963f, -0.03273156f, -0.11058561f, 0.11089405f, -0.10706726f, 0.06741454f, 0.20731035f, -0.03663044f, 
    0.26725271f, -0.06131786f, 0.00231509f, -0.45118675f, 0.08132688f, 0.12127013f, 0.00481757f, 0.11426956f, 
    0.02474388f, 0.02634288f, -0.08150277f, 0.08801082f, -0.25264877f, 0.02786137f, -0.01763119f, 0.20051651f, 
    0.04101718f, -0.06228328f, 0.35907722f, -0.37113610f, 0.04860742f, 0.07620750f, 0.08015293f, 0.07343014f, 
    0.06000397f, 0.16341987f, 0.02846084f, 0.32818350f, 0.04418587f, -0.29849717f, -0.06371841f, -0.01690376f, 
    0.38411865f, 0.24507333f, -0.03783429f, 0.12452570f, 0.27709684f, -0.16146137f, 0.02049238f, 0.07466115f, 
    -0.14306010f, -0.02987698f, -0.17979933f, 0.07813608f, 0.12905544f, 0.11630634f, 0.02608772f, 0.17119491f, 
    -0.16108392f, -0.15897703f, -0.11916790f, -0.27892870f, 0.30596104f, -0.02606505f, 0.24455807f, -0.23204154f, 
    0.11730878f, -0.00132004f, -0.02052441f, -0.10003728f, -0.01650548f, 0.18457030f, -0.07784309f, 0.13155733f, 
    0.07392914f, 0.02603183f, 0.01580116f, 0.33265033f, -0.06566202f, 0.12741987f, -0.18169641f, 0.06874395f, 
    -0.47211990f, -0.22188339f, -0.25742558f, 0.13979436f, 0.23187570f, -0.08072282f, -0.04233507f, 0.01388855f, 
    -0.02938817f, 0.00008731f, 0.01792521f, 0.05422148f, -0.14715685f, -0.07149176f, 0.15937218f, -0.06383996f, 
    0.09112456f, 0.04291359f, 0.19658262f, -0.10948817f, -0.05124155f, 0.04579535f, 0.07076211f, 0.03897033f, 
    -0.21309410f, 0.30312932f, 0.06698457f, -0.05706755f, 0.08321734f, -0.02634750f, 0.21567358f, 0.03981202f, 
    0.22956444f, -0.12368995f, 0.22049569f, 0.00545505f, -0.47922194f, -0.05666898f, 0.23693074f, 0.02443135f, 
    0.41986060f, 0.12581722f, 0.37167767f, -0.05625059f, -0.09080005f, 0.07608651f, 0.17843291f, 0.16696909f, 
    0.15179381f, -0.39132300f, -0.05017361f, -0.33557352f, 0.15532494f, -0.00273754f, 0.20852390f, 0.13678788f, 
    -0.24192984f, -0.28618738f, -0.00313945f, 0.08777382f, 0.10467630f, -0.16882192f, 0.04393917f, 0.12609825f, 
    -0.01959583f, 0.06538772f, -0.33457279f, 0.01780758f, 0.05176116f, -0.06664732f, 0.02988122f, 0.16853057f, 
    -0.34844565f, -0.06506326f, -0.36671415f, -0.10260476f, -0.21835577f, 0.00529449f, -0.31272289f, -0.28402913f, 
    0.00914919f, 0.05567548f, 0.24428026f, 0.19206403f, 0.21661738f, -0.28450063f, 0.05137146f, 0.14960708f, 
    0.47162923f, -0.26883978f, 0.07747883f, 0.21011384f, 0.34045830f, -0.01177238f, -0.00373809f, 0.17450979f, 
    -0.16740604f, 0.04484907f, 0.00584474f, 0.09206360f, -0.00115676f, 0.24391180f, -0.72626621f, 0.15378384f, 
    0.04345247f, -0.04028879f, -0.04809885f, -0.13678756f, 0.07496316f, -0.04511825f, -0.22404644f, -0.11961624f, 
    0.28592709f, 0.17328249f, -0.00503895f, -0.01694829f, -0.12261225f, 0.21608707f, -0.05412157f, -0.19685227f, 
    -0.43277389f, 0.01513480f, -0.14511326f, 0.02383329f, -0.00007216f, 0.03582677f, -0.14671642f, 0.00022695f, 
    -0.06839266f, 0.03010475f, -0.33388618f, 0.14971814f, 0.19142628f, 0.02557792f, -0.06014036f, 0.05599160f, 
    0.10596782f, -0.05740325f, 0.00094049f, 0.01771513f, -0.41326073f, -0.09542729f, -0.73664284f, -0.04852100f, 
    0.25011957f, -0.65359986f, 0.12445245f, 0.28810322f, -0.04203284f, 0.13609836f, 0.07819670f, -0.03715136f, 
    -0.15791251f, 0.13098411f, -0.98397684f, 0.14902654f, -0.28396943f, -0.04514870f, 0.07103576f, -0.01323271f, 
    -0.10785808f, 0.04842630f, 0.00903645f, 0.00234893f, -0.14088058f, 0.10236453f, 0.08956911f, 0.03129844f, 
    -0.00879310f, 0.00447221f, 0.00463024f, -0.01128968f, -0.40695712f, -0.25084054f, 0.28924942f, -0.10264681f, 
    0.29727539f, 0.22914721f, -0.47582564f, -0.17888303f, 0.07337324f, -0.01325492f, 0.29305586f, 0.06261897f, 
    -0.06709979f, -0.12829936f, 0.22196364f, -0.29501525f, -0.06237509f, -0.08133394f, 0.22597907f, -0.15580164f, 
    0.20625179f, -0.43340990f, -0.09300679f, -0.04616744f, 0.23285282f, -0.01856984f, 0.07790470f, 0.10121357f, 
    0.04359633f, -0.08081579f, 0.22631039f, 0.13502845f, 0.17598066f, 0.00283834f, 0.38700029f, -0.12795962f, 
    0.04730016f, -0.03403346f, 0.18022254f, 0.19539587f, -0.01421147f, -0.04270129f, 0.01652897f, 0.13298188f, 
    -0.39898902f, 0.25213838f, -0.10462385f, 0.14945000f, 0.05521150f, 0.07557926f, 0.10532487f, 0.22913170f, 
    0.32685634f, -0.02498939f, -0.03806546f, 0.08809436f, 0.00670002f, 0.02157771f, -0.02723794f, -0.11898679f, 
    0.19948974f, 0.38303286f, 0.20500843f, -0.23958315f, -0.01432610f, 0.13089937f, 0.03231978f, -0.35588625f, 
    0.10965022f, -0.18395421f, 0.12972766f, -0.30927896f, -0.08704364f, 0.10983052f, -0.09508226f, 0.07361907f, 
    -0.18616866f, 0.07266589f, 0.21568193f, 0.14947391f, -0.18742980f, -0.05736790f, 0.40389776f, 0.00837906f, 
    0.20278680f, -0.10112374f, -0.15510677f, 0.03914071f, 0.02965725f, 0.19686092f, -0.00871426f, 0.03183601f, 
    -0.02264727f, -0.23737155f, 0.24984591f, 0.19327714f, 0.11776081f, -0.19253510f, 0.06319086f, -0.04392646f, 
    -0.12295747f, 0.02114551f, 0.39586097f, -0.33543164f, 0.08625218f, -0.04681251f, 0.13235500f, 0.20429607f, 
    -0.20249666f, 0.03862599f, -0.73201448f, -0.03571129f, -0.07400498f, 0.07345051f, -0.07340400f, -0.46862668f, 
    0.04953864f, -0.53041512f, 0.17929582f, 0.00628770f, -0.02163949f, 0.36049816f, -0.02620346f, 0.07582986f, 
    0.06354500f, 0.04283082f, 0.01060641f, 0.07006729f, 0.04147133f, 0.00625120f, 0.02519188f, 0.01839827f, 
    -0.01807516f, 0.05776705f, -0.10905746f, 0.00513806f, 0.05892962f, 0.05634726f, 0.04225439f, -0.06241612f, 
    -0.00005110f, -0.01668331f, -0.09612343f, 0.06398916f, -0.10258032f, -0.00944273f, -0.07240283f, -0.04310460f, 
    -0.01342505f, -0.01450919f, -0.07337005f, -0.04174259f, 0.07729203f, 0.06222283f, 0.03695509f, 0.04344718f, 
    -0.06751797f, 0.06506120f, -0.08345479f, -0.06730940f, 0.00300820f, -0.03717759f, -0.01126838f, 0.02342520f, 
    -0.01197076f, 0.06664014f, -0.05320295f, -0.06010202f, -0.01557914f, 0.04197921f, -0.05442556f, 0.07016453f, 
    -0.08357748f, 0.06593876f, -0.02896617f, -0.06040645f, -0.08496713f, 0.05434527f, -0.01865336f, -0.00688012f, 
    0.01356658f, -0.08724929f, -0.06741931f, -0.06659389f, -0.01709126f, 0.04627378f, -0.03755075f, 0.00173113f, 
    -0.02781576f, -0.03920179f, -0.09472707f, -0.06266200f, 0.02731019f, -0.01287223f, 0.03059876f, -0.03744318f, 
    -0.02239418f, -0.03876219f, -0.09124962f, -0.02487293f, -0.01972178f, -0.01769862f, -0.07734209f, 0.03402245f, 
    0.02774856f, 0.05776742f, 0.06781493f, -0.09097727f, -0.06989940f, 0.05864388f, -0.04157432f, -0.08358390f, 
    -0.07699879f, -0.08066981f, 0.04036378f, -0.03120149f, 0.02354278f, 0.01489109f, 0.02878066f, -0.05438641f, 
    0.03734107f, -0.01104744f, -0.05362988f, 0.07646803f, -0.02598645f, 0.05289089f, -0.08185864f, 0.02986587f, 
    -0.05149399f, -0.02906036f, 0.03589663f, -0.05253081f, -0.08299691f, -0.07086156f, 0.04422646f, -0.00315197f, 
    0.05662538f, 0.00703050f, -0.00513592f, 0.01659362f, 0.02894836f, 0.04473382f, -0.04125081f, -0.06434108f, 
    -0.07772585f, -0.03114530f, 0.00628862f, 0.04582470f, 0.02695185f, -0.07657825f, 0.02060637f, -0.07649488f, 
    0.05439984f, 0.02371190f, 0.00679355f, 0.01948396f, -0.05619191f, 0.07403572f, 0.05174997f, 0.01948825f, 
    -0.09986828f, 0.00323572f, -0.06963883f, -0.02443114f, 0.01461422f, 0.03343122f, -0.01650780f, -0.03883644f, 
    -0.04092913f, -0.07953368f, -0.08214061f, -0.05671531f, -0.09333054f, 0.05925951f, -0.02305347f, 0.00603827f, 
    -0.06634866f, -0.08336592f, -0.04409987f, 0.07724672f, -0.00580442f, -0.02245598f, 0.08184639f, -0.06610083f, 
    -0.04691715f, 0.05400725f, -0.05576150f, -0.00597770f, 0.05588487f, 0.02425148f, -0.01481495f, -0.06874132f, 
    -0.00709147f, -0.07057688f, 0.02818981f, 0.04527526f, -0.02815361f, 0.06075934f, 0.06223683f, -0.05081528f, 
    -0.02540587f, -0.02494262f, 0.00607842f, 0.07067952f, -0.01205441f, -0.05318374f, -0.08675971f, -0.04035774f, 
    0.03451945f, -0.03460041f, -0.06073085f, -0.05711073f, 0.00399857f, -0.02580481f, -0.03875603f, 0.03942152f, 
    0.01873986f, -0.06161724f, -0.01292673f, 0.07769009f, -0.09070391f, -0.08457420f, -0.04809123f, -0.08390515f, 
    -0.00347941f, 0.02049583f, -0.05214137f, 0.02509773f, -0.08948207f, -0.02349977f, 0.02335903f, -0.08872247f, 
    0.06877434f, 0.03464187f, -0.01718716f, 0.05619461f, 0.06035199f, -0.00629064f, 0.06311586f, 0.05784722f, 
    0.01775471f, 0.04653622f, 0.06986492f, -0.09287750f, 0.00789670f, -0.01175408f, -0.07419406f, 0.02227642f, 
    -0.01217675f, 0.07711232f, 0.00307320f, -0.08052772f, 0.01922987f, -0.04253776f, 0.00507309f, 0.04128424f, 
    0.04731799f, 0.05815458f, -0.04560763f, 0.05914858f, 0.08443707f, -0.04900808f, -0.00219994f, -0.08988976f, 
    0.05047416f, -0.06817825f, -0.03708277f, 0.04306855f, -0.00781103f, -0.01122043f, -0.06814736f, -0.06457404f, 
    0.08048256f, 0.03595458f, 0.02306060f, 0.08130550f, 0.01729413f, -0.02896921f, 0.02750732f, -0.06086878f, 
    0.29561800f, 0.23220640f, 0.13303235f, -0.38767552f, -0.38585541f, 0.16539292f, 0.22464642f, -0.13338645f, 
    0.30151951f, 0.11289111f, -0.15575682f, -0.22440831f, -0.07766257f, -0.44860485f, -0.02564330f, -0.11167289f, 
    -0.11025196f, -0.23262237f, -0.22539361f, 0.18246460f, -0.11795696f, 0.01530652f, 0.36558136f, -0.18408157f, 
    0.26726601f, 0.18644536f, 0.21541145f, 0.06710432f, -0.23810668f, -0.15838277f, 0.03484390f, -0.23869145f, 
    0.07620223f, -0.03860821f, -0.06740088f, -0.68053281f, 0.12238596f, 0.43321517f, 0.26838934f, 0.04946542f, 
    0.05310135f, -0.12171761f, -0.00874560f, -0.00113224f, 0.12649894f, -0.36961493f, -0.04073067f, 0.28270864f, 
    0.15757331f, -0.41094539f, 0.05021018f, 0.08114151f, 0.09892616f, 0.10165699f, -0.37406826f, 0.23593107f, 
    -0.18870914f, 0.18062039f, 0.20992044f, -0.20793219f, 0.06954745f, -0.21534142f, 0.06012014f, -0.02749705f, 
    -0.10014413f, 0.15703845f, 0.20341422f, -0.35060325f, -0.09792403f, -0.04759130f, -0.02313294f, -0.21896869f, 
    0.17805490f, -0.18033916f, -0.02029325f, 0.00831493f, -0.15140176f, -0.20513593f, -0.07466015f, -0.40291762f, 
    -0.17186053f, 0.12233317f, 0.18639831f, -0.00798661f, 0.14881963f, 0.25144491f, -0.22456773f, 0.02907354f, 
    0.24473082f, -0.48620021f, 0.23103611f, 0.07366934f, -0.21614479f, 0.16887510f, -0.05582382f, -0.03494068f, 
    0.06067032f, -0.29815540f, -0.01704706f, 0.09937091f, 0.41207471f, 0.00749581f, 0.41590276f, 0.05263953f, 
    -0.30248675f, 0.35092723f, 0.26112759f, -0.14227450f, -0.01969584f, -0.01952302f, 0.13436541f, 0.06294968f, 
    0.12482513f, -0.12736422f, 0.15996000f, 0.08202447f, 0.48237073f, 0.08437174f, 0.13237461f, -0.15539040f, 
    0.21913913f, -0.13440894f, 0.26327667f, 0.06564278f, 0.00525567f, 0.18294293f, 0.10584214f, 0.15305947f, 
    -0.25466409f, 0.02547069f, -0.32037637f, -0.03491961f, -0.27419683f, 0.34487262f, 0.10080881f, -0.57663649f, 
    -0.02158041f, 0.38890904f, -0.32625422f, 0.38216045f, 0.07390215f, 0.03444159f, 0.15559685f, -0.14380343f, 
    0.16749950f, 0.29429403f, 0.20246950f, -0.54853612f, -0.00249778f, 0.07863483f, 0.21289547f, 0.12686585f, 
    -0.06585511f, -0.60303372f, 0.13734250f, -0.07101219f, -0.10026880f, -0.07373238f, -0.00096412f, -0.03421500f, 
    0.21616627f, 0.06222963f, 0.27025384f, -0.08493396f, 0.10546218f, 0.00084657f, 0.03887234f, -0.04318834f, 
    0.07041541f, 0.13818024f, -0.23445116f, 0.24113138f, -0.24877992f, -0.24373212f, 0.04945063f, -0.11344735f, 
    -0.07651343f, 0.61625344f, -0.04649217f, 0.00022355f, 0.05310428f, 0.16821365f, 0.00708746f, -0.03260316f, 
    -0.20028302f, 0.09343792f, 0.04340089f, 0.15004854f, 0.09779983f, -0.31405473f, 0.06514824f, 0.56151658f, 
    0.01910945f, 0.10207088f, 0.08610745f, -0.08420502f, 0.11368899f, -0.18875726f, -0.09061125f, -0.07811331f, 
    0.16381779f, -0.17043036f, 0.07968590f, -0.14252569f, 0.17437689f, -0.19752236f, -0.03159723f, 0.32026738f, 
    0.07201422f, -0.02513272f, 0.35007489f, 0.01669569f, -0.14889881f, 0.24286413f, 0.48947400f, 0.04432677f, 
    0.41366953f, -0.35851291f, 0.32863829f, -0.01210632f, -0.24386311f, 0.00417950f, 0.01663491f, -0.01246380f, 
    -0.10404456f, -0.05639323f, 0.12393638f, 0.10317218f, 0.33731714f, -0.26808056f, 0.44414455f, 0.03373798f, 
    0.08913686f, 0.40845710f, 0.03817109f, -0.46191478f, -0.02689705f, -0.19456354f, -0.24731757f, -0.10455664f, 
    -0.18274397f, -0.10741852f, -0.06772847f, 0.04701246f, 0.20506926f, 0.06985996f, 0.28965819f, -0.21247484f, 
    -0.01794102f, 0.16656050f, 0.14699169f, -0.00882084f, -0.18291767f, -0.06809634f, -0.22636890f, 0.06572440f, 
    0.02101989f, -0.13606764f, -0.14319812f, -0.06821222f, 0.00217366f, -0.10319471f, -0.09032496f, 0.12850584f, 
    0.14680618f, 0.20472580f, -0.08660799f, 0.15012789f, 0.17301789f, -0.04724395f, 0.19783561f, -0.04220574f, 
    -0.00851606f, -0.26886982f, 0.30564520f, -0.14526311f, -0.04535098f, 0.04243653f, 0.16067919f, 0.13215239f, 
    -0.04507899f, 0.08036611f, -0.03152606f, 0.00622140f, 0.16359286f, 0.07602336f, -0.08748105f, -0.08541208f, 
    -0.14384346f, 0.05936490f, 0.01676548f, 0.01218720f, 0.00351973f, -0.22172652f, 0.16081955f, -0.00003579f, 
    -0.10272597f, 0.01425602f, -0.06443496f, 0.18510376f, -0.02257580f, 0.22232880f, 0.06879561f, -0.02530039f, 
    0.16559358f, 0.14311709f, 0.04893991f, 0.23901600f, -0.12885468f, 0.17963585f, 0.11690567f, -0.01075799f, 
    -0.06765378f, 0.14537698f, -0.05815503f, 0.12420618f, 0.25680110f, -0.01617637f, -0.08799812f, -0.10106358f, 
    0.17989266f, 0.08369417f, 0.12301126f, 0.14316490f, 0.06226070f, 0.09996418f, 0.08533409f, -0.05715127f, 
    0.11469396f, -0.13700913f, 0.11799143f, 0.26942477f, 0.27482086f, 0.11215351f, 0.05572473f, 0.30169532f, 
    -0.08042352f, 0.27104014f, -0.04494828f, 0.02548718f, -0.06423333f, -0.16051082f, -0.00902061f, 0.07373475f, 
    -0.23469014f, -0.04721087f, -0.07254313f, 0.06224229f, 0.08970280f, 0.17556064f, -0.00231727f, 0.08021200f, 
    -0.10346420f, 0.07085665f, 0.07511372f, 0.02864680f, 0.19215935f, -0.04329466f, -0.41723770f, 0.06672030f, 
    0.05468716f, -0.39203274f, 0.05287365f, 0.05507815f, -0.07593334f, -0.03064959f, -0.00137679f, 0.10318915f, 
    -0.01459511f, -0.16336295f, -0.50216931f, -0.28396460f, -0.17325985f, 0.06178641f, -0.11424278f, -0.08255867f, 
    0.02893778f, -0.02902258f, -0.27979749f, 0.01026544f, -0.03515804f, -0.00112878f, -0.00075771f, 0.11767166f, 
    -0.23990194f, -0.17364623f, -0.02347132f, -0.01045363f, -0.26154089f, 0.23620917f, 0.13621797f, 0.11357631f, 
    0.05107254f, 0.11141065f, -0.35112032f, 0.10715442f, 0.05989550f, -0.03525653f, 0.07683259f, 0.09657183f, 
    0.02316431f, 0.04141531f, 0.52225721f, -0.20200902f, -0.04330892f, -0.06848723f, 0.10017975f, 0.19381492f, 
    0.10290915f, -0.04726736f, -0.20667151f, 0.05521343f, 0.22491220f, 0.19373354f, 0.05098467f, -0.00747403f, 
    -0.30679825f, -0.05073009f, 0.05902790f, 0.02247178f, 0.07724507f, 0.01037160f, 0.03330655f, -0.07039478f, 
    -0.02200853f, -0.09493519f, -0.02319817f, 0.11903188f, -0.23822565f, 0.04495583f, 0.08111025f, 0.06254207f, 
    0.11612542f, 0.45804760f, -0.02385014f, 0.26041168f, -0.06743474f, 0.04871424f, 0.13838086f, -0.01833815f, 
    -0.08148076f, -0.18585755f, -0.06800475f, 0.27516690f, 0.02761145f, 0.00557257f, -0.14102830f, -0.04500569f, 
    0.14765434f, 0.04862744f, 0.13028908f, -0.02287971f, 0.08992475f, -0.02857072f, -0.03873594f, -0.14653623f, 
    0.06790210f, -0.11365614f, -0.10507783f, 0.25065047f, 0.28303853f, 0.32283071f, -0.00900585f, 0.32272944f, 
    -0.06600716f, 0.07717933f, -0.02607114f, 0.05335727f, -0.00796255f, -0.02477033f, -0.26512274f, 0.00787515f, 
    0.10699983f, 0.25824675f, 0.02557425f, -0.05982222f, 0.06554954f, 0.21292578f, -0.04611089f, 0.01076974f, 
    -0.06193107f, 0.13758937f, 0.27834395f, -0.10739128f, -0.05811421f, -0.35283056f, -0.42532092f, -0.04530888f, 
    0.06317313f, -0.38891810f, -0.07038539f, -0.20911622f, -0.03515934f, -0.06106339f, 0.07395780f, 0.12181929f, 
    -0.29104632f, -0.08781183f, -0.38104352f, 0.06519718f, -0.33286253f, -0.02165742f, -0.21546257f, -0.43928120f, 
    -0.02015371f, -0.09217487f, 0.01663634f, 0.00799884f, 0.12756240f, 0.36264870f, -0.39662230f, 0.07223435f, 
    0.27874187f, 0.08127381f, -0.06690928f, -0.08615864f, -0.04521396f, 0.23875575f, 0.10267401f, -0.12012693f, 
    -0.18032797f, -0.20091014f, 0.09058822f, 0.04322974f, -0.07592382f, 0.13144745f, 0.04348952f, 0.14407572f, 
    0.15581667f, 0.17192386f, -0.31627387f, -0.36676568f, 0.02885667f, -0.01944925f, -0.01277842f, 0.09324922f, 
    0.07896214f, 0.75326347f, -0.09592891f, 0.07006168f, -0.24356273f, 0.17384329f, -0.04473176f, 0.14285231f, 
    0.00131725f, -0.06794337f, 0.23836409f, -0.23141874f, -0.02543607f, 0.18735798f, 0.11694936f, 0.22483197f, 
    -0.04752906f, -0.19322282f, 0.03111038f, 0.08113122f, 0.16219425f, -0.00413272f, 0.05796348f, -0.01224722f, 
    0.08710301f, 0.08336711f, 0.01116688f, 0.16493069f, 0.23261935f, -0.00157122f, 0.04453860f, 0.05914970f, 
    -0.05823416f, -0.01174534f, -0.08593938f, 0.00580932f, 0.09835355f, 0.20898609f, 0.12953566f, -0.00712689f, 
    -0.15659404f, 0.09727544f, -0.04414482f, -0.20985129f, 0.44717002f, 0.05661067f, 0.30671340f, -0.02257776f, 
    -0.05554481f, 0.14141697f, -0.00877731f, 0.13335364f, -0.20259535f, 0.25195467f, 0.03309096f, -0.00005817f, 
    0.23484887f, 0.01962693f, -0.20592472f, 0.45288661f, 0.16363664f, -0.05016264f, -0.21727815f, 0.07090452f, 
    -0.38357961f, -0.21252687f, -0.14457959f, 0.16046672f, 0.41682675f, -0.17844643f, 0.04141361f, 0.03038564f, 
    0.25833273f, 0.18647416f, -0.20644777f, -0.03896956f, -0.11803824f, -0.05387082f, -0.04115625f, 0.06877590f, 
    0.11314032f, -0.09614402f, 0.05185556f, 0.33809152f, 0.04999160f, 0.32631153f, 0.16939738f, -0.03891568f, 
    -0.03426865f, 0.26502782f, 0.42512384f, -0.03178786f, 0.10645282f, 0.02460398f, 0.05686863f, 0.11535624f, 
    0.27748260f, -0.08872490f, -0.01414572f, 0.09229732f, -0.23050627f, -0.05822473f, 0.22184502f, -0.05313663f, 
    0.19423831f, 0.00073339f, -0.30311987f, 0.03834762f, -0.24406661f, 0.21467894f, 0.06076148f, -0.48498875f, 
    0.12683587f, 0.08719154f, 0.05781323f, -0.04694092f, 0.21765523f, 0.05623584f, 0.14142832f, -0.13207249f, 
    0.28362352f, -0.10401040f, 0.06279663f, -0.25421259f, 0.04175195f, 0.21863295f, 0.08832737f, 0.24101420f, 
    0.08680375f, -0.36010322f, 0.31842458f, 0.07118061f, -0.12622069f, -0.13966477f, -0.07514484f, -0.06671456f, 
    -0.01084164f, -0.07972471f, -0.06351493f, -0.16080509f, 0.09944810f, -0.43722695f, 0.01084939f, 0.02278818f, 
    -0.07696801f, 0.17187412f, 0.09639195f, 0.16198285f, 0.06474332f, -0.35189781f, -0.00285868f, 0.10898420f, 
    0.07766822f, 0.00363395f, -0.00461029f, 0.06569172f, 0.17652661f, -0.12750040f, 0.12440991f, 0.23146272f, 
    -0.07904597f, 0.12840417f, 0.06323130f, 0.13287872f, -0.08125978f, 0.07022029f, -0.13285477f, 0.01493201f, 
    0.04218915f, -0.47360882f, -0.03252596f, -0.18719776f, -0.08529064f, 0.00705521f, -0.07486318f, -0.03661886f, 
    0.24181268f, 0.02911550f, 0.04524133f, -0.37433764f, 0.12502803f, -0.10572706f, 0.00318366f, 0.26943204f, 
    -0.22531974f, -0.22322704f, 0.11022331f, 0.04693379f, -0.11819973f, 0.10091188f, 0.01543748f, 0.05746311f, 
    -0.28536069f, -0.09688440f, 0.22855130f, 0.12886253f, -0.04527836f, 0.00045232f, -0.00496602f, 0.03486500f, 
    -0.07088087f, -0.03588308f, 0.05694395f, 0.24791758f, 0.25800475f, -0.00012801f, 0.13831802f, 0.05782526f, 
    0.14451775f, 0.07247570f, 0.28028509f, -0.21088110f, -0.07950882f, 0.05118298f, -0.10998455f, -0.18646014f, 
    0.02343689f, 0.00503900f, -0.57298481f, 0.11575421f, -0.00772396f, 0.07416062f, 0.09694803f, -0.11992578f, 
    0.16784120f, 0.03665597f, 0.05585283f, -0.23937765f, -0.24460447f, -0.10940883f, 0.28460377f, 0.17865025f, 
    -0.39347988f, 0.01853337f, -0.07114933f, -0.08861263f, -0.25970301f, 0.32162285f, 0.07867010f, -0.26243383f, 
    -0.09339476f, 0.17376740f, -0.29190204f, -0.01688388f, 0.02348419f, 0.00961277f, 0.24191611f, 0.02472782f, 
    0.38211536f, 0.44851753f, 0.26829812f, -0.20639312f, 0.06641417f, -0.04450503f, 0.24179758f, 0.08526443f, 
    0.08570848f, -0.34405366f, 0.04665914f, -0.03124947f, 0.20549805f, 0.30917460f, 0.00876112f, 0.12431603f, 
    -0.10546834f, -0.07555049f, 0.02885871f, 0.23865567f, 0.10018483f, 0.06701535f, -0.04171943f, 0.10741810f, 
    -0.04991731f, 0.05292286f, 0.16990829f, -0.11996519f, -0.04691540f, 0.01241385f, 0.08230354f, 0.05252837f, 
    -0.41989863f, 0.30846697f, -0.05539369f, -0.09923548f, 0.02802070f, -0.12495326f, 0.17499064f, 0.01604135f, 
    0.30738226f, -0.25757688f, 0.04294385f, 0.27442199f, -0.10753798f, -0.01449667f, 0.19088893f, 0.25013551f, 
    0.16254005f, -0.00137335f, 0.10974703f, -0.08765718f, 0.06955103f, 0.01189547f, 0.00640416f, -0.33871651f, 
    -0.17904791f, -0.04242478f, -0.24943838f, -0.22009836f, 0.06014113f, 0.21916841f, -0.03366974f, 0.19076347f, 
    0.03021638f, -0.10328557f, 0.13841330f, 0.05899367f, 0.09510481f, 0.23277514f, -0.47852024f, -0.02530109f, 
    0.15053201f, 0.17814964f, 0.15464199f, 0.07606061f, 0.05595455f, -0.05475640f, 0.15922810f, 0.01508359f, 
    0.06075383f, -0.04945388f, 0.26233277f, 0.16249685f, -0.12732351f, -0.15911257f, 0.06685168f, 0.02348634f, 
    0.01509361f, -0.02578975f, 0.04815714f, -0.21797296f, -0.08572561f, -0.03179184f, -0.03063797f, 0.38871706f, 
    -0.18914248f, 0.09036117f, -0.32210109f, 0.05065266f, -0.01042297f, 0.06259197f, -0.08022162f, -0.30979392f, 
    0.08190925f, -0.19759047f, 0.22473373f, -0.22038221f, 0.26889911f, 0.20272394f, -0.25933194f, 0.21468008f, 
    -0.03177956f, -0.01998859f, -0.04091270f, 0.02790400f, 0.04648297f, -0.08056788f, -0.07952014f, 0.03688278f, 
    -0.06140352f, 0.00969029f, -0.00178844f, 0.02212537f, -0.08435780f, -0.06300054f, 0.05052055f, -0.08733895f, 
    -0.00120355f, -0.07560208f, 0.05268874f, -0.06566162f, -0.10705564f, 0.05341210f, -0.02148898f, 0.01445371f, 
    -0.08424418f, -0.08305838f, -0.07740676f, 0.02305192f, 0.05450418f, -0.06046042f, -0.05806445f, 0.05315580f, 
    -0.01129431f, -0.06406826f, -0.03395071f, 0.01542338f, -0.06041852f, -0.05241283f, -0.03115363f, -0.13049349f, 
    -0.01488904f, 0.04163241f, 0.00947530f, -0.02721438f, -0.06011745f, -0.05116165f, -0.00059431f, 0.01969780f, 
    -0.07029130f, -0.00083802f, 0.01648242f, -0.00624821f, -0.01887496f, -0.08465535f, -0.05796401f, -0.09277127f, 
    -0.02924480f, -0.04038833f, -0.02780667f, -0.02905816f, -0.01668185f, 0.05272698f, 0.01063550f, -0.07223634f, 
    -0.03831016f, 0.03351820f, -0.03234646f, -0.00930280f, -0.12344513f, 0.00913957f, -0.04816598f, 0.02079540f, 
    0.04771532f, -0.06778158f, -0.05771362f, -0.12229480f, -0.05570960f, 0.00149071f, -0.05209998f, -0.01795831f, 
    -0.10366873f, -0.11498781f, 0.03370062f, -0.04540716f, -0.04991916f, 0.02059973f, -0.01918071f, 0.02133581f, 
    -0.05982452f, -0.13118139f, -0.07869595f, -0.10337672f, -0.08698741f, -0.00848806f, 0.00698837f, -0.06342346f, 
    0.00110260f, 0.07480069f, -0.04568012f, 0.05969157f, -0.07635797f, -0.02116682f, 0.03108219f, -0.00111990f, 
    -0.02965497f, -0.03625005f, -0.04050167f, 0.04085272f, 0.01163010f, -0.11437516f, -0.10192592f, -0.14318046f, 
    0.04840717f, 0.02637576f, -0.10994678f, 0.07920349f, -0.05319163f, -0.04972676f, -0.01178398f, 0.07551704f, 
    -0.01752636f, -0.01396222f, 0.03237937f, -0.03394670f, 0.01145629f, -0.00770535f, -0.09070195f, 0.04739360f, 
    0.37980172f, 0.24612893f, 0.40315658f, -0.05517583f, 0.03421293f, 0.06794403f, 0.02058818f, -0.10980792f, 
    -0.13650888f, -0.26001525f, 0.01010634f, -0.12176817f, -0.02435790f, 0.14376673f, 0.04547606f, 0.09983843f, 
    0.34256667f, -0.25875044f, 0.11570804f, -0.01196460f, 0.02432465f, 0.21159017f, 0.05931064f, 0.20709416f, 
    0.10757368f, 0.21885164f, 0.00371903f, -0.04443549f, -0.09188620f, -0.03493196f, -0.07845368f, 0.22141618f, 
    -0.21637864f, -0.07125210f, 0.03468879f, -0.02765405f, -0.14861487f, -0.06886765f, -0.09727596f, 0.03363841f, 
    -0.06029350f, 0.11913630f, 0.02675536f, -0.04546797f, 0.22625226f, -0.00573582f, -0.00084005f, 0.09716798f, 
    -0.32453161f, -0.24584766f, 0.07885781f, 0.11437131f, 0.19006228f, -0.07228366f, 0.00034293f, 0.09304091f, 
    -0.12422401f, 0.16766493f, -0.09757220f, 0.08741505f, 0.00877960f, 0.17581338f, -0.14185359f, 0.02488443f, 
    -0.00722437f, -0.02522759f, -0.01916705f, -0.05278426f, 0.11229466f, 0.04808244f, 0.04972678f, -0.02059149f, 
    0.10802650f, 0.11124949f, -0.00279922f, 0.01742388f, -0.18984367f, 0.16346514f, -0.03012628f, -0.05472008f, 
    0.09352054f, -0.06432892f, -0.03803398f, 0.10896217f, 0.12988704f, 0.18905386f, -0.04447764f, -0.06187638f, 
    -0.21711777f, 0.43235970f, 0.01246989f, 0.20904361f, 0.18737066f, 0.05439861f, 0.01985982f, 0.01906361f, 
    0.08456187f, -0.07596915f, -0.07606269f, 0.05245730f, -0.18108644f, -0.05666928f, -0.25423580f, 0.06503628f, 
    0.19597407f, -0.39498514f, 0.20322710f, 0.07782968f, -0.05728494f, 0.13865887f, 0.13228482f, -0.07349773f, 
    -0.07375916f, 0.18438524f, 0.08455421f, 0.07388109f, 0.03709068f, -0.06222244f, 0.15374237f, 0.03611528f, 
    0.05762617f, -0.22740433f, -0.03122125f, -0.11354918f, -0.07010298f, -0.03377157f, 0.20422836f, 0.05023260f, 
    -0.00223660f, -0.07338905f, 0.03932676f, -0.06826435f, -0.04088031f, -0.07457183f, -0.03762127f, 0.04751055f, 
    -0.02165967f, -0.01830981f, 0.03590477f, 0.03616401f, -0.13057464f, -0.02610771f, -0.06908603f, -0.10505781f, 
    -0.08377559f, -0.03769266f, -0.05112655f, 0.00987240f, -0.00279413f, 0.01311277f, -0.07624442f, -0.07484367f, 
    -0.04704593f, -0.01722571f, -0.07449832f, -0.08609650f, 0.01778073f, -0.03209764f, -0.04350805f, -0.06869007f, 
    0.04594862f, 0.07385310f, -0.07916768f, -0.01056166f, -0.09432326f, -0.09520656f, 0.02540232f, -0.08268148f, 
    -0.08209106f, 0.03558242f, 0.02764396f, -0.08214272f, -0.06604204f, -0.10945795f, -0.07653613f, 0.01355475f, 
    -0.02957490f, 0.06801120f, -0.05595741f, -0.11919411f, -0.00143938f, 0.01391643f, -0.09334457f, -0.08700576f, 
    0.01481153f, -0.10551853f, -0.08524963f, -0.00149580f, 0.05267192f, -0.08635941f, -0.08608723f, 0.00162928f, 
    0.01180488f, -0.09867291f, 0.02924578f, 0.00331906f, -0.02813818f, 0.03099370f, 0.06109067f, -0.12326552f, 
    -0.01086650f, -0.01417280f, -0.05474712f, -0.07965893f, 0.00021884f, -0.00926582f, -0.00144033f, 0.08132850f, 
    -0.05430172f, 0.03884464f, 0.03734751f, -0.02901823f, 0.07513028f, 0.06591869f, -0.04460018f, 0.07600545f, 
    -0.01211406f, -0.06815723f, 0.03076624f, -0.07884500f, -0.08319589f, 0.00427032f, -0.07528879f, 0.03121599f, 
    -0.07177615f, -0.04709226f, -0.10479498f, -0.12745531f, 0.01436708f, -0.08234086f, -0.01454008f, -0.07361136f, 
    0.02689745f, 0.00476421f, -0.04348350f, -0.12397515f, 0.02911227f, -0.07293120f, -0.02093008f, 0.02222735f, 
    -0.06885656f, 0.01213654f, -0.06391904f, -0.01629263f, -0.05221538f, -0.00230868f, -0.07759725f, -0.07030836f, 
    0.00673146f, 0.04132777f, -0.09954193f, 0.07669272f, -0.03837393f, -0.04471442f, 0.01638442f, -0.04335163f, 
    -0.03864513f, -0.03414730f, -0.00714020f, 0.02161159f, 0.10796201f, -0.37382963f, -0.06612507f, 0.14284343f, 
    0.32909581f, 0.12175898f, 0.01644911f, -0.07128826f, 0.06379319f, 0.01388061f, 0.20266089f, 0.03329872f, 
    0.14987130f, -0.01467441f, -0.13324298f, 0.04282404f, -0.17900820f, 0.04943256f, 0.27213100f, -0.19047229f, 
    0.08378451f, -0.30586320f, 0.07675811f, -0.02778639f, -0.19986305f, -0.06426755f, -0.00312384f, 0.03658262f, 
    0.22849445f, 0.05188229f, -0.02101888f, 0.16957420f, 0.23910719f, -0.13258018f, 0.27164444f, 0.09703651f, 
    -0.00147328f, 0.11431909f, 0.14356756f, -0.08204301f, 0.20028867f, -0.06441750f, 0.00588402f, 0.06540116f, 
    -0.47219166f, -0.10618620f, -0.01029096f, -0.18518004f, 0.00496995f, -0.07239974f, -0.00213674f, 0.02607610f, 
    0.28940204f, 0.13881145f, 0.18532854f, -0.12084185f, 0.11839484f, 0.10921099f, 0.02520458f, -0.20352416f, 
    0.10329793f, -0.08360375f, 0.00088778f, -0.08254322f, -0.18217422f, 0.13894252f, 0.01687446f, -0.05730107f, 
    0.09333549f, 0.00127434f, 0.10371777f, -0.40139318f, -0.05217059f, -0.04699229f, 0.02949243f, -0.01133129f, 
    -0.00352137f, -0.09096607f, -0.00054027f, 0.07863595f, -0.03745632f, 0.24528477f, 0.11522968f, -0.03522865f, 
    -0.37525427f, 0.14203341f, -0.25432491f, -0.00457016f, -0.04992234f, -0.16988905f, 0.08893000f, 0.00174800f, 
    -0.15070808f, -0.09395704f, -0.10687339f, 0.32992700f, -0.10608029f, 0.16433568f, 0.20473227f, 0.07517116f, 
    -0.09717329f, 0.11497258f, 0.16739194f, -0.14374468f, -0.01218519f, 0.19218224f, 0.01344220f, 0.36161336f, 
    0.13131014f, 0.04476817f, -0.43900764f, -0.26029268f, 0.12761083f, 0.00219796f, -0.11735484f, -0.06512851f, 
    0.22909202f, 0.11087997f, 0.07538759f, -0.17827998f, 0.05969860f, 0.09308448f, 0.28880891f, 0.12400738f, 
    0.28243658f, 0.21741453f, -0.01627880f, -0.11013648f, 0.12037104f, -0.52120197f, -0.16742918f, -0.65226358f, 
    0.14969452f, -0.23959121f, -0.02551088f, -0.33038875f, -0.32714856f, -0.19642437f, -0.08329626f, 0.06396549f, 
    -0.30115369f, -0.22827099f, -0.18165930f, -0.13485701f, -0.02804603f, 0.02418606f, 0.41870937f, -0.47721925f, 
    0.14833516f, -0.06443214f, 0.09561444f, 0.02641866f, -0.00388295f, -0.23030829f, 0.00685343f, -0.14330202f, 
    0.10723320f, 0.07473210f, -0.33690158f, -0.11433180f, 0.15313162f, 0.53588212f, 0.65604192f, 0.05832665f, 
    -0.05827150f, 0.26368061f, -0.01217707f, -0.13852690f, 0.30087206f, -0.12860298f, 0.03228426f, 0.30293462f, 
    0.57131350f, -0.71013093f, -0.07757923f, 0.05478627f, -0.01170143f, 0.03703265f, -0.12256255f, 0.09003465f, 
    -0.12808111f, 0.27718031f, 0.27378839f, -0.18703821f, 0.19360200f, -0.04593406f, 0.12131494f, -0.22633137f, 
    -0.03147865f, 0.22970574f, 0.25150228f, -0.06223141f, -0.24902602f, 0.12054865f, -0.06340694f, 0.00897511f, 
    -0.07072897f, -0.15314990f, 0.07623480f, -0.01685914f, -0.18588737f, -0.06179708f, -0.04904015f, -0.32305032f, 
    -0.10427379f, -0.08189400f, 0.04917959f, -0.21600680f, -0.11164533f, 0.24714264f, 0.17570937f, 0.01816965f, 
    0.10664910f, 0.02559653f, -0.23326494f, 0.07136426f, -0.31596294f, 0.27506986f, 0.06439099f, 0.03648609f, 
    -0.32361057f, -0.29262617f, 0.03422879f, 0.16419621f, 0.06178911f, 0.29707241f, 0.11172604f, 0.02181304f, 
    -0.35695091f, 0.32194713f, 0.16632923f, -0.14637256f, -0.04770878f, 0.08177336f, 0.21983545f, 0.35178548f, 
    0.15961954f, -0.15078087f, -0.86269540f, -0.06150597f, 0.10701931f, 0.05475418f, 0.12381649f, -0.01219308f, 
    -0.05586177f, 0.02581103f, 0.41905791f, -0.05447496f, -0.10299124f, 0.18707024f, 0.27048096f, 0.05496855f, 
    0.12601015f, 0.09370015f, -0.41124690f, -0.02310812f, 0.02514309f, 0.11438363f, 0.08791453f, -0.08126450f, 
    0.47525096f, 0.06407597f, 0.03658578f, -0.31812486f, -0.16125292f, -0.14314915f, 0.10952674f, 0.17650738f, 
    -0.36901292f, -0.19837791f, -0.22934102f, 0.24032767f, -0.07869402f, -0.07826548f, 0.38012001f, -0.33032763f, 
    0.06257875f, -0.00809135f, -0.00206031f, -0.06711102f, 0.07047061f, -0.19477579f, -0.01456173f, -0.11262599f, 
    0.24086612f, -0.00439861f, 0.04009481f, -0.12704489f, 0.05003923f, -0.00095374f, 0.24762240f, -0.08952818f, 
    -0.03758826f, -0.03073857f, 0.18557306f, 0.12665141f, 0.26393691f, 0.00165815f, -0.05207600f, 0.31089807f, 
    -0.06310851f, -0.37846884f, 0.04926392f, 0.10886806f, 0.14925422f, 0.08320466f, -0.07096421f, 0.19589597f, 
    0.08679757f, 0.08261076f, 0.24618113f, -0.16612597f, 0.08690059f, 0.03504988f, 0.00892102f, -0.21836464f, 
    0.00720323f, 0.17784382f, 0.27350616f, -0.02873839f, -0.15833053f, 0.12481911f, -0.12697385f, 0.05825260f, 
    0.19934794f, -0.06701189f, 0.11105931f, 0.00610814f, -0.18922773f, -0.09109943f, 0.08440452f, -0.26081276f, 
    -0.00482231f, 0.21224250f, 0.07916386f, 0.07470188f, 0.19506802f, -0.03583372f, 0.06107416f, 0.08656277f, 
    0.35904089f, -0.06598654f, -0.04682110f, 0.03607107f, -0.18913956f, 0.17758062f, -0.11610822f, 0.06052208f, 
    -0.09181523f, -0.09602141f, -0.00434013f, 0.16451195f, 0.28868783f, 0.15924536f, 0.09684546f, 0.05783455f, 
    -0.22874671f, 0.04509217f, 0.31800416f, 0.05185261f, 0.07375944f, 0.10746582f, 0.18843649f, 0.03754695f, 
    0.03755761f, -0.18813269f, -0.32508677f, 0.11769632f, 0.21437784f, 0.02391741f, 0.04268339f, -0.11941057f, 
    0.26610941f, -0.03225880f, -0.07411050f, 0.09726631f, 0.06906337f, 0.16306910f, 0.22680062f, 0.16689739f, 
    0.16641878f, 0.25252914f, -0.03024228f, -0.33488303f, -0.30966851f, 0.04789006f, 0.10612686f, -0.34440115f, 
    0.23729730f, 0.13627949f, -0.06126470f, -0.08688094f, -0.03098435f, -0.31030464f, 0.07393540f, -0.08041540f, 
    -0.09920353f, -0.25742042f, -0.13482495f, -0.02299594f, -0.00910879f, 0.01178025f, 0.22575232f, 0.01774833f, 
    0.17703322f, -0.11801863f, 0.15942898f, -0.02997516f, -0.28635064f, -0.03493876f, 0.05263314f, -0.05224337f, 
    0.15793003f, -0.03699100f, -0.03443724f, -0.54627347f, 0.03459693f, 0.17775266f, 0.20441815f, 0.05310507f, 
    -0.04512887f, -0.02652341f, 0.05164165f, 0.00000356f, 0.02799942f, -0.32953736f, 0.03890754f, 0.18136145f, 
    0.05328747f, -0.39587343f, -0.05191939f, 0.11620273f, 0.23192246f, -0.05454052f, -0.30340564f, 0.02688681f, 
    -0.01737205f, 0.19754328f, 0.15124130f, -0.17281921f, 0.09722295f, -0.24896039f, -0.02755406f, 0.07474811f, 
    -0.11872382f, -0.27656847f, 0.20138937f, -0.29949906f, -0.12743263f, -0.13906392f, -0.05976544f, -0.30004618f, 
    0.10535737f, -0.10583472f, 0.15735045f, -0.20306693f, 0.00666273f, -0.27954316f, 0.06080969f, -0.36437041f, 
    -0.17910892f, -0.00892443f, 0.26178065f, 0.08913395f, 0.21990283f, 0.12736800f, -0.03708711f, -0.05544490f, 
    -0.15338041f, -0.25466654f, 0.28458175f, 0.14637978f, -0.21082933f, 0.17764400f, -0.06195231f, 0.00414281f, 
    0.05611625f, -0.36531094f, -0.01802934f, 0.08285624f, 0.25723115f, -0.04688755f, 0.61593997f, 0.00519474f, 
    -0.25569898f, 0.45276511f, 0.26496309f, -0.18250407f, 0.02261704f, -0.11619952f, -0.08661097f, 0.06164191f, 
    0.05031216f, -0.00104887f, -0.10491565f, -0.02783729f, 0.37986949f, 0.01954019f, 0.25187114f, -0.08455743f, 
    0.32086995f, -0.35109201f, 0.25527012f, 0.03989670f, -0.23575795f, 0.20802929f, 0.16525716f, 0.11724215f, 
    -0.13390772f, -0.25988248f, 0.28563333f, -0.02299233f, -0.13189219f, 0.09676147f, -0.11185980f, -0.26467922f, 
    -0.07673576f, -0.00701196f, -0.03341491f, 0.33833498f, 0.06536777f, 0.01699482f, -0.13395065f, -0.09422074f, 
    0.17763509f, -0.09643488f, 0.18562527f, -0.20124437f, -0.12222871f, -0.05807547f, 0.05761854f, 0.02882988f, 
    -0.09877665f, -0.17415385f, 0.06860405f, 0.05860530f, 0.01698820f, -0.02010362f, 0.00745524f, -0.19336219f, 
    0.00836644f, -0.04054982f, 0.02015722f, 0.00262938f, -0.01153776f, 0.01323622f, -0.01115264f, -0.18560903f, 
    0.04465280f, 0.01337985f, -0.02466167f, -0.03052837f, -0.05699298f, -0.02692088f, 0.01898310f, -0.06520995f, 
    -0.03384953f, -0.09946289f, 0.08268499f, 0.03851171f, 0.02851920f, -0.14905988f, 0.01650298f, 0.00480228f, 
    -0.03645836f, -0.06753515f, -0.06669827f, 0.06449498f, -0.09748907f, -0.10599838f, -0.32573658f, 0.06445488f, 
    0.03938795f, -0.04280210f, -0.04885265f, -0.02341960f, 0.05266411f, -0.01711530f, 0.02953251f, -0.00045962f, 
    -0.23159496f, -0.03261542f, -0.05786953f, 0.03399659f, 0.19985518f, 0.02823741f, -0.04131036f, 0.10574373f, 
    -0.03967979f, -0.13064770f, -0.13255420f, -0.09594427f, -0.09905362f, -0.33027682f, -0.12710583f, -0.04563149f, 
    0.11507113f, 0.47117874f, 0.07714972f, -0.15050729f, -0.16861783f, 0.05803674f, -0.05824089f, -0.01544243f, 
    -0.16487910f, -0.18577796f, -0.02143075f, -0.05369311f, -0.42484990f, -0.15673454f, -0.03638299f, 0.05140655f, 
    0.00009606f, -0.07083271f, -0.25556836f, -0.28244546f, -0.03004779f, -0.04653558f, -0.00152634f, 0.05150482f, 
    -0.01455634f, 0.06575321f, -0.04500727f, -0.11942647f, -0.49092904f, -0.07689536f, -0.09479554f, -0.24513131f, 
    -0.36221334f, -0.21567978f, -0.10636479f, -0.11002140f, 0.03926356f, 0.06212775f, -0.02884156f, -0.02763972f, 
    0.04390234f, -0.02922535f, -0.04325941f, -0.02766909f, -0.00070254f, 0.01073715f, -0.07855099f, -0.00210188f, 
    -0.08370604f, -0.07894807f, -0.09857153f, 0.07009897f, 0.07167840f, -0.01331326f, -0.09502258f, -0.00222413f, 
    -0.04164151f, 0.04795169f, -0.06300552f, 0.04737630f, 0.01373569f, -0.02610143f, -0.02892886f, -0.11632387f, 
    0.00388930f, 0.00662743f, -0.03376578f, 0.08453183f, -0.04859638f, -0.08531219f, 0.06374942f, -0.01432840f, 
    0.05990716f, -0.05512652f, 0.06988464f, -0.08180436f, -0.07521695f, -0.09035523f, -0.04977496f, -0.00359030f, 
    0.06729759f, -0.00949872f, -0.00240461f, 0.06699277f, -0.09728763f, -0.02641672f, 0.08359773f, -0.05222471f, 
    -0.02432231f, -0.05422289f, -0.03469289f, 0.00060570f, -0.07803785f, -0.01621506f, -0.03478145f, 0.03767375f, 
    -0.00125131f, 0.01414439f, -0.05064682f, -0.03566530f, 0.00503042f, -0.11232555f, -0.01526126f, 0.05536972f, 
    0.02465685f, 0.05484688f, 0.02067280f, 0.03616543f, 0.02042954f, -0.07167046f, -0.04781637f, -0.11473226f, 
    -0.07031329f, -0.05541135f, -0.05962930f, 0.01755420f, -0.03179922f, -0.07791711f, 0.01959481f, -0.04655418f, 
    -0.01493607f, -0.01515096f, -0.06525180f, -0.05797713f, -0.07946093f, -0.01128822f, -0.08292582f, -0.04972856f, 
    -0.01588373f, -0.01901962f, 0.05475210f, -0.08170351f, 0.04947437f, 0.02498858f, 0.05116188f, -0.03830599f, 
    -0.06425573f, -0.10443346f, -0.09802765f, -0.09662344f, -0.01416008f, 0.02134396f, 0.06887910f, -0.06534652f, 
    -0.08946627f, 0.03661274f, -0.04449736f, -0.07222585f, 0.03250624f, -0.10625121f, 0.01937145f, -0.06844546f, 
    -0.05871142f, 0.01531257f, -0.00967862f, -0.06461614f, -0.07675293f, 0.01793886f, 0.02599951f, -0.11315700f, 
    0.01158358f, -0.08957350f, -0.02113488f, -0.03086944f, 0.00781361f, -0.10380642f, 0.03703860f, -0.11112279f, 
    -0.28629619f, 0.21132390f, -0.22045144f, 0.15038291f, 0.06582029f, 0.15635666f, -0.01224932f, 0.35521555f, 
    -0.22896211f, -0.19164287f, 0.13899045f, -0.18101130f, 0.24232928f, 0.17736211f, 0.00116783f, 0.15144533f, 
    0.13089377f, 0.38920736f, -0.07642205f, 0.20324554f, 0.07126623f, -0.09707805f, -0.18181761f, -0.07567687f, 
    0.07077751f, -0.19074816f, 0.05406536f, 0.05299887f, 0.18586458f, 0.06110853f, -0.02137403f, 0.02815915f, 
    0.01886493f, 0.06927486f, -0.15158296f, 0.24170284f, -0.02612478f, -0.01707892f, -0.40493932f, -0.00808722f, 
    0.04346509f, 0.16390599f, 0.28563198f, -0.28816304f, 0.03491541f, 0.06698671f, -0.05728900f, -0.00476312f, 
    -0.29168010f, -0.17634548f, -0.04029226f, -0.11404012f, -0.11556747f, -0.09418459f, 0.16268170f, 0.12570666f, 
    0.24954101f, -0.24800067f, 0.12301151f, 0.14609367f, -0.28186184f, 0.16422893f, -0.06089855f, -0.36314976f, 
    0.02531759f, -0.12998834f, 0.06220578f, 0.18929319f, 0.04061600f, -0.05671095f, 0.00631398f, 0.13852045f, 
    -0.28054643f, 0.11956590f, -0.11521281f, -0.01225014f, -0.11711468f, 0.20238902f, -0.10254057f, -0.14075787f, 
    0.17250071f, -0.06019941f, -0.29363579f, -0.03271163f, 0.02015852f, -0.00637999f, -0.29545876f, -0.05646681f, 
    0.08539910f, -0.46979725f, 0.06527081f, 0.12402861f, 0.07986556f, -0.13924637f, 0.04880747f, -0.05559421f, 
    0.17590730f, 0.09391571f, -0.05155879f, 0.08361758f, -0.14130315f, 0.23613623f, 0.08775397f, 0.08636736f, 
    0.21392664f, -0.31390497f, -0.18251954f, 0.17214265f, 0.02668186f, 0.23543915f, 0.06118407f, 0.19181374f, 
    0.09458419f, 0.08503826f, 0.30018964f, 0.32073563f, -0.15554099f, -0.05443480f, -0.38864991f, 0.13927348f, 
    -0.17940934f, 0.15735130f, 0.07271893f, 0.02691806f, 0.26746875f, -0.03221694f, -0.06958039f, -0.07517252f, 
    -0.02221227f, -0.10789555f, 0.00230734f, 0.01713463f, -0.02858096f, -0.12859410f, 0.03548332f, -0.03412027f, 
    -0.08674384f, 0.03405486f, -0.08451293f, -0.01522729f, -0.03837658f, -0.11565256f, -0.10497493f, 0.01193461f, 
    -0.07259186f, -0.07641807f, -0.13032615f, -0.04642637f, -0.08559026f, 0.04540590f, -0.02048389f, 0.01627028f, 
    -0.09693383f, 0.00214466f, -0.06588288f, -0.03290814f, -0.05843383f, 0.02740043f, -0.01477778f, -0.08711688f, 
    -0.03912904f, -0.03523608f, -0.02859729f, -0.03745258f, -0.02790445f, -0.08798654f, 0.05788987f, 0.07327827f, 
    -0.03515143f, 0.00110918f, 0.03489419f, -0.09943780f, 0.06499191f, 0.02980755f, 0.06389058f, -0.07756604f, 
    0.01823896f, -0.06423915f, 0.08388417f, -0.00549749f, -0.10305449f, -0.11261608f, -0.01608393f, -0.09665460f, 
    -0.11974715f, 0.01471952f, -0.08365181f, 0.01081530f, -0.10386509f, -0.04509724f, -0.00508526f, 0.01137489f, 
    -0.09262941f, 0.01460247f, -0.05761297f, 0.03503969f, 0.02037176f, -0.07845253f, -0.08254749f, 0.00729860f, 
    -0.05741835f, 0.04604475f, -0.05822016f, 0.00367988f, -0.12920123f, -0.10091123f, 0.01037021f, -0.09667105f, 
    0.00279655f, -0.04814556f, -0.08264224f, 0.04275479f, 0.01965738f, -0.08481535f, 0.02011630f, -0.03535076f, 
    0.01600345f, -0.00741910f, 0.03746997f, -0.12421358f, 0.04087193f, 0.01127549f, 0.03335563f, -0.02252153f, 
    -0.05760470f, 0.02769234f, -0.11007454f, -0.08206888f, -0.05445524f, -0.03950489f, -0.05777920f, 0.06174772f, 
    -0.10755783f, -0.04620923f, -0.09643777f, 0.04913780f, -0.02976144f, -0.02636375f, -0.04448826f, -0.12941839f, 
    0.05360314f, -0.03255881f, 0.04357324f, -0.04964255f, -0.10666100f, -0.08748863f, -0.12040509f, 0.02399481f, 
    -0.08848953f, -0.02997446f, -0.09008295f, -0.13098958f, 0.00803141f, -0.07745749f, -0.00514494f, -0.10434769f, 
    -0.01352132f, 0.03456882f, -0.20176215f, -0.01067106f, 0.04006451f, -0.35087195f, -0.03933629f, 0.32572523f, 
    0.25298610f, -0.03559041f, 0.09137741f, -0.00167169f, 0.09635398f, -0.13291921f, -0.01390185f, 0.01143579f, 
    -0.25146681f, -0.16808996f, -0.09176619f, -0.18481991f, 0.08646031f, 0.02345282f, 0.22307642f, -0.11196545f, 
    -0.10506562f, 0.11386420f, -0.01058501f, -0.08003941f, 0.02689778f, 0.08015364f, -0.00680809f, 0.03631633f, 
    0.18638043f, 0.06332999f, 0.15108934f, 0.09774143f, 0.04686005f, 0.09923778f, 0.29807007f, 0.03356570f, 
    0.05962779f, 0.06909847f, 0.05952902f, 0.14066973f, 0.11011301f, 0.21445064f, 0.07087925f, -0.00825859f, 
    0.00084549f, -0.04646779f, 0.06968194f, 0.00694828f, -0.16532864f, 0.32054889f, -0.03607309f, -0.07516108f, 
    0.10545046f, 0.05943492f, -0.01015891f, -0.02022258f, 0.29750666f, 0.00239000f, 0.17919049f, -0.40802091f, 
    0.07764298f, 0.12001092f, 0.05083025f, -0.04133885f, 0.05123360f, 0.06730154f, 0.16849962f, 0.15054640f, 
    -0.05125939f, -0.00622860f, -0.00074484f, 0.16443941f, 0.05991484f, 0.12976450f, -0.02230771f, -0.01917479f, 
    0.21172850f, 0.31470594f, -0.18151121f, 0.10330323f, 0.17476974f, -0.21550097f, -0.11367810f, 0.07316305f, 
    0.03834577f, 0.20377745f, -0.21126927f, 0.01588472f, -0.01437362f, 0.09110796f, -0.06698617f, -0.02468644f, 
    0.06986607f, 0.21670872f, -0.00380107f, 0.00196878f, -0.03446331f, 0.16943818f, -0.11068611f, -0.06122305f, 
    -0.13237590f, -0.08326226f, 0.08077455f, 0.00360166f, -0.08108617f, 0.11602022f, -0.14903973f, 0.08540921f, 
    0.10465783f, -0.01700646f, 0.16498815f, -0.10507537f, 0.00054818f, -0.00594668f, -0.10992294f, -0.09514733f, 
    -0.00043191f, -0.02034743f, -0.21713388f, 0.09574030f, -0.00931466f, 0.03404354f, 0.03343328f, -0.04184083f, 
    -0.01394623f, 0.00943923f, 0.03679726f, 0.02056125f, 0.06795089f, 0.01482958f, -0.04039445f, 0.08503703f, 
    -0.01143575f, 0.02244941f, -0.00789106f, 0.07378058f, 0.04130238f, 0.05092840f, -0.05510053f, 0.06818228f, 
    -0.02925364f, -0.07649946f, 0.04716837f, -0.00794691f, 0.06683904f, -0.02669621f, -0.04756049f, 0.01139000f, 
    -0.00743329f, -0.07651258f, -0.02883022f, -0.03583879f, -0.01304989f, -0.04306831f, -0.04501564f, -0.06278507f, 
    0.05392627f, 0.08161445f, 0.00459129f, -0.08951154f, 0.00970002f, 0.05027290f, 0.02904587f, -0.08348428f, 
    0.04321825f, -0.05860371f, -0.01534989f, 0.07963385f, -0.04325019f, -0.07583583f, -0.05597155f, -0.08722457f, 
    -0.08050988f, -0.06079571f, -0.03467900f, 0.00651919f, -0.07668341f, 0.05205861f, -0.06665724f, 0.07301320f, 
    -0.07630245f, 0.05670656f, -0.06793328f, -0.02057529f, -0.06337524f, -0.01357984f, 0.05875995f, -0.02840119f, 
    -0.00249845f, -0.05562919f, 0.04164685f, 0.05035719f, 0.03701609f, -0.00938658f, 0.04168472f, -0.05923897f, 
    0.02315987f, -0.06398024f, -0.05557594f, -0.08776447f, 0.07049181f, -0.06843621f, -0.03489551f, -0.00885871f, 
    0.00049715f, 0.08239432f, 0.02470354f, 0.04559956f, 0.01306820f, -0.07385961f, -0.01972668f, -0.06634025f, 
    -0.07486347f, 0.00680906f, -0.03081808f, -0.01092533f, -0.07922186f, -0.06056689f, 0.07467642f, -0.03287056f, 
    -0.02476053f, -0.02384803f, 0.07968516f, -0.05481191f, -0.01316771f, -0.02888349f, -0.00186450f, 0.03975087f, 
    0.04836933f, 0.05726209f, 0.03696750f, -0.06898663f, 0.01229614f, -0.07019583f, 0.04137534f, 0.00608017f, 
    -0.05571141f, 0.04133601f, -0.02720230f, -0.05892057f, -0.04505025f, 0.06819434f, 0.06745053f, -0.08519375f, 
    -0.08329660f, -0.03499883f, 0.05079925f, 0.02718007f, 0.04823638f, 0.08252818f, 0.04676032f, -0.01065337f, 
    -0.02063661f, 0.09641488f, 0.06863670f, -0.18686138f, -0.00209123f, 0.22468579f, 0.04002995f, -0.04805185f, 
    -0.11348660f, -0.07269613f, -0.21279034f, -0.13496123f, 0.03477028f, -0.00337039f, -0.06411262f, -0.17870735f, 
    0.14189734f, 0.17428002f, 0.03668865f, 0.04558523f, 0.04736988f, -0.15142247f, 0.08215817f, 0.01427186f, 
    -0.00903268f, 0.10721565f, 0.04720240f, 0.02291015f, -0.09104124f, 0.01538254f, -0.02107566f, 0.04932665f, 
    -0.06889633f, 0.04747698f, -0.07935415f, -0.12940697f, -0.03892167f, 0.19293554f, -0.04087331f, -0.05222829f, 
    -0.06538711f, -0.13479173f, 0.03904124f, -0.06701922f, -0.11490306f, -0.08670278f, -0.00783958f, -0.04718233f, 
    0.29698819f, -0.06834028f, -0.02802172f, -0.02602887f, 0.00800895f, -0.13571866f, -0.22573102f, 0.01693347f, 
    -0.08703310f, -0.20835748f, -0.01231377f, -0.11801695f, -0.06056803f, -0.07561034f, 0.07726855f, 0.15786768f, 
    -0.10740238f, 0.03082591f, -0.00051751f, -0.11439227f, 0.02637901f, -0.14520714f, -0.06843971f, -0.16858341f, 
    -0.04620006f, -0.14111619f, -0.20354277f, -0.12271368f, -0.08402868f, -0.01098956f, -0.01432566f, -0.13967583f, 
    -0.11911992f, -0.00549015f, 0.01531129f, -0.03980017f, -0.03209773f, 0.16711834f, -0.06796726f, 0.01926030f, 
    0.12709861f, -0.02820948f, 0.20799488f, 0.09376667f, 0.01131976f, 0.05604519f, -0.02740572f, -0.01638570f, 
    0.05104368f, -0.20052508f, 0.05703178f, 0.02133326f, 0.04136175f, -0.09434495f, 0.11181001f, -0.04789880f, 
    -0.05219575f, 0.13790686f, -0.00576940f, -0.06003904f, 0.01660090f, -0.11046448f, -0.11658915f, -0.04969148f, 
    -0.21144471f, 0.12408500f, 0.12879781f, 0.11159492f, 0.13868134f, 0.03235311f, 0.03166677f, -0.11516190f, 
    0.07800835f, -0.24595867f, -0.01029296f, -0.08049764f, 0.01243253f, -0.02338265f, -0.21761037f, 0.06666175f, 
    -0.06421707f, 0.02450630f, 0.03914502f, -0.01731881f, -0.11361558f, -0.09295113f, 0.04177504f, -0.06253662f, 
    -0.06828924f, -0.00608480f, -0.12090534f, -0.01375690f, -0.08500180f, -0.04451938f, -0.06938343f, 0.06158187f, 
    -0.05829263f, 0.02141270f, 0.06436533f, 0.02303073f, -0.07630729f, -0.09185731f, -0.11469292f, 0.01067180f, 
    -0.06127264f, -0.05048262f, -0.04285535f, 0.07954904f, 0.04059512f, 0.01704755f, 0.07470349f, -0.09828500f, 
    -0.02377128f, 0.07771263f, 0.00448615f, 0.08278257f, -0.00600150f, 0.00840367f, 0.05280236f, -0.01393176f, 
    0.04418728f, -0.06826802f, 0.05336012f, 0.06389674f, 0.00915814f, -0.06238847f, -0.03974755f, 0.00153955f, 
    -0.05545251f, -0.08755434f, 0.02272884f, -0.02857080f, 0.05883843f, -0.03867716f, -0.00816366f, -0.06083100f, 
    0.00087440f, 0.01453160f, -0.08932722f, 0.02140808f, 0.05485242f, -0.03057295f, -0.01813357f, -0.03592346f, 
    -0.01756167f, -0.06346504f, -0.03532682f, -0.07127431f, -0.03332997f, -0.01290912f, -0.06915142f, -0.00843138f, 
    -0.05633769f, 0.01237560f, -0.05896739f, -0.01795688f, 0.06461444f, -0.00772448f, -0.02216674f, -0.05563756f, 
    -0.10643309f, 0.02032279f, 0.05349274f, 0.06839701f, 0.08305484f, -0.01690518f, 0.01545069f, -0.01376167f, 
    -0.07928791f, -0.06695642f, 0.00172101f, 0.03974190f, -0.11959751f, -0.03415267f, 0.02766669f, -0.00938284f, 
    -0.01035435f, -0.07355920f, -0.10177884f, -0.04869859f, 0.05169208f, -0.02269994f, -0.06326373f, 0.08739741f, 
    0.02206686f, -0.06050021f, -0.00812626f, -0.01438030f, -0.00398601f, -0.02310256f, 0.03269262f, -0.05813406f, 
    -0.05096528f, -0.00999346f, -0.07797099f, -0.05012736f, -0.10859327f, -0.02677686f, -0.04516686f, 0.03788059f, 
    -0.01549591f, -0.00847260f, 0.00701473f, 0.07363057f, -0.08583818f, -0.03042330f, 0.06464618f, -0.04977895f, 
    0.03624456f, -0.02531270f, 0.00905065f, 0.05867279f, 0.00258365f, -0.04965445f, -0.05243441f, -0.01335168f, 
    0.00764768f, 0.02947371f, -0.07904982f, 0.06600716f, 0.02430634f, -0.01311670f, 0.03498582f, -0.00355976f, 
    0.06894567f, -0.02331043f, 0.00761345f, -0.03045428f, -0.00664468f, -0.02545892f, 0.01291218f, -0.02528350f, 
    -0.06092403f, -0.05012966f, -0.07476164f, 0.00780398f, 0.02785381f, -0.05267083f, 0.05190665f, 0.06495309f, 
    0.07651606f, -0.06237100f, -0.01372702f, -0.00214752f, -0.09548030f, -0.06736099f, 0.05966273f, 0.06106456f, 
    -0.03934789f, 0.01237792f, 0.04112098f, 0.05583485f, -0.04480477f, 0.05997683f, -0.03798825f, -0.05003380f, 
    -0.04688682f, -0.02511313f, 0.08225522f, -0.04636211f, -0.07210082f, -0.02678197f, -0.05358668f, 0.07418273f, 
    -0.00164554f, -0.07296921f, -0.08661392f, 0.06437212f, -0.09212680f, 0.04581352f, -0.08017591f, 0.05091279f, 
    0.05353313f, -0.00632768f, 0.07525058f, -0.06361730f, -0.09474678f, -0.01941995f, -0.06339569f, 0.02660657f, 
    0.00374314f, 0.04131566f, -0.07844906f, 0.03749744f, -0.08111446f, -0.05710631f, -0.07170479f, -0.06506442f, 
    -0.04568992f, 0.04630062f, -0.03624217f, -0.00180155f, -0.05004258f, -0.03771264f, -0.04708894f, 0.03190174f, 
    0.07435305f, 0.03479301f, 0.05635155f, 0.04604619f, 0.06452433f, 0.06873860f, -0.01974741f, 0.06194298f, 
    -0.05474692f, -0.02957792f, -0.08095725f, -0.07606690f, -0.05991633f, -0.07578345f, -0.05739293f, -0.07307261f, 
    0.01282819f, -0.03114706f, -0.07254863f, 0.04707039f, -0.08396395f, -0.01344200f, 0.00595255f, -0.05530918f, 
    0.02122179f, -0.01834243f, -0.02677662f, -0.04251091f, -0.07463779f, 0.02939918f, -0.04208370f, -0.03399014f, 
    -0.06091717f, -0.03713925f, 0.03509909f, 0.08655051f, -0.02536302f, 0.04324444f, -0.09593292f, -0.05289256f, 
    -0.25853458f, -0.43621945f, -0.19301164f, 0.05940557f, -0.15158962f, 0.05547490f, -0.00271487f, 0.24295233f, 
    0.00116347f, 0.20801017f, -0.13233496f, 0.10693486f, 0.17315465f, 0.01527643f, 0.22415404f, 0.18440731f, 
    -0.04321761f, 0.25853375f, 0.04479156f, 0.23845513f, -0.05894592f, -0.14351119f, -0.05776315f, 0.10174373f, 
    -0.12268081f, -0.06229699f, -0.25999987f, 0.07147796f, 0.08676613f, 0.12751518f, -0.06992351f, 0.17667727f, 
    0.08662284f, -0.08060896f, 0.22870928f, 0.06622834f, 0.23408134f, -0.41865563f, 0.09066339f, -0.00528556f, 
    -0.03063579f, -0.08096840f, 0.16312142f, 0.06669122f, 0.08581258f, 0.01508586f, -0.06454281f, -0.12897557f, 
    0.21888159f, 0.22870497f, 0.02401555f, -0.00731601f, -0.08327296f, 0.04273042f, 0.06134223f, 0.12127134f, 
    0.33905834f, -0.21855444f, -0.13549170f, 0.07720008f, 0.06733216f, -0.02694062f, 0.07479013f, -0.29641470f, 
    0.04396774f, -0.04837510f, -0.11459080f, -0.20813262f, 0.03873536f, 0.05572700f, 0.08538014f, -0.30251047f, 
    -0.04419981f, -0.01043424f, -0.00519779f, -0.04116352f, 0.11785269f, 0.02462082f, 0.00253643f, 0.21513715f, 
    0.10411426f, -0.00549708f, -0.06165221f, 0.22935390f, -0.01157100f, -0.31076121f, -0.18424563f, -0.06273931f, 
    -0.03926440f, -0.07384042f, -0.36224893f, -0.11338729f, 0.08643138f, -0.21497753f, 0.02619904f, -0.02045592f, 
    0.11620367f, 0.10616051f, 0.01993281f, 0.03798212f, -0.25667486f, -0.20182095f, -0.07540604f, 0.07395195f, 
    0.05197995f, -0.44803616f, 0.02691747f, 0.00007864f, -0.03830473f, 0.07623281f, -0.12275825f, 0.36052069f, 
    -0.10096202f, 0.09418672f, -0.06991260f, -0.27071357f, -0.35494056f, 0.08617377f, -0.31768796f, -0.11441968f, 
    0.07864746f, 0.11404416f, -0.05988635f, 0.03807403f, 0.08281104f, -0.04743000f, 0.06945543f, -0.04713124f, 
    -0.00538533f, 0.01424811f, 0.04640751f, -0.12595418f, 0.01490135f, -0.20675093f, 0.22392184f, 0.16365150f, 
    0.40765768f, 0.17133194f, -0.21142837f, -0.29683918f, 0.03415023f, -0.11327451f, 0.19336113f, 0.12645254f, 
    -0.14131244f, -0.05023568f, -0.14263833f, 0.16672632f, 0.02477930f, -0.02424019f, 0.32783151f, -0.18784988f, 
    0.24477673f, -0.02213100f, -0.02538281f, -0.00355419f, 0.14635746f, 0.03343007f, 0.03112649f, 0.06862467f, 
    0.06050058f, -0.05283174f, 0.05654719f, 0.06722721f, 0.22358645f, 0.09509231f, 0.14881626f, -0.06063888f, 
    -0.02421830f, -0.08427283f, 0.17305376f, -0.07443149f, 0.19433625f, -0.03560235f, -0.05369279f, 0.16288389f, 
    -0.16512735f, -0.13926695f, -0.00553407f, 0.04573860f, 0.14777431f, 0.07237183f, -0.01289347f, 0.06219296f, 
    0.25310311f, -0.13689655f, 0.00757263f, -0.01111478f, -0.09032508f, -0.10000902f, 0.05480268f, -0.16712397f, 
    0.00977262f, 0.32909456f, 0.11115622f, -0.24189694f, -0.10396814f, 0.12424966f, -0.10189958f, -0.11531717f, 
    0.05501239f, -0.06368565f, 0.01059855f, -0.23878671f, -0.34126493f, -0.01474356f, 0.00924954f, -0.17597078f, 
    0.06068884f, 0.07739174f, 0.07628585f, 0.04528785f, 0.06422476f, 0.26285535f, 0.31954464f, 0.06130334f, 
    0.27299917f, -0.04875511f, -0.13656147f, 0.05614453f, 0.03761085f, 0.12742843f, -0.03489865f, -0.01710688f, 
    0.03615961f, -0.19855349f, 0.10906225f, -0.02054990f, -0.06659546f, 0.09395346f, -0.04609573f, 0.08045479f, 
    -0.27868676f, 0.06349559f, 0.34403855f, -0.16318664f, -0.01554917f, 0.03580164f, 0.16104095f, 0.31378028f, 
    -0.04579893f, 0.06381632f, -0.20043762f, -0.01420082f, 0.21977860f, -0.05531856f, 0.00690913f, -0.01869557f, 
    0.07909060f, -0.38287327f, 0.10674228f, 0.03771025f, 0.07596298f, 0.37614709f, 0.06500273f, 0.14987740f, 
    -0.04148087f, 0.16043244f, 0.37875926f, -0.32815936f, -0.21067989f, 0.05871061f, 0.16256732f, -0.20133562f, 
    0.28583017f, 0.06563045f, -0.20888014f, -0.10897628f, 0.04116134f, -0.10855875f, 0.00607275f, -0.14186810f, 
    0.04313995f, -0.29692498f, 0.00104522f, -0.15116328f, -0.02925920f, 0.11386241f, 0.33359441f, -0.12848140f, 
    0.07987191f, 0.06464629f, 0.20044081f, -0.01262049f, -0.03027215f, -0.01738279f, 0.05169966f, -0.04272980f, 
    0.20095815f, 0.06945320f, -0.42749551f, -0.43035266f, 0.16398658f, 0.21221612f, 0.12704572f, -0.09636499f, 
    0.02091070f, 0.08953319f, 0.19503976f, 0.01834931f, -0.04043782f, -0.25344905f, -0.07783787f, 0.16062559f, 
    0.20485179f, -0.29837233f, 0.05079088f, 0.00909257f, 0.07126302f, 0.17346552f, -0.21560521f, 0.05789893f, 
    -0.06656884f, 0.02911285f, 0.12694655f, -0.08483493f, 0.01914849f, -0.00680670f, 0.10080445f, -0.02031622f, 
    -0.10941210f, -0.00626058f, 0.08443148f, -0.25111428f, -0.24938142f, -0.03052065f, -0.15002696f, -0.29457369f, 
    0.14315262f, -0.21513388f, 0.02020094f, 0.18058681f, 0.11962979f, -0.16091815f, 0.05117178f, -0.02528267f, 
    -0.26147276f, 0.02570073f, 0.16357970f, -0.21996540f, 0.00072756f, 0.42886946f, -0.45656991f, 0.01281526f, 
    0.01917166f, -0.47833169f, 0.22296454f, 0.16923027f, -0.27417275f, 0.13643028f, 0.04342953f, -0.07378811f, 
    0.05903301f, -0.35311338f, 0.15981683f, 0.08725473f, 0.18483280f, 0.06529458f, 0.25103277f, -0.00810663f, 
    -0.12147302f, 0.47828877f, 0.21017958f, -0.20206054f, -0.00911327f, -0.03285342f, -0.08765765f, 0.15158798f, 
    -0.01047656f, -0.11352960f, -0.05104164f, 0.16592158f, 0.23250677f, -0.01831236f, 0.11414824f, -0.15709163f, 
    0.19452572f, -0.07281175f, 0.19155820f, -0.01508549f, -0.07769419f, 0.29843187f, -0.05435938f, 0.19945861f, 
    0.03131257f, 0.08186400f, 0.17283897f, 0.03722699f, 0.00415677f, 0.00081162f, 0.12369245f, -0.32323983f, 
    -0.10427170f, -0.13598865f, -0.16323102f, -0.01151430f, 0.06316619f, 0.01828326f, -0.00620445f, 0.07907671f, 
    -0.09179479f, 0.17089739f, 0.09115977f, 0.19209677f, 0.03353574f, -0.04337918f, 0.05704781f, -0.01168897f, 
    0.15161827f, -0.09293297f, -0.00689805f, -0.04688906f, 0.04385311f, -0.06761415f, -0.00799787f, 0.03800920f, 
    -0.06060449f, -0.05869853f, 0.04942491f, -0.12993805f, -0.04009046f, -0.02568765f, 0.02568679f, -0.08234604f, 
    0.04071585f, 0.04483745f, -0.08749527f, -0.09724287f, 0.05586810f, -0.01324246f, -0.01915115f, 0.30437449f, 
    0.27258325f, 0.17445089f, 0.01524059f, 0.23461449f, 0.16534062f, -0.09359406f, 0.11005573f, 0.22367920f, 
    -0.04900959f, 0.03486829f, 0.08091763f, 0.04228998f, -0.06980718f, 0.15852974f, -0.00880037f, 0.43615213f, 
    0.16952957f, 0.34415767f, 0.13242745f, -0.09027067f, 0.08812891f, 0.03247179f, -0.06299213f, -0.14588423f, 
    0.10820324f, 0.08311676f, -0.10007632f, 0.04958780f, -0.01410763f, 0.01197732f, 0.06464052f, -0.13235031f, 
    -0.14402276f, 0.03107680f, 0.14845590f, -0.07679553f, -0.08983447f, 0.25005677f, 0.14861932f, -0.01913721f, 
    0.18010546f, -0.20987120f, 0.20765202f, 0.16432883f, 0.01089930f, 0.19502302f, 0.07116024f, -0.07606540f, 
    0.08682785f, 0.00441646f, 0.11786496f, 0.02825084f, -0.06751776f, -0.16053829f, 0.03650592f, 0.03255802f, 
    0.03674586f, 0.19866745f, -0.01924613f, 0.01293059f, -0.07392839f, -0.06946718f, 0.15472111f, 0.06828292f, 
    -0.06972060f, -0.01904971f, -0.09108529f, 0.16187792f, -0.13214311f, -0.08626657f, 0.18276919f, 0.04374113f, 
    -0.04300842f, 0.03192468f, 0.09125151f, -0.15449849f, 0.12868404f, 0.13902438f, 0.06072858f, -0.06315123f, 
    0.12464678f, 0.14191224f, 0.10905683f, -0.33142579f, -0.31318596f, 0.31131983f, 0.15011524f, -0.06940553f, 
    0.08417360f, 0.10332712f, -0.12086256f, -0.00647797f, -0.11321295f, -0.36181378f, -0.00179751f, -0.01657636f, 
    0.07202060f, 0.24321210f, -0.32356033f, -0.33887470f, 0.04023741f, -0.09020934f, 0.19471231f, -0.00154500f, 
    0.11750095f, 0.10208066f, 0.10093442f, 0.00373674f, -0.52766758f, 0.11179677f, -0.08854911f, 0.01656589f, 
    0.13289368f, -0.05569459f, 0.22386377f, -0.47196305f, 0.16215219f, 0.25487748f, 0.11109759f, 0.16176903f, 
    0.07339774f, -0.27755138f, -0.08766559f, 0.08880486f, 0.10735895f, -0.13035893f, 0.02528231f, 0.07153057f, 
    -0.10550400f, 0.10532615f, -0.00308626f, 0.02692341f, 0.09957884f, 0.09581082f, -0.33277577f, -0.05194694f, 
    -0.19642729f, -0.09819277f, -0.00212012f, -0.10568209f, 0.11261942f, -0.13467175f, 0.16410403f, 0.45760560f, 
    -0.37303805f, 0.31940094f, 0.04554303f, -0.34609562f, 0.18443120f, -0.34542274f, 0.16085605f, -0.54827589f, 
    0.13189685f, -0.12696046f, -0.20476016f, -0.05339284f, -0.00947602f, -0.04091519f, -0.01167454f, -0.06322388f, 
    0.19169703f, 0.06934257f, 0.09760918f, 0.16100059f, -0.00745628f, 0.28550893f, -0.58090371f, 0.00355945f, 
    0.14436898f, -0.16751714f, 0.43335027f, 0.10862667f, -0.01944462f, 0.00246361f, -0.04233097f, 0.03321368f, 
    0.17864479f, -0.12970477f, -0.08700477f, -0.04197187f, 0.15975164f, -0.02339816f, 0.56130666f, 0.01716536f, 
    -0.10506526f, 0.48419213f, 0.17855754f, 0.13023441f, -0.08448511f, 0.04918377f, -0.03868320f, 0.05898075f, 
    -0.06688730f, 0.09787605f, 0.35510218f, 0.00846423f, 0.40943280f, -0.02850730f, 0.34698766f, -0.16176796f, 
    0.32375741f, -0.08406929f, 0.19289394f, 0.10570096f, -0.30144885f, 0.10685807f, -0.06582247f, 0.05693400f, 
    0.13649844f, 0.06876587f, 0.19592386f, -0.09481234f, 0.08486035f, -0.12647565f, 0.00742315f, 0.49971071f, 
    0.03039945f, -0.13758263f, -0.03828255f, -0.21016657f, 0.13290185f, -0.00858024f, 0.22212134f, 0.08060195f, 
    0.10628327f, -0.34691200f, -0.05133174f, 0.09371509f, 0.21232025f, 0.04775346f, 0.02994829f, -0.09347645f, 
    0.17902586f, 0.16681835f, 0.04574243f, 0.02159814f, 0.15490384f, 0.03999831f, -0.05857750f, 0.18880884f, 
    0.04497845f, 0.05302648f, 0.08007943f, 0.11229934f, 0.13858700f, 0.04413817f, -0.19869384f, -0.02461018f, 
    -0.09284114f, 0.14406359f, 0.33986261f, -0.04615869f, 0.17891720f, -0.07106915f, -0.00342714f, 0.05031797f, 
    -0.47961530f, -0.20686133f, 0.02463146f, -0.01273631f, 0.11311670f, -0.11795411f, 0.06561752f, 0.10104283f, 
    0.21148689f, -0.01887919f, -0.21589364f, -0.05168198f, -0.05327998f, 0.16926162f, 0.01842468f, -0.20680486f, 
    -0.08984679f, -0.16150190f, -0.18978615f, -0.41877249f, 0.02322016f, -0.00250538f, 0.05080033f, -0.13865954f, 
    -0.01419837f, 0.18679862f, -0.01291120f, -0.33807933f, -0.29529428f, 0.00120117f, 0.00197863f, -0.02455862f, 
    -0.02120176f, -0.02230977f, -0.23223516f, 0.02491754f, 0.08510265f, 0.10277540f, 0.05761945f, 0.03690574f, 
    -0.25875792f, -0.25134110f, -0.15090771f, 0.03663625f, 0.14438586f, -0.18741715f, -0.09638221f, -0.07295045f, 
    0.11694162f, -0.07464958f, -0.03834166f, 0.15417179f, -0.20260355f, 0.11170493f, 0.11002378f, 0.00148672f, 
    0.06980878f, -0.29171747f, 0.21477553f, 0.08480659f, -0.03401963f, 0.11495347f, 0.17139398f, -0.05223627f, 
    -0.02409502f, 0.25686479f, 0.12331375f, 0.15662122f, 0.12720741f, 0.07451054f, -0.03026968f, 0.04883278f, 
    0.20234777f, -0.29848635f, 0.04334228f, 0.04178416f, -0.13355957f, 0.06271926f, 0.20516638f, 0.06199821f, 
    -0.10216809f, -0.04748041f, -0.05701742f, 0.02978441f, 0.06006646f, 0.05492883f, -0.07970357f, 0.02401867f, 
    -0.07133336f, -0.04141100f, 0.05215231f, -0.06715126f, 0.02399291f, -0.01301017f, 0.02929488f, -0.02405528f, 
    -0.01955405f, -0.04344450f, 0.03673553f, 0.06895681f, 0.06584574f, -0.03358991f, -0.02126425f, -0.03200675f, 
    0.05760426f, -0.07236506f, -0.02118251f, -0.02185280f, -0.09825410f, 0.04181176f, -0.04730797f, 0.03121139f, 
    0.02264581f, 0.07262371f, -0.08425283f, -0.03982673f, 0.06141511f, 0.01499173f, 0.06234457f, 0.02907187f, 
    0.04814815f, -0.05747042f, -0.08482713f, -0.03494204f, -0.09199339f, -0.03416555f, 0.06372277f, -0.08264563f, 
    -0.03230062f, -0.06225614f, 0.02366061f, -0.03042300f, -0.05914844f, -0.00968396f, -0.08770318f, -0.01403961f, 
    -0.09094676f, -0.09940088f, -0.04181643f, -0.08691748f, -0.10516795f, -0.08044831f, -0.01123387f, -0.03135519f, 
    0.04447022f, -0.06698463f, -0.01642083f, 0.00452485f, 0.00058832f, -0.04300622f, -0.00715296f, 0.01796248f, 
    -0.03990276f, -0.10542058f, -0.06057964f, -0.00691191f, 0.03103204f, -0.02125971f, -0.08342423f, 0.01558524f, 
    -0.00667743f, 0.02324342f, 0.00204372f, -0.00873635f, -0.05676469f, -0.05915591f, 0.06172335f, -0.08470560f, 
    0.02338384f, 0.00676094f, -0.04764476f, -0.04670524f, -0.04394431f, -0.00254920f, 0.03552674f, -0.05463638f, 
    0.00273376f, 0.01907429f, -0.01883986f, 0.06906288f, -0.08122922f, 0.06046882f, -0.00454287f, 0.07216067f, 
    -0.07545517f, 0.01365665f, -0.00502079f, 0.01733129f, -0.07992224f, -0.06030941f, -0.07294411f, -0.02663360f, 
    -0.08709079f, 0.04889031f, -0.01795811f, -0.07662430f, 0.05871820f, -0.04102675f, -0.10928521f, -0.07498267f, 
    -0.09567946f, 0.01122365f, 0.00325538f, -0.01567685f, 0.04762576f, -0.03640193f, -0.00053991f, -0.04818861f, 
    -0.01924392f, -0.11387243f, -0.07495319f, -0.12707706f, -0.11346375f, -0.00678919f, 0.17345621f, -0.43369877f, 
    0.09988399f, 0.00958645f, -0.18577814f, -0.12676609f, -0.00007006f, -0.13942258f, 0.02351198f, 0.09587169f, 
    -0.12240013f, 0.16020018f, -0.01624755f, -0.10793813f, -0.06100183f, -0.16272339f, 0.28597650f, -0.01940469f, 
    0.18505560f, 0.04916102f, -0.03891331f, -0.08329731f, -0.00018182f, -0.02057530f, 0.07044333f, -0.00704405f, 
    -0.06144472f, -0.04494165f, 0.14061303f, -0.04962065f, 0.06908649f, 0.03186007f, 0.30583072f, 0.05461488f, 
    -0.02236892f, -0.13497956f, 0.05131888f, 0.10613248f, 0.06676025f, -0.05643830f, 0.07281546f, 0.29034692f, 
    0.04279361f, 0.15002024f, -0.02081993f, 0.23270409f, 0.06161418f, -0.07386586f, 0.05055201f, 0.15389869f, 
    -0.02099710f, -0.00240430f, 0.04890644f, -0.08564698f, 0.07529569f, -0.01643983f, 0.03054524f, -0.03720030f, 
    0.06922186f, 0.38009331f, 0.08899928f, -0.04098880f, 0.13029660f, 0.10128935f, -0.02229338f, -0.27408221f, 
    0.05838042f, -0.03014610f, -0.10089647f, 0.00550935f, -0.15092702f, 0.07765234f, 0.00252823f, -0.24290906f, 
    0.00889021f, 0.05130280f, 0.06167116f, 0.10516247f, -0.13775776f, -0.09625449f, -0.19985797f, 0.02693832f, 
    0.15590872f, -0.02946745f, 0.05617923f, 0.11287047f, 0.05966729f, 0.02788869f, -0.02882962f, 0.06150931f, 
    0.04847660f, -0.11375769f, 0.00566856f, 0.10648394f, 0.13250329f, -0.07535858f, 0.27167374f, 0.04164737f, 
    -0.11299562f, 0.13392328f, 0.13887209f, -0.16732378f, 0.02580861f, -0.06195144f, 0.22307211f, 0.13409428f, 
    0.05862347f, 0.02231511f, -0.18519807f, -0.13697395f, -0.10154474f, -0.05039927f, -0.06982549f, -0.35680807f, 
    0.09053745f, -0.00823253f, 0.09840444f, -0.00632333f, -0.00924793f, 0.29826131f, -0.17153816f, 0.05628156f, 
    0.12425601f, -0.12939210f, -0.03160813f, -0.13589931f, -0.26414612f, -0.33582193f, -0.17175785f, -0.22903244f, 
    -0.04282818f, 0.07715781f, -0.22469752f, 0.08927061f, -0.14323583f, -0.23203784f, 0.00415166f, 0.00929134f, 
    -0.07301439f, -0.06163691f, -0.20821790f, -0.05040804f, -0.03899904f, -0.04531860f, 0.09195173f, -0.08153955f, 
    -0.00825518f, 0.36127844f, -0.26728153f, -0.08546697f, -0.20968597f, 0.10733880f, 0.06407768f, 0.13280137f, 
    0.17742942f, 0.02940957f, 0.34940502f, -0.39140159f, 0.13212636f, -0.00038665f, 0.35174531f, 0.16494624f, 
    0.01431116f, -0.11225088f, -0.04650549f, 0.47665012f, 0.02352542f, -0.07325139f, -0.03144451f, 0.04949688f, 
    0.49415314f, 0.36059132f, -0.07401450f, 0.17397220f, 0.14711249f, 0.24324434f, -0.11046401f, -0.07039479f, 
    -0.20172146f, 0.07602569f, -0.15459166f, -0.11438569f, 0.22456430f, -0.04700740f, 0.21240121f, 0.09986965f, 
    -0.06570397f, 0.10555064f, 0.04373729f, -0.34814012f, 0.32953140f, 0.02977594f, 0.16395985f, -0.23153858f, 
    0.13518848f, -0.25322226f, -0.04328091f, 0.13602459f, -0.03163963f, 0.00505092f, -0.00943794f, 0.18414360f, 
    0.13576686f, 0.15890478f, -0.10761303f, 0.31315580f, -0.17838268f, -0.11269844f, -0.92163569f, 0.03165305f, 
    -0.77282679f, -0.08618314f, -0.24058211f, -0.02207288f, 0.02341504f, -0.04490925f, -0.04116761f, -0.06335296f, 
    -0.16687852f, 0.04356742f, -0.01439983f, -0.04992295f, 0.10151801f, -0.17063212f, 0.39181414f, -0.06817965f, 
    -0.17395259f, 0.21646079f, 0.19185641f, -0.09372545f, 0.07337173f, 0.06198394f, -0.09062956f, 0.06138273f, 
    -0.19697091f, 0.15178515f, -0.20842668f, -0.40967155f, -0.06202608f, 0.05211527f, 0.14521761f, -0.20164777f, 
    0.09472148f, 0.27615345f, 0.15016119f, 0.23423575f, -0.65641397f, -0.05593442f, 0.20325273f, -0.08685199f, 
    0.08448452f, -0.02384878f, -0.07358561f, -0.03438299f, -0.05650020f, -0.03357010f, 0.02763678f, -0.00851030f, 
    0.05349301f, 0.00346549f, -0.03579010f, -0.04785643f, 0.05778909f, -0.07271716f, -0.06098983f, 0.01151899f, 
    -0.00133569f, -0.03237489f, 0.02345978f, 0.00465213f, -0.08533811f, -0.00554621f, -0.00304937f, 0.07255907f, 
    -0.05983965f, -0.00849607f, 0.00145964f, -0.01890655f, 0.01129610f, 0.08447675f, 0.01611606f, -0.03832104f, 
    -0.08513372f, -0.00899195f, 0.01994630f, -0.02645420f, -0.07997227f, -0.06328367f, -0.07949320f, -0.07112908f, 
    0.05040063f, -0.06601137f, 0.03832502f, -0.04359810f, -0.01482559f, 0.02835427f, -0.06603695f, -0.04858883f, 
    -0.08818308f, -0.05021511f, -0.08689676f, -0.02683754f, 0.00422458f, 0.08113067f, 0.08183341f, -0.08466402f, 
    0.06261067f, -0.00482831f, 0.00779766f, -0.04947551f, 0.01902490f, 0.01257098f, -0.04358786f, 0.07597425f, 
    0.03733191f, 0.04087871f, 0.02969703f, -0.07324971f, 0.07694328f, -0.01444719f, 0.08805718f, 0.01396800f, 
    -0.06203160f, -0.01805118f, -0.08199237f, -0.01316106f, -0.01673138f, -0.05444913f, 0.00126158f, -0.06813231f, 
    0.00835805f, -0.01079624f, 0.06645502f, 0.08624668f, -0.01428833f, 0.01020010f, 0.02265546f, -0.00611058f, 
    -0.05788472f, -0.03472639f, 0.07376309f, -0.07291290f, -0.01755808f, -0.05638848f, 0.06080814f, 0.04884291f, 
    -0.03731454f, 0.08219232f, -0.01542927f, -0.03615494f, -0.05859617f, 0.00879313f, -0.05687405f, -0.02697933f, 
    0.04432126f, 0.04840186f, 0.04290604f, -0.01883028f, -0.01901456f, 0.07302615f, 0.02323578f, -0.01840697f, 
    -0.01244223f, -0.03736853f, -0.05995648f, -0.04328914f, 0.00317519f, 0.06339755f, -0.08333104f, 0.08122689f, 
    -0.07962645f, -0.07658873f, -0.00932510f, 0.03783453f, 0.01122789f, -0.06728768f, -0.01690926f, 0.03086578f, 
    -0.00722523f, -0.09887958f, 0.04155559f, -0.08330289f, 0.06977638f, 0.09367742f, 0.02283747f, 0.04754723f, 
    0.00588176f, -0.02451420f, -0.08290143f, 0.04507622f, -0.04549213f, -0.00665191f, 0.03975257f, 0.06685469f, 
    -0.05364740f, -0.03149778f, -0.00157942f, 0.03776849f, 0.06476975f, -0.08578060f, -0.10373151f, 0.05615721f, 
    0.00684876f, 0.00018830f, 0.00798048f, -0.01117613f, 0.00619386f, 0.02428056f, 0.01707830f, -0.02357212f, 
    0.06352859f, 0.00819059f, -0.06353042f, -0.03377731f, -0.01423671f, -0.07710002f, -0.06258202f, -0.06900356f, 
    -0.06030824f, -0.05756405f, -0.08182053f, 0.04889134f, -0.03300476f, -0.01955965f, 0.07507175f, 0.00613197f, 
    -0.08719675f, 0.05627635f, -0.04898897f, 0.03124537f, 0.07460447f, -0.06663994f, 0.01603264f, -0.04127755f, 
    -0.04500081f, 0.02336144f, -0.06165685f, -0.07138073f, -0.01916834f, 0.03911883f, -0.11038062f, -0.09604713f, 
    -0.06897579f, 0.01222542f, 0.02419651f, 0.06157053f, -0.03599679f, -0.09673252f, -0.04084657f, 0.01011639f, 
    0.00506066f, -0.07977270f, -0.06781554f, -0.09063221f, -0.00870572f, -0.04754423f, 0.08249050f, 0.04126177f, 
    0.00249087f, -0.08290834f, -0.07029263f, -0.01134766f, -0.06370745f, 0.01244971f, -0.06101329f, -0.03776105f, 
    0.02184014f, -0.04534060f, -0.01615197f, -0.00243592f, -0.03975591f, -0.04801792f, 0.08124837f, -0.07740147f, 
    -0.03937322f, 0.01847112f, -0.06733000f, -0.02188765f, -0.04559447f, 0.01623418f, -0.08813825f, -0.05359258f, 
    -0.03290313f, -0.00483266f, 0.00367066f, -0.05068958f, -0.07276379f, -0.03954205f, 0.06821883f, -0.02520667f, 
    -0.02295315f, -0.09278882f, 0.04701672f, -0.03888267f, 0.02700142f, -0.04346574f, -0.02230363f, 0.02578362f, 
    0.06607213f, 0.07050093f, 0.00033843f, -0.06406710f, -0.03394353f, 0.04782642f, -0.05782615f, -0.08763433f, 
    0.23913422f, 0.01498960f, 0.03885720f, -0.14796978f, -0.11321734f, -0.24243902f, -0.04509252f, 0.01992791f, 
    0.03216775f, 0.00474722f, -0.17234881f, 0.02526904f, -0.24439572f, -0.28526905f, 0.01175577f, 0.05011540f, 
    -0.22404340f, -0.26165918f, -0.23147228f, 0.08442871f, 0.03638051f, -0.02268729f, 0.08044431f, -0.20229892f, 
    -0.10066480f, 0.30624908f, -0.09435545f, 0.05469099f, -0.22154421f, 0.08003864f, -0.01217145f, 0.07000462f, 
    0.21785271f, 0.03276010f, 0.24118882f, -0.12848823f, -0.02602410f, 0.19658470f, 0.18876325f, 0.11454380f, 
    -0.02537377f, -0.15100394f, -0.10011376f, 0.25216913f, 0.16408782f, 0.05828595f, 0.04317160f, 0.15447772f, 
    0.27780014f, -0.07441971f, 0.04676126f, 0.09436955f, 0.04311320f, 0.21153273f, -0.09366284f, -0.19179256f, 
    -0.12579717f, 0.03262077f, -0.05546233f, -0.22473691f, 0.20553394f, -0.05828233f, 0.11188141f, 0.07300601f, 
    -0.18955168f, 0.13547780f, 0.02811138f, -0.23684220f, 0.17759497f, -0.13023797f, 0.21332145f, -0.28138077f, 
    0.11467113f, -0.03212002f, 0.00382430f, 0.16765884f, -0.16982153f, 0.01297590f, 0.06185440f, -0.16859905f, 
    0.02985833f, 0.14417988f, 0.05235985f, 0.10883105f, 0.10666876f, 0.00312924f, -0.20954977f, -0.02918506f, 
    -0.30183035f, -0.04107311f, 0.17271648f, -0.09166094f, 0.09473335f, -0.13447303f, 0.01179791f, -0.05216147f, 
    -0.05493274f, -0.06997275f, -0.18807931f, -0.06412366f, 0.00155401f, -0.06815638f, 0.34588584f, 0.07030481f, 
    -0.23474614f, 0.21830985f, 0.08003559f, 0.07109281f, -0.06215120f, 0.09215557f, 0.08647873f, -0.21055193f, 
    0.06124205f, 0.13589621f, 0.37241805f, -0.19668724f, 0.07596771f, 0.06390303f, 0.16047756f, -0.12987803f, 
    0.08149782f, 0.02710020f, 0.03980906f, 0.15306549f, -0.42032790f, 0.05943040f, 0.16727695f, -0.08478664f, 
    0.25596225f, 0.38547248f, -0.10424210f, -0.04971616f, -0.14629516f, -0.17265479f, 0.16060638f, -0.35302195f, 
    0.25744021f, 0.02639823f, -0.10362069f, -0.12014700f, -0.27756169f, -0.15690309f, 0.02824468f, 0.01459399f, 
    -0.30277881f, 0.14763720f, -0.29693148f, -0.08504733f, 0.14869519f, 0.09262612f, 0.17479926f, -0.27087542f, 
    0.21868375f, -0.12680040f, -0.01709255f, 0.07354943f, -0.16285950f, -0.06123772f, 0.01892452f, 0.02063975f, 
    0.15949987f, 0.06255292f, 0.09104677f, -0.34977481f, 0.01170834f, 0.20802003f, 0.29375690f, -0.01026572f, 
    -0.00233511f, 0.12342671f, -0.04825861f, 0.04184543f, 0.27036768f, -0.23386271f, -0.08185890f, 0.50619841f, 
    0.28585887f, -0.04261192f, -0.04553720f, 0.16409047f, 0.34059218f, 0.05782838f, 0.06104780f, 0.16352361f, 
    0.00253436f, 0.17256762f, 0.26493490f, -0.08318792f, 0.07375924f, 0.10793776f, -0.04808316f, 0.28945431f, 
    -0.17075576f, 0.18396224f, 0.20623410f, -0.19953413f, 0.06424675f, -0.13416237f, 0.02658474f, -0.06925006f, 
    0.34797743f, 0.17983814f, -0.01094484f, -0.06423523f, -0.11207089f, 0.10593802f, -0.03384558f, -0.27147850f, 
    0.07866658f, 0.03485131f, 0.16898483f, 0.12401872f, -0.12565690f, 0.26566041f, 0.19135197f, 0.05089415f, 
    0.30851817f, -0.00615359f, -0.02166849f, 0.27533501f, 0.10150296f, 0.22365665f, -0.07961262f, -0.04502939f, 
    -0.06049076f, -0.08013600f, -0.07688285f, 0.15490578f, 0.05699199f, 0.03829913f, 0.49795160f, -0.04458060f, 
    -0.04727586f, 0.51715630f, 0.34930831f, -0.00124669f, -0.05458513f, 0.09785979f, 0.40003526f, 0.01426624f, 
    -0.02583963f, 0.01958263f, 0.06824306f, 0.07568010f, 0.15319820f, -0.01484826f, 0.28893611f, -0.01289569f, 
    0.16248761f, 0.09633422f, 0.39940140f, -0.00556351f, -0.15747920f, 0.19051734f, 0.11370653f, 0.13067123f, 
    -0.20068499f, 0.02535406f, -0.31662560f, -0.04430545f, -0.07104429f, -0.16511549f, 0.18867040f, 0.09937086f, 
    0.24393307f, 0.23316671f, -0.03198883f, -0.05171679f, 0.07449032f, -0.10993215f, 0.24603990f, 0.14671701f, 
    -0.09591555f, 0.05310762f, 0.00804649f, -0.07753082f, -0.06457075f, 0.02760726f, 0.27495316f, -0.08506448f, 
    0.00142062f, -0.34846017f, 0.07926897f, 0.08310793f, 0.03112497f, 0.16707462f, -0.08156353f, -0.02472454f, 
    0.20406953f, 0.05005800f, -0.01055270f, 0.09583066f, 0.21658053f, -0.08056998f, 0.17843726f, -0.03287483f, 
    0.02178692f, 0.04500483f, 0.18072863f, -0.23074991f, -0.00647048f, -0.04304617f, 0.03817840f, 0.19323654f, 
    -0.56881386f, 0.10396957f, -0.05393756f, -0.03830468f, -0.12717362f, -0.00326769f, -0.04397526f, 0.07392031f, 
    0.31015307f, -0.00746922f, 0.18761280f, 0.03583872f, 0.07695511f, -0.03937384f, 0.15003185f, -0.12881389f, 
    0.14885372f, 0.15362301f, 0.16791150f, -0.09226656f, -0.14871883f, 0.03524837f, -0.00596691f, -0.00773036f, 
    0.00300108f, -0.08445703f, 0.01117162f, -0.18692376f, 0.07004344f, 0.07139916f, -0.00825801f, -0.01971979f, 
    0.08807308f, 0.03601708f, 0.15979898f, -0.07923036f, 0.08777924f, 0.04250025f, -0.14165440f, -0.04318079f, 
    0.12894858f, -0.03365918f, -0.02855071f, 0.07585867f, -0.06338412f, 0.01888093f, 0.04572234f, 0.05142413f, 
    0.03672789f, -0.06345018f, 0.07900135f, -0.02067783f, 0.01815518f, 0.08295542f, -0.06317527f, 0.00422537f, 
    -0.21367109f, 0.18218780f, 0.04896448f, -0.18760142f, 0.01069425f, 0.09733620f, 0.10203762f, 0.41591465f, 
    -0.00242041f, -0.08675988f, -0.62326390f, -0.03078272f, 0.09247790f, -0.06912256f, -0.13573672f, -0.22696576f, 
    0.05072559f, -0.09819724f, 0.15645446f, -0.09354383f, 0.13865642f, 0.33745950f, -0.09516924f, -0.01101323f, 
    -0.05333458f, 0.02426861f, 0.05610165f, -0.08097991f, -0.08395282f, 0.04585809f, -0.05500609f, 0.00988241f, 
    -0.10061891f, 0.04758383f, 0.06124004f, 0.05348901f, -0.11111817f, -0.09325590f, -0.08167644f, -0.09794380f, 
    -0.00163083f, -0.00680425f, -0.00682077f, 0.04272236f, -0.01704783f, -0.08854523f, -0.01108766f, -0.09086630f, 
    -0.09244687f, 0.03940706f, -0.04140398f, 0.05230779f, 0.04891495f, -0.07626326f, -0.00398585f, 0.03374027f, 
    -0.00694171f, -0.08291124f, -0.06416422f, 0.01223585f, -0.02565974f, -0.04906544f, -0.01513650f, 0.09801275f, 
    0.02345908f, 0.01865938f, -0.06565239f, 0.02024499f, -0.06382553f, 0.04608257f, 0.02132948f, -0.07203930f, 
    0.01059417f, -0.07982786f, 0.06816611f, 0.00530378f, 0.01297392f, 0.02865014f, 0.02236237f, -0.04412910f, 
    -0.05479968f, -0.01784682f, 0.00521314f, -0.02099540f, 0.04108542f, 0.03453169f, -0.07525424f, -0.06142428f, 
    -0.05686143f, -0.02203659f, -0.04758351f, -0.04008839f, -0.04019400f, -0.11670878f, 0.08551715f, 0.00789829f, 
    -0.09965760f, 0.00188667f, -0.08155175f, -0.00888350f, -0.07335284f, -0.02822647f, -0.05079269f, -0.02733166f, 
    0.04989066f, -0.09385231f, -0.08920852f, -0.04469611f, 0.02232779f, 0.05438728f, 0.00408567f, -0.07250463f, 
    -0.12461732f, -0.06015232f, -0.00736108f, -0.04305565f, -0.04881112f, 0.05678846f, 0.01205537f, -0.02757806f, 
    -0.04084022f, 0.00473894f, -0.08508825f, 0.00461660f, -0.03298888f, 0.05760318f, 0.07822300f, -0.07335754f, 
    -0.07005713f, -0.04774211f, -0.03031556f, 0.05429512f, 0.01088482f, -0.02080839f, -0.02483130f, -0.07775322f, 
    -0.03699339f, 0.03211582f, -0.05977644f, -0.07192010f, 0.10832103f, 0.01690079f, -0.00677654f, -0.04104000f, 
    0.00763675f, -0.08737012f, 0.04203371f, -0.03881901f, -0.06527631f, -0.03066066f, -0.01268601f, -0.05082499f, 
    -0.04964199f, -0.14676094f, -0.18598288f, 0.05697040f, -0.01155786f, 0.04229543f, -0.08565660f, 0.46860787f, 
    -0.07302390f, -0.08002379f, -0.22146973f, 0.06549473f, 0.18459485f, 0.03486853f, 0.14111735f, 0.24162991f, 
    0.00692171f, 0.17101246f, -0.06798452f, 0.18211900f, -0.07374757f, -0.00775712f, -0.24469006f, 0.01807787f, 
    -0.00917461f, -0.21145482f, -0.20657805f, 0.02312507f, -0.04281795f, 0.21557939f, 0.02852109f, 0.27491084f, 
    -0.05043734f, 0.05489255f, 0.11089116f, 0.13094652f, 0.08018783f, -0.19464420f, -0.13807802f, 0.05365212f, 
    0.01584403f, -0.12862024f, 0.04017529f, 0.09097110f, 0.05121679f, 0.11132640f, -0.08138019f, -0.00106097f, 
    -0.19865179f, 0.21503627f, -0.09241867f, 0.05295566f, -0.00811306f, -0.03462519f, 0.05677180f, 0.06032573f, 
    0.38770777f, -0.08979510f, -0.16911662f, 0.08764066f, 0.09942402f, 0.14456226f, 0.13883802f, -0.24692066f, 
    -0.03874886f, -0.27406824f, -0.23530224f, -0.21948400f, 0.16973016f, -0.18122941f, 0.20291932f, -0.27641943f, 
    -0.03157292f, -0.02572007f, -0.08513301f, 0.04376261f, -0.01336366f, 0.18503952f, -0.04074765f, 0.02824030f, 
    0.17967050f, 0.14478551f, -0.19388130f, 0.10494001f, 0.04539334f, -0.16866732f, -0.22303998f, -0.01293879f, 
    -0.01303038f, -0.07352635f, -0.13486555f, -0.02263972f, 0.24963829f, -0.22434865f, -0.03336173f, 0.06440851f, 
    0.12205656f, 0.11545369f, -0.20392089f, 0.10683706f, -0.30959448f, -0.07990835f, -0.17022683f, 0.03487251f, 
    0.15726958f, -0.29126906f, 0.01467421f, 0.03098005f, -0.06110045f, 0.15458593f, -0.03176747f, 0.21698536f, 
    -0.14909151f, 0.14022171f, 0.20087558f, -0.09433849f, -0.32191610f, -0.02990400f, -0.18175220f, 0.05772329f, 
    0.05768896f, 0.04013737f, -0.04773752f, 0.13491829f, 0.00677192f, -0.10336355f, 0.02460402f, -0.15502605f, 
    -0.07648413f, 0.01056967f, 0.00234246f, 0.03292655f, -0.07372156f, -0.10478645f, 0.03306621f, -0.02677977f, 
    0.05943833f, 0.05820196f, -0.09253115f, -0.00207451f, 0.02787383f, 0.02983586f, -0.05371444f, 0.05974210f, 
    0.00022663f, -0.07775801f, 0.02352668f, 0.04134728f, -0.04962675f, -0.01199069f, -0.07922378f, -0.05852028f, 
    -0.09546881f, -0.06326484f, 0.05630784f, 0.07895825f, 0.05526093f, -0.01779441f, -0.05066370f, -0.02027380f, 
    -0.02577828f, 0.08586933f, -0.04516216f, 0.04684708f, -0.02316851f, -0.08706913f, 0.02098002f, 0.01038295f, 
    -0.08232014f, 0.05297521f, -0.05358706f, -0.08705077f, 0.00311003f, 0.06043781f, 0.02985918f, -0.06004057f, 
    0.02626649f, 0.00240438f, -0.06398892f, 0.00584279f, -0.07899310f, -0.05156610f, -0.08805272f, 0.02875513f, 
    -0.05360648f, 0.07898072f, -0.05326176f, 0.05970832f, -0.02335176f, -0.08382991f, -0.08264971f, -0.02028598f, 
    0.03518602f, 0.06879043f, -0.10292678f, 0.06169292f, -0.00190520f, -0.07772879f, -0.04463740f, -0.08441716f, 
    -0.05455284f, 0.01996446f, -0.03592009f, -0.07345203f, -0.08492632f, 0.05493508f, 0.07375636f, 0.01410453f, 
    -0.00994591f, 0.01781075f, 0.06043780f, -0.07125971f, 0.00817441f, -0.03895893f, 0.06609205f, -0.01964427f, 
    -0.01028071f, -0.06334434f, 0.06219572f, -0.09850357f, -0.01685691f, 0.01044759f, 0.00200473f, 0.04367672f, 
    -0.07009158f, -0.03952733f, -0.10014570f, 0.00933900f, 0.01094830f, -0.02018951f, 0.02220012f, 0.07291382f, 
    0.02962783f, 0.06126072f, 0.03223806f, 0.00900557f, -0.03357136f, -0.02840492f, -0.07276928f, 0.01503767f, 
    -0.01261932f, 0.00034735f, 0.06105539f, -0.02115177f, -0.04733193f, 0.00760816f, -0.03333377f, -0.10306261f, 
    0.05866108f, -0.02630729f, -0.01607314f, -0.02916812f, -0.08767536f, 0.00250230f, -0.05912073f, -0.03952477f, 
    0.08055367f, 0.13643788f, -0.20896390f, 0.02046161f, -0.04419091f, 0.01378522f, 0.00519650f, -0.17778780f, 
    -0.03163010f, -0.07207704f, 0.01495338f, -0.09795316f, -0.07954305f, 0.09729490f, 0.02386663f, -0.01216429f, 
    0.07256217f, 0.42987314f, -0.07762309f, 0.07324388f, -0.00676643f, 0.04280936f, 0.13335781f, -0.09607267f, 
    0.23896532f, -0.08216807f, 0.20859441f, 0.00837454f, -0.10593298f, 0.08940513f, 0.01763777f, 0.12276962f, 
    -0.01789870f, 0.04862625f, 0.06366411f, -0.11419372f, 0.08007100f, 0.07422902f, -0.15680465f, 0.02758429f, 
    0.01173493f, 0.06815025f, 0.00735617f, -0.21697208f, 0.07840260f, -0.10804854f, -0.06854762f, 0.18891238f, 
    -0.19966780f, -0.13599227f, 0.05793366f, 0.04484475f, 0.08266041f, -0.10668981f, -0.00380332f, 0.16229245f, 
    0.10755487f, -0.05200480f, -0.02986868f, -0.05080165f, -0.00971122f, 0.16599314f, 0.11142772f, 0.30576974f, 
    -0.07257895f, 0.17214563f, -0.05260521f, -0.22379538f, 0.10302440f, 0.04747267f, 0.02736518f, -0.21453114f, 
    -0.05563570f, 0.12227574f, -0.23777759f, -0.23423094f, -0.08869080f, 0.07355865f, -0.06091091f, -0.11032631f, 
    0.03040604f, -0.11825539f, 0.06976346f, 0.12038705f, -0.08031143f, 0.37744632f, -0.22560260f, 0.07805245f, 
    -0.15396407f, -0.43175697f, 0.10688870f, 0.12348373f, 0.07297412f, -0.03121521f, 0.06332951f, 0.00824282f, 
    0.00217319f, -0.04268957f, -0.08534839f, 0.18427031f, -0.06615507f, -0.00161085f, -0.00633058f, 0.01174304f, 
    0.02942158f, 0.26784730f, 0.00501297f, 0.08947739f, -0.07984966f, 0.11836267f, 0.20707530f, 0.21297006f, 
    -0.01832737f, 0.17789504f, -0.14025177f, 0.09129343f, 0.16418336f, 0.07785156f, 0.24511383f, 0.02454640f, 
    0.17890255f, 0.00990718f, 0.23561832f, -0.16823067f, 0.07117616f, 0.14290485f, 0.12650260f, -0.01105032f, 
    0.37963840f, 0.08356413f, 0.25969854f, -0.04385441f, 0.10365776f, 0.16111419f, -0.08531558f, -0.39574736f, 
    -0.51058710f, -0.04980249f, 0.21410790f, 0.17123204f, -0.06951014f, 0.03458584f, -0.32466793f, 0.13273457f, 
    0.35442153f, -0.23964544f, -0.30326244f, 0.27189955f, 0.03519338f, 0.02426552f, -0.38405395f, -0.24128635f, 
    -0.01027330f, 0.27748781f, -0.12325347f, -0.05285125f, -0.09449498f, -0.02619221f, -0.08380714f, 0.00269418f, 
    0.12735593f, 0.02414360f, -0.14128691f, 0.12160823f, -0.34517491f, -0.24830399f, -0.10609766f, 0.32459608f, 
    0.06571797f, -0.21652247f, -0.11353626f, -0.27376956f, -0.00220740f, 0.11703432f, -0.03264034f, -0.08043393f, 
    0.00381410f, -0.45433202f, 0.05520719f, -0.05703904f, -0.29113203f, -0.34507644f, -0.11108001f, 0.02730402f, 
    -0.17318432f, 0.12083595f, 0.01038603f, -0.13281699f, -0.10885132f, 0.02759535f, -0.13983217f, 0.32411137f, 
    -0.07176048f, -0.00386955f, 0.10290368f, 0.12288312f, -0.26196176f, 0.02327503f, 0.17800653f, 0.08275558f, 
    -0.09155283f, 0.00191421f, -0.00616327f, 0.27769774f, -0.11077376f, -0.17845891f, -0.02352716f, -0.00870864f, 
    0.01429083f, -0.27304655f, -0.22629850f, -0.18078336f, 0.03462851f, 0.45999452f, 0.07688861f, 0.04338983f, 
    -0.24766007f, -0.19621184f, -0.13784161f, 0.12119700f, -0.06140107f, -0.03632872f, 0.01866549f, -0.04338484f, 
    0.05286230f, 0.18886234f, -0.10951626f, 0.02718724f, 0.03889696f, 0.00487166f, 0.14732793f, -0.04578413f, 
    -0.04856298f, -0.23084272f, -0.41189641f, 0.21388096f, -0.08398839f, -0.00492964f, 0.02568582f, -0.18142223f, 
    0.18635021f, 0.06496874f, 0.14858280f, -0.00576428f, 0.21478245f, 0.01420765f, 0.02659021f, 0.11914461f, 
    0.16706270f, 0.04145485f, -0.29814562f, -0.03894386f, 0.07957447f, -0.14681044f, 0.04377047f, -0.00338524f, 
    -0.07643816f, -0.02279093f, -0.03116421f, -0.00157138f, -0.06303667f, -0.03062015f, 0.07505066f, -0.08649775f, 
    0.04565481f, -0.02844647f, 0.06124037f, -0.08230043f, -0.07159156f, 0.00424074f, 0.01912972f, -0.04637142f, 
    0.05431534f, -0.00106321f, 0.02118423f, 0.06214310f, -0.04414699f, 0.06294511f, 0.05160266f, 0.04960408f, 
    -0.01643481f, -0.06384743f, 0.01467180f, -0.01867584f, 0.02958510f, -0.00788829f, -0.03832942f, -0.07253313f, 
    -0.01399149f, -0.00580232f, -0.07137279f, 0.04227589f, -0.05097190f, -0.01079205f, 0.03105682f, -0.09896962f, 
    0.04888529f, 0.00739116f, -0.07470348f, -0.03909077f, -0.08261308f, -0.07754751f, -0.01838186f, -0.07224517f, 
    -0.08499049f, -0.07302678f, 0.04955635f, 0.06648119f, -0.06378843f, -0.03786049f, -0.02956999f, 0.02588251f, 
    -0.02673432f, -0.01797379f, -0.00864292f, -0.04232945f, -0.00473617f, -0.06281411f, -0.03106799f, -0.05409089f, 
    -0.05159703f, 0.00546578f, 0.02473799f, -0.08336955f, -0.02102020f, -0.07522602f, 0.06340933f, -0.08837789f, 
    0.00897459f, -0.06869997f, -0.07995429f, -0.05360681f, -0.01916771f, 0.05266013f, -0.04426927f, 0.05712734f, 
    -0.04006856f, -0.01741732f, 0.07538263f, -0.01944659f, -0.07905179f, -0.07143442f, -0.08737697f, -0.02146438f, 
    0.06678261f, 0.03689703f, 0.01385357f, -0.07546598f, 0.03475508f, -0.05888667f, 0.05898768f, 0.02228790f, 
    0.05139015f, -0.03387555f, -0.04581516f, -0.02375294f, -0.01481922f, 0.01017512f, 0.04656550f, -0.02350407f, 
    0.06812245f, -0.02142243f, -0.01429793f, 0.00025624f, -0.02826745f, 0.05422543f, 0.06807072f, 0.00827507f, 
    0.01529090f, 0.00940536f, -0.00306644f, 0.06890590f, -0.02724388f, -0.05744762f, -0.02214877f, 0.02991731f, 
    0.04019530f, 0.03786002f, -0.02961680f, 0.02289618f, -0.06507257f, -0.04661264f, -0.04116255f, 0.00351459f, 
    0.12548538f, 0.18428971f, -0.27215943f, 0.05104164f, 0.05006835f, 0.13239744f, 0.03471391f, -0.06319721f, 
    0.42036924f, 0.18296950f, -0.01142584f, -0.20053567f, -0.03582409f, -0.07349854f, 0.22410911f, 0.06964219f, 
    -0.27576154f, -0.14037530f, -0.17850702f, 0.06115996f, -0.15097253f, 0.09911930f, 0.15350841f, -0.16690136f, 
    -0.06974160f, -0.28540435f, 0.09223153f, -0.06139444f, -0.11793512f, -0.34579909f, -0.02474669f, -0.16297428f, 
    0.35638008f, -0.06787158f, 0.09209025f, -0.03362424f, 0.08048021f, -0.18081886f, 0.25575969f, -0.02359506f, 
    0.07848432f, -0.00437657f, 0.14759499f, 0.06661957f, 0.28945202f, -0.04566629f, 0.07607143f, 0.15350181f, 
    -0.00875110f, -0.52038985f, -0.00339033f, 0.01581743f, 0.24251860f, 0.10585134f, -0.06317667f, 0.16558999f, 
    0.10036840f, 0.12388740f, 0.23005462f, -0.12015157f, 0.15818036f, 0.02448077f, -0.11442728f, -0.06905126f, 
    0.04425995f, -0.15886104f, 0.13421293f, -0.02866254f, -0.09769116f, 0.08652567f, -0.23720604f, 0.11488119f, 
    0.39938471f, 0.06339041f, 0.19188237f, -0.05889153f, 0.11384469f, -0.21305397f, -0.01379385f, -0.27051660f, 
    -0.21083654f, 0.13145201f, 0.03047911f, 0.00142016f, 0.16780896f, 0.05456124f, 0.07300349f, 0.05886389f, 
    0.13799670f, 0.21486741f, -0.01042398f, 0.13561453f, -0.20184599f, 0.08055329f, -0.06098252f, -0.05313248f, 
    -0.02820701f, -0.04363574f, -0.11838307f, 0.11406738f, 0.34308597f, 0.15290128f, 0.24412572f, -0.06241799f, 
    0.03791846f, 0.18533428f, 0.22997101f, -0.13546371f, -0.02042592f, 0.00607846f, -0.05508905f, -0.10580582f, 
    0.14635302f, -0.08464666f, -0.19154990f, -0.07646436f, 0.14121327f, -0.05506844f, 0.02896964f, -0.11838248f, 
    0.32354003f, 0.11619265f, -0.13888699f, -0.05500185f, 0.06970244f, -0.03127754f, 0.11326413f, 0.06569289f, 
    -0.06263228f, 0.02854214f, -0.06890742f, 0.05036670f, 0.05088082f, 0.01331704f, -0.04938927f, 0.01017643f, 
    -0.02445773f, 0.06826647f, 0.05621519f, 0.00867671f, 0.05980939f, 0.03346036f, 0.00713728f, -0.05363400f, 
    -0.07191556f, -0.00192946f, 0.03362660f, 0.00688002f, 0.05181714f, -0.07826401f, 0.05926076f, 0.01259741f, 
    -0.06154723f, -0.06875224f, -0.04473333f, 0.07608956f, -0.05346038f, 0.06237429f, -0.00132150f, -0.04494203f, 
    -0.09497624f, 0.01462904f, 0.06529052f, -0.03534614f, -0.05330211f, -0.05360816f, 0.04636123f, -0.06906959f, 
    0.00199141f, -0.09863517f, 0.06396871f, -0.00742223f, -0.06986959f, -0.04193949f, -0.02214259f, -0.05992964f, 
    0.04003143f, 0.02951147f, 0.06435812f, -0.08316518f, -0.01401396f, -0.08869237f, -0.01105224f, 0.05992199f, 
    -0.06135167f, -0.00235180f, -0.10004386f, -0.04775287f, 0.03281722f, 0.02908778f, 0.06109364f, 0.00171610f, 
    -0.00790968f, -0.08655789f, -0.05824285f, -0.00605963f, -0.02370839f, -0.11751015f, -0.03573452f, 0.02403228f, 
    0.06109239f, -0.01962141f, -0.05325257f, -0.03241177f, 0.08748917f, -0.04041953f, 0.05045793f, 0.03776217f, 
    -0.02241227f, -0.04945235f, 0.02277223f, -0.03611504f, -0.08181591f, -0.03834595f, -0.02555800f, -0.05461653f, 
    -0.00240571f, -0.08575515f, 0.01495833f, -0.11177178f, -0.00768843f, -0.03352631f, -0.00608252f, 0.03531954f, 
    0.05916944f, 0.03943938f, 0.03322798f, -0.11169643f, 0.01522055f, -0.09661154f, -0.03022144f, 0.07396304f, 
    -0.07829971f, -0.08477975f, -0.00702313f, -0.05890587f, 0.03078688f, 0.06764941f, -0.02993344f, -0.11765376f, 
    0.05153115f, -0.02246501f, -0.01408051f, -0.00141201f, 0.05032547f, 0.03280822f, 0.07074969f, 0.02782229f, 
    -0.03200471f, -0.06691667f, -0.06484171f, 0.00723706f, -0.09355292f, 0.05374584f, -0.02148584f, -0.00815982f, 
    0.07893654f, -0.00041049f, -0.06713274f, -0.04177664f, -0.05393434f, 0.08512950f, -0.04691753f, -0.00798480f, 
    0.03862250f, 0.04734562f, -0.04503280f, -0.05745663f, -0.00891837f, -0.09981235f, -0.09263238f, -0.01672967f, 
    0.01567514f, -0.09080926f, -0.04243291f, 0.01951362f, -0.11046425f, 0.05285812f, -0.10070950f, -0.06168192f, 
    -0.00150780f, -0.09695948f, -0.04130094f, 0.06974159f, 0.00111195f, -0.09546061f, -0.02523591f, 0.00877970f, 
    -0.06202184f, -0.00013434f, 0.05904620f, 0.03066628f, -0.02001923f, -0.10543081f, 0.05086663f, -0.10234692f, 
    0.04154458f, -0.13364606f, -0.02575380f, 0.01581598f, 0.04910111f, -0.09787560f, -0.01577839f, -0.01163105f, 
    -0.08576563f, -0.03608193f, -0.03207667f, -0.07019200f, -0.09775347f, 0.07144638f, -0.00919698f, -0.09792139f, 
    0.04659126f, -0.00887300f, -0.06713857f, 0.02057939f, -0.01992971f, -0.00869396f, -0.06966823f, 0.07980177f, 
    -0.12530479f, -0.11281793f, -0.08288535f, 0.00101418f, -0.08806931f, 0.02169113f, 0.00810681f, 0.01841056f, 
    0.04365275f, -0.11067369f, -0.02213808f, 0.02654156f, 0.06151178f, 0.01889940f, -0.08335477f, -0.05443746f, 
    -0.05016743f, 0.02472853f, -0.04342003f, 0.07181606f, -0.07482001f, 0.07064079f, -0.12840682f, 0.06885096f, 
    -0.16343313f, -0.05955828f, -0.08276694f, -0.10154364f, 0.02721032f, -0.03775486f, 0.00625100f, -0.06983023f, 
    0.03325837f, -0.07235523f, -0.08520990f, -0.03678017f, 0.00799516f, -0.12161408f, 0.04915839f, -0.00068175f, 
    -0.07439414f, 0.05817211f, -0.05625753f, -0.04999477f, -0.05989349f, -0.01725234f, -0.01158023f, -0.04377427f, 
    -0.01550816f, 0.07866912f, -0.06380554f, -0.12756726f, -0.05977173f, 0.04123332f, -0.04305761f, -0.11382286f, 
    -0.07322943f, 0.03422785f, 0.00561951f, -0.04336386f, -0.13426909f, -0.00375705f, -0.08646333f, 0.02919875f, 
    0.03128302f, -0.06102054f, -0.07246622f, 0.07462845f, -0.05386110f, 0.05164524f, -0.00434137f, 0.03778335f, 
    -0.04169228f, -0.02580730f, 0.02958102f, -0.08014372f, -0.03136129f, -0.04170391f, 0.01350110f, 0.00831001f, 
    0.05877486f, 0.02252242f, 0.02569315f, 0.00349279f, -0.01896364f, -0.10478265f, -0.00948432f, 0.01375120f, 
    0.06493381f, 0.03023517f, -0.10065088f, 0.00724966f, 0.00301860f, -0.02213245f, 0.07866273f, -0.04614424f, 
    -0.01958890f, -0.04078200f, 0.06053837f, 0.06800009f, -0.09127598f, -0.08242638f, -0.03696366f, -0.08724568f, 
    0.00037795f, -0.01639079f, -0.06067632f, -0.00977805f, 0.04369981f, -0.04364987f, -0.08220116f, 0.06026813f, 
    -0.00942567f, 0.00017154f, 0.01750954f, -0.02075331f, -0.05138268f, -0.00924028f, 0.03106239f, 0.02344564f, 
    -0.06562999f, -0.07843448f, -0.04742464f, 0.04772115f, 0.05695086f, -0.09703075f, -0.03064584f, -0.07783559f, 
    -0.05850166f, 0.00244402f, -0.04167413f, -0.04584599f, 0.02154505f, 0.03339789f, -0.02338255f, 0.01352169f, 
    -0.05729809f, -0.07860318f, 0.01439858f, 0.06696922f, 0.02525247f, 0.01126053f, 0.08604030f, -0.03325640f, 
    0.03897227f, 0.01479656f, 0.00499319f, -0.01332872f, 0.05934896f, 0.06148315f, 0.02180912f, 0.07048782f, 
    -0.00772385f, -0.06780742f, 0.04631104f, -0.09674101f, -0.01179497f, -0.08757760f, 0.08469031f, -0.03371104f, 
    -0.06013577f, 0.03906365f, 0.04978085f, 0.07081474f, -0.06699385f, -0.02807241f, 0.07434440f, 0.05226323f, 
    0.05989058f, -0.09264857f, -0.09127720f, 0.07170437f, -0.06304955f, -0.06625727f, -0.03275553f, 0.00755845f, 
    -0.07492463f, 0.00943766f, -0.07000501f, 0.04212106f, 0.07526910f, 0.05819849f, 0.03923481f, -0.02520808f, 
    0.00272271f, -0.03397040f, -0.08856312f, -0.05728911f, 0.02869512f, -0.09507716f, -0.00957745f, 0.01967157f, 
    0.00892962f, -0.06707212f, -0.04344892f, -0.03861446f, -0.07289866f, 0.01555677f, 0.03347168f, -0.02601712f, 
    -0.03209576f, 0.01047294f, 0.03566605f, -0.04030537f, -0.03354602f, -0.08933438f, -0.01146920f, 0.02375738f, 
    -0.06103234f, -0.03245585f, -0.00353759f, -0.03353449f, -0.04235421f, -0.07294551f, -0.08373690f, 0.02353569f, 
    0.05104176f, 0.02770619f, 0.03260069f, 0.06801205f, -0.02602532f, -0.09864905f, -0.01673591f, 0.01003089f, 
    0.01568072f, -0.00332726f, -0.07479268f, -0.04831429f, 0.01042311f, -0.02015502f, -0.08432566f, 0.06881321f, 
    -0.03866534f, -0.02341694f, -0.00354757f, 0.03391271f, 0.03905674f, -0.11409964f, 0.00232487f, -0.12178121f, 
    -0.03221214f, 0.02824217f, -0.04973312f, -0.01188948f, -0.06462221f, 0.01490072f, -0.05125278f, -0.04276191f, 
    -0.02531626f, -0.04186673f, -0.00034234f, -0.00281656f, -0.07641637f, 0.06551447f, -0.01723681f, -0.05792347f, 
    -0.09259699f, 0.04341567f, -0.00876513f, -0.10758837f, 0.00796064f, -0.05704260f, -0.06428474f, -0.08836213f, 
    0.00416859f, -0.00960082f, -0.02325726f, 0.04028616f, -0.07321694f, -0.08562557f, 0.03548992f, -0.03135813f, 
    -0.03014842f, 0.04874630f, 0.04246908f, 0.03672237f, 0.03770940f, 0.02382223f, 0.05313912f, 0.00129960f, 
    -0.10248346f, 0.06827052f, 0.00283028f, -0.02160962f, 0.06918634f, -0.02181878f, -0.02627376f, 0.06480100f, 
    -0.09811273f, 0.05242736f, -0.02158233f, 0.04308467f, -0.04021696f, -0.09252042f, -0.03814358f, 0.06126558f, 
    -0.11144805f, -0.01588469f, -0.03741381f, 0.03847793f, 0.03471160f, 0.01011778f, -0.03177343f, 0.04724119f, 
    0.01826675f, -0.03061079f, 0.02728679f, 0.00561983f, -0.07991073f, 0.06686500f, 0.04726923f, -0.03927188f, 
    0.05997528f, -0.00205000f, -0.01519106f, -0.08453865f, 0.03102058f, 0.01764083f, -0.07955275f, -0.01911151f, 
    -0.09201992f, 0.08578070f, -0.02909457f, 0.04322399f, -0.04388095f, 0.08701407f, -0.08104936f, -0.09068731f, 
    -0.04862892f, 0.04436392f, 0.03747448f, 0.03245857f, -0.00700504f, -0.10124277f, 0.00703747f, -0.06582565f, 
    -0.03419366f, -0.02842087f, -0.03107611f, -0.07065647f, -0.10601372f, -0.02593042f, 0.08324888f, -0.05390675f, 
    -0.05386327f, -0.06420316f, -0.10840798f, 0.04519807f, -0.05153604f, -0.07170847f, 0.01223698f, 0.08733042f, 
    -0.05729021f, 0.03171273f, 0.04384679f, -0.01016485f, 0.04753123f, 0.05803924f, -0.02851507f, -0.04720947f, 
    -0.06891459f, 0.00523645f, -0.02933062f, 0.02221017f, -0.09270232f, -0.02996154f, -0.02275437f, -0.04240920f, 
    -0.06384398f, -0.01415581f, -0.02776225f, -0.06278670f, -0.03435563f, -0.05690838f, -0.07347611f, -0.06116970f, 
    0.01090078f, 0.03291642f, -0.10130277f, 0.01522208f, -0.00678267f, -0.07961693f, -0.04322091f, 0.01556473f, 
    -0.02471904f, -0.10792224f, -0.03677443f, 0.03498507f, 0.01924307f, -0.10588022f, -0.08425466f, 0.05814817f, 
    -0.01713500f, -0.03591257f, -0.02688475f, 0.05810568f, 0.01850155f, 0.05755220f, -0.01465278f, -0.08539677f, 
    0.03755463f, -0.07585572f, 0.03118317f, -0.00754607f, 0.05775248f, 0.06921373f, -0.04279004f, -0.03394072f, 
    0.05221426f, -0.08001580f, -0.03819301f, -0.09709544f, -0.03465212f, -0.07060231f, 0.04529561f, -0.08592720f, 
    -0.11615406f, -0.09359580f, -0.02172280f, -0.08799900f, 0.02545973f, -0.06767651f, 0.02112905f, 0.08091546f, 
    0.02263795f, -0.05112832f, 0.05444215f, 0.05451076f, -0.08791396f, 0.00620259f, -0.02279280f, -0.08132529f, 
    -0.03188875f, -0.01343828f, -0.08051034f, -0.07155122f, -0.08405849f, 0.06048212f, 0.02324335f, -0.11244280f, 
    0.05332436f, -0.04839065f, 0.05813414f, 0.04136266f, 0.05340105f, -0.07084875f, -0.07494492f, 0.04789496f, 
    -0.05210388f, 0.07947013f, 0.01263367f, -0.06785813f, -0.02076186f, -0.04181843f, -0.06842032f, -0.00571160f, 
    -0.02896528f, -0.01733093f, 0.09041508f, -0.09139408f, 0.01522230f, -0.01249101f, 0.01772359f, 0.05951107f, 
    0.05939403f, 0.00177674f, -0.03061030f, -0.01046118f, 0.05865459f, -0.10981034f, -0.05990341f, -0.04523450f, 
    0.05391740f, -0.06363060f, -0.08296894f, -0.08419135f, -0.11742400f, -0.02244180f, 0.05736462f, -0.02513126f, 
    0.06118037f, -0.00941842f, -0.03009385f, 0.04927396f, -0.09686977f, 0.00384079f, 0.06982096f, 0.07906144f, 
    -0.02289503f, -0.01423570f, -0.04094819f, -0.01464431f, 0.04435907f, 0.03432506f, 0.01535370f, -0.02169177f, 
    0.05514211f, 0.01695693f, 0.00900378f, 0.01418704f, 0.04202130f, 0.05315188f, -0.08098588f, 0.04871610f, 
    -0.03689497f, -0.05486074f, -0.08711429f, -0.08204199f, -0.06814434f, -0.04432736f, -0.02291702f, 0.09297085f, 
    0.04294704f, -0.08858123f, -0.10904569f, -0.05057685f, -0.08672721f, 0.05543304f, -0.02953219f, -0.00816246f, 
    -0.04491651f, 0.00195957f, 0.01095455f, 0.08885533f, -0.02815098f, -0.05659921f, -0.06829530f, -0.01060696f, 
    -0.08121061f, 0.03442725f, 0.05478135f, -0.06938543f, 0.07481346f, -0.04307913f, -0.06139539f, -0.06237471f, 
    -0.05394503f, 0.07298467f, -0.15781873f, -0.03713031f, 0.05503816f, -0.04809602f, 0.00523639f, 0.03424397f, 
    0.06994953f, -0.05701857f, -0.02072831f, 0.04166457f, 0.00936181f, -0.06000143f, 0.07364826f, 0.00345919f, 
    0.10064487f, 0.06438283f, 0.01469138f, -0.10281242f, 0.04548731f, -0.04845168f, 0.03195170f, 0.03066302f, 
    -0.05532575f, 0.00695604f, 0.00083999f, -0.09193494f, 0.00698546f, 0.08728772f, 0.05329829f, 0.01539695f, 
    -0.07302222f, -0.05348482f, -0.05690438f, -0.07247426f, -0.16081309f, -0.05383970f, 0.04599256f, -0.12057173f, 
    -0.04450697f, 0.01701890f, 0.47415173f, -0.02012895f, -0.28641182f, -0.23610759f, 0.06643127f, -0.37662393f, 
    -0.03268187f, -0.08296060f, -0.42881739f, 0.02851156f, -0.30364466f, 0.14450710f, 0.25804868f, -0.01464983f, 
    0.19948551f, 0.18864301f, 0.03652568f, -0.17447239f, 0.08081201f, 0.02906426f, 0.08432894f, -0.06029769f, 
    0.14552137f, -0.33277041f, -0.27372065f, -0.05523439f, -0.00793597f, 0.12012718f, 0.07394026f, 0.25476477f, 
    -0.10484768f, -0.07074618f, 0.07159176f, -0.15382934f, 0.11527935f, 0.16734669f, 0.20827383f, -0.00848618f, 
    0.02938007f, 0.11099776f, 0.03590666f, 0.08850671f, -0.02239607f, -0.24990429f, -0.07866611f, 0.15366301f, 
    -0.21970280f, 0.29967862f, -0.03240982f, 0.01969517f, 0.26790679f, -0.23403385f, 0.07784314f, 0.04683965f, 
    0.09059394f, 0.03226269f, -0.00584717f, 0.15214498f, -0.08454277f, 0.20279738f, 0.01226914f, 0.41644168f, 
    0.05587858f, 0.04676194f, -0.05644396f, -0.42107198f, 0.23887473f, -0.06340923f, -0.05890211f, -0.33002180f, 
    0.14670920f, 0.16729565f, -0.14676787f, -0.15060546f, -0.14421105f, 0.17924686f, 0.05107343f, -0.00961588f, 
    0.08294300f, -0.19901146f, 0.11036483f, 0.20186058f, -0.21790424f, 0.26832515f, 0.62476838f, -0.04536556f, 
    -0.01381318f, -0.10460945f, -0.09877901f, 0.03246259f, 0.11763848f, 0.01158860f, 0.10799715f, 0.07059576f, 
    -0.07066699f, -0.33743554f, 0.05124563f, 0.12719940f, -0.34349236f, -0.29374546f, 0.14455596f, -0.02470246f, 
    0.19196190f, -0.01526745f, 0.19468346f, -0.24931465f, -0.03457919f, 0.04796227f, 0.26058540f, 0.19624646f, 
    -0.23249370f, 0.26342800f, -0.19914258f, 0.07687938f, -0.12719154f, 0.00467467f, 0.24316749f, -0.16954364f, 
    0.01059486f, -0.15223752f, 0.50571102f, -0.13474536f, -0.29067019f, 0.05115194f, 0.02528686f, -0.00789521f, 
    0.05650927f, -0.14680424f, -0.04900705f, -0.01946006f, -0.02604561f, -0.04735943f, 0.00612983f, -0.02006467f, 
    -0.09008560f, -0.10759706f, 0.03358895f, 0.01078363f, 0.05162581f, 0.04900046f, -0.09598525f, 0.00326405f, 
    -0.06261298f, -0.03332808f, -0.06139980f, -0.04717561f, -0.06104396f, -0.06631545f, -0.03065318f, 0.02677757f, 
    -0.07204867f, 0.04396944f, -0.05911949f, -0.01401233f, 0.00573969f, -0.08936073f, -0.07626031f, -0.17139952f, 
    -0.16583569f, -0.04197226f, -0.14570209f, -0.03999263f, -0.03806105f, -0.00052802f, -0.15342116f, -0.04152048f, 
    0.07846851f, -0.13227144f, -0.02101057f, -0.00753392f, -0.14336009f, -0.03292733f, 0.01671307f, 0.01198820f, 
    -0.07367542f, -0.06563258f, 0.08585143f, 0.01841317f, -0.00836185f, -0.03119125f, 0.03804449f, 0.01304727f, 
    -0.07428784f, -0.03535521f, 0.03265517f, 0.01260751f, 0.03243765f, -0.12825313f, -0.04071403f, -0.02380672f, 
    -0.01373991f, -0.05160882f, 0.00689444f, 0.01513709f, -0.12422371f, -0.07132054f, -0.10733844f, -0.04210223f, 
    -0.07076399f, 0.04110662f, 0.01333614f, 0.04183253f, 0.09005247f, -0.14810446f, -0.07297455f, -0.11958667f, 
    -0.13727440f, -0.02993718f, -0.02837708f, -0.08108030f, -0.06961239f, -0.04139336f, -0.03060720f, -0.05657463f, 
    -0.08628862f, -0.13237070f, -0.08830767f, 0.03597493f, -0.02869666f, -0.00711623f, 0.02376841f, 0.00242454f, 
    -0.08307955f, 0.00018808f, 0.01815413f, -0.09526753f, 0.04468808f, -0.09447906f, -0.04145998f, 0.07892441f, 
    0.01814775f, -0.08502817f, -0.11304485f, -0.12142389f, 0.06905210f, -0.04285643f, -0.12076385f, -0.10035632f, 
    0.06675021f, -0.07557155f, 0.03231140f, -0.10902074f, 0.06111113f, 0.08758122f, -0.12945399f, -0.11958647f, 
    -0.00194682f, -0.03322642f, -0.01605022f, -0.02219792f, -0.03291070f, -0.13722517f, -0.00386177f, -0.10366075f, 
    -0.03551264f, -0.00188055f, -0.03921443f, -0.01720298f, -0.06473961f, 0.05816473f, -0.02442585f, -0.07929123f, 
    -0.08726529f, -0.05325280f, -0.07601003f, 0.04448945f, -0.04534065f, -0.05443804f, -0.03092278f, -0.02463628f, 
    -0.05408742f, -0.04456845f, 0.01043999f, -0.06894008f, 0.00892749f, -0.02284456f, -0.03339110f, -0.09257104f, 
    -0.03302030f, 0.03698858f, 0.04174779f, 0.06610802f, -0.06828609f, -0.10106160f, 0.00200370f, -0.00899878f, 
    0.02862397f, 0.02104606f, -0.07049537f, 0.04045213f, -0.08570480f, 0.03681799f, -0.04347997f, -0.04438731f, 
    0.00949779f, -0.04742312f, -0.03439135f, 0.06900398f, -0.06372820f, 0.02103150f, -0.06140111f, -0.09235750f, 
    0.00420407f, -0.00327357f, 0.06574643f, 0.04565035f, -0.07200622f, -0.01061126f, -0.02554972f, 0.03485971f, 
    -0.04729332f, 0.06767151f, -0.06730825f, -0.01548467f, -0.08024161f, -0.04776468f, -0.01114665f, 0.03571961f, 
    0.07618515f, -0.00799098f, -0.00885810f, -0.00406658f, 0.06724786f, -0.00493797f, 0.03619131f, -0.04424693f, 
    -0.08880004f, 0.01407984f, 0.00618661f, -0.08660902f, 0.03150406f, -0.03528189f, -0.00025598f, -0.00982563f, 
    0.05313398f, 0.05210236f, 0.07969523f, -0.07963037f, 0.04022932f, -0.03180812f, -0.02233888f, 0.03131589f, 
    -0.00368725f, 0.04529478f, 0.00926404f, 0.06317056f, 0.05952433f, 0.05892351f, -0.00918401f, -0.08405464f, 
    0.03690769f, -0.08144535f, -0.07985399f, 0.02995596f, 0.05406906f, -0.00298983f, -0.06445098f, 0.07408537f, 
    0.00383221f, -0.07391574f, 0.03785408f, 0.08625726f, -0.08023910f, -0.06225330f, 0.07816067f, 0.04142763f, 
    -0.00060895f, 0.01242589f, -0.04524228f, -0.02202854f, -0.01762094f, -0.08357685f, -0.02436429f, -0.03679147f, 
    -0.04801255f, -0.08207332f, -0.01970608f, -0.00202355f, -0.08657442f, -0.03215263f, -0.09155015f, 0.05267796f, 
    0.03760234f, 0.09501708f, 0.04354918f, 0.02848019f, 0.04071952f, -0.20519751f, -0.02425448f, 0.22864592f, 
    0.12672114f, -0.10457239f, -0.01580445f, -0.13949718f, 0.16327752f, -0.05747705f, -0.07738037f, 0.08996973f, 
    0.02517826f, 0.08888119f, -0.10591350f, -0.48723203f, 0.01325116f, 0.00448445f, 0.11728490f, -0.22047278f, 
    0.01739121f, 0.08137813f, 0.15599297f, -0.06981124f, 0.05265706f, -0.03779052f, -0.00907273f, 0.09941699f, 
    0.05068467f, 0.08825550f, -0.17082803f, 0.00185828f, -0.02018229f, -0.00064183f, 0.06628337f, 0.07017863f, 
    0.02288658f, 0.21767196f, 0.16425528f, -0.12124678f, 0.01068274f, 0.03504093f, 0.00569218f, -0.06723980f, 
    -0.20765851f, -0.43324545f, -0.04834661f, -0.36693612f, -0.14167528f, 0.16832475f, -0.09200447f, -0.25774196f, 
    0.19406952f, -0.00304667f, 0.12248135f, -0.11996735f, 0.01328853f, -0.02739632f, 0.05955408f, -0.32972297f, 
    -0.07825256f, 0.05202208f, 0.07214788f, -0.04713904f, -0.12176475f, -0.11672598f, 0.07136122f, 0.05085021f, 
    -0.14276633f, -0.07725196f, -0.16724102f, 0.14163010f, -0.08109773f, 0.11412206f, 0.00002152f, -0.05223181f, 
    0.24005523f, 0.00737853f, -0.22731121f, -0.15439227f, -0.11533671f, 0.07417344f, -0.12027863f, 0.03984964f, 
    0.02502866f, 0.30891886f, -0.07211155f, 0.07988916f, -0.02168219f, 0.04989648f, 0.01885188f, 0.01817823f, 
    0.11826431f, 0.11665197f, -0.11696264f, -0.05754149f, -0.04462105f, 0.19954263f, -0.35175231f, -0.07740893f, 
    -0.03666410f, -0.08271445f, -0.14955907f, 0.04769257f, 0.02818035f, 0.20582391f, -0.08196673f, 0.12416244f, 
    0.06008684f, -0.01876893f, 0.19312908f, 0.12644789f, -0.00486365f, -0.08807673f, -0.14098434f, 0.09689517f, 
    -0.08550777f, -0.24383776f, 0.01057076f, 0.00206518f, 0.16341260f, 0.13593856f, -0.08111406f, -0.00207442f, 
    -0.11714756f, 0.13489994f, -0.22129323f, 0.03646576f, -0.11273904f, 0.66016489f, 0.04444057f, -0.26117009f, 
    -0.26940531f, -0.02872885f, -0.12990780f, 0.19985326f, 0.17554887f, 0.23540971f, 0.10830349f, -0.25723642f, 
    0.64121640f, 0.54510677f, 0.11167859f, -0.02537106f, 0.11708252f, 0.04500998f, -0.03230945f, 0.33722726f, 
    0.16568899f, -0.11230461f, 0.18327427f, 0.07571072f, -0.01849558f, 0.14963563f, 0.02621712f, 0.11037076f, 
    -0.18095307f, 0.07770759f, 0.05316915f, -0.08859410f, 0.00347965f, 0.18418022f, -0.45865211f, -0.04090614f, 
    0.01967034f, 0.15828329f, -0.00818946f, 0.02003931f, -0.14622046f, -0.25343290f, -0.07242160f, -0.18511359f, 
    0.20914830f, 0.16301411f, -0.04088309f, -0.14284381f, 0.00446314f, -0.10493851f, -0.02678856f, -0.01956972f, 
    -0.07760975f, -0.04010653f, -0.04439897f, 0.04080651f, -0.20796980f, 0.04839939f, -0.11805630f, 0.46255726f, 
    -0.23918103f, -0.09328362f, -0.15476844f, -0.04134811f, 0.08176166f, -0.18840967f, -0.00674903f, -0.08748245f, 
    0.01278140f, 0.02671600f, -0.13241607f, -0.07938601f, -0.00134597f, -0.01199708f, 0.08217105f, 0.25216779f, 
    0.03178953f, -0.16957790f, 0.04964425f, 0.03148441f, -0.17322929f, 0.19754173f, -0.16849430f, -0.03077838f, 
    0.00979495f, -0.40111202f, 0.23284493f, 0.11258600f, -0.02911068f, -0.07264596f, 0.10691164f, -0.08392355f, 
    0.10891705f, 0.01299520f, 0.14190629f, 0.10841307f, 0.20372252f, -0.11069448f, 0.00006048f, 0.01184597f, 
    0.40192541f, -0.03252433f, -0.14361332f, 0.04281938f, 0.02781561f, -0.06389394f, -0.17395712f, 0.00983672f, 
    -0.35647139f, 0.11437403f, 0.03709805f, 0.35084915f, 0.23237465f, -0.01282008f, 0.11367024f, -0.00107518f, 
    0.14105664f, 0.03483329f, 0.01751054f, -0.13293554f, -0.11832024f, -0.09207258f, -0.14782199f, 0.12158848f, 
    0.14133409f, 0.08679197f, -0.37845147f, 0.00452309f, -0.11488687f, -0.41658255f, 0.04531624f, -0.38314405f, 
    0.24937396f, 0.13423608f, 0.06730912f, 0.02686249f, -0.07217593f, -0.26030958f, 0.11522062f, 0.15407544f, 
    -0.25172892f, 0.02338773f, -0.20519358f, 0.21792252f, -0.10359401f, -0.07786217f, 0.15556657f, -0.07564875f, 
    -0.02563110f, 0.30902141f, -0.07521166f, 0.07880852f, 0.04554596f, 0.26992926f, -0.02584300f, -0.00726710f, 
    0.28471979f, -0.03553305f, 0.40441063f, 0.19059563f, 0.13823543f, -0.03335878f, 0.45869377f, 0.21319807f, 
    -0.00540911f, -0.12625682f, 0.04334077f, 0.21458144f, 0.16624333f, 0.40054747f, 0.01748485f, 0.19426520f, 
    -0.08184036f, 0.40997472f, -0.07017206f, 0.04776926f, -0.09739280f, 0.25174567f, -0.03636726f, 0.04834415f, 
    0.26831374f, 0.15303105f, -0.00290625f, -0.02769641f, 0.36910626f, -0.21162587f, 0.17435218f, -0.22489855f, 
    0.24896371f, 0.18782674f, 0.18144953f, -0.04227588f, 0.11022976f, 0.00102844f, 0.24015066f, -0.11793707f, 
    0.03720345f, -0.19492719f, 0.16976896f, 0.45704424f, 0.14029624f, 0.00928553f, -0.00828225f, -0.11769537f, 
    0.15176807f, 0.39957666f, -0.01371217f, 0.36493623f, -0.05787017f, -0.09536688f, -0.33602089f, 0.08515789f, 
    -0.28233865f, -0.47187555f, -0.33627686f, -0.01119572f, 0.04979795f, -0.02665335f, 0.07428785f, 0.07871299f, 
    0.14126369f, 0.23784792f, -0.01944047f, -0.03898014f, 0.06996065f, 0.10549134f, 0.13361815f, 0.03018093f, 
    -0.23523138f, 0.20940019f, 0.09146899f, -0.23119299f, -0.05420223f, 0.10280418f, -0.01965290f, 0.30277541f, 
    0.24104717f, 0.06196977f, -0.73819500f, -0.31397030f, -0.07836703f, -0.07289047f, -0.01465638f, -0.47583306f, 
    0.11905815f, 0.04491664f, -0.05091799f, 0.01871164f, 0.14145809f, 0.18838784f, 0.07949408f, 0.12012727f, 
    -0.09102241f, 0.05265692f, -0.02495759f, -0.12934810f, -0.09308409f, 0.01300514f, -0.12829661f, 0.00775429f, 
    -0.08474451f, -0.06584764f, -0.01137290f, -0.00231860f, -0.08756448f, 0.01288200f, 0.00257306f, -0.03969936f, 
    -0.01035458f, -0.08641995f, -0.02196224f, -0.05218322f, -0.00779906f, -0.08528963f, -0.06272829f, 0.03424216f, 
    -0.01121481f, -0.01556540f, -0.00146765f, -0.08279323f, -0.00704111f, -0.07830214f, 0.03902634f, -0.03226696f, 
    -0.08072650f, -0.03921258f, -0.03637196f, 0.04164124f, -0.05553151f, 0.05108650f, -0.04374545f, -0.05805044f, 
    0.04766538f, -0.06403866f, -0.10462667f, -0.01428310f, -0.05130697f, -0.00739606f, -0.00120725f, 0.01068104f, 
    0.06061683f, 0.01819903f, -0.06331441f, -0.05174453f, -0.00576112f, 0.00746670f, 0.00220499f, -0.08247810f, 
    -0.10582748f, 0.00877225f, -0.05666161f, -0.02585988f, -0.03532410f, 0.00155830f, 0.00183613f, 0.02019945f, 
    -0.03659449f, -0.03450682f, -0.07903405f, 0.01865987f, -0.04056178f, 0.00664795f, -0.02813775f, 0.03982229f, 
    -0.04561777f, 0.00290927f, -0.00355089f, -0.03815049f, -0.04527290f, -0.07529089f, 0.03445340f, -0.07385684f, 
    -0.01844461f, 0.03644000f, -0.06120308f, 0.07439384f, -0.06614783f, -0.00985623f, -0.09636095f, 0.02051379f, 
    -0.04494754f, -0.00721218f, -0.04636824f, -0.11505266f, -0.04996093f, 0.02724310f, -0.04979404f, 0.03879470f, 
    -0.00572804f, -0.08640363f, -0.05107093f, -0.09427921f, -0.07292809f, -0.05199011f, 0.01444746f, -0.05886088f, 
    -0.12103257f, -0.03322110f, -0.00054589f, 0.03235817f, 0.02360159f, -0.06992984f, -0.04082340f, -0.02484575f, 
    0.00483448f, -0.01276523f, -0.09093098f, 0.01693754f, 0.00204822f, 0.01681466f, 0.02355546f, -0.00865300f, 
    -0.10306738f, 0.05488773f, 0.01823493f, -0.02474357f, 0.01300563f, 0.05283621f, 0.00318186f, -0.09777017f, 
    0.05863141f, 0.00884553f, 0.02949168f, -0.02426665f, -0.08936246f, -0.03205551f, 0.00085796f, -0.05375800f, 
    0.02322229f, -0.04150570f, -0.02502091f, -0.10508551f, 0.03353476f, 0.05129673f, 0.04253915f, 0.02724585f, 
    -0.04565468f, 0.04576292f, -0.01803675f, 0.03932847f, 0.01326757f, 0.05499507f, -0.10726379f, -0.04029439f, 
    0.00423866f, 0.01294845f, -0.06215553f, -0.05468525f, -0.02538569f, 0.05601841f, -0.00414555f, -0.05983105f, 
    0.01307585f, 0.03631333f, -0.05588983f, -0.04955546f, 0.00217076f, 0.05258966f, -0.05719515f, -0.01297448f, 
    0.02498455f, -0.07893552f, -0.06748089f, -0.04650058f, 0.01661306f, -0.11872099f, -0.01119930f, 0.02654042f, 
    -0.05451739f, -0.08814889f, 0.07229584f, -0.07042199f, -0.08859958f, 0.05028120f, -0.08928379f, 0.04450785f, 
    -0.03449574f, -0.09912856f, -0.05263006f, 0.06801452f, 0.04266101f, 0.00528108f, 0.03383711f, 0.02100994f, 
    -0.08018882f, -0.08538774f, 0.02289599f, -0.08098880f, -0.07640119f, -0.05803531f, -0.09117998f, 0.00347352f, 
    -0.06434647f, -0.06470291f, -0.07773141f, -0.03584592f, -0.00146183f, -0.05098775f, -0.02017774f, 0.05277743f, 
    -0.03622710f, -0.06254078f, 0.04823573f, -0.02304924f, 0.03954248f, -0.06039423f, -0.03938609f, 0.02282529f, 
    0.01462942f, -0.01245993f, -0.03655351f, 0.03396342f, -0.00348774f, -0.01778139f, 0.00250687f, 0.04281478f, 
    0.00556971f, -0.07946634f, -0.09464817f, -0.01451950f, 0.01590502f, 0.03964907f, -0.09784986f, -0.06458137f, 
    -0.08335599f, -0.11013163f, -0.02115032f, -0.06861449f, 0.03049548f, 0.00055239f, -0.03275159f, -0.00447546f, 
    0.04644301f, -0.04834772f, -0.03206507f, -0.02923774f, -0.03907515f, 0.00874988f, -0.03270983f, 0.01503140f, 
    -0.06791560f, -0.04523853f, 0.06582776f, 0.01987402f, -0.03256221f, -0.04309956f, -0.09017926f, -0.00332841f, 
    0.07993832f, 0.07365181f, -0.01482421f, -0.10123348f, 0.04274265f, -0.06668336f, -0.02461646f, 0.04046562f, 
    -0.01267719f, 0.00275440f, 0.00208967f, 0.04135786f, -0.05531039f, 0.01697033f, -0.09415440f, -0.03034578f, 
    -0.13906141f, -0.10208999f, -0.10670058f, -0.01066490f, -0.07127833f, -0.01451505f, 0.01832731f, 0.00004691f, 
    -0.05803675f, 0.00572964f, 0.03656535f, -0.07022562f, -0.08246084f, 0.04243255f, -0.07600850f, -0.06419796f, 
    -0.01359194f, -0.03644671f, 0.04132031f, -0.03755414f, -0.01623699f, -0.10537340f, 0.06135489f, -0.09963941f, 
    0.04303091f, -0.10854411f, -0.05221906f, -0.01980012f, 0.02511584f, 0.02109962f, 0.06173012f, 0.04859603f, 
    -0.04549317f, 0.06740236f, 0.05404070f, -0.08540075f, -0.06919905f, -0.03490025f, -0.03318885f, -0.10172182f, 
    -0.01501362f, -0.00768354f, 0.00512544f, -0.07854763f, 0.04978622f, -0.08760551f, -0.06153397f, 0.03688958f, 
    -0.01024833f, 0.03134440f, -0.06568354f, -0.09213603f, -0.01326263f, 0.02882316f, -0.04134954f, 0.01234404f, 
    -0.00845537f, 0.00047187f, 0.02600633f, -0.00641133f, -0.06477759f, -0.08856044f, 0.06843659f, -0.02572081f, 
    0.04361205f, 0.03695466f, -0.10274794f, 0.08128088f, 0.03437532f, -0.10335761f, 0.02025403f, 0.00188599f, 
    -0.10377791f, 0.02539565f, -0.00391997f, -0.10673869f, 0.05688545f, 0.01044618f, 0.08525337f, -0.00639467f, 
    -0.02856015f, -0.04724611f, -0.08593863f, 0.00673784f, 0.03661571f, 0.02356653f, -0.10587815f, 0.05117079f, 
    -0.02874418f, -0.08166428f, 0.03599400f, -0.03102335f, 0.02749636f, -0.08212971f, 0.06202354f, -0.07281853f, 
    0.03226142f, -0.01969079f, -0.00673109f, -0.01981107f, -0.10770807f, -0.03897265f, -0.03613048f, -0.02781615f, 
    -0.10470090f, -0.08072274f, 0.04931770f, -0.04927215f, -0.09981191f, -0.02572757f, -0.09516220f, 0.05379790f, 
    -0.14803401f, 0.06245983f, -0.08892287f, 0.04412723f, -0.07661591f, 0.36290258f, -0.05460213f, -0.13663204f, 
    -0.18497823f, 0.08339819f, 0.00123981f, 0.39478171f, 0.32657254f, 0.15461653f, 0.28890601f, -0.16313869f, 
    0.79480225f, 0.28991285f, 0.28224152f, 0.05295485f, 0.06699485f, 0.21094616f, -0.08140866f, 0.50602531f, 
    0.10591447f, -0.24310125f, 0.25878015f, 0.00842587f, 0.09581085f, 0.14103357f, -0.03278607f, 0.18986818f, 
    -0.10689559f, -0.00809411f, -0.01351440f, 0.01096121f, -0.04206865f, -0.12079541f, -0.32812747f, 0.12404215f, 
    0.05344456f, 0.18592885f, 0.03232070f, -0.18974724f, -0.18078215f, -0.00613673f, -0.05482244f, -0.14044634f, 
    0.12295572f, 0.13866986f, 0.08132298f, -0.00240054f, -0.01105856f, 0.04387074f, 0.19764298f, 0.10998479f, 
    -0.04321941f, -0.06992888f, -0.07236452f, 0.26187247f, -0.08372729f, 0.07246617f, -0.05627558f, 0.29219967f, 
    0.10264215f, -0.11280020f, 0.01827256f, -0.00392153f, 0.03215127f, -0.02522343f, 0.10262694f, -0.11178818f, 
    0.01594009f, 0.15049957f, -0.00915797f, -0.19266786f, 0.29137659f, 0.14600548f, 0.07429217f, 0.34166595f, 
    -0.11696062f, -0.27194589f, 0.12757288f, 0.00188624f, -0.19419342f, 0.17865360f, -0.13319153f, 0.01682870f, 
    -0.19566123f, -0.24781904f, 0.10501686f, 0.12009407f, 0.00244719f, -0.09086841f, 0.11742213f, -0.03363911f, 
    0.13128468f, 0.06550174f, 0.08112922f, 0.24718523f, 0.13098724f, -0.14946643f, -0.15485069f, 0.02739266f, 
    0.25651312f, -0.24612042f, -0.04403341f, -0.03481456f, -0.03526989f, -0.09623720f, -0.14724754f, 0.02021492f, 
    -0.00370443f, 0.09482242f, -0.22165544f, 0.24471782f, 0.01893475f, 0.03146864f, 0.04327025f, 0.06481566f, 
    0.03258613f, -0.05348616f, 0.03345209f, -0.23348238f, -0.04990538f, -0.13952914f, -0.06478676f, 0.17156427f, 
    -0.08120731f, -0.28478929f, 0.03237540f, 0.00679965f, -0.03390332f, -0.09528414f, -0.10619303f, 0.14541531f, 
    -0.11902529f, 0.19394036f, -0.00116110f, 0.30383310f, 0.08630431f, 0.08964671f, 0.00462337f, -0.01955672f, 
    0.21148551f, 0.02641394f, 0.34023789f, -0.17766906f, 0.00281937f, 0.06472966f, -0.14307812f, 0.20235069f, 
    -0.01433023f, 0.07736581f, 0.02783659f, 0.03228642f, 0.12496975f, 0.14632136f, -0.03348244f, 0.16255420f, 
    -0.04083550f, 0.08352180f, 0.06723920f, 0.10232744f, 0.06225954f, -0.18624014f, 0.11108411f, 0.19279151f, 
    0.02774232f, 0.07548092f, -0.01381179f, -0.01547901f, -0.12851422f, 0.17959180f, -0.06549349f, -0.33566868f, 
    0.00921350f, 0.33588743f, 0.00300653f, -0.09450469f, -0.15484740f, 0.01545979f, 0.07752760f, -0.19553007f, 
    -0.01995934f, 0.00931071f, 0.02082228f, 0.14214918f, 0.09469949f, -0.03920776f, 0.05896194f, 0.14535524f, 
    0.12392744f, -0.13008091f, 0.03702951f, 0.21685866f, 0.14930597f, -0.04878262f, 0.16330107f, 0.18177997f, 
    -0.16621013f, -0.05434853f, 0.12140466f, 0.12463409f, 0.28362706f, 0.01254847f, 0.09786423f, 0.37992847f, 
    0.15793581f, 0.07933104f, 0.03089173f, 0.12084736f, -0.05938442f, -0.15902299f, -0.06619372f, 0.02899209f, 
    -0.32348719f, 0.20715258f, -0.13669977f, -0.12914224f, -0.00117963f, 0.06927171f, 0.04122591f, 0.04391286f, 
    -0.04266583f, 0.12926522f, 0.08575347f, -0.17434345f, -0.22738844f, -0.04916744f, -0.27774954f, -0.03299025f, 
    -0.11980744f, -0.32798427f, -0.28363404f, -0.08193438f, -0.05779894f, 0.09537062f, -0.10841166f, 0.08864110f, 
    0.01380046f, 0.05269514f, -0.13218315f, -0.20387302f, -0.30558231f, 0.07295363f, -0.10535451f, -0.02998651f, 
    -0.10794771f, -0.15842845f, -0.30564794f, -0.03469261f, 0.16692191f, -0.00656247f, -0.03970644f, 0.06079591f, 
    0.38352531f, 0.09061073f, 0.11199047f, 0.00410994f, -0.07856926f, 0.19354172f, 0.17521000f, -0.13510500f, 
    0.17970355f, 0.17828493f, -0.07961050f, 0.14390166f, 0.32784259f, 0.03918141f, 0.10187116f, 0.04315899f, 
    -0.08262851f, -0.18203808f, 0.26393962f, 0.05702785f, 0.15566523f, 0.14927322f, 0.00650958f, 0.26646727f, 
    -0.01463183f, 0.25630060f, -0.04154338f, -0.04745342f, 0.02630080f, -0.16208050f, -0.02592020f, -0.10754061f, 
    -0.26464471f, 0.02773776f, -0.16759714f, -0.16191183f, -0.24497576f, -0.13788411f, -0.28577933f, -0.18162447f, 
    0.05581482f, -0.07541521f, 0.02008280f, 0.07936228f, -0.06852566f, 0.05618374f, -0.02997786f, 0.25074875f, 
    0.30361295f, -0.32170755f, -0.05285981f, 0.21473067f, 0.15764658f, 0.01772031f, 0.01987804f, 0.04509673f, 
    -0.35051709f, 0.25853831f, 0.04851174f, 0.15038408f, 0.04049751f, 0.09910294f, -0.44713178f, 0.26634216f, 
    0.07695399f, -0.07226351f, 0.13847210f, 0.05574114f, -0.02590047f, -0.00468142f, -0.22481702f, -0.00012290f, 
    0.39836782f, 0.08745309f, 0.28256813f, 0.20893592f, 0.09415841f, 0.07062184f, -0.03789850f, 0.11510906f, 
    -0.59250361f, 0.20417048f, 0.12267397f, -0.22366500f, -0.04592630f, 0.00518267f, 0.15836900f, 0.03840712f, 
    0.09117229f, -0.19161887f, 0.23300020f, 0.23817201f, -0.01252569f, 0.27611172f, -0.03405471f, 0.07448814f, 
    0.20520867f, 0.12869735f, 0.09132174f, 0.02038847f, 0.27924222f, -0.07449336f, -0.40967086f, 0.07624773f, 
    0.24831727f, -0.37330592f, 0.12326427f, 0.09364628f, 0.06470785f, -0.35465810f, 0.14564975f, -0.35209480f, 
    -0.06752290f, -0.14488289f, 0.02176025f, 0.25766510f, -0.00455468f, 0.00929510f, 0.24492653f, 0.01935115f, 
    0.06338864f, -0.16611561f, -0.20572947f, 0.17646439f, -0.10337126f, -0.00582979f, -0.02401401f, 0.08967538f, 
    0.33737132f, 0.21455036f, 0.11515392f, -0.30938980f, -0.60303932f, 0.18148698f, 0.18418978f, 0.17643157f, 
    0.19540425f, 0.15585180f, -0.00087214f, -0.00280959f, 0.04736288f, -0.25665513f, -0.02874083f, 0.07805686f, 
    -0.27321208f, -0.25003949f, -0.22207853f, -0.05845826f, 0.01780745f, -0.05885544f, 0.11767390f, -0.03786629f, 
    0.15387580f, 0.16929246f, 0.04317756f, -0.06194751f, -0.09342159f, -0.03363165f, -0.06908745f, 0.00892723f, 
    0.17165188f, -0.07754296f, -0.04135915f, -0.42911085f, 0.07279428f, 0.18969190f, -0.02839390f, 0.12372106f, 
    0.01175343f, -0.34508836f, 0.22731265f, 0.04171399f, 0.11570021f, -0.24927950f, -0.08784638f, 0.09046239f, 
    -0.30419913f, -0.43961924f, -0.01958310f, 0.12146766f, 0.18206196f, 0.12652500f, -0.20335059f, 0.04397399f, 
    0.09751292f, 0.08114389f, -0.02670291f, -0.17592223f, 0.09633184f, -0.11609007f, 0.11348481f, 0.11652222f, 
    -0.26828435f, -0.07564528f, 0.04917794f, -0.36950654f, 0.04087867f, -0.15183608f, 0.03915606f, -0.58514994f, 
    0.15130827f, -0.04319151f, 0.07491953f, -0.04484744f, -0.18730958f, -0.22887106f, -0.06688689f, -0.36241326f, 
    -0.01062424f, 0.04936250f, 0.04106043f, 0.10463183f, 0.18818878f, 0.22506291f, -0.16226250f, 0.07094453f, 
    -0.07865715f, 0.13068406f, 0.44333127f, 0.09134328f, 0.07161403f, 0.09158263f, -0.02096946f, -0.06583293f, 
    0.25760463f, -0.13169554f, -0.14170511f, -0.14931874f, 0.17755565f, -0.01056712f, 0.49714220f, 0.06931618f, 
    -0.14646921f, 0.28233394f, 0.06516467f, 0.16497335f, -0.08715184f, 0.02472251f, 0.03943611f, -0.22246192f, 
    0.13578679f, 0.07696260f, 0.14361475f, 0.08149619f, 0.51891476f, -0.07674574f, 0.20477806f, -0.02063179f, 
    0.32617775f, -0.30846983f, 0.09491154f, 0.08395191f, -0.17389882f, 0.27829108f, 0.12487194f, 0.02607281f, 
    -0.17016415f, -0.04054066f, -0.34723729f, -0.04088350f, -0.69677371f, -0.05225101f, 0.03062557f, -0.26829410f, 
    0.11180203f, 0.16517235f, -0.38718390f, 0.04847503f, 0.05809275f, 0.02262224f, 0.17807168f, -0.00316381f, 
    0.13319287f, 0.04463478f, 0.23502240f, -0.58117664f, -0.02489714f, 0.15757094f, 0.07567879f, 0.12053012f, 
    -0.03749744f, -0.23667413f, -0.10152876f, 0.03594762f, 0.12586133f, -0.08423995f, 0.07555264f, 0.04800173f, 
    0.19304095f, 0.07084303f, 0.03545404f, -0.12860768f, 0.10821670f, -0.30341777f, 0.05190391f, -0.07767440f, 
    0.05016145f, 0.02319764f, -0.10362520f, 0.08017993f, 0.03717316f, -0.00983412f, 0.07834437f, -0.05395455f, 
    -0.04129861f, 0.25720352f, 0.03779667f, -0.05023492f, 0.11510507f, 0.00972611f, 0.12916271f, -0.02732748f, 
    0.08280727f, 0.04837013f, 0.06903929f, 0.11974511f, 0.02936247f, -0.03384832f, -0.03019211f, 0.33758557f, 
    0.03888550f, 0.02428574f, 0.03216073f, -0.07003761f, -0.00747848f, -0.08826780f, -0.07711200f, -0.30724931f, 
    0.21413895f, -0.12731537f, -0.10810480f, -0.02332717f, 0.21252368f, 0.08836668f, 0.02381197f, 0.31230927f, 
    0.07010418f, 0.00418857f, 0.08503206f, -0.03316317f, -0.11684769f, 0.15488708f, -0.23514879f, 0.07553957f, 
    0.08908755f, 0.03911036f, 0.14186920f, -0.05328153f, -0.08336509f, 0.07435964f, 0.05929273f, -0.05199600f, 
    0.03242180f, -0.12280820f, 0.11351291f, 0.03451011f, 0.16676353f, -0.22529905f, 0.11232626f, -0.03047483f, 
    0.12516242f, 0.31649381f, 0.07176422f, -0.10817572f, 0.03681464f, -0.06737361f, 0.02439132f, -0.01586371f, 
    -0.17849618f, -0.08678844f, -0.19910356f, -0.16678473f, -0.18282250f, -0.03777026f, 0.15243641f, -0.42484334f, 
    -0.02008968f, 0.02539618f, 0.17885542f, -0.07277564f, -0.06738703f, -0.02547315f, -0.15427221f, 0.00681158f, 
    0.08994954f, -0.04379490f, 0.01772475f, 0.04037535f, 0.01126742f, -0.03134312f, -0.04945313f, 0.07422952f, 
    -0.08895356f, 0.01419874f, 0.03662162f, 0.03455675f, -0.08517699f, -0.10400005f, 0.07398901f, -0.02877562f, 
    -0.02756249f, -0.09068412f, 0.02568067f, -0.04025902f, -0.03664366f, -0.10466123f, -0.10730198f, -0.06874373f, 
    -0.03157660f, 0.04190915f, 0.04330442f, 0.05269985f, -0.06700879f, -0.01771910f, 0.03851887f, 0.00022220f, 
    0.04957353f, 0.02587158f, 0.06749207f, -0.06657158f, -0.08074064f, 0.04232025f, -0.06124675f, -0.12282726f, 
    0.00547910f, -0.07153022f, 0.03703686f, -0.01992365f, -0.07254822f, -0.09542237f, -0.03338464f, 0.03593866f, 
    0.01817131f, 0.00998907f, 0.05086630f, 0.02772120f, 0.00243095f, 0.01958058f, -0.07569785f, 0.04779533f, 
    -0.03825849f, -0.00116335f, 0.03449122f, -0.00813165f, 0.04308566f, -0.04817796f, -0.04122404f, -0.00285486f, 
    -0.06438807f, 0.01177714f, -0.11133058f, -0.12017958f, 0.01703588f, 0.02944363f, -0.09074578f, 0.04704207f, 
    -0.03505369f, -0.06567082f, -0.06118560f, -0.00300203f, -0.05330806f, -0.01904253f, -0.04197457f, -0.00966757f, 
    -0.04158175f, -0.04734966f, 0.01246716f, -0.00551069f, -0.01265923f, 0.04573853f, -0.01990236f, 0.07333063f, 
    0.01113530f, 0.04092200f, 0.04810796f, 0.02249069f, -0.07706308f, -0.01592346f, 0.01940994f, 0.01419628f, 
    0.04834798f, -0.03567843f, -0.07357354f, -0.06511548f, 0.00317723f, -0.03264759f, -0.01192686f, -0.00341316f, 
    -0.11644665f, 0.06387749f, 0.04578428f, 0.00144245f, 0.05569929f, -0.07117686f, 0.00459115f, 0.03479056f, 
    -0.11077642f, 0.01483936f, -0.06094762f, -0.09501941f, -0.03730216f, -0.02432463f, -0.08528882f, -0.02343821f, 
    -0.00905381f, -0.08200785f, -0.00630333f, -0.06881716f, -0.05195114f, 0.02885433f, 0.03990069f, -0.04001297f, 
    -0.26393315f, -0.01638613f, 0.04551633f, -0.02884612f, -0.10902644f, 0.24910112f, 0.14664072f, 0.38047478f, 
    0.07934329f, 0.30829933f, -0.02324438f, 0.17809045f, 0.42358357f, 0.14877522f, 0.15548466f, -0.01915421f, 
    0.20964193f, 0.12783115f, 0.29710296f, 0.04277861f, 0.06554077f, -0.04682149f, 0.12498094f, 0.43887782f, 
    0.09589446f, -0.06750469f, 0.19662060f, -0.00859130f, 0.03530077f, 0.22799312f, 0.04041310f, -0.13568150f, 
    -0.21067622f, 0.00636502f, -0.15118222f, 0.18503316f, 0.16027394f, 0.16387710f, -0.41042596f, -0.03469822f, 
    -0.04628119f, -0.05990238f, 0.11129393f, -0.30443326f, -0.27053419f, -0.00652189f, -0.05977352f, 0.04098594f, 
    -0.29091528f, -0.06093192f, -0.05771585f, 0.13215995f, -0.16220488f, 0.05718822f, 0.02096933f, 0.06952973f, 
    -0.01099178f, -0.25681672f, 0.01928697f, 0.10498960f, -0.11984283f, -0.09593351f, -0.02145037f, 0.09700879f, 
    0.04810533f, 0.02146491f, 0.08678595f, 0.04084020f, -0.20568371f, 0.04517626f, -0.15082441f, -0.14631228f, 
    -0.02083353f, 0.02684962f, -0.05794539f, 0.07409305f, 0.38751367f, 0.01457351f, -0.09903202f, 0.24490704f, 
    -0.21877061f, 0.02691889f, 0.14325126f, -0.13930917f, 0.03500151f, 0.16046679f, -0.11450852f, -0.05158575f, 
    0.20352086f, -0.36910468f, 0.29009542f, 0.11063588f, -0.11652343f, 0.11547522f, 0.05849847f, 0.03297113f, 
    0.18735272f, 0.11347172f, 0.15048447f, 0.13213424f, 0.15356725f, -0.05464062f, -0.06846946f, -0.03755170f, 
    0.08782791f, -0.04553203f, -0.05763986f, -0.13604052f, -0.00247878f, -0.18434380f, 0.06662635f, 0.24602282f, 
    0.03282388f, -0.08221461f, 0.18492499f, 0.14968342f, 0.21336754f, -0.06458267f, 0.02452477f, -0.13897885f, 
    0.14126535f, -0.07525790f, -0.12168428f, -0.02894768f, 0.18597449f, 0.23491655f, -0.29252273f, 0.11520439f, 
    -0.00604662f, -0.14077239f, -0.04698478f, 0.05222758f, 0.04073422f, -0.04846529f, 0.03166291f, -0.05016445f, 
    0.04782574f, -0.00607418f, 0.06075044f, -0.03751491f, 0.02118127f, 0.04905396f, -0.04256813f, -0.01676385f, 
    -0.04763158f, 0.05812764f, -0.03761317f, 0.06582581f, -0.09341870f, 0.02324214f, -0.08993518f, 0.08791745f, 
    -0.03772249f, 0.01181983f, -0.03708271f, -0.02498486f, -0.11471335f, -0.04263629f, 0.08031127f, 0.03890522f, 
    -0.06593419f, -0.07089672f, -0.02597033f, 0.02286674f, -0.00975047f, 0.01850592f, -0.02915434f, 0.03484829f, 
    -0.01070256f, -0.08323032f, -0.05779110f, 0.01326295f, -0.11502647f, 0.05879508f, 0.05067912f, -0.07592812f, 
    -0.10491468f, -0.00986718f, 0.08560992f, -0.04401950f, -0.12162469f, 0.02131500f, 0.03286913f, -0.07018946f, 
    -0.08610360f, -0.07044019f, -0.10014254f, -0.04500812f, 0.01566462f, -0.15784378f, -0.01650525f, -0.05552772f, 
    -0.04620570f, 0.02242758f, -0.06841452f, 0.00185367f, -0.10587423f, -0.10345671f, -0.10741729f, 0.03169815f, 
    -0.09688233f, -0.11075322f, -0.03508078f, -0.01630981f, 0.03525942f, -0.08898482f, -0.07630984f, 0.09769777f, 
    -0.04060028f, -0.04936450f, -0.04547961f, -0.08332226f, 0.08465337f, 0.00707133f, 0.05472858f, 0.04186650f, 
    0.03340420f, 0.03308322f, -0.07460798f, -0.00646510f, -0.08919943f, -0.07861374f, -0.04068995f, 0.01090799f, 
    -0.02868092f, -0.05780548f, -0.10528363f, -0.04940847f, 0.01017115f, 0.04433170f, -0.04683202f, 0.04848015f, 
    -0.04670532f, 0.03262649f, 0.01502113f, -0.02907569f, 0.06882791f, -0.02896941f, -0.05312401f, -0.00730440f, 
    -0.02068037f, -0.05854735f, -0.00481693f, -0.03437158f, -0.03246508f, 0.07054064f, -0.11424049f, -0.01676781f, 
    -0.03218605f, -0.00771123f, 0.00689111f, -0.06389660f, 0.01150982f, -0.09627062f, -0.09287547f, -0.09371881f, 
    -0.05236820f, -0.31833440f, -0.06542490f, 0.01992588f, 0.06116001f, 0.15179230f, -0.03480852f, 0.39594030f, 
    -0.01422779f, 0.05369579f, 0.03804074f, 0.06771834f, 0.24246779f, 0.12212767f, 0.12312588f, 0.17631693f, 
    -0.16145027f, 0.29491246f, -0.15498096f, 0.19904436f, -0.00846357f, 0.04040877f, -0.35576949f, 0.07787067f, 
    -0.03038882f, -0.12303695f, -0.19835998f, -0.06128415f, -0.06066844f, 0.18548755f, -0.00952248f, 0.08627854f, 
    0.13817585f, 0.06648363f, 0.28314367f, 0.22085306f, 0.15559630f, -0.35627803f, -0.03805742f, 0.05168696f, 
    -0.05831373f, -0.17096922f, -0.05076716f, -0.07850149f, 0.07390974f, 0.05508862f, -0.02961436f, -0.03404777f, 
    -0.24951832f, 0.08490727f, 0.03806051f, -0.10490130f, -0.01324106f, -0.10685486f, 0.09910076f, 0.07098256f, 
    0.30675012f, -0.07329341f, -0.14473036f, 0.05300682f, 0.01041259f, 0.11329082f, 0.11737210f, -0.06350227f, 
    -0.14621855f, -0.18402056f, -0.34761661f, -0.00990853f, 0.02471532f, -0.01563152f, 0.18544419f, -0.09409031f, 
    -0.08826602f, 0.16858536f, -0.08807655f, 0.07539500f, -0.08254607f, 0.10045826f, -0.01806103f, 0.00895427f, 
    0.40723965f, 0.13971920f, -0.10611679f, 0.08596946f, 0.13227044f, -0.05888143f, -0.03358838f, 0.02115246f, 
    -0.24527383f, -0.02326649f, 0.14637148f, -0.06665484f, 0.22457442f, -0.45019865f, -0.02721155f, 0.04451545f, 
    0.21943547f, 0.22226645f, -0.19569607f, -0.05574554f, -0.57387507f, -0.02823890f, 0.02657589f, 0.01317278f, 
    0.01392749f, -0.29721051f, -0.04321029f, 0.16128851f, -0.01383258f, 0.25673315f, -0.02860575f, 0.09478039f, 
    0.10256382f, 0.12600797f, 0.77233768f, -0.25951871f, -0.11434977f, 0.06441281f, -0.20928968f, 0.02045627f, 
    -0.09675400f, 0.21311565f, -0.24462698f, 0.14867724f, 0.00789745f, -0.09791470f, 0.09920618f, -0.20108773f, 
    -0.02752393f, -0.06041275f, 0.05245521f, -0.07412165f, -0.06448320f, -0.02640936f, 0.00694199f, -0.01649625f, 
    0.03785595f, -0.08016859f, 0.03273937f, -0.07757519f, 0.01456318f, -0.06436689f, -0.00066401f, 0.03126219f, 
    0.03404119f, -0.05563043f, -0.02081988f, -0.02939953f, 0.00952189f, -0.09186258f, -0.07205868f, -0.05784651f, 
    -0.05235234f, -0.02243768f, -0.06353112f, -0.01129758f, -0.02450069f, -0.03713893f, 0.04880317f, 0.05197744f, 
    -0.02740791f, 0.01104315f, 0.07873437f, -0.02591195f, 0.01400368f, 0.03719850f, -0.05349878f, 0.07919112f, 
    0.02009076f, 0.06051430f, 0.02077107f, -0.00338341f, -0.00192354f, -0.03028757f, -0.05293169f, -0.01111616f, 
    0.05497609f, -0.05136278f, 0.08333279f, -0.05857828f, 0.06401247f, -0.07137420f, -0.08427246f, -0.00730281f, 
    -0.02141950f, -0.05839520f, 0.00179618f, -0.00950852f, 0.00732178f, -0.08882871f, -0.00549587f, -0.01396129f, 
    0.04755365f, -0.07812250f, 0.06573319f, 0.05121259f, 0.00669630f, 0.05026333f, 0.00332606f, -0.04242816f, 
    -0.05932088f, -0.03862542f, -0.03376782f, -0.09346047f, 0.03698153f, -0.06295571f, -0.01556042f, 0.02558370f, 
    -0.03419080f, 0.01622322f, -0.01942969f, -0.07799689f, 0.01184590f, 0.04488344f, 0.02653042f, 0.01905947f, 
    -0.00902247f, 0.05596677f, -0.05598669f, -0.00290650f, -0.03282175f, -0.09262954f, 0.07984204f, -0.05723088f, 
    -0.02904597f, -0.02484891f, 0.07297768f, -0.00555316f, 0.04986645f, -0.01669679f, -0.00376685f, 0.00327402f, 
    -0.05505861f, -0.03817911f, -0.05121819f, -0.08189858f, 0.00689122f, 0.02721167f, 0.05033085f, -0.01199487f, 
    -0.04095872f, 0.05553331f, 0.05470894f, -0.07588279f, 0.05904771f, 0.04089318f, -0.05948793f, 0.04310466f, 
    -0.05897325f, -0.02962428f, -0.05848534f, -0.05711978f, -0.05487033f, 0.07532147f, 0.05370292f, -0.01095980f, 
    -0.02566359f, -0.17192823f, -0.22346893f, 0.07721090f, -0.09263724f, -0.07509998f, -0.05923297f, 0.52469450f, 
    0.00255486f, -0.00381389f, -0.08313245f, -0.01802885f, 0.08460238f, 0.00759020f, 0.25646660f, 0.13398036f, 
    0.05714566f, 0.39814097f, -0.16168810f, 0.15477397f, 0.10727615f, -0.02095162f, -0.27477163f, 0.03852341f, 
    0.00674474f, -0.33674729f, -0.13783488f, 0.00379776f, -0.11459649f, 0.07017584f, 0.01120214f, 0.26769644f, 
    0.17112814f, -0.05384637f, 0.28469935f, 0.33542785f, 0.21930692f, -0.28631958f, 0.02713210f, -0.01167915f, 
    -0.06508593f, -0.00283414f, 0.12446069f, 0.09388763f, 0.13946220f, -0.00808006f, -0.02822397f, 0.04110770f, 
    -0.39232486f, 0.06913783f, 0.05410735f, -0.00679945f, -0.07249903f, -0.01149894f, 0.10849307f, 0.02852588f, 
    0.48417810f, -0.14019558f, -0.12100034f, 0.17281710f, 0.10399778f, 0.21681327f, 0.11837798f, -0.19948612f, 
    -0.06332765f, -0.14294383f, -0.12086936f, -0.23654751f, 0.05958613f, -0.03922124f, 0.08190217f, -0.20548627f, 
    -0.00712015f, 0.10698395f, -0.10763691f, -0.10061436f, -0.07670823f, 0.17987081f, 0.01485233f, -0.18468533f, 
    0.19324321f, 0.16806012f, -0.12563060f, 0.14760520f, 0.14451589f, -0.16395418f, -0.08586492f, -0.05693590f, 
    -0.19546579f, 0.15430735f, -0.09091543f, -0.00190371f, 0.25335312f, -0.35718033f, -0.00541206f, -0.00759903f, 
    0.10633124f, 0.01972075f, -0.08147062f, 0.13140155f, -0.23518227f, -0.10104330f, -0.03622866f, -0.02618142f, 
    0.11724115f, -0.21608725f, 0.02619574f, -0.01718387f, 0.00821211f, 0.28170833f, -0.01932057f, 0.29542181f, 
    -0.06397666f, 0.22443995f, 0.34514841f, -0.23299961f, -0.24034373f, 0.04245174f, -0.08422019f, -0.06414150f, 
    0.13788298f, 0.02720796f, -0.04910014f, 0.07974017f, -0.03076656f, 0.01738025f, 0.03980544f, -0.12279630f, 
    -0.32083592f, -0.01845301f, -0.58278507f, -0.05234139f, -0.11818016f, 0.20748445f, 0.17851910f, -0.30914113f, 
    0.01857776f, 0.18575560f, -0.29511800f, 0.16281332f, -0.07940117f, 0.12007969f, 0.17892943f, -0.12651493f, 
    0.35697228f, 0.41159973f, 0.19526014f, -0.17453164f, 0.08737947f, 0.08597542f, 0.18952888f, 0.26017487f, 
    0.15122679f, -0.41464910f, 0.01012343f, 0.00817948f, -0.02725437f, 0.17541857f, 0.02534606f, 0.09401895f, 
    -0.12171420f, 0.04860368f, 0.01364172f, -0.04366519f, 0.07233658f, 0.19786346f, -0.10631383f, -0.00243724f, 
    -0.00926379f, 0.08490099f, -0.03254445f, -0.12925620f, -0.13372689f, -0.11199238f, 0.08251990f, 0.05145542f, 
    -0.11142044f, 0.39413458f, -0.02660590f, 0.14404337f, 0.05945903f, -0.13246447f, 0.08354035f, 0.08945424f, 
    0.03108829f, -0.10034832f, 0.04632942f, 0.21214458f, -0.07900023f, -0.03446470f, -0.02416382f, 0.30631992f, 
    0.11922574f, 0.02556784f, 0.01644190f, -0.10581037f, 0.09497009f, -0.09808226f, -0.06765047f, -0.18446407f, 
    0.04659717f, 0.16083615f, 0.00819543f, 0.00289044f, 0.23389085f, 0.02913204f, 0.00080989f, 0.15064785f, 
    -0.04952472f, -0.14339907f, 0.25751236f, 0.03608693f, -0.14677231f, 0.23506887f, 0.28473014f, -0.06060220f, 
    0.09641001f, -0.62340730f, 0.18187736f, 0.15162219f, -0.08903184f, 0.06715130f, -0.03421215f, 0.02891582f, 
    -0.04696099f, -0.11235922f, 0.28728950f, 0.04216935f, 0.09019610f, -0.14476871f, 0.11323516f, 0.00558259f, 
    0.23369265f, 0.32687163f, -0.03010743f, -0.19503914f, 0.02432575f, -0.00553908f, 0.14790638f, 0.26970863f, 
    -0.15032165f, -0.01882292f, -0.08208073f, 0.08699296f, 0.10910019f, -0.04901835f, 0.24572098f, -0.08391378f, 
    0.12977029f, 0.07208809f, 0.23713180f, -0.20531200f, -0.00565621f, 0.13988009f, -0.13025539f, 0.05410151f, 
    0.17053767f, 0.17551295f, -0.62672985f, -0.08169975f, -0.15700343f, 0.13795377f, 0.04216052f, -0.07158966f, 
    0.42637271f, 0.10936580f, 0.02634898f, -0.11691764f, 0.28782544f, -0.08429943f, 0.12177958f, -0.05262956f, 
    -0.12524827f, -0.08083264f, -0.03486479f, -0.18320347f, -0.05148640f, 0.08957695f, 0.15192817f, 0.03320824f, 
    0.06874635f, -0.03188809f, 0.17200117f, 0.06300120f, -0.11673099f, -0.14433549f, -0.09617874f, -0.02456269f, 
    0.06698337f, -0.02799654f, -0.17226291f, -0.15745462f, 0.13225059f, -0.19147354f, 0.10363746f, 0.08178140f, 
    -0.05646347f, 0.04017222f, 0.16384017f, 0.01191649f, 0.20312616f, -0.14839268f, -0.03062509f, 0.16148856f, 
    -0.05743523f, -0.51853979f, -0.02257920f, -0.02623971f, 0.01391104f, 0.06877097f, -0.16433725f, 0.19075523f, 
    -0.03008504f, 0.07214142f, 0.08995855f, 0.04322471f, 0.12924589f, -0.00153446f, -0.02706702f, -0.11509329f, 
    0.00134650f, -0.25135335f, 0.23032023f, -0.12892278f, -0.14381117f, -0.01306636f, -0.08394609f, -0.05251090f, 
    0.21661721f, -0.10653038f, 0.25803986f, -0.01236430f, 0.01683808f, -0.19020569f, 0.02621505f, -0.15138935f, 
    -0.08653809f, 0.14876013f, 0.03154206f, -0.04272426f, 0.18225580f, 0.04575069f, 0.25947100f, 0.01532485f, 
    0.12050162f, 0.00891292f, 0.13420120f, 0.15500280f, -0.17523782f, 0.13517535f, -0.07932922f, -0.00716914f, 
    0.06632137f, -0.00189681f, -0.11084859f, 0.24016500f, 0.40827921f, 0.14728607f, 0.01273917f, 0.05815566f, 
    0.07412247f, 0.05351989f, 0.20623548f, 0.04776616f, -0.00866820f, 0.12556918f, -0.05995176f, -0.09891293f, 
    0.15514781f, -0.18780534f, -0.27431259f, 0.02670585f, 0.10141960f, 0.03845781f, 0.02015303f, -0.19386913f, 
    0.18312214f, -0.02309700f, -0.17891647f, -0.02357377f, 0.04126544f, -0.02706924f, 0.10034479f, 0.09042341f, 
    0.37131217f, 0.18360895f, 0.46141508f, -0.06818593f, -0.12725490f, -0.08843540f, -0.13299412f, -0.00838459f, 
    0.29289272f, 0.21400447f, 0.21667801f, 0.24546514f, 0.03032242f, -0.23138653f, -0.00936390f, -0.06965093f, 
    -0.20644574f, -0.30665553f, 0.01004598f, -0.07559911f, -0.10828432f, 0.15442005f, 0.09247240f, 0.07543683f, 
    -0.19245264f, 0.29195428f, 0.13419300f, 0.00364169f, -0.42778012f, -0.20584765f, -0.06362642f, -0.02254394f, 
    0.22330505f, 0.06582776f, 0.25946143f, 0.09080930f, 0.06989740f, -0.22272545f, 0.10625072f, 0.06560555f, 
    0.03526609f, -0.13805209f, -0.16454795f, 0.24358906f, 0.15360743f, 0.05684409f, -0.08760288f, -0.02837332f, 
    0.11069851f, 0.17394373f, 0.02727526f, -0.15246218f, 0.11064454f, 0.26139385f, -0.34418842f, -0.10173227f, 
    -0.29241064f, 0.20057441f, 0.04309473f, -0.13458405f, 0.19417322f, -0.18976542f, 0.05983341f, 0.17813307f, 
    -0.22736664f, -0.23980989f, 0.04095484f, 0.08326639f, 0.17692915f, -0.15108006f, 0.23038231f, 0.17764044f, 
    0.15874645f, -0.29584181f, 0.24158548f, 0.18656418f, 0.11446507f, -0.26286843f, 0.08246072f, 0.02991767f, 
    0.16892499f, 0.27713302f, 0.07172228f, 0.07357468f, 0.13195066f, -0.10354609f, -0.08978195f, -0.04697252f, 
    -0.11264809f, 0.04267805f, 0.28069505f, 0.10391114f, 0.03968838f, 0.09508569f, -0.10414585f, -0.01420496f, 
    -0.03683307f, 0.19307120f, -0.21116127f, 0.01694670f, 0.49302909f, 0.24645767f, 0.25098911f, -0.06446650f, 
    -0.13974111f, 0.32726005f, 0.07367945f, 0.00963675f, 0.04480963f, 0.00796473f, -0.32233763f, -0.53831857f, 
    0.28751832f, 0.01553147f, 0.34750220f, -0.07793181f, 0.28539589f, -0.08060560f, 0.07346911f, -0.13481447f, 
    0.07326391f, -0.08572776f, -0.01848870f, 0.30902231f, -0.13110295f, -0.29616246f, 0.21039301f, 0.02201985f, 
    0.21008551f, 0.19979943f, -0.41673040f, -0.03392711f, 0.09117083f, -0.30628049f, -0.17246203f, -0.51378083f, 
    -0.00513615f, -0.28114218f, 0.08854277f, -0.06902576f, -0.16372915f, 0.03193080f, 0.10303766f, 0.07772083f, 
    -0.04004101f, -0.24621671f, -0.09287634f, -0.48118538f, 0.04057516f, 0.29592583f, 0.08997624f, -0.15479860f, 
    0.04695787f, 0.00540895f, 0.08210573f, -0.07444925f, -0.19269744f, -0.09437405f, -0.05549308f, 0.03448702f, 
    -0.00960346f, -0.03943880f, 0.10233589f, -0.11745909f, 0.03090455f, 0.07030161f, 0.50652629f, 0.06390572f, 
    -0.01289674f, 0.22810499f, -0.11384557f, 0.12372917f, 0.23798758f, 0.04196878f, 0.06188132f, 0.13024643f, 
    0.18216333f, 0.02714208f, -0.01158555f, -0.03107654f, 0.08921738f, 0.08060216f, 0.07839548f, -0.01689506f, 
    -0.09846773f, 0.42716968f, 0.09926431f, -0.06651425f, 0.25490364f, 0.05959112f, 0.14581022f, -0.11142138f, 
    -0.00706255f, -0.08841675f, 0.15860343f, 0.00149046f, 0.10148259f, 0.04197614f, -0.01979687f, 0.22254114f, 
    0.06701075f, -0.07541097f, 0.12719537f, 0.16480662f, -0.11741490f, 0.12376278f, 0.01374900f, -0.14111690f, 
    0.14130190f, -0.06839781f, 0.05618408f, 0.02692243f, -0.10200687f, 0.00923647f, 0.16605248f, 0.04848966f, 
    -0.28049594f, 0.24691930f, -0.35583016f, 0.16969010f, 0.08763646f, 0.17487562f, 0.03201341f, 0.05710439f, 
    -0.08868206f, -0.02161667f, 0.04866967f, 0.11006750f, -0.03610770f, 0.11281097f, -0.14253214f, -0.02302693f, 
    0.01657661f, -0.05894078f, 0.38058907f, -0.15254682f, -0.00601332f, -0.01477372f, 0.11899748f, -0.05894018f, 
    0.10289957f, 0.16152214f, -0.24736409f, -0.24265064f, -0.13127285f, -0.04518278f, 0.18180904f, 0.10896534f, 
    -0.00818123f, -0.08380055f, 0.22977714f, 0.01220959f, -0.02669131f, -0.09375799f, 0.27542692f, 0.03154628f, 
    -0.05824839f, -0.01809925f, -0.04678862f, -0.10705258f, 0.00186084f, -0.01656311f, 0.06379110f, -0.03523452f, 
    -0.09234159f, 0.00039694f, -0.11619009f, 0.02339730f, 0.07718445f, -0.11296283f, -0.06339528f, -0.00845539f, 
    0.05939728f, 0.04049856f, -0.05608225f, -0.04263552f, -0.06610810f, -0.07161067f, -0.04751875f, 0.00872723f, 
    -0.01844454f, -0.10214075f, 0.00973238f, -0.04549658f, -0.02985788f, -0.07800545f, -0.07831114f, -0.05444700f, 
    0.03205151f, 0.07237289f, 0.00647298f, -0.11546368f, 0.03906820f, 0.06551775f, -0.05280014f, -0.08779451f, 
    -0.02497475f, -0.08668403f, -0.06530731f, -0.07586926f, -0.10947920f, 0.02694213f, 0.02360635f, -0.03310543f, 
    -0.00707262f, 0.03937941f, 0.04574974f, -0.06426960f, 0.02744729f, 0.06123814f, 0.04164120f, -0.04593604f, 
    0.01621555f, -0.05006011f, -0.11838710f, -0.11426384f, 0.07782017f, -0.00197758f, -0.10398454f, -0.04735480f, 
    0.03406637f, 0.04635911f, -0.06038114f, 0.02503626f, 0.02915189f, -0.09827756f, -0.00704176f, 0.00612562f, 
    -0.04276183f, -0.09095648f, 0.00076059f, -0.06965485f, -0.01623229f, -0.09295721f, 0.01733679f, 0.05513961f, 
    0.07764146f, 0.07929456f, -0.02414588f, 0.00051475f, 0.03706829f, 0.05820761f, 0.02173899f, 0.05889224f, 
    -0.11288445f, -0.06208912f, -0.04005436f, -0.03288419f, -0.04752306f, 0.03039113f, 0.07584730f, 0.05158198f, 
    -0.05450063f, -0.05705634f, -0.04560456f, -0.06086859f, -0.06578465f, 0.05925363f, 0.01855649f, 0.07050718f, 
    0.05717287f, -0.00549302f, 0.01928219f, -0.07580437f, -0.06785759f, -0.05610265f, 0.04759229f, -0.01006036f, 
    -0.05294960f, -0.02505537f, 0.06012518f, -0.04550089f, 0.05825987f, -0.07535589f, 0.07172364f, -0.04559911f, 
    0.01206539f, -0.01409340f, -0.00847651f, 0.05417069f, -0.06024207f, -0.11911478f, -0.00466183f, 0.03406220f, 
    -0.03909172f, 0.04962217f, -0.02272892f, -0.02105203f, -0.09964809f, -0.05612785f, 0.01975200f, -0.01279192f, 
    -0.05545504f, 0.02764140f, -0.03683219f, 0.01863129f, -0.01498534f, 0.00697732f, 0.04275768f, -0.00022182f, 
    -0.03607708f, -0.00008418f, -0.08929893f, -0.02296078f, -0.03773038f, 0.02484399f, -0.06252059f, 0.01876441f, 
    -0.01565536f, 0.05370133f, -0.07410408f, -0.07932870f, 0.00066699f, -0.09493724f, -0.07485013f, -0.01122523f, 
    -0.08343127f, 0.02429729f, 0.03088391f, 0.04002783f, -0.01724329f, 0.03774629f, -0.06152806f, 0.04710621f, 
    0.00302019f, -0.10854798f, 0.00378777f, -0.07955340f, 0.01895736f, -0.04991215f, 0.07299487f, 0.00880607f, 
    0.06205215f, -0.04758809f, -0.06501067f, 0.05225892f, 0.03343112f, 0.07664217f, 0.00976691f, -0.08641745f, 
    -0.02847543f, -0.06801637f, -0.00827787f, -0.08959268f, 0.01793319f, -0.06897999f, -0.08136129f, -0.02508560f, 
    -0.09521353f, 0.02751066f, 0.06405950f, -0.00257613f, -0.07032103f, 0.03221692f, 0.06821036f, -0.01482931f, 
    -0.04299289f, 0.02670672f, -0.04232457f, -0.02765816f, -0.02487782f, -0.04648272f, -0.07972925f, -0.03979029f, 
    -0.07539378f, 0.00897023f, -0.10687800f, 0.00595175f, -0.08714847f, 0.06247674f, 0.01224785f, 0.08791131f, 
    -0.08668710f, 0.03316003f, -0.09232143f, -0.10718966f, -0.06247037f, -0.05856001f, -0.04256129f, -0.04892099f, 
    -0.06874563f, -0.03434049f, -0.08337839f, -0.03899216f, 0.07362077f, 0.00034776f, -0.03316854f, 0.07046795f, 
    -0.00058609f, -0.00159789f, 0.04994728f, -0.05399047f, -0.04391538f, -0.10576950f, -0.10444884f, 0.02200642f, 
    -0.01903651f, 0.05197008f, -0.04991293f, 0.06136209f, -0.08232780f, 0.08310421f, -0.10305489f, -0.00879452f, 
    -0.09515620f, -0.03788647f, -0.00698478f, -0.08164585f, -0.02357933f, -0.09158334f, -0.09143825f, -0.07040856f, 
    0.12120233f, 0.14073843f, -0.00181690f, -0.06127031f, 0.03446901f, 0.20876624f, 0.23799045f, 0.01042480f, 
    0.00914623f, -0.15887073f, -0.23415130f, -0.25473931f, -0.04785525f, -0.00050191f, 0.05047859f, 0.08246322f, 
    0.32795796f, -0.12542439f, -0.41782245f, 0.21605021f, 0.04428139f, -0.13786700f, 0.02312430f, -0.14919297f, 
    0.11157894f, 0.12625776f, -0.04829304f, 0.07765292f, -0.36251274f, 0.04750548f, 0.09893263f, 0.21320441f, 
    0.11213902f, -0.06557000f, 0.23618330f, -0.36076322f, 0.11273932f, 0.21394165f, -0.11884138f, 0.02996955f, 
    0.02694508f, 0.02122609f, 0.32164517f, 0.03873082f, 0.07562793f, -0.54752427f, 0.03814530f, 0.18782961f, 
    -0.31974834f, -0.26061925f, -0.01863601f, -0.01196092f, 0.22798540f, -0.18155836f, -0.03342114f, 0.07919353f, 
    0.01372989f, -0.14782216f, -0.11653717f, -0.19419259f, -0.09299439f, 0.16543126f, -0.06638039f, 0.26932353f, 
    -0.42091528f, -0.03868728f, -0.06034960f, -0.70574498f, 0.20439650f, -0.05093106f, 0.03587877f, -0.42275885f, 
    0.00210932f, 0.31453142f, -0.23866743f, -0.25141361f, -0.46834624f, 0.07873943f, 0.06693300f, -0.28281960f, 
    -0.02398787f, -0.03140112f, -0.01802598f, 0.16021587f, 0.16790171f, 0.28075963f, -0.22258903f, -0.05861858f, 
    -0.25784701f, -0.25952563f, 0.16102427f, 0.12046302f, 0.12706831f, -0.20523760f, -0.09754417f, -0.08020031f, 
    0.13450408f, -0.30322358f, -0.20430636f, 0.17667024f, -0.08890886f, -0.06875346f, 0.37914276f, 0.08287086f, 
    0.02927151f, 0.11308753f, 0.18185318f, 0.19066098f, -0.08331902f, 0.13183974f, 0.04743432f, 0.07238968f, 
    -0.25842679f, 0.29955000f, 0.38859120f, 0.34248805f, 0.21080983f, -0.01604636f, 0.09827474f, 0.12891786f, 
    0.21594428f, -0.17993723f, 0.26988339f, 0.15421191f, -0.33007368f, 0.02553639f, 0.18254940f, 0.04864862f, 
    -0.04665102f, 0.07286563f, -0.12870705f, 0.02528676f, -0.08707210f, 0.08203474f, 0.15601270f, 0.48456442f, 
    0.13027608f, 0.49396861f, -0.06978300f, 0.41381550f, 0.28386092f, -0.05659916f, 0.05004886f, -0.22133544f, 
    0.38983166f, 0.04515634f, 0.32538432f, -0.32742304f, 0.13752688f, 0.08907733f, 0.19405892f, 0.41845036f, 
    0.12379951f, -0.32202303f, 0.25633094f, 0.03936381f, -0.06409840f, -0.12005138f, -0.03934956f, -0.54562825f, 
    -0.20758535f, -0.00423119f, -0.70699918f, 0.07209887f, 0.03638489f, 0.22641999f, 0.02825682f, 0.11809137f, 
    0.00866333f, -0.01240170f, -0.12782314f, -0.48099110f, -0.19293639f, 0.07542368f, 0.04167631f, 0.00215710f, 
    -0.18015559f, -0.62072545f, 0.08888409f, 0.14635859f, -0.11314577f, 0.25964707f, -0.09792860f, 0.18553533f, 
    0.00762221f, 0.13393287f, 0.17252234f, 0.10918707f, 0.03628992f, -0.09542507f, 0.04524444f, 0.28617373f, 
    0.02142559f, -0.04134711f, 0.10037399f, 0.04954578f, -0.38592565f, -0.05675733f, -0.23587023f, 0.06088116f, 
    0.13898450f, 0.03811258f, 0.15862566f, -0.00391061f, 0.34426391f, -0.28145102f, -0.03381387f, 0.10131199f, 
    -0.20874727f, 0.07832049f, 0.38912919f, -0.23656785f, 0.06164224f, -0.07043044f, -0.00736535f, 0.04433670f, 
    0.18184046f, -0.31206834f, 0.18069576f, 0.17016667f, -0.20874983f, 0.11336645f, 0.00613191f, -0.02194779f, 
    0.25586945f, -0.02898050f, 0.22459950f, 0.11082666f, 0.18565825f, -0.03871645f, -0.17017229f, 0.05789102f, 
    0.14011070f, 0.05296167f, -0.00255130f, -0.17943196f, -0.04956252f, -0.40485311f, -0.00866770f, -0.01270845f, 
    0.12586781f, -0.38878626f, -0.56177884f, 0.06630839f, 0.13963903f, 0.06247012f, 0.22169684f, -0.11371292f, 
    -0.01788973f, -0.21489248f, -0.07840003f, -0.38641647f, 0.13668941f, 0.12043856f, -0.17425659f, 0.15657726f, 
    0.18756464f, -0.00323334f, 0.52324098f, 0.04680806f, -0.01196819f, 0.02476441f, -0.03061782f, 0.15156291f, 
    -0.07594836f, -0.12182462f, 0.04336843f, 0.14493802f, 0.13843764f, 0.13848852f, 0.14830771f, 0.07582778f, 
    0.40579286f, -0.21492592f, 0.12526870f, -0.04966441f, 0.08957963f, 0.18194930f, -0.00801830f, 0.26960874f, 
    0.11860809f, 0.14307712f, 0.00772527f, 0.06740242f, -0.12064930f, 0.15573408f, 0.01195662f, 0.28432003f, 
    -0.28927630f, -0.03745775f, -0.17233634f, -0.04229026f, 0.08317967f, -0.05243997f, -0.04060465f, 0.13791861f, 
    0.03099391f, 0.04173488f, -0.06601090f, -0.21324007f, 0.02773428f, -0.08590295f, -0.06301831f, 0.04582407f, 
    -0.08200926f, -0.06908437f, -0.03742206f, 0.03949742f, 0.06240084f, -0.05463769f, 0.04990219f, 0.06462736f, 
    -0.04884810f, 0.13751093f, -0.11245945f, 0.08113033f, 0.08782882f, 0.11543863f, 0.06853331f, -0.06321509f, 
    0.05745984f, 0.05331056f, -0.13075840f, -0.09555653f, -0.00688022f, 0.09476838f, 0.09564693f, -0.04512169f, 
    -0.04808762f, 0.10902891f, -0.04949727f, -0.01166455f, 0.12463846f, 0.13628863f, -0.03230688f, 0.18407646f, 
    0.03276185f, -0.27458698f, 0.15437476f, 0.13644269f, -0.00838099f, 0.11041300f, 0.00005290f, -0.07611600f, 
    -0.29334566f, 0.55304563f, 0.00297074f, 0.07071522f, 0.18285623f, -0.07047759f, -0.03314484f, 0.05449245f, 
    0.14588860f, -0.01350648f, 0.07719247f, 0.19514626f, -0.25535831f, -0.04242265f, -0.38727626f, -0.00557135f, 
    0.19616540f, -0.48828545f, 0.20835771f, -0.07266778f, -0.04848801f, 0.17326623f, 0.12242121f, 0.14547615f, 
    -0.02405930f, 0.14634882f, 0.15948337f, -0.18737051f, -0.10575804f, 0.00023572f, -0.04883921f, -0.10851325f, 
    0.16560532f, -0.16724771f, -0.03159420f, -0.08472528f, -0.11896534f, 0.12495422f, 0.10682189f, 0.07066435f, 
    -0.03642157f, -0.06246495f, -0.07396732f, -0.05672824f, -0.09121233f, -0.08268464f, -0.04585219f, 0.00589539f, 
    0.05251357f, -0.05601440f, 0.01269948f, 0.05075130f, -0.09558455f, -0.09957381f, -0.02496229f, 0.01076254f, 
    0.01885126f, 0.06018408f, -0.01528096f, -0.02682718f, 0.04053401f, -0.06232838f, -0.02995158f, -0.08819553f, 
    0.02508631f, -0.08899403f, -0.03458402f, 0.04136577f, -0.00989671f, 0.04638687f, 0.00135749f, 0.03894236f, 
    -0.10881466f, -0.05446826f, -0.06827210f, 0.02872985f, 0.02471837f, 0.04664290f, -0.05174349f, -0.05199220f, 
    -0.01232453f, -0.05228935f, -0.01265761f, 0.06222256f, 0.02538372f, 0.00271025f, -0.05299981f, -0.08282617f, 
    -0.03444478f, 0.05706824f, -0.08206365f, -0.01097613f, -0.07055334f, -0.08159166f, 0.05000458f, -0.02055841f, 
    -0.02951979f, 0.01433056f, -0.01230430f, 0.03362680f, 0.01134206f, -0.02250264f, -0.01665200f, 0.00960763f, 
    -0.09379960f, 0.02306099f, -0.09907126f, -0.01195004f, 0.01472382f, -0.10943108f, -0.03037657f, -0.10827174f, 
    0.03698942f, -0.00632830f, 0.02286501f, 0.00896493f, -0.09753897f, -0.04661178f, 0.06815053f, -0.07718516f, 
    0.00328165f, 0.03097258f, 0.00232640f, 0.05673149f, 0.00339101f, -0.00384612f, 0.01158406f, 0.04875728f, 
    0.00114179f, -0.02803693f, -0.00355828f, -0.09694082f, -0.07162905f, -0.06892405f, 0.05330130f, -0.06402403f, 
    -0.09758791f, -0.09804241f, -0.01851154f, 0.04920090f, -0.04431841f, 0.01590490f, -0.06627604f, -0.05568493f, 
    -0.09519639f, -0.05434193f, -0.04238820f, 0.00789100f, 0.04259645f, -0.06568620f, 0.00493021f, -0.01324099f, 
    0.04674900f, -0.08870720f, -0.08244345f, 0.04144904f, -0.09540617f, -0.01452987f, 0.02601120f, -0.08020912f, 
    -0.01958930f, 0.04786244f, -0.03136244f, -0.09085903f, -0.09018706f, -0.00180455f, 0.02133995f, -0.06215945f, 
    -0.11860567f, -0.14440905f, 0.46489924f, -0.20204118f, -0.10297208f, 0.04733057f, -0.24060340f, 0.10147911f, 
    -0.09197100f, 0.01945744f, 0.08937653f, 0.54674137f, -0.09729198f, -0.01612066f, -0.30691227f, -0.21566369f, 
    0.59312630f, -0.16735795f, 0.11556222f, -0.16908908f, -0.23401904f, 0.05144110f, 0.01398760f, 0.32638726f, 
    0.15153933f, 0.15231377f, 0.11522918f, -0.07403739f, -0.26426381f, 0.10744635f, -0.01639840f, -0.41081548f, 
    0.04866255f, 0.08710836f, -0.81782579f, -0.11128280f, 0.10261288f, 0.32571396f, 0.18528557f, 0.18758072f, 
    -0.03597965f, 0.07244851f, -0.45161262f, 0.09829958f, 0.00554116f, 0.02638156f, 0.00095823f, -0.11858330f, 
    -0.51238960f, -0.34819925f, 0.06167201f, -0.14901605f, -0.14444050f, -0.24936233f, -0.12201117f, -0.12331965f, 
    0.01943980f, 0.07015388f, 0.04916516f, -0.10105180f, 0.06594027f, -0.10207304f, 0.20822763f, 0.09533992f, 
    0.00969884f, 0.00712834f, 0.04967466f, 0.14379208f, -0.58995384f, 0.02370605f, 0.20079011f, -0.03649280f, 
    -0.46073431f, 0.05573595f, -0.25386775f, 0.08883169f, 0.20196210f, -0.60428703f, -0.02573700f, -0.10482416f, 
    -0.02006913f, -0.30071864f, 0.24816793f, -0.49195582f, 0.09787039f, 0.06802496f, 0.14110236f, 0.03258004f, 
    0.07828891f, 0.73656344f, -0.04509437f, -0.01393490f, -0.33067781f, 0.09254817f, 0.01292314f, 0.07031795f, 
    -0.25037807f, -0.18886968f, 0.08693948f, 0.12296584f, -0.23699909f, 0.06923101f, -0.00389514f, 0.00639331f, 
    -0.07816788f, 0.10681088f, 0.00306841f, -0.48078471f, -0.04191116f, -0.13784039f, -0.19289614f, 0.32388759f, 
    0.19316626f, -0.20380490f, 0.14443897f, -0.29523399f, 0.12966880f, -0.01665056f, 0.02940458f, 0.18263951f, 
    0.02203985f, -0.15314895f, -0.07660536f, 0.30719557f, -0.08949883f, 0.04246384f, 0.16955283f, 0.11378571f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02267748f, -0.07573984f, 0.28634718f, 0.11962929f, 0.10339234f, -0.02956298f, 0.10873082f, 0.02468853f, 
    -0.02976809f, 0.16990593f, 0.15432042f, 0.02728781f, 0.05370818f, 0.18928754f, -0.06164696f, 0.09528595f, 
    -0.06857343f, -0.04150141f, 0.06493574f, 0.20148320f, 0.21309771f, 0.08192339f, 0.32869729f, 0.21263942f, 
    -0.09334879f, 0.16418579f, 0.11719745f, -0.04846236f, 0.11942610f, 0.13471183f, -0.09508517f, -0.03277422f, 
    -0.18450943f, -0.02825313f, -0.21647884f, 0.02286286f, 0.12196976f, 0.21100922f, 0.08842570f, 0.02825590f, 
    -0.02187204f, -0.15013421f, 0.15749232f, 0.07990032f, 0.12367790f, -0.10315380f, 0.03412607f, 0.20108823f, 
    -0.10618407f, 0.04930574f, 0.01975173f, 0.16052738f, 0.08324614f, 0.13038723f, -0.06238713f, 0.30814099f, 
    -0.10831168f, 0.30775699f, 0.29760149f, 0.14609529f, 0.06077258f, -0.00899363f, 0.05974704f, -0.15448934f, 
    -0.12551312f, -0.00053517f, -0.08273938f, -0.12659575f, -0.02260312f, 0.00088192f, 0.06635251f, 0.19784245f, 
    0.13283557f, 0.05835645f, -0.08645916f, 0.19810931f, 0.03661346f, 0.12667510f, 0.07481955f, -0.08761290f, 
    0.04229008f, 0.01155690f, 0.25625446f, 0.09733858f, -0.06689978f, -0.03103945f, 0.04241708f, 0.21625441f, 
    -0.07041743f, -0.08178467f, 0.19617337f, 0.01943326f, -0.03257928f, 0.04381317f, 0.03488975f, -0.09725897f, 
    -0.08989272f, 0.15008374f, -0.10749590f, -0.04436994f, 0.13830233f, -0.09233714f, 0.05147098f, 0.02140647f, 
    0.00283654f, -0.03637232f, 0.19769792f, -0.02012827f, -0.02206208f, 0.15536761f, 0.05799385f, -0.10072967f, 
    0.16049452f, -0.09544146f, 0.01433449f, 0.06903203f, 0.09284143f, 0.06901230f, 0.12898645f, 0.01314657f, 
    0.35019207f, -0.05948422f, -0.05307356f, 0.19613257f, 0.04659785f, 0.38709578f, -0.08308633f, 0.21390772f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.15259601f, -0.05343339f, -0.49689001f, -0.21900533f, 0.02552039f, 0.07820918f, -0.04909411f, -0.05016102f, 
    -0.02901628f, 0.03293592f, -0.48722064f, -0.21990386f, -0.18973722f, -0.00511243f, 0.05904746f, -0.47873706f, 
    0.08177865f, -0.06733403f, -0.09356002f, 0.11954881f, -0.13312137f, 0.21076745f, -0.48677847f, -0.45867008f, 
    0.05064690f, 0.05853476f, 0.19873354f, -0.07491422f, -0.37675473f, -0.26757026f, -0.01550052f, -0.00009547f, 
    -0.37259915f, 0.03435450f, 0.13277167f, -0.14578997f, -0.17976125f, -0.21104681f, -0.43765336f, 0.12396591f, 
    -0.15182425f, 0.27261537f, 0.08393146f, -0.46819088f, 0.03210495f, -0.05452624f, 0.05427203f, 0.03598237f, 
    -0.71986485f, 0.10152992f, 0.22320953f, 0.05348115f, -0.52671516f, -0.13552488f, -0.02967528f, -0.08082035f, 
    -0.05118412f, 0.04790833f, -0.30523854f, -0.00069528f, -0.17260286f, 0.09456245f, 0.00705917f, 0.04666957f, 
    0.00771986f, 0.13498737f, -0.08267102f, 0.00635346f, 0.07411428f, -0.09290577f, 0.20747960f, 0.30072832f, 
    -0.11854480f, -0.38971683f, -0.04106797f, -0.01937721f, -0.06437612f, -0.18584719f, 0.10156734f, -0.07208911f, 
    -0.06980803f, 0.08538574f, -0.62005633f, 0.01844984f, 0.07042371f, 0.12759060f, -0.03885064f, -0.45302555f, 
    -0.03703009f, -0.00034084f, -0.02861153f, 0.03888172f, -0.00805468f, -0.07248851f, 0.06402053f, -0.02782068f, 
    -0.06408953f, -0.30089223f, 0.10685613f, -0.05902166f, 0.00271685f, 0.00232716f, 0.10079587f, -0.08279644f, 
    -0.05047865f, -0.08834761f, -0.09764917f, 0.23444128f, -0.41971761f, -0.16733354f, -0.38602763f, 0.00086008f, 
    -0.10876752f, 0.04532332f, 0.10673490f, 0.00897954f, 0.06204177f, -0.26014939f, 0.15797958f, 0.08552600f, 
    -0.03293707f, 0.00898880f, 0.04874863f, -0.16598243f, -0.31440818f, -0.04757840f, -0.08351213f, 0.01741390f, 
    -0.02587776f, 0.06180958f, 0.21090597f, 0.10124739f, -0.04770272f, -0.16285384f, -0.06136128f, -0.03175981f, 
    -0.07148708f, -0.03374481f, -0.80569994f, 0.00687868f, -0.47171798f, 0.19373308f, -0.06436110f, -0.06488071f, 
    0.07343969f, -0.04451839f, 0.03936048f, 0.03727864f, 0.15224886f, 0.20630060f, 0.06892703f, 0.05621867f, 
    0.00227276f, -0.27092505f, 0.19673978f, -0.07994074f, 0.22464241f, 0.12540497f, -0.08643780f, 0.03325378f, 
    -0.35573196f, -0.08847059f, -0.02310783f, -0.01701314f, 0.04608991f, 0.20106561f, 0.05048861f, 0.08778512f, 
    -0.01017280f, -0.92859596f, -0.04543869f, -0.41201797f, 0.10214344f, -0.05347726f, -0.01736818f, -0.01813482f, 
    -0.51996779f, 0.13485368f, 0.20130315f, -0.02494573f, -0.21768157f, 0.19365463f, -0.04248114f, 0.06169551f, 
    -0.00611269f, 0.14183860f, 0.14592189f, -0.13677245f, -0.05374410f, 0.17260657f, -0.05416437f, -0.09237592f, 
    0.05530053f, 0.03947419f, -0.08331749f, -0.25504056f, -0.09304364f, 0.00244832f, 0.20091027f, 0.05206558f, 
    0.12128741f, 0.01159592f, -0.56510782f, 0.07505809f, 0.00388331f, 0.05033765f, -0.36928156f, -0.02393616f, 
    0.02146900f, -0.36154863f, -0.12317493f, 0.10221106f, 0.03360727f, 0.16484872f, -0.03736811f, 0.05888239f, 
    -0.05497696f, -0.08358328f, -0.27715415f, -0.00560061f, -0.03527064f, -0.02237462f, 0.04074676f, 0.00233547f, 
    -0.06946034f, 0.04774358f, -0.03405884f, 0.04157722f, 0.07145079f, -0.09198852f, 0.08112635f, -0.05958391f, 
    0.00060549f, 0.01517505f, 0.15309304f, 0.14593109f, -0.19827282f, -0.60669947f, -0.11786615f, -0.08238773f, 
    0.19076952f, -0.04564481f, 0.24730036f, -0.05762360f, 0.11748992f, 0.04507189f, -0.15847032f, -0.44748780f, 
    0.04730454f, -0.00325094f, 0.04391713f, -0.06879672f, 0.05920902f, 0.17677100f, 0.00986200f, 0.28215382f, 
    -0.32658985f, -0.07013404f, -0.72906059f, -0.14751469f, -0.36143923f, 0.05531749f, 0.13233219f, 0.03950721f, 
    -0.04639992f, -0.20831951f, 0.26856437f, -0.68222898f, -0.27741614f, -0.52746844f, 0.03446756f, -0.00291435f, 
    -0.07964855f, -0.05678684f, -0.17384824f, -0.03286830f, -0.45514196f, -0.37529370f, -0.07044642f, 0.26780987f, 
    0.02806814f, 0.29071155f, -0.15084746f, -0.06195570f, -0.22628488f, -0.16696788f, -0.09261496f, -0.04622451f, 
    -0.26402858f, -0.04400520f, 0.19887146f, -0.01912010f, -0.31646848f, 0.00250010f, 0.12411084f, -0.03416815f, 
    -0.07266612f, -0.66680527f, 0.08750816f, -0.42046151f, 0.24261120f, 0.05846395f, -0.07350165f, 0.17443337f, 
    0.20900044f, -0.05227680f, -0.06962712f, -0.06170940f, 0.13331524f, -0.13573290f, -0.08500271f, -0.06181822f, 
    -0.08774104f, 0.19925359f, 0.13173757f, 0.04176870f, 0.29755861f, -0.03830583f, -0.01549949f, 0.13400030f, 
    -0.02318452f, 0.00412861f, -0.02148730f, -0.08329204f, -0.06052803f, -0.00568972f, -0.43836826f, 0.05626861f, 
    0.11533188f, -0.00258228f, 0.25058213f, 0.20348080f, 0.03030702f, 0.09527722f, 0.19950105f, 0.08817482f, 
    -0.02316947f, 0.17354317f, 0.14769264f, -0.06872702f, 0.07660431f, -0.71758997f, -0.06835458f, -0.01088945f, 
    0.17413874f, 0.01629813f, 0.07178526f, 0.02093875f, -0.06247228f, -0.01769935f, -0.06022711f, -0.00234591f, 
    -0.05600162f, 0.12849779f, 0.05504943f, -0.05986604f, -0.11802351f, -0.56568706f, 0.13365892f, -0.07384641f, 
    -0.01979451f, -0.01579147f, -0.44519606f, 0.05433252f, -0.35349444f, 0.29377002f, 0.09123567f, -0.03771812f, 
    -0.54914731f, -0.04894752f, -0.15411523f, -0.04069508f, -0.38246337f, -0.09676553f, -0.04320071f, 0.09256024f, 
    -0.02244479f, -0.04100308f, -0.06371212f, 0.25707242f, -0.78313261f, -0.13658436f, 0.02544843f, -0.32291320f, 
    0.06405293f, 0.02622262f, -0.52155524f, -0.39225250f, 0.24202193f, 0.12287261f, 0.21145047f, 0.08417238f, 
    -0.08025717f, 0.05635759f, 0.16276202f, -0.00545583f, -0.24507235f, -0.68496317f, -0.02303345f, -0.12096542f, 
    0.02037996f, 0.01029823f, -0.08032764f, 0.20732649f, -0.00830212f, 0.07196340f, -0.21580587f, -0.02541966f, 
    0.01250329f, 0.22044240f, 0.11461779f, 0.05511374f, -0.35879397f, -0.17099166f, 0.02952296f, -0.01095730f, 
    -0.18114382f, -0.09018945f, -0.61596304f, -0.05785763f, -0.11986170f, -0.24746171f, -0.18492301f, -0.03322195f, 
    -0.00589125f, 0.09698603f, 0.08139888f, 0.12882860f, -0.33774614f, -0.04577435f, 0.04349335f, 0.13389182f, 
    -0.27135840f, -0.06898135f, -0.39775416f, 0.10375460f, -0.04409367f, -0.61909682f, -0.00116811f, 0.15528218f, 
    -0.07049756f, -0.31663251f, -0.92987883f, -0.08064633f, 0.19275099f, -0.05179029f, 0.03389036f, 0.31346881f, 
    0.09682827f, 0.11448496f, -0.02840338f, -0.04506583f, -0.03829652f, 0.03170809f, -0.07493134f, -0.04859043f, 
    -0.18254034f, -0.15184161f, 0.17645086f, 0.17951196f, -0.00309075f, -0.08210173f, -0.00927629f, -0.06880662f, 
    -0.08665279f, 0.16361935f, 0.02517274f, -0.33839652f, -0.05876889f, 0.04170199f, 0.02714990f, -0.11665525f, 
    -0.66477364f, 0.02080298f, -0.09066910f, 0.03132343f, 0.00541191f, -0.10095047f, 0.00983649f, 0.02196200f, 
    0.04362491f, -0.30485588f, -0.06232757f, -0.02511194f, 0.07870593f, -0.05588448f, 0.03369642f, -0.00562169f, 
    0.03456876f, -0.04051178f, -0.17029798f, -0.20568822f, 0.20839526f, 0.33144331f, -0.21260521f, -0.06914660f, 
    -0.00536742f, 0.00135165f, 0.09933836f, 0.03440819f, 0.09020461f, -0.50541860f, -0.04007998f, 0.15555070f, 
    0.06878214f, 0.06860662f, -0.05418920f, 0.18419115f, 0.20784344f, 0.02725119f, -0.05380663f, 0.03748765f, 
    0.10210354f, -0.06911146f, 0.00743270f, -0.00514900f, -0.20265479f, 0.15393330f, -0.02516703f, 0.04400216f, 
    -0.08567079f, 0.14519812f, 0.08107637f, 0.16378468f, -0.45759407f, -0.24784680f, -0.00113077f, 0.10298291f, 
    -0.01882414f, -0.06082547f, -0.53145891f, -0.03451273f, -0.21295290f, -0.04430696f, 0.10653445f, -0.32198590f, 
    0.00829649f, -0.24267463f, -0.08230462f, -0.01200642f, -1.05761993f, 0.20873609f, -0.05637677f, -0.06346376f, 
    0.25598603f, -0.00734885f, -0.14087906f, 0.13142310f, 0.20330504f, -0.29448864f, -0.04609582f, 0.12971315f, 
    -0.04333171f, 0.14020087f, 0.11441468f, -0.08568384f, -0.62943423f, 0.04811733f, 0.06306098f, -0.90594929f, 
    0.19929659f, -0.01493132f, -0.06843546f, 0.09898266f, -0.25349954f, -0.12924592f, -0.06368409f, 0.05046115f, 
    0.02939883f, -0.34107438f, 0.06101846f, -0.41347060f, -0.76239944f, -0.02818824f, -0.00570035f, 0.04446598f, 
    -0.02585912f, -0.01572486f, -0.00434490f, -0.00244303f, -0.03782129f, 0.03710717f, -0.06290291f, -0.59591120f, 
    -0.86285937f, 0.09646628f, 0.25163490f, -0.18367529f, 0.00654406f, 0.08296677f, 0.08722278f, 0.04114610f, 
    -0.07889399f, 0.10307779f, 0.14148508f, -0.33157402f, 0.02680046f, -0.03360008f, -0.03960476f, -0.00917254f, 
    -0.10805053f, 0.07532095f, -0.33475950f, -0.06412826f, -0.05339239f, 0.03301056f, 0.03486326f, -0.05587078f, 
    -0.01895901f, 0.11326306f, -0.05849030f, -0.07995033f, -0.21973570f, -0.01184350f, 0.07319223f, 0.06976431f, 
    -0.02896670f, 0.00148298f, 0.09555741f, 0.04246487f, 0.24317308f, -0.28301176f, -0.05664738f, 0.02056643f, 
    0.16251844f, 0.04246265f, 0.00253982f, 0.02194682f, -0.02514065f, 0.05946228f, -0.48920938f, 0.13504124f, 
    0.12287601f, -0.00556785f, 0.02906835f, 0.04851530f, 0.29623470f, 0.05216292f, 0.03732525f, -0.25950840f, 
    0.02131400f, 0.00058847f, -0.41296613f, 0.17884092f, -0.11989017f, -0.10762242f, -0.11818214f, -0.06445035f, 
    0.05701596f, -0.03059534f, -0.16336237f, 0.01547409f, 0.24715847f, -0.39120811f, -0.07069471f, -0.03402284f, 
    -0.04266267f, -0.06994174f, 0.22152525f, 0.05049177f, 0.03622123f, 0.09326641f, 0.02099168f, 0.04240004f, 
    -0.00885441f, -0.43245932f, 0.03915566f, -0.05990304f, -0.05605303f, -0.06659088f, -0.00159545f, 0.02424802f, 
    0.09151136f, 0.07450932f, 0.11628794f, 0.09830099f, 0.02258469f, 0.18024933f, 0.00184788f, 0.11791926f, 
    -0.14640093f, 0.03234526f, 0.10180168f, 0.22646987f, 0.30042598f, 0.02158784f, 0.04354983f, -0.37380490f, 
    0.19807538f, 0.14197794f, 0.22829987f, 0.00777520f, 0.31893489f, 0.04812599f, 0.03505345f, 0.05972886f, 
    -0.12919287f, -0.03636201f, -0.29915169f, 0.16939825f, -0.25633630f, 0.09299824f, -0.07991162f, -0.31744206f, 
    -0.07632068f, -0.02188563f, 0.03724316f, -0.05994103f, 0.08274742f, 0.04800209f, 0.09838658f, -0.05909417f, 
    -0.44676813f, 0.03977285f, -0.35928783f, -0.03365235f, -0.03184957f, 0.10503316f, 0.08617897f, 0.07273779f, 
    -0.07520356f, -0.05272060f, 0.02369483f, -0.02999432f, -0.10650858f, 0.07924043f, 0.01500150f, -0.01857365f, 
    0.05189577f, 0.00705276f, 0.17131333f, 0.08708093f, 0.03005349f, 0.06433365f, 0.02837361f, 0.05789047f, 
    -0.02720780f, 0.21140021f, -0.06385408f, -0.03963896f, -0.19750454f, 0.06184014f, 0.08297148f, -0.01052341f, 
    -0.04859244f, 0.00039098f, 0.03048232f, 0.01255905f, 0.29250634f, -0.32665953f, 0.08544300f, -0.03726376f, 
    -0.12778467f, -0.01013214f, -0.09481376f, 0.07426645f, 0.04437813f, 0.00060421f, 0.21223970f, -0.05387456f, 
    0.08571304f, 0.04512753f, -0.08998413f, -0.02782343f, 0.09485107f, 0.00001413f, 0.03424065f, -0.90225726f, 
    -1.00127232f, 0.04909835f, -0.61578733f, -0.21208492f, -0.78771251f, -0.77031565f, -0.37291849f, 0.06052006f, 
    -0.08407015f, -0.69473988f, 0.25438073f, 0.13206552f, -0.30337560f, -0.16096684f, -0.02747728f, 0.14734298f, 
    0.08235826f, 0.05626409f, -0.16369294f, -0.85830045f, -0.31320012f, -0.32844031f, 0.04358158f, -0.35976854f, 
    -0.04352738f, -0.51265556f, -0.12786190f, -0.01134976f, 0.19249997f, 0.10224705f, -0.02457916f, -0.02703328f, 
    0.08937895f, -0.02025484f, 0.04789395f, 0.21883824f, -0.48088685f, 0.00745509f, -0.14832969f, 0.04038921f, 
    -0.06502900f, -0.57883441f, -0.93795562f, -0.11409582f, 0.05008774f, 0.00445597f, 0.03326021f, 0.25453421f, 
    0.12093975f, -0.02651745f, -0.24297825f, -0.98661494f, 0.02936804f, -0.42899975f, -0.08089682f, -0.33340436f, 
    0.04236564f, 0.13348445f, 0.25021565f, 0.24352799f, 0.18732840f, -0.12999119f, 0.04093745f, -0.01543683f, 
    -0.05363428f, 0.03366372f, 0.05199578f, 0.03097115f, -0.00979600f, 0.05457704f, -0.07822844f, 0.09931769f, 
    0.21094969f, 0.02305974f, -0.19612470f, -0.43353808f, -0.06427160f, 0.08054949f, -0.43989453f, 0.00982633f, 
    0.02331781f, -0.11594154f, 0.20840260f, 0.18419644f, 0.03550455f, -0.14254865f, -0.07363075f, -0.08821274f, 
    0.01312157f, 0.02269137f, 0.21538785f, 0.08443210f, -0.05094773f, 0.05692074f, 0.07227923f, -0.01038381f, 
    0.00535721f, -0.15763327f, 0.09073672f, -0.04066487f, 0.00072883f, -0.59939337f, -0.00696964f, -0.07228512f, 
    -0.04368393f, 0.01161406f, -0.63620889f, -0.12380167f, -0.16372415f, 0.12039317f, 0.00991689f, -0.01067808f, 
    -0.14141701f, -0.06177236f, -0.34038174f, -0.05324391f, -0.23559332f, -0.04015187f, 0.18625496f, 0.00598334f, 
    0.02136882f, 0.03870387f, -0.07619780f, -0.80256855f, 0.18537088f, -0.49915352f, 0.03817617f, 0.38136536f, 
    -0.46826997f, 0.07127023f, -0.15708351f, 0.01225551f, 0.34966859f, 0.09389953f, -0.31090149f, -0.00110142f, 
    -0.05517690f, -0.52778894f, 0.00603614f, 0.18032898f, 0.34929118f, -0.50802183f, -0.06359169f, 0.14187084f, 
    0.05403407f, -0.07011778f, 0.01094235f, -0.17360435f, 0.00060685f, -0.29042748f, -0.08805949f, -0.39851847f, 
    0.04321135f, 0.06360249f, 0.19940323f, 0.03377226f, 0.26580492f, 0.07747804f, -0.04678636f, 0.08195462f, 
    0.05074307f, 0.07048929f, 0.03574469f, 0.09189504f, 0.14599456f, -0.04996469f, 0.03547600f, 0.06944025f, 
    0.05022359f, 0.04176244f, -0.14237846f, 0.12300915f, -0.52361673f, 0.06768027f, 0.00661160f, -0.15328981f, 
    0.27215695f, 0.13170634f, -0.05376312f, -0.05306811f, 0.13824931f, -0.06120846f, -0.02126682f, -0.20027484f, 
    -0.04659028f, -0.14399172f, -0.53882700f, -0.21647859f, -0.00988212f, -0.20125003f, 0.02319032f, 0.03505832f, 
    -0.03516033f, -0.22664319f, 0.08663069f, -0.05338422f, -0.06667319f, -0.07691813f, -0.04477625f, -0.31896406f, 
    0.06052936f, 0.03503141f, 0.15749526f, 0.07509427f, -0.05969092f, -0.68174094f, -0.50823218f, -0.00941587f, 
    0.05243393f, -0.34353164f, -0.46477872f, -0.08257564f, -0.03431454f, -0.22722399f, 0.06822834f, -0.03371016f, 
    0.01265644f, -0.05576044f, -0.10887597f, 0.07416693f, 0.00791659f, -0.06166718f, 0.06709103f, -0.04213215f, 
    -0.03336139f, -0.33295703f, 0.01200749f, 0.02585855f, -0.02819850f, 0.27338719f, -0.32495078f, 0.04966345f, 
    0.05350921f, -0.04106281f, 0.24819747f, 0.05912266f, 0.18032452f, 0.19588345f, 0.22324029f, -0.04569302f, 
    0.19220535f, -0.06488133f, -0.09189560f, 0.05609252f, -0.13179938f, 0.09977376f, 0.10152611f, 0.26127499f, 
    -0.60631299f, -0.05594550f, -0.02365835f, -0.28408599f, 0.19944423f, -0.12548964f, -0.09073596f, -0.20487615f, 
    -0.26066864f, -0.08326447f, 0.16251884f, 0.18768696f, 0.14408769f, -0.40063927f, 0.31686732f, 0.02957201f, 
    0.00830524f, 0.05270658f, -0.24184403f, -0.03722463f, 0.32086420f, 0.17017253f, -0.03642054f, 0.08992124f, 
    0.00976347f, 0.05186997f, 0.43266964f, 0.07927752f, 0.42526728f, -0.32293427f, 0.14408658f, 0.19516593f, 
    0.02739757f, 0.19168645f, -0.29850128f, 0.06062989f, -0.25116938f, -0.07218511f, -0.07367439f, 0.01360711f, 
    -0.27223182f, -0.01078940f, -0.20556968f, -0.09527045f, 0.26342586f, 0.20103829f, 0.12106702f, -0.45216778f, 
    0.00229545f, -0.15120456f, 0.01560098f, 0.57237422f, 0.01250708f, 0.04671048f, 0.00307304f, -0.00700615f, 
    -0.11427690f, -0.02719949f, 0.15464395f, -0.07797872f, 0.13892354f, 0.01463666f, 0.01246141f, 0.12222806f, 
    -0.10323866f, -0.07204334f, 0.03969321f, 0.02043622f, -0.04521067f, -0.20529886f, 0.03417049f, -0.24307407f, 
    0.01532316f, -0.25331727f, -0.00708409f, 0.01772245f, -0.02567219f, -0.00650591f, -0.66405392f, 0.10167825f, 
    0.03006110f, 0.07811488f, -0.48852491f, 0.14558885f, 0.06473374f, -0.10656246f, -0.26443061f, -0.01655127f, 
    0.00829116f, -0.11852130f, 0.01826460f, -0.13917191f, 0.02581722f, -0.32033587f, 0.07245544f, -0.01292123f, 
    0.11699005f, 0.04631255f, -0.01894584f, 0.02248305f, -0.02466553f, 0.03703231f, 0.01198130f, 0.00188778f, 
    -0.15488954f, 0.16520604f, 0.04908533f, -0.08164050f, -0.05253686f, 0.17345278f, -0.70371056f, -0.11595231f, 
    -0.08400452f, 0.06973229f, 0.03385713f, -0.33186421f, 0.27878520f, -0.14133431f, 0.09543332f, 0.03381847f, 
    -0.03648676f, -0.06726725f, -0.79529649f, -0.03873946f, -0.68139809f, -0.00446625f, 0.01949613f, -0.44042596f, 
    0.03261969f, 0.06689592f, -0.01191039f, 0.11790287f, -0.12902074f, 0.09588275f, -0.08563924f, 0.61286181f, 
    0.03635744f, -0.07278994f, 0.51750970f, -0.39588681f, -0.73827547f, 0.00163552f, 0.02449030f, 0.00110967f, 
    -0.08092070f, 0.03895753f, 0.08195244f, -0.10589615f, -0.35901257f, 0.05806036f, 0.04088879f, -0.10848555f, 
    -0.01033830f, -0.04658510f, -0.12884378f, -0.06964525f, -0.06570652f, 0.12952723f, 0.01874108f, -0.26380077f, 
    0.07453980f, 0.23658855f, -0.21716151f, -0.07222933f, 0.17995124f, 0.02361565f, 0.07172924f, 0.04666701f, 
    0.12749504f, -0.08661784f, -0.08148376f, 0.09916367f, 0.01052552f, -0.38687915f, -0.32168189f, 0.19767311f, 
    0.01432639f, -0.46223921f, -0.16839713f, -0.21758991f, -0.25016314f, 0.06233181f, 0.02389313f, 0.09084691f, 
    -0.32015523f, -0.00414318f, -0.36289021f, -0.08132776f, -0.19521230f, 0.03493645f, -0.07027647f, -0.13008811f, 
    -0.03232399f, 0.07457504f, 0.23973523f, 0.21971595f, -0.00468491f, -0.02710528f, -0.02690888f, -0.17067580f, 
    -0.08492636f, 0.18357034f, 0.00102338f, -0.12427758f, -0.00025619f, -0.03683408f, -0.43058935f, 0.04229607f, 
    -0.03486197f, -0.03124413f, -0.17222424f, -0.35502094f, 0.04103191f, 0.07879533f, 0.08709794f, -0.05054017f, 
    -0.02348294f, 0.05267870f, 0.12954222f, 0.03515320f, -0.04921568f, -0.44980893f, 0.00614375f, 0.05535707f, 
    -0.38423929f, -0.06447764f, 0.11458223f, -0.06214384f, 0.07368227f, -0.07329973f, 0.03843763f, 0.06812575f, 
    -0.01761910f, -0.45492861f, -0.01277561f, 0.03511040f, 0.20004834f, -0.41064158f, 0.26761958f, -0.09000295f, 
    -0.03154812f, 0.04899075f, -0.56779426f, -0.17691137f, -0.19610614f, 0.08104962f, 0.03359409f, -0.06547826f, 
    -0.26949912f, 0.00015922f, -0.58145630f, -0.07800781f, -0.37505710f, -0.37840837f, 0.18166070f, 0.18728928f, 
    0.15129049f, 0.02855321f, -0.04416793f, -0.44071436f, -0.22621536f, -0.26287365f, -0.03276470f, -0.35940793f, 
    -0.40088639f, 0.02388911f, -0.68120599f, 0.15341848f, 0.22422059f, 0.12756513f, 0.20149130f, 0.03730850f, 
    -0.07410993f, 0.24454957f, -0.09540262f, -0.05446843f, 0.00087088f, -0.34655547f, -0.09116235f, 0.20465516f, 
    -0.08557214f, 0.00429893f, -0.34691623f, 0.01152717f, -0.40544587f, -0.38970521f, 0.10640278f, 0.04919001f, 
    -0.00240683f, -0.49815384f, -0.41690102f, -0.06971906f, 0.06485054f, 0.14040220f, 0.03775132f, -0.01237770f, 
    -0.00228071f, 0.04294076f, -0.75943655f, -0.10684923f, -0.18195751f, -0.01194495f, 0.18440759f, -0.54230434f, 
    -0.14042056f, -0.29323614f, 0.14451541f, -0.18532120f, 0.00678374f, -0.09417190f, -0.01949850f, -0.15923539f, 
    -0.29157016f, -0.67691410f, -0.54473287f, 0.13490514f, 0.09021653f, 0.22107445f, -0.04377547f, 0.17625505f, 
    0.06611454f, 0.19676402f, -0.00068709f, -0.22286408f, -0.11768389f, -0.01166445f, -0.07200115f, 0.11568184f, 
    0.01277552f, -0.29048982f, -0.01717689f, -0.11399222f, -0.04906254f, 0.04852399f, -0.01919763f, 0.11872014f, 
    -0.31152388f, -0.00755564f, 0.08137625f, 0.19172369f, -0.06188468f, -0.05219902f, -0.49876738f, 0.01994164f, 
    0.04639454f, -0.24636973f, 0.06077702f, 0.06116614f, -0.11723676f, 0.02087325f, 0.05298951f, 0.25869119f, 
    0.28077373f, 0.01215200f, -0.15586607f, 0.02548917f, -0.05671319f, 0.00076673f, 0.04576021f, -0.04521426f, 
    -0.05493345f, 0.23915905f, -0.06266322f, 0.08026840f, 0.03714139f, 0.28507584f, -0.27801588f, 0.02775542f, 
    0.01557991f, -0.00901848f, 0.11489195f, -0.14437559f, -0.71618485f, 0.03934873f, -0.14568727f, 0.04536509f, 
    -0.18045846f, -0.02984510f, 0.07715807f, 0.00002924f, 0.04663518f, 0.06125990f, -0.32313758f, -0.42642480f, 
    0.02561651f, 0.02419003f, -0.06507303f, 0.18856701f, -0.40344331f, 0.08904275f, 0.05318883f, -0.32343304f, 
    -0.33458963f, -0.02231299f, 0.12940252f, -0.22207934f, 0.06467918f, 0.32092786f, -0.32994586f, 0.04485596f, 
    0.04259624f, -0.44320232f, 0.13955957f, 0.05938621f, 0.24179989f, 0.25291374f, -0.03626248f, 0.10069457f, 
    -0.00503403f, 0.00323963f, -0.31399974f, -0.45918998f, -0.15600897f, -0.84521919f, -0.01447938f, 0.18200482f, 
    -0.03029087f, 0.24163732f, -0.15134533f, 0.05899820f, -0.02942228f, 0.05190599f, 0.02574848f, 0.04534324f, 
    0.15074322f, -0.03441090f, -0.08153371f, -0.07536799f, -0.86668175f, 0.11550778f, 0.13205637f, -0.52316093f, 
    -0.02117218f, -0.44643301f, -0.52134258f, -0.31333661f, 0.11942016f, 0.01959423f, -0.01135214f, 0.15278043f, 
    0.10144861f, -0.18941657f, 0.22042303f, -0.26959813f, -0.15739365f, 0.19764538f, -0.08705774f, -0.18210034f, 
    -0.06913204f, -0.23203667f, -0.00042749f, 0.05618647f, 0.01153577f, -0.32615635f, -0.06515995f, 0.38563085f, 
    -0.12012552f, -0.13648199f, -0.00841562f, 0.16971645f, -0.03249346f, 0.03979072f, -0.38824680f, 0.13159779f, 
    0.16633774f, 0.12933351f, 0.48324111f, -0.21922094f, -0.02617243f, 0.16594750f, 0.14189304f, 0.04229854f, 
    -0.05325402f, 0.03501689f, -0.00392766f, 0.13020784f, -0.01791115f, 0.00890159f, -0.00575845f, 0.08689912f, 
    -0.13413686f, -0.05749938f, -0.17033952f, -0.02606284f, -0.05715362f, 0.08067930f, 0.05068548f, 0.01342162f, 
    -0.11833145f, -0.02038828f, -0.05561734f, -0.03793501f, 0.03227029f, 0.18390866f, -0.03254726f, -0.06080342f, 
    0.00240029f, -0.03580314f, -0.04889068f, -0.63504213f, -0.00274768f, 0.19387798f, 0.06105130f, 0.05334732f, 
    0.15015212f, -0.06206515f, 0.16513787f, -0.04593680f, -0.06026563f, 0.13218439f, -0.04884186f, -0.42731273f, 
    -0.46271431f, 0.07155665f, 0.03038879f, -0.05174663f, 0.01692369f, -0.27552962f, -0.04114252f, -0.68228662f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.18133691f, 0.30753323f, 0.02227741f, -0.01816597f, -0.09229140f, -0.01918028f, -0.11735308f, -0.20042694f, 
    0.09406180f, 0.07799932f, 0.14762561f, -0.31014511f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
