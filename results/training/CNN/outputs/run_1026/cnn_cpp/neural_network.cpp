#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.05979681f, 0.03280225f, 0.34989178f, -0.62354672f, -0.39914572f, -0.25117475f, -0.07014761f, 0.05971020f, 
    -0.10019986f, -0.06490590f, 0.00313831f, 0.29485783f, -0.17896159f, -0.17878914f, -0.36306471f, -0.33508083f, 
    -0.37637791f, -0.53601217f, -0.48369139f, -0.66922462f, -0.39804211f, -0.03273762f, -0.29642394f, -0.48851395f, 
    -0.61163008f, -0.44955966f, -0.93384546f, 0.00131414f, 1.08538926f, 0.69384551f, 0.81861442f, -0.48879904f, 
    -1.26548183f, -0.74140239f, -0.56460673f, -0.27950534f, 0.14445481f, 0.10732502f, -0.12119898f, -0.04055369f, 
    -0.13226424f, -0.15257807f, 0.41985959f, 0.46325117f, 0.20537257f, -0.04515579f, -0.21352012f, -0.20905235f, 
    0.03013496f, -0.21917388f, 0.68699163f, 0.48555005f, 0.32633919f, 0.29135549f, -0.51813644f, -0.27226627f, 
    0.09331165f, -0.26267207f, -0.29921269f, -0.35082194f, 0.45494294f, -0.33037972f, -0.44945693f, -0.03120798f, 
    0.12660187f, 0.34731281f, 0.14973956f, 0.05949955f, 0.11237184f, -0.04610074f, -0.17839196f, -0.17527580f, 
    -0.24493609f, 0.11687274f, -0.06222688f, 0.94322014f, 0.18353461f, 0.02896912f, -0.58253026f, -0.66483033f, 
    0.20500062f, -0.30371678f, -0.29957563f, -0.03839003f, 0.05796045f, 0.14332640f, 0.39288193f, -0.31782719f, 
    -0.38503936f, 0.71547991f, -0.12331185f, 0.36025646f, -0.07573853f, -0.27256456f, -0.07284222f, -0.32625362f, 
    0.20812045f, 0.30104643f, -0.18371835f, -0.17385957f, 0.09032579f, 0.66710359f, 0.64331895f, -0.16194376f, 
    0.09438268f, -0.10950802f, -0.27424139f, -0.55588019f, 0.12695646f, 0.34884724f, -0.32623985f, 0.06280924f, 
    -0.00197769f, -0.30537665f, -0.09471401f, -0.14448452f, 0.10174005f, -0.09880775f, -0.15998012f, 0.18978886f, 
    -0.03463956f, 0.14145529f, 0.14926590f, -0.26537508f, -0.30392179f, -1.19591236f, -0.79554987f, 0.44113934f, 
    0.51132423f, 0.58768696f, 0.90900350f, 0.75447822f, -0.13639604f, -0.72407848f, -0.25345030f, -0.14362952f, 
    0.18598796f, -0.05753538f, -0.47619560f, -0.32716623f, -0.03536223f, 0.01596157f, -0.19416730f, -0.14129321f, 
    0.22442207f, 0.15293060f, -0.25288808f, -0.20113042f, -0.02048062f, 0.09468588f, -0.75676680f, -0.77086526f, 
    -0.45396802f, -0.39533693f, -0.14513725f, -0.61670607f, -0.79651874f, -0.19579940f, -0.62037903f, -0.67380190f, 
    -0.42985463f, -0.28325725f, 0.37580332f, 0.03936468f, -0.38349345f, -0.06196983f, -0.55145913f, -0.27967861f, 
    -0.04328457f, -0.09938596f, 0.20622520f, 0.12228296f, -0.23467350f, -0.25178504f, 0.41129398f, -0.03083816f, 
    -0.37065265f, 0.14977452f, 0.39078036f, 0.52480215f, 0.26625136f, 0.17177586f, -0.13444538f, -0.30818290f, 
    -0.02729545f, -0.33355257f, 0.25338936f, -0.12580141f, -0.11736338f, 0.44438460f, -0.32197177f, -0.08751577f, 
    0.10957704f, 0.11212073f, -0.24092630f, 0.31923759f, -0.01613314f, -0.33309940f, 0.08708591f, -0.11339998f, 
    0.18957056f, -0.09147671f, 0.06800852f, 0.27897021f, 0.16920403f, 0.28279582f, 0.14731583f, 0.02611324f, 
    0.26247770f, -0.25909692f, 0.08853766f, -0.08742411f, -0.12476357f, 0.30073464f, 0.26651248f, 0.07158905f, 
    0.03846562f, -0.23847118f, -0.11435053f, -0.12039670f, 0.21688175f, -0.11759272f, 0.18400659f, -0.08501320f, 
    -0.18525302f, -0.29767701f, -0.23418854f, -0.04822302f, -0.07021620f, 0.18599287f, -0.50275356f, 0.08197837f, 
    0.21859430f, -0.19990030f, 0.39144906f, 0.05512771f, -0.06000477f, 0.21208437f, -0.13713726f, 0.43825305f, 
    -0.41664630f, -0.28342396f, -0.24054815f, -0.10065246f, -0.28099692f, 0.43506593f, 0.11271925f, 0.32099703f, 
    0.20962280f, 0.36384034f, -0.89999586f, -0.65276188f, -0.69492829f, -0.26216564f, -0.32419854f, -0.06597795f, 
    0.09063785f, 0.45610473f, 0.08096235f, 0.44624484f, 0.13300687f, 0.13424991f, 0.22810473f, 0.01698315f, 
    0.14074165f, 0.09204192f, 0.19687085f, 0.08154330f, 0.12691063f, -0.12110076f, 0.11329187f, 0.02910249f, 
    -0.04186590f, 0.09198581f, -0.10284067f, 0.71119708f, 0.85859579f, -0.03754173f, -0.85422313f, -0.24132410f, 
    0.30765069f, 0.01719509f, 0.21171041f, -0.00725996f, -0.63378757f, -0.27002087f, -0.05194271f, -0.08934751f, 
    0.16404825f, -0.36405051f, -0.04751232f, -0.12959819f, -0.28211400f, 0.03044605f, -0.09326211f, 0.39624852f, 
    0.20429593f, -0.06180235f, 0.22602083f, -0.10871626f, 0.19805442f, -0.37865224f, -0.49160218f, -0.32263869f, 
    0.11968616f, 0.01990327f, 0.20611957f, -0.21322955f, 0.49070132f, 0.11341979f, -0.19071367f, 0.10194295f, 
    -0.03588684f, -0.46382964f, 0.19326852f, -0.47381285f, 0.18944810f, 0.01104695f, 0.03724033f, -0.09203965f, 
    0.39832839f, 0.47362494f, -0.10835341f, -0.20287670f, 0.50945687f, -1.15851057f, -0.48097658f, -0.34271431f, 
    -0.47463679f, -0.01444669f, 1.24152327f, -0.50900805f, -0.10696880f, 0.59007663f, 0.68351495f, 0.43626973f, 
    -0.12483692f, -0.25725889f, -0.00300063f, -0.14931922f, -0.33535144f, 0.01136235f, 0.12287090f, 0.36789486f, 
    -0.41750529f, -0.10370482f, 0.33312523f, 0.07084313f, 0.01319241f, -0.17400552f, -0.98800129f, -0.87812740f, 
    -0.75409836f, -0.28358582f, -0.58131790f, 0.15264891f, 0.19730780f, 0.33561903f, 0.25701952f, 0.80008912f, 
    0.01768820f, 0.21209180f, 0.18737909f, -0.10454769f, 0.23410593f, -0.11546978f, 0.17686273f, -0.16774750f, 
    -0.18670614f, 0.16887812f, -0.20372757f, -0.34323725f, 0.16372101f, -0.27115014f, -0.12904802f, -0.16020788f, 
    0.21581572f, 0.20466545f, -0.43534747f, -0.29245305f, 0.35143337f, -0.26833183f, 0.15316683f, -0.08360122f, 
    -0.38762820f, 0.42387879f, -0.49107262f, 0.13129975f, -0.36891952f, 0.04954998f, -0.24045952f, -0.04755586f, 
    0.19494531f, 0.33787841f, -0.00067485f, -0.48472595f, -0.05682767f, -0.00409740f, 0.00096656f, 0.66450095f, 
    -0.85505927f, -0.21682587f, -0.63960040f, -0.80167216f, -0.43614888f, 0.51394731f, 0.35320017f, 0.39271581f, 
    0.17990279f, 0.44926673f, 0.30189687f, 0.44102415f, -0.20227709f, -0.01350105f, -0.37711138f, -0.13480525f, 
    -0.26362842f, -0.08242209f, -0.22675174f, -0.30512103f, 0.19735700f, 0.10975724f, 0.31046459f, 0.15686597f, 
    0.22117934f, 0.00824382f, 0.95505548f, 0.61152536f, -1.10487175f, -1.12381136f, -0.38588542f, 0.23159331f, 
    0.07461641f, 0.34708804f, 0.28119054f, -0.04895503f, -0.19608973f, 0.62142569f, -0.24850914f, 0.09838087f, 
    -0.03473242f, -0.09533980f, -0.26705694f, 0.14430675f, 0.15568957f, -0.08068764f, 0.23928773f, 0.04504346f, 
    -0.22701764f, 0.44674012f, 0.98719996f, -0.22866158f, -0.21324903f, 0.00725356f, -0.66387701f, -0.10604697f, 
    0.25412294f, 0.52843708f, -0.40341869f, -0.81655288f, -0.19577600f, 0.49472359f, 0.14727645f, 0.03754212f, 
    -0.20008586f, -0.27419406f, -0.45282105f, 0.09135318f, 0.10773455f, 0.21461572f, 0.23391469f, -0.19180290f, 
    -0.39402172f, -0.41908619f, 0.17522846f, 0.34199813f, 0.09911985f, -0.86876559f, -0.43153262f, -0.98449779f, 
    -0.43835059f, -0.57908827f, 0.09706006f, 0.23022398f, 0.77066439f, 0.02963588f, 0.01440009f, 0.15919867f, 
    -0.01253192f, -0.44325957f, 0.16452892f, 0.18023850f, 0.28672129f, 0.39435098f, -0.10824448f, -0.09956121f, 
    -0.02737166f, -0.21557614f, -0.34513110f, 0.03645453f, -0.27444458f, -0.09067814f, -0.15489611f, 0.08803552f, 
    0.02231131f, 0.44070107f, 0.49279019f, 0.14252841f, 0.18411303f, 0.15156664f, 0.01644395f, -0.19260697f, 
    0.21276240f, -0.02024511f, -0.18441777f, 0.00638466f, -0.39632496f, 0.07447028f, -0.10930055f, -0.09872747f, 
    -0.09550598f, 0.24890567f, -0.09525628f, 0.15782724f, 0.31410968f, 0.70127255f, 0.55899173f, 0.54973429f, 
    0.46774825f, -0.13651064f, 0.04465177f, 0.12302789f, 0.21677908f, -0.15025809f, -0.17975800f, 0.06536545f, 
    0.20049131f, 0.07283782f, -0.15718763f, 0.16955602f, 0.00101387f, 0.26962346f, -0.17897557f, -0.01923978f, 
    -0.09816759f, -0.05904039f, 0.12571575f, -0.14337222f, -0.02690023f, -0.11631763f, 0.06612091f, 0.01827735f, 
    -0.47724125f, -0.38112250f, -0.76883519f, -0.48775205f, -0.19450197f, -0.60205883f, -0.96890461f, -0.89078206f, 
    0.19175060f, 0.00304076f, 0.09054541f, 0.22710486f, 0.05560026f, 0.11109501f, 0.42376885f, 0.31639650f, 
    -0.02025095f, -0.06865396f, 0.09237668f, -0.23503743f, -0.27373439f, 0.28719309f, -0.00791503f, -0.80681336f, 
    -0.76820648f, -0.99529803f, -0.60185128f, -0.36338204f, -0.62431175f, -0.51194465f, -0.05954690f, -0.48880178f, 
    -0.91255230f, 0.32731178f, -0.28412390f, -0.00715452f, 0.07717986f, 0.13828935f, -0.34788850f, -0.21707296f, 
    -0.25002301f, -0.07990732f, -0.11084465f, -0.33194676f, -0.35333174f, 0.50760359f, 0.10793975f, -0.23183119f, 
    -0.24913417f, -0.83812416f, -0.00186719f, 0.43760836f, 0.75889176f, -0.33042711f, -0.46417284f, -0.04194933f, 
    0.62205207f, 0.56476378f, 0.13172214f, -0.12815259f, -0.06001440f, -0.25337923f, 0.20782992f, -0.03807575f, 
    -0.15937665f, 0.06758753f, 0.09403830f, -0.31631398f, -0.13898182f, -0.25514722f, -0.33207217f, 0.31065172f, 
    0.30258051f, -1.37390995f, -0.42054620f, 0.79498309f, 0.76219743f, -0.28866312f, 0.19869158f, -0.05804828f, 
    0.25628352f, 0.00579154f, 0.00616818f, 0.23470095f, -0.35729584f, -0.29353774f, 0.72592187f, 0.00289609f, 
    -0.35075608f, 0.12432754f, 0.04184400f, -0.35295695f, 0.28896850f, 0.11817152f, -0.15241973f, 0.18993238f, 
    0.18411560f, -0.17927608f, -0.75559890f, 0.56724769f, 0.36912686f, -0.94123793f, -0.54709691f, -0.11487444f, 
    0.29954070f, 0.19639057f, 0.52210045f, 0.32181075f, 0.22972566f, -0.34010842f, -0.27518439f, -0.27497491f, 
    -0.40378651f, -0.02044122f, 0.07333883f, -0.10628776f, -0.03816351f, 0.02522847f, -0.14382203f, -0.18457408f, 
    -0.31849775f, -0.41064730f, -0.53144413f, 0.31631970f, -0.70423031f, -0.94931114f, 0.14285095f, 0.65319693f, 
    0.61965960f, 0.34641802f, -0.72596329f, -0.79538924f, -0.75115418f, 0.33875826f, -0.34438539f, -0.29649058f, 
    -0.32837841f, -0.27245367f, 0.12950423f, -0.18521698f, 0.03524124f, -0.48294947f, -0.24736613f, 0.00604856f, 
    0.30558047f, -0.11614159f, 0.09421489f, -0.16234271f, 0.12081061f, 0.88797355f, -0.23130579f, 0.07593416f, 
    -0.00411063f, -0.77142924f, -0.67836988f, -0.12407915f, -0.01434163f, -0.52138275f, -0.36923507f, -0.69765776f, 
    0.89843887f, -0.72023672f, 0.08079411f, -0.33757278f, 0.61303020f, -0.36221653f, -0.20308886f, -0.13635932f, 
    -0.19686267f, 0.06172361f, -0.32932019f, 0.18898463f, 0.00282201f, -0.03985107f, 0.27930030f, 0.10132495f, 
    -0.08086793f, 0.11023539f, -0.35919321f, -0.40956381f, 0.02842573f, -0.78228301f, -0.65735561f, 0.29290634f, 
    0.24019967f, 0.33920136f, -0.07681688f, 0.21782796f, 0.05941400f, 0.21295767f, -0.32668102f, 0.07242003f, 
    0.14943613f, -0.09463768f, -0.17575127f, 0.07328443f, -0.16293746f, 0.16721427f, 0.60995847f, -0.44522530f, 
    0.24143408f, 0.55610859f, -0.13602722f, -0.74874115f, -0.72363794f, -0.06783441f, 0.37392929f, 0.08723968f, 
    0.35718063f, -0.49942869f, -0.25897956f, 0.04069687f, -0.35748377f, 0.11002644f, 0.08314300f, 0.13573579f, 
    -0.23847966f, 0.08780581f, 0.03224301f, 0.04509034f, -0.08146995f, 0.20271561f, -0.09813538f, 0.26987070f, 
    0.38533875f, -0.28212491f, 0.00621698f, 0.06731369f, 0.46673524f, -0.14547943f, -0.01558517f, -0.10012572f, 
    -0.36018658f, 0.10474365f, 0.02061490f, 0.25093004f, 0.09537943f, -0.11200160f, -0.34440112f, 0.09699247f, 
    -0.02840604f, -0.01872159f, 0.10616614f, -0.09569352f, 0.08254297f, 0.20395230f, 0.21885282f, -0.12008873f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26623437f, 0.37758783f, 0.12960836f, 0.44640645f, 0.30083948f, 0.32518110f, -0.26176140f, 0.45209804f, 
    -0.05163368f, 0.11027860f, -0.09558674f, 0.43133587f, -0.05559398f, 0.49877179f, 0.03157220f, 0.25743324f, 
    0.31047100f, 0.47648430f, 0.16334209f, 0.10663029f, 0.36919275f, -0.08193729f, -0.28337851f, -0.24925214f, 
    0.69683194f, 0.30889794f, 0.03202884f, 0.58682740f, 0.05186220f, 0.06888589f, 0.10320406f, 0.10380930f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12295176f, 0.17124972f, 0.00193212f, -0.01336678f, -0.07641301f, -0.01603208f, -0.19247209f, -0.08408682f, 
    -0.16495943f, 0.02345239f, -0.03790581f, 0.14526233f, 0.58535463f, 0.17619185f, -0.25571209f, -0.08502799f, 
    0.03055943f, -0.09553072f, 0.18364784f, -0.04741212f, -0.02898004f, -0.03565250f, 0.05848295f, 0.02793992f, 
    -0.14182651f, -0.12485951f, -0.05413799f, -0.14473172f, 0.02698681f, -0.01459492f, -0.30214819f, -0.32572147f, 
    -0.08366134f, 0.11225370f, 0.01975825f, 0.07246296f, 0.02066165f, -0.00615161f, -0.06382684f, 0.05106740f, 
    -0.04191903f, -0.09030905f, -0.21490330f, -0.05464884f, -0.16163227f, -0.04839415f, -0.11268529f, -0.05482144f, 
    -0.88325596f, 0.00607556f, -0.30364206f, 0.12134367f, 0.01756188f, -0.07003874f, -0.03616808f, 0.04196334f, 
    -0.00453483f, 0.00132267f, 0.04323092f, 0.03797466f, 0.92196983f, 0.18309781f, -0.24047801f, -0.47317556f, 
    -0.18154155f, -0.14348307f, 0.12958716f, -0.10783105f, -0.20059992f, -0.20449975f, 0.10897678f, -0.01857852f, 
    0.47644103f, 0.32513633f, 0.01071558f, -0.22415833f, 0.16237579f, 0.15556602f, 0.28570777f, 0.09539524f, 
    -0.09246578f, -0.11843839f, -0.04655824f, -0.09204885f, -0.49833199f, -0.02983341f, 0.00032481f, -0.11025873f, 
    -0.08995564f, -0.07407520f, 0.04550653f, -0.01626635f, 0.00815178f, -0.01481564f, 0.01678405f, -0.07191315f, 
    -0.13895464f, -0.15799041f, -0.05251702f, 0.08957220f, 0.00886812f, 0.01932388f, 0.09018724f, -0.00418697f, 
    -0.08066253f, 0.10698167f, -0.25333062f, -0.25403258f, -0.17769317f, 0.38261223f, 0.13889380f, 0.00842938f, 
    0.02158639f, -0.01585651f, 0.06581587f, -0.20299220f, -0.09049258f, -0.10535020f, -0.20420738f, -0.22701733f, 
    0.12351619f, 0.21576999f, 0.03328164f, 0.04377905f, 0.11425284f, 0.16018450f, 0.00120685f, -0.25962859f, 
    -0.09468663f, -0.03260882f, -0.05319473f, 0.04376753f, -0.28757021f, -0.59865946f, -0.84786147f, 0.30550703f, 
    0.05470535f, 0.05996530f, -0.15027353f, 0.00084593f, 0.00086054f, -0.06362938f, -0.06419512f, -0.02616917f, 
    0.05346101f, 0.10731374f, -0.02770046f, 0.05432717f, -0.04460710f, -0.00735290f, -0.05071658f, -0.03798694f, 
    0.02483695f, -0.04355298f, -0.02349225f, -0.17607725f, 0.29194888f, 0.22644141f, 0.07160825f, -0.20122203f, 
    -0.09981770f, 0.21480338f, 0.03783631f, -0.08766358f, 0.16951428f, -0.02649965f, -0.03300187f, -0.11225924f, 
    0.24049094f, 0.11205688f, 0.01993694f, 0.02047617f, 0.17957859f, 0.12668820f, 0.09785954f, -0.12369936f, 
    -0.01638503f, 0.04416629f, 0.02415198f, 0.05569639f, 0.04226658f, -0.07410599f, -0.01852932f, -0.06829011f, 
    -0.12440725f, -0.02654305f, -0.14463651f, -0.08727594f, 0.01127395f, -0.02940136f, -0.06211092f, -0.04984850f, 
    0.11276054f, -0.14193954f, -0.10326578f, 0.00773893f, 0.13516647f, 0.21910433f, -0.10532045f, -0.16031899f, 
    -0.04877456f, -0.08932102f, -0.02335478f, -0.00519219f, -0.03809097f, -0.48001444f, 0.19630249f, -0.04264804f, 
    -0.04390424f, -0.23670885f, -0.25521255f, -0.26420066f, -0.12787826f, -0.40203568f, -0.01516575f, -0.13126139f, 
    -0.01567245f, -0.21667196f, -0.11496141f, -0.24675892f, 0.11580905f, -0.22355817f, -0.06015348f, 0.03486833f, 
    0.03640959f, 0.07628731f, 0.05631904f, -0.29928741f, 0.28707662f, 0.10869281f, 0.03757113f, 0.03664291f, 
    0.25527900f, 0.10680716f, 0.18361758f, 0.01088500f, 0.00358920f, -0.02167365f, 0.13808441f, 0.16052492f, 
    0.03652238f, -0.05883043f, -0.02155384f, -0.05706557f, -0.03773385f, 0.01939155f, 0.00432096f, 0.03082254f, 
    -0.09444288f, -0.29782629f, -0.30020741f, -0.32225180f, -0.13549988f, -0.09609313f, -0.06303331f, 0.04049242f, 
    0.08785783f, 0.05304275f, 0.04834102f, -0.03281382f, 0.01589989f, 0.06169746f, 0.04400320f, 0.06258062f, 
    0.54084772f, 0.14351264f, -0.31338975f, -0.13704500f, 0.11228640f, -0.07587207f, -0.19162521f, 0.24100335f, 
    0.04282456f, 0.07557110f, 0.03561584f, 0.07271302f, 0.50836647f, 0.26169571f, -0.06119417f, -0.35981390f, 
    0.09376722f, 0.19771136f, 0.10099767f, 0.06319832f, -0.06525740f, -0.03518589f, -0.00304221f, -0.00605035f, 
    -0.30776161f, 0.26436260f, 0.05103940f, -0.17875096f, -0.12114913f, 0.07055771f, 0.07498205f, -0.01236887f, 
    -0.01180696f, -0.25827742f, -0.04584964f, -0.14942493f, 0.01010484f, -0.47705743f, 0.31949976f, -0.39004001f, 
    0.07541627f, 0.00533800f, 0.02363614f, 0.02542624f, -0.19156894f, -0.05194197f, -0.37524742f, -0.05528026f, 
    -0.64267111f, -0.27370554f, 0.05622900f, -0.01763860f, 0.08151467f, 0.11255500f, -0.12302534f, 0.08111467f, 
    0.17532915f, 0.25151038f, 0.07090877f, -0.02958636f, 0.37841430f, -0.16692913f, -0.50858533f, 0.01216024f, 
    -0.07265711f, -0.05376960f, 0.06713936f, -0.01048248f, -0.14239945f, -0.06378726f, -0.18394463f, 0.04960112f, 
    -0.02017823f, 0.17432374f, 0.14494762f, -0.02155150f, -0.05969061f, -0.20719762f, -0.12149134f, 0.03358015f, 
    -0.02177523f, -0.05343836f, -0.06235899f, -0.00462421f, 0.28213832f, 0.11642060f, -0.28957456f, 0.03920406f, 
    -0.00635370f, -0.16486703f, 0.02120562f, 0.16882956f, 0.12909804f, 0.07113931f, 0.03895644f, -0.04677495f, 
    -0.19399446f, 0.26559967f, 0.32426649f, -0.69098324f, -0.20696723f, -0.01137106f, -0.20421748f, -0.03468221f, 
    0.00583280f, -0.03370472f, -0.05185596f, 0.01713531f, -0.04310661f, 0.00791836f, 0.04636814f, 0.04189866f, 
    -0.10510617f, -0.06701680f, -0.01349066f, 0.03373256f, -0.12927674f, -0.03117230f, -0.04394022f, -0.08398068f, 
    -0.18478028f, -0.07595564f, -0.09705554f, 0.05433558f, 0.05002746f, 0.18322749f, 0.01644612f, 0.22832647f, 
    -0.28696245f, -0.15095179f, -0.40367329f, -0.16693757f, -0.12276500f, -0.04608911f, -0.23698160f, -0.17913784f, 
    0.05635143f, 0.01044912f, 0.02759465f, 0.22152868f, 0.23842746f, -0.02648088f, 0.06971616f, 0.00182337f, 
    0.13244604f, 0.00401871f, 0.08254433f, -0.12030549f, -0.14956322f, -0.14197601f, 0.05646379f, -0.12092264f, 
    0.06484552f, -0.11615116f, 0.03382690f, 0.05716201f, 0.12904494f, -0.19958799f, 0.07225280f, -0.11245105f, 
    0.13455170f, 0.15916324f, 0.03840837f, -0.00247156f, -0.03878156f, 0.26958448f, -0.08196465f, -0.06018838f, 
    0.35417375f, 0.39081115f, 0.18762016f, 0.10367672f, 0.01276915f, -0.03524991f, -0.03220920f, 0.02023893f, 
    -0.05967667f, 0.05264083f, 0.01977927f, 0.11366631f, 0.50403541f, -0.47934908f, 0.40543148f, 0.39619145f, 
    -0.10631458f, 0.00574871f, 0.14313830f, -0.01814831f, 0.26129246f, 0.10407438f, 0.01452023f, 0.01165463f, 
    -0.16078290f, 0.24399048f, 0.21115884f, 0.40531707f, -0.16169271f, 0.12286761f, 0.10935900f, -0.25512010f, 
    0.03444107f, 0.02564740f, 0.03336108f, 0.04713995f, 0.25248981f, 0.04144881f, 0.04658087f, 0.30491132f, 
    -0.07680457f, -0.00926079f, 0.01081229f, 0.03646740f, 0.05329943f, 0.01968827f, 0.08933093f, -0.06875044f, 
    0.18548530f, 0.13204223f, 0.11283282f, 0.24018449f, -0.09186776f, -0.03822967f, -0.02988972f, 0.03125496f, 
    0.03970268f, 0.02708225f, 0.17360789f, -0.05397856f, -0.16508235f, -0.00622583f, 0.01141077f, -0.08108695f, 
    0.05253865f, 0.08159850f, 0.16450745f, 0.18263963f, 0.00728512f, 0.09143542f, 0.12691022f, 0.00234040f, 
    -0.14387025f, -0.12343543f, -0.11270905f, 0.00790742f, -0.00829311f, 0.11867632f, 0.08087739f, -0.07365101f, 
    -0.08848927f, -0.01959456f, -0.06312460f, -0.07937620f, 0.64973187f, -0.18580796f, 0.22791867f, 0.37642097f, 
    -0.12036724f, -0.14537175f, 0.09175817f, 0.06632315f, -0.09872343f, -0.11208042f, 0.10717694f, -0.03761095f, 
    0.08154886f, 0.15489252f, -0.16647904f, 0.20170251f, 0.05435956f, 0.21397552f, -0.12622762f, 0.06644170f, 
    -0.12778623f, -0.00155854f, -0.11749130f, -0.19826595f, 0.10953224f, 0.54046285f, -0.39624766f, -0.28096321f, 
    0.00116965f, 0.08652735f, -0.11478148f, 0.19748953f, -0.27377367f, 0.04413947f, -0.02002941f, -0.08201182f, 
    -0.07339365f, 0.13120130f, -0.13097946f, -0.04727531f, -0.00382235f, 0.06285477f, 0.04078162f, -0.21293935f, 
    0.19721203f, 0.05237355f, 0.04860330f, -0.12107417f, -0.04372126f, 0.02287111f, -0.01154115f, -0.29178387f, 
    -0.15288396f, 0.25035799f, 0.11884140f, -0.07122104f, 0.01873934f, 0.18031813f, -0.07074645f, -0.06226126f, 
    -0.01186843f, -0.02867908f, -0.31590551f, -0.37969738f, -0.10574369f, 0.01477705f, 0.03451666f, 0.21444348f, 
    -0.14434312f, 0.00510026f, -0.00553190f, 0.00384184f, 0.17096391f, -0.10662854f, 0.29495832f, -0.34526071f, 
    0.04679150f, 0.16200656f, -0.10165804f, 0.00117589f, -0.11579479f, 0.27064377f, -0.16254708f, -0.08139627f, 
    0.68893945f, 0.01404764f, -0.23974338f, -0.35619408f, -0.04159754f, 0.10300511f, -0.26765946f, -0.14522898f, 
    -0.12578101f, -0.07308114f, -0.04430206f, 0.32091936f, -0.09668332f, 0.02166596f, 0.30233732f, -0.16474162f, 
    -0.07389919f, 0.18070224f, -0.58092272f, -0.49493495f, 0.00647888f, -0.24259993f, -0.05865217f, 0.05114015f, 
    0.03665376f, 0.04401080f, 0.13608237f, 0.06036455f, -0.03405225f, -0.02135690f, 0.07223327f, 0.03659222f, 
    -0.00395335f, 0.11969434f, 0.15170646f, -0.02659872f, 0.23250994f, 0.09098674f, 0.13795385f, 0.15875462f, 
    -0.08901834f, 0.00068620f, -0.12029999f, -0.10704655f, 0.08928691f, 0.01926253f, -0.07604272f, -0.00121819f, 
    0.04017435f, 0.13833073f, 0.35761330f, -0.19966410f, -0.05360360f, -0.24897270f, 0.05200321f, -0.12078717f, 
    -0.01818768f, -0.09067411f, -0.06325504f, 0.02751230f, -0.06689564f, 0.06592394f, 0.28037733f, 0.15572986f, 
    0.17486550f, 0.14973490f, 0.22748818f, -0.43297780f, 0.10153679f, 0.03248090f, 0.06550493f, -0.04807782f, 
    -0.16749293f, 0.45428529f, -0.04753635f, 0.08921625f, -0.04080455f, 0.07627321f, 0.05531922f, -0.12279818f, 
    0.09597150f, 0.01831654f, 0.02275558f, 0.17779113f, -0.28321639f, 0.04761584f, 0.01538109f, -0.22470418f, 
    -0.18436718f, -0.08031447f, 0.13780700f, 0.07619869f, 0.01442890f, -0.22908893f, 0.16325042f, -0.05263984f, 
    0.01095124f, -0.07593153f, 0.14011298f, -0.17186847f, -0.03273676f, -0.00918936f, -0.20617808f, -0.04656102f, 
    -0.26701167f, -0.29154596f, -0.29018459f, -0.18632929f, 0.05974527f, -0.39302689f, 0.11773608f, -0.14162555f, 
    -0.05136445f, 0.06237238f, 0.33865380f, 0.08121946f, 0.07842723f, 0.09800617f, -0.17821929f, 0.10714556f, 
    -0.02900510f, -0.10864916f, -0.71119708f, -0.03831075f, 0.09998265f, 0.03015507f, -0.20833646f, -0.52829993f, 
    -0.06149762f, 0.06749919f, -0.11882487f, 0.14088818f, -0.06240655f, -0.03128404f, -0.25627080f, -0.13070816f, 
    -0.33187577f, -0.03582074f, 0.28600913f, -0.19938602f, -0.14617150f, 0.05658162f, 0.03397496f, 0.20255348f, 
    -0.56706238f, 0.41834235f, -0.23000094f, -0.22006838f, 0.08550014f, -0.06547947f, -0.17216511f, -0.17615151f, 
    0.01239617f, -0.04388208f, -0.06051197f, 0.00954091f, 0.09346554f, -0.01208869f, -0.03862258f, 0.03327344f, 
    0.13165252f, -0.12479062f, 0.04902718f, -0.03184890f, -0.06155923f, 0.05636192f, 0.01015436f, 0.04674524f, 
    0.32151020f, 0.24823436f, -0.00898085f, 0.25084859f, -0.08621031f, 0.00068150f, -0.00978433f, -0.04921411f, 
    -0.20960473f, 0.01242329f, -0.02466469f, 0.14412972f, -0.29963616f, 0.33387417f, -0.52341264f, -0.37226146f, 
    0.03731288f, -0.25742882f, 0.03134057f, 0.18752834f, -0.01139876f, -0.01761164f, -0.01734328f, -0.16461043f, 
    -0.28170559f, -0.09131627f, 0.02334056f, -0.31855607f, -0.01068590f, 0.13513182f, 0.04553416f, -0.24218178f, 
    0.07125414f, -0.04901314f, -0.03816327f, 0.13200153f, -0.20416167f, -0.00506724f, 0.21220261f, -0.08283841f, 
    -0.00695557f, -0.04780649f, -0.11398381f, -0.53659117f, 0.18065715f, 0.08638820f, -0.23270741f, 0.26111624f, 
    -0.20199078f, -0.19107082f, 0.29774186f, -0.40940747f, 0.05603019f, -0.03487940f, -0.01474298f, 0.05068776f, 
    0.08456429f, -0.03924353f, -0.05148173f, -0.01694446f, 0.00132795f, -0.18523134f, -0.14363533f, 0.00860525f, 
    0.13262659f, 0.02240075f, -0.06924140f, 0.24695469f, 0.16151929f, 0.11049771f, -0.20541991f, -0.00238981f, 
    -0.68402708f, -0.46022636f, -0.34898245f, 0.04005275f, 0.18153097f, -0.06799246f, -0.01768757f, -0.11046789f, 
    -0.03433635f, -0.06139791f, -0.03424100f, -0.04207785f, 0.23587507f, 0.14574873f, -0.22265737f, 0.08941342f, 
    0.00983386f, -0.02655165f, 0.03226166f, 0.12723798f, 0.02769767f, 0.02698188f, -0.01786169f, -0.14922059f, 
    -0.04673030f, 0.17057270f, -0.18505858f, 0.01469310f, -0.08180241f, -0.03815146f, 0.08362433f, 0.04389745f, 
    -0.12422208f, 0.02553964f, -0.09409956f, 0.12088172f, 0.06891181f, -0.52506459f, -0.39909542f, 0.13961442f, 
    0.06428729f, 0.12643388f, -0.24344678f, -0.07581609f, -0.00586526f, 0.06600922f, -0.27217978f, -0.16595803f, 
    0.07739062f, 0.11806789f, 0.19708405f, 0.13760841f, -0.12606785f, 0.02035099f, -0.05865652f, 0.03006208f, 
    -0.02684350f, -0.06506878f, 0.02141161f, 0.07898097f, -0.04608100f, -0.18721333f, 0.41567209f, -0.36694264f, 
    0.06847634f, 0.01331634f, -0.01837605f, 0.04980127f, 0.02397839f, -0.00803606f, -0.04771556f, 0.01730436f, 
    -0.10449520f, -0.01210577f, 0.03280012f, 0.07276940f, -0.20112784f, 0.03334277f, -0.28992793f, 0.08256064f, 
    -0.02510427f, -0.05796286f, -0.07450134f, -0.05858559f, -0.34474516f, 0.25172007f, 0.23757550f, 0.30067188f, 
    0.10597498f, -0.11425248f, -0.06256069f, 0.18361410f, -0.04717446f, -0.02185774f, 0.06215197f, 0.12634072f, 
    0.19740751f, 0.15417767f, 0.33677262f, 0.32914364f, -0.06167174f, -0.01379002f, 0.12813798f, -0.06327750f, 
    -0.09721781f, 0.04508579f, -0.08751803f, -0.04798089f, -0.07808089f, 0.18069814f, -0.05064192f, -0.22502327f, 
    0.18647520f, 0.06973954f, -0.01282923f, -0.04133486f, -0.12791838f, 0.01999892f, 0.03798099f, -0.00131504f, 
    -0.02993404f, 0.44272572f, 0.39423987f, 0.18066235f, -0.02119534f, 0.11419865f, 0.08408175f, -0.04535144f, 
    0.08060108f, -0.20260917f, -0.16447213f, 0.12146326f, 0.36323687f, 0.14825007f, 0.00048960f, 0.10357473f, 
    0.00937892f, -0.02236662f, -0.19488668f, 0.22106709f, -0.11902409f, 0.06252073f, -0.10009460f, 0.06568860f, 
    -0.27440336f, 0.14915013f, -0.13896550f, -0.17187643f, -0.07308821f, -0.07225625f, -0.24543394f, -0.02093238f, 
    0.15155472f, -0.14481118f, -0.00236701f, -0.18359786f, -0.14851223f, 0.39270437f, -0.08068044f, 0.22032689f, 
    -0.10186284f, 0.25251135f, 0.07239920f, -0.06216156f, 0.04915797f, 0.02466030f, 0.20314115f, 0.02522575f, 
    -0.03789008f, -0.07752864f, -0.03277054f, 0.02304502f, 0.00937703f, -0.02143506f, -0.06777421f, 0.05528002f, 
    -0.07672052f, -0.17049284f, 0.04908299f, -0.17238717f, -0.28874406f, -0.08161367f, 0.03374014f, -0.19009167f, 
    -0.10176753f, -0.08848145f, -0.03758133f, 0.00807674f, -0.02967546f, -0.04817306f, -0.01120056f, 0.00345436f, 
    -0.53989637f, -0.99627441f, -0.09680229f, -0.68411046f, -0.16411674f, -0.22379789f, 0.02566684f, -0.47902393f, 
    0.09787740f, -0.06145588f, 0.02930957f, -0.00826606f, -0.95840400f, 0.18967415f, 0.45061058f, 0.10652827f, 
    -0.23840454f, -0.24454591f, 0.06113807f, -0.10766378f, -0.04279343f, 0.00345292f, 0.02995780f, -0.05047983f, 
    0.04500961f, -0.07161995f, -0.15400882f, 0.19230984f, -0.01952242f, 0.01640942f, 0.01659090f, 0.15349035f, 
    -0.06478168f, 0.10326070f, 0.04339289f, 0.04475432f, 0.45025861f, 0.03699665f, -0.09953143f, 0.07559246f, 
    0.00257376f, -0.00557387f, 0.01623251f, 0.05713243f, -0.01989564f, -0.14545333f, 0.14069736f, -0.03326868f, 
    0.30390275f, 0.42599651f, -0.11072737f, 0.10711157f, 0.00851086f, -0.11481684f, 0.11675002f, -0.10044054f, 
    0.12558995f, 0.14284579f, 0.08420556f, 0.29939839f, 0.00859486f, 0.12753625f, 0.31852859f, 0.07029186f, 
    0.10962442f, -0.31565654f, 0.07040867f, 0.06557595f, 0.06633986f, 0.00878076f, -0.05332059f, 0.09090241f, 
    -0.25373179f, -0.32075956f, 0.00673167f, -0.18927141f, -0.03877454f, 0.00924338f, 0.05754634f, -0.40200946f, 
    0.03275806f, -0.01708098f, -0.01644861f, 0.00321166f, -0.15546608f, -0.09980933f, 0.05849171f, -0.07320167f, 
    0.21874195f, 0.17917384f, 0.05338744f, -0.44259879f, 0.00826940f, 0.01676216f, -0.04407286f, -0.08262303f, 
    -1.16150200f, 0.33264813f, 0.01395759f, 0.27447882f, -0.04676503f, 0.08294863f, 0.04110815f, -0.04302104f, 
    0.07335451f, -0.04521074f, -0.03153208f, 0.04296292f, -0.10992554f, -0.01834210f, -0.02617428f, -0.09455568f, 
    -0.11005401f, -0.15615322f, 0.07180437f, 0.01015021f, -0.03705158f, 0.08050574f, -0.05497858f, 0.00118413f, 
    0.21895517f, 0.01284873f, 0.02595103f, 0.17091690f, -0.02784663f, -0.02918947f, -0.14954197f, -0.02450257f, 
    -0.11196071f, -0.00730442f, -0.00331436f, 0.10933353f, -0.32485265f, 0.49957582f, -0.17804416f, 0.57542479f, 
    0.09422965f, 0.02472576f, -0.05237039f, -0.06375866f, -0.18807611f, -0.00706999f, -0.01756537f, 0.35339391f, 
    -0.05606162f, 0.10860839f, 0.36888501f, 0.53656268f, -0.24072963f, -0.27172351f, 0.12324115f, 0.01152568f, 
    0.14287929f, 0.04348945f, 0.10944050f, 0.09076662f, -0.40889633f, -0.25119081f, -0.01996686f, 0.14193624f, 
    -0.17109644f, -0.18247193f, -0.07288516f, -0.02942960f, -0.01895223f, -0.07891704f, -0.33362281f, -0.03337776f, 
    0.14968471f, -0.10411035f, 0.18376075f, -0.50789189f, -0.23283924f, -0.18198802f, 0.04013941f, 0.08327680f, 
    -0.02458003f, -0.02316437f, -0.13956986f, 0.02698018f, -0.73545253f, 0.87896287f, -0.46892801f, -0.77140689f, 
    0.31982008f, 0.17384003f, -0.05707924f, -0.06248304f, -0.43927237f, 0.05705038f, -0.06940176f, -0.01497177f, 
    -0.06034730f, -0.16236697f, -0.11520655f, 0.03118499f, 0.00771613f, 0.02050085f, 0.01474206f, 0.09572196f, 
    -0.19057043f, -0.04158396f, -0.01106935f, -0.10721764f, -0.33658215f, 0.61765409f, -0.38945791f, 0.01598220f, 
    0.12042806f, -0.27391216f, -0.05629786f, -0.17883343f, -0.33398870f, 0.01635558f, -0.22313139f, 0.18301560f, 
    -0.06728283f, -0.29768705f, -0.40181303f, -0.10819804f, 0.02877741f, 0.13861693f, -0.02274812f, -0.18670166f, 
    -0.15748408f, -0.27188271f, 0.15164639f, 0.00071361f, 0.08356722f, 0.16244036f, -0.02591839f, 0.11724914f, 
    -0.01975486f, -0.03130602f, 0.08983737f, -0.02036248f, 0.26367620f, -0.07370179f, 0.11539450f, 0.00668321f, 
    0.34876901f, -0.24404466f, -0.07523749f, 0.16498755f, 0.15420917f, -0.07452057f, -0.07535824f, -0.25327268f, 
    -0.05131260f, -0.00022638f, 0.10393842f, 0.09248686f, -0.19513011f, 0.10148448f, 0.72035116f, 0.31364596f, 
    -0.16016231f, 0.14672291f, 0.02080384f, -0.06255318f, 0.02620891f, -0.02490034f, 0.08732388f, -0.08294391f, 
    0.12515996f, 0.35101536f, 0.06433610f, 0.07939900f, 0.07980876f, -0.10057247f, -0.11779939f, -0.06931490f, 
    0.07580279f, -0.06635170f, -0.09127773f, 0.02814390f, 0.40593579f, -0.36362466f, -0.04060275f, -0.14645551f, 
    0.21951814f, 0.06207906f, -0.06431459f, -0.04875161f, -0.10417224f, -0.12700221f, 0.05872900f, 0.08096413f, 
    -0.05725300f, -0.33015248f, -0.07920581f, 0.07390787f, 0.33529136f, 0.09781389f, 0.05937902f, -0.25286612f, 
    -0.07471552f, 0.17923824f, -0.06412534f, 0.15407927f, 0.19837946f, -0.32011366f, 0.23020807f, 0.10998365f, 
    -0.12860695f, -0.00468327f, -0.21939293f, -0.12254772f, -0.02489982f, -0.15947877f, -0.03173750f, -0.33820602f, 
    0.17171735f, -0.16678849f, -0.11803970f, 0.24751468f, 0.21328966f, -0.06197641f, -0.10294262f, -0.13968363f, 
    -0.01872333f, 0.18319502f, 0.03431821f, 0.02566349f, 0.36472833f, 0.20457070f, 0.00639244f, 0.42516577f, 
    -0.09419941f, 0.01798944f, -0.39122921f, -0.11358421f, 0.02853595f, -0.23012896f, 0.15974957f, -0.03545316f, 
    -0.23122394f, -0.07786563f, 0.21891718f, 0.24662577f, -0.02803819f, 0.10699328f, -0.02896098f, 0.06884091f, 
    0.10671309f, -0.07673419f, 0.12203088f, -0.10473411f, -0.15630923f, -0.14535391f, -0.07016931f, 0.34282026f, 
    -0.24737175f, -0.00023471f, -0.23261186f, -0.09333473f, -0.12406266f, -0.14812267f, 0.15080178f, 0.04446009f, 
    -0.03008723f, 0.13609743f, -0.16305023f, -0.33206022f, 0.44143492f, 0.20983975f, -0.10859808f, -0.11529990f, 
    -0.11743470f, 0.02866602f, 0.06006709f, -0.16895880f, -0.25006646f, -0.31256592f, -0.18301323f, -0.17117190f, 
    -0.10838203f, -0.17665285f, -0.18344904f, 0.02268580f, 0.10674713f, 0.23799480f, -0.00384181f, 0.10730725f, 
    -0.02487498f, -0.42972556f, 0.17209412f, 0.44078222f, -0.14566889f, 0.06229607f, 0.13271280f, 0.25073618f, 
    0.05482762f, 0.18288548f, -0.13937083f, -0.03605526f, 0.04018791f, -0.24754354f, -0.16849615f, 0.12716131f, 
    0.12480100f, 0.09278126f, 0.06843399f, 0.11387463f, 0.07409975f, -0.05372119f, 0.06233914f, -0.05051818f, 
    -0.16552822f, 0.00687290f, -0.20681798f, -0.62669748f, 0.15095513f, -0.32664657f, -0.07960790f, -0.21400794f, 
    -0.18509306f, 0.00522294f, -0.19514956f, -0.02092721f, 0.18108024f, 0.92518419f, -0.12582941f, -0.61075228f, 
    0.20918678f, -0.07791927f, -0.20309652f, -0.30158392f, -0.33001307f, 0.05819511f, -0.12179659f, -0.03837571f, 
    0.95077842f, -0.27359751f, 0.22539102f, 0.11472437f, 0.13288631f, 0.16391926f, 0.14087056f, 0.08593369f, 
    -0.09627531f, 0.03423578f, 0.10497268f, -0.00137826f, -0.13040058f, 0.36291859f, -0.27864030f, 0.45387363f, 
    0.06012400f, -0.13322602f, -0.10753381f, 0.02629373f, -0.05413379f, 0.10978065f, -0.04235525f, -0.06151232f, 
    0.04980609f, -0.10540461f, -0.13191915f, 0.05104431f, -0.18274757f, 0.04689798f, -0.01533405f, 0.13471982f, 
    -0.05937010f, 0.18222478f, -0.06413884f, -0.09383449f, -0.04188244f, -0.30872691f, 0.19789074f, 0.21048436f, 
    0.15604390f, 0.27499565f, 0.15260817f, -0.07379483f, 0.07037573f, 0.05466595f, 0.04105740f, 0.17563455f, 
    -0.26989079f, -0.11366758f, 0.17805918f, 0.07108417f, -0.11994301f, -0.02400467f, -0.03112321f, -0.24823283f, 
    -0.15405454f, 0.16337453f, 0.02539841f, 0.06710174f, -0.55566067f, -0.19034499f, 0.12698548f, -0.07987549f, 
    0.01182452f, -0.14202982f, -0.13014835f, -0.30172917f, -0.04625249f, -0.08905786f, -0.16938829f, -0.34003013f, 
    -0.00471282f, 0.01097595f, 0.06278600f, 0.17407967f, -0.06273873f, -0.09509380f, 0.05804310f, -0.21211410f, 
    0.21389195f, -0.00953096f, 0.21619327f, 0.17577271f, 0.08041398f, -0.38693628f, 0.51700258f, 0.08046355f, 
    0.14777556f, 0.02997436f, 0.07271073f, 0.08051756f, -0.20382600f, -0.05706718f, -0.09470023f, 0.08018193f, 
    0.13698025f, 0.34068552f, -0.04346553f, 0.17623548f, 0.14104640f, 0.03905526f, -0.16595188f, 0.15721545f, 
    -0.00595083f, 0.07555763f, -0.19569944f, 0.01654923f, 0.12052210f, 0.05764129f, -0.16506392f, 0.09011646f, 
    -0.00809213f, 0.09835116f, -0.08898223f, -0.35351685f, -0.03586655f, -0.24342938f, 0.01054038f, 0.00070820f, 
    0.27803588f, -0.22214031f, -0.12746605f, 0.12913272f, -0.02275419f, 0.03583301f, 0.07929832f, -0.10557692f, 
    0.02633494f, -0.02508560f, -0.00315000f, 0.00790129f, 0.08356368f, -0.68208587f, 0.02546213f, 0.19708852f, 
    -0.01985185f, 0.11018057f, -0.06400992f, -0.09897313f, -0.11845769f, 0.12778465f, -0.12061638f, 0.07138961f, 
    -0.03033251f, -0.01618480f, 0.14000347f, 0.08173335f, -0.28485963f, 0.01040544f, -0.01354613f, -0.01652258f, 
    -0.00445402f, 0.00365308f, -0.02592809f, 0.02923929f, -0.11271018f, -0.48847723f, -0.04304796f, 0.09972513f, 
    0.15542220f, 0.03311059f, -0.02137792f, -0.03103682f, -0.01445463f, -0.10435218f, -0.04271065f, 0.03765356f, 
    -0.01382819f, 0.01995899f, 0.06288810f, -0.04256596f, 0.08674376f, 0.00264184f, 0.05531809f, 0.03468181f, 
    0.15612143f, -0.05251990f, -0.06080113f, 0.04029668f, 0.01738085f, -0.00480044f, 0.13192558f, 0.07516437f, 
    0.07570726f, 0.07223474f, -0.05155531f, 0.02302856f, -0.01998492f, -0.15260392f, -0.15769368f, -0.12645292f, 
    -0.02247119f, 0.06645682f, 0.08289652f, 0.07152040f, -0.16598146f, -0.12886521f, 0.10391177f, -0.02481645f, 
    0.13311367f, 0.02897293f, -0.04763210f, 0.11886261f, 0.02449248f, 0.20399904f, -0.77843434f, -0.02873986f, 
    0.19780776f, 0.04677266f, -0.00431727f, -0.04440511f, 0.00964283f, 0.02584105f, -0.10940556f, -0.08553372f, 
    -0.00637407f, 0.00866170f, 0.07676120f, -0.05782794f, -0.06724577f, 0.12613088f, -0.12709863f, 0.13996059f, 
    0.02395982f, 0.00601428f, -0.06849609f, -0.00111774f, 0.07757258f, 0.15229444f, -0.09351041f, 0.11356783f, 
    -0.00848810f, 0.02079412f, -0.03705921f, -0.21318716f, 0.10434515f, -0.05733860f, -0.31214875f, -0.05080147f, 
    0.02575993f, 0.10033152f, 0.05017660f, 0.10107497f, -0.03625823f, -0.11192897f, 0.08480875f, 0.05637506f, 
    -0.09862311f, -0.18492965f, -0.06112707f, 0.04294507f, -0.09163082f, 0.08595448f, -0.07795084f, 0.15791196f, 
    -0.01244958f, -0.24162085f, -0.25411004f, 0.16504647f, -0.02485560f, -0.09860621f, -0.03239341f, -0.29577097f, 
    0.31622139f, 0.28220078f, 0.15771431f, 0.23848204f, -0.00247886f, -0.06151931f, -0.01928246f, -0.16346309f, 
    0.05283006f, -0.24247956f, 0.09634782f, 0.02406109f, -0.26655653f, 0.12152776f, -0.37505654f, 0.04183331f, 
    -0.12775190f, -0.05318229f, -0.16446128f, -0.18999866f, 0.04102831f, -0.15208353f, 0.07451884f, -0.19745892f, 
    -0.01790154f, -0.14623059f, 0.14098807f, -0.14630474f, 0.01711407f, -0.15835363f, 0.13287218f, -0.19761185f, 
    0.06607328f, 0.08187272f, -0.22214891f, -0.23033255f, -0.24946988f, -0.05237944f, 0.05444186f, 0.13396941f, 
    0.04386753f, 0.03319314f, 0.13631208f, 0.03863063f, 0.17523898f, 0.08145157f, 0.01857108f, -0.00802833f, 
    0.21390931f, 0.00797245f, 0.00921950f, 0.02570251f, 0.07432753f, 0.05298968f, 0.00264044f, 0.12683366f, 
    -0.12808886f, -0.16199726f, -0.11125024f, -0.29103625f, 0.00330670f, -0.03745355f, 0.02069744f, 0.03091612f, 
    0.10950220f, 0.04320227f, 0.03414323f, 0.02459674f, 0.13848683f, 0.10877514f, 0.08111326f, 0.02855950f, 
    0.09497797f, 0.40746602f, 0.15018199f, 0.31024772f, 0.01003628f, -0.03056551f, -0.01014305f, 0.10350202f, 
    0.07909205f, 0.00951463f, 0.02677843f, -0.06312221f, -0.01246178f, 0.10415281f, 0.18621045f, 0.18581073f, 
    -0.23430152f, -0.15840180f, -0.09460565f, 0.17528632f, 0.03541997f, 0.00799869f, 0.01870277f, 0.06578005f, 
    -0.11737380f, -0.19056731f, -0.21630076f, -0.06229528f, -0.07984604f, 0.04580755f, -0.07455745f, 0.08731702f, 
    -0.39336234f, -0.00332454f, -0.27169031f, -0.20715308f, 0.18156900f, -0.73006731f, -0.08920666f, -0.07138063f, 
    -0.11121239f, -0.20588113f, 0.12371413f, -0.22226632f, -0.12379937f, 0.13626575f, -0.19936353f, 0.03256581f, 
    0.13365029f, -0.34254584f, -0.13476424f, -0.08803525f, 0.02864635f, -0.19315183f, 0.13285397f, 0.11435613f, 
    0.14912054f, -0.00754739f, 0.22111480f, 0.34655908f, 0.04088927f, -0.18129842f, 0.17728068f, -0.21160573f, 
    0.24039118f, 0.07796624f, -0.35731128f, -0.06716798f, 0.02373264f, -0.12655321f, 0.09187169f, -0.09450681f, 
    0.07839070f, 0.26204270f, 0.31490961f, -0.03163013f, 0.00128131f, 0.02392884f, -0.04866335f, 0.19048503f, 
    0.04806093f, -0.12976928f, 0.07524113f, -0.17656872f, 0.05995601f, 0.25578466f, 0.19898419f, 0.10803755f, 
    -0.31217906f, -0.04982258f, -0.04715456f, 0.29803002f, 0.08020538f, -0.04756410f, 0.02359906f, -0.06877092f, 
    0.23519069f, -0.32614383f, 0.13280536f, 0.00434097f, -0.31054720f, -0.11814778f, 0.07622440f, 0.45974100f, 
    0.06308930f, -0.07402846f, 0.05696752f, -0.02713905f, 0.11501803f, 0.11498498f, -0.02021889f, 0.02837072f, 
    0.14477570f, 0.03425725f, -0.06423219f, -0.01842524f, 0.06831328f, -0.05966647f, -0.03621015f, -0.06231039f, 
    -0.16700974f, 0.15132883f, 0.14956537f, -0.12458593f, 0.00288959f, -0.07040733f, 0.06907685f, -0.05034216f, 
    0.17257829f, -0.31007937f, -0.01344309f, -0.46878335f, 0.10815944f, 0.13304830f, 0.31073725f, -0.41968471f, 
    -0.28209916f, -0.08527721f, -0.06743387f, -0.12868701f, -0.00092560f, 0.22621068f, -0.04723067f, -0.12618855f, 
    -0.06147894f, -0.10367885f, -0.25266346f, 0.11100867f, 0.34672165f, 0.07240615f, -0.13579723f, -0.00690698f, 
    0.02697166f, 0.04883984f, 0.10584784f, -0.00487231f, 0.05516515f, 0.34348661f, -0.26332968f, -0.34733072f, 
    0.09582339f, -0.07430176f, 0.16550715f, 0.30848759f, 0.12412289f, -0.14230408f, 0.26527408f, -0.06121881f, 
    -0.46999952f, -0.37132791f, -0.04892018f, 0.28006876f, 0.02545402f, -0.01450630f, 0.03018254f, 0.14713356f, 
    0.08040138f, -0.01343130f, -0.04017613f, -0.07187504f, -0.37212047f, 0.20339277f, 0.01902895f, 0.09746905f, 
    0.06072968f, -0.19433090f, -0.15070727f, 0.15130897f, 0.07786331f, -0.22742018f, -0.07285571f, -0.05926940f, 
    0.12507978f, 0.11742076f, 0.24085398f, -0.10115821f, 0.34526625f, 0.06456248f, -0.16335464f, 0.15381773f, 
    0.06114763f, 0.02271061f, 0.03999474f, 0.13219978f, 0.13322957f, -0.36253351f, 0.18707806f, -0.15135689f, 
    -0.02420030f, 0.00573027f, -0.12246417f, 0.09727307f, 0.08641540f, 0.14872779f, 0.11163221f, 0.07927781f, 
    -0.14902581f, -0.30648494f, -0.01341446f, 0.00322309f, 0.07253429f, 0.01044641f, -0.08621079f, -0.07618473f, 
    -0.06337868f, 0.22548808f, -0.04402502f, 0.08585621f, 0.06359826f, -0.11019846f, 0.07875659f, 0.00334333f, 
    -0.28666866f, -0.15121005f, -0.17035234f, -0.11233550f, -0.07069416f, 0.06772831f, 0.00409337f, -0.01607969f, 
    -0.18989959f, -0.11725722f, -0.20332341f, -0.13726383f, -0.00770862f, 0.02128699f, -0.08509890f, 0.13235889f, 
    -0.01345136f, -0.00669528f, 0.15989199f, 0.01718529f, 0.04748955f, 0.23475853f, -0.63229591f, -0.40747607f, 
    0.10902888f, 0.19653192f, -0.18758747f, -0.04304327f, 0.07731832f, 0.10387322f, -0.01331406f, 0.02156475f, 
    -0.05532174f, -0.30782378f, 0.08947162f, -0.12758549f, -0.01573628f, -0.11221793f, 0.13791807f, -0.20074321f, 
    0.10817870f, 0.00807262f, 0.27149305f, 0.26816747f, -0.75431168f, -0.44312876f, 0.16232044f, -0.30839333f, 
    -0.18472725f, -0.13536043f, 0.10455763f, 0.03492478f, 0.19567649f, -0.07647068f, 0.18759641f, -0.00220930f, 
    -0.27153072f, -0.42807287f, -0.19515747f, -0.11600914f, -0.06694818f, 0.01823468f, -0.06699576f, 0.36905801f, 
    -0.01209631f, -0.05014129f, 0.00773570f, -0.18836902f, 0.10652052f, -0.08931759f, -0.17792082f, 0.18238035f, 
    0.46807629f, -0.10876787f, 0.00272708f, -0.10809150f, 0.01209321f, 0.03091221f, 0.09654667f, 0.36833438f, 
    -0.52728385f, -0.14386089f, -0.02727620f, -0.19457822f, -0.04860967f, 0.06330820f, 0.01515025f, -0.08759503f, 
    0.22614950f, 0.10774549f, 0.01948505f, -0.04170839f, -0.45480898f, -0.15912953f, -0.30332690f, 0.14396465f, 
    0.12924869f, -0.16300406f, 0.10556407f, 0.10802404f, 0.25097579f, 0.01071821f, 0.00850709f, 0.23943356f, 
    -0.04684994f, 0.07133023f, -0.30393654f, 0.34650216f, -0.09402288f, 0.02313133f, 0.14154014f, 0.09725945f, 
    -0.07107189f, -0.07449430f, 0.07317637f, -0.08903941f, 0.49900681f, -0.24138801f, -0.15422255f, 0.00613920f, 
    -0.11682052f, -0.19546477f, -0.04371598f, 0.33753443f, -0.09125832f, 0.08157973f, 0.04364628f, -0.05125504f, 
    -0.12794127f, -0.12530610f, -0.05506183f, 0.04597557f, -0.02177591f, -0.01995666f, -0.02808900f, -0.07478111f, 
    0.24419302f, -0.03246235f, 0.00145723f, 0.36299056f, -0.11336969f, -0.25115821f, -0.27858156f, 0.17044353f, 
    0.09761003f, 0.05190174f, 0.00006390f, 0.00717548f, -0.03171290f, -0.14092922f, -0.00262144f, -0.04815495f, 
    0.03933720f, 0.23757935f, -0.02499698f, -0.21365161f, 0.13033822f, 0.29116902f, -0.12716904f, -0.03476656f, 
    -0.10359667f, -0.05585494f, 0.10078909f, 0.01617469f, 0.07171217f, 0.22607824f, -0.05876515f, -0.06773900f, 
    0.08319197f, 0.04216219f, -0.00536553f, -0.25542882f, 0.08077452f, 0.00308660f, -0.01877231f, -0.02889421f, 
    0.05926086f, -0.56868869f, 0.35601458f, 0.17738459f, -0.03110459f, 0.01615028f, 0.03147755f, 0.14011648f, 
    0.02752266f, -0.15399492f, 0.03045009f, 0.14488618f, 0.13780700f, -0.42947280f, 0.13831130f, 0.49823791f, 
    0.11055662f, 0.23835878f, -0.17869736f, 0.08535690f, 0.23834783f, 0.14567503f, -0.12387946f, -0.10247073f, 
    -0.62623513f, 0.03989833f, -0.43484053f, 0.03735539f, 0.01919494f, -0.07927397f, 0.07699753f, 0.03380955f, 
    -0.20481992f, -0.27217260f, -0.39055428f, -0.15706171f, -0.04634717f, 0.48741782f, -0.07769184f, -0.29144692f, 
    -0.22714387f, 0.01477035f, 0.08174688f, 0.05712876f, -0.10992756f, -0.06591722f, -0.05358772f, 0.07079098f, 
    0.29580766f, 0.09156340f, 0.03095212f, 0.16791026f, -0.02312503f, 0.17782401f, -0.00090026f, 0.05707665f, 
    -0.00273346f, -0.00421266f, 0.18141334f, -0.01313023f, 0.00294351f, 0.12751749f, 0.03718621f, -0.08114453f, 
    0.51864213f, -0.13258481f, -0.17785057f, -0.01685775f, -0.01932446f, 0.10578252f, -0.00900620f, 0.05033199f, 
    0.68757421f, -0.11404618f, -0.12035132f, 0.16606538f, 0.18478459f, 0.11930919f, -0.04373994f, -0.02114779f, 
    0.09027600f, 0.08357675f, 0.00983594f, 0.05617772f, -0.02960148f, -0.17739432f, -0.11961428f, 0.08450730f, 
    -0.17467806f, 0.39428127f, -0.06047343f, -0.12155494f, 0.11600138f, -0.08020572f, -0.00711508f, 0.03946926f, 
    -0.15723763f, -0.27597001f, 0.27629238f, -0.24355607f, -0.14333580f, -0.02101360f, -0.00930188f, 0.06401764f, 
    0.08476959f, 0.29147109f, 0.24546209f, 0.02485521f, -0.99278259f, -1.07296228f, -0.32876134f, 0.69455940f, 
    0.26205650f, 0.11695410f, -0.06248303f, -0.07656607f, 0.00483207f, -0.00371143f, -0.04366508f, 0.11145679f, 
    0.21438895f, -0.12855956f, -0.14083943f, -0.16893093f, 0.21644790f, 0.05051067f, 0.22822118f, -0.20463239f, 
    0.01918644f, 0.00986727f, 0.06598245f, -0.03970031f, 0.50427788f, -0.03891977f, -0.06359631f, -0.02930740f, 
    0.15189095f, 0.05928119f, 0.04942187f, 0.05330414f, 0.22312121f, -0.23523468f, 0.29511848f, 0.00285928f, 
    0.05695422f, -0.06337728f, -0.33683383f, -0.06036568f, -0.06142058f, 0.12872611f, 0.01454208f, -0.09808793f, 
    -0.04501607f, -0.02315901f, 0.05909013f, 0.04316282f, 0.05788646f, -0.14779511f, 0.20511259f, 0.11432651f, 
    -0.01001561f, -0.03486604f, 0.09730481f, -0.17702985f, 0.13126506f, 0.02747851f, 0.16995957f, 0.09829173f, 
    -0.85462523f, -0.77862191f, -0.70491129f, -0.29100150f, -0.17457701f, -0.34941193f, 0.08523419f, -0.48389903f, 
    -0.09477952f, -0.01201602f, -0.06220760f, 0.06440474f, -0.24449979f, -0.09774406f, 0.00175453f, 0.12900402f, 
    0.09893071f, 0.09406731f, 0.09180526f, -0.07220533f, 0.01007029f, -0.05638884f, 0.03120582f, 0.20043652f, 
    0.02424472f, 0.04754164f, 0.03191571f, -0.00733737f, 0.11148556f, 0.04399216f, -0.06042208f, 0.01341783f, 
    0.06593718f, -0.10350927f, -0.15007325f, -0.14358321f, -0.01524088f, -0.04455237f, -0.12013158f, -0.03371026f, 
    -0.15127984f, -0.31215033f, -0.00974698f, -0.00411024f, 0.03682197f, 0.06118466f, 0.06629036f, 0.01184639f, 
    -0.32069719f, 0.36911553f, 0.10190348f, -0.04144317f, -0.14340340f, -0.03650679f, 0.01016258f, -0.03641807f, 
    -0.06852176f, 0.03765456f, -0.07428827f, -0.03551222f, -0.08624464f, 0.13646458f, 0.34471455f, -0.74306738f, 
    0.03616761f, 0.08374628f, -0.02929899f, -0.12163791f, 0.03573054f, 0.01425033f, 0.10137780f, 0.04676951f, 
    -0.22697057f, -0.03151399f, -0.05815091f, 0.06741907f, 0.14950050f, -0.08484763f, 0.11141533f, 0.17515719f, 
    0.07766090f, -0.12957881f, -0.01516188f, 0.07090992f, -0.57447314f, 0.03448875f, 0.42009360f, -0.00700685f, 
    -0.07854902f, 0.05599151f, -0.08222640f, -0.00433299f, -0.11356081f, 0.24028485f, 0.05205878f, 0.02595376f, 
    -0.42354780f, 0.37424794f, 0.24679025f, 0.18473783f, -0.11366075f, 0.12010450f, -0.05224050f, 0.04364255f, 
    -0.06492008f, -0.05010609f, 0.08651619f, 0.19644903f, -0.06755184f, -0.08638053f, 0.22944859f, 0.27669710f, 
    0.05426907f, -0.08857332f, 0.02148736f, 0.03669883f, -0.08105022f, -0.07927267f, -0.03411316f, 0.04016457f, 
    -0.36641851f, 0.26148564f, 0.62970459f, 0.43950382f, -0.10128412f, -0.13302252f, -0.09532437f, 0.11236739f, 
    -0.00406325f, 0.18355519f, -0.01181180f, -0.09827963f, 0.65670282f, -0.10316402f, -0.34663081f, 0.50568527f, 
    0.05200978f, -0.16706829f, 0.15711312f, -0.11675683f, 0.07660871f, -0.11475347f, -0.08670028f, -0.05597170f, 
    -0.08722382f, 0.32590082f, 0.11105980f, -0.29745206f, -0.02272866f, 0.10105982f, 0.26631808f, -0.43974978f, 
    0.01364678f, -0.10329399f, 0.06522047f, 0.22146393f, 0.12054604f, 0.00113340f, -0.28807032f, 0.08626477f, 
    -0.27167204f, 0.25969708f, 0.31567559f, 0.12831333f, 0.11385125f, 0.14361769f, -0.11010016f, -0.02959174f, 
    -0.07464959f, 0.01123681f, 0.07309815f, -0.03969555f, 0.01164430f, -0.11095288f, 0.02009560f, 0.04926876f, 
    0.14108591f, -0.17549331f, -0.06481521f, 0.14708789f, 0.24628747f, -0.05495533f, -0.10275266f, -0.12031057f, 
    -0.03214909f, 0.04121600f, 0.08212470f, -0.02154920f, -0.08124942f, -0.09912559f, -0.14555459f, -0.07772142f, 
    -0.70537955f, -0.83495927f, -0.58939058f, -0.41977641f, -0.06052482f, -0.07605717f, -0.09106497f, -0.49559695f, 
    0.09137510f, -0.00347229f, -0.08451644f, -0.07616585f, -1.10698330f, -0.91119778f, -0.33871225f, -0.27514419f, 
    -0.26758903f, 0.05776076f, -0.28036687f, -0.21856819f, -0.05217692f, -0.00427151f, 0.03008934f, 0.01784703f, 
    0.09824549f, -0.05078748f, 0.04148661f, 0.10146788f, 0.01260953f, -0.10845761f, 0.05755803f, 0.31475052f, 
    0.11046081f, -0.04735242f, 0.08053721f, -0.03524205f, -0.31720126f, -0.31279141f, 0.23565662f, -0.12029994f, 
    -0.09750000f, 0.19672652f, -0.15085982f, -0.01752556f, 0.01486903f, -0.08557533f, 0.16440183f, 0.09231077f, 
    0.03458501f, -0.06222095f, 0.11133291f, 0.23474716f, -0.03935182f, 0.13009699f, -0.06995972f, 0.07519966f, 
    0.16146138f, 0.22147320f, 0.26538798f, 0.00183237f, -1.07314229f, -0.81189883f, 0.04433197f, 0.27449876f, 
    0.14812705f, 0.09943850f, -0.13140048f, -0.19996719f, -0.00496181f, 0.12781782f, 0.16221063f, -0.12575437f, 
    -0.71229410f, -0.53406519f, -0.55846471f, -0.58585757f, -0.12599166f, 0.14505047f, 0.09968995f, 0.05761684f, 
    -0.02789691f, 0.11909913f, 0.02762174f, 0.16577779f, -0.22297172f, -0.26281163f, -0.00166399f, -0.05467305f, 
    0.02953670f, -0.01861541f, 0.09169097f, -0.22884217f, 0.04913918f, -0.12297130f, -0.04679960f, 0.03736350f, 
    0.06410304f, -0.31367519f, -0.97956902f, -0.28058150f, -0.06467429f, 0.10473910f, 0.18419102f, -0.09881583f, 
    0.03673228f, 0.01719721f, 0.00052219f, -0.05904021f, -0.08289117f, -0.01770516f, 0.10544405f, -0.04783609f, 
    0.11097153f, -0.06460726f, 0.02336862f, -0.06287680f, -0.09773754f, -0.10467386f, -0.19507293f, -0.03933127f, 
    -0.10635353f, -0.33967042f, -0.51620674f, 0.34007084f, -0.09804714f, -0.13256089f, -0.16017206f, -0.00734177f, 
    0.21016298f, 0.03357769f, 0.10868549f, 0.02435992f, -0.06428190f, -0.58553487f, 0.46024543f, -0.69629127f, 
    -0.20781460f, 0.15835686f, -0.06496646f, 0.17584273f, -0.09597819f, 0.02695820f, 0.09184786f, -0.05974395f, 
    0.06439035f, 0.15337804f, 0.06043974f, -0.08125090f, -0.28184476f, -0.00789869f, -0.11580086f, 0.27668315f, 
    -0.02785851f, 0.02047144f, 0.02187773f, 0.10202587f, -0.12058437f, 0.11794595f, 0.11406023f, 0.00236121f, 
    -0.00257218f, -0.05742690f, 0.11876035f, -0.06894176f, -0.08904419f, 0.04714588f, -0.01575068f, -0.13288146f, 
    0.05330625f, 0.10901534f, -0.12060162f, -0.12552570f, 0.05471722f, -0.08004983f, -0.08929356f, 0.03097199f, 
    0.09081788f, 0.02727957f, 0.05930971f, 0.01184025f, 0.29101795f, -0.04465858f, -0.19070378f, -0.18445837f, 
    0.09342157f, 0.02541615f, -0.00177427f, 0.04695243f, -0.12378214f, 0.03540631f, -0.05866876f, -0.22467661f, 
    -0.46956778f, -0.39143541f, -0.15153311f, 0.42430165f, 0.14198142f, 0.05502938f, -0.13113151f, 0.20312154f, 
    -0.01967505f, -0.05162928f, -0.10232400f, 0.02831692f, 0.11635704f, -0.09494954f, 0.08072249f, -0.26623496f, 
    -0.00941246f, -0.06620251f, 0.04412778f, -0.02024824f, 0.04061450f, 0.03840533f, -0.01887778f, -0.12213527f, 
    0.07420383f, 0.02360364f, 0.05734257f, -0.05899806f, 0.04502560f, 0.02462510f, 0.03830062f, -0.08397909f, 
    0.08239277f, 0.00597044f, -0.10979242f, 0.01629843f, 0.25251469f, -0.06759558f, -0.01149705f, 0.15874588f, 
    0.04677250f, -0.22790760f, 0.08274006f, -0.00914420f, -0.08521201f, 0.01749808f, 0.01185972f, 0.07976229f, 
    0.51761085f, -0.09491355f, 0.05080204f, -0.10809557f, -0.00241687f, -0.20981219f, -0.17230977f, 0.03836474f, 
    0.01187951f, 0.04511427f, 0.10449228f, 0.05462363f, -0.22584815f, 0.29082835f, -0.06741001f, 0.19236729f, 
    -0.04946858f, -0.00073345f, 0.07911567f, -0.00513194f, 0.10215937f, 0.02639915f, 0.05089807f, -0.14432912f, 
    0.11025678f, -0.07415496f, 0.01920660f, -0.26417413f, -0.19106144f, 0.10926391f, 0.26382244f, -0.01892109f, 
    0.07661100f, 0.07679374f, 0.03984850f, -0.10328700f, 0.66577673f, -0.79430604f, 0.16406755f, -0.68540090f, 
    -0.14672141f, -0.10002378f, -0.14909782f, 0.07982855f, 0.09738137f, -0.18172501f, -0.16999657f, -0.04286844f, 
    0.49495772f, -0.91730928f, -0.13725124f, -0.32460609f, -0.01091689f, -0.00546135f, -0.06034881f, 0.06275734f, 
    0.22663638f, -0.10375156f, 0.13106754f, 0.03133570f, -0.07107741f, 0.07006834f, -0.13242598f, -0.08908863f, 
    -0.43436325f, 0.17993017f, 0.16438623f, 0.07310020f, 0.01349059f, -0.09748162f, 0.04214231f, -0.05310092f, 
    0.44439545f, -0.34824032f, -0.63413930f, -0.47674125f, 0.01309473f, -0.11222940f, 0.06000283f, 0.06851496f, 
    0.10803404f, -0.08644899f, 0.05805866f, 0.08962620f, -0.37618130f, -0.11340719f, -0.29002297f, 0.20685127f, 
    -0.19099458f, 0.23008542f, 0.04585205f, -0.04546897f, -0.02749892f, -0.06010992f, 0.16518967f, 0.02541397f, 
    -0.35352063f, 0.51967567f, -0.20045629f, 0.09011123f, 0.10151851f, -0.36156350f, 0.05209779f, 0.16862659f, 
    -0.34136891f, 0.30570510f, 0.13405421f, 0.07917155f, -0.50611627f, -0.07412528f, -0.14133078f, -0.15223856f, 
    -0.06482919f, 0.23175271f, 0.12957360f, 0.00317926f, 0.05860508f, 0.01505930f, -0.06782693f, 0.04652729f, 
    0.14126314f, 0.02229367f, -0.11467903f, -0.09339459f, 0.04995364f, 0.04714380f, 0.02105317f, -0.01338768f, 
    -0.02356446f, -0.11320141f, -0.11773720f, -0.15659942f, 0.11460754f, 0.08196108f, 0.04121757f, 0.00211856f, 
    -0.06102057f, -0.06587707f, 0.03961654f, -0.01572498f, 0.02430952f, 0.01227541f, -0.00854972f, -0.02942759f, 
    -0.74348086f, -0.01788218f, -0.03950563f, 0.16089019f, 0.35760728f, 0.03903027f, -0.04078182f, 0.28462362f, 
    0.05364640f, 0.02306444f, 0.00673636f, 0.05722167f, -0.30007261f, -0.45527357f, -0.50230718f, 0.07278518f, 
    0.10864710f, -0.08502869f, 0.03653274f, 0.22282600f, -0.01420294f, -0.02800373f, -0.04643079f, -0.04771543f, 
    0.13240139f, -0.19343555f, 0.02818600f, -0.25372005f, 0.04608345f, 0.03052622f, -0.06704049f, -0.15678366f, 
    -0.17597170f, -0.00309955f, -0.36869222f, -0.20842747f, 0.25744855f, 0.27147385f, -0.17699420f, -0.32134929f, 
    0.08871081f, 0.08528569f, -0.10371890f, 0.02551966f, -0.20143062f, 0.31516677f, -0.11514852f, -0.00961558f, 
    0.00613258f, 0.08950306f, 0.21197899f, 0.05236929f, -0.07679847f, 0.16062200f, -0.06267721f, -0.04617698f, 
    0.18198584f, 0.05703178f, -0.09155715f, 0.09979430f, 0.09445160f, 0.00908346f, 0.63519788f, -0.11777354f, 
    -0.02074374f, -0.07161593f, 0.25559461f, 0.04081612f, 0.13344470f, -0.06557100f, 0.04130318f, -0.04842472f, 
    -0.89976281f, 0.25628570f, -0.23988917f, 0.19153130f, -0.05270112f, -0.29121169f, 0.05801295f, 0.08240836f, 
    0.06900118f, -0.03752445f, 0.02612550f, -0.09438411f, -0.24283071f, 0.10726555f, -0.08005883f, 0.32949451f, 
    0.04595605f, -0.20331198f, -0.05676566f, 0.02666698f, -0.06259236f, 0.04114455f, -0.01153000f, 0.00105083f, 
    0.01069497f, -0.74253911f, 0.47640160f, -0.15188770f, -0.04045625f, -0.05655774f, 0.02163410f, -0.25265887f, 
    0.01236003f, 0.00018799f, 0.04252220f, -0.01030958f, -0.02328828f, 0.15467773f, 0.01591044f, -0.05851620f, 
    0.00562973f, 0.02552236f, -0.02603655f, -0.02238127f, 0.01858969f, 0.04485563f, 0.09806619f, -0.08245872f, 
    -0.10114701f, -0.01237898f, -0.35312676f, -0.30655736f, 0.13438913f, 0.13182633f, 0.08710331f, 0.10054691f, 
    -0.13438360f, -0.02689831f, -0.38217032f, -0.56537044f, 0.54242826f, 0.38289887f, -0.37458304f, -0.23560977f, 
    0.00004833f, -0.17011656f, 0.03589255f, -0.34457710f, 0.06323098f, -0.01871704f, -0.03546402f, 0.15477271f, 
    -0.57051015f, 0.10817324f, 0.11168193f, 0.05048410f, 0.01182579f, 0.00340672f, -0.13720603f, -0.14467993f, 
    -0.02199462f, -0.02184502f, 0.00344962f, -0.17906649f, -0.50751680f, -0.11679135f, 0.11402061f, 0.15020716f, 
    0.03903543f, 0.14814721f, -0.10263845f, 0.21854557f, 0.01975541f, 0.01588335f, -0.00100195f, -0.12530106f, 
    -0.10480320f, 0.27444768f, 0.16762160f, -0.11224796f, 0.05207800f, -0.13363889f, 0.00052483f, -0.07351819f, 
    -0.15494846f, 0.07850391f, 0.00919313f, -0.02975720f, 0.13844575f, 0.23837061f, -0.32099444f, -0.55686915f, 
    -0.35371733f, -0.20294005f, 0.13787290f, -0.10918074f, -0.07619682f, -0.09933982f, 0.23609304f, 0.00794359f, 
    0.33545837f, -0.37580851f, -0.75525278f, -0.43739471f, -0.23730370f, -0.06151711f, -0.08498176f, -0.01623215f, 
    0.01365778f, 0.07231189f, 0.04005839f, -0.02770620f, 0.12494615f, 0.00669214f, 0.04979966f, -0.43965742f, 
    -0.13804469f, -0.01021567f, 0.00756789f, -0.07835033f, 0.08487877f, -0.02250053f, 0.08134647f, 0.17017755f, 
    -0.26418644f, -0.03687346f, -0.04539341f, -0.30014750f, 0.00285074f, 0.01570637f, 0.06881948f, -0.01914344f, 
    -0.04014514f, -0.07698005f, 0.03459179f, 0.11422973f, 0.01306308f, -0.29414734f, -0.43181434f, -0.35779366f, 
    0.12092692f, 0.11981302f, 0.00424563f, 0.02985424f, 0.05892613f, 0.10914408f, 0.37424538f, 0.22921740f, 
    -0.10379820f, -0.41690260f, -0.35954905f, -0.12026411f, 0.00183660f, 0.17346808f, 0.03118784f, 0.11756290f, 
    0.07101756f, 0.01119967f, 0.10242828f, -0.07514470f, -0.87385190f, 0.07750879f, 0.27288651f, 0.31519857f, 
    -0.12691826f, -0.11805898f, -0.10521471f, 0.03854473f, -0.07349737f, 0.08315878f, 0.15147525f, 0.13346258f, 
    0.00974708f, -0.08294795f, -0.10689094f, 0.04317119f, 0.02368148f, -0.29525796f, 0.19930811f, -0.20704028f, 
    -0.03633010f, 0.11510944f, 0.02795937f, 0.28446060f, -0.18512093f, -0.00702691f, -0.29794440f, 0.21388812f, 
    0.18914290f, -0.07607277f, 0.21742627f, 0.20277996f, 0.06218537f, 0.26789179f, -0.11215173f, 0.12512508f, 
    -0.22445948f, -0.34043887f, -0.22014968f, -0.00418915f, 0.05434525f, 0.18212919f, 0.04405089f, 0.02168816f, 
    -0.02913066f, -0.09702871f, 0.01541048f, -0.17976961f, -0.03700665f, 0.20083766f, 0.03712610f, 0.22910538f, 
    -0.01246368f, -0.12791592f, 0.13139634f, 0.01635389f, 0.14349066f, 0.03381898f, 0.14687788f, 0.14638740f, 
    -0.29312384f, -0.43331590f, -0.30048236f, 0.40563095f, -0.07794993f, 0.19091000f, 0.08264808f, 0.11297366f, 
    0.09128074f, 0.05727727f, 0.05131365f, 0.03978777f, -0.39048985f, 0.18118733f, -0.12704974f, 0.35274976f, 
    0.10188551f, 0.06134102f, 0.08352085f, 0.14785820f, -0.11435532f, -0.02973773f, 0.19261311f, 0.08882342f, 
    -0.13617083f, -0.07039900f, 0.13847150f, 0.25602326f, -0.11152181f, 0.30521366f, 0.05133126f, 0.03671734f, 
    0.02657616f, 0.18428200f, -0.00330422f, 0.25094268f, -0.35201064f, -0.51955253f, -0.25026682f, 0.24529010f, 
    0.26246586f, 0.01490437f, 0.04427651f, 0.08983915f, -0.15651861f, -0.29387879f, -0.10122771f, -0.13182123f, 
    -0.10928123f, 0.01650750f, -0.03501909f, -0.04290946f, -0.10992225f, -0.00053752f, 0.00433573f, 0.05605496f, 
    0.20215711f, 0.18900576f, 0.10496131f, 0.09042677f, -0.40457565f, 0.12540025f, 0.11456007f, -0.01278808f, 
    -0.04515725f, 0.05800042f, -0.05214907f, -0.03949979f, -0.15061738f, -0.13487001f, -0.12792429f, 0.00525475f, 
    -0.43187818f, -0.35094616f, -0.15059529f, 0.04139937f, -0.21235612f, 0.17729819f, 0.06752942f, -0.03745944f, 
    -0.09216855f, 0.05287398f, -0.02309586f, 0.08002358f, -0.08542019f, -0.72196037f, -0.82920945f, -0.63958675f, 
    -0.15367591f, 0.01095748f, 0.05797130f, -0.05327198f, 0.03090132f, -0.05148979f, 0.01467227f, -0.01865079f, 
    0.56727976f, -0.19439982f, -0.29155740f, -0.37466431f, 0.07495655f, -0.07773124f, 0.04314655f, 0.05958947f, 
    0.19459300f, 0.00705117f, 0.26504624f, 0.02690980f, 0.22617470f, 0.00591746f, -0.34711939f, -0.57689238f, 
    -0.09946579f, 0.04161067f, 0.14617690f, 0.17819077f, 0.19296640f, -0.09863420f, 0.23192781f, 0.24340113f, 
    -0.29525733f, 0.04245858f, 0.13010310f, 0.09963710f, -0.11573477f, 0.07872215f, -0.17538548f, 0.09041445f, 
    -0.15482803f, -0.11927041f, -0.14823976f, -0.43045178f, 0.16322179f, 0.17214662f, -0.35326955f, -0.12160093f, 
    -0.07348651f, -0.05896183f, 0.01110790f, -0.09358856f, 0.11250099f, 0.12552634f, 0.09447416f, 0.03272712f, 
    -0.07496685f, -0.11271170f, -0.05909098f, 0.35742381f, 0.17529975f, -0.00527171f, 0.04013880f, 0.07120868f, 
    0.07802448f, -0.04793111f, -0.00247106f, -0.16343129f, -0.15476879f, 0.09528732f, -0.08659240f, -0.05421380f, 
    -0.14433566f, -0.09854800f, -0.12166787f, -0.05251232f, 0.19664164f, 0.07250252f, -0.06090176f, -0.00711207f, 
    0.47921616f, 0.40754777f, 0.12273107f, 0.05116170f, 0.27943856f, -0.03206096f, -0.01064922f, -0.30197635f, 
    0.02982042f, -0.06129998f, -0.01460054f, -0.02513844f, -0.14102839f, 0.06575848f, 0.02096865f, -0.00587255f, 
    -0.03207307f, -0.12117970f, 0.06653155f, 0.06363454f, 0.17287698f, 0.11612717f, 0.10191029f, 0.11980215f, 
    -0.51045138f, 0.05968285f, -0.12213169f, -0.04667122f, 0.00179630f, 0.07829498f, 0.03103443f, 0.00391628f, 
    0.05648920f, 0.21392912f, 0.04139702f, 0.24738032f, 0.12944528f, -1.61733735f, 0.37617147f, -0.30119854f, 
    -0.11869477f, 0.03723359f, -0.28134623f, 0.12146281f, -0.03673521f, 0.04085069f, -0.01116396f, -0.04639835f, 
    -0.06366481f, -0.26237848f, -0.45299429f, -0.08951927f, -0.06652569f, 0.26776201f, 0.12625639f, 0.23417164f, 
    -0.12881668f, -0.03462239f, -0.03035766f, -0.02195115f, 0.27476504f, -0.09587906f, -0.12198908f, -0.45915404f, 
    -0.19462846f, 0.10964356f, 0.02426827f, 0.13880327f, -0.12699680f, -0.09236532f, 0.06074204f, -0.01625967f, 
    -0.03915918f, -0.39987388f, -0.26816911f, 0.20956647f, 0.16996484f, 0.11183793f, 0.19883059f, 0.03254218f, 
    -0.05689307f, -0.06600399f, -0.02353130f, 0.05237627f, -0.87676138f, -0.12496326f, 0.24936931f, 0.08598039f, 
    -0.12000437f, 0.22558364f, -0.49365816f, 0.19099474f, 0.12052285f, 0.01215464f, 0.03989637f, 0.00292891f, 
    -0.43799907f, 0.00258210f, -0.11350052f, -0.06716605f, -0.18732728f, -0.06763840f, 0.11234028f, 0.29992533f, 
    0.05083253f, 0.06618992f, 0.13740157f, 0.04206124f, 0.09893911f, -0.37918678f, 0.26194939f, -0.18454136f, 
    0.01814548f, 0.12626833f, -0.10295173f, -0.00691239f, -0.16803969f, -0.00237995f, 0.00742203f, -0.00760748f, 
    0.02887398f, -0.10535629f, -0.15646255f, 0.06538763f, -0.03812031f, 0.00115058f, 0.02120825f, -0.04873929f, 
    0.11806523f, -0.18608332f, 0.20551877f, -0.00570908f, -0.02729267f, -0.04883897f, 0.23848373f, -0.08034481f, 
    0.11675023f, -0.18020166f, -0.03991956f, -0.12690122f, 0.16090015f, -0.15798950f, -0.08704349f, 0.11179006f, 
    0.16344340f, -0.10145600f, 0.11157995f, 0.00937852f, 0.04459447f, -0.15611678f, -0.11717993f, -0.11248672f, 
    0.14081372f, 0.04120068f, -0.00519503f, 0.11208290f, -0.28469250f, -0.11977164f, -0.46782023f, -0.10747091f, 
    -0.00305546f, -0.21248631f, 0.19537370f, -0.09828681f, 0.11148054f, 0.00888706f, -0.10115600f, -0.03878140f, 
    0.41042504f, -0.11276261f, 0.18596046f, -0.47346982f, -0.00234942f, -0.24467325f, 0.09478684f, 0.03786489f, 
    0.02529204f, -0.05726995f, -0.12490118f, 0.06134965f, 0.25477076f, -0.38919252f, 0.39423162f, 0.13703959f, 
    -0.10871308f, -0.00399443f, -0.16456237f, -0.31056353f, 0.24788454f, -0.10142066f, -0.15859118f, 0.13467194f, 
    0.17552426f, 0.13913207f, 0.21010038f, 0.00829088f, -0.11922393f, -0.23763688f, -0.22483806f, -0.16556266f, 
    0.00409881f, -0.11140908f, 0.18135296f, 0.14378934f, -0.01796749f, -0.21424575f, -0.21155329f, -0.65244967f, 
    -0.00059198f, -0.10452797f, 0.11102997f, 0.19697207f, 0.05495353f, -0.15719211f, -0.05821298f, -0.04178229f, 
    0.31072700f, 0.32859734f, 0.41054976f, -0.19851679f, 0.12179655f, -0.22086389f, 0.00183078f, -0.17007437f, 
    -0.12353493f, 0.01629729f, 0.07198147f, 0.05913850f, -0.50651759f, 0.81105149f, -0.57702005f, -0.91335624f, 
    -0.19956723f, -0.15726776f, 0.13257515f, 0.06754325f, 0.14744025f, 0.05395318f, -0.02486430f, -0.03043019f, 
    -0.56060123f, 0.07843813f, 0.10598531f, -0.09979534f, 0.09236181f, -0.10618514f, 0.00584470f, 0.17918359f, 
    0.11863603f, 0.18526274f, 0.06230962f, 0.11671505f, -0.10128067f, 0.34006763f, 0.39118657f, -0.44687471f, 
    0.20392583f, -0.36431026f, 0.26380134f, -0.14185558f, -0.04654077f, 0.21103503f, -0.07219952f, 0.04351352f, 
    0.12992136f, 0.05744194f, 0.13966294f, 0.16613163f, 0.05756655f, -0.02430782f, -0.07006755f, -0.03302224f, 
    -0.15958840f, 0.14209995f, -0.06649654f, -0.07181807f, -0.17583644f, -0.16071954f, -0.27976355f, -0.08490115f, 
    0.15897021f, 0.20119366f, 0.21552318f, 0.11045463f, 0.17993067f, -0.03291988f, 0.08267595f, 0.12710410f, 
    -0.33789000f, 0.50233817f, 0.00723307f, -0.37259656f, -0.10644387f, 0.01645505f, 0.21063548f, 0.03583724f, 
    0.00594890f, 0.06892367f, -0.02601724f, 0.01057773f, -0.33791289f, -0.19538637f, 0.17051443f, -0.14770263f, 
    0.25177446f, -0.18514980f, -0.08989017f, 0.34607121f, -0.03880335f, 0.00921228f, 0.07983567f, 0.07171003f, 
    0.15320042f, -0.00835824f, 0.44585851f, 0.34955686f, 0.12209427f, -0.12078644f, 0.00825491f, -0.17011629f, 
    0.12474389f, 0.17163798f, 0.01513059f, 0.01563879f, -0.23434852f, 0.08560976f, -0.19212838f, 0.59953302f, 
    -0.12105911f, -0.00964815f, -0.28571948f, 0.07420407f, -0.16231646f, -0.06554065f, 0.22278716f, 0.02559523f, 
    -0.17587347f, 0.11583185f, -0.08130075f, -0.06195689f, -0.07386092f, -0.03303932f, 0.21396504f, -0.22035497f, 
    -0.04274387f, -0.02083418f, 0.18159355f, 0.10447909f, -0.05888124f, -0.46990240f, 0.15595043f, -0.30150807f, 
    -0.04123704f, 0.11991210f, -0.15436657f, 0.10166032f, -0.04438696f, 0.01976717f, 0.03424068f, -0.11662784f, 
    -0.28417373f, 0.29407662f, -1.05133188f, 0.15073368f, 0.05939205f, -0.20065536f, 0.20714821f, 0.02413429f, 
    0.05571328f, 0.05900474f, -0.08407953f, -0.01359854f, 0.19851410f, 0.17690180f, -0.31570834f, -0.22878213f, 
    -0.01550426f, 0.03937703f, 0.07927632f, 0.20286094f, -0.05615881f, -0.24022168f, -0.11547479f, -0.11652193f, 
    0.02210313f, -0.31385535f, -0.86700356f, 0.32305032f, 0.07636173f, 0.07799261f, 0.13615541f, 0.10803577f, 
    -0.01262102f, -0.00832901f, 0.02294832f, 0.02475492f, 0.13762586f, -0.13415162f, -0.09825785f, -0.06440090f, 
    0.27691391f, 0.08287115f, -0.04188927f, 0.12294541f, 0.04569669f, -0.05367363f, -0.01199306f, -0.02311691f, 
    0.44492841f, -0.04555934f, 0.29894701f, -0.25876570f, 0.08438603f, -0.00214430f, 0.14683914f, 0.09285368f, 
    -0.15050678f, -0.11668102f, -0.56890589f, -0.49302188f, -0.94414204f, -0.05957501f, -0.30371073f, 0.14491843f, 
    -0.09865655f, 0.28280005f, -0.19001311f, 0.08267462f, 0.02760913f, -0.08814412f, 0.01320741f, -0.03426823f, 
    0.08358511f, -0.29943568f, 0.25324860f, 0.04662016f, 0.07937910f, 0.10971504f, -0.11719576f, -0.06066645f, 
    -0.18375844f, 0.06019477f, -0.26527211f, -0.12568992f, -0.20245244f, 0.23053508f, -0.00493416f, 0.35657132f, 
    -0.10958101f, -0.31337532f, 0.15402247f, 0.15126854f, -0.28633413f, 0.07063650f, 0.16563591f, 0.18622677f, 
    -0.09876382f, -0.02725301f, -0.16514459f, 0.06868672f, -0.34449121f, -0.25121793f, 0.06942508f, -0.08261300f, 
    -0.10872501f, 0.09853245f, -0.05166972f, 0.08842837f, 0.09162704f, -0.51584077f, -0.08229590f, 0.17652610f, 
    0.14513871f, -0.07611346f, -0.04599877f, -0.00182952f, -0.08196028f, -0.09979635f, -0.03018113f, -0.10073095f, 
    -0.19259900f, -0.38287985f, -0.09165996f, 0.11113659f, -0.16069087f, 0.18890145f, -0.10601505f, 0.26233277f, 
    0.04443255f, 0.21996036f, 0.12017447f, 0.02539306f, -0.58681035f, 0.34037983f, 0.04242126f, 0.07886598f, 
    -0.35531509f, 0.30804199f, 0.01154713f, 0.14244309f, 0.22409473f, 0.05386886f, -0.03376748f, -0.01097070f, 
    -0.44409433f, 0.16102722f, -0.42665774f, -0.75047964f, 0.01364292f, 0.04178170f, -0.07778321f, -0.06769755f, 
    -0.15149683f, -0.05559733f, 0.01607806f, 0.03133338f, -0.28784263f, 0.24296275f, 0.28455108f, -0.21066672f, 
    -0.22494090f, 0.08659232f, 0.02164173f, 0.07464006f, 0.06406063f, 0.01014911f, 0.40757659f, 0.50592768f, 
    -0.28943229f, -0.13270196f, 0.22131084f, -0.12140219f, 0.00218901f, -0.11311232f, -0.30049226f, 0.06843315f, 
    -0.16538933f, 0.20330006f, 0.05521588f, -0.07653101f, 0.19172427f, 0.06453243f, 0.11076614f, 0.17907962f, 
    -0.10888980f, -0.04423843f, 0.17206198f, -0.05795667f, 0.17323565f, 0.08685763f, -0.11628629f, 0.15592290f, 
    -0.37217414f, 0.43360981f, 0.29554152f, -0.03981920f, -0.17354131f, -0.02523134f, 0.11247825f, -0.02475171f, 
    0.04353862f, 0.04045686f, 0.27526936f, 0.25167838f, 0.21162118f, 0.07910557f, -0.68007201f, 0.34982753f, 
    0.07294098f, -0.00576612f, 0.05559588f, -0.00675023f, -0.32471111f, 0.28324634f, -0.18728669f, -0.28241587f, 
    -0.29028895f, 0.20853686f, 0.18740346f, -0.36657366f, 0.01771992f, -0.20841430f, -0.11067897f, 0.31484163f, 
    -0.13862127f, 0.01214179f, -0.25837138f, -0.34160587f, 0.08707257f, -0.25746116f, 0.34986612f, 0.53101975f, 
    -0.05666446f, 0.03698316f, 0.00615055f, -0.19120482f, 0.24901316f, 0.29940373f, -0.09905101f, 0.33861718f, 
    0.44789499f, 0.02421686f, 0.12633641f, -0.12222871f, -0.23975888f, -0.15857221f, 0.06307866f, 0.20766464f, 
    -0.04886732f, -0.02496949f, -0.00917922f, -0.05088625f, 0.33629829f, -0.26414186f, 0.72260231f, -0.03824201f, 
    -0.22853209f, 0.07601850f, 0.37750557f, -0.02839908f, 0.00155914f, 0.10561264f, 0.19529711f, 0.31135190f, 
    -0.18171500f, -0.05226710f, 0.13888408f, 0.20632343f, 0.17217307f, -0.06694188f, -0.14603883f, 0.20714270f, 
    -0.12476258f, -0.14155003f, -0.23663664f, -0.35443458f, -0.30667698f, 0.17325601f, -0.20877542f, 0.07301359f, 
    0.15487991f, -0.34531200f, -0.03054285f, -0.14403690f, 0.15772414f, -0.06757438f, -0.35926110f, -0.12533303f, 
    0.11664119f, 0.02463461f, 0.09855510f, -0.25208816f, -0.03809581f, -0.07368156f, 0.09059036f, -0.19229384f, 
    0.09865444f, 0.11501568f, 0.00815704f, 0.13640650f, -0.07082513f, -0.51559699f, -0.37370285f, -0.56670547f, 
    -0.11882573f, -0.19171390f, 0.03356368f, 0.10124339f, -0.19121408f, -0.03700974f, -0.05281062f, -0.38612857f, 
    -0.06678804f, -0.48300901f, -0.04701966f, 0.19768584f, -0.07712764f, 0.08079534f, -0.14029378f, -0.15423328f, 
    -0.01811172f, -0.10038181f, 0.02466376f, -0.07241564f, -0.32395723f, -0.19943544f, -0.46241832f, 0.16041763f, 
    -0.08026747f, -0.21180113f, -0.22325641f, 0.12272444f, 0.07433897f, 0.21343623f, -0.01921068f, 0.01626175f, 
    -0.88467973f, 0.30333325f, -0.07115117f, -0.13876317f, 0.05408079f, 0.23463628f, 0.06703439f, -0.14363378f, 
    0.00296915f, -0.28004658f, -0.07490408f, -0.18168180f, -0.06682188f, 0.66242737f, 0.28581175f, -0.22956489f, 
    0.01940027f, 0.10720464f, 0.06962342f, 0.41788599f, -0.09208939f, 0.07847345f, -0.03844943f, 0.12413190f, 
    0.45610985f, -0.05405460f, 0.09023530f, -0.25407743f, 0.00183953f, -0.16213341f, -0.04769114f, -0.04555168f, 
    0.01584714f, -0.16728745f, -0.54345489f, -0.24036352f, -0.23596989f, 0.20107636f, -0.43501154f, 0.38700667f, 
    0.05086390f, 0.02924831f, -0.28523529f, 0.03311577f, 0.02150236f, -0.20306726f, -0.00857670f, 0.13139795f, 
    -0.08765225f, -0.26959249f, 0.47174045f, 0.17016806f, -0.17075025f, 0.06792299f, 0.20305471f, -0.07557901f, 
    -0.10556260f, 0.17992620f, -0.04657773f, 0.02467731f, -0.19689669f, -0.48295870f, 0.18648133f, 0.04514087f, 
    -0.11608882f, 0.07241608f, 0.02907727f, 0.07517245f, 0.03675205f, 0.23230419f, 0.07184635f, -0.05087167f, 
    -0.24011472f, -0.01819191f, -0.65275574f, 0.07300159f, 0.19190980f, 0.11685602f, -0.05350603f, 0.12564404f, 
    -0.27596498f, -0.03803661f, 0.06588817f, -0.06772947f, 0.02935816f, -0.11845870f, -0.16264085f, 0.17050442f, 
    -0.19274360f, 0.08224853f, -0.04029829f, 0.05099677f, -0.01548992f, 0.26330242f, 0.16937630f, 0.21783428f, 
    -0.43889588f, -0.36411911f, -0.36763766f, -0.48604119f, 0.03426450f, 0.00691637f, -0.05996927f, -0.11450642f, 
    0.03365086f, 0.04280195f, 0.17091529f, 0.16420820f, -0.63745230f, 0.21150713f, -0.24245943f, 0.31656155f, 
    -0.07657403f, -0.15832701f, 0.23851004f, -0.25526232f, -0.03656317f, -0.04621143f, -0.12021421f, 0.06966324f, 
    0.23648734f, 0.23195161f, 0.17148086f, 0.24341637f, -0.22496191f, -0.17406917f, 0.25625691f, 0.16832799f, 
    0.05062231f, -0.04745184f, 0.04517427f, -0.09988973f, -0.27144343f, 0.17577982f, 0.03690075f, 0.43721867f, 
    -0.06842892f, -0.05364870f, -0.10160139f, -0.06956087f, 0.03466396f, 0.06064875f, -0.11000389f, 0.26511055f, 
    0.36444587f, 0.21234168f, 0.31522217f, -0.07697579f, 0.10723205f, -0.00687578f, 0.05871849f, -0.11392003f, 
    -0.04024952f, 0.04009179f, 0.00823823f, -0.10537513f, -1.03087389f, 0.16006999f, -0.48089799f, -0.02607524f, 
    0.16324483f, 0.24961118f, 0.14495081f, -0.20043503f, -0.08318635f, 0.24443376f, 0.15839086f, 0.14386369f, 
    0.13359649f, -0.77285719f, 0.21029663f, -0.24026318f, 0.12551966f, -0.38598725f, -0.20162815f, -0.16049948f, 
    0.02885979f, 0.02523620f, 0.02399860f, -0.10550138f, -0.17801222f, 0.48112619f, -0.59709394f, 0.09562101f, 
    0.15619154f, 0.10357512f, 0.06265806f, 0.01436490f, 0.14312226f, 0.01100044f, 0.06427562f, 0.09284533f, 
    -0.05355063f, 0.17036147f, -0.07937311f, 0.00280292f, 0.06784370f, -0.04338033f, 0.02426171f, 0.02376125f, 
    0.01417159f, -0.12169979f, 0.11572301f, 0.03799755f, -0.01886069f, -0.03764660f, -0.19761205f, -0.08309118f, 
    0.09804314f, 0.01501140f, 0.07787545f, -0.00511215f, -0.24306169f, 0.02092697f, -0.20882940f, 0.01560319f, 
    -0.14866266f, 0.06313897f, -0.09292585f, -0.07913562f, -0.00260279f, -0.05104398f, 0.03789912f, -0.08669118f, 
    -0.11597314f, -0.01889617f, -0.12739912f, -0.22931786f, 0.06852007f, -0.31008989f, 0.33005923f, -0.28748029f, 
    -0.11656203f, 0.14154050f, -0.19776006f, 0.02434210f, -0.08665068f, -0.09216553f, 0.00093404f, 0.08306230f, 
    -0.02773548f, -0.11038649f, 0.00072347f, 0.03285327f, 0.15715742f, 0.23125945f, 0.01784458f, 0.05019691f, 
    -0.24410978f, -0.18377978f, 0.06986589f, -0.27165210f, -0.18489684f, 0.13354510f, -0.23315150f, 0.44060487f, 
    -0.01430020f, -0.13488258f, 0.04752208f, -0.06287320f, -0.01986733f, -0.01041038f, 0.12051294f, -0.09730313f, 
    -0.11082869f, -0.00432880f, -0.38608414f, -0.32690626f, -0.01566969f, -0.12659994f, 0.03740752f, -0.09963998f, 
    0.05208176f, 0.14421165f, -0.07853629f, 0.00836211f, 0.14028056f, 0.09221955f, 0.21373168f, 0.14828454f, 
    -0.06984662f, 0.08609199f, -0.09434878f, 0.14283861f, 0.05974100f, -0.07979593f, -0.01143334f, -0.09411062f, 
    -0.30538005f, -0.14271833f, -0.31070071f, -0.08183891f, 0.00337746f, -0.11059009f, -0.06768784f, 0.15005125f, 
    -0.32180154f, 0.03438762f, -0.02850171f, -0.15841921f, -0.00937189f, -0.28404576f, 0.79518825f, -0.48082453f, 
    0.38237429f, -0.06101223f, 0.15340839f, -0.00998661f, 0.02154719f, -0.00254818f, -0.06442340f, 0.04824889f, 
    -0.19083692f, -0.22393258f, 0.28357947f, 0.13938388f, -0.11679567f, 0.13325819f, -0.00860649f, 0.12461433f, 
    0.13152878f, 0.07586354f, 0.10801923f, 0.02571379f, 0.27906185f, -0.29221031f, 0.15641865f, -0.28022912f, 
    0.20933217f, -0.19943073f, 0.05471593f, -0.06566346f, -0.03926307f, 0.09190946f, 0.09228940f, -0.13905714f, 
    -0.15593749f, -0.03281477f, -0.27100006f, 0.08491034f, 0.03754376f, -0.06713517f, -0.14203076f, 0.02514916f, 
    -0.13098586f, -0.04244424f, -0.01210784f, -0.12966794f, 0.30378047f, 0.42121863f, -0.00600803f, -0.23467302f, 
    -0.13624574f, -0.02351945f, 0.19614758f, 0.17997801f, -0.19987556f, 0.06355812f, 0.14861245f, -0.09173193f, 
    -0.21943532f, -0.09793288f, -0.27284706f, 0.00444279f, -0.11312113f, -0.39744228f, -0.10082097f, -0.03890345f, 
    -0.00079062f, 0.07206747f, -0.00896339f, -0.07453370f, 0.09095450f, -0.54209048f, 0.17375942f, -0.06679847f, 
    -0.12293331f, -0.00289148f, -0.29898107f, 0.10113975f, 0.00093751f, 0.01703766f, -0.08459193f, 0.08476500f, 
    0.00696476f, -0.03650761f, -0.27058765f, 0.02773781f, 0.26226088f, -0.05920816f, 0.03139916f, 0.00546244f, 
    0.28626928f, 0.17977852f, 0.12120454f, 0.01545332f, -0.65348065f, -0.16777658f, -0.09782483f, 0.62816370f, 
    0.44413599f, -0.15206371f, 0.03556791f, -0.18837786f, 0.12293795f, -0.04357776f, 0.01781623f, 0.18248843f, 
    0.20054781f, -0.12074050f, 0.01029935f, -0.13409209f, 0.03817837f, 0.10403044f, 0.16321854f, -0.02890287f, 
    0.18392098f, 0.28618753f, 0.21016704f, 0.09459730f, -1.17560220f, 0.21311568f, 0.04876023f, 0.17461891f, 
    -0.41812432f, 0.12317430f, -0.06644720f, -0.13700233f, 0.08783244f, 0.02983272f, 0.27017564f, -0.08667430f, 
    0.53008014f, -0.43998316f, 0.87944514f, -0.43239188f, 0.09261461f, -0.11814062f, -0.33407435f, 0.28912893f, 
    0.06113460f, 0.17735951f, 0.15197529f, 0.09077848f, 0.19562024f, 0.02391365f, 0.55014020f, -0.33566758f, 
    -0.20099367f, 0.13615191f, -0.44051379f, 0.06148138f, -0.01025606f, 0.09214871f, -0.00432847f, 0.05300396f, 
    0.58259940f, -0.39298663f, 0.52821898f, 0.48315677f, -0.03990372f, -0.31699139f, -0.05488724f, 0.24777564f, 
    -0.13735527f, -0.02272678f, 0.04105129f, -0.18378942f, 0.20845959f, 0.08753995f, 0.08560801f, -0.16211523f, 
    -0.16911477f, 0.13087603f, -0.05232330f, 0.13932391f, -0.19296135f, 0.01195133f, -0.01703959f, -0.02625025f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19784002f, 0.18071309f, 0.06160640f, -0.14923598f, -0.15417816f, 0.11293020f, 0.01579115f, -0.13788344f, 
    0.03079625f, 0.04063785f, 0.02258869f, -0.05271075f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
