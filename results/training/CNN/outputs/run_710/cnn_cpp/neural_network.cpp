#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.16915315f, -0.65246326f, -0.60284692f, -0.57427526f, 0.16015519f, 0.42518595f, 0.55139291f, 0.05716059f, 
    0.24545652f, 0.60037571f, -0.47035110f, -0.22785844f, -0.39206609f, -0.32096863f, -0.16576166f, -0.22080523f, 
    -0.21015553f, -0.08151143f, -0.22827393f, -0.12247267f, -0.23496403f, -0.24580038f, -0.12333796f, 0.15098573f, 
    -0.09858625f, -0.76761812f, 0.33607775f, 0.18756215f, -0.43496624f, 0.30391806f, -0.62824082f, -0.17434597f, 
    0.01178704f, -0.56828862f, -0.32377994f, 0.25334442f, 0.19519012f, -0.24374294f, 0.35918677f, 0.01410483f, 
    0.32197845f, 0.06049791f, -0.15809640f, 0.24969283f, 0.46053916f, 0.07585859f, -0.01080587f, 0.12542684f, 
    0.54856747f, 0.15849900f, -1.23123169f, 0.70046455f, 0.78378034f, -0.56083560f, 0.50643587f, 0.68735534f, 
    -0.30358511f, -0.17266954f, 0.28708622f, -0.46211380f, -0.36965054f, -0.08355978f, -0.21606271f, 0.49266189f, 
    -0.22202489f, -0.19520365f, 0.03094848f, -0.22681299f, -0.05690361f, 0.03788615f, -0.10087316f, 0.21000694f, 
    -0.01554908f, -0.02867308f, -0.17417657f, -0.83328044f, 0.41724342f, -0.06629991f, -0.31132153f, -0.68020064f, 
    0.63364172f, 0.83369392f, -0.39898434f, 0.12290843f, 0.61708635f, -0.38848636f, -0.26015267f, 0.04811836f, 
    -0.19451782f, -0.08503995f, -0.09565153f, 0.07252380f, -0.13747370f, -0.14879359f, -0.00441365f, -0.01013513f, 
    -0.19273190f, -0.08989915f, -0.30362520f, 0.13647707f, -0.29039261f, -1.01315606f, -0.03083132f, 0.11955212f, 
    0.30723351f, -0.68787646f, 0.75643790f, 0.59506196f, -0.15351883f, -0.22561973f, 0.04448687f, 0.04446933f, 
    0.01044592f, -0.11061384f, -0.12344950f, -0.28303859f, -0.11213719f, -0.30581814f, -0.00758828f, -0.00725978f, 
    0.13110599f, 0.12208419f, 0.19017637f, 0.06346864f, 0.13201836f, 0.97531152f, 0.56579173f, 0.26223019f, 
    0.37870628f, -0.00191435f, -0.65786070f, -0.17502716f, -0.32708836f, -0.35446244f, 0.46370071f, 0.43481478f, 
    0.01205449f, -0.12572518f, 0.37986863f, -0.38186371f, 0.17175405f, -0.47455949f, 0.15789729f, 0.38832787f, 
    -0.07447395f, -0.07246161f, 0.24639831f, 0.26576942f, 0.09404828f, 0.00972951f, -0.40641740f, -0.09319584f, 
    -0.57583064f, 0.12453701f, -0.49179184f, 0.30221915f, -0.64042449f, -0.64341187f, -0.35320449f, -0.38942736f, 
    -0.43337962f, -0.31332684f, -0.30859473f, 0.00819306f, -0.34801754f, -0.45394266f, 0.09748127f, -0.04517943f, 
    0.14272788f, -0.11251342f, 0.10844947f, 0.08540171f, 0.03839850f, -0.28175431f, -0.04733846f, 0.22743258f, 
    -0.01924112f, 0.17387226f, 0.22784230f, 0.19750425f, -0.75111294f, -0.21318223f, -0.55501527f, 0.21139565f, 
    0.38980651f, -0.03974527f, -0.14054275f, 0.11860614f, 0.07367216f, -0.36672458f, 0.02342277f, 0.23691240f, 
    0.22661357f, -0.20481874f, -0.37339723f, -0.24886778f, 0.00957163f, -0.43443769f, -0.27082807f, 0.25253376f, 
    0.49501678f, 0.61035573f, 0.40977898f, 0.65652221f, 0.52845788f, -0.26755673f, 0.21618946f, 0.38096935f, 
    -0.16173589f, 0.09803334f, -0.51684731f, 0.02893414f, 0.51637709f, 0.24658951f, 0.09970049f, 0.11066657f, 
    -0.14957538f, 0.02956265f, 0.05132230f, 0.13907190f, 0.26968613f, -0.15130910f, 0.08855958f, 0.33144465f, 
    0.07796796f, -0.11484607f, -0.59285486f, -0.63238263f, -0.09050944f, 0.36439919f, 0.12337981f, -0.24345145f, 
    -0.39946482f, 0.36911225f, 0.29302084f, -0.41491678f, 0.13634969f, -0.21655010f, -0.14194684f, -0.34901798f, 
    0.16188803f, -0.12602100f, 0.24521959f, 0.24080858f, -0.18731700f, -0.16394669f, -0.01755003f, -0.08667838f, 
    -0.27443418f, 0.14441033f, -0.21820390f, -0.36594436f, 0.63804406f, 0.75514108f, 0.89390969f, -0.06266457f, 
    0.03382592f, -0.53138590f, -0.75304323f, -0.22948433f, 0.60272110f, 0.23668171f, -0.09289199f, 0.04882642f, 
    0.12762107f, -0.23270629f, 0.06678714f, 0.14251085f, 0.03116394f, 0.35756317f, -0.08616171f, -0.05807551f, 
    -0.09518918f, -0.05495374f, 0.06924017f, 0.67934424f, 0.70554352f, -1.11173987f, 0.00723501f, -0.64201838f, 
    -0.10389133f, 0.37516254f, 0.06587481f, 0.26007956f, -0.13878323f, 0.27863255f, 0.23707639f, -0.03701010f, 
    0.01251171f, -0.03329584f, -0.04716824f, -0.16217653f, -0.19694315f, -0.15628907f, -0.20725748f, 0.04496809f, 
    -0.05787079f, -0.01751231f, 0.04895763f, 0.12898922f, -0.51929492f, -1.04243338f, 0.19732344f, 0.39465877f, 
    0.28244424f, 0.69088012f, 0.84970909f, 0.14560848f, 0.27102792f, 0.09571280f, 0.04601884f, -0.25877908f, 
    -0.27221271f, 0.35810250f, -0.29859421f, -0.19259620f, 0.04907351f, -0.08960373f, 0.24021952f, -0.18075699f, 
    -0.23742485f, -0.12818086f, -0.18004635f, -0.10717884f, -0.18771094f, 0.68549448f, 0.39311516f, 0.53692496f, 
    0.18914711f, 0.89915955f, 0.22750345f, -0.18708555f, -0.22463852f, 0.38130859f, 0.13600871f, -0.22820979f, 
    0.09932601f, 0.04725141f, -0.08503761f, 0.15012667f, -0.15394008f, 0.13988768f, 0.08798967f, 0.24787332f, 
    0.26443911f, 0.03996082f, 0.30852738f, 0.06438069f, -0.37066194f, 0.13097392f, 1.00029802f, -0.05952062f, 
    -0.05946562f, 0.97499764f, 0.45560738f, 0.05477491f, 0.06124311f, -0.46040833f, 0.01804517f, -0.32670909f, 
    -0.33461022f, -0.39253044f, -0.08520464f, -0.08532872f, -0.11187717f, 0.26268986f, -0.04586740f, 0.27229586f, 
    0.15838142f, 0.22929981f, -0.14323144f, 0.10997014f, -0.14550844f, -0.34923354f, -0.27081835f, -0.73247987f, 
    -0.71709085f, -0.23079468f, 0.04272898f, -0.48365095f, 0.01697339f, 0.37309301f, 0.33955902f, 0.12332318f, 
    -0.30331743f, -0.04105706f, 0.05676770f, -0.03795441f, 0.35964805f, 0.38836855f, -0.08452874f, -0.08551501f, 
    -0.21465087f, -0.40809593f, 0.01104871f, 0.12440435f, 0.18044402f, -0.18640421f, 0.38426915f, -0.15095577f, 
    0.39972258f, -0.87567163f, 0.87277663f, -0.09468295f, -0.38763222f, 0.56049055f, -0.35345936f, 0.42932612f, 
    -0.13135064f, -0.34967461f, 0.05790388f, 0.15245320f, -0.06258452f, -0.07059392f, -0.30148897f, 0.19473390f, 
    -0.07705801f, -0.15962011f, -0.19134103f, -0.34026441f, 0.01045494f, -0.08293193f, 0.19897456f, -0.11090311f, 
    0.16932137f, -0.71314001f, -0.69232148f, -0.32869124f, -0.56162548f, -0.30884057f, -0.13161746f, 0.10795265f, 
    0.49090824f, -0.29717991f, 0.27607471f, 0.08204497f, -0.05295030f, 0.34751281f, -0.22919919f, -0.03477100f, 
    -0.26256284f, 0.08507183f, 0.03371587f, 0.17226361f, -0.14432223f, 0.13480684f, 0.00791895f, -0.14686069f, 
    0.22856334f, -0.03384475f, 0.47506720f, 0.22514436f, -0.53098905f, -0.75324363f, -0.62021154f, 0.42724800f, 
    0.79074967f, 0.16379568f, 0.22939326f, 0.35265374f, 0.53125423f, -0.17230490f, -0.32425019f, 0.13635373f, 
    0.34793621f, 0.09490389f, 0.11479414f, 0.14702411f, 0.12816407f, 0.11560291f, 0.04822421f, 0.01088260f, 
    0.20452756f, -0.00732707f, -0.08094928f, -0.33304513f, -0.88738072f, -0.52611095f, 0.23772234f, -0.18410751f, 
    -0.68327665f, 0.03893432f, 0.16315526f, -0.61465734f, 0.17714852f, -0.01094447f, 0.30420929f, 0.18196705f, 
    0.32068035f, 0.11517425f, -0.09872985f, -0.26721787f, 0.34553951f, -0.08496793f, -0.13117260f, -0.08424055f, 
    -0.25859901f, 0.01868365f, -0.04341488f, 0.26085529f, -0.95462608f, 0.17240001f, 0.02114907f, -0.16194937f, 
    -0.02096249f, 0.36989519f, 0.84276146f, 0.28009427f, -0.03795024f, 0.35837027f, 0.13152580f, 0.20978710f, 
    0.28892285f, -0.27111050f, 0.15104684f, -0.03132838f, -0.17275928f, 0.23732427f, 0.04593212f, -0.06313555f, 
    0.01478376f, -0.01405593f, 0.32255602f, 0.20256725f, 0.04980813f, 0.55052680f, -0.11764690f, 0.67194086f, 
    0.36143756f, 0.38854709f, 0.15221912f, -0.05744377f, 0.48420864f, 0.19459403f, -0.24255683f, 0.17126448f, 
    -0.12209541f, -0.02945332f, 0.33821008f, -0.09918810f, -0.00189696f, -0.03799425f, 0.07602609f, -0.08689298f, 
    0.31658080f, -0.22551319f, 0.15518463f, 0.24203682f, -0.05873553f, 0.33160627f, 0.48081264f, 0.45124325f, 
    0.43919775f, 0.83660197f, 0.20477042f, 0.20671560f, 0.45732790f, -0.54225743f, 0.42335656f, 0.05697209f, 
    -0.26035181f, -0.23785225f, -0.40305227f, -0.14856176f, -0.40923741f, -0.20051689f, 0.22937360f, 0.03058892f, 
    -0.37389544f, -0.13429154f, -0.01584639f, 0.01743049f, -0.23363166f, 0.16241030f, 0.00289690f, 0.23005661f, 
    -0.97750473f, -0.60134363f, 0.35337171f, 0.24958791f, -0.62712514f, 0.69037884f, 0.26427722f, -0.21969216f, 
    0.45679823f, 0.43711632f, 0.12402585f, -0.44001117f, -0.23423000f, 0.20964767f, 0.03870040f, 0.01549909f, 
    -0.19124790f, -0.06636913f, -0.05982605f, -0.02908335f, -0.00507186f, -0.01148921f, 0.00229663f, -0.05798092f, 
    -0.02112061f, 0.47319406f, -0.30560648f, -0.72177929f, 0.20419754f, 0.73490751f, -0.53840256f, -0.78019166f, 
    -0.44966233f, -0.29521555f, 0.18678214f, 0.35762247f, 0.30762079f, 0.15306066f, -0.19846202f, -0.03212640f, 
    -0.11872981f, 0.10859525f, -0.11980531f, 0.41087505f, 0.12036225f, 0.14056116f, 0.11409204f, 0.07691877f, 
    -0.25382304f, 0.64712983f, 0.35354492f, -0.78527510f, -0.92462122f, -0.52162051f, 0.39253151f, -0.25515381f, 
    0.16126037f, 0.31480739f, 0.01371484f, -0.71077234f, -0.00770624f, -0.04897887f, -0.22605394f, -0.37284401f, 
    -0.06485161f, -0.00998056f, -0.17029949f, 0.23649961f, 0.06922459f, -0.15800461f, 0.06550353f, -0.11090451f, 
    -0.09370124f, 0.31634641f, 0.49845907f, 0.18640465f, 0.90216595f, 0.32568234f, -0.42452908f, 0.13990061f, 
    -0.17645019f, -0.07121266f, 0.04828614f, 0.04779386f, 0.36927307f, 0.00429291f, -0.05048364f, 0.08558701f, 
    0.37640199f, 0.15173554f, 0.26804900f, 0.14591134f, -0.17310807f, 0.30797598f, 0.26146600f, 0.23064674f, 
    -0.09545661f, 0.26490131f, -0.13358025f, 0.47589338f, 0.82244760f, 0.12239201f, -0.13451780f, 0.61254948f, 
    -0.74969292f, -0.65871400f, -0.40291420f, -0.46589887f, -0.38933462f, 0.28785282f, 0.13266094f, 0.03718833f, 
    0.13352400f, 0.16319376f, 0.16445155f, -0.07387494f, -0.25652489f, -0.21911615f, -0.10155039f, 0.09651863f, 
    0.05440072f, -0.00635811f, 0.05403556f, 0.21376017f, 0.01677381f, 0.16351421f, 0.51882273f, 1.01557338f, 
    0.05311903f, 0.10950816f, -0.15109749f, 0.42057681f, 0.06879177f, -0.24254802f, -0.08827394f, 0.29527476f, 
    0.42270190f, 0.07414839f, -0.06518377f, -0.50025690f, -0.01213854f, 0.15146410f, -0.12881090f, -0.21131812f, 
    -0.32997212f, -0.13786379f, -0.38665617f, 0.07216986f, -0.06529704f, -0.56309521f, -0.72886831f, -0.27313522f, 
    -0.11732006f, -0.24128978f, -0.13244423f, -0.17464739f, 0.07686538f, -0.23029213f, -0.32067773f, 0.38061768f, 
    -0.24457307f, 0.21146449f, 0.21003816f, 0.37776262f, 0.29011869f, 0.36164618f, 0.46626115f, 0.16123639f, 
    0.01562046f, -0.06488943f, -0.30193809f, -0.24590956f, -0.29165700f, -0.02432079f, 0.16257374f, 0.50003356f, 
    -0.25516230f, 0.45962223f, 0.43997130f, 0.24886908f, -0.01443460f, 0.58589035f, 0.19516885f, 0.48353046f, 
    0.05631073f, -0.12107336f, 0.38500690f, -0.44165066f, -0.13039736f, 0.53553766f, 0.26372030f, -0.35343561f, 
    -0.37764752f, 0.03206715f, -0.09941022f, 0.02518746f, 0.07829201f, 0.32263485f, 0.08863927f, -0.54751104f, 
    -0.57084274f, -0.58838552f, -0.44148791f, -0.28141806f, -0.47895476f, -0.54532468f, -0.35732856f, 0.19570832f, 
    0.48277998f, 0.27159545f, -0.00158156f, 0.06782004f, 0.22498895f, 0.20818432f, -0.08019220f, 0.13153559f, 
    0.12803647f, 0.13287288f, 0.18550822f, 0.02488616f, 0.16829535f, -0.02145401f, -0.12430673f, -0.20665440f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11584935f, 0.27547821f, -0.00853785f, 0.08614390f, 0.23179944f, 0.17851621f, 0.27474388f, 0.04773969f, 
    0.22596402f, 0.14732559f, 0.16942172f, -0.00725021f, 0.07099012f, 0.15015860f, 0.03681793f, -0.01052424f, 
    0.19452789f, 0.21603629f, 0.41144556f, 0.19527285f, 0.04133200f, 0.02792682f, 0.08413849f, 0.16895784f, 
    0.25859821f, 0.11600485f, 0.24910127f, 0.20314218f, 0.06869629f, 0.33930966f, 0.00945469f, 0.04845355f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02559114f, -0.03740104f, -0.01956756f, -0.00524898f, -0.03089095f, 0.01126742f, 0.00776048f, 0.01014863f, 
    -0.05005104f, -0.06695490f, -0.03256616f, -0.00485547f, -0.03556501f, -0.04065756f, -0.02562931f, -0.05121226f, 
    -0.01636691f, -0.05861148f, -0.02323007f, -0.05639988f, -0.04775508f, -0.07136352f, -0.06438259f, 0.00094958f, 
    -0.00070267f, -0.06466824f, -0.05387322f, 0.00823485f, -0.00226217f, -0.04808182f, 0.00236242f, -0.06085203f, 
    -0.00395466f, 0.00068061f, -0.02198741f, 0.01651208f, -0.01188493f, -0.00978053f, -0.04934077f, -0.04037609f, 
    -0.05473167f, 0.01091991f, -0.06471321f, -0.00275458f, -0.00782999f, -0.05888577f, 0.02356237f, -0.00250196f, 
    -0.01232315f, -0.01352456f, -0.01140783f, -0.07235432f, 0.02000043f, -0.07612754f, -0.00486986f, -0.05853952f, 
    -0.06053305f, -0.03479133f, -0.03522619f, -0.06985685f, -0.02035541f, -0.02579220f, -0.00666771f, -0.00599253f, 
    -0.02487757f, -0.04646456f, -0.01097830f, -0.04826280f, -0.00988379f, -0.04015317f, -0.03646911f, -0.03877810f, 
    0.01902877f, 0.02357394f, -0.04158711f, -0.02448699f, -0.05221332f, -0.03747069f, -0.06806342f, -0.07355009f, 
    -0.02410346f, -0.04446929f, -0.05900292f, -0.02371085f, -0.05182520f, -0.00394319f, 0.00965376f, -0.00580563f, 
    -0.02364966f, 0.00369010f, -0.04373004f, -0.03920711f, -0.05000832f, -0.03501251f, -0.02433877f, -0.06266405f, 
    -0.03292561f, -0.01572894f, -0.04738064f, -0.07062435f, -0.00198592f, -0.02186990f, 0.02134190f, -0.06140977f, 
    -0.05500540f, 0.02280978f, -0.00975875f, -0.04839827f, -0.03755319f, -0.03524109f, -0.07054128f, -0.02806581f, 
    -0.05953207f, 0.02383765f, -0.01189128f, -0.01774789f, 0.01970859f, -0.07234669f, -0.05712994f, -0.02244887f, 
    -0.05652156f, 0.01728679f, -0.01656028f, -0.01796024f, -0.05696586f, -0.02544484f, -0.07077646f, -0.06620708f, 
    -0.00057600f, -0.05377068f, -0.02036432f, -0.06791271f, 0.02360526f, -0.00149448f, -0.07102552f, -0.05851457f, 
    -0.03822769f, -0.06591541f, -0.07269377f, -0.03371934f, -0.07119858f, -0.06893529f, 0.01805567f, 0.00602692f, 
    -0.07284394f, -0.00174755f, 0.01753978f, -0.01112943f, -0.02111357f, -0.00753882f, -0.07525638f, 0.01791917f, 
    -0.05177675f, -0.00158944f, -0.03882850f, -0.02704868f, -0.04426229f, 0.00452476f, -0.00496997f, -0.07307651f, 
    -0.04460448f, -0.03009339f, 0.03686533f, 0.00094309f, -0.06698214f, -0.05174508f, -0.06105945f, -0.06177694f, 
    -0.00031212f, -0.06291749f, 0.01266972f, -0.04597728f, 0.01904729f, 0.00107908f, -0.06797293f, -0.06383797f, 
    0.01560464f, -0.01137250f, 0.01969851f, -0.00148940f, -0.00924395f, -0.03202533f, -0.04363246f, -0.03235881f, 
    -0.01792574f, -0.01956405f, -0.03733144f, -0.04973972f, -0.03379511f, -0.04955906f, -0.07205572f, 0.03665674f, 
    -0.04387123f, -0.03032818f, -0.04953314f, -0.02918010f, -0.04694193f, -0.04537250f, -0.02874475f, -0.03995449f, 
    0.02660870f, 0.01723112f, 0.02089891f, -0.04233322f, 0.01830233f, -0.00035384f, -0.03867375f, -0.00040621f, 
    -0.06612534f, 0.01919196f, 0.01953188f, -0.07147309f, 0.01466764f, 0.00257626f, -0.00282009f, -0.05338959f, 
    -0.03217651f, 0.00980694f, -0.04043852f, -0.06003036f, -0.04899835f, -0.03252276f, -0.03157603f, 0.01988122f, 
    -0.03592419f, -0.04948328f, -0.01907707f, -0.03614431f, 0.04615282f, -0.04323963f, -0.01646034f, -0.04500017f, 
    -0.01796401f, -0.00960179f, 0.00204987f, -0.03250325f, -0.04040610f, -0.01444271f, 0.02328427f, -0.01135794f, 
    -0.05756724f, -0.02654843f, 0.01888197f, -0.02620858f, -0.05989457f, -0.06464208f, 0.01390278f, -0.03737185f, 
    -0.03680180f, -0.03004340f, -0.02081539f, -0.01613297f, -0.04633693f, 0.02239175f, -0.06056392f, -0.00347053f, 
    0.00079429f, -0.01864688f, -0.00382939f, 0.00249219f, 0.02374518f, -0.03433506f, 0.01621010f, -0.03014216f, 
    -0.03555261f, -0.01047025f, -0.05949080f, 0.00430148f, -0.03585773f, -0.04252464f, 0.03868476f, -0.04409251f, 
    -0.06274726f, 0.02300870f, -0.07006909f, 0.00410514f, -0.03115841f, 0.01510312f, -0.07248906f, -0.02549469f, 
    -0.02120631f, 0.00602714f, -0.04157753f, -0.00659226f, -0.04861509f, 0.01085242f, 0.04331429f, -0.05661083f, 
    0.00166617f, 0.00642343f, -0.01806480f, -0.03707493f, -0.00386006f, 0.00854377f, 0.00920677f, -0.01454402f, 
    -0.03157777f, 0.00402719f, -0.04698144f, -0.03806503f, 0.01432579f, -0.05399148f, 0.02382403f, -0.06257745f, 
    -0.07363734f, -0.04587908f, -0.03856910f, 0.01856551f, -0.00019389f, -0.04876057f, -0.02570327f, -0.02987717f, 
    -0.03069450f, -0.01914169f, -0.03530769f, -0.03044427f, -0.01187098f, 0.01397713f, 0.04122020f, 0.00636645f, 
    -0.03486562f, -0.04706533f, -0.02499366f, -0.06719332f, -0.06531452f, -0.01319977f, -0.01887149f, -0.01202758f, 
    0.00603139f, -0.07386652f, -0.01336592f, -0.05979867f, -0.07571283f, -0.02377071f, -0.06194236f, -0.07013866f, 
    -0.02084363f, -0.00972853f, -0.03703463f, 0.01852081f, 0.00589237f, -0.01344018f, -0.02969861f, -0.03879134f, 
    -0.01220773f, -0.04188996f, -0.01151351f, 0.00174644f, -0.02055872f, 0.02441713f, 0.01706792f, -0.06069141f, 
    -0.04644224f, -0.02939290f, -0.04711313f, -0.04063689f, -0.05685456f, -0.06977179f, -0.02997055f, -0.03207437f, 
    -0.07285310f, -0.01152990f, -0.02620572f, -0.01286351f, 0.02154888f, -0.03529071f, -0.04063296f, -0.02254675f, 
    -0.00706897f, -0.02663828f, 0.02137590f, 0.00858997f, -0.02919606f, -0.04527176f, -0.07228044f, -0.06540751f, 
    -0.00040869f, 0.01411880f, -0.02407635f, -0.03477382f, 0.00376962f, -0.03387064f, -0.01447412f, -0.00304448f, 
    -0.03187399f, 0.00406003f, 0.01680262f, -0.04880271f, -0.01421830f, 0.02312740f, 0.04591234f, 0.02882292f, 
    0.04043894f, -0.00975294f, 0.00418462f, -0.03588733f, -0.01995132f, -0.00052997f, 0.00405650f, -0.00521800f, 
    -0.02242182f, 0.04337233f, 0.02401386f, 0.04340157f, 0.03548440f, -0.03984016f, -0.05421073f, -0.02172507f, 
    0.00282973f, -0.04518057f, 0.03728230f, 0.01207685f, -0.01658892f, -0.01767035f, 0.03446753f, -0.03977376f, 
    -0.04020146f, -0.02324351f, 0.02051799f, 0.02348302f, -0.00325198f, 0.01338363f, -0.01897231f, -0.02220775f, 
    -0.01373861f, 0.00967916f, -0.02994399f, -0.00866920f, 0.03397503f, -0.01348864f, -0.03246561f, 0.01177787f, 
    -0.02165578f, -0.00751397f, -0.02540056f, 0.02246122f, -0.04574825f, -0.03319139f, -0.00725162f, -0.01529943f, 
    -0.03637558f, -0.03539233f, 0.01482326f, 0.04550941f, -0.00717273f, -0.01571303f, -0.04697357f, -0.01462071f, 
    -0.01204858f, -0.04953615f, 0.04595608f, -0.01034064f, -0.04877442f, 0.00948135f, 0.02647469f, 0.01957284f, 
    0.00471367f, 0.02431820f, -0.02307592f, -0.00450777f, -0.04156174f, 0.03769449f, -0.01798886f, -0.02611138f, 
    -0.05169516f, -0.03492448f, 0.04289996f, -0.02318294f, -0.03164525f, 0.02443848f, -0.04590619f, -0.02616557f, 
    -0.03187356f, 0.02943200f, 0.01834852f, -0.02724670f, 0.02885030f, 0.04007805f, 0.04045251f, -0.01829192f, 
    0.01938505f, -0.00103160f, 0.01641439f, -0.03529160f, -0.04463204f, -0.00785794f, 0.02813982f, -0.03803187f, 
    0.01031267f, 0.02192059f, 0.01445366f, 0.02353675f, -0.04033284f, 0.03265706f, -0.00618677f, -0.05221560f, 
    0.04767749f, -0.02575821f, 0.04171232f, -0.02540193f, -0.00081751f, 0.00385223f, -0.03673454f, 0.03028438f, 
    -0.00813397f, -0.04257357f, -0.05394356f, 0.01528472f, -0.05345258f, -0.02835265f, 0.01462267f, -0.05076877f, 
    0.00460784f, -0.00039248f, -0.04137151f, 0.04036077f, -0.01878567f, 0.04093112f, -0.00324725f, -0.01858793f, 
    0.00253792f, 0.01948509f, -0.00378639f, 0.03463612f, 0.00829392f, 0.02522295f, -0.03473178f, 0.00106674f, 
    -0.02946607f, -0.00927735f, -0.03280817f, 0.00988019f, -0.03348855f, -0.01363316f, 0.00085658f, 0.03971700f, 
    -0.05186104f, -0.03690035f, 0.01131168f, -0.01804126f, -0.05676150f, 0.02320249f, 0.03941856f, 0.02941220f, 
    -0.01969290f, -0.01761576f, 0.01133305f, -0.01388250f, -0.02687276f, -0.03465213f, -0.02103004f, -0.00653633f, 
    0.00029864f, -0.00823766f, 0.02716283f, 0.01379917f, -0.05159466f, -0.04076952f, -0.02224267f, -0.00849462f, 
    -0.05052159f, -0.02499457f, -0.02708349f, -0.02962120f, -0.01410518f, -0.04075518f, 0.03533034f, -0.00862196f, 
    -0.02842348f, -0.02048818f, 0.02249696f, 0.02329038f, 0.03930917f, -0.00657698f, 0.01292395f, 0.03606345f, 
    -0.02307065f, -0.04783135f, -0.02343372f, 0.04181233f, 0.03028175f, -0.03565371f, -0.01061156f, -0.05016964f, 
    0.02423387f, -0.02815014f, -0.00737580f, 0.02105546f, 0.04957785f, 0.04452586f, 0.02032074f, 0.01762851f, 
    0.02320806f, -0.04708292f, -0.01898836f, 0.00454903f, 0.03269888f, -0.02232152f, 0.02093863f, -0.02451971f, 
    -0.01732094f, -0.00622505f, -0.04068850f, 0.04559169f, -0.01260798f, -0.00376743f, -0.01664683f, -0.03233891f, 
    0.00571159f, -0.01506361f, -0.01146078f, 0.03465924f, -0.00794251f, 0.05795506f, 0.02659133f, 0.03020989f, 
    -0.02256939f, -0.01419210f, -0.00728740f, 0.00610388f, 0.04614607f, -0.00037811f, -0.04773439f, 0.01360704f, 
    0.02729715f, 0.02964598f, -0.00392522f, 0.00311274f, 0.01876304f, 0.02096497f, 0.02787981f, -0.04944066f, 
    -0.05434757f, 0.03940520f, -0.04827874f, -0.01496229f, 0.02162630f, 0.04074018f, -0.00097087f, -0.05364958f, 
    -0.04131604f, -0.02019571f, -0.02188358f, -0.03637878f, 0.01114352f, 0.01843931f, 0.04485714f, -0.05267315f, 
    -0.00006695f, 0.04571400f, 0.05047055f, -0.01138112f, 0.01396117f, -0.04757441f, 0.03669987f, 0.02890843f, 
    -0.00177358f, -0.03925264f, -0.00595713f, -0.03063536f, 0.05041194f, -0.00615318f, 0.01434722f, 0.03365478f, 
    0.02205313f, 0.02393533f, -0.00526577f, -0.04657767f, -0.04288214f, 0.00339369f, 0.02654762f, -0.03144983f, 
    0.02902582f, 0.03846465f, 0.05564921f, -0.03170402f, -0.05037378f, -0.02283764f, 0.01862637f, -0.03969388f, 
    -0.03820561f, -0.02713279f, 0.01575665f, -0.01056523f, 0.01060739f, -0.01386474f, 0.02870143f, -0.05093561f, 
    -0.01159506f, 0.01411231f, -0.04878772f, -0.01348294f, -0.04141781f, 0.04164964f, 0.01784918f, 0.02640527f, 
    -0.05612785f, -0.01558062f, 0.02288318f, -0.01780622f, -0.01473625f, -0.03417113f, -0.01819655f, 0.02479080f, 
    -0.04511031f, 0.01854304f, -0.00331097f, -0.00208394f, 0.00171913f, -0.01802505f, -0.04290150f, -0.01469580f, 
    -0.05327432f, -0.01300214f, -0.00978469f, -0.02086314f, -0.03764609f, -0.01060514f, 0.01549606f, -0.02507326f, 
    -0.04360758f, 0.02286311f, 0.02541833f, -0.05406689f, -0.01251030f, 0.02785250f, 0.00956004f, -0.04202111f, 
    -0.01706600f, -0.03421750f, -0.01419689f, 0.00276912f, -0.03562412f, -0.00967614f, 0.04005533f, -0.03260611f, 
    0.00273924f, 0.01195385f, 0.00106762f, 0.03768805f, 0.02276845f, 0.03164401f, 0.01616953f, -0.02660540f, 
    0.04126634f, 0.03628879f, -0.03726457f, -0.00743062f, 0.04279054f, 0.03058343f, -0.00389759f, 0.01234944f, 
    -0.02036064f, 0.00886410f, 0.03432731f, 0.00860947f, 0.03885665f, -0.01414497f, 0.00279366f, 0.05404853f, 
    -0.03310865f, 0.04375657f, -0.03591270f, -0.04594739f, -0.03167967f, -0.02566488f, 0.03355416f, -0.01020903f, 
    0.07471956f, -0.15003063f, -0.04715697f, 0.05164406f, -0.01055099f, 0.02419828f, 0.12422352f, 0.08015592f, 
    -0.05537863f, -0.00289591f, 0.06524508f, 0.05928881f, -0.15110104f, 0.35972601f, 0.04336582f, 0.16566262f, 
    -0.08705659f, -0.03550894f, 0.03849382f, 0.14493854f, -0.06072573f, -0.01335002f, 0.06349836f, 0.04126137f, 
    0.37640211f, 0.04880168f, 0.25453952f, 0.22083223f, -0.10882908f, 0.15202610f, 0.12140904f, 0.01558940f, 
    0.04281996f, 0.04700808f, -0.08544623f, 0.13471973f, 0.11165633f, 0.07808147f, -0.04192272f, -0.01698236f, 
    -0.06081127f, 0.08068296f, 0.05751251f, 0.06616037f, -0.08969994f, -0.04296264f, 0.02747669f, -0.00639490f, 
    -0.27164295f, 0.42027932f, -0.17872065f, -0.01160382f, -0.11716119f, -0.06030099f, 0.06530481f, 0.00516566f, 
    0.10983215f, -0.02908100f, 0.02116884f, -0.04724103f, 0.16389784f, 0.04550619f, 0.05160861f, 0.11229012f, 
    0.02533575f, 0.04350962f, 0.00159242f, 0.11964130f, 0.07994831f, 0.00874802f, 0.12090043f, 0.07054432f, 
    0.10781092f, -0.09378780f, -0.06572596f, -0.16825470f, -0.00106298f, 0.08709367f, 0.09077100f, 0.06805597f, 
    0.15401384f, 0.10887630f, 0.13440917f, 0.13415058f, 0.04711494f, 0.08005723f, -0.07135420f, 0.19250894f, 
    -0.02907310f, 0.11645055f, 0.06866160f, -0.08745629f, 0.13472877f, -0.08637924f, 0.01362311f, 0.14464600f, 
    -0.05223899f, 0.09370587f, 0.10183505f, 0.06294674f, -0.02929226f, -0.08800957f, 0.07934646f, -0.00716610f, 
    0.00759571f, 0.15110922f, 0.05649645f, -0.02890856f, 0.08845557f, -0.10659447f, -0.21322668f, 0.04170279f, 
    0.00203424f, -0.08240750f, 0.01116735f, 0.15355855f, 0.07211836f, 0.08893265f, 0.02972631f, -0.00070669f, 
    0.20007227f, -0.09487552f, 0.29612157f, 0.29100490f, 0.01147937f, 0.13610452f, -0.01585984f, -0.04248668f, 
    0.00270852f, -0.03577635f, 0.01388017f, 0.07317109f, 0.17289327f, -0.12078703f, -0.17382106f, -0.02950588f, 
    0.05777240f, 0.12989557f, 0.17141971f, -0.11802913f, -0.07887721f, 0.09037255f, 0.02369015f, -0.08687391f, 
    -0.25076061f, 0.03239189f, -0.08564532f, 0.01186650f, -0.04917876f, -0.05534686f, 0.08970972f, 0.05139527f, 
    0.05403018f, 0.03009408f, 0.01492370f, -0.04450167f, 0.20397887f, -0.11876272f, -0.01484488f, 0.03711429f, 
    -0.03896926f, 0.10609601f, 0.06828877f, 0.05863308f, 0.22825845f, 0.00834861f, 0.07750939f, 0.16384594f, 
    0.21319772f, -0.10409735f, 0.10918506f, 0.00848570f, 0.13474944f, 0.12878841f, -0.12348121f, -0.01370435f, 
    0.09477858f, -0.07440268f, 0.03874847f, 0.13167946f, -0.22806038f, 0.05483642f, -0.19251911f, -0.30726749f, 
    -0.09390566f, 0.08009410f, 0.01956621f, 0.07358196f, 0.00023898f, -0.05789094f, 0.04031355f, -0.13350500f, 
    -0.56134820f, -0.07762069f, 0.14620915f, 0.12590033f, -0.05063238f, 0.09238031f, -0.04167674f, -0.03446207f, 
    -0.00126324f, 0.06840505f, -0.08165013f, 0.06592712f, -0.12084075f, -0.03063176f, -0.09132376f, -0.05779497f, 
    -0.11859037f, 0.09441894f, -0.10103825f, 0.00426871f, 0.01986336f, -0.01624303f, 0.00539609f, 0.05840678f, 
    0.09257116f, -0.19765285f, -0.08191303f, -0.08234328f, 0.02839490f, -0.01766228f, 0.12590082f, -0.01877110f, 
    0.01363386f, 0.06253104f, 0.06716653f, 0.13813630f, -0.04832666f, 0.11590831f, -0.19041906f, 0.04812686f, 
    0.09967089f, 0.03841513f, -0.03503251f, 0.02341713f, 0.00736292f, -0.03171711f, 0.00794249f, -0.01545495f, 
    -0.22773027f, 0.31535575f, 0.12787808f, -0.10887906f, -0.07136256f, -0.02306939f, 0.08003142f, 0.08849468f, 
    -0.00379853f, 0.03137019f, 0.03399086f, 0.12336174f, -0.37862459f, 0.02671855f, 0.00825686f, 0.11082598f, 
    -0.02710172f, -0.04045906f, -0.07822285f, 0.09351816f, -0.02327198f, -0.00684245f, 0.10842742f, 0.03527623f, 
    0.27345926f, -0.08631241f, 0.06331856f, 0.01859834f, 0.02510242f, 0.00211359f, 0.08052094f, 0.04890844f, 
    0.09477897f, 0.16327770f, 0.10467251f, 0.09895796f, -0.03064137f, 0.04344860f, 0.04584556f, 0.00276914f, 
    0.13725990f, -0.04006752f, 0.04423669f, 0.04076377f, 0.02469026f, -0.02973245f, -0.01976934f, -0.13414069f, 
    0.10538515f, -0.04932307f, 0.15647657f, 0.23468690f, 0.07577245f, 0.17087106f, 0.10722082f, -0.03807242f, 
    -0.09857082f, -0.13079822f, -0.02500414f, 0.10239291f, -0.19108583f, -0.16517398f, -0.14178434f, 0.02348322f, 
    -0.01134816f, -0.02245454f, 0.06064907f, -0.04804309f, -0.10978401f, 0.03125324f, 0.01544553f, 0.07467753f, 
    -0.14297022f, -0.07740220f, -0.02565914f, 0.05461055f, -0.06269380f, 0.03900833f, 0.06878029f, 0.08011672f, 
    0.04831100f, -0.09836278f, 0.00201845f, 0.08893699f, 0.16347313f, 0.11639847f, 0.21927527f, 0.44504708f, 
    0.02939798f, 0.03423679f, 0.16033705f, -0.06776336f, 0.00786552f, -0.04686513f, -0.01436970f, -0.03823914f, 
    0.02099549f, -0.11334189f, 0.02041219f, -0.10531296f, -0.11825559f, 0.12702470f, 0.09056591f, 0.12176830f, 
    0.01428666f, 0.00238843f, 0.01373379f, 0.05570058f, -0.08764018f, -0.00097949f, 0.04437593f, 0.00231747f, 
    0.00709258f, 0.02970066f, -0.08471514f, 0.14603518f, -0.00260504f, 0.05178786f, -0.03576662f, 0.12421612f, 
    -0.00320986f, -0.09248155f, 0.04291665f, -0.04535860f, 0.06599503f, 0.00766607f, 0.11014885f, 0.03653682f, 
    -0.09320330f, 0.10491009f, -0.01943613f, -0.15730573f, 0.03875605f, -0.04327248f, -0.05185991f, 0.09325112f, 
    -0.01217709f, 0.04349284f, 0.04270006f, 0.17232791f, 0.06446043f, 0.06821775f, 0.06603140f, 0.02537308f, 
    -0.04231342f, -0.00864989f, 0.01430410f, 0.00686298f, -0.03389526f, 0.03999875f, -0.00163409f, -0.02246809f, 
    0.04082552f, 0.00942734f, 0.03289501f, 0.01479026f, -0.01643994f, 0.01542573f, -0.02481081f, -0.05381524f, 
    -0.00685723f, 0.02211396f, 0.01469125f, 0.00478701f, 0.01882055f, -0.01741273f, 0.00023408f, -0.00078623f, 
    -0.04136646f, 0.00181199f, -0.01746601f, 0.02940755f, 0.03992877f, 0.03096523f, 0.00680610f, 0.01307258f, 
    -0.00334029f, -0.04805291f, -0.03867339f, 0.01126953f, -0.05648426f, -0.00041753f, 0.02720511f, -0.04754346f, 
    -0.02441819f, 0.01285434f, -0.01926002f, -0.03066168f, -0.03016046f, -0.01685878f, -0.05490837f, 0.03459781f, 
    -0.02656844f, -0.00318355f, 0.02336128f, 0.00347430f, -0.03033943f, -0.02832413f, 0.01346939f, 0.03328335f, 
    -0.05171990f, -0.04192960f, -0.01465343f, 0.02196571f, 0.00290901f, -0.04572127f, -0.03086522f, 0.02109205f, 
    -0.05256510f, -0.04969648f, -0.01541373f, -0.02544897f, -0.04156491f, -0.03808913f, 0.03653537f, -0.00415009f, 
    -0.00452731f, -0.04330881f, 0.00828036f, -0.01248344f, 0.00027711f, 0.00490953f, -0.00271749f, -0.03438697f, 
    -0.02871967f, 0.02088046f, 0.00372055f, -0.00794959f, -0.00803073f, 0.03952707f, 0.01508666f, 0.03624107f, 
    -0.01485878f, -0.04772440f, -0.05646828f, -0.05463225f, 0.01387788f, 0.02615762f, -0.03413184f, -0.02134046f, 
    0.04257578f, -0.03538519f, 0.03174347f, 0.03310619f, 0.03086826f, -0.01516802f, 0.00506248f, -0.02203289f, 
    -0.04504425f, 0.03416163f, 0.04011466f, -0.01334434f, -0.00510131f, -0.02973091f, 0.02042236f, 0.01551103f, 
    -0.04253523f, -0.01819607f, 0.00849754f, -0.01793946f, -0.02691788f, 0.00451092f, 0.01587234f, 0.03523897f, 
    0.04121507f, -0.04008102f, 0.04038579f, 0.00687560f, -0.04655465f, -0.05335858f, 0.01698297f, 0.01531232f, 
    0.02090493f, -0.04338975f, -0.02230977f, -0.01132582f, -0.00616563f, -0.00014241f, 0.03796756f, -0.00642315f, 
    -0.04706529f, -0.03640234f, 0.00070371f, 0.00062930f, -0.00331909f, -0.04787283f, -0.00470138f, 0.01922260f, 
    -0.02754510f, -0.00782819f, -0.03792142f, -0.03561192f, -0.01888743f, 0.01572003f, -0.04223222f, -0.03384025f, 
    0.00153435f, 0.01767800f, -0.04145573f, -0.04318618f, 0.04040167f, -0.03809585f, 0.00192496f, 0.01498463f, 
    -0.01629510f, -0.00377791f, 0.00930485f, 0.02943811f, 0.03690793f, -0.02572488f, 0.03625359f, 0.00680443f, 
    0.02975170f, -0.02352770f, 0.00370248f, -0.04508369f, 0.01492787f, 0.04475324f, 0.01946577f, -0.01018730f, 
    0.03651436f, -0.01588666f, 0.00508053f, -0.01870783f, -0.05530763f, -0.01292618f, 0.02521698f, 0.02333548f, 
    -0.03884680f, -0.05188317f, -0.04914122f, -0.01003972f, -0.04248191f, -0.02027935f, 0.00939611f, -0.04706601f, 
    0.01453033f, 0.02193117f, -0.01343319f, -0.01123517f, -0.02934776f, -0.05637937f, -0.01712031f, -0.01421767f, 
    0.03442423f, 0.03386391f, -0.05431382f, 0.00264234f, -0.04464948f, -0.05507535f, -0.03936417f, 0.00888762f, 
    -0.03008377f, 0.01682121f, -0.00211911f, -0.04020459f, -0.04880046f, 0.00848451f, 0.04470264f, 0.00206271f, 
    0.00139967f, -0.01031570f, 0.04040851f, 0.02481342f, 0.01616686f, -0.01186828f, 0.01064114f, -0.05376289f, 
    0.00333621f, -0.01444919f, 0.00765773f, 0.03689188f, 0.00358009f, 0.04384745f, -0.01210882f, -0.04060555f, 
    0.03940941f, -0.05184411f, 0.01176778f, -0.04777138f, 0.00076979f, -0.01169202f, -0.00285924f, -0.02025377f, 
    0.00559215f, -0.05447980f, -0.00800428f, 0.01927107f, -0.01882092f, 0.03647481f, -0.00221826f, 0.01676968f, 
    -0.03754957f, 0.00733578f, -0.05113901f, -0.04342831f, -0.00284971f, 0.03182937f, -0.04114101f, -0.02773966f, 
    0.03369381f, 0.04158569f, 0.02073675f, 0.03797706f, -0.03514395f, -0.00091131f, -0.04852196f, -0.03135290f, 
    0.01113095f, 0.01671282f, -0.02073597f, -0.04571148f, -0.02876272f, -0.04897465f, -0.03881904f, 0.03292440f, 
    -0.04918510f, 0.02405757f, 0.01466165f, -0.03682535f, 0.03103169f, 0.03974241f, -0.05308133f, -0.02858034f, 
    -0.03444208f, -0.02065510f, -0.02271184f, -0.00459176f, -0.03503563f, 0.03652506f, -0.00493593f, 0.02162962f, 
    -0.04098985f, -0.00745914f, 0.01665651f, -0.04456662f, 0.03911623f, -0.01723923f, -0.04196251f, 0.03279629f, 
    -0.01004512f, -0.01797912f, 0.01477073f, -0.01727284f, -0.04980430f, -0.02592757f, 0.00152606f, -0.04270147f, 
    0.03280625f, -0.04821996f, -0.03139185f, 0.02998636f, 0.00028346f, -0.04829449f, -0.05092353f, -0.02558474f, 
    0.02914170f, -0.01225574f, -0.01983303f, 0.01106501f, -0.05355095f, -0.03072900f, 0.04206099f, -0.01651709f, 
    -0.02858681f, -0.04504960f, -0.01117138f, 0.03931757f, -0.03605068f, 0.02075848f, -0.04455335f, 0.04862407f, 
    0.01127905f, 0.02737156f, 0.03015902f, -0.05594995f, 0.03497976f, 0.00119364f, -0.01895246f, 0.01400750f, 
    -0.04893237f, -0.03918147f, -0.02255006f, 0.04007115f, -0.03892365f, -0.05459946f, -0.01019441f, 0.00939705f, 
    -0.03171676f, -0.01715015f, -0.01773984f, 0.03228788f, 0.03512383f, 0.03828821f, -0.00086415f, 0.00403264f, 
    0.03639448f, -0.04140592f, 0.03852766f, -0.05278252f, -0.01708822f, -0.01249026f, -0.01863688f, 0.00354300f, 
    -0.05573962f, -0.02326078f, -0.03291781f, 0.04426034f, -0.02498934f, 0.02287804f, 0.00943412f, -0.03420188f, 
    0.02796136f, 0.05200001f, -0.03434670f, 0.01398784f, 0.03859020f, 0.03083704f, 0.02323537f, -0.03126485f, 
    -0.02365542f, 0.00774964f, -0.03715423f, 0.04209188f, -0.04790896f, -0.04714755f, 0.03337845f, 0.00534404f, 
    -0.12651342f, 0.11144535f, 0.05715448f, 0.23863970f, -0.05188132f, -0.03401059f, 0.13237573f, 0.12851508f, 
    0.01967971f, -0.01197463f, -0.04571908f, -0.09144112f, 0.25169954f, 0.06262845f, 0.11159594f, 0.10660756f, 
    -0.03228201f, -0.04854742f, 0.06670125f, -0.02692752f, 0.05358440f, -0.04593458f, 0.02900229f, 0.11005170f, 
    0.23134442f, 0.41824135f, -0.14900543f, -0.08845681f, 0.13960616f, -0.02879682f, -0.09214505f, 0.02544806f, 
    0.07269092f, 0.01910442f, 0.10586065f, -0.05604075f, 0.10000024f, 0.13807537f, 0.05370860f, 0.10999141f, 
    0.12183441f, -0.09327961f, -0.00809466f, 0.10104425f, 0.03138491f, 0.03855087f, -0.01084734f, -0.02897479f, 
    -0.04708175f, -0.00045839f, 0.04138359f, -0.09529960f, 0.03176345f, -0.01608628f, -0.01063504f, 0.06405696f, 
    -0.05102314f, 0.03217806f, -0.03188181f, 0.03357574f, -0.32251719f, -0.11161529f, 0.06086298f, 0.05789517f, 
    0.09094889f, -0.01142654f, 0.08256746f, -0.03794430f, 0.09155475f, 0.02180437f, 0.14489923f, -0.02283462f, 
    0.04396580f, 0.01358037f, 0.06837770f, 0.23438676f, 0.00457941f, 0.13823614f, 0.05647810f, -0.00490845f, 
    0.01727969f, -0.08734170f, 0.02315714f, -0.04260940f, -0.16078769f, -0.13151179f, -0.00200745f, 0.15202679f, 
    0.06737931f, 0.04634914f, -0.00677441f, 0.00263998f, -0.01848218f, 0.06148233f, -0.00921358f, 0.10094831f, 
    -0.12856403f, -0.16405754f, -0.25152278f, 0.02462402f, 0.02424271f, 0.00942225f, -0.03801908f, -0.00442831f, 
    0.00999863f, -0.01587098f, 0.02539831f, 0.03220711f, 0.04348323f, 0.12917529f, 0.11270389f, 0.39636639f, 
    0.00825469f, -0.02793566f, -0.01527395f, 0.04168148f, -0.02360180f, 0.04444026f, 0.02181740f, -0.02286475f, 
    -0.20763193f, 0.16513959f, 0.03576497f, 0.09876810f, 0.03210077f, -0.01633023f, -0.08445001f, -0.08272868f, 
    0.09116487f, 0.01551621f, -0.02912988f, 0.07012286f, -0.30687502f, 0.01078094f, -0.11469372f, -0.18846484f, 
    -0.11331401f, -0.02812160f, -0.03314896f, -0.00851201f, 0.03858352f, 0.05796754f, 0.09649416f, -0.01592521f, 
    -0.09309353f, 0.24780667f, 0.04931330f, -0.03656973f, -0.08316723f, -0.03523386f, -0.03074481f, 0.10265974f, 
    -0.02538238f, 0.03069073f, -0.06425998f, -0.05262130f, -0.16034359f, -0.14102393f, -0.17570804f, -0.04736206f, 
    0.05627068f, -0.06786530f, -0.03863255f, 0.01322718f, -0.00993332f, 0.01049908f, 0.00044699f, 0.06612054f, 
    -0.18282828f, 0.07595892f, 0.16696970f, 0.16747290f, -0.03926483f, -0.02187335f, 0.05014395f, -0.10509563f, 
    0.04443541f, -0.07984714f, 0.08308141f, 0.01648875f, 0.19332124f, 0.04162480f, 0.10916528f, -0.02527265f, 
    0.09090560f, 0.11750721f, 0.01975638f, 0.18610905f, -0.00685479f, 0.01637749f, 0.05278311f, -0.00439594f, 
    -0.13580714f, 0.21076749f, 0.10023905f, -0.09004208f, 0.08908501f, 0.05497718f, -0.12932269f, 0.03929498f, 
    0.10706414f, 0.01005955f, -0.04994453f, -0.03133475f, 0.15379784f, 0.15519790f, 0.23917466f, 0.07472669f, 
    0.07065000f, 0.04486030f, 0.05444720f, 0.01069856f, 0.04579655f, 0.05619606f, 0.03939368f, -0.12108580f, 
    -0.18285406f, 0.24148136f, 0.24750772f, 0.11316048f, -0.08987224f, -0.00548519f, 0.02866855f, -0.03164292f, 
    0.02533173f, -0.00871694f, -0.03122101f, 0.09444850f, 0.36196488f, 0.00873263f, 0.13233237f, 0.02934102f, 
    0.06639146f, 0.03968829f, 0.02409794f, -0.01951995f, -0.00144837f, 0.17366922f, -0.07747472f, 0.02590572f, 
    0.11433890f, 0.24865130f, 0.03778721f, -0.05309759f, -0.01673245f, 0.02747823f, 0.04448278f, 0.19474930f, 
    -0.08423042f, 0.01187242f, 0.07759554f, -0.00492297f, -0.07110567f, -0.09175216f, -0.11771750f, -0.14630978f, 
    0.02139551f, -0.02532858f, -0.09250978f, -0.00001261f, 0.00812326f, 0.02138397f, 0.07832062f, 0.06573916f, 
    -0.17805414f, -0.04138988f, -0.09644629f, -0.02440175f, -0.00854485f, -0.03152865f, -0.13226850f, -0.05906772f, 
    -0.01143935f, 0.06966192f, -0.05823183f, 0.10975172f, -0.07578430f, 0.01947411f, -0.03914626f, 0.00663044f, 
    0.06379287f, -0.02001526f, 0.06947536f, -0.04314373f, -0.07382493f, 0.08592381f, -0.03982050f, 0.03790219f, 
    0.03197050f, 0.26332033f, -0.01823580f, 0.04020420f, 0.02475146f, -0.11550184f, -0.00188034f, 0.06051691f, 
    0.03309481f, 0.00499743f, 0.00554600f, 0.00476419f, -0.08023426f, 0.04106269f, -0.04608331f, 0.15299268f, 
    0.01713311f, 0.04894911f, -0.05306207f, -0.04437117f, 0.05820125f, 0.10209488f, 0.00967597f, -0.02270151f, 
    -0.08766409f, -0.04829489f, -0.01968488f, -0.05485173f, -0.06222180f, -0.00892462f, -0.06329674f, -0.05029637f, 
    0.01067540f, 0.00824840f, 0.00085963f, 0.11281633f, -0.07881599f, -0.21352467f, 0.01113473f, 0.24400221f, 
    0.01463170f, -0.03390553f, -0.05783048f, -0.06460795f, 0.08233192f, 0.08893065f, 0.13471347f, -0.01862563f, 
    -0.03843411f, -0.00011037f, -0.11506484f, -0.10236519f, 0.01396547f, -0.09846954f, -0.03905862f, -0.09595288f, 
    -0.03624452f, -0.00103477f, -0.01155809f, -0.05359414f, 0.09485048f, -0.04308245f, 0.04974340f, -0.09013586f, 
    0.07895838f, -0.07038415f, 0.10122135f, 0.00273000f, -0.08374725f, 0.02745285f, 0.04417927f, -0.06525583f, 
    0.18359886f, -0.15758318f, -0.16070114f, -0.08945870f, 0.08976094f, -0.00219909f, -0.07449707f, 0.06361722f, 
    -0.00383615f, 0.04264493f, -0.04480463f, 0.06002317f, 0.24651149f, 0.11072172f, 0.08116665f, 0.07127628f, 
    0.05132563f, -0.04235363f, -0.00922640f, -0.03024966f, 0.09106053f, 0.05363557f, 0.06453134f, -0.01653042f, 
    0.02654683f, 0.03495087f, -0.03942080f, 0.05368605f, -0.00017553f, -0.00555658f, -0.03861571f, 0.02246603f, 
    0.02805223f, 0.01815313f, 0.00912112f, 0.00272891f, -0.02505149f, -0.01926672f, -0.02099836f, 0.01343098f, 
    0.00659926f, 0.03221678f, -0.05390518f, 0.02327230f, -0.05254931f, 0.02332061f, 0.03275841f, 0.02944803f, 
    -0.00105933f, 0.02375901f, -0.03369693f, 0.03856790f, 0.00792540f, -0.00930508f, 0.02082204f, -0.04211302f, 
    0.01158126f, 0.02560071f, 0.01440276f, -0.03265955f, -0.03423201f, -0.00619350f, -0.02860360f, 0.01848300f, 
    -0.04731710f, -0.05072739f, 0.02567518f, 0.02341601f, -0.01973924f, 0.00576251f, 0.03653640f, -0.01496221f, 
    -0.03709001f, -0.04670665f, -0.02430814f, -0.01262975f, -0.04840212f, -0.03904036f, -0.02851398f, 0.01649112f, 
    -0.04585247f, 0.00477845f, 0.00733476f, -0.01023430f, 0.01310377f, 0.03452488f, 0.04448917f, 0.01782837f, 
    0.00582072f, 0.01829562f, 0.04023596f, -0.03962652f, -0.00241680f, -0.05697547f, -0.03355786f, -0.02017475f, 
    -0.02659937f, 0.01400845f, 0.05065827f, -0.02682910f, 0.02629635f, -0.00521807f, 0.02472655f, -0.03556437f, 
    0.02791796f, -0.01219873f, -0.01028850f, -0.03963296f, 0.01601195f, 0.02489823f, -0.01826699f, 0.03872643f, 
    -0.04641891f, 0.04252366f, -0.04506867f, -0.03783745f, -0.02157420f, -0.05392111f, -0.00779768f, -0.01661797f, 
    -0.05293910f, 0.03616608f, -0.04321456f, 0.00133559f, -0.03636793f, -0.05268117f, -0.03488465f, -0.03603592f, 
    0.04143887f, -0.01358757f, 0.01366549f, 0.00808472f, -0.04662449f, 0.02551889f, -0.02940984f, -0.01387343f, 
    0.00115594f, -0.03583333f, 0.02721279f, -0.05502328f, -0.04005763f, -0.01766354f, 0.05246201f, -0.04702272f, 
    0.02106313f, -0.00268780f, -0.05394278f, 0.01010670f, -0.05921413f, 0.03235327f, -0.03657239f, 0.01317031f, 
    -0.04464246f, 0.02879709f, -0.03791736f, 0.01897094f, 0.00828068f, -0.01819746f, -0.03660538f, 0.04328753f, 
    0.00663204f, -0.03945373f, -0.01788170f, 0.01949198f, 0.03380486f, -0.01798270f, -0.05613676f, 0.03892180f, 
    0.02064708f, 0.04207408f, -0.03494501f, 0.01866875f, -0.00287223f, 0.00219129f, 0.01207603f, -0.04323385f, 
    -0.04080111f, 0.00204048f, 0.02534028f, -0.00412668f, 0.02510265f, -0.03499557f, -0.05287871f, -0.04345514f, 
    -0.00110492f, -0.01390512f, -0.04077559f, 0.02965719f, 0.03297426f, 0.00492515f, -0.00356314f, 0.00237492f, 
    -0.01774395f, -0.01723909f, -0.05835651f, -0.00241517f, 0.03368468f, -0.01885450f, 0.03677901f, -0.03732927f, 
    -0.00302383f, -0.02934852f, 0.01278930f, -0.02818873f, -0.00004384f, 0.03704652f, 0.01294641f, -0.03903242f, 
    0.04657449f, -0.03517099f, 0.02418759f, 0.01027237f, -0.00587083f, -0.00479727f, -0.00677711f, -0.01553179f, 
    -0.03346297f, -0.00367093f, 0.03541984f, 0.03905372f, 0.03409095f, 0.03666666f, -0.03316464f, 0.02601166f, 
    -0.04621832f, 0.04953986f, 0.01013634f, -0.00679969f, 0.01593003f, 0.00109092f, -0.03125267f, -0.04359881f, 
    0.00017626f, 0.03653968f, -0.03005398f, 0.01027256f, -0.04329713f, 0.03829236f, -0.03901483f, 0.00635458f, 
    -0.04243230f, -0.06636635f, -0.03623281f, 0.04333388f, 0.04142860f, 0.01569288f, -0.03601203f, -0.04588247f, 
    0.03644858f, -0.05263937f, -0.03569960f, -0.01728429f, 0.03133079f, 0.01859615f, -0.03058911f, -0.04843503f, 
    0.02162652f, -0.05670654f, -0.00381397f, 0.03527652f, 0.01047644f, -0.05179062f, 0.00544099f, 0.00620112f, 
    0.03579708f, 0.01088030f, 0.01480970f, 0.01962892f, 0.04365477f, -0.01221278f, 0.01185852f, -0.03907102f, 
    0.03858101f, -0.00514941f, -0.05104658f, 0.00655110f, -0.03391996f, 0.00410372f, 0.02922888f, -0.02190402f, 
    0.02178388f, -0.04873987f, -0.02694847f, 0.04357177f, -0.04018142f, -0.01399059f, -0.02020004f, -0.05177871f, 
    0.01532356f, -0.01524566f, -0.01929854f, 0.01647822f, 0.00241040f, 0.03755898f, -0.00516549f, -0.03632501f, 
    -0.01179831f, -0.03220564f, -0.00965087f, -0.04399205f, -0.02911298f, 0.02774123f, -0.00087475f, 0.01841572f, 
    0.03096157f, -0.03065590f, 0.00791777f, 0.00837964f, 0.00642816f, -0.04301368f, -0.04324672f, -0.04884675f, 
    0.03860654f, 0.03293630f, -0.03360395f, 0.00036987f, -0.04347410f, 0.01443973f, -0.03010851f, 0.01859096f, 
    0.04214713f, 0.00593902f, -0.00623668f, -0.00993956f, 0.02353350f, -0.03272153f, -0.01110032f, 0.01942815f, 
    -0.03771081f, 0.00396159f, -0.03047761f, 0.03987809f, 0.03857066f, 0.03618103f, -0.04514508f, -0.05706905f, 
    0.00199390f, -0.01464654f, 0.02963506f, 0.02087169f, -0.02492015f, -0.02876973f, 0.00685417f, -0.04932978f, 
    0.03699594f, -0.04038421f, -0.00105000f, 0.02240906f, -0.01443638f, 0.04427254f, -0.00871185f, 0.04312038f, 
    -0.03257914f, -0.04271965f, 0.02546871f, -0.01142892f, 0.04077712f, -0.03434477f, 0.00247207f, -0.00863835f, 
    -0.02556602f, -0.05352087f, 0.01768926f, -0.01741752f, -0.03184437f, -0.05683615f, 0.04571447f, 0.01430581f, 
    0.00083606f, -0.02240347f, -0.05343414f, -0.01185707f, 0.01624035f, 0.04373219f, 0.03931486f, -0.04213098f, 
    0.02441532f, 0.04829601f, 0.02691276f, 0.05217892f, 0.00289259f, -0.05639942f, -0.04542032f, 0.01152332f, 
    -0.02397170f, -0.03564743f, -0.01323573f, 0.00352280f, -0.05456801f, -0.02712769f, 0.00323164f, -0.00847001f, 
    -0.02916042f, -0.05687117f, -0.02236131f, 0.02954208f, -0.02351690f, 0.00300337f, 0.02378036f, 0.04571885f, 
    -0.03041493f, -0.02738301f, 0.03580321f, -0.03363322f, -0.06102863f, -0.02333981f, -0.02670278f, 0.02954029f, 
    -0.13842447f, -0.13961478f, -0.04084185f, 0.02188858f, 0.11271504f, -0.02655501f, 0.02059069f, 0.14892185f, 
    -0.02249400f, 0.03900779f, 0.15830293f, 0.07262269f, -0.23951420f, 0.13537857f, 0.08839212f, 0.05542083f, 
    -0.00199911f, -0.05867978f, -0.06550273f, 0.02900236f, -0.10661645f, -0.18744107f, 0.10361127f, -0.15263782f, 
    0.25437388f, -0.02674060f, 0.09681021f, 0.11384249f, -0.10451311f, 0.08228216f, -0.04472411f, 0.05133865f, 
    0.02348542f, -0.12925050f, 0.10698331f, 0.09189899f, 0.12915254f, -0.14980659f, 0.13943897f, -0.11864955f, 
    -0.00491595f, 0.04847890f, 0.08480955f, 0.16664408f, 0.05361980f, 0.09276854f, -0.11490297f, 0.16111350f, 
    -0.46352267f, 0.30222890f, 0.00948538f, 0.11234101f, -0.08716063f, -0.02882714f, -0.00783924f, 0.03801577f, 
    0.02005596f, -0.01551600f, 0.02491764f, 0.13029079f, 0.21308069f, 0.00990920f, -0.04378656f, 0.09007142f, 
    0.07556920f, -0.01650191f, -0.05169536f, -0.03743595f, -0.05802061f, 0.00347754f, -0.01472019f, -0.01739880f, 
    0.00371258f, -0.14845353f, -0.04437192f, -0.21445802f, -0.06930389f, -0.00114029f, -0.03313176f, -0.05687256f, 
    0.05281879f, -0.02259903f, 0.06579600f, 0.09840553f, 0.01900310f, -0.00106513f, -0.07719156f, -0.01408131f, 
    -0.06533497f, -0.00102689f, 0.11833043f, -0.02900104f, 0.03368169f, 0.21172586f, 0.00000970f, 0.07937852f, 
    0.15969597f, 0.02330079f, -0.11256187f, 0.20014386f, -0.04841183f, -0.02048980f, 0.00220667f, 0.02669937f, 
    0.03545988f, -0.08714806f, -0.10661862f, 0.02299681f, 0.06224600f, -0.04055331f, 0.02542486f, 0.18540931f, 
    -0.08486404f, -0.06378693f, -0.05503314f, 0.04591413f, 0.03942321f, 0.04145042f, -0.02030341f, 0.14043780f, 
    -0.06913859f, -0.06996100f, 0.04224938f, 0.21260604f, 0.16818096f, 0.05181778f, 0.05407774f, -0.07181588f, 
    -0.03623826f, -0.03441702f, -0.04034363f, -0.12894556f, 0.19360077f, 0.01348148f, 0.07458988f, -0.20883079f, 
    0.04973923f, 0.07189271f, 0.05634553f, -0.02439232f, -0.12847643f, 0.18268120f, 0.08958413f, -0.00324589f, 
    -0.06531076f, -0.02902615f, 0.08155268f, -0.06072503f, 0.03919984f, -0.06950027f, 0.08568931f, 0.06081381f, 
    0.05726607f, -0.00020739f, 0.06361288f, 0.07364641f, 0.15919931f, -0.07580090f, -0.15748540f, 0.16405760f, 
    -0.06350202f, 0.00801128f, -0.04005469f, -0.03404486f, 0.08514406f, -0.04714154f, -0.07823166f, 0.08489653f, 
    0.17479515f, 0.00462722f, -0.02552966f, 0.11362974f, 0.08937185f, 0.08822513f, 0.05095370f, 0.03122722f, 
    0.07375170f, -0.10585571f, 0.09033703f, 0.04609109f, -0.05910845f, 0.13739370f, -0.08077118f, -0.11423143f, 
    -0.05756877f, 0.05981649f, -0.12320761f, 0.01339883f, 0.01870570f, -0.16133289f, 0.02458053f, -0.00220849f, 
    0.17248206f, -0.01787837f, -0.01234942f, -0.09522084f, 0.08249357f, -0.03261553f, -0.00180696f, 0.00126759f, 
    -0.05216118f, 0.15019913f, -0.06518750f, 0.07556753f, -0.06449293f, -0.07521814f, 0.03889756f, -0.17102589f, 
    -0.03513533f, -0.02754566f, -0.05811464f, 0.03966178f, -0.05506650f, 0.06167639f, -0.09876599f, 0.02978487f, 
    -0.04837334f, -0.14851427f, 0.24674439f, 0.02616554f, 0.06082121f, -0.00966640f, -0.02351980f, 0.09220252f, 
    -0.06889749f, -0.03610902f, 0.04849496f, 0.05038795f, -0.26227540f, 0.03145566f, -0.08546828f, 0.05902405f, 
    0.07396398f, -0.08391265f, 0.05133671f, 0.00516478f, 0.02669579f, 0.06945589f, -0.07954372f, 0.03592111f, 
    -0.04789558f, 0.17289339f, 0.16167654f, -0.08644412f, -0.00404037f, 0.04818077f, -0.06915332f, 0.11410548f, 
    -0.09693966f, -0.03299733f, -0.13212918f, 0.05400352f, 0.18378565f, -0.05222166f, -0.15565974f, -0.08579966f, 
    0.03513457f, -0.10188196f, -0.03354098f, 0.01589226f, -0.01258915f, -0.05168496f, -0.04781050f, -0.00723566f, 
    0.16042882f, -0.07726088f, -0.19741268f, 0.00798379f, 0.00887353f, -0.06231815f, 0.08598032f, 0.00243367f, 
    -0.05610287f, 0.13350123f, 0.05198718f, 0.09757063f, -0.26273289f, 0.13408332f, 0.01994714f, 0.12652066f, 
    0.02569945f, 0.10684818f, 0.05850687f, -0.04184894f, -0.01716327f, 0.01440847f, 0.19719918f, -0.08277507f, 
    0.08254857f, 0.08757801f, 0.12226386f, 0.07870695f, 0.09207489f, -0.09456751f, -0.06092089f, 0.03559792f, 
    -0.01923028f, -0.06563396f, -0.08533865f, -0.00978123f, -0.11646444f, 0.12322652f, 0.07407222f, 0.09878017f, 
    -0.05004716f, -0.12950534f, 0.05431481f, 0.05058206f, -0.10329966f, 0.11498939f, -0.04581926f, 0.15048383f, 
    0.23682471f, -0.05492608f, 0.02606777f, -0.05575707f, -0.03938003f, 0.00582628f, -0.00506335f, -0.01318531f, 
    -0.02984769f, -0.13707398f, -0.09759994f, 0.01306892f, 0.18000655f, 0.03039807f, 0.00051814f, 0.03631087f, 
    -0.01096679f, -0.00340337f, 0.05424432f, -0.07728405f, 0.06939103f, -0.03794968f, 0.02514457f, -0.22329137f, 
    0.10538172f, 0.03600932f, -0.04355697f, 0.02102078f, 0.00263709f, -0.10216340f, 0.06189062f, 0.10327984f, 
    0.07950137f, 0.12335057f, -0.03603463f, 0.08936324f, 0.04895160f, -0.00032472f, -0.02203969f, -0.03555959f, 
    -0.00667914f, -0.09530360f, 0.01633219f, -0.04414998f, 0.13140698f, -0.05997803f, -0.04559312f, -0.11518286f, 
    0.02737708f, -0.06550806f, -0.07808836f, 0.00009652f, 0.06204160f, 0.09300072f, -0.11103439f, -0.00041109f, 
    0.06897054f, 0.13217153f, -0.00844199f, -0.12292466f, 0.15928638f, -0.08229861f, -0.09309133f, -0.02661660f, 
    -0.18882945f, 0.02407849f, 0.02182785f, 0.10946278f, 0.02656547f, 0.00296900f, 0.01215174f, -0.08460192f, 
    -0.08837254f, 0.10635813f, 0.06100592f, 0.20567033f, 0.01684683f, -0.03439441f, 0.02433916f, 0.07060491f, 
    0.06498352f, 0.02729882f, 0.03128641f, 0.02268318f, 0.01175789f, -0.08360106f, 0.12393008f, 0.03449634f, 
    -0.00459597f, -0.15382092f, 0.02667197f, -0.10020546f, -0.14263795f, -0.09644423f, -0.03214212f, -0.11234295f, 
    0.31373450f, 0.09217546f, -0.00722369f, -0.00660786f, -0.05064503f, -0.02686884f, -0.13114998f, 0.01529553f, 
    -0.08102225f, -0.05343575f, 0.06186087f, 0.04769152f, -0.47326934f, -0.07912444f, 0.10077477f, 0.12770565f, 
    0.11341117f, 0.02728227f, 0.04243706f, 0.13990244f, 0.08291905f, 0.07953193f, 0.01889771f, 0.08669055f, 
    -0.29995644f, -0.02730163f, 0.12156232f, 0.03179334f, 0.04424826f, 0.10285327f, -0.01122593f, -0.00400376f, 
    0.01720662f, -0.02236750f, -0.07125921f, 0.07781432f, 0.04884835f, -0.04937960f, -0.19502790f, -0.02915423f, 
    0.03129200f, -0.03011934f, -0.00951901f, -0.04833131f, -0.04431110f, 0.00649652f, 0.03421099f, 0.01104161f, 
    0.06476528f, 0.09399095f, 0.03211049f, 0.06365752f, -0.09675661f, 0.09170152f, -0.03301289f, 0.01247745f, 
    0.05457624f, -0.08674012f, 0.10695568f, 0.05641054f, -0.06628783f, 0.01604884f, -0.08945361f, -0.07433055f, 
    0.04553429f, -0.08765923f, -0.02282167f, 0.05580574f, -0.01196962f, 0.00054013f, -0.01070876f, 0.03824138f, 
    0.16793363f, -0.09337276f, -0.03976071f, 0.03106642f, -0.01156008f, -0.12834829f, -0.09745791f, 0.03602835f, 
    0.10865442f, -0.00489268f, -0.09506220f, -0.09155495f, 0.11629453f, 0.19691333f, 0.09172312f, 0.09502037f, 
    -0.09208375f, -0.04832539f, -0.03581486f, 0.07198852f, 0.05021107f, 0.09635444f, 0.00238572f, 0.04757854f, 
    -0.28118578f, -0.09651279f, 0.02726319f, -0.01705202f, 0.08593958f, -0.07534621f, -0.00433962f, -0.17103013f, 
    -0.05318405f, -0.00168153f, -0.10226993f, -0.07036331f, 0.20403062f, 0.00650533f, -0.23847347f, 0.03067574f, 
    0.05131007f, 0.06583838f, 0.04291947f, 0.16303247f, 0.05858586f, 0.12318229f, -0.00777816f, 0.09938056f, 
    -0.15935507f, 0.07602624f, -0.06349041f, -0.08966179f, -0.04796936f, -0.00641331f, 0.05549110f, 0.07082299f, 
    0.03718795f, 0.09040850f, 0.03216383f, 0.09195426f, 0.10207909f, -0.17587012f, -0.13093135f, 0.18577704f, 
    0.05767997f, -0.02754149f, 0.04747412f, -0.01720759f, 0.01250849f, -0.01620197f, -0.04636159f, -0.12681307f, 
    0.13966399f, 0.04312278f, 0.00015049f, 0.00370546f, 0.05295013f, 0.05285385f, 0.17275830f, -0.03005419f, 
    0.08671726f, -0.05204488f, 0.04391284f, 0.00307547f, 0.01686102f, 0.07009277f, 0.32802024f, 0.05641823f, 
    0.02005093f, -0.04618667f, 0.00279321f, 0.06081929f, -0.09395345f, -0.04081913f, 0.02890199f, 0.02514715f, 
    0.04874528f, 0.01900055f, -0.17114572f, -0.06180745f, -0.05862461f, -0.05947154f, -0.13868624f, 0.17350775f, 
    -0.00773446f, -0.09560308f, 0.05625214f, 0.07593557f, 0.15111612f, 0.08783849f, 0.36383647f, 0.10806751f, 
    0.05735796f, 0.05640022f, 0.03636155f, -0.02058789f, 0.04943147f, -0.01289343f, -0.01099145f, -0.03454877f, 
    0.02531380f, 0.02814679f, 0.03373559f, 0.22805600f, 0.13799536f, -0.00960792f, -0.04426328f, 0.15888959f, 
    0.00409454f, -0.05642530f, -0.00369960f, 0.07565529f, -0.11607148f, 0.21533886f, 0.25916788f, 0.02362287f, 
    0.12806523f, -0.02118280f, 0.14219685f, -0.05529666f, -0.08772031f, -0.01085122f, -0.05957779f, -0.00833008f, 
    -0.31494182f, -0.00797463f, 0.00234018f, -0.01995340f, 0.08362917f, 0.18052216f, -0.01761649f, 0.13686280f, 
    -0.08878458f, 0.04168575f, -0.02370544f, 0.02697450f, 0.11294805f, -0.21349853f, -0.03465433f, -0.09634693f, 
    0.03480141f, -0.03423421f, -0.06358992f, -0.12626974f, 0.04298354f, -0.10775007f, 0.09401042f, -0.03005585f, 
    0.12311807f, -0.00841446f, -0.24240433f, -0.15169860f, -0.02883610f, -0.11548651f, -0.12357824f, -0.01009088f, 
    0.02754821f, 0.09120630f, 0.14667772f, 0.09643330f, -0.13426490f, 0.22671998f, -0.05779270f, 0.00131881f, 
    -0.01911521f, -0.03881763f, 0.08287271f, 0.06109447f, -0.01462412f, 0.04628329f, -0.00474161f, 0.02258225f, 
    -0.05430881f, 0.15423475f, -0.10164456f, 0.21302719f, 0.02462875f, -0.06247021f, -0.13099115f, 0.11265895f, 
    -0.01882917f, -0.07617734f, 0.02623094f, -0.07566320f, 0.17430606f, 0.21169476f, -0.10262451f, 0.35130945f, 
    -0.13478467f, 0.03046953f, -0.08483955f, 0.05866768f, 0.02844302f, 0.09483927f, 0.00397534f, -0.03603753f, 
    0.28612170f, -0.09722439f, 0.15154625f, -0.22816215f, -0.01619717f, -0.08579733f, -0.05728584f, 0.04779213f, 
    -0.06095485f, -0.05462697f, -0.02641672f, -0.09658980f, -0.10952064f, -0.08106259f, -0.15918459f, 0.22858998f, 
    -0.02843660f, -0.06352215f, -0.04644109f, -0.16203862f, 0.06290671f, 0.12847698f, -0.00531364f, -0.10190871f, 
    0.12218039f, -0.21043366f, 0.09710696f, -0.15349633f, 0.01657883f, -0.18815352f, -0.10334035f, -0.01353556f, 
    0.01818054f, 0.12847608f, 0.10342859f, 0.00084355f, 0.00818737f, 0.10969128f, 0.17812020f, 0.00931183f, 
    0.09310076f, -0.02877015f, 0.04549054f, -0.00161701f, 0.06243464f, -0.02946965f, 0.00773907f, -0.14182980f, 
    0.11221732f, -0.05141416f, -0.09612744f, -0.06200329f, -0.01842293f, -0.02347990f, -0.05635954f, 0.04892630f, 
    -0.00438807f, -0.00641635f, -0.15262946f, -0.00519670f, 0.15453228f, 0.34467691f, 0.08834568f, -0.01189554f, 
    -0.01107886f, -0.01018385f, -0.01849285f, 0.03107714f, 0.14171357f, -0.01299895f, -0.03126466f, 0.05141483f, 
    0.27194470f, -0.03349254f, 0.02587707f, -0.00244392f, 0.01576071f, 0.02612249f, 0.01046180f, 0.01295589f, 
    0.12399170f, 0.04310716f, -0.07744545f, -0.16281763f, 0.02808923f, 0.11461570f, -0.13906148f, -0.18454200f, 
    0.10646329f, 0.08024736f, -0.07852545f, 0.15126404f, -0.01148929f, 0.08451878f, 0.13192666f, 0.13813333f, 
    -0.09927085f, -0.04103315f, -0.12327097f, 0.00000944f, 0.09301046f, 0.05625173f, 0.06017021f, -0.03994289f, 
    0.02940444f, 0.08280998f, -0.08210002f, -0.02177708f, -0.24559483f, -0.03461251f, -0.02066127f, -0.19737972f, 
    0.01153209f, 0.00768535f, 0.00110061f, -0.09318779f, 0.09245813f, 0.05086535f, 0.04397247f, -0.12777568f, 
    0.17304446f, 0.09566219f, -0.02824359f, 0.16300790f, -0.09884325f, 0.04977719f, 0.00449463f, 0.00476725f, 
    0.03092590f, -0.01491791f, -0.06897582f, 0.01039257f, 0.12574022f, -0.11649577f, -0.10766479f, 0.01149791f, 
    0.07881843f, 0.08731523f, 0.14048895f, 0.06623201f, 0.06686367f, 0.00582323f, -0.03424814f, 0.01120072f, 
    -0.05288526f, -0.10661475f, -0.06211710f, -0.11202373f, -0.00491688f, 0.02723916f, 0.05816693f, 0.04448416f, 
    0.08993062f, 0.10038453f, -0.02358280f, -0.06336273f, 0.06906332f, 0.03015238f, 0.18953303f, -0.00526230f, 
    0.13166288f, -0.01397358f, 0.12282124f, -0.00224879f, -0.01220779f, -0.10369100f, 0.05061758f, -0.14650676f, 
    0.01899364f, -0.02835357f, -0.08338908f, 0.17332123f, 0.05219284f, 0.01609732f, 0.03294645f, 0.08052143f, 
    0.06630012f, 0.04401845f, -0.08230083f, 0.08879006f, 0.19324391f, -0.09210676f, -0.05901332f, 0.00952410f, 
    0.07762780f, -0.03163751f, 0.08000351f, 0.01587348f, -0.02588582f, -0.07777476f, -0.00616373f, 0.05449646f, 
    0.02145733f, 0.03117698f, 0.10434346f, 0.12634075f, 0.06462545f, 0.11050143f, -0.00857677f, 0.04142004f, 
    -0.02223939f, 0.04265209f, 0.15155447f, -0.04319961f, 0.39999655f, -0.25637421f, 0.13113993f, -0.12869053f, 
    -0.06984780f, -0.06183586f, 0.09100556f, 0.10862660f, -0.01761741f, 0.03740219f, -0.14300150f, 0.01415187f, 
    0.31255868f, 0.03888299f, -0.01910454f, 0.05508342f, 0.06434360f, -0.09009449f, -0.00823707f, 0.05654528f, 
    -0.09424541f, -0.02140843f, -0.00261600f, -0.06615855f, 0.05010711f, -0.19444370f, 0.04862377f, 0.17736080f, 
    0.09671012f, -0.01808402f, 0.01431510f, -0.08575998f, -0.02861088f, -0.07506068f, 0.08018440f, 0.02631781f, 
    -0.03841552f, -0.52595085f, 0.02127372f, 0.01444279f, 0.14211036f, 0.05080257f, -0.04238241f, 0.02888187f, 
    0.00083924f, 0.09773281f, -0.02029852f, 0.03254933f, 0.15194945f, 0.03686655f, -0.07726748f, 0.06435241f, 
    -0.15620856f, -0.09663701f, -0.10330473f, 0.03031064f, 0.00247850f, -0.03454525f, -0.09295216f, 0.08369602f, 
    -0.03495969f, -0.03298013f, 0.10579817f, 0.00371835f, 0.06391206f, 0.03134554f, -0.00936263f, 0.12679718f, 
    0.05209671f, -0.04113916f, 0.07009169f, -0.01450268f, 0.31625369f, 0.09815663f, 0.06731249f, 0.03362033f, 
    -0.11142454f, -0.03342230f, -0.01974812f, 0.12667963f, 0.11379288f, -0.02596551f, 0.04848049f, -0.02130784f, 
    0.39162627f, -0.23202991f, 0.01900779f, -0.20535320f, -0.09358401f, -0.10822630f, 0.08239099f, 0.10615854f, 
    -0.07789390f, -0.00029189f, 0.07671160f, 0.03265070f, 0.21537790f, -0.08420914f, -0.06881580f, 0.03390244f, 
    0.00939987f, -0.04590978f, -0.02035469f, 0.08311509f, -0.05999753f, -0.03565724f, 0.07612745f, -0.02122526f, 
    -0.00012833f, 0.05707268f, -0.02475953f, -0.13024057f, -0.00475053f, -0.01254333f, -0.18631013f, 0.06179161f, 
    0.11790659f, -0.04030954f, 0.10713305f, -0.04969396f, -0.17246948f, -0.01454443f, 0.02699465f, 0.03389837f, 
    -0.01514542f, -0.03283372f, 0.06462985f, 0.01455332f, 0.02449084f, 0.19066569f, 0.04813392f, 0.07371367f, 
    0.08421115f, -0.26336163f, -0.04968026f, 0.09885851f, -0.00297155f, 0.14171924f, 0.08637392f, -0.04274248f, 
    0.02943697f, -0.04357040f, -0.01636817f, -0.13604321f, 0.28149158f, -0.21933578f, -0.02946596f, 0.10662608f, 
    -0.12133418f, 0.06662406f, 0.01917629f, 0.04944241f, 0.02227095f, 0.06963012f, 0.01859071f, 0.07545818f, 
    0.13262248f, 0.04332148f, 0.12999378f, -0.17419325f, 0.13609694f, -0.00312995f, 0.04484396f, 0.04236094f, 
    0.05858449f, 0.11283698f, 0.04843157f, -0.02465968f, -0.13994877f, -0.19745404f, 0.31363070f, -0.26878753f, 
    0.10509021f, -0.08652727f, 0.01474623f, 0.07061089f, -0.03854021f, -0.04820059f, 0.10233737f, -0.06512905f, 
    -0.14000317f, 0.04283881f, -0.00551845f, 0.07695682f, -0.02838113f, -0.00936648f, 0.09149662f, 0.04661328f, 
    0.08020851f, 0.02684569f, 0.09589776f, 0.16490130f, 0.24087456f, 0.01077739f, 0.05577991f, -0.22656019f, 
    0.15986702f, 0.08128389f, 0.12099789f, 0.03004531f, 0.03687206f, 0.11661949f, -0.11737228f, 0.02997325f, 
    -0.16448161f, 0.10147557f, -0.17728449f, 0.31282973f, 0.00512092f, 0.05596012f, -0.08788157f, 0.01903697f, 
    0.02260994f, -0.02884744f, 0.01432841f, -0.08356874f, 0.19987614f, 0.13006109f, -0.02509463f, 0.05822381f, 
    0.00479407f, 0.11681243f, 0.07749129f, -0.06957708f, -0.04381714f, 0.00847197f, 0.04050389f, 0.04714227f, 
    0.27450216f, 0.14071977f, -0.02832791f, 0.10405362f, -0.09215409f, -0.07521549f, -0.06691519f, -0.04962728f, 
    0.05812446f, -0.17226067f, 0.05671639f, 0.13505232f, 0.20068263f, -0.00864963f, -0.00797916f, -0.05804048f, 
    0.00283149f, 0.11980926f, 0.07044269f, 0.11001893f, -0.03601069f, 0.04617115f, 0.06472404f, 0.09801982f, 
    0.14342590f, 0.01974400f, 0.21814698f, -0.07000934f, 0.01673642f, 0.06529826f, -0.12240852f, 0.08387960f, 
    0.06097103f, 0.07661237f, -0.11897375f, -0.06262901f, -0.25227532f, -0.13097501f, -0.14949469f, -0.19362386f, 
    0.16322429f, 0.09735005f, -0.08843625f, 0.01202867f, -0.04577442f, 0.14016236f, 0.02124955f, 0.08551410f, 
    -0.55484092f, -0.09189031f, 0.02569089f, 0.01824933f, 0.02319079f, 0.06008861f, -0.03608761f, -0.15466410f, 
    -0.07761221f, 0.04611664f, 0.07123267f, -0.08235428f, 0.10182509f, -0.05378025f, 0.03928776f, -0.09154211f, 
    0.06905326f, -0.03247577f, 0.00404781f, -0.06666903f, 0.03405000f, 0.07546143f, -0.05363598f, -0.02221058f, 
    -0.03033936f, -0.12166671f, 0.09592993f, 0.00713653f, -0.08219533f, 0.04017064f, -0.02554526f, 0.00090705f, 
    0.02827694f, 0.00097566f, 0.06961427f, -0.00291316f, 0.37350574f, 0.10608234f, -0.15761265f, 0.00916249f, 
    0.03377946f, -0.10556336f, 0.07810944f, 0.10246687f, 0.04154171f, 0.03717503f, -0.03762843f, 0.05960617f, 
    -0.38664621f, -0.21395208f, -0.14084750f, -0.03984733f, 0.00102628f, -0.07609927f, -0.06249612f, -0.03181599f, 
    0.02334304f, 0.07141320f, 0.01471986f, -0.09175119f, 0.06728512f, -0.00802341f, -0.01835578f, -0.16523053f, 
    0.01630967f, -0.07378069f, 0.02347717f, 0.05918372f, -0.00326415f, -0.02289654f, 0.03441824f, -0.19507624f, 
    0.47774401f, 0.22375807f, -0.01788487f, 0.17201373f, 0.09441698f, 0.11186355f, -0.04376911f, -0.00789267f, 
    0.06797088f, 0.01061378f, 0.02797126f, 0.05668445f, 0.06722738f, -0.18690085f, 0.14948545f, -0.07266896f, 
    0.02604317f, -0.03377894f, -0.04699248f, -0.01483925f, -0.03522052f, -0.13805269f, -0.00456266f, 0.04579464f, 
    -0.02369549f, -0.08198697f, -0.22542027f, -0.03767366f, -0.10869692f, -0.05045000f, 0.00605054f, 0.09418680f, 
    -0.02720776f, 0.03767170f, 0.10785452f, -0.03652646f, 0.21694730f, 0.02459828f, 0.01751149f, -0.11796363f, 
    -0.03046900f, -0.17611744f, -0.02687270f, 0.08400981f, -0.01136280f, -0.08790220f, -0.00991508f, 0.10032598f, 
    0.20941481f, 0.03165987f, 0.10066358f, 0.06089426f, 0.10359863f, 0.14462402f, -0.06258397f, 0.06516764f, 
    -0.09638519f, 0.02832439f, 0.03576158f, 0.08142813f, 0.34604219f, 0.03136230f, 0.00692550f, 0.25125790f, 
    -0.03820786f, -0.04700170f, 0.00483564f, 0.00118509f, -0.00595032f, 0.00985802f, 0.12117836f, -0.05524937f, 
    0.19479774f, -0.26084879f, -0.22866604f, 0.15782733f, -0.00616250f, 0.03588971f, -0.05639475f, 0.06654129f, 
    0.05028049f, 0.08751542f, -0.03551044f, -0.03078751f, 0.00058255f, 0.04468482f, 0.03809389f, 0.15013793f, 
    -0.12584521f, -0.09625755f, -0.10193633f, -0.02159352f, 0.05841011f, 0.05466891f, -0.11385771f, 0.02826122f, 
    0.10191625f, 0.04301218f, 0.01350487f, -0.10925214f, 0.01906470f, -0.03580410f, 0.07615749f, 0.01997705f, 
    0.00192075f, -0.05722562f, 0.04149746f, 0.00852991f, 0.09311689f, 0.12871911f, 0.09138339f, 0.05191388f, 
    -0.08085923f, -0.13625400f, 0.01455872f, 0.11993888f, 0.13009636f, -0.00600643f, 0.02644090f, -0.01612617f, 
    0.36296424f, 0.01689835f, 0.01455779f, -0.29202527f, 0.01131769f, -0.00557236f, 0.04891778f, -0.00654603f, 
    -0.01688730f, 0.06168993f, -0.03714558f, -0.04181037f, -0.18356036f, -0.12810697f, 0.01758897f, 0.01349759f, 
    -0.11690132f, -0.03931849f, -0.06614978f, 0.05601775f, -0.02211716f, -0.10137725f, 0.07947031f, -0.01804205f, 
    0.23181729f, -0.06360913f, -0.00336895f, 0.02488390f, -0.01230555f, 0.01371625f, -0.18946531f, -0.03298360f, 
    0.00237180f, 0.05808866f, 0.00049389f, -0.02960709f, 0.32665133f, 0.10467613f, 0.10779700f, 0.16059163f, 
    0.05765723f, -0.01891303f, -0.04783096f, 0.01937443f, -0.03769972f, -0.00488874f, -0.03283948f, -0.00768269f, 
    0.21002550f, 0.03048622f, -0.01506910f, 0.13426025f, -0.01415528f, 0.04699912f, 0.15688226f, -0.00748479f, 
    -0.02417202f, -0.12575230f, 0.01949602f, -0.04360579f, 0.18570738f, -0.03292877f, 0.02260588f, 0.10412025f, 
    -0.16126750f, -0.02393015f, 0.02401401f, 0.01813913f, -0.02642760f, 0.09755250f, 0.03978492f, 0.12010901f, 
    -0.14682393f, -0.18839996f, -0.01892779f, -0.20364492f, -0.03881828f, -0.02464944f, -0.01100464f, -0.00307255f, 
    0.07219778f, 0.08780039f, 0.08808097f, -0.00240587f, 0.21831140f, 0.03175107f, 0.12891831f, -0.34144172f, 
    0.15968782f, -0.15781160f, -0.04317912f, 0.14752176f, 0.05374357f, -0.01365096f, 0.16491063f, 0.00742114f, 
    0.17569466f, 0.09260239f, 0.01146162f, 0.10825627f, -0.03021272f, -0.07969633f, 0.08214265f, -0.10219657f, 
    0.04774448f, -0.01698716f, 0.01123041f, -0.00962135f, 0.10884965f, 0.04715076f, -0.10808469f, -0.30013055f, 
    -0.00409927f, 0.01643000f, 0.00663967f, 0.03993693f, 0.11920565f, 0.11085444f, -0.07882702f, 0.12689321f, 
    0.06763043f, 0.20072278f, -0.13233052f, 0.16506523f, 0.04611284f, 0.05737311f, -0.06110954f, -0.02701643f, 
    0.10134272f, 0.00008215f, 0.08341143f, -0.06737909f, 0.05402922f, 0.14083740f, 0.01062460f, 0.12593259f, 
    -0.02308049f, 0.09773532f, 0.01788696f, -0.05146954f, 0.05780077f, 0.01586379f, 0.06008431f, 0.00372358f, 
    0.15504119f, 0.15566200f, 0.06358673f, 0.16325709f, 0.06857321f, 0.04142118f, -0.04042494f, -0.04574603f, 
    0.02024714f, -0.06967763f, 0.03032273f, 0.03917257f, 0.05815712f, -0.04190571f, 0.04836068f, -0.10396791f, 
    -0.00496174f, -0.08525850f, -0.01353356f, 0.15197223f, -0.08657252f, -0.03415864f, -0.02837932f, 0.02245294f, 
    -0.01194011f, -0.01103132f, -0.03904428f, 0.00147954f, 0.04700244f, -0.01864623f, 0.04355317f, -0.04336142f, 
    0.03374883f, 0.02235750f, -0.04379373f, -0.00329962f, -0.01583345f, -0.01234251f, -0.05349116f, -0.03629790f, 
    0.00636681f, -0.02877659f, -0.04102066f, -0.00852434f, 0.03339561f, 0.00576686f, -0.01078043f, -0.02471174f, 
    -0.02984946f, 0.04007818f, 0.02175925f, -0.03816183f, -0.02687814f, -0.01494343f, 0.01384465f, 0.01810205f, 
    0.02142135f, 0.04832653f, 0.02195882f, 0.02119732f, -0.00973329f, 0.02908773f, 0.01381790f, -0.01623468f, 
    0.01487718f, 0.02575566f, -0.04529183f, 0.04153350f, 0.04488729f, 0.01999781f, -0.01482886f, 0.03458082f, 
    0.02596751f, -0.00323024f, -0.00678019f, -0.00630029f, 0.02340456f, -0.04873978f, -0.03274382f, 0.02767274f, 
    -0.04827373f, -0.00746628f, -0.03509517f, -0.01516052f, 0.01018479f, 0.00610475f, -0.04731028f, 0.00974064f, 
    -0.02459909f, 0.02437313f, 0.02570805f, 0.00196464f, 0.03444005f, 0.03151313f, -0.00829682f, -0.02677842f, 
    -0.02957467f, -0.02963966f, -0.01632730f, -0.05572386f, -0.01807366f, -0.04233252f, -0.03030626f, -0.00208973f, 
    0.03389242f, 0.04113739f, -0.00765519f, 0.01512734f, 0.00964959f, 0.03640686f, -0.00288215f, -0.00660711f, 
    -0.00599998f, -0.04270443f, 0.01192479f, -0.02852131f, 0.02341324f, 0.01627745f, -0.01050827f, -0.04176845f, 
    0.00720622f, -0.00202478f, -0.00539741f, 0.01387163f, -0.04841015f, 0.01814322f, -0.00036141f, -0.01852952f, 
    0.01183853f, 0.02666042f, -0.05196410f, -0.04221495f, -0.03207701f, 0.01897347f, -0.03481798f, -0.05489736f, 
    -0.03401741f, -0.00966541f, -0.00313247f, -0.00719259f, 0.03748095f, 0.01784573f, 0.03584443f, 0.03216152f, 
    -0.03716711f, -0.01808743f, -0.00109126f, 0.02453984f, -0.05058629f, -0.05425853f, -0.04500054f, -0.03912935f, 
    0.02543313f, -0.02067774f, 0.00148194f, 0.02519003f, -0.04776343f, 0.00374975f, -0.04461679f, -0.04875891f, 
    -0.00773193f, 0.01222357f, 0.02305017f, 0.01709603f, 0.00637145f, 0.01664270f, -0.03496874f, -0.02589846f, 
    -0.00272570f, -0.04060486f, 0.03328802f, -0.02114866f, 0.00968609f, -0.04190062f, -0.04998379f, -0.03122267f, 
    0.00661078f, -0.03449995f, 0.04235244f, 0.02604866f, -0.02688029f, 0.03082218f, 0.01992689f, -0.00749544f, 
    -0.04986463f, 0.03377467f, -0.03334934f, -0.03899593f, 0.04262998f, -0.02360821f, 0.04536292f, 0.03864317f, 
    0.03042703f, 0.03042706f, -0.01183335f, -0.01407477f, 0.03969648f, -0.00371999f, -0.02349605f, 0.01726039f, 
    -0.02536964f, 0.01234758f, -0.00787863f, -0.05139858f, 0.03945128f, -0.00022457f, -0.02919478f, 0.03993491f, 
    0.03387188f, -0.01319471f, 0.02991626f, -0.03225092f, -0.02750616f, -0.03116130f, -0.03799711f, -0.04118944f, 
    0.02312521f, -0.03366548f, -0.01886887f, -0.04415104f, 0.03183899f, 0.00628003f, -0.00531036f, -0.04403733f, 
    -0.04930786f, -0.01970093f, -0.03733636f, 0.03469682f, 0.01713517f, -0.00915899f, 0.01661474f, 0.04118934f, 
    0.02780203f, 0.03598391f, -0.02762120f, -0.00670253f, -0.04064861f, -0.02294609f, 0.04030506f, 0.00618984f, 
    0.03351845f, 0.01433341f, -0.03535216f, 0.03408115f, 0.00885142f, 0.04694096f, -0.02487611f, 0.02603132f, 
    0.03777617f, 0.00481264f, 0.03189690f, 0.02260833f, 0.00626091f, -0.04671440f, -0.04911257f, -0.04450716f, 
    -0.02579792f, -0.00666239f, -0.05118940f, 0.03220914f, 0.03552421f, -0.04897898f, 0.02944073f, -0.01256621f, 
    -0.03898164f, 0.00917466f, 0.03007633f, -0.04175632f, -0.04984898f, -0.03278108f, -0.02950083f, 0.02161165f, 
    -0.00799792f, 0.01681585f, -0.02209231f, 0.00166294f, 0.03743533f, 0.01000557f, -0.04782526f, -0.00783138f, 
    -0.02775910f, 0.04536808f, 0.02532788f, -0.02619463f, 0.01778810f, -0.05079558f, -0.03087074f, -0.05390840f, 
    -0.02168766f, -0.00019061f, 0.04477879f, 0.00880563f, -0.01560214f, -0.05283110f, 0.02182881f, -0.04815606f, 
    0.01879415f, 0.02531531f, -0.02351994f, -0.00750823f, -0.02218880f, -0.03570031f, 0.03628382f, 0.03420094f, 
    -0.02302826f, 0.00209174f, -0.04623700f, -0.02461084f, 0.01541338f, -0.04658907f, -0.03932784f, -0.00179884f, 
    -0.04658146f, -0.04768802f, 0.02610770f, -0.02524187f, -0.01735882f, 0.04497319f, -0.04602883f, -0.00717290f, 
    -0.04853106f, -0.01114596f, -0.02667373f, 0.00577273f, 0.01016079f, 0.00379361f, -0.00833689f, 0.02275172f, 
    0.02426570f, -0.02355659f, -0.04354516f, 0.03315768f, 0.00781903f, 0.01431447f, 0.02222502f, -0.04587731f, 
    -0.02720162f, -0.05419714f, -0.05042997f, 0.00475746f, 0.04374843f, -0.03316997f, 0.04116755f, 0.02238456f, 
    0.04451783f, -0.02800253f, -0.01540360f, -0.03703164f, -0.00188481f, -0.01871962f, 0.00306316f, 0.02837194f, 
    0.03478086f, 0.03329183f, -0.02605050f, 0.01845409f, 0.03591211f, -0.04979706f, -0.03472796f, 0.02405258f, 
    -0.02727635f, 0.02659100f, -0.03669087f, 0.02092199f, -0.01778658f, 0.00788095f, -0.03074931f, -0.01215449f, 
    0.02687213f, -0.04171044f, -0.00344605f, -0.02822815f, -0.01228309f, 0.01092761f, 0.01642502f, 0.04515097f, 
    0.03784861f, 0.01390999f, -0.00508932f, -0.05123435f, 0.00147439f, 0.01249919f, -0.02677870f, -0.04825896f, 
    -0.05148184f, -0.01643674f, -0.01937962f, -0.02202514f, -0.04713533f, 0.03011387f, 0.01952172f, -0.03218878f, 
    -0.02702400f, 0.03189238f, -0.00425734f, 0.01557795f, -0.04089681f, -0.05571421f, 0.00229096f, 0.00818271f, 
    0.00218557f, 0.01367320f, 0.03444792f, -0.00821877f, 0.00097164f, -0.04737566f, 0.04240032f, -0.05167808f, 
    0.00940855f, -0.05193713f, -0.02986647f, -0.03582050f, 0.04328566f, 0.02260343f, -0.00565919f, -0.05271241f, 
    -0.04707747f, 0.02059333f, -0.01795457f, 0.04607058f, -0.01064058f, -0.03232238f, -0.02502534f, -0.01821272f, 
    -0.01297919f, 0.03857181f, -0.04567080f, 0.04460574f, -0.00017213f, -0.04121302f, 0.01879360f, 0.03479012f, 
    0.01958788f, 0.00366805f, -0.04662957f, -0.03989841f, 0.03405217f, -0.00807804f, 0.00425628f, -0.04318154f, 
    0.02080325f, -0.04846607f, -0.03886319f, 0.04224671f, -0.00359517f, -0.00310754f, -0.05147190f, -0.03912602f, 
    0.00261805f, -0.00692570f, 0.03817758f, 0.00605642f, -0.01618567f, 0.00112012f, 0.02292726f, -0.04141759f, 
    -0.02830005f, -0.05160952f, 0.03073197f, -0.04113278f, 0.02778293f, -0.01640102f, -0.00977944f, 0.00395760f, 
    -0.00902538f, 0.02603384f, 0.03830454f, 0.02375581f, 0.00142238f, 0.03198237f, -0.05697531f, -0.04982349f, 
    0.00030885f, -0.03617719f, 0.00237527f, -0.02213090f, 0.01222933f, -0.05239109f, -0.03497383f, 0.03245775f, 
    -0.00320312f, 0.03275683f, 0.03172367f, 0.01299883f, 0.02263444f, 0.02507724f, 0.02293104f, 0.02241330f, 
    -0.00911887f, -0.00301452f, -0.05451376f, -0.04498559f, 0.00688101f, 0.03490018f, 0.03562139f, -0.04787678f, 
    0.01157873f, -0.05507741f, -0.04217220f, -0.02798147f, -0.01820347f, -0.03520852f, 0.03804634f, -0.03024358f, 
    -0.04728718f, -0.02623274f, -0.04417812f, 0.03686494f, -0.00683800f, 0.00417328f, -0.01988587f, -0.05218837f, 
    -0.03980448f, 0.01118995f, -0.00794840f, -0.00845881f, 0.03296940f, 0.00837014f, -0.01705820f, -0.02596511f, 
    -0.04571632f, 0.04462396f, -0.04310078f, 0.04025711f, -0.00820209f, -0.03837272f, 0.01813329f, 0.01633892f, 
    -0.05167403f, -0.03399869f, -0.00661016f, -0.05747011f, 0.01371839f, -0.01068354f, -0.03122772f, 0.03274784f, 
    0.02050365f, -0.02107001f, -0.03908478f, -0.04849040f, -0.03335007f, -0.04497062f, -0.02743247f, 0.03672660f, 
    0.01626760f, -0.04939167f, -0.04895421f, -0.01691872f, -0.01858133f, -0.02183832f, 0.03856286f, -0.00343480f, 
    -0.04770390f, 0.00471738f, -0.03630603f, 0.04133261f, 0.04487525f, -0.01072270f, 0.04245950f, -0.01686856f, 
    0.03405005f, -0.01404629f, 0.03223531f, -0.05156072f, -0.04778685f, 0.03673425f, -0.01291444f, -0.01116780f, 
    -0.04979788f, 0.04668233f, 0.03199073f, -0.04828505f, -0.03268803f, 0.00613680f, -0.01411360f, 0.03360609f, 
    0.03417192f, -0.03348936f, -0.02659613f, -0.03335846f, 0.00728630f, -0.03346316f, 0.01707805f, 0.04578594f, 
    0.03618285f, -0.00367975f, -0.00750177f, 0.03577183f, -0.01031170f, 0.02540206f, 0.01973235f, -0.04022358f, 
    -0.01997131f, -0.04442967f, 0.01681929f, -0.02452773f, 0.01498317f, -0.01962823f, -0.02850508f, 0.00620963f, 
    0.03381017f, -0.01045488f, 0.02843801f, 0.01521808f, -0.01692223f, -0.01883568f, -0.01509739f, 0.00889962f, 
    -0.04655830f, 0.03437923f, -0.00421950f, -0.05086961f, 0.01993867f, 0.00843084f, -0.05592423f, -0.01013134f, 
    -0.01494782f, 0.02714685f, -0.04274635f, -0.00418457f, 0.01068360f, -0.04737451f, -0.02724724f, 0.00668661f, 
    -0.04448881f, 0.00808327f, -0.01788715f, -0.03674872f, 0.04070030f, 0.02402557f, -0.01821229f, 0.00843653f, 
    -0.05575616f, -0.03884061f, -0.00625980f, 0.01592475f, -0.02954551f, 0.03713643f, 0.02950936f, 0.03406414f, 
    -0.02816817f, -0.01635753f, -0.01149807f, -0.01282310f, 0.02094034f, -0.03287068f, -0.01411129f, -0.00382791f, 
    -0.04354083f, -0.03058013f, 0.02109574f, -0.03354647f, 0.01722409f, 0.04886973f, 0.03648984f, 0.04390350f, 
    -0.01823490f, -0.01534557f, 0.00600944f, 0.04311266f, -0.02977149f, -0.04144606f, 0.00922704f, 0.00886739f, 
    0.01033304f, -0.04025134f, -0.02575688f, -0.03183278f, -0.00778540f, 0.01070374f, 0.00527809f, -0.03469691f, 
    -0.03936134f, 0.00394315f, 0.03632063f, 0.01303311f, 0.03650672f, -0.04567342f, -0.03197931f, -0.02893873f, 
    -0.02309023f, 0.01611012f, 0.01228304f, -0.00017419f, -0.02470866f, 0.01024810f, -0.00929790f, 0.04359901f, 
    -0.04835777f, 0.01376273f, 0.04450442f, 0.04109868f, 0.01992835f, 0.02709036f, 0.01306595f, 0.03435967f, 
    -0.04931840f, 0.02383975f, -0.05391996f, -0.04615089f, -0.04276596f, -0.00749591f, -0.05588967f, -0.00851935f, 
    -0.02809099f, -0.04294307f, 0.02509112f, -0.05310833f, 0.00723267f, -0.01046086f, -0.05153955f, -0.01663025f, 
    -0.04890939f, -0.05919221f, -0.04796375f, 0.01257184f, -0.04962116f, 0.00171808f, 0.00019829f, -0.00723432f, 
    -0.02601228f, -0.04744354f, -0.02009602f, -0.04448610f, -0.05022493f, -0.01867867f, 0.03881494f, 0.00760390f, 
    -0.04867531f, -0.02593557f, 0.02825714f, 0.03825181f, 0.01013912f, -0.02935408f, -0.01044888f, -0.05339067f, 
    0.00071550f, 0.00690496f, 0.01770430f, -0.01252974f, -0.01494711f, -0.01834805f, -0.04077005f, 0.02859852f, 
    0.04119302f, -0.05539099f, -0.05003653f, -0.00676706f, -0.01337629f, 0.00273006f, -0.02130979f, -0.03244424f, 
    0.03321711f, -0.01494233f, -0.00979705f, -0.02288501f, 0.03937341f, -0.02850115f, 0.04242820f, 0.01469826f, 
    0.01644649f, 0.01408297f, -0.02134861f, 0.01431660f, -0.02317823f, 0.04430412f, -0.00735347f, 0.02404135f, 
    -0.02029362f, 0.01659310f, -0.00365149f, -0.04473781f, -0.00286107f, 0.04251404f, 0.03090146f, -0.00301832f, 
    0.00713246f, -0.05106649f, 0.01572809f, -0.05302960f, 0.00776006f, 0.04572414f, 0.01704941f, -0.01421522f, 
    0.04411031f, -0.05793734f, -0.04107478f, -0.00654422f, -0.02396041f, -0.00682861f, 0.02496966f, 0.03260304f, 
    0.07689114f, 0.06662981f, 0.28746361f, 0.17037709f, 0.02473811f, -0.03092394f, 0.02721783f, 0.07326350f, 
    -0.13935669f, -0.04846529f, -0.03376260f, -0.06717197f, -0.18905941f, 0.02526900f, -0.13409355f, -0.01735074f, 
    -0.10476397f, 0.00781499f, -0.06206836f, -0.05539853f, -0.05323719f, 0.06046790f, 0.08485458f, 0.00036717f, 
    0.15962131f, 0.25414813f, 0.02815229f, 0.14713237f, -0.16215302f, 0.07418019f, 0.06263702f, -0.02531965f, 
    -0.02445432f, 0.01512489f, 0.04060330f, -0.10568206f, 0.36351877f, 0.23466107f, 0.11810186f, 0.07974915f, 
    0.09708838f, -0.01722940f, -0.04677068f, 0.08793785f, -0.00069136f, -0.09494586f, -0.08532196f, -0.09341101f, 
    -0.28839657f, 0.01991613f, 0.10524327f, -0.03394713f, -0.04740387f, 0.04800790f, 0.03368512f, 0.00533545f, 
    0.07674822f, -0.11792570f, 0.08606087f, 0.04358089f, 0.18041573f, -0.02655007f, -0.13966872f, 0.08963783f, 
    0.02824422f, -0.08208757f, 0.07835292f, 0.01156705f, -0.02061525f, -0.02131063f, 0.16517694f, 0.02276428f, 
    -0.35635573f, -0.26278144f, -0.23008092f, -0.19731399f, -0.06891553f, -0.15137134f, -0.07274930f, 0.01224017f, 
    0.02321243f, -0.03286455f, -0.01337754f, -0.12328331f, -0.03741226f, -0.18626212f, -0.11174364f, 0.02610114f, 
    -0.04476453f, 0.13294251f, -0.10491589f, -0.01106129f, 0.13017473f, -0.07476149f, 0.04358699f, -0.06341521f, 
    0.44605124f, 0.19623448f, 0.01305014f, 0.44353190f, 0.00045041f, 0.04396269f, 0.03244384f, -0.03809664f, 
    0.04136701f, 0.00583725f, 0.05780348f, -0.03174219f, 0.04791467f, -0.03962524f, 0.18522812f, 0.13968344f, 
    -0.04531153f, 0.04508194f, -0.09519295f, -0.05678583f, 0.00741038f, -0.06233035f, -0.00038768f, -0.02853864f, 
    -0.11792219f, -0.26554960f, 0.06428743f, 0.28175154f, -0.10009571f, 0.01170856f, 0.01395864f, -0.23210880f, 
    -0.05860538f, 0.05311650f, 0.01227695f, 0.02835113f, 0.20835499f, -0.00499926f, -0.19986829f, -0.22860101f, 
    0.03836678f, -0.15758179f, -0.04822936f, 0.01869935f, -0.05514444f, 0.00778240f, 0.02409306f, -0.03351372f, 
    -0.19443943f, 0.23993535f, 0.23730652f, 0.14494310f, -0.08186760f, 0.09628529f, 0.08071496f, 0.00102856f, 
    0.00081283f, 0.02665155f, -0.03467697f, -0.12352430f, 0.28447840f, -0.10588855f, 0.02970914f, 0.30322698f, 
    0.02970932f, 0.08117343f, -0.02282732f, -0.00834997f, -0.01695558f, -0.00291137f, 0.00167397f, 0.01313171f, 
    0.22270238f, -0.02487524f, 0.03914849f, 0.44336918f, 0.08770304f, 0.00909665f, -0.01486644f, -0.02226602f, 
    0.00166428f, -0.00470471f, 0.00105743f, -0.06656598f, -0.15088445f, 0.09268641f, 0.08776672f, 0.03385192f, 
    -0.02191031f, 0.02930475f, 0.00131444f, 0.05897351f, 0.00540759f, 0.00408514f, -0.04263977f, -0.06043007f, 
    -0.32777965f, 0.22720633f, 0.12327824f, -0.25416639f, -0.11910658f, -0.01855785f, -0.08015630f, -0.02488491f, 
    0.12712415f, -0.08490614f, -0.17413656f, -0.05048358f, -0.02452230f, 0.07636324f, 0.18939619f, 0.13413720f, 
    0.03018397f, -0.03425955f, -0.00048955f, -0.02796420f, 0.10765978f, 0.01051479f, -0.00381031f, -0.08948791f, 
    0.13291849f, 0.20221373f, 0.06552014f, -0.08276642f, -0.04949561f, 0.03188754f, 0.04644096f, -0.06095535f, 
    -0.06608374f, 0.04977309f, 0.01079860f, -0.03171088f, -0.03332439f, -0.08772188f, 0.13857797f, 0.00193147f, 
    -0.14959125f, -0.02694692f, -0.01878267f, -0.05897580f, -0.05308924f, -0.03628502f, -0.09323721f, 0.04952752f, 
    0.21900511f, 0.25645232f, 0.18196695f, 0.03255660f, -0.02729126f, 0.02162430f, 0.06704871f, -0.03828333f, 
    -0.07849813f, -0.02788654f, 0.16900906f, -0.07021608f, 0.23103155f, 0.20848857f, 0.09826498f, 0.24745029f, 
    0.09777210f, 0.09226271f, -0.07731218f, -0.02333611f, -0.04736562f, -0.02384850f, -0.01667296f, -0.10549120f, 
    0.22320183f, 0.10177381f, -0.03850061f, 0.28929392f, 0.01890147f, -0.07793297f, -0.05482686f, -0.10116004f, 
    0.03378479f, 0.03911940f, 0.01489709f, -0.00415614f, -0.01967043f, 0.26276624f, 0.08733157f, 0.07082596f, 
    -0.12809111f, -0.00944049f, 0.06967656f, -0.02667752f, -0.00245052f, 0.09987297f, -0.03392929f, 0.06748690f, 
    -0.29064170f, -0.00029144f, 0.00565283f, -0.10480437f, -0.09527878f, -0.15396397f, -0.04688278f, -0.11276437f, 
    -0.07907383f, 0.06294613f, 0.04259221f, 0.03258595f, 0.22458012f, 0.02659729f, -0.14887436f, -0.15033822f, 
    0.05363345f, -0.08876775f, -0.05374796f, 0.09098595f, -0.05130799f, 0.12034325f, 0.03132427f, -0.13004124f, 
    0.30286872f, 0.05931936f, 0.01012315f, 0.07643227f, -0.08177172f, -0.05989465f, 0.01159647f, -0.01113912f, 
    0.05056578f, 0.05130754f, -0.06230093f, 0.05015013f, -0.10184415f, 0.05063287f, 0.01709614f, 0.06836393f, 
    -0.05859946f, -0.17208549f, -0.09664020f, -0.07012987f, 0.04880267f, 0.10047169f, 0.04733542f, -0.00125487f, 
    0.18102983f, 0.16887678f, -0.06038216f, 0.13899739f, 0.04116489f, -0.02456031f, 0.07473920f, -0.08348327f, 
    -0.08196180f, -0.02559531f, 0.06005128f, -0.11344941f, -0.21426487f, -0.05465426f, 0.02310558f, -0.12438505f, 
    0.07263235f, -0.03556889f, -0.08377109f, -0.07892171f, 0.12735477f, 0.05895736f, 0.00222167f, 0.08452126f, 
    0.29181552f, 0.06098379f, 0.22911161f, 0.22197324f, 0.04583834f, 0.04412138f, -0.07564390f, -0.00377033f, 
    -0.01561939f, 0.15981290f, -0.19358015f, -0.05491693f, -0.11531645f, -0.08371667f, 0.18391962f, 0.05923337f, 
    -0.00681477f, -0.05312583f, -0.09346905f, 0.06447423f, 0.08396444f, 0.10617337f, 0.06835639f, -0.02514526f, 
    0.03604849f, 0.03899715f, -0.02761734f, 0.04075381f, -0.01960412f, -0.01448292f, -0.03884400f, -0.00686132f, 
    -0.03001675f, 0.03771070f, -0.03844115f, 0.03986529f, 0.00118225f, 0.03126833f, -0.03024204f, -0.05187585f, 
    0.00509112f, 0.03604972f, -0.03226189f, -0.02688721f, -0.00888110f, 0.02181618f, -0.05786519f, -0.03112160f, 
    -0.01294908f, 0.02794832f, 0.00855564f, -0.01985536f, 0.03664902f, -0.00025236f, 0.02732398f, 0.02032169f, 
    -0.05323584f, 0.01532931f, -0.01134857f, 0.00542365f, -0.01209624f, -0.01848610f, -0.05089706f, 0.00689451f, 
    0.00712545f, -0.01811627f, -0.05542352f, -0.05699917f, 0.04002629f, 0.02709362f, -0.02586328f, -0.04009819f, 
    -0.05399814f, -0.01253199f, -0.03839557f, 0.00831437f, -0.02684814f, -0.00475754f, -0.05000387f, -0.04326618f, 
    -0.02355724f, -0.01062623f, -0.03244699f, -0.02469299f, 0.01179690f, -0.00153861f, -0.04381944f, 0.01619465f, 
    0.03010105f, 0.03429609f, 0.03823677f, 0.03481756f, -0.05147090f, -0.02459508f, -0.04185006f, 0.03410194f, 
    0.04815436f, -0.03002252f, -0.03875766f, -0.04334912f, -0.03858658f, 0.00794968f, -0.03647940f, 0.00092042f, 
    0.01553790f, -0.00911540f, 0.02604709f, 0.00424111f, 0.03176157f, 0.00949006f, 0.01562622f, -0.05304230f, 
    0.04561869f, -0.00790559f, 0.03115490f, 0.03313191f, -0.01735598f, 0.02741388f, 0.03015066f, -0.01111073f, 
    -0.01916736f, 0.01455460f, 0.03473888f, 0.02341847f, -0.05715289f, -0.01982019f, -0.01837410f, -0.05805495f, 
    -0.00275090f, -0.01499213f, -0.00463990f, -0.03567718f, -0.02745111f, -0.03279400f, -0.04856205f, -0.02686695f, 
    0.04227591f, -0.04008495f, -0.04179700f, -0.05017295f, -0.04175731f, -0.00252037f, -0.02075708f, 0.00188027f, 
    0.02337986f, -0.02158892f, -0.02188711f, -0.01340221f, 0.00651917f, -0.02756024f, -0.04657663f, 0.02507745f, 
    -0.04388651f, 0.00804854f, 0.02156468f, 0.01352957f, -0.00013751f, -0.05408745f, 0.01277047f, -0.00435392f, 
    -0.05667971f, -0.04541783f, -0.03883275f, -0.00873882f, 0.01754587f, 0.00223761f, 0.02883995f, -0.04579638f, 
    -0.02505654f, 0.03956887f, 0.00351632f, -0.02315440f, -0.02726039f, -0.00949017f, -0.04335174f, 0.02821518f, 
    0.01322554f, -0.03110498f, -0.00048520f, -0.02850047f, -0.03009618f, -0.00834690f, 0.01287702f, -0.03356543f, 
    -0.01420313f, 0.04194466f, -0.03827415f, -0.05728181f, -0.02529242f, 0.00205834f, -0.02881002f, -0.03754099f, 
    -0.03759455f, -0.04620967f, 0.01798995f, 0.01316776f, 0.01975610f, -0.04086994f, -0.00884481f, -0.03208376f, 
    -0.05402210f, -0.01772248f, -0.03998907f, -0.01900172f, -0.01540106f, 0.02928519f, 0.01432798f, -0.03217990f, 
    0.02199212f, -0.03268278f, -0.02138533f, -0.00458284f, 0.00315966f, -0.02968352f, -0.02129575f, 0.03743053f, 
    0.02095253f, -0.00139581f, 0.02292867f, -0.00872867f, 0.03828437f, 0.01159450f, -0.03802262f, -0.03972275f, 
    -0.02992058f, 0.02068720f, -0.02089964f, 0.02650580f, 0.00914725f, -0.02567149f, 0.02340703f, 0.02110602f, 
    -0.00607933f, 0.00456658f, -0.02070379f, 0.01674880f, 0.02719067f, 0.01423933f, -0.05687307f, 0.03105112f, 
    0.04263359f, -0.03783837f, -0.05675063f, 0.00581235f, -0.00154769f, 0.03297754f, 0.03179247f, 0.03958412f, 
    -0.01717524f, -0.02153661f, 0.03740137f, -0.03803173f, -0.00390572f, 0.02955543f, -0.00070939f, 0.02873357f, 
    -0.02733884f, 0.00683304f, 0.04270069f, -0.00676426f, 0.03745476f, 0.01059899f, 0.00608832f, -0.00173602f, 
    -0.04843795f, -0.00647255f, 0.00962641f, -0.03616474f, 0.05249883f, -0.03392557f, -0.02932280f, -0.01851032f, 
    -0.05238430f, -0.04278712f, -0.03430175f, -0.04228986f, 0.02331126f, -0.05403301f, -0.01925377f, 0.00717804f, 
    0.00108305f, -0.02849769f, -0.01210294f, 0.02440303f, -0.04850008f, 0.02782304f, -0.00281756f, -0.00807138f, 
    0.04938673f, 0.01638395f, 0.01489771f, -0.03913303f, 0.00385661f, 0.03441662f, 0.00739161f, -0.01308855f, 
    0.03296401f, -0.01332812f, -0.01830689f, 0.03171524f, 0.00215483f, 0.00355200f, -0.01926800f, -0.05065886f, 
    -0.05209806f, -0.04247843f, -0.02959503f, -0.05383842f, 0.00922126f, -0.02651249f, -0.03714662f, 0.03882512f, 
    -0.02070358f, -0.05298974f, -0.01551159f, 0.03471750f, -0.00536855f, 0.01829913f, -0.03543178f, 0.04365458f, 
    0.03307357f, -0.01825933f, 0.00175338f, -0.03615763f, 0.02251488f, -0.01137989f, -0.03039031f, 0.03890605f, 
    0.03120569f, -0.01567820f, 0.00838486f, -0.03712624f, -0.00703214f, 0.03231684f, 0.03978601f, -0.05459499f, 
    -0.04816202f, -0.00707310f, 0.02524596f, -0.05632211f, 0.01063789f, 0.03636678f, -0.04373898f, 0.01714151f, 
    0.01879368f, -0.03984619f, -0.02966059f, -0.01453549f, 0.00699936f, -0.00634705f, 0.01283145f, 0.04019733f, 
    -0.04435095f, -0.01358622f, 0.03296639f, -0.03375346f, 0.01287584f, -0.00993637f, 0.03205555f, 0.03023101f, 
    -0.03797943f, 0.00575472f, 0.02833914f, 0.02282241f, -0.00995228f, -0.03083162f, -0.00482488f, 0.02683323f, 
    -0.03282792f, 0.02741106f, -0.00868921f, 0.02355196f, -0.04389079f, -0.01672996f, -0.01990597f, 0.01937006f, 
    0.03612280f, 0.03560298f, -0.05115214f, -0.04794605f, 0.03530480f, 0.03477313f, -0.02923376f, -0.00761881f, 
    -0.00896704f, -0.04386336f, -0.05316320f, -0.03396707f, -0.05774449f, -0.00588317f, 0.02694643f, 0.02808033f, 
    0.03874838f, 0.00709017f, -0.03654130f, -0.04454686f, 0.01421472f, 0.00472533f, -0.00533177f, -0.02858971f, 
    -0.01169148f, -0.00480395f, -0.05858411f, -0.03837933f, 0.01191763f, -0.04391085f, 0.00223026f, -0.05501408f, 
    -0.03580347f, 0.02959019f, 0.01958477f, -0.05498302f, -0.00651494f, -0.04779644f, 0.00425245f, -0.05249970f, 
    0.03860869f, 0.03853814f, -0.01807557f, -0.01673353f, -0.05667308f, -0.03758013f, -0.02331704f, -0.01020911f, 
    0.03204837f, -0.01225371f, 0.03253012f, 0.02819952f, -0.02094279f, 0.03684529f, -0.01678223f, -0.00549570f, 
    -0.03108979f, 0.02576960f, -0.03063621f, 0.01032941f, -0.02257215f, -0.00692696f, -0.02046601f, -0.01502389f, 
    0.01830693f, -0.01541528f, -0.02836183f, 0.00583803f, -0.03954938f, 0.02118061f, -0.03720830f, -0.00337438f, 
    -0.01258250f, -0.01057104f, -0.05820342f, -0.04322559f, 0.03980637f, -0.03137980f, 0.03141819f, -0.00646621f, 
    0.01504388f, 0.00232682f, 0.00100111f, -0.04058057f, -0.01787261f, -0.00058693f, -0.01043614f, 0.00329516f, 
    -0.03368966f, -0.02620498f, -0.02268982f, 0.04108733f, -0.04456350f, -0.01420338f, -0.03295392f, -0.01099309f, 
    0.03540841f, -0.00559092f, -0.03285556f, 0.01756926f, -0.00339213f, -0.02798051f, 0.03272867f, -0.03467440f, 
    0.02214998f, 0.02717468f, -0.05763639f, 0.02398539f, -0.01946605f, -0.03773745f, 0.02703757f, -0.00059301f, 
    -0.05363921f, 0.00111883f, -0.04106997f, 0.01740867f, 0.01423362f, -0.01024167f, 0.00831190f, -0.05831937f, 
    -0.05273043f, -0.05813311f, 0.01754537f, 0.01916828f, -0.04949239f, -0.00474424f, -0.01236802f, 0.02683980f, 
    0.00775524f, -0.00142055f, -0.00722023f, -0.00485293f, -0.02393700f, 0.01941678f, -0.03721889f, -0.03372166f, 
    -0.02726631f, -0.02810173f, 0.02903919f, 0.02450343f, -0.02349397f, -0.04511209f, 0.03089690f, -0.03707933f, 
    0.01734977f, -0.00199403f, 0.01362185f, -0.01805974f, 0.04119540f, 0.00926845f, 0.03305554f, -0.01918777f, 
    -0.05050172f, 0.02991809f, -0.05282856f, -0.04431516f, -0.02661051f, -0.00337053f, -0.03423792f, 0.03739145f, 
    -0.01252748f, -0.02957291f, -0.02715417f, -0.01052532f, -0.03538931f, 0.03774070f, -0.00129848f, -0.03752514f, 
    -0.02937361f, 0.00138343f, 0.01586447f, -0.05637369f, 0.03684130f, 0.03034138f, 0.00629903f, -0.01829448f, 
    -0.01569160f, -0.00505905f, 0.01069914f, -0.00404582f, 0.02905394f, 0.02553489f, 0.00564250f, 0.03715771f, 
    -0.03148467f, 0.02517273f, -0.02427068f, -0.05735593f, 0.01912775f, -0.03085024f, -0.01111844f, -0.00369077f, 
    -0.02923587f, 0.01375130f, -0.01228532f, 0.00373451f, -0.04799945f, 0.00955021f, 0.00252065f, 0.01288065f, 
    -0.02885771f, 0.02613885f, -0.01624418f, -0.03114556f, 0.01643009f, -0.00962239f, 0.01353409f, -0.05494895f, 
    -0.00780596f, 0.02615439f, -0.01405217f, 0.01707433f, -0.01018243f, 0.01099425f, 0.02374712f, 0.01560109f, 
    -0.01834816f, -0.00902737f, 0.01881155f, -0.03436574f, 0.04436525f, 0.03668163f, -0.01577062f, -0.02756918f, 
    -0.04160021f, 0.00357163f, 0.01368839f, -0.02286320f, -0.04750080f, -0.05876932f, -0.04594421f, -0.04990070f, 
    -0.02383632f, 0.00940439f, 0.01211311f, 0.01279817f, 0.00140358f, 0.03260022f, -0.01886816f, 0.00481102f, 
    0.02560879f, 0.02536127f, -0.02782490f, 0.02663542f, -0.00564942f, -0.05272675f, 0.03381472f, -0.05674915f, 
    -0.00850817f, -0.03482869f, 0.00817278f, 0.03322805f, -0.03232004f, -0.03930141f, -0.04708996f, -0.02057443f, 
    -0.04531765f, -0.02417334f, 0.02089636f, 0.00988538f, -0.04005852f, 0.04364910f, -0.00331612f, -0.04408380f, 
    0.00694675f, -0.04223539f, -0.04207882f, 0.02655669f, -0.00048969f, 0.01156131f, 0.00781971f, 0.00851388f, 
    0.00049904f, -0.02728177f, -0.01550603f, -0.04145987f, -0.01655908f, -0.03807189f, 0.01855663f, -0.00728838f, 
    0.02265549f, 0.00334965f, 0.03595610f, 0.03524232f, -0.02029186f, 0.02635822f, 0.02785504f, -0.05048811f, 
    0.03836574f, -0.00504741f, -0.02791849f, 0.03273087f, 0.04269822f, 0.02235248f, -0.02557943f, -0.01138323f, 
    0.04033578f, -0.03388424f, -0.00903612f, -0.00836276f, -0.02896691f, 0.00386468f, 0.04518410f, -0.00982527f, 
    -0.01138154f, -0.01042878f, -0.01651966f, 0.01510735f, -0.04348949f, 0.02350605f, 0.02420006f, 0.01013846f, 
    0.00133384f, 0.03318826f, -0.05227026f, -0.00548200f, 0.04175416f, -0.02145897f, 0.01112888f, -0.05398256f, 
    -0.01446803f, 0.03411929f, 0.01077916f, 0.02353843f, -0.00106327f, 0.02286871f, -0.04718226f, 0.01857975f, 
    -0.02546656f, -0.04255663f, -0.04935420f, -0.04853386f, -0.05492578f, -0.00154441f, 0.01136523f, 0.03824345f, 
    -0.01584810f, -0.02747932f, -0.04153617f, 0.00916909f, -0.05118550f, -0.01064569f, -0.04438286f, 0.03046554f, 
    0.02230483f, -0.01023785f, -0.02587797f, 0.00575784f, 0.01040500f, 0.01970422f, -0.05513278f, -0.01319910f, 
    -0.02830539f, -0.05391512f, 0.02420316f, -0.03396188f, -0.04284228f, -0.04747647f, 0.04189916f, -0.04593224f, 
    0.00313109f, 0.00027745f, -0.04474253f, -0.02425810f, -0.01101522f, -0.01879058f, -0.04091952f, -0.03091344f, 
    -0.04867516f, -0.01909776f, -0.03790257f, 0.02019438f, 0.01355024f, -0.05596427f, -0.03156395f, -0.04400109f, 
    -0.00928078f, -0.04491771f, -0.04472528f, 0.03001447f, -0.02261128f, -0.03822654f, 0.00600088f, 0.02006389f, 
    0.00232801f, -0.04704962f, 0.01248915f, -0.00221236f, -0.03986850f, -0.00423463f, -0.00896459f, -0.04433223f, 
    0.01565530f, 0.03811536f, -0.04544060f, -0.03048927f, 0.02094101f, -0.02742043f, 0.00240903f, 0.01130914f, 
    0.02803012f, 0.04165760f, 0.03243739f, 0.01676796f, -0.04786752f, 0.01672002f, -0.02803710f, 0.01284035f, 
    0.01942405f, -0.04918835f, -0.00924306f, 0.00877336f, 0.01846485f, -0.01183655f, -0.04089887f, -0.03292405f, 
    0.33615595f, 0.00974148f, -0.07838383f, -0.18752028f, 0.05243844f, 0.02432335f, 0.10527519f, -0.03105884f, 
    -0.00223405f, -0.01895837f, -0.00136549f, -0.08653168f, 0.16994265f, 0.03611421f, 0.04824957f, 0.28764001f, 
    -0.04709196f, 0.06494956f, 0.04561171f, 0.15749887f, 0.12125606f, 0.06791282f, -0.07220903f, 0.11692840f, 
    -0.46136874f, 0.03333734f, 0.27768165f, 0.24867427f, 0.02572026f, 0.15234581f, 0.15376733f, -0.03993714f, 
    -0.00899701f, 0.05277566f, 0.00052466f, 0.05233881f, -0.07623480f, 0.03477579f, -0.12050010f, 0.05323360f, 
    0.02360086f, 0.03560330f, 0.02613609f, -0.12456349f, 0.03317231f, 0.01243317f, 0.01191587f, -0.03039242f, 
    0.02765268f, 0.11251266f, -0.11216094f, -0.05692932f, 0.04863812f, 0.09541190f, 0.04212241f, 0.12260976f, 
    0.08829111f, 0.08675448f, 0.05752286f, -0.10248648f, 0.30087590f, 0.18760277f, 0.09507971f, 0.03095999f, 
    -0.13394232f, -0.06340998f, -0.03114546f, 0.06452502f, -0.00998856f, -0.07211608f, -0.02501140f, 0.03194250f, 
    0.10620263f, 0.12708482f, 0.08723032f, 0.37194425f, 0.07814083f, 0.09007603f, 0.21211664f, -0.04092752f, 
    -0.02631875f, 0.03311787f, 0.01992094f, 0.01753793f, 0.17354862f, -0.00463016f, -0.00356880f, -0.15949191f, 
    0.18468052f, -0.08440598f, 0.13050742f, 0.10415615f, -0.02128258f, -0.00013717f, 0.01591824f, 0.06771506f, 
    -0.19137855f, 0.08214063f, -0.01701583f, -0.33678168f, 0.06423309f, 0.05694249f, -0.03241443f, 0.04414213f, 
    0.04398172f, 0.06848489f, 0.03065262f, 0.07476622f, 0.25852272f, 0.14249012f, -0.17136034f, -0.13479812f, 
    0.11899564f, 0.05855487f, 0.20204970f, 0.11583801f, -0.00327110f, 0.02709371f, 0.01764079f, -0.09708156f, 
    0.29837051f, 0.13361394f, -0.00310439f, -0.07246825f, -0.08701174f, 0.02140433f, -0.00740924f, 0.08542413f, 
    0.06329004f, 0.02535338f, 0.12479150f, 0.04388971f, -0.31287810f, 0.06893277f, 0.10600016f, -0.02420802f, 
    -0.13452779f, 0.15682808f, 0.12282829f, 0.01018758f, 0.10665792f, 0.05518962f, 0.03365654f, -0.02088544f, 
    -0.13538000f, 0.26022792f, -0.01576900f, -0.12867324f, 0.12688211f, 0.04679377f, -0.03862023f, 0.03162460f, 
    -0.04598492f, 0.02127084f, -0.05972094f, 0.03863763f, 0.06432147f, 0.03742211f, -0.11254495f, -0.21378896f, 
    -0.00005927f, 0.08599314f, 0.04432257f, 0.04150777f, 0.10019030f, -0.01538409f, 0.12639076f, 0.15292794f, 
    -0.08903206f, 0.03725370f, -0.06938015f, -0.16785915f, -0.04608027f, 0.03060549f, -0.09442883f, -0.09681009f, 
    0.00762094f, 0.00726717f, -0.06942777f, 0.03467868f, -0.03116938f, 0.03508622f, -0.08859546f, 0.06271940f, 
    0.07561263f, 0.16472861f, 0.01846620f, 0.09017956f, 0.07660661f, 0.03842583f, 0.00375895f, 0.03926656f, 
    -0.20008263f, -0.10847706f, 0.16213985f, 0.32328701f, 0.03923852f, -0.01865279f, 0.01256581f, 0.10975125f, 
    0.02932275f, 0.00165576f, 0.02379047f, -0.00551816f, -0.06564815f, 0.13670456f, -0.13676529f, 0.24764588f, 
    0.08305582f, 0.13859443f, 0.09586206f, -0.01219992f, 0.00996074f, 0.11035096f, -0.00465780f, -0.03454241f, 
    0.11798415f, -0.07043967f, -0.12951481f, -0.06167099f, 0.11770348f, 0.04869871f, 0.14860730f, 0.04532572f, 
    0.01448227f, 0.16908561f, 0.07269456f, -0.01177998f, 0.12956788f, 0.19822629f, -0.07125363f, 0.13230407f, 
    0.06157671f, 0.14935943f, -0.00729147f, 0.01872678f, 0.03901036f, -0.04946279f, 0.02666842f, 0.04644843f, 
    -0.18278024f, -0.02504665f, -0.06403382f, -0.12044210f, 0.10345759f, 0.06498337f, 0.09963375f, 0.10910263f, 
    0.04776781f, 0.02828921f, 0.04555485f, 0.00694328f, -0.25759295f, -0.03626102f, -0.04210415f, -0.10291551f, 
    -0.05296318f, -0.02041426f, 0.04819643f, 0.05091476f, 0.04906292f, 0.07298634f, -0.00582261f, 0.13295272f, 
    -0.17300670f, 0.06398987f, -0.01506306f, -0.25505641f, -0.01828604f, 0.00326465f, 0.08553958f, 0.03177514f, 
    0.02109239f, 0.03372318f, -0.10293842f, -0.00838558f, 0.10435963f, -0.12124600f, 0.05907539f, -0.07785647f, 
    0.13617976f, 0.03252187f, 0.09320349f, 0.01110285f, 0.04880373f, -0.12154050f, -0.00617723f, -0.01867271f, 
    0.07379580f, -0.18971324f, 0.14753932f, 0.34705812f, -0.00407610f, 0.08772131f, 0.13976848f, -0.02490193f, 
    -0.04467419f, 0.00787684f, 0.04703131f, 0.02559814f, 0.24633054f, 0.08967262f, 0.00921680f, -0.07208116f, 
    0.12354901f, 0.01960656f, 0.05052640f, -0.11662639f, -0.05890975f, -0.04366335f, 0.02232675f, -0.03432429f, 
    -0.06250662f, 0.00547349f, 0.02118942f, 0.01613748f, 0.01850993f, 0.03096367f, 0.00333107f, 0.07034511f, 
    0.14591818f, 0.09383708f, 0.10153381f, 0.09941655f, 0.19213910f, 0.13959029f, 0.01643427f, 0.21145910f, 
    -0.00550359f, -0.00122268f, 0.00123645f, 0.04662624f, -0.10570218f, -0.03123574f, -0.05295886f, 0.17222422f, 
    -0.17376527f, 0.09945545f, -0.06661663f, -0.21226262f, -0.02657947f, 0.13012815f, -0.01201010f, -0.00584536f, 
    0.04422141f, 0.00729351f, 0.01556652f, -0.02026782f, 0.07911559f, 0.23755537f, 0.05845671f, 0.18935251f, 
    0.06317643f, 0.16081275f, 0.00767836f, 0.12407879f, -0.05042547f, -0.10559884f, 0.04505219f, 0.06030526f, 
    -0.22552018f, 0.10830895f, 0.00707424f, -0.23844555f, 0.17424038f, 0.05868179f, 0.06681579f, 0.09488810f, 
    -0.04538126f, -0.01860638f, -0.01342023f, -0.00820025f, 0.19212638f, 0.09748814f, -0.03601266f, 0.01575679f, 
    0.15045774f, 0.08201247f, 0.08587851f, -0.03148568f, -0.03929147f, 0.03188126f, -0.03280626f, -0.07616968f, 
    -0.07048177f, -0.01456304f, 0.12990125f, 0.10856457f, 0.15257163f, 0.11080892f, -0.12856536f, -0.02281774f, 
    -0.05764329f, -0.01916460f, 0.01627528f, 0.07763477f, -0.06589764f, 0.00049804f, 0.07190891f, -0.04686268f, 
    0.04046496f, -0.10825254f, -0.02152200f, -0.10446887f, -0.00895968f, 0.04228114f, 0.07895234f, -0.11104671f, 
    0.53735638f, 0.31173998f, -0.20341073f, -0.19186668f, -0.05579652f, -0.00229234f, 0.06465355f, -0.07167891f, 
    -0.04641804f, 0.11809929f, -0.04755126f, -0.08604067f, -0.25443998f, 0.05204667f, 0.06118333f, 0.09678303f, 
    0.08125568f, -0.09597519f, -0.05814464f, 0.08674449f, 0.04694438f, 0.07212074f, -0.03883872f, 0.03197996f, 
    0.06387729f, -0.09126048f, 0.09680082f, -0.07498761f, -0.05189229f, -0.07545617f, -0.03142417f, -0.02055984f, 
    -0.03381209f, -0.00491946f, 0.03749611f, 0.08226857f, -0.17322600f, -0.13011989f, -0.04523806f, 0.03906677f, 
    -0.08611680f, 0.00489321f, 0.04126525f, 0.07797618f, 0.05941164f, 0.01814805f, -0.09671051f, -0.03097835f, 
    0.06770266f, 0.12116703f, -0.00982583f, 0.08287588f, 0.01881821f, 0.03542036f, 0.04332471f, 0.12677576f, 
    -0.08301053f, 0.02241671f, 0.06513832f, 0.09873261f, 0.05270677f, -0.06922695f, -0.02252543f, 0.12144010f, 
    -0.11553562f, 0.04624700f, -0.04977833f, -0.04035961f, -0.02516928f, -0.06904254f, -0.00497501f, -0.12590010f, 
    0.24054079f, 0.04725697f, 0.12968056f, 0.27407241f, -0.09473416f, -0.00828539f, 0.06310682f, -0.05443336f, 
    -0.06795935f, -0.02503982f, -0.05946180f, -0.10737437f, 0.19400908f, -0.02552485f, 0.13955046f, -0.00601153f, 
    0.04603049f, 0.04695138f, 0.00755605f, 0.03190990f, -0.12320682f, -0.00109575f, 0.00206790f, 0.00547156f, 
    -0.39493373f, -0.10002369f, 0.12345059f, -0.09075356f, -0.01637007f, 0.07629661f, 0.04024724f, -0.13161635f, 
    -0.04975716f, 0.02359379f, -0.07757892f, -0.07904200f, 0.27506927f, -0.23487312f, -0.25375086f, -0.03664913f, 
    -0.00207712f, 0.03049098f, 0.06306073f, 0.08028307f, -0.03998527f, -0.11582989f, -0.08171975f, 0.00918979f, 
    -0.09883340f, 0.28693694f, -0.12007393f, 0.02952036f, -0.10018429f, 0.07220274f, 0.01708891f, 0.00628554f, 
    -0.03123544f, 0.11034116f, 0.04404645f, -0.07108161f, 0.18498468f, -0.15702453f, 0.06026632f, 0.15578562f, 
    0.01780582f, -0.10527052f, 0.03245068f, 0.08195896f, -0.05184156f, -0.04402360f, 0.01298663f, -0.00017179f, 
    0.45875683f, 0.04081566f, 0.07580412f, 0.27060395f, -0.08685000f, 0.11575942f, 0.04009191f, 0.05584741f, 
    0.01264627f, 0.00279373f, -0.06896528f, -0.03490706f, 0.01822628f, 0.06905000f, 0.01932479f, 0.09101287f, 
    0.01941683f, 0.07335583f, 0.06243216f, 0.06365731f, -0.07774182f, -0.07665094f, -0.05078933f, 0.05151252f, 
    0.11309223f, 0.14275227f, 0.00958936f, -0.17229082f, -0.13090356f, 0.09199958f, -0.05133520f, -0.06469364f, 
    0.00500374f, -0.04540521f, -0.00798105f, -0.07567669f, 0.30750057f, 0.01250027f, 0.04459633f, 0.08012659f, 
    0.13248280f, 0.00563564f, -0.00933310f, 0.11206016f, 0.05586866f, -0.09353352f, 0.07994005f, 0.01247914f, 
    -0.09823480f, 0.03010782f, -0.04492952f, -0.08967622f, -0.09104262f, 0.01597118f, -0.08142149f, 0.03076996f, 
    0.10422441f, -0.05021538f, 0.06358946f, 0.10633793f, -0.11303491f, -0.10260926f, 0.18015975f, -0.00221906f, 
    -0.01497973f, -0.03433672f, -0.03527206f, 0.06802837f, -0.00177990f, -0.00302228f, -0.06166273f, 0.06702939f, 
    -0.15034068f, 0.20234001f, 0.03484339f, -0.06393332f, 0.03566989f, 0.03103201f, -0.00900629f, -0.08081385f, 
    0.10425225f, 0.05562729f, 0.02713923f, 0.04309041f, 0.08530970f, 0.03251592f, 0.14580688f, 0.15817609f, 
    -0.02327258f, 0.02252745f, 0.04762487f, -0.06009463f, 0.00566815f, -0.00823682f, 0.05552198f, 0.00086102f, 
    0.11087850f, 0.17189410f, 0.03399070f, 0.30638441f, -0.09654751f, 0.08506644f, 0.01410180f, -0.02330804f, 
    -0.05300015f, -0.01071088f, 0.11709875f, 0.07356591f, 0.00936568f, -0.02431090f, 0.00379510f, 0.05880214f, 
    -0.08363157f, -0.04604035f, -0.12943037f, 0.08959969f, 0.03196376f, 0.10927853f, -0.01085464f, 0.10516661f, 
    -0.13994442f, -0.00706786f, 0.03349206f, -0.10993788f, -0.08474500f, 0.02147600f, -0.00515446f, -0.04616909f, 
    -0.02911448f, 0.04842532f, -0.03555781f, -0.09622939f, 0.26504585f, -0.20983526f, -0.01222083f, 0.00803514f, 
    -0.01802372f, 0.02590402f, 0.02035296f, 0.13480173f, -0.04629241f, 0.05271403f, -0.00094132f, 0.00115042f, 
    -0.09041684f, -0.07418091f, -0.04783283f, -0.03266004f, -0.14165054f, -0.06967910f, 0.04979551f, -0.06176015f, 
    0.03659094f, 0.03221113f, -0.04331629f, -0.11157229f, -0.23056462f, -0.13904129f, 0.14071226f, 0.07674435f, 
    -0.11283399f, -0.07559481f, -0.02596339f, -0.01066307f, -0.02225348f, 0.01963929f, 0.02072833f, -0.04916055f, 
    0.16372004f, 0.00280993f, -0.06246798f, 0.22777283f, -0.04494476f, -0.04431224f, 0.10484773f, -0.02111723f, 
    -0.07609458f, -0.04744848f, -0.00938796f, -0.01601919f, -0.03018789f, 0.01897630f, 0.06089729f, 0.09161129f, 
    0.16434659f, 0.00506981f, -0.02865202f, 0.04129632f, 0.21215187f, 0.10850096f, -0.07251148f, 0.14073041f, 
    0.10247172f, -0.06917191f, 0.10699230f, 0.12482573f, -0.12381109f, 0.02769828f, -0.12998077f, -0.05252077f, 
    -0.08692308f, 0.08205125f, -0.06071941f, 0.04770258f, 0.01232436f, 0.24856493f, -0.02758539f, 0.18295343f, 
    -0.00353714f, -0.01887038f, 0.05685876f, 0.08412986f, 0.05018106f, 0.02031855f, 0.13228819f, 0.06528207f, 
    -0.24260278f, -0.06704574f, -0.05706683f, -0.14843690f, 0.03435332f, 0.01622409f, 0.00353601f, 0.05623849f, 
    -0.06136937f, 0.05335438f, 0.13636442f, 0.33046827f, -0.18681499f, -0.13058308f, 0.18330395f, 0.20904680f, 
    0.01002910f, -0.00329561f, 0.01554716f, -0.08034866f, 0.00223397f, -0.15986344f, -0.04002931f, -0.28522700f, 
    0.04845453f, -0.08583037f, 0.13388287f, 0.04330719f, -0.04679039f, -0.01151297f, 0.03078609f, 0.09781332f, 
    0.02591493f, -0.02446005f, 0.06966670f, 0.13345239f, 0.06550210f, -0.10559200f, 0.09066514f, 0.12686111f, 
    -0.01480374f, 0.09940905f, 0.05546656f, 0.08947624f, 0.03930262f, 0.05932079f, -0.02573008f, 0.20572160f, 
    -0.09763117f, -0.10538600f, 0.13044187f, 0.06645469f, 0.00902061f, 0.01858159f, -0.05416491f, -0.01448604f, 
    -0.04446476f, -0.06008581f, 0.10993578f, -0.01282983f, 0.21801603f, 0.23241183f, -0.02406095f, -0.00207426f, 
    0.02475005f, 0.00407016f, -0.14047624f, 0.01462600f, -0.10430937f, 0.16136935f, -0.12435622f, 0.06606382f, 
    0.16091658f, 0.03121621f, 0.04087571f, 0.06967378f, -0.00769199f, -0.04299689f, -0.12630890f, -0.08074917f, 
    -0.02340870f, -0.01006774f, 0.03117501f, 0.13348401f, 0.07850125f, 0.07847590f, -0.14243664f, -0.16714321f, 
    -0.06882197f, 0.04316612f, 0.01785895f, 0.08403844f, 0.00715310f, 0.20406520f, -0.02136940f, 0.13469070f, 
    -0.03954128f, 0.07051940f, 0.12489787f, -0.20331140f, 0.05161443f, -0.04682653f, -0.01546949f, 0.03165951f, 
    -0.05778204f, 0.00828542f, -0.05486937f, -0.10159299f, -0.05320708f, 0.12115160f, 0.04323675f, -0.19325295f, 
    -0.10218382f, 0.01269620f, -0.04689049f, -0.07919173f, 0.03852300f, 0.09054949f, -0.06524087f, 0.04157616f, 
    0.14681615f, -0.00097388f, -0.08089222f, -0.16319878f, -0.02058271f, -0.03189745f, 0.14990258f, 0.05175389f, 
    0.04091644f, -0.04342691f, -0.08995006f, -0.12446874f, -0.22853245f, 0.20530316f, 0.15888739f, 0.23170322f, 
    0.11748577f, 0.08319896f, -0.01309353f, 0.05661985f, 0.10305312f, 0.07980236f, 0.18349482f, 0.01298524f, 
    -0.10408039f, -0.19795139f, 0.00962740f, -0.14747284f, 0.01862608f, 0.05699018f, 0.07776627f, 0.08591431f, 
    0.06634881f, 0.08595172f, 0.00822209f, 0.12592141f, 0.08311225f, 0.28298801f, -0.05400391f, -0.00668561f, 
    -0.08167224f, 0.05942369f, 0.02634066f, 0.07921900f, 0.11507773f, 0.03460849f, -0.07411389f, -0.11977391f, 
    0.14134161f, 0.40863863f, -0.13192521f, -0.17171825f, -0.00210447f, 0.14759266f, 0.15220794f, 0.02770597f, 
    -0.01621882f, -0.09242789f, -0.05203397f, -0.05956426f, -0.05699253f, 0.06186148f, 0.13137494f, 0.00962329f, 
    0.01771690f, 0.10883331f, 0.04115781f, -0.18630679f, 0.06914179f, -0.07620756f, 0.06557883f, 0.02439116f, 
    0.36318797f, -0.01666045f, -0.21190967f, 0.07787635f, -0.06377137f, -0.01762011f, 0.11460879f, -0.07261522f, 
    -0.20062190f, 0.04355107f, 0.13724849f, 0.03715380f, -0.20325160f, -0.01123826f, -0.10239553f, -0.10498680f, 
    0.05799753f, 0.02332155f, -0.06675091f, -0.12646194f, -0.07777185f, 0.12529650f, -0.08544447f, 0.15054542f, 
    -0.35696626f, 0.06279066f, -0.04639729f, 0.22055365f, 0.16959468f, 0.03861010f, -0.13283746f, 0.01423579f, 
    0.06678868f, 0.04866735f, -0.00073425f, -0.11096273f, -0.33058456f, 0.23532274f, 0.04906688f, -0.14617684f, 
    0.05771174f, 0.00223497f, 0.09198812f, -0.05719129f, 0.03220673f, 0.03126664f, -0.09268925f, -0.01117215f, 
    0.03965870f, -0.11013169f, 0.01665414f, 0.19447145f, 0.12551643f, 0.05116573f, 0.05775855f, 0.00906725f, 
    -0.08963894f, 0.09202209f, -0.15607187f, 0.06795876f, 0.24313504f, -0.05225222f, 0.00422273f, -0.05180763f, 
    0.03564965f, 0.05281961f, 0.07715722f, 0.04366518f, -0.01582557f, -0.14467873f, -0.13601305f, -0.04389470f, 
    -0.06459588f, 0.25947663f, -0.00422578f, -0.15357766f, 0.07160105f, -0.02672290f, 0.05391989f, 0.17001529f, 
    -0.00243303f, 0.07267859f, 0.04107401f, 0.19020610f, -0.13107891f, 0.18517089f, 0.09713882f, -0.06016501f, 
    0.10355741f, 0.01947022f, 0.01247542f, 0.02003055f, 0.03886031f, -0.01048601f, 0.24835134f, -0.05273379f, 
    0.05229760f, -0.19319369f, -0.00732440f, 0.20635372f, -0.05138741f, 0.07752012f, -0.03551859f, -0.03935632f, 
    -0.02127839f, -0.10288404f, -0.09053458f, -0.05074197f, 0.13818809f, 0.29470462f, -0.09675868f, 0.23973896f, 
    -0.07290807f, -0.01054924f, 0.08198118f, -0.01658096f, 0.04366980f, 0.15705587f, 0.02950899f, 0.09442506f, 
    0.29772967f, -0.04788912f, 0.08480857f, -0.09301631f, 0.04214944f, 0.02308950f, -0.04420286f, 0.04195920f, 
    -0.00002556f, -0.10154680f, -0.09727522f, -0.15944880f, -0.05406075f, 0.11329728f, -0.17093199f, 0.00536056f, 
    0.00235378f, 0.04936343f, -0.05541712f, 0.03135798f, 0.04748471f, -0.07207950f, 0.11872119f, -0.14806454f, 
    0.19622645f, 0.02920548f, 0.25424570f, -0.27299908f, 0.08032516f, -0.08853601f, 0.13386185f, 0.01918923f, 
    0.19113581f, 0.12813906f, -0.01169612f, 0.17039452f, -0.03104234f, -0.02095649f, 0.12506385f, 0.09842862f, 
    -0.02427619f, -0.11238597f, -0.07493030f, 0.02206836f, 0.14085381f, -0.08513503f, -0.06878366f, -0.14868265f, 
    -0.25361085f, -0.02019835f, 0.13158503f, -0.10264683f, 0.08824492f, 0.07464294f, 0.09344323f, 0.11586972f, 
    0.02962045f, 0.17063560f, 0.04327238f, -0.21420451f, -0.07601058f, 0.06287997f, -0.07952096f, -0.07260806f, 
    -0.11272242f, -0.10905129f, 0.04343360f, -0.00039453f, 0.05790545f, -0.06475552f, -0.01659008f, -0.11347846f, 
    -0.00029297f, 0.03172554f, 0.03575671f, -0.03036129f, -0.03620250f, 0.00025630f, 0.01231207f, -0.02756881f, 
    0.03116161f, 0.00336606f, 0.03100276f, -0.05378941f, 0.01409854f, -0.01967905f, -0.00325670f, -0.02770729f, 
    0.00098694f, -0.02460507f, 0.02119185f, 0.00354054f, 0.03900811f, 0.02084302f, -0.00926786f, -0.02695927f, 
    0.02689145f, 0.04275034f, -0.01686935f, 0.00475634f, 0.03143210f, 0.00482410f, -0.00045504f, -0.04064490f, 
    -0.05051370f, -0.01146488f, -0.05144341f, 0.00868538f, -0.03409087f, -0.04682015f, -0.00603230f, 0.04359516f, 
    -0.00193340f, -0.02904510f, -0.00778262f, -0.03973351f, -0.00662866f, -0.04481227f, 0.03530627f, -0.02016079f, 
    0.04314049f, -0.02499831f, -0.00569773f, -0.02862162f, 0.03446614f, -0.05566710f, -0.02270897f, -0.04995223f, 
    0.00324026f, 0.04135318f, -0.04128277f, -0.00969877f, -0.03884586f, -0.03531500f, -0.01704692f, 0.03606891f, 
    0.02984865f, 0.00146880f, 0.03438274f, -0.02219297f, 0.00949302f, -0.04603684f, -0.01539363f, -0.04543654f, 
    -0.04386217f, 0.02437725f, 0.00136888f, -0.05580634f, 0.01661628f, -0.02348241f, -0.01455901f, -0.03717475f, 
    -0.01382264f, 0.00055088f, -0.04637920f, 0.04339092f, -0.01138577f, 0.00194295f, -0.02871124f, -0.05563791f, 
    -0.01597435f, -0.00462989f, -0.01439836f, -0.00419196f, -0.05026814f, -0.02019935f, 0.02993901f, -0.02891034f, 
    0.00268327f, -0.01620083f, -0.05243622f, -0.04530673f, 0.00769841f, 0.03904446f, -0.00727037f, -0.01968396f, 
    -0.03857995f, 0.02243125f, -0.04690803f, -0.00966817f, -0.03255317f, -0.04082480f, 0.01608084f, -0.03361785f, 
    -0.02879801f, -0.04459462f, -0.00773578f, -0.02571863f, 0.01997113f, -0.04691144f, -0.00339276f, 0.01884063f, 
    -0.05378110f, -0.02655490f, -0.04799313f, 0.00589272f, -0.01370412f, 0.00372349f, 0.01559567f, 0.01798024f, 
    0.04302227f, 0.02717796f, 0.00673868f, -0.00499909f, -0.02123133f, -0.02999526f, -0.00553624f, -0.02802039f, 
    0.00202742f, -0.03963391f, -0.02721428f, 0.04169613f, 0.00612959f, -0.03271345f, -0.00125304f, 0.00946721f, 
    0.02967977f, -0.02112113f, -0.01775799f, -0.04098773f, -0.05128325f, 0.03163018f, 0.02161904f, 0.00680778f, 
    -0.03512316f, -0.01494936f, 0.03212499f, -0.03204814f, -0.04693501f, 0.00466258f, 0.00132394f, 0.00169243f, 
    0.00745011f, 0.02183415f, -0.00614416f, -0.04182706f, -0.03214353f, -0.03658504f, 0.01368097f, -0.02764472f, 
    0.01160449f, -0.00672371f, -0.00712926f, 0.00892624f, -0.05132638f, -0.05408421f, 0.00486391f, 0.01321041f, 
    -0.01631423f, 0.01742235f, -0.04052570f, -0.00144898f, 0.02891366f, -0.02817575f, -0.03751266f, -0.00538954f, 
    0.03713913f, -0.01766993f, -0.03571467f, -0.03665319f, -0.05436401f, 0.00675522f, 0.03668285f, -0.02256753f, 
    -0.03097858f, 0.03763198f, -0.02332500f, 0.00943134f, 0.02875106f, 0.01820864f, 0.01452727f, 0.01322976f, 
    -0.03458124f, -0.01877926f, 0.02185435f, -0.02180299f, -0.00939691f, 0.01945784f, 0.02559118f, -0.05276239f, 
    0.01894366f, -0.05161601f, 0.00401228f, -0.04786844f, 0.01064271f, -0.03714372f, -0.05001693f, -0.05437655f, 
    -0.05481477f, -0.04589299f, -0.05095004f, 0.03663480f, 0.00433723f, 0.04056061f, 0.01905148f, -0.00974788f, 
    0.01698104f, -0.05070009f, 0.01732304f, 0.03948933f, 0.00698391f, -0.04300644f, -0.00661977f, -0.02955889f, 
    0.01486176f, -0.01200403f, -0.04934112f, -0.01372998f, 0.02762867f, 0.03030508f, -0.02474270f, -0.04895845f, 
    0.02419067f, -0.01079118f, -0.02709427f, 0.03560142f, 0.00747417f, 0.04234569f, -0.04935706f, -0.04274789f, 
    -0.04460036f, -0.03979699f, 0.03271087f, 0.03708932f, -0.03424587f, -0.04422890f, 0.00196346f, 0.04308502f, 
    0.04449911f, 0.03338673f, 0.00727463f, -0.04163798f, -0.00839843f, -0.01375435f, -0.01549071f, -0.01661140f, 
    0.03050874f, -0.05610978f, -0.04411565f, -0.00394497f, -0.02825363f, 0.01718321f, 0.00452202f, -0.03717996f, 
    0.01478031f, -0.00901338f, 0.04131418f, -0.00614925f, 0.04388712f, 0.03223200f, -0.00046204f, -0.03372303f, 
    0.02410403f, -0.03101702f, -0.05252942f, 0.02193077f, 0.03741975f, -0.02667156f, -0.04031676f, 0.03541178f, 
    0.00106956f, -0.05638883f, 0.03764607f, 0.02033278f, 0.00712058f, -0.05361293f, -0.03325010f, -0.01126071f, 
    -0.00275906f, -0.00071762f, 0.02120355f, 0.00758577f, -0.01527183f, -0.03559685f, 0.04044468f, -0.01603144f, 
    -0.02173988f, 0.00601681f, 0.03463302f, 0.03339243f, 0.04273352f, 0.01130339f, 0.02536496f, 0.00622770f, 
    -0.00592895f, 0.02930662f, 0.01923316f, -0.00809169f, 0.04475250f, -0.00460922f, -0.01042309f, 0.00106485f, 
    0.01687026f, 0.00566651f, -0.03019185f, 0.03316744f, -0.03791886f, 0.01639715f, -0.00454498f, -0.03984703f, 
    -0.05691138f, 0.00529752f, 0.03549142f, 0.03648393f, -0.02626888f, 0.03443006f, 0.02471027f, 0.01564964f, 
    -0.04506835f, -0.04805307f, -0.04262169f, 0.03614994f, 0.00906429f, 0.00851268f, -0.01829003f, -0.04126729f, 
    -0.03962601f, -0.05302933f, -0.04360433f, -0.04700416f, -0.03458367f, -0.02757927f, -0.02613695f, 0.04108728f, 
    -0.01383521f, -0.01668778f, -0.04294090f, -0.01482974f, 0.04242751f, -0.02919990f, 0.04500455f, -0.00739264f, 
    -0.01915159f, -0.05428111f, -0.05460041f, 0.03169079f, -0.04868002f, -0.04335452f, -0.00765936f, -0.00650479f, 
    -0.04412869f, -0.03604043f, 0.00661184f, -0.04161150f, 0.00088635f, 0.03130526f, -0.02561871f, 0.01059726f, 
    0.04374303f, -0.02028689f, 0.02503707f, -0.04929556f, -0.03989646f, 0.03391023f, -0.01911564f, 0.04129529f, 
    0.02231154f, -0.05601593f, 0.03402798f, -0.01303219f, -0.03968743f, -0.00381165f, -0.03739956f, 0.04098322f, 
    -0.02565717f, -0.05458630f, 0.03025829f, -0.03905058f, -0.00820116f, 0.03005735f, -0.03748163f, -0.04721620f, 
    0.02928051f, 0.00053149f, -0.00951941f, 0.00484222f, 0.02272683f, -0.03016986f, 0.02201717f, -0.02788296f, 
    0.00913441f, -0.00709301f, 0.03095537f, 0.01015706f, 0.01332639f, -0.05125865f, -0.05760031f, 0.00518179f, 
    0.01901034f, -0.00196274f, 0.03204820f, 0.02126645f, -0.01733162f, -0.03483255f, 0.00623557f, -0.00694590f, 
    -0.00914812f, -0.02191047f, 0.02058950f, -0.05767148f, -0.01493206f, -0.04343459f, -0.05734123f, 0.00868030f, 
    -0.00676854f, 0.02221739f, 0.02896252f, 0.00308434f, -0.05792199f, -0.04420982f, 0.00142296f, 0.01379744f, 
    0.00939043f, -0.00673744f, -0.04056076f, -0.02071827f, 0.02261269f, 0.03617371f, -0.04733949f, -0.04138153f, 
    -0.05678267f, -0.03402080f, -0.03790027f, -0.00286423f, -0.02407567f, -0.01401837f, 0.00139691f, 0.01722926f, 
    -0.04131737f, -0.04408687f, 0.03998394f, -0.01249959f, 0.00586187f, -0.04790723f, -0.01818252f, -0.00846301f, 
    0.02582347f, -0.05266173f, -0.02291767f, -0.01889873f, 0.00263852f, -0.05251094f, -0.03835522f, -0.05828729f, 
    -0.03399197f, -0.02208892f, -0.01685254f, -0.05147954f, -0.04280889f, -0.03473294f, 0.03504247f, 0.02533059f, 
    -0.03182634f, 0.01800613f, -0.02226259f, -0.02609872f, 0.03569863f, -0.03166638f, 0.02841279f, -0.03771728f, 
    0.03695105f, -0.03456800f, -0.02783290f, -0.05274851f, -0.00908758f, 0.01438210f, 0.00132885f, 0.00696408f, 
    0.02626008f, -0.01806636f, -0.04038433f, 0.02255674f, -0.04152220f, 0.00459908f, 0.03449050f, 0.03905867f, 
    -0.04742199f, 0.02020984f, -0.04631073f, -0.04401080f, 0.01763650f, -0.03521419f, -0.01251813f, -0.01448026f, 
    0.02786978f, -0.03051108f, 0.04343534f, 0.04264334f, -0.04136691f, -0.02619066f, 0.04000720f, -0.01759116f, 
    0.01911952f, 0.04325527f, 0.01778338f, 0.01034599f, 0.00361369f, 0.02479541f, -0.05216284f, -0.03428303f, 
    -0.04903796f, 0.00198208f, -0.02405743f, -0.05308739f, -0.00015089f, -0.03572859f, -0.02608306f, -0.01070371f, 
    0.00200904f, -0.03714485f, -0.04813319f, -0.00787427f, -0.03261181f, 0.01323770f, -0.05698898f, 0.00511125f, 
    -0.02333427f, -0.00271686f, 0.02886643f, 0.03129483f, -0.04628345f, 0.00525591f, -0.05373343f, -0.01495796f, 
    -0.00362626f, -0.01441045f, 0.03591032f, -0.05242887f, 0.04270713f, -0.05410871f, 0.03974944f, -0.04823639f, 
    -0.01642299f, -0.01021024f, 0.03680471f, -0.03342980f, -0.01576502f, -0.01074385f, 0.00988806f, -0.03638079f, 
    0.03536465f, 0.04236335f, 0.00337113f, -0.02821041f, 0.00709408f, -0.00416958f, -0.00432677f, 0.02526953f, 
    -0.00179703f, -0.01002414f, -0.01685946f, 0.02720196f, 0.01686175f, 0.03666455f, -0.00132411f, 0.01932026f, 
    -0.01780495f, -0.04839465f, -0.00176648f, -0.04403130f, 0.01286131f, -0.05776491f, -0.01392179f, -0.02595788f, 
    0.03030896f, 0.01073332f, -0.03305413f, 0.02285651f, -0.03435030f, -0.03908034f, -0.02877972f, -0.03664853f, 
    -0.01190086f, 0.00531311f, -0.04726694f, 0.03524417f, -0.00976610f, 0.01531976f, -0.00195573f, 0.01988330f, 
    0.02594368f, 0.03530985f, -0.05137866f, -0.00317258f, -0.02879788f, -0.00610181f, 0.02601738f, 0.03995652f, 
    -0.00088937f, -0.05664267f, -0.00284041f, -0.03220372f, 0.03872735f, 0.03437747f, -0.02697319f, -0.02030504f, 
    -0.03303772f, -0.04915181f, -0.04729128f, -0.03305012f, -0.04448900f, -0.00106830f, -0.05418568f, 0.01427911f, 
    -0.00665431f, -0.04840472f, 0.04102714f, 0.04456887f, 0.00752840f, 0.04117496f, -0.04179412f, -0.05130182f, 
    -0.05075357f, 0.02809957f, -0.01719362f, 0.01279621f, -0.03944657f, 0.01524607f, -0.05143676f, -0.03227711f, 
    0.00932456f, -0.04064387f, 0.00759825f, 0.02787892f, -0.05407450f, -0.01006128f, -0.03245301f, 0.03932603f, 
    -0.05365877f, -0.01813202f, -0.02063524f, -0.00347377f, 0.00582585f, -0.01300031f, 0.03513904f, -0.03674942f, 
    0.01061565f, -0.05762647f, 0.00765476f, 0.02721298f, -0.00509054f, -0.04406752f, 0.00241814f, 0.02843461f, 
    0.00214133f, 0.03340124f, -0.02211313f, -0.01261480f, 0.03314019f, -0.03337306f, 0.03505094f, -0.04171940f, 
    -0.02035512f, -0.00109578f, -0.00154237f, -0.05365296f, -0.02327231f, 0.01726898f, 0.01186238f, 0.02740292f, 
    -0.02551733f, -0.01384615f, 0.02885631f, 0.02295705f, -0.01512999f, 0.03757465f, -0.03131458f, -0.02159448f, 
    -0.01584370f, 0.02675754f, -0.03270476f, -0.04287994f, 0.03353819f, -0.01105794f, -0.05136141f, -0.03763818f, 
    0.04363256f, -0.00576311f, -0.00335805f, 0.04138837f, -0.03205084f, -0.03800960f, -0.03342235f, 0.00073803f, 
    -0.05031234f, 0.04238456f, 0.02841189f, -0.03506772f, 0.01761757f, -0.05191273f, -0.01368085f, 0.00563171f, 
    0.03092241f, -0.00603228f, 0.00502477f, -0.00598143f, -0.01323991f, -0.02152380f, 0.01325280f, 0.01957371f, 
    -0.03740744f, -0.02983257f, -0.04608715f, 0.04320047f, -0.00109267f, 0.00828854f, -0.03615233f, 0.01891541f, 
    0.02603120f, 0.03850217f, 0.04340497f, 0.02453059f, -0.00008219f, 0.03014964f, -0.03915185f, 0.01555619f, 
    -0.02367254f, 0.03258280f, -0.00611975f, -0.03051460f, -0.01067320f, -0.02083321f, 0.02875963f, 0.03030743f, 
    -0.00524507f, 0.04026332f, -0.03788675f, 0.01718528f, -0.01392122f, -0.04649807f, -0.02006100f, 0.02647503f, 
    -0.03774551f, 0.00830115f, 0.01655356f, -0.03699410f, 0.01565755f, -0.04458025f, -0.01085822f, -0.00282797f, 
    0.06436439f, 0.16867499f, -0.02979288f, 0.07406213f, -0.07428092f, 0.01723040f, 0.15832123f, 0.02356517f, 
    -0.03746586f, 0.00049994f, 0.02805200f, -0.04012798f, 0.14127623f, -0.10451471f, -0.09732374f, 0.09869095f, 
    -0.08465384f, 0.03416689f, 0.00174572f, 0.00808512f, -0.00246823f, -0.09087004f, -0.06902339f, 0.11364597f, 
    -0.37243325f, -0.17328264f, 0.24565955f, 0.22048992f, 0.03289807f, 0.03839176f, 0.06868586f, 0.06277308f, 
    0.07958959f, -0.07017735f, 0.00720316f, -0.01210282f, 0.59407628f, 0.03317426f, 0.00301349f, 0.02927339f, 
    0.02347140f, 0.01307762f, -0.07347067f, 0.03911202f, -0.01302751f, -0.08535956f, -0.00881624f, -0.01793628f, 
    -0.04256990f, 0.03953342f, 0.04563162f, -0.01637593f, 0.11751314f, -0.01781874f, -0.03930308f, 0.07773927f, 
    -0.02528194f, 0.14630242f, 0.07974221f, -0.03589635f, 0.09869918f, 0.18820418f, 0.00149384f, -0.08459247f, 
    -0.02307916f, 0.02066361f, -0.03066701f, -0.06321268f, -0.07823434f, -0.02666112f, 0.06120695f, 0.03096282f, 
    -0.15404138f, -0.11065259f, 0.10749879f, 0.02521174f, 0.06371520f, -0.00038449f, -0.05612944f, -0.08236673f, 
    -0.00624480f, 0.02742522f, -0.05398380f, -0.10281640f, -0.14650625f, -0.08986165f, -0.04915844f, -0.03250078f, 
    -0.06942747f, 0.05184298f, -0.00180574f, 0.05942144f, 0.07907336f, 0.05186742f, 0.08023703f, 0.17320396f, 
    -0.11218422f, -0.04694343f, -0.14531843f, -0.14047956f, 0.11536554f, 0.03496038f, 0.00497952f, -0.04599435f, 
    0.01302941f, 0.02831062f, 0.02635878f, 0.06289005f, -0.12600741f, 0.01527444f, -0.00699651f, 0.08609796f, 
    0.01866397f, 0.08145437f, 0.07979685f, -0.00118992f, 0.03665917f, 0.07760884f, 0.05104500f, 0.05002568f, 
    0.28673282f, 0.09579635f, -0.09837937f, 0.07922062f, -0.01825587f, -0.00138843f, 0.04422675f, -0.01764414f, 
    0.00095888f, 0.06397070f, -0.03169681f, 0.11445621f, -0.28551668f, 0.35271850f, 0.16833344f, -0.09175297f, 
    -0.04642954f, -0.04343664f, -0.05940742f, -0.09289709f, 0.03975988f, 0.12950012f, 0.16422324f, -0.05024496f, 
    -0.10588886f, -0.07815500f, 0.18501960f, 0.01615555f, 0.09644453f, -0.05763353f, 0.06399645f, -0.03910402f, 
    -0.03735894f, -0.04764658f, -0.00624793f, 0.00260318f, -0.14423269f, 0.14691594f, 0.02626257f, -0.25000611f, 
    0.05884811f, 0.06200277f, -0.00718907f, -0.03166718f, 0.04369212f, 0.09987090f, -0.00299275f, -0.00815432f, 
    -0.41125450f, 0.21506351f, -0.05064721f, -0.04277730f, 0.02324677f, -0.09745169f, -0.03606514f, -0.03321502f, 
    -0.01373724f, -0.00026914f, 0.03657789f, 0.07405913f, -0.02565978f, -0.03325928f, 0.05051391f, -0.02011991f, 
    0.08360396f, 0.04233678f, 0.03357199f, 0.14830220f, 0.09117395f, 0.21377495f, 0.02936211f, -0.09122194f, 
    -0.07583733f, -0.00255255f, 0.14300977f, 0.08541773f, 0.12256840f, -0.05684156f, 0.02064545f, -0.07452250f, 
    0.06931893f, 0.08342306f, -0.02670618f, 0.06210911f, -0.22141045f, 0.02644502f, 0.00106234f, 0.07367241f, 
    0.00171809f, 0.04764380f, 0.05600305f, -0.06433293f, -0.03398615f, 0.13679080f, -0.05181127f, -0.07594872f, 
    0.03253548f, 0.27823731f, 0.14825089f, 0.25555548f, 0.06207855f, -0.06524482f, 0.13482964f, -0.07152018f, 
    -0.03169120f, -0.00772822f, -0.05324150f, -0.05320233f, 0.26458690f, -0.00306091f, -0.03370659f, 0.05366417f, 
    0.05941097f, 0.09108654f, -0.01456108f, 0.00807421f, 0.03123238f, 0.09099710f, -0.01538465f, -0.13718681f, 
    0.33722076f, -0.10463396f, 0.11470854f, 0.07938966f, 0.01779566f, -0.00297451f, 0.12402339f, 0.04468249f, 
    -0.00262761f, -0.02879358f, 0.02361534f, -0.02617974f, 0.02674085f, -0.02026748f, -0.17194898f, -0.08490058f, 
    -0.01166778f, 0.00398161f, 0.04694940f, 0.02870890f, -0.05983866f, -0.03543110f, -0.07438677f, 0.00215101f, 
    -0.21728128f, -0.08277727f, 0.02039929f, -0.11666542f, 0.12168607f, -0.08699124f, -0.03691912f, -0.01188645f, 
    0.00752937f, -0.00097539f, -0.15327284f, 0.03371466f, -0.02096905f, 0.18109222f, 0.09783570f, -0.05559744f, 
    0.10627489f, -0.02224325f, -0.01646535f, -0.08379914f, -0.01370741f, -0.04578989f, -0.01258427f, -0.04144241f, 
    -0.06134123f, 0.14016436f, 0.03529137f, 0.20680778f, -0.03855845f, -0.02977433f, 0.02676716f, 0.07573343f, 
    0.05901806f, -0.03354593f, -0.03571750f, 0.12494589f, -0.01627062f, 0.42649028f, -0.06001055f, 0.04311513f, 
    0.03195572f, -0.04953259f, -0.08062002f, -0.12402416f, 0.06599281f, -0.03057183f, -0.03730303f, 0.10262910f, 
    0.21464439f, 0.02664641f, -0.00873682f, 0.00094066f, 0.01738694f, 0.12130662f, 0.03897495f, -0.02507803f, 
    -0.07616924f, 0.03376545f, 0.01462535f, 0.07556921f, 0.12615448f, 0.09152032f, -0.12809770f, 0.00651540f, 
    0.04960386f, -0.02822836f, -0.02966691f, -0.02479478f, -0.03861051f, -0.01703258f, 0.11666896f, 0.06386863f, 
    -0.11170658f, -0.02585876f, 0.03568194f, -0.15790714f, -0.05412515f, 0.19191745f, -0.04735504f, -0.00264232f, 
    -0.01947848f, 0.09142064f, 0.00854329f, -0.00779349f, 0.06336449f, -0.09505221f, -0.02139197f, -0.09894975f, 
    -0.04314650f, -0.12636812f, -0.02704363f, 0.04984422f, -0.06612182f, -0.04330908f, 0.04021102f, -0.05967642f, 
    -0.12169810f, 0.04277639f, -0.06125917f, -0.11164623f, 0.14557824f, 0.06949703f, 0.07747411f, 0.02216084f, 
    0.02354131f, -0.00420453f, -0.04234228f, 0.00635629f, -0.04493220f, -0.20577139f, 0.11955813f, 0.07276754f, 
    0.03206395f, -0.08262312f, -0.10300436f, -0.11788616f, -0.06649867f, 0.01402385f, -0.04149832f, -0.06469789f, 
    -0.00706713f, -0.01528970f, 0.07713576f, 0.26778200f, 0.06004986f, 0.01820593f, 0.03323414f, 0.09696243f, 
    0.08295894f, 0.03183747f, -0.02476589f, -0.11206767f, -0.01502910f, 0.02929429f, -0.21125175f, -0.03173357f, 
    -0.16398917f, -0.06693578f, 0.10172313f, 0.08191251f, -0.02795960f, 0.00655530f, 0.14013468f, 0.18962798f, 
    -0.20975164f, 0.22154246f, -0.22816725f, -0.16132328f, -0.10350878f, 0.00742507f, -0.06035342f, 0.02779864f, 
    0.05414451f, 0.04586785f, 0.01244027f, -0.02860896f, 0.13048367f, -0.11349976f, 0.08911018f, 0.06762166f, 
    0.08202241f, 0.00349980f, -0.05424091f, -0.08005710f, 0.08563762f, 0.11868449f, 0.04332815f, 0.03419753f, 
    -0.49105087f, 0.12267089f, -0.08017486f, -0.12114396f, 0.00111731f, -0.01249026f, 0.03774760f, 0.08659589f, 
    0.03720473f, -0.04804491f, 0.06858730f, 0.02322862f, 0.19014353f, 0.05573101f, -0.00053110f, -0.01324822f, 
    0.08418742f, -0.09165992f, 0.12896171f, -0.05967850f, 0.07884797f, 0.01084233f, 0.05610697f, -0.06078948f, 
    -0.22843681f, -0.19919023f, -0.04960516f, -0.39267045f, -0.04778098f, 0.02925392f, -0.00707046f, -0.00409586f, 
    0.13756475f, 0.02425651f, 0.08734090f, -0.02459804f, -0.04212439f, -0.09526812f, 0.16066818f, -0.04290212f, 
    -0.07320293f, 0.00616421f, 0.01766763f, 0.04153009f, 0.06587743f, 0.02742102f, 0.05250273f, 0.02123891f, 
    0.35806453f, 0.13047543f, -0.14213361f, 0.28690478f, 0.06205488f, 0.04956474f, -0.06887245f, 0.02803943f, 
    0.04080496f, 0.07449131f, -0.01181417f, 0.00288922f, -0.03929754f, -0.13377695f, -0.02515453f, 0.34625721f, 
    0.05075715f, -0.04514531f, 0.01047579f, 0.08921387f, 0.12758093f, -0.00133551f, 0.09592352f, -0.04754197f, 
    0.03411312f, 0.14741930f, -0.17002709f, -0.03314764f, -0.06559569f, -0.02610985f, -0.10965071f, 0.00551287f, 
    -0.03072182f, 0.08939428f, 0.05487491f, 0.15070486f, -0.01395682f, 0.13151194f, -0.09170383f, -0.20387611f, 
    0.03585615f, -0.04447739f, -0.16619723f, -0.12016635f, -0.03279139f, 0.03247485f, 0.03412015f, 0.02910273f, 
    -0.04822198f, 0.15644719f, 0.04230569f, 0.06737993f, -0.10239540f, -0.06042693f, 0.02994558f, 0.07600771f, 
    -0.00710130f, -0.02281864f, -0.02750066f, 0.03645638f, 0.26785877f, -0.12894268f, 0.00712684f, 0.13557871f, 
    0.09656173f, -0.04471917f, 0.07212225f, 0.09446456f, 0.00840552f, -0.02313740f, 0.07969965f, -0.00660517f, 
    0.03260921f, -0.01967922f, -0.04999296f, 0.04187990f, 0.18541682f, -0.02999796f, -0.07510908f, 0.06271819f, 
    0.12925336f, 0.03847937f, -0.02926495f, 0.04345874f, -0.14318433f, 0.07646812f, -0.04686917f, -0.04461409f, 
    -0.00098447f, 0.03303433f, 0.04539349f, 0.18633614f, 0.04179673f, 0.07964037f, 0.02426070f, -0.02381758f, 
    -0.29930049f, 0.13221918f, 0.12877975f, -0.29989395f, 0.04746381f, -0.03504988f, -0.02356172f, 0.02320074f, 
    0.07197134f, -0.15933105f, -0.03846589f, -0.02422696f, -0.17998891f, 0.01689547f, 0.10121368f, 0.11962060f, 
    -0.05960857f, -0.07972733f, 0.10022208f, 0.08360573f, 0.17104140f, -0.03495124f, 0.14054778f, -0.11373343f, 
    0.18363655f, -0.00566800f, 0.14997534f, 0.01735980f, -0.02735571f, 0.02675244f, 0.11035176f, -0.05381475f, 
    -0.06206718f, -0.01058015f, -0.01414783f, 0.04162635f, -0.16295053f, 0.09851323f, -0.06872414f, 0.16983391f, 
    0.10117566f, -0.00081304f, 0.01701779f, 0.04469975f, -0.01605942f, -0.00980546f, 0.08280168f, 0.02188961f, 
    -0.04123555f, -0.00057172f, 0.02690791f, 0.07187407f, -0.12777577f, 0.02993374f, -0.05160853f, -0.07102399f, 
    -0.05864959f, 0.00385893f, 0.04558272f, -0.11459907f, 0.07640930f, 0.11402936f, -0.07845568f, 0.06227287f, 
    0.05102073f, -0.09395008f, -0.04179258f, 0.04783969f, -0.01931643f, 0.08722853f, 0.00949100f, -0.09912269f, 
    0.30165961f, 0.03087865f, 0.14617762f, 0.10029167f, 0.16645594f, -0.00015561f, 0.04506748f, -0.00136794f, 
    -0.00389999f, -0.07579028f, -0.05267123f, -0.08075332f, -0.26580322f, 0.24241175f, -0.06947293f, 0.13278425f, 
    -0.07166657f, 0.04847107f, 0.03358325f, -0.03549265f, -0.01623329f, 0.08902903f, 0.03404390f, 0.01989817f, 
    -0.29459625f, -0.04480844f, -0.06668127f, -0.03444286f, 0.09766222f, -0.03939114f, 0.03033517f, -0.04499532f, 
    0.01433961f, 0.07750578f, 0.05963665f, 0.16437176f, -0.11317397f, -0.06273635f, 0.02062565f, -0.04772853f, 
    0.14368491f, -0.02458107f, -0.05603085f, -0.01093384f, -0.01016826f, -0.00214060f, 0.07986639f, -0.06415683f, 
    0.26666659f, 0.08845612f, 0.12801436f, -0.05599399f, -0.02933102f, -0.01795860f, -0.03717411f, -0.09781245f, 
    -0.00326688f, 0.03726683f, 0.07941017f, 0.08763852f, 0.15363097f, 0.08704702f, -0.03983025f, 0.06712095f, 
    -0.12469125f, -0.02954245f, 0.07245554f, -0.05966024f, 0.08875666f, 0.05096934f, -0.01418321f, 0.09711111f, 
    -0.00161219f, -0.01432433f, -0.03540587f, 0.05909467f, 0.02417894f, -0.01313987f, -0.09165099f, 0.00813349f, 
    -0.13750929f, 0.00017589f, 0.09461953f, -0.09619581f, 0.00784401f, 0.06996467f, 0.08026137f, 0.01226466f, 
    0.11233697f, 0.09331515f, 0.03547748f, 0.06411128f, 0.07732797f, 0.01375026f, 0.11155559f, 0.01386220f, 
    0.40739152f, -0.25009698f, 0.05185286f, 0.17113990f, 0.10625619f, 0.10873908f, -0.07200479f, -0.01607258f, 
    0.08456970f, 0.04147098f, -0.17509286f, 0.00967498f, 0.21859834f, -0.21069032f, 0.18080743f, 0.08391498f, 
    0.11468626f, 0.16445844f, 0.02815534f, 0.23816614f, -0.00421267f, 0.11085810f, -0.00301183f, 0.13598277f, 
    0.18307559f, -0.18133725f, -0.02464579f, -0.12106769f, -0.04561687f, -0.04282473f, 0.04644741f, -0.03083688f, 
    0.01989488f, 0.12575172f, -0.02161198f, 0.06986909f, 0.00367578f, -0.08664166f, -0.04721998f, 0.10368195f, 
    -0.01507931f, -0.00689990f, -0.03840989f, -0.05951487f, -0.05887397f, -0.01142339f, -0.01762565f, -0.07463789f, 
    -0.09307977f, -0.19952668f, 0.13277809f, 0.17458986f, -0.05992077f, 0.06750588f, 0.07562156f, -0.02723763f, 
    -0.09107890f, 0.02260066f, -0.08382921f, 0.08552804f, -0.33479571f, -0.14095983f, -0.12684493f, 0.01716248f, 
    -0.06532323f, 0.08063454f, 0.07161908f, -0.07316725f, -0.03905782f, 0.05012764f, 0.01786040f, -0.03602793f, 
    0.23914698f, -0.11576717f, -0.04128930f, 0.05010014f, 0.05400662f, 0.10715894f, 0.03383814f, -0.05286342f, 
    0.06874728f, -0.02824666f, 0.09204545f, 0.00053013f, 0.30756980f, 0.18288803f, -0.03873294f, -0.07529473f, 
    -0.06217824f, 0.09086093f, -0.02848869f, -0.04076182f, 0.01757969f, -0.04342154f, -0.07037898f, 0.09948883f, 
    -0.03444448f, 0.11291430f, 0.06782348f, 0.02477832f, -0.03779379f, 0.00623297f, -0.00650469f, -0.07125853f, 
    0.04608949f, 0.12402423f, 0.04018439f, 0.00093187f, 0.13668245f, 0.16281238f, -0.02468304f, -0.19507667f, 
    0.16611834f, 0.00889768f, -0.03912428f, 0.06616861f, -0.04639076f, -0.12283066f, 0.06320594f, 0.06107737f, 
    0.01608707f, 0.20228979f, 0.15514232f, -0.10779293f, 0.11095967f, -0.02713302f, -0.01500958f, -0.05286710f, 
    -0.03534433f, 0.02978597f, -0.02648744f, -0.01113889f, 0.01646095f, -0.09148553f, -0.13793679f, -0.25622103f, 
    0.09962779f, -0.01831196f, -0.00712673f, 0.11448001f, 0.04852039f, 0.09779690f, 0.02386609f, -0.03233102f, 
    0.41654211f, -0.08468055f, -0.01366229f, -0.04694454f, 0.02227435f, -0.03571124f, -0.05792879f, 0.07003691f, 
    -0.10005034f, -0.04697163f, 0.07647988f, -0.06477734f, 0.12118889f, 0.15918143f, 0.00380569f, 0.21551427f, 
    0.07947903f, 0.17021294f, 0.11670722f, 0.06791513f, 0.05202574f, 0.00891454f, 0.00711720f, -0.00647622f, 
    0.10630634f, -0.22546126f, -0.08872245f, -0.09793905f, -0.02671828f, 0.12402722f, -0.00886565f, 0.03010983f, 
    0.01635745f, 0.02723271f, 0.02536616f, 0.04133354f, 0.17458040f, 0.24893457f, 0.12147259f, 0.05785726f, 
    -0.04252525f, 0.08445108f, 0.07832181f, -0.00308182f, 0.04413330f, -0.05341400f, 0.05478888f, -0.03981600f, 
    0.00834753f, 0.04237906f, 0.03208028f, -0.30758834f, 0.11246022f, 0.02690913f, -0.04299261f, -0.05622687f, 
    -0.03123579f, 0.00080241f, -0.07557908f, -0.04926134f, -0.07497388f, 0.04289598f, -0.01230629f, 0.00769673f, 
    -0.01614467f, -0.05660000f, 0.04642214f, -0.10543314f, -0.01953308f, -0.01073519f, 0.09637620f, 0.03851532f, 
    -0.11307880f, -0.12367168f, -0.07379434f, 0.17880034f, -0.06640494f, 0.02173688f, 0.01798041f, 0.10183502f, 
    -0.02588180f, -0.06986341f, 0.07100202f, 0.03546012f, -0.13226780f, 0.05770171f, -0.13356897f, 0.22319169f, 
    0.00488138f, 0.01042735f, 0.00729964f, -0.03884682f, -0.01056013f, 0.02383137f, 0.03179640f, 0.01347375f, 
    0.19290353f, -0.09387472f, -0.20955217f, 0.15193540f, 0.13800387f, -0.10623923f, 0.01356292f, 0.17253397f, 
    -0.01035791f, 0.01053277f, 0.11800112f, -0.14630783f, -0.05231043f, 0.21994185f, -0.06884054f, 0.01103626f, 
    -0.02791475f, 0.04173666f, 0.03736402f, 0.00682965f, -0.08576181f, -0.10120175f, 0.15501112f, 0.04951358f, 
    -0.08098018f, -0.25430349f, -0.16673508f, 0.06078733f, -0.01997323f, -0.01804357f, -0.03190243f, -0.02722511f, 
    0.02705131f, -0.00006812f, -0.02257199f, -0.04015932f, -0.10637419f, 0.07377581f, 0.17033404f, 0.12471865f, 
    -0.03469272f, -0.02732810f, -0.03941473f, -0.01863406f, -0.07634952f, -0.03801043f, 0.02282754f, 0.00887635f, 
    0.10860763f, 0.03366585f, 0.04034448f, -0.30198243f, 0.10625257f, 0.02410582f, 0.07097841f, 0.00208215f, 
    0.02036970f, -0.04478383f, 0.07680374f, 0.00999072f, 0.38263056f, -0.15933356f, 0.07203912f, -0.13211447f, 
    0.02204407f, -0.02164525f, 0.06334691f, 0.05447100f, 0.01505068f, -0.08052628f, 0.06014888f, -0.04493044f, 
    -0.00262181f, -0.21556289f, -0.13033433f, 0.16512467f, -0.01603263f, 0.10892972f, -0.02384641f, 0.01100248f, 
    -0.03550908f, 0.01071804f, 0.06154433f, -0.10406005f, 0.16263723f, 0.20411198f, 0.01201815f, 0.08501199f, 
    0.01811365f, -0.01436171f, 0.02759501f, -0.05078807f, 0.04888341f, -0.04690836f, 0.05740668f, -0.05847758f, 
    0.14279339f, 0.06657323f, 0.15389845f, -0.08745667f, 0.10212298f, -0.00193067f, -0.10576754f, 0.10490681f, 
    0.04521818f, -0.02236837f, 0.04794287f, -0.08041514f, 0.03706452f, 0.11674216f, -0.16029607f, 0.09316268f, 
    0.12283902f, 0.02225420f, 0.00923035f, 0.04103178f, 0.01113011f, 0.06896184f, -0.04044602f, 0.15802617f, 
    -0.03890053f, 0.10900983f, 0.14340577f, -0.13011840f, 0.02439474f, -0.02943315f, -0.07284166f, 0.00947333f, 
    0.06571943f, 0.04735038f, 0.02929753f, 0.03036106f, 0.02883421f, 0.19118194f, 0.04038707f, 0.06262083f, 
    -0.04972196f, 0.05508662f, -0.09957503f, 0.02037064f, -0.04730981f, -0.06534233f, -0.05513162f, -0.07664844f, 
    -0.10847347f, 0.10593823f, 0.16286321f, -0.08656459f, 0.09761826f, -0.12095895f, 0.03481134f, 0.04066227f, 
    -0.01667030f, -0.07470244f, -0.09347787f, -0.08586983f, -0.12024447f, -0.04988873f, 0.06287275f, -0.09093450f, 
    0.03120421f, 0.09995863f, 0.02276022f, -0.06061557f, -0.02711116f, 0.09784542f, 0.00021135f, -0.02509629f, 
    -0.07551961f, -0.00707155f, -0.01017951f, -0.08881731f, -0.03185535f, -0.00085088f, -0.15952112f, -0.12313123f, 
    -0.01079081f, 0.00640249f, -0.04246006f, 0.11235614f, 0.07348693f, 0.04963371f, 0.02732051f, -0.21654224f, 
    0.00952639f, 0.00629866f, 0.06643207f, -0.14785382f, -0.03015360f, 0.06299407f, 0.00212003f, -0.00589028f, 
    0.44128335f, -0.18144786f, -0.09117666f, -0.19395576f, 0.02787128f, -0.17039923f, 0.03520888f, 0.03427275f, 
    0.01248668f, 0.13370997f, -0.09001008f, -0.00767840f, -0.29617724f, -0.00600284f, -0.10724295f, -0.00559104f, 
    -0.07868366f, -0.00956171f, 0.01589621f, -0.00993871f, -0.06183858f, 0.01847784f, 0.07530832f, 0.03259422f, 
    0.29607591f, -0.16106369f, 0.02921370f, 0.12537010f, -0.02209792f, -0.02582317f, 0.10227369f, -0.00004218f, 
    0.01897841f, -0.05795638f, 0.01637367f, 0.05991467f, -0.35074255f, -0.11582820f, 0.04730924f, -0.04231991f, 
    0.01129051f, 0.14283949f, -0.02035829f, 0.02357999f, 0.13081487f, 0.00823152f, -0.05605704f, 0.05179012f, 
    0.03020080f, 0.20593007f, 0.02135820f, -0.18833353f, -0.03235872f, -0.01969200f, 0.01821928f, 0.10695634f, 
    0.07230721f, -0.00734170f, 0.06259567f, 0.00546159f, -0.03632054f, 0.16334225f, 0.08857977f, 0.09085395f, 
    0.03778832f, 0.01593597f, -0.11184194f, -0.03443536f, 0.02713731f, -0.12717041f, -0.01160088f, -0.05554378f, 
    0.13407356f, 0.02277482f, 0.30060816f, 0.06964399f, -0.01662009f, -0.02536805f, 0.09694452f, 0.02579196f, 
    -0.06466702f, -0.01298285f, 0.06572655f, 0.01154506f, -0.10697283f, -0.04434566f, -0.04076367f, -0.16859001f, 
    0.04097777f, 0.03576398f, -0.00881669f, 0.00577087f, -0.05538909f, -0.06970951f, 0.02453158f, 0.04607160f, 
    -0.03002744f, 0.03604952f, 0.11422160f, -0.13183916f, 0.13359530f, 0.10018242f, 0.03980587f, 0.07919042f, 
    0.02540550f, 0.01253256f, -0.02022035f, -0.03156400f, 0.39072704f, -0.12838513f, -0.05689888f, 0.28404781f, 
    0.11975951f, 0.03876223f, 0.07736589f, 0.07371361f, -0.03734981f, -0.01160055f, -0.06836277f, 0.01635301f, 
    0.26520565f, -0.19125745f, -0.10437852f, 0.17911781f, 0.01145461f, 0.02210725f, -0.02987203f, -0.01683718f, 
    0.04728078f, 0.05577806f, 0.05224201f, 0.03003671f, -0.08255623f, 0.10046682f, 0.26158765f, 0.07689120f, 
    0.06487521f, -0.03850311f, 0.06340546f, -0.02081086f, 0.01982927f, 0.03325870f, 0.02425408f, -0.03976730f, 
    0.07533160f, 0.00692491f, 0.11867471f, -0.04745854f, 0.04274133f, -0.00485206f, 0.02792459f, 0.07862085f, 
    -0.03664121f, 0.04812739f, 0.03864703f, -0.00084854f, 0.04376301f, -0.13812953f, -0.04694419f, -0.00220873f, 
    -0.04372259f, -0.08392137f, 0.07821819f, -0.08264429f, -0.02620441f, -0.00171555f, -0.02475080f, 0.08618835f, 
    0.24676664f, 0.06113285f, -0.14770159f, -0.04793325f, -0.03232460f, 0.04809369f, 0.08362193f, -0.02273840f, 
    0.03243759f, 0.02262618f, 0.03946856f, 0.08250149f, 0.05065290f, -0.07698897f, -0.05776045f, -0.05734273f, 
    -0.01922456f, 0.00660066f, -0.02296889f, 0.03452841f, -0.00562965f, -0.05187537f, 0.10434477f, 0.16046365f, 
    -0.00671546f, -0.04089472f, -0.18855792f, 0.09830645f, 0.01354558f, 0.04514286f, -0.07308167f, 0.10052783f, 
    0.04927361f, 0.00681450f, 0.04311762f, 0.06934005f, -0.10183443f, -0.09083034f, 0.13800132f, -0.10924103f, 
    -0.01957627f, 0.00327562f, 0.04864894f, 0.03880250f, -0.02751997f, -0.03486587f, 0.15158553f, 0.04668451f, 
    -0.10196523f, -0.12975925f, -0.08796865f, 0.15026774f, 0.02732444f, 0.00863736f, 0.07092091f, -0.07547836f, 
    0.07744299f, 0.05911827f, -0.01166711f, 0.09684014f, 0.01430041f, 0.16582909f, 0.23399058f, 0.18269712f, 
    0.08869813f, 0.05729400f, 0.05177690f, -0.07608543f, 0.02901525f, 0.00087832f, 0.13969441f, -0.00945750f, 
    0.11713567f, 0.07353470f, 0.22668427f, 0.08653969f, 0.07183480f, 0.10977726f, -0.02341564f, 0.01916287f, 
    0.03701602f, 0.00329698f, 0.22346622f, -0.00049069f, 0.03132993f, -0.09193043f, 0.03376216f, -0.01251346f, 
    0.03588385f, 0.03241564f, -0.05420157f, 0.04859471f, 0.07901642f, -0.06410734f, -0.11615600f, 0.05721221f, 
    0.08477106f, 0.05549185f, -0.07400807f, -0.14823073f, -0.04714280f, 0.04232742f, -0.01289120f, 0.04866221f, 
    0.12923026f, -0.00985789f, 0.06512583f, 0.04355224f, -0.00462852f, -0.20736466f, 0.07828227f, 0.03728003f, 
    -0.08786423f, 0.04906199f, 0.06966615f, 0.10331727f, 0.15262385f, -0.04795103f, -0.01845429f, -0.03012556f, 
    -0.12532979f, 0.02745734f, 0.10787350f, 0.06370657f, 0.12894174f, 0.02079232f, 0.01663836f, 0.09635994f, 
    0.04324310f, 0.02483440f, 0.04427430f, -0.04693471f, -0.22673045f, 0.05495270f, 0.02280991f, -0.11681280f, 
    0.05288027f, 0.08990508f, 0.01554559f, 0.02535291f, 0.03170287f, -0.04892737f, -0.09752472f, 0.05191423f, 
    0.18108140f, -0.09529111f, 0.19900687f, 0.16630927f, -0.04847396f, -0.02928068f, 0.05655933f, 0.08854674f, 
    -0.02343029f, -0.01420278f, -0.04761481f, 0.01487715f, -0.06263401f, -0.04159919f, -0.01413106f, -0.05874489f, 
    -0.02838794f, 0.07375048f, 0.01378346f, -0.01755634f, 0.05644922f, 0.11390755f, 0.02213872f, 0.13184258f, 
    0.01285089f, 0.01100605f, 0.06974773f, 0.14309493f, -0.17416617f, -0.06123199f, 0.08247937f, 0.02432661f, 
    0.07634233f, -0.00547789f, 0.00594807f, 0.06105892f, -0.33837038f, 0.09685804f, 0.05420303f, -0.03028077f, 
    0.00842716f, 0.00838790f, 0.02694824f, 0.05591097f, 0.02171532f, 0.01434156f, 0.05767958f, 0.08645748f, 
    -0.01819490f, -0.02129029f, -0.05544201f, 0.02256169f, -0.04205900f, -0.03123951f, 0.02500642f, -0.04006017f, 
    -0.01815699f, -0.02329213f, 0.03831321f, -0.03194078f, 0.00314170f, 0.00625171f, -0.02665339f, 0.01984215f, 
    -0.03832998f, 0.04289063f, -0.01145851f, -0.03360053f, 0.01740108f, 0.00464052f, 0.02307017f, 0.02971721f, 
    0.03804502f, -0.06564514f, -0.05136988f, 0.00980189f, -0.01381731f, 0.01168135f, -0.02785760f, -0.02691015f, 
    -0.02377320f, -0.02766420f, -0.00061703f, 0.03188764f, -0.03573987f, 0.01935482f, -0.00458413f, 0.02026297f, 
    0.03605326f, -0.02557055f, -0.02863288f, -0.02190058f, 0.01584297f, 0.02707595f, -0.03755061f, 0.01359077f, 
    -0.03863368f, -0.04686340f, -0.02200096f, -0.02922948f, -0.03099964f, -0.00927395f, -0.04543621f, 0.03193496f, 
    0.02778504f, 0.01794497f, -0.00955729f, -0.02498309f, -0.01205599f, -0.01765209f, -0.04969043f, -0.03327697f, 
    0.00362660f, -0.04251773f, -0.03429610f, -0.04755013f, -0.03827653f, -0.05083526f, -0.03017234f, 0.03609890f, 
    0.04054938f, -0.03439168f, -0.00369946f, -0.04922781f, 0.03190483f, -0.03633889f, 0.03653432f, -0.04691764f, 
    -0.04433733f, 0.01335084f, -0.02885796f, -0.02613277f, -0.00888775f, -0.00231753f, 0.01816772f, -0.03630226f, 
    -0.04441824f, -0.00417946f, 0.04630783f, -0.01077639f, -0.06131594f, 0.00097093f, 0.00158189f, -0.02443504f, 
    -0.02346298f, -0.02455140f, -0.03703130f, -0.00186250f, -0.04500327f, -0.03956113f, -0.01058634f, 0.02871053f, 
    0.02063192f, -0.03182221f, 0.00323063f, -0.01379081f, -0.00030516f, -0.02826560f, 0.00107190f, 0.00027870f, 
    -0.02883677f, -0.04341062f, 0.01214529f, 0.00543451f, -0.05545934f, 0.03795943f, -0.00063689f, 0.00372743f, 
    -0.00043915f, -0.05545219f, -0.03177623f, 0.00174147f, 0.03315504f, 0.01580523f, -0.00030916f, -0.04007745f, 
    0.03082330f, 0.04398318f, -0.02953927f, 0.02846004f, -0.00458830f, -0.03767263f, -0.00050441f, -0.05419302f, 
    0.03688214f, -0.05612960f, -0.03388692f, 0.02811901f, -0.01395460f, -0.01642098f, -0.01128907f, 0.00405610f, 
    -0.00551505f, -0.01486073f, 0.00419830f, 0.02842266f, 0.03926284f, -0.03773555f, -0.02629318f, -0.02895638f, 
    0.01907667f, 0.03815700f, -0.03332234f, -0.01824013f, -0.03690755f, -0.03465048f, -0.03312428f, 0.00851758f, 
    -0.01389303f, -0.00985462f, 0.00824462f, -0.06496590f, 0.03803601f, -0.00349665f, -0.00158329f, 0.00745158f, 
    0.01027214f, -0.03505785f, 0.00661283f, -0.05607259f, -0.01189109f, -0.04750908f, -0.05820109f, -0.03689076f, 
    0.00507748f, 0.03381443f, 0.03975837f, -0.00990237f, -0.02020419f, -0.03048620f, -0.04181748f, -0.04876896f, 
    0.04443474f, 0.02565221f, 0.01251375f, -0.01013058f, 0.01677591f, -0.05242757f, -0.05104714f, -0.01949533f, 
    0.03720203f, 0.02296047f, -0.00507600f, -0.05375092f, 0.01794067f, -0.03821922f, -0.01368958f, 0.03847228f, 
    -0.00581300f, 0.03755291f, 0.00724547f, 0.02889681f, 0.03485623f, 0.01782855f, -0.04410988f, -0.00890354f, 
    -0.01032041f, -0.04431219f, -0.01252567f, -0.01377148f, -0.03213796f, 0.00066231f, 0.04412136f, -0.05673447f, 
    0.03255661f, -0.02781811f, -0.03177382f, -0.02444074f, -0.00227254f, 0.00377840f, -0.04789636f, -0.03890321f, 
    0.03264071f, -0.00439803f, -0.01500779f, 0.00171804f, -0.02812101f, 0.02316116f, -0.03549799f, -0.01192275f, 
    0.02903848f, -0.00786131f, -0.04013033f, 0.01122015f, 0.02773035f, -0.01252462f, 0.00915722f, 0.02987693f, 
    -0.04917499f, -0.03919439f, 0.02723715f, -0.02270846f, -0.04366200f, 0.00998147f, 0.01807201f, -0.02552369f, 
    0.01271986f, -0.04096926f, 0.03081133f, -0.01429262f, 0.03237477f, 0.02287878f, -0.02064322f, 0.01724346f, 
    0.02138943f, 0.02727779f, -0.00156038f, 0.00810166f, 0.03063208f, 0.03471484f, -0.01557499f, -0.02913429f, 
    0.01602994f, 0.05195786f, -0.02523770f, -0.05328191f, 0.05134445f, 0.01860303f, 0.00315052f, 0.02067657f, 
    -0.01460060f, -0.00815080f, -0.04004351f, -0.02516082f, -0.04835251f, 0.02640999f, -0.03527515f, -0.01330515f, 
    -0.00760249f, -0.00531186f, -0.02560883f, -0.02877001f, -0.00286867f, 0.00409058f, -0.03852920f, -0.02741074f, 
    0.03278977f, -0.00169521f, -0.04389082f, 0.02984465f, -0.06292734f, 0.02309558f, 0.01729991f, -0.02260061f, 
    0.03616111f, -0.02167139f, -0.01285003f, -0.01092374f, 0.04118772f, 0.01889124f, -0.02582767f, 0.03251455f, 
    -0.00133318f, 0.03560835f, 0.03839632f, -0.02574940f, -0.04748187f, -0.00619936f, 0.00630400f, -0.02511196f, 
    0.01941406f, -0.05557510f, 0.02553966f, 0.01017121f, 0.02582632f, -0.03427741f, 0.00953591f, -0.00988095f, 
    0.01951946f, -0.04210468f, 0.03367514f, -0.03364933f, 0.02921925f, -0.01094717f, 0.03082986f, -0.03423659f, 
    0.02330882f, 0.03952235f, 0.00762504f, 0.03937380f, 0.01666033f, 0.04058772f, 0.02457736f, -0.04860350f, 
    0.03444238f, 0.03094351f, 0.03454602f, -0.04470007f, 0.01966400f, -0.02691595f, -0.02500576f, 0.00187006f, 
    0.00525982f, -0.01170579f, -0.02231904f, 0.02958179f, -0.04020359f, -0.03408567f, -0.04577999f, -0.05572478f, 
    -0.05392420f, -0.03628680f, 0.01053781f, 0.02070468f, 0.03848980f, 0.03715979f, -0.05090740f, -0.00240862f, 
    0.00479068f, -0.05642300f, 0.00829864f, -0.00832535f, -0.02849552f, 0.02021493f, -0.01959188f, -0.01050409f, 
    0.01501842f, -0.00698378f, -0.04236472f, -0.04554198f, 0.04375900f, 0.02363709f, -0.02227884f, 0.00544678f, 
    -0.03511546f, -0.05381426f, 0.02343575f, -0.03975927f, 0.01717630f, 0.02090664f, -0.03125228f, -0.01875634f, 
    0.02675357f, 0.09500830f, -0.06222491f, 0.07133426f, 0.03833132f, 0.01779525f, 0.03587826f, 0.03560125f, 
    0.06378483f, -0.03959067f, -0.05406485f, -0.16310619f, 0.14608833f, -0.00029401f, 0.16036434f, 0.03980717f, 
    -0.03012984f, -0.11774675f, 0.11569507f, 0.13229087f, 0.07376707f, 0.05817106f, -0.00658041f, 0.09684008f, 
    -0.08928546f, 0.29484868f, -0.06659544f, -0.17355220f, 0.13083969f, 0.02860149f, -0.03247117f, 0.01613004f, 
    -0.04775391f, -0.05322301f, 0.13792983f, 0.02348728f, -0.46308067f, 0.02485305f, 0.03091743f, 0.03176831f, 
    0.13191789f, -0.04024136f, 0.10161686f, -0.01185847f, 0.09318611f, 0.09322501f, -0.08312191f, 0.04801813f, 
    -0.15939330f, 0.07713164f, -0.06273084f, 0.03507736f, -0.00467215f, 0.06258994f, -0.06678785f, 0.07925583f, 
    -0.12939362f, -0.00157261f, -0.07192631f, 0.04119596f, -0.18139094f, -0.19282980f, 0.01058405f, 0.07995338f, 
    0.00804125f, -0.02516307f, 0.06002781f, 0.06708631f, 0.15633601f, -0.02735633f, 0.01137040f, -0.05522807f, 
    0.20780112f, 0.09855396f, 0.04258307f, 0.24681400f, 0.03073487f, 0.18005152f, 0.08410067f, 0.01896859f, 
    -0.09174970f, -0.05698496f, 0.00353226f, 0.03455910f, 0.05609993f, -0.01417326f, 0.07498101f, -0.00050864f, 
    0.05547579f, -0.12003841f, 0.06084292f, 0.02760763f, -0.14578402f, 0.10792201f, 0.03189593f, -0.12345271f, 
    -0.18510321f, -0.18071146f, -0.14474922f, -0.02895854f, -0.11635303f, -0.04737163f, -0.00400649f, 0.10849773f, 
    0.09970764f, 0.06340484f, -0.04962404f, 0.06953328f, 0.22250628f, 0.25355837f, 0.03948792f, 0.24428420f, 
    0.01273541f, -0.05738427f, 0.14783387f, 0.03288335f, 0.02879765f, -0.03759887f, 0.08631796f, -0.09750854f, 
    -0.32347876f, 0.29195437f, 0.06810093f, -0.14909969f, -0.01198011f, -0.01026361f, -0.04495658f, 0.01128484f, 
    -0.01679037f, -0.02514011f, 0.05317266f, 0.00696971f, -0.09581231f, -0.29102674f, -0.05071438f, -0.09793611f, 
    -0.09426717f, 0.06255262f, 0.03579421f, 0.04295595f, 0.06687744f, 0.02543125f, -0.10982311f, 0.01803381f, 
    -0.03789871f, 0.43043903f, -0.14261071f, -0.09982305f, 0.04049873f, 0.00639496f, 0.00282629f, 0.04761229f, 
    0.02695602f, 0.06756420f, -0.04823259f, -0.00730233f, -0.08048642f, -0.26182267f, -0.17414372f, -0.03879471f, 
    -0.05206339f, -0.11761778f, 0.03555601f, 0.05674756f, 0.06298578f, -0.03665861f, 0.00235133f, 0.07534697f, 
    0.04297356f, -0.02626909f, 0.02732329f, 0.06831390f, -0.07144621f, -0.07188784f, 0.09904821f, -0.13964038f, 
    0.05210000f, 0.06368549f, 0.06205153f, 0.07974254f, 0.14287406f, 0.17404014f, 0.01344499f, 0.18480280f, 
    0.04479779f, 0.05427564f, -0.06911431f, 0.15082034f, -0.16414884f, -0.07867355f, -0.04506496f, 0.08385057f, 
    0.16347736f, -0.01514572f, 0.04998428f, -0.01318723f, -0.04816836f, 0.00479976f, -0.08423099f, 0.15259349f, 
    -0.04042252f, -0.02498859f, 0.05693878f, 0.02185394f, 0.29022205f, 0.18847571f, 0.05655932f, 0.06144205f, 
    0.11435591f, -0.01021081f, 0.05232205f, 0.03220002f, 0.08557431f, 0.08934891f, -0.02769247f, -0.03784128f, 
    -0.12100416f, -0.07407260f, 0.06233062f, -0.06007660f, -0.00984365f, 0.05348895f, 0.02318351f, 0.02236128f, 
    0.06248015f, 0.02486974f, 0.03922173f, 0.13503417f, -0.02213362f, 0.15535408f, 0.11912593f, 0.08918791f, 
    0.14373377f, 0.09400177f, 0.08266634f, 0.06565386f, 0.02401948f, 0.02808302f, -0.10561357f, 0.03345732f, 
    -0.29987323f, 0.23502123f, -0.02424589f, -0.17508046f, 0.06142301f, 0.11280387f, 0.00084229f, 0.04459514f, 
    -0.03001589f, 0.05854778f, 0.03216508f, -0.03360534f, -0.09334450f, -0.18949731f, -0.10655606f, -0.22156683f, 
    -0.11890667f, -0.00312047f, 0.00876424f, 0.00584499f, 0.10510490f, 0.18312596f, 0.16266118f, 0.07799099f, 
    -0.25526220f, 0.03687377f, -0.19822343f, 0.03138161f, -0.19930536f, 0.04932248f, 0.00280831f, -0.01421127f, 
    -0.03175487f, 0.01867422f, -0.03852898f, 0.02474377f, -0.15139666f, -0.05244265f, -0.05868395f, 0.09300687f, 
    -0.03882314f, 0.04818939f, 0.03044200f, 0.02609027f, -0.03243463f, 0.04010179f, -0.04438281f, 0.04384604f, 
    0.13305566f, 0.04143701f, -0.00096414f, 0.15432099f, 0.09360747f, 0.06409547f, -0.02697434f, 0.04068381f, 
    -0.07307635f, -0.06125838f, -0.00526665f, 0.04517107f, -0.07180689f, -0.12923406f, 0.14692055f, 0.05237066f, 
    0.00424901f, 0.01153389f, 0.01249849f, 0.00286367f, -0.09212548f, 0.01945851f, 0.06382202f, -0.01681283f, 
    -0.16557099f, -0.11849304f, 0.03725372f, -0.03974253f, -0.03604881f, -0.08358578f, -0.02151831f, -0.09266332f, 
    0.04206321f, 0.05628010f, 0.10020736f, 0.16321911f, -0.02591382f, -0.14940146f, 0.18848707f, 0.15075174f, 
    -0.15289089f, -0.10575849f, 0.01531025f, 0.00000018f, 0.01510205f, 0.08140442f, -0.00035727f, -0.02244413f, 
    -0.20755020f, -0.03708383f, -0.23345916f, -0.04446907f, 0.02635154f, -0.15937094f, 0.00223168f, 0.00570681f, 
    0.00817898f, 0.00978512f, 0.09397297f, 0.01707203f, 0.20959109f, 0.25534821f, 0.05562466f, 0.13297023f, 
    0.12837254f, 0.14447987f, 0.14989607f, -0.00275716f, -0.01109848f, -0.01719363f, 0.02156920f, 0.06200549f, 
    0.08147346f, -0.07158117f, -0.09724842f, -0.11865184f, -0.02640642f, 0.07676066f, -0.07364643f, 0.03361304f, 
    0.03295600f, 0.04251099f, 0.05953434f, 0.10780194f, 0.50902617f, 0.21848713f, -0.07010338f, 0.00210201f, 
    0.00577524f, 0.09677028f, 0.12164751f, 0.05701912f, 0.06406610f, -0.00375932f, 0.04044007f, 0.01046408f, 
    0.06137456f, 0.29319715f, -0.09054674f, -0.26279554f, 0.13749947f, 0.09913819f, 0.06494968f, 0.07188378f, 
    0.03444886f, -0.04395612f, 0.17538077f, 0.10465052f, 0.05978529f, -0.31809616f, 0.06892828f, 0.08200012f, 
    -0.07042621f, -0.06128664f, 0.01168879f, -0.02353217f, 0.06675750f, -0.01735207f, 0.00886833f, 0.01504836f, 
    -0.16004126f, -0.18947597f, 0.27151617f, 0.11538894f, -0.03532521f, -0.07008199f, 0.06621823f, 0.03316831f, 
    -0.14112286f, -0.15125887f, -0.01902087f, -0.00863681f, 0.53059709f, 0.13540807f, 0.14459130f, -0.16755146f, 
    0.08056674f, 0.08525778f, 0.00182652f, 0.06400053f, 0.04013719f, -0.03577885f, 0.06347706f, 0.10608102f, 
    0.07907611f, -0.01992459f, -0.14798249f, 0.05633010f, 0.05593147f, -0.04075099f, -0.03571243f, 0.02632169f, 
    -0.13210724f, 0.08515835f, 0.03808638f, 0.02247804f, -0.04288729f, 0.00274754f, 0.23089902f, 0.00435874f, 
    -0.15003984f, -0.11862670f, -0.06758624f, -0.04434129f, -0.14593925f, -0.28834638f, 0.02582605f, 0.05693235f, 
    -0.14962715f, 0.04454542f, 0.14823115f, 0.12602831f, 0.11898974f, 0.10294189f, 0.08743881f, -0.03161754f, 
    -0.06199270f, 0.01061386f, 0.04810540f, 0.08581467f, -0.07456972f, -0.11041750f, -0.03811866f, 0.06236526f, 
    -0.01950855f, -0.06912601f, -0.06249314f, -0.03837656f, -0.03934499f, 0.18163571f, 0.13753781f, 0.15116997f, 
    0.00824520f, -0.02004253f, -0.00330729f, -0.14298965f, 0.01589790f, 0.13522823f, 0.08814921f, -0.09461118f, 
    -0.06600573f, -0.13965237f, -0.02180560f, 0.00869140f, -0.07798277f, -0.02755998f, 0.00127692f, 0.03328729f, 
    0.09717156f, 0.17312504f, 0.18697709f, -0.09852686f, 0.00030073f, 0.07957423f, 0.01699335f, -0.07598638f, 
    0.05808255f, 0.13846739f, -0.02932893f, -0.19991913f, -0.00598112f, 0.04522825f, 0.07107594f, 0.05802048f, 
    -0.03712029f, 0.05160332f, -0.06966107f, -0.05319909f, -0.29605955f, 0.17269920f, 0.27683729f, 0.05845473f, 
    -0.01186051f, 0.07483110f, 0.02417124f, -0.09044036f, 0.07932176f, 0.10597718f, 0.10357875f, -0.03959737f, 
    -0.20074037f, 0.17988892f, 0.09745775f, -0.15314993f, 0.14828132f, -0.02881535f, 0.07681263f, -0.07933778f, 
    -0.04901302f, -0.08110207f, 0.03690223f, 0.03951569f, 0.02831900f, 0.15995142f, 0.16889937f, -0.36884177f, 
    0.11676378f, 0.01470505f, -0.06081645f, -0.18810263f, -0.04623786f, 0.02260031f, -0.13396303f, 0.02498669f, 
    -0.09861908f, 0.35351649f, -0.15979972f, 0.13179852f, -0.09546261f, -0.10321516f, 0.00128953f, -0.13006532f, 
    0.00648061f, 0.09412896f, 0.01837225f, 0.09390920f, 0.06004603f, 0.02512069f, -0.18478800f, 0.16360578f, 
    0.09249434f, 0.07352600f, -0.02888226f, 0.10856352f, 0.15002513f, 0.08303892f, 0.03319300f, 0.04990475f, 
    0.37315392f, -0.04458012f, 0.01941966f, 0.31971273f, 0.11495699f, -0.01926132f, 0.12963170f, -0.02684861f, 
    0.04457644f, 0.11071290f, -0.13047951f, 0.06477921f, -0.12444024f, -0.10025229f, -0.15965702f, -0.02986206f, 
    0.12311214f, 0.02018120f, 0.07176249f, 0.04744536f, -0.08237591f, 0.11938486f, -0.05003878f, 0.11819681f, 
    -0.13135475f, 0.23727077f, -0.00912016f, -0.00767599f, 0.06393261f, 0.05506372f, -0.00433256f, 0.01158840f, 
    0.12248868f, 0.04139321f, 0.01084886f, 0.02329127f, 0.20853321f, -0.14210266f, -0.06556500f, 0.04994408f, 
    0.02507660f, 0.06810480f, 0.03596978f, 0.01435186f, 0.00929215f, 0.08886799f, 0.04543640f, 0.00062597f, 
    0.26581839f, -0.13350311f, 0.14432648f, -0.08224019f, 0.10335896f, -0.05389423f, 0.01614351f, -0.00171033f, 
    0.12071318f, -0.00489405f, -0.00352342f, 0.01111226f, 0.12240893f, 0.14045204f, -0.16329534f, -0.03781617f, 
    -0.06430117f, -0.12343439f, 0.04927907f, -0.10096624f, 0.03715546f, -0.16431487f, -0.14740171f, 0.03713619f, 
    -0.29066092f, 0.20028228f, 0.13817137f, 0.10663677f, 0.10204916f, -0.04684631f, 0.02075178f, -0.00326226f, 
    -0.02380990f, 0.10904538f, -0.09076882f, -0.01227435f, -0.23447259f, 0.00807084f, -0.02416796f, -0.00744889f, 
    0.03697220f, 0.05905254f, -0.03729108f, -0.06061055f, -0.03863201f, -0.05437279f, 0.11442255f, -0.06199366f, 
    -0.24118593f, 0.05119571f, 0.22750242f, -0.01215683f, -0.17021255f, -0.03814796f, -0.04163374f, 0.00322256f, 
    0.03239136f, -0.03307444f, -0.04396750f, -0.03978556f, 0.38606232f, 0.07325963f, 0.05900927f, -0.08935025f, 
    0.07199870f, -0.06564352f, 0.04696243f, 0.13620177f, 0.03268353f, -0.01226934f, 0.00080643f, 0.11883769f, 
    0.16909555f, 0.12994090f, -0.12079537f, 0.08777935f, 0.07457330f, 0.08476288f, -0.07602587f, -0.12725271f, 
    -0.01061800f, -0.10835040f, -0.05979608f, -0.11416383f, 0.10496446f, 0.07450695f, 0.15044343f, -0.01815131f, 
    -0.13902515f, -0.00788503f, -0.07432850f, 0.02022745f, -0.18434191f, -0.14885981f, 0.14395759f, -0.02174277f, 
    -0.03981202f, 0.14981765f, -0.10243516f, 0.01561920f, -0.11846048f, 0.19299351f, 0.11116518f, 0.09283420f, 
    -0.10797579f, -0.04914450f, -0.08656957f, -0.00830737f, 0.10644906f, -0.25703096f, -0.15782216f, -0.01806162f, 
    0.04067136f, 0.02774674f, -0.00218828f, 0.14056037f, 0.05757590f, 0.02374125f, -0.00367838f, 0.03236423f, 
    -0.07519756f, 0.08909379f, -0.09600484f, -0.24118511f, -0.03276122f, 0.01339851f, 0.09900015f, -0.09257957f, 
    -0.00877823f, 0.00540457f, -0.04949608f, -0.06917348f, -0.17725714f, -0.35048461f, -0.08074165f, 0.15321265f, 
    0.17401326f, 0.03883043f, 0.00384374f, -0.12174860f, -0.09081995f, 0.00129799f, 0.04096709f, -0.06077365f, 
    -0.16892129f, -0.12904273f, 0.24805784f, 0.22587486f, 0.06685502f, 0.06803187f, -0.11386950f, 0.07736304f, 
    0.00914932f, 0.03635299f, 0.14366981f, 0.26089895f, 0.08536683f, -0.12668386f, 0.00855109f, -0.12191870f, 
    0.08367514f, -0.08190332f, -0.08084857f, -0.13991717f, 0.03224014f, 0.00380126f, 0.04438762f, -0.16707839f, 
    0.47517788f, 0.29034179f, -0.34750819f, -0.19492483f, 0.04757207f, 0.03342889f, 0.02150545f, -0.09537242f, 
    -0.05643661f, 0.05124460f, -0.08763646f, 0.07499113f, -0.10395601f, 0.04459120f, 0.10506547f, 0.12044327f, 
    0.07598164f, -0.08040825f, 0.06609704f, 0.16809434f, 0.04486770f, 0.15001538f, 0.01137509f, 0.09283208f, 
    0.36796284f, -0.13065325f, 0.06245077f, 0.19482966f, -0.06702170f, -0.02202405f, -0.05284877f, -0.11188072f, 
    -0.06587463f, -0.00180146f, 0.04592171f, 0.06836269f, -0.22732411f, 0.00247233f, 0.06566328f, -0.01442780f, 
    -0.07465725f, 0.07405569f, -0.03239033f, 0.08007520f, -0.05184349f, 0.12573186f, -0.17079510f, -0.00970034f, 
    0.01237847f, 0.05544565f, -0.09907871f, 0.01405138f, -0.05292198f, 0.00934033f, -0.05590569f, 0.04195945f, 
    -0.07269364f, -0.00530732f, -0.01109398f, 0.19550635f, 0.06180615f, -0.05576589f, 0.05521019f, -0.03565209f, 
    -0.04538208f, 0.03357507f, 0.01344419f, -0.03722749f, -0.02130244f, 0.17428151f, -0.07444853f, -0.17251757f, 
    -0.05023409f, 0.06905563f, -0.03015146f, 0.11938124f, -0.07258987f, 0.01465206f, -0.00744342f, -0.05304414f, 
    -0.05277127f, -0.04041864f, -0.04762698f, 0.00059259f, -0.06347384f, -0.04315372f, 0.03525805f, 0.08669087f, 
    -0.02660325f, 0.10666958f, -0.09905442f, -0.03865873f, -0.05262147f, 0.05639752f, 0.00596301f, 0.01402524f, 
    -0.11548033f, -0.00190087f, 0.05642267f, -0.08325098f, 0.00448503f, 0.01978097f, -0.00212421f, -0.06127199f, 
    0.04991823f, -0.07025620f, -0.02704429f, -0.18001463f, 0.07548986f, -0.24989155f, 0.08248847f, 0.02090164f, 
    -0.12850840f, 0.07341388f, 0.20390089f, 0.08104145f, -0.03319781f, 0.04100192f, 0.12071398f, -0.09369212f, 
    0.15336069f, 0.02011819f, -0.04295259f, -0.04627381f, -0.07348967f, 0.06243654f, 0.00839100f, 0.16985548f, 
    0.04696383f, 0.17002177f, -0.04505687f, 0.05493468f, -0.09215818f, 0.11998332f, 0.02066672f, 0.07075648f, 
    -0.04091273f, 0.07756947f, 0.01443593f, -0.02883605f, -0.06902786f, -0.05528704f, -0.09977314f, -0.11476640f, 
    0.20617229f, 0.08180989f, -0.04335690f, 0.01596247f, 0.03928442f, 0.21148799f, 0.05344940f, 0.03867242f, 
    -0.16280937f, -0.19133216f, -0.21778335f, 0.00320164f, 0.31875533f, 0.10669494f, 0.01298240f, 0.15527163f, 
    -0.08121009f, 0.03752160f, -0.04410207f, -0.08261575f, 0.04596327f, -0.13165019f, 0.01429610f, 0.13514158f, 
    0.16780034f, -0.04770760f, -0.21476164f, -0.09926986f, -0.01669422f, 0.07293870f, -0.02359387f, 0.08255044f, 
    -0.12846629f, 0.11112800f, -0.00069117f, -0.10147265f, 0.41307101f, 0.10790667f, 0.09644184f, -0.00145136f, 
    0.01457948f, -0.02269633f, -0.11732583f, 0.02135900f, 0.02636436f, 0.05571666f, -0.06022569f, 0.05783492f, 
    -0.22899033f, 0.02782244f, 0.25055692f, 0.03260813f, -0.07684985f, -0.02214359f, -0.09730790f, 0.10406642f, 
    0.01996147f, -0.09823601f, 0.04816143f, -0.07954187f, 0.21258597f, -0.06894831f, 0.17294464f, 0.00877021f, 
    -0.10078861f, -0.00084442f, 0.08466569f, -0.03265499f, 0.00728772f, 0.02276996f, -0.03821260f, 0.04463184f, 
    0.19292785f, 0.06314848f, 0.05557755f, -0.04689702f, 0.04018653f, 0.01297968f, -0.13228753f, 0.01665490f, 
    -0.02721627f, 0.08796399f, -0.06456865f, 0.06430615f, 0.01520676f, 0.09714702f, 0.03093265f, 0.02341347f, 
    0.01968848f, -0.04280511f, -0.01927222f, 0.01985931f, -0.01777350f, 0.10344072f, -0.04415084f, 0.07179298f, 
    -0.04650338f, 0.21021928f, -0.03221130f, -0.06456128f, -0.13455865f, 0.11150233f, 0.10586099f, 0.04011618f, 
    -0.13368836f, 0.00457677f, 0.07495885f, 0.02722058f, 0.40618640f, -0.19801757f, 0.16702974f, 0.09985247f, 
    -0.04247839f, 0.07721183f, -0.05105518f, 0.06567277f, -0.03145736f, -0.02126387f, 0.16695426f, 0.07493926f, 
    -0.15282452f, -0.03041236f, 0.05180892f, -0.23053212f, 0.05721214f, 0.05134828f, -0.06291256f, -0.01429186f, 
    -0.04554828f, 0.00809557f, -0.03688282f, -0.14609341f, -0.01312523f, -0.07765873f, 0.06409981f, 0.16171864f, 
    0.04506596f, -0.03836555f, 0.20832960f, 0.11048988f, -0.05092817f, 0.21124002f, 0.05639551f, 0.08460423f, 
    -0.21691194f, 0.03278832f, 0.04280219f, -0.12635612f, -0.14046966f, -0.00954612f, 0.04724589f, -0.01535798f, 
    0.01150789f, -0.07730622f, -0.06915051f, -0.08238858f, -0.19712275f, -0.11078417f, 0.08424648f, -0.11482748f, 
    0.00406516f, -0.01141646f, 0.03574206f, -0.12475114f, 0.04094029f, 0.00292509f, 0.06489953f, -0.09208527f, 
    -0.03766175f, 0.22234769f, -0.09439734f, 0.12357726f, -0.07375163f, -0.05017873f, 0.06593534f, -0.04305187f, 
    -0.03724359f, 0.08888522f, -0.08490042f, 0.00792034f, 0.28505710f, 0.17536661f, 0.07807897f, 0.18233716f, 
    -0.00932416f, 0.05646832f, -0.01180214f, 0.03192202f, 0.09997915f, -0.05046852f, -0.12908252f, -0.11255577f, 
    -0.00842953f, -0.09088179f, 0.01196541f, 0.10945844f, -0.10089704f, 0.02233721f, -0.12485690f, 0.11827453f, 
    -0.05668601f, 0.04154392f, 0.01399696f, -0.09971810f, -0.01992797f, 0.07304232f, 0.01707543f, 0.13489346f, 
    -0.05002473f, 0.03481450f, 0.15166807f, 0.13618368f, 0.02794343f, -0.01871425f, 0.00397652f, 0.00365727f, 
    -0.19824992f, -0.09183504f, 0.04507585f, -0.06268392f, 0.12789299f, 0.03265918f, -0.03566818f, 0.23402783f, 
    -0.00806121f, 0.07025756f, 0.22100998f, 0.16780324f, -0.16377851f, 0.08659713f, 0.04203358f, -0.05351672f, 
    0.07465458f, -0.02878913f, -0.09732624f, 0.05119531f, -0.01082491f, -0.09779224f, 0.04182198f, -0.22168414f, 
    0.39592472f, 0.06598173f, -0.07120413f, -0.10669989f, -0.06199286f, 0.09573280f, -0.14656734f, 0.05883257f, 
    0.05126357f, -0.07525904f, -0.02073411f, 0.15546806f, 0.13804913f, -0.14917210f, 0.04797049f, -0.13325177f, 
    -0.08462291f, 0.05793146f, 0.09458718f, 0.03860646f, 0.08210120f, 0.03770880f, -0.02007649f, 0.26232925f, 
    -0.13245992f, 0.32469222f, -0.04543694f, 0.17581151f, -0.04885794f, -0.02956846f, -0.02432208f, 0.06747642f, 
    -0.07355308f, -0.01021723f, 0.05226104f, 0.12910426f, -0.04895853f, -0.06257470f, 0.07526849f, 0.13835499f, 
    0.02212238f, -0.04589672f, -0.09237711f, 0.01391259f, 0.10688900f, 0.12150403f, 0.00942426f, -0.02778999f, 
    0.11858586f, -0.08661882f, -0.05821078f, -0.08579998f, -0.06035410f, 0.01044362f, -0.03915042f, 0.03655649f, 
    0.11537064f, 0.00079163f, -0.06292876f, 0.17333344f, 0.03471277f, -0.09800018f, 0.06808265f, 0.11711088f, 
    -0.06995021f, 0.02968750f, 0.14612287f, 0.02018676f, -0.01024014f, 0.34802344f, -0.02378997f, 0.05970443f, 
    0.11290339f, 0.00921676f, -0.10922198f, 0.25272799f, -0.16732211f, -0.02923756f, -0.00183745f, -0.10765689f, 
    0.08473063f, -0.01023517f, -0.03788834f, 0.02073462f, 0.04892413f, -0.06525362f, 0.07986841f, 0.19066671f, 
    -0.01040766f, -0.09471444f, 0.03929633f, 0.09693909f, 0.05897416f, 0.06845826f, -0.03216616f, 0.10931445f, 
    -0.22729561f, 0.08343592f, 0.13347648f, 0.01150459f, 0.13415623f, 0.03996342f, 0.04795942f, 0.02741454f, 
    0.07528774f, -0.06687590f, -0.04576550f, -0.12815420f, 0.36358342f, -0.15875325f, -0.03814556f, -0.30230200f, 
    0.03152206f, -0.02373747f, 0.19176495f, -0.06044274f, -0.08258867f, 0.14047530f, 0.01046509f, 0.06059727f, 
    0.04810154f, -0.00603797f, -0.05616758f, -0.10107744f, 0.10636318f, 0.00262500f, 0.07618112f, 0.21225904f, 
    -0.01052949f, -0.04010434f, -0.01481459f, 0.08183426f, 0.10373197f, -0.12600730f, -0.16564040f, 0.03454173f, 
    -0.04745900f, 0.00066607f, -0.05211769f, -0.02647083f, -0.02922569f, 0.03440094f, -0.11984375f, 0.05144062f, 
    0.22455564f, -0.03812038f, -0.00062694f, 0.16034859f, 0.00786162f, 0.09722104f, 0.08849925f, -0.06422754f, 
    0.04668645f, -0.08541913f, 0.00910431f, 0.08902581f, 0.13439399f, 0.21301429f, -0.23395266f, -0.03957224f, 
    -0.00470175f, -0.03354358f, -0.10837728f, 0.02766079f, 0.01410997f, -0.12003705f, -0.05463982f, 0.02148082f, 
    0.35465616f, -0.05488172f, -0.03988528f, -0.29883349f, 0.03399577f, -0.01798631f, -0.02995880f, -0.04442348f, 
    -0.07967558f, 0.18171619f, 0.02516026f, -0.02466293f, 0.15604569f, 0.02952283f, -0.06462978f, -0.32987863f, 
    -0.03152005f, -0.04691960f, -0.04938226f, 0.06517340f, 0.00444446f, 0.02574738f, -0.14207646f, 0.06114053f, 
    0.02237375f, -0.16212942f, 0.15161015f, -0.16617197f, -0.10899372f, 0.09904085f, 0.03262625f, 0.01237545f, 
    -0.02564612f, -0.13190560f, -0.01438951f, 0.06809831f, -0.12202256f, -0.13333546f, -0.11512688f, 0.03564141f, 
    0.02324025f, -0.15985288f, 0.08177039f, 0.01306369f, 0.03311359f, 0.18864398f, -0.21899650f, -0.00827043f, 
    0.11688576f, 0.25556132f, 0.06804607f, -0.20894872f, -0.04100536f, 0.13637432f, -0.10528287f, 0.02309433f, 
    0.03539724f, 0.00935294f, -0.04268608f, 0.02126958f, 0.13212232f, -0.05713999f, -0.19199973f, -0.10260326f, 
    -0.03426818f, -0.08128645f, -0.08565915f, -0.00262482f, -0.03701711f, -0.00636930f, -0.00453841f, 0.01421698f, 
    0.04349456f, -0.05449849f, -0.13053860f, 0.14086372f, -0.09519115f, -0.06084252f, -0.09886858f, 0.03567137f, 
    0.02514541f, 0.26544780f, 0.13698027f, 0.10563692f, -0.11173603f, -0.03721334f, 0.01510068f, 0.07803094f, 
    0.09518550f, 0.01818156f, -0.04273245f, 0.03981640f, -0.01027413f, 0.08561292f, 0.18359303f, -0.03680594f, 
    0.04436558f, 0.11091211f, 0.15302642f, -0.23157638f, 0.07138243f, -0.05679302f, 0.04353018f, 0.05338020f, 
    0.09276529f, -0.01125803f, -0.11491504f, -0.11216821f, -0.08958580f, -0.12702696f, 0.15860046f, 0.05669367f, 
    -0.03354371f, -0.06233226f, 0.14179920f, -0.00092340f, -0.06501896f, 0.13720199f, 0.00028623f, 0.13670821f, 
    0.05136936f, -0.10522374f, -0.05891315f, -0.01683751f, -0.07363266f, 0.01021250f, 0.06095485f, -0.00472567f, 
    -0.02841865f, -0.08978431f, -0.01867006f, -0.01295536f, 0.03368415f, -0.09396457f, 0.18722422f, -0.20239496f, 
    -0.09114228f, -0.08349836f, 0.13010080f, -0.05860228f, 0.10092486f, -0.05548609f, 0.04134251f, -0.28642449f, 
    -0.00849781f, 0.12304493f, -0.20487207f, 0.13911226f, -0.05196124f, 0.05065418f, 0.13602082f, 0.05184406f, 
    0.14279523f, 0.10484467f, -0.11995654f, 0.12965596f, 0.15015270f, -0.03430061f, -0.07973674f, 0.00223669f, 
    -0.06752999f, -0.05943355f, 0.14061505f, 0.00494018f, 0.16042031f, -0.01156411f, -0.13502097f, -0.14585154f, 
    0.17430261f, -0.21493915f, -0.25942329f, 0.01707087f, -0.11307150f, -0.01662870f, -0.24806547f, 0.13799535f, 
    0.01616766f, 0.17597719f, 0.10213653f, -0.05175300f, 0.05906455f, -0.10055810f, -0.19808502f, -0.09013989f, 
    -0.07150815f, 0.06950390f, 0.10551731f, 0.18285306f, 0.02151434f, -0.09200052f, 0.01342817f, 0.01860075f, 
    -0.04077369f, -0.04968404f, 0.00134737f, 0.02686832f, -0.00174050f, 0.03738526f, -0.04888214f, 0.01543374f, 
    -0.02262590f, -0.00116532f, -0.04862233f, 0.03649752f, -0.03648521f, 0.00457103f, -0.04692197f, -0.04297158f, 
    0.04678223f, -0.00461070f, -0.03043370f, -0.04323236f, -0.02736493f, -0.02781792f, -0.01979981f, 0.00416184f, 
    0.04577415f, 0.03217832f, -0.04141321f, -0.04876760f, -0.02728027f, 0.02108513f, -0.01186219f, -0.00625531f, 
    -0.04254796f, 0.00589523f, 0.02891565f, 0.04949446f, 0.01851703f, 0.04745740f, 0.04016507f, 0.03817748f, 
    -0.03532714f, -0.04221177f, 0.01382652f, -0.03610725f, -0.01557470f, -0.04436865f, 0.04084352f, -0.01663185f, 
    0.01412154f, -0.00857650f, -0.04766104f, 0.03792562f, 0.03163128f, 0.00502232f, -0.00405844f, 0.02745345f, 
    -0.01437862f, 0.00191508f, -0.01635643f, -0.04458927f, -0.01518120f, -0.04237660f, -0.03954337f, 0.02165965f, 
    -0.02609569f, 0.01094390f, 0.04157604f, 0.01486186f, -0.03972196f, -0.03637047f, -0.04478762f, -0.00661231f, 
    0.05083372f, -0.01523560f, -0.04026849f, -0.03912608f, -0.01812620f, -0.02309420f, -0.01087797f, -0.05095761f, 
    -0.00094599f, 0.03402019f, 0.01739156f, 0.03257239f, 0.01308158f, 0.04405274f, 0.04145499f, 0.02118775f, 
    0.01479045f, 0.04140222f, -0.04877104f, 0.04000103f, -0.00458607f, 0.01424916f, -0.04959938f, -0.03188713f, 
    -0.02078480f, -0.03379674f, -0.00698533f, -0.04053681f, -0.03883894f, -0.04749132f, 0.03953931f, 0.01831250f, 
    0.00308956f, -0.05062900f, 0.01553239f, 0.00043375f, -0.01083630f, -0.04994074f, 0.04013081f, 0.01410506f, 
    0.02367296f, -0.02740066f, 0.01823197f, 0.00481811f, 0.03322932f, -0.00939864f, -0.01428427f, -0.02397287f, 
    -0.04337684f, 0.02066870f, 0.03733476f, 0.03614481f, 0.04443751f, -0.00998451f, -0.04282755f, 0.03886011f, 
    0.00094148f, 0.01762842f, 0.00210080f, -0.04633388f, -0.03751261f, 0.04566435f, 0.03216922f, 0.03942120f, 
    -0.02489087f, -0.00775695f, -0.05044071f, 0.02561119f, 0.03264388f, 0.01029001f, -0.02271281f, -0.00928274f, 
    0.02320802f, -0.04860581f, -0.02247707f, -0.02508996f, -0.02179521f, -0.05026243f, -0.03830097f, -0.01387933f, 
    0.02772665f, -0.03573697f, 0.02092786f, 0.04128745f, 0.04391460f, -0.02051223f, 0.00333014f, -0.02746073f, 
    -0.01410866f, 0.03766387f, -0.02642828f, -0.02584934f, -0.02901783f, -0.03318780f, -0.01237384f, -0.02982296f, 
    -0.02448009f, 0.00814455f, -0.02882646f, 0.04200618f, 0.00654760f, -0.01974840f, 0.00163019f, -0.02850360f, 
    0.03100031f, -0.00997586f, -0.03977622f, -0.03574738f, 0.04657223f, -0.02893789f, -0.01073259f, -0.03408714f, 
    0.03947162f, 0.01570415f, -0.00371779f, -0.02146388f, -0.02064667f, 0.00362285f, 0.00978468f, -0.04888032f, 
    0.00363702f, 0.01150623f, -0.05100549f, -0.03755891f, 0.04341217f, 0.00556629f, 0.02199036f, -0.02826409f, 
    0.00386782f, -0.03766634f, -0.00794292f, 0.01141029f, -0.04785581f, 0.04304789f, -0.00688564f, 0.04175968f, 
    -0.04807442f, -0.00504096f, 0.00779887f, 0.02169641f, -0.01294709f, -0.04139258f, -0.03631343f, 0.04256568f, 
    0.00399442f, 0.00611643f, 0.04009875f, -0.01105055f, -0.04478663f, -0.00432757f, -0.04805306f, -0.01359975f, 
    -0.01732446f, -0.00043614f, 0.00856181f, -0.02072021f, -0.02677532f, 0.00994451f, 0.01065092f, -0.04942447f, 
    -0.01551661f, -0.00649844f, 0.00325780f, 0.03182019f, -0.03477460f, 0.02012985f, 0.03376877f, -0.00656236f, 
    -0.01324473f, -0.02405150f, -0.02325866f, 0.04059823f, 0.02081078f, 0.02059205f, 0.00141372f, 0.03588556f, 
    -0.00508488f, -0.03815654f, -0.01130675f, -0.04058174f, 0.00068521f, 0.02520839f, -0.04648433f, -0.02437198f, 
    -0.03026474f, 0.00255725f, 0.00430836f, 0.03205897f, 0.04585239f, -0.04163248f, 0.01411835f, -0.01354932f, 
    -0.01713494f, -0.04698752f, 0.02326267f, -0.02388875f, -0.00577375f, 0.03662632f, -0.01802029f, -0.01511600f, 
    -0.00313235f, -0.00908786f, -0.04012356f, 0.02478721f, -0.01780047f, -0.01730626f, -0.01219794f, 0.02194920f, 
    0.02578060f, 0.02615300f, 0.01613566f, -0.00781412f, -0.01163472f, -0.01970700f, -0.03969258f, -0.01539595f, 
    0.03367416f, 0.00284863f, -0.04052428f, -0.03845653f, -0.00999663f, -0.02110934f, 0.00450345f, 0.02975899f, 
    -0.02941387f, 0.01949231f, 0.01148798f, 0.03640238f, 0.01379858f, -0.04611088f, 0.01796887f, -0.04927225f, 
    -0.04447210f, -0.00190715f, -0.04876135f, -0.00503375f, 0.01736544f, -0.04882431f, -0.00699361f, 0.00158929f, 
    0.03109076f, -0.01367488f, -0.03194255f, 0.00506111f, 0.02445650f, -0.03418406f, -0.04121318f, -0.00741149f, 
    0.01974546f, 0.02648615f, -0.03492692f, -0.01462878f, -0.01365450f, -0.04183932f, 0.03247854f, -0.00953470f, 
    -0.01665808f, -0.03109837f, -0.03353305f, 0.01205224f, 0.01488856f, -0.03620707f, 0.03785947f, -0.00015398f, 
    -0.05032954f, -0.00848986f, 0.01713511f, -0.04475833f, 0.01628202f, -0.01573766f, -0.04082187f, 0.04709685f, 
    0.04613528f, -0.01652864f, 0.03909615f, -0.02866485f, 0.01424911f, 0.04546092f, 0.02546891f, -0.02546260f, 
    -0.02511252f, -0.04700442f, 0.03129129f, 0.03183959f, -0.01241985f, -0.04304951f, 0.03151128f, 0.03563179f, 
    -0.03446384f, 0.01004015f, -0.00324429f, 0.01510923f, 0.02099090f, -0.01521880f, -0.01855062f, 0.01462480f, 
    -0.04170268f, -0.03515707f, -0.00810180f, -0.02121168f, 0.01289008f, 0.03257934f, 0.00901376f, -0.02156335f, 
    0.04723032f, 0.00691880f, 0.04511013f, -0.02924895f, -0.02961559f, 0.04657491f, 0.00320969f, 0.04970312f, 
    0.00408649f, 0.01599679f, 0.02381692f, -0.03765619f, 0.00826152f, 0.04592105f, 0.03912304f, 0.01446158f, 
    -0.03829897f, -0.01123957f, -0.02032141f, 0.02852190f, 0.00820508f, 0.03653813f, -0.02688150f, -0.03864030f, 
    0.02216861f, -0.00231694f, -0.01966428f, 0.04125842f, -0.03005647f, -0.04335383f, 0.00380083f, -0.01019580f, 
    -0.03116862f, -0.02462824f, -0.01293578f, 0.01437793f, -0.03683407f, 0.03226869f, -0.03397129f, 0.00733691f, 
    0.03493837f, 0.03136579f, -0.04877965f, 0.03688136f, 0.00994088f, 0.03195637f, 0.03775303f, 0.04060163f, 
    -0.01247411f, -0.02878330f, 0.00175805f, -0.05316914f, -0.04285112f, 0.03896260f, 0.00339705f, 0.04236222f, 
    -0.03720610f, -0.04404785f, 0.00715713f, 0.03600900f, 0.04513478f, -0.00390424f, 0.02729246f, -0.03640090f, 
    -0.05661857f, 0.00916116f, 0.01528598f, -0.01283839f, 0.01719235f, 0.04128765f, 0.01620499f, -0.00941161f, 
    -0.05592792f, -0.01450969f, -0.03186937f, 0.00535970f, -0.02098238f, -0.05581091f, 0.03277969f, -0.03437685f, 
    -0.03289330f, 0.02815623f, -0.03454925f, -0.03546394f, -0.00120059f, -0.04019765f, -0.02119605f, -0.04870975f, 
    0.01191664f, 0.03380065f, -0.01587292f, -0.03109139f, 0.01278124f, 0.03230148f, 0.03182149f, 0.02605892f, 
    -0.05475942f, 0.03528627f, -0.01209421f, 0.01563791f, -0.03908560f, 0.01002436f, -0.02030226f, 0.02608055f, 
    0.02374591f, 0.03187594f, -0.04559339f, -0.01569588f, 0.04248746f, 0.02195988f, -0.03419794f, 0.00670852f, 
    -0.03399237f, -0.02890069f, 0.03820468f, 0.00388784f, -0.01251807f, -0.02076332f, 0.00691342f, -0.05476519f, 
    0.02520120f, -0.00781506f, -0.00885991f, -0.02813431f, 0.02132361f, 0.02157618f, 0.00141015f, -0.02412560f, 
    -0.03286672f, 0.04079977f, -0.03503494f, -0.04939824f, -0.05184949f, -0.04075617f, 0.02735875f, 0.01460622f, 
    0.02985981f, -0.04146967f, -0.03771489f, 0.02262908f, 0.02754699f, -0.04384642f, -0.00086236f, 0.03190337f, 
    0.01055627f, -0.03392751f, -0.00496566f, 0.02381954f, 0.01855365f, -0.05881872f, -0.02131470f, -0.03196955f, 
    -0.00498211f, 0.03664085f, 0.02138517f, -0.05730350f, 0.00395038f, -0.00695788f, 0.03467530f, -0.03488765f, 
    0.01885054f, 0.01821590f, 0.00292073f, -0.04623937f, -0.02648246f, 0.02372926f, -0.01664039f, 0.00938503f, 
    0.02213995f, -0.02589419f, 0.04117401f, 0.02995427f, 0.01665365f, 0.00878631f, -0.03367167f, -0.01030092f, 
    0.04615843f, 0.00262226f, 0.00380719f, -0.05101372f, 0.00877270f, 0.00267176f, -0.04506069f, -0.03107599f, 
    -0.01289022f, -0.04702886f, 0.01729404f, -0.01837737f, -0.03643493f, 0.02234641f, -0.02219789f, 0.03608164f, 
    -0.05055938f, -0.00330612f, -0.03503357f, 0.02279287f, -0.04350721f, -0.02799256f, -0.03341886f, -0.00788263f, 
    -0.05699513f, -0.05020969f, 0.01336553f, -0.04427708f, 0.02247049f, -0.04251970f, 0.00087977f, -0.00610273f, 
    -0.04813859f, -0.02887898f, 0.04374877f, -0.03692418f, 0.03849891f, -0.00131808f, 0.03375519f, -0.00420195f, 
    -0.03270309f, -0.01612297f, -0.05109024f, -0.02597136f, -0.05157090f, 0.03245869f, 0.01481688f, -0.02040701f, 
    0.03809351f, 0.00974396f, 0.04377624f, -0.04052891f, 0.01026894f, -0.02863286f, 0.02912357f, -0.02021189f, 
    -0.01822391f, -0.01280403f, 0.00780371f, -0.05415839f, 0.02626007f, -0.01420689f, 0.00903968f, 0.01964390f, 
    0.01203891f, -0.04209949f, -0.04643173f, -0.05631943f, -0.03663302f, 0.00513963f, -0.04688428f, -0.02509036f, 
    -0.03763274f, 0.00883465f, -0.02104456f, -0.00196734f, 0.02802450f, 0.02781313f, -0.03880962f, -0.00747412f, 
    -0.04165574f, -0.04492984f, 0.02009813f, -0.02989567f, -0.02414411f, 0.03329471f, -0.05031214f, -0.00688115f, 
    -0.05072726f, -0.02722860f, -0.01875892f, 0.02029513f, -0.04919137f, 0.00717017f, -0.02218300f, 0.01566525f, 
    0.03108813f, 0.03966609f, -0.02092055f, -0.00299984f, 0.00586439f, -0.02978567f, -0.00589382f, -0.05786800f, 
    0.03320057f, -0.01324243f, -0.02450779f, 0.03329565f, -0.03346830f, -0.03033626f, 0.02618692f, 0.01306500f, 
    -0.04484490f, -0.02958719f, 0.01592625f, 0.04185216f, -0.00421620f, 0.00326340f, -0.03359035f, 0.01724695f, 
    0.01967763f, -0.02066846f, 0.01650549f, 0.03544372f, 0.01647890f, -0.02712226f, 0.01873289f, -0.01802777f, 
    -0.03359524f, -0.00635957f, -0.05756906f, -0.02574899f, -0.02175820f, -0.04604220f, 0.00682422f, -0.05234188f, 
    -0.00425518f, 0.00182516f, -0.05090774f, -0.03467559f, -0.02173827f, -0.04148546f, -0.02843118f, -0.05845139f, 
    0.02669211f, -0.03259575f, 0.03341589f, 0.03352224f, 0.01487631f, 0.03631834f, -0.01089817f, -0.00808776f, 
    0.01552099f, -0.02808242f, 0.03731763f, 0.02610486f, -0.03016577f, -0.00998933f, -0.02231903f, -0.02791549f, 
    -0.03863971f, 0.00128564f, -0.02056700f, 0.03177728f, 0.01718605f, -0.00649467f, -0.03332730f, -0.03021760f, 
    -0.04714072f, 0.02257364f, -0.00993990f, 0.04276287f, -0.05407684f, -0.01710103f, -0.04027623f, -0.02566389f, 
    -0.04220752f, 0.04083839f, -0.05107613f, -0.01834086f, 0.00247261f, 0.01885163f, -0.03148700f, 0.00767399f, 
    -0.03271340f, 0.02042435f, -0.00602323f, -0.04698955f, -0.00744102f, -0.02592380f, 0.03809820f, 0.02768905f, 
    0.04178995f, 0.02374561f, -0.00847835f, -0.03977142f, 0.03087342f, 0.01888964f, -0.03655401f, -0.04754062f, 
    0.02572112f, 0.03229731f, 0.04296052f, -0.05552996f, 0.03498446f, 0.03474157f, -0.05914013f, -0.02196559f, 
    0.02928909f, -0.02902467f, 0.01200098f, 0.03773785f, -0.02305192f, 0.00079776f, 0.02702465f, 0.03502646f, 
    0.34912378f, -0.02802587f, 0.16754158f, -0.13595602f, -0.02707729f, -0.01102112f, 0.02993804f, -0.08873301f, 
    0.05089935f, -0.01763615f, -0.20108487f, -0.05677153f, -0.12896869f, 0.11733951f, -0.15289670f, 0.02025968f, 
    -0.08215508f, 0.10853719f, 0.04611241f, 0.05073852f, 0.05942784f, 0.29522198f, -0.06808195f, 0.17151795f, 
    -0.51396286f, -0.09328266f, 0.14059067f, -0.03303916f, 0.03655041f, 0.06258274f, 0.04463336f, -0.06577604f, 
    -0.01474521f, 0.10064138f, -0.05913650f, -0.10811546f, 0.32385248f, 0.13676484f, -0.17165564f, 0.00423791f, 
    -0.12630606f, 0.08720732f, -0.11123347f, -0.07100934f, -0.10824359f, 0.02397494f, 0.04537952f, -0.15503475f, 
    0.05834612f, 0.03578322f, -0.05275498f, -0.11521718f, 0.01897743f, 0.07650606f, 0.10576505f, 0.07513585f, 
    0.13141237f, -0.03031842f, 0.06843293f, -0.01329218f, 0.31941235f, 0.02017032f, -0.05303117f, 0.06334087f, 
    0.00865224f, 0.01903932f, 0.03992273f, 0.07335497f, 0.16014490f, -0.05239240f, -0.01593010f, 0.05677194f, 
    -0.14221764f, -0.06314620f, 0.06383006f, -0.06339256f, -0.01701181f, -0.07103234f, 0.02208805f, 0.06966171f, 
    0.06861056f, 0.10735741f, -0.04309799f, -0.12448838f, 0.16164909f, 0.03263623f, -0.00808819f, 0.08368535f, 
    0.14311390f, -0.00898561f, -0.07270308f, -0.00571829f, 0.12912785f, -0.22985280f, 0.00737497f, -0.00882311f, 
    0.12942515f, 0.15595199f, 0.13504192f, 0.04908798f, -0.03152049f, 0.01286073f, -0.10175227f, 0.01117609f, 
    0.03814461f, 0.11803250f, 0.12517323f, 0.06499938f, 0.09083647f, -0.10301962f, 0.05260465f, -0.08964498f, 
    0.07741963f, -0.10942543f, 0.04408512f, 0.05973094f, -0.00115500f, -0.07885309f, 0.01214802f, -0.06605680f, 
    0.31149876f, -0.09957120f, -0.07355998f, 0.05352962f, -0.16094163f, -0.01812037f, 0.05588024f, 0.10857455f, 
    -0.06654267f, 0.05100351f, 0.12851289f, 0.19390105f, -0.10917343f, 0.07830311f, -0.19060843f, 0.06317921f, 
    0.00534397f, -0.05656436f, -0.01325478f, 0.00024290f, 0.06729987f, -0.13636678f, -0.09062117f, -0.00981429f, 
    0.00595263f, -0.12966523f, 0.09258618f, 0.14557970f, 0.01639500f, 0.09219232f, -0.03547791f, 0.02784325f, 
    -0.02624710f, -0.03645773f, -0.05791395f, -0.06325173f, 0.18792288f, -0.00653960f, 0.12649928f, 0.05827761f, 
    -0.04937469f, -0.00343177f, -0.04803451f, 0.07447268f, 0.07354473f, 0.03332232f, 0.15904976f, 0.09396166f, 
    -0.01663951f, -0.24354786f, 0.09039843f, 0.10263794f, 0.01040328f, -0.06502417f, -0.15797488f, 0.00006124f, 
    0.05227880f, 0.06835835f, 0.00725304f, -0.09262110f, -0.05785285f, -0.06346955f, 0.05287440f, -0.16948256f, 
    0.01856015f, -0.06684367f, 0.10694980f, -0.03723140f, 0.02913804f, 0.07243527f, 0.02118545f, 0.01595162f, 
    -0.49297142f, 0.01319583f, 0.16424677f, 0.05186206f, -0.09066498f, 0.10151015f, 0.04061281f, -0.06733915f, 
    0.08084213f, -0.03346555f, -0.01038213f, -0.00443517f, -0.20591053f, 0.06124382f, -0.09239563f, 0.10037891f, 
    -0.05253223f, 0.00829724f, 0.08578970f, 0.07611008f, 0.10870255f, -0.08889104f, 0.14123107f, 0.02648224f, 
    0.29309529f, 0.00346698f, -0.27027151f, -0.15465641f, -0.03966921f, 0.06229241f, 0.21100500f, -0.11437067f, 
    -0.01740152f, 0.15599971f, -0.08895130f, -0.03328435f, -0.02405591f, -0.02926380f, -0.07576736f, -0.01274639f, 
    -0.10637579f, 0.07627985f, -0.08495083f, 0.07154392f, -0.00022537f, -0.12386381f, 0.16356905f, -0.01887545f, 
    0.01796301f, -0.02337357f, -0.02939482f, 0.08809835f, -0.05866531f, -0.12702842f, 0.02308950f, -0.05671434f, 
    0.06355678f, 0.04446357f, 0.06459774f, 0.05769256f, -0.08312029f, 0.00565182f, 0.16620596f, 0.22620499f, 
    -0.08057687f, 0.00214736f, -0.13674358f, 0.05084544f, -0.03746095f, -0.00885566f, 0.02091327f, -0.03461511f, 
    0.18496804f, -0.08016840f, 0.23786843f, 0.16035402f, 0.05066558f, -0.01488786f, 0.05410596f, -0.01414275f, 
    -0.00343574f, -0.08567332f, 0.01109181f, -0.11783033f, 0.10994750f, 0.04387942f, 0.04156596f, -0.04082352f, 
    0.03307960f, -0.05811939f, 0.01965835f, 0.01622412f, -0.03307213f, 0.05294780f, -0.15440911f, 0.10494301f, 
    0.00548094f, -0.16194940f, -0.02765337f, -0.09444745f, 0.01556986f, 0.03872365f, 0.14362244f, -0.14619289f, 
    0.07127297f, 0.00380047f, 0.12863289f, 0.07053111f, 0.07924908f, -0.16253960f, -0.11981060f, -0.21040767f, 
    0.06367896f, 0.07542826f, 0.06374065f, -0.17497300f, 0.05379952f, -0.12980923f, 0.04500120f, -0.12319823f, 
    -0.15430999f, -0.03729306f, -0.09199324f, 0.18132401f, 0.04177899f, -0.11163932f, 0.06769355f, 0.02732556f, 
    0.04943863f, 0.05206547f, 0.00858785f, 0.06798118f, 0.12667990f, 0.21860275f, 0.03162543f, -0.03101765f, 
    0.04194017f, 0.08594444f, -0.06350815f, 0.08802219f, 0.01390503f, 0.10033436f, -0.10408146f, 0.24378935f, 
    -0.02643644f, -0.06675313f, 0.01644898f, 0.07888059f, 0.04910668f, 0.10077860f, -0.02217847f, -0.02662143f, 
    0.04458255f, -0.14097784f, 0.09929767f, -0.09901739f, -0.18163988f, 0.03297238f, 0.06029195f, 0.01824689f, 
    0.02680899f, 0.13156457f, -0.05581171f, 0.10111993f, -0.11626881f, 0.02029959f, 0.06470996f, 0.18385835f, 
    0.01271215f, 0.05627443f, 0.20223048f, 0.11690214f, 0.06366847f, -0.03535871f, 0.02920396f, -0.03189368f, 
    -0.03516328f, -0.05836391f, -0.00547436f, 0.04524455f, -0.02996586f, -0.07827862f, 0.09614907f, -0.06193699f, 
    0.13236125f, -0.05441735f, 0.06785214f, -0.01426569f, -0.12696385f, 0.10672746f, -0.02043631f, 0.02819358f, 
    -0.23534431f, -0.11464728f, -0.00004327f, 0.13589816f, -0.08625243f, 0.04047287f, 0.04690823f, 0.05060773f, 
    0.04552378f, 0.13076702f, 0.08691131f, 0.26317370f, 0.20052144f, -0.13164935f, -0.11147515f, -0.01309822f, 
    -0.08112998f, -0.00763730f, -0.02589920f, -0.08988489f, -0.00129350f, -0.16063261f, -0.01270685f, -0.16835964f, 
    0.10619745f, -0.05675791f, -0.09585495f, 0.05231281f, -0.02608785f, -0.01031937f, -0.04855929f, 0.14310838f, 
    -0.05471292f, -0.06056004f, -0.03427405f, 0.11793064f, 0.16956572f, -0.09696991f, 0.03777851f, 0.13977307f, 
    0.02351898f, 0.06428223f, 0.09626582f, 0.14091082f, -0.00916181f, 0.03625222f, 0.06008641f, 0.07848711f, 
    0.33444172f, -0.22033928f, 0.02354893f, 0.12262839f, 0.10524042f, 0.03621459f, -0.08579961f, -0.04127846f, 
    -0.00044214f, 0.02996315f, 0.07569645f, -0.03904925f, -0.19671595f, 0.21535376f, 0.05920244f, -0.11308976f, 
    0.00376871f, 0.07002085f, -0.01517716f, -0.16893670f, -0.10377695f, 0.09132910f, -0.09005143f, 0.06204352f, 
    -0.11621111f, 0.05026967f, 0.00770541f, -0.12084685f, 0.01058152f, -0.02934086f, -0.08751548f, -0.12659767f, 
    0.05549784f, -0.07573391f, 0.05990331f, 0.15338883f, -0.08240411f, 0.08404589f, -0.02142663f, -0.12748933f, 
    -0.04558188f, 0.08922695f, 0.00229593f, -0.00618952f, 0.04535491f, 0.20761853f, -0.06599662f, 0.12262075f, 
    -0.17904542f, 0.03371762f, 0.05793593f, -0.11648499f, 0.14506470f, -0.00093384f, 0.01684482f, -0.06332450f, 
    -0.05295524f, 0.04392330f, -0.04161538f, 0.05391333f, -0.33562335f, -0.02706483f, -0.10327038f, -0.04872362f, 
    -0.05779973f, 0.07394545f, 0.00794511f, -0.00416416f, 0.07532396f, 0.16955496f, 0.01763027f, 0.05177941f, 
    0.33512765f, 0.12449607f, -0.03128325f, -0.08428197f, 0.12283169f, -0.05125039f, -0.06758732f, 0.05693685f, 
    0.07027137f, 0.00032108f, -0.06908047f, -0.02411368f, -0.16573407f, 0.16495517f, 0.24526241f, 0.18955271f, 
    0.09574825f, 0.03243860f, 0.07974432f, -0.02066009f, 0.13339752f, 0.17964381f, 0.28397429f, -0.07306755f, 
    0.13299055f, -0.38115916f, -0.00032376f, -0.00969400f, 0.02097076f, 0.07200738f, 0.01848580f, 0.05626640f, 
    0.08503394f, 0.10161894f, -0.02699929f, 0.15120296f, -0.17967416f, 0.38484639f, 0.07052406f, -0.06155861f, 
    0.10729177f, 0.07846990f, 0.06728024f, 0.01240788f, 0.02257787f, -0.03508435f, -0.05506872f, -0.08666673f, 
    -0.38829765f, 0.41568723f, -0.10572916f, -0.38577402f, 0.07446726f, 0.00261579f, 0.01221097f, -0.03238929f, 
    -0.00063512f, -0.08274147f, -0.11720058f, -0.06014883f, 0.20929372f, 0.05440941f, 0.09629663f, -0.03769232f, 
    -0.02162284f, -0.00057449f, 0.02091202f, -0.02337270f, 0.06520968f, 0.00295064f, 0.04917492f, -0.02978530f, 
    0.11717328f, -0.10992130f, -0.20140474f, 0.00324225f, 0.07070401f, -0.03671629f, 0.05515936f, -0.02308462f, 
    -0.05083456f, 0.04137638f, 0.09717152f, 0.00790120f, -0.10716244f, -0.00749904f, -0.02661407f, 0.00524609f, 
    -0.06321035f, 0.05363360f, -0.06189864f, -0.02374958f, -0.08335160f, 0.10053393f, -0.05249656f, 0.07301394f, 
    -0.19441091f, 0.13632743f, 0.11270420f, 0.47035629f, 0.11884785f, -0.02799162f, -0.01586696f, 0.05576752f, 
    -0.00115574f, -0.01607085f, 0.07048436f, -0.12239980f, 0.22401954f, 0.15872775f, -0.04513174f, -0.15732156f, 
    -0.02834661f, 0.06320045f, 0.13063678f, -0.09265766f, -0.01328438f, 0.09520805f, 0.04832216f, -0.11529972f, 
    0.29943848f, -0.23178573f, 0.01741732f, 0.26124841f, 0.04092458f, 0.00695895f, -0.04227223f, -0.01783562f, 
    -0.05568819f, 0.07311616f, -0.07152808f, -0.03080540f, 0.02495928f, 0.11646245f, -0.06807478f, -0.15340836f, 
    0.16218536f, 0.01930908f, -0.03115645f, 0.03985611f, -0.02182670f, -0.04714180f, -0.08281198f, 0.06932724f, 
    -0.14644088f, 0.13933954f, 0.09440888f, -0.33580634f, 0.16607223f, 0.02843209f, 0.00710435f, 0.07749300f, 
    0.05643072f, 0.04425734f, 0.04593926f, 0.08976411f, 0.27088746f, -0.03034463f, 0.07471350f, -0.07708527f, 
    0.08152356f, 0.02556700f, 0.01164069f, 0.11249002f, 0.03785505f, -0.03381772f, 0.17388113f, -0.04293223f, 
    -0.01303678f, 0.00177543f, -0.10456929f, 0.05036141f, 0.10374409f, 0.09048578f, -0.05891518f, 0.15211041f, 
    0.04425707f, -0.08065950f, -0.07973415f, -0.01271583f, -0.13837810f, 0.32430393f, -0.02874059f, 0.37609375f, 
    -0.05192378f, 0.05583934f, 0.16839227f, -0.08569220f, 0.09958043f, 0.12293403f, -0.02420055f, 0.08492682f, 
    0.24386588f, 0.12687774f, 0.17002901f, -0.12767507f, 0.21357672f, 0.12529823f, -0.05167164f, 0.03092100f, 
    -0.05346291f, -0.05245875f, -0.08517377f, -0.13773955f, -0.07663456f, 0.05590248f, -0.30724078f, -0.09350447f, 
    0.15546252f, 0.09801127f, -0.08722876f, -0.15704213f, -0.02184479f, -0.07737356f, 0.12805216f, -0.07458467f, 
    0.08388517f, 0.05284045f, 0.17943329f, -0.30836877f, -0.00379648f, 0.00752591f, -0.02711127f, 0.08886986f, 
    0.08708815f, 0.10211481f, -0.08989925f, 0.06597105f, 0.19232143f, -0.02695680f, -0.03837688f, -0.00476400f, 
    -0.09726702f, -0.05388125f, -0.03922967f, 0.10322799f, -0.00083542f, -0.05886591f, -0.08352369f, -0.16086105f, 
    -0.09096177f, -0.01698920f, -0.02897185f, -0.10335671f, 0.12246642f, 0.03372839f, 0.03063957f, 0.04446454f, 
    0.02579456f, 0.03248174f, 0.05139720f, -0.10883044f, -0.26175064f, -0.14340355f, 0.04291599f, -0.04963584f, 
    -0.06789017f, -0.00716034f, -0.03511154f, -0.15273188f, 0.03803093f, 0.00516526f, -0.04691160f, 0.00183145f, 
    0.11424410f, -0.07722175f, -0.05048849f, -0.09248042f, -0.10097271f, -0.12027144f, 0.03686472f, -0.04543963f, 
    0.02192307f, -0.00485874f, -0.13714458f, -0.05341798f, -0.02224467f, 0.17886309f, 0.04398697f, 0.12104545f, 
    -0.05942857f, 0.02302232f, -0.00734126f, -0.00237804f, 0.02320345f, 0.19151153f, -0.00332660f, 0.06203675f, 
    -0.14161164f, 0.07728612f, 0.23951027f, 0.00666582f, 0.05625320f, -0.03325856f, -0.11874010f, 0.08799639f, 
    0.07042172f, 0.09454367f, 0.05177057f, -0.04702886f, -0.25427669f, 0.07617679f, -0.26667428f, 0.07702680f, 
    -0.03686905f, 0.06916894f, -0.07450990f, 0.00325595f, -0.10988294f, -0.02300167f, -0.02866421f, -0.07913671f, 
    0.08524098f, -0.06206968f, 0.06624608f, -0.14815104f, 0.06785222f, 0.02750744f, 0.09984243f, 0.02399525f, 
    0.14191370f, -0.01133122f, 0.09875340f, 0.05362955f, 0.28762609f, 0.04478465f, -0.12848225f, 0.05113797f, 
    0.10318542f, 0.12862588f, -0.02622106f, 0.03789476f, 0.12431023f, 0.14477384f, 0.09466684f, 0.05570738f, 
    0.20313671f, 0.08791538f, 0.11153747f, 0.23690942f, -0.06170745f, 0.02366781f, 0.09210615f, 0.05168533f, 
    0.10498670f, 0.03396393f, 0.04188922f, -0.09680092f, 0.17028372f, 0.09905170f, -0.06006102f, 0.10028378f, 
    0.22258110f, 0.07988954f, -0.07463740f, 0.04754208f, 0.02883071f, -0.13682911f, 0.02918820f, 0.03212867f, 
    -0.04832703f, 0.02502556f, 0.14855315f, -0.10616200f, -0.00534428f, -0.11353968f, -0.12820259f, -0.01002136f, 
    -0.00694190f, 0.05021995f, 0.11513150f, -0.06606732f, 0.21336517f, 0.01697828f, 0.02864179f, -0.16776323f, 
    0.06507143f, -0.20984434f, 0.09880877f, 0.10462339f, 0.06099461f, -0.03352586f, 0.02562733f, -0.08087052f, 
    0.15366396f, -0.16190006f, 0.01809840f, 0.09809020f, -0.00617495f, -0.08098445f, -0.02206962f, 0.11925343f, 
    -0.02275527f, -0.02498115f, 0.10613011f, 0.10766133f, -0.10277083f, -0.02012963f, -0.23282020f, 0.15491539f, 
    0.07472977f, 0.05808106f, -0.02865800f, 0.04849559f, 0.05106134f, -0.08155303f, -0.07636814f, 0.01246253f, 
    -0.04858291f, -0.19904950f, -0.12561254f, -0.02105751f, -0.05285906f, 0.04118017f, -0.07966014f, 0.01713335f, 
    -0.03639851f, 0.03455457f, 0.01242381f, -0.00341145f, 0.09910936f, 0.00092082f, 0.08857819f, 0.06356509f, 
    0.00752736f, -0.01467279f, -0.10553646f, -0.01468221f, 0.06852176f, 0.01811072f, 0.17500441f, 0.04128355f, 
    0.07081714f, -0.09550029f, 0.24217449f, -0.07082567f, 0.03389563f, -0.07835181f, -0.05127364f, -0.13500634f, 
    0.15398657f, 0.10559132f, 0.06672078f, -0.06968896f, -0.08561966f, -0.14006451f, 0.20871748f, -0.13046497f, 
    0.06458252f, -0.01992381f, 0.18251055f, -0.11722382f, -0.14602137f, 0.10099187f, 0.13274845f, 0.08612456f, 
    -0.31825241f, 0.18099886f, 0.04228457f, 0.08237671f, -0.06865951f, 0.11241449f, -0.02277235f, 0.11031266f, 
    0.04973780f, -0.05339051f, 0.06964768f, 0.08993843f, -0.16527547f, 0.09602443f, -0.01013991f, 0.14803311f, 
    -0.04621096f, 0.08057515f, 0.05855195f, -0.07226726f, 0.08475532f, -0.06561768f, 0.14582580f, 0.01603945f, 
    0.08719018f, -0.08462233f, -0.31846333f, -0.01532481f, 0.04549003f, 0.13068026f, 0.04750155f, 0.01259631f, 
    0.02013626f, 0.10019570f, 0.03472198f, -0.06866061f, -0.05475460f, 0.15378457f, 0.00885288f, -0.11951228f, 
    0.04164556f, 0.02710921f, -0.07303029f, -0.00722662f, 0.01737550f, -0.07521977f, 0.12815973f, 0.13044862f, 
    -0.24856266f, 0.00353786f, -0.26184574f, 0.04600396f, -0.04212486f, 0.01640616f, 0.14074905f, 0.01624128f, 
    -0.13939439f, 0.05283013f, -0.06700931f, 0.10648971f, -0.01719045f, -0.07161482f, 0.20005356f, 0.11292284f, 
    0.02352614f, 0.00471951f, -0.17528887f, -0.01420409f, -0.00475438f, 0.03700189f, 0.13087572f, -0.02691641f, 
    0.16850087f, -0.01039188f, -0.01437885f, -0.12130599f, 0.04660024f, -0.04293857f, -0.07164944f, -0.09589998f, 
    -0.00145439f, -0.04901945f, 0.07508326f, 0.06547781f, 0.06201684f, 0.04483651f, 0.00308463f, -0.20008627f, 
    0.08423711f, -0.09207260f, 0.15062112f, 0.10099881f, 0.01960942f, 0.01672628f, -0.12703423f, 0.06604542f, 
    0.26369822f, -0.07675616f, -0.23569266f, 0.24882577f, 0.05261628f, 0.07673834f, 0.05879823f, -0.06136536f, 
    0.12291648f, -0.08006888f, 0.11213550f, 0.11894441f, 0.08611951f, 0.06726835f, -0.22789189f, 0.05410207f, 
    -0.05469157f, 0.17269664f, 0.01850090f, -0.10364953f, 0.11922608f, -0.08135033f, 0.02509258f, -0.11804812f, 
    -0.01856762f, -0.03109244f, 0.03890684f, 0.06132053f, 0.06630911f, -0.07555994f, 0.00308694f, 0.04259000f, 
    0.12599477f, 0.02532072f, 0.06454040f, 0.05731031f, -0.05164486f, 0.14766334f, -0.04699126f, 0.27836952f, 
    0.15297133f, 0.02071473f, -0.07801022f, 0.07104623f, 0.04787057f, 0.07334898f, -0.01618285f, 0.22125229f, 
    0.08973162f, -0.12122047f, 0.14565010f, -0.24177760f, 0.15187421f, -0.04610258f, -0.06688630f, 0.00406919f, 
    0.09495662f, -0.03879938f, 0.08151946f, -0.05148984f, -0.21144460f, 0.13139240f, 0.08691774f, -0.00229515f, 
    -0.05427722f, 0.03543906f, 0.06242972f, 0.05613772f, -0.01163822f, 0.15777718f, 0.00352643f, 0.10345643f, 
    -0.16988826f, -0.06713068f, 0.18322738f, -0.02673653f, 0.12717386f, -0.11528131f, 0.00030310f, 0.03325717f, 
    -0.12865756f, -0.00233863f, -0.00676199f, 0.06628177f, 0.01773780f, 0.26992303f, 0.02688279f, -0.15736157f, 
    0.05560679f, -0.08897914f, 0.05573109f, 0.00077364f, 0.00940547f, 0.05441199f, -0.02533762f, 0.04352522f, 
    -0.08274724f, 0.34118962f, -0.01703829f, -0.02919311f, 0.01908270f, 0.03690334f, -0.02078117f, -0.03268746f, 
    0.04326324f, -0.08502646f, 0.06825788f, -0.02394893f, 0.02598961f, -0.16730875f, 0.19629182f, 0.00601375f, 
    -0.04864503f, -0.07991806f, 0.15273440f, -0.06045048f, 0.10091851f, 0.04066557f, 0.00724650f, 0.13296483f, 
    0.02719246f, -0.04834982f, 0.16206662f, -0.02223918f, 0.11940920f, -0.14106503f, 0.01848939f, 0.05973281f, 
    -0.00321748f, -0.10561430f, 0.08333948f, -0.16127795f, 0.17407660f, 0.18434997f, 0.09991395f, -0.05200465f, 
    0.08258768f, -0.00915389f, -0.06333300f, 0.02698483f, 0.04266813f, -0.05473840f, 0.00014833f, 0.08219238f, 
    -0.09995325f, -0.04470408f, 0.08052675f, -0.12445555f, 0.14902256f, 0.01396465f, -0.00840545f, 0.06615110f, 
    -0.07106435f, 0.05164513f, -0.11960557f, -0.02230377f, -0.35407996f, -0.10259028f, 0.11698822f, 0.03850913f, 
    -0.04477350f, -0.01671621f, -0.02433357f, -0.02380528f, -0.00261075f, -0.08463103f, 0.07287856f, -0.01272850f, 
    0.12765507f, 0.16421241f, 0.08438457f, 0.13741079f, 0.07395768f, 0.10314120f, 0.03377667f, 0.08598524f, 
    -0.08806772f, -0.09499442f, -0.04714970f, -0.04109986f, -0.26640242f, -0.15805469f, 0.00909845f, 0.09944898f, 
    -0.04672931f, -0.03742268f, -0.14321122f, -0.07213983f, 0.06360317f, 0.05946847f, 0.05319937f, 0.12259277f, 
    0.08811792f, -0.22530897f, 0.06210022f, -0.05015391f, 0.00425217f, 0.07391324f, 0.11310642f, -0.00205737f, 
    0.00982910f, 0.01050744f, 0.10274517f, -0.03030984f, -0.13166137f, 0.23550147f, 0.17259632f, 0.10643189f, 
    0.09938831f, 0.16860202f, 0.00029546f, -0.09328250f, -0.03874295f, 0.01111510f, 0.02503674f, 0.08507936f, 
    -0.32217729f, 0.06539706f, 0.04386581f, -0.09174015f, -0.01212942f, -0.03899087f, 0.00710888f, -0.04428650f, 
    0.05027754f, 0.09364486f, -0.13652080f, 0.12183526f, -0.14101410f, 0.12819716f, 0.00444689f, -0.04724111f, 
    -0.05889241f, -0.07397126f, -0.04514207f, -0.07122426f, 0.04022554f, 0.02832909f, 0.00386377f, 0.07999864f, 
    -0.22540595f, 0.29560891f, 0.05089999f, 0.01665063f, 0.03475487f, 0.00722368f, 0.04412135f, -0.20583364f, 
    -0.03203274f, -0.08512679f, 0.07807749f, -0.00495175f, -0.07197046f, -0.02606756f, 0.10718019f, -0.24555773f, 
    0.10248747f, 0.00771380f, -0.03194956f, -0.02135278f, -0.10913410f, 0.09924920f, -0.04918656f, 0.04887220f, 
    -0.09066863f, 0.28517669f, -0.04657581f, 0.25325167f, -0.12913966f, -0.13738151f, 0.08217863f, 0.01674476f, 
    -0.02060875f, 0.11334018f, 0.11779957f, 0.06053773f, -0.11705651f, -0.14798178f, 0.04620299f, 0.07724912f, 
    0.25451154f, 0.08356039f, 0.07457923f, 0.14609174f, 0.06254627f, 0.16222043f, -0.04536568f, -0.03275853f, 
    0.38125214f, 0.15491137f, 0.12827222f, 0.05603286f, 0.02147807f, -0.04614027f, 0.02611145f, -0.05007609f, 
    0.10324010f, 0.05155580f, -0.07252997f, 0.09308439f, -0.09039651f, -0.08941811f, 0.03541728f, -0.09853491f, 
    0.20664848f, 0.06457083f, 0.05958274f, 0.04152510f, -0.03421225f, 0.01332784f, 0.01633346f, 0.02436003f, 
    -0.11345886f, 0.31095943f, -0.08063782f, 0.05848506f, -0.06138619f, 0.14355820f, -0.03677586f, -0.09619079f, 
    0.10505393f, 0.01583389f, -0.08249028f, 0.08445154f, -0.01989183f, -0.08437515f, 0.22617498f, -0.06837407f, 
    0.00881422f, 0.06514466f, 0.00664725f, 0.05260199f, 0.06133894f, 0.12033296f, -0.03178505f, -0.04658750f, 
    -0.01062968f, 0.02061864f, 0.09706690f, 0.07981358f, 0.11589687f, -0.01713146f, 0.14084697f, -0.04687212f, 
    0.06637604f, 0.00606111f, 0.09380344f, 0.08168121f, 0.23582247f, 0.00374002f, -0.10426268f, -0.06682029f, 
    -0.01836834f, 0.07717124f, 0.02626493f, -0.13382408f, 0.09925254f, -0.01291451f, 0.00902778f, 0.06296017f, 
    -0.24984871f, 0.08338419f, 0.11691819f, 0.27315474f, -0.05025317f, -0.04152866f, -0.14221442f, -0.06303151f, 
    0.09868398f, 0.10119033f, -0.10212603f, 0.05956856f, -0.50077891f, 0.14129132f, 0.01289305f, 0.01764689f, 
    0.07670137f, -0.02648081f, -0.15093753f, -0.07422460f, 0.05919151f, 0.03907613f, -0.06251486f, 0.06793556f, 
    -0.10283922f, 0.31913108f, 0.06320257f, -0.07104346f, -0.11064763f, -0.09236894f, 0.05831943f, 0.05681609f, 
    0.03535950f, 0.00909395f, 0.04646052f, 0.12944178f, 0.15560962f, 0.07558143f, -0.01365095f, -0.07122924f, 
    0.00114356f, 0.03334854f, -0.06154532f, 0.09980024f, 0.01846652f, -0.01619654f, -0.04961975f, 0.11315345f, 
    0.11521918f, 0.01564715f, -0.11872481f, 0.04894308f, 0.02375425f, 0.01332868f, 0.01035678f, -0.02703275f, 
    -0.09868760f, 0.08821625f, -0.00156492f, -0.06512906f, -0.12499976f, -0.10045636f, 0.11284259f, 0.11980793f, 
    -0.12665927f, 0.05004610f, -0.05682095f, 0.01250618f, -0.08389492f, -0.06010207f, 0.10820814f, 0.02215718f, 
    0.21615496f, -0.13031068f, 0.06731910f, 0.04998232f, 0.01618618f, 0.08146666f, 0.10229924f, -0.01877451f, 
    -0.09254918f, -0.01097601f, 0.11505737f, 0.03330790f, -0.10822655f, -0.23092048f, 0.00785550f, -0.08814891f, 
    0.16173518f, -0.06339178f, 0.04169011f, 0.05245139f, 0.01851166f, 0.07761526f, 0.13388619f, 0.12225889f, 
    0.02896556f, 0.00565400f, -0.06251302f, -0.06828361f, -0.00514955f, 0.01356265f, 0.04211207f, -0.02806441f, 
    0.02668322f, 0.03160199f, -0.02071136f, 0.11856638f, -0.24632858f, 0.09661981f, 0.02389113f, 0.09696874f, 
    0.21730448f, -0.06617746f, -0.06957771f, -0.13589637f, 0.02992505f, -0.07647735f, 0.06610359f, 0.05148774f, 
    0.00314776f, 0.03985228f, 0.02120326f, -0.04970532f, -0.00749138f, 0.00655536f, -0.01246340f, 0.01050209f, 
    0.00755705f, -0.00311629f, 0.00354419f, -0.01336752f, -0.00895289f, -0.05196588f, 0.04203174f, 0.03859984f, 
    -0.04672398f, -0.03595963f, -0.00878796f, -0.03688222f, 0.02285358f, 0.02650260f, -0.01811638f, -0.04755602f, 
    -0.00492024f, 0.03483428f, -0.05899510f, 0.02689548f, -0.00291768f, 0.01944730f, 0.02846396f, 0.01097801f, 
    -0.02916441f, -0.04144654f, 0.01137898f, -0.04044062f, -0.01848796f, 0.03922659f, 0.04765933f, 0.01224564f, 
    -0.00369305f, 0.02642059f, -0.05711331f, 0.03915269f, 0.03459697f, 0.02810699f, -0.01746978f, 0.02230726f, 
    -0.05629025f, 0.01624083f, -0.03580548f, 0.03465458f, 0.00706464f, 0.02611736f, 0.04455179f, -0.00155540f, 
    -0.02001524f, 0.03621784f, 0.02972592f, -0.02758599f, 0.00985178f, 0.00090505f, 0.00468773f, -0.00213912f, 
    0.01683116f, -0.04544551f, 0.01141736f, -0.03127267f, -0.05381085f, 0.04457440f, 0.00130188f, -0.01143089f, 
    0.00894679f, -0.03757531f, -0.02149947f, 0.02267013f, -0.04626130f, 0.00021828f, -0.01455450f, 0.00204737f, 
    -0.02338983f, -0.00052279f, 0.01603672f, 0.00117970f, -0.02648045f, -0.03005775f, 0.01519699f, -0.02607103f, 
    -0.05198930f, 0.04062260f, -0.03257503f, 0.03930897f, 0.01373001f, 0.01859535f, -0.02206362f, 0.01388905f, 
    0.03217605f, 0.03908402f, -0.01366033f, -0.01889724f, 0.03008638f, -0.00236889f, -0.00554419f, -0.02918587f, 
    -0.00913589f, 0.04459000f, -0.02495897f, 0.01314077f, 0.03291303f, -0.03714067f, -0.00815307f, 0.03115279f, 
    -0.05272224f, -0.03342023f, -0.02226665f, -0.04774123f, -0.01761524f, -0.00763176f, 0.00128226f, -0.03938609f, 
    0.04150926f, -0.02774162f, -0.04269072f, -0.01028087f, 0.02863467f, 0.01861047f, -0.02677758f, 0.03770353f, 
    -0.00928126f, 0.03164294f, -0.02493632f, 0.01305227f, 0.00174658f, 0.03486674f, 0.00170443f, -0.03008111f, 
    0.03878393f, -0.02788895f, 0.01119648f, 0.02529852f, 0.02384210f, -0.00262917f, -0.02982174f, 0.02479652f, 
    -0.01811204f, 0.01824248f, 0.00630842f, -0.01379211f, -0.00302698f, -0.04340572f, -0.05367201f, 0.01675094f, 
    0.01132988f, 0.03999011f, -0.03133899f, 0.00538478f, -0.03198151f, -0.04041380f, -0.02012952f, 0.03637185f, 
    -0.03973372f, 0.02633818f, -0.05488966f, -0.01500930f, -0.04883207f, -0.01432784f, -0.00768557f, -0.03403178f, 
    -0.05676081f, 0.03981169f, 0.03322038f, -0.02049435f, -0.04371165f, 0.00213773f, -0.00144551f, -0.05188418f, 
    -0.03618827f, -0.00318687f, -0.01900414f, 0.01792133f, -0.05489482f, -0.04835065f, 0.00603657f, -0.03256949f, 
    -0.04301849f, 0.04656577f, 0.04244798f, -0.03540466f, -0.03169819f, 0.02918160f, -0.03911293f, 0.04233299f, 
    -0.00737781f, -0.05366587f, 0.04171533f, 0.00785177f, 0.04015584f, -0.00497550f, -0.00634842f, 0.04230152f, 
    0.01130688f, -0.02004499f, -0.04514850f, -0.02442381f, 0.03838811f, 0.01475329f, 0.03226858f, 0.00841780f, 
    -0.00339716f, -0.04322284f, 0.00482834f, -0.00974199f, 0.00950652f, -0.03988524f, 0.01361385f, 0.00928078f, 
    -0.04512421f, 0.02960771f, -0.00901109f, 0.02848154f, -0.00632055f, -0.02453426f, 0.02193932f, 0.00216077f, 
    -0.00766908f, -0.00621325f, -0.05014045f, -0.02408038f, 0.03063558f, -0.02986635f, -0.04117358f, 0.01681913f, 
    -0.02514576f, -0.00926130f, -0.03542087f, 0.03790319f, -0.00865301f, -0.03343697f, 0.00817225f, -0.03686902f, 
    -0.00403494f, 0.01777290f, 0.03035923f, 0.00843913f, 0.02158548f, 0.03910990f, -0.04421553f, -0.03831597f, 
    0.01807066f, 0.01894602f, -0.03620416f, -0.03989477f, -0.05385347f, -0.01331688f, 0.01138309f, 0.03736128f, 
    0.03480249f, 0.00788536f, 0.02852014f, -0.00860533f, -0.03727977f, -0.04379917f, 0.00731155f, -0.00989118f, 
    -0.05640642f, 0.01372265f, -0.04976742f, -0.02006077f, -0.02224676f, 0.04151525f, 0.03318543f, 0.00987952f, 
    0.04200607f, 0.01039531f, 0.02839968f, -0.03780330f, -0.01179335f, -0.04082649f, -0.03951063f, 0.01249760f, 
    -0.05410308f, -0.05140048f, -0.04760064f, -0.03642143f, -0.00822381f, -0.02072919f, -0.03486603f, 0.00409677f, 
    0.02963507f, 0.01095131f, -0.02302061f, 0.00789626f, -0.01726050f, -0.02077345f, 0.01886702f, -0.03286884f, 
    -0.04039020f, -0.02868390f, 0.03637602f, 0.00185808f, -0.05373671f, -0.00823101f, -0.01291808f, -0.04227924f, 
    -0.05522071f, 0.02045804f, 0.02556636f, -0.02702930f, 0.02712851f, 0.02400616f, 0.04061720f, 0.01218815f, 
    -0.01656787f, 0.00515659f, -0.03182482f, 0.00435695f, -0.01028695f, -0.04758317f, -0.03168312f, 0.03924433f, 
    -0.03751095f, -0.03724678f, 0.01453146f, -0.01375335f, -0.00303763f, -0.00050679f, 0.03823716f, 0.00056569f, 
    0.00461732f, -0.04400941f, 0.04286123f, 0.04286180f, -0.02259429f, -0.05052504f, 0.00481369f, -0.05453901f, 
    0.03050500f, -0.03836196f, -0.05541831f, 0.01357271f, 0.01274678f, 0.03155616f, -0.00453774f, 0.04166218f, 
    0.04339728f, 0.03009160f, 0.02130770f, 0.02809789f, 0.03038715f, 0.02744716f, -0.01704344f, -0.04836218f, 
    0.02863250f, -0.00292617f, -0.04869648f, -0.00637870f, -0.03999641f, 0.03774349f, -0.02865508f, -0.02404265f, 
    -0.00869493f, 0.03061431f, 0.00202353f, -0.01206475f, -0.04910762f, -0.01749814f, 0.01164302f, -0.05001761f, 
    -0.01299968f, 0.01149127f, -0.04067143f, 0.01398114f, -0.03393219f, -0.03900392f, -0.02101560f, 0.04223223f, 
    -0.04338726f, -0.03639457f, 0.03106434f, 0.02469306f, -0.04898971f, 0.01973713f, 0.02287509f, -0.00550929f, 
    -0.03804126f, -0.00372258f, 0.03354005f, -0.00150315f, -0.02572650f, 0.00006127f, -0.02803036f, 0.04416180f, 
    -0.01720787f, 0.01260308f, 0.02946514f, -0.01552345f, -0.03222308f, 0.00222738f, -0.00972470f, 0.00881389f, 
    0.01977724f, -0.03877722f, 0.01246843f, 0.03960241f, 0.00971174f, -0.04389127f, 0.02610820f, -0.04601254f, 
    0.01799238f, -0.05452847f, 0.04081739f, -0.00624756f, 0.01901877f, -0.05205084f, 0.03735187f, -0.04877675f, 
    0.03290935f, 0.04199959f, -0.01969509f, -0.03668864f, 0.02074346f, -0.02996619f, 0.00036546f, 0.01058737f, 
    -0.05084640f, 0.00874183f, -0.05224366f, -0.04089212f, 0.04337106f, 0.01887508f, -0.03098110f, 0.02161372f, 
    0.03254720f, -0.04466228f, -0.04636990f, -0.04000425f, -0.05743447f, -0.02539530f, -0.00198056f, 0.01076986f, 
    0.03710428f, -0.02043282f, -0.05365941f, 0.00902090f, -0.05640262f, 0.02568100f, 0.00012059f, 0.03197268f, 
    -0.00034642f, 0.04694473f, -0.02970556f, -0.01546852f, 0.03225337f, -0.04328317f, 0.04334729f, -0.01775050f, 
    0.01353442f, -0.04640802f, -0.05078877f, -0.02510928f, 0.02606018f, -0.04795423f, -0.00718324f, -0.00847024f, 
    -0.04905030f, -0.05180705f, -0.02814567f, -0.02471764f, -0.02525618f, 0.01527062f, 0.00597208f, 0.05052886f, 
    -0.05750421f, -0.00849447f, 0.03405510f, 0.00093850f, -0.03260464f, -0.03549166f, -0.03596992f, -0.05469240f, 
    -0.01854841f, -0.05094151f, -0.00422900f, -0.01750798f, 0.04842663f, 0.00337423f, 0.00874567f, -0.00512367f, 
    -0.03461820f, 0.00503855f, 0.00454298f, 0.00239480f, -0.03585292f, -0.01157646f, 0.00635680f, -0.01978910f, 
    0.02979107f, -0.02028348f, -0.03415740f, -0.03688705f, -0.01102976f, -0.01599823f, 0.01921913f, -0.02533891f, 
    0.01075415f, -0.05341405f, 0.02225879f, -0.05031135f, 0.01172154f, 0.01809882f, 0.00605328f, -0.04855949f, 
    0.02114904f, -0.04674109f, 0.03153042f, -0.02229895f, 0.00833924f, -0.01112793f, -0.03443747f, -0.03423226f, 
    -0.01042383f, -0.05171222f, -0.05513920f, 0.02328617f, 0.03636132f, 0.04035264f, -0.02121478f, 0.02464870f, 
    -0.03775996f, 0.02209907f, 0.00080458f, 0.02183641f, 0.01012683f, 0.03619919f, -0.00441278f, -0.01140032f, 
    -0.04553406f, 0.00369645f, -0.04773567f, -0.03112223f, -0.00316712f, 0.00046208f, 0.00338593f, -0.00158841f, 
    0.02993728f, 0.01663140f, -0.04802470f, -0.05468950f, -0.03689530f, -0.02651368f, -0.02047574f, 0.01388717f, 
    -0.02426389f, 0.00902484f, 0.03753648f, -0.05165312f, -0.03642960f, -0.00357374f, 0.02312867f, 0.01210682f, 
    0.01941838f, 0.03228825f, -0.04879105f, 0.01328025f, -0.01130075f, 0.01805392f, 0.02167985f, -0.03802840f, 
    0.00757380f, 0.02173234f, 0.04267835f, -0.00464509f, -0.04377067f, -0.02594152f, -0.00369963f, -0.00505462f, 
    0.02871567f, 0.02335631f, 0.03027934f, -0.04948358f, -0.05123065f, -0.00215592f, 0.03347552f, -0.01730501f, 
    -0.03780054f, 0.00890050f, 0.04493096f, -0.04387244f, -0.00486764f, 0.01182996f, -0.03498754f, -0.04677294f, 
    0.03232469f, 0.02718694f, 0.03175283f, -0.03659052f, 0.03109827f, 0.02259405f, 0.02061896f, -0.00538471f, 
    0.01490423f, -0.03319800f, 0.03862621f, 0.02823829f, -0.04578581f, 0.01089470f, -0.00614235f, -0.05518395f, 
    -0.03665476f, -0.02640547f, -0.01188226f, -0.03194781f, -0.05329735f, -0.03374504f, 0.00268941f, 0.00259143f, 
    -0.04009412f, 0.02416019f, -0.01380681f, 0.03055459f, -0.00839704f, 0.00006132f, -0.00703175f, 0.03508190f, 
    0.01557699f, 0.01932082f, -0.02888201f, -0.01717222f, -0.05591414f, 0.01451453f, 0.00046794f, 0.01841102f, 
    -0.00373524f, 0.02666681f, -0.02425946f, 0.02502775f, 0.03460398f, -0.02148033f, -0.02912436f, -0.02286845f, 
    0.02823614f, 0.02403922f, 0.01818950f, 0.02715470f, -0.02840155f, -0.03399271f, -0.02602263f, -0.01136392f, 
    0.03936389f, -0.04949869f, 0.03277695f, 0.00224383f, -0.02587426f, -0.04463482f, -0.01688186f, -0.02596388f, 
    -0.04615486f, -0.02821401f, 0.01107323f, 0.01147053f, -0.00962631f, 0.01403461f, -0.02915801f, -0.00843467f, 
    0.01625305f, -0.02052545f, -0.01875001f, -0.03535431f, 0.02455876f, 0.02881667f, -0.04989975f, 0.04221239f, 
    -0.04736505f, 0.01974529f, -0.05424382f, -0.03420650f, -0.02973728f, 0.01636870f, -0.03406480f, -0.04926188f, 
    0.04725014f, -0.00603245f, -0.05582364f, -0.02859782f, -0.03506257f, -0.00990222f, -0.00652659f, -0.03775451f, 
    -0.05491865f, -0.02100744f, -0.00697193f, 0.00965735f, 0.03753356f, -0.00660380f, -0.00724929f, 0.04101224f, 
    0.03424637f, 0.04460179f, -0.04107747f, 0.01802172f, -0.00642253f, 0.00118097f, 0.03868916f, -0.03477393f, 
    0.00494400f, -0.03754632f, -0.00906668f, 0.04978837f, 0.02625037f, -0.05141329f, -0.00294633f, 0.02823880f, 
    -0.04256414f, 0.02387884f, 0.00239493f, 0.01062838f, 0.00832096f, 0.04051139f, -0.02272601f, -0.04336404f, 
    0.02400016f, 0.02827659f, 0.01688867f, -0.01957750f, 0.02871298f, -0.00494804f, -0.02933369f, -0.00830975f, 
    0.03392142f, 0.03760559f, -0.02727749f, -0.01402966f, 0.04252088f, -0.04504288f, -0.03069264f, -0.04153737f, 
    0.04524965f, 0.00015256f, -0.04084294f, -0.03204602f, 0.00183682f, 0.01722068f, -0.01518803f, 0.00958668f, 
    -0.00183188f, -0.00375771f, 0.02997145f, -0.00416557f, 0.03633149f, 0.02806595f, -0.02864939f, -0.01058130f, 
    -0.01443181f, 0.01644275f, 0.02657486f, 0.03691676f, 0.02984600f, 0.02953819f, -0.03235282f, 0.03116403f, 
    0.00825988f, -0.00092972f, -0.05528703f, 0.01182752f, -0.01414895f, -0.01355448f, 0.02394175f, -0.02483970f, 
    -0.03866363f, -0.03414153f, -0.04970599f, 0.00121703f, 0.04119765f, 0.02293810f, 0.02060497f, 0.00150876f, 
    -0.03796764f, 0.01912677f, 0.00296527f, 0.04478474f, 0.01699888f, 0.01239754f, 0.00491188f, 0.01634024f, 
    -0.00196808f, -0.04207477f, -0.03316582f, -0.00301473f, -0.01073871f, 0.03320497f, 0.03396985f, 0.01303693f, 
    0.04498670f, -0.03626272f, -0.02222504f, -0.03700007f, -0.02405908f, 0.00563228f, 0.03312903f, 0.00861340f, 
    0.03773155f, 0.04279450f, -0.03818628f, 0.00883621f, -0.02039674f, -0.03345674f, -0.05173481f, -0.02750664f, 
    -0.02295933f, -0.00282883f, 0.00705984f, 0.03178932f, -0.01533919f, -0.00032888f, -0.04715362f, 0.03045472f, 
    -0.05448227f, -0.03551282f, 0.02537253f, -0.03420050f, -0.00244448f, -0.04341532f, -0.00320141f, -0.00135099f, 
    0.01348587f, 0.00852774f, -0.01586176f, 0.02339680f, -0.01273980f, -0.02299899f, -0.05575481f, -0.00046022f, 
    -0.01559478f, -0.04991393f, -0.03521121f, -0.02387013f, -0.00044775f, -0.00250089f, -0.00007732f, -0.00068169f, 
    -0.01105922f, -0.04449578f, -0.04944411f, -0.00297498f, 0.00823786f, -0.02845288f, -0.05195554f, -0.05068605f, 
    -0.00957346f, -0.05098206f, -0.04748289f, 0.00181932f, 0.01092188f, 0.03280295f, -0.00366999f, 0.00568691f, 
    0.00132740f, -0.03000191f, -0.01069078f, -0.03222358f, -0.00730625f, 0.02382731f, 0.04493968f, -0.01345048f, 
    -0.02897674f, 0.00418452f, -0.03204676f, 0.00660066f, -0.04130001f, -0.04801603f, -0.04340577f, 0.00408907f, 
    -0.05214451f, -0.05552397f, 0.01186647f, 0.02280135f, -0.01398665f, -0.04932068f, 0.04010031f, -0.01246489f, 
    0.01793503f, 0.00568772f, 0.01504376f, -0.01612665f, -0.04862169f, -0.00997371f, -0.03168160f, -0.03022324f, 
    0.03667092f, 0.04130774f, 0.00982944f, 0.00122615f, 0.01213339f, -0.03074508f, -0.03041233f, 0.03193515f, 
    0.04047516f, -0.00620373f, -0.03315783f, -0.05490954f, 0.04472364f, -0.02000892f, -0.03859472f, -0.00285013f, 
    -0.01238317f, 0.02464623f, -0.02177165f, -0.00498335f, -0.04430662f, 0.03391420f, 0.01821047f, 0.04437857f, 
    -0.00004016f, -0.01139253f, -0.01322970f, 0.01223571f, 0.02338881f, 0.01122789f, -0.01126154f, 0.02709291f, 
    0.04284582f, -0.02907318f, -0.05304259f, 0.03828258f, -0.02638761f, -0.00632126f, -0.00199132f, -0.02600352f, 
    -0.03213298f, -0.02025665f, -0.00025080f, -0.04142191f, -0.04140604f, 0.02391013f, -0.03296936f, -0.02945916f, 
    -0.02414561f, 0.02235624f, -0.01068524f, 0.01941546f, -0.00040611f, -0.02981351f, -0.04206808f, 0.03762401f, 
    -0.01928041f, -0.02312851f, -0.03086964f, 0.03988750f, 0.03267270f, -0.05227137f, -0.02313399f, -0.02236736f, 
    0.01975624f, -0.02754671f, 0.04095505f, 0.00293396f, 0.03662263f, -0.03580793f, -0.04822337f, -0.03764379f, 
    -0.03426728f, -0.00446445f, -0.05373745f, -0.00268955f, 0.01432153f, 0.03906971f, 0.02229906f, 0.02860345f, 
    -0.00026675f, -0.05593622f, 0.03310912f, -0.05517678f, -0.05540528f, 0.03081909f, -0.02567931f, -0.00735810f, 
    -0.00274441f, 0.02881070f, -0.01378686f, -0.02280024f, 0.03904698f, -0.02294683f, 0.04995996f, 0.02471132f, 
    0.02800456f, 0.03720610f, -0.02285381f, 0.01351358f, -0.03226548f, -0.04210620f, -0.04751657f, -0.01046009f, 
    -0.05558936f, -0.01872719f, -0.01423306f, 0.00988650f, -0.00412018f, -0.02345943f, -0.02539480f, 0.03289330f, 
    -0.01242712f, 0.04170721f, -0.00831445f, -0.05454396f, 0.02824171f, -0.02712945f, -0.03535282f, 0.00952048f, 
    -0.04671072f, -0.02489072f, -0.03720027f, 0.00655068f, -0.00740248f, 0.04288018f, 0.01849321f, -0.01664685f, 
    -0.00012254f, -0.05066326f, -0.03706481f, -0.03376281f, -0.05056682f, 0.04142537f, 0.02762505f, -0.05630818f, 
    0.01667576f, 0.00897969f, -0.04688459f, -0.02502892f, 0.01259988f, -0.02297722f, -0.05046622f, 0.02709150f, 
    0.00887983f, 0.01946367f, -0.00171345f, -0.01641622f, 0.04055003f, -0.01025158f, 0.02858611f, 0.04445080f, 
    0.03154760f, 0.00154416f, -0.01661397f, -0.02470249f, -0.00117074f, 0.00171795f, -0.03478088f, 0.01486617f, 
    -0.04175386f, -0.05042185f, -0.02991150f, -0.03694218f, -0.02211805f, -0.05223576f, 0.02098203f, 0.00952126f, 
    0.03659876f, -0.01925491f, -0.03939714f, 0.00234252f, 0.00473672f, 0.01575958f, 0.02662073f, 0.00257930f, 
    0.01566352f, 0.03346378f, 0.00388142f, 0.01337483f, 0.03582823f, 0.02302926f, -0.03628784f, 0.02720213f, 
    0.03556888f, -0.02274281f, 0.03281389f, 0.01704664f, 0.01777079f, 0.00102557f, -0.01371761f, 0.04044576f, 
    -0.04567761f, -0.02246806f, 0.02988669f, -0.04796577f, -0.01890944f, 0.03426825f, -0.03161289f, -0.00126458f, 
    -0.02780318f, 0.03993744f, -0.03344351f, -0.00385020f, -0.01573174f, -0.04129314f, -0.00502827f, 0.00659089f, 
    0.01863389f, 0.01744550f, -0.00639475f, 0.00811798f, -0.04675086f, -0.04324271f, 0.03670318f, 0.00267518f, 
    -0.01391431f, -0.05409724f, -0.03907812f, -0.03654255f, 0.00219405f, -0.00777768f, 0.02748989f, -0.05229164f, 
    0.02620077f, -0.01555535f, -0.01180990f, 0.01055030f, -0.05034633f, 0.01785397f, -0.01699409f, -0.03821620f, 
    0.03226571f, 0.00358020f, -0.05630612f, -0.00587770f, 0.00225226f, -0.04996957f, -0.05187848f, 0.02370120f, 
    -0.01374346f, 0.00251603f, -0.00586416f, -0.04169904f, 0.03227664f, 0.02891499f, -0.02146437f, 0.00855687f, 
    -0.00522945f, -0.02574297f, 0.00784300f, 0.00808683f, -0.02765223f, -0.05017741f, -0.00482885f, 0.01724193f, 
    -0.04936503f, 0.03484546f, -0.00981135f, -0.04484157f, 0.03502851f, 0.03783893f, 0.01019870f, -0.03105893f, 
    -0.03506552f, -0.03632629f, -0.03310811f, -0.04275565f, 0.03229615f, -0.02770908f, -0.05898704f, 0.04458844f, 
    -0.03706369f, -0.00772205f, 0.02694842f, -0.03341865f, -0.01699908f, 0.03858311f, -0.02681308f, -0.04670021f, 
    -0.03505012f, 0.01522447f, -0.05548133f, -0.03913229f, 0.00762488f, -0.03972388f, -0.04926633f, 0.01596824f, 
    -0.05053670f, -0.00616039f, 0.00549423f, -0.01962833f, 0.00473431f, 0.03028195f, -0.01367221f, -0.00479473f, 
    0.02535898f, 0.03305785f, 0.03576525f, -0.03093105f, 0.00825388f, 0.00024981f, -0.04339271f, 0.00906811f, 
    0.01435192f, 0.00483148f, -0.02805131f, 0.04266306f, 0.02745645f, -0.05578283f, 0.00003871f, 0.01248903f, 
    0.02554454f, 0.00930354f, -0.02233068f, 0.03738495f, -0.05174842f, 0.02586229f, 0.03104255f, 0.02052619f, 
    -0.00096762f, -0.01138216f, -0.00300757f, -0.00741520f, 0.02929219f, 0.01150027f, 0.00300283f, 0.02455604f, 
    -0.04710169f, -0.01244069f, -0.05090494f, -0.01319536f, 0.01477194f, -0.02885567f, -0.04587293f, 0.00703001f, 
    -0.03018731f, -0.00681632f, 0.03242913f, -0.05206306f, -0.03210540f, 0.03695126f, -0.04964021f, -0.00886173f, 
    0.01844552f, -0.05126073f, 0.00929095f, 0.03108991f, -0.04987023f, -0.02141269f, 0.02112755f, -0.02957818f, 
    0.04211645f, -0.01745167f, -0.00443115f, -0.04244043f, 0.00730213f, 0.01715724f, 0.03929355f, 0.03246834f, 
    0.00526542f, 0.02951251f, -0.00654137f, 0.03087966f, -0.00717736f, -0.02367174f, 0.01426337f, -0.05973018f, 
    -0.02014149f, -0.00722338f, 0.01439345f, -0.03831235f, -0.02009246f, -0.02767945f, 0.01340564f, -0.04014843f, 
    -0.05607661f, -0.04226450f, -0.00554702f, 0.02717073f, -0.01160549f, 0.03048560f, 0.00973135f, -0.03536193f, 
    0.02257515f, -0.04932179f, -0.04632163f, 0.03884272f, -0.01236359f, -0.01083172f, 0.01908270f, 0.02852179f, 
    -0.01455117f, -0.05449083f, 0.01354686f, -0.03579917f, -0.02284821f, 0.01345007f, -0.02601162f, 0.02514950f, 
    0.02579542f, 0.00487374f, 0.00474934f, -0.05480896f, 0.02544549f, -0.02242746f, 0.00649520f, -0.05490103f, 
    -0.01392641f, -0.00134751f, -0.04855180f, -0.05121458f, -0.00824881f, 0.00957712f, 0.01312645f, -0.01295988f, 
    0.04352222f, -0.04733499f, 0.03813648f, 0.00998557f, 0.01065576f, -0.03483156f, 0.03115251f, -0.01502280f, 
    -0.04273276f, 0.04077400f, -0.01153845f, 0.02937437f, -0.02183338f, -0.00943494f, 0.00416539f, 0.03824184f, 
    0.02267899f, 0.04100729f, -0.05180145f, -0.04639155f, -0.02680532f, -0.03831664f, -0.03424744f, 0.00697171f, 
    -0.03219106f, 0.03190660f, -0.00331521f, -0.00894836f, -0.00078066f, 0.00596737f, -0.04336064f, 0.02605741f, 
    -0.01936356f, -0.05335447f, -0.03276978f, 0.05048607f, 0.04363727f, -0.02710415f, 0.02723004f, 0.00663361f, 
    0.03602253f, -0.05446185f, -0.01687572f, 0.01927175f, -0.04239928f, 0.01970690f, 0.00093106f, 0.00901077f, 
    -0.01946756f, -0.05813092f, -0.04288817f, -0.02844575f, -0.02606857f, -0.02793112f, -0.02584996f, 0.01091681f, 
    0.00392491f, 0.01595733f, -0.00976774f, 0.00639516f, -0.05141957f, 0.04858167f, -0.02450108f, -0.00525628f, 
    -0.04780404f, -0.02013790f, -0.01192470f, -0.00309220f, 0.01873339f, -0.01025238f, -0.01241498f, -0.03306014f, 
    0.00206362f, -0.05511560f, -0.00449757f, 0.02089470f, -0.03187163f, -0.00845395f, 0.00301848f, 0.01765450f, 
    -0.03608978f, 0.01658836f, -0.04626035f, -0.02805301f, 0.00348963f, -0.05063085f, -0.04594388f, -0.02883104f, 
    -0.03909263f, -0.04788014f, -0.05753595f, 0.01517244f, 0.00071417f, 0.03493130f, 0.03163023f, 0.03510380f, 
    -0.05562307f, 0.01869621f, -0.02663021f, 0.03122297f, -0.03890926f, -0.04665108f, 0.02421715f, 0.02066156f, 
    -0.03515573f, -0.02305442f, -0.03054768f, -0.00738647f, 0.01654144f, -0.03130006f, 0.02790647f, 0.00722273f, 
    0.01943276f, -0.01632344f, 0.03198466f, 0.02575947f, 0.01020661f, -0.02842896f, 0.03762631f, 0.00059920f, 
    -0.02483341f, 0.03713793f, -0.03051285f, 0.00971845f, -0.01894292f, 0.03374675f, -0.04574567f, -0.04200842f, 
    0.01265653f, -0.01499626f, -0.05027089f, -0.03093221f, 0.00334761f, -0.01210711f, -0.03164346f, 0.01873372f, 
    0.02013524f, 0.00906294f, 0.04099564f, -0.00016607f, -0.03798575f, 0.04716300f, -0.01889466f, -0.03951298f, 
    -0.05359538f, -0.04737050f, 0.01570072f, 0.01338234f, -0.01091965f, 0.04058379f, -0.03766033f, -0.02177657f, 
    -0.05500314f, -0.03241492f, -0.02069888f, -0.03847189f, -0.05205710f, 0.03533809f, -0.01489969f, 0.01820640f, 
    0.04327353f, -0.04704376f, -0.03095921f, -0.01890626f, 0.03642442f, 0.01946242f, 0.00984509f, -0.04902008f, 
    0.02434223f, 0.02584856f, 0.01335485f, -0.02192653f, 0.03547899f, 0.04204869f, -0.04405039f, -0.03774111f, 
    -0.00404700f, -0.05476660f, -0.01248687f, -0.05662341f, -0.02966954f, -0.05617633f, 0.04582079f, -0.00600802f, 
    0.01543090f, 0.00840011f, 0.03458261f, -0.05510673f, -0.03421941f, -0.05100426f, 0.04419963f, -0.02073350f, 
    -0.00958436f, 0.01652113f, -0.04136499f, 0.00484245f, 0.03892670f, 0.01097945f, -0.01012712f, 0.01553936f, 
    -0.02357955f, -0.00327634f, -0.05234978f, -0.01542004f, -0.00343281f, -0.00353708f, -0.00258758f, 0.00228369f, 
    -0.04606358f, -0.00109643f, 0.03053267f, 0.01024924f, -0.02637408f, -0.04551742f, 0.03534117f, -0.02330575f, 
    -0.00343916f, 0.04304507f, -0.01106164f, -0.04803243f, 0.00110309f, 0.01825978f, -0.01017893f, -0.00467815f, 
    -0.05799344f, -0.04353445f, -0.00092173f, -0.02293155f, -0.05640078f, 0.03406857f, 0.01701345f, 0.01806878f, 
    0.10579447f, 0.06171303f, -0.09440120f, -0.36001313f, 0.18297610f, 0.09974705f, -0.04062243f, 0.04983687f, 
    0.05694590f, 0.01970911f, 0.08260938f, -0.03432327f, -0.12526153f, -0.26654848f, 0.00751724f, -0.07405000f, 
    0.01516882f, 0.08892998f, -0.06249201f, 0.06779142f, 0.06816197f, 0.11584727f, 0.02871885f, 0.12652948f, 
    -0.43604788f, -0.17957468f, 0.20697409f, 0.07510964f, -0.01587311f, 0.09555312f, 0.01389812f, -0.07093280f, 
    -0.01055088f, -0.00685127f, -0.00906953f, -0.01009333f, 0.06174779f, -0.16309020f, 0.07089955f, -0.27054340f, 
    0.05029061f, 0.13552181f, 0.00125346f, -0.03317089f, 0.07782324f, 0.04794342f, 0.01363173f, 0.03655519f, 
    -0.12964578f, -0.05363473f, -0.18087138f, -0.00074442f, 0.12418321f, -0.02089250f, 0.02392048f, 0.07684244f, 
    -0.01387934f, 0.05725305f, -0.00974323f, -0.02573203f, 0.11687911f, 0.06019365f, 0.25308329f, 0.07544199f, 
    -0.16579008f, -0.24957907f, 0.03627649f, 0.10767865f, -0.03246545f, -0.09692340f, 0.01299517f, 0.10602418f, 
    -0.18179655f, 0.00494075f, -0.06404993f, 0.09886503f, 0.14743783f, 0.07715155f, 0.05259564f, -0.00757927f, 
    -0.04290584f, 0.04969819f, -0.05656805f, 0.00640887f, 0.11951353f, -0.02812649f, 0.12239576f, -0.02949006f, 
    -0.01402604f, -0.13423540f, -0.01804008f, 0.04706030f, -0.03073205f, 0.05716889f, 0.07781756f, -0.05961117f, 
    0.23696677f, 0.06432909f, 0.10235498f, 0.03981731f, 0.00419522f, 0.18620512f, 0.08409159f, 0.01110667f, 
    -0.04670046f, -0.03206302f, 0.00320226f, -0.00291771f, -0.00064550f, -0.01605834f, -0.03799995f, -0.09236604f, 
    0.20020415f, 0.01415479f, 0.09692986f, -0.15167639f, 0.07035052f, -0.09051050f, 0.01885626f, -0.02529518f, 
    -0.08665343f, 0.20232292f, 0.04510177f, -0.10842568f, -0.09697100f, 0.04779257f, 0.07904474f, 0.05404756f, 
    -0.00067864f, 0.07302665f, 0.08415677f, 0.04231321f, 0.06406171f, 0.01706460f, 0.17548315f, -0.01793975f, 
    -0.09375942f, 0.10602698f, -0.01346473f, 0.07234039f, 0.07902896f, -0.04123726f, 0.01002450f, 0.04498385f, 
    -0.03945740f, 0.13452159f, -0.04165312f, -0.10861945f, 0.20296413f, -0.00749996f, 0.04098820f, -0.09611847f, 
    -0.14704043f, -0.00515101f, 0.05459583f, 0.04330262f, 0.23889929f, 0.11252671f, 0.19541985f, -0.07390616f, 
    0.02787873f, 0.05313300f, 0.05242529f, -0.15338571f, -0.11070973f, -0.02177983f, 0.01280854f, 0.01501034f, 
    0.04503039f, 0.14216028f, -0.11260037f, 0.10655546f, -0.12178881f, -0.12536818f, -0.04432711f, -0.00715753f, 
    0.00640629f, 0.15168044f, -0.04176530f, 0.06702705f, -0.47029194f, -0.17476662f, -0.37271357f, 0.15045746f, 
    0.16904697f, 0.12670450f, -0.06320684f, 0.10624394f, 0.07985996f, 0.06753346f, -0.07570462f, 0.02933860f, 
    0.33177382f, -0.07266782f, 0.05788617f, 0.10588866f, 0.02160831f, 0.02382768f, 0.12897785f, 0.06332953f, 
    0.08815945f, -0.03668569f, 0.05964573f, 0.05674603f, -0.27980471f, -0.20514335f, -0.38813177f, -0.08593588f, 
    0.13165103f, -0.03367508f, 0.15890825f, 0.13152644f, 0.03314212f, 0.11604343f, 0.01529803f, 0.08161540f, 
    0.13497850f, -0.14351162f, -0.05510252f, -0.22182851f, 0.02070924f, 0.14201209f, -0.06421074f, 0.09902975f, 
    0.03455460f, 0.04821648f, -0.02364918f, 0.10529485f, -0.50330997f, -0.28968081f, -0.19483566f, 0.02394086f, 
    -0.01185630f, -0.02426028f, 0.01035277f, 0.06366535f, 0.10356075f, -0.00008855f, 0.11037689f, 0.05468613f, 
    -0.10831443f, -0.23802477f, -0.07387280f, -0.25612050f, 0.13070332f, 0.02736483f, 0.03614361f, -0.02139157f, 
    0.10223913f, 0.00169190f, 0.02734341f, -0.04800620f, 0.19590753f, 0.13936569f, 0.00620626f, 0.09012994f, 
    -0.12416580f, -0.04645696f, 0.14052811f, -0.06782573f, 0.09926835f, -0.05805090f, -0.11552829f, 0.15813892f, 
    -0.11840917f, 0.07418294f, 0.12603378f, 0.17484863f, -0.00586501f, 0.07812855f, 0.08515830f, -0.07877131f, 
    0.04342134f, 0.01114373f, -0.10404911f, -0.15162528f, -0.37878302f, -0.16977887f, -0.05475335f, -0.00392299f, 
    0.00196035f, 0.00091492f, 0.00230065f, -0.01771584f, 0.04897335f, 0.07908107f, -0.06513605f, -0.00125692f, 
    -0.22673866f, -0.15562399f, 0.19406539f, -0.03487565f, -0.14756180f, 0.02320430f, -0.00064113f, -0.03049666f, 
    0.06157090f, 0.00739288f, 0.06527507f, 0.09641413f, 0.33303732f, -0.13666917f, 0.25760612f, -0.28953817f, 
    0.06080393f, -0.02967670f, 0.02618591f, 0.09673637f, 0.00482396f, -0.11040831f, 0.03806001f, 0.08086108f, 
    0.17491056f, 0.14990008f, 0.05084831f, 0.16403987f, 0.02306427f, 0.05384776f, 0.02839361f, -0.01873312f, 
    0.00953796f, -0.05068874f, 0.10548157f, 0.10711994f, 0.15099199f, 0.07112535f, 0.31056273f, -0.09648326f, 
    -0.19117334f, -0.01967284f, -0.00069432f, 0.16326430f, -0.05082919f, 0.04369696f, 0.00489231f, 0.12252501f, 
    -0.03304859f, 0.21225810f, -0.10092322f, 0.27730960f, 0.01639265f, 0.11864878f, -0.01411816f, 0.08038861f, 
    -0.05740184f, -0.00196628f, 0.14666252f, -0.01280112f, -0.10107405f, -0.09944224f, -0.25656396f, 0.06001455f, 
    0.06893693f, 0.08075012f, -0.03347540f, -0.00830303f, 0.15235400f, 0.03474387f, 0.04481931f, 0.08001246f, 
    0.02301642f, 0.28788164f, -0.06085303f, -0.13919991f, -0.07811785f, 0.00827093f, 0.12038755f, 0.00429480f, 
    -0.05163947f, -0.08261664f, 0.09186517f, 0.05018244f, -0.37547109f, -0.36117625f, -0.26132214f, -0.10974783f, 
    0.16102129f, 0.08594720f, 0.04867165f, -0.11019319f, -0.01414110f, 0.01287265f, 0.02144960f, 0.01067744f, 
    -0.00468676f, -0.03445609f, 0.02067290f, -0.00142627f, 0.03684384f, -0.01873614f, -0.01161576f, -0.05257425f, 
    -0.02885281f, 0.03145022f, 0.01364082f, -0.00256538f, 0.02748263f, 0.00321103f, 0.03377429f, 0.01801207f, 
    0.03008879f, -0.04668060f, -0.00922788f, 0.01886462f, 0.03989395f, 0.00286834f, -0.04286340f, 0.01648063f, 
    0.03939723f, -0.04372514f, 0.02187275f, -0.03002941f, 0.02118065f, 0.03187617f, 0.03566009f, -0.05587598f, 
    0.00028239f, -0.01165743f, -0.02435486f, 0.01306901f, -0.00381872f, -0.03091068f, 0.00817929f, 0.01457082f, 
    0.01343193f, 0.04378774f, -0.01869479f, -0.05673299f, -0.03853491f, -0.04522746f, -0.03766756f, 0.02399215f, 
    0.03830430f, 0.04290750f, -0.03173250f, 0.04215981f, 0.02599381f, -0.02284031f, 0.00414818f, 0.00604463f, 
    0.02986987f, -0.03493124f, 0.00356912f, -0.05375671f, -0.03158120f, 0.02898519f, 0.03631984f, 0.03309942f, 
    -0.02890343f, -0.01110955f, -0.03336971f, 0.03953576f, 0.04111988f, 0.00488049f, 0.03910518f, 0.02045895f, 
    -0.05806039f, 0.04171198f, 0.02947504f, 0.00538131f, 0.03560599f, -0.01164651f, 0.01526928f, 0.03618816f, 
    -0.05361959f, -0.00983662f, -0.03841937f, -0.05026869f, 0.00098857f, -0.01304753f, -0.05120756f, -0.04995366f, 
    -0.04015399f, -0.01755062f, 0.00747711f, 0.03360426f, -0.01864394f, 0.02339386f, -0.01169999f, -0.03117281f, 
    -0.02955048f, -0.05774761f, 0.02361583f, 0.02829338f, 0.01882967f, 0.02262445f, -0.00322021f, 0.02326611f, 
    0.00944178f, 0.02787409f, 0.02766529f, -0.04290597f, -0.00412626f, -0.04120495f, 0.03640957f, 0.02159758f, 
    -0.05276266f, -0.02659869f, -0.00152088f, -0.05173953f, -0.01440782f, 0.00964398f, -0.05061830f, 0.01319001f, 
    0.02081236f, 0.04208099f, -0.00610893f, -0.03331730f, 0.00491429f, 0.03518931f, -0.00798595f, -0.01252214f, 
    0.01781498f, 0.00514045f, -0.05467623f, 0.03074622f, 0.02630205f, 0.00932244f, -0.02484586f, 0.04278647f, 
    0.00162050f, 0.01314122f, -0.00275798f, 0.04064090f, -0.01459533f, -0.05852334f, -0.01545077f, 0.03814437f, 
    0.01595630f, -0.03565779f, -0.04819745f, -0.04614451f, 0.01300176f, 0.02870080f, -0.04761574f, -0.05950125f, 
    -0.00653355f, -0.06014708f, -0.02833088f, -0.03306767f, -0.01000928f, 0.00531365f, -0.04278412f, 0.01712400f, 
    0.02957654f, 0.00363993f, -0.00064825f, -0.04951626f, -0.02241520f, 0.02692713f, -0.03851102f, 0.03721780f, 
    0.00290444f, -0.05244046f, 0.00054957f, -0.02036743f, -0.04583948f, 0.00520210f, 0.03359312f, -0.04135732f, 
    -0.02151109f, 0.04862978f, -0.05490979f, 0.01221812f, -0.01583561f, -0.03674967f, -0.00052177f, -0.00941072f, 
    -0.05655602f, 0.02025067f, -0.02421858f, -0.04689679f, -0.06537663f, -0.03386471f, 0.03106667f, -0.02175028f, 
    0.02627470f, -0.02326541f, 0.00819486f, -0.01452488f, -0.04695854f, -0.05571771f, -0.03860019f, 0.01135424f, 
    0.00416233f, 0.03233903f, -0.04432782f, -0.01318394f, 0.00272114f, 0.00728035f, 0.00844870f, -0.02891811f, 
    -0.01994633f, -0.02242889f, -0.05155590f, 0.00207790f, -0.02964651f, -0.04237934f, 0.03714973f, -0.05842230f, 
    -0.04387837f, 0.02692286f, -0.02584995f, 0.01566837f, -0.00692158f, 0.01962315f, -0.01101130f, 0.03755384f, 
    -0.05660813f, 0.00431803f, -0.04975005f, -0.03144921f, 0.01560616f, -0.00643008f, 0.01859739f, -0.02534595f, 
    0.00946430f, 0.03127094f, -0.02241917f, -0.02970046f, -0.05386624f, -0.04225895f, -0.02813609f, 0.01272183f, 
    0.00329962f, -0.04079140f, -0.01786119f, 0.04364833f, -0.02843034f, 0.03439171f, 0.02025674f, -0.02387686f, 
    -0.05221492f, 0.02870731f, -0.04142490f, -0.01234887f, 0.00528785f, 0.00249706f, 0.04178230f, -0.03113377f, 
    -0.03828653f, -0.04242909f, -0.03678924f, 0.01400710f, -0.05296339f, -0.02804054f, 0.02593102f, 0.03410037f, 
    -0.00131693f, 0.00650189f, 0.03004037f, -0.01996847f, 0.04791692f, 0.03749333f, -0.01615699f, -0.04894546f, 
    0.03347631f, 0.03920365f, 0.00118111f, -0.02280506f, -0.03948712f, 0.02426934f, 0.02581432f, 0.01505573f, 
    -0.03396191f, 0.03862567f, -0.00672652f, 0.03827726f, -0.00205577f, -0.04592039f, 0.02835766f, -0.05415943f, 
    -0.00237450f, -0.02918067f, 0.00796745f, -0.02004905f, 0.02366002f, -0.03745787f, 0.00567783f, -0.02895925f, 
    0.03831455f, 0.03355614f, -0.03459191f, 0.03447463f, -0.01706640f, -0.04160102f, 0.03467301f, -0.03419776f, 
    -0.01807840f, 0.01490738f, -0.04370677f, 0.01498845f, -0.01724057f, -0.04394763f, -0.01621835f, 0.00548860f, 
    0.04907059f, 0.01590036f, 0.00505542f, -0.00589531f, -0.01239232f, 0.03502274f, -0.03731694f, -0.00182088f, 
    -0.02642940f, 0.00141016f, -0.03128998f, 0.04016319f, 0.03761152f, -0.00971557f, -0.00377983f, -0.00495571f, 
    -0.01749087f, -0.01650291f, 0.02501911f, -0.05383184f, -0.00724555f, -0.03422728f, 0.02993351f, -0.05740388f, 
    -0.00528844f, -0.05702786f, -0.01623436f, 0.02580008f, 0.05126474f, 0.04012620f, 0.04198903f, -0.01578006f, 
    -0.01544364f, 0.00114006f, -0.02688492f, 0.01662802f, -0.02653616f, 0.02040803f, -0.03831206f, -0.04626076f, 
    0.01010140f, 0.00295072f, 0.02504782f, 0.03512652f, -0.05582569f, 0.01121162f, -0.02556616f, -0.05072203f, 
    0.02429801f, -0.01868502f, -0.04702217f, 0.01774898f, -0.04712118f, -0.01054284f, -0.02876434f, 0.02014280f, 
    0.02722543f, -0.01206629f, -0.04802895f, 0.01374131f, -0.01460996f, 0.02128521f, 0.00485255f, 0.03843271f, 
    0.02128889f, -0.03698016f, 0.00426334f, 0.01959230f, 0.01231270f, -0.00519276f, -0.02419288f, -0.04910531f, 
    -0.19143146f, -0.17084153f, -0.08093128f, -0.05939730f, 0.00742692f, 0.02030048f, -0.03506099f, -0.02794397f, 
    -0.00555177f, 0.01280871f, 0.04070126f, 0.04841913f, -0.13407856f, 0.22470732f, 0.09964404f, -0.00701989f, 
    -0.13565452f, -0.06603450f, 0.15142493f, 0.04327827f, -0.01302348f, 0.08801675f, -0.01632011f, 0.06214332f, 
    0.37412637f, 0.10420278f, 0.03170991f, -0.20535129f, -0.00147340f, -0.12656865f, 0.04748309f, 0.13876730f, 
    0.08671132f, 0.11082425f, 0.01518374f, 0.07040974f, -0.25980181f, -0.06054750f, -0.07400663f, 0.15232427f, 
    -0.07645981f, -0.01173339f, -0.04613262f, -0.01258713f, -0.06501891f, 0.03296690f, -0.00432303f, 0.08717985f, 
    -0.30970126f, 0.15376475f, -0.07555883f, -0.08488547f, -0.05090117f, -0.07045028f, 0.05473697f, 0.07299317f, 
    0.09135023f, -0.01308704f, -0.00459031f, -0.02134847f, -0.16091624f, -0.10162232f, 0.12438415f, 0.06692030f, 
    -0.00552644f, 0.05011166f, 0.01334109f, 0.11818314f, 0.13698171f, 0.03213198f, -0.02090745f, -0.04540930f, 
    0.18746087f, 0.09294928f, 0.03931945f, -0.19094279f, -0.06079844f, 0.07845621f, 0.08765559f, 0.11628577f, 
    0.06978257f, 0.04844589f, 0.12484689f, 0.16924505f, 0.04248495f, 0.05525390f, 0.09282599f, 0.13630071f, 
    -0.03541195f, 0.08889235f, -0.00965417f, 0.02340393f, 0.06307576f, -0.04405290f, 0.05890668f, 0.08803697f, 
    0.11221366f, 0.06175238f, 0.34932819f, 0.12257016f, -0.11018553f, -0.02146146f, 0.00918773f, 0.08061887f, 
    0.01635692f, 0.12041601f, -0.02997713f, -0.05423086f, 0.00700012f, -0.00199544f, -0.08205156f, 0.00873333f, 
    0.05569106f, -0.05580037f, -0.02481279f, 0.09727750f, 0.07501996f, -0.01909702f, 0.02624247f, -0.06489497f, 
    -0.14628042f, 0.10045234f, 0.22690204f, -0.14900658f, 0.01115721f, 0.00019862f, 0.02939459f, 0.08472832f, 
    0.08944353f, 0.00246355f, -0.02462855f, 0.03225221f, 0.13434747f, -0.20391956f, -0.20398097f, 0.09289099f, 
    0.08294163f, 0.15031241f, 0.02835386f, -0.04225004f, -0.05893658f, -0.06377836f, -0.18227185f, 0.04800864f, 
    -0.16341163f, 0.04380716f, -0.16507955f, 0.09952805f, -0.01022806f, -0.07250284f, 0.10359310f, -0.06328926f, 
    0.04611164f, 0.10094348f, 0.03691345f, 0.02188607f, 0.12069054f, -0.08585771f, 0.10160913f, 0.02594796f, 
    -0.04373540f, -0.09302653f, 0.02806423f, 0.17052652f, 0.18915315f, 0.01019829f, 0.00924348f, 0.08404838f, 
    0.30929744f, 0.02833620f, 0.02462821f, -0.06849205f, 0.01761460f, 0.11298742f, -0.03555367f, 0.07870156f, 
    0.10405880f, 0.05684006f, 0.12362540f, 0.05052514f, -0.24565773f, -0.00123944f, -0.17049941f, -0.11954217f, 
    -0.03657194f, 0.03883278f, 0.11564948f, -0.03299111f, -0.08022317f, -0.01975658f, 0.09742592f, -0.00207048f, 
    -0.10761590f, 0.07329276f, 0.03596204f, 0.00429715f, -0.08243772f, 0.10376398f, 0.08763193f, -0.05932730f, 
    -0.03665631f, -0.04089014f, 0.09472751f, 0.05061685f, -0.19956085f, -0.12774418f, -0.11597671f, -0.15185852f, 
    -0.08305290f, 0.00316264f, -0.07080049f, -0.03245189f, 0.01058395f, -0.05451755f, 0.14657968f, 0.16867615f, 
    -0.11370911f, -0.17875442f, -0.18277934f, 0.02710581f, -0.02811369f, 0.12465120f, 0.00946478f, 0.00061183f, 
    0.07691049f, 0.09154990f, 0.03697487f, 0.10943951f, -0.38818190f, 0.04632904f, -0.03394226f, 0.04727653f, 
    0.02163665f, 0.02985116f, 0.07031415f, 0.06744456f, 0.01243272f, -0.04521256f, 0.10423313f, 0.11421555f, 
    -0.43318558f, 0.11921720f, -0.09414098f, 0.02501459f, -0.02728567f, 0.03975137f, 0.06939158f, -0.08557355f, 
    0.01051716f, 0.04857492f, -0.06146627f, 0.16222300f, -0.02827937f, 0.02931664f, 0.16079633f, 0.10335003f, 
    0.04114748f, 0.06344077f, -0.02656135f, 0.02425547f, 0.08423563f, 0.08017185f, 0.11120931f, 0.00355655f, 
    0.19303446f, 0.08895507f, 0.23015042f, 0.16352282f, 0.03935601f, 0.05693563f, -0.03390667f, 0.14127818f, 
    0.04555034f, -0.03849854f, 0.10452884f, 0.03299244f, -0.33659196f, 0.14355248f, -0.00162918f, 0.05002460f, 
    0.05275592f, -0.07057282f, 0.05127945f, 0.10836145f, 0.01073724f, -0.08833072f, -0.04335241f, 0.03276426f, 
    0.05347701f, -0.11984220f, -0.05125126f, 0.08799745f, 0.03184259f, 0.17313159f, 0.06738626f, -0.01614437f, 
    -0.01998937f, -0.09301889f, 0.02183917f, 0.09286976f, -0.11887278f, -0.22147614f, -0.06922101f, 0.05794922f, 
    0.01698686f, 0.08368234f, 0.06280089f, -0.03684856f, -0.01908778f, -0.01193874f, 0.04366782f, -0.03074518f, 
    -0.14377397f, -0.04465634f, 0.11872570f, 0.05426454f, 0.02230744f, 0.01104358f, -0.04315276f, 0.08681024f, 
    0.00674554f, 0.04687572f, 0.08873624f, -0.04338797f, -0.05374748f, 0.00877577f, 0.25763673f, 0.24325718f, 
    -0.06064048f, 0.02299007f, 0.06545140f, 0.04511388f, -0.02508397f, -0.05304356f, -0.03664939f, 0.07975653f, 
    0.23071906f, -0.18731034f, 0.18121955f, 0.02943740f, 0.03009704f, -0.01418616f, 0.14573339f, 0.10914151f, 
    -0.00870481f, -0.01897201f, 0.03671689f, 0.11623045f, -0.13445134f, 0.02217865f, 0.04418850f, 0.04128687f, 
    0.05235214f, 0.03972972f, 0.04570587f, 0.10981946f, 0.19776641f, 0.10988037f, 0.03608983f, 0.22778405f, 
    0.01542043f, -0.14994414f, 0.09813304f, 0.04582620f, 0.03957326f, 0.02072046f, 0.08451722f, 0.00681336f, 
    0.05731013f, 0.12715256f, -0.03897059f, -0.08922257f, 0.03742879f, 0.07088125f, -0.06169892f, 0.07594676f, 
    0.04900993f, 0.01210531f, 0.09452160f, 0.07278280f, 0.06735284f, 0.13023302f, 0.08167329f, 0.08983218f, 
    0.01242016f, 0.02408423f, -0.02947430f, -0.02721361f, 0.00907979f, -0.05576677f, -0.01312627f, -0.02738325f, 
    0.03622486f, 0.03435373f, -0.04545685f, -0.00796500f, -0.00931668f, 0.01137514f, -0.01807798f, -0.01363537f, 
    -0.00038245f, 0.03089535f, -0.04707490f, -0.03387880f, -0.00926824f, -0.04897627f, -0.03424358f, -0.02576772f, 
    -0.05039944f, 0.03137962f, -0.04922184f, -0.04502479f, 0.00760913f, -0.02902044f, -0.05131992f, -0.04751316f, 
    0.02803094f, 0.01878939f, 0.01469979f, -0.02551453f, -0.00040552f, -0.04260619f, 0.04186738f, 0.01443360f, 
    0.02973874f, -0.04095187f, 0.03103430f, -0.03420129f, -0.03262861f, -0.04969347f, -0.02917042f, 0.03231233f, 
    -0.02773503f, 0.01638551f, 0.04244644f, 0.02950694f, -0.00359339f, -0.04640065f, -0.00144731f, 0.04145102f, 
    -0.04515118f, 0.03878093f, -0.03926978f, -0.02065280f, -0.01936560f, -0.03282621f, -0.00074380f, -0.00021545f, 
    -0.04015240f, -0.00766134f, 0.03325143f, -0.03020640f, -0.05040691f, 0.04127712f, 0.03553155f, -0.00280414f, 
    0.03829427f, -0.03371136f, 0.01993658f, 0.02887346f, 0.02622101f, 0.04452413f, 0.02841439f, -0.01058121f, 
    0.02851481f, 0.00231101f, -0.04813740f, -0.04248491f, 0.02095171f, -0.00042523f, 0.02301927f, -0.04192560f, 
    0.03311366f, -0.01262411f, 0.03432265f, -0.04821065f, -0.02752637f, -0.03660085f, 0.00071254f, -0.00545408f, 
    -0.03867988f, -0.03160995f, 0.02512368f, -0.01247151f, 0.04030078f, -0.00439883f, -0.02908342f, -0.01650672f, 
    0.02397582f, 0.00327248f, -0.02708849f, -0.02923505f, -0.02642079f, -0.02048368f, 0.00767532f, 0.00063221f, 
    -0.01877455f, -0.02926892f, -0.02556315f, -0.02924181f, -0.01500054f, -0.03079305f, -0.02026376f, 0.01000438f, 
    -0.01330449f, -0.00247278f, 0.03476644f, 0.01048780f, 0.01059703f, -0.00001527f, -0.05574159f, 0.02885969f, 
    -0.02217035f, 0.04350542f, 0.03881029f, -0.04478752f, 0.00145540f, -0.03373425f, -0.02232128f, -0.01240056f, 
    -0.05359350f, 0.01814250f, -0.01621130f, 0.00397822f, 0.01885411f, 0.00572666f, 0.04576471f, -0.01634020f, 
    -0.01278559f, -0.01304730f, -0.01925668f, -0.00276197f, -0.00557165f, -0.02757241f, -0.01249489f, -0.00720850f, 
    -0.02600313f, 0.03199296f, -0.00278571f, -0.05587975f, 0.02438746f, 0.00977458f, -0.02585564f, 0.03717118f, 
    -0.03089489f, 0.01596338f, -0.03165364f, -0.04256320f, 0.01807465f, -0.04664001f, 0.04092910f, 0.01710602f, 
    0.04244855f, -0.04510155f, -0.04344694f, -0.05530970f, 0.01666432f, 0.03630312f, -0.02456615f, 0.03187585f, 
    -0.04390949f, 0.00491462f, 0.02283653f, -0.05186019f, 0.03219948f, -0.02199440f, -0.00227173f, 0.00019983f, 
    -0.04500252f, 0.02541944f, 0.04299691f, -0.04322584f, -0.05254047f, -0.02015991f, 0.03560046f, -0.05007432f, 
    0.02208211f, -0.05345963f, -0.02369722f, -0.03984678f, -0.01876601f, -0.05346033f, -0.04151190f, -0.05246155f, 
    0.00758884f, -0.03634096f, -0.02324312f, -0.04375770f, -0.02816433f, -0.04696206f, -0.04625188f, 0.03984039f, 
    -0.01283712f, -0.00476725f, -0.01560671f, 0.00348645f, -0.02545264f, -0.00166428f, 0.01815145f, -0.04436185f, 
    -0.04077246f, -0.03404732f, -0.04593228f, -0.00065578f, -0.04273577f, 0.01406634f, -0.04228789f, 0.04355908f, 
    -0.02622240f, 0.04254413f, 0.01285922f, 0.02340374f, 0.04568792f, 0.03368140f, 0.03176681f, -0.04234558f, 
    -0.02316205f, -0.03089990f, -0.03850934f, -0.00474326f, 0.02092442f, 0.02777150f, -0.03596311f, 0.02486804f, 
    -0.05378932f, -0.00050706f, -0.04244363f, -0.00587306f, -0.00700498f, 0.03910065f, -0.04763158f, 0.01146205f, 
    0.02652054f, 0.00861560f, 0.02435697f, -0.02540113f, 0.04528977f, 0.01369763f, -0.00972261f, 0.04359889f, 
    -0.05198649f, 0.04061738f, -0.04454038f, 0.04459086f, 0.03183000f, -0.01534131f, -0.04669939f, 0.04018364f, 
    -0.04735484f, -0.04670782f, 0.04163656f, 0.02103153f, -0.04956993f, 0.04052116f, 0.02177625f, 0.02823671f, 
    0.00981816f, 0.01487601f, -0.03288583f, 0.02446616f, -0.02182172f, -0.02831496f, -0.03875675f, 0.03616338f, 
    0.02248901f, 0.03470962f, -0.02209270f, -0.04235611f, -0.00969840f, -0.02972508f, -0.00828566f, -0.04358718f, 
    -0.05065975f, -0.03514071f, 0.03292571f, -0.02514772f, 0.04108120f, 0.01945287f, 0.00676271f, 0.03147272f, 
    0.00023515f, -0.02585615f, -0.02633752f, 0.02867048f, -0.02546985f, -0.01799743f, -0.03971276f, -0.05141414f, 
    0.00749860f, 0.01754353f, 0.01138433f, -0.00761421f, 0.03095510f, -0.03703697f, -0.02668694f, 0.00962881f, 
    -0.02630038f, 0.01534775f, -0.03422815f, -0.01789656f, -0.03906612f, 0.03664227f, -0.05342625f, -0.00043791f, 
    -0.02407981f, -0.03868219f, 0.00465036f, -0.03950987f, -0.00936326f, 0.01591823f, -0.03456182f, 0.00378174f, 
    0.00794868f, 0.00281133f, 0.01158830f, 0.03824903f, 0.02483252f, -0.00567218f, -0.03146216f, -0.03167015f, 
    -0.05193233f, -0.04948899f, 0.00582663f, 0.01247488f, -0.03415031f, -0.04288907f, -0.00833776f, 0.00749093f, 
    -0.00929243f, -0.02925765f, -0.02024844f, 0.03471773f, 0.01714316f, -0.04706367f, -0.04287760f, 0.03615183f, 
    -0.00259391f, -0.03369650f, 0.01559420f, 0.04333556f, -0.04457856f, -0.00304143f, -0.05052589f, -0.03970351f, 
    -0.02248680f, 0.02601860f, 0.03290594f, 0.04834715f, -0.05109281f, 0.02251360f, -0.04967457f, 0.02977343f, 
    -0.00609582f, -0.02582127f, -0.03573335f, -0.00589761f, -0.05559622f, 0.02752780f, -0.04593525f, -0.01535186f, 
    0.01446075f, -0.03736084f, 0.03905226f, 0.00241063f, 0.01579272f, -0.02053686f, 0.03864113f, -0.00321982f, 
    0.01195938f, 0.08129027f, 0.11633396f, -0.09500731f, -0.01851569f, 0.01478381f, 0.03725668f, -0.05092696f, 
    -0.09288184f, 0.07337356f, 0.10805057f, 0.08133546f, -0.13322297f, 0.12225225f, 0.20296051f, -0.01691322f, 
    0.16922520f, 0.12393777f, -0.06659058f, -0.01598698f, -0.00182605f, -0.00732800f, -0.00276700f, -0.10859119f, 
    0.23778529f, -0.15947676f, 0.25832152f, 0.20648369f, 0.07621317f, -0.01735472f, 0.06351054f, -0.01811496f, 
    0.10667456f, 0.03096235f, 0.01928923f, 0.01352926f, 0.35695657f, 0.25563043f, -0.10756288f, -0.02809778f, 
    -0.04967504f, 0.04324623f, -0.07027174f, 0.10285868f, -0.03965291f, -0.02221755f, 0.05911071f, 0.00213316f, 
    0.41130787f, 0.05227972f, 0.22352664f, 0.08178969f, -0.08040180f, -0.04737485f, 0.02890541f, -0.00735271f, 
    0.05689231f, 0.03726935f, -0.03726234f, 0.01779940f, -0.05412433f, -0.01717388f, -0.10203481f, 0.12747166f, 
    0.09487831f, 0.09100682f, -0.12900713f, 0.04980975f, -0.08413657f, 0.15477562f, 0.08338913f, 0.07360256f, 
    0.19423287f, 0.19258405f, 0.02634104f, 0.21282458f, 0.02555973f, -0.10464524f, -0.02823141f, 0.01369415f, 
    0.08182357f, 0.02241894f, -0.04067027f, -0.04123445f, 0.04418860f, 0.09200976f, -0.16934413f, 0.24638852f, 
    -0.00555803f, 0.06941699f, 0.03290937f, -0.13149118f, 0.07541851f, -0.02836313f, -0.11613032f, 0.06855726f, 
    -0.15557061f, -0.05535530f, 0.12983359f, -0.05954404f, -0.06322807f, -0.12308538f, 0.04271413f, -0.10786652f, 
    -0.01280104f, 0.00791534f, 0.14927521f, -0.02894420f, 0.00657629f, 0.09797239f, 0.08778067f, -0.11031435f, 
    -0.09424981f, -0.02611680f, -0.00035057f, 0.00603934f, -0.04594788f, -0.00366177f, -0.06068866f, 0.00624714f, 
    0.05457755f, -0.27605096f, 0.15965506f, 0.30568564f, -0.03081329f, 0.03010840f, 0.05178056f, -0.03325562f, 
    0.01403041f, -0.02311144f, -0.06091418f, -0.11508046f, 0.08132920f, 0.04996898f, -0.11577941f, 0.10379932f, 
    0.07839421f, -0.05430536f, 0.02629924f, 0.07521720f, 0.03932123f, 0.03771153f, 0.03280505f, 0.05833481f, 
    -0.01354081f, -0.28560144f, 0.12792201f, 0.05510960f, -0.06047628f, 0.02069613f, 0.04500077f, 0.05767779f, 
    0.06831888f, 0.06494445f, 0.10198072f, -0.06323223f, -0.10743737f, 0.05703533f, 0.07805520f, 0.07653657f, 
    -0.05958074f, 0.08208802f, -0.01635264f, -0.02249746f, 0.07402913f, 0.10614365f, 0.00571958f, 0.11402617f, 
    0.09317119f, -0.05596419f, 0.16113140f, 0.20715588f, -0.10924541f, 0.07639346f, -0.04213198f, 0.03247703f, 
    -0.01210482f, -0.01764633f, 0.04867244f, 0.01254377f, 0.19805005f, -0.06292564f, 0.19829224f, -0.03195355f, 
    0.00404897f, -0.01459956f, 0.02728402f, -0.11613503f, 0.04720057f, 0.02485426f, 0.04683274f, 0.02395901f, 
    -0.04932253f, 0.00779354f, -0.05467308f, 0.21185227f, -0.05165409f, 0.16574417f, 0.05135490f, -0.04827363f, 
    0.00543069f, 0.19101618f, -0.07888667f, -0.01186959f, 0.12940361f, -0.04178835f, 0.05580774f, -0.10273068f, 
    -0.05269364f, 0.03401562f, -0.01658465f, -0.01399134f, -0.01869518f, -0.05409614f, -0.04639046f, 0.18010150f, 
    -0.05030788f, 0.06526355f, -0.13451117f, -0.00306530f, -0.02618553f, 0.07970531f, 0.05196361f, -0.06755998f, 
    -0.03884766f, -0.02118373f, -0.04101932f, -0.02919572f, 0.26050213f, -0.02732666f, 0.12481540f, -0.13678996f, 
    -0.09851286f, 0.01263643f, -0.02933633f, -0.04251872f, 0.02063287f, 0.04217602f, -0.04734189f, -0.00386406f, 
    0.11623712f, 0.12734400f, 0.10444385f, 0.01545383f, 0.04769056f, -0.07555983f, -0.00539774f, 0.09373292f, 
    -0.05375954f, -0.01352160f, -0.09866311f, 0.18719728f, -0.03903059f, -0.04979305f, 0.07100934f, 0.06716533f, 
    -0.05578028f, 0.08018386f, -0.01188331f, -0.03384684f, 0.02949632f, -0.03208600f, -0.04236466f, 0.00379821f, 
    0.05309122f, -0.07778759f, -0.10079218f, 0.15597594f, -0.10775597f, -0.03310535f, -0.04290814f, -0.00919320f, 
    0.04431615f, 0.10897662f, 0.16795093f, 0.13030049f, 0.27090639f, 0.01670903f, 0.13219662f, -0.06679967f, 
    0.08391967f, -0.06009874f, 0.05108205f, 0.03332467f, -0.05835374f, 0.05647536f, 0.08195435f, 0.01822060f, 
    0.34153190f, 0.10229553f, 0.06469464f, 0.00745140f, -0.05117841f, -0.01424491f, -0.03603872f, 0.00851825f, 
    0.03074032f, -0.05450238f, -0.08417074f, -0.01878110f, 0.13284536f, -0.02652178f, -0.13086464f, 0.04588753f, 
    -0.06277972f, 0.09101483f, 0.06877422f, -0.03209227f, -0.02844324f, 0.07360787f, -0.09877919f, 0.10376386f, 
    -0.16082028f, -0.19520523f, -0.15335283f, 0.11624150f, -0.00303397f, -0.06924993f, 0.13188708f, 0.09473874f, 
    -0.02187294f, -0.04408562f, -0.06597530f, -0.08953732f, -0.03321818f, 0.03998274f, 0.03696593f, 0.00977863f, 
    0.06962895f, 0.03572257f, -0.03469723f, 0.00574404f, -0.02140135f, -0.00786913f, -0.02114311f, -0.09623261f, 
    0.16855644f, -0.11978928f, 0.13197064f, 0.00815255f, 0.00016480f, 0.05771643f, 0.15724058f, -0.03043309f, 
    0.16017263f, -0.01158116f, -0.01322749f, 0.02310342f, -0.18198735f, -0.19899189f, 0.05136052f, -0.07967680f, 
    -0.02778531f, -0.07962190f, 0.08030973f, -0.04197228f, -0.01608714f, 0.06292276f, -0.10668720f, -0.01130122f, 
    -0.23551153f, 0.03060173f, 0.03818035f, 0.01181025f, -0.17205513f, -0.06366967f, 0.03741176f, 0.00252276f, 
    -0.07078718f, 0.13753361f, 0.09985574f, 0.01197687f, -0.29969278f, 0.16462141f, -0.02367786f, -0.02269495f, 
    -0.13763388f, -0.07208326f, 0.02319623f, -0.06022527f, 0.01901999f, -0.03188634f, 0.05960065f, -0.11880264f, 
    -0.04760111f, 0.03964105f, 0.04274974f, 0.01414293f, -0.04495409f, -0.00720965f, -0.03189069f, -0.02605844f, 
    0.01530757f, 0.01144048f, -0.06056263f, -0.01969365f, 0.01448581f, -0.00476556f, -0.02943694f, 0.00632848f, 
    -0.00812446f, -0.00760983f, -0.04421435f, -0.04654359f, -0.05611526f, -0.05400775f, 0.00007068f, 0.01533823f, 
    0.02406523f, 0.03400762f, -0.01158880f, 0.00456190f, -0.02620958f, 0.01252312f, -0.00723063f, -0.00588535f, 
    0.01698650f, -0.02400110f, 0.01378422f, 0.01742427f, 0.02269252f, -0.01793208f, 0.01073820f, -0.01859794f, 
    -0.00473986f, -0.04297056f, -0.00084159f, -0.03451123f, 0.03458168f, 0.01181233f, -0.01466342f, 0.04249749f, 
    -0.00814637f, 0.02822541f, 0.04362453f, 0.00104853f, 0.02407604f, -0.05194893f, 0.03382224f, 0.03167748f, 
    -0.04962342f, -0.03178357f, 0.03435474f, -0.00268987f, -0.03386948f, -0.03917270f, 0.01260287f, 0.02039456f, 
    -0.00744706f, 0.04267067f, 0.02688314f, -0.03873141f, 0.03276842f, -0.04073871f, -0.03261727f, -0.03301287f, 
    0.01006414f, -0.02224436f, -0.05811743f, 0.03959990f, -0.03132524f, -0.04433661f, 0.02392766f, 0.02551792f, 
    -0.01785368f, -0.00304454f, 0.01620050f, 0.02833381f, -0.00741030f, 0.01004085f, 0.04192349f, -0.04692147f, 
    0.01758993f, 0.00853960f, -0.03674614f, -0.04286544f, 0.02676124f, 0.02824230f, -0.01603924f, 0.02154446f, 
    -0.01028903f, -0.01726908f, -0.00197399f, -0.03870224f, -0.04623873f, -0.05087052f, -0.00319559f, -0.00427863f, 
    -0.03771941f, 0.03066028f, 0.03329923f, 0.01047350f, -0.02947241f, 0.01173594f, 0.01314608f, 0.03682392f, 
    -0.03672111f, 0.00219989f, -0.01405066f, 0.00914042f, 0.01586529f, 0.02125742f, -0.03922015f, -0.04209611f, 
    0.02100327f, -0.04981421f, -0.03295955f, -0.05340613f, 0.02966635f, -0.05179274f, 0.00728036f, -0.05250447f, 
    -0.02349958f, -0.06155665f, -0.00650408f, -0.01025426f, 0.00884108f, -0.04078378f, 0.01527328f, 0.03213689f, 
    -0.01055487f, -0.01191253f, -0.00327701f, -0.05518712f, -0.01642278f, 0.02432569f, 0.00100709f, 0.00666303f, 
    -0.02823734f, 0.03482056f, -0.02922228f, -0.04883519f, -0.01861106f, -0.04197063f, -0.02015386f, -0.02634891f, 
    -0.00855741f, -0.01050356f, -0.01892583f, -0.04739241f, -0.04007150f, -0.05262294f, -0.02594967f, -0.03503368f, 
    -0.00210711f, -0.04409553f, -0.01677838f, 0.02105877f, -0.05031463f, 0.00713580f, 0.01466069f, 0.02631185f, 
    0.04302286f, 0.01347336f, -0.02111207f, 0.02456641f, -0.01429687f, -0.01446848f, 0.02026271f, -0.03523825f, 
    -0.01264321f, -0.00598587f, -0.00556054f, -0.02873521f, 0.02503125f, 0.04362119f, -0.02707975f, -0.00374402f, 
    0.00626590f, 0.04643933f, 0.03209725f, -0.00964387f, 0.04031941f, 0.00611717f, -0.04994000f, -0.00045761f, 
    -0.04034918f, 0.02450708f, -0.01231068f, -0.05325024f, -0.04995204f, -0.02789858f, -0.05324933f, -0.04553762f, 
    0.04320614f, -0.02507290f, 0.03064460f, -0.02190976f, -0.04094492f, -0.01534261f, 0.03232469f, 0.05540930f, 
    0.00017769f, 0.02042706f, 0.02600899f, -0.02110907f, 0.00368067f, -0.00293506f, 0.02771233f, 0.03515229f, 
    -0.02081080f, -0.03684778f, -0.00661658f, 0.00438512f, -0.00930506f, -0.02290397f, 0.01765441f, 0.02999581f, 
    -0.00461929f, 0.00109008f, -0.01919446f, -0.01267303f, -0.01365586f, 0.02078664f, 0.01672118f, 0.02387965f, 
    -0.05677096f, 0.01268616f, -0.03804231f, 0.00819883f, 0.03208053f, 0.03800679f, 0.02139218f, 0.01349051f, 
    -0.02432564f, 0.01310205f, -0.00445767f, -0.00298575f, -0.02970593f, -0.05177083f, 0.02820694f, 0.02320137f, 
    -0.04477835f, -0.02233959f, -0.05565635f, -0.01159231f, 0.03352122f, -0.03077226f, -0.05049425f, 0.03666390f, 
    0.02220471f, -0.05930300f, -0.03510205f, -0.04685345f, 0.02930579f, 0.03699147f, 0.02052156f, -0.03231235f, 
    0.01390459f, -0.01137286f, -0.04027238f, 0.03613733f, 0.02776415f, -0.03594435f, -0.02684183f, 0.00371374f, 
    0.01712542f, 0.03822040f, 0.00319293f, -0.02227382f, 0.02463260f, -0.05700704f, -0.00513388f, -0.02989235f, 
    -0.01013878f, -0.04544170f, 0.01754935f, 0.02843509f, -0.05810291f, -0.04516643f, -0.02139680f, -0.05333173f, 
    0.01593702f, -0.03094571f, 0.02227083f, 0.01869996f, -0.02938817f, 0.01376845f, -0.04256096f, -0.00207436f, 
    0.03806620f, -0.02059040f, -0.00991696f, 0.00321550f, 0.02505214f, 0.01707702f, -0.02296979f, 0.02292421f, 
    -0.01250893f, -0.00001254f, -0.00240084f, 0.00153923f, 0.01700633f, 0.02387698f, -0.03392015f, 0.00887576f, 
    0.00026232f, -0.02707239f, -0.03688955f, -0.05578487f, -0.01067614f, 0.03566277f, 0.02572890f, -0.04288139f, 
    0.02868122f, 0.02745751f, 0.01550829f, 0.00606169f, -0.00094697f, 0.00595047f, 0.00604124f, -0.02236417f, 
    -0.02174693f, -0.04841712f, -0.01753640f, 0.01645616f, -0.00785645f, 0.02530334f, -0.02869095f, 0.01259599f, 
    -0.03246874f, 0.01886470f, 0.02629509f, -0.04302139f, -0.00407693f, -0.01373776f, -0.05478647f, 0.00008197f, 
    -0.03816678f, -0.00824291f, 0.00241683f, 0.03977285f, -0.01003093f, -0.04589070f, -0.03620301f, -0.02455859f, 
    -0.05136186f, 0.03367040f, -0.02232020f, 0.03679788f, -0.02208516f, -0.01616195f, -0.01737240f, -0.03973693f, 
    0.02054924f, 0.01076414f, -0.03144217f, -0.05183156f, 0.01855946f, 0.03289826f, 0.02369318f, -0.00621590f, 
    0.02499513f, -0.02515969f, 0.01746028f, 0.01153540f, -0.00199850f, -0.04152451f, -0.02435725f, 0.02552689f, 
    -0.03848406f, -0.04443421f, 0.00929019f, -0.01439702f, -0.01349805f, -0.02086741f, 0.00748456f, -0.03656205f, 
    -0.08973700f, -0.21816994f, 0.14724100f, 0.06532762f, 0.15715322f, -0.01516347f, -0.08263418f, 0.08035854f, 
    0.05381669f, 0.02300540f, 0.01251217f, 0.16446106f, -0.02324785f, -0.13483305f, -0.13242301f, -0.03954643f, 
    0.05021473f, 0.03902187f, 0.01428428f, -0.01587537f, 0.02116599f, 0.02566112f, 0.04972416f, -0.05659278f, 
    -0.09311415f, 0.20219414f, -0.24292073f, -0.19085799f, -0.00277193f, 0.11861000f, -0.04960407f, -0.03695140f, 
    -0.01928881f, 0.02303086f, 0.01666735f, -0.01227685f, 0.17546292f, -0.20347810f, 0.19967921f, -0.08198547f, 
    0.03078799f, -0.00694496f, 0.11454741f, 0.01777679f, 0.02807148f, 0.15712722f, 0.03676910f, 0.09410520f, 
    -0.22240132f, -0.03436320f, -0.17846778f, -0.00825531f, 0.10932299f, 0.01818466f, -0.00209172f, 0.04957055f, 
    -0.08543082f, -0.08181624f, 0.01635436f, 0.03068990f, -0.04415054f, 0.19549707f, 0.22837405f, 0.13572471f, 
    -0.01717841f, -0.17993489f, 0.08464491f, 0.00496192f, 0.10263430f, 0.07276587f, -0.10977687f, -0.05002947f, 
    -0.35943449f, -0.17753211f, 0.03333331f, -0.23609932f, -0.03421760f, 0.03586847f, -0.04182519f, -0.09639210f, 
    0.04975022f, -0.09271158f, -0.03551763f, 0.02248262f, 0.15132199f, -0.10292412f, 0.16227965f, -0.02679789f, 
    -0.16813131f, 0.00220101f, -0.02475703f, 0.11858050f, 0.04026617f, 0.13236676f, 0.04336293f, -0.01610387f, 
    0.44924295f, 0.20334557f, -0.03642654f, 0.35814443f, 0.01795617f, 0.09850998f, -0.01295615f, 0.05027390f, 
    0.03033426f, 0.03576477f, 0.03487732f, 0.00996806f, -0.07771168f, -0.14215636f, 0.01963692f, 0.17652921f, 
    0.08610380f, -0.02349026f, -0.01264931f, -0.06438228f, 0.03226427f, -0.05571045f, -0.01713673f, 0.07495016f, 
    -0.03487597f, 0.37975669f, 0.02022676f, -0.05049016f, -0.06217231f, -0.01033041f, 0.05121696f, 0.07403377f, 
    0.04812000f, 0.14018361f, 0.02823489f, 0.04703926f, -0.08341125f, -0.01887555f, 0.00587339f, -0.20609115f, 
    0.00800405f, -0.05914754f, -0.01968646f, 0.01214560f, -0.06979156f, -0.02538769f, -0.01521152f, 0.05282088f, 
    0.20101440f, -0.03106884f, -0.15567280f, 0.05434918f, 0.13793105f, 0.01101156f, 0.02828031f, 0.10256565f, 
    0.11420216f, 0.02051865f, -0.02238194f, 0.07381967f, 0.18164691f, 0.00816223f, 0.15662502f, 0.05316238f, 
    0.05147642f, -0.03914172f, 0.00726171f, 0.05327772f, -0.00390444f, 0.06166703f, 0.10649889f, -0.06172718f, 
    0.18595630f, 0.17118461f, -0.11136778f, 0.17527930f, 0.04135174f, -0.10930227f, -0.09092095f, 0.08242975f, 
    0.02690155f, 0.09339310f, -0.03484699f, 0.01582709f, -0.21818487f, -0.14841665f, -0.18275541f, -0.03487204f, 
    0.15627442f, 0.09325477f, -0.00750092f, 0.19005756f, -0.06767200f, -0.01524547f, -0.07702918f, -0.07895617f, 
    0.14123605f, 0.20977534f, -0.03347055f, -0.29179564f, -0.07523581f, -0.00486279f, 0.08848453f, -0.09565867f, 
    -0.02699193f, 0.00518459f, 0.06965257f, -0.00432169f, -0.23089403f, -0.17346765f, -0.10397181f, -0.08792974f, 
    0.11375451f, -0.04420993f, 0.04515379f, 0.09752469f, 0.00756264f, 0.01008987f, -0.00135867f, -0.14077097f, 
    -0.07846995f, -0.03356740f, 0.21374787f, -0.11252575f, -0.00335572f, 0.13382775f, 0.08358801f, 0.07692410f, 
    -0.06972630f, 0.06089881f, 0.10058436f, 0.02762798f, -0.36972761f, -0.28531164f, -0.14837477f, 0.04194148f, 
    -0.02427282f, 0.02377541f, 0.08556144f, 0.01171375f, 0.05219896f, 0.02844300f, -0.06354117f, -0.04414832f, 
    0.12929934f, -0.09232595f, -0.10876160f, 0.08803119f, 0.09589182f, 0.12501436f, -0.01592251f, -0.02805712f, 
    0.03261199f, 0.10129017f, -0.01517203f, -0.04621106f, 0.23976669f, 0.25539351f, 0.05775493f, 0.09936546f, 
    0.08964726f, -0.02829242f, 0.01573203f, -0.03435940f, 0.10197683f, 0.07619156f, 0.01748044f, 0.05179859f, 
    0.21983238f, 0.29327589f, 0.12760760f, 0.08335286f, 0.04253968f, 0.08303948f, -0.08704924f, -0.10781138f, 
    -0.12946925f, 0.06560455f, 0.06323539f, -0.00352538f, -0.20885102f, -0.01570807f, -0.07008530f, 0.14037865f, 
    0.02287438f, 0.01959292f, 0.03579257f, 0.04475905f, 0.05568188f, 0.12911837f, 0.11979918f, 0.01516871f, 
    -0.31667140f, -0.17592148f, -0.01421314f, -0.27000797f, -0.05743258f, 0.06778997f, 0.06323706f, -0.05074096f, 
    0.08623654f, 0.06614915f, 0.00046608f, 0.04853109f, -0.14795399f, -0.06086394f, 0.23971868f, -0.09072684f, 
    0.08307230f, -0.08206134f, 0.09134801f, 0.11168506f, -0.04308350f, -0.02041017f, 0.08302426f, 0.02972121f, 
    0.17707184f, 0.18906710f, 0.14548044f, 0.07690084f, 0.01198907f, 0.10687412f, 0.08445935f, -0.10356780f, 
    -0.01823376f, 0.02829599f, 0.05361121f, 0.01220447f, -0.02175976f, 0.15595300f, 0.28499484f, -0.07327335f, 
    -0.23721586f, -0.05647541f, -0.10480276f, -0.07994211f, 0.12201986f, 0.07472049f, 0.00500580f, 0.08303106f, 
    0.04615644f, 0.13804209f, -0.21035905f, 0.19885702f, 0.00671983f, 0.02457272f, -0.10811041f, -0.03316300f, 
    0.02367151f, 0.01949998f, 0.01246006f, 0.09567935f, -0.04638134f, -0.05640298f, -0.10147488f, 0.02513144f, 
    0.13385132f, 0.08287740f, -0.00142454f, 0.04859755f, 0.16780415f, -0.08412174f, -0.09405405f, -0.07037345f, 
    0.25808153f, -0.00934112f, -0.01724719f, 0.11397394f, 0.01481592f, 0.08789434f, -0.04938342f, 0.06064023f, 
    0.12287661f, 0.04179702f, 0.05102971f, 0.08749823f, -0.09405512f, -0.34700218f, -0.04161571f, -0.06981751f, 
    0.07184449f, 0.09822755f, 0.04624430f, 0.09586908f, 0.00774226f, -0.02633130f, -0.11929104f, -0.01832899f, 
    -0.08242092f, -0.09888828f, 0.02438436f, 0.06829342f, 0.01379518f, -0.02229650f, -0.05790700f, -0.00090431f, 
    0.01458172f, -0.03316114f, -0.00261323f, -0.04314024f, 0.24237259f, -0.13040458f, -0.17324978f, -0.04089466f, 
    -0.00625301f, -0.10713622f, -0.06372026f, -0.09026921f, -0.08791338f, 0.05010309f, 0.02626729f, -0.12516043f, 
    0.37489101f, 0.09415840f, -0.23554726f, -0.06893943f, -0.00546877f, 0.00175893f, -0.05098244f, 0.03754070f, 
    0.00910886f, 0.09487715f, -0.05537468f, 0.05839398f, -0.43088806f, -0.10467662f, 0.03323752f, 0.03809307f, 
    0.02832144f, 0.00451221f, 0.04525486f, 0.02763886f, -0.07265496f, 0.03567328f, 0.07790240f, -0.02686612f, 
    0.16379945f, -0.18372434f, -0.03629804f, -0.02440199f, 0.12491656f, 0.03194928f, -0.03896924f, -0.02419811f, 
    -0.04793166f, -0.12252914f, 0.12566522f, 0.03572039f, -0.22269589f, 0.05170846f, 0.14324145f, -0.03208741f, 
    -0.06590857f, -0.06390001f, 0.06783804f, 0.06188457f, 0.00346868f, 0.00281306f, -0.04754803f, 0.10668256f, 
    -0.28137031f, 0.01029323f, -0.05684368f, -0.11789066f, -0.07710088f, 0.01899813f, 0.04209218f, -0.13529676f, 
    0.01863792f, -0.01555528f, 0.05791668f, 0.01967417f, 0.04784733f, -0.01959934f, 0.14782085f, -0.01440863f, 
    -0.05724645f, -0.09892122f, -0.13194570f, 0.06775958f, -0.11091050f, 0.03520882f, 0.13377506f, 0.04780214f, 
    0.22497007f, 0.18817519f, 0.21035726f, 0.04381908f, 0.06558237f, 0.06150162f, 0.07290474f, -0.04794841f, 
    -0.04212363f, 0.08746853f, 0.00916890f, 0.00898208f, -0.15814301f, -0.15958141f, -0.16904628f, -0.17036106f, 
    0.06114832f, 0.02913457f, -0.02431475f, 0.02055140f, 0.01432206f, -0.01236404f, -0.07073101f, 0.05565139f, 
    0.11603075f, 0.11366724f, 0.23375028f, -0.04587117f, 0.11763383f, 0.05058574f, -0.02800697f, 0.04419737f, 
    0.07882522f, 0.04802416f, -0.03159109f, -0.00813486f, 0.09587424f, -0.18218018f, 0.08251691f, 0.15153839f, 
    0.02011636f, 0.06912665f, 0.12042908f, 0.04509100f, 0.05499568f, 0.02221285f, 0.00499831f, -0.08560244f, 
    0.14067028f, -0.04766073f, -0.18010493f, -0.11809540f, 0.06305851f, 0.01478633f, -0.11524189f, -0.02230011f, 
    -0.01770505f, 0.01167934f, 0.05628730f, -0.10343173f, 0.04742403f, 0.28095829f, 0.21456060f, -0.01281241f, 
    0.17263602f, -0.08240470f, 0.00503053f, -0.00179674f, -0.06445950f, -0.08203749f, 0.02798213f, -0.02107692f, 
    -0.02785452f, 0.22932422f, 0.04682728f, -0.22317146f, 0.06229057f, -0.05148403f, -0.04007414f, -0.04152817f, 
    -0.04628232f, 0.15645042f, -0.03927705f, 0.17050590f, -0.28194806f, -0.06378847f, -0.25491685f, -0.04350907f, 
    0.04801106f, 0.05089627f, 0.00428675f, 0.00292521f, -0.10392616f, -0.04336809f, 0.03598232f, 0.06506406f, 
    -0.00240627f, -0.07578205f, -0.08597967f, -0.11185470f, 0.08257443f, 0.12128825f, -0.07217769f, -0.04868151f, 
    0.14044650f, -0.15410286f, 0.00981226f, 0.12872685f, -0.08144645f, -0.19384487f, -0.20287196f, -0.01963591f, 
    0.12416758f, -0.05484097f, 0.09984943f, 0.15564507f, -0.09718621f, -0.05688284f, 0.12936606f, -0.07657911f, 
    -0.14431199f, -0.00440032f, 0.11172946f, 0.17196326f, 0.07175710f, -0.08406201f, -0.02729141f, 0.11831204f, 
    0.02641340f, -0.10016771f, 0.07600015f, 0.00747612f, -0.09920211f, -0.19515322f, -0.04064887f, -0.17422080f, 
    -0.02935959f, 0.00609351f, 0.02517012f, 0.04239219f, 0.03659276f, -0.05417478f, 0.14920264f, -0.02091878f, 
    -0.23014139f, -0.10547222f, -0.10608900f, 0.03189066f, 0.02196945f, -0.01659162f, 0.07566497f, 0.02411557f, 
    -0.01427825f, 0.02892455f, -0.02300024f, -0.08060615f, -0.07347887f, 0.24682562f, 0.20862174f, 0.09985925f, 
    0.07870834f, 0.13529684f, 0.06703649f, -0.07725253f, 0.03578362f, -0.01365975f, 0.03595680f, 0.13663240f, 
    0.13135940f, 0.20105495f, 0.21415214f, -0.02585051f, 0.10646135f, 0.17319506f, -0.03402937f, -0.05464116f, 
    -0.01055647f, 0.00769920f, 0.14087872f, 0.09332649f, 0.09014665f, -0.25853106f, -0.09790862f, -0.15680520f, 
    0.06490125f, -0.02145264f, 0.00923274f, 0.12039892f, 0.08108442f, -0.00165222f, 0.03743004f, -0.06911754f, 
    -0.31947127f, -0.08069185f, -0.06832174f, -0.12037607f, 0.01212618f, 0.10769303f, -0.05548988f, 0.04952455f, 
    0.02552044f, 0.12254952f, 0.04516077f, -0.13816375f, -0.21255854f, -0.01699352f, 0.17148809f, 0.20674397f, 
    -0.05922708f, 0.06000524f, 0.10274544f, 0.12635648f, 0.07593885f, -0.05012687f, 0.05670182f, -0.02825385f, 
    -0.05674488f, 0.19959576f, 0.13873644f, -0.03419500f, 0.15639175f, 0.16426811f, -0.03368866f, 0.02547006f, 
    0.03111503f, 0.02345222f, 0.05308092f, 0.02504985f, -0.15373448f, 0.01076155f, 0.02644645f, 0.09369129f, 
    0.02685810f, -0.04687468f, 0.02042019f, -0.05041119f, -0.02378432f, 0.07786527f, 0.01356605f, 0.12840162f, 
    0.14546174f, 0.08414663f, 0.21730752f, 0.02704045f, -0.06904644f, 0.08104838f, -0.04183478f, 0.00487310f, 
    -0.15483715f, 0.04864958f, 0.02627942f, -0.00444078f, -0.05185381f, -0.15110330f, -0.19336754f, -0.03905761f, 
    0.10079958f, 0.10653909f, 0.03173026f, 0.04778990f, 0.10639574f, 0.06134520f, -0.02545660f, 0.05211163f, 
    0.20841846f, 0.16728574f, 0.02936197f, -0.05688632f, -0.01606538f, -0.07065668f, 0.02969581f, -0.00822634f, 
    0.00030306f, -0.05632033f, -0.01787571f, 0.07432685f, -0.28275761f, -0.20980147f, -0.17247151f, -0.09263739f, 
    0.06955664f, 0.12917672f, 0.02533769f, 0.04882216f, -0.00655279f, 0.09466688f, -0.00278014f, 0.07166410f, 
    0.14164591f, 0.06540652f, -0.02259781f, 0.04965355f, -0.00706787f, -0.04227410f, -0.08689760f, 0.01059322f, 
    0.09010813f, -0.04493165f, -0.06264076f, -0.24126711f, 0.28167471f, -0.17367736f, -0.11214487f, -0.10219681f, 
    0.02919546f, -0.05627595f, -0.06336161f, -0.05916636f, -0.00783606f, 0.06374645f, 0.00020405f, 0.20735298f, 
    0.06695788f, -0.11934815f, -0.15473382f, -0.04671935f, 0.11364515f, 0.02844919f, -0.02842750f, -0.04297959f, 
    -0.01078321f, 0.07462409f, -0.03224266f, -0.11319493f, -0.24332809f, 0.06027812f, -0.06472088f, -0.13928285f, 
    0.03617176f, -0.09512708f, 0.02758660f, -0.04216478f, 0.12234537f, 0.04190362f, 0.10463638f, -0.09598777f, 
    0.39677060f, -0.18496828f, 0.06834191f, 0.10848577f, 0.04153528f, 0.04354442f, 0.03209504f, -0.02586345f, 
    -0.02623514f, 0.00102231f, -0.02428046f, 0.03926749f, -0.18593940f, -0.14893855f, -0.02549605f, -0.10654576f, 
    -0.00671347f, 0.14171189f, 0.11027005f, -0.04041440f, 0.06697012f, -0.12142389f, 0.08170165f, 0.10635317f, 
    -0.14689514f, 0.06343727f, 0.16590565f, 0.13623433f, 0.02404262f, -0.03887859f, 0.08026268f, -0.00216659f, 
    0.01126535f, 0.00270114f, 0.04142741f, -0.11598857f, -0.13611895f, -0.04061936f, 0.05255580f, 0.00301907f, 
    0.16598994f, -0.06659164f, 0.04824677f, 0.02404007f, -0.06165513f, -0.14406516f, 0.11349409f, -0.06177066f, 
    0.02847401f, -0.08929630f, -0.07395904f, -0.01902851f, 0.16039500f, 0.07167865f, 0.04443684f, -0.05337923f, 
    0.01086550f, -0.01226270f, -0.02442081f, 0.11298212f, -0.07811482f, -0.07583483f, 0.03903237f, 0.03414117f, 
    0.04979886f, 0.00100819f, -0.00548523f, 0.02682577f, -0.01659980f, -0.00214260f, 0.04885063f, -0.02200598f, 
    -0.12048101f, -0.02202006f, 0.05643284f, 0.01078445f, 0.06655788f, 0.10100465f, -0.11756168f, 0.07552274f, 
    -0.06707544f, 0.10827177f, 0.09901427f, 0.04708625f, 0.28318593f, -0.10297564f, 0.09472710f, -0.07758370f, 
    -0.04152631f, -0.06935462f, -0.00610395f, 0.03475793f, -0.03444636f, -0.09478302f, -0.08625802f, 0.11872739f, 
    0.29547966f, 0.09976202f, -0.06332944f, 0.11055567f, -0.05478422f, -0.07151575f, -0.08742508f, -0.10853247f, 
    -0.08113715f, -0.08427135f, 0.07777349f, -0.04173499f, -0.12724945f, 0.01344484f, 0.03776744f, 0.02911247f, 
    0.23828928f, -0.06217382f, 0.00712606f, -0.11048946f, -0.08743855f, -0.01674787f, 0.07080644f, 0.04455747f, 
    -0.32199562f, -0.24426357f, -0.02483376f, -0.05049124f, -0.01056735f, -0.10779121f, -0.05303035f, 0.00870041f, 
    0.01230377f, 0.11763588f, 0.07369168f, 0.10696934f, 0.20740066f, -0.07215033f, -0.03250523f, 0.18185024f, 
    -0.13652675f, -0.16403124f, -0.07734890f, 0.06961022f, -0.00807153f, 0.13903742f, -0.07430700f, 0.05715930f, 
    0.05321896f, 0.02642817f, 0.06528481f, 0.03823127f, 0.02291916f, -0.02216747f, 0.03651270f, 0.12641639f, 
    0.17193398f, -0.02594356f, 0.05348198f, 0.12204676f, 0.36144415f, 0.02122948f, 0.17223810f, 0.17731784f, 
    -0.06257574f, -0.02587600f, 0.09598526f, 0.05370038f, 0.06230066f, -0.07431108f, 0.11504033f, -0.04816683f, 
    0.26371056f, 0.10682132f, 0.05468814f, -0.05228639f, -0.03873885f, -0.13780786f, 0.10012595f, 0.14122844f, 
    0.01262552f, -0.07895298f, 0.00472581f, 0.00580460f, 0.38873127f, -0.18729471f, 0.10441790f, 0.04407179f, 
    -0.09596859f, 0.03786813f, -0.09779954f, 0.04866750f, -0.04959859f, -0.05730112f, 0.17734565f, -0.00752150f, 
    0.06959848f, -0.04149315f, 0.00390038f, -0.01342943f, -0.06282277f, -0.06770069f, -0.02672146f, 0.06973914f, 
    0.16723427f, -0.07087772f, 0.11932992f, -0.04021620f, -0.08858386f, 0.12070479f, -0.04721414f, 0.04379931f, 
    0.01668483f, 0.04760455f, 0.00460953f, -0.03133017f, -0.06678648f, 0.12064294f, 0.14025530f, 0.11522937f, 
    -0.01831425f, -0.30697185f, -0.09955712f, -0.01258481f, 0.01629536f, 0.08045766f, -0.02004049f, -0.12344462f, 
    0.13219664f, -0.04210412f, -0.00596737f, -0.07309268f, 0.27445540f, -0.29309064f, -0.08862093f, 0.06058483f, 
    -0.07367546f, 0.01407573f, -0.08202726f, 0.09835367f, 0.07196665f, 0.03817425f, -0.07865475f, 0.03452877f, 
    0.00322149f, 0.24806191f, 0.06649014f, -0.16035788f, 0.04766631f, -0.05704661f, -0.02405459f, 0.07845688f, 
    0.06852937f, 0.16248254f, 0.09969608f, -0.05131369f, -0.06376725f, -0.07769057f, 0.34833917f, -0.16811843f, 
    0.06410907f, 0.01740931f, 0.02572760f, 0.15385535f, 0.08050445f, -0.10535494f, 0.00685406f, -0.02387841f, 
    -0.06232975f, 0.13588209f, -0.08078429f, 0.05804777f, 0.06968511f, 0.01025218f, 0.06218687f, -0.05179176f, 
    0.06765409f, 0.14031109f, 0.14305469f, 0.07232662f, -0.10372228f, -0.16724436f, -0.05936013f, -0.16995698f, 
    0.16562867f, 0.10560073f, 0.05449488f, -0.00770764f, -0.03765400f, 0.15454341f, -0.08486246f, 0.08060370f, 
    -0.02103927f, -0.00432735f, -0.10352142f, 0.15648735f, -0.01700500f, 0.01818098f, -0.06045435f, 0.02299879f, 
    -0.08724099f, -0.06484944f, 0.09741347f, -0.13752438f, 0.17241283f, 0.03498758f, -0.07026782f, -0.03024695f, 
    -0.06171542f, 0.06103356f, 0.01083610f, 0.02242805f, -0.11908766f, 0.00801488f, 0.02584060f, 0.08196464f, 
    0.27495241f, 0.11059254f, -0.04103742f, -0.03569038f, -0.04803951f, -0.07991429f, -0.00527108f, -0.08186908f, 
    0.00149472f, -0.16597508f, -0.00249150f, 0.23550919f, -0.15816957f, 0.02386547f, 0.09826043f, -0.04769189f, 
    0.01167411f, 0.06742682f, -0.05272108f, -0.02278968f, -0.06138442f, 0.06232507f, -0.03832162f, 0.05307189f, 
    0.05350664f, -0.02471037f, 0.10321648f, -0.04176591f, -0.10113424f, -0.06002528f, -0.00444878f, 0.00008936f, 
    -0.01441651f, 0.11919792f, 0.10909526f, 0.13857828f, -0.00250607f, 0.11054882f, -0.00543439f, -0.21487865f, 
    0.17869192f, 0.19925268f, -0.10590515f, -0.04051168f, 0.02797335f, -0.05505930f, 0.08498699f, -0.07220452f, 
    -0.02812514f, -0.28322953f, -0.09039836f, 0.08124270f, 0.03089341f, -0.01625442f, -0.00521140f, 0.08266274f, 
    0.07488173f, 0.06349485f, 0.09565756f, 0.01953430f, 0.34627366f, 0.03468918f, 0.01904941f, -0.08078650f, 
    -0.08417872f, 0.13694884f, 0.07847378f, 0.05777951f, -0.03604027f, 0.03640059f, 0.00997684f, 0.04680872f, 
    0.40968367f, -0.02854328f, 0.15268695f, 0.18592520f, -0.06030581f, 0.03384300f, 0.05685944f, -0.08128192f, 
    -0.00291416f, 0.03145128f, 0.02939494f, 0.07477592f, -0.02825238f, 0.06172835f, -0.00823133f, -0.08866987f, 
    0.19020188f, 0.14297885f, -0.02751085f, 0.03885622f, -0.06405351f, 0.15762772f, 0.00314271f, -0.00407521f, 
    0.02197484f, -0.09050281f, -0.02255517f, -0.11357300f, -0.01227904f, -0.05668229f, -0.10087061f, -0.01894945f, 
    0.02814787f, 0.01785007f, -0.01208524f, -0.03748639f, 0.04103151f, 0.14070739f, 0.03252040f, 0.11534200f, 
    -0.01836014f, -0.00946261f, 0.02126787f, -0.05709237f, 0.08824170f, 0.07671990f, -0.04386897f, 0.05202854f, 
    -0.14074020f, -0.04211170f, -0.05768074f, -0.01264856f, 0.04263802f, -0.05143993f, -0.02339778f, -0.07015690f, 
    -0.00187531f, -0.02892430f, -0.00762461f, 0.06889680f, -0.19365294f, -0.01273168f, 0.04873366f, -0.07043692f, 
    -0.18972024f, -0.08563666f, -0.07827522f, -0.09775744f, 0.02388791f, -0.02947654f, -0.01362687f, 0.07780430f, 
    0.21676382f, -0.02078556f, -0.11313750f, 0.15577111f, 0.08934017f, 0.00299056f, 0.08592794f, 0.09219370f, 
    -0.05430280f, -0.06089417f, -0.03415469f, -0.06409390f, 0.12053711f, 0.07252126f, 0.09172964f, 0.14627630f, 
    0.10619399f, -0.09425292f, -0.03929226f, 0.12805612f, 0.01163840f, 0.03579849f, 0.14556448f, -0.00715007f, 
    0.42394602f, -0.47928417f, 0.19514219f, 0.12260938f, 0.02854274f, 0.02366701f, 0.07556851f, 0.19504793f, 
    0.13430946f, -0.00838647f, 0.03244602f, 0.06065918f, -0.23329385f, 0.07185373f, 0.05695085f, 0.13476743f, 
    -0.01158685f, 0.09279900f, -0.03524947f, -0.05775508f, -0.02498459f, -0.00659501f, -0.02118566f, -0.04298022f, 
    -0.23024708f, -0.18273421f, 0.10472555f, -0.04066065f, 0.04495959f, 0.11213809f, -0.04206066f, 0.08511437f, 
    -0.01557688f, -0.07204234f, -0.02301520f, -0.09153707f, 0.40635389f, -0.02724597f, 0.12313300f, -0.05818626f, 
    -0.14431089f, -0.11538500f, 0.00224961f, -0.17872724f, 0.11287423f, -0.07575142f, -0.01372770f, 0.05164352f, 
    0.14053421f, -0.10111791f, -0.12514265f, -0.08036465f, 0.14334783f, 0.02215734f, 0.09261469f, 0.00220467f, 
    -0.07786428f, 0.23511659f, 0.02773413f, -0.02606685f, 0.13601583f, 0.04511537f, 0.06015845f, -0.25566906f, 
    -0.10378829f, 0.00496326f, -0.04243026f, -0.06307156f, -0.04002196f, 0.04056630f, -0.06595389f, 0.07245979f, 
    0.07631607f, 0.03033674f, 0.00778577f, 0.01277884f, -0.02981869f, -0.00025197f, -0.01586996f, 0.06960534f, 
    -0.08128791f, -0.06124435f, 0.00967276f, -0.13894935f, 0.29090494f, -0.03280080f, -0.02758697f, -0.12732247f, 
    -0.11648951f, -0.01292802f, 0.11349358f, -0.03366647f, -0.00126463f, 0.12960647f, 0.05023800f, 0.02643505f, 
    0.37485224f, -0.15197092f, 0.03044382f, 0.11472924f, -0.02229753f, -0.06205972f, -0.15707557f, 0.05130473f, 
    -0.00693028f, -0.02483842f, -0.13643183f, 0.06713262f, 0.06052432f, -0.03219404f, 0.00932374f, -0.07689419f, 
    0.04741437f, 0.02023313f, -0.05086314f, 0.08522985f, -0.06098697f, -0.00687612f, -0.07913925f, -0.03361553f, 
    -0.02035034f, -0.10983096f, 0.00772966f, -0.01570512f, 0.02834656f, 0.06673791f, 0.03049239f, 0.06292250f, 
    0.04544708f, -0.00376462f, 0.14729203f, 0.09876838f, 0.38338202f, -0.04910473f, 0.00369418f, 0.06254768f, 
    0.05249594f, -0.00904274f, -0.01026719f, -0.02507113f, 0.03498491f, 0.06755367f, 0.21804114f, 0.10169296f, 
    0.28979039f, 0.12897044f, -0.07094494f, -0.20371230f, 0.06594495f, 0.01071685f, -0.03957316f, 0.09403913f, 
    0.06799460f, 0.07815292f, -0.00896635f, -0.05853295f, -0.30695820f, 0.00001020f, 0.04145829f, 0.02600835f, 
    -0.05714935f, 0.03091644f, 0.10106356f, 0.05630889f, 0.06233522f, 0.14539346f, -0.02120757f, 0.10780912f, 
    -0.12809789f, -0.02669435f, -0.05724093f, 0.03942689f, 0.01993871f, 0.01979436f, 0.05242200f, 0.05733302f, 
    0.00137712f, -0.07596543f, -0.02301200f, -0.07789626f, 0.06556607f, 0.11598114f, -0.11639676f, -0.40646926f, 
    0.20987496f, 0.13367195f, 0.01318919f, -0.00932588f, 0.07313607f, -0.00791092f, 0.02990248f, -0.10733293f, 
    0.06737734f, -0.02080874f, 0.07043111f, 0.04797798f, -0.01515256f, -0.07980888f, 0.04050241f, 0.01526220f, 
    0.18811366f, 0.11815340f, -0.10217285f, 0.02365363f, 0.14300609f, -0.06588437f, -0.00765794f, -0.15217690f, 
    -0.16683854f, -0.02214138f, 0.11246258f, -0.06637779f, -0.04741110f, -0.04514435f, -0.01122953f, -0.03886732f, 
    -0.01651450f, 0.01084720f, -0.02283313f, 0.11384858f, -0.09085409f, -0.10499110f, -0.03944422f, 0.03080089f, 
    0.01426226f, -0.07321545f, 0.18089789f, 0.06468765f, -0.14764713f, -0.07701936f, -0.04115723f, -0.21268228f, 
    -0.10095542f, -0.01984479f, -0.01196354f, -0.05790348f, -0.04383694f, -0.05865312f, -0.02536894f, -0.02995037f, 
    -0.01386541f, 0.01458994f, -0.04303902f, 0.00953862f, 0.00795351f, 0.02024646f, -0.00010240f, -0.04168157f, 
    0.03344205f, -0.05354906f, 0.04680444f, 0.01161204f, -0.01211768f, -0.04226599f, -0.04349678f, -0.01702064f, 
    0.02281129f, -0.00955572f, 0.03436895f, 0.03276079f, 0.03191279f, -0.00558447f, -0.02896713f, -0.03525674f, 
    -0.04929623f, -0.03346439f, 0.01949431f, 0.04356760f, 0.00713663f, 0.03231157f, 0.02079689f, 0.00747317f, 
    -0.01762847f, -0.02109349f, 0.03123116f, -0.03899951f, 0.04284804f, -0.02578750f, -0.04385447f, -0.00829017f, 
    0.01879710f, -0.01886950f, -0.03812138f, 0.03020050f, 0.01017942f, -0.04490915f, -0.01484020f, 0.02021851f, 
    0.04068376f, 0.02104658f, -0.03091937f, -0.04504403f, -0.04478058f, -0.02945361f, -0.02583444f, 0.02678005f, 
    -0.02328625f, -0.02643778f, 0.03152031f, 0.03918369f, -0.03212717f, -0.04334426f, 0.01097515f, -0.05277853f, 
    0.02182632f, 0.01172993f, -0.02463574f, 0.02805179f, -0.05453351f, -0.04373643f, 0.01210828f, 0.01126055f, 
    -0.04101055f, -0.04504649f, -0.03107277f, 0.02182302f, 0.02696889f, -0.04464787f, -0.00829630f, 0.02820262f, 
    -0.04171113f, -0.05343941f, -0.01156376f, 0.03467584f, -0.02494847f, -0.05495828f, -0.02141024f, 0.02073982f, 
    -0.01097803f, -0.01886273f, 0.03024144f, -0.03016941f, 0.02040205f, -0.00620804f, -0.00748269f, 0.02203627f, 
    0.04246715f, 0.02657316f, 0.00926545f, -0.02792297f, 0.00945583f, 0.01611414f, 0.02539579f, -0.05735758f, 
    -0.02484275f, -0.02996554f, -0.05760411f, 0.03007479f, -0.00298622f, 0.01779022f, -0.03835665f, 0.00475192f, 
    -0.01768982f, -0.01234292f, -0.02812703f, 0.04198315f, -0.05408899f, -0.01899670f, -0.04185870f, -0.05483492f, 
    -0.00370125f, -0.05704891f, 0.02240875f, 0.03164141f, -0.00997353f, 0.04516794f, -0.04333610f, 0.03785894f, 
    0.04043312f, -0.01521394f, -0.02757345f, 0.00054963f, -0.00341932f, -0.04646707f, -0.00737153f, -0.05195594f, 
    0.02399704f, -0.06100464f, -0.03133830f, -0.04394186f, 0.03470579f, -0.00714091f, 0.04017238f, 0.02067892f, 
    -0.01087978f, -0.02462469f, -0.05374486f, -0.05320304f, -0.04517197f, -0.01280572f, -0.02665647f, -0.03276889f, 
    -0.02344145f, 0.00370783f, -0.03061376f, 0.02176639f, -0.05156354f, 0.01358821f, -0.05264607f, 0.00761278f, 
    -0.02655821f, 0.02982086f, 0.02694118f, 0.02819240f, -0.00485135f, -0.04502466f, -0.04820777f, 0.00177677f, 
    0.00435116f, 0.01631806f, 0.02673657f, -0.00946004f, -0.01196009f, -0.03845796f, 0.04281259f, 0.00613995f, 
    -0.04281035f, -0.03491897f, -0.03100645f, -0.03217426f, 0.01155754f, -0.00817285f, -0.00945146f, -0.03917567f, 
    0.04587714f, 0.00708619f, -0.00539953f, -0.00991648f, -0.04613043f, 0.03069080f, 0.03716467f, -0.02039219f, 
    -0.06063742f, -0.02122997f, -0.04447853f, -0.00639108f, 0.03979388f, 0.03254113f, -0.00602422f, -0.00133871f, 
    0.01276042f, 0.03060011f, -0.00202603f, 0.03514455f, -0.04312729f, -0.00819032f, -0.03740977f, -0.01691361f, 
    -0.01417285f, 0.01614297f, 0.04261183f, 0.01411814f, -0.03505946f, 0.02253165f, 0.03196761f, 0.01870196f, 
    0.02872758f, -0.05860549f, 0.02168309f, 0.00360819f, -0.02472086f, 0.01239250f, 0.03913716f, -0.01773700f, 
    -0.00127175f, 0.02885475f, 0.01449070f, 0.04039174f, -0.06033130f, 0.02437891f, -0.00397518f, -0.05925182f, 
    -0.05577151f, 0.02606122f, -0.00793561f, -0.01411809f, -0.00893512f, -0.01253252f, -0.02712606f, -0.00457802f, 
    0.03887657f, 0.01242445f, -0.01234937f, -0.05188843f, -0.03112976f, 0.01004705f, -0.02513728f, 0.03338834f, 
    -0.05233285f, -0.04266836f, 0.00280491f, 0.03907446f, -0.03985352f, -0.04481959f, -0.03157625f, 0.03173392f, 
    -0.00668896f, 0.01318298f, -0.03646950f, 0.03546445f, -0.02788490f, 0.00025940f, 0.01555938f, -0.04409688f, 
    -0.01434841f, -0.03842289f, -0.02041391f, -0.02871564f, -0.05388192f, 0.02082372f, 0.02965640f, -0.05144296f, 
    -0.00756761f, -0.03288262f, -0.03659876f, 0.00759343f, -0.01086241f, -0.00383940f, -0.05301680f, -0.03522372f, 
    -0.02255211f, 0.03943472f, 0.03653641f, -0.01946720f, -0.04843188f, -0.05473805f, -0.01492652f, 0.02263806f, 
    0.03286760f, 0.03595176f, 0.02454318f, 0.02376140f, -0.05609586f, -0.01780854f, -0.02870725f, -0.00077581f, 
    -0.03454766f, 0.02904116f, 0.01196472f, -0.02253874f, 0.00999125f, -0.03813650f, -0.00415544f, -0.05223328f, 
    0.03799118f, -0.03230571f, 0.02802571f, -0.05650890f, 0.02707826f, 0.02517806f, -0.01908016f, -0.04981455f, 
    -0.00657703f, -0.05757703f, 0.02599925f, 0.03219149f, 0.02343575f, -0.02382976f, -0.03856857f, 0.02062553f, 
    0.04076469f, -0.01714335f, -0.04828369f, -0.04757280f, 0.03158155f, -0.04787115f, 0.00423847f, 0.02088726f, 
    0.02532961f, -0.01082344f, -0.00642428f, 0.01934871f, 0.03069190f, 0.01919572f, -0.00549719f, -0.02598753f, 
    -0.02538624f, -0.04521490f, 0.01562708f, -0.03948120f, -0.02647679f, 0.03779561f, -0.00072623f, 0.03951413f, 
    0.00385993f, 0.05143702f, -0.04966699f, 0.04305082f, -0.03678213f, -0.02185569f, -0.01716906f, -0.01346880f, 
    0.02115055f, 0.03303369f, 0.03275376f, 0.02016045f, 0.04007518f, -0.04897324f, 0.01375691f, -0.00902331f, 
    -0.02128076f, -0.03585366f, 0.01740015f, 0.00793952f, 0.02485560f, 0.03245882f, -0.03135825f, -0.02724740f, 
    -0.02200360f, 0.02463002f, -0.03874386f, -0.02852378f, -0.04004088f, 0.03406360f, -0.00810386f, -0.00519286f, 
    0.03262213f, -0.04572964f, -0.02915242f, -0.03920608f, -0.01191038f, -0.01075505f, -0.04047443f, -0.00982295f, 
    0.01836351f, 0.00905384f, -0.03406717f, -0.00565693f, 0.00023819f, 0.00116595f, 0.00182599f, -0.00559976f, 
    0.01051087f, -0.03067129f, -0.02501448f, 0.03952495f, -0.05080126f, 0.03203281f, 0.03042140f, -0.03934550f, 
    -0.02324016f, -0.00450077f, 0.02331444f, -0.04380324f, -0.02883154f, -0.01299394f, 0.00595153f, 0.00779584f, 
    0.00866599f, -0.04713273f, -0.02276873f, -0.00299436f, 0.00942440f, -0.00388001f, -0.04884152f, 0.00900499f, 
    0.03396049f, -0.01125741f, -0.03604279f, 0.00114170f, 0.00911366f, -0.00042882f, -0.03207068f, -0.02918820f, 
    -0.05662500f, -0.04411244f, -0.01126794f, -0.01973680f, 0.01538573f, -0.00661863f, 0.02170378f, -0.03426088f, 
    -0.03568028f, 0.04106282f, 0.00754448f, -0.01260875f, -0.01575968f, -0.03583958f, -0.01462156f, 0.00646211f, 
    0.04354647f, 0.00306189f, 0.02696650f, -0.00220557f, -0.02883749f, -0.01453532f, 0.01632860f, 0.02883682f, 
    0.01748151f, 0.01634344f, -0.05418090f, 0.01503034f, -0.01497872f, 0.02201037f, -0.02179592f, -0.02692044f, 
    0.01630124f, 0.01929909f, -0.01765337f, -0.00016138f, -0.04490689f, -0.03516499f, -0.04519417f, -0.00131399f, 
    -0.03524673f, 0.02112330f, 0.02865845f, -0.01063069f, -0.01017031f, 0.02326681f, 0.01354745f, -0.02117636f, 
    -0.02213791f, 0.03771714f, -0.04086798f, 0.03443641f, 0.02720501f, -0.05019376f, -0.01379704f, 0.02657320f, 
    0.01618081f, -0.03278909f, 0.02920523f, -0.04981556f, 0.01652705f, -0.05014395f, 0.03688470f, -0.05395130f, 
    -0.01249001f, 0.03509812f, -0.04240670f, 0.04192803f, -0.02425252f, -0.00875629f, 0.03639220f, -0.05325713f, 
    0.02474125f, -0.05545865f, 0.04265804f, -0.01529915f, 0.03405333f, 0.03855130f, 0.02719291f, 0.02602053f, 
    0.01575541f, -0.04430702f, -0.03549873f, -0.02969256f, 0.01548456f, 0.02060212f, -0.00393126f, -0.05126025f, 
    -0.00725369f, -0.04905418f, -0.02731177f, -0.03667717f, -0.01890844f, 0.01601160f, 0.03380444f, 0.04257872f, 
    -0.00621500f, -0.05102212f, -0.02018392f, 0.01076251f, -0.02660539f, -0.02108483f, -0.03883872f, -0.00793093f, 
    -0.02250696f, -0.02443486f, -0.04168690f, 0.02387294f, 0.02024894f, -0.02145949f, -0.03932054f, 0.03425451f, 
    -0.00267999f, 0.02372859f, -0.05396714f, 0.00566771f, -0.01295664f, -0.02799493f, -0.01591775f, -0.00102398f, 
    -0.04939951f, 0.02984383f, -0.03024033f, -0.05017787f, -0.01313234f, 0.01893983f, 0.04011708f, -0.04173515f, 
    -0.05419387f, -0.03363555f, 0.03706366f, -0.04265247f, -0.02233444f, 0.03937841f, -0.03881943f, -0.02319074f, 
    0.02924049f, -0.03687157f, 0.03971339f, -0.00203316f, -0.03077392f, -0.03397952f, -0.01456783f, 0.00757280f, 
    -0.01934916f, 0.01005547f, -0.02099524f, -0.01808960f, -0.04912191f, -0.00288075f, 0.00244564f, 0.02476576f, 
    -0.01174068f, -0.05513306f, -0.02801876f, 0.00044430f, 0.03789700f, -0.05331637f, 0.03840040f, -0.03475462f, 
    0.02649962f, -0.00182235f, -0.00978130f, 0.01252006f, -0.04192703f, -0.03452916f, -0.00417728f, -0.04876617f, 
    -0.02316733f, -0.03241385f, 0.01177066f, -0.00543230f, 0.04456800f, -0.03267705f, 0.03849386f, -0.01277069f, 
    0.01658179f, 0.00840862f, -0.00389007f, 0.04484537f, 0.04308187f, -0.04173115f, -0.01498755f, -0.00253240f, 
    -0.04719381f, -0.04513127f, 0.02793164f, -0.00896897f, 0.02452746f, 0.03503938f, -0.04307004f, 0.01858021f, 
    -0.05063735f, -0.01225405f, 0.00599096f, 0.00063226f, -0.00190786f, 0.02742678f, 0.00864410f, 0.03864059f, 
    0.02733388f, -0.01482835f, -0.01244219f, 0.01246050f, 0.02365601f, -0.03808152f, -0.01287317f, 0.00842899f, 
    0.03502803f, -0.04561189f, 0.02277755f, -0.03490550f, -0.01191740f, -0.00141662f, 0.00693096f, -0.05438570f, 
    -0.03444909f, 0.01098195f, -0.04075077f, 0.03862695f, 0.01143262f, -0.00814954f, -0.01823539f, -0.04871688f, 
    -0.01820017f, -0.05655398f, 0.02024815f, -0.02908760f, 0.04350668f, 0.01299221f, -0.00543373f, -0.05458207f, 
    -0.00387638f, -0.05226279f, 0.04254216f, 0.00435748f, -0.02233853f, 0.00709377f, -0.04290525f, -0.01669594f, 
    0.02610120f, 0.01005267f, -0.01782170f, -0.02827160f, -0.03657924f, -0.02839047f, 0.00294236f, -0.05237670f, 
    -0.03653774f, -0.01927239f, -0.04217053f, -0.04891227f, 0.03218876f, 0.00308530f, -0.01852402f, -0.00701920f, 
    -0.02899522f, -0.02540320f, 0.03171921f, -0.02158698f, -0.05313535f, -0.05495466f, 0.01351972f, -0.00388847f, 
    -0.01452463f, -0.03407232f, -0.01352138f, 0.00366915f, -0.00583103f, 0.03144208f, 0.01313974f, -0.03976136f, 
    -0.01569212f, -0.04795163f, 0.03593479f, -0.03090176f, -0.05587439f, -0.00662846f, 0.02410880f, -0.01863314f, 
    0.03033656f, -0.04830087f, 0.01779703f, -0.04379215f, -0.00218762f, 0.01111119f, -0.00731806f, -0.04233125f, 
    0.03199792f, 0.03878370f, 0.00128302f, 0.02198236f, 0.01746102f, 0.04431405f, -0.02086508f, 0.02762272f, 
    -0.01606065f, 0.00777257f, 0.03853212f, -0.00961366f, -0.01712844f, 0.03386538f, -0.02488262f, -0.05150412f, 
    -0.00804473f, -0.00729684f, -0.05532997f, -0.01159845f, -0.00260190f, -0.04095783f, -0.02709528f, -0.00735424f, 
    0.01630411f, 0.03352943f, 0.03016282f, -0.04105081f, -0.02135660f, -0.00863279f, -0.03714487f, -0.01632090f, 
    -0.01723681f, 0.02470338f, -0.04391161f, -0.01576442f, -0.01969193f, -0.01857123f, -0.01874788f, 0.03067514f, 
    0.04386449f, 0.03359163f, -0.05687877f, 0.00483698f, 0.01812523f, 0.00469815f, 0.03837668f, 0.03948838f, 
    -0.00673305f, -0.04391693f, 0.03827000f, 0.01378659f, -0.05524534f, 0.02734751f, -0.00748089f, 0.02808694f, 
    0.01688483f, 0.02563608f, -0.05359336f, -0.03522294f, 0.00528076f, 0.00952169f, -0.01959883f, 0.02279738f, 
    -0.01461962f, 0.03888907f, 0.01557012f, -0.03755069f, 0.03610463f, -0.00166295f, -0.03018624f, -0.01344463f, 
    -0.00442868f, -0.01818958f, -0.03899441f, -0.01590261f, -0.05522248f, 0.00786989f, -0.04726050f, 0.03084956f, 
    0.01294781f, 0.03238634f, -0.05321933f, 0.00320386f, -0.05109918f, -0.00534521f, 0.01522172f, -0.03463445f, 
    0.02283288f, -0.04206094f, -0.04780201f, 0.03784906f, -0.03430854f, -0.05566950f, 0.00487969f, -0.04755501f, 
    -0.02709243f, 0.00348032f, 0.02947722f, 0.02934656f, 0.02838334f, 0.02292545f, 0.03615239f, 0.02065176f, 
    -0.02016800f, 0.03837643f, 0.00585706f, -0.05248646f, -0.00664258f, 0.04372314f, 0.01209772f, 0.03663065f, 
    0.01012303f, -0.04040506f, -0.02984204f, 0.02630335f, -0.02679331f, -0.03953929f, -0.03545231f, -0.04521638f, 
    0.01206600f, -0.03203549f, -0.04557195f, 0.02086737f, 0.01839863f, -0.03926829f, 0.01284321f, -0.03154898f, 
    -0.00641474f, 0.01236414f, -0.04856430f, -0.02336221f, 0.03289635f, -0.01662836f, -0.00825285f, -0.02476387f, 
    -0.05620096f, -0.04598518f, -0.03506861f, -0.01834807f, -0.04794425f, 0.00125509f, -0.05582363f, -0.04922432f, 
    -0.01708241f, -0.00177988f, -0.03040546f, -0.03627313f, -0.03961172f, 0.03126409f, 0.03914266f, 0.02451033f, 
    0.03638098f, -0.01416583f, -0.03598434f, -0.01960956f, 0.01355280f, -0.01418918f, -0.01104029f, -0.03278128f, 
    -0.05085393f, -0.03559919f, -0.03737461f, -0.00082278f, 0.02310814f, 0.04289985f, -0.02061021f, 0.00569345f, 
    -0.00324412f, -0.01383842f, -0.01689047f, -0.03205391f, -0.03604493f, 0.03696737f, 0.00918597f, -0.01252490f, 
    -0.03709739f, -0.04161733f, 0.03382193f, 0.01628974f, 0.04438106f, -0.00342287f, 0.03120772f, -0.03401672f, 
    0.01058431f, -0.02829161f, 0.03960245f, 0.02388277f, -0.03443195f, 0.00089770f, 0.03736901f, 0.04210042f, 
    -0.01396919f, -0.04592051f, -0.01388207f, -0.04550309f, 0.01873716f, 0.01922273f, 0.04463369f, -0.02171400f, 
    0.03706214f, 0.04204533f, 0.02773816f, -0.02907497f, 0.03639644f, 0.02127504f, -0.04145335f, 0.00495838f, 
    0.03564093f, -0.01986041f, -0.01689773f, 0.01124275f, -0.05062497f, 0.00376826f, 0.03498096f, 0.01784656f, 
    -0.05528416f, -0.02430792f, -0.01884850f, 0.02924383f, -0.03606272f, 0.03742217f, 0.01711201f, 0.01830274f, 
    0.00582041f, -0.02312140f, -0.02229712f, -0.04533250f, 0.01031975f, -0.02087121f, -0.01779683f, 0.00085078f, 
    0.00768423f, -0.03874979f, -0.00105779f, -0.03342695f, -0.00128279f, -0.02469142f, 0.04779398f, 0.01132272f, 
    0.00132037f, -0.04162364f, -0.03138063f, -0.05096656f, -0.00123105f, -0.03112494f, -0.01061769f, 0.01711733f, 
    0.01622427f, -0.04214751f, 0.02922891f, 0.01217150f, -0.04446300f, -0.03369490f, -0.00648881f, -0.02693663f, 
    -0.03656133f, 0.02950508f, 0.03628341f, 0.04295639f, 0.04308605f, 0.03930465f, 0.01294322f, -0.05377655f, 
    -0.04683544f, 0.01050091f, 0.00283500f, 0.02973465f, -0.05165157f, -0.03526978f, 0.03205324f, -0.04693994f, 
    -0.03668430f, -0.04564022f, -0.01549914f, -0.05344401f, -0.03217007f, 0.01817715f, -0.05552678f, -0.02187862f, 
    -0.00824035f, -0.04012780f, 0.01268442f, -0.00504699f, -0.01828215f, 0.01509676f, 0.02147082f, 0.02536649f, 
    -0.05087169f, 0.00437356f, -0.01162377f, 0.02389425f, 0.03459113f, 0.00385059f, -0.04833005f, 0.03337740f, 
    -0.02004230f, -0.05532820f, -0.01030761f, 0.01451679f, -0.02440322f, -0.03308896f, -0.02219718f, -0.02800171f, 
    -0.04578035f, -0.04726421f, -0.02333731f, 0.04680524f, -0.02643309f, -0.03540552f, -0.02927325f, 0.03143100f, 
    -0.01228565f, -0.04555776f, 0.02455991f, 0.02941237f, -0.00297167f, -0.02525632f, -0.00806308f, -0.05039155f, 
    -0.00357275f, -0.04941479f, -0.05522402f, 0.02602633f, 0.00433529f, -0.00776766f, -0.05549032f, 0.02272753f, 
    0.03042038f, -0.03211356f, -0.01802485f, -0.03751935f, -0.03517097f, 0.01381108f, -0.04396825f, 0.01749120f, 
    -0.03986062f, 0.03062392f, -0.03388893f, 0.04450256f, -0.01547289f, 0.02631695f, 0.03033848f, -0.02589015f, 
    0.02849021f, 0.01872452f, -0.00312340f, 0.04412434f, -0.03178428f, -0.01064775f, -0.02950895f, 0.02496932f, 
    -0.00132039f, -0.05293058f, 0.04155958f, -0.02431840f, -0.01807283f, -0.04282028f, -0.01158566f, 0.00102879f, 
    -0.04339519f, -0.03317488f, 0.02565045f, -0.01075990f, 0.01246985f, 0.01452524f, -0.00479979f, 0.02514909f, 
    -0.02142371f, -0.01458175f, 0.04065858f, 0.00712643f, 0.02055831f, 0.01269499f, 0.02548232f, 0.02862003f, 
    -0.01839568f, 0.02724599f, 0.00182196f, 0.02574964f, -0.03962645f, -0.05216823f, 0.00005919f, -0.02443260f, 
    -0.01078147f, -0.05041034f, 0.03579724f, -0.01580224f, -0.04160394f, -0.05094432f, -0.00385986f, 0.01279265f, 
    -0.01054122f, -0.01892591f, -0.05564252f, -0.00380204f, -0.02979870f, -0.03519910f, -0.01303383f, 0.02413479f, 
    0.00657979f, -0.04202571f, 0.02516187f, 0.02326866f, 0.04520696f, -0.01735779f, -0.05415155f, 0.00761426f, 
    -0.01964398f, 0.00256690f, -0.05388905f, 0.03732687f, 0.00195140f, -0.04834035f, -0.04202924f, -0.04532711f, 
    0.01048915f, -0.03136314f, 0.02251799f, 0.04894545f, -0.02681994f, -0.00466125f, -0.00329272f, -0.04998227f, 
    -0.03373258f, -0.04758482f, -0.03856082f, 0.04941478f, -0.00334164f, -0.03219083f, -0.03621330f, 0.02644228f, 
    0.03713069f, -0.01534589f, -0.03880417f, -0.04265330f, -0.04832136f, 0.03844703f, 0.02666041f, -0.00767533f, 
    0.02441377f, 0.03947427f, 0.02222970f, -0.00286368f, -0.02500487f, -0.05083842f, -0.02268972f, -0.05182426f, 
    -0.05675684f, 0.00939122f, -0.05219427f, 0.02299941f, -0.01827290f, 0.01480311f, 0.01586251f, -0.01609431f, 
    0.02232653f, 0.04492333f, -0.02009541f, 0.01201717f, -0.02084309f, -0.03762088f, 0.01419552f, -0.01042664f, 
    -0.00674871f, -0.00799526f, 0.02870470f, -0.03522381f, -0.02604635f, 0.02644732f, -0.00901075f, -0.01711629f, 
    0.00456806f, -0.02987424f, -0.03455443f, -0.04929027f, -0.02614046f, 0.03045157f, 0.00350574f, -0.03869773f, 
    -0.00305621f, 0.02621700f, -0.04979059f, -0.04215613f, -0.05705097f, -0.02125909f, -0.04782861f, 0.04532690f, 
    -0.04473468f, 0.03087039f, -0.05549761f, -0.03431084f, 0.03362707f, 0.03437970f, -0.02248861f, 0.02678946f, 
    0.00586386f, -0.04535856f, 0.02801126f, 0.00445306f, 0.01560782f, -0.04099654f, -0.00745449f, -0.04154554f, 
    0.00347285f, -0.00745101f, -0.00322411f, -0.02489314f, 0.03080931f, 0.03457848f, 0.02813715f, -0.01001398f, 
    0.03136317f, 0.04098653f, 0.01805006f, -0.04997775f, -0.03969937f, 0.04559245f, -0.01989539f, -0.03814293f, 
    0.03362077f, -0.00370679f, 0.04104186f, -0.00227044f, -0.01183429f, -0.04671816f, -0.03978394f, 0.02774297f, 
    -0.00183224f, -0.01656059f, -0.01195267f, 0.02893272f, -0.02231934f, -0.05367905f, -0.00723713f, 0.01951813f, 
    -0.00904932f, 0.00864531f, 0.02264190f, 0.00891166f, 0.00203321f, 0.02364790f, -0.04099312f, 0.04076643f, 
    -0.01818115f, -0.01379493f, -0.02941746f, 0.03910713f, -0.02368058f, 0.03944674f, 0.01986369f, 0.01837078f, 
    -0.05061053f, -0.02458947f, -0.00783454f, -0.01509412f, -0.04962739f, -0.03391931f, -0.01574839f, -0.04942594f, 
    -0.03204737f, -0.04305902f, -0.05329839f, -0.00171160f, -0.02946569f, -0.00249807f, -0.00394097f, -0.01998085f, 
    0.03106614f, -0.03114930f, -0.05111179f, -0.02385977f, -0.00935732f, -0.01709458f, 0.00265858f, -0.01054830f, 
    -0.02811564f, 0.01598734f, 0.03367763f, -0.03979260f, -0.06138460f, -0.02200987f, 0.01421112f, -0.02322936f, 
    -0.03830235f, 0.01182896f, 0.02077197f, -0.03966100f, 0.03374254f, 0.03470605f, 0.03661893f, -0.04526757f, 
    -0.00208304f, -0.04964083f, 0.04324761f, -0.04265193f, 0.02067070f, 0.04699945f, -0.00076741f, 0.01400776f, 
    -0.03415319f, 0.02944468f, -0.03049689f, -0.01816257f, 0.00989469f, -0.01070227f, 0.04602267f, 0.01760309f, 
    -0.00304682f, 0.03901855f, -0.00168172f, 0.00514894f, -0.01777294f, -0.02266216f, 0.00083417f, 0.01595133f, 
    0.04306354f, -0.01885361f, 0.01948261f, 0.03663182f, -0.04520331f, -0.00695687f, 0.00722846f, 0.01607176f, 
    -0.00633069f, -0.04097765f, -0.03656453f, 0.00225834f, 0.01570346f, -0.01438741f, -0.01215750f, -0.00932250f, 
    0.04061703f, -0.02135105f, -0.04149216f, 0.02462995f, -0.04309185f, 0.03051259f, 0.04264224f, 0.04211130f, 
    0.02323760f, -0.01603775f, 0.02331271f, 0.02458635f, 0.00752717f, 0.01785497f, 0.01940561f, -0.01474028f, 
    0.00566834f, 0.01628651f, 0.00991070f, -0.04456186f, 0.00303609f, -0.03962268f, -0.02307464f, -0.01789431f, 
    -0.04458907f, -0.00491042f, -0.03826586f, -0.00491574f, 0.04262216f, -0.00272706f, -0.05225978f, -0.01903252f, 
    0.00451648f, -0.03115085f, 0.00458934f, 0.03889522f, 0.04849466f, -0.01364557f, -0.05049798f, -0.00826940f, 
    0.02013488f, -0.01933352f, -0.02448775f, 0.03612953f, 0.00716078f, -0.02541574f, 0.04692860f, 0.04043454f, 
    -0.05762205f, -0.02806078f, -0.01846490f, -0.02779576f, -0.00057985f, -0.02765468f, 0.05077958f, -0.03371158f, 
    0.03317755f, 0.00846518f, -0.05535857f, -0.02015424f, -0.02358812f, -0.04719226f, 0.04930257f, -0.02575179f, 
    -0.02128220f, -0.02072040f, -0.02150841f, 0.02918836f, -0.00887607f, -0.03885964f, 0.00200023f, 0.02538740f, 
    -0.01108759f, 0.03633080f, 0.00888295f, 0.03040892f, -0.00989186f, 0.01495448f, -0.00983849f, 0.02742165f, 
    0.02575422f, 0.00262202f, -0.04250133f, 0.02186175f, 0.03987892f, 0.02249765f, 0.02805435f, 0.01477379f, 
    0.02726129f, 0.00454802f, -0.03071718f, 0.02126415f, 0.02782947f, 0.03014145f, -0.03712447f, 0.00084052f, 
    0.00214364f, -0.02546249f, 0.03850339f, 0.02320620f, -0.04689676f, 0.03804621f, -0.03510000f, -0.02164815f, 
    -0.05514348f, -0.01343246f, -0.04731564f, -0.00326840f, 0.02360959f, -0.00929633f, 0.04465146f, -0.01834527f, 
    0.03471997f, -0.01247318f, -0.05151074f, 0.01618392f, 0.02649640f, -0.01696464f, 0.01467601f, 0.03160869f, 
    -0.00669098f, -0.04002867f, 0.03928604f, -0.00861887f, -0.02358420f, -0.05020507f, -0.01602632f, -0.02869560f, 
    0.03099409f, 0.02211990f, 0.00499454f, 0.00723824f, -0.04334200f, -0.00052415f, 0.03030938f, 0.03160220f, 
    -0.01607676f, 0.02110222f, 0.02233097f, 0.04456403f, -0.01425954f, 0.03118501f, -0.01284061f, 0.01411455f, 
    0.02051146f, -0.03446520f, -0.02033430f, -0.05780396f, 0.00658785f, 0.01458318f, -0.02784196f, -0.03278247f, 
    -0.00491136f, 0.00091315f, -0.05003840f, 0.04083913f, 0.01757854f, 0.04655997f, -0.02785652f, -0.02355213f, 
    0.00953608f, -0.00704046f, -0.04063088f, -0.03715592f, -0.03417067f, -0.00666989f, -0.04436004f, -0.01546946f, 
    0.00049282f, 0.02913507f, -0.03331326f, -0.03551813f, 0.04618071f, -0.00993021f, -0.04348245f, -0.00319815f, 
    0.04035765f, 0.00540817f, -0.04764049f, -0.05078487f, -0.01745741f, 0.01408014f, -0.01177237f, -0.03073620f, 
    0.02192500f, -0.02329408f, 0.00543364f, -0.05428596f, 0.00643767f, -0.01544396f, 0.03645854f, 0.02683518f, 
    0.03980654f, -0.02420024f, 0.04138406f, 0.01541092f, -0.05498119f, -0.00351445f, 0.03035138f, 0.03028191f, 
    -0.03223012f, -0.00057173f, 0.02003316f, 0.01171379f, 0.04787859f, 0.00553267f, -0.03099589f, -0.03861004f, 
    0.01213540f, 0.03866109f, -0.00651402f, 0.02414737f, 0.02677853f, -0.01375157f, -0.05552087f, -0.00825329f, 
    0.01946892f, -0.04832227f, -0.02229435f, -0.00702923f, -0.01217948f, -0.03358475f, -0.03956752f, -0.02157904f, 
    -0.04487748f, 0.00333908f, -0.03740900f, -0.04483278f, -0.01248451f, 0.03159565f, -0.03191304f, -0.04051777f, 
    -0.01818115f, -0.01637068f, 0.00836755f, -0.02655323f, -0.04629736f, -0.03148868f, -0.03469864f, -0.00848729f, 
    0.00170685f, -0.01622815f, -0.01192679f, -0.04409130f, 0.00571756f, -0.02932605f, -0.00965633f, 0.00087662f, 
    0.00581873f, -0.00657561f, 0.02835582f, 0.00543145f, 0.02154324f, -0.05519622f, 0.00563162f, -0.04095426f, 
    0.01508187f, -0.01839019f, -0.05199620f, -0.04317103f, -0.00444392f, -0.02798622f, -0.04529171f, -0.03628846f, 
    -0.00927766f, -0.02669766f, 0.00439428f, 0.00649297f, -0.04745025f, 0.00950007f, -0.01789021f, 0.00747579f, 
    -0.03653198f, 0.03456707f, -0.03037135f, -0.04549426f, 0.01539649f, -0.05591550f, 0.00515625f, 0.01440302f, 
    0.00155593f, 0.03692821f, -0.04902359f, 0.03823434f, 0.02943107f, 0.00590223f, -0.02644333f, 0.03399204f, 
    -0.01483418f, 0.01547341f, 0.01530251f, -0.03141711f, 0.01537289f, -0.04823450f, 0.00840063f, 0.03399812f, 
    -0.04122524f, -0.04570954f, -0.05042076f, -0.03405094f, 0.03907024f, -0.00088396f, -0.03601385f, 0.00806025f, 
    0.01336322f, 0.01693991f, -0.05334865f, -0.00837164f, -0.03556687f, -0.05165907f, -0.03469257f, 0.00198808f, 
    0.01534537f, 0.00898163f, 0.00301239f, -0.04349265f, -0.04160624f, -0.05514463f, -0.03885840f, 0.01270872f, 
    -0.04843606f, 0.03430127f, -0.04891549f, -0.00507110f, 0.04040710f, -0.02431571f, -0.01476541f, -0.05278929f, 
    -0.03242888f, -0.05020695f, -0.01648781f, -0.02772972f, -0.05977729f, -0.03852553f, -0.00385747f, 0.01781313f, 
    -0.03379300f, 0.01155920f, -0.01966402f, 0.01505947f, -0.02575619f, 0.03892251f, -0.00401276f, -0.04383864f, 
    -0.04043043f, -0.03213587f, -0.02848981f, -0.00456860f, -0.02476173f, -0.02515651f, 0.01921758f, -0.04539350f, 
    -0.02808463f, -0.04843921f, -0.05768954f, -0.03872689f, -0.04007909f, -0.05945150f, 0.02429523f, 0.01763185f, 
    -0.04935511f, -0.03892972f, 0.03361376f, 0.01453418f, -0.05021638f, -0.02048218f, -0.04904783f, -0.05824532f, 
    0.01485030f, 0.02048424f, 0.00028339f, 0.02877414f, 0.02066943f, 0.00781357f, 0.01434204f, 0.03666461f, 
    -0.05736593f, -0.02665862f, -0.00673075f, -0.00849991f, 0.01768425f, 0.03987451f, -0.05703317f, -0.03133688f, 
    -0.04955355f, -0.04294318f, 0.02440578f, 0.01000399f, -0.05347819f, -0.05158069f, 0.00488868f, 0.02294730f, 
    0.02062909f, 0.00550787f, 0.02747286f, -0.03697385f, -0.05291643f, -0.04160460f, -0.03026247f, -0.03229998f, 
    0.01538728f, -0.00159234f, -0.05438226f, -0.04295928f, -0.02520656f, 0.01724378f, 0.03770610f, 0.00042991f, 
    -0.03920095f, 0.00839418f, 0.01795506f, -0.04109605f, -0.02594506f, -0.05810421f, 0.02175458f, 0.00537672f, 
    -0.03522531f, -0.04697932f, -0.02094406f, 0.00000872f, -0.04147684f, 0.02355338f, -0.05258997f, -0.03200494f, 
    0.03380397f, -0.04267767f, 0.03009057f, 0.03031603f, 0.02702162f, -0.01355028f, -0.03935844f, -0.02923818f, 
    0.03174935f, -0.01194988f, -0.04606754f, -0.03085255f, -0.03539057f, -0.02938771f, 0.01008142f, -0.04447376f, 
    0.04072237f, -0.00739588f, 0.00747966f, -0.02363399f, 0.01361945f, 0.01620833f, 0.00866209f, 0.02992562f, 
    -0.04523893f, -0.01926211f, 0.02306448f, 0.02246197f, -0.01364388f, -0.04522195f, -0.01495393f, -0.05615383f, 
    -0.03948419f, -0.03560043f, -0.03501603f, -0.04060495f, 0.03381997f, -0.00179992f, -0.05334349f, 0.04635388f, 
    -0.00718752f, -0.02366359f, 0.00595583f, 0.01798929f, 0.00662290f, -0.02470604f, 0.01906842f, -0.04444954f, 
    0.02991040f, 0.01138851f, -0.05213635f, -0.00979755f, -0.03449294f, -0.03596775f, -0.00316737f, -0.00731578f, 
    -0.03543513f, -0.01011700f, -0.05707387f, -0.01052291f, -0.00930047f, -0.00314736f, 0.01087583f, -0.03071285f, 
    -0.00947809f, 0.03128589f, -0.03845028f, -0.02988041f, -0.05106372f, 0.02387347f, 0.04193322f, 0.00461517f, 
    -0.04802718f, 0.03818920f, 0.01117046f, -0.05237962f, -0.03161614f, -0.05167635f, -0.04484741f, 0.02309498f, 
    0.02469310f, -0.03618351f, -0.01882718f, -0.02617385f, -0.04957727f, -0.02591631f, -0.02615176f, -0.01721951f, 
    0.00334587f, -0.00244963f, 0.02283547f, -0.05067149f, 0.02533076f, -0.00573441f, -0.01287709f, 0.01795513f, 
    0.02483312f, -0.01337390f, -0.03709916f, -0.04203645f, -0.00838516f, 0.01976940f, 0.02385452f, 0.00618000f, 
    0.03288214f, 0.01204866f, -0.02770769f, 0.02552758f, -0.01163203f, -0.00535081f, 0.03533823f, -0.04729912f, 
    0.01458225f, 0.03372580f, -0.01671592f, -0.03052622f, -0.01409509f, -0.04344051f, -0.00036906f, 0.02851691f, 
    -0.00919191f, 0.02499862f, 0.02862280f, 0.02258098f, -0.05050505f, 0.01323874f, -0.02896816f, 0.02521170f, 
    -0.00427428f, -0.04033370f, -0.01027099f, 0.01133258f, -0.05022798f, -0.04476700f, -0.03480696f, 0.02463717f, 
    -0.02146543f, 0.00032511f, 0.03512086f, 0.02785887f, -0.03477952f, -0.00049295f, -0.00149439f, -0.02291066f, 
    0.03687809f, -0.00281700f, -0.03942242f, 0.02967098f, -0.01471970f, -0.01200635f, -0.00323326f, 0.00650285f, 
    -0.03406093f, -0.00105320f, 0.00503578f, -0.05334705f, 0.04133669f, -0.02413480f, 0.00744488f, -0.00355658f, 
    -0.00548643f, 0.01423658f, 0.03087825f, -0.00758443f, -0.01028161f, 0.03322367f, 0.00221796f, -0.03325963f, 
    -0.01561205f, -0.00583862f, 0.03677840f, 0.02295700f, -0.04682869f, -0.05113320f, 0.04785570f, 0.01535115f, 
    -0.01691707f, -0.03354113f, -0.01912901f, 0.04144983f, -0.04811200f, -0.02256743f, -0.00365342f, -0.02502592f, 
    -0.01017252f, 0.02521975f, -0.03020369f, 0.03910021f, -0.04687937f, 0.03849750f, 0.00872280f, 0.03433356f, 
    0.00031310f, 0.00728861f, 0.03686174f, -0.03351683f, -0.03205772f, 0.03279725f, -0.00312349f, -0.01347186f, 
    0.03814203f, -0.02920554f, -0.03911224f, 0.00770824f, -0.05062056f, -0.02170363f, 0.03243953f, -0.01281986f, 
    0.03731222f, -0.01215507f, -0.00150007f, -0.01291589f, -0.00825948f, -0.01059982f, 0.00458805f, -0.02261933f, 
    0.03991841f, -0.05193207f, 0.00389562f, 0.02639428f, -0.02809879f, 0.03860768f, -0.02227453f, -0.03261468f, 
    0.05394324f, 0.03712413f, 0.04375270f, 0.01751941f, 0.00750533f, -0.00496172f, -0.00077013f, 0.00961902f, 
    0.03341025f, 0.03723374f, -0.03183525f, -0.02839863f, 0.04855526f, -0.01025094f, -0.02871400f, 0.03737356f, 
    -0.02386331f, 0.00276847f, -0.00899684f, 0.02542711f, -0.01984567f, -0.01145940f, -0.05251953f, 0.03300804f, 
    0.04616687f, 0.01644626f, 0.04319641f, 0.01951670f, 0.01082800f, 0.03663363f, 0.03552352f, 0.01017669f, 
    -0.03941112f, -0.02138267f, 0.04268250f, -0.04915467f, -0.03659699f, -0.01410826f, 0.01343550f, 0.00920545f, 
    -0.01172895f, 0.00544528f, 0.05206895f, 0.00092793f, -0.03110108f, -0.04063515f, -0.03793332f, 0.03341108f, 
    -0.04126686f, -0.02485582f, 0.02290533f, -0.02167151f, -0.03429389f, -0.01660921f, 0.00887354f, -0.03044487f, 
    0.02527836f, -0.01353048f, -0.00853173f, -0.00188283f, -0.03415877f, 0.01659176f, -0.02612358f, -0.03644739f, 
    0.01669527f, 0.04488385f, -0.01817913f, 0.03398912f, 0.02047048f, -0.01357818f, -0.03838234f, 0.03999473f, 
    0.02289041f, 0.00527999f, 0.04214521f, -0.04459228f, -0.02837549f, -0.04050364f, -0.03237687f, 0.02996193f, 
    -0.00365150f, -0.01074484f, -0.04690243f, -0.01587032f, -0.01845950f, -0.02683425f, -0.05060393f, 0.00651175f, 
    0.00528140f, 0.03796957f, -0.05163409f, -0.04867141f, -0.05467082f, -0.05260628f, -0.02010016f, -0.04123425f, 
    -0.02839334f, 0.03768622f, 0.04044195f, -0.03899127f, 0.00371450f, 0.01653488f, -0.02884222f, -0.00347648f, 
    -0.02604328f, 0.04293492f, 0.03345766f, -0.03750982f, -0.00816534f, 0.00096395f, -0.04107245f, 0.04061761f, 
    -0.03798866f, -0.01305571f, 0.04721431f, -0.03807436f, -0.02498026f, -0.03284106f, 0.03456424f, 0.01573107f, 
    -0.01834850f, 0.01347411f, 0.02892246f, 0.04293234f, 0.00571332f, -0.05170496f, -0.04263591f, -0.03003262f, 
    0.00868425f, -0.03469268f, -0.01572096f, 0.03531507f, -0.02350304f, -0.02325310f, 0.04147311f, 0.00782511f, 
    0.01889433f, -0.04139324f, 0.03530974f, -0.00088113f, -0.01322239f, -0.01005173f, 0.04347304f, 0.02865057f, 
    0.02914061f, -0.04307580f, 0.02879389f, -0.02952511f, -0.03894611f, -0.03301736f, -0.01683901f, -0.00108607f, 
    0.02307620f, -0.04513083f, 0.02714416f, 0.03533591f, -0.02886235f, -0.00265674f, -0.03878016f, -0.03362940f, 
    -0.01850856f, -0.05378628f, -0.01276603f, -0.04474981f, -0.02633440f, -0.04320826f, -0.02530634f, 0.00732390f, 
    -0.00585215f, -0.02175659f, 0.03673294f, 0.03933144f, 0.00193331f, -0.03372401f, -0.02559228f, -0.00803055f, 
    0.01689908f, 0.02557751f, -0.01194518f, -0.01146561f, -0.02957168f, 0.02983493f, -0.03989195f, -0.04100618f, 
    -0.05452647f, 0.00024444f, 0.03192652f, 0.01558514f, -0.03632135f, 0.03663803f, -0.05083105f, -0.00693741f, 
    0.01323176f, 0.04226219f, -0.04468077f, 0.03275047f, 0.03921251f, -0.02565497f, -0.00855642f, 0.04387856f, 
    -0.00481691f, -0.03623617f, 0.04199711f, 0.01031200f, -0.03529069f, -0.02880006f, 0.00722670f, -0.05224494f, 
    -0.05548799f, -0.03974478f, -0.04625466f, 0.03995634f, -0.05266578f, 0.02108192f, 0.04195145f, 0.03386715f, 
    0.04423310f, 0.03910971f, 0.01423744f, -0.00200408f, -0.03857603f, -0.01584118f, 0.03456475f, -0.03847216f, 
    -0.00290400f, -0.05231134f, -0.02718992f, -0.02346963f, 0.05012988f, 0.01895487f, -0.02322494f, 0.03391793f, 
    0.00438635f, -0.05337161f, 0.00423025f, 0.00535161f, -0.02250398f, 0.02649144f, 0.01588470f, -0.02621970f, 
    -0.03220757f, -0.02632874f, 0.04565913f, -0.05139933f, -0.04272238f, -0.00460429f, -0.03977872f, -0.03257570f, 
    0.02483516f, -0.04446357f, -0.02441618f, -0.04317471f, -0.00829343f, -0.04940714f, 0.02719199f, -0.01709896f, 
    -0.00958337f, -0.00714799f, -0.00185353f, 0.02631367f, -0.02838675f, 0.04292125f, 0.01134457f, -0.01616800f, 
    0.02928080f, 0.03781677f, 0.03821680f, 0.03301677f, -0.02903564f, 0.03745275f, -0.01302123f, 0.04606695f, 
    -0.00861437f, -0.01409302f, -0.05070257f, 0.01087048f, -0.04636849f, 0.01849966f, 0.02708432f, 0.03264533f, 
    0.02363896f, -0.01055823f, -0.00126674f, 0.03553159f, -0.00811581f, -0.01524839f, 0.00630293f, 0.00512596f, 
    -0.02526639f, 0.02944061f, -0.02018333f, -0.04592731f, 0.02817259f, -0.05044373f, 0.00566738f, -0.03229847f, 
    0.03973018f, 0.02741895f, -0.02412244f, 0.02990637f, -0.04835895f, 0.04189445f, 0.04618858f, 0.02884971f, 
    -0.01470187f, -0.01239994f, 0.01289284f, -0.00604130f, -0.04809921f, -0.04188583f, -0.04684474f, -0.05525783f, 
    -0.00604560f, 0.03350331f, -0.02109500f, 0.00286627f, -0.04059976f, -0.00732619f, -0.03330324f, -0.05942799f, 
    -0.04089257f, 0.00482849f, -0.03430187f, 0.01369159f, 0.00927367f, 0.01033875f, 0.02178032f, 0.00907466f, 
    0.01185885f, -0.01640289f, -0.02326245f, -0.06234833f, 0.02486354f, -0.00503450f, 0.02569486f, -0.03927155f, 
    0.03407569f, -0.04318807f, 0.02625539f, -0.02580466f, 0.01749928f, 0.04445923f, -0.00768108f, -0.04584851f, 
    -0.02455634f, -0.05992996f, -0.04601014f, 0.01480450f, 0.00650284f, 0.04139205f, -0.00717619f, -0.06351613f, 
    0.01045575f, -0.01193828f, 0.03151831f, 0.03130904f, -0.04451711f, -0.05466659f, -0.01662199f, 0.00644849f, 
    -0.02734341f, 0.03556155f, 0.00494824f, -0.01502654f, 0.03264619f, -0.04515028f, -0.02886551f, 0.01007138f, 
    0.00134778f, -0.01277345f, -0.03558467f, -0.00331579f, -0.00076657f, -0.06048043f, -0.02625564f, -0.00833776f, 
    0.02061500f, -0.02073419f, -0.04046652f, 0.00894779f, -0.02634268f, 0.02159780f, 0.03701204f, 0.03726933f, 
    -0.06571802f, -0.02418823f, -0.02626700f, 0.03993199f, -0.04439846f, 0.02314947f, -0.02199640f, 0.00280547f, 
    0.01689724f, -0.00439431f, -0.05829661f, -0.01526390f, -0.04555067f, -0.01292483f, -0.04847816f, -0.04053733f, 
    -0.01276584f, 0.00644821f, -0.04776962f, -0.07192717f, 0.02743371f, -0.06385423f, -0.00466315f, -0.03906125f, 
    -0.01180873f, 0.02595888f, -0.01172321f, 0.03813874f, -0.05790768f, -0.04411217f, 0.02345685f, 0.01112447f, 
    0.01976515f, 0.00137310f, -0.01600284f, 0.00808341f, -0.03780494f, 0.03486764f, -0.01429517f, -0.01993828f, 
    0.04727387f, -0.04134510f, -0.00676071f, -0.04741900f, 0.00563258f, -0.04195569f, -0.04199072f, 0.01850814f, 
    0.00117551f, 0.01202331f, -0.03371071f, -0.02721047f, -0.01726355f, 0.01642975f, 0.03162777f, -0.02859082f, 
    -0.01570264f, -0.02276476f, 0.02915003f, 0.00638039f, 0.05042924f, -0.05809420f, 0.02677052f, -0.06053871f, 
    -0.00795624f, 0.02323289f, -0.02119314f, 0.00501970f, -0.00005528f, -0.01517758f, -0.05011883f, 0.00278848f, 
    0.02270535f, 0.02185897f, -0.00911279f, 0.02230096f, -0.03101972f, -0.03278811f, -0.00020818f, -0.06621429f, 
    0.02692962f, 0.00399928f, -0.00966620f, -0.06624239f, 0.01384167f, -0.03738023f, -0.01928899f, -0.04583680f, 
    0.00464851f, -0.04342353f, -0.03155182f, -0.04397177f, 0.00360090f, 0.03793275f, -0.02227219f, -0.00885660f, 
    0.00388325f, -0.06580326f, 0.00687826f, 0.00098990f, -0.00099157f, -0.03338826f, -0.03066803f, -0.00018114f, 
    0.01487228f, 0.01701615f, -0.04858411f, 0.02353884f, -0.05278220f, 0.03077432f, -0.02383543f, -0.01950401f, 
    -0.00147487f, -0.00918117f, -0.05083051f, 0.03487909f, 0.00373683f, 0.01228780f, 0.02649560f, 0.04549526f, 
    -0.03031383f, 0.05783841f, -0.03086551f, -0.00531281f, 0.00723780f, -0.02958861f, 0.00251082f, 0.01730532f, 
    0.02919051f, 0.02379436f, -0.04087884f, 0.03507165f, -0.01427125f, 0.02113628f, -0.02346597f, 0.03794613f, 
    -0.04166240f, 0.00618152f, 0.03630595f, -0.01675689f, -0.03018423f, 0.03128438f, 0.04460808f, -0.03577488f, 
    0.01187566f, -0.01492673f, -0.03708224f, -0.05757505f, -0.01870831f, -0.04575678f, 0.00177676f, 0.03512065f, 
    -0.02875860f, -0.04597679f, 0.04152840f, -0.02388103f, -0.06271706f, 0.02070770f, -0.03277614f, 0.00026376f, 
    0.00324838f, 0.00727837f, -0.04254583f, 0.02441938f, -0.03087184f, 0.05346571f, 0.04232889f, -0.00879693f, 
    -0.05883760f, -0.03341656f, 0.04680503f, -0.02636418f, 0.01798111f, -0.02014649f, 0.00468662f, -0.05647687f, 
    -0.01408423f, -0.04025738f, 0.03589801f, -0.04548924f, 0.02032504f, -0.00058911f, -0.02459122f, 0.00432914f, 
    -0.00002450f, 0.03849240f, -0.05359726f, 0.02490540f, -0.04974684f, -0.00334336f, 0.03829679f, -0.03102795f, 
    0.01547928f, -0.00697382f, -0.02938044f, 0.01675398f, -0.02356556f, 0.00386048f, -0.02065940f, -0.01476843f, 
    -0.04077934f, 0.03704266f, 0.01751575f, 0.03059701f, 0.00047620f, -0.02088147f, -0.04492138f, -0.03774917f, 
    -0.04493024f, 0.00918875f, 0.00002818f, 0.01729175f, -0.03243317f, 0.04063121f, 0.02159166f, -0.01566381f, 
    0.00674110f, -0.05351612f, 0.05627319f, 0.00887066f, 0.04050712f, -0.01436735f, 0.01556828f, 0.01192416f, 
    -0.03111037f, -0.05197209f, -0.00436229f, -0.02249032f, -0.04326961f, -0.01573803f, 0.03229888f, 0.01368183f, 
    -0.00519874f, 0.04044173f, 0.01480189f, -0.00394696f, 0.03002072f, -0.03858711f, -0.01270556f, 0.03238112f, 
    0.00023715f, 0.00973893f, -0.03509323f, -0.02913760f, 0.00275511f, 0.02109006f, -0.00175184f, 0.03163693f, 
    0.00704493f, 0.04179272f, 0.03196983f, -0.02793890f, -0.00915534f, 0.00798875f, -0.00793372f, -0.01022120f, 
    -0.00159225f, -0.02512422f, -0.05613784f, 0.02704750f, 0.00149462f, -0.04165812f, -0.02502310f, 0.01279274f, 
    0.00578792f, 0.04058646f, -0.06509529f, 0.03944569f, 0.01646762f, 0.02395861f, -0.05030783f, -0.06773794f, 
    0.04054300f, 0.02618471f, -0.01241105f, 0.02001048f, -0.07910249f, -0.00810486f, 0.01459629f, -0.05967565f, 
    -0.02449110f, -0.05921592f, -0.03965733f, 0.02789034f, 0.03320162f, -0.01047430f, -0.04494660f, -0.02622333f, 
    0.00751755f, -0.01418338f, -0.04268262f, -0.00445154f, 0.00663617f, -0.01961837f, 0.01299318f, 0.02954328f, 
    -0.04627208f, 0.03153864f, -0.01611278f, 0.04074122f, -0.06748668f, 0.03811365f, -0.05305790f, 0.00162352f, 
    0.03130201f, 0.03144945f, -0.02479725f, 0.01742983f, 0.03662677f, -0.03873178f, -0.01059856f, -0.03711946f, 
    0.01761388f, 0.02328459f, -0.02334730f, -0.02856683f, -0.04193505f, 0.03351440f, -0.05131155f, 0.01750498f, 
    0.01277940f, 0.01474962f, -0.00183632f, -0.00056758f, -0.02045077f, 0.01475853f, -0.00074556f, 0.01838628f, 
    -0.05256454f, -0.01476021f, 0.03260622f, -0.00111121f, -0.05636717f, -0.00041601f, 0.03046498f, -0.02531746f, 
    -0.03786038f, -0.01548644f, -0.05811581f, -0.03046928f, 0.04715893f, -0.03085275f, -0.04377091f, -0.04130496f, 
    -0.01938528f, -0.05242008f, -0.03106746f, -0.00692127f, 0.02179002f, 0.02467180f, -0.04365641f, -0.00265834f, 
    0.00297037f, -0.01902580f, -0.02933018f, 0.00047580f, -0.05199866f, 0.01404035f, 0.03201852f, -0.00667901f, 
    -0.04194871f, 0.00087894f, -0.01458254f, 0.01984252f, 0.04409847f, -0.03534877f, 0.01379286f, -0.01845303f, 
    0.02111447f, -0.02434580f, -0.00787196f, 0.01025933f, -0.03010481f, -0.03192949f, -0.00923601f, -0.05595075f, 
    0.04293614f, 0.02013278f, -0.02418924f, -0.02933103f, -0.00265664f, -0.05369221f, -0.03849141f, 0.00506519f, 
    -0.00288217f, 0.00194780f, -0.00715909f, -0.04352625f, -0.04730809f, 0.02548661f, 0.01807298f, -0.02043702f, 
    0.02122139f, 0.00255089f, -0.02307662f, -0.01865636f, 0.02542337f, -0.03053472f, 0.03374529f, -0.00272546f, 
    -0.01795472f, -0.01868811f, -0.03983912f, 0.01360885f, -0.03071432f, -0.04164771f, 0.03676658f, 0.01591506f, 
    0.03213073f, 0.03897151f, 0.01062949f, 0.00241629f, -0.02682299f, -0.00126174f, -0.04495747f, -0.03650033f, 
    -0.02560516f, -0.01872862f, -0.03907361f, -0.04074075f, -0.01582033f, -0.01461884f, 0.03758025f, 0.02752767f, 
    0.01114994f, -0.01826311f, -0.00929980f, 0.03941346f, 0.02899582f, 0.02997195f, 0.03521406f, -0.04390726f, 
    0.04006361f, 0.03773969f, 0.03840113f, 0.02705959f, -0.02532185f, 0.02098280f, -0.04276451f, -0.02811035f, 
    -0.02540603f, 0.00610269f, -0.05663773f, 0.03788643f, -0.02071345f, -0.01932520f, -0.02612319f, 0.02457156f, 
    0.04271251f, -0.00396312f, -0.00590478f, -0.00782386f, 0.01949292f, 0.00778037f, -0.04483866f, -0.05153564f, 
    -0.04232930f, 0.01732866f, -0.04906980f, -0.04695057f, 0.01118957f, 0.02846874f, -0.02237226f, 0.00674125f, 
    -0.04370782f, -0.02822067f, 0.04391302f, -0.04225899f, -0.02111170f, 0.00856824f, 0.03410465f, -0.04648156f, 
    -0.04306953f, -0.01295027f, 0.01596037f, -0.01690063f, 0.01014365f, -0.03603435f, 0.01625450f, -0.03811510f, 
    0.01411184f, 0.04475786f, 0.01958099f, -0.00758142f, -0.02700055f, -0.03335147f, -0.02627566f, -0.01404415f, 
    -0.04757918f, -0.00789240f, 0.03902908f, -0.04284480f, 0.03581251f, -0.02036940f, 0.02965222f, -0.04435835f, 
    -0.02271509f, 0.04674774f, -0.01496256f, 0.03863871f, -0.05008385f, 0.03117017f, 0.02725286f, -0.01649905f, 
    0.00562493f, -0.03893579f, -0.02368381f, 0.02748476f, -0.04668957f, 0.00703096f, -0.01875393f, -0.02269702f, 
    0.01290321f, -0.02309773f, 0.02398394f, 0.02077651f, -0.03573933f, -0.02569532f, -0.03582651f, -0.05847970f, 
    -0.03624070f, 0.04565177f, -0.03718930f, 0.03585289f, -0.00960077f, 0.02987721f, 0.02679304f, 0.01149768f, 
    0.03984996f, 0.02142057f, -0.00738060f, -0.04190402f, 0.01105834f, 0.01347409f, 0.01980711f, 0.01289118f, 
    0.03207101f, 0.02109702f, -0.02537897f, 0.03494090f, -0.01825279f, -0.00114448f, 0.00329525f, -0.00451286f, 
    0.03183364f, -0.04561354f, -0.01296756f, 0.03630842f, -0.03519975f, 0.00809583f, -0.00431174f, -0.05283738f, 
    -0.00776780f, -0.00860234f, 0.02498450f, -0.04617279f, 0.00428640f, -0.02070964f, -0.02145951f, -0.01129764f, 
    -0.00382825f, 0.03435774f, -0.01746936f, -0.05093938f, -0.04306453f, -0.05330504f, -0.03853808f, 0.02283234f, 
    -0.02090608f, 0.04136286f, 0.03315993f, 0.01465721f, -0.02473004f, 0.03598233f, -0.02102662f, -0.02309404f, 
    -0.04744847f, -0.00334502f, -0.02086599f, 0.03743083f, -0.05561355f, -0.02454791f, -0.04388982f, -0.00760746f, 
    -0.01349532f, -0.00662577f, -0.01143156f, -0.01341680f, 0.03584031f, -0.00335688f, -0.02218802f, -0.02026214f, 
    0.02883604f, 0.02030233f, 0.03192466f, -0.00821994f, 0.00978855f, -0.02410811f, 0.01810769f, -0.02243560f, 
    -0.03164322f, -0.04617112f, 0.02942356f, -0.04423515f, 0.03223029f, -0.01304871f, 0.04044116f, 0.02449008f, 
    -0.02368846f, 0.00037558f, -0.04382706f, -0.01968864f, -0.02116368f, 0.02100710f, -0.02433906f, 0.04414141f, 
    0.02936814f, 0.03751103f, -0.03609286f, 0.03557402f, 0.01720596f, 0.00725603f, 0.00822840f, -0.03181939f, 
    0.01599656f, -0.01151318f, 0.03056696f, -0.04500218f, 0.02850867f, 0.01754779f, -0.02625534f, 0.02422681f, 
    -0.01043939f, 0.03708280f, -0.03822372f, -0.00595051f, -0.01350149f, 0.00096259f, -0.02098132f, 0.04202327f, 
    -0.00633556f, 0.01072188f, -0.00827194f, -0.01960123f, 0.00415317f, -0.05815612f, 0.01152954f, 0.02683844f, 
    0.01045784f, -0.02580212f, -0.05765928f, 0.04213349f, 0.01935662f, -0.05262233f, -0.02829090f, -0.05138953f, 
    0.03792397f, 0.04351006f, -0.02609593f, -0.01911046f, -0.04006794f, 0.01700043f, -0.05716884f, 0.00902645f, 
    0.04065641f, -0.05054846f, -0.00405545f, 0.03107996f, -0.00414607f, -0.03500071f, 0.02593647f, -0.01175806f, 
    0.04237260f, 0.02095686f, -0.00494011f, 0.03949442f, -0.02004096f, -0.04452187f, -0.03741523f, 0.03658726f, 
    0.03721553f, 0.00158575f, -0.03149658f, -0.03853323f, -0.01844615f, -0.03977371f, 0.02271006f, -0.00230566f, 
    -0.03409658f, 0.03610589f, -0.03520913f, -0.04086215f, -0.00728827f, -0.04143862f, 0.02807217f, 0.04143247f, 
    -0.02932750f, -0.02686132f, -0.00698818f, 0.03748335f, -0.03065893f, -0.04145355f, -0.01849382f, -0.01990397f, 
    -0.05575335f, 0.00281633f, -0.04310930f, -0.05031348f, 0.00571888f, -0.04923104f, 0.00151243f, -0.02775815f, 
    0.04037990f, 0.03664405f, -0.00682193f, 0.00722029f, 0.00640389f, -0.01053159f, 0.03662956f, -0.03577330f, 
    -0.02167884f, -0.01833219f, 0.02841046f, 0.00697656f, 0.00815026f, -0.02833369f, 0.01298680f, 0.04022916f, 
    -0.02378978f, -0.02088326f, -0.01686274f, -0.01489802f, 0.03122301f, -0.01298999f, -0.04701699f, -0.03972393f, 
    0.02415180f, 0.04449438f, 0.00118567f, -0.00221837f, -0.04972809f, -0.04763449f, 0.03085352f, 0.00183701f, 
    -0.04896849f, -0.03276008f, -0.04211742f, -0.02441891f, -0.02881157f, 0.01439059f, -0.04954875f, -0.05038714f, 
    -0.00533382f, -0.02101641f, -0.03023198f, -0.03809135f, -0.05064385f, -0.04463110f, 0.03143957f, -0.03267816f, 
    -0.04847959f, -0.05998207f, 0.02521767f, -0.03165011f, 0.03706126f, -0.04435431f, -0.00626002f, 0.01620591f, 
    -0.04860805f, 0.00967722f, 0.00266651f, 0.03116871f, 0.02759269f, -0.05846340f, -0.04307941f, 0.01768891f, 
    -0.02946688f, -0.01204602f, -0.01602030f, 0.00516923f, 0.01824778f, 0.01821149f, -0.01663418f, 0.01042750f, 
    -0.04544552f, -0.04995920f, 0.03552495f, 0.00220408f, -0.01041976f, 0.03868045f, 0.03711374f, -0.00477697f, 
    -0.00504877f, -0.03276706f, 0.02225803f, 0.00868273f, -0.01382949f, -0.04209163f, 0.02323118f, -0.04004948f, 
    -0.00804276f, 0.03520899f, 0.00395536f, 0.03657031f, 0.03348630f, 0.00129218f, -0.03737670f, -0.03118718f, 
    -0.04401339f, 0.01357446f, 0.03995325f, -0.02715576f, -0.03168090f, 0.00711408f, -0.04468258f, 0.00456153f, 
    -0.00614380f, -0.01041876f, 0.01816495f, 0.03428932f, -0.01153927f, -0.02088276f, -0.03196068f, 0.03239123f, 
    -0.02150185f, 0.03743877f, 0.01522247f, 0.02006787f, -0.05850640f, 0.03470270f, -0.03552294f, 0.04230685f, 
    -0.03330515f, 0.00896259f, -0.00813618f, -0.03794487f, 0.02219788f, -0.00616981f, 0.01428419f, -0.00239262f, 
    0.01542472f, -0.02758825f, 0.02957365f, 0.04066934f, -0.00580052f, -0.01356402f, 0.03890051f, -0.03881212f, 
    -0.04415580f, -0.04330706f, 0.00310215f, 0.02501623f, -0.00596113f, -0.04757177f, 0.03627175f, -0.02255222f, 
    -0.01912046f, -0.00245808f, -0.02479106f, -0.01792181f, -0.00638323f, -0.01749331f, -0.03458509f, 0.02355916f, 
    0.01767329f, 0.01406661f, 0.01643831f, -0.01799147f, -0.01015646f, -0.03553052f, 0.01288547f, -0.02194532f, 
    0.04042880f, -0.01917895f, -0.01229658f, 0.03701130f, -0.05083251f, -0.04270329f, 0.01903242f, 0.03598278f, 
    -0.03766367f, 0.01922631f, 0.01098850f, -0.04877304f, -0.04871463f, 0.01053328f, -0.01656461f, 0.02598567f, 
    0.01115528f, -0.05628955f, -0.02362239f, -0.03373230f, -0.04541261f, -0.04314474f, 0.00416967f, -0.00962461f, 
    0.01637356f, -0.04248729f, 0.04157300f, 0.01972932f, -0.05743742f, 0.00681468f, -0.03983486f, -0.01316521f, 
    -0.05004694f, 0.01366362f, 0.03650447f, -0.02134991f, 0.00704144f, -0.05629246f, 0.00250589f, 0.00782926f, 
    -0.03275859f, -0.04448854f, -0.04134129f, -0.01846724f, 0.02505181f, -0.03552395f, -0.01670618f, -0.05405059f, 
    -0.00151951f, -0.00300391f, -0.01594957f, -0.02599034f, 0.01383361f, 0.02294361f, -0.04664052f, 0.03772140f, 
    -0.02740863f, -0.04963349f, 0.01540996f, -0.02792926f, -0.00952636f, 0.05364118f, 0.01987538f, -0.02350938f, 
    0.04259046f, -0.05007640f, -0.00459992f, -0.03015621f, -0.05415142f, -0.04783947f, 0.02809769f, 0.02027438f, 
    -0.02831474f, 0.00793376f, 0.02159161f, -0.04512037f, -0.00761757f, 0.03312735f, 0.01415432f, 0.02514917f, 
    -0.02628605f, -0.02562306f, 0.03466609f, -0.00164030f, 0.02047366f, 0.00848714f, 0.01053210f, -0.01039962f, 
    0.03408932f, -0.01809088f, 0.00506799f, 0.03604801f, -0.05766699f, -0.01392437f, -0.00764622f, 0.00217850f, 
    -0.04012109f, -0.00920160f, -0.04822032f, 0.02038065f, 0.01387793f, -0.02888917f, 0.00673636f, -0.01735728f, 
    0.03462842f, -0.04311516f, -0.00978878f, -0.04023318f, 0.01301063f, 0.03623484f, -0.04470867f, 0.02684079f, 
    -0.03085587f, -0.00773717f, -0.04477262f, 0.00457578f, 0.02576806f, 0.03045898f, 0.02817987f, 0.02619955f, 
    -0.01912511f, -0.00660932f, -0.02064340f, 0.02296676f, 0.03254697f, -0.03149186f, -0.04248353f, 0.00825244f, 
    -0.01977071f, 0.00862213f, 0.00270912f, 0.03352014f, 0.04576281f, -0.01438401f, 0.02306433f, 0.03620643f, 
    -0.03998175f, -0.04518275f, -0.01937176f, 0.00136437f, -0.01606745f, -0.02186992f, 0.01094895f, -0.01566504f, 
    -0.04713599f, 0.02425605f, -0.05270775f, -0.05065530f, -0.02464944f, -0.05303524f, 0.03971125f, -0.05448332f, 
    0.03430123f, 0.04143279f, -0.02668716f, -0.02612908f, -0.02421691f, -0.00752341f, -0.03778382f, 0.03783750f, 
    -0.02561293f, -0.03040048f, -0.00393842f, -0.04313113f, -0.02387147f, -0.03827061f, 0.00940855f, 0.00929597f, 
    0.02908912f, 0.02117231f, -0.02794804f, -0.00782020f, 0.03783362f, -0.02558042f, 0.02851794f, 0.02380623f, 
    -0.03647292f, -0.00200147f, 0.03408294f, 0.02276529f, -0.01511547f, 0.04270755f, -0.01226904f, -0.05172052f, 
    -0.03202603f, 0.01485925f, -0.00035591f, -0.03750798f, -0.02712775f, 0.01539916f, 0.01570907f, -0.00311759f, 
    -0.02108283f, 0.03939349f, 0.00005728f, 0.00939987f, -0.02398618f, -0.02919848f, 0.01102262f, 0.00432982f, 
    0.03900418f, -0.03605236f, 0.02894087f, 0.03779310f, 0.03513336f, -0.00166609f, -0.02660973f, -0.01321727f, 
    -0.03713986f, -0.01437907f, 0.04222067f, -0.03297435f, 0.01122308f, 0.04549780f, 0.00910956f, -0.03864723f, 
    0.03511834f, 0.04712869f, -0.05153687f, 0.01914297f, 0.03355416f, -0.00859502f, 0.02561719f, -0.03800870f, 
    -0.05185893f, -0.04776704f, -0.05422679f, 0.03618244f, 0.02445076f, 0.03060723f, 0.04483856f, 0.04477613f, 
    0.01580475f, 0.04520436f, 0.02239210f, 0.01970343f, -0.01807981f, -0.03685232f, 0.00031452f, -0.05675388f, 
    -0.05676111f, -0.01434047f, -0.04922385f, -0.03874520f, -0.02639955f, 0.03760065f, -0.00584223f, -0.01075025f, 
    0.02468559f, 0.02126493f, 0.04293156f, 0.04088140f, -0.04864033f, 0.02023658f, 0.02413148f, 0.03465289f, 
    -0.03029379f, 0.01994953f, -0.05445018f, -0.01583561f, 0.01824439f, -0.04146339f, -0.01985735f, 0.02204742f, 
    -0.01344632f, -0.01287829f, -0.01284267f, 0.00490761f, -0.04679086f, 0.00423157f, -0.04166062f, 0.03192150f, 
    -0.04631810f, -0.02875466f, 0.00844872f, -0.02318951f, 0.02949656f, -0.03594686f, -0.03878934f, -0.01117835f, 
    -0.02355993f, 0.00306278f, -0.05417166f, 0.00307497f, -0.04462357f, -0.03445356f, 0.02900130f, -0.02579769f, 
    -0.02680931f, -0.03180686f, -0.04314350f, 0.00628563f, -0.03370432f, -0.01267810f, -0.04424584f, -0.03193458f, 
    -0.00278951f, -0.03985704f, -0.04928680f, 0.01685320f, 0.04172463f, -0.00946831f, -0.05098897f, 0.01572906f, 
    -0.03489245f, -0.05384371f, -0.03599141f, 0.00013959f, 0.03990446f, -0.04038394f, -0.01299010f, 0.03343192f, 
    0.02651833f, -0.05272318f, 0.02933440f, 0.02340874f, -0.00156715f, -0.01200153f, -0.02539803f, 0.03135514f, 
    -0.03489666f, 0.00354875f, -0.01812092f, -0.04766646f, -0.01473285f, 0.02200563f, -0.04290505f, -0.03089093f, 
    -0.04274744f, -0.03801033f, 0.02673694f, -0.02943246f, -0.02317971f, -0.02060019f, -0.04290798f, -0.03613584f, 
    -0.01795465f, 0.01130089f, -0.02566674f, -0.00563327f, -0.04058070f, 0.01500683f, -0.00339928f, 0.00605071f, 
    -0.01363781f, -0.00937041f, 0.01764599f, 0.01389032f, 0.03235357f, 0.01807569f, -0.01293995f, -0.01395576f, 
    0.03310171f, 0.02562159f, 0.00589600f, -0.01961398f, 0.03617407f, 0.01375184f, 0.04870870f, 0.02533567f, 
    0.02798535f, -0.03695008f, -0.00134897f, 0.01829403f, -0.03615521f, -0.02014332f, -0.02714119f, 0.03978848f, 
    0.02957864f, 0.01548044f, -0.00394473f, 0.00557288f, -0.04504120f, -0.01225875f, 0.04593967f, 0.04059306f, 
    -0.04706368f, 0.00719860f, 0.05097463f, -0.01881526f, 0.04670299f, 0.02965586f, -0.01332733f, -0.01723006f, 
    -0.01558207f, -0.01282084f, -0.05628436f, -0.00398860f, 0.05063388f, 0.01955206f, 0.03032476f, 0.01281351f, 
    -0.02866595f, -0.04992536f, 0.04123672f, -0.00841955f, -0.03759848f, 0.02445766f, -0.03214744f, 0.02006565f, 
    -0.05051729f, 0.04225632f, 0.03872351f, -0.03032255f, -0.03542674f, -0.02787574f, 0.03765152f, -0.04719789f, 
    0.00098035f, -0.00409189f, -0.03838263f, -0.03393392f, -0.04952240f, -0.04844734f, -0.00108888f, 0.03765345f, 
    -0.03520692f, -0.02683131f, 0.04027179f, -0.05281129f, -0.03920745f, 0.00633142f, 0.02341113f, -0.00155540f, 
    0.03287890f, -0.00846969f, 0.04520331f, 0.04229390f, -0.00176449f, -0.04732590f, 0.03671364f, -0.02041082f, 
    -0.03008733f, 0.03552175f, -0.03334366f, 0.04452815f, -0.01857969f, 0.03972984f, 0.00622400f, -0.03249650f, 
    0.02686826f, 0.01853059f, 0.01209002f, 0.01869150f, 0.02149345f, 0.00231210f, -0.00610524f, 0.00638101f, 
    0.02440435f, 0.02247707f, 0.02805820f, -0.04036509f, 0.03975460f, -0.01659665f, 0.02747439f, 0.04337657f, 
    0.04927250f, -0.02447796f, -0.00005469f, -0.02186559f, 0.04941818f, 0.00458187f, -0.03804270f, -0.01125323f, 
    -0.04101806f, -0.03540564f, 0.00535035f, -0.02455424f, -0.04560675f, -0.02338875f, -0.04606487f, 0.01007508f, 
    -0.00179131f, -0.00081492f, 0.04608774f, 0.01939125f, -0.01956711f, 0.02249421f, 0.02296587f, -0.02236821f, 
    0.00385235f, 0.00105172f, -0.01612935f, -0.03215102f, -0.00340104f, -0.00222606f, -0.04738318f, -0.01644359f, 
    0.01020903f, -0.00595743f, -0.04637621f, -0.05323353f, 0.03018409f, 0.01581632f, -0.02778766f, 0.03071314f, 
    0.04509234f, 0.01719306f, -0.04251913f, 0.04090674f, 0.03454134f, -0.01625677f, 0.03657775f, 0.01663034f, 
    0.00980446f, -0.00582713f, 0.00700901f, 0.00368487f, -0.05607430f, -0.03920773f, -0.00007855f, 0.03369924f, 
    -0.05165312f, 0.00183368f, 0.00398616f, -0.04723278f, 0.02105711f, 0.01401366f, -0.04700376f, -0.00007044f, 
    -0.00786196f, 0.00670923f, -0.00924124f, 0.02289025f, -0.04064059f, -0.01986606f, 0.04005537f, -0.01664881f, 
    0.04513264f, 0.00068011f, -0.03314041f, -0.02875987f, -0.03321044f, 0.04684984f, -0.04754917f, 0.01789377f, 
    -0.04896612f, -0.00254452f, 0.00399582f, -0.00768899f, -0.02349348f, -0.03871911f, -0.03137578f, -0.00018185f, 
    -0.01015504f, 0.00281351f, -0.01148837f, -0.03917923f, 0.02976034f, 0.02760221f, 0.04519192f, -0.00279943f, 
    -0.04201620f, -0.00835720f, -0.02605847f, -0.01898634f, -0.04638978f, 0.01747678f, -0.02075094f, 0.01486879f, 
    -0.03766257f, 0.02621875f, -0.03217566f, 0.03783274f, 0.02433602f, 0.02044754f, -0.02328793f, -0.00987879f, 
    -0.00043755f, -0.04832568f, 0.03270613f, -0.02394598f, 0.00349877f, -0.02204951f, -0.03055874f, -0.03773571f, 
    -0.01419430f, 0.04105383f, -0.04881275f, 0.02822901f, 0.03625286f, 0.02892722f, 0.04097607f, -0.00106029f, 
    0.04018668f, -0.03848205f, -0.00800665f, 0.01907587f, -0.00223492f, -0.03826303f, -0.01951642f, 0.02443063f, 
    0.04250511f, -0.03394097f, -0.01735401f, 0.01308570f, -0.15925172f, -0.12067086f, 0.05260078f, 0.00606774f, 
    0.05463624f, 0.07212341f, -0.08920738f, 0.00827048f, 0.11878907f, 0.09810692f, -0.03016925f, -0.07914313f, 
    0.07789712f, 0.17345402f, -0.04812758f, 0.04294375f, 0.03126666f, 0.05764328f, 0.00326272f, 0.10985144f, 
    -0.34660602f, -0.16397657f, -0.00940290f, -0.02944986f, 0.14587843f, 0.00175761f, -0.10863154f, 0.15131120f, 
    0.06809478f, 0.00485992f, 0.12178715f, -0.00530857f, 0.09447878f, -0.02669545f, -0.18574747f, -0.01183023f, 
    -0.09036870f, 0.09736132f, 0.03437988f, 0.02414941f, 0.00248824f, -0.03547689f, -0.03057892f, 0.04138909f, 
    0.21668966f, -0.05871411f, 0.13739519f, 0.07265520f, 0.10688914f, 0.03218399f, 0.00389281f, -0.01829885f, 
    0.00825337f, 0.01908701f, 0.06229357f, 0.09750274f, 0.06203738f, 0.00721826f, -0.05167333f, -0.06307648f, 
    0.28765509f, 0.08786704f, 0.06411856f, -0.03384817f, 0.05625502f, 0.13637246f, 0.04768079f, -0.01572669f, 
    0.03964738f, -0.11121015f, 0.05644342f, 0.07635034f, -0.02635261f, -0.04699582f, -0.07229631f, -0.04683990f, 
    0.11717825f, 0.03928799f, -0.00209628f, -0.05910387f, 0.04747071f, 0.08449432f, 0.05243853f, -0.02663302f, 
    0.13890617f, -0.04617794f, -0.03187566f, 0.08768733f, 0.00199289f, -0.00513358f, -0.01176230f, -0.01352309f, 
    -0.18008260f, -0.09412033f, -0.14067516f, -0.09763867f, 0.04735599f, -0.07496308f, -0.04976632f, 0.05374335f, 
    0.10759274f, 0.06890635f, 0.05473192f, 0.13499273f, -0.05504600f, -0.00544623f, 0.09591389f, -0.01642546f, 
    -0.08506392f, -0.16355635f, -0.00904269f, 0.06092855f, 0.08772662f, -0.00323494f, -0.04721835f, 0.10277529f, 
    0.17196873f, 0.05325475f, -0.14963777f, 0.05159050f, 0.00537218f, -0.08505473f, 0.00373565f, 0.08734294f, 
    0.04528533f, 0.01217615f, 0.10169118f, 0.09522549f, -0.14599764f, 0.07683971f, 0.12451296f, 0.07449473f, 
    0.07186866f, -0.08128031f, -0.08395772f, 0.06129859f, 0.10388705f, -0.02088579f, 0.10909530f, 0.09830122f, 
    0.36795738f, -0.40286976f, 0.08052298f, 0.09157047f, 0.00082261f, -0.05155548f, -0.05926701f, 0.19743006f, 
    -0.00291235f, -0.05424606f, 0.01642940f, 0.11396728f, -0.25305292f, 0.11279825f, 0.00223169f, 0.08144625f, 
    0.05600240f, -0.02049045f, -0.04101514f, -0.01164294f, 0.00665161f, 0.06674981f, 0.02963309f, 0.00483441f, 
    -0.39356023f, -0.15753835f, 0.15419993f, -0.12777038f, 0.00879228f, -0.07054392f, -0.01243817f, -0.06826188f, 
    -0.00316521f, 0.03424888f, 0.04635499f, -0.05383086f, 0.27931243f, -0.11051330f, 0.17191298f, -0.07214236f, 
    -0.02835297f, -0.09732794f, 0.05822660f, -0.12361947f, -0.03054370f, 0.06323539f, 0.04995285f, 0.05785931f, 
    0.06958817f, 0.04517990f, -0.05596764f, -0.09876447f, 0.19455387f, -0.00358345f, 0.02525057f, 0.02367036f, 
    0.02335308f, 0.03312775f, 0.19033541f, 0.03482209f, 0.00949644f, 0.12468612f, 0.07836941f, -0.09246050f, 
    -0.08404494f, 0.05378347f, 0.06717838f, -0.07046301f, 0.02517245f, 0.01551406f, 0.10132810f, -0.00536061f, 
    0.05724360f, 0.07088764f, -0.00662650f, 0.11452560f, 0.04844128f, -0.01438266f, 0.11425212f, 0.06258244f, 
    0.01211178f, -0.03919115f, -0.07771870f, -0.07389306f, 0.18616493f, 0.04027433f, -0.07001025f, -0.15420081f, 
    -0.02003268f, 0.05821623f, 0.11156645f, 0.03140514f, 0.04190376f, 0.04712337f, 0.01081751f, -0.01738852f, 
    0.15720293f, -0.14304838f, -0.08868092f, 0.19650249f, -0.06928669f, 0.02878551f, -0.05140628f, 0.07612492f, 
    -0.11967386f, 0.01428441f, -0.00961968f, -0.00286208f, 0.06506556f, -0.07375208f, 0.01948610f, -0.11721688f, 
    0.08434258f, -0.00117951f, -0.09506707f, 0.01844821f, -0.02336621f, 0.01502844f, -0.08044194f, -0.10788430f, 
    -0.01896660f, -0.16595137f, -0.06108401f, -0.17160924f, 0.06845453f, 0.03656435f, 0.01535600f, 0.00810499f, 
    0.04843326f, -0.11031240f, 0.03677057f, 0.00168016f, 0.17057364f, 0.00823253f, -0.03309483f, 0.05099336f, 
    0.06958087f, -0.03625912f, 0.11839840f, 0.02791636f, -0.04021729f, 0.09259963f, -0.00172075f, 0.07907411f, 
    0.27299595f, 0.13600901f, -0.24521188f, -0.06810071f, 0.10085561f, 0.02306428f, 0.02315870f, 0.06362640f, 
    0.16280897f, 0.09249542f, 0.05158172f, 0.01441329f, -0.30492327f, 0.17922007f, 0.07446056f, 0.05635761f, 
    -0.12062969f, 0.17868704f, -0.02056164f, -0.04474733f, 0.22200014f, 0.02443081f, -0.01526721f, -0.01765470f, 
    -0.01175659f, 0.06809898f, 0.05658349f, 0.02638344f, 0.16122495f, -0.01086011f, 0.02945305f, 0.01318989f, 
    -0.02844015f, 0.04904990f, 0.03052438f, 0.05007355f, 0.08006380f, 0.08414296f, -0.16308711f, -0.23688734f, 
    0.14437895f, 0.04048061f, -0.10489883f, -0.00870056f, 0.13975276f, 0.11835538f, 0.01614044f, -0.02881193f, 
    -0.03630441f, -0.05552311f, 0.11004040f, -0.06684455f, 0.14900249f, -0.06968462f, -0.09776440f, -0.10060477f, 
    0.19190025f, 0.04501610f, -0.03906838f, -0.08868293f, 0.00757419f, 0.04500983f, 0.04089664f, -0.14095305f, 
    -0.10153119f, -0.01024929f, 0.11741380f, -0.04317310f, -0.10444111f, 0.04096864f, 0.02741154f, -0.07068565f, 
    -0.08734612f, -0.02824751f, -0.09802134f, 0.06546582f, 0.11363249f, -0.03898283f, 0.02739555f, 0.00956795f, 
    0.02212396f, -0.16005808f, 0.02283954f, 0.10889904f, 0.10285977f, -0.03964543f, 0.03745038f, -0.25504681f, 
    -0.06017977f, -0.05108448f, -0.01481578f, 0.01591640f, -0.05837749f, -0.04108655f, 0.00086304f, 0.05572924f, 
    0.10805597f, 0.22879860f, -0.24754155f, -0.13025689f, 0.01870404f, -0.01295476f, 0.07087276f, -0.04685901f, 
    0.06587579f, 0.01339962f, -0.00338912f, -0.24594778f, 0.00985001f, -0.16233438f, -0.01798035f, 0.08253781f, 
    -0.00677264f, -0.08610335f, -0.03588777f, 0.09561397f, -0.02112788f, -0.03870896f, -0.06216349f, 0.16104071f, 
    -0.28380615f, -0.32346186f, 0.26864415f, 0.26041618f, -0.05567627f, 0.08942532f, -0.06299826f, -0.01006425f, 
    -0.02123204f, -0.08911944f, 0.08978686f, -0.02069005f, -0.30610099f, -0.15249194f, -0.02800701f, -0.22724931f, 
    0.04177484f, 0.00669512f, -0.04810145f, -0.06154454f, 0.08081169f, -0.07595412f, -0.07814235f, -0.09091290f, 
    -0.35623327f, 0.06164359f, 0.06414393f, 0.03325929f, 0.09120112f, 0.07843480f, 0.02300690f, 0.05136395f, 
    -0.02834272f, 0.08576298f, -0.05375590f, 0.04992917f, 0.28611955f, -0.06680924f, -0.07964329f, 0.06221668f, 
    0.07789270f, 0.00965639f, 0.02699963f, -0.04407223f, -0.05176343f, -0.20381600f, 0.17285602f, 0.02153122f, 
    -0.04046889f, 0.02764673f, 0.00090239f, -0.01298541f, 0.03796035f, 0.08360890f, -0.00851015f, -0.05207986f, 
    -0.04320582f, -0.02841594f, -0.02497407f, -0.11117443f, -0.01534685f, 0.00815858f, 0.03906228f, -0.11765403f, 
    0.11631983f, -0.11955185f, 0.01292881f, 0.04573945f, -0.02668109f, -0.05730481f, 0.19436771f, 0.12408734f, 
    0.12652226f, -0.12256462f, 0.02143935f, -0.10344668f, 0.19252512f, 0.06431447f, 0.03973671f, 0.04877997f, 
    0.00403266f, -0.02893581f, -0.06968809f, 0.03450749f, 0.03987230f, 0.14386141f, 0.02965225f, -0.02430144f, 
    0.10383923f, -0.02571735f, 0.07660741f, -0.06166847f, 0.00922314f, 0.03999856f, 0.03702103f, 0.07553960f, 
    -0.11374750f, -0.03494945f, 0.04115114f, 0.04733096f, 0.09142315f, -0.03940603f, -0.02905709f, 0.00585633f, 
    -0.03994991f, 0.09888849f, 0.00537344f, 0.06543721f, 0.09844752f, 0.21949270f, 0.17468366f, 0.00226574f, 
    0.02624828f, -0.03437702f, 0.00135254f, 0.05336674f, 0.00443720f, 0.09702949f, -0.01679168f, 0.03714938f, 
    -0.00522246f, 0.09796827f, 0.10718665f, -0.03034348f, 0.12424327f, -0.05960423f, -0.02596296f, -0.09485950f, 
    -0.09129862f, -0.14495142f, 0.15618828f, 0.04436561f, 0.21806143f, -0.06646200f, 0.00841957f, 0.10189059f, 
    0.13196072f, -0.03553103f, -0.01023324f, -0.12930954f, -0.04212369f, -0.02620696f, -0.02421104f, 0.06185506f, 
    -0.20225188f, 0.01091408f, -0.06525276f, 0.06128940f, 0.07582398f, -0.19369909f, 0.01613329f, -0.08771806f, 
    0.02781545f, 0.14378844f, 0.15406989f, 0.13882273f, -0.23735553f, -0.05958348f, 0.03326689f, 0.08095811f, 
    0.12942356f, -0.02203657f, -0.07040016f, 0.07145600f, 0.05279509f, 0.19216949f, -0.01523964f, -0.02216384f, 
    0.38187978f, 0.03506735f, 0.12127753f, 0.16721393f, 0.13608928f, -0.09417446f, 0.02073714f, 0.18229856f, 
    0.11267630f, -0.00455899f, 0.03695108f, 0.17312881f, -0.08454867f, -0.08369718f, 0.08647940f, 0.02383118f, 
    0.09168892f, 0.11718777f, 0.10559238f, -0.05591633f, 0.03243553f, -0.01717767f, 0.02517556f, -0.04086966f, 
    0.18094309f, 0.07077131f, 0.01362742f, 0.06772603f, 0.12475946f, 0.02573148f, -0.06482062f, 0.08331310f, 
    -0.03317890f, 0.01135910f, 0.00683142f, 0.03027490f, -0.25458804f, 0.02830993f, 0.01926183f, 0.02047091f, 
    0.14767705f, -0.03352196f, -0.04900502f, 0.01602493f, 0.03080757f, -0.08197067f, 0.09658749f, -0.00709104f, 
    -0.27210763f, -0.24680497f, -0.05551472f, -0.03254244f, 0.01716487f, 0.11719856f, 0.03688662f, 0.03835659f, 
    0.05116628f, -0.03947950f, 0.08018868f, -0.06206569f, 0.13765323f, -0.05910938f, 0.00928677f, -0.06633043f, 
    0.02798161f, -0.01341323f, 0.07837426f, -0.08351090f, 0.00572513f, -0.06812365f, -0.03228028f, -0.02275496f, 
    0.00669720f, -0.19637220f, -0.14026329f, 0.02718780f, 0.14976427f, -0.07832300f, -0.02218663f, -0.16745004f, 
    0.10920799f, 0.03044082f, -0.10511599f, -0.06511580f, -0.41993585f, 0.05487251f, -0.09560050f, -0.04192007f, 
    0.08382427f, 0.04631051f, 0.04420886f, 0.01999105f, -0.00024571f, 0.06069491f, -0.05018006f, -0.01026081f, 
    0.10125658f, 0.11407027f, 0.03420179f, 0.26316249f, 0.00687126f, -0.07022209f, 0.00752712f, 0.14191352f, 
    0.12934686f, 0.04236134f, 0.06140249f, 0.11831944f, 0.18964852f, 0.26368296f, 0.12256031f, -0.07611343f, 
    0.02840497f, -0.01549787f, -0.20338105f, 0.08095382f, 0.11842260f, -0.03258636f, 0.03523108f, 0.03377351f, 
    0.40479061f, 0.11979283f, 0.04786353f, -0.00237196f, 0.05777118f, -0.00999213f, -0.05744648f, -0.01181447f, 
    0.02924900f, 0.04088676f, -0.00855186f, 0.00467777f, 0.14521150f, -0.04630213f, -0.19666566f, 0.14019002f, 
    0.02879008f, 0.08581702f, 0.04092011f, 0.12074349f, 0.00067265f, 0.03807081f, -0.03381356f, 0.07675871f, 
    0.01592182f, 0.00652883f, 0.02825133f, 0.08728818f, 0.06800891f, -0.02580576f, -0.14272079f, 0.00838733f, 
    -0.01225626f, 0.04737106f, 0.09915131f, 0.02596241f, -0.00557646f, -0.07370898f, -0.05417281f, -0.09529477f, 
    -0.00728938f, -0.02992981f, 0.06843861f, -0.10137332f, 0.04105916f, 0.01137980f, 0.10733495f, 0.01576936f, 
    0.00145928f, 0.16150409f, -0.02148099f, -0.18099192f, 0.10884525f, -0.03757055f, 0.05780327f, -0.15808660f, 
    0.02364018f, -0.15795696f, -0.08372515f, 0.07413952f, 0.04748084f, 0.03349578f, 0.05669223f, -0.16217044f, 
    0.00352965f, 0.05985550f, -0.17404221f, -0.09099736f, -0.00199008f, 0.02401493f, 0.00516482f, 0.11485665f, 
    -0.00863765f, 0.00439131f, -0.02511897f, -0.05361349f, -0.05517045f, 0.00975453f, -0.05024740f, -0.02137237f, 
    0.03857807f, -0.05348721f, -0.00828654f, 0.03134423f, -0.03408817f, -0.04263332f, 0.04312582f, -0.01542707f, 
    -0.00838696f, -0.01574104f, 0.00356341f, -0.00579461f, -0.01871908f, -0.04868093f, -0.04406933f, 0.01932345f, 
    0.02296250f, -0.00222229f, -0.02166414f, -0.05557735f, -0.02751607f, 0.00684137f, -0.00995588f, -0.01507280f, 
    -0.04302587f, -0.00603717f, -0.03499811f, 0.04178448f, 0.01756722f, -0.00289303f, 0.03446910f, -0.00815797f, 
    0.01086998f, -0.02187637f, -0.00766537f, -0.01055211f, -0.03255933f, 0.00094149f, -0.01250565f, -0.05331533f, 
    0.04719989f, -0.05384562f, -0.05224308f, -0.02729874f, -0.05554968f, 0.01416325f, -0.01919527f, -0.01575894f, 
    0.03687538f, 0.02508694f, -0.03682034f, 0.02639499f, -0.03577561f, -0.03205010f, -0.02614795f, -0.01502331f, 
    -0.04578907f, 0.00554887f, -0.02059089f, -0.02990079f, -0.03423813f, -0.02113384f, -0.00475299f, -0.00192417f, 
    -0.05718621f, -0.00403279f, 0.03816439f, -0.03037188f, -0.03181436f, 0.03608795f, -0.05491467f, -0.02694681f, 
    -0.03405220f, -0.04184871f, -0.02439249f, -0.05853452f, 0.03917802f, -0.05707981f, -0.00498319f, 0.02368321f, 
    0.01924101f, -0.05656340f, -0.02529807f, -0.03653085f, 0.01793538f, -0.02704506f, -0.05792788f, -0.03096294f, 
    -0.04541647f, 0.02604800f, -0.00832433f, -0.03639560f, -0.00657690f, -0.02885970f, -0.02791965f, -0.03543242f, 
    0.04206492f, -0.01759216f, 0.02741127f, -0.00610664f, 0.02513148f, 0.02304716f, -0.00654629f, -0.04957196f, 
    0.00656526f, -0.02787622f, 0.03820167f, -0.01840957f, 0.02222092f, -0.01158222f, -0.03632630f, 0.02539955f, 
    -0.03964933f, 0.04053966f, -0.00964609f, -0.04920923f, -0.02989834f, -0.05018489f, -0.04885093f, 0.00919453f, 
    -0.04067417f, 0.04107869f, 0.03476851f, 0.01141444f, -0.01277922f, -0.04837878f, 0.00767296f, 0.01441893f, 
    0.00672090f, -0.04363466f, -0.04468799f, 0.00573390f, -0.01500082f, -0.00704981f, 0.04091194f, -0.05310905f, 
    0.02922101f, -0.04071405f, 0.00573689f, 0.00256624f, -0.01513828f, 0.03686359f, 0.00188592f, -0.02174158f, 
    0.01245671f, -0.03570626f, -0.00572461f, 0.00012649f, 0.03517994f, -0.01985852f, -0.04379404f, 0.02872917f, 
    0.00941160f, 0.02391741f, -0.04181819f, 0.04157006f, 0.01979482f, 0.03273486f, 0.00096447f, -0.05016074f, 
    -0.05685445f, 0.02760872f, -0.02612709f, 0.03908681f, 0.00431888f, -0.05735615f, -0.04010775f, -0.02493308f, 
    0.00999757f, -0.05112215f, -0.03328856f, 0.03407856f, -0.00732606f, 0.03074348f, -0.00649871f, 0.03763679f, 
    0.02418212f, -0.04079831f, 0.03968952f, 0.02406181f, -0.04842521f, -0.00730232f, 0.01564695f, -0.03712707f, 
    -0.01312079f, 0.00636874f, -0.05472781f, -0.04974806f, -0.02824552f, 0.01524231f, 0.00360777f, 0.03816388f, 
    0.00765899f, 0.00375728f, -0.00243900f, -0.00546437f, -0.01038033f, 0.03771763f, -0.03473089f, -0.00487186f, 
    -0.01810438f, 0.02851995f, 0.03187143f, 0.00113266f, 0.00434344f, 0.03796591f, -0.04307896f, -0.01246998f, 
    -0.04054450f, 0.03500478f, 0.03287726f, 0.02660692f, -0.02662348f, 0.04180656f, -0.00090676f, -0.00696070f, 
    0.01992798f, -0.01319447f, 0.03492740f, 0.03008734f, -0.05738471f, -0.01805513f, 0.03812137f, 0.02051493f, 
    0.03231659f, -0.02410223f, -0.02658893f, 0.04341540f, -0.03218561f, 0.00834478f, -0.01523983f, -0.00297447f, 
    -0.00836742f, 0.00275458f, 0.03103304f, -0.05501927f, 0.00772892f, 0.03359228f, 0.03377064f, 0.03274359f, 
    -0.03724930f, -0.01617068f, 0.01170090f, 0.03825675f, -0.02854330f, 0.02797928f, -0.03273898f, -0.04468343f, 
    -0.05687545f, -0.01632909f, -0.00312290f, -0.02444963f, 0.02059528f, -0.03586981f, -0.04325537f, -0.02956284f, 
    -0.04511217f, -0.05545104f, 0.05126240f, 0.01911002f, -0.04178775f, 0.00227386f, -0.02471701f, -0.05025622f, 
    0.01712625f, 0.02301094f, -0.01374961f, 0.03590984f, 0.02199863f, 0.01874373f, 0.02074448f, -0.04471819f, 
    0.03431025f, 0.01118333f, 0.00744940f, -0.01914668f, -0.04148268f, -0.02444492f, -0.02957365f, -0.04089478f, 
    -0.03297739f, -0.04009990f, -0.05774711f, 0.03654586f, 0.03301619f, -0.00943074f, -0.00317426f, -0.04177296f, 
    0.02445714f, -0.00095710f, -0.01741984f, 0.01130657f, -0.00818865f, 0.02111851f, -0.03971671f, -0.05228477f, 
    -0.00475779f, -0.03460486f, -0.00666512f, -0.05465412f, -0.05070376f, -0.01367713f, 0.03088691f, -0.02385508f, 
    -0.01984643f, 0.02616040f, -0.02331123f, 0.00067131f, 0.01507062f, -0.01269193f, -0.03663127f, -0.04843126f, 
    0.04035124f, 0.00697815f, 0.00359558f, 0.03712422f, -0.03911054f, 0.01369780f, 0.01260625f, 0.03720897f, 
    0.03218555f, 0.03977270f, 0.01593944f, 0.01862220f, -0.05128197f, 0.04422354f, -0.01134409f, 0.04070993f, 
    -0.00059464f, 0.00139124f, -0.02350824f, -0.01540682f, -0.02615924f, 0.01554356f, 0.02023381f, 0.00105029f, 
    -0.01010770f, 0.01180443f, -0.00345511f, -0.05562059f, -0.05193366f, -0.03108389f, 0.00635998f, -0.04848577f, 
    -0.05660833f, -0.01861947f, 0.01234349f, -0.02332912f, 0.01286192f, 0.00810793f, 0.04095940f, -0.00102186f, 
    0.00114492f, 0.02953025f, 0.02795423f, 0.03512474f, -0.03215418f, -0.03166940f, -0.02453907f, -0.02937458f, 
    -0.03751831f, 0.00707070f, 0.05066199f, 0.03127346f, -0.01533929f, -0.04423131f, -0.02949027f, 0.00241960f, 
    -0.03961453f, 0.01728316f, -0.03888272f, 0.01806512f, 0.00955697f, 0.01598864f, 0.03201320f, -0.03788046f, 
    -0.35982236f, 0.09031781f, -0.25980738f, 0.13478903f, 0.00937961f, -0.11556045f, 0.05737309f, 0.01994714f, 
    0.02406582f, -0.08000005f, 0.08753264f, -0.03657739f, 0.13655706f, 0.01729386f, 0.13281415f, 0.06663015f, 
    -0.11200655f, -0.10109960f, 0.13957192f, -0.01772293f, 0.02548178f, -0.08265480f, 0.05110358f, 0.02472881f, 
    0.27900180f, 0.00506343f, -0.03084158f, -0.16506758f, 0.07271127f, -0.06361870f, -0.06200018f, 0.17720553f, 
    0.02093592f, -0.05294071f, 0.05463606f, 0.07629540f, -0.20319788f, -0.13468316f, 0.09152559f, 0.10169490f, 
    -0.04355997f, 0.04589239f, -0.00335586f, 0.09436605f, 0.04672631f, 0.04518655f, -0.01602657f, 0.07897034f, 
    -0.38928020f, 0.11358283f, -0.09234705f, -0.04821365f, 0.06328956f, -0.01547601f, 0.03902656f, 0.11816530f, 
    -0.08072653f, -0.00635229f, 0.01840086f, -0.00234352f, -0.29314026f, -0.11746270f, 0.18241791f, 0.03950659f, 
    0.04996557f, 0.09388452f, 0.01141748f, -0.09543525f, 0.02051526f, -0.01834479f, 0.11731844f, -0.08023668f, 
    0.17625454f, -0.02710008f, -0.01137218f, -0.04233312f, -0.07819472f, 0.11739143f, 0.06965055f, 0.00848387f, 
    0.04354005f, -0.04303809f, 0.12444423f, 0.15981372f, -0.09364811f, 0.02756554f, 0.07706591f, 0.04031401f, 
    -0.01973583f, 0.06533053f, 0.00308702f, 0.02280214f, 0.02580368f, 0.08528911f, 0.10113940f, 0.23483118f, 
    -0.12130450f, -0.12715606f, 0.03889810f, -0.07380950f, -0.04305076f, 0.02763332f, 0.02926199f, 0.09427773f, 
    0.06058340f, 0.00807491f, -0.01686563f, -0.00310330f, -0.19172092f, 0.21806787f, -0.09800299f, 0.19845930f, 
    0.01527518f, 0.02130084f, 0.03470615f, 0.09663845f, 0.03549553f, 0.12803265f, 0.07761320f, 0.08289599f, 
    -0.19989969f, 0.34992859f, 0.05476515f, -0.06857091f, 0.21063590f, 0.05139532f, 0.00626715f, -0.02071765f, 
    0.07953391f, 0.03395982f, -0.05894544f, 0.14048146f, -0.18370102f, 0.00821489f, 0.14627120f, 0.04442112f, 
    -0.03063010f, 0.13988128f, 0.01200431f, -0.06893498f, -0.01540158f, 0.10961957f, 0.09267671f, 0.04337305f, 
    -0.09177189f, 0.08896521f, -0.01994997f, -0.06028805f, -0.00108605f, -0.14145730f, -0.00073398f, -0.02795649f, 
    0.01984731f, 0.04230903f, 0.06005586f, 0.05432313f, -0.13408957f, -0.02593125f, -0.06424306f, -0.16118732f, 
    0.16862997f, -0.00918077f, 0.08795496f, 0.00098226f, 0.06314790f, -0.00307409f, -0.05392163f, 0.05541081f, 
    -0.25016999f, 0.30278957f, -0.11510812f, -0.16449550f, 0.04510243f, 0.00057253f, 0.12321093f, -0.01168929f, 
    0.06803738f, 0.00132360f, 0.14873312f, 0.15994178f, -0.05492075f, -0.02695851f, -0.04546515f, -0.03596818f, 
    0.04085727f, -0.04544285f, 0.01769631f, 0.10612368f, 0.00426818f, 0.13874130f, 0.06060066f, -0.04180076f, 
    0.17608474f, 0.05161071f, 0.08636545f, -0.00800534f, 0.14867313f, -0.01549352f, 0.00835595f, -0.00696296f, 
    0.03605194f, 0.02380732f, 0.07727592f, 0.14678957f, -0.20893881f, -0.02810014f, -0.05429039f, -0.14753035f, 
    -0.07706933f, -0.00266392f, -0.09015230f, -0.03052452f, -0.06051511f, 0.05954491f, 0.03133808f, 0.05921414f, 
    -0.20331146f, 0.01650843f, 0.15132974f, 0.23961696f, 0.03717721f, -0.02132778f, -0.06126520f, -0.03677051f, 
    0.09287308f, -0.00088120f, 0.03909633f, 0.12031728f, -0.25822806f, 0.12858820f, -0.03219236f, -0.04735675f, 
    0.12166250f, 0.05032308f, 0.07724780f, -0.01326560f, 0.03982271f, 0.12052313f, 0.06789181f, 0.06610816f, 
    -0.27071819f, 0.08567935f, -0.01249165f, 0.10958271f, -0.03199450f, 0.02259537f, 0.08512422f, -0.01196410f, 
    -0.01023248f, -0.02459314f, -0.04076617f, 0.01676713f, 0.04842408f, -0.09329602f, -0.15625866f, -0.18408084f, 
    0.10885780f, 0.06326335f, 0.02609691f, 0.04898821f, 0.09781923f, 0.05402453f, 0.05016441f, 0.03334084f, 
    -0.21099323f, -0.02538892f, 0.04612112f, -0.05370156f, 0.14207582f, 0.07521787f, -0.07325114f, 0.10962482f, 
    -0.00071014f, 0.02666875f, -0.02087601f, 0.11272816f, -0.50267422f, 0.19972946f, -0.08509063f, 0.04119970f, 
    0.12964816f, 0.01275996f, 0.04548100f, -0.01823913f, 0.04927520f, -0.06331414f, -0.04733607f, -0.00868955f, 
    0.05438232f, 0.13857339f, -0.02679522f, 0.10695849f, 0.00776241f, 0.03310725f, -0.03762732f, 0.08455952f, 
    0.04717453f, -0.05198984f, -0.00464078f, 0.11981864f, -0.34970003f, 0.08668847f, 0.10558770f, 0.20434275f, 
    -0.12363823f, 0.07587979f, -0.01149355f, -0.04366964f, 0.09139565f, 0.06850376f, -0.06059242f, 0.10680438f, 
    0.09903094f, 0.01757875f, 0.09050758f, -0.15036145f, 0.08930181f, 0.11754273f, -0.06282914f, 0.08068922f, 
    -0.05542802f, 0.01277605f, -0.01038672f, 0.02371625f, -0.09362016f, -0.20141135f, 0.06913877f, 0.14065084f, 
    -0.05084899f, 0.10238524f, 0.02096247f, -0.01330312f, -0.00921805f, -0.10967217f, 0.11675577f, -0.09716552f, 
    0.06328827f, -0.11316618f, 0.11822381f, -0.17335302f, -0.01135537f, -0.04579702f, 0.02354655f, 0.08502030f, 
    -0.09341625f, 0.10760707f, -0.05794174f, 0.09051076f, 0.01347364f, -0.04844210f, -0.02925588f, -0.07768098f, 
    0.05858568f, -0.07873311f, 0.02855492f, -0.00250876f, 0.05050874f, 0.02991197f, 0.05235537f, 0.07286615f, 
    0.04341896f, -0.08158825f, -0.11013833f, -0.13923284f, 0.06558723f, 0.11253991f, 0.02982845f, 0.08037592f, 
    0.06667042f, 0.05160892f, -0.01420845f, -0.05437598f, 0.18398769f, -0.02311358f, -0.05077837f, 0.05894787f, 
    -0.03075673f, 0.06519046f, -0.00917726f, 0.00167725f, 0.06091479f, 0.05115152f, 0.00260127f, 0.06268298f, 
    -0.04891995f, 0.06605802f, 0.13626844f, 0.03220709f, -0.01986570f, -0.03193161f, 0.08510660f, 0.17541873f, 
    -0.03188594f, 0.03226347f, 0.05549852f, 0.10634169f, 0.13281514f, 0.00840211f, -0.00254124f, -0.20438354f, 
    0.13191512f, 0.16872054f, 0.02657421f, 0.00798508f, 0.14053594f, -0.00703353f, 0.03230031f, 0.04207240f, 
    -0.22393267f, 0.03598355f, -0.25318903f, -0.20208290f, 0.11538111f, -0.07357050f, -0.08263965f, 0.10461947f, 
    0.09102782f, -0.05566324f, 0.12300576f, 0.03073418f, 0.48074928f, 0.03833389f, 0.02635777f, -0.09575054f, 
    -0.01263930f, 0.02742078f, 0.08411673f, 0.03296002f, 0.04099506f, 0.06282206f, 0.01594814f, 0.19993687f, 
    0.34018350f, -0.09238002f, 0.05607077f, 0.15840378f, -0.00616379f, -0.00827767f, -0.07126382f, 0.05117787f, 
    -0.00728687f, 0.00725969f, -0.01727952f, 0.04136431f, -0.20096542f, 0.01169354f, 0.13548523f, 0.01035109f, 
    0.13261780f, 0.07338019f, -0.05327618f, -0.12795994f, -0.00055407f, 0.20863950f, -0.09969067f, -0.00474371f, 
    -0.01025948f, -0.06264894f, 0.01199192f, 0.09744490f, 0.04471402f, -0.01531219f, -0.08859037f, -0.08160222f, 
    0.01860901f, -0.03046556f, -0.07829189f, 0.01655175f, 0.08723725f, -0.05518385f, 0.07022209f, 0.02924343f, 
    -0.01883661f, 0.01122458f, 0.03144860f, 0.01020989f, -0.03533802f, 0.19918594f, -0.05733017f, -0.03465274f, 
    -0.18860866f, -0.09115557f, -0.28786215f, -0.05635286f, 0.04069782f, -0.04611140f, -0.00690941f, -0.07134520f, 
    0.07819703f, 0.04707770f, 0.10727575f, 0.11661533f, -0.16147880f, -0.01983560f, 0.18461514f, 0.23118259f, 
    -0.09356773f, -0.00681488f, 0.02420654f, 0.00959762f, -0.07556499f, -0.04328497f, -0.02372259f, 0.04884238f, 
    0.05058146f, 0.28091246f, -0.15382855f, -0.01219480f, -0.07069604f, -0.14001869f, -0.04408742f, 0.14652680f, 
    0.12613536f, 0.00057999f, 0.08369787f, 0.00633549f, -0.29847634f, -0.01686495f, 0.21069625f, -0.04816815f, 
    -0.02498152f, -0.05404392f, 0.04033576f, -0.00196940f, 0.11614572f, 0.10137029f, 0.09785033f, 0.06948229f, 
    0.34144938f, -0.16940302f, 0.09642605f, 0.01887460f, 0.03456139f, -0.04119911f, -0.02364039f, 0.25868049f, 
    0.14446807f, -0.02339254f, -0.05399276f, 0.07211141f, -0.31782666f, 0.06798484f, -0.05104845f, -0.03236146f, 
    -0.04006360f, 0.03133505f, -0.07122904f, -0.06581634f, -0.03387152f, 0.03995652f, -0.00967324f, -0.06966754f, 
    -0.24284889f, 0.08387422f, -0.03759978f, -0.00195520f, -0.05865284f, -0.05315416f, -0.00922577f, 0.05619957f, 
    -0.08094756f, -0.10208625f, -0.05476827f, -0.05303704f, 0.45749784f, -0.01813111f, 0.05084308f, 0.07136472f, 
    0.02886633f, -0.06660772f, -0.00833951f, -0.01964364f, 0.11155679f, -0.06325167f, -0.05821901f, 0.00006411f, 
    0.29125735f, 0.01520419f, -0.08718371f, -0.17307116f, 0.15744223f, -0.01179976f, 0.02652246f, 0.02291762f, 
    -0.07953724f, 0.17351790f, 0.13846797f, -0.06919263f, 0.15941551f, 0.12076676f, 0.07197370f, -0.10396841f, 
    0.03234370f, 0.03400656f, 0.04260187f, -0.02358205f, -0.07784698f, 0.02669922f, -0.11310562f, -0.01163844f, 
    -0.11452261f, 0.05035351f, 0.23252209f, 0.00658172f, -0.03151219f, 0.04533457f, 0.09820976f, 0.00731440f, 
    -0.04076282f, -0.09470577f, -0.03476950f, -0.03778822f, 0.38178661f, -0.18366189f, -0.04561166f, -0.03808839f, 
    -0.01849515f, 0.04407839f, 0.14302114f, -0.02470668f, 0.03535541f, 0.17205319f, -0.18314882f, -0.05471990f, 
    0.53239322f, -0.04096689f, -0.02470465f, 0.03157743f, -0.02417989f, 0.04911404f, -0.09002665f, 0.11550695f, 
    -0.03201779f, 0.03587723f, -0.05545988f, -0.00310229f, 0.22378287f, -0.01023812f, -0.15079299f, -0.14271796f, 
    0.16869062f, -0.00968029f, -0.01696349f, 0.12538609f, 0.05746184f, 0.07767898f, -0.06985037f, 0.01877295f, 
    -0.19235994f, 0.08119942f, -0.09059308f, -0.07254907f, 0.02396666f, -0.01450808f, -0.04288986f, 0.01477858f, 
    -0.06353879f, 0.02250450f, 0.04451918f, 0.12535389f, 0.19204225f, -0.09228644f, -0.03751180f, 0.10455913f, 
    0.00268922f, 0.04204239f, 0.03970524f, -0.07040436f, -0.10909231f, 0.03583018f, 0.14287357f, 0.09378472f, 
    0.09804542f, 0.12264382f, -0.09710711f, -0.30150756f, 0.02617060f, -0.02677145f, -0.04639143f, 0.02005182f, 
    0.09504648f, 0.04539745f, -0.02317801f, -0.06310510f, -0.32375163f, 0.01645721f, 0.18520518f, 0.06403907f, 
    0.01488293f, -0.00911416f, 0.07688370f, 0.03299272f, 0.04496865f, 0.11025766f, 0.06744912f, 0.15013297f, 
    -0.06122386f, 0.01729427f, -0.04482634f, -0.02609094f, 0.05525181f, 0.04726063f, 0.07504246f, -0.04690339f, 
    0.02387352f, -0.00931622f, -0.01657592f, 0.10032467f, 0.01579180f, 0.04826108f, -0.01284782f, -0.51119661f, 
    0.07335979f, 0.00427568f, -0.02231746f, -0.07688159f, 0.16314189f, 0.00757327f, 0.08557307f, -0.07312473f, 
    -0.11529267f, 0.12688042f, -0.14716344f, 0.04886669f, 0.12423993f, -0.12857351f, -0.11653701f, -0.06758887f, 
    0.13798416f, 0.02526022f, -0.14393732f, 0.02418414f, 0.35490021f, -0.05703640f, -0.00432283f, -0.08513378f, 
    -0.09037390f, 0.02694636f, 0.17670226f, -0.00011782f, -0.08549096f, -0.09098990f, -0.01884681f, -0.10926289f, 
    -0.00029655f, -0.15031151f, -0.27511847f, 0.10232304f, -0.00763858f, 0.03387587f, -0.02136298f, 0.10161188f, 
    0.10950182f, -0.05104081f, 0.22123154f, 0.10063718f, 0.22218651f, -0.13343826f, -0.08821721f, -0.13631982f, 
    0.04046505f, -0.03194878f, 0.05658955f, -0.04170602f, -0.08371650f, -0.10638740f, 0.03079876f, -0.15248828f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05762775f, 0.03867184f, 0.08413218f, 0.03943957f, -0.04627034f, 0.00125149f, 0.06195392f, 0.03465293f, 
    0.06482510f, -0.03483952f, -0.00335873f, -0.05196565f, -0.08826334f, -0.05609720f, 0.01628815f, 0.04672071f, 
    -0.04632282f, -0.05551207f, -0.03416131f, 0.03819484f, -0.04698880f, 0.06546169f, 0.06287638f, 0.05633912f, 
    -0.01008732f, 0.04971729f, -0.05829359f, -0.06337960f, 0.06959309f, -0.01934759f, -0.04395759f, -0.01556174f, 
    0.02892298f, 0.05419113f, -0.01627584f, -0.04850435f, -0.03203569f, 0.00293519f, -0.04208966f, 0.01841121f, 
    0.00197857f, 0.01722525f, 0.04210763f, -0.00908308f, -0.05204633f, 0.05540070f, 0.01496831f, 0.04486684f, 
    0.04789314f, -0.05388355f, 0.02846214f, -0.00908344f, 0.01668549f, 0.02865990f, -0.05371734f, -0.05700526f, 
    -0.02537586f, -0.00383204f, 0.04284705f, 0.08373588f, 0.09711270f, 0.03203467f, 0.06359098f, 0.06778762f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09496249f, -0.08016618f, 0.01861767f, -0.11246835f, -0.06595241f, 0.06447672f, 0.17898206f, -0.67693365f, 
    -0.11011722f, 0.20684950f, 0.11742119f, 0.04478663f, 0.29313365f, 0.02543416f, -0.03371548f, -0.01416516f, 
    0.09520990f, -0.00481156f, -0.03984729f, -0.02128812f, 0.16169383f, 0.06457870f, -0.43594766f, -0.19679998f, 
    0.06996988f, -0.01904809f, 0.37851125f, -0.07047216f, 0.26551560f, 0.07122694f, 0.03560716f, 0.21142392f, 
    -0.43747127f, -0.22731766f, 0.21884084f, -0.09236749f, -0.04017370f, -0.07570555f, -0.09483477f, 0.24279578f, 
    -0.03518318f, -0.02087289f, -0.06144033f, 0.11244546f, -0.08901230f, 0.20459744f, -0.55097455f, -0.37425765f, 
    -0.01833377f, 0.11931100f, -0.04468752f, -0.05015177f, -0.10528884f, 0.07650291f, 0.11917192f, 0.08147061f, 
    0.04228555f, 0.09407521f, -0.10042491f, -0.27406156f, -0.22921689f, -0.08572574f, -0.28832278f, 0.18133491f, 
    0.01418972f, 0.05577239f, -0.10443775f, -0.01873981f, -0.28319395f, 0.07420459f, -0.15679953f, 0.22634469f, 
    0.25214234f, 0.34147483f, -0.11208563f, 0.01696099f, 0.06082928f, 0.01112693f, 0.07281850f, -0.03992415f, 
    0.27970779f, -0.26242805f, -0.04533091f, -0.03849106f, -0.49852106f, 0.04648456f, 0.16889508f, 0.19936465f, 
    0.00003123f, 0.08956092f, -0.45321742f, 0.15653926f, -0.00612844f, 0.07751732f, -0.00037234f, 0.11682015f, 
    -0.34678137f, 0.05490724f, -0.27821454f, 0.06171675f, 0.04845035f, 0.04816406f, 0.00842989f, 0.24786180f, 
    0.01120424f, 0.02151160f, -0.00252423f, -0.19273145f, 0.09695831f, 0.24065220f, 0.25734323f, 0.26410919f, 
    -0.11946411f, 0.05297989f, 0.04736752f, 0.11214165f, 0.01323246f, -0.08704118f, -0.04296097f, 0.09186230f, 
    -0.00694443f, -0.11389994f, -0.03578795f, -0.15477808f, -0.03432287f, 0.07487266f, -0.48554277f, -0.25085932f, 
    -0.10771713f, 0.11092461f, 0.12354721f, -0.08552266f, 0.04291951f, -0.04683046f, 0.07497430f, -0.42490202f, 
    0.10766895f, -0.04608104f, -0.05104261f, 0.02510371f, 0.18139683f, -0.11172655f, 0.02434828f, -0.11818172f, 
    -0.15530424f, -0.31184009f, -0.03116577f, -0.03647352f, 0.32497695f, 0.08846062f, 0.12672460f, -0.02751117f, 
    -0.10148752f, -0.47590607f, 0.03357241f, 0.21011329f, 0.09067132f, -0.01058044f, 0.10815386f, -0.01440377f, 
    0.32901639f, -0.35841867f, -0.44272268f, 0.04029189f, -0.05580543f, -0.04621705f, 0.10331240f, -0.41113389f, 
    0.11005358f, -0.34186220f, -0.11882741f, 0.06991166f, -0.05735300f, 0.02502227f, 0.08231154f, 0.21927845f, 
    0.29032496f, 0.07025722f, 0.11577808f, 0.07918704f, 0.00934995f, -0.03180995f, 0.01566849f, -0.00413499f, 
    -0.08713981f, 0.11272327f, 0.07770927f, -0.00862845f, -0.45341134f, 0.08619308f, -0.38272601f, 0.20325875f, 
    -0.07510228f, -0.04739099f, 0.15183842f, 0.01524677f, 0.10418861f, -0.04802604f, 0.34704822f, 0.14163867f, 
    0.10644356f, -0.63743299f, -0.05315443f, -0.08382611f, -0.25698134f, 0.10794853f, -0.04225572f, -0.16673084f, 
    0.16099395f, -0.15011087f, -0.00185362f, -0.02677891f, -0.27129048f, -0.49095324f, -0.31125143f, 0.22828637f, 
    0.03136511f, 0.15756632f, -0.24135691f, 0.05669250f, 0.46905586f, 0.00174084f, 0.02239321f, -0.45702815f, 
    -0.27060497f, -0.06443752f, 0.13217802f, -0.10012195f, -0.02579437f, -0.06536154f, 0.07937670f, -0.43860158f, 
    0.07730485f, 0.06741154f, 0.03407422f, 0.36849335f, 0.04566608f, -0.81533366f, -0.41877100f, 0.16039070f, 
    0.19584276f, -0.09654576f, -0.00483414f, -0.10340536f, -0.08404949f, -0.03208438f, 0.10504320f, 0.09618454f, 
    -0.03048787f, 0.05711039f, 0.11448044f, -0.06512999f, 0.09595856f, -0.09077680f, 0.14645810f, -0.06669647f, 
    0.11726538f, 0.03150187f, 0.09881920f, -0.13074033f, 0.20858455f, 0.07292365f, 0.20758113f, 0.28488016f, 
    -0.23315834f, -0.37083715f, 0.07100490f, 0.07069377f, 0.17576799f, 0.01970191f, -0.01546604f, -0.15196986f, 
    0.25988659f, 0.01150409f, -0.03924349f, -0.05373351f, -0.18970211f, 0.20383011f, -0.23273106f, 0.07114287f, 
    0.11212553f, 0.21055564f, -0.17798506f, 0.14471798f, 0.21690233f, 0.06824362f, -0.07937357f, -0.35842705f, 
    0.00056803f, -0.14509599f, 0.09067817f, -0.08764018f, 0.02445430f, 0.03540286f, -0.08237232f, -0.24935159f, 
    -0.08812135f, 0.26076502f, -0.00049363f, -0.33046052f, -0.03850091f, 0.19337939f, 0.15031761f, -0.25547776f, 
    -0.40916559f, 0.05784648f, -0.11448616f, -0.07216101f, -0.01278265f, 0.03976956f, -0.10282024f, -0.02035765f, 
    0.07904657f, -0.05473628f, -0.11975592f, -0.31320164f, -0.27074307f, -0.04235242f, 0.38097155f, -0.13769872f, 
    -0.12300007f, -0.05682129f, 0.10643519f, 0.11156598f, -0.18160588f, -0.09753718f, -0.25560084f, -0.26733989f, 
    -0.14577588f, -0.19876839f, -0.04007070f, -0.10624213f, -0.12336347f, -0.03514593f, 0.06120317f, 0.17536521f, 
    -0.05020228f, -0.10000850f, -0.07539286f, -0.03999071f, 0.23490103f, -0.02850971f, 0.16052784f, 0.09362938f, 
    0.12513553f, -0.04098286f, 0.37618765f, -0.45023942f, -0.55426985f, -0.05834273f, 0.08834133f, 0.13677205f, 
    -0.08971772f, 0.06682345f, 0.27373555f, -0.04554471f, -0.07261363f, -0.12089955f, -0.08784706f, 0.28774354f, 
    -0.03172368f, 0.11028942f, -0.10065032f, -0.13499410f, -0.02488381f, -0.04496689f, 0.19753668f, 0.16169249f, 
    -0.50390542f, 0.01857730f, 0.11485489f, 0.10393272f, 0.04708518f, 0.00814914f, 0.08723284f, 0.00109773f, 
    0.10027076f, 0.01027884f, -0.07613071f, -0.33496952f, 0.31113183f, -0.11172135f, 0.06893118f, -0.69608212f, 
    0.01168741f, 0.01776561f, -0.03080236f, -0.04773090f, -0.39809653f, -0.03916787f, -0.14589845f, -0.21125194f, 
    -0.32231620f, -0.24157132f, -0.04285919f, -0.12074970f, -0.46462390f, -0.03050562f, 0.10504014f, -0.04144735f, 
    -0.07689670f, 0.36585754f, -0.09281192f, 0.01399429f, -0.02493642f, -0.29658931f, 0.30046302f, 0.29527682f, 
    0.06975032f, -0.33222920f, -0.02685024f, 0.10170487f, -0.14710373f, 0.11679414f, 0.00517329f, 0.10166366f, 
    0.39094979f, 0.18091206f, -0.17717330f, -0.11171883f, -0.01859054f, 0.10816304f, -0.04985150f, -0.11317012f, 
    0.04321714f, 0.11360324f, -0.03697841f, 0.27504984f, -0.06094662f, 0.00174516f, 0.15940748f, -0.40776178f, 
    0.28322318f, -0.00436576f, -0.10562711f, 0.09161177f, -0.02983066f, 0.03723854f, -0.03831462f, -0.11763837f, 
    -0.02703912f, -0.00222321f, -0.11749294f, 0.08075877f, -0.39088628f, 0.11514073f, -0.09577101f, 0.03731475f, 
    -0.08224062f, -0.00890141f, -0.31889898f, -0.00441269f, 0.32800311f, -0.03329729f, -0.45152864f, 0.29816628f, 
    -0.29971185f, 0.02628186f, -0.09669813f, -0.05553271f, 0.24708706f, 0.03407543f, -0.03864223f, 0.08918617f, 
    0.19427514f, 0.09428168f, -0.05004241f, -0.00335118f, 0.13721727f, -0.34788814f, 0.01633225f, -0.19455890f, 
    -0.02638287f, 0.18565652f, 0.21344684f, 0.19866261f, -0.29326281f, 0.06313273f, -0.11493590f, -0.17800856f, 
    0.13356316f, 0.09986034f, 0.21661198f, -0.09930314f, -0.05999304f, -0.01896634f, -0.11892287f, -0.18133512f, 
    0.11420340f, -0.37400252f, 0.01031370f, 0.14836344f, 0.09327983f, -0.33169210f, -0.19261764f, 0.01922400f, 
    -0.22817498f, -0.10300166f, 0.08778172f, 0.11928398f, -0.01141174f, -0.00548587f, 0.09798853f, -0.00702450f, 
    -0.03633903f, -0.06800919f, 0.08514717f, -0.11031078f, -0.09797659f, 0.01216096f, -0.26241702f, 0.09418514f, 
    -0.11400208f, -0.06997929f, -0.26363274f, -0.04369347f, 0.05692634f, -0.10313611f, -0.09316766f, 0.17202243f, 
    -0.14653741f, 0.11796219f, -0.04626773f, 0.06393896f, 0.32927138f, -0.08666519f, 0.02071504f, -0.41567793f, 
    -0.00286027f, -0.19588622f, 0.01460581f, -0.02201685f, 0.14196867f, 0.17877705f, -0.19472142f, 0.17354378f, 
    -0.08168791f, -0.34881657f, -0.40673009f, -0.42960727f, -0.52625114f, -0.08365481f, -0.10478947f, 0.20335406f, 
    -0.10828615f, 0.18826728f, 0.29232737f, -0.09603427f, 0.00688299f, 0.01234821f, 0.04995796f, -0.30908477f, 
    0.10495880f, -0.08036899f, -0.00967706f, 0.07937029f, -0.12124655f, 0.09973431f, -0.04389546f, 0.11935782f, 
    0.13762122f, -0.10267474f, 0.01894581f, -0.12291612f, -0.04209568f, 0.05221977f, 0.01807374f, 0.05359545f, 
    -0.09922265f, 0.01619531f, 0.02814780f, 0.25716728f, 0.24022034f, -0.05808303f, -0.08231841f, 0.01261540f, 
    0.11492375f, -0.09442874f, -0.40123311f, 0.09431054f, -0.04868494f, -0.00597560f, 0.10680898f, -0.04347705f, 
    -0.08194396f, 0.03129274f, -0.07692890f, -0.07115892f, -0.41429016f, 0.04960506f, -0.04679184f, -0.10897914f, 
    -0.18543617f, 0.12141868f, -0.01486297f, -0.07562964f, 0.23015201f, -0.05694019f, -0.08172362f, 0.04272616f, 
    -0.08009300f, 0.08649002f, 0.31547633f, 0.07982365f, 0.16240937f, -0.05763219f, -0.00612983f, -0.57783616f, 
    0.28668231f, -0.49540731f, 0.21495901f, 0.03087106f, -0.02227355f, -0.11817493f, 0.05707766f, 0.20911750f, 
    0.09518933f, -0.20894039f, 0.06492610f, -0.34661907f, 0.02193247f, 0.16749866f, 0.08384693f, 0.19475752f, 
    0.10561161f, 0.09794555f, 0.11621240f, -0.03740462f, -0.02606968f, 0.09540562f, -0.00390980f, 0.03430123f, 
    -0.03568054f, 0.04886079f, -0.08091934f, 0.06001043f, 0.25243601f, 0.10925492f, 0.22745588f, 0.34100196f, 
    0.10053678f, 0.00763151f, -0.04775759f, 0.03788650f, 0.22456717f, 0.12180377f, -0.60179406f, -0.31962246f, 
    0.15239215f, -0.23685998f, -0.06032620f, -0.00235537f, -0.75069618f, 0.01490909f, 0.00560790f, 0.15176184f, 
    -0.35563260f, -0.43164632f, 0.01409267f, -0.03209114f, 0.18025406f, -0.04928899f, -0.07344671f, 0.00055848f, 
    -0.08430590f, 0.22622064f, -0.31210804f, -0.15288597f, -0.42235872f, 0.10348758f, 0.00180656f, 0.26028198f, 
    -0.00983082f, 0.17363162f, -0.02967622f, -0.06623160f, -0.03183886f, -0.00655139f, -0.12965760f, -0.52853703f, 
    0.09673160f, -0.06857638f, -0.08813325f, -0.05476139f, -0.02041186f, -0.35421902f, -0.23906583f, 0.30409318f, 
    0.14559133f, -0.02575708f, -0.06451628f, -0.06421562f, 0.02266922f, -0.13018045f, -0.12270955f, 0.01206773f, 
    -0.08007526f, 0.04377997f, 0.05207267f, 0.34375879f, -0.14790496f, 0.04946481f, 0.11014937f, 0.38109225f, 
    -0.11860356f, 0.06468033f, 0.14558703f, 0.02814185f, -0.06042821f, -0.04016817f, 0.42371666f, 0.24816215f, 
    -0.05673922f, -0.00078344f, -0.07986352f, 0.01048164f, -0.13065556f, 0.02036491f, -0.04216582f, 0.16311778f, 
    -0.45013878f, 0.19610150f, 0.10454519f, -0.03229855f, 0.20652924f, 0.13794044f, 0.32702088f, -0.34960008f, 
    0.04016979f, 0.05167808f, -0.37571186f, -0.34902671f, -0.05269728f, -0.00600320f, 0.02479340f, 0.00181237f, 
    0.05558641f, 0.18585473f, -0.43080354f, 0.02192340f, -0.09553874f, -0.11850243f, -0.11545269f, -0.29463455f, 
    0.10216864f, -0.07059319f, 0.07788966f, -0.18120579f, -0.07244559f, -0.19921187f, -0.45176771f, -0.42964095f, 
    -0.09158111f, -0.06548156f, 0.07433723f, -0.03826846f, 0.04297457f, 0.01854797f, -0.11680969f, -0.04719092f, 
    0.09982596f, -0.04705023f, 0.08048262f, 0.12813398f, 0.36214259f, 0.00286310f, 0.06285395f, -0.18835483f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01290034f, 0.09536606f, -0.00940229f, -0.06885508f, -0.10595937f, 0.08738162f, -0.05882617f, -0.16904187f, 
    -0.05655634f, -0.06691330f, 0.10620032f, 0.00127004f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
