#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.00180459f, 0.97013617f, 0.89867276f, -1.22040796f, -0.82694292f, 0.15271850f, -0.33645532f, -0.27710307f, 
    -0.78430831f, 1.37040460f, -0.15274657f, 0.92830980f, -0.96393532f, -0.44546244f, -0.89795172f, 0.01932329f, 
    -0.27072561f, 0.59929204f, -1.57192099f, 1.41346979f, -1.05482543f, 0.53415138f, 0.64931297f, -1.01407063f, 
    -0.02474535f, -0.02963810f, 0.59936845f, -1.08914340f, 1.66121793f, 1.68588519f, -0.11805393f, 1.36560643f, 
    0.20271629f, 0.02265704f, 0.14837892f, 0.16889462f, 1.07480693f, -0.68108106f, 1.46026623f, 0.22042499f, 
    -1.21717584f, -0.35220167f, 0.85344917f, 0.67816353f, -0.15357749f, 1.62413323f, -1.23480296f, -1.18306684f, 
    1.18822420f, -0.39390060f, -0.11984471f, -0.35957634f, 0.06439736f, -0.14118071f, -0.75916934f, -1.71368670f, 
    -0.03489962f, -1.09594047f, 0.55810934f, 0.91612226f, -0.32463968f, -0.49849179f, -0.55175966f, -1.33986092f, 
    -0.88557714f, 1.40852106f, 1.38146341f, 0.93963921f, 0.06767544f, -0.53791851f, 0.13020504f, -0.01662110f, 
    1.75210977f, 1.11276102f, 0.20431302f, 0.13913642f, 0.79821444f, -0.23338686f, -0.17645565f, -0.05074625f, 
    -0.14089726f, 1.05252230f, 0.43592861f, 0.78608763f, 0.96285772f, 0.76729536f, 1.00433707f, -0.40661785f, 
    -0.20445983f, -0.65502077f, 0.15265071f, 0.65052229f, 0.78978884f, -1.65094638f, -0.01450631f, -0.79258347f, 
    0.47167107f, 0.44035068f, -0.46136835f, -1.09676504f, -1.65497541f, -1.19102407f, 0.55399084f, 1.00861883f, 
    1.03136861f, -0.04371058f, -0.01843323f, -0.18239720f, -1.60864544f, -0.12287386f, 0.28204116f, -1.13702762f, 
    -0.43881226f, -0.46987838f, 0.24422902f, -0.17261228f, 0.64236516f, 1.22936404f, 1.28119075f, -1.03625631f, 
    -0.37734231f, -0.89113659f, -0.70730382f, 0.43337974f, 0.53767353f, 0.69889158f, -0.12833729f, -1.55507374f, 
    -0.40365899f, -1.22252858f, 0.00304185f, -0.22803111f, 0.58895755f, 0.39543459f, -0.25595257f, 0.08431112f, 
    -0.85831273f, -0.99810421f, -0.89045459f, -0.97651720f, -1.12689614f, -0.73083383f, -0.09628912f, 0.02142545f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03487424f, -0.02119149f, -0.01653277f, 0.60000604f, 0.15206969f, 0.28705826f, 0.21018772f, 0.05896983f, 
    0.60698044f, 0.41123545f, 0.31362286f, 0.24827576f, 0.41814458f, -0.03063876f, 0.26292446f, 0.23961502f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.35815960f, 0.18090184f, -0.06104675f, -0.08082430f, 0.31045777f, -0.24141502f, -0.17670178f, -0.31641704f, 
    0.07304604f, 0.07718352f, -0.07974875f, -0.12599039f, 0.08264726f, -0.07884763f, 0.11219361f, 0.14544046f, 
    0.19914328f, -0.10743936f, 0.08582105f, 0.19353892f, 0.40529197f, 0.10662582f, 0.29737973f, -0.03141700f, 
    -0.16075933f, -0.10668176f, -0.18012613f, -0.10889915f, 0.11451933f, 0.17598118f, -0.12372506f, -0.06439934f, 
    -0.07824740f, -0.08627750f, -0.15705803f, -0.12748112f, -0.03704182f, 0.07610442f, 0.20038229f, -0.07274537f, 
    0.95497859f, 0.15062377f, 0.08583819f, -0.28103459f, 0.15417518f, -0.11018739f, -0.06398077f, 0.06400653f, 
    -0.25699139f, -0.11306031f, 0.06498545f, 0.01963450f, -0.08908024f, 0.16592255f, 0.18276165f, -0.12146272f, 
    -0.15197124f, 0.20707691f, -0.15724899f, -0.10640313f, -0.07508919f, -0.09007835f, 0.34141341f, -0.06714693f, 
    0.42064416f, -0.11271168f, -0.11505032f, 0.02855666f, -0.02610487f, 0.06596912f, 0.02631182f, -0.20247130f, 
    0.13826028f, 0.03467276f, -0.00547024f, 0.02212910f, -0.03914900f, -0.06382055f, -0.05266239f, -0.10437187f, 
    0.26326448f, -0.39172262f, 0.03444519f, -0.04411690f, -0.54374588f, -0.01383616f, -0.00564061f, 0.08226015f, 
    -0.09916423f, -0.07618921f, -0.11673402f, 0.06251277f, -0.08172976f, -0.04057778f, -0.16468637f, -0.02284350f, 
    -0.22118269f, 0.19769853f, 0.13154460f, 0.13664062f, 0.30002642f, -0.62425411f, 0.17768954f, -0.02302975f, 
    -0.00590078f, 0.21800755f, 0.10218851f, 0.04228558f, -0.01705196f, -0.13012926f, -0.29080638f, 0.10252097f, 
    0.09457880f, 0.01742427f, 0.08810383f, 0.14095822f, 0.02058058f, -0.03374055f, -0.23041908f, -0.02836149f, 
    -0.29806021f, 0.11465558f, -0.30798793f, 0.08021998f, -0.38595709f, 0.01938710f, 0.12166683f, -0.03104243f, 
    0.12673788f, -0.00758426f, 0.16877459f, 0.09124403f, -0.01181382f, -0.05476053f, -0.12250824f, -0.11088251f, 
    -0.05244040f, -0.08297265f, 0.07270748f, 0.11870340f, -0.36608785f, 0.34367892f, 0.63160264f, 0.26249602f, 
    -0.44330457f, 0.05315797f, 0.07673371f, 0.10126324f, 0.09026427f, -0.13828281f, -0.17020263f, 0.07541180f, 
    -0.12597890f, -0.10879787f, -0.10235852f, -0.02532461f, -0.06257010f, 0.03075162f, -0.05746188f, -0.05568084f, 
    0.20729834f, 0.21172477f, 0.03815326f, -0.24338226f, 0.44309393f, -0.32678211f, -0.23230119f, -0.04513684f, 
    0.14693117f, 0.03323876f, -0.01391618f, 0.07841363f, -0.05204296f, -0.02748292f, -0.03873629f, -0.01895100f, 
    -0.02609530f, -0.10058979f, 0.00577940f, 0.08401568f, 0.03130543f, 0.02792327f, 0.03195379f, -0.04826376f, 
    0.07676048f, -0.29105365f, -0.07899071f, 0.10411689f, -0.06938615f, -0.00299519f, -0.00484610f, -0.00964632f, 
    -0.08022349f, -0.14511777f, -0.04914584f, 0.11810297f, -0.00247310f, -0.15235987f, -0.02895923f, 0.08553343f, 
    0.11414338f, -0.01596349f, -0.12624525f, 0.22702667f, -0.05289861f, -0.20986015f, -0.06019576f, -0.23807241f, 
    -0.09068055f, 0.04795707f, 0.06369457f, 0.06800164f, 0.00847659f, -0.01999945f, 0.01091319f, -0.07090753f, 
    0.04562458f, -0.03364110f, -0.01959214f, -0.21101914f, -0.24187799f, 0.24537982f, -0.03940795f, -0.57695043f, 
    -0.62632430f, 0.17569399f, 0.14290169f, -0.08204198f, 0.14955296f, -0.07132801f, 0.03079075f, -0.08639527f, 
    0.01889884f, 0.06124404f, -0.07236575f, 0.10650261f, 0.00046312f, -0.05092607f, -0.02371270f, -0.01437936f, 
    -0.50392061f, -0.49619374f, -0.15369610f, 0.03410800f, 0.00441741f, -0.00821812f, -0.14060287f, -0.05881185f, 
    0.19763334f, -0.01815358f, 0.03101236f, 0.15270528f, 0.01820391f, 0.00827761f, 0.04046388f, -0.08831672f, 
    0.03104883f, -0.04640922f, 0.01702487f, -0.05966818f, -0.03503348f, -0.01999016f, 0.23611973f, -0.23430146f, 
    0.41430864f, -0.31732029f, 0.10592448f, -0.10929166f, 0.07563093f, 0.14317079f, -0.01304573f, 0.00299407f, 
    0.09286220f, 0.01540224f, 0.01868850f, 0.01757751f, -0.01635067f, 0.13063589f, 0.05729001f, -0.06640612f, 
    -0.23658629f, -0.81239223f, -0.34951243f, 0.29123130f, -0.48331809f, -0.06765496f, -0.27772537f, 0.06796227f, 
    -0.09349050f, -0.00347498f, 0.06338587f, -0.01984583f, -0.12200706f, -0.17421085f, 0.02855151f, 0.02277841f, 
    0.06147511f, -0.00908001f, 0.04603414f, 0.06543048f, -0.03753261f, -1.00810254f, 0.43495888f, 0.20925246f, 
    -0.05941507f, 0.11791243f, -0.14803119f, 0.08119140f, 0.04363441f, 0.01392742f, -0.18952435f, -0.13976355f, 
    -0.08502872f, 0.21558894f, -0.12792015f, -0.00427694f, -0.05103234f, -0.06373113f, 0.03150260f, -0.22547340f, 
    0.05972699f, 0.25191215f, -0.17380154f, 0.19978316f, -0.09042756f, -0.03404391f, -0.02047833f, 0.16030455f, 
    0.06789039f, 0.04979198f, 0.03392813f, -0.12016771f, -0.28057638f, 0.16412234f, -0.19748965f, 0.07683354f, 
    -0.06587194f, -0.08616097f, -0.09657703f, -0.13050862f, 0.14393136f, -0.23489286f, -0.20373246f, 0.16705030f, 
    -0.06742493f, 0.16666374f, 0.02079179f, 0.13885237f, -0.04993117f, -0.04789080f, 0.18734233f, 0.16485223f, 
    0.02101831f, -0.06969357f, 0.07481066f, -0.01332124f, 0.13553210f, -0.23672731f, -0.14218226f, -0.02208981f, 
    -0.67132717f, -0.10204240f, -0.24721561f, -0.14413062f, 0.33445179f, 0.13608202f, 0.05250199f, -0.02808797f, 
    0.00924454f, 0.23658648f, 0.14278145f, -0.04753639f, -0.00658168f, -0.12428270f, 0.03308897f, 0.05936997f, 
    -0.03823647f, -0.17994277f, 0.04254382f, -0.25086784f, -0.36877099f, 0.36070606f, -0.10937420f, -0.11132277f, 
    0.42147666f, -0.22063421f, 0.22064829f, 0.01055083f, -0.02600263f, -0.02562672f, 0.00433867f, -0.01223339f, 
    0.17634769f, -0.08193335f, -0.03429642f, -0.00671272f, -0.01113057f, 0.15650395f, -0.11697253f, 0.11829451f, 
    -0.46824232f, 0.33224553f, 0.26246509f, -0.17307475f, -0.23283896f, -0.06996054f, -0.07830400f, -0.14073040f, 
    -0.06197897f, 0.05768501f, 0.03792772f, 0.10479806f, 0.03575679f, 0.01330471f, 0.05110450f, -0.00809592f, 
    0.07858019f, -0.11288801f, -0.11156297f, 0.17572404f, 0.30363625f, -0.96291488f, 0.28597692f, -0.49815643f, 
    -0.15595989f, -0.10334029f, 0.09388521f, -0.16302490f, -0.10365739f, 0.01846204f, 0.05336985f, -0.15164386f, 
    0.02807933f, -0.08656859f, -0.19582991f, -0.07387803f, -0.07620796f, -0.32883310f, 0.15081759f, 0.02024096f, 
    0.11955985f, -0.15523772f, -0.00363763f, 0.03519858f, -0.18881083f, -0.21852691f, 0.01350932f, -0.16930193f, 
    0.00919203f, 0.01752632f, 0.09836306f, 0.02436589f, -0.14726689f, -0.03781271f, -0.04392145f, -0.09584274f, 
    -0.08628079f, 0.08365721f, -0.20999403f, -0.07829242f, -0.09857389f, 0.09512265f, -0.26920936f, -0.08352923f, 
    -0.20029524f, -0.03886296f, -0.00202777f, 0.03801697f, -0.14367911f, 0.20011444f, -0.03078747f, -0.02016776f, 
    -0.10060766f, 0.04370599f, -0.02392329f, 0.02618502f, -0.05425005f, -0.01671075f, 0.03927263f, 0.10107472f, 
    0.65217477f, 0.08033474f, 0.23776999f, 0.10180369f, 0.23238625f, -0.08925333f, -0.15526409f, -0.12731208f, 
    -0.01882956f, 0.00312609f, -0.03257010f, -0.18126243f, -0.04254033f, 0.16925122f, -0.05373989f, 0.02394338f, 
    0.16614577f, 0.01797264f, -0.06330067f, -0.00294293f, 0.45432377f, 0.05973274f, 0.24603568f, 0.14396457f, 
    0.25396842f, 0.06284692f, -0.00859358f, -0.01589664f, 0.04114543f, 0.11758076f, 0.00861647f, 0.18768787f, 
    -0.00579981f, 0.10527142f, -0.07195263f, -0.00832926f, 0.10533200f, 0.12850496f, 0.11926885f, 0.10278836f, 
    -0.25859019f, 0.02998008f, -0.44125748f, 0.09733610f, -0.04024115f, 0.11611121f, -0.00964931f, 0.04622982f, 
    0.03820819f, -0.03203314f, 0.09165978f, 0.01492601f, 0.14096348f, 0.20514782f, -0.19958088f, -0.10300942f, 
    0.07553912f, -0.00613667f, -0.17814477f, 0.09127120f, 0.51427472f, 0.14059564f, -0.32713413f, -0.01861513f, 
    -0.50789547f, -0.19151948f, 0.05347479f, 0.01590536f, -0.04274345f, 0.17598216f, 0.07193355f, -0.00748592f, 
    -0.01905777f, 0.06428293f, 0.05128674f, 0.16247459f, 0.22712252f, -0.00471599f, -0.01973535f, 0.04367090f, 
    -0.16144893f, 0.14047654f, -0.03913598f, -0.17987877f, -0.26628214f, 0.22029765f, 0.04355169f, 0.01608616f, 
    0.04144094f, 0.11102638f, -0.16383527f, -0.13926516f, 0.08337789f, 0.10160336f, 0.13042094f, 0.01882398f, 
    0.13066193f, 0.03373722f, -0.14409776f, -0.29581788f, 0.22284290f, -0.45427114f, 0.03264797f, -0.11770766f, 
    0.03799248f, 0.02135020f, -0.37791547f, 0.11702401f, 0.08529968f, -0.14106703f, -0.01859634f, 0.01835492f, 
    0.01984963f, 0.01216715f, 0.11515111f, -0.04590346f, -0.19360831f, -0.39586183f, -0.02424848f, -0.08412077f, 
    -0.00216345f, -0.36405084f, -0.22259100f, 0.15392669f, -0.01951184f, -0.06179149f, 0.03017200f, 0.09596517f, 
    0.20056227f, 0.04614757f, 0.06704379f, -0.17474112f, 0.08393396f, 0.25636762f, -0.08167393f, 0.16300002f, 
    -0.06169301f, -0.04547269f, -0.14273942f, -0.08415582f, -0.10518755f, -0.14043331f, -0.09473650f, -0.46971577f, 
    -0.11858761f, -0.10820382f, -0.01665352f, 0.13117293f, -0.03677930f, 0.01127875f, -0.23976324f, -0.12737440f, 
    0.17802864f, 0.04190408f, 0.09676161f, -0.02208470f, -0.02905985f, -0.24902724f, -0.27997270f, -0.04073793f, 
    -0.43587849f, 0.03932981f, -0.25211614f, -0.15658304f, 0.14127448f, 0.09389732f, 0.10522112f, 0.11119705f, 
    0.01295352f, -0.21840093f, -0.00727380f, 0.02087751f, -0.01283656f, 0.04869113f, -0.05544404f, -0.08024076f, 
    0.12806123f, 0.12169042f, -0.12307490f, 0.05670249f, -0.29661915f, 0.31808376f, -0.02792765f, -0.31827882f, 
    0.04556116f, 0.09151116f, 0.10857495f, 0.00428332f, 0.02134865f, -0.12753256f, -0.05640671f, 0.00974378f, 
    -0.01165185f, -0.28045061f, -0.10460145f, -0.04687828f, 0.05064255f, 0.05651096f, 0.06488403f, 0.00660797f, 
    0.05008300f, 0.03964534f, 0.09622516f, -0.24947138f, -0.17148843f, 0.27449271f, -0.10171814f, 0.03678362f, 
    -0.09404961f, -0.10394559f, -0.05533762f, 0.03116810f, -0.09275219f, -0.03347639f, -0.08357668f, -0.14358568f, 
    -0.05944756f, 0.13599154f, 0.08796194f, -0.05006818f, 0.39464003f, 0.12197483f, -0.26708600f, -0.07008899f, 
    -0.21995333f, -0.07397807f, 0.06843341f, 0.00726591f, -0.02682872f, -0.08714748f, -0.10240096f, -0.03742733f, 
    0.06970020f, 0.05001092f, 0.02977687f, 0.02445688f, -0.13773486f, -0.14168391f, -0.05782807f, 0.06635798f, 
    -0.45364407f, 0.20159587f, 0.03945914f, -0.02167776f, 0.07586940f, -0.00192393f, 0.23769507f, 0.00981440f, 
    -0.01745473f, -0.15145849f, 0.04549349f, -0.12166912f, 0.04852959f, -0.10383634f, 0.07131252f, 0.00364771f, 
    -0.04134052f, -0.02203706f, 0.17425764f, -0.06613261f, -0.46647844f, -0.29808581f, 0.15645203f, -0.01790132f, 
    -0.25608724f, -0.07142034f, -0.19615862f, -0.01174318f, 0.05682211f, 0.17443062f, -0.03118051f, -0.10966414f, 
    -0.16434416f, -0.02329021f, -0.01844430f, 0.02992063f, 0.02537819f, -0.12661953f, -0.01785660f, 0.00025718f, 
    0.45869499f, -0.09954233f, -0.24300209f, 0.17559281f, 0.00224666f, -0.27755988f, -0.05467065f, -0.05575504f, 
    0.05880136f, 0.19443624f, 0.05750985f, 0.05483919f, 0.10364548f, 0.08325221f, -0.04233999f, 0.05327306f, 
    -0.19241714f, -0.11090013f, -0.06001480f, -0.11975239f, 0.59601223f, -0.27471313f, 0.10045610f, 0.04222932f, 
    0.06737830f, -0.12660179f, 0.05409889f, 0.19366378f, 0.11747657f, -0.13290560f, 0.04969883f, 0.06129293f, 
    -0.06552053f, -0.07832524f, 0.19860213f, -0.09250980f, -0.10329827f, 0.07124607f, 0.05613916f, 0.04211137f, 
    0.35761878f, -0.17089121f, 0.17512073f, -0.36694723f, 0.06757011f, 0.09951833f, -0.05615008f, 0.24993753f, 
    0.11258256f, 0.01491855f, -0.09026674f, 0.13583115f, 0.08388647f, -0.04347530f, -0.05681650f, -0.08659665f, 
    -0.05299220f, 0.09039209f, -0.10711655f, -0.07623324f, -0.20805895f, 0.02468791f, 0.26859543f, -0.13024469f, 
    0.13434567f, 0.16034620f, -0.07928862f, 0.06248027f, 0.10116795f, 0.06445792f, -0.08571573f, -0.08495994f, 
    0.04834257f, -0.09001141f, -0.03311526f, -0.14655380f, -0.10021549f, -0.14652309f, -0.16128555f, 0.06046297f, 
    0.25699502f, 0.31424248f, -0.22437449f, -0.23489282f, -0.14962645f, 0.04334053f, 0.16004731f, -0.04787318f, 
    -0.05301657f, -0.06972743f, -0.07661507f, -0.05680743f, -0.01510100f, 0.00144640f, -0.08558075f, 0.01670214f, 
    0.09456881f, -0.22144952f, -0.02634822f, -0.13583367f, 0.41572407f, 0.00398568f, 0.22391243f, 0.39735797f, 
    0.32001227f, -0.25615808f, -0.26133543f, -0.39020371f, 0.17757036f, 0.14256838f, 0.16758882f, -0.11389068f, 
    0.02198720f, 0.04909610f, 0.08093136f, -0.05919300f, -0.16347462f, -0.01222616f, -0.03271216f, 0.03291952f, 
    0.46077967f, -0.14323696f, -0.37973318f, -0.01490019f, -0.41153920f, -0.07629423f, 0.12750451f, -0.31776172f, 
    0.04619542f, -0.01329399f, 0.02619954f, -0.09944677f, -0.11172989f, -0.03645675f, 0.04081646f, -0.09624616f, 
    0.02626657f, 0.00266245f, 0.12904717f, -0.02697518f, 0.03625462f, 0.02533899f, -0.01870963f, -0.43290576f, 
    -0.28471085f, 0.17261620f, -0.18848245f, 0.28773910f, -0.27180547f, -0.04214694f, -0.12845618f, 0.10234050f, 
    0.04689172f, -0.22454455f, 0.04494325f, 0.10885326f, -0.06676077f, 0.22303769f, 0.03685730f, -0.14628956f, 
    0.94372660f, -0.59019905f, 0.09179586f, -0.23512131f, -0.35734603f, -0.22762300f, 0.09706081f, 0.10921088f, 
    -0.03223602f, 0.05116595f, -0.04075398f, -0.12046127f, -0.02143590f, -0.11274386f, -0.12539504f, 0.04943928f, 
    0.07083534f, 0.00018734f, 0.02343943f, -0.04548545f, -0.47992253f, -0.63249236f, -0.29806602f, -0.42795929f, 
    -0.82791626f, 0.03367982f, 0.03609560f, -0.14902592f, 0.09643098f, -0.05466826f, 0.11305398f, 0.02135774f, 
    -0.02500953f, -0.05437883f, -0.08158211f, -0.10471440f, -0.03392308f, 0.31938854f, -0.03775140f, -0.11820830f, 
    -0.11688133f, -0.21232179f, -0.23930445f, 0.21839100f, 0.37653646f, 0.04148434f, 0.17586975f, 0.00546447f, 
    -0.13526848f, 0.04427772f, 0.00381692f, -0.01484959f, -0.04558017f, -0.00994897f, 0.00138980f, -0.00659286f, 
    0.15864648f, -0.04718758f, 0.15592065f, -0.10087071f, -0.12711085f, -0.00086022f, -0.04735641f, 0.26028076f, 
    0.25260210f, 0.05381902f, 0.11538104f, 0.13892506f, -0.00507401f, 0.04621454f, 0.06366384f, 0.02882504f, 
    -0.10960789f, -0.16494945f, -0.13618213f, 0.05146249f, 0.05604023f, 0.11455142f, 0.11191995f, 0.08448809f, 
    0.64292759f, 0.56847113f, -0.14477639f, -0.05033836f, -0.05648047f, 0.05129733f, -0.06672019f, -0.09707720f, 
    0.16463801f, 0.00373146f, -0.22818333f, -0.10919578f, -0.22102310f, 0.17759264f, -0.06612512f, -0.05728730f, 
    -0.07105603f, -0.06404917f, 0.15100828f, 0.22431479f, -0.47770184f, 0.23007527f, 0.03180851f, -0.06913430f, 
    -0.11591072f, -0.14977227f, -0.02826132f, -0.04588617f, 0.09681831f, -0.13416317f, 0.11201161f, 0.03071155f, 
    -0.05847882f, 0.02591889f, 0.00933211f, -0.02299681f, -0.00589051f, -0.21307136f, 0.16485797f, -0.02977698f, 
    -0.11493991f, -0.31781575f, -0.33777541f, 0.29960948f, 0.13572167f, 0.00099288f, 0.15885831f, 0.06438198f, 
    0.10727566f, -0.12218018f, -0.05721891f, 0.03323629f, -0.09242541f, -0.22620738f, -0.17631245f, -0.03433726f, 
    -0.07321098f, 0.13840267f, 0.09267015f, -0.20430560f, 0.10497417f, 0.40518972f, -0.05407057f, 0.24330555f, 
    -0.25408310f, -0.08790205f, 0.12279455f, -0.07113475f, 0.18450692f, 0.09795719f, -0.01141254f, 0.00079962f, 
    -0.03693888f, 0.06263842f, 0.04663058f, 0.07675342f, -0.09299483f, 0.01350806f, -0.14474316f, 0.06164102f, 
    0.19343890f, -0.07550661f, 0.19267841f, 0.12281214f, 0.08171601f, 0.00825576f, -0.17818618f, 0.02626343f, 
    -0.13663842f, -0.05968753f, -0.20590270f, -0.00665653f, -0.03459059f, -0.02818150f, 0.07753809f, 0.00701099f, 
    0.14146151f, 0.04976152f, 0.07454307f, 0.06807550f, -0.26848987f, -0.23934154f, -0.04604211f, -0.11953256f, 
    -0.26844126f, -0.01723089f, -0.24072191f, -0.04907864f, 0.14375660f, -0.24581707f, 0.15522854f, -0.25089535f, 
    0.06126789f, -0.10714102f, -0.02431122f, -0.14535628f, 0.11725613f, -0.08882063f, -0.01077086f, 0.03216299f, 
    -0.38605201f, -0.58867532f, -0.74233645f, -0.19062421f, -0.04412455f, -0.21281543f, -0.20000166f, -0.11376837f, 
    0.02088242f, -0.00294358f, -0.11721612f, 0.00025053f, 0.08923624f, 0.10353577f, -0.01605524f, -0.00131822f, 
    0.01642345f, -0.09947695f, -0.04619550f, 0.05871602f, -0.74923992f, -0.57049423f, -0.17517327f, -0.11938541f, 
    -0.32737213f, -0.10114559f, -0.05666786f, -0.06239225f, 0.00174208f, -0.05508207f, -0.21812800f, -0.10076674f, 
    0.10295696f, -0.06199111f, 0.04506839f, 0.11822332f, -0.02545461f, -0.01919875f, -0.01129204f, 0.22643806f, 
    -0.45322579f, 0.40948632f, -0.02011971f, 0.16878393f, 0.36141485f, 0.05999874f, 0.27532586f, 0.00001088f, 
    -0.06492884f, 0.15229239f, -0.01786155f, -0.12542218f, 0.00362554f, -0.21218036f, -0.03697627f, -0.07520084f, 
    0.00272948f, -0.06843667f, 0.18282214f, -0.08393843f, 0.12187264f, -0.32007691f, -0.05259478f, -0.27335107f, 
    -0.26894224f, -0.13505588f, -0.26451933f, 0.09020871f, -0.17128387f, -0.01917651f, -0.16154754f, 0.09822254f, 
    0.08242710f, -0.12888366f, 0.10544761f, -0.02516903f, -0.12727351f, 0.04532734f, 0.04603859f, 0.00382162f, 
    -0.36159080f, 0.44687930f, 0.12820011f, 0.02318979f, -0.17263117f, -0.03773488f, -0.12539364f, 0.01211947f, 
    -0.01256507f, 0.01627548f, -0.19847809f, -0.09246558f, -0.11385237f, 0.05586612f, -0.05793246f, -0.01104958f, 
    -0.04135869f, 0.10824888f, -0.09109284f, -0.04107851f, 0.38546464f, -0.16193134f, -0.26698670f, 0.19081765f, 
    0.09414478f, -0.00994688f, 0.04636595f, 0.07179338f, 0.04960243f, -0.01303159f, 0.17275624f, 0.05361889f, 
    -0.11608856f, -0.05302291f, 0.04054665f, -0.10389867f, -0.06186667f, 0.11617333f, -0.03971329f, 0.06668720f, 
    -0.26334140f, 0.27745035f, 0.08565085f, 0.14360745f, 0.09638415f, -0.11933209f, -0.11859027f, -0.15944713f, 
    -0.14305153f, -0.03059673f, -0.09627178f, 0.00343751f, 0.02153387f, 0.00221900f, -0.03050744f, -0.04366194f, 
    0.15028654f, -0.01553109f, 0.07234944f, -0.03712963f, 0.38769799f, 0.27904794f, 0.25669733f, 0.22405471f, 
    -0.01512092f, -0.04620772f, 0.02331742f, -0.12248608f, -0.11719290f, 0.03901453f, 0.03709799f, -0.06089090f, 
    -0.02066096f, 0.00083108f, -0.10199495f, 0.14408645f, -0.05335399f, 0.23228224f, 0.08460288f, 0.08003347f, 
    0.00630638f, -0.23134489f, 0.24919288f, 0.12064186f, 0.03698542f, -0.08903673f, -0.06038705f, 0.18907049f, 
    -0.16459057f, 0.02759740f, 0.11273497f, 0.01243305f, 0.08513722f, -0.11407239f, 0.08117040f, 0.09020601f, 
    0.01707861f, 0.07133006f, 0.08405196f, 0.12371597f, -0.20898125f, -0.32964060f, 0.12349069f, 0.26459825f, 
    -0.04646143f, -0.20183478f, 0.13732250f, 0.05629640f, -0.03839177f, -0.03582218f, 0.06219511f, -0.05737877f, 
    -0.11133584f, -0.02321780f, -0.04769881f, -0.10233130f, 0.00522140f, 0.05589285f, 0.14764374f, 0.11097962f, 
    -0.16529946f, -0.05889900f, -0.03510105f, -0.22718880f, -0.30471691f, 0.06919464f, 0.13460654f, 0.09169561f, 
    -0.06417436f, -0.08841715f, 0.03573902f, -0.01834791f, -0.01336349f, 0.00160830f, 0.08095091f, -0.01950196f, 
    0.16256864f, -0.15088472f, 0.05748970f, 0.11663837f, -0.22534123f, 0.54762667f, -0.24609442f, -0.00596540f, 
    -0.07092899f, -0.07813431f, -0.10817009f, 0.35838541f, 0.07384718f, 0.05658683f, -0.11322430f, 0.11387243f, 
    -0.05680728f, 0.02124243f, -0.00085474f, -0.02272934f, 0.07826481f, -0.13256685f, -0.07845745f, -0.11440760f, 
    -0.17561044f, -0.49037659f, 0.28634331f, 0.04960729f, 0.07244566f, 0.13111883f, -0.00067950f, -0.12041778f, 
    0.04123548f, 0.11472674f, 0.14416008f, -0.13706119f, 0.02200850f, 0.02741518f, 0.00096146f, -0.21384247f, 
    -0.16848136f, -0.09283485f, -0.07202119f, -0.08959860f, -0.17309226f, 0.49544773f, -0.57399112f, 0.17687243f, 
    -0.49663335f, -0.02293374f, -0.12093710f, -0.04427288f, -0.28572577f, -0.17233555f, -0.07371260f, -0.13211221f, 
    -0.10647930f, 0.00563437f, -0.01894117f, -0.00079438f, -0.10774251f, 0.06795605f, -0.20795682f, 0.06123755f, 
    -0.55684614f, -0.11159896f, 0.05092140f, 0.09174707f, 0.15302019f, 0.11091790f, -0.00406927f, -0.18693988f, 
    0.02141367f, 0.18932335f, -0.21945462f, -0.05973411f, 0.07622830f, 0.09057549f, -0.01390673f, -0.03171698f, 
    0.29058909f, -0.01206485f, 0.13213673f, -0.15854871f, 0.11118729f, 0.45223147f, -0.47571599f, -0.47177848f, 
    0.08936398f, 0.08730817f, -0.08049135f, -0.02008195f, 0.13292527f, -0.32915094f, 0.01994579f, -0.10159844f, 
    -0.28094789f, 0.10854279f, 0.05391271f, 0.00418990f, 0.01417934f, -0.03834585f, -0.06885967f, 0.03771893f, 
    0.25685611f, 0.02573892f, 0.25826731f, -0.04876039f, -0.32390055f, -0.02474536f, -0.03974570f, -0.01269702f, 
    0.14893286f, 0.12477527f, 0.09176543f, 0.02223990f, -0.01423712f, -0.04357718f, 0.00544550f, 0.03386590f, 
    0.05295520f, -0.13510907f, 0.01909888f, 0.01111215f, -0.09663692f, -0.00200692f, 0.09592976f, 0.12393743f, 
    0.04787083f, 0.11707857f, -0.05476970f, -0.10631382f, 0.11034040f, 0.05543819f, -0.03425091f, -0.03587791f, 
    0.10341834f, 0.01242655f, -0.00761275f, 0.08780134f, 0.14196536f, -0.10869972f, 0.01446642f, -0.13640085f, 
    -0.47849256f, -0.26160169f, 0.26986462f, 0.23569804f, 0.04898470f, -0.32134277f, -0.06939815f, 0.08465315f, 
    -0.22228093f, -0.03743985f, -0.05769169f, -0.02612705f, -0.09990789f, -0.13980252f, 0.06014018f, 0.09911373f, 
    -0.14462411f, 0.03400461f, 0.03457420f, -0.03131515f, -1.11076200f, 0.03799966f, -0.06286815f, 0.18691845f, 
    0.46723282f, 0.22486614f, -0.00497743f, 0.06063901f, 0.05457742f, 0.14327408f, 0.05210888f, 0.08490601f, 
    0.13991076f, 0.01705281f, 0.07992508f, -0.08369287f, 0.04279136f, 0.08608778f, 0.26703411f, -0.17599568f, 
    0.02043450f, 0.13084270f, 0.32898971f, -0.01386703f, -0.01108223f, -0.04321506f, 0.03155883f, 0.08388586f, 
    -0.07063984f, 0.03323218f, 0.15118694f, -0.13333450f, -0.06645162f, 0.02439428f, -0.02161610f, -0.14271860f, 
    -0.09144482f, -0.16134244f, 0.09970057f, 0.08996113f, -0.20977557f, -0.47484231f, -0.00194789f, 0.14517935f, 
    -0.27182522f, -0.29609641f, 0.06440463f, -0.14675291f, -0.28508508f, -0.09765260f, -0.10742119f, 0.09798675f, 
    -0.02934582f, 0.06844068f, 0.12418508f, -0.25002003f, 0.18288301f, 0.13740683f, 0.06415206f, 0.03407815f, 
    -0.45054901f, 0.21072847f, -0.15474890f, 0.00296238f, -0.03776770f, 0.24797620f, -0.06030534f, 0.07262582f, 
    0.20370393f, 0.02600729f, -0.09140465f, 0.11495066f, 0.00148320f, -0.06687720f, 0.01709124f, -0.04516359f, 
    0.00018106f, 0.08080720f, 0.16692613f, -0.09554484f, 0.19584757f, 0.13978222f, -0.21631755f, 0.31420162f, 
    -0.09829162f, -0.02257165f, 0.01794912f, -0.02436935f, 0.17274965f, -0.10852369f, 0.14389366f, 0.04262444f, 
    0.00665818f, -0.02860178f, 0.08339112f, 0.06585929f, 0.02800674f, -0.02228241f, 0.09117144f, 0.17073815f, 
    -0.02557133f, 0.08438443f, 0.07884740f, 0.04736351f, 0.02306991f, -0.25347507f, -0.07452063f, -0.19219738f, 
    0.10440569f, 0.16342199f, -0.06639741f, 0.07600456f, 0.20302883f, 0.13208255f, 0.09892659f, -0.13440874f, 
    -0.15888879f, 0.18034002f, 0.03473760f, -0.21319582f, 0.02873311f, 0.14567891f, 0.02065301f, 0.02981590f, 
    0.22883651f, -0.09549350f, -0.13797662f, 0.04822500f, 0.02734577f, 0.10525279f, -0.17131384f, -0.15553592f, 
    0.13567683f, 0.21489596f, 0.08004667f, -0.05589026f, -0.02233454f, -0.09642686f, -0.12311804f, -0.04577662f, 
    -0.66845715f, -0.00031357f, 0.22709548f, -0.00806998f, -0.28616634f, -0.28683916f, 0.02752336f, 0.08363053f, 
    -0.06073204f, 0.05087186f, 0.01910846f, -0.00062394f, 0.14375736f, -0.22181323f, -0.06943750f, -0.16943787f, 
    -0.00180667f, -0.26884437f, -0.03188114f, 0.18528184f, -0.21445216f, -0.28397077f, 0.21599315f, 0.13352999f, 
    -0.72983128f, 0.05064122f, -0.09746829f, -0.15589663f, -0.05682994f, -0.01645167f, 0.10136852f, 0.05032131f, 
    -0.06364751f, 0.10000837f, -0.01431157f, 0.02823110f, 0.02251911f, 0.19425632f, 0.15484047f, -0.03983118f, 
    0.14816885f, -0.01306549f, 0.00307928f, 0.42087433f, 0.17748952f, -0.16809179f, 0.05314811f, 0.00539924f, 
    0.06215847f, 0.08866119f, 0.16325867f, -0.18377997f, 0.02248668f, 0.02846344f, 0.17876677f, 0.08240649f, 
    0.21415678f, -0.04625238f, -0.09276623f, -0.32971108f, -0.39594719f, -0.18386556f, -0.23809150f, -0.20298795f, 
    0.19968496f, 0.03697606f, -0.00580867f, -0.06112651f, 0.00430867f, 0.09206262f, 0.17071076f, 0.17994796f, 
    0.08537712f, -0.05592782f, -0.02385825f, -0.02766645f, -0.06821202f, -0.04249447f, 0.13327819f, -0.21103209f, 
    -0.28800938f, 0.35233188f, -0.59234077f, -0.20408250f, -0.14128286f, 0.20342851f, 0.17535663f, 0.16880906f, 
    -0.01307315f, -0.06135166f, 0.01648548f, -0.03804124f, -0.21291965f, -0.16101554f, -0.13052005f, -0.07097082f, 
    -0.14823525f, 0.02850581f, -0.12418866f, -0.08769727f, -0.55102426f, 0.15528992f, 0.17251791f, 0.17100908f, 
    -0.05837789f, 0.00481784f, -0.05400208f, -0.06646023f, -0.19341055f, -0.00342544f, 0.04760402f, -0.07098554f, 
    0.05923992f, -0.10889880f, -0.08017009f, 0.04233130f, 0.09582392f, 0.00872824f, 0.22067110f, -0.06026092f, 
    0.06812332f, -0.11650801f, 0.04462375f, 0.11763217f, 0.23507604f, 0.14712387f, 0.04797207f, 0.05584895f, 
    -0.22939838f, -0.03969012f, 0.03792704f, 0.01717399f, 0.00594241f, -0.04863524f, 0.13816564f, -0.00454968f, 
    -0.01864568f, -0.03499776f, 0.10718327f, 0.02747165f, 0.29203695f, 0.29929024f, 0.13473515f, 0.02459052f, 
    -0.09431628f, -0.19788815f, 0.03201936f, 0.00144317f, -0.10081413f, -0.06485211f, 0.07958721f, -0.01831208f, 
    -0.04504938f, 0.07310130f, 0.05949557f, 0.05934115f, 0.02945644f, 0.13507029f, 0.06628708f, 0.00846957f, 
    0.20521928f, 0.06448411f, -0.06862526f, -0.15462554f, 0.08425406f, -0.05994087f, -0.00335011f, 0.00661697f, 
    0.09895528f, 0.00533667f, -0.13452704f, -0.03605776f, -0.02522087f, 0.08545431f, 0.32858416f, -0.03136516f, 
    0.03601885f, 0.06754292f, -0.02741791f, 0.05510602f, -0.78337455f, -0.02143124f, -0.59392256f, -0.36517805f, 
    -0.05952102f, 0.21163391f, 0.17216341f, 0.07503786f, -0.09472461f, -0.33324191f, 0.05666171f, 0.00422409f, 
    -0.12183983f, -0.10407635f, 0.00153531f, 0.17754380f, -0.01027900f, 0.00291508f, 0.03350475f, 0.11568966f, 
    0.00284008f, -0.13609232f, -0.16811487f, 0.19265965f, 0.16123258f, 0.17959434f, 0.11882509f, -0.16295333f, 
    -0.10724896f, 0.05882808f, -0.05048279f, 0.17667398f, 0.19294657f, 0.11558598f, 0.12848671f, 0.05696054f, 
    0.01490291f, 0.08877768f, -0.52420098f, 0.10937367f, 0.07695808f, 0.09958459f, 0.09414092f, 0.36567837f, 
    -0.07571407f, -0.14084199f, -0.08827624f, 0.06611639f, 0.05688757f, 0.08873125f, -0.15747721f, -0.35755801f, 
    -0.13904430f, 0.07330069f, 0.00848495f, 0.12428550f, 0.04768209f, -0.25776270f, -0.00526803f, 0.09842348f, 
    -0.62488717f, -0.38297486f, -0.03442974f, -0.04553880f, 0.05579796f, 0.25247350f, -0.21327108f, -0.04567032f, 
    0.07814972f, -0.00292436f, 0.07887853f, 0.05646512f, 0.05192119f, -0.01763389f, 0.07137268f, 0.04033432f, 
    -0.10612516f, -0.01039322f, -0.48651096f, -0.01626253f, -0.22794734f, -0.05640115f, 0.10086595f, 0.10907950f, 
    0.23000084f, 0.01478586f, -0.05371865f, 0.08881100f, -0.01215656f, 0.16493557f, -0.00226933f, 0.09671304f, 
    0.15314765f, -0.01048320f, -0.02488826f, -0.18433358f, 0.01843641f, -0.04370984f, -0.10762932f, -0.18910418f, 
    -0.17711075f, 0.42536417f, 0.10609177f, -0.12930225f, -0.40395012f, 0.15240739f, -0.07274835f, 0.06723355f, 
    0.11316703f, -0.07868858f, -0.04510032f, 0.00819500f, -0.28567237f, -0.08922857f, -0.07693578f, 0.09627659f, 
    0.01182838f, -0.30960634f, 0.21100745f, 0.26284620f, -0.18798655f, 0.28516874f, 0.05656739f, -0.06271438f, 
    -0.28170362f, -0.13119684f, 0.00558857f, 0.11209050f, -0.11634076f, 0.06914082f, -0.07277659f, -0.04876292f, 
    0.10294621f, -0.00763663f, 0.05952836f, 0.20153928f, -0.17604285f, 0.03824681f, 0.16391164f, -0.12748134f, 
    -0.12749521f, -0.00562508f, 0.27477759f, 0.36254612f, 0.40035838f, 0.00042746f, 0.07543784f, -0.11850262f, 
    0.04727087f, -0.14269903f, -0.08702575f, 0.08427931f, -0.16106775f, 0.18855028f, -0.02955235f, 0.13344540f, 
    0.07299146f, 0.13665138f, 0.06717963f, 0.05820536f, 0.52764374f, -0.22020879f, 0.16471568f, 0.18269579f, 
    -0.17338234f, 0.04810603f, -0.19835921f, 0.05629583f, -0.06398547f, 0.17416476f, 0.01140791f, 0.08499349f, 
    -0.11655255f, -0.11393796f, -0.08316793f, -0.11089683f, -0.01157118f, 0.08761879f, -0.04021635f, -0.16361928f, 
    -0.09958454f, 0.13641302f, -0.02064568f, -0.01727056f, 0.12884565f, -0.07155285f, -0.08188302f, 0.07392099f, 
    -0.04464703f, -0.07310860f, -0.05288946f, 0.19040279f, -0.17373370f, -0.19830273f, -0.04355833f, 0.06933270f, 
    -0.18758690f, 0.28832811f, 0.14952242f, 0.01130123f, 0.01784601f, -0.78816426f, -0.30558243f, -0.54973280f, 
    0.56390941f, -0.13476594f, 0.05945467f, 0.00593745f, 0.09925727f, -0.07057980f, -0.12017647f, -0.00941836f, 
    -0.10661032f, 0.11817173f, -0.11897477f, -0.04206733f, 0.03820724f, 0.21579511f, -0.01466835f, 0.25525776f, 
    0.17497647f, -0.40026039f, 0.04926782f, -0.53827327f, 0.16302034f, 0.02874614f, -0.09699601f, 0.14714983f, 
    -0.13692002f, -0.07892188f, -0.09489923f, -0.12817615f, 0.26687011f, 0.07506350f, 0.18263754f, 0.12591259f, 
    -0.06227166f, -0.01080968f, 0.08776983f, 0.15673646f, 0.40956432f, -0.98989230f, -0.43054143f, 0.29020420f, 
    -0.04682991f, -0.04038797f, 0.13459028f, 0.00836767f, 0.14547272f, 0.05457303f, 0.02024092f, 0.05596651f, 
    0.04719819f, 0.08555648f, 0.12432069f, 0.03920992f, -0.03369689f, -0.02155500f, -0.42265484f, -0.02327994f, 
    -0.55109489f, 0.36152753f, -0.05996877f, 0.25187722f, -0.43916026f, -0.17331830f, 0.00591998f, -0.02535622f, 
    0.10878992f, 0.12078068f, -0.00408132f, -0.08156393f, 0.14172411f, 0.10148092f, -0.05740402f, 0.05750712f, 
    -0.10931440f, 0.02133119f, -0.15232824f, -0.05301360f, -0.24281734f, -0.04784041f, -0.08931503f, 0.18412252f, 
    0.05377444f, 0.08628821f, -0.18686377f, -0.01075421f, 0.16235955f, 0.08192675f, -0.15459463f, -0.06019436f, 
    0.11007127f, 0.22582851f, 0.14638080f, 0.01431898f, -0.11821905f, -0.19295332f, -0.24880920f, -0.14642906f, 
    -0.04024634f, 0.19192825f, 0.21269703f, -0.14303112f, -0.16412443f, 0.23444207f, 0.01933916f, 0.02322483f, 
    0.02634717f, 0.18204986f, 0.01271376f, 0.05864617f, -0.22914846f, 0.00954312f, -0.09039357f, -0.00589913f, 
    0.02797233f, 0.08239616f, -0.02963071f, -0.00218515f, -0.06397488f, -0.53571814f, -0.01873095f, -0.63495523f, 
    0.07650679f, -0.06510644f, -0.08497037f, -0.04209979f, -0.05648824f, -0.03967083f, -0.03877300f, 0.05562420f, 
    0.06859030f, 0.18689324f, 0.06196675f, -0.09899686f, 0.00487631f, -0.16255470f, -0.25089267f, 0.08054624f, 
    -0.01329954f, -0.25333142f, -0.04010345f, -0.28594080f, 0.23525825f, 0.00790495f, 0.10102944f, 0.06208264f, 
    -0.05405397f, -0.11340340f, -0.00677229f, -0.03029252f, -0.27789956f, -0.24439299f, -0.12739952f, -0.02288091f, 
    -0.02000979f, -0.13392505f, 0.21786419f, -0.07567132f, -0.18010397f, 0.22889391f, -0.11922241f, 0.18253663f, 
    -0.30797401f, 0.12813210f, 0.21818705f, -0.19530793f, -0.04755948f, 0.10990496f, 0.02373883f, 0.18702357f, 
    -0.09581400f, 0.01316134f, -0.28050634f, 0.01192883f, 0.00262710f, 0.13584605f, -0.14716341f, 0.03130197f, 
    0.39578813f, 0.27294385f, -0.23572333f, -0.33370069f, -0.04827711f, -0.10359635f, 0.06671529f, 0.05952565f, 
    -0.08685146f, 0.03774180f, 0.11357067f, -0.10330384f, 0.10795093f, -0.25188455f, -0.04610043f, -0.16140674f, 
    0.00783921f, -0.00785824f, 0.06740204f, 0.13098249f, -0.31544402f, 0.07994393f, -0.37232354f, -0.27801082f, 
    0.09803823f, 0.14483376f, 0.09682198f, -0.09121206f, -0.08874977f, 0.06256800f, 0.00163010f, -0.00992557f, 
    -0.07415842f, -0.10044135f, 0.11441430f, 0.03998055f, -0.07537714f, 0.23470213f, 0.17232834f, 0.05777215f, 
    -0.16468519f, -0.28731942f, -0.26667529f, -0.16185398f, 0.03271968f, -0.10069408f, -0.18904293f, -0.08676981f, 
    -0.05579923f, -0.04897347f, -0.11686169f, -0.00733489f, -0.06916478f, -0.01562999f, -0.15862712f, -0.02587833f, 
    0.02574533f, -0.13398567f, 0.01807060f, 0.11951652f, -0.10241645f, 0.00603952f, -0.39312449f, 0.04489980f, 
    0.11821617f, -0.18659431f, -0.06636562f, -0.09502958f, 0.03282718f, -0.11074742f, -0.11595143f, 0.00154198f, 
    0.15490769f, -0.03721408f, -0.09293487f, 0.02651630f, 0.00808052f, -0.05682982f, -0.01500608f, -0.01375725f, 
    -0.29495466f, 0.04625362f, 0.11729624f, 0.06061855f, -0.05593700f, 0.05504522f, -0.36346301f, -0.05284154f, 
    0.16885008f, 0.04732559f, -0.10323574f, 0.22080740f, 0.11503629f, -0.07027376f, -0.18538377f, 0.06676238f, 
    0.00736075f, 0.08847263f, -0.15482290f, 0.02091568f, 0.28973767f, -0.57371253f, 0.22368523f, -0.07472667f, 
    -0.36967105f, 0.12090255f, -0.11239456f, -0.05579386f, -0.13774316f, -0.08046860f, -0.10911443f, -0.08373247f, 
    -0.20656604f, 0.01884812f, -0.17620164f, 0.04054053f, 0.13069353f, -0.02915506f, -0.02911897f, -0.01077443f, 
    -0.22504632f, 0.17279585f, -0.59079206f, 0.10192747f, 0.41903362f, -0.11876624f, -0.21391478f, -0.07034417f, 
    0.04374261f, -0.06608646f, -0.24347951f, -0.00310919f, -0.05102342f, -0.01777144f, -0.04488555f, -0.20736226f, 
    -0.25956234f, -0.03792685f, -0.09723070f, 0.11479528f, 0.06996009f, 0.25627741f, 0.07255103f, 0.10094955f, 
    0.28354600f, -0.22592849f, 0.17547980f, -0.17324211f, 0.06210784f, -0.05215137f, -0.25734723f, 0.07811818f, 
    -0.20507507f, -0.12781039f, -0.05615561f, 0.02895198f, 0.02554937f, 0.04255573f, -0.02630262f, -0.04518651f, 
    0.24127647f, -0.01671381f, 0.31243843f, 0.01342689f, 0.27526718f, 0.00325329f, 0.09429509f, -0.04858741f, 
    -0.03021808f, 0.04735574f, -0.00386881f, 0.14167072f, -0.01970237f, -0.04782305f, -0.02610659f, -0.08196158f, 
    -0.00244368f, -0.09218273f, 0.03357303f, -0.09290423f, 0.23102312f, -0.00909216f, 0.08186478f, 0.00274042f, 
    0.26034251f, 0.15165500f, 0.11066927f, 0.01063063f, -0.04353945f, -0.13601853f, 0.05872767f, -0.04813103f, 
    0.03457070f, -0.02562815f, -0.01591431f, -0.02112880f, -0.01660342f, 0.00249113f, -0.01690265f, 0.09094350f, 
    -0.51608878f, -0.12227525f, -0.16831061f, -0.17055255f, -0.30983722f, -0.10283719f, 0.09996923f, -0.06501020f, 
    -0.06289739f, -0.18455888f, 0.00062907f, 0.00413995f, -0.12714483f, -0.12079243f, -0.07018457f, 0.06110797f, 
    -0.06086708f, -0.08507163f, -0.06405928f, -0.05906228f, -0.02476375f, -0.31100297f, -0.14690731f, -0.20669207f, 
    -0.22536242f, -0.20366485f, -0.11435490f, 0.06963523f, -0.13127525f, -0.15261640f, 0.10405056f, -0.05900754f, 
    -0.04628228f, -0.06849344f, -0.03677310f, -0.00047868f, -0.06930287f, -0.05053646f, -0.11069480f, -0.05184697f, 
    0.09604098f, -0.52984422f, -0.03850451f, -0.00004962f, 0.07012773f, 0.00797288f, -0.06540971f, -0.04704489f, 
    0.00386251f, -0.08068192f, -0.12438080f, -0.06927515f, -0.05534313f, -0.05150682f, -0.01860184f, -0.08741765f, 
    0.06826128f, -0.02355836f, 0.01170639f, 0.07677827f, 0.26121011f, 0.08292716f, 0.51553059f, 0.31517121f, 
    0.20737229f, 0.02074527f, 0.21650812f, 0.05942347f, 0.00990100f, -0.10812211f, -0.07897613f, 0.09160829f, 
    0.13737279f, 0.02183782f, -0.15162131f, -0.03796657f, 0.00787961f, -0.00311338f, 0.05878150f, -0.09353317f, 
    0.15729097f, -0.28711706f, 0.10420574f, 0.13384715f, 0.06443491f, 0.10468280f, -0.10061120f, -0.19159776f, 
    -0.00638427f, 0.01629159f, 0.12473738f, 0.00436682f, -0.01244125f, -0.10723612f, 0.10870080f, -0.05283575f, 
    -0.01174197f, 0.00059079f, 0.17568704f, -0.07201967f, -0.58898509f, 0.26605695f, 0.00350234f, -0.20521948f, 
    0.10646007f, 0.04961327f, -0.02210234f, -0.26154149f, 0.07318069f, -0.18250844f, 0.00050977f, 0.00692755f, 
    0.05854839f, 0.00395411f, -0.12555036f, -0.20426279f, 0.05525035f, 0.19731876f, -0.02347327f, 0.00982998f, 
    0.51860672f, 0.05904308f, 0.40633318f, 0.04541504f, 0.32381126f, -0.25145525f, 0.14423974f, -0.09785607f, 
    -0.05185827f, 0.05863461f, -0.14865789f, 0.00423425f, -0.03189448f, 0.03388431f, -0.05289867f, -0.01904976f, 
    -0.05040004f, 0.05061254f, 0.10048467f, -0.06102505f, 0.23941335f, 0.22343032f, 0.08255638f, 0.02705588f, 
    0.37707949f, 0.05002955f, 0.00804659f, -0.05372011f, 0.00161333f, -0.15521304f, 0.02691636f, -0.07897054f, 
    -0.06590694f, -0.05331957f, -0.05513190f, -0.06025859f, 0.00803715f, 0.05548289f, -0.03210305f, -0.11082762f, 
    -0.28307122f, -0.29679492f, 0.03772629f, -0.09059441f, 0.26978734f, 0.14928566f, 0.10420773f, -0.13336717f, 
    -0.04182916f, -0.04671736f, 0.10563627f, 0.13041675f, 0.05516380f, 0.12230694f, 0.11647417f, -0.16916153f, 
    0.01269394f, 0.12241127f, 0.03527937f, -0.05183735f, -0.11065424f, -0.27819464f, -0.35535315f, -0.03968515f, 
    -0.00146481f, 0.07338616f, -0.06925464f, -0.06976295f, -0.16158099f, -0.12860006f, 0.11269695f, 0.10119787f, 
    -0.05518679f, -0.01741592f, 0.06961325f, -0.08822229f, 0.07573640f, 0.01854792f, -0.08738677f, -0.14389634f, 
    0.00005126f, 0.08232605f, -0.31517586f, 0.09252071f, -0.22861196f, 0.04543398f, -0.03447884f, -0.56096840f, 
    -0.18261081f, 0.05509104f, 0.04444720f, -0.03782222f, 0.07413908f, 0.00431571f, -0.06191521f, -0.02372970f, 
    0.06871857f, -0.19769681f, 0.13972229f, -0.04123493f, 0.20579642f, 0.04793523f, -0.18481387f, 0.24538065f, 
    0.19066253f, -0.04629147f, -0.08057619f, -0.13159439f, 0.00921953f, -0.01570732f, -0.01848096f, 0.02755007f, 
    0.01287129f, -0.11894529f, 0.04092474f, 0.06271804f, 0.06169263f, -0.02346842f, 0.21767673f, 0.04211637f, 
    0.20285419f, 0.08211360f, 0.01733833f, -0.18554510f, 0.01814107f, 0.08261590f, -0.05169240f, -0.09655602f, 
    -0.21293694f, -0.05170463f, 0.07429824f, -0.00575393f, -0.06891264f, 0.15741773f, -0.18036860f, 0.10959052f, 
    0.12924281f, 0.04814401f, -0.05123691f, -0.07306725f, -0.24118002f, 0.27721736f, 0.28408143f, -0.19993196f, 
    -0.28750882f, -0.14529307f, -0.05607666f, -0.01529185f, 0.03309640f, -0.28734091f, 0.23162307f, 0.03627783f, 
    -0.04471988f, 0.06517736f, 0.03461890f, -0.19833860f, 0.01769145f, -0.16424984f, 0.24192938f, -0.14494433f, 
    -0.33480263f, -0.13511099f, 0.35044238f, -0.19077843f, -0.11185289f, 0.20432405f, -0.05766045f, 0.17159493f, 
    -0.06567954f, 0.04052712f, 0.08885350f, -0.09585931f, -0.08060004f, -0.09345912f, 0.06410751f, -0.11793289f, 
    -0.05730186f, 0.09658343f, -0.10178380f, 0.00056391f, 0.06098799f, -0.10106817f, 0.14269368f, 0.01453397f, 
    0.09044330f, -0.24821614f, -0.09810507f, -0.04693523f, -0.11721452f, -0.07909074f, -0.04770756f, -0.19578920f, 
    0.01471100f, -0.13475236f, 0.13378868f, -0.00255147f, -0.05972629f, -0.00128018f, 0.12776564f, 0.15176047f, 
    0.20611525f, 0.04505500f, -0.24655111f, 0.25693795f, 0.21080765f, 0.08067343f, 0.10062855f, -0.14286350f, 
    -0.08916000f, -0.07672693f, 0.00443314f, 0.05384874f, 0.03105816f, -0.08124838f, -0.01674258f, -0.18769258f, 
    -0.08621567f, 0.03016227f, 0.18147530f, -0.02266322f, 0.38638335f, 0.42285314f, -0.08099657f, 0.10747624f, 
    0.17932925f, 0.02292088f, 0.04580070f, -0.05400467f, -0.09794275f, -0.03046510f, 0.02119516f, -0.03596340f, 
    -0.01115739f, -0.13016967f, 0.04035851f, -0.21879169f, -0.03176670f, 0.11097585f, 0.12356733f, -0.08456400f, 
    -0.05724476f, -0.16111131f, -0.47529197f, -0.36214617f, -0.09444493f, 0.14138018f, -0.12994169f, 0.04131562f, 
    0.12259160f, -0.07817655f, 0.06608055f, 0.08960526f, -0.00260441f, 0.06116329f, -0.09911361f, 0.07506836f, 
    -0.02576687f, -0.08813495f, -0.12300622f, 0.04005006f, -0.28571302f, -0.13490854f, 0.36232325f, 0.11612134f, 
    0.30796200f, -0.20001769f, -0.18759806f, 0.06161617f, -0.04905692f, 0.10131931f, 0.00700356f, -0.09768344f, 
    -0.17073083f, -0.13694876f, 0.07824791f, 0.08733676f, 0.00830119f, 0.07650523f, -0.04923576f, 0.13844498f, 
    -0.21392529f, -0.22451197f, 0.22820114f, -0.35085407f, -0.17555007f, -0.18780598f, -0.17241961f, 0.09778557f, 
    -0.15479030f, -0.08055814f, 0.05222648f, -0.01072959f, 0.04344432f, 0.00045686f, -0.09374374f, -0.06959805f, 
    -0.07461972f, -0.09049437f, -0.41728303f, 0.17699715f, 0.03275135f, 0.26854816f, -0.36656642f, -0.15528749f, 
    -0.05246476f, 0.02734132f, -0.00425078f, -0.05921305f, 0.11081026f, -0.04442945f, 0.12663673f, 0.05022436f, 
    0.07630040f, 0.02868684f, 0.17652562f, 0.10694388f, 0.03882822f, -0.07660872f, 0.18300609f, 0.06086224f, 
    -0.38640884f, -0.05543085f, 0.24889386f, -0.40979102f, -0.25600195f, 0.10685077f, 0.12242332f, -0.10423700f, 
    -0.02200093f, -0.11689719f, 0.09448357f, 0.04876915f, -0.02739368f, 0.11870995f, 0.02986837f, -0.00053006f, 
    0.01645494f, -0.02075950f, -0.46036461f, -0.02296123f, -0.27432650f, 0.09598690f, -0.06543490f, -0.65923911f, 
    -0.61557782f, -0.15152000f, 0.04207642f, -0.16282333f, 0.07328659f, -0.08673724f, 0.10794763f, 0.01286380f, 
    0.02673041f, -0.06708657f, -0.02070784f, 0.02480380f, -0.04051546f, -0.21437788f, -0.22799577f, 0.00130629f, 
    0.11887102f, -0.60261548f, 0.35040748f, -0.04413308f, -0.56651783f, -0.18443401f, 0.11313416f, 0.00542790f, 
    -0.11634351f, -0.01103761f, -0.11017147f, 0.01627601f, 0.11871181f, -0.26094162f, -0.12901306f, -0.17291197f, 
    0.15199563f, 0.01306178f, -0.01055339f, -0.20493911f, -0.10299026f, -0.20646505f, 0.06229518f, -0.35515803f, 
    -0.43971664f, -0.06025866f, 0.12368391f, -0.24471776f, 0.04202318f, -0.05247157f, -0.16362584f, -0.01331282f, 
    -0.09030081f, 0.04522633f, 0.04502885f, -0.13408072f, -0.06767888f, 0.09292223f, 0.07395255f, 0.05652183f, 
    0.35704634f, -0.85199845f, 0.23821509f, 0.13589603f, 0.13583915f, -0.05960125f, -0.04689565f, 0.11000855f, 
    0.07510356f, -0.02849015f, -0.08189724f, 0.00151792f, -0.16014160f, 0.04307865f, -0.06318530f, 0.01708939f, 
    -0.10822688f, 0.22339177f, -0.18072473f, 0.04897261f, 0.38264135f, -0.59398401f, 0.16367453f, -0.22576375f, 
    0.03816506f, 0.08383079f, -0.00839414f, -0.06198363f, 0.08770596f, -0.21517073f, 0.13528688f, -0.03200635f, 
    -0.04259269f, -0.03544512f, 0.08364367f, -0.01724298f, 0.00863666f, -0.23580319f, -0.04399258f, 0.10294541f, 
    0.53146309f, 0.10922745f, -0.25171196f, -0.78225029f, -0.39522427f, -0.10211502f, 0.00977972f, 0.16846988f, 
    -0.09709460f, -0.13303369f, -0.26892513f, -0.13498792f, 0.06288960f, 0.11157022f, -0.01735210f, 0.04164243f, 
    0.08652895f, -0.23170190f, 0.14107314f, 0.03134320f, -0.16768235f, 0.45844844f, 0.15696312f, 0.50544560f, 
    -0.04617003f, 0.07586714f, 0.06274059f, 0.10830183f, -0.04808725f, 0.08993674f, -0.10040642f, -0.08667655f, 
    0.05978262f, 0.14858963f, 0.23863462f, 0.13040653f, 0.03548125f, 0.17084819f, -0.33779126f, -0.08898659f, 
    0.52169430f, -0.21225570f, -0.11107852f, 0.08137340f, -0.06978411f, -0.03403931f, 0.11063958f, 0.01169431f, 
    0.05334828f, 0.03053192f, -0.16515838f, 0.04415916f, 0.11701868f, 0.09859314f, -0.01836726f, 0.15650508f, 
    0.05900965f, 0.00223376f, 0.11802996f, 0.13692686f, 0.03331691f, -0.17326026f, 0.07484736f, -0.25653762f, 
    0.37971184f, 0.33503976f, -0.11939120f, 0.02972290f, -0.13001931f, 0.15273182f, -0.09710959f, 0.03473134f, 
    0.15176429f, 0.27657995f, -0.00108112f, -0.00466180f, 0.23433173f, -0.21987920f, -0.04813829f, -0.26686445f, 
    -0.86295408f, 0.15597366f, 0.05939501f, 0.06358216f, -0.18205415f, 0.18686934f, 0.13749354f, -0.00617146f, 
    0.00636155f, -0.03778368f, -0.02142589f, 0.09944087f, -0.12806588f, -0.02362923f, 0.04266634f, 0.10572852f, 
    0.00079503f, 0.03761471f, -0.11553531f, 0.04030941f, 0.08043598f, 0.19275558f, -0.14732115f, 0.06549986f, 
    -0.14089300f, 0.08128455f, 0.14693548f, 0.04437421f, -0.01762181f, -0.28229183f, 0.11253856f, 0.08282581f, 
    -0.03021128f, -0.03882464f, 0.09593975f, 0.08862703f, -0.05672888f, -0.12478804f, 0.06337555f, -0.05196005f, 
    -0.21385363f, -0.22936803f, 0.39388129f, -0.35157269f, -0.29647133f, -0.16300629f, -0.00598374f, -0.00008992f, 
    -0.02310704f, 0.02622173f, 0.07855222f, -0.05185201f, 0.22726448f, -0.14013629f, -0.10118137f, -0.12903993f, 
    -0.01028749f, 0.01557861f, 0.15011209f, 0.10090066f, 0.17971341f, -0.28134513f, -0.15021600f, 0.38366857f, 
    -0.06169244f, 0.11687206f, 0.00302802f, -0.05869999f, 0.05676085f, 0.26748875f, 0.01853655f, 0.02745508f, 
    -0.07551976f, -0.03462894f, 0.10760726f, -0.16714230f, -0.18240310f, 0.05873715f, 0.03075676f, 0.00851642f, 
    0.23828246f, -0.28921100f, -0.18706779f, 0.02730618f, 0.17114609f, -0.11236432f, 0.02932605f, 0.07228344f, 
    0.01790703f, 0.03096586f, 0.00121817f, -0.07673185f, 0.01720227f, -0.26282725f, -0.09303879f, 0.18471949f, 
    -0.06970231f, 0.17110434f, 0.19225545f, 0.07169016f, -0.54151392f, 0.10751770f, 0.31511199f, -0.33815491f, 
    -0.09131209f, -0.12159958f, 0.06895303f, 0.03217149f, -0.06421883f, 0.03825921f, -0.00282492f, -0.05817285f, 
    -0.02016312f, -0.24951586f, -0.14288796f, -0.00486550f, -0.10536715f, 0.12888600f, 0.04068625f, -0.16274564f, 
    -0.22505677f, -0.58830798f, -0.19040123f, 0.05535523f, 0.07732841f, -0.07114875f, 0.26917264f, -0.13884820f, 
    -0.17705077f, 0.00991330f, 0.09206440f, 0.03165656f, -0.11616272f, 0.09078407f, 0.04516767f, -0.13481610f, 
    0.03329544f, -0.08090533f, 0.19865881f, -0.00622167f, -0.28061271f, -0.04531894f, 0.00607669f, -0.10764812f, 
    0.07666636f, -0.10550062f, 0.00573181f, -0.03231306f, -0.04718984f, -0.04292698f, -0.02688504f, -0.08242653f, 
    -0.12874714f, 0.03750944f, 0.04832314f, 0.17987049f, 0.01774829f, 0.01111482f, 0.02454174f, 0.23643304f, 
    -0.74869514f, 0.06665540f, -0.03920559f, -0.05111265f, -0.31758794f, 0.31255591f, -0.19176599f, 0.01277460f, 
    -0.12724105f, 0.00006737f, -0.08983640f, 0.07754222f, -0.04580696f, 0.23161843f, -0.04034167f, -0.00343701f, 
    -0.15083528f, -0.07813093f, -0.30742934f, -0.15320028f, -0.38236409f, -0.08550837f, 0.18970735f, -0.18281759f, 
    -0.46711013f, 0.18130113f, 0.03036076f, -0.03218766f, -0.02634772f, 0.15231538f, 0.02663067f, 0.10883307f, 
    -0.11354193f, 0.14758468f, 0.16487879f, 0.08232837f, -0.03033869f, -0.14303727f, -0.29416564f, -0.10645827f, 
    -0.25172299f, -0.13361591f, -0.31033754f, 0.23848280f, 0.10188883f, -0.10950265f, -0.09536542f, 0.00172195f, 
    -0.00830727f, 0.12842523f, 0.04756385f, -0.02180894f, 0.18395725f, -0.13508864f, 0.32616854f, -0.00867805f, 
    0.04428150f, 0.02762651f, 0.01208046f, -0.14069198f, -1.06534624f, -0.11682830f, -0.61919123f, -0.17735972f, 
    0.14342520f, 0.10035913f, 0.10958946f, -0.29748634f, 0.02056220f, 0.11293788f, 0.00516576f, 0.04681464f, 
    0.03331495f, -0.02543515f, 0.12385808f, 0.03475569f, 0.00074256f, 0.26438317f, -0.01028742f, 0.24834426f, 
    -0.23655485f, 0.09155461f, 0.11573392f, -0.08909424f, -0.37652516f, 0.18131487f, -0.13016462f, -0.12779538f, 
    0.03400651f, 0.10858204f, 0.07423281f, 0.17866649f, 0.12173672f, 0.06152520f, 0.11580955f, 0.08471023f, 
    0.23437114f, 0.12712222f, 0.01566225f, 0.12895201f, -0.41176239f, -0.37665206f, -0.04411281f, 0.11375234f, 
    0.16072732f, 0.10865645f, -0.03657933f, 0.16895385f, 0.01367417f, -0.03897367f, 0.08196248f, -0.03904655f, 
    0.06628599f, -0.09114591f, 0.02429251f, 0.05607560f, -0.20074020f, -0.21827726f, 0.28289676f, 0.03599771f, 
    0.09880079f, -0.25535166f, -0.06392439f, -0.08524316f, 0.14995912f, -0.14816290f, 0.04326836f, -0.21596679f, 
    -0.06567900f, -0.15515731f, 0.01797492f, 0.08425084f, -0.00410867f, -0.13910878f, -0.08328830f, -0.08413246f, 
    -0.04686733f, -0.17770736f, -0.33077845f, 0.09096766f, -0.11040359f, 0.30836454f, -0.30899328f, 0.14112413f, 
    -0.07032192f, -0.13586403f, 0.03855015f, -0.10958177f, 0.05372995f, 0.06410441f, 0.01471114f, 0.00085215f, 
    0.01570985f, -0.17683294f, 0.03500320f, -0.13092545f, -0.10359587f, 0.15691808f, 0.00562515f, 0.05279386f, 
    -1.05840743f, -0.99447984f, -0.24234325f, -0.13823943f, -0.31090131f, 0.19855632f, 0.04976749f, -0.05529472f, 
    -0.14691201f, -0.00079441f, 0.11438007f, -0.08120712f, 0.01730907f, 0.10733309f, 0.03573475f, 0.00277672f, 
    0.03170729f, 0.12229723f, 0.04751565f, 0.12203179f, -0.17372714f, -0.41061801f, -0.19472331f, -0.16824140f, 
    -0.11704852f, 0.03674061f, 0.12351081f, -0.19849734f, -0.04493359f, 0.03313363f, 0.12095135f, -0.04321249f, 
    -0.01523667f, -0.04570483f, -0.00503046f, -0.17316121f, 0.06292072f, 0.22164887f, 0.23246995f, 0.12039258f, 
    0.31818485f, 0.16957468f, 0.22351426f, 0.01208407f, -0.02926599f, 0.21830934f, -0.13441913f, 0.13280138f, 
    0.05918268f, 0.03621042f, -0.13573125f, 0.06072799f, -0.04233535f, 0.14896160f, -0.03598531f, 0.19948177f, 
    -0.00105830f, 0.03927231f, -0.17791621f, -0.09717171f, 0.46796322f, 0.05697182f, 0.03035054f, -0.03630498f, 
    -0.04719323f, -0.32961148f, -0.18995526f, -0.08289035f, 0.05557930f, -0.06717096f, -0.08705380f, -0.05837525f, 
    -0.19626014f, -0.04681147f, -0.15348306f, -0.17088854f, 0.09500346f, 0.07600204f, -0.16218962f, -0.07240580f, 
    0.32329366f, 0.39158329f, -0.03963367f, -0.05889133f, 0.13629670f, 0.01862982f, 0.07085480f, 0.15472235f, 
    0.02695061f, 0.12895218f, 0.01782626f, -0.04152457f, 0.19291727f, -0.02667620f, 0.02929390f, 0.22754043f, 
    0.21507409f, 0.07243890f, -0.18867727f, 0.19648758f, -0.00215271f, -0.34778270f, -0.16828619f, -0.02878062f, 
    0.22702961f, 0.14019680f, 0.00684621f, -0.04906690f, 0.05284948f, -0.17808570f, 0.09286658f, 0.00808839f, 
    0.08744441f, 0.10212694f, -0.00482097f, 0.19030856f, 0.12380717f, -0.20051524f, 0.06716635f, -0.02920832f, 
    0.23210701f, 0.12633824f, 0.01494461f, -0.14134270f, -0.27982271f, 0.28567776f, 0.07283857f, 0.02860813f, 
    0.02270321f, 0.00368288f, -0.02568066f, -0.11409374f, -0.04318668f, 0.02789461f, -0.12960589f, 0.06381612f, 
    -0.07482594f, -0.06110111f, -0.07115158f, 0.18068187f, 0.30880329f, -0.01338910f, 0.05047611f, 0.11445054f, 
    -0.00616885f, 0.13052405f, 0.07877067f, 0.26669040f, 0.03171128f, 0.10180618f, -0.01022801f, -0.03867432f, 
    -0.01086246f, -0.08234229f, -0.00447174f, 0.02885314f, 0.10327570f, -0.71857637f, -0.17296171f, -0.05674255f, 
    0.73819888f, 0.31775516f, -0.27204064f, -0.45576832f, -0.07944948f, 0.09580577f, 0.06325067f, -0.00531445f, 
    0.11160133f, -0.14803918f, 0.20627625f, -0.19880344f, -0.01544747f, -0.12386443f, 0.14999615f, -0.05157668f, 
    -0.16009720f, -0.04152407f, 0.01542856f, 0.25604433f, 0.33514875f, 0.39957705f, -0.28030255f, -0.28966659f, 
    0.48091704f, 0.07613081f, -0.15276612f, -0.06404898f, 0.07214991f, 0.01883206f, 0.14695728f, 0.14344054f, 
    -0.00247236f, -0.02597344f, -0.19413485f, 0.08741178f, 0.07770675f, 0.22817110f, -0.00161606f, 0.12223633f, 
    -0.06849557f, -0.07002886f, -0.13418140f, 0.20513868f, -0.37773633f, -0.00601401f, 0.16389643f, -0.17102203f, 
    0.06179140f, -0.17647326f, -0.10062569f, -0.06561626f, 0.01272813f, 0.07284032f, 0.01697715f, -0.06664487f, 
    -0.08958748f, -0.04269804f, -0.25952148f, -0.32272378f, -0.19700122f, 0.03475980f, -0.15402053f, 0.06990643f, 
    -0.12714501f, -0.06712527f, 0.03052236f, -0.16598189f, 0.04009834f, 0.08334597f, -0.03830754f, 0.02453735f, 
    0.12051362f, -0.01324287f, 0.05809188f, 0.08930318f, -0.01386614f, -0.13555764f, -0.04733941f, -0.04009990f, 
    0.27228007f, -0.18082412f, -0.14116409f, -0.02628383f, 0.36314306f, 0.12812847f, -0.09860425f, 0.00959492f, 
    0.14729965f, 0.07976737f, 0.05743013f, -0.02981248f, 0.06037596f, -0.03016434f, 0.05245032f, 0.21235901f, 
    -0.01990197f, 0.00988685f, -0.08143976f, -0.03124368f, 0.11379980f, -0.26659742f, 0.15839863f, 0.18394026f, 
    0.03082047f, 0.10025632f, -0.30495691f, -0.02783593f, -0.13027376f, -0.01026310f, -0.03899173f, 0.05797635f, 
    0.06680351f, -0.05244185f, -0.07392690f, -0.14557765f, 0.18795200f, -0.02228057f, -0.05749585f, -0.17453976f, 
    -0.55202359f, 0.49331132f, 0.00989822f, -0.11526073f, 0.10691617f, 0.04306467f, -0.21975350f, 0.06721905f, 
    0.04015379f, -0.10292234f, -0.00276398f, -0.04437584f, 0.04583482f, -0.01335515f, 0.14500615f, -0.02858245f, 
    -0.01973852f, -0.01330647f, -0.07596278f, 0.06151124f, -0.66113448f, -0.41196519f, 0.21385014f, -0.09383754f, 
    0.22415033f, -0.23456113f, 0.25774562f, 0.08382437f, 0.15287550f, 0.06466446f, -0.01831822f, -0.00581192f, 
    0.02060172f, 0.12717462f, -0.03754414f, -0.01761891f, -0.10289075f, -0.04738821f, -0.30573261f, 0.12032896f, 
    0.43820465f, 0.16991775f, -0.27540198f, 0.05350073f, -0.49910331f, 0.02447382f, 0.06346980f, 0.06976876f, 
    0.00150427f, -0.03694959f, 0.05670613f, 0.18339707f, -0.08218654f, 0.04016878f, 0.13874729f, 0.01407657f, 
    -0.00877916f, 0.02470496f, -0.01554098f, 0.03149688f, -0.58065093f, -0.84450638f, -0.23748451f, -0.35382006f, 
    -0.50458837f, 0.09669022f, 0.06877490f, 0.24836652f, -0.03425344f, 0.14532065f, -0.09333572f, 0.05514852f, 
    0.03309733f, -0.12209694f, -0.15709111f, -0.16424797f, 0.03347377f, -0.09497657f, -0.17938161f, -0.07131787f, 
    0.56377590f, -0.03941540f, -0.33576751f, 0.00137333f, 0.03381036f, -0.02485783f, -0.06507927f, 0.03609424f, 
    0.15924640f, -0.02185219f, 0.04869063f, -0.10330240f, -0.00109967f, 0.08440550f, 0.10694647f, -0.10845961f, 
    -0.06851918f, 0.00528368f, 0.11418238f, 0.04645991f, -0.15345636f, 0.04135605f, 0.11475216f, -0.02783232f, 
    -0.31062767f, -0.11739037f, -0.10601642f, 0.04506330f, -0.21154839f, -0.17816937f, -0.16955423f, -0.12810197f, 
    -0.00358828f, -0.00300377f, -0.17896117f, -0.11126630f, -0.13757564f, -0.03996462f, -0.12345410f, -0.07064997f, 
    -0.67347717f, 0.17606162f, -0.08326377f, -0.02905411f, 0.09180016f, -0.40074703f, -0.01002347f, 0.02887687f, 
    0.08213007f, -0.23580766f, 0.06954376f, -0.03668037f, -0.23994446f, 0.12475892f, -0.03418867f, 0.01730304f, 
    -0.08851003f, -0.10296827f, 0.23623022f, 0.11283998f, 0.22881466f, 0.27396503f, -0.32409316f, 0.11663895f, 
    0.24844685f, 0.31406406f, 0.21238665f, -0.03230473f, 0.02262335f, 0.02494767f, 0.09940796f, 0.30113411f, 
    0.07354014f, 0.01741740f, 0.01818120f, -0.04640613f, -0.06120839f, -0.00043986f, -0.10065878f, 0.04588294f, 
    -0.59199923f, 0.42008197f, -0.26095793f, -0.44114715f, 0.41033930f, 0.04686771f, -0.15220155f, 0.17349173f, 
    -0.09240357f, -0.04390998f, -0.18334889f, 0.02866281f, 0.10610107f, -0.06278070f, 0.19729789f, -0.04747257f, 
    -0.05449159f, 0.00626231f, 0.18645775f, -0.04027727f, -0.11806950f, -0.01511092f, -0.20886561f, -0.08537336f, 
    0.14845425f, -0.08888936f, -0.23085019f, -0.10235974f, 0.08096896f, -0.16390096f, 0.30389765f, 0.15026519f, 
    -0.02275177f, 0.00772296f, -0.08753653f, 0.19716190f, 0.13824353f, -0.03008885f, 0.08933705f, 0.17252287f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11683547f, 0.04157645f, -0.04092197f, -0.06230703f, -0.02603863f, 0.01062298f, 0.03049509f, -0.06795015f, 
    -0.07905986f, -0.01201793f, 0.13546954f, 0.05444332f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
