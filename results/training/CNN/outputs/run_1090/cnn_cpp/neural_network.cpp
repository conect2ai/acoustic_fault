#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.46446010f, -0.38673335f, -0.07728627f, 0.12915805f, -0.79705304f, -0.76627660f, 0.36086154f, 0.04332301f, 
    0.41536075f, 1.16862822f, -0.53904849f, -0.63540310f, 0.60042173f, 0.35614923f, 0.25169444f, -0.24154413f, 
    0.50649428f, -0.26651400f, -0.04885838f, 0.28926659f, 0.29036200f, 0.47144979f, 0.42583802f, 0.67429018f, 
    0.06020601f, -0.66379482f, 0.20307952f, 0.03893536f, 0.06909963f, -0.63385552f, -0.67922598f, -0.39384666f, 
    -0.70720345f, 0.05689571f, -0.33095720f, 0.45538503f, 0.31429911f, 0.03347274f, 0.57187182f, -0.28727531f, 
    -0.78320175f, -0.53700179f, -0.04857973f, 0.20126387f, 0.15244842f, 0.22538763f, 0.28612724f, -0.44145828f, 
    -0.60056096f, 0.05020722f, -0.06531904f, -0.46863735f, -0.13841552f, -0.57326150f, 0.07690193f, 0.48410517f, 
    0.41720533f, -0.11505126f, 0.59612077f, -0.26809701f, -0.01616547f, -0.41503945f, -0.35724723f, 0.82744306f, 
    -0.10851672f, 0.63662452f, -0.15592954f, 0.12476882f, -0.07879779f, 0.19767715f, 0.47942063f, -0.18790831f, 
    -0.41797942f, 0.64106148f, -0.00659951f, -0.33961460f, 0.37669316f, -0.59687144f, 0.36630982f, 0.34976894f, 
    0.41757682f, -0.64225352f, 0.78564984f, -0.82293880f, -0.07190412f, 0.38170341f, -0.73083413f, -0.15499096f, 
    -0.14553580f, -0.07618205f, 0.03536122f, -0.41916171f, 0.27973706f, -0.26399437f, -0.32355732f, 0.81871605f, 
    0.28515747f, 0.03041575f, 0.46954188f, 0.69016731f, -0.62366420f, 0.18068281f, -0.14586234f, 0.79558784f, 
    -0.60835749f, -0.12645288f, -0.08170541f, -0.06489170f, -0.39688966f, -0.89773846f, -0.44121850f, 0.72963536f, 
    0.61603773f, 0.36291403f, -0.28300932f, -0.23647645f, -0.17992045f, -0.10623959f, -0.12815614f, -0.11737075f, 
    -0.44196433f, 0.00754524f, 0.17214590f, -0.38243237f, 0.72785664f, -0.47654289f, -0.29945114f, 0.42192081f, 
    0.81193078f, 0.49665734f, -0.54639798f, 0.01330991f, -0.52874392f, -0.29527330f, -0.07841171f, -1.04202068f, 
    -0.39276475f, 1.14070451f, 0.06643149f, 0.15329599f, -0.26077953f, -0.09304830f, 0.03849575f, -0.24784368f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.18323871f, 0.19171247f, -0.07830440f, 0.00586657f, 0.23272374f, 0.29097417f, 0.41095558f, 0.38518253f, 
    -0.06029829f, 0.36542311f, 0.45408469f, -0.10339657f, 0.03933206f, 0.28274843f, -0.01084294f, -0.11086180f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.51093227f, 0.20615526f, 0.40543953f, -0.14298442f, -0.22633974f, -0.24023695f, 0.06299661f, -0.05924359f, 
    0.13894290f, 0.17609845f, -0.09030057f, 0.16864020f, 0.02363810f, -0.04564393f, 0.08378462f, -0.03532086f, 
    -0.04384676f, 0.10165136f, -0.02969918f, -0.00137721f, -0.06703508f, 0.00389247f, -0.25006622f, -0.27715752f, 
    0.04711936f, -0.14373583f, 0.02386852f, -0.23180261f, -0.05046052f, -0.50792545f, -0.03482975f, 0.09781216f, 
    -0.20123686f, 0.01706713f, -0.02868253f, 0.07442890f, -0.17491123f, -0.08308371f, -0.04206738f, -0.02866247f, 
    0.15199117f, -0.03561053f, 0.12862615f, -0.09198664f, 0.28257921f, -0.00552676f, 0.17127225f, 0.17095158f, 
    0.00008233f, 0.02944319f, -0.04898653f, 0.05303774f, 0.02619476f, -0.00590100f, 0.03452021f, 0.18846938f, 
    -0.09283642f, 0.06535381f, -0.09372492f, -0.26494333f, 0.08709528f, 0.01098697f, -0.04287275f, 0.43086645f, 
    0.18158807f, 0.14220202f, 0.12347033f, 0.21894726f, 0.04057484f, -0.08341654f, 0.07286488f, 0.08212240f, 
    -0.63902080f, -0.39008656f, 0.02121469f, 0.08003858f, 0.25496405f, 0.08824559f, 0.25964603f, 0.01964921f, 
    0.02296680f, -0.19185257f, 0.10910045f, 0.20456158f, 0.08255432f, -0.07323435f, 0.20214382f, 0.06970850f, 
    -0.00445302f, -0.10697620f, -0.12854314f, 0.29336494f, 0.12369391f, 0.00725503f, 0.00640564f, 0.21042661f, 
    0.17328292f, 0.19386759f, 0.11343396f, 0.15024564f, -0.09512274f, 0.20659609f, -0.24827138f, -0.11430001f, 
    0.00140588f, 0.01113175f, -0.12285338f, 0.14646411f, -0.44931924f, -0.19003853f, -0.19981538f, -0.03680479f, 
    -0.01463293f, -0.07699753f, -0.05084661f, -0.05408802f, -0.00363312f, -0.07438146f, 0.22262019f, 0.17078599f, 
    0.08174761f, -0.07806788f, 0.08377205f, 0.06219692f, 0.14702564f, 0.21645749f, -0.20032409f, 0.12653452f, 
    0.22230814f, -0.07058757f, 0.18765213f, -0.17534971f, 0.03331573f, 0.13308834f, -0.02567747f, -0.64057887f, 
    -0.21036431f, 0.19076766f, 0.00154320f, 0.26628739f, -0.14358643f, 0.00983619f, 0.08564202f, 0.15193000f, 
    -0.15978558f, -0.09290410f, 0.28422487f, 0.00155443f, -0.21983434f, -0.15321888f, 0.19374351f, 0.08503330f, 
    0.02906584f, 0.57399762f, 0.12308703f, -0.09968200f, 0.13230658f, 0.05287639f, -0.23304446f, 0.07154287f, 
    0.05561073f, -0.05170052f, 0.26336235f, 0.15692626f, 0.25998124f, -0.16805556f, 0.01186591f, -0.19708855f, 
    -0.02211107f, 0.03066050f, 0.08987433f, -0.01793267f, -0.23721537f, -0.18146951f, -0.00819941f, -0.15026318f, 
    -0.06962617f, 0.06590585f, -0.06694486f, 0.04959190f, -0.27635452f, -0.52193093f, 0.00552384f, 0.00958755f, 
    0.21899611f, 0.00167381f, -0.13364133f, -0.02527403f, -0.08877340f, -0.03182630f, -0.26198220f, -0.36808571f, 
    -0.00877212f, -0.09769449f, 0.04068661f, 0.12578352f, 0.21571343f, 0.06012934f, 0.32154912f, 0.04889823f, 
    0.09119491f, 0.08945660f, 0.12154122f, 0.12836830f, 0.07665326f, 0.10378720f, 0.19080478f, 0.01111397f, 
    -0.22873186f, -0.13327488f, 0.27204069f, 0.01154124f, -0.12542905f, 0.05427295f, -0.02401550f, 0.02633578f, 
    -0.50080007f, 0.02187365f, -0.08520462f, 0.21626504f, 0.23766610f, 0.12772128f, -0.03275986f, -0.12983261f, 
    -0.14999013f, -0.28722540f, -0.44459146f, -0.13326325f, -0.11973874f, -0.01926407f, -0.05353484f, -0.04796233f, 
    -0.07021724f, -0.16781409f, 0.05610187f, -0.02166484f, -0.08609500f, -0.17823713f, 0.03165831f, 0.16209053f, 
    0.02363492f, -0.10188700f, 0.12034869f, -0.12735994f, -0.10257655f, 0.04608083f, 0.04684245f, 0.07376964f, 
    0.26048928f, 0.49838638f, -0.12102282f, 0.02432135f, 0.15986735f, 0.44820213f, 0.25259680f, -0.09044387f, 
    0.05645093f, -0.16337836f, 0.22560617f, 0.15276529f, -0.17850032f, -0.65837014f, 0.37251067f, -0.04304080f, 
    -0.22439614f, -0.06664519f, -0.00742571f, -0.10649185f, 0.15490034f, 0.09519704f, 0.00405793f, -0.05194771f, 
    0.26830938f, 0.14606094f, 0.12240071f, -0.02321857f, 0.17863500f, 0.03898318f, 0.03782742f, -0.55234236f, 
    -0.24683842f, -0.04856395f, -0.42301053f, -0.39645046f, -0.01870843f, 0.15209156f, 0.06384649f, 0.04458300f, 
    -0.31261495f, -0.23423173f, 0.08531309f, 0.09367381f, -0.05079821f, -0.34729242f, 0.04122981f, -0.11252052f, 
    -0.15799697f, -0.25384116f, 0.13385195f, 0.41791245f, 0.05912602f, 0.28584102f, 0.23532704f, 0.11755630f, 
    -0.09047154f, 0.09467179f, -0.06642868f, 0.04149325f, -0.16738652f, 0.03556873f, 0.01737424f, -0.06322562f, 
    0.06773216f, -0.00007126f, -0.12271982f, -0.22361787f, -0.13378194f, -0.10238449f, 0.12863591f, -0.17061195f, 
    -0.06552168f, -0.03812875f, -0.10683762f, 0.00124763f, 0.19571058f, 0.03033703f, 0.27667394f, -0.03507869f, 
    -0.09241337f, 0.09640337f, 0.07175089f, -0.05641827f, 0.04326301f, -0.09018022f, -0.00344699f, 0.08515333f, 
    0.14522307f, 0.17390031f, 0.02946181f, 0.07902851f, 0.00179647f, 0.26606768f, -0.01260082f, 0.22991419f, 
    0.28101382f, -0.01555619f, -0.00272089f, -0.11865129f, 0.05836721f, 0.06645221f, 0.08728899f, 0.12596577f, 
    0.32155687f, 0.14864172f, 0.01034562f, -0.04786780f, -0.04121801f, -0.03974389f, -0.02228505f, -0.33381656f, 
    -0.23374625f, -0.10693777f, -0.08372486f, -0.00047886f, 0.12012776f, -0.35668248f, -0.04724880f, -0.12340394f, 
    -0.39870214f, -0.06091929f, 0.05866234f, 0.38303447f, -0.07859411f, 0.28215730f, 0.07104901f, 0.01041426f, 
    0.21851338f, 0.23149334f, 0.08202567f, 0.03735035f, -0.06898262f, -0.07335670f, 0.06069443f, -0.09376937f, 
    -0.06677543f, -0.12878199f, -0.36635432f, 0.06492499f, -0.15945408f, 0.36217552f, 0.20614982f, -0.05887001f, 
    0.09731461f, 0.29894364f, 0.14594617f, -0.18786749f, -0.08107433f, -0.26981586f, -0.21829581f, -0.00896394f, 
    0.06234923f, 0.08441401f, -0.15239356f, 0.11583669f, 0.22160499f, 0.14464387f, -0.13034263f, 0.26513022f, 
    0.05368672f, 0.04045051f, 0.09748179f, -0.06174807f, -0.16892271f, 0.22719274f, 0.17471534f, 0.05272911f, 
    0.14865831f, -0.10493212f, -0.08811868f, 0.04656127f, -0.04940325f, 0.04009619f, -0.20619012f, -0.19757740f, 
    -0.01194937f, -0.09306895f, -0.01457436f, 0.19227350f, 0.16005754f, 0.13133954f, -0.28540212f, 0.19313517f, 
    0.15344302f, 0.34036189f, 0.00515164f, 0.12544507f, 0.00345656f, 0.19098771f, -0.01874786f, -0.09461516f, 
    0.03418825f, 0.91068029f, -0.34727409f, -0.30294120f, 0.07851601f, -0.09197972f, -0.01792836f, -0.00226219f, 
    0.03830412f, -0.02361350f, -0.38931540f, -0.49508446f, 0.04620625f, -0.02350035f, -0.22303170f, -0.14667960f, 
    0.10854086f, 0.00515463f, 0.20531222f, 0.13640478f, 0.22495665f, 0.00465498f, 0.00646483f, -0.16197744f, 
    0.14546740f, -0.02647500f, 0.00241930f, 0.02116630f, -0.01252645f, -0.06465130f, -0.28834593f, -0.20753907f, 
    -0.18527019f, -0.30255511f, 0.03607246f, 0.00601790f, 0.03475458f, -0.04269984f, 0.21073495f, 0.40236905f, 
    -0.00368645f, 0.04958309f, -0.04972420f, 0.05777031f, 0.02432263f, -0.08414469f, -0.12514827f, -0.47892800f, 
    -0.11566892f, -0.18549694f, -0.02832843f, -0.13926409f, -0.07097290f, -0.00722249f, -0.03093459f, -0.13186829f, 
    -0.10965841f, -0.02806595f, -0.16509964f, 0.01135253f, 0.01674727f, -0.05272065f, 0.05925966f, -0.04669625f, 
    0.30246815f, -0.26400548f, 0.11675067f, -0.02478616f, -0.22997804f, -0.11987390f, -0.16548835f, 0.05185863f, 
    -0.01086616f, -0.18418641f, 0.14920428f, -0.26575151f, 0.06231927f, 0.17942800f, 0.04182107f, 0.13685991f, 
    0.05233439f, -0.09350882f, -0.12442226f, -0.03026475f, 0.13331009f, -0.08883345f, 0.26014599f, 0.10744159f, 
    0.04455337f, 0.10480917f, -0.07117564f, -0.05401479f, -1.03192008f, -0.55525041f, -0.56141335f, -0.28939793f, 
    0.03869471f, -0.06203887f, 0.17921244f, 0.00987895f, 0.32623586f, -0.07092604f, -0.04769543f, 0.13727641f, 
    0.21492435f, 0.16745853f, 0.07572538f, 0.04138036f, 0.03013302f, 0.06522942f, -0.00355011f, 0.02076724f, 
    0.08604037f, 0.16577417f, -0.00172111f, -0.01803495f, 0.03745244f, -0.11126119f, -0.50746959f, 0.23778933f, 
    -0.32442665f, 0.07852801f, 0.14309937f, -0.07114203f, 0.05754299f, 0.00112208f, -0.10613702f, 0.43188941f, 
    0.07939932f, 0.15125299f, 0.07140180f, -0.25236839f, 0.24557458f, 0.06746036f, 0.17563221f, 0.04168688f, 
    0.37707210f, 0.40939754f, 0.32554153f, -0.02351595f, -0.03891310f, 0.11517713f, 0.19047330f, 0.09076541f, 
    0.11902171f, -0.36999437f, -0.07447981f, -0.29337436f, 0.09819110f, -0.03244337f, -0.05235947f, -0.02972093f, 
    0.08046697f, -0.14743404f, 0.07782234f, -0.10199745f, -0.29745498f, -0.00419402f, -0.11094502f, -0.00608819f, 
    -0.01409643f, -0.03880621f, 0.08090507f, 0.07888295f, 0.39200693f, 0.13104340f, 0.20825785f, 0.18202963f, 
    -0.14174770f, -0.01369616f, -0.09811287f, -0.12137005f, -0.25937977f, -0.02560509f, -0.17815208f, 0.02322916f, 
    0.19662504f, 0.18461233f, -0.06473204f, 0.01025950f, 0.09576257f, 0.16702001f, 0.17788929f, 0.04406163f, 
    0.11987811f, -0.02648138f, -0.04536312f, 0.02567924f, -0.06005445f, -0.14675996f, 0.15852803f, -0.25327089f, 
    -0.01252502f, 0.12173105f, -0.00651455f, -0.13945356f, -0.02240904f, -0.02350411f, 0.07963978f, -0.24631380f, 
    -0.03728116f, -0.09489883f, 0.00953366f, 0.04591159f, -0.00369639f, 0.01600602f, 0.06516939f, -0.06701276f, 
    0.02816433f, 0.11378678f, 0.17896557f, -0.19084433f, -0.13714013f, 0.07982447f, -0.01647427f, 0.14341238f, 
    0.25831842f, -0.14663139f, 0.20331101f, -0.09294719f, -0.14563167f, 0.11026696f, 0.09033300f, -0.01242234f, 
    0.01423514f, -0.16126063f, -0.04281003f, 0.13328728f, -0.11921205f, -0.01507879f, -0.06949493f, 0.23953561f, 
    0.02803812f, 0.09020343f, 0.05377197f, 0.17116936f, 0.28096935f, 0.02570162f, 0.03763132f, -0.06049110f, 
    -0.18420671f, -0.03654964f, -0.02786414f, 0.28628722f, 0.00061618f, -0.18733561f, -0.12037443f, 0.07430011f, 
    -0.05578325f, -0.02589120f, 0.02040455f, -0.08791122f, 0.03087958f, -0.21442203f, 0.24226199f, 0.20378077f, 
    -0.01922269f, 0.08957346f, -0.09755147f, -0.07914705f, 0.22951570f, -0.16163963f, -0.51119930f, -0.62045950f, 
    -0.18217289f, -0.02157218f, -0.09321333f, -0.13629337f, 0.13669154f, 0.17759679f, -0.07212030f, -0.04344075f, 
    -0.17952719f, 0.11467938f, 0.11473788f, 0.22752835f, 0.04007267f, -0.04812900f, -0.06501398f, 0.02376009f, 
    -0.28548774f, -0.26265672f, 0.16190892f, -0.17326024f, 0.01518915f, 0.10773775f, -0.00904730f, 0.02631533f, 
    -0.03453195f, 0.31764224f, -0.00268783f, -0.22749016f, -0.05694700f, 0.06343963f, -0.05537961f, -0.11206522f, 
    -0.16876480f, -0.03352623f, 0.02819561f, -0.11576809f, 0.00748362f, -0.11395552f, 0.09421892f, -0.09634534f, 
    -0.01961848f, -0.17264253f, -0.27477404f, 0.03549530f, 0.00065118f, 0.21135043f, 0.00131915f, 0.06837068f, 
    0.26016885f, 0.06367390f, 0.05160998f, -0.29511654f, -0.01160312f, -0.10157658f, 0.02378028f, -0.00005496f, 
    0.03781455f, 0.00745557f, 0.12586796f, 0.19391970f, -0.03583831f, 0.26149383f, -0.11125283f, 0.08097216f, 
    0.12065541f, 0.12685704f, 0.20900515f, 0.00674976f, -0.15691181f, -0.19899784f, -0.10939975f, -0.21092556f, 
    0.05574132f, 0.13981657f, 0.19546251f, 0.12271203f, 0.03173904f, -0.25593975f, -0.31761020f, -0.02685154f, 
    0.14141110f, -0.05438798f, 0.07059482f, -0.00756426f, 0.14287533f, 0.21151924f, 0.01620343f, 0.22534911f, 
    -0.23243499f, -0.10017301f, 0.09758449f, 0.17475846f, -0.16900587f, -0.09299816f, -0.02822898f, 0.14883643f, 
    0.14542927f, -0.16453771f, 0.47088632f, 0.14622417f, 0.03075201f, -0.10166187f, 0.05150342f, 0.16775209f, 
    -0.27732292f, 0.04354229f, -0.04223320f, -0.03973117f, -0.06970919f, -0.01925979f, 0.05617885f, -0.04098657f, 
    0.23630323f, 0.20798792f, 0.11840510f, 0.34668338f, 0.02092900f, -0.11728059f, -0.13900274f, 0.09693608f, 
    0.07294774f, -0.18421526f, 0.08450694f, 0.08203463f, 0.02573199f, 0.00942272f, -0.32484549f, 0.04968486f, 
    -0.12042882f, 0.03056531f, -0.08155918f, -0.02269427f, -0.15943816f, 0.03131302f, -0.15772957f, -0.11507367f, 
    0.15221640f, 0.06446547f, 0.22924714f, -0.06390201f, 0.12007569f, 0.10100534f, -0.16978541f, -0.29847306f, 
    -0.06823179f, 0.12132548f, -0.03560363f, 0.05737812f, 0.04611656f, -0.19545016f, -0.13203162f, -0.17947400f, 
    -0.12228645f, 0.33243683f, 0.12783925f, -0.23637240f, 0.08856939f, 0.00259958f, -0.15578625f, -0.04337592f, 
    0.12813270f, -0.04178834f, 0.56861418f, -0.28113997f, 0.21290673f, -0.04318039f, 0.03729409f, -0.10654058f, 
    0.03549640f, -0.08446538f, -0.18612172f, 0.35877120f, -0.07692427f, -0.12014496f, 0.19588059f, -0.10806024f, 
    0.02737863f, 0.00836955f, -0.10353583f, 0.11977898f, -0.02335631f, -0.07199562f, -0.24353933f, -0.24646106f, 
    0.05976239f, -0.09772260f, -0.14538981f, -0.04619214f, 0.31971875f, 0.08636099f, -0.08545518f, 0.10437168f, 
    0.12063487f, 0.01895721f, 0.06121358f, -0.04183490f, -0.34510252f, 0.12763862f, 0.18136695f, -0.10537715f, 
    0.17741553f, 0.10277130f, 0.07170689f, 0.11310574f, 0.12383023f, -0.26699299f, -0.07392325f, -0.23468852f, 
    0.14369269f, -0.17739536f, 0.01307070f, -0.00326114f, 0.08224127f, -0.32389039f, 0.02328922f, -0.09675682f, 
    -0.02998519f, -0.02490114f, -0.05696733f, -0.05298585f, -0.01315877f, -0.07146543f, 0.03301588f, -0.04488187f, 
    0.04093274f, 0.23321092f, -0.04784869f, 0.15995482f, 0.05009075f, 0.15713455f, 0.06059428f, 0.00206715f, 
    0.35278428f, 0.42247033f, -0.03267036f, 0.16182478f, 0.02420153f, 0.16436204f, 0.11044411f, 0.33949837f, 
    0.26795405f, 0.05916877f, -0.08152829f, 0.07187971f, -0.09799571f, -0.10825369f, -0.07623369f, 0.07101294f, 
    -0.03126284f, -0.20584047f, 0.08450842f, 0.12192761f, -0.17572092f, 0.20242278f, -0.06764000f, -0.10417072f, 
    -0.00235022f, 0.13435791f, 0.14404015f, 0.41361248f, -0.23459093f, 0.43280941f, 0.02802958f, 0.03290490f, 
    0.08795575f, -0.20056760f, 0.06793067f, 0.01604917f, 0.49704915f, -0.20845778f, -0.30675980f, -0.11703238f, 
    -0.15653573f, -0.28529465f, 0.02892659f, -0.19870031f, -0.05068286f, -0.11021493f, -0.15753698f, -0.36115384f, 
    0.15526706f, 0.16408738f, -0.11415891f, 0.08038934f, -0.13634856f, -0.03312062f, -0.06995705f, 0.06782351f, 
    -0.10354839f, 0.07167719f, 0.02541025f, 0.04809023f, -0.03743235f, -0.11581279f, 0.13268156f, 0.08577675f, 
    0.11582339f, -0.17405000f, 0.02437113f, 0.14178963f, 0.18022779f, -0.09791591f, 0.22425078f, -0.21733123f, 
    -0.04565873f, -0.07475802f, 0.00157160f, 0.01231717f, -0.05383837f, -0.13770583f, 0.12671518f, -0.01935952f, 
    -0.03387303f, 0.65715748f, 0.08341087f, -0.03896058f, -0.07798417f, -0.15574808f, -0.22543114f, 0.01861240f, 
    0.11034820f, 0.07672241f, -0.18332799f, -0.22193782f, -0.02019887f, 0.33427903f, 0.08117314f, -0.18663664f, 
    0.01826169f, 0.03476412f, -0.20262940f, -0.06452969f, -0.25676221f, 0.17776398f, -0.04317393f, -0.04225318f, 
    -0.09898879f, 0.10189132f, 0.03423974f, -0.03943232f, -0.56757665f, -0.19864817f, -0.07566574f, -0.15986429f, 
    -0.11833702f, 0.14053820f, -0.29072151f, 0.07308527f, 0.09364787f, 0.12134838f, 0.02821896f, 0.19633636f, 
    -0.17595182f, 0.13892926f, -0.07374993f, -0.06977130f, 0.14458352f, -0.07904875f, 0.14703377f, -0.35073376f, 
    0.23267969f, -0.08882567f, -0.04656240f, -0.02820100f, -0.06514569f, -0.02348379f, -0.13854687f, -0.35287651f, 
    0.00893882f, 0.35437807f, 0.07366566f, -0.00228749f, 0.13302201f, -0.07956702f, 0.04060294f, 0.20082749f, 
    -0.35359699f, -0.16196732f, 0.20506851f, -0.07240663f, 0.03257692f, 0.01899766f, -0.11533201f, -0.21753415f, 
    0.03530424f, 0.17524570f, -0.21335468f, 0.16148162f, 0.07745777f, 0.04961444f, 0.17673144f, 0.09598624f, 
    -0.03972515f, 0.04794738f, -0.37165403f, -0.10692489f, -0.04945111f, 0.08658312f, 0.17081012f, 0.13638712f, 
    0.11164799f, 0.00356695f, 0.18424870f, -0.60831189f, -0.14805795f, 0.06659956f, -0.19329987f, 0.05290361f, 
    -0.15277518f, -0.10022733f, -0.05042884f, 0.06653296f, 0.01104428f, 0.17764656f, -0.05915289f, 0.08325484f, 
    -0.00908812f, -0.07837792f, 0.06168701f, 0.02871890f, -0.05719899f, -0.15455531f, 0.05905679f, 0.25654757f, 
    -0.08880857f, 0.07352531f, -0.04349459f, 0.07101192f, 0.13893461f, 0.20197922f, -0.29694626f, -0.14845541f, 
    -0.00970325f, -0.12433270f, 0.08568984f, -0.05614224f, 0.01186337f, 0.01295528f, -0.03800493f, 1.12193072f, 
    0.34391028f, -0.06599147f, -0.00819351f, -0.09701157f, 0.13240109f, -0.07993348f, 0.04386562f, -0.02968198f, 
    0.21338865f, 0.04517885f, -0.21230324f, -0.06444646f, -0.20294663f, -0.19943310f, -0.06411320f, -0.11576304f, 
    -0.01390670f, 0.10747115f, 0.01860422f, 0.07673315f, 0.10376746f, -0.03621747f, 0.00095274f, 0.13623254f, 
    0.04936898f, -0.02793414f, -0.07654262f, 0.09991486f, 0.36511922f, -0.13210681f, -0.05539837f, -0.03475672f, 
    0.03205667f, -0.20514466f, 0.15037736f, -0.00192504f, -0.40057769f, -0.07325818f, -0.06196946f, -0.01656402f, 
    0.09897828f, -0.02477256f, 0.06186391f, 0.01547345f, 0.24544097f, 0.42920294f, 0.32001761f, -0.14356564f, 
    -0.11842767f, -0.05544635f, 0.12401070f, 0.17850399f, 0.15966660f, 0.03953914f, 0.00246503f, 0.10972311f, 
    0.01907908f, -0.00903041f, -0.13128667f, 0.07914890f, -0.01796527f, -0.06731879f, 0.14620294f, 0.19313616f, 
    0.25755274f, -0.06897476f, 0.05663122f, -0.12062699f, -0.14028938f, -0.04787327f, 0.24278012f, 0.15267329f, 
    0.15415624f, 0.02574098f, 0.07186717f, -0.12793162f, -0.04955155f, 0.17139013f, 0.04694893f, 0.00540725f, 
    -0.06271509f, -0.06096643f, -0.08913019f, -0.10627699f, -0.03609078f, -0.01069632f, 0.05238800f, -0.03509680f, 
    -0.16577896f, -0.38232774f, -0.25580141f, -0.76567924f, 0.15737490f, 0.02496107f, 0.21238577f, -0.01743217f, 
    0.21752298f, 0.05243585f, 0.04375739f, -0.15809073f, -0.05077413f, 0.12585385f, 0.07125314f, -0.07380609f, 
    0.01362237f, 0.02162968f, -0.06718103f, 0.38358185f, -0.17591031f, -0.10183171f, -0.08165525f, 0.22302838f, 
    0.09477090f, -0.01517120f, 0.06295621f, 0.05030254f, -0.11922029f, -0.75637913f, -0.70708913f, -0.05662870f, 
    -0.13411731f, 0.18553406f, -0.03881344f, -0.12665001f, -0.09995755f, 0.06772303f, -0.39566714f, -0.18193635f, 
    -0.04342062f, 0.12453763f, 0.08001022f, 0.08364055f, -0.27250960f, 0.02876448f, -0.04017670f, -0.01788022f, 
    0.20221223f, -0.05541104f, -0.10949259f, 0.01097408f, 0.05031571f, -0.07459787f, 0.02996262f, 0.49613440f, 
    -0.40953711f, -0.48940963f, 0.00591217f, 0.09623141f, 0.22585699f, 0.25444809f, 0.13532566f, -0.06071635f, 
    0.22200330f, -0.12313740f, 0.32332671f, 0.08863515f, 0.02625458f, -0.12032914f, 0.11979235f, -0.36603132f, 
    0.10630237f, -0.39229566f, 0.01156995f, -0.29767376f, -0.32815659f, -0.11941483f, -0.01994456f, 0.16363880f, 
    0.21399353f, 0.12111180f, 0.27904129f, -0.17998984f, -0.16073893f, -0.02344690f, 0.06044114f, -0.01877205f, 
    -0.00455351f, 0.10302457f, 0.26140618f, 0.35591608f, 0.25528374f, 0.52251691f, -0.05848630f, 0.10651076f, 
    -0.01608904f, 0.02373670f, -0.13286172f, 0.07281122f, -0.11034395f, 0.03419587f, 0.26837707f, -0.05985599f, 
    0.05660289f, -0.00187949f, -0.08466352f, -0.21889038f, -0.00357188f, 0.20089294f, -0.08207283f, 0.35670000f, 
    -0.00550328f, -0.08076826f, 0.13747956f, 0.09559469f, 0.19057377f, 0.05479850f, 0.03585143f, -0.15657759f, 
    -0.08148056f, 0.14779378f, 0.05130062f, -0.07057216f, 0.03911125f, -0.00954817f, -0.11433685f, -0.10781445f, 
    -0.08728188f, -0.00153734f, -0.20208573f, 0.20799404f, -0.10515516f, 0.22642142f, -0.02092843f, 0.22404617f, 
    -0.23386875f, 0.12295065f, -0.33946702f, -0.14918643f, 0.01217240f, 0.04114631f, -0.13184820f, 0.05915160f, 
    -0.23685053f, 0.06010684f, 0.32053140f, 0.16871195f, -0.16850141f, -0.00518866f, 0.06787735f, 0.00182527f, 
    0.16620432f, -0.01884978f, -0.06569529f, 0.27950212f, -0.20737818f, 0.18317474f, -0.23599392f, 0.06943695f, 
    -0.04292862f, 0.09058440f, -0.12281703f, -0.23252350f, 0.31958196f, 0.17370197f, -0.08963180f, -0.00218664f, 
    0.05377398f, 0.26602316f, -0.04513805f, 0.08201680f, -0.04438708f, 0.10125188f, -0.12771657f, 0.21195993f, 
    0.12189084f, 0.23685405f, -0.13900997f, 0.05548884f, 0.14713378f, 0.07400449f, 0.00986426f, 0.29941982f, 
    -0.27739307f, 0.09858320f, 0.09384791f, 0.05432894f, 0.11195747f, 0.18338430f, -0.05054792f, 0.15812422f, 
    0.14935777f, 0.10106259f, -0.29137614f, -0.03092061f, -0.19111972f, 0.04179788f, -0.14819865f, -0.28834823f, 
    0.59315026f, 0.40254775f, 0.14925662f, 0.13733739f, -0.45445928f, 0.23178740f, 0.02709563f, 0.01427679f, 
    0.04949540f, -0.10141311f, -0.00155705f, -0.01922463f, -0.01051437f, -0.05214272f, -0.07732733f, -0.00589840f, 
    -0.03589148f, -0.09987753f, 0.04383255f, -0.06290688f, -0.01949252f, -0.00535807f, -0.07187819f, 0.01748423f, 
    -0.08390007f, -0.00189592f, -0.07076703f, -0.00122629f, 0.00695031f, 0.04774281f, 0.05336018f, -0.02937938f, 
    -0.01458775f, -0.05403174f, -0.04895053f, -0.02887390f, 0.03786121f, -0.06361548f, -0.06849724f, 0.02828750f, 
    -0.05868488f, 0.06177147f, -0.05228219f, -0.00098848f, -0.08069288f, 0.03666825f, -0.01929063f, -0.05632158f, 
    -0.05685800f, -0.02010474f, -0.03977245f, -0.00312905f, -0.06213034f, 0.03734172f, 0.05201852f, -0.06019089f, 
    -0.01041721f, 0.03514629f, -0.08144809f, -0.03300847f, 0.01451482f, -0.09794717f, 0.02804250f, -0.01536569f, 
    -0.01883845f, 0.01936585f, -0.09460858f, -0.02905868f, 0.05096843f, -0.03414348f, -0.04669582f, -0.06698289f, 
    -0.01297199f, -0.07795742f, -0.02203627f, 0.05165311f, -0.05041960f, -0.00615500f, -0.05509211f, -0.01935272f, 
    0.04170612f, -0.04827277f, 0.00208822f, 0.05135227f, -0.11053760f, -0.02730595f, -0.00032923f, 0.02615161f, 
    -0.08780333f, -0.02966784f, -0.08163562f, 0.04959756f, -0.08636113f, -0.02288680f, 0.02573557f, -0.04173135f, 
    -0.06398392f, 0.01974300f, -0.05887722f, -0.09805786f, -0.01408699f, 0.03610299f, -0.03523496f, -0.06048779f, 
    0.02971439f, -0.02233856f, -0.00942970f, 0.00271919f, -0.01247715f, -0.00106532f, 0.01332906f, 0.04547506f, 
    0.03302103f, 0.02989586f, -0.01311090f, 0.00631881f, 0.01138063f, -0.01574535f, -0.09349261f, -0.00729252f, 
    -0.04915950f, 0.03797173f, -0.07697878f, -0.03851876f, -0.05558927f, -0.03044065f, 0.02277609f, -0.01751126f, 
    0.02906535f, 0.01372221f, -0.03609587f, 0.03948629f, 0.03178087f, -0.10641125f, -0.02318139f, -0.03280975f, 
    -0.09081991f, 0.07089550f, 0.03440825f, -0.07054984f, -0.07826087f, -0.00366939f, 0.06083555f, 0.03055380f, 
    -0.02658495f, 0.06050501f, -0.07313353f, -0.02341948f, -0.03349141f, 0.05370731f, -0.03140021f, 0.03090098f, 
    0.11329257f, -0.05895381f, -0.28693402f, 0.24996066f, -0.02065260f, -0.00450148f, 0.19159287f, 0.15668179f, 
    0.04892643f, -0.16580069f, -0.12580766f, -0.12894200f, 0.09561653f, 0.19181223f, 0.09063222f, 0.08761620f, 
    0.00795666f, -0.17260467f, -0.11508204f, -0.05025968f, 0.09086704f, 0.15903352f, -0.00955564f, 0.15911227f, 
    -0.00928581f, -0.04360867f, -0.09898172f, 0.05564184f, 0.06388958f, -0.40436625f, 0.08124044f, -0.12688908f, 
    -0.03001134f, -0.09209792f, 0.24259877f, 0.09029046f, 0.09387720f, -0.01504582f, 0.10024245f, 0.21120638f, 
    -0.00451057f, 0.02250195f, 0.25616342f, 0.23811536f, -0.04697134f, -0.11127523f, -0.11631068f, -0.08780784f, 
    -0.03839265f, 0.06345867f, -0.02503878f, -0.09027300f, -0.02389131f, -0.09124637f, -0.34218085f, -0.21274731f, 
    0.05042490f, -0.03999148f, 0.00905557f, -0.00874221f, -0.14905210f, -0.10821851f, -0.01435739f, 0.16362149f, 
    0.11670213f, 0.14939271f, 0.07334913f, 0.01032633f, 0.08878678f, 0.10197522f, -0.08712626f, -0.12197482f, 
    0.10040351f, 0.06191467f, -0.01116529f, -0.19284035f, 0.10191449f, -0.18347688f, 0.14067660f, 0.38922760f, 
    0.27254120f, -0.03394473f, 0.22433631f, -0.00098811f, 0.20802923f, -0.10816127f, 0.07224364f, -0.32694581f, 
    -0.15783961f, -0.06019795f, 0.05969767f, 0.10871971f, 0.03649120f, -0.05705883f, 0.04505198f, 0.02699727f, 
    -0.08243326f, 0.24801937f, 0.12341734f, 0.35570538f, -0.35207307f, -0.25963476f, 0.32683042f, 0.15440936f, 
    -0.13500193f, 0.08020420f, -0.25459942f, 0.03568884f, -0.00711739f, -0.04904520f, -0.14851260f, 0.00375681f, 
    0.14336108f, 0.01839946f, -0.24415326f, -0.20153113f, -0.20930451f, 0.14262362f, -0.12739174f, 0.13229379f, 
    0.05991389f, 0.01030644f, 0.01272428f, -0.02325276f, -0.09351955f, -0.03611506f, -0.07986282f, 0.34810254f, 
    -0.09887347f, 0.08955663f, -0.17804031f, 0.06939174f, -0.11085443f, -0.00818588f, -0.29178566f, -0.08458605f, 
    0.03983970f, -0.04270789f, 0.21048351f, -0.03325238f, 0.22792491f, 0.06220023f, -0.06598826f, -0.00053568f, 
    -0.37988919f, -0.43516028f, 0.03910488f, -0.06116576f, -0.03901348f, -0.26587334f, 0.05754849f, -0.07410816f, 
    -0.09705833f, 0.35632455f, 0.09562480f, -0.12339259f, 0.05493323f, 0.06128499f, 0.22689468f, -0.01342406f, 
    0.17297332f, 0.09797458f, -0.20834614f, -0.17043766f, -0.12289418f, -0.19448252f, -0.22023550f, -0.03693204f, 
    -0.02206857f, -0.02808441f, -0.11548407f, -0.06404740f, -0.43557367f, -0.17086707f, -0.07400128f, 0.01152495f, 
    -0.15476844f, -0.07156106f, 0.00457644f, 0.04800687f, -0.22580099f, -0.06506013f, -0.09035528f, 0.32281977f, 
    -0.04405551f, 0.08523967f, 0.16861559f, 0.02143859f, 0.14151476f, -0.27304974f, -0.29252321f, -0.00993389f, 
    -0.01672325f, 0.31972989f, 0.17600620f, 0.11711267f, -0.10357013f, 0.06932886f, -0.27820179f, 0.14366196f, 
    -0.08501711f, -0.03547893f, -0.12250583f, -0.03812697f, 0.01800717f, -0.04288911f, 0.06809853f, -0.00742574f, 
    0.02954207f, -0.19312036f, 0.02868195f, -0.01651340f, 0.14074433f, 0.17034344f, 0.11180537f, 0.27181563f, 
    -0.25114387f, -0.09979004f, -0.06483683f, -0.18686599f, 0.00119692f, 0.01649067f, 0.11406909f, 0.05338477f, 
    0.01241216f, -0.13578388f, 0.09646966f, -0.01869944f, 0.06359161f, -0.06077255f, 0.16052400f, 0.08186324f, 
    -0.08081923f, 0.02616953f, 0.25047091f, 0.10178582f, 0.15085894f, 0.13962616f, 0.09592886f, -0.00514891f, 
    0.14345156f, 0.21782608f, 0.37538719f, -0.07691841f, -0.68606526f, -0.46042761f, -0.10285110f, -0.13115868f, 
    -0.42520228f, 0.13296083f, 0.10695247f, 0.05587099f, 0.02973729f, 0.39082399f, 0.41012454f, -0.30350390f, 
    -0.05892685f, 0.04685617f, -0.02617965f, -0.01185449f, -0.06299340f, 0.11347830f, 0.09083083f, 0.24921183f, 
    -0.00548625f, -0.02115140f, 0.00503085f, 0.13742608f, 0.07672034f, 0.29869956f, -0.51846522f, 0.05086425f, 
    -0.10314077f, 0.04528468f, -0.09405191f, 0.05193178f, 0.02479628f, -0.02634791f, -0.09938677f, 0.10620530f, 
    -0.30828130f, -0.07766578f, -0.16374627f, -0.13826989f, 0.20350696f, -0.00624790f, 0.02652154f, -0.02592982f, 
    -0.03142832f, 0.18443719f, 0.25481787f, 0.02123491f, -0.03467167f, 0.00212220f, 0.10928511f, 0.15761690f, 
    0.05258378f, 0.16674490f, -0.02263921f, -0.12552261f, -0.03836537f, 0.06763960f, -0.05726884f, -0.09548505f, 
    0.00453146f, 0.18970367f, 0.00121098f, -0.00511778f, -0.24992780f, -0.01826147f, -0.06737430f, -0.07320780f, 
    -0.09560848f, -0.11874848f, 0.04083087f, -0.16907465f, 0.22923106f, 0.26519555f, 0.03619457f, 0.04473582f, 
    -0.14319240f, 0.11118455f, 0.07060378f, 0.02959229f, -0.19528113f, 0.04815650f, 0.13571143f, 0.12548152f, 
    0.15508623f, 0.14450836f, 0.01426258f, 0.18175730f, 0.10576301f, 0.26039621f, -0.08159302f, -0.01853249f, 
    0.23462245f, 0.04726861f, -0.03666447f, 0.00747236f, 0.11953931f, -0.02298673f, -0.03893204f, -0.25941756f, 
    -0.11502884f, -0.06894617f, -0.02876955f, 0.05855687f, 0.05485775f, -0.09350998f, -0.17441243f, -0.35293564f, 
    -0.19737454f, 0.07075460f, -0.00500988f, -0.01393874f, 0.05949209f, -0.04081653f, 0.29981476f, 0.02047537f, 
    -0.19860129f, -0.04818084f, 0.05850098f, 0.30006802f, -0.03766893f, -0.07167100f, -0.04859127f, 0.08526166f, 
    0.28756484f, -0.02869829f, 0.10957087f, 0.35249734f, -0.04651248f, 0.04070586f, 0.04730490f, -0.02971489f, 
    -0.16139652f, 0.07094917f, -0.20985672f, 0.21720639f, -0.25187504f, 0.20499849f, 0.01613175f, 0.03085550f, 
    0.14156984f, 0.21167350f, -0.00081848f, -0.18474580f, 0.16318057f, -0.19084756f, -0.05954988f, -0.11510423f, 
    0.06550946f, -0.29291534f, -0.17106415f, -0.05841384f, -0.41417509f, 0.56939197f, 0.34903073f, 0.13547857f, 
    0.01496086f, 0.04750017f, 0.05140441f, -0.24273123f, -0.22078831f, 0.20882791f, 0.09622315f, 0.09547328f, 
    -0.10145731f, 0.03778986f, -0.04012666f, 0.06881890f, -0.11107249f, -0.06645708f, -0.46598914f, -0.75531656f, 
    0.07089202f, 0.02441319f, -0.17700247f, 0.01504438f, 0.11523715f, -0.00115589f, -0.03533651f, -0.31996885f, 
    -0.35493919f, 0.31055224f, -0.03116974f, 0.20793930f, -0.08253018f, -0.10486818f, 0.23870376f, -0.18848835f, 
    0.14262846f, -0.15119648f, -0.29838330f, 0.16500361f, 0.02492046f, 0.27039155f, 0.00407722f, 0.04238220f, 
    -0.21178949f, -0.10759260f, 0.01152694f, 0.11713704f, 0.13260718f, -0.18900239f, 0.23827954f, -0.03578301f, 
    0.01371382f, 0.07594951f, -0.31409392f, -0.13387844f, -0.24173351f, 0.02269400f, 0.06642441f, 0.00881095f, 
    0.09600694f, 0.15427972f, -0.21218051f, -0.20507047f, 0.10383064f, 0.09135216f, 0.18896611f, -0.01682762f, 
    0.03119857f, -0.22256891f, -0.02829341f, -0.08290352f, 0.31578162f, 0.22177842f, -0.08281677f, 0.00386802f, 
    -0.00903670f, 0.02921051f, -0.03891286f, 0.13666528f, -0.14531489f, 0.01473300f, 0.13493425f, 0.04060183f, 
    0.16781805f, -0.24407479f, 0.14156167f, 0.04443060f, 0.16086423f, 0.21846181f, -0.00120201f, 0.11689606f, 
    0.10069100f, 0.04090219f, 0.08013511f, 0.07219339f, 0.02441231f, 0.05909276f, 0.14791189f, 0.01194338f, 
    -0.02847835f, -0.35062677f, 0.00033729f, 0.06024533f, 0.09899824f, 0.18459935f, -0.24549605f, -0.00852294f, 
    0.04338541f, 0.15499809f, -0.11594296f, -0.09100197f, -0.17117925f, -0.04658496f, -0.45626679f, -0.43321827f, 
    -0.18599220f, 0.13940215f, -0.06936199f, -0.05103385f, 0.22308272f, 0.02709718f, -0.02818275f, 0.12333444f, 
    0.14996055f, 0.13295253f, 0.09060171f, -0.14333820f, 0.03690260f, -0.04797409f, 0.17912601f, 0.06440970f, 
    -0.03226985f, 0.00948433f, -0.29519504f, -0.17844221f, 0.28991047f, 0.02024389f, 0.01721961f, 0.14728515f, 
    0.16854538f, 0.36461696f, -0.02208482f, 0.20888756f, 0.14790507f, 0.05716997f, 0.10158978f, -0.07735983f, 
    -0.01228923f, 0.07395760f, 0.13418885f, 0.01068672f, 0.19075967f, 0.15127066f, 0.04340417f, -0.07289620f, 
    0.03169157f, 0.05387804f, 0.05113556f, 0.08883321f, -0.03190243f, -0.09200959f, 0.26069358f, 0.20236576f, 
    0.04656359f, -0.21947226f, 0.00534404f, 0.12442907f, 0.20314540f, 0.22684923f, 0.04224430f, 0.38420218f, 
    0.10854018f, -0.44235268f, -0.14873539f, 0.09290623f, -0.15881321f, 0.15485340f, -0.00093079f, -0.00778338f, 
    0.39678657f, 0.31737900f, 0.11616149f, 0.04876243f, -0.25455347f, -0.07249848f, -0.00024192f, 0.09563177f, 
    0.07514910f, 0.18367225f, 0.01814024f, 0.06454081f, -0.08167166f, -0.08144082f, -0.04778946f, 0.05585480f, 
    -0.03726159f, 0.03309375f, 0.19729985f, 0.05581058f, 0.41259977f, -0.07597730f, -0.06877773f, -0.27064082f, 
    0.05531318f, -0.09034519f, 0.05027180f, 0.17685197f, 0.32500732f, 0.14404178f, -0.06083472f, -0.16574158f, 
    0.01257072f, -0.05505531f, -0.03305001f, 0.03903443f, -0.02374274f, -0.01871085f, -0.04785363f, 0.00552007f, 
    0.15988353f, 0.03510987f, -0.11409152f, -0.04197938f, -0.07452272f, -0.12635800f, -0.02872992f, -0.14548787f, 
    0.18224862f, -0.03551833f, 0.16395719f, 0.10843685f, 0.04181013f, 0.08739363f, -0.31305152f, -0.24887188f, 
    0.20219420f, 0.02366071f, 0.05264115f, -0.23341727f, 0.12276174f, -0.18657446f, -0.00985686f, -0.16886178f, 
    -0.06845561f, 0.08155858f, -0.06596387f, 0.05562032f, -0.12249389f, 0.13573672f, 0.11846351f, 0.15918176f, 
    -0.10017736f, 0.07380468f, -0.19166717f, -0.23521024f, -0.04955959f, -0.02316021f, 0.08704136f, 0.06856140f, 
    -0.06466503f, -0.22030221f, 0.09738236f, -0.18626224f, 0.04390674f, -0.09974459f, 0.20448409f, -0.06549683f, 
    0.11151778f, 0.07796069f, -0.23763406f, -0.03903119f, 0.25630221f, 0.07041074f, -0.01620013f, 0.06419813f, 
    0.15456553f, 0.01266955f, 0.07195862f, -0.75284165f, -0.52733296f, 0.24601288f, -0.01902500f, -0.23136528f, 
    -0.23772252f, -0.05203334f, -0.01403623f, 0.00797565f, 0.30698106f, -0.31412756f, -0.10250565f, 0.09995368f, 
    0.15591027f, -0.10415315f, 0.02477529f, -0.04520232f, 0.04265346f, -0.11521173f, 0.28458738f, 0.21803868f, 
    0.03458934f, 0.07344417f, -0.11837906f, -0.08694410f, 0.30876130f, 0.10624616f, -0.75447428f, -0.50144982f, 
    -0.15370274f, -0.07280222f, -0.07923307f, -0.03380419f, 0.04335409f, 0.00083592f, -0.03818652f, 0.15343407f, 
    -0.06872008f, -0.15758836f, -0.08230469f, -0.09257048f, 0.12170767f, 0.06546379f, -0.06191446f, -0.08070404f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.17261428f, 0.10918584f, 0.06647796f, -0.16121070f, -0.05652678f, 0.27287984f, -0.14200059f, 0.21599165f, 
    0.40036449f, -0.00264352f, -0.10397583f, -0.01684327f, 0.44863033f, 0.14530720f, 0.15333980f, 0.11991926f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26242113f, 0.16059923f, -0.21448421f, -0.02264732f, 0.48889288f, 0.20586351f, 0.10791746f, 0.55350399f, 
    0.23127370f, -0.19969183f, 0.04574361f, -0.26134846f, -0.33330837f, 0.33248106f, -0.14278653f, 0.26960507f, 
    -0.48034877f, 0.04287022f, -0.28363454f, 0.34775254f, 0.36000186f, -0.08829407f, -0.25665599f, -0.15206969f, 
    -0.47040769f, 0.34388205f, -0.15636998f, -0.03188442f, -0.07961302f, 0.20349917f, 0.31932861f, 0.26808044f, 
    -0.33450210f, -0.21205021f, 0.07559313f, 0.06865857f, 0.51239824f, -0.03602685f, 0.51926166f, 0.19600113f, 
    0.38177827f, 0.47439134f, -0.17866282f, -0.01947495f, -0.38425070f, 0.36451378f, -0.08879628f, 0.41565868f, 
    0.18976384f, 0.03976059f, -0.26035577f, -0.00907966f, -0.12491375f, 0.20073508f, -0.26125699f, 0.19945419f, 
    -0.21460633f, -0.17273447f, -0.07523045f, -0.02595991f, -0.05931863f, 0.01527604f, -0.26483619f, 0.12393643f, 
    -0.22013804f, 0.04143369f, 0.14637610f, -0.46880376f, 0.20743291f, -0.26843974f, 0.25768232f, -0.26185957f, 
    0.40608296f, 0.06141112f, -0.01860115f, -0.09132927f, -0.18464807f, -0.08156446f, 0.03691945f, 0.14185937f, 
    -0.14442660f, -0.61556453f, 0.27639332f, -0.47883788f, -0.16061369f, 0.27849072f, -0.13929874f, -0.22123900f, 
    -0.42269599f, 0.36977372f, -0.07167757f, 0.16306253f, 0.38718456f, 0.37210640f, -0.18567386f, -0.24155550f, 
    0.59313148f, -0.47860739f, 0.37888333f, -0.20253782f, 0.27155605f, 0.08942702f, -0.14356090f, -0.07399058f, 
    -0.43719938f, 0.10143967f, -0.17660023f, 0.03095432f, -0.13668223f, 0.05728263f, -0.31929514f, 0.55194211f, 
    0.46024278f, -0.31348956f, 0.17730823f, -0.13656092f, 0.10869825f, 0.45582944f, -0.47047293f, -0.19984184f, 
    0.13363323f, 0.30638909f, -0.23822361f, 0.34426719f, 0.17897533f, -0.25785577f, -0.33027551f, -0.13331780f, 
    -0.24602208f, -0.07718754f, -0.00567353f, -0.14186779f, -0.12149459f, 0.14840978f, 0.08311984f, -0.04411396f, 
    -0.14993334f, -0.10056469f, 0.00138441f, -0.16315293f, -0.09843785f, 0.10115996f, -0.05825150f, -0.22728357f, 
    -0.29298949f, -0.10998880f, 0.14408846f, 0.23115036f, 0.03261938f, 0.00858742f, 0.54626101f, 0.47577032f, 
    0.19459131f, 0.03994606f, -0.17849123f, -0.00258923f, -0.04440488f, -0.07222465f, 0.03587677f, 0.28476372f, 
    0.16863045f, -0.04597462f, -0.16118565f, 0.20023499f, 0.34558585f, -0.33675697f, 0.23021977f, -0.08266456f, 
    -0.19264711f, -0.31086785f, 0.16690315f, 0.35938799f, -0.04015719f, 0.11974403f, 0.06080319f, -0.00649714f, 
    -0.31541818f, -0.02734476f, -0.20745863f, 0.39698872f, 0.14069970f, 0.21396866f, 0.13841623f, -0.57151204f, 
    0.44108704f, 0.45510325f, 0.11220592f, 0.07854510f, 0.00755499f, -0.21631065f, 0.03689320f, 0.73723984f, 
    -0.27205577f, -0.04136251f, 0.13600332f, 0.52376097f, 0.43990183f, 0.16107017f, -0.10258518f, -0.32588789f, 
    -0.03469734f, -0.13361400f, -0.19871433f, -0.22469690f, 0.05132054f, 0.30660588f, 0.10685300f, 0.80235612f, 
    0.35461786f, -0.13119631f, 0.03526368f, -0.55968475f, 0.13076662f, 0.29950541f, 0.28466359f, 0.03800118f, 
    -0.59623712f, 0.23387963f, -0.06700098f, -0.15978074f, 0.10188394f, 0.20716847f, -0.31371644f, 0.11895802f, 
    0.25201595f, -0.46543273f, 0.02327144f, 0.36645350f, 0.12863146f, -0.05073804f, 0.39758170f, -0.06308456f, 
    0.66815722f, -0.23190354f, -0.11080206f, -0.18050559f, -0.10240889f, 0.38996688f, 0.09548958f, -0.34883225f, 
    0.13282903f, 0.03941810f, 0.14108153f, -0.38633305f, -0.18564707f, -0.39330927f, -0.39786932f, -0.09582531f, 
    -0.18692252f, 0.25759503f, -0.06741229f, 0.15747051f, 0.31658691f, 0.13052508f, 0.35433471f, -0.38152590f, 
    0.29594502f, -0.09665176f, -0.13799599f, -0.20607880f, -0.23510519f, -0.18754260f, -0.11115132f, 0.40955007f, 
    -0.29157627f, 0.39700028f, 0.22780606f, 0.38342944f, 0.21694534f, 0.19594075f, -0.21444969f, -0.38322940f, 
    -0.28870583f, -0.44001639f, 0.28316087f, -0.47483963f, 0.12039784f, -0.03579112f, -0.35178414f, -0.24879231f, 
    0.44332483f, -0.02362889f, -0.19461310f, 0.09197807f, 0.40930256f, 0.50113219f, 0.24587819f, -0.31731242f, 
    0.10899308f, -0.16198871f, -0.09847009f, -0.18328729f, -0.15234923f, 0.11001447f, -0.18586910f, -0.15146941f, 
    -0.21318957f, -0.15990260f, -0.04121381f, -0.00868934f, 0.19419745f, -0.19467977f, -0.24906594f, -0.08852783f, 
    -0.23236218f, -0.25820744f, 0.38971519f, -0.11170580f, -0.05988400f, -0.62364000f, -0.13406396f, -0.41063213f, 
    0.18214041f, 0.05637417f, 0.17103866f, 0.01055289f, 0.18775524f, 0.29500347f, 0.32138702f, -0.04732285f, 
    0.27028334f, -0.38727728f, 0.40589318f, 0.30125022f, -0.16599594f, -0.72809124f, -0.24418919f, 0.18586896f, 
    -0.06055898f, -0.33112144f, 0.00344792f, 0.22205675f, 0.40444261f, 0.22394939f, 0.20441653f, -0.15728131f, 
    0.20437875f, 0.25106031f, -0.27999884f, 0.38609448f, 0.12630302f, 0.01492262f, 0.05909617f, 0.21611905f, 
    -1.39147747f, -0.23695014f, -0.03964044f, -0.15180622f, -0.17355128f, 0.48052609f, 0.10113897f, 0.36905348f, 
    0.35997882f, 0.07417440f, 0.15292729f, 0.25882649f, -0.37473702f, -0.28244564f, -0.06501695f, -0.37555367f, 
    -0.47202682f, 0.08918480f, 0.13718326f, 0.20874611f, 0.01328215f, 0.10028256f, 0.07931077f, -0.60437852f, 
    0.08146229f, -0.08486345f, 0.27503192f, -0.12320257f, -0.08728816f, -0.14123125f, -0.10217793f, -0.40130189f, 
    0.17104717f, -0.01174376f, -0.23768379f, 0.11104269f, 0.24426913f, 0.25304514f, 0.12127669f, -0.10978617f, 
    -0.09287506f, -0.36066729f, 0.20230673f, 0.09833159f, -0.23883137f, -0.83460677f, -0.01186164f, 0.30129546f, 
    0.09538309f, 0.50611401f, -0.15543550f, -0.33689120f, -0.12025847f, -0.35565701f, 0.32172549f, -0.36121666f, 
    0.11593369f, 0.19014063f, 0.21009129f, -0.09107316f, 0.35840407f, 0.19233018f, -0.39021903f, -0.14260158f, 
    -0.11886220f, -0.03881333f, -0.16591331f, -0.19972275f, -0.40768299f, 0.14855014f, -0.13516703f, 0.44765350f, 
    -0.00692170f, -0.25864053f, -0.15843678f, 0.47748965f, 0.14390256f, 0.08903185f, 0.34730497f, 0.82076710f, 
    0.46252641f, 0.33992156f, 0.14216650f, -0.00138498f, -0.36479548f, 0.18284418f, -0.04614371f, 0.02560682f, 
    -0.24471529f, 0.13058129f, -0.12700075f, 0.16447531f, 0.14420471f, 0.44042140f, -0.45276710f, 0.21233109f, 
    0.06443719f, 0.38509157f, -0.20046914f, -0.36314198f, 0.25559399f, -0.26809600f, 0.10992578f, 0.31560287f, 
    -0.04767315f, -0.48415560f, -0.30725375f, 0.47241095f, -0.01220351f, 0.15209083f, 0.16291490f, 1.04511237f, 
    -0.05371419f, -0.03362297f, -0.13135149f, 0.33684430f, 0.24644555f, 0.42426801f, 0.15267085f, -0.20492260f, 
    -0.26244190f, -0.08271584f, -0.06579179f, 0.26245594f, 0.73497897f, 0.15509176f, 0.21967570f, 0.47219980f, 
    0.40685737f, 0.23827821f, -0.18570741f, 0.20184922f, 0.04034766f, 0.25790662f, -0.32692072f, 0.94917089f, 
    0.01422121f, -0.01302009f, -0.23679246f, -0.18739104f, 0.25269303f, -0.17931813f, 0.12497009f, -0.37894371f, 
    -0.05068388f, 0.26305392f, 0.06971520f, -0.09882014f, 0.28072527f, -0.17542708f, -0.18995635f, -0.46513173f, 
    -0.18964949f, -0.13288656f, 0.16815585f, 0.14853860f, 0.12116738f, -0.11058122f, -0.22940409f, 0.15135306f, 
    -0.04609245f, -0.10766590f, 0.09383756f, -0.02000562f, -0.12533808f, -0.23018055f, -0.05487434f, -0.24922189f, 
    0.21844468f, 0.09778804f, 0.07142284f, 0.01996112f, -0.25971928f, -0.23746194f, 0.42669076f, 0.56437135f, 
    -0.50364500f, 0.20343776f, 0.01340655f, -0.22426172f, -0.23592234f, -0.05081127f, 0.19090199f, 0.09047534f, 
    -0.06645759f, 0.05587171f, 0.32731155f, -0.18656355f, -0.19686837f, -0.11074375f, -0.01517510f, -0.10653294f, 
    -0.30964011f, 0.26269057f, 0.02209605f, -0.42958894f, -0.01003597f, 0.19473980f, 0.14881866f, -0.40704393f, 
    0.12475526f, 0.26088655f, -0.15435484f, -0.19159877f, -0.09741667f, 0.20914489f, 0.06095348f, -0.43549627f, 
    -0.18892664f, -0.63297480f, -0.05693385f, -0.16599442f, -0.02884757f, -0.23878445f, -0.18384778f, -0.37550926f, 
    -0.13962926f, -0.41744658f, -0.26770943f, 0.57282919f, 0.24911904f, 0.51757073f, -0.20523597f, -0.48063582f, 
    0.34903216f, 0.31731901f, 0.17252609f, 0.60967386f, 0.04930343f, 0.22790743f, -0.10413735f, -0.05084519f, 
    0.19240148f, -0.17282458f, 0.11464266f, 0.40659505f, -0.01117476f, -0.02736762f, -0.02532827f, 0.61467445f, 
    0.21128710f, -0.15851395f, -0.09222658f, 0.05407837f, 0.14912413f, -0.05265704f, -0.44676867f, 0.35334733f, 
    -0.17937320f, 0.16833623f, 0.04895112f, 0.30809933f, 0.30709732f, -0.03728427f, 0.07356662f, -0.58373660f, 
    0.43888825f, -0.26050651f, 0.03054820f, 0.18795563f, -0.32073718f, -0.36104181f, -0.25088543f, -0.12495214f, 
    0.10345080f, 0.03893914f, 0.35704798f, -0.21455543f, -0.31908762f, -0.17674965f, 0.05296703f, 0.28776804f, 
    -0.60485953f, -0.23651741f, -0.10295116f, -0.07536396f, -0.00894779f, 0.06618100f, 0.34739295f, -0.14409028f, 
    0.19092897f, -0.08292653f, -0.03220927f, -0.01922470f, 0.33833060f, 0.29695255f, 0.21210422f, 0.04725424f, 
    0.32862064f, 0.14918435f, -0.21672051f, -0.13107975f, 0.02742417f, 0.10151599f, -0.47904673f, 0.22525737f, 
    0.06777022f, -0.44685450f, 0.21049584f, -0.06205650f, -0.43831700f, -0.56399494f, -0.06527384f, 0.35342124f, 
    -0.38202980f, 0.28444728f, 0.02271836f, -0.64495343f, 0.18509273f, 0.12563366f, 0.51023483f, -0.48766780f, 
    -0.37058958f, 0.31722197f, -0.15524833f, 0.54649192f, 0.06078503f, -0.21608627f, 0.27637297f, 0.20050862f, 
    0.14204420f, 0.42430177f, 0.00901511f, -0.19526580f, -0.27525491f, -0.22714886f, 0.20247309f, 0.25290397f, 
    -0.32155383f, 0.03431704f, -0.30869842f, 0.42911172f, 0.01958640f, 0.31897902f, -0.05321088f, 0.07956214f, 
    -0.10762506f, 0.17244792f, 0.02192763f, 0.34121883f, 0.22385471f, -0.19191599f, 0.19611651f, -0.20629822f, 
    0.10755542f, 0.20390686f, -0.26158345f, 0.54744327f, -0.09873646f, 0.29824069f, -0.13528815f, 0.83333969f, 
    -0.79580694f, 0.28488913f, -0.13066664f, -0.31076631f, 0.18678832f, 0.31800011f, -0.03705949f, -0.15808529f, 
    0.16502920f, -0.04001843f, 0.27970552f, 0.16753151f, 0.04789369f, -0.27464002f, -0.11098897f, 0.21074446f, 
    0.01900690f, -0.43907627f, -0.26902527f, 0.24414511f, -0.31471515f, -0.32650825f, 0.13437411f, 0.00360779f, 
    0.01894670f, 0.10050851f, 0.18484080f, 0.38454130f, -0.24758223f, -0.12465543f, -0.48004195f, -0.28399375f, 
    -0.25624603f, -0.11714435f, -0.21470074f, 0.16723019f, 0.56503189f, -0.24646299f, 0.27290064f, 0.12839001f, 
    0.16385148f, 0.10835657f, -0.21095718f, 0.13840127f, 0.13332164f, -0.22605288f, -0.02380255f, 0.47684059f, 
    -0.36111265f, -0.28946537f, 0.07676224f, 0.10001856f, 0.09969327f, -0.09396860f, 0.23010862f, 0.11451588f, 
    -0.23015791f, 0.01833162f, -0.23254287f, -0.09377977f, 0.06958404f, -0.19201124f, -0.09199238f, -0.20725062f, 
    -0.12882414f, -0.18353650f, 0.24632472f, 0.17873430f, 0.08747262f, 0.05186081f, 0.02510944f, -0.11151910f, 
    0.47963539f, -0.57183570f, -0.02638163f, -0.03325646f, -0.19205986f, 0.46497208f, -0.37385938f, -0.24304327f, 
    -0.01325112f, 0.17529812f, 0.18177977f, 0.28902262f, 0.38396132f, 0.45089540f, -0.27755770f, -0.36993518f, 
    0.04355626f, -0.25812483f, 0.06869355f, -0.48817864f, 0.21297282f, -0.17858288f, 0.43067211f, -0.25469553f, 
    -0.18545280f, 0.26916030f, -0.14552844f, 0.23624520f, 0.09471679f, 0.25011927f, -0.24387458f, -0.07128394f, 
    -0.17069997f, -0.64857346f, 0.38106364f, -0.19848303f, 0.02911928f, -0.22511348f, 0.07575754f, 0.00904052f, 
    0.26231915f, -0.12160581f, -0.16710372f, 0.09789609f, 0.33770463f, 0.59072632f, -0.06727693f, -0.21241738f, 
    0.03240752f, 0.17736498f, 0.11784365f, 0.37170118f, -0.15922689f, -0.20823775f, 0.21629684f, 0.33417678f, 
    0.34949189f, -0.17903401f, 0.21783024f, -0.34273905f, 0.25464049f, -0.14439082f, -0.12273054f, 0.08217282f, 
    0.23611921f, -0.04265863f, 0.17654605f, -0.24639285f, 0.31510314f, 0.37361974f, -0.18967582f, -0.26243818f, 
    0.24373938f, -0.04000961f, 0.11838768f, 0.14017145f, 0.16484451f, 0.42178819f, -0.26062986f, -0.34152287f, 
    -0.04388750f, -0.07924885f, 0.29379797f, -0.50754845f, -0.16028668f, 0.19088455f, -0.52373606f, 0.36634398f, 
    -1.13809752f, 0.34402165f, 0.12549189f, -0.26194713f, 0.44912088f, 0.10662090f, 0.12179720f, -0.11035228f, 
    0.19379905f, 0.18873143f, 0.20748328f, 0.20855185f, 0.22129546f, 0.27697617f, 0.22821079f, -0.27269787f, 
    -0.02273373f, 0.21154100f, 0.20115648f, -0.28448147f, -0.34748778f, 0.11557597f, -0.28849161f, 0.60258687f, 
    0.35885355f, -0.35891157f, 0.25660419f, 0.39768997f, 0.21901326f, 0.14071254f, 0.32337373f, 0.02338621f, 
    -0.02952547f, -0.14757900f, 0.00059098f, 0.17941542f, -0.35383561f, 0.26171070f, -0.24767812f, 0.05458116f, 
    -0.59089953f, -0.08410406f, 0.25478217f, 0.39747423f, 0.40017655f, 0.00512681f, -0.02294715f, -0.58180869f, 
    -0.08066060f, -0.05894781f, 0.07532214f, -0.23777846f, -0.30265391f, 0.22397812f, 0.40083343f, 0.58048791f, 
    0.18590547f, -0.20553337f, -0.14922060f, -0.34358752f, -0.16463464f, 0.42566040f, -0.30027962f, 0.11076143f, 
    -0.19802366f, -0.07772101f, -0.18879820f, 0.47404063f, 0.55917335f, -0.12077387f, 0.34342477f, -0.25739503f, 
    0.03066884f, -0.24887957f, 0.49300522f, -0.38388786f, -0.07065832f, -0.09690949f, 0.28343168f, -0.74777383f, 
    -0.06786386f, 0.31249577f, 0.12060431f, -0.31807932f, -0.25992188f, -0.37816593f, 0.18464369f, 0.00465273f, 
    -0.21310572f, 0.16564700f, 0.07256011f, 0.18330796f, -0.00272357f, 0.02868024f, -0.47548842f, 0.13385655f, 
    0.14624926f, -0.04970411f, 0.08200003f, 0.06633912f, 0.38583019f, -0.32470694f, 0.23248689f, 0.08319455f, 
    -0.21365282f, -0.05839297f, -0.03813833f, -0.09114039f, 0.14432117f, -0.06277004f, 0.06597915f, 0.02553535f, 
    -0.23571727f, -0.16088799f, 0.19489551f, 0.12040436f, 0.07088834f, -0.17736757f, -0.15617636f, 0.13427228f, 
    -0.20391190f, -0.14660591f, 0.13804960f, -0.07741386f, -0.08983985f, 0.06234807f, -0.02163720f, -0.21795973f, 
    -0.06183317f, -0.14355007f, 0.22248766f, -0.19512403f, -0.18905780f, 0.09661046f, -0.09001616f, 0.11544591f, 
    -0.23000163f, -0.26759213f, 0.09892096f, 0.20452037f, -0.24663819f, 0.06223451f, -0.15082695f, -0.04874465f, 
    0.19126034f, -0.24353023f, 0.18230674f, -0.19170834f, -0.01606814f, -0.18873207f, 0.08809283f, 0.04338014f, 
    0.43761006f, -0.57416838f, 0.07289521f, -0.03683901f, -0.17163089f, 0.50878644f, 0.16510274f, 0.26999772f, 
    0.43978384f, 0.07639301f, -0.20124911f, 0.19248755f, 0.13859069f, 0.30486968f, -0.32409960f, -0.36750248f, 
    0.23759878f, -0.04000795f, 0.24844714f, -0.50869566f, -0.04712137f, -0.28656960f, 0.18053401f, 0.27420345f, 
    -0.65787220f, 0.04721431f, -0.20491478f, -0.22338526f, 0.21395746f, 0.45279193f, 0.13936050f, -0.15457554f, 
    0.02220768f, 0.20716956f, -0.03686550f, 0.37376693f, 0.42903236f, 0.40781376f, -0.19347036f, 0.05739295f, 
    0.13560195f, 0.30755082f, 0.05795632f, 0.20198415f, -0.50361633f, 0.05593787f, -0.28388330f, 0.02457770f, 
    0.25920337f, 0.27230391f, 0.16892421f, -0.11471212f, -0.02429546f, -0.34123841f, -0.58089757f, 0.00527894f, 
    -0.39532802f, 0.15342423f, -0.27259764f, -0.18808062f, 0.52094644f, -0.25991076f, -0.01481305f, -0.14934294f, 
    -0.33619019f, 0.37653321f, -0.30921075f, 0.33918819f, 0.32227206f, -0.06565603f, -0.46690014f, -0.18981451f, 
    0.14874277f, 0.49390107f, 0.05043916f, -0.02135865f, 0.12964271f, -0.08887108f, 0.14170478f, 0.10424427f, 
    0.12601468f, -0.00687975f, 0.29676110f, -0.57762748f, -0.21139221f, 0.23179801f, -0.18506189f, 0.07692315f, 
    -0.21642062f, 0.22287555f, 0.06389514f, 0.12462640f, 0.33365375f, 0.34705821f, -0.10531323f, -0.20637688f, 
    -0.54757595f, -0.46405572f, -0.10631777f, -0.34170943f, 0.66608250f, 0.40024713f, -0.09162644f, 0.30386606f, 
    0.14493087f, 0.07943864f, 0.16719633f, 0.20139226f, 0.44320938f, 0.16621858f, 0.17019671f, 0.59730238f, 
    0.15160681f, -0.00598464f, 0.12741719f, -0.15300532f, -0.29362839f, -0.38419083f, 0.17941470f, 0.38043413f, 
    -0.28404281f, 0.17637280f, 0.00485774f, 0.00220224f, 0.08959075f, -0.01241731f, 0.08240513f, -0.24317931f, 
    0.10993947f, 0.03836497f, -0.12602104f, 0.30354792f, -0.05805987f, -0.05235329f, 0.01611245f, -0.05855330f, 
    0.07378852f, -0.52521318f, -0.17900547f, 0.27659607f, 0.37359563f, 0.57285064f, -0.10602236f, 0.17104483f, 
    -0.40856096f, 0.09405986f, 0.14434004f, 0.31258637f, 0.15500009f, -0.28575805f, -0.11246608f, -0.11331683f, 
    0.11639853f, 0.11361101f, 0.15744644f, -0.27154243f, -0.36879513f, 0.42010269f, 0.36642128f, 0.32943994f, 
    0.11733968f, -0.66517496f, -0.09282877f, 0.10233232f, -0.21172102f, 0.26862907f, 0.05360905f, -0.06789037f, 
    0.59621125f, 0.18452309f, 0.04671982f, 0.42903641f, 0.20638731f, 0.12814203f, 0.10661042f, -0.80477947f, 
    0.30358881f, -0.43697745f, 0.12536186f, 0.42268848f, 0.34791812f, 0.18684894f, -0.00522637f, -0.64747822f, 
    0.59743804f, -0.12553583f, -0.14029261f, 0.12538381f, 0.11523692f, -0.13370584f, 0.06431872f, 0.34603834f, 
    0.29033032f, -0.10608095f, 0.16891810f, -0.44354442f, -0.04292163f, 0.02571491f, -0.25617918f, 0.71976775f, 
    0.56615168f, -0.04441553f, 0.06179223f, -0.33045837f, 0.08392111f, -0.43822473f, 0.04755031f, -0.54197156f, 
    -0.70973420f, -0.17571978f, 0.07271472f, 0.22437036f, -0.01971785f, -0.06415907f, 0.10035437f, 0.32350358f, 
    -0.09658971f, 0.00281873f, -0.04724616f, -0.02358895f, 0.25909477f, -0.05192242f, 0.42447904f, 0.20932674f, 
    -0.15280505f, -0.68076384f, 0.02177080f, -0.26128820f, -0.16970907f, 0.20720498f, 0.12506947f, 0.01176824f, 
    0.59156108f, 0.10902210f, -0.09176708f, 0.26364923f, 0.20128369f, 0.54289341f, 0.06989427f, -0.46123984f, 
    0.34835207f, -0.00738005f, 0.27024552f, 0.08442319f, -0.29844549f, 0.01973406f, -0.25418791f, 0.28003991f, 
    -0.04011165f, -0.33414170f, -0.20495144f, -0.21674135f, 0.33038729f, 0.12816757f, 0.02312266f, 0.24654494f, 
    -0.29749617f, -0.03043190f, 0.47940171f, -0.47946432f, 0.10293548f, 0.25106487f, -0.39367402f, -0.28388375f, 
    -0.32041290f, 0.22995366f, -0.07706632f, -0.43645144f, 0.19652466f, 0.31946620f, -0.00722138f, -0.01482418f, 
    -0.33808309f, 0.18229127f, 0.05625288f, -0.28445435f, -0.35243630f, -0.23131748f, -0.12262651f, 0.60965812f, 
    -0.23595434f, -0.10329191f, -0.00870490f, -0.11785722f, 0.29966864f, 0.17619304f, 0.29808712f, 0.11075518f, 
    -0.47965968f, -0.06329148f, 0.20311007f, 0.08311973f, -0.35840634f, -0.08473997f, 0.40328181f, -0.29130039f, 
    -0.02618287f, 0.31182700f, -0.11259080f, -0.18403058f, -0.08429256f, 0.00726509f, 0.26287255f, 0.11252659f, 
    0.42291117f, -0.06210446f, 0.42736605f, 0.16222781f, -0.49379528f, -0.25652614f, 0.13880770f, -0.77564734f, 
    -0.15801829f, -0.06182311f, 0.14488964f, -0.18869853f, 0.21941875f, -0.19041650f, 0.15128568f, -0.03231401f, 
    0.21308829f, -0.34686187f, 0.23954834f, 0.55849046f, -0.29823947f, 0.08490177f, -0.09610772f, -0.09521578f, 
    0.00782218f, -0.20399693f, -0.32720906f, 0.44700548f, 0.36909226f, 0.16381444f, -0.13146430f, -0.12406909f, 
    -0.18512622f, 0.24157034f, -0.31909871f, 0.12103530f, 0.60060674f, 0.16658224f, 0.10676664f, 0.59565121f, 
    0.25827348f, -0.01133798f, 0.25661767f, -0.17243323f, -0.17162694f, 0.30355909f, 0.13964282f, 0.18351629f, 
    0.33151087f, -0.48346516f, 0.35034525f, -0.20862037f, 0.00218126f, -0.84868485f, 0.08534611f, 0.18436763f, 
    -0.18394923f, 0.45617229f, 0.09820385f, -0.52226400f, -0.46629509f, 0.08802263f, 0.06898399f, -0.26427802f, 
    0.10198871f, -0.02159755f, -0.05431622f, 0.40996155f, 0.36071917f, 0.44878834f, -0.12213980f, -0.03865867f, 
    -0.01139974f, -0.30848750f, 0.08570558f, 0.02473657f, -0.11692567f, 0.22647224f, -0.13569543f, 0.07332283f, 
    -0.13870786f, -0.15187439f, 0.05565974f, -0.35966316f, -0.05977359f, 0.30940950f, 0.22737025f, -0.33956355f, 
    0.02458337f, 0.13575700f, -0.16486311f, 0.01750018f, -0.13365313f, -0.31659052f, 0.29888800f, 0.59532565f, 
    -0.71439254f, -0.23452428f, -0.08035854f, -0.23081425f, 0.03815450f, 0.10580382f, 0.23906219f, 0.58322304f, 
    -0.47611660f, 0.37065154f, -0.07541442f, -0.20964105f, 0.17357697f, -0.21210770f, 0.35161942f, 0.39674711f, 
    -0.14446315f, -0.01528038f, 0.16817060f, -0.33615392f, 0.34183675f, 0.02837888f, 0.37390065f, 0.51501983f, 
    -0.00782219f, 0.34742153f, 0.03715426f, 0.13481359f, -0.33351240f, -0.08628957f, -0.24382834f, 0.00562315f, 
    0.20215492f, -0.09510785f, -0.29918137f, 0.25609097f, 0.05723947f, 0.13658109f, 0.18897903f, 1.04210865f, 
    0.26168662f, 0.06540336f, 0.10203852f, 0.12496421f, 0.00168360f, 0.08508230f, -0.13519563f, -0.50331676f, 
    0.16531529f, 0.05794099f, -0.11755035f, -0.07338570f, -0.02850590f, 0.02618614f, 0.16925821f, -0.50469482f, 
    0.23748568f, -0.37775245f, -0.17274006f, 0.00753932f, -0.41119412f, -0.09111156f, 0.09723676f, -0.45387962f, 
    -0.24874744f, 0.32598844f, 0.07197825f, -0.03696748f, 0.05241593f, 0.11583765f, -0.36469463f, 0.30722284f, 
    -0.49714985f, 0.44036520f, -0.21857122f, -0.59463435f, 0.38836914f, -0.13585059f, 0.16307089f, 0.28274915f, 
    -0.15953743f, -0.11408284f, 0.15819260f, 0.06192392f, -0.03148091f, -0.21867231f, -0.11899865f, 0.01107648f, 
    0.01818040f, -0.17017749f, 0.21853420f, -0.04313141f, -0.10805041f, -0.24127695f, -0.09841630f, -0.13654348f, 
    -0.08974661f, 0.05522040f, 0.11890472f, 0.67122394f, -0.01737760f, -0.19947948f, 0.24374661f, -0.26851526f, 
    0.25310448f, -0.13175380f, 0.12947157f, -0.39357874f, 0.28948292f, 0.04522115f, 0.06583130f, 0.48545149f, 
    -0.16153182f, -0.01415695f, 0.30842531f, -0.36576813f, -0.23465534f, 0.17262274f, -0.15105839f, 0.34227425f, 
    -0.42626324f, 0.05282347f, 0.05788051f, 0.15486331f, 0.20321946f, 0.27885699f, 0.12433284f, -0.37162814f, 
    -0.17906360f, 0.10623819f, -0.25337428f, -0.20056345f, 0.20993504f, -0.39301369f, 0.18221182f, -0.19959614f, 
    -0.03019670f, 0.14449473f, -0.04835191f, -0.15027398f, 0.52629781f, 0.28794131f, -0.14077066f, -0.21083896f, 
    0.26868761f, -0.20275353f, 0.33054370f, 0.16300173f, -0.48393330f, -0.34699461f, -0.09599874f, 0.02757202f, 
    -0.08773759f, 0.32740960f, 0.16524158f, -0.50948656f, -0.20575179f, -0.50433493f, 0.35577500f, 0.20439087f, 
    0.21215948f, -0.56277806f, 0.04665603f, -0.00883478f, 0.25215957f, 0.18139365f, 0.19606763f, -0.11032361f, 
    0.23314080f, 0.07440808f, 0.22470126f, 0.30684906f, 0.15435340f, -0.04848438f, -0.31469131f, -0.13247849f, 
    -0.19861978f, -0.60181248f, 0.10525920f, -0.73804426f, 0.20219938f, 0.21896632f, -0.19730324f, -0.10012267f, 
    -0.21107027f, 0.21706383f, 0.17285311f, 0.36892548f, 0.22085832f, 0.30768481f, 0.03630149f, 0.16469853f, 
    -0.23062608f, 0.05548482f, 0.29530731f, -0.14026877f, 0.11929392f, -0.07643601f, 0.38052776f, 0.06293920f, 
    0.36278167f, 0.12965605f, -0.15174721f, -0.20058767f, 0.05775375f, -0.14128403f, -0.19329730f, -0.33749986f, 
    -0.30886278f, -0.21739247f, -0.33733127f, 0.02121081f, 0.44810015f, 0.17064157f, -0.38602525f, -0.10075067f, 
    -0.33069429f, 0.35620111f, -0.11440115f, -0.39384139f, 0.26060024f, 0.25857323f, 0.30044031f, 0.25776747f, 
    -0.11646991f, 0.07026619f, -0.18524566f, -0.06292237f, 0.07524235f, 0.32709852f, -0.25908452f, -0.00151850f, 
    -0.27539226f, 0.27346131f, -0.17566290f, 0.26870659f, 0.22297093f, -0.37552387f, 0.20093773f, -0.14529237f, 
    -0.21880439f, -0.13895258f, 0.13802549f, -0.02079607f, -0.24536264f, 0.16982841f, -0.01736858f, -0.17818119f, 
    -0.07113692f, -0.13648239f, 0.14654106f, 0.05632414f, -0.06887899f, -0.11800081f, -0.23431779f, 0.13220254f, 
    -0.16379064f, -0.12345988f, -0.08051983f, -0.23199934f, -0.02112466f, 0.23823479f, 0.14196742f, -0.10561740f, 
    -0.17443746f, 0.01716131f, 0.16142321f, -0.16212887f, -0.20234296f, -0.16558421f, -0.10311371f, -0.17760456f, 
    -0.11771069f, -0.47751400f, -0.19502552f, -0.60835421f, 0.36321682f, 0.05836624f, 0.07712799f, 0.91358769f, 
    -0.61702526f, 0.26134822f, 0.03155769f, -0.17377797f, 0.38863733f, -0.09716704f, 0.03870708f, 0.18974152f, 
    0.42200533f, 0.09652313f, 0.37900221f, 0.04288006f, 0.02463502f, 0.11590356f, -0.37750891f, -0.50723714f, 
    -0.12895623f, 0.31809258f, 0.11002343f, 0.19667503f, 0.00738408f, -0.36956322f, -0.21022572f, -0.01826784f, 
    0.23044612f, -0.28634849f, -0.09072979f, 0.20962460f, -0.23082641f, 0.21939240f, -0.26894349f, -0.47692168f, 
    -0.37035820f, 0.02013371f, 0.17279191f, -0.04313495f, 0.35812020f, 0.06127612f, 0.40559557f, -0.27070805f, 
    0.23726949f, -0.21581601f, -0.29799080f, 0.54069281f, 0.10664327f, 0.39356157f, -0.06041037f, 0.05380337f, 
    -0.60267687f, -0.18008074f, 0.17723240f, 0.36265761f, 0.19628656f, 0.18785520f, -0.26936734f, 0.62853068f, 
    0.09774735f, -0.27663699f, 0.26009434f, -0.23345192f, -0.08526445f, 0.51427466f, 0.22063358f, -0.07725170f, 
    0.25794730f, 0.18959992f, 0.01545063f, 0.24490221f, -0.18478748f, 0.13093874f, -0.17768067f, -0.34695202f, 
    -0.39029902f, -0.03225521f, 0.32683203f, 0.28424042f, 0.39874613f, -0.22771099f, 0.06412607f, -0.27583513f, 
    0.00234106f, 0.21950465f, 0.16615295f, -0.31301475f, -0.11011386f, -0.33793849f, 0.21149930f, 0.50969571f, 
    -0.16289400f, 0.04664125f, -0.06109104f, 0.19228518f, -0.07702419f, -0.02768193f, -0.19327831f, -0.10405204f, 
    0.05245166f, -0.21979484f, 0.15101814f, 0.06505688f, 0.11207528f, -0.07960895f, -0.28845274f, -0.19181378f, 
    0.11461277f, -0.50264019f, 0.15252973f, -0.31943578f, -0.31834966f, 0.18125273f, 0.24083182f, 0.05321249f, 
    0.41425189f, -0.02233645f, 0.05534778f, -0.09894567f, -0.24899371f, -0.16387649f, 0.35023081f, -0.01291413f, 
    0.21479289f, -0.22603640f, -0.17232591f, 0.34958193f, 0.17405188f, 0.27932310f, 0.12995023f, 0.47355643f, 
    0.17584473f, 0.26969501f, -0.20105228f, 0.35536763f, -0.14759988f, 0.10709024f, -0.37665474f, 0.06475766f, 
    0.36684939f, 0.26924741f, 0.30167007f, 0.06425931f, -0.22387119f, -0.54913521f, -0.36558643f, -0.17061172f, 
    0.13683675f, -0.03810707f, 0.10440458f, -0.01078985f, 0.34650385f, -0.21254626f, 0.17118835f, -0.10267890f, 
    -0.10552430f, -0.24875592f, 0.20694982f, -0.19373682f, 0.24076895f, 0.37845504f, 0.26115000f, 0.11547870f, 
    0.13642494f, -0.03229227f, 0.06537612f, 0.35946333f, -0.14737591f, 0.23977239f, -0.13856204f, -0.35647154f, 
    -0.34756750f, 0.20667131f, 0.22539061f, -0.38461277f, 0.06579854f, 0.00104681f, 0.27395201f, -0.44759744f, 
    -0.26760772f, 0.42279646f, -0.00347124f, -0.02868169f, 0.02982738f, 0.11131600f, -0.10346602f, -0.02745388f, 
    0.07052669f, 0.08497332f, -0.26807088f, 0.55600095f, 0.13946733f, 0.24869311f, -0.37389454f, -0.06670429f, 
    0.39243817f, 0.22753565f, -0.13107990f, 0.05542640f, -0.15757093f, 0.21267471f, -0.17776188f, -0.39115512f, 
    0.13568574f, -0.10021654f, 0.24469216f, 0.12111741f, 0.06025053f, -0.16670857f, -0.03374311f, -0.68107855f, 
    0.18359682f, -0.09572600f, -0.02307005f, 0.24784657f, 0.38129073f, 0.23281643f, -0.04511582f, -0.07251678f, 
    0.11389881f, 0.00824655f, 0.08857204f, -0.29394495f, -0.18179269f, -0.00776052f, 0.06846154f, -1.00383949f, 
    -0.26944241f, 0.26773161f, 0.19496362f, -0.05700397f, 0.25109446f, 0.24237899f, 0.05423118f, -0.48329130f, 
    0.08925268f, -0.20670155f, 0.27073726f, 0.36066848f, -0.22611214f, -0.08103079f, 0.04718529f, -0.31279856f, 
    0.29466400f, -0.14229229f, -0.05558449f, 0.22452307f, -0.07643951f, 0.49050629f, 0.09725636f, -0.27054775f, 
    -0.11493941f, -0.17129177f, 0.54770631f, -0.34923726f, 0.14539108f, -0.34089085f, 0.17127840f, -0.62627387f, 
    -0.26449332f, 0.13767700f, -0.12300258f, -0.51067913f, -0.27985033f, 0.07278831f, 0.41561902f, 0.50184458f, 
    -0.12672240f, 0.07702042f, -0.24796931f, -0.25024071f, -0.07026777f, -0.01545907f, 0.17022564f, 0.71520036f, 
    0.10046697f, 0.29459134f, 0.24098186f, -0.38103932f, 0.11437411f, 0.47111621f, -0.15536159f, -0.49198759f, 
    -0.22314796f, -0.12579808f, -0.15356268f, -0.04985220f, 0.21473010f, -0.05256277f, 0.09356139f, -0.47777474f, 
    0.12578428f, -0.29027915f, -0.16761725f, 0.08440849f, 0.46260840f, 0.41411796f, 0.27695006f, 0.11395974f, 
    -0.01891062f, 0.02720189f, 0.03001500f, 0.59144598f, -0.04589185f, 0.08457087f, -0.37125942f, 0.08496983f, 
    0.34527829f, -0.21862651f, -0.11715103f, -0.34845215f, 0.69276285f, 0.08973155f, 0.15345332f, -0.19688851f, 
    -0.13857529f, 0.06164318f, -0.00246316f, 0.37249789f, -0.34360284f, 0.17700943f, -0.24814996f, -1.08268833f, 
    0.32674140f, 0.06394186f, -0.11722481f, 0.01243540f, -0.32332399f, -0.16891655f, 0.18833882f, -0.72806960f, 
    0.03590558f, -0.04868018f, -0.12373555f, -0.10292578f, 0.14774695f, 0.29572427f, 0.05934123f, 0.69500417f, 
    0.05518638f, 0.12519801f, 0.13059174f, 0.29292169f, -0.16452634f, -0.05451041f, -0.07110751f, -0.36858529f, 
    0.14672463f, 0.16579680f, -0.29010409f, 0.46308661f, -0.18800935f, -0.19207767f, 0.29334253f, -0.02425745f, 
    0.32184416f, -0.12888634f, 0.14426018f, -0.29931840f, 0.31402367f, 0.26468927f, -0.21609870f, 0.14000228f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19222993f, 0.03410796f, -0.23960344f, -0.23438625f, -0.19526917f, 0.44185424f, -0.25420198f, 0.40806916f, 
    -0.07793185f, -0.04012738f, -0.38202691f, 0.20758480f, -0.14773279f, -0.07498758f, 0.12514214f, 0.03974815f, 
    -0.03721492f, -0.00616387f, -0.01966271f, 0.25717640f, 0.32884794f, 0.09513070f, 0.09729562f, 0.16267429f, 
    0.11964438f, -0.05798488f, -0.19292134f, 0.55392098f, 0.09787516f, -0.14322868f, -0.18175498f, -0.00743789f, 
    0.15154213f, -0.07990102f, -0.11980602f, 0.02063976f, 0.17885138f, 0.19006561f, 0.25129035f, -0.00240620f, 
    0.29141602f, -0.40378746f, -0.04771083f, 0.11908706f, -0.03270380f, 0.32715330f, 0.25576937f, -0.15575770f, 
    0.17609695f, -0.06344318f, 0.34732351f, -0.11421738f, 0.41228655f, 0.36246470f, -0.19580288f, -0.04225234f, 
    0.21834841f, 0.52430040f, 0.39218709f, 0.25866014f, -0.22809890f, -0.21014661f, -0.23688722f, 0.11539616f, 
    -0.07325838f, -0.26955470f, 0.20041366f, 0.19887477f, 0.27323768f, 0.25988144f, 0.39219087f, -0.20779391f, 
    -0.15089388f, -0.05028147f, -0.10641449f, 0.28489947f, 0.18893988f, 0.09036487f, 0.22461149f, 0.33941123f, 
    -0.04559242f, -0.19622599f, 0.45260820f, 0.15020028f, 0.13079709f, -0.15294096f, 0.23339516f, 0.37202629f, 
    0.05088015f, -0.43597814f, 0.01067306f, -0.32809407f, 0.35073748f, -0.20181215f, 0.41711676f, 0.34404129f, 
    -0.10381886f, 0.13990882f, 0.29805732f, 0.18282448f, -0.15522015f, -0.19240600f, -0.21059343f, 0.10799841f, 
    -0.13864371f, 0.37167129f, -0.14940894f, 0.46623766f, 0.12956314f, -0.15318424f, -0.03425919f, -0.14011869f, 
    0.30171517f, -0.04719769f, -0.03732264f, -0.12111382f, -0.10580042f, 0.31044641f, 0.48217520f, 0.07733715f, 
    -0.26199600f, -0.00075840f, 0.21236411f, 0.10531814f, 0.60696429f, 0.19325024f, -0.27299163f, 0.02310334f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04348006f, 0.19070232f, 0.08311158f, -0.01096292f, 0.00038759f, -1.02614129f, 0.08617356f, -0.31103534f, 
    -0.07882871f, 0.12183680f, 0.15663067f, 0.16657764f, 0.22542550f, -0.48731440f, -0.17516966f, -0.29113057f, 
    -0.43404165f, -0.79906964f, 0.06285576f, -0.11807797f, 0.22037712f, 0.11861385f, 0.08943032f, -0.18759900f, 
    -0.01853539f, 0.16982384f, 0.04886203f, 0.21132697f, 0.00105496f, 0.16956988f, -0.15182105f, -0.03527380f, 
    0.12048483f, -0.42106095f, 0.12975883f, 0.11223417f, 0.18380241f, -0.03690467f, 0.01576666f, -0.07045680f, 
    -0.31136471f, 0.26950604f, 0.05841908f, 0.13396962f, -0.01377987f, 0.03701209f, 0.09588176f, 0.07751013f, 
    -0.73473626f, -0.50958395f, -0.49600855f, 0.03720591f, -0.58250493f, -0.55887592f, 0.09578361f, 0.00810562f, 
    0.28704032f, -0.26883677f, -1.16488230f, 0.04532135f, -0.00406841f, -0.04728379f, -0.02757011f, -0.73772061f, 
    -0.28889865f, 0.10023399f, -0.08000401f, 0.25194764f, -0.64578128f, 0.09851757f, -0.20951393f, -0.10705187f, 
    0.15527540f, -0.74443930f, 0.28161868f, -0.27015796f, 0.26862374f, -0.79333127f, 0.03733986f, -0.60056478f, 
    0.16640425f, -0.06623331f, -0.13623688f, -0.15753114f, 0.14578116f, -0.02541065f, -0.12909295f, -0.00514334f, 
    0.18591838f, -0.01203032f, -0.04577493f, 0.04687511f, 0.07582073f, 0.01278411f, 0.21536013f, -0.50488394f, 
    -0.20576589f, 0.26655328f, -0.24952041f, -0.33706954f, -0.05231458f, 0.08807438f, 0.01523280f, -0.07523701f, 
    -0.03276546f, 0.06540627f, -0.14758846f, -0.15921406f, 0.13974592f, -0.34793761f, 0.36700335f, 0.02942597f, 
    -0.07437067f, 0.03773513f, -0.01893249f, -0.25572887f, -0.24095331f, 0.01076114f, -0.32580808f, -0.01329807f, 
    -0.19943246f, 0.06359726f, -0.54995316f, -0.17535372f, 0.03214115f, -0.08554329f, -0.03280020f, 0.02685176f, 
    0.16558288f, 0.00969287f, -0.02291350f, -0.04248663f, 0.05977178f, -0.34964421f, -0.53698313f, 0.07479997f, 
    -0.06062651f, 0.02866549f, -0.05180938f, 0.02058224f, 0.04848046f, -0.24794307f, 0.25518093f, -0.22026208f, 
    -0.11269648f, -0.45360795f, 0.07235928f, -0.33741972f, -0.20829494f, 0.48081735f, -0.11111573f, 0.01169002f, 
    0.31545040f, -0.20244314f, 0.18444897f, -0.01832696f, 0.24260180f, 0.14222071f, -0.26999852f, -0.07148366f, 
    -0.07018828f, -0.07470633f, -0.04909068f, 0.24976070f, 0.18096648f, 0.06867264f, -0.11026534f, 0.09020352f, 
    -0.22235090f, 0.01901611f, 0.15283902f, 0.23598334f, 0.13883351f, -0.04851712f, -0.00016127f, -0.05597802f, 
    0.18137492f, -0.33758125f, -0.14859544f, 0.03402213f, 0.11107124f, -0.56540638f, -0.01346956f, 0.16512416f, 
    -0.04792925f, 0.05855379f, 0.15375958f, 0.00888048f, -0.03695334f, 0.06939977f, -0.00013739f, 0.19625404f, 
    -0.19263156f, 0.08712614f, -0.09838308f, 0.00217725f, -0.11581171f, -0.09660397f, -0.09461341f, 0.09600902f, 
    -0.05257880f, 0.12277085f, 0.10508261f, 0.87658930f, -0.21429917f, 0.05612187f, 0.03527849f, -0.56624806f, 
    -0.07910289f, -0.39595884f, -0.11595959f, 0.25034940f, 0.14440520f, -0.47115603f, 0.16714127f, -0.15240858f, 
    -0.42325431f, -0.14654812f, 0.15188566f, -0.02553294f, -0.07600733f, 0.03239899f, 0.07024001f, -0.15976480f, 
    -0.14007536f, -0.12424091f, 0.09225886f, -0.40292567f, 0.05565778f, -0.09863344f, -0.03248134f, -0.01417343f, 
    0.07541020f, -0.26594627f, -0.17105633f, 0.08623919f, 0.33359545f, 0.04933063f, -0.39109948f, 0.04155064f, 
    -0.04489065f, 0.18840246f, -0.00934918f, 0.07336721f, -0.26558116f, 0.33185303f, -0.08495186f, -0.23426931f, 
    0.07390212f, -0.98585546f, 0.27456987f, 0.09386637f, 0.50174242f, -0.17672171f, 0.03658509f, 0.03508168f, 
    -0.02906952f, 0.02547978f, -0.56322497f, -0.02814946f, 0.11182061f, 0.19134071f, -0.52505755f, -0.14590110f, 
    -0.08035848f, -0.38031152f, 0.24626048f, -0.63436633f, -0.99225670f, -0.18631391f, -0.37522647f, 0.19580635f, 
    0.13856444f, 0.33511105f, 0.00011070f, 0.00454324f, 0.18681532f, -0.07918511f, 0.00953944f, -0.01055184f, 
    -0.12644096f, -0.13094373f, -0.20327704f, 0.31232721f, 0.14548551f, -0.25041905f, -0.29755035f, 0.09654327f, 
    -0.04800112f, 0.03254594f, 0.04988774f, -0.40967956f, -0.28043637f, 0.21966374f, 0.09784824f, -0.16494957f, 
    0.46239328f, -0.09711593f, -0.10189190f, 0.27445972f, 0.19669010f, 0.05464098f, 0.08489712f, 0.02757633f, 
    0.11068147f, -0.22307274f, 0.20109019f, -0.02117404f, 0.00954774f, 0.58220255f, -0.29255301f, -0.43124115f, 
    -0.62293285f, 0.12376285f, -0.94843394f, 0.08047111f, 0.06300814f, 0.04356102f, -0.09350903f, -0.00897248f, 
    0.12486819f, -0.13753080f, 0.09024625f, -0.03855732f, 0.08270197f, 0.30824855f, 0.06704371f, 0.04255738f, 
    -0.21366215f, 0.00268186f, -0.53600699f, 0.00764795f, 0.48613247f, 0.11899734f, 0.01335449f, 0.36112848f, 
    0.24581175f, -0.12267556f, -0.21275085f, -0.19331557f, 0.05180486f, -0.32740584f, -0.11054521f, -0.32951292f, 
    0.33410120f, -0.25041747f, -0.00003656f, 0.21188311f, 0.19427148f, -0.04779407f, -0.14469436f, 0.13399062f, 
    -0.12635881f, -0.29310933f, -0.47499561f, 0.20422266f, -0.05838320f, 0.27839449f, -0.07454052f, 0.06035849f, 
    -0.01861198f, 0.44220391f, -0.30583021f, 0.16002536f, -0.72688442f, -0.22528483f, -0.49623358f, -0.00471273f, 
    -0.50738460f, -0.17826441f, -0.07556106f, -0.16538280f, -0.11376847f, -0.07985029f, -0.15155654f, -0.00887303f, 
    -0.04012746f, -0.27923587f, 0.35944155f, 0.00478550f, 0.35016534f, -0.04865639f, -0.10018402f, 0.08878502f, 
    -0.24300891f, 0.14272383f, 0.03616133f, -0.08102467f, -0.21869707f, -0.11840774f, -0.81196398f, -0.46876046f, 
    0.06685120f, 0.26747981f, 0.34832054f, 0.05737900f, -0.21841308f, -0.18737587f, -0.23502867f, 0.02102040f, 
    0.07219255f, -0.11930215f, -0.08550210f, 0.01189758f, -0.35506848f, -0.20729810f, -0.54243445f, -0.10555822f, 
    0.55013323f, -0.73432124f, 0.06230048f, 0.10773540f, 0.11637028f, 0.04161671f, 0.10233150f, -0.01224368f, 
    0.29437196f, 0.16784005f, -0.15965083f, -0.00327837f, -0.37420139f, -0.46481141f, 0.01139686f, -0.17322831f, 
    0.44111583f, 0.29829204f, 0.23019989f, 0.08330731f, -0.61550665f, -0.16364469f, -0.19656205f, -0.01389811f, 
    -0.37830138f, -0.02146119f, -0.18749441f, -0.27640995f, -0.56124973f, 0.07972332f, -0.15973315f, -0.32690856f, 
    0.06197201f, 0.03508969f, -0.09601730f, -0.02033228f, -0.03408002f, -0.02056971f, -0.05281676f, -0.33914262f, 
    -0.03620459f, -0.07645527f, -1.33537853f, 0.16541889f, -0.12683955f, 0.07814184f, 0.13196979f, 0.60938275f, 
    0.06667743f, 0.17108890f, -0.40026665f, -0.32707560f, 0.30203295f, 0.07969546f, -0.22596909f, -0.10285470f, 
    0.35012928f, 0.37381631f, -0.76938623f, -0.40452531f, 0.10924513f, 0.14728576f, -0.73685223f, 0.13603483f, 
    0.35360011f, 0.13611007f, 0.01197042f, -0.62250906f, 0.14064650f, -0.02156387f, 0.01086275f, -0.04162543f, 
    0.24726693f, 0.28299135f, -0.46275619f, -0.09538072f, -0.53522086f, 0.08518393f, 0.11820707f, 0.03250055f, 
    -0.01651130f, 0.10426401f, -0.79591876f, -0.02978521f, -0.28485024f, -0.08294287f, 0.09819998f, 0.02854445f, 
    0.65255255f, -0.01806067f, -1.50361681f, -0.08754787f, 0.25339940f, -0.00986007f, -0.48114085f, -0.40035611f, 
    -0.13885412f, -0.04192848f, 0.29087418f, -0.02768962f, -0.07488653f, -0.45587179f, 0.04878042f, 0.47834507f, 
    0.14983349f, 0.07087108f, 0.16403477f, 0.04859319f, 0.16565421f, -0.08130799f, 0.23681933f, -0.36648121f, 
    0.05486397f, -0.11578738f, -0.03875780f, 0.03875765f, 0.03449766f, 0.10158808f, -0.17928623f, -0.03782815f, 
    -0.15413496f, -0.01350707f, 0.04394566f, 0.06825634f, -0.41108572f, 0.12598327f, 0.05692556f, 0.02361583f, 
    -0.38692656f, 0.46642604f, -0.04682322f, -0.04024000f, -0.21171261f, 0.11301923f, 0.24322085f, -0.04390658f, 
    0.00051614f, 0.09198795f, -0.05315991f, 0.01262206f, -0.33431390f, -0.13217582f, -0.12647440f, 0.05406665f, 
    -0.13291737f, 0.05103588f, -0.17742804f, -0.03263199f, -0.01813418f, -0.17560817f, -0.12001778f, 0.00679459f, 
    -0.15430708f, 0.16268511f, 0.00212841f, 0.04360696f, 0.15121472f, -0.03891870f, 0.18735909f, -0.01731523f, 
    0.25825638f, -0.61065084f, -0.61772299f, -0.20703742f, 0.01144827f, 0.04724507f, 0.06149721f, -0.62858945f, 
    0.14863288f, 0.05710634f, -0.07316679f, 0.08983232f, -0.01700129f, 0.01815400f, -0.09469942f, -0.22326630f, 
    0.28297395f, -0.58132571f, -0.11742529f, -0.62562442f, -0.08562838f, -0.18240973f, -0.17799848f, 0.33200371f, 
    -0.21640298f, 0.01502401f, -0.01090153f, -0.60976446f, 0.12551521f, 0.15565836f, -0.07578653f, -0.05253089f, 
    0.00948991f, 0.07647999f, -0.17106931f, -0.10867015f, 0.00377613f, 0.08543224f, -0.00307866f, -0.11474378f, 
    0.34683314f, -0.30072591f, -0.44578096f, 0.12063411f, 0.07031590f, 0.15958598f, -0.10543436f, 0.01059864f, 
    -0.01658262f, -0.04321364f, 0.15594849f, -0.23042850f, -0.24958248f, -0.00731275f, 0.07570072f, -0.02004745f, 
    -1.19541597f, -0.10755877f, 0.04948382f, -0.00675268f, 0.25098804f, -0.02036405f, 0.00113700f, -0.10874629f, 
    0.04467293f, 0.28556621f, 0.09105360f, 0.09308935f, -0.26510781f, -0.10393231f, -0.03033629f, 0.05345606f, 
    -0.06434845f, 0.05019058f, 0.03147818f, -0.04189513f, 0.12996592f, 0.19455492f, 0.34154686f, 0.46485108f, 
    -0.04434112f, -0.28374109f, -0.47026685f, 0.25959322f, -0.22324349f, 0.14939511f, -0.36847213f, -0.04754167f, 
    0.11737106f, -0.05697930f, -0.06058732f, -0.23801412f, -0.85023689f, -0.14203027f, -0.04947433f, -0.05064004f, 
    -1.21495402f, 0.30718535f, 0.06418078f, 0.11650163f, -0.04673024f, 0.14364663f, 0.04185979f, -0.10111623f, 
    -0.27994511f, -0.20834830f, 0.03165262f, 0.30028236f, 0.02775097f, -0.01536469f, -0.24816950f, 0.15020545f, 
    -0.92692542f, 0.03937645f, 0.15210171f, -0.03708864f, 0.12189629f, -0.02927469f, -0.15343307f, 0.00144757f, 
    0.18258560f, 0.18486930f, -0.19685580f, 0.01381193f, 0.12421573f, 0.04781454f, 0.02816930f, -0.07481864f, 
    -0.16696078f, 0.17377900f, 0.15740934f, 0.10376510f, -0.03016469f, -0.01355605f, -0.06556033f, 0.10157222f, 
    -0.15917289f, 0.19953549f, -0.23280510f, 0.13338658f, 0.04538374f, 0.11454802f, -0.24571303f, -0.77065861f, 
    -0.30240792f, 0.17377792f, 0.15757245f, -0.34764978f, -0.22845994f, 0.01509092f, -0.23086673f, 0.02719446f, 
    -0.21132232f, -0.18805888f, -0.23803233f, -0.10086428f, -0.00129635f, -0.59808409f, -0.02512093f, 0.14468613f, 
    0.01389854f, 0.01623671f, -0.08062989f, -0.00345028f, 0.00392074f, 0.07976313f, -0.26959696f, -0.10789020f, 
    -0.25035697f, -0.71132809f, 0.25858837f, 0.29053164f, -0.03851164f, 0.14725751f, 0.26912233f, -0.05499965f, 
    -0.06095427f, 0.19860747f, 0.30245769f, 0.01345306f, 0.14618582f, 0.07462029f, -0.11790831f, -0.02187640f, 
    -0.18238112f, 0.10891281f, -0.09803505f, 0.02919586f, 0.09567767f, 0.20965151f, -0.22920175f, 0.29059535f, 
    -0.20055427f, -0.41024670f, -0.12830216f, -0.34306851f, -0.30760759f, 0.17199118f, 0.06594943f, -0.19483802f, 
    -0.39903355f, -0.69054723f, -0.90655971f, -0.06876394f, -0.27651757f, -0.10480804f, -0.13990328f, 0.29338190f, 
    0.03128169f, -0.75490719f, -0.15267187f, -0.69066912f, -1.84054887f, 0.08028983f, -0.59619206f, 0.37353054f, 
    0.10507279f, 0.07302840f, 0.06803736f, 0.14759392f, 0.41584522f, -0.36789626f, 0.23668528f, 0.14224410f, 
    0.27139133f, -0.30785105f, -0.85413045f, -0.21333654f, -0.73567349f, -1.13615167f, 0.02330634f, -0.09324216f, 
    0.01904405f, 0.09914509f, -0.07408765f, -0.98690969f, -0.14120162f, 0.23908590f, 0.17334013f, -0.57964230f, 
    0.36195260f, -0.24317615f, -0.08144370f, 0.39061835f, 0.07909138f, 0.34424323f, 0.06610645f, -0.00347773f, 
    0.14781012f, -0.34241322f, -0.24693806f, -0.17408709f, 0.09103944f, 0.57070166f, -0.15052949f, -0.42992318f, 
    -1.10550189f, 0.32826641f, -0.02321669f, 0.25505179f, -0.05331281f, -0.03901865f, -0.09051839f, -0.36055732f, 
    0.21014731f, -0.15961364f, 0.43282610f, -0.08202755f, 0.17578338f, -1.05275130f, 0.18282190f, -0.23801102f, 
    -0.51799846f, -0.09482500f, -0.15260167f, 0.00910041f, -0.79566652f, -0.25447252f, 0.16854572f, 0.19171672f, 
    0.05334423f, -0.34646612f, 0.18664159f, 0.26688862f, -0.35748464f, 0.29501930f, -0.29611090f, -0.20890394f, 
    -0.93446088f, -0.36286855f, -0.23682186f, 0.01170815f, 0.21338691f, 0.02975778f, -0.23721689f, 0.16944891f, 
    -0.38467833f, 0.16752504f, -0.63463628f, -0.68731380f, -0.40962577f, -0.44705689f, 0.16548255f, 0.04189733f, 
    0.08279097f, -1.05844295f, 0.23167995f, 0.33322552f, -0.47475114f, -0.10338853f, -0.17586763f, 0.01327225f, 
    -0.60058141f, -0.51702791f, 0.15866849f, -0.17228220f, -0.10870951f, -0.06808572f, 0.16579285f, 0.13321438f, 
    -0.03549187f, 0.02746723f, -0.14694078f, -0.31862935f, 0.22188164f, -0.10124692f, -0.05171710f, -0.37922350f, 
    -0.01829639f, -0.90275019f, 0.51098037f, -0.02254707f, 0.05625392f, -0.21260484f, -0.40059426f, -0.21183410f, 
    -0.05689658f, 0.17873427f, -0.00001577f, 0.07433153f, -1.76415646f, 0.05516139f, 0.30609953f, -0.04371089f, 
    -0.06682096f, 0.14798951f, 0.01076242f, 0.17712419f, 0.06653598f, -0.44548041f, -0.01683559f, 0.08644433f, 
    0.35835260f, -0.24816322f, 0.39612195f, -1.19494843f, -0.20900258f, 0.27943686f, 0.05307785f, 0.03620909f, 
    0.09118520f, 0.01221302f, 0.04851167f, -0.41355720f, -0.29377303f, -0.11803951f, -0.06846655f, 0.08927915f, 
    0.48952919f, 0.17620257f, -0.30571964f, -0.80350065f, -0.10988237f, -0.21491285f, -0.12380701f, 0.04293568f, 
    -0.24353014f, 0.14474945f, 0.17029302f, -0.03187782f, -0.00813791f, -0.67181158f, 0.06907141f, 0.19597246f, 
    0.12673314f, -0.63840789f, 0.14539470f, -0.24227582f, -0.01373240f, 0.01401548f, -0.01156526f, 0.15557909f, 
    0.09314653f, -0.03568083f, -0.44040436f, -0.76617360f, 0.03248505f, -0.73199135f, 0.02594942f, 0.10677835f, 
    0.50120300f, 0.13857704f, 0.03295898f, -0.42738646f, -0.04224008f, 0.24107046f, -0.04385379f, 0.00578514f, 
    -0.00233253f, 0.24991807f, -0.00665419f, -0.15255401f, 0.01959378f, 0.56866908f, -0.07012849f, -0.08068594f, 
    -0.04833780f, 0.11810503f, -0.04125248f, -0.09643259f, -0.44318512f, -0.08086562f, 0.01688653f, -0.11400532f, 
    -0.08275840f, -0.02316045f, -0.02218387f, -0.50683022f, 0.06877002f, -1.12687206f, -0.41572517f, -0.03875995f, 
    -0.00217572f, -0.69479078f, -0.01662481f, -0.51741099f, -0.24874328f, 0.10883077f, 0.30319393f, 0.01579969f, 
    0.21149726f, 0.08217040f, -0.07887542f, 0.14724956f, 0.15607449f, -0.16930868f, -0.08578788f, 0.01119434f, 
    0.15901005f, 0.42357266f, 0.21653637f, -0.32270473f, -0.66927391f, -0.44557619f, -0.02494400f, -0.07308540f, 
    -0.09502134f, -0.46513489f, -0.06247051f, 0.04413299f, -0.12959567f, 0.16657023f, -0.14910808f, 0.06996850f, 
    -0.04643282f, -0.04249688f, -0.04040835f, -0.03761616f, -0.16084608f, -0.25817457f, 0.36981219f, 0.00431856f, 
    0.12598442f, 0.47263232f, 0.02551835f, 0.25488806f, 0.35373667f, -1.03838742f, -0.08144822f, 0.15824012f, 
    -0.23906583f, -0.16631243f, -0.22282065f, -0.64231116f, 0.17160299f, 0.01681355f, -0.02081650f, 0.02537562f, 
    -0.52419180f, -0.20185514f, 0.16758011f, 0.22492874f, -0.05950058f, -0.21150312f, -0.15192629f, 0.06487899f, 
    -0.55518436f, -0.36492184f, 0.16640067f, -1.04178321f, -0.83383292f, -0.03965957f, -0.02323448f, 0.04995091f, 
    0.22922507f, 0.13151963f, 0.44933510f, -0.20982832f, 0.12863587f, -0.81652379f, -0.14964442f, 0.18079828f, 
    -0.12624317f, 0.19604288f, -0.19741032f, 0.02982156f, 0.06194993f, 0.07878247f, 0.02054911f, 0.19552979f, 
    -0.28788182f, -0.12373609f, -0.49589026f, -0.35589513f, 0.03887853f, 0.26332968f, -0.17955959f, -0.03482632f, 
    -0.40259406f, 0.39138630f, 0.30430299f, 0.01425896f, 0.13180369f, 0.42116734f, -0.00520142f, -0.19247420f, 
    -0.22524928f, -0.16846868f, 0.02078658f, 0.23826718f, -0.01219994f, -0.42844245f, 0.16200708f, 0.13244626f, 
    -0.67309999f, -0.19940740f, 0.00685391f, 0.02547964f, -0.87449020f, -0.08795995f, -0.09420607f, -0.00606448f, 
    -0.09921686f, -0.46719059f, 0.35105270f, 0.34578559f, -0.06667366f, -0.47090352f, 0.04778115f, 0.06295166f, 
    -0.00717821f, -0.09709482f, -0.23778714f, -0.18404488f, 0.03797581f, 0.17870806f, -0.21302886f, 0.06435154f, 
    0.34398571f, 0.11449499f, -0.24103822f, 0.24763110f, -0.04456524f, 0.08844945f, 0.23639862f, 0.09526657f, 
    0.20819068f, -0.71556765f, -0.31767061f, 0.31607181f, 0.11124898f, 0.06681515f, 0.05797330f, -0.09725512f, 
    -0.15445742f, -0.20632856f, -0.34994042f, -0.06873567f, -0.08648895f, 0.13794449f, -0.12336245f, -0.03537416f, 
    0.05168942f, -0.06584144f, -0.03187575f, 0.15618950f, -0.06538586f, -0.10741109f, -0.25767350f, 0.03439590f, 
    -0.56969631f, 0.03164509f, -0.00348584f, 0.06430451f, -0.10553575f, -0.27350125f, -0.07609800f, 0.14603658f, 
    -0.16726424f, -0.05796827f, -0.68092680f, 0.14304411f, -0.42891437f, -0.08077332f, -0.22012569f, -0.00360406f, 
    0.04701674f, 0.09931031f, -0.17692986f, -0.14770612f, -0.16217388f, -0.89047021f, 0.11068704f, 0.03570833f, 
    -0.15203327f, -0.02834436f, -0.22023475f, -0.47151026f, -0.57569659f, 0.23147286f, -0.00546694f, -0.04635437f, 
    -0.05589540f, -0.05509893f, 0.10598256f, 0.21880803f, 0.00027885f, 0.13817157f, 0.07237944f, -0.13231611f, 
    0.30204025f, 0.02274780f, 0.43033519f, 0.19166817f, -0.07462705f, -0.04440006f, -0.01543654f, -0.24966568f, 
    -0.09629937f, -0.56767291f, 0.11570995f, -0.12359431f, 0.12898715f, 0.24991217f, 0.07075887f, 0.22491191f, 
    -0.07491184f, -0.52486116f, 0.08899219f, -0.54954249f, 0.33387050f, -0.13589530f, 0.14196211f, 0.37070292f, 
    0.13852881f, 0.27595758f, 0.24482895f, -0.20948215f, -0.17395674f, -0.48688123f, -0.22923748f, 0.31165534f, 
    0.08533080f, -0.47670162f, -0.65360814f, -0.31528425f, 0.24027339f, -0.02991573f, 0.50048381f, -0.00813368f, 
    -0.05398771f, 0.11811440f, 0.17045754f, 0.22296512f, -0.03588240f, -0.10100366f, -0.13984071f, -0.01030522f, 
    -0.08671609f, -0.20857598f, 0.00964843f, 0.10734755f, 0.05209297f, -0.03477462f, 0.37854329f, 0.04123371f, 
    -0.03463199f, -0.23675944f, -0.02045485f, -0.28009135f, 0.15027471f, -0.51877373f, 0.13205342f, 0.13160777f, 
    -0.11337802f, 0.36082569f, -0.51117897f, 0.55549687f, 0.18964675f, -0.43840766f, -0.37918717f, 0.22411992f, 
    0.34114230f, -0.44180664f, 0.13674498f, 0.08741674f, -0.31067169f, -0.03951755f, 0.28988767f, 0.06417388f, 
    -0.03502787f, 0.41130224f, 0.00687562f, -0.42005056f, -0.56290585f, 0.36022741f, -0.20756012f, -0.32245177f, 
    0.18417582f, -0.48833784f, 0.00090737f, -0.51041001f, -0.06538042f, 0.28687298f, 0.00675186f, -0.16308065f, 
    -0.35372961f, -0.14115502f, 0.15388714f, -0.26674682f, 0.25210235f, 0.21067166f, -0.29081094f, -0.08967809f, 
    0.40880507f, -0.12535827f, -0.35801223f, -0.42558730f, 0.37409484f, -0.51010752f, 0.20284779f, 0.18019004f, 
    -0.18672836f, -0.14326125f, -0.17527993f, 0.20230775f, -0.66323525f, -0.50206494f, 0.19076030f, 0.01157581f, 
    0.00730484f, 0.11064229f, 0.00911571f, -0.97133011f, 0.00171443f, 0.09424230f, 0.12813419f, 0.28945968f, 
    -0.47612259f, 0.02335052f, -0.71426821f, -0.38865191f, -0.02120582f, 0.04909850f, 0.05245725f, 0.17985959f, 
    0.20504992f, 0.09010340f, 0.12940498f, -0.82124960f, 0.15755269f, 0.08700792f, 0.12182575f, -0.54487866f, 
    -0.74422878f, -0.11133654f, -0.52483284f, -0.69275129f, -0.19543785f, -0.00801756f, -0.01766751f, -0.28515485f, 
    0.06870332f, -0.31046790f, -0.55498564f, -0.16278665f, 0.12708795f, 0.18815933f, -0.31436878f, 0.14162092f, 
    0.08155513f, 0.47640893f, 0.33323500f, -0.69511330f, -0.12094718f, -0.07813603f, -0.65062702f, 0.12076087f, 
    -0.54298943f, -0.59569246f, 0.13046126f, 0.11062646f, -0.60923803f, -0.45434663f, -0.00777987f, -0.06453538f, 
    -0.00338805f, 0.39784378f, -0.03038487f, -0.52477664f, 0.10728974f, 0.19983040f, -0.65315640f, -0.00729901f, 
    -0.15233330f, 0.27354747f, -0.29570165f, 0.24651639f, -0.00507555f, -0.36324245f, -0.60157293f, -0.33530107f, 
    -0.39830106f, -0.28933352f, 0.15779372f, -0.54169601f, -0.93759310f, -0.60893476f, 0.35234758f, -0.81673068f, 
    -0.35119906f, -0.18130219f, -0.43805251f, 0.02270825f, -0.26853880f, 0.21407925f, 0.57217115f, 0.10470622f, 
    -0.00146026f, -0.23994520f, -0.03558059f, -0.30604801f, -0.29791480f, 0.32738045f, 0.18977366f, 0.08141903f, 
    0.27863500f, -0.15425509f, 0.00327976f, -0.02569585f, 0.25727165f, -0.12903194f, 0.35097796f, 0.04076505f, 
    0.24103691f, -0.14537664f, -0.20793232f, -0.49581075f, -0.11633860f, -0.51391667f, 0.07578623f, 0.06329285f, 
    0.17041488f, 0.05603926f, -0.72438401f, -0.48950529f, 0.02528991f, -0.52634215f, 0.07420202f, -0.06809489f, 
    0.21260139f, -0.27233857f, -0.27088270f, -0.29123396f, 0.31726244f, 0.00775867f, -0.16819127f, -0.06627622f, 
    0.32140684f, 0.23577112f, 0.13498667f, 0.05728680f, 0.01569665f, -0.10023306f, -0.01082758f, 0.37001067f, 
    -0.09701521f, 0.04107413f, 0.24326606f, -0.29021308f, -0.08294209f, 0.02746885f, 0.02667869f, 0.36673510f, 
    0.06379379f, -0.17669940f, -0.05508483f, -0.48386028f, 0.04349635f, -0.56318760f, 0.13456474f, -0.00490318f, 
    -0.27075112f, 0.23033616f, 0.16623896f, 0.02351999f, -0.49772516f, 0.09885840f, 0.16118258f, -0.21528618f, 
    -0.21755725f, 0.03770077f, 0.33637637f, 0.31316191f, -0.55351758f, 0.14484166f, -0.88573593f, -0.01444713f, 
    -0.47603881f, -0.15188399f, -0.06748030f, -0.14942913f, -0.57226980f, 0.01669068f, -0.12817855f, 0.00352541f, 
    0.53361964f, 0.42984673f, 0.16863859f, -0.00391872f, -0.13159513f, -0.17659725f, -0.29907823f, -0.03513540f, 
    -0.07126023f, -0.14189972f, 0.13852030f, 0.23748912f, -0.58088166f, 0.20143488f, -0.56470132f, -0.03680363f, 
    0.46767753f, 0.06412249f, -0.00666373f, -0.02986214f, 0.00742920f, -0.21576722f, 0.12505656f, 0.24752240f, 
    0.27358145f, 0.05766839f, -0.15482196f, -0.25227231f, -0.16337721f, 0.37222788f, -0.09792767f, -0.08986901f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.29115948f, 0.13993229f, -0.02261296f, -0.12837295f, -0.09609420f, -0.05779077f, 0.10902482f, -0.19307105f, 
    0.03011687f, 0.26113126f, -0.02043912f, -0.02019174f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
