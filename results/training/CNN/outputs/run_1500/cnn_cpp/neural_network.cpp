#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.62658304f, 0.36938015f, 0.15422781f, 0.34809673f, -0.04744656f, 0.36960000f, 0.23713122f, 0.23730747f, 
    0.27702466f, -0.24209976f, -0.28079325f, -0.28872913f, 0.13829878f, 0.11005323f, -0.14518003f, -0.12808904f, 
    0.01387630f, 0.04360229f, 0.11365766f, -0.13118951f, -0.38015085f, -0.16289669f, -0.07397373f, -0.51318216f, 
    -0.57578194f, -0.76470256f, -0.46796641f, -0.16089639f, 0.02221092f, 0.45449528f, -0.66625291f, -0.47424486f, 
    -0.13326696f, 0.63603228f, 0.22273546f, -0.26056695f, -0.63832098f, -0.36896169f, 0.22434366f, 0.31867900f, 
    -0.41006151f, -0.06563881f, 0.02897196f, -0.04653119f, -0.21764003f, 0.10208125f, 0.23835392f, -0.22380428f, 
    -0.49697894f, -0.28774813f, 0.00706667f, 0.36620173f, 0.03790481f, -0.46124160f, 0.41256008f, -0.23979078f, 
    0.17971966f, -0.06719311f, -0.18150377f, 0.10615002f, -0.36125094f, 0.26586100f, -0.07846992f, -0.07672714f, 
    -0.00660473f, 0.29545081f, 0.09794459f, 0.15912390f, -0.12962778f, -0.14540234f, -0.47108006f, 0.18553983f, 
    0.31111595f, 0.05861787f, -0.10030264f, -0.01840919f, -0.64128047f, -0.17146809f, 0.69399011f, 0.46043405f, 
    -0.03529355f, -0.08449009f, 0.10694614f, -0.34641227f, 0.23035790f, -0.11787249f, -0.17788273f, -0.20288783f, 
    -0.02193023f, 0.17184725f, 0.48452979f, 0.01179998f, -0.38659480f, 0.40026489f, -0.39815667f, -0.29784411f, 
    0.29967558f, -0.19984476f, -0.16936202f, -0.10911366f, -0.17528442f, -0.73473704f, -0.55502689f, 0.49718061f, 
    0.26491603f, -0.03933497f, 0.43825004f, -0.26728186f, -0.53032440f, -0.47862470f, 0.03745507f, 0.18648256f, 
    0.02809553f, -0.18999101f, -0.32273906f, -0.23741452f, -0.02367056f, -0.18973956f, -0.23156838f, -0.12066493f, 
    0.33646664f, -0.28621054f, 0.00931187f, 0.33059159f, 0.23239018f, -0.29915726f, -0.60844493f, -0.41696683f, 
    0.22754093f, 0.56895763f, -0.59509069f, -0.52704281f, -0.49415949f, -0.40805978f, 0.36221129f, -0.04545531f, 
    -0.24382873f, -0.11130992f, -0.15011416f, -0.40423846f, 0.04224081f, -0.09306978f, -0.30336696f, -0.15836105f, 
    -0.05837100f, 0.34180996f, -0.34795883f, 0.15128686f, -0.42550999f, 0.09378829f, -0.73319381f, 0.57497132f, 
    0.41343307f, -1.06025100f, -0.48043832f, -0.46031135f, 0.24079238f, 0.18196063f, 0.35044056f, -0.04630970f, 
    -0.41408285f, -0.46182474f, 0.01407360f, -0.01112675f, -0.08303085f, 0.09896681f, 0.20617102f, 0.01201596f, 
    -0.20000981f, -0.20947897f, -0.21991931f, -0.22745527f, -0.27484000f, -0.35668257f, -0.50023186f, -0.84765780f, 
    -0.18531866f, -0.62136900f, -0.40294313f, -0.46001670f, 0.08986812f, -0.05746316f, 0.33312234f, 0.50320899f, 
    0.42282507f, -0.13145143f, 0.23849604f, 0.06213571f, -0.11078648f, -0.02385563f, -0.26420856f, -0.23248921f, 
    -0.23306045f, -0.17203125f, -0.41804144f, 0.09951455f, 0.15722820f, -0.12270375f, 0.12518254f, 0.28057981f, 
    -0.49604037f, -0.74357551f, -0.68129575f, -0.04956194f, 0.30923361f, 0.33901152f, 0.49804351f, -0.23222077f, 
    -0.37277108f, 0.06978436f, 0.40665501f, -0.12466880f, 0.53603464f, 0.06294416f, 0.05659147f, 0.17817166f, 
    0.02601085f, 0.23263173f, -0.17042923f, 0.03550746f, -0.16251743f, 0.14127073f, -0.01042793f, -0.00221156f, 
    -0.00511228f, 0.00922741f, 0.06875372f, 0.14992024f, 0.20064825f, -0.11159004f, 0.55053884f, 0.27332920f, 
    -0.05294030f, -0.55012029f, 0.33813798f, 0.21582383f, -0.18990552f, 0.25850543f, 0.13162616f, -0.26694405f, 
    0.18805018f, 0.04470496f, 0.26408616f, 0.07899773f, -0.35272670f, -0.03108010f, -0.36325997f, -0.20507683f, 
    0.04642375f, 0.45137322f, -0.25657612f, 0.16987352f, -0.49148500f, 0.60852224f, 0.11078849f, 0.10926130f, 
    0.21936010f, 0.10586962f, -0.11230092f, 0.41934243f, 0.17082414f, 0.32492819f, -0.18766025f, -0.28613174f, 
    0.18795092f, 0.11969072f, -0.06582471f, 0.08421877f, 0.12595548f, -0.16204032f, 0.12060098f, 0.00692394f, 
    0.16000859f, 0.09237813f, -0.38874152f, -0.60237730f, -0.36955878f, -0.67512476f, -0.47479910f, 0.05871546f, 
    0.67447031f, 0.22049271f, 0.35873470f, -0.32447532f, 0.16001156f, 0.09237166f, -0.15418667f, -0.21476351f, 
    0.48051974f, -0.26192975f, 0.27805474f, -0.14537522f, -0.00394664f, -0.15325554f, -0.58991832f, -0.35058898f, 
    0.17752318f, 0.00280304f, 0.06777615f, -0.01885603f, -0.01486962f, -0.10566977f, 0.35570449f, -0.12862386f, 
    -0.07892980f, 0.01619963f, 0.28588310f, -0.06119899f, 0.16461442f, 0.17649266f, 0.10933068f, -0.26794353f, 
    0.28791878f, -0.02640426f, -0.30580780f, 0.36008289f, -0.45169812f, 0.23686618f, -0.22170964f, -0.16595639f, 
    -0.30231705f, 0.24058576f, 0.11684552f, 0.16044666f, 0.35473806f, -1.12236726f, -1.00928462f, 0.02097601f, 
    0.60934323f, 0.39960617f, 0.54232401f, -0.65319151f, 0.08074494f, 0.26312989f, 0.63090473f, -0.04609021f, 
    -0.01747924f, -0.33513042f, 0.15331073f, -0.00410012f, -0.20810935f, -0.08876402f, 0.17519994f, -0.01460581f, 
    0.10323932f, 0.05718885f, -0.30540118f, 0.16774994f, 0.11197164f, -0.11629134f, 0.65248746f, -0.03885908f, 
    0.04263809f, -0.20542890f, -0.73053759f, 0.61571956f, -0.71812391f, -0.12383115f, 0.35791296f, 0.08542677f, 
    0.34217614f, -0.41726515f, -0.18519974f, 0.60811549f, -0.11368882f, -0.46320578f, 0.28611067f, 0.20982482f, 
    -0.13699715f, -0.05281109f, 0.18311319f, 0.18684536f, -0.19734079f, -0.27820987f, 0.26460442f, -0.50460136f, 
    -0.01423433f, -0.49813056f, -0.10240912f, 0.35287878f, -0.26895204f, -0.42172995f, 0.19413373f, -0.46485639f, 
    -0.22797583f, 0.40547109f, 0.54572743f, 0.29661900f, -0.00181756f, 0.21738811f, 0.01869177f, 0.15765436f, 
    -0.21575598f, -0.05282044f, 0.12460830f, -0.11782616f, -0.12704615f, 0.14137885f, 0.11969281f, 0.24714035f, 
    -0.72805560f, -0.39223877f, 0.27267778f, -0.33009243f, -0.31961375f, -0.46960288f, -0.34097990f, -0.73709947f, 
    -0.33658081f, 0.27516103f, 0.18330990f, 0.18917218f, 0.45391077f, 0.05121598f, 0.11306821f, -0.22195107f, 
    -0.36118832f, -0.22520408f, -0.13090755f, -0.15221180f, 0.35006723f, -0.03468481f, -0.31500849f, 0.25493789f, 
    0.19487695f, -0.02910591f, -0.71906990f, -0.08701730f, 0.07573885f, 0.25832906f, 0.41412553f, 0.46535119f, 
    0.09365302f, -0.18897381f, -0.07207454f, 0.20156553f, -0.14693533f, -0.12617514f, 0.35469881f, -0.00504884f, 
    -0.26192951f, -0.28417739f, -0.08522582f, -0.23471594f, -0.37375230f, -0.14205280f, -0.31958750f, -0.13429643f, 
    -0.17267147f, -0.28098816f, -0.02382589f, -0.26957878f, -0.36993676f, 0.04266997f, -0.07021928f, -0.36452770f, 
    -0.50846988f, -0.40942478f, -0.23838794f, -0.61517990f, 0.47640246f, 0.46758646f, 0.00270076f, 0.83506411f, 
    -0.23993891f, 0.02769369f, 0.24444951f, -0.44715059f, -0.53702402f, -0.51973218f, -0.32749972f, 0.29010442f, 
    0.23667577f, -0.02469589f, -0.09103045f, 0.09101874f, -0.29706731f, -0.33724365f, -0.06766672f, -0.60016358f, 
    0.17554189f, 0.09394697f, 0.09856388f, -0.45663688f, 0.77939397f, -0.32981423f, -0.18070279f, -0.39366433f, 
    -0.26915339f, 0.03239018f, 0.10782223f, 0.68785423f, 0.02310925f, -0.36734900f, 0.06234929f, -0.12458330f, 
    -0.10665303f, -0.14634170f, -0.25764263f, 0.18852545f, 0.54603732f, -1.14710152f, -0.85911006f, -0.69331443f, 
    -0.12797706f, 0.68592483f, 0.43471807f, 0.19341405f, -0.28891736f, -0.23854977f, 0.28547499f, 0.02681637f, 
    -0.02152064f, -0.23162657f, -0.26675200f, 0.02271794f, -0.17546754f, 0.16563822f, 0.35106143f, -0.09930378f, 
    -0.16463332f, -0.29814148f, 0.17870268f, -0.17310727f, -0.35240030f, -0.75859386f, -0.27499774f, -0.64563507f, 
    -0.49294403f, -0.26992589f, 0.21865456f, 0.36351958f, 0.35646194f, 0.44577780f, 0.46780249f, 0.04146092f, 
    -0.11774576f, -0.39600182f, -0.35357082f, 0.16962822f, -0.38969409f, 0.19308276f, -0.21056958f, 0.31456158f, 
    0.16714858f, 0.07635275f, -0.04016177f, 0.10430512f, 0.26408312f, 0.06033735f, -0.03504098f, -0.01464944f, 
    -0.10032415f, 0.26740810f, -0.16231269f, -0.12210054f, -0.05007344f, 0.14392684f, 0.04096534f, -0.20694932f, 
    0.48487976f, -0.37077403f, 0.31820470f, 0.00936974f, -0.25789145f, 0.25747815f, -0.10999716f, -0.11635785f, 
    0.01811887f, -0.36345258f, 0.10410855f, 0.07770772f, 0.18537900f, -0.07096560f, 0.26580599f, -0.61998290f, 
    -0.55061060f, -0.42305225f, -0.51172692f, -0.42362884f, 0.13923097f, -0.27087405f, 0.41992560f, 0.06770319f, 
    0.06209159f, 0.44782001f, 0.12610321f, 0.33000109f, 0.03958094f, 0.24250822f, 0.01712714f, 0.20647758f, 
    0.20167954f, 0.09154171f, 0.15029314f, -0.18177368f, -0.18560770f, 0.20528723f, 0.01852667f, -0.36137205f, 
    0.19263992f, -0.28980687f, -0.58248246f, -0.05047328f, -0.07965309f, -0.01013221f, 0.16874006f, -0.34718800f, 
    -0.48036721f, -0.45336241f, -0.10618559f, -0.01827293f, 0.34967077f, -0.43253285f, -0.13485052f, 0.20836155f, 
    0.25375572f, 0.08994654f, -0.18842094f, 0.13249251f, -0.09056075f, 0.10804934f, -0.12873372f, -0.63920671f, 
    -0.06322189f, -0.82888943f, 0.46544722f, -0.22222152f, 0.15543252f, 0.03687232f, -0.85513955f, -0.24333179f, 
    0.55393207f, 0.46235189f, 0.50907850f, -0.24882019f, -0.02823554f, 0.47992679f, -0.18406887f, -0.23161134f, 
    -0.23879215f, -0.24974270f, -0.18343213f, -0.20554478f, -0.13601206f, -0.10906054f, -0.17163266f, 0.45936298f, 
    0.22088884f, -0.27117890f, -0.18173654f, -0.29981735f, 0.40799090f, 0.27447453f, -0.35583338f, -0.60934037f, 
    -0.73325890f, 0.04785213f, 0.30504233f, 0.41831565f, 0.42638999f, -0.50251180f, 0.07739267f, 0.32107157f, 
    0.22161324f, -0.16038272f, -0.18787186f, 0.00746127f, 0.15565901f, 0.35614291f, -0.21443720f, -0.01465247f, 
    0.42577410f, -0.08250233f, -0.41685283f, -0.59198546f, -0.26364261f, 0.00427391f, 0.34460333f, 0.47529942f, 
    0.51710540f, -0.24634899f, -0.70852810f, -0.29825786f, -0.03950849f, 0.36356285f, -0.11495356f, -0.21505332f, 
    0.34491229f, 0.37028372f, -0.19618675f, -0.45411783f, 0.20273982f, -0.04159541f, 0.04338320f, 0.07773864f, 
    0.25175855f, -0.09638142f, 0.12402450f, 0.17136751f, 0.27235132f, 0.75516659f, -0.24230500f, -0.38708767f, 
    -0.16849190f, -0.25972143f, -0.03936041f, -0.30491874f, -0.66649431f, -0.76651406f, -0.22625914f, 0.00885934f, 
    -0.11038759f, -0.21776226f, -0.06632660f, -0.42270827f, -0.25458282f, -0.21420391f, -0.10465847f, -0.02283373f, 
    -0.14269173f, -0.02195196f, -0.25729248f, -0.33251327f, -0.36384243f, -0.62360889f, 0.07303445f, 0.14113560f, 
    -0.51137775f, -0.49830392f, 0.41962990f, -0.10942382f, -0.69237024f, -0.52454132f, -0.29479972f, -0.13597460f, 
    -0.18122654f, -0.11875249f, -0.56519002f, -0.30004263f, -0.23795924f, -0.49111214f, -0.25901908f, 0.02031296f, 
    -0.20016895f, -0.20138757f, 0.02163783f, -0.00761000f, -0.00228955f, -0.01898489f, -0.33727834f, -0.32815671f, 
    0.09144160f, 0.48853052f, 0.32452047f, -0.12031677f, -0.16533551f, -0.01817912f, 0.31445861f, 0.49921831f, 
    0.02517057f, -0.15904875f, -0.37540522f, 0.09897439f, 0.44370973f, 0.13850571f, -0.08325738f, -0.10766844f, 
    -0.13529284f, -0.11858177f, -0.14714615f, -0.27604049f, 0.38208905f, 0.14209752f, 0.01537070f, -0.78024542f, 
    -0.05455260f, 0.19732468f, 0.30969501f, 0.38913375f, 0.31625158f, 0.09312829f, -0.04934139f, 0.15484339f, 
    0.12211388f, 0.27912131f, 0.23014115f, 0.15958382f, 0.17139357f, -0.07111529f, -0.11088169f, 0.06753700f, 
    0.20497100f, 0.08132869f, -0.03338535f, 0.26123914f, 0.29004860f, 0.07488851f, 0.10051286f, -0.22403945f, 
    0.56156248f, 0.39649317f, -0.09121205f, 0.05768911f, 0.09873195f, -0.32900324f, -0.25472361f, -0.01044151f, 
    0.07163323f, -0.40814552f, 0.08664861f, -0.02282768f, -0.06611536f, -0.05001786f, -0.20654577f, -0.04177625f, 
    0.22882350f, 0.28430235f, -0.09474205f, -0.09962586f, -0.39255068f, 0.11235753f, 0.16191046f, 0.24102768f, 
    -0.08033588f, 0.85426289f, 0.41978103f, -0.05864410f, -0.20237622f, -0.13087401f, -0.13398916f, 0.35999766f, 
    -0.08681280f, -0.10231088f, 0.14614753f, -0.01307339f, 0.09652165f, -0.19919868f, -0.37399969f, -0.23634255f, 
    -0.03806050f, 0.23684743f, 0.15276055f, -0.13124663f, 0.07353060f, -0.26429200f, -0.20568918f, -0.11552183f, 
    0.27003425f, -0.19273630f, 0.29464123f, 1.08162546f, 0.74988627f, -0.64663184f, -0.34597495f, -0.41036072f, 
    -0.12674688f, -0.04327260f, -0.29170027f, -0.79120582f, -0.00357367f, 0.14224850f, 0.01855064f, -0.13637976f, 
    0.13278361f, 0.29825732f, -0.14324424f, -0.37503359f, 0.17391025f, 0.00177977f, -0.27950969f, 0.31629813f, 
    -0.09793140f, -0.02077988f, 0.25561246f, -0.08496029f, -0.23945789f, -0.64690918f, -0.72048682f, -0.50976008f, 
    0.33790553f, -0.02925782f, -0.02439511f, 0.13648604f, -0.01683169f, 0.06703535f, 0.03917629f, 0.31602395f, 
    -0.05427923f, 0.28520149f, -0.18910514f, 0.04160515f, -0.09830037f, -0.01865918f, 0.14581296f, -0.09056535f, 
    -0.15393475f, -0.18217638f, 0.10412113f, -0.33497590f, 0.71250200f, 0.21442138f, -0.43502101f, -0.50406897f, 
    -0.71856213f, -0.66675520f, -0.27475059f, 0.27955765f, 0.67726809f, 0.31810525f, -0.15912384f, -0.04007504f, 
    0.19021814f, -0.07586906f, 0.36691344f, -0.29880476f, 0.23407985f, -0.14464116f, -0.03600380f, -0.22539921f, 
    -0.11496835f, 0.20336492f, 0.03848112f, -0.28400785f, 0.12586839f, -0.63778359f, -0.53402889f, -0.54167801f, 
    0.34793401f, 0.74440134f, -0.07368965f, 0.28994635f, 0.55814618f, 0.16185102f, -0.09887588f, -0.33548474f, 
    0.13963130f, -0.27116588f, 0.05812622f, -0.30828509f, 0.12301520f, 0.30281433f, -0.36365885f, 0.31008524f, 
    0.12503102f, -0.00226086f, -0.21847658f, -0.12588651f, 0.04614028f, 0.03315994f, -0.38465819f, -0.61848694f, 
    -0.59750527f, 0.12295384f, 0.77025491f, 0.46918473f, 0.30365515f, -0.55509645f, -0.61533612f, -0.28332436f, 
    -0.39519998f, -0.44376954f, 0.02720405f, -0.03554133f, -0.27491465f, -0.13076171f, -0.46389064f, 0.21134071f, 
    0.01055713f, -0.29527929f, -0.09508689f, 0.22991739f, -0.27816340f, -0.09201325f, -0.00725682f, 0.98630011f, 
    -0.70197988f, -0.35734761f, 0.25941905f, 0.20442797f, 0.05249722f, -0.43318319f, 0.89277816f, -0.55947447f, 
    -0.55097079f, -0.50945443f, -0.21097976f, 0.38292658f, -0.44277051f, 0.02825170f, 0.22437871f, 0.38675463f, 
    -0.00159885f, 0.07609617f, 0.01268400f, -0.04761068f, -0.21365954f, -0.22219741f, -0.11683337f, 0.21122597f, 
    -0.70941257f, -0.19403966f, -0.30207404f, -0.17533408f, 0.08267596f, 0.19177523f, -0.17710084f, 0.02671912f, 
    0.33892205f, 0.17293681f, 0.13169818f, 0.03282234f, -0.02287591f, 0.02239218f, 0.27530813f, -0.19911239f, 
    -0.08196273f, 0.02829589f, -0.04467936f, 0.14280005f, 0.27895126f, 0.47846299f, 0.29999465f, 0.22972955f, 
    0.14058657f, 0.12946019f, 0.23292255f, 0.08984254f, 0.25740138f, -0.01721498f, 0.29059413f, 0.12062142f, 
    0.03826106f, -0.06064131f, 0.30163544f, 0.15144576f, -0.14442337f, 0.18122816f, -0.26473722f, -0.18526758f, 
    -0.08057442f, -0.15060511f, 0.08539148f, -0.21002555f, -0.26158854f, -0.02022317f, 0.15227123f, -0.20180751f, 
    0.03203009f, 0.25556821f, 0.34387988f, -0.67081732f, -0.39438972f, 0.54957062f, 0.15383181f, 0.49460885f, 
    0.45138580f, 0.03263628f, -0.22790113f, 0.21510053f, 0.23923627f, -0.26198280f, -0.28967595f, -0.17514931f, 
    0.48629406f, -0.05219327f, 0.27912393f, 0.14740179f, -0.20612933f, -0.26271072f, 0.20037964f, -0.33385959f, 
    0.12838289f, 0.08405783f, -0.15909928f, 0.38363555f, 0.65989530f, 0.35997322f, 0.72471684f, -0.13994503f, 
    -0.00804684f, -0.39051217f, -0.56662560f, -0.36687014f, -0.30514500f, -0.17056723f, 0.04349951f, 0.03554453f, 
    -0.01461179f, -0.23087184f, 0.13432187f, 0.22239515f, -0.08273097f, -0.05456216f, 0.13955736f, 0.04705134f, 
    -0.21929413f, -0.15041995f, 0.01753444f, -0.00229275f, 0.56137598f, 0.19275984f, -0.12371078f, -0.05926847f, 
    -0.94032508f, 0.06935544f, 0.05041987f, 0.05633336f, -0.16559540f, -0.39056376f, 0.29618257f, -0.09161029f, 
    0.46573094f, -0.38731995f, -0.12058850f, 0.18695478f, -0.19006363f, 0.34588838f, 0.02602465f, -0.41360888f, 
    -0.40262765f, -0.17998929f, 0.16624133f, 0.04743964f, 0.09618526f, 0.76887357f, 0.15516950f, -0.15250579f, 
    0.02252236f, 0.13586253f, -0.42762098f, -0.19782701f, -0.17498299f, -0.18619874f, 0.26392984f, 0.19328170f, 
    0.29064932f, 0.07752097f, -0.25228930f, -0.12484448f, 0.14690313f, -0.11857100f, -0.25507185f, 0.44977903f, 
    -0.23783432f, -0.09883311f, -0.26107731f, -0.36144647f, -0.36464673f, -0.31542990f, -0.06287614f, -0.18381247f, 
    -0.17234236f, -0.06778972f, -0.32196090f, -0.28686169f, -0.17926867f, -0.32604551f, 0.17555061f, -0.53624797f, 
    0.05455712f, -0.04599722f, 0.19023837f, 0.27874476f, -0.06562173f, -0.04677033f, 0.18938585f, 0.11290874f, 
    0.05155826f, -0.01897390f, 0.11093738f, 0.18391789f, 0.00372259f, 0.16624252f, 0.13795690f, 0.68927968f, 
    0.50158399f, -0.25140181f, 0.53372282f, -0.59729111f, 0.01952659f, -0.84980893f, -0.11819939f, 0.82149661f, 
    -0.39421260f, 0.13958865f, -0.15308642f, -0.05617372f, 0.19262414f, -0.48738098f, -0.09200741f, 0.26580918f, 
    0.13694724f, -0.29488772f, 0.20944770f, 0.06603613f, 0.05881524f, 0.02077297f, -0.24222118f, 0.06793191f, 
    -0.42877185f, -0.33263022f, 0.33720672f, -0.35779849f, -0.34749037f, -0.20941310f, -0.44375840f, -0.42427421f, 
    -0.18879230f, -0.44477490f, 0.28004545f, 0.58139771f, -0.09365144f, -0.00879948f, 0.15089823f, -0.08437878f, 
    -0.13048737f, -0.27363163f, -0.39949271f, -0.41898715f, -0.10132916f, 0.11847906f, -0.19876063f, 0.02462078f, 
    -0.02395373f, 0.37894386f, -0.17729005f, 0.43450621f, -0.04371337f, -0.38392287f, -0.21080816f, 0.08432940f, 
    0.07778611f, -0.15976074f, 0.14277817f, 0.49988297f, -0.35362142f, -0.02972119f, 0.14366011f, -0.04814541f, 
    0.16499008f, 0.24050376f, 0.10253739f, -0.11065509f, -0.39579827f, 0.17507043f, 0.04141044f, -0.01240727f, 
    -0.10908669f, 0.12595423f, 0.84641272f, -0.34741291f, -0.87391967f, -0.83639973f, -0.53693199f, 0.55402589f, 
    -0.00676628f, 0.03264522f, 0.34082887f, 0.22644150f, 0.11142418f, 0.01182801f, 0.23710847f, -0.24021101f, 
    0.12433556f, -0.25443020f, -0.25140634f, 0.22087017f, -0.05418038f, -0.33575907f, 0.15651397f, -0.12010268f, 
    -0.18609546f, 0.42626199f, 0.30468005f, -1.16370094f, 0.91239530f, -0.19300751f, -0.61504513f, 0.62448442f, 
    -0.50591946f, -0.32118812f, 0.85902756f, 0.37127009f, -0.31621316f, -0.13788801f, 0.01876054f, -0.03906357f, 
    0.29284889f, -0.28194889f, -0.12503198f, -0.12390257f, -0.59113884f, 0.41730946f, -0.07909761f, 0.03678219f, 
    0.13112961f, -0.13231848f, 0.33823967f, -0.20308962f, 0.57544816f, -0.32480887f, -0.58949804f, -0.18462349f, 
    0.25185940f, -0.54360574f, -0.14964810f, -0.35878173f, 0.00306042f, 0.14265934f, 0.27051565f, -0.22542799f, 
    0.01622801f, -0.05313672f, 0.32917741f, 0.04422492f, 0.48659343f, -0.08305774f, -0.35351989f, -0.41041467f, 
    -0.35333860f, -0.42954713f, -0.01753324f, 0.19304863f, 0.12471777f, 0.19434975f, 0.14802773f, 0.17307271f, 
    -0.17320146f, -0.34459570f, 0.28204048f, 0.08229781f, -0.26389554f, 0.04832990f, 0.31709474f, -0.03189431f, 
    0.39529094f, -0.13247435f, 0.01341908f, -0.15617754f, 0.04740178f, -0.21524525f, 0.23405881f, 0.14167918f, 
    -0.22075397f, 0.15751074f, -0.07387785f, 0.29394168f, -0.49299711f, 0.30790648f, 0.17801569f, 0.06532092f, 
    -0.65890896f, -0.77332616f, -0.27501374f, -0.18483746f, 0.07877775f, 0.71440446f, 0.32586572f, -0.44261423f, 
    -0.29796168f, -0.30692580f, -0.12323169f, -0.02514064f, -0.12309193f, -0.17651585f, -0.17387824f, -0.03115613f, 
    -0.07322104f, 0.20002022f, 0.16425459f, -0.04361913f, -0.26068157f, 0.17398965f, 0.03566274f, 0.75942165f, 
    0.44067585f, -0.30012086f, -0.44630253f, -0.84462196f, -0.22072336f, -0.04569384f, 0.27265403f, 0.31447598f, 
    0.34237140f, 0.19668658f, 0.18435830f, -0.03713810f, -0.29502228f, 0.03795537f, -0.23061651f, 0.12439058f, 
    -0.36848351f, 0.12893163f, 0.14493108f, -0.02584743f, 0.29941267f, -0.08691578f, -0.05821278f, 0.15246321f, 
    -0.44715929f, 0.21975708f, -0.25920728f, -0.80691767f, -0.32123524f, -0.41489908f, 0.01476351f, -0.26135460f, 
    0.03553305f, 0.25679171f, -0.07824393f, -0.41379377f, -0.24186201f, -0.48390856f, 0.28574660f, 0.19121304f, 
    0.56949371f, 0.10182381f, 0.03781295f, -0.14809296f, -0.34906459f, -0.17865111f, -0.33315712f, -0.34042808f, 
    -0.40038398f, -0.16398662f, 0.33209801f, 0.41349462f, 0.54168355f, 0.29181069f, 0.27418864f, -0.50440687f, 
    -0.27255797f, -0.02000489f, 0.07426371f, 0.18027218f, 0.09403872f, 0.05390184f, -0.16731070f, -0.02325731f, 
    -0.21965091f, -0.05180749f, -0.00802341f, 0.10562059f, -0.02101095f, -0.05844180f, -0.07572666f, 0.11159294f, 
    0.08454580f, -0.08538254f, 0.23861097f, 0.16947933f, -0.17265101f, 0.41283953f, 0.23064981f, 0.23932371f, 
    -0.31478575f, -0.36118793f, -0.43295640f, 0.12252579f, 0.26474118f, -0.32500592f, 0.16193329f, 0.16379373f, 
    -0.02454373f, -0.28299251f, -0.16876619f, 0.03474883f, 0.13196871f, -0.01395975f, 0.16555643f, -0.18294604f, 
    -0.03047374f, 0.29795119f, -0.29447281f, -0.72443205f, -0.29355693f, -0.39112183f, -0.85833275f, -0.62308198f, 
    0.46210483f, 0.18047407f, -0.10891430f, -0.06474369f, 0.14851296f, -0.37856451f, -0.35564810f, -0.37681410f, 
    -0.21621397f, -0.15894674f, 0.22259171f, 0.01273569f, -0.07523315f, -0.01991416f, -0.05931513f, -0.02671597f, 
    0.06592742f, -0.05342080f, -0.05916207f, -0.21293513f, -0.06093147f, -0.67521453f, -0.65419191f, -0.13111047f, 
    -0.67443633f, 0.78072339f, 0.48865333f, 0.17368765f, -0.30684012f, 0.71207708f, -0.28400609f, 0.45307416f, 
    -0.12619677f, -0.02964110f, 0.12072941f, -0.28526875f, -0.05017442f, 0.35118264f, -0.26328486f, -0.17505483f, 
    0.01594202f, 0.07227027f, -0.11872378f, -0.02846354f, 0.13142225f, -0.08549430f, 0.16819037f, 0.34156832f, 
    -0.33182433f, -0.72049886f, 0.42518717f, 0.37143749f, -0.03251498f, -0.18046626f, -0.11761765f, 0.35885003f, 
    -0.21633083f, 0.24972820f, -0.04190381f, -0.04347938f, 0.02653920f, -0.25357598f, -0.05178086f, -0.16211991f, 
    0.11961526f, -0.24175420f, 0.30380908f, 0.40367070f, -0.02815206f, -0.19095658f, -0.60175580f, -0.51262432f, 
    0.24119292f, -0.11952101f, 0.28717938f, -0.10852331f, 0.37101111f, -0.56267548f, -0.42051020f, -0.14031464f, 
    -0.12612058f, 0.45907950f, -0.23337042f, -0.59738457f, -0.07204610f, 0.07469103f, 0.23055826f, 0.03507292f, 
    0.37528920f, 0.27534741f, 0.13926026f, -0.25358543f, -0.10535052f, -0.22555780f, 0.34231973f, -0.80056870f, 
    0.29758570f, 0.25921968f, -0.76322269f, -0.49253517f, 0.19950257f, -0.31031951f, 0.01435595f, 0.28069678f, 
    0.19746433f, -0.26467144f, 0.12738691f, -0.14397286f, -0.05994867f, -0.12638731f, 0.12162855f, 0.31264141f, 
    0.06465625f, 0.05993035f, 0.12826934f, -0.11192258f, 0.31913933f, 0.04649941f, -0.14827769f, -0.26362741f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01011916f, 0.12704468f, -0.05642572f, 0.19093868f, -0.10622436f, 0.16327155f, -0.07698425f, 0.10548608f, 
    0.04764046f, -0.13649499f, -0.05353509f, 0.13378532f, -0.02478696f, 0.19769457f, 0.08859761f, 0.11375661f, 
    -0.01219855f, 0.02152055f, 0.04598112f, -0.08595780f, -0.22709076f, -0.02692592f, 0.22103472f, -0.07308708f, 
    0.13310070f, 0.07272619f, 0.20861244f, 0.14109756f, -0.26659849f, -0.14378658f, 0.40159842f, -0.43683678f, 
    0.03028663f, 0.02927276f, 0.23836985f, -0.05384681f, 0.30528817f, 0.00991874f, -0.16459146f, -0.06119270f, 
    -0.43687025f, 0.01623570f, 0.21289626f, 0.15021320f, 0.16643618f, -0.20863020f, 0.11806199f, 0.11019231f, 
    0.05368853f, -0.07071035f, 0.23355302f, 0.17326230f, 0.09519842f, 0.34538132f, 0.03756724f, 0.27252895f, 
    -0.26900062f, 0.02502347f, 0.08702023f, -0.39159679f, 0.26154229f, 0.27080014f, 0.34199345f, 0.04996279f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00430798f, 0.02627986f, 0.00728289f, -0.03410177f, 0.00430870f, 0.00680417f, -0.00025199f, -0.01619087f, 
    -0.02347086f, -0.01404833f, -0.00168934f, -0.00065914f, -0.04383039f, -0.02803724f, 0.00089523f, 0.02227186f, 
    -0.04129976f, -0.00297381f, -0.01889874f, -0.00246102f, -0.03743812f, -0.02444513f, -0.02635927f, 0.01219188f, 
    0.00267680f, -0.01592900f, -0.00679428f, 0.00329233f, -0.00992414f, 0.01141752f, -0.04460087f, 0.00857085f, 
    -0.02569999f, -0.01840021f, -0.03438405f, -0.01774052f, -0.02200425f, 0.01246301f, 0.00755971f, -0.01957927f, 
    -0.02108222f, 0.00797306f, 0.02062513f, -0.00307161f, 0.01831193f, -0.01834888f, -0.03211559f, -0.01711064f, 
    -0.00804717f, 0.02476605f, 0.01437436f, 0.00801240f, 0.03756507f, 0.01477506f, -0.00231643f, 0.01687244f, 
    0.00837648f, -0.01553732f, 0.01435145f, -0.01453074f, 0.02224846f, -0.02430684f, 0.00889391f, -0.00918280f, 
    0.03483349f, 0.03094079f, -0.02452751f, -0.00795383f, 0.00746175f, 0.02985169f, 0.00055564f, 0.00799489f, 
    0.01473129f, -0.03442442f, -0.04404374f, -0.00893355f, -0.00599715f, 0.01240742f, -0.00109512f, -0.00740740f, 
    -0.00292621f, -0.02325360f, 0.03533744f, 0.03167627f, -0.03534125f, -0.03334444f, -0.00120037f, -0.00473770f, 
    -0.01028921f, -0.03181915f, -0.02186235f, 0.01762016f, -0.04110321f, -0.01144943f, 0.01238771f, -0.04338976f, 
    -0.01228611f, -0.01030048f, 0.01232917f, -0.03372106f, -0.02466988f, 0.02083989f, -0.04189200f, -0.00919631f, 
    -0.00998765f, 0.01684727f, -0.02466574f, -0.03447405f, -0.02311851f, -0.01545228f, -0.03593093f, 0.00003111f, 
    -0.03341115f, -0.00027027f, -0.01122546f, 0.00218597f, -0.03210869f, -0.02594573f, 0.01370064f, 0.00205554f, 
    0.02950669f, -0.02828312f, 0.03694490f, -0.00623066f, -0.02168737f, -0.01028145f, 0.01899035f, 0.01213502f, 
    0.01984882f, -0.04435322f, -0.03158245f, -0.02882094f, -0.02781809f, -0.02823790f, -0.04084935f, -0.02202951f, 
    0.01817376f, 0.01643433f, 0.02088164f, -0.00312526f, 0.00421524f, 0.00531722f, -0.00130448f, 0.01717682f, 
    0.01158147f, 0.01230716f, -0.00507326f, 0.01323768f, -0.00367819f, -0.01087999f, 0.01423371f, -0.03381624f, 
    0.00210233f, -0.01866392f, 0.01342852f, 0.00136787f, -0.03796136f, -0.03307952f, 0.00895950f, 0.01819604f, 
    0.02400413f, 0.00044583f, -0.02226081f, -0.00150392f, 0.00750622f, 0.02224641f, -0.01452373f, -0.02374338f, 
    0.01614205f, -0.00264056f, 0.00149583f, -0.01537577f, 0.02149118f, -0.03268836f, 0.00380302f, 0.00004958f, 
    0.02515352f, 0.00441482f, -0.02199754f, 0.00192483f, 0.00287770f, 0.02026075f, -0.02542094f, 0.01860642f, 
    -0.04315236f, 0.02349304f, -0.03437631f, 0.00303982f, -0.03052351f, -0.01841558f, 0.00873383f, -0.02230420f, 
    -0.03419131f, 0.01676586f, -0.01504945f, 0.00504848f, -0.04013232f, -0.00209518f, -0.02307397f, -0.03215010f, 
    -0.01974466f, 0.00818148f, 0.00095248f, -0.03508342f, 0.01513882f, -0.02849279f, 0.03579777f, 0.00758915f, 
    0.03924938f, -0.01119529f, 0.00586217f, 0.02295883f, 0.00301599f, 0.04039177f, 0.01560792f, -0.03842832f, 
    0.01355988f, -0.02587694f, -0.00855879f, 0.01645361f, 0.00636887f, 0.01752307f, -0.02605082f, -0.03264891f, 
    -0.02925675f, -0.02460102f, -0.01069118f, -0.03114925f, 0.01830890f, 0.00357107f, -0.01058288f, -0.00157531f, 
    0.02590708f, -0.00627046f, -0.03370244f, -0.00508037f, -0.00042245f, 0.01414079f, 0.03516798f, 0.02467997f, 
    0.02576965f, -0.00848889f, 0.00810192f, -0.03727299f, -0.01706246f, -0.02366716f, -0.01967282f, -0.02986727f, 
    0.02735847f, 0.00093812f, -0.00057774f, -0.02822837f, 0.01673548f, -0.03699603f, -0.02872698f, 0.03864267f, 
    -0.00436530f, 0.02181983f, 0.02492172f, 0.01113314f, -0.03310102f, 0.02642523f, 0.00106366f, -0.00134999f, 
    -0.02431508f, 0.02464404f, 0.02542938f, 0.01608071f, -0.03522632f, -0.00783086f, 0.01182069f, -0.00247300f, 
    -0.00607094f, 0.01703065f, -0.01417661f, 0.02128209f, 0.01302901f, 0.03759380f, -0.01993345f, -0.02028903f, 
    -0.03293641f, -0.03720023f, 0.02029568f, -0.01793532f, -0.02245802f, -0.03233451f, 0.01203355f, -0.02402426f, 
    -0.02457672f, -0.00170942f, 0.01517727f, 0.01279918f, -0.01490651f, 0.01748369f, 0.02012122f, 0.01510868f, 
    0.03780870f, 0.01910205f, 0.00866667f, 0.02594075f, 0.02171941f, 0.03018278f, 0.00210182f, -0.01524654f, 
    -0.03060903f, 0.03366270f, 0.03629417f, -0.01979321f, -0.00838501f, -0.03151621f, 0.00543404f, 0.02250349f, 
    0.00883713f, -0.00306822f, -0.00505644f, 0.00975892f, 0.01758788f, -0.02828606f, 0.00282762f, -0.01517271f, 
    0.00201983f, 0.01360908f, 0.02912062f, -0.01847517f, -0.02023018f, -0.04291228f, -0.03978728f, 0.00117464f, 
    0.01323197f, -0.02150771f, -0.00576116f, 0.02213558f, 0.02457231f, -0.01150049f, 0.02006469f, 0.00316494f, 
    -0.04189245f, -0.01538371f, -0.00593042f, 0.02096211f, -0.02526604f, 0.02010587f, -0.01789418f, 0.00568555f, 
    -0.03731588f, -0.02600936f, -0.01881258f, 0.02464916f, -0.01371336f, -0.00124676f, 0.01931141f, -0.00931491f, 
    -0.01387064f, 0.00106431f, 0.00855844f, -0.03775228f, -0.04128936f, 0.03298332f, -0.00548846f, -0.00397611f, 
    0.03228231f, -0.03089491f, 0.00491666f, 0.01736975f, 0.00376152f, -0.01344760f, -0.00001811f, -0.03629677f, 
    0.02391914f, -0.04457531f, 0.00837412f, 0.02551047f, 0.01048473f, 0.02319382f, -0.00352282f, 0.00000036f, 
    0.02711808f, 0.00260165f, 0.02577822f, -0.00200345f, 0.02896044f, 0.00000968f, -0.00100661f, 0.02712060f, 
    0.01626017f, 0.02138896f, 0.03758553f, -0.01475668f, 0.02810962f, -0.00648682f, -0.03962339f, -0.02307812f, 
    0.00174367f, -0.03405257f, -0.01306835f, -0.03642471f, -0.03672765f, -0.03868428f, -0.00214877f, -0.02604097f, 
    -0.01967288f, -0.01659365f, 0.01099262f, -0.01961327f, -0.03573297f, -0.01929947f, 0.02181347f, 0.02243876f, 
    -0.03928487f, -0.03286909f, 0.02567875f, 0.00753100f, -0.00672016f, -0.04329244f, 0.00289818f, 0.00760212f, 
    0.02067661f, -0.02936458f, -0.01966036f, -0.00306761f, 0.01680342f, -0.00697518f, -0.00819787f, -0.04188909f, 
    -0.03082785f, -0.00030334f, 0.01526382f, -0.02203089f, -0.00075773f, 0.01610740f, 0.01083296f, 0.00385084f, 
    -0.02667149f, 0.00748920f, -0.03205966f, -0.02159033f, 0.00809250f, 0.01927055f, -0.00752336f, -0.04210775f, 
    -0.02471457f, 0.00952430f, -0.00750865f, 0.01450816f, -0.01220888f, 0.00663602f, -0.02221519f, 0.01976700f, 
    -0.04354391f, -0.03086992f, -0.04386403f, 0.02583303f, -0.00421846f, 0.00408546f, 0.02529486f, -0.01338027f, 
    -0.02294312f, 0.01466543f, -0.01221024f, -0.02064999f, -0.02817939f, -0.00115485f, -0.03475700f, 0.00667449f, 
    -0.03819029f, 0.01126578f, 0.01929038f, -0.00851606f, 0.00887362f, -0.03662447f, -0.01791090f, -0.01086174f, 
    -0.01060623f, -0.03487048f, 0.00281868f, -0.00588844f, -0.02065469f, -0.01499592f, 0.01432086f, -0.00543707f, 
    0.01229876f, 0.01639411f, -0.03833121f, 0.02981028f, 0.02056920f, -0.02884138f, -0.02492163f, 0.01751054f, 
    -0.01084012f, 0.00327712f, -0.00166635f, -0.01579939f, 0.01748025f, -0.02632497f, 0.01970544f, -0.01801581f, 
    -0.00820399f, -0.02399976f, 0.00751145f, 0.01113391f, -0.02664985f, 0.00900247f, -0.03168754f, -0.03775188f, 
    -0.00522118f, -0.03434506f, 0.03239125f, 0.03323639f, 0.02354206f, -0.04288983f, -0.02378003f, -0.02005773f, 
    0.00160955f, -0.04380835f, -0.00997781f, -0.00285390f, -0.02230297f, -0.02536482f, -0.00223674f, 0.00515785f, 
    0.03376862f, 0.01594228f, -0.02641860f, 0.00044658f, 0.00101771f, -0.03092475f, -0.03501447f, -0.01535932f, 
    0.01148925f, -0.03528046f, 0.00366963f, -0.00854808f, -0.02644248f, -0.00746477f, 0.02243686f, -0.00114142f, 
    -0.02779416f, -0.03043362f, -0.00894535f, -0.01979479f, 0.00156549f, 0.00472609f, 0.00336049f, 0.01163334f, 
    0.00009640f, 0.00119677f, 0.00168624f, -0.00628717f, 0.00240173f, 0.01124313f, -0.03457936f, -0.00119045f, 
    0.00843499f, 0.02080465f, -0.02169333f, 0.01105349f, -0.00631862f, 0.00448256f, -0.04039099f, 0.00265747f, 
    0.00044864f, -0.02346794f, -0.04350266f, -0.03833523f, -0.01640622f, 0.01096558f, -0.03684391f, -0.01808456f, 
    0.02256482f, -0.00042111f, -0.00996008f, -0.00279123f, 0.00059423f, -0.04119269f, 0.00197268f, -0.03614807f, 
    0.00296982f, 0.02695958f, -0.03148467f, -0.02408843f, -0.02289941f, -0.00095357f, 0.01041740f, 0.01140629f, 
    -0.00707873f, -0.03530838f, -0.01994960f, 0.01610011f, -0.01376351f, -0.00650408f, -0.03045439f, -0.02430843f, 
    0.01760597f, -0.01571148f, 0.02196658f, 0.01734874f, -0.03110301f, -0.03123151f, -0.02525116f, 0.00127726f, 
    -0.02514323f, -0.02452963f, -0.03314659f, 0.02039228f, -0.02745282f, 0.00617174f, 0.02317164f, 0.01061756f, 
    0.01585277f, 0.02584346f, 0.00486058f, -0.01243485f, -0.02099310f, -0.04645691f, -0.03878425f, 0.00220296f, 
    0.00718306f, -0.00780403f, -0.02601426f, 0.00176056f, -0.01344872f, 0.02450357f, 0.01416970f, -0.02776952f, 
    -0.00162000f, -0.02704528f, 0.01040560f, -0.02869662f, -0.03856397f, 0.02005434f, -0.00379668f, -0.01805443f, 
    -0.00939947f, -0.01794823f, -0.02151703f, 0.01673994f, -0.03362494f, -0.02982774f, 0.01909532f, 0.00539274f, 
    0.01544658f, -0.01427763f, 0.02627191f, -0.03568749f, -0.00235850f, -0.04020624f, 0.01176578f, 0.00339635f, 
    -0.03541821f, -0.00952486f, -0.03904110f, -0.01005208f, 0.01614812f, -0.01213703f, 0.01665549f, -0.01599053f, 
    0.02073776f, -0.01863178f, 0.00694781f, 0.00167904f, -0.02193135f, -0.02516036f, -0.02199203f, 0.02110324f, 
    -0.02016309f, 0.00905536f, 0.01607164f, 0.01954943f, -0.01217320f, -0.00717941f, -0.02730410f, -0.04046669f, 
    -0.00555487f, 0.01965928f, 0.01420330f, -0.00762079f, -0.00234442f, -0.02098684f, 0.02582846f, -0.03685964f, 
    -0.00322855f, -0.00965380f, 0.02295248f, -0.02170709f, 0.01076272f, -0.03218268f, 0.01564643f, 0.03011674f, 
    -0.01129423f, 0.03422805f, -0.02698623f, -0.04173447f, -0.01338838f, -0.01928451f, -0.02326554f, 0.02381473f, 
    0.00238049f, -0.04492411f, 0.03339415f, -0.03063597f, -0.00291364f, -0.02592415f, -0.03026651f, -0.01437980f, 
    0.02413463f, -0.02569872f, -0.03308450f, -0.01767560f, -0.02217371f, 0.01906831f, -0.00326700f, -0.03420934f, 
    0.00769420f, -0.01962244f, 0.02081000f, 0.02650656f, -0.01169202f, 0.01832421f, 0.01599212f, 0.01332266f, 
    -0.00852624f, 0.02934403f, 0.00115260f, -0.00911458f, 0.02422841f, -0.03925470f, 0.01115996f, -0.00122433f, 
    0.01705526f, 0.01304151f, 0.03572317f, -0.03167159f, -0.01065219f, -0.00088097f, 0.01277805f, 0.01155245f, 
    0.02299124f, -0.01302967f, -0.03653330f, 0.01743139f, -0.01084305f, -0.00197226f, 0.01265422f, 0.02320295f, 
    -0.00007558f, -0.00569239f, -0.01857382f, -0.01809163f, -0.03865105f, 0.01669357f, -0.04352883f, -0.00483233f, 
    -0.03597563f, -0.00617797f, -0.00347667f, 0.02354935f, 0.02321420f, 0.00412998f, -0.01615650f, -0.00109289f, 
    0.01765519f, 0.02298499f, -0.00313490f, -0.01765136f, -0.00068347f, -0.03327467f, -0.01887674f, 0.00934423f, 
    0.03677513f, -0.03192442f, -0.09100894f, -0.10126101f, -0.01789984f, -0.11224161f, 0.01661358f, -0.02900591f, 
    0.21166487f, 0.05726080f, 0.00076723f, -0.18419860f, -0.07288215f, -0.19163060f, -0.00570320f, 0.21505994f, 
    -0.02313991f, 0.02326919f, 0.05439505f, -0.05139054f, 0.07135370f, 0.03356321f, 0.03240176f, 0.20298500f, 
    0.03419225f, -0.11828894f, -0.13860348f, -0.07048643f, 0.00600528f, 0.23260753f, -0.08015602f, 0.08053485f, 
    0.06245808f, -0.24419180f, 0.16054563f, 0.05580711f, 0.16330245f, -0.01900583f, 0.24504890f, -0.11036142f, 
    0.01396976f, 0.08494797f, -0.08629282f, 0.26157299f, 0.17109431f, 0.01099164f, 0.15910760f, 0.10275261f, 
    -0.16128142f, -0.04575384f, 0.19546658f, 0.12435334f, -0.09709920f, 0.13453002f, 0.00950715f, 0.11216335f, 
    -0.01074483f, 0.03266533f, -0.13011166f, 0.01715799f, -0.22089542f, -0.17762314f, 0.27430382f, 0.13983478f, 
    -0.02928318f, 0.03995639f, 0.05634595f, 0.23134692f, 0.01756055f, -0.01182247f, 0.04769113f, 0.08493434f, 
    -0.03200812f, 0.14825931f, -0.20831759f, -0.00725174f, -0.12025245f, 0.04171004f, 0.15857543f, -0.00079234f, 
    0.18273255f, -0.17328805f, -0.11303627f, -0.06428739f, -0.10083798f, 0.01172956f, 0.06504718f, 0.09155345f, 
    -0.07322401f, -0.06615904f, -0.08821302f, 0.04671058f, 0.12762809f, 0.12458100f, 0.15774047f, 0.14048067f, 
    -0.29694608f, -0.06893833f, 0.40132961f, -0.06353351f, 0.04558676f, 0.01827715f, -0.20037071f, 0.02563139f, 
    0.01284308f, 0.05226685f, -0.03276895f, 0.03382022f, -0.03613990f, -0.00264926f, 0.03715432f, -0.33690503f, 
    0.03312950f, -0.03014036f, -0.12020031f, -0.07931668f, -0.07936952f, 0.08329561f, -0.14117026f, 0.10391650f, 
    0.01131436f, -0.05669697f, -0.08027607f, -0.11032682f, 0.06268320f, 0.00474133f, -0.00961943f, 0.14818759f, 
    0.19207886f, 0.16651024f, 0.19654779f, 0.03086665f, -0.30942750f, 0.20754543f, 0.42652056f, -0.08998036f, 
    -0.00928489f, -0.08350665f, -0.04661640f, 0.11325457f, 0.10212100f, 0.01810027f, 0.14199036f, 0.03876635f, 
    -0.02182205f, -0.16539744f, -0.19115551f, -0.10820601f, -0.00883546f, -0.11968303f, -0.04636220f, -0.02080470f, 
    0.07501050f, -0.13329124f, 0.06708864f, 0.22130486f, -0.25356463f, -0.39719310f, 0.00226844f, 0.57121348f, 
    -0.04897133f, -0.00884094f, 0.00477793f, 0.17708194f, 0.12419673f, 0.04765417f, 0.22422683f, 0.19639812f, 
    0.37126532f, 0.51070487f, 0.06548065f, 0.11544085f, 0.16730693f, -0.06566373f, 0.11560257f, -0.03717467f, 
    0.14255039f, -0.06246398f, 0.13843071f, 0.10625795f, -0.28971982f, -0.12611473f, 0.19763559f, 0.01295424f, 
    0.01064889f, 0.10244811f, 0.04558573f, 0.06100132f, -0.01259650f, -0.06933782f, -0.08105355f, -0.03823985f, 
    -0.15734075f, -0.22737043f, 0.13518283f, 0.03368824f, 0.01685893f, -0.03391160f, -0.09922025f, -0.09080052f, 
    0.06746161f, 0.04049005f, -0.00751108f, 0.05140229f, -0.13172390f, 0.27353346f, 0.38703358f, -0.16352051f, 
    0.05010688f, -0.04076876f, -0.06956702f, 0.04832065f, 0.08551766f, 0.31020901f, 0.06606556f, -0.04506731f, 
    -0.27203938f, 0.00820876f, 0.26738262f, 0.03618755f, 0.11224191f, -0.04390119f, -0.13743640f, -0.29811978f, 
    0.03290887f, 0.03516964f, 0.07999822f, -0.06952120f, -0.11423531f, -0.14486659f, 0.02875319f, 0.11351191f, 
    -0.03188556f, 0.08830567f, 0.13130891f, 0.25536737f, -0.17711212f, -0.09375686f, 0.07798465f, 0.13836291f, 
    -0.35464886f, 0.14633760f, 0.46591032f, -0.33040312f, -0.05863716f, 0.04882807f, -0.11984280f, 0.20989184f, 
    -0.00377023f, 0.06569024f, 0.18701781f, -0.15440637f, -0.39917809f, -0.00260582f, 0.07787092f, 0.23623824f, 
    -0.14818519f, -0.01952556f, 0.14117725f, 0.02451312f, 0.05509440f, -0.04439101f, -0.02486906f, 0.08624031f, 
    0.13519882f, -0.07876506f, -0.14378329f, -0.03548004f, -0.04609285f, -0.03644267f, 0.09417795f, 0.06368343f, 
    0.02790868f, -0.05546630f, 0.05702749f, 0.10595328f, -0.31698748f, 0.16149962f, 0.06976651f, 0.02835756f, 
    -0.12156947f, -0.14492904f, -0.12104742f, 0.13333870f, 0.00940275f, -0.11600861f, -0.02868456f, -0.04684051f, 
    -0.27198267f, 0.01658457f, 0.18262713f, -0.00359178f, 0.06269680f, 0.06418542f, 0.00530871f, 0.06856044f, 
    -0.02949962f, 0.00786541f, 0.06421185f, 0.05844000f, 0.45310095f, 0.20560372f, -0.20455377f, 0.44115329f, 
    -0.09351142f, -0.11551044f, -0.04873511f, 0.00598909f, -0.01881349f, 0.14472072f, 0.20554771f, -0.11490650f, 
    -0.02880651f, -0.21005683f, -0.16205339f, 0.41623101f, 0.07556642f, 0.14629114f, 0.11221927f, 0.18315755f, 
    0.05892409f, 0.06028703f, 0.07340226f, 0.22550042f, -0.21091995f, -0.23755336f, 0.45256132f, 0.05963410f, 
    0.04540552f, 0.06732261f, 0.03183365f, 0.00432383f, 0.13578139f, 0.09249840f, -0.19924986f, -0.01604497f, 
    -0.13200313f, 0.09999917f, 0.06786897f, -0.01915015f, 0.05441974f, 0.07058736f, 0.06214605f, -0.10788825f, 
    0.09764530f, 0.03408018f, 0.04344388f, -0.07073431f, -0.24766417f, -0.20121565f, 0.21006560f, -0.12654752f, 
    0.04653741f, 0.06838430f, -0.00927555f, -0.12583314f, 0.14824800f, 0.12439515f, 0.06786636f, -0.02839115f, 
    -0.06582588f, -0.15971881f, -0.04304206f, 0.12084306f, -0.09289485f, -0.02724037f, 0.03067633f, 0.12264699f, 
    0.09344900f, 0.15676415f, 0.05039875f, 0.02179986f, -0.19805340f, -0.12042189f, -0.07343605f, -0.11418051f, 
    0.00534658f, -0.06950012f, -0.10961389f, -0.04230928f, 0.19302009f, 0.04805886f, 0.07445161f, -0.19420746f, 
    0.05739018f, -0.15164523f, -0.16692078f, -0.19212699f, 0.12347373f, 0.22550227f, 0.00921232f, -0.00455276f, 
    0.01524068f, -0.15461539f, 0.00596089f, -0.08629995f, 0.05112407f, 0.05872614f, -0.00165908f, -0.15908715f, 
    0.08146559f, 0.06761646f, -0.03534517f, -0.09016180f, 0.15905325f, 0.05080375f, 0.04999753f, -0.12778296f, 
    -0.14734131f, 0.09033097f, -0.20690762f, -0.01832090f, 0.41479760f, 0.13778755f, 0.20241392f, 0.04901478f, 
    0.05561291f, -0.08921182f, -0.12350085f, 0.03006770f, -0.25142375f, 0.21091272f, 0.08540069f, -0.11907938f, 
    -0.04374923f, -0.12461303f, 0.03180376f, 0.12351912f, 0.14992885f, -0.01530759f, 0.02715384f, 0.02238193f, 
    0.50967979f, 0.29579037f, -0.03935055f, 0.22237475f, -0.00173372f, -0.12587626f, 0.05279599f, 0.15029457f, 
    0.22360100f, 0.10768801f, 0.09330929f, -0.02470899f, -0.16964214f, 0.16503420f, 0.23118155f, 0.10367756f, 
    0.01960414f, -0.09083784f, -0.00415120f, 0.24369738f, -0.09154549f, 0.07189341f, 0.05853897f, 0.01049902f, 
    -0.28499398f, 0.06187521f, 0.17184925f, -0.09477663f, -0.08524074f, 0.04991397f, -0.02505280f, 0.06546769f, 
    0.04729922f, 0.16775684f, 0.04027702f, 0.10994016f, -0.27720055f, 0.18940522f, 0.11242462f, -0.03564098f, 
    0.10185934f, -0.11018476f, 0.00384492f, -0.02242824f, -0.12209063f, -0.01764496f, 0.16905387f, 0.11257264f, 
    -0.05392492f, -0.16515522f, -0.06755783f, -0.06415489f, -0.12899609f, -0.12320872f, 0.18190658f, -0.04486278f, 
    0.05778079f, 0.06726313f, -0.02240612f, -0.10955383f, 0.01771577f, 0.01260961f, -0.15390147f, -0.31878161f, 
    -0.08247977f, -0.14731401f, -0.02944186f, -0.06830315f, -0.00954780f, -0.18604638f, -0.14033964f, 0.07166319f, 
    -0.22386487f, 0.02648209f, 0.09194516f, -0.02446995f, 0.05692554f, -0.01646244f, 0.07145299f, 0.15519631f, 
    -0.00386492f, 0.10055355f, -0.03248131f, -0.01905111f, 0.20562887f, -0.18942145f, 0.00104363f, 0.00341962f, 
    0.05503371f, 0.07661362f, 0.08087998f, 0.04576366f, 0.01759873f, -0.06060392f, -0.04642215f, -0.11654319f, 
    0.21349381f, 0.39906946f, -0.08350576f, 0.03811783f, -0.00931943f, -0.02544503f, 0.06008588f, 0.03461807f, 
    0.12095384f, 0.09492876f, 0.07908861f, 0.06046072f, 0.22458863f, -0.15326293f, -0.16056253f, -0.20772634f, 
    -0.03078666f, -0.01412618f, 0.12896259f, 0.10078538f, 0.37814468f, 0.18380238f, 0.01844099f, -0.11517821f, 
    -0.23048277f, -0.00225647f, 0.01981705f, 0.04379664f, 0.04404865f, 0.12337533f, 0.07925496f, 0.03152053f, 
    -0.01991565f, 0.01084075f, -0.08568317f, -0.03125915f, 0.47208712f, 0.29839745f, -0.05209231f, -0.17350775f, 
    -0.02856293f, 0.11681969f, 0.16154242f, -0.11488935f, 0.11326551f, 0.02500818f, 0.06178939f, -0.00009706f, 
    -0.12441467f, -0.07610068f, 0.13006324f, 0.08805966f, 0.00937823f, -0.08395451f, 0.00493360f, -0.23739612f, 
    0.07849634f, -0.03271329f, 0.08204504f, 0.06483743f, 0.17201930f, 0.01408522f, -0.09591141f, -0.13676429f, 
    0.14635563f, 0.10020069f, -0.01549024f, 0.02404237f, 0.05658458f, -0.16741389f, -0.05834809f, 0.06069471f, 
    -0.04198575f, 0.37636289f, 0.19952473f, -0.04387180f, -0.09266946f, -0.10296761f, 0.17850491f, 0.04652666f, 
    0.25542164f, 0.16772288f, 0.04298023f, -0.01531202f, 0.02845836f, 0.46537054f, -0.12758213f, 0.05232736f, 
    0.05302317f, -0.03108817f, 0.19688462f, -0.01068822f, 0.03426892f, 0.18795934f, 0.03991291f, -0.05774404f, 
    -0.17055790f, -0.03583962f, 0.01347576f, 0.09716580f, 0.17840646f, 0.03161108f, 0.11023493f, 0.14309137f, 
    0.11611147f, 0.02940872f, 0.07397865f, 0.10469725f, -0.01662864f, 0.11598822f, -0.01151593f, 0.10082744f, 
    -0.01154371f, -0.03758609f, 0.15955941f, 0.11372775f, 0.26818752f, 0.01404357f, 0.29775196f, 0.34188107f, 
    -0.19271626f, 0.01681571f, -0.00023586f, -0.12386999f, 0.10971723f, 0.09089229f, 0.12502134f, 0.04647684f, 
    0.10241283f, 0.03180201f, -0.07732714f, 0.04993429f, 0.60524988f, 0.40810537f, -0.14268340f, 0.18796234f, 
    0.05627358f, -0.05759600f, 0.14851806f, -0.05695447f, 0.33098826f, 0.08173732f, 0.18452987f, 0.07325969f, 
    -0.18986771f, -0.09334633f, -0.12313122f, -0.06658592f, -0.14485981f, -0.05779172f, 0.16913611f, 0.10230363f, 
    0.01548446f, -0.15571286f, 0.05786863f, -0.11138209f, -0.10551712f, -0.11166772f, -0.08279617f, 0.00048857f, 
    -0.04329086f, 0.04433832f, -0.02148734f, 0.04992820f, -0.01597110f, -0.08424592f, -0.09042633f, -0.03782303f, 
    0.12487351f, -0.33061954f, 0.13937248f, 0.03487961f, 0.03134840f, 0.13572922f, 0.09656489f, 0.14056288f, 
    0.04196100f, -0.00926496f, -0.01521443f, -0.20231763f, -0.34670725f, -0.18713537f, -0.08268628f, -0.14277498f, 
    -0.05807966f, -0.23522687f, 0.02708445f, 0.01193739f, 0.03308151f, -0.06618876f, 0.02941803f, 0.00739405f, 
    -0.25610384f, 0.25551069f, 0.43293688f, 0.13460170f, -0.00923683f, -0.03928936f, -0.02576083f, -0.03412505f, 
    0.01760865f, 0.09618693f, 0.21446022f, 0.10543394f, -0.01992600f, 0.15764748f, -0.01767612f, -0.01165000f, 
    0.14011425f, -0.01517820f, 0.06853183f, -0.03156762f, 0.22359541f, 0.05193350f, 0.05768450f, 0.18416715f, 
    -0.38427463f, -0.14879094f, 0.29405686f, 0.22443312f, 0.12565324f, 0.08714318f, 0.11462615f, 0.21062751f, 
    -0.09652574f, -0.00690300f, 0.03124095f, 0.07132780f, -0.06818973f, -0.00754320f, -0.18135133f, 0.00580662f, 
    0.15685768f, 0.01911815f, 0.29553151f, 0.22167403f, -0.06619237f, -0.06087057f, -0.07600483f, -0.06739184f, 
    -0.01442847f, 0.01680517f, 0.00326182f, -0.01692113f, -0.01591760f, 0.01286740f, -0.03820155f, 0.01625630f, 
    -0.00648843f, -0.01425777f, 0.01841069f, 0.02220466f, -0.01289868f, 0.02653879f, -0.02128536f, -0.00953038f, 
    0.00437348f, -0.01127015f, -0.03057191f, -0.01146221f, -0.00030347f, 0.00955005f, -0.01059812f, -0.02979165f, 
    -0.03275251f, -0.03404525f, 0.00002893f, -0.03041487f, 0.02543322f, -0.03554836f, 0.01564507f, 0.01984564f, 
    -0.00901529f, 0.02106952f, -0.00708751f, -0.01793168f, 0.02023103f, 0.02644664f, -0.03904993f, 0.00764192f, 
    0.02660888f, -0.01950842f, -0.00043608f, -0.01909183f, -0.02244294f, -0.03357862f, -0.03676601f, 0.00456416f, 
    -0.00039490f, -0.02995768f, 0.02403106f, 0.02790281f, -0.02410149f, -0.00834717f, 0.01822333f, -0.01907963f, 
    -0.02119296f, 0.03483936f, 0.01003915f, 0.02343751f, -0.01844801f, -0.01571525f, 0.01228103f, -0.02495897f, 
    -0.01285157f, 0.02066701f, -0.00678219f, -0.03958812f, -0.00536873f, 0.00925674f, 0.02414446f, -0.01143763f, 
    -0.03655029f, 0.03339997f, 0.00990834f, 0.00284035f, -0.02896105f, -0.00661650f, 0.00616044f, 0.00031730f, 
    -0.02474787f, -0.02762548f, -0.02967647f, -0.03992269f, -0.00947988f, -0.02212724f, 0.00270719f, 0.02353310f, 
    -0.01709715f, -0.02385403f, -0.01005330f, -0.01709761f, 0.01461873f, 0.01258602f, -0.02878433f, -0.03836589f, 
    -0.01717853f, 0.01426940f, 0.00049863f, -0.04394173f, 0.00507710f, -0.04043236f, 0.02332466f, 0.02675690f, 
    0.00553515f, -0.00575982f, 0.01519638f, -0.02300025f, -0.02726571f, 0.02102372f, -0.01583708f, -0.04398330f, 
    0.01916748f, -0.03659216f, -0.00945384f, -0.00775200f, -0.00965421f, -0.00562217f, -0.01779144f, -0.00989649f, 
    -0.01166828f, -0.01930623f, -0.03640270f, -0.03824095f, -0.02753866f, 0.02175897f, -0.00612869f, 0.00556046f, 
    -0.01092098f, 0.02062725f, -0.01898023f, -0.02890968f, 0.00509255f, -0.04056457f, -0.03940137f, 0.00573324f, 
    -0.01877381f, -0.01851851f, -0.01515805f, -0.02904093f, -0.00603166f, -0.02270413f, -0.01568308f, -0.02183288f, 
    0.01079982f, 0.00637338f, -0.02257417f, -0.02160702f, -0.00608583f, 0.01042336f, 0.00979332f, 0.01571796f, 
    0.00821138f, 0.02195586f, -0.01188914f, 0.00950649f, -0.00254599f, 0.01225190f, -0.02103993f, -0.02212148f, 
    -0.02176983f, -0.02177571f, -0.01186242f, 0.02128755f, 0.00973076f, 0.01376784f, 0.02715653f, -0.01415525f, 
    0.02887647f, -0.02282397f, 0.01255189f, -0.03114563f, -0.03148374f, -0.03568285f, -0.01366502f, 0.02959648f, 
    0.01266794f, 0.00716563f, 0.00873672f, -0.02131146f, 0.00789992f, -0.03481920f, -0.04120815f, -0.01852079f, 
    0.02611275f, -0.02266872f, -0.00599565f, -0.02404952f, -0.02609772f, -0.03461571f, 0.00318325f, -0.02505589f, 
    -0.00085197f, -0.02041016f, -0.00825216f, 0.01616024f, -0.01336461f, -0.00617757f, -0.03652612f, -0.02609586f, 
    -0.00336720f, 0.01298748f, 0.01708351f, -0.00596421f, -0.04019090f, -0.03567652f, -0.00680984f, -0.02073726f, 
    0.02623421f, 0.02447993f, 0.02424329f, -0.02757963f, -0.02720074f, 0.01232580f, 0.01229194f, -0.02504926f, 
    -0.03606765f, -0.01078347f, -0.00051002f, -0.01502931f, -0.00477479f, 0.01546634f, -0.01081196f, 0.01881393f, 
    0.02298054f, 0.00672902f, -0.00463826f, -0.02001278f, 0.02931952f, 0.00944438f, 0.01865801f, 0.00567586f, 
    -0.03601376f, 0.01076273f, -0.03631711f, -0.00405329f, -0.01057594f, 0.00379552f, 0.02386291f, -0.01753695f, 
    -0.01328320f, 0.02728925f, 0.01991142f, -0.01480499f, 0.02942689f, -0.01439139f, 0.02541199f, -0.01824717f, 
    0.00528452f, -0.03811515f, 0.02355694f, -0.04031847f, -0.01353921f, -0.00130525f, 0.00976789f, -0.03137031f, 
    0.02959396f, 0.01684701f, -0.00120555f, 0.02003632f, -0.02191133f, 0.01927613f, 0.02742627f, -0.01465009f, 
    -0.00020800f, -0.03016922f, -0.00645959f, 0.02392833f, -0.03450738f, 0.00604920f, 0.00719885f, -0.02495332f, 
    -0.01422129f, 0.01846993f, -0.01469292f, -0.01299139f, -0.00489776f, 0.01004575f, -0.03157794f, 0.00578884f, 
    0.03179329f, 0.02989830f, -0.01498632f, 0.01022402f, 0.00007138f, -0.00695224f, -0.00348003f, 0.00114008f, 
    -0.02319865f, -0.03014283f, -0.02939023f, 0.02174093f, 0.03029850f, 0.00508227f, -0.00418370f, -0.03318246f, 
    -0.01523840f, 0.00213176f, 0.02366356f, -0.00318926f, -0.01974609f, -0.02044868f, 0.01954495f, -0.01681016f, 
    0.01300999f, -0.01060392f, -0.03038979f, -0.00258603f, -0.01879459f, 0.02229146f, 0.02690090f, -0.03609686f, 
    0.00511178f, -0.02926035f, 0.00059570f, -0.02922261f, 0.02212713f, -0.03853573f, -0.01304731f, -0.00866709f, 
    -0.00469949f, 0.02074657f, -0.01329071f, -0.02913160f, -0.04362628f, 0.00596245f, -0.01908224f, -0.00689867f, 
    -0.01239500f, -0.00147974f, 0.01699393f, -0.01289153f, 0.02415480f, -0.03437482f, 0.02484364f, 0.00150609f, 
    0.01645149f, -0.01771101f, -0.03193728f, 0.02847597f, 0.03591780f, 0.02175217f, -0.03221504f, -0.01298597f, 
    0.03395510f, 0.01730697f, 0.03191717f, 0.01808875f, -0.00100727f, -0.04373726f, 0.00259751f, 0.01071870f, 
    -0.03001788f, 0.02154676f, -0.00571013f, -0.01409939f, 0.00288021f, -0.01422057f, -0.02395516f, 0.00423363f, 
    -0.01649853f, 0.01328081f, 0.02129812f, 0.00182760f, -0.02019631f, 0.00042122f, -0.00378540f, -0.03647893f, 
    -0.01381784f, 0.02679019f, -0.03547019f, -0.02737423f, -0.02152191f, -0.03999917f, -0.02904431f, -0.03828216f, 
    0.01051303f, -0.03377963f, -0.01703510f, -0.02136267f, 0.00766610f, -0.01642192f, 0.01973174f, 0.00370547f, 
    -0.01421426f, -0.01664744f, 0.01071144f, -0.02117383f, -0.00349276f, -0.02573703f, 0.00801953f, -0.03121571f, 
    -0.02480260f, -0.00106800f, -0.03723104f, 0.00037307f, -0.00715296f, 0.00640254f, 0.00008082f, -0.03444685f, 
    0.00482385f, 0.03211356f, 0.00692404f, 0.00289992f, -0.02708559f, -0.00102878f, -0.01612662f, 0.00447819f, 
    -0.00122961f, 0.00889382f, 0.03326959f, 0.00962946f, -0.02059950f, 0.00474956f, 0.01843378f, -0.02673400f, 
    0.01078382f, 0.01809619f, 0.00677117f, 0.03382793f, -0.01818980f, 0.02127703f, -0.03743112f, -0.03117817f, 
    0.03019840f, 0.00723112f, -0.01109947f, -0.03850012f, 0.02460259f, 0.00837015f, -0.01468387f, 0.00478151f, 
    0.01645282f, 0.02229541f, -0.00738780f, 0.00518593f, -0.00280110f, -0.00900087f, 0.00533452f, 0.00125062f, 
    -0.01141412f, -0.01744404f, 0.02630911f, -0.01559496f, 0.01716027f, -0.01676711f, -0.01704836f, 0.01683243f, 
    -0.00281432f, 0.00066363f, 0.02635860f, -0.02666912f, -0.01411247f, 0.00970514f, 0.00465784f, -0.00405094f, 
    0.01575109f, 0.02217968f, 0.01237895f, 0.01921294f, 0.00465652f, -0.00422007f, 0.03450483f, 0.03344799f, 
    0.02595295f, -0.01061283f, -0.02084799f, 0.03443491f, -0.03256556f, 0.03710630f, -0.01766958f, 0.01443832f, 
    -0.02428436f, -0.02207959f, -0.01963352f, -0.03769181f, -0.03896091f, -0.00584927f, -0.00769491f, -0.00931410f, 
    -0.02197554f, -0.03407691f, 0.00646410f, -0.02645298f, 0.01751362f, 0.00588509f, -0.03524121f, 0.02493710f, 
    0.01020621f, -0.03390628f, -0.01278924f, -0.00568540f, -0.03849242f, -0.02104931f, 0.02007352f, -0.01758155f, 
    -0.01909852f, -0.01079573f, 0.01818563f, -0.02297747f, -0.02550423f, 0.02853267f, -0.03254825f, -0.01091345f, 
    -0.04383317f, -0.01084075f, -0.03050582f, 0.01714929f, -0.02617464f, -0.00487438f, 0.01283823f, -0.03493176f, 
    -0.03874198f, 0.00197783f, -0.00427940f, 0.01826231f, -0.02168415f, -0.03111080f, 0.00085615f, 0.02477615f, 
    -0.00669317f, -0.01517988f, -0.01558017f, -0.00070456f, -0.01432446f, 0.02434884f, -0.02920316f, -0.00824568f, 
    -0.00343708f, 0.02677459f, -0.02626924f, -0.01122461f, 0.02559735f, 0.02362416f, 0.02878002f, -0.04223487f, 
    0.01397461f, -0.03755451f, -0.01520967f, -0.01710229f, -0.00021723f, 0.02370469f, -0.00612127f, -0.03686335f, 
    -0.03364591f, -0.00118075f, 0.02585598f, 0.01048754f, -0.02392005f, -0.00490675f, -0.00301930f, -0.03285887f, 
    -0.01467717f, -0.01178186f, 0.00039936f, 0.01965105f, -0.00043877f, 0.03107124f, 0.01824765f, 0.02863374f, 
    -0.03270959f, -0.01564080f, -0.01594161f, 0.01731432f, 0.01071106f, 0.01403985f, 0.03286136f, -0.02135703f, 
    0.00552815f, 0.02940270f, 0.00401039f, -0.03605247f, 0.02475735f, 0.00293422f, 0.00864884f, 0.02548898f, 
    0.01039232f, -0.01930554f, 0.01707860f, -0.00089423f, 0.01651710f, 0.00728616f, -0.02794855f, -0.03555084f, 
    -0.01711601f, -0.03371000f, -0.03296001f, -0.01646655f, -0.01527117f, -0.02491080f, -0.00847844f, 0.01099131f, 
    -0.04175527f, 0.01772751f, 0.01936329f, -0.03003316f, -0.02180323f, -0.04025900f, -0.00173364f, -0.03334326f, 
    0.02141415f, 0.00733219f, 0.00863937f, -0.03358032f, 0.01242335f, -0.03068379f, 0.02110468f, -0.00960631f, 
    -0.02261407f, 0.01229268f, -0.02300203f, 0.02933601f, -0.02438869f, 0.03890779f, -0.03262641f, 0.03518226f, 
    0.00495179f, 0.00326720f, -0.02868157f, -0.01935292f, -0.03888550f, 0.00358049f, -0.02575982f, -0.00209501f, 
    0.00240874f, 0.00672958f, -0.01605842f, 0.01514628f, 0.01084975f, 0.01738447f, 0.01017534f, 0.00016428f, 
    -0.01619617f, -0.00140910f, -0.01235222f, -0.01480044f, -0.02169092f, 0.00444624f, -0.03606461f, -0.02057461f, 
    0.00750337f, -0.03320459f, -0.01098322f, -0.04013035f, -0.04014821f, 0.02406382f, 0.00758241f, -0.01819639f, 
    0.02284280f, 0.01831695f, -0.01832592f, -0.02763614f, -0.02054625f, -0.00704522f, 0.01005573f, -0.02193456f, 
    0.01502789f, 0.03305170f, 0.02890540f, -0.02661796f, -0.02488119f, 0.02616875f, 0.00651099f, 0.03043265f, 
    -0.01817334f, -0.00511791f, 0.02318111f, -0.01262182f, 0.03127147f, 0.00759051f, -0.02169566f, -0.00618718f, 
    -0.01809857f, -0.04075396f, -0.00000482f, -0.01767613f, 0.03391450f, -0.01372956f, -0.01854918f, 0.01773091f, 
    0.02599777f, -0.00682810f, 0.00268471f, -0.00369602f, 0.00954456f, -0.03495748f, -0.03663360f, -0.00953481f, 
    -0.01518054f, -0.03380762f, -0.04318294f, -0.02114935f, -0.02342170f, -0.03111464f, -0.01363124f, 0.01162836f, 
    0.01623857f, -0.03532448f, 0.02757289f, -0.00066547f, -0.02001231f, -0.03707257f, 0.03018466f, 0.00287876f, 
    -0.03097043f, 0.02505059f, 0.01199888f, 0.01293275f, 0.01843424f, -0.00039483f, 0.02757340f, 0.00624763f, 
    -0.00537275f, 0.02476913f, -0.02095453f, 0.00708233f, 0.02683888f, 0.01855279f, -0.02883217f, 0.01559934f, 
    -0.04082813f, 0.01491448f, -0.01242223f, 0.00851372f, -0.03066550f, 0.01384158f, -0.02408784f, 0.02884498f, 
    -0.00773494f, -0.01812810f, 0.01281479f, 0.01179788f, -0.04233131f, -0.00609066f, 0.01394857f, -0.03507842f, 
    -0.01686800f, -0.00663694f, -0.02296281f, -0.03603215f, 0.00351608f, -0.03203636f, 0.02767949f, -0.01979409f, 
    -0.00852685f, -0.02893169f, 0.02873635f, -0.01752175f, 0.02757348f, -0.03664992f, 0.01886790f, -0.03528244f, 
    -0.00530717f, 0.01682359f, -0.00085943f, 0.01136481f, 0.02010064f, -0.00160600f, 0.00034917f, 0.03134586f, 
    -0.01027847f, 0.01741896f, 0.01245087f, -0.01286279f, 0.01991334f, 0.01730430f, 0.00578020f, -0.01067252f, 
    -0.00557632f, -0.00534372f, 0.01708134f, -0.05040136f, -0.02134389f, -0.00179011f, -0.01003674f, 0.01260380f, 
    -0.02832680f, -0.05459568f, -0.01319222f, -0.02805922f, -0.05056759f, 0.00052208f, 0.02352826f, -0.03442036f, 
    -0.00953195f, 0.01193187f, 0.01146722f, 0.02056420f, 0.02143169f, 0.00457731f, -0.01157070f, -0.03039264f, 
    -0.02930616f, 0.01741349f, -0.00935713f, -0.03484615f, -0.00178439f, -0.00720404f, -0.04950556f, -0.03232184f, 
    -0.03215240f, -0.02890144f, 0.02215374f, -0.00489478f, -0.00467125f, -0.02980812f, -0.00841523f, -0.04209513f, 
    -0.04949713f, 0.00631957f, 0.00030506f, -0.06597675f, 0.00800396f, -0.03817054f, -0.02093195f, -0.05839556f, 
    -0.00837404f, 0.02931298f, -0.04256057f, -0.00295096f, 0.00805185f, 0.00026782f, -0.04832704f, -0.00499959f, 
    -0.03295110f, -0.00173542f, 0.00412311f, -0.01960197f, 0.03000603f, -0.01232497f, -0.00319815f, -0.03877893f, 
    -0.01066440f, -0.04465152f, -0.05106537f, -0.01258152f, -0.02453317f, -0.02637455f, -0.02535912f, 0.01265791f, 
    -0.01532948f, 0.01983605f, 0.01022472f, 0.02261540f, 0.01528655f, -0.03265031f, -0.00195472f, -0.00673782f, 
    -0.00426212f, -0.01664571f, -0.00396020f, -0.03035847f, -0.04228269f, -0.02557332f, -0.00558718f, -0.04016121f, 
    0.01032210f, 0.01060316f, -0.01906227f, 0.00919519f, -0.03872607f, -0.03262863f, -0.01564602f, -0.02823594f, 
    0.00118317f, -0.00385182f, -0.02520057f, 0.00925414f, -0.05191680f, -0.05002750f, -0.02805343f, 0.01344571f, 
    0.00996281f, 0.00186063f, 0.01963090f, 0.02068412f, -0.05590717f, -0.05062336f, -0.05348657f, -0.03106483f, 
    -0.00185940f, 0.00543706f, -0.00770160f, -0.05006864f, -0.02087566f, -0.01688943f, -0.03126446f, -0.03101782f, 
    -0.05674027f, -0.03917222f, 0.00605550f, -0.04010516f, -0.00926838f, -0.03159653f, -0.02364672f, -0.00010569f, 
    0.01171341f, -0.01806548f, 0.00192748f, -0.04368310f, -0.00547275f, -0.02892067f, -0.01698851f, -0.03535597f, 
    -0.02365283f, -0.00761314f, -0.03268123f, -0.01925036f, 0.02195969f, -0.05442062f, 0.01233316f, -0.04858439f, 
    -0.05164598f, -0.00419637f, -0.00017920f, -0.00984391f, -0.03812157f, -0.02436702f, -0.00103861f, -0.01031942f, 
    0.01208582f, -0.04870359f, -0.03030408f, -0.00916691f, -0.01485822f, -0.05554040f, -0.05197343f, -0.03334508f, 
    -0.01554954f, -0.04277210f, -0.02097631f, -0.00782546f, -0.00472898f, -0.00832936f, -0.05781611f, -0.01041291f, 
    -0.03003221f, -0.05764318f, 0.00904984f, -0.04743665f, -0.05475391f, -0.06059548f, -0.02691090f, -0.00467711f, 
    -0.02196760f, -0.02930050f, 0.00077554f, -0.01511686f, -0.00689958f, 0.00218006f, -0.00679863f, -0.04622958f, 
    -0.04056478f, -0.00662311f, -0.05813194f, -0.02911954f, -0.04338359f, -0.04154585f, -0.03480417f, -0.02804185f, 
    -0.03714999f, -0.02942042f, 0.03023580f, 0.01669595f, 0.02314933f, -0.03273819f, -0.00752290f, -0.02918638f, 
    -0.03430685f, -0.02402749f, 0.01339775f, -0.03689545f, -0.00771228f, -0.05032967f, -0.03983847f, -0.02412447f, 
    -0.02212907f, 0.01597156f, -0.00413179f, -0.03090914f, -0.00821272f, -0.05760174f, -0.01305406f, -0.02009915f, 
    -0.02452091f, -0.03517942f, 0.02842845f, -0.03394742f, 0.01090011f, -0.02476074f, -0.02738093f, -0.01355861f, 
    -0.00996582f, -0.00378827f, -0.03077110f, 0.01408273f, -0.02808008f, -0.04046975f, 0.01015503f, -0.00885065f, 
    -0.03788824f, 0.01048312f, -0.04012217f, -0.02578797f, -0.05351893f, 0.00974964f, -0.02921941f, -0.02725009f, 
    -0.04659572f, 0.02074719f, -0.01208504f, 0.00801546f, 0.01625965f, -0.02640992f, -0.00214032f, 0.00172302f, 
    0.01696178f, 0.01019739f, -0.05211155f, -0.03753935f, -0.00542632f, -0.00679482f, -0.03500236f, 0.00111234f, 
    -0.04100782f, -0.01521663f, -0.03560742f, -0.00174503f, -0.00771292f, -0.03977086f, 0.00180494f, -0.03893071f, 
    0.00487905f, 0.00624840f, -0.04594662f, -0.04141988f, -0.04900274f, -0.01303341f, -0.05873549f, 0.00095261f, 
    -0.02088961f, -0.03834207f, 0.01873982f, -0.04673810f, 0.00808051f, 0.00337670f, -0.05149098f, -0.00465639f, 
    -0.01689668f, 0.02097697f, -0.03471326f, -0.03900291f, 0.01520595f, -0.06223149f, -0.00979170f, 0.00176519f, 
    0.02514993f, -0.03122576f, 0.02271499f, -0.03023485f, -0.04023260f, -0.04310277f, -0.03405044f, -0.01941666f, 
    -0.05911239f, 0.00302775f, -0.00870190f, 0.00465925f, 0.00479932f, -0.00286378f, -0.04894248f, -0.05251784f, 
    0.01192126f, -0.01510248f, -0.02847646f, 0.00350808f, 0.00599818f, -0.00142790f, 0.00595555f, -0.02574879f, 
    0.00074597f, -0.03760631f, -0.02926634f, 0.01223706f, -0.02190528f, 0.00404569f, -0.00702623f, -0.01659849f, 
    -0.05358331f, -0.03121552f, -0.00673430f, -0.00945121f, -0.00443963f, 0.02833496f, -0.02469466f, 0.01473694f, 
    -0.04816650f, -0.00868543f, -0.04866676f, -0.04055285f, 0.00834971f, -0.01957487f, -0.01092092f, 0.01351177f, 
    -0.01912540f, 0.01194187f, -0.01537573f, -0.01787554f, 0.00467429f, -0.03282645f, 0.00201448f, -0.01617517f, 
    -0.01103516f, 0.01285180f, 0.00900837f, -0.04414948f, 0.02720434f, -0.00472254f, -0.01938139f, -0.01111574f, 
    -0.05018027f, -0.01522771f, 0.01936790f, -0.02835133f, -0.04306739f, -0.02242449f, 0.00755280f, -0.00855862f, 
    -0.06351520f, 0.00913180f, -0.03389559f, -0.05931235f, 0.01074679f, -0.04538242f, -0.04578435f, -0.01236284f, 
    -0.03185768f, 0.01119603f, -0.00263818f, 0.00365367f, -0.05114040f, -0.03236953f, -0.05196756f, -0.00718378f, 
    -0.04495943f, 0.00073151f, 0.00105380f, 0.00129364f, -0.02034744f, -0.03200288f, -0.03345090f, 0.01039023f, 
    0.00064430f, 0.01328580f, -0.04102236f, -0.05278702f, -0.04720142f, -0.03499088f, -0.00680993f, -0.02078033f, 
    -0.04637567f, -0.02263771f, -0.00235067f, -0.00517284f, 0.00511868f, 0.00788887f, 0.01119468f, -0.02239015f, 
    -0.04174363f, -0.01441344f, -0.04199421f, -0.00703725f, 0.00238785f, -0.04928010f, -0.04873928f, -0.03149515f, 
    0.02464103f, -0.01085817f, 0.02417413f, 0.00924750f, -0.01592906f, -0.01861339f, -0.02967507f, -0.02243375f, 
    0.01416643f, -0.04155159f, -0.00271112f, 0.01304017f, -0.04714135f, 0.01189739f, -0.05370597f, -0.02191873f, 
    0.01618513f, -0.05291380f, -0.02845575f, -0.00813530f, 0.00911376f, 0.01031886f, -0.05396684f, -0.01357078f, 
    -0.04943516f, -0.02540483f, -0.03768383f, -0.01674101f, 0.01637619f, -0.05497464f, -0.04288423f, -0.03569236f, 
    -0.03004573f, 0.02045064f, -0.00166539f, -0.02396830f, -0.05038976f, -0.02932983f, -0.02887059f, -0.05843619f, 
    0.01226695f, 0.00680157f, -0.02442086f, 0.00470947f, -0.01279519f, -0.03263164f, -0.05359684f, -0.04182407f, 
    -0.02365516f, -0.03112088f, 0.00920898f, -0.00996973f, -0.05194209f, 0.02283663f, -0.02734364f, 0.00077783f, 
    0.00556439f, -0.03015983f, -0.03293892f, -0.03866002f, -0.02488816f, 0.00942945f, 0.00830033f, -0.02180897f, 
    -0.00661417f, 0.00098781f, -0.01837908f, 0.01615929f, -0.03796379f, 0.00966648f, -0.00474875f, 0.00164918f, 
    -0.05413282f, -0.00193366f, -0.04540982f, 0.00852608f, -0.05171974f, -0.02896469f, 0.00168176f, -0.00297471f, 
    -0.01085431f, -0.04237580f, 0.00286758f, 0.01274457f, -0.04918754f, -0.02182883f, 0.01781500f, -0.05215297f, 
    0.01055051f, -0.00992959f, 0.01912944f, 0.00233674f, -0.02175681f, -0.02928431f, -0.05394888f, 0.00898304f, 
    -0.00164143f, -0.00331947f, -0.00374648f, 0.00217380f, -0.05241229f, -0.03667933f, -0.01871380f, -0.01240646f, 
    0.00498739f, -0.05299384f, -0.05585106f, -0.04294253f, -0.02067300f, -0.02522401f, -0.01319222f, 0.00931205f, 
    -0.05469518f, 0.01204055f, -0.04745026f, -0.02904081f, -0.04941507f, -0.03955450f, -0.04071391f, -0.01110709f, 
    0.01554030f, -0.00007555f, -0.03091658f, -0.00142481f, -0.02338324f, -0.02424057f, -0.02932517f, -0.03670234f, 
    -0.00951617f, -0.01767101f, -0.00104655f, -0.01351881f, -0.02543668f, 0.02800350f, -0.03916965f, -0.00105055f, 
    -0.04764202f, -0.06009212f, -0.00290385f, 0.02179092f, -0.03642516f, 0.00407224f, -0.00203623f, -0.04691246f, 
    -0.01301679f, -0.02748412f, -0.01355070f, -0.02721216f, -0.05293501f, -0.03038299f, 0.00083940f, -0.01295626f, 
    -0.00788339f, -0.00882958f, -0.00531361f, 0.02993468f, 0.01455534f, 0.00317082f, -0.01374117f, 0.01812047f, 
    -0.06304549f, -0.00333639f, -0.04382398f, -0.01795249f, -0.00279689f, -0.03360732f, -0.03663133f, -0.03781376f, 
    -0.01341957f, -0.00307089f, -0.03900044f, -0.01329251f, -0.01246502f, -0.00845622f, 0.00752786f, -0.02037209f, 
    -0.00925463f, -0.00677034f, 0.00130408f, -0.01855921f, -0.00955346f, -0.01557654f, 0.00709695f, 0.00890992f, 
    -0.02536873f, -0.02410202f, -0.04553897f, -0.00179121f, -0.02867674f, -0.01815476f, -0.00764761f, -0.02716465f, 
    -0.02760519f, -0.01376450f, 0.00101189f, 0.02333720f, -0.05286106f, 0.01486499f, -0.00582063f, 0.01236607f, 
    -0.00962208f, -0.03279785f, -0.03299959f, -0.06163713f, 0.03867412f, -0.04170543f, 0.02857205f, -0.00319439f, 
    -0.00064697f, 0.00823873f, -0.00245474f, -0.00458454f, 0.01389922f, 0.00816926f, -0.05350693f, -0.03110240f, 
    -0.04074402f, -0.03116124f, -0.06362893f, -0.02791559f, -0.04003553f, -0.00396830f, -0.04837237f, -0.01197736f, 
    -0.01679241f, -0.00665240f, -0.02837229f, -0.05822971f, -0.00827224f, 0.00612521f, -0.04797221f, -0.01103337f, 
    -0.05440585f, -0.00047559f, -0.01471309f, -0.02733955f, -0.00072499f, 0.01368854f, -0.02521885f, -0.02958091f, 
    -0.03531286f, -0.02765542f, 0.01870210f, -0.00842527f, -0.00482396f, -0.00743712f, 0.00914244f, -0.00858500f, 
    -0.02682420f, -0.02265390f, -0.01135227f, -0.01920532f, -0.04460821f, -0.01134997f, -0.03637730f, -0.04414826f, 
    -0.00364921f, -0.04588937f, -0.06022886f, 0.00701898f, -0.00346464f, -0.01229199f, -0.03447004f, -0.05799050f, 
    -0.00896467f, 0.01981174f, 0.00471099f, -0.00264147f, 0.00046316f, -0.05196112f, -0.01919404f, 0.00461832f, 
    0.01479333f, -0.03274830f, -0.03779386f, 0.00254533f, -0.02956326f, -0.02182970f, -0.04262018f, -0.04529769f, 
    -0.02575474f, -0.02151139f, -0.03341190f, -0.05300095f, 0.01187835f, -0.03081371f, -0.04539535f, 0.00141409f, 
    -0.04255534f, -0.00087075f, -0.00236612f, -0.02316935f, -0.04026714f, -0.02324645f, -0.05037019f, -0.01103307f, 
    0.01856833f, -0.00753575f, 0.01468634f, -0.01510951f, -0.01051821f, -0.03773050f, -0.00701612f, 0.00873339f, 
    -0.00530111f, -0.00299057f, -0.01016281f, -0.03503562f, -0.00645014f, -0.04009552f, 0.01694326f, -0.01270036f, 
    0.00196919f, -0.05278904f, -0.05199033f, -0.03725326f, -0.02957870f, -0.01657479f, -0.04601584f, -0.01129099f, 
    0.01069889f, -0.05583893f, -0.03979479f, -0.01355716f, -0.04559391f, -0.04468234f, 0.00789981f, 0.01191641f, 
    -0.01879577f, -0.06698062f, -0.02556347f, -0.05381050f, 0.00006063f, -0.05436296f, -0.04011379f, -0.00325928f, 
    0.01591595f, -0.01883476f, -0.01416161f, -0.01798493f, -0.04484740f, 0.00071120f, -0.00520039f, -0.01011208f, 
    -0.05570786f, -0.03448422f, -0.03655751f, -0.04192195f, -0.01840076f, 0.00500544f, 0.00941782f, -0.01974745f, 
    -0.01624987f, -0.06160951f, 0.01915858f, -0.02167010f, -0.03935450f, -0.01008851f, -0.01977882f, 0.02381371f, 
    -0.01458671f, 0.02252165f, 0.01793321f, 0.01435436f, -0.02870408f, 0.03526561f, -0.01202897f, 0.00832390f, 
    0.01819818f, -0.01753496f, 0.02493940f, 0.03245863f, 0.00313956f, -0.02673475f, 0.01237975f, -0.03519931f, 
    0.03362021f, 0.01773449f, 0.01618357f, -0.01568521f, 0.03174564f, -0.00455311f, -0.03284688f, -0.00189134f, 
    0.00321862f, -0.00306239f, -0.02467627f, 0.00631925f, -0.02398365f, -0.01521873f, 0.00258289f, -0.03780194f, 
    0.00116759f, -0.01780804f, 0.00741342f, 0.01327744f, 0.00286317f, -0.01345745f, -0.01684297f, -0.01881283f, 
    -0.00468079f, -0.03336797f, 0.00038701f, -0.01802995f, -0.02692444f, -0.01236546f, -0.02213256f, 0.01583689f, 
    -0.02927975f, -0.03630550f, 0.02844886f, -0.01738841f, -0.03152827f, 0.01379432f, 0.01275084f, 0.00757657f, 
    -0.01097464f, 0.02917723f, 0.00393803f, -0.00939353f, 0.01503392f, -0.03598846f, -0.00873705f, -0.03656052f, 
    -0.03403383f, -0.03713764f, 0.04044988f, -0.02407283f, -0.02183187f, 0.00651260f, -0.00933098f, 0.02081721f, 
    -0.02308129f, -0.03576786f, 0.01105889f, 0.00535809f, 0.02186693f, 0.00349862f, 0.00939634f, 0.00234741f, 
    -0.02343546f, -0.00068116f, -0.03133442f, -0.00497343f, 0.02027829f, 0.01013731f, -0.01902042f, -0.00727358f, 
    -0.02631596f, 0.02288052f, 0.00024977f, 0.00774152f, -0.02276169f, -0.03076580f, -0.01761168f, -0.02279520f, 
    -0.04395385f, -0.04027626f, -0.03713669f, -0.02879884f, -0.01765229f, 0.00449474f, 0.01225640f, -0.01274451f, 
    -0.00995278f, -0.01858395f, -0.03422923f, 0.01843360f, -0.00175050f, -0.01714329f, -0.02430834f, -0.01923447f, 
    -0.01710006f, 0.02530600f, -0.03088039f, 0.01398830f, 0.01721079f, -0.02928733f, 0.00949617f, -0.00020841f, 
    0.00682312f, -0.00722876f, 0.01063893f, -0.03998698f, -0.00406249f, -0.03182957f, -0.00672370f, -0.01654256f, 
    0.01294088f, 0.01095827f, 0.03393348f, 0.02408911f, -0.02046275f, -0.00020420f, -0.00038777f, -0.01281870f, 
    0.02253675f, 0.01415311f, 0.00091933f, -0.00214191f, 0.01027802f, -0.01324188f, -0.02289326f, -0.02154883f, 
    -0.01453251f, 0.01612734f, 0.00198695f, 0.00153934f, -0.01091230f, -0.00406119f, -0.02300796f, -0.00420697f, 
    -0.00559650f, 0.03598886f, 0.00135186f, 0.00728882f, 0.01084349f, -0.00063033f, 0.01511119f, 0.03316834f, 
    0.02221701f, -0.03037824f, 0.00182478f, 0.02490158f, 0.00608330f, -0.02657904f, -0.00226539f, -0.01933962f, 
    -0.02994788f, -0.00300700f, 0.01795824f, 0.01186775f, 0.01801523f, -0.03576569f, 0.01180027f, -0.02993379f, 
    0.01023941f, -0.01571779f, -0.03489978f, 0.01881487f, -0.02536322f, 0.00733479f, -0.01344295f, -0.02109486f, 
    -0.00049258f, -0.02216697f, 0.01641732f, 0.02766635f, -0.00566266f, 0.01809157f, -0.01507709f, -0.00432969f, 
    -0.00166112f, -0.01451209f, -0.00065865f, 0.01923749f, 0.03046250f, 0.02227728f, 0.01218974f, -0.01617211f, 
    0.00720344f, 0.01536870f, 0.02359112f, 0.02864050f, 0.01453805f, -0.03876130f, -0.01069055f, -0.01191398f, 
    -0.03633587f, 0.01703315f, 0.01489947f, 0.02807266f, 0.03408522f, -0.00447146f, 0.03835692f, 0.00387405f, 
    -0.02158689f, -0.03817426f, 0.02521629f, 0.02322957f, -0.03313531f, 0.03168935f, -0.02481669f, 0.02856595f, 
    0.02632449f, -0.03254785f, -0.01081729f, 0.01849914f, 0.02537763f, 0.00849223f, 0.00098284f, 0.00882682f, 
    0.02098107f, 0.00692011f, -0.02552320f, 0.03194522f, -0.03242918f, 0.01050679f, -0.03550228f, 0.02271612f, 
    0.02712403f, -0.03963693f, -0.03261421f, 0.00248546f, -0.02394296f, 0.00347491f, 0.00846082f, -0.00374575f, 
    0.00736562f, -0.02928074f, -0.01976531f, 0.03211931f, 0.01688484f, 0.00427290f, 0.01968105f, -0.01296820f, 
    -0.01499888f, -0.00082554f, 0.02137589f, -0.02835499f, 0.03704791f, 0.01658439f, 0.00185932f, 0.00385617f, 
    0.00731845f, 0.00121265f, -0.04039730f, -0.03846898f, -0.01222039f, -0.03275398f, 0.01065761f, 0.02550187f, 
    -0.00494142f, 0.03094362f, 0.02864113f, 0.02277367f, 0.01659323f, 0.02551598f, -0.00746612f, -0.00282938f, 
    0.00479312f, -0.02954426f, 0.00546508f, -0.02943852f, 0.01446541f, 0.01226548f, 0.02104861f, -0.02196638f, 
    -0.04275838f, 0.01314239f, -0.00405377f, -0.01533234f, -0.00757098f, -0.00896742f, -0.02475351f, 0.03213115f, 
    -0.03207565f, 0.03364974f, 0.02793732f, 0.03182947f, 0.02627553f, -0.02701335f, 0.01848003f, -0.02927434f, 
    0.00778360f, 0.01132771f, -0.00885909f, -0.03134105f, -0.00204282f, -0.00926886f, 0.02968837f, 0.03036287f, 
    -0.00446198f, 0.00960848f, -0.02696074f, -0.03970146f, -0.03004869f, -0.01114072f, 0.00743187f, 0.01752568f, 
    0.00914750f, -0.02294177f, -0.02763024f, 0.03172411f, 0.00245922f, 0.00524190f, 0.00835096f, -0.01191547f, 
    -0.00976986f, 0.02308777f, 0.00276164f, -0.01001289f, 0.00247586f, -0.00371207f, 0.00039661f, -0.03431801f, 
    -0.03181528f, -0.04258100f, -0.01941880f, 0.01343440f, -0.02470109f, 0.03150730f, -0.01650769f, -0.02649261f, 
    0.02342641f, -0.00994791f, -0.02705236f, -0.00331814f, -0.04795109f, -0.04628477f, -0.04323000f, 0.00130735f, 
    -0.00820860f, 0.03298319f, -0.01253858f, 0.01901777f, 0.02755004f, -0.03359719f, -0.02616447f, -0.00678772f, 
    -0.02473743f, 0.00413947f, 0.02191648f, -0.01942889f, 0.00909490f, -0.02037741f, 0.02158082f, -0.02563297f, 
    0.03630591f, 0.03064546f, -0.01118963f, -0.01708596f, 0.02048856f, -0.00511080f, 0.01646035f, -0.00134881f, 
    0.01452387f, 0.01159768f, 0.00365834f, -0.01688691f, -0.03403880f, -0.02552585f, 0.00303235f, 0.00569501f, 
    0.01487271f, 0.01659934f, 0.01639463f, 0.01966674f, 0.01656628f, -0.01469516f, 0.00479798f, -0.00584124f, 
    0.00743423f, 0.02897449f, -0.00464684f, 0.02501507f, 0.00668431f, 0.01499564f, -0.00456189f, 0.01889888f, 
    0.01797952f, 0.02265017f, -0.02282115f, -0.02342616f, -0.01795226f, -0.00129952f, 0.01222834f, 0.01984716f, 
    -0.03930805f, 0.02765851f, 0.00196454f, 0.00719845f, -0.01353208f, 0.00896849f, 0.02931891f, -0.03166521f, 
    -0.01299858f, -0.01679333f, -0.03332014f, -0.02061346f, -0.04068652f, 0.01065624f, -0.01030593f, -0.03819785f, 
    -0.01990054f, 0.00444870f, 0.03490772f, -0.01187784f, -0.03945394f, -0.01088864f, -0.01606407f, 0.01225282f, 
    -0.01710526f, 0.00832686f, -0.01062758f, -0.03022217f, 0.02141054f, -0.02153021f, 0.01843070f, -0.01939118f, 
    -0.02396005f, 0.01394509f, 0.01004194f, 0.00325067f, -0.00241956f, 0.02350079f, -0.03643266f, -0.01278575f, 
    -0.01454372f, 0.02413738f, -0.01530421f, -0.03153436f, -0.01112952f, 0.00588841f, -0.02077834f, 0.01718330f, 
    -0.02513077f, 0.02630953f, -0.00681973f, -0.01799796f, -0.00967813f, 0.02065261f, 0.01671063f, 0.00387389f, 
    0.03258743f, 0.03536798f, -0.02121731f, -0.01795792f, -0.03802232f, 0.00327916f, -0.01682628f, -0.01017431f, 
    -0.01536581f, 0.01810447f, -0.00766924f, 0.02393026f, 0.03162414f, 0.00453331f, 0.02447554f, -0.02736566f, 
    0.01883680f, -0.02883800f, 0.00270454f, -0.03662764f, -0.00088080f, -0.02670786f, -0.00621674f, 0.02230769f, 
    -0.02854968f, -0.02846767f, -0.00769172f, 0.02995704f, -0.02863619f, -0.01406215f, 0.01207323f, 0.00338130f, 
    -0.00833222f, 0.00932982f, -0.01291462f, -0.01660238f, 0.01395640f, -0.01955250f, -0.02970035f, 0.00249233f, 
    -0.00342091f, -0.00146562f, 0.01882076f, -0.01491504f, 0.01938915f, -0.02928110f, 0.00985288f, -0.04042696f, 
    0.03564190f, -0.00879454f, -0.02467890f, -0.01824445f, 0.02130307f, 0.03825097f, 0.01102488f, -0.00470883f, 
    -0.00897441f, -0.02147833f, 0.01667269f, -0.00291364f, 0.00278466f, -0.00432934f, 0.01703307f, 0.00387586f, 
    0.00355522f, -0.01642163f, -0.01560692f, 0.00419085f, -0.01604440f, 0.02521141f, 0.02967731f, -0.00063139f, 
    -0.00063132f, -0.02450489f, -0.00073426f, -0.03125240f, -0.00384659f, 0.00650084f, 0.01654877f, -0.02670340f, 
    -0.03344798f, 0.03241099f, -0.03382253f, 0.00215627f, 0.00639863f, -0.02536659f, -0.00268387f, -0.02047706f, 
    0.02663597f, 0.01891411f, 0.00014121f, -0.01370195f, 0.01906916f, 0.01086951f, 0.00662742f, -0.01862597f, 
    -0.02628750f, -0.03668392f, -0.03633096f, 0.00447739f, -0.03544448f, -0.00991959f, -0.02842358f, -0.01944257f, 
    0.03518129f, -0.00227385f, -0.01681355f, 0.01778573f, -0.01458581f, 0.01705811f, -0.03128313f, 0.01268512f, 
    0.01648377f, -0.02627994f, 0.01474100f, -0.04002840f, 0.00735152f, 0.00004514f, -0.02726560f, 0.02262429f, 
    0.02804316f, -0.02585102f, 0.01107638f, 0.00189224f, -0.00122302f, 0.01356069f, 0.02016008f, 0.01701011f, 
    0.02288109f, 0.02200486f, -0.03417187f, -0.03971215f, -0.02113732f, -0.03908420f, 0.01315244f, -0.00768200f, 
    -0.02946498f, 0.02047484f, -0.00087486f, -0.00555766f, -0.02035929f, -0.01972340f, -0.01354031f, -0.00135662f, 
    0.01630655f, -0.03564380f, 0.00279638f, -0.01350869f, -0.01689288f, -0.02842821f, -0.02081860f, 0.02758377f, 
    -0.01384043f, -0.01034622f, 0.02267114f, 0.00973851f, -0.01357765f, 0.02097715f, -0.01183979f, -0.02857953f, 
    -0.00276104f, -0.00901417f, 0.01104460f, 0.00921985f, -0.02903596f, 0.01047770f, 0.00056576f, -0.02225992f, 
    -0.03124588f, 0.03165016f, -0.01933457f, -0.01891161f, 0.01089925f, 0.00402185f, -0.03128370f, 0.01921323f, 
    -0.03612222f, -0.03063603f, 0.01300750f, -0.01425975f, -0.03192375f, 0.02164373f, -0.01030936f, -0.03565763f, 
    -0.01038417f, 0.00518833f, 0.01608188f, 0.02675422f, 0.03563918f, -0.00167347f, -0.00685248f, 0.01763894f, 
    -0.03129113f, -0.00160602f, 0.00345973f, 0.01124282f, -0.03458093f, -0.02083527f, 0.00779545f, 0.02305221f, 
    -0.03361358f, 0.01466093f, -0.01760943f, -0.00634824f, -0.02515628f, 0.00672296f, -0.03212187f, -0.02136599f, 
    0.02542912f, -0.00098151f, -0.00927343f, -0.01303116f, -0.01036569f, 0.00414016f, 0.03357527f, -0.03206071f, 
    -0.00995360f, 0.02645304f, -0.02187872f, 0.01050160f, 0.02910399f, 0.02994537f, -0.02638920f, 0.02773281f, 
    -0.00133398f, 0.01209265f, 0.00647685f, -0.02499875f, -0.01637231f, 0.00906660f, 0.00755492f, -0.02729779f, 
    -0.02429326f, 0.02458654f, 0.01735982f, -0.00333239f, 0.03215308f, -0.00468344f, -0.00147839f, -0.02834520f, 
    0.02338021f, -0.02396701f, 0.00580200f, -0.02073083f, -0.02715592f, -0.04105870f, 0.01649196f, -0.00982719f, 
    -0.03827249f, -0.00974189f, -0.01273179f, -0.02177452f, 0.01716017f, 0.01362316f, 0.01465445f, -0.01622118f, 
    0.02481709f, 0.02019665f, -0.02621447f, -0.01294355f, 0.01200100f, -0.00731583f, -0.00092099f, -0.03213455f, 
    -0.00971446f, -0.00266311f, 0.01228773f, 0.03474783f, -0.03237046f, -0.03770837f, -0.04632463f, 0.02346914f, 
    0.02272025f, -0.00893752f, 0.02355992f, 0.00274231f, -0.00920302f, -0.01808906f, -0.03383590f, -0.00419556f, 
    -0.00437627f, -0.02469496f, -0.02298007f, 0.02530954f, 0.01067316f, -0.00783142f, -0.02060670f, 0.01803402f, 
    0.01619586f, -0.01597479f, -0.02791778f, -0.02744118f, 0.00531511f, 0.02124737f, 0.01269369f, 0.02268020f, 
    -0.00790570f, 0.02804257f, 0.02706114f, -0.01150654f, -0.00453775f, -0.01625316f, -0.04123609f, -0.01445720f, 
    0.00693339f, 0.24670872f, 0.11367884f, 0.12593885f, -0.12848938f, -0.12029452f, -0.09824420f, -0.04362548f, 
    0.14045525f, 0.16242222f, 0.22343178f, 0.24013355f, -0.31237045f, 0.18410788f, -0.24903993f, -0.06927442f, 
    0.10599983f, 0.08929306f, -0.00301378f, 0.21807969f, -0.08397039f, -0.02549733f, -0.02992089f, -0.03999524f, 
    0.02683802f, -0.13625485f, 0.19986548f, -0.05232990f, 0.01059932f, -0.15176839f, 0.07417474f, 0.12504078f, 
    -0.11986329f, 0.11920445f, 0.00773286f, -0.01829673f, -0.04283634f, 0.20274402f, -0.45067638f, 0.46652982f, 
    0.06712049f, 0.11454958f, 0.06564761f, -0.00834138f, 0.04215475f, 0.16712524f, 0.23645562f, 0.01458318f, 
    -0.17958917f, -0.21356261f, 0.14677455f, -0.00726321f, -0.02706196f, -0.07445093f, -0.00230558f, 0.02262297f, 
    -0.03831301f, 0.03728703f, 0.06209162f, 0.03325158f, -0.14981645f, -0.16212648f, -0.33960295f, 0.10938872f, 
    0.08502958f, 0.00930786f, 0.06027710f, -0.15049796f, -0.04530124f, 0.05496411f, -0.12067118f, 0.03387155f, 
    0.20443647f, -0.02734271f, 0.05916899f, 0.01013629f, 0.10400239f, 0.09307097f, -0.05318655f, 0.04969367f, 
    -0.07059194f, 0.09870476f, -0.00793245f, 0.02043830f, 0.05521752f, 0.10844745f, -0.17332909f, -0.03744039f, 
    -0.08993503f, 0.06337878f, 0.03126114f, 0.10481185f, -0.02175765f, 0.06170259f, 0.00193976f, -0.01553000f, 
    -0.04444993f, -0.22239283f, 0.02684978f, 0.06005235f, -0.01509183f, -0.04857409f, 0.15468314f, 0.07398766f, 
    -0.19402532f, -0.08357918f, 0.10331263f, -0.01068067f, -0.05650059f, 0.06578471f, 0.13160782f, 0.11823431f, 
    -0.02679962f, -0.02567401f, -0.04841643f, -0.04858678f, 0.32159370f, 0.12360134f, 0.20465674f, -0.10990126f, 
    0.06761665f, 0.02549149f, 0.12569299f, 0.06737464f, -0.09287085f, -0.02509489f, -0.01626941f, -0.06510799f, 
    -0.02919970f, -0.01508306f, -0.08036288f, 0.05664941f, 0.17619540f, -0.10355449f, 0.11293238f, 0.15069295f, 
    -0.03751176f, -0.07012153f, 0.02613531f, 0.03934544f, 0.07299938f, 0.11178491f, 0.04254314f, 0.05514379f, 
    0.01714148f, 0.07204048f, 0.07807961f, -0.09977651f, -0.06387915f, 0.03764829f, 0.00355635f, 0.02204919f, 
    -0.17998412f, 0.09364422f, 0.17195316f, -0.03335262f, 0.18465275f, 0.41756982f, -0.12696551f, -0.21265325f, 
    -0.09608907f, 0.10631332f, 0.03491870f, 0.10864546f, -0.09402836f, 0.04047419f, -0.03160193f, -0.03750389f, 
    0.02636423f, 0.23183908f, 0.08926476f, -0.20298080f, 0.08584369f, -0.06190151f, -0.08553709f, 0.33712822f, 
    -0.04817273f, 0.25151858f, 0.03062687f, 0.06700600f, -0.11590249f, -0.13994113f, -0.18109003f, 0.18416496f, 
    -0.13193421f, -0.03895227f, -0.02515254f, -0.11377213f, -0.15810370f, 0.06239002f, 0.01569018f, 0.03375679f, 
    -0.16828093f, -0.17215389f, -0.04974402f, 0.18851097f, -0.07466497f, 0.11200809f, -0.07061262f, 0.06236653f, 
    -0.07350381f, 0.02729140f, 0.01680220f, -0.03302757f, 0.22337845f, -0.05418085f, 0.23160410f, 0.06023257f, 
    -0.14287741f, 0.01111856f, -0.00260001f, -0.02990352f, -0.08327415f, -0.23504898f, -0.03674658f, -0.10074350f, 
    -0.40268052f, -0.35084558f, -0.27584380f, 0.03870770f, -0.00261436f, 0.05705573f, 0.07846852f, 0.08884391f, 
    0.07038722f, -0.18380316f, 0.03539965f, 0.11938617f, 0.17992415f, -0.08053149f, 0.00527722f, 0.19035751f, 
    0.18325420f, 0.17734908f, -0.03573304f, -0.23122990f, 0.12755358f, -0.02267328f, -0.21921770f, 0.05058162f, 
    0.07245775f, -0.03320181f, 0.11732782f, 0.15202275f, -0.15458241f, -0.29733267f, 0.09872005f, -0.08666600f, 
    0.06937398f, 0.02134554f, -0.14160894f, -0.11758706f, 0.13211070f, 0.29748726f, 0.04469311f, -0.15508066f, 
    0.01082077f, -0.07211088f, -0.06265114f, -0.08712599f, -0.13482650f, -0.00858887f, -0.04905294f, -0.21845528f, 
    -0.09753703f, 0.02537488f, 0.05971266f, -0.05314786f, 0.00148218f, 0.18279788f, 0.13184404f, -0.01561072f, 
    -0.10135627f, 0.05725916f, 0.08489048f, 0.11024964f, -0.15707004f, -0.03912372f, 0.00099533f, -0.01090736f, 
    -0.13504525f, -0.00463322f, 0.13200887f, -0.08993631f, -0.28863820f, 0.06291198f, -0.06745610f, -0.06727015f, 
    0.05460891f, -0.13845395f, -0.03332923f, 0.02851460f, -0.00709328f, 0.03214299f, 0.00754612f, -0.06287592f, 
    0.00067331f, -0.17421490f, -0.05973102f, 0.06859626f, -0.11315774f, 0.02517697f, -0.05958614f, -0.22614025f, 
    -0.05363641f, 0.07052760f, 0.02951746f, -0.09611899f, 0.21686210f, 0.10950251f, -0.01293375f, 0.09072624f, 
    -0.20378353f, 0.07259789f, -0.13407832f, -0.05973937f, 0.09969725f, 0.37636375f, -0.01307079f, 0.07911197f, 
    0.21819292f, 0.02653032f, 0.21844806f, -0.10763785f, -0.14249068f, -0.05190571f, -0.14519927f, 0.06684472f, 
    0.10923407f, -0.20266712f, 0.10116632f, 0.27786681f, -0.00522274f, 0.11588609f, 0.35868204f, 0.03827905f, 
    0.06170814f, -0.30793458f, -0.11092093f, -0.23499635f, -0.00333427f, 0.00940755f, 0.04212954f, 0.08184604f, 
    -0.11966745f, -0.08852811f, -0.16096886f, 0.09276613f, 0.02888441f, -0.09850851f, 0.02434352f, 0.16921674f, 
    0.10171443f, 0.07071035f, 0.13522677f, 0.15365441f, -0.10949142f, -0.09142617f, -0.03580135f, -0.02760145f, 
    0.10950200f, 0.15803914f, 0.08783878f, 0.04165737f, 0.03496906f, 0.13498345f, 0.10171322f, -0.07276903f, 
    -0.12825967f, 0.14952610f, 0.13312203f, 0.10679000f, 0.02616990f, -0.00066274f, -0.01428945f, -0.06364667f, 
    0.01359561f, -0.07633368f, 0.09810253f, 0.02779846f, -0.22057500f, -0.09833250f, 0.08986817f, 0.07088223f, 
    -0.09146876f, 0.05325717f, 0.14581433f, -0.04430049f, -0.00510851f, -0.21025376f, 0.04047208f, 0.04614783f, 
    -0.15241887f, 0.07161290f, -0.00930712f, 0.10834333f, 0.10083493f, 0.00761816f, 0.29734045f, -0.03780988f, 
    -0.11090049f, -0.15624182f, 0.02668450f, -0.02244298f, -0.10059929f, 0.09337813f, 0.05552937f, 0.10966802f, 
    0.37163028f, -0.22014938f, 0.17242895f, -0.25273794f, -0.23814589f, -0.12910798f, 0.02901736f, -0.01654315f, 
    -0.17134446f, 0.02546582f, 0.05982736f, -0.01823219f, -0.08640853f, -0.15137573f, -0.04158269f, 0.01884611f, 
    -0.09729879f, 0.02915957f, -0.05932059f, -0.12618291f, 0.03460301f, 0.02855655f, -0.10903478f, -0.11853690f, 
    -0.31035048f, 0.02897148f, -0.13560686f, -0.10629005f, -0.01046903f, 0.34775382f, -0.04701218f, -0.12590496f, 
    0.10512506f, 0.15976110f, -0.05978731f, 0.12509012f, -0.00847398f, -0.03988003f, 0.02812175f, 0.05501106f, 
    -0.08617166f, 0.10158098f, 0.09067737f, -0.09494181f, 0.29416677f, -0.13518667f, -0.02143485f, 0.08075582f, 
    0.01024375f, -0.28842032f, 0.16531077f, 0.21719658f, 0.25798863f, -0.19273476f, 0.27083361f, 0.18606706f, 
    0.03970660f, 0.01068965f, -0.02274301f, -0.17698659f, 0.23491487f, 0.15830241f, -0.32907763f, 0.17799529f, 
    -0.02401170f, 0.12173859f, 0.23872688f, -0.31237459f, 0.10777641f, -0.04649820f, -0.15986429f, 0.07849332f, 
    -0.09008865f, -0.00281526f, -0.03667428f, -0.01015941f, 0.05507951f, -0.01481203f, -0.03759238f, 0.12089646f, 
    -0.26535127f, 0.00256449f, 0.05938238f, -0.08178145f, 0.10794429f, 0.12860309f, 0.10183962f, 0.04406879f, 
    -0.08457749f, -0.00861218f, -0.04080253f, -0.03178466f, -0.01188566f, 0.03569386f, 0.05401252f, 0.07336713f, 
    0.30552667f, 0.00876831f, 0.22081597f, 0.07485089f, 0.00756128f, 0.02117814f, -0.00390316f, -0.03143645f, 
    0.20949860f, -0.09980570f, -0.02324699f, 0.04825277f, -0.09294920f, 0.33783296f, 0.02658760f, -0.32631120f, 
    -0.11974571f, -0.13882545f, -0.20096257f, 0.05249221f, -0.01504396f, 0.01907454f, 0.01470476f, 0.02623702f, 
    -0.05550831f, -0.11526706f, 0.31237638f, -0.24902520f, -0.01449268f, -0.01749810f, 0.17789952f, -0.09450136f, 
    0.14033227f, 0.07880268f, 0.10190144f, -0.00387855f, -0.20772022f, 0.03186832f, 0.10428705f, -0.05251481f, 
    0.05771799f, 0.02735736f, -0.05242205f, -0.03363150f, 0.17409094f, -0.13128091f, 0.14768134f, 0.07197049f, 
    -0.12882160f, -0.01076593f, 0.04996054f, 0.04131596f, -0.03515581f, -0.16215204f, -0.08560567f, -0.12107749f, 
    -0.13635923f, -0.06038069f, 0.03245265f, 0.00877396f, -0.31792971f, 0.31602931f, 0.28833601f, -0.28748628f, 
    0.06744583f, -0.13971047f, -0.15412524f, 0.07323527f, -0.06896383f, -0.06282198f, -0.00711076f, 0.06253062f, 
    -0.26254356f, -0.17077604f, -0.09601591f, 0.11298879f, 0.03590768f, 0.06830026f, -0.03127055f, 0.21790650f, 
    -0.05255064f, 0.03858973f, -0.09055529f, 0.02521016f, -0.01272006f, -0.07726100f, 0.08173879f, -0.05026159f, 
    0.04077843f, 0.09085640f, 0.08451397f, 0.00349695f, 0.01740289f, -0.04223957f, -0.04820118f, 0.12245151f, 
    0.15939306f, 0.01555458f, -0.13160540f, -0.06155964f, -0.02369526f, 0.02059956f, 0.03923781f, 0.10675429f, 
    0.05266490f, 0.19754168f, 0.07661326f, -0.20153370f, 0.11138175f, -0.34005094f, -0.12276104f, 0.17504184f, 
    0.13879065f, 0.09053290f, 0.22129358f, 0.13634893f, 0.13967140f, -0.04637726f, 0.20435224f, 0.21695273f, 
    -0.02667989f, 0.04086951f, -0.05439591f, 0.09592726f, -0.01280004f, -0.03560921f, 0.06247919f, -0.12040702f, 
    0.26374364f, -0.05009948f, -0.05854444f, -0.00151695f, 0.22624432f, 0.14132825f, 0.30622724f, -0.09046776f, 
    0.03000890f, 0.07764237f, -0.07407683f, 0.06754014f, 0.04093465f, 0.15966368f, 0.00735939f, 0.08103241f, 
    -0.03077236f, 0.20144325f, 0.13116762f, 0.27297983f, -0.07614779f, 0.10547716f, 0.25511220f, -0.01769826f, 
    -0.07617456f, 0.07872333f, -0.08291630f, -0.17870659f, -0.03966852f, 0.07245762f, 0.17653066f, -0.11804732f, 
    0.15581304f, 0.07725221f, -0.02975441f, 0.09881743f, 0.14366768f, 0.32192668f, -0.05619005f, 0.07182609f, 
    0.09896120f, -0.09379925f, 0.06266499f, -0.00350906f, 0.16855940f, 0.08514313f, -0.19223273f, -0.12291280f, 
    -0.07986642f, -0.05982096f, -0.42731401f, 0.09042687f, 0.15163043f, 0.20297171f, 0.04290280f, -0.07347026f, 
    -0.06719615f, -0.07047679f, 0.05037344f, -0.01970707f, -0.03186368f, 0.02477072f, 0.04142189f, -0.07731457f, 
    0.06217877f, 0.39642984f, -0.11459465f, -0.07676124f, -0.01019554f, -0.19035180f, 0.05279245f, -0.06689678f, 
    0.01945100f, 0.00805721f, 0.10537183f, -0.06022619f, 0.19922373f, 0.14036301f, 0.18725768f, 0.22666228f, 
    0.03790058f, 0.09245689f, -0.09739641f, 0.09665918f, -0.08224439f, 0.01714004f, -0.19246563f, -0.23693408f, 
    0.48917335f, -0.03156771f, 0.06754072f, 0.02830347f, -0.09209154f, 0.03205576f, -0.05503847f, -0.06751626f, 
    0.09970111f, 0.05429413f, -0.07435057f, 0.03813022f, 0.15741415f, -0.05361969f, 0.17774248f, -0.15010084f, 
    -0.11626605f, -0.10144476f, 0.07595947f, 0.32938614f, -0.01576462f, 0.14956801f, 0.05800449f, 0.08554180f, 
    -0.00468539f, -0.15482126f, -0.17176242f, -0.23126575f, -0.05284452f, 0.03804354f, -0.00538524f, -0.06261981f, 
    0.02368991f, -0.06241689f, -0.02693517f, 0.09094758f, -0.00551262f, 0.05024624f, 0.04075331f, 0.01716947f, 
    -0.04137434f, 0.00876653f, -0.19845861f, -0.06387292f, -0.24315062f, -0.11563096f, -0.00997129f, 0.02168146f, 
    -0.06142065f, 0.11711205f, 0.12111799f, 0.02271716f, -0.18439810f, -0.07670327f, -0.20868973f, -0.15157519f, 
    -0.17473106f, 0.08162276f, -0.07588230f, 0.00392378f, 0.04597342f, 0.16456103f, -0.17267412f, -0.18816854f, 
    0.00150927f, 0.06508758f, 0.04406884f, 0.13655609f, -0.08872354f, -0.00334204f, -0.01531854f, -0.14923449f, 
    0.08617278f, -0.13546397f, 0.21297236f, -0.03050829f, -0.13878135f, -0.09273749f, -0.03415561f, 0.02405723f, 
    -0.09501091f, 0.25574827f, -0.07432941f, 0.02141945f, -0.12414598f, 0.38640034f, -0.10395449f, 0.40544984f, 
    -0.03115274f, -0.02581596f, 0.20152836f, 0.02181107f, -0.02917109f, 0.01560569f, 0.02260919f, -0.08281515f, 
    -0.01732386f, 0.04545821f, -0.22529407f, -0.00021825f, 0.09703457f, -0.05852910f, -0.04049408f, -0.05930734f, 
    0.04426711f, 0.00071892f, 0.10469902f, -0.00645212f, 0.05438830f, 0.06145194f, -0.47744232f, 0.01397313f, 
    0.08866645f, 0.03049191f, 0.12010199f, -0.06958539f, -0.11759312f, 0.06583482f, -0.05076006f, -0.05471253f, 
    0.35218552f, -0.11793272f, 0.23260321f, -0.06764386f, 0.00121242f, 0.00482589f, -0.09156425f, 0.23478925f, 
    -0.05584283f, 0.17842868f, 0.05260377f, 0.04305862f, -0.02927594f, 0.05579039f, 0.03513307f, 0.04003415f, 
    0.04783362f, 0.09723631f, 0.06512504f, 0.05909206f, -0.04789416f, 0.00252887f, -0.01226925f, -0.03782544f, 
    -0.25830227f, -0.04299497f, -0.32701325f, -0.03585177f, 0.00115093f, -0.02381127f, 0.06699329f, 0.01627381f, 
    -0.17840259f, 0.02972779f, 0.01423670f, -0.01815695f, -0.03038431f, -0.12238080f, 0.19043593f, 0.26357061f, 
    0.09149701f, -0.17444576f, -0.16005050f, -0.12186999f, 0.07797882f, -0.10103179f, 0.19006950f, -0.13156913f, 
    -0.16884136f, 0.06361401f, 0.10062746f, 0.20055999f, -0.15010424f, 0.04796412f, -0.11617393f, -0.15282562f, 
    -0.06058086f, -0.02601758f, -0.03262253f, 0.09480653f, 0.20812328f, 0.03104608f, -0.00830381f, 0.16324653f, 
    0.06586521f, 0.01725387f, 0.11790769f, -0.02753885f, -0.09497050f, 0.20405582f, -0.00900930f, 0.03410942f, 
    0.03233327f, 0.12044565f, 0.16992998f, -0.08146624f, -0.15813670f, -0.00210154f, 0.01902402f, -0.02865188f, 
    -0.11058686f, 0.23622902f, 0.11710333f, 0.10424009f, -0.26891768f, 0.49158418f, 0.03392186f, -0.20306417f, 
    0.18249060f, -0.02183654f, -0.13464935f, 0.05224425f, -0.10372361f, 0.05506796f, 0.07451154f, -0.01726166f, 
    -0.19528790f, 0.00187627f, -0.20237349f, 0.38334468f, -0.01235425f, -0.00758418f, 0.20318133f, -0.01116818f, 
    -0.09740004f, 0.16036978f, -0.05911325f, 0.12103611f, -0.06074510f, -0.09473540f, -0.23410161f, -0.12751482f, 
    0.03723126f, 0.02984764f, 0.00970350f, -0.08492463f, -0.00328043f, 0.08450121f, 0.11746866f, -0.00838972f, 
    0.11440345f, -0.06181182f, -0.12601988f, -0.14638700f, -0.02348907f, 0.04948311f, 0.04954664f, 0.02836667f, 
    -0.13959847f, -0.03881659f, 0.05691455f, -0.06774221f, 0.04599875f, 0.01364973f, -0.01031520f, 0.06955805f, 
    -0.03736116f, 0.05808649f, -0.11293512f, -0.07008981f, -0.08172528f, -0.22411311f, -0.00769927f, 0.10209242f, 
    -0.06573321f, 0.00226945f, -0.30184215f, -0.15124793f, 0.06772880f, -0.00781521f, 0.09847219f, 0.11368104f, 
    -0.03979758f, 0.24799058f, -0.10145979f, 0.13365692f, 0.06474999f, 0.17896716f, 0.14167553f, 0.17133762f, 
    0.02650570f, 0.09183051f, 0.02668904f, -0.07960568f, 0.05540625f, 0.07684173f, -0.12617385f, -0.12394819f, 
    0.15578397f, 0.04245868f, -0.29943845f, 0.25675473f, 0.20788427f, -0.04610928f, 0.02908462f, -0.08102998f, 
    0.08994129f, 0.09089659f, -0.09843995f, -0.03475052f, 0.24306361f, 0.15986712f, 0.09729423f, 0.02531931f, 
    0.22470051f, 0.10980621f, -0.02685466f, 0.04565885f, 0.04580355f, 0.05406724f, 0.11047975f, -0.08130137f, 
    -0.11969874f, 0.04115095f, -0.01395791f, 0.01393414f, 0.04186989f, 0.11866798f, 0.16298553f, -0.03291919f, 
    0.04752549f, 0.19964272f, 0.10560525f, 0.18747437f, -0.13388583f, -0.12344562f, -0.19497496f, -0.02018966f, 
    0.06107945f, 0.09265720f, 0.16387884f, 0.03203886f, -0.14137580f, 0.10105681f, -0.01191703f, -0.02048338f, 
    0.19806196f, -0.05981035f, -0.25544989f, 0.20404479f, 0.00456200f, 0.02374374f, 0.04264025f, -0.02168745f, 
    -0.08270047f, 0.05423398f, -0.02932383f, -0.00771355f, -0.18496516f, 0.00478094f, 0.31535894f, -0.04440903f, 
    -0.00671117f, 0.07357291f, 0.02887474f, 0.03837173f, 0.00774413f, -0.09048602f, 0.05667734f, 0.22799812f, 
    -0.13039297f, 0.10195416f, 0.03966641f, -0.34707984f, 0.00397124f, 0.08202606f, 0.02934906f, 0.07475555f, 
    0.10436329f, -0.02117961f, -0.11836489f, -0.02715344f, -0.10413290f, 0.15307888f, -0.51429367f, -0.03777548f, 
    -0.00069075f, -0.03218947f, 0.01554705f, -0.10683528f, -0.00094994f, -0.00904437f, 0.25800002f, 0.03427063f, 
    0.06595328f, -0.41832966f, -0.08280383f, -0.11314900f, -0.06337888f, 0.04876442f, -0.06265675f, 0.07452379f, 
    -0.08914427f, -0.04768064f, -0.10447459f, 0.07386729f, 0.20284142f, -0.11561879f, -0.20125164f, -0.01592702f, 
    0.06858429f, 0.07193055f, 0.05181724f, 0.03770224f, -0.06248156f, -0.08769920f, -0.06800669f, -0.05288739f, 
    -0.03694575f, 0.33449730f, 0.02877467f, -0.03122298f, 0.08929344f, 0.00241887f, 0.07473751f, -0.04089481f, 
    0.00801983f, 0.01735749f, 0.07258749f, 0.08862697f, -0.15771274f, -0.09813984f, -0.11241866f, -0.04431878f, 
    -0.18542679f, -0.11947371f, -0.12014800f, -0.21544856f, -0.17505105f, -0.02643008f, -0.05328207f, 0.02078530f, 
    -0.12603933f, -0.11918168f, 0.03306172f, 0.12879647f, -0.14404733f, -0.13608798f, 0.04051399f, -0.00506840f, 
    -0.06005580f, 0.19001015f, -0.15951417f, 0.15077814f, -0.20571141f, 0.17834999f, 0.29546764f, 0.00925525f, 
    -0.24418420f, -0.13431327f, -0.15077835f, -0.07278807f, -0.21532762f, 0.05482702f, -0.10634233f, -0.00657609f, 
    0.28618017f, -0.70366633f, 0.46248373f, -0.31369311f, -0.16945122f, -0.02962976f, -0.04104245f, -0.04436841f, 
    -0.06907158f, 0.14196350f, 0.04810654f, -0.03170585f, 0.08811411f, -0.09166192f, -0.12614462f, 0.25408715f, 
    0.07508422f, 0.00345700f, 0.00347008f, -0.09734270f, -0.05629987f, 0.16175920f, -0.02044966f, -0.12715900f, 
    -0.11217859f, 0.13800271f, 0.01316608f, 0.09905823f, -0.02493809f, 0.04660234f, -0.06828085f, -0.06794834f, 
    0.01398470f, 0.05526008f, -0.10387960f, 0.13570076f, 0.20520806f, 0.22425875f, -0.03601030f, 0.00296717f, 
    0.18971711f, 0.09797160f, -0.00827217f, -0.04587865f, 0.03436187f, 0.01614239f, 0.09946419f, 0.09668620f, 
    0.17173870f, 0.02696808f, -0.37704632f, 0.20740023f, 0.12144149f, 0.02895082f, 0.16797692f, -0.05509999f, 
    0.06450057f, -0.14248449f, -0.02831316f, -0.03310193f, 0.15209779f, -0.01933464f, -0.06729102f, 0.39676285f, 
    -0.00631112f, 0.12429091f, -0.04102728f, 0.03532773f, 0.04502469f, 0.08355967f, -0.07927042f, -0.05478774f, 
    -0.27919632f, 0.10043029f, -0.10688874f, -0.15629308f, 0.05046483f, 0.03088348f, -0.07365926f, -0.02797686f, 
    -0.11294101f, 0.00818202f, 0.05585996f, 0.03919219f, -0.09453531f, 0.02599257f, 0.12816945f, 0.27049106f, 
    -0.07530176f, -0.02560084f, -0.00625040f, -0.12763636f, -0.01226261f, 0.01189355f, 0.15463185f, 0.06360180f, 
    0.02933211f, 0.57591504f, 0.07339212f, 0.31237125f, 0.09175587f, 0.05743252f, -0.06192331f, -0.05688232f, 
    0.03799022f, 0.06978331f, 0.12097136f, 0.13064416f, -0.42193776f, 0.11264919f, 0.01355694f, -0.01238308f, 
    -0.13058358f, -0.11604572f, -0.09349012f, -0.13176431f, -0.02043501f, -0.06938427f, -0.06729287f, 0.02483044f, 
    -0.16536634f, -0.36960605f, 0.23942745f, -0.01627712f, 0.08512627f, 0.09821403f, -0.03193114f, -0.02225799f, 
    0.13018936f, 0.03659321f, 0.08648796f, 0.25694719f, -0.35757536f, 0.13878694f, -0.04519922f, 0.13056913f, 
    -0.02427884f, -0.03306355f, -0.19925673f, -0.07250734f, -0.29563794f, -0.15033418f, -0.17823389f, -0.12852454f, 
    -0.04975916f, -0.06621232f, -0.17051184f, -0.15196601f, -0.02195078f, -0.05908354f, 0.03619276f, -0.05321135f, 
    -0.05377312f, -0.02445041f, 0.07408138f, 0.10830835f, -0.52824819f, 0.22973700f, 0.03914773f, 0.24285921f, 
    0.06765113f, 0.03614850f, -0.02910842f, -0.05862815f, -0.17418022f, 0.12350418f, -0.12622498f, 0.14359464f, 
    0.00515249f, -0.11524182f, -0.24190725f, -0.26857448f, 0.05944141f, 0.10971421f, 0.02075784f, 0.17660281f, 
    -0.10000912f, 0.03557201f, -0.04710118f, -0.07029738f, -0.08002713f, -0.18282227f, -0.15945616f, 0.05496662f, 
    -0.12602240f, -0.13046737f, 0.11267318f, 0.04178127f, -0.02639500f, 0.16100438f, -0.00050687f, 0.19633475f, 
    0.17390242f, 0.17447847f, -0.17214717f, 0.25888723f, 0.12361241f, 0.04484316f, 0.02786382f, 0.12138515f, 
    0.08038673f, -0.02897484f, 0.12658143f, -0.01017549f, 0.38017303f, -0.25785404f, 0.28381893f, 0.02682725f, 
    -0.15973043f, 0.05802660f, 0.21361211f, 0.17681107f, 0.00338080f, 0.07988068f, 0.21024695f, 0.21155189f, 
    -0.09140500f, 0.17321074f, -0.22801393f, 0.04473740f, 0.00990568f, -0.03968140f, 0.08216351f, -0.03112607f, 
    0.06632196f, 0.01149515f, -0.01443298f, 0.03218101f, 0.09036767f, 0.17204423f, 0.21745434f, 0.04298814f, 
    0.02370534f, 0.01077714f, -0.02370141f, -0.00595692f, -0.08545551f, 0.18561821f, -0.00720440f, 0.00983649f, 
    0.29531845f, -0.03827617f, 0.08048173f, 0.20442192f, -0.09155001f, 0.13815778f, 0.05067312f, -0.08577700f, 
    0.05916667f, 0.05206947f, 0.03798438f, -0.09415253f, -0.07286480f, 0.00029647f, 0.18646446f, 0.21581723f, 
    -0.10822412f, 0.01697705f, -0.05456176f, 0.04163167f, -0.03080803f, 0.04488022f, 0.00896126f, 0.13759595f, 
    0.23125531f, -0.00992207f, 0.07705007f, -0.03947757f, 0.11917336f, 0.08553423f, -0.14906244f, 0.07387605f, 
    -0.03248797f, 0.12018327f, -0.12220497f, -0.03405469f, -0.01767049f, 0.12268902f, -0.03079852f, 0.16509406f, 
    -0.12735148f, -0.05902335f, 0.02427323f, 0.00608610f, -0.03879634f, 0.04697595f, -0.06864826f, -0.09905007f, 
    -0.11286353f, 0.19338083f, -0.12033846f, 0.26742896f, -0.13980830f, 0.01102088f, 0.06585029f, -0.14088653f, 
    0.05767209f, -0.06299642f, 0.00563039f, 0.11594036f, 0.37797499f, 0.04313870f, 0.01432399f, 0.07022498f, 
    0.04573539f, 0.16173846f, 0.03774539f, -0.00445228f, -0.08008777f, 0.09903725f, -0.10220305f, -0.16254079f, 
    0.10339945f, -0.00135523f, -0.01016037f, 0.20606554f, 0.02499757f, 0.02297379f, -0.05033704f, 0.07942991f, 
    0.04367321f, 0.17455438f, -0.01636893f, -0.00489927f, 0.14643398f, -0.19675533f, 0.18094425f, 0.08934093f, 
    -0.09163994f, -0.00806682f, -0.04063725f, 0.08849177f, -0.05916482f, 0.11189752f, -0.04009442f, 0.06134030f, 
    0.24262945f, 0.10388157f, -0.11475753f, -0.09020864f, 0.01849959f, -0.01470551f, 0.06735273f, -0.04592934f, 
    -0.05503320f, -0.02432222f, 0.04562183f, -0.03966365f, 0.27331838f, -0.02712502f, 0.08997759f, 0.07815295f, 
    -0.05570723f, 0.16758989f, -0.06474771f, 0.01183255f, -0.06985854f, 0.01949684f, 0.02073788f, -0.00853359f, 
    0.02210665f, -0.02007649f, -0.02745528f, -0.00664842f, -0.01091661f, -0.01767310f, -0.03497799f, -0.03820055f, 
    -0.01749943f, 0.02430789f, -0.01303464f, 0.03387163f, -0.01043009f, 0.02540052f, -0.01110522f, 0.00556227f, 
    -0.01932969f, 0.02904607f, -0.03745743f, 0.00095493f, 0.02930703f, 0.02057808f, -0.03779089f, 0.02064666f, 
    -0.01031109f, -0.03601154f, -0.00977027f, 0.01147872f, -0.00554620f, 0.00104121f, -0.01704840f, 0.01353297f, 
    0.00158397f, 0.00525402f, -0.01715344f, 0.00504681f, -0.01314695f, 0.00121002f, -0.00376715f, 0.01454664f, 
    -0.00533504f, 0.00944806f, 0.00909971f, -0.00493341f, 0.02307553f, -0.01825089f, -0.03800491f, -0.02246786f, 
    0.00152388f, -0.02543415f, -0.03947461f, 0.01678112f, -0.01574430f, 0.00839353f, -0.02387697f, -0.03740805f, 
    -0.03080934f, -0.01349996f, -0.00606599f, -0.03550043f, -0.04204782f, -0.00373447f, -0.02053423f, 0.00025063f, 
    -0.01487708f, -0.02643158f, -0.03419183f, -0.02300246f, -0.01640187f, -0.01102471f, 0.03054675f, 0.01758610f, 
    -0.02923676f, -0.01041752f, 0.02327123f, -0.00184196f, -0.01394796f, 0.00635483f, -0.00113115f, -0.02026935f, 
    0.00991020f, -0.00254100f, -0.03222237f, 0.01948884f, 0.01402743f, 0.01665878f, 0.02096207f, -0.01789201f, 
    0.02614447f, 0.02379937f, -0.00893193f, 0.01644388f, -0.03279535f, -0.00629693f, -0.03341984f, 0.00056169f, 
    0.00456329f, 0.02964006f, -0.02603171f, -0.01249291f, 0.01101172f, -0.00460456f, -0.02205210f, -0.03869988f, 
    0.02831693f, 0.00439659f, -0.03482930f, 0.00225485f, 0.02362013f, 0.00067077f, -0.00826102f, 0.03074189f, 
    -0.03955536f, -0.01349085f, 0.00259286f, 0.01240742f, 0.01342053f, 0.00440165f, -0.02836831f, -0.03164583f, 
    -0.00883222f, -0.03077260f, -0.02578618f, 0.00410367f, -0.01354269f, -0.00801142f, 0.00103592f, 0.02493669f, 
    -0.01175557f, -0.00110661f, 0.02823948f, 0.01248060f, -0.03920859f, -0.02441486f, 0.02216512f, -0.00757843f, 
    0.00926007f, -0.01756307f, 0.00374209f, -0.03773816f, 0.01876569f, 0.01430856f, 0.02421128f, 0.02097241f, 
    0.00038398f, -0.01877164f, -0.00432751f, -0.02462217f, -0.02644158f, -0.02052648f, 0.01968768f, 0.01967500f, 
    0.01571890f, -0.01210946f, -0.02929871f, -0.01734719f, 0.03081482f, 0.00614721f, -0.02714655f, -0.01374396f, 
    0.02269691f, 0.01529076f, -0.00264267f, 0.00398080f, -0.00760085f, 0.02343934f, 0.02021465f, -0.01674156f, 
    0.01672093f, 0.03066467f, 0.00265349f, 0.01407082f, -0.02135707f, 0.01201618f, 0.01409329f, -0.00018585f, 
    -0.02881606f, 0.01766193f, -0.03699870f, -0.02685933f, -0.03273271f, 0.00162327f, -0.02891451f, -0.01438018f, 
    0.00824951f, 0.02963206f, 0.00956277f, -0.01809807f, 0.03176654f, -0.00690339f, -0.00787242f, -0.02875324f, 
    0.02257588f, -0.01955890f, -0.01540879f, 0.00234846f, -0.01455529f, -0.02066221f, -0.02233187f, -0.00491842f, 
    -0.00930720f, 0.02813578f, -0.00087151f, -0.02288874f, -0.00175223f, -0.02019641f, -0.02710159f, -0.00298372f, 
    0.03077959f, -0.00700368f, -0.01282262f, -0.00852980f, -0.00059325f, 0.02019839f, 0.00230036f, 0.01854687f, 
    -0.02959488f, 0.01181994f, 0.00697087f, 0.02337745f, -0.00214328f, -0.01231505f, 0.02126772f, -0.00886641f, 
    -0.02347089f, -0.01031526f, -0.02956600f, 0.00680601f, 0.02310647f, -0.00722987f, 0.02086653f, -0.00062001f, 
    -0.02889008f, 0.00357329f, -0.03706007f, -0.02971355f, -0.00068106f, 0.01870060f, 0.01288945f, 0.02064928f, 
    -0.02392608f, -0.03055393f, 0.02364757f, -0.00796663f, -0.03637343f, -0.01584250f, 0.00518126f, 0.02681141f, 
    -0.01273524f, 0.02076381f, 0.00395513f, 0.01442869f, -0.01034071f, 0.03002592f, -0.01762358f, -0.02035308f, 
    0.00742529f, -0.03759630f, -0.02724049f, 0.00208415f, 0.02410089f, -0.01513237f, 0.00118872f, 0.02292119f, 
    0.01971309f, -0.00588139f, 0.02443883f, -0.01365696f, -0.02600450f, -0.03588402f, 0.02066067f, -0.03545934f, 
    0.00352835f, 0.00928739f, 0.00696674f, -0.01650765f, -0.00664157f, -0.04017885f, -0.00984813f, 0.00244136f, 
    0.02189236f, 0.01311654f, 0.00234291f, 0.02635546f, -0.01492575f, -0.03765356f, -0.03234661f, -0.02949798f, 
    -0.00700448f, -0.02471961f, -0.04606813f, -0.01109054f, -0.03769788f, 0.02289956f, -0.01327846f, -0.03829385f, 
    -0.03480269f, 0.00000496f, 0.01079277f, 0.00426850f, 0.01381232f, -0.00441215f, -0.02926099f, -0.02755280f, 
    0.01413111f, -0.00294146f, 0.01203082f, 0.02632698f, -0.00844215f, 0.02496912f, -0.02510083f, 0.00163882f, 
    -0.02682518f, 0.01353865f, 0.01142932f, 0.00853746f, -0.03558571f, 0.01318036f, -0.00146555f, -0.00524190f, 
    -0.00433894f, 0.02283960f, 0.01860401f, 0.01235553f, 0.01348087f, -0.04099707f, -0.03618215f, 0.00433913f, 
    -0.02891099f, 0.00576517f, -0.03238901f, 0.01717835f, -0.02200716f, -0.02000719f, -0.02500687f, 0.00533087f, 
    -0.01060878f, -0.03505702f, -0.01458529f, 0.01781890f, -0.03488480f, 0.00512926f, 0.00448307f, -0.00226438f, 
    -0.04087327f, 0.01830954f, 0.03154726f, -0.02011126f, -0.00232984f, -0.04351954f, 0.00192528f, -0.01016715f, 
    0.01795916f, -0.01068216f, -0.02429219f, 0.02271158f, 0.03434587f, -0.03547199f, 0.02793804f, -0.02179105f, 
    0.02704816f, 0.02811506f, -0.02446327f, 0.01367924f, -0.02851215f, -0.02833849f, -0.00196996f, 0.00873506f, 
    -0.00482483f, -0.01890159f, -0.03528571f, 0.02310369f, 0.00446317f, -0.04087248f, -0.01338969f, 0.01872750f, 
    0.01726797f, 0.01420303f, 0.00809399f, 0.01479747f, -0.00821874f, -0.00829351f, 0.00143607f, -0.01113737f, 
    0.02669264f, 0.00753063f, 0.01246481f, 0.02051924f, 0.02811196f, -0.01414877f, 0.00046505f, -0.02658970f, 
    -0.03239345f, 0.00923720f, -0.01486867f, -0.00986495f, 0.00353793f, 0.00657982f, -0.01372774f, 0.01121926f, 
    0.00904753f, -0.03497046f, -0.03071711f, 0.03050548f, 0.01138162f, -0.01618303f, -0.02285429f, -0.04125110f, 
    0.01535795f, -0.04491703f, -0.03949311f, -0.02567448f, -0.00442126f, 0.00566856f, -0.04068226f, 0.01152981f, 
    -0.01832172f, 0.02310686f, -0.01109732f, -0.00763733f, -0.01177269f, -0.00974716f, -0.03070754f, 0.02335810f, 
    0.02519359f, 0.02729148f, -0.00725915f, 0.00643594f, -0.02704236f, 0.02505628f, 0.01498942f, -0.04053699f, 
    0.03251180f, -0.02157197f, -0.03387408f, -0.01073036f, 0.03283924f, 0.00060295f, 0.01190948f, 0.00071145f, 
    0.00170612f, -0.03113220f, 0.02172834f, -0.00965204f, 0.01518509f, 0.02864278f, -0.03815376f, -0.01052641f, 
    -0.02655688f, -0.01979371f, 0.02561968f, 0.00884530f, -0.03156001f, -0.03237784f, 0.00803209f, 0.02873341f, 
    -0.00865183f, -0.00412944f, -0.02140348f, -0.01854722f, 0.02666637f, 0.00933894f, 0.01451131f, -0.03124674f, 
    -0.01517439f, 0.00185971f, 0.01613536f, 0.00370500f, -0.03659637f, -0.01513276f, 0.01273869f, -0.03685454f, 
    -0.03403765f, 0.00957373f, -0.04133663f, -0.00598758f, 0.01516400f, 0.00542777f, -0.02420106f, 0.01578552f, 
    -0.03233870f, 0.02030333f, 0.01149469f, 0.01853890f, 0.00679163f, 0.01060148f, 0.01626175f, -0.01442836f, 
    -0.03215815f, -0.04040313f, -0.02795011f, -0.01392917f, -0.00914428f, -0.01022766f, -0.01325769f, 0.00514261f, 
    -0.03811294f, 0.02837085f, -0.04149804f, -0.01571088f, 0.03397136f, 0.02878855f, 0.00897795f, -0.03279635f, 
    -0.03955242f, 0.00871795f, 0.00619771f, -0.01189733f, -0.00752194f, -0.03909918f, -0.00790458f, 0.02840456f, 
    -0.00793706f, 0.00836432f, 0.02339496f, 0.02204704f, 0.02038223f, 0.01083061f, -0.03395628f, 0.01340565f, 
    -0.03869487f, 0.02847782f, 0.00019838f, 0.00457258f, -0.00431321f, -0.00987632f, -0.02203138f, 0.00546749f, 
    -0.02436055f, 0.02505426f, -0.00526520f, -0.00629564f, 0.02182538f, 0.01036305f, 0.00612958f, 0.02696267f, 
    -0.03671366f, 0.02840308f, 0.03137530f, 0.00545878f, 0.01390758f, -0.01194438f, -0.03951054f, 0.00777417f, 
    -0.01508014f, -0.02072009f, -0.00441832f, 0.01433335f, 0.01154539f, -0.01680758f, -0.03684357f, -0.02100501f, 
    -0.04191392f, -0.02943532f, -0.01922881f, 0.01999605f, -0.03075700f, -0.02402324f, -0.02368773f, -0.03033211f, 
    -0.00400391f, -0.01133743f, 0.00020315f, 0.00784231f, 0.02059211f, -0.03807511f, 0.00416026f, -0.00068311f, 
    0.02386658f, -0.03653337f, 0.01211099f, 0.00303636f, -0.02168822f, -0.01848240f, 0.00691026f, -0.02375906f, 
    0.00772544f, -0.01890551f, -0.04118209f, -0.03260279f, 0.01562772f, 0.00748178f, 0.00486284f, -0.02844458f, 
    0.02893116f, -0.03241383f, -0.03913851f, -0.02426368f, -0.03682429f, 0.02387066f, -0.00440278f, 0.01656748f, 
    -0.01945629f, -0.04038304f, 0.00770243f, 0.02623831f, -0.02097585f, -0.03201056f, -0.03712950f, -0.02309199f, 
    -0.01025910f, -0.03253465f, 0.00742131f, -0.01398654f, 0.00315096f, 0.01165429f, -0.03017389f, 0.02354636f, 
    0.02093061f, -0.00538449f, 0.00780579f, -0.00815491f, -0.00347606f, -0.04011442f, -0.02875344f, -0.01051933f, 
    -0.01306095f, -0.00327559f, 0.01264010f, 0.01510445f, 0.01930103f, -0.01740846f, -0.03868390f, -0.02556229f, 
    -0.02452070f, 0.02520336f, 0.01942033f, -0.01931508f, 0.00029600f, 0.01096870f, -0.02253454f, 0.02004747f, 
    -0.03753220f, -0.03292723f, -0.02356567f, -0.01772979f, 0.01120011f, -0.03105838f, 0.00111162f, 0.01053408f, 
    -0.03946786f, 0.00046783f, -0.01381112f, -0.03286144f, 0.00489852f, -0.01581565f, 0.01428252f, 0.00038034f, 
    0.01527802f, -0.01892302f, -0.01203696f, -0.02070996f, -0.02173415f, -0.01098535f, -0.00805528f, 0.00774348f, 
    -0.00960908f, -0.00075096f, -0.01067976f, 0.02753776f, -0.00659308f, 0.00874473f, -0.01133154f, -0.03360784f, 
    0.01122792f, -0.01267360f, -0.00840205f, 0.00673902f, 0.00405805f, 0.00511101f, -0.01167516f, 0.01373650f, 
    -0.03575453f, -0.02783005f, -0.02175365f, 0.02420529f, 0.01699934f, 0.00772749f, -0.00826812f, 0.02403260f, 
    0.02336946f, -0.03302956f, -0.03938208f, -0.02607851f, 0.00375418f, 0.01315229f, 0.00125192f, -0.02522730f, 
    -0.00395872f, -0.03596979f, -0.01903646f, 0.01509740f, -0.02949639f, -0.02790014f, 0.00155841f, 0.01102765f, 
    0.01553395f, 0.01557870f, -0.02496021f, 0.00142991f, -0.01963487f, 0.01991086f, 0.00997253f, 0.02862006f, 
    -0.02346957f, 0.01757648f, 0.01609840f, -0.00780927f, -0.00242906f, -0.00349114f, 0.00560914f, -0.04408337f, 
    0.00010657f, -0.03241033f, 0.01317491f, -0.04447224f, -0.00959173f, -0.03876325f, -0.03050348f, -0.02850784f, 
    0.00852068f, -0.03354133f, 0.02552862f, 0.02555659f, 0.00437903f, -0.01984769f, -0.00943877f, 0.01516667f, 
    0.02359395f, -0.00257188f, -0.01109821f, 0.00627957f, -0.03419894f, -0.02088385f, -0.00703624f, 0.00949404f, 
    -0.03386360f, 0.02512094f, 0.02235655f, -0.03127064f, -0.02158411f, 0.02490959f, 0.00384261f, 0.03004628f, 
    -0.00372508f, 0.01549056f, -0.03035272f, 0.02277594f, -0.04416446f, 0.00071817f, -0.03337052f, -0.01392805f, 
    -0.02637529f, 0.00447785f, 0.00994679f, -0.02333202f, -0.03434404f, -0.00702050f, 0.02049093f, -0.03178505f, 
    -0.02127407f, -0.01550987f, -0.03784626f, -0.03280574f, -0.01567342f, -0.03929024f, 0.00489816f, -0.03694806f, 
    -0.02527526f, -0.01141418f, -0.03531486f, -0.03046221f, 0.00213669f, -0.02721370f, -0.01253836f, 0.02116170f, 
    0.02927796f, 0.02176100f, -0.04003058f, 0.01751723f, -0.02951145f, -0.03058769f, -0.02119547f, 0.02436552f, 
    -0.02281395f, -0.01716474f, 0.00273282f, -0.03884040f, 0.01396925f, 0.01036737f, -0.00955291f, 0.02900782f, 
    -0.00042843f, -0.00337426f, 0.02286525f, 0.02136499f, -0.00936989f, 0.00407925f, 0.00668523f, 0.02302674f, 
    -0.00805105f, -0.01401269f, -0.03654369f, 0.01565078f, -0.00605314f, 0.00912279f, 0.00466695f, 0.02647104f, 
    -0.01005431f, -0.03167800f, -0.01746310f, -0.02353834f, -0.01941884f, 0.01993597f, -0.00632910f, -0.01600751f, 
    -0.02815805f, -0.00284389f, -0.02223779f, -0.00027104f, 0.01306761f, -0.00493831f, -0.02433947f, -0.01378603f, 
    -0.02140588f, 0.02116271f, 0.00441019f, -0.00647718f, 0.00190292f, 0.00503098f, 0.02133102f, -0.02662731f, 
    0.01564413f, 0.00668761f, -0.00973518f, 0.01360632f, 0.00427708f, -0.01102434f, -0.03158124f, 0.02626682f, 
    0.00180796f, -0.01166282f, -0.02072494f, 0.00416858f, 0.01460011f, -0.02142440f, -0.03969085f, 0.02677539f, 
    -0.03449558f, 0.00128411f, 0.01111954f, 0.00211092f, -0.01122735f, 0.01640796f, 0.02777512f, 0.00202639f, 
    -0.03451381f, 0.02346627f, 0.01426438f, -0.02432556f, -0.02073281f, -0.01581508f, -0.02212329f, -0.00726557f, 
    0.01002930f, -0.02506569f, 0.00933286f, 0.00275900f, -0.03148916f, 0.00552888f, 0.01943251f, -0.03755924f, 
    -0.02054241f, -0.00306755f, 0.00817602f, 0.00340154f, -0.01496571f, -0.01113196f, -0.02734420f, -0.03254818f, 
    0.02201678f, -0.03927013f, 0.00081691f, -0.00610183f, -0.01672692f, 0.00232685f, -0.04109296f, 0.00469937f, 
    -0.00625409f, -0.02880310f, 0.02480345f, -0.01284460f, 0.01390400f, -0.00816104f, 0.01013953f, 0.01836181f, 
    -0.00786561f, -0.00970114f, 0.00965689f, 0.02122152f, 0.02038267f, 0.00618693f, -0.02325586f, -0.00046572f, 
    -0.00587062f, -0.01852998f, -0.03459091f, -0.03370987f, -0.02151454f, -0.00365527f, -0.03800563f, 0.00170683f, 
    -0.03796099f, -0.03026627f, -0.03435941f, 0.02123969f, 0.01241945f, 0.00062324f, -0.01424999f, 0.00388271f, 
    0.02593901f, 0.04049834f, 0.00481520f, -0.00116379f, -0.03059741f, 0.01435864f, 0.00470181f, 0.02976241f, 
    -0.00513299f, 0.02103792f, 0.02767159f, 0.00703461f, -0.02495542f, -0.00216528f, 0.02688005f, -0.02749051f, 
    -0.01832156f, -0.03264062f, -0.02737525f, -0.01576076f, -0.03771729f, -0.00533141f, 0.02975371f, -0.01768034f, 
    -0.00360087f, -0.02205293f, 0.01192304f, -0.03403418f, -0.03510009f, 0.02135243f, -0.01201050f, -0.01884965f, 
    0.01010883f, -0.01245531f, -0.01228127f, -0.01973976f, 0.02411418f, -0.02881727f, 0.01945017f, 0.01279536f, 
    -0.01301649f, 0.00889391f, 0.01978270f, 0.00833445f, -0.00914591f, -0.01330039f, -0.02571593f, -0.02543546f, 
    -0.01572669f, -0.02197209f, -0.03183750f, -0.01441367f, -0.02261677f, 0.00666075f, -0.02651088f, 0.01211422f, 
    0.00797094f, -0.00281379f, 0.02824861f, 0.00672835f, -0.02655146f, 0.02800030f, -0.00827485f, 0.01563849f, 
    0.00782310f, -0.02584448f, -0.02659038f, 0.02222836f, 0.01510456f, 0.02686558f, 0.03995429f, -0.02891513f, 
    0.02724116f, -0.01142531f, 0.01673861f, 0.02760445f, -0.04101441f, 0.01301982f, -0.02415134f, -0.01877834f, 
    0.01417398f, -0.00738606f, -0.00261402f, 0.01286581f, -0.00562854f, 0.02237106f, -0.03263488f, 0.02846058f, 
    -0.00624909f, -0.03258348f, -0.02956608f, -0.02833858f, -0.00289158f, -0.01201429f, -0.00573086f, -0.01676688f, 
    0.02332411f, 0.01168615f, -0.03573441f, -0.01941148f, 0.01670588f, -0.02663917f, -0.01741665f, -0.02064788f, 
    0.00482471f, 0.00893967f, -0.02711722f, -0.04073162f, 0.01005647f, -0.00516189f, 0.00565637f, -0.03462198f, 
    -0.01661969f, -0.01443169f, -0.01157547f, -0.00845269f, -0.04019924f, 0.02217180f, 0.00411767f, -0.01154164f, 
    0.00400384f, -0.00428647f, 0.00336841f, 0.00739325f, 0.02257441f, 0.01733428f, 0.01663571f, -0.00935301f, 
    0.00563697f, -0.03051097f, -0.01746760f, -0.03138570f, 0.01370088f, 0.01271191f, -0.03357779f, -0.00532684f, 
    0.00490565f, -0.00707555f, -0.04189628f, 0.00991283f, -0.03686976f, 0.02102594f, -0.02514177f, 0.02122301f, 
    -0.03567553f, -0.02966515f, 0.00516165f, -0.00402431f, 0.01487493f, 0.02959547f, 0.02765361f, 0.01615568f, 
    0.02257290f, 0.00076171f, -0.02718408f, -0.03590943f, -0.02504987f, -0.03980565f, -0.02191230f, 0.01430123f, 
    -0.03121217f, -0.01775636f, 0.00622568f, 0.01590936f, 0.02886877f, 0.01720857f, -0.03734638f, 0.01352372f, 
    0.00696000f, 0.01642961f, -0.01978064f, 0.00246491f, -0.00127861f, -0.03002542f, 0.00485070f, 0.02998832f, 
    0.02496994f, 0.01218483f, -0.03016223f, -0.02067848f, -0.00917783f, 0.02263104f, -0.00422488f, 0.00732782f, 
    -0.00182521f, -0.03328942f, -0.03360133f, -0.01003016f, -0.00692831f, 0.01860823f, 0.02207629f, 0.02256256f, 
    -0.00684852f, -0.01138792f, -0.03449962f, 0.01616123f, 0.02428469f, -0.02241935f, -0.02226093f, -0.01344739f, 
    -0.01694655f, -0.00429922f, 0.01521309f, 0.01996066f, 0.02807430f, -0.01989616f, 0.00380688f, -0.00015290f, 
    -0.04102440f, 0.01666051f, 0.01893551f, -0.02239950f, 0.00828692f, -0.00230507f, 0.00262377f, -0.01100287f, 
    0.01382422f, -0.01874127f, 0.02653217f, 0.02210964f, -0.02191374f, 0.00474796f, -0.03246013f, -0.01120129f, 
    -0.03683564f, 0.01180797f, 0.01508411f, 0.01760337f, -0.03436366f, 0.00384781f, 0.00023405f, -0.00802591f, 
    0.00372293f, 0.02351567f, 0.02494680f, 0.04108936f, -0.00996227f, -0.01977356f, -0.00731837f, -0.03293363f, 
    0.01431601f, -0.04136539f, -0.00361790f, -0.03468519f, 0.01843254f, -0.00416461f, 0.00539668f, 0.02750886f, 
    -0.01459678f, -0.02643235f, 0.02799339f, -0.02071662f, 0.00314711f, -0.03634782f, -0.01034457f, -0.04033328f, 
    0.02020753f, 0.00352627f, -0.00972590f, -0.01873167f, 0.00539558f, 0.01583920f, -0.02679451f, -0.01467214f, 
    0.00979182f, 0.02233513f, -0.01923099f, -0.02381483f, -0.03471845f, -0.04169516f, 0.00704831f, 0.00275284f, 
    -0.04145857f, 0.02985543f, -0.01737611f, 0.02253540f, -0.00203962f, -0.01211678f, -0.00916888f, 0.01349251f, 
    -0.03145216f, 0.00731141f, 0.00949692f, 0.02250149f, -0.00315770f, -0.02436998f, -0.01924419f, -0.01147357f, 
    0.00728603f, 0.00057459f, 0.02345057f, 0.00543953f, 0.00056657f, -0.00205456f, -0.00163653f, -0.00044941f, 
    -0.03255707f, 0.01544576f, 0.00893138f, -0.00119338f, -0.01980014f, 0.01688012f, -0.04103677f, -0.01369480f, 
    0.00688935f, -0.00318588f, -0.00779214f, 0.00856169f, -0.03801091f, 0.01596071f, 0.01891080f, -0.03971315f, 
    -0.02467879f, -0.02381978f, 0.00854385f, -0.00969894f, 0.00146699f, 0.01331436f, 0.01152282f, -0.01015780f, 
    -0.02586855f, -0.01379853f, 0.00697000f, -0.00485082f, -0.01584342f, 0.00685974f, -0.03592650f, -0.01337672f, 
    -0.01390067f, -0.04128446f, -0.01418180f, 0.02260413f, 0.02203857f, -0.01457238f, -0.02304077f, 0.01310013f, 
    0.01379863f, -0.01693876f, -0.01744311f, -0.00167075f, 0.00497183f, -0.01946808f, -0.00967853f, -0.02960930f, 
    -0.01704806f, -0.03717371f, -0.03653514f, 0.02526446f, -0.03657959f, -0.04029915f, 0.01837369f, 0.00690251f, 
    0.00547067f, 0.02983904f, 0.00297066f, -0.04162068f, -0.03778013f, 0.02502625f, -0.02239128f, 0.01264733f, 
    -0.03436089f, -0.03544499f, 0.01397683f, 0.01162070f, -0.03019349f, -0.02041033f, -0.01941736f, -0.02144240f, 
    -0.01367069f, 0.01777563f, -0.00353227f, 0.00097675f, -0.01305796f, -0.03871780f, -0.01618028f, -0.00710846f, 
    0.00619045f, -0.03800508f, -0.02107247f, -0.00223747f, 0.01031400f, -0.03863727f, -0.02045040f, 0.01825529f, 
    0.02775199f, -0.02967352f, -0.03232130f, -0.03870132f, 0.02970441f, -0.01411992f, -0.00418220f, 0.01191226f, 
    0.01642508f, -0.01122007f, -0.00705424f, -0.00632502f, -0.03421704f, -0.03160243f, -0.01559905f, 0.02638421f, 
    -0.02287816f, 0.01114896f, -0.01792654f, -0.00956416f, -0.00962307f, 0.01283095f, -0.03906173f, -0.03067737f, 
    -0.01586460f, 0.00268336f, 0.01794279f, -0.00399510f, 0.00689572f, 0.01789615f, -0.03389262f, -0.00357903f, 
    -0.04115915f, 0.02478435f, 0.03296210f, -0.02789705f, -0.01103237f, 0.02068726f, 0.01289469f, 0.00688821f, 
    -0.02243428f, 0.01205847f, 0.01488600f, 0.02100636f, -0.00485367f, -0.01754133f, -0.02699346f, -0.00065486f, 
    0.02460977f, -0.04188910f, -0.00128924f, -0.03308142f, 0.00869959f, -0.02657200f, -0.01135202f, -0.03801338f, 
    -0.01176986f, 0.00968418f, -0.00152038f, -0.03837638f, 0.00956258f, -0.03720909f, -0.01679455f, 0.02351154f, 
    -0.03406433f, 0.00638419f, -0.02735073f, -0.00317885f, 0.00033078f, 0.00973096f, -0.04135386f, -0.01958343f, 
    -0.00061273f, -0.01158350f, -0.00318766f, -0.03514020f, 0.02349176f, 0.01888872f, 0.01255685f, 0.01095732f, 
    -0.00145347f, -0.02605180f, -0.00933706f, 0.00434985f, -0.01574402f, 0.01836314f, 0.00867344f, -0.03255674f, 
    -0.02038459f, 0.02118120f, -0.00951631f, -0.00171653f, -0.02200971f, 0.01726228f, 0.01757864f, 0.00409576f, 
    0.02723984f, -0.02989702f, 0.00931270f, -0.03902164f, 0.02425000f, 0.01720553f, -0.00528086f, 0.00762044f, 
    0.02552656f, -0.03333691f, -0.04188993f, -0.03712448f, -0.03973228f, -0.01647343f, 0.02624616f, 0.01111601f, 
    -0.00022229f, 0.02640458f, 0.01875850f, -0.01169670f, 0.00859325f, 0.00752326f, 0.01181720f, 0.02156981f, 
    -0.02650235f, 0.00104727f, -0.02994418f, -0.04170970f, -0.02767123f, -0.02549206f, -0.04111070f, 0.02725574f, 
    0.01641019f, 0.00936959f, -0.01981945f, -0.02917363f, 0.01825927f, -0.01666966f, 0.00359690f, 0.01163939f, 
    0.02963462f, -0.03474148f, 0.02679015f, -0.00399466f, 0.02063403f, -0.01835432f, 0.02034817f, -0.03550780f, 
    -0.01659882f, -0.03129679f, -0.01298564f, 0.02655127f, 0.01030749f, -0.00351201f, -0.02181789f, -0.00691195f, 
    -0.03594051f, -0.00981353f, -0.03380754f, -0.02617923f, -0.03514494f, -0.03015821f, -0.01239695f, -0.03082630f, 
    0.02164347f, 0.02860800f, -0.02309557f, 0.00993189f, 0.01128085f, -0.00464045f, -0.03363248f, 0.00097981f, 
    -0.00117768f, -0.03190392f, -0.00210632f, 0.00906560f, 0.00585829f, -0.01730635f, -0.00851378f, 0.00424459f, 
    -0.03176623f, -0.00275920f, -0.03270009f, -0.03162953f, 0.00714213f, 0.01895532f, 0.01432469f, 0.00055431f, 
    0.02959244f, 0.02407281f, -0.00922588f, 0.01731513f, -0.01582336f, -0.01572174f, -0.03863733f, -0.03984798f, 
    0.02543466f, 0.00253393f, 0.01111654f, -0.03280779f, 0.00864991f, 0.00423496f, -0.03504765f, -0.01693382f, 
    0.01663413f, -0.00540082f, 0.01178215f, -0.00066065f, -0.01618177f, -0.00605412f, 0.00299352f, 0.00062184f, 
    -0.01780035f, 0.00452656f, 0.02452320f, -0.00727310f, -0.01279039f, -0.02459425f, -0.02241727f, 0.02331116f, 
    -0.02113035f, -0.02884908f, 0.00753436f, -0.04132242f, 0.00433847f, 0.02518090f, -0.02335703f, 0.00089586f, 
    -0.03621971f, -0.01939729f, -0.02864822f, 0.01121923f, -0.01850909f, -0.00802774f, -0.01530319f, -0.01162724f, 
    -0.02489452f, 0.02975782f, -0.02555959f, 0.02631210f, 0.02118046f, 0.00585113f, 0.01359176f, -0.01126598f, 
    0.00514621f, -0.02448678f, -0.00368219f, -0.00692294f, 0.01805785f, -0.03470103f, -0.01311475f, -0.03091314f, 
    -0.01218186f, -0.00611306f, -0.01932749f, 0.00640261f, -0.03217030f, -0.00753983f, -0.01619998f, 0.00115186f, 
    -0.00935565f, -0.02450661f, -0.03503260f, -0.02215760f, -0.02070025f, 0.00441762f, -0.04013163f, -0.03689506f, 
    -0.00883227f, 0.00791702f, -0.02966511f, -0.03034607f, -0.03067612f, -0.04075529f, 0.01591689f, 0.01988318f, 
    -0.02529249f, -0.01007117f, -0.02787291f, -0.00536073f, -0.03241428f, 0.02280937f, 0.00782027f, -0.02254214f, 
    -0.02748872f, -0.03665883f, 0.00196745f, 0.01530804f, -0.02370126f, -0.01675708f, 0.02745594f, 0.01348196f, 
    0.01254694f, 0.00776094f, 0.00557185f, -0.03742138f, -0.02987798f, 0.01283543f, -0.00111361f, 0.00034563f, 
    -0.02188196f, -0.03849538f, -0.01514636f, 0.02712519f, -0.02359324f, 0.00407612f, 0.00392952f, 0.00074087f, 
    -0.01525551f, -0.02714665f, 0.00515485f, -0.03736627f, -0.00889231f, 0.02928152f, 0.02085316f, 0.00410458f, 
    0.01410326f, -0.00525512f, 0.00814713f, -0.01434583f, -0.02787771f, 0.00390253f, 0.02343363f, -0.02151672f, 
    -0.02853094f, -0.00757075f, 0.02654664f, 0.01775571f, -0.01276560f, 0.00174239f, 0.02518080f, -0.02025350f, 
    -0.02523428f, -0.02034995f, 0.01532951f, -0.01586652f, 0.02019798f, 0.01085975f, -0.04074825f, 0.00368607f, 
    -0.02330134f, 0.00192459f, -0.02551794f, -0.01688754f, -0.00035735f, 0.00928566f, -0.03675307f, -0.03025757f, 
    0.01910912f, -0.01351303f, -0.00690723f, -0.03248560f, -0.01197606f, -0.01268129f, 0.01194791f, -0.00495063f, 
    -0.03700429f, 0.00317123f, 0.01124060f, 0.02759378f, 0.03312349f, -0.03214494f, 0.02050205f, 0.00336284f, 
    0.02382682f, -0.01087903f, -0.03488461f, 0.01306041f, 0.02554110f, -0.02805420f, 0.01511155f, -0.03583334f, 
    0.00602376f, -0.01952274f, -0.01839940f, 0.02962418f, -0.00992253f, 0.00869088f, -0.01747176f, -0.04215657f, 
    -0.01240307f, 0.00018138f, -0.03038583f, -0.03444187f, 0.02320627f, -0.02712527f, 0.02326031f, -0.03907448f, 
    0.00145672f, 0.00915786f, -0.00026071f, -0.02324413f, -0.00441932f, 0.02255203f, -0.01330240f, -0.02478770f, 
    0.00801135f, -0.02076777f, 0.02225834f, -0.00374727f, -0.00525019f, -0.03287169f, 0.02706493f, 0.01200909f, 
    0.03609131f, -0.01024885f, 0.02221914f, -0.00939046f, -0.01398255f, -0.02375044f, 0.00667483f, -0.01333696f, 
    -0.02214335f, -0.03442024f, 0.02047127f, -0.04004790f, 0.00155565f, -0.03883611f, 0.02181914f, 0.01107937f, 
    -0.02085155f, 0.00293049f, 0.02750275f, 0.00763758f, -0.00351373f, 0.02624158f, -0.00312940f, 0.00486230f, 
    -0.00462724f, 0.02357149f, -0.03118266f, -0.01086734f, -0.04476319f, 0.02840075f, -0.01019579f, 0.00529542f, 
    -0.02253617f, 0.03100545f, -0.01478833f, 0.01914364f, 0.02418680f, -0.03262933f, 0.03072122f, -0.01879361f, 
    0.00275321f, -0.03047399f, -0.02198565f, -0.01333031f, 0.02926034f, -0.01632652f, -0.01907485f, 0.00578251f, 
    0.00649015f, -0.01982094f, -0.03772236f, 0.00608654f, 0.01430074f, -0.02483548f, -0.03135113f, -0.00637092f, 
    -0.03481833f, 0.01326134f, 0.01653919f, -0.02083013f, 0.02352293f, 0.01859784f, -0.01197396f, -0.02920422f, 
    0.03342416f, 0.01604598f, 0.02592596f, -0.01790170f, 0.01991073f, -0.00522206f, -0.00661678f, -0.02855980f, 
    0.02962990f, -0.03441509f, -0.01553594f, -0.01147622f, -0.01798125f, 0.01358006f, 0.00245344f, -0.01216672f, 
    0.03246809f, -0.03744142f, -0.01457996f, 0.00696310f, 0.02983380f, -0.02595864f, 0.00674465f, 0.02039454f, 
    -0.04499713f, 0.01939996f, -0.02764658f, -0.02858657f, -0.03479024f, -0.02015605f, 0.02838940f, 0.01015177f, 
    -0.01667896f, 0.00055095f, -0.03948127f, 0.01093154f, 0.02025121f, -0.02430002f, 0.00683600f, 0.00694443f, 
    -0.02517097f, 0.00776934f, -0.03873274f, 0.01004506f, 0.00096097f, -0.00237641f, -0.03146756f, -0.00934530f, 
    0.00523198f, -0.03643321f, 0.02324517f, -0.02321359f, -0.03863436f, -0.04040090f, -0.02351371f, -0.01624358f, 
    -0.01521026f, -0.02180684f, -0.00179936f, -0.00657376f, -0.01602773f, 0.00573455f, -0.03691424f, -0.01042235f, 
    0.01150443f, -0.03143944f, 0.02225201f, -0.02883994f, 0.01090327f, 0.00896467f, -0.03396502f, 0.00747064f, 
    -0.03099586f, -0.00782566f, -0.00403453f, 0.02577502f, -0.01385999f, -0.03336846f, -0.02446730f, -0.00828583f, 
    0.00187971f, -0.02659127f, 0.01825918f, 0.02915403f, 0.01349266f, -0.02564715f, -0.01617896f, -0.03523313f, 
    0.01270877f, -0.00524253f, -0.03583401f, 0.00713917f, -0.02619058f, 0.02499191f, 0.01533318f, 0.00673250f, 
    0.02474508f, 0.02067089f, 0.00740937f, 0.01303466f, 0.00164420f, -0.03484621f, -0.00756906f, 0.00512633f, 
    -0.03680601f, 0.02985814f, -0.00632077f, 0.00509129f, 0.02615559f, 0.02434268f, -0.01800700f, 0.02616923f, 
    -0.02318218f, -0.01136033f, -0.02641032f, 0.03064962f, 0.00409307f, 0.01493631f, 0.00645235f, 0.02234829f, 
    -0.02325786f, -0.00657509f, 0.02456763f, 0.03089235f, -0.01288380f, -0.01461258f, -0.00237259f, -0.00966652f, 
    0.01696176f, -0.01356191f, 0.02558899f, 0.00072752f, 0.03181386f, -0.02472319f, 0.02712052f, 0.01864029f, 
    0.00628407f, -0.00594826f, 0.00268922f, -0.03297791f, -0.03830105f, -0.03997915f, -0.01141047f, -0.02620782f, 
    -0.01107207f, -0.00838424f, -0.02836804f, -0.02324351f, -0.02955249f, -0.00965206f, -0.02025332f, -0.00201342f, 
    -0.01150807f, -0.01432983f, -0.02371281f, 0.02231257f, 0.01283396f, -0.01038649f, -0.01295000f, -0.01153228f, 
    -0.01685947f, -0.00193897f, -0.02358990f, 0.01104825f, 0.03132823f, -0.01526217f, -0.03977957f, 0.01983841f, 
    0.02502025f, -0.00893133f, -0.02161480f, -0.02613075f, -0.02597534f, 0.02574405f, 0.00913045f, -0.02206917f, 
    0.01717716f, -0.02969175f, 0.02490405f, 0.02235165f, -0.01087011f, -0.00701209f, -0.02284761f, 0.01121080f, 
    0.02213296f, -0.02408686f, -0.04198085f, 0.00925950f, 0.01423462f, 0.01083292f, -0.03822910f, -0.03515244f, 
    0.01461630f, 0.01125723f, -0.02414195f, -0.01720022f, 0.01599937f, 0.00191825f, -0.02335773f, -0.03435260f, 
    -0.02213703f, 0.02879275f, -0.00415643f, -0.02533735f, -0.02814302f, 0.01870467f, -0.02758556f, -0.00145834f, 
    -0.00615554f, 0.01408710f, -0.02803799f, -0.01055244f, -0.03360653f, -0.03054185f, 0.02411375f, -0.03203201f, 
    0.01040657f, 0.02350142f, 0.01306368f, -0.03450535f, -0.01478927f, 0.00902076f, 0.00328954f, 0.02718106f, 
    -0.01167562f, -0.03997472f, -0.03480599f, -0.03168757f, -0.04266455f, -0.00358577f, -0.01322181f, -0.00318061f, 
    -0.02861306f, 0.02403361f, 0.03315224f, 0.00045165f, -0.03095035f, 0.03107334f, 0.00230275f, 0.01377075f, 
    0.00693345f, 0.00310285f, -0.02564260f, 0.01390524f, -0.02100565f, 0.01634454f, 0.02535515f, 0.03705306f, 
    -0.03130230f, 0.00059037f, 0.00578233f, -0.03126586f, -0.02666715f, -0.01818819f, -0.02908838f, -0.00122589f, 
    -0.02724181f, 0.01929026f, 0.01520984f, -0.00574187f, 0.00274899f, -0.04090128f, 0.01211854f, -0.02315676f, 
    -0.00091622f, -0.02878144f, -0.03624184f, 0.00632150f, 0.00701319f, -0.00561721f, 0.00168698f, -0.02298163f, 
    -0.02907725f, 0.02106584f, 0.02722308f, 0.00347981f, 0.02523081f, -0.04278592f, -0.02626476f, -0.00934091f, 
    -0.00443454f, 0.01508718f, 0.02310406f, -0.03288697f, -0.01051223f, 0.02597679f, -0.02021512f, -0.00487006f, 
    -0.02970374f, 0.00468865f, -0.00641686f, -0.01575333f, 0.00390347f, -0.00858923f, -0.03736554f, -0.00345453f, 
    0.01972305f, -0.03184911f, -0.00422940f, 0.02859822f, -0.03504417f, -0.02569544f, -0.01361079f, -0.01234082f, 
    -0.03566203f, -0.04147142f, -0.01333372f, -0.03157138f, 0.01579908f, -0.02112228f, -0.00854659f, -0.01346136f, 
    0.02707262f, 0.02619312f, -0.00794102f, 0.02196039f, 0.01321935f, 0.02437502f, -0.02428394f, -0.00410268f, 
    -0.03317516f, 0.02666480f, 0.00346616f, -0.02109481f, -0.00905748f, 0.02536615f, 0.00833726f, 0.00721878f, 
    -0.03753602f, 0.00685471f, 0.02809453f, 0.01257901f, 0.03303219f, -0.00734762f, 0.02822777f, -0.03396489f, 
    0.02527853f, -0.00998432f, 0.01537035f, -0.01811192f, 0.01633533f, -0.02750354f, -0.00011231f, -0.02260373f, 
    0.01345300f, -0.03344461f, 0.01901312f, -0.03463385f, -0.03918411f, 0.00846163f, -0.01627743f, -0.01307642f, 
    0.02744533f, -0.03849211f, 0.00135753f, -0.03840568f, -0.03754276f, 0.00701616f, 0.00932821f, 0.00955253f, 
    -0.00084104f, 0.01705039f, 0.02598882f, 0.02707262f, 0.01657544f, -0.00229849f, -0.00206751f, -0.01912067f, 
    -0.00638269f, 0.00729943f, 0.02807637f, -0.00471691f, -0.03216771f, 0.02781604f, -0.01324154f, -0.01443699f, 
    0.02596630f, -0.00949257f, -0.03469481f, -0.01770313f, -0.01290077f, -0.00673655f, -0.03959717f, 0.01020277f, 
    -0.00452165f, 0.02612607f, 0.02108994f, -0.02417775f, -0.03567248f, -0.00498914f, 0.00013639f, 0.02129266f, 
    0.00618654f, -0.02489376f, 0.02876909f, -0.02360132f, 0.02979181f, 0.00219023f, -0.03925218f, -0.00613115f, 
    -0.02789287f, -0.03092323f, -0.01436009f, -0.01155529f, -0.00832655f, -0.03072981f, -0.04049129f, -0.01123848f, 
    0.02237450f, -0.00425623f, -0.01294402f, 0.00198232f, 0.02006363f, 0.01012022f, 0.02101256f, -0.03142325f, 
    -0.02242373f, -0.01292307f, -0.02481557f, -0.01757507f, 0.02018394f, -0.01133393f, 0.00685993f, -0.02708312f, 
    -0.01441198f, 0.01801528f, 0.02512016f, 0.02564468f, -0.02917532f, -0.03846355f, 0.01991128f, 0.00534183f, 
    0.00952070f, -0.02847777f, -0.04000099f, 0.02888604f, -0.02795033f, 0.01522420f, -0.02435851f, 0.03320818f, 
    0.02715966f, -0.03623457f, -0.02490526f, -0.00464082f, 0.00212846f, -0.03132999f, 0.01012130f, 0.00481461f, 
    -0.02623967f, -0.00779417f, -0.02327588f, 0.00957394f, 0.00677044f, -0.03604835f, 0.00219743f, -0.00443629f, 
    0.01126613f, 0.01023239f, -0.02856928f, -0.01314278f, -0.00764500f, -0.01224222f, 0.01521282f, 0.00550212f, 
    0.02999351f, -0.02777781f, 0.03027033f, -0.03150181f, -0.02488919f, -0.00148352f, 0.00303346f, 0.00292145f, 
    -0.00462042f, 0.00902127f, -0.01888620f, -0.00281439f, 0.03208904f, -0.03789758f, 0.00340971f, -0.01028563f, 
    0.00399355f, 0.00310220f, -0.00746620f, -0.03005645f, 0.02759572f, 0.02668128f, -0.00998899f, -0.03348904f, 
    -0.02588528f, -0.01472682f, 0.02822316f, 0.00855261f, -0.03918770f, -0.01426935f, 0.02641571f, 0.01452534f, 
    -0.03333961f, 0.01241761f, -0.02708216f, 0.01356115f, -0.00737404f, -0.03368426f, 0.00555951f, 0.02774606f, 
    0.00595248f, -0.01264447f, -0.02660508f, 0.02135880f, 0.03207630f, 0.03087697f, -0.00498003f, 0.01587042f, 
    -0.00841856f, -0.02780919f, -0.02135082f, -0.02016559f, -0.00982103f, 0.03076608f, 0.00082965f, 0.02440881f, 
    -0.01423648f, -0.01905028f, -0.03429107f, -0.00526822f, -0.03384187f, 0.02067318f, -0.01652535f, -0.02514422f, 
    0.00144762f, -0.03148888f, 0.01179491f, -0.03650473f, 0.00415341f, -0.01774834f, -0.03022443f, 0.00560213f, 
    -0.26429015f, -0.24134603f, -0.23326533f, -0.18134192f, -0.07037473f, -0.11199228f, 0.00611495f, -0.03721532f, 
    0.15121886f, 0.18157297f, 0.11116409f, 0.41695738f, -0.24620436f, 0.02458886f, -0.15135664f, 0.07232145f, 
    -0.00961245f, 0.15870744f, 0.04014714f, -0.16340670f, -0.08722182f, -0.04057454f, -0.01860883f, 0.20060283f, 
    -0.10800357f, -0.05315198f, -0.06844555f, -0.02527267f, 0.08483668f, 0.00887963f, 0.10562525f, -0.08608081f, 
    0.10462436f, 0.09960765f, -0.04659491f, -0.19517352f, -0.13920963f, -0.21001829f, 0.21508193f, -0.08996174f, 
    -0.06181112f, 0.10514671f, -0.28452045f, 0.01976920f, -0.03140463f, 0.02801164f, -0.14123598f, 0.05531251f, 
    0.16365209f, -0.07632329f, -0.03319683f, 0.15373009f, -0.01754021f, 0.09374350f, -0.29961959f, 0.00453931f, 
    -0.03660722f, 0.02060430f, 0.07159494f, -0.06359820f, -0.13792217f, -0.01940845f, -0.04915681f, 0.01964430f, 
    -0.16000009f, 0.01969406f, -0.18106189f, -0.15097709f, -0.04704588f, 0.01297035f, 0.09308027f, 0.00307417f, 
    0.22271994f, 0.16494633f, -0.09853462f, -0.01899637f, 0.06114691f, -0.17147981f, 0.06691829f, 0.08586372f, 
    0.11412555f, 0.10467977f, 0.06597699f, 0.18849055f, 0.44504026f, 0.26178837f, 0.21730253f, 0.05649902f, 
    -0.01346244f, -0.03733927f, 0.05483199f, 0.05718490f, -0.03021008f, -0.16108638f, 0.07433438f, 0.00514113f, 
    0.27664024f, -0.07047562f, 0.06532197f, 0.07487525f, 0.04179683f, -0.03780219f, -0.14792114f, -0.09971111f, 
    0.01384947f, -0.03390650f, 0.09861350f, 0.01828964f, 0.07351841f, -0.28502238f, -0.10114250f, 0.09166069f, 
    -0.00297933f, 0.04328875f, -0.03398532f, -0.04242748f, 0.09319896f, 0.09871209f, 0.16079171f, -0.07438086f, 
    -0.11846620f, -0.15625340f, 0.00826525f, -0.17703192f, -0.00888527f, 0.03682901f, -0.05848721f, -0.05745846f, 
    0.04594855f, 0.07706419f, 0.03384408f, 0.10003015f, 0.30111310f, 0.17032287f, 0.12690148f, 0.35869318f, 
    0.03633875f, -0.02697072f, -0.00794918f, 0.10228761f, -0.01202189f, 0.01167756f, 0.03088775f, -0.03803560f, 
    0.01777617f, -0.13009445f, 0.16096684f, -0.07219656f, 0.10519566f, 0.01987449f, -0.00031685f, 0.02936083f, 
    -0.03235712f, -0.06016329f, 0.13327025f, 0.00282441f, -0.09218382f, 0.26616713f, 0.25269607f, 0.25098795f, 
    0.01734272f, 0.00298990f, 0.00633143f, -0.11020953f, -0.07913763f, -0.04416189f, -0.08458669f, 0.09700602f, 
    -0.13210794f, 0.34107116f, -0.57702571f, 0.10187182f, -0.01051945f, -0.07739468f, 0.05918889f, -0.02125530f, 
    -0.00394885f, 0.14270744f, -0.18284519f, -0.08409745f, 0.12219916f, 0.06362741f, 0.11125980f, -0.03898975f, 
    0.04790671f, 0.01380154f, -0.02229874f, 0.24793917f, 0.09528033f, 0.06750583f, 0.10368143f, -0.03970343f, 
    0.05808285f, 0.27091998f, 0.11299887f, 0.07655253f, -0.26052752f, -0.06204934f, 0.05067609f, 0.01075061f, 
    0.02963058f, 0.01089550f, 0.02500072f, 0.00840918f, 0.04373231f, 0.06623774f, 0.11192726f, 0.13505761f, 
    0.00506769f, -0.02322646f, -0.11356830f, -0.04034198f, 0.23324454f, 0.01105809f, 0.08981653f, 0.07464301f, 
    0.45198423f, 0.51876676f, 0.14872821f, 0.09416701f, 0.12384070f, 0.09090659f, -0.00034953f, 0.23635206f, 
    0.18524140f, 0.03157133f, -0.01422342f, -0.03359069f, -0.06268528f, 0.04580618f, 0.10988581f, -0.03691173f, 
    0.03163466f, 0.16178215f, 0.05295409f, -0.07530113f, 0.04472886f, 0.04339148f, -0.01053801f, 0.05548798f, 
    0.00982612f, -0.12050243f, 0.38679913f, 0.15722695f, 0.14276433f, -0.04353700f, -0.15848564f, 0.08936609f, 
    -0.01870910f, -0.08083492f, -0.05847609f, 0.10999636f, 0.13402495f, 0.12177336f, 0.25540650f, 0.07511476f, 
    0.08606766f, -0.02412825f, 0.07723415f, 0.11988410f, -0.07539140f, 0.04381891f, -0.05144724f, -0.01199460f, 
    -0.01412276f, 0.02290952f, 0.15274481f, 0.08247352f, -0.00467838f, 0.02818006f, -0.08240873f, 0.12158966f, 
    0.04859233f, -0.01651499f, -0.03750515f, -0.09657657f, 0.08756589f, -0.00019436f, 0.19213389f, 0.15556197f, 
    0.06843457f, -0.24709032f, -0.04629290f, 0.20320116f, -0.00122825f, 0.10407835f, 0.11942883f, 0.08239760f, 
    0.03945969f, 0.03647513f, 0.19255584f, 0.03996897f, -0.07765812f, -0.10280668f, -0.10353568f, 0.11988464f, 
    -0.00866219f, -0.08518793f, 0.01638823f, 0.01777469f, -0.45999682f, 0.23498866f, 0.09997550f, -0.00088302f, 
    -0.01469338f, 0.01998203f, -0.02312335f, 0.01648949f, -0.03034065f, -0.25495526f, -0.15409726f, -0.04055412f, 
    -0.06177225f, 0.11312886f, -0.04990888f, -0.13933015f, 0.01851559f, -0.07656706f, 0.06443024f, 0.02433885f, 
    -0.01671822f, 0.08612520f, -0.08173128f, 0.21526963f, 0.18203370f, 0.15034285f, -0.18029930f, 0.08157387f, 
    -0.01750278f, -0.00305202f, -0.03372600f, -0.05447764f, -0.19231957f, -0.00225930f, -0.06161408f, -0.07482529f, 
    0.09020989f, 0.06773786f, -0.04384634f, 0.08737981f, 0.20322849f, 0.08326420f, 0.21484767f, 0.00403743f, 
    0.11237056f, 0.01357529f, -0.01180336f, 0.00571368f, 0.04196769f, -0.10349889f, -0.04568423f, 0.17218332f, 
    0.03154806f, 0.08107552f, 0.05915679f, 0.05091127f, 0.04636129f, 0.04430156f, 0.07724635f, 0.06620052f, 
    -0.06501763f, 0.06500315f, 0.00346906f, -0.08773880f, 0.00344205f, -0.03816614f, -0.00912399f, -0.01674604f, 
    -0.15927869f, -0.04328677f, -0.12481087f, -0.08084983f, -0.07945515f, -0.07464679f, -0.09970994f, 0.01348509f, 
    0.08719613f, -0.03015159f, -0.12193560f, -0.09867202f, 0.20247829f, 0.22884473f, 0.00983319f, 0.15223920f, 
    -0.06563992f, -0.10405438f, -0.28592482f, 0.14455996f, -0.07923542f, -0.07667184f, 0.01854188f, 0.13375491f, 
    -0.03020760f, -0.01800925f, -0.04215847f, -0.12209294f, 0.03157144f, -0.20115915f, -0.31045431f, -0.24316959f, 
    -0.08041088f, -0.03408138f, -0.05226584f, -0.12258680f, 0.13630767f, 0.04116395f, -0.05677751f, -0.05301360f, 
    0.11690680f, 0.05126031f, -0.05935571f, 0.11039390f, 0.03988196f, 0.15638348f, 0.25177664f, 0.10182229f, 
    0.01505224f, -0.07589687f, -0.11865310f, -0.18653147f, 0.18704611f, 0.26618508f, 0.21798728f, 0.11102135f, 
    0.05399353f, -0.09458610f, -0.11309370f, 0.07653127f, -0.06185326f, 0.07341275f, 0.06506495f, 0.04448812f, 
    -0.35952780f, 0.22730091f, 0.16025995f, -0.29040632f, -0.07987007f, -0.05451900f, 0.05038158f, 0.11061221f, 
    -0.11488374f, -0.01684061f, 0.07653831f, 0.01282668f, -0.10988280f, -0.03794986f, 0.31633490f, 0.05137451f, 
    0.01369959f, 0.07870381f, -0.28011209f, 0.19101381f, -0.00966362f, 0.09642855f, 0.13159502f, -0.05536557f, 
    -0.10985830f, -0.20511809f, 0.00217775f, 0.14164826f, 0.13536388f, 0.34703740f, -0.09662373f, -0.07207894f, 
    -0.04703952f, 0.02241959f, 0.06306064f, 0.11919568f, 0.01240684f, -0.15867555f, 0.20531976f, -0.01962997f, 
    0.17283389f, 0.12562284f, -0.03777235f, 0.08669241f, -0.05277989f, -0.03738450f, 0.15574054f, -0.09869213f, 
    0.14232469f, 0.14013442f, -0.05336997f, -0.06482834f, 0.12861070f, 0.03765332f, 0.04686342f, 0.12345693f, 
    0.16131620f, -0.01055163f, 0.00503922f, 0.10049336f, -0.11686163f, -0.32559177f, 0.00594908f, 0.10719284f, 
    -0.04447236f, -0.02066561f, -0.05722949f, -0.10114755f, -0.01887378f, -0.06832381f, -0.01510051f, -0.03951236f, 
    0.15524414f, 0.13451307f, -0.02187033f, -0.01436154f, 0.01598541f, -0.01887003f, -0.15872489f, 0.03084850f, 
    -0.00331815f, -0.08682498f, 0.00850358f, 0.02628990f, 0.02050747f, -0.34996977f, -0.18997598f, 0.28090382f, 
    0.00951253f, 0.12972625f, 0.08003160f, 0.07096919f, 0.00870042f, -0.00731672f, -0.08618546f, -0.04841097f, 
    -0.06290011f, -0.02858300f, 0.13226907f, 0.12629324f, -0.10110252f, -0.01674978f, -0.01510572f, 0.03658179f, 
    -0.10638052f, 0.01136822f, 0.07602566f, -0.02082544f, -0.14422038f, -0.08425472f, -0.06397782f, -0.26689243f, 
    -0.05499937f, -0.05938064f, -0.00816788f, -0.15584446f, 0.01962112f, 0.13403811f, 0.11211501f, -0.13701867f, 
    0.12882292f, 0.16888876f, 0.06194348f, 0.05178061f, -0.08284173f, 0.00779107f, 0.10511979f, 0.21501547f, 
    0.04447995f, 0.06082599f, -0.00500773f, -0.02715364f, -0.26926437f, -0.07859033f, -0.78412747f, 0.17674042f, 
    -0.10235402f, 0.07381675f, 0.10183842f, 0.07466486f, 0.02864926f, -0.05393898f, -0.12390397f, 0.01295072f, 
    0.16681841f, 0.16429885f, 0.17176566f, 0.07884032f, 0.00228284f, 0.05300742f, 0.10450872f, 0.02449504f, 
    0.03771945f, 0.07340051f, 0.00582528f, 0.02378155f, -0.15350996f, -0.13836008f, -0.17262703f, -0.07376313f, 
    0.00309547f, -0.03279719f, 0.03060992f, 0.10583708f, 0.07848618f, 0.15018831f, -0.16622734f, -0.12633684f, 
    0.36536095f, 0.27420160f, 0.27138379f, 0.07631640f, -0.02549277f, 0.00637972f, -0.06935978f, 0.01046894f, 
    -0.25737455f, -0.11402306f, 0.18157665f, 0.07565336f, -0.19533087f, 0.02736093f, 0.02212155f, 0.07572501f, 
    0.06367064f, -0.00868500f, -0.16691519f, 0.18892661f, 0.13514537f, -0.01652643f, -0.05258901f, 0.00194301f, 
    0.23067023f, 0.21118858f, 0.11694616f, 0.24584632f, 0.03600812f, -0.04111109f, -0.00327830f, 0.02180248f, 
    -0.15371540f, -0.01524759f, -0.05628916f, -0.01371654f, 0.10194786f, -0.04290012f, -0.17192411f, -0.10903502f, 
    0.10926632f, -0.18386851f, 0.00896818f, -0.01788899f, 0.12740523f, 0.04287008f, -0.10215192f, 0.01351582f, 
    0.00016148f, -0.01443736f, 0.05864545f, 0.00885549f, -0.04864118f, -0.11254861f, -0.18037653f, 0.00442292f, 
    -0.04870009f, 0.02563694f, -0.04054184f, -0.03512979f, -0.24726772f, 0.10436843f, 0.00493463f, -0.58531678f, 
    0.10699822f, 0.02026926f, 0.13831432f, 0.03703671f, 0.06348970f, 0.07911702f, 0.06777184f, -0.05143743f, 
    0.19754028f, 0.21723133f, 0.05165555f, 0.18263683f, 0.12798260f, 0.04585668f, -0.03741078f, -0.00146860f, 
    0.15580933f, 0.10290258f, 0.06313647f, 0.24860556f, -0.33879596f, -0.66144389f, -0.23020692f, 0.23349421f, 
    -0.01288758f, 0.05216029f, 0.01107059f, -0.12259408f, -0.00751555f, -0.01915049f, -0.01768206f, 0.01397908f, 
    -0.28758305f, -0.40745911f, -0.11544418f, 0.26895335f, 0.03580349f, 0.09382752f, -0.05132474f, -0.07498278f, 
    -0.07966607f, -0.04011868f, -0.08593209f, -0.01288923f, -0.13129327f, -0.18032105f, -0.01380858f, 0.08947728f, 
    0.02977704f, -0.08006938f, -0.12546337f, -0.02917185f, 0.06284764f, 0.02271798f, 0.00589846f, 0.05817027f, 
    0.54954952f, 0.42433453f, 0.21608852f, -0.08099026f, -0.01082839f, -0.04219988f, -0.09477389f, 0.08473188f, 
    -0.11648022f, -0.05015489f, 0.10083974f, 0.12451454f, 0.44959918f, 0.17053488f, 0.06762979f, -0.03377355f, 
    0.02283741f, -0.03769240f, -0.05142802f, 0.01479544f, -0.06786864f, -0.12572457f, -0.00026855f, -0.04673252f, 
    -0.06065035f, -0.07802940f, 0.33068261f, 0.26428214f, -0.06828015f, -0.11390484f, -0.04221506f, -0.07974359f, 
    -0.00545827f, -0.05570414f, 0.04939408f, -0.14541973f, 0.10981712f, 0.02884816f, -0.06589487f, 0.01757654f, 
    -0.05246574f, -0.16061801f, 0.10780737f, -0.02528779f, 0.06675630f, 0.04251183f, 0.02472018f, 0.07136936f, 
    0.02792821f, 0.00855020f, -0.01235867f, -0.01245274f, 0.00760553f, -0.03222150f, -0.01488177f, 0.02292998f, 
    -0.00929211f, 0.00996323f, -0.00352856f, 0.00699792f, 0.02728595f, -0.02957023f, -0.00730279f, -0.04102949f, 
    -0.00244946f, -0.04046230f, 0.02225520f, -0.02226896f, -0.02880436f, 0.02464065f, -0.02391404f, 0.00810930f, 
    -0.00935353f, -0.00493348f, 0.01744888f, 0.02135754f, -0.00802614f, -0.03256171f, -0.01377560f, -0.00316861f, 
    -0.00649365f, -0.04221644f, 0.01208094f, 0.02778378f, 0.01461190f, -0.02555052f, 0.03040768f, 0.02871781f, 
    -0.01349291f, 0.00017876f, 0.02955700f, -0.01897672f, -0.02795886f, -0.00199124f, 0.00835714f, -0.03045764f, 
    0.01005346f, -0.02389709f, -0.01828873f, 0.01786419f, 0.00470938f, -0.01649146f, -0.03365282f, 0.00145816f, 
    0.00264664f, -0.03163956f, -0.02021037f, -0.02306707f, 0.01255604f, -0.00659403f, 0.01707003f, -0.01942981f, 
    0.02971393f, -0.02084532f, -0.00590769f, -0.04134784f, -0.01282118f, 0.01323009f, 0.01891446f, -0.00982699f, 
    -0.03161070f, -0.03707682f, 0.00438226f, -0.03487761f, 0.02995998f, -0.02215493f, 0.00690045f, 0.00836358f, 
    0.03522084f, -0.02561297f, -0.02403192f, -0.02145527f, 0.02462877f, -0.00852954f, 0.00893959f, -0.02166897f, 
    -0.02662303f, 0.01937793f, -0.03598160f, -0.03867027f, -0.02575595f, 0.02881743f, -0.03088368f, -0.01120165f, 
    -0.02124394f, 0.01445344f, -0.02825373f, 0.02652797f, -0.00283738f, -0.02086919f, 0.01370693f, 0.00780906f, 
    -0.02089311f, 0.00124333f, -0.00478048f, -0.00419814f, -0.04121333f, -0.01916086f, -0.02229198f, 0.00789440f, 
    -0.03479357f, -0.02405580f, -0.00638855f, 0.01453133f, -0.01107418f, -0.02123939f, -0.03412770f, -0.03206048f, 
    -0.01190930f, -0.00895530f, -0.04129658f, 0.00065080f, -0.03861564f, 0.02670483f, -0.01897253f, 0.02062103f, 
    -0.01215518f, -0.03753389f, 0.01127507f, 0.00092272f, -0.03610767f, -0.02485648f, -0.01007340f, -0.01511030f, 
    -0.00375313f, -0.01132732f, 0.01513654f, -0.02326945f, -0.03421616f, 0.01963764f, 0.01813701f, 0.03266555f, 
    0.00151742f, -0.01696293f, -0.00336424f, -0.03596101f, -0.03860947f, 0.01739629f, -0.00822149f, 0.00177290f, 
    -0.02725740f, 0.01980242f, -0.04025507f, -0.01634648f, 0.03993714f, -0.00563675f, 0.02654785f, 0.01856674f, 
    0.02246456f, 0.02733679f, 0.01644208f, -0.03827658f, -0.00103359f, 0.01261430f, -0.03037345f, 0.02069611f, 
    0.01382232f, -0.03130909f, -0.01324878f, 0.00351951f, -0.03150162f, -0.01413053f, -0.01087882f, 0.01522548f, 
    0.02811901f, 0.03249445f, -0.01433905f, 0.00682671f, 0.02934807f, -0.04089158f, -0.01916186f, -0.03041977f, 
    0.00830466f, 0.01760625f, -0.02233132f, 0.00641762f, 0.02059745f, -0.03907400f, -0.03822223f, 0.01720704f, 
    -0.01341158f, -0.00576780f, -0.02276029f, -0.02405197f, -0.03439727f, -0.02332398f, 0.00996576f, -0.03745608f, 
    -0.00714747f, -0.02841045f, 0.03480926f, -0.03379264f, -0.00319448f, -0.02825412f, 0.02485039f, 0.00550113f, 
    -0.04200996f, -0.02727256f, -0.02166228f, -0.00866872f, -0.01549552f, 0.01996246f, 0.00627837f, 0.00093614f, 
    0.00886912f, -0.03937405f, 0.02570064f, -0.01971604f, -0.03269914f, 0.02566157f, -0.00583773f, 0.02891399f, 
    0.00275099f, -0.01628435f, 0.01096380f, -0.01259750f, -0.02395579f, 0.01474925f, -0.02065540f, 0.02534560f, 
    -0.01144706f, -0.03710938f, -0.02620170f, 0.00651563f, 0.02549584f, -0.03307930f, 0.03320836f, 0.03234046f, 
    -0.02048857f, -0.01999865f, -0.03797654f, -0.03380966f, -0.03385205f, -0.00892975f, 0.01255811f, 0.02727379f, 
    0.01125186f, 0.00613979f, -0.03221687f, -0.02845749f, -0.03400424f, -0.02741941f, 0.00341710f, -0.03823270f, 
    0.02604994f, 0.00459016f, 0.01431664f, -0.02266065f, 0.02678935f, 0.01392691f, -0.02069427f, -0.02566528f, 
    -0.02245891f, -0.03669601f, 0.02373377f, 0.01961513f, 0.03053801f, -0.02288558f, -0.00064828f, -0.00437171f, 
    -0.01273391f, 0.02320644f, 0.00889005f, -0.02458019f, -0.02203272f, 0.00827538f, 0.00908906f, 0.01018968f, 
    -0.03548212f, -0.02599056f, -0.03531753f, 0.02327025f, 0.02359601f, 0.02376486f, -0.02004050f, 0.01074665f, 
    -0.04356442f, 0.03050214f, -0.03977014f, -0.00035885f, -0.02096907f, 0.02366944f, -0.01449759f, -0.01214743f, 
    -0.02410123f, 0.03163880f, 0.01511821f, -0.01469058f, 0.03144750f, -0.03824014f, 0.00331809f, -0.02435235f, 
    -0.00248792f, -0.00555623f, -0.03068681f, -0.03322738f, 0.00824932f, 0.01976764f, -0.03167550f, -0.00055093f, 
    -0.00459123f, -0.02773419f, 0.01256306f, 0.00413211f, 0.01957189f, -0.01896048f, 0.02087789f, 0.01259089f, 
    -0.03204525f, -0.01372837f, -0.02772071f, -0.01193792f, -0.02940220f, 0.02313757f, 0.02705491f, 0.01963045f, 
    0.01190319f, -0.02436474f, 0.02829968f, -0.00423731f, 0.00740798f, 0.00551721f, 0.02081636f, -0.00856132f, 
    -0.02689745f, 0.00753552f, 0.00819235f, 0.00911881f, -0.00092823f, -0.01275418f, 0.00109252f, 0.03246027f, 
    -0.03807954f, 0.00520046f, 0.03772204f, -0.01741432f, 0.01358835f, 0.02464136f, -0.00401900f, 0.02295878f, 
    -0.01284066f, 0.02684094f, -0.03587063f, 0.02567244f, 0.00107139f, -0.02329599f, -0.00147635f, -0.03518641f, 
    -0.01865280f, -0.03748147f, -0.03614152f, -0.01347469f, 0.01860560f, -0.02004749f, -0.01587368f, -0.03743446f, 
    -0.02137338f, -0.00958023f, -0.01104593f, -0.02755235f, 0.01085794f, -0.03159324f, -0.02506479f, 0.01038247f, 
    -0.03341349f, -0.02733248f, 0.00145007f, -0.02721628f, -0.00713401f, 0.01744046f, -0.01315757f, -0.03973944f, 
    0.00023833f, 0.00148707f, -0.03106773f, -0.00380199f, 0.02337655f, -0.02241033f, 0.00298646f, -0.02431748f, 
    -0.03384515f, 0.02007187f, 0.00490077f, 0.02331326f, -0.02709673f, -0.02431805f, 0.01878200f, -0.00777256f, 
    -0.03410060f, -0.02398110f, -0.00352917f, -0.03326697f, 0.02175673f, 0.00508847f, 0.00948139f, -0.02398738f, 
    -0.04085919f, -0.03819636f, -0.01908020f, -0.00247830f, 0.00584241f, -0.04060740f, -0.00283553f, 0.00573906f, 
    -0.00854986f, 0.01167462f, -0.00484365f, -0.03505888f, -0.03165615f, -0.01226979f, 0.01799549f, 0.00557510f, 
    -0.00269353f, -0.00565499f, -0.03564806f, -0.01975990f, 0.00584636f, -0.01821302f, 0.00940407f, -0.00527150f, 
    0.00587803f, 0.00311283f, 0.00088877f, 0.01080005f, 0.03090605f, 0.00647286f, 0.00560347f, 0.02903059f, 
    0.03131212f, -0.00273459f, -0.01047776f, 0.00759119f, -0.02742362f, -0.02589222f, 0.02313700f, 0.02535468f, 
    -0.01213004f, 0.01110295f, 0.02314252f, 0.00086805f, 0.02322731f, 0.02458253f, 0.01150899f, -0.03967275f, 
    -0.01164086f, -0.01418559f, -0.03224616f, -0.00790830f, -0.00005922f, -0.00367819f, 0.02922696f, -0.02494170f, 
    0.01744109f, -0.02814874f, 0.01339677f, -0.00661434f, -0.04106082f, 0.02615179f, -0.00420211f, -0.03592930f, 
    0.01306899f, 0.00769039f, 0.01183811f, -0.03879239f, -0.00485274f, 0.01277855f, -0.01378313f, 0.01057807f, 
    -0.00167454f, -0.02513147f, -0.01926208f, -0.03954976f, 0.00786355f, -0.04390551f, 0.01929613f, -0.02838103f, 
    -0.01127771f, 0.00322569f, -0.00633568f, -0.02043105f, -0.00385135f, -0.01932591f, -0.00002758f, 0.02344307f, 
    0.01227755f, 0.00974685f, -0.02785982f, -0.03228221f, -0.01143724f, 0.00333993f, 0.00183947f, -0.00161294f, 
    -0.01565776f, -0.03547260f, -0.01633132f, -0.02741928f, 0.02439583f, -0.01226341f, 0.02884559f, 0.00570573f, 
    0.01026767f, 0.00637331f, -0.01192670f, 0.00765174f, -0.00614142f, 0.02202071f, -0.02548299f, -0.00216928f, 
    0.02944408f, -0.00368403f, 0.02562255f, -0.02794055f, -0.03839555f, -0.00029840f, -0.02365259f, 0.01794791f, 
    -0.02637344f, 0.00222171f, 0.02524238f, 0.03117911f, 0.00735588f, -0.02412817f, -0.03086239f, 0.01440843f, 
    -0.00155333f, 0.02902642f, 0.01655226f, -0.00173537f, -0.00162895f, -0.03206301f, -0.03359155f, -0.03155994f, 
    -0.03654530f, 0.02043040f, 0.01527612f, 0.02401059f, 0.02607828f, -0.01740189f, -0.00453428f, 0.02122450f, 
    0.02794229f, 0.00201934f, -0.03005722f, 0.01265097f, 0.00381806f, -0.00309165f, 0.00054104f, 0.02848405f, 
    -0.03993341f, -0.02636544f, -0.00140553f, -0.00837604f, -0.04757481f, -0.03585855f, 0.03964278f, -0.02022738f, 
    -0.02587749f, -0.01636200f, -0.03522025f, -0.03229811f, 0.01795759f, 0.00992906f, -0.02927943f, -0.03719106f, 
    -0.00238948f, 0.00159417f, -0.03885012f, -0.03876042f, 0.01223704f, -0.00078750f, 0.00633151f, -0.01439555f, 
    0.00987785f, 0.03299112f, -0.02180766f, -0.00555806f, -0.00287683f, 0.02790446f, -0.00629146f, -0.01054635f, 
    -0.01234413f, 0.00817008f, -0.03495404f, 0.02581291f, -0.04542144f, -0.03568378f, 0.02309366f, -0.02173514f, 
    0.00653906f, 0.01845759f, -0.00182338f, 0.00601204f, -0.02473753f, 0.01237926f, -0.00245096f, 0.02519939f, 
    -0.02069809f, 0.00037500f, 0.00746634f, -0.02807823f, 0.01846254f, 0.00264896f, 0.00682616f, 0.01110855f, 
    -0.03804602f, 0.01854214f, 0.00085515f, 0.03749643f, 0.03379406f, -0.03760860f, 0.01645106f, 0.01030095f, 
    0.02562509f, -0.02515567f, -0.03910663f, -0.02332641f, 0.00978557f, 0.02225405f, -0.03351055f, -0.03620610f, 
    -0.02530356f, -0.02308080f, 0.02055717f, -0.02627584f, -0.03997228f, -0.02092298f, 0.02316002f, -0.02105553f, 
    0.02383617f, -0.00428055f, -0.00158471f, -0.00819570f, 0.01856298f, 0.00498608f, -0.04190046f, -0.00959909f, 
    -0.03375731f, -0.01580089f, -0.01151572f, 0.01746039f, 0.02070803f, 0.02814328f, -0.00010313f, 0.01793612f, 
    0.00903062f, 0.02357285f, -0.01773539f, -0.02659101f, -0.01498938f, 0.01669665f, 0.00634416f, -0.00263076f, 
    -0.00027067f, 0.00736542f, 0.02608412f, -0.01304281f, 0.01563593f, 0.01184943f, -0.03682268f, 0.00100956f, 
    0.00203831f, 0.01843632f, 0.01490945f, -0.02308441f, 0.02417506f, -0.03116006f, -0.02399767f, 0.02707095f, 
    0.01539839f, -0.02729890f, -0.02821495f, -0.03296604f, 0.00891008f, -0.01513052f, -0.02792083f, -0.01790350f, 
    0.00118967f, 0.00371895f, 0.02722858f, 0.02793353f, 0.01812754f, -0.02636260f, -0.01277144f, 0.00506685f, 
    -0.00149302f, 0.02412680f, 0.01806347f, -0.02835405f, -0.02052145f, -0.02040795f, -0.02861078f, -0.02976136f, 
    -0.00701101f, 0.02187467f, 0.00229799f, -0.03711255f, 0.00610767f, -0.03873777f, -0.04332001f, 0.00600208f, 
    0.03010924f, 0.03719079f, 0.03470584f, 0.02521893f, 0.00071820f, 0.01453800f, -0.02218438f, 0.01205082f, 
    -0.00151488f, 0.01481023f, -0.02879971f, -0.01578523f, -0.02588713f, -0.00397343f, -0.01282907f, 0.00651529f, 
    -0.02717124f, 0.01607620f, 0.00487115f, 0.03044312f, -0.04747837f, 0.01193649f, 0.00649910f, -0.00524195f, 
    -0.03004913f, -0.02100213f, -0.01313542f, -0.01320399f, 0.02167375f, 0.02356322f, 0.02357804f, -0.03915304f, 
    -0.01919134f, 0.00537655f, 0.01614855f, 0.02253300f, 0.01140584f, -0.03675336f, 0.03120817f, -0.03587513f, 
    -0.02489724f, 0.01418033f, -0.01429411f, 0.00224722f, -0.03234220f, -0.03373589f, 0.00982382f, 0.01665558f, 
    -0.02050916f, -0.03078052f, -0.03648686f, 0.03213767f, -0.03275446f, 0.00012987f, 0.00027825f, 0.01652198f, 
    0.05595035f, 0.01266238f, -0.02174867f, 0.07964915f, -0.01631850f, -0.01365319f, -0.05171302f, -0.12542719f, 
    0.16789407f, -0.08764143f, -0.04894676f, -0.23113354f, 0.22211362f, 0.09712596f, 0.37957805f, 0.04286495f, 
    0.14478549f, -0.26177397f, 0.11593538f, 0.22203165f, 0.17883621f, -0.03428117f, -0.15129316f, -0.22961701f, 
    -0.19227496f, 0.05328746f, -0.07676538f, -0.02665462f, 0.05498075f, -0.00271075f, 0.05749476f, -0.02810071f, 
    -0.03371063f, -0.00974411f, 0.09164587f, 0.13717176f, 0.20826483f, -0.17710592f, 0.22062083f, 0.03047424f, 
    0.05866385f, -0.10014099f, -0.02013717f, -0.16453771f, 0.00436095f, 0.10495866f, -0.12878768f, 0.04534423f, 
    0.16900490f, 0.26572606f, 0.14132914f, -0.27657050f, 0.09634476f, -0.03983212f, 0.34970123f, 0.02501826f, 
    0.12122165f, -0.01911329f, 0.11595792f, 0.09239873f, 0.27447078f, 0.18542610f, 0.24957997f, -0.03643064f, 
    0.21770799f, 0.03104019f, 0.09468536f, 0.16644733f, 0.02937317f, -0.00444236f, -0.08538122f, 0.05814041f, 
    -0.33295351f, 0.01245589f, 0.11849581f, 0.25988942f, 0.08642790f, 0.07609255f, -0.02957486f, 0.14323199f, 
    -0.15052681f, -0.06338132f, -0.17142089f, -0.36571261f, -0.18954918f, -0.44002309f, -0.23336354f, -0.00828586f, 
    0.13045774f, 0.15123926f, 0.05195361f, -0.04263018f, 0.10165673f, 0.10670905f, 0.16559005f, 0.04190480f, 
    0.23068188f, -0.22288664f, -0.16910525f, -0.33857194f, -0.01618985f, 0.04152711f, 0.09663321f, 0.18085407f, 
    0.07015907f, -0.00876117f, 0.00291011f, 0.06583691f, 0.01972662f, 0.00558439f, 0.02319918f, -0.08961272f, 
    -0.06957694f, -0.01237610f, -0.13980143f, -0.00174363f, 0.17659864f, -0.07433356f, 0.04733621f, 0.17363092f, 
    0.10359085f, -0.10400720f, 0.11155063f, -0.08098934f, -0.01389077f, -0.09151572f, -0.05062455f, -0.13296457f, 
    -0.10967077f, -0.09647102f, 0.08494471f, 0.03912321f, -0.03209202f, -0.19585940f, -0.43995133f, -0.18130594f, 
    0.08741387f, 0.07951991f, 0.12028912f, -0.02986062f, 0.13896087f, 0.04039578f, -0.14670001f, 0.04920641f, 
    -0.00639787f, -0.03281572f, -0.12080313f, 0.05063073f, 0.06947037f, 0.11734802f, -0.06658907f, -0.15455934f, 
    0.13197054f, 0.01415143f, 0.10389151f, 0.27945715f, 0.70561719f, -0.12937507f, 0.14687862f, -0.43797803f, 
    0.09504359f, 0.07990497f, -0.19267188f, -0.09713212f, 0.04644549f, 0.10062458f, 0.08289906f, 0.12677971f, 
    -0.05491753f, -0.07343674f, -0.07135465f, -0.20232314f, -0.18150333f, 0.08400267f, 0.19858077f, 0.36198607f, 
    0.08232899f, 0.16559899f, 0.13122834f, -0.00600426f, 0.21826088f, 0.00270162f, -0.21030459f, -0.02706746f, 
    0.23955454f, 0.01974053f, 0.23952794f, -0.02743950f, -0.04164513f, 0.03671679f, 0.05252608f, 0.09857518f, 
    0.16523904f, -0.05746191f, -0.01362303f, -0.06241322f, 0.19865343f, 0.27328858f, -0.00543035f, 0.25326139f, 
    0.02882127f, 0.03708406f, 0.03232392f, -0.04032903f, 0.36723450f, -0.02978017f, -0.14473607f, -0.00633882f, 
    0.00457318f, -0.02328591f, -0.03150877f, -0.01677204f, -0.16532239f, -0.13881001f, -0.20521955f, -0.38076296f, 
    0.01140834f, -0.17455384f, -0.25460935f, -0.08984829f, 0.11531667f, 0.05154913f, 0.19583806f, -0.04402724f, 
    -0.06368690f, 0.08627994f, 0.02309783f, 0.01979749f, 0.24654143f, -0.16789187f, -0.01823550f, 0.05403708f, 
    0.08776431f, -0.05655520f, -0.16813710f, 0.02770456f, 0.02561024f, 0.00460911f, -0.10872925f, -0.06865184f, 
    0.45781010f, -0.02802391f, -0.34392846f, -0.15480720f, 0.12953247f, 0.11706534f, 0.17873000f, -0.04379661f, 
    -0.00643356f, -0.16465317f, -0.01798257f, 0.07030784f, 0.31884480f, -0.27327827f, -0.15250932f, -0.03138354f, 
    0.03936626f, 0.11980653f, 0.21046574f, 0.03385701f, 0.08013344f, -0.02345746f, 0.04498868f, 0.05864568f, 
    -0.02467492f, 0.06142046f, -0.08918247f, 0.01882644f, 0.08349380f, 0.14965692f, -0.04943258f, -0.03533134f, 
    -0.02453528f, 0.04270191f, 0.02918820f, 0.20358635f, 0.01796087f, -0.19838512f, -0.30140194f, -0.25469479f, 
    0.20307608f, 0.10085522f, 0.13373521f, 0.20534562f, -0.00224682f, -0.09868933f, 0.11457834f, -0.06035883f, 
    0.23757261f, 0.19062485f, -0.17663486f, -0.12607880f, 0.12311555f, 0.06043475f, 0.10427163f, 0.06238403f, 
    -0.04799495f, 0.02599806f, 0.01187584f, 0.09786255f, 0.28186545f, -0.06492198f, -0.00066739f, 0.20016359f, 
    0.05043241f, -0.10477849f, 0.02692357f, -0.23903313f, 0.20351209f, -0.01229689f, -0.05008071f, -0.01817156f, 
    0.12244869f, -0.01851454f, -0.02587923f, -0.27787352f, 0.36282489f, -0.09967742f, 0.01848511f, 0.18383014f, 
    -0.16936083f, 0.07852024f, 0.16750632f, -0.15078150f, 0.43497980f, -0.05474314f, 0.12403877f, -0.40770242f, 
    0.00583873f, 0.32610881f, 0.12316450f, -0.01631761f, 0.10459601f, 0.12639345f, 0.07674635f, 0.05333534f, 
    0.02688614f, 0.25059140f, -0.13206188f, 0.12529019f, -0.15787016f, 0.06135115f, 0.02754562f, 0.19540201f, 
    -0.06562496f, -0.01425773f, -0.05007508f, -0.07823538f, 0.03471790f, 0.35826057f, 0.08897729f, -0.00550324f, 
    -0.07209723f, 0.10117528f, 0.09447972f, 0.23508911f, 0.04282320f, -0.02757232f, -0.02443074f, 0.06702481f, 
    0.17896144f, -0.12695147f, 0.13979846f, -0.18462236f, 0.02374715f, -0.04620916f, -0.04515555f, -0.14017345f, 
    0.13502483f, 0.21966298f, 0.20070942f, 0.05784325f, 0.16506633f, 0.01785286f, -0.05464697f, -0.11650237f, 
    -0.06592817f, -0.02413060f, -0.03177155f, -0.08357806f, -0.07564405f, 0.00476571f, 0.23718612f, 0.01797637f, 
    -0.30760568f, 0.08908413f, -0.01115165f, 0.01034947f, 0.02140991f, 0.08563774f, -0.09537342f, -0.06676289f, 
    0.09562976f, -0.02856888f, 0.04648896f, 0.06074766f, -0.17257422f, 0.18665679f, 0.06598548f, 0.12557697f, 
    -0.08954389f, 0.02705338f, -0.06443408f, -0.04723475f, 0.16442974f, -0.17353423f, 0.04207786f, 0.04949237f, 
    -0.46266419f, 0.24355260f, -0.23900443f, 0.29711738f, -0.01224061f, -0.08817370f, 0.05126199f, 0.27281949f, 
    0.00713711f, 0.01334725f, 0.03360620f, 0.01609271f, -0.04672736f, -0.23666093f, -0.18034171f, -0.05436147f, 
    0.07047834f, 0.13010658f, 0.11931758f, 0.25652477f, -0.09641592f, -0.07804139f, 0.10537601f, -0.11494076f, 
    -0.05143509f, -0.05076165f, -0.00430023f, 0.02519240f, -0.06983351f, -0.08731077f, 0.07544322f, 0.04884492f, 
    0.09180130f, 0.01824159f, 0.01734017f, -0.02014107f, 0.49463421f, 0.00638966f, -0.18174118f, -0.09617127f, 
    -0.03415391f, -0.02017382f, 0.12916814f, -0.18619220f, -0.09839794f, -0.22254734f, -0.01896419f, 0.01364854f, 
    0.34594509f, 0.34221357f, 0.10369992f, -0.32074818f, 0.06970350f, -0.07433145f, 0.08084989f, 0.17276679f, 
    0.07928295f, -0.01907227f, -0.10327321f, 0.04597678f, 0.27654570f, 0.06677922f, -0.20174816f, 0.14575413f, 
    0.12876511f, 0.07678753f, 0.03474114f, 0.04581881f, 0.01266169f, -0.05180496f, -0.01662030f, 0.06002119f, 
    0.09357039f, -0.14658360f, -0.05592135f, -0.06097227f, -0.03419239f, -0.04873182f, 0.10114750f, 0.02527079f, 
    0.02489981f, 0.15252624f, 0.05683402f, 0.03692940f, 0.07967750f, 0.06147538f, 0.05159866f, 0.19937129f, 
    -0.05548151f, -0.04463233f, -0.02874707f, -0.01009254f, 0.08449093f, 0.02922760f, -0.01289875f, 0.11538853f, 
    0.15488286f, -0.23943251f, 0.26051757f, -0.24233869f, -0.06881733f, 0.03263490f, -0.05790023f, -0.09584035f, 
    0.05587583f, 0.04792298f, 0.04330707f, -0.01228873f, -0.20766863f, 0.15269400f, 0.05779772f, 0.16414313f, 
    -0.03382858f, -0.23023564f, -0.24384674f, 0.03721408f, -0.01538807f, -0.06211405f, 0.00716193f, -0.01559459f, 
    0.07470981f, 0.05246488f, -0.23781098f, 0.10978466f, 0.03939184f, 0.08357611f, -0.12750466f, 0.16818231f, 
    -0.04257020f, -0.14282082f, -0.04942146f, 0.08617957f, -0.21216594f, -0.04210027f, 0.07603009f, 0.01522588f, 
    0.05500725f, 0.00866647f, -0.03598708f, -0.04457569f, 0.03131722f, -0.00389097f, -0.07545353f, 0.18473825f, 
    0.08184151f, -0.04873296f, -0.18759696f, -0.06990823f, 0.17011538f, 0.12796509f, 0.09444985f, 0.03541627f, 
    0.01583546f, 0.02047033f, 0.08292925f, 0.09202455f, -0.02665738f, 0.00334858f, -0.01285270f, 0.05403937f, 
    0.01353771f, 0.00116865f, -0.13507855f, -0.01702866f, -0.01492599f, 0.05276150f, 0.04457708f, 0.04581976f, 
    0.08778492f, 0.03598044f, -0.12681709f, -0.01046211f, 0.16295831f, 0.19299112f, -0.03010513f, 0.19156779f, 
    -0.00488752f, -0.01051699f, 0.04569193f, -0.00284353f, -0.06174999f, 0.00776217f, -0.09626915f, 0.03356874f, 
    0.01433766f, 0.17884155f, -0.25606844f, 0.12554665f, -0.09526802f, -0.02946158f, 0.04978630f, 0.17408435f, 
    -0.13723978f, -0.46464586f, -0.17447735f, -0.14899483f, -0.06460554f, 0.13405108f, 0.10265239f, 0.15646663f, 
    0.32361668f, 0.04911735f, 0.02915791f, 0.00165689f, -0.09242432f, 0.21914914f, -0.27211303f, 0.43931606f, 
    -0.05646148f, -0.10016689f, 0.31996387f, -0.01871831f, -0.14156972f, 0.09004673f, -0.03079884f, 0.09862117f, 
    -0.05346303f, -0.14578038f, 0.22363938f, -0.09835650f, 0.07686099f, 0.06079424f, -0.03144417f, -0.12262775f, 
    0.00855419f, -0.02713094f, -0.04875032f, 0.00638709f, -0.10139637f, 0.00933833f, 0.06136421f, -0.10580982f, 
    -0.06113280f, 0.10363484f, -0.06644144f, 0.09388608f, 0.09756098f, 0.09895495f, 0.08679762f, 0.12855309f, 
    0.16529568f, 0.00063260f, -0.15044828f, 0.02977950f, 0.13509057f, 0.03199296f, 0.11111063f, 0.22718336f, 
    0.00954466f, -0.01431442f, 0.05031357f, 0.04780500f, -0.38582999f, -0.00788497f, 0.05768099f, 0.02778032f, 
    -0.11210255f, -0.06651462f, 0.04809050f, -0.03885995f, 0.08428694f, 0.00822948f, -0.06994283f, 0.09214038f, 
    0.00337985f, 0.06027495f, 0.26654625f, 0.08014255f, 0.03954190f, -0.00352791f, -0.01737707f, -0.03032293f, 
    -0.12610778f, -0.09300084f, -0.16976497f, -0.12351717f, 0.02474390f, 0.07424615f, 0.12714155f, -0.08742642f, 
    -0.06643619f, -0.12297118f, -0.07757922f, 0.01241324f, 0.03927770f, 0.01023657f, 0.03684365f, -0.01437740f, 
    0.05452510f, 0.05091077f, 0.16852985f, -0.16868532f, -0.02979828f, -0.06862792f, -0.03065742f, -0.04996660f, 
    0.07617971f, -0.03963451f, 0.05776732f, -0.09827523f, 0.17283529f, 0.21809295f, 0.00910682f, -0.10213522f, 
    -0.04585371f, -0.05599529f, 0.03119634f, 0.05249111f, -0.01978402f, -0.07053852f, -0.12721714f, -0.02963481f, 
    0.23613174f, -0.66152489f, -0.14890434f, -0.22170618f, -0.02348094f, 0.03222617f, -0.08627754f, 0.09550498f, 
    0.12473866f, 0.03798805f, 0.05308028f, -0.16668727f, -0.21168658f, -0.02503585f, -0.13357203f, 0.02474009f, 
    -0.02009415f, 0.03401838f, 0.24887171f, 0.24244413f, 0.15941930f, 0.14568165f, 0.12723342f, 0.03178250f, 
    0.31120965f, 0.24028689f, -0.04222881f, -0.31549636f, 0.21330492f, 0.10645768f, -0.01692455f, 0.24097942f, 
    0.06430132f, -0.00606927f, 0.03719130f, 0.08960291f, -0.18862271f, 0.06145590f, 0.00269831f, 0.04293710f, 
    0.03697453f, 0.10046711f, 0.01529537f, 0.09793098f, -0.01951329f, 0.05801319f, -0.01378246f, -0.00546389f, 
    -0.02885230f, -0.00127713f, -0.03300992f, -0.00093474f, 0.03355301f, 0.01808043f, -0.02184424f, 0.01866518f, 
    -0.03749168f, -0.02001240f, -0.02930689f, 0.02713962f, -0.01358163f, 0.02696438f, 0.00270804f, -0.01740297f, 
    -0.00304418f, 0.00575617f, 0.01920166f, 0.03423319f, -0.02876733f, 0.00228206f, 0.02766364f, -0.02721337f, 
    0.01270348f, -0.01604294f, -0.03526707f, 0.01358242f, -0.01276279f, -0.00600080f, 0.00693091f, 0.02230403f, 
    -0.03035501f, -0.02729018f, 0.01347697f, -0.01787117f, -0.00028015f, -0.01184361f, 0.01219853f, -0.01571900f, 
    0.00839877f, 0.00679630f, 0.00543194f, -0.00608706f, 0.01448443f, 0.01541958f, -0.02270268f, -0.01658035f, 
    -0.03489273f, 0.00413209f, -0.02577291f, -0.00624050f, 0.00909458f, -0.02703967f, -0.00610375f, 0.00992781f, 
    -0.00260254f, -0.02361876f, 0.02137585f, -0.02829051f, -0.01672732f, -0.03060334f, 0.01024981f, -0.01177904f, 
    -0.00840249f, 0.00944799f, -0.01351476f, -0.03780922f, -0.02433220f, 0.01612726f, 0.00338907f, 0.03805433f, 
    -0.00079195f, 0.01801252f, 0.00804895f, 0.00110025f, 0.01874721f, 0.02778902f, 0.01623718f, 0.00311529f, 
    0.00237320f, -0.00009807f, 0.02318809f, -0.00399709f, -0.01698001f, -0.03350347f, -0.00527906f, -0.01015950f, 
    0.00030514f, -0.00482566f, -0.02246430f, -0.01659735f, -0.00487805f, 0.02860793f, -0.02790712f, -0.02467405f, 
    -0.01007762f, -0.02918242f, -0.03226315f, -0.01414297f, 0.01034669f, -0.03505587f, -0.03251404f, -0.01016747f, 
    -0.00895574f, -0.01968986f, -0.02888245f, 0.01481756f, 0.02698821f, 0.01631125f, 0.02039588f, 0.01836061f, 
    0.01162710f, 0.01407028f, -0.02002881f, -0.01889111f, -0.01099120f, -0.02460967f, -0.04040986f, 0.00262402f, 
    -0.03842228f, 0.01056523f, -0.02647275f, 0.02128083f, 0.01659121f, -0.02679027f, 0.01430613f, 0.00782011f, 
    0.02417840f, 0.00107565f, -0.03375932f, -0.00548945f, 0.00496880f, 0.01432196f, 0.02578109f, -0.02112153f, 
    -0.00514526f, -0.01847977f, 0.01769800f, 0.02564217f, -0.02740792f, 0.03837637f, -0.01343656f, -0.02032288f, 
    -0.01508225f, -0.01053574f, -0.01215746f, 0.02791927f, -0.00421233f, 0.01317740f, 0.00976085f, -0.01801287f, 
    0.01518741f, 0.01760485f, -0.03812539f, -0.00618763f, -0.01379093f, -0.02312530f, -0.01196857f, -0.00571925f, 
    -0.00285787f, -0.03468496f, 0.02796652f, 0.01451461f, 0.01255899f, 0.00466608f, -0.03596263f, 0.01062529f, 
    0.01974621f, 0.00435726f, 0.00262157f, 0.01279289f, 0.01142913f, -0.00394698f, 0.01359485f, -0.03620957f, 
    -0.02980295f, 0.03517838f, 0.03184611f, 0.01354872f, -0.01702787f, -0.01036352f, -0.01538168f, -0.00308500f, 
    0.01531967f, -0.01668555f, 0.00636422f, 0.02763111f, -0.03732571f, -0.02332480f, -0.03968289f, -0.02959984f, 
    0.01794181f, -0.03115743f, -0.03913316f, 0.02586567f, -0.03582321f, 0.01757533f, 0.00683706f, 0.02340737f, 
    -0.02179624f, 0.00662067f, -0.02924568f, -0.01642153f, -0.02787834f, 0.01457160f, -0.02077764f, -0.00560956f, 
    -0.00410408f, 0.03246576f, 0.00590817f, -0.02518252f, -0.00139996f, 0.03518945f, -0.00151176f, -0.00973175f, 
    0.00639340f, -0.01981780f, 0.01931012f, -0.02765484f, -0.01109577f, -0.01645969f, -0.01551067f, 0.02749803f, 
    -0.02306432f, -0.00041085f, -0.02978590f, -0.02209278f, 0.00733374f, -0.02216507f, 0.01960301f, -0.01113481f, 
    -0.02021731f, -0.04119288f, -0.02913642f, -0.00831022f, 0.03687185f, 0.01149101f, 0.03016648f, 0.01510419f, 
    -0.00253109f, -0.00827995f, -0.03136904f, -0.01595535f, -0.02998156f, 0.01718595f, 0.00415734f, -0.00118472f, 
    0.00095360f, 0.02885972f, 0.03780933f, -0.01957176f, -0.01519833f, 0.00028120f, -0.03124548f, -0.01041441f, 
    -0.02305280f, -0.02606864f, -0.02263704f, -0.00809846f, -0.02327368f, -0.04164707f, -0.03376757f, -0.01252244f, 
    -0.01545490f, 0.01245153f, 0.02753375f, -0.03749118f, -0.00180624f, -0.00091361f, 0.00953657f, -0.00225201f, 
    -0.02389058f, 0.01291872f, -0.00500433f, 0.02588240f, 0.01672208f, 0.01936383f, -0.02365629f, -0.04177044f, 
    0.04073481f, -0.03537853f, -0.00702176f, -0.01571270f, 0.00209379f, -0.03817299f, -0.00161114f, -0.02487485f, 
    -0.02823798f, -0.02887176f, -0.02204566f, 0.00215823f, -0.02107162f, 0.00991797f, -0.01449750f, 0.01125904f, 
    0.02545060f, 0.02744959f, 0.03323429f, 0.02551444f, -0.00845225f, 0.02504168f, 0.01727047f, 0.01557173f, 
    0.00406023f, 0.00090781f, -0.00501174f, -0.01453405f, 0.00294463f, -0.01991659f, 0.02742613f, -0.02471013f, 
    -0.03024936f, -0.03993302f, 0.00818340f, -0.03802102f, -0.02833235f, 0.02361684f, 0.01281176f, -0.02963517f, 
    -0.02089746f, -0.00767475f, -0.02405430f, -0.03801354f, 0.00941939f, 0.00435201f, -0.01600590f, -0.00055026f, 
    -0.01451614f, -0.02540838f, -0.00264073f, 0.00130015f, -0.03425271f, -0.02934049f, 0.02163217f, -0.01303039f, 
    0.00219278f, -0.03674071f, -0.00236711f, -0.02127882f, 0.02256396f, -0.01228622f, 0.02846608f, 0.01510778f, 
    0.00564018f, 0.02408361f, 0.01220942f, 0.00620664f, -0.03259368f, 0.01399671f, -0.00001535f, -0.00309851f, 
    -0.01262543f, -0.02418059f, 0.00659061f, -0.01916028f, 0.03565589f, 0.00874245f, -0.02759350f, 0.01211524f, 
    -0.01778028f, -0.02534442f, -0.03135873f, -0.02963910f, -0.00359472f, 0.02546620f, -0.03391638f, 0.01733190f, 
    0.02372194f, -0.03268103f, 0.02621598f, 0.01273645f, -0.00726103f, -0.03512839f, -0.01208469f, -0.03952973f, 
    0.01143156f, 0.02056109f, 0.01343762f, 0.02929837f, -0.00053539f, -0.02140556f, 0.00208398f, -0.02208110f, 
    0.01140438f, -0.01015086f, -0.03435187f, -0.02989917f, -0.03070200f, 0.02746644f, -0.03806001f, 0.02780610f, 
    -0.00140909f, -0.01876862f, 0.00035528f, 0.00199855f, -0.00396109f, 0.02108697f, 0.01019028f, 0.02650577f, 
    -0.02240971f, 0.01182774f, 0.00635988f, -0.00640832f, -0.01569327f, -0.00274290f, 0.01815572f, -0.00746040f, 
    0.02621268f, 0.01704164f, 0.00810632f, 0.01284528f, -0.02007182f, 0.01586825f, 0.00720463f, 0.02291822f, 
    -0.00552266f, -0.02358729f, 0.01446568f, -0.01200547f, 0.02781288f, -0.00662156f, -0.03376327f, 0.01434363f, 
    -0.02337280f, -0.02081232f, 0.00525690f, -0.01100496f, -0.01316225f, 0.01054479f, -0.03574706f, 0.02201606f, 
    0.01193563f, -0.00196244f, 0.01596575f, 0.00028163f, -0.00176559f, 0.02563698f, 0.00583479f, 0.01058955f, 
    0.02836126f, -0.02056042f, -0.03032158f, 0.00012157f, 0.02949406f, 0.02684261f, -0.02884026f, -0.03468696f, 
    0.00017931f, 0.02051768f, -0.03893078f, -0.01382208f, -0.03264126f, -0.00629678f, 0.01817057f, -0.01427431f, 
    0.00670073f, -0.00155671f, -0.01241984f, 0.01239231f, -0.01084469f, -0.00426520f, -0.03302375f, -0.02713256f, 
    0.02994947f, 0.01712815f, -0.03042948f, 0.02154095f, 0.02920399f, 0.00863749f, -0.01670625f, -0.03022519f, 
    0.01659294f, -0.00361606f, 0.02585713f, -0.01154580f, 0.00346315f, 0.02604064f, -0.00702218f, -0.02214469f, 
    0.00910516f, 0.01482117f, 0.00579047f, -0.03269712f, -0.02456718f, -0.02903856f, 0.00061447f, -0.02961634f, 
    -0.00793131f, -0.03415616f, -0.01546143f, 0.02237687f, -0.04074806f, -0.01791323f, -0.00318545f, -0.01042722f, 
    -0.01449731f, 0.00503597f, 0.02099155f, 0.03408429f, 0.02368464f, -0.02766821f, -0.01051942f, 0.00235611f, 
    -0.01706575f, -0.01183287f, -0.03026483f, -0.01520119f, -0.03960612f, 0.02250412f, -0.00226458f, -0.01086458f, 
    0.00199885f, -0.00635797f, -0.00778013f, -0.01638119f, -0.03685248f, 0.00121327f, -0.03876759f, -0.02328713f, 
    -0.01926354f, 0.00296782f, 0.02080258f, -0.03621523f, -0.04054347f, 0.01396307f, -0.00166219f, -0.03319935f, 
    -0.03900759f, -0.02570183f, -0.02011272f, -0.02933897f, 0.01969197f, -0.00971621f, -0.02043987f, -0.02445387f, 
    -0.01428749f, -0.02468711f, -0.02215378f, 0.00500872f, -0.04032082f, -0.03889717f, 0.02689733f, -0.04075201f, 
    -0.04072748f, 0.00313264f, -0.01390782f, 0.03885665f, 0.01826481f, -0.00090325f, 0.02232829f, -0.01607363f, 
    0.01397644f, -0.00420139f, 0.00605879f, -0.00885953f, -0.03203712f, 0.01963535f, 0.01639248f, 0.02555395f, 
    -0.02118131f, -0.01945647f, -0.02552107f, 0.00442598f, 0.00448803f, 0.01627600f, 0.01282066f, -0.01485581f, 
    0.00850588f, -0.01743875f, 0.02538667f, 0.00561365f, 0.02083317f, -0.00066441f, -0.01080569f, 0.00822965f, 
    -0.00654508f, -0.01643846f, 0.02777357f, -0.03141923f, -0.02910236f, -0.03659561f, -0.02138265f, 0.02214250f, 
    0.02452075f, 0.00763058f, 0.00274079f, 0.01405089f, 0.01016596f, -0.00706988f, 0.02646701f, -0.01574104f, 
    0.00295587f, 0.00857269f, -0.01605461f, -0.01193524f, -0.02823713f, -0.04168061f, -0.03664298f, -0.02968890f, 
    -0.02737281f, 0.00604281f, -0.01414916f, -0.02010484f, 0.01632715f, 0.02477787f, -0.01001611f, 0.02599549f, 
    -0.02111224f, -0.02735895f, 0.00802600f, -0.02647373f, 0.02649343f, 0.00087732f, -0.03364424f, 0.01171142f, 
    -0.00015342f, 0.00285246f, -0.02248833f, 0.00514606f, -0.02294557f, 0.00726015f, 0.00939485f, 0.02402811f, 
    -0.00827479f, -0.00496205f, -0.00586706f, -0.02907302f, 0.01387981f, 0.01327769f, 0.02126195f, 0.00976367f, 
    -0.02032964f, -0.04085614f, 0.02973772f, 0.01682539f, -0.02363746f, -0.02930567f, 0.00760184f, -0.00459819f, 
    0.01598134f, -0.02161467f, -0.00533600f, -0.01329713f, 0.02128478f, -0.01488256f, 0.01341007f, 0.02504262f, 
    -0.01067200f, -0.02399017f, -0.03945272f, -0.03410562f, -0.01625404f, -0.04134797f, 0.00663407f, 0.02738297f, 
    -0.02718829f, -0.01465607f, -0.02649852f, -0.03772911f, -0.02318199f, -0.00058450f, -0.00463923f, -0.03102654f, 
    0.02699997f, 0.01460014f, 0.03400795f, -0.03342135f, 0.01251546f, 0.02302635f, 0.00109228f, -0.02818541f, 
    -0.02228414f, 0.02175017f, -0.03692039f, -0.03853718f, -0.01607659f, -0.02436664f, -0.02177778f, 0.02394568f, 
    0.01096259f, -0.03204571f, -0.02181734f, 0.04170854f, 0.00763696f, -0.03370067f, 0.02004706f, -0.02660986f, 
    -0.02403466f, -0.00684931f, 0.00617056f, -0.00496631f, 0.00829755f, 0.00297440f, -0.02544172f, 0.00433499f, 
    -0.03578163f, 0.01526206f, 0.03644418f, -0.02070906f, -0.02708381f, 0.01853796f, -0.03468229f, -0.00361984f, 
    -0.03294839f, -0.01771408f, -0.02427884f, -0.02430635f, -0.03654624f, 0.00322868f, 0.01670639f, 0.01717049f, 
    0.01039247f, -0.00867957f, -0.03207654f, -0.02311374f, 0.01712201f, 0.03418001f, -0.01937913f, -0.02817217f, 
    -0.04203202f, 0.02699722f, -0.03331635f, 0.02413181f, -0.01771110f, -0.01285561f, 0.01359503f, 0.03044867f, 
    0.01649113f, -0.00510388f, 0.00572468f, 0.00189246f, -0.00800693f, -0.02289883f, -0.02953225f, -0.01259672f, 
    -0.03892604f, 0.02235222f, 0.02089420f, 0.00782207f, -0.02908053f, 0.02904956f, 0.00296828f, 0.01635344f, 
    0.00953775f, 0.01434953f, 0.02824773f, 0.00265232f, 0.01439173f, -0.00207654f, -0.03235122f, 0.00080429f, 
    0.02378287f, -0.02161959f, 0.02869541f, -0.00682001f, -0.00796772f, 0.01344810f, -0.02602584f, -0.00609974f, 
    0.00354335f, 0.00657567f, 0.00493658f, -0.00102310f, -0.02729138f, 0.00914885f, 0.01310906f, 0.00038639f, 
    0.01360659f, -0.02700458f, 0.03032028f, 0.00197306f, -0.02754557f, 0.01890889f, -0.01663492f, -0.01160148f, 
    0.02091954f, -0.03517411f, 0.02839955f, -0.00684881f, -0.01387497f, -0.02481714f, 0.00552976f, -0.02313870f, 
    -0.01132361f, -0.03307502f, 0.00831989f, 0.00313977f, 0.00126644f, -0.03430883f, 0.01496516f, 0.01959197f, 
    0.00358513f, -0.00867158f, 0.01937605f, -0.03209643f, -0.01959212f, -0.01449130f, 0.02202139f, -0.02624369f, 
    -0.03835259f, 0.03181159f, -0.03205100f, -0.03170354f, -0.03014002f, 0.02483287f, -0.02867696f, -0.03093389f, 
    0.00676077f, -0.02730943f, 0.01620614f, -0.01997656f, -0.00295379f, 0.03312811f, -0.00354219f, 0.01701418f, 
    -0.01646597f, 0.01226503f, 0.02635682f, -0.02118570f, 0.01857338f, -0.00271784f, 0.00606187f, 0.01163622f, 
    -0.02988546f, 0.00757190f, 0.02709439f, -0.02772416f, 0.01619391f, -0.01352053f, 0.02330180f, 0.01478854f, 
    0.02029999f, 0.01307959f, -0.01419169f, -0.03512793f, -0.01208667f, -0.01190481f, -0.02418768f, -0.02134988f, 
    -0.01316279f, -0.03884287f, -0.01769831f, 0.01290917f, -0.03851853f, 0.03455809f, 0.01271652f, -0.02135263f, 
    -0.01953750f, 0.02594445f, -0.02376481f, 0.01750267f, 0.00223342f, -0.00567866f, -0.01906483f, -0.03767316f, 
    -0.00018851f, -0.00839792f, 0.01114097f, 0.01361219f, -0.03237765f, -0.01542109f, -0.03622188f, -0.03218453f, 
    -0.03485079f, -0.01714163f, 0.01632418f, -0.03254545f, -0.03163300f, 0.00186984f, -0.01841543f, 0.02519326f, 
    0.02128052f, -0.02811442f, -0.02128228f, 0.01602599f, -0.03394326f, -0.03196833f, -0.01629434f, 0.00718635f, 
    0.01208378f, -0.01568100f, -0.00903466f, 0.00623949f, -0.02557841f, -0.03153585f, -0.02078142f, -0.03767536f, 
    0.02664345f, -0.03302885f, 0.02185155f, 0.01504500f, -0.01964448f, -0.01475330f, 0.03089541f, -0.03220667f, 
    -0.00447453f, -0.01197337f, -0.03066201f, -0.00243937f, -0.00104208f, 0.02375295f, -0.03280767f, 0.02753322f, 
    0.01036622f, 0.00702585f, 0.02398438f, 0.00665389f, -0.03688454f, -0.00808366f, -0.00665633f, 0.02691303f, 
    -0.00561691f, 0.01230711f, -0.00847084f, -0.00102876f, 0.01825514f, -0.00771730f, -0.03251369f, 0.01032166f, 
    -0.01230282f, -0.00745397f, 0.01128200f, -0.03451005f, 0.01684895f, 0.02315024f, 0.01224280f, -0.01047931f, 
    -0.00313091f, 0.01412077f, -0.00733173f, 0.00414290f, 0.03027765f, 0.00858270f, -0.00149797f, -0.03024162f, 
    0.00083848f, 0.02281010f, 0.01862635f, -0.00493363f, -0.01974736f, -0.01667066f, -0.03762970f, 0.02978501f, 
    0.01133041f, -0.00409725f, 0.02613077f, 0.01446997f, 0.01514994f, -0.03177070f, -0.04339741f, 0.01386741f, 
    0.01588763f, 0.01910058f, -0.03805940f, -0.00031325f, -0.03118322f, 0.00785674f, -0.02784863f, -0.00620974f, 
    0.00786798f, 0.01722847f, -0.03285395f, 0.01025210f, -0.03885760f, 0.01284582f, 0.02344776f, 0.02145406f, 
    -0.00692995f, 0.01300364f, -0.02938812f, 0.02928231f, 0.00131516f, -0.01605014f, -0.00040742f, 0.00983788f, 
    0.03419071f, 0.01498152f, 0.00056311f, 0.02246680f, 0.01882842f, -0.00628335f, -0.01277776f, -0.04285051f, 
    -0.00046012f, -0.02233403f, -0.00105065f, -0.02876900f, 0.02620056f, 0.00483705f, -0.02723969f, 0.01153017f, 
    0.01729066f, -0.00916006f, 0.00220497f, -0.03654629f, -0.03606354f, -0.00647157f, -0.00892866f, 0.01478740f, 
    -0.00402832f, -0.02584796f, -0.01223065f, 0.00643821f, -0.03170508f, -0.02435915f, -0.01514072f, -0.02754017f, 
    -0.02714581f, 0.00611270f, -0.03036838f, 0.01411276f, 0.02416603f, 0.02014708f, -0.01607552f, -0.02490357f, 
    -0.02261973f, -0.03204494f, -0.01275709f, -0.00376384f, 0.00255350f, -0.01926124f, -0.03783793f, 0.00747742f, 
    0.00150129f, -0.01098690f, -0.02601089f, -0.03440301f, -0.03413752f, 0.00021875f, 0.00922545f, -0.03700100f, 
    -0.03642885f, 0.00734920f, 0.02437034f, -0.00828943f, 0.00929282f, 0.01208162f, -0.01743214f, -0.01439404f, 
    0.00242693f, -0.02949660f, -0.03151227f, -0.03582092f, 0.02555976f, -0.00679714f, 0.01358350f, -0.04497215f, 
    -0.03389243f, -0.00554409f, -0.00627647f, -0.00887933f, -0.01508859f, -0.00291438f, -0.01348168f, -0.03103247f, 
    -0.01245598f, -0.03872173f, -0.03531957f, -0.00286260f, -0.00266480f, 0.01477992f, 0.02937744f, 0.01060047f, 
    0.02480768f, -0.00551384f, -0.00518363f, 0.00333557f, 0.01184692f, -0.03635075f, -0.03744633f, -0.02773195f, 
    -0.01280568f, -0.00535349f, -0.01541350f, 0.02082196f, 0.02701618f, -0.01142546f, -0.02236128f, 0.02157931f, 
    0.01417108f, -0.03005285f, -0.02179887f, -0.01642622f, -0.00899867f, -0.01232539f, -0.01028765f, 0.01824403f, 
    -0.02136736f, 0.00881423f, -0.03781971f, -0.01747725f, -0.04399858f, -0.02854784f, -0.01342581f, -0.03892649f, 
    0.00168809f, -0.00147520f, -0.02235824f, -0.01723954f, 0.01885341f, -0.01541711f, 0.02262119f, 0.01953655f, 
    -0.04268840f, 0.01003475f, 0.01017675f, -0.03830152f, -0.00757184f, -0.00273578f, 0.00407873f, 0.02522087f, 
    0.00659589f, 0.00079639f, 0.02743144f, 0.00628152f, 0.00296477f, 0.00200500f, 0.02617644f, 0.01435805f, 
    0.01582760f, 0.02821399f, -0.03137678f, -0.00840973f, -0.01413983f, -0.00723361f, -0.03433388f, 0.02277440f, 
    -0.01323291f, 0.00767979f, -0.02170045f, 0.02314002f, 0.01612497f, -0.03046295f, -0.02697234f, -0.00178190f, 
    -0.01454065f, 0.00740218f, -0.03054222f, -0.03744849f, -0.03006739f, -0.00779581f, 0.00874521f, 0.00068083f, 
    0.03436730f, -0.00067742f, -0.02644877f, -0.01372200f, -0.02649327f, -0.02957787f, -0.00057640f, 0.00585293f, 
    -0.00409349f, 0.00334055f, -0.00009156f, -0.00214321f, 0.01985057f, 0.01550358f, -0.00113263f, -0.00576268f, 
    -0.01049725f, -0.00019187f, -0.00313457f, 0.01451187f, 0.01974439f, -0.01969296f, 0.01782753f, -0.03876057f, 
    -0.00880678f, 0.03197344f, -0.03713389f, -0.03360370f, -0.04160351f, 0.02511626f, -0.02256115f, 0.00196264f, 
    -0.00371365f, -0.00926223f, -0.03213182f, -0.02715760f, -0.00036652f, 0.03077112f, -0.00251756f, -0.02442673f, 
    0.03581312f, 0.00373661f, 0.02145292f, 0.02358085f, -0.02447562f, -0.02741855f, 0.03028191f, -0.01112870f, 
    0.00022650f, -0.02747793f, 0.02882934f, 0.02692128f, -0.01556211f, -0.02011310f, 0.00951912f, -0.02736431f, 
    0.03490044f, -0.01230707f, -0.02852052f, -0.01197671f, 0.02180258f, 0.01122794f, -0.01612159f, -0.01681345f, 
    -0.04082992f, 0.00013993f, -0.03991809f, -0.04090228f, 0.02672048f, -0.02952187f, 0.02539350f, -0.02613853f, 
    0.02676656f, 0.02137667f, -0.00523824f, 0.02391885f, -0.03653261f, -0.02103537f, -0.01215783f, -0.02152390f, 
    0.01329404f, -0.01540970f, 0.00186455f, -0.00308161f, 0.00020625f, 0.02152132f, 0.01563629f, 0.01971699f, 
    -0.03771087f, 0.00177703f, 0.00052903f, 0.03213162f, 0.00592026f, -0.01913048f, 0.00525832f, -0.01117261f, 
    -0.00843901f, 0.02561563f, 0.02006124f, -0.02770064f, 0.01390950f, 0.00061668f, 0.01203987f, -0.00052711f, 
    -0.03508275f, -0.00300962f, -0.00202335f, 0.01498405f, 0.01820029f, 0.02486390f, 0.02111153f, -0.01095807f, 
    -0.02988687f, -0.00146278f, 0.00686682f, -0.01266061f, 0.01960122f, 0.01953917f, -0.02194110f, 0.02989968f, 
    0.03342213f, 0.00020126f, -0.03677983f, 0.03014554f, -0.02830007f, 0.01082892f, -0.02408776f, -0.03247510f, 
    0.03415118f, 0.01784423f, 0.02705285f, -0.01077971f, 0.02625293f, -0.02925745f, -0.00802833f, 0.03541135f, 
    0.02059376f, -0.02555757f, 0.01418425f, 0.02429330f, -0.03376797f, -0.02441460f, -0.03211031f, 0.01574537f, 
    -0.02390276f, 0.00214841f, -0.01068529f, -0.03371582f, -0.02054365f, 0.02868103f, -0.00887255f, 0.00283257f, 
    -0.02668705f, 0.00317858f, -0.01253469f, 0.01611793f, -0.01376789f, 0.00197172f, 0.03589826f, 0.00915969f, 
    0.00054148f, 0.00095624f, 0.02930842f, -0.02077812f, 0.02678711f, 0.02502357f, 0.01171929f, 0.02693072f, 
    0.00170746f, -0.02509191f, 0.03324093f, 0.01732423f, 0.02986674f, 0.03018563f, 0.02362419f, 0.01514597f, 
    -0.01744132f, -0.04120686f, -0.01968931f, -0.02312706f, 0.02647411f, 0.00409915f, -0.01255933f, 0.01101617f, 
    -0.00360518f, 0.03134751f, 0.02967707f, -0.03442520f, -0.02435128f, -0.02633568f, -0.03918535f, -0.01061634f, 
    -0.02716133f, 0.01110996f, -0.01857305f, -0.02984703f, 0.00287825f, -0.00277127f, 0.02023828f, 0.02764504f, 
    0.01804649f, -0.03842898f, -0.03215935f, -0.02163444f, 0.01384710f, -0.03550363f, 0.01255487f, 0.00471725f, 
    0.02715906f, -0.00572812f, 0.00389271f, -0.00877514f, -0.01130745f, -0.01808585f, -0.01043911f, 0.02415170f, 
    0.00897352f, -0.00243152f, -0.02836248f, -0.00977347f, -0.01243473f, -0.00479011f, -0.01144435f, -0.04463708f, 
    -0.02956675f, -0.01546039f, 0.01858787f, -0.02490759f, -0.02062292f, 0.00579964f, -0.00403929f, -0.01958463f, 
    0.00022545f, -0.03310920f, 0.00679005f, -0.03040865f, -0.00041184f, -0.03112807f, -0.03891648f, 0.02212550f, 
    -0.01973522f, -0.03805280f, -0.03250648f, 0.02122177f, -0.00077860f, -0.03917554f, 0.00472277f, 0.00260355f, 
    -0.00648014f, 0.00359841f, -0.02292676f, -0.00683297f, -0.03141015f, 0.03208874f, 0.00544746f, 0.01999989f, 
    0.01691933f, 0.01145249f, 0.03048268f, 0.01420313f, 0.01551560f, 0.03288549f, 0.02517726f, 0.02627381f, 
    0.01200085f, 0.00312543f, 0.02864579f, 0.02954726f, -0.01456043f, -0.01917929f, -0.01234410f, -0.02255057f, 
    0.00167376f, -0.03946793f, 0.01426477f, 0.02996716f, -0.02207100f, -0.01139560f, -0.00566698f, 0.00391826f, 
    0.02674914f, -0.03246753f, -0.01590403f, 0.00299204f, -0.00943931f, 0.01656901f, -0.00661123f, 0.02903074f, 
    -0.00315323f, 0.00540019f, -0.03573395f, 0.00985288f, -0.03548976f, 0.00659581f, -0.02298450f, 0.01848371f, 
    0.01544342f, -0.01175394f, -0.02386545f, 0.01541147f, 0.01837539f, -0.01065621f, 0.02745252f, -0.02385495f, 
    -0.00653703f, -0.02347802f, -0.03078256f, 0.02699131f, -0.00987574f, 0.01236704f, 0.00694795f, -0.01446995f, 
    0.03122427f, -0.02275219f, 0.02934466f, -0.00773078f, -0.03211055f, 0.03105234f, -0.00246467f, 0.02128678f, 
    0.00951903f, -0.03114752f, -0.00667340f, 0.02159132f, -0.02993024f, 0.00334830f, 0.03001429f, 0.02788948f, 
    -0.01821387f, 0.01759467f, -0.02263403f, 0.00493752f, -0.02334505f, -0.01819499f, 0.00913912f, 0.01537200f, 
    -0.02120079f, 0.02036904f, -0.00554290f, -0.02521498f, -0.00318911f, 0.01649657f, 0.02397568f, -0.02876422f, 
    0.00036022f, 0.02719506f, -0.01238698f, 0.02952181f, 0.02686195f, -0.00393967f, 0.00060367f, 0.02680743f, 
    -0.03214610f, -0.02562016f, 0.01977306f, -0.02987249f, -0.01311078f, -0.02785865f, 0.01779919f, -0.00604458f, 
    -0.03744754f, 0.00978690f, 0.00209912f, -0.04165817f, -0.01967316f, -0.02555189f, -0.00875508f, 0.01197501f, 
    0.01874355f, -0.02928167f, 0.03124278f, 0.01874204f, 0.01155018f, -0.01373790f, -0.04355441f, 0.02822613f, 
    -0.00294673f, 0.01275542f, -0.01270333f, -0.02254856f, 0.00738879f, 0.01384141f, -0.03134864f, -0.01876361f, 
    -0.02970526f, 0.02854258f, -0.02026613f, 0.00845020f, 0.01406950f, 0.00919340f, -0.04080325f, 0.01297334f, 
    -0.36491853f, -0.00354530f, -0.04620958f, -0.07662068f, -0.01724593f, -0.04484557f, 0.02782467f, 0.03030645f, 
    0.18364465f, 0.17212094f, 0.04720892f, 0.17757177f, 0.36962393f, -0.12700216f, -0.02785171f, -0.05903418f, 
    -0.01671628f, 0.09524462f, 0.06365913f, -0.01148664f, 0.06591209f, -0.03479213f, 0.01739242f, 0.19858877f, 
    -0.05840885f, -0.05082553f, 0.07939211f, -0.16478705f, -0.05527876f, -0.01770807f, -0.15333635f, 0.07600839f, 
    -0.06057448f, -0.11168823f, 0.04902771f, -0.05086615f, 0.16214795f, 0.24340065f, -0.28593484f, 0.03949846f, 
    -0.05042439f, -0.15128341f, 0.02012729f, 0.01246869f, 0.10942602f, 0.14651304f, 0.04976349f, 0.01791546f, 
    0.05833546f, 0.08731788f, -0.32625329f, -0.07028237f, 0.07453518f, -0.11219280f, 0.07687724f, -0.14346302f, 
    -0.15403555f, -0.00246578f, 0.09377443f, -0.02547688f, 0.14543803f, -0.03812492f, -0.20744762f, -0.09031254f, 
    -0.08707570f, -0.01183767f, 0.05867077f, 0.06552597f, -0.05657719f, -0.02960278f, 0.00823089f, -0.08897289f, 
    0.23249847f, -0.10361551f, -0.00634841f, 0.12255398f, -0.08897723f, 0.15148127f, -0.05880516f, 0.11936629f, 
    -0.17319067f, -0.03741100f, 0.16839419f, 0.24329227f, 0.19544971f, 0.00343917f, 0.06019585f, 0.34545612f, 
    0.19161697f, 0.04932181f, 0.20990930f, 0.01008365f, 0.02077445f, 0.10994732f, -0.03570589f, 0.15045448f, 
    0.02610264f, 0.23531841f, 0.04060031f, -0.20441735f, 0.05960968f, 0.02499253f, -0.08344790f, 0.07536917f, 
    0.03782649f, -0.02955378f, -0.22557384f, -0.20790635f, -0.13202754f, -0.17964175f, 0.06337931f, -0.24284628f, 
    0.04916406f, -0.01790890f, 0.04738482f, 0.17952979f, -0.14749609f, -0.01769510f, 0.03475338f, -0.14849968f, 
    0.08349884f, -0.19588037f, 0.00186789f, -0.21437812f, -0.02650111f, 0.01375104f, -0.03511436f, -0.08008049f, 
    -0.00878952f, 0.08843804f, 0.05781733f, -0.05110905f, 0.03775049f, -0.23328267f, -0.00419715f, 0.00171457f, 
    0.06663635f, 0.19808072f, 0.07509123f, 0.13933024f, -0.03756971f, 0.05125448f, 0.00959516f, 0.06875879f, 
    -0.11924513f, 0.04446659f, -0.07263415f, -0.02351683f, 0.10033121f, 0.04559562f, -0.13402013f, -0.05331207f, 
    0.02876884f, 0.02659875f, -0.02645680f, -0.11482134f, 0.13127610f, 0.11171397f, 0.07305287f, -0.40864176f, 
    0.15074544f, 0.01535613f, -0.01417919f, 0.07452700f, -0.07306223f, 0.16987722f, 0.09997947f, 0.01038986f, 
    -0.28354806f, 0.04780598f, 0.25532162f, -0.16209747f, 0.14554474f, 0.14194632f, -0.01163399f, -0.04900446f, 
    0.18291411f, -0.09409091f, -0.04628818f, 0.17884596f, -0.01193080f, -0.07492796f, -0.16774675f, -0.09705712f, 
    0.00316907f, -0.18172982f, 0.05968717f, -0.17091937f, 0.08294947f, -0.11362091f, -0.09033257f, -0.17108682f, 
    0.10982418f, -0.14977162f, -0.23874368f, -0.11127219f, -0.01081640f, 0.03535391f, 0.11202300f, -0.01554833f, 
    0.01231886f, -0.02031639f, -0.06764246f, -0.12661673f, -0.06838529f, 0.14378540f, -0.03096262f, -0.11619337f, 
    0.00231208f, 0.05714935f, -0.08289143f, -0.08325604f, 0.02519041f, 0.19973101f, 0.19049554f, 0.13537112f, 
    -0.00078847f, -0.14931628f, -0.14322905f, -0.12458626f, -0.06340715f, -0.01429308f, 0.00935376f, 0.13794994f, 
    0.12009075f, 0.11242308f, -0.07346634f, -0.27018574f, -0.22419405f, -0.12297153f, -0.01988583f, 0.19254319f, 
    -0.18366536f, -0.00434895f, 0.17650212f, 0.01037054f, -0.13480692f, 0.07980824f, -0.06757258f, 0.18010011f, 
    -0.26896477f, 0.18006419f, 0.06379144f, 0.02319990f, 0.06483115f, 0.17743550f, 0.20074609f, -0.03617961f, 
    0.03288790f, -0.09112525f, 0.14123140f, 0.09551760f, 0.21994108f, -0.11649155f, 0.05662455f, 0.41905382f, 
    0.08460400f, 0.10016952f, 0.19033684f, 0.19784671f, -0.05865226f, 0.00374142f, 0.20826447f, 0.11733049f, 
    -0.01933842f, -0.06354263f, -0.08645424f, -0.11396728f, 0.16035424f, -0.07314540f, -0.16032876f, -0.05702025f, 
    -0.00704515f, 0.10274188f, -0.10351489f, -0.22159997f, 0.13466941f, 0.02096750f, 0.04262953f, 0.06048157f, 
    0.14799087f, 0.12782477f, 0.11957147f, 0.09840918f, -0.06186591f, -0.07401353f, -0.06139593f, 0.04134354f, 
    -0.00513182f, 0.00058523f, -0.20064250f, 0.03576287f, -0.03121312f, 0.04429082f, 0.06495529f, 0.01763268f, 
    0.01075137f, 0.01618983f, -0.15774316f, 0.01936527f, 0.72810954f, 0.28411284f, -0.20637538f, 0.21462934f, 
    0.04524459f, -0.02327233f, 0.07076205f, -0.03104213f, 0.10428321f, 0.15949295f, 0.14550467f, 0.17913561f, 
    0.37639332f, -0.04291549f, -0.00916437f, -0.15931737f, 0.08477391f, 0.27250284f, -0.00192756f, -0.00853486f, 
    -0.05390458f, -0.09912269f, 0.09099656f, 0.03911923f, 0.06319652f, -0.21031891f, 0.11273761f, -0.12950233f, 
    0.00968667f, 0.05739520f, -0.01829242f, -0.04916394f, -0.10470695f, -0.06300163f, -0.04236217f, 0.05193700f, 
    -0.23563153f, -0.09515233f, 0.13978580f, 0.10390686f, -0.06060510f, 0.02434169f, -0.01756150f, -0.03579778f, 
    -0.01691845f, -0.04366971f, -0.00434472f, 0.05446415f, -0.10024023f, -0.19233470f, -0.15259261f, -0.12476300f, 
    0.01109154f, -0.08113866f, -0.10592832f, -0.09853061f, -0.05930930f, -0.02923584f, 0.01547651f, -0.06314050f, 
    0.35636854f, -0.00436501f, -0.11841428f, -0.27152523f, -0.02872215f, 0.00511269f, -0.09573469f, -0.05378442f, 
    0.11610323f, 0.00470642f, 0.11887433f, -0.00015869f, -0.02054508f, -0.15247758f, -0.03064805f, -0.24881044f, 
    -0.10437016f, -0.04870645f, -0.08036479f, -0.02172872f, -0.07863675f, -0.08568969f, -0.02045995f, -0.12315778f, 
    -0.29630101f, -0.11846691f, 0.19802985f, 0.01389234f, 0.02610201f, -0.00293291f, -0.02619367f, 0.01347151f, 
    0.09028742f, -0.08635534f, -0.07526162f, 0.01172759f, -0.76710027f, 0.02725708f, 0.05892567f, 0.00400506f, 
    -0.10120364f, -0.09782936f, -0.01588223f, 0.09242881f, 0.02380109f, 0.15430313f, 0.14471968f, 0.00635541f, 
    -0.42920616f, 0.15186155f, 0.19129674f, 0.06898637f, 0.11146859f, 0.01828288f, -0.18486804f, -0.11954044f, 
    -0.03209259f, -0.11587578f, 0.08720753f, -0.11286968f, -0.07610539f, 0.01863680f, 0.00241734f, 0.24509215f, 
    0.01557828f, 0.08484691f, 0.12812009f, 0.05124137f, 0.01352720f, -0.07082937f, -0.01056807f, 0.18039353f, 
    0.03053746f, 0.41599053f, -0.32475773f, 0.15634720f, 0.08125427f, -0.03870573f, 0.05667002f, 0.15582086f, 
    -0.02533752f, 0.05464425f, -0.03429884f, 0.17592631f, 0.49068826f, 0.35083759f, -0.35448474f, -0.12333681f, 
    -0.03993972f, -0.09304146f, 0.14715587f, 0.16248436f, 0.01453077f, 0.01945762f, 0.00390764f, -0.07307237f, 
    0.15727562f, 0.11167809f, -0.28189164f, -0.09522748f, -0.02357890f, -0.07320490f, -0.11196263f, 0.03899618f, 
    -0.02570854f, -0.01346724f, 0.02917757f, 0.08504997f, -0.30433893f, 0.08034335f, -0.14257528f, 0.24215686f, 
    0.01662377f, 0.01917922f, 0.16143934f, -0.04915603f, 0.04201603f, -0.02361371f, -0.01775904f, -0.00902090f, 
    0.07864003f, -0.13534401f, 0.01354338f, -0.00935417f, -0.05338343f, 0.02238306f, 0.01433885f, -0.09760661f, 
    0.04388434f, -0.12507962f, -0.06397992f, 0.04581641f, -0.11375231f, 0.06813054f, -0.04034293f, -0.25352824f, 
    0.06913559f, -0.03544266f, -0.02115060f, 0.00607830f, -0.07085478f, 0.16392750f, 0.11203749f, 0.02552517f, 
    -0.02215420f, -0.08491782f, -0.03896302f, -0.34664986f, 0.11926835f, 0.08712854f, -0.04936998f, -0.06398303f, 
    0.03984330f, 0.13478279f, 0.03827991f, 0.09756999f, -0.34240702f, -0.07582030f, 0.14042066f, 0.22774377f, 
    -0.07691741f, -0.00200257f, 0.19085041f, -0.08946449f, -0.12952209f, 0.03317937f, -0.01199701f, 0.07395644f, 
    -0.34866151f, 0.11400373f, -0.03030933f, 0.14920747f, 0.12430251f, -0.05270641f, 0.07246640f, 0.16298810f, 
    0.12961388f, 0.23535213f, 0.12159676f, -0.02478106f, -0.27928805f, -0.24013567f, -0.18388025f, 0.03257660f, 
    0.04512453f, 0.12454766f, 0.03775078f, -0.04530739f, 0.09463870f, 0.14611448f, 0.14202152f, 0.24607615f, 
    -0.03743858f, -0.26358071f, -0.23486724f, -0.03969652f, 0.05120753f, -0.09005436f, -0.02345766f, -0.03761240f, 
    -0.01945975f, -0.00375106f, -0.09898164f, 0.00135454f, -0.53365374f, 0.05330046f, 0.16995968f, -0.34317189f, 
    -0.00717404f, 0.01144657f, -0.05616321f, -0.08734237f, 0.00162770f, -0.02688668f, -0.06282151f, -0.01736980f, 
    -0.02557141f, -0.15131468f, -0.19286208f, -0.09834444f, 0.08668931f, 0.02306226f, -0.06612259f, 0.02075483f, 
    0.11133625f, 0.05412393f, -0.05024389f, -0.15650274f, 0.00083413f, 0.09361948f, -0.00737028f, -0.03787501f, 
    0.08706876f, 0.06334820f, -0.03809705f, -0.06661817f, 0.04580110f, 0.02332662f, 0.01652653f, 0.00039149f, 
    -0.36536443f, 0.22137024f, 0.04542500f, 0.27415478f, 0.16659799f, -0.11860224f, 0.20062320f, -0.07046133f, 
    -0.00040188f, 0.02666061f, -0.03266377f, 0.02897441f, 0.95174891f, 0.19548213f, -0.24587344f, 0.13807027f, 
    -0.02270434f, -0.09022647f, 0.16616119f, 0.02857847f, 0.00160082f, 0.00995371f, 0.20715298f, -0.22636628f, 
    0.01013753f, -0.04986798f, -0.05209481f, -0.14961210f, 0.01144597f, 0.05282514f, 0.07004502f, 0.08295328f, 
    -0.02008188f, 0.07638332f, 0.12777674f, -0.07266214f, -0.10410202f, -0.13948362f, -0.15612057f, 0.30254766f, 
    0.03820667f, 0.00943831f, -0.21899733f, -0.01351640f, 0.07654085f, 0.06340826f, 0.00996877f, -0.04974231f, 
    0.07539226f, -0.18035693f, -0.10852306f, 0.20532572f, -0.00997806f, -0.09009845f, 0.13030945f, 0.06422196f, 
    -0.03329682f, -0.04981976f, 0.19708139f, 0.02549494f, -0.31364605f, 0.42378956f, -0.29051578f, 0.43132052f, 
    -0.04079254f, -0.08185169f, -0.05655754f, -0.01171152f, -0.04736983f, 0.10752886f, -0.02526832f, 0.11957480f, 
    0.15772980f, -0.19638355f, -0.06597027f, 0.01446866f, 0.00883419f, 0.06246900f, 0.15521011f, 0.07447424f, 
    -0.11105923f, -0.02783947f, 0.08949047f, 0.08556765f, 0.12882477f, 0.00942115f, 0.04343186f, -0.16768044f, 
    -0.03644161f, 0.05716483f, 0.05822944f, -0.00006181f, -0.07132544f, 0.00742533f, -0.08026589f, -0.06456611f, 
    -0.13253206f, -0.25411418f, 0.09603602f, -0.04860096f, 0.07418544f, 0.09120081f, 0.09153221f, -0.11785297f, 
    -0.03240337f, -0.06085190f, -0.08197775f, -0.03619987f, 0.05621461f, -0.23257197f, -0.08650375f, 0.17236552f, 
    -0.02621949f, 0.03820999f, 0.05724340f, 0.03308254f, -0.07877917f, 0.05389370f, 0.09393274f, 0.19498578f, 
    -0.30597082f, -0.26319593f, 0.25216061f, 0.39782256f, 0.11006585f, 0.07122909f, 0.14017268f, 0.11820454f, 
    0.03828008f, 0.14386177f, 0.02164392f, 0.10230007f, -0.09770314f, 0.03829585f, 0.09580291f, 0.03334768f, 
    0.05359722f, 0.08524634f, -0.10769403f, 0.05992604f, -0.00494580f, 0.06667522f, -0.00202280f, -0.04461794f, 
    0.05285877f, 0.06882598f, -0.15961669f, 0.12841724f, 0.00961877f, -0.06012199f, 0.00953229f, -0.02173734f, 
    -0.04677553f, -0.07884560f, 0.04378274f, 0.04588028f, 0.29335073f, -0.04911207f, -0.14885016f, 0.24703716f, 
    0.12558359f, 0.06214514f, -0.08448648f, 0.13302705f, -0.01352815f, 0.01177149f, -0.12110320f, 0.11770537f, 
    0.00095338f, 0.01811527f, 0.01782103f, -0.04443272f, 0.01307723f, -0.00422465f, -0.00973263f, -0.00838234f, 
    -0.03075534f, 0.00882479f, -0.03950645f, -0.01686756f, 0.03372947f, -0.00761940f, -0.03373020f, 0.00389454f, 
    -0.02555053f, -0.00830477f, 0.00022143f, -0.02981492f, -0.02746121f, -0.00261023f, 0.01092508f, -0.01604289f, 
    -0.02710969f, -0.00197539f, -0.03143180f, -0.03679450f, -0.01327002f, 0.00522687f, 0.02530734f, 0.01330051f, 
    -0.00745818f, -0.01551223f, -0.01535014f, -0.00926071f, -0.02580523f, 0.00443394f, 0.01029430f, 0.02951062f, 
    -0.04212132f, 0.00508614f, -0.01922685f, -0.01837588f, 0.02020388f, 0.01996696f, -0.00268922f, -0.00994812f, 
    -0.00373450f, 0.00030531f, 0.00352979f, -0.00002087f, 0.00776043f, 0.01033897f, 0.02464158f, -0.03830533f, 
    -0.01693400f, -0.03571486f, -0.00871825f, 0.01124477f, -0.02166038f, 0.03888792f, -0.02436125f, -0.03376439f, 
    0.01656582f, -0.01539730f, 0.00875385f, -0.01605684f, -0.00976756f, -0.00634311f, 0.02486652f, -0.02579930f, 
    -0.00465982f, 0.01763706f, -0.01939310f, -0.04160529f, -0.03039799f, -0.03454643f, 0.01028500f, -0.03146231f, 
    -0.02452452f, 0.00547377f, -0.01929869f, -0.03228620f, -0.00166795f, 0.01027476f, -0.01880333f, -0.02817034f, 
    0.03381906f, 0.02317964f, -0.01485566f, -0.00248637f, -0.00496010f, 0.00915822f, -0.03075387f, 0.00540644f, 
    -0.01451686f, 0.02306708f, -0.02426155f, 0.02007980f, 0.00157511f, -0.02392178f, -0.01058118f, 0.00685770f, 
    0.01969193f, -0.00230287f, -0.00127216f, 0.02741406f, -0.01163458f, -0.02100866f, -0.03168743f, -0.02754218f, 
    0.02622766f, -0.03014864f, -0.00930863f, -0.03053809f, -0.01484885f, 0.00045317f, 0.02043861f, -0.01001421f, 
    -0.01678839f, 0.00521898f, 0.01283466f, 0.00454493f, -0.03185862f, 0.01844007f, 0.01184720f, 0.00936417f, 
    -0.03132948f, -0.02801915f, -0.00965369f, -0.03794513f, 0.00440766f, 0.02208130f, 0.02530237f, 0.02998742f, 
    0.02896767f, 0.00198528f, -0.03087531f, -0.00743921f, 0.02816753f, 0.02771679f, 0.01704662f, 0.01912909f, 
    -0.02088160f, 0.00720263f, -0.01118566f, -0.00679513f, 0.01767446f, -0.02583241f, 0.02722051f, -0.04046023f, 
    0.00412380f, 0.00229366f, -0.03631432f, -0.02083165f, -0.01509656f, -0.02790865f, -0.02519797f, -0.04302531f, 
    -0.01266153f, -0.02075799f, 0.02184999f, 0.00420032f, -0.02523490f, 0.02765667f, -0.03153215f, -0.01559406f, 
    -0.00412746f, 0.02592580f, 0.00059318f, 0.02883361f, -0.02469359f, -0.01305947f, -0.03327793f, 0.00731136f, 
    -0.02843382f, 0.03367901f, -0.02795177f, -0.00636686f, 0.01739352f, -0.03165551f, 0.02608799f, -0.04059572f, 
    0.01670089f, 0.02348181f, 0.00593221f, -0.01579429f, -0.00996527f, -0.02658095f, -0.03796963f, 0.02781020f, 
    0.00450044f, 0.02011858f, -0.03035784f, 0.01653011f, 0.02390935f, 0.01631044f, 0.03218767f, -0.01665612f, 
    -0.00640456f, 0.02861704f, 0.01432339f, 0.01667113f, -0.03430047f, 0.00975013f, -0.00215438f, -0.04463997f, 
    -0.03429129f, 0.02081752f, 0.01215323f, -0.03302514f, 0.00521309f, -0.01620757f, 0.00912403f, 0.00162925f, 
    0.00398074f, -0.01598163f, -0.02955133f, 0.01123663f, 0.00761517f, -0.02178591f, -0.02834577f, 0.02351420f, 
    0.00864346f, 0.00411800f, -0.02071899f, 0.02166150f, -0.01758131f, 0.00056433f, -0.00637190f, 0.00902885f, 
    -0.00759879f, 0.02716791f, -0.03327544f, -0.03955561f, -0.00930344f, 0.00745827f, 0.01337746f, 0.02032672f, 
    -0.01733715f, -0.02809067f, -0.04452272f, -0.01972747f, 0.02687832f, 0.01773161f, -0.03073809f, 0.03019387f, 
    0.00755213f, -0.00160488f, -0.01741139f, -0.03949025f, -0.01182741f, -0.00187744f, 0.01888984f, 0.02776890f, 
    -0.01822881f, -0.02365398f, -0.04124000f, -0.01729686f, 0.01617966f, 0.02207567f, -0.02148059f, -0.00876257f, 
    0.02459935f, 0.02084607f, -0.02168710f, -0.03283341f, -0.02531324f, -0.00233033f, -0.03859858f, -0.00992122f, 
    -0.02794995f, -0.01371217f, 0.00133697f, -0.00668040f, -0.01124284f, 0.00720996f, 0.00339629f, 0.02367922f, 
    -0.01978359f, 0.02943675f, -0.00555322f, -0.01576062f, 0.02376906f, -0.02311384f, 0.02181973f, 0.00082912f, 
    -0.00237101f, -0.00132168f, 0.03567458f, -0.00479394f, -0.03267449f, 0.01443869f, -0.02533620f, 0.00138989f, 
    -0.01978682f, 0.02507433f, 0.01837788f, 0.02324870f, 0.01644323f, -0.00502169f, 0.01079553f, -0.03926060f, 
    -0.02381074f, -0.03717265f, 0.00380133f, 0.02208530f, -0.00451190f, -0.02795053f, 0.02048002f, 0.00806739f, 
    -0.00735180f, 0.00417677f, -0.01434906f, 0.00026603f, -0.01986436f, -0.03549748f, 0.00876202f, -0.00409687f, 
    -0.00639350f, 0.01384314f, -0.02790661f, 0.00823634f, -0.04273418f, 0.00972364f, -0.01563535f, -0.01342413f, 
    0.01186717f, 0.00187666f, -0.02795712f, 0.01598028f, 0.00066381f, 0.02597803f, -0.04261378f, 0.00609071f, 
    0.02959962f, 0.02034078f, -0.00258880f, 0.02385755f, -0.02807031f, -0.03734660f, 0.00618415f, 0.00636041f, 
    0.00876347f, 0.01429298f, -0.03424492f, 0.01611378f, 0.00256726f, -0.00596982f, -0.03344285f, -0.01484953f, 
    0.02089680f, 0.02398736f, -0.02574822f, -0.01605563f, -0.00915862f, -0.01305744f, 0.02065032f, -0.00062711f, 
    -0.01571384f, -0.01038606f, -0.04367748f, 0.00197612f, 0.00780510f, 0.02543238f, 0.00761777f, 0.00276458f, 
    0.02520135f, 0.01313039f, 0.02757138f, -0.02067816f, -0.03009672f, 0.01443820f, 0.02230518f, -0.01531694f, 
    -0.01299948f, -0.02308861f, -0.01831561f, 0.00387999f, -0.00094351f, 0.01870297f, -0.02030061f, -0.03502471f, 
    0.00411290f, -0.04525781f, 0.00694521f, -0.02050323f, -0.00529281f, -0.04115876f, 0.01365323f, 0.02261629f, 
    -0.01939365f, 0.01152811f, 0.02763112f, -0.00782933f, -0.03399831f, -0.01701396f, -0.02116906f, 0.00769371f, 
    0.01098849f, 0.01578926f, -0.02937886f, 0.00716658f, -0.00345592f, -0.00584063f, -0.02002590f, -0.00134579f, 
    0.00042793f, -0.03462888f, -0.00854641f, 0.02097605f, 0.00471514f, 0.02238364f, -0.00147057f, 0.01668434f, 
    0.02625954f, -0.00895082f, -0.01719953f, -0.03680782f, 0.02117295f, -0.02557516f, -0.00503715f, -0.03124377f, 
    -0.03537046f, 0.02069244f, -0.00593016f, 0.00931680f, 0.01562599f, -0.00289046f, -0.03974083f, -0.01428729f, 
    0.00051069f, 0.03453047f, 0.00171232f, -0.01982856f, -0.02873132f, 0.01854617f, -0.02167814f, -0.03084159f, 
    -0.03161581f, -0.02374005f, 0.01370968f, -0.00285121f, 0.01472455f, -0.00635655f, -0.01882624f, -0.04681134f, 
    -0.03498095f, 0.00064868f, -0.03029753f, 0.02711227f, 0.00192070f, -0.01634820f, -0.00021551f, 0.01791763f, 
    -0.01655512f, -0.00445721f, 0.00448767f, -0.01883294f, -0.00762570f, 0.03125600f, -0.01741324f, 0.00106601f, 
    0.01614738f, 0.01556475f, 0.00623204f, 0.00582854f, -0.03720115f, 0.01983980f, -0.01103044f, -0.02907299f, 
    0.00000372f, 0.03116107f, 0.02305612f, -0.00393261f, -0.02944925f, -0.03490126f, 0.00928938f, -0.01775579f, 
    -0.01439723f, 0.01267066f, 0.00309450f, -0.01552044f, -0.01940599f, 0.01768380f, 0.02763614f, 0.00507680f, 
    0.02299514f, 0.01013242f, -0.03065526f, -0.04096941f, -0.03256470f, 0.00082043f, 0.02285071f, -0.03657872f, 
    -0.04115628f, 0.02668454f, -0.03226710f, -0.02373263f, 0.01980679f, -0.03183015f, 0.00626579f, 0.00427589f, 
    -0.03850273f, 0.00784419f, -0.03921738f, 0.01456133f, -0.03810878f, 0.00660410f, 0.00150360f, 0.02104907f, 
    0.01866029f, 0.01720089f, 0.02337878f, -0.00632156f, -0.00398802f, -0.00324902f, -0.01425696f, -0.01235098f, 
    -0.00676863f, 0.02622532f, -0.00113241f, -0.02353215f, 0.01162754f, -0.01786763f, 0.01780484f, -0.02887595f, 
    0.01612082f, -0.04471807f, 0.02746502f, 0.01721945f, -0.01110084f, -0.03890141f, -0.01336235f, 0.02062597f, 
    -0.03755580f, -0.03720019f, 0.00247874f, -0.00835846f, 0.01208119f, 0.01639678f, 0.01987532f, -0.01449128f, 
    -0.01416481f, -0.01698745f, 0.02022411f, 0.00698682f, 0.00851385f, -0.00681456f, 0.00642808f, 0.00477878f, 
    -0.02600436f, -0.01030667f, -0.00870299f, -0.00230203f, 0.01380528f, -0.01156066f, -0.00284855f, 0.00490302f, 
    0.00834688f, -0.00087515f, -0.00004327f, 0.01823162f, -0.02884880f, 0.00681050f, -0.01305798f, 0.00969716f, 
    0.00299477f, -0.03916631f, 0.01007026f, -0.02186530f, 0.01099289f, -0.03559811f, -0.02593368f, 0.02853548f, 
    0.02147814f, -0.00503326f, 0.01307620f, -0.01079647f, 0.01026882f, 0.00261261f, 0.00924487f, 0.00223999f, 
    -0.02321653f, -0.03430232f, -0.03551578f, 0.00745254f, -0.01110514f, 0.02386005f, 0.00337359f, 0.02332932f, 
    0.01457998f, 0.00327448f, -0.02099268f, 0.02405937f, 0.02645133f, 0.01422884f, 0.01968376f, 0.00959081f, 
    -0.01310222f, -0.01214267f, 0.01506034f, -0.02526216f, -0.02312571f, 0.01558135f, 0.02424602f, -0.02537842f, 
    -0.02751455f, -0.00470991f, 0.01719276f, 0.02495457f, -0.00292776f, -0.00766057f, 0.01647513f, -0.01191290f, 
    0.01210040f, -0.00486743f, 0.03204942f, -0.01207095f, -0.02971140f, -0.03517091f, 0.02854552f, -0.01233794f, 
    -0.01620984f, -0.03088709f, -0.00217610f, -0.00664146f, 0.01115721f, 0.00055956f, -0.02627693f, 0.01350382f, 
    0.01911566f, -0.00577537f, 0.00703263f, -0.03109538f, 0.02209017f, 0.02255643f, 0.01511300f, -0.02348758f, 
    -0.02791832f, -0.02939912f, -0.00585835f, -0.01156186f, -0.01072937f, -0.02119314f, -0.00410992f, 0.00560090f, 
    -0.02589039f, -0.03518311f, 0.00677866f, -0.00031301f, 0.03215664f, -0.02540464f, -0.00058050f, -0.01152393f, 
    0.02623734f, 0.01582899f, 0.02135182f, -0.03314676f, -0.02851550f, 0.02064262f, 0.00935485f, 0.00515620f, 
    0.02390543f, -0.01819103f, 0.01936800f, 0.00972165f, -0.02537218f, -0.02568270f, 0.00043873f, 0.00495568f, 
    0.01613567f, 0.01719712f, 0.00210184f, -0.03462712f, -0.03135385f, -0.01146590f, -0.03074235f, -0.02755051f, 
    -0.04658835f, 0.00040395f, -0.03339346f, -0.03089816f, -0.04153963f, -0.00121325f, 0.01755579f, -0.00288193f, 
    0.02188714f, 0.00974678f, -0.02716552f, -0.02739044f, 0.02156627f, 0.01860388f, 0.01304630f, -0.00952740f, 
    0.00862873f, -0.00511801f, -0.01659571f, -0.00109204f, -0.02961319f, 0.01696772f, -0.02695319f, -0.01725817f, 
    0.01065852f, -0.02949557f, -0.02725793f, -0.01585348f, 0.04366243f, -0.02822821f, -0.03725066f, -0.03236447f, 
    0.01470231f, -0.01774138f, 0.02177009f, -0.00167385f, -0.03416409f, -0.01481196f, 0.02668140f, -0.03264713f, 
    0.02616084f, 0.02186126f, -0.00547613f, 0.02790579f, 0.01809857f, -0.03912617f, -0.01686663f, 0.02012279f, 
    -0.03014489f, 0.01174735f, -0.00866085f, 0.00010159f, -0.02663945f, 0.02066439f, -0.00351394f, -0.01580241f, 
    -0.01488022f, 0.01128993f, -0.00970444f, -0.02304004f, 0.02020701f, -0.03397810f, 0.00539594f, -0.03904334f, 
    0.01669644f, 0.03245797f, 0.02079114f, 0.02794833f, 0.02159018f, -0.03910255f, 0.00329808f, -0.02376342f, 
    -0.04017493f, -0.00848148f, -0.01579725f, 0.00571039f, -0.03331722f, -0.01505039f, -0.03087071f, -0.03754011f, 
    -0.02562808f, -0.01593130f, 0.02010005f, 0.00625856f, -0.01915476f, -0.00056742f, 0.01517855f, -0.01515708f, 
    -0.03656725f, -0.14818984f, -0.20826943f, -0.02709448f, 0.00225526f, 0.04495814f, 0.00635352f, 0.28072581f, 
    0.15699323f, 0.09304740f, 0.07738340f, 0.08371722f, 0.34017029f, -0.19507454f, 0.05379097f, -0.01718918f, 
    0.03046880f, 0.09992477f, -0.02546548f, 0.01346426f, -0.07106781f, -0.04416000f, 0.10588208f, 0.15002672f, 
    0.17259452f, 0.41279662f, 0.01423572f, 0.11981713f, -0.07177783f, 0.05407229f, -0.10751788f, -0.11459228f, 
    -0.08381669f, -0.15916023f, 0.08276701f, -0.23011786f, -0.01656734f, 0.25122741f, -0.09158442f, -0.07998763f, 
    -0.03695479f, -0.15269686f, -0.03797480f, -0.07489390f, 0.02859685f, 0.15826242f, -0.06800660f, 0.16891012f, 
    0.05116545f, 0.31761655f, -0.18891239f, 0.13348445f, 0.05588789f, 0.15628923f, 0.08929900f, 0.18372421f, 
    -0.11156985f, -0.06719822f, -0.09878714f, -0.24681038f, 0.05044922f, 0.07951998f, 0.10806781f, 0.02003897f, 
    -0.04144545f, 0.06392838f, -0.00585119f, 0.04740346f, -0.11836322f, -0.07393536f, 0.00839705f, -0.08772421f, 
    0.46521583f, -0.06798387f, 0.10986669f, 0.08637942f, -0.07715053f, 0.08168536f, 0.13921784f, -0.03676702f, 
    -0.05835929f, -0.03174573f, 0.03016637f, 0.22232100f, 0.31938276f, -0.23009241f, -0.00299809f, -0.08720235f, 
    0.05553601f, -0.10283832f, 0.00552044f, 0.02462551f, 0.10735389f, 0.03297704f, -0.10858524f, -0.04826610f, 
    -0.06378575f, 0.26273900f, -0.28622606f, 0.32787511f, 0.07950290f, 0.04062444f, -0.09281182f, -0.16389295f, 
    -0.02380903f, -0.00077426f, -0.03699108f, -0.20781431f, -0.18566117f, 0.10737026f, -0.08778130f, -0.04741896f, 
    0.01458140f, -0.03935492f, 0.17784746f, 0.05101908f, -0.09624448f, 0.02908831f, -0.05553215f, -0.08405747f, 
    -0.24336533f, 0.07508396f, -0.44710481f, -0.11927075f, 0.10578014f, 0.07406919f, 0.13314988f, -0.14743291f, 
    0.09324306f, -0.00648444f, 0.10977463f, 0.04690536f, 0.06140542f, 0.04626391f, -0.25750020f, 0.07620081f, 
    -0.07373188f, -0.07847830f, -0.07314323f, -0.00105304f, -0.01214833f, -0.03449433f, -0.01089937f, 0.02158259f, 
    -0.07776695f, 0.02635282f, -0.06097971f, -0.13442230f, 0.13540153f, 0.06450535f, -0.18962245f, -0.10809557f, 
    0.03156997f, -0.06645569f, -0.02603889f, -0.26013860f, -0.25002810f, 0.07310395f, 0.04590653f, -0.13610384f, 
    0.38402772f, 0.10774561f, 0.10590876f, -0.14039400f, -0.06325167f, 0.00191369f, 0.07532612f, 0.05081550f, 
    -0.24139482f, -0.58568549f, 0.50748587f, 0.54704630f, -0.04402266f, 0.25363159f, -0.17931196f, -0.10240601f, 
    0.01359200f, -0.09994715f, -0.01023741f, 0.17629303f, 0.19728917f, -0.05689836f, 0.19757606f, -0.21302322f, 
    0.16610681f, 0.11815351f, 0.01031626f, 0.10262319f, 0.04724485f, 0.02444467f, -0.15447530f, -0.24634168f, 
    0.03135007f, 0.08955705f, -0.08943536f, 0.05285004f, 0.20375094f, -0.11690452f, 0.13494869f, -0.02051447f, 
    0.02020111f, 0.15855350f, -0.18665932f, -0.04068925f, -0.18922997f, 0.14748810f, -0.34065658f, 0.10553631f, 
    -0.01519750f, -0.10065667f, -0.11804379f, -0.03022940f, 0.00786845f, 0.05133538f, 0.01668186f, 0.23332563f, 
    0.07090849f, -0.07665182f, 0.14123669f, 0.34952638f, 0.07912257f, 0.12971938f, -0.00843487f, 0.20671560f, 
    0.05837874f, 0.06248515f, 0.17825358f, -0.14942648f, -0.30416828f, 0.17863388f, 0.03905310f, -0.10263404f, 
    -0.04699021f, -0.05865037f, 0.07080328f, 0.09919311f, -0.19576930f, 0.01529002f, 0.15293977f, 0.02608040f, 
    -0.35384750f, 0.05460153f, -0.30872548f, 0.33372018f, 0.15652892f, 0.19129772f, 0.25414205f, 0.08076879f, 
    -0.03578809f, -0.01026093f, 0.15099044f, 0.08455012f, 0.13296442f, -0.25832060f, -0.12221086f, -0.11740339f, 
    0.12010422f, 0.14878973f, 0.14320469f, 0.04190031f, -0.04724259f, 0.09661822f, -0.00685684f, 0.13096890f, 
    -0.03467064f, -0.15146561f, 0.19853245f, 0.14935179f, -0.01714616f, 0.03563911f, -0.11187162f, 0.11552886f, 
    -0.14369561f, -0.21434142f, -0.05960384f, -0.18015783f, 0.45640850f, -0.23633273f, -0.04279282f, 0.15522003f, 
    0.24434754f, -0.09033677f, 0.12194531f, 0.00658887f, 0.10104039f, 0.00928455f, -0.16899860f, 0.04149025f, 
    -0.11363004f, -0.04100475f, 0.12998006f, 0.14828454f, 0.02034738f, -0.01250264f, 0.05714307f, 0.09680399f, 
    -0.04769226f, -0.05309856f, -0.02217694f, -0.08320322f, 0.36930266f, -0.09279326f, 0.07409175f, -0.10764877f, 
    0.10809354f, 0.12263557f, 0.02164671f, 0.04870887f, -0.08377354f, -0.00921954f, 0.09831624f, 0.03578710f, 
    0.24968477f, -0.24657243f, 0.13399492f, 0.19629744f, 0.06844935f, -0.04929860f, 0.08109248f, -0.00945050f, 
    -0.07451709f, 0.10094122f, -0.03958058f, 0.18088625f, 0.00221293f, 0.47188085f, -0.12830611f, 0.02236397f, 
    0.06614686f, 0.08793443f, -0.13964303f, -0.03153716f, 0.00231960f, -0.04137007f, -0.09657657f, -0.06098419f, 
    -0.01798033f, 0.20749499f, 0.48518389f, 0.40699357f, 0.05732956f, 0.05071935f, 0.06504675f, 0.04967372f, 
    0.11978479f, -0.00282657f, -0.02946455f, -0.08188954f, 0.06219226f, -0.19885539f, 0.06326303f, 0.09800960f, 
    0.02740277f, -0.02678361f, 0.06349441f, 0.03520008f, -0.04999427f, -0.04343448f, -0.07814509f, -0.00250050f, 
    -0.09346949f, -0.13513608f, -0.23810442f, -0.23973396f, 0.03786885f, -0.11635539f, -0.05187379f, -0.26178023f, 
    -0.02630440f, 0.01044796f, -0.09061012f, 0.02686853f, 0.01169962f, 0.20117259f, -0.06842077f, -0.17017113f, 
    -0.00259634f, 0.06379401f, -0.01441966f, -0.01113973f, 0.04054574f, 0.07510217f, -0.08220173f, -0.18611787f, 
    0.29443675f, 0.15842663f, 0.14170738f, 0.19282082f, -0.04290112f, -0.00363993f, -0.26753885f, 0.16267513f, 
    -0.16062781f, -0.04284721f, -0.01598630f, -0.34589818f, -0.15551755f, 0.12026578f, 0.02228676f, 0.10939686f, 
    -0.02915625f, -0.04480676f, -0.18575314f, 0.11314341f, -0.03651876f, 0.00160300f, 0.08053774f, -0.00182993f, 
    -0.07743227f, 0.36610165f, 0.26498637f, 0.24448781f, 0.07431752f, 0.18397371f, -0.10870067f, 0.02928589f, 
    -0.01913128f, -0.07990813f, 0.05040460f, -0.12334760f, -0.14792088f, -0.26218855f, -0.17956986f, 0.12183643f, 
    -0.04576368f, -0.08366115f, 0.10063122f, -0.01821642f, 0.14352107f, 0.07610206f, -0.14122361f, -0.05532808f, 
    -0.14048746f, -0.39082706f, 0.19064793f, 0.00922065f, 0.04404662f, 0.02590735f, 0.03065858f, 0.08033421f, 
    -0.15309246f, -0.06187626f, 0.08613683f, -0.21672969f, 0.04526351f, 0.17037688f, -0.26573661f, -0.22098018f, 
    0.13445099f, 0.12664191f, -0.01306435f, 0.03166910f, -0.20578556f, 0.14573658f, 0.06482809f, 0.11636264f, 
    -0.10426176f, 0.22177075f, -0.21330273f, 0.06039128f, -0.07320382f, 0.17897810f, -0.10020806f, 0.01096933f, 
    -0.02798291f, -0.06633515f, 0.09966071f, 0.11717071f, -0.12817881f, 0.13145500f, 0.49520391f, 0.05525035f, 
    0.10270488f, -0.05645704f, -0.13017169f, 0.34482500f, -0.22272572f, 0.07299136f, -0.09194285f, -0.01086917f, 
    0.31983373f, -0.08404983f, 0.07264057f, -0.02801735f, -0.02299901f, 0.04055315f, -0.00540308f, 0.01895114f, 
    0.15602723f, -0.04463052f, -0.14603887f, -0.17818080f, -0.09298157f, -0.04942293f, -0.02363330f, -0.21483564f, 
    0.05881406f, -0.05108822f, -0.06513734f, -0.04795121f, -0.06945550f, -0.13381985f, 0.04574588f, -0.18274173f, 
    -0.39060020f, 0.21024103f, -0.44822076f, -0.14385980f, 0.07308792f, -0.02918076f, 0.14441966f, -0.05101595f, 
    -0.14541611f, 0.11904789f, 0.08294863f, 0.14011088f, 0.37562153f, 0.23033872f, 0.35742432f, 0.19881986f, 
    -0.09672398f, -0.11593541f, 0.06260031f, 0.12122929f, -0.04455645f, 0.07893775f, -0.05466907f, -0.02926853f, 
    -0.28741479f, 0.08191048f, 0.18608068f, 0.39254451f, -0.03919942f, 0.08074306f, 0.09322079f, 0.10745417f, 
    -0.19411060f, 0.12434829f, 0.18488349f, -0.00852716f, -0.06568651f, 0.16049163f, -0.09345782f, 0.20205279f, 
    -0.08202610f, 0.00054051f, -0.08945240f, 0.07266705f, -0.02502590f, 0.14746661f, 0.19831762f, 0.30187586f, 
    0.16394016f, -0.12641932f, 0.12544614f, 0.08987960f, -0.03474853f, 0.06819020f, 0.04037430f, 0.13778815f, 
    -0.04680668f, 0.07715668f, -0.18696795f, -0.20912685f, 0.23524058f, -0.45013258f, 0.53328276f, 0.27702424f, 
    -0.06019768f, 0.05312146f, -0.13516858f, 0.13527268f, -0.11855110f, -0.09229101f, -0.04269535f, -0.19242653f, 
    0.11476295f, -0.02287415f, 0.12251911f, 0.25625601f, 0.06317405f, 0.03990487f, 0.24587974f, -0.06834764f, 
    0.04753861f, -0.05639853f, -0.12714472f, 0.01542066f, -0.29361227f, -0.11175676f, 0.33740285f, 0.38259465f, 
    -0.01563568f, -0.03459455f, 0.13536878f, -0.09763578f, -0.02281307f, -0.02030123f, 0.08023724f, -0.12092073f, 
    -0.53298950f, -0.25799942f, -0.01395684f, 0.32899383f, -0.07412326f, 0.05105535f, 0.01694809f, 0.02089217f, 
    -0.08938298f, 0.02002451f, -0.08566999f, -0.06496482f, 1.07391250f, 0.07355905f, 0.23921783f, -0.28032485f, 
    0.01545126f, 0.32026184f, -0.09515519f, 0.19801268f, 0.01174549f, 0.08118781f, -0.06614351f, -0.00321650f, 
    -0.10176687f, -0.03312064f, -0.01514648f, 0.13525231f, -0.05120401f, 0.07760075f, 0.07544425f, 0.18052916f, 
    -0.24268280f, 0.06114271f, 0.06549768f, -0.06575683f, -0.21601321f, -0.18270032f, -0.14383854f, 0.25863171f, 
    -0.01845281f, -0.04958431f, -0.02228260f, -0.12336589f, 0.07700622f, -0.18737361f, 0.14575304f, -0.00089046f, 
    0.05508130f, -0.20703335f, -0.00521794f, 0.03734338f, 0.02794415f, 0.12257317f, 0.00030445f, 0.08972749f, 
    -0.06685810f, 0.01265491f, -0.07389574f, 0.04205161f, -0.25675356f, -0.30017257f, 0.05973742f, 0.12043253f, 
    0.00490619f, 0.02980072f, -0.03363652f, -0.07443427f, -0.06771235f, -0.05455025f, 0.15389276f, 0.04341006f, 
    0.22302593f, -0.01079193f, -0.13003364f, 0.02321624f, 0.02443231f, -0.02020345f, 0.19036350f, 0.15490796f, 
    0.07508238f, 0.03503599f, 0.18945800f, 0.14604294f, 0.27005503f, 0.28169173f, 0.06529817f, -0.22242579f, 
    -0.10874959f, -0.10645895f, -0.03716655f, 0.00738703f, -0.03364477f, 0.03621145f, -0.20355743f, -0.01462235f, 
    0.12552999f, 0.12153303f, -0.01115869f, 0.03299795f, -0.09371298f, 0.08686344f, 0.03788096f, -0.00375910f, 
    -0.07415647f, -0.04011276f, -0.18199669f, -0.00742433f, -0.07351844f, -0.31736773f, -0.21046674f, 0.09846649f, 
    0.10422000f, 0.11169458f, 0.20063560f, 0.11126310f, 0.10859539f, 0.06014623f, 0.07694755f, 0.16354895f, 
    -0.37453547f, 0.22716872f, -0.30697930f, 0.07484869f, 0.08882066f, -0.08179846f, 0.02202659f, 0.10322704f, 
    -0.03524126f, -0.04399531f, -0.01472613f, -0.05359947f, -0.25982279f, -0.04454472f, -0.00536541f, 0.31269324f, 
    0.03122107f, 0.06730680f, 0.00888543f, -0.21307448f, -0.08883359f, 0.04233534f, -0.13106665f, -0.05897080f, 
    0.07502425f, 0.16147646f, 0.01562441f, 0.22051214f, 0.01538525f, -0.02178869f, 0.02372231f, -0.11669217f, 
    -0.23703900f, -0.03561133f, -0.11307082f, 0.00805643f, 0.49463075f, -0.13224539f, 0.05463974f, 0.02869376f, 
    -0.06230941f, -0.05723704f, 0.08746780f, -0.07833025f, -0.02518133f, -0.06902014f, -0.04298481f, 0.08504348f, 
    0.03450358f, -0.11303399f, -0.02138917f, 0.13683313f, -0.12008404f, -0.10412997f, -0.01654529f, -0.08216978f, 
    0.20949803f, 0.10930637f, 0.36798039f, 0.34719661f, -0.01670051f, 0.01361451f, 0.30158487f, 0.28161615f, 
    0.20863277f, -0.00709532f, 0.08857203f, 0.06165559f, 0.17819601f, -0.05314716f, -0.00795965f, 0.06196316f, 
    -0.21431080f, -0.06853980f, -0.18452288f, -0.15994224f, 0.26489320f, -0.09966537f, 0.08543229f, -0.07726224f, 
    -0.00290264f, -0.01133083f, -0.26307282f, -0.49776897f, 0.06926373f, -0.40608555f, 0.06097049f, 0.17717601f, 
    0.12479782f, 0.03552644f, -0.04306839f, 0.09421009f, -0.05538125f, 0.07368240f, -0.03666307f, -0.03175934f, 
    0.26010224f, -0.06143520f, 0.07364421f, -0.26769540f, 0.15308473f, -0.09794403f, 0.16288427f, 0.10796214f, 
    -0.18566281f, -0.07252373f, -0.09726622f, -0.03620158f, 0.14330822f, 0.08368029f, 0.32404339f, -0.08789637f, 
    0.09940527f, -0.04771611f, -0.01841934f, 0.07813969f, -0.01567034f, 0.00076842f, 0.03581766f, 0.00202500f, 
    -0.27955177f, 0.11706758f, -0.16968064f, 0.10851945f, 0.09468960f, 0.03185349f, 0.04393341f, -0.06145683f, 
    0.20341061f, 0.17392069f, 0.18999103f, 0.30597177f, 0.29973945f, 0.17827280f, 0.10418224f, 0.16487834f, 
    0.05893048f, 0.02398343f, 0.01693356f, -0.15979089f, 0.01687299f, -0.08424542f, -0.06143575f, 0.08019400f, 
    0.74527419f, -0.33841980f, -0.05980712f, -0.06644017f, 0.01036840f, -0.01914164f, 0.00653170f, -0.03069359f, 
    0.12462247f, 0.00583671f, -0.11017416f, -0.09811361f, 0.02450328f, -0.27270147f, -0.04713304f, -0.20770395f, 
    -0.02980860f, 0.22674538f, 0.08803863f, 0.14096959f, 0.15556283f, 0.04928650f, 0.15886545f, 0.01027513f, 
    0.11745667f, -0.20472369f, 0.20679474f, 0.05849629f, -0.11726237f, -0.19402200f, -0.17473942f, -0.11721564f, 
    0.04306395f, 0.02904769f, -0.02440832f, 0.15010342f, 0.25514677f, -0.13380586f, 0.02521228f, 0.24245533f, 
    0.02682728f, 0.09862816f, -0.03369331f, -0.00348038f, 0.09741589f, -0.04097561f, 0.06464540f, 0.03572923f, 
    -0.04235191f, -0.13891947f, -0.11778168f, -0.05524360f, 0.29228306f, 0.10130528f, -0.13742837f, -0.07746912f, 
    -0.13425291f, -0.09690060f, -0.09343035f, -0.23219976f, 0.44536206f, -0.03638174f, 0.48380092f, 0.04818487f, 
    -0.12326160f, -0.08928846f, 0.06167462f, -0.10726184f, 0.18058173f, 0.03998723f, -0.01139598f, -0.03243624f, 
    -0.01917660f, 0.14657071f, -0.17327558f, -0.50183821f, -0.15085961f, -0.02037272f, -0.11451951f, 0.00173471f, 
    0.18397364f, -0.05540711f, -0.08949701f, 0.07314658f, 0.25740555f, 0.21986066f, -0.21256067f, 0.01316265f, 
    0.04824264f, -0.06929439f, 0.03905546f, 0.06883668f, -0.12371820f, -0.06509015f, -0.05672340f, -0.25622708f, 
    0.15414391f, 0.32395613f, 0.03131456f, 0.16335776f, -0.00957170f, 0.05635164f, 0.11069284f, 0.16683064f, 
    0.11835237f, -0.04195212f, -0.05914025f, -0.03678711f, 0.29463992f, -0.24058044f, 0.08897868f, 0.26141033f, 
    -0.11481160f, -0.07006735f, 0.00609792f, -0.09139217f, 0.17486188f, 0.20465456f, 0.22085518f, 0.20606482f, 
    0.34308505f, -0.09505812f, -0.15712632f, 0.04363101f, -0.04836512f, -0.03634029f, 0.00933297f, 0.16197632f, 
    0.13114825f, -0.15266909f, 0.04331739f, -0.06778034f, 0.22034170f, -0.02570547f, 0.04974091f, -0.23373547f, 
    0.17427054f, 0.07830914f, -0.03047594f, -0.03795488f, 0.13639860f, 0.11445983f, -0.04827885f, 0.19310440f, 
    0.22715408f, -0.18691327f, 0.32893983f, -0.19517852f, -0.07536978f, 0.00029453f, 0.08363969f, 0.11303257f, 
    0.04131890f, 0.04206225f, 0.14565626f, 0.36153927f, 0.17866889f, 0.02651918f, 0.27385595f, 0.02895815f, 
    0.07536352f, -0.09090966f, 0.05269096f, -0.07305134f, -0.01201332f, -0.17340837f, -0.01317603f, 0.04589104f, 
    -0.13493359f, -0.02028367f, -0.04495706f, -0.08031622f, 0.18591207f, 0.01032919f, -0.02104923f, -0.07746425f, 
    -0.21174157f, -0.28572536f, -0.19605136f, -0.32064003f, 0.29702458f, 0.08754213f, 0.23040581f, -0.04352644f, 
    0.04445607f, -0.11987498f, 0.02265738f, -0.05818669f, 0.18210772f, 0.02770268f, 0.24325369f, 0.14071840f, 
    0.15443791f, 0.12703350f, 0.08764262f, -0.24505512f, 0.00525378f, -0.00102458f, 0.18489216f, 0.20802836f, 
    0.07757736f, -0.01513921f, -0.00163220f, 0.04155891f, -0.21181469f, 0.04738733f, -0.01107185f, 0.21234961f, 
    0.22551231f, 0.00911901f, -0.07446732f, -0.22316191f, 0.11585192f, 0.06342945f, 0.00171571f, 0.05545406f, 
    0.12567848f, 0.17945506f, -0.05082661f, -0.19517504f, 0.05402806f, 0.00143165f, -0.00873552f, -0.07731424f, 
    0.18358606f, 0.09304458f, 0.25295797f, 0.10371014f, 0.18591194f, -0.16279101f, 0.14921014f, -0.14592750f, 
    0.17120694f, 0.11047784f, -0.06005611f, 0.12907432f, -0.17983946f, -0.03219635f, -0.07487630f, -0.33437791f, 
    0.13553371f, 0.52994800f, -0.05202392f, -0.00216440f, -0.00512661f, -0.07393239f, 0.11410953f, 0.16682592f, 
    0.09987996f, 0.08173015f, 0.01339164f, 0.07604644f, 0.05757726f, 0.49288115f, -0.02828993f, 0.06228764f, 
    0.01779873f, 0.15713038f, 0.04602861f, 0.12979369f, -0.07997417f, -0.00621292f, 0.00584815f, 0.09024743f, 
    0.12042674f, -0.13240948f, 0.37540948f, 0.24232925f, 0.14463811f, -0.01188042f, -0.18808852f, -0.22921811f, 
    -0.00815642f, -0.08410274f, 0.02090975f, -0.02178324f, 0.18144554f, 0.11807437f, 0.11394504f, 0.32524928f, 
    0.20391870f, 0.06589536f, -0.05653571f, 0.06016236f, -0.01188558f, -0.14354448f, 0.02427284f, -0.17491269f, 
    -0.07547986f, -0.18098475f, -0.18248510f, 0.07330442f, 0.00871105f, 0.09526138f, -0.15034296f, 0.09123218f, 
    -0.06452630f, -0.21440671f, -0.17470603f, -0.33159855f, 0.10644752f, -0.00549839f, -0.13795757f, -0.19518514f, 
    -0.05867916f, -0.01743593f, -0.04773076f, 0.09298646f, 0.15481101f, 0.13413246f, 0.08402801f, 0.28545287f, 
    -0.08895400f, 0.55547059f, -0.41458967f, 0.24845123f, -0.04024050f, -0.00719159f, 0.05003958f, 0.13194644f, 
    -0.05720409f, -0.19376689f, -0.19856237f, -0.25048354f, 0.10020994f, -0.03818347f, 0.23366101f, -0.06764669f, 
    -0.20953637f, -0.06502165f, 0.08743579f, -0.11450561f, 0.04899355f, 0.03266060f, 0.14557442f, 0.21652879f, 
    -0.33391213f, 0.03132783f, 0.12999293f, -0.31677505f, -0.09243648f, 0.01050535f, 0.10576298f, -0.14659135f, 
    0.02037627f, 0.02907829f, -0.04281111f, 0.04962088f, 0.10868159f, -0.22713009f, 0.09147330f, 0.28054324f, 
    -0.04624559f, -0.10518340f, 0.10219281f, 0.09084350f, 0.18748593f, 0.12558243f, 0.02821171f, 0.08965974f, 
    0.21378163f, -0.18401584f, 0.43243125f, -0.07171928f, 0.08652558f, 0.02300663f, -0.02772454f, 0.13889156f, 
    -0.01618840f, 0.10668834f, 0.03653737f, 0.07181847f, 0.19798651f, -0.15933585f, -0.15184148f, -0.33434948f, 
    0.00723251f, -0.04710595f, 0.29515576f, 0.01085909f, 0.11032183f, 0.13099711f, 0.04681779f, 0.04971373f, 
    0.10781239f, 0.01124049f, 0.15342298f, 0.12513837f, 0.12506822f, 0.03151231f, -0.09997699f, -0.06263388f, 
    -0.01517655f, -0.27339724f, -0.31491521f, -0.25565973f, 0.04002519f, -0.11724746f, 0.05123094f, 0.02336155f, 
    -0.09015670f, 0.05225188f, -0.18348248f, -0.06612217f, -0.13703413f, 0.09324600f, -0.07177880f, -0.11723197f, 
    0.39608601f, -0.56296098f, 0.30934045f, -0.02708882f, -0.09365268f, -0.03538626f, -0.08953095f, -0.08191176f, 
    0.24013425f, 0.01670047f, 0.04094171f, 0.06105594f, 0.10432778f, 0.08528068f, 0.01459881f, 0.10867301f, 
    0.16835566f, -0.08364974f, -0.02373589f, 0.34532902f, -0.09679731f, -0.03811828f, -0.02345089f, -0.08132219f, 
    -0.06376778f, 0.11645000f, -0.10466798f, -0.30553746f, -0.00619521f, 0.06291492f, -0.00315687f, 0.04356654f, 
    -0.09236131f, 0.14601357f, 0.17182922f, 0.04419763f, -0.28722042f, -0.19754915f, 0.10519657f, -0.22171327f, 
    -0.11532640f, 0.11665840f, -0.04194560f, -0.12666586f, 0.20769322f, 0.11169585f, 0.30317429f, 0.38613397f, 
    0.12433124f, 0.01915834f, -0.08020601f, -0.08709030f, -0.00884202f, -0.10994842f, 0.06802408f, 0.09186330f, 
    -0.07415076f, -0.10655329f, -0.11180692f, -0.33607045f, -0.23782998f, -0.41777256f, -0.28252757f, 0.02110413f, 
    -0.08460763f, -0.13444230f, -0.12820849f, 0.15516825f, -0.06427865f, -0.11417913f, -0.04589298f, -0.00775088f, 
    0.15790503f, 0.26994866f, 0.00495593f, 0.12943317f, 0.06765330f, 0.07020211f, -0.05838468f, 0.12279373f, 
    0.07915461f, 0.09621283f, -0.03353910f, 0.12820256f, -0.29496878f, 0.00853446f, -0.20707840f, -0.15364103f, 
    0.14096402f, 0.16784565f, -0.15564847f, -0.07156583f, 0.08832996f, -0.02061830f, -0.06704913f, -0.24123050f, 
    0.19830701f, -0.00290521f, 0.39775553f, -0.41017783f, -0.13284630f, 0.00845976f, 0.02388915f, -0.14744397f, 
    -0.21130009f, 0.04186370f, -0.05034477f, 0.09885330f, -0.66461736f, 0.00965798f, -0.27669060f, 0.47812313f, 
    0.25384140f, -0.13239975f, -0.09620670f, -0.16944836f, 0.21142438f, -0.24537939f, -0.14402950f, 0.05145868f, 
    0.14765754f, -0.03680240f, 0.45571727f, -0.04847240f, 0.14078860f, -0.00059986f, -0.07424909f, -0.11569107f, 
    -0.01751252f, 0.07668351f, 0.10040615f, 0.03602054f, 0.14535595f, -0.02180601f, -0.04837980f, -0.34449458f, 
    0.03661051f, -0.16408706f, -0.07508498f, -0.05221915f, 0.06164275f, 0.12561749f, -0.08323297f, -0.03935663f, 
    -0.14499767f, 0.13728389f, 0.04598638f, -0.14620063f, 0.08157405f, -0.07596954f, 0.17468566f, 0.03134630f, 
    -0.06563230f, 0.00288694f, -0.00026170f, 0.08168954f, -0.41541794f, 0.06919831f, 0.02638723f, -0.58607018f, 
    0.15421212f, 0.19853546f, -0.04927022f, 0.02328724f, 0.09516796f, 0.16121532f, -0.19068158f, 0.07430534f, 
    -0.02024546f, 0.12862226f, 0.20739606f, 0.04314867f, 0.21178944f, 0.13388185f, 0.08634041f, -0.05317331f, 
    0.15663314f, 0.12203021f, 0.12976313f, 0.44745520f, -0.04881673f, -0.24850819f, 0.14590009f, 0.05791191f, 
    0.11542296f, -0.02512011f, -0.01469528f, 0.07639959f, -0.09728990f, -0.15882491f, 0.03042683f, -0.10621776f, 
    0.03329546f, -0.00138520f, 0.22360985f, -0.10214038f, 0.14828888f, -0.10459217f, -0.15611364f, 0.10929485f, 
    -0.11395346f, -0.17809863f, -0.04112948f, -0.10854102f, -0.16649218f, 0.22681212f, 0.19230646f, 0.14981839f, 
    0.03323235f, 0.12582588f, 0.01149708f, 0.03982880f, 0.06718378f, -0.00928832f, 0.10572696f, 0.19814554f, 
    0.44934303f, -0.08556943f, 0.12564664f, -0.23481530f, -0.13954911f, -0.10516533f, -0.18364783f, -0.19921255f, 
    0.04735103f, -0.02680097f, 0.00470594f, 0.10717618f, 0.06441944f, 0.20490481f, -0.12797195f, -0.34582397f, 
    -0.03326548f, 0.04410624f, 0.00914941f, 0.11413511f, 0.07867455f, -0.10359430f, 0.07296944f, -0.11246485f, 
    0.07330442f, 0.00778130f, -0.00266052f, -0.18910874f, 0.04835989f, 0.02748309f, -0.17977758f, 0.19895148f, 
    0.09919824f, -0.06614783f, 0.06704763f, 0.06923749f, -0.29695714f, 0.20314634f, -0.03988002f, -0.21705957f, 
    0.02785178f, 0.05302200f, -0.06994879f, -0.15391992f, 0.04426670f, -0.08577498f, -0.14053005f, 0.08188214f, 
    0.00892797f, 0.00539994f, 0.00488006f, 0.02845586f, 0.00328243f, 0.00951236f, -0.03066312f, -0.03985879f, 
    0.02558100f, -0.01373326f, -0.00748384f, 0.01498537f, -0.01976187f, 0.02614504f, -0.01433562f, 0.00593901f, 
    0.01176992f, -0.01494468f, 0.02688250f, 0.02591940f, 0.00096787f, 0.01514619f, 0.02131503f, -0.00276393f, 
    0.00077132f, -0.02085510f, 0.01008406f, -0.01403189f, -0.01187803f, -0.03280540f, -0.01586485f, 0.00849916f, 
    -0.03861809f, 0.02749518f, 0.02680429f, -0.00688967f, 0.02191629f, -0.01011063f, 0.01831997f, 0.00605181f, 
    -0.02161382f, -0.01739805f, 0.01879873f, -0.03816194f, -0.02366852f, 0.02641797f, 0.00887123f, -0.00846530f, 
    0.00688184f, -0.02769978f, -0.02312919f, 0.02452526f, 0.00403400f, -0.01782386f, 0.00101464f, -0.01180690f, 
    0.01807781f, -0.01236314f, -0.01197650f, -0.03829278f, -0.00316091f, 0.00548815f, 0.02175758f, -0.02689210f, 
    -0.00251190f, -0.03990593f, 0.02583845f, 0.01960202f, 0.00945656f, -0.03008949f, -0.00496342f, -0.03131204f, 
    -0.01339626f, -0.01122675f, -0.04166438f, 0.01695055f, 0.02607632f, -0.01635616f, -0.03182016f, 0.02384660f, 
    -0.01312461f, -0.01175217f, -0.01978311f, 0.01896236f, 0.02333396f, -0.01311247f, 0.02677171f, 0.00964008f, 
    0.01020884f, -0.00164343f, -0.03216076f, -0.02959090f, 0.00992860f, -0.03341449f, -0.01937611f, 0.01819392f, 
    -0.03010829f, 0.00144391f, -0.00084000f, -0.03500770f, 0.01089115f, -0.03556276f, 0.02307028f, 0.01292032f, 
    -0.03607532f, 0.02914815f, 0.00680768f, -0.00548094f, 0.00241991f, -0.02272097f, -0.00889085f, -0.02818846f, 
    0.02820192f, -0.01679547f, 0.01198284f, 0.02786139f, 0.01869056f, -0.03260710f, -0.03497344f, 0.01094370f, 
    -0.00312661f, -0.02951657f, 0.01746796f, 0.02016553f, 0.02950251f, 0.00001748f, -0.03914927f, 0.00913746f, 
    -0.00626319f, -0.01603922f, -0.02787307f, -0.03631352f, -0.02520574f, -0.03324280f, 0.01428147f, -0.01990997f, 
    -0.00391377f, 0.01000744f, -0.02016160f, -0.01116519f, 0.02461207f, -0.02322389f, -0.00641964f, -0.02495146f, 
    0.00930117f, 0.00650006f, -0.02289215f, 0.00950013f, 0.00108420f, 0.00125618f, -0.00705554f, -0.03369578f, 
    0.02895753f, -0.01237001f, 0.01669109f, -0.02425826f, -0.00130735f, -0.00645578f, 0.02662137f, -0.00370650f, 
    -0.02277788f, 0.00124194f, 0.00937653f, 0.01384296f, 0.02615048f, -0.01576922f, -0.03179982f, -0.00241069f, 
    0.00928961f, 0.03375484f, -0.02714144f, -0.00077019f, -0.03444005f, -0.03704002f, 0.00164453f, -0.00345753f, 
    0.02615058f, -0.03569341f, 0.01981970f, -0.03127158f, -0.02917064f, 0.00745482f, 0.02525555f, -0.02336404f, 
    0.01030165f, 0.02598385f, -0.03362370f, 0.02741085f, -0.01029944f, 0.02866797f, -0.01439159f, -0.04088832f, 
    -0.02450979f, -0.02807917f, -0.01981195f, -0.04068520f, -0.02529943f, 0.02878362f, -0.01676317f, 0.02469415f, 
    -0.03740598f, -0.01021916f, 0.01336512f, 0.01839079f, -0.00699143f, 0.00291149f, 0.02370601f, 0.00686528f, 
    0.01893590f, 0.02869643f, -0.01210485f, 0.01429170f, 0.02391901f, 0.01144856f, 0.02194348f, -0.00812780f, 
    0.02909183f, 0.01265687f, 0.00217618f, -0.01661145f, 0.01538582f, 0.02691425f, -0.03899039f, -0.01249031f, 
    -0.00214330f, 0.02013568f, -0.03343500f, -0.02223385f, -0.00264837f, -0.04111477f, -0.02042328f, -0.02175274f, 
    -0.01808346f, -0.00384992f, 0.02802759f, 0.01753458f, -0.02107330f, -0.00026333f, 0.02327212f, -0.00403958f, 
    -0.01409358f, 0.02643312f, -0.00479605f, 0.01015315f, -0.02043913f, -0.03741581f, -0.00834510f, 0.00360821f, 
    -0.00401830f, 0.02375403f, 0.02645975f, -0.01672803f, -0.00840455f, -0.01866903f, 0.00995112f, -0.03315213f, 
    -0.03620912f, -0.04190975f, 0.02249524f, -0.03648164f, 0.00366945f, -0.01003806f, -0.00398895f, -0.02908918f, 
    -0.04048333f, 0.01685747f, 0.00111347f, -0.04201072f, -0.00836510f, 0.00322753f, -0.01931171f, -0.03502094f, 
    0.00031481f, 0.02596374f, 0.02357713f, -0.01878539f, -0.01326413f, -0.03476830f, 0.00012863f, 0.01204675f, 
    -0.01214642f, 0.01162305f, 0.00085785f, 0.00000162f, 0.02714428f, -0.00806283f, -0.04082529f, -0.00194578f, 
    0.01126208f, 0.01757516f, 0.00478817f, -0.01994439f, -0.01680047f, -0.02093569f, -0.01304671f, -0.02688016f, 
    -0.01066743f, 0.01832572f, -0.01790569f, -0.00272317f, 0.00839322f, 0.00849590f, -0.04070806f, -0.00972890f, 
    0.01531552f, -0.00666216f, -0.02969347f, -0.00551634f, 0.00573533f, 0.03577621f, 0.02743306f, 0.00111488f, 
    -0.03231238f, -0.03064621f, -0.02901793f, -0.00242306f, 0.00394783f, -0.00414692f, 0.02904947f, 0.00124985f, 
    -0.01093076f, -0.03476733f, -0.03370477f, 0.00750799f, 0.00643333f, -0.02540359f, -0.02447470f, -0.00325353f, 
    0.02456615f, 0.00990438f, -0.00907002f, -0.00935637f, -0.04122714f, 0.00006295f, 0.02850973f, -0.02082432f, 
    0.00709667f, -0.03722029f, -0.01280177f, -0.01096334f, -0.02650306f, -0.03566218f, -0.00623607f, -0.00395011f, 
    0.01003530f, -0.01730959f, 0.01518034f, -0.04009160f, 0.00266614f, -0.03255539f, -0.04254373f, 0.01422146f, 
    -0.03093242f, 0.00665332f, 0.00364696f, -0.03770716f, 0.01737547f, -0.00726116f, -0.01975606f, 0.00266872f, 
    -0.00117487f, -0.03239908f, -0.02365931f, 0.03030925f, -0.00985261f, -0.03308662f, -0.03827528f, 0.02845648f, 
    -0.01398871f, -0.01589765f, 0.02604956f, 0.03000224f, -0.00730558f, 0.01768059f, -0.00149982f, -0.03002723f, 
    0.01047381f, -0.03367376f, -0.04114521f, -0.03797618f, 0.00510370f, -0.03002800f, -0.00525450f, 0.00276505f, 
    0.00174327f, 0.00288878f, 0.01193552f, 0.02301588f, -0.03407511f, 0.02761601f, 0.00475974f, -0.01047385f, 
    -0.03510112f, -0.01848814f, -0.03657856f, 0.02170691f, 0.01493957f, -0.03605248f, 0.02049398f, 0.02437270f, 
    -0.03289191f, -0.04116125f, 0.00293112f, 0.00861685f, 0.00794786f, 0.02437692f, -0.02778078f, -0.00480145f, 
    0.01811033f, 0.01830673f, -0.02724764f, -0.02402490f, -0.03366403f, 0.00848374f, -0.02528016f, -0.03950287f, 
    0.01073411f, -0.01493912f, 0.02794112f, 0.01286187f, 0.00191179f, 0.02531796f, 0.02352406f, -0.00041320f, 
    0.01301530f, -0.03477507f, 0.00994901f, 0.01730396f, -0.01569610f, 0.01197381f, 0.00683445f, 0.02697699f, 
    0.00917044f, -0.02434885f, 0.01365262f, 0.02726779f, -0.00121651f, -0.00196482f, -0.02789425f, -0.01977189f, 
    -0.03151746f, 0.02877435f, -0.01867495f, -0.03150827f, 0.02986577f, -0.03005867f, -0.01827071f, -0.01153176f, 
    0.00804901f, 0.01601785f, -0.03213300f, 0.01599482f, -0.01501242f, 0.02273961f, -0.04103177f, 0.00439552f, 
    -0.02773909f, -0.02790476f, 0.01228957f, -0.02520198f, -0.02328333f, -0.00890628f, 0.00821626f, -0.03502564f, 
    0.00259982f, -0.00711476f, -0.03340896f, -0.01127099f, -0.00522121f, 0.01714512f, -0.03893797f, -0.00482507f, 
    0.00758178f, -0.01883182f, -0.03321438f, -0.03004156f, -0.00498194f, 0.02730174f, -0.00894991f, 0.01401093f, 
    -0.00366018f, -0.00990164f, 0.01556694f, -0.02857294f, -0.03409963f, 0.00121632f, 0.02231039f, -0.03949355f, 
    0.02626632f, -0.03901544f, -0.01794250f, 0.01652978f, -0.01906612f, -0.00855153f, -0.00896689f, 0.02617217f, 
    0.02726604f, -0.00093455f, -0.02813946f, -0.03618033f, -0.00027888f, 0.02199554f, -0.04094378f, -0.00279463f, 
    -0.01283539f, 0.02492380f, -0.01748254f, -0.00564038f, -0.00722331f, 0.00385230f, 0.02114846f, 0.02711542f, 
    0.00470534f, 0.02522358f, -0.02583802f, -0.03229937f, -0.00628634f, -0.00770290f, -0.03308539f, -0.00495758f, 
    -0.01613120f, 0.01490079f, 0.03927565f, 0.00637605f, 0.00468861f, -0.02488232f, 0.02510754f, -0.01293060f, 
    -0.02927439f, -0.02727553f, -0.00426732f, -0.02401925f, 0.00384165f, 0.01485071f, -0.01750854f, -0.03217800f, 
    0.01287437f, 0.02862176f, -0.04185835f, -0.01980454f, 0.00801279f, 0.00790658f, 0.02845027f, -0.01947038f, 
    -0.02972671f, -0.00973018f, -0.00683169f, -0.01082720f, 0.02284044f, -0.02843696f, -0.00524438f, -0.03434255f, 
    -0.02208181f, -0.00210221f, 0.01986716f, -0.01452809f, -0.00992241f, -0.01909599f, -0.00532044f, 0.00326794f, 
    0.02519430f, 0.00969177f, 0.01358709f, -0.01463660f, 0.01269802f, -0.00811817f, 0.02013595f, -0.02041195f, 
    -0.00658856f, -0.01962364f, 0.03035989f, 0.00893980f, -0.03259953f, 0.00120030f, -0.03121182f, 0.02489471f, 
    -0.00261937f, -0.02928067f, 0.00547839f, 0.02260971f, 0.02373484f, 0.01454449f, 0.02082345f, -0.02964563f, 
    -0.00525187f, 0.00410217f, 0.02297166f, 0.00364761f, -0.02798448f, 0.00023243f, -0.03489141f, -0.00916390f, 
    -0.04157845f, -0.00092115f, -0.03066757f, 0.02905219f, 0.02101352f, -0.02914450f, -0.02126663f, 0.01875700f, 
    0.02642038f, -0.02770480f, -0.02843299f, -0.01714566f, 0.00920517f, -0.03928324f, -0.02693858f, 0.01509063f, 
    -0.02073182f, -0.02820023f, 0.01878873f, -0.00593150f, -0.02349636f, 0.02797472f, -0.01278076f, -0.00866369f, 
    -0.03445418f, 0.02416858f, -0.01555279f, 0.01298795f, 0.00106271f, -0.03753607f, 0.00117026f, 0.01738261f, 
    -0.03741357f, 0.00484111f, -0.03762157f, -0.00406240f, -0.02931400f, 0.00975992f, -0.01681791f, -0.02300449f, 
    -0.01141671f, -0.03135876f, -0.03995745f, -0.01511748f, 0.02342980f, -0.00829838f, 0.01393006f, -0.02022984f, 
    -0.04237659f, 0.02166464f, -0.00357047f, -0.03515472f, -0.01987915f, 0.01194404f, 0.00865156f, 0.02824665f, 
    0.00581226f, -0.00978889f, -0.01653881f, 0.00937964f, 0.02651598f, -0.03353026f, -0.00189642f, 0.00219581f, 
    -0.01880148f, -0.03819383f, -0.01067479f, 0.00353323f, 0.02463584f, 0.02890194f, 0.02004496f, 0.00077061f, 
    -0.02560586f, -0.01483536f, 0.01477643f, 0.00665583f, -0.01797428f, -0.01095357f, 0.00093993f, 0.00704488f, 
    -0.02652061f, -0.00844922f, -0.03672785f, 0.02695023f, -0.01905820f, 0.01150091f, -0.03112217f, -0.00916791f, 
    0.00389231f, -0.02373938f, -0.00559867f, 0.00370039f, 0.00591326f, -0.03637755f, 0.02208125f, 0.02509891f, 
    -0.02240409f, 0.00039317f, 0.02260891f, 0.01214076f, 0.01329156f, -0.00737293f, 0.01471333f, -0.01013990f, 
    0.01641606f, -0.01432472f, -0.02472627f, -0.03582609f, 0.01425615f, -0.02150341f, 0.02660137f, -0.01252582f, 
    -0.04046807f, -0.04078132f, -0.03077084f, 0.02095558f, -0.04059209f, -0.03379754f, -0.02734831f, -0.00596572f, 
    0.02650339f, -0.00104919f, -0.00651744f, 0.02275496f, -0.00202474f, 0.00882119f, -0.01868050f, -0.03809117f, 
    -0.03481191f, 0.00353118f, -0.01875484f, -0.03534954f, -0.03967538f, 0.02981974f, -0.02965085f, -0.00240755f, 
    -0.02025003f, -0.01638196f, 0.02711431f, -0.00149099f, -0.00493615f, -0.01538728f, -0.00372576f, 0.01791739f, 
    -0.02459303f, -0.00901548f, -0.03309333f, 0.02249568f, -0.02067526f, -0.00061657f, -0.03054381f, -0.03028952f, 
    -0.01464912f, -0.00661803f, -0.02680922f, 0.01545584f, 0.00901065f, -0.01805168f, -0.03620808f, 0.02011934f, 
    0.00852520f, 0.02104409f, 0.01822896f, 0.02928957f, -0.01050068f, -0.00937488f, 0.02094720f, -0.00008473f, 
    0.01979562f, -0.01126655f, -0.04043149f, -0.00540146f, 0.00150801f, 0.01665008f, 0.01057118f, -0.02614378f, 
    0.03062972f, -0.00007125f, -0.02892486f, 0.03408584f, 0.00751629f, 0.02438878f, 0.02290650f, -0.01854933f, 
    -0.02609426f, -0.02170935f, -0.02311786f, -0.00611013f, 0.01473487f, 0.02341593f, -0.03986149f, 0.01914314f, 
    -0.03893127f, -0.00652926f, -0.03935332f, -0.00129065f, -0.03431769f, -0.01787196f, 0.01793448f, -0.02094163f, 
    0.00421727f, 0.00070041f, -0.02400584f, 0.02977137f, 0.03193464f, 0.00256478f, -0.04447936f, 0.01090400f, 
    0.01057220f, -0.00121309f, -0.00371693f, 0.02011464f, -0.00836494f, -0.02637522f, 0.00624342f, 0.02975227f, 
    0.01094595f, -0.00262459f, 0.00929157f, -0.03964185f, -0.02835682f, -0.03976786f, 0.01869545f, 0.00522552f, 
    0.01686782f, -0.02479953f, 0.02462525f, -0.00418508f, 0.00566904f, 0.01088365f, 0.01059648f, -0.03969960f, 
    -0.01894216f, -0.02210704f, 0.02190476f, -0.03389268f, -0.03361492f, -0.01117330f, -0.01018042f, 0.01217591f, 
    0.00926997f, -0.04337278f, -0.00539238f, -0.00930269f, -0.02414727f, -0.03691673f, 0.02795045f, -0.03473186f, 
    0.01384190f, 0.01502559f, -0.00540168f, 0.02842700f, -0.01848463f, 0.01630110f, -0.03292076f, -0.01737421f, 
    0.01190159f, 0.01700914f, 0.00708987f, -0.03965680f, -0.04086849f, -0.01739462f, -0.01083120f, -0.02767036f, 
    0.02113143f, -0.01215141f, 0.02264999f, -0.03206196f, 0.02730710f, -0.00166677f, 0.02284946f, -0.03630687f, 
    0.04134897f, -0.00251964f, -0.02097438f, -0.04072932f, -0.02242861f, 0.01581533f, 0.02360282f, -0.02092536f, 
    -0.02186225f, -0.00995989f, 0.02710319f, -0.02990102f, 0.00951290f, 0.01749372f, 0.03979620f, -0.02275515f, 
    0.03965605f, 0.01469685f, 0.01925408f, 0.02131826f, -0.02817008f, 0.02015954f, -0.02812221f, 0.00980237f, 
    -0.03618796f, 0.03592780f, 0.01331972f, -0.00643862f, 0.01613940f, -0.01687797f, -0.02478491f, -0.00721233f, 
    -0.03151304f, 0.02352016f, -0.03205584f, 0.01215537f, 0.02920661f, -0.01440016f, -0.03622928f, -0.04427081f, 
    0.02392894f, -0.01727473f, 0.02531147f, -0.03183084f, -0.00647176f, 0.02873838f, 0.01570340f, -0.03479658f, 
    0.02210089f, -0.04060882f, -0.00043725f, -0.00439462f, 0.02516606f, -0.01733866f, -0.00859778f, 0.00732132f, 
    -0.03866473f, 0.01980648f, -0.04024304f, 0.01183941f, -0.02395746f, -0.04192307f, 0.02888115f, -0.04094470f, 
    0.01571536f, 0.00059197f, 0.00275528f, -0.02630034f, 0.02335692f, 0.02383002f, 0.00062073f, 0.02500909f, 
    -0.02508429f, 0.01245867f, -0.01974082f, 0.00370158f, -0.03144255f, 0.04124461f, -0.03115377f, -0.00560637f, 
    0.03153061f, 0.02046572f, -0.01926829f, -0.01065054f, -0.02588565f, -0.00461575f, -0.00582400f, 0.02721967f, 
    0.00009015f, 0.00228077f, 0.02463266f, 0.01849481f, -0.04164804f, -0.02312807f, -0.03093701f, 0.02772932f, 
    -0.00725319f, -0.00507029f, 0.01839179f, -0.00788903f, -0.01240868f, -0.02981856f, 0.00315962f, -0.03042877f, 
    0.01839581f, -0.02316876f, 0.02834909f, -0.01086273f, -0.03000912f, 0.01251892f, -0.03472009f, 0.01736607f, 
    -0.02135477f, -0.02077674f, -0.03521469f, -0.01987118f, -0.03407423f, 0.03037346f, 0.02463628f, 0.01304186f, 
    -0.03885455f, -0.02523297f, 0.00540455f, 0.02542004f, -0.03431918f, -0.02712603f, -0.01210005f, 0.01480467f, 
    -0.01237040f, 0.01103031f, 0.01069333f, 0.02330297f, -0.03927583f, 0.01372285f, -0.02312216f, -0.03097834f, 
    -0.02758742f, -0.02216867f, -0.01061920f, 0.01141978f, 0.00296316f, 0.00936483f, -0.00093656f, -0.04203831f, 
    -0.02476072f, -0.02685408f, -0.01221910f, 0.03013953f, -0.02245508f, 0.01450872f, -0.02533221f, -0.00392781f, 
    0.01397585f, 0.02375000f, -0.01170995f, -0.02279182f, 0.00625425f, -0.04021858f, 0.01412041f, -0.03942528f, 
    -0.00514855f, 0.01326165f, 0.01033152f, -0.02229312f, 0.01230829f, -0.02885175f, 0.02332036f, 0.02788991f, 
    -0.00325661f, 0.01163717f, -0.02471133f, 0.00320978f, -0.03868473f, 0.02026223f, -0.00536116f, -0.01984956f, 
    0.00713341f, 0.00609267f, 0.01519220f, -0.02267554f, -0.01974533f, 0.01563063f, -0.02023139f, 0.01553385f, 
    -0.00329099f, -0.02219959f, -0.03270376f, 0.02900655f, -0.02866740f, -0.04016297f, -0.02217142f, -0.02001096f, 
    -0.01257958f, -0.02944830f, 0.00206089f, 0.00602047f, 0.01408350f, 0.00392518f, 0.01437060f, -0.02921563f, 
    0.02042180f, -0.02983341f, 0.01940363f, -0.03104152f, -0.02332425f, 0.01827904f, -0.02301168f, -0.01191738f, 
    -0.01620854f, 0.01682337f, 0.01942955f, -0.01801906f, -0.02450782f, -0.00238995f, -0.00369645f, 0.01340228f, 
    0.00875537f, -0.02024691f, -0.02341154f, -0.03462278f, 0.02946751f, -0.02686117f, 0.00506932f, 0.02269588f, 
    -0.02533927f, 0.00567739f, -0.03800899f, 0.02277448f, -0.02633019f, 0.02455533f, -0.00669163f, -0.02101040f, 
    0.02417341f, -0.00886957f, 0.02604247f, 0.00184453f, -0.01049887f, 0.01872756f, -0.02971899f, -0.03631135f, 
    -0.01590347f, -0.01620582f, 0.00871280f, -0.02775790f, -0.03206186f, -0.00636839f, -0.00966541f, -0.00893687f, 
    -0.02974253f, -0.01140290f, -0.00118111f, -0.01983253f, -0.02116034f, 0.01992914f, -0.01472720f, -0.00205382f, 
    0.01888495f, 0.00689445f, 0.01325410f, -0.02415225f, -0.03434556f, -0.02676808f, 0.01887496f, -0.03763998f, 
    0.01651697f, 0.00034860f, 0.03261754f, -0.03120027f, -0.01102844f, -0.03779948f, -0.03481254f, 0.02854689f, 
    -0.01551608f, -0.00487228f, 0.01221466f, 0.00651838f, 0.02731078f, -0.00755290f, -0.01293725f, -0.01707212f, 
    -0.02993939f, 0.02326870f, 0.02693259f, 0.01222287f, 0.01937331f, -0.02414748f, -0.00771526f, -0.01788039f, 
    -0.00253157f, 0.03004072f, 0.01697208f, 0.02790594f, 0.00084407f, 0.01135299f, -0.02227992f, 0.00011860f, 
    -0.03928008f, -0.00162194f, -0.03247143f, -0.03183311f, -0.00935106f, -0.01536442f, 0.02574104f, -0.00332497f, 
    -0.02435397f, 0.00588004f, 0.00482185f, -0.03480269f, 0.02118821f, -0.03434143f, 0.00470488f, 0.01973733f, 
    0.03413710f, -0.00737443f, 0.00690861f, -0.00581679f, 0.00121324f, -0.04115795f, -0.00340821f, -0.02325066f, 
    -0.02038733f, -0.02451466f, 0.01212955f, 0.00433710f, -0.02065197f, -0.02701883f, 0.01713923f, -0.02830778f, 
    0.02535223f, 0.02640036f, 0.01283704f, -0.03413483f, -0.01815421f, -0.00462502f, 0.02428151f, 0.01062799f, 
    0.01865485f, 0.02040903f, -0.03301194f, -0.00767334f, 0.01103251f, 0.01410240f, -0.04190510f, 0.02030420f, 
    0.00776209f, 0.00953145f, -0.01229984f, -0.03231283f, 0.03529197f, 0.00824702f, -0.02970313f, 0.02691391f, 
    0.00190663f, -0.01326196f, -0.01390089f, -0.02530722f, -0.01974370f, -0.01579450f, -0.02135875f, -0.00054570f, 
    -0.02670619f, -0.00170991f, -0.04076938f, -0.01369258f, 0.00024554f, -0.01253996f, -0.03178649f, 0.02861620f, 
    0.02299625f, -0.00958457f, -0.01060737f, -0.02679053f, -0.01205696f, 0.00019136f, 0.02834710f, -0.00439004f, 
    -0.03477204f, 0.02940507f, -0.03727083f, 0.00521960f, -0.01445238f, 0.01202641f, -0.02482280f, -0.01437930f, 
    0.01429803f, -0.02788220f, -0.03478548f, -0.00587870f, -0.01433956f, -0.01849019f, -0.02667065f, -0.00850242f, 
    -0.01114705f, 0.00287974f, -0.03857768f, -0.00716991f, 0.00154970f, -0.02642780f, -0.01126210f, 0.01223979f, 
    0.02505906f, 0.00173164f, -0.01537173f, -0.02711267f, -0.03884888f, 0.01493239f, 0.02802250f, 0.01868279f, 
    -0.00562489f, 0.02003402f, 0.02842099f, -0.01605715f, -0.02175973f, 0.02507548f, 0.00912356f, -0.00892326f, 
    0.02350442f, -0.03335424f, 0.01856700f, 0.00959727f, -0.02044749f, -0.00724551f, -0.02360916f, -0.00219254f, 
    -0.00103067f, 0.01515635f, -0.01395949f, -0.02869236f, -0.04055365f, -0.02880095f, 0.02412737f, -0.04292097f, 
    0.00008392f, -0.04285912f, -0.02432588f, -0.02945806f, 0.03231610f, -0.01037047f, -0.00148930f, 0.02099707f, 
    -0.01006783f, -0.03424485f, -0.00592181f, -0.04157743f, 0.02722090f, -0.01017027f, 0.01869869f, 0.03023007f, 
    0.00885731f, -0.00347536f, 0.00567895f, -0.02697693f, -0.01476564f, 0.00842625f, -0.01374179f, -0.02555271f, 
    -0.02819373f, -0.00000103f, -0.00798278f, -0.03120903f, -0.01361859f, -0.04015039f, -0.01977063f, -0.02385042f, 
    -0.03824665f, -0.01452924f, -0.01918965f, -0.02432403f, -0.02070445f, 0.00096956f, -0.02182573f, -0.03585720f, 
    -0.01875146f, 0.01474453f, 0.01824603f, 0.01294989f, 0.00968287f, 0.01252971f, -0.03128940f, 0.00161166f, 
    0.00636775f, -0.00617872f, 0.01188891f, 0.02362539f, -0.01421803f, 0.00070730f, -0.03003625f, -0.02921988f, 
    -0.00209315f, -0.02331236f, 0.02487863f, -0.01797219f, 0.01790977f, 0.00364827f, -0.01610417f, 0.01754930f, 
    -0.02430722f, -0.02153879f, 0.02190506f, -0.02438822f, -0.00272084f, -0.00777914f, 0.00307795f, -0.03015262f, 
    0.01776547f, -0.01511151f, -0.03150019f, -0.01297323f, -0.01114909f, -0.02508965f, 0.01407939f, 0.00166310f, 
    0.01730138f, -0.01286132f, 0.03509011f, -0.01669061f, 0.01806651f, -0.04241772f, -0.01828239f, 0.02333217f, 
    0.02102405f, 0.01171553f, 0.02469936f, 0.02779318f, 0.02312126f, 0.00711180f, 0.00681278f, 0.01327796f, 
    -0.02594835f, -0.03390357f, -0.00426963f, -0.01732170f, -0.01162503f, -0.00960555f, 0.02803349f, 0.02795449f, 
    -0.01669195f, 0.02440750f, -0.02327502f, 0.00871081f, 0.00328958f, 0.00611930f, -0.03633919f, -0.00936519f, 
    0.00980485f, -0.02652854f, 0.02679621f, -0.01756149f, -0.02971590f, -0.01890818f, -0.02158252f, -0.00496365f, 
    -0.01065992f, 0.02107668f, -0.02756772f, -0.04202069f, 0.00920845f, 0.01854104f, -0.03956798f, 0.00412815f, 
    0.02683716f, 0.01071101f, 0.02741068f, -0.01734983f, -0.01446150f, -0.00240485f, -0.01399460f, -0.02661778f, 
    -0.01674000f, 0.01245258f, -0.01368943f, -0.00076386f, -0.00845965f, 0.00127134f, -0.02834800f, -0.00744712f, 
    0.01058180f, -0.00673795f, -0.02766579f, 0.00703115f, -0.00504835f, 0.02191612f, -0.03141833f, -0.04051251f, 
    -0.00858564f, -0.03576920f, -0.04050176f, 0.01252931f, 0.01994273f, -0.00133945f, 0.01090195f, 0.01881607f, 
    -0.01714386f, -0.00906131f, 0.01537298f, -0.00088807f, -0.02972348f, -0.04234757f, -0.01134815f, -0.00551930f, 
    0.00054708f, -0.02552797f, -0.00980311f, -0.00141859f, -0.00549118f, -0.01983010f, -0.00653482f, -0.00806028f, 
    -0.01751147f, -0.04077155f, -0.01697240f, 0.01149742f, 0.01767392f, 0.02685349f, 0.02701804f, 0.00874985f, 
    0.00625993f, 0.00224415f, 0.00253803f, 0.00494706f, -0.03384565f, -0.02381401f, 0.00109666f, 0.00761711f, 
    0.02289686f, 0.03043422f, 0.02098108f, -0.00676544f, 0.01585168f, 0.00708232f, -0.00551891f, -0.01878257f, 
    0.01655505f, -0.01147814f, 0.01006492f, 0.02443469f, -0.02421370f, 0.02213299f, -0.01093622f, -0.03928680f, 
    0.01965429f, -0.03050970f, -0.03317187f, -0.02204428f, -0.03323191f, -0.00754814f, -0.02342012f, -0.00282200f, 
    0.01965213f, -0.01088727f, 0.02343609f, 0.02326139f, -0.02840218f, -0.00603298f, -0.01386721f, 0.02379775f, 
    0.02853330f, 0.01283383f, 0.01692077f, 0.02481934f, -0.03310270f, -0.01463563f, -0.03932906f, -0.01024838f, 
    0.01460258f, -0.01867907f, 0.01122440f, 0.01176327f, -0.02739062f, 0.00225328f, 0.02064890f, 0.02975115f, 
    0.02955645f, -0.15745400f, -0.03706476f, -0.04160572f, 0.02512278f, 0.03620346f, -0.08329547f, -0.02147701f, 
    -0.18686463f, -0.01413016f, -0.11869616f, -0.11226828f, 0.17247343f, 0.20779839f, 0.26231408f, 0.02454316f, 
    -0.06458247f, -0.13199814f, 0.08786292f, 0.06954857f, -0.07999751f, -0.08010987f, -0.02787206f, -0.19260229f, 
    -0.18570113f, -0.01553781f, -0.10613804f, -0.05380695f, 0.09088556f, -0.02518829f, -0.00808250f, -0.03169105f, 
    -0.02856993f, 0.05095354f, -0.08042893f, 0.03601405f, -0.16442281f, 0.05786732f, -0.10003836f, 0.10894199f, 
    0.07731789f, 0.00517729f, 0.11201543f, -0.13630210f, -0.18450442f, -0.01033285f, 0.00842451f, -0.11408287f, 
    0.13829023f, 0.29541487f, 0.30389446f, 0.21058458f, -0.02793554f, -0.06885424f, 0.02503440f, 0.07208440f, 
    0.04929996f, 0.02005086f, 0.01158604f, 0.02205350f, 0.23228762f, 0.31276825f, 0.11128383f, 0.11564361f, 
    0.06551144f, -0.05439227f, -0.02886143f, -0.07343064f, -0.00966114f, -0.03999309f, -0.02177319f, -0.01626412f, 
    -0.00482452f, 0.05182587f, 0.26598164f, 0.09312724f, 0.00801242f, 0.01902696f, -0.01154238f, 0.16803178f, 
    -0.08312768f, 0.15521318f, -0.05092669f, -0.10289120f, 0.03268921f, -0.06803464f, 0.00895466f, -0.07516949f, 
    0.03714749f, 0.09258682f, -0.06998183f, 0.02599746f, 0.06059424f, 0.11255006f, 0.02225652f, 0.18108277f, 
    -0.13524307f, 0.10266173f, -0.14027058f, -0.07838062f, 0.06945301f, 0.08652105f, 0.08249707f, -0.04736873f, 
    0.06763221f, -0.00035811f, -0.01689772f, -0.00557153f, -0.04195096f, -0.04419610f, -0.15681551f, -0.03323603f, 
    -0.04430027f, -0.05943566f, -0.06972682f, -0.04788238f, 0.08825959f, 0.05517092f, 0.00846301f, 0.06296742f, 
    -0.13451517f, -0.08893538f, -0.12507308f, -0.02348888f, -0.07682934f, 0.00679553f, -0.12584409f, -0.11241035f, 
    -0.08740267f, -0.09519278f, 0.02752464f, -0.04404305f, 0.26282951f, 0.14427774f, -0.24347165f, 0.02330290f, 
    0.10489889f, 0.05167508f, 0.02748370f, -0.10953894f, -0.03001376f, 0.11802660f, 0.03167067f, -0.02168913f, 
    0.05599171f, -0.00740510f, -0.05803951f, 0.04569584f, -0.07132324f, 0.02000085f, -0.01097503f, -0.15999472f, 
    0.02020307f, 0.18359546f, -0.06916857f, 0.18451419f, 0.11049558f, 0.04069569f, 0.15309456f, -0.26626134f, 
    -0.01845852f, 0.01510539f, -0.07861310f, -0.01782540f, 0.05547946f, 0.11954430f, 0.00920779f, 0.05965496f, 
    0.25009742f, -0.59985805f, 0.02494609f, -0.20073768f, -0.21569884f, -0.08195458f, 0.31768048f, 0.07589051f, 
    -0.00475136f, 0.04061334f, -0.00202768f, -0.03462695f, 0.10098063f, 0.16616119f, 0.00072061f, 0.07710236f, 
    0.12578295f, 0.06070890f, -0.05196815f, -0.05496237f, -0.06155940f, -0.07919600f, 0.05137093f, 0.01370289f, 
    0.12331393f, 0.28220204f, 0.24049912f, 0.11950715f, 0.12609141f, 0.00764205f, 0.00929040f, 0.10734753f, 
    -0.07342476f, -0.05663271f, 0.00990069f, 0.03634609f, -0.02290873f, -0.15372777f, -0.32086658f, 0.16691311f, 
    -0.01154354f, 0.04998238f, 0.02889572f, -0.02500144f, -0.18693964f, -0.16383955f, -0.18328060f, -0.11832613f, 
    0.30086833f, 0.28182364f, 0.14581130f, 0.16897894f, 0.03240754f, 0.07341134f, 0.15332098f, 0.07070131f, 
    -0.19854984f, 0.14885172f, -0.07570402f, -0.01520133f, 0.42740414f, 0.20403029f, 0.07270803f, -0.01540147f, 
    0.14750612f, -0.06946092f, 0.04286802f, 0.02346648f, 0.00802947f, -0.15232678f, -0.00251629f, -0.15961824f, 
    0.46528694f, 0.09059025f, -0.28425127f, 0.16754217f, 0.07972942f, 0.08112660f, 0.11338528f, -0.03706315f, 
    0.07046854f, 0.09655185f, -0.08084612f, 0.07373317f, 0.43741107f, 0.07293755f, -0.13332979f, -0.09349549f, 
    0.12136179f, 0.09478229f, 0.01287762f, 0.03636751f, 0.04538622f, 0.01326052f, 0.05894022f, -0.01793646f, 
    -0.03823905f, 0.04463349f, 0.05881727f, -0.04091449f, 0.01403059f, -0.03237431f, 0.05159935f, -0.10879540f, 
    -0.02574313f, 0.06515683f, 0.00337129f, 0.08193066f, 0.08055267f, -0.14683165f, -0.14531496f, -0.14499658f, 
    0.19952926f, 0.19408076f, -0.02962510f, -0.03041240f, 0.00768085f, 0.01141958f, -0.01112543f, -0.03651014f, 
    0.34718046f, 0.24674991f, -0.00462749f, 0.17702246f, 0.01363093f, -0.04317100f, -0.09628920f, -0.05211370f, 
    -0.06595937f, 0.03232770f, -0.11952854f, 0.01060260f, -0.33266807f, -0.29473004f, 0.16492538f, 0.06387424f, 
    0.01952066f, 0.01596733f, 0.00058806f, -0.06728281f, 0.02483127f, 0.06133210f, -0.13427892f, 0.14903668f, 
    0.08782263f, -0.02340573f, 0.20522089f, -0.19386922f, -0.03531964f, -0.03476714f, -0.13436282f, -0.00413625f, 
    -0.08715897f, -0.05157025f, -0.05962856f, -0.26999435f, 0.19862762f, 0.15647379f, 0.09150644f, -0.04724611f, 
    -0.04882076f, 0.17481475f, 0.13460651f, -0.14949127f, 0.12420889f, -0.06943171f, 0.11942626f, -0.08527261f, 
    0.22763073f, 0.03966195f, -0.02472083f, 0.09945030f, -0.08341406f, 0.02349095f, -0.03763659f, 0.17826484f, 
    -0.12654555f, -0.03688110f, -0.05052413f, 0.01274412f, 0.26372382f, 0.36209106f, 0.16690256f, 0.11696851f, 
    -0.05556287f, 0.11462007f, 0.05384765f, 0.16453482f, -0.06830220f, -0.03770769f, -0.09345296f, 0.06888821f, 
    -0.15583120f, 0.02821094f, 0.03693622f, -0.06095645f, -0.00683128f, -0.01771089f, -0.10043653f, -0.09959537f, 
    -0.00980004f, 0.03394677f, 0.14430264f, -0.03325333f, -0.19525729f, -0.16733281f, -0.04416817f, -0.12632453f, 
    -0.09147406f, -0.01720350f, -0.02843090f, -0.04143029f, -0.04398062f, 0.06268468f, -0.01517984f, 0.03115021f, 
    -0.02284282f, -0.10750572f, -0.15085562f, -0.08976164f, -0.04467093f, 0.08556223f, 0.00837525f, -0.11004312f, 
    -0.02987868f, 0.10910038f, -0.03584740f, 0.05460698f, 0.09937765f, -0.20169146f, -0.16953738f, 0.05302028f, 
    -0.01130527f, -0.02358541f, 0.05880916f, -0.01082261f, -0.04096977f, -0.05867771f, -0.03129741f, -0.02610307f, 
    0.21597208f, -0.19069238f, -0.13266306f, 0.00230827f, -0.19717260f, -0.02481136f, 0.16718809f, -0.01459228f, 
    -0.01295275f, 0.07609465f, 0.08815290f, 0.12344486f, 0.04010921f, -0.16937518f, -0.11752289f, -0.11492626f, 
    0.06364962f, 0.11247121f, -0.06295507f, 0.01989844f, -0.04028100f, -0.04772206f, 0.01130278f, -0.04228653f, 
    0.27293012f, -0.17346217f, 0.08923180f, 0.04471418f, -0.04781541f, -0.09587616f, -0.04727132f, -0.03241891f, 
    0.05132397f, 0.06313768f, -0.07530510f, 0.02048026f, 0.02253044f, 0.13416901f, -0.22679520f, 0.02675167f, 
    0.13458584f, 0.01252289f, 0.07696828f, -0.18572515f, 0.06702293f, -0.10046663f, -0.04824685f, 0.05260907f, 
    0.25740525f, 0.22034803f, 0.10457327f, 0.16685142f, -0.00922020f, -0.01874094f, 0.21143885f, 0.01022991f, 
    0.03122982f, -0.06957710f, -0.11246499f, 0.08049396f, 0.44120288f, 0.18716368f, 0.00885488f, 0.15318465f, 
    0.08727712f, -0.04814237f, 0.05821474f, 0.09737960f, -0.00420029f, -0.03093099f, -0.25419390f, -0.01221229f, 
    -0.02168368f, 0.05899632f, 0.01193290f, 0.01347221f, 0.19814560f, 0.10970185f, 0.06890376f, -0.01576255f, 
    -0.10544713f, 0.00496645f, 0.00043181f, 0.07815738f, -0.14815137f, -0.32403231f, -0.29569465f, 0.14260629f, 
    -0.04924177f, -0.03473505f, -0.02251783f, -0.12043579f, 0.08843443f, 0.08488956f, -0.10374117f, 0.07121386f, 
    0.11252251f, -0.05752388f, 0.00461040f, -0.00516897f, 0.00706304f, 0.01905386f, -0.08515047f, -0.12851997f, 
    0.08170642f, -0.03596924f, 0.12047204f, -0.16714333f, -0.13619766f, -0.21802720f, -0.38810056f, -0.22615109f, 
    -0.05728824f, -0.06999158f, 0.02446728f, -0.20450957f, 0.05282159f, -0.03040546f, 0.03881518f, 0.04875312f, 
    0.14692159f, -0.16368054f, -0.06459107f, -0.04286016f, 0.04976868f, 0.03727108f, 0.01561217f, 0.13174072f, 
    0.05193413f, 0.01695355f, -0.19969246f, 0.12698863f, -0.09010162f, -0.00208947f, 0.05903190f, -0.02511793f, 
    -0.02817878f, -0.02568081f, 0.06288076f, 0.08028837f, -0.20851232f, -0.04263046f, -0.06794059f, -0.08523791f, 
    0.16016781f, 0.11681546f, -0.01498387f, -0.04831864f, 0.09146737f, -0.00614922f, -0.12549123f, -0.05806484f, 
    -0.05315774f, -0.03087055f, -0.04806878f, 0.01236449f, 0.21625443f, -0.50973141f, -0.18286867f, -0.04566348f, 
    -0.09297608f, -0.18863738f, 0.13420150f, -0.14543468f, -0.00924679f, 0.03625310f, 0.02218370f, -0.00543610f, 
    0.13549727f, 0.26235184f, 0.17879458f, 0.09555831f, 0.07385832f, 0.10093843f, -0.03924754f, 0.17638390f, 
    -0.13375336f, -0.09852217f, 0.06480405f, -0.11844245f, -0.00940670f, -0.01434709f, -0.10608394f, -0.12168148f, 
    -0.20339416f, -0.01464321f, 0.04829605f, -0.03680190f, -0.00357095f, 0.15377100f, 0.05650989f, 0.01110863f, 
    0.35879329f, -0.11909939f, 0.07728939f, 0.01357980f, 0.07769862f, 0.03054469f, -0.06677859f, 0.10335653f, 
    0.10970271f, 0.03473037f, -0.01862118f, 0.11226938f, -0.30633280f, -0.06267196f, 0.06683702f, 0.11190159f, 
    -0.02019322f, 0.03608032f, 0.02203959f, 0.05253105f, -0.03995684f, -0.12647536f, -0.00685689f, 0.09596483f, 
    0.20249991f, 0.06757454f, 0.11570912f, -0.04444518f, -0.02365730f, -0.03340220f, -0.06398293f, -0.01154502f, 
    0.06981631f, -0.03775360f, -0.09702546f, -0.10450889f, -0.04347450f, -0.19868755f, 0.09238812f, -0.24262354f, 
    -0.08090758f, 0.08545250f, -0.01120556f, 0.00873503f, -0.11934137f, 0.16792661f, -0.12759155f, -0.04254237f, 
    0.42060369f, 0.19416295f, 0.05339634f, 0.09137627f, 0.06416344f, 0.08693845f, 0.02726917f, 0.04141578f, 
    -0.01675192f, 0.00589026f, 0.00732329f, 0.03236276f, 0.19296494f, -0.36613300f, 0.12678471f, 0.02904407f, 
    -0.05983875f, -0.04245024f, 0.00464040f, 0.00981561f, -0.01722076f, 0.00363580f, -0.05961156f, 0.02135766f, 
    0.18596393f, 0.14213306f, 0.25741264f, 0.09888978f, 0.09267932f, 0.05867863f, -0.16398871f, 0.06224406f, 
    -0.12389087f, -0.04812068f, -0.04990875f, -0.12910867f, -0.33293226f, -0.27864906f, -0.09027101f, -0.17385933f, 
    -0.11784965f, 0.04117324f, -0.11815646f, -0.07046162f, 0.07816401f, -0.03105776f, 0.02312022f, -0.05163673f, 
    0.00115459f, 0.02483959f, -0.16707753f, -0.23177309f, -0.18672808f, -0.06620158f, -0.08952425f, -0.10452582f, 
    0.04707714f, 0.00072014f, -0.01322841f, 0.03919903f, 0.49425784f, 0.36684385f, 0.13839285f, 0.01228702f, 
    0.02550001f, 0.14170249f, -0.02439246f, 0.05388523f, -0.05763021f, 0.00653234f, 0.01581262f, -0.03374957f, 
    0.27610919f, -0.22982129f, -0.27278748f, -0.14446796f, 0.04574180f, -0.08723613f, -0.02105716f, 0.02078581f, 
    0.03942989f, 0.00710124f, -0.06532042f, -0.13840128f, 0.04028825f, -0.04915055f, -0.03390672f, 0.04888099f, 
    -0.03182780f, -0.03277870f, -0.03101678f, 0.03571212f, 0.03171888f, 0.06692848f, -0.03218003f, -0.04346776f, 
    0.12434497f, 0.13195324f, 0.03947743f, -0.03142451f, -0.08053590f, -0.06330402f, 0.01687334f, -0.05987871f, 
    0.12909693f, -0.02832237f, -0.06465601f, 0.02025538f, -0.02318738f, 0.05738403f, 0.13170524f, -0.07387663f, 
    -0.03247979f, 0.05123230f, -0.12490149f, -0.00575083f, 0.00284050f, 0.02658717f, -0.04106430f, -0.02800260f, 
    -0.03022057f, 0.01104582f, 0.01356007f, -0.03831534f, 0.00967654f, 0.01782011f, 0.01969020f, -0.02498336f, 
    0.02302552f, 0.00772960f, -0.02257783f, 0.00828857f, -0.02691720f, -0.01707464f, -0.02864227f, 0.01930804f, 
    0.02786019f, -0.00444503f, 0.02511123f, -0.03966058f, -0.03365610f, 0.02678528f, -0.00993969f, 0.02247078f, 
    -0.03605964f, 0.01837737f, -0.02372215f, -0.00591001f, -0.02791754f, -0.01034740f, 0.02131392f, 0.00646594f, 
    -0.00679123f, -0.00227957f, -0.02360572f, -0.01841437f, -0.03905281f, -0.00396822f, 0.01423947f, 0.00284716f, 
    -0.01377830f, -0.03699133f, 0.01445412f, -0.01097744f, 0.00382359f, -0.03855219f, 0.00036275f, 0.02741586f, 
    -0.03501204f, 0.02137236f, -0.00878779f, 0.01412056f, -0.02642057f, 0.01582962f, 0.00181206f, 0.00764278f, 
    -0.00942378f, 0.01292533f, -0.01400984f, 0.00431808f, -0.03985658f, -0.03118881f, 0.01703064f, 0.02296803f, 
    -0.03186934f, -0.02019181f, 0.00960943f, -0.00128728f, 0.00442969f, 0.02309252f, -0.02077504f, 0.02591842f, 
    0.00684047f, 0.01249715f, -0.00115156f, -0.01469368f, -0.04195528f, -0.01043322f, -0.00519892f, 0.01557794f, 
    -0.03810785f, 0.00644389f, -0.02759708f, 0.00374928f, 0.01650372f, -0.02616466f, -0.02397633f, -0.01049527f, 
    -0.03154187f, 0.01580318f, -0.02240944f, -0.02877715f, -0.02030079f, -0.00397961f, -0.02058028f, -0.04111637f, 
    0.00883843f, -0.00817985f, -0.00193737f, -0.03374387f, 0.00561572f, 0.01681773f, -0.03593060f, -0.03738241f, 
    -0.01738010f, 0.01700694f, -0.00884440f, 0.02766101f, 0.00240520f, -0.00191943f, -0.04183156f, -0.02328212f, 
    -0.01353009f, 0.01739941f, -0.00355709f, 0.01480116f, 0.01108319f, 0.00820001f, -0.02571492f, 0.00517713f, 
    0.02338246f, 0.00259265f, -0.04090463f, 0.00887133f, 0.01072561f, -0.03934944f, -0.02984248f, 0.01805491f, 
    -0.00131126f, -0.02638927f, 0.02465488f, -0.00296915f, -0.03977460f, -0.03336407f, 0.01509275f, -0.00844750f, 
    -0.01649949f, -0.02802361f, -0.01987148f, -0.02094634f, -0.04185255f, 0.01521148f, -0.00462288f, 0.01744920f, 
    0.00703284f, 0.01517515f, -0.03828313f, -0.02928230f, -0.03535296f, -0.03097743f, 0.00771138f, -0.00529642f, 
    0.00864102f, -0.00118709f, 0.00197241f, 0.02575885f, -0.00584566f, 0.02672586f, -0.00596065f, -0.02071423f, 
    -0.00830433f, 0.00515832f, 0.00659571f, -0.00395358f, 0.00932625f, -0.02192853f, -0.03831279f, 0.01844184f, 
    -0.01879750f, 0.02285771f, -0.02867845f, -0.03662210f, 0.02043072f, 0.02774897f, -0.04157718f, -0.01957064f, 
    0.02829213f, 0.00801184f, -0.01694207f, -0.02277174f, -0.00990588f, 0.01630636f, -0.03611148f, -0.02768611f, 
    0.01279497f, -0.01956160f, 0.02622783f, -0.01471595f, 0.00284698f, -0.02452681f, 0.01525552f, 0.01566445f, 
    -0.01861474f, 0.01636407f, 0.01347097f, 0.00251228f, -0.03016392f, -0.02885140f, 0.00805320f, -0.02592107f, 
    0.01132853f, -0.01880019f, -0.01892930f, -0.04150899f, 0.01771972f, -0.00559358f, 0.00952693f, 0.01673364f, 
    -0.01697955f, 0.02473330f, 0.02056625f, -0.01226044f, 0.00064547f, -0.01900341f, 0.01295466f, -0.02684133f, 
    0.02977363f, -0.03900889f, -0.01055381f, -0.01744152f, -0.03604320f, -0.00277435f, -0.03350398f, -0.04133425f, 
    0.00370825f, 0.00234623f, -0.00295448f, 0.02383822f, 0.00356911f, -0.01144741f, 0.01925669f, -0.01718795f, 
    0.02117715f, -0.02136583f, -0.03580476f, -0.00115916f, 0.00229780f, 0.00178117f, -0.04132674f, -0.02237661f, 
    0.00562585f, -0.01148155f, -0.03448350f, 0.00749334f, 0.01663439f, 0.00286053f, 0.01986795f, 0.00928997f, 
    -0.02897163f, 0.01085771f, -0.00134335f, -0.03606807f, -0.02773167f, 0.02361945f, -0.03868280f, -0.00348973f, 
    -0.01681629f, 0.01746297f, 0.02379129f, 0.01102540f, -0.03690797f, 0.01362901f, -0.02678493f, -0.00980184f, 
    -0.02184281f, -0.02928360f, -0.04102137f, 0.01388589f, -0.03131894f, 0.02309248f, 0.02467177f, -0.04276284f, 
    -0.02400494f, 0.00459664f, -0.00708221f, -0.02693967f, 0.00629563f, -0.00355636f, -0.03193533f, -0.02068724f, 
    0.00364691f, -0.00104963f, -0.03407626f, 0.00434119f, -0.00392272f, 0.00321850f, -0.02908799f, -0.01037143f, 
    -0.00931255f, -0.00894270f, -0.02138506f, -0.02554882f, 0.02776087f, 0.02368538f, -0.02412773f, -0.02078084f, 
    -0.00246626f, 0.00290819f, -0.02483685f, -0.01032807f, 0.00180730f, -0.01403325f, 0.02870218f, -0.01866809f, 
    -0.00673524f, 0.01615081f, -0.02698919f, -0.03247293f, -0.04135408f, -0.02552547f, -0.01831824f, 0.01335991f, 
    0.00191070f, 0.00351129f, 0.01967567f, -0.03538989f, -0.03813104f, -0.02357370f, 0.02723905f, -0.00454641f, 
    -0.00474770f, 0.00669121f, 0.00604383f, -0.03290099f, -0.02299241f, -0.01953304f, -0.04060502f, -0.01045548f, 
    -0.04217346f, -0.00621677f, -0.01860524f, -0.03862742f, -0.01640141f, -0.02816534f, -0.01632032f, 0.01539277f, 
    0.01165103f, 0.00778652f, 0.02745791f, -0.01291829f, 0.01929359f, 0.01669377f, -0.03469810f, -0.03263555f, 
    -0.04021334f, 0.02179508f, -0.03662576f, 0.02007201f, -0.03132487f, 0.01698688f, -0.01119867f, 0.00952165f, 
    -0.01929062f, -0.00056755f, -0.01047364f, -0.02632917f, -0.01227265f, 0.00551870f, -0.03072124f, 0.02668730f, 
    0.02272322f, 0.00180087f, 0.01462918f, -0.03908890f, -0.03190344f, -0.02291302f, 0.02756723f, 0.02885329f, 
    -0.03894998f, -0.02896940f, -0.03620274f, 0.01474428f, -0.00958088f, -0.04104383f, 0.02679587f, 0.01634934f, 
    0.00802075f, -0.00008264f, -0.03202416f, 0.01394431f, -0.00495417f, -0.02870725f, -0.03065054f, -0.04019098f, 
    0.01359577f, 0.01818682f, 0.01290075f, -0.03848083f, -0.01249454f, -0.03298867f, 0.02572665f, 0.01533974f, 
    0.01676940f, 0.00785847f, 0.00118562f, -0.00609749f, 0.02917897f, -0.00632589f, 0.01106838f, -0.01341006f, 
    -0.02569606f, -0.02105127f, 0.02001908f, -0.01279188f, 0.02310785f, -0.00464399f, -0.00781015f, 0.01311913f, 
    -0.02279621f, 0.02548407f, -0.00169727f, 0.00846678f, -0.01409160f, 0.00354956f, -0.04137973f, -0.00886278f, 
    -0.03821955f, -0.00184471f, -0.01208305f, -0.00555753f, -0.01078646f, 0.02117512f, -0.00832219f, 0.01743981f, 
    -0.01554901f, -0.03118407f, -0.02378326f, -0.02010114f, 0.00061771f, 0.02376974f, 0.01999657f, -0.00146647f, 
    0.00992278f, -0.01499290f, 0.02743158f, -0.02425611f, -0.03237171f, 0.00231725f, -0.00931724f, -0.03528803f, 
    -0.04151341f, 0.01737435f, -0.02804037f, -0.01330885f, -0.00748777f, 0.00632357f, -0.01954866f, -0.01979922f, 
    0.01552122f, -0.01298588f, -0.00125122f, -0.01383565f, 0.00533932f, 0.02446889f, -0.01911664f, 0.02065479f, 
    -0.02667071f, -0.00280839f, 0.00107650f, -0.03804579f, -0.00854949f, 0.00903577f, 0.02047159f, 0.01401019f, 
    0.00316517f, -0.00319218f, 0.00949849f, -0.04118607f, -0.02596598f, -0.00504322f, -0.03928849f, 0.00374357f, 
    0.00414444f, 0.00702028f, -0.01624092f, -0.03109689f, -0.01054275f, -0.00822436f, -0.00375599f, -0.00949244f, 
    -0.04035822f, -0.02870403f, 0.00703873f, -0.04149563f, 0.01397078f, 0.00611383f, -0.02645811f, -0.03522109f, 
    -0.01649100f, -0.02128134f, 0.01756474f, -0.02933225f, -0.00532479f, -0.04204152f, 0.01316463f, 0.00360566f, 
    -0.02905064f, 0.00398681f, 0.01501423f, 0.00669358f, 0.02334962f, 0.02881989f, -0.02625499f, 0.01694300f, 
    -0.02295623f, -0.01899407f, 0.01589504f, -0.02695583f, -0.02137254f, 0.02716382f, 0.01720861f, 0.02277602f, 
    -0.03954023f, -0.00114059f, 0.00841186f, -0.00030113f, -0.03646686f, -0.03943758f, -0.00873647f, 0.00697314f, 
    -0.01962621f, -0.00235675f, -0.02147806f, 0.00013907f, 0.00728485f, -0.01188588f, -0.02176869f, -0.01118010f, 
    -0.01743967f, -0.00891979f, -0.01091321f, -0.01846132f, 0.02645078f, 0.00455804f, -0.03277955f, -0.04132018f, 
    0.02195840f, -0.02319751f, -0.01004150f, 0.02727287f, -0.02076800f, 0.01387735f, 0.00834867f, -0.00356286f, 
    0.01142707f, 0.00727877f, 0.01789898f, -0.03649015f, 0.00479745f, 0.01671669f, 0.02213834f, 0.02713605f, 
    0.01187941f, 0.01525263f, -0.03570030f, -0.04047759f, -0.01617798f, -0.00812148f, 0.00919089f, 0.00291218f, 
    -0.02201262f, -0.03578969f, -0.02920474f, 0.01264035f, -0.01277192f, 0.01280513f, 0.01688274f, -0.03518990f, 
    0.00394310f, -0.00572911f, -0.00645853f, 0.00687215f, -0.03753163f, -0.03792511f, 0.02823909f, -0.03801018f, 
    -0.04061234f, 0.02608867f, 0.01875729f, 0.00401104f, -0.00025958f, -0.00812404f, -0.00966078f, 0.01798061f, 
    0.00171128f, -0.00663949f, -0.00427765f, 0.02259424f, 0.00550047f, 0.02728685f, 0.01244193f, -0.00724396f, 
    0.02273257f, -0.00290148f, 0.02418386f, -0.03732803f, 0.02716551f, -0.02588809f, -0.00928838f, -0.02981907f, 
    -0.00794950f, 0.01914850f, -0.01577440f, -0.02513415f, -0.01866018f, 0.00864622f, -0.00901853f, -0.00032433f, 
    0.01373366f, -0.02905467f, 0.00264581f, 0.00008538f, -0.04222606f, -0.01895104f, -0.01831003f, -0.02017686f, 
    -0.01302838f, 0.01444270f, 0.01555637f, 0.00919117f, -0.01396466f, -0.03770933f, 0.00311638f, 0.02643774f, 
    -0.00493873f, 0.02780000f, -0.03360677f, -0.00358758f, -0.01756223f, -0.01848884f, -0.01102276f, 0.00360881f, 
    0.00481023f, 0.02598682f, 0.01741267f, -0.02169525f, -0.02087018f, -0.00261605f, -0.02140616f, 0.00654637f, 
    -0.01671425f, -0.02292649f, -0.04245058f, 0.00002466f, 0.01816989f, -0.00436036f, 0.02235687f, -0.00060429f, 
    -0.03971002f, 0.02492441f, -0.03066300f, 0.02057783f, -0.01562975f, 0.00573714f, 0.00961804f, -0.00479308f, 
    -0.00998847f, 0.02041909f, 0.01025444f, -0.01872363f, 0.01519397f, 0.01287741f, -0.03365537f, -0.04233732f, 
    -0.00245192f, 0.02088720f, -0.01423035f, 0.02473620f, -0.01603831f, -0.02393175f, -0.02992625f, -0.01273292f, 
    0.01595104f, 0.02700978f, 0.00997042f, -0.02751281f, -0.02486235f, -0.01811919f, -0.04011583f, 0.01157556f, 
    0.02403892f, 0.00162210f, 0.00566231f, -0.01295471f, 0.01907696f, -0.02521095f, -0.02285214f, -0.00773471f, 
    -0.01067766f, 0.00724967f, 0.02313191f, 0.01180586f, -0.01930480f, 0.02335411f, -0.03506643f, 0.02036265f, 
    -0.02849583f, -0.00860166f, -0.01618642f, -0.00262431f, -0.03617569f, -0.03436726f, -0.01052244f, -0.02151003f, 
    -0.02183348f, 0.02347168f, 0.02420903f, 0.00922337f, -0.00787553f, -0.03444530f, -0.03323207f, -0.00114409f, 
    -0.00100313f, 0.00403566f, -0.03849778f, 0.02044513f, 0.01619874f, 0.00677827f, -0.04083141f, -0.01682337f, 
    0.01486430f, -0.02397985f, 0.01101119f, -0.03627623f, 0.02646272f, 0.02281195f, 0.02853630f, 0.01117336f, 
    -0.00750844f, -0.00796503f, 0.00903917f, -0.02423525f, 0.02671281f, -0.02697286f, -0.04182937f, -0.02292476f, 
    0.02840149f, -0.03456842f, -0.02581644f, -0.03682840f, -0.04222629f, -0.00357106f, -0.00038689f, -0.02885761f, 
    -0.02359324f, -0.02201539f, 0.02772645f, 0.02528008f, 0.01135183f, -0.00574015f, -0.01456958f, -0.01311021f, 
    -0.02341451f, -0.03581679f, -0.00730510f, 0.02828799f, 0.01109198f, -0.04103808f, -0.01042295f, -0.02624595f, 
    -0.00602272f, 0.02944585f, 0.01048645f, -0.01652698f, 0.01479607f, -0.00676170f, -0.02473198f, 0.01876088f, 
    -0.02820744f, -0.02728766f, 0.02213826f, 0.02191557f, 0.01459253f, -0.00899768f, 0.00710175f, -0.02202526f, 
    -0.01396301f, 0.00716727f, 0.00080409f, -0.00845104f, -0.01703709f, -0.02698722f, 0.01718793f, -0.00952083f, 
    0.01286505f, 0.00429424f, -0.01579488f, 0.02873826f, 0.01634272f, -0.03246045f, -0.01165307f, 0.01929947f, 
    0.00097528f, 0.01307040f, -0.04328088f, 0.01555994f, 0.01661516f, -0.01553433f, -0.01594293f, 0.00434104f, 
    0.02230964f, -0.02790743f, 0.02722714f, -0.00284006f, -0.01722213f, -0.03211600f, -0.02330902f, -0.03983146f, 
    0.01336446f, -0.02704214f, -0.00599030f, -0.01074499f, 0.00174489f, -0.04136343f, -0.03662119f, 0.01963820f, 
    0.00751792f, 0.02615834f, -0.01238055f, -0.02178035f, -0.02585246f, 0.01719669f, -0.01649074f, 0.03163864f, 
    0.00819569f, 0.01230369f, -0.01263887f, 0.01010068f, 0.01038514f, 0.01643347f, -0.02433470f, 0.00666471f, 
    -0.02909680f, 0.02118568f, 0.00066346f, -0.00430475f, -0.03539101f, -0.03799521f, -0.02685723f, -0.04179102f, 
    -0.01776780f, 0.00276284f, -0.02307945f, -0.03150703f, -0.03452087f, -0.03092138f, 0.03585963f, 0.02654116f, 
    -0.02431841f, 0.03684220f, 0.01110609f, 0.01943374f, -0.02136040f, 0.00842533f, -0.00669491f, 0.02108074f, 
    -0.01173101f, -0.03973651f, -0.01728940f, -0.02840288f, 0.00044593f, -0.03011106f, 0.01506504f, -0.00417222f, 
    0.01098040f, -0.00580286f, -0.03629556f, -0.01777824f, -0.03733082f, -0.01715903f, 0.00650051f, -0.02255442f, 
    -0.01663876f, -0.02494738f, -0.01565528f, -0.01850074f, -0.02828787f, 0.00836200f, -0.01797848f, -0.00260319f, 
    -0.03538696f, -0.01966107f, 0.02258087f, 0.00691443f, 0.01372285f, 0.02190940f, -0.02213079f, 0.00443024f, 
    0.02878494f, -0.02209882f, -0.02225952f, -0.02478974f, -0.04123029f, -0.01467033f, -0.02100280f, -0.01312595f, 
    0.02276056f, -0.01351275f, -0.03566157f, -0.03235782f, 0.02102410f, -0.01253318f, 0.02055104f, -0.03147331f, 
    0.01653394f, -0.01795059f, 0.00354495f, -0.00660431f, 0.02387358f, 0.00240925f, -0.02477705f, -0.03972381f, 
    0.01430198f, -0.03612516f, 0.00001511f, 0.02781478f, 0.02200007f, -0.01172439f, -0.00023487f, 0.01824191f, 
    0.00049094f, -0.00508847f, 0.00977266f, -0.01816547f, -0.01534088f, -0.01955507f, -0.03166489f, 0.01998399f, 
    -0.03570515f, 0.01900904f, 0.02695606f, -0.04364890f, -0.01415390f, -0.03247573f, 0.01024501f, 0.01840986f, 
    0.02562415f, -0.03856012f, 0.02295956f, 0.00698328f, -0.00082435f, -0.02871797f, 0.00466294f, 0.00193483f, 
    0.01738285f, -0.02955105f, -0.01460389f, 0.00382896f, -0.03039956f, 0.01355362f, 0.02040017f, -0.03270764f, 
    0.01245507f, -0.01338899f, 0.01307550f, 0.01821888f, -0.00247406f, -0.01653498f, 0.02099902f, -0.02403431f, 
    -0.00682031f, 0.00938809f, 0.01096892f, -0.02122135f, -0.00115266f, -0.00802048f, 0.02465722f, -0.00022311f, 
    0.01414881f, 0.02252181f, 0.02906506f, -0.02051435f, 0.03237318f, -0.02054578f, 0.01676486f, 0.02471575f, 
    0.02800212f, 0.02418962f, 0.02560983f, 0.02456662f, 0.02773787f, 0.02693652f, -0.00961304f, 0.02520883f, 
    -0.01915079f, 0.00414815f, -0.01673826f, -0.04251049f, -0.00197702f, -0.02856597f, 0.01997433f, 0.00595866f, 
    -0.04293267f, 0.02234869f, -0.01499467f, -0.03288295f, 0.00629409f, 0.00916639f, 0.00523233f, -0.02748444f, 
    -0.03150423f, -0.00641001f, 0.00456103f, 0.01757741f, 0.01434261f, 0.01039883f, 0.00302743f, 0.02832943f, 
    0.00468525f, -0.02375424f, -0.00631118f, -0.04185347f, -0.00845548f, 0.01013720f, -0.03658213f, 0.02754473f, 
    0.02569676f, 0.03240190f, 0.03103081f, 0.01380637f, 0.01992607f, -0.01838222f, 0.03551665f, -0.02846677f, 
    -0.03147318f, -0.00695322f, 0.00552502f, -0.02074308f, -0.00267915f, -0.03087488f, 0.01345762f, -0.04273569f, 
    0.00522601f, -0.00948059f, 0.01683222f, -0.03264583f, -0.03286989f, 0.01260593f, 0.00501521f, 0.02860451f, 
    -0.00996741f, 0.01225233f, -0.02799076f, 0.00581801f, -0.00182018f, 0.03132201f, 0.00100453f, -0.02324222f, 
    -0.04194358f, 0.00754833f, -0.02181828f, -0.00370659f, -0.04385409f, -0.00809317f, -0.02890894f, -0.03546743f, 
    -0.04136939f, -0.03110951f, -0.02604579f, -0.01650839f, 0.03287904f, -0.00362227f, 0.03227006f, 0.00702963f, 
    -0.00945443f, 0.00757043f, 0.01311003f, 0.00529219f, -0.02551366f, 0.01572140f, -0.00245976f, -0.02560132f, 
    -0.02776369f, 0.02755360f, 0.03005723f, -0.00215478f, 0.01972711f, 0.02234941f, -0.03059537f, 0.03754298f, 
    -0.02151632f, 0.01775331f, -0.03012844f, -0.03884177f, -0.04016896f, -0.04032397f, 0.00453043f, 0.02135137f, 
    0.00372598f, -0.00045863f, -0.02008064f, 0.01726417f, -0.00648710f, -0.04114718f, -0.03466699f, -0.03638173f, 
    -0.03624634f, -0.00984559f, -0.02564505f, 0.01133347f, -0.02015237f, -0.00349473f, -0.00624135f, -0.00705499f, 
    -0.00983446f, -0.01511255f, 0.02090236f, 0.04078795f, 0.00518433f, -0.01086102f, 0.03299148f, 0.01229195f, 
    -0.03171361f, -0.00655388f, -0.02840721f, -0.01048488f, -0.03096045f, 0.03591678f, -0.00764855f, 0.02791226f, 
    -0.00927331f, -0.02454734f, -0.01978701f, -0.00738805f, -0.02287225f, 0.01503232f, -0.01346160f, 0.00688879f, 
    0.01978591f, -0.04171939f, -0.03797601f, -0.02093994f, -0.04250127f, -0.03097179f, 0.00604462f, -0.00577405f, 
    -0.01202702f, 0.00417128f, 0.01305757f, -0.02729807f, 0.03255362f, -0.01268847f, 0.01055857f, 0.01868640f, 
    -0.03115886f, -0.04041368f, -0.02585821f, -0.00741914f, -0.00702496f, -0.02843148f, 0.01850673f, 0.00074645f, 
    0.02494377f, 0.01932529f, 0.02085868f, -0.03876525f, 0.01806841f, -0.00950399f, -0.01425677f, -0.01336482f, 
    -0.01039543f, 0.00215953f, -0.03287120f, 0.01332024f, -0.02072296f, -0.00131068f, 0.01158491f, 0.00529487f, 
    0.00900497f, -0.00373214f, 0.01317026f, -0.02600285f, -0.01045610f, 0.00955421f, -0.01278174f, 0.02525133f, 
    -0.03449153f, 0.00660015f, 0.01405916f, -0.01451600f, -0.03785073f, 0.01761511f, 0.01348683f, -0.00439881f, 
    0.01088117f, -0.03501480f, 0.02954468f, -0.00658948f, 0.02441022f, 0.02351952f, -0.02547514f, 0.02052525f, 
    0.01652804f, -0.04129776f, 0.02562776f, -0.03663537f, -0.02724855f, -0.01611955f, -0.04269788f, -0.03647016f, 
    -0.00096069f, -0.02888731f, -0.00936290f, -0.00198139f, -0.04331003f, 0.01129116f, -0.01563762f, 0.02320503f, 
    -0.03710002f, 0.00876949f, -0.03921587f, 0.00661448f, -0.00152918f, -0.02028276f, -0.03874328f, 0.02204894f, 
    -0.02038928f, -0.00109482f, 0.01453332f, -0.01077877f, 0.00140219f, 0.00441833f, 0.00107937f, -0.02753040f, 
    -0.03537890f, -0.01316740f, -0.02051284f, -0.04157208f, -0.01660378f, 0.00745471f, 0.00882484f, -0.00127154f, 
    -0.01958208f, -0.00494388f, 0.02573919f, -0.03716843f, 0.02592076f, 0.00585263f, 0.00946386f, -0.00713003f, 
    -0.04429626f, 0.03488845f, -0.02584878f, 0.00615776f, -0.03005951f, -0.03399705f, 0.00962907f, -0.01077099f, 
    -0.03429023f, -0.00708007f, -0.01780101f, 0.00469203f, 0.00385552f, 0.01054282f, 0.01817890f, 0.00907055f, 
    -0.00649108f, 0.02757206f, -0.01924662f, 0.01554828f, 0.01080909f, -0.00747670f, -0.01142014f, -0.01566885f, 
    0.02898674f, -0.00442247f, 0.02110000f, -0.00367483f, 0.01550498f, 0.01003806f, 0.00323541f, -0.02306179f, 
    -0.01476351f, -0.00091481f, -0.02705568f, -0.03856818f, 0.02647721f, -0.02801274f, -0.02237426f, -0.01648868f, 
    -0.02753658f, -0.03889027f, 0.00635830f, 0.02575251f, -0.01713882f, 0.02347939f, -0.02326708f, -0.01728438f, 
    0.03097904f, -0.01897770f, -0.00265432f, -0.02262256f, 0.01770545f, 0.00128213f, 0.00971828f, -0.02437849f, 
    -0.02488576f, -0.03173270f, -0.04064592f, -0.01711671f, -0.01731248f, -0.02095477f, -0.00709907f, -0.00135644f, 
    0.02792341f, 0.02723620f, -0.01553812f, -0.01528388f, 0.03190634f, 0.00035118f, 0.02670412f, -0.00969381f, 
    -0.02534676f, -0.00290536f, 0.01416544f, 0.01308800f, -0.00222957f, -0.03375332f, -0.02185382f, -0.01492737f, 
    -0.00512201f, 0.00498586f, 0.02650147f, 0.01223155f, -0.03153925f, 0.00520847f, -0.02679134f, 0.01769481f, 
    0.01088163f, -0.02357391f, -0.01217123f, 0.02067322f, -0.02453271f, 0.01714370f, 0.01282309f, -0.02438606f, 
    0.00127793f, 0.00843925f, 0.02482598f, -0.02172533f, 0.00737743f, -0.03441623f, -0.00691953f, -0.00402826f, 
    -0.03262618f, -0.00533235f, -0.02945246f, -0.03340928f, 0.00519952f, 0.01492233f, -0.03399416f, 0.00808245f, 
    0.01904492f, -0.03119151f, 0.00725526f, 0.01964432f, 0.03404234f, 0.01624654f, -0.00419221f, 0.00461428f, 
    0.02642938f, -0.03026359f, -0.04000921f, -0.00850908f, -0.02384146f, 0.00603110f, -0.02466301f, 0.01998795f, 
    -0.02511596f, 0.02178383f, -0.02287120f, -0.01137123f, -0.03786157f, 0.02124690f, 0.01602384f, -0.03795476f, 
    -0.02558576f, -0.01229948f, -0.00076911f, -0.01769245f, 0.00145047f, -0.03120661f, -0.00912280f, -0.02151751f, 
    -0.03819393f, -0.04060764f, 0.01925744f, 0.00603389f, -0.02597719f, 0.01555190f, -0.02375080f, -0.02484617f, 
    -0.01905393f, -0.01505651f, -0.03727028f, -0.03394255f, -0.00674771f, -0.00197443f, -0.00339127f, 0.01938844f, 
    -0.02883672f, 0.00239351f, -0.02694120f, -0.03667780f, 0.01723180f, 0.01126208f, 0.02881091f, 0.01942678f, 
    -0.01984496f, -0.01861282f, -0.02357258f, 0.00578083f, -0.01456672f, 0.00988962f, -0.04111781f, -0.01216409f, 
    0.02315939f, -0.01223660f, -0.01083639f, 0.01323396f, -0.02034464f, -0.00585410f, 0.02124281f, 0.02533326f, 
    -0.03997691f, 0.00290817f, -0.03333259f, -0.01405993f, 0.02136126f, 0.00704135f, -0.02684546f, 0.02664007f, 
    0.01594543f, -0.03134220f, 0.00838721f, -0.03309995f, 0.01610520f, -0.01906049f, -0.00777292f, -0.03165908f, 
    -0.01802103f, 0.02677421f, -0.03072617f, 0.00104217f, -0.01418104f, -0.00521648f, 0.02490749f, -0.03587965f, 
    -0.00835696f, -0.00627912f, 0.02119625f, -0.02089455f, -0.01856230f, -0.03404829f, -0.00913809f, 0.01096384f, 
    -0.02491574f, 0.01655801f, -0.03244238f, -0.02110361f, 0.02165079f, 0.02576977f, -0.04294373f, 0.02106806f, 
    -0.00135082f, -0.02656025f, -0.01192277f, 0.00039660f, 0.01309610f, 0.00221221f, -0.02036563f, -0.01875135f, 
    -0.00076960f, -0.01115838f, -0.04138335f, -0.01148549f, -0.01947645f, -0.02769268f, -0.00831990f, -0.03863181f, 
    -0.01355406f, -0.01393997f, 0.02181792f, -0.03061584f, 0.03575777f, -0.00482318f, 0.01033693f, -0.00706747f, 
    0.01016300f, -0.00530442f, 0.01741361f, -0.02297980f, -0.01834807f, 0.02460990f, -0.01611031f, -0.02760094f, 
    -0.02520224f, -0.03158166f, 0.02165857f, -0.03091131f, 0.03184507f, 0.00379357f, -0.01547769f, -0.02305073f, 
    -0.02141660f, 0.02191225f, -0.02882810f, 0.00254165f, -0.01791972f, 0.00690483f, -0.04165668f, -0.04236985f, 
    -0.03767889f, -0.03806653f, -0.01901032f, -0.03648205f, 0.01707497f, -0.01921760f, -0.01219144f, -0.03712297f, 
    -0.02996936f, -0.00521499f, 0.00845307f, 0.00420334f, 0.02417937f, 0.02805061f, -0.00711462f, -0.03043193f, 
    -0.03989497f, 0.01790695f, 0.02365667f, 0.02119904f, -0.02546019f, 0.02483139f, -0.02486971f, 0.02555165f, 
    -0.01485179f, -0.01411081f, -0.04164648f, -0.02878838f, 0.01822456f, -0.02072032f, -0.02630635f, -0.03829249f, 
    0.04275550f, -0.02485177f, 0.01540393f, -0.01032329f, -0.00009166f, 0.00766859f, -0.01368747f, 0.00330782f, 
    -0.03890315f, -0.00701024f, 0.02507750f, 0.01741519f, 0.00361699f, 0.00008099f, -0.02418171f, 0.01947199f, 
    0.02417547f, 0.01320103f, -0.01066698f, -0.02868220f, 0.02221181f, 0.01141955f, -0.04091254f, -0.02480591f, 
    -0.00060179f, -0.01720916f, -0.00738221f, -0.01818648f, 0.01333551f, -0.01464434f, -0.01174423f, 0.02634710f, 
    -0.00926791f, 0.00482498f, -0.03963033f, 0.00391804f, -0.02757230f, -0.02151118f, 0.02617819f, -0.01247094f, 
    -0.01768127f, 0.00309712f, 0.02212693f, 0.00811515f, -0.01735712f, 0.01007407f, 0.01971253f, -0.03669548f, 
    -0.00698479f, -0.02396107f, 0.02585232f, 0.01968861f, 0.01432071f, -0.04007704f, -0.03543742f, 0.00211486f, 
    0.00506343f, -0.02685585f, -0.01131129f, 0.02306516f, -0.02873840f, 0.02169926f, 0.01621110f, -0.02433847f, 
    -0.03232666f, -0.00447091f, 0.01650412f, -0.01300733f, -0.02098642f, -0.01455608f, 0.02374148f, 0.01922698f, 
    0.01956045f, -0.00405623f, 0.02767582f, 0.03150057f, -0.02971280f, 0.02256481f, -0.03405269f, 0.01353798f, 
    -0.03842469f, 0.01084680f, -0.03707185f, -0.00975591f, -0.03401550f, 0.01931610f, 0.00237258f, -0.02700453f, 
    0.01421403f, 0.02894722f, 0.00949930f, -0.01570626f, -0.00685706f, -0.01308031f, 0.00781513f, -0.03924869f, 
    -0.01497259f, -0.00738904f, 0.01764209f, -0.02771098f, -0.01028568f, -0.03549951f, 0.02827788f, -0.03293873f, 
    0.00331563f, -0.01277316f, -0.00774779f, -0.02587087f, 0.00855017f, 0.01912855f, -0.00376867f, 0.02317272f, 
    -0.01398199f, -0.02020951f, -0.00433306f, 0.02719574f, 0.03341919f, 0.01994107f, 0.02026534f, -0.00147087f, 
    -0.01144139f, -0.00470750f, -0.00316635f, -0.02357823f, -0.02267756f, -0.01816027f, 0.01042007f, -0.03326157f, 
    -0.00527710f, -0.03740776f, 0.00829503f, -0.01295194f, -0.01046979f, -0.01374240f, 0.00995351f, -0.01913521f, 
    0.00579504f, 0.00646710f, -0.00028956f, 0.00493997f, 0.00747539f, -0.02488332f, 0.00245166f, 0.00463045f, 
    -0.01483928f, 0.01546288f, 0.01788100f, 0.01274627f, 0.00719757f, -0.00482356f, 0.00845251f, 0.00876032f, 
    0.00018822f, -0.00024231f, -0.02522130f, 0.00998692f, 0.00083268f, 0.00392210f, 0.01922190f, 0.00632421f, 
    0.02250467f, 0.00753650f, -0.02283422f, -0.04292138f, -0.03176419f, -0.02454075f, 0.02934038f, 0.02216981f, 
    -0.02676033f, -0.03467924f, -0.00653058f, -0.00624679f, -0.01054833f, 0.00509208f, -0.00997391f, -0.04052716f, 
    -0.04015861f, -0.04180624f, 0.00982874f, -0.02278260f, 0.01658766f, -0.00047824f, -0.00643896f, 0.00114878f, 
    -0.02150333f, 0.01817445f, 0.01936476f, -0.00180037f, -0.04083269f, -0.03317178f, 0.02711098f, -0.00710911f, 
    -0.02800189f, 0.00488882f, -0.00015980f, 0.02657379f, 0.02395762f, 0.00313804f, 0.00606806f, -0.02165809f, 
    -0.01789524f, 0.01306359f, -0.00322856f, -0.01431191f, 0.01439977f, 0.00248862f, -0.02397260f, 0.00093691f, 
    0.02434834f, -0.01606381f, -0.03981677f, -0.01406266f, -0.04179116f, -0.01753771f, -0.04277163f, -0.00565485f, 
    -0.00953193f, 0.00711352f, -0.04216090f, -0.00423523f, 0.00462676f, 0.01968802f, -0.00677936f, -0.01056936f, 
    0.01867278f, -0.04006983f, -0.00308602f, 0.02450729f, 0.02975346f, -0.04139294f, -0.01553729f, 0.02729669f, 
    -0.00310098f, -0.03890314f, -0.00328851f, 0.02524773f, -0.01762116f, -0.01976090f, 0.00995169f, 0.00600563f, 
    0.02096361f, -0.02352736f, -0.01735612f, -0.00318197f, -0.01200596f, 0.02293356f, -0.02245021f, -0.00057832f, 
    -0.00783874f, -0.03468014f, 0.00877383f, 0.00033438f, -0.03491821f, 0.00444857f, -0.03185800f, 0.02545619f, 
    -0.01179610f, 0.01913250f, -0.03398700f, -0.00291213f, -0.02722768f, -0.03374661f, 0.00272460f, -0.01023512f, 
    0.00027555f, 0.02163233f, -0.00155598f, -0.01396572f, -0.02675534f, 0.00772766f, 0.02569591f, -0.02735102f, 
    -0.03199412f, -0.00630909f, -0.02001666f, 0.00432106f, -0.02201145f, 0.02262283f, -0.04335681f, -0.00390386f, 
    -0.04093684f, -0.01772201f, 0.01761338f, -0.03164120f, -0.00501055f, 0.01175602f, -0.01849532f, -0.02850991f, 
    0.01914626f, -0.01807613f, 0.02795831f, 0.00343718f, -0.01019562f, 0.00064514f, 0.01521512f, -0.02888603f, 
    -0.04159886f, 0.02483427f, 0.00451149f, -0.00756153f, -0.02198671f, 0.00848960f, 0.00340291f, -0.03072063f, 
    -0.00362792f, -0.01078421f, 0.02018283f, -0.02816732f, -0.00635091f, 0.00670349f, -0.03607157f, 0.01046223f, 
    0.01544062f, 0.02525667f, -0.02568144f, -0.01520815f, -0.03209325f, -0.01286148f, -0.04129868f, -0.03836947f, 
    -0.00779543f, -0.00722591f, -0.01612794f, -0.02601518f, 0.00466631f, -0.01489707f, 0.02340678f, -0.00240997f, 
    0.02549827f, 0.00797835f, -0.03733297f, -0.03133177f, -0.00743010f, 0.00160427f, 0.02262314f, 0.01370597f, 
    -0.03689086f, 0.02933038f, -0.02745458f, -0.03731724f, 0.00513218f, 0.01330475f, 0.02312589f, 0.00167491f, 
    -0.02918230f, 0.00908719f, 0.02621049f, 0.01792737f, -0.01771015f, -0.00644345f, 0.01670538f, -0.00446656f, 
    -0.00311999f, -0.01433010f, -0.02154695f, -0.03633233f, -0.00862412f, -0.01107038f, 0.01993202f, -0.00018527f, 
    -0.01523878f, -0.03202873f, 0.00809200f, 0.00873537f, -0.01066836f, 0.01116637f, 0.01474407f, 0.01464150f, 
    -0.00624296f, -0.01181903f, -0.01168593f, -0.02812433f, -0.03129664f, -0.03896870f, -0.00811918f, -0.02616673f, 
    0.01208802f, -0.00964504f, 0.00006049f, 0.00028901f, -0.03858944f, 0.01452263f, -0.00523687f, -0.03643418f, 
    0.02253016f, 0.01371070f, 0.01471547f, -0.00526740f, 0.00665986f, -0.02837496f, -0.02562203f, -0.03441181f, 
    0.02627382f, 0.00610459f, -0.04123113f, -0.01139408f, 0.02636667f, 0.00996098f, 0.01428707f, 0.01430718f, 
    -0.02631700f, -0.01004189f, 0.00718869f, -0.00620222f, -0.00349090f, -0.01984866f, -0.03268762f, -0.02210955f, 
    0.02399663f, 0.00368194f, -0.00117462f, -0.03882718f, 0.00371892f, -0.01357019f, -0.01440607f, 0.00943328f, 
    -0.02354388f, 0.01104412f, 0.00276816f, 0.01618888f, -0.03510216f, -0.00552497f, 0.01961740f, 0.00643061f, 
    -0.03170162f, 0.00088682f, -0.01523047f, 0.02465181f, 0.02700379f, -0.01800052f, 0.00904055f, 0.01624130f, 
    -0.02588459f, 0.01441638f, 0.00534712f, -0.01365248f, -0.00174473f, -0.02061054f, 0.01017921f, -0.02774478f, 
    -0.02672170f, -0.01737149f, 0.00313150f, 0.02457562f, -0.03052551f, 0.00071895f, -0.00354804f, -0.02356193f, 
    -0.02144420f, 0.02289498f, 0.01059310f, 0.01251694f, -0.02282655f, 0.01266897f, 0.00156046f, -0.03420949f, 
    0.02435932f, 0.01749316f, -0.01300361f, -0.00443967f, 0.00265706f, -0.02041460f, -0.03809305f, 0.02321553f, 
    -0.02815229f, 0.02804879f, -0.01269734f, -0.00743041f, -0.00174236f, 0.00306889f, 0.01870521f, -0.02099819f, 
    -0.01330936f, 0.00498330f, -0.02588302f, -0.03700643f, 0.00363599f, -0.01052054f, -0.00786003f, 0.00180372f, 
    0.00833014f, -0.00542054f, 0.00895236f, -0.01983084f, -0.02586130f, -0.03688512f, -0.01491279f, -0.01460325f, 
    0.00377821f, -0.03168594f, -0.01448524f, 0.00166588f, 0.01686932f, -0.02598106f, -0.03439838f, -0.02856754f, 
    -0.00510231f, -0.00842991f, 0.02548074f, -0.03596135f, -0.01200821f, 0.00310304f, 0.00171890f, 0.01144731f, 
    0.02510641f, 0.02403102f, 0.01337221f, -0.03537159f, 0.01659791f, -0.02270550f, -0.00307858f, 0.02812082f, 
    0.01746518f, 0.01583013f, 0.00346056f, -0.03847964f, -0.03883447f, -0.00611683f, -0.03717982f, -0.02443573f, 
    0.00410575f, 0.01617393f, -0.02976673f, 0.00596198f, 0.00859325f, -0.03203940f, 0.02190887f, 0.01929460f, 
    -0.00518821f, -0.00205156f, -0.04396330f, 0.02464928f, -0.00975261f, 0.01760034f, -0.01496514f, -0.00189483f, 
    -0.00582304f, 0.02301269f, 0.01609357f, 0.00820196f, 0.00494335f, -0.03306841f, 0.00126314f, -0.00932559f, 
    0.01983926f, -0.00296528f, -0.02201027f, -0.03529919f, -0.00324284f, -0.03890324f, -0.03094910f, 0.02599319f, 
    -0.00548190f, 0.02594125f, 0.01351161f, 0.02670739f, 0.02296888f, 0.02747556f, -0.03075919f, 0.01234935f, 
    0.01712960f, 0.00295236f, 0.01874957f, -0.02850805f, -0.02436759f, -0.00532711f, 0.00785677f, -0.03121562f, 
    0.01246239f, -0.04127175f, 0.02756272f, -0.03226933f, -0.00698264f, 0.01223373f, -0.00343357f, -0.01958860f, 
    -0.03867360f, -0.00691512f, -0.02499855f, 0.00044811f, 0.02371872f, 0.01967021f, -0.02430216f, -0.03005975f, 
    0.00427500f, -0.02167602f, -0.01092643f, -0.03815220f, -0.00433100f, 0.02635728f, -0.01677663f, -0.01734637f, 
    0.01597771f, 0.01558330f, -0.03054309f, -0.00334503f, -0.02475958f, 0.01341921f, -0.03045660f, 0.00942026f, 
    -0.00494763f, -0.02577846f, -0.03105495f, 0.00392188f, -0.02014037f, -0.02256843f, -0.02994908f, -0.01897968f, 
    -0.00565375f, -0.01325773f, 0.02486078f, -0.02771064f, -0.03700365f, -0.00968460f, 0.01621443f, -0.02511921f, 
    0.02397935f, 0.02554170f, -0.02963638f, -0.03348350f, -0.00217747f, 0.01067110f, 0.02072258f, -0.04329159f, 
    -0.03013236f, -0.00266350f, -0.03869497f, 0.02537962f, -0.01975624f, -0.03158666f, 0.01237379f, -0.03932078f, 
    -0.02616372f, 0.02726530f, -0.02203260f, 0.02633287f, -0.02425012f, -0.02397569f, -0.03163046f, -0.03038543f, 
    -0.01111074f, 0.02809761f, -0.03980412f, -0.03548225f, 0.02683642f, -0.02387862f, -0.01085946f, -0.01296477f, 
    -0.01238740f, -0.03656271f, 0.00875124f, 0.02664638f, 0.02649161f, -0.03000305f, -0.03754174f, -0.00660263f, 
    -0.02727234f, -0.01615610f, -0.00830583f, 0.00376615f, 0.01064071f, -0.00514163f, -0.02823662f, 0.01101966f, 
    0.00959454f, -0.03760920f, -0.02187324f, 0.02328841f, -0.02482524f, 0.01638469f, -0.00856282f, 0.02445925f, 
    0.02805123f, 0.03924944f, 0.00952138f, -0.02500824f, -0.01656235f, 0.01049909f, -0.00635091f, 0.01176660f, 
    0.02170738f, -0.00834607f, 0.01777172f, -0.01771300f, -0.00365359f, -0.02606046f, -0.03483531f, -0.01554217f, 
    -0.00641298f, 0.01455095f, -0.03964756f, 0.01329414f, -0.00248568f, -0.00855111f, 0.02985831f, -0.00446477f, 
    -0.03082924f, -0.00800293f, 0.00449207f, -0.03279817f, 0.02745356f, -0.01448555f, -0.00113661f, -0.02192902f, 
    -0.03833148f, 0.00495111f, -0.01207709f, -0.02078278f, -0.02483680f, 0.00097449f, -0.03614946f, -0.01128459f, 
    0.02243495f, 0.01137826f, -0.00509029f, -0.01840285f, -0.00993903f, 0.01418445f, 0.03009154f, 0.00596712f, 
    -0.01463766f, 0.01598071f, -0.03068028f, 0.03699347f, 0.02692528f, 0.02577432f, -0.03511752f, 0.01204703f, 
    -0.04315564f, -0.02212451f, -0.03643965f, 0.00276748f, 0.00867403f, -0.00250204f, -0.00199583f, 0.01801044f, 
    -0.03907924f, -0.00115242f, 0.01209473f, -0.03007643f, -0.00739607f, 0.01864203f, -0.03475738f, -0.02674502f, 
    -0.03664607f, 0.01319529f, -0.02087913f, -0.00989557f, 0.00526009f, 0.00977472f, 0.00966797f, 0.00120888f, 
    0.02485052f, 0.02408111f, -0.03708618f, 0.02106683f, -0.03671665f, -0.03873701f, 0.02433098f, -0.01147823f, 
    -0.11957688f, 0.00137645f, -0.06615032f, -0.01038508f, -0.09996928f, -0.05186246f, -0.17397636f, -0.23596567f, 
    -0.03865542f, -0.01467616f, -0.12559865f, -0.14216888f, -0.26762858f, 0.03199710f, -0.20436691f, -0.13341793f, 
    -0.10764430f, 0.11494721f, -0.12481663f, 0.14828946f, -0.14074218f, 0.08994192f, -0.12843750f, -0.03776937f, 
    0.04735352f, -0.13043967f, 0.07724788f, -0.05852631f, -0.04113877f, -0.02182580f, -0.04566216f, 0.01368554f, 
    0.01204387f, -0.01853694f, 0.06973176f, 0.05928650f, -0.09621758f, 0.30619490f, 0.03034858f, 0.21107207f, 
    -0.21258946f, -0.07918552f, -0.06210288f, -0.02519049f, 0.07690907f, -0.17751871f, -0.05055384f, 0.14959717f, 
    0.11203891f, 0.37396049f, 0.03675588f, 0.25134230f, 0.02860427f, -0.01999991f, 0.13674802f, -0.08672296f, 
    0.07753618f, 0.05835956f, 0.06040178f, 0.08271571f, -0.14958583f, 0.03372858f, -0.13393024f, 0.18900970f, 
    -0.00302253f, 0.10802998f, -0.04571038f, 0.10787885f, 0.01091002f, -0.02145385f, -0.10121536f, 0.01336501f, 
    0.47174576f, -0.15077646f, 0.07558072f, 0.08145988f, 0.09435934f, 0.05496666f, 0.02798061f, -0.01856261f, 
    -0.07548162f, -0.06678185f, -0.03023553f, -0.05960109f, 0.20506695f, 0.21244051f, -0.03527174f, 0.32662123f, 
    -0.02762936f, 0.09932765f, 0.12340359f, 0.19258894f, 0.00459915f, -0.02452367f, 0.02631920f, 0.06330892f, 
    -0.04310948f, -0.14947020f, 0.07761031f, -0.17186360f, 0.02662153f, -0.09170084f, 0.01417322f, 0.13874437f, 
    -0.01079616f, 0.12090987f, -0.00073674f, 0.07787204f, -0.03784144f, -0.02388898f, 0.03676095f, -0.02445103f, 
    0.03245777f, 0.00242383f, -0.18207118f, -0.08043618f, -0.02267325f, -0.17799494f, 0.08945030f, 0.00694731f, 
    0.00961159f, -0.07510881f, -0.06739713f, -0.22219206f, 0.03604370f, -0.07491598f, -0.03500146f, -0.03964384f, 
    -0.06078172f, -0.01179667f, 0.09553786f, 0.05180017f, -0.08471864f, 0.07712431f, 0.40121597f, 0.01184366f, 
    0.16433311f, 0.08152673f, 0.13257200f, 0.02305992f, 0.19444571f, 0.02334672f, 0.05877627f, 0.05471192f, 
    0.10718364f, -0.00615306f, -0.08407969f, 0.10198641f, -0.04434429f, -0.08739509f, -0.06474715f, -0.04053477f, 
    0.09302956f, -0.12051604f, 0.31302041f, 0.41776708f, -0.31534350f, 0.15321322f, -0.18074158f, -0.30652812f, 
    -0.03178123f, -0.07353128f, 0.06179057f, 0.13033375f, -0.12278938f, 0.06592048f, -0.12350745f, 0.03292697f, 
    -0.36380664f, 0.27299911f, -0.18370801f, -0.02389930f, 0.05849115f, 0.12194012f, -0.17302610f, 0.19602402f, 
    -0.01512765f, 0.11081762f, -0.06642061f, 0.06343877f, 0.11119492f, -0.11483866f, -0.15340564f, 0.07467701f, 
    0.10303631f, 0.11598555f, 0.15711628f, -0.02800051f, 0.05373197f, 0.03446895f, -0.00855326f, 0.03129286f, 
    0.26363987f, -0.07299143f, 0.15122089f, 0.27019075f, 0.18270829f, 0.24021269f, -0.11663857f, 0.06367254f, 
    -0.14516757f, 0.00247106f, 0.01098744f, 0.00037863f, 0.07166985f, 0.15938720f, 0.10641712f, -0.31719989f, 
    -0.00265346f, -0.00633564f, -0.06794153f, 0.02276414f, 0.03809796f, -0.04814624f, -0.10298234f, -0.17758895f, 
    -0.00820746f, -0.13716301f, 0.07923823f, 0.08752905f, 0.08990758f, 0.09594463f, 0.14198436f, -0.01097558f, 
    0.03649515f, 0.03276669f, -0.01600593f, 0.05874133f, -0.10724945f, -0.21314837f, 0.14444689f, 0.32518250f, 
    -0.06465148f, 0.10663392f, -0.10776253f, -0.06392177f, -0.02160561f, 0.00298377f, -0.09461962f, 0.07426365f, 
    -0.22168572f, 0.40684086f, 0.07580636f, 0.11341783f, 0.00248090f, -0.14102173f, -0.09297542f, -0.07595293f, 
    0.09113570f, -0.08185656f, -0.07154190f, -0.11003057f, -0.06738965f, 0.28082219f, 0.06622683f, 0.28256753f, 
    -0.04742732f, 0.12534878f, 0.01198813f, 0.06605169f, 0.08949893f, 0.05280061f, -0.07932988f, 0.01439687f, 
    0.05485856f, -0.04311261f, -0.03503963f, -0.03760380f, 0.02369343f, 0.03850505f, -0.01364338f, -0.00711805f, 
    0.12190238f, 0.09442378f, 0.26177713f, 0.26068833f, -0.14916672f, 0.11556306f, -0.04183226f, 0.25850672f, 
    0.08036005f, -0.02920307f, 0.16625448f, 0.16621511f, -0.15349326f, -0.02725429f, -0.01166091f, 0.01947725f, 
    0.03440461f, -0.08178335f, -0.02414982f, 0.18644735f, 0.06193223f, -0.07819255f, -0.09409016f, -0.04709469f, 
    -0.05179125f, -0.06840812f, 0.04711086f, 0.04396875f, 0.31732455f, 0.17124540f, -0.21025771f, 0.01946422f, 
    -0.10450988f, -0.08854382f, -0.00243251f, 0.01985698f, -0.06707491f, -0.14740513f, -0.05817978f, -0.09910523f, 
    -0.30913416f, -0.00202894f, -0.16249683f, -0.05228661f, -0.00985133f, 0.02317940f, 0.05781499f, 0.07717440f, 
    -0.05274094f, -0.00170089f, -0.07023933f, -0.02401998f, -0.01814194f, 0.07789931f, -0.07254588f, -0.16457744f, 
    0.04020672f, 0.00035958f, 0.06233239f, 0.25360671f, -0.00565139f, -0.02592097f, -0.08560976f, 0.10421882f, 
    0.12674680f, -0.15958063f, 0.11049420f, 0.08295102f, 0.13932820f, 0.11796835f, 0.01642671f, -0.01604904f, 
    -0.07800286f, -0.09816528f, -0.01390885f, 0.02525886f, 0.04027886f, -0.17504643f, 0.20385079f, 0.22399399f, 
    0.20436029f, 0.03142494f, -0.00527252f, 0.09826610f, -0.00500708f, -0.00097353f, 0.12931339f, 0.00202530f, 
    -0.02332122f, -0.07838025f, -0.13345066f, -0.23674497f, -0.05728094f, -0.06608712f, 0.05700878f, 0.04291969f, 
    0.02741480f, 0.04888329f, -0.00986847f, 0.17555967f, -0.07993782f, -0.08226877f, -0.24432473f, -0.23749655f, 
    0.00111296f, -0.07307953f, -0.10317137f, -0.12651774f, -0.00274205f, 0.20076676f, 0.00442392f, 0.07146867f, 
    -0.36368072f, 0.00307365f, 0.22884822f, 0.03817271f, -0.08681895f, -0.16481121f, 0.03610310f, -0.15073486f, 
    0.03457164f, -0.05865147f, 0.02519533f, 0.08201627f, -0.14791004f, 0.08914977f, 0.14809601f, -0.08994993f, 
    -0.03035933f, -0.11948421f, -0.04318688f, -0.09578247f, -0.03638086f, -0.10090397f, -0.09762864f, -0.04981423f, 
    -0.00734625f, -0.29412901f, 0.31995526f, 0.04409620f, 0.21305504f, -0.03953356f, -0.16565868f, -0.03659557f, 
    0.03464817f, -0.02229659f, -0.02223984f, -0.01906264f, -0.06924086f, 0.01279830f, -0.04166611f, 0.36171407f, 
    0.07708327f, -0.00395994f, 0.07766220f, 0.01326907f, 0.04826669f, 0.04149622f, -0.04912200f, -0.03247826f, 
    -0.26951963f, 0.21355960f, -0.17459223f, 0.37172729f, -0.09182122f, 0.04524169f, -0.03362203f, -0.01735315f, 
    0.00905512f, 0.07456096f, -0.06159437f, 0.14646338f, 0.07643022f, 0.03614777f, 0.05776652f, -0.24260984f, 
    -0.19530183f, 0.03823585f, -0.01996456f, -0.08884459f, -0.02358068f, -0.01505915f, -0.03444955f, 0.02282793f, 
    -0.19195743f, 0.23603909f, -0.01934178f, -0.12832364f, 0.04022049f, -0.06632058f, 0.03566864f, 0.09846974f, 
    0.07495143f, 0.06173615f, -0.00045025f, -0.05950617f, 0.04085880f, 0.28847337f, 0.00670519f, 0.36952472f, 
    -0.09736966f, 0.27802736f, -0.06663702f, -0.17266105f, 0.02644668f, -0.08728507f, 0.16350552f, -0.06675399f, 
    -0.03618823f, -0.11342268f, -0.20548610f, 0.01651825f, 0.01255631f, 0.05200793f, 0.00847936f, -0.02570082f, 
    0.08230542f, 0.11302584f, -0.00178537f, -0.03082416f, -0.03126849f, 0.15190707f, 0.02168829f, -0.06003710f, 
    -0.01310534f, -0.11356707f, -0.11945455f, -0.02169823f, 0.02357967f, -0.02004129f, 0.26387504f, 0.26495576f, 
    -0.10537381f, 0.26154831f, 0.04778768f, -0.20734586f, 0.08832814f, -0.02321636f, -0.01337185f, -0.03674177f, 
    0.06270166f, 0.12701285f, -0.10533419f, 0.01972314f, -0.50696141f, 0.20307377f, 0.21590069f, 0.07741464f, 
    -0.10651614f, -0.16958393f, -0.19985946f, -0.05703311f, -0.05312179f, -0.02582610f, -0.10463867f, -0.03054804f, 
    -0.15718739f, -0.01144097f, -0.03899550f, 0.04076543f, 0.01577201f, 0.05291675f, -0.01409709f, -0.15603080f, 
    0.05570104f, -0.12838162f, 0.20564127f, -0.03992739f, -0.44038621f, -0.03542063f, -0.04278916f, 0.02374937f, 
    0.06845737f, -0.16692719f, -0.15057176f, -0.14599012f, 0.05786881f, 0.03183706f, -0.12076309f, -0.24358179f, 
    -0.13011716f, -0.13946417f, -0.10210445f, 0.06936257f, 0.01616411f, 0.06494711f, 0.10443290f, -0.03923445f, 
    -0.04164674f, 0.07708753f, 0.03008111f, 0.08660577f, -0.35524541f, 0.39363587f, 0.03750221f, -0.38907212f, 
    -0.10468899f, 0.02731628f, -0.20804536f, -0.09378252f, 0.06770019f, 0.01739849f, -0.13266705f, 0.05733145f, 
    0.21704154f, -0.11928722f, 0.16024081f, 0.13810469f, 0.17844738f, 0.12824185f, 0.02776660f, 0.21581177f, 
    -0.00966446f, 0.00457286f, -0.02873595f, 0.00393308f, -0.10702872f, -0.06988580f, -0.10307746f, 0.04402342f, 
    0.06510615f, 0.08318806f, -0.13451923f, -0.02063253f, -0.02267590f, -0.00977327f, 0.03114062f, 0.20817843f, 
    -0.06981342f, 0.35744375f, -0.14374116f, 0.56352460f, -0.00404489f, 0.10610870f, -0.00899860f, 0.02532928f, 
    0.24598838f, 0.01512928f, 0.12003261f, 0.03117754f, 0.67737448f, 0.18546420f, -0.24666619f, 0.09773387f, 
    -0.24221779f, 0.07980168f, 0.20061412f, 0.18467437f, -0.00193513f, 0.13326456f, 0.05712095f, -0.02003386f, 
    -0.21444167f, -0.00878235f, -0.08486598f, 0.26781699f, 0.05743760f, 0.06801658f, -0.00399753f, -0.04693413f, 
    -0.05769423f, 0.01074271f, -0.05456795f, 0.11928025f, 0.07117733f, 0.15206838f, -0.13573387f, 0.01922324f, 
    0.04397895f, -0.02219837f, -0.02038853f, 0.18233548f, 0.07181720f, -0.10746031f, 0.17252612f, 0.08822384f, 
    0.11496609f, 0.34000987f, 0.09125219f, 0.46970749f, -0.07547633f, 0.07338689f, -0.02541733f, 0.06684724f, 
    0.11557221f, 0.05566783f, -0.02876300f, 0.01221433f, 0.05839684f, 0.18501860f, -0.24450088f, 0.30512789f, 
    -0.04424556f, -0.12314539f, -0.18731937f, -0.04034567f, 0.16163516f, -0.00203542f, -0.08532491f, 0.14136280f, 
    0.03837143f, -0.21737908f, -0.06104599f, 0.12655367f, 0.14979295f, 0.07728055f, -0.03075367f, -0.09581833f, 
    -0.04588147f, -0.04504970f, -0.17453021f, 0.01458361f, -0.32419482f, 0.24442972f, -0.03359659f, 0.05107368f, 
    -0.08300935f, -0.25991169f, -0.05268792f, -0.02783929f, 0.00029055f, 0.01145039f, -0.02211664f, 0.06822586f, 
    -0.38391235f, 0.24523365f, -0.13836141f, 0.02434921f, -0.02401539f, -0.06259371f, 0.00140513f, -0.01164719f, 
    -0.08616249f, -0.01870777f, 0.05748585f, -0.02793322f, 0.12807502f, 0.08039071f, 0.29750314f, 0.35397142f, 
    -0.00770140f, -0.14676678f, -0.02882200f, 0.01176750f, -0.01080099f, -0.03202824f, -0.11869611f, 0.02162403f, 
    -0.04770186f, 0.02190048f, 0.37863648f, 0.08404997f, -0.03015463f, 0.14068358f, 0.01330120f, -0.00344503f, 
    0.04284740f, 0.16021371f, 0.05901046f, 0.01252139f, 0.25463468f, -0.09263190f, 0.16421893f, 0.23346411f, 
    -0.03146807f, -0.06466268f, -0.02760820f, 0.03999057f, 0.12925552f, 0.17056218f, 0.04423112f, -0.01580037f, 
    0.01253357f, -0.04838966f, 0.13276114f, 0.16798799f, 0.16361298f, -0.11065838f, 0.07221688f, 0.05355708f, 
    -0.13743263f, -0.07308892f, 0.01325184f, -0.00610823f, 0.29292777f, 0.03317526f, -0.05588480f, 0.34274799f, 
    0.19861613f, -0.06396836f, 0.03920348f, 0.30680874f, -0.09119646f, 0.06364420f, 0.00801203f, 0.11016099f, 
    0.25483596f, 0.10560667f, 0.21306117f, 0.02269080f, -0.10696265f, -0.06687754f, -0.01652317f, 0.03751217f, 
    0.18905126f, 0.28521535f, 0.36075312f, 0.17441304f, -0.06736702f, -0.07462321f, -0.13451564f, 0.01628494f, 
    0.04022574f, 0.02727304f, 0.05415555f, 0.06127148f, 0.05787557f, 0.17042357f, 0.23382901f, 0.04847606f, 
    0.19370930f, -0.11239828f, 0.07071637f, -0.15491751f, 0.08485273f, 0.09901065f, -0.19306466f, -0.00689794f, 
    0.09207718f, 0.02748477f, -0.15804301f, -0.06937268f, 0.03132646f, 0.44940349f, -0.28076708f, 0.42579561f, 
    0.17740789f, -0.03928854f, 0.04953307f, 0.25517249f, 0.07304250f, 0.22700197f, 0.38709608f, 0.00588786f, 
    -0.34374562f, 0.00894176f, 0.20275278f, 0.26250988f, -0.07163006f, -0.02682145f, -0.19756891f, 0.20282432f, 
    0.01321412f, 0.03911091f, -0.02438976f, -0.00187141f, -0.31118819f, -0.17016707f, -0.15342982f, 0.21497753f, 
    -0.13461316f, -0.12596209f, 0.05308233f, -0.06955560f, -0.02901896f, 0.08698907f, 0.04536626f, -0.01659479f, 
    0.26955071f, -0.04447174f, -0.01515693f, -0.16319427f, 0.11746231f, -0.07075296f, 0.13777909f, -0.01705873f, 
    0.14038637f, 0.13033934f, 0.09551389f, 0.12447477f, -0.08767813f, -0.05829340f, -0.10076865f, -0.08684204f, 
    0.00641448f, -0.18273018f, -0.08107109f, 0.05003535f, 0.04280780f, 0.30468801f, 0.01115618f, 0.08524607f, 
    -0.39491832f, -0.10109092f, -0.01177672f, 0.05648528f, 0.12413356f, -0.02746459f, -0.02002237f, 0.09384144f, 
    -0.11362595f, -0.04241535f, -0.02124406f, -0.21942100f, -0.10505486f, 0.01298705f, -0.04299537f, 0.00204779f, 
    0.05651492f, -0.12787464f, 0.01834890f, -0.13403971f, 0.17778595f, 0.23698294f, 0.11376732f, -0.04406150f, 
    -0.12394166f, 0.08133282f, -0.14813358f, 0.06412091f, -0.06479424f, -0.01474344f, -0.01623156f, -0.00331879f, 
    0.19775061f, 0.17263031f, 0.02580343f, 0.04077412f, -0.04166861f, -0.06249512f, 0.05180873f, 0.08332902f, 
    0.02063002f, -0.17566410f, -0.20375963f, 0.04904131f, -0.07935183f, 0.10219231f, 0.18449648f, 0.04919907f, 
    0.02436199f, 0.02447361f, 0.07530161f, -0.05546895f, 0.02310891f, -0.05579512f, -0.10416800f, -0.06598216f, 
    -0.10110261f, 0.15106840f, -0.01660090f, -0.14597401f, -0.52039707f, 0.16917555f, -0.26716360f, 0.24226587f, 
    0.18823023f, 0.05374216f, -0.06489741f, 0.07351894f, -0.04367439f, 0.00417383f, 0.13699745f, 0.13399230f, 
    0.29384887f, -0.04507163f, 0.43968275f, 0.17851692f, -0.06418792f, 0.00833682f, 0.26267394f, -0.10483890f, 
    0.08137432f, 0.11897966f, -0.00167346f, 0.19538449f, -0.24870513f, -0.19019116f, 0.04409849f, -0.03613459f, 
    0.13703056f, 0.15429923f, 0.07733033f, 0.01978123f, -0.22948422f, -0.10715809f, -0.12588269f, -0.03964807f, 
    -0.33130831f, -0.12044773f, -0.00010122f, 0.13754298f, -0.12721948f, -0.19565305f, -0.01408461f, -0.01131367f, 
    -0.05877071f, 0.11406536f, -0.05998429f, -0.01727791f, -0.29084858f, 0.23192264f, 0.16559738f, 0.21808115f, 
    0.03878679f, -0.06584154f, -0.07565386f, -0.04104783f, -0.28680724f, -0.15592088f, 0.00441768f, 0.04874810f, 
    -0.30330330f, -0.29279822f, -0.00404106f, 0.18276036f, 0.10661528f, -0.03088535f, 0.07285950f, 0.29280129f, 
    -0.01538737f, -0.03493539f, 0.01367223f, 0.04300211f, 0.06707045f, 0.00004468f, -0.11965568f, -0.06387857f, 
    0.02247332f, 0.00298090f, 0.09279627f, -0.00963117f, 0.04278402f, -0.01559137f, 0.08523399f, 0.19028297f, 
    -0.22246642f, 0.07444193f, 0.18708886f, 0.07767350f, -0.00483410f, 0.02092036f, 0.07050233f, 0.05025310f, 
    0.07109728f, 0.19310014f, 0.15492705f, 0.06823891f, 0.05736681f, -0.03953378f, -0.10966801f, -0.02266165f, 
    0.32299575f, -0.02753840f, -0.01230778f, -0.03758901f, -0.15528873f, 0.00042753f, 0.05251182f, 0.11869098f, 
    0.08024827f, 0.04724117f, 0.04336713f, -0.01321130f, 0.06650247f, -0.10764182f, 0.16882445f, -0.09534265f, 
    0.01529313f, -0.01608277f, 0.09972781f, -0.09968201f, -0.30069602f, -0.21779397f, -0.02057690f, -0.11403014f, 
    -0.06727824f, -0.09817342f, 0.09463785f, -0.16568838f, -0.05578346f, 0.05263793f, -0.13178554f, -0.14955905f, 
    -0.05301416f, 0.04253547f, 0.11056770f, 0.12519515f, -0.08845030f, -0.03618157f, -0.05267594f, 0.07863750f, 
    0.04516305f, 0.01055547f, -0.09954067f, -0.01774837f, 0.00537027f, -0.14446783f, 0.08253048f, -0.14298259f, 
    0.05937213f, 0.00275513f, -0.10310376f, -0.03106378f, 0.04813397f, 0.31939527f, 0.08153858f, 0.07432549f, 
    -0.01254152f, -0.24020605f, -0.04016031f, 0.21506314f, 0.04953304f, 0.24232732f, 0.09018609f, 0.10476963f, 
    0.29698157f, 0.07464244f, 0.05749637f, 0.01751233f, -0.12332665f, -0.09434578f, -0.08039381f, 0.28520033f, 
    0.16527042f, -0.00161992f, 0.03654625f, 0.07867257f, -0.03232304f, -0.06428558f, 0.13276733f, -0.06687262f, 
    -0.05069454f, -0.34942681f, 0.16909494f, -0.08262631f, -0.01764254f, 0.09079439f, 0.00585731f, 0.02161694f, 
    0.01118836f, -0.01255149f, 0.00404685f, 0.09970829f, -0.16579288f, -0.29621276f, 0.22988670f, 0.17893182f, 
    -0.08559676f, 0.03985347f, 0.04007086f, -0.10881013f, 0.06696691f, 0.08712929f, 0.00029090f, 0.12216783f, 
    -0.09443365f, 0.23532553f, -0.05389452f, 0.23118885f, 0.01296532f, -0.02889459f, -0.05235876f, -0.10158153f, 
    -0.05554051f, 0.14457731f, 0.15074874f, 0.08482689f, -0.15410580f, -0.06395841f, -0.01774923f, -0.01794229f, 
    0.02797659f, -0.04129406f, -0.06076743f, -0.09988048f, 0.07270971f, -0.02698184f, -0.04423366f, -0.09857433f, 
    0.40476343f, 0.01041330f, 0.11509531f, -0.00000750f, 0.04603646f, -0.00708694f, 0.06956972f, -0.00461295f, 
    -0.12298326f, 0.05257280f, -0.14737433f, -0.12496069f, 0.51389289f, 0.06139750f, 0.21882196f, 0.05260836f, 
    -0.17174982f, -0.11123616f, 0.07446191f, 0.00584944f, 0.02568874f, 0.19827515f, 0.02950947f, 0.05569607f, 
    0.50061327f, -0.06344741f, 0.23569569f, -0.31637248f, -0.08237255f, 0.16155054f, 0.05740761f, -0.03995365f, 
    -0.11229803f, -0.07432610f, -0.00058774f, 0.12371759f, -0.21598324f, -0.08217901f, 0.06190573f, -0.16593590f, 
    -0.18793987f, -0.15471584f, 0.03145261f, -0.01339368f, 0.06194076f, 0.05080215f, -0.02925034f, 0.08446888f, 
    0.26302320f, 0.06819615f, 0.13463432f, -0.00065675f, 0.05897398f, 0.07332156f, 0.09756376f, 0.13886732f, 
    0.11262462f, 0.17023523f, 0.05181738f, -0.05860060f, -0.29734024f, 0.41511759f, -0.18984976f, 0.04475102f, 
    0.19929732f, 0.01623663f, -0.03564486f, 0.18731843f, 0.09778406f, -0.02666836f, 0.07602159f, 0.19724849f, 
    -0.33944744f, -0.08238452f, 0.01366291f, 0.28426018f, 0.06002509f, 0.01193099f, 0.04832326f, -0.02439691f, 
    0.06560485f, 0.04917423f, 0.11755110f, -0.01745871f, 0.02194968f, 0.43071818f, -0.04583451f, 0.20824851f, 
    0.02594504f, -0.19442469f, 0.10436545f, 0.00304733f, 0.01922378f, -0.00812320f, -0.14336483f, 0.02851876f, 
    -0.24035896f, -0.06524598f, 0.02164708f, -0.02255527f, 0.17388453f, -0.01045108f, -0.01185804f, 0.10224057f, 
    -0.14058942f, -0.09031048f, -0.10724126f, -0.13457701f, 0.18584837f, 0.15059975f, 0.19961813f, 0.08414997f, 
    -0.12540056f, -0.08552384f, -0.11646789f, -0.10962559f, -0.04775211f, 0.07376736f, -0.02495852f, -0.08786486f, 
    -0.03573203f, 0.26911375f, -0.06663103f, 0.09103574f, 0.08917344f, 0.00135326f, 0.05124867f, 0.03275620f, 
    0.17033947f, -0.05213483f, 0.16687243f, 0.04240939f, 0.56877416f, 0.21397910f, 0.25109339f, -0.01287256f, 
    -0.05510261f, 0.03260644f, 0.14433117f, -0.02390463f, -0.02203099f, -0.04574629f, -0.10923102f, 0.07591753f, 
    0.03186074f, 0.14196603f, 0.35144359f, 0.00464700f, 0.01758621f, 0.09426182f, 0.25630102f, 0.08474144f, 
    0.25026634f, 0.14429958f, 0.15221952f, 0.01973650f, 0.17994376f, 0.08075569f, 0.01472335f, -0.01000188f, 
    -0.09501671f, 0.21590590f, 0.02552297f, 0.05692610f, 0.16614234f, 0.00188005f, 0.20535085f, 0.22621994f, 
    -0.09802692f, -0.06197422f, 0.03597280f, -0.03884964f, 0.16000493f, 0.00216845f, 0.02687396f, 0.07889879f, 
    -0.08203862f, -0.14967251f, -0.13179916f, -0.16460334f, 0.60078454f, -0.23264557f, 0.27555925f, 0.41390157f, 
    0.01917998f, -0.10219312f, 0.16556600f, -0.11015251f, -0.02474299f, -0.02641969f, -0.04367050f, -0.03716898f, 
    -0.34256026f, -0.11979807f, -0.10798830f, 0.17635514f, 0.02122310f, -0.15488760f, 0.10005699f, 0.12218145f, 
    -0.07107343f, 0.06273698f, 0.05310895f, 0.04098355f, 0.17385730f, 0.03787051f, -0.00918910f, -0.10549241f, 
    -0.02321323f, 0.02696603f, 0.20820968f, -0.07183859f, 0.13560532f, 0.10291662f, 0.01732530f, -0.15909186f, 
    0.13426308f, 0.05578491f, 0.37250960f, 0.05381782f, 0.02035668f, -0.17531589f, 0.11807597f, 0.16170235f, 
    -0.05128064f, 0.24409132f, 0.05344325f, -0.08034647f, 0.12164154f, -0.47804999f, 0.09539808f, -0.21159740f, 
    0.33509928f, -0.05506712f, 0.03089124f, 0.01727380f, 0.07248043f, 0.06463449f, 0.13716508f, 0.17157473f, 
    -0.08414607f, -0.12046271f, -0.04138460f, 0.07205606f, 0.01298792f, -0.15537989f, 0.19396907f, 0.20684309f, 
    0.24394310f, 0.06173328f, -0.00375449f, 0.01792414f, 0.19196509f, 0.22185981f, 0.24158642f, 0.01828543f, 
    -0.04378051f, 0.09555930f, -0.03916032f, -0.08723813f, 0.07576679f, 0.25768268f, 0.07057077f, 0.16084306f, 
    0.09478183f, -0.09373786f, 0.05067049f, -0.06432729f, 0.02586388f, 0.00529440f, 0.16774692f, 0.00850290f, 
    -0.08309010f, 0.06961654f, -0.03664512f, -0.00603254f, 0.42292148f, 0.17272763f, 0.24766672f, -0.04086261f, 
    0.14048839f, 0.05060552f, -0.00327636f, 0.13379267f, -0.02133633f, 0.23237841f, 0.09041705f, -0.01910576f, 
    0.15783842f, -0.17393680f, -0.10567477f, -0.11434849f, -0.09935530f, -0.18581814f, -0.07269850f, 0.07727459f, 
    0.13991044f, 0.09133164f, 0.02463454f, 0.14978687f, 0.27041584f, 0.14922214f, 0.04488067f, -0.03183427f, 
    -0.03623056f, 0.04770990f, -0.08913893f, -0.08882821f, -0.02948119f, -0.05248031f, -0.10705304f, -0.07317206f, 
    0.44521385f, 0.10229363f, 0.03209304f, 0.03500554f, 0.00763093f, 0.12896411f, 0.01162722f, -0.14877626f, 
    0.04596328f, -0.09516922f, -0.01134902f, 0.03348453f, 0.01785750f, -0.08413933f, -0.06841937f, 0.00991315f, 
    -0.02570518f, -0.03800086f, 0.01725016f, -0.00380749f, 0.00774566f, 0.05982661f, 0.12546490f, 0.06928743f, 
    0.10619893f, 0.09852367f, -0.14055523f, 0.00588514f, 0.00641921f, -0.17992316f, -0.07145338f, 0.00017018f, 
    -0.03449059f, -0.01359880f, 0.04149276f, 0.13477091f, -0.06713806f, 0.19018516f, 0.10152879f, 0.03056428f, 
    -0.06999725f, 0.02274884f, -0.07102060f, 0.03097738f, 0.10349197f, 0.08343926f, 0.06948248f, 0.01604291f, 
    -0.35664630f, -0.07555561f, -0.01881731f, 0.02930681f, -0.17190678f, 0.03380108f, 0.01039703f, -0.10415732f, 
    0.05888616f, -0.01973830f, -0.07789578f, 0.03515445f, 0.10252944f, -0.03742174f, 0.07785013f, -0.13669318f, 
    0.10651703f, 0.03676160f, 0.02071357f, -0.08548816f, -0.12011648f, -0.20684072f, -0.08976019f, -0.07387463f, 
    0.00208101f, 0.00218860f, 0.01694619f, 0.01627993f, -0.00726201f, 0.00068196f, -0.00000578f, -0.00378408f, 
    -0.02035489f, -0.01268352f, -0.00734774f, 0.01572954f, -0.01948446f, 0.02164074f, -0.01727264f, 0.02323652f, 
    0.01418971f, 0.02128336f, 0.01655095f, -0.02024517f, 0.00268033f, -0.01757196f, 0.02628365f, -0.01639734f, 
    0.02441680f, -0.00399225f, 0.01097811f, -0.00868178f, -0.01696108f, -0.03917837f, -0.04125812f, 0.02790791f, 
    -0.03745512f, -0.02828093f, 0.00462995f, 0.02453449f, -0.03422078f, 0.01363625f, 0.00602034f, 0.02077984f, 
    0.00364121f, -0.02950982f, 0.00593130f, 0.01344737f, 0.02503573f, -0.04147575f, -0.01580560f, -0.04124884f, 
    -0.00895480f, -0.04093119f, -0.00822635f, -0.00911766f, -0.04050831f, 0.02950726f, 0.02578747f, 0.00678543f, 
    0.02530349f, -0.03150628f, -0.01562400f, 0.00468901f, -0.03478839f, -0.01923935f, -0.04192371f, 0.02829470f, 
    0.02327991f, -0.00367244f, 0.00263997f, -0.01141413f, 0.03334775f, -0.02849097f, -0.02398761f, -0.00326235f, 
    0.01599415f, -0.03043664f, 0.02270733f, -0.01196136f, -0.02861193f, -0.01152895f, 0.00490547f, 0.00984003f, 
    0.01263367f, -0.00821247f, -0.03075008f, -0.03964761f, -0.03870540f, -0.02330207f, -0.01880557f, -0.02106021f, 
    -0.01306238f, 0.01957873f, -0.00904737f, -0.03951887f, -0.03978981f, -0.03333873f, 0.00932644f, -0.01332889f, 
    -0.00164261f, -0.03636023f, 0.02131156f, -0.00117444f, 0.00166724f, -0.00324744f, -0.03236079f, -0.01611654f, 
    -0.01647624f, -0.03197547f, 0.00280671f, -0.03171340f, 0.01703865f, -0.03235976f, -0.04135676f, -0.01260087f, 
    -0.00539472f, -0.02777882f, -0.00755394f, 0.02858383f, 0.00235531f, -0.02843265f, -0.03456946f, 0.01450891f, 
    0.00357077f, -0.02272184f, -0.02111105f, -0.03450510f, 0.02715751f, -0.01306238f, 0.02899760f, 0.02696073f, 
    -0.00788821f, -0.03428289f, -0.03483883f, 0.02842082f, 0.00377155f, 0.02767734f, 0.02031181f, 0.01068405f, 
    0.00835583f, 0.02895667f, -0.01015367f, -0.02415603f, 0.02648896f, -0.03216536f, -0.00696502f, 0.00549263f, 
    0.01442322f, 0.01596344f, 0.00385502f, -0.01813475f, -0.00695183f, 0.02845605f, -0.00263598f, 0.01375297f, 
    -0.01861995f, -0.00188647f, -0.02155196f, -0.01624009f, -0.02573706f, -0.00337923f, 0.02008677f, -0.01681999f, 
    -0.02963082f, 0.01920104f, 0.01563340f, -0.00242241f, -0.03091518f, -0.00434787f, -0.03371143f, 0.02794677f, 
    0.02694194f, -0.01408388f, -0.03251877f, 0.00388591f, -0.00572315f, -0.04170242f, -0.01160122f, 0.00191639f, 
    0.00081010f, -0.02982894f, -0.04187210f, -0.02782232f, -0.04053988f, 0.00732395f, -0.01397517f, -0.03247672f, 
    -0.02639184f, 0.02453896f, -0.01748326f, 0.02218135f, -0.00218005f, 0.01322135f, -0.00418650f, -0.03451179f, 
    -0.01811503f, -0.02089076f, -0.03500414f, -0.03503180f, -0.02689845f, -0.00126917f, 0.01159154f, -0.02954703f, 
    -0.03029869f, -0.00994795f, 0.02962459f, -0.02323450f, 0.02210832f, -0.01765399f, 0.02392560f, -0.00085296f, 
    -0.02251474f, 0.00535870f, -0.01452812f, -0.02007905f, 0.00990161f, 0.01984823f, -0.01084734f, 0.01236001f, 
    0.02353704f, 0.01720281f, -0.02336977f, 0.00744197f, -0.01138778f, 0.02884135f, -0.03079340f, -0.01044425f, 
    -0.00159671f, 0.01834788f, -0.02903021f, -0.02728143f, 0.00221901f, -0.03841839f, -0.02600734f, -0.03406348f, 
    -0.03322943f, -0.00085227f, -0.03967998f, -0.03350052f, 0.01367228f, -0.03403163f, 0.02609306f, 0.00508118f, 
    -0.02541374f, 0.00674776f, 0.01877567f, -0.03583614f, 0.02133182f, 0.01884932f, 0.00315601f, 0.00584318f, 
    -0.00877234f, 0.01384529f, 0.02730298f, -0.00632497f, 0.02600148f, -0.04184809f, -0.03033585f, -0.03470520f, 
    -0.01125605f, -0.02675278f, -0.01203342f, -0.01878873f, -0.03812239f, 0.00637615f, -0.03415649f, -0.03320321f, 
    -0.03307607f, -0.03231792f, 0.01937932f, -0.03852260f, -0.03646895f, -0.00153790f, -0.02105451f, 0.02722956f, 
    0.01228889f, -0.01675084f, -0.02378913f, 0.00061777f, 0.02878048f, 0.01986803f, -0.01531351f, 0.02294938f, 
    0.00841705f, -0.03003526f, -0.02030061f, -0.01273423f, -0.01995631f, -0.03744387f, 0.02284196f, 0.00524768f, 
    0.00101658f, -0.00660355f, 0.00486055f, -0.03481640f, -0.02466341f, 0.02749828f, -0.00624399f, -0.03280888f, 
    -0.01310797f, -0.00990568f, 0.02555298f, -0.01748646f, 0.01326551f, 0.01226044f, 0.00356622f, -0.03923343f, 
    0.01593312f, 0.00890282f, 0.00322278f, -0.02568390f, -0.01297616f, 0.01765797f, -0.02699033f, -0.03688519f, 
    0.00059821f, -0.03657522f, -0.00175556f, 0.01065490f, -0.00973412f, -0.01918404f, 0.02721685f, -0.03610388f, 
    -0.02831715f, 0.02538992f, -0.00601872f, 0.00368982f, -0.00747067f, 0.00568850f, 0.00828219f, 0.02725188f, 
    -0.03695789f, -0.02927590f, -0.01214457f, 0.01280953f, -0.01465411f, -0.01210442f, 0.02276425f, -0.02243793f, 
    0.00259562f, 0.01722656f, -0.00647764f, 0.00025077f, -0.00861082f, -0.03608865f, 0.03294788f, -0.03123997f, 
    0.01381411f, -0.01931902f, -0.02248836f, -0.02151680f, -0.02107471f, 0.02634496f, -0.03362723f, 0.01710210f, 
    0.02967821f, -0.02153128f, -0.04190548f, 0.02828852f, 0.01185410f, -0.01112001f, -0.01690846f, 0.02588496f, 
    -0.01211167f, 0.00691580f, -0.00751319f, 0.00058026f, -0.00817398f, -0.03469035f, 0.01551871f, 0.02482278f, 
    -0.04043455f, -0.04104140f, -0.01008913f, 0.02428094f, 0.01136221f, -0.00274954f, -0.02197007f, 0.02816105f, 
    -0.04048982f, 0.01345369f, 0.00869736f, -0.02069042f, -0.00408603f, 0.01938334f, -0.02041976f, 0.02936600f, 
    0.00760863f, -0.03083802f, -0.02919065f, 0.02973014f, -0.03216754f, -0.04014248f, 0.00825908f, -0.03693987f, 
    0.00430124f, -0.02817857f, 0.02754634f, -0.00703601f, -0.03966958f, -0.00190464f, -0.01095334f, 0.01403701f, 
    0.01797405f, 0.02419384f, -0.01682454f, -0.02737522f, -0.04176123f, 0.01110522f, -0.01700258f, -0.01394610f, 
    0.01455085f, -0.03097570f, -0.00476428f, -0.03443360f, 0.02306734f, -0.02122490f, 0.02969134f, -0.00608764f, 
    -0.01998894f, 0.02077154f, 0.02511211f, -0.03001537f, 0.02335458f, 0.00574896f, -0.00180893f, -0.02200110f, 
    0.00151725f, -0.00886619f, 0.00493841f, -0.01155978f, -0.03596643f, -0.04029524f, -0.01419863f, -0.03391914f, 
    0.00840568f, -0.01887229f, -0.01121314f, 0.01021115f, -0.04045595f, -0.00822460f, -0.01919345f, -0.02238708f, 
    -0.02759404f, 0.01733883f, -0.01879806f, -0.00869344f, 0.00662551f, 0.01105691f, 0.02404358f, -0.03980265f, 
    -0.01413515f, 0.00619155f, 0.00961835f, -0.00196095f, 0.01666619f, 0.01351505f, 0.02530909f, 0.00704818f, 
    0.01580292f, -0.02178006f, -0.00804237f, -0.03021568f, 0.02574013f, 0.02285093f, 0.00674203f, -0.01808975f, 
    0.02954262f, -0.01739606f, 0.02078284f, 0.00691583f, -0.03172925f, -0.02902275f, 0.00082614f, -0.00892664f, 
    -0.03607825f, -0.02507935f, -0.03925179f, 0.02670197f, -0.02747070f, 0.01897094f, 0.00835109f, -0.01116994f, 
    0.00825212f, -0.03615275f, 0.01711463f, 0.02615263f, 0.02043959f, -0.01105141f, -0.04149983f, 0.01860358f, 
    0.02323358f, -0.01791036f, 0.02041425f, 0.02704574f, 0.00484173f, -0.01980514f, -0.00827709f, -0.01754070f, 
    0.01107757f, -0.00146158f, 0.01354767f, 0.01467387f, 0.01472483f, 0.00035977f, 0.00490062f, 0.00426819f, 
    -0.00146758f, -0.01359677f, -0.01763549f, 0.02141585f, 0.01796108f, 0.01605726f, 0.02288226f, 0.00189141f, 
    0.02104369f, 0.01707140f, 0.00184944f, -0.02684695f, -0.02432391f, -0.01074066f, 0.00056177f, 0.02757768f, 
    -0.04059004f, 0.02058619f, 0.02161310f, -0.03207191f, -0.03242821f, 0.00003374f, -0.01659173f, -0.02061225f, 
    -0.01353364f, -0.00545837f, -0.00669485f, -0.04143552f, -0.03450473f, -0.01387361f, -0.01490507f, -0.01534916f, 
    -0.03823574f, 0.01129652f, -0.02166166f, -0.00253429f, 0.02958734f, 0.00670228f, -0.01494275f, -0.00584346f, 
    0.02419236f, 0.00623040f, -0.03360916f, -0.01364812f, -0.03941713f, -0.04020503f, -0.00450458f, 0.01909823f, 
    0.00364492f, -0.01574020f, -0.00236605f, 0.02837712f, -0.04111196f, 0.00688271f, -0.02819586f, 0.00443531f, 
    0.00513425f, -0.02996159f, -0.03063122f, -0.04132335f, 0.02123246f, -0.02048471f, 0.02978897f, 0.00039149f, 
    -0.02768737f, -0.02695103f, 0.01467543f, -0.00125025f, -0.03089716f, -0.02550135f, -0.03233221f, 0.00433142f, 
    0.00069759f, -0.02353849f, 0.00041229f, -0.02222423f, 0.01650509f, 0.00244963f, -0.01937265f, -0.01741805f, 
    -0.01773941f, -0.02964209f, -0.03649069f, -0.02689404f, -0.03893393f, -0.02956394f, 0.02844772f, -0.01613232f, 
    0.02377212f, -0.00574616f, -0.01229285f, 0.00312627f, -0.00816031f, 0.00816591f, 0.02301580f, -0.01503792f, 
    0.00830705f, -0.03352925f, 0.01325421f, -0.03077542f, -0.00703480f, 0.01544305f, 0.02850058f, -0.01804637f, 
    -0.03104782f, -0.02901807f, -0.02090384f, -0.01100061f, 0.02859503f, 0.03041805f, 0.01045566f, -0.02095000f, 
    -0.04059094f, -0.01667984f, 0.02574683f, -0.02130843f, 0.01152700f, 0.02224902f, -0.02062673f, -0.00764121f, 
    -0.00408172f, 0.02328928f, 0.01865589f, 0.00119850f, -0.03777926f, 0.01120472f, 0.02576162f, -0.03345153f, 
    -0.01851609f, 0.01498768f, 0.01167126f, 0.00235774f, 0.01361349f, -0.01946489f, -0.01431933f, 0.00556118f, 
    -0.02167220f, -0.00956450f, 0.00977860f, -0.03974815f, 0.02756756f, -0.03565871f, 0.01234463f, -0.00276200f, 
    -0.01806228f, -0.01029237f, -0.04018464f, 0.02245662f, -0.02754572f, -0.01950422f, 0.01484629f, 0.02167676f, 
    0.00174767f, 0.00158790f, 0.02370880f, -0.01991948f, -0.00937328f, 0.01790204f, -0.03744957f, -0.02096996f, 
    -0.02588347f, -0.01116259f, 0.00423718f, 0.02816155f, 0.01120512f, -0.00849980f, -0.03024281f, 0.00836984f, 
    0.02639426f, -0.03669361f, 0.00342215f, -0.00978173f, 0.02027944f, 0.00553015f, 0.01848368f, -0.02786129f, 
    -0.00584002f, 0.00907485f, 0.00692043f, 0.01304668f, -0.02213320f, 0.01424235f, 0.02722027f, 0.02309856f, 
    -0.03863367f, 0.02031405f, -0.01079123f, -0.04196383f, -0.03620289f, -0.03243466f, 0.01865913f, 0.00181054f, 
    0.02363297f, 0.00214777f, -0.02247961f, 0.00616921f, 0.01558543f, -0.03456323f, 0.01824558f, -0.00562910f, 
    -0.02739093f, -0.02804953f, -0.00323781f, 0.00049820f, -0.04083565f, 0.02023578f, 0.02156124f, 0.00982244f, 
    0.02378695f, -0.02376570f, -0.03613789f, -0.00389541f, -0.00535385f, -0.00189474f, 0.00817163f, 0.02434106f, 
    -0.01230601f, 0.01865334f, -0.01038975f, -0.00468583f, -0.03674475f, -0.03292257f, -0.01529632f, -0.04151148f, 
    -0.03863884f, -0.02416735f, 0.00352601f, -0.00748684f, -0.00438743f, -0.00896986f, -0.03705785f, -0.00725606f, 
    -0.02525821f, -0.00213563f, 0.02561444f, -0.00813825f, 0.01313705f, -0.02701169f, -0.00061635f, -0.02554641f, 
    -0.04002776f, -0.00263188f, -0.01760037f, -0.03072280f, 0.01204478f, -0.01986823f, 0.02945160f, 0.00732862f, 
    0.02694618f, -0.00351513f, -0.00265330f, -0.01503983f, 0.02961545f, 0.02479547f, -0.02670129f, -0.02778110f, 
    -0.01234682f, -0.00664738f, 0.00167865f, 0.00826107f, -0.02557144f, -0.02222522f, -0.02098170f, -0.02972615f, 
    -0.07900380f, -0.30782732f, -0.32483247f, -0.01155208f, 0.09169529f, 0.04485561f, 0.03922985f, -0.05972874f, 
    0.04497929f, -0.03239445f, 0.07392500f, -0.07180460f, -0.04761967f, 0.09251599f, 0.28176934f, 0.17335401f, 
    0.04351781f, -0.09118715f, -0.04385951f, -0.07926270f, 0.03739331f, -0.08071232f, -0.04846036f, 0.00169840f, 
    -0.16041981f, 0.14244361f, -0.23987296f, 0.09916393f, 0.06773396f, 0.00678837f, 0.12584931f, 0.01894191f, 
    0.02411541f, -0.04378588f, 0.01845035f, -0.05116073f, -0.12267216f, -0.40547130f, 0.46385726f, -0.27050152f, 
    0.03104156f, 0.09314091f, -0.01142686f, 0.00385187f, 0.13104002f, -0.04003974f, -0.10652699f, 0.04505401f, 
    0.21590197f, 0.05386524f, 0.17238003f, -0.06063680f, 0.03420668f, 0.02181889f, 0.18150398f, 0.12028436f, 
    0.13107960f, 0.04948798f, -0.08205839f, -0.03789905f, 0.09262580f, 0.17416608f, 0.38174143f, -0.02046953f, 
    0.12245407f, 0.09768742f, 0.00178628f, 0.08956858f, -0.01345988f, -0.04917195f, -0.02174913f, -0.02000361f, 
    -0.30614269f, 0.14708029f, -0.06807023f, 0.06706887f, -0.04181293f, 0.01207104f, 0.05181589f, -0.06806243f, 
    0.06759341f, -0.15357307f, -0.15151015f, -0.13123760f, -0.04078801f, 0.10299804f, 0.05325095f, -0.06565108f, 
    -0.01721245f, 0.08281967f, 0.06196981f, -0.04149946f, 0.14269157f, -0.09386718f, 0.04725232f, -0.15863091f, 
    0.30505109f, 0.00307236f, 0.11273779f, 0.03989070f, -0.03546518f, 0.04854289f, 0.04752396f, -0.00674102f, 
    -0.04588643f, -0.06272387f, 0.04817557f, 0.04438027f, -0.04735809f, 0.03340761f, -0.22806650f, -0.19788267f, 
    -0.12152974f, -0.01828579f, -0.05735316f, -0.00414597f, 0.05643094f, -0.10344858f, -0.08076531f, 0.20762268f, 
    -0.09293587f, -0.05756980f, -0.05344740f, -0.04848719f, 0.02654584f, -0.11025214f, 0.02156715f, 0.12548135f, 
    -0.10893881f, -0.08389229f, 0.01145824f, -0.03406642f, -0.07372737f, 0.30082536f, 0.11239007f, 0.00759088f, 
    -0.01541471f, 0.03180533f, 0.08732063f, 0.00716542f, 0.14388680f, -0.11868645f, 0.01900727f, 0.02537879f, 
    -0.05175972f, -0.16286243f, -0.16747320f, -0.06579982f, 0.01167166f, -0.02982140f, 0.02994570f, -0.01499064f, 
    0.04703636f, -0.16839534f, -0.07450278f, 0.18994877f, 0.13388102f, -0.24829875f, 0.23310356f, 0.36358044f, 
    -0.14434905f, -0.03226348f, 0.12817748f, 0.02142842f, 0.10484141f, -0.04428543f, 0.02092521f, 0.07629132f, 
    0.17333364f, 0.13070281f, -0.29265201f, 0.04682251f, -0.01663785f, -0.06641056f, -0.11521752f, 0.11924430f, 
    -0.01571484f, 0.11525351f, 0.05443625f, -0.07181890f, 0.28231341f, 0.28225389f, 0.12522539f, 0.08268511f, 
    -0.06620869f, 0.11044572f, 0.00951878f, 0.14548615f, 0.03206441f, -0.04327213f, -0.08101742f, 0.02513370f, 
    0.19114059f, 0.16797338f, 0.19921976f, 0.04406493f, 0.15774304f, 0.07522988f, 0.02049628f, 0.10899898f, 
    0.08266985f, -0.04439372f, -0.02360083f, -0.05446651f, 0.09179920f, -0.23544991f, 0.02362008f, -0.10053087f, 
    -0.01847176f, -0.02549333f, 0.04912402f, 0.05928915f, 0.24844116f, 0.12711385f, -0.02518297f, 0.03251524f, 
    0.24504703f, 0.32703641f, 0.19317871f, 0.02303536f, 0.02917574f, 0.05288944f, 0.05192550f, -0.14674163f, 
    -0.03553499f, -0.03874115f, -0.06404493f, -0.04003779f, 0.07885264f, 0.15214205f, 0.16103348f, -0.08571884f, 
    0.01032420f, 0.00038152f, -0.00571901f, 0.18661788f, -0.10440905f, -0.10138872f, -0.00905203f, 0.03886247f, 
    0.27850348f, 0.00283012f, 0.08651106f, -0.11358172f, -0.04057541f, 0.13266353f, 0.07087016f, 0.08051877f, 
    -0.15360209f, -0.01171007f, -0.02990507f, -0.09535436f, -0.19603327f, 0.16009317f, 0.13578130f, 0.06017536f, 
    -0.08474348f, 0.05441358f, 0.02428032f, -0.10775793f, 0.00586519f, -0.03657985f, -0.07283643f, 0.04683203f, 
    -0.00246200f, -0.02463870f, -0.02457437f, 0.07094394f, 0.04149587f, 0.03513463f, -0.06048136f, 0.11088049f, 
    -0.01544181f, -0.11646328f, -0.05931898f, 0.07540527f, 0.17774461f, 0.24707446f, 0.11266079f, 0.02248577f, 
    0.09721727f, 0.10850178f, 0.09332106f, -0.01457671f, -0.01529527f, -0.10441423f, 0.05771760f, -0.08569066f, 
    0.16361839f, 0.16765796f, 0.20840499f, -0.11283474f, 0.11827969f, 0.07143950f, 0.12638229f, 0.02053579f, 
    -0.00484286f, -0.06422608f, 0.10068853f, -0.01204523f, -0.29641455f, -0.07749783f, 0.10537971f, 0.26837543f, 
    0.05176380f, -0.04421567f, -0.00290751f, 0.08417617f, -0.04754804f, -0.09025393f, -0.00819214f, -0.10558716f, 
    -0.12388419f, 0.11274514f, 0.00337401f, 0.12964238f, 0.12195325f, -0.16699430f, 0.08014633f, 0.09515245f, 
    -0.07095140f, 0.07005362f, 0.02943380f, 0.04223366f, 0.09998150f, 0.21593353f, 0.22708891f, -0.05231639f, 
    -0.03230518f, 0.03072814f, 0.05762690f, 0.12996359f, 0.04557384f, 0.06877913f, -0.08305902f, -0.02537579f, 
    0.17575955f, 0.38083965f, -0.09337105f, -0.03610813f, -0.08713992f, -0.12577192f, 0.05790780f, 0.00435822f, 
    -0.03905286f, 0.00028781f, -0.02147061f, -0.10155570f, 0.05777936f, 0.34215727f, -0.02920298f, -0.09147997f, 
    0.01965495f, -0.04818649f, -0.04519467f, 0.05704578f, -0.03484102f, -0.03098961f, -0.05065085f, -0.00520718f, 
    -0.41684982f, -0.32436132f, 0.12144162f, 0.17375423f, -0.01438889f, -0.03293624f, 0.03935383f, 0.06661345f, 
    0.05421638f, 0.02970952f, -0.16622892f, -0.03615769f, -0.10940878f, -0.02640382f, -0.07595030f, -0.01437693f, 
    0.01709154f, -0.09174772f, -0.00570336f, 0.04245785f, -0.05280501f, -0.03427580f, 0.01598232f, -0.13418929f, 
    0.00614225f, 0.14842574f, -0.21250798f, -0.09567584f, -0.07772589f, -0.01019080f, -0.04476536f, 0.06247976f, 
    0.01043519f, -0.07469975f, 0.09287357f, -0.01462272f, 0.08713998f, -0.25734779f, -0.45611942f, -0.05804491f, 
    0.07047952f, 0.08324821f, -0.12606360f, 0.02930127f, 0.17995249f, -0.11930484f, -0.00240143f, 0.00260901f, 
    -0.04787299f, 0.24312150f, -0.28040063f, 0.23075569f, 0.20131604f, 0.06469354f, 0.01239523f, 0.19181184f, 
    0.05499576f, 0.03547285f, -0.01550608f, -0.00483460f, 0.14742869f, 0.09155849f, 0.02460010f, -0.06773394f, 
    0.09292035f, 0.10106969f, 0.06385788f, 0.03940921f, -0.04054318f, -0.06302837f, -0.05015952f, -0.09106301f, 
    0.09152043f, -0.20209560f, 0.19107780f, 0.08467553f, 0.04419185f, -0.02063558f, 0.06116087f, -0.00739383f, 
    0.11726064f, 0.06803440f, 0.04958450f, -0.03741985f, -0.32772404f, -0.41208738f, 0.32948416f, 0.13016774f, 
    -0.12470561f, 0.09137458f, 0.06498320f, 0.05797146f, 0.05621982f, -0.02543619f, 0.10880516f, 0.10163395f, 
    0.10146298f, 0.04133731f, 0.25608563f, -0.16673040f, -0.05065155f, -0.01295043f, -0.03775163f, -0.03746630f, 
    -0.00359911f, -0.03186788f, -0.06657116f, 0.00135886f, 0.20442651f, -0.14259942f, 0.28602293f, -0.18307987f, 
    -0.11637184f, 0.00869613f, 0.02744732f, 0.12028268f, -0.07109535f, -0.14680471f, 0.13544221f, 0.02478058f, 
    0.00178692f, 0.04533882f, -0.01206163f, 0.00726240f, -0.12806167f, -0.01799686f, -0.09130649f, -0.18970685f, 
    0.03494409f, 0.03607033f, -0.09534717f, -0.10995118f, -0.15617932f, -0.32834196f, -0.18747118f, 0.03299842f, 
    0.00176432f, -0.06444965f, -0.01483936f, 0.02294646f, 0.08651004f, -0.06816576f, -0.02729464f, 0.13945851f, 
    -0.17290340f, -0.39476407f, -0.03592006f, 0.03082416f, -0.10965665f, -0.07467733f, 0.04526231f, 0.05243054f, 
    0.06915746f, -0.07564062f, -0.05669384f, -0.05013801f, 0.00286973f, -0.14146575f, -0.14055462f, -0.05030895f, 
    0.03370640f, -0.08189110f, -0.21231253f, 0.13299997f, -0.01518122f, 0.02008249f, 0.08497063f, -0.04658206f, 
    0.22879611f, 0.09327366f, -0.17072304f, -0.08812750f, -0.11777519f, 0.04730003f, -0.07693242f, -0.05129157f, 
    -0.06548259f, -0.04262372f, 0.03298634f, 0.07748412f, -0.05511107f, -0.10713684f, 0.04586133f, -0.11941215f, 
    -0.04253161f, -0.11068051f, -0.01446386f, -0.08107340f, 0.02160726f, 0.00433963f, 0.17424589f, -0.12647337f, 
    0.20035933f, 0.24318586f, 0.17124821f, 0.01249798f, 0.02737228f, 0.16056840f, 0.06564066f, 0.11607295f, 
    0.01215689f, 0.01266093f, 0.03237916f, -0.04503403f, 0.24927203f, -0.02181887f, -0.25299019f, 0.02201015f, 
    0.00330519f, 0.02737802f, -0.10261098f, 0.12215754f, 0.04711043f, -0.07117254f, 0.13157275f, 0.01624574f, 
    0.15485515f, 0.21631482f, 0.21642023f, 0.04152923f, 0.00741904f, 0.05540600f, 0.01530632f, -0.00461872f, 
    -0.00635898f, -0.04349319f, -0.03932442f, -0.02616945f, -0.17828019f, -0.07399092f, 0.02901352f, -0.05798625f, 
    -0.01218876f, 0.05120799f, -0.03446950f, 0.08878797f, -0.05277164f, -0.06919179f, -0.00322843f, -0.04725331f, 
    0.15867858f, -0.06196187f, 0.04260534f, -0.07767706f, -0.10821987f, 0.14255834f, -0.01095207f, -0.06148114f, 
    0.04839841f, -0.07445183f, -0.01036828f, -0.03088620f, -0.63944191f, 0.33797610f, 0.17093781f, 0.25014925f, 
    0.04500999f, 0.06394148f, -0.08763463f, 0.05723006f, 0.13436960f, 0.03720347f, -0.15943007f, 0.08609988f, 
    0.12915431f, 0.11234032f, 0.27621713f, 0.10488206f, 0.15170184f, -0.00131664f, -0.12567201f, -0.00298514f, 
    -0.05638528f, -0.16674037f, -0.00832768f, -0.02348374f, -0.06642868f, -0.14364472f, -0.12543997f, -0.20055668f, 
    0.00270499f, -0.03954550f, 0.13025858f, 0.07302318f, -0.01562401f, -0.07002191f, 0.01754882f, 0.10275614f, 
    -0.11937439f, 0.20928332f, 0.06693191f, -0.15154234f, -0.01916048f, 0.02759095f, -0.08196023f, -0.01100266f, 
    0.01033972f, 0.02137313f, -0.05978457f, 0.05170038f, 0.11278114f, -0.27582952f, 0.00771162f, -0.15923111f, 
    0.04652846f, 0.12400800f, -0.04891307f, -0.06532589f, 0.09894799f, -0.06729508f, 0.11281894f, 0.07991729f, 
    -0.18899533f, 0.26235172f, 0.13932993f, 0.03517586f, 0.07871019f, 0.05400975f, 0.10988943f, 0.02676536f, 
    -0.09328355f, -0.16459727f, -0.04830223f, -0.05645079f, -0.37074453f, -0.16360389f, -0.04162141f, 0.00732014f, 
    0.01901001f, -0.14189629f, -0.02676781f, 0.03982148f, -0.00694810f, 0.01941369f, 0.04330335f, 0.03617651f, 
    -0.11332094f, 0.05783490f, 0.06648479f, -0.03316677f, -0.02610405f, -0.15343575f, -0.10448357f, 0.08483428f, 
    -0.07770298f, 0.05540368f, 0.01642482f, 0.01845474f, -0.15115933f, 0.13291204f, 0.05602358f, -0.12131937f, 
    0.02983333f, -0.01548011f, 0.00866265f, 0.06966305f, -0.02163772f, -0.14591342f, -0.07572450f, -0.05999466f, 
    0.10989089f, 0.21241894f, 0.04924797f, -0.13541155f, -0.04056494f, 0.07919362f, -0.00943778f, 0.02874998f, 
    0.09088401f, -0.02462614f, 0.14371708f, -0.02892037f, -0.02906273f, 0.00806586f, -0.24254617f, -0.11940516f, 
    0.02679101f, 0.03857727f, 0.16324656f, -0.06330785f, 0.06062651f, 0.04981875f, -0.04127871f, 0.07090752f, 
    0.24077140f, 0.18725385f, 0.24409857f, 0.13081829f, 0.16804652f, 0.10957971f, 0.10223927f, 0.20549735f, 
    -0.03329366f, 0.05513661f, 0.01186902f, 0.03718848f, -0.26217550f, 0.17478904f, 0.11989694f, 0.06048033f, 
    0.07695626f, 0.02066928f, 0.21110275f, 0.12322401f, -0.03081063f, 0.12177297f, 0.06519564f, -0.00392546f, 
    0.08130676f, -0.04281187f, -0.00637950f, -0.01805772f, -0.03476364f, 0.00372510f, -0.11066788f, -0.00682979f, 
    -0.15849987f, 0.04521713f, 0.00156768f, -0.00729141f, -0.05878530f, 0.04596147f, 0.01252922f, -0.14147329f, 
    0.15841472f, -0.10908750f, -0.05420327f, 0.22499794f, 0.05019040f, 0.14250998f, 0.07931422f, -0.23180254f, 
    0.10771336f, -0.08563782f, 0.06056331f, -0.04463424f, 0.03049745f, 0.03509143f, -0.05240842f, 0.01396950f, 
    -0.01229370f, 0.19990686f, -0.13044414f, 0.03613153f, -0.16227724f, 0.41262165f, -0.37808019f, 0.19355002f, 
    -0.03954907f, -0.10641468f, 0.14271516f, -0.00922482f, -0.05475336f, 0.02610976f, 0.24602665f, 0.24353054f, 
    -0.02210935f, 0.19947655f, -0.09629389f, 0.03971366f, 0.01346646f, -0.05386325f, 0.17430179f, -0.09194306f, 
    0.05271213f, -0.04507604f, -0.01024708f, 0.08337115f, 0.11363190f, 0.06913385f, -0.11019965f, -0.01602492f, 
    -0.06522454f, -0.06611940f, 0.06961844f, -0.08145145f, -0.00017167f, -0.01123497f, 0.02565385f, 0.01318533f, 
    0.27004451f, -0.18427883f, 0.31614313f, -0.03825150f, 0.15553637f, 0.02983402f, -0.08167446f, -0.07726220f, 
    -0.01707138f, 0.16824429f, 0.18374415f, -0.15121458f, -0.30635217f, -0.14341129f, -0.24539389f, 0.18693146f, 
    0.11892368f, 0.06675110f, 0.12486355f, 0.14780730f, -0.03611866f, 0.13770647f, 0.05198531f, -0.00535572f, 
    -0.14678282f, -0.09882196f, -0.19519825f, 0.00745829f, -0.07908479f, -0.02421235f, 0.14737226f, 0.32123235f, 
    -0.02176050f, -0.04472537f, -0.04824511f, -0.08754469f, -0.15856855f, 0.02174025f, -0.04018308f, 0.05515581f, 
    0.00895020f, -0.14051062f, -0.00643343f, -0.07881778f, 0.21961471f, 0.11603090f, 0.38549358f, 0.11329783f, 
    -0.13575132f, 0.05159049f, -0.10373989f, 0.03453542f, -0.01944616f, -0.09528031f, -0.00540868f, 0.00582103f, 
    0.10161386f, 0.17962907f, 0.10984831f, 0.23773895f, -0.24052663f, -0.24073184f, 0.13811916f, 0.04497338f, 
    0.00332318f, 0.07405666f, 0.04922380f, 0.04636817f, 0.01857674f, -0.08485559f, 0.04437938f, 0.19195618f, 
    -0.02178039f, 0.03391081f, 0.01020542f, 0.10647688f, 0.04147344f, -0.11675692f, -0.05248999f, -0.01964745f, 
    0.01897961f, 0.07139740f, -0.00097828f, -0.11301747f, -0.23783928f, 0.11827316f, -0.38410002f, -0.06465945f, 
    0.05694652f, -0.11735556f, 0.04905538f, -0.01940449f, 0.02597619f, -0.16160052f, 0.01574336f, 0.06337010f, 
    -0.30987588f, -0.23116675f, 0.28909206f, 0.15813725f, 0.15171681f, 0.11146996f, -0.30899206f, 0.10564161f, 
    -0.13095914f, 0.07743201f, 0.02269761f, 0.13866700f, 0.04379534f, -0.09557588f, -0.10804249f, 0.02515923f, 
    0.14415513f, 0.09985711f, 0.06482683f, -0.12021673f, -0.05922607f, -0.03519150f, -0.09862665f, -0.01229292f, 
    0.10894856f, -0.12414668f, -0.07637587f, 0.13602100f, 0.21644603f, 0.02201680f, -0.00644602f, -0.06265865f, 
    -0.08477630f, -0.00734661f, 0.05712363f, -0.06427953f, -0.13980964f, -0.17838159f, -0.07692407f, 0.01161224f, 
    -0.03198276f, -0.03585686f, 0.03179860f, -0.04941845f, -0.28465164f, -0.22598882f, -0.12055684f, -0.06102465f, 
    -0.23483148f, -0.58439648f, -0.14665128f, 0.05581835f, -0.13704601f, 0.00180789f, 0.17259145f, 0.04826251f, 
    -0.00843324f, -0.10993288f, -0.03422323f, 0.12103854f, 0.06540079f, 0.11913721f, -0.01441982f, 0.09308384f, 
    -0.00323607f, -0.04546806f, -0.24493246f, -0.18753970f, 0.03817516f, -0.01420579f, 0.02452769f, 0.04390551f, 
    0.12886201f, 0.36335945f, -0.14110753f, 0.08071584f, -0.02635903f, 0.14196564f, 0.06764430f, -0.17641354f, 
    0.09666854f, -0.01388112f, 0.09924585f, 0.00221712f, -0.04408844f, 0.19928019f, -0.04043670f, 0.06744788f, 
    0.10946134f, 0.07865042f, 0.01949912f, -0.08389951f, -0.05694888f, -0.07521262f, -0.02309845f, 0.01676687f, 
    -0.05152969f, -0.02784961f, 0.04277260f, -0.04336944f, 0.17069255f, 0.13124450f, 0.02899274f, -0.09586425f, 
    0.00965112f, 0.03579410f, 0.13673435f, 0.01144269f, -0.07489196f, -0.08192920f, -0.12410749f, -0.00019954f, 
    -0.08022258f, 0.07350545f, 0.27764913f, -0.10118232f, 0.06163190f, 0.05016113f, -0.07559291f, -0.13009347f, 
    0.16413788f, 0.17806798f, -0.14659855f, 0.07767024f, -0.03383914f, 0.00274233f, -0.04766519f, -0.14305224f, 
    0.00573617f, 0.01196826f, 0.00902043f, -0.03029361f, -0.01574076f, -0.30257121f, 0.13326247f, -0.16625567f, 
    0.10049689f, -0.02480739f, 0.04209563f, -0.04722120f, 0.24034470f, 0.20147663f, 0.03972305f, 0.01609441f, 
    -0.05668629f, -0.03432767f, -0.01691605f, 0.03842240f, 0.17068921f, -0.00712680f, 0.12322123f, -0.00088814f, 
    0.07842784f, -0.04724053f, 0.14893429f, -0.24890770f, -0.03728812f, 0.15579346f, -0.22660306f, 0.01378515f, 
    0.06504232f, -0.19375154f, -0.02588391f, 0.28802609f, 0.04082269f, -0.08459077f, 0.09463603f, 0.04325265f, 
    0.09840170f, -0.40678588f, 0.08210481f, -0.33118680f, 0.04985166f, 0.03763578f, -0.27937815f, 0.07993656f, 
    -0.09602700f, 0.01584816f, -0.00750642f, 0.07517561f, 0.01158487f, -0.04865601f, -0.00455898f, 0.12922093f, 
    -0.00655901f, -0.16346954f, 0.07770118f, -0.04963715f, -0.02810958f, 0.08866663f, 0.09754638f, 0.05915556f, 
    -0.11207553f, 0.00563735f, -0.07830106f, 0.00891064f, 0.04187229f, -0.00576791f, 0.01352139f, -0.07646411f, 
    0.02314213f, 0.07165674f, 0.13910636f, 0.32553640f, -0.01050893f, -0.05188454f, -0.10618520f, -0.00490651f, 
    -0.06331853f, -0.08373904f, 0.03643465f, 0.03496850f, 0.16728272f, 0.10199416f, 0.10683212f, -0.09722064f, 
    0.00291330f, 0.03996484f, 0.28705922f, 0.01906263f, 0.04049555f, -0.15838277f, -0.04387048f, -0.00115081f, 
    -0.04450661f, 0.02350359f, -0.03301174f, 0.06516133f, 0.01130963f, -0.07408360f, 0.05192745f, 0.05594859f, 
    -0.12401112f, -0.14461249f, -0.02533502f, 0.07089289f, -0.09537753f, -0.04686304f, -0.06098000f, 0.03615764f, 
    0.15176895f, -0.11548666f, 0.34428656f, -0.18852450f, -0.05920320f, -0.08862277f, -0.41590825f, 0.06986289f, 
    -0.07410855f, -0.07426360f, 0.04514677f, 0.01625905f, -0.00712643f, -0.19431034f, 0.02700909f, 0.22251423f, 
    -0.07062432f, 0.04490923f, 0.13258430f, -0.04410153f, -0.02214422f, 0.19548108f, -0.03599876f, -0.06774631f, 
    -0.19736591f, -0.28992540f, 0.07032282f, 0.14870349f, 0.05311672f, 0.23199086f, -0.05563987f, -0.00687064f, 
    -0.03731544f, 0.12573695f, -0.07961544f, 0.09834559f, -0.03789264f, -0.06339833f, -0.14989698f, -0.10888240f, 
    0.02036095f, -0.02137244f, 0.14205992f, -0.15648109f, 0.19588539f, -0.24914551f, 0.04062190f, 0.28659737f, 
    -0.08110056f, 0.09049498f, -0.04919186f, 0.01826501f, 0.00982715f, -0.26435491f, 0.06022575f, -0.03784694f, 
    0.11357450f, -0.02034884f, 0.04938814f, -0.16439594f, 0.40775186f, 0.21818565f, -0.06424247f, 0.13097358f, 
    -0.15085779f, 0.05212379f, -0.02499792f, -0.16893341f, 0.14090925f, -0.05758577f, -0.03312026f, 0.00290865f, 
    -0.15975480f, -0.15734665f, -0.09279379f, 0.00879108f, 0.23288101f, 0.19966955f, 0.11682242f, 0.06123760f, 
    -0.16839367f, -0.05497220f, -0.08484541f, -0.13902089f, -0.04532871f, 0.11363638f, 0.12275410f, 0.05318984f, 
    -0.05365375f, -0.00435324f, -0.05753529f, 0.00700387f, -0.07583522f, 0.03626552f, 0.07393373f, -0.00814679f, 
    -0.14397560f, 0.10266789f, -0.08981910f, -0.09335258f, -0.05821040f, 0.01036429f, 0.11771534f, -0.00849122f, 
    0.13900681f, 0.04853078f, 0.01680927f, 0.23391069f, -0.07955048f, 0.40372476f, 0.29317227f, -0.08602952f, 
    -0.04566564f, -0.18661194f, -0.07688716f, 0.02382004f, -0.03460187f, -0.03229269f, -0.02381118f, -0.00449731f, 
    -0.09949885f, -0.03499077f, 0.09325285f, -0.12227497f, 0.06455656f, 0.15869771f, 0.05885547f, -0.16198237f, 
    0.20516089f, -0.05142913f, 0.15970498f, 0.07038913f, -0.12242895f, -0.01719425f, -0.01291491f, 0.16573213f, 
    -0.06592273f, 0.06002475f, -0.21914108f, -0.08381402f, -0.12254481f, -0.19108012f, 0.00914753f, 0.08296993f, 
    -0.03827143f, -0.16959693f, -0.00773704f, -0.00430568f, 0.12711225f, -0.04331538f, 0.01669371f, -0.04937640f, 
    -0.10737328f, -0.12102877f, -0.03089102f, -0.01071507f, -0.07005479f, -0.10354118f, 0.47247362f, 0.00633853f, 
    0.16093884f, -0.15005837f, -0.22430368f, 0.12190743f, -0.09669000f, -0.06572387f, -0.02633262f, -0.01629053f, 
    -0.10540945f, -0.09001573f, -0.21536793f, -0.00393432f, 0.05615753f, -0.00604521f, -0.01236685f, 0.13228640f, 
    -0.03939954f, 0.07242119f, -0.06225431f, 0.10708717f, -0.12464585f, -0.00089841f, 0.07244330f, 0.03944704f, 
    0.01536957f, 0.08791656f, -0.00839145f, -0.03370506f, -0.06352813f, 0.01524822f, 0.11575904f, -0.01092979f, 
    -0.27269000f, -0.18181948f, -0.01266438f, 0.23848934f, 0.07785497f, 0.10644139f, 0.05055219f, 0.04991389f, 
    -0.01734659f, 0.13430680f, -0.00258198f, -0.09201983f, 0.32016698f, -0.58250147f, 0.09794868f, -0.04872702f, 
    0.23430793f, 0.06192110f, -0.03066294f, 0.05364208f, 0.12300181f, -0.11380976f, 0.20961718f, 0.08452370f, 
    -0.03915053f, -0.09471966f, 0.14788100f, -0.13379632f, -0.18027472f, 0.07638346f, -0.05530240f, -0.07304164f, 
    0.20484555f, 0.02072232f, 0.07806264f, 0.12202371f, -0.04673744f, 0.14602518f, 0.01748432f, 0.05939996f, 
    -0.00429154f, 0.06096683f, -0.10174336f, 0.02729606f, -0.00415944f, 0.14256679f, 0.25181025f, -0.01427353f, 
    0.24438165f, 0.15115374f, 0.28174716f, 0.20799349f, -0.15144536f, 0.08344086f, -0.01237018f, 0.00896024f, 
    -0.11959378f, 0.00750987f, -0.03225502f, 0.00152999f, -0.09458731f, -0.07092986f, 0.08761191f, 0.17075513f, 
    0.02848837f, 0.07948984f, -0.27206364f, 0.14772981f, -0.21950084f, -0.06860676f, -0.01415166f, 0.21329176f, 
    0.18282141f, -0.04831461f, 0.14112748f, 0.02299427f, 0.00627836f, -0.16703886f, -0.18757410f, -0.19951309f, 
    0.06395537f, 0.07501719f, -0.05240589f, 0.00225424f, 0.19728008f, 0.40997005f, 0.06521042f, -0.06166919f, 
    -0.04264481f, -0.19603808f, -0.02266407f, -0.02677133f, -0.05366615f, -0.01515975f, -0.05457066f, 0.06326678f, 
    0.16151823f, 0.39695901f, -0.02724703f, -0.17686224f, -0.08116053f, -0.17480575f, 0.04148577f, -0.02541728f, 
    -0.04951186f, -0.06405585f, 0.02015604f, 0.12678464f, 0.22684903f, 0.30786225f, 0.29391438f, 0.25314277f, 
    -0.11860955f, -0.03283456f, 0.01768542f, -0.12462072f, 0.00008346f, 0.06244852f, 0.00233253f, -0.01848942f, 
    -0.26976433f, -0.02879134f, -0.20850892f, -0.00048602f, 0.01057452f, 0.04994835f, 0.06168672f, 0.12491104f, 
    0.15388227f, -0.01215648f, -0.07187307f, -0.07313046f, -0.16847090f, -0.08969838f, 0.03308753f, 0.00109364f, 
    -0.07119994f, 0.03472309f, 0.00273517f, -0.02938630f, 0.02776766f, 0.26340491f, 0.00332589f, -0.13126545f, 
    0.31637800f, 0.31682622f, -0.25838572f, -0.11023312f, 0.03262216f, 0.13112584f, 0.04137620f, -0.02245652f, 
    0.05617420f, -0.03729006f, -0.10795932f, 0.05647860f, 0.08647803f, 0.05462452f, 0.05333685f, 0.15658233f, 
    0.11181823f, -0.00666945f, -0.10014708f, 0.03892281f, -0.12915897f, 0.01371429f, -0.06788380f, -0.00529723f, 
    -0.02246409f, -0.01449671f, 0.01661007f, -0.00061088f, 0.01103065f, -0.01413975f, -0.00447050f, -0.02666827f, 
    -0.02647089f, -0.02367773f, -0.03815667f, 0.00299102f, 0.01772711f, -0.03918196f, -0.02143048f, -0.01064441f, 
    0.00303781f, -0.03255332f, -0.00209350f, -0.02528240f, 0.00314447f, -0.01656522f, -0.00365601f, -0.00636401f, 
    0.01915079f, 0.01671625f, -0.02847862f, -0.02827710f, 0.00889425f, -0.02337747f, -0.01436011f, -0.01653634f, 
    0.00219844f, -0.00372307f, 0.02605469f, 0.02356095f, 0.00357340f, -0.02137486f, 0.00381818f, 0.00935887f, 
    0.01277134f, 0.02579213f, -0.03290235f, -0.01284071f, -0.03680838f, 0.00367610f, -0.02362856f, 0.01477348f, 
    -0.02370200f, 0.02158258f, -0.03142299f, -0.02895689f, -0.03004020f, 0.00706057f, -0.02998795f, -0.00784188f, 
    0.01018387f, 0.01413009f, 0.02402860f, -0.00314583f, 0.01555045f, -0.02415466f, -0.04348833f, 0.02744978f, 
    -0.00698527f, -0.01934300f, -0.02678448f, -0.03258790f, 0.02074243f, -0.04100280f, -0.03116128f, -0.01743953f, 
    -0.02465019f, -0.00067137f, -0.00582536f, -0.02213096f, 0.01048311f, 0.01837859f, -0.03150684f, 0.03561199f, 
    -0.03330262f, -0.01015558f, -0.00974640f, -0.01757962f, -0.02596839f, -0.00549034f, -0.00330372f, -0.02947149f, 
    -0.03343932f, 0.01020845f, -0.03479937f, 0.01321922f, -0.03403939f, -0.01521015f, -0.00048407f, -0.00815466f, 
    0.01845920f, -0.02904632f, -0.00313832f, -0.01898463f, -0.01486956f, -0.03667668f, -0.01710924f, -0.01942604f, 
    -0.04432973f, -0.04265934f, 0.00439261f, -0.04201158f, 0.02812460f, -0.03101028f, 0.02182618f, -0.02915787f, 
    -0.00909598f, -0.02997344f, 0.01068769f, -0.04306363f, 0.01674319f, -0.00689708f, -0.03654185f, 0.00224034f, 
    -0.00991425f, -0.00289691f, -0.02471516f, -0.02668042f, -0.01634391f, -0.00070045f, -0.03040369f, 0.00901421f, 
    -0.01785184f, -0.00922732f, -0.00409398f, -0.04045662f, -0.00155157f, -0.01862356f, -0.03693486f, -0.01445238f, 
    0.01340577f, -0.02227385f, 0.01036551f, -0.00878832f, 0.01249866f, -0.03963241f, -0.01636327f, 0.01098740f, 
    0.00044843f, -0.03102791f, -0.03512023f, 0.01229762f, -0.03526254f, 0.01102446f, 0.01476533f, -0.02984365f, 
    0.00394872f, 0.02219874f, -0.03049864f, -0.02880077f, 0.01710152f, -0.02977603f, 0.01512337f, -0.02427702f, 
    0.01251365f, -0.04387023f, 0.02028363f, -0.03117932f, -0.03130137f, -0.03709678f, 0.00306171f, 0.00872868f, 
    -0.02403489f, -0.04132854f, -0.02314247f, -0.03006945f, -0.00648866f, -0.02321296f, 0.01114015f, 0.02398472f, 
    0.02274402f, -0.00417466f, -0.03812324f, 0.02201874f, -0.02363850f, -0.01468289f, 0.01756692f, -0.03277063f, 
    -0.03046769f, -0.00811865f, -0.00275696f, -0.02894546f, -0.03205286f, -0.03834265f, 0.02231511f, -0.03933227f, 
    0.00412038f, 0.00952122f, -0.02640759f, -0.00730715f, -0.00978342f, -0.00164737f, -0.02097377f, -0.00206331f, 
    -0.02942863f, -0.01883051f, -0.02453128f, 0.01746374f, -0.00944785f, 0.02542486f, 0.01322883f, 0.00672832f, 
    0.02506987f, 0.03146565f, -0.02828974f, -0.00043768f, -0.02992112f, -0.04240391f, -0.04132236f, -0.00647345f, 
    -0.01703373f, -0.03490017f, 0.00656829f, -0.03797451f, -0.00249122f, -0.01585709f, 0.01007332f, -0.00099988f, 
    -0.01891674f, -0.00516024f, -0.04278312f, 0.00379722f, 0.00857658f, 0.00567555f, -0.01406003f, -0.03220829f, 
    -0.04046649f, 0.00983282f, 0.00883938f, -0.00370230f, -0.00785567f, 0.02360165f, 0.01657122f, -0.04130471f, 
    -0.00702996f, -0.00295614f, 0.01295371f, -0.01942543f, 0.03115536f, -0.02751522f, 0.03146530f, -0.02135698f, 
    0.00723622f, -0.01754898f, 0.00746392f, 0.00535516f, -0.00224503f, -0.01462437f, -0.00541526f, -0.01855369f, 
    -0.00965546f, -0.00458668f, -0.03281606f, -0.03634107f, -0.00833075f, -0.03089536f, -0.03869699f, -0.00203648f, 
    -0.00653161f, -0.00219528f, -0.00715123f, -0.04310034f, 0.02319403f, 0.00021948f, 0.00737427f, -0.01746967f, 
    0.01712192f, -0.03389587f, -0.03123244f, -0.02865931f, 0.00836065f, 0.02900825f, -0.00356741f, -0.03687428f, 
    -0.01899966f, -0.03785331f, 0.02594327f, -0.01407126f, -0.02699070f, -0.03184338f, -0.01168987f, -0.01612632f, 
    -0.00311052f, -0.01072804f, 0.00804108f, -0.03423711f, 0.02409576f, -0.02944444f, 0.00794252f, -0.02388795f, 
    -0.01468453f, 0.02585059f, -0.01971382f, -0.02695807f, -0.01528707f, -0.02404466f, 0.00844480f, -0.02668042f, 
    0.00718735f, 0.01602164f, -0.02920497f, 0.01636478f, 0.01916283f, -0.00602952f, -0.02317949f, -0.00900874f, 
    -0.03320371f, -0.04232045f, -0.01581226f, 0.01180530f, -0.01978256f, -0.02024398f, -0.02419096f, -0.03333316f, 
    -0.00180433f, 0.00896930f, 0.01569111f, -0.03888172f, -0.01013149f, -0.01601584f, -0.03585446f, -0.00515644f, 
    -0.01347563f, -0.02735901f, -0.02408235f, 0.00108526f, 0.00373983f, -0.02232230f, -0.03865019f, 0.01784180f, 
    -0.01013067f, -0.02712920f, -0.00484637f, 0.00683779f, -0.01044804f, -0.01590366f, -0.00198858f, 0.02172048f, 
    -0.02632226f, -0.03093499f, 0.01745669f, -0.03480745f, -0.00001912f, -0.01707927f, 0.00974064f, 0.00161320f, 
    -0.02950667f, 0.01545536f, -0.01156420f, 0.02729884f, -0.02907232f, -0.00294021f, -0.02065284f, 0.02400313f, 
    -0.00951416f, -0.04348724f, 0.00209997f, -0.04179003f, -0.03104088f, -0.01212414f, 0.01226374f, 0.00698686f, 
    -0.00428670f, -0.04350320f, -0.03650783f, 0.02594981f, 0.01465108f, 0.00974288f, 0.00486517f, 0.00213847f, 
    0.00441835f, -0.00382333f, -0.03854934f, 0.02395922f, 0.02448017f, -0.02940684f, 0.02716741f, 0.00402746f, 
    -0.01238541f, -0.00033177f, 0.01534036f, 0.00650406f, 0.01255037f, 0.01697117f, -0.02374022f, -0.03000297f, 
    0.02603162f, -0.01178900f, -0.02676747f, -0.03712506f, 0.01792356f, -0.02751970f, 0.00371203f, -0.02693233f, 
    -0.02563355f, 0.00569323f, 0.02826193f, 0.00191727f, -0.02676775f, 0.00362898f, -0.01691969f, -0.03470937f, 
    0.00844819f, 0.02270456f, 0.01552417f, -0.01102206f, -0.03931781f, 0.00848556f, -0.00500962f, 0.00026887f, 
    -0.02617249f, -0.02406946f, 0.00210544f, 0.01496736f, -0.01170489f, 0.00831948f, -0.01577402f, 0.02626969f, 
    0.02728570f, 0.00055675f, 0.02162969f, -0.00650173f, -0.02972077f, 0.00318597f, 0.02816883f, -0.02398461f, 
    0.01119688f, 0.01151433f, -0.02874843f, 0.02418986f, -0.03250581f, -0.03230084f, 0.01250642f, 0.00812796f, 
    0.01845630f, -0.01750066f, -0.01824415f, 0.00545378f, -0.02269186f, -0.02870762f, -0.04180770f, 0.01682880f, 
    -0.02181164f, 0.02465321f, 0.02306213f, 0.02186804f, -0.01476461f, 0.01965001f, -0.01946007f, 0.00258922f, 
    -0.02359494f, 0.00065252f, -0.04056042f, -0.01877137f, 0.00900351f, -0.02391724f, 0.00492574f, -0.02299298f, 
    0.02384227f, -0.02365059f, -0.04110437f, -0.03860162f, 0.01612016f, -0.02625471f, -0.03126661f, 0.00231214f, 
    0.00966095f, -0.02048352f, -0.00503753f, 0.02313532f, -0.02179424f, -0.02046733f, 0.01856509f, -0.03038585f, 
    0.01677714f, -0.02284588f, -0.03444839f, -0.01946063f, -0.01871438f, 0.02694008f, 0.01269256f, 0.02177471f, 
    -0.00735234f, 0.02043981f, 0.01199679f, 0.02309103f, 0.00738407f, -0.02029170f, -0.00764677f, -0.03625722f, 
    -0.01377692f, -0.00761567f, -0.00967349f, 0.00334534f, 0.01735015f, 0.00090821f, 0.02250272f, -0.01754635f, 
    -0.02183588f, -0.00533789f, -0.01458048f, 0.01788349f, -0.04240655f, 0.01681424f, 0.02396492f, -0.03481965f, 
    -0.03221789f, -0.01983834f, 0.02256632f, -0.02888441f, 0.01741948f, -0.00352539f, -0.01978084f, 0.01041374f, 
    -0.01029911f, -0.03914695f, -0.01983977f, -0.00405808f, -0.02765459f, -0.02466960f, -0.03599176f, -0.00903907f, 
    0.01608739f, -0.01187196f, -0.01864518f, -0.03754759f, -0.00669884f, -0.01043383f, 0.01422636f, -0.00159412f, 
    -0.04331662f, -0.03349330f, -0.00361787f, 0.01108037f, -0.01196429f, 0.01234653f, -0.01190015f, 0.00927029f, 
    0.00082700f, 0.01111052f, 0.02341117f, 0.02768883f, 0.00505694f, -0.01835221f, -0.01126102f, -0.02373828f, 
    -0.03618942f, 0.01474310f, -0.02818815f, -0.00246067f, -0.00199491f, -0.02562756f, 0.00692794f, -0.00377886f, 
    0.00104318f, -0.00760484f, -0.02071172f, -0.04185829f, 0.00938224f, 0.01018165f, -0.02119729f, 0.02723783f, 
    -0.01025149f, -0.01530860f, 0.01400048f, -0.01524662f, 0.02582033f, -0.03374500f, -0.02421046f, 0.00057789f, 
    0.01485700f, -0.03331513f, -0.02249567f, -0.02499125f, -0.03836951f, -0.03366668f, -0.00705776f, 0.02433396f, 
    0.01709062f, 0.01657972f, 0.02137191f, -0.02170146f, 0.02425966f, -0.03726314f, -0.02616163f, -0.03482337f, 
    0.01713462f, -0.03396325f, 0.01014885f, 0.01692598f, -0.04150174f, 0.01543233f, 0.01315916f, 0.02405613f, 
    0.01269563f, -0.00443954f, -0.04245727f, -0.02610053f, 0.00209603f, -0.01455274f, -0.03867647f, 0.01273283f, 
    0.00688761f, 0.00989425f, 0.00262386f, -0.00823565f, 0.01858298f, 0.00357296f, -0.03713294f, -0.02871829f, 
    0.00933967f, 0.02799536f, -0.02111129f, -0.02192341f, -0.00907622f, 0.02280742f, 0.02671889f, 0.01730234f, 
    -0.04254272f, -0.02401124f, 0.00139227f, 0.02255308f, -0.01042164f, -0.02026940f, -0.02392293f, 0.00088794f, 
    0.01454074f, -0.03338399f, 0.02787980f, -0.00670435f, -0.01384814f, -0.00685643f, -0.03018403f, 0.00354319f, 
    0.00613847f, 0.02562442f, 0.00445202f, 0.00956320f, 0.01927090f, 0.00047171f, -0.04036120f, -0.01147714f, 
    0.02538469f, 0.02045109f, -0.03651573f, 0.01710742f, -0.03329672f, 0.00877025f, 0.00524735f, -0.04221744f, 
    -0.03325566f, -0.02913278f, 0.01256190f, -0.01109294f, -0.03786726f, -0.03193929f, 0.01153527f, 0.01016315f, 
    -0.00360822f, -0.02600328f, 0.00188557f, 0.02777071f, -0.00361428f, -0.00297180f, 0.00320676f, -0.03070122f, 
    0.02792780f, -0.01537660f, 0.00315114f, 0.03594739f, 0.02633852f, 0.03545919f, -0.01989825f, 0.00792182f, 
    -0.03027462f, 0.00175627f, 0.02261006f, -0.01055479f, 0.02909912f, -0.01030883f, 0.02416375f, 0.00602495f, 
    0.00291689f, -0.02232428f, 0.02259822f, 0.02260769f, -0.03795098f, -0.03840335f, 0.01123861f, -0.01267324f, 
    -0.00495788f, 0.00034858f, 0.01884100f, -0.03534641f, 0.02699183f, 0.02535959f, -0.01796982f, -0.03388433f, 
    0.00786502f, 0.02126124f, -0.00629786f, -0.01994441f, -0.02853767f, -0.00314194f, 0.00538965f, 0.01858209f, 
    0.02631303f, -0.01832335f, 0.02027553f, -0.02714717f, -0.03011950f, -0.03002786f, 0.02515762f, 0.02935432f, 
    -0.01917275f, -0.02672803f, -0.02048188f, -0.01520970f, -0.01028834f, -0.01692757f, -0.03564759f, -0.00284117f, 
    -0.03105886f, -0.01261789f, 0.01108186f, -0.01585560f, 0.01277177f, -0.00776614f, 0.02250348f, -0.01770065f, 
    -0.00565850f, -0.03231055f, -0.04163273f, -0.00849915f, -0.00061382f, 0.02583401f, 0.01364320f, 0.01108080f, 
    0.01406312f, 0.01404409f, -0.01288125f, -0.00402914f, 0.01668032f, -0.00411048f, 0.00209017f, 0.00839003f, 
    -0.01934284f, -0.03647114f, 0.02693631f, 0.02628820f, -0.03654112f, -0.01826551f, -0.04085886f, -0.03016126f, 
    -0.01512699f, 0.02065860f, 0.02118634f, -0.03702123f, -0.00322318f, 0.01268853f, -0.00575470f, -0.03565069f, 
    -0.10352771f, -0.06784920f, -0.04527881f, -0.14534412f, -0.06852546f, 0.05554146f, -0.00099811f, -0.02098605f, 
    -0.11564457f, -0.10270473f, -0.29374149f, -0.21422042f, 0.23737393f, 0.07364981f, 0.19328472f, -0.05978987f, 
    0.14566326f, -0.00591309f, 0.19820912f, -0.00165811f, 0.22129139f, -0.02841480f, 0.07343390f, 0.02708057f, 
    -0.11394090f, 0.00879225f, -0.10241704f, 0.05735170f, 0.10134860f, 0.27708921f, 0.01983659f, 0.09834332f, 
    0.00024965f, 0.05920773f, 0.12960441f, 0.17447284f, 0.21484803f, 0.00393209f, 0.28667444f, -0.36687720f, 
    -0.03040103f, 0.11225788f, 0.10688403f, -0.10008979f, 0.09119701f, -0.01441795f, 0.07796443f, 0.00312973f, 
    0.07147668f, -0.10129696f, -0.13230757f, 0.00007125f, -0.06688745f, 0.14100392f, 0.16331282f, -0.11210509f, 
    0.10220121f, -0.05895963f, 0.08066466f, 0.08549069f, 0.38210675f, 0.18475725f, 0.22546269f, -0.13393308f, 
    0.11226229f, 0.11566485f, 0.14002074f, 0.05662696f, 0.03572504f, 0.00485211f, 0.13675603f, 0.06343764f, 
    -0.43141186f, 0.05414307f, 0.08504946f, 0.01081432f, -0.03470501f, 0.06043797f, 0.05045736f, 0.30605683f, 
    0.09956381f, -0.02147248f, -0.05112383f, -0.28718847f, -0.54772031f, -0.27072868f, 0.02098944f, -0.11129114f, 
    0.00546046f, 0.08175655f, 0.00465876f, 0.05052735f, 0.16556157f, 0.09488383f, 0.17492570f, -0.06841110f, 
    -0.34498119f, 0.26717314f, -0.05281215f, -0.10357741f, -0.04762711f, 0.06299411f, 0.06544646f, 0.18612717f, 
    0.00524147f, -0.01889797f, -0.10854857f, -0.05055352f, -0.11624657f, 0.06673826f, -0.00746342f, -0.12114989f, 
    -0.08165540f, -0.22854331f, -0.08923466f, 0.04778683f, 0.01689094f, 0.12340163f, -0.03653174f, 0.24599974f, 
    -0.10240529f, 0.05598190f, -0.14953978f, 0.01214278f, -0.01912670f, -0.01373701f, 0.05002043f, 0.03748465f, 
    0.21428524f, 0.14545673f, 0.23651201f, 0.01678758f, -0.17342414f, 0.19762124f, -0.07570184f, -0.27085835f, 
    -0.07492206f, 0.02652604f, 0.02395881f, 0.07015838f, 0.03868432f, 0.04120632f, -0.03130687f, 0.12633286f, 
    -0.13049342f, 0.00535266f, 0.02680434f, 0.11110049f, -0.08140879f, -0.15676901f, -0.01702789f, -0.05611868f, 
    0.12717885f, 0.08699875f, -0.05302377f, 0.26044109f, 0.01302034f, -0.21223205f, -0.10236585f, 0.33991507f, 
    -0.04107295f, -0.02338791f, -0.07785597f, -0.00130336f, 0.27423808f, -0.03898717f, 0.33292747f, 0.10683373f, 
    0.23817870f, -0.01778589f, 0.02038828f, 0.33125424f, 0.20578071f, -0.05573970f, 0.23568656f, 0.10760213f, 
    0.06794056f, -0.04209654f, 0.21947984f, -0.04276744f, -0.02119337f, 0.04574991f, 0.22660650f, -0.14085016f, 
    -0.08545855f, 0.05124341f, -0.04022189f, 0.04437239f, -0.00448926f, -0.14586888f, -0.15082309f, -0.01818078f, 
    0.10227016f, -0.11935613f, -0.00960017f, -0.39143926f, 0.07996412f, -0.00772027f, 0.06024164f, -0.07646772f, 
    0.08563269f, -0.08409435f, 0.04825686f, 0.01695380f, -0.10736251f, 0.03573893f, -0.01611809f, -0.11477813f, 
    -0.05348742f, 0.03708629f, -0.01053153f, 0.01983738f, 0.12405153f, -0.00426748f, -0.09206079f, -0.08531679f, 
    0.00412665f, 0.15148470f, 0.01093738f, -0.29442221f, 0.06246042f, 0.00236100f, 0.04990128f, -0.23486322f, 
    -0.04267514f, 0.23413889f, -0.08954713f, 0.06845118f, 0.02261644f, 0.24449429f, 0.06080648f, 0.14884219f, 
    0.01746351f, -0.07517363f, 0.08096433f, 0.24412851f, -0.19714507f, -0.09307227f, 0.21385552f, -0.09586615f, 
    0.27334878f, -0.14543177f, -0.35748854f, -0.19296634f, 0.06098381f, 0.16910410f, -0.09472818f, 0.15250148f, 
    -0.07520549f, 0.07249592f, -0.01313197f, -0.11762194f, -0.34313017f, -0.20200904f, -0.11537730f, 0.01673686f, 
    -0.11498630f, 0.03302294f, -0.00155920f, -0.04925628f, 0.04184036f, -0.06932651f, 0.01808734f, -0.03116831f, 
    -0.00155805f, -0.02279821f, -0.10792840f, 0.00244817f, 0.10837856f, 0.08914402f, 0.09441294f, 0.03597611f, 
    -0.00779750f, 0.17101984f, -0.02726806f, 0.14736959f, -0.15732011f, -0.04708026f, -0.29181713f, -0.33121365f, 
    -0.13028072f, 0.28256637f, -0.08135932f, 0.18274693f, 0.02885492f, -0.09541216f, -0.12869154f, -0.25317597f, 
    0.08902699f, 0.04274924f, -0.01599657f, 0.12486969f, 0.11329702f, 0.19392990f, 0.04424002f, -0.15617532f, 
    -0.14301175f, 0.03988810f, 0.12459926f, 0.00716794f, 0.10414243f, -0.07970957f, 0.23564300f, 0.14635831f, 
    -0.14265049f, -0.04454759f, -0.04381439f, 0.12647219f, 0.10387202f, 0.00446391f, 0.22395331f, 0.01331115f, 
    0.06239179f, -0.06469020f, 0.03593804f, 0.10420587f, 0.09564462f, 0.04065542f, 0.05867339f, 0.12638715f, 
    -0.07087453f, -0.09111635f, -0.08064242f, -0.00659725f, -0.05493668f, 0.04988706f, -0.01924018f, -0.13986023f, 
    -0.10711617f, -0.06639832f, 0.07141498f, -0.23405431f, 0.21760938f, 0.01689151f, -0.06006190f, 0.07008749f, 
    -0.08188127f, -0.02879365f, -0.19741373f, -0.08902415f, 0.04608749f, 0.03773077f, -0.09447689f, -0.03333209f, 
    0.01035851f, 0.05718059f, 0.08181853f, 0.10244989f, 0.05716098f, 0.11423867f, -0.22985902f, -0.33709913f, 
    0.06705216f, -0.06255683f, 0.06497909f, -0.05866754f, 0.14052938f, 0.13459446f, 0.02369094f, 0.10580969f, 
    -0.04168236f, 0.02894223f, -0.09334150f, 0.06031363f, -0.00614212f, 0.01359389f, -0.01200030f, 0.12830777f, 
    0.26400739f, 0.12628207f, 0.21981816f, 0.14795539f, -0.13925762f, -0.13577253f, -0.00339004f, -0.05256693f, 
    -0.12059344f, -0.09203228f, -0.00840559f, -0.03083901f, 0.14390895f, 0.15550832f, 0.21922848f, -0.00021340f, 
    0.00908601f, 0.02947722f, -0.11978120f, -0.14393488f, 0.20348121f, 0.17982818f, 0.06463732f, 0.00809524f, 
    0.03214522f, 0.03935373f, 0.01963959f, 0.04327100f, -0.19313349f, -0.16171952f, -0.12981878f, 0.16003038f, 
    0.06463725f, 0.06616091f, -0.10793783f, 0.01578057f, -0.01148251f, -0.18103297f, -0.11698338f, -0.27518556f, 
    -0.20974700f, -0.11089272f, -0.09399804f, -0.03893076f, 0.28307813f, -0.02933105f, 0.07352278f, 0.03695666f, 
    0.00775032f, 0.05831030f, 0.04948191f, 0.16327384f, 0.01346217f, 0.06869472f, -0.26658377f, -0.31679317f, 
    0.07699984f, 0.02383811f, -0.05225701f, 0.27931410f, -0.05650647f, 0.03428416f, 0.01573586f, -0.19713581f, 
    0.58586073f, -0.05041406f, -0.05170974f, 0.16822171f, 0.12909825f, -0.08120877f, 0.12217575f, 0.26494607f, 
    0.14241593f, 0.01487798f, 0.05018644f, 0.04255680f, -0.00010428f, -0.01935083f, -0.06223924f, -0.16830188f, 
    0.08572587f, -0.01343979f, 0.01101097f, -0.00736194f, -0.02697190f, 0.02373187f, 0.17550460f, -0.02249907f, 
    0.24652873f, 0.13093638f, -0.21846651f, -0.14300047f, -0.10725407f, 0.08359405f, 0.07057353f, -0.07497177f, 
    0.06193766f, -0.00925464f, 0.00953002f, 0.22918811f, -0.06612184f, -0.25748667f, 0.22707589f, 0.00240475f, 
    0.10261944f, -0.01213302f, -0.15330538f, 0.18085164f, -0.03192607f, -0.10406034f, 0.16694391f, 0.08280142f, 
    -0.24020641f, -0.16456816f, -0.09636376f, -0.16022345f, -0.06909580f, 0.14382957f, 0.13895066f, 0.02787436f, 
    -0.03734259f, -0.00653063f, -0.06672724f, -0.06331302f, -0.07024311f, 0.08800010f, -0.09819988f, 0.08125968f, 
    -0.09807274f, -0.12559842f, 0.01423609f, -0.03913574f, 0.04371141f, -0.01430489f, 0.00733119f, 0.14813462f, 
    -0.29803106f, 0.01675419f, -0.19358775f, 0.08409782f, -0.10447950f, -0.01478622f, 0.09141509f, 0.09918942f, 
    0.05580364f, 0.01663429f, 0.10325471f, 0.10709639f, -0.06929304f, -0.25256109f, -0.08935209f, -0.00713841f, 
    -0.04957606f, 0.03089544f, 0.04142729f, -0.16918002f, -0.15170595f, -0.07031208f, -0.03921997f, -0.16866232f, 
    0.27225211f, -0.18526186f, -0.05123620f, 0.21226047f, 0.04410705f, -0.01738403f, 0.05078147f, 0.11249349f, 
    0.09078850f, -0.02574836f, -0.20144662f, 0.27332374f, 0.22496416f, -0.16091414f, -0.25243974f, 0.07298078f, 
    -0.02396574f, -0.04639931f, 0.02753338f, 0.01581188f, -0.21086326f, -0.07903864f, -0.18466081f, -0.22064769f, 
    -0.02779752f, 0.00924303f, 0.01729668f, -0.07697332f, 0.04141840f, 0.16605528f, 0.05550170f, 0.04165332f, 
    -0.12762132f, -0.06763934f, -0.05569572f, 0.01728885f, 0.22790298f, 0.24111742f, 0.11321490f, 0.16735445f, 
    0.10003524f, 0.13180135f, 0.13506259f, 0.02454250f, -0.03586326f, 0.03922345f, 0.08075144f, -0.09432915f, 
    -0.01530526f, -0.02082500f, -0.14058909f, -0.29488814f, 0.02126163f, 0.03045407f, 0.05399907f, -0.15034105f, 
    0.10731872f, -0.01991918f, 0.07545825f, 0.04386034f, 0.04746867f, -0.03464314f, -0.00946586f, 0.01238173f, 
    0.05542139f, 0.00330434f, 0.15963389f, 0.07892265f, -0.10951179f, 0.00598205f, 0.13319257f, 0.13479504f, 
    0.00117504f, -0.18128304f, -0.18290967f, 0.04424128f, 0.05121771f, -0.05812054f, 0.08433041f, 0.16787489f, 
    0.17255831f, -0.11639626f, -0.03241118f, -0.06426065f, -0.23207730f, 0.16091628f, 0.50068825f, -0.23083156f, 
    0.03441932f, 0.24376164f, 0.14303739f, 0.05176038f, 0.06944481f, 0.08506692f, 0.16596308f, -0.01440141f, 
    0.15618448f, 0.00348664f, -0.16146792f, -0.14086834f, 0.08302052f, 0.17668553f, 0.06365508f, 0.22207563f, 
    0.20853962f, -0.11579650f, 0.12923166f, 0.14119102f, -0.26385653f, -0.08356887f, 0.03686740f, 0.28809360f, 
    -0.01431867f, -0.06407645f, 0.14037599f, -0.00235506f, 0.11243926f, 0.14886147f, 0.11130731f, 0.25388667f, 
    0.01946097f, -0.16828360f, 0.02796878f, -0.15401864f, 0.11402344f, 0.06952972f, -0.09346507f, 0.00117152f, 
    0.08730713f, -0.04764164f, 0.13694637f, 0.07742094f, 0.48960131f, -0.14054351f, -0.02188039f, 0.48388660f, 
    -0.13437776f, 0.04196838f, 0.11557427f, 0.00802332f, -0.00267207f, -0.07185425f, 0.18338493f, 0.03154475f, 
    -0.23819356f, 0.16494320f, -0.04574378f, -0.06291106f, -0.14008699f, 0.06906544f, 0.00218721f, 0.17129639f, 
    -0.08339272f, -0.14820054f, 0.19207002f, -0.39737517f, 0.14938138f, 0.05164226f, -0.02861018f, 0.01414134f, 
    -0.00394132f, 0.07178687f, -0.03061906f, -0.00634452f, -0.05059549f, -0.09832861f, -0.01045260f, -0.01698943f, 
    0.12380917f, -0.10878906f, 0.07390551f, 0.08999943f, 0.05528026f, 0.03996516f, 0.04046058f, 0.04315345f, 
    -0.03624129f, -0.00621312f, -0.08229221f, 0.01039494f, -0.00169356f, -0.01186581f, -0.26535493f, -0.34038797f, 
    -0.01135667f, 0.03698318f, 0.08167162f, 0.00061930f, -0.07235728f, -0.04783873f, -0.02604140f, -0.03737447f, 
    -0.56893522f, 0.11439865f, -0.17342076f, 0.18046631f, -0.04242932f, -0.00141646f, 0.14304528f, 0.10368283f, 
    0.15181997f, 0.03658154f, -0.00945056f, -0.03900552f, -0.20177664f, -0.13261636f, -0.20038472f, 0.10296499f, 
    0.09383143f, 0.06460126f, 0.04211979f, -0.01688416f, 0.19315338f, 0.14923745f, -0.12956801f, 0.07825638f, 
    0.18755889f, 0.18146113f, 0.01430931f, 0.08281854f, 0.12819152f, 0.11979198f, 0.17070805f, 0.11931525f, 
    -0.11688963f, -0.00552866f, 0.07882892f, 0.01666147f, -0.31833744f, -0.17309862f, -0.03329779f, -0.16972347f, 
    0.11113510f, 0.16540085f, 0.05801863f, 0.10785328f, -0.01278779f, 0.02597988f, 0.01802420f, -0.10778953f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00129471f, 0.12203770f, -0.00544294f, -0.06199292f, -0.00957640f, 0.17188571f, 0.06743358f, -0.00034948f, 
    -0.03459718f, -0.02073143f, 0.01865415f, -0.00357753f, 0.06060322f, -0.00874678f, -0.00747170f, -0.00745727f, 
    -0.03851966f, -0.10558729f, 0.01130458f, 0.01096867f, 0.01710390f, -0.08147690f, -0.03574422f, -0.00762498f, 
    -0.03943286f, 0.07252250f, 0.16402705f, 0.01742379f, 0.10422582f, 0.08964092f, -0.03555835f, 0.04381624f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13346718f, -0.60553157f, -0.10849891f, -0.11094636f, -0.05332666f, -0.34125552f, 0.24445336f, 0.13798553f, 
    -0.05040805f, -0.05807548f, -0.02530082f, 0.13409182f, 0.13686997f, 0.14542474f, -0.16899411f, -0.02642165f, 
    0.02017547f, 0.13361073f, 0.29414022f, -0.11037488f, 0.05370535f, 0.18579003f, 0.03837410f, 0.08373547f, 
    0.16676314f, -0.20322621f, -0.54560363f, 0.08274502f, 0.26793396f, -0.09835999f, 0.13007690f, 0.04679054f, 
    0.09563684f, -0.22605543f, -0.04680856f, -0.18125694f, -0.09664724f, 0.42105824f, 0.20992316f, -0.09921087f, 
    0.07869176f, -0.14113125f, -0.16745384f, -0.16378646f, 0.16439809f, -0.03063038f, -0.09514090f, -0.72995621f, 
    -0.10967050f, -0.66302037f, 0.05403158f, -0.00850102f, 0.01910158f, 0.39464217f, 0.05020421f, -0.14267437f, 
    0.03902972f, 0.01875004f, 0.12464750f, 0.07792473f, 0.08098868f, 0.27626532f, -0.15126559f, -0.20082231f, 
    0.17647646f, 0.09500482f, 0.04665564f, -0.12489760f, -0.06491344f, 0.20996615f, 0.14923646f, 0.02980357f, 
    -0.14478850f, -0.15265818f, -0.01843878f, -0.09154735f, -0.18999714f, 0.00031458f, 0.12697051f, 0.10702067f, 
    -0.05286506f, -0.41938865f, 0.28856024f, -0.06242834f, -0.01766056f, -0.75808245f, -0.07682934f, 0.09342854f, 
    0.18281780f, 0.37907794f, -0.17812827f, 0.07366856f, 0.16821799f, 0.19553356f, 0.07914036f, -0.54529899f, 
    -0.10836264f, -0.22920403f, 0.12663218f, 0.08918589f, -0.16806780f, -0.28400761f, 0.18110274f, -0.14272457f, 
    -0.10951158f, -0.11423396f, -0.00944216f, -0.15425809f, 0.00688471f, -0.13513854f, -0.04362812f, 0.36007443f, 
    0.01966048f, 0.39817163f, -0.03483239f, -0.15508629f, -0.01450274f, 0.10912721f, -0.02589842f, 0.16000053f, 
    0.13906167f, 0.27924854f, -0.03759733f, -0.03408028f, -0.28752095f, 0.15279345f, -0.07257752f, -0.59583157f, 
    -0.06700947f, 0.00495310f, 0.00398754f, 0.08499437f, -0.13729036f, -0.21093829f, -0.30951697f, -0.12880747f, 
    -0.15424651f, -0.01896901f, 0.23936304f, -0.01236898f, -0.21382193f, 0.09689181f, -0.05637881f, -0.14892910f, 
    0.00834305f, 0.23462214f, 0.27075660f, 0.03723095f, -0.12470371f, -0.11629245f, 0.13573012f, 0.10569347f, 
    -0.07089551f, 0.04622520f, -0.20900199f, -0.17270640f, 0.20600820f, -0.09415998f, 0.16512324f, -0.40827501f, 
    -0.13303156f, 0.16734879f, 0.12199236f, 0.11780500f, 0.16907679f, -0.55476612f, -0.24282949f, -0.03542700f, 
    0.09935015f, 0.12819730f, -0.19773874f, -0.17067941f, 0.35464519f, 0.16496474f, 0.11057749f, -0.39073229f, 
    -0.13098590f, -0.15385428f, -0.06052494f, -0.17041312f, 0.05588694f, 0.16389784f, -0.05827843f, 0.05989071f, 
    -0.06289759f, 0.05582445f, -0.14429367f, -0.09633352f, 0.23401964f, 0.04782913f, 0.10464571f, 0.22797091f, 
    0.11839823f, 0.35633582f, -0.06185669f, -0.04957676f, -0.05354293f, -0.12693320f, -0.03701950f, 0.16002074f, 
    -0.11082975f, -0.07093424f, -0.11470688f, 0.02486670f, -0.64776838f, 0.12994379f, 0.09884702f, 0.36526075f, 
    0.02909006f, -0.49605474f, -0.28969547f, 0.10834129f, 0.03921374f, -0.22561042f, -0.07232680f, 0.04997233f, 
    0.15175933f, -0.30715996f, 0.15864037f, 0.02675881f, -0.61956382f, -0.53111565f, 0.12772733f, 0.24332060f, 
    -0.12970990f, 0.03105398f, 0.07160531f, -0.01245256f, 0.02163677f, 0.14662276f, -0.62986529f, -0.14434668f, 
    0.01189770f, -0.14102733f, -0.50002033f, 0.01451697f, 0.42711389f, 0.14938153f, -0.05039615f, 0.29489863f, 
    -0.12371760f, 0.49890098f, 0.27014557f, 0.08545818f, 0.08896545f, -0.37278795f, 0.14635719f, 0.12183220f, 
    0.10670700f, -0.17022452f, -0.15827546f, 0.02178932f, -0.26704171f, -0.43280667f, -0.12809424f, -0.45700249f, 
    -0.12687555f, -0.15317380f, 0.14762552f, 0.05563316f, 0.05384306f, -0.02840074f, 0.19907258f, 0.14716269f, 
    -0.00261264f, -0.12695475f, -0.35811225f, 0.11828802f, 0.35411954f, 0.07192731f, -0.01511574f, 0.44721612f, 
    0.13018459f, -0.13238801f, -0.50594980f, -0.11489267f, -0.13490240f, -0.27101490f, -0.07032156f, -0.12543565f, 
    -0.08264253f, 0.03996234f, -0.21506064f, -0.10630808f, -0.50474262f, 0.26802766f, -0.13394278f, 0.31100562f, 
    -0.05435542f, 0.02865121f, -0.14484127f, -0.02510872f, 0.10049386f, -0.12907076f, -0.17992973f, 0.10092196f, 
    -0.05426516f, 0.03937409f, 0.31500530f, -0.05646531f, -0.06952202f, -0.13640642f, 0.08697362f, 0.03291583f, 
    -0.05115797f, -0.38079995f, 0.56649750f, 0.05275616f, -0.13629130f, -0.15045081f, 0.02209094f, -0.13595235f, 
    -0.09743329f, -0.65577370f, 0.07177666f, 0.07185014f, -0.07159651f, -0.60069060f, 0.06003166f, -0.37969127f, 
    0.11905351f, 0.04951067f, -0.02569340f, 0.13628960f, -0.13809721f, 0.02518563f, 0.46716902f, 0.09913026f, 
    0.11158919f, -0.14625418f, 0.13719423f, -0.08209681f, -0.26380122f, 0.13826086f, 0.04985421f, -0.38015717f, 
    0.03323209f, 0.05920113f, -0.79908901f, -0.08314230f, 0.09765617f, -0.06979861f, 0.08312809f, -0.17183472f, 
    0.07628381f, 0.29775548f, -0.06114148f, -0.09488910f, -0.05395798f, -0.24789125f, -0.12849280f, 0.09643671f, 
    -0.08372781f, 0.05389022f, -0.16374943f, -0.02373064f, 0.12277950f, -0.14458326f, 0.06551202f, 0.10810772f, 
    0.14470270f, -0.10921844f, -0.29476583f, 0.08721859f, -0.49926332f, -0.09503278f, -0.04983411f, -0.16372187f, 
    -0.06307079f, 0.62245160f, -0.34971949f, 0.09383211f, -0.04678764f, 0.00724845f, -0.10334817f, -0.18033956f, 
    0.03840507f, -0.48365486f, 0.29893950f, -0.09193549f, -0.11959904f, 0.20617808f, -0.09320161f, 0.17869876f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.41825241f, 0.30170467f, 0.32853445f, -0.70603174f, 0.13985467f, 0.24987426f, 0.15854573f, -0.07704195f, 
    -0.64126021f, -0.17014953f, -0.77390754f, -0.67477089f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
