#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.18173803f, 0.28445375f, 0.34835082f, -0.28106937f, 0.45511639f, -0.34118214f, -0.61149204f, 0.48331454f, 
    -0.56739163f, 0.01471182f, -0.46023411f, -0.67305940f, -0.32684350f, 0.80008823f, -0.47455770f, 0.19413097f, 
    -0.35700554f, -0.33037859f, 0.66295797f, 0.30935633f, 0.59638560f, 0.20850433f, -0.14897525f, -0.44002968f, 
    -0.40743047f, -0.01421633f, 0.36997315f, -0.13250326f, 0.17218669f, 0.62433219f, 0.42258748f, -0.98256671f, 
    -0.32397786f, -0.12866424f, -0.11808389f, 0.03833641f, 0.17941269f, 0.85650122f, -0.61635381f, -0.46946532f, 
    -0.05577191f, -0.01268729f, -0.07892923f, 0.43221813f, 0.07975829f, 0.42561054f, 0.50276780f, -0.34180054f, 
    -0.37026104f, -0.17944252f, 0.57824641f, -0.53768444f, 0.21360868f, 0.39854676f, -0.02873375f, 0.55345756f, 
    0.06044994f, 0.50164473f, 0.23533463f, 0.01206132f, 0.10669816f, 0.53820497f, 0.18016233f, 0.48012370f, 
    0.01017854f, 0.07406557f, -0.27505720f, -0.17396511f, 0.68518639f, 0.73395139f, -0.58202809f, -0.38368788f, 
    0.13902749f, 0.56027174f, 0.60014910f, -0.49797034f, 0.83091867f, -0.09878730f, 0.18664894f, -0.18338320f, 
    -0.25062612f, -0.22525033f, -0.34123009f, 0.25669366f, 0.24966753f, -0.31574732f, -0.66915286f, 0.09670147f, 
    0.41681278f, 0.55073172f, 0.26340255f, 0.65804982f, -0.52905774f, 0.07888835f, -0.16480953f, -0.36063263f, 
    0.09068150f, 0.22556007f, 0.24242447f, -0.09299453f, -0.46463698f, -0.51654625f, -0.57130933f, -0.61558861f, 
    -0.23782413f, -0.04131407f, -0.37800419f, -0.22131954f, -0.29321697f, -0.66271549f, 0.07204401f, -0.13373633f, 
    -0.11828419f, -0.55326813f, -0.51529366f, -0.29531139f, -0.22965445f, 0.72153217f, 0.41532865f, 0.40994632f, 
    0.15829158f, 0.40720612f, 0.04347366f, 0.49337980f, -0.03966110f, 0.38018528f, 0.73379260f, 0.29340783f, 
    0.40694934f, -0.31457064f, -0.50052381f, -0.32012737f, 0.37311521f, 0.34631532f, 0.08014496f, -0.45810542f, 
    0.77306491f, -0.57981098f, -0.45916718f, -0.04500229f, 0.15496910f, 0.32656345f, -0.24644203f, 0.48474807f, 
    -0.06126854f, -0.32566887f, 0.37199944f, -0.28962010f, -0.36105606f, 0.12858200f, -0.46038130f, 0.53027594f, 
    0.54405177f, -0.70247614f, 0.04067677f, 0.85058010f, 0.25798008f, -0.09992911f, 0.09682314f, -0.28290704f, 
    -0.33156440f, -0.32082021f, -0.41876045f, 0.05996912f, 0.53451771f, -0.70187116f, 0.50250256f, -0.31290129f, 
    0.54786468f, 0.25181094f, 0.20122798f, -0.30251884f, -0.65748620f, -0.25893417f, 0.66080278f, 0.48795810f, 
    0.26879048f, -0.27089164f, -0.24155502f, -0.21229187f, -0.58457863f, -0.16912234f, 0.55343145f, 0.51728141f, 
    0.50838083f, 0.49126074f, -0.01561861f, 0.23100771f, 0.19708078f, 0.45926398f, -0.16402163f, 0.15570228f, 
    0.47077441f, 0.02813047f, 0.92282444f, -0.42362297f, -0.18014547f, -0.49353874f, 0.04053434f, -0.14810020f, 
    -0.06401744f, -0.27102792f, 0.50466764f, 0.92350388f, 0.28427005f, 0.40678838f, 0.38957080f, -0.35548827f, 
    0.37564403f, 0.23225158f, 0.54644889f, 0.10819037f, -0.24822868f, 0.20991309f, -0.64168000f, -0.54087412f, 
    0.28851715f, 0.66882640f, -0.77342862f, 0.21189545f, 0.62994665f, -0.42827430f, 0.22456147f, -0.16183610f, 
    0.20624329f, -0.40888563f, 0.35243610f, -0.16885297f, -0.35806152f, -0.14405635f, -0.60767013f, 0.47262526f, 
    0.39212999f, -0.01449921f, 1.01193666f, -0.19482519f, -0.40787014f, 0.25900644f, -0.02328059f, 0.55719113f, 
    0.01851939f, -0.05666405f, 0.10271847f, 0.81651860f, -0.61456060f, -0.26550430f, -0.05622603f, -0.44431487f, 
    -0.17610356f, 0.33828622f, 0.50903469f, 0.38414416f, -0.20558713f, -0.61680543f, -0.84785312f, 0.18205097f, 
    0.36557811f, 0.64475143f, 0.02878379f, 0.30387318f, 0.31983593f, -0.50528336f, 0.79094487f, -0.74264795f, 
    -0.62261391f, -0.21950465f, 0.57399505f, -0.54181284f, -0.05958401f, -0.17180280f, 0.42759553f, 0.47822610f, 
    0.20644696f, -0.57290769f, -0.47082034f, -0.58279413f, -0.06152809f, -0.48446217f, -0.29959360f, -0.34749907f, 
    -0.52267379f, -0.54416656f, 0.39340600f, 0.51161247f, -0.67107975f, 0.51023209f, 0.08524375f, 0.00391887f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03673841f, -0.17194998f, -0.16862567f, -0.22251783f, -0.04250199f, 0.37718093f, 0.18620896f, 0.20822509f, 
    0.08255878f, 0.08291309f, 0.31600437f, -0.27605814f, -0.03189686f, 0.19640601f, 0.12409626f, -0.21040894f, 
    0.05761488f, 0.00125726f, -0.04199561f, -0.05176776f, -0.36631256f, -0.13778299f, -0.17783350f, 0.27834752f, 
    -0.03260001f, 0.18182594f, -0.03442590f, -0.12307246f, -0.00312886f, 0.22800371f, 0.29062423f, 0.10657504f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05581762f, 0.14820848f, 0.01915086f, 0.07760344f, 0.07204031f, -0.16138761f, 0.05698829f, -0.01446444f, 
    0.02384032f, -0.17314246f, -0.07490079f, -0.53591645f, -0.01398016f, 0.20694953f, -0.01253442f, -0.09043323f, 
    -0.22266577f, -0.04039026f, 0.41459525f, 0.22583999f, -0.00473686f, -0.03518920f, -0.10730749f, 0.15631586f, 
    0.09345377f, 0.02068052f, 0.01113250f, 0.29830772f, 0.44820899f, -0.21870846f, 0.00660204f, -0.26360279f, 
    -0.14029466f, 0.12598623f, 0.03065352f, -0.07028831f, -0.02776113f, -0.47843879f, -0.11497802f, -0.02100731f, 
    0.14412992f, -0.29620335f, 0.03116274f, 0.01083944f, -0.09003094f, 0.19889075f, -0.04999153f, 0.20330957f, 
    0.02885283f, 0.20840669f, 0.12006453f, 0.15971246f, -0.00414244f, 0.04852415f, 0.11587606f, 0.24648474f, 
    0.10017228f, -0.12353829f, 0.14580481f, 0.08173147f, 0.11570533f, 0.05068493f, -0.07073154f, -0.08284026f, 
    0.25731447f, 0.06990807f, -0.06375793f, 0.17275871f, 0.00927404f, -0.06859776f, 0.03269367f, 0.11299487f, 
    0.14409123f, 0.27374780f, 0.13774902f, -0.09730505f, 0.09060447f, 0.02501032f, 0.00513703f, 0.13918659f, 
    0.04915998f, -0.17913131f, 0.12947208f, -0.25360247f, -0.06688324f, -0.01588798f, 0.08539925f, 0.11863903f, 
    -0.03844664f, -0.03529695f, -0.10081729f, -0.00073921f, -0.11202713f, -0.00406988f, 0.15716361f, 0.12337551f, 
    0.12727627f, 0.07656810f, 0.14107268f, -0.01137307f, -0.40736318f, -0.06573464f, -0.32755181f, 0.01134356f, 
    0.08411671f, -0.04930310f, -0.16591300f, 0.01112476f, 0.26684618f, 0.10779008f, -0.40985247f, -0.06995268f, 
    -0.10176168f, 0.09739517f, 0.11551514f, -0.00433962f, 0.15847577f, 0.18787855f, 0.26703483f, 0.16824491f, 
    -0.07605733f, -0.00355436f, 0.06324385f, 0.06401606f, 0.07001354f, -0.00329163f, 0.27411404f, 0.22769962f, 
    0.18329115f, -0.06367081f, -0.18467093f, 0.01295371f, -0.01313680f, 0.03435576f, 0.06425731f, -0.12122264f, 
    -0.64301980f, -0.49219292f, -0.05266432f, 0.21319929f, -0.32467672f, 0.10139988f, -0.00108601f, -0.12594168f, 
    0.14885716f, 0.06413098f, 0.03513809f, 0.06784849f, -0.08791186f, -0.12003372f, 0.15177168f, -0.12063861f, 
    0.02151778f, -0.04365532f, -0.03523789f, -0.09853721f, 0.07725947f, -0.05620708f, 0.14243291f, 0.07886299f, 
    0.14965609f, 0.09276441f, -0.23073828f, -0.17858569f, -0.03481070f, 0.01254961f, 0.04627704f, 0.00742133f, 
    0.11486561f, 0.04327859f, -0.25991645f, -0.44077188f, -0.84582734f, -0.67330950f, -0.17159396f, -0.06256925f, 
    -0.01367081f, -0.10866379f, -0.08447717f, 0.03623274f, 0.18373883f, -0.11148032f, -0.21813984f, -0.18255658f, 
    -0.01654906f, 0.01054019f, -0.04519018f, -0.22736441f, 0.00559497f, -0.14177583f, -0.08735619f, 0.05876977f, 
    -0.10529686f, -0.00857695f, 0.00178483f, -0.10496507f, -0.06705755f, 0.10661703f, 0.04057476f, -0.20779282f, 
    -0.12354366f, -0.03536836f, 0.10735417f, -0.07232973f, 0.15423945f, -0.20165327f, -0.03665021f, 0.02476958f, 
    0.16795743f, -0.15717389f, -0.04121179f, 0.07680063f, 0.01787735f, 0.02271112f, 0.19322824f, 0.27580085f, 
    -0.25026354f, 0.29916066f, -0.06836570f, -0.10568452f, 0.24497277f, 0.02303009f, 0.10197648f, -0.06984823f, 
    -0.15135829f, -0.29816508f, -0.27862310f, -0.21401766f, 0.00947061f, -0.08578477f, -0.14350085f, 0.05204604f, 
    -0.07263778f, 0.02943956f, -0.06377254f, 0.03321564f, 0.04200425f, -0.04856145f, 0.17540395f, -0.04716450f, 
    0.13098165f, 0.12809782f, -0.09891173f, -0.21376520f, -0.06264407f, -0.25297338f, -0.11345463f, 0.05494034f, 
    -0.32288590f, 0.03911722f, 0.07931633f, 0.00844326f, -0.21310507f, -0.70380867f, -0.39039293f, -0.04957861f, 
    0.09337224f, -0.09193405f, 0.00704917f, -0.01250398f, -0.08956490f, -0.11382189f, -0.66950917f, 0.06440934f, 
    0.09586788f, 0.12421925f, -0.03137285f, 0.09375230f, -0.01555767f, -0.09975974f, 0.27873707f, 0.31345904f, 
    0.25975749f, -0.08963808f, 0.00815173f, 0.01135295f, -0.01905439f, -0.01833940f, 0.09867842f, -0.32324359f, 
    0.00802105f, -0.22094913f, -0.12498761f, 0.27065924f, 0.13586983f, 0.08253765f, 0.04803728f, 0.04563754f, 
    0.03044002f, -0.21982148f, 0.04307828f, 0.06396253f, -0.03846068f, -0.05625655f, -0.08973639f, -0.07642283f, 
    -0.18202141f, -0.09038447f, 0.20400679f, -0.02003274f, -0.02535092f, -0.05140896f, 0.10098459f, -0.17826249f, 
    0.08991411f, -0.27936205f, -0.13391986f, 0.06138142f, 0.13555577f, 0.13487406f, 0.04513007f, -0.01835444f, 
    -0.16511767f, -0.03303752f, 0.07522342f, 0.29915136f, -0.16768202f, 0.18358278f, 0.10673849f, 0.10155720f, 
    -0.18796720f, 0.00031376f, -0.04259735f, -0.11149622f, 0.21283218f, 0.16917396f, -0.14482549f, 0.12380692f, 
    0.07711097f, 0.09267763f, 0.16152479f, -0.04906204f, 0.02609830f, 0.21741912f, 0.08160266f, 0.04658682f, 
    0.11688703f, 0.02794551f, 0.02439033f, 0.01873923f, -0.07339347f, 0.06121784f, 0.06340767f, 0.09198716f, 
    0.00202788f, 0.22884017f, 0.00219032f, -0.04570319f, 0.03328962f, -0.02888027f, 0.11746672f, -0.10499560f, 
    0.15690111f, -0.05031948f, 0.01842781f, 0.00535554f, -0.05809934f, -0.09438516f, 0.17240511f, -0.10307309f, 
    0.01436147f, -0.19131167f, 0.01780272f, 0.04394763f, 0.12146421f, -0.11737303f, -0.11792852f, -0.06569454f, 
    -0.00929710f, 0.20322345f, 0.08209696f, -0.07083506f, 0.00777749f, -0.03368145f, -0.00782397f, 0.17955403f, 
    0.16226946f, 0.15825325f, 0.01368451f, 0.10160869f, 0.00147495f, 0.08759236f, 0.09005928f, 0.05254118f, 
    0.14085071f, 0.12204684f, 0.04192166f, -0.03045156f, -0.02877245f, -0.06803528f, 0.03705287f, -0.07132916f, 
    -0.03689550f, 0.13625887f, 0.17945530f, -0.12585792f, 0.11332867f, -0.12709381f, -0.04507352f, -0.00382711f, 
    0.00134972f, -0.06926695f, -0.00556393f, -0.13598779f, -0.25775996f, -0.01789603f, 0.06658412f, -0.03129206f, 
    0.15945835f, 0.17649654f, 0.01079111f, 0.07615989f, 0.05290542f, 0.15848272f, 0.01738020f, 0.04496948f, 
    0.04751938f, 0.19268394f, 0.16875891f, 0.08051106f, 0.14335203f, 0.03804290f, 0.14795378f, 0.13420245f, 
    0.20448799f, 0.01119243f, 0.01112654f, 0.09335024f, 0.01538824f, 0.13082378f, 0.14255235f, -0.14753301f, 
    0.12257028f, -0.18746874f, -0.10774784f, 0.12152549f, 0.12817588f, 0.02026044f, 0.11678991f, 0.04126267f, 
    0.03333545f, 0.14844038f, 0.15692668f, 0.18079793f, -0.15841976f, 0.02852156f, -0.13227732f, 0.02859057f, 
    -0.03982216f, -0.26742235f, 0.24333642f, 0.01299106f, -0.15783632f, 0.07731760f, -0.15740483f, -0.01764400f, 
    -0.05964172f, 0.00331296f, 0.26414698f, 0.03089850f, -0.12047732f, -0.00387278f, 0.02173245f, -0.03545377f, 
    0.00539289f, -0.02607196f, -0.34686318f, -0.23258437f, 0.01602175f, -0.07376849f, -0.12556161f, 0.18742484f, 
    0.03747072f, 0.07228652f, -0.20503476f, 0.13652386f, -0.06190265f, -0.09673446f, -0.10902169f, -0.12109239f, 
    0.09480056f, -0.12781355f, 0.03657960f, 0.00032979f, 0.01529816f, -0.10488255f, 0.05071279f, 0.05553392f, 
    0.05281559f, 0.15891232f, 0.07332314f, 0.06247696f, -0.02643594f, 0.04826402f, 0.21388207f, -0.04508914f, 
    -0.10497037f, 0.10372834f, 0.03997288f, 0.07562600f, 0.07807542f, -0.17015050f, -0.10842087f, -0.10087504f, 
    0.00652254f, 0.00454025f, -0.20292974f, 0.09071484f, 0.03884264f, -0.09032855f, 0.17790522f, 0.05085070f, 
    -0.02132902f, 0.01453258f, 0.06974170f, 0.08662761f, -0.07130910f, -0.24164402f, 0.16967204f, 0.26433706f, 
    0.02907896f, 0.01261458f, -0.10685407f, 0.05425115f, 0.10309732f, 0.08217561f, 0.04943336f, -0.04719938f, 
    -0.01696880f, 0.12786315f, -0.00626664f, 0.09098152f, -0.21648861f, 0.02719590f, -0.26115695f, 0.17187014f, 
    -0.09179570f, 0.39474881f, -0.01618767f, 0.25894704f, -0.10768412f, 0.09427984f, 0.24043246f, 0.12174973f, 
    -0.09797543f, -0.04467757f, -0.06237245f, -0.07222252f, 0.01094443f, 0.32320845f, 0.13748233f, 0.05922728f, 
    0.06071730f, 0.09610061f, -0.14477661f, -0.03979895f, -0.12165658f, -0.06467722f, -0.11090595f, 0.01858082f, 
    0.05240829f, -0.06033639f, 0.06096495f, -0.02741277f, 0.05191867f, -0.09136990f, -0.09763023f, -0.01721377f, 
    -0.01590656f, 0.27122793f, 0.02702628f, 0.01041347f, -0.01685772f, -0.25426045f, -0.00145372f, 0.00468158f, 
    0.02603671f, -0.05792649f, 0.03469772f, 0.03902232f, -0.02430434f, 0.02331895f, 0.04126724f, -0.05000390f, 
    -0.00389514f, -0.00344513f, -0.06486290f, -0.05595003f, 0.02636599f, 0.00544132f, 0.05206314f, -0.04037351f, 
    -0.02454970f, -0.03299710f, -0.03423811f, 0.00812655f, -0.00854834f, 0.02750687f, 0.03826365f, -0.06412149f, 
    -0.01959204f, -0.01226129f, 0.04175783f, 0.01599377f, -0.00539662f, -0.01439214f, 0.04024002f, 0.01403365f, 
    -0.03350076f, 0.04067555f, 0.03483728f, 0.03921299f, -0.03421001f, 0.03143534f, 0.03711877f, -0.02097114f, 
    -0.04483087f, 0.04781503f, -0.03777152f, 0.01239823f, -0.06733681f, 0.00004341f, 0.03092423f, 0.00669695f, 
    -0.03424954f, 0.03338493f, -0.01610061f, 0.02291573f, 0.03784151f, -0.00418408f, -0.06495004f, 0.02051855f, 
    -0.05179019f, -0.05231655f, -0.05887540f, -0.02776881f, -0.02328420f, -0.00890340f, 0.03649108f, 0.00600260f, 
    -0.06882987f, -0.01250669f, -0.01973366f, -0.00805554f, -0.04961258f, -0.01359472f, -0.02240048f, -0.03204966f, 
    0.02383125f, 0.03538889f, -0.04920901f, -0.02422715f, -0.02336693f, 0.00359501f, -0.05152043f, 0.03201600f, 
    -0.00836591f, -0.03020103f, -0.05058482f, 0.01168196f, -0.05575069f, -0.02614285f, 0.00131961f, 0.02765008f, 
    -0.05245725f, -0.05733873f, -0.01071015f, 0.02895495f, 0.02114557f, 0.01565877f, 0.02662157f, 0.01702351f, 
    -0.00496732f, 0.01553683f, -0.05704471f, -0.02806135f, -0.01034781f, -0.02919187f, -0.04136799f, -0.00712575f, 
    -0.00677009f, -0.04222413f, -0.04523839f, -0.00335487f, 0.01818025f, -0.01072217f, -0.01264206f, -0.02304798f, 
    -0.04867592f, -0.02090008f, 0.03005912f, 0.01499380f, -0.04944558f, -0.00051949f, -0.01302180f, -0.05160378f, 
    -0.03588003f, -0.01363031f, -0.03938320f, -0.02240610f, -0.01961630f, -0.01450063f, 0.02461544f, 0.00931881f, 
    0.00930705f, -0.02745628f, -0.03951939f, 0.00920689f, -0.00677027f, -0.05815254f, -0.00360088f, 0.03963761f, 
    0.02104968f, 0.02608413f, 0.03944485f, 0.04583578f, -0.05974332f, -0.01625843f, -0.01435304f, 0.02474425f, 
    0.04234195f, -0.02309163f, -0.01222382f, 0.01497490f, -0.04204481f, 0.02725542f, -0.05482344f, 0.04510929f, 
    0.04868166f, 0.02512815f, 0.04282898f, 0.04399869f, 0.04570774f, -0.05591518f, -0.05682134f, 0.03304478f, 
    -0.04198255f, -0.01224452f, 0.03872121f, 0.00950786f, -0.00704522f, -0.06459164f, -0.05198146f, 0.02525009f, 
    0.03084366f, 0.02229590f, -0.00913167f, 0.02049354f, -0.00669164f, 0.02107071f, 0.03894696f, 0.00266506f, 
    -0.04045730f, 0.00827054f, -0.04897020f, 0.03667506f, -0.05088570f, 0.01555214f, 0.04938953f, 0.03131770f, 
    -0.03973209f, 0.00488684f, -0.02604838f, 0.01167388f, 0.01286132f, -0.00456450f, 0.03425732f, 0.02919331f, 
    -0.02930001f, 0.04885334f, -0.04226829f, -0.04230024f, 0.02782844f, 0.01139677f, -0.01679377f, -0.00759107f, 
    0.04210034f, -0.04961501f, -0.00276845f, 0.03227291f, -0.05460607f, -0.03695711f, -0.02026245f, 0.04086479f, 
    -0.04133118f, 0.02194948f, -0.00482060f, -0.06029780f, -0.01852837f, -0.02091265f, -0.03203724f, -0.04446570f, 
    0.02730364f, 0.01791251f, 0.00207885f, -0.02281083f, 0.01039099f, -0.01007171f, -0.01142076f, 0.04834748f, 
    0.01803695f, -0.00202343f, -0.01880440f, -0.03667132f, -0.03696245f, -0.05060205f, 0.04804269f, -0.03383171f, 
    -0.04765401f, -0.00426344f, 0.03547199f, 0.00229498f, -0.05365337f, -0.00622811f, 0.02217907f, -0.04238711f, 
    -0.04782071f, -0.04275518f, 0.02556743f, -0.03490195f, 0.00977342f, -0.01109791f, 0.02312095f, 0.03692461f, 
    -0.00049529f, -0.00557702f, -0.06100706f, 0.01880351f, -0.01438843f, 0.03266108f, -0.02478891f, -0.02878707f, 
    -0.03929367f, -0.05807677f, 0.04748049f, -0.03432164f, -0.05160691f, -0.04654863f, -0.00469092f, 0.00837485f, 
    0.04912025f, 0.00478002f, 0.03420103f, 0.03136086f, -0.01792447f, -0.03493219f, 0.03022771f, -0.01841318f, 
    0.02313773f, -0.04380662f, -0.03226148f, -0.04566327f, -0.03556152f, -0.01061871f, -0.06731124f, 0.03238335f, 
    0.04958934f, -0.06870324f, -0.02665334f, 0.02830509f, 0.02251367f, 0.02569337f, -0.00189775f, 0.00507586f, 
    -0.19525541f, -0.04574571f, 0.06992564f, -0.09339955f, 0.11760578f, -0.02562214f, -0.05813500f, -0.09764273f, 
    0.00881713f, -0.07994998f, 0.37222537f, 0.57154262f, -0.09892643f, -0.21708274f, -0.00447042f, 0.12168749f, 
    -0.12827125f, 0.00250667f, -0.29129848f, 0.09036359f, -0.12435184f, -0.02116585f, -0.10630396f, 0.07508469f, 
    -0.21298487f, -0.22952285f, -0.10315156f, -0.59303486f, 0.09384609f, -0.01338501f, -0.24657844f, -0.22413209f, 
    -0.18846759f, -0.15453514f, -0.11964638f, -0.31090304f, 0.27122772f, 0.12553042f, -0.02392776f, -0.10050659f, 
    0.17335683f, -0.09817812f, 0.08255387f, -0.07133486f, -0.09834124f, 0.05886769f, -0.08440867f, -0.46552998f, 
    -0.05659707f, -0.12030088f, -0.12181960f, 0.14988609f, 0.18678176f, -0.27257848f, -0.06462029f, -0.03646806f, 
    -0.20798756f, 0.06767039f, -0.04985524f, 0.02018417f, 0.24736950f, 0.14298618f, -0.09303197f, -0.21726064f, 
    -0.03831388f, 0.24625890f, 0.11914629f, -0.29050466f, 0.14400056f, 0.14642605f, 0.12802011f, -0.08244121f, 
    -0.06309087f, 0.27471653f, -0.21190687f, 0.01978156f, -0.02853609f, -0.14786668f, 0.04723195f, -0.09594102f, 
    -0.04432628f, -0.05234640f, 0.09372646f, 0.25770906f, -0.11059042f, 0.02231963f, 0.00047508f, 0.10916514f, 
    0.05626884f, 0.09904586f, 0.13608451f, 0.27971986f, 0.00116910f, 0.20038395f, 0.25044638f, 0.17345202f, 
    0.00226566f, 0.10177536f, -0.05248617f, -0.06780764f, 0.00196039f, 0.57015830f, -0.06263661f, -0.09862296f, 
    0.19188836f, 0.21728539f, -0.05879988f, -0.05739485f, -0.10488759f, 0.28680918f, 0.51980495f, 0.05740388f, 
    0.04176819f, 0.12687491f, 0.34065732f, 0.08971342f, -0.09901147f, -0.00019363f, 0.26984024f, 0.11632470f, 
    0.26061726f, 0.04162584f, 0.25535148f, 0.22187726f, 0.08559296f, 0.12256133f, -0.04668619f, 0.07450967f, 
    -0.20680125f, 0.08010712f, -0.00691234f, 0.18053964f, 0.00828925f, -0.05235767f, -0.17930725f, 0.16078125f, 
    0.17297049f, -0.06870254f, -0.05830929f, -0.09774383f, 0.09517342f, 0.00210912f, -0.04393698f, 0.02622214f, 
    -0.03693125f, -0.06533921f, 0.04792009f, -0.25282845f, 0.07562583f, 0.16963489f, 0.28454420f, -0.13662720f, 
    -0.29599714f, -0.47872692f, -0.24442156f, -0.08041947f, -0.05769783f, 0.07524294f, -0.10775865f, -0.01385616f, 
    -0.23186272f, 0.26058328f, 0.35013944f, -0.14595623f, -0.01796152f, -0.17730413f, -0.06543278f, -0.29033285f, 
    0.16050731f, -0.14150050f, -0.09343279f, -0.34573662f, -0.08666918f, 0.30249521f, -0.00665556f, -0.28423449f, 
    -0.11900259f, 0.01155787f, -0.06761988f, 0.03285812f, -0.07194225f, -0.13150296f, -0.19271567f, -0.21891461f, 
    0.00181389f, -0.11115753f, 0.19488350f, -0.05849295f, -0.15941635f, -0.34169838f, -0.01967969f, -0.00167543f, 
    -0.14718807f, -0.27456412f, -0.24213694f, -0.14725175f, 0.22720765f, -0.00911146f, -0.15017962f, 0.03011252f, 
    0.02807589f, -0.35048369f, -0.24896039f, -0.07646121f, 0.10415143f, 0.02404757f, 0.01302896f, -0.17943075f, 
    -0.18769810f, 0.10902672f, 0.17594743f, 0.10099556f, -0.04132951f, 0.17921129f, -0.08820736f, 0.22149549f, 
    -0.08902189f, 0.07634409f, -0.02961438f, -0.00567269f, 0.10334402f, -0.27837616f, -0.09443392f, 0.23677558f, 
    0.00003078f, 0.31596214f, 0.32840693f, 0.57124346f, 0.02935906f, 0.15575239f, 0.11084486f, 0.06258304f, 
    -0.00071185f, -0.04749046f, -0.39101872f, -0.01178830f, 0.23379369f, 0.00338593f, -0.51241636f, -0.05607026f, 
    -0.04654647f, 0.05627513f, 0.01277670f, -0.07767560f, -0.07049526f, 0.58097601f, -0.03509035f, -0.06972922f, 
    0.17288063f, -0.04548179f, -0.31987152f, -0.09935991f, -0.42734379f, 0.09415507f, 0.38005486f, -0.03850041f, 
    -0.27318925f, -0.19437592f, 0.06387366f, 0.13712719f, 0.19665909f, 0.22460932f, 0.01738649f, 0.11860958f, 
    0.16563435f, 0.11736697f, 0.34766749f, -0.05403045f, 0.08682805f, -0.08206920f, 0.11573111f, 0.15378504f, 
    0.40275550f, 0.16458918f, 0.23888247f, 0.12014829f, 0.11317459f, 0.00033199f, -0.01029292f, 0.01566195f, 
    0.08213435f, 0.64706761f, -0.04289675f, -0.02022934f, -0.12547795f, -0.07026600f, -0.05125943f, 0.09694667f, 
    -0.07658630f, 0.04187181f, -0.06255390f, -0.08001108f, 0.02977569f, -0.14305566f, -0.04108410f, 0.26379469f, 
    -0.31606305f, 0.05986418f, 0.11289271f, 0.11907186f, 0.05927340f, -0.21390660f, -0.06300040f, -0.10529073f, 
    -0.06194784f, -0.05447331f, -0.12607718f, -0.24511595f, 0.08073602f, 0.05461281f, 0.03640553f, 0.07092116f, 
    0.13802893f, -0.08696941f, 0.02277181f, 0.02259002f, -0.23904364f, 0.04545355f, -0.06725490f, 0.20290972f, 
    -0.00368630f, -0.06577063f, 0.08752634f, -0.00230846f, 0.18495747f, -0.00146688f, -0.11322980f, -0.09421797f, 
    0.01244851f, 0.15198569f, -0.01559890f, 0.30859160f, -0.00085212f, -0.01341552f, -0.01968034f, 0.03412723f, 
    -0.03929424f, -0.11327408f, 0.13938552f, 0.08719242f, -0.15279023f, 0.04789839f, -0.08207988f, -0.04496930f, 
    -0.03678429f, 0.00354607f, -0.00068609f, -0.09936164f, -0.08464504f, 0.05880029f, 0.08278625f, -0.05920487f, 
    0.22082283f, 0.06916244f, -0.16025990f, -0.09800068f, -0.11109436f, -0.17379092f, 0.22139116f, -0.04396240f, 
    -0.25549203f, 0.02120593f, -0.09890077f, 0.01076609f, -0.15565749f, 0.16794816f, 0.18567117f, 0.20278084f, 
    -0.20877938f, 0.03971662f, 0.22105706f, 0.08688458f, -0.08181771f, 0.06176695f, -0.05943809f, 0.12945196f, 
    0.16998623f, 0.11730301f, 0.11491308f, -0.02807797f, -0.03142544f, -0.07324710f, 0.08750524f, 0.09769504f, 
    0.01444001f, 0.10713081f, 0.12343822f, 0.16750386f, -0.05430736f, -0.06191029f, -0.03113865f, 0.01993960f, 
    -0.07424626f, -0.00983408f, 0.11142648f, -0.09289687f, 0.13610825f, 0.07430074f, -0.18481635f, 0.03783239f, 
    0.05894161f, 0.09528301f, -0.13902783f, -0.15341532f, -0.03743112f, -0.17161258f, -0.00037272f, -0.11140095f, 
    0.10459369f, -0.08233869f, 0.18496740f, 0.09796406f, -0.00539674f, 0.11659051f, 0.02836690f, -0.09769268f, 
    0.05251975f, 0.05686614f, 0.03773633f, 0.13755393f, -0.14589958f, 0.04506550f, 0.18711053f, -0.23980884f, 
    0.29962999f, 0.12050073f, 0.13507682f, 0.11311578f, 0.04303898f, 0.14045803f, 0.11596893f, -0.18336801f, 
    0.14021645f, 0.03117545f, 0.05875157f, 0.02212079f, 0.06883501f, 0.11595392f, 0.10120641f, 0.06755494f, 
    0.19230433f, -0.55873334f, -0.13003655f, 0.01776719f, -0.01314647f, 0.21115212f, 0.05713621f, -0.15631862f, 
    -0.13923384f, -0.03776219f, 0.11607990f, 0.17077507f, 0.10438918f, 0.15523627f, -0.11416651f, 0.03044559f, 
    -0.32178271f, 0.11941771f, 0.16139042f, -0.11042997f, -0.06325170f, 0.06690971f, 0.13381365f, -0.11671101f, 
    -0.16939218f, -0.00241680f, -0.14763452f, -0.04315046f, 0.09528098f, -0.23223747f, -0.08258448f, 0.09336478f, 
    0.10907607f, -0.03153125f, 0.00001061f, 0.12725131f, 0.04325243f, -0.12262561f, 0.25987408f, 0.01401578f, 
    0.07166089f, -0.02314201f, -0.08197812f, 0.00688765f, -0.13208072f, 0.11893091f, -0.15667516f, 0.09198747f, 
    -0.09360441f, 0.23401543f, 0.00277089f, 0.16946571f, 0.34014115f, -0.12412135f, -0.21108058f, -0.08675896f, 
    -0.10743322f, 0.00540109f, 0.01285332f, -0.24566594f, 0.02645706f, 0.03995147f, 0.00497737f, -0.05387592f, 
    -0.24186967f, 0.14188504f, -0.04564090f, 0.08112410f, 0.00233474f, 0.20707472f, 0.04807360f, -0.06522664f, 
    -0.00872290f, -0.01740286f, 0.13590552f, 0.18719392f, -0.06593778f, -0.10654932f, 0.01020407f, -0.03220778f, 
    0.14641121f, 0.09668960f, -0.14825647f, -0.04854907f, 0.00220804f, 0.08466850f, -0.10725969f, 0.05349787f, 
    -0.13330415f, -0.00732585f, -0.18635124f, 0.00674109f, -0.15894659f, -0.01427475f, 0.03455721f, 0.05607711f, 
    0.15754022f, 0.00767526f, -0.14846514f, 0.26683596f, -0.10802840f, 0.02420669f, -0.05375666f, 0.05637924f, 
    -0.03512719f, -0.02329400f, 0.09846060f, -0.01470846f, -0.09793134f, 0.19439536f, 0.18849583f, -0.01606535f, 
    0.00091043f, 0.10328906f, 0.08526622f, -0.09058753f, -0.13019004f, -0.12045504f, 0.04575539f, -0.04353463f, 
    -0.07255803f, -0.01194501f, 0.09749676f, -0.02965872f, -0.02077585f, -0.12125178f, -0.05202423f, 0.18395381f, 
    0.11541174f, 0.15580782f, 0.00137429f, -0.08463433f, 0.04428157f, -0.09308808f, -0.01959687f, -0.11946353f, 
    0.01161350f, 0.02817894f, 0.01119140f, -0.05712356f, 0.05186734f, 0.01598524f, 0.02472313f, -0.04504371f, 
    0.00859981f, 0.03786344f, 0.04908668f, -0.01323785f, 0.03213502f, -0.00006151f, -0.00345172f, -0.01651492f, 
    -0.03703956f, -0.04151089f, -0.00740086f, -0.05076988f, -0.02161543f, -0.00475501f, -0.01484044f, 0.01702046f, 
    -0.02783109f, 0.00606021f, 0.00602479f, 0.01241080f, -0.02355372f, -0.02302049f, -0.05095215f, 0.04777527f, 
    -0.05911364f, 0.00210288f, -0.01123860f, -0.04773074f, -0.04877681f, 0.05040175f, -0.02350898f, 0.03681380f, 
    0.03512813f, -0.00764521f, -0.06075730f, -0.02818797f, 0.03863860f, 0.02916403f, 0.02328818f, 0.00053553f, 
    0.03589608f, 0.01329743f, -0.01522809f, 0.01728392f, -0.03800074f, -0.00902165f, -0.03479475f, -0.05447813f, 
    0.04550175f, -0.04402465f, 0.03999737f, -0.05133991f, 0.00524530f, -0.06731436f, -0.01028051f, -0.00558372f, 
    -0.03870953f, -0.02699334f, 0.00828496f, 0.00412354f, -0.05392770f, -0.04701727f, 0.03568758f, -0.06416395f, 
    0.03994467f, -0.00294800f, -0.05614981f, -0.02751891f, 0.04271191f, -0.03884733f, -0.05178681f, 0.01834488f, 
    -0.01282647f, 0.02705291f, -0.02727655f, 0.02689406f, -0.04824135f, -0.00293679f, 0.01067084f, 0.02112013f, 
    0.01087532f, 0.02456276f, -0.03422495f, 0.00960251f, 0.03277317f, 0.03830045f, -0.00269234f, 0.00655010f, 
    0.04585915f, -0.05840918f, -0.03251678f, 0.01089088f, 0.03036755f, 0.01052209f, 0.02731499f, 0.04645074f, 
    0.01356177f, -0.06234747f, -0.05834354f, 0.01014708f, 0.04170040f, 0.00875511f, -0.03674438f, -0.06520491f, 
    0.01123183f, -0.00046762f, -0.05412817f, -0.05925211f, -0.03583217f, 0.01647487f, -0.06417347f, -0.05464387f, 
    0.04214814f, -0.00476470f, 0.04081756f, 0.01050022f, 0.04725318f, 0.03146039f, 0.01710888f, -0.03287104f, 
    0.00726283f, -0.05957435f, 0.02189956f, -0.01954969f, 0.04291194f, -0.01870252f, -0.02379528f, -0.01050833f, 
    -0.05969905f, -0.02663896f, -0.00198331f, 0.02130134f, -0.03379660f, -0.04754965f, -0.03663855f, -0.02302724f, 
    -0.04353633f, -0.05207389f, 0.02853491f, 0.04875186f, 0.01369941f, -0.04784099f, 0.04190494f, 0.00329161f, 
    0.01440595f, 0.01348056f, 0.01371406f, 0.01422576f, 0.02466935f, -0.03894676f, -0.04848475f, -0.06274245f, 
    -0.04729562f, 0.04739203f, -0.01082554f, 0.03924223f, 0.04699445f, -0.02250007f, -0.02779531f, -0.04783837f, 
    -0.05173928f, 0.03862252f, 0.01538339f, 0.04471545f, -0.01470672f, -0.04989731f, 0.01541378f, 0.02817773f, 
    -0.06400426f, -0.05796335f, -0.02855254f, 0.00432655f, 0.03426673f, -0.03640835f, 0.02874000f, 0.03443414f, 
    0.04339562f, -0.01547780f, -0.04712477f, -0.05384292f, 0.03290988f, 0.00146802f, 0.02304507f, 0.00762332f, 
    0.01821998f, 0.00907659f, -0.00801877f, 0.04502062f, -0.05158639f, -0.06177574f, -0.05779102f, 0.04395429f, 
    -0.05748304f, 0.01015840f, 0.04880857f, -0.02354483f, 0.03355266f, -0.04206628f, -0.00501598f, 0.03351409f, 
    0.01360345f, -0.05857258f, -0.05682291f, -0.03393107f, 0.00672595f, 0.03032739f, 0.01196561f, -0.06511533f, 
    -0.05578155f, -0.05341287f, -0.03468051f, 0.00113907f, 0.00310216f, -0.03248551f, -0.02979980f, 0.04228249f, 
    -0.00181613f, -0.04317657f, 0.00304125f, 0.02262302f, -0.03317266f, 0.00980813f, -0.04933305f, 0.01410926f, 
    -0.00634043f, 0.01374776f, -0.03335167f, -0.00030748f, -0.05695327f, -0.01925037f, 0.00758198f, -0.03344756f, 
    0.03209674f, -0.02707490f, -0.04593414f, -0.06765771f, 0.01034675f, -0.04949224f, 0.00822460f, -0.03949343f, 
    -0.04340288f, -0.00359869f, 0.01167186f, -0.02899721f, -0.05803765f, 0.04201693f, 0.00726129f, -0.05986197f, 
    0.00854358f, 0.04218828f, -0.02049954f, -0.02750097f, -0.03157022f, 0.02143892f, 0.01361745f, 0.00383445f, 
    -0.02301801f, -0.03840943f, 0.03406702f, 0.04392824f, -0.02030508f, -0.05227506f, -0.03406945f, -0.01276959f, 
    -0.01146960f, 0.02314128f, 0.04496254f, -0.04834574f, 0.00103589f, -0.04119639f, -0.04374597f, 0.02008706f, 
    0.02190551f, -0.04259277f, 0.00533284f, -0.00654709f, -0.04809828f, 0.00223797f, -0.02112957f, -0.01182713f, 
    0.04256425f, -0.06045345f, -0.02226552f, -0.03586348f, -0.02636733f, 0.01287945f, 0.04015681f, 0.00088809f, 
    0.00091750f, -0.05476106f, -0.06413728f, -0.05184615f, 0.03767601f, 0.03877485f, -0.06742197f, -0.01108088f, 
    -0.03306462f, 0.03274941f, -0.00139903f, -0.03039001f, -0.02207717f, -0.03271461f, -0.05561060f, 0.03844750f, 
    0.02451323f, -0.06262055f, -0.06014407f, -0.01505153f, -0.06329966f, 0.02499496f, -0.00957373f, 0.01143454f, 
    -0.01887329f, -0.02039230f, -0.06798875f, 0.01415286f, 0.03293051f, 0.04774311f, -0.02425417f, 0.03113069f, 
    -0.04713294f, -0.00816613f, 0.02293849f, -0.04770988f, 0.00520864f, 0.04179821f, -0.03042664f, 0.04507268f, 
    0.00632269f, 0.03547449f, -0.02686909f, -0.03294811f, 0.01268991f, 0.00070597f, -0.01536534f, 0.03985175f, 
    0.00788164f, 0.04059115f, 0.03631556f, -0.04047355f, -0.00794574f, 0.02873129f, -0.03570923f, -0.06897862f, 
    0.01328600f, -0.05642188f, -0.05922708f, -0.03611821f, -0.02389304f, -0.05908421f, 0.00943366f, 0.00274371f, 
    -0.04306553f, 0.03347296f, 0.01884746f, -0.00446446f, 0.00745945f, 0.05096185f, 0.03670930f, 0.01329605f, 
    0.03896160f, 0.00298515f, -0.00043495f, -0.00021699f, 0.00602631f, -0.04353606f, -0.06839919f, -0.04622626f, 
    -0.03604788f, -0.02522861f, -0.04930021f, -0.05437611f, 0.01719087f, 0.03130867f, -0.06288309f, -0.03447057f, 
    0.03164838f, -0.06273922f, -0.01409355f, -0.00807151f, -0.02898425f, -0.06466435f, -0.01160740f, -0.00112043f, 
    0.01679295f, 0.04771704f, 0.05008474f, -0.04603299f, -0.06588799f, 0.01464685f, 0.03536540f, -0.03340618f, 
    0.02781900f, -0.00769390f, 0.02602248f, -0.04420471f, -0.04832096f, -0.01950157f, 0.00292407f, -0.06204595f, 
    0.03824257f, 0.04977660f, -0.06560215f, 0.00761141f, -0.07620011f, 0.00015446f, 0.02692283f, 0.03113246f, 
    -0.03851977f, 0.03637525f, 0.01111997f, -0.02649063f, 0.02285456f, -0.07448442f, -0.04481619f, 0.02841909f, 
    -0.05596859f, 0.04506292f, -0.00296851f, -0.07023130f, -0.04462103f, -0.03312055f, -0.00255732f, 0.01594478f, 
    -0.04373729f, -0.02351111f, -0.00070626f, 0.02595050f, -0.01816636f, 0.03891020f, -0.02196961f, 0.00624878f, 
    0.03295069f, -0.03538222f, -0.06064161f, 0.03604967f, -0.03235909f, -0.06008851f, -0.04180954f, -0.01722488f, 
    -0.07106075f, -0.06432249f, -0.01905044f, -0.00235342f, 0.04586086f, 0.03383562f, 0.01098982f, -0.02753129f, 
    -0.04312455f, -0.03637853f, 0.01120776f, -0.03762786f, 0.03409865f, -0.05260324f, -0.01832832f, 0.01621573f, 
    -0.04347578f, -0.02611935f, 0.03658600f, 0.01654611f, 0.02297440f, -0.04898234f, 0.03720098f, 0.04366345f, 
    0.03680582f, -0.06101426f, 0.03287130f, 0.00178814f, 0.00105631f, 0.02373586f, -0.01896925f, 0.00980867f, 
    -0.02559742f, -0.03667467f, -0.00062081f, 0.02877161f, 0.04356493f, 0.01867044f, 0.02568000f, -0.00752149f, 
    -0.02459246f, -0.00777754f, -0.06718435f, -0.05102438f, 0.02600614f, -0.05753612f, 0.00899977f, -0.05770965f, 
    -0.07380959f, -0.05675257f, -0.02831247f, 0.04625366f, 0.02971536f, 0.01694819f, 0.03576252f, -0.03771295f, 
    0.02875055f, -0.03611098f, -0.02142826f, -0.06008947f, -0.03017495f, -0.06427179f, -0.02045743f, 0.02363732f, 
    0.00234487f, -0.03564747f, 0.00256940f, -0.05773104f, -0.04441129f, 0.02584335f, 0.02768817f, -0.04094393f, 
    -0.00157001f, -0.03463061f, -0.02093725f, 0.05298897f, 0.00581067f, -0.05615962f, -0.05071564f, 0.03690803f, 
    -0.03470014f, -0.01849784f, -0.04494128f, -0.03773579f, 0.02616606f, -0.02074227f, -0.03176421f, -0.05704498f, 
    -0.04824656f, 0.03802216f, 0.00889112f, 0.00461311f, -0.03062794f, 0.03275819f, -0.05365913f, -0.05437231f, 
    0.03436857f, 0.02339261f, -0.02014557f, 0.03458315f, 0.04305291f, -0.03333314f, -0.01174450f, -0.01584938f, 
    -0.02634789f, 0.00862324f, -0.02851946f, -0.02578027f, -0.05665461f, -0.01423650f, 0.01254664f, -0.04416314f, 
    -0.06393276f, 0.00889167f, 0.01507758f, 0.00105956f, -0.03187589f, 0.03689015f, -0.02282614f, -0.04507497f, 
    -0.04529385f, -0.00970839f, 0.00607869f, 0.02479715f, -0.07066160f, 0.03711908f, 0.02346892f, 0.03878924f, 
    -0.07664987f, -0.16931084f, 0.05307397f, -0.00152964f, -0.01779884f, 0.01668885f, -0.06824936f, 0.06317559f, 
    -0.09133953f, 0.12526636f, -0.07280878f, 0.12250688f, 0.14507726f, 0.19772761f, -0.19501278f, -0.15201874f, 
    -0.02000416f, -0.10102076f, 0.17897861f, 0.02521292f, 0.30640587f, -0.00800330f, 0.06893004f, 0.04831434f, 
    -0.13158052f, 0.17294045f, 0.12157140f, 0.11598396f, -0.06303614f, 0.02889509f, -0.01631888f, 0.15872787f, 
    -0.03021912f, 0.22642387f, -0.04417624f, 0.11252549f, 0.37468717f, 0.02205268f, 0.07700998f, 0.04918995f, 
    -0.01857505f, -0.03547410f, 0.00831593f, 0.26311487f, 0.19770940f, 0.22517979f, -0.10825684f, 0.22426873f, 
    -0.05845328f, 0.13405089f, -0.07172832f, -0.02337595f, -0.05616925f, -0.11881687f, 0.02457751f, 0.10993696f, 
    0.21775435f, 0.10713229f, 0.06684996f, -0.01864536f, -0.12430587f, 0.01226849f, 0.09389672f, 0.22763704f, 
    -0.08801116f, 0.17831931f, -0.07831247f, -0.11051815f, 0.11967424f, -0.05834233f, -0.14450692f, -0.18062773f, 
    -0.00864837f, -0.09932885f, 0.02561660f, 0.10704633f, 0.00590296f, -0.04368796f, 0.09173608f, -0.10913984f, 
    -0.12533556f, -0.10775439f, -0.05433386f, -0.17399934f, 0.03281459f, 0.08694907f, -0.09798753f, 0.13501258f, 
    -0.00202607f, 0.16670106f, 0.22973897f, 0.07952105f, 0.09502857f, -0.01328674f, 0.02707209f, -0.05043120f, 
    -0.06020898f, 0.19752419f, 0.07843954f, -0.29909289f, 0.03331151f, 0.16512275f, -0.01777497f, 0.10248987f, 
    -0.17760113f, 0.01798308f, 0.07556560f, 0.04901762f, 0.06117332f, -0.06519298f, 0.12447213f, 0.08703775f, 
    0.02213666f, -0.19330835f, 0.00769650f, -0.12546925f, -0.03285361f, 0.10282835f, 0.06484586f, 0.13105310f, 
    -0.06055696f, 0.00450440f, 0.07426490f, -0.22856143f, -0.02173232f, 0.02014152f, 0.24604483f, 0.11217771f, 
    0.09863643f, 0.10727418f, 0.20486352f, 0.02792772f, -0.07298218f, 0.03686250f, -0.04233488f, 0.27886671f, 
    0.30583110f, 0.24570586f, 0.04260604f, 0.02371178f, 0.02157886f, -0.13811597f, 0.26409796f, -0.18139087f, 
    -0.00978362f, -0.00017553f, 0.06307001f, 0.11179123f, 0.06161792f, 0.00202273f, 0.09146843f, -0.10686500f, 
    -0.01553926f, -0.29603156f, 0.24181718f, -0.10845027f, -0.00760549f, -0.30527389f, 0.20908932f, -0.11500794f, 
    -0.08378971f, -0.10032621f, 0.04512525f, 0.14872380f, 0.08351149f, -0.13913605f, 0.01917733f, -0.03389528f, 
    -0.04070325f, 0.00142141f, 0.24003430f, 0.00204618f, -0.05403350f, -0.33533329f, -0.03847727f, -0.08834708f, 
    0.00307506f, -0.14499576f, -0.16509330f, -0.35078910f, -0.10215975f, 0.00409213f, 0.11537150f, 0.21407747f, 
    0.09083975f, 0.04240083f, -0.12300467f, -0.02402803f, 0.03890406f, 0.02844042f, 0.03742821f, 0.05446034f, 
    0.12259280f, -0.05072979f, 0.17482519f, -0.00885616f, -0.15629452f, -0.14431371f, 0.05326515f, 0.13623141f, 
    0.13678068f, -0.06872196f, 0.06841473f, -0.02362829f, -0.08174092f, 0.06892646f, 0.01945362f, 0.15734415f, 
    -0.05750041f, -0.33607510f, -0.04469532f, -0.21345367f, 0.05039578f, -0.17385183f, -0.07197699f, -0.14920114f, 
    0.11669619f, 0.05901222f, 0.06661614f, 0.11551601f, -0.02127142f, -0.00211809f, -0.07640200f, 0.03478599f, 
    0.00278943f, -0.14444900f, 0.00786094f, 0.02599405f, -0.06851584f, 0.12009647f, 0.02516849f, 0.06842402f, 
    0.15858586f, 0.00667092f, 0.18378706f, -0.07244074f, 0.16168506f, 0.11939347f, -0.02827445f, 0.03483970f, 
    -0.05424784f, -0.15217556f, -0.15388763f, 0.08142386f, -0.16335519f, -0.09979768f, -0.13576087f, -0.08797269f, 
    -0.09274593f, -0.13540435f, 0.07704642f, 0.15408684f, -0.33417809f, -0.07135071f, 0.00995919f, 0.00188433f, 
    0.04817044f, -0.11145871f, 0.03312508f, -0.04653777f, -0.00925596f, -0.03229345f, 0.10661964f, 0.14680500f, 
    0.02712863f, 0.12738679f, -0.08309221f, -0.09443261f, -0.09616389f, -0.03378076f, -0.05305289f, 0.05910584f, 
    -0.15781984f, -0.00609282f, 0.05478742f, 0.10825816f, -0.05256102f, 0.04546710f, -0.06018782f, -0.17232192f, 
    0.03679420f, -0.04254589f, 0.08096335f, -0.01356609f, -0.03713631f, 0.11781610f, 0.08935578f, 0.07998486f, 
    -0.06366469f, -0.04813419f, -0.06746117f, 0.00841683f, 0.04240729f, 0.04369934f, 0.02225304f, -0.00196824f, 
    -0.06118489f, -0.02722155f, -0.01399107f, -0.00645762f, -0.01365629f, -0.03897681f, 0.00796584f, 0.00805387f, 
    -0.05188183f, -0.04958942f, 0.03584767f, -0.01093982f, 0.02564508f, 0.04000502f, -0.05424288f, 0.03292956f, 
    -0.02314015f, -0.00540203f, -0.06112280f, 0.04339781f, -0.01735203f, -0.01379377f, 0.04633640f, -0.00890908f, 
    0.03916450f, 0.01698831f, -0.06849445f, 0.00707689f, 0.04225581f, -0.00241794f, 0.01101555f, 0.00258843f, 
    -0.01646205f, 0.00240150f, 0.00563421f, 0.03236172f, -0.00736903f, -0.01276179f, -0.02801455f, 0.00671540f, 
    0.01350788f, -0.05556188f, 0.03177635f, 0.04930834f, -0.02609996f, -0.00627325f, -0.04244559f, -0.01675115f, 
    0.00475151f, 0.02273538f, 0.01233828f, 0.03209644f, -0.01981367f, 0.02309256f, 0.01658864f, -0.05597262f, 
    0.01394871f, -0.06324809f, -0.04841511f, -0.00633553f, -0.06384877f, -0.03292996f, -0.04684298f, 0.00069824f, 
    0.02673315f, -0.07074498f, -0.01038589f, 0.03337131f, -0.01573465f, 0.00186367f, -0.04045250f, -0.02182765f, 
    -0.00568591f, 0.02798975f, -0.03638116f, 0.03459881f, -0.04154100f, 0.03272971f, -0.01171516f, 0.00207821f, 
    -0.05466418f, -0.02681874f, -0.00530280f, -0.06059091f, -0.05825578f, -0.02099284f, -0.04958272f, -0.00117102f, 
    0.04363948f, 0.00519377f, -0.05012380f, -0.04347902f, 0.01212178f, -0.03282864f, -0.06398915f, 0.02822109f, 
    -0.00520838f, 0.04680640f, 0.02341712f, -0.02849661f, 0.02439732f, -0.02244969f, -0.00468926f, -0.04313375f, 
    0.04680093f, -0.05460389f, 0.05011667f, -0.02450202f, -0.02182557f, -0.04727261f, -0.03373440f, 0.01087023f, 
    0.00474300f, -0.06704082f, 0.00776198f, -0.01468160f, -0.03180274f, -0.02927183f, -0.03197419f, 0.03357353f, 
    -0.01611119f, -0.00392613f, -0.00404145f, -0.00483255f, -0.03302101f, -0.04502242f, 0.04188886f, -0.03194185f, 
    -0.05838048f, -0.03247612f, -0.02562173f, -0.05895863f, 0.01819223f, -0.05496284f, -0.00083295f, 0.02497474f, 
    0.00972906f, 0.02938466f, -0.03171980f, -0.03790614f, 0.00461880f, -0.01235296f, -0.05354756f, 0.04468426f, 
    0.02211371f, -0.03058920f, -0.02930612f, -0.06155411f, -0.02951192f, -0.05122462f, -0.04309243f, -0.03900649f, 
    -0.04706580f, 0.00205811f, -0.00967236f, -0.00843466f, 0.01618002f, 0.03227498f, 0.02059077f, -0.01493459f, 
    -0.01898613f, 0.03059578f, -0.06766590f, 0.03820778f, -0.00589482f, -0.03893325f, 0.01723432f, -0.00435370f, 
    0.00273498f, -0.03690831f, -0.01752437f, -0.01596257f, 0.03890802f, 0.01199060f, -0.03451480f, 0.02999802f, 
    -0.02906013f, -0.03805159f, 0.00542384f, 0.01000521f, -0.00526358f, 0.01047032f, -0.00508728f, -0.02074261f, 
    0.03517225f, -0.06404845f, -0.04428313f, -0.01404399f, -0.00057963f, 0.03389043f, 0.01554774f, -0.04814256f, 
    0.03875016f, 0.05190724f, -0.02991893f, -0.06918429f, 0.03358172f, 0.00138621f, 0.04766155f, -0.06204166f, 
    -0.03313674f, -0.04664825f, 0.02277855f, -0.05264680f, 0.04493776f, -0.00813864f, 0.01771270f, 0.03958564f, 
    0.00990291f, 0.01553004f, -0.01700173f, -0.04133888f, -0.02915692f, 0.03069781f, 0.00590940f, -0.00889444f, 
    -0.06814976f, 0.02204007f, 0.00329803f, -0.05833572f, 0.04447251f, 0.04984425f, 0.02757988f, 0.03367194f, 
    0.04951886f, -0.01160190f, -0.01915645f, 0.04489563f, 0.00359013f, 0.02568957f, -0.02107211f, -0.04592488f, 
    0.00501458f, -0.04539305f, -0.05727561f, 0.02371734f, -0.04274832f, -0.03054908f, 0.04724571f, 0.03550998f, 
    0.04453840f, -0.00623971f, -0.01480685f, -0.02598735f, 0.00999247f, -0.04916426f, -0.04654905f, 0.04018807f, 
    -0.03814514f, -0.02509080f, -0.06018084f, 0.00253274f, -0.03165891f, 0.01931092f, -0.04234441f, 0.02474827f, 
    -0.04234158f, -0.05685171f, -0.04941780f, -0.04405315f, -0.00019532f, 0.00785875f, -0.02905645f, -0.01322668f, 
    -0.04437548f, -0.00303598f, 0.00490254f, -0.02636826f, -0.05275713f, -0.06444900f, 0.03749074f, -0.02481620f, 
    -0.00738576f, 0.00931217f, -0.02292252f, -0.03408644f, 0.01304465f, -0.01097064f, -0.02355544f, 0.02462639f, 
    -0.15471512f, -0.10925966f, 0.24421784f, -0.14482184f, 0.25645506f, 0.20118530f, 0.10419620f, 0.14181788f, 
    -0.09094889f, -0.05783106f, 0.07879356f, 0.26507536f, -0.11432032f, -0.02418166f, -0.00160394f, 0.09717580f, 
    0.19950746f, 0.01649247f, -0.21721669f, -0.34723625f, -0.28551975f, -0.08581948f, 0.10763942f, -0.12841970f, 
    -0.16355528f, -0.12079403f, -0.04861059f, -0.37616301f, -0.27240512f, -0.28580144f, 0.01348531f, -0.09166255f, 
    -0.08907151f, -0.09967389f, -0.01575357f, -0.04051023f, 0.12865770f, 0.06212371f, -0.67127967f, -0.12687224f, 
    0.09588096f, -0.11422684f, 0.17434423f, 0.02313419f, -0.15967347f, -0.23845841f, 0.05374411f, -0.39950365f, 
    0.09340002f, 0.19651975f, -0.01469866f, 0.24393554f, 0.16159461f, -0.10515258f, -0.00555816f, -0.12884626f, 
    -0.32842055f, -0.04688625f, 0.10108905f, 0.16526784f, -0.17604958f, 0.00713639f, -0.00571144f, -0.03039010f, 
    0.00599087f, -0.11780819f, 0.08971304f, -0.03358225f, 0.04716142f, 0.14993325f, 0.11325118f, 0.06073625f, 
    -0.01453267f, -0.18356997f, 0.11450391f, 0.17450999f, -0.02063041f, 0.15844303f, 0.16107772f, -0.07475537f, 
    0.05570794f, 0.14329588f, 0.11719467f, 0.24487199f, 0.10640141f, 0.00714422f, -0.04731084f, -0.08853088f, 
    -0.21243750f, -0.13176362f, 0.10556606f, 0.00712536f, -0.30562988f, 0.08373444f, 0.18539983f, -0.01490693f, 
    -0.00502700f, 0.19306523f, -0.11201247f, 0.10471242f, 0.14698674f, 0.31320891f, -0.04559963f, 0.05624940f, 
    0.03669637f, 0.17036110f, -0.08431696f, 0.02805566f, 0.05125929f, 0.08885447f, 0.27239335f, -0.03648539f, 
    0.06203490f, -0.01227206f, 0.09494855f, -0.13694574f, 0.08179109f, 0.02665599f, -0.09657482f, -0.21625732f, 
    0.21077038f, 0.07237094f, 0.15635832f, -0.01865504f, -0.16287163f, 0.08672046f, -0.15456973f, -0.20766474f, 
    -0.14449677f, -0.02864557f, 0.05825783f, -0.05228841f, 0.02002424f, -0.03582742f, 0.01128650f, 0.23160553f, 
    0.40728462f, -0.22368197f, -0.05204261f, 0.27272633f, 0.23072442f, -0.08782389f, 0.20596372f, -0.32629499f, 
    -0.11725094f, 0.05528163f, 0.15911353f, 0.18487708f, -0.04845177f, 0.03898595f, 0.04557066f, 0.11245757f, 
    -0.30839294f, 0.17034428f, 0.05786430f, -0.14025183f, 0.01335701f, -0.12431460f, -0.00800840f, 0.28999415f, 
    0.16840611f, 0.02961351f, 0.14287610f, -0.10029310f, 0.14949290f, -0.18297793f, -0.03679144f, -0.10335015f, 
    -0.13804358f, -0.20080778f, -0.16850954f, 0.23431830f, -0.06398023f, 0.07081296f, 0.08107264f, -0.12783310f, 
    -0.08187911f, 0.01594277f, 0.01304450f, 0.19366212f, -0.19767372f, -0.49844202f, -0.44788983f, -0.07583617f, 
    -0.25323939f, -0.05933467f, -0.08173777f, 0.28598318f, 0.08766373f, -0.00988146f, -0.21015653f, -0.53882080f, 
    0.01240074f, -0.16762379f, -0.10227221f, 0.06641995f, 0.09200794f, 0.15430433f, -0.16954757f, -0.44538015f, 
    -0.19760261f, -0.05691515f, -0.00509796f, 0.07169820f, -0.03735620f, 0.13739973f, -0.21938504f, 0.19829065f, 
    0.12555572f, 0.06362602f, -0.02183259f, 0.01867434f, 0.12425208f, 0.11119541f, 0.07953133f, 0.13646522f, 
    -0.24784932f, 0.03608921f, -0.59897524f, 0.09292922f, 0.10892023f, -0.13459770f, 0.04389460f, 0.28633597f, 
    -0.10916411f, 0.16139616f, 0.21050499f, 0.21697830f, -0.06783620f, 0.07029694f, 0.07071482f, -0.03024468f, 
    0.03209484f, -0.05316008f, 0.06489586f, 0.19858487f, -0.42960048f, 0.00321139f, -0.21701603f, 0.00433861f, 
    0.29642799f, 0.23706636f, 0.13180724f, 0.07152021f, 0.50281537f, -0.08000568f, 0.05313440f, 0.17263946f, 
    -0.02363592f, -0.13038826f, -0.42414993f, -0.02526960f, 0.13562849f, 0.01015855f, 0.17049731f, 0.14295092f, 
    0.05373957f, 0.15607835f, 0.01072895f, 0.09793322f, 0.12203400f, -0.06652840f, 0.21362081f, 0.12735616f, 
    0.02843869f, 0.00523186f, 0.13157690f, 0.00443732f, -0.03282090f, -0.03440318f, 0.10173483f, 0.16918647f, 
    0.28007972f, 0.14263041f, -0.05496844f, -0.04671199f, 0.09196899f, 0.03212308f, -0.00635444f, 0.09900223f, 
    0.19469096f, 0.18286858f, 0.11487094f, 0.16238700f, 0.06068602f, 0.11243001f, -0.08031661f, 0.06817189f, 
    0.15751989f, 0.35824814f, -0.07343598f, 0.10581934f, 0.01866781f, 0.17349772f, 0.06865656f, -0.00958480f, 
    -0.03031294f, 0.09558909f, -0.30101216f, 0.10585656f, -0.14313345f, 0.13954777f, 0.28743413f, 0.08999305f, 
    0.15805279f, 0.26561001f, 0.32347506f, 0.12315068f, 0.02851227f, 0.01776429f, -0.10025672f, -0.01903343f, 
    -0.10260541f, 0.01016032f, -0.13898504f, 0.27358913f, 0.27994919f, 0.05106570f, 0.17876229f, -0.23697424f, 
    0.01625003f, -0.06846330f, 0.13728197f, -0.03202392f, 0.04440692f, 0.18022442f, 0.02404247f, 0.03055825f, 
    0.05958167f, -0.00708824f, -0.06599649f, 0.01651889f, -0.12535566f, 0.16304556f, 0.04349679f, 0.13417290f, 
    0.08646763f, 0.17630178f, 0.00974405f, 0.13098533f, -0.10217516f, -0.07765111f, -0.02543677f, 0.06273656f, 
    -0.01246411f, 0.02991686f, -0.07098646f, 0.12373754f, -0.00394092f, -0.03671549f, -0.12761188f, 0.03017186f, 
    0.01854037f, 0.27776462f, 0.09331066f, 0.23267752f, -0.01355918f, 0.24985215f, -0.01768912f, 0.22883798f, 
    0.18503855f, 0.39696947f, 0.13112825f, 0.18539642f, 0.21144335f, 0.04654324f, 0.00074897f, -0.00455782f, 
    0.01318230f, -0.03952064f, -0.07217459f, -0.08389691f, 0.18115859f, -0.12802286f, 0.06748091f, 0.14270726f, 
    -0.03289126f, -0.16174012f, -0.01516334f, 0.19442584f, 0.11245678f, 0.08341211f, 0.10436133f, 0.06457940f, 
    -0.16785543f, 0.07365347f, 0.04046153f, -0.09104101f, -0.20934053f, -0.23062284f, 0.16846232f, 0.08725803f, 
    0.06400427f, -0.05563366f, -0.20518297f, -0.03461600f, 0.04981065f, 0.04998374f, 0.10535122f, 0.05635129f, 
    -0.05612667f, 0.10350221f, 0.02564765f, 0.05100208f, 0.22271468f, 0.13922833f, 0.11821859f, 0.05653604f, 
    0.00478196f, -0.00893790f, 0.01120880f, -0.01127022f, 0.08233494f, -0.16596049f, 0.22799620f, 0.15601543f, 
    0.03847949f, -0.00234917f, -0.07551699f, -0.13110155f, -0.11337093f, -0.07264630f, 0.03021770f, -0.35166988f, 
    0.10686276f, -0.00854594f, 0.13617347f, 0.02988447f, -0.03265681f, -0.15693823f, 0.25789753f, -0.07841741f, 
    0.06634773f, 0.08791734f, 0.04700211f, 0.06539984f, 0.06495050f, -0.19109087f, 0.06080541f, -0.04781503f, 
    -0.09653581f, 0.02113936f, 0.15541466f, -0.06357823f, -0.02478987f, 0.14979708f, 0.07051074f, 0.12345169f, 
    0.02304916f, 0.00439153f, -0.00470680f, -0.01361999f, -0.24145834f, 0.04983913f, 0.04255690f, 0.16178589f, 
    -0.06457978f, -0.00119582f, 0.03843047f, 0.03678614f, -0.17948782f, -0.18223292f, -0.06953008f, 0.12732856f, 
    0.20505399f, 0.03191846f, 0.12644410f, 0.25037661f, -0.08656690f, 0.06279904f, -0.19264160f, 0.13131914f, 
    0.02287858f, -0.04516972f, 0.04550406f, -0.17939825f, 0.13801679f, -0.02405471f, -0.03419459f, -0.10766132f, 
    0.07459507f, 0.08542832f, 0.02835907f, 0.16026405f, 0.14108364f, -0.13569872f, -0.03410720f, -0.13730776f, 
    -0.19482064f, 0.07588917f, 0.12805597f, 0.01490797f, -0.19500235f, 0.02855748f, 0.09024582f, -0.03232015f, 
    0.21175338f, -0.14353004f, 0.08563287f, 0.11173958f, -0.01578192f, 0.14024341f, 0.06399097f, 0.12812279f, 
    0.08948211f, 0.25082469f, 0.21167910f, 0.13039431f, 0.19146214f, 0.31054884f, -0.06485164f, 0.26840189f, 
    0.04458124f, 0.04034028f, -0.14751311f, -0.12367036f, 0.23500864f, 0.13500953f, -0.02315729f, -0.17824875f, 
    -0.06064577f, 0.07375862f, 0.03512013f, -0.09221003f, 0.19947535f, -0.00857692f, 0.06926654f, 0.05277015f, 
    0.03466014f, 0.23084907f, 0.09406949f, -0.03001145f, -0.12322181f, 0.02655337f, 0.01885075f, -0.00240983f, 
    -0.01855924f, -0.07794272f, 0.03079541f, -0.26078287f, 0.17600332f, -0.26541737f, -0.15176348f, -0.09352574f, 
    0.01351696f, -0.01486071f, -0.08604919f, 0.04142225f, 0.00314424f, 0.09599444f, 0.04126326f, 0.10497440f, 
    0.03501163f, 0.18255778f, 0.10636748f, 0.20015040f, 0.13569313f, 0.04607033f, 0.18749487f, 0.12167796f, 
    0.06871969f, 0.22948112f, -0.02451919f, -0.07301144f, -0.00225097f, -0.08698384f, 0.08185468f, 0.12228864f, 
    -0.16639815f, -0.09754186f, 0.08806864f, 0.21594974f, 0.19451189f, 0.07076388f, -0.01240001f, 0.15299951f, 
    0.03479483f, -0.13129222f, 0.04597250f, -0.03764101f, -0.03415732f, -0.05196077f, 0.13341402f, 0.07215604f, 
    0.09560532f, 0.09420224f, 0.20165820f, -0.05677800f, -0.01879600f, -0.12650526f, 0.07670645f, -0.07040893f, 
    -0.14217168f, -0.05865437f, -0.14652161f, -0.13148633f, -0.10375808f, -0.14171699f, 0.04431379f, 0.12095744f, 
    -0.12429713f, -0.13792743f, 0.17415521f, -0.31972647f, -0.46307105f, -0.23285450f, 0.07696224f, -0.11576748f, 
    0.05639195f, -0.19947478f, -0.06051745f, 0.06369305f, -0.16749395f, -0.15055634f, -0.00393612f, 0.01918609f, 
    -0.10046242f, 0.03066218f, 0.07272468f, -0.00417668f, 0.03841153f, -0.00409035f, 0.01314795f, 0.09477784f, 
    0.09254980f, 0.12382334f, 0.01786908f, 0.00244683f, -0.05078133f, 0.12176127f, -0.01835201f, -0.03135164f, 
    0.05629581f, -0.21026449f, -0.00311609f, 0.12559603f, -0.03490268f, 0.12276870f, 0.00846462f, 0.06780811f, 
    0.09381512f, 0.14884830f, 0.02448193f, -0.00134941f, 0.07300709f, 0.04888345f, -0.24358907f, 0.06336109f, 
    0.02896250f, -0.18940285f, 0.08146171f, 0.00856739f, -0.15589818f, -0.17107737f, -0.00076070f, 0.01922368f, 
    0.01194855f, 0.09167019f, -0.02674463f, 0.07597840f, 0.10560796f, 0.14405949f, -0.03742147f, 0.14042914f, 
    0.07699735f, 0.12773356f, -0.13418584f, -0.05038575f, 0.13728869f, 0.12059232f, -0.12697770f, 0.17570662f, 
    0.04457788f, 0.06619657f, 0.15258682f, -0.22870186f, -0.02585937f, -0.23750250f, -0.18461917f, 0.03939532f, 
    0.10100405f, 0.03471524f, 0.14235453f, 0.04098089f, 0.02358409f, 0.02316646f, -0.10172696f, -0.15624797f, 
    0.06391312f, 0.01717781f, 0.26085350f, 0.01923150f, -0.01492796f, -0.16136698f, -0.06801657f, -0.00270944f, 
    -0.29876056f, -0.01246294f, 0.09616465f, -0.02755877f, 0.01940911f, 0.03548144f, -0.10208895f, 0.12201605f, 
    0.26124451f, 0.03753173f, -0.14337038f, 0.08203147f, -0.11475208f, 0.02408329f, 0.15672313f, 0.01099420f, 
    -0.41640857f, 0.26785535f, 0.01224681f, -0.10047210f, 0.10557824f, 0.11021642f, -0.02302249f, 0.04741636f, 
    0.27999341f, -0.04974521f, -0.01908941f, 0.23053741f, 0.10932034f, -0.01231679f, 0.20638514f, 0.18945482f, 
    0.01046748f, -0.05883510f, -0.13829444f, 0.09917038f, 0.09275879f, -0.18688330f, -0.05056233f, 0.07073851f, 
    -0.10722385f, 0.05323071f, 0.08320584f, 0.10957538f, 0.15402962f, -0.03351682f, 0.24192718f, -0.10951673f, 
    -0.03905489f, 0.22428899f, 0.28627393f, 0.00197169f, 0.07881541f, 0.01515501f, 0.03336089f, -0.06693010f, 
    -0.25575462f, -0.06223271f, -0.18493845f, -0.18522453f, -0.13117279f, -0.03564328f, -0.26265058f, -0.28527406f, 
    -0.04477580f, -0.10438389f, -0.17307410f, 0.01220335f, -0.04113349f, -0.38349628f, -0.24032925f, 0.08259092f, 
    0.18513633f, -0.01052371f, -0.05422163f, 0.04716684f, -0.14929335f, 0.03859666f, -0.11499078f, 0.00114426f, 
    0.02417743f, -0.08233562f, 0.14428797f, -0.09124355f, 0.10510895f, -0.03975629f, 0.04329421f, 0.05189860f, 
    -0.08856167f, 0.07725906f, 0.09797177f, -0.04180046f, -0.01154178f, -0.08763468f, 0.01410041f, 0.04277008f, 
    -0.20911975f, -0.49241605f, -0.17681316f, 0.03060795f, -0.16528966f, 0.07613892f, -0.02061097f, -0.00390691f, 
    -0.00406057f, -0.04831171f, -0.01813763f, 0.15209159f, 0.04996905f, -0.03459780f, 0.01046889f, 0.19960937f, 
    0.10954921f, 0.08881289f, 0.13761136f, 0.07214307f, 0.02693969f, 0.06084508f, -0.04261974f, -0.00385969f, 
    0.00509654f, -0.05037785f, -0.05156195f, 0.18205582f, -0.41923934f, -0.29360643f, -0.02363081f, -0.23123375f, 
    -0.15815660f, 0.00510827f, 0.11088754f, 0.17907842f, -0.03901818f, 0.02254307f, -0.25013363f, -0.08947530f, 
    0.00153413f, 0.13004690f, 0.02889387f, -0.01981239f, 0.06961922f, 0.05495347f, 0.02432789f, 0.11805960f, 
    0.00594458f, 0.11938747f, 0.03251831f, 0.03803111f, -0.04151708f, -0.02859108f, -0.16844922f, 0.12193508f, 
    0.07837237f, 0.15537928f, -0.04088478f, 0.07932039f, -0.03824776f, 0.17969786f, 0.02468936f, 0.04566681f, 
    0.00109047f, -0.01616246f, 0.01474806f, 0.16646603f, 0.03532406f, -0.07216705f, 0.09080072f, 0.05983194f, 
    -0.02184496f, -0.01031441f, -0.05173789f, -0.05373748f, -0.06216821f, -0.00371743f, 0.04143529f, 0.03425408f, 
    0.01907275f, -0.04210066f, -0.02229042f, 0.00081757f, -0.01625355f, 0.01369624f, -0.05240997f, 0.03786553f, 
    -0.05864858f, -0.02594266f, -0.04214787f, -0.01386167f, -0.00233838f, -0.06636390f, -0.05075466f, -0.01801021f, 
    -0.05002532f, 0.01622512f, -0.04091587f, 0.00219982f, 0.03197261f, 0.00919648f, -0.02657204f, 0.01480838f, 
    0.02310553f, -0.04675741f, 0.00161120f, 0.03802861f, 0.00826764f, -0.03739123f, -0.00054599f, 0.03575378f, 
    0.03394763f, -0.02321778f, -0.05241648f, 0.01176693f, -0.03746126f, 0.02247837f, -0.02910928f, 0.03617370f, 
    0.02094734f, -0.04049942f, -0.01552639f, 0.03850064f, -0.05635528f, -0.00651644f, -0.06566177f, 0.04241223f, 
    0.00824244f, 0.02058123f, -0.01893864f, 0.03078186f, -0.05570825f, 0.01593747f, 0.00022156f, 0.00071077f, 
    0.00466141f, 0.02762040f, 0.04342572f, -0.05814912f, 0.04578754f, -0.02170826f, -0.04126855f, 0.02963335f, 
    -0.02464430f, -0.05421766f, 0.02578810f, 0.02414815f, -0.06829237f, -0.06387065f, -0.01222262f, -0.04945235f, 
    0.03694245f, 0.04339717f, 0.01189174f, -0.03825390f, 0.03231208f, 0.01141439f, 0.01168321f, -0.00787868f, 
    -0.05004955f, -0.00241000f, -0.00574903f, -0.01469184f, 0.00183514f, -0.03825598f, -0.00438823f, 0.00663693f, 
    0.02352092f, -0.03598701f, -0.03299489f, -0.04719605f, 0.01590236f, -0.04137287f, 0.01372257f, -0.01241926f, 
    -0.05478156f, -0.04683625f, -0.04779016f, -0.02825475f, -0.02928358f, 0.00596049f, 0.00408567f, 0.00118288f, 
    0.01158603f, -0.02593366f, -0.01208632f, -0.02637485f, 0.00021763f, 0.03170567f, 0.03122627f, -0.03085475f, 
    -0.00709006f, -0.03009255f, -0.05080292f, 0.01615195f, -0.03914544f, -0.05619772f, -0.00488664f, 0.02936991f, 
    -0.01664753f, -0.02944088f, 0.04569405f, 0.02816533f, 0.04193376f, 0.03050984f, -0.05552813f, -0.00304165f, 
    0.00126851f, -0.04997260f, -0.04637234f, -0.00560281f, 0.00928187f, 0.00400651f, 0.02256862f, -0.02191154f, 
    0.02591167f, -0.03946486f, 0.02406642f, -0.06684116f, -0.01101136f, -0.06083547f, 0.03552921f, -0.05383180f, 
    -0.04571568f, 0.04132784f, -0.03402672f, 0.01450676f, 0.01758337f, -0.00531303f, 0.04879340f, -0.04005643f, 
    -0.03605599f, 0.02286434f, -0.03955791f, -0.02176542f, 0.02861415f, 0.00225929f, -0.01523885f, 0.02857252f, 
    -0.06449251f, -0.05720059f, -0.05435929f, -0.03651796f, 0.00703525f, -0.03958149f, -0.05913380f, -0.00885226f, 
    -0.04867993f, -0.05828252f, -0.01330067f, -0.05476601f, 0.04785410f, -0.01410879f, 0.00469392f, -0.06586298f, 
    -0.00392795f, 0.00031704f, 0.01625533f, 0.00627828f, -0.02112363f, -0.00544154f, -0.02364196f, 0.02442104f, 
    -0.01033411f, -0.05778105f, 0.04410749f, 0.04691040f, -0.04075778f, 0.03707294f, -0.02278242f, -0.03533901f, 
    0.04774401f, -0.03595119f, -0.00509061f, -0.00956970f, -0.01694832f, -0.03155585f, -0.00764478f, 0.02405610f, 
    -0.00304173f, 0.04632217f, -0.06398019f, 0.03160247f, -0.06707470f, 0.04163744f, -0.05789236f, 0.00383191f, 
    -0.00060901f, 0.01564547f, -0.04346704f, -0.02944651f, 0.03322846f, -0.02199619f, 0.03899075f, -0.03939317f, 
    -0.02300143f, 0.00266442f, 0.01627769f, 0.03768424f, 0.00813407f, -0.04426997f, 0.03738987f, -0.02705385f, 
    -0.00713928f, -0.02474707f, -0.04130872f, -0.06552085f, -0.04426333f, 0.00067328f, 0.04565334f, -0.02971487f, 
    -0.03166092f, -0.01447898f, 0.03449367f, -0.02910124f, -0.01221173f, 0.01483136f, -0.06074503f, 0.01588605f, 
    0.05008916f, 0.03425872f, -0.05971376f, 0.03500659f, -0.04513665f, -0.02932433f, -0.03491588f, -0.06399081f, 
    -0.02244005f, 0.01451055f, -0.02518830f, -0.01451304f, 0.00284687f, 0.00250745f, 0.01675990f, -0.03878645f, 
    0.02687703f, -0.01203451f, 0.00279915f, -0.00884669f, 0.04210706f, -0.04872607f, 0.00994909f, -0.01436372f, 
    0.04089514f, -0.04472923f, 0.03227604f, -0.00259307f, 0.01498139f, -0.06688060f, -0.02534605f, -0.00528492f, 
    -0.06696725f, 0.02749255f, 0.00744857f, -0.04008542f, 0.04247173f, 0.04105502f, 0.02406057f, -0.06905521f, 
    0.00288561f, -0.06301417f, 0.02260753f, 0.04070271f, 0.00581549f, -0.03052497f, -0.03907377f, 0.01085458f, 
    -0.05828516f, -0.04390001f, -0.03650937f, 0.03003072f, -0.03735976f, 0.02116622f, 0.01917925f, 0.01601347f, 
    -0.06440739f, -0.01836450f, -0.05268473f, 0.01951575f, 0.03804657f, -0.02804969f, -0.04868339f, -0.04759947f, 
    -0.04591563f, -0.04339137f, 0.05670681f, -0.05013793f, -0.03860991f, -0.04332938f, -0.05618051f, -0.05282199f, 
    0.03167901f, -0.04040482f, 0.01356259f, -0.06601800f, 0.03769332f, -0.06637453f, 0.03113968f, 0.00917112f, 
    -0.05058423f, 0.02201907f, 0.01319147f, -0.04059549f, -0.00249133f, -0.05099165f, -0.05162482f, -0.03403771f, 
    -0.02806787f, 0.03563788f, -0.05991753f, 0.04553607f, -0.05628734f, 0.03289920f, 0.03066317f, -0.03714264f, 
    0.03232638f, 0.03915663f, -0.05315919f, -0.04847441f, -0.04232240f, 0.00508873f, -0.03294649f, -0.01670308f, 
    0.02178697f, 0.00251183f, -0.03589865f, -0.05429843f, -0.02704387f, -0.02531604f, 0.03461927f, 0.03982567f, 
    -0.04359666f, 0.00873277f, -0.02445062f, -0.05481356f, 0.04136590f, 0.04453031f, -0.04781472f, -0.06048673f, 
    -0.03825884f, 0.01675072f, 0.01476775f, -0.02391913f, 0.04709896f, -0.03967670f, 0.00201829f, -0.01900502f, 
    0.04406831f, 0.03519659f, 0.00358622f, -0.06224202f, -0.03476352f, 0.02395753f, -0.03220844f, -0.04993535f, 
    0.01223529f, -0.00366928f, 0.00252959f, 0.00388909f, 0.00599670f, 0.00496544f, -0.04188446f, -0.01805795f, 
    0.02879570f, -0.00359920f, -0.01955163f, 0.03758448f, 0.00509121f, 0.03613413f, -0.02657964f, 0.02010494f, 
    -0.00980916f, -0.01869456f, -0.06248875f, -0.04062905f, 0.00197604f, -0.06783420f, 0.02619280f, -0.01995762f, 
    -0.00124198f, -0.05260806f, -0.03642203f, 0.03229308f, 0.01395149f, 0.01344154f, -0.04131116f, 0.02602989f, 
    0.04610624f, -0.04345923f, -0.04652926f, 0.00805265f, 0.01208504f, 0.00182703f, 0.04431409f, 0.03241054f, 
    -0.04600849f, 0.03175208f, 0.02006088f, -0.04892155f, -0.03942841f, 0.03210432f, -0.05480756f, 0.03246589f, 
    -0.03979289f, 0.02097001f, -0.05438031f, -0.00359991f, 0.04042124f, 0.02663417f, 0.02615024f, -0.03855943f, 
    0.00806787f, -0.04004014f, 0.04128570f, 0.02169060f, 0.00835047f, -0.01247825f, -0.05260515f, -0.01531443f, 
    0.00748433f, -0.01922990f, 0.03410400f, 0.04410017f, 0.04950256f, -0.00281941f, -0.00369269f, 0.00758509f, 
    -0.03932751f, 0.00735839f, 0.01271093f, -0.02055356f, -0.02698202f, -0.01804191f, -0.01855328f, 0.02599835f, 
    0.01970909f, -0.04482271f, 0.01473386f, 0.02012714f, -0.06455597f, 0.02402206f, 0.02928867f, -0.00344646f, 
    -0.01564416f, -0.03313873f, 0.00489088f, -0.01297880f, -0.01853835f, 0.03296308f, -0.00989123f, 0.00105512f, 
    0.01887074f, 0.03562981f, 0.03762444f, 0.00302121f, -0.05075002f, -0.00727859f, 0.00859438f, 0.03204512f, 
    -0.03106980f, -0.01400986f, 0.03057476f, 0.04167618f, -0.06340534f, 0.04147211f, -0.03709577f, 0.03458354f, 
    -0.03856455f, -0.05332302f, 0.02349862f, -0.04652504f, -0.05063058f, -0.00284313f, -0.02693961f, -0.05910513f, 
    0.01228935f, -0.01159406f, -0.01353882f, -0.00881702f, -0.06671187f, 0.00062769f, 0.03714221f, -0.00690419f, 
    -0.05095965f, 0.05381346f, 0.00130088f, -0.02448633f, -0.06517402f, -0.01935718f, 0.03518326f, 0.02231201f, 
    -0.03399473f, -0.03376725f, 0.04452102f, 0.01867830f, 0.02576382f, -0.03129273f, 0.00442768f, 0.04591933f, 
    -0.01365960f, -0.04256369f, -0.03474445f, -0.06265174f, 0.00819970f, 0.00414619f, -0.01358892f, -0.06236281f, 
    -0.01810352f, -0.02631871f, 0.02185544f, -0.02040381f, -0.00594518f, 0.04225916f, -0.03482834f, -0.01554753f, 
    0.01454972f, -0.02995699f, 0.01642677f, 0.02447249f, 0.00618510f, 0.00179608f, 0.03151938f, -0.00300023f, 
    0.04016586f, 0.03301410f, 0.02358632f, -0.01351617f, -0.06191141f, -0.04981407f, -0.05048248f, -0.00104431f, 
    0.02533556f, 0.03053555f, 0.02703417f, 0.01944436f, 0.02388429f, -0.06453943f, 0.04072755f, -0.03444857f, 
    0.02084506f, 0.03414601f, -0.03919553f, 0.01314158f, -0.00337469f, 0.01426275f, -0.06358057f, 0.04067055f, 
    0.14828558f, 0.29098350f, 0.21485712f, -0.10665893f, -0.06857724f, 0.11441574f, 0.09666250f, 0.04782775f, 
    -0.04646659f, 0.03696039f, 0.04532698f, 0.01094478f, 0.04062955f, 0.01678823f, -0.11397130f, 0.20123029f, 
    -0.10493340f, -0.02931744f, -0.37785158f, -0.12150801f, -0.07564403f, -0.05605986f, -0.06185480f, 0.17916030f, 
    -0.04094894f, 0.13985933f, -0.29697222f, -0.08450846f, -0.09338800f, 0.25130373f, -0.48639911f, 0.13273893f, 
    -0.08208768f, 0.06723054f, 0.00844719f, 0.00366246f, -0.13097504f, 0.01190645f, 0.59119076f, -0.09154786f, 
    0.17815836f, 0.17947420f, 0.06267882f, -0.00548864f, 0.21507344f, -0.05115898f, 0.02884429f, -0.00979277f, 
    -0.21844889f, -0.01498771f, 0.04187520f, 0.14739816f, 0.27299160f, -0.01274105f, 0.19672199f, -0.02591847f, 
    -0.07389534f, 0.11322836f, 0.01571715f, -0.14635718f, 0.01572794f, 0.10180876f, 0.02094477f, -0.04784264f, 
    -0.06081702f, -0.00939518f, 0.03993201f, -0.29858649f, -0.01812052f, -0.00773974f, -0.04985604f, 0.34315568f, 
    -0.29132426f, -0.09936886f, 0.27702472f, 0.01299273f, -0.05385967f, -0.17899612f, 0.15776660f, -0.22387625f, 
    0.01040537f, 0.25044504f, 0.02748407f, -0.15598194f, 0.04373006f, 0.14701295f, 0.08672584f, -0.02399805f, 
    0.05117902f, -0.06441886f, -0.15449968f, -0.12504442f, 0.27150646f, -0.05966138f, 0.21582548f, -0.00344204f, 
    -0.04023575f, 0.05459405f, -0.01742144f, 0.25507805f, -0.08947127f, -0.00239542f, -0.01371387f, -0.05750141f, 
    -0.18047567f, -0.24877353f, 0.12693019f, 0.06120438f, 0.22203156f, 0.13395403f, -0.04534363f, -0.09533490f, 
    -0.01174828f, -0.15195939f, -0.03936537f, -0.01954090f, -0.13164899f, 0.07081045f, -0.34052548f, 0.19482073f, 
    0.11511441f, 0.05577453f, -0.01131289f, -0.05259512f, 0.14965516f, 0.19063042f, -0.65717620f, -0.32174763f, 
    0.30588469f, -0.11742821f, -0.07694468f, 0.23736040f, -0.04642093f, -0.12104559f, 0.01855230f, 0.21025483f, 
    0.47410718f, 0.19632256f, 0.03852525f, 0.29005802f, 0.22169583f, 0.09805570f, 0.18152368f, 0.30758071f, 
    0.02587619f, 0.33852875f, -0.23674165f, -0.01306102f, -0.08303828f, 0.08737916f, -0.02055306f, -0.01996379f, 
    -0.15486540f, 0.71999198f, 0.25403097f, -0.27360541f, -0.14349543f, 0.11765114f, -0.09770949f, 0.02445936f, 
    0.07966270f, -0.19423540f, -0.02777754f, 0.30044687f, 0.35278535f, -0.03855847f, 0.07825927f, 0.03129396f, 
    -0.17648363f, 0.07394491f, 0.01712010f, 0.13113329f, -0.01871900f, -0.13090327f, 0.06223384f, 0.04619904f, 
    -0.16164036f, 0.14903170f, 0.07477043f, 0.00178280f, 0.09007870f, -0.24615465f, 0.14895870f, -0.08969571f, 
    -0.16580561f, -0.17673908f, -0.11173711f, -0.01072586f, 0.01092879f, -0.28580996f, -0.17609943f, -0.03779692f, 
    0.21447553f, -0.26119193f, -0.18511130f, 0.24646929f, 0.03006072f, 0.01113207f, -0.07926393f, -0.10643348f, 
    -0.03055869f, -0.12363936f, -0.11315742f, -0.29240841f, 0.06239352f, 0.09357583f, -0.15244420f, 0.21657194f, 
    0.10680145f, -0.08970832f, -0.08541843f, 0.15008111f, -0.02678000f, 0.03838956f, -0.01774172f, -0.04484527f, 
    0.05356371f, -0.09100596f, 0.04550024f, -0.06855375f, -0.08697421f, -0.23410094f, -0.03068659f, -0.06084921f, 
    0.09941427f, 0.32648781f, 0.14587879f, 0.07245640f, 0.00879655f, -0.06695075f, 0.14972925f, -0.03837791f, 
    -0.18822978f, 0.04195869f, 0.19662747f, -0.25707072f, -0.12389437f, -0.03506638f, -0.17650950f, -0.00886461f, 
    0.07921462f, 0.22459167f, 0.09851440f, -0.28555754f, -0.11893856f, -0.19749375f, -0.10705936f, 0.15410277f, 
    0.02981940f, -0.17624772f, 0.07511203f, -0.12431334f, -0.09722122f, -0.29381269f, -0.05032078f, 0.14155480f, 
    0.00595580f, -0.08639818f, 0.02706771f, 0.09061088f, -0.03249644f, 0.21468930f, -0.03269845f, 0.16899432f, 
    0.03399510f, 0.02256853f, 0.19138667f, 0.02505420f, 0.09943330f, -0.01678587f, -0.09108749f, 0.02063870f, 
    0.15582351f, -0.25336093f, -0.00768474f, 0.07491007f, 0.04448922f, -0.09978557f, 0.05597889f, 0.01803613f, 
    -0.34007308f, 0.12799215f, 0.04458303f, -0.11012091f, -0.05534615f, -0.13833377f, -0.04438862f, 0.09905492f, 
    -0.24132007f, -0.10466296f, 0.12945394f, 0.05340850f, 0.00352338f, 0.18117875f, 0.01345532f, 0.01050718f, 
    -0.09203468f, 0.34945476f, 0.15714638f, -0.04656401f, -0.04851364f, -0.02997625f, -0.04407699f, 0.06882650f, 
    0.07840418f, -0.03588151f, -0.12413631f, -0.12297469f, -0.04792593f, -0.01553599f, 0.10091510f, -0.02016593f, 
    -0.02577860f, -0.46141037f, -0.01980134f, -0.30597731f, -0.09856789f, -0.41100228f, -0.15881310f, 0.10346820f, 
    0.00684933f, 0.02670773f, -0.25679058f, 0.00449511f, -0.12745011f, 0.06036869f, -0.14528796f, -0.04826045f, 
    -0.01430093f, 0.18000966f, 0.02349493f, 0.05027127f, 0.00466904f, -0.06988223f, 0.00965662f, 0.01045250f, 
    0.02524939f, 0.22421655f, -0.05430254f, -0.00245913f, -0.12467797f, 0.12973361f, -0.04150071f, 0.10603093f, 
    0.01418810f, -0.09460131f, -0.13192518f, 0.05914749f, 0.07701104f, 0.05513149f, -0.07132485f, 0.12018348f, 
    -0.20176421f, 0.10209966f, -0.00623303f, 0.08212397f, -0.18805724f, -0.05721933f, 0.06859564f, -0.04445417f, 
    -0.04673978f, -0.46748045f, 0.26486647f, 0.10201357f, 0.04344679f, -0.00948747f, -0.16870573f, -0.21396595f, 
    0.01083123f, 0.04288617f, 0.20922704f, 0.11448982f, -0.09917121f, -0.01749581f, -0.05231412f, 0.13184905f, 
    0.17627054f, 0.01863300f, 0.01662280f, 0.04733009f, -0.00790631f, 0.14591415f, -0.08784109f, 0.14755073f, 
    0.09027193f, -0.03784802f, 0.17934373f, 0.07429096f, 0.17119658f, 0.07159062f, -0.00703954f, -0.00085698f, 
    -0.00522578f, 0.04165798f, 0.05638670f, -0.04230454f, 0.30086926f, 0.26611730f, -0.06811079f, -0.06665207f, 
    -0.04012715f, 0.10795596f, 0.15105949f, -0.06262747f, -0.01950131f, 0.01447924f, 0.04676078f, -0.10268724f, 
    -0.07218662f, -0.09220595f, 0.04350964f, -0.03337459f, -0.02484924f, 0.18603399f, -0.11559498f, -0.06759487f, 
    0.11270743f, -0.07836155f, 0.03197003f, 0.01477899f, -0.06107930f, -0.00887108f, 0.10626084f, 0.15867518f, 
    -0.05332978f, 0.17005973f, 0.06074721f, 0.10845866f, 0.08145372f, -0.07011968f, 0.02856783f, 0.17112890f, 
    0.02264027f, 0.14572617f, 0.27375445f, 0.02684098f, 0.03669064f, -0.13640010f, 0.20918274f, -0.04331221f, 
    -0.01217847f, -0.08853544f, 0.18068476f, 0.08957698f, 0.05421878f, -0.01636714f, 0.16638832f, -0.00986005f, 
    -0.10803387f, -0.25806862f, 0.04469930f, 0.17119592f, 0.35713115f, -0.04258659f, 0.20197399f, -0.05920649f, 
    -0.11195806f, 0.13125309f, 0.03674689f, 0.23077290f, -0.19248003f, -0.33512288f, 0.15353964f, -0.02661124f, 
    0.01818860f, -0.01785493f, 0.02551946f, -0.01803910f, -0.02810299f, -0.07471987f, -0.02119437f, -0.07420604f, 
    -0.03543533f, -0.18556616f, -0.15690035f, -0.04602044f, -0.07486010f, -0.16982448f, -0.39167485f, 0.16937895f, 
    0.05144947f, -0.01950910f, -0.09364247f, -0.04979927f, -0.24067977f, 0.04191642f, -0.09302002f, 0.08811425f, 
    0.08402222f, -0.00967306f, 0.05124269f, -0.31145093f, -0.09312214f, -0.11719767f, 0.04020230f, -0.09952390f, 
    0.19360769f, -0.08174467f, 0.10879952f, 0.10134779f, 0.12332025f, -0.02199027f, -0.20158625f, -0.15379897f, 
    -0.15982608f, -0.05839442f, -0.08467060f, -0.09149423f, -0.06521467f, 0.05447777f, 0.16924794f, 0.10814255f, 
    -0.01232671f, -0.02837180f, 0.22904456f, 0.16217807f, -0.03384633f, -0.03573911f, 0.09211323f, 0.10216656f, 
    0.11855600f, -0.00382979f, 0.35053548f, -0.17927073f, -0.07583295f, 0.08179652f, 0.17123008f, -0.23907648f, 
    -0.05262011f, 0.07129297f, -0.03662347f, 0.03684805f, -0.00826915f, -0.36859414f, -0.16806301f, -0.00680455f, 
    -0.03534464f, -0.05571671f, -0.00460605f, -0.14269547f, 0.24092537f, -0.14212587f, -0.20010540f, 0.18021265f, 
    -0.02056060f, -0.00419530f, -0.07706050f, 0.07720222f, 0.18848309f, -0.21257173f, 0.14012912f, 0.24352615f, 
    0.06061038f, 0.14518504f, 0.00861893f, 0.11246327f, 0.03303264f, -0.15307449f, -0.28688264f, 0.06853674f, 
    0.06740957f, 0.03156605f, 0.03955861f, 0.02566805f, -0.02687096f, -0.16414887f, -0.05064771f, 0.11449353f, 
    0.18394375f, -0.18126747f, -0.09420581f, -0.06316902f, 0.10573455f, 0.00487940f, 0.08299600f, 0.06800059f, 
    -0.04611697f, -0.05983132f, 0.03629022f, -0.05620719f, 0.01646351f, -0.00430941f, 0.04083877f, 0.02820474f, 
    0.02331356f, 0.02588745f, -0.00509901f, 0.02739061f, -0.05336328f, 0.03664899f, -0.02580884f, 0.00839948f, 
    -0.02926403f, -0.01895596f, 0.04291742f, 0.01638178f, -0.06239384f, 0.00996318f, 0.02336132f, 0.04707628f, 
    -0.00006496f, -0.06061008f, -0.03869785f, -0.04824669f, -0.01128141f, -0.05582589f, -0.02603782f, -0.02923691f, 
    -0.00269098f, -0.04425837f, -0.00015378f, 0.04579924f, -0.05383081f, 0.01550362f, 0.00264567f, -0.05298014f, 
    0.04727870f, 0.00519556f, -0.06510510f, -0.02963856f, -0.01222877f, 0.02368335f, -0.01434511f, -0.04397296f, 
    0.00989837f, -0.04726277f, -0.05834082f, 0.04800108f, 0.04007789f, -0.02020298f, -0.06088264f, 0.01823945f, 
    -0.06581193f, 0.02781869f, -0.05146613f, 0.03874970f, -0.03125321f, 0.04374276f, 0.01070742f, 0.04408108f, 
    -0.04440417f, -0.00235193f, 0.01285123f, 0.00659969f, -0.06080208f, -0.03295516f, 0.01726007f, -0.01971911f, 
    -0.03021896f, -0.00585632f, -0.01933141f, -0.03739863f, -0.00621856f, -0.01634418f, -0.00018632f, 0.02878422f, 
    -0.05211689f, -0.04298809f, -0.02232752f, -0.00081967f, -0.06241409f, 0.00247685f, 0.04254016f, -0.05914725f, 
    -0.00960834f, 0.00865934f, -0.01360568f, -0.01474893f, -0.01282044f, 0.01679058f, -0.03844693f, 0.04194989f, 
    0.02848081f, 0.04302029f, -0.00477905f, -0.02645354f, -0.04670811f, 0.04777783f, 0.01655969f, -0.01652330f, 
    -0.01212433f, -0.03656184f, 0.03750350f, 0.05163018f, -0.03724795f, 0.00841249f, 0.00121044f, 0.03579244f, 
    0.01522446f, 0.04507934f, -0.04811154f, -0.05674425f, 0.02492441f, -0.03144292f, 0.04119962f, 0.02358059f, 
    -0.00320746f, -0.03869006f, -0.03532210f, -0.04620915f, -0.05541979f, 0.00907253f, -0.04011501f, -0.02177837f, 
    -0.03415601f, -0.01643019f, 0.05322385f, 0.02313237f, -0.03278388f, -0.00671822f, -0.01285930f, -0.04054036f, 
    -0.02604079f, -0.06214765f, 0.03617612f, -0.01480416f, -0.03513980f, 0.01590077f, 0.01386151f, 0.03226487f, 
    -0.05957397f, -0.04523389f, -0.03594563f, 0.03386128f, -0.04199513f, 0.01590925f, -0.05091502f, 0.03184661f, 
    -0.05403033f, 0.03606416f, -0.00340157f, 0.04246946f, 0.03069626f, 0.03797269f, 0.03972792f, -0.02608964f, 
    0.03416771f, 0.01566168f, -0.01486370f, 0.03556694f, -0.05190475f, -0.03520687f, 0.01437510f, -0.03627605f, 
    -0.02850007f, 0.02884846f, -0.04605934f, 0.03762725f, 0.00460452f, 0.04470464f, -0.02939383f, 0.03265128f, 
    -0.06146247f, 0.01846803f, 0.04716788f, -0.01240265f, 0.03387048f, -0.03623068f, -0.01206492f, -0.02512240f, 
    -0.04069423f, -0.04683694f, -0.05372440f, -0.00742112f, 0.04285150f, -0.02650670f, 0.04289120f, -0.00402938f, 
    0.03849444f, 0.02799701f, -0.01370687f, -0.06496438f, 0.00883981f, 0.03183482f, -0.01775843f, 0.05034289f, 
    -0.01647246f, 0.04803458f, -0.01206161f, 0.01762206f, -0.06040933f, 0.03763930f, -0.02680200f, -0.00543558f, 
    -0.01597943f, 0.02083142f, -0.02977918f, 0.03012945f, -0.05050184f, 0.00848532f, -0.03443982f, -0.06412447f, 
    -0.00997513f, 0.03646125f, -0.00181175f, -0.04034823f, 0.05122125f, -0.03518566f, -0.01949344f, 0.04417324f, 
    0.00331182f, -0.05045880f, -0.06184644f, 0.00196706f, 0.03836456f, -0.04880382f, -0.02950564f, 0.02167512f, 
    -0.05430755f, -0.00816858f, 0.01456056f, -0.00656132f, 0.00110797f, 0.00009978f, -0.00309406f, 0.04920921f, 
    -0.01399738f, -0.01061413f, 0.03246092f, -0.00569900f, -0.05302857f, 0.03234198f, 0.05193912f, 0.04428691f, 
    -0.06361131f, -0.01235347f, -0.03538448f, -0.04938779f, -0.03544780f, 0.05028976f, -0.00872792f, 0.01328285f, 
    -0.04443428f, -0.03886774f, 0.05173194f, -0.01997268f, -0.06424797f, -0.05814169f, -0.05107469f, -0.03309433f, 
    0.04971824f, -0.03417361f, -0.00020255f, -0.01965123f, 0.02258197f, 0.02521306f, 0.02857585f, -0.04972262f, 
    -0.00900647f, 0.04235392f, -0.04807816f, -0.04748099f, -0.04939003f, 0.02808836f, 0.03795063f, 0.03281758f, 
    0.04347038f, 0.01316375f, 0.01481877f, -0.05671430f, -0.02144830f, -0.05454137f, -0.02006510f, 0.04118646f, 
    -0.01200478f, -0.02039962f, -0.04426835f, -0.04482142f, -0.06108033f, 0.02113698f, 0.00443937f, 0.01639021f, 
    -0.02753761f, 0.02066456f, 0.04547938f, -0.06617532f, 0.03274182f, -0.06376531f, 0.03486856f, 0.04139452f, 
    0.02336622f, -0.02545011f, -0.01541016f, -0.04840394f, 0.00898353f, -0.00464382f, -0.00092655f, 0.05301822f, 
    -0.03772756f, -0.05001746f, -0.05707792f, -0.03762589f, -0.04711086f, 0.03497150f, 0.00096554f, -0.03690284f, 
    -0.00245942f, 0.01486979f, -0.06043961f, -0.06174564f, 0.00133617f, -0.03700642f, -0.06139182f, 0.02668510f, 
    -0.03835982f, 0.01813511f, 0.04120195f, 0.00587108f, 0.03346826f, 0.01539781f, -0.03037300f, 0.02622174f, 
    -0.06689157f, 0.03072370f, -0.01074858f, 0.02115215f, 0.02547971f, -0.04503083f, -0.01952704f, -0.02615794f, 
    -0.06427246f, 0.02330132f, 0.04261973f, 0.05190458f, 0.02518544f, -0.04370061f, -0.03266706f, -0.06149623f, 
    0.00209413f, -0.04131218f, 0.02723040f, 0.02650609f, -0.01645339f, -0.00362677f, -0.04886471f, -0.00161913f, 
    -0.04519233f, 0.03403433f, 0.01112701f, -0.00712424f, -0.05069833f, 0.03617810f, 0.03979803f, -0.01816226f, 
    -0.02948497f, 0.05062702f, -0.05510264f, -0.03424019f, -0.06460077f, -0.04487716f, 0.03546089f, -0.03108998f, 
    -0.03825131f, 0.03106052f, -0.06035670f, 0.02721624f, -0.05984954f, 0.01757998f, 0.00656724f, -0.03648020f, 
    0.04127568f, 0.04779190f, -0.06200990f, -0.00545299f, -0.03902883f, -0.02701685f, 0.00670699f, 0.03319908f, 
    0.02456220f, 0.05189217f, -0.03047870f, -0.04966186f, -0.00793464f, 0.02912872f, 0.01845755f, -0.03707023f, 
    -0.02066827f, 0.02273298f, -0.02266840f, -0.05280247f, 0.00058662f, -0.03644402f, 0.03757807f, 0.02850965f, 
    0.02058358f, 0.03006968f, -0.03985037f, -0.00726007f, -0.00420931f, 0.02406261f, 0.02303569f, -0.02982186f, 
    -0.04795279f, 0.00555066f, -0.05756316f, -0.00910183f, -0.06060323f, -0.01817607f, -0.01530385f, 0.01630875f, 
    0.04305644f, 0.05676034f, 0.03530130f, 0.04288270f, -0.04052667f, 0.01429062f, -0.06565715f, -0.00661829f, 
    0.03741914f, 0.01285840f, 0.03260469f, -0.04726166f, 0.02849070f, -0.00243756f, -0.04027166f, 0.04802322f, 
    0.01091686f, -0.06433737f, 0.03963885f, -0.05726016f, 0.01198672f, -0.02061175f, 0.01269219f, 0.03788211f, 
    -0.05205185f, -0.02475557f, -0.06749884f, 0.03505811f, -0.01122453f, -0.04337875f, -0.03351325f, -0.00832582f, 
    0.04069938f, -0.00902279f, -0.06571698f, -0.03386978f, -0.00170615f, -0.01114048f, 0.00919903f, -0.02175867f, 
    0.04619527f, -0.00865685f, 0.01393675f, -0.06582569f, 0.02610273f, -0.00467623f, -0.04593410f, -0.06128846f, 
    0.02002470f, -0.02364736f, -0.00137064f, 0.04508951f, -0.04493645f, -0.02341360f, 0.00455778f, -0.00751628f, 
    0.04776398f, -0.05126313f, 0.04277817f, 0.00202743f, -0.01513935f, -0.06354021f, 0.00939787f, -0.02438947f, 
    0.00013345f, -0.04709952f, 0.02977526f, 0.01316322f, -0.01382927f, -0.05099623f, -0.05969620f, -0.05609238f, 
    0.02186201f, 0.01864173f, 0.00521773f, 0.04157699f, 0.02619510f, -0.06131369f, 0.00475822f, -0.00975503f, 
    -0.05033410f, 0.01274926f, 0.01874846f, -0.02448217f, -0.02430580f, 0.00274563f, -0.05783976f, -0.02363694f, 
    -0.01652868f, -0.02984549f, -0.03071337f, 0.00156158f, -0.03516817f, 0.01559579f, -0.00806957f, -0.05138556f, 
    -0.04179531f, 0.00368603f, -0.04175109f, 0.03314418f, 0.03188472f, -0.06611409f, -0.05863708f, 0.02206603f, 
    -0.00807619f, 0.03291008f, -0.04169394f, 0.04630447f, -0.05792511f, 0.04594947f, -0.01391033f, -0.00483645f, 
    0.04331299f, -0.01680839f, 0.00579462f, 0.01522518f, 0.02646339f, 0.04597852f, -0.05127854f, -0.03598648f, 
    -0.05942559f, -0.01324092f, -0.01915382f, -0.05971432f, -0.02158928f, -0.01017026f, -0.05159942f, -0.02780913f, 
    -0.05621389f, 0.01233988f, -0.02558454f, -0.02172589f, 0.01102272f, -0.04935328f, 0.01169841f, -0.02978473f, 
    0.04072252f, 0.03436749f, 0.04313869f, -0.04739590f, -0.03446824f, 0.02930967f, 0.03809186f, -0.02332938f, 
    0.02313860f, 0.01843438f, 0.04337931f, 0.03617013f, -0.04535611f, -0.00710339f, -0.03363433f, -0.05283843f, 
    0.01076148f, 0.14415973f, 0.11597063f, -0.13879922f, 0.08692093f, 0.03588651f, 0.10536543f, 0.25212872f, 
    -0.14887363f, 0.11634965f, 0.09276243f, -0.09876172f, 0.00586284f, 0.05266799f, -0.25442350f, -0.14703242f, 
    -0.19613531f, -0.02201920f, 0.19789998f, 0.00609442f, 0.21343148f, 0.07535224f, 0.15969323f, 0.19826247f, 
    0.03749630f, -0.28092465f, 0.07631136f, 0.09009405f, -0.37979135f, -0.12238894f, 0.22164533f, 0.12061749f, 
    0.27434453f, 0.18040295f, -0.01337053f, -0.08164858f, 0.19689509f, -0.05904362f, 0.23070903f, -0.01121529f, 
    0.10414656f, 0.02640287f, -0.09270936f, 0.08468121f, 0.08477374f, -0.01646865f, -0.02817078f, -0.05871413f, 
    -0.03582217f, -0.03938376f, -0.10372949f, -0.31088585f, 0.01320647f, 0.13015381f, 0.10452028f, 0.07283819f, 
    0.25690621f, -0.24186818f, -0.27220160f, -0.09597003f, 0.01612485f, 0.15525845f, 0.17039858f, 0.03429776f, 
    -0.05492682f, -0.14622833f, -0.10731546f, -0.28838798f, 0.00317785f, -0.00074236f, -0.17092991f, -0.05666637f, 
    -0.00248657f, 0.12496017f, 0.04683573f, -0.12516099f, -0.05197033f, 0.13664848f, -0.02416208f, 0.04552702f, 
    0.11737230f, -0.04167822f, 0.03321242f, 0.02796636f, 0.02237759f, -0.23509787f, 0.18648417f, 0.12615398f, 
    0.07522846f, 0.03341635f, 0.06426579f, -0.17754322f, 0.09072810f, -0.03996003f, 0.04573767f, -0.19791663f, 
    -0.06758950f, -0.13918908f, 0.07440257f, -0.11505052f, -0.12038612f, -0.31087300f, 0.10326467f, 0.09949414f, 
    -0.00941138f, -0.07009035f, 0.00627277f, 0.15552986f, 0.10571451f, -0.01146485f, -0.24525286f, -0.03505267f, 
    0.01854473f, 0.01777294f, -0.02877859f, -0.03078646f, 0.01864329f, 0.02944249f, 0.04671733f, 0.24846983f, 
    -0.19730440f, -0.27008450f, -0.06547299f, 0.07583721f, -0.06012481f, 0.12903169f, 0.13639353f, -0.01222971f, 
    0.27341029f, 0.09318541f, 0.00859853f, 0.13019902f, -0.11745839f, -0.23329584f, 0.06093876f, 0.21214484f, 
    -0.04976229f, 0.17589097f, 0.18755707f, -0.15178381f, -0.24512987f, 0.00543870f, 0.03019709f, -0.04492694f, 
    -0.01801381f, -0.12079218f, -0.15641904f, -0.03859422f, -0.21412425f, 0.07876343f, -0.06949701f, 0.07677092f, 
    -0.03852892f, -0.07915460f, 0.01713816f, 0.07093459f, 0.08085833f, -0.10798183f, 0.00782463f, -0.16159858f, 
    -0.23986663f, -0.23514695f, -0.04357866f, -0.00355820f, 0.45370522f, -0.12476887f, -0.26102847f, -0.14061376f, 
    0.04943904f, -0.04315170f, 0.26898524f, -0.05279121f, -0.05055068f, -0.18898474f, 0.13341999f, -0.08903984f, 
    -0.15544210f, 0.05168871f, -0.08888421f, 0.06420496f, 0.19435911f, 0.04422615f, 0.29318374f, -0.15415590f, 
    -0.17928696f, -0.11971336f, 0.08713759f, 0.05966222f, 0.22281864f, 0.22517982f, 0.09423491f, 0.33628902f, 
    -0.11534011f, -0.21584359f, 0.07543301f, -0.14900815f, -0.10320255f, -0.10102759f, -0.02835462f, 0.03919556f, 
    0.21824676f, -0.12088303f, -0.22512132f, -0.04326941f, 0.15088007f, 0.06750592f, 0.13946250f, 0.16893683f, 
    0.02915311f, -0.08345613f, 0.07112519f, -0.20075364f, -0.12421752f, -0.11741828f, -0.07172473f, -0.30974779f, 
    0.06594775f, -0.15889809f, 0.07033774f, -0.36193299f, -0.40550461f, -0.18356739f, 0.12423012f, 0.07695118f, 
    0.22407645f, -0.44683805f, -0.10702901f, -0.02797745f, -0.03600521f, -0.02461076f, -0.00433859f, 0.08815978f, 
    -0.02945406f, 0.00860225f, 0.03767864f, 0.04528826f, -0.06488567f, -0.12034400f, -0.28802919f, -0.20546758f, 
    0.24960126f, 0.23755896f, -0.19191158f, 0.15441725f, -0.31182054f, -0.52964383f, 0.08736829f, -0.15345524f, 
    0.10709003f, 0.13234697f, 0.13001870f, 0.11441082f, -0.13670433f, -0.10066397f, -0.34686533f, -0.12214164f, 
    0.04002337f, 0.15820919f, 0.09896874f, 0.10472910f, 0.24963684f, -0.27530316f, -0.18959408f, -0.05810865f, 
    0.00935025f, -0.01052929f, 0.06488916f, -0.16463959f, -0.07949485f, 0.14047855f, -0.06189781f, -0.12174959f, 
    -0.22190130f, -0.01499008f, -0.00528507f, 0.22561581f, -0.14371435f, -0.04062923f, -0.08943551f, -0.23719738f, 
    0.09462856f, -0.33451056f, -0.24230245f, -0.07447124f, 0.05490426f, 0.18234767f, 0.01261502f, 0.07343262f, 
    0.20146273f, -0.08652179f, -0.16764647f, 0.18256468f, -0.08500145f, 0.10824461f, 0.10489200f, 0.09185308f, 
    0.09787911f, 0.01078893f, -0.02395233f, -0.16560966f, -0.07493281f, 0.08046842f, 0.14723773f, 0.09217900f, 
    0.10144190f, -0.07762971f, 0.10174531f, 0.01861783f, -0.11750021f, -0.03824685f, -0.17698249f, -0.22284837f, 
    0.03573072f, -0.09646723f, 0.07720203f, 0.13541445f, 0.14768697f, 0.23338333f, -0.04269269f, -0.23118502f, 
    -0.08702967f, 0.04108092f, 0.02466537f, -0.05577339f, 0.03433955f, -0.21845549f, -0.30391702f, -0.05112478f, 
    -0.11585121f, 0.07513877f, -0.11096951f, -0.04704962f, -0.15647256f, -0.06504238f, 0.07251692f, -0.02449211f, 
    0.00769677f, 0.01757322f, 0.16238697f, 0.09245075f, -0.16731697f, -0.04898154f, 0.28036141f, 0.19730106f, 
    -0.06521713f, -0.05511379f, -0.15199779f, 0.02928705f, -0.05597402f, -0.09401189f, -0.02954342f, -0.19806989f, 
    0.14447169f, -0.08028296f, 0.23178974f, 0.17096558f, 0.01023861f, 0.05797786f, 0.09021814f, -0.10098682f, 
    0.11435360f, 0.22060207f, -0.01918388f, 0.12093791f, 0.01946197f, 0.18690374f, 0.07564265f, 0.09648009f, 
    0.01642376f, -0.14399433f, -0.32177165f, 0.11514448f, 0.22682241f, 0.18775663f, -0.07343627f, -0.01294634f, 
    -0.12717591f, -0.38308102f, -0.01869561f, 0.09017407f, -0.09889998f, 0.05635745f, -0.07265854f, 0.00805697f, 
    -0.08370562f, -0.11668140f, 0.01872921f, 0.15972295f, 0.03327570f, 0.14389902f, 0.20754099f, 0.17786036f, 
    -0.18707457f, 0.02509875f, 0.03887748f, -0.16354907f, 0.12076280f, 0.14419189f, 0.10537187f, 0.13614628f, 
    0.02756867f, -0.04382089f, -0.02565147f, 0.20131220f, 0.02751498f, 0.26228446f, 0.23028898f, -0.23222306f, 
    0.10591731f, -0.03971501f, 0.03315384f, -0.01736066f, -0.09697524f, 0.08938897f, -0.10733552f, 0.06171615f, 
    -0.12524398f, 0.13243681f, -0.05528331f, -0.00866216f, 0.13216847f, -0.06435763f, 0.01017222f, 0.18310533f, 
    -0.35063022f, -0.43950176f, 0.06980046f, -0.09717084f, -0.07022129f, -0.31312078f, 0.17277411f, 0.04822566f, 
    -0.15001458f, -0.33592999f, 0.18722455f, 0.15477981f, 0.13729146f, 0.01527263f, -0.00997034f, -0.19509135f, 
    -0.08107474f, 0.18206213f, 0.13969338f, -0.05315911f, 0.07161341f, -0.12186501f, -0.02812999f, -0.07466824f, 
    0.21661836f, 0.12247150f, 0.14598820f, -0.36725682f, -0.20835115f, 0.00968993f, 0.16664512f, 0.27572417f, 
    0.03608633f, -0.34875074f, -0.17954002f, -0.38795990f, -0.25687394f, 0.06114681f, -0.02743722f, 0.14385998f, 
    0.25718251f, -0.02139746f, 0.12764283f, 0.21661842f, 0.18070178f, -0.16468231f, -0.23934114f, -0.01916052f, 
    -0.01559988f, 0.11123180f, -0.11499016f, -0.02436806f, 0.06800235f, -0.16863243f, 0.01603317f, -0.02809075f, 
    0.19850340f, 0.14268868f, -0.03124520f, 0.15095842f, 0.09105356f, 0.10239272f, 0.20161410f, -0.21229298f, 
    -0.30034098f, -0.07416180f, 0.00905818f, 0.11481681f, -0.01866162f, -0.15639867f, -0.11204764f, 0.02282113f, 
    0.20918274f, -0.08873449f, 0.02902010f, 0.05233150f, -0.03923798f, -0.03531434f, 0.18937638f, 0.13734041f, 
    0.13183594f, 0.27602133f, -0.30513045f, 0.13183384f, 0.07324991f, 0.06069978f, -0.06069449f, -0.09486267f, 
    0.01924473f, 0.17145088f, -0.34252375f, -0.19666956f, 0.19400965f, 0.12829676f, 0.01346388f, -0.14174280f, 
    -0.00721696f, -0.02610651f, -0.08849759f, 0.13674308f, -0.18827279f, 0.06995682f, 0.11676275f, 0.04348564f, 
    0.10765664f, 0.00685058f, 0.01335983f, -0.22773451f, 0.04911852f, -0.03528525f, 0.13056363f, 0.16807809f, 
    -0.08236353f, -0.06000272f, 0.01480133f, -0.18002950f, -0.23719226f, -0.23259656f, 0.10696503f, -0.14525157f, 
    -0.03635533f, 0.06623808f, 0.13562727f, 0.00545342f, 0.01290576f, 0.17026603f, -0.20121539f, -0.07010895f, 
    0.01031076f, 0.20558615f, 0.03710938f, 0.09060965f, -0.19874258f, 0.18974429f, 0.17373355f, -0.00779911f, 
    0.21875069f, 0.31613374f, 0.20479570f, -0.07507507f, 0.09241538f, 0.01806132f, 0.02752330f, 0.00527038f, 
    -0.36342683f, 0.02933199f, 0.13125490f, -0.00849314f, 0.10389253f, -0.00416410f, -0.03679190f, -0.05349114f, 
    0.02071338f, -0.13011719f, -0.02127497f, 0.11789142f, -0.09559998f, -0.10422622f, -0.00617702f, -0.12421495f, 
    0.05394735f, -0.10952049f, 0.09533535f, 0.46392712f, -0.06007954f, -0.06445394f, -0.01576754f, -0.13305031f, 
    -0.06420334f, -0.01418991f, -0.01262961f, 0.12703866f, 0.05403662f, -0.15467487f, 0.03247276f, -0.17779198f, 
    0.05098877f, 0.10130777f, 0.16555128f, -0.04083343f, 0.01258362f, 0.10661427f, -0.12078320f, 0.09589028f, 
    -0.04210280f, 0.09817957f, 0.07784920f, -0.15357089f, 0.00468258f, -0.02717708f, 0.19524927f, 0.24949855f, 
    -0.02056663f, -0.02786338f, 0.09136920f, 0.03445179f, 0.19879682f, 0.15182911f, 0.14662737f, 0.26167628f, 
    0.22447947f, 0.07688989f, 0.01643084f, 0.07896272f, 0.02485711f, 0.13833846f, 0.03409725f, 0.01483855f, 
    0.10676307f, 0.16386485f, 0.08490452f, -0.02641773f, 0.06012597f, -0.00600363f, 0.21237999f, -0.07138179f, 
    0.17266461f, 0.18850677f, -0.07926273f, -0.00430364f, 0.09793739f, -0.22535744f, 0.11435258f, -0.02397881f, 
    0.12136675f, -0.05019463f, 0.18574251f, -0.06324180f, -0.04174279f, -0.11705072f, 0.09991041f, 0.04071989f, 
    0.05167441f, -0.06295692f, -0.05083461f, 0.01004705f, -0.04748157f, -0.03621102f, -0.05058113f, 0.00445980f, 
    0.04912753f, 0.02178785f, -0.02376085f, 0.09692066f, 0.17018530f, 0.02691645f, 0.09935451f, 0.06713764f, 
    0.04035573f, 0.11418912f, 0.18444608f, -0.17178652f, -0.17647743f, -0.16256331f, -0.00841391f, -0.05435772f, 
    -0.07891754f, 0.00549331f, 0.19532204f, -0.17214751f, -0.05019642f, -0.25665957f, 0.07081407f, 0.12641907f, 
    -0.06958428f, -0.02389004f, -0.06175178f, -0.07752700f, -0.16648227f, -0.08664510f, 0.12648062f, 0.06905520f, 
    0.07463772f, 0.13391638f, -0.05520355f, 0.12161075f, 0.04024364f, 0.18233424f, 0.00808282f, 0.10644919f, 
    0.15604976f, 0.14553759f, 0.01542170f, -0.01751391f, 0.08927033f, 0.08157928f, 0.27426043f, -0.08797299f, 
    0.08577307f, -0.15250486f, 0.14764418f, 0.03659207f, 0.08066329f, -0.06427004f, 0.10580671f, -0.08204105f, 
    0.12326674f, -0.18486983f, 0.08240776f, 0.18224974f, 0.19958164f, -0.11149675f, 0.07821216f, 0.11584485f, 
    -0.05011401f, -0.00302780f, -0.00992721f, 0.08720142f, -0.03111994f, 0.06729929f, -0.13004653f, 0.01296575f, 
    -0.08557183f, -0.20115039f, 0.13391002f, -0.03867586f, -0.03787146f, 0.15774493f, -0.02851736f, -0.10786814f, 
    -0.08258878f, -0.04873763f, 0.24397716f, -0.03593378f, -0.04043537f, 0.01400559f, -0.04394295f, -0.09836476f, 
    -0.06465661f, -0.21606416f, -0.36462831f, -0.14637230f, -0.01588812f, -0.02877782f, -0.26415312f, 0.14608698f, 
    0.13118164f, -0.04469451f, 0.11128186f, -0.07633482f, -0.09497707f, -0.12444345f, -0.09641571f, -0.14058354f, 
    -0.16768411f, -0.06190366f, -0.00459224f, 0.00282302f, -0.09455656f, -0.32656541f, 0.17758134f, -0.05855482f, 
    -0.14169109f, 0.10043510f, 0.04443404f, 0.06725912f, 0.01426382f, -0.07943159f, 0.14390926f, -0.11156138f, 
    -0.14925818f, 0.15081294f, -0.01286595f, 0.03540656f, -0.03511867f, -0.13177855f, -0.06807315f, -0.12782052f, 
    -0.17711158f, 0.03842195f, 0.08948598f, -0.02238201f, 0.02040198f, 0.02707537f, 0.06766918f, 0.00253018f, 
    0.05221782f, -0.11858343f, -0.12890705f, 0.07420448f, -0.06827173f, -0.16654953f, 0.08020136f, 0.16272181f, 
    0.14490323f, 0.09401633f, -0.12623501f, 0.30000266f, -0.09074762f, -0.04291827f, 0.08899365f, 0.07508649f, 
    -0.05916564f, -0.02466515f, 0.01777415f, -0.29727030f, -0.12792960f, 0.00415252f, 0.03536316f, 0.10347726f, 
    0.06098941f, 0.08169716f, 0.11521661f, 0.16354936f, -0.03544917f, -0.03367234f, -0.02494468f, 0.10283520f, 
    -0.09626594f, 0.13686569f, -0.03946945f, -0.05099094f, 0.02729889f, 0.35609710f, 0.05280736f, -0.15810224f, 
    0.00295458f, -0.17355868f, -0.02484454f, -0.01828392f, -0.13624480f, -0.08286162f, -0.04017200f, -0.03348724f, 
    -0.09552491f, -0.05279199f, -0.06925453f, 0.16415325f, -0.03485888f, 0.02363887f, -0.24457553f, 0.03494729f, 
    0.08354158f, 0.44443738f, -0.03388347f, -0.06207862f, 0.08857725f, -0.10375365f, 0.09659601f, 0.07388721f, 
    0.05188816f, -0.01972895f, 0.05296610f, -0.04680414f, -0.03394584f, -0.01272325f, -0.01747399f, 0.04545897f, 
    -0.04521246f, 0.02566874f, -0.02322680f, -0.03109195f, -0.03424624f, 0.02677300f, -0.00291845f, -0.01538260f, 
    -0.02987348f, -0.05083833f, -0.04945404f, -0.00960357f, 0.03885177f, -0.06022092f, -0.01986948f, -0.01309145f, 
    0.05153805f, 0.01582799f, -0.02718573f, 0.02548547f, 0.00132331f, 0.05152895f, 0.06028623f, 0.06087841f, 
    0.02101524f, -0.03873764f, -0.02621406f, 0.04692036f, -0.03812586f, 0.02667830f, 0.04226569f, 0.00145310f, 
    0.04892261f, -0.01281702f, -0.00402968f, -0.00999524f, -0.00674137f, -0.04218084f, -0.02018117f, -0.03144637f, 
    0.00830090f, 0.01315778f, -0.04643091f, 0.00710277f, -0.01462414f, 0.00631208f, -0.02386689f, 0.01583421f, 
    0.05626313f, -0.05430449f, 0.01235187f, 0.03648873f, -0.05246175f, -0.03910924f, -0.01426640f, -0.04829057f, 
    0.00935135f, -0.01884115f, 0.00335669f, -0.03422340f, -0.04795774f, -0.06417503f, 0.01188863f, 0.01284362f, 
    -0.02870999f, 0.03567871f, -0.02225672f, -0.02284355f, -0.00998649f, 0.04116915f, -0.05923558f, -0.05012461f, 
    -0.02655968f, -0.05622702f, -0.02098042f, -0.04305992f, -0.00787577f, 0.02840831f, -0.01873374f, -0.06496706f, 
    -0.00107410f, -0.02354771f, -0.04784407f, -0.02378796f, -0.04623446f, -0.02423138f, 0.02905505f, -0.01213230f, 
    0.04155649f, -0.01620997f, -0.02007608f, -0.00305618f, -0.01465446f, -0.04979254f, 0.03835933f, 0.02702090f, 
    0.02128571f, -0.06048141f, -0.03073374f, 0.01574518f, 0.01385129f, -0.00853699f, -0.00713052f, 0.01999750f, 
    0.03871216f, -0.00802068f, 0.03300655f, -0.01310035f, 0.04955414f, -0.03970737f, -0.02002790f, 0.01824463f, 
    -0.04948195f, -0.02787602f, -0.04258926f, 0.01953429f, -0.05623472f, -0.06201411f, -0.01138335f, -0.01347947f, 
    -0.02657989f, -0.00231005f, -0.04182148f, -0.05094522f, 0.02314922f, -0.00135466f, 0.00283591f, 0.02678486f, 
    -0.02806454f, 0.01458354f, -0.00409193f, -0.05235263f, -0.02240966f, -0.06259097f, 0.00402552f, 0.00432888f, 
    0.02454137f, 0.03203070f, 0.03656796f, -0.00783405f, -0.03103095f, -0.04369667f, 0.05211062f, 0.02507051f, 
    -0.03425938f, -0.06462645f, -0.04148487f, -0.01305149f, -0.01806066f, -0.05419057f, -0.02795929f, 0.03295003f, 
    -0.03685612f, 0.04134407f, -0.01835411f, -0.06206270f, 0.01352875f, 0.03842169f, -0.02748778f, -0.02333533f, 
    0.04665971f, 0.02485267f, 0.02003259f, -0.05149160f, -0.01063263f, -0.02961923f, -0.05904249f, 0.00176581f, 
    0.02776117f, -0.03725141f, 0.01506683f, 0.03836434f, -0.02625757f, -0.00035630f, 0.00782617f, -0.00456761f, 
    -0.03280523f, 0.00630128f, 0.04348714f, 0.04307689f, -0.03876847f, 0.02931378f, 0.05605336f, 0.01039741f, 
    0.02724992f, -0.00346257f, 0.03005326f, -0.00749737f, 0.02062126f, 0.02741434f, -0.05901438f, -0.03225985f, 
    -0.01413371f, -0.06929490f, 0.05070673f, -0.03661077f, 0.01608552f, -0.04550485f, -0.04233338f, -0.00782016f, 
    0.01906684f, 0.04414716f, -0.01888894f, -0.02104574f, -0.04949652f, 0.04446132f, 0.00732454f, 0.02537667f, 
    -0.03695266f, -0.02634182f, 0.01540564f, -0.00686814f, -0.05278587f, 0.00219005f, -0.00184613f, -0.05476860f, 
    -0.02573969f, -0.01621459f, 0.02043233f, 0.01228356f, -0.05993547f, -0.02312567f, -0.01444115f, 0.04085501f, 
    0.00364434f, -0.03990549f, -0.00667762f, 0.01492708f, -0.04453077f, -0.01196152f, 0.05222687f, 0.01405763f, 
    -0.04805895f, -0.03194683f, -0.02545498f, 0.03697412f, -0.02573722f, 0.04333777f, -0.02284572f, -0.05079794f, 
    -0.02177965f, -0.02841199f, -0.01387145f, -0.00323981f, -0.03464256f, 0.02879967f, 0.02100474f, 0.03330070f, 
    -0.01122370f, 0.02702846f, -0.02533101f, -0.04588593f, -0.00806221f, 0.02673691f, 0.00988686f, 0.01480215f, 
    -0.03606953f, 0.01161497f, 0.02257233f, 0.02883513f, -0.06383607f, -0.03024588f, -0.03636068f, -0.02043815f, 
    0.03008170f, 0.02035011f, 0.00362197f, -0.02774786f, 0.00821945f, -0.05895135f, 0.03762040f, 0.03941562f, 
    -0.01414679f, 0.03600748f, -0.03784964f, -0.01477597f, -0.06073396f, 0.03889822f, 0.00948909f, -0.03619692f, 
    -0.42919853f, -0.41840836f, -0.02093441f, 0.08663546f, -0.02229999f, 0.04326788f, 0.01234579f, 0.03940125f, 
    -0.18652624f, 0.20877446f, -0.15297291f, 0.07383137f, 0.10696400f, -0.07099494f, 0.07818746f, 0.18077275f, 
    0.11915566f, 0.07302240f, -0.01960914f, -0.04318021f, 0.02512873f, 0.14361043f, -0.04730005f, -0.16512321f, 
    0.05967686f, -0.11032912f, -0.11208826f, -0.36693826f, -0.29528639f, -0.57159519f, -0.12217567f, -0.00410296f, 
    -0.37302196f, -0.09568936f, -0.02062302f, -0.04047292f, 0.00477217f, -0.59189326f, -0.68152446f, -0.14361653f, 
    0.04742541f, -0.13238023f, -0.06548601f, -0.05285076f, -0.00811476f, -0.16058794f, -0.30312136f, -0.05149405f, 
    0.06639058f, -0.10836829f, 0.16505109f, -0.03534287f, -0.07927415f, 0.00079799f, 0.04837361f, -0.21605210f, 
    -0.94595438f, 0.09430595f, -0.23475038f, 0.23308189f, 0.09101401f, 0.14622799f, 0.07024747f, -0.18137990f, 
    -0.16422100f, -0.02246849f, -0.08175480f, -0.10100518f, 0.04399774f, 0.13317208f, 0.09879322f, 0.07677115f, 
    -0.07109948f, -0.46430981f, -0.40632200f, -0.10442087f, 0.08813521f, -0.13248880f, 0.09073363f, -0.00733160f, 
    0.09454141f, 0.19670947f, 0.39586085f, 0.34057966f, -0.04013085f, -0.09689210f, 0.02938977f, 0.09574168f, 
    -0.03116571f, 0.05991036f, 0.00829758f, -0.23097579f, -0.44349706f, 0.10491114f, 0.02596774f, -0.16832142f, 
    -0.09218276f, 0.19202985f, 0.01980224f, 0.15308227f, 0.27699140f, 0.29767793f, 0.11949723f, 0.09493886f, 
    0.20391744f, 0.06084132f, 0.08144889f, 0.05071125f, 0.39275801f, 0.13678691f, 0.13338935f, 0.02662362f, 
    0.03356562f, 0.12846473f, 0.12248508f, 0.02392903f, 0.07018699f, -0.08945808f, -0.04249225f, -0.26220027f, 
    0.12816647f, 0.04680410f, -0.00714086f, 0.15864992f, -0.02534677f, 0.08089927f, 0.03160079f, -0.15459202f, 
    0.00107837f, -0.14104256f, 0.08050677f, -0.23310314f, 0.09971409f, 0.00219335f, 0.05237042f, -0.32356396f, 
    -0.13687523f, -0.20968242f, 0.03138762f, -0.34395516f, -0.30052680f, 0.01350465f, 0.10104214f, -0.03665957f, 
    0.06217922f, 0.15765214f, 0.21871436f, -0.12716654f, 0.04809050f, 0.12287727f, 0.11269910f, -0.01416971f, 
    0.17588238f, -0.28078353f, -0.35089636f, -0.17771335f, -0.15446481f, -0.03678309f, 0.03431469f, 0.15597965f, 
    0.12572515f, -0.02801433f, -0.24341810f, -0.06020077f, 0.43311545f, -0.02321494f, -0.04984754f, -0.16920134f, 
    0.07181645f, 0.02693567f, -0.14115338f, 0.29920933f, -0.28299916f, 0.10348512f, -0.04100988f, 0.00231545f, 
    0.05811910f, 0.26839641f, 0.09069564f, 0.06771812f, -0.07497273f, 0.01382645f, -0.30254215f, -0.37986991f, 
    -0.01454495f, 0.10587815f, -0.04194164f, 0.10358451f, 0.18858987f, 0.61357242f, -0.13248652f, -0.48963282f, 
    -0.19581755f, -0.13869038f, -0.21116087f, -0.09788112f, 0.09174722f, 0.00926307f, -0.23073867f, -0.46809536f, 
    -0.11849985f, -0.21320677f, 0.07904066f, 0.11122736f, 0.24125841f, 0.03701628f, 0.14788955f, -0.02936314f, 
    -0.07610096f, -0.00538862f, -0.16407450f, -0.06812628f, 0.01071088f, 0.09006677f, 0.05035920f, 0.08209153f, 
    -0.28716025f, -0.29323158f, -0.58778173f, -0.02941377f, -0.04239680f, 0.00406037f, 0.11117215f, -0.02890354f, 
    0.15555900f, 0.14095455f, 0.15599181f, 0.32862067f, -0.05309916f, 0.02310814f, -0.08874957f, 0.05120847f, 
    0.20475227f, -0.09068382f, 0.70798010f, -0.05845573f, -0.07246391f, -0.18347652f, -0.01951977f, 0.05898960f, 
    0.04951543f, 0.09473392f, -0.04645579f, 0.00516049f, 0.30504951f, -0.11150566f, -0.22869989f, 0.07899478f, 
    -0.13758093f, 0.08711617f, 0.16891609f, 0.04267948f, 0.22986865f, -0.09620308f, -0.24035360f, -0.05934667f, 
    -0.05059291f, 0.22374487f, -0.06764676f, -0.05834886f, 0.06139310f, -0.50342852f, 0.00577767f, 0.09874842f, 
    -0.09505361f, 0.05188217f, 0.10946516f, 0.04667407f, 0.06473175f, -0.06091097f, 0.05681640f, 0.18048310f, 
    0.19381200f, -0.08806535f, -0.08594029f, -0.15865631f, 0.06312817f, -0.03038985f, 0.06596562f, 0.22593118f, 
    0.00323502f, -0.01376451f, 0.10199583f, 0.00944890f, 0.13128409f, 0.00179961f, -0.01811309f, 0.04295749f, 
    0.05186304f, -0.05338597f, -0.03403404f, 0.00634768f, 0.05202613f, -0.02193381f, 0.02295991f, 0.14861411f, 
    0.13166195f, -0.11805142f, -0.13971917f, -0.13580225f, -0.02249369f, 0.13234664f, -0.06711470f, 0.04594804f, 
    -0.05735000f, 0.19492655f, 0.01144498f, -0.18991110f, -0.06514851f, 0.12282636f, -0.00095197f, 0.02448994f, 
    -0.15009809f, -0.01676841f, -0.12436270f, -0.06523905f, -0.14183544f, 0.08010565f, -0.00291704f, 0.06295536f, 
    -0.20198332f, 0.21207315f, 0.04705264f, -0.21155474f, 0.34812653f, -0.10635050f, -0.25670165f, -0.14823094f, 
    -0.13370495f, 0.15214412f, 0.08598045f, 0.02324773f, 0.06889658f, 0.17903435f, -0.08451459f, -0.11170039f, 
    -0.06950219f, -0.05714211f, -0.00315984f, -0.06959649f, 0.09457505f, -0.09021077f, 0.15517455f, -0.11576868f, 
    -0.03163068f, -0.11302699f, -0.02732046f, 0.09304818f, 0.06000575f, 0.13708498f, -0.07678643f, 0.01707407f, 
    0.01840375f, -0.06344801f, 0.04106977f, -0.05078247f, -0.04849228f, 0.12571590f, -0.08193094f, 0.13993168f, 
    -0.02822959f, -0.02774207f, 0.11269124f, 0.13009250f, -0.01688709f, 0.13068943f, 0.09429014f, 0.02832820f, 
    0.03495964f, -0.20069019f, -0.16283159f, 0.09867853f, 0.08250412f, 0.10730225f, -0.19177528f, 0.01506921f, 
    -0.03904333f, -0.05550221f, 0.30548277f, 0.14771625f, -0.06831557f, 0.06735725f, -0.13924971f, -0.00052200f, 
    0.11229988f, -0.00477795f, 0.08388130f, 0.12899597f, 0.14687094f, 0.22986677f, 0.00532556f, -0.20177859f, 
    -0.24383436f, -0.05282865f, -0.02472970f, 0.09933408f, 0.03802871f, 0.08670800f, 0.17712572f, -0.07810838f, 
    -0.06074964f, -0.08783278f, 0.07685491f, -0.06143235f, -0.01014649f, 0.17557064f, 0.11074723f, 0.03831073f, 
    0.01235265f, -0.09574248f, 0.02417394f, 0.03464051f, 0.06333729f, -0.02532002f, -0.00849760f, -0.10736521f, 
    -0.09812823f, 0.01812251f, 0.02775303f, -0.17453083f, 0.03974182f, 0.03381345f, 0.19723214f, 0.11904478f, 
    -0.50143605f, -0.47877690f, 0.02087063f, -0.04629170f, -0.04636803f, 0.05441362f, 0.06504921f, -0.05325174f, 
    0.12176316f, -0.23061901f, -0.09213463f, -0.04482098f, 0.07743406f, -0.14365372f, -0.09501209f, -0.17337714f, 
    0.02923383f, 0.26802915f, 0.04151459f, -0.05112740f, -0.04746504f, -0.00489098f, 0.07187331f, 0.03414398f, 
    0.12632681f, 0.07126507f, -0.20093566f, -0.47180623f, -0.19105367f, -0.15815814f, 0.05047901f, 0.00281149f, 
    0.08611447f, -0.08416829f, 0.04753899f, -0.19575313f, 0.03201783f, 0.04193700f, -0.13847838f, 0.10613882f, 
    -0.01274556f, -0.02677439f, -0.01524423f, 0.18404327f, 0.14644575f, 0.00878826f, -0.10946847f, -0.03704375f, 
    0.10227589f, 0.10569020f, 0.08236760f, 0.00732283f, 0.00427048f, -0.29978961f, 0.15948862f, 0.02009288f, 
    -0.00953474f, -0.08924092f, -0.05228875f, 0.05213806f, -0.00035567f, 0.25420618f, 0.12189679f, 0.04431603f, 
    -0.04805837f, -0.36410785f, -0.02854232f, -0.06690045f, 0.11038005f, 0.34083879f, 0.05121983f, 0.01548853f, 
    0.13774374f, -0.05546985f, 0.00247594f, -0.01273422f, 0.07057705f, 0.11007553f, 0.13224374f, 0.27703863f, 
    0.24941757f, -0.04198509f, -0.16132477f, -0.08185779f, -0.00961362f, -0.00068695f, 0.07833050f, -0.03293274f, 
    -0.09264419f, -0.13728997f, -0.15493494f, -0.02825575f, 0.04457553f, -0.02232531f, -0.11781204f, 0.07565853f, 
    -0.09228405f, -0.07429012f, 0.00498857f, 0.13636340f, -0.03248756f, -0.05342828f, -0.13090137f, 0.02688238f, 
    0.09757289f, 0.18061402f, -0.00749436f, 0.14193289f, 0.49215949f, -0.08821985f, -0.05067232f, 0.08066676f, 
    -0.08509700f, 0.10037376f, -0.09251111f, 0.02731228f, -0.35374740f, 0.44868335f, 0.66689581f, -0.04528636f, 
    -0.00205705f, -0.24121350f, 0.05821131f, -0.01787578f, 0.06667790f, 0.05731430f, -0.09170061f, -0.11099610f, 
    -0.02051671f, -0.11098897f, -0.03279234f, 0.02517544f, -0.05261559f, -0.04969339f, -0.04027800f, -0.18410593f, 
    -0.00314332f, 0.10371067f, 0.06443772f, -0.04380626f, 0.05238424f, 0.00002229f, 0.02004628f, -0.57832146f, 
    0.06576957f, 0.20080933f, -0.02944258f, 0.12792885f, -0.09751314f, -0.05572916f, 0.00745437f, 0.13243297f, 
    -0.16344829f, 0.06357823f, 0.33287737f, 0.02947142f, 0.13465515f, -0.21519102f, 0.02948355f, 0.10390586f, 
    0.16413143f, -0.04707536f, -0.02922502f, 0.08782573f, -0.13527407f, 0.06138226f, -0.33377355f, 0.02393227f, 
    0.03989474f, -0.06399880f, -0.05078894f, 0.17591341f, 0.08474249f, 0.00266362f, 0.11587667f, -0.24743624f, 
    0.23843817f, -0.02393071f, 0.08837873f, -0.45974806f, 0.11292615f, 0.21767741f, -0.02159943f, 0.13834050f, 
    -0.45211324f, 0.15802228f, 0.07500364f, -0.06282321f, 0.12583151f, -0.10893513f, 0.16979955f, -0.01758606f, 
    0.03312410f, 0.12641238f, 0.07788031f, 0.01554177f, -0.00924838f, 0.07291560f, -0.01222663f, 0.23340715f, 
    0.08569251f, -0.00997069f, 0.00293569f, -0.04557687f, 0.06193005f, 0.06270658f, 0.00430116f, 0.00373628f, 
    -0.09945601f, -0.01204302f, 0.01930912f, -0.08454244f, -0.07156330f, -0.04782346f, -0.02439479f, -0.19355559f, 
    0.23304610f, 0.33760223f, -0.07919201f, -0.18627435f, -0.00418400f, -0.01575080f, 0.17212392f, 0.14803597f, 
    -0.07223807f, 0.32983857f, 0.09320372f, 0.10079724f, -0.03444280f, -0.22879584f, -0.13862137f, 0.16948611f, 
    -0.17145017f, -0.23789717f, -0.14534296f, 0.13565119f, 0.18873025f, 0.13374695f, -0.32122320f, 0.05918135f, 
    0.06613398f, 0.08677806f, -0.09266440f, 0.12456985f, -0.23608977f, 0.09269322f, 0.11701439f, 0.13617884f, 
    0.09701986f, 0.01320197f, -0.10242121f, -0.14573245f, -0.22350948f, -0.44096953f, -0.33829084f, 0.07493345f, 
    -0.00692960f, 0.02045842f, -0.05041099f, -0.12447079f, -0.00046634f, -0.14804959f, -0.10788669f, -0.13187490f, 
    0.08946583f, 0.05969037f, 0.18780176f, -0.09278522f, -0.08491682f, 0.10501835f, 0.15570803f, 0.13520844f, 
    -0.08469287f, -0.10748650f, -0.06924760f, -0.09474461f, 0.01930303f, -0.18024962f, 0.21964382f, 0.08685233f, 
    0.02334001f, 0.04639674f, 0.01433457f, -0.14743942f, 0.08459222f, 0.02164250f, 0.04101694f, -0.34299409f, 
    0.44861907f, -0.20854786f, -0.26656771f, 0.07391574f, 0.41597462f, 0.11375868f, -0.04874327f, 0.19244216f, 
    0.09356222f, 0.13052823f, -0.01137808f, -0.03504763f, 0.08927414f, 0.07512429f, 0.05190114f, 0.00215661f, 
    0.11217597f, -0.21420586f, 0.06519818f, 0.05164739f, -0.02104810f, 0.06676517f, -0.00820150f, -0.08969326f, 
    0.04310093f, 0.26702055f, -0.04882016f, -0.10943978f, 0.33837000f, 0.11312551f, 0.20879340f, -0.14622439f, 
    -0.08985655f, 0.15316282f, -0.19475654f, -0.02837490f, -0.37446240f, -0.32518852f, -0.05939662f, -0.11405905f, 
    -0.16212702f, -0.07050286f, -0.13670744f, 0.02834495f, -0.09065289f, -0.11305587f, -0.15203713f, -0.06824758f, 
    -0.01699198f, -0.11356836f, 0.04403473f, -0.16495630f, -0.05289135f, -0.23158877f, 0.21327344f, 0.13723268f, 
    0.03087299f, -0.10363418f, -0.04702524f, -0.19172022f, -0.06714460f, 0.04177989f, -0.11956985f, 0.05398362f, 
    -0.16255051f, -0.10182080f, -0.07978745f, -0.00167880f, -0.12358184f, 0.08939967f, 0.10489362f, -0.13629428f, 
    -0.02210384f, -0.04721778f, 0.11026002f, -0.09095383f, -0.06086581f, 0.06320754f, 0.06772634f, 0.15442641f, 
    -0.23528871f, 0.18978442f, 0.07166862f, -0.00417969f, 0.04461442f, 0.09950846f, -0.08000614f, 0.08931886f, 
    -0.14781997f, -0.32010421f, -0.06318509f, 0.01645253f, -0.03329675f, 0.14142855f, -0.07163333f, 0.11203034f, 
    0.06539672f, 0.06101236f, -0.11902706f, 0.02424311f, 0.12764896f, 0.01661687f, -0.03782123f, 0.17789492f, 
    -0.12081935f, 0.05466351f, -0.05623963f, 0.22985555f, -0.25508475f, -0.19137715f, 0.01256015f, 0.09548803f, 
    0.16747329f, -0.03760137f, -0.07063423f, 0.06102277f, -0.32629669f, -0.02741325f, -0.16749190f, -0.15337698f, 
    0.04129365f, -0.07380120f, -0.01392341f, -0.07318906f, 0.09286161f, -0.16949004f, 0.11207482f, -0.21796477f, 
    -0.14639312f, -0.04743610f, 0.19531211f, 0.06857827f, 0.00855527f, -0.03640512f, -0.28488427f, 0.30502254f, 
    -0.00272916f, -0.06018174f, 0.05017954f, 0.05937650f, 0.06924766f, 0.00208217f, 0.11085827f, 0.08439974f, 
    -0.18026675f, 0.20463532f, 0.01909912f, -0.08562212f, -0.06202623f, -0.04056011f, 0.16722786f, -0.05553970f, 
    -0.02984234f, 0.14345384f, -0.15705344f, -0.23785676f, -0.04187137f, 0.11103768f, 0.12240282f, 0.15745015f, 
    -0.04822499f, 0.01281570f, -0.04633668f, -0.06116863f, -0.28536668f, 0.04394402f, -0.16360591f, 0.07495136f, 
    0.18891355f, 0.26324511f, 0.45260182f, 0.09511217f, 0.03839253f, -0.22777437f, -0.03299200f, 0.13245045f, 
    0.00674347f, -0.00149459f, -0.03509373f, 0.23788103f, 0.16917579f, 0.17943664f, -0.20404235f, 0.10055000f, 
    0.06944472f, -0.06507533f, -0.05854209f, 0.04913427f, 0.06999312f, 0.09755120f, 0.12137345f, -0.04575523f, 
    -0.10001641f, 0.08609521f, -0.03540408f, -0.14217854f, -0.25119910f, 0.07204895f, -0.05778614f, 0.12405605f, 
    0.12075187f, 0.06067039f, -0.08301505f, 0.03619437f, 0.00002286f, -0.01067494f, -0.13884611f, -0.03372541f, 
    -0.00178467f, 0.12175818f, 0.08053111f, 0.12927763f, -0.08306061f, 0.07737614f, -0.06231490f, 0.05165185f, 
    -0.01460324f, -0.06198351f, -0.07368183f, -0.02191437f, 0.16354460f, 0.02989904f, 0.08910446f, 0.01680330f, 
    0.13271628f, 0.17518190f, -0.03504577f, -0.13367338f, 0.10274483f, 0.06792133f, 0.15810327f, 0.11620103f, 
    0.03314794f, -0.19682972f, 0.10402767f, -0.18315320f, 0.12005373f, -0.03341846f, -0.12369467f, 0.04802939f, 
    -0.34927872f, -0.37516904f, -0.00377121f, 0.11341175f, 0.18416572f, -0.08177514f, 0.01076711f, -0.12556952f, 
    0.01343643f, -0.05777913f, -0.05046524f, 0.08873423f, -0.18204895f, -0.00191889f, 0.24430911f, 0.08444219f, 
    0.02336463f, -0.05719074f, -0.02096256f, 0.20275603f, -0.00432239f, 0.03984396f, 0.08587920f, -0.19575465f, 
    -0.02745944f, 0.16557342f, 0.11786579f, 0.03648238f, 0.15773289f, 0.23514241f, 0.01118217f, -0.00754353f, 
    0.01392931f, 0.05658197f, 0.14874788f, 0.00306624f, 0.13977839f, -0.00344271f, 0.33271095f, 0.10204048f, 
    -0.17273380f, -0.08542909f, 0.03899554f, 0.07255378f, 0.04388146f, -0.01305619f, -0.00390238f, -0.09119846f, 
    0.04145926f, 0.34867448f, -0.00313929f, 0.06864514f, -0.14318746f, -0.20935978f, -0.16458493f, -0.17485119f, 
    -0.05347642f, 0.04069554f, -0.01123544f, 0.13149194f, -0.06192840f, 0.14090295f, 0.04967031f, -0.15954053f, 
    -0.42463258f, -0.11915527f, 0.11904707f, -0.06375667f, -0.02211821f, 0.08333523f, -0.00625691f, 0.00062191f, 
    0.02260059f, 0.01168861f, -0.18606365f, -0.25094059f, 0.09080576f, 0.01534807f, 0.11472855f, 0.15635887f, 
    -0.08632143f, -0.04676225f, -0.16595615f, -0.23910271f, -0.37675217f, 0.04931639f, -0.14387965f, -0.05262778f, 
    0.04526654f, -0.07155115f, -0.08965557f, 0.27138558f, -0.10138142f, 0.01555560f, -0.03902528f, 0.08083784f, 
    0.15511583f, 0.03507960f, -0.05425216f, -0.05180350f, 0.02166295f, -0.26052758f, -0.07274046f, 0.07156841f, 
    -0.03811789f, -0.13405938f, 0.08125835f, 0.02896892f, 0.10869000f, 0.00741334f, -0.08555237f, -0.07934514f, 
    0.25395808f, 0.02729763f, 0.11727142f, -0.01959858f, -0.24426724f, 0.22707036f, 0.02054615f, -0.16677035f, 
    -0.00861252f, -0.13840757f, -0.08997714f, 0.20903783f, 0.07484069f, 0.14449215f, 0.08793687f, 0.09642668f, 
    0.07189545f, 0.11075480f, 0.23460205f, 0.05255066f, 0.13225920f, 0.03821058f, 0.22131439f, -0.04736518f, 
    0.06296089f, -0.05465993f, 0.04154255f, -0.11376448f, 0.06007066f, 0.09592803f, -0.02370476f, -0.04955461f, 
    -0.09769810f, -0.08149980f, -0.08056311f, -0.13063185f, 0.25265709f, -0.06894421f, 0.01773619f, 0.12486978f, 
    0.04604388f, 0.02133211f, 0.11417273f, -0.15688173f, 0.11263957f, 0.19630501f, 0.13145798f, 0.00050053f, 
    -0.03266957f, 0.00391806f, -0.20837922f, -0.32587013f, -0.08069950f, 0.02873327f, 0.22810073f, -0.09079116f, 
    -0.05419060f, -0.10639805f, -0.16598821f, -0.16020778f, -0.07140740f, 0.17203312f, -0.10414402f, 0.23089178f, 
    0.02710223f, 0.10580841f, 0.04125121f, 0.06911979f, 0.03126416f, 0.12942041f, 0.16631982f, 0.09882236f, 
    0.02112522f, 0.03905455f, -0.00043056f, 0.08588069f, 0.02216252f, 0.10488028f, 0.13017146f, -0.18870850f, 
    0.08001697f, 0.00502551f, 0.03593064f, -0.02608263f, 0.01383119f, -0.08486199f, -0.05581531f, 0.09052870f, 
    0.17020296f, 0.15649627f, 0.00824806f, 0.00509981f, 0.02963523f, -0.21117221f, 0.16117154f, -0.06007032f, 
    0.14456303f, -0.25709653f, -0.25344014f, -0.17430831f, -0.00278550f, 0.05749396f, -0.19040450f, -0.09347276f, 
    -0.21508466f, 0.18969145f, 0.18761811f, 0.05912749f, -0.25670889f, -0.05338272f, 0.10192972f, -0.05307135f, 
    0.15813668f, 0.05597722f, 0.09518655f, -0.07274102f, 0.18372568f, -0.12485760f, -0.17112970f, 0.16864014f, 
    -0.11713705f, 0.13094904f, -0.04665304f, 0.09008518f, 0.27511793f, -0.15774883f, -0.27680412f, -0.04169490f, 
    0.08159988f, 0.09717087f, 0.11479947f, -0.15738945f, 0.11534359f, 0.08984270f, 0.07768917f, -0.01124552f, 
    -0.01473569f, -0.02697194f, 0.21083015f, 0.01233741f, -0.03225748f, 0.04901575f, 0.09267934f, 0.19364144f, 
    -0.04928325f, -0.13195089f, 0.08961233f, 0.01801312f, 0.10398067f, -0.06115051f, 0.12268497f, -0.03456541f, 
    0.32201225f, 0.25687948f, 0.00222844f, -0.20707867f, -0.06749107f, 0.02930814f, 0.07061163f, 0.10725686f, 
    0.04331403f, 0.02512099f, 0.01489554f, -0.06229762f, 0.09928587f, 0.01989641f, 0.14192991f, 0.05741713f, 
    -0.01247081f, -0.68985462f, -0.02661389f, 0.25807691f, -0.00344094f, -0.06833887f, -0.07981077f, 0.13613020f, 
    0.04574575f, 0.06878414f, 0.01862335f, 0.06195136f, -0.21251106f, 0.07313331f, -0.04179111f, 0.09768167f, 
    -0.07435926f, -0.10965063f, -0.05960758f, -0.28144014f, -0.79377204f, -0.19521438f, -0.26166835f, 0.08602194f, 
    0.13446419f, 0.07382283f, -0.09319441f, -0.03481912f, 0.54048043f, -0.21805869f, -0.43165824f, -0.10884727f, 
    -0.08432613f, 0.01158253f, 0.08484083f, -0.15170406f, 0.03426361f, 0.28782210f, 0.09760048f, 0.00347774f, 
    -0.15404938f, -0.14019905f, -0.05249020f, -0.10715935f, -0.07949007f, -0.10686436f, 0.39230508f, -0.14452039f, 
    -0.13734047f, 0.05888442f, -0.01251305f, -0.07304828f, 0.11913817f, -0.03298948f, 0.01012696f, -0.11556932f, 
    -0.42690641f, -0.45206380f, 0.08393325f, 0.24257509f, -0.15718374f, -0.05641108f, -0.15022120f, 0.00734607f, 
    -0.10993582f, 0.08699588f, 0.02314710f, -0.10355488f, 0.02654336f, -0.12196162f, -0.00303074f, 0.19095676f, 
    -0.07248015f, 0.21351810f, -0.06397559f, -0.13085142f, -0.12209931f, 0.09646109f, -0.08196223f, -0.03447307f, 
    0.13661018f, 0.07426937f, -0.27796781f, -0.35511714f, 0.22574297f, 0.02762920f, -0.00362718f, 0.04144328f, 
    -0.01676811f, -0.07487349f, 0.16448167f, -0.32561293f, -0.36260262f, -0.51909971f, 0.05939677f, -0.10691392f, 
    0.01955786f, -0.08267479f, -0.09159896f, 0.02772971f, -0.02431913f, 0.02222305f, -0.02513566f, -0.09439114f, 
    -0.01069550f, 0.12522811f, 0.19539401f, -0.01997233f, 0.11777124f, -0.02407043f, 0.32557946f, 0.05305084f, 
    0.07621163f, -0.06388886f, 0.03612819f, -0.03878857f, -0.05234846f, 0.06701342f, -0.11916778f, 0.18555892f, 
    -0.08880445f, -0.04385887f, -0.04488727f, 0.00013765f, -0.00793120f, 0.02127324f, 0.04471957f, 0.12300758f, 
    0.00360242f, 0.01389463f, -0.13888504f, 0.03004584f, -0.05742851f, -0.07177267f, 0.18150662f, 0.10102426f, 
    -0.09372292f, 0.12820263f, 0.12142053f, 0.05964550f, 0.02369961f, -0.00876226f, -0.04040263f, -0.12083265f, 
    -0.04886142f, -0.39934552f, -0.34641212f, -0.10491554f, -0.09269882f, 0.07059130f, -0.05000740f, 0.12336587f, 
    -0.06499877f, 0.07437075f, 0.07692842f, 0.22377172f, -0.01353894f, 0.10054733f, -0.20462474f, 0.07586117f, 
    0.02432024f, 0.05305253f, 0.07110789f, 0.15659010f, 0.07956636f, -0.31539506f, -0.07786582f, -0.06794820f, 
    0.01147991f, 0.09283403f, -0.00764452f, -0.06313915f, -0.68225098f, -0.04021241f, -0.27274257f, 0.12016734f, 
    0.04290856f, 0.03178205f, -0.08459371f, -0.10513623f, -0.06496856f, -0.26331684f, -0.11725880f, -0.19015282f, 
    0.04251703f, -0.00122533f, 0.04520989f, 0.13460064f, 0.00988015f, -0.08055662f, -0.10816747f, -0.03721730f, 
    -0.31737554f, -0.00379877f, 0.07912805f, 0.04459841f, 0.04971788f, 0.06156507f, 0.07429544f, -0.47336975f, 
    -0.31345028f, 0.16426542f, -0.02154825f, 0.17269213f, 0.01873603f, 0.06654187f, 0.02807247f, 0.14060308f, 
    -0.06740987f, 0.16659667f, 0.09401446f, 0.06119861f, -0.08458962f, -0.10483186f, -0.17194019f, -0.28664136f, 
    0.17017648f, 0.29219282f, -0.12446655f, -0.29722545f, 0.21179274f, 0.01362955f, 0.04009753f, 0.00710605f, 
    0.03177061f, -0.21397169f, -0.19634630f, 0.05291650f, -0.17615956f, 0.17819645f, -0.16638006f, 0.00094395f, 
    -0.09956949f, -0.08331618f, -0.16621013f, -0.11032051f, 0.17044066f, 0.26236275f, -0.29584777f, -0.22413817f, 
    -0.01112550f, -0.07520504f, -0.25839978f, 0.13050164f, -0.13523065f, 0.07661954f, -0.06917764f, 0.00668564f, 
    -0.15826139f, -0.03849657f, 0.09859896f, -0.15073897f, -0.05958118f, -0.16766307f, -0.04774764f, -0.06320234f, 
    0.08629704f, -0.00806306f, -0.12288174f, 0.14478453f, 0.16523376f, -0.11592606f, 0.22703925f, 0.06790137f, 
    -0.00125118f, -0.10402754f, 0.07561418f, -0.11857156f, 0.05848824f, 0.10464400f, 0.02431644f, -0.16782951f, 
    -0.29792473f, -0.03850033f, 0.01045750f, -0.12526225f, -0.13582481f, 0.06886639f, 0.21956216f, 0.18075097f, 
    -0.16833083f, -0.24929653f, 0.04373341f, 0.11971236f, 0.01411560f, -0.12903564f, 0.05661705f, -0.23032527f, 
    0.19697212f, 0.13775730f, 0.16885778f, -0.26558793f, -0.16672169f, -0.04664310f, 0.05501733f, -0.06256241f, 
    0.00423350f, 0.07497708f, -0.02957409f, 0.10153732f, -0.02256705f, -0.01482655f, -0.08887134f, 0.06463920f, 
    0.09736442f, 0.00094297f, -0.26701385f, 0.32655874f, 0.04489096f, 0.04840784f, 0.09858966f, -0.10389500f, 
    -0.08313524f, -0.10571500f, 0.19246250f, 0.00195753f, 0.13504919f, 0.19702628f, 0.04302068f, -0.11372890f, 
    -0.03486476f, -0.07465228f, -0.08207905f, 0.12491403f, -0.40013424f, 0.11999159f, 0.10638119f, -0.04615523f, 
    0.18453839f, 0.14819913f, -0.10352380f, 0.11230198f, 0.05616202f, 0.21608365f, -0.42519462f, 0.18538223f, 
    0.27051419f, 0.01983860f, -0.05737119f, -0.01693456f, 0.04705948f, -0.12084927f, 0.10440637f, 0.07976185f, 
    -0.10117648f, -0.36784065f, -0.10412613f, -0.02156130f, 0.04605911f, -0.25343817f, 0.26992062f, -0.05016578f, 
    -0.08172245f, 0.15271254f, -0.08590493f, 0.02733243f, -0.13108611f, -0.07399734f, 0.00422744f, 0.15696022f, 
    -0.14282246f, 0.61799908f, 0.54589874f, -0.07901772f, -0.11142419f, -0.04730120f, 0.04588114f, 0.04824348f, 
    -0.12960523f, -0.00105992f, 0.22986007f, -0.02746776f, 0.00585722f, -0.05659609f, 0.01505220f, -0.03717045f, 
    0.11994448f, 0.05586043f, -0.00632275f, 0.45589346f, 0.33800292f, -0.05280535f, -0.00631157f, 0.07576588f, 
    0.15573883f, 0.11063634f, -0.01345843f, -0.00755181f, 0.32183754f, 0.18541586f, 0.14495175f, -0.25212738f, 
    -0.25837144f, -0.19959065f, -0.03916617f, 0.05108109f, -0.11484233f, -0.24611816f, -0.14080308f, -0.07528415f, 
    0.23431423f, -0.00630263f, -0.38182512f, -0.08287117f, -0.01901894f, 0.26272643f, 0.20048213f, 0.12129007f, 
    0.23156604f, -0.28806520f, -0.19079168f, -0.26730502f, 0.08334401f, 0.05995996f, -0.12304299f, 0.11019904f, 
    0.19407722f, 0.03307242f, -0.04445944f, 0.07977936f, 0.05639756f, 0.18997811f, -0.05239476f, 0.13482215f, 
    0.15398824f, 0.05625883f, -0.37112483f, -0.15619472f, -0.19452235f, -0.08599512f, 0.08590750f, -0.17553593f, 
    -0.03922224f, 0.32275990f, 0.17139682f, -0.10128447f, -0.01049384f, -0.12057914f, 0.01177859f, 0.04206848f, 
    0.00078458f, 0.05113722f, 0.04009479f, 0.11594669f, -0.27429828f, 0.12682003f, -0.05982989f, -0.13371101f, 
    0.01386522f, 0.06378365f, 0.16428274f, -0.07461813f, 0.41895708f, -0.32430404f, -0.07784193f, 0.06512089f, 
    0.02066415f, -0.02640460f, 0.12025177f, -0.11517019f, 0.28647181f, 0.22701699f, 0.20752387f, 0.05674005f, 
    0.06933372f, -0.02581316f, -0.04789948f, 0.05481089f, 0.09039378f, 0.01598505f, 0.00599346f, -0.18160540f, 
    0.06573546f, -0.07029742f, 0.04751097f, -0.00580157f, -0.01658516f, -0.26241085f, -0.42871264f, 0.06421920f, 
    0.13773562f, -0.10130512f, -0.07655394f, 0.00036401f, -0.10604281f, -0.13164996f, 0.05067888f, 0.04920754f, 
    0.03323627f, -0.13471614f, -0.03220017f, -0.01184817f, 0.07107753f, 0.07869175f, -0.03006996f, 0.05061774f, 
    0.00047157f, -0.00654516f, 0.14754760f, -0.11810472f, -0.06794963f, 0.12264032f, -0.08545181f, -0.07115224f, 
    0.12550570f, -0.07747319f, 0.10852478f, 0.07096608f, 0.06433965f, 0.08494864f, -0.01796895f, -0.16307208f, 
    -0.00355655f, 0.24121042f, 0.05983525f, -0.08837976f, -0.00703467f, -0.03000913f, -0.21114294f, 0.12745029f, 
    0.05778000f, -0.02078172f, -0.00396979f, -0.13104314f, -0.32943591f, 0.16616273f, -0.23622555f, -0.18580978f, 
    -0.12756819f, 0.13044666f, 0.02917365f, -0.09275398f, 0.42602411f, -0.48868501f, -0.10692483f, -0.06077525f, 
    -0.08378635f, -0.09268433f, -0.04208819f, -0.04329151f, -0.09306774f, 0.33667794f, -0.10705391f, -0.03982827f, 
    0.19585715f, 0.02523006f, 0.07103623f, 0.09416302f, 0.20019646f, 0.10530385f, 0.05070930f, -0.05653218f, 
    -0.10736100f, -0.14653999f, 0.09016369f, -0.07044758f, 0.06679707f, 0.09816697f, 0.17682607f, 0.13159251f, 
    -0.18390062f, 0.00792009f, 0.07518269f, 0.00642570f, 0.04430750f, 0.08619391f, -0.07157952f, 0.10414372f, 
    -0.07686127f, -0.06985870f, 0.08263338f, -0.08818503f, -0.09546005f, -0.06082772f, -0.07475632f, -0.03033966f, 
    0.04575557f, -0.08742376f, -0.46434319f, 0.01193680f, 0.02537074f, 0.02243562f, -0.13553596f, 0.06408136f, 
    0.03961036f, -0.06117819f, 0.21286146f, 0.06138249f, 0.05886698f, 0.05508966f, -0.07341956f, 0.05382938f, 
    0.13720770f, -0.03095105f, 0.20797731f, -0.07485301f, -0.06843568f, -0.08651198f, -0.09319037f, 0.04688542f, 
    -0.07160625f, -0.11787507f, 0.14249609f, 0.09045263f, -0.14786482f, 0.08112214f, 0.00772155f, -0.13644072f, 
    -0.09815354f, -0.07540155f, 0.14402111f, 0.21016105f, -0.01102237f, 0.01273511f, 0.27316803f, -0.05296491f, 
    -0.09798323f, -0.06170591f, -0.13426027f, 0.08416968f, 0.14820136f, 0.21531549f, 0.03627374f, 0.08526133f, 
    -0.28073528f, 0.06686124f, 0.01356280f, -0.22400343f, 0.13274564f, 0.07356904f, 0.12367851f, 0.27079430f, 
    -0.45531198f, -0.53687298f, -0.00023715f, 0.03238314f, 0.08779918f, -0.07906168f, -0.20108363f, -0.05358071f, 
    0.22536926f, -0.25892895f, -0.25324288f, 0.02611153f, 0.02327986f, -0.07709685f, 0.10135984f, 0.11224788f, 
    -0.02649851f, 0.04304079f, 0.23920359f, 0.29129249f, -0.10619287f, 0.18622176f, -0.07051961f, -0.05965000f, 
    0.08576048f, -0.02776867f, -0.02000779f, -0.49786651f, -0.28952059f, 0.01498874f, -0.05447226f, -0.00017250f, 
    -0.06720045f, 0.03741856f, -0.01413328f, -0.30148119f, 0.15394613f, -0.28915057f, 0.01399478f, -0.00029558f, 
    -0.05693239f, -0.20623012f, 0.03415406f, -0.07608251f, 0.00425177f, -0.34678686f, -0.48654711f, -0.15804422f, 
    -0.04213549f, -0.19291410f, -0.00822433f, -0.04514250f, -0.01152445f, -0.62111455f, -0.11717071f, -0.07089836f, 
    -0.03880167f, -0.09777568f, 0.08007629f, 0.04443819f, -0.14700237f, 0.03050855f, -0.23403235f, -0.08728784f, 
    0.03108959f, -0.12122196f, -0.15723391f, -0.31346297f, 0.05703331f, 0.22021055f, 0.05184994f, -0.11857670f, 
    0.04998333f, 0.18230043f, -0.04811613f, 0.06890254f, 0.04880705f, 0.15567303f, 0.01646408f, 0.15135309f, 
    0.16367161f, -0.14582525f, -0.17680851f, -0.18620054f, -0.25169122f, 0.08805620f, 0.24492085f, -0.00014743f, 
    -0.08291184f, -0.07384434f, -0.03265316f, 0.08404449f, 0.00004570f, -0.07472347f, -0.02527882f, 0.03068423f, 
    0.04661775f, -0.04047861f, -0.24185212f, 0.35003445f, -0.03950237f, -0.03838730f, -0.12836821f, -0.21376319f, 
    0.16846132f, 0.17988700f, 0.11363977f, -0.43113199f, -0.03643166f, -0.34110075f, 0.03614422f, -0.03497282f, 
    -0.07282887f, 0.06050624f, -0.19427101f, -0.11040891f, -0.21136388f, 0.00209552f, 0.08837229f, 0.12111633f, 
    0.05195524f, 0.19544555f, -0.08795569f, -0.00874888f, 0.02814789f, 0.33500949f, -0.02263224f, 0.10905015f, 
    0.12940760f, 0.02552132f, 0.05367074f, 0.08843307f, 0.01335387f, 0.21682949f, 0.02710855f, -0.03069751f, 
    0.06999060f, 0.03768364f, -0.05118727f, -0.12310436f, 0.11062150f, 0.00601356f, 0.17265150f, -0.44592649f, 
    -0.05492360f, 0.28678334f, -0.00285497f, 0.12112639f, 0.02692333f, 0.06133569f, 0.01544451f, 0.05160395f, 
    -0.18349198f, -0.00893207f, 0.07159960f, 0.13128988f, -0.00651712f, -0.12906517f, 0.02784808f, 0.06643499f, 
    0.05968391f, -0.40503922f, -0.32456782f, -0.29877502f, 0.06801532f, -0.15944308f, -0.22634940f, -0.08198967f, 
    -0.18095909f, -0.00622933f, 0.07630373f, -0.49179497f, -0.08264940f, 0.13272391f, 0.16296124f, 0.08405658f, 
    -0.04178042f, -0.28106421f, 0.11461388f, -0.05028430f, -0.59705186f, -0.26013568f, -0.12043752f, 0.14511861f, 
    0.26243839f, 0.05752612f, -0.04334687f, -0.07695618f, -0.23908307f, 0.26352096f, -0.17257684f, 0.01343072f, 
    0.05947670f, 0.11217708f, -0.16988936f, 0.13219446f, -0.25219941f, -0.16566798f, 0.08034343f, -0.22825156f, 
    0.23178223f, -0.04489221f, 0.11074425f, -0.12541468f, 0.20802370f, 0.05371366f, 0.06919611f, 0.02498353f, 
    0.15475701f, -0.03983572f, 0.05455318f, 0.11857410f, 0.16742460f, 0.12497970f, 0.06273935f, 0.02238968f, 
    -0.17399894f, 0.01481824f, 0.04941567f, 0.03733227f, -0.07366202f, 0.10785806f, 0.22464748f, -0.06870742f, 
    0.00224884f, -0.08520173f, 0.00255820f, 0.01110932f, 0.07338277f, 0.11832419f, 0.12446176f, 0.12499303f, 
    0.01431289f, 0.03393304f, -0.09207667f, 0.03771501f, -0.39825305f, -0.01851851f, -0.02998253f, 0.22307023f, 
    0.18963355f, 0.15930027f, 0.11872773f, 0.06287678f, 0.02294649f, 0.08987617f, 0.22185110f, 0.19858202f, 
    0.06126887f, 0.06679252f, 0.06551948f, -0.14715093f, -0.36814126f, -0.19211438f, -0.09196533f, -0.37719464f, 
    -0.27037257f, 0.01388542f, 0.18874703f, 0.15907404f, -0.47716799f, -0.49944934f, -0.54522091f, -0.05630420f, 
    -0.13070591f, -0.28234881f, 0.04163626f, 0.12757243f, 0.17658126f, 0.13137895f, -0.10971549f, 0.15317604f, 
    0.20881759f, 0.25804409f, 0.17191951f, 0.15549910f, 0.07204682f, 0.03612381f, 0.17405342f, -0.15658802f, 
    -0.04217391f, 0.08537841f, 0.20179686f, 0.38318363f, 0.04221680f, 0.02920673f, -0.11438683f, -0.33852950f, 
    -0.04447910f, -0.05435671f, -0.12917253f, 0.05581970f, -0.01435995f, -0.19946170f, 0.10033073f, -0.02739481f, 
    -0.46585846f, 0.01693253f, -0.01895759f, -0.15510327f, -0.21362726f, 0.18797213f, 0.05028342f, 0.07932501f, 
    0.02741164f, -0.36221352f, 0.11970088f, -0.05721300f, -0.24546944f, -0.06708685f, -0.12368731f, 0.21911731f, 
    0.04384245f, 0.03705351f, -0.21163440f, -0.00875339f, -0.02334249f, 0.17729898f, -0.05609606f, 0.16963480f, 
    0.21816024f, 0.14666519f, 0.01881577f, 0.10027521f, 0.25587660f, 0.26985067f, -0.28892559f, -0.23262800f, 
    -0.25104490f, 0.20926930f, 0.00811390f, -0.18969341f, 0.05908724f, 0.12442941f, 0.27223361f, -0.26583168f, 
    -0.19228145f, -0.04206543f, 0.07969795f, 0.06346334f, 0.03461637f, 0.36286443f, 0.12353936f, 0.33663383f, 
    -0.36407882f, -0.11089734f, -0.10247675f, 0.05659209f, -0.15883537f, 0.10799774f, -0.19674172f, 0.02250141f, 
    0.22059180f, -0.15117796f, -0.03601921f, -0.17666127f, 0.09099299f, 0.07276046f, 0.02722199f, 0.02879521f, 
    -0.09667084f, 0.15713006f, -0.08077911f, 0.08340660f, 0.02186167f, 0.23097815f, 0.06684903f, 0.18029720f, 
    0.23105980f, -0.07538689f, 0.06849445f, -0.06027557f, -0.05930695f, 0.01494432f, -0.11397008f, 0.10952838f, 
    0.08556765f, -0.10528440f, 0.12386123f, -0.13694035f, -0.03653511f, -0.07169423f, 0.02942287f, 0.17412370f, 
    0.04446217f, 0.15666145f, 0.19031493f, -0.06566798f, 0.05454298f, 0.03882149f, -0.13547571f, -0.14409801f, 
    0.04791536f, -0.07858782f, -0.02071108f, 0.09448931f, 0.27347663f, -0.12719429f, -0.03299343f, 0.02072894f, 
    0.27993563f, 0.18559228f, -0.07866175f, 0.05872872f, -0.09732134f, 0.00122919f, 0.22939977f, -0.22669354f, 
    -0.19390477f, -0.19111677f, -0.06972039f, 0.03367834f, -0.03613880f, -0.58478338f, -0.55743235f, -0.42625436f, 
    -0.08126232f, -0.11151467f, 0.08115798f, 0.06045294f, 0.17264630f, 0.03719731f, 0.12110956f, -0.22109932f, 
    -0.48327136f, -0.02518960f, -0.08698848f, 0.00118721f, 0.09661958f, 0.22821939f, 0.14612864f, -0.25416020f, 
    -0.20803499f, 0.00950519f, -0.19233225f, -0.02295164f, -0.46312192f, -0.01295997f, 0.10000163f, 0.03650751f, 
    0.03662967f, 0.08532470f, 0.03875659f, 0.04549414f, 0.17969748f, -0.20690815f, -0.12551486f, -0.11064332f, 
    0.04485387f, -0.05350172f, -0.11431354f, -0.30400676f, -0.01153572f, -0.12847523f, 0.04032561f, -0.18442367f, 
    0.00835851f, -0.17975043f, 0.27939436f, 0.01840672f, 0.05327615f, 0.09251597f, -0.08933040f, 0.04948191f, 
    0.22640729f, 0.09650493f, 0.23376524f, -0.05188360f, 0.22350217f, 0.19458435f, 0.00103555f, 0.14172743f, 
    -0.01435320f, 0.13795009f, -0.00269382f, 0.09310383f, 0.00098355f, 0.08343202f, 0.35175535f, -0.04174300f, 
    0.11212119f, -0.12780499f, -0.10245614f, 0.01147183f, 0.19906637f, 0.05456100f, -0.04872475f, 0.16017772f, 
    0.03826233f, 0.05749675f, 0.22210950f, 0.05396979f, -0.17525688f, 0.11164483f, 0.06891927f, 0.25182217f, 
    0.23289193f, -0.01371903f, -0.04947284f, -0.00471279f, -0.04092460f, -0.18462469f, 0.19310459f, 0.14049670f, 
    -0.01758007f, 0.15365763f, -0.07092798f, 0.13896039f, -0.06943111f, -0.19518292f, -0.08816080f, 0.11273347f, 
    0.02778296f, 0.29225293f, 0.05373764f, 0.07765102f, 0.13647281f, -0.02278337f, 0.02316081f, -0.10261284f, 
    0.01547227f, -0.13808951f, 0.22583614f, -0.08897828f, 0.09351781f, -0.07007691f, 0.07787327f, 0.02764936f, 
    -0.04499282f, 0.13125077f, 0.01182161f, 0.18707427f, 0.11137680f, 0.09606209f, 0.11083523f, 0.06195798f, 
    -0.05419514f, 0.00051971f, 0.11094089f, 0.14276645f, 0.04562830f, 0.02034079f, -0.05964845f, -0.13029686f, 
    0.13344637f, 0.08630489f, 0.09220333f, 0.01453733f, 0.04192797f, -0.06411435f, -0.02971010f, -0.13294278f, 
    -0.05417316f, -0.01859882f, -0.00798964f, 0.09027443f, 0.20165564f, 0.08998740f, 0.09548265f, 0.20464981f, 
    0.01333031f, -0.06016091f, -0.01314957f, 0.04694891f, -0.02842085f, 0.09237123f, -0.06464987f, 0.01237616f, 
    0.25693050f, 0.09092803f, -0.04974455f, 0.02805226f, -0.11907021f, 0.04291653f, 0.08930548f, 0.11116002f, 
    0.02614540f, 0.11649127f, -0.02835711f, 0.05061296f, -0.08011258f, -0.00173750f, -0.09769630f, -0.25252098f, 
    -0.04232682f, 0.21192856f, 0.13370949f, 0.00221737f, 0.09475128f, 0.09765082f, -0.04644501f, -0.00324250f, 
    0.13312152f, -0.29224223f, -0.07993571f, 0.13575277f, -0.10643838f, 0.06236197f, 0.00372209f, -0.06369648f, 
    0.06083642f, 0.19415443f, 0.20236057f, 0.17440592f, 0.15853500f, 0.24200727f, -0.01799832f, 0.14172649f, 
    0.03987351f, -0.21966603f, -0.11410407f, -0.17536184f, -0.14467746f, -0.20510586f, -0.01139077f, -0.20147118f, 
    -0.09646659f, 0.02834498f, 0.08363026f, -0.01192506f, 0.14162607f, 0.29816052f, 0.24849682f, -0.26457760f, 
    -0.06063784f, -0.00933300f, 0.01180197f, -0.00155249f, -0.10890886f, 0.20704289f, 0.15722495f, 0.22897588f, 
    -0.14849856f, 0.00150365f, 0.00662654f, 0.00715068f, 0.02487034f, -0.14272283f, 0.05925614f, 0.04560367f, 
    -0.02399009f, 0.05640987f, 0.01122860f, -0.08735052f, -0.17687863f, -0.24612705f, -0.13915716f, -0.19400518f, 
    0.04855343f, 0.16735631f, 0.06454006f, 0.03279381f, 0.00235033f, -0.13360709f, -0.13319185f, 0.04511898f, 
    0.08526732f, 0.36499149f, 0.22269191f, -0.07104006f, 0.09235568f, 0.06845491f, -0.03315058f, -0.17825051f, 
    0.01753565f, 0.18970960f, -0.15032195f, -0.11438152f, 0.01371713f, -0.06942771f, 0.06985001f, -0.11118986f, 
    0.07084111f, -0.05565428f, 0.09621657f, -0.05445062f, 0.19855355f, 0.13949966f, -0.05524169f, -0.11352971f, 
    -0.04569299f, -0.09274758f, 0.00361901f, -0.02997795f, -0.03835783f, 0.04438110f, 0.12335458f, 0.25206330f, 
    0.25091648f, 0.03847470f, -0.05413143f, -0.08542557f, -0.00886159f, -0.27242389f, -0.59995836f, -0.16868125f, 
    -0.12415422f, -0.17667829f, 0.03504949f, 0.13057265f, -0.02390837f, -0.14268920f, -0.24116088f, -0.05460532f, 
    0.05856656f, 0.02224845f, -0.02854088f, 0.08866754f, -0.15115845f, -0.06665874f, 0.05546432f, -0.01051778f, 
    0.10643685f, -0.07098108f, -0.01520483f, 0.11380681f, 0.05171527f, 0.09201382f, -0.09748971f, 0.05423390f, 
    -0.08257659f, -0.42308727f, -0.11045174f, -0.05453855f, 0.13342331f, 0.09969346f, 0.00211629f, -0.05598530f, 
    0.05305250f, -0.35060275f, 0.08104321f, -0.10219742f, 0.09628318f, 0.08206169f, 0.03001009f, -0.06811345f, 
    0.00735552f, -0.07711644f, 0.19709083f, 0.21055563f, -0.05034659f, -0.06984734f, -0.12526301f, 0.05994014f, 
    0.16730636f, 0.00948742f, 0.01788176f, 0.13689689f, 0.15885000f, 0.02650474f, -0.21860734f, 0.11497117f, 
    -0.09088492f, -0.00181283f, -0.06662529f, -0.31532273f, 0.04083601f, -0.05251718f, 0.28545931f, -0.06866069f, 
    0.08008683f, 0.05674415f, 0.05756076f, -0.01592587f, 0.07705604f, -0.00769005f, -0.00755821f, -0.00328417f, 
    -0.02126251f, 0.12219886f, 0.10665327f, 0.15397049f, 0.01089152f, 0.36937186f, 0.06176324f, 0.32372609f, 
    0.07720046f, 0.06501948f, 0.00326121f, 0.09970266f, 0.13349178f, 0.11668064f, -0.00129662f, -0.02546651f, 
    -0.13086170f, 0.15720637f, 0.00039487f, 0.06118833f, 0.06933447f, 0.04879182f, -0.11882611f, 0.05882674f, 
    0.09205768f, 0.15667105f, -0.01175360f, 0.22121274f, -0.00070850f, -0.09444056f, 0.06027722f, -0.15914774f, 
    0.25380155f, 0.02065562f, 0.14846125f, 0.02310585f, -0.15373939f, -0.10617109f, -0.18043475f, 0.03784474f, 
    -0.01983135f, -0.11514622f, -0.08722580f, -0.19226202f, 0.15022172f, 0.02065762f, -0.07324641f, 0.18495314f, 
    -0.05255114f, 0.20024532f, 0.02590640f, 0.13323136f, 0.02642110f, 0.13215692f, 0.02302253f, 0.09109654f, 
    0.08638549f, 0.12689896f, 0.14378041f, -0.33357993f, -0.20867342f, -0.12186783f, -0.06007756f, -0.12263706f, 
    -0.24822982f, 0.07301621f, 0.18306686f, -0.03007240f, -0.11412518f, -0.22698002f, 0.08966763f, -0.00772382f, 
    -0.03022403f, -0.13359228f, -0.06149450f, 0.03353734f, -0.12048225f, 0.12774228f, 0.09729596f, 0.09630936f, 
    -0.00654259f, -0.07244893f, 0.00957202f, 0.01413253f, 0.03358638f, -0.15874274f, 0.13833760f, 0.03707816f, 
    0.10857642f, 0.08425653f, 0.05287679f, -0.12309435f, 0.02080568f, 0.16028772f, 0.05045990f, -0.00526500f, 
    0.02603704f, 0.05918511f, 0.11759100f, -0.54575139f, 0.41797838f, 0.15933967f, 0.32830125f, 0.15525588f, 
    0.01155581f, -0.17367865f, -0.12545383f, 0.03610163f, -0.01205101f, 0.13313968f, 0.11947749f, 0.07922263f, 
    0.06953974f, 0.01484094f, 0.00127402f, -0.09081759f, 0.07445592f, 0.04213404f, 0.16538756f, -0.07475571f, 
    -0.04919103f, -0.12171109f, -0.02384401f, -0.07042711f, 0.08202290f, -0.25377205f, -0.05847213f, -0.12246320f, 
    0.15238111f, 0.26533812f, 0.34234834f, -0.15288728f, 0.09498609f, 0.07796455f, -0.13500476f, -0.05466400f, 
    -0.07999261f, -0.15608519f, 0.01865701f, -0.14856644f, -0.16656263f, -0.28721654f, -0.39740071f, 0.22810587f, 
    0.07059210f, 0.03920401f, 0.00125567f, -0.18630791f, 0.12293696f, -0.20232409f, -0.01829616f, -0.14092404f, 
    -0.01441698f, -0.00656804f, 0.11041952f, -0.08083870f, -0.07058189f, -0.24016719f, 0.04527791f, 0.09281486f, 
    -0.08695830f, 0.01738229f, 0.06953045f, -0.03154293f, 0.05614920f, -0.05016797f, 0.15653394f, -0.08399416f, 
    0.13420330f, 0.03547001f, 0.09725858f, -0.01370090f, 0.01731862f, -0.16193305f, -0.02332056f, -0.05232542f, 
    0.12710670f, -0.06767174f, -0.03643293f, 0.19306894f, 0.05661314f, 0.09476501f, -0.12944484f, 0.04614749f, 
    0.02889715f, -0.31530353f, -0.12284347f, -0.11625076f, -0.01052963f, -0.02363037f, 0.02176498f, 0.09553490f, 
    0.14399594f, 0.02820499f, 0.09337360f, 0.29916966f, 0.03531000f, 0.01106061f, 0.11485200f, 0.01856003f, 
    -0.04843245f, 0.01935363f, -0.09798261f, -0.10721412f, -0.24700467f, -0.14387371f, -0.18200381f, 0.02151738f, 
    -0.07506866f, -0.08030512f, 0.05873614f, 0.03258674f, -0.13696991f, 0.18406625f, 0.18814892f, -0.06449418f, 
    -0.06450757f, 0.10922641f, -0.06154756f, -0.14287582f, 0.18455160f, 0.21435679f, 0.10786772f, 0.00792758f, 
    -0.09970394f, -0.03752524f, 0.12380496f, -0.15109046f, 0.07342125f, 0.15424497f, -0.34020406f, -0.20103669f, 
    -0.21658780f, 0.10295749f, 0.09642132f, 0.06618091f, 0.04448261f, 0.03696274f, 0.06066239f, -0.10714377f, 
    0.17222680f, 0.25048372f, -0.10500003f, 0.09222350f, -0.02898201f, -0.06006978f, -0.03663059f, 0.03766716f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.20207000f, 0.14045943f, -0.04182249f, 0.31718904f, 0.05939743f, -0.03037832f, -0.03103470f, -0.06058322f, 
    0.04240811f, 0.03294600f, 0.08846115f, 0.16079625f, -0.02536052f, -0.03580485f, 0.03688415f, 0.13902132f, 
    0.00273342f, -0.00460834f, -0.04815662f, 0.07604017f, 0.14765386f, -0.04547052f, 0.00056684f, 0.07330417f, 
    0.07747822f, -0.06142859f, 0.10412984f, -0.00537754f, 0.24939036f, 0.15367584f, -0.08035705f, 0.08868054f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16448019f, 0.05609796f, -0.08284913f, -0.14396304f, -0.12023064f, -0.11316765f, -0.12410281f, 0.03733316f, 
    0.04244521f, -0.11238596f, -0.14489973f, -0.18482289f, -0.12727740f, -0.08507939f, 0.13967134f, 0.03491235f, 
    0.06714099f, -0.12702991f, 0.03075967f, -0.06315034f, -0.04318468f, -0.02283914f, -0.04836020f, -0.08639484f, 
    -0.14908455f, 0.06568883f, 0.09429956f, 0.13989611f, -0.04288971f, -0.06759553f, -0.17146119f, 0.08070146f, 
    0.04960725f, -0.20171711f, 0.06625459f, -0.06804494f, -0.12778872f, -0.11449707f, 0.02716335f, -0.10541019f, 
    -0.15146703f, -0.01671521f, -0.13242663f, -0.13255599f, 0.09397881f, 0.10122238f, -0.00199192f, 0.06189275f, 
    -0.13354962f, -0.10443881f, -0.08794719f, 0.12924767f, -0.00335414f, -0.15695688f, 0.01299885f, 0.11489672f, 
    -0.18889721f, 0.08640110f, -0.11275209f, -0.10808811f, -0.14504036f, -0.03967725f, 0.12697281f, -0.03851883f, 
    -0.34172052f, 0.05170991f, -0.09818962f, -0.13666303f, -0.11322489f, -0.08551630f, -0.10985743f, 0.01564127f, 
    0.01745936f, 0.06117134f, -0.07462329f, 0.12224148f, -0.04173461f, -0.08991335f, -0.24093474f, 0.26586342f, 
    -0.13358928f, -0.09394272f, -0.10651656f, -0.16709490f, 0.19007553f, 0.10412913f, 0.57180023f, 0.05854907f, 
    -0.46488672f, -0.21924053f, -0.24719694f, 0.18714054f, -0.12531060f, 0.00027015f, 0.13100436f, 0.24362014f, 
    0.63698709f, 0.12001709f, -0.03905808f, 0.00982531f, 0.08718879f, -0.15121795f, 0.09777363f, 0.09077868f, 
    -0.08378638f, 0.20371366f, 0.08900718f, 0.07500718f, 0.00336695f, 0.02461110f, 0.19631340f, -0.04192051f, 
    0.00788911f, -0.03868493f, -0.21905309f, -0.17192595f, 0.32419363f, -0.08733473f, 0.29272297f, -0.14397408f, 
    0.34103808f, -0.02244486f, 0.28881592f, -0.37593630f, -0.10926462f, -0.23817909f, 0.12534079f, 0.11886690f, 
    0.11810161f, -0.04994614f, -0.12497962f, 0.07577312f, 0.29122642f, -0.02668769f, 0.15941481f, 0.22286664f, 
    0.00084314f, -0.04681566f, -0.03327679f, 0.32823735f, -0.14621103f, 0.16183235f, 0.52467763f, 0.25063255f, 
    -0.05055711f, 0.16217439f, 0.11899771f, -0.28440756f, 0.13356715f, 0.00105261f, -0.90953761f, -0.32729256f, 
    0.50218815f, 0.06547439f, 0.19368547f, -0.25703299f, -0.20378545f, 0.16637747f, 0.20191467f, -0.09401936f, 
    0.05839463f, -0.12452424f, -0.10817903f, 0.04851326f, -0.30864722f, -0.09887943f, -0.07183630f, 0.02365060f, 
    -0.05929361f, 0.16130094f, 0.22128168f, -0.53878111f, -0.05638463f, 0.02912163f, -0.16550173f, -0.04795693f, 
    0.06687997f, 0.15686816f, -0.20296735f, 0.06419127f, 0.00825935f, -0.05132446f, 0.24891484f, 0.31947264f, 
    -0.13979977f, 0.25285831f, -0.22599670f, 0.20287111f, 0.16572998f, -0.15619515f, -0.13167016f, 0.15713185f, 
    -0.15293540f, 0.16321485f, 0.15392780f, 0.20321012f, 0.20031381f, 0.16847564f, 0.06014793f, 0.26002905f, 
    -0.14610113f, -0.21133140f, 0.19300815f, 0.14513896f, 0.02536081f, -0.14738199f, -0.37621459f, -0.03478787f, 
    0.04485192f, -0.05367376f, -0.12136094f, -0.02361887f, 0.26519167f, -0.11788426f, -0.05003085f, 0.39466155f, 
    0.34406543f, 0.17120014f, 0.02010674f, -0.38971898f, 0.19509171f, -0.28863534f, -0.24415021f, 0.34691912f, 
    0.32106856f, 0.38276228f, -0.09188505f, 0.31856441f, 0.07856590f, -0.02862833f, 0.00635409f, 0.24170381f, 
    0.06579309f, -0.02342921f, -0.08571215f, 0.39293271f, -0.00512684f, -0.11920465f, 0.06827528f, 0.23805621f, 
    -0.04355236f, -0.01370923f, -0.26269680f, 0.17590217f, 0.30253270f, 0.11801796f, -0.51177460f, 0.03068578f, 
    0.45739099f, -0.16809127f, -0.24116598f, -0.20343252f, 0.51735193f, -0.40820369f, -0.20940338f, 0.21624459f, 
    -0.02389508f, -0.11501618f, 0.01627558f, 0.09747455f, -0.47053206f, 0.01546935f, 0.10542171f, -0.42766714f, 
    0.01737215f, 0.16876791f, 0.33361545f, -0.21030217f, 0.15369485f, -0.05809588f, 0.10197002f, -0.35546690f, 
    -0.08770631f, -0.05495417f, -0.40118697f, 0.27471131f, -0.00007033f, -0.10650820f, -0.38853660f, 0.57795560f, 
    -0.09853525f, 0.20117217f, 0.12555495f, 0.34357280f, 0.29152146f, -0.19089936f, -0.32440811f, 0.06959742f, 
    0.02144925f, -0.14161707f, 0.06196179f, -0.10168549f, -0.05682877f, -0.05270748f, -0.00068674f, -0.03324221f, 
    0.12320750f, 0.03724574f, 0.04977621f, -0.01234820f, -0.12609075f, 0.06326716f, -0.01828105f, -0.08420797f, 
    -0.01640412f, 0.08825845f, -0.12008191f, -0.12813973f, -0.08255229f, -0.00159184f, -0.06458450f, -0.06113417f, 
    -0.01121197f, -0.12993042f, 0.02781064f, -0.07285057f, 0.03612646f, 0.11302792f, 0.01819361f, 0.07189043f, 
    -0.12150221f, -0.03375756f, 0.09194419f, -0.19898021f, 0.08225359f, -0.16376029f, -0.03898497f, -0.21723452f, 
    -0.12266202f, -0.06284392f, -0.15859722f, 0.07457563f, 0.12903717f, -0.04889494f, 0.09703532f, 0.04588148f, 
    0.06108136f, 0.06357062f, -0.15702213f, -0.16064686f, 0.03715267f, -0.13025711f, -0.07775094f, -0.15082555f, 
    0.10886624f, 0.00659305f, -0.17080422f, -0.20069382f, -0.18000768f, -0.03202586f, 0.08325331f, 0.03385780f, 
    -0.10083754f, -0.16152544f, 0.16368338f, 0.12284785f, 0.28276503f, 0.07521056f, 0.10285853f, 0.05076542f, 
    0.16014528f, 0.23419982f, -0.04333245f, -0.01094836f, 0.09303609f, 0.08889808f, 0.08102268f, 0.15198280f, 
    0.01023509f, 0.16706486f, 0.01680472f, -0.21575792f, -0.19877437f, -0.15694524f, 0.62422353f, -0.16153161f, 
    -0.26434907f, 0.15918021f, -0.11532582f, 0.17639710f, -0.34440279f, -0.15372165f, 0.02604638f, -0.00421325f, 
    -0.00050868f, -0.14895877f, 0.00177226f, 0.12698451f, -0.06872014f, 0.05694953f, -0.09460074f, -0.15094620f, 
    0.01943709f, -0.14400405f, 0.30972767f, -0.41971305f, -0.01926194f, 0.14304705f, 0.08229971f, -0.33061528f, 
    0.04747820f, -0.06823077f, -0.45807087f, 0.09537552f, 0.04676331f, -0.10273916f, 0.08209915f, 0.20035709f, 
    -0.01198613f, 0.33505520f, -0.27365619f, 0.03050451f, -0.29627401f, -0.02343245f, 0.11131945f, -0.03712233f, 
    -0.02057586f, -0.17553742f, 0.00150683f, 0.15269729f, -0.02010512f, -0.05042199f, -0.12869652f, -0.20884378f, 
    0.01007148f, 0.28170168f, 0.31936783f, -0.25863740f, 0.01711617f, 0.13017567f, -0.20225580f, -0.37017810f, 
    0.13789876f, 0.04594314f, -0.01719765f, 0.27939716f, -0.28659952f, 0.04799869f, -0.11701731f, 0.20397712f, 
    0.20005906f, 0.34173429f, -0.07103989f, -0.30780414f, -0.14646985f, 0.02920176f, -0.04543316f, -0.02519696f, 
    0.16234519f, -0.06553192f, 0.01206464f, -0.16133638f, -0.10219869f, -0.04064121f, -0.03771753f, 0.03719883f, 
    -0.12755451f, -0.15246105f, -0.07166391f, -0.07217112f, -0.06908400f, -0.05680135f, -0.00673791f, -0.09872141f, 
    -0.03182226f, -0.09242155f, 0.03735722f, -0.10586740f, -0.03967097f, -0.11602566f, 0.13216253f, -0.01084974f, 
    -0.15650381f, -0.10326631f, -0.04727999f, -0.02621890f, -0.15590610f, 0.09758835f, -0.17049482f, -0.14098679f, 
    0.61675072f, -0.09883036f, -0.14163512f, 0.04510061f, -0.12627588f, -0.09650789f, -0.04318035f, 0.13460185f, 
    -0.12732685f, 0.13125253f, 0.21757223f, -0.22532706f, -0.04829474f, -0.12402767f, -0.28446475f, -0.33569568f, 
    -0.16505545f, -0.00109805f, -0.14968330f, 0.21297154f, 0.21158634f, 0.04214100f, 0.23031457f, 0.36847201f, 
    0.21933371f, 0.30083483f, 0.05581253f, -0.24563579f, 0.19639108f, -0.35620546f, 0.12028639f, 0.00677260f, 
    -0.40193632f, 0.20624438f, -0.07576496f, 0.26977581f, 0.34414211f, 0.00219236f, -0.00249877f, -0.00313478f, 
    0.06204894f, 0.47911674f, -0.04362940f, -0.02935343f, -0.10043576f, 0.04930498f, 0.62696773f, 0.32662842f, 
    0.08015768f, 0.12465397f, 0.05062123f, -0.39943129f, -0.02136746f, -0.00886445f, -0.25015548f, -0.08756217f, 
    0.28811902f, -0.07846812f, -0.45738003f, 0.19412242f, 0.09314908f, -0.16288917f, 0.08461504f, -0.03791835f, 
    -0.14649816f, 0.22449127f, -0.04349077f, 0.26565900f, 0.13366406f, -0.04376612f, 0.06584462f, -0.17583545f, 
    -0.12058915f, 0.28652424f, 0.02145066f, 0.21066974f, -0.09903284f, 0.08550107f, 0.11629688f, 0.48154318f, 
    0.04162077f, -0.03909242f, -0.17084388f, 0.09008863f, -0.07727619f, -0.12896302f, -0.04850452f, -0.29077080f, 
    -0.08836811f, -0.34328172f, -0.42013663f, 0.32786438f, 0.09455151f, 0.08813154f, 0.13433163f, -0.00391220f, 
    0.07101315f, 0.14588444f, -0.15838410f, 0.27307278f, 0.34772861f, 0.12158486f, -0.15671466f, -0.19234279f, 
    0.04369272f, 0.11962941f, 0.03942031f, 0.20157671f, -0.05070767f, -0.11289071f, -0.27481902f, 0.09420224f, 
    0.08383651f, 0.13730912f, -0.07402379f, 0.04982275f, 0.12397398f, -0.16650240f, 0.70443869f, -0.25922886f, 
    -0.37727970f, -0.15149906f, -0.12236866f, 0.04788797f, -0.22516009f, 0.08525094f, -0.03499099f, 0.12978175f, 
    0.01193177f, -0.12027496f, 0.16101423f, -0.19142689f, 0.06290539f, -0.03720697f, -0.05053952f, 0.12263174f, 
    0.10198595f, 0.07786445f, -0.04630519f, -0.10815731f, 0.07839812f, 0.07069532f, -0.14876226f, -0.12237820f, 
    0.12278224f, -0.15511015f, -0.16306807f, -0.11459896f, -0.12277302f, -0.05862216f, 0.12010282f, -0.14714479f, 
    0.09755932f, -0.00351234f, -0.03054244f, -0.04515285f, 0.10579600f, 0.00693231f, -0.11074175f, -0.02727187f, 
    0.12527007f, -0.07048719f, 0.14292264f, -0.23998970f, -0.16878855f, -0.13384777f, -0.10881975f, 0.16034290f, 
    0.01362382f, 0.11636331f, 0.12100700f, 0.18152893f, -0.13147409f, -0.10813197f, 0.09596331f, 0.37323037f, 
    -0.14332801f, 0.04599888f, -0.16590247f, -0.13198787f, 0.07777102f, -0.07675200f, -0.05805641f, 0.17151399f, 
    -0.14868394f, -0.16294028f, -0.00432813f, -0.00870864f, 0.17629218f, 0.10462184f, 0.02662173f, -0.17727380f, 
    0.05929879f, -0.14733906f, 0.16420329f, -0.17331305f, 0.04503320f, -0.11237182f, 0.02967290f, 0.08327528f, 
    -0.16612722f, -0.13049807f, -0.05365400f, 0.02805677f, 0.09074529f, 0.16137105f, 0.05309201f, 0.08493540f, 
    -0.00484843f, 0.00387419f, 0.05984974f, -0.06191784f, 0.01866433f, 0.13152833f, 0.03303865f, 0.12992987f, 
    -0.16159451f, -0.18762763f, 0.17402521f, -0.09539885f, 0.02372937f, -0.19928412f, -0.19499508f, -0.16149920f, 
    0.25371912f, 0.02292428f, 0.11568554f, -0.14487383f, -0.02339926f, 0.06732781f, 0.12640956f, -0.12614411f, 
    -0.08699095f, 0.33846319f, -0.03362744f, -0.15534995f, 0.04849735f, 0.11924451f, 0.17130004f, 0.32099402f, 
    0.08794249f, 0.02032871f, -0.24701269f, 0.28230566f, 0.07173534f, 0.04232094f, 0.40757319f, -0.28889096f, 
    -0.17111017f, 0.21744832f, -0.27310422f, 0.46508801f, -0.12836054f, -0.20295081f, 0.25410989f, -0.22659114f, 
    -0.37523845f, 0.05836530f, 0.16140135f, -0.13310483f, -0.21305159f, -0.13751228f, -0.09219359f, -0.21279961f, 
    -0.05709155f, 0.18602052f, -0.24469128f, 0.43783554f, 0.02076717f, -0.13262311f, 0.39770722f, 0.39284521f, 
    -0.10334218f, 0.15400547f, -0.21185221f, 0.05271737f, 0.28363976f, -0.02883785f, -0.07305461f, 0.21919344f, 
    -0.09230351f, -0.00168433f, -0.70794266f, 0.53250635f, 0.48464325f, -0.26279405f, -0.32454786f, 0.29504448f, 
    0.16531228f, 0.31608987f, -0.02868977f, 0.32036644f, -0.15359484f, -0.12026956f, 0.14207971f, -0.04901030f, 
    0.08056743f, 0.29110456f, 0.02071224f, 0.33699885f, 0.07345101f, -0.03696652f, -0.05693001f, 0.01639423f, 
    -0.02218674f, 0.17619151f, -0.15968664f, 0.16222064f, 0.23209642f, 0.08842415f, 0.03413314f, 0.05279312f, 
    0.37672246f, 0.18790339f, -0.13095301f, -0.05548127f, 0.75458241f, -0.17202820f, -0.27919108f, 0.36312625f, 
    0.13129704f, -0.17707337f, -0.15289833f, -0.01402185f, -0.12832165f, 0.10892330f, -0.05120172f, -0.08454194f, 
    -0.01316368f, -0.04613604f, -0.12800956f, 0.05962995f, -0.11324542f, 0.01445005f, -0.15041403f, 0.10639492f, 
    0.00611705f, -0.13729905f, -0.12795413f, 0.13893218f, -0.19822995f, 0.11570054f, 0.04108718f, 0.10714757f, 
    -0.15057467f, 0.04204933f, -0.03649403f, -0.14714922f, -0.02319151f, 0.09669837f, -0.00750899f, -0.16154894f, 
    -0.30039185f, 0.12919873f, -0.14088529f, 0.27986369f, 0.21175748f, 0.12774199f, -0.05902729f, -0.34349412f, 
    -0.01778401f, 0.11420195f, -0.05511503f, 0.02005036f, -0.03739256f, -0.01059772f, 0.07849550f, -0.04629420f, 
    -0.06008880f, -0.10510413f, -0.16438875f, 0.31826243f, -0.18547854f, -0.05834078f, 0.13426043f, 0.17756245f, 
    -0.38690525f, 0.04232303f, -0.57418233f, 0.26586226f, 0.00493924f, 0.37202269f, 0.18705903f, -0.19277461f, 
    0.51876521f, 0.04572744f, 0.15589519f, -0.25404388f, 0.13253285f, 0.13554691f, 0.06609748f, -0.25169629f, 
    0.10029227f, 0.27590996f, 0.18819988f, 0.04642924f, -0.02283587f, -0.11477537f, 0.02433729f, 0.20091462f, 
    0.13421015f, 0.04277320f, 0.05612748f, 0.28350589f, 0.08671042f, 0.05223861f, 0.43121737f, -0.36274162f, 
    -0.38649303f, -0.26165920f, 0.18914562f, 0.06394424f, -0.35299465f, 0.11595958f, 0.23877086f, -0.23433948f, 
    -0.37780675f, 0.04531068f, 0.03703102f, -0.06157954f, -0.26680529f, 0.10101055f, -0.04638017f, 0.24391000f, 
    0.14751291f, -0.14980672f, 0.03555458f, -0.14049515f, 0.16565642f, 0.04158625f, 0.13974598f, -0.43289354f, 
    0.11740386f, -0.00246779f, 0.08794022f, -0.16576496f, -0.09034418f, -0.06503949f, 0.13221255f, 0.30637217f, 
    0.12634455f, -0.00606983f, 0.23278321f, -0.01574180f, 0.21273208f, 0.22451565f, 0.13755882f, 0.18538600f, 
    -0.60193020f, -0.10256389f, 0.05363424f, 0.11055000f, -0.23177947f, -0.10203113f, -0.12349432f, -0.35345900f, 
    -0.01540131f, 0.19147128f, 0.35886481f, -0.27279684f, -0.10158312f, -0.13291161f, 0.26338574f, -0.06414514f, 
    -0.06958546f, 0.16756842f, -0.44891819f, 0.12835188f, -0.03308227f, -0.13871238f, -0.39919755f, 0.31246650f, 
    -0.13347431f, 0.18720590f, -0.34644994f, 0.32791704f, -0.07140175f, 0.50638986f, -0.11727591f, -0.01929152f, 
    0.05021846f, -0.14801562f, -0.08556645f, -0.14127839f, 0.15393567f, -0.17002165f, -0.08002184f, 0.04466135f, 
    0.09185208f, -0.17670937f, -0.06331765f, -0.06757254f, -0.06951912f, -0.06941818f, -0.17314817f, 0.13130513f, 
    -0.05395760f, 0.16562459f, 0.04080898f, -0.06100689f, -0.10681851f, -0.02074523f, -0.04614273f, -0.16139570f, 
    0.14180739f, -0.14828420f, -0.04309374f, 0.11490809f, 0.17663571f, -0.10867368f, -0.16762002f, -0.13931336f, 
    0.37610736f, -0.18653867f, 0.10849745f, 0.22426155f, 0.38746566f, -0.04696625f, -0.09524696f, -0.02022983f, 
    -0.00513565f, 0.27222082f, 0.15446672f, -0.17454205f, -0.07903109f, -0.00262714f, 0.11094335f, 0.06731983f, 
    0.00735597f, -0.00224223f, -0.11090995f, -0.03254529f, 0.07510553f, 0.00338634f, 0.55363733f, -0.34496760f, 
    -0.09662812f, -0.09096529f, 0.02297401f, -0.20641108f, -0.56086206f, 0.08399086f, 0.32261842f, -0.37611654f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00879365f, -0.07163965f, 0.09102946f, -0.03528382f, 0.03961053f, 0.13790490f, 0.19078140f, 0.21839090f, 
    0.22711186f, -0.12820525f, -0.05387812f, -0.22429393f, 0.15617003f, 0.06734135f, -0.14460358f, 0.04670179f, 
    -0.04086140f, 0.19282554f, 0.02965334f, -0.02573693f, 0.19817671f, -0.19095063f, -0.12030455f, 0.13690633f, 
    0.38359946f, -0.08460313f, 0.04207994f, -0.09581897f, 0.19523278f, 0.24819976f, -0.14097019f, -0.03390836f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00386637f, 0.00749171f, 0.40492499f, 0.10499579f, -0.02439407f, -0.24548042f, 0.12091736f, 0.15249120f, 
    -0.33498320f, -0.07722432f, 0.02859243f, 0.03207638f, -0.66554886f, -0.29381016f, -0.04919749f, -0.12084641f, 
    0.00109096f, 0.22068492f, 0.37652925f, 0.11407494f, 0.32820553f, 0.00780263f, -0.15944074f, 0.07605322f, 
    0.20033026f, 0.04690745f, -0.02014504f, 0.16571325f, -0.24058725f, -0.30051652f, -0.14080068f, 0.02233890f, 
    -0.12186837f, -0.09081135f, 0.08002570f, 0.07802467f, 0.03462621f, 0.19383025f, 0.11537891f, -0.05289138f, 
    -0.22910237f, 0.12034379f, -0.08632465f, 0.49299085f, -0.15420285f, 0.11130584f, -0.09416910f, 0.40659419f, 
    -0.12726781f, -0.08017235f, 0.12994659f, -0.12615916f, -0.19183703f, 0.05996109f, 0.45625898f, -0.11402328f, 
    0.20381157f, -0.03315177f, -0.14374577f, -0.07069579f, -0.04475990f, -0.63677752f, -0.01741291f, 0.23624016f, 
    0.12695217f, -0.05046274f, 0.44086608f, -0.01365199f, -0.49052322f, 0.29382214f, -0.26907423f, -0.28471777f, 
    -0.33286822f, 0.00088831f, -0.00764621f, 0.60970944f, -0.02622446f, 0.01660714f, 0.11664001f, -0.18113540f, 
    0.25326869f, 0.31236386f, 0.38843158f, 0.09321199f, -0.17522088f, 0.03300070f, 0.49980259f, -0.12206890f, 
    0.13302435f, 0.07169531f, 0.20539795f, 0.38970160f, 0.16606447f, 0.01889123f, 0.14854513f, 0.19107302f, 
    -0.01719075f, 0.09569252f, 0.19086374f, 0.29181868f, -0.12020922f, 0.18956324f, 0.01711507f, 0.31140122f, 
    -0.31357548f, 0.12044785f, 0.04097240f, -0.00342493f, -0.42250076f, -0.20993485f, 0.04887458f, 0.27432984f, 
    -0.06941149f, 0.15781473f, 0.09004679f, 0.07081170f, 0.16726421f, -0.11980958f, -0.19882132f, 0.25950202f, 
    0.23525412f, -0.12053294f, -0.18573649f, -0.03054605f, -0.15111944f, -0.51484615f, -0.05130635f, -0.15759885f, 
    -0.02829282f, -0.12733921f, 0.15332031f, 0.09296825f, -0.27121133f, -0.00071279f, -0.09282506f, 0.13541751f, 
    -0.04384369f, 0.13461046f, -0.04246064f, 0.25649643f, 0.26349118f, 0.14763814f, 0.07499747f, 0.09970220f, 
    -0.11704391f, -0.04447356f, 0.30902174f, -0.19370642f, -0.01682042f, 0.06203820f, 0.17730613f, -0.46045950f, 
    -0.06175834f, -0.10052389f, -0.05466836f, 0.64750415f, -0.57905287f, -0.20104259f, 0.15571837f, 0.63843161f, 
    -0.04888127f, 0.09342029f, -0.08714037f, -0.07806720f, -0.05631609f, 0.44124788f, -0.12005650f, 0.08661941f, 
    0.60033399f, -0.03565261f, -0.12143618f, -0.05101316f, -0.22469321f, 0.02312789f, 0.00523017f, 0.11952557f, 
    -0.08268199f, 0.05452630f, -0.14441152f, -0.09981772f, 0.07276531f, -0.14037628f, 0.17096749f, 0.14853069f, 
    -0.05585747f, 0.02189889f, 0.08467502f, 0.21797228f, 0.11237050f, 0.35056618f, -0.10338131f, -0.27288100f, 
    0.13560529f, -0.04828509f, 0.12639086f, -0.16510876f, -0.04609231f, -0.04519559f, 0.04022705f, -0.11821812f, 
    -0.14972022f, 0.15429822f, -0.06900109f, 0.02212800f, -0.09875242f, -0.07119445f, -0.13090685f, -0.15905255f, 
    -0.11563075f, -0.17278631f, -0.09022750f, 0.15203308f, -0.13985358f, -0.05269514f, -0.07710493f, -0.09620628f, 
    -0.18528897f, -0.15024455f, -0.14336878f, 0.03697462f, -0.08700816f, -0.05035378f, 0.01382613f, -0.14842509f, 
    0.12843412f, 0.06467809f, 0.19031715f, 0.11217571f, 0.06823812f, -0.25442547f, -0.09313453f, 0.06631157f, 
    0.15133519f, -0.04185216f, -0.12796053f, -0.28244892f, -0.71236056f, -0.02118605f, 0.13715963f, -0.04007149f, 
    -0.10692425f, 0.10260110f, -0.14505164f, -0.13565858f, 0.14963952f, 0.00895942f, 0.09036533f, -0.22971773f, 
    0.06812093f, -0.09605130f, -0.17168422f, 0.40556717f, 0.05097647f, 0.14713658f, -0.17671914f, -0.10313547f, 
    0.00388444f, -0.01600273f, 0.32690847f, 0.30569318f, 0.16657212f, -0.16857189f, 0.08970716f, 0.26624393f, 
    -0.04512843f, 0.13819429f, -0.14990275f, -0.05046468f, -0.39170071f, -0.25917941f, -0.09434089f, 0.00848043f, 
    0.38297746f, 0.10799336f, -0.15812431f, -0.11510552f, -0.13472018f, 0.18701205f, 0.21759635f, 0.34812167f, 
    0.12797034f, -0.08548314f, -0.09332655f, -0.00561492f, -0.24208066f, -0.15640807f, 0.11512601f, 0.15523858f, 
    -0.16113651f, 0.14304891f, 0.48719090f, -0.17878628f, -0.30552483f, 0.09046844f, -0.27314073f, -0.03979648f, 
    0.16742137f, -0.13244577f, -0.15393849f, 0.13636056f, -0.00967281f, -0.26369891f, 0.17592897f, -0.27410215f, 
    0.16518286f, 0.20005111f, 0.08357454f, 0.19852775f, -0.02520877f, 0.03437171f, 0.32130894f, 0.63975221f, 
    0.19466974f, -0.01918092f, 0.36169600f, 0.22037421f, -0.32280394f, 0.43660608f, -0.11229336f, -0.18080834f, 
    -0.11035455f, -0.17897347f, -0.22058725f, 0.06132606f, 0.00101493f, 0.01909270f, 0.04646402f, -0.18740967f, 
    -0.13903166f, -0.00647333f, 0.00234640f, 0.02843464f, -0.30611590f, 0.43255770f, -0.13022788f, 0.08865531f, 
    0.04765042f, 0.10579440f, -0.20642568f, -0.13179561f, 0.30824777f, -0.06043519f, -0.24474269f, -0.35906109f, 
    -0.08010421f, 0.13018207f, 0.00281560f, 0.41269091f, -0.11939752f, 0.11907957f, 0.04898351f, 0.28652650f, 
    -0.12359281f, -0.04605992f, 0.01072208f, 0.15016977f, -0.08577622f, 0.36067805f, 0.43348330f, 0.18428807f, 
    0.39307684f, 0.14226313f, -0.01442649f, -0.58330679f, 0.47751814f, 0.36830124f, -0.15448710f, 0.38831562f, 
    -0.37567368f, -0.29228511f, -0.10384877f, 0.16096853f, 0.01689629f, 0.17927599f, -0.39035460f, -0.13637428f, 
    0.20332894f, 0.14909478f, -0.20844504f, -0.42751378f, 0.08288202f, 0.27746302f, -0.13430189f, -0.45004204f, 
    0.09584245f, 0.11446646f, -0.09805625f, -0.22028084f, -0.06028005f, 0.28223088f, -0.06309988f, 0.16891931f, 
    0.31708461f, -0.11726273f, 0.12093779f, 0.07745149f, -0.00525598f, 0.30317622f, 0.08932670f, 0.04303050f, 
    0.31398258f, 0.16505626f, -0.16337930f, -0.12400390f, 0.30332613f, 0.05580072f, 0.20307110f, 0.29178348f, 
    0.21985961f, -0.08398852f, 0.01281848f, -0.49713153f, 0.24976747f, 0.49248055f, 0.00970185f, -0.28785408f, 
    -0.07498351f, 0.18477038f, -0.44587088f, -0.07644588f, -0.37176791f, 0.04863733f, -0.31419930f, -0.15963104f, 
    0.67369485f, 0.09035871f, -0.06964298f, 0.11126674f, 0.44015959f, 0.35235897f, -0.16840945f, 0.06701269f, 
    -0.02372383f, -0.08780241f, -0.06796079f, 0.06800830f, 0.05495315f, -0.13269056f, 0.05339841f, -0.08644894f, 
    0.04827457f, -0.02657994f, 0.38660148f, -0.04160976f, 0.08984995f, 0.58070147f, 0.04252457f, 0.10986006f, 
    0.13148540f, -0.07587434f, -0.10564674f, 0.23848426f, 0.13448600f, -0.14372772f, -0.10692783f, 0.07639964f, 
    -0.43564427f, 0.12136895f, 0.03060151f, 0.29272160f, -0.10275106f, 0.01836601f, 0.06908640f, 0.21404679f, 
    0.28562534f, 0.38301054f, 0.16552906f, 0.12373836f, 0.16469143f, 0.12200804f, 0.16994810f, -0.35304525f, 
    -0.06067229f, 0.01264267f, 0.20025323f, 0.22612083f, -0.12178877f, -0.02230144f, 0.03922114f, 0.66072565f, 
    0.08870411f, -0.00397047f, 0.32532430f, 0.02339850f, -0.17654555f, 0.15980452f, 0.05530138f, -0.15032247f, 
    -0.43986189f, -0.04144782f, -0.01263578f, 0.30105859f, 0.31829587f, 0.16460511f, -0.08916908f, 0.30102831f, 
    0.00059488f, -0.15303399f, 0.37084675f, -0.00301870f, -0.16046625f, -0.14848229f, 0.10273527f, -0.46121630f, 
    -0.03671475f, 0.13502519f, 0.26480600f, 0.08193500f, 0.03430292f, -0.10994893f, -0.06708000f, 0.46411514f, 
    0.04491504f, 0.13125353f, 0.28364977f, -0.06537656f, -0.02895891f, -0.09725202f, -0.34074244f, -0.02344932f, 
    -0.02889555f, 0.06010739f, -0.07414465f, 0.19534618f, 0.23987634f, -0.11104324f, -0.06254331f, -0.18082964f, 
    0.50534320f, 0.46896973f, 0.32414097f, 0.07854297f, 0.08877947f, -0.13809529f, 0.29760882f, 0.11253475f, 
    -0.06815264f, 0.09937616f, 0.70786798f, 0.18652943f, 0.02699829f, 0.45749155f, 0.07206251f, 0.47613180f, 
    -0.05841990f, 0.08983105f, -0.25356543f, -0.02583104f, -0.29027024f, 0.36398691f, 0.32165501f, 0.37492093f, 
    0.68094563f, 0.02802314f, 0.12615281f, -0.18120612f, 0.71660244f, 0.25913769f, -0.14285487f, 0.35005203f, 
    -0.13399042f, -0.13534851f, -0.04199580f, -0.01031010f, -0.19975741f, -0.01008839f, -0.05302715f, -0.08255108f, 
    0.08271659f, 0.11100388f, 0.07935730f, -0.47219703f, -0.19495657f, 0.43550256f, -0.07982946f, -0.09605368f, 
    0.06132473f, -0.06732418f, -0.10986709f, -0.06652234f, -0.29224569f, 0.41550422f, -0.22581719f, -0.23378547f, 
    0.24145304f, -0.16315155f, -0.09127958f, 0.18122308f, 0.53011853f, 0.23545863f, 0.04689971f, -0.01176372f, 
    -0.13617970f, 0.19329180f, -0.06424930f, -0.04379634f, 0.12259433f, 0.06770162f, 0.43309277f, -0.13150826f, 
    0.05256169f, 0.04318141f, 0.17486072f, 0.32868692f, -0.26471275f, 0.37930959f, 0.01618045f, 0.31863129f, 
    -0.10306334f, -0.03636815f, -0.25380754f, -0.16131325f, -0.22396968f, 0.07871396f, 0.12095039f, 0.20416988f, 
    0.38873371f, 0.05839189f, -0.15596198f, -0.27395767f, 0.11606622f, 0.33128959f, 0.10691307f, 0.02118499f, 
    -0.22504590f, 0.09975076f, 0.16728552f, -0.05249249f, -0.15767290f, 0.03427909f, -0.18483929f, -0.10554345f, 
    0.26718363f, -0.08426712f, 0.36545229f, -0.01810343f, -0.03047337f, 0.37151936f, 0.15938137f, -0.17852926f, 
    -0.13214637f, 0.11615132f, -0.25758091f, 0.32493475f, 0.06629327f, 0.11498662f, -0.07729490f, -0.22243604f, 
    0.46583030f, 0.09478999f, 0.16268551f, -0.19844785f, 0.15852414f, 0.39084458f, -0.08550847f, 0.30086908f, 
    -0.13403310f, -0.44654724f, -0.62849313f, -0.10170273f, 0.21462883f, 0.04113167f, -0.22751206f, -0.91647619f, 
    0.06664667f, -0.14396642f, -0.25469571f, 0.00526487f, 0.02339733f, 0.14580467f, -0.00317058f, 0.48878479f, 
    0.01159903f, -0.11063690f, -0.09685311f, 0.13141146f, 0.02219323f, -0.08666239f, 0.17663361f, 0.35824895f, 
    -0.22880203f, -0.00313539f, -0.06063486f, -0.08232314f, -0.42344108f, 0.24335776f, -0.09640805f, 0.00906797f, 
    0.48044130f, 0.15485212f, -0.09212295f, 0.12601264f, 0.06209509f, 0.12841755f, -0.33089060f, 0.00104697f, 
    0.27543893f, -0.08997735f, -0.11598481f, -0.48730209f, -0.11008033f, -0.05253337f, -0.10891070f, 0.10718018f, 
    -0.15475048f, -0.15744339f, -0.05767794f, -0.14174365f, 0.03611110f, -0.04085197f, -0.13468534f, -0.19642261f, 
    -0.13099398f, -0.04964346f, -0.07881065f, -0.10391092f, 0.11385305f, -0.01653343f, -0.03743390f, -0.05762610f, 
    0.07272656f, -0.18785141f, -0.10214718f, 0.10324285f, 0.11406648f, 0.04939668f, 0.06453963f, -0.07430482f, 
    0.09206490f, -0.04885802f, -0.07544713f, -0.03690302f, -0.08570176f, -0.00327476f, 0.16584188f, 0.13809967f, 
    0.13728133f, 0.14465736f, -0.56979054f, 0.03756115f, 0.25836852f, -0.24821685f, -0.03653163f, 0.48613900f, 
    0.05552275f, -0.01048633f, -0.13163249f, -0.10578569f, -0.17382465f, -0.03008782f, 0.17450508f, -0.25385159f, 
    0.50008219f, 0.22522055f, -0.04271190f, -0.05154233f, -0.27473930f, 0.02231478f, -0.05587390f, 0.13757089f, 
    0.27018252f, -0.19177262f, 0.01519644f, -0.46120706f, -0.30731300f, 0.06927253f, -0.15586346f, 0.02475348f, 
    0.08027802f, 0.03667106f, -0.07300837f, -0.51916075f, 0.07859796f, -0.21600221f, -0.02565694f, -0.00088370f, 
    0.08502493f, -0.06305347f, -0.02435123f, 0.06549620f, 0.09308354f, 0.09596980f, -0.16501306f, -0.44120821f, 
    -0.05445950f, -0.40044501f, -0.35750321f, 0.01297432f, -0.12134869f, 0.16721860f, 0.01030940f, 0.02269438f, 
    -0.25413531f, 0.16960317f, 0.37221014f, -0.03541683f, 0.13145222f, -0.35897654f, 0.12584263f, -0.30508158f, 
    0.03698564f, 0.12901384f, 0.19027135f, 0.33690655f, -0.38974977f, 0.07379806f, 0.49801284f, 0.36449844f, 
    0.11875672f, -0.17045674f, -0.03056484f, 0.07715511f, 0.00808125f, -0.00939608f, 0.08069351f, 0.18253204f, 
    -0.14399512f, -0.16399302f, 0.35554996f, 0.21520136f, 0.03964751f, 0.04301766f, -0.31368214f, 0.08114510f, 
    0.30785874f, -0.03827789f, 0.09814647f, -0.36422646f, 0.06977051f, -0.22558644f, -0.02033421f, -0.14303567f, 
    -0.01067049f, 0.01995036f, 0.52031153f, 0.08956647f, -0.18579432f, 0.05853841f, 0.21128368f, 0.18923707f, 
    -0.21239142f, -0.04499920f, 0.06881499f, -0.02783476f, -0.24811044f, -0.45088872f, -0.08174013f, 0.24242088f, 
    0.08300112f, -0.14375751f, 0.25568852f, 0.15550750f, 0.10807639f, 0.16724592f, -0.12734386f, 0.30377641f, 
    -0.01532451f, -0.03294600f, 0.01397420f, -0.06990179f, -0.44271758f, -0.14319651f, 0.05010672f, -0.02270222f, 
    -0.11393522f, 0.15529659f, -0.17125811f, -0.06635185f, -0.37772492f, 0.33440480f, 0.30355489f, 0.46850184f, 
    0.32425886f, 0.06002935f, 0.10531501f, -0.40394917f, 0.14853548f, 0.09841318f, 0.02707261f, 0.35578966f, 
    -0.18603520f, 0.11952028f, -0.08287572f, -0.07562009f, -0.08228194f, 0.14221096f, -0.00885500f, 0.28823176f, 
    0.31594673f, 0.00980167f, -0.02886073f, -0.06558379f, -0.45429167f, -0.25664857f, -0.07387080f, -0.45173684f, 
    -0.04517883f, -0.10773014f, -0.12300978f, 0.36182258f, -0.00662890f, 0.05384059f, -0.16195811f, 0.19112559f, 
    0.31990460f, 0.00869696f, -0.11906937f, -0.38400063f, 0.04418409f, 0.04099412f, -0.16193368f, 0.32960129f, 
    -0.12272932f, -0.26918641f, -0.17685813f, -0.08739307f, 0.10194819f, 0.18790664f, 0.46881351f, -0.31550124f, 
    0.20468830f, 0.00073127f, -0.85111284f, 0.32730716f, -0.32925716f, -0.66813111f, 0.12293241f, 0.47770911f, 
    -0.16545320f, -0.10233954f, -0.04849526f, -0.01876849f, 0.21335840f, -0.36350861f, 0.15514436f, 0.10308720f, 
    -0.27591705f, -0.10755695f, -0.09386358f, -0.14877324f, -0.61683452f, -0.44139531f, 0.11751401f, -0.15856646f, 
    -0.30855045f, 0.27378815f, 0.40348598f, 0.04557848f, 0.09576060f, 0.15968667f, 0.08500101f, -0.20166938f, 
    0.27441925f, -0.08064500f, -0.01358055f, 0.15399034f, -0.03801259f, -0.37871104f, -0.11409146f, -0.03472330f, 
    0.10372308f, -0.05186389f, -0.33124167f, -0.14552552f, -0.12071577f, 0.11064303f, 0.29555485f, -0.07050367f, 
    -0.23394184f, 0.09329007f, 0.02702503f, -0.00223664f, 0.35076979f, 0.40176752f, -0.09288976f, -0.09174658f, 
    0.09388416f, 0.09280951f, 0.19529472f, 0.15479627f, -0.18969458f, -0.13648815f, -0.42858723f, -0.39978364f, 
    0.12826374f, -0.07253653f, -0.04539454f, -0.09932122f, 0.00964380f, 0.27984968f, 0.08115611f, 0.28108305f, 
    -0.17275415f, 0.11469617f, 0.19033016f, 0.19585201f, 0.10017651f, -0.10332265f, 0.10639210f, -0.12608892f, 
    -0.03596337f, 0.08924662f, -0.08843859f, -0.05645514f, -0.51125407f, 0.12752710f, -0.04915288f, -0.00653224f, 
    0.02521741f, -0.05896533f, -0.24003620f, -0.00442892f, 0.29514000f, 0.02330164f, 0.03741186f, -0.40840617f, 
    -0.07284550f, 0.15254100f, 0.11142942f, 0.01480902f, 0.15226267f, 0.04769589f, 0.06487251f, -0.60870308f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.18280099f, -0.49560696f, -0.11139432f, 0.26916403f, 0.06810121f, -0.24784832f, 0.12874812f, 0.37933096f, 
    0.04841830f, 0.03742286f, 0.12653813f, 0.17413795f, 0.18260472f, 0.10654189f, 0.13805234f, -0.15621118f, 
    0.22506399f, 0.16283073f, -0.01661261f, 0.32874957f, 0.28260604f, 0.23815525f, -0.14346857f, -0.02170442f, 
    -0.02000625f, -0.03316561f, 0.17298202f, -0.05611864f, -0.16463199f, 0.28809536f, 0.05353346f, -0.29777056f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.14169948f, 0.27378601f, 0.39377850f, -0.19035621f, 0.18779397f, -0.01761774f, -0.00615860f, -0.09477320f, 
    -0.03511241f, 0.16174990f, -0.15692973f, -0.15435004f, 0.08346261f, -0.25480944f, 0.12951800f, 0.11106111f, 
    0.08816132f, -0.74555039f, 0.30755326f, -0.65427434f, -0.72133529f, -0.55309886f, -0.14336222f, -0.25687286f, 
    0.15756027f, -0.83149308f, -0.21830639f, -0.68340296f, 0.27126256f, -0.19770709f, -0.61993241f, 0.01737110f, 
    0.26251832f, -0.07292777f, 0.07665372f, 0.17308930f, 0.20245744f, -0.23789075f, 0.08787037f, 0.11263887f, 
    0.15477377f, 0.14198443f, 0.05444380f, -0.36244017f, -0.25681168f, -1.15224147f, 0.15257792f, 0.19763167f, 
    0.13478744f, -0.63979107f, -0.25572786f, -0.09576863f, 0.19647455f, 0.06104771f, -0.14929742f, -0.10331977f, 
    0.06236479f, -0.04520367f, 0.23825082f, -0.29231864f, 0.39453205f, 0.03008390f, -0.23130859f, -0.18092583f, 
    -0.45080632f, -0.28941920f, -0.91577148f, -0.14907116f, -1.15931511f, 0.09639788f, 0.01221111f, 0.14659792f, 
    -0.10360575f, 0.27482513f, -0.28263208f, 0.12119407f, 0.32189554f, 0.14926234f, -0.57478833f, -0.41979513f, 
    -0.03728440f, 0.08757897f, -0.07885952f, 0.22006834f, -0.54156309f, -0.03013942f, -0.17034176f, 0.06074967f, 
    0.06014484f, 0.03505940f, -0.06764668f, 0.28953409f, -0.67148060f, -0.09532906f, -0.30637968f, 0.02881585f, 
    -0.27543703f, -0.76409096f, 0.02247639f, -0.48611158f, -0.30917004f, 0.27413625f, 0.10800204f, 0.26933432f, 
    -0.12107264f, 0.28429979f, -0.42240354f, -0.64284569f, 0.17527828f, 0.37836361f, -0.12435508f, -0.40465319f, 
    0.12296019f, -0.08154105f, 0.10337695f, 0.14467363f, -0.50921750f, -0.11712522f, 0.06080687f, 0.25287139f, 
    -0.71658260f, -0.41739959f, -0.42824578f, -0.12186923f, 0.51727539f, 0.60060871f, -0.20681280f, -1.43496501f, 
    -0.16438411f, 0.10693670f, 0.14122279f, -0.49183008f, 0.08743829f, -0.11277103f, 0.08264784f, 0.25334573f, 
    -0.27631643f, -0.15771152f, 0.10268670f, -0.87533844f, -0.00708110f, 0.23570639f, 0.18446702f, 0.36411399f, 
    0.07113775f, -0.17047118f, 0.13387743f, -0.02698822f, -0.11884580f, -0.01545168f, 0.14893927f, -0.09262493f, 
    -0.42339018f, -0.04196617f, -0.27105954f, -0.38641804f, -0.71633309f, -0.23019040f, 0.40766820f, 0.03485396f, 
    -0.03156015f, 0.12148813f, 0.12813666f, 0.23499088f, -0.30602819f, 0.10311599f, -0.05802618f, 0.02813693f, 
    0.09088790f, 0.09889788f, 0.39085758f, -0.34380376f, 0.27900070f, -0.45023483f, -0.13314241f, -0.15908819f, 
    -0.02629647f, -0.13154612f, -0.10616868f, -0.09325957f, 0.20650929f, 0.25292608f, -0.16320755f, 0.00249287f, 
    -0.00684200f, 0.08557805f, 0.18029481f, 0.09308649f, -0.08556921f, -0.47154719f, -0.13722898f, -0.06526772f, 
    0.06700476f, -0.41077048f, -0.60772455f, -0.74850643f, -0.71452731f, 0.05218076f, 0.12002262f, 0.04000081f, 
    -0.66648257f, -1.03633118f, 0.10472013f, 0.33690086f, 0.08814271f, 0.37257352f, -0.96718723f, -0.17085810f, 
    -0.86981946f, 0.18036203f, 0.05584002f, 0.21405730f, 0.38177386f, -0.15665217f, 0.09197658f, -0.46054783f, 
    0.07008035f, 0.07323217f, -0.18980791f, -0.06164920f, -0.23028214f, 0.15470903f, 0.25266594f, -0.22575897f, 
    -0.15634082f, 0.26046664f, -0.38179073f, -0.21636024f, 0.42597544f, 0.07710946f, -0.02676432f, -0.02207595f, 
    0.00077848f, -0.14102237f, -0.27230376f, -0.10897519f, -0.68843299f, 0.24352859f, -0.19939743f, -0.00371262f, 
    -0.22777499f, -0.01306507f, 0.21970369f, -0.20088568f, 0.20734902f, -0.64376301f, -0.13537371f, -0.59145004f, 
    -0.80161345f, -0.07230668f, 0.14192206f, 0.19984689f, 0.32677531f, 0.25994208f, -0.71918321f, 0.18335307f, 
    0.32851151f, 0.01346795f, -0.45819721f, 0.39953277f, 0.19058642f, -0.07591346f, 0.00196125f, -0.03997047f, 
    0.02325495f, -0.47625974f, -0.27356428f, -0.07491252f, -0.28138673f, -0.60779196f, 0.04175551f, -0.17955893f, 
    -0.77989113f, -0.19177423f, -0.50599205f, -0.02887492f, -0.43556100f, 0.13854258f, -0.13548012f, -0.01637481f, 
    -0.05031679f, 0.18590380f, 0.32138121f, 0.35266101f, 0.17407015f, 0.38866976f, -0.08058512f, -0.00794288f, 
    -0.41275570f, -0.45086923f, -0.26155192f, -0.35902581f, 0.14929776f, -0.04197219f, 0.04486820f, 0.00115076f, 
    -0.54404080f, -0.35222644f, 0.01224908f, -0.05120860f, 0.03361509f, 0.15689495f, 0.03523602f, 0.30001551f, 
    0.01715557f, 0.18426256f, 0.35429400f, 0.23605296f, -0.01715233f, -0.29737505f, 0.12578590f, -0.36203212f, 
    -0.18980648f, -0.21945485f, 0.03869550f, 0.13147815f, -0.56069285f, 0.29823950f, 0.13739946f, -0.27991554f, 
    0.05395337f, -0.58437485f, -0.73786414f, -0.02031839f, -0.39974949f, -0.51102263f, 0.11923138f, -0.29495209f, 
    0.43331340f, -0.37199152f, 0.09827044f, -0.45056081f, 0.15215543f, -0.36874440f, 0.29460040f, -0.44822457f, 
    0.12236501f, -0.15641932f, -0.63777202f, -0.27013040f, -0.49117258f, 0.53388435f, -0.02246570f, 0.43190545f, 
    -0.07763897f, -0.18562868f, 0.12971452f, -0.09962098f, -0.94223207f, -0.25077263f, 0.31304944f, -0.83929944f, 
    -0.44576639f, 0.08544685f, -0.46890435f, 0.08605483f, -0.34661672f, -0.21268579f, -0.03713799f, -0.73989093f, 
    0.01671186f, -0.40099251f, -0.63513267f, 0.29253134f, 0.07036944f, -0.35761917f, -0.28963092f, 0.07237902f, 
    -0.37618795f, 0.11414636f, -0.21936804f, -0.10791479f, 0.12819736f, 0.10121615f, 0.05964125f, 0.11489913f, 
    -0.35309619f, 0.25856692f, 0.27708030f, 0.09836951f, 0.17036992f, -0.83942378f, 0.00631566f, -0.46854067f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.25091049f, 0.35112882f, 0.31576478f, -0.05973895f, -0.04483954f, -0.04092226f, 0.19138508f, -0.36308864f, 
    0.11538267f, 0.36401829f, 0.14947283f, -0.04634455f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
