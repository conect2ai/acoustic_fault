#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.20186114f, 0.78800434f, 0.32905817f, 0.28754863f, -0.14023121f, -0.50826591f, -0.84256470f, 0.39510635f, 
    0.38767192f, 0.54611796f, 0.07750867f, 0.06500327f, -0.02775137f, -0.05685721f, -0.28454116f, -0.08879725f, 
    -0.19309106f, -0.05183293f, 0.21069644f, -0.08738407f, 0.24164325f, 0.23454954f, 0.12359398f, -0.14041539f, 
    0.20213263f, 0.59866309f, 0.12710652f, 0.35874733f, 0.25710642f, 0.39133206f, -0.71971720f, -0.35882393f, 
    -0.30648839f, -0.49000633f, -0.57607019f, -0.23229720f, 0.20008767f, -0.23230085f, 0.03690639f, 0.30634385f, 
    -0.08770324f, -0.05410630f, -0.15752526f, 0.47491509f, -0.21506219f, -0.57011467f, 0.01238472f, -0.07647473f, 
    0.06211443f, -0.02933300f, -0.08601560f, 0.61667567f, -0.50012499f, -1.05694044f, -0.50377011f, 0.74900657f, 
    -0.69319880f, -0.16337547f, 0.17145111f, -0.27245072f, -0.08941017f, 0.08080819f, 0.38364482f, 0.29374760f, 
    0.08065382f, 0.28517291f, 0.05959336f, 0.01588619f, -0.03203734f, 0.31988680f, -0.20938928f, -0.02638566f, 
    0.12945238f, -0.15703730f, 0.35032418f, -0.92988336f, 0.93364269f, -0.04122754f, -0.29319528f, 0.16153446f, 
    -0.60502994f, 0.75970131f, 0.25185511f, 0.16114736f, 0.56680107f, -0.09157939f, 0.24221046f, 0.27446234f, 
    -0.23924111f, 0.03826186f, -0.21916310f, 0.00974565f, 0.13349682f, 0.02705720f, 0.16588303f, 0.16990680f, 
    0.44895640f, 0.08313489f, 0.25020748f, -0.12155146f, 1.23234582f, -0.38984045f, 0.15757465f, 0.60403872f, 
    0.38567087f, 0.77551359f, 0.25406781f, -0.40954936f, -0.39159483f, -0.27754661f, -0.02085761f, 0.04670012f, 
    -0.18909648f, 0.22062753f, -0.17812727f, 0.13660291f, 0.02076305f, 0.23223466f, 0.24613729f, -0.09439942f, 
    0.05861199f, -0.09098779f, -0.01070920f, 0.03642004f, 0.37995350f, -0.39601421f, 0.37847778f, 0.68413365f, 
    0.46468559f, 0.37705502f, 0.32999313f, 0.17011468f, 0.49948341f, -0.12208143f, 0.54792374f, 0.03935339f, 
    -0.31778228f, 0.40741223f, -0.01709722f, -0.37504756f, -0.29365745f, -0.49866828f, -0.13605514f, -0.16745044f, 
    -0.52893937f, 0.18465470f, 0.00108102f, -0.07314093f, 0.20262682f, -0.08495422f, -0.82970345f, -0.94590265f, 
    0.48202342f, 0.78919411f, -0.24236256f, 0.48552299f, 0.54902184f, 0.60484582f, -0.21918197f, -0.53637189f, 
    -0.33807811f, -0.37743074f, -0.25512666f, 0.37731826f, 0.24918884f, -0.02893143f, -0.16816172f, -0.42930001f, 
    -0.22307219f, 0.18486725f, -0.20486136f, 0.34841841f, 0.10416941f, 0.29758102f, -0.14973980f, -0.43559685f, 
    -0.12760268f, -0.86364555f, 0.06181306f, 0.39393637f, -0.27010417f, 0.91592664f, 0.53770530f, 0.50833529f, 
    0.44048589f, 0.13404587f, -0.20889179f, 0.42412788f, 0.04745173f, 0.25502869f, -0.26555243f, -0.56055778f, 
    -0.24042004f, 0.00701278f, -0.07262043f, 0.01483066f, -0.04267494f, 0.02335939f, -0.23442827f, -0.11003035f, 
    -0.61559004f, -0.22144215f, 0.61301011f, -0.52566999f, -0.53962713f, 0.12519254f, 0.23084961f, -0.72981095f, 
    -0.36550590f, 0.11577223f, -0.17272539f, 0.53651023f, -0.29684824f, 0.09306003f, 0.03430004f, 0.20781955f, 
    -0.16604863f, -0.22553445f, -0.07985283f, -0.20719379f, -0.14098041f, 0.05844339f, 0.34170061f, 0.03627717f, 
    -0.10672911f, -0.25834081f, -0.89780575f, -0.29903480f, -0.27311370f, -0.23592912f, -0.24947149f, -0.73946255f, 
    0.32501367f, 0.46119460f, -0.40853682f, 0.47635052f, 0.01425943f, -0.13967822f, 0.51178181f, 0.10177965f, 
    0.38683668f, 0.27885354f, -0.03550917f, 0.18023996f, 0.45853558f, -0.04761027f, -0.09459391f, 0.22352642f, 
    -0.30389053f, 0.30008060f, 0.84994864f, 1.02495623f, -0.04479469f, 0.45711282f, 0.85558814f, -0.01579701f, 
    0.04589773f, 0.01271016f, -0.13848251f, -0.39144111f, 0.09487752f, 0.28506646f, -0.23345868f, 0.11130245f, 
    -0.24070422f, 0.30335653f, -0.18141419f, -0.34873047f, -0.08553069f, -0.01096641f, -0.09810401f, -0.06831305f, 
    0.17876057f, 0.00574521f, 0.41981813f, -0.43472353f, 0.09278163f, -0.46263027f, -0.65475106f, -0.10775574f, 
    -0.53044337f, -0.09695359f, 0.56868184f, 0.43434930f, 0.39180881f, -0.55525219f, 0.12230595f, 0.36903468f, 
    -0.10429226f, -0.50073814f, 0.31613991f, 0.21701519f, -0.19960099f, -0.02815746f, 0.19299804f, 0.05436542f, 
    -0.39852518f, -0.05329476f, -0.45895892f, -0.17724890f, 0.87841296f, 0.61779571f, -0.52710581f, -0.87602150f, 
    -0.99167097f, 0.34063110f, 0.52927262f, 0.35340443f, -0.07013720f, 0.14268354f, 0.50466388f, 0.03344820f, 
    -0.20431155f, 0.00592806f, -0.21252911f, 0.11522049f, -0.07617392f, 0.03258428f, 0.15386891f, 0.09423542f, 
    0.27418464f, -0.01896558f, 0.01198205f, -0.05261155f, 0.15829189f, -0.50133818f, 0.31568357f, 0.03775549f, 
    -0.32463041f, 0.35418978f, 0.38203076f, 0.19375147f, 0.31184152f, 0.14232047f, -0.04136100f, -0.07610913f, 
    -0.44575185f, 0.03150778f, 0.29716349f, 0.67025000f, 0.25169352f, 0.05771364f, -0.16730402f, 0.33626410f, 
    0.27966425f, 0.72949499f, -0.11355088f, 0.23733437f, 0.37263393f, 0.05990835f, -0.65482187f, -1.15692616f, 
    -0.69556993f, 0.21477568f, -0.09803720f, 0.62648439f, 0.91543096f, 0.36076418f, 0.29338124f, 0.28599620f, 
    -0.45020992f, 0.26960674f, -0.18431295f, 0.30419365f, 0.04810912f, -0.09663686f, 0.13399695f, 0.15468201f, 
    -0.14114150f, -0.03037425f, 0.05226068f, -0.03052711f, 0.11010262f, -0.14821081f, 0.07391115f, 0.98597008f, 
    -0.30432823f, 0.88815892f, -0.18302961f, -0.36580598f, 0.11741006f, -0.07057936f, 0.46222323f, -0.07159949f, 
    -0.57068139f, -0.08748451f, 0.16564973f, 0.14610271f, 0.51067841f, 0.00430443f, -0.12357567f, 0.08990106f, 
    -0.33370447f, 0.11993214f, 0.32505748f, -0.46040061f, 0.11918432f, 0.21594712f, 0.38391486f, -0.18815163f, 
    -0.59928012f, -0.60640591f, -0.47864041f, 0.10374700f, 0.12537478f, -0.32642645f, -0.84783787f, -0.85603487f, 
    -0.49060374f, -0.03232663f, -0.03927355f, -0.05791615f, 0.36828461f, -0.19629405f, -0.03135974f, 0.09128303f, 
    -0.33602160f, -0.25306332f, 0.44795394f, 0.02830413f, -0.14087677f, 0.35786048f, -0.09912007f, 0.12304080f, 
    0.13383050f, 0.33456177f, 0.61634952f, -0.37690216f, -0.59617794f, -0.00659772f, -0.18482842f, -0.90384698f, 
    -0.52526909f, -0.76225728f, -0.50306875f, 0.20243885f, 0.41681239f, 0.16062371f, -0.35707194f, -0.31242055f, 
    -0.30690455f, -0.22877894f, -0.17447524f, -0.10329743f, -0.14004530f, 0.35864478f, 0.09118458f, -0.03142709f, 
    0.15406865f, 0.00023616f, 0.55358225f, 0.29959309f, 0.61492985f, 0.73007119f, 0.58684421f, 0.31463695f, 
    0.35547751f, 0.55448383f, -0.12901871f, 0.45969501f, -0.64482850f, -0.45252830f, -0.08611777f, 0.41336238f, 
    0.05088765f, -0.05312759f, 0.12630269f, 0.18787436f, 0.08849509f, -0.04447372f, -0.10620692f, -0.25894141f, 
    -0.15153675f, -0.18171161f, -0.02002199f, -0.33758202f, 0.30039150f, 0.89233184f, 0.76332241f, 0.54314417f, 
    0.12484396f, -0.10569276f, 0.08608522f, -0.02516598f, 0.21359958f, -0.07540169f, -0.05968532f, -0.46028149f, 
    -0.33372396f, -0.00102993f, -0.01447385f, -0.06251011f, 0.54512984f, -0.08092628f, 0.19264361f, 0.35397834f, 
    0.37107065f, -0.35184819f, 0.06088712f, 0.20732337f, -1.10675001f, 0.37430602f, -0.16820483f, -0.82228225f, 
    -0.49005294f, 0.69340587f, 0.12368964f, -0.31645581f, 0.35545230f, 0.52939391f, 0.22713752f, -0.12169483f, 
    -0.17534630f, 0.11901267f, 0.17129695f, -0.00425336f, -0.09885871f, -0.08744685f, 0.05564826f, -0.12370889f, 
    -0.28105915f, 0.02770935f, 0.27660078f, 0.04856256f, 0.18893133f, -0.11269144f, -0.22730097f, -0.56467408f, 
    0.51602459f, 1.12791955f, 1.06139815f, 0.11854196f, -0.84576809f, 0.39214754f, -0.20915107f, -0.03223960f, 
    0.42760175f, -0.26541564f, 0.22041744f, 0.15412934f, 0.02485677f, -0.21584554f, -0.04443582f, -0.13861020f, 
    -0.05838303f, -0.08007236f, 0.04487863f, -0.01489414f, -0.08225182f, -0.01364869f, 0.42120683f, 0.61752129f, 
    0.24480991f, 0.58603454f, 0.46603319f, 0.37100390f, 0.18662412f, -0.45049840f, 0.57286072f, 0.16785474f, 
    -0.53147382f, -0.42352960f, 0.03952395f, 0.02080385f, -0.39659986f, -0.21326859f, 0.34467667f, -0.08379480f, 
    -0.33000556f, 0.35293755f, 0.20168282f, -0.06693747f, -0.15563574f, -0.37112093f, 0.04443377f, -0.18714772f, 
    -0.45569271f, 0.70509446f, 0.40883768f, 0.28130418f, 0.33400995f, 0.48410562f, 0.57542765f, 0.19844720f, 
    -0.83019853f, 0.08883667f, -0.24785425f, -0.32878456f, -0.00959273f, -0.44228825f, 0.01608661f, 0.18722372f, 
    0.00248597f, 0.09847126f, -0.51267362f, 0.22438250f, -0.09041071f, 0.11392771f, 0.20551178f, 0.16319707f, 
    1.14533579f, 0.68239212f, -0.56302738f, -0.41094270f, -0.11670257f, -0.41236061f, -0.47824726f, -0.45432419f, 
    -0.09567491f, 0.04722757f, -0.13687646f, -0.20990260f, 0.28206053f, -0.18045725f, 0.20135209f, 0.16278069f, 
    0.03477464f, 0.14946124f, 0.04634473f, 0.19751909f, -0.11362866f, -0.41798308f, -0.33346868f, -0.23936905f, 
    -0.22976454f, 0.10714567f, 0.40945801f, 0.37216592f, -0.82039642f, -0.27400032f, 0.43799955f, 0.37033582f, 
    -0.32987064f, 0.45470142f, 0.01330284f, 0.43541029f, 0.47578642f, 0.08056866f, 0.21885093f, 0.36437902f, 
    -0.15687551f, 0.08764906f, 0.05203789f, 0.16630098f, 0.12868896f, 0.26465508f, 0.54022652f, 0.15614560f, 
    0.21788695f, 0.31572992f, 0.67788148f, 0.73722875f, 0.83761746f, 0.83988959f, 0.61920321f, -0.00956505f, 
    -0.05051982f, -0.40226647f, -0.64624321f, 0.09584233f, 0.35245827f, 0.33052048f, -0.01323708f, 0.07600287f, 
    0.30259350f, -0.20710807f, 0.09204720f, 0.38148496f, -0.23823312f, 0.29152641f, 0.22149630f, 0.09995332f, 
    0.27278525f, 0.15967129f, 0.12384197f, -0.06174462f, -1.20793962f, -0.32055762f, 0.80973095f, 0.06681866f, 
    -0.94484013f, 0.36955795f, 0.60403126f, -0.68117476f, 0.37231353f, 0.52830088f, 0.38609710f, -0.20517021f, 
    -0.13608955f, 0.15616968f, -0.08126111f, 0.23776416f, 0.29654723f, 0.10419562f, -0.34200829f, 0.10090189f, 
    -0.16821802f, -0.02079199f, 0.09312148f, 0.13462225f, -0.27140477f, -0.60500658f, 0.19734927f, 0.31254077f, 
    0.67440695f, -0.24145681f, -0.59536463f, -0.54807681f, -0.70200539f, -0.33727258f, -0.11284814f, 0.49190199f, 
    0.50687736f, 0.13932931f, -0.47014162f, 0.26745075f, -0.01729343f, 0.66671181f, -0.12819967f, -0.36779204f, 
    -0.22418922f, -0.22556190f, 0.27651727f, -0.19189538f, -0.06802458f, -0.06938610f, 0.09198695f, -0.58508223f, 
    -0.37233776f, -0.31858149f, 0.31011504f, -0.46957865f, 0.04127711f, -0.39506915f, -0.32249075f, -0.70071596f, 
    -0.53563052f, -0.18851556f, 0.20708869f, -0.26249045f, 0.16261795f, -0.17119117f, 0.50367844f, 0.29184180f, 
    -0.22970872f, -0.08706719f, -0.23139368f, -0.21004398f, 0.15779375f, 0.49043831f, -0.32579580f, 0.96602690f, 
    -0.47149551f, -0.50745714f, -0.50758743f, 0.56544924f, 0.51404285f, -0.75698632f, 0.40765241f, 0.34424502f, 
    0.22721893f, -0.18844286f, -0.28650066f, -0.39623684f, -0.51525801f, 0.15617703f, 0.12489118f, -0.00673065f, 
    -0.00867364f, -0.06984022f, -0.24908747f, -0.35426494f, 0.07008171f, -0.11026737f, -0.27132419f, -0.00643111f, 
    -0.94140255f, -1.09695530f, -0.53017712f, -0.31082776f, -0.60531276f, 0.33862880f, 0.26988691f, 0.09239630f, 
    0.30620065f, 0.12512763f, 0.08455814f, 0.12822227f, 0.11418194f, 0.11471304f, -0.07863455f, 0.14071430f, 
    -0.22119281f, 0.08346779f, 0.18460378f, 0.03656774f, -0.03501883f, 0.08203731f, -0.19714116f, 0.32007381f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.28231338f, 0.18570976f, 0.19576214f, 0.33706456f, 0.01744741f, 0.22384189f, 0.09134257f, 0.12835091f, 
    0.12229097f, 0.25284901f, 0.03177470f, 0.05583813f, 0.42287162f, 0.17680363f, 0.35627365f, 0.02863821f, 
    0.03755300f, 0.13387772f, 0.20207164f, 0.23471324f, 0.26281238f, 0.45673549f, 0.21977694f, -0.00986315f, 
    0.24339519f, -0.02936196f, 0.30657688f, 0.32043129f, 0.38115960f, 0.25987801f, 0.00511926f, 0.20009099f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.35234976f, 0.09409125f, -0.22492622f, -0.11253595f, -0.01923361f, 0.30337012f, -0.01420052f, -0.11064172f, 
    -0.10968502f, 0.10390501f, 0.15427978f, -0.13013928f, 0.06653400f, -0.09975341f, 0.14134227f, -0.21996585f, 
    0.12134769f, 0.09682475f, 0.14248805f, -0.06479421f, -0.06434859f, 0.07746577f, 0.03343882f, 0.02089297f, 
    0.28373221f, 0.27687770f, -0.17723367f, 0.27128339f, 0.14312175f, -0.06295551f, -0.14704238f, 0.10395654f, 
    0.17592613f, -0.12675141f, -0.13165520f, -0.08261587f, 0.07466861f, -0.15152860f, 0.17901713f, 0.17006946f, 
    0.09568665f, -0.01874920f, 0.00101228f, -0.02848224f, -0.01805325f, 0.07260969f, -0.02275037f, 0.06112556f, 
    -0.26739717f, 0.42859200f, -0.09622644f, -0.00755459f, 0.07744177f, -0.01203233f, 0.05820421f, -0.07864460f, 
    -0.14411516f, -0.08217835f, 0.09692571f, -0.03967533f, 0.10776222f, -0.22912811f, -0.02577965f, -0.14589001f, 
    -0.01822638f, -0.01835120f, -0.10064752f, -0.05812033f, 0.07585805f, -0.09394376f, 0.05375724f, 0.19830796f, 
    0.65089577f, -0.33581442f, 0.15291893f, -0.28466329f, 0.10777287f, -0.17950201f, 0.12559749f, -0.05229177f, 
    -0.00931985f, -0.04426024f, 0.04559211f, -0.02001368f, -0.22392085f, -0.15741108f, 0.13548121f, 0.17520680f, 
    -0.15292615f, 0.02895814f, -0.06935885f, 0.02811705f, 0.09569409f, -0.02225442f, 0.22351582f, 0.10237402f, 
    0.55073786f, 0.04031463f, -0.07414129f, 0.11502009f, 0.09525885f, -0.05444554f, 0.11086074f, 0.06721792f, 
    -0.02937242f, 0.05108785f, 0.13921274f, 0.07856231f, -0.03053016f, 0.09890179f, -0.02611161f, 0.01113290f, 
    -0.01315079f, -0.00902216f, -0.12857834f, -0.11952001f, 0.03812211f, -0.07083636f, 0.01644857f, -0.09842970f, 
    -0.40446845f, 0.04338896f, -0.18967189f, -0.00782294f, 0.13132089f, 0.10607613f, -0.04291722f, -0.07490101f, 
    -0.08373278f, -0.03918277f, 0.10339569f, -0.11512264f, 0.01937528f, -0.04533356f, 0.08018059f, 0.41861257f, 
    0.17598495f, 0.12946135f, 0.10422917f, 0.02049755f, 0.03920333f, 0.13198486f, 0.06003289f, 0.11158753f, 
    -0.26060602f, 0.18637928f, -0.07476309f, 0.40145129f, -0.04402149f, -0.01713659f, 0.01656339f, -0.13397798f, 
    0.19679409f, 0.00638858f, -0.04458730f, -0.02432293f, 0.02037934f, -0.09018345f, 0.05369956f, 0.10011426f, 
    -0.00735361f, -0.03931758f, 0.14760843f, 0.12229995f, -0.25766569f, -0.16372220f, 0.07793825f, -0.14209011f, 
    -0.11377367f, -0.19726288f, 0.27161801f, 0.09177615f, -0.12439887f, 0.02773730f, 0.15284464f, 0.03694116f, 
    -0.10151758f, -0.03464457f, -0.05500775f, 0.02779617f, 0.16399296f, -0.10655784f, 0.04707947f, -0.11393239f, 
    0.05477176f, 0.26344302f, 0.04325204f, 0.06168768f, 0.02576772f, -0.05039467f, 0.05160716f, 0.07995316f, 
    -0.02748273f, 0.17890260f, 0.03528287f, -0.08299462f, -0.03138306f, 0.14808531f, 0.07946814f, -0.04470879f, 
    0.12132677f, -0.04583260f, 0.12089063f, -0.05714430f, 0.17302258f, 0.06671096f, -0.36729500f, 0.30136907f, 
    0.10518485f, -0.00028257f, -0.25302476f, -0.00728841f, -0.06874341f, -0.00837893f, -0.07952751f, 0.11918093f, 
    -0.23704159f, -0.11574900f, 0.17657089f, -0.08824857f, 0.04637391f, 0.02299943f, 0.04236590f, -0.10722543f, 
    -0.09501052f, 0.02513069f, 0.00552670f, 0.09620634f, -0.04332040f, -0.15649796f, 0.21613842f, -0.05600108f, 
    0.24729741f, -0.07509853f, -0.06406838f, -0.03712378f, 0.16104695f, 0.00786568f, -0.01383157f, 0.01566085f, 
    0.02843898f, 0.08732529f, 0.00025236f, 0.23493539f, 0.00457769f, 0.02833146f, 0.09459873f, 0.09202337f, 
    -0.15109332f, -0.02815808f, 0.11974237f, 0.09804610f, -0.10226813f, 0.20191637f, 0.07369533f, 0.09309416f, 
    -0.14437041f, 0.06577174f, 0.09239709f, 0.15996045f, 0.12184200f, -0.05689810f, -0.04732266f, 0.03691117f, 
    -0.15912098f, 0.09768496f, 0.10629507f, -0.04131868f, 0.03456828f, 0.06172588f, 0.00293208f, -0.01513728f, 
    0.09208617f, -0.01382348f, -0.05784938f, 0.09622807f, 0.36182806f, -0.26302925f, 0.14251921f, -0.09961376f, 
    -0.01844781f, 0.01224746f, 0.05166800f, -0.07415888f, -0.06856181f, 0.06107176f, 0.03990348f, -0.00544590f, 
    -0.22475852f, 0.18286134f, -0.23914702f, 0.33031353f, 0.04712034f, 0.10231254f, 0.01290795f, 0.08737735f, 
    0.04051585f, -0.06259941f, 0.03113541f, -0.08880984f, 0.29762855f, 0.17556079f, -0.10875660f, 0.26916796f, 
    0.17136331f, -0.04062174f, 0.19271220f, -0.04972722f, -0.00461563f, -0.05587361f, 0.05001199f, 0.02810433f, 
    -0.26344553f, -0.08728193f, -0.10710952f, -0.12836692f, 0.18604326f, 0.03963766f, -0.13380441f, -0.02186385f, 
    0.04092567f, -0.02465908f, -0.07163554f, -0.15903330f, 0.33823189f, 0.02815651f, 0.27571082f, -0.34736282f, 
    0.16229430f, -0.05013659f, 0.15418087f, 0.03925993f, 0.06255386f, 0.17915270f, -0.03539634f, -0.06700422f, 
    0.09909562f, 0.07552353f, -0.02609240f, 0.01960846f, 0.02883488f, 0.11451248f, 0.05153551f, -0.00742215f, 
    -0.03731343f, 0.08413134f, -0.15817492f, -0.07776412f, 0.08506814f, 0.05207424f, -0.05564230f, 0.09588728f, 
    0.02469139f, -0.03075799f, 0.03908706f, -0.04149825f, -0.03806587f, -0.00434605f, 0.06640392f, 0.06125113f, 
    -0.13255052f, 0.15835878f, -0.08490985f, 0.32072857f, 0.06782537f, 0.19126143f, 0.03350218f, 0.23006286f, 
    0.00667620f, 0.06160673f, -0.07444309f, 0.23814976f, -0.24877490f, 0.21356852f, 0.08343646f, -0.08178926f, 
    -0.07700405f, 0.06354234f, -0.01926597f, -0.05846810f, 0.16139489f, 0.04807393f, -0.03222903f, 0.06661851f, 
    0.04386989f, 0.02536697f, -0.01328605f, 0.00925694f, 0.00657400f, -0.01772351f, 0.02685301f, 0.01138393f, 
    0.02852334f, 0.04150409f, -0.02582889f, 0.02409417f, 0.02361313f, 0.01319064f, 0.02128587f, -0.03664716f, 
    0.03220636f, -0.02338738f, 0.02799674f, -0.00975444f, -0.01588118f, -0.04867746f, 0.01234972f, 0.02481570f, 
    -0.05078133f, 0.02632125f, -0.03241449f, 0.00655253f, 0.03113338f, 0.03471858f, 0.01209665f, -0.04099530f, 
    0.02770838f, -0.00651956f, 0.00321805f, -0.04530299f, -0.01528652f, 0.01920272f, -0.01243334f, 0.01797173f, 
    -0.01824426f, -0.04893964f, -0.01323591f, -0.01693849f, -0.03596150f, -0.05777134f, 0.02922159f, 0.00798499f, 
    0.00168704f, -0.03474455f, 0.01172357f, -0.02514758f, -0.04168959f, -0.03597603f, 0.00014929f, -0.03925227f, 
    -0.02245668f, 0.00325938f, -0.04625828f, 0.01473046f, -0.03502055f, -0.03279332f, -0.00982294f, 0.00648389f, 
    -0.04135067f, 0.02718708f, -0.03513179f, -0.02173033f, 0.03452957f, 0.00525146f, 0.02623184f, 0.03308172f, 
    -0.01337326f, 0.01866678f, 0.02659802f, -0.03184442f, -0.02940728f, 0.00710560f, -0.02889407f, -0.02595684f, 
    -0.04313857f, -0.04491038f, -0.00068181f, 0.00491682f, 0.00585390f, -0.01651988f, -0.03454898f, 0.00993945f, 
    -0.01788396f, -0.00579537f, 0.03331389f, 0.03183859f, 0.04200972f, -0.01582524f, -0.04233176f, 0.00628839f, 
    0.01697890f, 0.00614066f, -0.00885551f, -0.04876578f, 0.00547893f, 0.01439999f, 0.03619098f, -0.01554570f, 
    0.03860839f, 0.04207107f, 0.02306806f, 0.00521944f, 0.01676798f, -0.05639652f, -0.02043384f, -0.02884995f, 
    -0.04570291f, 0.04302309f, -0.02132660f, -0.01943584f, -0.02639632f, -0.01641148f, -0.05684940f, 0.00317660f, 
    0.00640628f, -0.00034834f, -0.02907954f, -0.04910227f, 0.01294702f, -0.00346055f, 0.03631315f, -0.01930120f, 
    -0.04129104f, 0.01632350f, -0.01496837f, -0.02286736f, -0.04410743f, -0.02950160f, -0.00062051f, 0.00723646f, 
    -0.01954891f, -0.03316240f, 0.03761055f, -0.00546054f, 0.02832087f, 0.03838142f, -0.03578923f, 0.04742574f, 
    -0.01432607f, -0.01993296f, 0.01894446f, -0.03956863f, -0.02231889f, -0.02088561f, 0.01669719f, -0.05480046f, 
    0.02665458f, -0.02170508f, 0.00615374f, -0.01755125f, 0.01950236f, -0.04803887f, -0.03060307f, -0.01428272f, 
    -0.02253462f, 0.00172446f, -0.01652578f, -0.04809495f, -0.00384836f, 0.00509316f, 0.02950327f, 0.02580734f, 
    0.01751077f, -0.03722530f, 0.02081902f, -0.03063029f, 0.02718866f, 0.01007318f, -0.04086355f, 0.01652649f, 
    0.02946833f, -0.02453850f, 0.04434797f, -0.01956458f, 0.03877343f, 0.00071488f, -0.05063174f, 0.03324098f, 
    -0.01741280f, 0.00130885f, 0.02291949f, -0.04781342f, 0.03191641f, -0.04137589f, 0.00495406f, -0.00834597f, 
    0.01983149f, -0.04032688f, -0.03973352f, -0.03886482f, 0.01732773f, -0.04823766f, -0.04400713f, -0.04216421f, 
    -0.02315063f, 0.01103078f, -0.02855920f, 0.00305573f, 0.03108062f, 0.02749679f, -0.05864582f, 0.01045337f, 
    -0.01114582f, -0.04061141f, -0.03699387f, 0.04001791f, 0.00252520f, -0.00787768f, 0.02699904f, -0.04020515f, 
    0.02135451f, 0.01025477f, 0.03046161f, -0.03032006f, -0.04051878f, -0.00176502f, -0.00719931f, -0.00314987f, 
    0.01740585f, 0.01190882f, -0.01792526f, -0.03499639f, -0.01629248f, -0.02266480f, 0.00663288f, -0.04427179f, 
    -0.01678758f, 0.00447570f, 0.03158183f, -0.02956980f, 0.04404084f, 0.03007302f, -0.00019171f, -0.00437342f, 
    -0.02179253f, -0.03598792f, -0.01881604f, 0.01505313f, 0.01789498f, -0.02485268f, -0.04159604f, 0.03582439f, 
    0.03316771f, 0.04344178f, -0.05812097f, -0.02898260f, -0.00894359f, 0.01481259f, -0.03054959f, 0.00887759f, 
    -0.02239382f, -0.02699106f, 0.00755145f, 0.03813280f, -0.00092207f, -0.02615513f, -0.02372150f, 0.00243563f, 
    0.02263591f, -0.05691637f, -0.02208527f, -0.01563837f, 0.00120062f, 0.04165687f, 0.03853897f, 0.02417948f, 
    -0.03603484f, 0.01447132f, 0.03395452f, -0.05285690f, 0.03910196f, -0.03401029f, 0.03935105f, -0.05207750f, 
    -0.03380573f, -0.05433467f, -0.00293942f, -0.04523406f, -0.02338288f, -0.00759103f, -0.04780323f, -0.01160713f, 
    0.01013313f, 0.03825324f, -0.05432044f, -0.05184218f, -0.03162725f, 0.03930641f, 0.04262626f, 0.04039457f, 
    -0.03741596f, -0.04313944f, -0.02976701f, -0.00143691f, -0.04418976f, -0.01528944f, 0.02324547f, -0.04579860f, 
    -0.00826209f, 0.03954073f, -0.03338072f, -0.01129160f, -0.03991031f, 0.03013887f, 0.03470937f, -0.03228274f, 
    0.03041858f, 0.04456825f, -0.03839865f, -0.01313434f, -0.00781827f, -0.03512108f, 0.00217877f, -0.00307488f, 
    -0.04402290f, 0.00484406f, -0.01269109f, 0.00732319f, -0.00876490f, -0.03440394f, 0.00524587f, -0.02525896f, 
    0.00354425f, 0.01213539f, 0.00226098f, -0.00537342f, -0.01650060f, 0.02690568f, 0.01178548f, -0.03754586f, 
    -0.04720665f, -0.04244709f, 0.01598654f, -0.01616018f, -0.00425562f, 0.00266402f, -0.03642217f, 0.02098471f, 
    0.02720794f, 0.00596800f, -0.00060837f, 0.02033834f, 0.02037802f, -0.01239737f, -0.00551867f, -0.02263565f, 
    -0.05322510f, -0.02052515f, 0.01074112f, 0.03830239f, 0.03567586f, 0.01878268f, -0.05003627f, -0.00288260f, 
    -0.02973145f, -0.05498383f, -0.00873325f, 0.02897927f, 0.03666330f, -0.02649456f, -0.00092939f, -0.01998803f, 
    -0.01082110f, -0.03276909f, 0.03537750f, -0.03717359f, 0.00363570f, -0.01197128f, -0.01778129f, 0.00384576f, 
    0.03345327f, -0.00010020f, -0.00046321f, -0.01775064f, 0.02014631f, -0.04124198f, -0.05154758f, -0.01215555f, 
    0.37554526f, 0.21769039f, -0.02662350f, 0.15024871f, -0.10112198f, 0.08340993f, -0.05180145f, 0.15736058f, 
    -0.03293480f, -0.03443427f, 0.05462103f, 0.03300254f, 0.25139955f, 0.02269847f, -0.06318924f, -0.14423741f, 
    -0.00860783f, 0.10985960f, 0.12855180f, 0.05185125f, -0.10613215f, 0.00339272f, 0.10600722f, 0.10275673f, 
    0.17975818f, -0.00763850f, -0.08074692f, 0.20303585f, -0.10546871f, -0.04055860f, 0.01398145f, -0.12458151f, 
    0.07994111f, 0.04717138f, 0.09988523f, 0.03083729f, -0.24437848f, 0.20681733f, -0.04535602f, -0.05726020f, 
    0.16692814f, 0.00708239f, -0.00366186f, 0.12365861f, 0.06078516f, -0.04115829f, -0.10527293f, 0.04537429f, 
    0.47774839f, -0.19855437f, 0.25035137f, 0.18963325f, -0.30168289f, 0.15268774f, 0.02945641f, 0.02009569f, 
    0.04843397f, -0.10928248f, 0.06937211f, 0.18676455f, 0.13406946f, -0.10443615f, 0.27069387f, 0.32188019f, 
    -0.09835754f, -0.02021657f, 0.11798148f, 0.07311865f, -0.01495637f, 0.08473347f, -0.00120829f, -0.09364321f, 
    -0.15365167f, -0.08935610f, 0.17979254f, 0.11419045f, -0.00803742f, 0.12608601f, 0.09718149f, -0.15407287f, 
    0.01365598f, 0.04644274f, -0.02536418f, -0.13045877f, -0.40604079f, 0.15060015f, -0.00867141f, -0.20269488f, 
    0.01323756f, 0.05795747f, 0.10284740f, -0.06891250f, 0.02928155f, -0.04958310f, 0.03384221f, 0.07147795f, 
    -0.16229084f, 0.20358507f, -0.11751832f, 0.29395351f, -0.07588284f, 0.08312876f, 0.06638977f, 0.00434593f, 
    -0.04016269f, -0.03242129f, 0.04018426f, 0.00585839f, -0.41909647f, -0.00293958f, 0.11424974f, -0.03416429f, 
    0.16294408f, -0.05087736f, -0.04486150f, -0.10374439f, 0.05398935f, 0.11838092f, 0.00904661f, 0.09353712f, 
    -0.06875338f, 0.14539717f, 0.29878113f, 0.20798817f, -0.04963678f, 0.11315718f, -0.03073193f, 0.06140438f, 
    0.10487443f, 0.02770082f, -0.05205398f, 0.00176130f, -0.31644970f, -0.25477612f, 0.03407746f, -0.20498474f, 
    0.07194948f, -0.07928443f, 0.00069295f, -0.12423708f, 0.11088884f, 0.05141880f, 0.06007947f, -0.01700470f, 
    0.42816240f, 0.00870705f, -0.53651220f, 0.06482349f, 0.03697793f, 0.06637984f, -0.13353488f, 0.03575724f, 
    -0.07623962f, 0.06029614f, -0.00715953f, -0.02183476f, -0.28439158f, 0.12098172f, 0.22693484f, 0.04782664f, 
    -0.02698853f, 0.11047313f, 0.03642465f, -0.00440505f, 0.16691247f, 0.04232091f, -0.00723845f, -0.17164028f, 
    -0.04615085f, -0.19323346f, -0.25502738f, -0.38035226f, 0.00471935f, 0.03181574f, 0.02503583f, -0.14230049f, 
    -0.01692656f, 0.02391433f, 0.10767650f, 0.00915946f, 0.41840097f, 0.10488363f, 0.05737843f, 0.18036549f, 
    -0.05608051f, -0.10398182f, -0.02249005f, -0.12663324f, -0.02443114f, -0.07497233f, -0.05385515f, 0.03088984f, 
    -0.26737440f, -0.00973457f, 0.12399849f, -0.05235094f, -0.13025789f, 0.00814610f, -0.14603481f, -0.01841612f, 
    -0.18145153f, -0.13118456f, 0.05785820f, -0.07220144f, 0.12619591f, -0.16468601f, -0.13905101f, 0.30208313f, 
    0.01121177f, -0.01385158f, -0.12623219f, 0.07677213f, 0.03065558f, 0.00056109f, -0.09920757f, 0.13299692f, 
    0.32129082f, 0.09391767f, 0.39489493f, 0.16159540f, -0.10088324f, -0.06520270f, 0.02065101f, 0.01107316f, 
    0.13139166f, -0.06007883f, 0.07579611f, 0.06153794f, 0.29936689f, -0.17115453f, 0.19754916f, 0.23149261f, 
    0.05314878f, 0.14379574f, 0.08640282f, 0.13267767f, 0.04678067f, 0.06159135f, 0.05803728f, -0.17128524f, 
    -0.17828798f, 0.07770937f, -0.13274254f, -0.19421351f, -0.18710661f, 0.06101133f, 0.07107318f, -0.03383032f, 
    0.02382059f, 0.01236761f, -0.09541574f, 0.01714628f, 0.31704330f, -0.29220268f, 0.23848702f, -0.13219900f, 
    -0.03261233f, 0.11026911f, -0.11270969f, 0.02900042f, 0.06349178f, 0.15877709f, -0.03486361f, -0.06225014f, 
    0.31287798f, 0.01806637f, 0.10539223f, 0.22500643f, -0.10129210f, -0.09252323f, 0.04355930f, 0.00540427f, 
    -0.04665620f, 0.06158479f, 0.15545104f, -0.10700320f, -0.13268098f, 0.12882636f, 0.23285872f, 0.27504387f, 
    -0.00037141f, 0.00693728f, 0.08545867f, 0.05602351f, 0.17993785f, 0.05814691f, -0.07711232f, 0.09725048f, 
    0.37775084f, 0.09608991f, -0.09786985f, -0.09471098f, 0.18890528f, 0.00978158f, -0.01447767f, 0.08928208f, 
    0.06521700f, -0.01436921f, 0.01040668f, 0.15506895f, -0.08533594f, -0.02138818f, -0.03771032f, 0.22003362f, 
    -0.26445046f, -0.00214190f, -0.00894021f, 0.08537988f, 0.00043933f, 0.02039746f, -0.11440147f, -0.05288784f, 
    0.33500424f, 0.05702111f, 0.24842449f, 0.26027474f, -0.10860746f, 0.08027410f, -0.04083525f, 0.02757779f, 
    0.07243928f, 0.01792826f, -0.04065319f, -0.06060223f, -0.04520863f, 0.04794141f, 0.07085475f, -0.07663083f, 
    0.02310474f, 0.00711353f, -0.04494621f, 0.05907423f, 0.09536459f, -0.09052610f, -0.09724861f, 0.11471055f, 
    -0.00424960f, -0.12413304f, 0.10835481f, -0.06788457f, 0.15390906f, 0.06731432f, -0.01403490f, -0.06664381f, 
    0.16695778f, -0.07877407f, 0.10411833f, 0.10949481f, 0.12677225f, 0.05064224f, -0.00980340f, -0.18657991f, 
    -0.10628891f, 0.02480342f, 0.06978635f, 0.09133493f, 0.19330561f, -0.02695587f, 0.16589718f, -0.01394216f, 
    0.33969292f, 0.19577488f, -0.22413808f, 0.19064359f, 0.04140158f, 0.13348199f, -0.20531011f, -0.09213997f, 
    0.05655078f, -0.06642973f, -0.05981693f, 0.06015391f, -0.14318959f, -0.20552616f, -0.10505304f, -0.27901670f, 
    0.02836114f, -0.00192052f, -0.04886942f, -0.14745817f, 0.09363113f, -0.01480535f, 0.07360501f, 0.09315067f, 
    0.23848695f, 0.08861884f, -0.36801285f, -0.05526732f, 0.32246289f, -0.03410853f, -0.18334360f, 0.04235258f, 
    0.08466128f, -0.05010571f, -0.01726131f, 0.12391675f, -0.09143064f, -0.19709618f, -0.11407785f, 0.06405025f, 
    0.10166427f, -0.05925184f, 0.07987080f, 0.01797119f, -0.05009672f, -0.10523470f, 0.07643791f, 0.13495149f, 
    0.03605774f, 0.08119045f, 0.01320344f, -0.09647523f, 0.13549788f, 0.03305054f, -0.09469725f, -0.00139957f, 
    0.08391467f, 0.07048851f, 0.00407260f, 0.05336250f, -0.09179822f, 0.10553552f, -0.02007243f, 0.02487683f, 
    0.03089157f, 0.02848865f, -0.10185332f, 0.17234845f, 0.09727611f, -0.00244905f, 0.14167012f, -0.00931890f, 
    -0.23083508f, -0.39661911f, -0.05593929f, 0.28320301f, 0.09251600f, 0.08067893f, -0.09134807f, -0.14578915f, 
    0.03176515f, 0.03908534f, -0.07541379f, 0.16758187f, -0.28562129f, -0.11609180f, -0.19566618f, -0.25710988f, 
    0.06122923f, 0.05914644f, -0.01151802f, 0.01468283f, 0.13447589f, -0.10821941f, -0.12333919f, -0.12483180f, 
    -0.07668689f, 0.00524788f, 0.18599129f, 0.12951577f, -0.11503720f, -0.13396288f, 0.07365531f, 0.14343920f, 
    -0.15414576f, 0.18081370f, 0.05802650f, 0.02548994f, 0.09622811f, -0.01244565f, -0.07358484f, 0.10036435f, 
    -0.04784613f, -0.05051846f, 0.06222800f, 0.03294993f, -0.08991749f, 0.11898132f, -0.09468299f, -0.10917477f, 
    0.07976215f, 0.10072066f, -0.05160654f, 0.29723281f, -0.00910576f, -0.01790623f, 0.18512060f, -0.03855956f, 
    0.07213253f, -0.06947201f, 0.00175024f, 0.01344868f, 0.22128995f, 0.02156052f, 0.21295057f, -0.18343320f, 
    0.01879720f, 0.01300344f, -0.06833842f, 0.11010668f, 0.01293531f, 0.18887314f, -0.01446220f, 0.11271521f, 
    -0.04971617f, -0.22645617f, -0.26290071f, 0.03523640f, 0.19308367f, 0.18016621f, -0.07428167f, -0.13527423f, 
    -0.07469018f, 0.01570402f, -0.09792070f, 0.22255792f, -0.09534984f, 0.19108465f, 0.08744815f, -0.02809439f, 
    -0.15108669f, 0.03267280f, -0.05200915f, -0.08877233f, 0.00457575f, -0.16020067f, -0.08394884f, -0.07857727f, 
    0.29797024f, 0.24828221f, 0.01115870f, -0.03882310f, 0.06465476f, -0.09993989f, -0.10232691f, 0.06281576f, 
    -0.06977319f, -0.03662331f, 0.05345843f, 0.06485445f, -0.04649040f, 0.01207083f, 0.15006685f, 0.03379869f, 
    0.01295928f, 0.03602286f, 0.03872815f, 0.09813591f, 0.07598396f, 0.20224027f, 0.10307148f, 0.19805050f, 
    0.36254704f, 0.11168917f, 0.05932700f, 0.12722474f, -0.08316528f, -0.03826202f, -0.00094380f, -0.00420984f, 
    -0.11957236f, -0.04473287f, 0.07754339f, -0.15832360f, 0.01058113f, -0.00121119f, -0.01730945f, 0.00812850f, 
    -0.00238578f, -0.17669146f, 0.16842051f, 0.11748333f, 0.07890119f, 0.05194674f, 0.06779853f, 0.00062116f, 
    0.19795837f, 0.22066317f, -0.13507892f, 0.06712876f, -0.05559535f, -0.21693379f, -0.08576839f, -0.02480157f, 
    0.04966911f, 0.22426943f, 0.00453357f, 0.07031722f, 0.27024525f, 0.19546327f, 0.09569754f, 0.10620271f, 
    0.07419875f, -0.07890600f, 0.02036594f, 0.00334466f, 0.12118335f, 0.18443686f, -0.00836253f, -0.02610690f, 
    0.00014696f, -0.26029345f, -0.29117158f, -0.21726678f, 0.01879453f, 0.01390625f, -0.14089558f, -0.10204849f, 
    0.01205992f, -0.12224873f, 0.17220306f, -0.12044372f, -0.22347364f, -0.14770193f, -0.16766675f, -0.02407747f, 
    0.03630020f, -0.03345773f, -0.16271409f, 0.09812015f, -0.10570535f, 0.18170863f, 0.07119425f, 0.01237536f, 
    -0.36044869f, -0.02448598f, 0.18937227f, 0.14656574f, 0.07412570f, -0.04905964f, -0.03609476f, -0.00488634f, 
    0.12161507f, -0.05028197f, 0.07348680f, 0.00185399f, 0.27251059f, 0.12320243f, 0.04992133f, 0.07952721f, 
    0.08882016f, -0.09882717f, 0.00396995f, 0.09093410f, 0.13446169f, 0.08090347f, 0.01081944f, 0.04022508f, 
    0.10327888f, -0.29184976f, -0.06498155f, -0.11890130f, 0.05664108f, -0.03530874f, -0.22677924f, -0.02369726f, 
    0.09216227f, -0.01462849f, 0.03130352f, 0.01646048f, -0.21249984f, -0.18996933f, 0.09765466f, 0.01499087f, 
    -0.07223483f, 0.11028718f, -0.10112677f, 0.08106813f, -0.12584840f, -0.16330871f, -0.04493149f, -0.07648437f, 
    -0.03027860f, 0.03652121f, -0.06803524f, 0.10999759f, 0.10570671f, 0.03750112f, -0.08014340f, -0.07856165f, 
    0.08710599f, 0.10598227f, -0.04601879f, 0.10077213f, 0.26645920f, -0.06745440f, 0.07500719f, 0.11339154f, 
    -0.03704854f, 0.01766986f, -0.07468083f, 0.16137262f, 0.06751335f, 0.03553622f, 0.10047791f, 0.09027314f, 
    0.17061161f, -0.16594788f, -0.19976772f, 0.13431035f, 0.15180232f, 0.09191271f, 0.10294209f, 0.05903398f, 
    0.01796645f, 0.12585461f, 0.23392946f, 0.03824343f, -0.16699317f, 0.23962073f, 0.03009007f, -0.02622600f, 
    0.07234056f, 0.07306340f, 0.01715813f, -0.03073255f, -0.02802874f, -0.00153253f, 0.04772199f, 0.04605978f, 
    -0.08935075f, 0.01614387f, -0.18380831f, 0.15341328f, -0.01883644f, -0.08515457f, 0.14842713f, -0.02082115f, 
    -0.00221944f, -0.11742482f, 0.30871084f, 0.02167412f, 0.05441288f, -0.06391744f, 0.13807596f, 0.14593108f, 
    -0.08161513f, 0.35680354f, 0.03601479f, 0.02181577f, 0.02614461f, -0.05885452f, 0.12945773f, -0.11030225f, 
    -0.04741027f, 0.10783926f, -0.08307033f, -0.03542766f, -0.04074957f, -0.19890602f, -0.11708173f, -0.22953250f, 
    -0.00852162f, -0.15609068f, -0.00740623f, -0.01520352f, 0.13523297f, 0.10650874f, 0.07577399f, 0.03785514f, 
    -0.03533691f, -0.02542993f, -0.04762446f, 0.09062438f, -0.00471637f, 0.09085914f, -0.04167459f, 0.02342592f, 
    -0.02848616f, -0.00934487f, -0.00650170f, -0.00075424f, 0.03799014f, -0.05249519f, 0.05299052f, 0.00293303f, 
    0.02801611f, -0.01445127f, -0.00770381f, 0.02257765f, 0.03209602f, -0.00050756f, -0.01887755f, -0.00117732f, 
    0.00330740f, -0.01136905f, -0.01720401f, 0.02291503f, -0.00675103f, -0.03620672f, -0.02181286f, 0.01420884f, 
    0.03309150f, 0.00918167f, 0.01667716f, -0.00382079f, 0.03840671f, 0.00391361f, 0.02974777f, 0.01050876f, 
    -0.00577419f, 0.00818899f, -0.00255493f, 0.01338997f, 0.02305158f, 0.00485210f, -0.03080482f, -0.01552691f, 
    -0.04626154f, -0.01008789f, -0.02862712f, -0.00440209f, 0.01193217f, 0.02669561f, 0.00363459f, -0.03319146f, 
    0.01177750f, -0.05053826f, 0.04856848f, -0.03564739f, -0.00187027f, -0.01068728f, 0.00785147f, -0.03060706f, 
    0.02268057f, -0.00908211f, 0.01417057f, 0.04327898f, 0.04384590f, 0.00720010f, 0.03591327f, 0.03576010f, 
    -0.01332306f, -0.01200523f, 0.01188652f, -0.01690152f, -0.02514795f, -0.02701643f, -0.01529058f, -0.02133754f, 
    0.04256602f, -0.02969782f, -0.01620554f, -0.00586676f, -0.03176126f, -0.04411744f, -0.03311414f, -0.00087825f, 
    -0.01778104f, -0.03903725f, -0.05260262f, -0.02133988f, -0.02078885f, -0.04141556f, -0.00154979f, 0.02369881f, 
    -0.02361315f, 0.03735032f, 0.02357333f, -0.02484318f, 0.03489943f, 0.00971253f, -0.02290241f, -0.05224751f, 
    -0.04018843f, -0.00379200f, -0.01531594f, 0.02714911f, 0.03407299f, -0.05222085f, -0.05472030f, -0.00137647f, 
    -0.00967736f, -0.02921191f, 0.03352359f, 0.00999694f, -0.00514162f, 0.01382890f, 0.00882487f, 0.03096258f, 
    -0.03625681f, -0.05575633f, -0.02015702f, 0.01488761f, -0.04231843f, 0.03828809f, 0.01893796f, -0.04583680f, 
    -0.02810332f, -0.01570068f, -0.03339747f, -0.02124361f, -0.03475450f, -0.03375572f, -0.03768241f, -0.01124277f, 
    0.02640200f, -0.00213990f, -0.05478342f, -0.01709959f, -0.05901400f, 0.04190462f, -0.03798981f, -0.01323470f, 
    -0.00319405f, -0.00886780f, -0.05501615f, 0.02097922f, 0.03054009f, 0.00370511f, -0.01570559f, 0.00830073f, 
    0.02698670f, -0.01274024f, 0.04110821f, -0.01335103f, -0.04548523f, -0.00265549f, 0.01688533f, 0.02763752f, 
    0.02895972f, -0.00293695f, -0.03271569f, -0.02481134f, -0.02931437f, -0.00467100f, 0.01599755f, 0.02577380f, 
    -0.03678451f, -0.00221838f, -0.02716169f, 0.01957309f, -0.02846054f, 0.01108426f, 0.03803585f, -0.02397104f, 
    0.03068834f, 0.01471359f, 0.02263433f, -0.02813217f, -0.01433655f, -0.01974796f, 0.03460731f, 0.03178477f, 
    0.03525333f, -0.03546255f, -0.02689669f, -0.00572770f, 0.00704832f, -0.04447117f, -0.03814232f, 0.01043670f, 
    -0.05111357f, -0.02306620f, -0.00547178f, -0.03703222f, -0.04047732f, 0.03127529f, -0.03457674f, -0.01998560f, 
    -0.02008767f, -0.02886878f, -0.04850277f, 0.02747472f, -0.00799416f, -0.01791884f, 0.02203739f, 0.03544277f, 
    -0.02349761f, -0.05742164f, 0.04300972f, 0.04444341f, -0.04529120f, 0.04183421f, -0.05429461f, -0.00621029f, 
    -0.04764767f, -0.05158697f, 0.01345032f, -0.05553289f, 0.03010484f, -0.03001234f, -0.02790983f, -0.03344188f, 
    -0.03617027f, -0.00816487f, 0.03905148f, -0.01256449f, 0.03807650f, 0.01252487f, -0.01748707f, -0.03031478f, 
    -0.02105679f, -0.02443656f, -0.02543339f, 0.02280630f, 0.02445454f, 0.04731660f, -0.01481791f, -0.04041762f, 
    0.00792849f, 0.00182953f, -0.01413753f, -0.03614872f, 0.00974967f, -0.04119338f, -0.02985266f, -0.00085760f, 
    -0.02934427f, 0.02713685f, -0.00531088f, -0.00588065f, 0.00554156f, 0.02214469f, -0.05085205f, -0.03437928f, 
    -0.00730778f, 0.04780762f, -0.04851816f, -0.02831605f, 0.02021978f, 0.01927600f, -0.04447427f, -0.00583638f, 
    0.03081351f, -0.04744063f, -0.01664019f, -0.04607750f, 0.03251833f, -0.03437114f, 0.02461948f, 0.04058934f, 
    0.04250626f, -0.02611984f, -0.03805460f, -0.03516636f, 0.04321869f, -0.04909870f, -0.01615815f, -0.02260590f, 
    0.04196366f, 0.03349671f, 0.01652896f, -0.03990839f, -0.03328615f, 0.01819870f, 0.01758341f, -0.03150183f, 
    -0.02480868f, 0.03392799f, 0.01939003f, -0.00272395f, -0.04223099f, 0.00529126f, -0.03134957f, 0.01842766f, 
    0.01038406f, -0.02397354f, 0.04763860f, -0.00398114f, -0.03869409f, 0.04141335f, -0.03995308f, 0.00493273f, 
    0.01959738f, -0.03189311f, 0.03943865f, 0.02591598f, 0.04765424f, 0.04249780f, -0.00194541f, 0.01116535f, 
    -0.01996832f, -0.00142193f, -0.04437905f, -0.02899256f, -0.05086152f, 0.02008587f, 0.00816195f, -0.03517442f, 
    -0.00577676f, -0.03484046f, 0.03733044f, 0.01905660f, -0.05258448f, -0.02325324f, -0.04617527f, -0.04634255f, 
    0.02086342f, -0.02003762f, 0.01689297f, -0.03441012f, 0.03274088f, -0.01346532f, 0.03103486f, -0.01664958f, 
    -0.03394525f, 0.02746591f, -0.02609607f, -0.00228133f, -0.03971425f, 0.01204630f, 0.03057785f, 0.01716749f, 
    -0.00781069f, 0.03190858f, 0.00557542f, 0.01724538f, -0.04454169f, -0.05260948f, -0.04425322f, 0.00336436f, 
    0.01195506f, -0.01105496f, -0.05444515f, 0.03673966f, 0.00099434f, -0.02201389f, -0.02766555f, 0.02674842f, 
    0.02873507f, 0.03712476f, -0.02121679f, -0.04291098f, 0.01174038f, 0.01595137f, -0.02603484f, 0.04485306f, 
    -0.01553668f, -0.02445743f, -0.02979233f, 0.04411945f, 0.01432087f, 0.00873020f, -0.03059543f, 0.01119592f, 
    0.02982893f, -0.02680173f, -0.05082677f, -0.00453374f, -0.00755008f, 0.03007552f, 0.00501754f, -0.00920793f, 
    0.01580008f, -0.05572524f, -0.02303526f, -0.03848463f, -0.00738666f, -0.04688300f, 0.04714889f, -0.00631132f, 
    0.04170926f, -0.04784139f, -0.01167376f, 0.00431271f, -0.04416425f, -0.02921890f, -0.00092105f, 0.04390359f, 
    -0.03422514f, 0.04305810f, -0.01713925f, 0.01755145f, -0.02921713f, -0.03924262f, -0.01128560f, -0.04297702f, 
    -0.03953653f, 0.01843123f, -0.04103165f, 0.03169998f, -0.04885555f, 0.01719809f, 0.03854940f, -0.04666556f, 
    -0.00357262f, -0.00743433f, -0.05500747f, 0.01798644f, 0.03914163f, 0.03453514f, -0.05649899f, -0.01559235f, 
    0.03531724f, 0.01290084f, 0.01959492f, 0.03528212f, 0.00412851f, -0.00769133f, 0.00927990f, -0.02928962f, 
    0.03240616f, -0.01797528f, -0.00750805f, -0.05558452f, 0.03446402f, -0.01073087f, -0.00007254f, -0.01437172f, 
    -0.02095681f, -0.00463675f, -0.00430391f, -0.02643321f, 0.02642610f, 0.02751866f, 0.02647955f, 0.02973471f, 
    -0.02350427f, -0.02783593f, -0.01714554f, -0.03637439f, -0.00638776f, 0.01073393f, 0.01189114f, 0.03001825f, 
    0.03506683f, -0.03040866f, -0.02787389f, -0.01765879f, -0.02150429f, 0.03711311f, 0.00598510f, 0.02732668f, 
    -0.01504892f, -0.03037997f, 0.00627317f, -0.00995178f, -0.01249780f, -0.05062335f, -0.01142474f, -0.01550809f, 
    0.02606130f, 0.03843002f, 0.03001267f, -0.05404739f, 0.02236524f, 0.03462219f, 0.02932625f, -0.01445680f, 
    -0.02699437f, -0.04437089f, -0.02286187f, -0.03671838f, -0.02466201f, -0.04187256f, 0.00184259f, -0.02327774f, 
    0.04147868f, 0.00960264f, -0.04344314f, 0.00083068f, -0.02382969f, -0.02294291f, 0.02397572f, -0.02086046f, 
    0.00493628f, 0.01406891f, -0.00397398f, 0.01422071f, -0.05382138f, 0.01228351f, -0.03525841f, 0.02658104f, 
    0.00357431f, 0.02985224f, 0.02208145f, -0.03707077f, -0.01953045f, 0.00197941f, -0.03400813f, 0.01443097f, 
    -0.03235392f, -0.01799306f, -0.04038942f, 0.00955303f, -0.00355766f, 0.01653147f, -0.04298012f, 0.01076221f, 
    -0.00380711f, -0.04465548f, -0.01358703f, -0.04420378f, 0.01917117f, 0.01172247f, 0.00961110f, -0.04121351f, 
    0.01894615f, -0.02599299f, 0.03606043f, 0.02192768f, 0.00783567f, -0.03294808f, -0.03492260f, -0.03980569f, 
    -0.03625091f, 0.01547003f, -0.02967567f, 0.03949320f, -0.04739968f, -0.04351927f, 0.00755548f, 0.01382762f, 
    0.00530412f, 0.02345768f, -0.01254957f, 0.04565679f, -0.00297273f, -0.04010062f, -0.00299661f, -0.02777124f, 
    0.03740511f, 0.01233658f, -0.04135564f, 0.03809691f, 0.00818362f, 0.01492836f, 0.01959367f, -0.01427843f, 
    -0.04007285f, 0.01520305f, -0.02580824f, -0.00954694f, 0.02097836f, 0.03789297f, -0.01424192f, -0.04425767f, 
    0.01058131f, -0.00495121f, -0.00993205f, 0.03461831f, 0.02752796f, 0.01377507f, -0.04168152f, 0.03429885f, 
    0.02577041f, 0.00151594f, 0.00850785f, -0.04332694f, 0.03410953f, -0.01180483f, 0.00590256f, 0.00042751f, 
    -0.01608993f, -0.05645185f, 0.03757180f, 0.03728993f, 0.03601679f, -0.01896604f, -0.02315672f, 0.01152907f, 
    0.03628564f, -0.00198935f, 0.02389600f, -0.04567216f, 0.04047170f, -0.04000133f, -0.00608605f, -0.03262158f, 
    -0.05860770f, 0.03373573f, -0.04996514f, 0.04288516f, -0.04986458f, 0.00859990f, -0.04901275f, 0.02895780f, 
    -0.02430882f, 0.03495620f, -0.01242456f, 0.02524841f, -0.01200684f, -0.02687960f, 0.03864168f, -0.03744360f, 
    -0.03164674f, -0.01329329f, 0.00909846f, -0.02893999f, -0.04003394f, 0.04144249f, -0.05551589f, 0.03484011f, 
    -0.06169026f, -0.04090035f, 0.03594119f, -0.01806300f, 0.01759284f, -0.05426145f, -0.05858540f, -0.02767539f, 
    -0.05049260f, 0.01291777f, -0.04501795f, -0.06011070f, 0.01988322f, -0.01841745f, -0.02195974f, -0.04447855f, 
    -0.01036419f, 0.01753007f, 0.01103495f, -0.04206290f, -0.04579009f, 0.02390960f, 0.00709034f, -0.03927069f, 
    -0.04679492f, -0.05359622f, 0.01886127f, 0.00033026f, 0.01624951f, -0.00996363f, -0.02523349f, 0.03671638f, 
    -0.05145763f, -0.04897387f, -0.00235588f, -0.03522936f, -0.05169182f, 0.03694341f, -0.05051989f, -0.01671098f, 
    0.01785194f, -0.00663612f, 0.03489760f, -0.01246978f, -0.04079247f, 0.03416656f, -0.01665538f, 0.02299855f, 
    -0.05358404f, -0.03787722f, 0.02784649f, -0.02335917f, 0.03654107f, 0.00595368f, -0.01173164f, -0.02228753f, 
    0.02796820f, 0.00778558f, 0.01482037f, 0.03020180f, 0.04089792f, 0.03096474f, -0.03095294f, -0.05914854f, 
    0.00113861f, 0.02842538f, 0.03837699f, -0.02197709f, -0.04172736f, -0.02084888f, -0.01386557f, 0.02074468f, 
    -0.01211828f, 0.01793667f, 0.03983164f, 0.00717651f, -0.03663801f, -0.05091868f, -0.03608608f, 0.01260977f, 
    -0.03931076f, -0.02412504f, 0.03619067f, 0.00867142f, 0.01281780f, -0.04842687f, -0.05723782f, 0.04237244f, 
    -0.01178253f, 0.03482538f, -0.01376364f, 0.03108332f, -0.00711170f, 0.03070351f, -0.05824734f, -0.01630838f, 
    -0.03416750f, 0.02079117f, 0.02037609f, -0.02478429f, -0.05124106f, 0.01125240f, -0.04613924f, -0.02673247f, 
    -0.05619646f, -0.02159328f, -0.01985158f, -0.03316335f, 0.02481770f, 0.02283911f, -0.03750728f, 0.03462430f, 
    0.00648754f, -0.04582486f, -0.04860082f, 0.03957586f, -0.04002453f, 0.03667651f, -0.03812312f, -0.04874313f, 
    0.01809268f, -0.02516987f, -0.01912826f, -0.05167295f, -0.02359760f, 0.00577238f, 0.02818704f, -0.01047398f, 
    -0.05671505f, -0.03648882f, -0.04719531f, 0.02193286f, -0.01434413f, -0.02391832f, 0.03304167f, -0.01458461f, 
    0.00591078f, -0.03333639f, 0.02950785f, 0.02708753f, 0.03403825f, 0.00571621f, 0.01591784f, 0.03090526f, 
    -0.04606426f, -0.00306529f, 0.02290267f, 0.03125717f, 0.01612001f, 0.00579671f, 0.02945086f, -0.00902244f, 
    -0.02437934f, 0.21264672f, 0.16347776f, 0.00854976f, -0.14550233f, 0.12335192f, 0.29332176f, -0.04038942f, 
    -0.08688710f, 0.03620794f, 0.00957614f, 0.00174522f, -0.22606423f, 0.06462689f, 0.09303327f, -0.19166778f, 
    0.08053041f, 0.08482081f, 0.05060772f, 0.06278574f, -0.08697203f, 0.05319732f, 0.22251226f, 0.07348917f, 
    -0.59144133f, -0.16910864f, 0.28157049f, 0.13518856f, -0.09501950f, 0.08190329f, -0.07061717f, 0.11742269f, 
    -0.03067985f, 0.01663854f, -0.05472776f, -0.11945126f, 0.26148203f, -0.41493905f, 0.08868689f, -0.11166812f, 
    -0.13545693f, -0.11121719f, 0.04782364f, 0.03085326f, -0.16288948f, -0.00797205f, 0.17215340f, 0.02561650f, 
    0.05797720f, 0.32035673f, -0.18565200f, -0.29294679f, 0.25673646f, 0.13540938f, 0.01812640f, 0.15543818f, 
    -0.10591904f, -0.03340749f, 0.01722550f, -0.05668612f, 0.21731277f, 0.10275996f, -0.01188617f, -0.07103026f, 
    -0.00673730f, 0.03543251f, 0.10335913f, -0.05022039f, 0.06380722f, 0.11832236f, -0.00062687f, 0.23299029f, 
    0.50935274f, 0.04646716f, -0.16929422f, -0.33530745f, 0.11420642f, -0.08900013f, 0.07550228f, 0.06847138f, 
    0.06626418f, 0.07878574f, -0.04823792f, 0.21887694f, 0.01990257f, -0.22725990f, 0.09561021f, 0.03429781f, 
    -0.03109892f, -0.08864833f, -0.06488235f, 0.01363158f, -0.04503733f, 0.02593298f, 0.02145410f, -0.12202124f, 
    -0.09991188f, -0.20775871f, -0.04989856f, -0.15169479f, -0.09531494f, -0.13152942f, -0.11176565f, 0.07929391f, 
    -0.01305716f, 0.10659642f, -0.05654260f, 0.10576033f, -0.12745591f, -0.28393084f, -0.27464059f, 0.15215302f, 
    -0.04410276f, -0.05753024f, 0.05699381f, -0.03263590f, -0.14549981f, -0.05482324f, -0.04340086f, -0.00345204f, 
    -0.13494100f, 0.16556147f, -0.12843753f, -0.10136086f, 0.15322556f, -0.00579055f, 0.07172780f, -0.11461203f, 
    -0.01971279f, 0.01084134f, 0.11285952f, 0.17889832f, 0.10293303f, -0.25343427f, -0.13996850f, 0.20598879f, 
    0.00976141f, 0.09295585f, 0.06395610f, 0.03926795f, -0.08271126f, 0.01295733f, -0.05411477f, 0.08902146f, 
    0.11854149f, -0.12257773f, 0.30750409f, 0.41577563f, 0.00094104f, 0.03029980f, 0.14332925f, 0.16469043f, 
    0.02786494f, 0.03469956f, 0.08108249f, -0.04625192f, 0.04064024f, -0.05290597f, 0.04279801f, -0.14467420f, 
    0.11751558f, 0.01016241f, 0.17820652f, 0.10627199f, -0.08589460f, -0.10432539f, 0.04780577f, -0.12781583f, 
    -0.11163522f, -0.11474153f, -0.01232076f, 0.05576596f, 0.07521912f, -0.15971102f, 0.01153079f, -0.10278500f, 
    -0.00671990f, -0.07331134f, -0.10587374f, -0.02762711f, 0.09787748f, 0.07476471f, 0.08974545f, 0.03927654f, 
    0.01429002f, 0.13688698f, 0.00511058f, 0.21770376f, -0.13270698f, -0.20389578f, 0.05257199f, 0.05079891f, 
    0.04091998f, -0.09717370f, -0.14934318f, -0.04066420f, -0.05546058f, 0.12360265f, -0.03170221f, -0.08760002f, 
    -0.01525399f, 0.19642316f, 0.15908632f, -0.02989910f, -0.15194528f, -0.05554337f, 0.00748384f, -0.05443986f, 
    0.15716507f, -0.03359238f, -0.09335953f, -0.01238473f, -0.12602930f, 0.13227746f, 0.01031339f, -0.03615179f, 
    -0.09086822f, 0.19163917f, 0.17919792f, -0.07556016f, 0.13381450f, 0.08970431f, 0.09866935f, -0.06346053f, 
    0.00775839f, 0.11430783f, -0.05402435f, 0.15048148f, 0.15085702f, -0.09778707f, 0.02068272f, 0.04319647f, 
    0.17427382f, 0.21419792f, 0.02441753f, -0.07437401f, 0.02351583f, -0.00657665f, -0.13507803f, -0.01715032f, 
    -0.37662411f, -0.17311740f, 0.19435009f, 0.05990315f, 0.05469319f, -0.07797562f, -0.04801054f, 0.02111248f, 
    -0.09126838f, -0.04466554f, 0.01000682f, 0.01136902f, -0.03397500f, 0.24608073f, -0.27532634f, -0.14444652f, 
    0.05140996f, 0.13012406f, 0.04962278f, 0.09591901f, 0.03318109f, 0.08674341f, 0.00643942f, 0.12752989f, 
    0.05859797f, 0.00079506f, 0.28400663f, -0.08847903f, 0.15250447f, 0.08192536f, 0.06696910f, -0.08663848f, 
    -0.01202689f, -0.03091474f, -0.03267975f, 0.07993627f, 0.32801360f, -0.05632704f, -0.06843504f, 0.08089046f, 
    0.22859609f, -0.10957135f, -0.00695632f, -0.00587122f, 0.01994434f, -0.01389888f, 0.01959883f, 0.06834409f, 
    -0.06708325f, -0.18257861f, 0.05937720f, 0.05244704f, 0.13798435f, -0.06279227f, 0.16837993f, -0.04361245f, 
    -0.02366909f, -0.01397473f, -0.04551532f, -0.01390241f, 0.14992142f, -0.10450476f, 0.19218394f, -0.12000202f, 
    0.09842141f, -0.15547524f, 0.02986566f, -0.06918976f, -0.15979336f, -0.21546389f, -0.06595736f, -0.08144656f, 
    -0.13141388f, 0.22439297f, 0.03767867f, -0.14931121f, 0.22826689f, 0.09881064f, -0.05896493f, -0.00496968f, 
    -0.09045385f, -0.03487168f, -0.03717060f, -0.04140483f, 0.46711043f, -0.18338622f, 0.22518694f, -0.16574284f, 
    -0.14936669f, 0.09396664f, 0.12151393f, -0.02369991f, 0.11640202f, 0.05395717f, 0.09756949f, -0.09352738f, 
    0.26879263f, 0.07022206f, -0.02732532f, 0.01958467f, -0.03551795f, 0.10633298f, -0.05070681f, -0.03993410f, 
    0.02221965f, -0.05785108f, -0.02852637f, 0.16063923f, -0.23894008f, -0.06816787f, 0.05706745f, -0.08340797f, 
    0.06645348f, -0.03150804f, 0.08709368f, 0.09279844f, 0.03092963f, 0.02341944f, 0.09488541f, 0.04869095f, 
    -0.14519350f, -0.20269984f, 0.19208528f, 0.09795952f, 0.09468004f, 0.06701517f, 0.10970999f, 0.25910288f, 
    -0.00803474f, -0.11007899f, 0.01829635f, -0.03277970f, -0.12916070f, -0.34847945f, -0.24180119f, 0.29921216f, 
    -0.05707374f, -0.04633928f, -0.11152340f, 0.11108053f, -0.11830736f, -0.00480789f, -0.03671852f, 0.10254823f, 
    -0.02268180f, 0.02279177f, -0.04688137f, -0.02963241f, -0.03673000f, -0.02735317f, -0.02031341f, -0.03162707f, 
    0.04208275f, -0.04238530f, -0.04018545f, -0.03780319f, -0.01635121f, 0.00710049f, -0.03814410f, 0.04274352f, 
    -0.02578881f, 0.00402123f, -0.00279439f, 0.01764734f, -0.06001935f, -0.03222562f, -0.05622440f, 0.03372278f, 
    0.01295253f, -0.03285094f, -0.00179704f, 0.02700923f, 0.04106730f, 0.02163804f, 0.02955852f, 0.00626392f, 
    0.03352232f, 0.00168863f, -0.03674359f, 0.00780344f, -0.03829278f, 0.03570452f, 0.01712460f, 0.02893329f, 
    0.03055847f, -0.01769543f, -0.01258355f, 0.03032715f, 0.00106863f, -0.02536851f, 0.00851824f, 0.02223798f, 
    0.03940804f, 0.02272867f, -0.04472019f, -0.04926059f, -0.05055239f, -0.01508692f, -0.00206117f, -0.04588665f, 
    -0.04958827f, 0.01877384f, 0.01294540f, 0.02031534f, -0.03125513f, -0.03906577f, 0.01217387f, 0.01765627f, 
    -0.04871373f, -0.00723487f, -0.04833348f, 0.02310765f, 0.02781076f, 0.00437588f, 0.01118383f, -0.05134787f, 
    0.02114755f, 0.02007093f, 0.04031815f, -0.00835051f, -0.05135724f, -0.03810858f, -0.00203095f, -0.03052789f, 
    0.00589300f, 0.00386319f, -0.05596877f, -0.05707049f, -0.03607674f, 0.00099725f, 0.02119728f, 0.01047776f, 
    -0.03616234f, -0.02574000f, 0.00947188f, 0.01055637f, -0.00464077f, 0.04270721f, -0.00622775f, -0.02589096f, 
    0.03732930f, -0.04389973f, -0.02294437f, -0.00420314f, -0.04397140f, 0.02420914f, 0.01636908f, -0.03285727f, 
    0.01999252f, 0.00930083f, -0.01104103f, -0.00662377f, -0.05961318f, -0.01329420f, -0.02214295f, 0.00561880f, 
    0.03306640f, -0.01783342f, 0.00329399f, -0.01014286f, 0.03090666f, -0.00304906f, -0.03907299f, 0.02889573f, 
    -0.00286008f, 0.02771958f, -0.03310787f, -0.02207580f, -0.02848064f, 0.03679504f, 0.00302934f, 0.03228834f, 
    -0.03568518f, -0.01022923f, 0.02814097f, -0.01811409f, -0.04865757f, -0.03421151f, 0.03323861f, 0.02682296f, 
    -0.00229049f, -0.00798652f, 0.03622102f, 0.01462602f, -0.05465632f, 0.03419071f, -0.02857283f, -0.04060970f, 
    -0.01129351f, -0.01715931f, 0.03275314f, 0.00921271f, -0.05087883f, -0.04609385f, 0.00046159f, 0.01349360f, 
    -0.01194833f, -0.04691199f, 0.02710732f, 0.00003902f, -0.04521442f, -0.02171406f, -0.01307902f, -0.03510868f, 
    -0.01326700f, 0.02251945f, 0.03466835f, 0.03857326f, -0.03307549f, -0.04949658f, 0.03209693f, 0.04538972f, 
    0.01787749f, -0.02387794f, 0.00311260f, -0.02372296f, -0.02175122f, -0.00218453f, -0.01032259f, -0.03169924f, 
    0.01751146f, -0.01037388f, -0.04024715f, 0.01632135f, -0.02853032f, 0.02895927f, -0.03015401f, -0.01565391f, 
    0.02088496f, -0.04084072f, 0.01803243f, -0.05801792f, 0.02992153f, 0.02704469f, -0.04148038f, 0.03906032f, 
    -0.03946907f, 0.01813937f, -0.01953112f, -0.02268341f, 0.03587437f, 0.02641098f, -0.03844214f, -0.05737909f, 
    -0.03488029f, 0.00357257f, 0.02530777f, -0.01162286f, -0.04868029f, -0.00679565f, -0.03238109f, -0.05356979f, 
    -0.02622225f, -0.05012189f, 0.01807786f, 0.03606352f, 0.03789216f, -0.00321485f, -0.05747887f, -0.04545620f, 
    0.02421673f, -0.05198481f, -0.00073644f, 0.03271447f, -0.04154954f, 0.01940269f, -0.00638230f, 0.03905303f, 
    0.00839674f, -0.03318719f, 0.02271735f, 0.02301050f, -0.00040067f, -0.00574098f, -0.02252824f, -0.03512237f, 
    -0.04401202f, 0.01711042f, -0.02948054f, 0.01095644f, -0.04026571f, -0.00410235f, -0.05180217f, 0.03584418f, 
    -0.02628594f, -0.02344111f, 0.00941472f, -0.04186694f, -0.01608531f, -0.04600205f, -0.01727551f, 0.02628299f, 
    0.00540410f, 0.03513543f, -0.01842207f, -0.01777300f, 0.01853498f, 0.00016382f, 0.00964241f, 0.01138629f, 
    0.02407737f, -0.02109346f, 0.01112308f, -0.01894427f, 0.02469064f, 0.01089333f, -0.03889515f, 0.04055224f, 
    -0.00791795f, -0.01177623f, -0.03000564f, -0.03355608f, 0.01980714f, 0.00394832f, -0.00466411f, -0.04437857f, 
    -0.04346482f, -0.01836868f, 0.04140907f, 0.03177088f, -0.00631725f, 0.02791508f, -0.04876430f, 0.02052078f, 
    0.02374982f, -0.01415772f, 0.03625478f, 0.03125349f, -0.02363269f, -0.03714983f, -0.03524205f, 0.02201114f, 
    0.03113751f, 0.04724847f, 0.03671515f, -0.03693066f, -0.00099294f, 0.02940209f, 0.03446240f, 0.00631630f, 
    -0.02639933f, -0.00037178f, 0.02053596f, -0.02121362f, 0.06710617f, -0.01260300f, -0.02531238f, 0.00577332f, 
    0.00115151f, -0.00214708f, -0.02007502f, 0.00665761f, 0.04150832f, 0.04525516f, -0.02130491f, 0.01475345f, 
    0.03896198f, 0.03850388f, -0.01473875f, -0.01458300f, -0.04229151f, 0.00643763f, 0.01050820f, 0.03066115f, 
    0.01166088f, -0.01174597f, 0.01827396f, -0.03774117f, -0.01258962f, 0.00282668f, 0.01541079f, -0.04461618f, 
    0.03513199f, 0.01575724f, 0.01930937f, 0.01168227f, -0.02720241f, -0.01302648f, 0.00851936f, -0.04247315f, 
    -0.03672219f, -0.00139255f, -0.02718416f, -0.03445958f, -0.04169299f, -0.04076179f, -0.05321714f, 0.02418540f, 
    -0.03086857f, -0.05478648f, -0.01378027f, -0.03756191f, 0.00153452f, 0.00037137f, -0.04569308f, -0.01948395f, 
    0.01645676f, -0.02587626f, 0.00832717f, 0.01117613f, 0.00490848f, 0.03280460f, 0.02936366f, -0.01008536f, 
    -0.01525293f, -0.01804299f, 0.02908404f, -0.05507515f, -0.02594570f, -0.03668769f, 0.00491696f, -0.03833199f, 
    -0.02754525f, 0.02047457f, -0.00514185f, 0.00350972f, 0.00923628f, -0.03764759f, -0.01614346f, -0.03601196f, 
    -0.00034970f, -0.00132956f, 0.02971401f, -0.00364936f, -0.00610889f, -0.01558202f, 0.01462628f, -0.02867484f, 
    -0.21633191f, 0.25125155f, 0.17351241f, 0.03328740f, 0.17049760f, -0.04710862f, -0.01074488f, 0.01893296f, 
    0.04070484f, -0.06851318f, 0.04291374f, 0.17848837f, 0.10319811f, 0.05163691f, -0.12112722f, -0.09222678f, 
    -0.03623267f, -0.05253555f, 0.03901635f, 0.02511572f, -0.08045344f, 0.09856842f, 0.07580003f, 0.18792880f, 
    -0.33193800f, -0.19142000f, 0.06364907f, 0.03909326f, -0.02103784f, 0.01065132f, 0.01834224f, -0.20474303f, 
    -0.07421756f, 0.09686273f, 0.11271212f, 0.18671703f, -0.22420290f, -0.10653309f, -0.19739042f, 0.14971383f, 
    0.01387649f, -0.02640823f, 0.06955949f, 0.10746977f, 0.22473942f, 0.11675477f, 0.23120958f, 0.10600322f, 
    -0.16086900f, -0.15494715f, 0.16610843f, -0.13687499f, -0.02152912f, 0.07666434f, -0.04816367f, -0.07803361f, 
    0.15859748f, -0.02782375f, 0.00901598f, 0.07513961f, 0.00992995f, -0.00612753f, 0.12342864f, 0.01137160f, 
    -0.05830545f, 0.00104751f, 0.05176455f, 0.01317383f, -0.08743349f, -0.18915035f, -0.11035496f, -0.23176424f, 
    -0.10774032f, 0.00762878f, -0.01201348f, 0.00653144f, 0.04967388f, 0.05843370f, 0.08865982f, -0.05714245f, 
    -0.00632494f, 0.28473699f, -0.01831941f, -0.09701803f, 0.02755505f, -0.21281648f, -0.00913302f, -0.06146902f, 
    0.06007810f, -0.11064427f, 0.06407710f, 0.04411121f, -0.06052987f, 0.07607598f, -0.06827801f, -0.09226476f, 
    -0.29554778f, -0.04215406f, -0.30399761f, 0.24921958f, -0.02411478f, 0.08903231f, 0.09701765f, -0.11417336f, 
    0.10235695f, 0.01888375f, -0.06122078f, -0.13588467f, -0.28112856f, 0.00708259f, 0.19321330f, -0.13954909f, 
    0.25829592f, 0.07237370f, 0.02771164f, 0.00646081f, -0.11360820f, 0.26282594f, -0.02525509f, 0.30181158f, 
    -0.25548714f, -0.01243229f, 0.03678693f, 0.18416931f, 0.17340934f, 0.13126956f, -0.11659618f, -0.28171638f, 
    0.09135835f, -0.13034587f, -0.18511426f, 0.40649396f, -0.15212692f, -0.08888321f, 0.00208519f, -0.19612037f, 
    0.08544014f, -0.03213963f, -0.02447572f, -0.11037291f, -0.05029638f, -0.07670045f, -0.10605610f, -0.02809344f, 
    0.28645390f, 0.12951854f, -0.22263891f, 0.12519306f, 0.04282675f, 0.03823065f, -0.00349154f, 0.06417099f, 
    0.09215137f, -0.01751466f, 0.05335718f, 0.07888110f, -0.04564859f, -0.09229767f, 0.10878506f, 0.06026296f, 
    0.02968342f, -0.04590343f, 0.06470363f, -0.02846682f, 0.29674646f, 0.34464937f, 0.08261616f, 0.12366871f, 
    0.13755471f, 0.01190101f, -0.21054006f, -0.13253242f, 0.03195095f, 0.18778446f, 0.07806577f, -0.04607424f, 
    0.03958163f, 0.04622046f, 0.01391009f, -0.11655860f, -0.25600505f, 0.07122502f, 0.01047606f, 0.25952515f, 
    -0.07077003f, -0.02913067f, 0.09897482f, -0.18158868f, 0.04107380f, 0.19971803f, 0.05845033f, 0.05820234f, 
    0.20313765f, 0.10458127f, -0.09041686f, 0.02475694f, 0.04381538f, -0.04029524f, -0.05750538f, -0.11494359f, 
    -0.06123142f, 0.29118124f, 0.05046997f, 0.14662223f, 0.09276597f, -0.01786954f, 0.06990507f, 0.08266194f, 
    -0.07214338f, 0.05111142f, -0.01396079f, 0.05187370f, 0.04554612f, -0.11218783f, 0.08372139f, -0.03664289f, 
    0.25271422f, 0.23870908f, 0.16485891f, -0.16395546f, 0.07067607f, 0.01679965f, -0.19118547f, -0.07346553f, 
    -0.01290984f, -0.01594807f, 0.05393051f, -0.10582411f, 0.11655214f, 0.23361361f, -0.06224641f, -0.15730809f, 
    0.04492182f, 0.18176283f, -0.18991001f, 0.08356293f, 0.08300287f, 0.12722319f, 0.08968077f, 0.11954288f, 
    -0.41760033f, -0.25128758f, -0.03624333f, 0.11344588f, 0.01955058f, 0.00241846f, 0.14665364f, -0.12958618f, 
    -0.03254269f, 0.16317236f, 0.00050540f, 0.00989640f, -0.03674574f, -0.10129638f, -0.05919013f, -0.26457536f, 
    0.20568666f, -0.15828171f, 0.04343102f, 0.14855722f, 0.03577264f, 0.04717870f, -0.03838715f, 0.13346379f, 
    -0.02034487f, -0.08300183f, 0.21363451f, -0.09999529f, -0.00599349f, 0.03281818f, -0.17598893f, -0.07035490f, 
    0.08230446f, -0.06111014f, 0.16487396f, -0.15754138f, 0.02262216f, 0.23698494f, -0.03163061f, 0.01585481f, 
    0.04932341f, 0.17390071f, -0.05326770f, 0.04440578f, 0.12786333f, -0.08614820f, 0.00449845f, -0.00094345f, 
    -0.19677518f, -0.14253321f, 0.08518090f, 0.06137982f, 0.20638125f, -0.14153239f, -0.08981714f, -0.12669432f, 
    -0.07507806f, 0.08274721f, -0.05228708f, -0.02033552f, -0.30705249f, -0.04020327f, -0.22698942f, 0.14839534f, 
    -0.18930309f, -0.15733312f, -0.03041596f, 0.08464370f, 0.11056656f, 0.17043576f, 0.08940117f, 0.04958108f, 
    0.15213464f, 0.19676918f, 0.11213966f, -0.09350381f, -0.02792395f, 0.11674508f, 0.05543026f, 0.14780201f, 
    0.09302276f, 0.20169133f, 0.23217082f, 0.23162855f, 0.01923502f, 0.15575930f, -0.08134462f, -0.11341172f, 
    -0.07337331f, 0.12278977f, 0.04193906f, 0.09916484f, 0.10667501f, -0.12597497f, 0.10807432f, 0.18564969f, 
    0.35479450f, 0.22649750f, -0.12398172f, -0.23436375f, 0.05864377f, -0.04943668f, -0.00584620f, -0.09205919f, 
    0.03847983f, -0.19180942f, 0.48106512f, 0.14299580f, 0.01919727f, 0.03472774f, 0.11580230f, -0.02504262f, 
    0.08647937f, 0.27542090f, -0.13100171f, -0.06706496f, 0.16520123f, -0.03620889f, 0.11770934f, -0.24429299f, 
    -0.33937374f, -0.18707101f, -0.17453030f, 0.07341950f, 0.07601485f, -0.20919934f, -0.09257600f, -0.18418904f, 
    0.02068938f, -0.21851628f, -0.18494219f, -0.07869612f, -0.17482200f, -0.24676748f, -0.00593881f, -0.16742325f, 
    0.23543869f, 0.17679048f, -0.07148542f, 0.03223629f, 0.03645124f, 0.06024903f, -0.03489256f, 0.02458552f, 
    -0.00863480f, -0.01262416f, -0.04452804f, -0.03286683f, 0.01386720f, 0.03871620f, -0.00281571f, -0.02266826f, 
    -0.02547487f, -0.01605202f, -0.03025904f, 0.01571355f, -0.03074464f, 0.01072615f, -0.02119200f, 0.02224392f, 
    -0.04019153f, -0.01510953f, 0.03468257f, -0.04979060f, 0.04126468f, 0.00787345f, -0.05213698f, -0.00529786f, 
    -0.04284385f, -0.02117575f, -0.00947727f, -0.04656927f, 0.00930204f, -0.02982079f, -0.04130860f, -0.05326191f, 
    -0.03690265f, -0.05279213f, 0.04113266f, -0.01565675f, -0.00522080f, -0.03651141f, 0.00643399f, -0.02806838f, 
    0.02770202f, -0.05240672f, -0.03659479f, -0.04268188f, -0.00857271f, 0.02121871f, -0.02117073f, 0.04045964f, 
    0.00506078f, -0.03752274f, -0.03043149f, -0.05376874f, -0.02079408f, 0.03626323f, -0.03137928f, 0.02193759f, 
    -0.01316014f, -0.00879204f, -0.05278109f, -0.03912857f, 0.01240260f, 0.04000619f, -0.05394257f, -0.00331495f, 
    -0.02099621f, 0.03144468f, 0.02789573f, -0.02048293f, -0.03847612f, -0.05101320f, 0.03954845f, -0.03426888f, 
    -0.05292333f, -0.04371947f, 0.00189831f, 0.01348193f, -0.02416452f, -0.04100597f, 0.02457512f, -0.03221707f, 
    -0.01753351f, -0.04515881f, 0.04192395f, 0.00328939f, 0.02946657f, -0.03099268f, 0.04420545f, 0.04434575f, 
    -0.01151719f, 0.00083846f, -0.01724867f, -0.02802384f, 0.04272925f, 0.03407081f, 0.04381160f, 0.02135998f, 
    -0.04670321f, -0.05440324f, 0.02725232f, -0.01091260f, -0.00521885f, -0.01988903f, 0.01440079f, 0.03469147f, 
    0.03291006f, -0.04415559f, 0.02907987f, 0.00580428f, 0.00269977f, 0.01259470f, -0.02695088f, 0.03326370f, 
    -0.04980233f, -0.04629007f, -0.02909353f, -0.02030014f, -0.00556248f, 0.02463217f, -0.03159377f, 0.00247001f, 
    0.00660374f, -0.00256312f, 0.00316594f, -0.02982902f, 0.02590047f, 0.04134026f, 0.00234660f, -0.01898215f, 
    -0.04917175f, 0.03624589f, -0.05541629f, -0.03521015f, -0.01193632f, 0.04174050f, -0.04230174f, -0.00043008f, 
    -0.01459582f, -0.01140209f, 0.02998156f, -0.02360765f, 0.02592759f, -0.02320100f, 0.03805725f, 0.04042839f, 
    0.00508445f, -0.02856926f, -0.03570765f, 0.02021476f, -0.02279309f, -0.00006871f, -0.02697322f, 0.03624081f, 
    0.00472216f, -0.03513457f, -0.05020680f, 0.01658634f, -0.04540105f, 0.02798875f, 0.00646182f, 0.00109411f, 
    -0.03596218f, -0.00371892f, -0.05526653f, 0.03057848f, 0.00502206f, 0.03552677f, 0.00535984f, -0.03824814f, 
    0.03843968f, -0.01333451f, 0.04156969f, 0.00807787f, 0.00191998f, -0.02566244f, -0.02081436f, -0.05315680f, 
    0.04238166f, -0.04252946f, -0.01459523f, 0.00090313f, -0.02806863f, -0.05327324f, -0.05150316f, -0.03874248f, 
    -0.00572024f, 0.03680553f, -0.00574288f, -0.02668423f, -0.02625895f, 0.03004665f, -0.03890970f, 0.00555624f, 
    0.03750963f, -0.04429552f, 0.04230763f, -0.05676058f, 0.00720476f, -0.05577601f, 0.02555687f, -0.03012665f, 
    -0.00250540f, -0.03395163f, -0.02439107f, 0.00067368f, -0.01737808f, 0.01340429f, -0.02729364f, 0.00264184f, 
    0.03710049f, 0.00190088f, -0.01287458f, -0.04850909f, 0.02292539f, 0.02124338f, -0.01955198f, 0.02688247f, 
    0.01644409f, -0.02292131f, -0.05023646f, 0.00660043f, 0.02103822f, 0.02491954f, -0.05057953f, 0.02950331f, 
    0.02643410f, 0.04267375f, -0.00895894f, -0.00238604f, -0.01239784f, -0.01470290f, 0.01585102f, -0.00873706f, 
    0.01000428f, 0.04079237f, -0.02569079f, 0.02282234f, -0.03168532f, -0.03883837f, 0.03491461f, 0.03306475f, 
    0.02966296f, -0.03648971f, -0.02641592f, -0.02231324f, 0.00374471f, 0.00767163f, -0.05588360f, 0.02912511f, 
    -0.03995652f, 0.01317604f, 0.03363808f, 0.02860567f, 0.03394490f, -0.02847369f, -0.03516803f, -0.02978484f, 
    0.03208350f, 0.02214262f, 0.00053625f, 0.00297917f, 0.02900843f, -0.04984876f, -0.02051101f, 0.02194354f, 
    0.02673187f, 0.01706491f, 0.03034431f, 0.01731720f, -0.02514923f, -0.02914377f, 0.01685765f, -0.04565624f, 
    -0.00989614f, -0.00580404f, -0.03090621f, -0.02331155f, -0.05512314f, -0.00527779f, 0.04138144f, 0.02634037f, 
    -0.01145341f, 0.01905187f, -0.00394170f, -0.02964577f, -0.01451388f, 0.02508844f, -0.05652617f, -0.01608227f, 
    -0.03685483f, 0.00313843f, -0.04878697f, -0.03545579f, 0.00287933f, -0.01247594f, 0.01988818f, -0.01777543f, 
    0.01387925f, 0.03592226f, -0.01427239f, 0.03131840f, -0.03541354f, -0.00167033f, -0.03224359f, -0.02220989f, 
    -0.01526036f, -0.01780752f, -0.02827104f, 0.03990174f, -0.00610522f, 0.02561303f, -0.01351241f, -0.05615598f, 
    0.01788136f, -0.03571290f, 0.04484775f, -0.02690155f, 0.02133657f, -0.00772642f, 0.01688011f, 0.03485444f, 
    -0.00737351f, 0.01321175f, -0.00042759f, -0.00142095f, 0.00186824f, -0.00612324f, -0.00306370f, 0.03096527f, 
    -0.01437472f, -0.00638018f, 0.02571261f, -0.02653933f, -0.02367002f, 0.00034123f, -0.01026135f, -0.00334695f, 
    0.02324619f, -0.04281367f, 0.01749985f, -0.04432292f, -0.04882692f, -0.01356866f, -0.03989400f, -0.04859100f, 
    -0.02950146f, 0.00708182f, 0.00064807f, -0.00962370f, 0.01866709f, 0.01278719f, -0.03162747f, 0.02394223f, 
    0.01135172f, 0.02044871f, 0.00701907f, -0.04464965f, -0.03804897f, 0.00692171f, 0.01159611f, -0.05666506f, 
    -0.02222029f, -0.01873350f, -0.02945038f, -0.04467056f, 0.02619645f, 0.02039448f, 0.01893341f, 0.02430717f, 
    -0.03282951f, -0.00592401f, -0.05359276f, -0.04868638f, -0.05424811f, 0.02474113f, 0.00006477f, -0.02947230f, 
    -0.02981990f, -0.00226671f, -0.05572898f, 0.02618320f, 0.02311834f, 0.04386233f, 0.00577797f, 0.02784167f, 
    -0.02631693f, -0.02891522f, -0.04071631f, -0.00823720f, -0.05042133f, -0.04376509f, 0.00695236f, -0.04307026f, 
    -0.03795578f, -0.00371651f, -0.00228710f, -0.00196795f, -0.05341984f, -0.05179876f, 0.02517891f, -0.01535488f, 
    0.00992883f, -0.03037089f, 0.00947228f, -0.00570999f, -0.02250341f, 0.03928848f, 0.02997570f, 0.01395284f, 
    -0.01993207f, 0.03113141f, 0.02212595f, -0.00864656f, -0.02708362f, 0.02996464f, -0.05483198f, -0.04396069f, 
    0.02037133f, -0.04275111f, 0.03840606f, -0.00952893f, 0.03242219f, 0.01609421f, 0.04151835f, -0.02704971f, 
    -0.02508795f, -0.04127024f, 0.02516243f, 0.02756151f, -0.01693309f, -0.02330553f, 0.04318975f, -0.00463375f, 
    0.05136445f, -0.01979562f, 0.03848643f, -0.00731857f, -0.03777232f, 0.02901411f, -0.01004736f, 0.02564616f, 
    -0.02277987f, -0.01577038f, -0.00304536f, 0.04396795f, -0.02252029f, 0.04242076f, 0.02371129f, -0.01926299f, 
    -0.04687978f, 0.00907341f, 0.02444604f, 0.02540654f, 0.01700283f, 0.02411230f, 0.04496587f, 0.01947104f, 
    -0.02338423f, 0.00486588f, -0.01206313f, 0.03469084f, -0.01021067f, 0.02269206f, -0.04192111f, -0.02318548f, 
    -0.03570497f, -0.00118981f, -0.00384705f, -0.02676877f, -0.02876366f, -0.04316136f, 0.02526085f, -0.03913595f, 
    -0.04959131f, 0.00987590f, 0.03264349f, 0.00645927f, 0.00680666f, 0.04710494f, -0.02934531f, 0.00817459f, 
    -0.04112696f, -0.02297803f, -0.00265136f, -0.05219641f, -0.03697604f, -0.04014551f, 0.02427108f, -0.03295919f, 
    -0.04123969f, 0.01704858f, 0.03536759f, 0.00604825f, 0.02948854f, -0.03928898f, -0.03263073f, 0.01552281f, 
    0.00668256f, -0.05509882f, -0.00474550f, 0.00922800f, -0.04437444f, 0.03984190f, -0.01544119f, 0.00187321f, 
    -0.02365243f, 0.02343621f, 0.04267813f, -0.05466518f, 0.02241375f, -0.04952502f, 0.00947923f, 0.01493365f, 
    -0.02757311f, -0.03539405f, 0.04996896f, 0.02583213f, 0.03520212f, 0.02415349f, -0.02431536f, 0.01215167f, 
    -0.02598970f, 0.01884327f, 0.03757951f, 0.00689588f, -0.01209092f, 0.01982503f, -0.01586824f, 0.03544016f, 
    0.02243486f, 0.03891525f, -0.04396409f, -0.03803330f, 0.00156257f, -0.01626296f, -0.02525217f, 0.03915677f, 
    0.01631403f, -0.02088136f, -0.00371276f, 0.02517213f, -0.05630665f, 0.00024224f, 0.00404509f, -0.02630679f, 
    0.03811757f, -0.02485332f, 0.00741509f, -0.02575660f, -0.04994974f, -0.04706085f, -0.00989595f, 0.00444598f, 
    -0.05148169f, -0.02681080f, -0.04066925f, -0.00332591f, -0.01386713f, -0.03952558f, -0.01357975f, 0.01774368f, 
    -0.01989088f, 0.00954326f, -0.00565941f, 0.00032568f, 0.01544513f, -0.02092185f, -0.02444119f, 0.03261774f, 
    -0.04786400f, -0.00362717f, -0.00051161f, -0.02549249f, 0.00669074f, -0.02960232f, -0.05694931f, 0.04178010f, 
    -0.03713423f, 0.00907320f, 0.04334032f, -0.03926076f, 0.03530843f, -0.04109843f, 0.01484878f, 0.01201580f, 
    0.03865267f, -0.02573588f, 0.03291576f, 0.01140156f, -0.03356810f, 0.03334326f, -0.02833386f, -0.03917709f, 
    0.01187978f, 0.04853654f, 0.00000644f, 0.00519233f, -0.02862498f, 0.02445444f, -0.00256920f, -0.04314698f, 
    -0.00580426f, -0.03964785f, -0.03865379f, 0.00397996f, -0.01137825f, -0.00476905f, 0.00903961f, 0.02079143f, 
    0.00466541f, -0.00010330f, -0.00586505f, -0.04017133f, 0.00750173f, 0.02425539f, 0.02874936f, 0.05628281f, 
    -0.00214036f, -0.01887145f, 0.04186671f, 0.01922990f, 0.02382574f, -0.02117504f, -0.00902875f, 0.00328999f, 
    -0.05291167f, -0.05542924f, 0.02742818f, -0.03643914f, -0.03691344f, -0.01362633f, 0.01264894f, 0.03044844f, 
    -0.04097879f, 0.02439155f, 0.03276214f, -0.03534262f, 0.01404842f, 0.00768220f, -0.04968033f, 0.02080817f, 
    -0.01236732f, -0.04998676f, 0.01639479f, 0.02932922f, -0.03127094f, 0.00698119f, -0.05387321f, -0.02772403f, 
    0.02132868f, -0.00619077f, -0.02415834f, -0.05111871f, -0.00899920f, -0.02759741f, -0.02608445f, 0.03153703f, 
    -0.00385068f, 0.03111339f, -0.00846592f, -0.00994072f, -0.03980282f, -0.00809034f, -0.05305904f, 0.03625824f, 
    -0.00897362f, -0.03089078f, -0.01277279f, 0.01023707f, 0.01421332f, 0.01659935f, 0.02825680f, -0.02541956f, 
    -0.02611162f, 0.01195812f, -0.02858403f, -0.01373892f, 0.01118022f, 0.01607858f, -0.04299944f, -0.04416952f, 
    0.00960062f, -0.01586228f, 0.01922568f, -0.00787015f, 0.02082139f, -0.02734694f, 0.03148054f, -0.01122064f, 
    0.00035503f, 0.03902676f, -0.03391011f, 0.02226865f, 0.01108185f, -0.00872672f, 0.00805479f, 0.01512650f, 
    -0.03477967f, 0.00663706f, -0.04851644f, -0.04358133f, 0.01066237f, -0.01527235f, 0.01640812f, 0.03965675f, 
    -0.01003203f, 0.03340157f, 0.00619265f, 0.00982443f, 0.02640796f, -0.02054908f, 0.03952708f, -0.02828950f, 
    0.03150583f, -0.05541602f, 0.04462496f, -0.01357547f, -0.04163365f, 0.04259278f, 0.01412439f, 0.00519027f, 
    0.03889682f, -0.04940930f, 0.03138128f, -0.01460367f, -0.01154977f, -0.05447162f, -0.04647271f, -0.05380248f, 
    0.00922699f, -0.02863944f, -0.00522007f, 0.02981629f, -0.05575839f, -0.01959212f, -0.02320915f, 0.02901629f, 
    -0.03231055f, 0.02208706f, -0.02421352f, -0.03260728f, -0.00637604f, 0.01980993f, -0.00026646f, -0.00770876f, 
    -0.01866518f, -0.00068472f, -0.02545910f, -0.05034411f, -0.05218197f, -0.04046720f, 0.02362836f, -0.03731607f, 
    0.00412668f, -0.03709334f, -0.00892867f, 0.01440151f, 0.01076261f, -0.05343229f, 0.00197517f, 0.02003015f, 
    0.03432759f, -0.02037082f, -0.02259096f, -0.03637381f, -0.01498443f, -0.03287079f, -0.04641609f, -0.03749469f, 
    -0.03361515f, -0.00762752f, -0.02852863f, 0.02618444f, -0.04233261f, -0.04481006f, 0.01376641f, 0.03507913f, 
    -0.00957093f, 0.03839208f, 0.02787132f, -0.02104960f, 0.00798954f, 0.00024323f, 0.04672301f, 0.00411210f, 
    0.02560990f, 0.04237005f, 0.01687065f, -0.01256896f, -0.03800536f, -0.00348154f, 0.01889605f, -0.04666239f, 
    0.01475190f, 0.05291331f, -0.05450159f, 0.03562450f, 0.04765773f, -0.03540658f, -0.00698304f, 0.02193832f, 
    -0.01883669f, 0.01053878f, -0.02173702f, 0.00492681f, 0.00211178f, -0.03842169f, -0.05348181f, 0.01253666f, 
    -0.02909734f, -0.05521644f, 0.02008068f, 0.02782621f, 0.00758246f, -0.03790990f, -0.04633578f, -0.02574893f, 
    -0.03171241f, -0.00780186f, 0.00434155f, -0.00903051f, 0.02850848f, -0.02806651f, -0.04641136f, 0.03513017f, 
    -0.00321095f, -0.00766855f, 0.00790535f, -0.01830525f, 0.04165308f, -0.02672749f, 0.03739831f, -0.04795505f, 
    0.02582236f, -0.04741234f, 0.02080424f, 0.02003183f, 0.00380206f, -0.02044530f, -0.00056884f, 0.02244925f, 
    -0.03802751f, 0.00856229f, -0.04745886f, 0.03890483f, -0.05003250f, 0.01440421f, -0.00008406f, 0.04407890f, 
    0.01860813f, 0.01065890f, -0.03388288f, -0.05238216f, -0.04273658f, -0.03262168f, -0.01793832f, -0.01291220f, 
    0.03243905f, -0.04285025f, -0.00572237f, -0.01501986f, 0.02208005f, -0.02773955f, -0.00283596f, -0.00856083f, 
    0.02674085f, 0.02804026f, -0.04873346f, 0.00704909f, -0.01443883f, -0.04308942f, 0.04660577f, -0.05066300f, 
    -0.05270674f, -0.03152773f, -0.00264163f, -0.00422446f, 0.00769444f, -0.05126595f, 0.00503979f, -0.05172040f, 
    -0.00826260f, 0.00813815f, 0.02507999f, -0.00882498f, -0.00607170f, 0.00901134f, -0.00193653f, -0.03966396f, 
    0.01209057f, -0.04246053f, 0.03736573f, 0.02918770f, 0.02429658f, 0.00696942f, 0.02417353f, 0.01053471f, 
    0.02829240f, 0.02310437f, -0.04600872f, 0.03201985f, -0.02229314f, 0.01485142f, -0.05683365f, -0.02747449f, 
    -0.02515356f, -0.01364800f, 0.02655298f, -0.00764114f, 0.03536135f, 0.03666260f, 0.02737538f, -0.03371498f, 
    -0.02429164f, 0.01950158f, -0.01301343f, 0.03746457f, -0.00336081f, 0.03440863f, 0.01483116f, -0.00623062f, 
    -0.03666278f, -0.03248167f, -0.01615750f, 0.00402859f, 0.02545353f, 0.01597006f, -0.02171009f, -0.00593448f, 
    -0.03857948f, -0.00475853f, -0.00265026f, -0.01825503f, 0.01353616f, -0.00312232f, -0.05789465f, -0.02654144f, 
    -0.04300889f, -0.01947237f, -0.00631891f, -0.02345954f, -0.03292349f, 0.03108504f, -0.04726936f, -0.03418721f, 
    -0.01625252f, -0.02236003f, -0.02370954f, 0.01313407f, 0.03961431f, -0.02482944f, -0.01717264f, -0.01314050f, 
    0.04035679f, 0.03076245f, 0.02424855f, -0.02707525f, 0.00573488f, -0.03992449f, 0.02049384f, -0.02781230f, 
    -0.03644729f, -0.02788202f, -0.04693683f, -0.03454778f, -0.01884808f, -0.00167847f, -0.02804022f, 0.03312808f, 
    -0.03595786f, 0.04213179f, -0.02347728f, -0.00456852f, 0.02139096f, -0.04940014f, 0.02565203f, -0.00624789f, 
    -0.00416864f, 0.01515142f, -0.03007782f, 0.00981456f, 0.01474516f, -0.04844304f, 0.02423253f, -0.03352206f, 
    -0.05667904f, 0.02015733f, -0.00187527f, -0.04756334f, -0.01940786f, -0.05905045f, 0.00967468f, -0.02504942f, 
    0.03685479f, -0.04524373f, 0.03488701f, -0.02886277f, 0.01831349f, 0.03783640f, -0.02373146f, 0.03954823f, 
    -0.01529725f, -0.02890710f, 0.00557595f, 0.03095507f, 0.02904257f, 0.04105793f, -0.04502252f, 0.02335789f, 
    -0.02658064f, -0.01256799f, 0.02420117f, -0.01125993f, -0.00468362f, -0.04097414f, 0.01038396f, 0.02914222f, 
    -0.03426735f, 0.01509277f, -0.03303332f, -0.01231328f, 0.03478966f, 0.00336621f, -0.03707394f, 0.04453445f, 
    0.03279943f, -0.04888156f, 0.02182050f, -0.02046846f, 0.01876305f, -0.01732421f, -0.04494485f, -0.03872380f, 
    0.03426550f, 0.01925067f, -0.04835916f, -0.03843272f, -0.01662087f, -0.03902612f, -0.02862319f, -0.04951609f, 
    -0.04339489f, -0.01246464f, 0.01965787f, 0.01068031f, -0.05305282f, 0.00426415f, 0.02210012f, -0.03645179f, 
    -0.01816934f, -0.03611088f, 0.03806805f, -0.02026421f, -0.00516287f, -0.00938186f, 0.05070105f, -0.00273729f, 
    0.05173033f, 0.03146840f, -0.01148470f, -0.04517895f, -0.01175534f, -0.01905574f, -0.02648879f, 0.03048295f, 
    0.03223311f, 0.04107300f, -0.02591327f, 0.03662448f, -0.01870801f, -0.02075766f, 0.02598729f, -0.04390291f, 
    -0.04521659f, -0.01778934f, 0.03038834f, 0.01204480f, 0.04288998f, 0.02825802f, 0.02844716f, -0.01511416f, 
    -0.04632709f, -0.03886396f, 0.03656216f, -0.04127533f, -0.03795376f, -0.04840126f, -0.03636859f, -0.03104834f, 
    -0.00198027f, -0.01989138f, 0.01313679f, 0.02462374f, -0.02250087f, 0.03364105f, -0.01736997f, 0.01071563f, 
    -0.03252518f, 0.02766264f, 0.01390663f, -0.00641163f, -0.00923073f, 0.00042396f, -0.01644027f, 0.00904861f, 
    0.00895706f, 0.02336507f, -0.00395225f, 0.00126508f, -0.00347088f, 0.02549672f, 0.00245061f, -0.03959193f, 
    -0.02754812f, 0.02004254f, 0.02420056f, -0.03387215f, 0.02011027f, 0.03766761f, -0.01924173f, 0.00367164f, 
    0.01667549f, -0.00147028f, -0.03652035f, 0.02362351f, -0.01907382f, 0.00418847f, 0.01822140f, 0.02796740f, 
    0.02094889f, 0.03846491f, -0.01018406f, 0.02008728f, 0.02157066f, 0.02454515f, -0.03298364f, 0.03996924f, 
    -0.00959138f, 0.04710649f, -0.04446861f, 0.00633010f, -0.00960632f, 0.02111632f, -0.02295284f, 0.00849924f, 
    -0.04123110f, -0.04484953f, 0.04663697f, -0.01423439f, 0.02872175f, -0.04774880f, -0.03747661f, -0.03220848f, 
    -0.02039798f, -0.01726482f, 0.01736878f, -0.03750057f, 0.00516633f, 0.04297850f, -0.02779916f, -0.01092202f, 
    -0.02815918f, -0.01879119f, -0.05361299f, -0.00958248f, 0.03611899f, 0.02002298f, 0.01582860f, -0.02494410f, 
    0.02247172f, 0.01498437f, 0.02139944f, -0.04155013f, 0.00419339f, 0.04018832f, 0.03851097f, -0.02478271f, 
    -0.03510442f, -0.03857671f, 0.01523674f, -0.04463881f, -0.04920515f, 0.04617381f, 0.02215549f, 0.01579502f, 
    0.00871412f, 0.01166409f, 0.02019548f, 0.02540074f, -0.04137840f, 0.03858888f, 0.03071681f, 0.02270603f, 
    -0.03409242f, -0.00623593f, 0.04203774f, 0.01165667f, -0.04457601f, -0.04110764f, 0.04146910f, -0.04628715f, 
    0.03655086f, 0.02240003f, -0.00892135f, -0.00311280f, -0.03054609f, 0.00203275f, -0.03815420f, 0.01662030f, 
    -0.04046497f, -0.03338458f, 0.03442572f, -0.05422178f, -0.05697746f, 0.01867944f, 0.03616175f, -0.01554642f, 
    0.01367861f, 0.00028324f, -0.02997301f, 0.03395160f, -0.05268349f, 0.03213575f, 0.00815389f, 0.00500336f, 
    -0.01929748f, 0.03307333f, 0.04045015f, -0.02554499f, -0.04086060f, -0.03340285f, -0.04460296f, 0.00760982f, 
    -0.01514526f, 0.00875206f, 0.01149938f, -0.05790585f, 0.00695872f, -0.03545577f, -0.05691039f, -0.03945978f, 
    -0.01707496f, 0.01676789f, -0.01053940f, -0.00313531f, 0.04568788f, 0.00819447f, -0.04500661f, 0.00491567f, 
    0.03982022f, -0.03939395f, 0.03647451f, 0.02730477f, -0.00457228f, 0.03072439f, -0.01224675f, -0.04492816f, 
    0.03887377f, -0.04760643f, -0.03511999f, 0.01044323f, 0.00829027f, 0.01306986f, 0.03747155f, -0.04144997f, 
    -0.02425668f, -0.03631460f, 0.00845728f, 0.00244622f, 0.01921141f, -0.03166144f, -0.03162682f, -0.05099317f, 
    0.00918818f, -0.02919247f, 0.02812203f, 0.04098812f, -0.03636928f, -0.01393559f, 0.03507318f, -0.01486250f, 
    0.04238375f, 0.01885487f, -0.01568513f, 0.02712784f, 0.03854571f, -0.02574634f, -0.03983212f, 0.01706764f, 
    -0.02124486f, 0.01660507f, -0.01723155f, 0.03409841f, -0.00767174f, 0.00300334f, 0.00792702f, 0.01659889f, 
    -0.00459359f, 0.02716874f, -0.03303214f, -0.00585238f, -0.03159156f, -0.00427652f, 0.00870364f, 0.00302911f, 
    0.03223665f, -0.01754330f, -0.03356726f, -0.02350588f, 0.01419015f, 0.01638814f, -0.04410550f, -0.01313745f, 
    0.01143101f, -0.03282308f, 0.00335775f, -0.05442611f, 0.00055044f, -0.04962517f, -0.04684267f, -0.01003668f, 
    0.00055561f, -0.04710518f, 0.03726443f, -0.05351780f, -0.03281562f, -0.03109601f, 0.03946671f, -0.03721594f, 
    0.03881481f, 0.02434265f, 0.03248246f, 0.01430969f, 0.00546774f, -0.03367007f, -0.05435874f, -0.04995770f, 
    0.01236262f, 0.02806344f, -0.02575511f, 0.01684003f, 0.00648702f, 0.00300636f, -0.03618456f, -0.05494729f, 
    -0.01137675f, 0.01894296f, -0.00383497f, -0.05548478f, -0.01747756f, 0.00385393f, -0.04743176f, -0.03442386f, 
    0.02803811f, -0.00569149f, 0.02694425f, -0.01888113f, 0.02401027f, -0.01670306f, 0.01627087f, -0.01878438f, 
    0.02036823f, -0.02788169f, -0.03089044f, 0.00978478f, -0.05829910f, 0.03849005f, -0.02334731f, 0.03984870f, 
    0.03631278f, 0.04212577f, -0.01420670f, 0.03402461f, -0.04239335f, 0.00170857f, -0.00308678f, 0.02025079f, 
    -0.00529092f, -0.02257871f, -0.00773677f, -0.02447895f, -0.00923939f, -0.03863227f, -0.01526713f, 0.03516419f, 
    0.02685478f, -0.02333393f, 0.03341764f, -0.00043977f, 0.03142881f, 0.03610431f, 0.04286687f, 0.03584661f, 
    -0.02329004f, -0.01395130f, 0.02061860f, -0.04748757f, 0.00326726f, -0.02495219f, 0.00069887f, 0.03519649f, 
    0.01100566f, 0.02327334f, -0.05790252f, -0.00060753f, 0.02495406f, -0.00540891f, 0.04176111f, -0.00640050f, 
    -0.03527867f, -0.03255112f, -0.02504829f, 0.00111579f, -0.04255649f, 0.00426420f, -0.03827728f, 0.00212088f, 
    0.00361057f, 0.01905784f, -0.01340087f, 0.04022667f, 0.02461590f, 0.03894797f, -0.03258412f, -0.01086061f, 
    -0.02952539f, 0.01478743f, 0.01360058f, 0.03599791f, 0.00734153f, 0.04336864f, -0.00926990f, -0.04545311f, 
    -0.03654448f, 0.02143425f, 0.01975531f, 0.01077476f, -0.04925133f, -0.04715005f, -0.02793402f, 0.00991869f, 
    0.03328997f, -0.06340985f, -0.03418216f, -0.05802885f, 0.01564238f, -0.04925150f, -0.00415364f, 0.01033244f, 
    0.02839470f, -0.05507594f, 0.02763287f, -0.05584331f, -0.02769924f, 0.04088299f, -0.05625844f, -0.02890559f, 
    -0.05776840f, -0.03079762f, 0.01781613f, -0.01579689f, -0.04674474f, -0.05073958f, -0.02454877f, -0.02618931f, 
    0.02802059f, -0.02440253f, -0.02888135f, -0.00618846f, 0.01206961f, -0.01732551f, -0.01051100f, 0.00344690f, 
    -0.03894713f, -0.02974240f, 0.03371880f, -0.05374685f, -0.00718583f, 0.03424431f, 0.00125659f, -0.01012797f, 
    -0.03036011f, -0.02791087f, -0.03816302f, 0.00807792f, -0.03237660f, 0.02481689f, 0.02806531f, -0.02551404f, 
    -0.01435728f, -0.05689416f, -0.03453270f, 0.01617805f, -0.03116133f, -0.00518329f, -0.03914068f, 0.02482015f, 
    0.03224212f, -0.04195243f, 0.02265085f, -0.02098277f, -0.00576582f, 0.03976236f, -0.03014180f, -0.01318935f, 
    -0.04200193f, -0.02100178f, 0.01532423f, -0.04839273f, -0.01685424f, -0.03995242f, -0.02261284f, -0.05624333f, 
    -0.01601019f, -0.03077244f, 0.04319805f, 0.03568195f, 0.03535151f, -0.00841711f, 0.04329248f, -0.03606428f, 
    -0.05279271f, -0.00573753f, 0.03046938f, -0.03419984f, -0.01557913f, -0.01949278f, 0.01666791f, 0.02162040f, 
    0.04162589f, 0.01020184f, -0.04905944f, -0.00766201f, 0.03419257f, -0.02373305f, -0.05700787f, -0.04207851f, 
    0.04021711f, -0.03510222f, -0.00682032f, -0.00762087f, 0.03036254f, 0.04214389f, -0.00999881f, 0.00777664f, 
    0.00473090f, -0.04055288f, -0.04707609f, 0.00441185f, -0.05446946f, -0.03709447f, 0.03728591f, 0.01530126f, 
    0.00242481f, -0.05745333f, 0.02949627f, -0.02946150f, -0.00840748f, -0.01487649f, 0.03797407f, 0.00631934f, 
    0.02518700f, -0.05199772f, -0.04036158f, 0.02507864f, -0.05236673f, 0.04033956f, -0.05391974f, -0.01439936f, 
    -0.01383511f, 0.04031943f, 0.02504975f, -0.00291268f, -0.02193924f, 0.03737494f, 0.02176690f, -0.05514003f, 
    -0.01790781f, -0.01739496f, -0.05152443f, -0.01789523f, 0.03436789f, -0.02203011f, 0.03117611f, 0.02908218f, 
    0.02900914f, -0.01681757f, 0.01656476f, -0.01224721f, 0.00197727f, -0.02369010f, -0.05013926f, -0.02594146f, 
    -0.02259600f, -0.03501005f, -0.00044439f, -0.02472644f, 0.00814872f, -0.04861507f, -0.00495506f, -0.03007671f, 
    0.02864043f, -0.02125745f, 0.03369391f, -0.04363354f, 0.01538771f, -0.01199501f, -0.01689715f, -0.02129597f, 
    0.03655206f, 0.04218919f, 0.00290971f, 0.02966292f, 0.01230588f, -0.01542712f, 0.02866560f, -0.00141090f, 
    -0.03266002f, -0.00147059f, -0.01539352f, 0.03433922f, 0.01141392f, 0.01549096f, -0.02775281f, 0.00462664f, 
    0.04252702f, -0.03384507f, -0.05368164f, -0.00920860f, 0.01373674f, -0.01957412f, -0.02910081f, 0.00201328f, 
    0.01064326f, -0.01494616f, -0.03460268f, 0.02934759f, -0.03950472f, -0.03711805f, -0.03439072f, 0.03695421f, 
    -0.03771224f, -0.02181567f, -0.00930229f, -0.03495860f, 0.00193291f, -0.02299195f, -0.04034735f, -0.04170902f, 
    0.00934266f, -0.02215412f, 0.03941795f, -0.00475366f, -0.03026250f, 0.01669377f, 0.00778791f, 0.02035743f, 
    0.02698791f, 0.03641979f, 0.03025080f, -0.03715652f, 0.03388190f, -0.00652453f, 0.03057937f, -0.00206627f, 
    -0.03003648f, -0.04569933f, -0.00599214f, -0.04183447f, -0.04876771f, 0.02335240f, -0.01852230f, 0.02659819f, 
    0.03802741f, 0.02566778f, -0.01651369f, -0.01509821f, -0.02019797f, 0.04043508f, -0.00089653f, -0.04538584f, 
    -0.01684413f, -0.03193929f, 0.00310254f, -0.04480450f, 0.00035323f, -0.00967690f, -0.03076907f, 0.03425149f, 
    -0.00472096f, -0.05446391f, 0.01701615f, -0.03362012f, 0.01697170f, 0.01380333f, 0.01990259f, -0.00757094f, 
    0.02402605f, -0.03515249f, 0.00476506f, 0.02954491f, -0.05106606f, 0.00351445f, -0.04253758f, -0.03032424f, 
    0.01812353f, -0.02575312f, 0.02214913f, -0.03411822f, -0.01006008f, -0.00785049f, 0.01056251f, -0.00913102f, 
    -0.03122934f, 0.01444595f, 0.03680585f, -0.04461508f, -0.03631149f, 0.02189772f, -0.01601426f, 0.01626223f, 
    -0.05258228f, -0.00715566f, 0.01220368f, 0.00553164f, 0.00726655f, 0.02231737f, 0.00990216f, -0.01193386f, 
    0.01828444f, -0.04422110f, -0.05620624f, -0.03402303f, -0.00955198f, -0.03131387f, -0.04616963f, -0.02641899f, 
    -0.01214924f, 0.00378096f, -0.02273809f, -0.00051474f, 0.02307075f, -0.04250032f, -0.03020714f, 0.00956151f, 
    -0.02638659f, 0.01183377f, -0.03112002f, 0.02252245f, 0.00058210f, -0.01244253f, 0.04151314f, -0.03139558f, 
    0.03226908f, -0.02494431f, 0.00471015f, -0.03503402f, 0.02183577f, 0.02380671f, -0.00567957f, 0.03468813f, 
    0.01816084f, -0.05207490f, -0.02064769f, 0.03024589f, 0.01486441f, 0.02672043f, -0.02994637f, 0.00674556f, 
    -0.01802921f, 0.03335471f, -0.00566176f, -0.03064087f, 0.04212081f, 0.03222655f, -0.03769820f, -0.00406249f, 
    0.01978335f, 0.00229499f, -0.05412159f, 0.02099923f, 0.02195844f, -0.04701651f, 0.00618287f, -0.01330210f, 
    0.03453271f, 0.01613585f, 0.04442484f, 0.04330313f, -0.01843377f, -0.04713526f, -0.05517913f, 0.00750561f, 
    -0.00787256f, -0.04240160f, -0.01198713f, 0.01884958f, -0.00609874f, -0.03138523f, 0.01936354f, -0.05217743f, 
    -0.03878937f, -0.00379168f, 0.00955411f, -0.05103351f, -0.05289800f, 0.00596514f, -0.00731112f, -0.01038430f, 
    0.03519557f, 0.03754540f, 0.01174479f, -0.00835815f, -0.02910988f, 0.00484486f, -0.05093919f, 0.00217392f, 
    -0.04753308f, 0.01415483f, 0.04394888f, 0.02248850f, -0.04407234f, -0.04630709f, -0.05366844f, -0.00208494f, 
    0.00625927f, -0.01551794f, 0.00896562f, -0.05001538f, -0.01172121f, 0.02809158f, 0.01432639f, -0.01881342f, 
    0.03719655f, -0.01826876f, -0.04265166f, -0.05043868f, -0.03978963f, -0.00819932f, 0.01493738f, 0.02590197f, 
    -0.01714743f, 0.04063645f, 0.01977321f, -0.04659070f, 0.02225124f, -0.05526745f, 0.03020616f, 0.02123573f, 
    0.01857110f, 0.03471261f, -0.03042871f, 0.02993276f, 0.00178649f, 0.04080202f, -0.01426052f, 0.02997330f, 
    0.01335260f, -0.03724360f, 0.03993435f, 0.03220044f, 0.00848767f, -0.00108335f, -0.03490594f, -0.03246305f, 
    -0.03334760f, -0.00594771f, -0.00616941f, -0.02165544f, -0.02798063f, 0.00513157f, 0.01029930f, -0.04015464f, 
    0.01817606f, -0.03922395f, 0.02231719f, -0.03137117f, 0.01743696f, -0.00306064f, 0.04226257f, -0.00682114f, 
    -0.04105508f, -0.01623790f, 0.02757592f, 0.03495146f, -0.02249771f, 0.01559524f, 0.00421999f, 0.02873555f, 
    -0.04559386f, -0.02004490f, -0.01098183f, -0.02978533f, -0.02333691f, -0.03592673f, -0.03891663f, -0.04883667f, 
    0.01410377f, -0.00414729f, 0.03481872f, 0.03266885f, -0.01068286f, -0.05025433f, -0.02122473f, 0.03050488f, 
    0.02715020f, -0.01430798f, -0.02187089f, -0.01107872f, -0.01421130f, -0.00676155f, -0.04672025f, -0.02501794f, 
    -0.00400414f, -0.04462587f, -0.00787787f, 0.00709275f, 0.00733194f, 0.03364373f, 0.03992286f, -0.00641950f, 
    -0.28919974f, 0.22070378f, 0.01401880f, -0.02560098f, 0.15812384f, 0.04743475f, 0.13912858f, 0.06102351f, 
    0.10543055f, 0.10310832f, 0.02078141f, -0.02711279f, -0.16677599f, 0.09102210f, 0.10818014f, -0.15352073f, 
    0.16003309f, 0.08958296f, 0.02237925f, -0.11648983f, 0.20643966f, 0.08307490f, -0.09226235f, 0.03313797f, 
    0.19134337f, -0.16262095f, -0.33959183f, 0.37899661f, 0.01964628f, 0.05666462f, 0.06823355f, 0.04729128f, 
    -0.00409487f, 0.04519915f, 0.01797063f, -0.07077236f, -0.11321455f, 0.26912716f, -0.10276772f, 0.06878491f, 
    0.03246882f, 0.14011233f, 0.06668858f, -0.00934249f, 0.04818144f, 0.06231641f, 0.04771267f, -0.04834000f, 
    -0.03494395f, -0.29246831f, 0.09048781f, -0.30821308f, 0.15280116f, 0.04600810f, -0.00325913f, -0.09571031f, 
    -0.03121351f, 0.03896989f, 0.03871357f, -0.07286596f, 0.16350606f, -0.02726071f, -0.03062276f, -0.05763480f, 
    0.08297039f, -0.01621206f, -0.01715782f, 0.09491292f, 0.03660259f, 0.11903253f, 0.07314003f, 0.17725007f, 
    0.08071655f, -0.31805223f, 0.11780453f, -0.17502995f, 0.03820711f, -0.03854747f, -0.08482943f, -0.06831785f, 
    0.15211868f, 0.03927248f, 0.11494961f, 0.09379247f, 0.07734438f, -0.25088724f, 0.06867440f, 0.24200204f, 
    -0.00069959f, 0.13956885f, 0.09186573f, 0.18782185f, 0.00015996f, -0.23852906f, -0.01561102f, 0.07217788f, 
    0.29095429f, -0.11461879f, -0.14938387f, -0.05128847f, -0.19532067f, 0.07751253f, -0.05387522f, -0.00376392f, 
    0.05254674f, -0.01137726f, 0.03291330f, -0.00115123f, -0.07742095f, 0.21046062f, -0.01398942f, -0.17041291f, 
    -0.02289357f, -0.12245642f, -0.08328458f, 0.04692663f, -0.05179286f, -0.09738296f, -0.01504084f, -0.00099901f, 
    0.13365325f, -0.02168612f, -0.23698442f, 0.10114212f, 0.17024399f, -0.11604615f, 0.01434926f, -0.12755810f, 
    0.02741043f, 0.14223817f, 0.18263981f, 0.01146783f, -0.25906664f, 0.10056391f, 0.10591755f, 0.18263058f, 
    -0.08272738f, -0.13059573f, 0.15047415f, 0.05252577f, 0.06165363f, 0.02610454f, 0.06254996f, -0.01721842f, 
    0.06657786f, -0.24367855f, -0.03819001f, 0.24791260f, 0.07375167f, 0.05475274f, 0.05527864f, -0.02241142f, 
    0.09062423f, -0.00561554f, 0.05790025f, -0.02441180f, 0.13209642f, -0.12821236f, 0.08461506f, 0.11172690f, 
    -0.02934333f, 0.03878104f, 0.07303673f, -0.09952449f, -0.10344310f, -0.07411277f, -0.02850774f, -0.04593654f, 
    0.32670295f, -0.18542095f, -0.07830068f, 0.14323151f, -0.24200369f, -0.13669758f, 0.01549343f, 0.12596719f, 
    -0.06579643f, 0.04915638f, -0.00019235f, 0.06782295f, -0.54558188f, -0.00033039f, 0.05613855f, -0.11088604f, 
    0.22974464f, -0.03964334f, -0.11424651f, 0.05584606f, 0.04490627f, 0.04931019f, 0.01963755f, -0.13978672f, 
    0.12363762f, 0.14997195f, -0.14466670f, -0.10678367f, -0.03132700f, -0.09667348f, -0.02225135f, -0.01844012f, 
    0.18282069f, -0.13586220f, 0.00038755f, 0.08342617f, -0.06122819f, -0.05165454f, -0.27483582f, 0.01853762f, 
    0.17451338f, 0.09663486f, -0.06650919f, 0.05963739f, 0.01092286f, 0.04478508f, 0.02138547f, -0.09675705f, 
    -0.12192849f, -0.07608660f, 0.02679484f, -0.14631744f, 0.05197413f, -0.05324263f, -0.01494158f, 0.07650335f, 
    -0.11596503f, 0.03576883f, -0.11159319f, 0.12956911f, 0.24187182f, -0.00146669f, -0.06078612f, -0.16613491f, 
    0.04327476f, -0.02481090f, 0.03559680f, 0.03982018f, 0.04632670f, -0.02755763f, -0.08652318f, 0.10523888f, 
    0.12970407f, 0.07162315f, -0.12635775f, 0.21785015f, -0.19573350f, 0.00639636f, -0.19840166f, 0.06517772f, 
    -0.09846023f, 0.15248232f, -0.07232029f, 0.04716123f, 0.42624030f, -0.24403560f, 0.00175196f, 0.07743146f, 
    0.00585527f, 0.12762387f, 0.14931470f, 0.22330444f, 0.07149573f, -0.11800378f, -0.09347060f, 0.17928861f, 
    -0.09155621f, 0.02475236f, -0.10128382f, -0.12294688f, 0.05880492f, 0.09852623f, 0.14768806f, 0.00052482f, 
    0.01741468f, -0.06471219f, 0.13548675f, 0.05095377f, 0.08990608f, -0.14006980f, -0.12688172f, -0.29025781f, 
    -0.04032205f, -0.00527874f, -0.09295511f, 0.13334243f, -0.03044334f, 0.13171375f, 0.04781152f, 0.02883103f, 
    0.01603233f, -0.01203139f, -0.21058153f, 0.21460766f, 0.14457671f, 0.11456682f, 0.10192077f, -0.03750758f, 
    0.07994222f, 0.02689213f, 0.02982217f, -0.01993584f, 0.01172138f, -0.09933729f, -0.19680516f, 0.17758401f, 
    0.13383369f, 0.00855227f, -0.06316791f, 0.11651009f, 0.03105894f, -0.08208728f, -0.06349235f, -0.23488878f, 
    0.11610892f, 0.04803738f, 0.03607335f, 0.01359543f, 0.17884263f, 0.00526902f, -0.10826591f, 0.01097037f, 
    0.17098588f, -0.01430659f, 0.05977872f, -0.04197805f, 0.26029477f, 0.18459575f, 0.13207692f, 0.03510142f, 
    0.05018851f, 0.02757820f, 0.17223056f, 0.14401689f, -0.07808707f, 0.00089175f, 0.01090642f, -0.13087948f, 
    0.11863679f, 0.26574275f, 0.00429886f, 0.01510546f, -0.08110456f, 0.03680860f, -0.03361614f, 0.09161432f, 
    -0.03573225f, -0.03600607f, -0.01619747f, -0.10277563f, 0.02580427f, -0.11274951f, -0.22367518f, 0.12027746f, 
    -0.09849654f, -0.15679589f, 0.04534383f, 0.01385619f, -0.06380714f, -0.06585601f, -0.09984373f, -0.03332334f, 
    -0.33677617f, -0.34875956f, 0.00109645f, 0.23375744f, 0.07796294f, 0.02079056f, 0.19549394f, 0.06293794f, 
    -0.00558096f, 0.11850023f, -0.07282495f, 0.12821406f, 0.33597252f, 0.18471928f, 0.13898431f, 0.12761690f, 
    -0.07837260f, -0.16403708f, -0.00087694f, -0.04733522f, 0.07692313f, -0.03757800f, 0.13103947f, -0.00252769f, 
    0.02147865f, -0.05813044f, -0.00443751f, 0.03275429f, -0.00879428f, 0.00285578f, 0.01465613f, -0.00075630f, 
    -0.03788444f, -0.04452749f, -0.04563570f, 0.00377127f, 0.00476757f, 0.04003286f, 0.01634090f, 0.03615158f, 
    -0.02318690f, -0.01790516f, -0.04383659f, -0.04798765f, 0.03955910f, 0.02928984f, -0.05270753f, -0.02724072f, 
    -0.01788208f, 0.03377452f, -0.03852792f, -0.02491067f, 0.02841499f, -0.01398944f, -0.02900841f, -0.01292824f, 
    0.01466009f, 0.01365377f, 0.00850363f, -0.04124220f, -0.00070055f, -0.01684736f, -0.01667586f, -0.04872477f, 
    -0.03362114f, 0.02914957f, -0.01081853f, 0.00645688f, -0.04722430f, -0.00015968f, -0.02791882f, -0.04172818f, 
    -0.04727880f, -0.05582459f, -0.03277638f, -0.01786899f, -0.01258544f, -0.01033347f, -0.00581906f, 0.03798221f, 
    0.00924621f, -0.01399801f, -0.03869306f, -0.02302142f, 0.03607507f, 0.03534621f, 0.01985766f, 0.03607671f, 
    -0.02903218f, -0.03147002f, 0.00054197f, -0.03250392f, -0.04653962f, 0.02543914f, -0.03319697f, 0.04750230f, 
    -0.04589410f, -0.03878638f, 0.00839516f, 0.01688761f, 0.03386418f, -0.03689008f, 0.00628371f, -0.03597458f, 
    -0.04860599f, 0.02122801f, 0.02629422f, -0.04587154f, 0.03468708f, 0.00647172f, -0.05528005f, -0.03244082f, 
    -0.02107089f, -0.05424581f, -0.00005511f, -0.02982061f, -0.03970374f, -0.00338463f, -0.02483160f, 0.02721826f, 
    0.02922883f, 0.01375351f, -0.04552721f, -0.02181673f, 0.01115865f, -0.05386421f, 0.03953768f, 0.02065062f, 
    -0.01181463f, 0.01042259f, 0.03068434f, -0.00142976f, 0.03045216f, 0.03220228f, -0.00121810f, 0.04504851f, 
    -0.00022634f, -0.02579889f, -0.03862406f, 0.04050209f, -0.02994804f, -0.01314746f, -0.01973421f, -0.03528677f, 
    0.01608157f, -0.04181008f, -0.04836605f, -0.01060105f, 0.03034839f, -0.01379050f, -0.02285357f, 0.00104623f, 
    -0.03940801f, 0.04506991f, 0.04468381f, 0.03797384f, 0.01256308f, -0.04359724f, -0.03848131f, -0.05238707f, 
    0.01955950f, 0.01977501f, 0.01435391f, -0.03009929f, 0.00081183f, 0.01761341f, 0.04040481f, -0.00681526f, 
    -0.01467201f, -0.03264293f, 0.00198927f, -0.03843958f, -0.05325354f, -0.04503205f, -0.05949421f, -0.02475172f, 
    -0.04599399f, -0.01326227f, 0.02524832f, 0.04112750f, 0.00636790f, -0.04090154f, -0.04829343f, 0.04750111f, 
    -0.03333677f, -0.00894485f, 0.00655347f, 0.00893453f, -0.05371998f, -0.02245361f, -0.00615099f, 0.02815300f, 
    -0.00809849f, -0.03014831f, 0.02480934f, -0.01141970f, -0.02435706f, -0.05339067f, 0.02065343f, -0.01514373f, 
    -0.02484144f, -0.00586768f, 0.04833117f, 0.03744156f, 0.01040309f, 0.03197014f, -0.02503547f, 0.02740989f, 
    -0.00294267f, -0.04784966f, 0.03270539f, 0.03270485f, -0.02446180f, 0.00230295f, -0.03251973f, -0.04818993f, 
    0.02406918f, 0.01395836f, 0.00977762f, 0.02006137f, -0.05617873f, -0.03326083f, -0.01321550f, -0.02614787f, 
    0.03945442f, 0.01291660f, -0.00180216f, -0.00582463f, 0.01284047f, -0.04356737f, 0.01833219f, 0.01885391f, 
    0.01182735f, -0.00751159f, -0.01339145f, 0.02073116f, 0.01495421f, 0.01584786f, 0.04072652f, 0.01586432f, 
    0.04112826f, -0.05551252f, 0.01560173f, 0.01280099f, -0.03659504f, -0.01492002f, -0.00099989f, 0.03798166f, 
    -0.03683317f, -0.00206726f, 0.00840461f, 0.00041385f, -0.00154149f, -0.05192214f, -0.03325291f, -0.03986588f, 
    -0.05301564f, -0.03103570f, -0.03235348f, -0.02288105f, 0.01044151f, 0.00171469f, -0.05621216f, 0.03820686f, 
    -0.05987538f, -0.04657348f, 0.03091955f, 0.04733361f, -0.04099058f, -0.01579707f, -0.03327540f, 0.02261712f, 
    0.03583179f, -0.03642442f, 0.03986951f, -0.03308806f, -0.01593315f, -0.03456520f, -0.05011439f, 0.04165546f, 
    0.03106989f, -0.01232386f, -0.04521720f, -0.04638594f, 0.01445901f, 0.03711587f, 0.02629740f, -0.02574008f, 
    0.02965420f, -0.03803441f, -0.02990172f, -0.02347104f, 0.00146912f, -0.02131357f, -0.03335615f, -0.03297198f, 
    0.00806229f, -0.00976484f, 0.04366030f, 0.02437370f, 0.00765503f, -0.04799824f, -0.02041752f, 0.01330186f, 
    -0.00145326f, -0.01517188f, -0.01820643f, 0.01277887f, -0.02056079f, 0.02886328f, 0.04174018f, 0.01047899f, 
    -0.04402656f, -0.04886434f, 0.03344003f, 0.01590811f, -0.00629673f, -0.00407697f, -0.03260551f, -0.01035407f, 
    -0.02907803f, 0.02321132f, 0.02324581f, 0.02611881f, 0.04364654f, -0.05921313f, -0.00298404f, 0.03525449f, 
    -0.01124301f, 0.04638303f, -0.00830214f, -0.02898139f, 0.03808573f, 0.02639500f, -0.00510938f, -0.04525173f, 
    0.01268349f, -0.04041483f, 0.00320239f, -0.04604701f, -0.04131490f, -0.02566669f, 0.02427040f, -0.00361068f, 
    -0.05597349f, 0.00050028f, 0.02371782f, 0.04932287f, -0.02528133f, -0.01157366f, 0.01957336f, -0.04556463f, 
    -0.03732523f, 0.00397712f, -0.00129324f, 0.03933647f, 0.00066585f, 0.04041833f, 0.02487833f, 0.02957938f, 
    -0.02167178f, -0.03550432f, -0.01869109f, -0.04133443f, 0.03959657f, 0.00656589f, -0.00403087f, -0.03968832f, 
    -0.01048758f, -0.04695305f, 0.03509232f, -0.01302262f, 0.04301079f, 0.01254919f, -0.04744825f, -0.00989840f, 
    -0.04985063f, -0.01200045f, -0.01790308f, -0.02873767f, -0.02027815f, -0.02244939f, -0.02397953f, 0.03772921f, 
    -0.02077860f, -0.00859385f, -0.01992525f, -0.04346116f, -0.00991631f, -0.03333332f, -0.03908393f, 0.01665343f, 
    -0.03146094f, 0.03543986f, -0.01273344f, -0.00138094f, -0.01378269f, 0.00151461f, -0.02421944f, 0.03475294f, 
    0.00852911f, -0.00728652f, 0.01077159f, 0.03424573f, 0.01918106f, 0.02769291f, 0.00969170f, -0.01418986f, 
    0.01447516f, -0.24852362f, 0.09378669f, 0.21736042f, 0.15515767f, 0.02128329f, 0.03608341f, -0.00490325f, 
    -0.03451861f, -0.03579528f, -0.04527656f, 0.08773506f, -0.04501100f, 0.06498261f, 0.00184514f, 0.05556804f, 
    0.03772303f, -0.03421635f, 0.03011529f, 0.07289353f, 0.04680339f, -0.03775264f, 0.06380339f, 0.03786217f, 
    -0.08968277f, -0.04885295f, 0.33234614f, -0.40438160f, 0.00800692f, 0.03992261f, 0.00332781f, 0.17741168f, 
    0.08880458f, -0.00594813f, -0.01933796f, 0.04296922f, 0.36408737f, -0.23977104f, -0.00954444f, -0.19049595f, 
    -0.07514398f, 0.07645608f, 0.04400354f, 0.07682906f, 0.02199212f, 0.13836931f, 0.08492818f, 0.05288985f, 
    -0.05078983f, 0.16135690f, -0.20554149f, 0.27562165f, 0.02574671f, 0.03461398f, 0.06102982f, 0.03333536f, 
    0.00814243f, 0.07350210f, 0.04759117f, 0.11297178f, -0.14258346f, 0.09242816f, -0.03427486f, -0.01977950f, 
    0.11253589f, 0.12955248f, 0.05637518f, -0.10463938f, 0.04274854f, 0.09960207f, -0.00568480f, 0.10614397f, 
    0.42435870f, 0.31644812f, -0.09155910f, 0.44447419f, -0.03202765f, -0.00016808f, -0.03156132f, 0.10914543f, 
    0.02380251f, 0.04617477f, 0.00585493f, 0.12814394f, 0.38161135f, 0.12002992f, -0.07273007f, -0.04009295f, 
    -0.02091392f, -0.06787951f, -0.12813513f, -0.04931581f, -0.02456400f, 0.25250170f, -0.15190047f, -0.01664690f, 
    -0.22275652f, 0.17695639f, 0.13079958f, 0.01769729f, 0.16741429f, 0.04586722f, 0.05841238f, -0.01191876f, 
    0.06034263f, 0.00969321f, 0.14447503f, -0.02226181f, 0.33731201f, -0.22869717f, 0.03463745f, -0.14062479f, 
    -0.12415466f, 0.14932372f, 0.23266870f, 0.09266920f, 0.00899656f, 0.10774127f, 0.09971821f, -0.05221619f, 
    -0.12782824f, 0.03366268f, 0.08263181f, -0.27281755f, -0.07439551f, 0.07028507f, -0.02836608f, 0.16513376f, 
    0.04407603f, 0.13717507f, 0.00440736f, -0.03232694f, 0.04412547f, 0.08961467f, -0.04729007f, -0.30324209f, 
    0.07653634f, 0.05810817f, 0.11336186f, 0.19960880f, 0.00205546f, -0.04171218f, -0.01663104f, 0.05274054f, 
    0.02611906f, 0.11808980f, 0.31856066f, -0.17815831f, 0.00872397f, 0.01765768f, 0.05497002f, 0.19148842f, 
    -0.09150492f, 0.05169131f, 0.07494487f, 0.12342175f, 0.18536218f, 0.01595889f, -0.04555188f, -0.09187662f, 
    0.15084626f, 0.00445724f, -0.01158282f, 0.05095898f, 0.05235048f, 0.05882246f, -0.00318229f, 0.19599135f, 
    0.40004164f, 0.11915027f, -0.00726934f, 0.05038057f, 0.08740842f, 0.05876141f, 0.04995336f, 0.15967305f, 
    0.08353488f, 0.07429736f, 0.08634897f, -0.01201236f, 0.49704272f, -0.09819299f, -0.03225757f, 0.09280797f, 
    0.03638155f, -0.03694260f, 0.16197130f, 0.09510182f, 0.14661816f, -0.02802290f, 0.04282667f, 0.14094475f, 
    0.24201748f, 0.16698919f, -0.08447354f, 0.01291781f, 0.02341453f, 0.02961891f, 0.18452299f, -0.06226465f, 
    -0.05333229f, 0.05760238f, -0.09707480f, -0.03035900f, 0.32722893f, 0.11362521f, 0.23274238f, -0.37683174f, 
    0.06873937f, 0.11540743f, 0.17567933f, -0.02335066f, 0.05057937f, 0.09101821f, 0.10782035f, 0.05816096f, 
    -0.00801649f, -0.11197678f, -0.13472334f, 0.22623293f, 0.02456317f, 0.05249118f, 0.05106526f, -0.00449023f, 
    0.14165752f, -0.05388201f, 0.06050348f, -0.02759626f, -0.34095490f, 0.14674649f, -0.00646089f, 0.24017704f, 
    0.05057290f, -0.09520420f, -0.03337269f, -0.13481729f, -0.12294024f, -0.06082761f, 0.09912535f, -0.03076752f, 
    -0.11702106f, -0.01781712f, 0.04870707f, -0.33447802f, 0.05120372f, 0.02329857f, 0.09644420f, 0.06892363f, 
    0.16105875f, -0.08629671f, 0.12389617f, -0.02300047f, 0.03800643f, 0.46164003f, -0.14088942f, 0.32989430f, 
    0.19441068f, -0.06026413f, 0.07175476f, -0.04075117f, -0.03236422f, 0.08729750f, 0.04439073f, -0.08399829f, 
    -0.01500158f, -0.06664227f, -0.03538603f, 0.08165950f, 0.10023403f, -0.04469595f, -0.06099111f, 0.01061253f, 
    0.05373729f, 0.12771381f, 0.01188381f, 0.10539754f, 0.22322242f, 0.16532505f, -0.02141320f, 0.22885528f, 
    0.14184482f, 0.00032611f, 0.02112033f, -0.00318694f, -0.04144881f, -0.02269910f, 0.13649732f, 0.01496357f, 
    -0.12193357f, -0.05054678f, 0.29066738f, -0.11869506f, 0.01542160f, 0.20922065f, 0.01296787f, 0.18749753f, 
    0.05871291f, -0.00983561f, 0.04399020f, 0.12866445f, 0.01116763f, -0.03985722f, 0.26573297f, -0.11578361f, 
    0.09152839f, 0.17146811f, 0.04904158f, 0.00454108f, 0.01189682f, 0.08635566f, 0.12513191f, 0.15780692f, 
    -0.27130225f, 0.10752691f, -0.09806937f, -0.11035227f, 0.02301643f, -0.01495781f, 0.03422819f, 0.04608020f, 
    -0.06739573f, 0.06408606f, 0.06128127f, -0.04677733f, -0.10443221f, -0.15217617f, -0.04373676f, 0.32024470f, 
    -0.06742595f, 0.04607471f, -0.04282852f, -0.03616395f, 0.07373737f, 0.10630652f, 0.10788222f, 0.16390780f, 
    0.11323261f, 0.11806487f, -0.00014524f, -0.06094119f, 0.04027410f, 0.01270594f, 0.15755922f, 0.09767814f, 
    0.11394770f, 0.13420130f, -0.11899247f, -0.00949546f, -0.07105127f, -0.11158804f, 0.19163167f, -0.04790488f, 
    -0.02219865f, 0.12382261f, 0.04700320f, -0.01809753f, -0.04617308f, 0.04065599f, -0.15796475f, 0.03856955f, 
    0.10780077f, -0.05462382f, 0.11545506f, -0.20679833f, -0.08866204f, 0.09856947f, -0.08128240f, 0.09752589f, 
    0.12503070f, -0.00727471f, 0.08069538f, -0.05055735f, 0.28158334f, -0.19188596f, -0.03807562f, -0.16454630f, 
    0.01213077f, 0.03166259f, 0.03355887f, 0.02329572f, -0.11948490f, -0.00403324f, -0.05510367f, -0.00161345f, 
    0.20816822f, 0.21172813f, -0.05814595f, -0.15613295f, -0.06492270f, 0.05738389f, -0.09489239f, 0.01555702f, 
    0.09394324f, 0.05557794f, 0.09070128f, -0.03091211f, 0.20139426f, 0.04661486f, -0.04178643f, -0.08063385f, 
    -0.06214966f, -0.11194545f, -0.05014941f, 0.03925294f, 0.13430630f, 0.09948507f, -0.05728222f, 0.03585942f, 
    0.30695054f, -0.21094975f, -0.00251418f, 0.16307779f, 0.03475786f, 0.08581928f, -0.05480568f, -0.06558082f, 
    0.02773268f, -0.11579784f, -0.09192333f, 0.07987383f, -0.10205418f, -0.12112008f, 0.07983455f, 0.22219004f, 
    0.03438319f, 0.04111222f, 0.07940905f, -0.05051622f, -0.10705413f, -0.04679297f, -0.04844174f, -0.09077456f, 
    0.20856011f, 0.28290063f, 0.02645470f, -0.01183135f, 0.14267966f, -0.05302946f, 0.06033407f, 0.05782583f, 
    0.08311526f, 0.11952266f, 0.05453007f, -0.04947034f, -0.09413683f, -0.07706857f, 0.05335386f, -0.08862548f, 
    -0.01590697f, -0.09255952f, 0.00626082f, 0.07067678f, 0.08358424f, -0.00644726f, 0.03278582f, 0.17624862f, 
    -0.33618876f, -0.11274280f, 0.08931115f, -0.12060469f, 0.24720339f, 0.10599150f, -0.07151253f, 0.09242442f, 
    -0.08348243f, -0.12060373f, 0.10449716f, 0.07561606f, -0.31759638f, 0.08844115f, -0.01179102f, -0.02405672f, 
    0.02785032f, 0.04765053f, 0.07558919f, 0.07008768f, 0.06759127f, -0.01419732f, 0.12921584f, 0.11613437f, 
    -0.02590183f, -0.16506325f, 0.11684891f, 0.00457946f, 0.07524236f, -0.05671892f, -0.07475659f, 0.06623203f, 
    -0.03329242f, 0.12672238f, 0.02495359f, -0.01604727f, 0.17091323f, 0.07634491f, -0.08594041f, 0.09756880f, 
    -0.04521389f, -0.08284909f, -0.06580920f, -0.09719592f, 0.08743095f, -0.20296933f, -0.07140449f, -0.13530810f, 
    0.16665088f, 0.21796614f, 0.05244166f, 0.01292793f, 0.05546984f, 0.00377770f, -0.00294407f, 0.08401075f, 
    0.03794083f, -0.11649604f, 0.09328978f, -0.13998955f, 0.08898478f, -0.07579395f, -0.08416433f, 0.20135303f, 
    -0.09689952f, 0.13168427f, -0.02092970f, -0.02422819f, 0.10300210f, 0.06956248f, 0.14447042f, -0.03319179f, 
    -0.30629736f, 0.02870112f, 0.03231054f, 0.10379878f, 0.17834203f, 0.05186403f, -0.00483185f, -0.13520271f, 
    0.16809177f, 0.06474783f, -0.09296887f, -0.05135276f, 0.02466717f, -0.15031691f, 0.08805311f, 0.16972855f, 
    -0.06260224f, 0.04187878f, -0.00677483f, 0.10995110f, -0.11602528f, -0.15154539f, -0.02586441f, -0.10065284f, 
    -0.55016863f, -0.01898015f, 0.08068737f, -0.01068028f, 0.11460855f, -0.00179557f, -0.03956170f, -0.02454528f, 
    0.02788473f, -0.00154497f, 0.02840528f, 0.04453602f, 0.01293439f, 0.04938452f, 0.12947801f, 0.01363417f, 
    0.08850515f, 0.15163894f, -0.12158022f, 0.06743994f, -0.02061936f, -0.04409070f, 0.05603303f, 0.02799510f, 
    -0.42616171f, -0.31176168f, -0.12470036f, 0.08165084f, -0.08407936f, 0.13402231f, 0.00684979f, 0.16682343f, 
    0.13353282f, -0.11114812f, -0.07653679f, 0.06610011f, -0.09155044f, -0.00623445f, -0.03664258f, 0.22572665f, 
    -0.09968865f, -0.04867127f, -0.06170465f, -0.05550097f, -0.03030451f, -0.07233865f, -0.02207690f, 0.09844913f, 
    -0.07048651f, 0.06108160f, 0.01225448f, -0.13044760f, 0.07052086f, -0.04724190f, 0.09117773f, 0.09423675f, 
    0.06815684f, 0.18098903f, -0.03245470f, 0.11268885f, 0.24958339f, 0.07349979f, 0.07173383f, -0.07050695f, 
    -0.06030239f, -0.04715551f, 0.06332127f, 0.06362092f, 0.07346686f, -0.06510904f, -0.03045051f, 0.15457690f, 
    0.46914813f, -0.25556472f, 0.02304601f, 0.05417744f, -0.04623079f, 0.15997872f, -0.05078181f, -0.00032249f, 
    -0.07144506f, 0.05135656f, -0.05952831f, 0.05408930f, -0.22542493f, 0.05070887f, 0.23563379f, 0.19354323f, 
    -0.11981475f, 0.02387680f, 0.14147727f, 0.06633418f, 0.07714897f, 0.04154865f, 0.18747416f, 0.07886745f, 
    -0.12195876f, 0.28670073f, 0.03892054f, -0.00085560f, -0.04767378f, 0.06221098f, 0.06296932f, 0.10617021f, 
    0.07868781f, 0.08426225f, -0.13432103f, 0.08195072f, 0.20322996f, 0.02638208f, 0.04139795f, -0.19261135f, 
    0.02909805f, -0.02278027f, 0.05334868f, -0.05490519f, -0.12126353f, 0.08945854f, 0.04739685f, 0.03503226f, 
    -0.04966811f, 0.35366154f, -0.06626684f, 0.19849570f, -0.08561806f, -0.06748947f, -0.08112311f, 0.04793457f, 
    0.09086896f, -0.01570815f, 0.10654692f, -0.00354842f, 0.14675842f, 0.10943230f, -0.00228355f, 0.15164889f, 
    0.07498809f, 0.09069280f, -0.01199323f, -0.06798226f, -0.09595179f, 0.01295672f, 0.03640217f, -0.03273779f, 
    0.29096222f, 0.11334179f, -0.12057015f, -0.16737364f, -0.05500438f, -0.00706726f, -0.09696722f, 0.01252377f, 
    0.11138098f, -0.09309300f, -0.09712411f, -0.01248794f, -0.60196972f, 0.26064771f, -0.27482879f, -0.12280033f, 
    0.23286693f, -0.09480709f, 0.05497797f, 0.02065805f, 0.00905769f, 0.09560406f, -0.02515603f, -0.09482154f, 
    -0.24459215f, -0.07652561f, -0.05800978f, 0.05239044f, -0.03047778f, -0.05013309f, -0.03929249f, 0.03045861f, 
    0.05894241f, 0.10001960f, -0.01105242f, -0.02690009f, 0.11147812f, 0.04729744f, -0.06690200f, 0.02986733f, 
    -0.03878213f, -0.11260622f, 0.07776735f, -0.06236554f, 0.10195480f, -0.02329029f, 0.05441214f, 0.08152833f, 
    0.28042191f, -0.08503740f, 0.12366201f, 0.11011822f, -0.02043282f, 0.09128176f, 0.13951187f, 0.08558942f, 
    -0.03488808f, 0.16942340f, 0.01968526f, 0.13531166f, -0.51597935f, 0.23353615f, -0.12760633f, -0.03334556f, 
    0.07464679f, -0.02388723f, 0.03679948f, -0.06699048f, 0.01115576f, 0.02707199f, -0.00693435f, -0.10186113f, 
    -0.03609637f, -0.08022551f, 0.14195810f, -0.00039817f, -0.05393902f, -0.10870410f, 0.01213169f, -0.01848641f, 
    0.05972617f, 0.04728959f, 0.08723430f, -0.04720212f, -0.28687692f, -0.29359534f, -0.21456444f, -0.00317984f, 
    0.08678158f, -0.04468022f, -0.12093749f, -0.07047933f, -0.07407725f, 0.04482428f, 0.01869348f, -0.12108026f, 
    -0.07521611f, 0.41551000f, -0.11355826f, -0.06487446f, 0.07040834f, -0.09158388f, 0.01166882f, -0.11660945f, 
    -0.01601933f, 0.14071722f, 0.20998012f, 0.01962502f, 0.21742623f, 0.39544764f, 0.09594399f, 0.12137137f, 
    -0.12644318f, -0.02395447f, 0.03087159f, -0.06747967f, 0.13602175f, -0.03879680f, 0.03602814f, -0.03764343f, 
    0.25700715f, 0.21737996f, 0.27610207f, 0.13966697f, 0.02575086f, 0.05955085f, -0.08631419f, -0.01316947f, 
    0.05278387f, -0.00300874f, 0.09623202f, -0.01481215f, 0.36332017f, 0.18758990f, 0.17836864f, 0.31415668f, 
    -0.02224674f, -0.13703498f, -0.03089468f, -0.00065046f, -0.01282361f, -0.11086516f, -0.08827562f, -0.33809814f, 
    -0.35200301f, 0.03996596f, -0.11555988f, -0.23703849f, -0.06544405f, 0.06513824f, 0.06321970f, -0.10377513f, 
    -0.02040867f, 0.09587009f, -0.06367362f, -0.22448373f, 0.41200176f, 0.16754465f, 0.12144493f, 0.05731454f, 
    -0.00057416f, 0.00540344f, 0.01615815f, 0.00356011f, 0.06376673f, -0.12916565f, 0.13909195f, -0.03700594f, 
    0.00394837f, 0.08226927f, -0.07828226f, -0.35167053f, -0.00495872f, -0.06373545f, 0.16312559f, -0.06567204f, 
    0.00846400f, -0.01043101f, -0.07400134f, 0.07273914f, -0.29800862f, 0.06250633f, -0.08780865f, 0.24033725f, 
    0.01217058f, -0.01388523f, -0.02556833f, 0.05433071f, 0.01445170f, 0.04397805f, 0.06779065f, 0.09682695f, 
    0.25408676f, 0.09568978f, 0.15828742f, 0.36740905f, 0.05827601f, -0.08560119f, -0.02433149f, -0.14345081f, 
    -0.04991247f, -0.11898012f, -0.05963460f, 0.24643900f, 0.32838801f, 0.02863462f, 0.13257456f, 0.21350664f, 
    -0.02545928f, -0.04852140f, -0.22849241f, -0.05763577f, -0.05151972f, -0.13081941f, -0.02065296f, 0.02018041f, 
    0.20750275f, 0.26326507f, -0.01781233f, -0.15863787f, -0.08472437f, 0.07785492f, 0.00192068f, -0.09524973f, 
    0.05493176f, -0.06692024f, -0.00569055f, -0.00157472f, 0.14089523f, 0.18059090f, -0.01781200f, 0.03719577f, 
    -0.14790031f, -0.01645691f, -0.02247328f, -0.09178469f, 0.21023662f, 0.10013485f, 0.05175092f, 0.02269927f, 
    -0.09065133f, 0.32792664f, 0.31483951f, 0.23420660f, -0.06876892f, -0.11837615f, -0.10112371f, 0.05535429f, 
    0.03883072f, -0.01290049f, -0.02126501f, -0.07482357f, -0.21890855f, 0.17137678f, -0.05460904f, -0.24668333f, 
    -0.02727183f, 0.10013083f, 0.08271619f, -0.22434014f, 0.05715739f, 0.09838810f, 0.04770085f, 0.03510923f, 
    -0.32413921f, -0.28741211f, 0.05464985f, -0.07967971f, 0.02975989f, -0.09218775f, 0.01259330f, 0.07538071f, 
    0.04135547f, 0.13908403f, 0.19233677f, 0.06314517f, -0.60953879f, -0.12701157f, -0.12271117f, -0.16706337f, 
    -0.04597705f, -0.10731788f, -0.08023503f, 0.09717035f, 0.03434772f, -0.14929329f, -0.03237506f, -0.17057179f, 
    0.33532417f, 0.21523209f, 0.06338063f, 0.33244675f, 0.08583677f, -0.10213678f, -0.08494637f, 0.04453040f, 
    -0.03979900f, 0.07761031f, 0.14751245f, -0.02798715f, 0.20757112f, 0.01234711f, -0.05603089f, 0.29094589f, 
    -0.05266465f, -0.02419366f, -0.04302998f, 0.05773557f, 0.17532066f, 0.18123917f, 0.11207055f, 0.08187705f, 
    0.30620313f, 0.29549491f, 0.19436142f, 0.21284035f, 0.02389869f, -0.09942391f, 0.08309212f, 0.02537917f, 
    0.02726663f, -0.01582067f, 0.02916219f, 0.00353236f, -0.13532853f, -0.25229520f, 0.01020612f, -0.29682943f, 
    -0.16524370f, 0.02800047f, -0.11204080f, -0.03690108f, 0.00598166f, 0.00488898f, 0.05032584f, 0.01957830f, 
    0.24220137f, 0.04206455f, 0.15651023f, 0.28685468f, 0.09138764f, 0.01527293f, -0.00605698f, -0.06495718f, 
    0.05290283f, -0.00983683f, -0.04854536f, -0.02304114f, -0.21010554f, 0.22077174f, 0.18571712f, 0.19378331f, 
    -0.11845737f, 0.01963419f, 0.03695264f, -0.12431056f, 0.10503969f, -0.12225470f, 0.02377601f, -0.02669621f, 
    -0.16874777f, -0.40511844f, -0.32885811f, -0.37716159f, -0.00344913f, -0.03828495f, 0.06673121f, -0.17180631f, 
    -0.10735360f, 0.02434738f, -0.01640271f, -0.06981687f, 0.24570212f, 0.24887413f, -0.19355763f, -0.16515315f, 
    -0.09782542f, -0.12159637f, -0.00853913f, 0.06747493f, 0.02635747f, -0.01128726f, 0.04888640f, 0.14035489f, 
    0.01782018f, -0.08990093f, 0.19068983f, 0.39497146f, 0.00792944f, 0.08675312f, 0.02147100f, 0.01742292f, 
    -0.07804898f, 0.09443764f, -0.00238196f, 0.17886251f, 0.13931869f, -0.15364267f, -0.01505873f, -0.05846969f, 
    -0.13473780f, 0.00760185f, -0.04652143f, 0.01791930f, 0.09869857f, 0.00664048f, 0.03779330f, 0.11386897f, 
    -0.20593306f, -0.23368198f, -0.05081002f, 0.01261861f, -0.01953200f, -0.07818823f, -0.04145968f, -0.16252045f, 
    -0.02730442f, -0.09265275f, 0.15588522f, 0.05864885f, -0.25081474f, -0.01638716f, -0.08917853f, -0.11136619f, 
    0.03037372f, -0.01324380f, -0.13304819f, 0.00287923f, 0.08273292f, -0.00392981f, 0.19035682f, -0.00634492f, 
    0.18323010f, 0.31419563f, -0.05620492f, 0.00139922f, 0.17276552f, -0.22114505f, -0.01967281f, -0.06724210f, 
    -0.07398318f, -0.09427935f, -0.05033778f, -0.01011111f, 0.01773704f, 0.13096906f, 0.21082880f, 0.28684476f, 
    -0.02781275f, 0.04461925f, -0.02241185f, 0.19681545f, 0.00820082f, 0.01164741f, -0.15190256f, 0.02308726f, 
    0.70659578f, 0.23223500f, 0.07535709f, -0.08899169f, 0.14261048f, -0.13210502f, -0.06941474f, 0.02684117f, 
    0.00701573f, -0.05474237f, 0.07590400f, 0.02035891f, 0.04335922f, -0.06316829f, -0.35110331f, -0.00220525f, 
    -0.00279113f, -0.11473596f, -0.15755254f, 0.06215436f, -0.04521657f, -0.07461579f, 0.02980777f, 0.00501936f, 
    -0.26956201f, 0.04390217f, 0.22805466f, -0.27848104f, 0.10104200f, 0.06308551f, -0.14203969f, 0.03272369f, 
    0.03761140f, -0.06760392f, -0.07554562f, 0.07104040f, 0.37036654f, -0.31030440f, 0.07212094f, 0.04860992f, 
    -0.02533022f, 0.15282896f, -0.08036818f, 0.10711083f, -0.13364957f, -0.12601574f, -0.02070052f, -0.06305195f, 
    0.20402071f, -0.01754022f, 0.06710286f, 0.20762950f, 0.15705588f, -0.00839264f, -0.00426730f, -0.00240881f, 
    -0.11657365f, 0.14337896f, -0.03235887f, 0.07189575f, 0.06207049f, -0.01706773f, -0.00128750f, -0.07032477f, 
    0.03245405f, 0.16814117f, -0.01742495f, -0.01505344f, -0.00377493f, 0.06259937f, 0.04267562f, -0.00933648f, 
    -0.16735919f, 0.29635155f, 0.03995989f, 0.01545895f, 0.02447147f, 0.06157767f, -0.11848065f, 0.05307166f, 
    -0.04220478f, 0.08130945f, 0.02306382f, 0.04279396f, 0.07671482f, 0.17721644f, 0.03101039f, 0.07543174f, 
    0.10236750f, 0.00710600f, 0.04381452f, 0.13602236f, -0.00652469f, 0.18438469f, 0.03789638f, -0.14572465f, 
    -0.12061798f, -0.14256227f, 0.07738693f, -0.13415602f, 0.11615679f, -0.00051836f, 0.13063557f, 0.03159935f, 
    0.05193351f, 0.05111161f, 0.00674360f, 0.09270450f, 0.06745419f, -0.07314536f, -0.08479056f, 0.04204262f, 
    0.00749103f, -0.02713557f, -0.02029738f, 0.14632808f, -0.07130034f, -0.09654240f, -0.07182721f, -0.04485276f, 
    0.32989141f, 0.10723311f, -0.03338296f, 0.13300215f, 0.20621687f, -0.01368270f, -0.01489939f, 0.05193336f, 
    -0.08974990f, 0.06672227f, 0.12069158f, -0.02026436f, 0.02977461f, 0.16028674f, -0.08877902f, 0.04336667f, 
    -0.02467448f, 0.24510622f, -0.07874091f, 0.08458336f, -0.01032544f, -0.06197858f, -0.06042525f, -0.07331201f, 
    0.17141236f, 0.26425570f, 0.31063893f, -0.14470105f, 0.15056729f, -0.03460809f, -0.01120327f, 0.01355375f, 
    -0.03267584f, 0.02817728f, 0.03942966f, 0.13970377f, 0.06340440f, -0.03731888f, 0.11985137f, -0.02342507f, 
    0.03247844f, 0.04592779f, -0.07608879f, 0.03833061f, -0.02543398f, -0.12952611f, 0.03179897f, 0.09298754f, 
    -0.12717105f, -0.00619924f, 0.15843908f, 0.12186256f, 0.15320741f, 0.10223784f, -0.08277179f, 0.01936220f, 
    0.02040787f, -0.13630386f, -0.08695225f, -0.01391256f, 0.33995798f, 0.15714735f, -0.26504686f, -0.00773381f, 
    -0.00975544f, -0.02879140f, 0.02220645f, 0.12550232f, -0.04761538f, -0.06161377f, -0.07425220f, 0.03210218f, 
    -0.33305663f, -0.25113276f, -0.11142232f, -0.08462708f, -0.01010653f, -0.13579164f, 0.06759412f, 0.08327199f, 
    0.19746378f, 0.05936404f, 0.03289593f, 0.00147377f, 0.00954880f, 0.23807043f, 0.00602824f, -0.21489997f, 
    0.04095949f, -0.10361026f, 0.15004426f, -0.06755889f, 0.09415398f, 0.18128981f, 0.08660372f, -0.04689977f, 
    0.20640370f, 0.00929733f, -0.11114204f, -0.02063203f, 0.14250758f, 0.01118463f, -0.03663438f, -0.05236786f, 
    0.02379414f, 0.04471070f, -0.05017900f, -0.08104858f, 0.03372035f, -0.11097533f, 0.09662608f, 0.16283512f, 
    -0.04577860f, -0.08519792f, -0.09413931f, -0.05882457f, -0.10796968f, 0.03644022f, -0.08683875f, -0.05167764f, 
    -0.01260095f, -0.28109476f, 0.20696788f, 0.02289902f, 0.13203590f, 0.11392709f, 0.02527847f, 0.02399722f, 
    0.08711410f, 0.02900199f, -0.00377206f, -0.06930897f, -0.32915303f, 0.09936970f, 0.16403179f, 0.14305121f, 
    -0.11440042f, -0.03191451f, -0.05223291f, -0.05456645f, 0.05449379f, 0.10221374f, 0.00654686f, -0.04400144f, 
    0.16783875f, -0.01652507f, 0.11147170f, 0.07617787f, 0.11456694f, 0.07563779f, -0.10263932f, -0.08683140f, 
    0.13553572f, 0.05620063f, -0.02154491f, 0.07462173f, 0.09250325f, 0.05080191f, 0.11992300f, 0.12980157f, 
    0.19991542f, -0.06242627f, -0.07906131f, -0.18347836f, 0.07088669f, -0.01453809f, -0.10294715f, 0.14643772f, 
    0.04955440f, 0.39231551f, -0.06346577f, -0.19550100f, -0.15745328f, -0.08964099f, -0.08936754f, -0.06202697f, 
    0.04685022f, 0.13625993f, -0.01537549f, -0.00617363f, 0.45321685f, 0.01259601f, 0.21226424f, -0.09210439f, 
    0.05503696f, 0.15637727f, 0.08948885f, -0.05541387f, -0.05173971f, -0.09337752f, 0.07709739f, 0.18422784f, 
    0.43099627f, 0.16424708f, -0.10485502f, 0.06776527f, 0.04752389f, -0.01882000f, 0.00354921f, -0.08626179f, 
    -0.07960130f, -0.01543695f, -0.07000408f, -0.05392068f, -0.14466842f, -0.00891047f, -0.15666033f, 0.08020575f, 
    0.07508855f, -0.01117543f, -0.05168474f, -0.18023068f, -0.01729293f, -0.04629368f, 0.13248052f, 0.00728174f, 
    -0.32970938f, -0.10816104f, -0.19016539f, 0.05417394f, -0.14327084f, -0.05672264f, 0.04923968f, 0.00156945f, 
    -0.05491131f, -0.09693132f, 0.03539452f, 0.04577850f, -0.12980235f, -0.02710450f, 0.02818196f, -0.07342364f, 
    0.02661535f, 0.03702578f, 0.03872175f, -0.00650769f, -0.01469010f, 0.00186290f, 0.07376572f, -0.10267805f, 
    0.48132908f, -0.11226780f, 0.13086179f, -0.18069293f, -0.05107687f, 0.01176034f, 0.03557847f, -0.09428158f, 
    -0.00365547f, 0.09945241f, 0.00888401f, -0.03476899f, -0.18056890f, 0.18245377f, 0.02968233f, 0.20278816f, 
    0.07563963f, 0.03668618f, -0.11515450f, 0.16859406f, -0.08609631f, 0.04202125f, -0.04801554f, -0.05071056f, 
    0.04188424f, 0.02190744f, 0.04169456f, 0.01131939f, -0.00557946f, -0.02160000f, 0.02578649f, -0.00880619f, 
    -0.05200411f, 0.01631924f, 0.00971954f, 0.00877224f, -0.01198813f, -0.05301749f, 0.03482343f, -0.04415360f, 
    -0.04614941f, -0.04552191f, -0.04743715f, 0.02542652f, 0.02846126f, -0.00058652f, -0.04239299f, 0.01730182f, 
    0.02336259f, 0.02034123f, -0.05054430f, -0.04219066f, -0.02002418f, 0.01821359f, -0.01641844f, -0.03227994f, 
    0.00091888f, 0.03531454f, 0.00235307f, -0.01078863f, -0.00701044f, -0.00942167f, -0.02470699f, -0.05827508f, 
    -0.05290528f, -0.05202898f, 0.00896758f, 0.02007853f, -0.00437712f, 0.02821085f, 0.02415009f, 0.01706517f, 
    0.02721230f, -0.01953078f, 0.00611683f, 0.02001756f, 0.00252748f, 0.00157164f, 0.03413547f, 0.00492785f, 
    -0.02504303f, 0.03857655f, 0.00932943f, 0.02303283f, -0.01572545f, 0.04882944f, -0.01165577f, -0.01832235f, 
    -0.00321732f, -0.00352964f, -0.00763979f, 0.02444213f, 0.02589838f, 0.03709222f, -0.04194897f, -0.04408072f, 
    0.04075421f, 0.01218697f, -0.02383330f, 0.00076326f, 0.00635327f, 0.02659030f, 0.03799275f, 0.04241902f, 
    -0.02338000f, -0.01176797f, 0.03759839f, -0.00781352f, -0.01561517f, -0.05357330f, 0.02387195f, 0.01905196f, 
    0.00162624f, -0.02525190f, -0.03591945f, 0.04434596f, -0.04737087f, 0.02530040f, -0.00281561f, -0.00787420f, 
    -0.01331229f, -0.00241930f, -0.04290304f, 0.01231821f, 0.02464942f, -0.04816168f, -0.00563675f, -0.04853889f, 
    0.02543508f, -0.01439547f, -0.01242006f, -0.02697573f, 0.03394959f, 0.02046138f, -0.04181931f, -0.04806610f, 
    0.00662484f, 0.02237102f, -0.04875461f, 0.03455260f, -0.00779952f, 0.02019615f, -0.05232664f, 0.01392309f, 
    -0.04643886f, -0.04025298f, -0.02524721f, -0.04295315f, 0.04659084f, -0.01028219f, 0.02704306f, 0.04451555f, 
    -0.03631138f, -0.00375612f, 0.03757170f, 0.02892495f, -0.00108589f, -0.03815024f, 0.02223532f, -0.01366159f, 
    -0.02868446f, -0.00787475f, 0.02399463f, -0.02494666f, -0.03650886f, 0.02653772f, -0.04425119f, -0.01254315f, 
    -0.01874178f, -0.00918155f, 0.00850008f, -0.03574814f, -0.00815191f, 0.03518215f, -0.04452063f, -0.01510202f, 
    -0.03135267f, -0.05809710f, 0.04158735f, 0.00453347f, 0.03007656f, -0.05496370f, -0.06059972f, 0.00224610f, 
    -0.03104223f, -0.02244166f, -0.00342485f, -0.03228552f, -0.05475071f, 0.01448690f, -0.01718502f, -0.02945074f, 
    0.04161928f, 0.02636289f, 0.03766052f, -0.04577773f, 0.01849235f, -0.04218289f, -0.03435460f, 0.01533940f, 
    -0.03015737f, -0.03143613f, -0.05187065f, 0.03345578f, -0.03203719f, -0.01213923f, -0.02507894f, 0.04043580f, 
    -0.05635060f, 0.01623156f, -0.00760683f, -0.03297790f, -0.02068103f, -0.04400602f, 0.02114414f, -0.02311415f, 
    0.02223198f, 0.01080294f, -0.02060195f, -0.01686391f, -0.00216502f, -0.02185470f, 0.02107547f, -0.03585395f, 
    0.03421854f, -0.03282066f, -0.04156081f, -0.00786927f, 0.00209504f, -0.01911532f, -0.05205807f, 0.01262702f, 
    0.01866280f, 0.01085972f, 0.02489815f, 0.02896099f, 0.02478612f, -0.04794042f, -0.01976823f, -0.02380758f, 
    0.02632457f, 0.03182885f, -0.03595306f, 0.02642529f, 0.04009555f, 0.00723346f, -0.01060066f, 0.00491120f, 
    0.04174557f, -0.02306539f, 0.02180005f, 0.03297190f, -0.00515879f, 0.01975701f, 0.01672004f, -0.00628579f, 
    0.04248150f, -0.01293377f, -0.05494447f, 0.00000699f, -0.00265106f, -0.04314280f, 0.04513459f, -0.04753622f, 
    -0.00639690f, 0.03265706f, -0.03950948f, -0.02415601f, 0.00827563f, -0.00818885f, -0.01832603f, 0.04340356f, 
    -0.05167916f, -0.04630879f, -0.02808910f, 0.01266139f, 0.01202403f, -0.01571473f, 0.01001680f, -0.03583235f, 
    0.03031554f, 0.02595628f, -0.04268816f, -0.00725463f, -0.01287415f, -0.04971281f, 0.03635711f, -0.03370020f, 
    -0.02555305f, -0.04209890f, -0.02673806f, -0.00569694f, 0.01260147f, -0.01940452f, 0.02786375f, 0.02739700f, 
    0.00226840f, -0.03475243f, -0.04052481f, 0.02769041f, -0.04452560f, 0.00963288f, -0.00526039f, 0.03664662f, 
    -0.02804971f, 0.03627082f, 0.01193167f, -0.01640335f, 0.02953842f, 0.01544243f, 0.00827754f, -0.01674185f, 
    -0.00201070f, 0.02636507f, 0.00989785f, -0.03537615f, -0.03799222f, 0.01458577f, -0.04311212f, 0.00580271f, 
    -0.01495122f, -0.04002890f, -0.04923084f, -0.02460769f, -0.05923536f, -0.03647329f, -0.01735525f, -0.00210027f, 
    -0.05039011f, -0.04872421f, 0.00335549f, -0.04338219f, 0.01019030f, 0.00106719f, -0.03175409f, 0.03449259f, 
    -0.03107721f, 0.00386331f, -0.02379708f, -0.02760384f, 0.00225197f, -0.00247466f, -0.03884917f, -0.02855202f, 
    -0.04109387f, -0.00745129f, -0.01624546f, -0.02881755f, -0.03657022f, -0.04589301f, -0.02341235f, 0.03636040f, 
    -0.00835692f, -0.01602034f, 0.01029450f, -0.03953116f, 0.02669766f, 0.00472853f, -0.00446344f, -0.00968222f, 
    -0.05135937f, -0.01916750f, 0.02768037f, -0.05034550f, 0.01188375f, 0.04465963f, -0.03864226f, 0.04380134f, 
    -0.04335233f, -0.05135168f, -0.02680862f, 0.02855451f, 0.03951480f, 0.00110998f, -0.00694591f, 0.01762040f, 
    -0.02275131f, -0.00035828f, -0.01428870f, 0.00384508f, 0.01933655f, -0.03173062f, -0.04717569f, 0.01855935f, 
    0.02626556f, -0.04147920f, -0.00194762f, -0.00493673f, 0.02138101f, -0.00720293f, -0.01409359f, 0.03850202f, 
    -0.01911338f, 0.03095026f, 0.03181383f, -0.01551373f, 0.02377805f, 0.00461093f, 0.01305830f, -0.04723921f, 
    0.03739509f, -0.00288390f, 0.00857712f, 0.01483509f, 0.04511222f, 0.02334440f, 0.00921222f, -0.01103451f, 
    -0.10793873f, -0.03531113f, -0.04322882f, -0.10169280f, -0.10943080f, 0.11334048f, -0.01175785f, -0.04075131f, 
    -0.01751221f, 0.11155771f, 0.17738774f, 0.03012796f, 0.24251278f, 0.29465878f, 0.20128214f, 0.15386723f, 
    -0.15220122f, 0.03776000f, -0.02011366f, 0.05472782f, -0.05621497f, -0.03979203f, 0.04046779f, -0.11273844f, 
    0.17433982f, 0.08785806f, -0.11532925f, 0.15230271f, -0.00126641f, -0.00592621f, -0.03929233f, -0.06882978f, 
    -0.07371774f, -0.03239989f, -0.05478825f, 0.04678781f, -0.10597192f, 0.02425303f, 0.00434221f, 0.07339960f, 
    0.07045853f, -0.03169810f, -0.00168496f, -0.02946154f, -0.09387158f, -0.00406786f, -0.04386490f, 0.04176539f, 
    -0.17855541f, 0.03381094f, -0.07522074f, 0.14676422f, 0.08103473f, -0.09078883f, 0.04779651f, 0.14470746f, 
    0.13023886f, 0.11676060f, -0.00506255f, 0.00552988f, -0.16373149f, 0.01546324f, -0.06888075f, -0.06718567f, 
    0.00264134f, -0.05133786f, -0.08743072f, 0.04543357f, 0.12779997f, -0.06074444f, 0.12111609f, 0.08581118f, 
    -0.18899800f, -0.06355298f, 0.09196219f, -0.11111102f, 0.12637627f, 0.11291444f, 0.05905128f, 0.09513035f, 
    0.03627745f, -0.15226139f, 0.12560269f, -0.07766542f, -0.20202152f, 0.24033871f, -0.04924381f, -0.15254882f, 
    -0.04657914f, -0.08399911f, 0.03641662f, -0.13239907f, 0.09904058f, 0.03146444f, 0.11107080f, 0.17209788f, 
    0.08458844f, 0.00738415f, 0.25095233f, -0.07822146f, 0.02953869f, -0.05990618f, -0.19837305f, 0.11436167f, 
    -0.10014525f, 0.13655293f, 0.10849927f, 0.02966258f, 0.01456092f, -0.06517743f, -0.20502499f, 0.13060077f, 
    0.10621497f, 0.02245018f, -0.02177410f, -0.12662639f, 0.15937132f, 0.03492864f, 0.01876882f, -0.09987867f, 
    0.03456822f, 0.01525666f, 0.10333347f, -0.24127409f, -0.20172530f, -0.00847654f, 0.07413030f, 0.10974428f, 
    0.08614595f, -0.02545261f, 0.03285556f, -0.09964610f, 0.25029010f, 0.08328998f, -0.21195830f, 0.15998839f, 
    -0.01921894f, 0.19323340f, -0.00491656f, 0.04616009f, 0.03116906f, 0.18328975f, 0.02364912f, 0.01494564f, 
    -0.55939287f, -0.01769956f, -0.01931987f, 0.05883398f, -0.00958503f, -0.07893315f, 0.03928846f, -0.09186430f, 
    0.09934252f, 0.02943119f, -0.04714541f, -0.01682939f, 0.04320480f, 0.06794848f, 0.02764056f, 0.14401306f, 
    -0.06199854f, 0.06843463f, 0.02110646f, 0.23509578f, -0.01727087f, -0.04027424f, 0.06522070f, -0.05050199f, 
    -0.41873777f, 0.17864016f, 0.07300471f, -0.07570605f, -0.05756714f, -0.06733167f, 0.07409751f, 0.11188976f, 
    -0.00845403f, -0.03174984f, -0.06112285f, 0.04177114f, -0.26990464f, 0.05063459f, 0.15509780f, 0.27609733f, 
    -0.11657211f, 0.22996654f, 0.05640978f, 0.03442043f, -0.01997161f, -0.03113966f, -0.05484958f, -0.00265388f, 
    0.11142537f, -0.23900937f, 0.14713983f, 0.07776014f, 0.00754918f, 0.08498322f, -0.11991535f, 0.00803972f, 
    0.02951614f, 0.06514811f, 0.07463117f, -0.02109697f, -0.16904667f, 0.09218673f, 0.41498116f, 0.36802238f, 
    0.00155845f, 0.08636647f, -0.04357206f, -0.09177230f, 0.02653361f, -0.09668121f, -0.02113030f, 0.09934332f, 
    -0.28100502f, -0.03722216f, -0.01490760f, -0.13863976f, 0.06119281f, 0.02428692f, 0.02295564f, 0.01711734f, 
    0.03544650f, 0.02924369f, 0.04636926f, 0.17857963f, -0.00906051f, 0.02066124f, 0.03570484f, 0.01121638f, 
    -0.06232957f, 0.04824292f, -0.00225721f, 0.04072386f, 0.21204747f, -0.01398518f, 0.04894572f, 0.12760805f, 
    0.76534754f, 0.08543184f, -0.09116805f, 0.06197972f, -0.00109115f, 0.13977955f, 0.09813183f, -0.01981969f, 
    -0.03422161f, -0.01494300f, -0.03782322f, 0.00103018f, -0.17072001f, -0.05993907f, 0.36577967f, -0.01029983f, 
    -0.02452999f, -0.00239024f, 0.09000893f, -0.05090804f, 0.08853691f, -0.02877279f, 0.14205997f, 0.00808209f, 
    -0.03893023f, 0.04420938f, 0.07231835f, -0.00554859f, -0.00196404f, -0.04990424f, 0.10700664f, 0.04166719f, 
    0.01090260f, 0.08156788f, -0.17617254f, 0.19326735f, -0.32393244f, -0.02568016f, -0.04788601f, -0.15707059f, 
    -0.17896062f, -0.06439698f, 0.08195733f, 0.05128160f, 0.05607247f, 0.00238352f, 0.00144460f, -0.17430842f, 
    -0.18437780f, -0.00823858f, 0.32768568f, 0.11855859f, -0.06952236f, 0.04838064f, 0.06651671f, 0.04752716f, 
    0.04606291f, -0.04270504f, 0.21137743f, 0.06538048f, -0.08782969f, 0.18978858f, 0.04585654f, 0.00314060f, 
    -0.05401681f, 0.09720781f, 0.14729090f, -0.08878524f, 0.03545903f, 0.02430539f, 0.07870935f, 0.04590457f, 
    -0.03632718f, -0.01121444f, -0.04590676f, -0.11319921f, -0.10771155f, 0.01331801f, -0.03053525f, -0.06299658f, 
    0.05872099f, -0.08650711f, -0.13077350f, 0.05271238f, 0.12900776f, 0.08813224f, -0.02557498f, -0.08599760f, 
    0.12637919f, 0.01079743f, 0.09630034f, -0.01626348f, 0.03521250f, 0.10951520f, -0.12934066f, -0.00716124f, 
    0.22045581f, -0.13700144f, 0.21698095f, 0.20265980f, 0.01804936f, 0.05336770f, -0.03010439f, 0.08614865f, 
    0.01236470f, 0.20715313f, -0.04443528f, 0.02904609f, 0.09151456f, 0.20582409f, 0.05410997f, 0.17367728f, 
    0.11094736f, -0.07206727f, -0.07332507f, 0.00513748f, 0.10616564f, 0.03591814f, 0.03038121f, 0.19581671f, 
    0.43120742f, 0.28782859f, 0.13562533f, -0.05498895f, 0.03380026f, 0.16961747f, 0.27481467f, 0.03775356f, 
    0.00267605f, 0.04615634f, 0.14683510f, 0.02378091f, -0.24154238f, -0.05323986f, -0.16943841f, -0.04389739f, 
    0.01280147f, 0.02690694f, 0.13116777f, -0.02960883f, 0.10054199f, -0.05299482f, -0.02636832f, 0.10569581f, 
    0.03733232f, -0.02449401f, 0.02888962f, -0.05428940f, -0.02646217f, -0.01329934f, 0.02841547f, -0.04316041f, 
    0.01357278f, -0.05099193f, 0.03552365f, -0.01499555f, 0.04371191f, 0.00862526f, -0.01340115f, -0.03566016f, 
    0.00205040f, -0.04739614f, 0.00322517f, -0.02490012f, 0.00410841f, -0.01301439f, 0.03024201f, -0.02247105f, 
    -0.05367743f, -0.01511281f, 0.00799800f, 0.01226296f, 0.03506768f, 0.00529213f, -0.00946161f, 0.03005107f, 
    0.00789394f, 0.03282952f, 0.01861845f, -0.04768790f, -0.02826660f, 0.00484008f, -0.01286532f, -0.01669234f, 
    -0.02296502f, 0.01138958f, -0.01270261f, -0.04323867f, -0.02458261f, -0.03112000f, 0.02637026f, -0.01540092f, 
    0.03223079f, 0.02987661f, 0.01553717f, -0.01963653f, -0.01194016f, 0.04225354f, 0.01852307f, -0.04831684f, 
    -0.04403491f, -0.03283317f, 0.03632559f, 0.03094677f, 0.00721548f, -0.03556326f, -0.03143985f, -0.05117328f, 
    -0.03461685f, -0.03352667f, -0.02094593f, 0.01193992f, -0.05139061f, 0.02510320f, -0.02923403f, -0.03672668f, 
    0.01207252f, 0.01790669f, 0.01307592f, -0.05483542f, -0.04054827f, 0.04385981f, -0.05295586f, -0.02896037f, 
    -0.04153724f, -0.03319711f, -0.01971047f, -0.01557919f, 0.01708458f, -0.00972634f, 0.04068382f, -0.03272305f, 
    -0.03923879f, -0.01946568f, -0.02888177f, -0.05046876f, -0.02399529f, -0.00062130f, 0.02104974f, -0.00223863f, 
    0.00738578f, -0.05123324f, 0.02901993f, 0.02698711f, 0.01619381f, 0.02728506f, 0.02609585f, -0.01085574f, 
    0.01385930f, -0.03130452f, -0.01077980f, 0.02396573f, 0.02186374f, 0.00085885f, 0.02948116f, -0.03435786f, 
    0.03082701f, -0.02794138f, 0.03411284f, -0.04960145f, -0.03908421f, 0.02422377f, -0.05568352f, -0.01265234f, 
    0.02636336f, -0.01902780f, -0.04870702f, 0.01242235f, 0.03843627f, 0.01922937f, 0.02131106f, 0.03416944f, 
    -0.03964871f, 0.03389560f, 0.02808744f, -0.01274057f, 0.03944938f, -0.01435420f, -0.03904421f, 0.04442834f, 
    -0.01939385f, -0.02778029f, 0.03570307f, -0.01957024f, 0.01871474f, -0.03825275f, -0.03162415f, 0.03835869f, 
    0.00716375f, -0.00495357f, -0.03542737f, 0.01494502f, 0.00324197f, -0.05315153f, 0.00400693f, -0.03778379f, 
    0.00744868f, -0.00324766f, 0.00783281f, 0.00838942f, 0.01266091f, -0.00533011f, 0.02037319f, 0.03852780f, 
    -0.04731284f, -0.04334157f, -0.02044805f, 0.02108002f, 0.01345871f, -0.02224991f, -0.00217893f, -0.03416887f, 
    0.00317100f, 0.04090034f, -0.04498829f, -0.05589353f, 0.02498407f, -0.02785553f, 0.02088009f, 0.02105189f, 
    0.02583698f, -0.00086094f, 0.00002327f, -0.04552260f, 0.01575348f, -0.05283737f, 0.02253395f, -0.01931284f, 
    0.00281566f, 0.02172592f, -0.04187121f, -0.02995540f, 0.01883161f, 0.01054999f, -0.05357536f, 0.00645015f, 
    -0.04345447f, -0.01028505f, 0.02270275f, 0.03354914f, -0.03505590f, 0.02762460f, 0.03665962f, 0.04050825f, 
    -0.02786536f, 0.01351774f, 0.00253051f, -0.05324190f, -0.00649640f, -0.02725322f, 0.01092070f, -0.01947397f, 
    -0.05181871f, 0.02595395f, -0.04704330f, -0.04863666f, 0.01852171f, -0.04678692f, -0.04387255f, 0.04357357f, 
    0.01728055f, -0.02425268f, -0.05474332f, -0.00400413f, 0.04348214f, -0.01985981f, 0.02153805f, 0.04072996f, 
    -0.04929724f, -0.01647866f, -0.03776943f, -0.00136969f, 0.01727384f, -0.01038644f, 0.02060430f, 0.01667445f, 
    0.01719558f, 0.01596669f, -0.05296196f, -0.01703545f, 0.03289745f, -0.03321797f, -0.01585305f, 0.03004624f, 
    0.00280421f, 0.03218975f, 0.02204173f, 0.00398184f, -0.02399606f, -0.03169884f, -0.00007479f, 0.00097313f, 
    -0.00718899f, -0.02298204f, -0.01379687f, 0.01754187f, -0.02808648f, 0.03831882f, 0.00590012f, -0.01775401f, 
    -0.05188540f, -0.04880898f, -0.05086868f, -0.04927882f, 0.04247257f, 0.01398837f, 0.04030827f, -0.05135985f, 
    -0.05091860f, -0.02002701f, -0.04409747f, 0.04451932f, -0.04431541f, -0.04524427f, 0.00132072f, -0.04488491f, 
    0.01839975f, 0.02241829f, -0.03180720f, 0.00917930f, -0.03596830f, -0.02423150f, 0.00110315f, 0.03258719f, 
    -0.00303153f, 0.00109369f, -0.00006427f, -0.01680999f, -0.04522857f, -0.00495714f, -0.04944573f, -0.05652201f, 
    -0.03490359f, 0.03950515f, -0.02042341f, -0.01219488f, 0.01860532f, -0.04992368f, 0.03809455f, 0.03248715f, 
    0.02518967f, 0.04103462f, 0.04131777f, -0.05005259f, -0.05297482f, -0.00706449f, -0.05655461f, -0.03193733f, 
    0.00101970f, -0.04590714f, -0.04477909f, 0.04235582f, -0.02113463f, 0.00065627f, -0.04759328f, 0.00311921f, 
    0.02559273f, 0.03590008f, 0.02260145f, 0.00697761f, -0.05083412f, 0.00638632f, -0.00467893f, -0.02764686f, 
    -0.05067863f, -0.01214400f, -0.00617520f, -0.00070391f, -0.05536328f, 0.02367003f, -0.00240231f, 0.00311149f, 
    0.03533687f, -0.05114902f, 0.02516101f, 0.03240663f, 0.00367514f, -0.03878615f, 0.00765908f, 0.04312164f, 
    0.01356362f, -0.00425552f, -0.05570085f, -0.04119883f, -0.05655857f, -0.02237849f, 0.00035975f, -0.02891763f, 
    -0.04750229f, -0.02969104f, -0.03288113f, 0.04422534f, -0.05040884f, -0.03157117f, 0.03484214f, -0.00231964f, 
    -0.02687415f, -0.01257343f, 0.01948930f, 0.01940971f, -0.02838447f, 0.02423496f, -0.01640410f, -0.03970937f, 
    -0.05639859f, 0.01380510f, 0.03777977f, 0.04249422f, 0.04214292f, 0.01982885f, -0.02397366f, -0.02896896f, 
    -0.03479752f, -0.04155901f, -0.02069317f, -0.04251328f, -0.03502347f, -0.05691779f, -0.03333435f, -0.00222557f, 
    -0.01863449f, -0.02059795f, -0.00422585f, -0.03820743f, -0.01378263f, -0.05234207f, 0.00930212f, 0.00652385f, 
    -0.00249240f, 0.03567492f, 0.00213351f, -0.01322038f, 0.02674278f, 0.01671062f, -0.04467347f, -0.00662501f, 
    -0.02391981f, 0.01835205f, 0.03570372f, 0.04467835f, 0.00406342f, -0.00507041f, -0.03848570f, 0.04155229f, 
    0.01919593f, 0.01032634f, -0.01967988f, 0.03770600f, -0.03822387f, 0.01934770f, 0.02663933f, 0.02520030f, 
    0.04435263f, 0.05282305f, 0.00877327f, 0.00351625f, -0.00617292f, -0.01022762f, 0.02854718f, -0.04701858f, 
    0.04098562f, 0.01689642f, 0.02085560f, -0.01188099f, -0.01860484f, -0.04961840f, 0.03146116f, 0.00787050f, 
    0.03411437f, 0.04610043f, -0.00467351f, 0.01791749f, -0.00375044f, -0.01762524f, -0.00517355f, 0.03206900f, 
    -0.02209016f, -0.00872570f, 0.03359826f, 0.03664529f, -0.02202228f, -0.01016876f, -0.03082185f, 0.00792259f, 
    0.02475063f, -0.01393127f, 0.01982147f, 0.03660074f, -0.00983815f, -0.05290849f, 0.02693825f, -0.03666459f, 
    0.00317597f, 0.02751554f, 0.03941199f, 0.01759554f, 0.01951418f, 0.00923236f, 0.01450814f, 0.02288448f, 
    -0.00084464f, 0.00963428f, 0.00266664f, -0.05032046f, -0.01882315f, 0.03524061f, 0.01902712f, -0.01580621f, 
    -0.02958708f, -0.00181912f, -0.01797811f, -0.05014603f, -0.03034706f, 0.00865013f, -0.01833270f, -0.04189255f, 
    -0.03333336f, -0.04457774f, -0.02136317f, -0.03138336f, -0.01780088f, -0.03811729f, -0.00686398f, 0.01308104f, 
    -0.01690121f, -0.05854967f, 0.02253602f, -0.04419639f, 0.01722782f, -0.04143905f, -0.00815473f, 0.01121743f, 
    -0.00041868f, 0.00467948f, -0.05445487f, -0.02696935f, -0.01822224f, 0.02836344f, -0.00797643f, 0.03509050f, 
    -0.03387211f, 0.05216015f, 0.02759818f, -0.04583342f, 0.01524478f, -0.04553248f, 0.00352445f, -0.00726223f, 
    -0.01464671f, -0.02564266f, 0.01450663f, -0.01140322f, 0.00454595f, -0.04104642f, 0.01627969f, -0.01725498f, 
    -0.03319222f, 0.02614852f, 0.04390946f, 0.04176567f, 0.02723312f, 0.03929719f, -0.05760989f, -0.02150418f, 
    -0.02847733f, -0.01611604f, -0.01229554f, 0.01694557f, 0.03109153f, -0.04950484f, -0.05509477f, 0.03622239f, 
    -0.02410120f, -0.01738674f, 0.04252971f, -0.02199460f, 0.04917127f, 0.03192727f, -0.00279397f, 0.02899632f, 
    -0.02499928f, 0.02187964f, 0.00933894f, 0.00615610f, 0.03593079f, 0.03394309f, 0.02242008f, -0.02444023f, 
    0.05481851f, -0.01288540f, 0.00145402f, -0.00743464f, 0.01820655f, 0.03912664f, 0.00655846f, -0.01799952f, 
    -0.03075560f, -0.00635698f, 0.01453798f, -0.04096324f, -0.01820086f, 0.04349462f, 0.04384887f, -0.05389345f, 
    -0.03949374f, -0.02969624f, 0.01311501f, 0.02654593f, 0.02211974f, -0.04198614f, -0.02042623f, -0.00326441f, 
    -0.04833809f, -0.00475865f, -0.04193349f, -0.05412212f, 0.01031117f, 0.02006521f, -0.02491114f, -0.02877239f, 
    0.01625239f, -0.03407673f, 0.00479607f, -0.01988449f, -0.01885854f, 0.02549190f, 0.01886353f, -0.04273252f, 
    -0.04939365f, 0.03069046f, -0.01499586f, 0.03418143f, -0.03058770f, -0.00611388f, -0.00345229f, 0.00982539f, 
    -0.02995803f, -0.00826225f, 0.01687958f, -0.04546409f, -0.02448593f, -0.01323397f, 0.02986910f, 0.03924301f, 
    0.04487597f, -0.02756315f, 0.01821692f, -0.04138541f, -0.00826572f, 0.00964128f, 0.00480710f, -0.03938729f, 
    0.03516914f, -0.05036373f, -0.03055793f, -0.01942195f, 0.01867709f, -0.01435747f, 0.02478035f, 0.03075211f, 
    -0.02464416f, -0.00379274f, 0.04434841f, 0.02187616f, 0.00458125f, -0.03459566f, -0.04215325f, 0.00472806f, 
    -0.01234593f, 0.05048088f, -0.01933597f, -0.03017690f, -0.01063919f, 0.02182047f, -0.01813982f, 0.01744939f, 
    -0.04344373f, 0.04489554f, -0.03396718f, -0.04723036f, -0.03515985f, -0.04976035f, -0.04242680f, -0.01794352f, 
    -0.00341566f, -0.04066763f, -0.03887241f, -0.01400260f, -0.04147284f, 0.00331911f, -0.01245760f, -0.01528632f, 
    -0.04899516f, -0.01478903f, -0.01967023f, -0.04004922f, 0.05429998f, 0.02876825f, -0.01952455f, -0.04133754f, 
    0.01270415f, 0.03810202f, 0.00378332f, -0.05731555f, -0.03605055f, -0.03861285f, -0.04244621f, -0.04828259f, 
    -0.05154775f, -0.01358362f, 0.02434527f, -0.00059355f, 0.03715936f, -0.00802475f, 0.03686142f, 0.00146056f, 
    0.01861945f, -0.01839366f, 0.02299629f, -0.03079584f, -0.05362749f, -0.04409932f, -0.04156818f, -0.03611901f, 
    0.01825474f, 0.04291115f, -0.04686912f, 0.01379838f, -0.02407098f, -0.04555763f, 0.04157364f, 0.04697737f, 
    -0.02728334f, -0.02652632f, -0.02327980f, 0.01824367f, 0.00083805f, -0.00769758f, 0.01606959f, -0.02297096f, 
    -0.05127016f, 0.02426350f, 0.02073030f, 0.03669852f, 0.02580549f, 0.04002677f, -0.02137358f, -0.00636830f, 
    -0.03441557f, -0.03968076f, -0.02574362f, 0.04023043f, -0.04010589f, -0.04379321f, -0.05516309f, -0.03350089f, 
    0.00743498f, 0.02607192f, -0.03299158f, -0.03576751f, 0.04610239f, 0.00383749f, -0.02562089f, -0.03536111f, 
    -0.03219403f, -0.02119637f, -0.03382366f, -0.03112647f, -0.05653943f, -0.04830885f, -0.02909888f, 0.00400374f, 
    -0.00032638f, 0.04190458f, 0.01848568f, -0.03254233f, 0.03993016f, -0.04049611f, 0.02804859f, -0.05764416f, 
    0.03061496f, 0.00379901f, 0.02661687f, -0.05904837f, -0.04506029f, -0.00783396f, -0.05189170f, -0.06044195f, 
    -0.03309999f, 0.03945832f, 0.03335259f, -0.05754888f, -0.04713722f, 0.01449017f, 0.01785316f, 0.02042957f, 
    0.00459114f, -0.05184235f, 0.00650876f, -0.00010124f, -0.03208820f, -0.02935867f, -0.04149725f, 0.03893636f, 
    0.03341384f, 0.04391522f, -0.02965602f, 0.01957763f, -0.03221595f, 0.00778601f, 0.02646015f, -0.05372591f, 
    0.13868389f, -0.64427519f, 0.17901027f, 0.29148921f, -0.10596962f, -0.11564520f, 0.10961659f, -0.02215810f, 
    0.12071974f, -0.03044765f, -0.17582116f, 0.11302329f, -0.22094807f, 0.00554018f, 0.25632429f, 0.31390920f, 
    -0.02883820f, 0.05977453f, -0.10122984f, -0.04530681f, 0.15746173f, -0.00529852f, 0.05653239f, -0.09904908f, 
    -0.04885852f, -0.20253864f, -0.02109717f, -0.30107382f, -0.07364233f, 0.11457298f, 0.15054150f, 0.21786204f, 
    0.00238899f, 0.16460359f, 0.11136549f, -0.13747132f, -0.26434338f, 0.35042229f, -0.13763759f, -0.18107222f, 
    -0.06349292f, 0.03891624f, 0.05926156f, 0.07213559f, 0.05758820f, -0.03825430f, -0.02286218f, 0.03122610f, 
    0.17449512f, 0.07022399f, 0.16045375f, 0.04841645f, -0.03452995f, 0.04717531f, 0.00641606f, 0.16320844f, 
    0.13569266f, -0.02290328f, 0.05964224f, 0.03695199f, -0.05184738f, 0.40255013f, -0.04069432f, 0.20808548f, 
    0.14573841f, 0.01953621f, 0.06767005f, 0.11478263f, -0.01896429f, 0.14675558f, 0.00805350f, -0.08162833f, 
    -0.44538054f, 0.28535554f, -0.27280390f, 0.14693500f, -0.04028180f, 0.06023568f, 0.00281070f, 0.17415020f, 
    -0.03857544f, -0.01906513f, -0.00905554f, 0.06364078f, 0.20060171f, 0.15336590f, -0.19463271f, -0.07167199f, 
    0.13214315f, 0.06942858f, 0.09013035f, -0.01791876f, -0.03556744f, 0.01308778f, -0.05950523f, 0.02699897f, 
    -0.18225473f, 0.11848036f, 0.13518186f, -0.26261497f, -0.03552358f, -0.18455333f, -0.21367796f, 0.08144503f, 
    0.10069650f, -0.01942172f, -0.15921214f, 0.12180179f, 0.10648317f, -0.05345816f, -0.03447016f, 0.04675610f, 
    -0.09803888f, -0.02519141f, 0.08623150f, 0.13301550f, 0.01911619f, 0.06769727f, 0.09012352f, 0.03636027f, 
    0.55498171f, -0.22148010f, 0.08618516f, 0.05767632f, -0.22270526f, -0.15009588f, 0.07330368f, 0.13834658f, 
    0.14777443f, 0.09931177f, -0.01322214f, -0.02513406f, 0.01785499f, -0.00559268f, 0.07952496f, -0.17371182f, 
    -0.07792240f, -0.11362008f, -0.09919059f, 0.05032586f, -0.09712638f, -0.02462435f, -0.04058228f, 0.02192996f, 
    0.08990639f, -0.36684981f, 0.25239599f, -0.25046852f, -0.04529129f, 0.08094033f, 0.01049778f, 0.13986664f, 
    -0.11309917f, -0.01106352f, -0.06800276f, 0.02438192f, 0.11828898f, 0.24024568f, -0.24632928f, -0.14410676f, 
    0.05095936f, -0.03727457f, 0.10562226f, -0.07430787f, 0.10714550f, 0.02751828f, -0.02987325f, 0.16807729f, 
    -0.11828193f, 0.18927366f, -0.26489317f, 0.01204746f, 0.12738359f, -0.04191214f, 0.04023207f, 0.07827277f, 
    0.07876460f, 0.08098280f, 0.12193947f, 0.05817382f, -0.29692477f, 0.07726384f, 0.16945456f, -0.16477652f, 
    0.10433055f, -0.13346186f, -0.00316342f, -0.05031126f, 0.03351825f, -0.05092291f, 0.12482738f, -0.04949317f, 
    0.20508215f, 0.00966530f, 0.12871513f, 0.16345958f, 0.05449732f, 0.04544114f, 0.05710408f, 0.07157627f, 
    0.06995499f, -0.02615672f, 0.01504199f, 0.08106960f, -0.03728195f, -0.06316870f, 0.32449690f, -0.17643957f, 
    0.00856432f, 0.05117217f, 0.22760911f, -0.01771067f, 0.06302807f, 0.10334496f, -0.01975954f, -0.08411273f, 
    0.11833507f, 0.06230202f, -0.21920599f, 0.31270218f, -0.02546244f, -0.00262206f, 0.04135922f, 0.15185262f, 
    0.05887762f, 0.01577503f, 0.07912536f, -0.00726308f, -0.09081420f, 0.19575776f, -0.15046202f, 0.20973825f, 
    -0.21306610f, -0.05390849f, 0.13361190f, 0.12622641f, 0.02411587f, -0.02873650f, 0.01726119f, 0.02568971f, 
    0.08411318f, 0.13944480f, -0.03322543f, -0.22211683f, -0.00147032f, -0.00253905f, -0.04640076f, 0.05357256f, 
    0.08443899f, 0.02052533f, -0.03664656f, 0.04343093f, 0.34590837f, -0.05904622f, -0.29000208f, -0.04805670f, 
    0.09761730f, 0.07632038f, 0.00471206f, -0.01888163f, -0.07627190f, -0.00614018f, 0.07854486f, -0.01106048f, 
    0.17645878f, -0.19905727f, -0.25165531f, 0.18617706f, -0.01044781f, -0.00693191f, 0.03583119f, 0.04648777f, 
    -0.03933273f, 0.07401226f, 0.03787724f, 0.01493429f, -0.21166112f, 0.27687877f, -0.20381844f, 0.06708279f, 
    -0.09253292f, -0.01299803f, -0.02560535f, 0.16199178f, 0.06246463f, -0.01515299f, 0.03569907f, 0.00261399f, 
    0.35711661f, -0.35722697f, 0.14508750f, -0.18379495f, -0.26864830f, 0.13801710f, 0.15869002f, -0.07808812f, 
    0.06575622f, 0.03550542f, 0.01116253f, 0.08758694f, -0.26105815f, -0.24613596f, 0.14507972f, -0.33834690f, 
    0.08913498f, 0.05305289f, -0.15173896f, 0.06644399f, 0.07066454f, -0.00102789f, -0.10725632f, -0.04226234f, 
    -0.24077079f, -0.22596072f, 0.34990856f, 0.40783086f, -0.07852050f, 0.03106617f, 0.05775278f, -0.01710297f, 
    0.00721260f, 0.02588160f, 0.09775641f, 0.03692403f, -0.55417699f, -0.14190367f, -0.04388759f, 0.33090785f, 
    -0.02328029f, 0.01829200f, -0.07318475f, 0.06936276f, -0.04820964f, 0.06135119f, -0.02419734f, -0.00255370f, 
    -0.05688920f, 0.04646331f, 0.39250550f, -0.01370613f, -0.09176620f, -0.03052335f, -0.04514476f, 0.02066381f, 
    0.09458389f, 0.01735389f, -0.04679170f, 0.11656712f, -0.05983431f, 0.04689808f, 0.03016123f, 0.06230433f, 
    0.07100796f, -0.06952557f, 0.09865373f, 0.02820221f, -0.08312488f, 0.05192127f, -0.00203286f, 0.13815553f, 
    0.07256922f, 0.01514643f, 0.16532196f, -0.16925350f, -0.08158485f, 0.03515290f, 0.08240298f, -0.03308310f, 
    0.05768552f, 0.05082740f, 0.11574540f, -0.08420336f, 0.32174626f, -0.15766673f, -0.04447655f, 0.17416444f, 
    -0.03000260f, 0.06660759f, 0.11232367f, 0.15899134f, -0.10293291f, 0.04295216f, 0.00450157f, 0.00269160f, 
    0.00580353f, 0.03979102f, 0.03678517f, -0.02730156f, 0.02521136f, 0.02283636f, 0.02366129f, -0.01971447f, 
    -0.00277382f, 0.00070289f, -0.00568681f, -0.04618205f, 0.00263702f, 0.03568927f, -0.00148970f, 0.00060011f, 
    0.03299778f, -0.03652193f, -0.03465569f, 0.04416427f, -0.02468046f, -0.00410012f, -0.04759509f, -0.00573991f, 
    0.01008796f, -0.02373793f, -0.03563426f, -0.02447662f, -0.03455601f, -0.04970161f, -0.05209774f, -0.02924776f, 
    -0.00834667f, -0.04765155f, -0.03490911f, -0.00861201f, 0.02082404f, -0.02108780f, 0.00210350f, -0.03179489f, 
    0.01800382f, -0.03285992f, -0.01750877f, -0.01229119f, 0.03280175f, 0.03170701f, -0.03821440f, -0.01078101f, 
    0.02455791f, -0.00062833f, -0.00564718f, -0.05604164f, -0.05440352f, -0.02371189f, 0.03551167f, -0.01967696f, 
    -0.04506518f, -0.00480785f, -0.03259558f, 0.00031456f, -0.04929621f, 0.04161622f, 0.02732060f, -0.04073473f, 
    -0.03125885f, -0.01595341f, -0.04243670f, -0.01808677f, -0.04904191f, 0.03984642f, -0.00736403f, 0.03518383f, 
    0.00865258f, 0.03706503f, -0.03809423f, -0.02081270f, -0.00914169f, 0.00442052f, -0.04605484f, 0.02121215f, 
    0.04700973f, 0.00016538f, -0.03368676f, -0.02681975f, 0.00476012f, 0.04072159f, -0.05385468f, 0.03772627f, 
    0.02542228f, -0.02601845f, 0.01254845f, -0.03752717f, 0.00565259f, 0.02985933f, -0.05698026f, -0.01954462f, 
    -0.04869970f, 0.01925965f, -0.04498556f, -0.03297632f, 0.02768757f, -0.02859469f, -0.03849664f, -0.04660322f, 
    -0.01834371f, -0.04459464f, -0.02983953f, 0.00439442f, 0.00211159f, -0.02016888f, 0.02472452f, -0.00576219f, 
    -0.03961234f, -0.00317176f, -0.00763864f, 0.02771521f, 0.02510747f, 0.01100893f, 0.01990895f, 0.00659539f, 
    -0.01772336f, -0.03047854f, -0.03833167f, -0.04018374f, 0.00072608f, -0.04599967f, 0.02654651f, -0.03788289f, 
    0.03366851f, -0.05290373f, 0.00546002f, -0.03178685f, -0.00824572f, -0.01756916f, -0.00731090f, 0.03118268f, 
    0.00889777f, 0.00973211f, -0.00395619f, 0.03652678f, -0.03384954f, -0.00744292f, -0.03470586f, -0.04288763f, 
    -0.01152499f, -0.04139991f, -0.03836389f, 0.01759778f, -0.04209050f, -0.05057191f, 0.02617776f, -0.01771587f, 
    0.03060971f, -0.02039000f, -0.01768253f, -0.01402133f, 0.03747771f, -0.05360238f, 0.01510135f, -0.02131675f, 
    0.02109289f, -0.02473606f, -0.05368917f, -0.04359415f, -0.03621148f, -0.04331767f, 0.02147735f, -0.05078376f, 
    0.00703766f, 0.03623347f, -0.04814542f, -0.05037310f, 0.01389081f, 0.03522446f, 0.02735254f, 0.01856340f, 
    0.00094335f, -0.03703397f, -0.01377410f, 0.00415175f, 0.00134468f, 0.02618950f, 0.00806134f, -0.03304011f, 
    0.00875205f, 0.02174891f, -0.05482049f, -0.04454844f, 0.01175698f, -0.04367371f, 0.03900470f, -0.01002126f, 
    0.00684708f, -0.04727276f, 0.02842990f, 0.02500226f, 0.00362811f, -0.00304988f, -0.05079416f, -0.04630619f, 
    0.00453431f, -0.01540152f, -0.04786922f, -0.00484961f, -0.00918520f, -0.02176134f, 0.02563971f, 0.03748739f, 
    -0.03682161f, 0.00794135f, -0.04712089f, 0.00724250f, -0.05629062f, -0.01927640f, -0.05697631f, 0.00118009f, 
    -0.03682809f, -0.02869846f, -0.03195646f, -0.03890923f, 0.02828562f, 0.01230727f, -0.01654509f, 0.00759031f, 
    -0.01205435f, 0.03349651f, -0.04206374f, -0.04745896f, -0.02479868f, -0.02275489f, -0.02963627f, 0.03395587f, 
    0.00871982f, 0.02874620f, 0.00132408f, -0.03923187f, 0.03830341f, -0.01020959f, -0.03840709f, -0.02264124f, 
    0.01458519f, -0.02643758f, -0.00068782f, -0.05274003f, -0.00421254f, 0.02593395f, 0.00634867f, 0.02957391f, 
    0.04004646f, 0.02409143f, 0.04063857f, -0.00930655f, 0.00024244f, 0.02378142f, -0.02631582f, 0.03847426f, 
    -0.04955543f, -0.00947607f, -0.00791517f, 0.03389258f, -0.02934471f, -0.01202539f, 0.00750426f, 0.01784375f, 
    -0.01873021f, -0.01492309f, -0.03329555f, 0.03018572f, -0.00244759f, -0.00411980f, -0.04113058f, -0.01580125f, 
    0.01829049f, -0.02439405f, 0.02511956f, 0.00267281f, -0.05168750f, 0.03354300f, -0.01579149f, 0.00720144f, 
    -0.03504381f, -0.03212637f, -0.03377525f, 0.04138875f, -0.01914299f, 0.03496769f, -0.00537628f, -0.02077835f, 
    -0.01376789f, -0.00657904f, -0.04568789f, -0.02464848f, -0.04734391f, 0.01721203f, -0.01582026f, -0.05386848f, 
    0.03109623f, 0.00513770f, 0.02866595f, 0.00491992f, 0.03744408f, 0.03303299f, -0.00379858f, 0.04476350f, 
    -0.02599628f, -0.00784569f, -0.04347988f, -0.05470713f, -0.01014047f, 0.03002241f, -0.01374135f, 0.04017720f, 
    -0.01171751f, 0.01234179f, 0.01635653f, -0.01051365f, 0.03883528f, 0.03310205f, -0.00776143f, 0.01258945f, 
    -0.04339527f, 0.03515943f, 0.03305508f, -0.01040474f, -0.03916454f, -0.01903602f, 0.03814647f, 0.03483049f, 
    -0.02230321f, 0.04136391f, -0.02609961f, -0.02037223f, -0.00565269f, 0.01334342f, -0.05360502f, -0.03318502f, 
    -0.02114496f, -0.01461439f, 0.00482593f, -0.02375409f, -0.03474319f, 0.02643172f, -0.01406804f, 0.02877217f, 
    -0.05048924f, -0.04025638f, -0.01749418f, 0.01308272f, -0.03674436f, -0.05502721f, -0.03962169f, 0.03462616f, 
    0.03535205f, 0.02547467f, -0.04824961f, -0.02455948f, 0.01158517f, -0.03769102f, 0.00171298f, -0.05174111f, 
    -0.03878818f, 0.00876551f, 0.01752756f, 0.03646204f, -0.00765972f, 0.02481915f, 0.02061564f, -0.00195047f, 
    -0.00400579f, -0.04739339f, -0.01785346f, -0.02464787f, -0.02865149f, 0.00696964f, 0.01379920f, -0.02154456f, 
    0.03361435f, -0.03832843f, -0.00124043f, -0.02348044f, 0.00797106f, 0.01141153f, -0.05034681f, -0.04072645f, 
    -0.36525503f, 0.02559562f, 0.24170609f, -0.02548278f, -0.09724748f, 0.00021918f, -0.02419502f, -0.08953441f, 
    0.05435346f, 0.05112553f, 0.00869752f, -0.01399691f, 0.05344408f, -0.12992960f, 0.01116791f, -0.11479654f, 
    0.00575422f, -0.05844939f, 0.00000081f, -0.01275874f, 0.08097865f, 0.24424423f, 0.03987961f, 0.07051308f, 
    -0.03998883f, -0.14919306f, 0.18793912f, 0.04915227f, 0.01218564f, -0.04102006f, 0.03329259f, 0.08337064f, 
    0.09265352f, -0.05993260f, 0.10185955f, 0.06273399f, 0.06978349f, -0.29136473f, 0.10015052f, 0.12376015f, 
    -0.05478895f, -0.11034435f, 0.14486896f, -0.19014850f, 0.11453990f, 0.06421994f, 0.07488313f, 0.07839713f, 
    0.19862202f, 0.47317263f, -0.04688045f, -0.38840953f, 0.02381786f, -0.06708323f, 0.03269351f, -0.00796084f, 
    0.07688504f, -0.08492249f, 0.06687604f, -0.08732889f, 0.12535568f, -0.00105645f, 0.12604699f, 0.11072812f, 
    0.01906580f, -0.11954380f, 0.08048261f, -0.01701912f, -0.16295491f, -0.26344004f, -0.04134423f, 0.01954309f, 
    0.10510077f, 0.03258637f, -0.23233846f, -0.16907485f, 0.10336170f, 0.02242798f, 0.12766878f, -0.00100873f, 
    -0.06827741f, 0.08499819f, -0.06131136f, 0.09770925f, -0.00031461f, -0.33727837f, 0.12493452f, 0.11355162f, 
    0.12699133f, -0.02016199f, -0.08678020f, 0.05965666f, 0.01093779f, -0.02782146f, 0.05800356f, -0.01592314f, 
    -0.08519757f, -0.08266459f, -0.09965777f, 0.06720799f, 0.08945870f, -0.02611487f, 0.08977726f, -0.07443026f, 
    0.09988700f, 0.12462344f, -0.02416306f, -0.01031791f, 0.02378655f, 0.18616904f, 0.14885290f, 0.04485133f, 
    -0.03730705f, -0.06139659f, 0.07743654f, 0.06110485f, -0.08914483f, -0.01102924f, -0.04831358f, -0.00652301f, 
    -0.23819949f, 0.15153386f, 0.07997837f, 0.04037881f, 0.05816811f, 0.01583267f, -0.11649960f, -0.11209290f, 
    -0.02591478f, -0.07754844f, -0.12794419f, 0.18223383f, 0.14562669f, -0.22886428f, 0.21514326f, -0.03004960f, 
    0.18641259f, -0.00205710f, 0.08407095f, 0.01892235f, -0.02203876f, -0.00817979f, 0.07350822f, 0.09033737f, 
    0.11502426f, 0.13123077f, -0.00370371f, 0.14077097f, 0.01231503f, 0.12661779f, -0.01525902f, 0.03308808f, 
    0.20311692f, -0.00419300f, 0.02572915f, 0.02448876f, 0.11034665f, -0.30273858f, -0.12086327f, 0.00764484f, 
    0.04754074f, -0.09898327f, 0.00233421f, -0.03535572f, 0.06464822f, -0.02644242f, -0.04235878f, 0.01545592f, 
    -0.24466132f, 0.01219529f, 0.08757017f, 0.03085686f, 0.19882558f, 0.15189148f, 0.02439568f, -0.03522459f, 
    0.03578771f, 0.14391582f, 0.00249401f, 0.01948923f, 0.08551827f, -0.05764745f, 0.11510035f, 0.01001271f, 
    0.08757571f, 0.04590615f, -0.06266140f, -0.14022644f, 0.11921641f, 0.16200292f, 0.08362825f, 0.13710928f, 
    -0.08480776f, 0.11552910f, -0.00737397f, 0.15115389f, 0.04727277f, 0.19173048f, 0.12052777f, 0.02184429f, 
    0.00358983f, 0.08299864f, 0.05677370f, 0.08077940f, -0.04767185f, -0.09939051f, 0.00696966f, 0.05006468f, 
    -0.12779965f, -0.06538542f, -0.08376625f, 0.07761078f, -0.04821499f, -0.10158572f, 0.05256521f, 0.05902395f, 
    0.28650936f, 0.35918611f, 0.15355304f, 0.06262475f, 0.04558272f, -0.06208823f, -0.01411555f, 0.09665818f, 
    0.01202262f, 0.12190416f, -0.04834862f, -0.05552468f, 0.22084750f, 0.33755583f, -0.06001695f, -0.09579536f, 
    0.09002907f, 0.09934660f, 0.00210630f, 0.09485960f, 0.04841796f, -0.03074852f, 0.01238392f, 0.06969988f, 
    -0.19612844f, -0.22168586f, 0.04655685f, 0.13098775f, 0.09342510f, 0.01560264f, 0.12599242f, -0.00854596f, 
    -0.01715597f, 0.13621241f, 0.07881469f, 0.06745183f, -0.50586325f, 0.22634023f, -0.22115581f, -0.25221726f, 
    -0.00949893f, -0.06724594f, 0.07950856f, 0.14601958f, -0.01757511f, -0.00060393f, 0.00711971f, 0.10481039f, 
    -0.29922977f, 0.32481992f, 0.14612445f, -0.05271379f, 0.05414386f, 0.10556147f, -0.00580701f, 0.12981375f, 
    0.03350132f, -0.14376840f, 0.06384059f, -0.13272506f, 0.47318283f, 0.17449072f, 0.02595107f, 0.01519726f, 
    0.12719920f, 0.13980480f, 0.02715472f, -0.02581260f, -0.04989854f, -0.01491400f, 0.11214339f, 0.05790420f, 
    -0.20184337f, -0.15187760f, -0.08833322f, 0.20125647f, 0.12313488f, -0.14906681f, -0.04933088f, 0.06420390f, 
    -0.12287077f, -0.05950927f, -0.01479690f, -0.01487089f, -0.14620863f, 0.07092694f, -0.20202009f, 0.07571566f, 
    0.11980546f, -0.07976765f, -0.05837099f, -0.03567101f, -0.01297518f, 0.03393256f, -0.04333358f, 0.01307615f, 
    -0.25879854f, 0.15828867f, 0.01775696f, -0.29189599f, -0.08128992f, -0.03237125f, 0.04018541f, 0.13303193f, 
    -0.01272985f, 0.04434930f, 0.04669290f, 0.04100103f, -0.20025872f, 0.05746264f, -0.17634092f, -0.11726560f, 
    0.05585293f, -0.05356646f, 0.01541654f, 0.13595185f, 0.04242290f, 0.00304287f, 0.04412279f, -0.05830798f, 
    0.09565950f, 0.20332099f, -0.09766648f, -0.20525602f, 0.01767034f, -0.01899574f, -0.01490920f, 0.05361379f, 
    0.10730392f, -0.00948176f, 0.12884703f, 0.11585502f, 0.07789883f, 0.08721991f, 0.04710604f, 0.01185631f, 
    0.02368221f, 0.08043426f, -0.04780893f, -0.00896948f, 0.14432405f, -0.01208507f, 0.01835212f, -0.08180578f, 
    -0.47283816f, -0.23484148f, 0.06283256f, 0.31042883f, 0.16085178f, -0.22270197f, -0.00494031f, 0.06252722f, 
    0.09432513f, 0.04568800f, -0.11547919f, 0.09287278f, -0.24218559f, 0.10135851f, 0.02069412f, 0.05812632f, 
    0.17534053f, 0.05768046f, 0.03228927f, 0.14097556f, 0.02864458f, 0.04794665f, -0.00842260f, -0.07407314f, 
    -0.26376501f, -0.06183647f, 0.06506550f, -0.05710322f, -0.17623734f, 0.11972594f, 0.22900899f, -0.08904827f, 
    -0.12045147f, 0.05195177f, -0.04747005f, -0.14889477f, -0.13834128f, 0.02472710f, 0.10200991f, 0.07494999f, 
    0.06654073f, 0.05692625f, 0.00167268f, -0.00376532f, 0.09801148f, 0.00819119f, 0.00547335f, -0.02213810f, 
    0.35768208f, 0.20847325f, -0.04755713f, 0.40629223f, 0.07926152f, 0.00804428f, 0.13259819f, 0.17387439f, 
    0.12578687f, -0.06875978f, -0.01035362f, -0.09089030f, -0.05209265f, 0.08315698f, 0.09970208f, -0.06775921f, 
    0.03238974f, -0.03537704f, 0.03427058f, -0.21844555f, -0.02218262f, -0.04113515f, -0.06580417f, -0.06728301f, 
    -0.03318419f, 0.29405916f, -0.07512440f, -0.36586827f, -0.07029441f, -0.14542650f, -0.00164886f, 0.06011095f, 
    -0.14318031f, -0.08643926f, 0.02991512f, -0.19616562f, 0.10288806f, 0.04235935f, -0.08852448f, -0.11837136f, 
    -0.02679491f, -0.09561185f, 0.00016020f, 0.03979835f, 0.08374804f, 0.07196639f, 0.07170988f, 0.17411380f, 
    0.29750919f, -0.24517342f, -0.11750375f, -0.11425999f, 0.07004687f, -0.10029686f, -0.06064567f, 0.04527796f, 
    0.16918834f, -0.01791947f, -0.09323619f, 0.15262797f, -0.02383828f, -0.23053886f, 0.09522214f, 0.14790435f, 
    0.03145264f, 0.17629984f, -0.04433926f, 0.23888060f, 0.05736819f, -0.27318808f, 0.05180570f, 0.10172641f, 
    0.35731071f, 0.05786924f, 0.13534473f, -0.01295599f, 0.09237035f, 0.04561491f, -0.05922303f, 0.08183284f, 
    0.01509743f, 0.00173270f, -0.03434751f, 0.11085655f, 0.19006254f, 0.35085055f, -0.04353808f, 0.14205921f, 
    -0.04959447f, -0.02062504f, 0.01885593f, 0.03213466f, -0.04829562f, -0.25742683f, -0.00317798f, -0.23567946f, 
    -0.00103455f, 0.11808471f, -0.06416904f, -0.08236901f, -0.08799642f, -0.21843424f, 0.06721660f, 0.02092046f, 
    0.00577133f, 0.05579426f, 0.17319524f, -0.10191429f, 0.16165559f, 0.08020723f, 0.14499824f, 0.24449593f, 
    0.07161773f, -0.05562301f, 0.16051579f, 0.18720639f, -0.00832717f, 0.05088628f, 0.03341174f, -0.01018889f, 
    -0.33526903f, -0.10208476f, 0.07340934f, 0.16969110f, -0.12314276f, 0.06297205f, 0.10581571f, 0.04466123f, 
    0.11807901f, -0.03030010f, -0.00320913f, -0.04246885f, -0.08406108f, -0.01793722f, -0.26020095f, -0.02168974f, 
    -0.02955866f, -0.07935263f, 0.03886949f, -0.15151775f, -0.20052151f, -0.24233240f, -0.17552683f, -0.00386932f, 
    -0.08900308f, -0.16296044f, 0.21653590f, 0.21755561f, 0.02431095f, 0.01864461f, 0.05650127f, 0.18223046f, 
    -0.01300213f, 0.18176679f, 0.01190368f, 0.12795384f, -0.10423448f, -0.04431166f, 0.09169704f, -0.26627573f, 
    0.00145692f, -0.04997874f, -0.08455050f, -0.02502564f, -0.14211951f, 0.03264352f, 0.07463586f, -0.01825879f, 
    0.06898749f, 0.09157535f, 0.22843756f, 0.10268044f, 0.11257245f, 0.11622062f, 0.06666610f, -0.01287889f, 
    0.02629667f, -0.14953259f, -0.12287480f, 0.01175745f, -0.15091757f, -0.09126851f, -0.22778997f, 0.06185796f, 
    -0.01408202f, 0.03521777f, -0.07400192f, 0.06378290f, -0.08439022f, 0.00218073f, 0.04586106f, 0.01491457f, 
    -0.14637703f, 0.03781392f, -0.15508330f, -0.06077985f, -0.14489909f, 0.02835233f, 0.15798138f, 0.11138392f, 
    0.04120526f, 0.09777745f, -0.02214391f, 0.11763059f, 0.22764112f, 0.03114532f, -0.03811523f, -0.22481315f, 
    0.06287387f, -0.04317911f, 0.13960055f, -0.07541423f, 0.08436588f, -0.10890287f, -0.02074018f, 0.07274497f, 
    0.27633885f, 0.28851846f, 0.04416893f, 0.15392342f, 0.12987807f, 0.00063896f, -0.03346124f, 0.10965735f, 
    -0.12747066f, 0.00266637f, -0.02401366f, 0.00758528f, -0.13139845f, 0.05988080f, -0.19159557f, -0.12460620f, 
    -0.10465728f, 0.05843640f, 0.03347787f, 0.06837980f, -0.09714636f, -0.05687410f, -0.04030653f, -0.04199135f, 
    -0.10725299f, 0.33849201f, -0.11869956f, -0.13764825f, -0.07345511f, 0.05582798f, 0.17405877f, 0.03902123f, 
    -0.11892905f, 0.00919249f, 0.05286391f, 0.06526350f, 0.18830401f, -0.22271407f, -0.12992218f, -0.26157433f, 
    -0.09743096f, -0.04073923f, 0.06295165f, 0.00818722f, -0.00497784f, 0.12998742f, 0.10499831f, 0.02368864f, 
    0.05588848f, -0.03739511f, -0.08364262f, 0.17354764f, -0.02258870f, 0.15114817f, -0.00643642f, 0.06434260f, 
    -0.00250518f, -0.05410422f, 0.00603777f, -0.10333999f, -0.20232412f, 0.09227891f, -0.15383202f, -0.00306996f, 
    0.16517963f, -0.03456267f, -0.14090799f, 0.03696488f, -0.08276734f, -0.00155741f, -0.07866143f, -0.19613694f, 
    -0.25388503f, 0.08494493f, 0.09275236f, -0.17488457f, 0.01696734f, -0.07389595f, -0.09829542f, -0.06008440f, 
    0.03473327f, -0.07356547f, -0.06375953f, -0.12445903f, 0.21014619f, -0.14940491f, 0.11338315f, -0.02265544f, 
    0.05754263f, -0.07814099f, 0.07654157f, 0.00251823f, -0.11448964f, 0.13088508f, -0.08196965f, -0.11351401f, 
    -0.07609048f, 0.05070269f, 0.08269326f, 0.07635859f, 0.07799485f, 0.01442665f, -0.02573840f, 0.09536432f, 
    0.07202840f, 0.13765568f, -0.19464007f, -0.07003183f, 0.21616668f, 0.04323677f, 0.09118595f, 0.31322542f, 
    -0.00413187f, -0.11765550f, 0.13459219f, 0.02828240f, -0.07370113f, -0.01625126f, -0.13047108f, 0.18795073f, 
    -0.44884303f, 0.04948707f, 0.09957360f, 0.22429864f, 0.04351021f, 0.02137350f, 0.21446683f, 0.24982849f, 
    -0.00915363f, 0.17337582f, 0.11510393f, 0.03845916f, 0.36662805f, 0.34845573f, 0.23962316f, 0.16775689f, 
    -0.08927661f, -0.01701496f, 0.13253696f, 0.05429571f, -0.02387537f, -0.02419090f, 0.04262646f, -0.07243392f, 
    -0.30301109f, -0.20655140f, -0.00285177f, 0.16910830f, 0.04897109f, 0.04275535f, 0.11112010f, 0.05930291f, 
    0.05002883f, 0.09792297f, -0.01089467f, -0.00468451f, -0.19526242f, -0.05472127f, 0.13774259f, -0.04922237f, 
    0.12870482f, 0.09919003f, -0.09944014f, -0.10594998f, 0.25551853f, 0.13696212f, -0.09370049f, -0.04408557f, 
    0.07060692f, 0.02553250f, -0.26236439f, -0.11662717f, 0.08117308f, 0.06289024f, -0.03444879f, 0.02227741f, 
    0.08065631f, 0.05617232f, 0.10822167f, -0.07425056f, 0.04972157f, 0.32674733f, -0.13324501f, 0.05401795f, 
    0.02156050f, -0.07373560f, 0.05178371f, 0.03585375f, 0.07636861f, 0.03702691f, 0.10525940f, 0.03062188f, 
    0.02739169f, -0.32701206f, 0.20811044f, -0.03405094f, -0.07716530f, -0.01334107f, -0.13288325f, -0.08190019f, 
    0.08456090f, -0.10292228f, 0.02993778f, -0.00216451f, 0.24998830f, 0.10422881f, 0.04415276f, 0.17096855f, 
    0.04307785f, -0.02460984f, -0.04516889f, 0.02003450f, 0.01396358f, 0.12360700f, 0.03908725f, -0.20000392f, 
    -0.01239756f, -0.18881090f, 0.08413116f, -0.04550446f, -0.17367128f, -0.18122682f, -0.02672698f, -0.18622391f, 
    0.08000118f, 0.03891687f, 0.02239761f, 0.00428574f, 0.38516432f, -0.00917831f, 0.03519303f, 0.28279948f, 
    0.02852035f, 0.18185428f, 0.08833754f, 0.02602676f, -0.01709642f, -0.08337267f, -0.03105170f, -0.02368078f, 
    0.12650047f, 0.06115576f, -0.27097395f, -0.16891703f, -0.00059475f, 0.01439498f, 0.16013074f, -0.15075020f, 
    0.13304697f, -0.04779808f, -0.03731719f, 0.06780811f, -0.20179838f, -0.04410307f, 0.23879722f, -0.23144318f, 
    -0.02368480f, 0.05630223f, -0.01040044f, 0.17331325f, 0.05031634f, 0.07426883f, 0.13284481f, 0.08885582f, 
    0.17753202f, -0.15679383f, -0.19531649f, 0.18824905f, 0.10646523f, -0.04418188f, -0.21334523f, -0.05000091f, 
    0.08197476f, 0.17310181f, 0.03133240f, 0.04100725f, -0.29588601f, 0.15840127f, 0.15138485f, -0.14301722f, 
    0.08106615f, -0.17421000f, 0.05726074f, 0.10488608f, 0.11519847f, -0.02818788f, 0.11721758f, 0.08728022f, 
    0.17768286f, 0.00973382f, -0.20736006f, -0.10642503f, 0.00429512f, -0.04560100f, 0.01475859f, 0.04063711f, 
    -0.06968998f, -0.14481452f, 0.07640480f, 0.02092751f, 0.12826321f, 0.07009330f, -0.02739188f, -0.03618035f, 
    -0.06408479f, -0.07009622f, -0.05784296f, -0.13158382f, -0.00568020f, 0.10749505f, 0.08535854f, 0.06544811f, 
    0.32768589f, -0.18891266f, 0.03695800f, 0.07284628f, -0.14352182f, -0.10874683f, 0.03517341f, 0.13934484f, 
    -0.00674533f, 0.05674270f, 0.06698412f, 0.05483288f, -0.27320647f, -0.01426501f, -0.03242105f, -0.22438480f, 
    0.24032438f, -0.24719772f, 0.06188804f, -0.21144421f, 0.09764028f, 0.16847602f, 0.10123227f, -0.08715042f, 
    0.16648677f, 0.16428585f, 0.01226720f, -0.22795469f, 0.01784579f, -0.07264081f, 0.06126841f, -0.02165180f, 
    0.09658401f, -0.03638674f, 0.00405913f, 0.01959694f, 0.00804604f, 0.13319056f, -0.22899480f, -0.40170565f, 
    0.15292232f, 0.08102450f, 0.04750384f, 0.05248766f, 0.21987756f, -0.01918244f, -0.01096254f, 0.03210857f, 
    0.09494152f, -0.09731148f, -0.02545891f, 0.22889064f, -0.01328633f, -0.02043530f, -0.09483705f, 0.11034218f, 
    -0.03265059f, 0.01932893f, 0.10621610f, -0.00764956f, 0.04553264f, 0.02235172f, -0.03845021f, 0.13343076f, 
    0.08580628f, -0.16431755f, 0.04292248f, 0.07265226f, -0.09876791f, 0.01013507f, 0.05090959f, 0.04595877f, 
    -0.06356041f, 0.21757168f, -0.06662975f, 0.04112811f, -0.07353817f, 0.00057500f, -0.11898211f, 0.07299399f, 
    0.00477193f, 0.10153134f, -0.03815806f, 0.02305317f, 0.49325249f, -0.26990014f, -0.11116902f, 0.18196550f, 
    -0.00551901f, 0.06967573f, -0.01350646f, 0.03720827f, 0.04005986f, -0.08574517f, -0.08693006f, 0.10389385f, 
    0.12007649f, -0.22607727f, -0.17513819f, 0.06556185f, 0.11899646f, 0.04043023f, 0.00338710f, 0.02541857f, 
    -0.01851613f, 0.00273067f, 0.13426270f, 0.00694322f, -0.00623896f, -0.05097343f, -0.04601036f, -0.00723466f, 
    -0.05855250f, -0.10069545f, -0.03522528f, 0.03845280f, 0.03048142f, -0.05256372f, -0.08505757f, 0.06025014f, 
    -0.04125398f, -0.13087726f, -0.16790189f, -0.12975381f, -0.03078179f, 0.14408995f, -0.03395795f, -0.03582156f, 
    0.17725495f, 0.08972648f, -0.07448887f, 0.01354427f, -0.03847614f, -0.13589086f, -0.25238192f, 0.04040027f, 
    0.11740954f, -0.09970209f, -0.08667964f, 0.16686787f, 0.01133015f, -0.02838239f, 0.02185042f, -0.00589489f, 
    -0.06265225f, -0.00327839f, 0.05235543f, 0.29222792f, 0.13224758f, 0.01725881f, -0.04695671f, 0.07609323f, 
    0.09732018f, 0.11237731f, 0.10303979f, 0.08988831f, 0.18543231f, -0.21974872f, 0.07252280f, 0.22747393f, 
    0.01232578f, 0.07562577f, 0.00629991f, 0.04332982f, -0.06461455f, -0.02081306f, -0.00693903f, 0.14959161f, 
    0.04133365f, 0.04598644f, 0.09043396f, -0.10658753f, -0.02321533f, -0.04905883f, 0.08187200f, -0.04314614f, 
    -0.05932339f, -0.00701419f, 0.00773514f, -0.05353031f, -0.15295300f, -0.09388633f, -0.08652206f, -0.14138651f, 
    -0.08466869f, 0.03077468f, 0.02513841f, -0.03453674f, -0.09985761f, 0.05095196f, -0.01182216f, -0.12850447f, 
    -0.21600756f, -0.03819348f, -0.18062633f, 0.05110243f, 0.07604247f, -0.00507534f, -0.06456313f, -0.04483654f, 
    0.00670922f, -0.03509830f, -0.09288774f, 0.04876829f, 0.32159194f, 0.14459883f, 0.30565453f, 0.03481395f, 
    0.02292646f, 0.04567100f, -0.12886547f, -0.08875164f, 0.05334936f, 0.00731806f, 0.10873573f, 0.00195790f, 
    0.07841823f, 0.39626625f, -0.01016532f, -0.13000311f, 0.14773975f, 0.00202507f, 0.08447681f, 0.09503504f, 
    -0.06303176f, -0.05627762f, 0.01669916f, 0.08297461f, 0.16531280f, 0.17203291f, -0.19597138f, 0.01923932f, 
    0.09965621f, 0.09611143f, 0.04222275f, 0.00133524f, 0.05593696f, 0.00603239f, -0.20177233f, -0.03958027f, 
    0.03707177f, -0.05144947f, -0.08570278f, 0.17782383f, 0.11791049f, 0.04923737f, 0.14239511f, 0.02382708f, 
    -0.00016525f, 0.06301565f, -0.05865505f, 0.03512187f, 0.05134261f, 0.18925802f, -0.12707184f, -0.04950802f, 
    0.06162599f, 0.09579484f, -0.03029533f, 0.05359370f, 0.00989597f, -0.01410555f, 0.09970653f, -0.07997984f, 
    -0.14413239f, -0.62299782f, 0.01949268f, -0.09048729f, -0.10392407f, -0.03218568f, -0.05108210f, -0.01080771f, 
    -0.05616294f, 0.05460331f, -0.17235109f, -0.09895356f, 0.05225628f, 0.01710765f, -0.02759150f, -0.02555117f, 
    0.02520409f, 0.09134095f, -0.03396131f, -0.04465266f, -0.05390610f, 0.14619258f, 0.03839603f, 0.09897688f, 
    0.06730966f, -0.11087349f, 0.21372005f, 0.16897166f, -0.08486458f, 0.04830150f, -0.15201850f, -0.16017798f, 
    0.20683418f, 0.04736956f, 0.06072248f, -0.09695321f, 0.19458622f, -0.12096363f, 0.04225264f, 0.04917662f, 
    -0.03042006f, 0.09951932f, 0.10572328f, 0.09481299f, 0.02342837f, -0.05647098f, -0.15406550f, 0.05210130f, 
    0.13798915f, 0.04205116f, -0.04292544f, 0.22414023f, -0.06408903f, 0.18553524f, 0.04428494f, 0.03353272f, 
    0.09082010f, -0.02273740f, 0.01502872f, -0.04574531f, -0.05911980f, 0.14064962f, 0.06743030f, -0.11024500f, 
    0.13454735f, -0.00853862f, 0.00122255f, 0.19270733f, -0.04959299f, -0.09463846f, 0.02981647f, 0.01381307f, 
    0.05067014f, -0.07324643f, -0.07504751f, -0.02714642f, 0.18699585f, -0.02441779f, 0.00505408f, 0.01474177f, 
    0.10432024f, 0.14162077f, 0.14395769f, 0.04853925f, -0.17370130f, 0.28110430f, -0.05621063f, -0.01487711f, 
    0.03676721f, -0.15542185f, 0.09151459f, 0.10721651f, 0.12176356f, -0.09913871f, -0.01397036f, -0.09019323f, 
    0.19470640f, -0.13661273f, 0.00874512f, -0.06808802f, 0.01403836f, -0.12641983f, 0.08234822f, -0.01321027f, 
    -0.04772731f, -0.00270967f, 0.02643831f, 0.01730883f, -0.09443440f, 0.05272908f, 0.15747601f, 0.10074545f, 
    0.03985430f, 0.07642983f, -0.10699507f, -0.00667045f, 0.01363340f, 0.12643698f, -0.05736564f, 0.12048186f, 
    0.67872357f, 0.01313500f, 0.01012668f, 0.09848195f, -0.13655412f, 0.01516295f, 0.01693523f, 0.06296568f, 
    -0.01151311f, 0.05813285f, 0.02238796f, 0.06572494f, -0.28526506f, -0.00072351f, -0.17115282f, -0.02701596f, 
    -0.02286554f, -0.20994766f, -0.06300525f, 0.11589457f, -0.07145289f, 0.01720711f, -0.03731489f, -0.15574688f, 
    0.12365180f, 0.11424953f, -0.06780000f, -0.07007173f, 0.09890204f, -0.17025641f, 0.03190921f, -0.09708945f, 
    0.02840373f, -0.01170767f, -0.14269766f, 0.05180261f, -0.00441714f, -0.02940816f, -0.14129238f, -0.15657234f, 
    0.20292133f, 0.01759931f, 0.15909536f, 0.02875897f, 0.06021971f, 0.11686254f, -0.02985457f, -0.07531362f, 
    -0.04597223f, -0.14992759f, -0.03053586f, -0.21088435f, -0.04061214f, 0.06339850f, 0.01619917f, 0.04711127f, 
    -0.00225689f, -0.00594193f, -0.17023778f, 0.02123359f, 0.04548820f, -0.12488082f, -0.10360767f, -0.17829418f, 
    0.04665177f, 0.11161106f, 0.08286084f, -0.13553165f, -0.14705478f, -0.01656516f, 0.03390982f, -0.07430299f, 
    0.00539183f, 0.19460399f, -0.03317435f, 0.16050114f, -0.13398317f, -0.06437413f, -0.13985078f, 0.06873542f, 
    -0.04566758f, 0.11251066f, -0.05252536f, -0.03784705f, 0.28209877f, -0.19900629f, 0.10034284f, 0.20132522f, 
    0.04574702f, -0.02738750f, -0.01897117f, 0.01875708f, 0.02726747f, 0.04465452f, -0.10707668f, -0.02805478f, 
    -0.00170942f, -0.00352626f, -0.06518514f, -0.06962761f, -0.02344371f, 0.03118153f, 0.11937752f, -0.02702631f, 
    -0.03996596f, 0.00008037f, 0.13214816f, 0.05132592f, -0.14501883f, -0.22702602f, -0.03945028f, -0.13715483f, 
    -0.01129668f, 0.02527967f, -0.08163141f, 0.12637697f, 0.05008657f, 0.02051840f, -0.01159147f, -0.05018291f, 
    0.17895856f, 0.11150054f, 0.04930079f, 0.05176537f, 0.14650798f, 0.08100300f, -0.04915242f, 0.06883507f, 
    -0.06992239f, 0.01079644f, -0.00151100f, -0.00920198f, -0.14153029f, -0.06997107f, -0.03936769f, 0.13949345f, 
    -0.03861764f, 0.11548368f, -0.04398077f, 0.11858502f, 0.06403581f, 0.01312947f, -0.02494260f, -0.19260794f, 
    0.38302600f, 0.20260122f, -0.04930637f, 0.00720729f, 0.05442142f, -0.11115202f, 0.08813121f, -0.03236397f, 
    0.03733497f, 0.03399650f, 0.06613745f, 0.05793303f, 0.57844424f, 0.06838083f, 0.02427567f, 0.15714964f, 
    -0.11974134f, 0.04110345f, 0.04567097f, 0.01885217f, -0.16301337f, -0.09236173f, 0.12826417f, -0.00612375f, 
    -0.00874493f, 0.03451477f, -0.16082041f, 0.00368717f, 0.07505683f, 0.00088918f, 0.06727210f, -0.04424421f, 
    -0.05045405f, -0.04802378f, -0.02921387f, -0.14023224f, 0.11347195f, -0.00431090f, -0.05055833f, 0.11539615f, 
    -0.08259050f, 0.06293494f, -0.00657400f, -0.03312468f, -0.09888951f, 0.06183683f, -0.23295364f, -0.06006561f, 
    -0.20006976f, -0.30586299f, 0.01566350f, -0.03952485f, -0.00955391f, -0.06560817f, 0.02178492f, -0.07165186f, 
    -0.00767419f, -0.02049357f, -0.12888782f, -0.03935617f, 0.54901367f, 0.09023480f, 0.22046304f, -0.05493950f, 
    -0.02495857f, -0.15978447f, 0.03960035f, -0.14515856f, 0.07223803f, -0.02473345f, 0.18555297f, -0.05004588f, 
    0.38391808f, 0.23685865f, 0.28261280f, -0.00062419f, -0.08983860f, -0.05432659f, 0.03974365f, 0.15076324f, 
    0.00023861f, -0.06229178f, 0.02416584f, 0.03045403f, 0.12574373f, 0.19037229f, -0.04853649f, -0.07409939f, 
    0.00675000f, 0.07760015f, -0.08952268f, 0.03192512f, 0.09782107f, -0.01294860f, -0.11990412f, -0.07581747f, 
    -0.04214473f, -0.24904434f, -0.06306806f, 0.08965056f, -0.11280121f, 0.14689448f, 0.11423049f, -0.07682619f, 
    -0.10986999f, 0.01548550f, -0.00912010f, -0.02772162f, -0.06528865f, 0.17938279f, -0.09339440f, -0.02880235f, 
    0.00866138f, 0.09016646f, 0.00454565f, 0.07138619f, 0.00230310f, -0.12275359f, 0.00064248f, -0.07662020f, 
    0.45965680f, -0.28741965f, 0.18873128f, -0.11026147f, 0.00291454f, -0.00634495f, -0.03889416f, 0.07787367f, 
    0.09159715f, 0.11736148f, -0.03439152f, 0.02739638f, 0.12913392f, 0.15163979f, 0.05539837f, 0.19842423f, 
    0.01432477f, 0.00353803f, 0.06968210f, 0.06639397f, -0.05308948f, 0.20171012f, 0.12707858f, 0.03468232f, 
    -0.40578791f, 0.05033937f, -0.00375446f, 0.07147381f, 0.06764030f, 0.25388989f, -0.11024521f, -0.07843739f, 
    0.17843270f, -0.06512333f, 0.10602642f, -0.01244298f, -0.11227650f, 0.09844285f, -0.00501864f, -0.04234578f, 
    0.13634206f, 0.13569790f, 0.17373787f, 0.13233876f, -0.03398495f, -0.03545337f, 0.06609044f, 0.09467423f, 
    -0.17049094f, -0.12771916f, -0.06248840f, -0.04521229f, -0.12176676f, 0.04597868f, -0.22238861f, 0.04913559f, 
    0.01370416f, 0.02140908f, -0.03737055f, 0.00921559f, -0.16682066f, 0.05274970f, -0.00973108f, 0.02163386f, 
    0.04285889f, -0.04740919f, -0.00900856f, 0.10633164f, 0.02577172f, -0.09317426f, -0.02554945f, -0.02053386f, 
    0.53217417f, 0.17687201f, 0.08456300f, 0.07332720f, -0.01919607f, -0.12942098f, 0.12645710f, 0.14753835f, 
    0.16557373f, 0.09612650f, 0.17035429f, -0.09444643f, -0.07213874f, -0.00151883f, -0.08937044f, -0.09913988f, 
    -0.05489400f, -0.13557154f, 0.05464962f, 0.03503066f, 0.17534071f, 0.08911916f, 0.04821646f, -0.08603688f, 
    0.18552178f, -0.13817999f, -0.04555908f, -0.07539729f, 0.16044596f, -0.04000567f, 0.07783911f, 0.08906630f, 
    -0.09893833f, -0.03564005f, -0.02586624f, 0.11481562f, -0.06714791f, -0.03792944f, 0.07644553f, 0.09251507f, 
    -0.05555400f, 0.12484089f, -0.07751949f, -0.01054184f, 0.05524209f, -0.07161111f, -0.09257501f, -0.07030513f, 
    -0.09563930f, -0.03853073f, -0.23583122f, -0.04896699f, 0.10527058f, 0.04669632f, -0.03942022f, 0.00841909f, 
    0.05318085f, 0.05309667f, 0.07003356f, 0.21704206f, -0.00130990f, 0.22339058f, -0.02197513f, 0.03048975f, 
    0.07237942f, -0.09487017f, -0.07009548f, -0.09128173f, -0.06692961f, -0.05431533f, 0.01070238f, -0.03539297f, 
    -0.33305356f, -0.17578581f, 0.03433967f, -0.03225922f, -0.09105919f, -0.04691591f, -0.02438906f, 0.05968689f, 
    0.07221568f, -0.10565779f, -0.09548453f, 0.07683237f, -0.20150022f, -0.02715305f, 0.02219550f, -0.08968434f, 
    0.07132048f, 0.02633065f, 0.12284916f, 0.05495312f, 0.05769670f, -0.00568125f, -0.06314471f, 0.00524821f, 
    0.19004476f, 0.16752402f, 0.06819382f, -0.01586025f, 0.03430533f, 0.00554385f, 0.10431217f, 0.08615381f, 
    0.10063807f, 0.12079271f, -0.01668425f, 0.12294846f, 0.39102453f, -0.06662647f, -0.01799789f, -0.04666796f, 
    -0.08966555f, 0.14732417f, 0.19115609f, -0.00663163f, -0.01780352f, 0.01092398f, -0.04564726f, -0.09324258f, 
    0.18855873f, -0.04942618f, -0.03533655f, -0.11401919f, -0.13212208f, 0.13668509f, -0.08065177f, 0.02994812f, 
    -0.03321868f, 0.06228530f, -0.06439187f, -0.03140555f, 0.10721235f, -0.33003718f, 0.07995336f, -0.00698454f, 
    0.00364247f, 0.14492448f, -0.06068022f, -0.02707742f, -0.09875022f, 0.06161540f, 0.01984289f, -0.03902758f, 
    0.09442738f, 0.07138414f, -0.10419369f, 0.13954557f, 0.00704413f, 0.00810133f, 0.18044807f, 0.04834847f, 
    -0.04904630f, 0.10602885f, 0.06975280f, -0.01089817f, -0.08821744f, 0.07744078f, -0.05709125f, 0.00690247f, 
    0.10517590f, -0.00808528f, 0.05379054f, 0.11231706f, 0.12756814f, 0.10956549f, -0.04043927f, 0.07021374f, 
    0.24753968f, 0.13090117f, 0.09739043f, -0.13483270f, -0.07287946f, -0.00331702f, 0.09952301f, 0.04236680f, 
    0.05116901f, 0.03573466f, 0.02374079f, 0.02945595f, -0.13458528f, -0.12088548f, -0.04199625f, 0.01296534f, 
    -0.04539360f, 0.06143313f, -0.09127683f, 0.08499420f, -0.08041693f, -0.04675343f, -0.11317281f, -0.09165026f, 
    0.47422341f, 0.23079838f, 0.20703013f, 0.13126799f, -0.01679505f, -0.03133553f, -0.00435180f, -0.00220034f, 
    0.03621795f, -0.11181541f, -0.02010349f, 0.02459723f, -0.13094459f, -0.02528815f, -0.12243786f, 0.26709521f, 
    -0.03617520f, -0.04469198f, -0.04503735f, 0.08114923f, -0.00155913f, -0.07623297f, -0.01904240f, -0.01097332f, 
    -0.17680724f, -0.03221705f, 0.07769986f, -0.07852478f, -0.01103154f, -0.02763726f, -0.07815972f, 0.02070567f, 
    0.07653331f, 0.00749245f, -0.09294850f, 0.12174170f, 0.02217333f, -0.00590099f, -0.12248349f, 0.00200015f, 
    0.00314214f, -0.12688009f, 0.03465856f, -0.00979852f, 0.00291764f, 0.06204346f, -0.09038042f, -0.02136008f, 
    0.26069331f, -0.10077602f, 0.16960141f, -0.01880007f, 0.00612515f, 0.09241031f, 0.03252171f, -0.03374071f, 
    0.02454680f, 0.11872165f, -0.01029463f, -0.01607596f, -0.02516828f, -0.07434189f, -0.00786453f, 0.00837644f, 
    0.02460192f, -0.06860064f, 0.04312121f, -0.04223558f, -0.02476191f, 0.02371966f, 0.13385276f, -0.02703298f, 
    0.32426533f, -0.02420635f, -0.36730155f, -0.05690393f, -0.17186216f, -0.04461201f, -0.15984806f, -0.14277875f, 
    0.24773401f, 0.10271911f, -0.03366682f, 0.07194937f, 0.11950159f, -0.01774471f, 0.10242041f, 0.40939692f, 
    -0.10373240f, -0.04447234f, 0.07372627f, 0.03359630f, -0.02440519f, -0.07153980f, 0.06180590f, 0.08119940f, 
    0.24777782f, 0.15075129f, 0.00643622f, 0.23156632f, 0.10652429f, 0.07486612f, -0.04345625f, 0.00292106f, 
    0.03681819f, 0.10229865f, 0.02527470f, -0.08787588f, -0.60000592f, 0.09123832f, -0.01036456f, -0.00979268f, 
    0.04287443f, 0.06102381f, -0.06416024f, 0.08117473f, 0.04799265f, -0.04200916f, 0.03121191f, -0.00592829f, 
    -0.09717561f, -0.07627875f, 0.05431249f, 0.24655442f, -0.02007603f, 0.10784096f, -0.01196702f, -0.08941714f, 
    0.11461852f, -0.07304146f, -0.06513064f, 0.09456120f, -0.35701212f, -0.11441024f, -0.00697882f, -0.12664519f, 
    -0.03280109f, -0.05905249f, -0.01050020f, 0.06437194f, 0.05773112f, -0.08579732f, -0.17030044f, -0.09279992f, 
    -0.49580109f, 0.06085425f, 0.10008828f, -0.20231077f, 0.10505559f, -0.02161420f, 0.12604418f, 0.18688914f, 
    -0.12048986f, 0.02045940f, -0.06252541f, -0.03984760f, -0.41946179f, -0.00466576f, -0.06061100f, -0.16636376f, 
    0.02160589f, -0.05146471f, 0.03068974f, -0.00541117f, -0.02253978f, -0.00756181f, 0.06531821f, -0.03912341f, 
    0.27142337f, 0.23209094f, 0.21097438f, 0.23809902f, 0.02285457f, -0.02252944f, -0.03781427f, 0.12508231f, 
    0.03439795f, -0.01705385f, -0.17331885f, 0.10122978f, 0.25044036f, 0.12597927f, -0.05577285f, 0.18337083f, 
    0.03322551f, -0.04029493f, -0.10383285f, -0.11343932f, 0.09902796f, 0.04916634f, -0.09128569f, 0.04568652f, 
    0.09267878f, -0.20106210f, 0.02531922f, 0.31117946f, -0.12632750f, 0.10556499f, 0.14443637f, -0.07280210f, 
    -0.03622610f, -0.13010539f, -0.21607526f, 0.04568415f, 0.07442291f, 0.03592180f, 0.08979843f, 0.25954807f, 
    -0.10928730f, 0.13814703f, -0.13429385f, -0.13351145f, -0.01403918f, 0.03500437f, 0.00903984f, -0.04670636f, 
    -0.08073762f, -0.19670047f, -0.04811193f, 0.12269284f, -0.08095268f, 0.10254750f, -0.12548740f, 0.02506296f, 
    0.03750649f, 0.10049624f, -0.12177263f, -0.03969811f, -0.29793805f, 0.08898742f, -0.02185096f, -0.01510830f, 
    -0.04122310f, 0.04477177f, 0.20423253f, 0.08759648f, 0.05313670f, -0.06477132f, 0.02959542f, 0.03145690f, 
    -0.45032531f, 0.19206768f, -0.07838018f, -0.00117257f, 0.19517338f, 0.08125970f, 0.09465623f, -0.08652851f, 
    -0.14696120f, -0.05334055f, 0.05423552f, -0.04723815f, -0.13508956f, -0.07108605f, 0.29415014f, 0.12410197f, 
    -0.15614121f, 0.08777228f, -0.04292778f, 0.18470137f, -0.00423660f, -0.05025588f, 0.01970315f, 0.02296301f, 
    0.24883425f, 0.18954837f, 0.10471581f, 0.32214472f, 0.11159304f, -0.02482409f, -0.04119388f, 0.15639456f, 
    0.06556518f, -0.03417897f, 0.13494194f, 0.09828863f, 0.24664909f, 0.12614484f, 0.09802415f, 0.69868451f, 
    -0.05299653f, -0.11226714f, -0.07575447f, 0.04568011f, 0.03532002f, 0.14723296f, -0.08588444f, -0.00857024f, 
    -0.08196915f, -0.06467900f, -0.02523914f, -0.20460327f, 0.01332977f, -0.09419965f, -0.06022417f, -0.09289774f, 
    -0.04478346f, -0.00574322f, 0.05706178f, 0.04379036f, -0.10769111f, -0.11120525f, 0.05364808f, -0.07099911f, 
    -0.14253958f, 0.05074264f, -0.12479759f, 0.17326820f, 0.21267249f, 0.08778182f, 0.04259804f, 0.11763508f, 
    -0.11528450f, 0.01034753f, 0.12841031f, 0.15967563f, 0.14502609f, 0.10854977f, 0.10372938f, 0.01609756f, 
    0.16597076f, -0.06860262f, 0.03208449f, 0.01244240f, 0.11045630f, 0.18410121f, 0.03670667f, -0.17069153f, 
    -0.07536536f, 0.02071338f, 0.00818654f, -0.01827052f, 0.01039603f, -0.01672975f, 0.12332489f, 0.06801204f, 
    0.25258982f, 0.00539423f, -0.02135469f, -0.04231071f, -0.02558173f, -0.07183123f, -0.08085638f, 0.01837623f, 
    0.08371302f, 0.00703195f, -0.09894448f, 0.03348104f, -0.30537727f, -0.03687725f, 0.22962733f, -0.06553760f, 
    -0.04777952f, 0.11663121f, -0.11725098f, -0.05834684f, 0.01250580f, -0.03772564f, -0.03488623f, -0.11202291f, 
    0.29120162f, -0.02709943f, -0.03411145f, 0.14584367f, -0.02740872f, -0.04648490f, -0.01824107f, -0.07677327f, 
    -0.04225589f, 0.07568261f, -0.05502190f, 0.02413876f, 0.12327696f, -0.05486625f, 0.12344973f, 0.02001995f, 
    -0.06019427f, 0.00680849f, -0.05566445f, -0.03006640f, 0.00442398f, -0.08993663f, -0.10692023f, 0.00292394f, 
    -0.03148764f, -0.33886218f, 0.05046074f, 0.28485233f, -0.12681863f, 0.10230290f, -0.06635332f, -0.05750672f, 
    -0.01844696f, -0.02638481f, -0.01264151f, -0.01891311f, -0.44294775f, 0.35063672f, 0.07126369f, -0.23106135f, 
    0.20262353f, -0.02700862f, 0.08378363f, 0.00950374f, 0.01261526f, -0.00283735f, -0.06148169f, -0.09080943f, 
    -0.12762623f, -0.01638856f, 0.17812438f, 0.24815780f, -0.01175181f, 0.04766487f, -0.02400096f, 0.08321955f, 
    0.04583799f, -0.05949081f, 0.24551211f, 0.09052925f, 0.33611292f, 0.21132009f, 0.13035031f, 0.29425037f, 
    0.14446016f, 0.12760708f, 0.19158863f, 0.12279368f, 0.08753202f, -0.07696074f, 0.29247868f, 0.09451333f, 
    0.04935957f, 0.37625182f, -0.00438380f, 0.03442346f, -0.05084202f, -0.10363143f, -0.00459241f, 0.04531300f, 
    0.03930109f, -0.07236248f, -0.02205513f, 0.01924466f, -0.03189780f, 0.09256547f, -0.06634458f, 0.26511320f, 
    0.00796013f, 0.07306767f, -0.03414117f, 0.11504563f, -0.03985116f, 0.13034946f, -0.01221087f, 0.04252171f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03716998f, 0.01689071f, 0.01265986f, 0.10545586f, -0.02198221f, 0.03944926f, 0.01528062f, -0.04728336f, 
    0.15185590f, 0.00757703f, -0.02866821f, -0.04492160f, -0.03566817f, -0.02762837f, 0.06372057f, 0.03429089f, 
    0.07777047f, 0.03924494f, -0.05267471f, -0.05730332f, 0.01149344f, -0.00957208f, -0.00363943f, 0.02772908f, 
    0.04127904f, 0.02383497f, 0.01286634f, 0.03218119f, -0.00581623f, 0.03208257f, -0.03668510f, 0.00022792f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.51257724f, 0.16759792f, 0.16291527f, -0.26914871f, -0.02556059f, 0.10152899f, -0.59272999f, 0.12547404f, 
    -0.32780507f, -0.14394742f, 0.11091018f, 0.09775890f, 0.14672562f, 0.05351151f, -0.73892409f, -0.08485356f, 
    0.25117922f, 0.28010586f, -0.05010806f, 0.31159687f, 0.08174755f, 0.41129395f, -0.13293189f, -0.03183350f, 
    0.22073279f, -0.02536252f, -0.25567660f, -0.40943646f, -0.19312467f, -0.17701118f, 0.27190319f, -0.29511589f, 
    -0.68854642f, -0.07503848f, 0.28006315f, 0.02449871f, -0.01957129f, 0.10191217f, -0.03263708f, -0.03343961f, 
    0.30262560f, -0.05716076f, 0.08550395f, 0.11915363f, 0.14886571f, 0.00085710f, -0.00289586f, 0.14628711f, 
    0.08310303f, -0.48097509f, 0.06021858f, 0.00051919f, 0.14462918f, -0.54379463f, 0.16882740f, 0.09423032f, 
    0.39469782f, 0.08112098f, 0.06647030f, -0.06093592f, 0.24934326f, 0.21025886f, 0.25566748f, -0.28390741f, 
    -0.11083703f, -0.07826738f, -0.38384131f, -0.17845029f, 0.00853977f, -0.15155759f, 0.43875441f, 0.08259852f, 
    -0.22065717f, -0.01343365f, 0.10715938f, 0.07255556f, -0.07697255f, -0.00567701f, 0.38310128f, -0.15156426f, 
    -0.16264468f, -0.46363726f, 0.29263896f, 0.19707233f, 0.13952231f, 0.22985236f, 0.04169083f, -0.12004385f, 
    0.02831154f, 0.01710012f, -0.53613377f, 0.13380776f, 0.23066853f, 0.43996719f, 0.19794284f, -0.71044421f, 
    0.09777598f, -0.00553610f, 0.25976604f, 0.21101786f, -0.15825608f, -0.12337917f, 0.10467236f, 0.13601737f, 
    -0.64679915f, -0.13154414f, -0.09512843f, 0.12899171f, 0.12113085f, -0.16354738f, -0.06222812f, 0.13624892f, 
    0.22706500f, -0.43635786f, -0.63306183f, -0.49994844f, 0.03196782f, 0.14656867f, -0.03041738f, 0.00692182f, 
    0.30032378f, 0.06388085f, -0.71464813f, -0.11880006f, 0.04493607f, -0.12084997f, -0.27259329f, 0.34196392f, 
    -0.04819448f, -0.03574738f, -0.27146435f, -0.38534948f, 0.07529232f, 0.11681043f, -0.02290272f, -0.16032283f, 
    -0.29077771f, 0.16057067f, -0.04739218f, 0.12755743f, 0.11020830f, -0.07002665f, 0.14539452f, -0.15666124f, 
    -0.24279901f, 0.33906096f, 0.33508623f, -0.18705530f, -0.08196911f, 0.20354284f, 0.12811968f, -0.05910642f, 
    0.38401172f, -0.01720513f, 0.26944920f, 0.31305042f, -0.00490556f, -0.53121644f, 0.08872459f, 0.17127769f, 
    -0.18603085f, 0.14078641f, 0.35422969f, 0.11331636f, -0.16855516f, -0.01704875f, 0.22557969f, 0.00398376f, 
    0.49984509f, 0.07814606f, -0.16210526f, -0.08142189f, -0.09697538f, -0.00550905f, -0.40705255f, 0.09923025f, 
    -0.21936616f, 0.06738192f, 0.09574397f, 0.02061882f, 0.00241595f, 0.17154106f, -0.02155367f, 0.16949394f, 
    -0.18725407f, 0.15552506f, 0.18337390f, -0.79722065f, -0.51235116f, -0.37487218f, 0.01580244f, 0.32177359f, 
    0.28273058f, 0.00852869f, 0.45271042f, -0.59904236f, -0.13304342f, -0.05201679f, 0.15667440f, -0.14071159f, 
    0.07137740f, -0.03445382f, -0.14175346f, -0.06339205f, 0.08811568f, 0.00475940f, 0.42845765f, -0.16456315f, 
    -0.28432932f, 0.19572622f, -0.39231047f, -0.44919184f, 0.04159806f, 0.07521822f, 0.04135191f, -0.01915778f, 
    -0.51432669f, -0.12263551f, 0.23338225f, 0.19428436f, 0.10704488f, 0.15317462f, 0.19379424f, -0.55601823f, 
    0.31657478f, -0.14672971f, -0.30109048f, 0.05499750f, -0.18287513f, 0.00527650f, -0.47302765f, 0.01959569f, 
    -0.26070365f, 0.03915291f, -0.00643455f, 0.11473847f, 0.13106880f, 0.14785053f, -0.14318898f, 0.16374624f, 
    -0.11960440f, -0.08623791f, 0.38185266f, -0.16671008f, -0.01248762f, 0.10200366f, 0.12274879f, 0.15689445f, 
    -0.58708656f, 0.12330068f, 0.23560977f, 0.47608486f, -0.26541775f, 0.16450471f, -0.46401203f, 0.25473127f, 
    0.18944541f, 0.12045169f, 0.19623730f, 0.30379495f, 0.06876250f, -0.01058984f, -0.22099145f, 0.13433868f, 
    0.09313879f, 0.05646074f, -0.02770787f, 0.03933742f, 0.06107210f, 0.04953752f, -0.11784451f, -0.15609735f, 
    -0.05524410f, -0.13239065f, 0.38760006f, 0.38704696f, -0.04834957f, -0.44872057f, -0.07743295f, 0.11211915f, 
    -0.38717803f, -0.17230776f, 0.08747199f, -0.55338991f, 0.42830309f, -0.39040488f, -0.25781727f, -0.23484309f, 
    0.12131514f, 0.03571898f, -0.46495029f, -0.06860786f, -0.08926998f, 0.07453302f, 0.57501280f, -0.04825130f, 
    -0.12371004f, -0.04113749f, -0.10247289f, -0.13159482f, 0.15659037f, -0.01273422f, -0.24417238f, -0.06281999f, 
    0.42301223f, 0.09929150f, -0.56748927f, 0.36709845f, 0.04912903f, -0.13308509f, 0.12083926f, -0.11347888f, 
    -0.24502303f, 0.05354119f, 0.33876604f, -0.05726780f, -0.42949602f, -0.30939353f, -0.15962344f, -0.45865190f, 
    -0.09526112f, 0.13086011f, -0.59090543f, 0.35619453f, 0.12108067f, 0.09066926f, -0.36953920f, 0.02588946f, 
    0.63729185f, -0.01757650f, -0.10263554f, -0.10308812f, -0.16073532f, -0.14714338f, 0.31069094f, -0.10739416f, 
    0.25303462f, -0.43592402f, -0.26984996f, -0.73667186f, -0.16490783f, 0.05954603f, -0.10602563f, 0.16600293f, 
    0.00217618f, 0.15273558f, 0.18844515f, -0.13102052f, 0.31126878f, 0.30208889f, -0.40091562f, -0.23572206f, 
    -0.09912058f, 0.05301265f, 0.05948526f, 0.33203956f, -0.18664674f, -0.05137518f, -0.42985162f, 0.04178650f, 
    -0.10094771f, 0.07575773f, 0.12573990f, 0.12055469f, -0.14527717f, 0.07235461f, 0.39406139f, 0.16613252f, 
    -0.29226047f, 0.46773690f, -0.64233387f, 0.38558251f, -0.11131082f, -0.02170986f, 0.00422905f, 0.01721373f, 
    -0.35783657f, 0.08872145f, -0.31230643f, -0.23558633f, -0.09773938f, 0.40516663f, 0.24355955f, 0.21975644f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17117546f, -0.16887164f, 0.04005027f, 0.07389849f, -0.15465912f, -0.00770355f, -0.09665865f, -0.20231722f, 
    -0.17081408f, 0.10424263f, 0.25048122f, -0.09104468f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
