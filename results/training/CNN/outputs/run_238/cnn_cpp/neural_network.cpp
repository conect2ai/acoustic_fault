#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.51214468f, -2.00277376f, 1.24235511f, 0.94212264f, -0.57059312f, 0.42051437f, 0.36523360f, 0.64918250f, 
    -0.98840648f, -0.62140107f, -0.05717430f, -0.29463157f, 0.06985348f, 0.32302991f, -0.04633981f, -0.13439175f, 
    -0.14884816f, -0.24001534f, 0.18644579f, -0.33601493f, -0.36888963f, 0.08247770f, 0.11768916f, 0.46837741f, 
    0.30293062f, -0.78416246f, -1.52517796f, -1.44152617f, 0.05126784f, 0.59558463f, -1.18431544f, 1.03744137f, 
    0.80635953f, -0.57489926f, 0.38402671f, 0.35751277f, 0.07940287f, 0.40306738f, -0.11333273f, 0.50368029f, 
    -0.26692340f, 0.18216053f, 0.12641989f, -0.23160496f, -0.18333136f, 0.17779873f, -0.10055652f, 0.13175768f, 
    0.04451628f, 0.11530713f, -1.25419414f, -0.98243707f, -0.63235301f, -0.27772006f, -0.09977005f, -0.19244455f, 
    -0.57344723f, -1.05146134f, 0.01542133f, 0.33362085f, -0.29360133f, 0.57942098f, -0.07262278f, -0.05158730f, 
    -0.09149752f, -0.47550860f, 0.54028773f, 0.48760656f, -0.02202560f, -0.74374032f, 0.16576163f, -0.09845621f, 
    -0.06169554f, -0.56824833f, -0.36779389f, -1.07124746f, 1.17516720f, -0.11249375f, -1.13386130f, -0.70038301f, 
    0.55123699f, 0.95516133f, 0.71651191f, 0.55323309f, 0.73965901f, -0.29135755f, -0.27624255f, 0.13571474f, 
    -0.64539522f, -0.21200030f, -0.09017428f, -0.23916461f, -0.37497166f, 0.08779772f, 0.05652186f, -0.45055047f, 
    -0.61900634f, -0.17560320f, -0.44241136f, 0.24858260f, 0.92746139f, 0.84301358f, 0.99181348f, 1.44368792f, 
    0.41570300f, 0.40287977f, 0.55085117f, -0.63441950f, -0.37530771f, 0.27687499f, 0.29973194f, 0.76618761f, 
    0.25215989f, 0.27007619f, -0.04843109f, 0.02907345f, -0.18604755f, -0.02280910f, 0.00725676f, 0.26900074f, 
    0.07356509f, 0.38118136f, 0.64154691f, -0.01626548f, -0.00513644f, -0.31595418f, -0.03242537f, -1.28186226f, 
    -1.09527254f, -0.44728369f, -0.66436255f, 0.64405036f, 0.50357658f, 0.39856181f, 0.74664855f, 0.29974273f, 
    -0.39694312f, -0.14094225f, -0.79779083f, -0.12342084f, 0.10878804f, 0.37630618f, -0.01087224f, 0.07103807f, 
    -0.05214923f, 0.06834308f, 0.40519765f, -0.18521553f, 0.22811273f, -0.02193812f, -0.20758595f, 0.06910385f, 
    -0.68778729f, 0.39498582f, 1.43042028f, 0.12227648f, -1.30544221f, -1.62367487f, -0.93129075f, 0.17593206f, 
    0.35419422f, 0.82311004f, -0.14898393f, 0.04982150f, 0.17501448f, -0.15233491f, -0.03632963f, 0.19932094f, 
    -0.25713891f, 0.15672851f, 0.01537181f, -0.32198241f, -0.26373920f, -0.02376245f, -0.14414437f, -0.93100703f, 
    -1.54940355f, -1.02182055f, -0.30340952f, -0.74329364f, -0.04441231f, 0.54560852f, 0.68705344f, 0.01365080f, 
    0.37858540f, -0.53179908f, 0.09648132f, -0.41738063f, 0.00926781f, -0.68513805f, 0.13427716f, 0.12162069f, 
    0.04414159f, -0.48924935f, 0.20409077f, -0.11924659f, -0.05200223f, -0.04472462f, -0.21845393f, 0.39164531f, 
    1.12462294f, 0.56826848f, 0.57307476f, 1.77414596f, 0.83986461f, 0.40646604f, 0.36201435f, 0.30409187f, 
    -0.35083506f, 0.15967844f, -0.81514919f, -0.51922596f, -0.56553221f, 0.00657270f, -0.00458331f, -0.26282224f, 
    -0.31581426f, 0.08658504f, -0.21549262f, -0.03007152f, 0.61498958f, 0.07010572f, -0.23789556f, 0.11033800f, 
    0.09031095f, 0.86685002f, -0.36439449f, 1.02207136f, -1.30380285f, -1.74067116f, -0.02464386f, -0.15188237f, 
    -0.36957660f, -0.83391309f, 0.19259219f, 0.53199422f, 0.39514655f, -0.77821022f, 0.02754663f, -0.11811866f, 
    -0.09004095f, -0.24175398f, -0.27657425f, -0.24313667f, 0.16198473f, -0.02797531f, 0.37985301f, 0.15418558f, 
    0.01653497f, 0.24114496f, 1.45953059f, 1.42407608f, -0.71253675f, -0.19030164f, -0.06787556f, 0.91843158f, 
    0.23004434f, -0.97016448f, 0.30406243f, -0.05496792f, 0.21778457f, 0.03877581f, 0.17168473f, 0.21468154f, 
    -0.73270422f, -0.27581713f, -0.16491096f, 0.14495155f, 0.15922593f, -0.34820071f, -0.34543267f, 0.03960092f, 
    -0.14591840f, -0.14074253f, 0.02198701f, 1.27104390f, 0.62655669f, -0.18788299f, 0.21328431f, 0.62906098f, 
    -0.77751142f, -1.38091743f, -0.22560430f, -0.65264022f, -0.46813482f, -0.35720041f, -0.75705665f, 0.39033112f, 
    -0.56121975f, -0.62479174f, 0.21419854f, -0.04906785f, -0.17573783f, 0.03275723f, 0.29936755f, 0.00108673f, 
    -0.07487167f, -0.04684466f, 0.07171305f, -0.17084447f, 1.40510333f, 1.24201441f, 1.30872238f, 0.72332054f, 
    0.14525643f, -0.38405627f, -0.24593568f, -0.33794677f, 0.54771346f, -0.18186203f, 0.10460234f, -0.10254586f, 
    -0.36097634f, 0.41015619f, -0.08006129f, 0.13587317f, 0.38629729f, 0.56430036f, -0.10768300f, 0.26984909f, 
    -0.39178738f, -0.19455010f, 0.26260999f, 0.32406074f, 0.68486828f, -0.79784632f, 0.20354664f, 0.40614384f, 
    0.43190843f, 1.70657408f, 1.06712651f, 0.55248696f, 1.22476614f, -0.26920825f, 0.04523994f, -0.37204406f, 
    0.00878576f, 0.31628093f, 0.36268196f, 0.11687849f, 0.27861831f, 0.05884394f, 0.27309319f, 0.27607915f, 
    0.30733052f, 0.18466057f, -0.04965759f, 0.08933122f, 0.00217657f, -0.21189514f, 0.40741944f, 0.32814443f, 
    0.45999175f, 0.94125319f, 0.60822445f, 1.04672790f, -0.12866591f, 0.34218234f, 0.73452795f, 0.81675583f, 
    -0.88303739f, 0.23190936f, -0.20059443f, -0.05993228f, -0.12957396f, -0.24352863f, 0.09671333f, -0.74429858f, 
    -0.30922008f, -0.55185574f, -0.40984765f, -0.41755700f, -0.20029013f, -0.47807723f, -0.10225505f, 0.37168619f, 
    0.09951010f, 0.65014786f, 0.32861251f, 0.30964935f, -1.50451279f, -0.18256825f, -0.14454538f, -0.90138769f, 
    -0.64121604f, -0.19875796f, 0.65755582f, 0.40588987f, 0.30872634f, 0.66158944f, -0.33460268f, 0.07493565f, 
    0.38510978f, -0.24896574f, 0.35496986f, 0.52094150f, 0.17898640f, -0.35380682f, 0.22203557f, 0.22105823f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24702132f, 0.52683115f, 0.37589517f, -0.07669737f, 0.18169418f, 0.03784426f, 0.22013642f, -0.10613620f, 
    0.40877303f, 0.31875381f, 0.20194149f, 0.13294359f, 0.49212897f, 0.26843020f, 0.24394618f, 0.21845205f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07518317f, 0.18851227f, -0.39566186f, 0.42591316f, -0.17866221f, 0.01748460f, 0.03985528f, -0.24166101f, 
    -0.13264637f, 0.07981330f, -0.01551651f, -0.15237857f, -0.90958130f, 0.44885674f, -0.24464834f, 0.12551580f, 
    0.06666325f, -0.12351801f, -0.35648769f, 0.03974865f, 0.02556615f, 0.11816303f, -0.10899612f, 0.13668466f, 
    -0.36119026f, -0.74972689f, 0.04215236f, 0.17206563f, 0.07861073f, -0.11645965f, 0.20769115f, 0.07554728f, 
    -0.16596858f, 0.20866343f, -0.20011353f, -0.13321321f, 0.66887766f, 0.18393730f, 0.19178410f, -0.26838413f, 
    0.13744499f, 0.13135858f, -0.02377896f, -0.08708466f, 0.04996430f, -0.17192057f, 0.04628593f, 0.10685062f, 
    0.11690634f, 0.33400282f, -0.19402871f, 0.28464025f, -0.20071369f, -0.10098941f, -0.15028434f, 0.20989920f, 
    -0.03503126f, 0.21447375f, 0.06986497f, 0.10934093f, -0.09824992f, 0.27043498f, -0.13359378f, -0.85284883f, 
    -0.11139739f, 0.13625267f, 0.13146000f, -0.00066258f, -0.00327076f, 0.07680155f, 0.05490275f, 0.11061509f, 
    -0.01883161f, -0.74108011f, 0.78495908f, 0.10017736f, -0.25339228f, -0.08541680f, 0.04667847f, -0.12982479f, 
    0.16671497f, 0.20263554f, 0.08348070f, -0.04789121f, 0.10597775f, 0.15593760f, -0.13745984f, -0.56385911f, 
    -0.08120043f, 0.17517626f, -0.13842648f, 0.20331854f, -0.11249846f, -0.08437935f, 0.04000645f, -0.18393116f, 
    0.19947955f, 0.09374958f, -0.19179814f, 0.49229303f, -0.27978027f, 0.05046993f, -0.03814743f, 0.06605240f, 
    -0.08586188f, -0.00294107f, 0.09318307f, -0.00832152f, -0.89264065f, -0.21090011f, 0.31118578f, -0.18323755f, 
    0.07700160f, -0.01304775f, -0.09469814f, 0.01809508f, -0.02370100f, -0.17397371f, -0.14825171f, -0.07803826f, 
    0.04953431f, -0.21948811f, 0.24646367f, -0.18547677f, 0.00548287f, 0.21845980f, 0.08299404f, 0.15035281f, 
    -0.05505215f, 0.28279227f, 0.02289254f, 0.14705360f, 0.41468516f, -0.11452184f, 0.27000493f, 0.02695251f, 
    -0.06479707f, 0.11052211f, -0.12364382f, 0.24621257f, -0.19009955f, -0.15162858f, 0.04728295f, -0.03328690f, 
    0.25843441f, 0.07831164f, -0.36151463f, -0.01343218f, -0.11615932f, -0.47729439f, -0.00946364f, 0.20943801f, 
    0.11238597f, 0.15619294f, -0.13347004f, 0.09996425f, -0.71616459f, -0.03485529f, 0.05639306f, -0.01762744f, 
    0.13067339f, 0.01606639f, -0.07252104f, -0.22328790f, -0.04487523f, -0.03428511f, -0.04707412f, -0.02138414f, 
    0.10232699f, -0.23851727f, -0.09524030f, 0.56004703f, -0.03250814f, -0.06714465f, -0.06767324f, 0.02730673f, 
    -0.15258484f, 0.04529173f, 0.20548137f, -0.07100388f, 0.10188591f, 0.32890072f, -0.30011269f, 0.02006190f, 
    0.01047846f, -0.07128076f, 0.07101155f, -0.04263776f, -0.21171169f, -0.11493757f, -0.18007141f, -0.09208041f, 
    -0.68008864f, -0.25008854f, -0.40952793f, 0.25860950f, -0.39119214f, 0.28530103f, 0.15575571f, 0.03193113f, 
    0.17537318f, -0.10652866f, -0.01767846f, 0.06896836f, 0.54609168f, -0.22516592f, -0.13325682f, 0.15946794f, 
    -0.01571056f, 0.16963015f, -0.16001740f, -0.07877638f, -0.13127561f, -0.22280815f, 0.09544270f, -0.05488939f, 
    0.19765122f, 0.30453125f, -0.03054532f, 0.12561163f, -0.00723722f, -0.24537961f, 0.02221654f, 0.17003885f, 
    0.01571253f, -0.34086871f, 0.26902103f, 0.07104070f, -0.29933915f, -0.06813583f, 0.05367258f, -0.44049555f, 
    0.03051382f, -0.02966944f, -0.01950512f, -0.15993865f, -0.02094425f, -0.09491705f, 0.13475461f, -0.14723006f, 
    0.24558224f, 0.00499186f, 0.27856612f, 0.31246558f, -0.04586688f, -0.02712281f, -0.08563981f, -0.07692043f, 
    -0.00499518f, 0.16639109f, -0.10405321f, -0.04910955f, 0.62635833f, -0.08485022f, -0.15508991f, -0.36230141f, 
    0.16538894f, -0.19773614f, -0.11275685f, 0.16196497f, 0.35815874f, -0.07436252f, -0.14662369f, 0.12634672f, 
    -0.17802250f, -0.23021348f, -0.21595393f, -0.28352496f, 0.02062222f, -0.22654295f, -0.12377186f, 0.13943000f, 
    0.00215987f, -0.09621596f, 0.08954047f, -0.08506226f, 0.08946674f, -0.15375806f, -0.19404140f, -0.00680553f, 
    0.08507136f, -0.04744379f, 0.04235494f, 0.07885450f, 0.27071947f, -0.02519551f, 0.06327827f, -0.02414495f, 
    0.55657500f, -0.00869849f, 0.03149356f, 0.43308872f, -0.30718571f, 0.07055515f, 0.14948522f, 0.16509345f, 
    0.02063056f, 0.09196345f, -0.03361146f, -0.07902560f, 0.07569432f, 0.09835517f, -0.88706183f, -0.22137398f, 
    -0.00311277f, 0.21912213f, -0.00468652f, 0.07742284f, -0.04381569f, -0.11308527f, -0.10004408f, -0.04926423f, 
    0.38939649f, -0.33242396f, 0.06743398f, -0.23627804f, -0.07550643f, -0.20957196f, -0.19249047f, 0.10127734f, 
    -0.28630826f, -0.13415568f, -0.06040995f, -0.08634411f, 0.27403742f, -0.39457646f, -0.14023726f, 0.01675474f, 
    0.05591401f, 0.04054512f, 0.06275359f, 0.02287825f, -0.09635130f, -0.01204729f, -0.33440003f, 0.00010893f, 
    0.26239634f, -0.04392970f, -0.09370553f, 0.28224373f, -0.10926594f, 0.02003307f, -0.07270373f, 0.02876508f, 
    -0.07839501f, -0.11194707f, 0.16210289f, 0.17019215f, 0.26966000f, 0.14434364f, -0.51036733f, -0.01215211f, 
    -0.16404615f, 0.05672263f, -0.12067088f, 0.10026450f, -0.00549267f, 0.20357424f, 0.02856332f, 0.03124367f, 
    0.47226626f, 0.01608042f, 0.08755782f, 0.19871093f, 0.09642775f, 0.21208824f, -0.08485420f, -0.05776360f, 
    0.18287545f, -0.09731236f, 0.04541980f, -0.19290571f, -0.58955973f, 0.05529117f, -0.11386200f, 0.19733176f, 
    -0.05019732f, 0.06952074f, -0.32480031f, 0.02983459f, 0.09173044f, 0.00968555f, 0.19643110f, 0.12169152f, 
    0.22260515f, -0.64813393f, -0.37790188f, -0.55855674f, 0.08169862f, -0.05098466f, -0.33127436f, 0.11258424f, 
    -0.08380682f, -0.00236289f, -0.21566103f, -0.44372082f, 1.15239930f, -0.29041865f, 0.04457902f, 0.17138873f, 
    -0.21434002f, -0.02212466f, -0.11455637f, 0.07440016f, -0.13256669f, -0.17109744f, 0.11862463f, 0.13865316f, 
    0.14137967f, -0.84694630f, 0.02097757f, -0.42190120f, -0.26182556f, -0.08322573f, 0.04935745f, -0.21029754f, 
    -0.05383709f, -0.08535246f, -0.29854581f, -0.09741450f, 0.54981148f, 0.41461444f, -0.28099018f, 0.36024696f, 
    -0.16710895f, 0.11121786f, 0.16774178f, 0.25991994f, -0.16589646f, 0.11898684f, 0.14642867f, -0.17513973f, 
    0.18105535f, 0.15412900f, 0.04013494f, 0.05456409f, 0.05747473f, 0.16102068f, 0.00547393f, -0.01790158f, 
    -0.05515629f, 0.04811822f, 0.01152275f, -0.20297223f, 0.05959133f, -0.07130158f, 0.24419557f, 0.49753621f, 
    -0.01325218f, -0.25072309f, 0.14909850f, 0.07064742f, -0.05757335f, -0.03132728f, 0.00737822f, 0.04661739f, 
    -0.11535324f, -0.82756060f, 0.19843505f, -0.20314614f, 0.27817938f, 0.14447798f, 0.04218249f, -0.07626192f, 
    -0.15350711f, -0.00407054f, 0.13795422f, -0.32610890f, 0.41142291f, -0.07195052f, 0.27175894f, 0.30933890f, 
    -0.29931745f, -0.03608087f, -0.29705629f, 0.26845902f, 0.15253995f, 0.06218897f, -0.00779123f, -0.08252925f, 
    -0.18738216f, 0.13038380f, 0.02723909f, -0.32717136f, 0.25784683f, 0.04465296f, -0.05915364f, -0.04425175f, 
    0.05392128f, 0.02775185f, 0.11157992f, 0.00503149f, -1.00193369f, -0.36493045f, 0.28243360f, -0.71875674f, 
    -0.05830290f, 0.23042661f, 0.07439662f, -0.03036463f, 0.03051579f, -0.07203535f, -0.08856465f, -0.12030071f, 
    0.69966716f, -0.44408262f, 0.15003566f, -0.33742648f, 0.30493358f, -0.51092333f, 0.27919886f, -0.17181763f, 
    -0.17487822f, 0.09733010f, -0.01508291f, -0.03008007f, -0.49289387f, 0.06166248f, 0.00550944f, -0.13461015f, 
    0.15904172f, -0.08614995f, 0.03377101f, -0.06853104f, 0.10372406f, 0.03100886f, 0.14602932f, -0.01125936f, 
    0.13789822f, 0.20375417f, -0.16553441f, 0.11249618f, -0.03449951f, 0.10221123f, -0.11450639f, 0.16918509f, 
    -0.34880361f, -0.02880173f, -0.16015507f, 0.04211764f, -0.07323494f, -0.19556737f, 0.15480787f, 0.19021600f, 
    -0.07798863f, 0.06452360f, 0.01498921f, -0.16242073f, -0.09138202f, -0.22214101f, -0.12178369f, 0.17113540f, 
    0.09809860f, 0.01435071f, -0.12871788f, -0.06192962f, -0.04055694f, 0.02175663f, -0.03831845f, 0.03649094f, 
    0.04506855f, 0.05146840f, -0.03660110f, -0.07002632f, 0.65456331f, 0.05421674f, -0.23147246f, -0.33356848f, 
    0.09827157f, 0.10479687f, 0.33685505f, -0.18681592f, -0.01409962f, 0.00783613f, -0.32892585f, -0.15610823f, 
    -0.01898570f, -0.09005315f, 0.21852604f, 0.10810343f, 0.00384629f, 0.21926314f, 0.02440016f, 0.23040402f, 
    -0.03828961f, -0.08702598f, -0.12324461f, 0.13362721f, 0.11246316f, -0.03246459f, -0.00217842f, -0.16034240f, 
    -0.05267198f, -0.16761269f, 0.21924752f, -0.18240979f, -0.13148122f, 0.08304695f, -0.26659393f, 0.08107874f, 
    0.05456336f, 0.32330704f, -0.15795384f, -0.12066035f, -0.21704823f, 0.18645552f, -0.15932108f, 0.17289019f, 
    -0.06111249f, 0.06106060f, 0.07226182f, 0.28836611f, -0.60255897f, 0.37331298f, 0.14373216f, -0.43920612f, 
    -0.01551205f, 0.00152769f, -0.08804265f, 0.11831625f, 0.04063224f, 0.01976185f, -0.16553988f, 0.12302846f, 
    -0.73182482f, -0.68985665f, 0.07006997f, 0.38628820f, -0.03901501f, -0.16697125f, -0.15186192f, 0.08608784f, 
    -0.11107215f, 0.08344404f, -0.20171528f, -0.03574981f, -0.15964635f, -0.18500102f, 0.04069243f, -0.10883936f, 
    -0.31426099f, 0.15520598f, -0.08171138f, -0.10625551f, -0.20349732f, 0.04924778f, -0.12320446f, 0.20017476f, 
    0.74340647f, 0.52108532f, 0.15378343f, 0.51374972f, 0.12788777f, 0.40034395f, 0.19083914f, -0.10363796f, 
    0.02347945f, -0.03026251f, -0.23469184f, -0.24544467f, 0.09687038f, -0.33446854f, 0.04554841f, -0.23360217f, 
    -0.14368847f, -0.40788931f, -0.01179726f, 0.15471308f, -0.27586988f, 0.00058120f, 0.10854299f, -0.00079679f, 
    -0.47836125f, -0.96234286f, -0.36099210f, 0.02040764f, -0.12124078f, -0.07886899f, 0.06486619f, -0.37336513f, 
    0.07998260f, -0.22645435f, 0.23007712f, 0.02927458f, 0.09574883f, 0.15598497f, 0.09367273f, 0.03222285f, 
    -0.11037830f, -0.14663398f, -0.16330801f, 0.03288908f, 0.08464745f, 0.14140105f, 0.06022057f, 0.00849544f, 
    0.49497452f, 0.16068873f, -0.26096949f, 0.05549608f, -0.30814648f, -0.08635278f, 0.05252992f, 0.11142915f, 
    -0.11647034f, -0.02631118f, -0.07123800f, 0.13111049f, 0.75825149f, -0.16378056f, 0.10459418f, 0.21267214f, 
    0.11585370f, 0.37249476f, 0.02510734f, -0.15516809f, 0.17004514f, 0.02817227f, 0.01574026f, 0.15761955f, 
    -0.27028748f, -0.54049814f, -0.63991767f, 0.18205880f, -0.16172290f, 0.06384410f, 0.05318142f, 0.13163674f, 
    -0.19937915f, 0.06839938f, 0.14736220f, -0.04185553f, -0.41091031f, 0.02261712f, 0.24506909f, -0.06758488f, 
    0.18297362f, -0.04243958f, 0.14585964f, -0.10248671f, 0.12054119f, -0.14608847f, -0.21956812f, -0.06864896f, 
    -0.42691225f, -0.08910410f, -0.62907100f, 0.05311112f, -0.13288531f, -0.02339526f, 0.03345768f, 0.01527071f, 
    0.18734130f, 0.18117529f, -0.01388246f, 0.18189044f, -0.20811555f, 0.13309158f, 0.09687990f, 0.12579823f, 
    0.16670781f, 0.05119410f, -0.05552918f, -0.14363429f, 0.10674240f, -0.06277494f, -0.03959759f, -0.02504618f, 
    -0.57451099f, 0.66811210f, 0.25599068f, -0.90561557f, 0.24938333f, -0.15851317f, -0.13914885f, 0.12834725f, 
    0.06233006f, -0.07297786f, -0.00696274f, 0.05676023f, -0.41605785f, 0.27593598f, -0.07310224f, -0.15749347f, 
    -0.04892754f, 0.01214886f, 0.20167208f, 0.05035779f, 0.16992450f, -0.19627059f, -0.20981801f, 0.07690813f, 
    0.29414549f, 0.17514722f, 0.17220116f, 0.11624312f, -0.00506941f, 0.00084645f, -0.03637153f, 0.17121398f, 
    0.12844548f, 0.06538439f, -0.02506023f, 0.08868083f, -0.15919998f, -0.00853639f, -0.04182700f, 0.40406483f, 
    -0.03506159f, 0.05369390f, 0.13586238f, -0.04582753f, -0.03398199f, 0.15186711f, 0.02740498f, 0.29602626f, 
    -0.57652032f, 0.20612980f, -0.02680501f, -0.11092881f, -0.12262895f, -0.02892762f, -0.09114818f, 0.04646681f, 
    0.04436749f, -0.26536110f, -0.14330576f, -0.08720060f, -0.13685532f, -0.29145145f, -0.06334498f, 0.28182852f, 
    -0.06347969f, 0.14392978f, 0.17968941f, 0.05892282f, -0.19967657f, 0.10089573f, 0.18816648f, -0.13609350f, 
    -0.53576416f, 0.10443274f, 0.05948964f, 0.06744698f, -0.01586312f, 0.07747066f, -0.16344199f, 0.00451087f, 
    0.05280075f, -0.16814275f, -0.16562611f, 0.02709800f, -0.77637446f, -0.19480976f, -0.04275296f, 0.35041970f, 
    0.15480167f, 0.03253066f, -0.21683770f, 0.27189615f, -0.29139307f, 0.15077515f, 0.15539455f, 0.10847604f, 
    0.19646855f, 0.38610151f, 0.09188933f, 0.16781706f, 0.09468400f, 0.14908271f, 0.16509856f, 0.05065653f, 
    0.07463603f, 0.11297261f, 0.03372998f, 0.23189287f, -0.03588738f, -0.38103995f, 0.37715843f, -0.46354479f, 
    0.03500555f, 0.26866880f, 0.03171836f, 0.06154376f, -0.03353635f, -0.03648375f, -0.11722060f, -0.21974126f, 
    -0.16682832f, -0.09564158f, -0.07864940f, 0.03117838f, -0.35868114f, 0.00183827f, 0.19116047f, 0.02649559f, 
    -0.10645271f, -0.17882109f, 0.01911632f, 0.04107546f, 0.10584465f, -0.07015068f, -0.08200654f, 0.33122337f, 
    -0.30483642f, 0.06321654f, 0.10068087f, -0.15579295f, 0.05548403f, -0.03669830f, 0.07879713f, -0.08382700f, 
    -0.28151894f, 0.19011760f, 0.13660617f, 0.07019889f, -0.22249669f, 0.09711066f, 0.05066954f, 0.03437337f, 
    0.14150976f, 0.14163205f, -0.14318468f, -0.11477490f, -0.02558152f, 0.10058082f, -0.62306213f, 0.04376018f, 
    0.02329635f, -0.07559720f, 0.10304131f, -0.03256835f, 0.11723081f, -0.03374288f, 0.11487545f, -0.21561222f, 
    -0.07146833f, -0.22522838f, -0.13291928f, 0.07462459f, -0.05907211f, -0.09624565f, 0.22766083f, 0.29589108f, 
    -0.13479736f, 0.03127994f, -0.00256120f, 0.32657218f, -0.45428216f, -0.60168529f, 0.52415216f, 0.00165394f, 
    -0.17297721f, 0.03214248f, -0.19832213f, -0.31794488f, 0.24332400f, 0.00313064f, 0.02626516f, -0.09631950f, 
    -0.29461917f, 0.39931786f, 0.18479672f, 0.38401127f, -0.08872222f, 0.06054524f, -0.06831879f, -0.15778422f, 
    -0.13137144f, -0.11964267f, 0.02117397f, -0.12839909f, -1.12071860f, -0.21661998f, -0.25986120f, -0.47510615f, 
    0.23937215f, -0.02631783f, -0.05907465f, 0.15062158f, 0.08673225f, -0.01642635f, 0.06751966f, -0.05468232f, 
    -0.40667081f, 0.20432134f, -0.00316152f, 0.14708105f, 0.37275314f, 0.27459422f, 0.09680826f, -0.08977371f, 
    0.05814385f, -0.03083251f, 0.30733940f, 0.00802855f, -0.02056932f, -0.01809572f, -0.24636507f, -0.17751221f, 
    0.08261313f, -0.25809571f, -0.26004687f, -0.36893892f, -0.04205029f, 0.07523248f, 0.00623494f, -0.10403986f, 
    0.03866857f, -0.12649472f, 0.16522443f, 0.02997113f, -0.05124861f, 0.03429847f, 0.18626569f, 0.11710434f, 
    0.17805500f, -0.07600781f, 0.04326644f, 0.26501414f, -0.25480041f, -0.37260714f, -0.25379696f, 0.04630167f, 
    0.16294080f, 0.16706072f, -0.23513737f, -0.08743934f, 0.04197076f, -0.09939331f, -0.33917063f, 0.06977249f, 
    -0.13797812f, -0.09472528f, -0.10847131f, -0.06556633f, -0.22622266f, 0.06058843f, 0.14048350f, 0.07094434f, 
    -0.17299002f, 0.08185925f, 0.11909328f, 0.22484027f, -0.22613047f, 0.41046220f, -0.60503232f, 0.23141661f, 
    0.09004054f, 0.08196774f, 0.34124404f, -0.32250831f, 0.07329001f, -0.17062907f, -0.26437557f, 0.15367241f, 
    0.07426603f, -0.03638864f, 0.14378422f, -0.40566000f, -0.17863512f, 0.13882238f, -0.12245087f, 0.11579262f, 
    0.09934764f, 0.09920222f, -0.05376855f, -0.05938910f, -0.50357014f, 0.05683153f, 0.00096184f, 0.29761717f, 
    -0.12425601f, -0.28997564f, 0.25219586f, 0.10188480f, 0.12791719f, 0.08224642f, -0.11849627f, 0.14962164f, 
    -0.28731003f, 0.04188555f, -0.20636821f, 0.13257544f, 0.10762340f, 0.19722670f, -0.08030198f, -0.10054544f, 
    0.18333185f, -0.39694998f, -0.05814961f, -0.13397834f, 0.01444872f, -0.04078368f, 0.12315950f, 0.16428804f, 
    0.04140187f, -0.43626279f, -0.06680556f, 0.04729982f, -0.02333386f, -0.07762066f, -0.10826162f, 0.11980508f, 
    0.22352572f, -0.02383895f, -0.03722323f, 0.03323540f, -0.05314067f, 0.18277211f, 0.08252246f, -0.04860837f, 
    -0.00431518f, -0.15365313f, 0.17999217f, 0.22465798f, -0.43913367f, 0.25500378f, 0.82242858f, -0.35547671f, 
    0.11671856f, -0.02689725f, 0.15570940f, -0.15551469f, 0.13591065f, -0.13947040f, 0.17254177f, 0.02253487f, 
    0.03811688f, 0.17709109f, 0.29779586f, -0.02081308f, 0.11050365f, -0.12468931f, 0.16144270f, -0.23309264f, 
    -0.21647106f, -0.02553417f, -0.40268359f, -0.23724662f, 0.15903158f, 0.05643324f, 0.14682244f, 0.06702134f, 
    -0.01888726f, 0.03525075f, 0.09670768f, 0.27568936f, -0.32017860f, 0.17919914f, 0.27022243f, 0.09356576f, 
    0.74592829f, -0.67380977f, 0.20176399f, -0.18429407f, 0.12814173f, -0.02475680f, -0.06537280f, 0.00553289f, 
    -0.11357585f, 0.13520947f, 0.15234315f, -0.02621524f, -0.00334129f, 0.04181124f, 0.04507406f, 0.04496963f, 
    -0.07858596f, 0.08219627f, 0.15136556f, 0.12830634f, 0.02323382f, -0.09893306f, 0.03365871f, -0.03602614f, 
    -0.01997637f, -0.30473679f, -0.20962438f, -0.24344589f, -0.09933651f, -0.19732460f, -0.27671823f, -0.10565092f, 
    0.07023758f, 0.39997599f, -0.20266169f, 0.29159594f, -0.09001976f, -0.49954179f, -0.56650776f, 0.44574356f, 
    0.01198710f, 0.17452046f, 0.16641374f, 0.03409986f, -0.00145308f, 0.00555432f, -0.06154883f, 0.01954716f, 
    0.12032826f, 0.15771723f, 0.23715752f, -0.41736963f, -0.29975963f, -0.05547670f, -0.02010661f, 0.00003174f, 
    -0.14674811f, -0.10596935f, 0.01153197f, -0.36532554f, -0.99931884f, -0.04704908f, 0.01532972f, 0.10664851f, 
    0.21865720f, -0.16872616f, 0.12483099f, -0.03508253f, 0.13053161f, -0.06106898f, 0.32193828f, -0.15405622f, 
    0.25229549f, 0.01011753f, -0.05744315f, -0.13414507f, -0.03622144f, 0.10533950f, 0.12730716f, -0.10245476f, 
    -0.04673257f, -0.19076936f, -0.19689550f, -0.01387995f, 0.03279256f, -0.33756879f, -0.07784873f, -0.54834723f, 
    -0.10924006f, -0.09132782f, -0.13422929f, -0.00577866f, -0.13066328f, -0.01781163f, 0.12419167f, 0.22208288f, 
    -0.03999520f, 0.11883489f, 0.34481451f, -0.44700465f, -0.14866047f, -0.23869431f, 0.03758657f, 0.10572601f, 
    -0.05593192f, -0.11805119f, 0.08598249f, 0.18543002f, -0.39494175f, 0.10376846f, -0.58224165f, 0.53129905f, 
    0.03079287f, 0.10902968f, -0.16634959f, -0.09477623f, -0.22115022f, -0.06098865f, -0.01420524f, -0.19898745f, 
    -0.03021889f, 0.12873144f, -0.16059031f, 0.46651649f, 0.04294902f, 0.04777070f, -0.06708084f, 0.05154148f, 
    0.15965149f, 0.31762704f, -0.10396334f, 0.34494302f, -0.23857249f, 0.36067373f, -0.01526427f, -0.54234183f, 
    0.11982340f, 0.32324415f, 0.12060507f, -0.15510923f, -0.00340306f, -0.00162781f, 0.23058377f, -0.07867677f, 
    -0.33891755f, 0.56468093f, 0.17624521f, -0.29507664f, -0.07399525f, -0.10185621f, 0.18745148f, -0.07342703f, 
    0.18262510f, -0.02814367f, -0.10132250f, -0.27310026f, 0.22159657f, -0.53816897f, 0.21719705f, 0.28206512f, 
    -0.13291769f, 0.12197676f, 0.07318811f, 0.15919587f, 0.05515200f, -0.08990739f, -0.12003292f, -0.00532392f, 
    -0.33307794f, 0.20933712f, 0.18149225f, -0.08246519f, -0.25887504f, -0.00616845f, -0.09714717f, 0.24984545f, 
    0.18843544f, -0.01114051f, 0.30007410f, 0.13686685f, 0.11873745f, 0.11137147f, 0.13279203f, -0.14661866f, 
    -0.12963103f, 0.02953587f, 0.15240812f, -0.01976045f, 0.03630339f, -0.25314370f, -0.00102826f, 0.04410784f, 
    0.51912689f, -0.17456421f, 0.25637648f, -0.01615407f, -0.29091373f, -0.18166302f, 0.03023155f, -0.12893346f, 
    -0.03744141f, 0.00296704f, -0.19878282f, 0.00242746f, 0.39797282f, -0.15599771f, 0.49568805f, -0.28902391f, 
    0.07733770f, 0.04887437f, -0.18357538f, -0.00401090f, -0.10148015f, 0.10491876f, -0.19034031f, 0.15907831f, 
    -0.24226350f, 0.06334051f, 0.20183319f, -0.04163474f, 0.22807601f, 0.37198108f, 0.06706854f, -0.25521606f, 
    -0.20027363f, -0.09554090f, -0.08745555f, -0.45060536f, -0.07279290f, 0.06842061f, 0.05862508f, 0.11640701f, 
    0.26765662f, -0.02510081f, -0.04721645f, 0.06132935f, 0.13128829f, 0.03509840f, -0.08159193f, -0.14463891f, 
    -0.25248027f, 0.02762529f, -0.30123717f, -0.05813905f, 0.05695550f, 0.08545965f, 0.00635894f, -0.10261275f, 
    -0.09020886f, -0.01841702f, -0.10917243f, -0.02357223f, 0.23974547f, 0.44195893f, 0.44598806f, 0.30360210f, 
    0.21291345f, -0.10092684f, 0.04915636f, -0.26323542f, 0.01419227f, 0.25388998f, 0.17777532f, -0.18796097f, 
    -0.99760485f, -0.05715977f, -0.20540774f, -0.05321224f, -0.13891593f, -0.43517524f, -0.10734910f, 0.05024756f, 
    0.13392808f, -0.05302460f, -0.07147728f, -0.10500726f, 0.33524823f, 0.22398466f, 0.41789895f, 0.33644441f, 
    0.31735560f, 0.26357755f, 0.07866562f, -0.06524413f, -0.08280089f, 0.16716978f, -0.07218938f, 0.01191966f, 
    -0.25492513f, -0.00906858f, -0.16466342f, -0.32564428f, -0.21822590f, 0.05525214f, 0.06510558f, -0.07661120f, 
    -0.12069752f, -0.11145364f, -0.11907665f, 0.15237285f, -0.05014718f, 0.20635751f, 0.06965669f, 0.39130899f, 
    0.00885940f, -0.13642806f, 0.07113469f, -0.08527242f, -0.10972136f, -0.07521275f, -0.12864171f, 0.02493307f, 
    -0.46308860f, 0.39654139f, 0.19282244f, -0.00212707f, 0.04707245f, 0.05222929f, 0.14108469f, 0.10443047f, 
    -0.18334714f, 0.36744374f, 0.00691631f, 0.06346572f, -0.33658037f, 0.03626596f, -0.11238698f, 0.38613302f, 
    0.02817133f, -0.14640783f, -0.32711110f, 0.05029259f, -0.22439763f, -0.03797603f, 0.01192009f, -0.21419884f, 
    -0.56361157f, -0.39419484f, -0.17919520f, -0.18349510f, 0.02781240f, -0.09684332f, -0.02028370f, 0.01611651f, 
    -0.14898287f, -0.02055282f, 0.05110679f, 0.01970158f, 0.10119896f, -0.31860679f, 0.01756122f, 0.02502033f, 
    -0.36980224f, -0.12205152f, 0.09594845f, -0.03643501f, 0.02976835f, -0.06741387f, 0.08744051f, -0.07414724f, 
    0.23907721f, 0.17078313f, -0.18438089f, -0.38457879f, -0.25204936f, 0.10144188f, -0.15175398f, -0.05867685f, 
    -0.19543952f, -0.09436058f, -0.00500760f, -0.35703245f, 0.76172465f, -0.23860273f, 0.07309333f, -0.10807551f, 
    -0.30607292f, -0.13878874f, -0.01513673f, -0.04456552f, -0.00278575f, -0.03812194f, -0.07340158f, -0.09875768f, 
    -0.17215289f, 0.11915527f, -0.10080467f, -0.20166011f, -0.11312076f, -0.25282243f, 0.04230290f, -0.22057636f, 
    0.17388687f, -0.12263844f, -0.02312983f, 0.36201236f, -0.20279369f, 0.08167324f, 0.23277654f, -0.12053577f, 
    -0.16572508f, 0.04906268f, -0.05629414f, -0.23324387f, 0.06945215f, -0.01788971f, 0.13236538f, 0.18264078f, 
    -0.45000359f, -0.25665739f, 0.30576041f, -0.28326824f, -0.03254035f, -0.07573537f, -0.31063884f, -0.11146245f, 
    0.25157231f, -0.01802500f, 0.02777315f, -0.11176259f, 0.15771657f, 0.27689654f, 0.04931281f, 0.21658981f, 
    -0.10626993f, -0.09466717f, -0.22701764f, -0.08707165f, -0.02815644f, -0.08480914f, -0.17152025f, -0.09327564f, 
    0.44606748f, -0.19558969f, -0.25019759f, 0.46499974f, 0.00206719f, 0.03918865f, 0.03263451f, -0.04696845f, 
    -0.10311998f, 0.06557974f, 0.05406722f, 0.08497541f, -0.31571001f, 0.39020315f, -0.01103534f, 0.30428955f, 
    -0.03260950f, 0.11033738f, -0.06683707f, 0.18260872f, 0.02540345f, -0.04091800f, -0.38807929f, -0.04279835f, 
    -0.50485265f, 0.19485159f, -0.50060612f, -0.20345564f, -0.20032765f, -0.00079023f, -0.16002846f, -0.00855098f, 
    0.06497091f, 0.27834100f, -0.11243611f, -0.03042529f, -0.58936948f, -0.31966311f, 0.55425376f, -0.14739367f, 
    -0.13235115f, 0.14066629f, -0.10414980f, -0.25760999f, -0.03863152f, -0.34581968f, -0.13461378f, 0.02426791f, 
    0.37618637f, -0.03206474f, 0.00905188f, 0.42687279f, 0.10473800f, -0.14643949f, -0.10769698f, -0.01408183f, 
    -0.06411272f, 0.10148743f, -0.11815283f, -0.52491868f, 0.58167553f, 0.04656241f, -0.45509928f, -0.64754224f, 
    -0.16950727f, 0.10631709f, 0.10121706f, -0.12049753f, 0.15344116f, -0.09149947f, -0.05072666f, 0.22329925f, 
    0.32242498f, -0.01310499f, -0.26870215f, 0.17671379f, 0.08716086f, 0.14423731f, -0.28258434f, -0.16891225f, 
    -0.00270378f, -0.15002182f, 0.16586600f, 0.01815223f, -0.65319705f, -0.34031516f, -0.31409231f, -0.17802654f, 
    -0.10649271f, -0.27759221f, -0.17443950f, 0.12027948f, 0.25004500f, -0.05892928f, 0.14121002f, 0.05319874f, 
    -0.06626484f, -0.42046925f, -0.03192839f, 0.45020139f, 0.24262290f, 0.25344548f, -0.16284592f, -0.27887025f, 
    -0.14968310f, -0.07744841f, 0.15768649f, 0.24302745f, 0.39538404f, -0.07271121f, 0.11026438f, 0.18647633f, 
    -0.01569765f, -0.05371202f, -0.14183874f, -0.13199322f, -0.17900170f, 0.07941371f, 0.05064594f, 0.14423521f, 
    0.33166876f, -0.23233500f, 0.00369421f, 0.11295723f, 0.04314998f, -0.03085080f, -0.14142403f, -0.16317591f, 
    -0.05264290f, 0.21075386f, -0.26257342f, -0.21625985f, 0.17475291f, -0.26012447f, -0.21288240f, -0.31264025f, 
    0.18569613f, -0.02409107f, -0.02090001f, 0.11905576f, 0.34193012f, 0.13069753f, 0.09325894f, 0.05594696f, 
    0.80563754f, 0.04584085f, -0.50941855f, -0.34228611f, 0.31486800f, -0.05354085f, 0.07886484f, 0.08031838f, 
    -0.20196262f, 0.05527324f, 0.10264491f, 0.19728355f, -0.17523251f, -0.63981253f, -0.11837636f, 0.32808802f, 
    -0.00937156f, 0.10805324f, -0.08576547f, 0.05843151f, 0.04506604f, 0.22472972f, 0.08741913f, -0.12298784f, 
    -0.27070308f, -0.44530737f, -0.07981418f, -0.01110736f, -0.03419907f, 0.27639571f, 0.22462553f, -0.22360517f, 
    -0.21230236f, -0.07985342f, -0.20619048f, -0.08791443f, 0.33048707f, -0.42323977f, 0.33243227f, -0.07810196f, 
    0.10824586f, -0.06811795f, 0.14762346f, 0.25864321f, 0.09544071f, 0.20311704f, 0.06612132f, 0.03505028f, 
    -0.54068840f, 0.35418344f, -0.22586009f, -0.52715415f, 0.12561339f, 0.15121944f, 0.16753080f, 0.12415215f, 
    -0.03395717f, -0.03715836f, 0.07695051f, 0.02912747f, 0.12189824f, -0.53264844f, -0.12027925f, 0.02374825f, 
    -0.12133408f, 0.04997675f, -0.05662442f, 0.25763491f, -0.34731206f, 0.06839585f, 0.06236519f, 0.02627846f, 
    -0.42827463f, 0.31249279f, -0.16649666f, -0.11929014f, 0.10305432f, -0.09721854f, -0.04175698f, -0.04357293f, 
    0.09825412f, 0.18080135f, 0.09751003f, 0.01368248f, -0.04517880f, -0.03878260f, 0.18996289f, -0.03720122f, 
    0.17657617f, 0.07909320f, 0.12156989f, -0.07225287f, -0.01167328f, 0.05071124f, -0.09875800f, 0.10916289f, 
    -0.74484712f, 0.34166610f, -0.27870435f, -0.15437102f, 0.27993485f, 0.03792033f, 0.09732986f, -0.16389023f, 
    -0.20536999f, -0.10992086f, 0.00428623f, 0.05899117f, 0.80592227f, -0.09739908f, 0.08322882f, 0.01906757f, 
    -0.04882741f, -0.14048627f, -0.09351418f, -0.01450246f, -0.08850338f, 0.22565706f, 0.25179666f, 0.06261508f, 
    -0.69359052f, 0.48876724f, 0.46847004f, -0.04834796f, 0.08717955f, 0.01819325f, -0.02218547f, 0.04896710f, 
    -0.01201391f, -0.00961834f, 0.05661736f, 0.00139970f, -0.25625280f, -0.04712017f, -0.19244812f, -0.32795778f, 
    -0.41306663f, -0.02332979f, 0.17757592f, 0.03874530f, -0.04277763f, 0.12972720f, -0.07384268f, -0.02283961f, 
    0.05380811f, -0.08881708f, 0.52004832f, -0.23181261f, 0.02681297f, 0.18358599f, -0.21844183f, -0.27433059f, 
    -0.15603621f, -0.00680315f, -0.07801884f, -0.26151419f, 0.44896880f, 0.10076290f, -0.76846415f, 0.06548066f, 
    0.14296550f, 0.06442434f, -0.04571236f, 0.16976823f, -0.14177994f, -0.05538730f, -0.14336190f, -0.11773963f, 
    -0.28107315f, 0.28573325f, 0.28143647f, -0.24872607f, 0.03931769f, -0.15928218f, -0.01107170f, -0.22662780f, 
    0.14497353f, -0.12877080f, 0.14227314f, 0.24997149f, 0.15114899f, -0.35636982f, -0.38420108f, -0.14924784f, 
    0.09719381f, -0.02812708f, 0.33719403f, -0.18022153f, 0.03718796f, -0.21212706f, -0.21129084f, -0.20472033f, 
    0.13069999f, 0.11364380f, 0.12391280f, 0.56004363f, -0.01749992f, -0.07169808f, 0.02311634f, -0.05669680f, 
    0.26017943f, 0.14790446f, 0.20506266f, -0.14861594f, 0.26158884f, -0.08223794f, -0.05267277f, 0.10253517f, 
    -0.10013840f, 0.10072841f, 0.07081818f, 0.22492775f, -0.00758010f, 0.27430049f, -0.06877676f, 0.10770582f, 
    0.35520747f, 0.22629534f, -0.15285255f, 0.12223356f, 0.10420916f, -0.27626416f, 0.38623264f, 0.18680282f, 
    -0.06477796f, -0.01101511f, 0.27442500f, -0.21725464f, -0.03988005f, 0.03217723f, -0.22239144f, -0.24840617f, 
    -0.19044192f, 0.07945399f, -0.03624314f, -0.19583023f, 0.07656305f, -0.25133848f, -0.27837038f, -0.23701933f, 
    -0.94143021f, -0.54477328f, -0.34221324f, -0.48651087f, 0.24008328f, -0.14174561f, -0.00380943f, 0.00429597f, 
    0.08136969f, 0.24245983f, 0.09583055f, 0.07569186f, -0.06288383f, -0.04880146f, 0.08261230f, -0.09120908f, 
    -0.14830475f, 0.05152940f, 0.07017262f, -0.13653989f, 0.14544249f, -0.00967139f, -0.22035153f, -0.18182373f, 
    0.93291861f, 0.11908769f, -0.17447202f, -0.22165217f, 0.25358403f, 0.06157029f, 0.13236542f, 0.20984049f, 
    0.01419518f, -0.11090300f, 0.08687141f, 0.20651644f, 0.41108447f, 0.05512103f, 0.02905252f, -0.22258937f, 
    -0.42573324f, -0.16616148f, -0.02395746f, -0.37424895f, 0.11476966f, -0.16753285f, -0.02246605f, -0.07935437f, 
    -0.56691259f, -0.21018839f, -0.25106236f, -0.44552106f, 0.08543735f, -0.03477500f, -0.17297058f, 0.11044971f, 
    0.10171602f, -0.14662628f, -0.09974977f, -0.08846916f, -0.48939332f, -0.00916690f, 0.07733683f, 0.24217461f, 
    0.24329278f, -0.15629347f, -0.02970281f, 0.05247098f, -0.03821945f, 0.13255288f, -0.06425145f, 0.09949568f, 
    -1.36844468f, -0.80808771f, -0.35256782f, -0.01581505f, 0.19825539f, 0.00200202f, 0.14552262f, -0.04361364f, 
    0.26617405f, -0.16840491f, -0.09920776f, -0.10918613f, -0.41833061f, 0.01841367f, 0.34756464f, -0.45421872f, 
    -0.04271443f, -0.00120487f, 0.11575367f, 0.16984905f, -0.07032684f, -0.15082270f, 0.08048704f, -0.11217724f, 
    -1.01321280f, -0.24223511f, 0.13602374f, -0.12706909f, 0.28220972f, -0.00350305f, 0.01692701f, -0.18494496f, 
    0.28906000f, 0.27944523f, -0.01308720f, 0.34852919f, 0.01437240f, -0.00619394f, -0.13006622f, -0.11544791f, 
    0.01522292f, -0.09505603f, 0.07176054f, 0.29866168f, -0.13460739f, 0.19525385f, 0.18954915f, 0.05189531f, 
    -0.30944315f, -0.20890689f, -0.06183119f, -0.22764771f, 0.29205805f, -0.08540720f, -0.10230552f, -0.21866569f, 
    0.05714510f, -0.43274793f, -0.26423207f, -0.09473147f, -0.29346237f, 0.19271992f, 0.20908070f, 0.04936901f, 
    0.18846652f, 0.22839303f, -0.03687647f, 0.09128857f, -0.17318960f, 0.41840857f, 0.05597207f, 0.24088529f, 
    -0.53337932f, -0.41191706f, 0.16704696f, 0.08002607f, 0.18574689f, -0.13654706f, -0.06263843f, 0.09945175f, 
    0.01458389f, 0.14503665f, -0.00574781f, 0.12186117f, -0.27443084f, 0.36642891f, 0.11072372f, 0.04432957f, 
    0.19510028f, -0.05899915f, 0.13333264f, 0.05501967f, 0.00787445f, -0.06151933f, 0.11924586f, -0.10136724f, 
    0.31814718f, 0.08606981f, -0.27367988f, -0.30056643f, -0.20265962f, -0.04449363f, -0.19623889f, -0.09966970f, 
    0.02360471f, -0.18916926f, -0.07856075f, -0.02113019f, -0.87639064f, -0.32101345f, -0.13813151f, 0.13124958f, 
    -0.18442975f, 0.10570683f, 0.02097422f, 0.10103273f, -0.06804655f, -0.06182028f, 0.05282548f, -0.12427730f, 
    0.97318983f, -0.37888768f, -0.07627480f, -0.07787678f, 0.15804322f, 0.09761843f, 0.01762312f, -0.10009411f, 
    0.03451340f, -0.01499979f, 0.10977093f, 0.23056963f, 0.05814876f, 0.33013281f, -0.22058216f, -0.08890042f, 
    -0.05657220f, 0.02250822f, 0.03692858f, -0.16300480f, -0.07043330f, 0.13343140f, 0.02812175f, -0.19539391f, 
    0.03164916f, -0.11664932f, -0.17790858f, 0.51179487f, 0.35710180f, -0.00496953f, 0.34372807f, 0.26406327f, 
    0.00747796f, 0.16801767f, -0.10340834f, 0.03078230f, -0.12244119f, 0.19768608f, -0.24025767f, -0.11879831f, 
    -0.39057383f, 0.21397930f, 0.04261786f, -0.35303113f, 0.21520124f, 0.11394386f, 0.13121392f, -0.26431540f, 
    -0.01194162f, -0.48624331f, 0.06687030f, -0.52115810f, 0.11513403f, -0.08847869f, 0.07211218f, -0.21166915f, 
    0.01308454f, -0.18401374f, -0.02387259f, -0.07135373f, 0.70492077f, -0.03274227f, -0.01633437f, -0.05352855f, 
    -0.24258284f, -0.16311905f, -0.22140987f, -0.04446168f, 0.07431192f, 0.03809481f, 0.28212088f, 0.04936681f, 
    0.41955554f, -0.43654510f, -0.21042684f, 0.21909910f, 0.00930338f, -0.12107537f, 0.09226954f, -0.17546126f, 
    0.20456432f, 0.02240899f, 0.00718295f, 0.08287737f, -0.03130966f, 0.68127286f, -0.24080347f, 0.05897928f, 
    0.44510245f, -0.16494359f, -0.17900218f, 0.01636853f, 0.27534580f, 0.06795076f, -0.02650599f, -0.07459710f, 
    0.61536896f, -0.16799760f, -0.05806742f, -0.21191938f, 0.12506497f, -0.16966163f, 0.07396667f, 0.05169142f, 
    -0.01150538f, -0.05203753f, -0.19512865f, -0.21573325f, -0.31150550f, -0.02239713f, 0.24186841f, 0.00686754f, 
    0.08030700f, -0.03370854f, -0.11386194f, -0.07476538f, -0.27108333f, 0.01791454f, -0.12391341f, 0.07846387f, 
    -0.01775902f, -0.08146628f, 0.03133723f, -0.67635638f, -0.00687178f, 0.10831325f, 0.05870253f, 0.18927656f, 
    0.05032762f, 0.08670642f, 0.10947999f, 0.02399336f, -0.13234773f, 0.21408622f, -0.19112502f, 0.33439645f, 
    -0.19772673f, -0.08233512f, 0.21545678f, 0.14073856f, 0.07185022f, -0.05547665f, -0.24715675f, 0.01497443f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19457622f, 0.06429534f, -0.20791924f, -0.04085420f, -0.01386831f, 0.03746784f, 0.07241378f, -0.23955506f, 
    -0.02053651f, -0.01112910f, 0.32822502f, -0.05077935f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
