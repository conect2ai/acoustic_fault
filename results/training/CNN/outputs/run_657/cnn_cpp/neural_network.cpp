#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.16142356f, -1.26318133f, 0.79993618f, 0.69157761f, 0.20245995f, 0.71904933f, 0.03284763f, -0.19439171f, 
    -0.01229377f, 0.95789099f, -0.38785049f, 0.66430074f, 0.65842694f, 0.37022498f, 0.74227649f, -0.07471791f, 
    -0.15057144f, -0.38522187f, -0.42412484f, -0.87182623f, -0.92428356f, 0.51044041f, 0.61595494f, 0.53136283f, 
    -0.47686258f, 0.11220365f, -0.19486709f, -0.42558083f, -0.82055116f, -0.06552180f, -0.89149159f, 0.82160789f, 
    -0.24869332f, 0.55436885f, 0.26342228f, -0.29420143f, 0.55048984f, 1.31657481f, 0.83320385f, -0.89826620f, 
    0.46501461f, 0.02690117f, 0.23546790f, 0.48519549f, -0.33569020f, 1.03500473f, 0.78566360f, 0.19312227f, 
    -0.38016570f, -0.21801053f, 1.00636172f, -0.40563294f, -0.44585517f, -0.32640982f, 1.31905019f, 0.77857864f, 
    -0.99142540f, 0.52916622f, 0.34732494f, -0.54543978f, 0.07855293f, -0.09000478f, 0.00036721f, -0.64151287f, 
    -0.46057504f, -0.45666251f, 0.27553725f, 1.01508892f, -0.50647163f, 0.11626199f, -0.34230062f, 0.27308112f, 
    -0.32456291f, -0.97631866f, -0.62686533f, -0.86721522f, 0.60802191f, 0.90335572f, -0.30293682f, -0.35142344f, 
    -0.06795684f, -0.08148665f, -0.67670983f, 0.51791900f, -0.80208915f, -0.75160599f, -0.53195357f, 0.58290678f, 
    -0.18459795f, -0.61262172f, -0.28348249f, 1.05061388f, 0.34177837f, 0.37052226f, -0.87787950f, -1.13465369f, 
    0.41980085f, -0.10589806f, 0.44237414f, 0.16034301f, -1.10179079f, -0.71056241f, -0.29670802f, -0.50255179f, 
    -0.67925495f, 0.10006367f, -0.21991229f, 0.16613437f, -0.26214278f, -0.57976985f, 0.24125513f, -0.82117075f, 
    -0.57418764f, -0.15195560f, 0.59983873f, 0.06801321f, 0.78188759f, 0.28074619f, 0.31554389f, 0.18503262f, 
    0.22136222f, 0.37097692f, 0.58223820f, 0.50259680f, 0.20917346f, 0.80508113f, -0.14590620f, 1.12967646f, 
    -0.57137001f, -0.70148081f, -0.44033232f, -0.47959924f, -0.09275150f, -0.23186582f, -0.31167746f, 0.05747148f, 
    1.11663675f, 0.93294644f, -0.02340520f, 0.40080330f, -0.01926223f, 0.20913434f, -0.21230279f, 0.26867822f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13241568f, 0.00040208f, 0.08221892f, 0.10997713f, 0.09297097f, 0.01751945f, 0.22101592f, -0.01623873f, 
    -0.20812167f, 0.08710252f, -0.07289553f, 0.25434938f, 0.18169953f, -0.13810159f, -0.04393504f, 0.13218100f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01300087f, -0.04582924f, -0.04171041f, -0.05927164f, -0.03901475f, -0.02025559f, 0.05054613f, -0.00135674f, 
    0.04314301f, 0.03017123f, 0.04013713f, 0.01618997f, -0.06062514f, 0.02143191f, -0.01514303f, 0.02024824f, 
    0.00796045f, -0.05919163f, 0.04698557f, -0.05182381f, -0.00440962f, 0.02176254f, -0.06041056f, -0.01117939f, 
    0.00497778f, 0.01898076f, -0.04038790f, -0.05608037f, 0.02435325f, -0.05673815f, -0.05363164f, -0.00674218f, 
    0.02451931f, -0.06097357f, 0.00473857f, 0.03897111f, -0.06149408f, 0.00840531f, -0.01087412f, -0.04228409f, 
    0.02151862f, -0.01926885f, -0.01289417f, 0.00217690f, 0.01452474f, -0.00851935f, 0.00207804f, -0.01314870f, 
    0.01609821f, -0.04938504f, -0.00346374f, -0.01900210f, 0.02423393f, 0.04485318f, -0.02050458f, 0.02037186f, 
    -0.00147884f, -0.02039357f, -0.01146787f, 0.01316296f, 0.00589535f, -0.03087161f, 0.01971646f, 0.03843870f, 
    -0.04735570f, -0.05008481f, 0.02843435f, -0.03597553f, 0.05200456f, -0.02408891f, -0.04545635f, -0.04655782f, 
    0.00933672f, -0.02734553f, 0.00326716f, 0.00592618f, -0.05600027f, -0.04784650f, 0.02036624f, 0.02637185f, 
    -0.06665707f, -0.05182234f, -0.01858814f, -0.04308120f, 0.03602201f, -0.01964530f, -0.05020015f, 0.01134322f, 
    0.01242044f, 0.05578534f, -0.02766358f, -0.00428955f, -0.05146622f, 0.04278698f, -0.00574750f, 0.02415532f, 
    0.00494165f, 0.02370832f, -0.02803591f, 0.02848394f, 0.02407910f, -0.01542520f, 0.04512669f, -0.04496634f, 
    0.00704614f, -0.04053162f, -0.02348949f, -0.02356143f, 0.01137933f, 0.02947717f, 0.03721372f, -0.02212478f, 
    -0.03713579f, 0.00373311f, 0.01785574f, 0.01830876f, -0.04671065f, -0.01860875f, 0.04315533f, -0.01384225f, 
    0.05091429f, 0.04081959f, -0.02837010f, 0.04311755f, 0.03995308f, -0.00622460f, -0.06134518f, 0.01344326f, 
    0.00696087f, -0.05753025f, 0.04905858f, -0.00941138f, -0.00190345f, -0.03547869f, -0.05554138f, -0.00289941f, 
    0.00046778f, 0.02448615f, 0.04261863f, -0.04275672f, 0.01808786f, -0.01760534f, 0.01275150f, 0.02471837f, 
    -0.00941594f, 0.04727181f, -0.00789452f, -0.01740027f, 0.00480087f, -0.04213269f, 0.04502662f, -0.04397733f, 
    -0.05535083f, -0.05282845f, 0.00361417f, 0.02596818f, -0.00794057f, -0.04511040f, 0.04540268f, -0.03689266f, 
    -0.00714735f, -0.02039256f, 0.04241710f, -0.05455811f, 0.02744561f, 0.04221864f, -0.04668500f, 0.00775487f, 
    -0.00745483f, -0.00702718f, 0.00001928f, 0.03222280f, -0.02050603f, -0.02173348f, 0.01093358f, 0.00321039f, 
    0.00620942f, 0.00365131f, 0.03925306f, 0.05017145f, 0.04226271f, 0.01781770f, -0.00168111f, -0.06116254f, 
    0.04351493f, -0.04925033f, 0.01635398f, -0.06076661f, 0.00701518f, 0.04654424f, -0.04623056f, 0.02992086f, 
    -0.02533367f, 0.03066149f, -0.04224794f, -0.03772780f, 0.01344447f, -0.02362529f, -0.01827415f, -0.00510075f, 
    0.01848685f, -0.00957186f, -0.03176665f, 0.02989979f, -0.00859729f, -0.02213256f, 0.01603360f, -0.04229278f, 
    0.00085548f, 0.04526104f, -0.02115530f, -0.01919722f, 0.03035060f, -0.05009090f, 0.01873491f, -0.01083273f, 
    -0.04229642f, -0.00017377f, -0.04901113f, 0.03763970f, -0.05044743f, -0.04934074f, -0.00415529f, -0.02134390f, 
    -0.02465286f, 0.01618475f, -0.05774453f, 0.00206049f, -0.03250675f, -0.05100312f, 0.00708764f, 0.04195799f, 
    -0.01006864f, 0.03086738f, 0.01131559f, -0.04730789f, 0.04735231f, -0.05183164f, -0.02289673f, -0.01930706f, 
    -0.01264550f, 0.03387733f, 0.02532717f, -0.02854914f, -0.02368416f, 0.02457823f, -0.04120989f, -0.00533846f, 
    0.03194901f, -0.02048386f, -0.03722074f, -0.04981919f, -0.03719085f, 0.04478152f, -0.05871059f, -0.02104726f, 
    0.03802850f, -0.02518678f, 0.02537982f, 0.03587500f, -0.01386048f, 0.04938109f, 0.01636977f, -0.04470925f, 
    -0.01463567f, 0.01952047f, -0.03072325f, -0.03712862f, 0.02418211f, 0.04841951f, -0.03690632f, 0.04078092f, 
    -0.00407684f, 0.00918163f, -0.01650700f, -0.02750382f, -0.04827684f, -0.02481396f, 0.00112863f, -0.02729363f, 
    -0.00129840f, -0.01939645f, 0.01387301f, 0.01285494f, 0.04588062f, 0.03637137f, -0.05322844f, -0.01039154f, 
    0.00604120f, 0.03386967f, 0.03255759f, -0.01930908f, 0.00206141f, 0.03931432f, -0.04915489f, -0.00690035f, 
    -0.05166802f, 0.00477185f, 0.04418021f, -0.05722841f, -0.06256662f, 0.04081595f, -0.04289741f, -0.01501660f, 
    0.01504264f, -0.03260588f, 0.04502685f, 0.01469874f, 0.02340720f, 0.02853556f, -0.00001424f, -0.06364060f, 
    -0.02716148f, -0.02801612f, -0.05188485f, 0.03403189f, 0.04225212f, -0.00605929f, 0.03033549f, 0.02991956f, 
    0.24847525f, -0.08856559f, -0.21053647f, -0.12607528f, 0.15748629f, 0.01641014f, 0.07634544f, -0.03513148f, 
    -0.03300931f, 0.05526559f, -0.04705383f, 0.02293320f, -0.05232317f, 0.16194282f, 0.11126644f, -0.01955721f, 
    -0.01509856f, -0.15687120f, 0.02945223f, 0.00036037f, -0.04207278f, -0.06187445f, -0.22543421f, -0.03300123f, 
    0.04908217f, 0.17203005f, -0.05645647f, 0.10747971f, 0.27431092f, 0.08189637f, 0.05068514f, -0.04586994f, 
    0.05389680f, 0.04666862f, -0.00087742f, 0.19229242f, 0.10846380f, -0.14664946f, -0.07207043f, -0.04550300f, 
    -0.21756922f, -0.24121124f, 0.12577705f, 0.20263371f, 0.00758678f, 0.20148328f, 0.00291191f, -0.06020650f, 
    0.05307362f, 0.22403917f, 0.08756659f, -0.01604098f, 0.18661293f, 0.12075990f, 0.09708236f, -0.06474203f, 
    -0.10923412f, -0.07620685f, -0.05386622f, 0.01044611f, 0.22625427f, 0.13410547f, -0.00397354f, 0.09101924f, 
    0.19607089f, 0.03010782f, 0.12727493f, -0.00725808f, -0.01571819f, 0.09105135f, -0.03904112f, 0.01131513f, 
    0.11397630f, -0.05715133f, 0.02836340f, 0.04427869f, 0.17526710f, 0.09816357f, 0.25290981f, 0.09382266f, 
    0.17489964f, 0.02179635f, 0.24159808f, 0.08712953f, -0.13082144f, 0.07763185f, -0.00367305f, 0.16108538f, 
    -0.03993310f, 0.00016610f, 0.16225268f, 0.08688644f, 0.03706263f, -0.05706133f, -0.05722554f, 0.09670106f, 
    0.02404739f, -0.08870692f, -0.09871260f, -0.05652912f, 0.20532061f, 0.01044065f, 0.21662679f, 0.18389854f, 
    -0.24445409f, 0.08649918f, -0.09566531f, 0.28900006f, 0.16973679f, -0.05600090f, 0.09904689f, 0.05061537f, 
    -0.08307757f, -0.14525481f, -0.03942695f, -0.02287783f, -0.04515667f, -0.09949284f, -0.04703749f, -0.06449357f, 
    0.44207337f, 0.00419341f, 0.24135663f, 0.01930479f, -0.51409197f, 0.05484296f, 0.04331713f, 0.03409164f, 
    0.04928766f, 0.00795436f, -0.21227752f, -0.01056867f, -0.00349341f, 0.05219698f, 0.05974292f, -0.08297730f, 
    0.00622645f, 0.08762354f, -0.26352790f, 0.04287827f, -0.12626952f, -0.27733275f, 0.04835397f, 0.05358918f, 
    0.16743238f, 0.06133031f, -0.00342859f, -0.05127339f, -0.04536137f, 0.10134007f, -0.08416110f, 0.08014663f, 
    -0.06321250f, 0.18124728f, -0.08793759f, 0.00664609f, -0.11618303f, 0.18275481f, 0.02735962f, 0.02465141f, 
    0.01814421f, -0.15184091f, 0.07011850f, 0.19708972f, 0.03712126f, 0.00066533f, -0.16212951f, -0.14584953f, 
    0.00421589f, 0.19391520f, -0.09276798f, -0.08129629f, 0.21686471f, 0.04871052f, 0.11533588f, 0.07524212f, 
    0.09609812f, -0.00454114f, -0.01999751f, 0.05696340f, -0.07896722f, -0.17484324f, -0.06558912f, -0.00540944f, 
    -0.13085918f, 0.03845595f, 0.05319158f, 0.03135983f, -0.07783042f, -0.01759366f, 0.10330062f, 0.06048691f, 
    0.05887701f, 0.09135836f, -0.08978415f, -0.06635667f, -0.12890480f, -0.01330382f, 0.26029393f, 0.01901537f, 
    0.05000967f, -0.00449903f, 0.21013923f, -0.21499473f, -0.08941308f, -0.01528438f, 0.12271403f, -0.09876349f, 
    -0.00758480f, -0.06313791f, -0.04929281f, -0.09725735f, -0.05542152f, -0.06274583f, -0.01166174f, 0.01503188f, 
    0.03709749f, 0.02023558f, -0.02878229f, 0.02935067f, 0.06493364f, 0.11085492f, -0.10257731f, -0.12977907f, 
    0.03487466f, -0.04809037f, -0.02633645f, 0.05798630f, -0.05600658f, 0.01752312f, -0.02992648f, 0.00752996f, 
    -0.00626333f, -0.03902486f, 0.04534651f, 0.04595069f, -0.01346201f, 0.15342419f, 0.10744482f, 0.11605893f, 
    -0.14624913f, -0.02986558f, -0.04379273f, 0.10483766f, 0.04678360f, 0.08100994f, -0.02632577f, 0.09868198f, 
    -0.02805998f, 0.07304087f, 0.12825863f, -0.07523102f, -0.11247507f, -0.06448219f, 0.01691400f, -0.07607754f, 
    -0.19669423f, 0.06804188f, 0.21115428f, -0.07066440f, 0.13146955f, -0.05582146f, -0.10142138f, 0.12082423f, 
    -0.05085670f, -0.00247658f, 0.05589225f, -0.04570087f, -0.14385897f, -0.11752221f, -0.04742607f, 0.12121701f, 
    -0.02068914f, 0.04154838f, 0.05673130f, -0.05761403f, -0.05891692f, -0.25532722f, 0.03987826f, -0.21485460f, 
    0.05841815f, -0.06203358f, -0.28659818f, -0.24229908f, -0.09939549f, -0.00653201f, 0.17879471f, 0.10707870f, 
    -0.21026149f, -0.12280168f, 0.03505363f, -0.15441719f, 0.05760043f, -0.09389359f, -0.10422038f, 0.14385240f, 
    0.06874628f, 0.28373972f, -0.01434091f, 0.13217419f, 0.35415256f, 0.11814972f, -0.04537511f, -0.01786828f, 
    0.02921186f, 0.02120985f, -0.03074887f, 0.08690500f, 0.04698126f, -0.01849967f, 0.04073585f, 0.06587446f, 
    -0.04455577f, 0.07191677f, -0.08290455f, 0.05793425f, 0.04223864f, -0.06122801f, -0.04353900f, -0.07452679f, 
    0.02750120f, 0.02012089f, -0.05878383f, 0.02731617f, -0.03203041f, 0.05276740f, -0.04164404f, 0.02791598f, 
    -0.01214737f, 0.00509703f, 0.00977315f, 0.02298079f, -0.00994720f, -0.00925397f, -0.06287741f, 0.02844105f, 
    0.00614257f, 0.01839728f, -0.00141136f, -0.01603649f, -0.02049838f, 0.02051588f, -0.00717948f, 0.00602713f, 
    -0.02448910f, -0.05878005f, -0.02600343f, 0.04981651f, -0.03047675f, -0.05195826f, 0.03772650f, 0.00020160f, 
    -0.00399035f, 0.02938385f, -0.03506914f, -0.04291986f, -0.04673349f, 0.02497349f, -0.03763731f, 0.00584184f, 
    -0.03673975f, 0.01080031f, -0.03293175f, -0.00582124f, -0.02448981f, 0.02135155f, -0.04658691f, 0.03918057f, 
    -0.06248156f, 0.01509644f, -0.04835525f, -0.00067432f, -0.02422024f, -0.03403400f, -0.05002440f, -0.01129498f, 
    -0.04267937f, -0.06828517f, -0.06494161f, -0.06331207f, -0.05650288f, -0.04162576f, 0.02813874f, -0.05274172f, 
    0.05017896f, -0.06942002f, 0.02703407f, 0.00040379f, 0.01882560f, 0.02356073f, 0.00666002f, -0.02030786f, 
    0.00271255f, -0.02290998f, -0.06897723f, 0.02522061f, -0.03726793f, -0.02409328f, -0.00297927f, -0.00721082f, 
    0.00412905f, 0.02386616f, 0.02296416f, 0.03439076f, 0.01132818f, -0.01389998f, 0.00631434f, -0.04197870f, 
    -0.00918851f, -0.03059337f, 0.00644252f, 0.02808136f, 0.00996451f, -0.04575212f, 0.00819759f, -0.01355533f, 
    0.02920072f, -0.01814700f, -0.03035376f, 0.03628914f, 0.04083779f, -0.02058417f, 0.03559576f, 0.03087433f, 
    -0.04836059f, 0.00827522f, 0.00428635f, 0.02981482f, 0.00822252f, 0.04843110f, -0.05733313f, 0.03929451f, 
    -0.04148779f, 0.03030685f, -0.00345470f, 0.03256977f, -0.06682155f, 0.00294840f, -0.00798715f, 0.03507133f, 
    -0.01324966f, -0.01310972f, -0.04701209f, -0.03304577f, -0.00512634f, 0.02879108f, 0.03589915f, -0.05817768f, 
    -0.06285901f, 0.00454552f, -0.06246540f, -0.01205953f, 0.00202349f, -0.03595373f, -0.01691007f, -0.04518421f, 
    -0.02907899f, -0.03945359f, -0.02226298f, -0.01749392f, -0.03636508f, -0.00558683f, -0.03251496f, -0.05438542f, 
    0.04332275f, -0.02865865f, -0.00655000f, -0.00784702f, 0.02971590f, -0.04785050f, -0.00338785f, 0.01994036f, 
    -0.02521938f, 0.01284899f, -0.01810126f, 0.03083616f, -0.01191820f, -0.03719698f, -0.01435540f, -0.02752930f, 
    0.05312181f, 0.00919759f, -0.02926857f, 0.04572833f, -0.06081836f, -0.00767782f, -0.04495782f, 0.02543664f, 
    0.01071004f, -0.01418670f, -0.02844439f, -0.01378042f, -0.06011539f, 0.02892084f, 0.00916474f, -0.05602358f, 
    -0.04928408f, -0.01840438f, 0.00677896f, -0.00329505f, -0.00535617f, -0.04459606f, 0.05050385f, -0.00224706f, 
    -0.02017139f, -0.00748973f, -0.06178863f, -0.02710778f, 0.01390516f, -0.01218252f, 0.03287006f, 0.02577920f, 
    0.02890362f, -0.03175863f, 0.03453444f, -0.04508800f, 0.03865875f, -0.01093352f, 0.04854507f, -0.00535318f, 
    0.06178758f, 0.02315648f, 0.02112439f, 0.01816700f, -0.00983982f, 0.02397168f, 0.04438805f, -0.01598403f, 
    0.00520194f, 0.01173847f, 0.04151215f, -0.06604547f, -0.03531383f, 0.03996621f, -0.02563533f, 0.05049033f, 
    -0.04533399f, -0.02782807f, 0.02292434f, 0.01902777f, -0.02196617f, 0.03377328f, -0.00598877f, 0.01840807f, 
    -0.00944956f, 0.00691355f, -0.02805910f, -0.06700566f, 0.02840848f, 0.01807043f, 0.02688710f, 0.00457584f, 
    0.04178204f, -0.00959572f, -0.01104144f, -0.02032522f, -0.04143702f, -0.04997058f, 0.01898692f, -0.06152479f, 
    0.02132936f, 0.04004199f, 0.00946554f, -0.02477383f, -0.02817350f, 0.00903914f, 0.04686452f, 0.04186128f, 
    -0.02162375f, -0.01321062f, -0.02375485f, 0.00731337f, 0.00712037f, 0.01702083f, 0.00481182f, -0.01255526f, 
    0.01863471f, 0.04237222f, 0.02770820f, -0.06123129f, -0.06044277f, -0.01133140f, -0.07241505f, 0.03319035f, 
    -0.02373051f, 0.04584935f, -0.00816166f, -0.02198598f, 0.01849403f, -0.00123327f, -0.04959008f, -0.05904591f, 
    -0.02050726f, -0.00762508f, -0.04587127f, 0.00981017f, -0.01976363f, 0.00771239f, 0.02797152f, -0.03292789f, 
    -0.03523055f, 0.03034648f, 0.02789322f, -0.01561211f, -0.00951323f, -0.00891364f, 0.01991020f, -0.06623779f, 
    0.04135882f, 0.03401940f, 0.03257214f, 0.03444984f, -0.01363746f, 0.01803689f, 0.02052763f, -0.00289368f, 
    -0.05784579f, -0.02521266f, 0.03731143f, 0.04099445f, 0.00740739f, -0.01232758f, 0.01761589f, 0.03917114f, 
    -0.04269822f, -0.01584309f, 0.00300670f, 0.02651978f, -0.01427977f, -0.01879758f, 0.02359173f, 0.00243424f, 
    -0.06087223f, -0.06264853f, 0.00013239f, -0.06255367f, -0.03699219f, -0.02725251f, -0.05415087f, 0.00727378f, 
    0.29883617f, 0.20617035f, -0.00430088f, -0.05237702f, -0.01765054f, -0.02504456f, 0.01928340f, -0.01123997f, 
    0.07899652f, 0.01028285f, 0.06668194f, -0.05469064f, -0.05123662f, -0.02735221f, -0.01587318f, -0.01086660f, 
    0.14315945f, -0.16972157f, -0.03586917f, 0.10970653f, 0.26442552f, -0.00623407f, -0.16275372f, -0.25848654f, 
    -0.02910256f, 0.19630691f, -0.02989099f, 0.16824864f, 0.01263656f, -0.11063394f, -0.11496517f, -0.06433816f, 
    0.12376953f, 0.11633179f, -0.01324589f, 0.10992543f, 0.05040289f, -0.25122610f, -0.12058586f, 0.01335288f, 
    0.15259455f, -0.02291734f, 0.08219216f, 0.12804276f, -0.08252295f, 0.03814605f, -0.01475149f, -0.02858780f, 
    0.11088621f, 0.08038118f, 0.08353266f, -0.06531185f, 0.03594964f, 0.10559473f, 0.10943311f, 0.00292621f, 
    -0.00515638f, 0.00718122f, -0.00518765f, 0.11800585f, 0.19446054f, -0.15089500f, -0.18510862f, -0.00519215f, 
    -0.07946140f, -0.06950264f, 0.05049723f, -0.04124975f, 0.02206025f, 0.11527222f, 0.05639224f, 0.09654418f, 
    -0.05148955f, -0.05879854f, 0.05011282f, -0.00982841f, 0.00089910f, -0.11847439f, 0.22505081f, 0.08237191f, 
    0.09510773f, 0.05416428f, 0.13040093f, -0.13905691f, 0.29300517f, 0.05926862f, -0.10461042f, -0.04609315f, 
    -0.18026583f, 0.05736586f, -0.08876270f, -0.01427395f, 0.01356529f, -0.17449531f, -0.05745844f, 0.09585474f, 
    0.09133139f, -0.08839732f, -0.07274884f, -0.02619464f, 0.06103838f, 0.10630878f, -0.20958309f, 0.07920186f, 
    0.06123121f, -0.12606497f, -0.21468371f, 0.06484413f, 0.07042729f, -0.24336611f, -0.14059666f, 0.15397526f, 
    0.29910293f, -0.16899468f, 0.03568782f, 0.11576495f, 0.23793928f, -0.36463305f, -0.23472223f, -0.07243390f, 
    0.13275707f, -0.00723049f, 0.37355924f, -0.26096275f, 0.36676574f, -0.21341211f, -0.09492308f, 0.05334431f, 
    0.01043379f, -0.17455967f, -0.07610928f, -0.00758473f, 0.03206475f, 0.04524470f, -0.00532827f, 0.24709731f, 
    -0.04760140f, 0.13529354f, -0.35370001f, 0.12929499f, 0.80379373f, 0.01996307f, 0.11566464f, -0.03219536f, 
    0.01901444f, 0.05288261f, 0.03664550f, -0.11346141f, 0.13327256f, 0.09592158f, -0.05483428f, 0.10177837f, 
    -0.19594444f, 0.24210371f, 0.02436529f, 0.03205114f, -0.09315887f, -0.03513837f, 0.13875291f, 0.07927026f, 
    0.32779893f, 0.32499242f, -0.28980371f, 0.29402265f, -0.18198311f, -0.07844318f, 0.05004162f, 0.07580408f, 
    0.01906744f, 0.14225429f, -0.18000266f, 0.06488091f, 0.17903750f, 0.00154028f, 0.05432760f, 0.11043515f, 
    0.01631700f, -0.18297055f, 0.06511800f, 0.02073125f, 0.21792996f, -0.30251527f, -0.15752698f, 0.02246933f, 
    -0.24347526f, -0.05663132f, 0.04121337f, -0.04799391f, -0.13769230f, 0.03977397f, 0.06636010f, 0.15480001f, 
    -0.00100902f, -0.05964743f, -0.13708968f, 0.09469386f, -0.07031219f, -0.09286364f, 0.27789676f, 0.06849403f, 
    -0.13362366f, 0.13232303f, 0.00527249f, -0.32479480f, 0.07478476f, -0.07544074f, -0.09588908f, -0.06817175f, 
    -0.02480968f, -0.08644021f, 0.05099284f, 0.10782932f, 0.09739913f, -0.04752742f, -0.16217950f, 0.00673607f, 
    -0.00449734f, 0.05619077f, -0.03123067f, -0.06207015f, 0.16354677f, -0.49856550f, 0.17063664f, -0.01960460f, 
    -0.13395721f, 0.00213890f, 0.23323649f, -0.05359709f, 0.01284722f, 0.01408834f, -0.02520985f, -0.03000045f, 
    -0.26708674f, -0.06209349f, 0.16333643f, 0.01750198f, 0.10815521f, 0.08880923f, 0.03150536f, 0.10469066f, 
    0.12489519f, -0.29350823f, -0.32529911f, 0.05118749f, -0.26882544f, 0.10359349f, 0.12239375f, 0.05754206f, 
    -0.01768004f, -0.05733363f, -0.00782435f, 0.20594436f, -0.19006440f, -0.21510965f, 0.02429801f, 0.05744491f, 
    0.09402900f, 0.15060139f, 0.32884780f, 0.06598221f, -0.16715096f, 0.02040146f, -0.07206882f, 0.06682358f, 
    -0.20520042f, -0.19022623f, 0.13025858f, 0.03695692f, -0.27386093f, -0.21778005f, -0.14903809f, 0.03049590f, 
    -0.03066726f, 0.11453413f, 0.01056235f, -0.04611428f, -0.23405121f, 0.03898839f, -0.02377279f, -0.03886579f, 
    -0.08085588f, -0.22509909f, 0.06540307f, -0.27922818f, 0.11187828f, 0.06277353f, 0.03170137f, 0.02370337f, 
    -0.22486210f, 0.00856667f, -0.10588020f, 0.01410322f, 0.08054008f, -0.22364375f, -0.03487382f, 0.13639413f, 
    0.03725437f, 0.07661933f, 0.05041841f, -0.11140102f, 0.27852824f, 0.13715711f, 0.13648388f, -0.22527891f, 
    0.37411305f, -0.15577173f, -0.01512970f, -0.07936238f, 0.04187217f, -0.05362404f, 0.07656034f, 0.01244486f, 
    -0.04018736f, -0.01470700f, -0.14225936f, 0.04749015f, 0.08884281f, -0.07407709f, -0.02556305f, 0.03389456f, 
    0.13542250f, -0.00010079f, -0.09241647f, 0.02628071f, -0.27690363f, -0.15679123f, -0.09088077f, -0.07033061f, 
    -0.08922402f, 0.06375486f, 0.12467776f, -0.04699933f, -0.02624839f, -0.01871265f, 0.09191331f, -0.00360608f, 
    0.00877652f, 0.21479256f, 0.04404109f, 0.03593736f, -0.04772108f, 0.04725063f, 0.09735873f, 0.05072372f, 
    0.05963778f, -0.09613514f, 0.01836582f, -0.08423126f, -0.03232224f, 0.00875826f, 0.03498246f, 0.05684090f, 
    0.01970498f, 0.05570542f, 0.13215947f, -0.09650397f, 0.08890154f, 0.16494472f, 0.07473125f, -0.01591831f, 
    0.32646537f, 0.05649522f, -0.20916201f, -0.02116505f, -0.11661811f, -0.17725837f, -0.06070225f, 0.00056319f, 
    -0.08298905f, -0.04624617f, -0.00805792f, 0.00521824f, -0.06169159f, -0.08502574f, 0.01699781f, -0.00481565f, 
    0.09982514f, 0.02211247f, 0.07071175f, 0.09609553f, 0.18381688f, -0.21634781f, -0.13961628f, -0.01442037f, 
    -0.02195915f, 0.07332830f, -0.06037143f, -0.02971142f, 0.15317166f, 0.05473579f, 0.01564147f, -0.18434493f, 
    0.01895830f, 0.06485464f, 0.01854378f, 0.10902642f, 0.10281774f, -0.06751754f, -0.08981232f, -0.02662239f, 
    -0.16218971f, 0.35289401f, -0.20663328f, 0.14261079f, 0.04054691f, -0.02066653f, 0.15857650f, -0.01522776f, 
    0.05637292f, 0.03304985f, -0.10365874f, 0.15771596f, 0.02649525f, 0.12869878f, 0.07578404f, -0.02873404f, 
    -0.04480032f, 0.01338682f, 0.01934475f, 0.02359631f, -0.12622292f, -0.02221209f, -0.12711085f, 0.10209397f, 
    0.28873950f, 0.02170999f, 0.11667413f, -0.11934619f, -0.05173153f, 0.00315929f, -0.10742580f, -0.07413595f, 
    -0.07386226f, 0.18981740f, -0.16502206f, -0.15083382f, -0.20797801f, 0.19403900f, -0.00887611f, -0.06422752f, 
    0.22442235f, -0.49407217f, -0.04602003f, -0.10123261f, 0.00114106f, 0.01933140f, -0.16364689f, 0.14821883f, 
    -0.08847337f, 0.11905800f, 0.02791674f, 0.02383332f, 0.00110895f, 0.06903050f, 0.05335507f, 0.04614545f, 
    0.02261759f, -0.04010668f, 0.11817862f, 0.03181905f, 0.06548985f, -0.21250540f, -0.36178988f, 0.09070601f, 
    0.04258050f, 0.05966719f, -0.15128551f, 0.12036637f, -0.00689126f, 0.10903852f, 0.10870767f, 0.05963740f, 
    -0.02784639f, -0.09525532f, 0.08469834f, -0.04418708f, 0.08177268f, -0.10617461f, -0.03324075f, -0.00196356f, 
    0.18922608f, -0.36161891f, -0.26649618f, 0.09638156f, -0.15946080f, -0.07373757f, -0.08628264f, 0.10723066f, 
    -0.06136614f, -0.07455343f, 0.07057942f, 0.08162650f, -0.19571623f, -0.06292026f, -0.00203180f, 0.05357415f, 
    -0.07195002f, 0.09482007f, -0.06309935f, 0.11707747f, -0.18375489f, 0.24263443f, 0.10918458f, 0.02679117f, 
    -0.13129251f, 0.12007428f, 0.14163662f, -0.02466822f, 0.10033919f, 0.00913427f, -0.07912381f, 0.02631851f, 
    0.06382452f, 0.17738499f, 0.09402180f, 0.06756935f, 0.21102971f, -0.02631003f, -0.05579929f, -0.17371620f, 
    0.39045665f, 0.15057631f, 0.03568162f, 0.07209226f, 0.05783476f, 0.23207211f, 0.01560070f, 0.15676416f, 
    -0.04501159f, 0.08880533f, 0.00063513f, 0.04566990f, 0.11532167f, 0.04257968f, -0.05872072f, 0.05381076f, 
    0.05826423f, -0.22635327f, 0.04440088f, 0.12528408f, -0.01245695f, -0.07055812f, -0.10826629f, -0.01931486f, 
    -0.01903234f, 0.01685267f, 0.06955614f, 0.04717147f, -0.03185378f, 0.22291580f, 0.01954425f, 0.10133999f, 
    0.15450686f, 0.22589502f, -0.04182014f, -0.12641397f, 0.23514992f, -0.03268913f, -0.15151945f, -0.00114803f, 
    0.03314326f, 0.17888644f, 0.11321957f, -0.05540426f, -0.15453634f, -0.03618821f, 0.04921450f, -0.09727421f, 
    0.08114856f, 0.06226666f, 0.04100414f, 0.06217453f, 0.09641305f, 0.01463677f, -0.05106139f, 0.21961182f, 
    0.22293697f, 0.04653366f, -0.20000823f, 0.10848595f, 0.13262039f, 0.13432577f, 0.17457947f, 0.01955143f, 
    -0.12947817f, -0.21496743f, -0.05821502f, 0.05666475f, 0.13294294f, -0.03523629f, 0.09786152f, -0.01142987f, 
    -0.06231423f, -0.19379394f, -0.02327117f, 0.18883298f, 0.10874226f, 0.11189532f, 0.07164415f, 0.15670876f, 
    0.01110257f, -0.01742940f, -0.15228996f, -0.03388691f, 0.02131862f, -0.00523307f, 0.01682574f, -0.01883676f, 
    0.12911028f, 0.11687131f, -0.09334785f, 0.02719146f, 0.08123492f, 0.16431832f, 0.06960402f, -0.13272950f, 
    -0.02117776f, -0.16191660f, -0.05807262f, -0.04589246f, -0.11999486f, -0.01718064f, -0.03069009f, 0.18017644f, 
    -0.11036543f, -0.01072307f, 0.11731220f, -0.02548972f, -0.01697650f, 0.03822588f, -0.00531097f, 0.06708078f, 
    0.04516488f, -0.00839297f, 0.10848885f, 0.07700223f, -0.14199135f, 0.04812582f, 0.02035353f, 0.02456054f, 
    0.07196760f, -0.17486705f, 0.15184565f, 0.04998441f, -0.01953357f, -0.04208127f, 0.02610326f, -0.09370237f, 
    0.15794823f, -0.03119509f, -0.05425276f, 0.00788582f, 0.02581795f, 0.05899911f, -0.02478044f, -0.06537532f, 
    0.10423487f, -0.01331222f, -0.08310109f, 0.07843667f, -0.34190193f, -0.41135687f, -0.05274395f, -0.10036148f, 
    -0.15391465f, -0.02591486f, 0.02590893f, 0.06418067f, 0.06548884f, 0.04569494f, -0.12375332f, -0.01780795f, 
    0.04688117f, -0.01780247f, -0.05707042f, -0.01830070f, 0.00343689f, 0.00648828f, 0.01869473f, 0.04054245f, 
    0.16833925f, -0.18638690f, 0.02351169f, -0.12148592f, -0.16916864f, -0.02205923f, -0.15846182f, 0.06901527f, 
    -0.00818350f, -0.18092738f, -0.06628054f, 0.01423812f, 0.04016916f, -0.03179119f, -0.11986556f, -0.04120844f, 
    0.00461080f, -0.00971247f, -0.09451115f, -0.07749672f, -0.12435415f, 0.40793344f, 0.00172370f, 0.07216524f, 
    -0.01621917f, 0.02524684f, -0.03438309f, 0.02361544f, -0.01082672f, 0.00370622f, -0.10196847f, -0.01726621f, 
    -0.05218122f, -0.09845165f, -0.01105245f, -0.00958444f, 0.00501273f, 0.05051600f, 0.11844797f, -0.01352232f, 
    -0.41942787f, -0.01314990f, -0.04038664f, -0.03803071f, 0.01513262f, 0.02381696f, -0.09685352f, 0.00607306f, 
    0.05321125f, 0.05177868f, -0.03449070f, -0.05035768f, -0.02622717f, -0.03728381f, -0.16005087f, 0.04281822f, 
    0.17818999f, -0.09224270f, 0.00270005f, -0.10880866f, -0.38569272f, -0.24621217f, -0.09370077f, -0.14634618f, 
    -0.11513223f, -0.08326036f, -0.03868600f, 0.00973827f, 0.01678351f, 0.02591051f, 0.05271102f, 0.08694360f, 
    0.00913863f, 0.01858153f, 0.11895613f, 0.02418877f, 0.12290810f, -0.18052618f, 0.03134747f, 0.13077067f, 
    -0.22009221f, -0.03858908f, -0.16493830f, 0.32328281f, 0.05358839f, -0.03680285f, 0.09746211f, -0.13338676f, 
    0.20920524f, -0.12729208f, 0.00718891f, 0.07367220f, -0.00401570f, -0.05317372f, -0.00774478f, -0.16313861f, 
    0.03800803f, -0.02118949f, -0.12698182f, -0.02721440f, 0.21281084f, 0.30807662f, 0.06273012f, 0.21223752f, 
    -0.09769423f, -0.03792793f, -0.01261296f, -0.01049658f, -0.04906838f, -0.22126622f, -0.11969183f, -0.06924559f, 
    -0.11465297f, 0.07590087f, -0.09172919f, 0.05130961f, 0.00973698f, 0.04944324f, 0.04494650f, -0.03525227f, 
    -0.01414113f, -0.17907083f, 0.23307492f, -0.13364030f, 0.01767614f, -0.02229094f, -0.14782614f, -0.04097940f, 
    -0.14851518f, -0.04389341f, -0.05141036f, -0.03746459f, 0.05479145f, -0.05826476f, -0.02225773f, 0.01354842f, 
    0.03613970f, -0.07599897f, -0.10583428f, 0.13910133f, 0.08716188f, 0.12917182f, 0.00682506f, 0.07182952f, 
    0.03230470f, -0.03879511f, -0.16213427f, 0.08572488f, -0.07950981f, 0.09972396f, -0.11827093f, -0.06862168f, 
    -0.10470612f, -0.09572975f, 0.00355151f, 0.02548531f, -0.08545516f, -0.01450559f, 0.13285547f, 0.07316940f, 
    0.12704256f, -0.00902246f, -0.08322202f, 0.19884987f, 0.09879193f, 0.04053104f, -0.02122265f, -0.03974503f, 
    0.13218533f, -0.07548024f, 0.07447623f, 0.09516022f, -0.01080550f, 0.02040337f, -0.15551464f, -0.03785269f, 
    0.00268936f, 0.07376308f, 0.00405433f, -0.05943117f, 0.22146317f, 0.12790844f, 0.00127668f, -0.09418263f, 
    0.07206365f, -0.12328945f, -0.04878309f, 0.02275542f, 0.04557447f, -0.02686301f, -0.01894177f, -0.06315759f, 
    -0.19481403f, -0.14785188f, -0.03530805f, 0.10936289f, -0.10091702f, -0.01535470f, 0.08132728f, 0.03319688f, 
    -0.01663370f, -0.05809392f, -0.00903076f, 0.12702043f, 0.04555557f, 0.05555191f, 0.00975793f, 0.12985884f, 
    -0.00534265f, -0.08137266f, -0.02352665f, -0.01176431f, -0.03156482f, -0.11249208f, 0.02178040f, 0.05607972f, 
    0.12642904f, 0.06069203f, 0.05505334f, 0.04325882f, -0.38988703f, -0.30788580f, -0.07074192f, -0.00255855f, 
    0.13481574f, 0.03512635f, 0.05890581f, -0.01842386f, 0.06557510f, 0.09510010f, -0.02726956f, -0.05149449f, 
    0.00809016f, -0.01135813f, 0.05482105f, -0.06174630f, -0.02978546f, 0.07144433f, -0.09489381f, -0.04412791f, 
    0.00841708f, 0.31665602f, 0.10640740f, 0.21132375f, 0.21223068f, 0.06406152f, 0.08725056f, 0.05046501f, 
    0.09549488f, 0.06775217f, 0.03927403f, 0.05059590f, -0.03740457f, -0.10720890f, -0.10874157f, 0.11698749f, 
    -0.00430197f, 0.06007954f, 0.00937633f, 0.01227543f, -0.17260450f, 0.04934832f, 0.02819953f, -0.21580990f, 
    -0.04143350f, -0.00988776f, -0.09374584f, -0.02874154f, 0.07670436f, -0.00901651f, 0.03732228f, 0.01793337f, 
    -0.04152878f, 0.06330302f, 0.00220654f, 0.04104576f, 0.12487306f, 0.03094823f, 0.03219972f, -0.00332699f, 
    0.04052868f, -0.03923818f, 0.00819599f, -0.00105381f, -0.04485217f, 0.01359946f, -0.04744341f, -0.04314129f, 
    0.03290531f, 0.04261314f, -0.03228855f, -0.00070368f, -0.03016794f, 0.02518163f, -0.03598505f, -0.00404535f, 
    0.02625954f, -0.03993063f, -0.00545147f, -0.03832695f, -0.02519214f, -0.04775542f, 0.04090106f, -0.05209128f, 
    -0.03904947f, 0.02245822f, 0.00136099f, -0.02839138f, 0.02799769f, -0.01879320f, -0.00545116f, -0.00720051f, 
    -0.01500265f, 0.02917992f, -0.05906140f, 0.04033149f, 0.02076285f, 0.01075760f, 0.03310431f, 0.02920677f, 
    0.00494805f, 0.04537179f, -0.01759132f, -0.01940858f, -0.03746833f, -0.02012729f, -0.03112326f, -0.01692434f, 
    -0.05224879f, 0.04179757f, 0.03557704f, 0.01874880f, -0.04214823f, -0.04616367f, -0.01948052f, -0.03820504f, 
    0.03728591f, 0.03648376f, -0.04413939f, 0.00945844f, -0.06069573f, -0.01769579f, -0.01459740f, 0.01869215f, 
    -0.06058387f, 0.03689678f, -0.03264256f, 0.04589343f, 0.01688213f, 0.03467823f, 0.01956578f, -0.05797084f, 
    -0.04738789f, 0.04002719f, 0.03285172f, -0.02833910f, 0.03581141f, -0.05083105f, -0.03291635f, -0.05730448f, 
    0.02031427f, -0.05066082f, -0.05616197f, 0.03452327f, 0.00727788f, -0.04052831f, 0.01728531f, -0.06117538f, 
    0.00604025f, 0.02056530f, 0.00016664f, 0.00314238f, -0.01951719f, -0.05562781f, 0.02153473f, 0.04296451f, 
    0.00245495f, -0.01328130f, -0.04488509f, 0.03110718f, 0.01818017f, 0.02095656f, -0.04017658f, -0.04093152f, 
    -0.03237420f, -0.04599824f, 0.01735186f, -0.05742036f, -0.05171364f, 0.00087781f, -0.01800279f, -0.03041672f, 
    -0.01329005f, 0.02854148f, -0.00366373f, 0.02544235f, -0.02152969f, 0.01406182f, -0.05880837f, -0.01652504f, 
    -0.00925857f, -0.05093280f, 0.04493866f, -0.02824651f, 0.00502612f, 0.03041265f, -0.03954000f, 0.03509600f, 
    -0.01332984f, -0.03072030f, 0.04035601f, -0.04555212f, -0.05896266f, -0.01574952f, -0.02948772f, 0.03986201f, 
    -0.00424755f, -0.05189025f, 0.03948449f, 0.03513127f, -0.03527445f, -0.04978717f, 0.01470216f, -0.00195554f, 
    0.00736124f, 0.00164165f, 0.02701199f, -0.03464173f, 0.02821383f, 0.00018801f, -0.01538999f, 0.01812251f, 
    -0.05859714f, 0.02761964f, -0.05259607f, -0.05704563f, 0.04732380f, -0.05928880f, 0.02170378f, -0.00860252f, 
    0.01357380f, -0.03355900f, -0.04860723f, 0.01601868f, 0.02398190f, -0.03831345f, -0.06023574f, -0.01469799f, 
    -0.03706804f, -0.04865228f, -0.02544709f, -0.05432932f, 0.00361784f, 0.03281783f, -0.03346759f, -0.01763476f, 
    -0.01415163f, -0.05313678f, 0.00965296f, -0.03225777f, 0.02727448f, 0.01735105f, -0.02765688f, 0.03910099f, 
    -0.05580210f, -0.03870222f, -0.06054479f, 0.03499976f, -0.04157020f, 0.04677079f, 0.04088780f, -0.02361689f, 
    -0.05809793f, 0.00018576f, -0.01091152f, -0.05773024f, 0.03156914f, 0.02242965f, -0.01704196f, 0.02193506f, 
    -0.04228604f, -0.04596609f, -0.02913742f, -0.06006119f, -0.05139124f, 0.00698075f, 0.02117300f, 0.02882502f, 
    0.00883544f, -0.04563889f, 0.00322411f, -0.04955891f, -0.05983505f, -0.06154272f, 0.01565455f, -0.01664739f, 
    0.00076439f, -0.03790223f, -0.01901583f, 0.03580068f, -0.05678143f, 0.01570682f, -0.04553630f, 0.02317728f, 
    -0.04247828f, -0.04662754f, 0.02362984f, -0.03074210f, 0.03988511f, 0.00313047f, 0.04379903f, 0.03676425f, 
    -0.02717117f, -0.01620654f, -0.05043625f, -0.00620969f, -0.03731608f, -0.06100271f, -0.00156015f, -0.04378518f, 
    0.03346629f, 0.00357655f, 0.02699660f, -0.03033500f, -0.04429227f, 0.03271326f, -0.03618101f, -0.05132848f, 
    0.01740423f, -0.05554662f, 0.02082412f, -0.05878484f, 0.03221117f, 0.03210709f, 0.00139024f, -0.04618726f, 
    -0.00788022f, 0.00653725f, -0.02360948f, 0.04613589f, -0.05343895f, -0.02415359f, -0.06069802f, 0.01955502f, 
    -0.05259641f, 0.02729194f, -0.00985752f, 0.03417188f, -0.05776165f, 0.00594133f, -0.01586820f, 0.00681800f, 
    0.04562241f, 0.04307783f, 0.03068976f, 0.00367832f, 0.03956753f, 0.01303684f, 0.00873676f, -0.00959280f, 
    0.01593857f, 0.03454442f, 0.02670810f, 0.04452938f, -0.05290638f, 0.00890950f, -0.03835800f, -0.05470691f, 
    -0.03449686f, -0.03353009f, -0.00387397f, -0.02325208f, 0.01176106f, -0.00077985f, -0.05561069f, 0.00077594f, 
    0.02616876f, 0.01854007f, -0.02350218f, -0.02059583f, 0.03274300f, -0.04156332f, 0.03071045f, -0.02944187f, 
    -0.01002190f, 0.03221878f, -0.02712995f, -0.02354573f, 0.04316789f, -0.04357123f, -0.00073002f, -0.04564423f, 
    0.02149509f, 0.04451565f, -0.04265038f, -0.01007099f, 0.01927634f, -0.04907804f, 0.02864642f, -0.05977358f, 
    -0.26614419f, 0.09456067f, 0.00905533f, 0.12254321f, -0.26839170f, -0.02662601f, 0.14888631f, 0.05117520f, 
    0.07473651f, -0.02931475f, -0.07977945f, 0.00580711f, -0.03214524f, 0.02988262f, -0.00682837f, 0.05662407f, 
    0.05995350f, 0.01063599f, -0.03525792f, 0.02997556f, -0.15391122f, -0.12769186f, 0.09793678f, 0.08291609f, 
    -0.03817823f, -0.04405930f, 0.06029840f, -0.01545998f, -0.00486193f, 0.14082675f, -0.11508983f, 0.04022419f, 
    0.08740187f, -0.07535618f, -0.14804661f, 0.01399545f, -0.05662921f, 0.02126646f, -0.00862603f, -0.06265131f, 
    0.13174045f, 0.05973929f, -0.23242976f, -0.14138465f, -0.16343500f, 0.12948090f, 0.03620787f, 0.08400051f, 
    0.00380165f, -0.03473683f, 0.00004139f, 0.09133991f, 0.13290271f, -0.00757228f, -0.05478617f, 0.15128350f, 
    0.12482223f, 0.03901689f, 0.06943313f, 0.06196538f, -0.37419915f, 0.35360634f, -0.20142174f, 0.00209853f, 
    0.06852496f, 0.03204082f, -0.01410184f, 0.03849844f, 0.02438984f, -0.01355902f, -0.00315043f, -0.09219413f, 
    0.03512808f, -0.03913891f, -0.05892185f, 0.05388237f, 0.03412353f, 0.00143660f, -0.09113025f, -0.04196684f, 
    -0.11984491f, 0.31673840f, -0.05361390f, 0.22271174f, 0.25305170f, -0.13493562f, -0.06226567f, 0.08902348f, 
    0.15128142f, -0.01734728f, 0.12649870f, 0.02723960f, -0.02551427f, 0.02909085f, -0.02244188f, 0.07706525f, 
    0.02098259f, -0.04113586f, -0.05011785f, -0.06642301f, 0.27139866f, -0.08422279f, 0.10786414f, -0.01259062f, 
    0.23516618f, -0.05910957f, -0.01765163f, -0.02635993f, -0.10347827f, 0.00575415f, -0.03954650f, -0.04453658f, 
    -0.05020323f, 0.11597072f, 0.03614014f, 0.06641486f, -0.04381543f, 0.02683214f, 0.11282308f, 0.04234270f, 
    0.57998896f, -0.06752258f, -0.15634573f, 0.05778201f, -0.05889006f, -0.07118834f, -0.12508033f, -0.09673470f, 
    0.02241233f, -0.03836024f, -0.08372447f, -0.02264539f, -0.05165100f, -0.02484843f, 0.01881076f, -0.17121314f, 
    0.01084553f, -0.17745076f, 0.01481358f, -0.05813250f, -0.29778910f, 0.31022012f, -0.23006330f, -0.11905118f, 
    -0.23870431f, 0.06197760f, 0.05118010f, 0.08750322f, -0.07544186f, -0.13336204f, -0.01862735f, -0.06375507f, 
    0.06925873f, -0.11207025f, 0.02547481f, 0.04293616f, 0.06854444f, -0.01052571f, 0.07045636f, 0.01618639f, 
    -0.38525546f, -0.14930931f, 0.28382999f, -0.27580270f, 0.00297268f, 0.04035708f, -0.07408043f, -0.10545211f, 
    -0.00598828f, -0.03556180f, 0.06049810f, -0.02884717f, -0.00180893f, 0.07048400f, 0.03438931f, -0.01607464f, 
    -0.04173302f, 0.05289014f, 0.07833235f, -0.08563559f, -0.18889338f, 0.06338803f, 0.04337625f, 0.15250380f, 
    0.18145652f, 0.11367489f, 0.03326515f, 0.02229247f, 0.05463342f, 0.02306347f, -0.14256147f, -0.08161956f, 
    -0.14131153f, -0.08420846f, 0.11786194f, 0.02750999f, 0.02943076f, 0.07848453f, -0.07656709f, 0.06738080f, 
    0.16748592f, -0.36763179f, 0.15097348f, 0.16978131f, 0.14053287f, 0.00476953f, 0.01248412f, -0.15183809f, 
    0.04197413f, 0.06270558f, -0.01279962f, 0.09225652f, -0.04248279f, 0.11295182f, -0.05945185f, -0.11580104f, 
    -0.01588759f, -0.10072089f, 0.07311386f, 0.04288162f, 0.06846756f, 0.23978503f, 0.07848720f, 0.08398938f, 
    0.29821643f, -0.04506925f, -0.10323565f, 0.03468429f, 0.15211456f, 0.11176682f, 0.05939750f, 0.10175845f, 
    0.09271656f, -0.01488035f, -0.10628145f, 0.02827082f, -0.07741992f, 0.01692213f, 0.03578809f, 0.03892105f, 
    -0.31090242f, -0.32545489f, 0.02032075f, 0.16004570f, 0.13856795f, 0.14869140f, -0.06472670f, 0.08353005f, 
    -0.00929057f, 0.00076116f, 0.01907215f, -0.03385698f, 0.05882519f, 0.07717701f, 0.07961608f, 0.02185821f, 
    -0.00544451f, 0.00241029f, -0.11941611f, -0.03137295f, -0.14345118f, -0.08200422f, 0.02723486f, -0.06646916f, 
    0.13052268f, 0.03678094f, -0.00642658f, 0.07115541f, 0.12581313f, 0.06646809f, -0.00268114f, 0.00117982f, 
    0.03616111f, -0.16886985f, 0.01789787f, 0.10300650f, 0.11584675f, -0.00301959f, -0.20960045f, -0.01516719f, 
    0.32749444f, 0.41308284f, -0.09602286f, 0.10661763f, 0.27601224f, 0.03567857f, -0.01651277f, 0.07941438f, 
    0.11032971f, 0.03078070f, 0.22814403f, 0.05736682f, 0.08353408f, 0.01366327f, 0.08264025f, 0.02358962f, 
    0.03252117f, -0.13894700f, 0.06800636f, -0.00585927f, -0.12871106f, 0.21897656f, -0.04624216f, 0.13725001f, 
    0.09880510f, -0.02316157f, -0.05120476f, 0.12750246f, 0.07437187f, 0.01564888f, -0.08091290f, 0.00145208f, 
    0.00300089f, 0.07135235f, 0.04075398f, 0.05428648f, 0.12437175f, -0.06189964f, -0.02083017f, -0.10128232f, 
    -0.05537752f, -0.05035619f, -0.04877797f, -0.05292486f, -0.02431286f, -0.02129757f, 0.01308921f, -0.03123375f, 
    -0.01256383f, -0.02159884f, -0.03616428f, 0.04039899f, -0.01453024f, 0.04738442f, 0.02720392f, -0.02656512f, 
    0.01206646f, -0.04856538f, 0.03938910f, -0.03118433f, -0.01212834f, 0.00161342f, 0.04634877f, -0.04936146f, 
    -0.04669051f, -0.03743458f, 0.01925568f, -0.04837619f, 0.01221354f, -0.02005197f, -0.00054628f, -0.03401519f, 
    -0.01056060f, 0.03053901f, -0.03553611f, 0.05295759f, 0.02747944f, -0.01620276f, 0.01142094f, -0.00578679f, 
    -0.03008188f, -0.05713637f, 0.01118842f, 0.01415807f, -0.04597023f, 0.04674578f, 0.03482017f, -0.02368334f, 
    -0.01642758f, 0.01567960f, 0.00230956f, -0.05440633f, 0.03896146f, 0.01601751f, 0.03853548f, 0.02776072f, 
    -0.03348265f, -0.01600450f, -0.04685507f, -0.03273594f, -0.04226233f, -0.03248583f, -0.05889042f, -0.04537947f, 
    -0.02586632f, 0.01696837f, -0.04466586f, 0.00090711f, -0.02023316f, 0.02358080f, 0.03772741f, 0.01035711f, 
    -0.03809369f, 0.02326257f, 0.02321940f, -0.04179846f, 0.00805037f, 0.01517099f, -0.02134777f, 0.04921019f, 
    0.02607538f, 0.03428981f, -0.02132483f, 0.02373560f, -0.04893468f, -0.02725395f, 0.03476627f, 0.00024568f, 
    -0.01312433f, 0.03756652f, 0.04684328f, -0.01750084f, -0.03094395f, 0.01337786f, 0.03465079f, -0.03430632f, 
    0.04996570f, -0.03794617f, 0.04402940f, -0.02743840f, -0.01759508f, -0.04804475f, 0.02029659f, -0.02302415f, 
    0.01986453f, 0.01923177f, -0.01968157f, -0.03714157f, 0.02335826f, -0.01487645f, -0.05503218f, -0.00895512f, 
    -0.05072039f, -0.04639610f, -0.02677065f, 0.01027143f, -0.00865571f, 0.02667125f, -0.04753993f, -0.02656965f, 
    -0.00799436f, 0.04341150f, -0.04988287f, 0.00239727f, -0.02260610f, 0.00022532f, -0.06053201f, 0.03796288f, 
    0.01785541f, 0.02967925f, -0.02115237f, -0.00613645f, 0.02201570f, -0.02794194f, -0.05267348f, -0.05499474f, 
    -0.03971978f, 0.01871552f, 0.00464221f, -0.05603927f, 0.05065559f, -0.03374960f, -0.04071031f, 0.01689720f, 
    -0.01027580f, 0.02558160f, -0.04305310f, -0.02060377f, -0.00682342f, 0.04009506f, -0.00686779f, -0.05173611f, 
    0.02584827f, -0.01524521f, 0.04050075f, -0.04500222f, -0.05489296f, -0.06098018f, -0.01323584f, 0.02760880f, 
    0.01115045f, -0.00432468f, 0.01398989f, -0.04035585f, -0.04013329f, -0.03638067f, -0.05269532f, -0.01680028f, 
    -0.04822028f, -0.02724280f, -0.01318508f, -0.02543734f, 0.00246078f, 0.02994826f, 0.04349606f, -0.04740722f, 
    -0.02025186f, -0.03957396f, 0.03891634f, 0.01832396f, 0.01530764f, 0.04279381f, 0.00852796f, -0.02266821f, 
    -0.04449425f, 0.03751003f, 0.03956557f, -0.05367060f, 0.04804996f, -0.02891134f, -0.04371943f, 0.05039272f, 
    -0.00314192f, -0.02611734f, -0.03675831f, 0.00808506f, 0.04166158f, 0.03966122f, -0.04489100f, 0.00098236f, 
    -0.03370579f, -0.04565985f, 0.04061323f, -0.01787791f, 0.01220294f, 0.00720619f, -0.00648925f, -0.02910062f, 
    -0.00696009f, 0.03966257f, -0.02480448f, 0.00100653f, 0.02709031f, -0.01965016f, -0.00234504f, -0.00823501f, 
    -0.05182295f, -0.05117858f, -0.01994720f, 0.03213401f, 0.00280646f, -0.04286831f, -0.01942439f, -0.04885347f, 
    0.02515161f, -0.04142665f, 0.00240491f, -0.01155555f, -0.06039082f, -0.03736056f, 0.01963738f, 0.01285929f, 
    -0.05775470f, -0.05188147f, -0.02460044f, 0.03568932f, -0.02327848f, -0.04915918f, 0.04383997f, -0.00289114f, 
    -0.02887193f, -0.00380289f, 0.02408954f, 0.04204088f, 0.01020880f, -0.04604610f, -0.04755896f, -0.02130277f, 
    -0.01105546f, -0.06086746f, -0.00895255f, -0.03037521f, 0.03270964f, 0.04313621f, 0.00408375f, 0.01258224f, 
    -0.01811606f, -0.02215293f, -0.01394505f, 0.05016428f, -0.03496273f, 0.01445234f, 0.00633350f, -0.05256028f, 
    -0.04558963f, -0.01233392f, -0.01130462f, 0.01366015f, 0.01169386f, -0.04010446f, -0.00381898f, 0.04074646f, 
    0.00926514f, 0.00441289f, 0.00497244f, 0.01311228f, 0.00165232f, 0.03372407f, 0.03749986f, -0.00036922f, 
    -0.04414827f, 0.04497010f, -0.03872662f, 0.00726392f, 0.02485493f, -0.01282112f, 0.05027921f, 0.00382907f, 
    0.01898957f, -0.02530708f, -0.03507143f, -0.04512307f, -0.03945158f, -0.03645113f, -0.04554201f, 0.01706241f, 
    -0.00046544f, -0.01788930f, 0.01158071f, 0.02536441f, -0.00103345f, -0.05501285f, 0.01954796f, -0.05104619f, 
    -0.04167369f, -0.05549378f, -0.04816831f, -0.02950713f, 0.01623960f, 0.02157542f, 0.02367630f, 0.01855318f, 
    0.00016197f, -0.05327779f, 0.02862333f, 0.02979888f, 0.04447858f, 0.01943711f, -0.03152664f, 0.02658827f, 
    0.39061308f, -0.18715858f, -0.06625841f, -0.04242601f, 0.25621289f, -0.05657212f, -0.09333295f, -0.03371408f, 
    0.09313907f, 0.04910502f, 0.00470538f, 0.02697546f, 0.13569030f, -0.01374933f, -0.02381582f, -0.11736328f, 
    0.03189596f, -0.02834490f, -0.01635017f, -0.02687353f, -0.42507514f, -0.32883930f, -0.12781817f, -0.24454367f, 
    -0.10144790f, 0.06300569f, 0.01449767f, -0.00575850f, 0.11023436f, -0.12056398f, -0.11916388f, -0.13548656f, 
    0.07118977f, -0.02789865f, 0.03248082f, 0.02463697f, 0.02019088f, -0.10475700f, -0.02591450f, 0.05954692f, 
    0.05286018f, -0.08744935f, 0.18002960f, 0.04211967f, 0.09379500f, -0.04052198f, -0.05925689f, 0.06748177f, 
    0.00549851f, -0.02867587f, -0.05948987f, -0.01077783f, 0.04722101f, 0.02527620f, 0.00738515f, -0.08900780f, 
    -0.19601624f, -0.05446528f, 0.03154371f, -0.09395853f, 0.12418530f, 0.26800755f, 0.19510947f, 0.01241305f, 
    0.12574440f, 0.00477236f, 0.03710829f, 0.04560836f, -0.01866861f, -0.04680763f, -0.14256576f, 0.01097722f, 
    0.07282054f, 0.04554597f, 0.03540770f, 0.07830042f, 0.15242361f, 0.03161736f, 0.21847345f, -0.00030719f, 
    -0.09744730f, -0.30636066f, -0.00583169f, -0.08197758f, -0.33346665f, -0.00394901f, 0.15051915f, -0.00645523f, 
    -0.03068941f, 0.03863934f, -0.12447540f, 0.02729772f, 0.02564007f, -0.04371439f, 0.12632869f, -0.01689047f, 
    -0.00806778f, -0.07107816f, 0.02231267f, 0.04951444f, -0.39962143f, -0.26607937f, -0.14931440f, -0.05015010f, 
    -0.32688329f, 0.03629845f, 0.16298325f, 0.21995756f, -0.06933407f, 0.05189431f, 0.03230838f, -0.02085981f, 
    0.07075457f, -0.01533614f, 0.01349884f, -0.10608862f, 0.07784707f, 0.01260239f, -0.02396672f, 0.00883862f, 
    -0.39437777f, 0.23233378f, -0.05734060f, 0.13450721f, -0.20141800f, 0.14765909f, 0.09737438f, 0.03429232f, 
    0.04934889f, 0.00150694f, 0.11716968f, -0.01803809f, 0.03356297f, -0.05512726f, -0.03702391f, 0.06918459f, 
    0.10052729f, 0.08927421f, -0.12835486f, 0.14242947f, 0.02543428f, 0.09015660f, 0.09882711f, 0.23424606f, 
    0.13978791f, -0.12379856f, -0.06384569f, 0.08717294f, 0.00857642f, 0.04036567f, -0.02169027f, -0.02620823f, 
    -0.04509204f, 0.05815604f, -0.06515706f, -0.07565320f, 0.01326660f, 0.13521802f, 0.06453656f, 0.03383220f, 
    0.44321713f, -0.15014267f, 0.06158421f, 0.23462728f, 0.06515199f, 0.03498558f, -0.00405729f, 0.12597564f, 
    -0.14632826f, -0.07014329f, -0.05234012f, 0.08114853f, 0.04700473f, -0.08796436f, -0.03391285f, -0.04052494f, 
    0.09037899f, 0.01746436f, -0.07535423f, 0.08707300f, 0.20940056f, 0.25666061f, 0.13616739f, 0.02861867f, 
    0.29426092f, -0.03925109f, 0.06585796f, 0.07614178f, -0.01464644f, 0.06753547f, -0.03986102f, 0.18647821f, 
    0.16868733f, 0.02757692f, -0.02810784f, 0.03382690f, 0.07638160f, -0.00819115f, 0.12412032f, -0.03653802f, 
    0.30982485f, 0.21040782f, -0.13070361f, 0.18546841f, -0.03009764f, 0.13589638f, 0.09292921f, -0.09201159f, 
    0.15937428f, -0.05781006f, 0.04520442f, -0.00699720f, 0.01615267f, -0.08982757f, -0.01905957f, 0.08485539f, 
    -0.00210762f, 0.01613593f, 0.01683502f, -0.04869242f, 0.21436600f, 0.28668958f, -0.03310611f, -0.07161275f, 
    0.01852788f, -0.00197225f, -0.00015816f, -0.07628860f, -0.14843607f, 0.01205877f, 0.00402414f, -0.02997195f, 
    -0.07359260f, -0.09911828f, 0.02784816f, 0.00895553f, 0.01522621f, 0.03769718f, 0.05385641f, 0.02722259f, 
    0.15688798f, 0.39598513f, 0.04903713f, 0.09118126f, 0.07964251f, -0.14103360f, 0.09946328f, 0.06123596f, 
    -0.05714682f, 0.12810153f, 0.07260197f, 0.06186769f, 0.02149242f, -0.11776036f, -0.03444723f, -0.05619027f, 
    0.03794923f, 0.10992274f, 0.14019735f, 0.11446755f, -0.07497491f, -0.13824382f, 0.01416325f, -0.01924144f, 
    -0.16049574f, -0.03005174f, 0.01712927f, -0.03937073f, -0.02545679f, 0.01153851f, 0.00289514f, -0.03852640f, 
    -0.08671266f, 0.01279293f, -0.03802207f, -0.09169161f, -0.12087174f, -0.06472604f, 0.14929524f, 0.00305698f, 
    0.10102189f, 0.15120801f, -0.08523335f, 0.11323632f, -0.08653925f, 0.11608611f, 0.13921246f, 0.06705403f, 
    0.08612207f, 0.01981739f, -0.12333286f, -0.04634638f, -0.02428209f, 0.02791016f, -0.12327266f, 0.13392717f, 
    0.08401804f, 0.09278692f, 0.00341798f, 0.08703855f, -0.09959406f, -0.35638413f, -0.01159082f, -0.13877271f, 
    -0.23227645f, -0.02373711f, 0.04195638f, -0.09446020f, 0.04227721f, -0.03220552f, 0.06962726f, 0.00518972f, 
    -0.11714723f, 0.09399416f, 0.04471602f, 0.03155931f, -0.08089591f, 0.02830168f, 0.06691965f, -0.02237247f, 
    0.16410045f, 0.12263189f, 0.03957148f, 0.11378580f, 0.13008729f, -0.23364264f, -0.00149479f, -0.08649285f, 
    -0.05838063f, -0.08597874f, -0.00241815f, -0.03081888f, -0.14088036f, -0.09489646f, 0.04954113f, 0.01594922f, 
    -0.03641383f, -0.03307131f, 0.11475610f, 0.13021766f, 0.13927995f, 0.48827294f, 0.26271477f, 0.15393952f, 
    0.40050775f, -0.00367371f, 0.01507284f, -0.07151963f, 0.04159127f, 0.00218788f, -0.01836988f, -0.07536159f, 
    0.15805772f, -0.05786515f, 0.05691293f, -0.16281284f, 0.06557906f, -0.07919887f, 0.03165583f, -0.12197154f, 
    0.14185163f, 0.04712418f, 0.16803880f, 0.12068919f, 0.29714444f, -0.25664943f, -0.14592475f, -0.00861840f, 
    -0.03049567f, 0.08217133f, -0.02732148f, 0.00922787f, -0.04218462f, 0.06239493f, 0.04405018f, 0.11100375f, 
    0.02883230f, 0.08169222f, 0.01723019f, 0.04998315f, 0.37330154f, -0.06521142f, -0.13072166f, -0.06093242f, 
    -0.13687651f, -0.09991150f, 0.15440114f, -0.05279114f, -0.04672530f, -0.02582341f, 0.04349559f, 0.00585312f, 
    0.01949524f, 0.10495474f, -0.01324781f, -0.01481258f, -0.03813782f, 0.08353115f, -0.03667738f, -0.05234617f, 
    -0.10803214f, 0.31636882f, -0.01912330f, 0.29190850f, 0.21254647f, 0.20706047f, -0.08227683f, 0.14565295f, 
    0.00035863f, -0.12433631f, -0.00545224f, -0.04422937f, -0.05396606f, -0.01131233f, -0.16110905f, -0.03648611f, 
    0.07774424f, -0.04465103f, -0.02467736f, -0.05565508f, 0.03333319f, 0.17223458f, -0.09324193f, 0.15007181f, 
    0.16133927f, 0.00402257f, -0.06479102f, 0.00346092f, 0.04748815f, -0.01067627f, -0.11475019f, 0.11499375f, 
    -0.05684865f, -0.07958581f, -0.11836531f, -0.16310471f, 0.02453796f, -0.02204114f, 0.15212983f, -0.16470630f, 
    0.50495732f, 0.00117679f, -0.05586620f, -0.00814915f, -0.21383695f, -0.06298081f, -0.10872760f, -0.01591266f, 
    -0.09526300f, -0.00418843f, -0.14911027f, -0.07421573f, -0.01452227f, -0.06336271f, -0.05575602f, -0.01158989f, 
    -0.15530957f, 0.01936769f, 0.11991903f, -0.04613993f, 0.07773086f, -0.09663674f, 0.07721858f, -0.20038529f, 
    -0.02050984f, -0.11026283f, -0.00471981f, -0.03135124f, -0.00532725f, -0.05076327f, 0.11810903f, -0.07693681f, 
    0.05306469f, 0.02180403f, 0.01851726f, 0.03580440f, -0.03264016f, 0.05835108f, 0.03376509f, 0.07027569f, 
    0.22744244f, -0.21468137f, 0.18661672f, -0.13046554f, 0.00924658f, -0.25125256f, -0.03822480f, -0.09781606f, 
    -0.03149373f, 0.15454189f, -0.05908094f, -0.02363891f, 0.04725561f, 0.15017760f, 0.10965091f, -0.03064996f, 
    -0.05044663f, 0.08270582f, 0.07169444f, -0.01599199f, -0.31734586f, -0.36107740f, -0.09856012f, -0.32099390f, 
    -0.27664426f, 0.02601876f, 0.01790573f, 0.00355648f, -0.07350821f, 0.00104591f, 0.02543476f, -0.04595976f, 
    -0.13352849f, 0.03780649f, 0.03160264f, -0.02142044f, -0.04801473f, 0.11251103f, -0.17570733f, -0.07438950f, 
    -0.20431903f, -0.03984360f, -0.05437043f, -0.22001334f, -0.09558781f, 0.22509432f, 0.04819071f, 0.02351493f, 
    0.00371999f, -0.06571959f, -0.15010346f, -0.03496551f, 0.19885713f, -0.01607394f, -0.07900505f, -0.05311482f, 
    0.00751053f, 0.02767294f, -0.13186610f, 0.05883155f, -0.26453319f, -0.13330352f, -0.11320297f, -0.45855233f, 
    -0.35321698f, -0.10530183f, 0.04403772f, 0.03063292f, 0.00802728f, 0.08072565f, -0.00496375f, -0.05274346f, 
    -0.03159122f, 0.03940763f, -0.03885359f, -0.06000703f, -0.07137381f, 0.14716117f, -0.11445890f, 0.00873312f, 
    0.04933809f, -0.25450605f, -0.08476955f, -0.17860898f, -0.27647483f, -0.04503731f, -0.09150607f, 0.06431127f, 
    -0.01188767f, -0.23020577f, 0.01784101f, -0.05188806f, -0.08628038f, 0.01529494f, 0.02936256f, -0.10937332f, 
    -0.07974977f, -0.08526772f, -0.10528309f, -0.19426182f, 0.17864294f, 0.27732676f, 0.02338149f, 0.11934868f, 
    0.07085365f, -0.05624900f, 0.06039766f, -0.04276379f, -0.11354709f, -0.05046525f, 0.03571740f, -0.01971878f, 
    0.05392263f, 0.04103297f, -0.15812443f, -0.01376774f, -0.05623385f, -0.04171586f, -0.08216375f, -0.06928165f, 
    -0.30179963f, -0.12195846f, -0.31030372f, -0.44749299f, -0.07459401f, 0.20014319f, 0.03435582f, 0.06727084f, 
    -0.17250988f, 0.04982110f, -0.05775133f, 0.03983520f, 0.06729550f, -0.07640241f, -0.04168209f, 0.00714426f, 
    -0.22171804f, 0.15093066f, 0.01590346f, -0.10615225f, 0.09222396f, 0.39541230f, -0.10008880f, 0.20699044f, 
    0.24849965f, 0.09635714f, -0.04779020f, 0.14394961f, 0.01186021f, -0.02917795f, -0.13159913f, -0.01638120f, 
    -0.09448753f, -0.02109472f, -0.22101921f, 0.05829863f, -0.03118746f, 0.01806969f, -0.03346531f, 0.03632922f, 
    -0.16062854f, 0.19102052f, 0.01506345f, -0.05508545f, -0.14858964f, -0.25371253f, 0.00442486f, -0.07243880f, 
    0.06828283f, -0.08754166f, 0.02864795f, -0.01402246f, -0.08240117f, 0.03034471f, 0.11336201f, 0.02081562f, 
    0.06953170f, 0.00829252f, -0.03760469f, 0.10818327f, -0.32731694f, -0.03723219f, 0.14627188f, 0.04831538f, 
    0.01146327f, 0.06674995f, 0.03677860f, -0.02224065f, -0.01229962f, 0.12010656f, -0.05311494f, 0.05948601f, 
    0.08375026f, -0.03787094f, -0.07505873f, -0.05412294f, 0.05237379f, 0.04958430f, -0.00295373f, -0.05894029f, 
    0.12083755f, 0.10256502f, -0.24841304f, -0.02166142f, -0.10890257f, -0.15038720f, -0.14940645f, 0.10587977f, 
    0.02124144f, 0.05539272f, 0.04000836f, -0.00043936f, 0.00153151f, -0.00758862f, 0.06065566f, 0.03861678f, 
    0.12486450f, -0.02078645f, 0.03647208f, 0.04873039f, -0.20123765f, 0.06008414f, -0.32923517f, -0.02454864f, 
    -0.04948114f, 0.06279992f, -0.04996962f, 0.04381604f, 0.02451543f, 0.06124548f, 0.06160968f, 0.04628509f, 
    0.02092670f, 0.01675692f, 0.02472195f, 0.03562413f, 0.08054420f, -0.00109410f, -0.10851423f, 0.13212506f, 
    -0.48490858f, 0.45392925f, -0.21335575f, 0.32157102f, 0.42328176f, -0.04983217f, -0.05022850f, 0.10158948f, 
    0.05383693f, 0.06900074f, 0.11794213f, 0.08319765f, -0.05082980f, 0.05363181f, 0.01872201f, 0.11658926f, 
    -0.02923465f, -0.01214805f, -0.08449871f, 0.06596046f, 0.08749228f, -0.08359611f, 0.05609095f, 0.12207638f, 
    0.29177791f, -0.01039165f, -0.06716641f, -0.10658023f, -0.02141768f, 0.08089706f, -0.02975792f, -0.06188142f, 
    -0.00902148f, 0.13936973f, -0.04359507f, -0.13282178f, 0.01054245f, 0.05833007f, 0.09547033f, -0.00049055f, 
    0.60191143f, -0.53446931f, -0.16207317f, -0.02151716f, -0.22053814f, 0.08493175f, -0.10887478f, 0.06718360f, 
    -0.04093146f, 0.04505796f, 0.00642786f, -0.05250417f, 0.04143647f, 0.03812140f, -0.02909619f, -0.10881137f, 
    0.02740574f, -0.13434538f, 0.05717265f, 0.03096974f, -0.03487355f, -0.10051611f, -0.24297139f, -0.04767181f, 
    -0.15165065f, 0.03435009f, -0.12388625f, 0.11425223f, -0.03340473f, -0.11741719f, 0.08712167f, -0.08251805f, 
    -0.03215357f, -0.07078400f, 0.10048533f, 0.04398529f, 0.00123545f, 0.05963462f, 0.05809806f, 0.06189737f, 
    -0.30178946f, -0.23770864f, -0.09511472f, -0.08080097f, 0.11053414f, -0.13739721f, -0.21705025f, -0.03884937f, 
    -0.01865253f, 0.00812097f, 0.00971659f, -0.08469333f, -0.02708903f, 0.01430523f, 0.03008844f, -0.07648910f, 
    -0.04175550f, -0.00354800f, 0.06790502f, -0.06123752f, -0.22748590f, 0.02165047f, 0.24702097f, 0.11762735f, 
    -0.21010551f, 0.20940770f, 0.05966445f, 0.03019326f, 0.10754418f, -0.00063189f, -0.08034021f, -0.00513804f, 
    0.04346905f, 0.03386851f, 0.12707667f, 0.03635465f, 0.02991415f, -0.02721945f, -0.07817152f, -0.02756301f, 
    0.17093804f, -0.08096917f, 0.15591012f, 0.02559170f, 0.11119087f, 0.10817857f, 0.05281324f, 0.01448210f, 
    0.00301935f, -0.01591748f, 0.10212175f, 0.12858951f, -0.02427162f, 0.21171585f, -0.03243967f, -0.03898496f, 
    0.06683884f, -0.09328278f, 0.00446673f, 0.06939736f, 0.05505709f, -0.05182401f, -0.12256731f, 0.04732618f, 
    -0.10586741f, 0.04509157f, -0.01224383f, 0.05510933f, 0.23772581f, 0.06239234f, 0.08221404f, 0.04835832f, 
    0.13474202f, 0.05093246f, -0.02226897f, 0.03940921f, -0.00958570f, -0.07895477f, 0.08113607f, 0.12027036f, 
    -0.05474171f, -0.03963246f, 0.04111291f, 0.04807821f, -0.09828667f, 0.26393175f, 0.00711120f, 0.07653949f, 
    -0.04016738f, -0.07399423f, 0.04478589f, 0.08982116f, 0.09881142f, 0.02087855f, 0.10309951f, 0.06583837f, 
    0.23720382f, -0.07277501f, -0.00205064f, 0.05944257f, -0.03719636f, -0.01556992f, -0.08206698f, 0.08155646f, 
    0.21990208f, 0.04627969f, -0.03273413f, -0.04535547f, 0.06936718f, 0.10498431f, -0.01811523f, -0.07811128f, 
    0.09719867f, -0.06432138f, 0.05511167f, 0.14919399f, 0.15760618f, 0.06596157f, -0.06224618f, 0.01593704f, 
    0.18928513f, 0.11865727f, -0.07082991f, 0.11111996f, -0.09175512f, 0.05802003f, 0.09546816f, 0.21374385f, 
    -0.03996340f, 0.07009434f, 0.15501554f, 0.10096820f, 0.09493487f, 0.09470497f, 0.21529686f, 0.09321582f, 
    0.01072833f, -0.09049904f, -0.02908238f, -0.03480693f, -0.29702049f, 0.33288568f, -0.26023442f, 0.04305863f, 
    0.32787916f, 0.11452835f, -0.04336458f, 0.08313642f, 0.01900989f, 0.14518422f, -0.02279324f, 0.06456292f, 
    -0.00525200f, -0.02330602f, 0.07782800f, 0.06128375f, 0.10900335f, 0.04450962f, 0.01621743f, 0.01388046f, 
    0.01885558f, 0.04544379f, 0.04037252f, 0.02460016f, -0.05300403f, -0.01979407f, 0.03805259f, 0.02666180f, 
    -0.05383077f, -0.01823075f, 0.01688700f, -0.00041988f, -0.01781068f, -0.01607816f, 0.02497406f, -0.00169123f, 
    0.01603327f, -0.01284264f, 0.03124054f, -0.00825001f, -0.01004536f, -0.03481777f, 0.02331259f, -0.05881890f, 
    -0.06696313f, -0.04093024f, 0.04014962f, -0.03919636f, -0.03346829f, 0.03495926f, 0.00729645f, -0.04652015f, 
    0.03617732f, -0.00294050f, -0.00058535f, -0.05132451f, 0.00633742f, -0.02222859f, 0.03489190f, -0.05655611f, 
    -0.00155041f, -0.06090083f, 0.04565273f, 0.00265020f, -0.02911922f, -0.02551619f, 0.02346478f, 0.04319628f, 
    -0.02998304f, -0.03056204f, 0.01045269f, -0.00160654f, -0.04979149f, 0.00175011f, 0.02017836f, 0.00438887f, 
    0.02101895f, -0.03888235f, -0.04676746f, 0.02249753f, -0.01497875f, -0.01317194f, -0.01952092f, 0.03530168f, 
    0.00574121f, -0.00413266f, 0.04749773f, 0.00314490f, -0.03055586f, -0.06480825f, -0.03829546f, 0.00580087f, 
    -0.06647291f, 0.05722909f, -0.03848668f, -0.03600951f, -0.00666751f, 0.01613484f, -0.02524423f, -0.03809860f, 
    -0.01729294f, -0.03397017f, 0.00566795f, -0.00552176f, -0.01242554f, 0.03123598f, 0.02400750f, -0.05934215f, 
    0.01286349f, -0.02772404f, 0.01191865f, -0.01434562f, -0.05836188f, -0.05914243f, 0.01632776f, 0.04885074f, 
    -0.02034532f, -0.00329119f, -0.00800692f, -0.04801602f, 0.03298859f, 0.00182606f, -0.00194580f, -0.04444980f, 
    0.01183078f, 0.04909978f, 0.04703809f, -0.03807377f, -0.06000029f, -0.04780637f, 0.02318015f, -0.05484025f, 
    -0.01561393f, -0.04200737f, -0.04662531f, 0.02046880f, -0.05737492f, 0.03201471f, 0.00852431f, 0.02120318f, 
    -0.00310833f, 0.02253349f, -0.01279507f, -0.02790748f, -0.01154615f, -0.01348332f, -0.03758194f, 0.02989938f, 
    0.02664229f, -0.04838567f, 0.04124258f, -0.03994409f, -0.02467686f, -0.00122122f, -0.03190406f, 0.03236759f, 
    0.01533551f, -0.01018239f, 0.02794469f, 0.01591978f, 0.01708507f, -0.02933469f, -0.03632170f, -0.03842267f, 
    0.01397619f, -0.05234513f, 0.01977190f, 0.01795614f, 0.03646981f, -0.05143849f, 0.03020177f, 0.01152959f, 
    -0.01662208f, 0.02347678f, -0.00959091f, -0.00768950f, -0.02950676f, 0.03940129f, -0.05859959f, 0.00464703f, 
    0.01131065f, 0.03495559f, -0.02342832f, -0.03955510f, -0.05272418f, -0.03805128f, -0.04422906f, -0.03659899f, 
    0.02303101f, 0.01824309f, -0.05455625f, 0.02693628f, -0.04323762f, -0.05438294f, 0.02111241f, 0.00100527f, 
    -0.02451016f, -0.04375651f, -0.03856316f, 0.01318490f, -0.02709926f, -0.05763149f, -0.04801536f, -0.02660994f, 
    0.02081984f, -0.04357166f, 0.03168952f, -0.05345204f, -0.00516934f, 0.03456985f, -0.00508167f, -0.01149274f, 
    0.00768104f, 0.01296929f, -0.04521854f, 0.02215515f, 0.02116302f, -0.02900354f, 0.02513861f, -0.03040177f, 
    -0.02883071f, 0.04447827f, 0.03288912f, -0.00871442f, -0.02755265f, -0.02414445f, -0.00858221f, 0.00490190f, 
    -0.00534332f, -0.02389228f, 0.02025500f, 0.01429133f, 0.05077108f, 0.00334925f, 0.01399760f, -0.03802149f, 
    -0.02344720f, -0.00639245f, -0.03734713f, 0.02246736f, 0.02012359f, -0.04441502f, -0.05125116f, 0.01783471f, 
    0.04834628f, 0.00184789f, -0.03330900f, -0.03991987f, -0.06353858f, 0.03003792f, -0.03173646f, -0.01744164f, 
    0.05810467f, -0.03697782f, -0.04495494f, 0.02238502f, 0.03473266f, -0.00091494f, 0.01548000f, -0.02614316f, 
    -0.01621174f, -0.03887787f, -0.02404271f, 0.03209014f, -0.03405461f, -0.02503485f, 0.04149963f, 0.02485803f, 
    0.01359281f, -0.02671998f, -0.00817828f, -0.06211553f, -0.01589087f, -0.00738767f, -0.05979986f, 0.01384621f, 
    0.00754946f, 0.00965633f, -0.01320766f, -0.02810842f, 0.04998452f, -0.03424235f, -0.05541204f, -0.02565013f, 
    -0.05124411f, 0.00548733f, -0.03014748f, 0.00094003f, 0.05381316f, 0.00198498f, -0.06333730f, -0.00620477f, 
    0.02060935f, -0.03352579f, 0.02866269f, 0.03245768f, 0.01245007f, -0.00317804f, -0.04778432f, 0.01530627f, 
    0.03574185f, -0.04022362f, 0.00873174f, 0.04516025f, 0.02224451f, -0.03272844f, -0.02973242f, 0.01664375f, 
    -0.05040497f, 0.03505802f, 0.02369818f, 0.00735702f, 0.01653758f, 0.01816450f, 0.02304107f, -0.03043479f, 
    -0.04173558f, -0.05437943f, -0.00140994f, -0.03362092f, -0.05683000f, 0.04559089f, 0.04599953f, 0.01474034f, 
    0.03173511f, -0.04548161f, -0.05949052f, -0.04961084f, -0.01077614f, -0.00018532f, 0.00269359f, 0.04743481f, 
    -0.02436049f, -0.05043897f, 0.01143887f, 0.02601250f, -0.02715673f, 0.01343535f, -0.02243207f, 0.02742166f, 
    -0.01193840f, 0.01872919f, -0.34112763f, -0.07584684f, -0.36688897f, 0.27371565f, 0.04305571f, 0.07176251f, 
    -0.13913900f, 0.07149399f, 0.01270497f, 0.03113003f, -0.03890824f, 0.08685484f, 0.05180317f, 0.07351039f, 
    0.10099750f, -0.04415942f, 0.08360962f, -0.10153913f, 0.12013450f, 0.09011169f, 0.11432946f, 0.21589953f, 
    0.10065963f, 0.05404765f, 0.12534189f, 0.15320106f, 0.12766042f, -0.01097581f, -0.01507008f, -0.02039430f, 
    -0.06578590f, 0.08916061f, 0.09165679f, 0.08795844f, -0.00044623f, -0.09710065f, 0.08044755f, 0.13613316f, 
    -0.20134018f, 0.06369837f, -0.29305375f, -0.17800984f, -0.01152019f, 0.13793102f, 0.16356130f, -0.11128687f, 
    -0.05073630f, -0.13726948f, 0.16284756f, 0.12770374f, 0.03195710f, 0.07445417f, 0.01728641f, 0.07739968f, 
    0.00043808f, -0.00405391f, -0.04877112f, 0.02031733f, 0.25191224f, -0.38362020f, -0.00817948f, 0.06707352f, 
    -0.05426016f, -0.03079837f, -0.00895960f, -0.01738799f, 0.13944374f, -0.11568008f, 0.05594286f, -0.02619868f, 
    0.08914629f, -0.09849858f, -0.03690023f, -0.06217267f, -0.02977606f, -0.02186759f, 0.00821627f, 0.04961445f, 
    -0.06213771f, 0.22793652f, 0.38210976f, 0.04691728f, -0.15463202f, -0.10162636f, 0.03375724f, 0.05492797f, 
    0.08035780f, 0.02253983f, 0.02194827f, -0.01900828f, 0.10929666f, -0.00761758f, 0.01793909f, -0.16612929f, 
    0.01878651f, -0.06175750f, 0.00243508f, -0.00911815f, 0.22576533f, 0.15656053f, 0.32466635f, 0.15985762f, 
    0.15902911f, -0.06620472f, -0.07835696f, 0.04754355f, 0.08345171f, 0.06478937f, -0.01207466f, 0.04757667f, 
    0.09830692f, -0.00384985f, -0.08371663f, 0.25625408f, 0.06958878f, -0.01003717f, -0.12211189f, -0.09030356f, 
    0.04368920f, 0.04099362f, 0.22164342f, -0.11425042f, 0.21223252f, -0.11335055f, -0.10730543f, 0.14211726f, 
    0.09610143f, 0.05217060f, -0.04696070f, -0.04529423f, -0.01322976f, 0.02472978f, -0.09221088f, 0.12263494f, 
    0.08452691f, 0.14660546f, -0.09997730f, 0.07234055f, -0.27204490f, 0.06054876f, -0.14003558f, -0.09862337f, 
    0.11567596f, 0.02628650f, -0.02981771f, -0.12699550f, 0.11390238f, -0.00323107f, 0.14496948f, 0.03542086f, 
    -0.00660640f, -0.02534229f, -0.00029873f, -0.07308939f, -0.09391466f, -0.05389872f, -0.10979256f, 0.06455424f, 
    0.04721362f, -0.06196577f, -0.43779999f, 0.04119633f, -0.12629153f, 0.08505511f, 0.12381002f, -0.03037052f, 
    0.10150669f, -0.01491518f, 0.00110235f, -0.01850965f, 0.00749591f, 0.12092385f, -0.09306150f, 0.07147481f, 
    -0.00522937f, -0.04151348f, -0.03455419f, 0.04696222f, 0.11403894f, -0.10560982f, -0.17605615f, 0.15856178f, 
    -0.07765450f, -0.22727217f, 0.08113993f, -0.05855383f, 0.03648068f, -0.00754745f, 0.01116176f, 0.00368170f, 
    0.07080325f, -0.04026745f, 0.06436259f, 0.06169722f, 0.03726906f, -0.00332625f, 0.03102878f, 0.06580923f, 
    0.01479419f, 0.17647362f, 0.40366864f, -0.03938274f, -0.07535614f, -0.17347004f, 0.05960974f, 0.14635077f, 
    -0.15308341f, 0.00513445f, -0.25475144f, -0.12656847f, -0.17286588f, -0.05737493f, 0.06604569f, 0.03886274f, 
    -0.02110690f, -0.03061874f, -0.02128258f, 0.06039976f, -0.07759641f, -0.30162477f, -0.20938326f, 0.15698203f, 
    0.17950208f, 0.03758713f, 0.07819008f, 0.11594044f, -0.11218049f, 0.06399833f, 0.01865091f, 0.08103225f, 
    0.14496861f, 0.19148788f, -0.00421250f, 0.03729446f, -0.05044779f, 0.13701230f, -0.01710624f, -0.10164189f, 
    0.02644015f, -0.19941896f, -0.13918072f, 0.21935748f, 0.09557052f, -0.03606960f, 0.03289270f, -0.13001771f, 
    0.04318372f, 0.17951536f, 0.09111419f, -0.04132786f, -0.13898493f, 0.05241340f, 0.03063569f, -0.00366362f, 
    -0.10458628f, 0.05496104f, -0.03974536f, -0.10705147f, -0.07274295f, 0.07826171f, 0.19315045f, 0.01825468f, 
    -0.09440408f, -0.21093680f, -0.08548513f, -0.01342617f, -0.00277755f, 0.03703504f, 0.02458881f, -0.03325001f, 
    -0.05626651f, -0.01102011f, 0.10759188f, 0.02475938f, 0.01562512f, -0.05951170f, 0.10909715f, -0.06591194f, 
    -0.00151867f, -0.24618624f, 0.36677098f, 0.05990255f, 0.03736660f, -0.20293726f, 0.02617756f, 0.23178442f, 
    0.01839882f, 0.18404530f, -0.12535778f, -0.02793112f, -0.01031133f, 0.05355525f, -0.11799390f, -0.13936611f, 
    -0.04569387f, 0.11418420f, 0.06433903f, 0.05575607f, 0.20030661f, 0.15509619f, 0.41188851f, 0.14020973f, 
    -0.28569341f, -0.14914942f, -0.10975736f, 0.18778208f, 0.01056817f, 0.03873571f, -0.00349493f, 0.05526301f, 
    -0.02710361f, 0.05737718f, 0.05000887f, -0.00297695f, -0.04618408f, 0.00764460f, -0.11347240f, -0.04536320f, 
    -0.34696424f, 0.06504580f, 0.06617753f, 0.00149501f, -0.38181162f, 0.08780707f, 0.09576241f, 0.05039640f, 
    0.17592697f, -0.05232086f, 0.02605679f, -0.02365866f, 0.08744291f, -0.00661397f, -0.06624713f, -0.03308411f, 
    -0.00705437f, -0.11206852f, 0.01744906f, -0.01402630f, -0.25531015f, -0.16097815f, 0.10051101f, -0.03704815f, 
    -0.28139421f, -0.14565793f, 0.05373685f, -0.05135450f, -0.13732125f, -0.03399760f, -0.11284124f, 0.09175806f, 
    -0.05091074f, -0.14917502f, 0.05079067f, -0.02597427f, -0.15096299f, -0.05559633f, 0.03997565f, 0.06884998f, 
    -0.00919786f, 0.19927600f, -0.23264319f, -0.29279757f, -0.16102299f, 0.11522917f, 0.03160079f, 0.06456134f, 
    0.01580360f, -0.16204454f, 0.03197580f, 0.08375185f, 0.09856943f, 0.07432265f, -0.13647395f, -0.03332171f, 
    0.08755651f, 0.00299596f, 0.08028384f, 0.02674978f, -0.41760856f, 0.18644941f, 0.08322714f, -0.07443611f, 
    -0.13297416f, 0.03718895f, -0.15788625f, 0.06612080f, 0.10469197f, -0.08085403f, 0.04887879f, -0.02073601f, 
    -0.07954270f, 0.03005442f, -0.00938791f, -0.05464734f, -0.14077942f, -0.07117537f, -0.08828389f, 0.01596167f, 
    -0.16236398f, 0.05753139f, -0.09807748f, 0.00059837f, 0.23581652f, -0.17632239f, -0.03832005f, -0.00384342f, 
    0.13073586f, -0.04393932f, -0.03389705f, -0.08183991f, 0.00204589f, -0.01125138f, 0.16382246f, -0.18199028f, 
    -0.06636618f, -0.02770258f, 0.05762229f, 0.02846505f, 0.26135871f, -0.04523361f, 0.02019463f, -0.15801765f, 
    0.31631714f, -0.20431371f, -0.03361962f, -0.07748990f, -0.04601581f, 0.11682465f, -0.11575779f, 0.04628446f, 
    0.12283160f, -0.03461999f, -0.01702662f, 0.10804246f, 0.07228900f, 0.03762656f, -0.01159515f, 0.14599930f, 
    0.06582343f, 0.05896166f, -0.16315247f, -0.06449713f, 0.44798625f, -0.08539581f, -0.06436868f, 0.05957057f, 
    0.03741391f, -0.03416622f, -0.05040890f, 0.05439975f, -0.03878173f, -0.06250782f, -0.10153080f, 0.01836547f, 
    -0.04162419f, 0.04349139f, -0.04199709f, -0.01530728f, -0.17968239f, 0.39897346f, 0.04041314f, -0.06974054f, 
    -0.22738288f, 0.06340037f, -0.02580115f, 0.07657544f, 0.09664569f, -0.08713837f, 0.00427141f, -0.11624943f, 
    0.12302881f, -0.01835658f, -0.06541884f, -0.01314734f, -0.05970560f, -0.09602471f, -0.04340511f, -0.00631304f, 
    -0.30660647f, 0.17553216f, -0.03865806f, -0.09611257f, -0.12472294f, 0.21876167f, -0.00334918f, 0.04605861f, 
    0.14280066f, -0.01856362f, 0.15845725f, -0.01234689f, -0.07974932f, 0.16417891f, -0.10333300f, -0.01716664f, 
    0.01789773f, 0.06839697f, 0.08947323f, -0.06206736f, 0.05672306f, 0.05416775f, 0.03140705f, 0.32098946f, 
    0.32889143f, -0.08227329f, -0.04292452f, -0.00377489f, 0.06315687f, 0.05425063f, -0.06416568f, -0.11083122f, 
    -0.05098585f, -0.03295692f, 0.10412455f, 0.04400460f, -0.02562204f, 0.10258368f, 0.02178450f, 0.05541256f, 
    0.23284924f, -0.01684668f, 0.02525180f, 0.30229497f, 0.04620834f, -0.09100861f, -0.03458196f, 0.01685596f, 
    -0.02729314f, -0.01831827f, -0.05894175f, 0.04916185f, -0.03411803f, 0.00229444f, 0.09221278f, 0.00687114f, 
    -0.10497663f, 0.16460592f, -0.02158558f, -0.11748044f, 0.02553610f, -0.18069246f, 0.13777319f, 0.29658166f, 
    0.09237007f, -0.02540295f, 0.01110079f, 0.03542326f, 0.17200537f, 0.01785836f, 0.02933595f, 0.03575322f, 
    0.12365544f, -0.06200676f, -0.10591877f, 0.11095916f, -0.06804284f, 0.11674301f, -0.01510024f, -0.02478766f, 
    -0.06930651f, -0.17726973f, 0.07254964f, 0.22467904f, 0.09535032f, -0.00278011f, -0.01616018f, -0.11682942f, 
    0.05810412f, 0.02232112f, -0.02913360f, -0.12616234f, 0.11320741f, 0.08338007f, -0.04595805f, -0.03431667f, 
    0.03534864f, -0.09691980f, -0.05930160f, 0.06408331f, -0.31274122f, -0.10287275f, 0.08010370f, -0.00575575f, 
    -0.11951435f, 0.10319488f, -0.01068753f, -0.00173991f, 0.04768773f, -0.08368509f, 0.01884766f, 0.02769117f, 
    0.02621005f, 0.06545001f, 0.10810371f, -0.03113170f, -0.00379444f, 0.03263029f, -0.14817598f, 0.08863328f, 
    0.19255798f, 0.23313294f, 0.28390294f, 0.27777743f, 0.18597317f, 0.04635981f, -0.13949244f, 0.12041957f, 
    0.26642081f, 0.08675674f, 0.00932231f, 0.07672203f, -0.01383168f, 0.06173432f, 0.01944713f, -0.03680629f, 
    0.03061572f, 0.08635050f, 0.07043298f, 0.01095346f, -0.30772138f, -0.01468078f, 0.08518630f, 0.04435899f, 
    -0.04932181f, -0.03971320f, -0.13007763f, 0.07593151f, -0.08822973f, 0.02015545f, -0.00556111f, -0.00227868f, 
    0.10351256f, 0.04042281f, 0.00083036f, -0.21821964f, -0.02330589f, 0.02648040f, 0.03736708f, -0.03345027f, 
    -0.16515543f, 0.44024873f, -0.05925294f, -0.15442234f, 0.15823151f, -0.10630014f, -0.01025570f, -0.02008760f, 
    0.07047076f, 0.01453895f, 0.05802552f, -0.01485087f, -0.11567976f, -0.11496120f, -0.02402884f, 0.03916721f, 
    -0.01437781f, 0.00103080f, 0.07233997f, -0.04726664f, -0.05593890f, 0.26231569f, 0.19298902f, -0.13140766f, 
    -0.05726641f, 0.11486952f, -0.00491247f, 0.07727078f, -0.07303552f, 0.13339749f, 0.08689357f, 0.07219473f, 
    -0.00307910f, -0.07074565f, -0.07785217f, 0.01768233f, 0.16014469f, -0.00306765f, 0.01002582f, 0.07422984f, 
    -0.25919428f, 0.19413938f, -0.05879426f, 0.30503988f, 0.05429009f, 0.05514822f, -0.08047166f, 0.01238217f, 
    0.09921272f, 0.08715170f, 0.02266924f, -0.07298416f, 0.01232648f, 0.03053437f, 0.05197570f, -0.04382563f, 
    -0.00496582f, 0.04978093f, -0.00772129f, 0.01099244f, -0.13274710f, -0.27667865f, -0.19654202f, -0.02568556f, 
    -0.06118783f, -0.02269826f, 0.01866110f, 0.02131608f, 0.03290832f, 0.02903146f, 0.12213039f, 0.07855377f, 
    -0.14583570f, -0.02090491f, 0.00547142f, 0.01855271f, -0.01491454f, -0.02154236f, -0.00602953f, 0.06401532f, 
    0.02679099f, -0.04050870f, -0.01571039f, 0.02316267f, 0.33600962f, -0.08776576f, -0.02358139f, 0.03566872f, 
    -0.08556577f, -0.02030187f, 0.03702396f, 0.03518982f, 0.07782833f, 0.06427877f, 0.23617347f, 0.17609181f, 
    -0.16914713f, 0.07464752f, 0.04138438f, 0.05265848f, 0.42421263f, -0.02411345f, 0.09038156f, 0.07215794f, 
    0.03535723f, 0.04933579f, -0.15566726f, 0.07071600f, -0.01710593f, 0.13777539f, 0.02518070f, 0.04399677f, 
    0.14304209f, -0.08237270f, 0.01820892f, -0.07065371f, 0.16174485f, 0.17009455f, -0.01886089f, 0.00194965f, 
    0.19358300f, -0.47723934f, 0.16574368f, -0.32224876f, -0.01687813f, 0.15529515f, -0.09227511f, 0.22382458f, 
    -0.01663384f, 0.09047761f, 0.05296186f, -0.03777666f, 0.11432463f, -0.00575829f, 0.01320043f, 0.05511120f, 
    0.01641864f, -0.08236853f, 0.10751054f, -0.07894059f, 0.12676643f, -0.19035344f, -0.00175405f, -0.08613369f, 
    0.00182430f, -0.03523430f, -0.08193906f, -0.02685153f, 0.06212686f, 0.05438450f, 0.02361352f, -0.00028680f, 
    0.00767697f, 0.00318413f, 0.00319537f, 0.03693175f, -0.00192523f, 0.02256307f, 0.02561749f, 0.01374829f, 
    -0.29949594f, 0.34112489f, -0.27489585f, 0.35923117f, 0.02296059f, -0.08419682f, -0.05734921f, -0.05611692f, 
    0.23323198f, 0.08134120f, 0.03095123f, -0.07100652f, 0.06287138f, -0.06546515f, -0.04789737f, -0.15407506f, 
    -0.03020632f, 0.00730013f, 0.00491239f, -0.18428671f, 0.04755968f, -0.23654905f, 0.19768471f, 0.06964365f, 
    -0.17124081f, 0.11158963f, -0.03604557f, 0.03627449f, 0.13017270f, -0.06301100f, 0.02088362f, -0.02134730f, 
    0.12048326f, -0.01809125f, -0.00068199f, -0.03889750f, -0.00009892f, -0.09108697f, -0.09092356f, 0.03928623f, 
    -0.25387302f, 0.06272011f, 0.15607741f, -0.27230409f, -0.10280152f, -0.06803050f, 0.06521054f, -0.07485277f, 
    -0.19654761f, -0.02124568f, -0.00735126f, -0.04989019f, 0.07617114f, 0.15963903f, 0.15805238f, 0.03083204f, 
    0.01061668f, 0.02255097f, -0.06485129f, 0.01390443f, -0.01995741f, -0.36321762f, -0.10642455f, 0.27860928f, 
    -0.31763440f, 0.15626095f, 0.05688106f, 0.00736901f, 0.11581871f, -0.05442399f, 0.17977245f, 0.05928463f, 
    0.03606800f, 0.02497938f, -0.04981531f, 0.07741096f, -0.04297330f, -0.10835983f, -0.01312434f, 0.12191606f, 
    0.27229556f, -0.03251331f, -0.01901466f, 0.06280535f, -0.06985313f, 0.12928547f, 0.04381986f, -0.01782057f, 
    0.10385605f, 0.04644547f, 0.04000313f, 0.11848550f, 0.06546839f, -0.01641777f, 0.06753350f, -0.08321474f, 
    0.14418164f, 0.02930101f, 0.06582645f, 0.09864648f, 0.17736182f, 0.26607823f, -0.07418175f, -0.06799439f, 
    0.18088256f, 0.19593939f, 0.08415098f, 0.01957595f, -0.00073453f, -0.00856636f, -0.12167773f, 0.04310413f, 
    0.08104343f, 0.07881025f, 0.15356746f, 0.03816531f, -0.01013147f, 0.00841060f, 0.02846369f, 0.07556279f, 
    0.15024774f, -0.25607476f, 0.00154308f, 0.03498031f, -0.36697927f, -0.08497524f, -0.03759869f, 0.13126023f, 
    -0.22518860f, -0.16119626f, 0.08386128f, -0.01390780f, 0.00653163f, 0.06072028f, 0.04411262f, -0.04404017f, 
    0.07058723f, 0.00089955f, -0.10249976f, -0.04696445f, -0.21992439f, 0.14980558f, -0.24857807f, 0.00645579f, 
    0.33021894f, 0.07520135f, 0.07463119f, -0.01754039f, 0.02099978f, 0.05604833f, -0.00396948f, 0.08011498f, 
    0.11823070f, 0.09931848f, 0.02405130f, -0.05650461f, 0.11479197f, 0.01789531f, 0.07924899f, 0.09337144f, 
    -0.28835395f, -0.07534046f, -0.08954448f, 0.07397738f, -0.07819262f, 0.00381736f, 0.19113399f, 0.00600793f, 
    0.05202524f, -0.01991028f, -0.12219390f, 0.07886542f, -0.03941601f, 0.01134127f, 0.09738518f, 0.00239480f, 
    0.01618718f, 0.02310376f, -0.04662170f, -0.03854177f, -0.14707352f, -0.10224428f, 0.02129424f, 0.06443398f, 
    0.17560732f, 0.10236429f, 0.03622092f, 0.07624194f, 0.03109926f, 0.12960497f, -0.06201906f, -0.02924708f, 
    -0.05195551f, 0.14033696f, 0.01596303f, -0.03634250f, -0.04253771f, -0.10420147f, -0.11067385f, -0.12121472f, 
    0.12076140f, -0.18840967f, -0.03288016f, -0.02376072f, -0.00520441f, 0.15246806f, 0.06281380f, -0.11194786f, 
    0.02620782f, -0.03329391f, 0.14210294f, -0.04131777f, 0.04709852f, -0.00892390f, 0.02051722f, 0.02353961f, 
    0.09093500f, -0.06753426f, -0.05407441f, 0.01934612f, 0.44518790f, 0.00921237f, -0.11198319f, -0.04770133f, 
    0.05547547f, -0.03267119f, -0.00018683f, 0.02204122f, -0.09397212f, -0.07819377f, -0.10364234f, -0.07723390f, 
    0.21853179f, -0.11495544f, -0.04387432f, 0.00857392f, -0.04345259f, 0.15998864f, 0.00770583f, -0.06555224f, 
    0.61103517f, 0.43623427f, -0.11493953f, 0.03769076f, -0.19309895f, -0.02224236f, -0.01090952f, 0.06176402f, 
    -0.05299028f, -0.07811850f, 0.14336848f, 0.02928395f, 0.05960805f, 0.03427815f, -0.14514410f, 0.05086166f, 
    -0.03468101f, -0.05778195f, -0.15208831f, -0.09087511f, -0.01676970f, 0.54316717f, 0.05435201f, 0.10283873f, 
    -0.15436630f, 0.07862298f, -0.07731932f, 0.13803345f, 0.13533829f, -0.01634347f, 0.01523112f, 0.00046545f, 
    -0.24053988f, 0.10231338f, -0.13724524f, -0.05208464f, -0.05071391f, -0.05319825f, 0.04840786f, -0.13980132f, 
    0.47194996f, -0.30985036f, 0.03094661f, 0.05847797f, -0.33964387f, 0.02970149f, -0.05785814f, -0.00270397f, 
    -0.09044649f, 0.03434831f, -0.06773370f, 0.10809271f, -0.03606109f, -0.04716697f, -0.04359541f, -0.10171659f, 
    -0.06607581f, -0.06425617f, -0.04604357f, -0.02606012f, 0.17440338f, -0.17760862f, -0.01778669f, -0.05071479f, 
    0.06372862f, 0.02018848f, 0.10686834f, -0.04804808f, -0.07601520f, 0.05189224f, -0.05098870f, 0.00438438f, 
    0.12820962f, -0.01185383f, 0.08535248f, 0.05913867f, -0.05014668f, 0.01073639f, -0.06532263f, 0.05013553f, 
    -0.03263430f, 0.08782774f, 0.00434864f, -0.04377107f, 0.05576744f, 0.05143784f, -0.04553538f, -0.09000946f, 
    -0.06815598f, 0.00017792f, 0.03424057f, -0.08774797f, 0.10395008f, 0.06743828f, -0.00909052f, 0.10916825f, 
    -0.13917811f, -0.10095362f, 0.05530515f, 0.00676599f, -0.10313560f, -0.01527541f, -0.17755917f, -0.16227330f, 
    -0.00471606f, -0.02692876f, -0.02637988f, -0.08411480f, 0.02092798f, -0.09383804f, -0.01545169f, -0.07934801f, 
    -0.00920512f, 0.13093637f, 0.01523761f, 0.07166042f, 0.02208166f, -0.05113425f, 0.07826763f, -0.03352823f, 
    0.14749168f, -0.20811126f, -0.01763646f, 0.09607314f, 0.13106737f, -0.07270809f, -0.01285410f, 0.04503909f, 
    0.04636025f, -0.00432429f, 0.05710558f, -0.02536951f, -0.05970011f, 0.08343998f, -0.02715413f, 0.03613713f, 
    0.03537626f, -0.01839117f, 0.01940111f, 0.09375786f, 0.01248249f, -0.03587982f, -0.08939207f, -0.28699142f, 
    0.18432860f, 0.03903294f, -0.25855610f, 0.08371795f, 0.01536257f, 0.13591141f, 0.06541075f, -0.04720203f, 
    0.03854724f, 0.00195407f, -0.03661507f, -0.05328923f, 0.02215812f, 0.06071378f, 0.05807606f, 0.07065304f, 
    -0.20761895f, -0.18882863f, 0.00815108f, -0.14293866f, -0.05065270f, 0.13156106f, -0.03064448f, 0.01192450f, 
    0.04303708f, -0.00880477f, 0.04256985f, 0.05365153f, -0.06880262f, -0.08808919f, 0.02601594f, -0.13075584f, 
    -0.17521770f, -0.01491950f, 0.08843949f, -0.16698229f, -0.05617748f, -0.03417914f, 0.00519238f, 0.00962087f, 
    0.05161465f, -0.09452416f, -0.02496134f, -0.01665995f, -0.08202945f, -0.01579104f, 0.10094650f, 0.04158497f, 
    -0.12582022f, -0.13753156f, -0.00362334f, 0.03151872f, -0.12251414f, 0.02597415f, -0.08484239f, -0.09307063f, 
    -0.03795696f, 0.12613957f, -0.32101300f, -0.16850823f, 0.06014172f, -0.00884996f, 0.05112302f, -0.00560900f, 
    -0.06300871f, -0.12510078f, 0.06281736f, 0.00570619f, -0.02266974f, 0.09858517f, -0.18125993f, 0.04367064f, 
    0.03750687f, 0.08171079f, -0.08075416f, -0.02086842f, 0.49887013f, 0.26876652f, -0.14854155f, 0.04773654f, 
    0.02791941f, -0.09037643f, 0.01831363f, 0.10382860f, -0.03437331f, -0.01633391f, -0.05367984f, -0.04676448f, 
    -0.05262952f, -0.01485715f, -0.00630762f, 0.05486260f, -0.03262988f, -0.00592000f, -0.12405652f, -0.02280102f, 
    -0.04335086f, 0.00912397f, 0.03113256f, -0.01196903f, -0.04778136f, 0.02487808f, -0.03688608f, -0.01013734f, 
    -0.05862528f, 0.03236755f, -0.00450670f, 0.00539551f, 0.02255657f, -0.02190378f, -0.01310703f, -0.01168790f, 
    0.00512893f, 0.00312750f, -0.04579028f, 0.04019444f, -0.04420063f, -0.00649677f, 0.03197862f, 0.02335368f, 
    -0.01960257f, -0.00890594f, -0.02619296f, 0.00759440f, -0.05357176f, 0.04137382f, -0.02902661f, 0.04369938f, 
    0.03395360f, -0.03396495f, 0.00037056f, 0.03600492f, -0.03398300f, -0.03514163f, -0.03174256f, -0.02050551f, 
    0.01449497f, -0.03746071f, -0.01423218f, 0.01605500f, -0.04379546f, -0.04064455f, -0.04912354f, 0.02097998f, 
    -0.05153092f, -0.03151327f, 0.00838360f, 0.03615817f, 0.00944937f, -0.00759438f, -0.02517143f, -0.06137547f, 
    -0.04434451f, 0.01702741f, 0.00697080f, -0.04466230f, -0.01730541f, 0.02163491f, -0.02581152f, 0.04847012f, 
    0.02164017f, 0.02776159f, -0.01019343f, 0.04309192f, -0.05755043f, 0.04260910f, -0.02312406f, -0.04375052f, 
    -0.00618722f, -0.03269096f, 0.01916476f, 0.03196370f, -0.04478594f, 0.02827356f, -0.05994823f, -0.05019585f, 
    -0.01019980f, 0.00691685f, 0.02348146f, -0.04840627f, -0.05189877f, 0.02127414f, 0.00969291f, -0.00233488f, 
    -0.06027429f, -0.03267310f, 0.02767326f, -0.02677258f, 0.00569279f, -0.05370618f, -0.04954156f, -0.02375566f, 
    -0.03694249f, 0.03945678f, 0.00316741f, 0.02749964f, -0.01546350f, 0.03492891f, 0.02781808f, 0.00521613f, 
    0.01172905f, 0.03431224f, -0.00523053f, -0.02505849f, 0.03631069f, 0.02861634f, -0.05880959f, 0.03700847f, 
    -0.04995917f, 0.02503547f, -0.02277728f, -0.05432822f, -0.00990638f, -0.05578716f, -0.04281983f, 0.00534354f, 
    0.04905398f, 0.02382792f, -0.02729422f, -0.04199012f, -0.00571623f, -0.02034782f, -0.06274844f, 0.03641685f, 
    -0.03021964f, 0.03444805f, -0.03445640f, -0.04777899f, 0.02860219f, -0.03696315f, -0.06446862f, -0.02921244f, 
    0.00978676f, 0.02044732f, -0.00204765f, -0.05115655f, -0.00428270f, -0.04578071f, 0.00369240f, -0.02568549f, 
    -0.00590893f, -0.05948027f, 0.04577501f, -0.02063688f, -0.01134019f, 0.03301663f, -0.02371987f, -0.01055103f, 
    -0.06426275f, 0.01960805f, 0.02025303f, -0.05851536f, -0.05762387f, -0.02242441f, 0.03227194f, -0.06514508f, 
    -0.05071685f, 0.02880348f, 0.04332062f, -0.01463951f, -0.00803983f, 0.00682440f, -0.05489587f, -0.04357686f, 
    -0.04648573f, -0.05235834f, -0.01047336f, -0.04144938f, 0.00524338f, 0.02042157f, 0.02497781f, -0.00023833f, 
    0.03027148f, -0.02217757f, 0.03383704f, -0.04652848f, 0.04489153f, 0.00679185f, -0.04689147f, 0.03010352f, 
    -0.05807297f, 0.01373776f, -0.03455032f, -0.03430213f, -0.01711578f, 0.01115204f, -0.05741693f, 0.00485795f, 
    -0.00596145f, 0.02558587f, 0.00319355f, -0.03805429f, -0.04497239f, 0.00864279f, -0.01978070f, 0.04182974f, 
    -0.04880554f, 0.03288494f, -0.00430273f, 0.02372643f, -0.01716601f, 0.02206257f, 0.03074238f, -0.00812632f, 
    -0.02208347f, -0.04517544f, 0.03496959f, 0.01338036f, 0.04015648f, -0.05091265f, -0.00787484f, -0.05969309f, 
    0.03575743f, 0.00460506f, 0.00130041f, 0.00518078f, 0.03944527f, -0.04541279f, 0.04387607f, 0.01940334f, 
    -0.05697069f, -0.05571499f, -0.00131167f, 0.00544787f, -0.05306197f, -0.02039697f, -0.02473071f, -0.04620484f, 
    -0.06112951f, 0.03221767f, -0.00371750f, 0.04614221f, 0.04861786f, -0.00395329f, -0.01392604f, 0.05015182f, 
    -0.05520223f, 0.02768768f, -0.05048576f, 0.00024079f, 0.03507864f, -0.02548396f, -0.03946252f, 0.04595593f, 
    -0.02263872f, -0.02129948f, 0.01087748f, 0.02611444f, 0.04179051f, -0.04471177f, -0.05986027f, -0.03791275f, 
    0.02143926f, -0.01898437f, -0.03390864f, 0.03371105f, -0.03314193f, -0.04308879f, -0.05110959f, -0.05744262f, 
    -0.03394316f, -0.04892080f, 0.01554793f, -0.01017530f, 0.01486567f, 0.01557764f, 0.00190898f, 0.02591660f, 
    -0.02831363f, 0.02123686f, 0.02293520f, 0.04237365f, -0.03434419f, 0.00563453f, -0.03375743f, -0.06293576f, 
    0.00181661f, -0.04167146f, -0.05631431f, -0.00520361f, -0.02095787f, 0.02136895f, -0.02097052f, 0.03776607f, 
    -0.03625165f, 0.00599346f, 0.04017808f, 0.00472649f, 0.03737246f, -0.01997299f, 0.02609549f, 0.00671916f, 
    0.04187347f, -0.02330234f, -0.01029073f, -0.01710705f, 0.01107429f, -0.02594838f, -0.00184712f, -0.01323666f, 
    -0.06220058f, -0.00419456f, -0.01566156f, -0.06184346f, -0.04913178f, -0.03341889f, 0.00899161f, 0.01276211f, 
    -0.01782407f, -0.04993242f, 0.01257549f, 0.03356210f, 0.01407949f, -0.03476009f, -0.01042287f, -0.05778926f, 
    0.29240054f, -0.43392381f, 0.04957182f, -0.06758884f, 0.19724320f, -0.00140678f, -0.07036311f, 0.03906961f, 
    0.00884705f, 0.06770685f, 0.05075817f, 0.05800167f, 0.19914860f, 0.16358952f, 0.07157261f, -0.01981090f, 
    0.01696257f, 0.02625930f, 0.01176774f, -0.00145930f, -0.04894013f, -0.32424548f, -0.25478354f, -0.03220130f, 
    0.00092625f, 0.06148608f, 0.02905470f, 0.00553291f, 0.09908302f, -0.08514048f, -0.10613375f, -0.09254003f, 
    0.08925523f, 0.12075211f, 0.04379492f, 0.05289371f, -0.02300239f, -0.04188110f, 0.02439743f, 0.00355455f, 
    -0.16699912f, -0.24353077f, 0.10527018f, 0.01638915f, -0.04072900f, 0.06032522f, -0.06601922f, 0.00160752f, 
    -0.13287641f, -0.08384707f, -0.07452791f, 0.03114491f, 0.03824067f, -0.01452626f, 0.07152579f, -0.01095066f, 
    -0.18116121f, -0.06470609f, -0.00105594f, -0.06220241f, -0.04886356f, 0.22653423f, 0.08754468f, -0.00428156f, 
    0.06228354f, 0.04598313f, -0.01542879f, 0.01400090f, -0.02771416f, -0.05827682f, -0.01796509f, 0.06042017f, 
    0.10774519f, -0.03966668f, 0.04258985f, -0.00326806f, 0.15770985f, 0.09802555f, 0.10691767f, 0.04960887f, 
    0.22672276f, -0.15351231f, 0.02370284f, 0.00319985f, -0.41134608f, 0.12859641f, 0.07339975f, -0.06554634f, 
    0.00585969f, 0.01953606f, -0.06148706f, 0.00202079f, 0.05973803f, -0.09018256f, -0.00127540f, -0.04700499f, 
    0.02441973f, -0.05321636f, 0.11717673f, -0.01990629f, -0.35036978f, 0.22411384f, -0.08668683f, -0.03455528f, 
    -0.27448654f, 0.18483950f, 0.16426076f, 0.07182689f, 0.03769558f, -0.06522629f, 0.09076076f, -0.03645484f, 
    -0.08809979f, 0.02895897f, 0.08104482f, 0.02371229f, -0.08168780f, -0.12356629f, 0.02100045f, -0.01671635f, 
    -0.30718690f, 0.46726230f, -0.01700796f, 0.42599905f, -0.20568052f, 0.18194982f, 0.14786913f, -0.05828813f, 
    -0.00722651f, 0.02036117f, 0.03626477f, -0.04607239f, 0.04676843f, 0.09113261f, 0.00094016f, 0.04008117f, 
    0.04523941f, 0.14976451f, -0.17806016f, 0.13511376f, 0.06315451f, -0.18353245f, 0.07227704f, 0.18819904f, 
    0.04694246f, -0.08227935f, 0.00073854f, 0.00627380f, -0.15625112f, 0.13691300f, -0.07845772f, 0.02773266f, 
    0.01951004f, 0.12164854f, -0.04055561f, -0.04609890f, -0.05021701f, 0.10079709f, 0.02451038f, -0.01858811f, 
    -0.08931201f, 0.04720766f, -0.00503263f, -0.03209627f, 0.02474111f, 0.10833911f, -0.08658363f, 0.12417207f, 
    -0.26247224f, -0.04764760f, 0.00821562f, 0.00836470f, 0.04024343f, -0.16599303f, 0.10980177f, 0.09722658f, 
    0.18317908f, 0.01889771f, -0.03346428f, 0.08215239f, -0.00298785f, 0.12689851f, -0.18001346f, -0.31187347f, 
    0.21951266f, -0.01771007f, 0.06564521f, 0.08661328f, 0.02572857f, 0.05471291f, -0.00165127f, 0.07370310f, 
    0.07497367f, 0.08783789f, -0.01253934f, -0.04093245f, 0.12481064f, -0.00075590f, 0.12630992f, -0.02779636f, 
    0.31175736f, 0.01977230f, -0.22666073f, 0.06241520f, 0.05949895f, -0.02292947f, 0.12165272f, -0.01254440f, 
    0.20839453f, -0.03561310f, 0.08320610f, -0.02826589f, -0.01280503f, -0.12502684f, -0.05168258f, 0.07662125f, 
    0.11372732f, 0.10263267f, 0.05170536f, 0.00078808f, -0.04063728f, 0.39019275f, -0.05053479f, -0.23325330f, 
    0.13740493f, 0.00030602f, -0.13140467f, -0.07225352f, -0.14292841f, -0.01768600f, -0.01828624f, 0.00174341f, 
    -0.04579696f, -0.06611613f, 0.15190664f, -0.02698361f, 0.04149817f, -0.00951955f, 0.00681327f, -0.01880797f, 
    -0.12984656f, 0.32367608f, 0.04881595f, -0.11038998f, 0.07282805f, -0.05365013f, 0.03360951f, 0.04800340f, 
    0.03904416f, 0.05635016f, 0.13928840f, 0.10766251f, -0.01318769f, -0.04722821f, 0.02831924f, 0.03671367f, 
    -0.08664405f, 0.10912214f, 0.11400276f, 0.10856709f, 0.06628909f, -0.18580931f, -0.15926230f, 0.00957617f, 
    -0.13684300f, -0.02730601f, -0.02521688f, -0.04737542f, 0.02178976f, -0.04244287f, -0.01993483f, 0.14073405f, 
    0.03400194f, 0.02788659f, -0.11102184f, -0.09227788f, 0.00014183f, -0.01198671f, 0.14299689f, -0.06474574f, 
    0.03125815f, 0.12201308f, -0.19488101f, -0.06023561f, -0.17911789f, 0.05745991f, 0.20382978f, -0.12113032f, 
    0.04430961f, -0.05674241f, -0.05216421f, -0.03367347f, -0.03668851f, 0.08365587f, -0.17680724f, 0.10424309f, 
    0.10607203f, 0.12113338f, 0.01420432f, 0.10919593f, 0.26751587f, -0.23277573f, 0.02169927f, 0.01960067f, 
    -0.21794957f, -0.01601028f, 0.01638750f, -0.07747955f, -0.00848756f, 0.01797237f, 0.02423834f, 0.05249442f, 
    0.00679353f, 0.08841597f, 0.01285738f, 0.01925676f, -0.04162228f, -0.01943810f, 0.12670501f, -0.01500309f, 
    -0.26631707f, 0.11129142f, 0.04258011f, -0.07156318f, -0.19289073f, 0.14304699f, -0.01700178f, 0.14805460f, 
    0.06137267f, 0.07495918f, 0.00843907f, 0.06352830f, 0.05260130f, 0.01561439f, -0.05018065f, 0.03384520f, 
    0.01187222f, 0.15634339f, 0.00707490f, -0.05194993f, 0.27375221f, -0.14464563f, -0.08132565f, -0.01987327f, 
    -0.17196153f, 0.03793783f, 0.07654903f, 0.02933458f, -0.15629089f, 0.01095786f, 0.05303844f, 0.02812702f, 
    -0.02389344f, 0.02149242f, -0.06441487f, -0.02386641f, 0.03036018f, 0.09420636f, -0.00147398f, 0.06221037f, 
    -0.19857088f, 0.23401411f, -0.27267778f, -0.12758599f, -0.20106190f, 0.23259474f, 0.09418201f, -0.05137557f, 
    -0.01833543f, -0.08817068f, 0.00105666f, -0.00934506f, -0.06106851f, -0.12092023f, 0.11093180f, 0.09358992f, 
    0.01741108f, 0.01077125f, 0.05754566f, 0.03824337f, -0.61590785f, -0.18425405f, -0.14066492f, 0.09138628f, 
    -0.00138788f, 0.10289668f, -0.18856417f, 0.09027377f, 0.03905475f, 0.00265574f, 0.12257237f, 0.03691313f, 
    -0.11128237f, -0.10260481f, 0.03818060f, 0.01327703f, -0.03661345f, 0.01395193f, -0.11863600f, -0.03451375f, 
    0.33409420f, -0.12940833f, -0.07348043f, -0.01216748f, -0.02202555f, -0.08352290f, 0.05642170f, -0.21190906f, 
    0.10616950f, 0.13951682f, 0.00587414f, 0.09792658f, 0.03888014f, 0.06102927f, 0.25833431f, 0.02233505f, 
    -0.19243981f, 0.13006675f, 0.11097871f, 0.07839549f, 0.04859280f, 0.28413463f, -0.01757811f, 0.05372814f, 
    0.13379800f, 0.04555194f, 0.17135072f, -0.22394104f, -0.17046779f, 0.06959319f, 0.14192343f, -0.01744384f, 
    0.07867729f, 0.10031301f, 0.06362233f, 0.12699683f, 0.01731026f, 0.00649568f, 0.05831013f, 0.07090969f, 
    -0.28382295f, 0.10038061f, 0.07158163f, 0.18674879f, 0.36872503f, 0.11643103f, 0.16137183f, 0.03008034f, 
    -0.06236853f, -0.07690353f, 0.25314406f, 0.05176407f, 0.11102617f, 0.07175760f, 0.14741638f, 0.06505957f, 
    0.03587050f, -0.08916210f, 0.10902321f, -0.03026956f, 0.06898692f, -0.12035674f, -0.23445493f, 0.13034968f, 
    -0.16754420f, 0.11822940f, -0.01278761f, 0.09181887f, -0.03144869f, 0.13111432f, -0.03193482f, -0.01904563f, 
    -0.00904895f, -0.12258463f, 0.09043682f, -0.01841999f, 0.04925217f, -0.17904536f, -0.11336256f, -0.00843942f, 
    -0.67913002f, 0.40558809f, -0.33724228f, -0.18470851f, -0.13681006f, 0.16994271f, -0.00714968f, -0.05516971f, 
    0.04313441f, -0.19079873f, 0.02728269f, -0.03521324f, -0.08172729f, -0.15063976f, -0.09227192f, 0.06789403f, 
    -0.05561988f, 0.04613076f, -0.06283235f, 0.00727797f, -0.02505272f, 0.07817666f, -0.04037908f, -0.06585685f, 
    0.01792720f, 0.07901344f, -0.08896172f, 0.05046332f, 0.09938706f, -0.02313804f, 0.00381311f, -0.05286961f, 
    0.14368263f, 0.04869602f, 0.08944559f, 0.04698043f, 0.12943524f, 0.04435898f, -0.04691665f, 0.08405375f, 
    0.14546019f, -0.15948300f, 0.04639489f, -0.14422470f, 0.06741807f, -0.16325372f, -0.05117015f, -0.01192487f, 
    -0.02576804f, 0.11479298f, 0.10663932f, -0.04926704f, 0.00942847f, 0.10884932f, 0.15892908f, 0.08457339f, 
    -0.02968864f, 0.00843764f, 0.07841614f, -0.14049686f, -0.18720977f, -0.20062615f, 0.04398235f, 0.17762959f, 
    0.01136397f, 0.16925439f, 0.02564539f, -0.02574045f, 0.07522276f, -0.06768522f, -0.02056010f, 0.08895740f, 
    0.11935635f, 0.16769245f, 0.08122299f, -0.03272500f, 0.07265089f, -0.08201739f, -0.04655380f, -0.07831111f, 
    -0.25918287f, 0.07138082f, 0.03724919f, -0.15566398f, 0.21415153f, -0.05026324f, -0.00516452f, 0.01143317f, 
    0.09398219f, -0.03069866f, -0.02924501f, 0.04917574f, 0.22667481f, 0.12133606f, 0.05550153f, 0.21352044f, 
    0.09563686f, -0.01989616f, -0.03125280f, 0.23416030f, 0.12239311f, 0.00715662f, -0.12293769f, -0.04072737f, 
    -0.03322459f, 0.13475475f, -0.06693369f, 0.05486992f, 0.15630944f, 0.08233646f, 0.07066502f, 0.12316100f, 
    0.04349874f, 0.00458920f, 0.07823834f, 0.03921942f, 0.05519185f, 0.01965528f, 0.07689484f, 0.19507135f, 
    0.30259892f, 0.02169966f, 0.13933478f, 0.17440933f, -0.19559474f, -0.25199786f, -0.05551911f, -0.17923367f, 
    0.24683635f, -0.08975946f, 0.00964700f, 0.07269347f, 0.05861369f, 0.12132713f, 0.19098556f, -0.01686886f, 
    0.22386228f, -0.12055942f, 0.03457256f, -0.05102656f, 0.00868758f, -0.16752262f, 0.01742563f, -0.03637557f, 
    0.12182910f, -0.04914045f, -0.03141499f, -0.14646728f, 0.08463371f, 0.02751082f, 0.08556967f, 0.10410303f, 
    0.11219286f, -0.01304203f, 0.11474460f, -0.11452829f, -0.00563516f, 0.11225218f, 0.11319184f, 0.06410298f, 
    -0.05397495f, -0.01551090f, 0.02667801f, 0.00926528f, -0.06081031f, -0.03904609f, -0.05526843f, -0.05039045f, 
    -0.05123474f, -0.04236631f, 0.01290921f, 0.01834926f, -0.05379046f, -0.03080598f, 0.02099812f, -0.01540322f, 
    0.03210410f, -0.05839747f, -0.05232561f, -0.02963910f, -0.00131065f, 0.04413484f, 0.02830900f, -0.05727495f, 
    0.04860285f, -0.00674920f, -0.02738739f, 0.02384533f, -0.00983297f, 0.03962519f, -0.01449938f, -0.03928164f, 
    -0.04690623f, 0.04163444f, 0.03184820f, -0.05888255f, 0.04485451f, -0.04570648f, -0.00981605f, 0.03401643f, 
    -0.02895251f, -0.04485617f, -0.05306051f, -0.05282111f, -0.03310814f, -0.01676595f, -0.00858307f, 0.04248491f, 
    -0.00688209f, 0.00619159f, 0.03205010f, 0.01821106f, 0.02282323f, 0.04612477f, 0.00104043f, -0.00777129f, 
    0.04906450f, -0.03197898f, -0.00256700f, -0.05926124f, -0.04241744f, -0.04150169f, 0.00961625f, 0.03392708f, 
    0.02901835f, -0.01455033f, -0.04583685f, -0.03092863f, 0.03223181f, 0.03767546f, 0.02955619f, -0.00821235f, 
    -0.01496848f, -0.00327880f, -0.02923461f, 0.00932970f, 0.04263452f, 0.02759532f, -0.03023498f, -0.01860335f, 
    -0.04910615f, -0.03494245f, -0.00716893f, -0.03285002f, -0.00909946f, -0.03854022f, 0.02770388f, 0.01712064f, 
    -0.03710779f, -0.04369878f, -0.03542655f, 0.04468767f, -0.02866519f, 0.01648488f, 0.00074312f, 0.03835335f, 
    -0.00785709f, 0.05235383f, -0.03943273f, -0.00104074f, -0.02022608f, -0.01449667f, 0.00846381f, -0.05982157f, 
    -0.04221531f, 0.02535038f, 0.02863364f, -0.02967767f, -0.00275011f, -0.04500007f, -0.05546715f, 0.00560208f, 
    -0.00610807f, -0.00479182f, -0.01611956f, 0.02892488f, -0.05328310f, -0.00617320f, 0.00678117f, 0.01142634f, 
    -0.01051730f, -0.05176348f, -0.04123663f, -0.04200420f, -0.01734446f, -0.05045919f, -0.03763058f, 0.03177409f, 
    0.03598820f, 0.00640626f, 0.04543672f, -0.02579908f, 0.01443396f, -0.04165217f, -0.05757329f, -0.01167043f, 
    0.03407234f, -0.02805449f, -0.00059315f, 0.01227785f, -0.01655154f, 0.00076456f, 0.01763090f, 0.01775238f, 
    0.03533240f, 0.02673485f, 0.04472624f, -0.03482815f, -0.02638969f, 0.04421974f, -0.01147538f, -0.00499375f, 
    -0.05819476f, -0.00135155f, -0.00945897f, 0.01939853f, 0.02730946f, 0.02428911f, 0.00648322f, 0.00734803f, 
    -0.05997052f, -0.05987200f, -0.02485272f, 0.05396660f, -0.03680802f, -0.03232414f, -0.05581532f, -0.04888996f, 
    -0.02629049f, 0.01439147f, 0.02011947f, 0.00908756f, -0.04222125f, 0.04913235f, -0.02635440f, 0.04787494f, 
    -0.06137773f, -0.00696253f, -0.03777293f, 0.04266912f, 0.02792349f, -0.05792198f, -0.05530649f, -0.04487493f, 
    -0.01852276f, -0.00101724f, -0.05230986f, -0.04784669f, -0.05111924f, -0.05014173f, -0.02078342f, 0.00151192f, 
    -0.02232359f, 0.01624344f, -0.05656095f, -0.04012863f, 0.05226371f, -0.04472953f, 0.02969827f, 0.01501964f, 
    -0.01805900f, -0.03539827f, 0.00886713f, 0.00180927f, -0.01372419f, 0.04037189f, -0.03983073f, 0.03240442f, 
    0.03077376f, 0.03830171f, 0.04178970f, -0.02203969f, 0.01484072f, 0.04209946f, 0.00000895f, 0.04590257f, 
    0.02644545f, 0.04442535f, 0.02272042f, -0.05963392f, -0.02468241f, -0.00418635f, -0.06129308f, -0.03197148f, 
    -0.03842165f, -0.05558078f, 0.03257552f, -0.03408533f, 0.00196154f, 0.03999329f, -0.00991908f, -0.03708768f, 
    0.02637496f, -0.06092309f, -0.02121121f, -0.03096600f, -0.04354975f, 0.03372741f, 0.00464487f, -0.01531910f, 
    0.00132088f, 0.03214943f, 0.01722308f, 0.04912301f, 0.01544177f, -0.05564426f, -0.05946848f, -0.03560597f, 
    0.03229969f, -0.00400366f, -0.01230212f, -0.02678903f, 0.04807094f, 0.02101728f, 0.00879787f, -0.03344563f, 
    0.04765663f, 0.03157398f, 0.00593633f, -0.02771086f, 0.05390914f, -0.00158139f, -0.04891587f, 0.00670917f, 
    0.01434003f, -0.05265741f, -0.01629729f, -0.05911136f, -0.05086784f, 0.03890144f, -0.04404724f, 0.01275205f, 
    -0.01212357f, 0.00046181f, -0.05621121f, -0.05199350f, -0.03386320f, 0.02940962f, 0.03365618f, 0.01309814f, 
    -0.03362124f, 0.02504159f, -0.04181942f, 0.03024964f, 0.03095640f, 0.02118130f, 0.01726158f, -0.05493246f, 
    -0.05263890f, 0.01490222f, -0.02084748f, -0.02936758f, -0.02940046f, -0.01125554f, -0.03660448f, -0.04974272f, 
    -0.03744267f, -0.05192899f, 0.00494885f, -0.04629765f, 0.00553055f, 0.04904351f, -0.02824895f, 0.04592477f, 
    -0.05427741f, -0.05066118f, 0.00839395f, 0.04586471f, -0.05555423f, -0.05426771f, -0.02875904f, 0.01388976f, 
    0.04645352f, -0.04700778f, 0.02150916f, 0.04124672f, 0.00024745f, -0.02974211f, 0.02729360f, -0.05730551f, 
    -0.31547806f, -0.08749764f, 0.18557209f, 0.10666452f, 0.16117172f, 0.06828402f, 0.03310262f, 0.10659728f, 
    0.09386742f, 0.04008305f, 0.05202035f, -0.01396774f, 0.09872302f, -0.02495941f, -0.09029245f, 0.05285943f, 
    -0.11631546f, 0.18477294f, -0.00559990f, -0.06438897f, 0.07441389f, -0.00762375f, -0.03375573f, -0.03228333f, 
    -0.04201973f, -0.06910643f, -0.00282413f, 0.13606395f, -0.08454809f, 0.06521492f, -0.03398691f, 0.04774942f, 
    -0.07380188f, 0.02826908f, 0.10290378f, -0.02672872f, -0.08748121f, -0.01781032f, -0.08527848f, -0.03747064f, 
    0.20733729f, 0.12071279f, 0.12335680f, 0.03120011f, 0.17345965f, 0.02910874f, 0.10977261f, -0.10082476f, 
    -0.01203520f, -0.18462044f, -0.00886466f, -0.04924479f, -0.13718998f, 0.02589573f, -0.11276125f, -0.08264881f, 
    0.05385070f, -0.04853808f, -0.03811156f, -0.03322472f, 0.43614230f, -0.11165860f, 0.11684421f, -0.10996339f, 
    -0.10211997f, -0.00647680f, -0.06553345f, 0.01301567f, -0.13280810f, -0.10536572f, -0.00685700f, -0.07164542f, 
    0.09828077f, -0.02608180f, -0.04664641f, -0.00154219f, -0.16269761f, 0.13365380f, -0.11430837f, -0.05456255f, 
    0.85409635f, 0.02498409f, -0.21591254f, -0.24284266f, -0.30806413f, 0.06902955f, 0.01672281f, -0.08745260f, 
    -0.02257965f, -0.00926128f, 0.01432138f, -0.02553020f, 0.11188828f, -0.09023776f, 0.07607546f, -0.07750823f, 
    0.00315562f, -0.01577726f, 0.00092795f, -0.08238074f, -0.25642022f, 0.56943220f, -0.21725559f, -0.12967604f, 
    -0.31552550f, 0.23913544f, 0.03337680f, 0.07021631f, 0.10695959f, 0.00646410f, 0.07997072f, -0.03721050f, 
    0.01773756f, -0.04582680f, 0.04934534f, 0.05766509f, 0.01636900f, 0.00514276f, -0.11181162f, 0.06983200f, 
    -0.17880867f, 0.20841630f, 0.04464532f, 0.08956136f, 0.22525352f, 0.16044925f, 0.14726743f, 0.12681636f, 
    -0.08396678f, 0.00669721f, 0.13167942f, 0.17575723f, 0.00979869f, -0.06982148f, -0.05735116f, 0.15991417f, 
    -0.05500440f, 0.07629813f, 0.04892243f, -0.00198110f, 0.61949158f, 0.05145923f, 0.37780532f, 0.07509404f, 
    0.05663062f, -0.02744553f, 0.16170135f, -0.07793570f, -0.09444416f, 0.09485333f, 0.01455183f, 0.06523777f, 
    0.10770465f, -0.10234984f, -0.05829599f, 0.03209736f, 0.02551636f, -0.10876995f, -0.12802334f, 0.04060979f, 
    0.14074466f, 0.49233118f, 0.02825290f, 0.07558624f, 0.05285415f, 0.19622250f, 0.11369853f, 0.03459356f, 
    0.02815554f, -0.11293443f, 0.16602051f, 0.05160505f, 0.00445700f, -0.00214065f, -0.07399442f, 0.02521169f, 
    -0.03173025f, -0.04383340f, -0.02828909f, 0.05924557f, 0.10749187f, -0.01418717f, -0.22521716f, -0.20206408f, 
    0.28193054f, -0.17234182f, -0.14746431f, -0.09332912f, 0.00206797f, -0.14372714f, 0.01321504f, -0.10742168f, 
    0.05045573f, 0.17393793f, 0.02028278f, 0.11365012f, 0.11636763f, 0.07949953f, -0.02046039f, 0.06863700f, 
    0.04127535f, -0.24755706f, -0.18250394f, -0.00754806f, -0.00913718f, -0.13342647f, -0.09145039f, -0.03167824f, 
    0.01074245f, -0.03846413f, -0.00766659f, -0.10332276f, 0.01571343f, 0.01535184f, 0.06282835f, 0.17068110f, 
    -0.05509356f, 0.16830276f, -0.01879152f, 0.07308578f, -0.10261129f, -0.24776937f, 0.06210868f, -0.11322550f, 
    0.10335016f, 0.02503931f, -0.15660280f, -0.07959082f, 0.04750702f, 0.01103921f, 0.08779470f, -0.00193807f, 
    -0.07416146f, -0.02787302f, -0.03039578f, -0.04549296f, 0.05417699f, 0.01385649f, 0.05585221f, -0.02039652f, 
    0.13343638f, 0.05844877f, -0.00537915f, -0.26341000f, 0.04732195f, -0.16488200f, 0.01551192f, -0.10552572f, 
    0.09344579f, 0.04454579f, 0.04709738f, -0.02824809f, 0.07097092f, -0.02522590f, 0.01018884f, -0.10115162f, 
    -0.08855466f, 0.07893012f, 0.02430752f, 0.02607112f, 0.01822388f, 0.12259573f, 0.10188029f, -0.07069135f, 
    -0.05737158f, 0.10381993f, 0.03141933f, 0.01522455f, -0.04919065f, 0.02946323f, 0.14274879f, 0.00728735f, 
    -0.13908277f, -0.04269191f, 0.03831963f, -0.08719879f, -0.13049366f, 0.07925339f, 0.14048031f, -0.00136404f, 
    -0.12169475f, 0.03837569f, 0.11270853f, -0.06410960f, 0.02121572f, -0.03217015f, -0.13274056f, -0.13789383f, 
    0.11927450f, -0.14996263f, -0.04475846f, 0.01067223f, -0.00956784f, 0.14749628f, -0.13218676f, 0.01846218f, 
    0.04780991f, 0.05595129f, -0.11244781f, -0.08663020f, 0.37249547f, -0.18908519f, 0.02961983f, -0.14301665f, 
    -0.11148816f, -0.06528065f, 0.14225857f, -0.01986898f, -0.00767831f, -0.08317088f, 0.06469187f, -0.04837666f, 
    0.04774481f, -0.01895842f, 0.05354108f, -0.06177345f, 0.00099461f, 0.10103640f, -0.02769942f, 0.06571309f, 
    0.30070353f, 0.08228830f, -0.29187503f, 0.07629555f, -0.15630142f, 0.07234557f, 0.08487152f, -0.07940868f, 
    -0.09859932f, 0.10237555f, 0.02618471f, -0.00952513f, -0.01745512f, 0.09083193f, 0.07002020f, 0.06754859f, 
    0.09346878f, -0.08484610f, 0.00838540f, -0.00419851f, -0.09896759f, -0.09650553f, 0.03143857f, 0.14076214f, 
    0.06580044f, -0.02468076f, 0.07668650f, 0.00581757f, 0.14345151f, 0.02712470f, 0.07901387f, 0.00862916f, 
    0.04516029f, 0.07959272f, -0.07111177f, 0.13911186f, 0.02945234f, 0.00206980f, -0.01987556f, 0.04233492f, 
    0.15301105f, -0.12938005f, -0.00167940f, 0.00485995f, 0.01305133f, -0.07513230f, 0.06709253f, 0.09002431f, 
    -0.01145750f, 0.15958308f, 0.04509221f, 0.13277218f, 0.10826460f, -0.01111572f, 0.05170046f, 0.05188785f, 
    0.04902331f, -0.01565112f, -0.02089365f, -0.07900834f, 0.18210265f, 0.08830987f, 0.02942520f, 0.09579115f, 
    0.17957222f, -0.03533934f, 0.16667007f, -0.03614957f, 0.07754454f, 0.10522480f, -0.03205127f, -0.05363028f, 
    0.04630519f, -0.07580566f, -0.08250831f, 0.01406541f, 0.15947774f, -0.06381789f, 0.08829539f, 0.01049357f, 
    -0.45453852f, 0.13210015f, 0.17778985f, 0.15213741f, -0.10127317f, -0.02861646f, -0.03766098f, 0.12936594f, 
    0.04596311f, -0.03834040f, 0.08167076f, 0.06073250f, -0.00608394f, 0.09326299f, -0.16666301f, 0.09812050f, 
    0.07152805f, -0.02057663f, -0.13687465f, -0.03609607f, 0.21859516f, -0.28517619f, 0.24444117f, 0.10578413f, 
    0.02990104f, -0.13035128f, -0.04350974f, 0.16718291f, -0.04951353f, 0.00250843f, -0.07234249f, 0.03779415f, 
    -0.16286804f, 0.10325029f, -0.11311619f, 0.02756200f, -0.12437636f, 0.05586698f, 0.03112010f, -0.13089342f, 
    0.18579940f, -0.05640145f, 0.14699982f, -0.11690025f, -0.21476220f, -0.10201189f, -0.12597844f, -0.03526070f, 
    -0.01237669f, 0.05928827f, -0.18435736f, -0.02563020f, -0.06028995f, 0.08506102f, -0.03776990f, -0.02351453f, 
    0.08677603f, -0.06631214f, -0.08112185f, 0.05144471f, -0.46502349f, 0.21537255f, -0.21806037f, 0.01373203f, 
    0.10689618f, -0.02673472f, -0.02072144f, 0.06194652f, 0.17325117f, 0.03096051f, 0.03629891f, -0.00213453f, 
    -0.02054891f, -0.10354271f, -0.06426431f, -0.04587466f, 0.04198378f, 0.07405906f, 0.11777570f, -0.03191757f, 
    0.61196095f, -0.56555378f, 0.15635079f, 0.00559355f, 0.09644500f, -0.14536294f, 0.02872988f, -0.03939562f, 
    -0.00640767f, 0.16034658f, -0.14030811f, 0.08503900f, -0.10234396f, 0.00080385f, 0.03275674f, 0.03552236f, 
    -0.01100679f, 0.04453625f, 0.05390004f, 0.04212908f, -0.00283506f, 0.15319832f, 0.16559277f, 0.24909198f, 
    -0.09210722f, 0.02566255f, 0.20506144f, -0.04998923f, -0.00997197f, 0.09506402f, -0.07345984f, 0.05908570f, 
    0.09014592f, 0.00003951f, -0.00659808f, -0.03980457f, -0.00049200f, -0.01245041f, 0.07821959f, 0.01798741f, 
    -0.11848638f, 0.10299872f, 0.28177777f, 0.17667846f, -0.01679280f, 0.13524504f, 0.03878435f, 0.06554432f, 
    -0.02790907f, 0.02138541f, -0.17967065f, 0.04848563f, 0.05677044f, -0.10863275f, -0.05352357f, -0.12556191f, 
    0.01098085f, -0.15264314f, -0.07890573f, 0.11637285f, 0.27759370f, 0.37521791f, -0.06020801f, 0.08217444f, 
    0.27643046f, -0.03081959f, 0.19212838f, 0.05247844f, 0.02543804f, 0.17640941f, -0.06468515f, 0.07016307f, 
    0.09558529f, 0.04364452f, -0.00838204f, 0.00374495f, 0.09448060f, 0.00943529f, -0.04843833f, 0.10659215f, 
    -0.11845232f, -0.06893578f, 0.06780185f, 0.17930484f, 0.02280773f, 0.14799772f, 0.06461657f, 0.13179541f, 
    -0.06976008f, 0.12944688f, -0.03702172f, -0.08968958f, -0.10575650f, 0.01655158f, -0.06897690f, 0.06872170f, 
    0.00664911f, -0.02165295f, -0.02552433f, -0.05187966f, 0.05703507f, -0.03022305f, 0.20716718f, 0.06237097f, 
    -0.07261173f, -0.17115764f, -0.04617913f, 0.09087279f, -0.04649944f, -0.05824494f, 0.00961545f, -0.10998658f, 
    -0.11695367f, -0.14549807f, 0.01594670f, -0.00443673f, 0.04725330f, -0.13371643f, -0.08525556f, -0.08917725f, 
    -0.02075402f, 0.01950137f, -0.17965822f, -0.06687596f, 0.34462780f, -0.02650889f, 0.01230591f, 0.09989061f, 
    -0.04901950f, 0.09519000f, 0.00386758f, -0.07828279f, 0.07701294f, 0.02400119f, 0.01266120f, 0.06115692f, 
    -0.10690862f, -0.00385251f, 0.05044705f, 0.11006426f, -0.10402902f, 0.19206043f, 0.10368469f, 0.08369052f, 
    -0.07414062f, -0.06590474f, -0.08286092f, 0.09656105f, -0.01295716f, 0.07904243f, -0.06378102f, -0.02590366f, 
    -0.03951875f, 0.01541281f, 0.03354183f, 0.08627086f, -0.02451780f, -0.06474983f, -0.10969438f, -0.05422134f, 
    0.03061891f, 0.02058226f, -0.02495880f, 0.03922678f, -0.02155383f, -0.04171501f, -0.03669831f, 0.01068417f, 
    -0.05542555f, 0.00092308f, -0.03873198f, 0.04102678f, -0.05942940f, 0.04221944f, -0.02104039f, -0.00157023f, 
    0.03044391f, -0.00417043f, -0.01779927f, -0.05753196f, 0.00007029f, 0.03337269f, 0.03201676f, -0.03487074f, 
    -0.05240288f, -0.03824936f, -0.03371404f, 0.01380233f, -0.00927620f, -0.02098920f, -0.00349383f, 0.01926763f, 
    -0.02634525f, -0.04744837f, 0.02912371f, -0.05581558f, 0.03353772f, -0.00839610f, 0.04058105f, 0.00746553f, 
    -0.01995659f, -0.05829557f, -0.05485689f, -0.01261386f, -0.03697830f, 0.02350312f, 0.00175784f, 0.01583250f, 
    -0.03565091f, -0.04820219f, -0.03362602f, 0.01046221f, -0.01094023f, 0.02086446f, -0.02006526f, 0.00042032f, 
    -0.05800385f, 0.02707364f, 0.03932391f, 0.03570860f, 0.03645309f, -0.04322669f, -0.03369578f, 0.00770395f, 
    0.04504782f, -0.06305709f, -0.03315338f, -0.00216270f, -0.05941854f, 0.04841990f, -0.00538483f, -0.05495597f, 
    -0.04824686f, -0.01272860f, 0.02433038f, 0.03860704f, 0.00181554f, -0.05416981f, 0.00532874f, -0.01656886f, 
    -0.00746140f, 0.01494900f, -0.02859233f, -0.06311077f, -0.01633012f, -0.06133649f, 0.04452668f, 0.02768058f, 
    -0.03805350f, 0.01312912f, -0.04243399f, -0.02041160f, -0.05357436f, 0.03116155f, 0.03070012f, 0.00204667f, 
    -0.02577026f, 0.02366886f, -0.04348586f, -0.00815263f, -0.03030992f, 0.03949396f, -0.04446749f, -0.00637719f, 
    0.03120452f, -0.02330862f, -0.04152019f, -0.02266013f, -0.03884138f, -0.01845889f, 0.04075030f, -0.05936374f, 
    -0.03241543f, -0.02148205f, -0.00064205f, -0.03679275f, 0.02343700f, -0.01305630f, -0.04167461f, 0.01905870f, 
    0.01093572f, 0.00158337f, -0.00958946f, -0.01805949f, 0.01014981f, -0.00785490f, 0.03161554f, 0.04668975f, 
    0.03665461f, 0.02746854f, -0.04544432f, -0.02224506f, 0.01190373f, 0.04382213f, 0.02516302f, 0.04194229f, 
    0.00094804f, 0.04661880f, 0.03185758f, -0.00797702f, -0.04405943f, 0.01613831f, -0.05079075f, -0.03363546f, 
    0.02126285f, -0.03213894f, 0.01459872f, -0.01108131f, 0.03296231f, -0.01928767f, -0.01530452f, -0.01044981f, 
    -0.00768565f, -0.01145707f, 0.02324190f, -0.05056838f, -0.06234816f, -0.03262329f, -0.02385435f, 0.01666222f, 
    0.03380432f, -0.03657513f, 0.01596476f, 0.05862258f, 0.04716018f, -0.04952393f, -0.01165268f, -0.02673589f, 
    0.04214155f, 0.01671831f, -0.00357483f, -0.05994732f, -0.04221439f, -0.04988553f, -0.00335048f, -0.01873697f, 
    -0.03864988f, -0.06219662f, 0.03248904f, 0.02831580f, -0.02543896f, 0.03161935f, 0.02136229f, -0.01663315f, 
    -0.02118293f, -0.03525123f, -0.02120091f, 0.01315138f, 0.03886391f, 0.03893042f, -0.03659224f, -0.00886618f, 
    -0.00012085f, -0.03144379f, 0.04557652f, 0.01407664f, -0.05472915f, 0.04295555f, 0.00954836f, 0.00248941f, 
    -0.01681474f, 0.01457782f, 0.02034858f, -0.05916479f, 0.04324773f, 0.00797224f, -0.05497536f, 0.03513854f, 
    -0.04781037f, 0.00203520f, -0.05380012f, -0.03789454f, 0.01481164f, 0.03747006f, 0.04264097f, -0.00848973f, 
    0.03926920f, 0.02357043f, -0.01348673f, -0.05700585f, -0.01671116f, 0.01931297f, -0.04239403f, -0.04326031f, 
    -0.00512359f, 0.03108334f, -0.03746431f, -0.05681480f, -0.04776176f, -0.00674943f, 0.04427123f, 0.00908167f, 
    -0.04716672f, -0.01747781f, 0.03977941f, 0.00616254f, -0.03721853f, 0.03391625f, -0.00935255f, -0.04728462f, 
    0.01284627f, 0.03122758f, -0.02754876f, 0.03394163f, 0.03724545f, -0.03502766f, 0.03610923f, -0.01513786f, 
    -0.02291207f, -0.04955234f, 0.00042959f, 0.02177270f, 0.02033501f, -0.01588188f, -0.01494212f, -0.05789910f, 
    0.02929471f, -0.02830130f, -0.00532845f, 0.00729827f, -0.07257943f, -0.02525092f, -0.01301456f, -0.03219311f, 
    0.02588682f, -0.05699353f, -0.01122276f, 0.03781033f, -0.00518291f, -0.01045654f, 0.03389473f, 0.05257907f, 
    -0.03670119f, 0.02884740f, 0.02921607f, 0.04591189f, 0.01405782f, 0.03876769f, -0.05170753f, 0.02403694f, 
    0.06337822f, 0.03706542f, 0.02513331f, 0.04081545f, -0.00281255f, 0.01502925f, -0.04612222f, 0.03388752f, 
    0.02641030f, -0.04534356f, 0.02849318f, 0.00609784f, -0.04958763f, 0.04439714f, -0.03593770f, -0.04029450f, 
    -0.00904127f, -0.02120841f, 0.03472549f, -0.04028793f, -0.03724379f, -0.01277511f, 0.03037055f, 0.01537788f, 
    -0.03390915f, -0.00651969f, -0.03060615f, -0.01355239f, -0.00387943f, -0.05671623f, 0.01823350f, -0.03975769f, 
    0.02204980f, -0.04222581f, 0.01365750f, 0.03897600f, 0.03891077f, 0.01758336f, -0.03792566f, 0.03436137f, 
    -0.43033376f, 0.00118192f, -0.29205009f, -0.02761916f, -0.01944559f, 0.04827572f, 0.14421609f, 0.15376225f, 
    -0.03898121f, -0.02455900f, 0.01312899f, 0.03696212f, -0.03877560f, 0.09111173f, 0.05101143f, 0.14139132f, 
    -0.02506620f, -0.00505070f, 0.01586013f, -0.02367669f, -0.07769944f, 0.28640252f, 0.09903979f, 0.18439673f, 
    0.09927763f, -0.02617756f, 0.13197581f, 0.04537640f, -0.01616508f, 0.12487512f, 0.11265069f, -0.03148571f, 
    0.02479593f, 0.07827103f, -0.00035246f, 0.01233304f, -0.01430212f, -0.03924190f, -0.06406055f, -0.06794836f, 
    -0.45727500f, 0.12778465f, -0.12605843f, -0.03629706f, 0.19045456f, 0.10252422f, 0.08330351f, 0.02284449f, 
    0.03695155f, -0.07081415f, 0.09646005f, 0.03006965f, 0.02640577f, -0.05110184f, 0.04333277f, 0.09704586f, 
    0.08183853f, 0.03657390f, 0.10754742f, -0.08288748f, -0.14568377f, -0.20136231f, -0.15155780f, -0.19347973f, 
    -0.02926072f, 0.11072194f, 0.05783657f, 0.11488319f, 0.03923865f, -0.18717174f, 0.03545084f, -0.01439984f, 
    0.11730143f, -0.08712546f, 0.05866734f, -0.11077572f, -0.05526333f, 0.04429398f, -0.04781630f, 0.04921193f, 
    0.35411295f, 0.24144045f, 0.09456382f, 0.30519062f, -0.11715042f, -0.15370916f, 0.01069953f, 0.02635100f, 
    0.02842002f, 0.01385918f, 0.11646031f, 0.07253368f, 0.14547238f, 0.08455529f, 0.03834767f, 0.03582886f, 
    -0.03501105f, 0.07564621f, -0.01924881f, -0.00865988f, 0.33663422f, 0.34297395f, 0.22705087f, 0.09823970f, 
    0.02217196f, -0.03728762f, 0.09027431f, -0.04932949f, -0.07515800f, 0.14208743f, 0.04232551f, -0.05484913f, 
    -0.04546380f, 0.08891670f, -0.05719678f, 0.05359236f, -0.03926375f, 0.12000984f, 0.08115883f, -0.12317000f, 
    0.28627035f, 0.12185356f, -0.02325725f, 0.03282703f, -0.19349129f, 0.15118739f, 0.05129831f, -0.01696230f, 
    -0.04437808f, 0.10331722f, -0.00852326f, -0.01058719f, 0.12916137f, 0.01626073f, -0.05658096f, 0.00326992f, 
    0.03692188f, -0.04808949f, 0.04328409f, 0.00276066f, -0.54269540f, -0.13091369f, -0.11889920f, -0.24237125f, 
    0.01726192f, -0.04109045f, 0.07981637f, 0.12659281f, -0.12542504f, -0.04365838f, 0.02517607f, -0.15347704f, 
    0.09274399f, -0.07264304f, -0.03717357f, 0.01101692f, 0.09764045f, -0.06045880f, 0.04730088f, 0.04719537f, 
    -0.48463061f, 0.16403838f, -0.28191826f, -0.20858939f, 0.17680445f, 0.23519433f, 0.04968185f, -0.03648778f, 
    0.10650650f, 0.03215541f, 0.13268274f, -0.15745027f, 0.03188284f, -0.02313710f, -0.13870274f, 0.06774800f, 
    0.03525449f, 0.08412492f, 0.08729442f, -0.16213970f, -0.08754707f, -0.06234069f, -0.00326867f, -0.13749659f, 
    0.16496775f, 0.17731814f, -0.00443120f, -0.10375456f, 0.09388832f, -0.05658945f, 0.02599637f, 0.01617606f, 
    -0.03575674f, 0.06395008f, 0.18873543f, -0.05154716f, 0.08028132f, 0.07868163f, -0.21307136f, 0.17437083f, 
    0.01625042f, -0.24022514f, 0.23441716f, 0.16845898f, 0.04126749f, -0.26611844f, -0.03926442f, -0.15833767f, 
    -0.06013650f, 0.10430237f, -0.03143156f, -0.08485401f, -0.02392123f, 0.17780219f, 0.08778539f, 0.01621596f, 
    0.03530931f, -0.11691176f, 0.09962916f, 0.05020352f, -0.24437851f, -0.00993173f, -0.18104428f, 0.09425060f, 
    0.23189822f, 0.13644719f, -0.18122092f, -0.08092174f, 0.01099633f, 0.04441526f, 0.13751829f, 0.04288430f, 
    0.16948526f, 0.16538644f, -0.07843564f, 0.01060829f, -0.06622496f, -0.01498996f, 0.05253656f, 0.07948211f, 
    -0.24542449f, -0.04805371f, 0.03186284f, 0.00505533f, 0.15841153f, 0.04008970f, -0.02712409f, -0.00396894f, 
    0.00477396f, 0.01457368f, 0.16059278f, 0.08258964f, -0.02792103f, 0.16352777f, 0.11425434f, -0.06203807f, 
    -0.13796298f, -0.00560795f, -0.11817081f, -0.03089363f, 0.14993083f, 0.16199175f, -0.02901256f, -0.02585937f, 
    0.10104081f, 0.02809188f, -0.04977856f, 0.11587114f, 0.15579994f, 0.20949389f, 0.06102367f, 0.03168118f, 
    -0.05289728f, -0.00964183f, -0.06602060f, 0.01893442f, 0.11884797f, -0.01283923f, 0.02474039f, -0.03538418f, 
    0.19642238f, 0.02484677f, -0.00930858f, 0.32840532f, -0.13138428f, -0.14290313f, -0.05179232f, -0.03316326f, 
    -0.02180693f, -0.09742387f, 0.02328502f, -0.00721205f, 0.06242808f, 0.17483833f, 0.10764287f, -0.03821312f, 
    0.04342536f, -0.12557307f, -0.04612135f, 0.09822913f, 0.07850121f, 0.33458334f, 0.02875469f, 0.36298016f, 
    -0.00663268f, -0.03183598f, 0.02503874f, 0.09223022f, -0.07418130f, 0.11811912f, 0.04086355f, 0.17780846f, 
    0.02652883f, -0.04349450f, 0.05208034f, 0.03123939f, -0.02666618f, 0.01979696f, 0.09751632f, 0.00390064f, 
    -0.00963957f, 0.06913330f, -0.03440196f, -0.04361977f, -0.11168464f, 0.16488360f, 0.01479981f, 0.11935693f, 
    0.04841259f, -0.05213706f, 0.09791318f, -0.05245336f, 0.08990137f, 0.05056695f, 0.04029283f, 0.09603614f, 
    0.05262563f, 0.03105197f, 0.03290268f, -0.11428118f, 0.19036444f, 0.14117123f, 0.05626490f, -0.11760096f, 
    -0.24748138f, -0.14123659f, 0.01059167f, -0.04883654f, -0.22442429f, -0.25242567f, -0.06130902f, -0.05255004f, 
    -0.08776404f, 0.02222475f, -0.00803911f, 0.24893041f, 0.06439286f, 0.09102880f, -0.02373276f, 0.01118184f, 
    -0.19251655f, 0.28541759f, -0.07728721f, -0.32650402f, -0.01166179f, -0.00390416f, 0.17245410f, 0.15007129f, 
    0.14139557f, -0.02536730f, -0.03523869f, -0.02077861f, -0.05735069f, 0.03708185f, 0.02100054f, 0.04481680f, 
    0.17651860f, 0.04036369f, -0.02850094f, -0.08484951f, -0.52349800f, -0.05347864f, 0.19983678f, 0.10805291f, 
    -0.11001445f, 0.12795272f, 0.01198376f, -0.02667057f, 0.08042756f, 0.05223461f, 0.18588181f, 0.17729631f, 
    -0.05116475f, 0.11823720f, 0.03860873f, -0.05078547f, -0.06453831f, -0.04270848f, 0.06323411f, 0.09472334f, 
    -0.17951788f, -0.41693234f, 0.12498352f, -0.17816633f, 0.06809166f, 0.00143557f, 0.01649699f, -0.16431409f, 
    -0.05323319f, -0.08289184f, -0.13998501f, -0.06170894f, -0.03067559f, 0.05599364f, 0.04577559f, -0.00300576f, 
    0.06782196f, -0.06868038f, 0.03454705f, -0.06306402f, 0.21173106f, -0.22104566f, -0.00730025f, -0.35940135f, 
    0.20063719f, -0.02660710f, 0.09201939f, -0.11911631f, -0.26910469f, -0.07722927f, -0.01822203f, -0.10673612f, 
    0.21023943f, -0.03959797f, 0.00960547f, 0.26494384f, 0.22347395f, -0.03838665f, -0.19847623f, 0.06380687f, 
    -0.52779841f, 0.40816548f, 0.04128280f, -0.14050297f, 0.45877489f, -0.04700339f, 0.11706555f, -0.01862065f, 
    0.06611542f, -0.14006306f, 0.14002471f, -0.07453001f, -0.10880502f, 0.05541492f, 0.04026926f, 0.06745221f, 
    0.16116196f, -0.12196735f, 0.04313639f, -0.12609257f, -0.23958752f, 0.32750633f, 0.17384902f, 0.01273541f, 
    -0.19565356f, 0.08321112f, 0.05573083f, 0.05112964f, 0.14050692f, 0.07500073f, 0.08656536f, -0.05181693f, 
    -0.06435148f, 0.04649817f, -0.05595807f, 0.04154324f, 0.10905182f, -0.03857295f, 0.05646596f, 0.04005269f, 
    -0.16917190f, 0.20326114f, -0.27722979f, -0.13520804f, -0.00111480f, 0.22651245f, 0.27193335f, 0.22970834f, 
    0.16521394f, 0.03807205f, 0.01133691f, 0.05870584f, 0.05563994f, -0.02761539f, -0.01275214f, 0.04631886f, 
    0.13408135f, 0.05227785f, -0.10216297f, -0.01457916f, 0.14122583f, 0.05974937f, 0.08455034f, 0.23316579f, 
    0.09198968f, -0.05729526f, -0.16469976f, -0.05915931f, -0.01161894f, 0.22190888f, 0.04675980f, 0.13674943f, 
    0.01664790f, 0.04809048f, 0.08237398f, -0.06017883f, 0.00323866f, 0.02406881f, -0.10017174f, 0.10839624f, 
    -0.22069956f, 0.23561890f, -0.02544528f, -0.04422177f, -0.13338862f, -0.07526638f, -0.11427418f, -0.13472666f, 
    -0.08384197f, 0.17461053f, -0.09668089f, 0.00925391f, 0.03946744f, -0.08994503f, 0.02972585f, 0.05315597f, 
    0.16668545f, -0.06162998f, -0.08977879f, -0.01589693f, 0.01124286f, 0.04018147f, 0.06924810f, 0.55689776f, 
    0.03329541f, 0.08006085f, 0.20602185f, 0.01162144f, 0.07730538f, 0.00224184f, 0.00619874f, 0.01454732f, 
    0.07557397f, 0.15909345f, 0.16927911f, 0.01725916f, 0.07979980f, -0.10787056f, -0.00337510f, -0.08153652f, 
    0.20200123f, 0.04943127f, 0.00672568f, 0.02791838f, 0.06616209f, -0.12580226f, -0.14967456f, -0.08564782f, 
    0.02686773f, -0.00782003f, -0.01893825f, 0.11668541f, 0.16423431f, 0.01160605f, 0.03318411f, -0.00105506f, 
    0.07714918f, 0.01099751f, -0.07349346f, 0.14950892f, -0.11709283f, -0.03747283f, 0.00931530f, -0.39707431f, 
    -0.15707788f, -0.05400599f, -0.22400856f, 0.00211087f, 0.11972462f, -0.15395856f, 0.00405911f, -0.06566541f, 
    -0.09530662f, -0.08778402f, -0.10498700f, 0.12733901f, 0.10904110f, 0.04446532f, -0.04729366f, -0.00597413f, 
    0.01453996f, -0.12384288f, 0.57214516f, 0.48916224f, 0.02381859f, 0.07573649f, -0.12349753f, -0.00876990f, 
    0.13321035f, 0.18646351f, -0.02545250f, -0.00556063f, -0.01802079f, 0.22069454f, 0.12280788f, -0.11033941f, 
    0.00360414f, -0.22820918f, 0.01659978f, 0.02610486f, -0.33177909f, -0.20861837f, 0.08147515f, -0.00706841f, 
    -0.15782344f, -0.00218868f, -0.14961392f, -0.08582123f, -0.10847549f, -0.18569866f, 0.03444454f, -0.07626470f, 
    0.03037855f, -0.01589968f, -0.00892019f, 0.09402920f, 0.08345040f, -0.03792567f, -0.05720301f, 0.01336837f, 
    0.12017071f, 0.15883149f, 0.09689328f, 0.19220285f, -0.29849184f, 0.09088120f, 0.12427193f, 0.01360937f, 
    -0.02918256f, 0.12837514f, -0.04723202f, 0.06080136f, -0.08681580f, -0.05351934f, 0.10939330f, 0.06836798f, 
    0.09159654f, 0.09786411f, 0.03021563f, 0.08192706f, 0.43592453f, 0.13606597f, 0.09395324f, 0.18401445f, 
    0.22947320f, -0.04182522f, 0.01083129f, 0.06530904f, -0.02554029f, 0.06201592f, -0.00817524f, 0.12917408f, 
    0.03365693f, 0.00595177f, 0.05607847f, -0.12984528f, 0.03652444f, 0.15065441f, 0.13360608f, 0.06522322f, 
    0.54014915f, -0.00269804f, -0.03164755f, -0.13313015f, -0.12272817f, -0.12568437f, 0.15854003f, -0.08194401f, 
    0.10828958f, -0.08435831f, 0.02736427f, -0.02653710f, -0.11527573f, 0.04274904f, -0.09819277f, 0.04782856f, 
    0.07013554f, 0.01324382f, -0.07481816f, 0.16740124f, 0.46412027f, -0.20006737f, -0.01459277f, 0.24845879f, 
    -0.05788516f, -0.11631294f, -0.01917068f, -0.09257628f, 0.03803818f, 0.13485460f, 0.05723864f, -0.03824221f, 
    -0.12881674f, 0.04341888f, -0.04160521f, 0.07173350f, -0.14417133f, 0.05630203f, -0.05809491f, 0.03405319f, 
    -0.20519927f, 0.34092009f, -0.05568666f, -0.16003971f, 0.15293820f, 0.10704847f, -0.02440106f, -0.03244146f, 
    -0.02320134f, 0.04030831f, 0.02935741f, 0.01524086f, -0.05630646f, 0.13298936f, -0.08670161f, -0.04435583f, 
    0.11223304f, 0.09050097f, -0.06303201f, -0.00587824f, -0.08162036f, -0.03578070f, 0.01368660f, 0.10279889f, 
    0.23140112f, -0.04660320f, -0.12670338f, -0.04682348f, 0.12341852f, -0.13639131f, -0.06144813f, 0.05845622f, 
    0.09928998f, -0.00244648f, -0.03581528f, 0.05243969f, 0.09893933f, 0.05113695f, -0.04489090f, -0.04393905f, 
    -0.01713649f, -0.40244403f, 0.10410612f, -0.17547731f, 0.40648875f, -0.22255704f, -0.06050470f, 0.05610596f, 
    0.20323114f, -0.04442210f, 0.00026813f, 0.09599467f, -0.07534674f, -0.03232613f, 0.02671655f, 0.04244481f, 
    -0.08909515f, 0.08857675f, 0.15161175f, -0.04678233f, 0.59362137f, 0.02407291f, -0.04866284f, -0.05982949f, 
    -0.08014494f, 0.02586744f, -0.01502911f, -0.05123864f, 0.06286996f, 0.04075032f, 0.09277503f, 0.16425592f, 
    -0.00189194f, -0.00697216f, 0.08414649f, 0.00052722f, 0.06336944f, -0.02755319f, -0.08943504f, 0.02026763f, 
    0.34744543f, -0.21517280f, 0.01220710f, -0.13235120f, -0.16010694f, -0.14939921f, 0.13545072f, -0.01624700f, 
    0.11867907f, 0.05052403f, 0.04979009f, 0.02517488f, -0.00728919f, 0.11427242f, -0.04175567f, 0.03753222f, 
    -0.09697122f, -0.03083916f, -0.06615803f, 0.19321854f, 0.09948288f, -0.01240747f, -0.00687808f, 0.07051369f, 
    -0.47342861f, -0.13028716f, -0.03973992f, 0.03218101f, -0.10527123f, -0.00360971f, -0.03935589f, -0.02834714f, 
    -0.07664956f, 0.04510166f, -0.07169332f, 0.12958740f, -0.08936268f, -0.03237670f, 0.03159515f, -0.07846596f, 
    -0.29552758f, 0.29064894f, -0.06550358f, -0.16253854f, 0.06910154f, 0.14408852f, -0.12797022f, 0.16557600f, 
    -0.08176049f, 0.09540102f, -0.01936246f, 0.13422927f, 0.05824633f, -0.06198556f, -0.05686651f, 0.06084335f, 
    -0.02856751f, 0.02637407f, -0.09725338f, 0.01247365f, 0.05039386f, -0.23187822f, 0.18511316f, -0.04588960f, 
    -0.16680269f, 0.01170861f, 0.15098108f, 0.11511393f, 0.05653204f, 0.10293555f, -0.03064165f, 0.02378025f, 
    -0.04788690f, 0.04545162f, 0.02538254f, 0.01935878f, 0.09371397f, -0.07770665f, -0.06344850f, -0.08992486f, 
    0.14185381f, -0.22656614f, -0.00332121f, 0.01766101f, -0.24337165f, 0.05775679f, 0.16105576f, -0.00820975f, 
    0.07865015f, -0.00120952f, -0.07828180f, 0.00816701f, -0.02587907f, -0.00459718f, -0.03406217f, 0.06998950f, 
    0.15889028f, -0.00560178f, 0.12618296f, -0.04503761f, -0.10180658f, -0.00770115f, 0.10045468f, 0.02122649f, 
    0.12548992f, -0.11681307f, -0.00156357f, -0.01475659f, -0.08661634f, -0.07565593f, 0.04823609f, -0.11650715f, 
    0.02737684f, -0.04737222f, 0.12167464f, 0.10039128f, -0.10041511f, 0.16495113f, -0.01600352f, 0.09326302f, 
    -0.28543106f, -0.08017956f, 0.18959898f, -0.22495058f, 0.32175976f, 0.08009876f, -0.04490721f, 0.06872419f, 
    -0.01106483f, 0.10698390f, -0.03575411f, 0.02659112f, -0.00791836f, -0.16512759f, 0.06098650f, -0.11238354f, 
    -0.12893476f, -0.05412560f, 0.06905540f, -0.13991849f, 0.02032097f, 0.11047237f, 0.08701497f, -0.20750354f, 
    0.21868327f, 0.07941978f, -0.02464064f, 0.04405913f, -0.00725461f, -0.03326646f, 0.03464419f, -0.13072819f, 
    -0.04156912f, -0.07139866f, -0.02365838f, 0.04134120f, -0.09139138f, 0.05488830f, -0.15217495f, 0.05835048f, 
    0.04026641f, -0.02210828f, -0.00263395f, -0.01417434f, 0.01530752f, -0.00819174f, 0.01682820f, -0.06411926f, 
    -0.03369735f, 0.03649512f, -0.02290898f, 0.04126155f, -0.05737852f, -0.03796094f, 0.02958116f, -0.04491816f, 
    -0.01405441f, -0.02547746f, 0.02002517f, 0.00387112f, -0.03188100f, 0.01293188f, 0.00435296f, -0.02458727f, 
    -0.02562328f, -0.03934606f, 0.03257319f, -0.01845898f, -0.01128670f, 0.03942950f, -0.00914531f, 0.02721799f, 
    -0.05135480f, 0.02739249f, 0.04298226f, 0.02734471f, -0.05207963f, -0.05044128f, 0.04267185f, -0.01004282f, 
    0.01500580f, 0.03754681f, 0.03993264f, -0.04035436f, -0.02271109f, -0.06243950f, -0.00940764f, -0.01639442f, 
    -0.04466496f, -0.03474459f, 0.02451882f, 0.03432636f, -0.04346601f, -0.05418548f, 0.03545303f, 0.01957284f, 
    0.04601130f, 0.00848206f, -0.04055572f, 0.04028368f, -0.02206504f, -0.03661381f, 0.05002247f, -0.02105401f, 
    -0.01247126f, -0.04615154f, 0.01796412f, -0.02483901f, -0.03577258f, -0.03933426f, -0.03757518f, -0.00237720f, 
    -0.05010647f, -0.06132064f, 0.00700288f, -0.04747712f, -0.03291431f, -0.03442029f, 0.04019251f, -0.00751223f, 
    -0.01055810f, 0.03166513f, -0.04556710f, -0.02158776f, -0.00157772f, -0.02420856f, -0.02279805f, 0.01820764f, 
    0.00039444f, -0.04137642f, 0.02941585f, -0.04676320f, 0.03446977f, -0.05730335f, -0.04367281f, -0.04540347f, 
    0.04010156f, -0.00117693f, -0.04319487f, -0.03286263f, -0.05992338f, -0.03110775f, 0.02217621f, 0.03116402f, 
    0.04317897f, 0.00500501f, -0.01421611f, 0.01239706f, 0.05028413f, 0.03395061f, -0.01637938f, 0.01247735f, 
    0.00124902f, 0.03158072f, 0.01511804f, -0.01105454f, -0.02805230f, -0.00052909f, 0.00905207f, 0.05124810f, 
    -0.01017443f, 0.04210717f, -0.01492884f, -0.01113826f, -0.04206089f, 0.00180319f, -0.02426835f, -0.03559132f, 
    -0.04486996f, 0.00922237f, 0.03241070f, -0.00430305f, 0.02795232f, -0.00011702f, 0.00658549f, -0.02952208f, 
    -0.00315853f, -0.02586781f, 0.01179002f, 0.01959163f, -0.02020626f, 0.00784234f, -0.03958174f, 0.01331472f, 
    -0.04243828f, 0.00384272f, 0.00101875f, -0.00165241f, 0.02104428f, 0.03087850f, -0.02235496f, 0.04004703f, 
    0.02839196f, 0.02843128f, -0.00348499f, 0.04941913f, -0.04200681f, 0.04659255f, -0.00672112f, 0.02037898f, 
    0.01346855f, 0.01665365f, -0.05444733f, 0.01512782f, -0.03191757f, -0.01337759f, -0.04153989f, -0.03509185f, 
    0.04194742f, -0.01674833f, -0.01126949f, -0.01655416f, 0.01701800f, -0.06377485f, 0.05325216f, -0.00682698f, 
    -0.04237101f, -0.04528749f, -0.04109873f, 0.00044522f, 0.02081245f, 0.01164506f, -0.06036192f, -0.02392334f, 
    0.02728074f, -0.00499502f, 0.00556071f, 0.05129959f, 0.04195613f, -0.02876889f, 0.00173667f, 0.02606411f, 
    0.02238115f, 0.00848772f, -0.01883776f, 0.02390855f, 0.01660303f, -0.04466583f, -0.00208907f, -0.00737922f, 
    -0.01017754f, -0.03180603f, -0.00962504f, -0.04375976f, -0.01657768f, 0.04234016f, -0.04992083f, 0.04705177f, 
    0.04565013f, -0.00303259f, -0.02346776f, -0.02565756f, -0.00145639f, -0.03436413f, 0.05686801f, -0.05678440f, 
    0.02779943f, 0.00308224f, -0.00066308f, 0.03511152f, -0.04450673f, -0.03951675f, -0.05375601f, -0.05419982f, 
    -0.00138412f, -0.00555679f, -0.02580066f, -0.02516130f, -0.01221424f, 0.02972019f, 0.00871167f, -0.04017085f, 
    0.02828534f, -0.00557942f, -0.02502360f, -0.00137433f, 0.01487337f, 0.01007726f, -0.02126614f, -0.01309216f, 
    0.03370529f, 0.03946384f, 0.00630782f, -0.06066431f, -0.00637353f, -0.04018782f, -0.01051652f, -0.01180205f, 
    0.00117156f, -0.03866963f, -0.04211664f, -0.03731829f, -0.00375251f, -0.02334803f, -0.03271419f, -0.00523018f, 
    -0.02584955f, -0.03269541f, -0.06510677f, -0.02024806f, -0.03007480f, 0.05707588f, -0.01346833f, -0.04953302f, 
    0.01910955f, -0.06099151f, -0.01143169f, 0.03842235f, -0.03959436f, 0.01046572f, -0.03894153f, 0.02659417f, 
    0.00916812f, -0.04149249f, -0.01153403f, -0.00990383f, 0.03259517f, 0.01611839f, -0.05488893f, -0.03895901f, 
    -0.04728209f, -0.03745782f, -0.04632679f, -0.02581001f, 0.03643560f, 0.04510044f, -0.05737161f, 0.00171203f, 
    0.00262078f, 0.04858999f, 0.03077440f, 0.01565718f, 0.05208184f, -0.05785732f, 0.01684221f, 0.02933925f, 
    -0.02053157f, -0.01724106f, 0.04674839f, 0.04273062f, 0.01390024f, -0.05277150f, 0.02243258f, 0.05394607f, 
    0.00206737f, -0.03957897f, 0.03080426f, 0.01044528f, -0.03865141f, -0.04847878f, -0.00097625f, -0.01872824f, 
    0.01583699f, 0.01374812f, 0.01126477f, 0.03200298f, -0.03754007f, -0.05686352f, -0.00741476f, -0.03454978f, 
    0.02307676f, 0.02634553f, -0.00714303f, -0.05355787f, 0.04680206f, -0.04896101f, -0.04265305f, -0.00986313f, 
    -0.03586891f, 0.04723018f, -0.01238499f, 0.04286384f, -0.01560637f, -0.05897668f, 0.02344035f, 0.00333953f, 
    0.04328859f, 0.00745760f, 0.01824197f, -0.00103135f, 0.03346841f, 0.04961178f, 0.00703375f, 0.01671499f, 
    -0.00419855f, 0.01391226f, -0.02160506f, -0.02804305f, -0.00378605f, 0.02907504f, 0.00401410f, 0.04127935f, 
    0.04129602f, 0.04398115f, -0.03490800f, 0.04928922f, 0.00214960f, -0.06051799f, -0.01780251f, -0.01621622f, 
    -0.02836226f, 0.02667473f, -0.02907305f, 0.03292155f, 0.01710194f, 0.03351755f, -0.05601352f, -0.03723178f, 
    -0.00556079f, -0.05013575f, 0.03407511f, -0.01356886f, 0.01012534f, -0.02423905f, -0.03291892f, -0.01624095f, 
    -0.01695099f, -0.02919799f, -0.03598762f, -0.06087887f, 0.03017719f, -0.04547566f, -0.01723584f, -0.00446389f, 
    0.02837073f, -0.00050495f, 0.02537694f, -0.02254854f, -0.00409255f, 0.02538488f, -0.00171032f, -0.02441668f, 
    -0.04435654f, -0.06139111f, 0.02203063f, -0.02930845f, -0.03802220f, -0.05531706f, -0.02349598f, -0.04566459f, 
    -0.00710883f, 0.03046779f, -0.03787920f, -0.05677558f, 0.03367044f, -0.03663285f, 0.04963394f, -0.02066052f, 
    -0.03419375f, -0.00004083f, 0.00080919f, -0.02407892f, -0.04075154f, 0.03879445f, -0.05270723f, 0.04727804f, 
    -0.05033558f, 0.00893018f, 0.02102241f, -0.03547242f, 0.03548892f, 0.01066589f, -0.05103219f, -0.01411059f, 
    -0.01930718f, 0.02380942f, 0.00963906f, -0.04194690f, -0.01860698f, 0.00841438f, -0.04057611f, -0.01541271f, 
    0.03629099f, 0.00529421f, 0.03363529f, 0.04567115f, -0.00662270f, 0.01299941f, 0.00411718f, 0.00553017f, 
    0.03454711f, -0.01093185f, -0.01317316f, -0.02892746f, 0.04429191f, -0.05074811f, -0.00209214f, -0.01682745f, 
    -0.04351328f, 0.02604826f, -0.00117174f, 0.03061442f, -0.06180398f, 0.04425035f, 0.01717921f, -0.05616081f, 
    -0.01956610f, 0.02849794f, 0.04328326f, 0.04944517f, 0.04440087f, 0.01127839f, 0.04937034f, -0.01971895f, 
    -0.03466416f, -0.02832577f, 0.03445106f, 0.03373132f, -0.01783149f, 0.04905761f, -0.04845261f, -0.03794961f, 
    -0.02962282f, -0.03867725f, 0.04779694f, -0.04659432f, 0.04354301f, 0.03983015f, 0.01478878f, -0.05427574f, 
    -0.01026077f, -0.04982457f, -0.02547419f, 0.02680036f, 0.00921355f, -0.02117532f, 0.04751850f, -0.01088271f, 
    -0.03765263f, -0.02875850f, -0.00064543f, 0.02375815f, 0.02054179f, -0.00864597f, -0.02975480f, -0.03206560f, 
    -0.04713199f, 0.00486150f, -0.04041912f, -0.00181125f, -0.04917272f, 0.03061010f, -0.05313626f, -0.02357400f, 
    0.03036625f, -0.06189026f, -0.03154656f, -0.00354230f, -0.02927942f, -0.05913989f, -0.00511212f, -0.03455718f, 
    0.00903498f, -0.03491960f, -0.00438878f, -0.04323026f, 0.03189863f, -0.03402709f, -0.05564350f, -0.00566700f, 
    -0.06019865f, -0.02039671f, -0.01298632f, -0.04098161f, -0.01801331f, -0.03169470f, 0.01899827f, 0.03989947f, 
    -0.02914975f, 0.02568088f, 0.03918613f, 0.04776546f, -0.03399625f, -0.03203826f, 0.01765448f, -0.04645231f, 
    -0.01057911f, 0.01237958f, -0.01898454f, 0.00080530f, 0.03841157f, -0.03587484f, -0.01948139f, -0.00774644f, 
    -0.02765878f, -0.03008729f, -0.05608018f, -0.00760625f, -0.01442225f, 0.03554451f, -0.00011584f, 0.01068059f, 
    -0.01441456f, -0.03945477f, -0.04300048f, -0.02385056f, 0.02738566f, 0.01599943f, -0.05960176f, 0.00039430f, 
    0.00072936f, -0.02907137f, 0.01016754f, 0.02294794f, -0.06028162f, -0.01889909f, 0.03903905f, -0.03683541f, 
    -0.01539994f, -0.00627574f, 0.01170528f, -0.01015440f, -0.05008694f, 0.01731129f, -0.00352336f, -0.03976185f, 
    -0.04554626f, -0.03650687f, -0.03338982f, -0.05977721f, -0.04377476f, -0.00042240f, 0.00404051f, 0.01090811f, 
    -0.05617176f, 0.03965794f, -0.03991943f, 0.00430778f, -0.01420880f, 0.03145378f, -0.01310959f, 0.02756215f, 
    -0.02301799f, -0.04362879f, 0.02243023f, -0.05056611f, 0.01615195f, -0.02163755f, -0.01436755f, -0.01092693f, 
    0.00902158f, -0.02232196f, -0.01939372f, 0.01806148f, -0.02394861f, -0.05567498f, -0.00081074f, -0.04625830f, 
    0.03603385f, -0.00399933f, 0.04092891f, 0.03738180f, -0.02391031f, 0.00784444f, -0.02476994f, -0.00378813f, 
    0.04867224f, -0.02134822f, -0.03662057f, -0.03816179f, -0.01105632f, 0.04087710f, 0.01352340f, 0.04315613f, 
    -0.01626579f, 0.03114203f, -0.02236990f, 0.01640854f, 0.04434527f, -0.03392091f, 0.01986154f, 0.02250438f, 
    -0.03925584f, -0.05468966f, -0.05780604f, -0.01267680f, -0.03067999f, 0.02280600f, -0.04768779f, -0.01734990f, 
    -0.00745005f, 0.01266831f, 0.03098549f, 0.02155154f, -0.01168458f, 0.04424192f, 0.01973408f, -0.06075200f, 
    0.02510725f, -0.05487134f, -0.05165372f, -0.06234926f, -0.05926593f, 0.01043920f, -0.05347348f, 0.03141763f, 
    -0.06295735f, -0.05931686f, -0.03897377f, -0.03418850f, -0.02479034f, 0.02259125f, 0.03142134f, 0.00842199f, 
    0.01209066f, -0.01330507f, -0.01119376f, 0.00889836f, 0.01750225f, -0.03697628f, 0.00219427f, 0.00312679f, 
    -0.04218611f, 0.03367494f, -0.05734549f, 0.02464681f, 0.03571693f, 0.03046292f, 0.02996521f, -0.06494967f, 
    0.02180614f, -0.02990620f, -0.03695424f, -0.04994317f, -0.05336029f, 0.02221579f, 0.04512072f, 0.00280461f, 
    -0.04343057f, -0.00835354f, 0.02548620f, 0.04266467f, -0.03452027f, 0.02895144f, -0.06261154f, -0.05239675f, 
    -0.04090678f, -0.05434043f, -0.01323083f, -0.00577575f, -0.00671404f, 0.01561087f, -0.04738725f, -0.03732470f, 
    0.03957247f, 0.01335273f, 0.01935030f, -0.04872103f, -0.06362889f, -0.04830386f, 0.00544644f, 0.01953457f, 
    -0.00925064f, 0.00826644f, -0.01510417f, -0.00051133f, 0.03386586f, -0.05731437f, 0.03671562f, -0.01596410f, 
    0.01968642f, -0.05691021f, 0.00623197f, 0.04539313f, 0.04449183f, -0.00722605f, -0.00218860f, -0.05300959f, 
    0.00329152f, -0.05409911f, -0.05433178f, 0.04528109f, -0.02645252f, -0.05113286f, -0.05967971f, -0.02943250f, 
    -0.02265812f, -0.01090489f, -0.02278460f, -0.04626784f, -0.05209848f, 0.03011768f, 0.01696816f, -0.06196139f, 
    -0.03022200f, -0.05469284f, -0.01308537f, -0.02137598f, -0.00348559f, -0.04466285f, 0.01403438f, -0.01260617f, 
    0.02462123f, -0.00595109f, -0.02750598f, 0.02963860f, 0.01383161f, -0.03667457f, -0.03776790f, -0.02177592f, 
    0.01147912f, -0.02779702f, 0.04367319f, 0.00455086f, -0.01218341f, 0.01059145f, -0.01004905f, -0.04287689f, 
    -0.01562305f, -0.04821039f, 0.03512871f, -0.01468700f, -0.01390463f, 0.03040448f, 0.02694599f, -0.02096998f, 
    -0.01978625f, -0.03122162f, 0.02254912f, 0.02278611f, 0.03099753f, -0.05286648f, 0.02753815f, -0.03846313f, 
    -0.00073621f, -0.06144363f, 0.02310038f, -0.02108075f, -0.01403993f, 0.00444877f, 0.03668089f, -0.00299932f, 
    -0.06423318f, -0.02246461f, -0.01799420f, -0.00131736f, 0.01733725f, -0.02894219f, 0.03926810f, 0.00879286f, 
    0.04500415f, 0.04384923f, -0.00926215f, 0.01985330f, 0.03662086f, -0.00558706f, -0.05782092f, 0.04295696f, 
    -0.01899938f, 0.03502937f, 0.01553353f, -0.01575959f, -0.02241744f, -0.02175711f, -0.00783811f, 0.03516077f, 
    -0.06442763f, -0.02695198f, -0.02260408f, 0.04481551f, -0.05214025f, -0.03087577f, -0.04267609f, 0.01009448f, 
    0.02139436f, -0.03468065f, 0.01592441f, 0.04112467f, -0.00791724f, 0.00331773f, 0.01339054f, -0.06361006f, 
    0.03183611f, -0.01402716f, -0.00747770f, -0.00427869f, -0.01447838f, 0.01014228f, -0.05207342f, -0.05667793f, 
    0.00977199f, -0.02583874f, -0.01286800f, 0.02300574f, 0.04285775f, -0.04987770f, -0.02896322f, 0.02576804f, 
    0.02221235f, 0.03791117f, 0.04442220f, -0.01099751f, 0.00133529f, 0.01411851f, 0.03801804f, -0.01665742f, 
    -0.04681757f, -0.01243328f, 0.00945177f, -0.01534161f, -0.01344941f, -0.03098164f, -0.05854673f, -0.02819223f, 
    -0.02147284f, -0.04202344f, 0.03203306f, -0.03928453f, 0.00122277f, -0.00282772f, -0.06373385f, -0.04731075f, 
    0.03171325f, -0.01298909f, 0.01479177f, -0.01885407f, 0.00638466f, -0.03791582f, 0.03842377f, 0.03949103f, 
    -0.03875111f, -0.04050302f, -0.02096969f, -0.04138650f, -0.04058679f, -0.06391513f, 0.03493986f, -0.03579829f, 
    0.01044051f, 0.03064250f, 0.02040492f, 0.03987322f, 0.03170872f, -0.03587088f, 0.01817692f, -0.03862016f, 
    -0.03905898f, -0.01845014f, 0.02769710f, -0.03112340f, 0.01420446f, -0.04025510f, -0.02669806f, -0.06152701f, 
    0.01506423f, 0.01903919f, 0.03066337f, 0.03184292f, -0.03392849f, -0.00156128f, -0.00173735f, -0.03545675f, 
    -0.02687002f, -0.02252238f, -0.03298644f, -0.04608304f, -0.00879775f, 0.02888424f, -0.04573606f, -0.00078367f, 
    -0.02770612f, 0.00779381f, 0.04377051f, 0.01109115f, -0.00018636f, -0.04578023f, 0.01179674f, 0.04455914f, 
    -0.00064685f, 0.01623352f, 0.01672501f, 0.01165030f, 0.03433486f, -0.02226900f, -0.04841483f, -0.04317595f, 
    -0.00613167f, 0.02348130f, 0.00697112f, -0.01645013f, 0.00276543f, 0.03815129f, 0.04028552f, -0.01021349f, 
    -0.02428799f, -0.02948377f, -0.05781556f, 0.04278734f, -0.06000303f, -0.03667840f, -0.00092164f, 0.00689887f, 
    -0.01045722f, 0.03623621f, 0.04128364f, -0.05317964f, -0.02757760f, 0.03983128f, -0.04502426f, -0.01316942f, 
    0.01350611f, -0.03351625f, -0.02692062f, -0.04646046f, -0.04603212f, -0.00928586f, -0.02320658f, -0.02634214f, 
    -0.03837143f, -0.00508729f, -0.03159809f, 0.03799123f, 0.03662742f, 0.01618150f, -0.03923117f, -0.05764570f, 
    0.04014393f, 0.05138632f, -0.04065990f, -0.05179654f, 0.01205141f, -0.00153554f, 0.02821909f, 0.03298265f, 
    0.03287336f, -0.05146442f, 0.02650101f, 0.03299637f, -0.04104826f, 0.00890702f, -0.01035721f, -0.01066467f, 
    -0.04784264f, 0.03245348f, -0.01509338f, 0.00440199f, 0.01675794f, 0.04420421f, -0.03458928f, 0.03916527f, 
    -0.04827636f, -0.02249516f, 0.04826896f, 0.02276814f, -0.05599482f, -0.04095428f, 0.00121957f, 0.03686884f, 
    0.02585952f, -0.04184955f, 0.02372910f, 0.03798847f, -0.00087966f, 0.01535726f, -0.02721092f, -0.05699844f, 
    -0.03813939f, 0.04832229f, -0.02486449f, -0.01942174f, -0.02131340f, -0.01725120f, -0.00629173f, 0.05478648f, 
    0.01535164f, -0.00428883f, -0.04658379f, -0.02520004f, -0.03337581f, 0.01802325f, 0.00403749f, -0.02936113f, 
    -0.01590658f, -0.00154010f, -0.04065363f, 0.02226433f, -0.04925827f, 0.04248068f, 0.02310826f, 0.04271182f, 
    -0.05238642f, -0.02251137f, 0.04934675f, 0.03218973f, -0.02840527f, -0.00326068f, -0.05411189f, -0.03020418f, 
    0.02414444f, -0.05914425f, 0.04223907f, -0.02971278f, -0.01377484f, 0.03215988f, 0.02176803f, -0.05273933f, 
    0.03021131f, 0.04371577f, -0.01148572f, 0.03446573f, -0.03159466f, 0.00603621f, 0.01512631f, 0.01607838f, 
    0.00212030f, -0.02555182f, -0.01911481f, -0.02752875f, 0.04984936f, -0.00818920f, -0.05618060f, -0.03212157f, 
    0.00817359f, -0.02509781f, 0.00418810f, -0.05446222f, -0.02502709f, 0.00795402f, 0.05466174f, 0.00143293f, 
    0.01160347f, 0.02725319f, -0.03594511f, -0.02175442f, 0.02603040f, -0.02948658f, -0.00887745f, -0.02737369f, 
    -0.05438140f, -0.05842126f, 0.01033723f, 0.02488180f, -0.05912279f, -0.04588936f, -0.01779968f, 0.03505450f, 
    0.01236809f, 0.02225808f, -0.01347998f, -0.05813746f, -0.03704339f, 0.00091218f, 0.01796869f, -0.02392325f, 
    0.04557950f, -0.02968074f, 0.00098800f, -0.05505590f, -0.04841340f, -0.04810116f, 0.01690472f, 0.05226776f, 
    -0.01618184f, -0.02251180f, -0.02010148f, -0.00958386f, -0.01160233f, -0.03756632f, 0.03073999f, -0.05221089f, 
    -0.03634791f, 0.00145717f, -0.00807913f, 0.01260906f, 0.03162864f, -0.01972696f, -0.00579518f, 0.04509437f, 
    -0.04010521f, -0.02334466f, -0.01705400f, -0.01477412f, 0.03174564f, 0.00186838f, -0.05493328f, -0.02731588f, 
    0.00826065f, 0.00342802f, -0.05222991f, 0.01888274f, 0.01136993f, -0.03865265f, -0.00319026f, 0.03642517f, 
    -0.00432001f, 0.04791028f, 0.05104410f, 0.02932527f, -0.02884345f, -0.01412491f, 0.02800144f, -0.01941915f, 
    0.01391995f, 0.00698523f, 0.03319868f, 0.00162510f, 0.05105044f, 0.00098273f, -0.05183058f, -0.03801342f, 
    0.04477325f, 0.00101652f, 0.00046862f, -0.04156168f, -0.03216206f, -0.04092889f, -0.01615266f, 0.00527198f, 
    -0.00845315f, -0.03055282f, 0.01483707f, -0.02883959f, 0.00820093f, 0.01448282f, 0.04214273f, -0.01582534f, 
    0.04535822f, -0.01773869f, -0.01053416f, 0.02793587f, -0.03544360f, -0.00454682f, -0.03963831f, -0.01217859f, 
    -0.04639068f, -0.03756906f, -0.00105289f, 0.05211724f, 0.03458697f, 0.02051975f, -0.03248554f, -0.02087971f, 
    0.01198589f, -0.02298530f, 0.00355182f, -0.05144978f, 0.00555864f, -0.00491783f, -0.03764888f, 0.02626342f, 
    -0.00395207f, 0.00246780f, -0.04132803f, 0.00973032f, -0.00725734f, 0.00126555f, -0.03382675f, -0.01799437f, 
    -0.04617227f, 0.00832743f, 0.03011636f, -0.00389546f, -0.04734128f, -0.00148879f, -0.03464625f, -0.01176626f, 
    0.04950534f, -0.00666046f, 0.01273583f, -0.02455182f, -0.01738510f, -0.02027986f, -0.05441443f, 0.04012920f, 
    -0.00889945f, 0.02666716f, 0.01893800f, 0.04913791f, 0.05297829f, 0.01651206f, -0.04974778f, 0.00256832f, 
    -0.04810906f, -0.05174777f, 0.01212340f, 0.01913065f, -0.01059991f, 0.02009990f, -0.05209420f, -0.02911453f, 
    0.01429563f, 0.03183568f, -0.02472664f, 0.05696157f, -0.04597113f, 0.02041271f, -0.04877491f, -0.00587646f, 
    0.03262891f, 0.00493185f, 0.02991701f, 0.01976449f, 0.00393665f, 0.00260184f, 0.03600930f, -0.04041065f, 
    0.04389026f, 0.04905657f, 0.03606606f, -0.02462683f, 0.00122743f, 0.02157422f, -0.05982376f, -0.04135523f, 
    0.04552857f, 0.04999967f, -0.00731624f, -0.03785240f, -0.04768299f, -0.04919266f, 0.01983111f, 0.04351892f, 
    0.04184136f, -0.05445286f, 0.01527722f, 0.04118539f, -0.02134404f, 0.03779395f, 0.00881197f, -0.04548242f, 
    0.21539621f, -0.06165361f, -0.00921342f, 0.16793674f, 0.09583545f, 0.08396903f, -0.01202021f, 0.04032001f, 
    -0.07993856f, 0.21130984f, -0.03403371f, 0.02263059f, 0.07067000f, 0.05572171f, 0.05030063f, 0.01451843f, 
    0.01732192f, 0.06769416f, -0.08355308f, 0.08134685f, 0.31326485f, -0.05477213f, -0.14835189f, 0.09799888f, 
    0.25040781f, 0.07465554f, -0.07656931f, 0.06768429f, -0.01213752f, 0.01153699f, 0.13343570f, 0.03785572f, 
    -0.01636212f, 0.05597381f, 0.01484970f, -0.13813739f, 0.14891750f, 0.17605886f, 0.08615815f, 0.02028981f, 
    0.36746180f, -0.15026040f, 0.23314165f, 0.09828535f, -0.04445776f, -0.14059725f, 0.07597769f, -0.06778356f, 
    0.06853623f, 0.01612143f, 0.03335950f, -0.06978094f, -0.09275763f, -0.00521767f, 0.01035717f, -0.02733675f, 
    0.03620218f, -0.03103474f, -0.06379894f, 0.01623285f, 0.31297892f, -0.01921430f, -0.04018652f, 0.22884461f, 
    0.07568485f, 0.11890672f, 0.10025319f, -0.11088110f, 0.01568186f, 0.17839442f, 0.04103227f, -0.07381804f, 
    0.03863054f, 0.04662431f, 0.01668206f, 0.14384872f, 0.07738264f, 0.10038981f, -0.06144003f, 0.02428630f, 
    0.21592927f, 0.03400579f, -0.13155249f, -0.08323516f, -0.24848741f, 0.17527361f, 0.05849612f, -0.05720318f, 
    -0.10806840f, 0.06038275f, 0.01621525f, 0.16466898f, 0.04959954f, 0.15320709f, -0.13639881f, 0.08412249f, 
    -0.00425245f, 0.09673954f, -0.13913226f, 0.02337641f, -0.42698812f, 0.11928414f, -0.12425429f, 0.14267068f, 
    -0.10086574f, 0.12242360f, 0.06726410f, 0.00661646f, -0.04921141f, -0.19452642f, 0.05584566f, -0.06117648f, 
    -0.17723624f, 0.10603368f, 0.03904394f, -0.02792947f, -0.07712837f, -0.00009673f, 0.00843840f, -0.11353618f, 
    -0.30700803f, -0.04496616f, -0.05509768f, 0.10863097f, -0.28322196f, 0.05299831f, 0.13571371f, -0.05029407f, 
    -0.08677945f, -0.07133198f, 0.10962091f, 0.00265110f, 0.06241807f, 0.08271913f, 0.12415596f, -0.00472187f, 
    -0.02929830f, 0.07351170f, 0.11764052f, 0.03484974f, 0.32375577f, -0.21493894f, -0.11147792f, 0.18615864f, 
    0.01305975f, -0.02182582f, 0.05523707f, -0.01459327f, 0.05085538f, 0.16671637f, 0.01254913f, 0.19542070f, 
    0.02730334f, 0.00391327f, 0.03886333f, -0.04210756f, 0.08767867f, 0.03020968f, 0.02938875f, 0.06284598f, 
    0.31506079f, -0.28493860f, 0.14621808f, -0.17038918f, 0.10888560f, -0.16662045f, -0.00383770f, -0.01112700f, 
    -0.04815982f, 0.05180198f, 0.03439574f, 0.01547603f, -0.00166516f, -0.14864859f, 0.06885272f, 0.00854418f, 
    0.02773714f, -0.06387910f, -0.04768525f, 0.21371353f, 0.06883460f, 0.11113703f, 0.11692641f, -0.23623838f, 
    -0.34536323f, 0.11754098f, -0.02231446f, 0.09780177f, -0.05611473f, -0.02071865f, -0.03382481f, 0.03605984f, 
    -0.00546366f, 0.15668099f, -0.05375414f, 0.05200849f, 0.00561884f, -0.00909550f, 0.04278634f, 0.08736835f, 
    -0.23950255f, -0.01770247f, -0.15905769f, -0.27189767f, 0.05978732f, 0.11875725f, -0.07578885f, 0.03548542f, 
    0.04343515f, 0.00753981f, 0.18997486f, -0.04016181f, 0.19896492f, -0.06944039f, -0.03618765f, -0.02439315f, 
    0.00016286f, -0.09206177f, -0.08979765f, 0.00959856f, 0.07251532f, 0.16217586f, 0.09575550f, -0.12947515f, 
    0.05769075f, 0.13624354f, 0.02160969f, 0.15503800f, -0.04523376f, 0.07155313f, -0.07385293f, -0.04661020f, 
    -0.02315870f, 0.06656073f, 0.17543402f, -0.06423209f, 0.09684300f, -0.08324827f, 0.05797217f, -0.03169354f, 
    0.01786107f, 0.27605689f, 0.03759395f, -0.32027891f, -0.03605076f, 0.05624744f, 0.14461133f, 0.10637591f, 
    0.08531625f, -0.04472083f, 0.00781332f, 0.10365860f, -0.07732723f, -0.06470633f, -0.06087403f, 0.11867580f, 
    0.01024181f, 0.05564279f, 0.16859023f, 0.14600801f, 0.18420169f, 0.00960670f, -0.15116614f, -0.13280530f, 
    0.09071804f, -0.00073137f, 0.10760958f, -0.03983860f, -0.08771317f, 0.03621096f, -0.04520847f, -0.01520514f, 
    -0.06215548f, -0.13686131f, -0.00191226f, 0.02852391f, 0.00711537f, 0.09170766f, 0.18043850f, 0.00969252f, 
    -0.31383768f, 0.02006356f, -0.12699266f, -0.11340740f, 0.01038690f, 0.11541445f, -0.04095518f, -0.17711799f, 
    -0.06594974f, -0.11002579f, 0.01580848f, 0.00729595f, 0.07543121f, -0.02299466f, -0.01732122f, 0.09822220f, 
    0.00812903f, -0.14741264f, -0.00373127f, -0.07582976f, 0.22924189f, -0.05931607f, -0.07161526f, -0.14056259f, 
    0.13827440f, 0.10492320f, 0.12470281f, -0.10375391f, -0.05650458f, 0.00990722f, -0.03764191f, 0.01655194f, 
    0.02016495f, 0.07417338f, 0.06876472f, 0.09106372f, -0.02191426f, 0.07547402f, -0.04096014f, -0.00256213f, 
    0.21305273f, 0.18937771f, 0.10096192f, -0.11787329f, 0.14084254f, -0.05742593f, -0.04296099f, -0.02688837f, 
    -0.02427375f, -0.10832824f, 0.07673462f, -0.02978307f, 0.01492998f, -0.00003741f, -0.01361094f, -0.00755471f, 
    0.00282414f, -0.03633035f, 0.03995565f, -0.02823422f, 0.33882377f, 0.29071504f, 0.05127793f, -0.12306236f, 
    -0.07881148f, -0.00961319f, -0.05437122f, 0.05359199f, 0.01807097f, -0.15584525f, 0.17014953f, 0.00417085f, 
    -0.06942361f, -0.03262459f, -0.05998404f, 0.06583204f, 0.06967293f, -0.08197270f, 0.06406245f, 0.07082940f, 
    -0.41814113f, 0.09744056f, 0.04321016f, 0.24687853f, 0.02133838f, 0.11111382f, -0.06090292f, 0.05035876f, 
    -0.01881295f, 0.20002377f, 0.03931338f, -0.02355555f, 0.10574938f, 0.00821293f, 0.05014181f, 0.04663412f, 
    -0.04056045f, 0.14976387f, -0.00711545f, 0.03783884f, -0.35560930f, -0.15809278f, 0.01398680f, -0.04586588f, 
    0.11546852f, 0.06228609f, -0.07571313f, 0.06533650f, -0.02260382f, 0.06553146f, 0.13585427f, 0.12596707f, 
    -0.14771640f, 0.12445264f, 0.01833322f, 0.04111715f, 0.03394257f, -0.05594130f, 0.07324309f, -0.01553270f, 
    0.09008174f, -0.26434454f, 0.20155749f, -0.06135177f, 0.48723501f, 0.03746161f, -0.01107692f, 0.08038137f, 
    0.03183571f, -0.12852620f, -0.05543063f, 0.00817095f, 0.00710299f, 0.01531382f, 0.15023257f, 0.02083153f, 
    -0.13720308f, 0.05196581f, 0.08199260f, 0.04593582f, 0.47167364f, -0.21690550f, 0.06249648f, -0.00945006f, 
    0.15337014f, 0.02662216f, 0.00013921f, 0.07434759f, 0.05902499f, -0.01839036f, -0.05226329f, 0.08706025f, 
    0.11960829f, -0.15910500f, 0.05058994f, -0.06410642f, -0.01606494f, 0.09877695f, -0.05023828f, 0.03444442f, 
    0.13033371f, 0.22263356f, 0.19745922f, -0.21435232f, 0.00728016f, -0.04341227f, -0.01052153f, 0.11995524f, 
    0.03837434f, 0.01248645f, -0.08343863f, -0.00059510f, 0.00785691f, 0.07007143f, 0.04022546f, 0.00453868f, 
    -0.04539533f, -0.02877413f, 0.01286752f, 0.04960665f, -0.25552183f, -0.15078534f, 0.00020347f, 0.03484227f, 
    0.10695372f, 0.01685887f, -0.11950982f, -0.02987650f, 0.10666363f, 0.06753469f, -0.02571246f, -0.01859213f, 
    -0.11715323f, 0.10305362f, -0.01823080f, -0.06651412f, -0.06059914f, -0.06923058f, 0.07921351f, -0.07816684f, 
    -0.22452706f, 0.26120353f, -0.03473010f, 0.30193955f, -0.13562582f, -0.00391017f, 0.05366915f, 0.00533158f, 
    0.19404055f, 0.11293361f, -0.01221248f, 0.00599039f, -0.03594435f, -0.06933067f, 0.10296798f, -0.00147055f, 
    0.03996437f, 0.08169061f, -0.02044433f, -0.09745590f, -0.04374380f, -0.26008603f, 0.08442093f, 0.12545313f, 
    -0.17561048f, 0.01609931f, -0.01762922f, 0.02977694f, -0.10338505f, -0.03817590f, 0.11403957f, 0.15641774f, 
    0.04881763f, -0.15479633f, -0.19225349f, 0.01107862f, 0.00938309f, -0.03659608f, -0.01435131f, -0.13050154f, 
    -0.13807459f, 0.14165916f, -0.01029254f, -0.25278714f, -0.14969802f, 0.02260660f, 0.01226371f, -0.00537910f, 
    -0.16587390f, -0.10131380f, -0.02251800f, -0.01485391f, -0.00906715f, -0.02918015f, 0.13190754f, -0.00641217f, 
    0.03630088f, 0.03628984f, -0.00924628f, -0.01808424f, -0.14579426f, -0.05429511f, 0.10873239f, 0.22670482f, 
    -0.34531146f, 0.02461808f, 0.17003731f, -0.06306773f, -0.02578263f, -0.02749295f, 0.03357570f, -0.02088976f, 
    0.03022169f, -0.07270586f, 0.02398616f, 0.04559940f, 0.00900290f, 0.05497344f, -0.07320040f, 0.03012891f, 
    0.05479599f, -0.13036413f, -0.00935916f, 0.08294284f, -0.09576065f, -0.00823828f, -0.00896653f, -0.08651342f, 
    -0.07501119f, -0.10042650f, -0.06624026f, 0.03508992f, 0.02076168f, 0.04236061f, -0.03872989f, 0.01288874f, 
    0.00160269f, -0.02714060f, -0.05979832f, -0.01080037f, 0.27096322f, 0.13524948f, -0.00475514f, 0.05267225f, 
    -0.15069057f, 0.09049886f, -0.01831261f, 0.05795329f, -0.10101623f, -0.12092391f, -0.12200247f, 0.08964016f, 
    0.12199593f, 0.20363134f, 0.00284803f, -0.04409235f, -0.05118367f, -0.07787150f, -0.05003160f, 0.05945590f, 
    0.07372450f, -0.22877055f, -0.03748503f, -0.26995018f, -0.03110620f, 0.02009802f, -0.00291834f, -0.03051109f, 
    -0.05713091f, -0.04907335f, 0.05144768f, -0.14928247f, 0.04407918f, -0.07719264f, -0.02404292f, -0.08718107f, 
    0.05529540f, 0.13076600f, -0.02181836f, 0.07948605f, -0.03473895f, -0.03453330f, 0.06304062f, -0.02656424f, 
    0.22051093f, -0.03290031f, 0.05625845f, -0.02707617f, 0.09345280f, -0.06345038f, 0.03215593f, 0.08282860f, 
    0.13038810f, 0.09646834f, -0.01964479f, -0.03079591f, 0.11791663f, -0.00941574f, 0.04666984f, 0.06651100f, 
    0.15120898f, -0.01403682f, -0.17350671f, 0.03058243f, -0.22133902f, 0.11474755f, 0.03015999f, 0.05069794f, 
    -0.12440362f, 0.11059196f, -0.08260087f, -0.04942630f, 0.01806749f, 0.06572378f, 0.06700718f, 0.02844789f, 
    0.08374618f, 0.06181493f, 0.03244177f, -0.01030452f, 0.60019696f, -0.05787149f, -0.04903711f, 0.24573909f, 
    0.08343729f, -0.00003167f, 0.05804734f, -0.05898364f, -0.06574652f, -0.11820048f, 0.12287242f, -0.03597649f, 
    -0.06892121f, 0.01793314f, -0.04620425f, -0.09528353f, -0.02868213f, 0.11594487f, 0.07907178f, 0.00700049f, 
    0.07831098f, -0.12346349f, -0.12134134f, -0.11080355f, -0.25876015f, 0.02963971f, 0.09242208f, -0.12519000f, 
    -0.00658263f, -0.04435596f, -0.06357505f, 0.02256453f, -0.12363520f, -0.04021401f, 0.03371223f, -0.02398823f, 
    -0.08393097f, -0.01779779f, -0.06690950f, 0.03731000f, 0.01220434f, -0.38763589f, -0.16502196f, 0.30311853f, 
    -0.02541747f, 0.05726822f, 0.03048437f, -0.09673267f, 0.01270470f, 0.12063411f, 0.04836519f, 0.02401927f, 
    -0.13039574f, -0.06555158f, -0.06184049f, 0.05064906f, -0.07521112f, -0.03534294f, -0.13653477f, 0.04005047f, 
    0.02327880f, -0.06671810f, 0.14876276f, -0.10508330f, -0.09306146f, 0.00003070f, -0.06421227f, -0.17605045f, 
    -0.12965302f, 0.02855354f, -0.12092043f, 0.11911937f, -0.05210829f, 0.05131668f, -0.18782136f, -0.03069795f, 
    -0.00841139f, 0.05199238f, -0.06632159f, -0.08018997f, -0.21184112f, 0.07120299f, 0.20381273f, 0.15773053f, 
    0.14059420f, -0.07639520f, -0.03262701f, -0.10965989f, -0.05158414f, -0.18129911f, 0.04223282f, -0.01013332f, 
    -0.06884722f, -0.05929388f, -0.09052537f, 0.09966610f, 0.03772505f, -0.05887387f, 0.02211834f, -0.09345733f, 
    -0.44123927f, 0.01446537f, 0.18977571f, 0.08237383f, 0.10152885f, -0.08162012f, 0.12772591f, -0.11971797f, 
    -0.02933398f, -0.09700526f, -0.01619909f, 0.12335782f, -0.06599249f, 0.02779916f, 0.08664306f, -0.02037270f, 
    -0.01976842f, 0.05685596f, 0.00807924f, -0.00734227f, 0.15968055f, -0.16278939f, -0.23136917f, -0.00388610f, 
    -0.10933821f, 0.05522250f, -0.02391603f, -0.17276549f, -0.03896536f, 0.18264249f, -0.00759715f, 0.13103242f, 
    -0.03126434f, -0.07633474f, -0.02122767f, -0.07122611f, 0.06179381f, -0.05318138f, -0.11965136f, -0.00511000f, 
    -0.17936610f, -0.16038632f, -0.17709841f, -0.18250673f, -0.02873462f, -0.10377570f, 0.01451337f, -0.06987861f, 
    0.03864109f, 0.05214376f, -0.07268551f, -0.04511354f, 0.09517610f, 0.01745202f, 0.00340112f, 0.03869693f, 
    -0.00640514f, -0.07521315f, -0.14923447f, 0.22009398f, 0.04469265f, 0.04715492f, -0.10711126f, -0.16482587f, 
    -0.46393096f, 0.05569274f, -0.03384773f, 0.06362397f, -0.04415061f, -0.03845408f, -0.01339552f, -0.00672771f, 
    -0.01248393f, 0.02855982f, -0.02647417f, 0.09017817f, -0.06456137f, -0.01285206f, -0.00341401f, 0.02518641f, 
    -0.27233580f, -0.00289451f, 0.12549509f, -0.32487488f, 0.03265703f, -0.10962667f, -0.14867567f, 0.01723371f, 
    -0.02025241f, 0.13693260f, 0.04129529f, -0.03862310f, 0.09549622f, -0.06333204f, 0.00650746f, -0.00465906f, 
    -0.06373380f, -0.12343257f, -0.03381502f, -0.04709293f, -0.12338184f, -0.13836768f, 0.07256325f, -0.02341683f, 
    -0.02083153f, 0.07159452f, 0.08412503f, 0.10461046f, -0.05615380f, -0.04778881f, -0.11763976f, 0.02398092f, 
    -0.00910197f, 0.17575179f, 0.19090742f, -0.01477015f, 0.02344244f, -0.07180868f, -0.09567156f, -0.06071170f, 
    -0.07580538f, 0.03980500f, -0.07714844f, -0.17970948f, 0.00406353f, 0.01351354f, 0.07614012f, 0.01790897f, 
    0.09731650f, -0.03030311f, -0.07208761f, -0.03727782f, -0.08563463f, 0.05685887f, -0.00811661f, 0.14429580f, 
    -0.00736511f, -0.02103156f, 0.10478491f, 0.04005631f, 0.11656595f, -0.01052960f, -0.17298895f, -0.03512738f, 
    -0.01862191f, -0.09389837f, -0.06469631f, -0.10977761f, -0.07621737f, -0.02724052f, -0.05263048f, -0.02285306f, 
    -0.04049326f, -0.08629410f, 0.03728102f, -0.04611801f, 0.02153070f, -0.00476146f, 0.01477166f, 0.04455495f, 
    -0.18185447f, -0.27540067f, 0.19240160f, -0.08888521f, 0.11826681f, -0.08382110f, -0.00133309f, -0.14466143f, 
    -0.04245595f, 0.07258126f, 0.00255627f, -0.13345183f, 0.02401567f, -0.07002193f, -0.01964804f, -0.07600074f, 
    -0.05184019f, -0.08404315f, 0.06736705f, -0.04004271f, 0.14814126f, -0.05367807f, 0.18753788f, -0.15790464f, 
    0.14014541f, -0.01257350f, -0.01138365f, -0.06157138f, -0.00900104f, -0.12950398f, -0.04660978f, -0.02690650f, 
    -0.04394565f, -0.04491284f, -0.01770882f, -0.04206771f, -0.07129031f, 0.04937194f, -0.03876784f, -0.01903728f, 
    0.06094623f, -0.00975829f, -0.02904278f, 0.02652206f, 0.02573304f, -0.00149355f, -0.02992536f, -0.03178826f, 
    -0.02093356f, -0.04190307f, 0.03539657f, -0.02982654f, 0.03401264f, -0.00355140f, -0.02020186f, 0.03424745f, 
    0.01855698f, 0.04253453f, 0.04460948f, -0.04937303f, -0.06016979f, 0.02009223f, -0.01326918f, -0.05752557f, 
    -0.05806438f, -0.04915113f, -0.04997224f, -0.03060837f, 0.01071187f, -0.04841528f, -0.03262427f, 0.03710179f, 
    -0.00549707f, 0.01120121f, 0.01645727f, -0.05775822f, -0.01953371f, -0.05555229f, 0.01028395f, -0.03543591f, 
    -0.04677326f, 0.01875129f, -0.05001343f, 0.02845834f, 0.00972791f, -0.04655550f, -0.03538748f, 0.04588098f, 
    -0.04827598f, -0.05147619f, -0.01044969f, 0.03463878f, -0.02109987f, -0.02573004f, -0.01611605f, 0.04785223f, 
    -0.04305870f, -0.03359851f, -0.00812993f, -0.01752593f, -0.05517763f, 0.05022854f, -0.03375035f, 0.02925638f, 
    0.05303307f, -0.04432828f, 0.04315267f, -0.06087588f, -0.02435667f, 0.00861762f, 0.02158705f, 0.04079592f, 
    -0.02886555f, -0.03373540f, 0.01684156f, 0.01979220f, -0.00324987f, -0.03846673f, 0.03331296f, 0.01130154f, 
    0.03679394f, 0.01426772f, -0.04938260f, -0.03139298f, 0.01553016f, -0.03715686f, -0.00684859f, -0.04754327f, 
    -0.02157142f, -0.00349454f, 0.02428397f, 0.05414470f, 0.00683338f, 0.04071581f, -0.00400992f, -0.01865072f, 
    -0.00742794f, -0.07192083f, 0.03103939f, -0.02851782f, -0.03288837f, 0.01038192f, 0.00526811f, -0.03015791f, 
    0.01999338f, 0.04152719f, -0.05265756f, -0.03236894f, -0.00675979f, 0.00144172f, 0.04466699f, -0.04888100f, 
    -0.00906688f, -0.01548918f, -0.06207806f, -0.01854803f, -0.02976788f, -0.07109599f, 0.04061089f, -0.02306096f, 
    0.00972145f, -0.05762006f, -0.00703189f, 0.03197225f, 0.03621798f, -0.04206257f, 0.03296157f, 0.04969218f, 
    -0.05493223f, -0.01584416f, 0.04377119f, -0.02252169f, -0.05149058f, -0.00180570f, -0.04918981f, -0.06531066f, 
    -0.05390202f, -0.06072279f, -0.02972230f, 0.02561535f, 0.00709116f, -0.03256155f, 0.02024715f, -0.00393461f, 
    0.05008341f, -0.01245431f, -0.01876666f, -0.04308375f, -0.01507152f, -0.03199895f, 0.02063225f, -0.01582533f, 
    0.05165147f, 0.01312154f, -0.00449538f, -0.04209174f, -0.00486461f, -0.05015727f, -0.04666398f, -0.04713818f, 
    0.03904310f, -0.02115367f, -0.03007276f, 0.04880710f, -0.05525753f, -0.00700588f, -0.04564856f, -0.03955545f, 
    -0.02835299f, -0.03570551f, 0.01066914f, 0.01294661f, -0.05624133f, 0.04284268f, -0.05420718f, 0.04146032f, 
    -0.04233381f, -0.04696851f, -0.01732402f, 0.02266247f, 0.03262375f, -0.02509438f, -0.03175207f, -0.03194792f, 
    -0.03328883f, -0.02707525f, -0.06130791f, -0.02402956f, -0.04039744f, -0.00021636f, 0.03917946f, 0.01026443f, 
    -0.03128560f, 0.03666752f, -0.00129037f, -0.04888405f, 0.00465545f, -0.00989699f, 0.00464916f, 0.04563675f, 
    -0.01758561f, 0.05378275f, 0.00866095f, -0.02830341f, 0.05548465f, -0.06321715f, 0.02328725f, -0.03413389f, 
    0.02619800f, -0.03716609f, -0.03694802f, 0.04101009f, -0.02435816f, 0.02555921f, -0.03385044f, -0.00638877f, 
    -0.03760419f, -0.03275637f, -0.02292954f, 0.03879731f, 0.04191689f, -0.01925138f, -0.00608785f, 0.01129457f, 
    0.00614299f, -0.02637818f, -0.04164805f, -0.03326057f, -0.01752106f, 0.04578346f, -0.03529058f, -0.03589738f, 
    -0.02789963f, 0.04367664f, 0.00117726f, 0.02611216f, 0.04423465f, -0.03226217f, 0.01692598f, -0.02897926f, 
    -0.01865751f, 0.03186869f, -0.03569369f, 0.01292854f, -0.01742636f, 0.00984391f, 0.00114047f, -0.01172852f, 
    -0.02162207f, 0.02564698f, -0.01859711f, 0.03549001f, 0.00823129f, -0.00942420f, -0.00743073f, 0.02736868f, 
    0.04536943f, 0.04600456f, -0.00131923f, -0.02802542f, -0.02541418f, -0.02255051f, -0.06613464f, 0.03097586f, 
    -0.04210952f, 0.02617992f, -0.04409743f, -0.04295776f, -0.04087280f, -0.01159996f, 0.01863099f, 0.05009399f, 
    -0.00189900f, -0.02546177f, -0.05551911f, -0.02786183f, -0.01756768f, 0.02802520f, -0.00013021f, 0.02000476f, 
    0.03072745f, 0.03435671f, -0.05311029f, -0.04739008f, -0.00197078f, 0.00147693f, 0.03171904f, -0.03446917f, 
    0.01828189f, -0.01968568f, 0.06784388f, -0.00481700f, -0.05111239f, -0.05366317f, -0.01406557f, 0.00339397f, 
    -0.05538946f, -0.01457264f, 0.04268206f, 0.02518052f, -0.00685581f, -0.00497333f, 0.02505923f, -0.03308406f, 
    -0.00774837f, 0.04999122f, 0.03486461f, 0.02280593f, -0.04864676f, 0.03794945f, -0.04689046f, -0.05604596f, 
    0.00733734f, -0.02960287f, -0.05537105f, 0.02275031f, 0.01234968f, -0.04767856f, 0.01517460f, 0.02938635f, 
    -0.21289773f, 0.27667606f, -0.09909716f, -0.04569040f, 0.31505901f, -0.02682146f, 0.07990320f, -0.01436663f, 
    0.06953631f, -0.12013216f, 0.03360274f, 0.00854973f, -0.09220332f, -0.11179025f, -0.03280501f, -0.02782394f, 
    -0.03565278f, -0.05694703f, -0.02234397f, -0.00593184f, -0.52642822f, 0.07281277f, 0.00556095f, -0.21597691f, 
    -0.19119443f, -0.01647661f, -0.07727372f, -0.05615000f, -0.07254749f, -0.07666977f, 0.01830761f, -0.06942929f, 
    -0.07354420f, 0.00253893f, -0.08459476f, -0.08633445f, 0.00147556f, -0.13552079f, -0.09623477f, 0.03567082f, 
    -0.10152598f, 0.16715790f, 0.24323486f, 0.11355813f, 0.16809243f, -0.04953786f, 0.06875817f, 0.08931198f, 
    0.16433455f, 0.07540350f, -0.03806795f, 0.05714110f, -0.00186024f, 0.02319295f, 0.04285086f, -0.04226978f, 
    -0.03954015f, -0.05353040f, 0.01051189f, -0.18466331f, 0.09807950f, 0.01445698f, 0.11519303f, -0.18585497f, 
    -0.03883856f, 0.05999757f, 0.00388051f, 0.06834628f, 0.00283433f, -0.02355828f, -0.03083527f, 0.08260762f, 
    -0.01627863f, -0.01087643f, -0.10056669f, -0.03259548f, 0.00334446f, 0.01821877f, 0.03341851f, -0.00002595f, 
    -0.10146165f, -0.25746790f, -0.00014668f, -0.12738156f, -0.28793529f, -0.14135934f, -0.00263693f, 0.08132374f, 
    -0.16294673f, -0.16222157f, 0.07334065f, -0.00815643f, -0.03013869f, 0.08367045f, 0.05871509f, 0.05998466f, 
    -0.00768920f, 0.03126950f, -0.09698743f, 0.08792926f, 0.12034780f, -0.16400503f, 0.03573568f, -0.21619640f, 
    -0.29069722f, 0.03952818f, -0.04088081f, 0.05111738f, -0.09346510f, 0.00921263f, -0.07862695f, -0.11083695f, 
    0.05265788f, -0.00920022f, 0.01252903f, -0.04982142f, 0.00669756f, 0.00971574f, -0.03519557f, 0.01657696f, 
    -0.31089965f, -0.09151917f, -0.07185157f, -0.30540627f, -0.22702077f, 0.13502723f, -0.01840008f, 0.14302205f, 
    -0.09390741f, -0.12241788f, 0.09090320f, -0.07282571f, 0.04919823f, -0.06314085f, -0.02611629f, -0.02773319f, 
    0.01152665f, -0.00263485f, 0.00533454f, -0.04709442f, -0.29825893f, 0.18815176f, 0.13517000f, -0.09315751f, 
    -0.04312092f, -0.02131294f, 0.06352989f, 0.09342603f, 0.14020588f, -0.08218025f, -0.04488341f, -0.05651747f, 
    0.07432920f, -0.03565725f, -0.15353346f, -0.04479413f, 0.05334391f, -0.00995515f, 0.03989064f, -0.03814499f, 
    0.34055892f, 0.13285971f, 0.11332293f, 0.15390792f, 0.17233463f, 0.03883846f, 0.23021013f, -0.05335685f, 
    0.15246005f, 0.02423899f, 0.06160576f, 0.04044915f, -0.09707052f, -0.04069905f, -0.11411118f, -0.10943443f, 
    0.12539768f, -0.07620057f, 0.02498923f, -0.15799095f, 0.14655441f, -0.08622736f, 0.16597916f, 0.12486587f, 
    0.18873526f, 0.05579761f, -0.01744981f, -0.05818295f, -0.02256307f, 0.00312920f, 0.00974500f, 0.01928700f, 
    0.12442664f, 0.06962112f, -0.03483688f, 0.00565611f, -0.04076770f, -0.03099499f, -0.04761369f, 0.05868880f, 
    -0.44268137f, -0.03854943f, -0.00000629f, 0.09359732f, -0.10232846f, -0.08181462f, -0.02941917f, -0.18167779f, 
    -0.06456509f, -0.03007741f, -0.12041439f, -0.00031070f, 0.00512363f, 0.01393818f, 0.13512042f, -0.01278436f, 
    0.02984783f, -0.01595929f, 0.02934870f, 0.01448825f, 0.09777848f, -0.06522109f, -0.09055430f, 0.19120358f, 
    -0.03897637f, 0.12249148f, 0.07610629f, -0.12008145f, 0.08915288f, 0.01159249f, 0.07234328f, 0.11233767f, 
    -0.02764191f, -0.04853585f, -0.05472888f, 0.04140946f, -0.03424318f, -0.13481505f, 0.08506947f, 0.03151806f, 
    0.25060865f, 0.10011078f, -0.04846615f, -0.03879973f, 0.10673176f, 0.03232049f, -0.06148126f, -0.08166929f, 
    -0.05970993f, 0.04006323f, -0.03505346f, 0.04661822f, 0.02976821f, -0.01644233f, 0.05266665f, -0.13510458f, 
    -0.03391140f, 0.03152162f, -0.02359128f, -0.00526178f, 0.09433612f, 0.09037310f, 0.09035151f, -0.10140300f, 
    -0.04517344f, 0.12391760f, 0.05886102f, 0.04617026f, -0.01661153f, -0.05269051f, -0.09732223f, -0.07733141f, 
    -0.14921311f, -0.00604262f, -0.02089370f, -0.16212721f, -0.05371777f, -0.03724545f, 0.06289291f, -0.03140047f, 
    -0.12177099f, -0.15345880f, 0.01431520f, 0.29659200f, -0.13593905f, 0.04367147f, -0.11606250f, 0.03934167f, 
    -0.08586764f, -0.15819749f, -0.03824914f, -0.07499236f, -0.03991273f, 0.07318722f, 0.11003987f, -0.04581419f, 
    -0.06542571f, -0.16006404f, -0.16401841f, -0.02614626f, -0.32120168f, -0.01162357f, -0.14854330f, -0.06652083f, 
    -0.20732972f, -0.05148847f, 0.09909175f, -0.06280628f, -0.16188733f, -0.05265534f, -0.06023500f, 0.00913915f, 
    -0.06121115f, 0.05951269f, 0.03645625f, -0.05272193f, -0.01156492f, 0.01176029f, 0.00104468f, -0.00791840f, 
    -0.27258739f, 0.27370819f, 0.31772238f, 0.08891682f, 0.03605589f, -0.12380689f, 0.16792975f, -0.11308976f, 
    0.14275165f, -0.07757453f, 0.04439691f, -0.06728801f, -0.00917504f, -0.07619151f, -0.00945925f, -0.03445724f, 
    -0.08618654f, 0.12781973f, -0.13134119f, -0.02480762f, -0.25292546f, -0.26497459f, 0.09806946f, -0.16128136f, 
    -0.13624927f, -0.01376733f, -0.01556003f, 0.01391142f, -0.06356002f, 0.16863789f, -0.00949874f, 0.10561113f, 
    0.08850640f, -0.08201199f, -0.12907103f, -0.10720243f, -0.04902116f, 0.16983160f, -0.02634078f, -0.00038774f, 
    0.64319491f, 0.03918748f, -0.01074879f, -0.03390268f, -0.21964778f, 0.02035095f, -0.02403452f, 0.08856984f, 
    0.00863620f, 0.03603548f, -0.05373487f, 0.05619062f, 0.06026126f, -0.01140988f, -0.09736345f, 0.06538729f, 
    0.19879222f, 0.01634648f, 0.06534294f, 0.06565446f, 0.03872252f, 0.38060337f, -0.12021605f, 0.08179881f, 
    0.06582310f, -0.09354823f, -0.05746467f, 0.05511731f, -0.00981901f, 0.06027532f, -0.00108992f, 0.00591294f, 
    0.02811846f, 0.07475241f, -0.00233430f, 0.15497895f, -0.02550837f, -0.02476063f, -0.02044898f, -0.10078916f, 
    0.15558207f, 0.15998355f, -0.37913224f, -0.03146577f, 0.23759022f, -0.07716325f, 0.03842255f, -0.01255286f, 
    0.06925050f, -0.03292438f, 0.05906675f, -0.02739454f, -0.06345364f, 0.06864206f, -0.03462982f, 0.07309899f, 
    0.07052283f, 0.00477550f, -0.12049127f, 0.04772886f, -0.01527529f, -0.04642712f, -0.21274126f, -0.15076992f, 
    0.16862439f, 0.04905640f, 0.06938704f, -0.07674181f, -0.01327367f, 0.04371802f, -0.08642296f, -0.06826496f, 
    -0.02152222f, 0.16213362f, -0.04257955f, -0.06374646f, 0.00394346f, 0.09690075f, -0.01600148f, 0.06309507f, 
    0.32619002f, -0.38385621f, -0.14740227f, -0.08976212f, 0.04632651f, -0.00462133f, -0.12715045f, 0.07765865f, 
    -0.06732094f, -0.09507530f, 0.02961768f, 0.08067568f, 0.01520009f, -0.02859248f, 0.06801450f, -0.11909495f, 
    0.00866346f, -0.10802640f, 0.09658317f, -0.05703624f, 0.42412981f, 0.24360979f, 0.00405326f, 0.13393387f, 
    -0.19217929f, 0.04417395f, 0.01623748f, 0.13578992f, 0.04378346f, -0.11186793f, -0.04423129f, 0.05456232f, 
    0.13176417f, -0.09120236f, 0.06304543f, 0.10464896f, 0.12110002f, 0.01820523f, 0.05963015f, -0.06133511f, 
    0.02106959f, 0.06480227f, 0.30839333f, -0.04079580f, -0.05985013f, -0.01171017f, -0.00796091f, -0.00710191f, 
    -0.00579213f, -0.09141879f, 0.00963636f, 0.10880940f, 0.01085249f, 0.00604806f, 0.04741609f, -0.06802940f, 
    -0.05952100f, 0.00612332f, 0.13451546f, -0.02693340f, -0.06251124f, 0.08408224f, 0.06256443f, 0.13634858f, 
    0.13860193f, 0.11700016f, -0.12239508f, 0.00295953f, 0.11074173f, -0.03157786f, -0.04543197f, -0.10766763f, 
    -0.08518130f, 0.02979349f, 0.06679288f, 0.03386730f, -0.00717020f, 0.01645556f, 0.03718983f, -0.09887157f, 
    0.08778193f, -0.23433089f, -0.21378431f, 0.22681758f, 0.19479965f, 0.18922856f, -0.03372796f, 0.00644860f, 
    0.00591681f, 0.01246223f, 0.11204953f, 0.06467901f, 0.00184909f, 0.13285688f, -0.06016685f, 0.05239863f, 
    0.06833403f, -0.00475220f, 0.04529727f, 0.13634886f, 0.32565168f, -0.01326584f, 0.16311453f, -0.06187281f, 
    0.02622200f, -0.00271186f, -0.05049780f, 0.09157977f, 0.15436795f, 0.05691219f, 0.02871267f, 0.01725317f, 
    -0.01863055f, -0.10577412f, -0.08759459f, 0.03857100f, -0.00589087f, -0.05100726f, -0.02200743f, 0.05826185f, 
    0.04079928f, -0.09000464f, 0.03511060f, -0.08190720f, 0.05667939f, 0.12587711f, -0.05004598f, 0.04554169f, 
    0.10327022f, -0.01524239f, -0.07987147f, 0.06664278f, 0.13679014f, -0.05245370f, 0.04615887f, 0.01188899f, 
    0.14080571f, 0.00126480f, 0.01314583f, -0.04616553f, -0.18022604f, -0.20081995f, 0.04083579f, -0.09024602f, 
    0.06819917f, 0.13416922f, 0.09697004f, -0.04290345f, 0.09324089f, 0.00112454f, 0.02963156f, -0.02492052f, 
    0.01929364f, -0.14189346f, 0.05499470f, 0.01785188f, -0.02923192f, 0.26501051f, -0.11902263f, 0.10976445f, 
    0.23719658f, 0.35047269f, -0.13594949f, -0.08347569f, 0.26875287f, 0.15103839f, -0.04187756f, -0.01972149f, 
    0.11096932f, 0.01758207f, 0.11311356f, 0.07118907f, 0.06601119f, 0.02347658f, 0.11924012f, 0.05466833f, 
    0.04727365f, -0.17718355f, -0.05149230f, -0.09165092f, -0.08908301f, -0.07047958f, -0.15214333f, -0.12790279f, 
    0.20931421f, 0.02543170f, 0.01584204f, -0.02181343f, -0.01525809f, 0.03281660f, -0.02395578f, -0.07712541f, 
    0.07972766f, 0.06681420f, -0.03246144f, 0.08295572f, 0.10680608f, -0.01288148f, 0.01045833f, 0.04906603f, 
    -0.01182034f, 0.01007469f, -0.04348405f, 0.03607872f, 0.04374368f, -0.00921858f, -0.05296226f, 0.00563634f, 
    -0.02954222f, 0.02278744f, 0.01995898f, -0.01299398f, -0.01325936f, 0.00365426f, -0.02303598f, 0.00683700f, 
    -0.03184639f, 0.00507995f, -0.04707428f, -0.06557049f, -0.01474075f, -0.02338667f, 0.01036710f, -0.02366079f, 
    -0.03172272f, -0.03258624f, 0.03133625f, -0.01612213f, 0.01633729f, 0.02553761f, 0.04242757f, -0.00029206f, 
    -0.01655952f, -0.02422398f, 0.04156418f, 0.04710994f, 0.01200791f, 0.01672243f, 0.03952821f, 0.03611545f, 
    0.04805615f, -0.00337470f, 0.04454073f, -0.02893317f, 0.02418447f, -0.05383685f, -0.00033254f, -0.04907204f, 
    -0.02036764f, 0.01075967f, -0.03041681f, -0.03716107f, -0.03572880f, 0.03901577f, 0.01566884f, -0.00324412f, 
    0.00517522f, -0.04923321f, -0.01025438f, -0.04196159f, 0.01691226f, -0.01168874f, -0.03464668f, 0.02027174f, 
    0.01227079f, 0.02954317f, 0.04086755f, -0.05899903f, 0.02163912f, 0.00343522f, -0.04025175f, 0.01861564f, 
    0.00269906f, 0.02776284f, 0.00697685f, 0.01945194f, 0.03151193f, -0.02239074f, 0.02269645f, -0.05990825f, 
    -0.00910633f, -0.05934067f, 0.02711652f, 0.01471157f, 0.04007301f, -0.03210976f, -0.02416867f, -0.02684496f, 
    0.01631860f, 0.00027300f, -0.01932069f, -0.02869655f, -0.05822729f, -0.00762796f, 0.00545797f, 0.03470683f, 
    -0.06064273f, 0.02138060f, -0.04840047f, -0.04161324f, -0.02123172f, -0.03933517f, -0.05844542f, 0.03925176f, 
    0.00815533f, -0.03812144f, 0.04542273f, -0.04924214f, -0.01669611f, 0.00603594f, 0.01667530f, 0.00854280f, 
    0.02686867f, -0.06335660f, 0.03987447f, -0.00496836f, 0.02544175f, 0.01055947f, -0.01239970f, -0.00050184f, 
    0.03347742f, -0.05318713f, -0.00823989f, 0.02256303f, 0.03457868f, 0.04238780f, 0.00457274f, -0.01629989f, 
    -0.00729960f, -0.05526443f, -0.00662424f, -0.04844791f, -0.01850121f, 0.03747264f, 0.03559321f, -0.02119143f, 
    0.02942933f, 0.02053453f, -0.04532599f, 0.03844838f, -0.03510471f, -0.02207372f, -0.05768895f, -0.06503924f, 
    -0.01378973f, 0.04523652f, -0.00238434f, -0.02818737f, 0.02020327f, -0.03744211f, -0.06188551f, -0.01257580f, 
    -0.02314732f, 0.01319596f, -0.03035734f, -0.02985012f, 0.01640690f, -0.02506120f, -0.00496961f, -0.02315508f, 
    0.00697823f, 0.01502902f, -0.04600882f, -0.00708839f, 0.05082289f, -0.04100766f, -0.01994346f, -0.01905353f, 
    0.04811277f, 0.00779146f, 0.00135540f, -0.05833713f, 0.03604062f, 0.00149539f, 0.00431607f, 0.00982803f, 
    0.03281116f, 0.00498237f, 0.01137063f, 0.04002691f, -0.03422891f, -0.01135417f, -0.03145982f, -0.02621751f, 
    0.02906696f, -0.04498769f, -0.05089154f, 0.04445161f, -0.03412219f, 0.03086080f, 0.02509583f, -0.04910066f, 
    -0.01882752f, 0.03188314f, -0.05334869f, -0.05210055f, -0.01241136f, -0.00257018f, 0.04034655f, -0.01258705f, 
    0.04732454f, -0.03669738f, -0.01957067f, 0.04033921f, -0.06088782f, 0.02692498f, -0.00485953f, 0.02086788f, 
    -0.05912328f, -0.01698010f, -0.04974436f, 0.04089874f, -0.05898713f, -0.01872945f, 0.00410837f, -0.04752855f, 
    0.02298580f, -0.00148100f, -0.01484338f, 0.01416937f, 0.03543177f, -0.01529770f, 0.02960001f, -0.05338644f, 
    0.02962711f, 0.03968192f, -0.00805237f, -0.01629282f, 0.03330953f, -0.02857809f, -0.03246509f, -0.02469036f, 
    -0.00996370f, -0.03049551f, -0.05449417f, -0.04794016f, -0.02457461f, 0.03789290f, -0.04667025f, 0.02164931f, 
    0.00376066f, 0.01144964f, -0.04254320f, -0.01428996f, -0.02058668f, 0.01037464f, 0.01707286f, -0.01412681f, 
    0.03017954f, -0.03453299f, -0.00366073f, -0.02789949f, 0.03156061f, 0.02585678f, -0.03678297f, 0.01243700f, 
    0.04261592f, -0.03090210f, 0.01482585f, 0.01455998f, 0.03700115f, -0.02553398f, -0.04135461f, 0.04051609f, 
    0.02631451f, 0.03657945f, 0.01577426f, 0.03074085f, 0.00418342f, -0.05126317f, -0.02201149f, -0.05321376f, 
    -0.01166701f, -0.03537479f, -0.00393305f, -0.05500967f, -0.05433274f, -0.05590452f, -0.02719412f, 0.00300911f, 
    0.03179215f, 0.00600602f, 0.02040888f, 0.03784533f, 0.01683736f, -0.05324879f, -0.05747461f, -0.04443388f, 
    0.02133211f, 0.03202087f, 0.01433430f, 0.00698689f, -0.01258738f, -0.03337379f, 0.00344654f, 0.05518068f, 
    0.01796954f, -0.01683564f, -0.05357208f, -0.05934121f, 0.02791352f, -0.03016875f, 0.03339338f, -0.05138626f, 
    0.02110507f, 0.00039293f, -0.00601106f, -0.01732760f, -0.00148755f, 0.02834249f, -0.06467422f, -0.00936264f, 
    0.02278259f, -0.00349639f, -0.04003895f, -0.04438432f, 0.03519051f, 0.00327109f, -0.00698371f, 0.00982411f, 
    -0.00919034f, 0.00020518f, 0.04839299f, -0.02169137f, 0.01988748f, 0.01912827f, -0.05752609f, -0.06169663f, 
    0.02248817f, -0.05287573f, -0.03307994f, 0.03777086f, -0.05715487f, 0.02196963f, -0.03711685f, 0.01742679f, 
    -0.04928198f, 0.00347776f, 0.00565168f, -0.02488719f, 0.00798556f, -0.05928840f, -0.00499442f, -0.00157829f, 
    -0.02037109f, -0.02565563f, -0.02156387f, -0.03660782f, -0.01271025f, 0.00004824f, 0.01748891f, 0.04910958f, 
    0.00425986f, 0.00314977f, 0.00381284f, -0.01424212f, 0.03503912f, -0.02388156f, 0.01320696f, -0.05061909f, 
    0.04396493f, 0.00725798f, -0.05725357f, -0.00534524f, 0.01905098f, -0.03336813f, 0.02432701f, -0.01183060f, 
    0.04528848f, -0.04668138f, 0.03878916f, 0.00069896f, 0.04636599f, 0.01508066f, -0.05699703f, -0.03278194f, 
    0.03454736f, 0.00165254f, -0.01002756f, 0.00490121f, -0.05969975f, -0.01472497f, -0.02916448f, -0.02970353f, 
    -0.02747537f, 0.00317310f, 0.01377084f, 0.00601380f, -0.03915909f, 0.01391869f, -0.00505210f, -0.00338821f, 
    0.00698994f, 0.00396294f, -0.05120712f, 0.01901845f, 0.00982210f, -0.00545498f, 0.04459885f, -0.05686935f, 
    -0.03078033f, 0.00088544f, 0.04404305f, 0.03448402f, -0.03061044f, -0.05013181f, 0.03513376f, 0.04304127f, 
    0.03133316f, -0.01048629f, 0.00653676f, -0.04011084f, 0.00922046f, -0.03642296f, -0.05940599f, -0.03368242f, 
    0.04796203f, 0.03122365f, -0.01584838f, -0.01787365f, 0.00603990f, -0.01630648f, 0.00635297f, -0.01770788f, 
    0.06810724f, -0.01245628f, -0.02359011f, -0.04919137f, -0.02775727f, -0.01626897f, 0.00997717f, -0.03635184f, 
    -0.01555929f, 0.03215101f, 0.00749448f, 0.02937664f, -0.00267677f, 0.00307365f, -0.00489626f, 0.01944846f, 
    -0.03881907f, 0.03529724f, 0.03194480f, 0.01416881f, 0.05097969f, -0.06182124f, 0.03290795f, 0.02587347f, 
    0.00593456f, -0.00457366f, -0.00925963f, 0.04728035f, -0.04577270f, -0.06093292f, -0.00406779f, -0.05733468f, 
    -0.01396405f, 0.04181655f, -0.06807716f, 0.05616226f, -0.06047729f, 0.00362086f, -0.03219377f, -0.01767727f, 
    -0.03702560f, -0.05135814f, -0.01234568f, -0.04680464f, -0.01512951f, 0.04080484f, -0.01144666f, -0.04332744f, 
    -0.01698476f, 0.03524629f, 0.02588051f, 0.01895636f, -0.01906027f, -0.05226183f, -0.06335238f, -0.04397558f, 
    0.03903273f, 0.02670273f, -0.00416129f, -0.02228576f, -0.00309464f, 0.00070132f, -0.04890143f, -0.02745029f, 
    0.01836822f, 0.03092175f, -0.02332333f, 0.01629989f, -0.04193165f, 0.03617432f, 0.01310543f, -0.04309916f, 
    0.02447717f, -0.01843839f, 0.01263629f, 0.04233488f, -0.02966098f, -0.03778614f, -0.01915959f, 0.01905907f, 
    -0.04723010f, 0.01776435f, -0.03448438f, -0.02659726f, 0.02639187f, 0.04819316f, 0.02559070f, 0.00421523f, 
    -0.05602307f, -0.01463227f, -0.03807084f, 0.02976362f, -0.00282853f, 0.00156206f, 0.03544202f, 0.03714841f, 
    -0.00256509f, -0.01628537f, 0.00311967f, 0.02344063f, 0.04059420f, -0.04616716f, 0.00344263f, 0.01381712f, 
    0.02653824f, 0.02310265f, -0.05724199f, -0.01503717f, 0.01090669f, 0.01894771f, 0.02411080f, -0.06105269f, 
    -0.00636224f, -0.00003586f, -0.04334023f, -0.06101481f, -0.00779307f, 0.01676390f, 0.01533113f, -0.05512084f, 
    0.03618074f, 0.01751105f, -0.05979011f, -0.04667951f, -0.00287729f, 0.04476166f, -0.03829153f, -0.01592983f, 
    -0.02488408f, 0.01678070f, -0.03504986f, 0.02184379f, -0.01805400f, 0.03259154f, 0.00309726f, -0.05643700f, 
    0.02362851f, -0.02592109f, -0.01569195f, -0.02152783f, -0.00969061f, 0.03796214f, -0.03704153f, 0.05285545f, 
    -0.00615470f, 0.03653021f, -0.02081671f, 0.03367993f, 0.02597723f, -0.03145462f, 0.01682482f, -0.00813711f, 
    -0.03176359f, 0.00206640f, 0.04088340f, 0.01637944f, 0.02052465f, -0.04003623f, -0.03942261f, -0.04194396f, 
    -0.01512725f, -0.04426334f, -0.00081016f, 0.00431456f, -0.00521601f, -0.05571244f, 0.00040930f, -0.01361737f, 
    -0.02146842f, 0.02611771f, 0.01377356f, 0.02421852f, -0.01355906f, 0.04680815f, 0.02284790f, 0.02739604f, 
    0.04101481f, 0.03644134f, 0.04089952f, 0.03721846f, -0.00460276f, -0.04752199f, -0.00791710f, -0.03297715f, 
    -0.00657610f, 0.01500038f, 0.05219339f, -0.04552117f, -0.01831568f, -0.02371459f, -0.05533846f, -0.01138229f, 
    -0.02223380f, -0.00787695f, -0.00559627f, 0.04303843f, 0.04521566f, -0.01764014f, -0.01203990f, -0.00844308f, 
    -0.04746083f, -0.05148377f, 0.00074799f, 0.02287193f, 0.00145483f, -0.04690412f, 0.02207378f, 0.00375152f, 
    -0.03445855f, -0.03477115f, 0.03393780f, -0.01194388f, -0.00917678f, -0.05491646f, -0.00275093f, -0.02674849f, 
    -0.17234272f, 0.03764864f, -0.07211785f, 0.10966850f, -0.08105627f, -0.15783326f, 0.00324156f, 0.00719449f, 
    0.02848160f, 0.05944287f, -0.00084715f, 0.06594049f, -0.06654776f, -0.06428304f, 0.01771438f, 0.07970438f, 
    -0.03610850f, 0.14439438f, -0.00118311f, -0.00669434f, -0.07655087f, 0.12235692f, 0.14952895f, 0.09153355f, 
    0.09014230f, 0.00191706f, -0.04138971f, -0.00566740f, 0.00682895f, 0.10311269f, 0.02890365f, 0.05443575f, 
    0.00018985f, 0.01321877f, 0.06961002f, -0.17587057f, -0.06703189f, 0.10223819f, -0.00362391f, -0.06702211f, 
    0.35107449f, -0.00633433f, -0.08577292f, -0.13905689f, 0.02949849f, -0.11544610f, 0.03929371f, -0.13417640f, 
    0.01242379f, -0.18031843f, 0.04837521f, -0.00631477f, -0.07069556f, -0.05493449f, 0.01365493f, 0.03679216f, 
    0.12905163f, -0.11458189f, 0.04621586f, -0.00561843f, 0.43454000f, -0.19368502f, -0.12530582f, -0.06616015f, 
    -0.05166752f, -0.00442136f, -0.00034724f, -0.05238888f, 0.06364162f, -0.04590994f, 0.06595489f, -0.11776935f, 
    0.01321455f, 0.03752559f, -0.06396858f, 0.10113749f, -0.12482421f, 0.10443936f, -0.25480264f, 0.01223039f, 
    0.11705415f, 0.43811345f, -0.26073569f, 0.11091814f, -0.24906723f, -0.02579230f, 0.05980157f, 0.01128882f, 
    -0.06826700f, 0.11281162f, 0.06341858f, 0.07694321f, 0.04987277f, 0.14384018f, -0.04291613f, -0.04041717f, 
    -0.10004905f, 0.14969742f, 0.01735805f, 0.01727505f, -0.30411810f, 0.33854315f, -0.04249343f, 0.06132240f, 
    -0.00041786f, 0.10396140f, 0.04851919f, -0.02745504f, -0.02514284f, -0.05098919f, -0.01344961f, -0.05558771f, 
    -0.13702071f, 0.17545690f, -0.08617476f, -0.11840112f, -0.12208492f, 0.20490594f, 0.10944730f, -0.09297653f, 
    0.09667209f, -0.51704204f, -0.18188426f, -0.01971489f, -0.07007416f, 0.08995036f, -0.08609804f, 0.14229941f, 
    -0.09002943f, 0.14356562f, 0.21345823f, 0.02435292f, 0.02521089f, -0.01980456f, -0.01479388f, 0.01852416f, 
    -0.01617719f, -0.05236059f, 0.22996473f, 0.06149833f, 0.31611708f, -0.19338061f, -0.23833491f, -0.04929218f, 
    -0.10291626f, -0.01622009f, -0.08259092f, 0.10031728f, -0.04355056f, 0.01579898f, 0.07487191f, -0.00330672f, 
    0.03087343f, -0.18441615f, 0.08000296f, 0.03531509f, 0.01855839f, -0.05450972f, -0.07886138f, 0.05221561f, 
    0.10919407f, -0.07758454f, -0.34344891f, -0.09846581f, 0.00474504f, 0.03687888f, -0.06957856f, 0.02528578f, 
    -0.11682804f, -0.11058098f, 0.16568431f, -0.01373736f, -0.11471771f, -0.02311474f, -0.08734790f, -0.05835499f, 
    -0.10808846f, -0.07941607f, -0.04290181f, 0.08807489f, -0.02493628f, 0.11388198f, -0.09143897f, -0.21461254f, 
    -0.04441937f, 0.06815635f, -0.03521857f, -0.13172440f, 0.13794686f, -0.13483080f, -0.02952595f, -0.02755281f, 
    -0.03466935f, 0.21318722f, 0.11406401f, 0.06384490f, 0.10872180f, -0.05985783f, -0.06516704f, -0.00521300f, 
    0.07323305f, -0.14028825f, -0.02017459f, 0.11350778f, 0.06595995f, 0.01412457f, -0.02123961f, 0.09588018f, 
    -0.04070596f, 0.05511028f, 0.00291410f, 0.04607983f, 0.02319350f, 0.09265998f, -0.06773214f, 0.04174989f, 
    0.04405711f, -0.16292368f, 0.04377371f, 0.12978637f, -0.04295200f, -0.23872590f, -0.15524375f, -0.07481344f, 
    0.11203395f, 0.12541069f, -0.09143507f, -0.00548800f, 0.03046609f, 0.06852264f, 0.13614167f, 0.02920704f, 
    0.08472797f, 0.16796574f, -0.12725201f, -0.11362625f, 0.11413971f, -0.10045442f, -0.01204481f, 0.04513825f, 
    0.06934701f, 0.11761094f, 0.04870901f, -0.15880883f, -0.02441105f, 0.05129573f, 0.10390513f, -0.01171378f, 
    0.11361217f, 0.01660352f, 0.06740286f, 0.03061203f, 0.07802831f, 0.06913063f, 0.00427615f, 0.12425946f, 
    0.15940689f, 0.03910619f, -0.12174459f, 0.05087221f, -0.04730880f, 0.12009227f, 0.05552177f, -0.07343213f, 
    0.07774359f, -0.09215669f, -0.03693889f, 0.09317949f, 0.14117858f, 0.17718102f, 0.11781465f, -0.00526394f, 
    -0.10414979f, -0.22195432f, -0.09085248f, 0.03038267f, 0.01629406f, 0.26994869f, 0.16292493f, 0.11933818f, 
    -0.16307059f, 0.03958881f, -0.09139210f, 0.13642792f, -0.07112657f, -0.00337115f, -0.04868749f, 0.03601192f, 
    0.03838318f, -0.01374198f, -0.07456786f, 0.08030567f, 0.03934648f, 0.14532237f, 0.09122023f, -0.03558381f, 
    -0.08583838f, -0.28901914f, -0.06790213f, -0.07062335f, -0.00927066f, 0.11077873f, -0.15519999f, -0.00949416f, 
    -0.12422916f, 0.05038616f, 0.04025390f, 0.01183722f, -0.05413400f, 0.01118498f, -0.06912381f, -0.01913548f, 
    0.01226644f, -0.02885956f, 0.12911974f, 0.04236624f, -0.20460925f, 0.05464453f, 0.02796525f, 0.06216634f, 
    0.17099614f, -0.08276513f, 0.31670272f, -0.03439705f, 0.40341437f, -0.05972737f, -0.04422779f, -0.01455214f, 
    0.07816519f, -0.06477053f, 0.01286525f, -0.09164282f, 0.03801509f, 0.01801248f, 0.02122496f, -0.08637139f, 
    -0.05464777f, -0.05583952f, -0.02092581f, 0.09913854f, -0.10504596f, -0.11290142f, -0.14700884f, -0.21291000f, 
    -0.05296062f, 0.11496252f, -0.05170385f, -0.05333479f, -0.01484498f, -0.06029605f, -0.04766567f, -0.06734823f, 
    0.05916359f, -0.00439270f, 0.02621065f, -0.02259529f, 0.05083928f, 0.08799967f, 0.00905037f, 0.00161510f, 
    -0.06139862f, -0.05716290f, 0.33580327f, 0.13752344f, 0.00194563f, -0.08548809f, -0.17344220f, 0.05490388f, 
    0.10739777f, 0.09825991f, -0.06390740f, -0.07642290f, 0.08665568f, 0.04664996f, 0.11443902f, -0.05091293f, 
    -0.08228432f, -0.02566041f, -0.03939220f, 0.02120408f, -0.23103662f, 0.25928974f, 0.07188155f, 0.01833072f, 
    0.00443375f, 0.11559983f, 0.00008575f, 0.02099934f, -0.07729863f, 0.10414667f, -0.07383156f, 0.08774597f, 
    -0.00981438f, 0.03760872f, 0.05174035f, 0.04911161f, 0.08574998f, 0.03357100f, 0.16398917f, 0.09817601f, 
    0.05523016f, -0.25262260f, -0.12821874f, -0.05575553f, 0.06612625f, 0.22905813f, -0.07224419f, 0.03670660f, 
    -0.11568189f, 0.04080447f, 0.04973842f, 0.01769542f, -0.13488275f, -0.02743078f, 0.03204110f, 0.03399386f, 
    0.11941262f, -0.00185003f, 0.08247747f, 0.04250658f, -0.16439155f, -0.11559391f, -0.15254648f, -0.04368599f, 
    -0.22308718f, 0.18059996f, -0.00055420f, 0.05139881f, -0.01281670f, -0.00965532f, 0.12605694f, 0.04235023f, 
    0.02699062f, -0.11956187f, 0.25692636f, -0.17991711f, 0.09859641f, -0.04620907f, 0.04520022f, 0.06626862f, 
    -0.13224268f, 0.09927712f, -0.09348339f, 0.21659003f, -0.22219104f, 0.17171673f, 0.16384919f, -0.04439708f, 
    -0.01118812f, -0.03978159f, -0.00674042f, 0.05407737f, 0.01836728f, -0.09225453f, 0.04935518f, -0.02226555f, 
    -0.06495231f, 0.14770328f, 0.02344945f, 0.01037172f, 0.26494291f, -0.05734640f, 0.26157275f, 0.09910830f, 
    -0.09060959f, 0.00374973f, -0.07023983f, 0.04544220f, -0.13784501f, 0.00344440f, -0.04403158f, -0.02245073f, 
    0.00722250f, 0.16797020f, -0.00594229f, 0.00158590f, -0.09455894f, 0.09667110f, 0.06249598f, 0.03337322f, 
    -0.23226574f, 0.19208325f, 0.25746176f, 0.08442515f, 0.09683178f, -0.07075082f, -0.14928146f, 0.03046054f, 
    -0.04157028f, 0.10328312f, 0.00395138f, 0.01246257f, 0.11166979f, -0.04265266f, 0.17849278f, -0.03852161f, 
    0.04459560f, 0.03837280f, 0.04691168f, 0.05231189f, -0.06455291f, -0.10840216f, 0.06708124f, -0.11817033f, 
    0.02090672f, 0.15332730f, -0.07806706f, 0.11219716f, -0.04050831f, -0.00253552f, 0.14467487f, -0.04150248f, 
    0.01020700f, 0.01517766f, -0.16576837f, 0.03649182f, -0.10999807f, 0.05679873f, 0.12802775f, 0.09728185f, 
    -0.03221670f, 0.01845960f, -0.21752100f, -0.13803065f, -0.10150921f, 0.10782352f, 0.05221136f, -0.16069441f, 
    0.04705925f, -0.07293013f, 0.18649924f, 0.04702569f, 0.03864928f, -0.01226167f, 0.00212519f, 0.04513306f, 
    0.02156891f, 0.08068452f, -0.00662785f, -0.01512780f, 0.03644701f, 0.15553521f, 0.13300271f, -0.16887563f, 
    -0.26133043f, -0.06625688f, -0.05828307f, 0.03037427f, 0.05756925f, -0.09219176f, 0.09090814f, -0.11582607f, 
    -0.07612174f, -0.15632699f, 0.07293925f, 0.14613195f, -0.11403041f, 0.10035402f, 0.12770878f, 0.10613742f, 
    0.10397891f, 0.15525436f, 0.01781065f, -0.05667947f, -0.11892758f, 0.03985570f, -0.01955308f, 0.07647310f, 
    -0.00132878f, -0.06485271f, 0.05196881f, 0.00322981f, 0.01704589f, -0.09511875f, -0.05493862f, -0.06136685f, 
    0.00038714f, -0.00836559f, 0.18745038f, 0.11421771f, 0.06960102f, -0.03268576f, -0.22706215f, 0.03215808f, 
    0.10617810f, 0.22518106f, 0.07331836f, -0.07853382f, -0.06730022f, -0.05765286f, -0.03221749f, 0.10665662f, 
    0.03409886f, 0.10712593f, -0.00261862f, -0.02484882f, -0.00012302f, -0.03522719f, -0.04094622f, -0.01950924f, 
    -0.09101345f, 0.08936743f, -0.10595836f, -0.12934907f, -0.18756375f, 0.12761395f, 0.04794206f, 0.00886425f, 
    -0.14771293f, -0.19400820f, 0.11645745f, 0.02939869f, -0.03461256f, -0.12786067f, -0.08985427f, 0.18165539f, 
    0.12235294f, 0.20782898f, -0.00268196f, 0.00274278f, -0.03722319f, -0.09065725f, -0.23113945f, -0.12768824f, 
    0.28098682f, 0.14346433f, 0.02060960f, -0.12366415f, 0.00405117f, -0.01539914f, 0.02158935f, 0.05036965f, 
    -0.10377567f, 0.00675514f, 0.00142231f, 0.00747703f, 0.13178511f, 0.00920106f, 0.13403000f, 0.05466586f, 
    -0.07214145f, -0.01711627f, 0.01643463f, -0.03635746f, 0.02457827f, -0.04393775f, -0.00187274f, -0.03621874f, 
    -0.00168825f, -0.04608555f, -0.03168917f, 0.01441229f, -0.01424903f, 0.01797590f, -0.02815441f, -0.04373746f, 
    -0.04554015f, -0.05303482f, -0.01861649f, -0.01981259f, -0.06079413f, 0.03579673f, 0.02934411f, -0.05180386f, 
    -0.01842645f, -0.05645022f, -0.01719997f, -0.05558312f, 0.00001922f, -0.04190709f, -0.04616512f, -0.01125937f, 
    -0.01775644f, 0.03641762f, -0.01908701f, 0.01961817f, 0.03318103f, -0.00459111f, 0.02330165f, 0.04887576f, 
    -0.04703264f, 0.02939388f, -0.06027878f, 0.00394958f, -0.07221626f, -0.01136699f, -0.04904890f, -0.01365985f, 
    -0.01352981f, 0.01223164f, -0.04873322f, 0.00787422f, 0.02719231f, -0.05591580f, 0.01561570f, 0.02130309f, 
    -0.03584297f, -0.02115685f, -0.02192971f, -0.03876293f, 0.02332149f, -0.00398864f, -0.04401160f, -0.00408181f, 
    -0.03385220f, 0.02075849f, 0.03981813f, -0.05931018f, 0.03050075f, -0.05493742f, -0.05933713f, 0.03146822f, 
    -0.03181732f, -0.02872358f, -0.04407188f, -0.03087330f, 0.05345031f, -0.04027793f, 0.02625908f, -0.01965860f, 
    0.01852205f, -0.02760243f, -0.02721443f, 0.01218929f, -0.00270759f, -0.06447792f, -0.06469657f, -0.04050044f, 
    -0.05855056f, -0.00979517f, 0.03827746f, -0.05595811f, -0.03500394f, -0.01117277f, 0.02493073f, 0.05340394f, 
    -0.01548804f, -0.01632139f, -0.01871788f, 0.00698166f, 0.07571518f, 0.00954280f, 0.03513641f, 0.03514758f, 
    -0.03095313f, -0.00060384f, -0.01948519f, 0.02368300f, -0.07061964f, 0.01937149f, 0.03249681f, -0.00576033f, 
    0.04233416f, 0.02861028f, 0.01274215f, 0.00606035f, 0.01402663f, 0.02797812f, 0.00054996f, -0.00808003f, 
    0.02466353f, -0.03600396f, 0.04620210f, -0.06192335f, -0.01995999f, -0.06816423f, 0.03109517f, 0.03363902f, 
    -0.05372571f, -0.00677486f, -0.05871778f, -0.03449748f, -0.02128076f, -0.04493473f, 0.02228051f, 0.01096660f, 
    0.04561612f, -0.05394972f, -0.03608379f, -0.01570961f, -0.04825848f, -0.03792286f, -0.04429911f, 0.04775245f, 
    0.01910965f, 0.01040717f, 0.04372761f, 0.01584734f, -0.00249471f, 0.01020196f, -0.03238832f, -0.07524649f, 
    0.00454446f, 0.01887833f, -0.03931841f, 0.04219678f, -0.05961153f, -0.00206602f, 0.02225571f, -0.03915543f, 
    -0.03454921f, -0.03349126f, -0.02414957f, 0.06055258f, -0.04213640f, -0.05101985f, -0.04992102f, 0.03942950f, 
    -0.02066452f, 0.00940513f, 0.02404171f, -0.05660849f, -0.06154007f, 0.00287147f, -0.05877044f, -0.01735438f, 
    -0.03046994f, -0.03806321f, 0.00690287f, 0.03583877f, 0.04468119f, 0.00075913f, 0.01254396f, 0.02789751f, 
    0.03405507f, -0.04294898f, -0.06162894f, 0.02573120f, 0.00941759f, 0.03964560f, 0.01123346f, -0.05300548f, 
    -0.00543924f, -0.04242989f, -0.01648167f, -0.01333928f, -0.05943728f, 0.00446378f, -0.02355840f, -0.01026525f, 
    -0.00461760f, -0.03885343f, 0.01217583f, 0.05804353f, 0.04250962f, -0.06262770f, 0.02459313f, -0.02376974f, 
    -0.00188404f, -0.03749437f, -0.03510103f, -0.06613312f, -0.04058132f, -0.00870670f, -0.02253072f, -0.02261328f, 
    -0.00188308f, -0.04273199f, -0.03669060f, -0.06214409f, -0.02739888f, -0.00021214f, 0.06022481f, -0.02426873f, 
    -0.00190491f, -0.00446429f, -0.04795230f, -0.02184529f, -0.01283812f, 0.01995776f, 0.02426002f, 0.00078561f, 
    -0.06586558f, -0.03058316f, -0.06707590f, -0.01901733f, 0.03376472f, 0.01317253f, -0.04978894f, 0.04569223f, 
    0.01945634f, -0.02368451f, -0.04020488f, -0.01554091f, -0.00794075f, 0.02371945f, -0.01849582f, 0.03702401f, 
    0.00113423f, -0.01488961f, -0.00774717f, 0.02090911f, -0.03495276f, -0.01473588f, -0.03055565f, 0.02590427f, 
    0.02534582f, -0.01961942f, 0.02018592f, -0.05347412f, -0.02481747f, 0.00551038f, -0.00217089f, 0.01227775f, 
    -0.02477753f, -0.02678319f, -0.05612825f, -0.05799525f, 0.01700909f, -0.02406339f, -0.00541383f, -0.00676109f, 
    -0.04121623f, 0.03926264f, -0.01242087f, -0.04137928f, 0.03620371f, 0.03555227f, -0.00323394f, 0.03514360f, 
    0.00059333f, -0.04842285f, 0.03156037f, -0.01014307f, -0.04068265f, 0.01474157f, -0.00902947f, -0.05080913f, 
    0.04671921f, 0.00422944f, 0.02108873f, 0.03817187f, 0.00660527f, -0.04238915f, -0.00352610f, -0.06277212f, 
    0.03102023f, -0.01206386f, 0.03661411f, -0.02554137f, -0.05625042f, 0.02587380f, -0.00435398f, 0.02680641f, 
    0.05456290f, 0.01700816f, -0.03557034f, -0.02844875f, -0.04404132f, -0.01434636f, 0.00920281f, -0.03929503f, 
    -0.05411661f, 0.03530047f, -0.04440419f, -0.04403164f, -0.04347563f, -0.03247646f, -0.03203153f, 0.04457318f, 
    0.29401731f, 0.00174260f, -0.17431410f, -0.11284982f, 0.07415003f, 0.15080900f, 0.02347814f, -0.06443838f, 
    0.11950149f, 0.03914256f, 0.01450838f, 0.00356777f, 0.10153247f, 0.15203254f, -0.03849502f, -0.05069919f, 
    0.06304202f, -0.12886833f, 0.03680507f, 0.03105096f, -0.29322857f, -0.33379400f, -0.08661774f, -0.15323131f, 
    -0.11185731f, 0.06369138f, 0.08612800f, 0.03957419f, 0.05754090f, -0.03133051f, -0.03665691f, -0.07138007f, 
    0.11694576f, 0.00608027f, 0.00282897f, 0.06909732f, 0.00079977f, -0.11731775f, -0.07135516f, 0.06446330f, 
    -0.31027004f, -0.16076139f, 0.13079061f, 0.09118999f, 0.04339901f, 0.03319119f, -0.07022517f, 0.03650136f, 
    -0.00191476f, -0.05490583f, -0.06602451f, 0.00060438f, 0.13417824f, 0.05807954f, 0.05459807f, -0.06269680f, 
    -0.10294433f, 0.03646985f, -0.00758648f, -0.07217796f, -0.32061207f, 0.29678303f, 0.08665971f, 0.03497512f, 
    0.04117389f, 0.06073032f, 0.06017154f, 0.07051300f, 0.02279718f, 0.05397755f, -0.08415121f, 0.05346549f, 
    -0.05030918f, -0.10292884f, 0.00031240f, -0.08785036f, 0.11041401f, 0.09044319f, 0.21777557f, 0.08885176f, 
    -0.54494834f, -0.36737865f, 0.27792564f, -0.00880636f, -0.12820567f, -0.00705015f, -0.03821697f, 0.02104928f, 
    0.06863438f, 0.09545012f, 0.01759533f, 0.00137639f, 0.01317777f, -0.07574598f, 0.05087017f, 0.03411118f, 
    0.08054582f, -0.04296950f, -0.04190169f, 0.08305084f, -0.24376705f, -0.41545600f, 0.11275292f, 0.03170039f, 
    -0.24178092f, -0.02253874f, -0.00834876f, 0.13745542f, 0.00681615f, 0.08264969f, 0.09154457f, 0.02921103f, 
    0.07622507f, -0.07911994f, 0.10719106f, -0.00847407f, 0.18090163f, -0.12074240f, 0.00800600f, 0.09147986f, 
    -0.49367040f, 0.26330724f, 0.02771738f, 0.08751266f, -0.09833445f, 0.13521509f, 0.12187403f, -0.02875821f, 
    0.07886096f, 0.00030011f, 0.10974945f, -0.06302301f, 0.06414561f, -0.00208146f, 0.02232734f, 0.02463354f, 
    0.06070770f, 0.09899960f, -0.17146276f, 0.09905761f, -0.28151548f, 0.25747159f, -0.00722856f, 0.08252698f, 
    0.10398225f, -0.09780200f, -0.07584216f, 0.00156672f, 0.06116715f, -0.07678036f, -0.04514317f, -0.02345688f, 
    -0.04540341f, 0.12322030f, -0.13778906f, -0.01655940f, -0.02118229f, 0.21261585f, 0.00362500f, 0.02781940f, 
    0.09664459f, -0.12895536f, 0.01293325f, 0.08076777f, 0.13499151f, 0.03292644f, -0.01254476f, -0.07394296f, 
    -0.08188771f, 0.06432120f, -0.10130672f, 0.05161906f, 0.12365752f, 0.00403228f, 0.03179311f, -0.01602367f, 
    0.14552960f, -0.05904731f, 0.00491471f, -0.04863725f, 0.21569926f, 0.06004837f, 0.11873940f, 0.14387733f, 
    0.14002879f, -0.02551368f, 0.03370511f, 0.05981778f, -0.06931956f, 0.08700165f, 0.05779891f, 0.12028712f, 
    0.08851819f, -0.08141674f, -0.00365404f, 0.02520567f, -0.10690899f, -0.01903706f, 0.20466962f, 0.11101844f, 
    0.01127998f, 0.15809083f, 0.16873860f, 0.02197351f, -0.06643074f, -0.08483825f, 0.11521762f, -0.05053898f, 
    0.11109709f, 0.02311729f, -0.08890046f, -0.04578111f, -0.07989437f, -0.08505876f, 0.04341260f, -0.05734698f, 
    0.05373590f, 0.10676826f, 0.00566142f, -0.08726009f, 0.19877262f, 0.22874895f, -0.10763156f, 0.20211241f, 
    0.04417742f, -0.11704043f, 0.01372792f, -0.01309608f, -0.06473968f, -0.06260595f, 0.00448037f, -0.06610182f, 
    0.01153191f, -0.07009579f, 0.03292659f, 0.15846264f, -0.02389831f, 0.07707912f, 0.09416234f, 0.04466293f, 
    0.07434603f, 0.25231481f, -0.03037256f, 0.23556681f, 0.11062352f, -0.00691503f, 0.08876579f, 0.09574935f, 
    -0.06220756f, 0.06852943f, -0.04685881f, 0.00780815f, -0.07936853f, -0.00120986f, -0.01853638f, 0.00407544f, 
    -0.03948576f, -0.00364455f, 0.12596379f, 0.11727026f, -0.05962124f, -0.17657909f, -0.01321082f, -0.00828589f, 
    0.05714489f, 0.08820021f, 0.03116808f, -0.02336497f, 0.01163041f, 0.09279583f, -0.04421657f, -0.04914615f, 
    -0.05265190f, 0.13067706f, 0.05127377f, -0.11586533f, 0.04663269f, -0.06958190f, 0.02928874f, -0.12074941f, 
    0.07844616f, 0.00087347f, 0.24643469f, 0.26114231f, -0.11163955f, -0.06329960f, 0.10968667f, 0.10137182f, 
    0.04574083f, -0.01931635f, -0.04719278f, -0.02326212f, -0.08563299f, -0.06077998f, -0.09162827f, 0.14383270f, 
    0.00473308f, 0.09196677f, 0.04334794f, 0.13242845f, -0.32184613f, -0.12441926f, 0.05739632f, -0.14056168f, 
    -0.19291911f, 0.01348931f, -0.04869373f, -0.01082356f, 0.04389396f, 0.05532421f, 0.06073223f, 0.09433432f, 
    -0.04298387f, 0.15603161f, 0.00486210f, -0.07032353f, 0.07729234f, 0.01199213f, 0.03651986f, -0.01599261f, 
    -0.22470608f, 0.09057967f, -0.17613201f, 0.03516464f, 0.04973985f, -0.05572277f, -0.03881671f, -0.00685127f, 
    -0.15591466f, -0.05272773f, -0.03450422f, -0.00935677f, -0.03078433f, -0.07387001f, 0.00342787f, -0.02580658f, 
    -0.09529829f, 0.09391025f, -0.08838633f, -0.08357173f, -0.16137218f, 0.10585951f, 0.08620860f, 0.06910891f, 
    0.00523423f, -0.14585152f, -0.02212117f, -0.20471820f, -0.09462404f, 0.02793222f, 0.06898259f, -0.00835030f, 
    0.01842909f, -0.05171473f, -0.08678998f, -0.07757293f, -0.03614897f, 0.12613261f, -0.01343011f, -0.12055579f, 
    0.13456433f, 0.04850942f, 0.00162324f, -0.08959408f, 0.10790576f, -0.13871467f, -0.04239648f, -0.00127075f, 
    -0.12156559f, -0.00928061f, -0.04953404f, 0.06297375f, -0.05567610f, -0.19892322f, -0.07395434f, 0.05868414f, 
    0.14664564f, -0.09035950f, 0.02194749f, -0.08215643f, -0.11215127f, 0.02543144f, -0.13003883f, -0.16208486f, 
    0.09090524f, 0.11288061f, -0.02479396f, -0.01478128f, 0.08908358f, 0.00064976f, 0.07063087f, -0.06209140f, 
    -0.09221119f, -0.03515741f, 0.02199637f, 0.06280170f, 0.03328376f, -0.06671939f, -0.17992678f, -0.01843969f, 
    -0.14986992f, 0.04763192f, -0.09796792f, 0.10665860f, -0.14200307f, -0.19054344f, -0.01229224f, -0.11119485f, 
    0.01626834f, -0.05571265f, 0.01552702f, 0.05167772f, -0.00121838f, 0.16743985f, -0.02985606f, 0.05531637f, 
    0.00124884f, -0.00780432f, -0.03053175f, 0.01218918f, 0.11480491f, -0.09102881f, -0.01329392f, -0.08212685f, 
    -0.05665446f, -0.07075395f, 0.08965558f, -0.11557895f, -0.23611072f, -0.01734599f, -0.08452629f, -0.06605269f, 
    -0.13835336f, 0.10260613f, -0.11244863f, -0.03565672f, -0.24763569f, 0.18073952f, 0.06031275f, -0.17101812f, 
    -0.08765568f, -0.15252319f, -0.28326687f, -0.00643117f, -0.32296968f, -0.07357235f, -0.07953678f, -0.09910388f, 
    -0.14167631f, -0.02734724f, 0.06890118f, -0.10064432f, -0.13829814f, 0.08482920f, 0.00691401f, -0.13780794f, 
    0.05007893f, -0.24420974f, 0.19220634f, -0.05818165f, -0.47189489f, 0.08636900f, -0.26000676f, -0.10258721f, 
    -0.06470258f, -0.00567918f, 0.02340570f, 0.09512809f, -0.08886728f, -0.05491307f, -0.03382207f, -0.08638635f, 
    0.09353317f, -0.22820362f, -0.08607544f, -0.06485108f, 0.09509066f, -0.15737048f, 0.00921585f, -0.00657612f, 
    0.10168783f, -0.31708226f, 0.16401796f, -0.38615197f, 0.26301223f, 0.02040910f, 0.04232089f, -0.11432497f, 
    -0.02954490f, -0.13897087f, -0.02540388f, 0.02937650f, -0.28461775f, -0.04806722f, -0.03283137f, -0.08806974f, 
    0.02708432f, 0.07309096f, 0.03502428f, 0.02132472f, -0.04259533f, 0.15624899f, 0.07075264f, -0.13605967f, 
    0.11262111f, 0.25430888f, 0.06350193f, -0.08773713f, 0.09292471f, -0.06638169f, -0.01176414f, -0.00218457f, 
    -0.04934493f, -0.03034396f, 0.12506427f, -0.04663164f, 0.06002289f, -0.00519915f, -0.23023577f, -0.04812031f, 
    -0.16670868f, -0.24094015f, 0.03506137f, 0.12204082f, 0.06596456f, 0.08692191f, -0.10924223f, -0.04402032f, 
    0.06890149f, 0.07669347f, 0.01478662f, 0.01522614f, 0.03126109f, 0.01253658f, 0.00568853f, -0.12829016f, 
    0.00392374f, -0.17505363f, -0.00987467f, 0.03291535f, 0.05585043f, 0.38185808f, -0.08483777f, 0.04307546f, 
    0.18385671f, 0.06884453f, -0.05563528f, 0.00061663f, -0.00058797f, 0.09734990f, -0.04029337f, 0.13566448f, 
    0.03938743f, 0.12036854f, -0.13446870f, -0.06995529f, 0.09334016f, -0.20948751f, -0.06963138f, -0.01281121f, 
    -0.02501022f, 0.09038737f, 0.12496033f, -0.25664303f, 0.11199170f, 0.11845653f, -0.11011819f, 0.11563483f, 
    0.05710252f, -0.07227299f, -0.05862604f, -0.05129412f, 0.01222900f, 0.12435739f, 0.02359272f, 0.08019473f, 
    -0.00644792f, -0.08553647f, -0.31022954f, 0.02876550f, 0.10793035f, 0.03108286f, 0.09885003f, -0.11530933f, 
    -0.02421999f, -0.07812379f, -0.13390748f, 0.07426451f, 0.15990190f, 0.15092236f, -0.01377196f, -0.11213315f, 
    -0.02027641f, -0.19826783f, -0.12602682f, 0.08777595f, 0.15694822f, 0.03499161f, 0.02966019f, 0.06474935f, 
    0.04489183f, 0.00027437f, -0.07999401f, 0.20213944f, 0.02578644f, -0.04176284f, -0.14479782f, -0.09725038f, 
    0.05693772f, -0.06306329f, -0.00668003f, 0.04101022f, -0.02213787f, 0.04728336f, 0.13957137f, -0.11491934f, 
    -0.17386281f, -0.36161920f, -0.04944669f, -0.08665391f, -0.30902499f, -0.02218008f, -0.09207848f, 0.19346896f, 
    -0.12296639f, 0.06268321f, 0.00731473f, -0.14601746f, -0.12274399f, 0.05456980f, -0.06240380f, -0.01234299f, 
    0.01718217f, 0.01682859f, 0.03287575f, 0.07886003f, -0.12582938f, -0.00884524f, -0.02944043f, -0.07720898f, 
    0.12982185f, 0.22082183f, 0.07448498f, 0.02171015f, -0.17493121f, -0.04828657f, 0.00453184f, -0.11962324f, 
    -0.10754788f, 0.02874411f, 0.02393698f, 0.01014769f, 0.03459159f, -0.09514911f, 0.01794900f, 0.01522444f, 
    -0.06493624f, 0.06773862f, 0.04440192f, -0.02394187f, 0.36027253f, 0.17428219f, -0.10277291f, -0.09483329f, 
    -0.05789163f, -0.00319571f, 0.05082751f, 0.05696813f, -0.11562490f, -0.04014096f, 0.18475407f, 0.04554217f, 
    -0.11378975f, -0.01205142f, -0.09408230f, 0.10316994f, 0.09269649f, 0.12667412f, 0.06868559f, 0.05061562f, 
    0.40547019f, 0.14822614f, -0.09881249f, 0.03973651f, -0.26454625f, -0.00256032f, -0.04128263f, -0.02984235f, 
    0.00190725f, 0.17118238f, 0.04575294f, -0.01352599f, 0.03059351f, -0.01378712f, -0.05456958f, 0.02215694f, 
    0.06404480f, 0.08958632f, 0.00521234f, 0.08652849f, 0.08104592f, -0.23855093f, 0.02369377f, 0.12162273f, 
    0.11267299f, -0.07165819f, -0.08146117f, -0.10072792f, 0.08874112f, 0.16553229f, 0.05808300f, 0.01144014f, 
    -0.03969538f, 0.08074722f, -0.09130216f, 0.15411811f, -0.01244318f, -0.13890210f, 0.00630428f, -0.13992476f, 
    0.31171042f, 0.13315791f, -0.08027871f, -0.14083016f, 0.27383485f, 0.05526428f, 0.01688546f, -0.04238983f, 
    0.00921214f, 0.00822638f, -0.03320928f, -0.00773075f, -0.00500954f, 0.25934508f, 0.05173425f, 0.07847428f, 
    -0.11723571f, 0.07988114f, -0.02848358f, 0.04083756f, 0.23607363f, -0.18409890f, -0.08858710f, -0.05151760f, 
    0.27258629f, 0.01894601f, 0.02741126f, -0.00032276f, -0.05456712f, -0.10737021f, -0.14900306f, -0.12403660f, 
    -0.03953604f, 0.12299283f, -0.13241936f, 0.08566151f, -0.10988817f, 0.22351433f, -0.02226853f, 0.00716216f, 
    0.22171833f, -0.18859541f, 0.29486200f, -0.48174062f, 0.11500853f, -0.14356215f, -0.24213181f, 0.02622565f, 
    -0.04452823f, -0.00920063f, -0.10409948f, 0.01808496f, -0.00021221f, 0.12557767f, 0.03133291f, 0.03377081f, 
    0.05778115f, -0.10090964f, 0.20026512f, 0.02086153f, 0.14344500f, -0.10294055f, -0.07453972f, -0.04077401f, 
    -0.02416203f, 0.14871472f, -0.10612492f, -0.05253193f, 0.23203158f, 0.13511164f, 0.02389718f, 0.03968171f, 
    -0.02971226f, -0.02266551f, 0.13392362f, 0.02159536f, 0.04437397f, -0.09484313f, 0.10294070f, -0.05982986f, 
    0.32095158f, -0.11547942f, -0.09624428f, 0.27042729f, -0.38657787f, -0.22878808f, 0.09816340f, -0.02886399f, 
    0.15851979f, -0.07562824f, -0.05355218f, 0.12119120f, -0.02571136f, -0.04005304f, 0.03560276f, -0.05064947f, 
    -0.04435727f, 0.15848108f, 0.07256369f, -0.02019159f, -0.17089543f, -0.10300031f, 0.05607442f, 0.13801122f, 
    -0.37966377f, 0.06754406f, 0.02631299f, -0.06082612f, 0.01917741f, -0.10475216f, 0.00842357f, 0.04345537f, 
    0.12514885f, 0.02118507f, -0.06317713f, 0.06432847f, 0.06908354f, -0.14115153f, -0.13034680f, -0.13687029f, 
    -0.19158672f, 0.05966484f, -0.16481528f, -0.13858773f, 0.02639643f, 0.13939480f, 0.01250445f, 0.07296572f, 
    -0.12883149f, -0.03698839f, 0.13100801f, 0.04765143f, 0.14000723f, 0.02969091f, 0.04162659f, 0.05213428f, 
    0.00667128f, -0.02028193f, 0.08786830f, -0.01863412f, 0.00372014f, -0.22547376f, 0.23501045f, 0.06752797f, 
    -0.15931447f, 0.02294921f, 0.08200001f, -0.02237989f, 0.04095391f, 0.08330069f, -0.11298940f, 0.06865551f, 
    0.05684698f, 0.05339636f, 0.09823792f, -0.01478179f, 0.14715834f, -0.02349700f, -0.14809245f, -0.02636790f, 
    -0.03049705f, -0.13820361f, 0.04662581f, 0.01683980f, -0.11870751f, 0.01935702f, -0.07449171f, -0.06273306f, 
    0.01681508f, 0.03127094f, -0.11387957f, 0.15670438f, 0.11571144f, -0.02115116f, -0.15527596f, 0.16627106f, 
    0.05800128f, 0.02415750f, 0.02753211f, 0.08621515f, 0.21980537f, 0.24680310f, 0.21061292f, -0.09409789f, 
    -0.18382563f, -0.02068442f, -0.02789805f, 0.09550153f, 0.04592749f, -0.08543605f, -0.05799363f, -0.07747310f, 
    0.04053110f, -0.09317360f, -0.00888384f, 0.11123293f, -0.04226368f, 0.10553153f, 0.04981072f, 0.28527576f, 
    -0.15666541f, -0.21412860f, -0.30892318f, -0.34061447f, 0.27590516f, -0.02020594f, -0.11171130f, -0.06919863f, 
    0.00445870f, 0.02911422f, 0.09645791f, -0.14017928f, 0.06344479f, 0.03859199f, 0.04092049f, -0.08521432f, 
    -0.02643558f, -0.08546682f, -0.07257345f, -0.10188337f, 0.03717605f, -0.03531593f, 0.01370973f, -0.03623940f, 
    0.24143451f, 0.05787424f, 0.19206220f, -0.03157172f, -0.03749124f, -0.04927489f, -0.03392921f, -0.13253286f, 
    0.16002974f, 0.12736462f, 0.04200009f, 0.10879084f, -0.02229631f, 0.11308844f, -0.05301932f, 0.07006516f, 
    0.24220121f, 0.17982134f, -0.20129183f, -0.02618515f, -0.24987707f, 0.19388580f, 0.04110344f, 0.07788299f, 
    -0.07761085f, 0.15330945f, -0.01646880f, 0.02570984f, -0.10480134f, 0.14574605f, 0.06369851f, 0.06346887f, 
    0.16348647f, -0.16634311f, 0.01882308f, 0.03656986f, 0.50859874f, 0.09672949f, 0.04791760f, 0.18623768f, 
    0.09133602f, 0.13447504f, 0.05017394f, 0.16939537f, 0.09456985f, 0.00122692f, 0.09701240f, 0.04652974f, 
    -0.06148761f, -0.00379012f, -0.00587494f, 0.03665181f, 0.06501016f, -0.04495759f, 0.01293456f, 0.06389069f, 
    -0.24904114f, -0.06690498f, -0.15416946f, 0.04405986f, -0.16157936f, 0.14020644f, 0.09046953f, -0.03333575f, 
    0.06187357f, 0.01384752f, 0.03823584f, -0.04294341f, -0.02978061f, 0.07518187f, 0.09147956f, 0.02145829f, 
    -0.01061592f, 0.00792190f, -0.03831245f, 0.02171700f, -0.11953397f, -0.25223464f, -0.15137284f, 0.23950250f, 
    -0.05494421f, 0.03484643f, 0.05604098f, -0.05196399f, -0.03935496f, 0.08060233f, 0.07434174f, -0.00386701f, 
    -0.12700161f, -0.08602975f, 0.04262519f, -0.08192369f, -0.04617881f, 0.02260865f, -0.04015845f, 0.08476884f, 
    -0.30263308f, -0.06436834f, 0.34467548f, -0.06241375f, 0.09294703f, -0.00415543f, -0.06631212f, 0.01673361f, 
    -0.06162703f, 0.15763173f, 0.00102324f, -0.00691475f, -0.04535906f, -0.05378374f, -0.00118371f, 0.03469885f, 
    0.01912393f, 0.09899932f, -0.05199431f, -0.03206243f, 0.19346626f, -0.03182595f, 0.43672284f, 0.22010681f, 
    0.13839731f, -0.15877289f, -0.15061212f, 0.01356648f, 0.03800075f, 0.04362268f, 0.10578904f, 0.03940149f, 
    0.06742486f, -0.07297783f, -0.02448281f, 0.13428558f, 0.26166373f, -0.16601974f, -0.02088249f, -0.00529131f, 
    -0.10803188f, -0.02333988f, 0.29507148f, 0.01877105f, 0.18022582f, -0.05791027f, 0.14989538f, 0.03966141f, 
    0.15317613f, -0.00431590f, 0.02232845f, 0.00097716f, -0.00210457f, 0.03231534f, 0.05802720f, 0.05892909f, 
    0.01915925f, 0.05676072f, -0.06683329f, -0.03237144f, 0.16962144f, -0.07628832f, -0.15644948f, 0.03692735f, 
    0.02715649f, -0.00917332f, 0.06225602f, -0.16772234f, 0.05558358f, 0.02564904f, 0.03439906f, 0.04422784f, 
    -0.18604384f, 0.06905350f, 0.00436833f, -0.00691361f, -0.07869305f, 0.05379578f, 0.01604086f, 0.10736841f, 
    -0.32999790f, -0.02830094f, -0.28465265f, -0.02698908f, 0.02578706f, -0.11659297f, 0.02934825f, -0.11544321f, 
    0.04866946f, 0.10009748f, -0.06876718f, -0.06413770f, 0.17669632f, 0.06928122f, 0.07826207f, 0.04453865f, 
    -0.05230009f, -0.09250680f, -0.10973182f, 0.07013086f, 0.13195299f, -0.06337627f, 0.03361486f, 0.04440114f, 
    -0.46454659f, -0.01186682f, -0.03456633f, 0.07228098f, -0.12297173f, -0.00042868f, 0.09223858f, 0.06527545f, 
    -0.03682917f, -0.05532160f, -0.11091989f, -0.02978196f, -0.17968145f, -0.02129704f, 0.08334376f, 0.07420380f, 
    -0.27278793f, 0.16527183f, 0.31614596f, -0.37651345f, -0.05717013f, -0.09853444f, 0.03395650f, 0.07607645f, 
    -0.17001477f, 0.01887534f, -0.08783747f, 0.01184346f, 0.01687913f, -0.06908379f, 0.00223998f, -0.04070867f, 
    -0.05304667f, 0.00012934f, -0.05944102f, -0.14864850f, -0.05406150f, -0.14963996f, 0.04483718f, 0.26349711f, 
    -0.10430229f, 0.03781590f, 0.14262961f, 0.16297555f, 0.07596897f, -0.08339584f, -0.09299836f, -0.01174594f, 
    0.01349646f, 0.11956609f, 0.14515953f, 0.12266631f, 0.01955416f, -0.02358738f, -0.01174225f, 0.02483065f, 
    -0.01832288f, -0.16409619f, -0.02377131f, 0.10470361f, -0.05411668f, 0.16455875f, 0.13745086f, 0.04653395f, 
    0.03332251f, 0.04451391f, -0.06308708f, -0.03479510f, -0.04769105f, -0.00366903f, 0.08301470f, 0.06776252f, 
    -0.04900481f, -0.08257535f, 0.22875296f, -0.07103446f, -0.00817584f, -0.01683688f, -0.10131313f, 0.11750656f, 
    0.12479056f, -0.03310740f, 0.04930883f, 0.00916865f, -0.10353034f, 0.01540720f, -0.11723691f, -0.02962885f, 
    0.07077078f, 0.11014954f, 0.18604778f, -0.01212583f, -0.00387474f, -0.13850327f, -0.04543699f, 0.00040580f, 
    -0.07773284f, -0.28448942f, 0.25740358f, -0.01222197f, -0.16909002f, -0.16614594f, 0.03471791f, 0.14924622f, 
    -0.15024315f, 0.06776992f, 0.07913207f, -0.03531194f, -0.02423060f, -0.13491602f, -0.01948822f, 0.01961461f, 
    -0.00684994f, 0.07088625f, 0.12159497f, 0.06491660f, -0.02317605f, 0.19538786f, 0.09974305f, -0.21888870f, 
    0.25838265f, 0.01333070f, -0.07135103f, 0.09428352f, 0.04694220f, 0.05612140f, -0.00729788f, 0.07785168f, 
    -0.00558638f, 0.06329147f, -0.03157469f, -0.00820880f, -0.01809111f, 0.00428294f, 0.01967643f, -0.03452464f, 
    0.37798202f, -0.35555357f, 0.23463450f, -0.22434537f, 0.02286229f, -0.03971339f, -0.03832420f, -0.02475422f, 
    0.20071951f, 0.05453207f, -0.00283700f, -0.00194944f, 0.13870797f, 0.02588190f, -0.00317839f, 0.08772462f, 
    0.07785580f, -0.09121891f, 0.02352319f, 0.04206215f, 0.02496590f, -0.21926697f, -0.18875088f, -0.24289976f, 
    -0.00487547f, 0.00096989f, -0.09417579f, 0.03829162f, -0.08060115f, -0.04788228f, -0.10151275f, 0.10214300f, 
    0.06305179f, 0.11011788f, 0.17296813f, 0.09419691f, 0.09059443f, -0.29291087f, -0.28812581f, -0.01683770f, 
    -0.03265640f, -0.02722258f, -0.22511792f, -0.20807049f, 0.04546581f, 0.04711567f, -0.05018664f, -0.10718855f, 
    0.14680851f, 0.08033843f, -0.03774326f, -0.19429679f, 0.12887917f, 0.04085384f, -0.02741843f, -0.03286777f, 
    0.07068875f, 0.09938227f, -0.03781508f, 0.07845934f, 0.18848436f, 0.15354624f, 0.17611939f, 0.03564794f, 
    0.00481055f, 0.14998810f, 0.08415765f, -0.02648779f, 0.00453566f, -0.04955716f, -0.12987521f, 0.08768007f, 
    -0.10003002f, 0.15618482f, 0.08297379f, -0.00625005f, 0.01163014f, -0.03005112f, 0.13620484f, 0.11231976f, 
    0.02630996f, 0.08887469f, 0.20473921f, -0.12749675f, 0.08416584f, 0.01273276f, 0.14859426f, -0.12094796f, 
    -0.13562423f, 0.12887461f, -0.17554981f, -0.01108367f, -0.13794228f, -0.05831454f, 0.03317713f, -0.00698435f, 
    0.06774510f, -0.20973578f, 0.03153738f, -0.09984265f, -0.09309690f, 0.16175535f, -0.36408755f, 0.06183670f, 
    0.04103534f, -0.09373666f, -0.01282074f, -0.01011830f, -0.03859574f, -0.04042048f, 0.02744370f, 0.13417839f, 
    0.29067281f, -0.07226136f, 0.21085529f, 0.04317364f, 0.18346022f, -0.29321793f, -0.36463296f, -0.00897631f, 
    0.15927811f, 0.29968369f, 0.11812282f, 0.18434842f, 0.19477935f, 0.05497405f, -0.05960273f, 0.17293528f, 
    -0.00923997f, -0.01155682f, 0.06703886f, 0.07522985f, 0.11980422f, -0.00317227f, -0.06489713f, 0.05284442f, 
    0.07987285f, 0.08574603f, -0.17105305f, -0.09613908f, 0.54655826f, -0.02708129f, 0.16783626f, -0.01992047f, 
    0.12231472f, 0.01558026f, -0.06461103f, -0.15262036f, 0.05395143f, 0.11790779f, -0.17246124f, -0.03274344f, 
    -0.16071557f, 0.13965279f, 0.05193150f, 0.01049225f, -0.10511100f, 0.00443803f, 0.02383993f, 0.01955963f, 
    0.09768098f, 0.32271042f, -0.47913921f, 0.10524150f, -0.23062597f, 0.07541454f, -0.13032402f, 0.10595202f, 
    0.06183086f, 0.02405638f, -0.20661756f, 0.02366082f, 0.17962749f, 0.01580782f, 0.09544829f, 0.16125293f, 
    -0.03891738f, -0.12023427f, -0.02417952f, 0.12701921f, 0.03676656f, 0.04375722f, -0.14749154f, -0.11250757f, 
    0.06402706f, -0.09643818f, -0.06326416f, 0.06964559f, -0.14653726f, -0.00434552f, -0.01914024f, 0.02737318f, 
    0.03007498f, -0.06194491f, -0.00888199f, 0.01665906f, -0.05005129f, -0.01729922f, 0.18506445f, 0.04723591f, 
    0.53936589f, 0.27201799f, -0.18861265f, -0.09282821f, -0.03424710f, 0.05261447f, 0.16979973f, 0.00392106f, 
    0.03182381f, -0.00536938f, -0.03860829f, 0.00228197f, -0.11074112f, 0.01808505f, -0.11469165f, 0.15077060f, 
    0.05981998f, 0.14349236f, 0.02324362f, -0.04403657f, 0.05586042f, -0.08282319f, -0.02367173f, -0.19797847f, 
    -0.05024743f, 0.04853593f, -0.04846705f, -0.04666327f, -0.09605937f, -0.03287840f, -0.07340956f, -0.21739475f, 
    -0.07668594f, -0.04381821f, 0.13892642f, 0.03627895f, -0.01589703f, 0.18443386f, 0.06578866f, 0.17204998f, 
    0.05282883f, 0.13357648f, -0.16694637f, -0.05695796f, -0.06967111f, -0.04332518f, 0.06393794f, -0.16282171f, 
    -0.11012535f, -0.08014008f, -0.03436772f, -0.00663589f, -0.00406590f, -0.22038598f, -0.09867343f, 0.19459473f, 
    -0.07226804f, 0.12920184f, 0.07999999f, 0.15947059f, -0.33864018f, -0.09769467f, -0.09832492f, -0.01556424f, 
    -0.22060801f, -0.18790613f, 0.01536148f, -0.10963597f, -0.07033844f, 0.03572473f, 0.08855522f, 0.10968287f, 
    -0.11819860f, -0.12781903f, -0.10705244f, 0.05433998f, -0.19595267f, -0.22794795f, -0.14773649f, -0.08190457f, 
    0.14695267f, 0.01953393f, 0.08738861f, -0.01504230f, -0.02043097f, -0.02755488f, 0.15248783f, -0.00695380f, 
    -0.10646686f, 0.03570708f, -0.11543250f, -0.07778103f, -0.01786785f, -0.06352939f, -0.06438495f, 0.15738954f, 
    0.11239967f, 0.24179682f, 0.14099187f, -0.02878159f, 0.31138051f, -0.10098800f, 0.18437293f, -0.05173007f, 
    -0.13481797f, -0.16857387f, 0.00309218f, -0.05944014f, 0.10268749f, 0.01396360f, 0.12680478f, 0.07444273f, 
    -0.08435947f, -0.11859051f, -0.05253158f, -0.06729051f, 0.10191921f, -0.13841820f, -0.00949153f, -0.06301647f, 
    -0.27185646f, 0.42115524f, -0.18321560f, -0.06310585f, 0.26933005f, 0.03271960f, 0.12584950f, -0.01464555f, 
    -0.02418853f, -0.05847823f, -0.05994619f, 0.05567788f, -0.00734588f, 0.02291275f, -0.05601788f, 0.01304553f, 
    -0.09323913f, -0.17502232f, -0.05547264f, -0.09014755f, -0.12269434f, 0.00529034f, 0.06778487f, -0.17494473f, 
    -0.22601406f, 0.03936064f, 0.08502180f, 0.03413456f, 0.02891121f, -0.01140047f, 0.15843679f, -0.04392643f, 
    -0.00889955f, -0.05094824f, -0.11684661f, 0.15257803f, -0.05601899f, -0.16258861f, -0.01370703f, -0.08707431f, 
    -0.24352980f, 0.22612196f, 0.15405533f, 0.21666938f, 0.14466977f, 0.19980028f, 0.08271234f, 0.06978227f, 
    -0.00864015f, 0.13022988f, 0.01145214f, 0.05759143f, 0.09314285f, -0.02242423f, 0.05210174f, 0.03662373f, 
    -0.01223861f, 0.10644889f, 0.09584249f, -0.08750190f, -0.20657729f, 0.08953260f, -0.01321227f, -0.13541371f, 
    0.13957369f, -0.06747674f, -0.00789239f, 0.03824078f, 0.04834543f, -0.01351071f, -0.01844367f, 0.07479160f, 
    -0.02092150f, -0.11813236f, -0.09530336f, 0.02754250f, 0.04600932f, -0.06208321f, 0.03874450f, -0.12055011f, 
    0.49445575f, -0.32053411f, 0.15101685f, 0.05225619f, -0.14930330f, -0.07635758f, -0.02502347f, 0.01304736f, 
    -0.02599969f, -0.06427769f, 0.18254200f, 0.01113704f, 0.02286074f, -0.05209560f, 0.09763414f, 0.06721218f, 
    -0.10398745f, 0.03102876f, -0.01233242f, 0.06839649f, 0.44591272f, 0.01231608f, 0.18128058f, -0.10686316f, 
    -0.19618882f, 0.01029616f, -0.00230214f, 0.06533537f, -0.02100655f, 0.23475446f, 0.07339320f, -0.08400860f, 
    -0.06744783f, -0.11028007f, 0.00244704f, -0.04349189f, -0.02401985f, 0.04804655f, -0.04026233f, 0.05283905f, 
    0.14285515f, 0.16226879f, 0.20624383f, -0.27397397f, -0.19090047f, 0.14282458f, -0.06549159f, 0.06959265f, 
    -0.18541926f, -0.02323194f, 0.02348311f, -0.02653259f, 0.06172480f, 0.05385273f, -0.05743418f, -0.07360330f, 
    0.05455540f, -0.10352737f, -0.04552048f, -0.10656054f, -0.43699530f, 0.14995220f, 0.07102560f, -0.04525304f, 
    0.01219706f, 0.03405802f, 0.08455282f, 0.04155347f, -0.00996898f, 0.08581571f, -0.14181180f, -0.04111633f, 
    0.06908981f, -0.07326841f, -0.15516764f, 0.04282705f, 0.09939013f, 0.04421010f, 0.04779987f, -0.01245206f, 
    -0.04423115f, 0.41825110f, 0.10898715f, 0.19547853f, 0.17131083f, 0.07943828f, 0.15355919f, -0.06778060f, 
    0.14560252f, 0.06274718f, -0.03746750f, 0.08293086f, -0.01289242f, 0.01845255f, -0.00989474f, -0.04693171f, 
    0.11891855f, 0.09752652f, 0.09556978f, -0.15889360f, 0.14664219f, -0.06290071f, 0.02858792f, 0.04456864f, 
    0.37075722f, 0.08753645f, 0.04797070f, 0.03022739f, 0.06405070f, 0.08692648f, 0.02079215f, -0.01823702f, 
    0.13575338f, 0.02263120f, 0.10445227f, -0.00665017f, 0.08135866f, 0.04095210f, -0.02644710f, 0.04052884f, 
    -0.23779400f, -0.30001065f, 0.09383024f, 0.04532496f, -0.11578712f, -0.17507637f, 0.01883233f, -0.13744654f, 
    -0.10945371f, -0.02166547f, -0.13784511f, -0.13354054f, -0.04021641f, 0.05707824f, 0.23162319f, 0.05135535f, 
    -0.10056651f, -0.00595760f, 0.06277519f, 0.03034505f, 0.09964761f, -0.00599626f, -0.06284685f, 0.22715780f, 
    0.10241958f, 0.04233609f, -0.02331702f, -0.03564669f, 0.04096370f, 0.00512045f, 0.08648621f, 0.02569803f, 
    0.11066512f, 0.03882194f, -0.01312944f, 0.12116260f, -0.06728241f, 0.02622135f, 0.10214755f, 0.00077987f, 
    -0.03285885f, -0.04351079f, -0.04782857f, 0.04799566f, 0.24856962f, 0.01703137f, -0.10534342f, 0.00511644f, 
    -0.06722271f, 0.04545854f, -0.04920188f, 0.04471528f, -0.01201889f, 0.00855105f, 0.09540607f, -0.16815042f, 
    -0.15319172f, 0.00097838f, 0.05216810f, 0.00786282f, 0.22575969f, 0.04117111f, 0.15195638f, -0.01760849f, 
    -0.06994856f, 0.22636607f, 0.05683622f, 0.08797880f, 0.01797612f, -0.02317001f, -0.03782405f, -0.01169117f, 
    -0.07917940f, 0.05231951f, 0.03090625f, -0.04936276f, -0.02886762f, -0.09309187f, 0.00139515f, -0.12460663f, 
    0.31588215f, -0.14240956f, -0.02878577f, 0.03678075f, -0.12973791f, -0.09327523f, -0.13889776f, -0.09753291f, 
    0.06287728f, -0.16290626f, 0.07745232f, -0.07545014f, 0.02661051f, 0.06500858f, -0.01840057f, -0.01890013f, 
    0.15138040f, 0.00277666f, -0.08734778f, 0.11398447f, -0.02106135f, -0.00182451f, 0.00973347f, 0.11690925f, 
    -0.11125533f, -0.02637711f, 0.11821053f, -0.07097341f, -0.04589612f, -0.01216208f, -0.02472339f, -0.01402261f, 
    -0.05126882f, 0.15002470f, -0.04487002f, -0.04755205f, 0.03788166f, -0.09258070f, -0.00665356f, 0.05881459f, 
    0.04701714f, -0.13967249f, 0.12588893f, 0.02209161f, 0.13592206f, -0.07511374f, -0.13334948f, -0.10243797f, 
    0.15779535f, -0.12072741f, 0.04419916f, -0.00399615f, 0.04438037f, -0.12825064f, -0.10488057f, -0.15775794f, 
    -0.03585638f, 0.04963280f, 0.02372994f, 0.00516110f, -0.62111372f, -0.00164350f, 0.01000809f, -0.13412839f, 
    -0.09300028f, -0.13867268f, 0.00673297f, -0.07597423f, -0.01485318f, 0.00400363f, -0.12009914f, 0.01486888f, 
    0.09640504f, 0.01672679f, 0.14088777f, -0.09193665f, -0.00284606f, -0.00558754f, -0.02979797f, 0.04722128f, 
    0.14481896f, 0.06731390f, 0.18060379f, -0.10439687f, 0.22667497f, -0.25210083f, -0.06986956f, 0.00785788f, 
    0.04310878f, -0.19878042f, -0.11448909f, 0.02476957f, -0.05976503f, -0.01309938f, -0.00229554f, 0.02997921f, 
    0.01154462f, 0.03186546f, 0.07559696f, -0.08723876f, 0.17324556f, 0.12788679f, 0.21287370f, -0.18248436f, 
    -0.17143314f, 0.00082959f, 0.01485211f, 0.01515515f, 0.09233057f, -0.14556731f, -0.05486340f, -0.05025406f, 
    -0.01959886f, 0.12716724f, 0.02313499f, -0.06670772f, 0.00824535f, 0.02697199f, 0.08132779f, 0.01195312f, 
    -0.23823778f, -0.00781882f, -0.12136017f, -0.00403568f, -0.16889052f, -0.02650130f, 0.16872413f, -0.00331593f, 
    0.09093481f, -0.08766343f, -0.03683932f, 0.02099746f, 0.05690617f, 0.04360812f, 0.06684159f, -0.18896662f, 
    0.07337109f, 0.00819993f, 0.13411930f, 0.04119988f, -0.49109611f, -0.08657685f, -0.27246189f, -0.20289010f, 
    -0.05171110f, 0.04753179f, 0.09043175f, 0.01815144f, 0.03244447f, 0.01218189f, -0.02841952f, 0.05236419f, 
    0.23955664f, 0.02314854f, 0.07442867f, -0.05871570f, 0.06396329f, 0.07585062f, -0.04813943f, 0.16129029f, 
    -0.22225617f, -0.00728735f, -0.19932713f, 0.05803991f, 0.21298636f, 0.05999478f, -0.07774226f, 0.15776607f, 
    0.07241414f, 0.06772158f, 0.22457692f, -0.04930362f, 0.04229168f, -0.03081035f, -0.13574131f, 0.08741826f, 
    0.00328509f, 0.14832045f, 0.17589718f, 0.08974408f, -0.04550086f, 0.13268656f, 0.23057415f, 0.04165486f, 
    0.08486906f, -0.12706244f, -0.08865718f, 0.06768212f, 0.02499242f, -0.02138346f, 0.05452001f, -0.07667629f, 
    0.08388905f, -0.01747749f, -0.00411880f, 0.03211961f, -0.04101601f, -0.03304385f, -0.00085270f, 0.10943834f, 
    0.41073173f, 0.01587601f, -0.03077326f, 0.14648853f, 0.03136593f, 0.07704210f, -0.00034312f, 0.18803439f, 
    -0.07082029f, -0.03937276f, 0.03549371f, 0.10459480f, -0.06921086f, -0.09295217f, -0.21376295f, -0.03762968f, 
    0.08488788f, 0.01075859f, 0.00344253f, 0.04878041f, 0.09677543f, 0.22351320f, 0.02118325f, 0.08287998f, 
    0.42134455f, -0.09233588f, 0.03399892f, -0.10541450f, 0.01959822f, 0.04637433f, -0.07889576f, 0.05323601f, 
    0.00056411f, -0.03547459f, 0.09522877f, 0.04252907f, 0.05060918f, -0.03136235f, -0.02920596f, -0.03004402f, 
    0.38808569f, 0.16673949f, -0.22134319f, 0.42320266f, 0.00599550f, 0.01447453f, 0.00466985f, 0.05194980f, 
    0.15539330f, -0.04139151f, -0.05713021f, 0.09450702f, -0.11325862f, -0.02454581f, -0.07280321f, 0.12173193f, 
    0.07215629f, 0.11136049f, 0.05426160f, 0.08563776f, -0.02540784f, 0.05586104f, -0.12029655f, -0.12926817f, 
    -0.09404449f, -0.10751770f, -0.10770722f, -0.20885374f, -0.04254737f, 0.16252384f, 0.08630945f, -0.01130974f, 
    -0.01833874f, -0.09862114f, -0.18315424f, -0.03544484f, -0.03026200f, 0.00231681f, 0.03749249f, 0.05331588f, 
    0.35194585f, 0.26451471f, 0.07165385f, -0.03826317f, 0.00396149f, -0.15807405f, 0.08293211f, -0.13596471f, 
    0.02543691f, 0.04371176f, 0.11801931f, -0.01527369f, 0.07859888f, -0.04916000f, -0.07205015f, 0.01740242f, 
    0.17107338f, 0.06841174f, -0.04015397f, 0.08251171f, -0.23930468f, 0.04957620f, 0.19267224f, 0.03929749f, 
    -0.02994675f, -0.03733463f, -0.02301456f, -0.01852532f, 0.13831596f, 0.09307222f, 0.08660265f, -0.03244901f, 
    -0.02463564f, 0.04184933f, -0.06770322f, -0.01136852f, -0.00823179f, 0.20083387f, 0.17544731f, 0.06002698f, 
    -0.06049793f, 0.18076092f, 0.15720800f, 0.38614899f, 0.11691988f, 0.12004594f, 0.04332617f, 0.08608863f, 
    0.05750050f, 0.00814972f, -0.21929774f, 0.19055749f, -0.06458823f, 0.13271697f, -0.05703774f, 0.04920359f, 
    -0.05697018f, 0.06224345f, -0.05302579f, -0.02323146f, -0.23242065f, -0.12599181f, 0.03006474f, -0.00067994f, 
    -0.39746034f, 0.00244925f, 0.05344834f, -0.05094999f, 0.01346493f, -0.05615787f, 0.13133977f, 0.08030358f, 
    -0.06577066f, -0.08380131f, 0.04435132f, -0.12142368f, -0.11795541f, 0.02376429f, 0.12891158f, 0.08658540f, 
    -0.30094787f, -0.28945488f, 0.15587558f, 0.15486309f, -0.49592206f, 0.00406546f, 0.11389045f, 0.09348474f, 
    -0.01737468f, -0.02882232f, -0.04942261f, 0.04927891f, 0.00631047f, -0.01490379f, 0.09551257f, 0.05592402f, 
    0.07160168f, 0.19751662f, -0.02778717f, 0.01232142f, 0.02081654f, -0.01144151f, 0.06816564f, 0.20657669f, 
    0.07284427f, -0.15904586f, 0.07905282f, 0.02805473f, -0.07096208f, 0.06214636f, -0.12437215f, 0.01421794f, 
    -0.05963391f, -0.04026363f, 0.06880743f, -0.05925597f, -0.05058742f, 0.09402218f, 0.02378470f, -0.11001804f, 
    0.17026773f, 0.01782857f, -0.33754942f, -0.42884615f, -0.15702519f, 0.07044913f, 0.12330183f, -0.09493305f, 
    -0.05522733f, -0.19782968f, 0.06296892f, 0.07660227f, -0.03804879f, -0.01898069f, -0.04637256f, 0.02759362f, 
    0.11426437f, 0.04948115f, 0.07213641f, 0.12413076f, 0.09865203f, 0.12231743f, -0.11633611f, -0.00897224f, 
    -0.12430291f, 0.01184720f, -0.05456257f, 0.01651521f, 0.04471707f, -0.12112121f, 0.03964132f, -0.01696524f, 
    0.11958187f, 0.01189625f, 0.00447285f, -0.02658179f, -0.14679229f, 0.00312151f, -0.14853060f, 0.00608719f, 
    0.13274282f, 0.55787963f, -0.18783490f, 0.11641566f, 0.12005033f, -0.00830601f, -0.01333262f, -0.05689932f, 
    0.17608790f, 0.05385652f, -0.04637683f, -0.07328028f, -0.04168878f, -0.00995824f, -0.03447480f, -0.19109838f, 
    -0.01098178f, -0.05685436f, 0.07193060f, -0.04995675f, -0.04795698f, 0.41875535f, -0.10333750f, -0.04368629f, 
    0.29797775f, -0.00800681f, 0.13434154f, -0.13916606f, 0.09835155f, -0.04088968f, -0.06773533f, -0.00743263f, 
    0.02263009f, 0.13828416f, -0.04945781f, 0.05947480f, -0.02649238f, -0.00478927f, 0.07999253f, -0.02234041f, 
    0.47699237f, 0.00877346f, -0.12269732f, 0.25309750f, 0.38022733f, -0.21146667f, 0.00743872f, -0.11354656f, 
    -0.00319458f, 0.04359575f, 0.05359360f, 0.09801689f, -0.03329135f, -0.00305465f, -0.00839567f, -0.08958656f, 
    0.00439910f, 0.02007714f, 0.05898679f, 0.00494309f, 0.20758818f, 0.05785248f, 0.02972396f, -0.06620535f, 
    -0.11059549f, 0.06301788f, 0.03488550f, -0.01219494f, -0.05557305f, -0.07667124f, 0.15044020f, 0.02009650f, 
    0.10686833f, 0.01898103f, 0.18561609f, -0.01942733f, 0.00211594f, -0.09963829f, -0.10765123f, 0.02618413f, 
    -0.39812571f, 0.10218541f, 0.00829689f, -0.29503515f, -0.13217561f, 0.21278475f, -0.00229564f, 0.19030336f, 
    -0.10634046f, -0.05609503f, 0.14811456f, -0.01857523f, -0.06290438f, 0.06408844f, -0.03502431f, 0.12373331f, 
    -0.07503200f, 0.06055013f, -0.01763793f, 0.19827408f, -0.18189159f, 0.09115239f, -0.22864847f, -0.03760714f, 
    0.09349226f, -0.05668802f, 0.01397252f, -0.01982325f, 0.01711772f, -0.01350601f, -0.08883730f, -0.09831569f, 
    -0.07571758f, -0.00624786f, 0.15627711f, -0.03528391f, 0.05372859f, 0.11391808f, -0.02846339f, 0.01338948f, 
    0.50157410f, -0.07275144f, -0.14116168f, 0.29325971f, 0.08544043f, -0.00501581f, 0.00670116f, 0.10032176f, 
    0.07948117f, 0.05644293f, 0.08785351f, 0.08272557f, -0.05674306f, 0.04416071f, -0.06194509f, 0.06734819f, 
    0.00488727f, 0.00202151f, 0.02982291f, 0.02644758f, -0.15092425f, -0.06619460f, 0.13720512f, -0.19812943f, 
    0.14200081f, -0.01854718f, -0.14757828f, 0.06422485f, 0.02937560f, 0.14429869f, 0.02839071f, -0.00793412f, 
    0.04179718f, 0.08611313f, -0.05947099f, -0.07569966f, -0.07157237f, -0.00247332f, -0.06507599f, -0.07251081f, 
    -0.19619586f, -0.27424061f, 0.10918473f, -0.00132896f, -0.11479831f, -0.00920880f, 0.00375346f, -0.02965510f, 
    0.03007942f, -0.01944097f, 0.05161229f, 0.04230183f, 0.11125501f, 0.01652893f, -0.03434512f, -0.00201318f, 
    0.02932669f, 0.00585009f, -0.16966663f, -0.04554830f, -0.25135562f, -0.11798224f, 0.02443007f, 0.08264897f, 
    0.08757821f, -0.09611767f, -0.10364887f, -0.13556238f, 0.13960984f, 0.08240210f, 0.19422211f, 0.00027576f, 
    0.07451816f, -0.09550677f, -0.04322523f, 0.07328395f, 0.07462750f, 0.07402238f, -0.07435766f, 0.00594267f, 
    0.10921995f, 0.41324395f, -0.00372158f, -0.06047572f, 0.22208378f, 0.04091239f, 0.05319120f, -0.04976880f, 
    0.13619937f, 0.23321685f, 0.02725650f, 0.07579834f, 0.04153537f, 0.02516491f, -0.00111294f, -0.02044792f, 
    0.04739692f, -0.03809876f, 0.13221493f, -0.08306305f, 0.29617628f, 0.21277876f, 0.12896864f, 0.21990830f, 
    -0.05165830f, -0.04325622f, -0.18113908f, 0.09886977f, 0.00737718f, -0.04597164f, -0.04878101f, -0.03562048f, 
    0.06560721f, -0.08452383f, -0.04161258f, 0.05725129f, 0.02832284f, 0.07773551f, 0.02883257f, -0.03753961f, 
    0.09752715f, 0.38532865f, -0.17530005f, -0.06565558f, -0.08845606f, 0.15268569f, 0.01168544f, 0.05647244f, 
    -0.08423957f, -0.00380570f, 0.02726223f, 0.03523669f, -0.00964013f, 0.00198300f, -0.07756817f, 0.02385033f, 
    -0.01717881f, -0.06585009f, -0.10852929f, -0.08489962f, 0.12460354f, -0.32194063f, -0.05313489f, -0.07659467f, 
    -0.35047168f, 0.05942607f, 0.07791790f, 0.12456431f, 0.04984020f, -0.06800043f, 0.16700561f, 0.06948515f, 
    -0.04458206f, -0.01411546f, -0.10879277f, 0.16978666f, 0.05502308f, 0.01876706f, 0.08680047f, 0.07185774f, 
    0.16143225f, 0.10501770f, -0.13269943f, 0.15261905f, -0.29942289f, 0.19395389f, 0.16194159f, 0.10509291f, 
    -0.13753985f, 0.11806905f, -0.04672917f, -0.02406574f, 0.07625505f, 0.01194024f, 0.00859743f, -0.04504540f, 
    -0.02919965f, 0.04472524f, 0.00729221f, 0.06019545f, -0.34308565f, 0.15157536f, 0.02081151f, 0.10959410f, 
    0.21664578f, -0.04270080f, -0.07900710f, -0.02019928f, 0.11202718f, 0.15739083f, -0.03729814f, -0.10105699f, 
    -0.06491893f, -0.14793031f, -0.02954140f, -0.00708377f, 0.01965231f, -0.15925385f, -0.00474739f, -0.18480176f, 
    0.17640051f, -0.24544689f, 0.10386267f, -0.04905127f, -0.05884760f, -0.12311256f, 0.01279263f, 0.01543805f, 
    0.01497372f, 0.02935654f, 0.08042967f, 0.09335526f, 0.07869493f, -0.00880683f, 0.18745673f, -0.03043426f, 
    -0.06209225f, 0.07826769f, -0.06501276f, 0.10069397f, 0.27660498f, -0.13661817f, 0.11463588f, 0.03725248f, 
    -0.00071689f, -0.03798844f, 0.07848529f, -0.00370187f, -0.03461051f, 0.02816628f, 0.05955151f, -0.03117140f, 
    -0.08408917f, 0.00632567f, -0.05881738f, 0.07097517f, -0.07174394f, 0.08084997f, -0.06867795f, 0.00787351f, 
    -0.07938839f, -0.00577827f, 0.22798407f, -0.15827093f, 0.04732235f, 0.02520783f, -0.02436747f, 0.00119102f, 
    -0.03435259f, -0.02928349f, 0.00009239f, 0.06319889f, -0.06261516f, 0.08794376f, 0.03273952f, -0.07976939f, 
    0.01950542f, -0.16282198f, -0.08730251f, -0.00864117f, -0.17371503f, 0.12408530f, -0.24261050f, 0.20425794f, 
    -0.06437553f, 0.12663876f, 0.07507787f, 0.02271966f, 0.06747059f, 0.05973878f, -0.13410784f, 0.05482871f, 
    -0.03265410f, -0.08558522f, -0.10393000f, 0.01060195f, 0.13851479f, -0.07738166f, 0.03745684f, -0.17093655f, 
    0.04027553f, 0.04747266f, -0.11309215f, 0.23549491f, -0.13495915f, 0.03179062f, 0.11233900f, -0.05995372f, 
    0.11507592f, -0.08962105f, -0.10830704f, 0.11028964f, -0.02965781f, -0.07807577f, 0.03704256f, 0.02392467f, 
    0.02785529f, 0.04426245f, -0.00660365f, -0.10631220f, 0.08117590f, 0.16529359f, 0.02031142f, 0.13778356f, 
    0.13232677f, 0.02561842f, 0.02862113f, -0.00891654f, 0.07054409f, 0.06555712f, -0.00542142f, -0.02466037f, 
    0.20064810f, 0.02140542f, -0.03019988f, -0.00340699f, 0.05315869f, -0.06003372f, 0.03361720f, -0.10295854f, 
    -0.02739711f, -0.10470892f, 0.03881364f, 0.00170754f, 0.03150746f, -0.12630534f, 0.00381893f, 0.06895918f, 
    -0.09254592f, 0.14427352f, -0.02585421f, -0.21720822f, -0.01364387f, 0.01271593f, 0.10353394f, 0.04770003f, 
    0.00255943f, -0.04446981f, -0.00194141f, -0.04908455f, 0.27742502f, -0.02383485f, 0.09599133f, 0.25159541f, 
    0.23984635f, 0.03336568f, 0.08617438f, 0.01988871f, 0.01306516f, 0.03511364f, -0.06635968f, 0.09119993f, 
    0.04075767f, 0.04040410f, 0.07073580f, -0.02493529f, 0.07851370f, -0.01283504f, -0.00078465f, -0.02880744f, 
    -0.22421980f, 0.08000940f, 0.06687145f, 0.06698077f, 0.27282339f, -0.00789181f, -0.05454131f, 0.07864869f, 
    0.10236572f, 0.09659346f, -0.06132836f, 0.01010137f, 0.01336677f, -0.00946242f, 0.06233103f, 0.03553946f, 
    -0.07927874f, -0.04169155f, 0.03017139f, 0.10087296f, 0.05587023f, -0.13118476f, 0.13311580f, -0.13609990f, 
    -0.22695941f, 0.13247228f, -0.05594849f, -0.01245400f, 0.06587056f, -0.04663397f, -0.04267346f, 0.03632711f, 
    -0.13754424f, -0.10431407f, 0.12066928f, 0.05679967f, 0.09913900f, -0.06840626f, -0.00354505f, 0.08211503f, 
    0.36789507f, -0.08801071f, -0.03917580f, -0.15447851f, 0.12553136f, -0.10619228f, -0.01067702f, -0.07253968f, 
    0.18587092f, -0.03272463f, 0.08071653f, -0.20882152f, 0.01835475f, 0.11071179f, 0.01908564f, -0.02661831f, 
    0.12584533f, -0.10731757f, -0.06412430f, 0.04368589f, -0.04153290f, -0.30981696f, 0.09631600f, 0.03588145f, 
    -0.03821874f, -0.05246510f, 0.10933132f, -0.08160599f, -0.01373780f, -0.03333004f, 0.03189044f, -0.00836569f, 
    0.11390933f, 0.07873868f, -0.03116765f, 0.01700899f, 0.02499810f, 0.06898895f, -0.10854508f, 0.07125103f, 
    -0.04055245f, -0.04751234f, 0.04461756f, 0.00648585f, 0.04302353f, 0.03525981f, 0.03399786f, -0.02425761f, 
    -0.04907615f, -0.02153284f, -0.00265231f, -0.04465418f, 0.02289732f, -0.02993428f, -0.01143076f, 0.00068620f, 
    -0.00454239f, 0.02779882f, -0.00534327f, -0.05742332f, -0.01233794f, 0.03822168f, -0.02471894f, -0.00198719f, 
    -0.01828024f, 0.01818350f, 0.00637233f, 0.05176492f, -0.05126524f, -0.04292852f, -0.01320338f, 0.02387233f, 
    -0.01905120f, 0.03961335f, 0.02452091f, 0.00093516f, -0.03082702f, -0.02090131f, 0.04831138f, -0.00933830f, 
    -0.03182947f, -0.00630439f, -0.04801071f, -0.04275701f, 0.00273128f, -0.01632789f, -0.00664991f, -0.01286311f, 
    0.04616633f, -0.06035282f, -0.00514996f, -0.01129495f, -0.02711803f, -0.04720419f, 0.04187448f, -0.04619659f, 
    0.03510039f, -0.00296275f, 0.02248496f, -0.05443578f, -0.02423031f, -0.00237896f, -0.04138408f, 0.00672334f, 
    0.02166731f, -0.00853446f, -0.01566418f, 0.02111956f, -0.05606208f, 0.04823980f, 0.01159419f, 0.04891520f, 
    -0.02521022f, -0.03910737f, 0.04045722f, 0.01684282f, -0.03670682f, 0.00323066f, -0.05961507f, 0.03910329f, 
    -0.00906736f, 0.00635773f, -0.00183372f, 0.00528263f, -0.05106030f, -0.03854268f, -0.00426111f, -0.02414291f, 
    -0.05651493f, -0.01683394f, -0.01821077f, -0.05238000f, 0.00861692f, -0.03071571f, 0.00878085f, 0.05294249f, 
    -0.02858778f, 0.04903034f, -0.04976383f, 0.00968428f, 0.05358771f, 0.01812490f, -0.04208870f, -0.05613824f, 
    -0.02810265f, 0.00467537f, 0.01874221f, -0.00198970f, -0.04892080f, -0.01851691f, 0.04728202f, -0.00828066f, 
    -0.02686598f, -0.04996394f, 0.05160272f, 0.03620867f, 0.01746864f, 0.03884762f, -0.03031483f, -0.02587396f, 
    -0.01737554f, -0.03450200f, 0.02034836f, 0.01900086f, 0.04216013f, -0.04314763f, -0.00883739f, -0.00682677f, 
    0.01596322f, 0.03192406f, 0.00369367f, 0.01520133f, -0.01849108f, 0.02562906f, 0.00749665f, 0.00413912f, 
    -0.01694841f, 0.03227264f, -0.05025313f, 0.02247815f, -0.03944632f, 0.04445704f, 0.02646636f, 0.04065625f, 
    -0.01699881f, -0.05590706f, -0.02828738f, -0.01353023f, 0.03216400f, 0.02802357f, 0.00897382f, -0.04373004f, 
    -0.02697660f, -0.05064079f, -0.02593489f, 0.00909283f, 0.04866124f, 0.02644122f, -0.04684759f, -0.03784204f, 
    0.02366071f, 0.00443095f, -0.01157542f, -0.03954872f, 0.01539091f, -0.00653141f, -0.03288388f, 0.01752717f, 
    0.03631889f, -0.05082470f, -0.04721352f, -0.03482481f, -0.05157423f, 0.03428791f, 0.03769250f, 0.02723729f, 
    0.05413658f, -0.04754406f, -0.04269554f, 0.04816534f, 0.01056735f, -0.05141842f, -0.03502940f, -0.02467943f, 
    0.02388255f, -0.04407224f, 0.03189487f, 0.01273623f, -0.00971356f, 0.01116869f, -0.02920156f, -0.00983704f, 
    0.04082580f, 0.04416776f, 0.02167461f, -0.02361322f, 0.02201196f, -0.01220164f, 0.00292246f, 0.01961436f, 
    0.02062266f, 0.00916627f, 0.04305375f, 0.03101319f, -0.05375770f, 0.03075745f, -0.05065800f, -0.00002599f, 
    -0.04349795f, -0.05503280f, 0.04440425f, -0.04755275f, 0.02180654f, -0.03501130f, -0.00160491f, 0.03800051f, 
    -0.05621239f, 0.01008359f, 0.01429466f, 0.02861127f, 0.00055164f, -0.02066515f, 0.03135173f, -0.04946126f, 
    -0.04379072f, -0.01905113f, 0.03666928f, 0.02166367f, -0.01893092f, 0.00743040f, 0.04085603f, 0.04592405f, 
    -0.03553526f, 0.01256402f, 0.02026255f, 0.00686027f, 0.03758605f, -0.03245751f, 0.02285316f, 0.02796800f, 
    -0.04110704f, -0.03978711f, 0.01433310f, -0.01526758f, -0.05929916f, -0.00776420f, -0.04064328f, -0.05635224f, 
    -0.02193858f, -0.00222965f, -0.01465348f, 0.04480952f, -0.01548128f, 0.03613892f, -0.02753722f, 0.00489644f, 
    -0.04949209f, -0.01326366f, -0.03673189f, -0.01392395f, -0.02279339f, -0.01273428f, -0.01865534f, -0.01071890f, 
    0.02459600f, 0.01511418f, -0.01359638f, 0.01274387f, -0.05181849f, 0.00517085f, -0.06238490f, -0.02253986f, 
    0.00001765f, 0.04284544f, 0.01317629f, 0.04362926f, 0.04477860f, 0.01928328f, 0.00135602f, -0.00767566f, 
    0.05041363f, -0.06126335f, 0.01712161f, -0.05722094f, 0.00834171f, 0.00199727f, -0.05920816f, -0.05922132f, 
    0.03214275f, -0.00750701f, 0.04687767f, 0.03566021f, -0.01590656f, 0.05317789f, -0.02297870f, -0.05044120f, 
    0.02161700f, 0.01859118f, -0.01681088f, 0.00330977f, 0.00319669f, 0.04423437f, -0.03313614f, -0.04083024f, 
    -0.04123856f, 0.02157835f, -0.02455086f, 0.05255909f, -0.05186281f, -0.01803583f, 0.02405642f, -0.03386603f, 
    -0.00468416f, 0.04474908f, 0.03442630f, -0.05784622f, -0.00799323f, 0.01902135f, -0.05533965f, 0.04493406f, 
    -0.00825111f, 0.01544322f, -0.05192046f, 0.04351519f, -0.01489310f, -0.04927136f, 0.02250211f, 0.01166715f, 
    0.00747968f, 0.03900237f, -0.02156963f, 0.00446139f, -0.00925100f, -0.04872364f, 0.01724189f, -0.04439202f, 
    0.00645998f, 0.00420358f, -0.05625841f, 0.03826395f, -0.01257045f, 0.01693449f, -0.05891236f, 0.03435015f, 
    0.00162135f, -0.04769745f, -0.02533037f, -0.06393331f, 0.03159312f, -0.04457246f, -0.02785586f, 0.02927441f, 
    -0.05997463f, -0.06121498f, -0.01588280f, 0.01995564f, -0.06461964f, -0.01904622f, -0.05155187f, -0.04617756f, 
    0.04695042f, -0.01616630f, 0.02663463f, -0.04040175f, -0.01416665f, -0.02916796f, 0.04434373f, -0.03619406f, 
    0.01912097f, -0.00799019f, 0.03041856f, -0.05898767f, 0.03124711f, -0.04155650f, -0.05657220f, -0.05398704f, 
    0.02504857f, 0.04791201f, -0.02907113f, -0.04646465f, -0.05507114f, -0.00050806f, -0.05170653f, -0.01161504f, 
    -0.05664155f, -0.02320033f, 0.03790827f, -0.02587481f, 0.03173383f, 0.02228095f, 0.02255776f, -0.03489342f, 
    0.02338878f, -0.01031351f, -0.03631750f, -0.04056393f, -0.03312666f, -0.02479610f, -0.04208101f, -0.00790227f, 
    0.02957717f, 0.04432290f, -0.06149118f, 0.01499617f, -0.06095172f, 0.01111035f, -0.06243445f, -0.01096386f, 
    -0.03162180f, -0.05191298f, -0.00978641f, 0.00422624f, 0.01073276f, -0.04845417f, -0.04657587f, -0.03582040f, 
    0.00078597f, -0.04906586f, -0.03503888f, -0.06095726f, 0.03741909f, 0.00166513f, -0.05856004f, 0.01775704f, 
    0.00973610f, -0.03906079f, -0.05751476f, -0.00630577f, 0.03617314f, -0.01457886f, 0.01802146f, -0.03475977f, 
    -0.01796274f, 0.04442517f, -0.03840870f, -0.03788168f, 0.01457045f, 0.03152257f, 0.02750315f, 0.01011720f, 
    -0.02403095f, -0.01066535f, -0.03431345f, 0.03668749f, 0.01002039f, -0.01000680f, -0.03015244f, 0.00284827f, 
    0.04589610f, -0.00686441f, -0.02807210f, -0.01324654f, -0.03779171f, -0.04189181f, 0.02150623f, -0.02699073f, 
    0.02943657f, -0.00785612f, 0.01903787f, 0.02028777f, 0.01957661f, 0.03282520f, 0.01675268f, 0.04383275f, 
    0.04504490f, -0.00320744f, 0.04595683f, 0.03275146f, 0.03655457f, -0.01015136f, -0.01788966f, -0.03469153f, 
    -0.01867047f, -0.04614668f, -0.01296527f, -0.01428162f, 0.01157267f, -0.03320603f, -0.03422115f, -0.00745941f, 
    -0.00758904f, 0.03812624f, -0.02967182f, 0.04475945f, 0.02494846f, -0.02728251f, 0.02877836f, -0.03050611f, 
    0.00557014f, -0.01204414f, -0.00005578f, -0.04905454f, -0.03489765f, 0.00677291f, 0.00879344f, 0.00941604f, 
    0.03304658f, -0.01895247f, 0.01373321f, 0.03258716f, 0.01284924f, -0.05643655f, -0.04353251f, 0.02735261f, 
    -0.01260540f, 0.01100423f, 0.04613485f, 0.03529033f, -0.03617899f, -0.05132217f, -0.00190959f, -0.00198112f, 
    0.03739255f, -0.04062561f, 0.00370879f, -0.01655612f, 0.05081510f, -0.02306341f, 0.02896138f, -0.02792309f, 
    -0.02111783f, 0.02690671f, -0.01256996f, 0.02251652f, -0.06469635f, -0.01568340f, -0.02292312f, -0.01684652f, 
    -0.03638313f, -0.00474032f, -0.04314671f, -0.04195786f, -0.05964021f, 0.00229854f, -0.02929195f, -0.02257514f, 
    0.01583504f, 0.03166697f, 0.01785994f, -0.03473535f, -0.01001625f, -0.01813853f, -0.02373896f, 0.00003186f, 
    -0.01707289f, 0.03137450f, 0.03009364f, 0.04079188f, 0.02116740f, 0.04847177f, -0.02567806f, 0.01227172f, 
    0.04538714f, -0.04570942f, -0.03189282f, -0.05690799f, -0.02023657f, 0.04257052f, -0.00462181f, 0.00131219f, 
    -0.01458205f, -0.01475963f, -0.00129225f, 0.01115943f, -0.04683220f, 0.03784673f, -0.01734467f, 0.04454304f, 
    -0.04132590f, -0.01645517f, -0.03687036f, -0.01755767f, -0.06399178f, -0.03196574f, -0.04150276f, 0.01742309f, 
    0.02885977f, -0.00659005f, 0.00528462f, -0.01717504f, 0.01147818f, 0.01632633f, 0.02795391f, 0.03618240f, 
    0.03519319f, 0.03203374f, 0.04182214f, 0.01351606f, -0.05160053f, 0.00679306f, -0.04067309f, -0.05514153f, 
    0.04156382f, 0.04600976f, 0.04552108f, 0.00649655f, -0.01261663f, 0.00745647f, 0.00789998f, -0.04861791f, 
    0.00752954f, -0.05236422f, 0.03831838f, 0.01570880f, 0.04590785f, -0.05959220f, -0.01505001f, -0.01074237f, 
    -0.02219135f, -0.05399749f, 0.00104247f, -0.05955203f, 0.03330868f, 0.03178062f, -0.00573402f, -0.00710706f, 
    -0.02028286f, -0.05641833f, -0.04758209f, 0.03064830f, -0.04431714f, 0.04412428f, 0.03368100f, -0.06045720f, 
    -0.02877187f, -0.03190347f, 0.03000039f, -0.04265468f, 0.02670600f, 0.04735679f, 0.02696843f, 0.00552881f, 
    0.03376339f, 0.02332692f, -0.04519564f, -0.00078240f, -0.04085438f, 0.02692012f, -0.06252977f, 0.02681129f, 
    -0.20645574f, 0.27318177f, 0.20185563f, 0.02856089f, 0.18407659f, -0.11710704f, -0.01721818f, 0.00152500f, 
    0.06124948f, -0.15725300f, -0.00664764f, -0.06907434f, -0.01213180f, -0.07852878f, -0.08531768f, -0.03226369f, 
    -0.02417195f, 0.01089257f, 0.05272146f, -0.05598190f, 0.01285158f, 0.20280696f, 0.07209136f, -0.11858199f, 
    -0.17819893f, -0.07254199f, 0.01541720f, -0.12352867f, -0.09416195f, -0.04474432f, 0.04975588f, -0.03732310f, 
    0.02925446f, -0.08676113f, -0.11361178f, 0.08162282f, 0.04270682f, -0.02417346f, -0.04692368f, -0.07320285f, 
    -0.08555654f, 0.32912183f, 0.11473861f, 0.20164955f, 0.08528959f, 0.00164222f, -0.02526626f, 0.19491290f, 
    0.06039029f, 0.17394331f, -0.04423873f, -0.00817641f, -0.05732553f, -0.03233499f, 0.02047141f, 0.02873017f, 
    0.03196892f, 0.17830583f, 0.14161333f, 0.01535346f, -0.43854210f, 0.21810602f, -0.00351838f, -0.13464320f, 
    0.07300678f, -0.03612467f, -0.00081930f, -0.01816238f, -0.00986554f, 0.12213174f, 0.07360703f, 0.08325629f, 
    -0.06684139f, 0.11013482f, -0.01643381f, -0.01432562f, -0.04189791f, -0.07179281f, -0.03633973f, -0.10563312f, 
    0.03667949f, -0.13161200f, -0.05059864f, 0.10099824f, 0.52479380f, -0.06693586f, -0.03102765f, 0.01418770f, 
    0.06636673f, -0.10497818f, 0.08443910f, -0.06943306f, -0.07457019f, -0.00133398f, 0.10654733f, 0.12896302f, 
    -0.00866305f, 0.02820142f, 0.15451783f, 0.09398981f, 0.55215377f, -0.30293459f, -0.08089109f, -0.18580469f, 
    0.09635308f, -0.10514549f, 0.08098631f, -0.10157224f, -0.12070376f, 0.09484383f, -0.10695829f, -0.05652928f, 
    0.02092717f, 0.01471791f, 0.07665758f, -0.08205475f, -0.02829479f, 0.12447964f, 0.09649712f, 0.07174195f, 
    0.36294991f, 0.13180889f, -0.14920768f, -0.12124965f, 0.03638682f, -0.06057183f, -0.02495284f, -0.13296181f, 
    -0.10388523f, -0.11367347f, -0.11349764f, -0.06354579f, -0.00390346f, -0.00336495f, -0.01427229f, -0.07413350f, 
    -0.00062002f, -0.13055080f, 0.12924613f, -0.02338699f, -0.43768090f, 0.18801038f, 0.13463391f, -0.10518876f, 
    -0.04667732f, 0.08835009f, -0.02542620f, 0.06743639f, 0.02622394f, 0.02141959f, 0.01847342f, -0.15271924f, 
    0.04686469f, 0.04030901f, -0.03552761f, 0.06530076f, 0.03099015f, -0.04429166f, 0.10604564f, -0.05542938f, 
    -0.12037811f, 0.23138337f, 0.41432354f, 0.05817089f, 0.07269260f, -0.01030967f, 0.07703667f, 0.02334828f, 
    0.16312560f, 0.08171639f, -0.03863016f, -0.04288662f, -0.07893501f, -0.02885835f, 0.09903976f, -0.03209415f, 
    0.00492679f, 0.19489059f, 0.10784820f, -0.14680822f, -0.15942882f, -0.16111512f, 0.19397400f, 0.20998001f, 
    0.21744868f, 0.11079274f, 0.03113038f, -0.01820252f, -0.02847302f, -0.03695235f, -0.05502860f, 0.00682968f, 
    -0.03335989f, -0.08789023f, -0.01951418f, -0.01737293f, 0.03365768f, 0.08322378f, -0.15524457f, -0.05511965f, 
    -0.15216708f, -0.05176541f, -0.09919056f, 0.05681135f, -0.05132643f, 0.04256420f, -0.04727784f, -0.13754602f, 
    -0.08103735f, -0.11219484f, 0.01045755f, -0.00106128f, -0.01433451f, 0.02924178f, 0.20151253f, 0.01732230f, 
    0.01379788f, -0.00421371f, 0.08330856f, -0.03608160f, -0.00050142f, 0.18331073f, 0.21344167f, 0.17006257f, 
    -0.10015449f, -0.01664650f, 0.12080485f, -0.09536734f, 0.10656548f, 0.02632880f, 0.01208638f, 0.05524373f, 
    0.06641681f, -0.15766549f, -0.10007972f, 0.04861934f, -0.09849411f, 0.02772690f, -0.01404134f, 0.03483728f, 
    0.03114865f, -0.12529284f, 0.10643575f, 0.07614023f, 0.03143624f, 0.00444741f, -0.11561513f, -0.04229847f, 
    -0.03743452f, -0.05296281f, -0.05479188f, 0.07305977f, 0.05510693f, 0.00934807f, 0.05619439f, -0.09293979f, 
    -0.06103363f, 0.00040998f, -0.08681265f, -0.04215797f, 0.13963577f, 0.08651514f, -0.01757967f, -0.02666897f, 
    0.02321334f, 0.15830702f, -0.04445152f, 0.04992699f, 0.07723761f, -0.01681310f, -0.09651606f, -0.02308941f, 
    0.08587851f, 0.09188481f, -0.07450025f, 0.06085682f, -0.02342471f, -0.11014301f, -0.13274081f, -0.01856346f, 
    0.25605705f, 0.05677215f, -0.12428332f, -0.08664998f, 0.09609343f, 0.08799030f, -0.11165637f, -0.08014641f, 
    0.01240065f, 0.00359154f, 0.16620493f, -0.04312196f, 0.02463081f, 0.00007709f, 0.10306527f, 0.02229152f, 
    0.00038605f, -0.00207404f, -0.03100453f, 0.01059841f, -0.18235852f, 0.05410352f, -0.09679558f, 0.18996727f, 
    0.24260329f, 0.06595723f, 0.05513493f, -0.07300213f, -0.00454557f, -0.04505730f, -0.05250707f, -0.03179926f, 
    0.06414649f, 0.00768360f, -0.10129592f, -0.00577937f, 0.11084063f, -0.03166979f, 0.11820168f, -0.00069602f, 
    0.00871826f, 0.01985445f, 0.01732355f, -0.06029490f, -0.00172982f, 0.02666803f, 0.02685217f, 0.02430641f, 
    0.02562544f, -0.04089773f, -0.03759682f, 0.01591148f, -0.05418221f, 0.01700708f, 0.01156434f, 0.04367250f, 
    -0.02072420f, 0.02119743f, 0.02421582f, 0.01317741f, -0.02523779f, 0.00798782f, 0.02705337f, 0.01198926f, 
    -0.00977909f, -0.02383209f, -0.02648690f, 0.03829894f, -0.00266297f, 0.04946797f, 0.04772507f, -0.04147818f, 
    -0.00095173f, 0.02930996f, 0.02284637f, -0.05545232f, 0.04333688f, -0.01953345f, 0.00349858f, 0.03547348f, 
    0.01118610f, -0.01668644f, 0.04539578f, 0.00308643f, -0.04813645f, 0.02343615f, -0.05691890f, 0.04752306f, 
    0.03091891f, -0.02883237f, 0.00697352f, -0.04665769f, 0.03026333f, -0.03555539f, 0.04535468f, -0.04050634f, 
    -0.05821589f, -0.03744568f, -0.04605244f, -0.02713715f, -0.02223120f, -0.04642603f, -0.03999895f, -0.00678528f, 
    0.02161261f, -0.03245946f, 0.03914513f, -0.03079835f, 0.03648266f, -0.02549637f, 0.04031122f, 0.01981502f, 
    -0.03169112f, -0.02077126f, -0.04898702f, -0.00343921f, 0.03532472f, 0.04373838f, 0.04462277f, -0.02902303f, 
    -0.03904162f, -0.03978310f, -0.00756861f, 0.02450183f, -0.01560663f, 0.02557433f, 0.01605666f, -0.03156349f, 
    0.00523786f, -0.05542661f, -0.00843976f, 0.03051335f, -0.03170045f, 0.02066042f, 0.01383854f, 0.01272116f, 
    0.00670848f, 0.01506278f, -0.04300203f, -0.01324512f, 0.00556082f, 0.01890207f, -0.01775980f, 0.02259675f, 
    0.00856338f, -0.03729485f, -0.00059901f, -0.05694782f, 0.01857282f, 0.03684158f, 0.04217369f, -0.01435246f, 
    0.04412270f, -0.02741511f, 0.00969935f, 0.03274989f, 0.02196469f, 0.04257266f, -0.05714691f, 0.02994395f, 
    -0.02590837f, -0.05415090f, 0.03803882f, -0.04129748f, -0.00910242f, 0.03008157f, -0.03775844f, -0.00359992f, 
    -0.01736765f, -0.01836780f, -0.06064937f, 0.01546318f, 0.00016444f, 0.02930527f, 0.01085136f, -0.03223341f, 
    0.04277778f, 0.00318150f, -0.01550680f, 0.02572912f, -0.01232541f, -0.01019416f, 0.02481392f, -0.06021751f, 
    -0.05584413f, 0.03377153f, 0.01144456f, -0.01960448f, -0.03464401f, 0.03883501f, 0.00600618f, -0.03333698f, 
    -0.02168503f, -0.00763214f, 0.04830930f, -0.05661863f, -0.05427558f, 0.00281692f, -0.05710339f, -0.01968931f, 
    -0.01517198f, -0.03482137f, -0.05977116f, 0.02908342f, 0.02734816f, -0.03930263f, 0.03790957f, -0.03646514f, 
    0.00947382f, 0.04970966f, -0.01901152f, -0.00170286f, -0.00259598f, 0.03645344f, 0.04925475f, -0.05986184f, 
    0.02270495f, -0.00582935f, -0.05176524f, -0.02449718f, -0.05202665f, -0.03466811f, 0.01086971f, -0.05291991f, 
    -0.04658857f, -0.04432536f, -0.04542697f, -0.02599650f, -0.01412596f, -0.06127780f, -0.02744214f, -0.05235412f, 
    0.00171738f, -0.05781883f, 0.00719463f, 0.00458523f, -0.02899835f, -0.00763125f, 0.02734179f, -0.04873275f, 
    -0.00676272f, -0.04754388f, 0.02922337f, -0.05839617f, 0.02182269f, 0.02673227f, -0.01874131f, -0.01579095f, 
    0.01209889f, 0.03381659f, -0.03349959f, -0.04026561f, -0.01990440f, -0.05594185f, -0.02447797f, 0.00755460f, 
    -0.04846799f, -0.02892345f, -0.00883821f, -0.03230220f, -0.00154584f, -0.02346952f, 0.02720951f, -0.02233199f, 
    -0.04694843f, 0.00100529f, -0.02980384f, -0.05672627f, 0.00707198f, 0.01410840f, -0.05834238f, -0.04456807f, 
    0.03098347f, 0.00354776f, -0.04411437f, 0.04318190f, -0.05625688f, -0.02106564f, -0.01467044f, 0.02776130f, 
    0.00798228f, -0.03208628f, -0.01680828f, 0.01910820f, 0.01045594f, -0.02324171f, -0.01489874f, -0.01498774f, 
    0.02660722f, 0.04004330f, -0.03575696f, -0.01281298f, -0.03491257f, 0.00784115f, 0.02494571f, -0.03103822f, 
    -0.01893758f, -0.05171663f, -0.05827092f, -0.05507982f, 0.00665862f, -0.01462341f, -0.00373907f, 0.04993227f, 
    -0.00283480f, -0.05221422f, -0.01117161f, 0.00150464f, -0.00208177f, -0.00781376f, 0.02821258f, 0.04600856f, 
    -0.03812224f, 0.01147617f, -0.03883127f, 0.04559933f, -0.03794882f, -0.04403242f, -0.03405514f, -0.06011052f, 
    -0.03494762f, 0.01621919f, -0.04056141f, -0.05192816f, -0.05603788f, 0.03814716f, 0.03392045f, -0.05099824f, 
    -0.04154878f, 0.03536150f, 0.00698978f, 0.01133025f, -0.05849251f, -0.04270275f, -0.00783572f, 0.00042236f, 
    0.00853642f, 0.02986771f, -0.03147747f, -0.01669110f, 0.00466377f, 0.02042392f, -0.03882662f, -0.02826310f, 
    0.00269934f, 0.04836969f, 0.04372300f, -0.00583376f, 0.02551968f, -0.04907559f, 0.00090228f, 0.00397616f, 
    -0.02309664f, -0.03322035f, -0.03003209f, 0.04736150f, 0.04266496f, -0.02505396f, 0.00536681f, -0.00913351f, 
    -0.02910849f, -0.17014673f, -0.02476844f, 0.12642761f, 0.11414561f, 0.15403479f, -0.07499072f, 0.02256818f, 
    -0.10683540f, -0.00623120f, -0.02134538f, 0.02838151f, -0.04828982f, 0.06885403f, 0.00513026f, 0.05875364f, 
    0.01616097f, -0.03384992f, 0.06264985f, 0.01273441f, 0.15792857f, 0.59776682f, 0.09701345f, 0.24552639f, 
    0.33427104f, -0.21256201f, 0.00820581f, -0.12442262f, -0.02816831f, -0.11089291f, 0.08530706f, -0.04202459f, 
    0.06532126f, 0.01915482f, 0.14002003f, -0.00877308f, 0.00742160f, -0.06220956f, -0.03468912f, -0.10830012f, 
    -0.37017798f, 0.12319420f, 0.12899005f, -0.11991343f, 0.41341549f, -0.08617740f, 0.08896943f, 0.04280677f, 
    0.01010494f, -0.02329289f, 0.00212518f, 0.11084388f, -0.01181015f, 0.01139680f, 0.01827937f, 0.05524226f, 
    0.03683842f, 0.03983068f, 0.12229908f, -0.05019866f, -0.04462907f, -0.22594345f, 0.06540616f, -0.13290764f, 
    -0.11692010f, 0.11755597f, 0.11077493f, 0.08214514f, 0.02331803f, -0.06437010f, 0.07488257f, 0.08247323f, 
    0.01798222f, 0.00847752f, 0.00090935f, -0.14026527f, 0.01020987f, -0.00990521f, -0.03424535f, 0.18463221f, 
    -0.30557644f, -0.06227750f, 0.27389976f, 0.24579942f, -0.14510363f, 0.07049283f, 0.01880904f, -0.00995368f, 
    -0.07377695f, 0.02834999f, -0.10479856f, -0.07744347f, -0.05660534f, 0.00058998f, -0.06857528f, -0.00396386f, 
    0.09407680f, -0.01568747f, 0.14546062f, -0.07715749f, 0.00200388f, 0.06048202f, 0.11385277f, -0.00225844f, 
    -0.09716813f, -0.07128244f, 0.04196945f, -0.03479116f, -0.09274839f, 0.04830863f, 0.05356321f, 0.00726448f, 
    0.06526722f, -0.04614601f, 0.14557059f, 0.05397050f, -0.00525056f, 0.02059247f, 0.15861987f, -0.08076511f, 
    -0.35722664f, 0.46381831f, -0.22447856f, 0.20577687f, -0.08759846f, -0.12346301f, 0.14273658f, -0.13425590f, 
    0.00635483f, 0.01449097f, 0.02046311f, -0.08937127f, -0.03877421f, 0.03500740f, 0.04734815f, 0.08917399f, 
    0.04730653f, 0.01699745f, 0.14590530f, 0.00528956f, -0.55289727f, 0.19213937f, 0.06772994f, -0.15008666f, 
    0.06023125f, -0.07183420f, 0.04279910f, -0.03356664f, -0.05601558f, -0.02660451f, 0.00127213f, -0.07906161f, 
    0.04021736f, 0.01562827f, -0.00668886f, 0.03534520f, 0.07225138f, -0.05217218f, 0.11342541f, 0.16972139f, 
    0.04936533f, -0.09147179f, 0.21281798f, -0.34621227f, 0.29206735f, 0.15652828f, 0.16464306f, 0.05045353f, 
    0.01478855f, 0.03518425f, -0.00332182f, -0.04315403f, -0.00234639f, 0.13742508f, -0.11404324f, 0.05376875f, 
    0.12441026f, 0.05004288f, -0.02197842f, -0.03948126f, 0.03187516f, 0.02238792f, 0.08574503f, -0.12627426f, 
    0.03310989f, 0.07228690f, 0.00511058f, 0.03120892f, -0.10430524f, 0.13143989f, 0.11752560f, 0.06774852f, 
    -0.06421472f, -0.00074740f, 0.01296251f, 0.02666138f, 0.00276390f, 0.14337984f, -0.14086346f, 0.22596574f, 
    -0.30385423f, 0.09516872f, 0.08818974f, 0.00203308f, -0.16015911f, 0.00373525f, -0.07452156f, -0.10091462f, 
    0.02681583f, -0.02701962f, -0.19468932f, 0.14031406f, 0.08413424f, 0.03052729f, 0.05683633f, -0.13167574f, 
    -0.04120906f, 0.04065556f, 0.04957046f, -0.05677018f, -0.25224233f, 0.29380271f, -0.01190543f, 0.10242128f, 
    0.10979293f, 0.14334026f, 0.11884642f, -0.05548263f, -0.03620683f, -0.02902393f, -0.01790772f, -0.01881208f, 
    0.05099799f, 0.06211325f, -0.04617606f, 0.06238431f, -0.00766847f, 0.00689844f, -0.00159923f, -0.03440385f, 
    0.10777047f, 0.03859616f, 0.05634038f, -0.10577075f, 0.12894507f, -0.02429685f, 0.08255409f, 0.01048747f, 
    -0.01838996f, -0.01733587f, 0.12343484f, -0.08106795f, -0.00603900f, 0.17955998f, 0.08369292f, -0.13904397f, 
    -0.01701286f, -0.05276256f, -0.13260908f, -0.01828882f, 0.25185901f, 0.24360466f, -0.03919849f, 0.08139923f, 
    0.11349490f, -0.15752758f, 0.00053535f, 0.05243342f, -0.02472825f, 0.18513283f, -0.01516471f, -0.02548796f, 
    0.07064929f, 0.11682500f, -0.11913312f, -0.03450698f, 0.12206484f, -0.13278021f, 0.07274503f, -0.03121631f, 
    -0.34451646f, -0.04458501f, 0.29193082f, 0.44707397f, -0.15963306f, 0.11259794f, -0.02314293f, -0.11940877f, 
    -0.03681298f, 0.02903078f, -0.11037062f, 0.05553104f, 0.04930373f, -0.00492527f, 0.11269902f, -0.09919327f, 
    -0.17629188f, -0.11548319f, 0.11700229f, 0.06459006f, -0.11130975f, 0.17824368f, 0.09075846f, 0.19185805f, 
    -0.14812197f, 0.02912176f, -0.04963373f, 0.00956102f, -0.05998973f, 0.00653358f, -0.05147533f, 0.13890064f, 
    0.00856697f, -0.02711504f, -0.03663932f, 0.02075660f, 0.02900963f, -0.07227430f, 0.09574184f, -0.06142683f, 
    0.02153069f, -0.02278400f, 0.03451507f, -0.05483907f, -0.03231563f, -0.05597729f, 0.00115887f, 0.02428702f, 
    0.03147554f, 0.03463557f, 0.02754729f, 0.01920983f, -0.00148170f, -0.04065624f, -0.00779114f, -0.03417284f, 
    0.03909650f, -0.05445252f, -0.03980043f, -0.04541855f, -0.02775682f, 0.04097433f, -0.04579564f, 0.00283126f, 
    -0.02897417f, 0.00554119f, 0.04705966f, 0.03598788f, 0.04752144f, 0.04535825f, -0.03042022f, 0.03738712f, 
    -0.01248271f, 0.04564189f, -0.01029421f, -0.04413545f, -0.02271178f, -0.03199173f, -0.05321651f, -0.02404089f, 
    0.02877577f, -0.01828234f, -0.05741518f, 0.03274411f, 0.00663853f, -0.05568791f, -0.04715795f, 0.04765799f, 
    -0.05983235f, 0.03107643f, 0.04219428f, 0.03561702f, 0.04146370f, 0.04680108f, 0.02141836f, 0.04137595f, 
    0.01682802f, 0.03923021f, -0.04971545f, 0.02120459f, -0.03820436f, -0.03735895f, 0.02965593f, 0.00368176f, 
    -0.02681196f, 0.02342459f, -0.04511173f, -0.00503076f, -0.04132889f, -0.04507708f, -0.02151960f, -0.05638710f, 
    0.00184243f, 0.02937464f, -0.01454835f, 0.03831254f, 0.02717574f, -0.05713372f, -0.03001129f, -0.05642879f, 
    -0.04236708f, 0.04020227f, -0.03360427f, -0.05374556f, 0.03117562f, -0.05633840f, 0.00492322f, 0.04632604f, 
    0.00039569f, -0.03921147f, 0.02770168f, 0.02009609f, -0.03577506f, -0.01898865f, -0.01339456f, -0.05992345f, 
    0.01672561f, -0.03334282f, 0.01712716f, -0.05441801f, 0.04541771f, -0.02225816f, 0.02355793f, 0.02994336f, 
    -0.03661563f, -0.02795029f, -0.04712263f, 0.01085684f, -0.00829397f, 0.04787361f, -0.04875238f, -0.01749947f, 
    -0.04376279f, -0.03735754f, 0.02630285f, 0.01020530f, -0.04984539f, 0.01373976f, 0.02951753f, -0.04442679f, 
    0.00650536f, -0.01386612f, -0.04580646f, -0.04652089f, -0.01186102f, -0.04114205f, 0.03353086f, -0.05733266f, 
    -0.00470329f, -0.02518335f, -0.05273277f, 0.00418372f, -0.02015284f, -0.02409851f, -0.02441926f, -0.03470373f, 
    -0.05101269f, 0.02663645f, -0.03678229f, 0.00974509f, -0.04347384f, -0.00126216f, 0.04964810f, 0.02933643f, 
    -0.04092569f, -0.01345005f, -0.05117676f, -0.00387030f, -0.05564521f, 0.03696820f, -0.04172428f, 0.03890807f, 
    0.02476508f, 0.00387448f, -0.06027615f, 0.01922788f, 0.04016874f, 0.00969222f, 0.01528363f, 0.00792471f, 
    -0.01327057f, 0.00193577f, -0.00395092f, -0.02700673f, 0.02883158f, -0.01926683f, 0.00556538f, -0.02056990f, 
    0.02068541f, -0.04050528f, 0.00246951f, 0.02713605f, 0.02078542f, -0.06097710f, -0.04336397f, -0.02342685f, 
    0.05093129f, 0.01634561f, -0.01757715f, 0.03089616f, 0.03961205f, 0.01682781f, -0.04611157f, -0.01152993f, 
    0.03912309f, 0.04775420f, -0.04718941f, 0.00446703f, -0.01170364f, 0.02256211f, 0.03897861f, -0.03639795f, 
    0.00091568f, -0.01848344f, -0.04021876f, -0.03812043f, -0.04518612f, 0.01443682f, -0.02541994f, -0.00306243f, 
    -0.02750561f, -0.03219703f, 0.02290731f, -0.05036164f, -0.04185077f, -0.03060376f, -0.03874036f, 0.01448190f, 
    0.03467730f, 0.00815633f, -0.01674354f, -0.01050501f, -0.05356109f, -0.02728347f, -0.00781196f, -0.04704444f, 
    0.04470268f, 0.03883372f, -0.05085428f, -0.03842443f, -0.01474867f, 0.03112131f, 0.00668429f, 0.00391714f, 
    -0.03877342f, -0.00702474f, -0.03743584f, 0.03388026f, 0.02901992f, -0.05085560f, 0.00168505f, 0.02579099f, 
    -0.01672826f, 0.02736763f, -0.01065083f, 0.01596797f, -0.05130020f, -0.00448534f, -0.03522886f, -0.05343169f, 
    -0.02811818f, -0.05996556f, -0.00602348f, 0.01947419f, 0.01529013f, -0.05705651f, -0.06045330f, -0.01576332f, 
    -0.04558787f, -0.04047126f, -0.02561602f, -0.05669649f, -0.04901766f, -0.01778585f, -0.03723297f, -0.03961169f, 
    0.04091492f, -0.03851270f, 0.00606966f, -0.02966997f, -0.04002459f, -0.02262064f, 0.03127351f, 0.04417988f, 
    -0.03526970f, 0.00053585f, 0.01090963f, 0.02694779f, 0.01087221f, -0.00548449f, -0.05564123f, 0.04923658f, 
    0.02184909f, -0.03007247f, 0.04209279f, -0.00662820f, 0.02271526f, -0.00611271f, 0.01847905f, -0.03911769f, 
    -0.05665509f, 0.03539182f, -0.01707340f, 0.03775309f, -0.04374014f, 0.00021758f, -0.03596878f, 0.05443655f, 
    -0.05135141f, 0.03405208f, 0.03549475f, -0.01475143f, 0.01217510f, 0.01304989f, -0.04682476f, -0.02794468f, 
    0.03804750f, -0.04112022f, -0.04777330f, 0.03829840f, 0.00703035f, -0.04108328f, 0.02576062f, -0.03526112f, 
    -0.03521864f, -0.02410710f, -0.03594490f, -0.04851914f, 0.02919475f, 0.01184258f, -0.00698329f, 0.04424252f, 
    -0.06137373f, -0.04453894f, -0.02107970f, -0.02429087f, 0.04722271f, 0.03933733f, 0.02988138f, -0.01349952f, 
    -0.38117117f, 0.22012186f, 0.18177830f, 0.00832835f, -0.14247370f, 0.08524659f, 0.07743963f, 0.11520030f, 
    0.11629865f, -0.02869863f, -0.07974423f, -0.01144392f, -0.02307488f, -0.12514231f, 0.04679963f, 0.03751416f, 
    0.03564999f, 0.12814090f, 0.02097902f, 0.00818915f, 0.31543744f, -0.13175714f, 0.16604789f, -0.03220113f, 
    -0.12909643f, 0.04655439f, 0.06307060f, 0.22301455f, -0.10695004f, 0.20795549f, 0.09449859f, 0.12275276f, 
    -0.09463411f, 0.02668347f, -0.04479401f, 0.02962345f, -0.08125900f, 0.00617822f, 0.08640096f, 0.07116006f, 
    0.20702630f, 0.11045744f, -0.16527347f, -0.10797571f, -0.17321210f, 0.07957267f, 0.09975235f, -0.12744349f, 
    0.05966020f, -0.19208209f, 0.11770926f, 0.00195246f, -0.02245069f, 0.06334088f, -0.09653840f, -0.03866350f, 
    0.10666832f, 0.02494798f, -0.04900476f, 0.08112132f, 0.02305801f, -0.10353357f, -0.03354048f, 0.05459456f, 
    -0.08406933f, -0.13830355f, -0.16518518f, -0.02429359f, 0.04466964f, 0.00267641f, 0.02281546f, -0.02185109f, 
    -0.00855508f, -0.01638270f, 0.01065858f, -0.01621094f, -0.25050092f, 0.01156429f, -0.14792474f, -0.09655897f, 
    0.63789499f, 0.02116651f, -0.11273563f, -0.21455438f, 0.18812081f, 0.05038169f, -0.10874064f, -0.12279546f, 
    -0.01386255f, 0.04655008f, 0.05540915f, -0.06189467f, 0.03808526f, 0.00512799f, 0.10279513f, -0.07899588f, 
    -0.15761171f, 0.07609675f, 0.03481339f, 0.03262673f, 0.12946747f, 0.21376748f, 0.05073445f, -0.03216815f, 
    0.14726028f, 0.00231160f, -0.02348903f, -0.10170988f, 0.12454661f, 0.02358997f, 0.03208468f, 0.00443356f, 
    0.10622758f, -0.12330340f, -0.03271563f, 0.22337458f, 0.16215885f, -0.12099480f, -0.08790576f, 0.18720950f, 
    0.08175356f, -0.16733976f, 0.11007693f, -0.05147018f, 0.42050463f, -0.05893957f, 0.07768393f, 0.09138580f, 
    0.11285560f, -0.08626681f, 0.07207738f, 0.11269966f, -0.04110234f, 0.04308548f, -0.01661726f, 0.06285465f, 
    -0.04379432f, 0.00341840f, 0.08717705f, -0.03673816f, 0.69176698f, 0.14027821f, 0.16338041f, -0.10689656f, 
    -0.17416227f, -0.01331978f, 0.01602469f, -0.16798431f, 0.07829852f, -0.04640245f, 0.06308948f, 0.12412845f, 
    0.05061691f, 0.02978207f, 0.10361278f, 0.04650803f, 0.03348801f, -0.07849654f, -0.06481727f, -0.04095055f, 
    -0.37215424f, 0.55484903f, -0.16213971f, 0.02442526f, -0.21838683f, 0.00172160f, 0.09372945f, 0.01829133f, 
    0.15060891f, -0.17243382f, 0.08093701f, -0.01253998f, 0.15084615f, 0.03089151f, -0.04496691f, 0.04506393f, 
    -0.13252200f, -0.00491610f, 0.00020671f, -0.03536307f, 0.11269826f, -0.10708818f, -0.26739112f, -0.00572045f, 
    0.00104921f, -0.10246285f, -0.23127502f, -0.10742686f, -0.00235534f, -0.08990631f, -0.06645598f, -0.13493128f, 
    0.01636009f, 0.03572952f, 0.06575552f, 0.04451405f, 0.00817094f, -0.01896900f, -0.05242528f, 0.04568973f, 
    -0.11988605f, -0.10145455f, -0.01374914f, -0.14938189f, 0.12368087f, -0.18825275f, -0.10094039f, 0.12617631f, 
    -0.19505657f, 0.03744356f, -0.00159986f, -0.00908888f, -0.01196987f, 0.06446715f, 0.06741729f, 0.10322887f, 
    -0.08644262f, 0.13337615f, 0.05678320f, -0.00765405f, -0.00686824f, -0.67431295f, 0.23628858f, 0.19295067f, 
    -0.05919258f, 0.00669441f, -0.09876293f, 0.04691925f, 0.11082000f, -0.01987319f, -0.00709137f, -0.04154855f, 
    -0.01148116f, 0.00941192f, 0.08154344f, -0.05293028f, -0.01392495f, 0.06779274f, -0.01298891f, -0.06678088f, 
    0.02075879f, -0.29046604f, -0.00878868f, 0.04191945f, 0.02848157f, -0.04347779f, -0.03692558f, -0.16549480f, 
    0.12035047f, -0.01746767f, -0.06252506f, 0.02816012f, 0.10069147f, -0.05453444f, 0.05160577f, -0.09165598f, 
    0.01620622f, 0.02534879f, 0.06766079f, 0.00113045f, -0.16211319f, -0.04777243f, 0.06479230f, -0.01072489f, 
    0.10868163f, 0.13881114f, -0.00855093f, -0.10686765f, 0.01432696f, 0.00743223f, 0.16274333f, -0.02392949f, 
    -0.01609101f, 0.06238474f, 0.16869427f, 0.01452159f, -0.20858273f, 0.12586990f, -0.12100643f, 0.10042161f, 
    0.05978785f, -0.09141835f, 0.21216032f, -0.03521355f, 0.10935012f, -0.17469802f, -0.13807502f, -0.01042932f, 
    -0.02354553f, 0.07960153f, 0.07826412f, 0.10920239f, 0.04629080f, -0.02492427f, -0.00968061f, -0.10916778f, 
    0.07729251f, 0.03086944f, 0.02330584f, -0.08157325f, 0.16338962f, -0.06699243f, 0.17999193f, -0.17391396f, 
    0.21962450f, -0.04976753f, -0.02945458f, 0.07705894f, 0.05404901f, -0.06528410f, 0.05950435f, -0.17427258f, 
    0.10064890f, -0.06650747f, 0.02823732f, -0.15044080f, 0.05020932f, 0.11418629f, -0.03253049f, 0.04267024f, 
    -0.03479039f, -0.04779353f, -0.04835754f, -0.02748250f, 0.00056334f, 0.02078211f, 0.03606420f, -0.05851081f, 
    -0.01645277f, 0.04304892f, 0.03933392f, 0.00581196f, -0.04946704f, 0.03229165f, -0.04338824f, 0.02080536f, 
    -0.02150390f, 0.02585175f, 0.00154176f, -0.03349147f, -0.06592629f, 0.01244494f, -0.06436980f, -0.03427141f, 
    0.03176921f, 0.01756621f, 0.03651731f, 0.00229545f, 0.01088551f, -0.01384927f, -0.05073265f, 0.04161868f, 
    -0.00274510f, -0.05910939f, -0.01740045f, 0.03711502f, -0.06039572f, -0.03158543f, -0.02005409f, 0.02732572f, 
    0.03601083f, -0.00915791f, 0.00484724f, -0.03398482f, -0.00208834f, -0.00227683f, -0.00111442f, -0.05441653f, 
    0.00099191f, -0.02609795f, -0.04956977f, -0.02213659f, -0.02701603f, -0.03617104f, 0.03227947f, 0.00785791f, 
    -0.03040798f, -0.01955229f, 0.01067206f, -0.03931947f, -0.01678748f, -0.02055289f, -0.01709420f, 0.01963305f, 
    0.01902945f, 0.02978224f, -0.00592585f, 0.04107644f, -0.04594412f, -0.06229492f, -0.05342919f, -0.03708472f, 
    0.04263552f, -0.01532443f, -0.01591940f, -0.05243720f, 0.02111235f, -0.01272927f, -0.01789074f, -0.04211802f, 
    0.02633978f, 0.03543670f, -0.00333497f, 0.02393805f, 0.01419720f, -0.02425168f, 0.02600682f, 0.03457737f, 
    -0.01636489f, 0.00295748f, 0.01261740f, -0.06212015f, -0.01092235f, 0.00583095f, -0.03867218f, -0.01343554f, 
    -0.03458674f, -0.00145866f, -0.05750930f, -0.00088107f, 0.02744783f, -0.00706800f, 0.03130559f, -0.03549376f, 
    0.00925189f, 0.04294726f, -0.00453991f, -0.02098784f, 0.02917268f, 0.03230343f, 0.04269449f, 0.00792664f, 
    -0.03843679f, -0.00871005f, -0.03184070f, -0.06227630f, 0.01834935f, 0.01521125f, -0.01623681f, -0.01985098f, 
    -0.00461673f, 0.04264794f, -0.04902318f, -0.05124944f, 0.04126970f, -0.03873163f, 0.04101208f, 0.01763421f, 
    -0.06141602f, -0.04007334f, -0.00417209f, -0.02067406f, -0.02103161f, 0.00512810f, -0.01055236f, 0.03443118f, 
    -0.04705916f, -0.00260153f, 0.04400742f, 0.02544605f, 0.02343733f, 0.01531869f, -0.01109971f, 0.03467095f, 
    -0.05105046f, -0.00601113f, -0.06002007f, -0.00383470f, -0.03507999f, 0.03621502f, -0.06013814f, -0.02492988f, 
    -0.00062135f, 0.02334728f, -0.00334001f, -0.00457206f, 0.03354996f, -0.00412516f, 0.00498344f, -0.03259122f, 
    0.01092233f, 0.01797760f, -0.02333221f, -0.05146271f, 0.02441111f, -0.03241888f, 0.03891464f, 0.04374503f, 
    0.01618342f, -0.03174253f, -0.05138623f, -0.03664829f, 0.01442952f, -0.02336665f, -0.01212757f, 0.02708691f, 
    -0.02158110f, -0.00001093f, 0.00239233f, -0.05334862f, -0.03648034f, -0.03648604f, -0.00457185f, 0.04624170f, 
    0.01409698f, -0.00900817f, 0.01974726f, 0.00448129f, -0.02925803f, -0.01392682f, -0.04993813f, 0.04118030f, 
    -0.03161639f, 0.03388739f, 0.00839130f, -0.01368348f, -0.01826284f, -0.00048849f, 0.00650756f, -0.02278539f, 
    0.03698114f, -0.04006336f, 0.01596459f, -0.04047333f, -0.01010829f, 0.03143761f, -0.04075077f, -0.06102988f, 
    0.02651227f, -0.06053912f, 0.02972791f, -0.05260945f, -0.02618406f, 0.01546941f, -0.01623697f, -0.05275350f, 
    -0.00980532f, -0.01341372f, 0.02044396f, -0.01501297f, 0.01807743f, -0.01791867f, -0.02143696f, 0.01609217f, 
    -0.05376319f, 0.03036057f, -0.05834127f, -0.05394065f, -0.03932025f, -0.03602636f, 0.04217215f, -0.01395922f, 
    -0.00766158f, 0.03743313f, -0.04694730f, 0.01464004f, -0.00477058f, -0.04327941f, -0.05545044f, 0.02750904f, 
    -0.00374673f, 0.04255126f, -0.05658928f, -0.04141547f, 0.04607177f, -0.04079918f, -0.03853223f, 0.03521618f, 
    -0.05045174f, 0.03740110f, 0.01844449f, -0.00536444f, 0.01912835f, 0.03781542f, 0.00271453f, -0.00557557f, 
    0.01279215f, -0.03283792f, -0.01976348f, 0.00519716f, 0.01281924f, -0.00564627f, 0.03355076f, -0.06580117f, 
    0.03721221f, -0.04872375f, -0.05866572f, -0.03264112f, -0.01288816f, -0.02569636f, -0.00772084f, 0.00422420f, 
    -0.05646693f, 0.02932111f, 0.03602990f, -0.03016615f, -0.03311622f, -0.02140358f, 0.04190177f, -0.02693103f, 
    -0.01150062f, 0.00861085f, -0.02678014f, 0.04060324f, -0.05205669f, -0.05300022f, 0.04446519f, 0.01077087f, 
    0.00143478f, -0.03741571f, 0.00671053f, -0.01171184f, 0.03900068f, -0.00123165f, -0.01592444f, 0.01200949f, 
    -0.05815239f, -0.02532229f, 0.01670811f, -0.02156363f, 0.00355851f, -0.03616514f, 0.00129678f, -0.03248208f, 
    0.02642319f, -0.04926208f, 0.02200869f, -0.01171866f, 0.02502031f, -0.05923438f, -0.00546330f, -0.00841901f, 
    -0.01002260f, -0.00166637f, -0.02018359f, -0.05969344f, 0.00316906f, -0.04692583f, 0.03719509f, -0.01959741f, 
    0.09807242f, -0.44011816f, 0.25663683f, -0.16637088f, 0.05841471f, -0.02399686f, 0.05052058f, -0.05453931f, 
    0.16774392f, -0.09400161f, -0.02621663f, -0.04127887f, 0.03143548f, 0.03958601f, 0.03679570f, 0.01709411f, 
    0.12393640f, -0.22345574f, 0.01625544f, 0.02622004f, -0.39691275f, -0.02035064f, -0.06362759f, -0.13180789f, 
    0.04628040f, 0.11728767f, 0.01551551f, 0.03588679f, -0.07709096f, 0.07333630f, -0.22186309f, -0.12112813f, 
    0.08536298f, 0.06810511f, 0.17972574f, 0.04920688f, 0.09072053f, -0.19925211f, -0.34261954f, -0.19369160f, 
    -0.16812362f, -0.14929184f, -0.01643760f, -0.18817793f, 0.13722710f, -0.04030205f, -0.14838719f, 0.15270366f, 
    0.13603069f, 0.10071111f, 0.01866506f, 0.01159038f, 0.07496375f, 0.09742153f, 0.00135535f, 0.02291669f, 
    0.03625721f, -0.03919049f, -0.07235134f, -0.09393678f, 0.01321671f, 0.37210497f, 0.00376096f, -0.22901453f, 
    0.01731821f, -0.04780878f, 0.10342715f, 0.09752776f, 0.00341921f, -0.07766850f, -0.12315085f, 0.05286521f, 
    0.05768971f, 0.05834496f, 0.14857228f, 0.03859920f, 0.08739527f, 0.06098210f, 0.10491362f, 0.10319721f, 
    -0.45726269f, 0.31753498f, 0.01540404f, 0.04943660f, 0.21305040f, 0.13705912f, 0.04641772f, 0.08232046f, 
    -0.12968697f, 0.08087432f, 0.00596388f, -0.02854702f, -0.11210389f, -0.03273509f, -0.09826367f, 0.09569136f, 
    0.08407269f, -0.17442113f, 0.00759011f, -0.00842204f, -0.08972081f, 0.04942824f, -0.18460636f, 0.01034835f, 
    0.04178351f, -0.16350104f, -0.00091839f, 0.02512669f, -0.07748316f, -0.03886920f, -0.04386724f, 0.02213603f, 
    0.11359158f, 0.09733705f, 0.08002366f, -0.00023019f, 0.15198489f, -0.32346302f, -0.12181088f, -0.03329787f, 
    0.59275758f, 0.01987750f, -0.25350431f, 0.25254217f, -0.18686193f, 0.06067896f, -0.04573007f, 0.07214839f, 
    0.05734520f, -0.01097868f, 0.01959602f, -0.08730692f, 0.04473300f, 0.03949716f, -0.00620108f, -0.02349453f, 
    -0.04401707f, 0.18108770f, -0.19551219f, 0.04686926f, -0.03328323f, 0.07841156f, 0.14119351f, -0.18297368f, 
    0.02963129f, 0.00433600f, -0.05305574f, -0.01453644f, 0.02697610f, -0.06161904f, 0.04456094f, -0.13487370f, 
    -0.08389577f, 0.16586278f, 0.03028265f, -0.00022350f, 0.03428439f, 0.05317247f, 0.03845385f, 0.08826233f, 
    -0.17742887f, -0.08618407f, 0.04274506f, -0.06539416f, 0.10867435f, -0.05288785f, -0.12731709f, 0.15020204f, 
    -0.02172779f, 0.15380460f, -0.08335117f, -0.07112307f, 0.13353451f, 0.07161953f, 0.03793166f, 0.06241270f, 
    0.00632703f, -0.13115479f, 0.04733248f, 0.08885286f, -0.02893054f, -0.10884682f, 0.01885318f, 0.12056898f, 
    -0.00303762f, 0.02814453f, 0.01172320f, -0.01747967f, -0.07559499f, 0.06543916f, -0.03302241f, 0.01818593f, 
    -0.03367611f, -0.10925826f, 0.02909912f, 0.01864542f, -0.09632949f, 0.02177556f, 0.23509604f, 0.02494735f, 
    0.39221793f, 0.15013997f, -0.01212331f, 0.06847444f, 0.06520805f, 0.18606871f, 0.13975625f, -0.07810864f, 
    0.13977529f, -0.13481715f, 0.09869701f, 0.13812196f, -0.12318663f, 0.03757901f, -0.15954044f, 0.02963406f, 
    0.07223966f, 0.14387582f, 0.00751279f, -0.00069260f, 0.01567491f, 0.19296522f, -0.11684480f, -0.09681302f, 
    -0.01541915f, -0.19529577f, -0.16265145f, -0.04478114f, -0.05179513f, -0.05873610f, 0.04585833f, -0.06764983f, 
    -0.03530466f, -0.10136433f, -0.06737591f, 0.03997448f, -0.06631645f, 0.20993508f, 0.20276737f, 0.22645205f, 
    0.03991758f, -0.08963948f, -0.07051795f, 0.05056090f, -0.15241605f, 0.00195731f, 0.10307750f, 0.02562984f, 
    -0.15966976f, -0.05934047f, 0.08328745f, 0.00108907f, -0.02747170f, -0.14968476f, 0.00610159f, 0.02566317f, 
    -0.02489947f, 0.09482878f, 0.06434306f, 0.04136906f, -0.12910585f, 0.01477786f, -0.16152544f, 0.03103376f, 
    0.08769202f, -0.06018730f, 0.03072430f, 0.07259258f, -0.13489774f, 0.05801497f, -0.09203391f, -0.08862688f, 
    0.09917719f, 0.01885496f, -0.04974091f, 0.01789719f, -0.05745547f, -0.11017048f, -0.22273467f, -0.14453661f, 
    -0.02475465f, 0.25940865f, -0.13100603f, 0.02603284f, -0.05995749f, 0.08602931f, 0.17848510f, 0.15053961f, 
    -0.19602500f, 0.10233249f, 0.01009969f, 0.10062784f, 0.00666470f, -0.14864083f, 0.04729563f, 0.25530586f, 
    0.07389441f, 0.18866365f, 0.11120618f, 0.04157222f, 0.07222316f, 0.27097565f, -0.03752414f, 0.04169690f, 
    0.00308413f, 0.04885033f, -0.11002143f, 0.11586086f, -0.02848255f, 0.10399336f, -0.00878353f, 0.12301438f, 
    -0.16123889f, 0.00361489f, -0.04446561f, -0.04703914f, 0.09167728f, -0.16311872f, 0.07334399f, 0.00655452f, 
    -0.03926588f, -0.00436750f, -0.01961477f, 0.02980109f, 0.00983057f, 0.01292956f, -0.03452454f, 0.03336912f, 
    0.04508907f, -0.02571698f, 0.03579513f, 0.01500433f, -0.04712956f, -0.05301797f, -0.03805283f, -0.05182672f, 
    0.01922832f, -0.05417683f, 0.01801086f, -0.00412353f, 0.04169379f, -0.02383901f, -0.02231257f, 0.03787156f, 
    0.03551568f, 0.03494222f, -0.01811511f, 0.00486939f, -0.03603747f, -0.00630156f, 0.02948918f, -0.01289072f, 
    -0.01318964f, -0.00324326f, -0.02231882f, 0.01505830f, -0.01939484f, -0.02843323f, -0.01059201f, -0.04030206f, 
    0.02773022f, -0.01699067f, -0.02780196f, 0.04408336f, 0.00922290f, -0.05247493f, -0.04635475f, -0.02456827f, 
    -0.04122647f, -0.03039475f, 0.02790740f, -0.04616209f, -0.05842520f, 0.01432366f, -0.02022102f, 0.02256983f, 
    -0.05803648f, 0.03411539f, -0.03681838f, -0.05645602f, 0.02838400f, 0.01385194f, -0.00566194f, 0.01826451f, 
    0.04727343f, 0.00293744f, 0.04526161f, -0.01652230f, -0.05761122f, -0.01786201f, 0.01925037f, 0.04568364f, 
    -0.05688558f, 0.04306654f, -0.02616591f, -0.04207086f, -0.00528623f, -0.01323626f, 0.02535207f, -0.00817005f, 
    -0.05152958f, 0.00905026f, -0.02253296f, 0.04615190f, 0.00393516f, 0.03553106f, 0.00373528f, -0.00621723f, 
    0.01210277f, 0.04672128f, -0.04310189f, 0.04501501f, 0.03500541f, -0.01709190f, 0.03613695f, 0.00415975f, 
    0.04439679f, 0.00673332f, -0.04220997f, 0.03601898f, -0.05706999f, 0.04651694f, 0.01012603f, -0.02900284f, 
    0.03972642f, -0.01696786f, -0.03974000f, -0.04696274f, -0.00822155f, 0.03267970f, -0.00047540f, -0.03854834f, 
    -0.02624495f, -0.05280554f, -0.01612774f, -0.05774481f, -0.01214816f, 0.00242495f, -0.04174292f, -0.04309427f, 
    -0.05791097f, -0.04932427f, -0.01446976f, -0.03471337f, 0.03938869f, 0.00998480f, 0.03854547f, 0.02794812f, 
    0.02501167f, -0.04339148f, 0.04203530f, 0.04938196f, 0.04317880f, -0.05116817f, -0.05626856f, -0.04066647f, 
    -0.00182799f, -0.05830036f, 0.00254958f, 0.02857078f, 0.04176976f, -0.05214147f, 0.02435406f, -0.04291745f, 
    -0.00954454f, 0.00622938f, 0.01403418f, 0.03779807f, 0.02752329f, -0.03129372f, -0.04019639f, 0.01656340f, 
    0.01013378f, -0.05352780f, 0.03164751f, 0.01730906f, -0.00127457f, 0.04955637f, -0.02010152f, 0.02992608f, 
    0.03903767f, 0.02837804f, -0.03626275f, 0.01959048f, -0.01976001f, 0.01239717f, -0.01396151f, 0.00089028f, 
    0.02022000f, 0.03120348f, -0.05617184f, 0.02411843f, -0.06080472f, -0.03268676f, 0.02599109f, -0.00464695f, 
    0.04888961f, -0.00660261f, -0.05604284f, -0.03487642f, -0.05798687f, 0.04095602f, -0.03974222f, 0.02059156f, 
    -0.03180660f, -0.02299912f, 0.03703648f, -0.03868996f, -0.01371568f, -0.03941298f, -0.01773740f, -0.04816984f, 
    -0.05559716f, 0.03238283f, -0.02616372f, -0.01996874f, -0.00520596f, -0.05690663f, 0.00729809f, -0.03849234f, 
    -0.03924188f, -0.05637554f, -0.03431839f, -0.04877307f, 0.01663828f, 0.01093337f, -0.00191902f, 0.04827474f, 
    0.00972334f, -0.03175523f, -0.00822168f, -0.05969432f, 0.03802267f, -0.00211398f, 0.04637214f, 0.04851978f, 
    0.01761479f, 0.02303698f, 0.00072294f, -0.01510311f, 0.02556822f, -0.01126690f, -0.06026679f, 0.02574757f, 
    -0.03725581f, -0.02519989f, -0.04929509f, 0.02696711f, -0.03586525f, -0.00325920f, -0.01399276f, 0.01518408f, 
    -0.01477417f, -0.04935934f, 0.05149114f, -0.05424843f, 0.02430958f, 0.03001596f, -0.00554173f, -0.02915134f, 
    -0.01995495f, 0.03094464f, 0.03892198f, -0.05467749f, -0.00093353f, -0.03086608f, -0.01816905f, 0.04482967f, 
    -0.02431426f, -0.05026291f, -0.00127973f, 0.00764993f, 0.01248525f, -0.02101154f, -0.03958362f, 0.02876598f, 
    0.04162337f, 0.00948514f, 0.02230945f, -0.01242922f, 0.02693629f, 0.03374264f, -0.01763136f, 0.01081326f, 
    -0.04326009f, 0.04125444f, 0.04190195f, -0.04713206f, 0.01298774f, -0.00505313f, 0.00140882f, -0.00228394f, 
    -0.04991532f, 0.01611266f, -0.05805814f, -0.00389855f, -0.04501101f, -0.03151964f, -0.01691352f, -0.05224201f, 
    0.02120506f, 0.00935795f, -0.02972800f, -0.00068100f, -0.04542423f, 0.01355690f, -0.05704374f, 0.01216296f, 
    -0.04029995f, 0.03614362f, 0.00485601f, -0.05080049f, 0.04447564f, 0.02743001f, -0.02285900f, 0.01226158f, 
    0.04103220f, 0.03215398f, -0.04877506f, 0.03426769f, -0.00618845f, -0.02058590f, -0.01163454f, 0.03489630f, 
    0.01217370f, -0.00661536f, 0.04465265f, -0.05722926f, -0.01237756f, 0.04089722f, -0.04928143f, 0.04738617f, 
    0.00334060f, -0.03900340f, -0.06032370f, -0.03789908f, 0.02934108f, 0.04804887f, 0.03329515f, -0.02335691f, 
    -0.25189680f, -0.19515033f, -0.08250646f, -0.11033300f, 0.28833675f, 0.01032268f, 0.03365579f, 0.06376426f, 
    0.12476257f, -0.10301197f, -0.01165862f, 0.02240464f, -0.03687906f, 0.11330841f, -0.01934909f, -0.08893134f, 
    0.01359101f, -0.11055987f, -0.00142944f, 0.06163266f, -0.42779523f, 0.01401078f, 0.03692046f, 0.03623751f, 
    0.00758221f, 0.06647642f, 0.06129754f, -0.03608723f, 0.09212640f, 0.01195903f, -0.07408961f, -0.09381825f, 
    0.00696755f, 0.00833863f, 0.07164182f, -0.00319594f, -0.01496240f, -0.18344501f, -0.17414962f, -0.12274274f, 
    -0.59706062f, -0.03788643f, 0.03961727f, -0.00686276f, 0.23176360f, 0.06933510f, -0.01140398f, 0.08194860f, 
    -0.04555830f, -0.04335354f, 0.00220137f, 0.01309301f, 0.00006643f, 0.08627316f, 0.01809509f, 0.01855804f, 
    -0.00488353f, 0.01405009f, -0.00903764f, -0.12684032f, -0.13278320f, 0.13174888f, -0.06972773f, -0.17670363f, 
    -0.09994137f, 0.05232044f, 0.00552596f, 0.16653565f, -0.00798247f, -0.17434423f, -0.09794429f, 0.11929938f, 
    0.10321652f, -0.03810772f, 0.05120908f, -0.09793320f, 0.02996521f, 0.05810825f, 0.11334664f, 0.08926618f, 
    0.06380133f, 0.02005072f, 0.12215250f, 0.18602109f, -0.13239606f, 0.01375704f, -0.08974575f, 0.00736245f, 
    -0.01121031f, -0.00356623f, 0.10926225f, -0.13143410f, -0.01803110f, -0.08588313f, 0.00241080f, 0.00547479f, 
    0.01083233f, -0.09131937f, 0.04489457f, -0.03943106f, 0.05895406f, 0.26985496f, 0.10498645f, -0.01324583f, 
    -0.25426933f, 0.06644975f, 0.00439234f, 0.08504440f, 0.03248449f, 0.06073496f, 0.11198135f, 0.03511038f, 
    0.05566984f, -0.15756959f, 0.09466579f, -0.02787350f, 0.14343411f, -0.18177752f, -0.00344445f, -0.02291816f, 
    0.00118319f, 0.34446111f, -0.13268581f, 0.22416423f, -0.28331655f, 0.15475963f, 0.09822878f, -0.01168986f, 
    0.04790608f, -0.02076782f, 0.06355830f, -0.01750707f, 0.02213203f, -0.01343007f, -0.10892734f, 0.01650034f, 
    0.02436658f, 0.10995320f, -0.12183352f, 0.05132428f, -0.36211848f, 0.00236691f, 0.22273515f, -0.12178948f, 
    0.00081726f, -0.08736450f, 0.04270677f, 0.06869378f, -0.07312618f, -0.18003032f, -0.07426259f, -0.15096985f, 
    0.04909186f, 0.06591356f, -0.06214172f, 0.01629927f, -0.03277430f, -0.01437405f, -0.01253028f, 0.11085904f, 
    -0.42744043f, 0.27280211f, -0.03121267f, 0.00308853f, 0.19996803f, 0.17689559f, -0.16105013f, -0.07268704f, 
    -0.07362121f, 0.03041588f, 0.01489305f, -0.09563565f, 0.17054622f, 0.01758131f, -0.00122165f, 0.02582905f, 
    0.13315517f, -0.01930978f, 0.10878984f, -0.13165744f, 0.00607816f, -0.19953828f, -0.07597847f, -0.09365111f, 
    0.24777910f, -0.03658661f, 0.01316288f, -0.01758321f, -0.00518098f, 0.02252000f, 0.03083757f, 0.05969634f, 
    0.01188209f, -0.03801643f, 0.10758872f, -0.02308473f, -0.01611985f, 0.09449594f, 0.06313783f, 0.14653398f, 
    0.12755027f, -0.15825650f, 0.18193024f, 0.18126136f, -0.03450794f, -0.15596803f, 0.13092573f, -0.17943141f, 
    0.12399683f, -0.08731605f, -0.01886366f, 0.02145397f, -0.08986787f, 0.01487248f, 0.05039098f, -0.06027639f, 
    0.01591217f, 0.06493024f, 0.02099565f, -0.06976865f, -0.16553369f, 0.09250829f, -0.11864582f, -0.02581635f, 
    0.06242906f, -0.02537781f, -0.13140690f, -0.03899756f, 0.01403943f, -0.14602597f, 0.05742165f, 0.00129423f, 
    0.03416748f, -0.01321638f, -0.09236516f, 0.09750018f, -0.10108078f, 0.03823533f, 0.22783220f, 0.09322187f, 
    -0.02210574f, -0.03453193f, -0.12305459f, 0.07960179f, 0.06288725f, 0.06278674f, -0.02737771f, 0.08439741f, 
    -0.01256964f, -0.01343899f, 0.14951843f, 0.01337862f, 0.02625174f, 0.02446789f, 0.13955742f, -0.16159908f, 
    -0.14105541f, 0.02061516f, 0.02827562f, -0.10601997f, 0.00403673f, -0.02324777f, -0.11646745f, 0.11258122f, 
    0.18251896f, 0.17360212f, 0.05779855f, -0.01155219f, -0.01090657f, 0.11553656f, 0.11359030f, 0.04800623f, 
    -0.01786221f, 0.12986065f, -0.01444712f, -0.02599370f, 0.04841233f, -0.13793211f, -0.03598823f, -0.26860806f, 
    0.08284266f, 0.13307285f, 0.07650507f, 0.31786093f, -0.27167627f, -0.00051052f, 0.06087255f, 0.04552408f, 
    -0.08982155f, -0.16511625f, 0.03581284f, 0.13343637f, -0.03682595f, -0.02392182f, -0.02122880f, 0.13759887f, 
    0.02135220f, 0.09264721f, 0.06659751f, 0.12154802f, 0.03580783f, 0.21212476f, -0.01063928f, 0.09563025f, 
    -0.16913551f, -0.04979397f, -0.05324824f, 0.05737159f, 0.02869744f, 0.00503916f, 0.01776387f, 0.11570090f, 
    -0.10886365f, 0.00064877f, 0.04856109f, -0.12143929f, 0.11493226f, -0.14192460f, 0.04436518f, -0.03576749f, 
    0.17407322f, -0.38936239f, -0.17172650f, 0.08876371f, -0.15217240f, 0.14473954f, -0.07629276f, 0.11717322f, 
    -0.13858025f, 0.09622046f, 0.07477990f, -0.00180473f, 0.03451263f, 0.12576793f, 0.10964511f, 0.00892304f, 
    0.10916043f, -0.04264451f, 0.14899975f, -0.04184856f, 0.45492026f, 0.40730101f, -0.06496059f, 0.30791000f, 
    0.29552591f, -0.09367330f, -0.03252586f, -0.13194650f, 0.05869168f, -0.12072490f, 0.03876125f, -0.10463877f, 
    -0.00472445f, 0.16303563f, 0.23044521f, 0.06833066f, 0.00953264f, -0.05214457f, -0.00617398f, 0.04222931f, 
    -0.30773735f, -0.03089889f, 0.01251984f, -0.13121794f, 0.24847053f, -0.04947961f, 0.17200181f, -0.08397628f, 
    -0.03520117f, -0.07531786f, -0.00620283f, -0.02168835f, -0.02931187f, 0.05381761f, 0.03503855f, -0.01875226f, 
    -0.05492184f, 0.01415003f, 0.03610057f, 0.04673009f, 0.24414395f, -0.34094211f, 0.20160316f, 0.01492371f, 
    -0.04138201f, 0.07509830f, 0.08613060f, -0.03086734f, 0.00892650f, -0.09969591f, -0.00841010f, -0.00400507f, 
    0.07477982f, 0.09950816f, 0.06021924f, -0.13379183f, -0.00499372f, -0.01456679f, -0.04038602f, 0.00158677f, 
    0.13314906f, -0.02225507f, 0.26730245f, 0.10535484f, -0.36705410f, 0.08846752f, 0.00032580f, -0.04522795f, 
    -0.01946533f, -0.07558229f, -0.16289833f, 0.01682067f, 0.07552717f, 0.02620362f, -0.08245730f, -0.16490550f, 
    0.04551101f, 0.00432009f, 0.17484006f, -0.05201913f, -0.11679123f, 0.25083235f, 0.10673300f, 0.14661112f, 
    -0.02339795f, -0.00606000f, 0.07200500f, -0.00492825f, 0.07404473f, -0.05658912f, -0.02979887f, 0.02942726f, 
    0.03130503f, -0.01871107f, -0.06118135f, 0.12014860f, -0.05881143f, -0.01213014f, 0.05689401f, -0.10535929f, 
    -0.33071250f, 0.62137151f, 0.04562413f, 0.18172421f, 0.13687474f, -0.15242814f, 0.07888750f, -0.05540812f, 
    -0.00105634f, 0.04126272f, -0.04928005f, 0.07766049f, 0.01475034f, -0.00696776f, -0.01661231f, 0.12779875f, 
    0.00243163f, 0.07348677f, 0.05002236f, 0.13694474f, -0.25533780f, -0.05625885f, 0.05373110f, -0.10171489f, 
    0.23019253f, 0.05691549f, 0.01136213f, -0.06358177f, -0.02402345f, 0.11902300f, 0.14341548f, 0.09085506f, 
    0.03770334f, 0.06819814f, 0.05583727f, -0.06281693f, -0.06881527f, -0.07822139f, -0.07697840f, 0.12139415f, 
    0.21907140f, -0.14859568f, -0.11749806f, -0.17965533f, -0.00475449f, 0.17555836f, 0.17268902f, 0.11283539f, 
    -0.01841808f, 0.05619295f, 0.02845915f, 0.01076449f, -0.07819485f, 0.09908116f, -0.06633571f, 0.10184867f, 
    -0.01678828f, 0.01792645f, -0.11732926f, 0.10773803f, 0.02736705f, 0.07776430f, -0.13219750f, -0.11980721f, 
    0.04831005f, -0.12964718f, 0.13323505f, -0.00760735f, -0.02657583f, 0.07543754f, 0.09796615f, 0.05654663f, 
    0.00708524f, -0.00134496f, -0.04901231f, -0.02767427f, 0.13290189f, 0.05720057f, -0.06625772f, -0.01748232f, 
    0.03676060f, 0.24024469f, 0.04210024f, -0.03078778f, -0.04712914f, -0.09577093f, -0.04868279f, 0.14660868f, 
    0.05955603f, 0.01792463f, -0.07798044f, -0.02858859f, 0.03812014f, -0.07335491f, -0.04955317f, -0.02262224f, 
    0.00873392f, 0.07774936f, -0.02924355f, 0.04594332f, -0.27867311f, 0.12662084f, 0.00467927f, -0.08188749f, 
    0.19830030f, 0.05019192f, 0.05665391f, -0.06426546f, -0.11113595f, 0.07747305f, -0.12161930f, 0.00540128f, 
    0.01791322f, 0.11924924f, 0.07651511f, -0.02322724f, 0.09266553f, 0.09050796f, -0.07065820f, -0.08367630f, 
    0.04487533f, 0.13177063f, 0.08440614f, -0.03746804f, 0.00475839f, -0.19770497f, 0.07235805f, -0.15204935f, 
    -0.00276086f, 0.03294687f, 0.14485066f, -0.07288383f, -0.02342235f, 0.03598040f, -0.07898802f, 0.01708025f, 
    -0.14339700f, 0.01835671f, -0.05116256f, 0.03253980f, 0.18999001f, 0.18723811f, 0.07980058f, 0.09029759f, 
    -0.17268232f, -0.31809461f, -0.08801728f, 0.03181386f, -0.08077661f, -0.01216079f, 0.00653629f, 0.04764912f, 
    0.02257754f, 0.02746606f, -0.11987536f, -0.04789713f, 0.01326356f, -0.09089700f, 0.09891582f, 0.00529063f, 
    -0.30299208f, -0.12950470f, 0.12030102f, -0.01083551f, -0.04648393f, -0.01296242f, 0.10843594f, -0.12668276f, 
    -0.00556814f, 0.10296401f, -0.19523279f, -0.03832263f, 0.06872153f, -0.01316019f, 0.00528717f, -0.09097083f, 
    -0.14376025f, 0.08907041f, 0.08350987f, 0.04137584f, 0.31074557f, 0.02162931f, 0.23253241f, 0.13271619f, 
    -0.36090270f, -0.01506291f, -0.09785775f, 0.10397573f, 0.03344019f, -0.06914245f, -0.00809852f, 0.01301469f, 
    -0.03071427f, -0.07410429f, 0.03920126f, 0.00780496f, -0.08949733f, 0.02286849f, -0.00255153f, -0.03109623f, 
    0.22577322f, -0.12890600f, 0.10481998f, -0.24065340f, 0.15682662f, -0.00739467f, -0.20666364f, 0.03169995f, 
    -0.05014238f, -0.07015419f, 0.00876593f, 0.01514805f, 0.05289653f, -0.01833012f, -0.08766367f, 0.00302430f, 
    0.02146509f, -0.03960652f, 0.01944668f, -0.08849140f, 0.12353055f, 0.16048203f, -0.09666274f, -0.14759004f, 
    -0.21483321f, -0.02113340f, 0.02771878f, -0.10037944f, 0.04916197f, -0.21946566f, 0.10786482f, -0.04110212f, 
    0.02537188f, 0.00451132f, 0.02306090f, 0.15460838f, 0.09831085f, -0.03194118f, -0.02414375f, 0.02324554f, 
    -0.41594958f, 0.06184730f, -0.05760352f, 0.22777833f, 0.01488745f, 0.10239016f, -0.08206862f, 0.12097586f, 
    -0.12880974f, 0.17672181f, -0.09927996f, 0.00289844f, 0.12484452f, -0.02240800f, 0.17189249f, 0.04293210f, 
    -0.07619619f, 0.14926393f, 0.03026722f, 0.07101268f, -0.62596560f, 0.06143727f, 0.07461666f, -0.14397241f, 
    0.11422214f, 0.02734597f, -0.01804455f, -0.04044865f, 0.03689254f, -0.01205923f, 0.09685562f, 0.10766419f, 
    0.01500422f, 0.04890060f, 0.12991706f, -0.10280497f, 0.10616330f, -0.16928090f, 0.20398334f, -0.05333591f, 
    0.05692110f, -0.46449426f, 0.17041896f, 0.11985227f, 0.23561850f, 0.00843817f, 0.13550530f, 0.01575289f, 
    0.04439298f, -0.13389026f, -0.10060922f, -0.02495743f, -0.04369581f, -0.15880772f, 0.13235262f, 0.00605010f, 
    -0.12632248f, -0.09506559f, 0.13747112f, 0.06784290f, 0.26901507f, -0.34395781f, -0.07064152f, -0.03339840f, 
    0.07600560f, 0.01068356f, 0.13091509f, 0.03143726f, -0.05695182f, 0.02965334f, 0.02480537f, -0.00163545f, 
    0.02901956f, -0.12422442f, 0.03316553f, -0.02121441f, -0.02243842f, 0.02831992f, 0.03090625f, 0.03334981f, 
    0.03004809f, 0.39436066f, 0.05295486f, 0.09247763f, 0.03682926f, 0.03811802f, -0.00221604f, -0.05287985f, 
    -0.11791026f, -0.01558147f, -0.02756961f, -0.04499114f, -0.05055192f, 0.09166484f, 0.05809592f, -0.00147035f, 
    0.03278246f, -0.05889360f, -0.07397583f, 0.04394587f, -0.52361089f, 0.00695669f, -0.07610568f, 0.06454305f, 
    0.01483847f, 0.05861670f, -0.12441134f, -0.00738587f, 0.00725538f, 0.11770112f, -0.08615270f, -0.13602002f, 
    -0.08631022f, 0.13495892f, -0.00109721f, -0.02643000f, -0.00928351f, -0.07752455f, 0.12497163f, -0.04737711f, 
    -0.36616054f, 0.16875802f, -0.07752282f, 0.19984630f, -0.08123776f, 0.06795626f, -0.02795675f, 0.06802604f, 
    0.09774767f, 0.09729663f, -0.06410918f, 0.01453872f, -0.09467643f, -0.00954132f, 0.11494350f, -0.00653849f, 
    0.11195411f, 0.17780642f, 0.02379488f, -0.07654892f, -0.17695011f, -0.03993516f, -0.00193181f, 0.05351187f, 
    0.19662078f, 0.00797378f, 0.14816272f, 0.07738895f, -0.06289726f, 0.04989121f, 0.12433336f, 0.09893326f, 
    0.08255422f, -0.09639622f, -0.03107708f, -0.05539787f, 0.10731543f, 0.01670504f, -0.04222705f, -0.03250035f, 
    0.13309762f, 0.06765839f, 0.01259937f, -0.06077579f, -0.15333630f, 0.03611446f, 0.13328904f, -0.08630967f, 
    -0.00729814f, -0.02575601f, 0.05538705f, -0.08393624f, -0.04350288f, -0.06541503f, 0.07010937f, 0.02500613f, 
    0.04194122f, 0.02184233f, 0.03015598f, -0.04697528f, -0.07566892f, 0.16942714f, 0.00625050f, 0.14107968f, 
    -0.11779030f, -0.02904223f, 0.10059679f, -0.04645125f, -0.07111567f, -0.11385045f, 0.03312348f, 0.02204269f, 
    0.09346028f, 0.01898212f, 0.13756342f, 0.05489338f, -0.06243927f, 0.07698201f, 0.00699239f, 0.04870338f, 
    -0.10054497f, 0.12834215f, -0.00132411f, 0.15194665f, 0.01701132f, -0.07304129f, -0.06929018f, 0.00555465f, 
    -0.06297296f, -0.00528974f, 0.01569829f, 0.02407804f, 0.09429286f, -0.01236144f, -0.02513877f, -0.01453021f, 
    -0.05936945f, -0.05721700f, -0.09656303f, 0.13224903f, 0.27698895f, 0.02855766f, -0.12444922f, 0.00565878f, 
    -0.15785635f, 0.05267794f, -0.12270290f, -0.00068474f, -0.05643290f, -0.13072555f, -0.19382398f, 0.07728712f, 
    0.12959959f, 0.15279314f, -0.07263026f, -0.01327605f, 0.09450998f, -0.11904329f, -0.05359517f, -0.01533814f, 
    0.32921493f, -0.08934031f, -0.09416751f, -0.09646805f, -0.12375616f, -0.05038505f, 0.09266795f, -0.09849533f, 
    -0.01222685f, -0.09080396f, -0.06507206f, -0.14812431f, 0.09467660f, -0.01893704f, 0.08928970f, -0.05325653f, 
    0.05160142f, 0.15537344f, 0.11496017f, 0.15315744f, -0.04000246f, -0.18467182f, -0.00726553f, 0.20047507f, 
    0.11809273f, 0.03847415f, -0.01365778f, -0.05521605f, 0.10651782f, 0.01465215f, 0.01578236f, 0.12418596f, 
    0.02735206f, 0.09470587f, -0.08089518f, -0.03586793f, 0.08277953f, -0.12182925f, 0.17579997f, -0.00323376f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02332346f, 0.04869294f, 0.03172968f, -0.02610148f, 0.07163437f, 0.07570233f, 0.02619166f, 0.06035618f, 
    -0.00110701f, 0.07610211f, -0.02470978f, 0.05537939f, 0.01600329f, -0.02107624f, -0.04817263f, -0.00856358f, 
    0.05136723f, -0.04088596f, 0.10301656f, 0.12024477f, 0.01525045f, -0.01314936f, 0.04935789f, -0.00111163f, 
    0.06606939f, 0.05526026f, -0.04740901f, 0.04374621f, -0.01834916f, -0.02301886f, 0.04907530f, 0.12519948f, 
    -0.01052609f, 0.01275364f, 0.01557540f, -0.03128252f, 0.06143124f, 0.03269889f, 0.02637974f, 0.07555816f, 
    0.04382348f, -0.05497085f, 0.07444318f, 0.04807500f, 0.05120102f, 0.09692217f, 0.02510692f, -0.04656458f, 
    -0.02867543f, -0.06363816f, 0.00763360f, -0.02877897f, -0.03965791f, -0.05653839f, 0.04607872f, -0.05470819f, 
    0.02725369f, -0.11316505f, 0.01007053f, 0.06227202f, -0.05157742f, 0.00022360f, 0.03118042f, -0.03557396f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07812417f, -0.25021097f, 0.00843198f, 0.42045829f, -0.25034398f, 0.03011971f, -0.04789504f, 0.06564476f, 
    0.06114012f, -0.50701553f, -0.02645829f, 0.01701721f, -0.05825713f, 0.14748830f, 0.26346001f, 0.12151834f, 
    -0.13771628f, 0.00669646f, -0.58837479f, 0.10301380f, -0.11934052f, 0.09063280f, -0.31782117f, 0.02877953f, 
    -0.10231366f, 0.34081978f, 0.33081654f, 0.00743190f, -0.06755083f, 0.02582593f, -0.09149374f, -0.38580772f, 
    0.14918457f, 0.12492730f, -0.02151724f, -0.23138410f, 0.05198646f, -0.08341589f, 0.12349190f, -0.15684439f, 
    -0.09956210f, 0.09224939f, -0.10204045f, -0.47696877f, 0.01911889f, 0.23710500f, 0.23157553f, -0.10212024f, 
    -0.22050980f, 0.22548924f, -0.03951069f, -0.12284362f, 0.02144043f, 0.03059403f, 0.10998028f, -0.13080156f, 
    0.07935727f, 0.47339815f, 0.08837374f, -0.02716634f, 0.00633936f, -0.12629059f, -0.12986331f, -0.15552910f, 
    -0.05011227f, 0.10409467f, -0.03198572f, -0.03351682f, 0.21442224f, -0.13082381f, -0.02345336f, 0.24955337f, 
    0.00603426f, -0.38850641f, 0.13815585f, 0.16620497f, 0.08643264f, 0.12245487f, -0.19802967f, -0.01033921f, 
    0.27992886f, 0.00006704f, -0.41148162f, -0.06198056f, 0.02678524f, -0.18385175f, 0.27095041f, 0.07597781f, 
    0.10533506f, -0.65756136f, 0.28527084f, -0.05741587f, -0.06870256f, -0.10528251f, 0.00549175f, 0.12315059f, 
    -0.05592582f, 0.16944991f, 0.00764681f, -0.22751468f, 0.15554810f, -0.10708330f, 0.06936654f, 0.16092302f, 
    -0.25035620f, 0.02233114f, -0.21835852f, 0.14880186f, 0.31954420f, 0.11946863f, -0.65327156f, 0.00550554f, 
    -0.48053756f, 0.11460108f, 0.19253097f, 0.05927054f, -0.09519722f, 0.01582288f, -0.10195436f, -0.18274841f, 
    -0.09921642f, 0.00264925f, -0.10562571f, -0.31139094f, 0.04689722f, -0.39122695f, -0.10010158f, -0.28963983f, 
    -0.06740007f, 0.14880963f, 0.07674373f, 0.34618372f, 0.29244098f, -0.29983097f, 0.05038393f, -0.59700263f, 
    0.07487130f, 0.06307205f, 0.31462479f, 0.03259588f, 0.03446187f, 0.11217707f, -0.33872893f, 0.26939300f, 
    0.22734660f, -0.09643969f, -0.26805478f, -0.49807686f, -0.12539764f, 0.22734971f, -0.04656685f, -0.01810301f, 
    -0.21228123f, -0.53682691f, 0.19941729f, 0.06274086f, -0.10377900f, 0.06094706f, 0.05198480f, -0.07893243f, 
    0.18329045f, -0.34112945f, 0.02659344f, 0.14007977f, -0.02081827f, -0.03417125f, -0.04189356f, 0.23666257f, 
    0.03200197f, 0.03119688f, -0.20209208f, -0.33154953f, 0.30929860f, -0.17561975f, 0.35283661f, -0.01276673f, 
    0.31350571f, -0.23495819f, -0.33191395f, 0.06488431f, 0.06764101f, -0.06838794f, -0.05402578f, -0.24818255f, 
    -0.04970300f, -0.03937014f, 0.07112470f, 0.25590944f, 0.08987457f, -0.14805166f, 0.00908029f, -0.19929904f, 
    0.11284374f, -0.13393421f, 0.04236130f, -0.12506208f, 0.23540692f, 0.22729614f, -0.11927870f, 0.23945980f, 
    -0.09244677f, 0.21877381f, -0.45331112f, 0.14044560f, -0.08449986f, -0.15303484f, 0.17964520f, -0.31875956f, 
    -0.46335584f, 0.01477207f, 0.11982975f, -0.17097156f, 0.03121025f, -0.58727741f, 0.14915648f, 0.09172573f, 
    -0.60001969f, 0.05694316f, -0.11748058f, -0.10569280f, -0.00044953f, -0.02814526f, -0.00468116f, -0.30013949f, 
    0.18090181f, -0.42318583f, 0.02995993f, -0.26451549f, 0.20188481f, 0.00572499f, 0.12315135f, -0.25911665f, 
    0.08123206f, -0.07637567f, 0.16078514f, -0.02235626f, 0.16690269f, -0.27765298f, 0.37759188f, -0.22868259f, 
    0.20947087f, 0.15519197f, 0.16067627f, 0.07686499f, -0.10466298f, 0.20722224f, -0.12149047f, -0.27504739f, 
    0.04213126f, -0.48968300f, 0.03462335f, 0.39449754f, 0.04620198f, -0.25936052f, -0.16965443f, 0.36915421f, 
    0.10641925f, 0.20606813f, -0.02791073f, -0.03460334f, -0.25235808f, -0.02566684f, 0.06058160f, 0.14603698f, 
    0.01957687f, 0.00452031f, 0.22200912f, 0.14803435f, -0.03133911f, 0.04982441f, 0.03762490f, 0.20601994f, 
    -0.13614018f, 0.00100950f, -0.11801574f, -0.10711906f, -0.09582676f, -0.45602393f, 0.08923751f, 0.10802356f, 
    0.21944459f, 0.09746253f, -0.33267793f, -0.07036771f, -0.11453201f, 0.01345310f, 0.04999066f, -0.29711652f, 
    0.26471168f, -0.18753158f, 0.03498283f, 0.07108551f, -0.22358860f, -0.03039630f, -0.07457259f, -0.26694399f, 
    0.09815583f, 0.04057289f, 0.19858494f, 0.08155273f, -0.31321689f, 0.12453978f, -0.25556633f, 0.29273587f, 
    -0.15539865f, -0.38207310f, -0.01440305f, 0.10676828f, -0.01267963f, 0.27530396f, -0.04187492f, 0.25553751f, 
    0.09520713f, -0.35966703f, -0.10078766f, 0.29357654f, 0.09374783f, 0.28650305f, -0.10736515f, 0.27070427f, 
    -0.07360470f, -0.31635171f, 0.08695312f, -0.79020077f, 0.21902016f, -0.19403546f, 0.06087856f, 0.09367401f, 
    -0.05355317f, -0.14778750f, -0.26090670f, 0.00496990f, 0.11406541f, 0.22492056f, 0.20129837f, -0.01439300f, 
    -0.06203791f, 0.08502574f, -0.14132263f, 0.18470743f, 0.00021021f, 0.14919202f, -0.06953584f, -0.04593470f, 
    0.31310561f, 0.38888216f, -0.16977191f, 0.01555414f, 0.02375608f, 0.11423517f, -0.03222284f, -0.28208461f, 
    -0.10524598f, 0.01177453f, -0.11298284f, -0.05166111f, -0.13646673f, -0.07072318f, -0.09491202f, 0.19223838f, 
    -0.41815564f, 0.05025469f, -0.08250398f, 0.24607174f, -0.10275449f, -0.08465658f, -0.19733241f, 0.11966158f, 
    0.10640930f, 0.22359122f, 0.10639018f, 0.02935329f, 0.05619230f, 0.01477529f, -0.10083123f, 0.19708347f, 
    0.11072774f, 0.00895475f, 0.07187010f, -0.47954977f, 0.06736333f, -0.00465929f, 0.21517073f, 0.01304330f, 
    0.10136297f, 0.10165639f, -0.01813311f, -0.10013146f, -0.03179293f, 0.09458486f, -0.05132042f, 0.02826133f, 
    -0.03446141f, 0.05310933f, 0.05343364f, 0.01324863f, 0.05224461f, 0.15304248f, -0.22703998f, -0.31381142f, 
    0.20530084f, 0.02272052f, 0.26350206f, -0.12219751f, -0.05191926f, 0.02135037f, 0.05115490f, 0.05134103f, 
    0.09907140f, -0.33089668f, 0.04379724f, 0.05296718f, -0.06216682f, 0.11681829f, -0.06499068f, 0.07302669f, 
    -0.40817147f, 0.07754409f, 0.00359947f, -0.25507110f, -0.24769838f, -0.01270000f, 0.06724875f, 0.11568888f, 
    -0.01831299f, -0.10571836f, 0.09380941f, -0.11883160f, -0.66206968f, 0.04293038f, 0.23975475f, -0.33002043f, 
    0.07876255f, 0.26951167f, -0.33626142f, -0.03207263f, -0.10097796f, -0.49894732f, -0.03513109f, 0.25578237f, 
    0.00992046f, -0.24225609f, -0.02671438f, 0.44159734f, 0.06242933f, 0.21713488f, 0.31709933f, -0.26886073f, 
    -0.02562890f, -0.19902931f, -0.00735720f, 0.08422656f, -0.50026691f, 0.14635985f, 0.04337645f, -0.01178162f, 
    -0.08073738f, 0.21538693f, 0.06245830f, -0.55501354f, 0.06907852f, -0.13904031f, 0.07902952f, -0.56449497f, 
    -0.21686524f, -0.10838291f, -0.00922348f, -0.64471138f, -0.09317381f, 0.33451980f, 0.16626942f, 0.00730164f, 
    -0.36750227f, 0.35823566f, 0.06431120f, -0.08274419f, -0.05226958f, -0.00705500f, -0.06746141f, 0.02203473f, 
    -0.07363156f, -0.22993447f, 0.02786524f, 0.28226259f, 0.17832345f, 0.01427934f, -0.07515723f, -0.35729656f, 
    0.08104331f, -0.09125390f, 0.16333365f, 0.15793851f, 0.03131114f, -0.41470510f, -0.18276337f, 0.26581579f, 
    0.25023293f, -0.23601520f, 0.11865014f, -0.05436581f, -0.05031947f, 0.25418881f, 0.05769368f, 0.30580351f, 
    -0.04214733f, -0.07631487f, -0.01520006f, -0.13432363f, 0.07994606f, -0.05892915f, 0.13814716f, -0.13424005f, 
    -0.04378352f, -0.21086523f, -0.07799690f, -0.32790050f, 0.06309628f, -0.27791360f, 0.03776113f, -0.01854718f, 
    -0.06097443f, -0.29341859f, 0.34754923f, 0.10531408f, 0.00172973f, -0.68124241f, -0.42742565f, 0.03967822f, 
    -0.06022321f, -0.10656939f, 0.07309946f, 0.09006733f, -0.11077950f, 0.08964349f, -0.46176448f, -0.05354714f, 
    0.02772123f, 0.08051089f, 0.01024113f, 0.04565560f, 0.02849766f, 0.07294862f, -0.02743880f, 0.25071713f, 
    0.24398144f, 0.09415708f, -0.02615905f, -0.18049365f, 0.03786806f, -0.10022455f, -0.11016155f, 0.07219295f, 
    0.35174769f, -0.01568055f, -0.42181459f, 0.22332439f, 0.11368106f, -0.14866288f, -0.34295806f, -0.22669184f, 
    -0.16466571f, 0.13626453f, -0.42618901f, 0.06715957f, -0.04554858f, 0.35937500f, -0.09694056f, 0.32585225f, 
    -0.00895336f, -0.12274974f, -0.04366308f, 0.06949022f, -0.00556150f, -0.06933249f, 0.09576009f, 0.26051465f, 
    -0.09562651f, 0.21425903f, 0.06483025f, 0.33938795f, -0.14642034f, -0.19799949f, -0.08877082f, -0.58489382f, 
    0.04026897f, 0.16227551f, -0.40566215f, -0.37761897f, 0.01918725f, 0.16163804f, -0.38740626f, -0.00724258f, 
    -0.24736398f, -0.04898799f, 0.30082551f, 0.11590528f, 0.04363681f, 0.03418169f, -0.05875206f, 0.07611457f, 
    -0.11857771f, 0.19671674f, -0.08770084f, 0.10417912f, -0.11930314f, -0.04471801f, -0.12116601f, 0.15261830f, 
    0.28741822f, 0.30957359f, 0.01986993f, -0.08039007f, -0.56273282f, -0.08456998f, -0.08230643f, -0.29714715f, 
    0.04316135f, -0.09713568f, 0.19075142f, -0.37492901f, 0.14618202f, 0.24374898f, 0.27085799f, 0.09220424f, 
    -0.26503861f, -0.54469502f, 0.31096762f, -0.10092486f, -0.08409931f, -0.25401506f, -0.11581337f, -0.01129192f, 
    0.07602154f, -0.01497751f, -0.00922641f, -0.40580145f, -0.05506615f, -0.10971338f, 0.27995455f, 0.29177064f, 
    -0.01519036f, -0.55081975f, -0.09837932f, -0.14159018f, 0.24577187f, 0.25540361f, -0.06734812f, -0.11017963f, 
    -0.06058720f, 0.23621993f, -0.21614459f, 0.21082789f, 0.09373216f, -0.32685679f, -0.07145711f, 0.11721369f, 
    -0.46841201f, -0.04255103f, -0.07973012f, 0.10720555f, -0.07611109f, -0.10070033f, -0.03730832f, 0.07810623f, 
    -0.36295840f, 0.29172298f, 0.29888734f, -0.06108656f, -0.09976731f, -0.00625254f, 0.06381798f, 0.35766035f, 
    -0.45965198f, 0.23536019f, -0.02592965f, 0.15155680f, 0.21457721f, 0.05692801f, 0.02192604f, 0.33542058f, 
    0.16621038f, 0.08871243f, 0.23480402f, 0.22279002f, -0.03212797f, 0.05288973f, -0.36601982f, -0.29018676f, 
    0.29793531f, -0.45567560f, 0.01235348f, -0.04649879f, -0.00840275f, -0.21679492f, 0.00325284f, 0.03468169f, 
    -0.03218994f, -0.20083159f, -0.00689171f, -0.26603526f, -0.06774732f, -0.27423185f, -0.41722912f, -0.46950638f, 
    0.06540257f, 0.06656864f, 0.07396660f, -0.21883251f, -0.15891176f, 0.11097871f, -0.05711975f, 0.16999321f, 
    -0.10428533f, 0.12201297f, -0.56950420f, 0.01699793f, 0.00727137f, -0.25317186f, 0.00718046f, -0.07933641f, 
    0.40693241f, -0.00036969f, 0.38762581f, 0.14765276f, -0.10268925f, 0.46575388f, -0.38426948f, 0.09118827f, 
    0.10234094f, -0.41531974f, -0.50349396f, 0.10312975f, -0.07548551f, 0.08691741f, -0.02901062f, -0.01433787f, 
    -0.29842916f, -0.31912997f, -0.03264952f, -0.10018740f, 0.31267306f, -0.00619480f, -0.00375545f, 0.10692966f, 
    0.24164440f, -0.02086553f, -0.00623304f, -0.07379076f, -0.32317027f, -0.36167693f, 0.24083772f, 0.22668280f, 
    0.04073634f, 0.24313451f, 0.12942614f, 0.01967531f, 0.10492888f, -0.03353037f, 0.07291757f, -0.43585065f, 
    0.09381503f, 0.14803693f, 0.09795364f, 0.11986642f, -0.05247505f, 0.21433777f, -0.38893044f, -0.05011868f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11658660f, 0.07780308f, -0.02693197f, -0.08889975f, 0.08483224f, 0.02249036f, -0.03106209f, -0.13328758f, 
    -0.09888408f, -0.11498339f, 0.16535285f, 0.02374579f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
