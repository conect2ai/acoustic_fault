#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.77250481f, 0.15530328f, -0.11675780f, 0.31034571f, -0.03222040f, 0.18963683f, 0.52357781f, -0.24217182f, 
    0.49052772f, 0.41388211f, 0.14157635f, -0.19492911f, 0.40755704f, -0.23257393f, -0.13163410f, 0.19352102f, 
    -0.00267824f, 0.11711442f, -0.03233397f, -0.10744521f, -0.31535947f, -0.15449256f, -0.09534079f, -0.01761586f, 
    0.14359784f, 0.35577109f, 0.14578235f, -0.43664536f, 0.28080395f, -0.26959085f, -0.45420721f, -0.36670771f, 
    0.27590543f, 0.13689463f, -0.27012348f, -0.16918276f, -0.32308009f, 0.33760852f, 0.05852638f, 0.04660618f, 
    -0.07557354f, -0.30703145f, -0.28531018f, -0.20167457f, 0.10233200f, 0.03205388f, -0.07623763f, -0.13091862f, 
    -0.33995414f, -0.15176427f, 0.76353979f, 0.61529976f, -0.04303636f, -0.03159345f, -0.19598825f, 0.09333280f, 
    0.34885228f, 0.38205376f, 0.16586818f, 0.48773569f, 0.05698263f, 0.16338970f, -0.19380942f, 0.00297666f, 
    0.22949311f, 0.04115511f, -0.12463648f, 0.00399064f, -0.11874808f, 0.19532697f, -0.04907204f, -0.32004669f, 
    0.03786312f, -0.07572734f, -0.02135120f, 0.09978600f, 0.42037892f, -0.07872210f, 0.28693995f, 0.04699235f, 
    -0.51932693f, -0.77165592f, -0.51253974f, -0.12516497f, -0.22644736f, 0.31349358f, -0.19686429f, 0.00976112f, 
    -0.02696122f, -0.17086513f, 0.02910662f, 0.09436266f, -0.19789614f, -0.16935821f, -0.00891597f, 0.16009611f, 
    0.20094584f, 0.13642019f, 0.08594286f, 0.08290599f, -0.18939947f, 0.32475930f, -0.20828532f, -0.64842743f, 
    0.52493399f, -0.20544398f, -0.13002311f, -0.03736730f, -0.25223622f, -0.38199061f, -0.20664793f, 0.28819427f, 
    0.22260535f, 0.06382114f, 0.22907899f, 0.27183113f, -0.21168564f, -0.24966355f, -0.03390208f, 0.07224492f, 
    -0.22746739f, -0.14900669f, -0.02252967f, 0.12246474f, 0.07790711f, -1.10010147f, 0.92608559f, 0.14464018f, 
    -0.35400325f, 0.12189981f, -0.15530084f, 0.51677287f, 0.04245786f, 0.04053478f, 0.11246188f, -0.18964918f, 
    0.10650263f, 0.02299711f, -0.10625414f, 0.03334818f, -0.03127091f, -0.05992873f, -0.08134790f, -0.04768299f, 
    -0.22462250f, 0.07775576f, 0.15072148f, 0.10371120f, 0.13370924f, -0.00455372f, 0.79600465f, 0.48681706f, 
    0.64023066f, -0.34749374f, -0.08854349f, -0.36510628f, -0.42174464f, 0.15127937f, -0.17748795f, 0.24475341f, 
    0.15821603f, 0.15748146f, 0.11098715f, 0.09802490f, -0.22039990f, -0.00928048f, 0.02639553f, -0.00569000f, 
    -0.00296010f, 0.03077027f, 0.13927200f, 0.30305970f, -0.02725736f, -0.10809437f, 0.19458798f, 0.69055152f, 
    -0.15967615f, -0.75451589f, -0.25167423f, -0.27374810f, -0.29665464f, 0.15980512f, -0.03317612f, -0.01665092f, 
    -0.10352129f, 0.13561915f, 0.20969377f, -0.13778216f, 0.01502445f, 0.15982638f, -0.21249537f, -0.16570480f, 
    -0.30303463f, -0.33039582f, -0.24756603f, 0.05082045f, 0.13424781f, 0.12940982f, 0.14615311f, -0.05361677f, 
    -0.22747107f, -0.27790996f, -0.33370352f, -0.15580879f, -0.31750131f, 0.39781219f, 0.77001625f, -0.41087413f, 
    -0.05494907f, 0.27010328f, -0.03504643f, -0.07099657f, -0.28911412f, 0.01390418f, 0.31488460f, -0.14356685f, 
    -0.14977440f, 0.13287318f, 0.15708241f, -0.13900517f, 0.00707419f, -0.02072354f, 0.07575023f, 0.11086153f, 
    0.13871451f, -0.06508312f, -0.91857374f, -0.38128668f, 0.44123346f, 0.08786311f, -0.72210014f, 0.49908841f, 
    0.40579626f, -0.31618956f, 0.09268941f, 0.20129083f, 0.21569961f, 0.22206581f, -0.10757828f, 0.16518767f, 
    -0.14559850f, 0.27763498f, 0.13211696f, 0.05930480f, 0.03788694f, 0.14832927f, -0.02396619f, -0.03435878f, 
    0.15126954f, 0.17372936f, -0.53788984f, -0.43810099f, -0.70351404f, -0.58163798f, 0.22689340f, -0.23661734f, 
    0.47880274f, 0.42391998f, 0.31659487f, 0.29289386f, -0.13687754f, -0.10368016f, -0.01962521f, -0.33955786f, 
    -0.33620915f, -0.02569919f, 0.05538279f, 0.16648263f, 0.06079844f, -0.14157011f, -0.09353897f, -0.10182089f, 
    -0.19350663f, -0.15498890f, -0.09033959f, 0.81657565f, 0.18883099f, -0.62018543f, -0.35694602f, 0.04506124f, 
    0.41942793f, -0.24748915f, -0.32900158f, -0.53745520f, 0.04062892f, -0.01784812f, 0.24291568f, 0.13654435f, 
    0.04983657f, -0.10763250f, 0.04940027f, 0.08978520f, 0.10239919f, 0.11895863f, -0.03210937f, 0.00694323f, 
    0.17506987f, -0.02351647f, -0.04375743f, -0.00346595f, 1.02465582f, 0.29645362f, 0.39687768f, 0.75710309f, 
    0.69421959f, -0.00455691f, 0.13615589f, -0.23173442f, -0.08085777f, -0.01625948f, 0.09494713f, 0.15885895f, 
    0.12388191f, 0.06413726f, -0.03013964f, 0.03066990f, -0.00078927f, 0.05814561f, 0.11817138f, 0.15714012f, 
    -0.09759180f, 0.07366210f, -0.01724518f, -0.10998916f, 0.09576584f, -0.41380414f, -0.16536410f, -0.59334821f, 
    -0.19654414f, -0.21462965f, 0.10028671f, -0.24132816f, 0.11231428f, 0.13337791f, -0.34774882f, -0.30011576f, 
    0.04955426f, -0.02079216f, 0.01116567f, -0.17773791f, 0.20579976f, 0.01203202f, -0.07336570f, -0.07130264f, 
    -0.29398859f, -0.17459640f, 0.02738412f, 0.14314169f, 0.11247611f, 0.28704453f, -0.08039735f, 0.20057759f, 
    -0.51592106f, -0.52072960f, 0.26693761f, -0.28396213f, -0.41302311f, -0.40369833f, -0.28390118f, -0.12470935f, 
    -0.27323788f, -0.28890821f, 0.03120530f, 0.02083551f, -0.17800167f, -0.27012211f, -0.01862527f, -0.18340881f, 
    0.17682029f, 0.22978006f, -0.14842793f, -0.00282476f, -0.04659042f, -0.05204455f, -0.11925212f, 0.47381604f, 
    0.30519029f, -0.37927333f, 0.24493417f, 0.52627939f, -0.30359218f, 0.03779037f, 0.21648511f, 0.30652320f, 
    0.34525579f, -0.33636913f, -0.13137941f, 0.19461431f, -0.41477072f, -0.11241271f, -0.25239804f, -0.04403103f, 
    0.01927502f, -0.24818096f, -0.04506039f, 0.10869564f, -0.00240129f, 0.06345440f, 0.24242771f, 0.07641208f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04191124f, 0.01814030f, 0.07974645f, 0.22456513f, 0.01618070f, -0.15485850f, -0.02473717f, 0.03982086f, 
    -0.08460107f, 0.17924865f, -0.08504222f, 0.14254981f, 0.20132753f, 0.15777652f, 0.10569471f, 0.17872256f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.26926440f, -0.04219612f, -0.01675955f, -0.09815160f, -0.04500151f, 0.03851281f, -0.05711844f, 0.21338278f, 
    0.05599968f, 0.09243767f, -0.05241676f, -0.06199377f, 0.08510943f, 0.10668977f, 0.03551567f, -0.16750087f, 
    -0.01467963f, -0.03380997f, -0.00501745f, 0.08097593f, 0.19619273f, 0.21511495f, 0.11706292f, 0.18603122f, 
    -0.23517047f, -0.09131987f, 0.07839171f, 0.03085368f, 0.09905282f, -0.07124323f, 0.12180018f, 0.07146511f, 
    0.12257613f, -0.02133790f, -0.09080407f, 0.17829895f, 0.05943535f, -0.06845603f, -0.25385275f, -0.18109412f, 
    0.09886258f, 0.10286909f, -0.09468260f, 0.00373318f, -0.01769491f, -0.03760155f, -0.00365888f, -0.15889856f, 
    -0.06304616f, 0.10529783f, -0.08745901f, 0.23611891f, -0.05863964f, -0.02470580f, 0.04957243f, 0.13200285f, 
    0.16744979f, -0.07261964f, -0.02316049f, -0.16677073f, 0.09616174f, 0.22717564f, -0.18741611f, -0.13933888f, 
    0.04157737f, 0.06162380f, 0.00508140f, -0.04022868f, 0.01083423f, -0.07204699f, 0.08203173f, 0.11502372f, 
    0.31070712f, -0.18714337f, -0.35492885f, -0.11891947f, -0.04181585f, 0.14459312f, 0.04741031f, -0.09079959f, 
    0.06971614f, 0.12161928f, -0.06659424f, -0.05677748f, 0.40022969f, 0.26605922f, -0.02398181f, -0.03086142f, 
    0.12114415f, 0.01591419f, -0.12814802f, 0.17178327f, -0.03115350f, 0.15388362f, 0.10592125f, 0.08155511f, 
    0.18415880f, 0.00707212f, 0.14710671f, 0.28602445f, -0.02915199f, -0.06358464f, -0.03627751f, -0.13433009f, 
    -0.15219130f, 0.01460129f, -0.08221784f, 0.06142322f, 0.17668764f, 0.05123070f, 0.12026175f, 0.15234227f, 
    -0.03990420f, -0.06126197f, 0.13100140f, -0.16120587f, -0.18254346f, -0.14399198f, 0.05380689f, -0.13442734f, 
    -0.31909037f, 0.05142329f, 0.31393573f, 0.43732277f, -0.03534336f, -0.07117081f, 0.18553521f, 0.10850070f, 
    0.05203638f, 0.17152393f, 0.19947900f, 0.04946018f, 0.22867568f, 0.00317933f, -0.22953270f, 0.09735488f, 
    0.22981720f, 0.03564306f, 0.01615958f, -0.04976383f, -0.10449839f, -0.09273221f, 0.00726815f, -0.20592892f, 
    0.11548321f, 0.08742057f, -0.18431096f, 0.01999750f, 0.01336937f, 0.01662070f, -0.08105381f, 0.04238972f, 
    0.00346759f, -0.12668265f, 0.00627638f, -0.15863349f, 0.19698127f, 0.22454393f, 0.19122155f, 0.12370864f, 
    -0.12225418f, -0.17737325f, -0.01150599f, 0.07841378f, -0.02252393f, 0.10735391f, 0.04897893f, -0.09369682f, 
    -0.02866508f, 0.19716452f, -0.08903237f, -0.05106340f, -0.09828117f, 0.06520057f, 0.05140593f, 0.17898938f, 
    0.06670775f, -0.01857997f, -0.07485954f, 0.06078485f, -0.10464889f, 0.05991251f, 0.04052756f, 0.20686059f, 
    0.13483928f, -0.04944340f, 0.00959332f, 0.07066383f, 0.01661096f, -0.02404753f, -0.09693199f, 0.25656193f, 
    0.00307540f, -0.00804990f, -0.04972210f, -0.03789569f, 0.06392036f, -0.03717009f, 0.05711510f, -0.03050087f, 
    -0.06195962f, 0.03350326f, -0.05716308f, -0.03674106f, 0.03305278f, 0.05580779f, -0.03652170f, -0.02807000f, 
    -0.03235817f, 0.04946199f, 0.04821163f, 0.05843541f, 0.05276586f, 0.02651904f, -0.06675588f, -0.03674594f, 
    0.06684955f, -0.00411757f, -0.02018460f, 0.01206938f, -0.04715093f, 0.06718308f, 0.02067307f, 0.01783884f, 
    0.05998193f, -0.01935365f, 0.05777517f, 0.04616000f, -0.02320511f, -0.06794797f, 0.00175267f, -0.04547562f, 
    0.00592156f, -0.03597092f, -0.02913471f, -0.04330993f, -0.02861628f, -0.01242098f, -0.04703861f, 0.04699244f, 
    0.04929055f, -0.04763405f, -0.00778362f, -0.03620636f, -0.07668039f, -0.05132842f, -0.01072837f, -0.01219140f, 
    -0.04063521f, 0.03368180f, 0.06444371f, -0.04799637f, 0.05538983f, 0.03412966f, -0.07330549f, -0.06285062f, 
    -0.03518515f, -0.01705964f, 0.02250249f, 0.03379496f, 0.03643577f, 0.05446596f, -0.07321168f, -0.05317283f, 
    -0.03365640f, -0.02319939f, 0.01447860f, 0.03257780f, 0.05009323f, 0.01728935f, 0.01568430f, -0.00303846f, 
    -0.04372708f, -0.06665649f, -0.07957060f, 0.04273141f, -0.00548076f, -0.01478775f, 0.00758526f, -0.05819303f, 
    -0.05659207f, -0.03165913f, -0.07318448f, -0.00206184f, -0.07615398f, 0.05578539f, -0.01945700f, 0.05902667f, 
    0.04562195f, -0.07070236f, 0.02830009f, 0.02421855f, -0.06470186f, -0.03201501f, 0.03882300f, -0.02042976f, 
    -0.02701056f, -0.02554410f, 0.06788123f, -0.05104584f, -0.03430642f, -0.03205100f, -0.06822401f, -0.06025810f, 
    -0.04789865f, 0.01477733f, -0.05623060f, 0.04808737f, 0.01118816f, -0.02759468f, -0.07186940f, 0.06232247f, 
    -0.00757381f, 0.00173686f, -0.04397758f, -0.06329403f, 0.06046534f, -0.04715823f, -0.06559286f, 0.05410042f, 
    0.03350898f, -0.02279952f, 0.00030970f, -0.04496535f, 0.01072914f, 0.00893216f, 0.03057887f, -0.01414718f, 
    -0.03751395f, 0.06351029f, -0.03152652f, -0.04777380f, -0.06240045f, -0.05572141f, -0.05327995f, -0.05599362f, 
    0.02441931f, 0.06526929f, 0.00452930f, -0.06070967f, -0.02662358f, 0.05232806f, -0.02362015f, 0.00049268f, 
    0.03018921f, -0.04922109f, 0.04540382f, 0.06601680f, -0.01650740f, 0.01879335f, -0.01203680f, -0.02815816f, 
    0.00272784f, 0.05850022f, 0.01196281f, 0.06533419f, -0.05525249f, -0.03817901f, 0.00778206f, 0.04779193f, 
    -0.03127339f, -0.05193153f, 0.04401320f, -0.05406621f, -0.01790789f, -0.00907465f, -0.02199206f, 0.06833588f, 
    0.05296558f, 0.02063153f, -0.06652366f, 0.05609879f, -0.07132242f, 0.05496156f, -0.03765850f, -0.07753108f, 
    -0.04158357f, -0.02576337f, 0.01352392f, -0.07187202f, 0.05622473f, -0.03976766f, 0.01370273f, 0.04077898f, 
    0.24739459f, 0.13386025f, -0.14790808f, 0.10587323f, -0.03429325f, 0.16397297f, -0.05182890f, -0.05086464f, 
    0.09116194f, 0.09397341f, 0.07453061f, 0.03509599f, 0.25560322f, -0.13918148f, -0.05876658f, 0.11563438f, 
    0.05868044f, 0.11974224f, 0.04597934f, -0.07065046f, 0.07227968f, -0.04683923f, 0.08131463f, 0.01045840f, 
    0.21939504f, -0.18463455f, -0.00485351f, -0.00807191f, -0.05027670f, 0.02108888f, 0.01632648f, 0.01199419f, 
    -0.01394721f, 0.07320961f, 0.09455020f, -0.00982791f, -0.12308991f, 0.02639762f, 0.33179983f, 0.22635290f, 
    -0.08025574f, 0.05413824f, 0.09966234f, -0.11121873f, 0.14247942f, 0.11013341f, 0.02941805f, 0.02657527f, 
    -0.05695914f, 0.16546780f, 0.04687940f, -0.28461805f, 0.03483128f, -0.03646932f, 0.00844262f, 0.03491672f, 
    0.08369569f, 0.00197881f, 0.11002281f, -0.12305429f, 0.12751272f, 0.24466297f, 0.09747995f, -0.18681146f, 
    -0.04103351f, 0.03627134f, 0.05817637f, -0.02538453f, -0.04861338f, -0.02740177f, -0.05257685f, -0.07637682f, 
    -0.17547478f, -0.08291402f, 0.14386469f, 0.04202957f, -0.02959928f, 0.07737228f, -0.01588496f, -0.02518050f, 
    -0.05110933f, -0.02494042f, -0.08336840f, -0.02174390f, 0.00626078f, -0.14516656f, 0.12938759f, 0.08485769f, 
    0.05859603f, 0.01143091f, 0.12358076f, -0.00011033f, -0.09218676f, -0.06044996f, 0.02664318f, 0.04470541f, 
    -0.29025933f, -0.16911103f, -0.03301312f, -0.17774120f, 0.02140670f, 0.00554006f, -0.09791611f, -0.00198616f, 
    0.13068917f, 0.08604588f, 0.04410158f, -0.03882383f, -0.46352154f, -0.04244329f, -0.20743398f, 0.11786769f, 
    0.02535674f, -0.02158129f, -0.03033034f, 0.02253237f, 0.02911022f, 0.01098878f, 0.02054551f, 0.11644773f, 
    -0.03813118f, -0.00607796f, -0.17045538f, -0.15945528f, -0.02234701f, -0.01879267f, -0.05999558f, 0.18324624f, 
    -0.01258264f, -0.02181357f, -0.03218166f, 0.14993119f, 0.07824100f, 0.05959067f, 0.38639045f, -0.10092501f, 
    0.03487324f, 0.05430594f, 0.02035033f, 0.08226331f, 0.00775841f, 0.05895850f, 0.01782270f, 0.02447780f, 
    0.19312689f, -0.09134456f, 0.17358057f, 0.11774031f, -0.01194385f, -0.03352772f, 0.08769751f, -0.00169579f, 
    0.12502874f, 0.12287241f, 0.02303644f, 0.07411212f, -0.14066042f, -0.21504474f, -0.13901739f, -0.11379782f, 
    -0.01622025f, -0.06782158f, -0.02771893f, 0.21612123f, 0.12705989f, 0.10307712f, 0.06608166f, 0.01868611f, 
    -0.04824483f, -0.11089768f, 0.05193178f, -0.15731849f, -0.10379343f, 0.08102711f, 0.08947723f, 0.06358149f, 
    0.14285177f, 0.06520868f, 0.07499158f, 0.11789613f, 0.26633948f, -0.12594415f, 0.06312092f, 0.23581782f, 
    -0.08816025f, 0.05405546f, 0.01298988f, 0.00492193f, -0.10563324f, 0.07275669f, 0.07568591f, -0.00300323f, 
    -0.03271618f, -0.07173389f, -0.04679475f, 0.01980403f, -0.02507360f, -0.01774081f, -0.01969182f, -0.06818242f, 
    -0.02084853f, 0.00834205f, 0.05565948f, 0.01704837f, 0.02812200f, -0.04681772f, -0.02877491f, -0.04935910f, 
    -0.02845697f, 0.00785144f, -0.05305416f, -0.00431563f, -0.00141262f, 0.01763220f, 0.00527849f, 0.00895459f, 
    0.02401113f, 0.04002187f, -0.03366583f, -0.03576016f, -0.04426164f, -0.03044898f, -0.01998788f, -0.04818115f, 
    -0.05290808f, 0.01637700f, 0.05097131f, -0.07572666f, -0.04690289f, 0.06758957f, 0.01290751f, -0.01977664f, 
    -0.03232086f, 0.01755241f, 0.01751106f, -0.03382684f, -0.01090014f, 0.04317020f, -0.06554385f, 0.04082543f, 
    -0.02814964f, -0.00627513f, -0.03753537f, -0.06234973f, -0.03072513f, 0.05184024f, -0.05403689f, -0.01058143f, 
    -0.08486791f, -0.03278535f, -0.02865984f, -0.08490504f, -0.01572056f, -0.04547207f, 0.00728787f, -0.05643742f, 
    -0.08772223f, 0.02410504f, -0.06326290f, 0.02164057f, 0.02297978f, 0.04120385f, -0.05616641f, -0.03384449f, 
    -0.05939418f, -0.04938400f, -0.04915880f, -0.05228740f, 0.01524129f, -0.03621960f, -0.01471013f, -0.03389031f, 
    0.00144545f, 0.02453070f, -0.03962832f, -0.00236219f, -0.00777459f, 0.04273868f, 0.04667292f, -0.02557473f, 
    -0.06545073f, -0.04064675f, -0.07560533f, 0.03770197f, -0.04482117f, 0.06309035f, -0.04392433f, 0.04615777f, 
    -0.01507248f, -0.04287786f, 0.00666670f, -0.00778649f, 0.01807607f, -0.07156850f, 0.01994645f, -0.03999946f, 
    -0.07182080f, 0.04568498f, -0.03116342f, -0.03435175f, 0.05247895f, -0.01059797f, -0.02023858f, -0.06974860f, 
    -0.02769489f, 0.03516252f, -0.07255244f, 0.05376830f, -0.02582879f, -0.06533048f, -0.06211724f, 0.03039369f, 
    -0.07373866f, -0.05382333f, 0.03852971f, -0.00944657f, -0.07028867f, -0.01151801f, -0.04324939f, -0.06806425f, 
    -0.04994946f, -0.08160055f, -0.00764705f, -0.07912481f, 0.05320207f, -0.05305144f, -0.02985494f, -0.08930056f, 
    -0.01204541f, -0.05454769f, 0.01458762f, -0.07378908f, 0.01080617f, -0.02936738f, -0.07196389f, -0.01643302f, 
    -0.05523074f, -0.05555116f, -0.01637345f, 0.04849663f, -0.01216942f, -0.00663923f, 0.02315130f, -0.02602037f, 
    -0.02608647f, -0.07474405f, 0.03685042f, 0.02017556f, -0.02418521f, -0.03158370f, -0.04474226f, -0.00892210f, 
    0.01027779f, -0.06415170f, 0.06487775f, 0.05136837f, 0.04567738f, 0.01165877f, 0.00174075f, 0.02377382f, 
    0.00832369f, -0.01642714f, 0.00740437f, -0.04981301f, 0.02018570f, -0.05475036f, -0.05569737f, -0.00514184f, 
    0.01281621f, 0.05866187f, -0.06598887f, -0.04427450f, 0.04942032f, 0.05149456f, -0.02705870f, -0.03460072f, 
    -0.05466576f, -0.06630150f, 0.02438966f, 0.05115838f, -0.03917741f, 0.04279895f, 0.01876181f, -0.00232844f, 
    0.03486390f, 0.08362788f, -0.06344236f, -0.16976716f, 0.05155868f, 0.09605842f, -0.00406688f, 0.11800522f, 
    0.13516562f, 0.00481033f, -0.11436684f, -0.02566134f, 0.20959227f, 0.22646868f, 0.02886105f, 0.00197675f, 
    -0.02893513f, 0.09947888f, 0.02870449f, 0.00441422f, 0.07656102f, -0.00857177f, 0.09709096f, 0.15452388f, 
    -0.60868609f, -0.14890946f, 0.03344626f, -0.04262386f, -0.01287274f, 0.04366447f, 0.07554180f, 0.14291060f, 
    0.05233380f, -0.11268158f, 0.01318314f, -0.03166231f, 0.20255394f, 0.10213541f, -0.06535257f, 0.02600878f, 
    0.02040810f, 0.01298127f, -0.12477601f, 0.02056469f, -0.05113171f, 0.08404679f, -0.00485456f, -0.18022944f, 
    0.20204194f, -0.06882953f, 0.09098373f, 0.16225931f, -0.05766367f, -0.05924653f, -0.01218896f, 0.14646949f, 
    0.06534851f, -0.02149987f, 0.12962626f, -0.10136610f, -0.00306598f, 0.13600111f, 0.04904483f, -0.08194590f, 
    0.12514329f, 0.00881054f, -0.00517503f, 0.08506237f, -0.04793217f, 0.02259084f, -0.16475956f, 0.14571081f, 
    -0.14107300f, -0.07153919f, -0.19556789f, 0.09674189f, 0.03204098f, 0.11325967f, -0.04109197f, -0.09785991f, 
    0.04541941f, 0.11923489f, 0.02269531f, 0.00264467f, 0.11205162f, 0.03855563f, -0.00654278f, 0.03878560f, 
    -0.02133254f, 0.10492653f, -0.01838620f, -0.04543025f, -0.11904711f, 0.04633689f, 0.07586245f, -0.01268230f, 
    0.16580977f, 0.22034450f, 0.07613204f, 0.22546560f, 0.02991326f, 0.07870483f, 0.02829904f, -0.05379739f, 
    0.02043155f, 0.05507119f, 0.10482512f, 0.05729954f, 0.05870807f, 0.04237104f, 0.15231830f, -0.07433877f, 
    -0.04920132f, 0.00544673f, 0.09755543f, -0.08054490f, 0.01775508f, 0.05060604f, -0.07271565f, -0.07738350f, 
    -0.06693681f, 0.14020044f, 0.00975999f, 0.00167624f, 0.03065795f, -0.06421857f, 0.19135466f, 0.05059817f, 
    -0.08923429f, -0.01347153f, 0.06102328f, 0.09734068f, 0.08274289f, -0.00263352f, -0.05301712f, 0.18951525f, 
    -0.07666848f, -0.08327212f, 0.05248938f, 0.04682462f, -0.13182068f, 0.04990962f, -0.02838918f, -0.09775366f, 
    -0.06121889f, 0.05822437f, -0.18631823f, -0.19155331f, -0.08759797f, 0.11926012f, 0.03924553f, 0.04396136f, 
    0.06928368f, -0.06327086f, 0.05869017f, -0.09638251f, 0.25160971f, 0.21043205f, 0.08226900f, 0.18545093f, 
    -0.06816423f, -0.10569906f, 0.03509773f, -0.05190332f, -0.06828973f, -0.00090597f, 0.01781623f, -0.07775827f, 
    0.15616058f, 0.21426959f, 0.17196608f, 0.24005638f, -0.12625311f, -0.02643383f, -0.09219271f, 0.00760624f, 
    0.06797182f, -0.14615314f, -0.10154356f, 0.06473345f, -0.22401308f, -0.00106837f, -0.04072694f, -0.12631612f, 
    0.16798903f, -0.01417009f, -0.08181523f, -0.02452722f, -0.07284931f, 0.11869778f, -0.00498856f, 0.05728806f, 
    -0.04574145f, 0.11608342f, 0.05153717f, 0.05604180f, 0.13200837f, 0.01156923f, -0.17472433f, 0.18291311f, 
    -0.05394518f, 0.02705425f, 0.13647872f, 0.08159254f, -0.25711739f, -0.29101905f, 0.02969506f, -0.05272353f, 
    -0.07329316f, 0.02461824f, 0.08111079f, 0.01990146f, -0.07279617f, 0.09376989f, -0.15633881f, -0.06462682f, 
    0.26476777f, -0.07154857f, 0.05378313f, -0.11314427f, 0.13386086f, 0.00670230f, 0.05554159f, -0.06264762f, 
    -0.07936915f, 0.09923998f, 0.08256371f, 0.14112361f, -0.13771656f, -0.08640311f, 0.15467113f, -0.16840298f, 
    0.01299387f, 0.00461588f, 0.03901258f, 0.05895921f, 0.04642540f, -0.02615861f, 0.05638912f, 0.08230503f, 
    0.06149052f, -0.00094223f, 0.09597352f, -0.16372114f, -0.00060030f, 0.05176872f, 0.19810686f, -0.07911965f, 
    0.12474860f, 0.13755073f, -0.13147208f, 0.00843345f, 0.00786953f, 0.03675616f, -0.31543154f, -0.18504237f, 
    0.04587997f, 0.10920242f, -0.02735263f, -0.08142761f, 0.10107058f, 0.02221488f, 0.11486577f, -0.03730744f, 
    -0.11624467f, -0.01554336f, 0.22813323f, -0.18711764f, 0.05619445f, 0.08817606f, 0.10841094f, -0.08906925f, 
    -0.04803863f, -0.07071122f, -0.04102413f, 0.02460174f, 0.20034781f, -0.33456179f, 0.22283977f, 0.03531377f, 
    -0.10710402f, 0.07542169f, -0.00960627f, 0.06075759f, -0.07833783f, -0.04073438f, -0.07982016f, 0.10801923f, 
    0.07936274f, -0.00895262f, -0.06350137f, -0.05148606f, 0.01865091f, -0.22681038f, -0.16524097f, 0.11147772f, 
    0.07335731f, -0.02922961f, 0.01804432f, -0.01292359f, 0.44168252f, -0.28430441f, -0.05137047f, 0.20614739f, 
    -0.14570281f, 0.04506477f, -0.07150586f, 0.00439606f, -0.04083890f, 0.00196676f, 0.11536771f, 0.00741072f, 
    0.43142340f, -0.07574481f, -0.00146793f, 0.13035369f, -0.17064825f, -0.12349323f, -0.10722680f, 0.17842861f, 
    -0.00198387f, 0.06724682f, -0.07685839f, -0.05964426f, -0.24251206f, -0.08292335f, 0.23627004f, -0.18278398f, 
    0.22843716f, 0.00226230f, -0.01202779f, 0.04372518f, -0.00949805f, -0.02240429f, -0.01841854f, 0.04047575f, 
    0.00317268f, -0.07106277f, -0.09999267f, 0.09813306f, 0.19706143f, 0.00095031f, 0.00088135f, -0.06396502f, 
    0.06162259f, 0.00059490f, -0.06057709f, 0.00536503f, -0.14047806f, -0.08660035f, 0.01932284f, -0.10247693f, 
    -0.15986444f, -0.16591153f, -0.06311020f, 0.21985672f, 0.08026923f, 0.00907362f, 0.02644011f, 0.13229288f, 
    -0.12374251f, -0.21037990f, 0.01340723f, -0.20602238f, -0.03312856f, 0.12862119f, 0.15317914f, 0.07021295f, 
    -0.04854156f, 0.26828989f, 0.03783401f, 0.04993554f, 0.28599960f, -0.11095774f, 0.02244623f, 0.13607085f, 
    -0.01173991f, 0.02910105f, 0.13263808f, 0.03108152f, 0.02298682f, -0.07973947f, 0.02327057f, 0.00821884f, 
    0.13079776f, 0.06671297f, -0.20568524f, -0.04586269f, -0.12438556f, -0.00133068f, 0.11113332f, -0.07250673f, 
    -0.02024358f, -0.03927593f, 0.03374935f, 0.08034447f, 0.06882205f, 0.11929230f, 0.02160987f, -0.04963730f, 
    0.00420980f, -0.04908006f, -0.05790179f, 0.11235416f, 0.07354392f, 0.00664749f, 0.17230107f, 0.15027398f, 
    -0.11142198f, 0.12771063f, -0.09720314f, -0.01999665f, -0.04037141f, -0.02612861f, -0.07330552f, 0.06000282f, 
    0.00388974f, -0.04438551f, 0.04705758f, -0.01537065f, 0.27421033f, 0.00214883f, -0.28358015f, 0.13964833f, 
    0.12958655f, 0.08152347f, 0.09701159f, 0.07115877f, -0.05000454f, -0.03134412f, -0.07500574f, -0.02916553f, 
    0.06404313f, 0.00525871f, 0.02891399f, 0.04163355f, 0.02623346f, 0.09132849f, -0.02845426f, 0.08860508f, 
    0.10670976f, 0.02580909f, -0.04671736f, 0.03622941f, -0.36582160f, 0.22830386f, -0.14163584f, 0.03583699f, 
    0.02947774f, 0.04512301f, -0.12538885f, 0.12602891f, -0.06218461f, 0.05118259f, -0.01652949f, -0.04162164f, 
    0.24253306f, 0.13494202f, -0.26069120f, 0.17009547f, 0.16028155f, 0.04604628f, -0.01130538f, 0.07875764f, 
    0.12438232f, 0.01160369f, 0.03165890f, -0.02828798f, 0.16221319f, 0.01547602f, -0.06356823f, -0.05761750f, 
    0.11771631f, -0.05161626f, -0.07635517f, 0.07593850f, 0.11458766f, 0.09598378f, 0.06688591f, 0.02361977f, 
    0.44621491f, -0.08426274f, -0.23807976f, 0.01272677f, -0.13857456f, 0.09210361f, -0.02518932f, -0.06524784f, 
    -0.11510555f, -0.06920432f, 0.00884265f, 0.07116745f, -0.09187251f, 0.03528305f, 0.11053466f, -0.00371532f, 
    0.05775639f, 0.04579960f, 0.14042795f, -0.03798394f, 0.04534172f, -0.04911823f, -0.07435023f, -0.01151418f, 
    -0.25537783f, 0.19729567f, -0.20999990f, -0.24045765f, -0.00371457f, -0.14162694f, 0.00859097f, -0.08822481f, 
    0.05577014f, 0.06466537f, -0.02260523f, 0.06608290f, 0.33110225f, -0.01434073f, -0.14846307f, 0.14044306f, 
    -0.09111116f, -0.05401542f, -0.09405014f, 0.11612321f, 0.14819673f, 0.00766219f, -0.06618543f, -0.04260577f, 
    0.16982955f, -0.13365658f, 0.18797481f, 0.13545205f, -0.02078583f, 0.17907190f, -0.06644504f, -0.12419862f, 
    0.05943124f, -0.01275698f, 0.10491176f, -0.00856397f, 0.10335096f, 0.16344233f, 0.02653052f, -0.07330058f, 
    -0.09590267f, -0.15110971f, -0.04597637f, -0.09125910f, -0.02246097f, 0.06595733f, 0.01209980f, -0.02964179f, 
    0.02360204f, 0.22851032f, 0.02815420f, 0.07769585f, -0.11644573f, -0.02225710f, -0.10752371f, 0.09678547f, 
    0.16190425f, -0.07037776f, 0.05420195f, -0.03941005f, -0.38006330f, 0.05450121f, -0.06574337f, -0.11046772f, 
    0.10184838f, 0.07831891f, -0.01450300f, -0.02596262f, -0.00167715f, 0.03952663f, -0.00737017f, 0.04029107f, 
    0.23610128f, -0.19341746f, -0.00033527f, -0.04600040f, -0.14029926f, 0.11781952f, -0.04961970f, 0.06749025f, 
    0.08110990f, 0.11327805f, 0.01694898f, -0.05001700f, -0.12960599f, 0.00261004f, -0.06782795f, -0.09906823f, 
    0.02572617f, -0.09664214f, 0.00048906f, 0.15859142f, 0.12888828f, 0.09336215f, 0.10897588f, -0.03522450f, 
    0.20252158f, 0.06057271f, 0.04392293f, 0.16417363f, -0.15256619f, -0.14605787f, 0.04255907f, 0.06624468f, 
    -0.08670466f, -0.01829638f, 0.02566429f, -0.07192776f, -0.23516184f, -0.09676995f, -0.04401645f, -0.06539919f, 
    0.03592989f, -0.10990681f, 0.08959854f, -0.03930607f, -0.00764872f, 0.08059485f, 0.06155089f, -0.01136445f, 
    -0.32939696f, 0.18949170f, -0.13410008f, -0.08960356f, -0.00596133f, -0.02237537f, -0.05514847f, -0.00567877f, 
    0.03197059f, -0.01603506f, -0.11588007f, -0.04900653f, 0.44351521f, 0.10614325f, -0.17379710f, 0.00391585f, 
    -0.04085842f, 0.05410341f, 0.16058433f, -0.05830704f, -0.01884704f, -0.05053072f, 0.01258025f, -0.06115661f, 
    0.03179898f, 0.13401859f, 0.05864046f, 0.01714561f, -0.18657742f, -0.00257601f, -0.12383705f, -0.09174958f, 
    -0.08024644f, -0.03597964f, 0.02380520f, -0.07922690f, 0.04444943f, 0.14150546f, -0.08669408f, -0.25287485f, 
    0.19961575f, -0.01151877f, 0.02706348f, -0.00594945f, -0.09710331f, -0.00325736f, 0.18243425f, 0.00815282f, 
    0.13888711f, -0.10318948f, 0.22731753f, -0.00727761f, 0.04034984f, 0.04461452f, 0.02510033f, -0.05353065f, 
    -0.02553927f, 0.01423070f, 0.05245788f, 0.15601765f, 0.20046198f, -0.14327846f, -0.07181905f, 0.02619288f, 
    0.01052904f, 0.04430938f, 0.06610221f, 0.04812510f, -0.00928142f, -0.06806899f, 0.03395309f, -0.06297005f, 
    -0.08758206f, 0.00023427f, 0.03562209f, 0.05689654f, 0.12988217f, -0.03681425f, 0.06129721f, 0.07576203f, 
    0.16398415f, -0.03824168f, 0.02535219f, 0.08603693f, 0.04038800f, -0.02365807f, -0.09598909f, -0.36144328f, 
    0.01620412f, -0.14128074f, -0.05098838f, 0.00724119f, 0.01023195f, -0.19719802f, 0.09284580f, -0.03003046f, 
    0.37898049f, 0.32674074f, 0.15968634f, 0.27361035f, -0.03604765f, -0.07118299f, -0.12518939f, 0.01496811f, 
    0.01090498f, 0.12251601f, -0.05264070f, 0.01818979f, -0.16898905f, -0.10334617f, -0.02313180f, -0.18407977f, 
    0.06932727f, -0.10447879f, -0.00716062f, 0.18359971f, 0.07675280f, 0.09364506f, -0.03553059f, -0.14240940f, 
    -0.30839479f, -0.07682534f, -0.17602356f, -0.23305586f, 0.08443647f, 0.01324488f, 0.10394401f, 0.09016705f, 
    0.00136215f, 0.03025003f, 0.02430005f, -0.02213121f, 0.21004376f, 0.13294545f, 0.16720822f, 0.12664255f, 
    0.00192628f, -0.04997689f, -0.01049373f, -0.02909253f, 0.05196621f, 0.07997284f, -0.11961963f, 0.04161771f, 
    0.01775156f, 0.06627093f, 0.05610029f, 0.02329334f, -0.04682570f, -0.00381685f, 0.02061294f, -0.03263951f, 
    -0.02348487f, -0.00994257f, 0.00683244f, -0.05496356f, 0.06607893f, 0.04072673f, 0.02940898f, 0.03888016f, 
    0.04915336f, -0.05034918f, 0.02185958f, 0.05744570f, -0.04969298f, 0.02948932f, 0.05502440f, -0.01210251f, 
    -0.06523859f, -0.06333527f, 0.04563580f, 0.01064044f, -0.05700466f, 0.03537657f, 0.06424733f, 0.04028090f, 
    0.02687904f, 0.04618587f, -0.06635345f, 0.05532707f, -0.04232847f, 0.02631165f, -0.04698562f, -0.04727210f, 
    0.03385891f, -0.04606533f, -0.02895240f, 0.04541093f, 0.03617471f, -0.06930393f, -0.00835425f, -0.03185163f, 
    -0.03864398f, -0.05756697f, -0.04709223f, 0.00117297f, -0.05695201f, -0.05475717f, 0.05157428f, -0.04070209f, 
    0.02616058f, 0.05584764f, -0.05825232f, 0.02729821f, -0.06391747f, -0.00749668f, -0.06265734f, -0.02989169f, 
    -0.06591153f, -0.02844925f, -0.03278944f, 0.00092914f, 0.03507498f, 0.00380058f, 0.02657975f, 0.01522519f, 
    -0.00213533f, 0.05668033f, 0.02422526f, -0.03880087f, -0.04763715f, -0.04520407f, -0.01235990f, 0.02801185f, 
    -0.07104056f, -0.04837734f, 0.06063712f, 0.01366019f, 0.01499665f, -0.06692945f, 0.05242825f, -0.06263681f, 
    -0.02193029f, -0.05294072f, 0.00542602f, -0.07372277f, -0.03952647f, 0.06649319f, -0.00330887f, -0.06781587f, 
    -0.05979034f, -0.01143187f, -0.00231470f, -0.05407015f, -0.06474317f, 0.03542189f, 0.00271452f, -0.00958154f, 
    -0.04010385f, 0.05612050f, -0.05528341f, 0.04370030f, 0.03483879f, 0.05783561f, 0.01389177f, -0.00824897f, 
    -0.05556633f, -0.06509411f, -0.03751061f, 0.01809984f, -0.06699817f, 0.06564559f, -0.06088946f, -0.06740030f, 
    -0.02311296f, -0.05722222f, 0.06069329f, 0.03444225f, -0.03191499f, -0.03302202f, -0.02707528f, -0.06841376f, 
    0.01413980f, 0.03389437f, 0.03159431f, -0.00818671f, -0.02186624f, 0.06541473f, -0.06468474f, -0.03262965f, 
    -0.04198013f, -0.03983195f, 0.00190218f, -0.03140109f, -0.00611729f, 0.01266507f, -0.02478542f, -0.01935412f, 
    0.01729657f, -0.00944837f, 0.00651862f, -0.02822984f, 0.05164391f, -0.01552030f, 0.03555585f, -0.01587714f, 
    -0.00991899f, -0.04920011f, -0.03199136f, -0.00130770f, -0.06568822f, -0.04314981f, 0.02346111f, 0.03465306f, 
    -0.04814687f, -0.04080699f, 0.06617164f, 0.05686850f, -0.05293402f, -0.05168397f, -0.06947262f, -0.00553288f, 
    -0.05140138f, 0.01540876f, 0.04455063f, -0.05140722f, 0.02279830f, -0.00127593f, -0.07203893f, -0.02111378f, 
    -0.02757832f, -0.00705216f, -0.02521636f, -0.00401714f, -0.02763259f, 0.01746150f, 0.02672830f, -0.06770656f, 
    -0.05246569f, 0.04379401f, -0.04486420f, -0.01715627f, 0.03528052f, 0.01268238f, -0.01090321f, -0.06794772f, 
    -0.20256113f, -0.22157995f, 0.02320634f, 0.07249528f, -0.03797197f, -0.00815125f, 0.15079537f, -0.12198864f, 
    -0.01829184f, -0.00429191f, -0.14325222f, 0.03395458f, -0.22119044f, 0.18465935f, 0.14940329f, 0.08617168f, 
    0.09472394f, -0.04318449f, 0.05863660f, -0.05305050f, -0.04360385f, 0.01743737f, 0.04113031f, 0.02292966f, 
    0.07183547f, 0.33884016f, 0.00376702f, 0.16009837f, 0.02631431f, 0.14021495f, 0.03124005f, -0.02282452f, 
    0.10090436f, -0.08593467f, -0.05042959f, -0.08247171f, -0.02094530f, 0.09804419f, -0.08726338f, -0.04906338f, 
    0.11989124f, -0.03220286f, 0.03777123f, 0.04024457f, -0.01925968f, -0.06277975f, 0.00448360f, 0.08702093f, 
    0.18093914f, -0.06783479f, -0.06450443f, 0.31172070f, 0.02987039f, 0.04715895f, -0.03006887f, -0.00703490f, 
    -0.01532857f, 0.07933477f, 0.08296283f, 0.13753122f, -0.24684830f, -0.30324197f, 0.00741330f, 0.35117668f, 
    0.08354417f, -0.01344652f, -0.13404544f, 0.09737856f, -0.00363131f, -0.05684695f, 0.10972529f, 0.01872581f, 
    0.26838988f, 0.14772516f, 0.05438621f, 0.23250945f, 0.12435021f, 0.15917975f, -0.03089545f, -0.01753079f, 
    -0.04034558f, 0.00809089f, 0.10691603f, 0.08323472f, -0.11721325f, 0.19808409f, -0.00148912f, 0.08114358f, 
    0.02515173f, -0.00408620f, 0.01611045f, 0.00307747f, 0.19606255f, -0.11252991f, -0.08226823f, 0.00341188f, 
    -0.04823478f, -0.02531989f, -0.23634084f, 0.00716505f, -0.06462587f, 0.06010396f, 0.12666380f, -0.02617416f, 
    0.01320833f, 0.05990236f, -0.08141840f, -0.04302153f, 0.05922462f, 0.08495206f, 0.00911628f, -0.23470378f, 
    0.03489070f, 0.03230160f, -0.03197908f, 0.02272333f, 0.07881368f, 0.04618264f, 0.02732759f, -0.05529612f, 
    0.13482146f, -0.42202705f, -0.19254920f, -0.10156861f, -0.01046211f, -0.02175484f, -0.01332140f, -0.09977738f, 
    0.14324901f, 0.06103985f, -0.07277261f, -0.08319449f, -0.11345419f, 0.02819044f, -0.15803120f, 0.27210936f, 
    0.07030697f, 0.14531200f, -0.10562547f, 0.01022709f, 0.16203393f, 0.13943411f, 0.04551666f, 0.03607592f, 
    -0.31947592f, 0.17715479f, 0.03402256f, -0.38822186f, 0.05788012f, 0.03561279f, 0.12625560f, -0.14857404f, 
    -0.02452645f, -0.08637916f, -0.08049519f, 0.15381582f, -0.02330322f, 0.00718862f, 0.01623405f, 0.25781465f, 
    0.12896696f, 0.22052000f, 0.13290797f, -0.15561570f, -0.00840846f, 0.05104914f, 0.12182146f, 0.12525220f, 
    0.17536654f, -0.01650668f, -0.11577262f, 0.15159139f, 0.03847167f, 0.03035541f, -0.09650902f, -0.05556869f, 
    -0.01240317f, 0.11203166f, -0.01628548f, 0.13571405f, -0.16864555f, 0.03903605f, 0.01217051f, -0.35787091f, 
    0.00573089f, 0.06934499f, 0.00301416f, -0.02318821f, 0.10679166f, -0.07978714f, 0.14267763f, -0.06507893f, 
    -0.33880058f, -0.15128054f, -0.08754785f, 0.03054122f, -0.02407685f, 0.01592520f, 0.10567939f, 0.03194287f, 
    -0.08202198f, 0.01881681f, 0.11649168f, 0.01628224f, -0.23844871f, 0.10172739f, -0.07561993f, -0.01751414f, 
    -0.05174217f, -0.10130724f, -0.03650026f, 0.02128039f, -0.03039817f, 0.07815211f, 0.00432764f, 0.01257714f, 
    0.26274663f, -0.03818275f, -0.09662586f, -0.01746461f, 0.12457587f, -0.02504471f, -0.19816032f, -0.09807214f, 
    -0.04389919f, 0.08558188f, -0.00823797f, 0.14808497f, 0.19615845f, 0.00152129f, -0.00563407f, 0.17814830f, 
    -0.03967381f, 0.05296385f, 0.00514021f, 0.11532764f, 0.03716774f, 0.01188586f, -0.04623481f, 0.17620003f, 
    -0.10652216f, 0.12227093f, -0.04125061f, 0.25980264f, 0.07347924f, 0.08799104f, 0.08892962f, 0.02395495f, 
    -0.08278792f, 0.03513928f, -0.00178138f, 0.13924274f, -0.55431104f, 0.25410551f, -0.24461749f, -0.02933610f, 
    -0.06030466f, 0.03959813f, -0.02735774f, 0.06389786f, 0.09659915f, 0.03249405f, 0.15620194f, -0.02774326f, 
    0.20548448f, 0.12189032f, 0.07247239f, 0.00405943f, -0.01856934f, -0.14843614f, 0.02054693f, 0.06817985f, 
    0.14349271f, 0.01451271f, 0.07565312f, -0.06752159f, -0.01213043f, 0.01739130f, 0.04373831f, -0.20101428f, 
    0.09302902f, -0.06405357f, -0.02815209f, 0.09789985f, 0.10756814f, 0.00585416f, -0.12041485f, 0.01123213f, 
    -0.06355760f, -0.21535438f, -0.27391168f, 0.02269559f, -0.10426628f, -0.14139825f, 0.03912318f, 0.12860680f, 
    -0.05818684f, -0.05839593f, -0.06185278f, -0.10104311f, -0.45260248f, 0.08711623f, 0.01866317f, 0.05984775f, 
    0.09614641f, 0.07804099f, 0.02221224f, 0.10216147f, -0.03664602f, -0.05932653f, 0.08919626f, 0.07430133f, 
    -0.19161588f, 0.05461595f, 0.03692938f, 0.03668823f, 0.00361572f, -0.16916743f, 0.04344455f, -0.18678541f, 
    0.14749494f, -0.06949008f, -0.05980090f, -0.04916198f, 0.09973198f, -0.03922294f, -0.07578610f, 0.07164510f, 
    -0.02249791f, 0.05198480f, -0.08544284f, -0.08736984f, 0.23585846f, -0.11082242f, 0.02528987f, 0.00774056f, 
    0.21165913f, -0.15910666f, 0.08095108f, 0.16260016f, 0.00042948f, -0.10354654f, -0.06760150f, -0.00379964f, 
    0.11778887f, -0.02018640f, 0.01466228f, 0.15811422f, 0.00452136f, 0.02716600f, 0.01507032f, -0.08762056f, 
    0.14382124f, 0.08354927f, 0.06758756f, -0.10223273f, 0.01504557f, -0.02838632f, 0.04421009f, -0.03408350f, 
    0.04901827f, 0.18479320f, -0.04029975f, 0.07503147f, 0.05142115f, -0.07825535f, 0.07166062f, 0.07399265f, 
    0.00090506f, 0.06823220f, 0.08225383f, -0.07502301f, -0.00384911f, -0.00302248f, -0.04633825f, -0.06206848f, 
    -0.01750698f, 0.07051329f, 0.07008251f, -0.00735715f, 0.20811410f, -0.04497755f, 0.01141689f, -0.04735703f, 
    -0.00202289f, -0.01861533f, -0.05577232f, -0.02620774f, 0.02254109f, 0.02351829f, -0.03373548f, -0.06503513f, 
    0.00929723f, -0.01983897f, -0.01745355f, -0.04541517f, 0.06471191f, 0.04247395f, -0.01423500f, -0.07150858f, 
    -0.01244443f, 0.04374536f, 0.04602112f, -0.06223879f, -0.04432062f, -0.01912470f, 0.03491018f, -0.03413233f, 
    0.06064317f, -0.02945147f, 0.00687026f, -0.06454893f, -0.04410544f, -0.05857885f, 0.04223313f, 0.02270867f, 
    -0.04645556f, 0.00091261f, -0.03431369f, 0.00674520f, -0.06485020f, -0.03785235f, 0.02116861f, -0.05053164f, 
    -0.07054562f, 0.03433728f, 0.01532369f, 0.03766533f, 0.03565207f, -0.03013257f, 0.00247867f, 0.04317460f, 
    -0.01450388f, -0.04063391f, 0.04217409f, 0.01330295f, 0.03534779f, -0.06488703f, 0.03438973f, -0.06311960f, 
    -0.02677197f, 0.01499242f, 0.06474387f, -0.05267556f, 0.02348511f, -0.01332918f, -0.04983896f, 0.05277036f, 
    0.01908880f, -0.06431986f, 0.05231560f, -0.06326080f, -0.01306706f, 0.01755565f, 0.02454367f, 0.04403270f, 
    -0.01133935f, 0.05967378f, 0.05896919f, 0.01312344f, -0.05625326f, 0.05502839f, 0.02868783f, -0.01405688f, 
    0.00110061f, -0.05065376f, -0.03383094f, -0.02212335f, 0.01564331f, 0.05055562f, 0.04284141f, -0.02591174f, 
    -0.04218610f, 0.06201834f, -0.04107988f, 0.01579918f, 0.02762570f, -0.01763026f, -0.00866760f, -0.01374074f, 
    0.00297249f, -0.06793680f, -0.07646148f, -0.00578197f, 0.06706309f, 0.03800381f, -0.03470504f, -0.02520601f, 
    -0.02696103f, -0.07107634f, 0.07285725f, -0.01680232f, -0.00691794f, -0.01512106f, 0.04361491f, -0.03839601f, 
    -0.04551505f, 0.03398134f, 0.00287441f, -0.06968784f, -0.05205351f, -0.05756402f, -0.05143341f, 0.01624656f, 
    -0.07310925f, 0.00522795f, 0.01901961f, 0.04515913f, 0.05759364f, -0.06309060f, 0.05823429f, 0.03810387f, 
    -0.04627611f, 0.02610408f, -0.03823988f, -0.04616762f, -0.01090793f, -0.02656818f, -0.00508279f, -0.05865186f, 
    0.00792460f, 0.01453194f, 0.04418547f, 0.02995832f, -0.02781652f, -0.03820631f, -0.05006577f, 0.00938886f, 
    -0.06387133f, -0.01898805f, -0.02405330f, 0.05355209f, 0.04919360f, 0.02188906f, -0.04434599f, 0.02314199f, 
    0.03741550f, 0.02475777f, -0.04001097f, 0.03801147f, -0.02338221f, -0.07715084f, -0.02717565f, -0.04700672f, 
    0.04083228f, 0.02394704f, 0.00919238f, 0.01003745f, -0.00562061f, -0.01198501f, 0.01106786f, -0.01835747f, 
    0.04143008f, -0.04917879f, -0.00264448f, -0.03871711f, -0.04304290f, -0.01487415f, -0.03031102f, -0.00639522f, 
    0.01060988f, -0.05503521f, -0.04012511f, 0.01238457f, -0.02270192f, 0.02207325f, 0.01743260f, 0.02516130f, 
    0.06246650f, -0.06745473f, -0.03576345f, -0.04681085f, -0.03435937f, -0.00311999f, -0.03379474f, 0.04985632f, 
    -0.02597480f, -0.00281942f, 0.05921185f, 0.05265683f, 0.03009245f, 0.07099804f, 0.01379012f, -0.17830902f, 
    0.02242803f, 0.02863937f, 0.00815869f, 0.09338447f, -0.16108228f, -0.06357051f, 0.08728010f, -0.00733917f, 
    -0.04346551f, -0.18910323f, 0.02034775f, 0.05441555f, -0.09538443f, -0.01927774f, -0.02318014f, -0.03722338f, 
    0.46150249f, 0.27841911f, 0.06525783f, -0.04646606f, -0.14570890f, -0.09247158f, -0.07895662f, -0.04025178f, 
    -0.12321267f, 0.05605686f, -0.01938905f, -0.03699247f, -0.10336521f, -0.11306211f, -0.00525446f, -0.22766952f, 
    -0.01148654f, -0.05492838f, 0.16159385f, -0.01160690f, -0.03691934f, -0.02051182f, 0.02695438f, 0.09045120f, 
    -0.19188225f, 0.02237771f, 0.10900765f, -0.12907416f, -0.00545853f, 0.00710676f, 0.05402780f, -0.07200684f, 
    0.02683195f, 0.10629021f, -0.12030458f, 0.04890138f, 0.03148312f, -0.31997633f, 0.01319427f, 0.05461979f, 
    0.03000733f, 0.15938333f, 0.08932240f, -0.06728522f, 0.02020364f, 0.00574271f, 0.11086482f, -0.07336777f, 
    0.27765739f, 0.20814167f, 0.09551492f, -0.02599107f, 0.00717437f, 0.01877313f, -0.05294074f, 0.17814694f, 
    -0.02301265f, -0.04562190f, 0.00794058f, 0.04616493f, 0.23885003f, -0.05361445f, 0.02991218f, 0.03598433f, 
    -0.03534021f, -0.00236660f, 0.00235464f, -0.07084165f, -0.01238090f, -0.09234800f, -0.05214927f, 0.08435119f, 
    0.03586772f, 0.04229965f, -0.18870543f, -0.11152189f, 0.09305467f, 0.13654724f, 0.07756476f, 0.02301417f, 
    0.03688607f, 0.06278815f, -0.00670037f, -0.06924023f, 0.27727169f, -0.12680766f, -0.03449216f, 0.08787450f, 
    0.06006642f, -0.01961978f, 0.00370385f, 0.01478647f, 0.10342771f, -0.04704499f, 0.05620488f, 0.04594623f, 
    0.33428299f, -0.17184395f, -0.03033120f, -0.23310660f, 0.23915580f, 0.12366140f, -0.16015875f, 0.11841570f, 
    0.01473787f, -0.06113742f, -0.12983327f, 0.06669317f, 0.14426281f, 0.12166177f, 0.13873181f, -0.15533297f, 
    0.00498873f, 0.00028505f, -0.06839509f, 0.02456291f, 0.08115862f, 0.06622103f, -0.00666703f, -0.06594544f, 
    0.02129173f, 0.01389884f, 0.09793608f, 0.09561713f, -0.05884287f, -0.03189364f, 0.00465748f, -0.00679696f, 
    0.00721341f, 0.05005999f, 0.03376108f, 0.07840472f, -0.31753919f, -0.10879864f, 0.05875950f, 0.00183055f, 
    0.10321812f, 0.00395547f, -0.03072220f, 0.06611688f, -0.01072979f, -0.04117231f, -0.02131120f, 0.02912309f, 
    -0.15264855f, -0.04147378f, 0.02396096f, -0.29953390f, 0.04443118f, 0.05092695f, 0.10458833f, 0.10142043f, 
    -0.06089366f, -0.03164322f, 0.12545691f, -0.03320216f, 0.13856702f, 0.18213536f, 0.11352055f, -0.09599676f, 
    -0.09079324f, -0.05917155f, -0.03346288f, 0.04425879f, 0.07843988f, -0.08167130f, 0.05945420f, -0.11848025f, 
    -0.04618445f, -0.00050293f, -0.05536870f, -0.06815971f, 0.06295972f, 0.06284959f, -0.01614264f, -0.05851460f, 
    -0.02183236f, 0.03747328f, 0.02777471f, 0.02247197f, -0.03305559f, 0.01295477f, -0.00534296f, 0.03350806f, 
    -0.06659187f, 0.06150452f, 0.00838375f, 0.02917835f, 0.05977799f, -0.04716380f, -0.07603159f, -0.06745730f, 
    -0.03849898f, -0.03746392f, -0.07620841f, -0.01723412f, -0.00075197f, 0.04307540f, -0.04836280f, 0.02842486f, 
    -0.00572693f, -0.03497796f, -0.03464770f, -0.06785376f, -0.06526850f, -0.00880585f, -0.05154010f, -0.01069096f, 
    -0.04011217f, 0.05629564f, 0.04797945f, -0.06013129f, -0.00665573f, -0.05596017f, -0.06419178f, 0.00156668f, 
    0.00891540f, -0.06450531f, 0.00899498f, 0.02772918f, 0.00128223f, -0.04524303f, 0.04186535f, -0.04547800f, 
    -0.08033180f, 0.04421343f, -0.02086163f, 0.07001200f, 0.04776188f, -0.05692033f, -0.07043333f, 0.05268998f, 
    0.06547502f, -0.06429854f, 0.05692511f, 0.05299767f, -0.06785249f, -0.00412634f, 0.00757051f, -0.03465264f, 
    0.02272702f, 0.02290250f, -0.01198275f, 0.03133094f, 0.02129758f, -0.00106394f, -0.04541004f, -0.00695697f, 
    0.04645018f, 0.04062864f, 0.02043223f, -0.00693161f, -0.07738890f, 0.02221225f, -0.04814233f, 0.02659243f, 
    -0.02804465f, -0.00920224f, -0.04467346f, -0.03638178f, -0.01475043f, 0.05731978f, 0.01505855f, -0.07023851f, 
    -0.04068618f, 0.04492436f, 0.02645051f, -0.07387326f, 0.02023312f, -0.05203173f, 0.01021588f, -0.00893499f, 
    -0.02624613f, -0.03161073f, 0.03714944f, 0.00689323f, 0.03653068f, -0.01707194f, -0.00264701f, 0.02268630f, 
    -0.07541413f, -0.04061490f, -0.01157158f, 0.00954834f, -0.00072823f, 0.05882150f, 0.01409470f, 0.00356974f, 
    -0.06289310f, -0.01788069f, -0.07575625f, -0.04156163f, -0.05094271f, 0.05166165f, 0.02314149f, 0.05294514f, 
    -0.05076931f, -0.06445717f, -0.07638080f, 0.04410734f, 0.05405375f, -0.05277565f, 0.05260334f, -0.06511157f, 
    -0.05474206f, 0.02233117f, -0.02097905f, -0.03354853f, -0.03331316f, -0.02497043f, -0.04481494f, -0.01551127f, 
    0.04947054f, -0.01859448f, -0.02613021f, -0.07407627f, -0.07977549f, -0.06433766f, -0.05041060f, -0.01748859f, 
    0.01510267f, -0.02246170f, -0.05364430f, 0.03146287f, -0.02231979f, 0.05509645f, 0.02542370f, 0.04207083f, 
    0.01500022f, -0.00087351f, 0.04996704f, 0.00527487f, 0.05524879f, -0.05727309f, 0.05162720f, 0.00312545f, 
    -0.01031710f, 0.00653730f, 0.01210828f, -0.01733065f, -0.03155617f, 0.05442639f, -0.05954057f, -0.01011056f, 
    -0.08004513f, -0.02520030f, -0.03343380f, 0.05546902f, -0.00687116f, -0.03350200f, 0.02832398f, 0.03944020f, 
    -0.01742082f, -0.00416758f, -0.01390922f, 0.04364391f, -0.07664639f, 0.05975124f, -0.00030270f, 0.01638804f, 
    0.34835848f, -0.31009710f, 0.05026833f, 0.00981034f, -0.05806061f, 0.01902375f, 0.07571413f, -0.02292630f, 
    0.06708555f, 0.12897114f, -0.06664391f, 0.06107962f, -0.24871755f, -0.01206179f, 0.27528518f, 0.06773192f, 
    0.03542709f, -0.03325730f, 0.05081591f, 0.04801000f, 0.05168306f, 0.04099545f, 0.13282087f, 0.26043025f, 
    -0.27438635f, 0.28758210f, 0.02215966f, 0.19415464f, -0.00908848f, -0.01268513f, 0.02480449f, -0.08238116f, 
    0.07468911f, -0.00347185f, 0.06045832f, -0.01436295f, -0.19746403f, 0.03348551f, 0.05994200f, -0.16087538f, 
    0.17166996f, -0.00647612f, 0.10215566f, 0.02240447f, -0.03767757f, -0.13278340f, 0.06833077f, 0.00520316f, 
    -0.05874340f, -0.16375466f, -0.21168499f, 0.01809893f, -0.12083663f, 0.05209757f, 0.01877161f, 0.01498315f, 
    0.13111773f, -0.06157048f, -0.07452098f, 0.02594077f, 0.29951155f, -0.42248389f, 0.15362799f, 0.16861121f, 
    0.10843364f, -0.00399840f, -0.05259747f, -0.01240544f, -0.04347251f, 0.03597534f, -0.04030111f, 0.03070063f, 
    0.02502222f, 0.21983115f, -0.07301670f, 0.16987577f, 0.08559672f, 0.24319580f, -0.08857474f, -0.10069326f, 
    -0.10154881f, 0.02188058f, 0.04058870f, 0.11741948f, -0.34124672f, 0.34557796f, 0.01155027f, 0.08951592f, 
    -0.04004156f, 0.13681947f, 0.06949536f, -0.05964094f, 0.00141407f, -0.08568031f, 0.10733098f, 0.05188400f, 
    0.04530369f, -0.00572949f, 0.08039691f, -0.10280308f, 0.04917325f, 0.15351795f, -0.01570641f, -0.05684647f, 
    0.15503418f, 0.06222199f, 0.06620232f, 0.04096868f, 0.15090173f, -0.01817636f, 0.09009062f, -0.19993351f, 
    -0.04418755f, 0.01885139f, 0.02194740f, 0.02755252f, 0.06461889f, -0.02683454f, -0.05672939f, -0.02420026f, 
    -0.37049672f, -0.29463032f, -0.13900217f, -0.31003407f, 0.09945770f, 0.08009631f, -0.02448132f, 0.13005191f, 
    -0.02041098f, -0.02162581f, 0.02322993f, 0.10468304f, 0.16315369f, 0.10325351f, -0.24309193f, 0.01446814f, 
    -0.02172454f, 0.16011980f, -0.10502781f, 0.13157244f, 0.06148352f, 0.03493102f, -0.00034856f, -0.02737731f, 
    -0.01941038f, 0.42936400f, 0.14062934f, -0.29502228f, -0.11139676f, 0.10436571f, -0.15589617f, 0.00460877f, 
    -0.00388138f, -0.01205370f, -0.02646809f, -0.04137731f, -0.04289821f, -0.14396109f, 0.02877097f, -0.01120794f, 
    -0.03756296f, -0.02065009f, -0.07827725f, 0.02463927f, -0.14137827f, -0.00385453f, -0.02447176f, -0.03780922f, 
    -0.12169702f, 0.03694812f, -0.04115055f, -0.15284729f, -0.10483773f, 0.04394629f, -0.01478276f, 0.00242392f, 
    0.07612015f, -0.11696681f, -0.14504890f, 0.09148721f, -0.36314419f, 0.28662589f, 0.16461310f, -0.17456909f, 
    0.09204903f, -0.03650264f, -0.13343550f, 0.05559330f, -0.12339172f, 0.10010540f, -0.01576731f, 0.14485633f, 
    -0.24499474f, 0.09012801f, -0.08943047f, 0.01489712f, 0.02850389f, 0.01179120f, -0.07546587f, -0.10197273f, 
    0.04323322f, -0.12912434f, 0.19994639f, 0.06739414f, 0.06323595f, -0.15134306f, 0.13970298f, -0.08446014f, 
    -0.11671494f, -0.20033158f, -0.10486794f, 0.06361594f, -0.14468205f, -0.09751486f, -0.08681132f, -0.00699291f, 
    0.19337487f, 0.07830660f, -0.10195152f, -0.10684925f, -0.01309973f, -0.04859580f, -0.18280773f, -0.08579861f, 
    -0.09192528f, 0.16449304f, -0.13522498f, 0.17313476f, 0.13332161f, 0.02094398f, 0.18927348f, 0.14434397f, 
    0.06598921f, 0.10647620f, 0.15570229f, 0.12630971f, -0.07901784f, 0.03994136f, -0.04933815f, 0.11705960f, 
    -0.09179377f, 0.00628603f, 0.23056100f, -0.14924374f, -0.00015013f, 0.08428242f, 0.11288560f, -0.01121092f, 
    0.04801310f, 0.08076110f, -0.15486175f, 0.14486124f, -0.39084592f, 0.18056364f, -0.05944173f, -0.01576302f, 
    0.01989705f, -0.07072876f, -0.01458989f, -0.12049051f, 0.05554361f, -0.01873072f, -0.00037429f, -0.07027972f, 
    0.01135673f, 0.02557933f, 0.03405816f, 0.04178727f, 0.08588196f, -0.02882305f, 0.08010139f, 0.13394585f, 
    0.13986309f, 0.05049798f, 0.02458948f, -0.02042370f, 0.11598735f, -0.32706955f, 0.04861348f, -0.09017388f, 
    -0.03008907f, 0.12877615f, 0.01930128f, -0.03211197f, -0.08040032f, -0.04855927f, -0.17622112f, -0.08476564f, 
    0.04855533f, 0.01929321f, -0.30801454f, -0.11987788f, -0.02064120f, 0.03777229f, 0.09616715f, 0.06955430f, 
    0.04339980f, -0.00839032f, -0.06173470f, 0.00344079f, -0.13125639f, -0.02655967f, -0.06305838f, 0.10727744f, 
    -0.01110657f, 0.05240325f, -0.03692480f, 0.18012670f, 0.10191190f, -0.01386920f, 0.09341604f, 0.07239717f, 
    0.10784628f, 0.09770852f, 0.03123907f, -0.33246332f, 0.14092392f, 0.02845606f, -0.04880957f, 0.01973383f, 
    0.05046654f, -0.02693513f, -0.08530320f, 0.08408698f, 0.19788855f, -0.17952080f, 0.12880358f, -0.10880468f, 
    -0.07265297f, 0.05814225f, -0.03248665f, 0.10974585f, 0.16461608f, -0.01218464f, 0.07931318f, -0.01087893f, 
    0.20756383f, -0.27063084f, 0.22604658f, 0.21125834f, -0.11430024f, -0.02463533f, -0.08446874f, -0.04791017f, 
    0.00120921f, 0.02784796f, 0.00723944f, -0.01039906f, -0.09731667f, -0.02835620f, 0.09549548f, -0.16739680f, 
    0.04589223f, 0.13263118f, 0.03625626f, 0.10253177f, 0.00248782f, 0.02778267f, 0.05478213f, 0.04974013f, 
    0.08465677f, 0.07154977f, 0.17769289f, -0.10997289f, 0.04991064f, 0.01027886f, 0.10462299f, 0.07054082f, 
    -0.09702595f, 0.01290613f, 0.12604581f, -0.13850310f, 0.11843424f, -0.02209482f, 0.13383718f, 0.02941397f, 
    -0.00509750f, 0.09413425f, 0.01003739f, 0.09924506f, 0.06731031f, -0.06920185f, 0.00404588f, 0.01562436f, 
    0.22060147f, 0.24355257f, 0.05374371f, -0.13839461f, 0.01661626f, 0.00335063f, -0.00165554f, 0.25227678f, 
    -0.09641398f, -0.02162771f, -0.06938902f, -0.10246987f, -0.15679923f, 0.09890445f, -0.10497115f, -0.13430744f, 
    -0.09041139f, 0.12962198f, 0.19085111f, 0.05117860f, 0.17273167f, 0.06042426f, -0.00491067f, 0.08761051f, 
    -0.12345645f, -0.08143184f, -0.08264119f, -0.35530099f, -0.01125685f, -0.07083286f, 0.16390258f, 0.09222280f, 
    -0.05073202f, -0.05266136f, 0.07807442f, -0.03943665f, 0.40581989f, 0.01828582f, -0.14175446f, -0.08375012f, 
    0.08083715f, 0.08540213f, -0.03603936f, 0.00534153f, -0.03447367f, -0.04314368f, 0.04721448f, -0.13598083f, 
    0.18101181f, 0.02247154f, -0.03322502f, -0.05793549f, 0.11150546f, 0.00353814f, 0.12523420f, 0.08773026f, 
    0.07142351f, 0.03444087f, -0.14499356f, 0.01122185f, -0.00584316f, 0.12381765f, -0.24438119f, -0.15619089f, 
    -0.00766236f, 0.15374491f, -0.11843301f, 0.04922956f, -0.01670706f, 0.05804510f, 0.15024269f, 0.04475392f, 
    0.10797916f, 0.16546823f, -0.09343829f, 0.05335449f, 0.14477025f, 0.02765020f, 0.04327708f, -0.10969768f, 
    0.03762094f, 0.14563249f, -0.06396972f, 0.08081572f, 0.14424272f, -0.19643873f, 0.12538159f, -0.04125188f, 
    -0.04929549f, -0.12095748f, 0.04286857f, 0.02700322f, 0.01093449f, 0.07690084f, -0.06420856f, -0.04126030f, 
    0.51563793f, -0.13519081f, 0.02517930f, 0.08380505f, -0.03922753f, -0.01814394f, 0.01425117f, 0.17387380f, 
    -0.02040467f, -0.07992733f, -0.02527866f, 0.01062040f, 0.49644354f, 0.03196117f, 0.13388203f, 0.27498153f, 
    0.00471511f, -0.02333402f, 0.10361466f, -0.05261160f, -0.06379256f, -0.00333843f, -0.04495167f, -0.03961312f, 
    0.18356337f, 0.18507172f, -0.14749743f, 0.03183922f, -0.11071076f, -0.18607332f, 0.07248970f, 0.06959502f, 
    -0.10333700f, 0.01816530f, -0.00458243f, 0.01791455f, -0.14585648f, -0.18169242f, -0.01792639f, 0.00997299f, 
    0.17804009f, -0.13322797f, 0.14807956f, 0.03468001f, -0.07898464f, 0.00325280f, -0.06908853f, -0.05199309f, 
    -0.16336973f, -0.21239316f, -0.18205161f, 0.01302759f, 0.28410926f, 0.06041925f, -0.04954931f, 0.01174800f, 
    -0.01873221f, 0.02074333f, 0.10515259f, -0.05999863f, 0.15704425f, 0.11974475f, -0.06357295f, 0.07047798f, 
    -0.14450635f, -0.20667647f, -0.04105913f, 0.02277532f, -0.00824734f, 0.01034512f, 0.04044620f, -0.02725765f, 
    0.03883104f, 0.17110792f, 0.04815841f, 0.00479295f, 0.00283702f, 0.09954283f, -0.06249573f, 0.02207640f, 
    0.22203991f, 0.00722625f, -0.05865454f, 0.09682415f, -0.21642646f, 0.15833119f, -0.29415929f, 0.03986054f, 
    0.18054858f, -0.02125158f, 0.15079448f, 0.01953868f, 0.14823094f, 0.08466166f, 0.15312514f, 0.24532761f, 
    0.04053542f, -0.17154244f, 0.03131315f, 0.08109684f, -0.05057023f, -0.05228809f, 0.07281639f, 0.04371073f, 
    -0.01590214f, 0.07773820f, -0.00897659f, 0.07967748f, -0.40753433f, 0.06173292f, 0.08444190f, 0.03945912f, 
    -0.05225891f, -0.06782584f, -0.02429462f, 0.10036305f, 0.05331089f, 0.03688877f, 0.02311899f, 0.07806225f, 
    0.23646826f, 0.30853164f, 0.10618374f, 0.20502068f, -0.05904205f, -0.01063215f, 0.01136328f, 0.06936643f, 
    0.01656444f, 0.03989029f, -0.01175992f, -0.08057602f, 0.04680677f, -0.05292308f, -0.11700522f, -0.12246419f, 
    0.02578310f, -0.00799608f, 0.08591019f, 0.08815707f, -0.05883237f, -0.00856065f, -0.08128659f, 0.12560272f, 
    -0.18057489f, 0.07608073f, -0.05217062f, 0.10876313f, -0.00186531f, 0.03084537f, -0.03643885f, 0.01907929f, 
    0.02077648f, -0.04603147f, -0.12860149f, 0.11810322f, -0.31684443f, 0.07674199f, -0.11998160f, 0.03345313f, 
    0.05091741f, 0.14782973f, 0.06465529f, -0.03607600f, -0.03966077f, 0.01176992f, 0.15743710f, -0.00922650f, 
    0.26514700f, 0.23438844f, 0.05710936f, -0.09169295f, -0.03963397f, -0.01083894f, -0.04173329f, 0.11896469f, 
    0.08283889f, 0.01034123f, 0.04359127f, -0.01086278f, -0.04651675f, -0.01502076f, -0.02400075f, -0.15599889f, 
    0.07316991f, -0.01839439f, -0.11495536f, -0.06583944f, 0.03442289f, 0.02510578f, 0.04255131f, 0.01003927f, 
    0.07733773f, -0.21861258f, -0.09923322f, 0.00799455f, -0.12220664f, -0.04677800f, 0.03854018f, -0.03669792f, 
    -0.09857962f, 0.06992055f, -0.15409443f, -0.05764989f, -0.09573859f, 0.08904716f, 0.03836679f, 0.05240902f, 
    0.12276770f, 0.11960626f, 0.07354599f, 0.07102858f, 0.03312340f, -0.03549412f, 0.05941720f, -0.05522090f, 
    -0.12588651f, -0.05875329f, -0.01721747f, -0.01914068f, 0.01710912f, -0.04102110f, -0.11547802f, 0.01857835f, 
    0.16575293f, -0.08121209f, 0.00372767f, -0.00767897f, 0.14799364f, 0.05677885f, -0.11928888f, 0.02893869f, 
    -0.01631058f, -0.07173801f, -0.00239620f, -0.06270719f, 0.19958730f, 0.02175955f, -0.03419287f, 0.02484211f, 
    0.34599215f, 0.09826090f, 0.09660882f, 0.00287924f, 0.00452581f, -0.04802925f, -0.04963565f, 0.03981124f, 
    0.04598531f, 0.06918871f, -0.05387921f, 0.05400969f, -0.09484051f, -0.00363742f, -0.05115169f, -0.15028834f, 
    0.08705761f, -0.01399087f, 0.01761486f, -0.10205931f, -0.02401257f, 0.04973586f, 0.09505203f, -0.08761589f, 
    0.01309888f, -0.07839980f, -0.24519137f, 0.02041078f, 0.03772181f, 0.01114706f, -0.02604674f, -0.02822098f, 
    0.06187907f, -0.04132415f, 0.00244168f, 0.10445511f, -0.13022588f, 0.18896087f, 0.12811442f, 0.10739251f, 
    0.09763582f, -0.04807675f, 0.02123932f, 0.11034522f, 0.02114150f, -0.00333720f, -0.05097468f, 0.02782386f, 
    0.05481494f, 0.08305487f, -0.00310469f, 0.07256456f, 0.02469087f, 0.06741968f, -0.15212546f, 0.08554082f, 
    -0.00746283f, -0.02272003f, 0.20440072f, 0.02878066f, -0.23500608f, -0.41135564f, -0.12344538f, -0.21030292f, 
    0.08799046f, -0.19911845f, -0.11837164f, 0.04235007f, -0.04371619f, -0.01899908f, -0.04240254f, -0.11101156f, 
    0.11438950f, 0.16260923f, -0.25335470f, 0.17955258f, 0.18782184f, 0.12039341f, -0.13878137f, -0.12738873f, 
    0.02981175f, 0.07134428f, -0.23647827f, 0.19354020f, -0.26921415f, -0.08055636f, -0.06993399f, -0.11724525f, 
    0.04524111f, 0.05890700f, 0.12725562f, 0.16411254f, 0.00080668f, -0.05581230f, -0.03029561f, 0.23803380f, 
    0.17123854f, 0.00365141f, -0.28308848f, -0.03944651f, -0.12461419f, -0.00793481f, -0.06733330f, 0.01020093f, 
    0.07104742f, 0.01121207f, -0.02665885f, 0.17019323f, -0.05398715f, 0.20911074f, -0.17671786f, 0.13456725f, 
    0.00210522f, 0.01532148f, -0.02196749f, 0.06021591f, 0.12303455f, 0.08027164f, 0.00029396f, 0.05462950f, 
    -0.02393379f, -0.11000902f, -0.04680427f, -0.12095424f, 0.16994283f, 0.16621812f, -0.05375769f, 0.07304192f, 
    0.10536794f, 0.04665468f, -0.01798765f, 0.08025782f, -0.10689317f, 0.21296656f, -0.01258160f, -0.30243304f, 
    -0.03979355f, 0.07000873f, -0.07130028f, 0.16851957f, 0.14391609f, 0.04384090f, -0.24251907f, 0.05461558f, 
    0.24635050f, 0.16086768f, -0.04623141f, -0.08964591f, -0.23708628f, -0.08724061f, -0.01770442f, 0.10202592f, 
    0.01901074f, -0.11779274f, 0.05386568f, -0.00983378f, 0.04112041f, 0.00223637f, -0.02907645f, -0.00180915f, 
    0.03526293f, 0.14882854f, 0.05732790f, 0.15463580f, -0.00601858f, 0.18334036f, 0.11846046f, 0.05893544f, 
    -0.04268604f, -0.01074244f, 0.24579448f, 0.22941825f, -0.35845760f, -0.23208936f, -0.07655793f, -0.19068179f, 
    -0.04436554f, -0.10898859f, 0.01797258f, -0.14485547f, -0.24468264f, 0.15947022f, -0.10079803f, -0.06342261f, 
    -0.08650831f, 0.18528120f, -0.06398511f, -0.01022258f, 0.09893803f, -0.07068470f, 0.07654570f, 0.05519652f, 
    -0.09054448f, -0.10667337f, 0.17243558f, 0.26260763f, 0.12345676f, 0.01637061f, -0.08331569f, -0.06172109f, 
    -0.01859129f, 0.06468258f, 0.06558748f, -0.01433613f, -0.10514173f, -0.00541256f, 0.12422213f, -0.35532135f, 
    0.01880713f, 0.13296391f, -0.01613447f, -0.05670055f, 0.04432598f, -0.06530352f, 0.02357271f, -0.07975239f, 
    -0.06651635f, 0.11247142f, -0.12080850f, -0.22062393f, -0.00310858f, 0.08079030f, -0.04195609f, 0.10916010f, 
    -0.02299482f, 0.09948152f, -0.02309837f, -0.26270947f, 0.12938386f, -0.19827855f, 0.02146662f, 0.15390112f, 
    -0.00743504f, 0.09625401f, 0.12110023f, 0.01347179f, 0.04520642f, -0.02829471f, -0.02736703f, -0.03703428f, 
    0.02623549f, 0.04824591f, -0.04075975f, -0.10061598f, 0.09064856f, 0.10440932f, -0.02617118f, 0.02031328f, 
    0.08083934f, -0.02271272f, -0.05024403f, 0.00020738f, 0.41688827f, 0.19286993f, 0.05090338f, 0.05248005f, 
    -0.04944946f, 0.06328274f, 0.19117945f, -0.08435575f, 0.09433937f, -0.00979649f, 0.10807645f, 0.18514130f, 
    -0.40483153f, -0.05949141f, 0.04423163f, -0.08069655f, -0.10750815f, 0.06047200f, 0.11726253f, 0.08329722f, 
    0.10418350f, 0.05225713f, 0.19334476f, -0.02011523f, 0.12744063f, 0.15493454f, 0.09162965f, 0.16911639f, 
    0.04328359f, 0.04456404f, -0.16652489f, -0.16240752f, -0.00389328f, -0.05124520f, 0.10589788f, -0.15142390f, 
    0.08521347f, 0.01313582f, 0.14920330f, -0.11063129f, -0.04638877f, 0.00474337f, 0.05534368f, -0.00764016f, 
    -0.03722586f, -0.03901243f, 0.02513159f, -0.12737130f, 0.28284800f, 0.04659022f, 0.19971700f, -0.08148562f, 
    0.04625925f, 0.01070234f, -0.03170817f, -0.03268608f, -0.09832796f, 0.07863860f, -0.06128662f, 0.12624988f, 
    -0.36585322f, -0.00439375f, -0.04861470f, 0.25608292f, -0.00952707f, 0.02686745f, 0.00011494f, -0.00191970f, 
    0.01013050f, 0.06875054f, -0.06758094f, -0.02074104f, 0.14606921f, -0.26796860f, 0.08687022f, 0.21297397f, 
    -0.03467506f, -0.01028833f, 0.03350781f, 0.00441252f, -0.10761046f, 0.09624778f, 0.19485928f, -0.03182501f, 
    0.03566910f, 0.04777571f, 0.06066815f, -0.05974478f, 0.14811802f, 0.14593732f, 0.00277891f, -0.03460709f, 
    0.06958090f, 0.11326447f, 0.02738797f, 0.02970945f, 0.20434408f, -0.13721623f, 0.06392831f, -0.02979982f, 
    0.04097536f, 0.00831235f, 0.03357281f, -0.02418284f, -0.04079858f, -0.05645655f, -0.10959875f, -0.07891838f, 
    -0.02528688f, 0.11611166f, -0.19219296f, -0.22533673f, 0.20458856f, 0.09824377f, 0.14094232f, 0.17148089f, 
    -0.12691845f, 0.07813017f, -0.08979040f, 0.15056346f, 0.12144472f, -0.00851448f, 0.18409359f, 0.07921433f, 
    -0.02733412f, 0.00820230f, 0.07023991f, 0.13224614f, -0.08167880f, 0.06360791f, -0.01240036f, -0.05425625f, 
    0.03736478f, 0.02605166f, 0.08019943f, -0.12262347f, -0.14000423f, 0.08571102f, 0.03132173f, 0.00827969f, 
    0.01411409f, -0.04382377f, 0.02739460f, -0.07636131f, 0.16927876f, 0.11625477f, 0.01948750f, 0.20293449f, 
    -0.03216856f, -0.09210496f, -0.06107851f, 0.02725394f, -0.06928881f, 0.03554115f, 0.06026365f, 0.03816303f, 
    0.08536865f, 0.07213441f, 0.18836407f, 0.06267332f, -0.17752783f, 0.04043189f, 0.09129275f, 0.01140182f, 
    0.11813670f, -0.09822517f, -0.04182943f, 0.20986083f, -0.13666524f, 0.05845363f, 0.07978998f, -0.11132469f, 
    -0.02865537f, -0.01272164f, -0.04168010f, -0.03069613f, -0.16175830f, 0.15241070f, 0.06086296f, 0.06651806f, 
    0.36692974f, 0.11853841f, 0.03218295f, -0.03177459f, -0.03079035f, -0.03939510f, 0.05610450f, -0.10015915f, 
    -0.02306685f, -0.06738846f, -0.02504019f, -0.19837028f, 0.00039830f, 0.25963351f, -0.21219690f, 0.02086244f, 
    -0.07590798f, 0.05210900f, -0.12830661f, 0.11430038f, 0.01809814f, -0.11459947f, 0.06363875f, -0.11508848f, 
    0.24059139f, -0.18823047f, -0.25605798f, -0.20566225f, -0.05982630f, -0.03353744f, -0.02508676f, -0.16272984f, 
    -0.03416987f, 0.03014380f, -0.03641289f, -0.00205802f, 0.25979468f, 0.03690674f, 0.14825642f, 0.18952002f, 
    0.07174630f, -0.03785896f, 0.09202127f, 0.14723112f, 0.14239503f, -0.00875129f, -0.06406385f, 0.07538539f, 
    -0.02562973f, -0.09091137f, 0.10822535f, 0.13401546f, 0.02755645f, -0.00657167f, -0.03381993f, 0.07164978f, 
    -0.12081318f, 0.04820747f, -0.10020039f, -0.07023882f, -0.09373529f, -0.10080735f, 0.12640397f, 0.19531764f, 
    -0.06692436f, 0.01962346f, -0.13098019f, -0.01802230f, 0.00988025f, -0.00360980f, 0.01592896f, 0.07921680f, 
    0.57490343f, 0.23134613f, -0.17836127f, -0.35365260f, 0.11075602f, -0.14129139f, -0.05966722f, -0.01869558f, 
    0.12653719f, 0.03803356f, -0.00509059f, 0.03978162f, -0.25534716f, 0.13005944f, 0.01683751f, -0.19826037f, 
    0.03794329f, -0.15967777f, -0.08578737f, -0.11608981f, -0.01431761f, 0.08216072f, 0.05472684f, 0.03254284f, 
    0.17339386f, 0.03211888f, 0.19845806f, -0.03964855f, -0.00769318f, 0.06959893f, 0.02681687f, 0.07559756f, 
    0.03214569f, -0.07100405f, 0.10698278f, -0.08025000f, -0.58718050f, 0.43132579f, -0.11637194f, 0.05777776f, 
    0.14011605f, -0.09501354f, -0.12600619f, -0.04946550f, 0.04776106f, -0.08693140f, -0.04514474f, 0.14565669f, 
    -0.03793088f, 0.60318238f, 0.00304477f, -0.09320851f, 0.02258961f, 0.07914884f, 0.05945300f, -0.04023984f, 
    -0.16017264f, -0.01532436f, 0.00439387f, -0.10966244f, 0.08104447f, 0.21884374f, 0.05622105f, 0.09934808f, 
    -0.07016279f, -0.05695157f, 0.08684665f, -0.11859031f, -0.04716930f, 0.02984982f, -0.11179592f, 0.01676395f, 
    0.12600771f, -0.29304540f, -0.13531590f, 0.32668462f, 0.05832770f, -0.06135978f, -0.08542714f, -0.00922786f, 
    0.10140846f, -0.00577632f, -0.08258513f, 0.03793493f, 0.21143369f, 0.06786769f, -0.00577178f, -0.12636475f, 
    0.20766503f, 0.11049356f, 0.13928123f, -0.04003150f, 0.02534332f, 0.09416594f, 0.05653286f, 0.04125633f, 
    0.09495797f, 0.10436267f, 0.07638290f, 0.45818314f, 0.07478435f, -0.14990330f, 0.04599996f, -0.04959556f, 
    0.01923737f, -0.08232810f, 0.06152139f, -0.08124872f, 0.04245372f, 0.04159652f, -0.23493934f, -0.00355182f, 
    0.10126130f, 0.01322932f, -0.01023438f, 0.02012457f, 0.00665008f, -0.02515252f, 0.02004353f, -0.08632749f, 
    -0.15445559f, -0.03834775f, -0.06065770f, -0.05704993f, 0.06132160f, 0.01248195f, 0.14661689f, -0.05141634f, 
    -0.02932269f, -0.14825118f, 0.13132313f, 0.05325150f, -0.22763270f, 0.18214232f, 0.02440017f, 0.02113096f, 
    0.00909306f, -0.06198144f, -0.03272950f, -0.00752336f, -0.19183764f, 0.03874421f, 0.02924568f, -0.05521843f, 
    0.21628526f, 0.13911444f, -0.05076330f, -0.06056712f, 0.09758255f, 0.00984595f, -0.00510341f, -0.03142718f, 
    -0.10493141f, 0.06398544f, -0.06254152f, -0.01829718f, 0.22574520f, 0.09235182f, 0.07575911f, 0.22433591f, 
    0.04315966f, 0.02521954f, 0.06021984f, 0.07742215f, 0.01117248f, 0.09568193f, -0.08388431f, 0.15788895f, 
    -0.07380799f, -0.02867227f, 0.23789690f, 0.06742109f, 0.01335940f, 0.04394260f, -0.00016512f, -0.09653167f, 
    -0.07205944f, -0.03046962f, -0.03024559f, 0.25997123f, -0.60039270f, 0.11694019f, -0.14673433f, 0.13267030f, 
    -0.03619825f, 0.09526640f, 0.01864455f, 0.04225045f, 0.07890998f, 0.09096021f, 0.04680603f, -0.10097029f, 
    -0.02144024f, 0.36210802f, 0.18457450f, 0.25290301f, 0.01285634f, -0.14518213f, -0.03637719f, 0.22735797f, 
    0.11694269f, -0.01580290f, 0.18244518f, -0.04855573f, 0.01298184f, -0.23883855f, -0.07128272f, -0.18807273f, 
    0.08142166f, 0.03286280f, 0.02642369f, -0.02845705f, 0.06409386f, -0.13998289f, -0.16008712f, -0.16508722f, 
    0.13784057f, -0.13631918f, -0.34049046f, 0.03403834f, -0.08052879f, 0.01159167f, 0.09313877f, 0.03569859f, 
    -0.04081589f, 0.01187159f, 0.05252954f, -0.08384817f, -0.08903912f, 0.07645267f, -0.01531852f, -0.03903268f, 
    0.07764132f, 0.04810268f, 0.03830763f, 0.16525996f, 0.04550486f, 0.02524232f, 0.08413667f, 0.11181846f, 
    0.02416487f, 0.06395312f, -0.13463120f, -0.26435170f, 0.07779682f, 0.00741085f, -0.04865349f, -0.18409330f, 
    0.05750510f, -0.11347203f, -0.08008678f, 0.01656587f, 0.10908172f, -0.18318653f, 0.04142350f, 0.01180420f, 
    -0.04555355f, -0.07994168f, -0.03598775f, 0.01829747f, 0.20066372f, -0.04992428f, 0.07082342f, 0.03767287f, 
    0.17000178f, -0.03655806f, 0.26023281f, 0.04206823f, -0.10836755f, 0.02648432f, -0.09137525f, -0.03763674f, 
    0.06286692f, 0.02725158f, 0.04012680f, 0.22225544f, -0.04316858f, -0.01949107f, -0.04804904f, -0.17823543f, 
    0.10303162f, 0.20558377f, -0.00045835f, -0.06640060f, -0.02845105f, -0.02031915f, 0.04331223f, -0.01594717f, 
    0.18461242f, 0.10899018f, -0.08468170f, 0.17622656f, 0.08471181f, -0.09450510f, -0.02970241f, -0.12306562f, 
    -0.14942336f, -0.03687470f, 0.01026871f, -0.09867672f, -0.09558327f, 0.07496384f, 0.06051760f, -0.21667077f, 
    0.04143202f, -0.01505068f, 0.04422501f, 0.02965076f, 0.05784547f, -0.05814080f, -0.00233037f, -0.09698650f, 
    0.09517702f, -0.08214417f, 0.11255220f, 0.15971956f, 0.03941647f, 0.10388277f, 0.09047519f, 0.17800070f, 
    0.04604639f, -0.05767923f, 0.17252360f, 0.13849230f, 0.22551276f, -0.04273735f, 0.04640453f, 0.06786289f, 
    0.09695798f, -0.02342769f, 0.12874353f, 0.14503980f, -0.02383115f, 0.07258438f, -0.12453839f, 0.17434357f, 
    -0.28787982f, -0.14094304f, 0.02003973f, -0.08181307f, -0.14654370f, -0.28944212f, -0.07879867f, 0.17799944f, 
    0.05419710f, 0.07164887f, 0.09537943f, -0.11449403f, -0.04729453f, 0.08319245f, 0.06634545f, 0.09291021f, 
    0.03742966f, 0.01628404f, -0.00181948f, 0.09126654f, -0.00406159f, -0.18385851f, -0.06939092f, 0.09696895f, 
    -0.07389486f, 0.04862086f, 0.01167699f, -0.18643746f, 0.03445769f, 0.00115933f, -0.08987278f, -0.00898964f, 
    -0.27370116f, -0.06725050f, 0.15238614f, -0.03268597f, 0.14328432f, 0.11511294f, -0.00982046f, -0.01562021f, 
    -0.06439459f, -0.23995589f, 0.06188826f, 0.15241851f, 0.04852725f, -0.08257504f, -0.19141294f, -0.07199915f, 
    -0.28490904f, 0.10612553f, -0.08640176f, -0.25383684f, 0.11487928f, -0.03284329f, 0.01945532f, 0.12007438f, 
    0.14464204f, 0.05785500f, -0.05263137f, -0.09807967f, -0.18023185f, -0.04893610f, 0.08315771f, -0.19162108f, 
    0.08308719f, 0.07388453f, -0.10516044f, 0.09146625f, 0.02464646f, 0.02756434f, -0.03094244f, 0.09311078f, 
    -0.02211224f, 0.01182882f, -0.00010099f, -0.02210886f, 0.11003567f, 0.14443064f, -0.04901658f, -0.05992306f, 
    0.10501760f, -0.00309579f, 0.21048445f, 0.01848506f, -0.12097850f, -0.22855829f, 0.01348557f, 0.07571780f, 
    0.03333456f, -0.00280866f, 0.13875301f, 0.05137655f, 0.17041202f, 0.01104407f, -0.04671121f, 0.17560035f, 
    -0.48292759f, -0.19350836f, 0.05947639f, -0.04428410f, 0.13462922f, 0.14082044f, 0.00918519f, 0.05641394f, 
    -0.08287905f, -0.09427334f, -0.15822724f, 0.13277072f, -0.14989491f, 0.08239932f, -0.01327180f, -0.21876347f, 
    -0.01586392f, -0.00256815f, -0.08896840f, 0.20255592f, -0.04500062f, -0.15546733f, 0.02557540f, 0.02401664f, 
    0.08633717f, -0.24989115f, -0.18634757f, -0.07431358f, -0.15378305f, -0.03461389f, 0.00872246f, 0.16385448f, 
    0.00634249f, 0.05606717f, -0.04874348f, -0.06108687f, -0.10666852f, -0.17458425f, -0.06360873f, -0.12230331f, 
    -0.00780733f, 0.06619977f, 0.08499074f, -0.16370323f, -0.14014402f, -0.07713258f, -0.10662856f, 0.00293259f, 
    -0.07368517f, 0.18799065f, 0.27290571f, 0.08172981f, 0.07000480f, 0.13124053f, -0.06235927f, 0.04374111f, 
    0.03873082f, -0.25296453f, 0.09576146f, -0.00533358f, 0.01364096f, -0.02939297f, 0.05827507f, 0.18169069f, 
    -0.18123937f, -0.00202655f, 0.06826464f, 0.13318641f, 0.03789314f, 0.05805300f, -0.28607067f, 0.01049625f, 
    0.01075302f, 0.04738188f, -0.19675662f, 0.03553615f, 0.04936682f, 0.07427232f, 0.02696599f, 0.10688473f, 
    -0.00550278f, 0.00410080f, 0.02342633f, 0.10944558f, 0.26891208f, -0.21755290f, -0.01092502f, -0.00351338f, 
    0.09392347f, -0.07614338f, 0.02615000f, -0.07442548f, -0.05321750f, 0.03609975f, -0.06215325f, 0.15219691f, 
    0.00126087f, -0.03162325f, -0.01733090f, -0.07292745f, -0.16457692f, -0.11667281f, -0.01252019f, 0.05005637f, 
    -0.06570650f, 0.00326082f, 0.06697397f, 0.04890320f, 0.07364727f, -0.07824002f, 0.17735913f, 0.18612181f, 
    -0.02600544f, 0.13083576f, 0.05640281f, 0.01226326f, -0.02282781f, 0.18312235f, 0.08314895f, -0.01195428f, 
    -0.14026009f, 0.19095169f, 0.10334125f, -0.33335856f, -0.07522968f, 0.03585924f, 0.02373423f, -0.02388432f, 
    0.04157933f, 0.01464361f, -0.01297774f, -0.07145081f, 0.15538004f, 0.42950544f, -0.02978428f, -0.31759107f, 
    0.02225691f, 0.08426221f, 0.05211731f, -0.07520136f, -0.09839312f, 0.08111002f, -0.05361176f, -0.13282745f, 
    -0.35215917f, -0.04265545f, -0.10124300f, 0.20342746f, -0.03122637f, -0.04714851f, 0.00211027f, -0.03344328f, 
    -0.00041847f, 0.00687981f, 0.00760731f, -0.10537765f, 0.17751107f, -0.28387719f, 0.05021659f, -0.01820305f, 
    0.14965436f, 0.07067937f, 0.13139388f, 0.05444758f, -0.17535032f, 0.05315587f, 0.11700781f, 0.05654476f, 
    0.00055940f, -0.17800260f, -0.00470104f, -0.19003764f, -0.02033219f, -0.11334786f, -0.08841146f, -0.04248353f, 
    -0.04216655f, 0.07759569f, 0.00849723f, 0.17706956f, -0.02375324f, -0.23241255f, -0.15131576f, 0.17924154f, 
    -0.01735984f, -0.02259528f, -0.01367049f, 0.10777837f, 0.02255237f, -0.05161773f, 0.04107745f, -0.05252614f, 
    -0.11975792f, 0.06172144f, -0.11530296f, -0.13374035f, 0.09193400f, -0.03175314f, 0.07781435f, 0.11269545f, 
    0.07601894f, 0.01761329f, -0.07454868f, 0.15403296f, 0.15702802f, -0.12385042f, 0.26327330f, -0.22330377f, 
    0.00231630f, -0.03116240f, 0.01299572f, 0.09858506f, 0.03572106f, -0.09735332f, -0.06073597f, 0.01872720f, 
    0.49630553f, 0.03539477f, 0.22855434f, 0.26502162f, -0.20364705f, 0.03476160f, -0.02156959f, 0.13921644f, 
    0.07666451f, 0.07958996f, 0.05656369f, -0.13375856f, -0.04435942f, -0.11975272f, -0.04918337f, -0.12309486f, 
    -0.09761556f, -0.15429564f, -0.03134059f, 0.14421594f, 0.08134935f, 0.06194852f, 0.03532871f, -0.14860599f, 
    -0.12361516f, 0.01176182f, 0.14236479f, -0.19069521f, -0.03555748f, -0.04212346f, 0.09147449f, 0.04367445f, 
    0.14926131f, -0.08732684f, 0.09235130f, 0.08568735f, 0.10148701f, -0.13527207f, 0.20314048f, 0.32658330f, 
    0.06481051f, -0.05539332f, -0.03412544f, 0.01854080f, -0.05887390f, 0.13903254f, -0.10604285f, 0.02970522f, 
    0.30082864f, 0.03015491f, 0.11175068f, 0.15739016f, 0.02673844f, -0.05584987f, -0.03355043f, 0.17379083f, 
    -0.09758138f, 0.08400720f, -0.05961362f, -0.05056681f, -0.30569300f, -0.05284344f, 0.04100486f, -0.01054106f, 
    -0.11242459f, 0.18272741f, -0.00921408f, -0.09538092f, -0.02095446f, -0.15677086f, -0.13588607f, -0.06715741f, 
    -0.24063657f, -0.13414115f, -0.10752034f, -0.11530330f, 0.13473561f, 0.04708530f, 0.10960627f, -0.18126656f, 
    -0.00816263f, -0.04342578f, 0.05235656f, 0.08649841f, -0.00778170f, 0.13983783f, 0.34947619f, -0.03426613f, 
    0.11484489f, -0.01842321f, -0.07974321f, 0.05740625f, 0.10521654f, -0.01008450f, 0.01338004f, 0.14587694f, 
    0.28159621f, -0.25459668f, -0.08954269f, -0.02537564f, -0.03812036f, -0.12696972f, -0.01709968f, 0.00879480f, 
    0.07946237f, 0.01389045f, 0.01962460f, -0.02438189f, 0.11811817f, -0.34224480f, -0.10706218f, -0.03261086f, 
    0.14245754f, -0.04043975f, -0.06732247f, 0.00688801f, -0.00222848f, -0.03484355f, 0.08151189f, 0.12171176f, 
    -0.12551545f, 0.04763779f, 0.34282720f, -0.40328264f, 0.11531196f, -0.00067495f, -0.05347878f, -0.16801237f, 
    -0.00552041f, -0.01270090f, 0.04082712f, 0.13552321f, -0.29701117f, -0.15112145f, 0.10681263f, 0.06962366f, 
    -0.10386693f, -0.00140869f, 0.02818127f, -0.12018587f, 0.04914158f, -0.08033364f, -0.09773482f, -0.02916992f, 
    0.15425673f, 0.21785326f, 0.06871760f, 0.15401657f, 0.02943969f, -0.02203157f, -0.04586037f, -0.02173627f, 
    0.06633326f, -0.05259417f, -0.03361411f, 0.01679687f, 0.10011044f, 0.07005432f, -0.14755104f, 0.23793317f, 
    0.11643133f, 0.15274276f, 0.09426339f, -0.00800830f, -0.03054501f, 0.15820839f, 0.10464641f, 0.05467083f, 
    0.36104202f, 0.08161680f, 0.02849078f, 0.15557648f, -0.03004377f, 0.01368530f, -0.03146982f, 0.12225185f, 
    -0.14518984f, 0.05043856f, -0.00761050f, -0.08457661f, -0.23664330f, -0.03029402f, 0.10487752f, 0.06550997f, 
    0.11486448f, 0.13408713f, 0.05952431f, 0.04701906f, -0.10050023f, 0.12984660f, 0.03380639f, -0.07155532f, 
    -0.47886211f, -0.10757378f, -0.36387801f, -0.37736219f, -0.04402542f, -0.18853305f, -0.05450173f, -0.05485956f, 
    -0.05786081f, -0.05289296f, 0.00276627f, -0.06858600f, 0.13902257f, 0.05762236f, 0.20934375f, 0.08604182f, 
    0.06870777f, 0.13830373f, 0.07246944f, 0.06348942f, -0.04604220f, -0.15527093f, 0.04248627f, -0.01170153f, 
    0.19556876f, -0.04261268f, 0.16871503f, 0.13547927f, 0.06908349f, 0.28159472f, -0.03207368f, 0.07755146f, 
    0.07642949f, 0.22401376f, -0.05465451f, 0.04606671f, 0.06470113f, -0.01592093f, -0.35172084f, 0.04163775f, 
    0.00858781f, 0.03582142f, 0.14577334f, 0.08250272f, -0.05395871f, 0.05429595f, 0.18061660f, 0.02545304f, 
    0.01489666f, -0.05015203f, -0.04229797f, 0.00100777f, 0.02480764f, 0.03222424f, 0.00227618f, 0.00053743f, 
    0.01777331f, 0.04476590f, -0.07755151f, -0.01498526f, -0.01395734f, -0.03483837f, -0.02495098f, 0.01906467f, 
    -0.01036836f, -0.02161983f, 0.03855675f, 0.04284613f, 0.05658795f, -0.03823564f, 0.00324547f, 0.01974432f, 
    0.01602428f, 0.02867015f, 0.03348540f, -0.03764729f, 0.00057640f, -0.06279338f, -0.05690413f, -0.05880399f, 
    0.00427829f, -0.08024314f, -0.05474386f, -0.03043932f, -0.01846326f, 0.02142037f, -0.00890525f, -0.05652981f, 
    -0.07235099f, 0.04437272f, 0.01904456f, -0.05568804f, -0.00064357f, -0.06885598f, -0.07651159f, 0.02015631f, 
    -0.04143471f, -0.01871722f, -0.06283503f, -0.07195009f, -0.03066584f, -0.06712402f, 0.01938904f, -0.05119855f, 
    -0.04388916f, 0.01628903f, 0.02631848f, 0.02671473f, -0.08055649f, -0.01573693f, -0.06958441f, -0.04978525f, 
    0.01689741f, -0.04506807f, 0.00915172f, -0.01142724f, -0.05919501f, 0.04038632f, 0.06296886f, 0.05925138f, 
    -0.07211956f, -0.00364431f, 0.00188994f, -0.07419541f, 0.01461867f, 0.00031393f, -0.02261148f, -0.02018438f, 
    -0.05154167f, -0.04717115f, 0.02235547f, -0.01880706f, -0.05159734f, -0.07168894f, -0.00396153f, -0.05820298f, 
    -0.05418961f, 0.03157599f, 0.01099477f, -0.01649888f, -0.05740662f, -0.07915516f, -0.01335326f, 0.05807908f, 
    0.02068518f, -0.00579113f, -0.02447708f, -0.02448388f, -0.01526030f, 0.02558612f, -0.06044714f, 0.03368895f, 
    0.02987963f, 0.06354395f, -0.04974997f, -0.04540483f, -0.03968017f, -0.03187240f, -0.07237244f, 0.00950551f, 
    0.00428622f, 0.03552872f, 0.05007189f, 0.02302631f, 0.05048256f, 0.01981761f, -0.00903260f, -0.00601671f, 
    0.04917415f, 0.02383488f, -0.07780387f, 0.05652032f, -0.04330070f, -0.03021908f, 0.01285831f, 0.01399782f, 
    -0.01623466f, 0.00098576f, -0.06450129f, 0.02606013f, -0.03614103f, -0.00741913f, 0.01284113f, -0.06901593f, 
    0.04299422f, 0.01520435f, -0.07635939f, 0.00160043f, -0.07029395f, 0.00761157f, -0.04985174f, -0.04347776f, 
    -0.04729345f, 0.00052237f, 0.02094729f, -0.05517793f, -0.07790930f, -0.01421093f, 0.06062616f, 0.02579881f, 
    -0.01426090f, -0.05941674f, 0.01404232f, -0.04453440f, -0.01954636f, 0.01030331f, 0.03531975f, 0.06226098f, 
    0.04853222f, -0.07948618f, -0.03824046f, 0.00137442f, 0.01661881f, 0.03782745f, 0.03354326f, 0.03977299f, 
    -0.00509533f, -0.07087318f, -0.03211206f, -0.05785852f, 0.00175119f, -0.06076347f, 0.01595160f, -0.05151318f, 
    0.04796109f, 0.06566978f, 0.05243400f, 0.02357647f, 0.02308844f, 0.00181498f, -0.07447357f, 0.02685463f, 
    -0.02441650f, -0.07429937f, 0.00976261f, 0.05511979f, 0.00405393f, -0.05672976f, -0.00385947f, -0.06130528f, 
    0.04736301f, 0.04844357f, 0.01294500f, -0.05103306f, -0.03038598f, -0.00837919f, -0.00377915f, -0.05125587f, 
    0.00402687f, -0.04777215f, 0.00992375f, -0.00496525f, -0.00491852f, -0.01710851f, 0.03197310f, 0.04650555f, 
    0.00108981f, -0.04895150f, 0.06514066f, -0.01556841f, -0.05321803f, -0.07399245f, 0.01534472f, 0.04567955f, 
    0.01802509f, 0.02768771f, -0.03714320f, -0.04179354f, -0.03151195f, -0.03001441f, 0.02339009f, 0.00764077f, 
    -0.01478281f, -0.07309867f, -0.00599941f, 0.05757200f, -0.04992982f, -0.06084261f, 0.03072974f, -0.05509750f, 
    -0.04939440f, -0.07462459f, 0.00140539f, 0.01148341f, -0.04399595f, -0.04510876f, 0.03548199f, 0.05703807f, 
    0.00223801f, -0.05222137f, -0.04567599f, 0.02548030f, -0.02884397f, 0.03834506f, -0.02792561f, -0.00768172f, 
    0.02514600f, -0.02346207f, -0.06452376f, -0.05301159f, -0.07491480f, 0.02983548f, -0.05829499f, -0.05375535f, 
    0.00650633f, 0.06205053f, -0.04920439f, -0.05569792f, 0.01493398f, -0.02596799f, -0.02760187f, 0.03159424f, 
    0.05870730f, -0.03495769f, -0.04928922f, -0.04941883f, -0.02417708f, -0.05509930f, 0.01460271f, -0.02087932f, 
    -0.07413545f, -0.03228550f, 0.00142105f, -0.01135346f, -0.05721888f, -0.00750290f, -0.00660325f, -0.00915840f, 
    -0.05894781f, -0.06109463f, -0.03251312f, 0.04338633f, -0.02053682f, 0.01580849f, -0.03325894f, -0.01313719f, 
    0.03192183f, -0.05327439f, 0.04586603f, 0.03958502f, -0.04432312f, -0.02958011f, 0.02290621f, 0.06121843f, 
    -0.00708127f, 0.01698435f, 0.02865230f, -0.03969456f, 0.01932166f, -0.02607785f, 0.05787988f, -0.07616856f, 
    -0.05515203f, -0.05475717f, -0.05412549f, -0.00416001f, -0.06009566f, 0.05390232f, 0.00165025f, 0.05802224f, 
    0.04333719f, 0.03287651f, -0.04558175f, 0.04878894f, 0.06216818f, 0.00651573f, -0.05925775f, 0.00150607f, 
    -0.00835172f, -0.07824612f, -0.00869944f, -0.00823375f, -0.07817541f, -0.01058441f, 0.05235577f, -0.06698257f, 
    -0.03213448f, 0.02010969f, 0.00731503f, -0.01291610f, 0.03088959f, -0.07282072f, 0.04704519f, -0.03224343f, 
    0.03442475f, -0.06521153f, -0.00424849f, 0.03718337f, -0.05101145f, -0.06602460f, 0.02456168f, 0.02691452f, 
    -0.04206255f, -0.03074514f, -0.06186485f, 0.00395407f, -0.02442510f, -0.06085116f, 0.00272906f, -0.07574255f, 
    0.01011629f, 0.00127036f, -0.02410681f, -0.02554674f, -0.07884322f, 0.04059327f, 0.01069303f, 0.05866886f, 
    -0.06883782f, -0.03513917f, -0.01462718f, 0.05806531f, 0.05658400f, -0.00127595f, 0.01508815f, 0.03802577f, 
    -0.05589627f, 0.01595744f, -0.06576943f, 0.05414598f, -0.02924920f, 0.02453553f, 0.01917750f, -0.05531169f, 
    -0.07217117f, 0.05482021f, 0.05580499f, 0.05128701f, -0.04473443f, -0.05507497f, -0.02644274f, 0.05628761f, 
    0.00623234f, 0.06226101f, -0.06713346f, 0.03848049f, 0.00975049f, -0.05550336f, 0.01960025f, -0.05730641f, 
    -0.04449407f, -0.05653998f, -0.03631962f, -0.04160981f, 0.03763758f, -0.01699698f, -0.02409026f, 0.06056825f, 
    0.04433851f, -0.05639253f, 0.04508957f, -0.07438913f, 0.01399942f, -0.05015408f, -0.00480349f, -0.02031583f, 
    -0.03031501f, -0.04281042f, -0.05523810f, -0.04754806f, -0.03522940f, 0.00890894f, 0.04901307f, -0.02889565f, 
    -0.03571696f, -0.06376053f, 0.02499896f, -0.05321820f, -0.01686666f, 0.01600481f, -0.04140591f, 0.00111272f, 
    -0.05924856f, -0.00008062f, 0.00841452f, -0.01109965f, 0.00885496f, -0.02082638f, -0.07480989f, -0.02433357f, 
    0.04189292f, 0.01208670f, -0.00594210f, 0.03780210f, -0.05872698f, -0.00521909f, -0.04882667f, 0.06550840f, 
    -0.05275401f, 0.02627685f, -0.07772327f, -0.02264014f, 0.06528518f, 0.04813599f, 0.02338462f, 0.04779422f, 
    0.00050079f, -0.07781895f, -0.01943673f, -0.04696918f, -0.00102888f, -0.07044932f, -0.05305638f, -0.05014127f, 
    -0.05633680f, 0.06233554f, 0.00955616f, -0.00162726f, -0.01233238f, 0.00565894f, 0.02126443f, 0.05157437f, 
    -0.00758364f, 0.00263091f, 0.00987184f, -0.01762145f, -0.06018292f, 0.06495158f, -0.03138617f, -0.06941744f, 
    -0.00949710f, -0.06606616f, -0.06634010f, 0.05667910f, -0.00174478f, 0.00290594f, -0.04194069f, 0.01824283f, 
    -0.05043610f, -0.05175808f, 0.00474740f, 0.04448598f, -0.04347194f, -0.04140644f, -0.00761557f, -0.00358120f, 
    -0.04898354f, -0.05812021f, 0.02115358f, 0.02943958f, -0.04593494f, 0.05991844f, 0.03602730f, 0.06275760f, 
    0.05921023f, -0.01852788f, -0.00311727f, 0.04324730f, 0.01376090f, -0.05634958f, 0.03055772f, -0.03638829f, 
    -0.04598665f, 0.06240961f, -0.07094184f, 0.03566151f, 0.04847450f, -0.06640691f, -0.03944167f, 0.00217481f, 
    -0.01335840f, -0.02950471f, -0.04807737f, 0.01830168f, 0.05951088f, -0.00488750f, -0.06519516f, -0.00498164f, 
    0.02563806f, -0.04707531f, -0.04477036f, -0.05159272f, -0.04160046f, 0.03215153f, 0.00150670f, -0.06293800f, 
    0.04005690f, 0.02346791f, -0.02095383f, -0.01263345f, -0.04120496f, -0.02531359f, 0.05698632f, -0.03916135f, 
    -0.07537486f, 0.04573643f, 0.06560406f, -0.07040320f, -0.06674083f, -0.02500379f, -0.06503402f, -0.06452955f, 
    -0.00748576f, -0.05890877f, 0.05329455f, 0.00978627f, -0.00523890f, 0.03223436f, -0.00890851f, -0.00587541f, 
    0.00774369f, 0.06515624f, 0.05535272f, 0.00094987f, 0.02875270f, -0.01368432f, 0.04940598f, -0.00938331f, 
    0.06110397f, 0.01945348f, 0.01406542f, -0.03743210f, 0.04433899f, -0.06248420f, 0.02973550f, 0.01519235f, 
    0.06325823f, -0.02423456f, 0.00984799f, -0.00119349f, -0.06129930f, -0.05289774f, 0.03475041f, 0.05649032f, 
    -0.17016709f, -0.12595184f, 0.12013510f, -0.14131536f, -0.04844305f, 0.02680212f, 0.00751429f, -0.18959707f, 
    0.06161140f, 0.07497890f, -0.06169755f, 0.00513458f, 0.49011379f, 0.36138254f, 0.01428831f, 0.14640972f, 
    0.10721961f, 0.06860471f, 0.14211093f, -0.08341764f, 0.06593317f, 0.12399171f, 0.22370082f, 0.01331319f, 
    -0.17765860f, -0.07549398f, 0.17295773f, 0.13906895f, -0.14067273f, 0.14218959f, 0.08728775f, 0.11492882f, 
    0.05242568f, -0.03186943f, 0.12298519f, -0.12388282f, -0.01448592f, -0.01915241f, 0.03304089f, 0.12376271f, 
    -0.07938869f, -0.08199549f, -0.08294465f, -0.20347589f, -0.08418071f, -0.00605680f, -0.04843106f, -0.06926467f, 
    -0.15115304f, 0.07763910f, -0.02284824f, 0.03324753f, 0.06327327f, -0.02065804f, 0.01905662f, -0.01520577f, 
    -0.05830807f, -0.10694727f, 0.11977199f, 0.01624253f, 0.38887045f, -0.02485090f, 0.34927541f, 0.00858156f, 
    -0.01725797f, -0.13358741f, 0.14442192f, 0.13388823f, -0.17315239f, -0.05949958f, -0.12762046f, 0.11353768f, 
    -0.10660248f, -0.19165723f, 0.05651635f, 0.29597762f, -0.11324080f, -0.02561380f, 0.05072148f, -0.02435704f, 
    -0.03056464f, -0.14543276f, 0.01450212f, -0.04400657f, 0.12015332f, -0.00572822f, -0.08590730f, 0.14708661f, 
    0.00052175f, 0.01690705f, 0.05289553f, 0.10809171f, -0.17719115f, 0.13964722f, 0.13363305f, -0.03554164f, 
    -0.26581818f, 0.05256086f, 0.13202037f, -0.12576357f, 0.19653364f, 0.15961707f, 0.02633940f, -0.06005924f, 
    0.05046412f, 0.01842504f, -0.01471648f, 0.12605031f, -0.12986465f, -0.03823444f, 0.08315337f, -0.24548233f, 
    0.03056430f, -0.05634999f, 0.05449816f, 0.08009482f, 0.06449936f, 0.01120811f, -0.12451430f, -0.09599744f, 
    -0.11711839f, -0.02779813f, -0.14051074f, -0.03339625f, 0.22551216f, 0.14267603f, 0.05187274f, 0.12331104f, 
    -0.02219038f, 0.06128478f, 0.03804503f, 0.20046191f, 0.21377182f, 0.10776938f, 0.01738411f, 0.17475963f, 
    -0.04616226f, -0.05740412f, -0.04396239f, 0.05680022f, -0.04870997f, -0.03906009f, -0.04876352f, -0.02454850f, 
    0.20153023f, 0.33748373f, 0.25086018f, -0.05436251f, -0.11686409f, 0.00456343f, 0.12427270f, 0.12241944f, 
    0.05468531f, -0.12964937f, -0.02526910f, 0.06697606f, 0.02637298f, -0.02739400f, -0.13662912f, 0.18224514f, 
    0.09317795f, -0.04075585f, 0.03124217f, 0.12749344f, 0.00940851f, 0.13007995f, -0.08893483f, -0.02941645f, 
    -0.03289753f, -0.07872585f, 0.05463915f, 0.08353963f, -0.06514296f, -0.06202676f, 0.07351674f, -0.14206281f, 
    -0.04935970f, -0.11855233f, -0.03821725f, 0.20973468f, 0.08647959f, -0.01132839f, 0.27550161f, -0.12847316f, 
    -0.10133229f, -0.05734087f, -0.14929900f, -0.09528527f, -0.16606808f, -0.02847443f, 0.00966583f, -0.08604061f, 
    0.29193598f, -0.01245013f, 0.08554763f, -0.02333157f, -0.08893709f, 0.03300598f, -0.02696196f, 0.07104144f, 
    0.08578718f, -0.10605158f, 0.03713676f, -0.08355478f, -0.14776000f, -0.03841715f, -0.16354653f, -0.16310282f, 
    0.07125780f, 0.15917040f, 0.05219464f, 0.14717413f, 0.14513725f, 0.00282187f, 0.05770595f, -0.02380803f, 
    -0.09467930f, 0.04693283f, -0.20026411f, -0.01199077f, 0.02955486f, -0.06199105f, 0.13041902f, 0.07249112f, 
    -0.06907251f, -0.07572627f, 0.04532083f, 0.03057691f, 0.07807926f, 0.13889360f, -0.23615454f, -0.13488737f, 
    0.21104702f, -0.00699469f, -0.03850030f, 0.01840744f, -0.04078301f, 0.02789858f, -0.03175871f, -0.01777072f, 
    0.17739342f, 0.02432168f, -0.15276319f, 0.10034956f, 0.16624483f, 0.06963886f, 0.01131833f, -0.02749566f, 
    -0.10602140f, -0.00590013f, -0.01348345f, 0.13326111f, 0.16528708f, 0.13480596f, -0.26061806f, 0.17595439f, 
    0.00795348f, 0.03504002f, -0.07120901f, -0.01355124f, 0.09306358f, 0.08635088f, -0.05390736f, -0.01046000f, 
    -0.18748501f, 0.18541485f, -0.14067672f, 0.06614873f, 0.23697880f, 0.13823634f, 0.00842963f, -0.12449253f, 
    0.12749368f, 0.14340667f, 0.05552164f, 0.03830643f, -0.15375596f, 0.33421594f, 0.01046673f, -0.18452731f, 
    -0.05535020f, 0.02647847f, 0.02720358f, 0.08596473f, 0.16982226f, -0.00115903f, 0.00045622f, -0.07646401f, 
    0.47924021f, -0.02505578f, 0.16763234f, 0.10632376f, -0.09216100f, -0.04455064f, 0.03946757f, 0.04903940f, 
    -0.00609367f, 0.03320515f, 0.15248041f, 0.12201371f, 0.52831060f, -0.00259044f, 0.22189683f, -0.09081147f, 
    -0.07804840f, 0.14934707f, 0.10146103f, -0.01620692f, -0.01829739f, 0.12614964f, -0.04680264f, 0.01429258f, 
    -0.13350010f, 0.15807138f, 0.10665257f, 0.15079248f, -0.30928153f, -0.03307699f, 0.08681253f, -0.20436876f, 
    -0.04923737f, -0.05407979f, -0.00350398f, -0.01207484f, -0.42156976f, -0.03512133f, -0.27059272f, -0.04020439f, 
    0.03627297f, -0.07675024f, 0.07262415f, -0.02566765f, -0.01825712f, 0.03548430f, 0.09741466f, 0.07425573f, 
    -0.31340691f, 0.00954084f, -0.09709302f, 0.02250668f, 0.13497424f, 0.06701858f, -0.06773728f, -0.01370365f, 
    -0.11635904f, -0.04257006f, 0.10598534f, -0.01514854f, 0.08804981f, 0.06155591f, -0.01988047f, -0.06364218f, 
    -0.11791309f, 0.02010924f, -0.05031719f, -0.11084210f, -0.06798307f, 0.00691940f, 0.11128337f, -0.02624960f, 
    -0.08822269f, 0.31587386f, -0.06269107f, 0.07820174f, 0.21576209f, -0.01430173f, 0.00242947f, -0.00395134f, 
    0.10513081f, 0.05886363f, -0.09094864f, -0.10743461f, -0.21035089f, -0.00197976f, -0.15081586f, -0.00942081f, 
    0.05212075f, -0.03446664f, 0.04759927f, 0.10563685f, 0.11345409f, 0.03726092f, 0.10634850f, 0.12364779f, 
    -0.05380576f, 0.08537041f, -0.00179197f, 0.06198187f, 0.09560823f, 0.01481475f, -0.06326695f, 0.06641118f, 
    0.08069757f, -0.08508343f, 0.04529520f, 0.00563451f, 0.34014022f, 0.01738373f, -0.09985817f, -0.01739645f, 
    0.18415743f, 0.09388749f, 0.00159101f, -0.09524382f, 0.01401979f, 0.07189523f, 0.02126356f, -0.00467027f, 
    -0.15141930f, -0.16797104f, -0.16483608f, -0.03058509f, 0.05816159f, 0.02043703f, -0.06137332f, -0.07833905f, 
    0.06743109f, -0.02493266f, -0.03293459f, 0.14681754f, 0.00676556f, -0.03816019f, 0.10528716f, 0.27612740f, 
    -0.04056692f, 0.03674000f, 0.00062930f, 0.00212878f, 0.13622181f, 0.10515682f, -0.02116357f, 0.11959749f, 
    0.15278773f, 0.05361279f, 0.01198881f, 0.04580197f, 0.02280119f, -0.08846478f, -0.10467735f, -0.01383436f, 
    -0.05440772f, 0.01627777f, 0.11280262f, 0.00670722f, -0.05112378f, 0.17227212f, 0.16567934f, 0.14185674f, 
    -0.00511745f, -0.14328696f, 0.00262485f, 0.02248370f, 0.04334461f, -0.02444085f, -0.21379265f, 0.05409455f, 
    -0.11194380f, -0.27660039f, -0.22705813f, -0.14232005f, 0.02425857f, 0.03689737f, 0.02359444f, 0.01156051f, 
    0.01103798f, 0.07628585f, -0.05398744f, -0.01637698f, -0.07692866f, 0.24742016f, -0.06334978f, 0.08448606f, 
    -0.09500077f, -0.03470814f, 0.12674572f, 0.15428151f, 0.01206690f, 0.02440185f, 0.03017561f, 0.08001049f, 
    -0.14613578f, 0.16497861f, 0.11812600f, 0.10504545f, -0.03795237f, -0.05425704f, -0.01929948f, 0.01401480f, 
    -0.02980430f, -0.00336224f, 0.12357368f, 0.07557998f, -0.43541321f, 0.13606693f, 0.03650095f, -0.13912162f, 
    0.07521684f, 0.01496313f, 0.01845001f, 0.03372357f, 0.03420430f, 0.13417163f, -0.00106160f, 0.09779502f, 
    -0.20362656f, 0.10230196f, 0.16306648f, 0.20950192f, -0.12238423f, 0.01555164f, 0.08826565f, 0.06614571f, 
    -0.08017198f, 0.01238106f, 0.13101552f, -0.02192095f, -0.16054127f, 0.09971508f, 0.05927164f, 0.23762681f, 
    -0.19938667f, 0.07150263f, -0.01653521f, -0.02671889f, -0.03882256f, 0.05269842f, 0.00365700f, 0.09207169f, 
    -0.10051116f, -0.17843899f, -0.03775310f, 0.16757661f, 0.02726352f, -0.01469882f, 0.00741272f, -0.03455904f, 
    -0.01858199f, -0.05703517f, 0.13223141f, 0.06416444f, 0.23497117f, 0.03479162f, 0.03571400f, -0.02823133f, 
    0.03292928f, 0.21202925f, 0.12100803f, -0.04302705f, 0.09090067f, 0.01700907f, -0.09225230f, 0.09144504f, 
    0.15103832f, 0.05762141f, 0.14573565f, 0.24783574f, 0.00064604f, -0.07506648f, 0.00352512f, 0.02090564f, 
    0.01604569f, 0.03359352f, -0.00908241f, -0.02096892f, 0.17824289f, -0.15724137f, -0.07214254f, 0.01190709f, 
    0.01845496f, 0.15915570f, -0.03267110f, -0.05204195f, -0.09702008f, 0.03812089f, -0.01171556f, -0.07195061f, 
    -0.06526341f, -0.03579991f, 0.06409333f, -0.00910918f, -0.03909903f, 0.02822293f, 0.03176629f, -0.05701946f, 
    0.03139399f, -0.05079097f, 0.06625207f, -0.02844216f, -0.01945416f, -0.04662958f, -0.01399124f, -0.06500745f, 
    -0.01411726f, 0.01323020f, 0.04057306f, -0.01880831f, 0.01573792f, -0.05782740f, 0.01885617f, -0.00606242f, 
    0.05123317f, -0.06399952f, -0.07376920f, -0.00081499f, -0.05399102f, 0.05578018f, -0.00088172f, -0.04854662f, 
    -0.02514648f, 0.00481431f, -0.02356793f, -0.00493286f, 0.04170792f, 0.04375552f, 0.03097468f, 0.04728497f, 
    -0.02959805f, -0.01326532f, -0.04261838f, -0.05090991f, -0.03289787f, 0.00318117f, -0.04971383f, 0.03578172f, 
    0.01200324f, 0.04381394f, 0.01572398f, -0.01916717f, -0.03992350f, 0.05848297f, -0.04321568f, -0.00479684f, 
    -0.02785770f, -0.07639004f, 0.05078475f, -0.07704559f, -0.07065341f, 0.03025813f, -0.02584725f, 0.05095648f, 
    0.00098922f, 0.00726741f, 0.00870570f, -0.01179773f, -0.00719493f, -0.01153361f, -0.01513949f, 0.03349377f, 
    -0.06816237f, 0.06068503f, -0.00815748f, 0.00221476f, 0.06283995f, -0.07671878f, -0.05663431f, -0.05885771f, 
    -0.03485832f, -0.05400808f, -0.01167731f, -0.00678595f, -0.02063944f, -0.00947278f, 0.04027344f, 0.02284769f, 
    -0.00029837f, -0.05670261f, 0.03696867f, -0.02862880f, 0.05791154f, -0.03293533f, 0.04836997f, -0.00175789f, 
    0.03188932f, -0.04597090f, -0.01490164f, -0.07129487f, 0.05591347f, -0.03370389f, -0.01133151f, -0.01764810f, 
    -0.06465918f, 0.01516789f, -0.06229936f, 0.02569614f, 0.02432851f, 0.00468286f, -0.01403486f, 0.05923169f, 
    -0.05733977f, -0.05836354f, -0.07455033f, 0.01468001f, -0.05072782f, -0.00294771f, 0.06171025f, 0.02108413f, 
    0.00513631f, -0.01303572f, -0.01436080f, 0.05862465f, -0.06741947f, -0.06648395f, -0.06440953f, 0.04382801f, 
    0.01916721f, 0.01509449f, 0.06235422f, -0.06538802f, 0.03763804f, -0.00146982f, -0.07747629f, -0.03568079f, 
    -0.04544567f, 0.03850823f, 0.00307143f, -0.07284772f, -0.02815582f, -0.03061465f, -0.02084371f, 0.02817673f, 
    -0.03033833f, -0.05796424f, -0.01433927f, -0.06918258f, 0.05660756f, -0.07152224f, 0.02061176f, -0.05043036f, 
    -0.05520603f, 0.04368201f, -0.05277853f, 0.03322793f, -0.02287315f, -0.05065394f, -0.02650803f, -0.05259372f, 
    -0.02437148f, -0.04762113f, 0.05862383f, -0.02367765f, 0.05433375f, 0.05528218f, -0.07369931f, -0.05382588f, 
    0.03487413f, 0.00474612f, -0.04470959f, -0.00183056f, 0.06237680f, -0.00111205f, -0.06855893f, 0.02078423f, 
    -0.07436585f, 0.04221343f, -0.00011754f, -0.06332225f, -0.02129314f, 0.00604570f, -0.01669694f, -0.05920668f, 
    0.01227061f, 0.03592468f, 0.06946323f, 0.06105971f, 0.03261885f, 0.00947527f, -0.03397096f, 0.03391403f, 
    -0.07236415f, -0.07794268f, -0.00771767f, -0.04477694f, -0.08695828f, -0.06782337f, -0.04780588f, -0.04461160f, 
    -0.00836844f, 0.03518486f, -0.01484938f, 0.04192165f, -0.04366824f, -0.07257408f, -0.07324342f, -0.05423253f, 
    -0.05861342f, -0.00499418f, 0.04107811f, -0.08069455f, -0.01323743f, -0.05246767f, -0.07591695f, -0.04104628f, 
    -0.04194248f, 0.05494667f, -0.03430898f, 0.04782266f, -0.01884018f, 0.05048987f, 0.02736749f, 0.01471372f, 
    0.04523387f, -0.00485260f, 0.02155671f, -0.04246105f, -0.00250522f, 0.03341018f, -0.02335362f, 0.03793357f, 
    -0.03635339f, -0.03439702f, 0.03435406f, -0.05565413f, 0.04130287f, -0.03551221f, -0.00326720f, -0.05816900f, 
    -0.04520338f, -0.05746733f, 0.04658523f, 0.03954643f, 0.02411254f, -0.03863436f, -0.02500394f, 0.03221795f, 
    -0.04110815f, 0.01947757f, 0.02255831f, -0.03299334f, -0.00615395f, 0.01672537f, -0.05035287f, 0.02941117f, 
    -0.09045771f, 0.01703675f, 0.03192244f, 0.01257816f, -0.06992828f, 0.05084889f, 0.01979166f, 0.03669315f, 
    -0.05674863f, 0.02421751f, -0.02514447f, 0.01475846f, 0.02842808f, -0.01871028f, 0.00203448f, 0.01671183f, 
    -0.01554009f, 0.02216560f, -0.01559637f, 0.04760420f, 0.04225353f, 0.06624985f, -0.04060111f, 0.01523502f, 
    0.03195199f, -0.07193545f, -0.01277079f, 0.05107670f, 0.02171092f, 0.02582519f, -0.03918440f, 0.00686765f, 
    -0.03713134f, -0.02116245f, 0.04786344f, -0.06136310f, -0.00818909f, -0.00279404f, -0.03410733f, -0.01575546f, 
    -0.00815799f, 0.03698276f, 0.01050536f, 0.04843822f, -0.01679350f, 0.00850263f, -0.06077511f, -0.01424120f, 
    -0.08583242f, 0.02455469f, -0.06152724f, -0.07022918f, -0.07787870f, -0.06692945f, 0.00023986f, -0.06681742f, 
    -0.03151751f, -0.04992862f, 0.01717353f, 0.04192773f, 0.01951271f, 0.03540386f, -0.00525516f, 0.02693337f, 
    -0.02094469f, -0.06062222f, -0.00566323f, -0.05683825f, 0.04586731f, -0.02826761f, -0.00710258f, -0.02298333f, 
    -0.02913772f, -0.06162443f, -0.06515349f, -0.01797421f, -0.03892505f, -0.02386607f, -0.02617558f, -0.00196791f, 
    0.01483836f, 0.02094424f, 0.05516805f, -0.02036722f, 0.03649927f, 0.04003354f, -0.04402238f, 0.04634568f, 
    -0.00313646f, 0.05046151f, -0.02964824f, -0.02022475f, -0.02519873f, -0.04020873f, -0.02361564f, 0.06270591f, 
    -0.03962494f, -0.05918274f, -0.01722635f, -0.07015482f, 0.02973058f, 0.03173414f, -0.01515245f, -0.05562913f, 
    -0.07177034f, 0.01413150f, -0.07853745f, 0.00756058f, -0.02880546f, -0.00253872f, 0.06050920f, -0.05177959f, 
    0.05037970f, -0.01392605f, 0.05058606f, 0.03162307f, -0.04444751f, -0.07856689f, -0.00782189f, 0.03578450f, 
    -0.04759487f, 0.04206826f, -0.06275420f, -0.05885899f, -0.08333120f, -0.08107562f, 0.04490097f, -0.08472379f, 
    -0.03700420f, -0.04720153f, -0.01253875f, -0.03983694f, 0.02012982f, 0.01977515f, -0.02210566f, 0.02376438f, 
    -0.02132964f, 0.05999031f, 0.06899978f, -0.02715697f, 0.03752404f, 0.00400062f, 0.00613763f, 0.02124685f, 
    0.01470999f, -0.00760693f, -0.05805173f, -0.06924864f, 0.05484787f, -0.03719214f, -0.03115515f, 0.02892649f, 
    -0.00900012f, 0.05649551f, 0.05501242f, 0.01005022f, -0.00704846f, -0.06592704f, 0.04960427f, -0.05252662f, 
    0.02635160f, 0.02124865f, 0.05119650f, 0.06403299f, 0.05549274f, -0.06788051f, -0.04794838f, -0.02889782f, 
    -0.03774558f, 0.02676850f, -0.00953260f, 0.01328416f, 0.03051241f, -0.02310922f, -0.01416366f, -0.00991273f, 
    -0.06976163f, 0.01734107f, -0.01030357f, 0.06031787f, -0.05927270f, 0.03082032f, -0.01393099f, 0.04517323f, 
    0.00971087f, -0.02321838f, -0.01840138f, -0.03587511f, -0.02710946f, 0.02382747f, -0.04383793f, -0.02882858f, 
    -0.05690207f, -0.02136996f, 0.01049762f, 0.03081460f, -0.07079878f, -0.03063071f, -0.04181020f, 0.01458098f, 
    -0.06468769f, -0.05716400f, -0.05635376f, -0.00563674f, 0.01609879f, -0.00847594f, 0.01647046f, 0.01178709f, 
    0.02271459f, 0.05456554f, -0.05594740f, -0.05494571f, -0.03473105f, 0.00099896f, 0.02234042f, -0.00801922f, 
    -0.03304930f, -0.01073403f, 0.04348223f, -0.03832921f, 0.02231662f, -0.07155032f, 0.04423923f, -0.06443404f, 
    -0.04382446f, -0.03248894f, -0.04594757f, -0.03621013f, 0.06993911f, 0.02767273f, -0.04557649f, -0.06060442f, 
    -0.05248195f, 0.02079813f, -0.00073610f, 0.05773900f, -0.00823967f, -0.03018388f, -0.01023265f, -0.02255500f, 
    0.05650658f, 0.02176186f, -0.02724732f, 0.02515549f, 0.06240129f, -0.06178420f, -0.05643828f, 0.04877608f, 
    0.02353300f, -0.05595924f, -0.05865200f, -0.06546629f, 0.04621519f, -0.06438008f, 0.02380216f, 0.04653590f, 
    0.05403026f, 0.00112226f, 0.03619070f, -0.00221717f, -0.01590524f, 0.05495654f, -0.02889354f, -0.00640096f, 
    -0.03303684f, 0.01817237f, -0.02528608f, 0.02215774f, -0.06541936f, -0.06920545f, -0.04523206f, -0.02941510f, 
    0.02613933f, -0.03771940f, 0.04577687f, -0.04940961f, -0.03905278f, -0.07250886f, -0.05603909f, 0.05925389f, 
    -0.05446461f, -0.01085926f, 0.00960339f, -0.06948530f, 0.05331100f, 0.06485029f, -0.06812200f, -0.06661786f, 
    -0.02647106f, 0.06257364f, -0.05280094f, 0.05786350f, 0.01559616f, -0.06764226f, 0.06738691f, 0.00224396f, 
    -0.03117387f, -0.04416296f, 0.03945412f, 0.01770019f, -0.07039686f, 0.03007806f, -0.03738266f, 0.03251177f, 
    -0.02048693f, 0.05748226f, -0.02630444f, -0.07012980f, -0.02134744f, -0.00531131f, 0.01261600f, -0.05820891f, 
    0.00740444f, 0.04103079f, 0.04850229f, -0.04977072f, 0.01611595f, -0.02869370f, -0.03714846f, -0.05432539f, 
    0.00331249f, -0.03210656f, 0.00163811f, 0.00205696f, -0.00401769f, -0.02113467f, -0.05979145f, -0.03624976f, 
    -0.02656573f, 0.06015074f, -0.07730446f, 0.04782834f, 0.00190583f, -0.05822664f, -0.04846360f, 0.01257030f, 
    -0.07719715f, -0.00890544f, -0.04988459f, -0.04666369f, 0.03690997f, 0.01539716f, -0.00266934f, 0.02981884f, 
    -0.05212756f, 0.05334638f, 0.05938955f, -0.06315340f, -0.01896974f, 0.04815306f, 0.01766243f, -0.06161942f, 
    -0.01937209f, -0.05719661f, 0.05382894f, -0.05023015f, -0.02380170f, -0.02983144f, 0.01495664f, 0.01393173f, 
    0.01741168f, -0.06346844f, -0.03472496f, -0.03950913f, -0.04603031f, -0.07886914f, 0.05912678f, -0.00685567f, 
    -0.01177245f, -0.04026074f, -0.00069828f, -0.02297812f, 0.05954582f, -0.06927234f, 0.06030906f, 0.04526052f, 
    -0.06544722f, 0.02557230f, 0.04021053f, -0.07884712f, 0.03338797f, -0.03885413f, -0.06675550f, -0.03894477f, 
    0.03373281f, -0.04915711f, 0.04028122f, -0.06947028f, -0.04321076f, 0.02337248f, 0.01050294f, -0.00310677f, 
    -0.02991330f, -0.06987578f, 0.03789814f, 0.03807831f, 0.01364304f, 0.02023874f, -0.02139058f, 0.04248197f, 
    -0.05317876f, 0.04014388f, 0.05261561f, -0.00508225f, -0.04734425f, -0.00303313f, 0.02029282f, 0.01449133f, 
    0.00458402f, -0.06233003f, 0.03400327f, 0.02495484f, -0.03105571f, 0.03321729f, -0.07009464f, 0.01061172f, 
    0.04675422f, 0.02801197f, 0.04302383f, 0.06090754f, 0.05457012f, 0.02189910f, -0.00926493f, -0.04930070f, 
    -0.05281319f, 0.03676434f, -0.02899309f, 0.00486042f, -0.03307246f, 0.05858810f, -0.03583482f, 0.00673737f, 
    0.02701228f, -0.05289078f, 0.05318469f, -0.01133534f, -0.07400370f, 0.01392432f, 0.00793422f, 0.05597941f, 
    0.00293165f, 0.04301663f, -0.03747375f, -0.00898997f, -0.05575938f, -0.01712383f, -0.03596180f, -0.06243826f, 
    0.05248563f, -0.01893129f, -0.00742607f, 0.01425220f, -0.04770289f, 0.00053873f, -0.03183730f, -0.06563295f, 
    0.02629520f, -0.02792511f, -0.02021953f, -0.01105771f, -0.05689517f, 0.01134937f, -0.02741967f, -0.06892775f, 
    -0.02682988f, 0.00898726f, 0.02826525f, 0.01426912f, 0.00993789f, -0.01951914f, -0.03153575f, -0.03457903f, 
    -0.06566763f, -0.05999986f, 0.00768748f, -0.02010168f, 0.05737069f, -0.02488230f, 0.00918749f, -0.07316075f, 
    0.04082596f, -0.03410829f, -0.00982969f, 0.06170607f, -0.01507519f, 0.05366886f, 0.03409817f, 0.04434798f, 
    0.02729290f, -0.00633421f, -0.01440679f, 0.02448404f, -0.04159572f, 0.04697075f, -0.04332533f, 0.02935978f, 
    -0.04539260f, -0.03872548f, 0.01336999f, 0.02252049f, -0.02596943f, 0.01052185f, 0.02108161f, -0.00324163f, 
    -0.02325601f, 0.01825158f, -0.06898308f, -0.03967412f, 0.05785446f, 0.02627088f, 0.04018370f, 0.06063325f, 
    0.02147599f, -0.03942006f, -0.06301856f, 0.04255459f, 0.06320113f, -0.03302400f, 0.00393219f, -0.02585269f, 
    -0.01857929f, 0.02504911f, -0.02187403f, 0.06071477f, 0.05830929f, -0.06270275f, 0.02949356f, 0.06673405f, 
    0.04276628f, -0.03709618f, 0.00584702f, 0.00148312f, 0.06054362f, -0.07497183f, -0.00031985f, 0.04627559f, 
    -0.04016051f, 0.04616828f, 0.04205035f, -0.03122288f, 0.01822813f, 0.03900255f, 0.05746372f, 0.00363144f, 
    0.00140024f, 0.01025820f, -0.05997045f, -0.01533862f, 0.04630987f, -0.00422762f, -0.06707042f, 0.02336965f, 
    0.04838312f, 0.05346004f, -0.04032731f, 0.02789394f, -0.03208200f, -0.07210273f, 0.02062912f, 0.01933998f, 
    -0.02640633f, 0.01846433f, -0.04381845f, -0.06178043f, 0.02664697f, -0.07901686f, -0.01266914f, 0.05461118f, 
    -0.06924708f, 0.01626511f, 0.03871102f, 0.00501511f, -0.01286758f, 0.04679606f, -0.02058059f, 0.00922674f, 
    -0.03880095f, 0.03964770f, -0.05835289f, 0.00031747f, -0.04386793f, -0.07408217f, -0.03366536f, 0.04317469f, 
    0.07040181f, -0.03826037f, 0.00866530f, -0.04817512f, -0.04698293f, -0.00806370f, 0.04738780f, 0.05879990f, 
    0.03203397f, -0.02356317f, 0.00196729f, 0.04496664f, -0.05291426f, -0.03629637f, 0.00535341f, 0.01834930f, 
    -0.03374763f, -0.05145975f, 0.00798068f, -0.03536595f, 0.01414348f, -0.06543342f, -0.00669276f, -0.03227067f, 
    0.01782474f, 0.05408531f, -0.02541724f, -0.02726778f, 0.02373010f, -0.04936161f, -0.00862991f, -0.01363148f, 
    0.05471273f, -0.02061506f, -0.01982633f, -0.00384521f, -0.07241777f, -0.01472247f, 0.05199105f, -0.07667773f, 
    0.00975404f, -0.03122041f, 0.01184751f, 0.04562266f, 0.00774513f, -0.01590987f, -0.06880227f, -0.03200991f, 
    0.04988005f, -0.05434748f, -0.06533539f, -0.03202270f, 0.00285488f, -0.07249806f, 0.01189165f, 0.00237335f, 
    0.06111421f, -0.05902962f, -0.04858347f, 0.06049369f, -0.00306278f, -0.01738388f, -0.00680511f, -0.05648298f, 
    -0.06019966f, -0.07030362f, -0.06123910f, -0.06648606f, 0.01896892f, -0.07157408f, -0.06120182f, 0.03174484f, 
    0.06223373f, -0.07848251f, 0.01426962f, -0.07379708f, 0.02616094f, -0.04622322f, -0.07220069f, -0.07057912f, 
    -0.06294993f, 0.00519640f, 0.00268507f, 0.02220238f, -0.04166413f, -0.02041387f, 0.02456456f, -0.00850209f, 
    -0.00325993f, 0.00185943f, -0.04921540f, 0.04177907f, 0.04198554f, -0.04810695f, -0.02888513f, 0.01908744f, 
    0.01844758f, -0.04554515f, -0.02716249f, 0.03354450f, -0.02019716f, -0.02675261f, -0.06458766f, -0.05045097f, 
    -0.00553993f, 0.03795443f, -0.04944801f, -0.01929162f, 0.00426040f, 0.03204409f, -0.05645717f, -0.03909359f, 
    0.05401591f, -0.00434968f, -0.01220613f, -0.01130457f, -0.07358772f, 0.03475352f, 0.00082066f, 0.00179693f, 
    -0.04860669f, -0.06003539f, -0.05291608f, 0.00319274f, -0.00188404f, 0.02586832f, 0.01326260f, -0.01231025f, 
    -0.00388738f, -0.01447233f, -0.03994728f, 0.03440508f, -0.00317051f, -0.03574503f, 0.06454378f, -0.06118727f, 
    -0.07063753f, 0.01423423f, -0.03121094f, 0.03888172f, -0.06850959f, -0.00196853f, -0.01092128f, -0.01787268f, 
    0.04508004f, -0.05937165f, -0.01200501f, -0.03807737f, -0.03713996f, -0.06343260f, 0.01835445f, 0.00045917f, 
    0.00602474f, 0.01471362f, -0.07528955f, 0.06185758f, 0.02594300f, 0.06364249f, 0.03128168f, -0.07632534f, 
    -0.03009406f, -0.07456374f, 0.00156153f, 0.04353553f, -0.05541063f, 0.06250093f, -0.04878302f, -0.02912573f, 
    0.02062379f, -0.07425960f, -0.04730519f, -0.06932692f, -0.01000903f, -0.02815160f, -0.06931913f, 0.00304301f, 
    0.05190672f, -0.06485593f, 0.02791172f, 0.00585370f, -0.02056611f, -0.02089704f, 0.06210122f, -0.06609284f, 
    0.03589885f, -0.01058561f, -0.05818354f, -0.00150393f, 0.00312235f, -0.06246772f, 0.04546413f, 0.00368065f, 
    -0.04576300f, -0.01971720f, 0.01584475f, 0.00836424f, -0.05220958f, -0.02961089f, -0.07809638f, 0.03014089f, 
    0.03747713f, -0.02568493f, 0.03326872f, -0.02061072f, 0.00120886f, -0.00443521f, -0.00228936f, -0.05450675f, 
    -0.06737193f, 0.02187170f, -0.03279725f, 0.01505533f, 0.02812243f, 0.04232557f, -0.03822994f, -0.01700988f, 
    0.00358106f, 0.04658005f, 0.03925076f, 0.03003668f, -0.06586277f, 0.04631625f, 0.05989834f, 0.03716519f, 
    0.02467140f, 0.05365618f, 0.06045022f, -0.00739403f, -0.07699896f, -0.03172608f, 0.05030003f, 0.03040713f, 
    -0.03131257f, 0.00412014f, -0.00039533f, -0.00610022f, 0.04191921f, -0.00862742f, 0.01880449f, -0.06746617f, 
    -0.00031576f, -0.06518868f, 0.03682386f, -0.05760867f, 0.03828138f, 0.04063389f, -0.06653860f, -0.02200778f, 
    0.04011613f, -0.02495023f, 0.05516027f, -0.02673169f, -0.07788214f, 0.05600750f, 0.00097523f, -0.05046643f, 
    0.03802951f, 0.03868038f, -0.04269938f, 0.01038771f, 0.00463520f, -0.02567918f, 0.01261945f, -0.02205439f, 
    -0.06998046f, -0.00276483f, 0.05988616f, -0.03655330f, -0.05702345f, -0.04139726f, 0.05807709f, 0.05363600f, 
    0.03252640f, 0.03124641f, -0.06742756f, 0.03040270f, -0.06955135f, 0.01136250f, 0.02702623f, 0.02735553f, 
    -0.00556993f, -0.05732139f, -0.00066645f, -0.03768969f, -0.07378963f, -0.06489187f, 0.05823939f, -0.03424567f, 
    -0.05596593f, -0.03808092f, -0.03453916f, -0.00204200f, 0.01620517f, 0.00829466f, -0.05886904f, 0.03699531f, 
    -0.02441583f, -0.07220291f, -0.07420959f, 0.00495398f, -0.03503206f, 0.02092691f, -0.06584039f, 0.00619401f, 
    0.02653003f, 0.00290473f, 0.02733548f, -0.01360280f, -0.04058040f, -0.01230819f, 0.04310387f, 0.01463001f, 
    -0.16158032f, -0.28961289f, 0.01893810f, 0.04860561f, -0.01602509f, 0.09196131f, -0.01058180f, 0.23421785f, 
    -0.02666209f, 0.16172321f, 0.08024208f, -0.06415761f, -0.18658730f, 0.21247901f, -0.20650575f, 0.06058296f, 
    -0.00916287f, 0.05015686f, -0.00879480f, 0.09561341f, 0.04320551f, 0.18342921f, 0.12510444f, -0.14639676f, 
    0.49772188f, 0.09906348f, 0.04876604f, 0.17972386f, 0.09567831f, 0.18445817f, -0.03921326f, -0.09237920f, 
    -0.05021339f, -0.05732558f, 0.02493915f, 0.02631826f, -0.22877884f, -0.04666260f, -0.05871592f, -0.06486996f, 
    -0.13810499f, -0.15639356f, -0.11771353f, -0.13877133f, 0.03996321f, 0.02285090f, 0.00708413f, 0.27574748f, 
    -0.23734242f, -0.00331157f, -0.30232576f, 0.21743336f, 0.01312078f, 0.01943403f, 0.03975940f, 0.11794735f, 
    0.18668035f, 0.01430444f, -0.03189614f, -0.06442577f, 0.50004101f, -0.09807099f, -0.04194674f, 0.02461686f, 
    0.03067764f, 0.00053980f, 0.09870546f, -0.00535666f, 0.05113942f, 0.08073945f, 0.11353262f, 0.13712606f, 
    0.46959323f, 0.04904425f, 0.03970265f, -0.13588767f, -0.05729479f, 0.02020255f, -0.05407391f, -0.22643852f, 
    -0.05339080f, -0.02134589f, 0.06621511f, -0.11965188f, -0.13116203f, 0.33198887f, -0.18262333f, -0.15964220f, 
    0.12299055f, 0.05379857f, -0.04141299f, 0.14222088f, -0.13249567f, 0.20095699f, 0.13453276f, 0.13445987f, 
    -0.20116359f, -0.00055401f, 0.30369803f, -0.03734801f, 0.08410230f, 0.02780736f, 0.03041830f, 0.08887722f, 
    -0.17482890f, -0.12762564f, -0.04139683f, 0.00733717f, -0.02985815f, 0.04875416f, 0.00452304f, -0.11033299f, 
    0.08816453f, -0.10049830f, -0.04734997f, -0.01876193f, 0.10837865f, 0.01202066f, -0.06668018f, -0.03047294f, 
    -0.15909943f, -0.07185078f, 0.03648072f, 0.18901084f, 0.09528247f, 0.02051780f, 0.10173976f, 0.17330162f, 
    0.01622338f, -0.02505045f, 0.12257319f, -0.09267770f, -0.10424412f, 0.29128000f, -0.04905704f, 0.00293338f, 
    0.01110531f, 0.00142064f, 0.03117701f, -0.08101022f, -0.00266872f, 0.00047185f, 0.05262437f, 0.05097852f, 
    0.46399960f, 0.40696725f, 0.17245381f, 0.46610224f, 0.26703942f, -0.06641325f, -0.08004951f, -0.15206264f, 
    0.00693143f, 0.02591657f, 0.03668604f, 0.10296018f, -0.21711475f, -0.02623980f, 0.08124115f, 0.17504951f, 
    0.12593608f, 0.00318767f, -0.05787865f, 0.10634509f, 0.02076567f, -0.08770607f, -0.02060259f, 0.01637997f, 
    -0.33173567f, -0.13876292f, -0.17303537f, 0.12681486f, -0.02323434f, -0.18165381f, -0.04636240f, 0.02851053f, 
    -0.10891181f, 0.08382477f, 0.12349749f, 0.05316902f, 0.48914814f, 0.02035056f, -0.07753284f, 0.08041120f, 
    0.10651449f, -0.08361494f, -0.04024535f, -0.05432153f, 0.13418084f, 0.06988817f, 0.04182366f, 0.14199312f, 
    0.35918373f, 0.06343056f, -0.03173077f, 0.10595677f, -0.01817792f, 0.06570868f, -0.12655771f, -0.05344379f, 
    -0.11174152f, -0.00567207f, 0.15132384f, -0.06196861f, -0.23231444f, -0.05244292f, -0.03318970f, -0.05195056f, 
    -0.07908212f, 0.03041218f, 0.00583661f, 0.07171876f, -0.00014144f, -0.06142197f, 0.02674047f, -0.04722106f, 
    0.45942050f, 0.07483810f, -0.07555259f, -0.14966866f, -0.09172641f, -0.14912589f, 0.01941873f, -0.14220236f, 
    -0.06371406f, 0.02400670f, 0.08754614f, -0.07321830f, 0.05620473f, -0.07286282f, 0.05754030f, -0.09845970f, 
    -0.03406356f, 0.02756651f, 0.10464273f, 0.03818725f, 0.04483656f, -0.08629812f, 0.04367359f, 0.08132039f, 
    -0.14437176f, -0.07950509f, -0.04864842f, -0.25281185f, 0.10197292f, 0.07854898f, 0.06992402f, 0.09909505f, 
    0.06805374f, 0.10888515f, -0.11617556f, 0.03801481f, 0.06042912f, -0.24162419f, -0.09556699f, 0.05368253f, 
    -0.07033599f, 0.04538908f, -0.03576660f, 0.03511150f, 0.08340552f, -0.00817431f, 0.12669611f, -0.11678461f, 
    0.12160715f, 0.28384116f, 0.14788592f, -0.24648213f, 0.07021907f, -0.01302538f, 0.03425600f, -0.04242487f, 
    -0.08934100f, 0.00124530f, 0.03494713f, 0.11400511f, -0.06619476f, -0.01615845f, 0.08072044f, -0.00369267f, 
    0.02100903f, -0.13054809f, 0.00886362f, -0.07522911f, 0.02933468f, -0.08454496f, -0.00807441f, 0.04554387f, 
    0.22924034f, -0.01712279f, 0.12136545f, -0.20378992f, -0.02882131f, -0.02070426f, 0.07704090f, 0.17519398f, 
    0.13334355f, 0.05148320f, 0.13274626f, -0.07820590f, 0.36207220f, -0.10331050f, -0.16179509f, 0.21412562f, 
    0.08247310f, -0.06945562f, -0.04463706f, 0.05480029f, -0.02409009f, 0.00689403f, 0.01205851f, 0.12898543f, 
    0.28694874f, 0.22597258f, 0.01014694f, -0.18109117f, 0.07349064f, 0.11701337f, -0.16001521f, 0.09725934f, 
    -0.00826426f, 0.03020007f, -0.09048867f, 0.08136696f, -0.14159311f, -0.03311384f, 0.11226721f, -0.26577809f, 
    0.03976420f, -0.15424111f, 0.06101371f, 0.13423195f, 0.09915802f, 0.07055239f, 0.10647570f, 0.05811490f, 
    -0.02928645f, -0.05619938f, -0.05224491f, 0.27013281f, 0.13164079f, -0.09651409f, 0.01484039f, 0.01207078f, 
    -0.04094600f, 0.07139684f, -0.00697105f, 0.06698465f, -0.27308679f, -0.09195070f, -0.11558603f, -0.07426970f, 
    0.05366461f, -0.02143992f, -0.02325305f, 0.04349411f, 0.04604505f, -0.04135371f, -0.04403308f, 0.07810417f, 
    -0.20315586f, -0.07475740f, 0.03182773f, -0.17644644f, 0.04993582f, 0.03035757f, -0.02660567f, 0.05117308f, 
    0.01042599f, 0.10548192f, 0.06302922f, -0.07303295f, 0.18187170f, 0.15503433f, -0.00917350f, 0.00169206f, 
    -0.01866433f, 0.11726193f, 0.09286986f, 0.07848370f, 0.04872622f, -0.01475193f, 0.04180028f, 0.01741327f, 
    -0.11785749f, 0.06517303f, 0.01603715f, -0.01786803f, 0.08470522f, -0.06748456f, -0.03886949f, -0.07200145f, 
    -0.11458914f, 0.05953459f, -0.01693931f, -0.05052935f, 0.00709651f, -0.05530519f, 0.15265854f, 0.04713505f, 
    -0.11582841f, -0.04938465f, 0.16337852f, 0.04395735f, -0.08741468f, -0.04880404f, -0.14600846f, 0.01295191f, 
    0.16970193f, -0.04500656f, 0.03645815f, -0.07734642f, -0.05811885f, -0.12416358f, 0.04040828f, -0.02245387f, 
    -0.00540761f, 0.03874204f, 0.07008466f, -0.06126602f, -0.06732294f, -0.00786694f, 0.01433234f, -0.20914643f, 
    -0.02374324f, -0.08409822f, 0.07850590f, -0.14185505f, -0.01784785f, -0.08048275f, 0.12838228f, -0.02020388f, 
    -0.02645119f, -0.00780147f, -0.08114900f, -0.14696547f, -0.00374150f, 0.06846310f, 0.14439757f, -0.09491463f, 
    0.07315940f, -0.05784049f, -0.02943417f, -0.00966761f, 0.27837932f, -0.36058208f, -0.06061255f, -0.03926795f, 
    0.03573919f, 0.01139106f, -0.09038413f, -0.06798754f, -0.02216651f, -0.09055225f, 0.04602140f, 0.03143947f, 
    -0.03184136f, -0.01582471f, 0.03688875f, 0.02661657f, -0.02988925f, -0.02733093f, 0.00285249f, -0.07836752f, 
    -0.13572899f, -0.00437795f, -0.07734960f, 0.02910597f, 0.20957948f, -0.08090244f, 0.02882816f, 0.30607247f, 
    -0.13079306f, -0.01885076f, 0.00565551f, -0.02264807f, -0.09312236f, -0.02507601f, -0.00375438f, 0.04312674f, 
    0.04967246f, 0.23983815f, 0.07707329f, -0.11825974f, 0.11132640f, 0.01908064f, 0.04666090f, 0.11064881f, 
    0.03890974f, 0.03142208f, 0.08509199f, 0.02629268f, 0.64987499f, -0.14903152f, 0.06787116f, 0.17421818f, 
    -0.12873237f, -0.04001939f, -0.03778715f, -0.08384987f, -0.03820638f, 0.09343517f, 0.04618795f, -0.11230884f, 
    0.49997458f, -0.15670508f, -0.01866203f, 0.01777160f, 0.14401244f, 0.13672531f, 0.02818199f, 0.17287199f, 
    -0.00285305f, 0.03830260f, -0.00336284f, 0.03007820f, -0.18674125f, 0.05470038f, 0.19899350f, -0.15695204f, 
    0.16197254f, 0.02751086f, 0.02310990f, -0.06401999f, -0.11839826f, 0.03221692f, 0.04098935f, -0.01299472f, 
    -0.20608011f, 0.10849337f, -0.02544626f, -0.00553581f, 0.08911970f, -0.03425672f, -0.09410205f, -0.13808990f, 
    -0.03080477f, -0.05781987f, -0.10899661f, -0.07275991f, -0.23247154f, 0.00612995f, 0.15103002f, 0.26450944f, 
    -0.11606507f, -0.02616312f, -0.08441279f, 0.17405732f, 0.00514452f, -0.03400581f, -0.02110350f, 0.12448012f, 
    -0.12415218f, 0.00280209f, 0.13999574f, -0.12645686f, 0.04178179f, 0.09263480f, 0.07361782f, 0.01896967f, 
    -0.04618648f, 0.08784162f, 0.10603136f, -0.02346078f, 0.26442716f, 0.03473915f, -0.08841798f, 0.05583068f, 
    -0.04810220f, -0.07029757f, -0.02165907f, -0.02474255f, -0.06549902f, -0.03027778f, 0.04811200f, 0.07026703f, 
    -0.39343131f, 0.27255479f, 0.01791899f, 0.10198490f, 0.14838402f, 0.03155673f, -0.04130995f, 0.21112788f, 
    -0.10117750f, 0.00945364f, 0.18452622f, 0.14127474f, 0.06911877f, -0.16935824f, -0.05875594f, 0.06811956f, 
    0.16968603f, 0.04203035f, 0.12629181f, -0.07333332f, -0.12370335f, 0.06938314f, -0.16363144f, -0.08661172f, 
    0.27869910f, -0.04288990f, -0.09825757f, 0.12778620f, 0.23090695f, 0.09175081f, -0.14204134f, -0.06778932f, 
    -0.03724626f, 0.11208838f, 0.00352683f, 0.08813021f, -0.06452093f, 0.07624445f, 0.18418452f, 0.09432517f, 
    -0.10673779f, 0.05816310f, 0.03556605f, -0.00288316f, 0.03346717f, 0.18879481f, 0.04899035f, 0.28237915f, 
    0.28932062f, -0.08277777f, -0.08673792f, 0.10758347f, -0.06316327f, -0.05471566f, 0.09588012f, -0.22042386f, 
    -0.05851587f, 0.08535411f, 0.16306987f, 0.09515192f, -0.18624642f, 0.36000824f, -0.19056997f, -0.08154298f, 
    0.02173832f, 0.06878644f, 0.05247288f, -0.02011355f, 0.17523418f, 0.10872677f, 0.02455769f, -0.04359074f, 
    -0.49397856f, -0.43228841f, 0.19297560f, 0.08919426f, 0.05769705f, 0.10609062f, 0.12088439f, -0.08528452f, 
    0.17929706f, 0.02405802f, 0.12102065f, 0.05611226f, -0.08644044f, -0.24894919f, -0.02627367f, -0.07451810f, 
    -0.05169311f, 0.13829428f, 0.14499733f, 0.20975026f, -0.09162374f, 0.01707267f, -0.09068607f, -0.04471392f, 
    -0.29791060f, -0.09877153f, -0.23408888f, 0.05698026f, 0.01535253f, -0.08797257f, -0.00607920f, 0.13186018f, 
    0.01214140f, -0.08570024f, -0.09799184f, -0.11732975f, -0.03558876f, -0.13039149f, -0.03853160f, -0.09454708f, 
    0.01855287f, 0.09007433f, -0.12861978f, 0.13244700f, 0.00083662f, 0.04783932f, 0.05334930f, 0.05344021f, 
    0.18791157f, -0.27086705f, 0.02091245f, 0.23276854f, -0.19252238f, -0.12613896f, 0.09028506f, -0.02244779f, 
    0.07801364f, -0.06354408f, 0.02974915f, -0.11866791f, -0.35275382f, -0.28730518f, 0.07194232f, 0.10538062f, 
    0.07021417f, 0.05505750f, 0.06380432f, 0.01020642f, 0.11107277f, 0.03576910f, 0.14378229f, 0.00520781f, 
    -0.12792841f, -0.05392844f, 0.03707137f, 0.06104623f, 0.17180164f, -0.09304162f, 0.01073893f, -0.09838735f, 
    0.07174086f, 0.04125379f, -0.02640793f, 0.12592129f, -0.11929757f, -0.12465385f, -0.11222208f, 0.05506776f, 
    -0.02192490f, 0.26658687f, 0.06157387f, 0.01955981f, 0.05366256f, -0.08486740f, 0.08217628f, 0.19191264f, 
    0.10794647f, -0.06822258f, -0.07194165f, -0.01560694f, 0.04999354f, -0.05124301f, 0.14636377f, 0.05443662f, 
    -0.05852696f, 0.09784075f, 0.12364031f, -0.02140536f, 0.28678450f, -0.30245703f, -0.10981327f, 0.11218151f, 
    -0.02598512f, -0.00097426f, 0.17847861f, 0.01785096f, 0.08578538f, -0.07869656f, -0.01965768f, -0.03919570f, 
    -0.05335695f, -0.07199398f, 0.00744001f, 0.03861194f, 0.06074385f, -0.06840610f, -0.05298825f, -0.08183073f, 
    -0.07282563f, 0.00007515f, -0.02008867f, -0.07549275f, -0.05202500f, -0.05873600f, -0.04608821f, -0.04560288f, 
    0.01969138f, 0.03738132f, 0.00542741f, -0.01155475f, -0.06314567f, 0.00789132f, -0.04841817f, -0.03664261f, 
    0.04721844f, -0.05115133f, 0.05049305f, 0.03282570f, -0.00977811f, 0.02025606f, 0.02012252f, 0.00642922f, 
    -0.04310910f, -0.07295732f, -0.01129085f, -0.01006466f, 0.02197751f, 0.01662027f, -0.05609001f, -0.06099025f, 
    0.03850382f, 0.03051053f, 0.05370972f, -0.00476037f, 0.02813536f, -0.02029973f, -0.02340849f, 0.02450078f, 
    -0.02626562f, -0.05493769f, -0.08147316f, -0.02536370f, 0.03249073f, 0.03421567f, -0.04615136f, 0.03427653f, 
    -0.00030248f, 0.00048791f, 0.04953193f, -0.06912700f, -0.00380311f, 0.00028422f, -0.00891376f, -0.04891054f, 
    0.01547789f, -0.06152037f, -0.07126560f, -0.02566529f, 0.02285306f, -0.05259241f, 0.05725743f, 0.04670601f, 
    -0.00478607f, 0.00771063f, -0.02625258f, -0.04194788f, 0.06278984f, -0.01318141f, 0.04361422f, 0.05098866f, 
    -0.02640664f, -0.01887625f, -0.04797287f, 0.02713390f, 0.04217605f, -0.00090372f, -0.02934408f, 0.01874710f, 
    -0.01904642f, -0.02311763f, -0.02131456f, -0.05886088f, -0.02857882f, -0.02930322f, -0.07587123f, 0.01579325f, 
    -0.04548071f, 0.00659058f, -0.01354407f, 0.00344462f, 0.06126598f, 0.01645359f, -0.02069964f, 0.02624954f, 
    -0.02711144f, 0.05222612f, 0.01984040f, 0.02218256f, -0.02335702f, 0.03276976f, 0.06196523f, 0.04440353f, 
    -0.01948875f, 0.02950044f, -0.01618313f, 0.03968433f, 0.01691698f, 0.02630214f, -0.06661075f, 0.05573449f, 
    0.05120119f, -0.08019604f, -0.06996040f, 0.02989279f, 0.05982316f, -0.08260604f, -0.02917511f, -0.04034257f, 
    -0.04392844f, 0.06000606f, 0.04788827f, 0.00068010f, 0.03356700f, -0.01549636f, -0.03022016f, -0.01855594f, 
    -0.04654646f, -0.02700249f, -0.05147358f, -0.03345550f, 0.02869661f, 0.00149607f, -0.01743062f, -0.06074858f, 
    0.04923472f, -0.04147820f, -0.00783194f, -0.06961142f, 0.04111820f, 0.02280320f, 0.01724021f, -0.01701544f, 
    0.03098758f, 0.02213439f, -0.04426211f, -0.03401976f, 0.04574116f, 0.00457049f, -0.02858719f, 0.02348691f, 
    -0.08198051f, 0.03246732f, -0.04255357f, 0.00915064f, -0.06631805f, -0.07652679f, 0.00150410f, -0.03363219f, 
    -0.05470748f, -0.01375547f, 0.05446246f, -0.01494872f, -0.01712703f, 0.06590571f, 0.03995076f, -0.07479604f, 
    -0.02643196f, 0.02972186f, 0.03817529f, -0.06617164f, 0.04125987f, -0.05840297f, -0.02217974f, -0.05593504f, 
    0.06286025f, -0.07628543f, -0.07546367f, 0.02553163f, -0.07088025f, 0.05829860f, -0.02895808f, 0.03780519f, 
    -0.00447407f, -0.04223695f, 0.01592860f, 0.00309899f, -0.06479366f, 0.01354330f, -0.01849851f, 0.05453412f, 
    -0.03923494f, -0.08154781f, 0.04650455f, -0.04073124f, 0.04069273f, 0.03896749f, -0.07405783f, -0.01864209f, 
    -0.07229502f, 0.00623550f, 0.01795655f, 0.01136055f, -0.05747010f, -0.01555944f, -0.04038838f, -0.08099284f, 
    -0.06497494f, -0.06624188f, -0.04122821f, 0.01031984f, 0.04090917f, -0.01983144f, -0.03868179f, -0.00358850f, 
    -0.04191706f, -0.03559289f, 0.02708931f, -0.04965338f, -0.06107805f, 0.02311872f, 0.03826518f, -0.00255213f, 
    0.04216839f, 0.02419023f, -0.02494370f, -0.00671825f, 0.03997734f, -0.00191452f, -0.01028439f, -0.02155991f, 
    -0.04050617f, -0.02191316f, -0.06043747f, 0.00544324f, 0.02567740f, -0.05986788f, 0.00475763f, -0.07339776f, 
    -0.06709671f, -0.02790985f, -0.00519902f, -0.03651882f, -0.07449033f, 0.06338108f, -0.08263306f, -0.01636116f, 
    -0.07321443f, 0.06484777f, -0.07129540f, -0.00945970f, -0.07370630f, 0.01472302f, 0.00039955f, 0.01719352f, 
    -0.01608023f, -0.00315759f, -0.04658504f, 0.03477922f, -0.07784922f, -0.07092078f, 0.05141833f, 0.02489428f, 
    0.00437147f, -0.07798276f, -0.02907575f, 0.06408155f, 0.05088608f, -0.00643855f, -0.00287001f, 0.05301643f, 
    -0.06165192f, -0.02443892f, -0.00477602f, 0.05216964f, 0.04450334f, -0.07785729f, -0.01107185f, 0.01721150f, 
    -0.07486874f, 0.04243818f, -0.06446300f, 0.00703233f, 0.06016912f, -0.07424712f, -0.05676701f, -0.00112876f, 
    0.03788076f, -0.06078132f, -0.05972306f, 0.02153759f, -0.02214229f, -0.08207132f, -0.01396793f, 0.02063011f, 
    0.05219050f, 0.00404092f, 0.03167924f, 0.00006204f, -0.04494812f, -0.06934004f, 0.04415060f, -0.07247337f, 
    0.00569830f, 0.04143531f, 0.00931788f, 0.01763986f, -0.05450725f, -0.00319211f, 0.03550335f, -0.02848295f, 
    -0.01109646f, -0.04940607f, 0.05589082f, -0.08118018f, 0.00358126f, 0.04096655f, -0.05366785f, 0.00781528f, 
    -0.03195754f, 0.02920957f, -0.04183946f, -0.04287335f, 0.02900702f, 0.04020086f, -0.00948777f, 0.04601295f, 
    -0.04174071f, -0.07187536f, -0.07953341f, -0.04710982f, 0.04415873f, -0.04976647f, 0.02418215f, -0.01007572f, 
    -0.04153325f, -0.06915695f, -0.04673579f, 0.03140942f, -0.04870952f, 0.00889323f, 0.05339462f, -0.05250781f, 
    -0.05204386f, -0.02713260f, 0.03716284f, -0.07424191f, 0.05880317f, 0.05733268f, 0.00787022f, -0.06501296f, 
    -0.06598802f, 0.02159024f, -0.05757000f, 0.04642799f, 0.05639737f, -0.01418253f, 0.02779889f, 0.02169836f, 
    0.05807355f, 0.01001570f, 0.02279420f, -0.00518861f, 0.01845554f, 0.02730343f, -0.00360028f, -0.06533109f, 
    -0.02295156f, 0.01233404f, -0.07368063f, -0.03530875f, -0.06920791f, 0.04722044f, 0.00342339f, -0.02090080f, 
    0.48554879f, -0.03085134f, -0.08342627f, 0.14323255f, -0.09069563f, -0.00936263f, 0.02176981f, -0.00764167f, 
    0.11401492f, 0.08142077f, -0.09441993f, 0.03827640f, -0.09422778f, 0.00979085f, -0.01153126f, 0.14715466f, 
    0.01612429f, 0.01960315f, 0.08101723f, 0.14682221f, 0.01373553f, 0.06275854f, 0.06705941f, 0.23514712f, 
    0.09728582f, -0.05365925f, -0.05859092f, -0.01137086f, 0.07631788f, 0.15705165f, 0.00370751f, -0.03960910f, 
    0.12485727f, 0.00900495f, -0.09526616f, 0.09318847f, 0.15163986f, -0.03221049f, 0.33598769f, 0.13736489f, 
    0.27417347f, 0.04113841f, 0.15513927f, 0.06666743f, 0.23208991f, -0.06021222f, -0.05930326f, 0.10898653f, 
    0.03690956f, -0.00333415f, -0.00051377f, -0.14067116f, -0.02940595f, -0.07989612f, 0.01636791f, 0.16234313f, 
    -0.05371290f, 0.09356640f, 0.10082211f, -0.14615549f, -0.18634060f, 0.06488851f, -0.04514963f, 0.08889043f, 
    -0.04960901f, -0.03827737f, -0.10049062f, 0.05089710f, -0.04311590f, 0.05581591f, 0.05022210f, 0.08243134f, 
    0.41868109f, 0.17347229f, 0.07003015f, -0.11599668f, 0.06221705f, 0.19458717f, -0.02565244f, 0.01465003f, 
    -0.00561549f, 0.05729871f, -0.16331406f, 0.00012087f, -0.24234615f, 0.07839938f, 0.12314694f, 0.02624181f, 
    0.09076636f, -0.11097602f, 0.12887537f, -0.07960571f, 0.07007515f, 0.00875136f, 0.00734166f, 0.03607071f, 
    -0.10992086f, -0.22820000f, 0.03296094f, -0.13925995f, -0.06901998f, 0.01370083f, 0.03542940f, -0.11065819f, 
    0.18342748f, -0.02402489f, 0.14696547f, -0.02823643f, -0.73706710f, 0.23844463f, -0.08391709f, 0.11284011f, 
    0.15306327f, -0.01966405f, 0.06441487f, 0.02456677f, 0.06258754f, 0.03570566f, 0.03577313f, 0.08429178f, 
    -0.12489840f, 0.13118847f, -0.19847116f, -0.17057025f, -0.00007536f, -0.01974166f, -0.07635137f, 0.13642339f, 
    -0.05488639f, 0.16391897f, 0.07801264f, -0.00532641f, 0.18336575f, 0.24702014f, 0.09663417f, 0.16226617f, 
    -0.01845284f, 0.14278311f, 0.04255666f, 0.15095925f, 0.13893652f, 0.04017678f, -0.00306569f, -0.00635590f, 
    0.02696078f, -0.08849759f, -0.07117686f, 0.13133585f, -0.00360476f, -0.01075725f, 0.00968820f, 0.08972558f, 
    0.07628424f, 0.05521522f, 0.04907224f, 0.06881752f, 0.15616819f, -0.14324440f, 0.02412719f, -0.25708312f, 
    -0.02468450f, -0.04100756f, 0.06150363f, -0.00850258f, 0.10015434f, 0.06032900f, 0.06949320f, -0.04625776f, 
    0.07238159f, -0.00693278f, -0.02278043f, -0.00021593f, -0.08178589f, 0.03136966f, 0.08486357f, -0.05695650f, 
    0.08770645f, 0.02569639f, 0.05487165f, 0.14766131f, -0.26996604f, -0.00721519f, -0.14225021f, 0.15105183f, 
    0.05110748f, 0.19930826f, -0.04455785f, -0.03291067f, 0.04986680f, 0.04944162f, 0.10157670f, -0.03231946f, 
    0.00527227f, -0.00919249f, -0.03490752f, -0.00397911f, 0.03909415f, 0.02866008f, 0.05619750f, -0.07185962f, 
    -0.00670352f, -0.07183248f, -0.06514832f, 0.02869423f, -0.02480019f, 0.02429022f, -0.02163043f, -0.04237907f, 
    0.03741122f, 0.02437715f, 0.03972355f, 0.00995410f, 0.01257811f, -0.06490993f, -0.03930941f, -0.07914842f, 
    0.03462273f, -0.01047617f, 0.01689052f, 0.00070159f, -0.04454244f, -0.07447017f, 0.01462448f, 0.00040911f, 
    -0.01013191f, 0.00227634f, -0.06259838f, 0.05376869f, 0.04866400f, 0.02129097f, -0.03844989f, -0.00923386f, 
    0.02895776f, 0.03612009f, -0.07928566f, -0.02264189f, -0.08030267f, 0.00883436f, -0.04227714f, -0.03625068f, 
    -0.07033110f, 0.00167979f, -0.04029482f, 0.04427611f, 0.04330486f, -0.06558926f, -0.05114539f, -0.07262775f, 
    -0.06999622f, -0.06390421f, -0.04856485f, -0.08772291f, 0.03053337f, -0.03790757f, 0.06423809f, -0.06329449f, 
    0.01039089f, -0.02695213f, -0.05522374f, 0.05916817f, 0.00005587f, -0.04773343f, 0.00227305f, -0.01084930f, 
    -0.02149102f, -0.03390408f, -0.00882543f, 0.01281302f, -0.00751249f, -0.03181947f, -0.02982442f, -0.07085546f, 
    -0.07867729f, -0.00153435f, 0.00370910f, -0.03477297f, -0.03118375f, -0.06823510f, -0.03625071f, 0.01070966f, 
    -0.01930143f, 0.00708261f, -0.08536352f, 0.05226146f, 0.04704310f, -0.06626520f, 0.01880334f, -0.04219228f, 
    0.01160188f, 0.00662126f, 0.06030207f, 0.03219889f, -0.03425299f, 0.04756593f, -0.04143596f, 0.00265080f, 
    0.00078170f, 0.05324134f, -0.08588617f, -0.05644544f, -0.07270945f, 0.03600915f, -0.06979537f, 0.00770861f, 
    -0.07330316f, -0.08255412f, -0.00393782f, 0.03247694f, -0.06773692f, 0.03198749f, 0.00068246f, -0.03816487f, 
    0.04707567f, -0.03142705f, 0.00460672f, 0.02430263f, 0.03544894f, 0.01661537f, 0.04397104f, 0.00603339f, 
    -0.02381387f, 0.02528322f, -0.04265874f, -0.05451952f, 0.04633225f, 0.03134535f, 0.00032229f, -0.04572647f, 
    -0.00402189f, 0.02279383f, -0.06276307f, 0.03729974f, -0.02155439f, 0.01786957f, -0.04123599f, 0.02861740f, 
    0.04068423f, -0.00424835f, 0.06124225f, -0.03126842f, 0.04742203f, -0.05419939f, -0.09020897f, -0.00407531f, 
    0.02205124f, -0.03415884f, -0.04217844f, 0.03577059f, -0.06914177f, -0.04768728f, -0.05542389f, 0.04308735f, 
    -0.01172224f, 0.03947929f, -0.03275711f, -0.00938341f, -0.00099664f, -0.03100581f, -0.04907129f, -0.05265091f, 
    -0.08451367f, -0.05808952f, -0.03808734f, -0.07597326f, -0.01479708f, -0.04177463f, 0.00063909f, 0.06446725f, 
    -0.08478630f, -0.08507978f, -0.08783224f, -0.05687935f, -0.03442261f, -0.03529860f, -0.06032248f, -0.02509266f, 
    0.00129534f, 0.00893836f, -0.07137611f, 0.00416101f, -0.05326768f, -0.01302749f, -0.01717694f, -0.03465673f, 
    0.19921033f, -0.08243263f, 0.05871184f, 0.02954426f, 0.05509973f, 0.05199066f, -0.03874146f, 0.11184927f, 
    0.03047531f, 0.22455432f, -0.10236360f, 0.03506418f, -0.15923567f, 0.06583729f, 0.10535806f, 0.26463100f, 
    -0.04837493f, 0.07636998f, -0.02392837f, -0.08571769f, 0.05370516f, 0.04686742f, -0.00958446f, 0.01884466f, 
    -0.07951469f, -0.18147224f, 0.18735744f, 0.02022829f, 0.04347482f, 0.19355965f, 0.22940035f, 0.07827143f, 
    0.14569700f, 0.02527494f, 0.05032251f, -0.04763032f, 0.04193604f, 0.07691740f, 0.41525853f, 0.02049856f, 
    -0.13207188f, -0.03600415f, -0.09824350f, -0.13650291f, 0.14021981f, -0.04056871f, 0.07083260f, -0.02291394f, 
    0.04520972f, -0.14007419f, -0.10150870f, 0.00491692f, -0.06029295f, -0.09823185f, -0.03593281f, 0.11065060f, 
    -0.04801277f, -0.01132884f, 0.16244182f, -0.09306438f, 0.32834405f, -0.41287541f, 0.07458812f, -0.13309230f, 
    0.01522690f, -0.06637832f, 0.13688923f, 0.10323268f, -0.16289645f, -0.00479622f, 0.01157908f, 0.08932284f, 
    0.11614402f, 0.10416608f, 0.35403317f, -0.22217248f, -0.06695297f, -0.01111395f, -0.01244156f, 0.01892248f, 
    -0.09423286f, -0.04246292f, -0.06279075f, 0.02470284f, -0.34800565f, -0.11215310f, 0.13419721f, 0.03852485f, 
    0.11720294f, -0.00470778f, 0.11574930f, -0.10211301f, -0.04926786f, -0.02524053f, 0.16554812f, -0.03695090f, 
    -0.41409892f, -0.20064805f, 0.22027326f, 0.10616463f, 0.14051642f, -0.02371236f, 0.03712208f, -0.04057010f, 
    0.16639461f, -0.00974640f, -0.01721246f, -0.02777886f, -0.36598641f, 0.15253709f, -0.15688513f, 0.04284815f, 
    0.11546483f, 0.02778163f, 0.07980394f, -0.01985403f, 0.01465828f, 0.01800661f, -0.03220646f, -0.05575282f, 
    0.01033969f, -0.04972986f, -0.12410343f, -0.04184999f, 0.06207454f, 0.07767107f, 0.02812715f, 0.22606403f, 
    -0.04713980f, 0.07309040f, 0.10709981f, -0.02162754f, 0.03579387f, 0.00805906f, 0.09730611f, 0.04074325f, 
    0.07669976f, 0.05316445f, 0.08348916f, 0.03793943f, -0.07391994f, 0.11211944f, -0.12126977f, -0.05854319f, 
    -0.13554659f, 0.21303783f, -0.15093030f, -0.25836924f, -0.10100093f, -0.08194901f, 0.10747219f, 0.16353194f, 
    0.19851932f, 0.05933772f, -0.14819288f, 0.04998387f, 0.02834574f, -0.01756877f, -0.07756553f, 0.19479264f, 
    0.06848505f, -0.04400642f, 0.03350873f, 0.04327150f, -0.05051403f, -0.10195883f, -0.00873154f, -0.08270021f, 
    0.08255713f, -0.40156007f, -0.10155301f, 0.09053844f, -0.08644032f, 0.10564565f, 0.09736661f, -0.03152320f, 
    0.02938814f, 0.10685061f, -0.16471292f, 0.22890250f, 0.02255492f, 0.09890873f, -0.07792871f, 0.08662888f, 
    -0.10640767f, -0.02497358f, 0.00049370f, 0.09008679f, 0.01757864f, 0.10472392f, 0.08379878f, 0.03506998f, 
    -0.19072996f, -0.22056706f, 0.05114100f, 0.07125881f, -0.09216083f, -0.02628701f, 0.15582527f, 0.12251488f, 
    -0.06037489f, 0.06342455f, -0.04046197f, 0.10377329f, -0.35208529f, -0.10841557f, 0.11160704f, 0.06943454f, 
    -0.08537959f, -0.15118296f, 0.07537503f, 0.09394290f, -0.02705172f, -0.00659776f, -0.13235295f, -0.00586914f, 
    0.24545792f, 0.28481689f, 0.04607625f, 0.13794477f, -0.04729727f, -0.03309605f, -0.06634513f, 0.00708647f, 
    0.06970888f, 0.11148413f, -0.07167231f, 0.01060000f, 0.09918292f, 0.02363825f, 0.02739901f, -0.17462659f, 
    0.05336754f, -0.01673181f, 0.02824710f, 0.11244234f, -0.08757573f, -0.00259239f, 0.03875109f, 0.08163761f, 
    0.02990850f, -0.06597088f, -0.06992443f, 0.02512762f, 0.02303661f, 0.08014710f, 0.15809812f, -0.02750692f, 
    0.14861870f, -0.00859840f, -0.10720836f, 0.03662148f, -0.34559304f, -0.20538673f, -0.28066370f, -0.01878447f, 
    0.03396037f, 0.13409682f, 0.06095113f, -0.07895534f, 0.02872746f, -0.00230728f, 0.12937191f, -0.06169031f, 
    0.24532202f, 0.24583468f, 0.19995406f, -0.00370759f, 0.02642870f, 0.03972151f, 0.05071885f, 0.07208370f, 
    -0.04682750f, -0.13506839f, 0.00265302f, 0.01973843f, 0.09600994f, -0.14637068f, 0.03651237f, 0.03216195f, 
    0.17469484f, 0.08158589f, 0.00010665f, -0.04093713f, -0.00313640f, -0.10556528f, -0.14258842f, -0.06629924f, 
    0.07496314f, -0.20900896f, -0.28094530f, 0.03443630f, -0.03880928f, 0.02285806f, -0.04319894f, 0.02036642f, 
    -0.01204543f, 0.14183520f, -0.08758643f, -0.03415123f, 0.22684069f, -0.11424693f, -0.02332093f, 0.13604550f, 
    0.02339544f, 0.05200570f, 0.01105762f, 0.07020675f, -0.01239087f, -0.05856941f, 0.08570659f, 0.01489738f, 
    0.19644178f, -0.29317692f, -0.08468734f, -0.05984133f, 0.08676456f, -0.01515594f, -0.10905766f, 0.00612318f, 
    0.23075077f, 0.06197180f, -0.03291051f, -0.08654319f, 0.17834070f, -0.05425756f, -0.11882072f, 0.01480274f, 
    0.17525890f, 0.08344194f, 0.00021077f, 0.01172297f, 0.18381639f, -0.07598595f, 0.03348728f, -0.11834337f, 
    0.06009210f, 0.13902307f, 0.02083389f, -0.20327315f, 0.02650888f, 0.00018790f, -0.00389027f, -0.01358504f, 
    -0.03287686f, 0.06618984f, 0.02106632f, -0.05543978f, -0.04767183f, 0.08461942f, 0.06965622f, 0.00762835f, 
    -0.02278708f, 0.01564936f, 0.05935912f, 0.07497808f, -0.02685222f, -0.01513925f, 0.09018265f, -0.06839762f, 
    0.05386589f, -0.03501087f, -0.06046820f, -0.11053758f, 0.00574999f, 0.02489646f, 0.04881508f, -0.03965981f, 
    0.01321485f, 0.07748671f, 0.05404789f, 0.00296262f, -0.06773785f, 0.05707432f, 0.06187755f, 0.00057941f, 
    0.01405386f, 0.00330901f, 0.17515095f, 0.11139181f, 0.17963047f, -0.00302571f, -0.03667809f, 0.13184039f, 
    0.15747084f, -0.03752295f, -0.05829062f, -0.00256291f, 0.06057872f, 0.03188524f, -0.07272194f, 0.10581699f, 
    0.05120697f, 0.10173500f, -0.18534337f, -0.06735390f, 0.25245020f, 0.04222548f, -0.09831188f, 0.05412306f, 
    -0.04059589f, 0.20257121f, 0.10191678f, 0.06687784f, 0.05954957f, -0.01831125f, -0.02796744f, 0.04813914f, 
    -0.31763366f, -0.21467914f, 0.06808773f, -0.02951694f, -0.04697767f, 0.05498664f, 0.13248855f, 0.13198356f, 
    0.08866185f, -0.07187665f, 0.11581860f, 0.08852762f, 0.03485946f, -0.08767676f, 0.01753259f, -0.00718998f, 
    0.03736111f, 0.06048319f, -0.15318075f, -0.02182826f, 0.06274894f, 0.00190067f, 0.01393991f, -0.17140909f, 
    0.11945865f, -0.09840091f, -0.16657518f, 0.06759603f, -0.00250023f, -0.09759975f, 0.04705313f, 0.14288683f, 
    0.15062653f, 0.06045497f, 0.11825000f, -0.24252541f, 0.48544163f, -0.09388430f, 0.01656667f, -0.16386035f, 
    0.05113962f, -0.04184108f, -0.04017071f, 0.12230792f, -0.11067524f, 0.05412142f, -0.01403928f, 0.13843402f, 
    0.01209656f, -0.12181070f, -0.10294547f, -0.08182012f, 0.00118816f, 0.04407019f, 0.05155675f, -0.08806583f, 
    -0.08216263f, 0.06161933f, -0.03350529f, 0.00674410f, -0.03638552f, 0.09669538f, 0.14222479f, 0.16897094f, 
    -0.04442950f, 0.08132786f, -0.04296229f, 0.11953112f, -0.07422312f, 0.13154089f, 0.14421074f, 0.09360051f, 
    0.05888072f, 0.10058776f, 0.28937870f, 0.14852080f, 0.07333252f, 0.13436295f, 0.03259071f, 0.02501617f, 
    0.03621618f, -0.09028636f, 0.01152512f, 0.03186386f, 0.00414910f, 0.01862650f, -0.04456130f, 0.02604488f, 
    0.08204306f, -0.01281723f, 0.06488532f, -0.05977067f, -0.09289583f, 0.03663954f, -0.10240588f, 0.00742827f, 
    -0.06709957f, 0.14999457f, 0.07107433f, 0.15347606f, 0.03374569f, -0.01512070f, 0.09546509f, 0.17672560f, 
    -0.14488450f, 0.17554823f, 0.10164353f, 0.03130040f, -0.07457882f, 0.02345549f, 0.00032254f, 0.10759395f, 
    0.10358314f, -0.04343728f, 0.00930069f, 0.01905699f, -0.23783858f, -0.00248271f, -0.10941011f, 0.04822932f, 
    -0.13790965f, 0.09873315f, -0.28081843f, -0.09555718f, 0.07528719f, -0.00793957f, -0.00511769f, -0.00888888f, 
    -0.04662038f, -0.10729907f, 0.06212066f, -0.13408454f, 0.12290630f, 0.04445298f, -0.04547278f, 0.24317026f, 
    -0.10900445f, -0.20110106f, 0.02419178f, 0.03791721f, -0.03336402f, 0.09282843f, -0.08489165f, 0.05884722f, 
    0.07343465f, 0.00785315f, 0.13468854f, 0.04596010f, -0.13119885f, 0.02621873f, -0.08870818f, 0.01449381f, 
    0.13159177f, -0.04828756f, -0.05456825f, 0.09145807f, -0.04412893f, -0.04109394f, -0.11024191f, 0.02006911f, 
    -0.00520352f, 0.00474602f, 0.00532223f, -0.09563980f, -0.03667527f, 0.03184961f, 0.08986994f, 0.10562466f, 
    -0.04374836f, 0.25495085f, 0.00485809f, 0.04247750f, -0.00786367f, 0.04645567f, -0.08956260f, -0.03820584f, 
    0.11178658f, -0.09353393f, 0.31662211f, 0.02185814f, 0.36647752f, -0.14243138f, -0.01131690f, -0.01729510f, 
    0.12033685f, 0.01131571f, -0.01934161f, -0.05444218f, -0.07210478f, 0.04783319f, 0.06331512f, 0.02755635f, 
    0.21134435f, -0.09227213f, -0.10431004f, -0.04388837f, -0.04962346f, -0.07008738f, -0.05716768f, -0.00977433f, 
    -0.06598634f, 0.05180004f, -0.05259276f, 0.11874326f, -0.25608012f, -0.09246767f, -0.02404484f, 0.09944756f, 
    -0.08020096f, 0.05079553f, 0.05609282f, -0.05625886f, -0.01714480f, 0.03976541f, 0.04621470f, 0.06458046f, 
    -0.11295621f, 0.03867166f, 0.04506391f, -0.08897261f, 0.02725861f, 0.03578153f, -0.03501226f, -0.08233408f, 
    0.00491922f, 0.00622562f, 0.02282024f, -0.00201210f, 0.42295930f, 0.07206207f, 0.15386119f, 0.10235538f, 
    -0.00341864f, -0.06830400f, -0.01040892f, -0.08508027f, 0.03587212f, -0.01010409f, -0.12926732f, -0.02769014f, 
    -0.34450111f, -0.16072591f, -0.16796021f, -0.08980031f, -0.05218812f, -0.07274149f, -0.02305077f, -0.04290585f, 
    0.06028129f, 0.07996275f, 0.05789360f, -0.02089562f, 0.07836457f, 0.07419094f, -0.14866884f, 0.06340051f, 
    -0.08993890f, 0.12339904f, 0.02341506f, 0.17644724f, -0.17949152f, 0.12172443f, 0.09121270f, 0.09925374f, 
    0.07261650f, 0.35436019f, 0.16584742f, -0.11431063f, 0.15071297f, -0.01603216f, -0.02200717f, 0.14137411f, 
    -0.05830559f, 0.05101864f, 0.11283225f, 0.18066680f, 0.06814540f, -0.07855815f, 0.05403126f, 0.00327638f, 
    -0.04475511f, -0.09498769f, -0.05306488f, 0.10084829f, 0.01219423f, 0.08629449f, -0.04204928f, 0.09081385f, 
    -0.02590142f, 0.22997950f, 0.27832383f, -0.00043461f, 0.07512487f, 0.03539711f, 0.07662927f, 0.03215890f, 
    -0.01279250f, -0.04551091f, -0.01056535f, 0.08601279f, -0.08873112f, 0.01174191f, 0.08877219f, -0.15230855f, 
    -0.18822207f, -0.01298558f, -0.09631680f, -0.02750944f, 0.02337520f, -0.05448579f, 0.09490830f, -0.01179550f, 
    0.29296744f, 0.07189864f, 0.15062155f, 0.46425962f, -0.10728044f, -0.04894616f, -0.08451281f, 0.08182731f, 
    0.01089930f, 0.11109999f, 0.04865253f, 0.00433695f, 0.01752575f, -0.03184605f, -0.01439056f, -0.10203498f, 
    0.02345565f, 0.19409958f, -0.09832812f, 0.10377567f, 0.04995142f, -0.01106598f, -0.11956359f, 0.10007534f, 
    -0.06613731f, 0.03405004f, 0.12963463f, -0.03901910f, 0.05053595f, -0.04569215f, 0.02570338f, 0.06172574f, 
    -0.16073585f, -0.03564961f, 0.11192656f, -0.10381225f, 0.38302252f, -0.12032535f, 0.15242377f, 0.18758065f, 
    -0.10183204f, 0.02180962f, -0.04201759f, -0.06790050f, -0.04169391f, 0.01002014f, -0.13004814f, -0.03227169f, 
    0.01410229f, -0.03808961f, -0.04158647f, -0.06379353f, 0.00231120f, 0.01150742f, 0.05400102f, -0.05814298f, 
    -0.02305185f, -0.03346056f, -0.06089370f, 0.05985910f, -0.03525525f, 0.01684923f, -0.03186694f, -0.01770176f, 
    0.06007490f, -0.04498566f, -0.06646183f, -0.04940415f, -0.05906367f, -0.02090887f, -0.07701311f, 0.02486613f, 
    -0.01340075f, -0.01437348f, 0.01375311f, 0.02621442f, -0.03428044f, 0.06286112f, 0.02749679f, -0.00117868f, 
    -0.04068591f, 0.03999114f, 0.05975382f, -0.07563011f, 0.00800660f, -0.02676892f, -0.06164258f, 0.00006645f, 
    0.05399381f, 0.00029213f, 0.04224807f, -0.02549363f, -0.03924521f, -0.01749304f, -0.06331532f, 0.06257424f, 
    -0.06861597f, -0.02146233f, -0.03071319f, -0.03125068f, -0.06907923f, -0.02926694f, -0.01816330f, 0.04025987f, 
    0.00041779f, 0.04918440f, 0.02002825f, 0.04079819f, 0.00716509f, 0.05310633f, 0.00186227f, 0.05142850f, 
    -0.04193166f, 0.04991070f, -0.06901434f, 0.05984087f, 0.00486312f, -0.04605909f, 0.00751200f, -0.02897253f, 
    -0.04285041f, 0.04311856f, 0.02870265f, -0.04194452f, -0.06713407f, 0.00955914f, -0.00486997f, 0.03423632f, 
    -0.03241126f, 0.03501446f, -0.04931990f, -0.04275940f, -0.07458129f, 0.03344730f, 0.01023465f, -0.05334684f, 
    0.03232004f, 0.00920325f, 0.00973448f, -0.00304525f, 0.05572860f, -0.00238807f, -0.02643734f, 0.02722504f, 
    0.00833747f, -0.00306689f, 0.00467280f, 0.05869922f, -0.06319772f, -0.03577686f, 0.05098420f, -0.00638000f, 
    -0.07725985f, -0.06548909f, 0.02949323f, 0.02754193f, 0.02965056f, 0.06990338f, -0.02884806f, -0.07573133f, 
    0.02223404f, -0.04900527f, -0.04030611f, 0.06480579f, -0.02369842f, -0.05916363f, 0.03160534f, -0.07335508f, 
    -0.06496775f, -0.01019780f, 0.04342998f, 0.04185746f, 0.05850582f, -0.07132053f, -0.02049270f, -0.00525091f, 
    0.03846248f, -0.03186475f, -0.00171953f, 0.01147395f, 0.03455108f, -0.04749619f, -0.02523013f, -0.01270061f, 
    0.03257104f, -0.01668122f, -0.05804880f, 0.05740854f, -0.00011404f, -0.02734934f, 0.00249005f, -0.00461172f, 
    -0.00952435f, -0.00327363f, 0.01000898f, -0.06299090f, 0.00498927f, -0.06392560f, -0.02255174f, 0.03304043f, 
    -0.04817969f, -0.01215482f, -0.04663977f, 0.06388126f, -0.06058311f, 0.04583175f, -0.03734985f, -0.03116160f, 
    -0.00621230f, -0.00681916f, 0.00261243f, -0.03149810f, -0.04879604f, 0.03119957f, 0.00621385f, 0.00372228f, 
    -0.05799402f, 0.00749434f, -0.02958256f, -0.00944437f, -0.00713061f, 0.00029770f, 0.03853691f, -0.00866716f, 
    -0.07495143f, -0.06238112f, -0.05630286f, -0.01065868f, -0.07631893f, -0.00777582f, 0.03185845f, 0.02595728f, 
    -0.07202869f, -0.02200362f, 0.05092519f, -0.04459759f, 0.06227604f, 0.04582877f, -0.04852726f, -0.02718017f, 
    -0.05091034f, -0.13412681f, 0.01708764f, 0.02381230f, 0.05260510f, -0.02803661f, 0.04725342f, -0.11587404f, 
    -0.00628015f, 0.02135044f, -0.03291641f, 0.07142652f, -0.02281609f, 0.17407566f, 0.15742783f, 0.18630025f, 
    0.01855143f, 0.04121643f, 0.02820266f, -0.02230056f, -0.03197061f, -0.05775758f, 0.01204947f, -0.05050408f, 
    0.14685082f, 0.07071245f, 0.05072945f, 0.08907817f, 0.09397706f, 0.11448965f, 0.12246452f, -0.05131992f, 
    0.01777764f, 0.02261009f, -0.00408739f, -0.04265797f, 0.00065440f, 0.13599442f, 0.30801982f, 0.19166794f, 
    -0.07382645f, -0.00791187f, -0.00464279f, 0.00168239f, 0.09553338f, -0.11412847f, -0.05852718f, 0.10573388f, 
    0.00767455f, -0.14212947f, 0.01683070f, 0.22473992f, 0.04254790f, -0.04834702f, 0.08987787f, 0.11942291f, 
    -0.12065308f, 0.00991598f, 0.16773209f, 0.01135387f, -0.06951954f, -0.36176106f, 0.11769678f, 0.11523134f, 
    0.01291841f, -0.08481290f, 0.01177120f, 0.06367775f, -0.13945286f, -0.09612280f, 0.02609470f, 0.05829792f, 
    0.29563424f, 0.13611092f, 0.33287209f, 0.08067475f, -0.10749721f, -0.01186850f, -0.00460205f, 0.07001544f, 
    0.00978674f, -0.06579636f, 0.02635798f, -0.05876794f, -0.28235200f, 0.15673158f, 0.06375100f, 0.11473357f, 
    0.11465225f, -0.09696341f, 0.12455180f, -0.02976586f, 0.08301688f, -0.09118535f, 0.04238514f, -0.06475727f, 
    -0.52592641f, -0.23214149f, -0.03284234f, -0.02318698f, 0.11410343f, 0.07227404f, 0.06496702f, -0.07649148f, 
    0.12605374f, -0.02602790f, 0.04208942f, -0.19577329f, -0.45431834f, 0.17171058f, -0.04698539f, -0.14523232f, 
    0.13608930f, -0.02196044f, 0.00549879f, 0.00941764f, -0.01292608f, -0.01657802f, -0.03691468f, -0.03075404f, 
    0.05114942f, -0.27044839f, -0.24643731f, -0.11054356f, 0.05253473f, 0.17120485f, -0.13366464f, 0.04041048f, 
    -0.05021029f, 0.00495171f, -0.03880082f, -0.09709449f, 0.00607265f, 0.13545214f, -0.01016752f, 0.23443347f, 
    0.02923675f, 0.07501940f, 0.04302541f, 0.01888206f, -0.00212354f, 0.10547250f, -0.03751877f, 0.07340815f, 
    -0.14487302f, 0.06752715f, 0.03139419f, -0.35430235f, 0.07746994f, -0.03079517f, 0.10011934f, -0.05867916f, 
    0.11046529f, 0.00313395f, -0.05615104f, 0.26548830f, -0.07963776f, -0.03920094f, -0.04602158f, 0.31093729f, 
    0.15866812f, 0.15348369f, 0.07666249f, -0.00424022f, 0.07169777f, -0.03890604f, -0.03394944f, 0.06272693f, 
    0.08014384f, -0.12385454f, -0.09718675f, 0.12969379f, 0.03404940f, -0.03238395f, 0.00647003f, -0.20448554f, 
    -0.06033817f, 0.16700740f, 0.02331202f, 0.08054963f, -0.01085227f, -0.02904140f, -0.00985170f, -0.27157810f, 
    -0.01437258f, 0.11698765f, -0.05782748f, -0.11111965f, 0.02636979f, -0.04553488f, 0.13945058f, -0.13297914f, 
    -0.01063628f, 0.01133364f, -0.02973531f, -0.05452042f, -0.07589679f, 0.02406355f, 0.04012123f, -0.06260189f, 
    0.04105623f, -0.06161219f, 0.03923022f, -0.01081024f, -0.05267189f, -0.05469896f, -0.01116190f, -0.00894151f, 
    -0.04471918f, -0.03794700f, 0.00885954f, -0.01129797f, 0.02370588f, -0.01605663f, -0.04626924f, 0.05898916f, 
    -0.04812418f, 0.05931183f, 0.04288081f, -0.06498569f, 0.02044833f, -0.03845014f, -0.02791617f, -0.04164651f, 
    -0.02469967f, 0.04736764f, 0.03304664f, -0.07543881f, 0.02545191f, -0.05563811f, -0.01397057f, 0.02259722f, 
    -0.04888679f, 0.04123138f, -0.01887044f, 0.04711608f, -0.06330739f, -0.02793222f, -0.01613541f, -0.05812288f, 
    -0.07324070f, 0.06597089f, 0.02677209f, 0.01868116f, 0.03393319f, -0.02719747f, 0.05233376f, -0.03779536f, 
    -0.02176832f, -0.00206536f, -0.07465099f, -0.00544606f, 0.02733740f, 0.04167914f, -0.07193629f, -0.02563403f, 
    -0.07369493f, 0.02750695f, -0.01963219f, -0.05714194f, 0.03569138f, -0.02051424f, -0.02773169f, 0.03862289f, 
    -0.06041850f, -0.01705428f, -0.02782273f, 0.02953961f, 0.02569959f, 0.05062709f, -0.03403934f, 0.00628868f, 
    -0.01159064f, -0.00398449f, 0.04544894f, 0.04683148f, 0.04756353f, -0.03491046f, -0.05154299f, 0.04481636f, 
    -0.04080936f, 0.05073790f, 0.06341093f, -0.04989628f, 0.02525184f, -0.03655470f, -0.00804754f, -0.06963231f, 
    0.04536811f, -0.04176423f, 0.01296581f, 0.04439438f, -0.05510240f, 0.03604241f, -0.04269402f, -0.00647292f, 
    0.02852513f, -0.00547963f, -0.06536587f, -0.04855591f, -0.05845290f, 0.06154663f, -0.02358468f, -0.02902341f, 
    -0.00468005f, 0.05894280f, -0.02117143f, -0.01887865f, -0.01046148f, 0.00047300f, -0.03937542f, 0.06311472f, 
    0.00612389f, 0.03122851f, 0.03337805f, -0.05634493f, -0.06722442f, -0.02661042f, -0.02372337f, -0.06707416f, 
    -0.00334734f, -0.03150962f, 0.02819052f, 0.01092859f, 0.00896098f, -0.02923594f, 0.02612491f, 0.05335608f, 
    -0.01515501f, -0.03269713f, -0.01189150f, -0.03086334f, -0.05883415f, 0.05136152f, 0.03319476f, -0.07417434f, 
    0.02570618f, 0.06184175f, 0.00674158f, -0.01729557f, -0.03051941f, -0.02475640f, 0.05815438f, -0.00725151f, 
    -0.02978174f, 0.02026263f, -0.02384934f, -0.06402357f, -0.02656817f, 0.02019784f, 0.06348445f, -0.02859187f, 
    0.00490225f, -0.05925764f, -0.06893530f, -0.01942747f, 0.03994808f, 0.04241335f, -0.03065019f, -0.00605394f, 
    -0.06516911f, -0.00995938f, 0.06419098f, -0.06610385f, -0.04450252f, -0.01560181f, -0.03247782f, -0.03441182f, 
    0.02663585f, 0.03159169f, -0.05913499f, -0.00185790f, -0.04256811f, 0.01785852f, -0.06436018f, -0.03773618f, 
    0.01443982f, 0.04416949f, -0.04738642f, -0.05099798f, -0.04903042f, -0.02715010f, 0.02977425f, 0.02357320f, 
    0.20771565f, -0.23166659f, 0.13549195f, -0.04155572f, 0.07075302f, 0.00305138f, 0.02505183f, 0.21172912f, 
    0.06350689f, 0.14283155f, -0.21385914f, 0.03180322f, -0.06432094f, 0.05881989f, -0.06282161f, 0.04512341f, 
    0.10508767f, 0.08142616f, 0.10073432f, 0.05122820f, 0.21126813f, 0.06155493f, 0.15496407f, 0.05477830f, 
    -0.30854887f, 0.06741096f, 0.09858014f, 0.21314134f, 0.11982104f, 0.14575239f, 0.10275698f, 0.00742383f, 
    0.10613792f, -0.08117458f, 0.03986167f, 0.00799918f, -0.09131058f, -0.03906463f, 0.06298813f, -0.13790414f, 
    0.02877313f, -0.07413699f, -0.09784274f, 0.00900653f, 0.09987191f, -0.07383943f, 0.00821003f, 0.02016370f, 
    0.11167171f, -0.05665105f, -0.33984831f, 0.30680203f, -0.05078198f, -0.09245908f, 0.01172690f, 0.07968505f, 
    0.01621088f, -0.15365385f, 0.06906304f, -0.08394902f, 0.35946581f, -0.09913585f, -0.00134758f, 0.04399950f, 
    0.15981327f, -0.04069742f, 0.05720745f, 0.02333550f, -0.10673741f, -0.00322441f, -0.00211691f, 0.09329693f, 
    0.19046994f, -0.03803524f, 0.00111837f, -0.02408253f, 0.02345901f, 0.10221170f, -0.00062270f, -0.19376521f, 
    -0.05188842f, 0.11080319f, -0.07884897f, 0.04292009f, -0.28633928f, 0.39967656f, 0.02072931f, 0.01389261f, 
    0.13329166f, -0.04865026f, -0.11554937f, 0.03677815f, 0.15481094f, 0.04722754f, 0.11569790f, 0.09275581f, 
    -0.02675062f, -0.12328305f, 0.28543386f, 0.13966466f, 0.02570545f, 0.11543618f, -0.01285940f, -0.18811236f, 
    0.00544927f, 0.05607689f, -0.04820114f, 0.10016096f, -0.04399882f, 0.17856263f, 0.07715496f, -0.15967943f, 
    -0.00111033f, -0.00030370f, 0.04415851f, -0.13763832f, -0.09142350f, 0.03523683f, -0.02761631f, -0.06837813f, 
    -0.20507407f, -0.24415368f, 0.09776653f, 0.30194598f, -0.08946301f, -0.11699924f, -0.00358682f, 0.01335900f, 
    -0.08822062f, 0.12271109f, 0.12495935f, -0.04389455f, -0.18075955f, 0.12862109f, -0.26983652f, 0.13490058f, 
    0.13612369f, 0.10113848f, 0.01241967f, -0.03778068f, -0.12296794f, 0.05572601f, -0.06096338f, -0.03580635f, 
    -0.20943221f, 0.28191167f, -0.11173905f, -0.27266771f, 0.06862204f, -0.03558404f, 0.03896749f, -0.01319635f, 
    0.10824545f, 0.00063116f, -0.01483418f, -0.03400126f, 0.14035900f, 0.07766645f, 0.11034824f, 0.15707994f, 
    -0.05645950f, -0.17206138f, -0.01742409f, -0.08268455f, -0.08998190f, 0.01251756f, -0.02196088f, -0.02055372f, 
    -0.01299202f, -0.16608413f, -0.20465156f, 0.15005016f, -0.03997192f, 0.14068888f, -0.08250513f, -0.01095434f, 
    0.05108680f, 0.13367458f, -0.11848842f, 0.23787516f, -0.15358326f, 0.08351079f, -0.09705777f, -0.03621196f, 
    0.08198855f, -0.07502192f, -0.01833870f, 0.05839420f, 0.06123905f, 0.04639776f, 0.07444840f, 0.16370940f, 
    -0.36145937f, 0.05495721f, 0.08952155f, -0.13747923f, 0.05157797f, 0.02824295f, 0.11872624f, -0.05983361f, 
    -0.00194602f, -0.12408697f, 0.05240295f, 0.02493688f, 0.29833278f, 0.23542377f, -0.05084960f, 0.09763914f, 
    0.01803410f, 0.12037530f, -0.03472436f, -0.08766937f, -0.05694818f, 0.04587840f, 0.00612942f, 0.02020778f, 
    -0.01895058f, -0.23095377f, -0.06224790f, 0.06632940f, 0.16187797f, 0.12512720f, 0.05118686f, 0.00837142f, 
    0.07361663f, -0.01397337f, -0.03311988f, -0.04679898f, 0.20549491f, 0.02907155f, 0.04636977f, 0.31171998f, 
    -0.10273568f, 0.02822469f, -0.11006917f, 0.04422900f, 0.05944413f, 0.07306189f, -0.03682951f, 0.06683176f, 
    -0.02443758f, 0.03476463f, 0.10083029f, 0.38571638f, 0.00965638f, -0.05062522f, -0.03087304f, 0.05255044f, 
    -0.10798386f, -0.12081181f, 0.11812189f, 0.09311043f, -0.07588716f, 0.31960225f, 0.07577328f, 0.00814394f, 
    -0.12525001f, -0.08645824f, 0.03169741f, 0.12796742f, -0.03079321f, -0.02045192f, -0.07526719f, 0.07921629f, 
    -0.12828405f, -0.24845190f, -0.02454026f, 0.12565376f, -0.00691605f, -0.09950541f, 0.17385127f, -0.07240829f, 
    0.14094986f, 0.01096938f, 0.02420040f, -0.13607280f, -0.03509854f, 0.18383153f, -0.13614175f, -0.03471279f, 
    -0.00108013f, -0.06604085f, 0.11955146f, 0.05780997f, -0.01258972f, 0.10255756f, 0.00805885f, -0.10902065f, 
    -0.22528775f, -0.19447063f, 0.01908758f, 0.15666279f, -0.02306844f, -0.01458007f, -0.02562545f, 0.05785169f, 
    -0.06608526f, -0.11599622f, -0.04056105f, 0.00818441f, -0.42912984f, 0.20848258f, 0.13645835f, -0.25956082f, 
    0.01884762f, -0.06576844f, 0.04241648f, 0.01082197f, 0.00804472f, 0.02998964f, -0.12201572f, 0.04052033f, 
    -0.28553861f, 0.07335882f, -0.00518918f, 0.28456292f, -0.05053106f, -0.03865996f, 0.12629929f, -0.14458185f, 
    -0.00180827f, 0.05885927f, 0.05963183f, -0.03531317f, -0.00683218f, -0.01397473f, -0.00375353f, 0.31933022f, 
    -0.11177165f, 0.01483806f, 0.04647509f, -0.09748950f, 0.07159657f, -0.06227922f, 0.02381459f, 0.02280777f, 
    0.03671264f, -0.11416823f, 0.11232208f, 0.00543661f, 0.06959233f, 0.05214228f, 0.09209646f, 0.01295364f, 
    0.06330500f, 0.00060651f, 0.04824386f, 0.12633348f, 0.06433268f, 0.10435410f, -0.08312062f, 0.15611358f, 
    0.03184198f, 0.07562225f, 0.01205038f, -0.07519559f, 0.00126386f, 0.02542075f, 0.04652135f, 0.06822518f, 
    0.23696598f, 0.10108024f, -0.09558302f, 0.31839916f, -0.02888144f, -0.10206498f, 0.05022259f, -0.07420743f, 
    0.01780951f, -0.04292286f, -0.01780122f, 0.05498851f, 0.11187442f, -0.14278044f, -0.07801057f, -0.07754497f, 
    -0.00955154f, 0.10214870f, -0.10477683f, 0.02619071f, -0.00165263f, 0.01422391f, -0.03355683f, -0.08874078f, 
    -0.07175019f, -0.04413925f, -0.06300397f, -0.00447678f, -0.05558865f, 0.04911784f, -0.06380872f, 0.03535220f, 
    0.02827271f, -0.03552965f, -0.01321548f, -0.01787402f, -0.07606189f, 0.04429691f, -0.03488604f, 0.06291106f, 
    0.00974634f, -0.05576201f, -0.02003977f, 0.02157161f, 0.06304021f, -0.01783166f, -0.06937026f, 0.05430593f, 
    -0.01208192f, -0.00196888f, 0.05884451f, -0.04879733f, 0.04437462f, -0.02151993f, 0.02947897f, 0.00697060f, 
    -0.06094296f, 0.02042054f, 0.04849131f, -0.04980971f, -0.04669190f, -0.02646011f, 0.03691004f, -0.00658280f, 
    0.02331197f, 0.00131274f, -0.04343604f, -0.03900271f, -0.04813854f, 0.05053057f, -0.00957349f, 0.00017087f, 
    0.03041041f, -0.02671419f, 0.04118085f, -0.01960063f, 0.04148227f, -0.07745719f, -0.03558479f, 0.04321484f, 
    -0.01380144f, 0.03006720f, -0.04069156f, -0.02570049f, -0.05608197f, 0.00670488f, -0.05204875f, -0.04978852f, 
    -0.00926225f, 0.05665018f, -0.05399733f, -0.06666735f, 0.04344209f, 0.01437645f, -0.01361951f, -0.01843215f, 
    -0.00232842f, -0.03706379f, 0.03313524f, -0.05153875f, 0.01858079f, -0.02479890f, -0.05960918f, -0.04619364f, 
    -0.04317316f, 0.01349024f, 0.03128691f, 0.02149118f, -0.03490686f, 0.04774244f, 0.04023124f, -0.03471310f, 
    0.03951460f, 0.04424404f, 0.01224669f, -0.02962189f, -0.04402260f, -0.01171581f, 0.05814712f, -0.01419587f, 
    -0.04074606f, -0.07480538f, -0.02282874f, -0.01280087f, -0.06482848f, 0.04242618f, -0.01834144f, -0.00117156f, 
    0.04560039f, 0.04293558f, 0.01766036f, -0.03778578f, -0.05308124f, -0.04321678f, 0.01996987f, -0.07508950f, 
    0.03102425f, -0.05398307f, -0.05990669f, -0.00856430f, -0.02827756f, 0.06644068f, -0.03212461f, -0.01950236f, 
    0.04573431f, -0.02295812f, 0.00572277f, 0.02643485f, -0.02251067f, -0.00329565f, 0.00028212f, 0.05824035f, 
    0.04717940f, -0.05664125f, -0.04271973f, -0.00447910f, -0.06021405f, -0.01987691f, -0.03399795f, -0.05421460f, 
    -0.03238467f, 0.05403013f, -0.01720815f, 0.02955270f, 0.05990366f, -0.01854260f, -0.07748811f, -0.04679314f, 
    -0.05367595f, -0.04534554f, -0.07058203f, -0.00123402f, 0.01134073f, 0.06645224f, 0.01064360f, 0.02503744f, 
    0.05194363f, -0.04847052f, -0.03995372f, 0.00864256f, -0.06626416f, 0.04400448f, -0.06893342f, 0.06344083f, 
    0.01565658f, -0.06547816f, 0.00060064f, -0.03455173f, 0.04959657f, -0.01676271f, -0.03719514f, -0.03067474f, 
    0.01385340f, -0.02594770f, 0.01156843f, 0.03322047f, 0.05648576f, -0.03064046f, -0.00663839f, -0.00609226f, 
    -0.06733201f, 0.01881376f, 0.01886352f, -0.06263259f, 0.04872606f, -0.06589291f, -0.04275204f, 0.04122371f, 
    0.03098395f, -0.03666703f, 0.05724668f, 0.01831090f, -0.01271701f, 0.06473493f, 0.02505181f, -0.06548682f, 
    0.05617611f, 0.01751984f, 0.05165241f, -0.03179599f, 0.01524723f, -0.03239316f, -0.07724661f, -0.03986100f, 
    -0.01522417f, -0.04067504f, 0.04792415f, 0.01585822f, -0.03258709f, -0.04384589f, -0.00399965f, -0.02028778f, 
    0.04553855f, -0.00863465f, -0.04161226f, 0.04769485f, -0.05890034f, -0.00028301f, 0.02052227f, -0.00880743f, 
    -0.04612716f, -0.02964111f, -0.06397415f, -0.06122465f, 0.04689895f, -0.05051825f, 0.04745789f, -0.02318521f, 
    -0.03009319f, -0.05819064f, 0.05907458f, -0.05891496f, 0.03435846f, -0.06418841f, 0.01545046f, 0.01217928f, 
    0.03298828f, 0.05882902f, -0.02650188f, 0.04637403f, -0.01864122f, 0.05268459f, 0.03882017f, -0.03773867f, 
    -0.02575031f, -0.04810506f, -0.06092403f, -0.05360084f, 0.02663902f, -0.04683080f, 0.03147445f, -0.02314292f, 
    0.05142123f, -0.07760735f, 0.04605880f, 0.01934144f, 0.02909225f, -0.07060617f, 0.05111030f, 0.06638954f, 
    -0.00842094f, 0.02330991f, -0.02807799f, -0.04748432f, -0.01338079f, 0.00135459f, -0.07068291f, 0.00936464f, 
    0.06774316f, 0.04425932f, 0.00611645f, -0.06402878f, -0.06653438f, 0.06456912f, 0.02639965f, 0.00738730f, 
    0.00899605f, -0.04951660f, -0.02180667f, 0.05988365f, 0.05492381f, -0.02588102f, -0.04913085f, -0.06163001f, 
    -0.06845833f, 0.02246372f, -0.07720891f, -0.04585040f, -0.05333419f, 0.03373493f, 0.04904113f, 0.02779370f, 
    0.01966512f, 0.00963694f, 0.01332973f, -0.06964356f, -0.02062850f, -0.06653950f, -0.03918834f, 0.04683525f, 
    -0.06559394f, 0.01365524f, 0.06426826f, 0.04188324f, -0.03305890f, 0.01824627f, 0.05753504f, 0.03642153f, 
    -0.05810337f, -0.02366273f, -0.07871799f, 0.03199185f, -0.01596593f, 0.04126857f, -0.00741579f, 0.04244502f, 
    0.02220776f, 0.06414303f, -0.01116197f, 0.02028617f, -0.04112355f, 0.00936767f, -0.04877049f, -0.07374114f, 
    -0.05979105f, -0.02256227f, -0.01273699f, 0.02472218f, -0.08236260f, -0.05123487f, -0.02208116f, -0.04200525f, 
    0.02826280f, -0.01700167f, -0.06249657f, 0.00070921f, -0.05279380f, 0.03918275f, -0.02254715f, 0.02243419f, 
    0.04504658f, -0.06528141f, -0.00105799f, -0.06228179f, -0.04442131f, 0.02689543f, -0.01985514f, 0.04348924f, 
    -0.06719219f, 0.03515846f, 0.00426255f, 0.00413222f, -0.03830578f, 0.05379846f, -0.05892363f, 0.02588673f, 
    -0.01337152f, 0.00141554f, 0.00275210f, -0.03295560f, -0.06275809f, -0.02248271f, -0.05670379f, -0.06210776f, 
    -0.04094442f, -0.02000166f, 0.03985815f, -0.01269317f, -0.00486505f, -0.06624191f, -0.00211647f, 0.02729223f, 
    -0.00515022f, -0.06938420f, 0.02149005f, -0.00550974f, -0.02834893f, 0.04687677f, -0.05224557f, 0.01345272f, 
    0.04960810f, 0.02383464f, 0.00285547f, -0.08108671f, 0.02160796f, 0.03911955f, -0.06028468f, 0.03468991f, 
    -0.07325214f, 0.01130122f, 0.01503699f, -0.06931809f, -0.04316905f, -0.05299700f, -0.04151486f, -0.08087297f, 
    0.01625558f, 0.00558996f, -0.03841146f, -0.04419956f, -0.01202034f, -0.03164706f, 0.04167311f, 0.01134481f, 
    0.04377200f, -0.07804243f, -0.07534417f, 0.01375486f, 0.01100415f, -0.06475960f, -0.04372742f, 0.06414812f, 
    0.02690796f, -0.05165629f, -0.05915289f, 0.01055768f, 0.02367420f, 0.00764440f, -0.03137561f, 0.05232967f, 
    0.03192298f, 0.01358601f, -0.05567412f, -0.00410645f, 0.01592457f, 0.05189389f, -0.04252371f, -0.07371058f, 
    -0.04358019f, -0.00110023f, -0.04107910f, -0.00656263f, 0.06050132f, 0.00431306f, -0.07301734f, -0.04112789f, 
    -0.07354597f, 0.05904604f, 0.03931051f, -0.05752752f, 0.02039220f, 0.05136709f, 0.06108268f, 0.00980792f, 
    -0.01146385f, -0.05316092f, 0.03292223f, 0.03441581f, 0.03530715f, 0.04870755f, -0.03571092f, 0.02196868f, 
    -0.05093744f, 0.06169520f, 0.01419563f, 0.03386083f, -0.02184938f, 0.04053558f, 0.00311118f, 0.02351905f, 
    -0.06379250f, -0.07508945f, 0.06382278f, 0.03530350f, 0.04072906f, 0.05095794f, -0.05502905f, -0.04744592f, 
    -0.03712571f, -0.06416415f, 0.01470247f, 0.02753867f, 0.05875564f, -0.03557001f, -0.07302582f, 0.03057567f, 
    0.04787600f, -0.00855327f, -0.00104401f, 0.05964267f, -0.00684965f, -0.03608666f, -0.03145423f, -0.06434590f, 
    0.01398509f, 0.04115496f, -0.02349699f, 0.03404066f, -0.00186716f, 0.03500691f, -0.03246967f, -0.01176876f, 
    0.00433457f, -0.04420412f, -0.04157585f, 0.05433754f, 0.05517906f, -0.00404666f, 0.00304977f, 0.05218012f, 
    0.03254067f, 0.01156435f, 0.00746115f, 0.04288360f, -0.06332397f, 0.00818378f, 0.01535752f, -0.02650264f, 
    -0.03424468f, 0.05518340f, -0.07234499f, -0.06152811f, 0.03344016f, 0.03362674f, -0.03121233f, 0.04884875f, 
    0.01483023f, 0.01064751f, -0.03208304f, -0.00459450f, -0.01191366f, 0.00855907f, 0.02744898f, -0.06368122f, 
    -0.02522470f, -0.04513911f, 0.02145062f, -0.02548935f, 0.02355234f, 0.02337060f, -0.03902553f, -0.07720213f, 
    -0.02896835f, 0.02464540f, 0.03966933f, 0.04391609f, 0.00745491f, -0.04637992f, 0.01653702f, -0.07815591f, 
    -0.07214230f, -0.00069763f, -0.00797778f, 0.00689195f, -0.05846278f, -0.01539387f, 0.03093400f, -0.04647874f, 
    0.04679859f, -0.06217846f, 0.00002881f, -0.04281877f, -0.06879415f, -0.04362233f, 0.01554671f, -0.06190502f, 
    0.02343965f, -0.03952697f, -0.07125318f, 0.00862406f, -0.00624427f, -0.05155483f, 0.05928771f, 0.01309357f, 
    -0.07697903f, -0.06180897f, -0.06082803f, -0.06698840f, -0.00464843f, 0.05670436f, 0.02835129f, -0.00636016f, 
    0.05529273f, -0.01232898f, 0.03688999f, -0.01436603f, -0.00818582f, -0.04286076f, -0.02679608f, -0.03451070f, 
    -0.06538827f, 0.00554517f, -0.05159110f, 0.08262729f, -0.04194074f, -0.04968115f, 0.00621072f, 0.04555943f, 
    -0.07170412f, -0.07611278f, 0.18836793f, 0.00553056f, -0.03059385f, -0.06070089f, -0.04036785f, 0.03704645f, 
    -0.06303076f, 0.00699203f, -0.05357478f, 0.02276203f, -0.13685250f, -0.02107621f, -0.15895602f, -0.06554956f, 
    0.58601952f, -0.10314763f, -0.10682001f, -0.07437204f, 0.03281825f, 0.00479770f, -0.03798889f, -0.12000716f, 
    -0.15562667f, 0.08542092f, 0.02033295f, 0.04162696f, -0.05491430f, -0.06239443f, 0.16378367f, 0.15783978f, 
    -0.16356198f, 0.04114067f, 0.07792361f, -0.07109260f, 0.03663297f, 0.00285687f, -0.02847068f, 0.10139887f, 
    -0.19072898f, 0.10031075f, 0.14133860f, -0.11260431f, 0.00995864f, 0.06681880f, 0.04904329f, -0.06043560f, 
    -0.04744894f, 0.04125372f, -0.08612288f, 0.10172758f, -0.11318496f, -0.00422121f, -0.01681191f, -0.05838871f, 
    -0.10291032f, 0.08897670f, 0.05516996f, -0.11265313f, 0.04995447f, 0.05007047f, 0.06196861f, -0.11977929f, 
    0.01585483f, 0.03877387f, 0.08478721f, -0.10503996f, -0.04977699f, -0.17219400f, 0.11142945f, 0.04288457f, 
    0.00066764f, 0.00484337f, 0.03914532f, -0.02746101f, 0.15880546f, -0.18690774f, 0.04919775f, -0.09252714f, 
    -0.00198226f, -0.06112193f, 0.10269681f, -0.04538452f, -0.03859842f, -0.00479613f, -0.09746520f, 0.05917905f, 
    -0.20669453f, -0.12491991f, -0.00212568f, -0.13240828f, 0.06900761f, -0.01852860f, -0.05283082f, 0.07578654f, 
    -0.03069125f, -0.02061050f, -0.03436185f, -0.13080034f, -0.28196260f, 0.00239898f, -0.08575166f, 0.19661498f, 
    0.11967202f, 0.01168097f, -0.00822531f, 0.05539676f, 0.03458946f, 0.01264678f, 0.11363188f, 0.03822957f, 
    0.18448338f, 0.15286906f, -0.06937425f, -0.03121510f, 0.14489229f, 0.03812873f, -0.08437850f, 0.07529821f, 
    0.13649350f, -0.06561124f, -0.09925672f, -0.04222346f, 0.06349412f, 0.08460131f, 0.22256064f, -0.10442755f, 
    -0.01449551f, -0.05429544f, -0.02959912f, 0.02527316f, 0.07203384f, -0.03493479f, 0.05921429f, 0.02522644f, 
    0.33657828f, -0.13637643f, 0.11841641f, 0.32065335f, 0.03343698f, -0.01081597f, 0.02705879f, 0.08902999f, 
    0.04742257f, 0.12262043f, 0.03212918f, 0.07924014f, -0.12485271f, -0.03938425f, -0.02839675f, -0.12255111f, 
    0.13013482f, 0.06392474f, 0.04574839f, 0.08977385f, 0.11600313f, -0.08423679f, 0.00503181f, 0.08868184f, 
    -0.11491051f, -0.00519867f, 0.06380513f, -0.06857301f, 0.10346814f, -0.02649450f, 0.12887560f, -0.03510524f, 
    -0.04923920f, -0.00903674f, 0.21793900f, -0.02945898f, 0.37878233f, 0.00023871f, 0.08889707f, 0.22443126f, 
    -0.11222871f, 0.05464225f, 0.04253627f, 0.05290565f, 0.11602771f, -0.10006538f, -0.08720896f, -0.11813872f, 
    0.02221489f, 0.02605929f, -0.07192161f, -0.01625566f, -0.00638552f, -0.03134353f, 0.05026807f, -0.00726852f, 
    -0.03132591f, 0.04992648f, -0.03513752f, 0.04012057f, -0.06079322f, -0.05396342f, -0.04050354f, -0.00521216f, 
    -0.01272045f, 0.01304644f, -0.00718138f, -0.05676091f, 0.04796116f, 0.01489314f, 0.04587466f, -0.02775942f, 
    0.03488848f, 0.02041232f, -0.04061041f, -0.00621108f, 0.03505818f, -0.05712049f, -0.01086411f, -0.02667211f, 
    -0.05779816f, 0.04305481f, 0.05030496f, 0.01555128f, 0.00193289f, 0.02917949f, -0.03158054f, 0.04169188f, 
    0.00882530f, 0.01197855f, -0.07568696f, -0.05679951f, -0.01265125f, -0.01309860f, -0.07021475f, -0.06226487f, 
    -0.04656426f, -0.00918559f, -0.06251420f, -0.02921999f, -0.04695518f, -0.01538766f, 0.03630796f, -0.06270500f, 
    -0.02908822f, 0.04114509f, -0.04354835f, -0.00360574f, -0.06799527f, -0.02042279f, -0.01617895f, 0.00978144f, 
    0.00258145f, 0.02286035f, 0.05986343f, -0.02100237f, 0.03866239f, 0.00667213f, -0.03811534f, -0.07035124f, 
    -0.03839510f, -0.06797776f, -0.06403932f, -0.07113466f, 0.03246702f, 0.01087491f, 0.05774790f, 0.04228203f, 
    0.00044261f, 0.05676857f, -0.01179829f, 0.02724839f, 0.04046817f, -0.07799372f, 0.04312274f, 0.01874207f, 
    -0.00848595f, 0.04114765f, -0.05473197f, 0.04946845f, 0.02602852f, -0.03883914f, 0.01355259f, 0.05078279f, 
    -0.03543853f, -0.01038937f, -0.04845608f, -0.01724790f, -0.07008454f, -0.06797988f, 0.03625442f, 0.01169445f, 
    -0.03308786f, -0.05996659f, 0.04664845f, 0.01414374f, 0.03511230f, -0.00527931f, -0.04632401f, -0.08038665f, 
    -0.00800601f, 0.04146482f, 0.03833086f, -0.00351504f, 0.04034145f, 0.01051584f, -0.04197038f, 0.00873954f, 
    0.05639420f, 0.03192703f, -0.03166349f, 0.01130788f, 0.04992602f, -0.05497451f, -0.00144610f, -0.07226542f, 
    -0.04941055f, -0.05626882f, -0.02645461f, 0.02925970f, -0.04101358f, -0.07757134f, 0.02489585f, -0.00296643f, 
    -0.03707858f, 0.04525132f, -0.03983214f, -0.06461136f, -0.06623502f, -0.07633114f, 0.03292827f, -0.07764469f, 
    -0.03613441f, 0.06050534f, -0.06065226f, 0.04835372f, -0.06476697f, 0.03176889f, -0.07314830f, 0.02142579f, 
    -0.00703054f, -0.00292609f, -0.02536831f, -0.02708564f, 0.04323698f, 0.02709983f, 0.00394073f, -0.05872600f, 
    -0.00389603f, -0.07768221f, 0.05506135f, -0.04939260f, -0.02474118f, -0.05318972f, -0.07449681f, 0.05351117f, 
    -0.00681672f, -0.04896587f, -0.05519588f, -0.05859113f, -0.01985800f, -0.04547434f, 0.06076510f, -0.06857859f, 
    -0.06409508f, 0.02692469f, -0.04384239f, 0.01254557f, -0.05011553f, -0.01366052f, -0.02250402f, 0.06102747f, 
    -0.03728944f, 0.05348477f, -0.06440866f, 0.04482343f, 0.01535389f, 0.04458055f, -0.01444058f, 0.04670214f, 
    0.14767265f, -0.02250432f, -0.00126324f, 0.03229660f, 0.01020031f, 0.00141625f, 0.05778212f, 0.07955638f, 
    0.05386664f, 0.16484030f, 0.05633731f, 0.11606374f, -0.38010272f, -0.16282044f, 0.21747379f, 0.09759504f, 
    0.03159485f, -0.10017306f, 0.13637881f, -0.04882716f, -0.06502236f, 0.09009090f, -0.00594839f, 0.19145146f, 
    -0.05042880f, 0.35488525f, -0.03343690f, 0.17140912f, 0.05167278f, -0.00419828f, 0.01156339f, -0.02338347f, 
    0.10977761f, 0.11314687f, 0.01229449f, -0.03406060f, -0.09526473f, 0.14440632f, 0.09738066f, -0.03700206f, 
    0.06009619f, 0.00926394f, 0.06654561f, 0.00718603f, -0.06608416f, -0.01994395f, 0.11420231f, 0.15193604f, 
    0.09589069f, -0.04732747f, -0.03296450f, -0.09272715f, -0.00903639f, 0.15179598f, 0.04165137f, 0.01552629f, 
    0.09593323f, 0.01780879f, -0.01085141f, 0.08793043f, -0.21752071f, -0.05988320f, -0.29378012f, 0.09157823f, 
    0.13339433f, 0.09483273f, 0.06401398f, -0.00381718f, -0.01710118f, 0.11636499f, 0.00570453f, -0.07767026f, 
    -0.22304428f, 0.32517785f, 0.35127118f, 0.26125470f, 0.09315321f, 0.09377854f, -0.04822523f, 0.00514752f, 
    -0.04087396f, 0.03649094f, 0.16447692f, 0.04653709f, -0.14011733f, -0.26286486f, -0.02278464f, -0.10518999f, 
    0.05686196f, 0.13623509f, 0.09619839f, -0.03851105f, 0.08081953f, -0.17419080f, -0.01278978f, 0.03209146f, 
    0.20291081f, -0.17975013f, -0.22661099f, -0.04133261f, -0.10815594f, 0.06680379f, 0.01977423f, 0.02324090f, 
    0.12682015f, 0.20641059f, -0.07491376f, -0.04997785f, 0.29025030f, -0.20124821f, -0.06851497f, -0.07058110f, 
    0.04737319f, 0.20398051f, 0.01089885f, 0.12468981f, 0.06808455f, -0.00092124f, 0.13378280f, 0.03682692f, 
    0.12153885f, -0.20719373f, -0.19702156f, -0.23773131f, 0.02212786f, -0.08403605f, 0.01368816f, 0.00115240f, 
    0.02929150f, -0.00414726f, -0.02145886f, -0.01878700f, 0.06094829f, -0.12280826f, 0.01512417f, 0.00563078f, 
    0.07106300f, 0.07553617f, 0.02417297f, 0.08719338f, 0.22200903f, 0.02448825f, 0.05767281f, -0.02164647f, 
    0.06734665f, 0.27000740f, 0.23394829f, -0.21022119f, -0.07216528f, -0.02007339f, -0.06502043f, -0.05721860f, 
    -0.01247737f, 0.12538181f, 0.06537323f, 0.05248093f, -0.08218420f, -0.15493146f, -0.09173097f, -0.12497112f, 
    0.05341107f, -0.01940695f, -0.01614317f, 0.02310468f, -0.01173071f, -0.00868759f, 0.16100055f, -0.09098566f, 
    0.01856342f, 0.00520815f, -0.12049159f, -0.08832342f, 0.11805510f, 0.13312732f, 0.03267835f, -0.00144851f, 
    0.02752020f, 0.05931064f, 0.00090759f, 0.02509083f, -0.09139098f, 0.04943256f, 0.11081160f, 0.04948770f, 
    0.00772884f, 0.01486881f, 0.12923236f, 0.01721431f, 0.01171759f, -0.00152926f, 0.06157536f, 0.12192056f, 
    -0.28397152f, 0.00144245f, 0.04639547f, -0.08898713f, 0.05500988f, 0.02928634f, 0.03148737f, -0.00713053f, 
    -0.03023046f, -0.04621807f, -0.02326312f, 0.05400890f, 0.39598766f, 0.13565150f, -0.02272682f, 0.01707573f, 
    0.07135694f, 0.05441392f, 0.12751669f, -0.14459120f, -0.08302702f, 0.07620206f, -0.04294723f, -0.00241136f, 
    -0.15851758f, -0.13193172f, 0.11185636f, 0.00075362f, 0.11989176f, 0.20670448f, -0.08388148f, -0.00022224f, 
    -0.01066195f, -0.01975577f, -0.03395878f, 0.06105301f, 0.02673409f, 0.06132175f, 0.05207667f, 0.16949661f, 
    -0.05135577f, 0.06631669f, -0.13876472f, -0.01927551f, 0.04379445f, 0.02087591f, -0.05944449f, 0.01921173f, 
    0.09367940f, -0.02262031f, -0.01382130f, 0.22065507f, -0.07592160f, -0.09355918f, 0.07714456f, 0.01642776f, 
    -0.11198504f, -0.10185292f, 0.14557366f, 0.03164899f, 0.06270597f, -0.00052205f, 0.11053774f, 0.05500068f, 
    0.00145898f, -0.07276486f, -0.05392690f, 0.03458370f, 0.05288842f, -0.02326510f, -0.11149666f, 0.09667142f, 
    -0.11975043f, -0.35871649f, 0.01684326f, 0.13011129f, 0.02931910f, 0.07585844f, 0.06965477f, -0.01927239f, 
    0.04720397f, 0.02105927f, -0.05867155f, 0.02283507f, 0.05272733f, 0.08775055f, 0.00244150f, 0.12496836f, 
    0.01750837f, 0.03251228f, 0.01779975f, 0.13594571f, 0.04174334f, 0.09026022f, -0.05492086f, 0.00515488f, 
    -0.31380913f, 0.13337238f, 0.05386933f, 0.04002878f, 0.04088220f, -0.00620301f, -0.02927101f, -0.02408415f, 
    0.01525070f, -0.00062326f, 0.00010038f, -0.02698859f, -0.27759624f, 0.17387062f, 0.03562816f, -0.19876327f, 
    -0.07142119f, 0.02477399f, -0.04819902f, -0.00480794f, -0.03686491f, 0.12460054f, -0.03694662f, 0.01158328f, 
    -0.04530411f, -0.12526917f, -0.03156500f, 0.15949489f, -0.14384630f, -0.00463630f, 0.13366267f, -0.10097352f, 
    -0.08899337f, 0.03368901f, 0.13713585f, 0.04667395f, -0.06543744f, 0.02043381f, -0.10987537f, 0.37640372f, 
    0.02257909f, 0.19281742f, -0.02557192f, -0.00372763f, -0.00108763f, -0.04788208f, 0.04618060f, 0.08078486f, 
    -0.16860551f, 0.07882079f, 0.00979599f, -0.19174886f, 0.04165586f, 0.01607650f, 0.05405596f, -0.00053571f, 
    0.05392334f, -0.07023029f, 0.03808907f, 0.11770663f, 0.08975399f, 0.19854131f, 0.09804419f, 0.30634016f, 
    -0.02451505f, 0.15234548f, 0.10631403f, -0.01543506f, 0.02385963f, 0.03718066f, -0.05862061f, 0.16417632f, 
    0.13445131f, 0.09438378f, 0.07562538f, 0.27304339f, 0.03714031f, -0.00302229f, 0.04888744f, 0.03315061f, 
    0.05293793f, 0.07941163f, -0.00425435f, 0.08002120f, 0.08848717f, -0.13478705f, 0.05513590f, -0.17511983f, 
    -0.07573192f, -0.00824711f, 0.02448537f, -0.07217442f, 0.00770959f, 0.01100794f, 0.00632029f, -0.00165953f, 
    -0.03367392f, 0.09437142f, -0.09042484f, -0.04476663f, 0.09996389f, -0.04554738f, 0.08249079f, 0.19939700f, 
    -0.12300212f, 0.03352192f, 0.08306570f, -0.03002426f, 0.01009293f, 0.04901979f, -0.07229304f, 0.03556968f, 
    0.01531708f, 0.14863212f, 0.13531515f, 0.09469191f, -0.00876095f, 0.01633248f, -0.06753870f, 0.03259073f, 
    -0.27275541f, -0.07191494f, -0.16276181f, -0.14422135f, 0.07839421f, 0.01999747f, 0.02824385f, -0.02681467f, 
    0.07640933f, -0.10052220f, -0.02415360f, 0.08348618f, 0.39047933f, 0.08322539f, -0.05388889f, 0.16057016f, 
    0.13652734f, 0.11138535f, -0.01420063f, 0.06849409f, 0.03187168f, -0.01239629f, -0.08000009f, 0.01811134f, 
    0.36578467f, -0.08337437f, 0.15243414f, 0.17871511f, -0.02831874f, -0.05951539f, 0.10820042f, 0.05728886f, 
    -0.01452083f, -0.06729023f, -0.03630573f, 0.11917115f, -0.57968116f, 0.23487459f, -0.14248364f, -0.01545189f, 
    0.04714310f, 0.13186803f, -0.19774009f, 0.03090284f, -0.01030566f, 0.14438733f, 0.03151622f, 0.01478244f, 
    -0.07493278f, -0.01777580f, 0.03097416f, 0.09988398f, 0.20593716f, 0.05877005f, 0.00935581f, 0.02500509f, 
    0.14050569f, 0.11573397f, 0.05098791f, -0.00558266f, -0.14334561f, -0.12935586f, 0.06526779f, -0.06173526f, 
    -0.08281147f, -0.06648038f, 0.06644244f, 0.00830032f, 0.02567189f, -0.04995294f, -0.15668723f, -0.09094020f, 
    0.27486819f, 0.01272433f, -0.22497100f, 0.13754165f, -0.12690738f, -0.11199204f, 0.03659461f, 0.10107245f, 
    -0.02613281f, -0.05628463f, -0.04344119f, -0.13898546f, -0.03037079f, 0.10154362f, -0.03719682f, -0.00785785f, 
    0.13541229f, 0.11867126f, -0.00382366f, -0.04102678f, -0.08467349f, 0.03643378f, -0.02527182f, -0.01152330f, 
    0.05665006f, 0.13120517f, -0.09213268f, 0.05075448f, -0.20236020f, -0.21417812f, 0.03581494f, -0.05773843f, 
    -0.00958623f, 0.07894998f, -0.04224142f, -0.02096841f, -0.01179437f, -0.25438073f, -0.09369807f, 0.22020987f, 
    0.09214332f, 0.08581679f, 0.14219856f, -0.00914847f, 0.06531756f, 0.02659445f, -0.01197728f, 0.00002486f, 
    -0.24795537f, -0.33920184f, -0.11799633f, -0.30610079f, 0.09419737f, 0.04654093f, 0.04306699f, -0.01492005f, 
    -0.00492724f, -0.00560619f, 0.10855219f, 0.05277782f, 0.17566712f, 0.14310239f, 0.02466807f, 0.02030652f, 
    0.00761401f, 0.01974615f, 0.09775432f, -0.13361540f, -0.07819785f, -0.01368586f, 0.12332516f, -0.00887750f, 
    0.29044750f, 0.08695550f, 0.05222667f, 0.28031072f, 0.07722984f, 0.02982947f, -0.05345372f, -0.07330488f, 
    0.06876576f, 0.02700941f, -0.09996545f, 0.03518751f, -0.41406536f, -0.07904419f, -0.23319879f, -0.11895663f, 
    0.06926945f, 0.10221261f, 0.09465684f, -0.00108848f, 0.16909721f, 0.02440230f, 0.08869938f, 0.03339288f, 
    -0.28550357f, 0.02519202f, 0.17527293f, 0.02481016f, 0.15999874f, 0.01968714f, -0.02373844f, -0.09019801f, 
    0.05908881f, -0.03357358f, 0.08404080f, 0.00635646f, 0.21380228f, 0.01013928f, 0.06250101f, 0.07934968f, 
    0.07227670f, 0.12502299f, 0.07970733f, -0.12359556f, -0.05782069f, 0.02783650f, 0.02774179f, -0.25244179f, 
    0.08941159f, 0.12913445f, -0.15245634f, 0.12173465f, -0.03199705f, 0.00479042f, -0.04195754f, -0.13855146f, 
    -0.09465756f, -0.04794087f, -0.00347379f, 0.01272185f, -0.26175949f, 0.07331990f, 0.03134787f, -0.05914073f, 
    -0.05261971f, -0.08086957f, 0.06691033f, -0.00418890f, -0.01971911f, -0.05293974f, 0.01582071f, 0.16268712f, 
    0.13326354f, -0.07180595f, -0.04774940f, 0.24995917f, -0.01662185f, 0.00983941f, -0.15593818f, -0.02837599f, 
    -0.08885765f, 0.01592396f, 0.05912080f, 0.14311825f, 0.17835428f, -0.25172734f, 0.17515387f, 0.26740989f, 
    0.12780423f, -0.15836528f, -0.01089494f, -0.06278983f, 0.15966876f, -0.05011499f, -0.00483242f, 0.01051019f, 
    -0.21456930f, -0.18403473f, -0.05481747f, -0.04637618f, 0.05883035f, 0.04651443f, -0.10429334f, -0.01055819f, 
    -0.08885676f, -0.03718030f, 0.12943606f, 0.01707691f, -0.01508486f, 0.34068057f, -0.13859040f, 0.18374103f, 
    -0.08998228f, 0.08819255f, 0.02130342f, 0.17839852f, 0.18143454f, -0.08814561f, -0.16258706f, -0.03201424f, 
    -0.06130816f, 0.32397053f, 0.12159502f, 0.04837963f, 0.00451109f, 0.14550212f, 0.23537929f, 0.10790741f, 
    0.08199031f, -0.07211512f, 0.12003686f, 0.03988289f, 0.27903032f, 0.03294491f, 0.14174291f, -0.30664784f, 
    0.01009611f, 0.05944429f, -0.07326137f, 0.17632572f, -0.01579127f, 0.15947838f, 0.00011724f, 0.07347219f, 
    0.13490383f, -0.17147724f, 0.11869538f, 0.21601990f, 0.08905239f, 0.18221882f, -0.00965060f, -0.13114247f, 
    0.07970177f, 0.02170592f, -0.05644683f, -0.02388163f, -0.35895532f, 0.11323127f, -0.09806947f, 0.03059358f, 
    -0.09746999f, 0.19398479f, 0.02900899f, -0.05093325f, 0.07706130f, -0.01825015f, 0.04293988f, 0.17442071f, 
    -0.42746678f, 0.11896100f, -0.02021036f, -0.10663477f, -0.01348205f, 0.02255386f, 0.00152414f, -0.07335229f, 
    -0.09234227f, -0.05174225f, 0.05567502f, 0.15279099f, 0.00439790f, 0.17494671f, 0.13442966f, 0.25925398f, 
    0.08339612f, 0.33176050f, 0.11953726f, -0.14432020f, 0.01965878f, -0.02398202f, -0.14812952f, 0.14401506f, 
    0.04812415f, 0.09372342f, 0.03681280f, 0.12244556f, 0.26477754f, -0.00392670f, -0.07068997f, 0.04673653f, 
    -0.13575919f, 0.09112022f, -0.12981369f, -0.17542490f, 0.14415951f, -0.15395704f, -0.05410449f, -0.29690626f, 
    -0.06949795f, 0.07164043f, -0.16204064f, 0.02159048f, -0.04078106f, -0.16114767f, 0.10523659f, -0.21128023f, 
    0.02692223f, 0.05539986f, -0.03674239f, 0.00315088f, -0.01128729f, -0.02881532f, 0.03494835f, -0.02542164f, 
    0.04346187f, 0.05034093f, -0.03124734f, -0.03173006f, 0.05923210f, -0.02081835f, -0.04654750f, 0.04436047f, 
    -0.02174296f, -0.02402303f, -0.07579037f, 0.01028112f, -0.06923802f, 0.00256104f, -0.05577302f, -0.03163656f, 
    -0.06028777f, 0.01151784f, -0.04310663f, -0.05044233f, -0.02173608f, -0.03050260f, -0.04003355f, -0.01906418f, 
    -0.00147293f, -0.07019918f, 0.06526143f, 0.02746792f, -0.07169317f, 0.04155381f, -0.01250150f, -0.00263615f, 
    -0.06923170f, 0.03467886f, 0.04024969f, 0.00636531f, 0.00699626f, -0.04922893f, -0.07489698f, -0.06139030f, 
    -0.03706745f, -0.02352778f, -0.04163457f, -0.06246426f, 0.01949006f, 0.01896426f, 0.00850088f, -0.07666226f, 
    -0.02809135f, -0.00040349f, -0.01399199f, -0.03930479f, -0.01260511f, 0.05609637f, 0.00498209f, -0.01162903f, 
    -0.05604774f, -0.02493527f, 0.02280534f, -0.06502680f, 0.04234044f, -0.05790739f, 0.04173287f, -0.02978962f, 
    0.06219479f, -0.04511046f, 0.00796796f, 0.03787637f, -0.07115129f, -0.05056512f, 0.04869662f, 0.00417588f, 
    0.04804994f, 0.04703979f, -0.05519008f, 0.00604210f, -0.02817775f, 0.01893443f, 0.02586818f, -0.03828597f, 
    0.00759244f, -0.03097573f, -0.04001114f, 0.05073396f, 0.00870522f, 0.04896755f, -0.03958799f, -0.02738275f, 
    -0.04500059f, -0.07586868f, 0.05146791f, 0.03630539f, -0.04804253f, 0.01672050f, 0.03780087f, 0.05907745f, 
    0.02956683f, 0.03143581f, 0.01004858f, 0.04069805f, -0.07229192f, 0.04859672f, 0.00061280f, 0.01489055f, 
    0.03244398f, 0.03855188f, -0.04031486f, 0.04608243f, -0.04606558f, -0.06710079f, -0.06757416f, 0.01545026f, 
    0.00456962f, -0.00292767f, 0.00329517f, 0.04835346f, 0.03791316f, -0.02524291f, 0.01879739f, -0.05608541f, 
    0.03751959f, 0.00880692f, -0.03271438f, -0.05542157f, -0.05006027f, 0.01094232f, -0.01000939f, 0.05342583f, 
    -0.03439230f, 0.04621997f, -0.01733417f, -0.03027277f, 0.02437282f, -0.03577007f, 0.03233734f, 0.04243695f, 
    -0.00976706f, 0.06154814f, -0.05264012f, -0.03460930f, -0.06411348f, -0.03068875f, -0.02420537f, -0.06392128f, 
    -0.01813875f, 0.00038296f, -0.06220946f, 0.01582974f, -0.00718056f, 0.03766239f, -0.07281787f, 0.05713525f, 
    -0.05694217f, 0.04201400f, -0.01781516f, -0.02688334f, -0.03368289f, -0.02098978f, 0.03358956f, 0.00968984f, 
    -0.05915359f, -0.03027561f, 0.00495269f, 0.01978291f, -0.00472506f, -0.02177917f, -0.02775431f, 0.06255591f, 
    -0.00182518f, 0.03655901f, -0.05052869f, -0.06892459f, -0.06739665f, 0.05880391f, -0.02850977f, -0.04245482f, 
    0.00175451f, -0.07434481f, -0.05979567f, -0.02748306f, 0.02531126f, -0.00738762f, -0.00927467f, -0.02966869f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07031110f, -0.07239817f, 0.14533488f, -0.00471199f, -0.09371287f, 0.12474872f, 0.07503816f, -0.08595183f, 
    0.00145509f, 0.10396665f, 0.10719302f, -0.03338171f, -0.01440464f, 0.05599565f, 0.01729067f, 0.02876290f, 
    0.09722040f, 0.10447858f, 0.05432288f, -0.06444222f, 0.05948774f, 0.14717905f, -0.13646103f, -0.06700312f, 
    0.13455980f, -0.03804423f, 0.05387095f, -0.04675437f, -0.10557538f, -0.00768622f, 0.01143814f, -0.02302609f, 
    -0.05819505f, -0.00522486f, -0.05463357f, 0.05271646f, -0.02893176f, 0.03607262f, 0.00823817f, -0.07204962f, 
    0.17362183f, 0.03298946f, 0.03538540f, 0.12264004f, -0.05005828f, 0.04354054f, 0.04443180f, -0.10422068f, 
    -0.06123102f, -0.00842120f, 0.07705188f, -0.04621034f, 0.04040781f, 0.02285293f, -0.07603770f, 0.03122923f, 
    0.00458083f, 0.05965448f, -0.08113316f, 0.05853610f, 0.04622321f, 0.13896050f, -0.02219179f, -0.03425136f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.46993211f, -0.06005081f, -0.03602422f, 0.01411799f, -0.04105722f, 0.06013419f, 0.25550017f, 0.10208901f, 
    0.11786596f, 0.05574671f, 0.05887610f, -0.10312477f, -0.02294980f, 0.05262708f, -0.09116949f, 0.10404406f, 
    0.14525327f, 0.18734142f, -0.12415128f, 0.04507247f, -0.24220937f, -0.13982289f, -0.15304153f, 0.09476826f, 
    -0.16780503f, -0.03134544f, 0.04966915f, -0.02565851f, 0.01456447f, -0.24874707f, -0.02719823f, 0.12929784f, 
    0.06359766f, -0.04734576f, -0.10359471f, 0.07713887f, 0.11581859f, 0.06561049f, -0.07594243f, 0.11552009f, 
    -0.06254103f, 0.01166502f, 0.05238325f, 0.07016528f, -0.03318270f, -0.09085125f, 0.22758073f, 0.10435985f, 
    -0.09072480f, 0.06717100f, -0.18915349f, -0.11751805f, 0.08078647f, -0.15374008f, 0.06502925f, -0.04876664f, 
    0.06693519f, 0.11107226f, -0.03069914f, 0.07227630f, -0.01904456f, 0.03986988f, -0.24666098f, 0.09365492f, 
    -0.04169174f, 0.09353210f, -0.02077718f, 0.09792411f, -0.12847036f, -0.15716523f, -0.04380462f, 0.02867897f, 
    -0.07490711f, -0.05034316f, -0.02762968f, 0.01380888f, -0.01327192f, -0.06229585f, -0.07142292f, 0.05202445f, 
    -0.10847452f, -0.09662630f, -0.11170860f, -0.09013122f, -0.10620586f, 0.04232005f, 0.02264298f, 0.03960653f, 
    0.02955979f, -0.01050115f, -0.11105399f, 0.08983310f, -0.07021596f, -0.05013976f, 0.06282665f, 0.04595451f, 
    0.01058601f, -0.00123765f, 0.09144352f, 0.04491545f, -0.11038645f, -0.03953352f, -0.04760346f, -0.12986046f, 
    0.10113218f, -0.05126576f, -0.02890670f, -0.05532639f, 0.12385449f, -0.00029643f, -0.05453372f, -0.06891388f, 
    -0.01076012f, -0.06973138f, -0.10613035f, 0.10781462f, 0.06673855f, -0.10155847f, -0.05564395f, -0.00034609f, 
    0.04732960f, -0.15133379f, -0.12007152f, -0.02794034f, 0.02602403f, 0.08944591f, -0.16519217f, 0.06699191f, 
    0.22613996f, 0.01362039f, 0.06717870f, -0.00430009f, 0.17948906f, 0.07098418f, 0.04346610f, 0.16109306f, 
    -0.11707002f, -0.12609822f, 0.05010399f, -0.02135634f, -0.12503019f, -0.06593645f, -0.09817706f, -0.07586154f, 
    0.15060841f, 0.05314812f, -0.27607688f, 0.19736885f, -0.31822145f, 0.14106366f, 0.08405430f, 0.34839994f, 
    -0.16609521f, 0.10316709f, 0.11201865f, -0.04341868f, 0.08335254f, 0.17483236f, -0.16179335f, -0.05454789f, 
    0.01225170f, -0.05111723f, -0.01214197f, -0.09414694f, -0.09939878f, -0.02883603f, -0.14875853f, 0.05931133f, 
    0.17577079f, -0.02674690f, 0.09039302f, -0.08434047f, 0.06266553f, 0.07638085f, 0.15577863f, -0.03672533f, 
    -0.14210372f, 0.09920321f, -0.14554967f, -0.04182764f, 0.16494870f, 0.13091621f, 0.04497787f, 0.02750358f, 
    -0.10073648f, -0.09704010f, 0.09557335f, 0.11564562f, -0.16299549f, 0.03729897f, -0.35457534f, -0.11241440f, 
    -0.50266790f, -0.05890742f, 0.00071256f, 0.00961002f, -0.26554614f, -0.10482942f, 0.12240116f, -0.05893882f, 
    0.06971320f, 0.23278858f, 0.14902429f, 0.04139648f, 0.20712736f, -0.10932215f, -0.13393992f, 0.34090659f, 
    0.00660613f, 0.01166889f, 0.11481446f, -0.07883866f, 0.28414229f, 0.35361180f, -0.23733123f, -0.15907069f, 
    -0.05416690f, 0.11411179f, 0.09563404f, 0.05326025f, -0.11223516f, 0.06558447f, 0.16360165f, 0.05125338f, 
    -0.00900604f, -0.00057687f, -0.04952905f, 0.07745764f, 0.10386133f, -0.09519748f, 0.18780583f, 0.13410597f, 
    0.19443358f, 0.08698355f, 0.11853631f, 0.04440242f, -0.07521932f, -0.25844878f, -0.02048850f, -0.29180869f, 
    0.12426720f, -0.04547758f, 0.15584736f, -0.01642455f, -0.17044035f, 0.16881384f, -0.01319164f, -0.06998934f, 
    -0.03227396f, 0.25432062f, -0.00128833f, 0.04079750f, 0.12677999f, -0.00637367f, 0.28248155f, 0.03607278f, 
    0.13639361f, 0.00452662f, 0.06703347f, 0.02728060f, -0.18178463f, 0.21822976f, -0.33142981f, 0.23888686f, 
    0.06218836f, -0.11232290f, 0.06073121f, -0.08149005f, 0.32783958f, -0.08717393f, 0.08794648f, 0.00439609f, 
    -0.09591844f, 0.15165399f, 0.08250931f, -0.10480500f, -0.11379352f, -0.18411286f, -0.08195246f, 0.06422925f, 
    -0.06049723f, 0.03603733f, -0.03687644f, 0.00900362f, 0.10113097f, -0.24313907f, 0.02965519f, 0.10596844f, 
    -0.11134319f, -0.07699364f, -0.06772498f, 0.07202912f, 0.10009629f, 0.45074221f, 0.09102009f, 0.23233742f, 
    -0.09551366f, 0.02330499f, 0.10629795f, 0.08093681f, 0.03031819f, 0.17085354f, 0.06173952f, 0.06901297f, 
    0.24440730f, -0.07492047f, 0.15634112f, -0.09944741f, 0.16558149f, -0.10694312f, 0.00796598f, -0.08042905f, 
    0.01953488f, 0.29570457f, -0.04549730f, -0.02404867f, -0.08387356f, -0.28042594f, 0.19315065f, -0.05370015f, 
    -0.10351005f, 0.09210058f, 0.25512782f, 0.03640819f, -0.10067787f, 0.21613923f, -0.19451430f, 0.11106996f, 
    -0.06036120f, -0.03450080f, -0.21604979f, 0.01671100f, -0.02297388f, -0.08132430f, 0.37014055f, -0.03393705f, 
    0.00968773f, -0.00978779f, 0.09869565f, 0.11790054f, -0.24793993f, -0.12851354f, 0.36399651f, 0.33766711f, 
    0.29590836f, -0.12190305f, -0.01465037f, 0.03295472f, -0.02329898f, 0.16644076f, 0.08166882f, -0.08209395f, 
    -0.04293162f, 0.05690342f, 0.11084056f, 0.01201102f, 0.09549753f, -0.23108207f, 0.06885890f, -0.02135669f, 
    -0.01227411f, 0.08823043f, -0.08397956f, 0.14838514f, -0.03914353f, 0.16125810f, 0.05353563f, 0.04715483f, 
    0.09372978f, -0.07128485f, 0.10885385f, -0.00358656f, 0.06256788f, -0.15317456f, 0.11415572f, 0.02650018f, 
    -0.00835834f, -0.06652235f, -0.05426216f, 0.27523571f, -0.06069452f, -0.02286618f, -0.00113149f, -0.08958675f, 
    -0.14088233f, 0.11413376f, 0.01740868f, -0.09329249f, 0.03082677f, -0.10230364f, -0.04681541f, 0.10148640f, 
    -0.00549799f, -0.12319873f, -0.04044667f, 0.12078626f, 0.03530773f, 0.07523792f, -0.06416640f, 0.05370608f, 
    -0.07037159f, 0.05316432f, -0.06303819f, -0.13415261f, -0.10520472f, -0.11451063f, 0.02464947f, -0.02644349f, 
    0.02031804f, -0.10758480f, 0.04868601f, 0.07353294f, -0.13768959f, -0.00677412f, -0.05123833f, 0.08247232f, 
    0.12474228f, -0.11538991f, -0.04390125f, -0.00180431f, 0.05582993f, 0.02350756f, -0.06495377f, -0.09114083f, 
    -0.04521838f, -0.04583093f, -0.02333207f, 0.05967009f, -0.01149458f, -0.06029422f, -0.12817661f, -0.05901334f, 
    -0.08190627f, 0.11962216f, -0.07482198f, 0.03273260f, 0.07743762f, -0.06887332f, -0.03835756f, -0.04028628f, 
    -0.10417451f, 0.05423957f, 0.02556582f, -0.15749902f, 0.06958231f, -0.10120126f, -0.07775482f, 0.11522767f, 
    -0.17696530f, -0.08962046f, 0.13892689f, -0.05647763f, -0.25490209f, 0.09017706f, -0.01021645f, 0.17214006f, 
    0.03166689f, -0.21553412f, 0.15498328f, -0.04825176f, 0.28229934f, -0.00140644f, -0.09506688f, 0.28303906f, 
    -0.20886230f, 0.03385531f, -0.07928805f, 0.05297118f, 0.12468016f, 0.30051881f, 0.15801428f, 0.23061700f, 
    -0.08895158f, 0.10738287f, -0.02556630f, 0.00947865f, 0.11607598f, -0.17765339f, 0.05403657f, -0.00173548f, 
    0.07620028f, 0.06792343f, 0.10044898f, -0.07960265f, -0.03252978f, 0.22399348f, 0.23599730f, 0.00143653f, 
    0.23623353f, 0.09181228f, 0.05399027f, 0.02942827f, -0.04883705f, -0.15082785f, 0.10580060f, -0.27774256f, 
    0.13459378f, 0.05920177f, -0.12762216f, 0.01106524f, -0.39450744f, 0.13757013f, 0.05453960f, 0.07139505f, 
    0.12162545f, 0.24667041f, 0.09577053f, 0.12640741f, -0.10648426f, -0.13903990f, 0.06316119f, -0.07356159f, 
    0.22888608f, -0.02078979f, -0.18257655f, -0.00358863f, -0.02898362f, 0.17136066f, -0.18176341f, 0.11584231f, 
    -0.02710691f, -0.08167213f, 0.25146237f, 0.00593071f, -0.08761925f, -0.11294035f, -0.39751217f, -0.25649697f, 
    0.13681953f, 0.07078613f, 0.36927828f, -0.10861447f, 0.01271633f, -0.20505565f, -0.00999720f, -0.18611248f, 
    0.06685079f, 0.03615350f, -0.10719262f, -0.03048265f, -0.01678727f, 0.27923691f, 0.21099666f, 0.07804116f, 
    -0.06204510f, 0.10688993f, 0.10290877f, 0.10222557f, -0.00353016f, 0.36275131f, 0.10129429f, -0.05342082f, 
    0.34508070f, 0.11656692f, -0.07194394f, -0.01977694f, -0.03862086f, -0.15643589f, -0.01117430f, 0.13144487f, 
    0.08125733f, -0.02248100f, -0.01813974f, 0.05097587f, 0.21022913f, 0.27846473f, 0.09381983f, 0.02888390f, 
    0.11046080f, 0.13487384f, 0.09000152f, -0.22485173f, 0.15128499f, 0.07179359f, 0.18950570f, -0.05350313f, 
    -0.11890505f, 0.10377595f, 0.03161865f, -0.09362165f, 0.00365208f, 0.00799017f, 0.09381272f, 0.01221750f, 
    -0.10915938f, 0.01867725f, -0.13664369f, -0.07341512f, -0.02787652f, -0.01127792f, -0.06015006f, -0.12410273f, 
    0.06809212f, -0.04772720f, 0.03631242f, -0.02187967f, 0.05437871f, -0.03434344f, 0.07585255f, -0.12361681f, 
    -0.09331959f, 0.01982431f, -0.01618492f, 0.09321456f, -0.10701050f, -0.01791481f, -0.09574001f, -0.12176839f, 
    0.03658358f, 0.06503532f, -0.04022706f, 0.03518849f, -0.03222210f, -0.06120576f, -0.10826454f, -0.11447213f, 
    -0.01456428f, -0.04058878f, -0.04794631f, -0.02148689f, 0.01781945f, -0.12758914f, 0.07613632f, -0.08217501f, 
    -0.14854239f, 0.04129499f, -0.08782739f, 0.03367588f, -0.04826882f, -0.10041381f, 0.08267269f, 0.04061999f, 
    -0.08529399f, -0.10644779f, -0.11775290f, -0.00116480f, 0.01358434f, -0.11519657f, -0.05923346f, -0.11305229f, 
    -0.09795267f, 0.02585503f, -0.07227401f, -0.01451450f, -0.03293251f, 0.02535413f, 0.08604009f, -0.01912550f, 
    -0.02522001f, -0.06654707f, 0.07253699f, 0.02286346f, -0.01358616f, -0.07347040f, -0.01296179f, -0.08858552f, 
    -0.13433680f, 0.01116674f, 0.08385851f, -0.01652322f, 0.05363907f, 0.06485729f, -0.03081969f, 0.05869336f, 
    -0.09417824f, 0.09845871f, 0.04901317f, -0.07947856f, 0.07047378f, -0.08096441f, 0.04870679f, -0.04438449f, 
    -0.06339333f, -0.12492280f, -0.03893050f, -0.08671314f, 0.06415151f, -0.08712733f, -0.13646604f, -0.00288943f, 
    -0.12570438f, -0.04432686f, -0.03163595f, -0.12233900f, 0.10890566f, -0.04111920f, 0.01757075f, -0.00924594f, 
    0.02011971f, -0.04846503f, 0.08076369f, 0.05140165f, 0.00847441f, -0.15001999f, 0.08708596f, 0.03851184f, 
    -0.00738251f, -0.07111120f, 0.10102107f, 0.01975819f, -0.06368493f, -0.01571444f, 0.06114521f, -0.10764442f, 
    0.07972537f, -0.00634463f, -0.14917433f, -0.01497309f, 0.04134586f, -0.03877172f, -0.11682243f, -0.13033074f, 
    -0.05189002f, -0.10297885f, -0.02224240f, 0.01873243f, 0.07970601f, 0.03447207f, -0.15510091f, 0.08307151f, 
    -0.11623880f, -0.12713578f, -0.17116317f, -0.03106910f, -0.02267672f, -0.01683285f, 0.01400700f, -0.14568745f, 
    -0.12357542f, 0.03196648f, 0.05986974f, 0.04045525f, -0.17239162f, 0.08572357f, -0.08862693f, 0.04744470f, 
    -0.07619707f, 0.09617147f, 0.00928873f, 0.02047236f, 0.09740939f, -0.01172385f, 0.06479303f, -0.04057848f, 
    0.00839781f, -0.12148038f, 0.09540229f, -0.06125439f, 0.00853732f, 0.07023987f, 0.04757209f, -0.06650065f, 
    0.00627729f, -0.10467781f, -0.06164254f, 0.10068245f, 0.01982475f, -0.08953641f, -0.02390769f, 0.10502513f, 
    -0.01685118f, 0.11999051f, 0.09627331f, 0.05253984f, -0.16411577f, -0.11090507f, -0.10415643f, 0.01177585f, 
    -0.11032768f, -0.01170655f, -0.06308299f, 0.02106613f, 0.00312240f, 0.05093405f, -0.35597152f, -0.05548037f, 
    -0.08422549f, 0.14557129f, -0.11781859f, -0.07882409f, -0.12609030f, -0.12011379f, -0.03256047f, -0.14655674f, 
    -0.06917799f, -0.18145972f, -0.03736798f, 0.08239650f, -0.13734399f, 0.04256242f, -0.05712682f, -0.20799696f, 
    0.34032935f, -0.09315644f, -0.06843472f, -0.05892506f, 0.00981629f, 0.05435858f, 0.11707457f, 0.06408476f, 
    -0.04202736f, -0.09480353f, 0.02099795f, 0.05377371f, -0.09029825f, -0.04963094f, -0.03352596f, 0.14748530f, 
    0.27648440f, 0.01420306f, 0.10647129f, -0.01043341f, 0.01722668f, 0.29336441f, -0.05184922f, 0.09656324f, 
    0.02939860f, -0.07740806f, 0.36510292f, 0.02536834f, 0.27973896f, 0.19745335f, -0.07472281f, 0.05181962f, 
    0.04838752f, -0.03676011f, -0.10121481f, 0.12417949f, 0.21005046f, 0.09145979f, 0.43909323f, -0.06136640f, 
    -0.07723744f, -0.02265195f, 0.09885999f, -0.09788937f, -0.04410801f, 0.16307937f, 0.14540024f, -0.02937833f, 
    -0.11772563f, 0.22271393f, 0.19475454f, 0.08265221f, 0.01529259f, -0.07265509f, 0.01598161f, 0.04556672f, 
    0.03223059f, 0.05022318f, 0.42244613f, -0.23685893f, 0.20711026f, -0.05149907f, -0.25038156f, -0.20745239f, 
    0.24310593f, -0.04890092f, -0.09601569f, -0.05323067f, -0.47132307f, 0.18098651f, -0.05786152f, 0.11493721f, 
    -0.10179961f, 0.08899082f, -0.09830007f, 0.07589484f, 0.09010495f, -0.12377805f, 0.33105782f, 0.03009529f, 
    0.23318161f, -0.07691936f, 0.06841940f, 0.22663206f, 0.05513347f, -0.08337133f, 0.03893323f, -0.09869487f, 
    -0.23564847f, -0.10639140f, 0.15341829f, 0.05837253f, 0.21283239f, 0.02631387f, -0.06178935f, 0.04585350f, 
    -0.02440086f, -0.10330322f, 0.05547237f, -0.00165714f, -0.07187580f, 0.25447422f, 0.02611991f, 0.07596803f, 
    0.19165868f, -0.11853291f, -0.00298281f, -0.03087733f, 0.07209160f, -0.06867910f, 0.25335291f, 0.05684572f, 
    0.05933675f, -0.11931779f, 0.38803065f, -0.06744679f, 0.02027747f, 0.10559567f, 0.04453423f, 0.36200815f, 
    -0.06498718f, 0.17936780f, 0.13815129f, 0.01379300f, 0.16060071f, 0.44602260f, 0.04290101f, 0.33613738f, 
    -0.04750930f, 0.02653562f, 0.08301532f, -0.04376596f, -0.01212039f, -0.17311530f, 0.13754150f, 0.08473901f, 
    0.01727858f, 0.02577196f, -0.06009037f, 0.06934839f, 0.07055318f, 0.00231742f, -0.19831498f, -0.21159786f, 
    0.02514236f, -0.06907598f, 0.10559065f, -0.03410489f, 0.09649260f, -0.06138290f, 0.19193719f, -0.11075626f, 
    0.18613683f, 0.01311642f, -0.04937369f, 0.05234253f, -0.11771587f, 0.09741026f, 0.01221697f, -0.08075234f, 
    0.00068920f, 0.17767483f, -0.11110155f, 0.12527741f, -0.06601609f, 0.13560700f, -0.24143830f, -0.05426595f, 
    -0.22342816f, -0.07143114f, 0.10852017f, 0.04770498f, -0.24361931f, 0.33798251f, -0.10464408f, -0.09880014f, 
    0.08361326f, 0.15459575f, 0.14171997f, -0.01324055f, -0.19753112f, 0.01660411f, -0.20222190f, 0.01757200f, 
    0.03571059f, 0.03358234f, 0.36796713f, -0.17984287f, -0.23649387f, -0.03555374f, -0.10706381f, -0.03898037f, 
    0.32149196f, -0.12007657f, -0.08450416f, -0.02478028f, -0.30249187f, 0.14838395f, 0.13775486f, -0.09171441f, 
    0.08125735f, 0.01983124f, 0.08803445f, 0.07522497f, -0.03658906f, 0.11730099f, 0.10276958f, -0.11265208f, 
    0.39423227f, 0.05852262f, 0.10189229f, -0.05265936f, -0.02506056f, -0.01463903f, 0.06871212f, -0.14982106f, 
    0.07814915f, -0.05590523f, -0.00432256f, -0.03966072f, 0.06319623f, -0.14666155f, 0.06912114f, -0.03320123f, 
    0.11589707f, 0.02139597f, 0.11612779f, 0.18190706f, 0.03915934f, 0.16055377f, 0.30139175f, 0.09942823f, 
    -0.00239208f, -0.02477554f, 0.21158591f, 0.03860740f, -0.06633110f, 0.39715725f, -0.05778588f, 0.14212358f, 
    0.03188917f, 0.10079071f, 0.09829205f, 0.02235810f, 0.33123121f, -0.04738447f, -0.25767189f, 0.11648536f, 
    0.20104566f, 0.15842627f, -0.34913203f, 0.00737235f, 0.02848347f, 0.09634344f, -0.11933706f, 0.03863684f, 
    0.24793543f, -0.05944588f, 0.08877863f, -0.11050784f, -0.07122887f, -0.32664058f, -0.24013004f, -0.01047192f, 
    -0.10284492f, 0.10145169f, -0.03112229f, -0.02281198f, -0.04553190f, 0.01202642f, 0.25306678f, 0.15367860f, 
    -0.04508351f, -0.03017829f, -0.05390714f, 0.05604088f, -0.09921054f, 0.22618358f, 0.30840340f, 0.08831282f, 
    -0.11993122f, -0.02578060f, 0.30820340f, 0.07732999f, -0.16074297f, -0.11038123f, 0.00802700f, -0.09624616f, 
    0.06009570f, 0.11704506f, 0.04689518f, 0.06959593f, -0.11555868f, 0.11585333f, -0.29117817f, -0.04579510f, 
    0.07731597f, -0.01826696f, -0.04880079f, -0.07884541f, -0.13546322f, 0.18590946f, 0.03588201f, -0.08428212f, 
    0.01376274f, -0.04178916f, -0.02382706f, -0.06762126f, 0.08481084f, -0.03540018f, -0.04705707f, 0.02507235f, 
    0.02963886f, -0.07225350f, 0.12155025f, -0.14586440f, -0.18820405f, -0.09111005f, -0.03756838f, 0.05081081f, 
    -0.14373143f, 0.09635800f, 0.06070656f, 0.03793682f, 0.11643025f, -0.02068779f, -0.08861408f, 0.08714047f, 
    -0.05187428f, 0.00885589f, -0.10045828f, 0.08519112f, 0.12449560f, -0.07826658f, -0.05401624f, 0.00266194f, 
    0.11246783f, -0.06399441f, 0.10225668f, -0.09083874f, -0.00532317f, -0.13632761f, 0.05881647f, 0.06107311f, 
    0.12636568f, 0.07414617f, 0.01889235f, -0.02814364f, -0.09428436f, -0.01581247f, -0.02141079f, 0.07203493f, 
    -0.00362030f, 0.00400669f, 0.02278040f, -0.13887912f, 0.09128374f, 0.00336403f, -0.10889752f, 0.04141261f, 
    -0.08025223f, 0.01490505f, 0.30964592f, -0.03995324f, -0.30042189f, 0.35989037f, -0.20484316f, 0.16706571f, 
    -0.11011077f, -0.03747004f, -0.08115704f, 0.07065871f, 0.24062705f, 0.06130761f, -0.12775837f, 0.06829097f, 
    -0.10009766f, -0.14276761f, -0.05799460f, 0.08641893f, -0.04915481f, -0.20451649f, -0.08788778f, 0.24991019f, 
    -0.06982641f, 0.00309545f, -0.10093851f, -0.11035060f, 0.08983411f, -0.43324265f, -0.05374929f, -0.09187785f, 
    -0.04162844f, 0.01128786f, 0.06842983f, -0.06932850f, -0.00435458f, 0.21472821f, 0.25464913f, 0.22386353f, 
    0.27502659f, -0.12190975f, -0.01090797f, 0.12900053f, 0.14493430f, 0.22720863f, 0.11010271f, 0.12840152f, 
    0.01573068f, 0.03379286f, 0.23596643f, -0.10979270f, -0.03721190f, -0.08109347f, 0.01766801f, 0.10664292f, 
    0.03554645f, 0.24330164f, 0.11087789f, 0.05960266f, -0.07920207f, -0.06396840f, 0.05381764f, -0.12660630f, 
    0.02044261f, -0.02216983f, -0.12448557f, 0.04204561f, -0.12573248f, 0.06242057f, -0.08869946f, 0.07773823f, 
    0.05801041f, 0.03061129f, 0.07584619f, 0.01090956f, 0.00435788f, -0.05544462f, -0.12573108f, -0.05408749f, 
    0.04587461f, -0.00491232f, -0.00111586f, -0.00484094f, 0.03159023f, -0.10113242f, -0.02994978f, -0.02864374f, 
    0.04671849f, -0.10572861f, 0.08905854f, 0.11746442f, -0.11473339f, -0.00413582f, -0.11388531f, 0.00825805f, 
    0.07457672f, 0.00932430f, -0.10355447f, -0.08887348f, -0.08764586f, -0.08098445f, -0.10162795f, -0.16682939f, 
    -0.00118308f, 0.02969513f, -0.08627958f, -0.09445632f, -0.03218865f, -0.07059852f, 0.06896553f, -0.08120865f, 
    -0.03439267f, 0.07405725f, 0.06799649f, 0.09162620f, 0.00483853f, -0.17246233f, -0.06503305f, 0.04601307f, 
    0.11184560f, -0.09468948f, -0.09031660f, -0.10432272f, -0.13220763f, 0.01977955f, -0.08766866f, 0.07032445f, 
    0.01883786f, -0.12356113f, -0.15052497f, -0.08924993f, -0.21579812f, 0.23199850f, -0.06189966f, 0.20995969f, 
    -0.04469745f, -0.10607450f, 0.15564699f, 0.01573799f, 0.15000960f, 0.10091022f, -0.21563222f, 0.14989686f, 
    0.15039995f, 0.16853164f, 0.32060406f, -0.20242397f, 0.12653814f, 0.20404044f, -0.01770204f, -0.07193726f, 
    0.09451261f, -0.11199699f, -0.00227441f, 0.08296059f, -0.25138727f, 0.18516658f, -0.21025969f, -0.07333047f, 
    -0.03610986f, 0.13287821f, -0.11611005f, -0.03733860f, 0.04378853f, 0.05014359f, 0.24028632f, 0.07305606f, 
    0.12803617f, -0.03440117f, -0.09852545f, 0.04892279f, 0.00072307f, -0.02932041f, 0.15644449f, -0.05706133f, 
    0.14616674f, 0.04594609f, -0.25600734f, 0.04179384f, -0.11822496f, -0.15136181f, -0.01081015f, 0.03881340f, 
    -0.07718749f, 0.12036679f, -0.07350733f, 0.06426553f, -0.34919649f, -0.04391298f, 0.01717042f, -0.10486998f, 
    -0.03638667f, 0.03976080f, -0.04466081f, 0.03797607f, -0.03526668f, -0.10388299f, -0.06414091f, -0.14988640f, 
    0.05453165f, -0.12363887f, 0.00085750f, -0.01343875f, -0.06936024f, 0.05540146f, -0.10624366f, -0.01712026f, 
    -0.10278966f, -0.02379771f, -0.16603121f, 0.02623017f, -0.04074623f, -0.11368608f, 0.04623063f, 0.08436522f, 
    0.05939061f, -0.00630488f, -0.00915880f, 0.01930854f, -0.08087300f, 0.04658304f, 0.06663489f, 0.10933185f, 
    -0.05609519f, -0.09679636f, -0.01020571f, -0.07079264f, 0.00174755f, 0.01267945f, -0.02817765f, -0.06521765f, 
    -0.04308518f, -0.01189637f, -0.07876869f, 0.08709387f, 0.10530309f, 0.01571317f, -0.00275144f, 0.15318452f, 
    -0.07511998f, -0.11491817f, -0.03948097f, -0.11616421f, -0.07282403f, -0.03623389f, -0.02651478f, 0.07782184f, 
    0.00586805f, 0.04475136f, 0.01634417f, -0.05046064f, 0.00235045f, 0.05370442f, -0.00964961f, -0.09075968f, 
    -0.21540418f, 0.11753163f, -0.09103422f, -0.11226544f, -0.01233054f, 0.17913871f, 0.18900563f, -0.04708334f, 
    -0.11633484f, 0.31843764f, 0.19918184f, -0.07596488f, 0.22400177f, -0.08564427f, 0.08395952f, 0.23896724f, 
    -0.09611756f, 0.16819628f, 0.10304031f, 0.11530046f, -0.25098658f, 0.30462214f, -0.24156258f, -0.03899588f, 
    0.00578276f, -0.07691671f, 0.03822050f, -0.04100487f, 0.10015807f, -0.15899043f, -0.08328675f, -0.08577445f, 
    -0.09210068f, 0.03206634f, 0.03751685f, 0.08277162f, -0.05582172f, -0.07137200f, 0.07925839f, 0.12909916f, 
    0.25649685f, 0.02408201f, -0.04942743f, -0.11375649f, -0.06071994f, -0.19582713f, 0.18791424f, -0.23057364f, 
    0.00596996f, 0.02300988f, 0.16264482f, 0.06090773f, -0.29383284f, -0.02710444f, 0.10898149f, 0.03576906f, 
    -0.06906632f, 0.19255958f, -0.02233077f, 0.20712857f, 0.00334049f, 0.18523934f, 0.24342334f, -0.00278901f, 
    -0.03881760f, 0.02378547f, -0.10893202f, -0.00057594f, 0.03993497f, -0.14624009f, -0.12444271f, 0.04433810f, 
    -0.02041827f, -0.00269619f, -0.00525933f, 0.01225725f, -0.10190084f, 0.07877561f, -0.13752988f, -0.02111900f, 
    -0.09132215f, -0.01694797f, -0.09247507f, -0.08720032f, 0.05060151f, -0.01991320f, 0.07806515f, 0.00415104f, 
    -0.07503691f, -0.04948668f, 0.03729634f, 0.02912873f, -0.00200098f, -0.00711674f, 0.01575373f, -0.09164859f, 
    0.10979070f, -0.01789467f, 0.12423526f, -0.00662313f, -0.00309408f, 0.04169936f, -0.02296762f, -0.10701256f, 
    -0.09530893f, -0.02641171f, -0.07098071f, -0.10918371f, 0.06457254f, -0.03241210f, -0.02006017f, 0.01463748f, 
    0.06939801f, -0.11018337f, -0.02044986f, 0.08108337f, -0.06737950f, 0.01149640f, -0.11252630f, -0.10264809f, 
    0.03606810f, -0.01660537f, -0.07050276f, -0.00933777f, -0.03926787f, -0.12814184f, -0.12226314f, -0.05920906f, 
    -0.14136635f, -0.00568360f, -0.06464559f, 0.07558693f, 0.01700877f, 0.00009198f, 0.02182415f, 0.07635568f, 
    -0.01896450f, -0.01408899f, -0.10664968f, 0.07972164f, -0.08768436f, -0.03644115f, -0.01381524f, 0.08270703f, 
    -0.09144809f, -0.11592977f, -0.09212425f, -0.12916735f, 0.00147345f, 0.07931854f, -0.16089612f, -0.02112192f, 
    -0.09659798f, -0.05607387f, 0.10675135f, 0.09870808f, 0.01367890f, 0.05120170f, -0.14471252f, 0.10108706f, 
    0.01690634f, 0.02030417f, -0.10966158f, 0.04652430f, 0.07932496f, 0.07262015f, -0.16209702f, -0.05573045f, 
    0.01852598f, 0.03127801f, -0.02053602f, -0.03871953f, -0.06469774f, -0.12210865f, 0.04733581f, -0.07855804f, 
    -0.02241874f, 0.12380424f, -0.10465033f, -0.12086566f, -0.10166039f, -0.08407872f, -0.07691054f, -0.11377732f, 
    -0.08671437f, -0.16304028f, -0.04242454f, -0.10527070f, 0.07861778f, 0.02388487f, 0.01643965f, -0.11339045f, 
    0.21108004f, 0.06731130f, -0.11776077f, 0.01319692f, -0.08952234f, -0.18482457f, 0.13303034f, 0.14193009f, 
    0.07441814f, 0.29438081f, -0.00165950f, 0.11617843f, -0.07460555f, 0.04670462f, 0.44346750f, -0.34805393f, 
    -0.18000606f, 0.18285468f, -0.00628518f, -0.18178859f, -0.02960959f, -0.18658382f, -0.38984370f, -0.31687391f, 
    0.09784047f, 0.06025007f, 0.05584337f, -0.03059386f, -0.00758551f, 0.15332799f, 0.01279888f, 0.08478226f, 
    0.12149708f, -0.01696168f, 0.01238458f, 0.12016391f, -0.05221712f, 0.26955396f, -0.16151002f, -0.05298476f, 
    0.06590167f, 0.11112763f, 0.08035812f, 0.08681289f, -0.14622548f, 0.13558897f, 0.19327646f, 0.12654345f, 
    -0.12622112f, -0.08401932f, 0.21746330f, -0.03196014f, 0.40906939f, -0.00906154f, -0.02172321f, -0.12318312f, 
    0.06192540f, -0.27700049f, -0.09305322f, 0.15778907f, 0.08236080f, -0.10697749f, 0.22102340f, 0.01680543f, 
    -0.08590036f, 0.08281415f, -0.13946152f, -0.02013451f, -0.10640350f, -0.07627918f, -0.04536946f, -0.12446765f, 
    0.03779750f, 0.01598368f, -0.06947579f, -0.02880025f, -0.01836655f, 0.02439795f, 0.02344437f, 0.01879029f, 
    -0.07116077f, 0.01848057f, -0.07820182f, -0.08664656f, 0.03001623f, -0.09802346f, 0.02798128f, 0.02064461f, 
    -0.11024542f, -0.01582083f, -0.05027323f, -0.04060988f, -0.10909583f, -0.10891647f, -0.10564144f, 0.04400134f, 
    -0.09089351f, 0.07927206f, 0.04435448f, 0.08333271f, -0.11268057f, -0.05931610f, -0.14359732f, 0.06787368f, 
    0.08015306f, 0.08955081f, 0.10919263f, 0.02646549f, 0.08843755f, 0.00921722f, -0.05131975f, -0.00229862f, 
    -0.00229097f, 0.09697199f, -0.16701880f, 0.12256463f, -0.06933584f, -0.03912630f, -0.00920005f, -0.09469303f, 
    -0.04832300f, 0.00437330f, -0.05758633f, -0.13098319f, 0.04625822f, 0.02414295f, -0.14478420f, 0.05107571f, 
    0.04222051f, -0.07556222f, -0.00620981f, -0.04306167f, -0.01764801f, -0.09956947f, 0.03734361f, 0.05333716f, 
    0.00642650f, -0.12894215f, -0.05556553f, -0.00816423f, -0.03916795f, -0.10974461f, 0.08264986f, -0.05941422f, 
    -0.04873076f, -0.13049091f, -0.10054058f, -0.13331151f, -0.08716856f, 0.07441430f, -0.04491439f, -0.09363674f, 
    -0.00193424f, -0.03646810f, 0.01289217f, 0.09085692f, -0.09430430f, -0.01644183f, 0.06238767f, -0.08564976f, 
    0.02251911f, -0.07218900f, 0.06513773f, -0.02386549f, -0.05664927f, -0.04007926f, -0.07087233f, 0.00188150f, 
    -0.03094160f, -0.10280763f, -0.02880274f, -0.09785659f, -0.08337538f, 0.07294424f, -0.07928782f, -0.08894151f, 
    -0.05806265f, -0.02418886f, -0.04965064f, -0.02595884f, 0.03687405f, -0.11620925f, 0.08023924f, -0.09730412f, 
    -0.10155809f, 0.07275158f, -0.03341204f, -0.09973300f, 0.02556733f, 0.02466107f, -0.11460648f, 0.07261819f, 
    0.14161901f, -0.12285537f, -0.14605685f, -0.02615364f, 0.33530304f, -0.34349963f, 0.17904231f, 0.19361518f, 
    -0.02420865f, 0.13118041f, -0.21100289f, -0.07447386f, -0.02668385f, -0.06839956f, 0.41249609f, -0.15885335f, 
    -0.11191960f, 0.15705864f, 0.08154719f, 0.18608509f, 0.05378125f, 0.07824090f, 0.09972535f, -0.01918512f, 
    -0.12920827f, 0.06486752f, 0.04801808f, -0.07917830f, 0.10720102f, 0.19488977f, 0.08677647f, -0.08212519f, 
    0.11215501f, -0.02878609f, -0.06534500f, -0.09271485f, 0.02646132f, 0.02828020f, -0.20871757f, -0.15463001f, 
    -0.18207175f, 0.10627836f, 0.04340852f, 0.10835283f, -0.05954109f, 0.06259966f, -0.12086922f, 0.18296041f, 
    0.04867435f, -0.10685442f, -0.05421695f, -0.06816251f, 0.31745043f, 0.17547065f, -0.02953019f, 0.07872803f, 
    -0.07213362f, -0.26834053f, -0.07204653f, 0.14022973f, -0.02217019f, 0.04932351f, 0.24603271f, 0.11305167f, 
    -0.09255901f, 0.08032842f, -0.07168757f, 0.10094935f, 0.06469660f, 0.01951250f, 0.00979321f, -0.15923479f, 
    -0.02742929f, -0.02626346f, -0.06507945f, 0.05540083f, 0.03220539f, -0.07990113f, 0.07617585f, 0.01429566f, 
    0.05355478f, -0.04303453f, -0.06838720f, -0.03928217f, -0.11552620f, -0.08160669f, 0.01081114f, 0.03144499f, 
    -0.11303362f, 0.10305218f, 0.10811465f, 0.06497572f, -0.06441126f, 0.02341053f, -0.05920779f, 0.00106920f, 
    -0.00544487f, 0.10047659f, 0.01032976f, 0.02199611f, -0.00525194f, 0.00872759f, -0.05960076f, -0.16441618f, 
    0.02481661f, 0.11409805f, -0.04802258f, 0.03257721f, 0.02491212f, -0.17640528f, -0.14409959f, -0.01091852f, 
    -0.12093165f, 0.01599781f, 0.00630678f, -0.10793161f, -0.04574952f, -0.11836152f, 0.09446301f, -0.00164368f, 
    0.05728189f, -0.19693135f, 0.02789097f, -0.12521531f, -0.00760457f, 0.06804951f, 0.11004227f, 0.09362909f, 
    0.31336179f, 0.00788992f, -0.14201695f, 0.00794320f, 0.10757442f, -0.19784722f, 0.11794643f, 0.15689254f, 
    -0.04808821f, 0.28540558f, 0.09255613f, 0.00616833f, 0.01978911f, -0.02264283f, 0.34608737f, 0.11662202f, 
    -0.08338216f, 0.04529219f, 0.25822437f, -0.09611000f, -0.34903249f, 0.05232873f, -0.10916983f, 0.05123217f, 
    -0.42456418f, -0.12267105f, 0.07473759f, -0.12842476f, 0.13112767f, 0.11196109f, -0.00611513f, -0.00580960f, 
    -0.04142164f, -0.03745416f, 0.06443668f, -0.01206246f, -0.05266544f, 0.27301010f, -0.31432170f, -0.01823935f, 
    0.24008356f, -0.04239785f, 0.12296052f, -0.03293683f, -0.13795090f, -0.30541560f, 0.14809187f, -0.01783797f, 
    0.19312298f, 0.00464324f, -0.01712164f, 0.06006021f, 0.24536590f, 0.16238344f, 0.08788399f, 0.08942366f, 
    0.11522155f, -0.14402188f, 0.00547832f, 0.00478626f, 0.25729394f, -0.03716280f, 0.30725190f, -0.03693273f, 
    0.29260817f, 0.09973890f, 0.16401008f, -0.07434552f, -0.17715436f, -0.00587651f, 0.08430567f, 0.08054335f, 
    0.10890077f, -0.09591722f, 0.32208121f, -0.08761729f, -0.00534138f, -0.07948045f, 0.02739017f, 0.03731588f, 
    -0.11495540f, 0.26235485f, 0.09172162f, -0.16553891f, 0.33567673f, -0.22205177f, -0.11628707f, 0.01420447f, 
    0.16711628f, 0.01798151f, 0.06731663f, 0.10209795f, 0.03645897f, -0.31716847f, 0.15325218f, 0.09768818f, 
    -0.00517688f, 0.04466548f, 0.01114730f, -0.03016114f, -0.08010036f, 0.43021819f, -0.05558934f, -0.18377550f, 
    -0.03470451f, 0.05068842f, -0.04955582f, 0.21764340f, -0.09782086f, 0.39362660f, -0.00026403f, -0.05132209f, 
    -0.10107055f, 0.05122227f, 0.09728639f, -0.05799529f, 0.18624340f, 0.10010933f, -0.04909919f, 0.10391777f, 
    -0.02363485f, 0.17306830f, -0.12515865f, 0.04364488f, -0.06524378f, -0.09355013f, -0.34834000f, -0.00106789f, 
    0.30624425f, -0.07079244f, -0.26546478f, -0.02756140f, 0.19870287f, 0.25627539f, 0.21804850f, -0.11150343f, 
    0.05501948f, 0.04349485f, 0.05050021f, 0.03516166f, 0.16895723f, -0.02849130f, -0.21432443f, 0.08518795f, 
    0.21410125f, -0.13107128f, -0.24471407f, 0.05189323f, 0.32205099f, -0.12024059f, -0.11138950f, -0.29421034f, 
    0.13666010f, -0.08005837f, -0.08692493f, 0.06710766f, -0.10469592f, 0.02662363f, 0.09332001f, -0.12284879f, 
    -0.02517471f, -0.02937138f, -0.09664413f, 0.06426474f, 0.06614317f, -0.02773579f, -0.01325933f, 0.24990460f, 
    -0.12734134f, 0.00059356f, 0.07906519f, 0.00898653f, -0.09985505f, -0.15485997f, 0.03659635f, 0.26053002f, 
    -0.04155898f, 0.10018392f, -0.07885039f, 0.02065606f, -0.17420232f, -0.03704746f, 0.03800762f, -0.08840830f, 
    -0.02140163f, -0.04042275f, 0.06249158f, -0.15707499f, 0.15619546f, 0.01676262f, 0.06233792f, -0.00453302f, 
    0.36660847f, 0.07046951f, -0.30228299f, -0.05755800f, 0.29186699f, -0.00082106f, 0.18455082f, -0.27222532f, 
    0.11694360f, 0.10381113f, -0.13052343f, -0.06287510f, 0.04992871f, 0.04398173f, -0.34223631f, 0.00536793f, 
    0.27469546f, -0.10432249f, -0.12003258f, 0.13022551f, 0.17749113f, -0.06882780f, -0.22006485f, -0.14337924f, 
    0.08292369f, 0.08765951f, 0.01028129f, -0.04702442f, 0.03228766f, -0.12539971f, 0.12685622f, 0.01843673f, 
    0.03611653f, -0.09351796f, 0.06601545f, -0.11329859f, -0.00586030f, -0.15109025f, -0.09706687f, 0.13686366f, 
    -0.00724189f, -0.10044318f, -0.06701438f, 0.01569296f, -0.05190803f, -0.24891877f, 0.01459138f, 0.25348836f, 
    0.10550831f, 0.00287610f, -0.13665649f, 0.10077786f, -0.06988397f, 0.21502714f, -0.01882511f, 0.08851080f, 
    0.07940556f, -0.22806698f, -0.07323041f, -0.27576882f, 0.14402665f, 0.23362993f, 0.12232235f, -0.07622068f, 
    -0.01782938f, -0.02851214f, 0.11094313f, -0.10660720f, -0.24299902f, -0.14153479f, 0.34967405f, 0.08747268f, 
    -0.06492628f, 0.42521808f, 0.43446621f, -0.08701337f, -0.01989317f, 0.07247874f, 0.09547403f, -0.07771254f, 
    -0.03152703f, 0.12253451f, 0.13737194f, -0.20421083f, 0.14826640f, 0.22464612f, -0.20958287f, -0.15741244f, 
    -0.36313218f, -0.04594406f, -0.00802887f, 0.02464107f, 0.12245413f, 0.11171088f, 0.07322524f, 0.02070298f, 
    0.04175995f, 0.03629120f, -0.00491019f, -0.02630136f, 0.11141439f, 0.18236676f, -0.17204235f, -0.22981787f, 
    0.14769624f, -0.01617658f, -0.03814387f, 0.11734530f, 0.11736720f, -0.10250476f, 0.11261882f, -0.23189920f, 
    -0.15312731f, 0.06557879f, 0.30090499f, 0.01330091f, 0.10551485f, 0.24466562f, 0.07214066f, -0.09619419f, 
    0.03908541f, 0.06755736f, -0.00869727f, 0.09045199f, 0.08071134f, 0.11417463f, 0.16900192f, -0.09794110f, 
    0.12436011f, 0.12146033f, 0.05867272f, -0.10389788f, 0.22269326f, 0.10442743f, -0.11079148f, -0.29638687f, 
    0.09449232f, 0.18737203f, 0.12973151f, -0.09269962f, -0.25816569f, -0.04248674f, -0.18756816f, 0.08292230f, 
    -0.02910776f, -0.13241231f, 0.18520565f, 0.19008744f, 0.19530383f, -0.02717994f, -0.18574776f, -0.14484672f, 
    0.06956473f, 0.08623070f, 0.11560281f, -0.03549843f, 0.01824464f, -0.23180871f, 0.36218560f, -0.00286639f, 
    -0.02421074f, -0.06413145f, -0.10998019f, 0.00424769f, 0.06553929f, 0.01893643f, -0.28440434f, -0.05519984f, 
    0.39343855f, -0.09026200f, -0.01360607f, 0.15341268f, -0.12311926f, 0.14799128f, 0.01351061f, 0.17631845f, 
    -0.03283006f, -0.01967837f, 0.20566538f, 0.00204260f, 0.02439036f, 0.26196656f, -0.00653832f, 0.06814712f, 
    0.10258690f, -0.09333557f, -0.00746145f, 0.04216395f, 0.43482488f, 0.06726789f, 0.26718608f, 0.10754877f, 
    -0.02879964f, 0.00437035f, 0.01536704f, -0.04966868f, 0.10047929f, 0.10374551f, -0.12441279f, -0.04471056f, 
    0.07501469f, 0.28182638f, -0.39530626f, -0.04094359f, 0.25566369f, 0.00976302f, 0.08531806f, -0.10704557f, 
    0.03444832f, 0.03309251f, -0.24618900f, 0.15436095f, -0.01496276f, -0.22833306f, -0.11380935f, -0.16672486f, 
    0.10930857f, -0.03584190f, 0.08681568f, 0.12299132f, 0.29618457f, -0.26343814f, -0.13486663f, -0.07003921f, 
    0.12134527f, 0.07216676f, 0.12109529f, -0.03440220f, 0.05623519f, 0.20753869f, 0.09860820f, 0.22675319f, 
    -0.06261923f, 0.08480728f, -0.01420898f, -0.05430899f, 0.09343513f, 0.28522089f, -0.06306012f, 0.10260750f, 
    0.01458220f, 0.03603675f, 0.23887686f, -0.11714320f, 0.14081733f, -0.09243450f, 0.09040475f, -0.01194814f, 
    -0.03670981f, -0.01407137f, 0.07880086f, -0.06595699f, 0.09039959f, -0.02578234f, 0.21770048f, -0.05825987f, 
    -0.09838997f, -0.03257034f, 0.10690274f, 0.08699723f, 0.09520223f, 0.34364042f, -0.38501784f, 0.00198480f, 
    -0.03901936f, -0.13692610f, -0.12567092f, 0.00078807f, -0.12715313f, 0.09789166f, -0.27178514f, 0.04131339f, 
    0.11392181f, -0.09456743f, -0.20561694f, 0.10379876f, -0.01203436f, 0.07429108f, 0.18406819f, 0.00888498f, 
    0.35616785f, -0.02220253f, -0.06292529f, 0.06777658f, 0.21350220f, 0.01170949f, -0.09779153f, 0.06838623f, 
    0.09659566f, -0.02509211f, -0.08013981f, 0.00020368f, 0.06113441f, -0.17975013f, -0.16027176f, 0.19149743f, 
    0.37597162f, -0.06333041f, -0.07821429f, 0.10771741f, -0.06506410f, 0.45595714f, 0.05149364f, 0.05220411f, 
    0.01942160f, 0.11775467f, 0.15133908f, -0.04761013f, 0.16424727f, 0.09159873f, 0.05558165f, -0.03245651f, 
    -0.04800443f, 0.15363680f, 0.03101444f, 0.14156964f, 0.19227229f, 0.17627497f, -0.07510316f, -0.03244412f, 
    0.03824816f, 0.11091246f, -0.13085218f, -0.01068938f, -0.04107200f, 0.00256001f, -0.07349705f, -0.11598279f, 
    0.09010436f, 0.02109844f, -0.14019847f, -0.11344223f, 0.02316427f, -0.11003812f, -0.13852322f, -0.06191391f, 
    -0.05742924f, -0.00988726f, -0.10790787f, -0.13953386f, -0.06040113f, -0.02192383f, -0.03219622f, -0.11513442f, 
    -0.12706520f, -0.12195256f, 0.08877140f, -0.06098795f, 0.08549654f, -0.13376705f, -0.12625073f, -0.00265948f, 
    0.03489083f, -0.11753491f, -0.08690313f, -0.09576693f, -0.00893258f, 0.06098587f, 0.04944329f, -0.00267370f, 
    0.03722164f, -0.03441167f, 0.10891921f, -0.01858077f, -0.03032622f, -0.07872526f, 0.01541161f, 0.09196106f, 
    0.04408102f, 0.04248351f, -0.13453916f, 0.06601827f, 0.03142350f, 0.07351830f, 0.10924261f, 0.05258685f, 
    0.02821845f, -0.06831652f, 0.10923450f, 0.08579344f, -0.14739965f, -0.11772469f, -0.01910552f, -0.08030227f, 
    -0.15956050f, 0.02178953f, -0.03550258f, 0.01868553f, 0.06166456f, -0.21681552f, -0.00090129f, 0.08771262f, 
    -0.10457604f, 0.25081283f, -0.00757388f, -0.09215333f, -0.09740789f, 0.08571015f, 0.29691902f, -0.06747074f, 
    -0.00558555f, 0.10072257f, -0.34357032f, 0.23704246f, 0.20324709f, -0.03951763f, 0.04229765f, -0.01814950f, 
    0.02877330f, 0.07535274f, 0.10523310f, -0.04022123f, 0.44551584f, -0.08778919f, 0.10207212f, 0.07296935f, 
    -0.00623840f, 0.11461812f, -0.09273011f, -0.02819677f, 0.06481610f, 0.15372987f, -0.08436283f, 0.02924278f, 
    -0.18593194f, -0.10854591f, -0.12153561f, 0.00000423f, -0.02185458f, 0.20133151f, -0.14030091f, 0.16062890f, 
    0.11978386f, -0.01327856f, 0.34759533f, 0.06129321f, 0.20768338f, 0.17860100f, 0.09853410f, 0.03738757f, 
    -0.09086113f, 0.08104590f, 0.02485955f, -0.08720990f, 0.12141363f, 0.09376715f, 0.21397066f, 0.06050707f, 
    0.15808561f, 0.01470136f, 0.18879737f, -0.12270763f, -0.02518855f, -0.05783284f, 0.16966169f, 0.29373074f, 
    -0.09564731f, -0.54274529f, -0.13656057f, -0.11399358f, -0.31002375f, 0.11769839f, -0.10823736f, -0.11327281f, 
    0.18886107f, -0.11687344f, -0.02011254f, 0.06136322f, 0.31140876f, -0.27054298f, 0.29062352f, 0.24245749f, 
    -0.18842915f, 0.09521976f, -0.03704260f, -0.08108954f, 0.20032513f, 0.21168524f, 0.22994407f, -0.04708574f, 
    0.04580910f, 0.00390861f, 0.07540798f, -0.05515413f, -0.00944294f, 0.37650543f, 0.13026010f, 0.05164194f, 
    -0.14455993f, 0.07529663f, 0.01831895f, -0.06037766f, 0.09509048f, -0.05051519f, -0.36727390f, 0.24905643f, 
    0.21300472f, -0.00022346f, -0.27265799f, -0.03833967f, 0.11267501f, 0.12397198f, -0.03466089f, 0.03694996f, 
    -0.12724762f, 0.16781743f, 0.08640549f, -0.20301320f, 0.02482007f, -0.01468559f, -0.08818305f, -0.09196647f, 
    0.01982973f, -0.00562260f, 0.03178539f, -0.10994656f, 0.11664490f, -0.10782339f, 0.09843654f, 0.05820858f, 
    0.11453921f, -0.27816948f, 0.20243916f, -0.11383297f, -0.26286417f, 0.11187853f, -0.37480205f, 0.17519733f, 
    -0.16416642f, -0.17203242f, 0.07017498f, 0.08270080f, 0.27039361f, 0.13612823f, 0.29081175f, 0.17630173f, 
    -0.09201050f, -0.08125282f, 0.06311717f, -0.08234631f, 0.39216557f, -0.23216990f, 0.14190483f, -0.12465772f, 
    0.05104438f, 0.11790416f, -0.07630854f, 0.00787717f, -0.02401835f, 0.13827060f, -0.23826575f, 0.00454937f, 
    0.14965700f, -0.06752161f, 0.04391790f, 0.16435753f, -0.07251182f, -0.14864573f, -0.21348321f, 0.02386321f, 
    0.25082418f, 0.02217445f, 0.03729508f, -0.03161845f, -0.22896595f, 0.30679196f, 0.02920195f, -0.12877497f, 
    -0.06071302f, 0.01524480f, -0.07628149f, -0.08015994f, 0.27141860f, 0.02308094f, -0.00657786f, 0.02562942f, 
    0.10514056f, 0.01352619f, -0.30786943f, -0.12015981f, -0.08861738f, 0.19333929f, -0.26681823f, 0.16414864f, 
    -0.03687787f, 0.24024498f, -0.18764885f, -0.02773516f, 0.03522561f, -0.07495492f, 0.27828979f, -0.27618152f, 
    0.16632600f, 0.04967491f, 0.22432561f, -0.09546586f, -0.15145235f, -0.14763945f, -0.25964221f, -0.41249219f, 
    0.23638728f, 0.04630564f, 0.04642287f, 0.06309409f, -0.05683773f, 0.31378239f, -0.03448376f, -0.10922909f, 
    -0.01247947f, 0.01168909f, 0.11046192f, -0.06761905f, -0.04157878f, 0.17178182f, 0.21601054f, 0.22945085f, 
    -0.10610036f, 0.05550900f, -0.11255287f, -0.09201395f, 0.03246959f, 0.03992311f, 0.08387093f, 0.18418223f, 
    0.07421020f, 0.03955313f, -0.07535940f, 0.01964439f, 0.35745299f, -0.25610536f, -0.03304362f, -0.06876230f, 
    0.02206832f, -0.25210720f, 0.03282383f, 0.13405174f, -0.00606243f, 0.02963035f, 0.42952001f, 0.06389648f, 
    0.01152636f, 0.08398627f, 0.41557160f, 0.11159761f, -0.09115518f, 0.16416919f, 0.01189963f, 0.05768374f, 
    0.00396025f, -0.32959643f, 0.26543555f, -0.04070035f, -0.13613972f, -0.05159160f, -0.36356285f, 0.23338261f, 
    -0.01224799f, 0.10469727f, 0.20216647f, 0.08407361f, -0.09901801f, -0.04485188f, 0.11288428f, 0.44592682f, 
    -0.12932658f, -0.02901710f, 0.12007189f, -0.01841037f, -0.02415910f, -0.15624002f, 0.11191664f, 0.01599314f, 
    -0.11431783f, -0.07515597f, -0.05241358f, 0.09387758f, -0.05654440f, -0.14995559f, -0.10156190f, -0.04551198f, 
    0.47352836f, -0.07768836f, 0.10713722f, 0.10164386f, 0.08331449f, -0.02626837f, -0.03127520f, 0.10639279f, 
    0.18467499f, -0.09137579f, -0.15045115f, -0.00949429f, -0.05587624f, 0.25095737f, -0.09733725f, -0.06115085f, 
    -0.10536900f, 0.32449841f, -0.07729769f, 0.08013868f, 0.14557733f, -0.00206607f, -0.13258478f, -0.05307140f, 
    0.02054249f, -0.12324654f, -0.12467727f, -0.08892819f, -0.15414433f, -0.01214539f, 0.18518868f, -0.01115953f, 
    -0.08804300f, 0.19190685f, -0.02912870f, -0.10889041f, 0.16053392f, -0.08327279f, 0.36326355f, -0.11424974f, 
    0.14133197f, 0.05973396f, -0.23050036f, 0.14170316f, -0.54204035f, 0.26129609f, 0.03808492f, 0.17158446f, 
    -0.39736828f, -0.09858606f, -0.00438309f, -0.11735670f, 0.13857117f, 0.00739850f, -0.35144839f, 0.10243689f, 
    -0.08154549f, 0.08722544f, -0.08889581f, 0.03458045f, -0.09854277f, 0.02089794f, 0.11092790f, 0.15769078f, 
    0.19696474f, -0.05634830f, 0.05857852f, -0.13040625f, 0.08069799f, -0.00360864f, 0.26072893f, -0.11693998f, 
    -0.03858418f, -0.11625787f, 0.00216490f, -0.03332884f, 0.07536441f, -0.00067820f, -0.04361322f, 0.00188236f, 
    0.06090438f, -0.11264789f, -0.00648487f, 0.25685719f, 0.04614505f, 0.02447417f, 0.05985726f, 0.03634186f, 
    0.06056356f, -0.07952034f, -0.05164693f, -0.10065387f, 0.03890256f, -0.04776862f, -0.01053507f, 0.06400727f, 
    -0.07593138f, -0.02117278f, -0.03745401f, 0.05250257f, -0.07041262f, 0.10458677f, 0.03468631f, -0.12250489f, 
    -0.10989156f, 0.05869776f, 0.00592008f, 0.01539385f, 0.00017609f, -0.13674538f, -0.03217208f, -0.14056669f, 
    -0.09632025f, 0.03732845f, -0.05579861f, 0.10616373f, -0.00482402f, 0.03025793f, -0.07987667f, -0.05363527f, 
    0.07436504f, 0.01699769f, 0.09346709f, 0.05013729f, -0.05329781f, 0.03511317f, -0.11653974f, -0.14172940f, 
    0.04654496f, -0.01903480f, -0.01199801f, 0.03010815f, 0.11221679f, -0.08821027f, -0.10467717f, -0.09993140f, 
    -0.14422113f, 0.10458986f, -0.15270892f, 0.05848376f, -0.07448336f, -0.09513077f, -0.11759910f, 0.05161534f, 
    0.08301788f, 0.09149496f, 0.02521213f, 0.08298327f, -0.06764898f, 0.04890073f, -0.09124704f, -0.10278502f, 
    0.18418331f, 0.09525042f, -0.01977372f, -0.02039650f, -0.27252847f, 0.36343881f, -0.33936000f, 0.19427335f, 
    -0.11682932f, -0.11852749f, 0.01955418f, -0.05422797f, 0.05844997f, 0.07324944f, -0.31209084f, -0.10868996f, 
    0.15074651f, 0.02245106f, 0.12209128f, -0.11747424f, -0.45413476f, 0.01443654f, -0.00711336f, 0.23805138f, 
    -0.20506422f, 0.12372850f, 0.03945287f, -0.11591844f, -0.01859026f, 0.17181005f, -0.20046553f, -0.11047812f, 
    -0.11335199f, 0.11190788f, 0.01031051f, 0.06923962f, -0.12447295f, 0.26009163f, 0.06630204f, 0.26030579f, 
    0.55997926f, 0.10170566f, 0.01621752f, -0.06585115f, -0.06201745f, -0.12855609f, -0.04443099f, -0.08767557f, 
    0.12659803f, 0.09156857f, -0.31221089f, 0.06717286f, -0.02271907f, -0.01165096f, 0.04891142f, 0.04060617f, 
    0.09384008f, 0.10285173f, 0.05765750f, 0.17604564f, -0.15344827f, -0.01508094f, -0.16463451f, 0.04744446f, 
    -0.16753277f, -0.11601345f, 0.21633714f, -0.06860352f, -0.16027436f, 0.17930788f, -0.17375688f, 0.27628815f, 
    0.10345083f, 0.06414368f, -0.20816261f, -0.09184616f, 0.48249850f, -0.01774621f, 0.47251302f, 0.16356182f, 
    -0.17999932f, 0.20758313f, 0.01403049f, 0.18698844f, -0.14197579f, 0.06892163f, 0.08501477f, 0.12037735f, 
    0.08733083f, -0.08566149f, 0.00473271f, -0.00117087f, 0.17250815f, -0.14318013f, -0.14028862f, 0.10069195f, 
    0.00135934f, 0.10092551f, 0.02193191f, 0.02356266f, -0.00630633f, 0.16293076f, 0.34394163f, 0.16436696f, 
    -0.16750248f, -0.12390907f, 0.10377113f, 0.03515298f, -0.08243439f, 0.18654135f, 0.16350663f, -0.10447068f, 
    0.21526287f, -0.03807028f, -0.03013708f, -0.03226024f, -0.09003107f, -0.03801298f, 0.10390610f, 0.04630703f, 
    0.04908660f, 0.20374857f, -0.10833496f, 0.25689399f, -0.23896669f, -0.25014797f, 0.08726316f, 0.01767445f, 
    -0.04731608f, 0.10299059f, 0.10384239f, 0.11064641f, -0.14914861f, 0.29270932f, -0.17580442f, 0.07277817f, 
    -0.11494728f, -0.11320101f, -0.21570447f, 0.10265180f, 0.13345586f, -0.02642687f, 0.05400124f, -0.22191736f, 
    0.13928522f, -0.11875456f, 0.01033747f, 0.01245254f, 0.33453748f, -0.23674205f, 0.02948112f, -0.03012433f, 
    0.19590418f, -0.03380121f, -0.05946634f, -0.03561097f, -0.03007170f, 0.05761474f, -0.11216589f, 0.09419850f, 
    0.02897637f, 0.11387121f, -0.10973793f, -0.06189401f, -0.08567421f, 0.37321606f, 0.42776710f, 0.22118667f, 
    -0.22400281f, 0.09852270f, 0.05875873f, 0.05998445f, -0.09104816f, 0.17118436f, -0.03131010f, 0.26500440f, 
    0.14940658f, -0.10108075f, 0.11710378f, -0.04854209f, 0.03872282f, -0.20872816f, 0.09804686f, 0.07706948f, 
    -0.08079185f, 0.16488197f, -0.04479406f, -0.05162472f, -0.19637358f, -0.18386316f, -0.00649487f, 0.06933920f, 
    0.16794270f, 0.08300325f, -0.00626615f, -0.08342017f, 0.25553250f, 0.23550519f, 0.24336259f, 0.07399853f, 
    -0.06126155f, -0.11369594f, -0.31431863f, 0.06087162f, 0.06201555f, -0.10617448f, 0.12310258f, 0.14400876f, 
    0.28362861f, -0.16463810f, 0.12285490f, 0.15753423f, -0.06430296f, -0.07321697f, 0.31200820f, 0.04554677f, 
    -0.01757739f, 0.10922178f, -0.05255937f, -0.03853569f, 0.00818988f, 0.39014488f, 0.08781824f, -0.00362482f, 
    -0.05937775f, 0.00953736f, -0.08433421f, 0.09672234f, -0.04670097f, -0.09706019f, 0.24254967f, 0.23247914f, 
    -0.06481849f, 0.04020611f, -0.03196207f, -0.08678831f, -0.03051523f, -0.42886221f, -0.23673743f, 0.01859018f, 
    0.20547551f, -0.04209283f, -0.48813394f, 0.10390213f, -0.24348675f, -0.10025452f, -0.00624210f, 0.07601926f, 
    0.03953541f, -0.08687674f, -0.00735390f, 0.08085658f, -0.05459539f, 0.11130136f, 0.27909172f, -0.11798850f, 
    -0.27660096f, -0.09570953f, 0.12390199f, 0.00800450f, -0.04872951f, -0.25341451f, 0.23582210f, -0.04562491f, 
    0.06356433f, 0.38309184f, 0.16437392f, 0.08522970f, 0.04723077f, -0.05583258f, 0.43379340f, -0.00316941f, 
    -0.09315004f, 0.08097699f, 0.03386735f, -0.06095274f, 0.04465956f, 0.23255746f, -0.25364950f, -0.06160633f, 
    -0.28603092f, 0.04573198f, -0.00957225f, -0.12381861f, 0.27043784f, -0.08889094f, 0.06681802f, -0.11789437f, 
    0.11751507f, 0.09076525f, -0.02549369f, 0.12591182f, 0.06578892f, 0.12016567f, -0.13211083f, -0.23438586f, 
    -0.08549493f, 0.05159188f, -0.03062068f, 0.24569578f, 0.11674776f, 0.03973600f, 0.14293441f, -0.10550028f, 
    -0.06132478f, -0.00955859f, 0.23878577f, 0.08632062f, 0.01685031f, 0.02061105f, 0.03571836f, 0.09594717f, 
    0.11167694f, -0.00223758f, 0.00040437f, 0.21135196f, 0.15648766f, -0.04760512f, -0.13196491f, 0.09377414f, 
    0.21686769f, -0.11393818f, 0.05758103f, -0.01825534f, 0.14875239f, 0.08137072f, 0.02417001f, 0.02649967f, 
    -0.12909724f, -0.14332941f, -0.03255987f, 0.02000914f, -0.02650606f, 0.04489183f, 0.14343011f, 0.26094082f, 
    -0.03204592f, -0.13311230f, 0.45242700f, 0.11293611f, -0.18472990f, -0.14353843f, 0.16729532f, 0.19999737f, 
    0.04642130f, -0.08371940f, -0.02058091f, 0.10773738f, -0.19247434f, 0.22701079f, 0.33774114f, -0.03509884f, 
    0.04384192f, 0.04101999f, -0.03615268f, -0.03099283f, -0.07593898f, -0.14407505f, -0.17601617f, -0.06533924f, 
    0.20750511f, 0.02656998f, -0.06038898f, 0.05367466f, 0.03937646f, -0.29209396f, -0.02219781f, 0.16728103f, 
    0.27865365f, -0.01529519f, -0.39044341f, -0.01887554f, 0.08853989f, -0.00113799f, 0.01197890f, 0.01126512f, 
    0.01173753f, -0.18279351f, 0.09833060f, 0.00321968f, 0.14249383f, 0.04116466f, 0.17053771f, 0.11895888f, 
    -0.02673924f, 0.05588315f, 0.00629088f, -0.03346213f, -0.08333329f, 0.00511976f, -0.09630354f, 0.10849821f, 
    0.02819017f, -0.02513288f, -0.07911914f, 0.06826709f, -0.02079264f, -0.09733921f, -0.12223522f, -0.02868876f, 
    -0.13194050f, 0.08376847f, 0.10766240f, 0.10035966f, -0.05538835f, -0.02037728f, 0.11121369f, 0.00134285f, 
    -0.12623377f, -0.01904827f, 0.00547210f, 0.00815724f, 0.03273372f, -0.08750835f, -0.10757333f, 0.05381639f, 
    -0.08925438f, 0.12286779f, 0.10583091f, -0.06925831f, -0.11444166f, -0.00579201f, 0.02229059f, -0.10319787f, 
    -0.07606845f, 0.10012496f, 0.07983675f, -0.00511547f, -0.04033117f, -0.05768568f, -0.08935869f, -0.06537189f, 
    -0.12439832f, -0.11483479f, 0.06104344f, -0.11459449f, 0.06545198f, -0.08242004f, -0.00797777f, 0.09382967f, 
    -0.01731495f, -0.00854759f, -0.03787277f, -0.04724223f, -0.04071594f, -0.00325417f, -0.05981615f, -0.09176624f, 
    -0.05205233f, -0.04922163f, 0.23588362f, 0.09978725f, 0.23646946f, 0.01638559f, 0.05837240f, 0.10070661f, 
    -0.06406631f, -0.16456096f, -0.34748459f, -0.05850257f, -0.04558124f, -0.05915701f, 0.29960588f, -0.14810243f, 
    0.18117340f, -0.12801027f, -0.18816604f, 0.23791145f, -0.07917090f, -0.15470342f, 0.38324887f, 0.15646005f, 
    0.29775950f, -0.01495138f, 0.11760594f, -0.03035481f, 0.19225310f, -0.06354179f, 0.11897038f, -0.03525728f, 
    -0.11178962f, 0.11333043f, -0.05892466f, -0.07591670f, 0.06971511f, -0.27996400f, 0.13087447f, 0.08937716f, 
    -0.10772093f, 0.00826910f, 0.05789610f, 0.19128750f, -0.00587771f, 0.19566527f, -0.06270193f, 0.34666047f, 
    0.13813680f, 0.02134104f, -0.10243449f, -0.03064663f, 0.21963014f, -0.17948015f, -0.01345248f, -0.02713399f, 
    0.11401638f, -0.23738997f, 0.06421054f, 0.09520029f, -0.08670693f, 0.16371918f, -0.19291128f, -0.03131125f, 
    -0.11400484f, -0.03961294f, 0.02121210f, -0.10915091f, 0.01414011f, 0.05017842f, 0.07494262f, -0.14423534f, 
    0.00136533f, -0.15398784f, -0.11999268f, -0.01668138f, -0.07277422f, -0.06025779f, -0.10083582f, -0.13251849f, 
    0.03531710f, -0.12666978f, 0.01791798f, -0.00569448f, -0.10845576f, 0.03327423f, 0.08694126f, -0.01220458f, 
    0.01009636f, 0.04121216f, -0.08180077f, -0.02838688f, -0.06508567f, 0.00770953f, -0.06734746f, 0.00464055f, 
    0.05864695f, -0.10820374f, -0.04380413f, 0.01131089f, 0.09689835f, -0.13181475f, -0.04788584f, -0.10320909f, 
    -0.06532212f, 0.02440698f, -0.08299959f, -0.02646164f, 0.00112031f, 0.02704940f, -0.05292540f, -0.14574252f, 
    -0.07521130f, -0.05846369f, 0.12413443f, -0.10100115f, -0.08310191f, -0.15695906f, 0.09031285f, 0.03826147f, 
    -0.10669325f, 0.03160183f, 0.00910178f, 0.03030250f, 0.01488213f, -0.11468732f, 0.02073007f, 0.03314804f, 
    0.05305998f, -0.11857347f, 0.14569560f, 0.04509167f, -0.07425810f, -0.13580732f, 0.43334290f, 0.05422523f, 
    0.11344859f, -0.19895758f, 0.34994346f, -0.02374390f, -0.02296069f, -0.00636287f, -0.27065551f, 0.34546101f, 
    0.23272957f, 0.14208755f, 0.07945705f, 0.00305171f, 0.38836265f, 0.38496700f, -0.02022029f, 0.21897320f, 
    0.10373922f, 0.03497287f, 0.06730498f, 0.11455218f, -0.22577168f, 0.04488545f, -0.02580154f, 0.00940223f, 
    0.03686249f, -0.11714538f, -0.09132650f, 0.06653711f, -0.10542822f, -0.16858396f, 0.21835133f, -0.20723210f, 
    0.07908230f, -0.02624953f, -0.06421533f, 0.26661414f, 0.09118330f, 0.05261944f, -0.03836278f, -0.02657843f, 
    0.00885303f, -0.04503744f, -0.19143108f, 0.07646552f, -0.00788029f, 0.00091104f, -0.12480710f, 0.00169769f, 
    0.07288107f, 0.18402991f, -0.09701757f, 0.09846249f, -0.18291560f, 0.27479565f, -0.35907334f, -0.04788265f, 
    -0.04891393f, -0.09808695f, 0.16623607f, 0.03262767f, 0.08012320f, -0.00726200f, 0.29503196f, -0.18676648f, 
    0.05209875f, 0.26046667f, 0.26805398f, -0.12284809f, -0.30082318f, 0.12391541f, -0.25029567f, -0.10892164f, 
    0.26408601f, 0.17645955f, -0.06073961f, 0.17585471f, -0.02130224f, 0.17777626f, -0.05451846f, -0.08267569f, 
    -0.04883589f, 0.06106215f, 0.05846385f, 0.10425241f, 0.02061009f, -0.02423302f, 0.16071586f, 0.05456070f, 
    -0.08859659f, 0.06625941f, 0.02291485f, 0.07679596f, 0.00756653f, -0.30172226f, -0.21575828f, -0.02671835f, 
    0.27540740f, 0.04770448f, 0.01096450f, 0.15414757f, 0.02612715f, 0.02194245f, 0.01912314f, 0.08029260f, 
    -0.08682058f, 0.05830739f, 0.12451059f, 0.06850681f, 0.03640044f, 0.32751888f, 0.12761442f, 0.05479962f, 
    0.01550499f, 0.04928950f, 0.05927936f, 0.11708399f, 0.32741198f, 0.20852339f, -0.14985542f, -0.11602671f, 
    0.28314617f, -0.02429713f, -0.18835719f, -0.08067626f, -0.07200839f, -0.03199359f, 0.39433500f, 0.21229909f, 
    0.03046349f, 0.07232420f, 0.16725142f, 0.06444258f, 0.06663701f, 0.07428069f, 0.18676926f, 0.07170931f, 
    0.22142176f, 0.18308395f, 0.03499456f, -0.00628837f, -0.09473264f, 0.07468760f, 0.00277365f, -0.01659664f, 
    -0.22423831f, 0.07661608f, 0.10358912f, -0.04668131f, 0.03265262f, 0.16992579f, -0.20756033f, 0.04755014f, 
    0.08543857f, 0.12386691f, -0.02546605f, -0.10726997f, 0.06071681f, 0.15010412f, 0.17611867f, 0.09380086f, 
    -0.27951634f, -0.02057936f, 0.03677290f, 0.06890664f, 0.04761267f, -0.20913585f, 0.10135181f, -0.04724785f, 
    0.07047205f, 0.12784895f, -0.02040244f, 0.12519133f, -0.04357039f, -0.00547030f, -0.04492747f, -0.05880420f, 
    0.10094789f, 0.03032156f, 0.10116176f, 0.15333284f, -0.24416994f, 0.04464216f, -0.00904857f, -0.03619743f, 
    -0.13667893f, 0.05336368f, -0.12902561f, -0.05863561f, 0.05445069f, -0.13926859f, -0.17715178f, 0.10447635f, 
    -0.09964132f, -0.04682476f, -0.07315807f, -0.11586292f, -0.11204501f, -0.02475290f, 0.05732615f, 0.01033696f, 
    0.01314014f, 0.00599177f, -0.08111072f, -0.14297648f, 0.04578276f, -0.01629692f, 0.05638710f, -0.17168988f, 
    -0.06189257f, 0.11185187f, 0.03676109f, -0.01553635f, -0.01901070f, 0.00279309f, 0.00947012f, -0.01707552f, 
    0.02635349f, 0.03995346f, 0.03293142f, 0.05114645f, -0.06148611f, 0.02615742f, 0.08717344f, -0.05197911f, 
    -0.14675820f, -0.12137809f, -0.11489421f, -0.09277552f, -0.08909523f, -0.08913903f, -0.10231051f, 0.03582593f, 
    0.09503751f, -0.00623734f, 0.08644534f, -0.03485471f, -0.02070262f, -0.08435522f, 0.11700851f, -0.01345308f, 
    0.09660487f, -0.01749633f, -0.08000250f, -0.09180537f, 0.02586856f, -0.16154987f, 0.07061032f, 0.05942044f, 
    0.10395552f, -0.07949244f, -0.09997083f, 0.06526888f, -0.04059479f, 0.30821100f, 0.17386937f, -0.08082528f, 
    -0.02293450f, -0.00658237f, 0.07219023f, 0.06462817f, 0.03926816f, 0.00353342f, -0.10001849f, 0.18776479f, 
    0.09848218f, 0.10287454f, 0.25214985f, -0.12312675f, 0.32547069f, 0.09502406f, -0.25656483f, -0.08630759f, 
    0.38313523f, -0.09494239f, -0.04966401f, 0.02961197f, -0.39745575f, 0.02409396f, 0.13405426f, 0.07516938f, 
    0.10042435f, 0.08192440f, -0.00920080f, -0.08923578f, -0.11785492f, -0.01780211f, 0.20419878f, 0.14046465f, 
    0.04807937f, 0.08127840f, -0.02622112f, 0.15647291f, 0.09700010f, -0.11404004f, 0.17053702f, 0.02447606f, 
    -0.01897447f, -0.10505213f, -0.12271773f, 0.11711819f, -0.02945301f, -0.14897391f, 0.12321594f, -0.04172755f, 
    -0.10856222f, 0.17411071f, 0.08649068f, 0.03647698f, -0.20092738f, 0.22297066f, -0.09362794f, -0.08183940f, 
    0.21150453f, 0.09785128f, -0.28274235f, 0.11415395f, 0.23968486f, -0.06184750f, -0.08945114f, -0.13865653f, 
    -0.07721488f, 0.08107909f, 0.27621871f, -0.02083725f, -0.31511101f, -0.06932734f, -0.35855088f, -0.04843874f, 
    0.12242471f, 0.02814044f, 0.17598285f, -0.05495562f, 0.32568792f, 0.02571322f, -0.08738342f, -0.37429351f, 
    0.39369068f, 0.07044905f, -0.09326929f, -0.05344968f, -0.23057525f, 0.13235012f, 0.18495768f, -0.09539045f, 
    -0.03262382f, -0.04191212f, -0.10625778f, -0.00396738f, 0.08619123f, -0.09023589f, -0.11426187f, -0.06402571f, 
    0.01549008f, 0.03449276f, -0.08509676f, -0.12775087f, 0.05430264f, 0.18225546f, 0.16616535f, 0.04259586f, 
    -0.02489035f, 0.03000885f, -0.01927333f, 0.08521918f, 0.24326839f, 0.26559964f, 0.12088558f, -0.00570956f, 
    -0.01767402f, -0.02925636f, -0.11805616f, -0.10162190f, 0.15105008f, 0.26689655f, -0.02652878f, 0.02219725f, 
    -0.03382468f, 0.05463357f, -0.04404709f, -0.00117261f, -0.03460012f, -0.27977729f, 0.04509420f, 0.16238755f, 
    0.03790370f, -0.02141517f, 0.07019187f, 0.06290942f, 0.13281681f, 0.10275073f, 0.43950266f, -0.12835297f, 
    0.02212790f, 0.32730001f, -0.09653862f, 0.00153679f, 0.35923356f, 0.22095948f, -0.11389471f, -0.05350458f, 
    -0.02556878f, -0.09671134f, -0.09515084f, -0.00564712f, 0.00324423f, 0.02488632f, -0.17749253f, -0.05395819f, 
    -0.02040931f, -0.10473492f, 0.13740616f, 0.12369044f, -0.11361352f, 0.38905197f, 0.25654799f, -0.15572082f, 
    -0.55105931f, -0.11587646f, -0.08426812f, 0.19707206f, 0.01384318f, 0.18551484f, 0.14526847f, -0.11553670f, 
    0.03300551f, -0.10571627f, 0.12675089f, 0.07879350f, 0.24128787f, -0.02705919f, -0.04582711f, -0.09323971f, 
    -0.00693377f, 0.08245740f, 0.02317209f, 0.12112466f, -0.22775383f, 0.02142477f, -0.24476129f, -0.01876847f, 
    0.23330358f, -0.10798436f, -0.07549196f, -0.09043516f, 0.17260140f, 0.21309879f, 0.13405117f, -0.03334769f, 
    -0.05290773f, 0.13694121f, -0.06691578f, 0.05279024f, 0.00224782f, -0.10170389f, 0.29666206f, -0.08970989f, 
    0.31681123f, -0.05743461f, -0.08748724f, 0.21646056f, -0.28539452f, -0.13458560f, -0.05646506f, 0.05603260f, 
    0.24474384f, 0.10760866f, 0.01007228f, 0.05675483f, -0.17095755f, 0.32734820f, -0.25974515f, 0.06214395f, 
    0.11261291f, -0.04961226f, 0.10886470f, -0.01708626f, 0.12494549f, -0.25406140f, 0.01409940f, 0.21726415f, 
    -0.12484592f, 0.04863787f, 0.11022922f, 0.07610799f, 0.00838515f, -0.01535406f, 0.27075097f, 0.18181057f, 
    -0.21298236f, 0.11573141f, -0.08413294f, 0.00333171f, 0.25264215f, -0.07852454f, -0.01835553f, -0.07162759f, 
    0.00004319f, -0.28983137f, -0.04875334f, 0.18497679f, 0.02357019f, 0.13034154f, -0.08844437f, -0.07401247f, 
    -0.32043126f, 0.00729957f, 0.00775094f, 0.10102846f, 0.01196485f, 0.09899141f, 0.18789539f, -0.01974130f, 
    -0.04223458f, 0.05527417f, -0.01443702f, -0.04688295f, 0.00148042f, 0.08129404f, 0.05121565f, 0.23842955f, 
    0.35161397f, 0.08808751f, -0.11750836f, 0.03359297f, 0.31082079f, 0.30225447f, -0.01921916f, 0.03453691f, 
    0.26237586f, 0.04931381f, 0.02073338f, -0.05688208f, -0.16133673f, 0.36454728f, -0.00689039f, 0.05949540f, 
    -0.01464572f, -0.05493188f, -0.10615852f, 0.11010686f, -0.11019896f, -0.39359671f, 0.29713178f, -0.07468093f, 
    -0.00931559f, 0.06568535f, 0.00253873f, 0.15681361f, -0.02828226f, 0.07624169f, 0.03949927f, 0.01023714f, 
    0.00625800f, -0.10230389f, 0.02436860f, 0.03061338f, -0.20714316f, -0.00910192f, 0.07927814f, -0.11763526f, 
    0.10698199f, 0.05152329f, -0.07352384f, 0.21227798f, -0.23613922f, 0.11607628f, -0.04241787f, -0.10743367f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.13551979f, -0.06023172f, 0.12641484f, 0.16123678f, -0.01921250f, 0.19643593f, -0.04778817f, -0.05735040f, 
    0.07704060f, 0.05539426f, 0.00526713f, 0.07462271f, 0.09114398f, 0.09100765f, -0.00268601f, 0.28102043f, 
    0.13766338f, -0.04092067f, -0.08824582f, -0.09628254f, 0.09477302f, -0.06499875f, -0.03610121f, -0.06977057f, 
    -0.00443164f, 0.14884010f, 0.01289444f, -0.05934599f, -0.08608779f, -0.02813666f, 0.02059350f, 0.15560114f, 
    -0.14289366f, -0.11651956f, 0.00352895f, 0.06650914f, 0.08971059f, 0.13358511f, 0.10873380f, 0.14440508f, 
    -0.05778123f, 0.07284451f, -0.02905051f, 0.21689174f, 0.06684701f, 0.09519610f, 0.10786458f, -0.09439051f, 
    0.01850635f, -0.02349296f, 0.21712542f, 0.08636334f, -0.05139020f, -0.01425376f, -0.05172033f, 0.09071191f, 
    0.23189460f, 0.06647144f, -0.07457210f, 0.14956468f, 0.00307094f, -0.05413419f, 0.01597092f, 0.12081614f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.10169432f, 0.09311244f, -0.04995978f, -0.08712579f, 0.04780724f, 0.14208014f, 0.05743318f, 0.14496201f, 
    -0.30214921f, -0.05672042f, 0.06928580f, -0.16464563f, -0.27880067f, -0.16743550f, 0.15404011f, -0.45969620f, 
    0.11089640f, -0.04082508f, 0.12005677f, -0.00685448f, 0.03338851f, 0.00651653f, -0.30892208f, 0.03618871f, 
    -0.08977640f, -0.47990736f, 0.07312156f, -0.07981385f, -0.02703166f, -0.11391648f, -0.52125800f, 0.17540810f, 
    -0.50389177f, -0.33677998f, -0.29431963f, -0.22599816f, -0.05850700f, 0.02103869f, -0.12485675f, 0.07474259f, 
    0.39423046f, 0.02481402f, -0.42743909f, 0.08827151f, -0.32800153f, -0.04108845f, -0.46344015f, 0.14690900f, 
    0.30408490f, 0.08761682f, -0.07788743f, -0.01706462f, -0.03147097f, 0.29713660f, -0.08796759f, 0.26943663f, 
    -0.18518373f, 0.01479567f, -0.13802657f, 0.04990907f, -0.21159616f, 0.26474839f, -0.31043199f, 0.22689711f, 
    0.24022156f, 0.09618063f, 0.07789449f, 0.07843249f, 0.15117829f, -0.05461477f, 0.07900120f, 0.26155838f, 
    -0.10251385f, -0.08113465f, -0.02427490f, 0.01048372f, -0.46679652f, -0.14039846f, 0.22292314f, 0.01987471f, 
    0.23148353f, 0.12498690f, 0.19725877f, -0.04486479f, 0.10098127f, 0.00941350f, 0.29211256f, 0.08810161f, 
    -0.07168830f, -0.39839914f, -0.01982505f, 0.10212991f, -0.45703399f, -0.01294829f, -0.08577047f, 0.05998398f, 
    0.34810328f, 0.12964891f, -0.06657434f, -0.13756149f, -0.11962465f, 0.00502069f, -0.00554263f, -0.26709938f, 
    -0.18897770f, -0.05697753f, -0.32082775f, 0.16518742f, 0.10679254f, 0.02641675f, 0.28174183f, 0.09380414f, 
    -0.06106193f, -0.00797346f, -0.13403228f, 0.02905675f, 0.02199291f, -0.24236298f, -0.04766024f, 0.13382889f, 
    -0.12550880f, 0.13128959f, -0.18495047f, 0.02485147f, -0.03423925f, -0.13032694f, -0.11031087f, -0.08603441f, 
    -0.03901112f, -0.05739697f, 0.18419632f, -0.18800212f, 0.04785063f, 0.13479562f, 0.08486900f, 0.00627343f, 
    0.22632417f, -0.06883097f, 0.04757187f, -0.00109093f, 0.00547453f, -0.09830269f, -0.39027420f, 0.00325944f, 
    0.08629019f, -0.04402804f, 0.10204148f, -0.07153323f, 0.19952761f, -0.02017357f, -0.16495484f, -0.05958898f, 
    -0.04972697f, -0.19294116f, -0.04323424f, 0.01320489f, -0.25688863f, 0.00471633f, -0.23387618f, -0.36486647f, 
    -0.02306416f, -0.33207971f, -0.16680664f, -0.40954933f, -0.02796726f, 0.14124620f, 0.09655666f, -0.20679665f, 
    0.21940576f, -0.39689595f, 0.33028147f, -0.14302963f, 0.18177016f, -0.05203440f, 0.32754952f, 0.07057530f, 
    0.25711748f, 0.24762481f, -0.44193506f, -0.15259133f, -0.02921750f, -0.01199262f, -0.05381188f, -0.13917805f, 
    -0.20901206f, 0.21077856f, -0.07665972f, -0.01820979f, -0.12223469f, -0.03236881f, 0.30930567f, 0.15401378f, 
    0.10639283f, -0.01036937f, 0.07539004f, -0.05959843f, -0.46872735f, -0.07891818f, 0.09274638f, -0.27233773f, 
    0.16161214f, -0.04032626f, 0.08191636f, 0.03935411f, -0.13183671f, -0.11097889f, 0.08446956f, -0.44682348f, 
    -0.29465485f, -0.18243101f, -0.13874587f, -0.13903198f, -0.36277533f, 0.01492019f, -0.24853788f, 0.04281847f, 
    0.06661054f, -0.34519485f, 0.00526192f, -0.04377616f, 0.00956756f, -0.04437974f, 0.09920410f, -0.21089232f, 
    -0.05242273f, 0.16513245f, -0.00315913f, 0.17896864f, -0.14816804f, -0.04729525f, -0.08450973f, -0.04030496f, 
    0.34398231f, 0.22493979f, -0.40793639f, 0.21303208f, 0.20584537f, -0.08060348f, -0.39772642f, -0.56390923f, 
    -0.23146321f, 0.27517810f, -0.06472269f, 0.21588454f, -0.07713464f, 0.13751902f, 0.08668447f, 0.11472417f, 
    0.20155169f, 0.03489834f, -0.06952336f, -0.07026020f, -0.06097786f, -0.57114494f, 0.02225155f, 0.00622232f, 
    -0.06951367f, -0.09047747f, 0.11641794f, -0.28261623f, 0.12746343f, 0.08608869f, -0.10152892f, 0.05569121f, 
    0.23889363f, -0.10496379f, 0.05554426f, -0.05511639f, 0.18607701f, -0.25899702f, 0.04111337f, 0.15217693f, 
    -0.15137984f, 0.07954172f, 0.09546909f, 0.01071281f, -0.11112785f, -0.10298613f, -0.29621729f, -0.07660914f, 
    0.00546708f, 0.02959073f, -0.13395913f, 0.01094586f, 0.05631014f, 0.06470074f, 0.12138008f, 0.18241458f, 
    -0.55027789f, -0.20927829f, 0.03104674f, 0.16950072f, -0.01507824f, 0.22093768f, -0.01728620f, 0.13337468f, 
    0.24918517f, 0.27260271f, -0.21136533f, 0.24826674f, -0.35018235f, 0.04601207f, 0.25293273f, -0.11489525f, 
    -0.16408543f, -0.34421283f, -0.02317852f, 0.02748628f, 0.03017476f, -0.02723123f, -0.09673402f, -0.17691340f, 
    0.03757680f, -0.25901768f, -0.14340533f, -0.40177655f, 0.02173408f, -0.16107473f, -0.33595517f, -0.37730977f, 
    -0.24578284f, 0.07572685f, -0.16391551f, 0.49092093f, -0.04650273f, -0.00766731f, 0.07230050f, 0.20992924f, 
    -0.04984809f, 0.02390332f, -0.04426374f, -0.06548560f, 0.10475962f, 0.09188908f, -0.01014381f, 0.17577726f, 
    0.09894738f, -0.04901123f, 0.13469033f, 0.09329048f, -0.20123534f, -0.02859793f, 0.29366153f, 0.06910085f, 
    -0.00478914f, -0.04944923f, 0.08490493f, 0.07207184f, -0.13315189f, -0.00693162f, -0.05557109f, -0.04700115f, 
    0.10663158f, -0.14175227f, 0.20235179f, 0.03507104f, 0.05654642f, 0.04289806f, 0.05476183f, 0.19258098f, 
    -0.31795657f, 0.03645830f, -0.12538354f, -0.06027375f, 0.04160685f, 0.06687501f, -0.30201840f, 0.06790239f, 
    -0.04762528f, -0.26616073f, 0.20791364f, -0.42908245f, 0.07678638f, -0.19664389f, 0.09466700f, -0.02407693f, 
    0.06714496f, -0.04307546f, -0.05436390f, -0.24046217f, -0.34795696f, 0.05995382f, -0.50889033f, 0.12531073f, 
    0.17594208f, -0.04430466f, 0.27666879f, -0.28068572f, -0.08455329f, 0.14637093f, -0.12690017f, -0.15227205f, 
    -0.53078139f, 0.06626345f, -0.02938267f, -0.07545372f, -0.11235086f, -0.32037437f, 0.06171330f, -0.56331831f, 
    0.01489433f, 0.10503449f, -0.10562617f, -0.12793742f, -0.35064396f, 0.01274336f, 0.11063947f, -0.07220056f, 
    -0.10711440f, 0.21044794f, -0.01270413f, -0.11728690f, 0.24727339f, -0.00564662f, 0.24241446f, -0.10064521f, 
    -0.46152449f, -0.33901873f, 0.03659900f, -0.16654016f, 0.04497777f, -0.01459159f, 0.05376826f, 0.11312243f, 
    -0.17827955f, -0.30967635f, -0.01106492f, -0.15282601f, 0.46282196f, -0.04935878f, -0.47041383f, 0.15314473f, 
    -0.28613585f, 0.11285611f, 0.19309308f, 0.07235874f, -0.10507450f, 0.19699937f, 0.05674987f, -0.14880215f, 
    -0.02061300f, 0.24287555f, -0.03907046f, -0.46649909f, -0.40421447f, 0.15099898f, 0.27750257f, 0.00310416f, 
    -0.20313528f, -0.09973549f, -0.30629444f, -0.03483349f, -0.04354067f, -0.38615561f, 0.03624218f, -0.05050704f, 
    0.20425594f, 0.06631076f, 0.03195882f, 0.07875412f, 0.23046841f, -0.43449920f, -0.17699267f, -0.24376526f, 
    -0.45173290f, 0.01865965f, -0.34961134f, 0.06765057f, 0.03833092f, 0.08663176f, -0.01147220f, -0.03125736f, 
    0.06750784f, 0.02048794f, -0.06688367f, 0.08431671f, 0.21456067f, -0.05181615f, 0.17634186f, -0.49910477f, 
    0.13050275f, 0.25797987f, -0.33106542f, 0.13759631f, 0.20547229f, -0.00874247f, -0.10691115f, 0.11085059f, 
    0.11124102f, 0.05023859f, 0.31516427f, -0.48646742f, -0.09245553f, 0.05470632f, 0.20997535f, -0.10432985f, 
    0.08608293f, 0.25322309f, -0.38339928f, 0.12140220f, -0.10805102f, -0.00174146f, -0.09580869f, -0.56094325f, 
    -0.13184853f, -0.03639779f, 0.00492345f, -0.07507135f, 0.16413532f, -0.08361165f, -0.07215536f, -0.29660153f, 
    -0.08267386f, -0.06332070f, -0.41717508f, 0.27585113f, 0.15622324f, -0.05134082f, 0.03729539f, 0.05043660f, 
    0.24140091f, -0.00987731f, -0.04106846f, -0.01918683f, -0.20403540f, 0.22488397f, 0.08162539f, 0.17773990f, 
    -0.37497595f, -0.26628774f, -0.11132678f, 0.03536995f, 0.19699354f, -0.09124126f, -0.04007225f, 0.03302388f, 
    -0.06843994f, 0.23438665f, 0.08825334f, -0.07262814f, 0.00540993f, 0.10351074f, 0.28808978f, 0.10413277f, 
    -0.26905444f, -0.32724759f, 0.17526853f, -0.17233802f, -0.43406352f, -0.58272105f, 0.00703978f, -0.25036541f, 
    0.07456531f, -0.20303404f, 0.24557847f, -0.11767388f, -0.58167273f, 0.06047984f, -0.17574075f, -0.00842332f, 
    0.01778902f, 0.02320729f, -0.01669013f, 0.20080274f, 0.04851071f, -0.43462554f, -0.03275237f, 0.03088810f, 
    -0.33106029f, 0.20893653f, -0.01134875f, 0.15603048f, -0.04963163f, 0.09001801f, -0.25745192f, -0.14883441f, 
    0.05070568f, 0.12150496f, -0.18706860f, -0.40085882f, 0.24016479f, 0.13313353f, 0.05919629f, -0.48400512f, 
    -0.05794825f, 0.05335813f, -0.02031121f, -0.04411957f, 0.23613867f, 0.17771477f, -0.58087188f, 0.08857302f, 
    0.16527545f, 0.03037199f, 0.23209652f, -0.04188547f, -0.28721401f, -0.09802581f, -0.27681196f, -0.07012625f, 
    0.05386001f, 0.29906157f, 0.08928535f, 0.12042557f, -0.08384083f, -0.00384937f, -0.14754994f, 0.19233844f, 
    0.10919989f, -0.03623192f, -0.08253640f, 0.08343993f, 0.27804387f, 0.10670760f, -0.11880472f, 0.07824253f, 
    -0.15958984f, -0.36297682f, 0.21855804f, -0.15599045f, -0.12327826f, -0.11050019f, -0.38396493f, 0.06207176f, 
    0.34268650f, -0.32106486f, 0.01479460f, -0.22828311f, -0.01172809f, 0.20255330f, 0.11757088f, -0.37680414f, 
    -0.08616854f, -0.15004180f, -0.11624942f, 0.03578810f, -0.19013228f, 0.02836839f, 0.20413138f, -0.26124495f, 
    -0.24467561f, -0.07062025f, -0.02513355f, 0.16725171f, -0.54372776f, 0.17855167f, 0.03815663f, -0.20828956f, 
    -0.03249504f, 0.08840611f, -0.01658660f, 0.04431073f, 0.26525632f, 0.36639062f, 0.03774007f, 0.45725685f, 
    -0.00646557f, -0.06695589f, -0.20350938f, -0.01733165f, 0.14746483f, 0.07301140f, 0.09196484f, -0.04019313f, 
    -0.11910252f, -0.11464085f, 0.01076867f, -0.07293363f, -0.09817766f, 0.04321906f, -0.22325166f, -0.27764237f, 
    -0.09440608f, -0.01950547f, -0.15963170f, 0.12756924f, -0.23034313f, 0.21405222f, -0.01657810f, -0.19735977f, 
    -0.46565029f, -0.19252913f, 0.13167226f, -0.01196449f, -0.35811859f, -0.01074788f, 0.15994859f, -0.18086445f, 
    -0.50702024f, 0.03429109f, -0.17723142f, 0.15048829f, 0.00984673f, 0.09646887f, 0.06597700f, 0.16238381f, 
    0.12291273f, -0.21363977f, -0.03695369f, 0.24662271f, 0.19161320f, -0.40035710f, 0.21885154f, 0.34182942f, 
    0.16739497f, -0.01743396f, 0.15338291f, -0.21598926f, -0.25906101f, -0.18029693f, -0.10618661f, -0.27654430f, 
    0.16938475f, -0.05524814f, 0.06469403f, -0.11154357f, -0.15403165f, 0.20238826f, 0.16019048f, -0.38316363f, 
    0.18337265f, 0.05666152f, -0.23207545f, -0.01963437f, 0.04401053f, -0.02507224f, -0.34682515f, -0.04661889f, 
    0.00119594f, 0.17548266f, 0.11475360f, 0.02915680f, -0.00390028f, -0.08091990f, -0.07752812f, 0.30699408f, 
    -0.01507322f, 0.00481014f, 0.18065606f, 0.01913882f, -0.18125936f, -0.00293917f, -0.03054264f, 0.01476795f, 
    0.00803014f, -0.13184053f, -0.03194138f, -0.11949456f, -0.17871161f, -0.11463433f, -0.59424609f, -0.38635683f, 
    -0.12753060f, -0.39877838f, 0.05428153f, -0.34051764f, -0.09793505f, -0.20828819f, 0.00372800f, 0.31172121f, 
    0.17096604f, 0.18748371f, -0.01103188f, 0.08158217f, 0.28038639f, 0.35836568f, 0.10195240f, 0.10036953f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.12674195f, -0.14840975f, -0.09688585f, -0.04753807f, 0.02768067f, 0.07739611f, 0.05162935f, -0.24715410f, 
    -0.04534373f, 0.01459178f, 0.13491663f, -0.09672281f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
