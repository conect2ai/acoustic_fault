#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.06568693f, 0.22239438f, 0.31448141f, -0.22668624f, -0.13852227f, -0.01429013f, 0.20586258f, -0.02383651f, 
    -0.21194154f, 0.00599979f, -0.13972576f, 0.05219596f, 0.18700920f, 0.03123992f, -0.22537021f, 0.38272026f, 
    0.21568446f, -0.40220332f, 0.05811450f, -0.17069528f, -0.02583162f, 0.01196427f, -0.28927758f, 0.08691388f, 
    0.31977114f, 0.29074201f, 0.30466092f, 0.53804094f, -0.21248010f, -0.61337376f, -0.69896811f, -0.48276609f, 
    0.09320162f, 0.38893026f, 0.32646024f, 0.21782678f, -0.22762735f, 0.13194270f, 0.22491622f, -0.05268985f, 
    -0.21332577f, 0.07076088f, -0.16541614f, 0.09040785f, -0.14186835f, -0.19053693f, -0.13372751f, 0.19207585f, 
    0.03744108f, -0.19218391f, -1.01794887f, -0.52091277f, 0.03192202f, 0.56553227f, 0.24167943f, -0.53433138f, 
    -0.50914025f, 0.26681373f, 0.39115369f, 0.29748666f, -0.17422716f, -0.19318816f, 0.02146719f, 0.35538214f, 
    0.04878892f, 0.12287492f, -0.07587324f, 0.13373876f, 0.01364101f, 0.19000407f, -0.13798372f, -0.21690947f, 
    0.24481675f, -0.24368708f, 0.13854070f, -0.96092087f, -0.62528449f, -0.17264701f, 0.30257827f, -0.12239163f, 
    0.45368752f, -0.24254501f, 0.03605348f, 0.49247593f, 0.52064580f, 0.03255448f, 0.08654144f, -0.22893900f, 
    0.05324128f, -0.15770628f, -0.07593405f, 0.01644222f, -0.05274320f, -0.09366153f, -0.03841091f, -0.10157555f, 
    -0.18119512f, -0.15975277f, -0.06172102f, -0.36101454f, -0.49431369f, 0.26157960f, -0.00011067f, 0.39320302f, 
    -0.00443914f, 0.21940319f, 0.08273049f, -0.17416957f, 0.20222454f, -0.58057088f, -0.21518457f, 0.07748415f, 
    0.17834796f, -0.02471840f, 0.12562960f, -0.27912879f, -0.01288631f, 0.07232410f, -0.17231579f, 0.27697718f, 
    0.03455055f, -0.06497692f, -0.05244503f, -0.17454927f, 0.14763051f, -0.72709048f, -0.55163109f, -0.47966561f, 
    -0.04264067f, 0.41364199f, 0.03084055f, -0.39206403f, -0.10285126f, -0.39209974f, -0.38089421f, 0.02868248f, 
    0.27392945f, -0.11739983f, -0.44332317f, -0.24572176f, 0.15393771f, 0.17751667f, 0.14569691f, 0.30059168f, 
    0.27045420f, 0.12584312f, -0.17990753f, 0.05740648f, -0.02287875f, 0.01111095f, 0.06760430f, 0.09650902f, 
    -0.21602391f, -0.05228505f, 0.16732839f, -0.33535087f, -0.15213504f, -0.02019433f, 0.14854190f, 0.35742867f, 
    0.03245959f, 0.30677360f, 0.32300812f, -0.07650488f, -0.38130316f, -0.30547261f, -0.02679227f, 0.37665829f, 
    -0.01399882f, -0.31942016f, -0.08940228f, 0.10888746f, -0.07350027f, 0.12828334f, 0.20710137f, 0.01714196f, 
    -0.11740381f, -0.36092916f, -0.14342608f, 0.06311975f, 0.07435545f, 0.04488858f, -0.24801745f, -0.39603516f, 
    0.25546786f, 0.32971385f, -0.06622906f, 0.07063460f, -0.02765033f, 0.19973098f, 0.08645929f, -0.23185560f, 
    -0.01126840f, 0.00359997f, 0.07784244f, 0.04827503f, 0.08446013f, 0.20031294f, -0.04558517f, 0.35502002f, 
    -0.60693181f, -0.83742720f, -0.02506927f, 0.10180616f, 0.21074827f, 0.78398168f, 0.13409202f, -0.03378780f, 
    -0.23450461f, 0.59033757f, -0.23271579f, -0.08657980f, -0.10086238f, 0.21142976f, 0.33794171f, -0.16117486f, 
    -0.16876495f, -0.33894551f, 0.18787807f, -0.13972816f, 0.09226793f, -0.19450302f, 0.16262892f, 0.35766500f, 
    0.01370639f, -0.85987991f, -0.67979264f, -0.09126558f, 0.37546095f, 0.41891402f, -0.61117369f, -0.56910074f, 
    -0.38213328f, 0.48684263f, 0.27386719f, 0.27016255f, -0.08527028f, 0.04645339f, 0.16020395f, 0.18575962f, 
    -0.21375425f, 0.32644168f, -0.25566038f, -0.26818889f, -0.20007282f, 0.16905616f, 0.02833152f, -0.04455893f, 
    -0.22169624f, -0.19226824f, -0.05443686f, -0.00055360f, 0.19078743f, -0.15146433f, 0.05679287f, 0.42070925f, 
    0.17281860f, -0.38039762f, 0.02837984f, 0.08672563f, 0.17092919f, 0.39648178f, -0.11025618f, -0.01882802f, 
    -0.39653045f, -0.25966835f, -0.20614035f, 0.08930284f, -0.13783073f, 0.24983972f, -0.28161818f, 0.41656014f, 
    0.18066637f, -0.12061527f, -0.09374367f, 0.41764674f, 0.29972360f, 0.10984204f, -0.20003776f, 0.24487650f, 
    -0.38586655f, 0.00485303f, 0.28860706f, 0.05444574f, -0.21484357f, -0.18455406f, 0.13491675f, 0.31406587f, 
    -0.31969482f, -0.26667953f, 0.09358881f, 0.02491981f, -0.21057759f, 0.05522963f, -0.15117736f, -0.05346463f, 
    0.26319683f, 0.09789393f, 0.04514765f, 0.05789750f, -0.02606859f, -0.60990894f, -0.15610518f, -0.34769231f, 
    -0.26233906f, -0.29580694f, -0.57516211f, -0.55551010f, -0.15872642f, 0.10556925f, 0.17628875f, -0.13663884f, 
    -0.21027777f, 0.04295774f, 0.48095375f, -0.04054563f, 0.09667175f, -0.07841848f, 0.11334600f, 0.13865328f, 
    -0.22620417f, -0.20393287f, -0.17348145f, 0.07413857f, -0.27327758f, 0.27889222f, 0.39015055f, 0.13595654f, 
    -0.11482207f, -0.03924091f, -0.10867517f, -0.16148134f, 0.03055037f, -0.32926232f, 0.07632661f, -0.03366886f, 
    -0.04272339f, 0.08071527f, 0.06801645f, 0.24161285f, 0.21657105f, -0.07441534f, -0.13425048f, 0.24956088f, 
    -0.18398255f, 0.10357496f, -0.08335188f, -0.03271445f, -0.08505592f, -0.29522243f, 0.44455388f, 0.35960382f, 
    0.20028104f, -0.25130698f, -0.44689310f, 0.22423780f, 0.25792560f, 0.25590554f, -0.44118950f, -0.21155079f, 
    0.06434175f, -0.03681299f, 0.08386016f, 0.00187381f, -0.35199082f, 0.16022216f, -0.00243908f, -0.22127935f, 
    -0.19564086f, 0.13880368f, -0.14858195f, -0.09292363f, -0.29338405f, 0.16215941f, 0.22275865f, -0.50943649f, 
    0.17181426f, -0.68009841f, -0.17546824f, -0.05547787f, -0.60325474f, -0.29247981f, -0.54049957f, -0.79206127f, 
    -0.39657763f, 0.10221985f, 0.04435314f, 0.42220795f, 0.45256492f, -0.09216467f, 0.23870052f, 0.13551441f, 
    -0.17250378f, -0.31866339f, -0.06761999f, 0.11304791f, -0.09577934f, -0.23201515f, -0.11237637f, 0.20257491f, 
    -0.80379635f, 0.81187797f, 0.70394236f, -0.36853001f, -0.42122039f, -0.50001758f, -0.15837924f, 0.44942021f, 
    0.13085890f, 0.19130348f, -0.26544234f, -0.32150358f, 0.46918300f, -0.16735955f, -0.17218161f, -0.06678724f, 
    0.09229609f, -0.13118829f, -0.22488689f, 0.21595708f, -0.08810573f, -0.13300140f, -0.43330449f, -0.13593307f, 
    -0.22500791f, -0.16107863f, 0.23739016f, 0.27472651f, -0.06415993f, -0.19355094f, -0.61417836f, -0.33177805f, 
    -0.07276513f, -0.10489937f, 0.57042575f, 0.23447976f, -0.11703075f, -0.20982905f, 0.13309085f, 0.42190418f, 
    -0.00265096f, -0.01137288f, -0.13000759f, -0.15123628f, -0.46692649f, 0.18064129f, 0.16037877f, -0.22098510f, 
    0.27433059f, 0.28739217f, -0.27744555f, -0.50734746f, 0.20454375f, 0.45147374f, 0.53119123f, 0.27855670f, 
    -0.24249825f, 0.32202572f, -0.13475171f, 0.24209686f, -0.36884558f, -0.27382845f, 0.53428537f, -0.41084826f, 
    -0.14000303f, 0.03553149f, -0.16047426f, -0.10119249f, 0.16673394f, -0.24563602f, 0.18920329f, -0.24756792f, 
    -0.18680103f, 0.28447002f, -0.07108344f, 0.29278937f, -0.07713722f, 0.25721824f, 0.25487503f, 0.31437626f, 
    0.03452110f, -0.17067014f, -0.02709281f, 0.14799125f, -0.01135546f, 0.07583869f, 0.11494699f, 0.01046727f, 
    -0.10534942f, 0.08468004f, 0.09613132f, 0.11761111f, 0.05137913f, 0.01166117f, -0.00145903f, -0.04620548f, 
    0.02506407f, -0.03027221f, 0.05020461f, 0.00930000f, -0.62005782f, -0.45160261f, -0.50891316f, -0.66508430f, 
    -0.55703270f, -0.08782392f, -0.36950073f, -0.69905829f, -0.56433785f, -0.29657006f, -0.14367755f, -0.07868978f, 
    0.15472893f, 0.12261628f, 0.21814840f, 0.16581605f, -0.21473233f, 0.11205348f, 0.01849609f, -0.19967301f, 
    0.04214403f, 0.31507391f, 0.29505080f, 0.03100059f, 0.30157945f, 0.13743828f, 0.25014734f, 0.25736216f, 
    0.34280381f, -0.30892414f, -0.26134521f, -0.02361836f, -0.05264660f, -0.06569245f, -0.11200582f, -0.00938405f, 
    -0.41221613f, 0.20438461f, 0.43911862f, -0.10648236f, -0.25440562f, -0.06936256f, -0.07297659f, -0.12690039f, 
    -0.27797171f, -0.37098068f, -0.47686630f, -0.45709214f, -0.52591395f, -0.43737265f, 0.45867941f, -0.59069514f, 
    -0.16443223f, 0.12118296f, 0.27975792f, -0.32921052f, -0.23626138f, 0.16683698f, 0.24340354f, 0.12784752f, 
    -0.18357524f, 0.04208916f, -0.04243698f, -0.19218405f, 0.36960334f, -0.20142116f, -0.02184323f, 0.22135346f, 
    0.17895404f, -0.41301158f, 0.15347883f, -0.15333247f, -0.10830493f, 0.14911807f, 0.15519895f, 0.56870979f, 
    0.45903388f, -0.39370537f, -0.27760682f, -0.24031778f, 0.09801243f, -0.09221281f, -0.00569883f, 0.03896425f, 
    0.17700440f, -0.12938882f, 0.28386456f, -0.28158513f, 0.09892206f, -0.14731987f, 0.13316190f, 0.04360026f, 
    -0.24448359f, 0.01390854f, -0.13363747f, -0.13362579f, -0.07135554f, -0.16078025f, -0.26645067f, -0.15364957f, 
    0.02120802f, 0.36760265f, 0.12283891f, -0.10392749f, -0.32473031f, 0.22918406f, 0.70459253f, -0.53624886f, 
    -0.30040643f, -0.75405592f, -0.21037474f, -0.22168243f, -0.34457517f, -0.17468056f, 0.05325197f, 0.17859031f, 
    -0.16820587f, -0.11873756f, 0.27366734f, -0.35114777f, 0.07726212f, -0.14575945f, 0.02404970f, 0.04978479f, 
    0.09863496f, 0.28306490f, -0.33978802f, -0.70899785f, -0.51957935f, -0.63522518f, 0.37952128f, 0.54116720f, 
    0.41880530f, 0.22839448f, -0.30871361f, 0.16724156f, -0.08194090f, -0.06808629f, 0.25994772f, -0.02285449f, 
    -0.06362690f, 0.05484608f, -0.14319989f, 0.09951619f, -0.09297625f, -0.01498781f, -0.17177862f, 0.14509380f, 
    0.14766875f, 0.03766087f, -1.05441868f, 0.01865263f, 0.02739611f, 0.21220665f, 0.25686690f, -0.46558544f, 
    -0.04167484f, 0.49139199f, 0.27973372f, 0.00697992f, 0.16162598f, 0.16899115f, -0.36342591f, 0.42837188f, 
    -0.34523144f, 0.09772895f, -0.31039393f, -0.10193332f, -0.16535270f, 0.13897568f, -0.02584454f, 0.27738455f, 
    0.44505218f, -0.06860430f, -0.14419267f, 0.54498619f, -0.46954805f, -0.39882007f, -0.19528876f, -0.37696210f, 
    0.07897768f, 0.16038686f, 0.39421174f, -0.04407135f, 0.04521395f, -0.04864687f, -0.13829578f, 0.07434525f, 
    0.03180964f, 0.14944579f, -0.11353835f, -0.08570448f, -0.19420645f, 0.16025983f, -0.29223877f, 0.30650091f, 
    0.03037162f, 0.35933942f, 0.09398687f, 0.02766573f, 0.57940274f, 0.33809873f, -0.12956168f, -0.41870162f, 
    -0.53784400f, 0.45398074f, 0.07812472f, -0.22030549f, 0.17466038f, 0.32630110f, 0.00306677f, 0.23513211f, 
    -0.33567479f, 0.12825067f, -0.15485728f, 0.09724416f, -0.08309770f, 0.08519810f, -0.03096641f, -0.25196645f, 
    0.14989981f, -0.03335257f, -0.12373174f, 0.07527032f, 0.02797296f, 0.00535488f, 0.14317855f, 0.19697131f, 
    0.09916314f, -0.31297442f, -0.08516394f, -0.16383910f, 0.15938048f, -0.16943139f, -0.01027480f, 0.00369377f, 
    -0.01431518f, 0.34707183f, -0.50620687f, 0.31045038f, -0.14126737f, 0.47243562f, 0.21951869f, -0.22309643f, 
    -0.14601280f, -0.34540728f, 0.13125579f, -0.04728206f, 0.26221943f, 0.08269621f, -0.86386824f, -0.71963441f, 
    -0.66882819f, -0.13739029f, 0.33947080f, 0.73089248f, 0.75762397f, 0.34814253f, -0.07166224f, -0.04997274f, 
    0.10413818f, -0.09470380f, -0.24634057f, -0.00182333f, -0.06907380f, -0.01608120f, 0.05219664f, 0.21250337f, 
    0.03354240f, -0.09334573f, 0.14824557f, 0.03773672f, -0.15788169f, 0.08426593f, -0.21534498f, 0.20969945f, 
    -0.50063503f, -0.56526351f, -0.21522439f, -0.54483825f, -0.59964973f, -0.34227043f, -0.29003707f, -0.46419618f, 
    -0.32940203f, -0.36251414f, -0.46082264f, -0.26185206f, -0.10342279f, -0.06273855f, 0.25850347f, 0.18456243f, 
    -0.00639371f, 0.22172710f, -0.25072035f, -0.00752925f, -0.26313376f, -0.17145221f, -0.10773573f, -0.25174478f, 
    -0.58964574f, 0.22788103f, 0.37538373f, 0.49689150f, 0.17823189f, 0.63854408f, -0.70131022f, -0.36480972f, 
    -0.03635494f, 0.07979327f, -0.29864594f, 0.02671938f, -0.29004452f, 0.44226760f, -0.40756553f, -0.06279115f, 
    0.16048642f, 0.17538528f, 0.26313877f, -0.00969872f, -0.27977750f, 0.12029918f, 0.06742611f, -0.18720312f, 
    -0.11534489f, -0.40914020f, 0.15425989f, 0.49747950f, 0.40809453f, 0.16500276f, 0.23025383f, -0.19882469f, 
    -0.09596204f, -0.27068752f, -0.00997766f, -0.00098541f, -0.15849723f, 0.08918803f, 0.10028843f, 0.12249725f, 
    0.30730933f, -0.01091576f, -0.31413275f, -0.25770709f, -0.10031474f, 0.15847959f, -0.16008526f, -0.02549045f, 
    0.17618228f, -0.02261580f, -0.80770171f, -0.35828292f, 0.56194901f, 0.22906837f, 0.24458180f, 0.25506493f, 
    0.75641507f, -0.22338936f, -0.38930658f, -0.10952681f, -0.19837086f, 0.11800422f, -0.32656717f, 0.35264668f, 
    -0.14876971f, -0.16815940f, -0.08160553f, -0.13841592f, -0.14933015f, 0.18814813f, 0.05789880f, -0.04825823f, 
    0.06966484f, 0.05086911f, 0.11216440f, -0.48185763f, 0.67861378f, 0.16550076f, -0.56746840f, -0.10116169f, 
    -0.24747524f, 0.18840465f, 0.44624183f, 0.44040421f, 0.09651110f, -0.55991113f, -0.32116246f, 0.34959069f, 
    -0.15738721f, -0.19632226f, 0.11852933f, -0.25071973f, -0.08568890f, 0.13911767f, 0.16827115f, -0.16887946f, 
    0.19427958f, 0.10298672f, 0.06527030f, -0.25846410f, 0.06360289f, 0.41368526f, 0.09461208f, -0.29328099f, 
    -0.27941993f, -0.11468734f, 0.25500828f, -0.25972170f, -0.07362295f, -0.06287379f, 0.36315486f, -0.15039997f, 
    -0.07030581f, 0.03014788f, 0.19345233f, -0.08597980f, 0.05955577f, 0.09059981f, 0.18426767f, -0.26788983f, 
    -0.14825098f, -0.05946659f, 0.06802403f, 0.09548689f, 0.01145939f, 0.46963060f, 0.55325526f, -0.17774598f, 
    -0.34673569f, 0.64827383f, -0.52535695f, -0.27613461f, -0.28299066f, -0.32189795f, -0.49279380f, -0.08692397f, 
    0.37548372f, 0.09630206f, 0.06212559f, -0.14541292f, 0.27273980f, -0.14141981f, 0.14157479f, -0.35776323f, 
    -0.40520042f, -0.16051942f, 0.01258938f, 0.07319237f, 0.06399458f, 0.05584377f, 0.44993463f, 0.11852740f, 
    -0.70390588f, -0.59194893f, -0.39890710f, -0.21773712f, 0.08150316f, 0.29432857f, 0.32014972f, 0.28067148f, 
    -0.00451302f, 0.11314559f, 0.07316070f, 0.07291358f, -0.03935197f, 0.01158013f, -0.14315140f, 0.30768153f, 
    -0.21898033f, -0.17032346f, -0.04922734f, -0.18447402f, -0.14349139f, -0.18088506f, 0.00064018f, -0.89072502f, 
    -0.68190849f, 0.08119463f, 0.16580099f, 0.68368012f, 0.06655132f, 0.36433107f, -0.22499716f, 0.19364358f, 
    0.16496538f, 0.05396821f, -0.49912024f, -0.04395542f, -0.17147824f, 0.22005118f, 0.06628060f, 0.13508004f, 
    0.12980700f, -0.24200080f, 0.02289862f, -0.09944504f, -0.28458861f, 0.14882360f, 0.26287320f, 0.08822024f, 
    -0.65001708f, 0.46482357f, 0.13070540f, -0.82834285f, 0.18545730f, 0.16702035f, 0.36205235f, -0.50405973f, 
    -0.22540724f, 0.21961290f, 0.12577705f, -0.45055592f, -0.30938923f, -0.26607233f, 0.26575401f, -0.12992889f, 
    -0.12465881f, -0.25965905f, -0.07089281f, -0.31402081f, -0.03794795f, -0.41323194f, -0.57376301f, -0.32639974f, 
    -0.79026967f, 0.23757702f, -0.10768108f, -0.15546110f, 0.30373439f, -0.22335163f, 0.20737678f, 0.27774343f, 
    -0.03304211f, 0.17577744f, -0.18244605f, -0.22919223f, 0.34902054f, 0.03668526f, -0.22354436f, -0.03329113f, 
    -0.26110083f, -0.08578401f, -0.00839770f, 0.05022782f, -0.26920423f, 0.29518807f, 0.17921211f, 0.09631279f, 
    0.09386166f, 0.10829784f, -0.19235727f, -0.30045611f, 0.12687299f, -0.93774658f, -1.01632118f, 0.26277846f, 
    -0.33244026f, -0.31545925f, 0.22970171f, 0.64713073f, 0.22678985f, -0.04580232f, 0.21790133f, -0.17885679f, 
    0.23563869f, -0.29920679f, -0.27459764f, 0.02385453f, 0.12032381f, 0.00456085f, -0.03809750f, -0.31161508f, 
    0.25721702f, 0.14012450f, -0.01470035f, -0.40690061f, 0.02878985f, 0.19022140f, 0.29872739f, 0.06277215f, 
    0.28342843f, -0.36211056f, -0.30172288f, -0.00343223f, 0.31527892f, -0.06597540f, 0.13303994f, 0.13084158f, 
    0.22426739f, -0.12211483f, -0.19086620f, -0.01427276f, -0.08229273f, -0.04823821f, 0.25950027f, 0.35334960f, 
    0.31468451f, -0.28541365f, -0.07827707f, -0.25400004f, 0.50912642f, 0.48785603f, 0.34039345f, 0.23318833f, 
    0.04409983f, -0.04169095f, 0.24003783f, -0.04408382f, 0.03146830f, 0.16263461f, 0.11197315f, -0.20164859f, 
    -0.08533107f, -0.26006138f, 0.05779497f, 0.06802262f, 0.27391040f, -0.11745168f, -0.17794251f, -0.28460339f, 
    -0.02276661f, 0.03728438f, -0.14359096f, 0.06123728f, -0.04651863f, 0.58513230f, 0.22720431f, -0.13811232f, 
    0.32614651f, 0.25060999f, 0.15020378f, 0.04793242f, -0.11586180f, -0.34863684f, -0.53129458f, -0.00643232f, 
    0.01030754f, 0.06400774f, -0.01586088f, 0.00800506f, -0.04490362f, -0.06982917f, 0.23289897f, 0.16133823f, 
    0.03462597f, 0.19283850f, -0.25103733f, -0.22298302f, -0.22636497f, -0.35021025f, -0.68375218f, -0.42218891f, 
    -0.21939744f, -0.59817350f, 0.08013449f, -0.42539635f, -0.01621220f, 0.38724759f, -0.39400643f, -0.72411650f, 
    0.32172829f, 0.06561071f, 0.02935700f, -0.10146111f, -0.17137049f, -0.50243074f, -0.56734997f, 0.09723289f, 
    -0.42127132f, -0.24972047f, 0.16819459f, 0.19310112f, 0.02067616f, -0.16039228f, 0.35405576f, 0.21282965f, 
    0.02116711f, 0.11624178f, 0.74325079f, -0.08414640f, 0.54923671f, -0.04427615f, -0.43172002f, -0.53189546f, 
    -0.27822578f, -0.01176610f, 0.19575678f, 0.03336646f, 0.04980335f, 0.17329825f, -0.31176376f, -0.17814164f, 
    -0.11452623f, -0.09456701f, 0.44742620f, -0.21557635f, 0.06136437f, -0.11692219f, 0.23945592f, -0.09109799f, 
    -0.44603735f, -0.73777944f, -0.08496030f, 0.35833690f, 0.55808163f, 0.39790997f, 0.48306915f, 0.17893519f, 
    -0.13445061f, 0.13647738f, -0.25286859f, -0.27304983f, -0.60118848f, -0.20245333f, -0.03771448f, 0.11290216f, 
    0.31143266f, -0.04055451f, 0.10154679f, -0.14287572f, -0.11356660f, -0.14562969f, -0.19776727f, -0.27592626f, 
    -0.07101671f, -0.15490755f, 0.05400921f, 0.21492234f, -0.29615980f, -0.30451515f, 0.29396763f, 0.30654457f, 
    0.09215811f, 0.02063645f, 0.02593999f, -0.11648763f, -0.21256544f, 0.24731787f, -0.29347220f, -0.33554253f, 
    0.07769243f, -0.31262639f, -0.04744291f, -0.30540478f, 0.05418306f, 0.10234279f, 0.31796804f, -0.17109877f, 
    0.03300608f, 0.55140650f, -0.83790386f, -0.18484023f, -0.36392409f, -0.47243306f, -0.22788677f, 0.38160586f, 
    0.21940604f, 0.50825948f, -0.41523236f, -0.44976088f, 0.23767798f, 0.06316565f, -0.08014681f, 0.52128172f, 
    -0.20415273f, -0.06131233f, 0.07714228f, -0.36144501f, -0.43151996f, 0.35537106f, 0.16977707f, -0.48130241f, 
    -0.02711218f, 0.21480855f, 0.19079284f, 1.08948183f, -0.90038681f, -0.93385154f, -0.28327382f, -0.46900332f, 
    0.65997124f, 0.35808775f, 0.37249279f, 0.10249960f, 0.13022979f, -0.27102229f, 0.52326882f, -0.10416075f, 
    0.15129024f, -0.32434401f, -0.07093608f, -0.11518931f, 0.14888191f, -0.01470680f, -0.05339359f, -0.08721206f, 
    -0.22858241f, 0.05668085f, 0.17442144f, 0.11730874f, 0.61346221f, -0.47058719f, -0.26026714f, 0.40562600f, 
    -0.12663318f, 0.49536934f, 0.31759521f, 0.24626856f, 0.21579978f, 0.09563581f, -0.25945100f, 0.05123482f, 
    -0.12326577f, -0.14334136f, -0.19862239f, 0.26133758f, -0.13343740f, -0.00863085f, -0.18476242f, -0.26955262f, 
    -0.21923913f, 0.10510951f, 0.22064981f, -0.06927798f, -0.18010902f, 0.04829306f, -0.60416615f, -0.13886298f, 
    -0.67299229f, -0.77052051f, 0.05494788f, -0.30402735f, 0.10671516f, 0.31639388f, 0.50692993f, 0.22315706f, 
    -0.21453607f, -0.23762073f, -0.19402710f, -0.18123809f, 0.20349154f, -0.02805144f, 0.28627121f, 0.20957182f, 
    0.07446568f, -0.10836951f, -0.11131874f, -0.47279578f, -0.31687641f, 0.16781081f, 0.20319065f, -0.42166704f, 
    -0.02430311f, -0.44956177f, 0.41972962f, 0.22791739f, 0.12321988f, 0.00312908f, 0.14951277f, -0.18664873f, 
    0.15351491f, -0.00448574f, -0.05581556f, -0.32395330f, 0.13392356f, -0.27015296f, -0.38672441f, -0.43879703f, 
    -0.37480071f, -0.38102934f, 0.28149009f, -0.08910388f, -0.18425924f, -0.01061581f, 0.13809282f, 0.56263691f, 
    0.60646904f, 0.25754836f, 0.02670618f, -0.66140032f, -0.52168137f, -0.21500544f, -0.02285560f, -0.07489946f, 
    -0.07370494f, 0.31579736f, -0.01054598f, -0.27852216f, -0.26222971f, 0.28085282f, 0.07812759f, -0.14785960f, 
    -0.12081694f, 0.31124130f, -0.12902738f, -0.11016534f, 0.20274526f, -0.29298458f, -0.34152859f, -0.16904004f, 
    0.30798352f, 0.65944237f, 0.16516641f, -0.37807497f, 0.62594485f, -0.45442516f, -0.31189841f, -0.21225388f, 
    0.00905486f, -0.25341001f, -0.23699287f, -0.36442572f, -0.09550133f, 0.38415730f, 0.10075027f, -0.04617828f, 
    0.00077202f, 0.06906161f, 0.16313837f, -0.03545133f, -0.04424709f, 0.07734589f, -0.07604159f, 0.28500974f, 
    -0.16966762f, 0.30345678f, -0.21549608f, 0.19735801f, 0.30621532f, -0.35887074f, -0.34871975f, -0.40973908f, 
    -0.14222942f, -0.04165519f, -0.12378536f, 0.51559263f, -0.38296494f, 0.19483066f, 0.20180301f, -0.06727663f, 
    -0.05393174f, 0.23933405f, -0.01064989f, -0.22667326f, -0.39908904f, -0.15243043f, -0.02905095f, 0.22951317f, 
    0.34319252f, 0.23860973f, -0.29094404f, -0.73819369f, 0.38896701f, 0.43700218f, 0.67572320f, -0.41094437f, 
    -0.30703688f, -0.70928365f, -0.56523907f, -0.13957794f, -0.28155622f, -0.25736821f, 0.49079224f, -0.26099488f, 
    0.07349072f, -0.00674401f, -0.27152643f, 0.20271601f, 0.31846458f, -0.15664759f, 0.31612930f, -0.23830193f, 
    -0.11864089f, 0.21884170f, -0.07865260f, -0.48334646f, -0.05301722f, -0.34758833f, -0.45126587f, -0.31180632f, 
    -0.36759269f, -0.34091723f, -0.50906777f, -0.57758963f, -0.58820605f, 0.16868700f, -0.27887577f, -0.08916646f, 
    -0.16227227f, -0.27764374f, -0.26157624f, -0.23732933f, -0.18065220f, -0.26267055f, -0.13997410f, -0.13580872f, 
    -0.26234388f, 0.13630970f, 0.24694419f, -0.04916940f, 0.91710979f, 0.77942246f, -0.40963027f, -0.72563154f, 
    -0.87708896f, -0.29627356f, -0.10076614f, 0.18322697f, 0.06304373f, -0.01236834f, 0.20746303f, 0.23426943f, 
    0.19909292f, 0.16025861f, -0.16032003f, 0.12319528f, -0.02565287f, -0.14280517f, 0.04069792f, -0.00532458f, 
    0.26364028f, -0.22331181f, -0.25223228f, -0.22141385f, 0.34830028f, -0.40769783f, -0.29416975f, 0.47104067f, 
    0.37679547f, -0.42404407f, -0.54285896f, -0.35102263f, 0.10786598f, 0.21953920f, 0.21559657f, 0.05000521f, 
    0.11835961f, -0.17401117f, -0.06005497f, 0.36413744f, 0.00516299f, 0.00722219f, -0.16378550f, -0.17068571f, 
    -0.44592577f, 0.20104758f, 0.28872225f, 0.09438120f, -0.07255901f, 0.22698192f, -0.06779666f, 0.28030837f, 
    -0.11691973f, -0.26450968f, 0.37175965f, -0.08998405f, 0.11637269f, 0.29044086f, 0.02389537f, -0.14110355f, 
    0.21851251f, 0.15102468f, -0.21419293f, 0.33622056f, -0.35729584f, 0.36425689f, 0.15292877f, -0.48406774f, 
    -0.07601789f, -0.11188677f, -0.00292589f, -0.11427820f, 0.19553697f, 0.38102028f, -0.14266045f, -0.13075745f, 
    -0.40890324f, -0.84927326f, -0.59545732f, 0.01613563f, -0.07621830f, -0.24053374f, -0.12902243f, 0.14759663f, 
    -0.16692325f, 0.41181520f, 0.49828246f, 0.32871184f, 0.23342738f, -0.10641983f, 0.11016465f, -0.01555166f, 
    -0.25022766f, -0.21924652f, -0.25218123f, -0.23294148f, -0.24706848f, 0.00855167f, -0.35996643f, -0.41041771f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18121886f, 0.17916942f, 0.26341990f, 0.12034097f, 0.23419975f, 0.00905818f, 0.35199654f, -0.15363985f, 
    0.14520365f, 0.17856999f, 0.24986736f, 0.18019105f, 0.13962936f, -0.08475177f, 0.48847464f, -0.01554412f, 
    0.14647450f, 0.21381991f, 0.26422349f, 0.00432934f, -0.14091022f, -0.32384962f, 0.34611821f, 0.07824595f, 
    0.01433721f, 0.24545330f, 0.22105850f, -0.11361728f, 0.39576283f, 0.14989443f, 0.07110746f, -0.46115798f, 
    0.13703221f, 0.16002190f, 0.21431471f, 0.23217538f, 0.03404331f, 0.09058139f, 0.12164970f, 0.23884413f, 
    0.04065398f, -0.08534380f, 0.37236780f, 0.17787127f, -0.18607283f, -0.01181088f, 0.13047403f, 0.09491313f, 
    0.07341465f, -0.08083472f, 0.31014341f, 0.25780439f, 0.19236861f, 0.03732406f, 0.02934494f, 0.29998592f, 
    0.14942622f, 0.15885876f, 0.31210512f, -0.29789153f, 0.22538275f, 0.24190047f, 0.04605043f, 0.01293599f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01571155f, -0.03487997f, -0.04246788f, 0.02506974f, -0.18297648f, -0.05198579f, -0.01434748f, 0.06134614f, 
    -0.01602303f, -0.06348602f, -0.08408620f, -0.01169178f, -0.10388482f, -0.12883261f, 0.12959097f, 0.00851213f, 
    -0.12102000f, -0.10140179f, 0.00453308f, 0.05184500f, 0.00630704f, -0.11239278f, -0.14854731f, -0.13431153f, 
    0.20397966f, 0.19931009f, 0.28912497f, -0.21822278f, 0.06817747f, -0.00313221f, 0.02565807f, 0.00580045f, 
    -0.11219962f, -0.07698311f, -0.04808650f, -0.02436331f, 0.30397680f, 0.21671192f, 0.20290387f, -0.14956260f, 
    0.06569236f, 0.04121155f, 0.07410851f, 0.00833359f, -0.02215610f, 0.08700295f, 0.04750985f, 0.06086773f, 
    -0.01597795f, -0.05135131f, 0.01309830f, 0.02756912f, -0.05006136f, -0.04161507f, -0.04868073f, -0.03775405f, 
    -0.13805214f, -0.04121600f, 0.07747497f, -0.10607185f, 0.39200792f, 0.27158803f, -0.15580802f, -0.10232597f, 
    0.10379920f, 0.04838091f, 0.15334216f, 0.01767886f, 0.00411940f, 0.00452896f, 0.01628696f, 0.00021722f, 
    -0.19195491f, -0.00333122f, -0.13911523f, -0.10632197f, -0.02460587f, 0.02461709f, -0.02083010f, -0.02475834f, 
    -0.10516793f, -0.10145158f, 0.06776601f, -0.04713668f, 0.06218927f, 0.16795783f, -0.02803116f, 0.05555047f, 
    -0.06200641f, -0.08775988f, -0.06924225f, -0.30165148f, 0.00728822f, 0.01694888f, -0.03080994f, 0.00033294f, 
    0.21308979f, 0.07841570f, -0.05281534f, -0.08589039f, 0.00565159f, 0.03003388f, 0.04554890f, -0.05437252f, 
    0.01823709f, -0.04603114f, -0.08204584f, -0.12978755f, 0.30626872f, 0.33187276f, 0.23646648f, -0.41239032f, 
    -0.04590697f, 0.10535071f, 0.07103539f, -0.06107635f, -0.05563804f, -0.10588624f, -0.22150490f, -0.15556616f, 
    -0.17880102f, -0.15126631f, -0.13342810f, -0.08083532f, -0.00134829f, 0.00721527f, 0.06108480f, 0.03985749f, 
    -0.10081896f, -0.01918156f, -0.06719080f, -0.15632038f, -0.16638632f, 0.02825681f, -0.14498053f, 0.12907811f, 
    0.01798123f, 0.01471326f, -0.02099073f, 0.05249155f, 0.00859453f, -0.04210018f, 0.03718135f, 0.00760731f, 
    0.27647680f, 0.18521668f, -0.01409193f, -0.22849753f, 0.13112985f, 0.11068668f, -0.11195765f, -0.01049841f, 
    0.03638639f, 0.02850681f, 0.06968037f, -0.02456391f, 0.01579808f, -0.00799343f, -0.01694101f, 0.05031900f, 
    -0.08675881f, -0.01139914f, 0.15771617f, -0.03414301f, -0.01209142f, 0.00927385f, -0.01760613f, 0.00525584f, 
    -0.26383442f, -0.46988589f, -0.27120504f, 0.07297152f, -0.01321325f, 0.00767236f, 0.04433849f, -0.02908285f, 
    -0.00995471f, -0.08805803f, -0.07289744f, -0.10103817f, 0.33152026f, 0.23510826f, -0.13732083f, -0.16596802f, 
    0.07778839f, -0.02675007f, 0.01651696f, 0.11630970f, -0.00138132f, 0.01110178f, 0.02849261f, -0.03995012f, 
    -0.84602112f, -0.30574071f, 0.27783832f, 0.07748345f, 0.02256444f, 0.01294329f, -0.04742675f, 0.13062637f, 
    0.16951887f, -0.22762008f, -0.05511786f, 0.07210634f, -0.00820510f, 0.05043885f, 0.15748954f, -0.21978740f, 
    -0.02731367f, 0.06128269f, -0.09770962f, -0.11337253f, -0.01199380f, -0.05898310f, -0.07915036f, -0.16637738f, 
    0.05789170f, 0.17606568f, 0.18815178f, 0.17077668f, 0.00059951f, 0.00768512f, 0.06352242f, 0.04576953f, 
    0.01440330f, 0.01825767f, 0.03137753f, 0.00986792f, 0.00632608f, -0.01458526f, 0.05856736f, 0.05333754f, 
    -0.03642502f, 0.00646740f, 0.01869034f, -0.03998126f, -0.03044610f, -0.02918092f, 0.00394889f, 0.00765634f, 
    0.26721886f, 0.19229481f, -0.12456274f, -0.16137855f, 0.03019907f, 0.07310247f, 0.00691593f, -0.07294484f, 
    -0.00598696f, -0.04356467f, 0.02626391f, -0.01028260f, -0.28085619f, -0.25530979f, 0.12147997f, -0.14238526f, 
    -0.02540668f, -0.00581377f, -0.06764045f, 0.06533634f, 0.08606187f, -0.06703169f, 0.15700811f, 0.20819944f, 
    -0.19133383f, 0.05794308f, -0.01656871f, -0.06433310f, -0.17018370f, 0.01645016f, -0.04036777f, -0.06491755f, 
    0.01004179f, -0.06014145f, -0.09267514f, -0.03164012f, -0.36257881f, -0.18892288f, -0.11515144f, 0.00027950f, 
    0.01069137f, 0.05394859f, 0.01034272f, -0.00562403f, -0.22714359f, -0.02931898f, -0.25586817f, -0.07101884f, 
    0.15371986f, 0.15759179f, -0.32350892f, -0.05102699f, -0.13233797f, -0.08851271f, -0.09317060f, -0.10352933f, 
    -0.07890314f, -0.06951408f, 0.03098468f, 0.07169908f, 0.14249143f, -0.33920589f, -0.22365867f, 0.06998034f, 
    0.06673598f, 0.12538843f, -0.24737123f, -0.08859247f, -0.06576903f, -0.13685459f, -0.09903553f, 0.01125809f, 
    -0.27433646f, 0.07056218f, 0.24723928f, -0.18590909f, -0.05071138f, 0.00244399f, -0.00911532f, 0.06111415f, 
    -0.18296319f, -0.10378776f, -0.30726457f, 0.09549253f, 0.02290361f, -0.00173587f, -0.10240825f, 0.11766980f, 
    0.13227224f, -0.03862356f, -0.18325216f, -0.11225246f, -0.02594548f, -0.07270870f, -0.13798077f, 0.03010560f, 
    -0.30548173f, -0.62483001f, -0.44896239f, -0.04030518f, 0.01996668f, 0.06197108f, -0.07499067f, -0.06149220f, 
    -0.19178788f, -0.15528631f, -0.15170974f, -0.17079459f, 0.01493838f, -0.05245305f, 0.03203772f, -0.04544490f, 
    -0.07551286f, 0.01506606f, 0.01126886f, -0.05748213f, 0.04191312f, -0.02684747f, -0.02310910f, -0.01004171f, 
    0.38896799f, -0.13987008f, -0.46137527f, -0.00520996f, 0.07851952f, 0.12094274f, 0.06380817f, -0.01399927f, 
    -0.06327742f, -0.03696762f, -0.00058272f, 0.06385846f, 0.24704538f, 0.18705091f, 0.19194320f, -0.11030979f, 
    0.16241649f, 0.11747117f, 0.08796640f, 0.19691952f, -0.05841212f, 0.02813787f, -0.01358705f, 0.01639927f, 
    -0.00962270f, 0.14894730f, -0.18280905f, -0.12164379f, -0.00027091f, -0.11810071f, 0.06104613f, -0.03882637f, 
    -0.03621380f, -0.03074466f, 0.04515250f, -0.02352274f, -0.27009204f, -0.28719312f, -0.06684321f, -0.15349282f, 
    -0.04705519f, -0.08403809f, 0.06314476f, 0.05076160f, -0.02252827f, 0.01553785f, -0.01928366f, 0.03093089f, 
    0.36244294f, -0.19189864f, -0.00250710f, -0.15968169f, -0.07533801f, -0.09201812f, 0.10605000f, 0.05689471f, 
    -0.01977325f, -0.05643691f, -0.03446272f, -0.15889916f, -0.71299207f, -0.20950298f, 0.15812489f, 0.06640233f, 
    0.00543079f, -0.01726811f, 0.03295959f, 0.00618275f, 0.08150458f, 0.00884667f, 0.09160511f, 0.00928608f, 
    0.03994170f, -0.02335323f, 0.00998195f, 0.06601884f, -0.05676234f, 0.00254853f, -0.02325465f, -0.12324601f, 
    -0.18008763f, -0.09432535f, 0.07579326f, -0.00378058f, -0.00999736f, 0.13466196f, -0.52345157f, 0.01490302f, 
    0.07694966f, 0.08798215f, -0.09402140f, -0.03857450f, -0.03017645f, -0.00394098f, -0.05011056f, 0.00154488f, 
    -0.22262789f, -0.15335079f, -0.00370413f, 0.11042118f, 0.03762911f, 0.01862921f, -0.03843419f, -0.02023373f, 
    -0.07283794f, 0.01435699f, -0.05081576f, 0.05806417f, 0.38151118f, 0.07239407f, 0.04233225f, -0.33405760f, 
    -0.16183318f, 0.00528351f, 0.12579799f, -0.05917844f, -0.05540279f, 0.02238689f, -0.05599600f, -0.03559630f, 
    0.04984201f, 0.19549893f, -0.14745423f, 0.04806338f, -0.07158941f, -0.01139940f, -0.15432972f, -0.04569048f, 
    -0.04741943f, -0.02789792f, 0.07571392f, 0.05474354f, -0.07426251f, -0.00859739f, -0.01907344f, 0.02956132f, 
    0.04757212f, 0.03472976f, 0.02692163f, -0.01236260f, -0.04734487f, 0.01128934f, -0.05891935f, -0.09253915f, 
    0.27797821f, -0.01551642f, -0.05273842f, -0.20088732f, 0.00623392f, 0.02639382f, 0.01208273f, -0.06865892f, 
    0.03895547f, -0.15268196f, -0.02451559f, 0.08170035f, -0.03319812f, -0.01240570f, 0.07967186f, -0.02644414f, 
    -0.04874805f, -0.00581371f, 0.01931418f, 0.01778973f, 0.00054899f, -0.01569647f, 0.03977272f, -0.13312089f, 
    -0.29241791f, -0.20231447f, -0.21226756f, 0.01908604f, 0.05427583f, 0.00876497f, 0.00138211f, 0.05296472f, 
    -0.00808015f, 0.00485460f, 0.03111460f, 0.06536206f, -0.09848074f, -0.08293176f, -0.20922866f, 0.20849456f, 
    0.01199051f, -0.08317576f, -0.09242020f, -0.02289922f, -0.02222331f, 0.06081458f, 0.04984666f, 0.00197420f, 
    0.20817940f, 0.23027827f, -0.08391149f, -0.15377294f, 0.10641183f, 0.12749092f, 0.00856030f, -0.11889725f, 
    -0.05062544f, -0.19097456f, -0.07793054f, -0.11840548f, -0.01817428f, -0.23763160f, -0.18076766f, 0.00725361f, 
    -0.03947765f, -0.02889106f, -0.05876420f, 0.04427361f, -0.01924909f, -0.01834614f, 0.03432516f, -0.05295177f, 
    0.50467300f, -0.00395918f, -0.09699594f, -0.11909381f, -0.00362663f, 0.00845159f, 0.12838884f, 0.07803035f, 
    -0.06487395f, 0.16998279f, 0.04979708f, 0.10110105f, 0.08643109f, -0.19828714f, -0.17316233f, -0.04057268f, 
    0.02005698f, 0.04772571f, 0.02817222f, 0.01912712f, 0.02567098f, -0.04482155f, -0.09561136f, -0.13760662f, 
    0.23352659f, 0.04790863f, -0.05433721f, -0.20432371f, 0.03213865f, 0.11599891f, -0.07727163f, 0.10864735f, 
    -0.18874401f, -0.10060604f, 0.06851199f, -0.02854823f, 0.03301175f, -0.24112394f, -0.48723727f, 0.12047485f, 
    0.16605404f, 0.03075619f, -0.05496783f, -0.17162223f, 0.02665922f, -0.01786470f, -0.06241394f, -0.07579854f, 
    -0.09434459f, -0.31142816f, -0.46230388f, 0.08111674f, 0.04173735f, 0.00098763f, 0.06855370f, 0.01025707f, 
    -0.02812981f, -0.01964526f, -0.18905537f, -0.00574600f, 0.19683212f, 0.15506478f, 0.06485701f, -0.06853024f, 
    0.10671217f, 0.16009621f, 0.07523229f, 0.10754460f, 0.07961328f, 0.08755159f, 0.11736505f, 0.00577678f, 
    -0.04124747f, -0.20762503f, -0.33973575f, -0.06801756f, -0.05388315f, 0.04084723f, 0.03798288f, -0.01145455f, 
    -0.08489055f, -0.02314815f, -0.00219938f, -0.06535778f, -0.33076701f, -0.17124590f, 0.09612468f, -0.07369903f, 
    -0.01341932f, 0.04151626f, -0.00830634f, -0.13189365f, -0.09279181f, 0.00625124f, 0.05361727f, -0.06849211f, 
    -0.22098352f, 0.20995846f, 0.05285521f, 0.02548466f, -0.05259651f, -0.00731104f, -0.05909330f, -0.13061033f, 
    0.00614566f, -0.04198601f, 0.01367033f, -0.00350883f, -0.01384819f, 0.05501561f, 0.08964990f, -0.27585840f, 
    0.06601066f, 0.10867856f, -0.06800473f, -0.14034721f, -0.00154961f, 0.01794445f, -0.05143244f, -0.02945592f, 
    0.35719153f, 0.26720247f, -0.08916952f, -0.24640772f, 0.08229976f, -0.08488864f, -0.04285076f, 0.04695747f, 
    -0.02348510f, -0.03548646f, -0.05259421f, -0.04039603f, 0.28796405f, 0.21690662f, -0.06612750f, -0.14679930f, 
    0.15356722f, 0.13861281f, 0.09768502f, 0.04263260f, -0.07586538f, -0.08255574f, -0.08860822f, -0.11023248f, 
    0.04023292f, -0.10880022f, -0.05683731f, 0.05400648f, -0.02045171f, -0.17638639f, -0.05821117f, -0.22888799f, 
    -0.11363386f, 0.00012868f, 0.03963169f, 0.01607365f, -0.13698936f, 0.04592304f, 0.21666203f, -0.12709765f, 
    -0.05457545f, 0.08668050f, 0.07023157f, -0.07038791f, 0.00086281f, -0.13877632f, -0.14607459f, -0.10748396f, 
    -0.10540389f, 0.02726111f, 0.01869495f, -0.01710178f, -0.00503883f, -0.02123731f, 0.09724230f, 0.01049881f, 
    -0.09473378f, -0.03085449f, -0.41265228f, 0.16959979f, 0.27591494f, 0.07989644f, -0.13632630f, -0.00533169f, 
    0.00931922f, 0.10008189f, 0.00916499f, -0.01743937f, -0.01648276f, 0.09063850f, -0.02774637f, 0.02694123f, 
    0.11968214f, -0.02674210f, 0.05282285f, 0.04674013f, 0.07714256f, 0.03006112f, 0.08974966f, -0.11100018f, 
    0.04504114f, -0.06252261f, -0.04187054f, -0.01222877f, 0.02622547f, -0.14524339f, 0.17802246f, -0.11697374f, 
    0.02801317f, 0.03012287f, -0.05542249f, -0.01615694f, 0.11976220f, -0.04144526f, 0.03870371f, -0.05224189f, 
    -0.63327432f, 0.12215594f, -0.00712511f, -0.01901573f, 0.06692642f, 0.02486230f, 0.06538913f, -0.01083866f, 
    0.04797811f, -0.00113585f, -0.01199165f, -0.07055806f, 0.10331874f, 0.13931365f, -0.16066507f, -0.14709362f, 
    -0.09920679f, -0.03876394f, -0.01725287f, -0.02712877f, -0.21048929f, -0.18270069f, -0.17226528f, -0.18512186f, 
    -0.06990803f, -0.05507502f, 0.04872717f, -0.03595219f, 0.04033074f, -0.14695928f, -0.01522009f, -0.00317562f, 
    0.16260532f, 0.01250143f, 0.01127563f, 0.03938478f, 0.06049635f, 0.04995024f, -0.07906162f, 0.16823189f, 
    -0.20351221f, 0.03857296f, 0.06751417f, -0.09310837f, -0.02951544f, -0.04714521f, -0.08901493f, 0.01897402f, 
    -0.21202810f, -0.01420146f, 0.14011556f, -0.07726628f, -0.00968875f, 0.08682136f, -0.02096988f, 0.09066965f, 
    0.08439209f, 0.00580300f, 0.00610253f, 0.03969036f, 0.03643175f, -0.04562533f, 0.00766357f, -0.06582371f, 
    0.14048852f, 0.10509756f, -0.02788858f, -0.05927253f, -0.11791436f, 0.01647343f, -0.01424483f, -0.00156719f, 
    0.05191507f, -0.08362375f, -0.00373439f, -0.04990682f, -0.06050198f, -0.07278690f, 0.03041628f, -0.03245586f, 
    -0.07844877f, -0.06923508f, 0.11793788f, -0.06345360f, -0.72517949f, 0.10983852f, -0.21760979f, -0.10025036f, 
    -0.05796394f, -0.10074307f, 0.12189864f, 0.07798167f, -0.06376287f, 0.04523811f, -0.07505579f, -0.04266805f, 
    0.29173169f, 0.12802044f, -0.01393632f, 0.07320366f, -0.02368403f, -0.11797702f, 0.00352416f, 0.07989461f, 
    -0.11396553f, 0.16272585f, -0.17629024f, -0.03177641f, 0.13052686f, 0.03081979f, 0.07020942f, -0.00540835f, 
    -0.03533449f, -0.04291331f, 0.02588261f, -0.00790856f, -0.08258961f, -0.01230877f, -0.00382789f, 0.03997077f, 
    0.13749865f, 0.13225159f, 0.06645813f, -0.14287804f, -0.10948931f, -0.02014859f, -0.11342122f, -0.07652951f, 
    -0.03333159f, 0.03116029f, 0.02041405f, -0.01792878f, 0.04218736f, 0.02423841f, -0.04785652f, -0.01097198f, 
    0.09109703f, 0.00656555f, -0.06157987f, 0.01071236f, 0.01716593f, 0.00207775f, 0.06586657f, -0.01265458f, 
    0.38408455f, -0.08023728f, 0.13673614f, 0.06447142f, -0.03487660f, -0.06670462f, 0.04973128f, -0.01127241f, 
    0.06610723f, 0.00605116f, -0.05176124f, 0.11216957f, -0.12163122f, -0.08677131f, 0.10123537f, 0.11415019f, 
    0.10867424f, -0.14287630f, 0.14561506f, -0.23963399f, 0.02684074f, 0.03117657f, 0.01942652f, 0.04737520f, 
    -0.06178381f, -0.13594142f, -0.02675562f, -0.20812240f, 0.10305058f, -0.02587166f, -0.01954046f, -0.00978962f, 
    -0.06123859f, 0.11738936f, -0.11728229f, -0.32309178f, -0.15799989f, -0.06769941f, 0.01715316f, -0.17914748f, 
    0.01009604f, 0.09769532f, -0.08068670f, 0.17601007f, -0.01373583f, 0.00161416f, 0.09549741f, 0.05390910f, 
    -0.05191271f, 0.04046929f, 0.02082272f, 0.34250477f, -0.06186432f, 0.01862670f, 0.01917785f, 0.01079006f, 
    0.09961129f, 0.03867193f, -0.02027452f, 0.07276389f, 0.01634063f, 0.03253217f, 0.09563227f, 0.04343997f, 
    -0.02536388f, 0.01990687f, -0.05491497f, -0.00568218f, -0.01232281f, -0.01542332f, -0.03573526f, 0.00622428f, 
    0.04116825f, 0.21514702f, 0.28590554f, 0.27812639f, -0.01542969f, 0.03387107f, -0.11028059f, 0.09729851f, 
    -0.07105901f, 0.04596119f, 0.02059463f, -0.02154271f, 0.04765305f, 0.02402015f, 0.00833696f, -0.20915462f, 
    -0.00013269f, 0.03961246f, -0.05411895f, -0.00199548f, -0.23375963f, -0.20145655f, -0.20066613f, -0.40472037f, 
    0.07640719f, 0.30198118f, -0.02273431f, -0.02981924f, -0.15251756f, 0.05005502f, 0.03953397f, -0.05044019f, 
    -0.02001283f, 0.03811358f, 0.02194683f, -0.01900033f, 0.07244586f, -0.01964926f, -0.06268116f, -0.07223217f, 
    0.06820852f, 0.01964469f, -0.06321465f, 0.02068278f, -0.04966997f, -0.13291356f, -0.18417732f, -0.00941261f, 
    0.17792346f, -0.58100408f, 0.08118836f, -0.11817244f, -0.13633780f, -0.10369515f, -0.06365224f, -0.04128663f, 
    0.04215169f, 0.06921310f, 0.00901236f, 0.02633268f, 0.22349028f, -0.25962344f, -0.10703465f, -0.10640734f, 
    0.00015633f, -0.01555358f, 0.15645213f, -0.00941073f, 0.01013468f, -0.06296378f, 0.05826793f, -0.06375334f, 
    -0.31918553f, -0.23606977f, -0.02769207f, -0.18788347f, 0.03686278f, 0.01658117f, 0.15511551f, 0.04420805f, 
    -0.07263033f, 0.02237382f, 0.03281453f, 0.04646618f, 0.13498221f, 0.02162085f, 0.00103338f, 0.02178753f, 
    -0.09803967f, -0.04981353f, 0.06116496f, -0.00076439f, -0.12626612f, -0.07189009f, -0.00597539f, -0.10326611f, 
    0.32357201f, 0.06095992f, 0.25566667f, -0.09413129f, -0.03184982f, -0.05015700f, 0.00087903f, 0.04841444f, 
    0.13689229f, 0.10190115f, 0.14550912f, -0.03093477f, -0.04995711f, 0.02703560f, -0.00763196f, -0.07418545f, 
    0.20726320f, 0.02597503f, -0.01643710f, -0.18545334f, -0.00207385f, 0.00250215f, -0.14879885f, 0.03241082f, 
    0.15348051f, -0.38896716f, 0.05273320f, -0.00141365f, 0.02954494f, 0.02162494f, -0.06262632f, -0.00992983f, 
    0.01208451f, -0.15678503f, -0.07923838f, 0.05207788f, 0.27949616f, 0.12532970f, 0.22923240f, -0.08524109f, 
    0.14042494f, -0.05197167f, -0.13284142f, -0.31065455f, -0.02135452f, 0.02699341f, -0.01580046f, 0.04041407f, 
    -0.05098073f, 0.07201342f, -0.11707632f, -0.02322755f, -0.02588148f, 0.05126981f, -0.13074349f, 0.19482440f, 
    -0.04466025f, 0.00597999f, -0.00859117f, 0.06395491f, 0.00055309f, 0.08357997f, -0.06560253f, 0.09924692f, 
    0.03577963f, -0.03833804f, 0.05487316f, 0.00544614f, -0.01329905f, -0.00069505f, -0.01755298f, 0.00739660f, 
    0.14305504f, -0.29050165f, 0.24143751f, -0.03476320f, -0.03328361f, 0.04576538f, -0.01130638f, -0.00865305f, 
    0.07462467f, 0.06506939f, 0.14730717f, 0.00617885f, -0.19941433f, 0.03687286f, 0.16601491f, 0.06342699f, 
    -0.03853445f, -0.12320416f, 0.00419761f, -0.01236695f, -0.07992145f, 0.10969760f, -0.07794176f, -0.12537970f, 
    0.04196004f, -0.08942117f, 0.05719198f, -0.08662260f, -0.06522563f, -0.01971970f, -0.07177006f, -0.00172740f, 
    0.08879476f, 0.17157449f, -0.16063796f, 0.03113534f, 0.03491374f, -0.14757657f, -0.39148119f, -0.14708649f, 
    -0.24468981f, -0.08746505f, -0.00438992f, -0.02188817f, 0.00760200f, 0.03068933f, -0.08621389f, 0.06548970f, 
    0.07558430f, -0.14089750f, 0.11741421f, -0.12431423f, 0.02287216f, 0.02762789f, -0.08477841f, -0.02524522f, 
    0.26030540f, -0.07680850f, -0.09990799f, 0.04821496f, -0.01219645f, -0.02776600f, 0.04387727f, -0.22656247f, 
    0.13610658f, -0.05994065f, 0.00992603f, -0.02431756f, 0.19151767f, 0.01181089f, 0.00452978f, -0.19405685f, 
    0.25817055f, -0.26309624f, 0.08322574f, -0.12250219f, 0.10284905f, 0.01304813f, -0.10268391f, 0.01921730f, 
    -0.37908715f, -0.19671316f, -0.13244900f, -0.22456829f, 0.11604950f, 0.03185641f, -0.09555903f, 0.03566195f, 
    -0.04331442f, -0.06468462f, -0.02194880f, 0.05913726f, -0.05591964f, 0.02596049f, -0.13770983f, 0.08253126f, 
    -0.04236422f, -0.05805909f, 0.03872686f, -0.36518827f, 0.05441326f, 0.16118431f, -0.14740311f, 0.13231191f, 
    -0.00362557f, 0.00220396f, 0.02806008f, -0.05472906f, -0.05087062f, 0.15993792f, -0.05442506f, 0.05214504f, 
    0.04782485f, -0.11449760f, 0.02709552f, 0.02297341f, -0.04487694f, -0.07459378f, 0.04093235f, 0.04882641f, 
    0.27343327f, 0.22268103f, 0.15272039f, 0.11765753f, -0.02473878f, 0.00203009f, 0.00306928f, -0.02416554f, 
    -0.04545290f, 0.04488507f, -0.07797230f, 0.04726135f, 0.09982192f, 0.08642100f, 0.00595155f, -0.01555280f, 
    -0.04756260f, -0.23994242f, -0.06826675f, 0.07112259f, -0.02584203f, -0.05668228f, 0.10225895f, 0.05674420f, 
    -0.37896901f, 0.07595387f, 0.14266817f, -0.04438665f, 0.11525456f, 0.06189294f, 0.13058205f, 0.22794977f, 
    -0.11084912f, 0.04503653f, -0.06560677f, 0.07388084f, 0.10643014f, 0.07701239f, -0.09089699f, 0.09163924f, 
    -0.03948800f, -0.14762524f, 0.06315838f, -0.06749723f, 0.04097930f, -0.04342312f, 0.03437676f, 0.09424330f, 
    0.19456472f, -0.07500175f, 0.09973473f, 0.25314096f, -0.03207954f, 0.00568680f, -0.01757277f, -0.06172511f, 
    0.29110995f, -0.09384266f, -0.27361694f, 0.12597814f, 0.07673728f, 0.00732625f, -0.01163217f, -0.00345379f, 
    -0.22267278f, 0.04498729f, 0.00907203f, -0.00044971f, 0.01743537f, 0.06523276f, -0.01337492f, -0.03414147f, 
    -0.19164962f, -0.26902485f, 0.14701058f, -0.07921262f, 0.06611613f, 0.15263447f, 0.43920738f, -0.18896665f, 
    0.09032302f, 0.01929590f, 0.06825630f, -0.04701662f, 1.03816593f, -0.14728515f, -0.43700334f, -0.18653178f, 
    -0.00575741f, 0.01438674f, 0.07915904f, -0.10507125f, 0.22023755f, 0.07653544f, -0.01392808f, 0.04133574f, 
    0.53942513f, 0.16200496f, 0.20905869f, 0.11662208f, -0.02789230f, -0.04473160f, -0.03523909f, -0.01215821f, 
    -0.16501336f, 0.12764712f, 0.14426276f, 0.10595433f, 0.02094692f, 0.20114151f, 0.11032522f, -0.15909097f, 
    -0.14703591f, 0.07034131f, -0.36807021f, -0.48326787f, -0.04172017f, 0.01355144f, -0.07523648f, -0.08779707f, 
    -0.10014524f, -0.17795639f, 0.02119461f, 0.14955518f, -0.03581091f, 0.00971350f, -0.02918788f, 0.06769202f, 
    0.01801327f, 0.05954110f, -0.49347401f, -0.35433221f, 0.09599847f, -0.13080059f, 0.17167348f, -0.24218422f, 
    0.00192129f, 0.02982097f, -0.08200127f, -0.01272759f, 0.02386795f, -0.09486226f, 0.05022477f, -0.12822619f, 
    0.29215375f, 0.06817071f, -0.06525204f, -0.07346787f, -0.08362618f, -0.20491588f, -0.01855024f, 0.10669488f, 
    -0.05920614f, 0.03509085f, 0.07190941f, 0.02254262f, -0.14049287f, 0.17426370f, -0.06351713f, -0.23549032f, 
    -0.05248166f, -0.06562902f, 0.18439171f, 0.08018897f, -0.08626696f, -0.03351387f, 0.01501273f, 0.05034826f, 
    -0.35806024f, 0.03970504f, -0.32050240f, -0.02109291f, -0.00514253f, 0.10821830f, 0.09085162f, -0.09481976f, 
    0.05741534f, -0.04591733f, 0.10126024f, -0.07906711f, 0.23828636f, 0.05336737f, 0.20364036f, 0.05545984f, 
    0.00849158f, 0.01018920f, -0.00728850f, -0.02947220f, -0.01290742f, 0.06243494f, -0.02036399f, 0.10482618f, 
    0.02785535f, -0.19991234f, 0.07579081f, -0.10174624f, 0.03168483f, 0.12128291f, 0.06711958f, 0.08369824f, 
    0.02156757f, -0.03263626f, -0.07457517f, 0.05085132f, -0.28026396f, 0.02020285f, -0.02951152f, -0.17285015f, 
    0.00072626f, 0.06129594f, 0.05095649f, 0.10713201f, -0.09879237f, 0.06971518f, 0.07850833f, -0.02810925f, 
    0.04217815f, -0.09529337f, 0.07391434f, 0.07272124f, -0.03342656f, -0.04947609f, 0.11239423f, -0.03657243f, 
    0.02801977f, -0.08016355f, 0.22920783f, 0.03173764f, -0.16579567f, -0.17541584f, -0.18326609f, 0.02808075f, 
    0.01995836f, 0.04493574f, 0.01029236f, 0.06897783f, 0.04443963f, -0.01435744f, 0.07081881f, -0.05025231f, 
    0.05819941f, -0.13691956f, 0.04399053f, -0.00479608f, -0.01071713f, 0.02970212f, -0.03937975f, 0.05585223f, 
    -0.02890364f, -0.05597588f, 0.03217227f, 0.02960406f, -0.18020979f, 0.22636127f, 0.04318929f, -0.03570887f, 
    0.00143693f, -0.00569569f, 0.06414699f, -0.20534453f, 0.12081930f, -0.05580918f, -0.12694502f, 0.11985951f, 
    0.06316531f, 0.00771813f, -0.16695695f, 0.11314075f, -0.04855553f, 0.02217351f, -0.02274778f, 0.04473238f, 
    -0.04264909f, 0.01400462f, 0.04632513f, -0.06111855f, 0.06802995f, 0.13326043f, 0.06742066f, 0.20845571f, 
    0.01290483f, 0.00256702f, 0.03265466f, 0.02962302f, -0.06777582f, -0.11062619f, 0.04144195f, 0.05688796f, 
    0.04906453f, 0.21480723f, -0.27998304f, -0.14257057f, 0.04258612f, -0.07663102f, -0.04982064f, 0.13492651f, 
    0.03849183f, 0.07768591f, -0.03907304f, -0.06122122f, -0.22036734f, -0.13944612f, -0.04021519f, 0.16665719f, 
    0.08487497f, -0.08080430f, 0.14335556f, 0.11308615f, 0.02428026f, -0.00366894f, -0.02248767f, 0.04943778f, 
    -0.07121372f, -0.11551709f, 0.02283901f, -0.00134040f, 0.09319522f, 0.06900619f, -0.04081729f, -0.02555515f, 
    0.06576731f, -0.05757202f, 0.16545412f, -0.04292906f, -0.00895126f, -0.07102876f, 0.05223861f, -0.01872922f, 
    -0.06445996f, 0.02010259f, -0.18990457f, 0.03789201f, -0.04294141f, 0.01174677f, -0.02815319f, 0.00401296f, 
    -0.08534873f, -0.28888804f, 0.30851072f, 0.22845489f, 0.00449379f, 0.03283937f, -0.00079374f, 0.02628785f, 
    -0.08416551f, -0.06212764f, 0.02199078f, -0.11021331f, 0.01627162f, -0.12044477f, -0.22651516f, 0.20733054f, 
    -0.07147577f, -0.10775445f, -0.07816800f, 0.09619296f, -0.06501523f, -0.00059404f, -0.07170753f, 0.17104493f, 
    -0.01352807f, -0.00321004f, -0.17554200f, 0.01258270f, 0.03522436f, -0.06144350f, -0.06138879f, 0.08316609f, 
    0.10216099f, -0.05094789f, 0.01664091f, -0.05422651f, 0.06214222f, -0.17637165f, 0.06795787f, -0.06983536f, 
    -0.03202379f, 0.04802796f, 0.04575005f, 0.04243919f, 0.00060156f, -0.03677931f, -0.00734534f, 0.03420189f, 
    -0.30241227f, -0.13054027f, 0.09206097f, -0.00082050f, -0.00889920f, 0.00497149f, 0.11469682f, -0.02562506f, 
    0.02117491f, 0.05766325f, 0.02330881f, 0.01811253f, -0.08370305f, -0.07105670f, 0.09359681f, 0.05028811f, 
    0.05278223f, -0.12240952f, -0.13416815f, -0.10227179f, 0.06542767f, -0.06920932f, 0.04151383f, 0.03013458f, 
    -0.12708734f, -0.04573729f, -0.09923697f, -0.30702049f, 0.06526925f, -0.03252782f, -0.01479487f, 0.04734399f, 
    0.04417173f, -0.01817877f, -0.00702650f, 0.01825097f, -0.08884767f, -0.84114420f, -0.09264323f, -0.20051803f, 
    0.12995090f, -0.04100330f, 0.05249470f, -0.09379307f, -0.02185903f, -0.00951847f, -0.00805746f, 0.01395437f, 
    0.26093817f, 0.08035114f, -0.21302429f, -0.00288098f, -0.00964814f, -0.03320123f, -0.05149271f, -0.04209065f, 
    -0.13476568f, 0.07290276f, 0.02096702f, 0.04901263f, -0.15043738f, -0.20473492f, -0.11939690f, 0.11259557f, 
    0.01205159f, 0.05533431f, -0.15416561f, 0.05161466f, 0.04325685f, -0.02388434f, 0.02096508f, 0.09405769f, 
    -0.08701196f, 0.11151932f, -0.58396155f, 0.05770618f, -0.01563968f, -0.03503517f, 0.04823843f, 0.02041377f, 
    0.02331598f, -0.05753289f, 0.21424094f, -0.27395305f, -0.10595148f, -0.01961255f, -0.01617059f, 0.03096151f, 
    -0.02585242f, -0.03477488f, -0.01515262f, 0.07295625f, 0.01113345f, -0.05072097f, -0.02053137f, -0.00764942f, 
    -0.42453951f, -0.42883903f, 0.07708979f, 0.00139958f, -0.06237979f, -0.05661160f, 0.03892016f, -0.04275174f, 
    0.00262907f, -0.03937804f, -0.04247313f, -0.03795705f, -0.24249329f, -0.03421614f, -0.04317282f, -0.11058090f, 
    -0.01381656f, -0.02235154f, -0.06340411f, -0.03903433f, -0.14080147f, -0.05088691f, 0.22163646f, -0.01535107f, 
    -0.27570194f, 0.12387627f, -0.01553451f, 0.27392876f, -0.11636928f, 0.09250636f, 0.03037630f, -0.10585822f, 
    0.03435320f, 0.09048660f, 0.08070642f, 0.00242172f, -0.02526233f, 0.07274409f, -0.01089952f, -0.01278690f, 
    -0.04021534f, 0.02557045f, -0.01593165f, -0.10329730f, 0.05814758f, 0.09189241f, 0.03354716f, 0.20437112f, 
    0.04073601f, -0.03851634f, -0.30605456f, -0.12063148f, -0.02952291f, -0.05923188f, -0.06676055f, -0.04101388f, 
    -0.00536097f, -0.06918603f, 0.07741730f, -0.03789304f, -0.26331207f, 0.41622120f, 0.42018604f, -0.00164638f, 
    -0.09542747f, 0.03667856f, 0.17820211f, -0.11887826f, 0.01551219f, -0.04951645f, 0.02221136f, 0.01133743f, 
    0.16867262f, -0.06397413f, -0.52425128f, 0.06835941f, 0.09790709f, 0.10045937f, 0.08754791f, -0.00330693f, 
    -0.02246623f, -0.04030999f, -0.11173559f, 0.01933028f, -0.13150699f, 0.06747644f, 0.01845158f, 0.07063513f, 
    -0.17764357f, 0.09313075f, -0.11364821f, -0.09451717f, -0.01733124f, -0.05450020f, -0.04918344f, -0.04688126f, 
    0.02893124f, 0.29924133f, 0.10770937f, -0.08783440f, 0.01753166f, 0.04249899f, -0.06701073f, 0.05285920f, 
    -0.01238615f, -0.06105970f, 0.03436892f, 0.10561266f, -0.08993749f, -0.07052328f, 0.05600467f, -0.01722377f, 
    -0.08562149f, -0.04873609f, -0.02377580f, -0.08765477f, 0.00188848f, -0.05664252f, 0.00408465f, 0.00359982f, 
    -0.13603573f, -0.07696532f, 0.63836020f, 0.07712421f, 0.01671865f, -0.10612148f, 0.05092030f, 0.18491000f, 
    0.12707357f, 0.01426937f, 0.04984999f, -0.19517629f, -0.87806946f, -0.51340616f, -0.20869441f, -0.21838205f, 
    -0.12275026f, 0.04946288f, 0.01817897f, -0.22281849f, 0.00456170f, -0.05488563f, 0.04808774f, -0.01627104f, 
    -0.11565856f, 0.06956737f, -0.23577531f, -0.21361476f, 0.01189772f, -0.01884495f, -0.04477796f, 0.14118396f, 
    0.02185455f, -0.01531910f, 0.05702221f, 0.00396890f, -0.03927115f, 0.21728623f, -0.28012827f, 0.08585424f, 
    0.05732992f, -0.02268522f, 0.00730742f, 0.02794603f, 0.00590753f, -0.01072593f, 0.02245319f, -0.01010112f, 
    0.35064110f, 0.05521647f, -0.17532063f, 0.01843146f, 0.06998114f, 0.01596574f, -0.00512424f, 0.09022277f, 
    -0.16394012f, 0.08659039f, 0.04271608f, -0.22721978f, 0.07865494f, 0.09319081f, -0.09114915f, 0.19952890f, 
    -0.02643999f, -0.04461021f, 0.01082282f, 0.03643665f, 0.00010116f, -0.00743512f, -0.04426034f, -0.07879639f, 
    -0.02890384f, -0.07037114f, 0.10444916f, -0.05353076f, 0.06755080f, -0.01315324f, 0.01277132f, -0.03287328f, 
    -0.02501089f, 0.00014783f, 0.04797754f, 0.08841453f, -0.21061280f, -0.47202003f, 0.40205577f, -0.03113808f, 
    -0.21895333f, -0.15022618f, 0.04161609f, -0.17019016f, -0.00898086f, -0.01321666f, -0.00247113f, -0.03115693f, 
    -0.07155642f, 0.31998140f, 0.06718935f, 0.09997353f, -0.01848921f, 0.06393364f, 0.03355145f, -0.03491100f, 
    -0.01922150f, 0.08168542f, 0.02422899f, 0.02948700f, -0.01530829f, -0.13263921f, 0.21767010f, 0.22587608f, 
    0.04278436f, -0.05641004f, 0.02458588f, 0.03267957f, -0.04869753f, -0.00636578f, -0.01493016f, -0.09722407f, 
    0.18548289f, -0.18685563f, 0.21203326f, -0.05436203f, 0.01798137f, -0.08282255f, -0.01051685f, -0.01631158f, 
    0.07295991f, 0.21239783f, 0.02270354f, 0.15254764f, -0.16045192f, -0.00403679f, -0.14827664f, -0.04921167f, 
    -0.02599218f, 0.01137161f, -0.00401951f, 0.03871880f, 0.03681846f, -0.07649278f, 0.03017482f, -0.00671327f, 
    0.27926037f, 0.40447351f, 0.17618592f, 0.35029283f, 0.00671635f, 0.01128384f, 0.01476889f, 0.00558958f, 
    0.01182044f, 0.09548283f, 0.01763721f, -0.01186708f, 0.04187040f, 0.07782979f, -0.04923654f, 0.02379142f, 
    0.12776412f, -0.12441453f, 0.01580762f, 0.10681601f, 0.02952937f, 0.03797407f, 0.07749020f, 0.02031532f, 
    -0.40658203f, -0.47934601f, 0.03440019f, -0.14445409f, 0.03700594f, -0.00270304f, -0.02914196f, 0.02246163f, 
    -0.00042852f, -0.04221417f, -0.02031634f, 0.06835536f, -0.13858224f, 0.09071991f, 0.05023893f, -0.23232251f, 
    0.02603719f, -0.10923051f, -0.18424648f, 0.15520205f, 0.00131821f, -0.04129083f, 0.02668056f, -0.03579357f, 
    -0.05491006f, 0.19620337f, -0.03139188f, -0.16970083f, 0.05454824f, 0.00112640f, -0.06140082f, 0.05085590f, 
    -0.07931956f, 0.02322900f, -0.02004787f, -0.16951640f, -0.31083179f, 0.24908085f, -0.44729283f, -0.39699057f, 
    0.10822653f, -0.12519689f, -0.02704929f, 0.09677180f, -0.00716948f, 0.07854010f, -0.02603259f, -0.05687865f, 
    0.03034665f, -0.13489476f, 0.16386972f, 0.01891619f, 0.03272775f, 0.01099464f, -0.06843050f, -0.04208599f, 
    0.06499726f, 0.04140165f, -0.03006327f, 0.09830852f, -0.12758949f, -0.06551947f, 0.06264189f, -0.03561140f, 
    0.05022186f, 0.07313938f, -0.07677963f, 0.01614591f, -0.04662019f, -0.09073046f, 0.03054021f, -0.08849150f, 
    0.30987480f, 0.11427491f, 0.38307196f, 0.22426808f, 0.01145810f, -0.09042557f, 0.08215223f, 0.05776243f, 
    -0.06562343f, 0.03772754f, -0.05811200f, -0.01194321f, -0.23820582f, 0.56640929f, 0.35998493f, 0.07096320f, 
    -0.06119723f, -0.05401444f, 0.03386501f, -0.12195294f, 0.03226091f, -0.08801157f, -0.02893233f, 0.05619229f, 
    -0.40639651f, -0.07192995f, 0.04738675f, -0.00860635f, -0.00675020f, -0.00469011f, -0.01040802f, -0.02238023f, 
    0.03595141f, 0.01222302f, 0.08488934f, -0.01172587f, -0.08275352f, 0.33062181f, 0.06342708f, 0.09215684f, 
    0.12183167f, 0.04941958f, -0.07018117f, 0.02375325f, 0.03072320f, 0.07690225f, 0.09979564f, 0.12930639f, 
    -0.01145227f, 0.03030101f, -0.03959085f, 0.07904200f, 0.00401887f, -0.03529464f, 0.01602173f, -0.02894861f, 
    -0.06425864f, 0.04461011f, -0.20697314f, 0.10337634f, -0.18536539f, -0.01327940f, 0.15805808f, -0.15956047f, 
    0.00175431f, 0.03691655f, -0.32719833f, -0.13994588f, 0.14644396f, -0.09735030f, -0.11347603f, 0.11732841f, 
    -0.10904107f, -0.18517432f, 0.22169276f, -0.09865459f, -0.07375698f, -0.04475446f, 0.05070579f, 0.07805061f, 
    -0.00576372f, -0.00095995f, 0.03673080f, -0.05547474f, -0.46623117f, -0.03816291f, -0.12145582f, -0.06968464f, 
    -0.07228930f, -0.09064750f, 0.07808294f, -0.21178421f, -0.00278856f, -0.02709784f, 0.02973449f, -0.00266048f, 
    -0.01330337f, 0.27507353f, -0.24365813f, -0.06634840f, -0.14441407f, -0.08829776f, 0.11359347f, 0.09579463f, 
    -0.07942399f, -0.03064318f, 0.07673790f, -0.08667920f, -0.66590917f, -0.34993520f, -0.06932729f, -0.40791845f, 
    0.06020672f, -0.07908478f, 0.09853005f, -0.07662684f, -0.03774358f, -0.02506416f, 0.05297683f, -0.01015823f, 
    -0.11971913f, 0.21097443f, -0.01193648f, -0.06755172f, -0.07531834f, 0.04341199f, -0.18807557f, -0.16080391f, 
    -0.02598573f, 0.07613324f, -0.04279859f, 0.01005239f, 0.07945430f, 0.00977120f, -0.24657556f, 0.12457796f, 
    0.00842427f, 0.02752253f, -0.06229948f, 0.01203811f, 0.05549010f, -0.05177609f, -0.19722180f, 0.06958307f, 
    0.07006157f, -0.30425885f, -0.10364499f, -0.03890724f, -0.05681969f, -0.03223798f, 0.07937277f, 0.05119245f, 
    -0.11442162f, -0.05652121f, 0.00703972f, 0.18864663f, 0.05395826f, 0.05944084f, 0.05759579f, 0.12939470f, 
    -0.07690275f, -0.03727784f, 0.07054799f, -0.02844318f, 0.02606607f, 0.08678552f, 0.02539665f, 0.12221833f, 
    0.00626699f, 0.14836788f, 0.23669717f, -0.04511189f, -0.22758983f, -0.10120842f, -0.03648390f, -0.21429959f, 
    -0.06048520f, -0.13682599f, 0.11484610f, 0.01154173f, 0.21043275f, -0.02813441f, 0.16655877f, -0.20538901f, 
    -0.09619107f, -0.06635197f, -0.22413065f, -0.08091959f, -0.01937340f, -0.08180017f, -0.02890020f, -0.05591485f, 
    0.08054227f, 0.28524110f, -0.19852284f, -0.40179256f, 0.05608733f, -0.00715156f, -0.07680855f, -0.17916110f, 
    -0.06537606f, -0.05983221f, -0.00600610f, -0.19554220f, -0.00259565f, 0.06675947f, 0.00901411f, -0.20501909f, 
    0.14604245f, 0.17670503f, 0.03745610f, -0.05224413f, -0.13179721f, -0.04396389f, -0.06911238f, -0.05025084f, 
    -0.02664080f, 0.24928658f, -0.02952156f, -0.28129077f, -0.03603932f, -0.00235485f, -0.00715401f, 0.02820038f, 
    -0.08893961f, 0.05412844f, -0.11259622f, -0.11248049f, -0.07320087f, 0.04650769f, -0.17835140f, 0.10151724f, 
    0.09383900f, 0.03446243f, -0.00997630f, -0.00550048f, 0.06083235f, -0.02296134f, 0.05545476f, 0.10236879f, 
    -0.08336276f, -0.05410908f, -0.26248497f, -0.02565613f, 0.01735148f, -0.21992107f, -0.04831021f, -0.17730880f, 
    0.01725382f, 0.01579921f, -0.18531211f, -0.10599449f, -0.02805187f, -0.07472211f, -0.05311165f, 0.16567697f, 
    0.03533798f, -0.00255708f, -0.11296338f, -0.16503900f, 0.10241861f, -0.12174931f, 0.18814923f, -0.07719536f, 
    -0.43581498f, 0.31096354f, 0.02239417f, -0.22613959f, 0.29590055f, 0.04408703f, -0.01559589f, -0.14081217f, 
    -0.31545678f, -0.11747333f, 0.09060849f, 0.06287590f, 0.12929963f, -0.03854673f, -0.11863103f, -0.17076682f, 
    0.06410111f, 0.01977642f, -0.03371109f, 0.13009264f, -0.05480362f, -0.02672873f, -0.05764653f, -0.03499649f, 
    -0.43547118f, 0.02799688f, -0.24795189f, -0.20308869f, 0.02032905f, -0.02155183f, -0.14762636f, 0.06264324f, 
    -0.02852741f, 0.00626136f, 0.05756861f, -0.05281909f, -0.15937576f, -0.05931851f, 0.08381610f, 0.04873339f, 
    -0.04778863f, -0.09197716f, -0.30089360f, -0.08950526f, -0.09484173f, -0.01976093f, 0.01847390f, -0.10268615f, 
    -0.13167937f, -0.14849779f, -0.03661345f, 0.15625437f, -0.04150907f, 0.00577559f, 0.13874805f, -0.07336491f, 
    0.01748596f, 0.01965265f, -0.06873454f, 0.01254071f, -0.32072723f, 0.01752160f, 0.15848210f, -0.06103311f, 
    -0.07126316f, 0.05715066f, -0.05055493f, 0.10071138f, 0.06810462f, 0.02396881f, 0.16686386f, 0.11697750f, 
    -0.48585913f, -0.08647130f, 0.15307395f, 0.02725626f, -0.04716038f, -0.12495642f, 0.00599248f, -0.03253443f, 
    -0.01133376f, -0.00133103f, 0.09365351f, -0.06247047f, 0.00486954f, -0.19832639f, -0.05339772f, 0.11413205f, 
    0.05730610f, 0.09379604f, 0.01466651f, 0.12345097f, -0.08943099f, 0.02043102f, -0.03909562f, -0.16522765f, 
    0.71320134f, 0.18717416f, 0.04907445f, -0.37881109f, -0.14509889f, 0.00491221f, 0.07896549f, -0.18015352f, 
    -0.03413951f, 0.13468091f, 0.14597386f, -0.01903614f, 0.21300000f, -0.02460166f, -0.01023085f, -0.01886939f, 
    -0.06046677f, -0.05302747f, 0.12580617f, 0.04537813f, 0.12360635f, -0.04096726f, -0.03089543f, -0.01530829f, 
    -0.57046169f, 0.65266418f, -0.46429178f, -0.48192579f, 0.11453474f, 0.16846848f, -0.06360795f, -0.10903248f, 
    -0.10045955f, -0.15309437f, 0.09892444f, 0.04822068f, -0.25475940f, -0.29934117f, -0.06441770f, -0.13183647f, 
    -0.35353252f, -0.19842741f, -0.04636823f, -0.18950973f, 0.00646636f, 0.08496097f, -0.01978361f, 0.04219330f, 
    0.03060816f, -0.13922291f, 0.00076105f, 0.21819930f, 0.04273229f, 0.01938505f, -0.11510921f, 0.08757423f, 
    -0.00991188f, -0.00692622f, -0.04055694f, -0.05135556f, 0.03134690f, 0.15638979f, 0.16309124f, 0.14101081f, 
    -0.01820054f, 0.06493964f, -0.09250990f, 0.09429959f, 0.06367981f, -0.03691816f, 0.16486865f, 0.00358048f, 
    -0.33186194f, 0.26924926f, -0.00583512f, 0.05706786f, -0.13286099f, -0.26672876f, 0.01082882f, -0.15708554f, 
    -0.09422468f, 0.16873546f, -0.11594437f, -0.11885156f, -0.27613357f, 0.08460262f, -0.05375851f, 0.11718865f, 
    -0.12282349f, 0.07745317f, -0.16634636f, 0.02772947f, 0.10849064f, -0.02446500f, -0.00825570f, 0.07461541f, 
    -0.01341878f, 0.00542410f, 0.11077887f, 0.24662301f, -0.03308009f, 0.08080747f, -0.07501131f, 0.05456267f, 
    -0.01653754f, -0.04027072f, -0.01208158f, -0.16417378f, -0.10111041f, -0.00956462f, 0.10058060f, 0.23768680f, 
    0.17079763f, 0.04083630f, 0.04170634f, -0.06865088f, -0.02629953f, -0.05053665f, -0.03830638f, 0.10561004f, 
    0.37171948f, 0.09954431f, -0.11155631f, -0.44227609f, 0.04912784f, 0.00422387f, -0.09635939f, 0.08197521f, 
    -0.17048566f, 0.07911389f, 0.16207008f, -0.15455812f, -0.23430985f, 0.21120726f, 0.12686205f, 0.33660835f, 
    0.11233113f, -0.04243783f, 0.10112962f, -0.14176069f, -0.04176420f, 0.09647075f, 0.07366242f, 0.09806699f, 
    -0.35000515f, -0.01527159f, -0.11823845f, 0.23415747f, -0.02085296f, 0.06162926f, 0.01553366f, 0.00719857f, 
    -0.04077473f, -0.07087232f, 0.04124846f, 0.05389653f, 0.12521991f, -0.13721028f, -0.12004188f, 0.10817493f, 
    -0.04766609f, -0.24102820f, -0.05861767f, 0.06322403f, -0.09602505f, 0.27150282f, -0.33514398f, -0.05478681f, 
    0.14502853f, 0.57517231f, -0.14512837f, -0.08541107f, 0.33288983f, 0.04646260f, 0.09591677f, -0.03262861f, 
    -0.23323844f, -0.01039856f, 0.02395210f, -0.02306236f, -0.16000208f, -0.12285773f, -0.02941614f, 0.24812384f, 
    -0.10351480f, 0.01166984f, 0.07957052f, 0.11372216f, -0.08279961f, 0.08863553f, -0.03358639f, -0.05714634f, 
    0.07298495f, 0.57773638f, 0.13559549f, -0.00047250f, -0.34465998f, 0.09194432f, -0.08581647f, 0.03296211f, 
    -0.16279623f, 0.05867248f, 0.08326888f, -0.00380499f, 0.03839776f, 0.43846411f, 0.19748324f, -0.15580142f, 
    -0.13776626f, -0.11673222f, 0.00635562f, 0.05014589f, -0.19301432f, -0.10423629f, -0.09221679f, 0.12727188f, 
    -0.47597605f, 0.88599133f, -0.55743939f, -0.26105466f, 0.11126089f, -0.02534581f, -0.19654904f, 0.00752608f, 
    -0.25097793f, -0.14923200f, -0.17665680f, -0.04198764f, 0.99625999f, -0.03146927f, -0.03769581f, 0.12907277f, 
    -0.15501283f, 0.12455361f, -0.16953719f, 0.07829383f, 0.04031071f, -0.07645429f, 0.16917849f, 0.14013609f, 
    -0.03559469f, -0.07534632f, -0.24321030f, -0.00111221f, -0.08846008f, 0.12707891f, -0.14734142f, 0.00247084f, 
    -0.00206611f, 0.02173427f, -0.05198091f, -0.16223870f, 0.04284472f, -0.02954184f, 0.43738109f, 0.10894920f, 
    -0.01458505f, -0.01925324f, -0.00143797f, 0.13200760f, -0.10757715f, 0.11460486f, -0.02462062f, 0.04376573f, 
    0.12348457f, 0.07329997f, -0.07463697f, 0.20725359f, 0.01376157f, 0.00420464f, -0.16202042f, 0.08691064f, 
    0.01146892f, 0.01093600f, 0.11596129f, 0.01416276f, -0.17407759f, 0.41810974f, -0.29168078f, -0.69329804f, 
    0.08211425f, 0.10794743f, -0.13292523f, -0.14338890f, -0.09239884f, -0.02403326f, -0.13213710f, -0.10618410f, 
    0.20038721f, -0.16789800f, 0.07875094f, 0.04296220f, -0.06999762f, -0.04015651f, 0.02887035f, -0.06683077f, 
    -0.01134627f, 0.04521908f, 0.00529329f, -0.02212843f, 0.02392603f, 0.07413781f, 0.03873480f, 0.15895705f, 
    0.20007388f, -0.01618061f, 0.04493872f, -0.04516868f, -0.07647127f, 0.10965968f, -0.04326877f, 0.04595801f, 
    0.10158473f, -0.11244433f, -0.06601959f, 0.12085728f, 0.02740472f, -0.05901553f, 0.01459072f, -0.14130801f, 
    0.02252241f, -0.05265108f, 0.03637464f, 0.06812090f, -0.07494479f, -0.00510237f, -0.20717894f, -0.56332278f, 
    -0.01532947f, 0.15241538f, -0.06207790f, 0.01975723f, -0.09999847f, 0.00276819f, -0.17531615f, -0.04072395f, 
    -0.45532858f, -0.34823135f, -0.19063245f, -0.16994227f, -0.10711611f, -0.06860927f, -0.11401737f, 0.08242223f, 
    -0.13456216f, 0.23078786f, 0.01458186f, 0.01890651f, -0.04252614f, 0.29334661f, 0.28448266f, 0.58653247f, 
    -0.00012652f, 0.16286422f, -0.06287791f, -0.01085461f, 0.20286562f, 0.13573711f, 0.11175313f, 0.16539823f, 
    0.14892155f, -0.05838200f, -0.09935633f, 0.08188074f, 0.02282143f, 0.04322828f, -0.00067486f, 0.19995318f, 
    0.02225632f, 0.03723778f, 0.17257217f, -0.14732581f, -0.34472913f, 0.35675949f, -0.02495737f, 0.47217017f, 
    0.03074569f, -0.24172835f, -0.09935030f, 0.05678692f, -0.07237438f, -0.06982139f, -0.03441188f, 0.04285487f, 
    -0.05508231f, 0.48463991f, -0.46077105f, -0.16201660f, 0.15021104f, -0.00724357f, 0.10118189f, 0.02346607f, 
    -0.18997994f, -0.06270915f, 0.01556551f, -0.03780138f, 0.32888800f, -0.04770467f, 0.07522330f, 0.15747786f, 
    0.10313943f, 0.03720338f, -0.06351200f, -0.04119843f, 0.02300896f, 0.33293179f, 0.19699197f, 0.01067714f, 
    -0.08284171f, 0.01537910f, -0.08669609f, 0.08595137f, 0.09046315f, -0.06522792f, 0.01911333f, 0.03306772f, 
    -0.02496890f, 0.06504463f, -0.12025553f, -0.05639990f, -0.41122302f, -0.01862545f, 0.05790527f, 0.16093913f, 
    0.05595546f, 0.03223803f, 0.17560677f, -0.12846728f, -0.01106959f, -0.06014481f, 0.12920935f, -0.05180916f, 
    -0.49168214f, 0.21972895f, -0.19669496f, -0.21804985f, 0.16723847f, 0.26826131f, 0.08000059f, 0.14955983f, 
    -0.21399799f, 0.00604017f, 0.02993816f, -0.01264663f, -0.05894483f, -0.13841417f, 0.05138377f, 0.13835144f, 
    -0.03403872f, -0.03216590f, -0.09564626f, -0.08510624f, -0.09761394f, -0.12532897f, 0.16746409f, -0.00191771f, 
    -0.21882759f, 0.40840518f, -0.01471239f, 0.10784464f, 0.05223380f, -0.05466240f, -0.04270545f, -0.09046011f, 
    -0.15201020f, 0.10021431f, -0.08024537f, 0.04280368f, -0.26189595f, -0.09855214f, 0.15455496f, 0.01398880f, 
    -0.13113940f, 0.02424460f, -0.15306629f, 0.13350566f, -0.03650748f, -0.01379803f, -0.05160251f, -0.06711443f, 
    0.08376469f, -0.49521899f, 0.23312429f, 0.05547397f, -0.27283761f, -0.04905342f, -0.00855305f, 0.02724146f, 
    0.09530104f, -0.02205279f, 0.15596236f, -0.07027599f, 0.06607115f, -0.10842107f, 0.16601183f, 0.12967318f, 
    -0.06656578f, -0.07638337f, -0.03063540f, -0.07486036f, 0.02260254f, 0.07536663f, -0.03099367f, 0.04634085f, 
    -0.28450140f, 0.18898617f, -0.28243279f, 0.18345179f, 0.08673861f, 0.02370443f, -0.02347677f, -0.19753915f, 
    0.04195305f, -0.04783783f, -0.02208220f, 0.06812750f, 0.03706312f, -0.11926578f, 0.01399761f, 0.11205593f, 
    -0.01891007f, 0.05254612f, 0.07200690f, 0.05864368f, -0.05094660f, -0.00965190f, -0.04460508f, -0.03881210f, 
    -0.42207259f, 0.14303130f, 0.11920225f, 0.37716660f, 0.07716058f, 0.05853262f, -0.26655096f, -0.01354680f, 
    0.00988065f, -0.01332922f, 0.11348637f, -0.09925009f, 0.27128348f, 0.07178947f, 0.07637057f, -0.19464724f, 
    -0.07353739f, -0.20010591f, -0.08799189f, -0.00395822f, 0.09989294f, 0.01306076f, -0.08201341f, -0.02406684f, 
    0.13222079f, -0.20469187f, -0.17732820f, -0.26518387f, 0.02602043f, -0.22908109f, -0.21075520f, -0.08284510f, 
    0.01883529f, -0.02225736f, 0.16691060f, -0.06364769f, -0.07177274f, -0.06303775f, -0.14070928f, 0.19173476f, 
    0.11341643f, 0.06641300f, 0.13004492f, -0.00385604f, -0.03518935f, 0.07659803f, -0.05483116f, 0.06449557f, 
    0.05404364f, -0.03160395f, -0.12530208f, -0.05045132f, 0.09962682f, 0.09048044f, -0.02263167f, -0.00499748f, 
    -0.00833627f, -0.01229964f, -0.06910525f, -0.17398539f, -0.32862371f, -0.07746060f, -0.08006758f, 0.08923643f, 
    -0.06659168f, 0.08810309f, -0.21774139f, -0.05649578f, 0.04101079f, 0.10271292f, 0.16909283f, 0.06599315f, 
    -0.19749753f, -0.21730416f, -0.01329319f, 0.01305104f, -0.40484458f, -0.07194633f, 0.03649498f, -0.09180783f, 
    -0.17602198f, 0.01906185f, -0.13024127f, 0.12067585f, 0.12378976f, -0.04281928f, -0.10369644f, 0.09197388f, 
    -0.09527098f, -0.04557667f, 0.04805258f, 0.07314779f, 0.08860858f, 0.11105328f, -0.13300936f, 0.10166627f, 
    0.12153046f, -0.35639524f, 0.04570323f, 0.05926047f, 0.11090007f, -0.01780903f, -0.06210114f, 0.00808250f, 
    -0.02222974f, 0.00145441f, -0.07568075f, 0.03945535f, -0.07543445f, -0.11897147f, 0.19201224f, 0.14519133f, 
    -0.09874136f, -0.11027803f, -0.18437293f, -0.05416294f, -0.01152222f, 0.08734115f, -0.00201754f, -0.00085190f, 
    -0.04710658f, 0.11844214f, -0.17404930f, -0.03452791f, -0.00679203f, -0.03278192f, -0.00125732f, -0.06158960f, 
    -0.12553450f, -0.04970150f, -0.13189307f, -0.26594540f, 0.08266158f, 0.03565953f, 0.02976482f, 0.05737396f, 
    0.01341090f, -0.04479475f, 0.09461474f, 0.23420039f, 0.02180964f, 0.05185247f, -0.01341318f, -0.01793583f, 
    0.21096081f, 0.07592200f, -0.25064933f, 0.07390255f, -0.16393307f, 0.00406218f, 0.06404785f, 0.00337001f, 
    0.10952729f, -0.03056741f, -0.13216993f, 0.00210133f, -0.02177817f, 0.04163697f, 0.00388761f, 0.16063282f, 
    -0.11001960f, -0.01576995f, -0.13732018f, -0.19137515f, -0.10076408f, -0.01928218f, 0.08266462f, 0.07866883f, 
    0.31850642f, -0.08917093f, -0.16915040f, -0.02604115f, 0.05706978f, -0.03906790f, 0.05474121f, -0.18083569f, 
    -0.16021797f, -0.16509371f, 0.02346306f, -0.02044028f, 0.06444592f, 0.03470668f, 0.05406810f, -0.06122735f, 
    0.08185575f, 0.03364222f, 0.02566995f, 0.01646280f, 0.07712521f, -0.08830151f, -0.02886326f, -0.07342466f, 
    0.05216167f, 0.10344446f, 0.07347345f, 0.14292179f, -0.19363780f, 0.02885496f, 0.00464480f, 0.01825971f, 
    -0.04302015f, -0.02278117f, -0.08287192f, 0.01595408f, 0.05051267f, 0.02546677f, -0.00579663f, 0.12148427f, 
    0.11653098f, 0.12221652f, 0.05210852f, -0.01504422f, 0.03584065f, 0.03565941f, -0.12076392f, 0.08080657f, 
    -0.15383263f, -0.00445637f, -0.30606106f, -0.18157794f, 0.09439287f, 0.07258092f, -0.04007871f, 0.00325780f, 
    -0.10585543f, 0.03677256f, -0.09268624f, -0.13846557f, 0.15800458f, 0.25538298f, 0.16898568f, 0.16557735f, 
    -0.13004361f, 0.05868106f, -0.06167850f, 0.00192939f, 0.01851620f, 0.01143942f, 0.01425094f, -0.01854210f, 
    0.17597018f, -0.01084161f, -0.22850339f, -0.08021493f, -0.04515851f, -0.08884481f, -0.03808774f, -0.04497781f, 
    0.18101892f, -0.24380228f, -0.01707309f, 0.17316610f, -0.22973433f, -0.02966326f, 0.14824620f, 0.26417527f, 
    0.02364401f, -0.04353135f, -0.10540958f, -0.11883985f, -0.04142879f, -0.05158077f, -0.16796263f, -0.07873905f, 
    0.11611787f, -0.60779250f, -0.02442598f, -0.41570944f, 0.01595738f, -0.01502435f, 0.02633523f, 0.05552495f, 
    -0.00999011f, -0.05445516f, -0.11158259f, 0.01193838f, 0.08076380f, 0.00266992f, -0.00251422f, 0.09259448f, 
    0.14226036f, 0.04861155f, 0.07315049f, 0.02628471f, 0.03369299f, 0.03782092f, -0.00567428f, 0.06906074f, 
    0.12087782f, 0.13945442f, 0.16293915f, 0.11135349f, -0.08423305f, -0.09435268f, -0.00865640f, 0.07714757f, 
    0.03308440f, 0.03969864f, 0.02780246f, 0.05791843f, -0.04385678f, 0.14260893f, -0.10639004f, 0.30542415f, 
    -0.02101822f, -0.09394351f, 0.02603094f, -0.06665260f, -0.00645529f, 0.25320122f, -0.12371729f, 0.40375137f, 
    -0.02535243f, -0.22181873f, 0.09818938f, -0.21483032f, -0.07195411f, 0.04163718f, -0.03615238f, 0.06737509f, 
    -0.19522280f, -0.15928768f, -0.20852648f, -0.10187453f, -0.10406817f, -0.15307628f, -0.15424983f, -0.02726397f, 
    0.05335567f, -0.02519089f, 0.02729389f, 0.03569872f, 0.02451976f, 0.06634589f, 0.10957191f, 0.12521560f, 
    0.07864504f, 0.02731675f, -0.11913926f, 0.14921565f, 0.26897314f, -0.08757967f, 0.03218867f, 0.09369106f, 
    -0.00686039f, -0.01604654f, -0.06782573f, -0.08606363f, -0.03663979f, 0.10063070f, 0.11279889f, -0.01075165f, 
    -0.02856278f, -0.05366591f, 0.03176352f, -0.12412969f, -0.09038389f, 0.03829767f, -0.03365031f, 0.02273719f, 
    0.04318891f, -0.10854687f, 0.00743182f, -0.13181438f, -0.04249712f, -0.02114855f, -0.07690680f, -0.08999784f, 
    0.15777040f, -0.19177423f, -0.07730505f, -0.03348484f, 0.03070310f, -0.00741839f, -0.01242809f, -0.06943982f, 
    -0.06758565f, -0.00327237f, -0.00844823f, 0.03196786f, 0.04046318f, -0.06982987f, -0.05462931f, 0.07155794f, 
    -0.04870561f, 0.05238103f, -0.37411177f, 0.05408609f, 0.02914912f, -0.08616611f, 0.03329072f, 0.04172450f, 
    -0.11742710f, -0.15239158f, -0.13681099f, 0.12516642f, -0.01750543f, 0.05688652f, 0.02739837f, 0.00235328f, 
    -0.08245450f, -0.13971701f, -0.03605490f, -0.00634706f, -0.06172512f, 0.03202429f, -0.05782450f, -0.14248081f, 
    -0.15498333f, -0.25933260f, 0.27863735f, 0.06347141f, -0.13865077f, -0.01703794f, -0.04853507f, -0.05137687f, 
    0.07913055f, 0.02259015f, -0.07473287f, -0.05535060f, 0.04024393f, 0.11139613f, 0.00332112f, 0.05216596f, 
    0.01236192f, 0.07479985f, 0.03156682f, 0.07559697f, 0.02783190f, -0.02399533f, 0.00993012f, 0.09049542f, 
    0.28719366f, -0.42709580f, 0.17326984f, 0.20599413f, -0.00833061f, 0.02340031f, 0.20779070f, -0.17555758f, 
    -0.00082023f, 0.01094430f, -0.06960162f, 0.07452828f, 0.07194094f, -0.10713859f, 0.00765735f, 0.20860186f, 
    0.02063031f, 0.13913818f, -0.08354138f, -0.06780093f, -0.04101513f, 0.00778067f, -0.05711276f, -0.02916899f, 
    0.14624861f, -0.53845656f, 0.11581446f, 0.08868543f, 0.00100936f, -0.00529958f, -0.03167202f, -0.13318940f, 
    -0.04074219f, 0.02075131f, -0.01894590f, 0.04364938f, 0.11139311f, -0.10338277f, -0.18144087f, -0.31268427f, 
    0.10336013f, -0.05564442f, 0.00133323f, 0.03082895f, -0.05145342f, -0.13514195f, -0.16102396f, -0.17661458f, 
    0.02391341f, 0.15014751f, -0.00520014f, 0.09876265f, 0.09902943f, -0.01033316f, 0.01196670f, -0.00588496f, 
    -0.03331399f, -0.12372088f, -0.10076320f, -0.14310430f, 0.03811996f, 0.25860614f, 0.20737636f, 0.14578570f, 
    0.01923819f, 0.03908594f, 0.05310085f, -0.11817321f, 0.04229690f, -0.08921364f, 0.06315149f, -0.08048924f, 
    -0.30285507f, -0.00155999f, -0.01287321f, 0.02884780f, -0.01825183f, -0.04209305f, 0.08037695f, 0.03213855f, 
    -0.03531040f, -0.02011677f, 0.03313852f, 0.06210149f, -0.06224615f, -0.27553847f, -0.08403576f, 0.15082255f, 
    -0.03695695f, 0.00418383f, 0.07824932f, -0.09004876f, -0.18412215f, 0.00903919f, 0.02104089f, -0.07007445f, 
    0.01723848f, 0.00985587f, -0.18069787f, 0.08822203f, 0.05235417f, -0.13338579f, 0.02341240f, -0.07836277f, 
    0.05618698f, 0.06560633f, 0.14689526f, 0.25575012f, 0.11388463f, 0.06538692f, 0.03523820f, 0.03366015f, 
    0.09079548f, 0.09591152f, 0.03531642f, 0.04499907f, -0.01217617f, -0.12792645f, -0.14698726f, -0.19797876f, 
    -0.10083415f, 0.30486429f, 0.00290951f, 0.20977497f, -0.05314253f, -0.11331008f, -0.02409215f, -0.03135845f, 
    -0.17676286f, -0.16669908f, -0.09191103f, -0.06686525f, -0.01359808f, 0.00678962f, -0.03604348f, 0.03921031f, 
    0.00270672f, -0.01092439f, -0.05284112f, 0.00380500f, -0.01032533f, 0.05623287f, -0.11157503f, 0.09096151f, 
    -0.01207777f, 0.01332100f, -0.00719340f, -0.02045297f, 0.05988439f, 0.06149341f, 0.07541296f, 0.09190013f, 
    0.08528782f, 0.05166003f, 0.00180572f, 0.01020435f, 0.11172336f, -0.02146282f, 0.05010448f, 0.08321130f, 
    0.22303547f, 0.01105111f, 0.15025905f, -0.03768940f, 0.07314809f, -0.03297212f, 0.04710746f, 0.12469362f, 
    0.04056942f, -0.02302669f, 0.20819809f, 0.08283758f, -0.14471661f, -0.10927852f, -0.01923460f, -0.28574917f, 
    0.06308486f, -0.03888537f, -0.07394677f, -0.03138198f, -0.00199145f, -0.12107513f, 0.05653533f, -0.02580527f, 
    0.17237447f, 0.16189982f, -0.00467121f, 0.03466566f, -0.07377039f, 0.07892591f, -0.03611821f, 0.07497624f, 
    -0.33312592f, -0.34647077f, 0.14733025f, -0.29371160f, 0.01267553f, 0.04512700f, 0.03244835f, 0.03358498f, 
    0.00546612f, 0.09336443f, 0.03939947f, 0.06389583f, -0.00965136f, 0.19603509f, -0.03916230f, 0.03346400f, 
    0.09216564f, -0.00419727f, 0.07794931f, -0.01899286f, -0.12504813f, -0.08636939f, -0.02456851f, -0.27433407f, 
    0.21866773f, -0.03052322f, 0.02758062f, 0.06529564f, -0.07053840f, -0.12132079f, -0.11555669f, -0.17135003f, 
    -0.12845783f, -0.01315114f, -0.04803578f, 0.01321573f, -0.13637406f, -0.10995132f, 0.09258341f, 0.13358934f, 
    -0.04671297f, -0.05656340f, -0.08567838f, -0.11736558f, -0.16850808f, -0.23386809f, -0.04111579f, 0.10594814f, 
    -0.13747059f, -0.14103478f, -0.00228842f, -0.17928000f, 0.06144653f, 0.08624684f, 0.00256621f, 0.11711769f, 
    0.06886393f, -0.18972935f, 0.02079582f, -0.02405111f, -0.20620616f, 0.00398045f, -0.00236168f, 0.04386915f, 
    -0.00229782f, 0.00245677f, -0.02210761f, 0.12912478f, 0.01513476f, 0.03330927f, -0.02582021f, -0.00697185f, 
    0.13180368f, -0.11076017f, 0.03543548f, 0.18219879f, -0.03013592f, -0.05296909f, -0.00434794f, 0.03053759f, 
    -0.03643480f, -0.13023429f, -0.06166693f, 0.08846305f, 0.02396819f, 0.21146277f, -0.12979479f, 0.14201759f, 
    0.10966786f, -0.12070609f, 0.04170406f, -0.28254294f, 0.12348744f, 0.04435661f, 0.00856442f, 0.04170027f, 
    0.13744807f, 0.21188736f, 0.02977753f, 0.16764502f, -0.08425143f, 0.20741172f, -0.06322037f, 0.06408699f, 
    0.05394738f, 0.00396553f, -0.05947476f, -0.02418643f, 0.05545220f, 0.09149668f, 0.11985176f, 0.22866176f, 
    -0.03920106f, 0.01511639f, -0.13059095f, 0.17449477f, -0.10666855f, -0.01576380f, -0.09875938f, -0.12584406f, 
    -0.05111682f, -0.08536189f, 0.30734086f, 0.22648507f, -0.04759551f, 0.00158373f, -0.00687795f, 0.07977480f, 
    -0.05110807f, -0.00351883f, -0.07153921f, 0.00626926f, -0.03503384f, 0.13576616f, 0.12931684f, 0.16994891f, 
    0.02739269f, -0.03083119f, -0.02946517f, 0.07312769f, -0.00861862f, -0.01410310f, 0.04892390f, 0.04911442f, 
    0.00013397f, -0.02546569f, -0.00751283f, 0.01962055f, 0.03290565f, 0.10490136f, -0.22332123f, -0.16164762f, 
    0.03988175f, 0.01066573f, -0.00012380f, -0.11393438f, -0.07151411f, -0.02721966f, 0.14195533f, 0.05101164f, 
    -0.03529972f, -0.16175298f, 0.05721628f, -0.09538386f, -0.03816822f, -0.05939417f, -0.00001884f, -0.11304498f, 
    0.00234970f, 0.11451269f, 0.05798394f, 0.02762974f, -0.00686320f, 0.05146099f, 0.00772524f, 0.04242027f, 
    -0.00234038f, -0.13964523f, -0.06066024f, -0.13921569f, 0.05631133f, 0.03162679f, 0.25498119f, 0.17913465f, 
    -0.07996813f, -0.11363305f, -0.06342068f, -0.09110268f, 0.31272659f, 0.06176395f, 0.11203025f, 0.02378628f, 
    -0.11746655f, 0.12728968f, -0.23378389f, -0.01960326f, 0.16798866f, -0.03754222f, -0.17010556f, 0.06737223f, 
    0.05866205f, 0.08194320f, 0.09918863f, 0.26202649f, -0.04718328f, 0.00577322f, -0.13970125f, 0.09393643f, 
    0.10436105f, -0.14496504f, -0.00088673f, 0.08058138f, -0.12733752f, 0.04038730f, -0.11929552f, -0.10505280f, 
    0.05422870f, -0.36793417f, 0.14038368f, 0.19435599f, 0.05754321f, -0.02906848f, -0.03288104f, 0.06932446f, 
    0.06375494f, -0.05571689f, -0.07274540f, -0.02667015f, -0.60810274f, -0.47466880f, 0.04785303f, -0.08037115f, 
    0.03147966f, -0.04642262f, -0.01442749f, 0.02947935f, 0.14803559f, -0.02414477f, 0.15213299f, 0.03968512f, 
    0.01775350f, 0.09605284f, -0.05128714f, 0.36512670f, -0.11955491f, 0.05475338f, 0.10111786f, -0.01994963f, 
    -0.01822666f, -0.04120865f, 0.13369063f, 0.03195923f, -0.07095186f, 0.17672615f, 0.17864327f, -0.15202293f, 
    0.22963794f, 0.19642869f, 0.14587104f, 0.13674396f, -0.01788690f, 0.05820995f, 0.09877123f, 0.08261072f, 
    0.27805954f, -0.05297051f, -0.00764248f, 0.11204943f, -0.11913095f, -0.01946850f, -0.01087631f, 0.07326329f, 
    -0.03577210f, 0.02217527f, 0.09698504f, 0.18444407f, -0.09734397f, 0.01273323f, 0.02002583f, -0.04460160f, 
    0.01741335f, 0.14578032f, 0.03063497f, 0.14585187f, 0.14115432f, -0.04152950f, -0.01322407f, 0.04403733f, 
    -0.32223341f, -0.21521592f, 0.05790620f, -0.01343383f, -0.02890449f, 0.03868086f, -0.08489743f, 0.07849449f, 
    0.22681701f, 0.17081045f, -0.17907052f, 0.00566062f, 0.12517127f, -0.19429700f, 0.36466196f, 0.07486656f, 
    0.02722926f, -0.05840712f, -0.00491855f, 0.08753459f, 0.22571912f, -0.00629758f, 0.07430919f, -0.05351945f, 
    -0.25174442f, -0.29293659f, 0.00231931f, -0.01383105f, 0.01919645f, 0.09175333f, -0.02505323f, -0.01966770f, 
    0.28821537f, -0.13951300f, 0.15246747f, 0.23817806f, -0.10143955f, -0.06524017f, -0.11615841f, 0.11297289f, 
    0.01307526f, 0.10761397f, -0.04993813f, -0.05035471f, 0.11511365f, 0.02088193f, 0.06366998f, 0.05031889f, 
    0.06037798f, -0.05713835f, 0.12238291f, 0.00589088f, 0.18472128f, -0.03805083f, -0.07379318f, 0.06111443f, 
    -0.00110522f, 0.01645916f, -0.00985094f, -0.03304628f, -0.06468698f, 0.00353279f, 0.03528570f, -0.06026707f, 
    -0.17773825f, -0.10652333f, 0.13261838f, 0.08259384f, -0.07699159f, 0.08295544f, 0.07928094f, -0.19709329f, 
    0.07183776f, 0.05177945f, -0.57460511f, 0.19941318f, -0.00396703f, 0.00021144f, -0.03906804f, -0.03723551f, 
    0.06799018f, -0.00415847f, 0.06184264f, 0.15604265f, 0.05350497f, 0.24158908f, 0.06148437f, -0.03954884f, 
    0.05286188f, 0.03779082f, -0.20305344f, 0.04807924f, 0.00208126f, -0.06516184f, 0.02682399f, 0.06070456f, 
    -0.43642473f, -0.13214664f, -0.00060823f, 0.31325021f, 0.05237650f, 0.01425684f, -0.09750692f, 0.01792742f, 
    -0.23076902f, -0.19431056f, -0.10245871f, -0.10599885f, 0.11733104f, 0.18845223f, 0.03279802f, 0.01150666f, 
    -0.06817335f, 0.01248840f, 0.02555769f, 0.08948316f, -0.02003296f, 0.08835016f, -0.06284785f, 0.07385490f, 
    0.02835719f, -0.20322166f, 0.38249198f, 0.07715993f, -0.00781956f, -0.00715571f, -0.09507489f, 0.00635353f, 
    -0.04099753f, -0.01021553f, 0.00346755f, 0.04662661f, -0.12752050f, -0.07844484f, -0.01325580f, -0.01740714f, 
    0.05000760f, -0.03373788f, -0.02777927f, -0.01056002f, -0.03716351f, -0.00596843f, 0.04233123f, -0.01558104f, 
    -0.09937601f, 0.06168999f, -0.03711936f, -0.28104481f, 0.31055719f, 0.13974003f, 0.25546741f, 0.01031360f, 
    0.01433309f, -0.02182630f, 0.01106281f, 0.05644341f, 0.14717834f, -0.16975901f, -0.12270678f, 0.08159627f, 
    0.04512824f, 0.07112508f, 0.04752436f, -0.03454925f, 0.03901853f, -0.01461377f, -0.30850577f, -0.59860903f, 
    0.09434527f, -0.43306032f, 0.15138678f, 0.17369656f, 0.30732372f, -0.03129396f, -0.06529801f, 0.07267039f, 
    0.11677057f, -0.05144810f, 0.15779662f, 0.19894026f, 0.28168529f, -0.04704068f, -0.06858119f, -0.03019874f, 
    -0.09636497f, 0.04413598f, 0.07814827f, -0.04108624f, 0.08962266f, -0.13551848f, -0.03476948f, -0.31613585f, 
    -0.02325942f, 0.46537149f, -0.13257420f, -0.36880067f, 0.09331990f, 0.01146816f, 0.03254320f, -0.03480383f, 
    0.08031580f, 0.03292824f, -0.01110228f, 0.00340680f, -0.14201099f, -0.10128044f, -0.43181908f, -0.27678838f, 
    0.00005108f, 0.08008717f, -0.17127563f, -0.00081102f, 0.10410867f, 0.07612979f, -0.10348463f, -0.03455104f, 
    -0.17630336f, -0.09550276f, 0.24209729f, 0.40101171f, -0.13066636f, -0.24638224f, 0.00360095f, -0.08319525f, 
    0.28014749f, 0.14522085f, -0.01717341f, -0.07843111f, -0.01069283f, -0.21018088f, -0.04116604f, -0.22437547f, 
    0.08186716f, 0.00618501f, -0.25256726f, -0.02308789f, 0.08779728f, 0.24056597f, 0.03766635f, -0.08461000f, 
    -0.02742836f, 0.03983233f, -0.31033379f, -0.33937550f, 0.00144448f, 0.06694607f, -0.03321115f, -0.08213875f, 
    0.10014644f, 0.00896108f, -0.04891413f, -0.01127994f, 0.07585789f, -0.08497234f, -0.06477652f, 0.04586692f, 
    0.03079000f, 0.35202575f, -0.08203278f, 0.17649220f, 0.04288465f, -0.09801145f, 0.28563088f, 0.06114043f, 
    -0.37008935f, 0.24545930f, -0.49354836f, -0.29998934f, -0.10728734f, -0.01123798f, 0.01842623f, -0.08626185f, 
    0.03223524f, 0.01126680f, -0.00790825f, -0.05375554f, 0.01111354f, 0.07734114f, 0.10805728f, 0.00905427f, 
    0.05088779f, -0.08554722f, -0.23114970f, 0.03818843f, -0.01094882f, -0.03963677f, 0.07122678f, -0.02863698f, 
    -0.24082026f, -0.16454549f, 0.27860180f, -0.08807062f, -0.01113359f, -0.16251534f, -0.06371377f, -0.06634841f, 
    0.14580160f, 0.00596622f, -0.03051009f, -0.12966354f, -0.17582726f, -0.07567598f, 0.22055630f, 0.02666966f, 
    0.02300557f, -0.07437910f, -0.06736691f, -0.01306626f, 0.01364917f, -0.10203147f, 0.04199124f, 0.08185476f, 
    -0.06048166f, 0.04657253f, 0.01758296f, 0.18298207f, 0.13955478f, -0.23825312f, -0.00152541f, 0.14768896f, 
    0.18068612f, -0.08980094f, -0.12573963f, 0.00123020f, -0.15925090f, -0.02252016f, -0.10835585f, -0.03539236f, 
    0.08825055f, 0.06773826f, -0.01501383f, -0.03307468f, 0.12086820f, 0.02488972f, 0.01845131f, 0.07607985f, 
    -0.13347316f, 0.13634022f, -0.16214310f, -0.01115111f, 0.16401763f, 0.02045828f, 0.11614832f, 0.02373373f, 
    -0.09327406f, -0.16172965f, 0.09130999f, -0.01691199f, 0.05994359f, 0.16077170f, -0.02002187f, -0.04720039f, 
    0.17163628f, 0.12910779f, 0.01594526f, 0.01282742f, -0.01406974f, -0.10097390f, 0.03140805f, 0.08262344f, 
    0.19236048f, -0.20105258f, -0.27072448f, -0.09393489f, -0.03177472f, -0.05738746f, 0.02254369f, 0.11222923f, 
    -0.05293001f, -0.12694727f, 0.01308812f, -0.09473809f, -0.11153756f, -0.11006555f, 0.19326609f, 0.34251729f, 
    -0.23429760f, 0.01343765f, -0.01525082f, 0.03109198f, -0.01165391f, -0.18136345f, -0.09092118f, 0.22544383f, 
    -0.51820606f, 0.29560423f, 0.08853159f, -0.14361738f, 0.00523853f, 0.01301801f, 0.03534823f, 0.10391229f, 
    0.18027653f, -0.20810896f, -0.49475375f, -0.44649372f, -0.10307030f, -0.10990133f, 0.01101399f, -0.01038865f, 
    -0.17918363f, -0.03838987f, -0.04168173f, -0.09375544f, 0.06333730f, 0.01220036f, 0.23798285f, -0.01573104f, 
    -0.18840082f, -0.22015475f, -0.03479115f, -0.00994898f, -0.03070115f, -0.03326393f, -0.00878226f, 0.08274703f, 
    0.09859973f, 0.02473588f, 0.07863224f, -0.11810245f, 0.14108109f, -0.32633263f, 0.18559411f, 0.08223645f, 
    -0.11812279f, -0.00212416f, -0.05455588f, 0.03115964f, 0.06068312f, 0.07853432f, 0.03976879f, -0.15350083f, 
    -0.11761837f, -0.10567143f, -0.04788762f, 0.11216373f, 0.02788681f, 0.01570071f, 0.01148505f, -0.00391273f, 
    0.10034215f, -0.09869932f, 0.05156410f, -0.00365326f, 0.00528047f, -0.07773016f, -0.08017405f, -0.15937883f, 
    -0.09213153f, 0.19883630f, 0.03131909f, -0.06471818f, -0.08563422f, 0.01481697f, -0.12913223f, -0.32349947f, 
    0.15035845f, -0.00091932f, -0.14495751f, 0.08913067f, 0.02262350f, 0.13829476f, 0.01663365f, -0.19631150f, 
    0.05342499f, 0.02187544f, 0.12167749f, 0.01126286f, 0.17967391f, -0.09272068f, 0.02174710f, 0.17315239f, 
    -0.09286079f, 0.07104654f, 0.03539239f, -0.01884161f, 0.02550599f, -0.00256964f, -0.04933150f, -0.07242022f, 
    0.01314755f, -0.02584995f, 0.09955769f, -0.20652232f, -0.01860045f, -0.07352464f, -0.04125107f, 0.02344606f, 
    -0.36207026f, -0.28080320f, -0.16065462f, -0.19791129f, -0.22903772f, 0.02201976f, -0.23292872f, -0.03003103f, 
    0.25997263f, -0.12356297f, 0.02810263f, -0.11194395f, 0.09285790f, -0.09195632f, -0.00796849f, 0.43713954f, 
    -0.01029566f, 0.19276649f, -0.31482196f, 0.14885843f, -0.01070330f, 0.13388360f, -0.27363169f, 0.12179860f, 
    0.12776850f, 0.08001722f, -0.13739619f, 0.04029242f, -0.31999260f, -0.05468593f, -0.12650405f, -0.32010114f, 
    0.00978525f, 0.12508330f, -0.07507898f, 0.06180341f, 0.01025793f, -0.01997870f, -0.01728670f, -0.14699049f, 
    0.08466524f, -0.33296067f, -0.19502154f, -0.12929125f, -0.03800089f, -0.01719577f, -0.03229998f, -0.07633796f, 
    0.12173440f, -0.15608031f, -0.26173899f, -0.20521055f, 0.14553936f, -0.27146265f, -0.13033240f, -0.03086183f, 
    0.06236690f, -0.10967667f, 0.05750087f, 0.23835444f, -0.08761434f, -0.07660834f, -0.06776948f, 0.14288466f, 
    0.17868465f, -0.03787037f, -0.04469708f, -0.28419772f, -0.03600852f, 0.04991377f, 0.01108366f, 0.02618396f, 
    0.04510535f, -0.09287694f, 0.22259344f, 0.17047781f, 0.11805052f, 0.01894452f, -0.26576802f, 0.25329918f, 
    0.07630122f, -0.06015734f, 0.08452691f, 0.12831596f, -0.05310598f, 0.02774380f, -0.06785746f, 0.01292897f, 
    -0.44031215f, -0.17765737f, -0.06517417f, -0.09744785f, 0.18681137f, 0.09803905f, -0.00296700f, -0.08995227f, 
    -0.02143579f, 0.07928540f, -0.00289238f, 0.06816103f, 0.17782930f, -0.11598490f, -0.04442575f, -0.02948713f, 
    0.04242017f, 0.31270018f, -0.06630552f, -0.17843412f, 0.11485496f, -0.04020588f, 0.06730409f, 0.00251572f, 
    0.33073792f, -0.00857916f, 0.38296989f, -0.25360259f, 0.10527039f, 0.02186093f, -0.03932016f, 0.09265765f, 
    -0.00423172f, 0.09260899f, -0.03585141f, 0.02218477f, -0.01826729f, 0.16847272f, 0.06795235f, -0.04459834f, 
    0.00150957f, 0.03858772f, 0.03177484f, -0.02792772f, 0.08137098f, 0.01979335f, 0.00352828f, -0.00835516f, 
    0.19946149f, 0.06043874f, -0.30641896f, 0.06393918f, -0.10665427f, -0.02391528f, -0.06370778f, 0.09036864f, 
    0.11562045f, -0.00592877f, -0.04317359f, 0.03110171f, 0.13398691f, -0.14416566f, 0.04357979f, 0.15080144f, 
    -0.00118289f, 0.06840627f, -0.09993159f, 0.06504781f, 0.07061622f, -0.04946806f, -0.07402418f, 0.08653934f, 
    -0.15098614f, 0.14771070f, -0.09645055f, 0.06057659f, 0.05405420f, -0.06899076f, -0.15116711f, -0.06481159f, 
    -0.13391028f, 0.20866887f, -0.19280264f, -0.02439241f, 0.02096060f, 0.10495224f, 0.00309863f, -0.31466517f, 
    0.04781501f, 0.02597356f, 0.01698469f, -0.06561772f, -0.26484135f, -0.28930402f, 0.00967107f, -0.13684875f, 
    0.11322494f, -0.02870393f, 0.03853580f, -0.03617080f, -0.01682940f, 0.04103422f, 0.07724786f, -0.01045795f, 
    -0.04089634f, 0.06362578f, -0.03234824f, -0.15215147f, 0.39967185f, 0.05264175f, -0.24779734f, 0.13585886f, 
    -0.13569665f, -0.01494783f, 0.14183870f, 0.06087514f, 0.00058976f, 0.17125136f, -0.01387047f, -0.12807789f, 
    -0.16411133f, -0.04304615f, -0.18327308f, 0.08881105f, -0.21792236f, 0.00879314f, -0.02296541f, 0.09500229f, 
    -0.04052757f, -0.03961116f, 0.04504231f, 0.09072669f, -0.22520210f, 0.04535017f, 0.09753261f, 0.09935292f, 
    -0.00956880f, 0.06184543f, 0.00392016f, -0.00714593f, 0.02793096f, 0.16816469f, 0.05323915f, -0.00253015f, 
    -0.32880491f, -0.05955003f, 0.09787667f, 0.09452514f, 0.07159749f, 0.06404129f, 0.11081726f, -0.01850854f, 
    0.06103891f, -0.09781065f, 0.04277359f, 0.10549134f, -0.50091428f, -0.46641067f, -0.14093375f, -0.00207523f, 
    -0.22372495f, -0.23839396f, -0.04603720f, -0.15572427f, -0.03602852f, 0.02295436f, -0.01933202f, -0.01597180f, 
    -0.00838151f, -0.00826850f, -0.03969667f, -0.00822211f, -0.07661902f, -0.10888295f, 0.05248737f, 0.06574342f, 
    -0.01085539f, 0.15124516f, -0.35819814f, -0.10528381f, -0.06853978f, -0.04106784f, 0.05548180f, 0.03413139f, 
    -0.08924539f, -0.21395631f, -0.00080195f, 0.14059222f, -0.07826172f, -0.03694877f, -0.03312635f, -0.06094693f, 
    -0.22666024f, -0.04908420f, 0.00770984f, 0.02380008f, -0.03151525f, -0.02598039f, 0.03554421f, 0.14631629f, 
    -0.07777318f, 0.04649135f, 0.09878391f, 0.16428906f, -0.41628271f, -0.30289799f, -0.27256078f, -0.15386039f, 
    -0.06784896f, 0.10209925f, -0.05057145f, -0.02038621f, 0.08094885f, 0.01624488f, 0.16606976f, -0.03102133f, 
    0.02113997f, -0.05807960f, 0.17255512f, 0.10986291f, 0.04612038f, 0.04120949f, -0.11899605f, -0.06717437f, 
    0.01469874f, 0.01168695f, 0.09816563f, 0.08755060f, -0.07667755f, -0.08023449f, -0.18693493f, -0.17370339f, 
    -0.00257157f, -0.00177854f, 0.05480822f, -0.00617306f, -0.03936257f, 0.00938830f, -0.05517834f, -0.08364839f, 
    -0.44972056f, -0.47686526f, -0.43127078f, 0.14269312f, -0.06516184f, 0.18943982f, -0.02790946f, -0.11629082f, 
    0.07148983f, -0.04630487f, 0.07443468f, 0.02570324f, 0.11799695f, -0.09169714f, -0.15193333f, 0.06835083f, 
    0.01473788f, -0.02297445f, 0.09990178f, 0.07464854f, -0.03752477f, -0.01631058f, -0.06840224f, -0.03533921f, 
    0.06134808f, 0.07575691f, 0.10124138f, -0.15189855f, 0.00948421f, -0.01530218f, 0.00015272f, -0.01641840f, 
    0.00781949f, 0.05540162f, -0.07472453f, 0.01067611f, -0.82818967f, -0.65107036f, -0.45560506f, -0.25322208f, 
    -0.26753950f, -0.17825545f, -0.09692279f, -0.22153220f, -0.01321742f, 0.03459384f, 0.02718330f, 0.00335813f, 
    0.14762370f, -0.07979544f, -0.08622395f, -0.03689705f, -0.09211107f, 0.06383629f, 0.19418848f, 0.02327827f, 
    0.03062233f, 0.26387590f, 0.07583015f, 0.18595994f, 0.28643361f, -0.20909065f, -0.15222970f, -0.00580931f, 
    -0.12940477f, -0.17694733f, 0.26564106f, 0.01880529f, 0.00139347f, 0.00293178f, 0.03954464f, -0.13316102f, 
    0.28692529f, 0.10989334f, -0.05563378f, -0.07368211f, -0.01976875f, -0.00625686f, -0.07317942f, 0.02304571f, 
    -0.04034454f, 0.07095924f, -0.13044006f, -0.03339428f, -0.07202475f, -0.08005857f, -0.05888235f, -0.00743945f, 
    -0.00601201f, 0.02885797f, 0.01329882f, 0.02146025f, -0.04216841f, -0.09316204f, -0.00463406f, -0.02026242f, 
    -0.48567459f, -0.55344164f, -0.42483559f, -0.28477985f, -0.03456467f, -0.35077548f, -0.17210543f, -0.34630269f, 
    -0.07007176f, -0.04297288f, -0.00826915f, -0.02020353f, 0.10970700f, -0.06177606f, -0.02908976f, -0.11791009f, 
    -0.05132316f, 0.04959319f, 0.03550806f, 0.05715152f, -0.05341709f, 0.03407968f, 0.05787593f, 0.17048585f, 
    -0.06818160f, 0.08575745f, -0.19239536f, -0.08304431f, -0.05446037f, -0.08209722f, 0.04592713f, 0.06866840f, 
    0.06031516f, -0.06754881f, 0.00897205f, 0.03335380f, 0.29516813f, 0.12383526f, -0.04285343f, 0.05436172f, 
    0.00617721f, 0.03166177f, 0.00300458f, 0.05764366f, 0.04943360f, 0.14145453f, 0.08037585f, 0.06401877f, 
    -0.38517824f, -0.63950640f, 0.30457726f, 0.13619399f, 0.11856164f, 0.01684881f, 0.10684509f, -0.01808068f, 
    0.01753230f, 0.00040028f, 0.03443065f, 0.02539247f, -0.06584550f, 0.28375125f, 0.22764084f, 0.12796648f, 
    -0.02640893f, -0.04325022f, -0.12001689f, 0.02734838f, 0.09202306f, -0.01961221f, 0.12048909f, 0.01568266f, 
    -0.14885496f, 0.04517669f, 0.21548271f, -0.11161115f, -0.18216991f, 0.05182391f, -0.17872073f, 0.05017823f, 
    -0.06647081f, 0.00540707f, 0.34830764f, -0.14318667f, -0.01832566f, 0.15315375f, -0.21413505f, -0.04178462f, 
    0.00449021f, -0.11339504f, 0.00686434f, 0.12265737f, 0.05400175f, -0.05986184f, -0.01414726f, -0.00910521f, 
    0.30965686f, 0.09392690f, -0.02723215f, 0.20805416f, 0.01467321f, -0.06158585f, 0.09045674f, 0.00564992f, 
    0.06012190f, 0.16461705f, 0.05692542f, -0.05062501f, 0.12555943f, -0.00464541f, -0.03145764f, 0.01717521f, 
    -0.15011740f, 0.06544372f, 0.16184315f, 0.13187724f, 0.00920821f, 0.01769661f, -0.08228470f, 0.02077115f, 
    -0.40310335f, 0.12148604f, 0.24507473f, -0.05505582f, -0.00566347f, -0.03538371f, -0.05334355f, -0.19381347f, 
    -0.06013350f, 0.09255154f, 0.04014006f, 0.00929358f, -0.32087025f, -0.45396423f, -0.66973525f, -0.24625731f, 
    -0.21401405f, -0.08155537f, -0.00860153f, -0.22920212f, 0.06023315f, -0.00143515f, 0.01279558f, 0.01315068f, 
    0.02524365f, -0.18934682f, -0.13012667f, 0.09039015f, -0.02720504f, 0.14796205f, -0.14651668f, 0.07107569f, 
    0.07524366f, 0.01127615f, -0.02203074f, -0.02661802f, -0.04065417f, -0.14406498f, 0.01675351f, 0.08406511f, 
    -0.01445837f, 0.10878475f, -0.05932023f, -0.01436176f, -0.02355599f, 0.02374553f, -0.07476190f, -0.08837529f, 
    -0.15800396f, -0.41715878f, 0.03671343f, 0.06020987f, -0.07380346f, 0.03073229f, 0.00552270f, -0.03906153f, 
    0.01225227f, -0.09266871f, 0.06288411f, 0.19310448f, 0.10831914f, 0.04470663f, -0.03284286f, -0.04544231f, 
    -0.07949261f, 0.10888521f, -0.02792851f, 0.06716560f, 0.07755497f, -0.07198878f, 0.03777352f, 0.00907744f, 
    0.20302121f, -0.10696182f, -0.04279153f, -0.01507949f, -0.00314480f, -0.08171425f, 0.05465674f, 0.08599537f, 
    -0.04732509f, 0.01441983f, 0.07522602f, -0.11190774f, -0.38974389f, -0.59744656f, -0.40843970f, -0.32928014f, 
    -0.06229560f, -0.01600092f, 0.01909144f, 0.12680472f, -0.02295536f, 0.05465244f, -0.02786248f, -0.03339061f, 
    0.30020112f, 0.24088669f, -0.03463983f, 0.03550904f, -0.04025217f, 0.02976501f, 0.01135711f, 0.06864523f, 
    0.00986882f, 0.12256188f, 0.02075513f, 0.00641292f, -0.09356699f, -0.19245426f, 0.08205350f, 0.18837619f, 
    0.03200485f, -0.16514485f, -0.16926138f, 0.18110690f, -0.07952057f, -0.06866847f, 0.11810103f, 0.06920839f, 
    -0.03755198f, -0.18832013f, 0.02580475f, 0.03546065f, 0.01754963f, -0.00060974f, 0.07925858f, 0.04530298f, 
    0.07871304f, 0.05240225f, 0.20455334f, 0.15789022f, -0.12879726f, 0.00960387f, 0.09308825f, -0.03652345f, 
    0.07804538f, -0.09495763f, 0.07757109f, -0.05444920f, -0.02669711f, 0.02989954f, -0.13270667f, -0.05713001f, 
    0.31208199f, -0.08855446f, 0.12250709f, 0.57644427f, 0.00928181f, -0.01269976f, 0.03461037f, 0.27399075f, 
    -0.03595514f, 0.10719229f, -0.08079939f, 0.08510244f, 0.03893167f, -0.16698377f, 0.03445122f, 0.17565857f, 
    -0.04152713f, 0.09466399f, 0.01280126f, -0.04080995f, 0.10119423f, -0.08150598f, 0.06873541f, -0.01211145f, 
    0.03794577f, 0.00508530f, -0.11424709f, -0.10624176f, 0.02615472f, 0.05114716f, 0.03332952f, -0.05321643f, 
    -0.08423611f, -0.03639919f, -0.03299261f, -0.08411354f, -0.03735956f, -0.15417466f, -0.01792064f, 0.09055253f, 
    0.11291467f, 0.12968689f, 0.19937888f, -0.06473297f, 0.00683984f, -0.07196067f, 0.03558116f, 0.04246558f, 
    -0.91401279f, -0.42550677f, 0.03768414f, -0.48333615f, -0.12876303f, -0.24336071f, -0.22627521f, -0.33484778f, 
    -0.07977286f, -0.11790732f, -0.05085097f, 0.05721863f, -0.30587614f, -0.25405449f, -0.01317098f, 0.30037814f, 
    0.06398177f, 0.07181596f, 0.12257351f, -0.03220597f, -0.03904871f, -0.04797318f, 0.03707802f, 0.05123955f, 
    -0.00523804f, 0.01140639f, -0.13412197f, 0.06941386f, 0.03284378f, 0.01418522f, -0.03897583f, 0.04007605f, 
    -0.07936347f, 0.05871478f, 0.13839301f, 0.03379200f, -0.06771173f, -0.09809268f, 0.13585165f, -0.11883425f, 
    0.00308267f, -0.10154924f, 0.05959174f, -0.02728606f, 0.02871693f, -0.00738431f, 0.01519111f, 0.04166676f, 
    -0.32925180f, -0.22345540f, 0.45866129f, -0.27963749f, -0.10863128f, -0.22772641f, -0.05877588f, -0.12790519f, 
    -0.07029909f, 0.03515010f, 0.00880465f, -0.02032814f, -0.25335127f, 0.47604278f, 0.22649932f, 0.27264458f, 
    -0.00772647f, -0.03320107f, -0.03838356f, 0.11124776f, 0.00690279f, -0.02168694f, -0.05206281f, 0.00042125f, 
    -0.00122899f, 0.09781422f, -0.00694144f, -0.00935433f, -0.04627283f, 0.02704809f, -0.06343827f, -0.02279686f, 
    0.11593291f, 0.11528434f, 0.11679802f, 0.07995210f, -0.03170209f, -0.05716317f, 0.03186905f, 0.25824806f, 
    0.01298555f, 0.04531996f, 0.28981394f, 0.14457762f, 0.00985704f, 0.13701439f, 0.04829702f, -0.12587528f, 
    -0.10552118f, 0.02130714f, -0.06932587f, -0.33437839f, 0.01318923f, 0.01196566f, 0.05771753f, 0.05751681f, 
    0.02662298f, 0.04783393f, 0.27201316f, 0.10827971f, 0.37971371f, -0.10963174f, -0.17010629f, -0.10101017f, 
    0.00079785f, -0.04580724f, 0.24458094f, 0.01459456f, -0.01750151f, 0.03993746f, 0.11789575f, 0.02340045f, 
    -0.31790191f, -0.20387615f, -0.16442150f, -0.00955324f, 0.04268212f, 0.08942150f, 0.04509060f, -0.09985296f, 
    -0.01693367f, -0.04077362f, 0.02502923f, 0.08690777f, 0.19983789f, -0.12986891f, -0.12867470f, -0.36867189f, 
    -0.07958503f, -0.13311517f, 0.10527112f, -0.01114056f, 0.03449620f, 0.06068525f, -0.08813830f, -0.11240777f, 
    -0.20531315f, -0.95186692f, -0.60938567f, 0.38096359f, 0.07556797f, -0.02879831f, -0.04741520f, -0.12441913f, 
    -0.01262755f, -0.00775458f, -0.02631116f, 0.13815139f, -0.33869082f, -0.53649616f, -0.44685149f, -0.35349083f, 
    -0.07368780f, -0.21347190f, -0.36427587f, -0.22306257f, -0.04785737f, -0.08604112f, -0.01459941f, -0.06167839f, 
    0.48116323f, 0.15955172f, -0.13951631f, -0.15894848f, 0.00607056f, -0.19717994f, 0.14226481f, -0.03535702f, 
    0.12293184f, -0.00267158f, -0.09035179f, -0.14278658f, -0.02685511f, -0.16259521f, -0.09366656f, 0.03737365f, 
    -0.06668550f, -0.09705690f, 0.05445423f, -0.11621837f, 0.00789317f, 0.00790333f, 0.06965266f, -0.05643583f, 
    0.02725577f, -0.04204164f, 0.15989569f, -0.14537674f, 0.09479075f, -0.01835888f, -0.08409961f, 0.11235406f, 
    -0.10900036f, -0.00049401f, -0.08299719f, -0.46975705f, -0.11945894f, 0.27484161f, 0.15992181f, -0.07430734f, 
    -0.06263231f, 0.02732333f, -0.09026317f, -0.00940894f, 0.07602526f, -0.01119415f, -0.02130488f, 0.06630517f, 
    -0.07502800f, 0.04844600f, 0.01952590f, 0.03360636f, 0.01628843f, 0.07566217f, -0.09276069f, -0.02351367f, 
    -0.07979605f, 0.03003398f, -0.12067747f, -0.00072359f, -0.10363002f, -0.03855233f, 0.06392174f, 0.06796291f, 
    -0.08360662f, 0.07400291f, -0.16973475f, 0.04031801f, 0.00230271f, -0.01944007f, -0.01995228f, 0.00716725f, 
    0.45790029f, -0.28171453f, -0.06837486f, -0.01041860f, 0.03128804f, -0.07645735f, -0.20720461f, -0.13931160f, 
    -0.14104688f, 0.06462663f, -0.03252857f, -0.14241345f, 0.45893162f, -0.30895805f, 0.19389853f, -0.52734447f, 
    0.02919530f, -0.05069171f, -0.09871165f, 0.04767283f, 0.07600571f, 0.08929799f, -0.05665846f, 0.00529763f, 
    0.17249675f, 0.05570644f, -0.08754079f, -0.15056749f, -0.11805696f, -0.03896759f, -0.02771886f, -0.04919171f, 
    -0.06888016f, 0.09015063f, 0.01260456f, -0.14943318f, 0.19238643f, -0.36816454f, -0.13964847f, -0.32509807f, 
    0.07811110f, -0.06837419f, -0.10819168f, 0.22174929f, -0.01244767f, -0.00233591f, -0.02767714f, 0.03239118f, 
    0.03821713f, -0.07402273f, 0.00467408f, -0.01752616f, -0.02188505f, -0.00914591f, -0.04922910f, -0.09964332f, 
    -0.02683502f, -0.05185742f, -0.00924408f, -0.04773655f, -0.00031252f, 0.02471880f, 0.04649831f, -0.05525616f, 
    -0.22576834f, -0.18105784f, -0.00008186f, -0.18390395f, 0.03554789f, 0.03094529f, 0.01801685f, 0.04739336f, 
    0.35714704f, -0.14638627f, 0.05350757f, -0.39809051f, -0.09861553f, 0.09714735f, -0.01569229f, -0.00350315f, 
    -0.04446792f, 0.10253709f, 0.08868518f, -0.00998562f, 0.46715409f, -0.62394971f, 0.13316499f, 0.22422241f, 
    -0.04727759f, 0.22011109f, 0.05024282f, -0.00423665f, -0.03493885f, 0.06800417f, -0.12366240f, 0.00353585f, 
    -0.01444959f, 0.03363780f, 0.08529463f, -0.08488045f, -0.04510844f, 0.07823361f, 0.05385351f, 0.06885757f, 
    0.09199477f, 0.00478733f, -0.01550669f, -0.18783484f, -0.09571704f, 0.03906099f, -0.04588116f, 0.03912629f, 
    0.01689084f, -0.07236593f, 0.03283654f, 0.00944759f, 0.08220652f, 0.04644214f, -0.02151613f, -0.07122825f, 
    -0.50749886f, -0.33770084f, -0.02254396f, -0.03281568f, -0.00760202f, 0.13780698f, 0.11069231f, -0.02887362f, 
    -0.01581736f, -0.00338820f, -0.02854034f, -0.06780573f, -0.03126113f, 0.07852231f, -0.05347824f, 0.00619638f, 
    0.02172624f, 0.01300656f, -0.03695862f, -0.00408047f, 0.01582522f, 0.03261060f, -0.05001218f, 0.03932109f, 
    -0.03256907f, 0.17329386f, 0.00318585f, 0.06368315f, 0.02473789f, -0.00150368f, -0.02459513f, 0.00815339f, 
    0.02445921f, -0.03519509f, -0.07546851f, -0.15841091f, -0.57312524f, -0.31110266f, -0.02561676f, 0.23643814f, 
    0.10223574f, 0.01473985f, 0.12820956f, 0.01737195f, -0.00969233f, -0.00870014f, -0.04461953f, -0.02797012f, 
    0.02251308f, 0.29283097f, -0.30309004f, 0.28496170f, -0.01648009f, 0.14886256f, -0.04463049f, 0.03781900f, 
    0.07552450f, 0.07649277f, -0.01222058f, 0.20430796f, -0.09207863f, -0.08754537f, 0.04350122f, 0.24730173f, 
    0.02253107f, -0.02026921f, 0.00694875f, -0.13168199f, -0.02131441f, 0.01311685f, -0.09052931f, -0.00458614f, 
    0.16967753f, 0.03979608f, -0.09523718f, -0.20137171f, 0.04529542f, 0.01484280f, 0.00083014f, 0.00965846f, 
    -0.00832867f, 0.06066190f, -0.11105325f, -0.10008735f, 0.10180803f, 0.00389959f, 0.01628717f, -0.05591114f, 
    0.00386053f, -0.08153927f, -0.01174039f, -0.09049713f, 0.00396923f, -0.03812180f, -0.00638385f, 0.01979231f, 
    -0.34753031f, -0.33534539f, -0.27196786f, -0.22908601f, -0.07154761f, -0.07710696f, 0.02711695f, -0.05607874f, 
    0.07723233f, -0.00518599f, 0.04245694f, 0.04130229f, 0.06157780f, 0.00259402f, -0.00287830f, 0.02608145f, 
    -0.01727499f, -0.02181959f, 0.00824607f, -0.00125448f, 0.17265077f, 0.02135854f, 0.11303991f, 0.11599684f, 
    0.16902581f, -0.30593237f, 0.01362307f, -0.15017255f, 0.04493795f, 0.01279205f, -0.03445771f, -0.09888568f, 
    -0.01311322f, 0.04524611f, -0.02598203f, 0.02670866f, -0.07036034f, 0.04129158f, 0.07697443f, 0.03980583f, 
    0.00859782f, -0.06984664f, 0.09167097f, -0.04507668f, 0.04342623f, 0.07230088f, 0.05071988f, -0.10062639f, 
    0.01824210f, 0.42925417f, 0.09098326f, 0.12569498f, -0.12108711f, -0.07254260f, -0.02508938f, 0.07524217f, 
    -0.08907647f, -0.02463997f, -0.00034016f, -0.02212291f, -0.02387288f, 0.08630555f, -0.27868289f, -0.00064176f, 
    -0.03688172f, -0.07135506f, 0.10083006f, -0.00425677f, -0.07208207f, 0.11798185f, -0.00533528f, 0.02451518f, 
    0.35673356f, 0.12668154f, -0.24483699f, 0.02548705f, 0.01646627f, -0.06531754f, -0.06540887f, -0.05259608f, 
    -0.08024822f, 0.02501557f, -0.14305808f, -0.06044789f, 0.03686440f, 0.00683107f, -0.00851946f, -0.03775163f, 
    -0.10943643f, -0.04788500f, 0.27883804f, -0.02823060f, -0.02564113f, 0.08254485f, 0.06002162f, 0.04067362f, 
    -0.09386826f, -0.16797784f, 0.12267675f, 0.01432468f, 0.00307938f, 0.08292847f, 0.04115843f, -0.02720045f, 
    -0.01685001f, -0.11473719f, -0.06413730f, -0.08428644f, -0.02572693f, -0.00160081f, -0.01271239f, -0.01590349f, 
    -0.16372132f, -0.15120548f, 0.02860287f, -0.07048267f, -0.05551229f, 0.03862963f, 0.06757528f, -0.04838747f, 
    0.34543383f, 0.11578222f, -0.28620243f, -0.16010116f, 0.04541907f, -0.17775030f, -0.07196639f, 0.17070270f, 
    0.05186941f, -0.01264817f, -0.01316743f, -0.01333893f, -0.37984866f, -0.18756650f, -0.28964683f, -0.04465864f, 
    0.10607146f, 0.12373158f, 0.21915221f, 0.19923405f, -0.01715376f, -0.06779033f, -0.12069774f, 0.05000320f, 
    0.15864857f, -0.05458961f, 0.03286784f, -0.13966778f, -0.06975206f, -0.02669595f, -0.14502226f, -0.01073867f, 
    -0.07773340f, 0.01356054f, 0.07629064f, 0.02680555f, 0.07304604f, 0.04471871f, 0.01826712f, -0.08672902f, 
    -0.04647013f, -0.08854801f, 0.02254556f, 0.03377536f, -0.05784193f, 0.03448244f, -0.04010852f, -0.08058689f, 
    0.17875484f, 0.20788547f, -0.09127625f, -0.13821568f, -0.02204248f, 0.05427494f, -0.00020227f, 0.07096088f, 
    -0.12430197f, 0.07232978f, -0.06087011f, -0.20581838f, -0.14738366f, 0.04590674f, -0.24589407f, 0.08526262f, 
    0.01779656f, 0.08153218f, 0.06450722f, -0.00738445f, -0.12150419f, -0.13773961f, 0.09001344f, 0.04116475f, 
    0.00104809f, 0.06565693f, 0.04822270f, 0.00480056f, -0.02206996f, 0.03895202f, -0.00461454f, -0.01048516f, 
    -0.09122454f, -0.13944598f, 0.03825336f, -0.03046073f, -0.59464020f, 0.17358547f, 0.04355933f, 0.21173358f, 
    0.03383082f, -0.21533881f, -0.10676361f, 0.00350535f, 0.04473972f, -0.04688511f, -0.00556364f, -0.05972650f, 
    -0.06474564f, -0.10474655f, -0.11329724f, 0.05512865f, -0.05702869f, -0.00632162f, 0.00311932f, -0.04992115f, 
    -0.13201834f, 0.06666481f, 0.03323654f, 0.00357971f, 0.47103119f, -0.37568215f, -0.23322344f, -0.43123135f, 
    -0.01820621f, -0.00322208f, -0.00683947f, 0.07054977f, 0.00223375f, 0.14182796f, 0.04216006f, -0.11396913f, 
    0.02141783f, -0.17693013f, 0.04573838f, 0.22965160f, -0.08270535f, -0.06282645f, -0.00870870f, -0.04518241f, 
    0.07999267f, -0.05463821f, 0.07734135f, 0.03560147f, 0.06395876f, 0.07423935f, 0.00795805f, -0.05597188f, 
    -0.03819975f, 0.04642132f, 0.08319137f, 0.01007135f, -0.04126557f, -0.03662787f, -0.00241438f, -0.11492375f, 
    -0.34993616f, -0.46203542f, -0.40583608f, -0.20590766f, -0.08405237f, 0.13491127f, -0.22588626f, -0.05978938f, 
    -0.00002029f, -0.01316013f, 0.01284863f, -0.04573603f, 0.10577311f, 0.01078288f, 0.02115307f, -0.11726817f, 
    -0.00974165f, 0.03050134f, -0.07313410f, -0.00509368f, -0.13317803f, 0.16314301f, -0.04121970f, 0.05547025f, 
    0.09898423f, 0.03913347f, 0.09313320f, -0.03814339f, 0.04101514f, 0.03003220f, -0.01292357f, 0.01240142f, 
    0.05756688f, -0.05418944f, 0.00099519f, -0.02066849f, 0.02917843f, 0.06652668f, 0.02907496f, -0.08724914f, 
    -0.04188946f, -0.03308200f, 0.00427892f, 0.00918542f, 0.01218932f, 0.06529097f, 0.08082307f, 0.05457691f, 
    -0.18799856f, 0.31433445f, -0.65100956f, 0.47966954f, 0.14521624f, -0.10306246f, -0.02316435f, 0.02887813f, 
    -0.01691035f, 0.00240523f, 0.01643298f, 0.02791414f, -0.06154010f, -0.00105914f, 0.12982103f, -0.28617835f, 
    -0.06239733f, 0.05970901f, -0.00100011f, 0.06818316f, 0.04507809f, 0.06857560f, 0.07804310f, -0.13056448f, 
    0.09446075f, -0.33516085f, -0.14114894f, -0.07233568f, 0.03918072f, -0.06334728f, 0.01953368f, 0.01016188f, 
    0.02009840f, 0.07478400f, 0.13900861f, -0.12464370f, 0.13176748f, 0.08706673f, -0.01751653f, -0.08899089f, 
    0.11561082f, 0.13005428f, 0.04254777f, 0.05101015f, -0.06941650f, 0.05846353f, -0.05299727f, 0.00009197f, 
    -0.23784886f, 0.13863535f, -0.39182273f, -0.19324873f, 0.05907346f, -0.18385147f, -0.03298452f, 0.12494927f, 
    0.02862870f, 0.09035791f, -0.08041237f, 0.02773372f, -0.34418672f, -0.22725739f, -0.12235175f, -0.16732194f, 
    -0.10692996f, -0.00894179f, 0.12878785f, 0.03333523f, -0.10069566f, 0.07290956f, 0.04996723f, -0.01883985f, 
    -0.01588763f, -0.05541780f, 0.10064255f, -0.07840284f, 0.02600032f, -0.00171726f, 0.02102395f, 0.01206085f, 
    0.08936068f, 0.00721081f, -0.05045113f, -0.21968317f, -0.14647424f, -0.07645724f, -0.08661693f, -0.12806053f, 
    -0.17681311f, 0.12052169f, 0.21071272f, 0.04354161f, 0.00525997f, -0.06365056f, -0.14255548f, 0.02997888f, 
    0.01141966f, 0.11077487f, 0.06136164f, 0.01886749f, 0.02973373f, 0.01977838f, -0.02552766f, -0.04286555f, 
    -0.02243639f, -0.02979507f, 0.13891566f, -0.12848371f, -0.09111792f, 0.04804491f, -0.05901834f, 0.01933128f, 
    -0.14360715f, 0.01374064f, 0.00644688f, 0.07754985f, 0.00142325f, 0.05280713f, -0.01212932f, 0.04266405f, 
    -0.28915498f, 0.13004872f, -0.06338833f, -0.01799690f, -0.03700566f, -0.08384532f, -0.10569450f, -0.03586457f, 
    0.07256305f, 0.04145795f, 0.02473885f, -0.00567672f, -0.20399129f, -0.10004883f, 0.14107867f, 0.25653252f, 
    -0.13928501f, 0.04986539f, -0.08272523f, -0.08992214f, -0.03294090f, -0.09501180f, -0.06518847f, 0.01971970f, 
    -0.37466800f, -0.26862317f, 0.32675621f, -0.01797773f, 0.03419143f, -0.11098967f, -0.14986160f, 0.03320926f, 
    0.03260797f, 0.03658815f, -0.04143850f, 0.02105372f, -0.38619366f, -0.18296753f, -0.05822250f, 0.43419078f, 
    -0.04420051f, -0.06953337f, 0.10108156f, 0.06822925f, -0.05656566f, -0.08995721f, -0.05018371f, -0.00654189f, 
    -0.07975108f, 0.01479824f, -0.11810020f, 0.03484424f, 0.02014239f, -0.04446992f, 0.12159286f, 0.09068818f, 
    -0.10022298f, 0.09655256f, 0.03126812f, 0.05680471f, 0.13488178f, -0.07015362f, 0.02905052f, 0.31460112f, 
    -0.01289913f, -0.09058216f, 0.05223013f, -0.09911031f, -0.06959254f, 0.09338097f, -0.00589335f, -0.01496836f, 
    0.02747506f, 0.06857452f, -0.06180451f, 0.00326742f, 0.03507733f, 0.04482541f, 0.03430391f, 0.02282059f, 
    0.05642723f, -0.04506025f, -0.35376823f, -0.09326164f, -0.02469483f, -0.33867294f, -0.21044834f, -0.13992299f, 
    -0.01376694f, 0.01900187f, 0.01208476f, 0.04739359f, 0.11532310f, 0.08886093f, 0.06532872f, -0.03501498f, 
    -0.12247750f, 0.01623297f, 0.05753868f, 0.12277468f, -0.06565740f, -0.04413096f, 0.00702637f, 0.06646693f, 
    0.05312202f, 0.00764246f, 0.02895626f, 0.03331208f, 0.01886844f, 0.25342461f, -0.10053593f, -0.05170589f, 
    0.27556658f, 0.02000025f, -0.03430605f, 0.05649768f, -0.15240757f, -0.07311691f, 0.16040675f, 0.02464519f, 
    0.24684598f, 0.05156236f, -0.23988850f, -0.28643101f, 0.15941823f, 0.05033523f, 0.07922202f, -0.02771943f, 
    0.15498197f, -0.07746617f, 0.07447706f, 0.02305203f, -0.16388346f, -0.11620467f, -0.26204193f, -0.10827979f, 
    0.07578018f, 0.00020849f, 0.14403288f, 0.00793528f, -0.10007660f, 0.07712746f, -0.06766665f, -0.27115119f, 
    0.10007402f, 0.17573090f, 0.03435512f, -0.12520109f, 0.02409046f, -0.07721692f, 0.05102054f, -0.03454758f, 
    -0.04529345f, -0.02331833f, -0.02220213f, 0.15137090f, 0.17796072f, 0.02296363f, -0.44437891f, -0.18936798f, 
    -0.02502256f, 0.01758033f, 0.02258305f, -0.24267875f, -0.02218706f, -0.09112927f, -0.00619573f, -0.01200643f, 
    0.17405356f, -0.02887407f, -0.12168691f, -0.00825450f, 0.07667568f, -0.06255442f, 0.13006431f, 0.03478396f, 
    0.07449234f, 0.08469987f, 0.12966871f, 0.25473639f, -0.08116623f, -0.12367131f, -0.11310486f, -0.06739209f, 
    0.06914631f, 0.03895659f, -0.03492988f, -0.00553658f, -0.05260093f, 0.05347567f, 0.12791294f, 0.00859652f, 
    -0.04105185f, -0.33398047f, -0.22701199f, -0.13629732f, -0.06523304f, 0.00838191f, 0.04919250f, 0.03448545f, 
    0.11547447f, -0.09943768f, 0.12564448f, 0.01926156f, 0.18996783f, -0.03776227f, -0.27012914f, -0.42232454f, 
    0.15327655f, 0.19470300f, 0.19466558f, -0.01209434f, 0.02432358f, 0.11034763f, 0.05667030f, 0.00165470f, 
    0.01927370f, 0.03654834f, -0.03312292f, 0.08389063f, -0.15469684f, -0.02436903f, -0.02764519f, -0.00473124f, 
    -0.04430729f, 0.07787224f, 0.04126690f, -0.00272793f, -0.18987012f, 0.09775271f, 0.06946108f, 0.04563879f, 
    -0.00574972f, 0.00311955f, -0.04575134f, -0.04081047f, -0.01589845f, 0.03624484f, 0.03524373f, 0.13511722f, 
    0.05377086f, -0.09204890f, -0.02139084f, 0.00226485f, 0.10151824f, 0.00870404f, -0.01005038f, 0.01972181f, 
    -0.04444831f, -0.10038394f, -0.03647746f, -0.05789479f, -0.20121142f, -0.09731545f, 0.09517966f, 0.04887525f, 
    -0.01634726f, 0.05611672f, -0.05767044f, 0.00029678f, -0.07678763f, -0.01131055f, -0.02309029f, -0.05119551f, 
    -0.49037799f, 0.08111430f, 0.14063826f, 0.15046084f, -0.02996809f, -0.04050287f, -0.07683215f, 0.05573433f, 
    -0.05620138f, -0.07271294f, 0.07236052f, 0.03236875f, -0.26641482f, -0.37418687f, -0.23885192f, -0.15718189f, 
    -0.16773015f, 0.05089564f, 0.00476598f, -0.00726203f, -0.02040045f, 0.02347937f, 0.03580320f, -0.01108698f, 
    0.22816779f, 0.08638899f, -0.12700035f, 0.09068675f, -0.01667933f, 0.04154623f, -0.02125463f, 0.18160892f, 
    -0.10514267f, -0.08536782f, 0.01938281f, -0.15876251f, 0.07168660f, -0.04968806f, -0.08217144f, -0.01562752f, 
    0.14024277f, -0.05855904f, -0.04417441f, 0.03745714f, 0.09897721f, 0.14631607f, 0.26737502f, 0.10104180f, 
    0.30791256f, -0.07322273f, -0.04064535f, -0.25220528f, -0.04899941f, -0.10399675f, -0.05149575f, -0.04452043f, 
    0.04152076f, 0.02954693f, 0.01134393f, 0.08070762f, -0.01834390f, 0.02933598f, 0.01704867f, -0.10580745f, 
    -0.00582155f, -0.01729637f, 0.01527613f, -0.02270132f, 0.00611199f, 0.01848274f, 0.02021754f, 0.04811937f, 
    -0.33608049f, -0.54844540f, -0.23980811f, -0.06996457f, 0.06652402f, -0.02610592f, 0.05151382f, -0.01860202f, 
    -0.06593705f, 0.03018515f, -0.01078010f, 0.09564167f, -0.12328494f, 0.05872650f, 0.01880238f, 0.02511345f, 
    -0.03970273f, -0.00371774f, -0.01895606f, 0.00615761f, -0.07238496f, -0.04775996f, -0.19435742f, -0.43016815f, 
    0.32424390f, 0.03857250f, -0.02935430f, -0.13224368f, 0.14456090f, 0.03684729f, 0.00686935f, 0.02579756f, 
    0.12971310f, -0.04563022f, 0.08970869f, 0.15902053f, -0.31944171f, -0.12065387f, 0.09329060f, 0.01535735f, 
    0.00834030f, 0.00770484f, -0.02231807f, -0.02869673f, -0.24306469f, -0.04278625f, -0.21839678f, -0.17912191f, 
    -0.36000773f, -0.05354840f, 0.02021507f, 0.13690475f, 0.06698056f, 0.03451180f, -0.10884067f, -0.00656299f, 
    -0.00258178f, 0.05779731f, 0.05602728f, 0.01041723f, -0.18130501f, -0.25190794f, 0.14138559f, -0.05629815f, 
    -0.04272430f, 0.18446867f, 0.02272194f, 0.13887449f, -0.00422765f, 0.06942597f, 0.05422413f, 0.04459614f, 
    0.23158017f, -0.12260673f, -0.34224144f, -0.25413626f, -0.02160663f, 0.13658097f, 0.11725979f, 0.06044447f, 
    0.02799205f, 0.09618861f, 0.14610657f, 0.14049400f, -0.20538302f, -0.23543745f, -0.02974080f, -0.01821627f, 
    0.07523675f, 0.15724626f, -0.01270710f, -0.05136449f, 0.02490497f, 0.08098296f, 0.14095163f, 0.16412613f, 
    -0.66114712f, 0.03773009f, 0.03913189f, 0.18851648f, 0.04383969f, 0.00264989f, -0.09504165f, -0.00285429f, 
    0.03688868f, 0.04647354f, -0.03816214f, 0.00384068f, -0.10705616f, 0.03011393f, 0.02517445f, 0.12506709f, 
    0.07208162f, -0.09153111f, 0.01269394f, 0.08908934f, 0.12152653f, 0.03265827f, -0.01550226f, 0.16399740f, 
    -0.08923314f, -0.24298836f, -0.10842957f, -0.12949975f, -0.19487365f, -0.03670138f, 0.14475913f, 0.08000924f, 
    0.03306383f, 0.05055339f, -0.03092006f, 0.01563870f, -0.16671455f, -0.27651823f, -0.07979499f, -0.00032956f, 
    -0.13202748f, 0.06984367f, -0.02880471f, -0.34858650f, 0.02233352f, -0.03555727f, -0.04319452f, -0.06472146f, 
    0.06949341f, 0.18581760f, 0.04754153f, -0.13358004f, 0.07560865f, -0.11746478f, -0.10206772f, 0.01790584f, 
    -0.09696367f, -0.00660081f, -0.14298832f, 0.06881087f, 0.20886587f, -0.05116677f, 0.05470262f, -0.13780558f, 
    -0.05502949f, -0.08396192f, -0.01865987f, 0.00530987f, 0.03933547f, 0.09719111f, 0.03071638f, 0.01325597f, 
    0.03023382f, -0.05359891f, -0.14154910f, -0.21283635f, -0.22415325f, 0.02396004f, 0.00635799f, 0.08994475f, 
    0.11746367f, -0.00537025f, 0.10501970f, 0.19393440f, 0.02472051f, 0.10680465f, -0.04033919f, 0.01175935f, 
    -0.06640732f, -0.00026872f, -0.00983804f, 0.01928942f, -0.08200519f, -0.00549291f, 0.03422626f, 0.04893742f, 
    -0.11226210f, -0.04541615f, 0.00618599f, 0.00879769f, -0.03936573f, -0.04249432f, -0.00082853f, 0.09464233f, 
    0.16168608f, -0.04034657f, 0.10350733f, -0.03927375f, -0.14473797f, -0.02632792f, 0.02755206f, -0.01310174f, 
    0.13337219f, -0.05705894f, 0.07512597f, 0.00580734f, 0.06072408f, 0.05419178f, -0.04618426f, 0.07966176f, 
    -0.32298723f, -0.17037512f, 0.03436498f, -0.06382677f, 0.03251135f, 0.02837922f, 0.03688338f, 0.02933635f, 
    -0.13215698f, -0.03165021f, -0.14994800f, -0.10505836f, 0.10858715f, 0.05331674f, -0.27951404f, -0.30768383f, 
    -0.12462996f, -0.06801393f, -0.08105417f, 0.12594737f, 0.19406696f, -0.00761158f, 0.01482086f, 0.08415404f, 
    0.04234442f, -0.00722556f, 0.07448743f, -0.12779668f, 0.09686739f, -0.04281339f, 0.02888272f, 0.06104556f, 
    -0.04815074f, -0.10214333f, -0.16858181f, -0.50875968f, -0.22980951f, -0.07776191f, 0.01329002f, 0.01298845f, 
    -0.02709976f, 0.06193192f, -0.05023571f, -0.07621609f, 0.08581706f, 0.06238517f, 0.10074989f, 0.13387665f, 
    -0.13452455f, -0.42378765f, -0.25349906f, 0.14351666f, 0.20020275f, 0.09112594f, 0.16464974f, 0.13653322f, 
    0.04224571f, -0.10922810f, 0.12650979f, 0.02313980f, 0.01569009f, -0.00066510f, -0.01016861f, -0.11377324f, 
    -0.02410365f, -0.04814748f, 0.04157738f, -0.03814674f, 0.00207728f, -0.01872270f, 0.04728881f, 0.09070695f, 
    -0.30355683f, 0.04160801f, 0.06324323f, -0.05129681f, -0.05461613f, -0.09678846f, -0.05786418f, -0.03965873f, 
    -0.06571627f, -0.07774994f, -0.00771225f, -0.05989832f, -0.22029980f, -0.05209789f, 0.04860229f, -0.03470805f, 
    -0.08657675f, -0.00614130f, -0.17363732f, -0.27167130f, -0.23610459f, -0.16732015f, -0.18447298f, -0.07854642f, 
    -0.03711479f, -0.41959095f, -0.57036102f, -0.21803972f, -0.10070749f, 0.08720125f, 0.17306943f, 0.09973302f, 
    0.06285796f, 0.20278701f, -0.01034273f, 0.09715933f, -0.11289043f, -0.04189320f, 0.06491777f, -0.16822109f, 
    -0.11916344f, 0.02115558f, 0.00468984f, -0.08954392f, -0.02328576f, -0.07121624f, 0.06156356f, -0.01662896f, 
    0.05465086f, 0.16263941f, -0.01130521f, -0.24630632f, -0.10824979f, -0.10538710f, -0.04334110f, 0.00488239f, 
    0.03186520f, 0.03171669f, -0.06748642f, -0.16929109f, -0.16288447f, 0.02339453f, 0.04841085f, 0.28573164f, 
    -0.10101723f, -0.11313508f, -0.07464030f, -0.07217132f, -0.04486122f, 0.12231144f, 0.03060516f, 0.02041859f, 
    -0.16763225f, -0.14968725f, -0.19904509f, -0.08173613f, -0.03417993f, 0.12961014f, 0.15907678f, 0.09360342f, 
    0.12868595f, -0.04133425f, 0.07673448f, 0.00794282f, -0.28785980f, -0.36023480f, 0.15523863f, 0.19136906f, 
    -0.01821081f, 0.08481774f, 0.09437369f, -0.05963929f, 0.20240279f, 0.04041008f, 0.04841199f, 0.00787610f, 
    -0.44981691f, 0.10609639f, 0.00979273f, -0.06550432f, -0.04225447f, -0.03233300f, -0.00597627f, -0.08657000f, 
    0.08077817f, 0.07422389f, -0.09848221f, 0.11044431f, -0.06963812f, -0.29291084f, -0.09833975f, 0.18987001f, 
    0.21238975f, 0.11394272f, 0.13445631f, 0.09948994f, -0.07403049f, -0.12439030f, -0.12335422f, -0.13801423f, 
    0.15233862f, -0.16915067f, 0.06137120f, -0.27360708f, -0.10508057f, -0.00478027f, -0.01347607f, 0.04968669f, 
    0.09589608f, 0.06886707f, 0.11806175f, -0.18317860f, -0.24094722f, 0.06184527f, 0.17992344f, 0.18567418f, 
    0.09668081f, 0.08148259f, -0.18289673f, 0.06062971f, -0.31508592f, -0.07915046f, -0.06020799f, -0.14380078f, 
    -0.25836444f, 0.16412660f, 0.19046445f, 0.08532848f, 0.10994457f, -0.13056117f, 0.09905630f, -0.09120405f, 
    0.00742514f, -0.07961120f, 0.06246814f, 0.01952312f, 0.14000492f, 0.07423416f, -0.03280969f, 0.00336944f, 
    0.15874961f, -0.27345511f, -0.13675602f, 0.05010169f, 0.14603390f, 0.15637514f, 0.14477636f, 0.09984897f, 
    0.66540837f, 0.23511796f, 0.06177920f, -0.00217893f, -0.10780011f, 0.01320329f, -0.07962699f, -0.25794876f, 
    0.09333339f, 0.04128065f, 0.02028876f, 0.06596191f, -0.27301261f, -0.29041171f, -0.34344074f, -0.32066610f, 
    -0.08806582f, -0.25191963f, -0.03863297f, -0.19460765f, 0.07230820f, 0.01761107f, 0.02273179f, 0.02708378f, 
    -0.30994511f, -0.04001965f, 0.08687086f, 0.12331991f, 0.01247857f, 0.01334637f, 0.02983815f, 0.11444531f, 
    -0.14522889f, -0.05487878f, 0.10740284f, 0.02018288f, 0.10172935f, 0.03134223f, -0.14060135f, -0.05656525f, 
    0.19821341f, 0.03948637f, -0.04552311f, 0.04272630f, 0.08922669f, 0.14128166f, 0.17566223f, 0.19172634f, 
    -0.02821208f, -0.03346521f, -0.06066069f, -0.12951086f, -0.00054283f, -0.07206734f, -0.02672874f, -0.02968881f, 
    0.07425710f, 0.06624889f, 0.04500622f, 0.00158201f, -0.14927079f, -0.20158567f, -0.19991103f, -0.10509443f, 
    -0.02245571f, 0.03232141f, 0.00611652f, 0.08193114f, -0.23746936f, -0.13419072f, -0.34790143f, -0.20324343f, 
    -0.39134386f, 0.07649364f, -0.03873521f, -0.04765868f, -0.02473355f, 0.03560160f, 0.17660396f, 0.06982632f, 
    0.10351139f, 0.00267169f, -0.14124617f, -0.13193764f, 0.02152047f, 0.27282923f, -0.37099212f, -0.12613504f, 
    -0.00946411f, -0.01805235f, 0.09018995f, 0.01972623f, 0.01195662f, -0.04196649f, 0.09108713f, 0.16382070f, 
    -0.25699583f, 0.08137245f, 0.09361561f, 0.34477699f, 0.03418467f, -0.17879215f, -0.12175609f, -0.11458238f, 
    0.17114431f, 0.09876408f, 0.04539776f, 0.01604333f, 0.07640235f, 0.08528627f, 0.27527002f, 0.25403827f, 
    -0.05580709f, -0.04167382f, -0.16305049f, -0.13689114f, 0.00306946f, -0.03354016f, 0.05454388f, 0.08419539f, 
    -0.07779811f, -0.22360216f, 0.05026673f, 0.04909442f, 0.05130680f, 0.06772879f, -0.04651378f, -0.06437306f, 
    -0.07805831f, -0.11533574f, -0.01728053f, 0.06040301f, -0.40989783f, -0.13774295f, 0.14024866f, -0.22583972f, 
    0.01544334f, -0.05853250f, -0.20491414f, 0.07906932f, 0.06068884f, -0.03006397f, 0.01183924f, 0.04822500f, 
    0.01263016f, -0.02547404f, 0.14786454f, 0.16259617f, 0.11727887f, -0.08917189f, 0.04704837f, -0.08311513f, 
    0.08173577f, -0.03476189f, -0.19936064f, 0.07122282f, 0.22378854f, -0.00789754f, 0.11382390f, -0.11028048f, 
    0.09727345f, -0.01993935f, 0.07808303f, -0.03162527f, 0.05034440f, -0.06562062f, -0.01375959f, 0.01820261f, 
    0.23868534f, -0.06792346f, 0.07697207f, 0.24957027f, -0.06102302f, 0.06280513f, -0.28212214f, -0.18151964f, 
    -0.06728742f, -0.10283241f, 0.02085334f, -0.03158187f, 0.00956545f, 0.04713763f, 0.37180382f, 0.39408231f, 
    0.17345013f, -0.12611772f, -0.05409874f, -0.12202075f, 0.00552673f, 0.01946472f, -0.04226874f, 0.06709623f, 
    -0.07416335f, -0.16285928f, 0.12696329f, -0.07404263f, 0.07501550f, 0.01960149f, -0.08071985f, -0.01402897f, 
    0.11981491f, -0.03879798f, -0.08312085f, -0.07343909f, -0.36653700f, -0.07523440f, -0.14609578f, 0.12157721f, 
    0.18447484f, 0.00924102f, 0.12723912f, 0.03475635f, 0.03584321f, -0.13174719f, -0.03036833f, -0.03138483f, 
    0.19855598f, -0.11243113f, 0.08643403f, -0.15406278f, -0.06206325f, -0.08938929f, -0.07497200f, 0.09025445f, 
    -0.01464839f, -0.00435322f, 0.05092446f, 0.02937811f, 0.06417323f, 0.06157076f, -0.13533999f, -0.24115165f, 
    0.06546808f, 0.09371772f, 0.05216657f, 0.06659754f, 0.08585558f, -0.09134930f, -0.02186294f, 0.02163842f, 
    -0.17619672f, 0.02750534f, -0.00149657f, 0.07087705f, 0.04050171f, 0.02322635f, 0.11886842f, 0.13473092f, 
    0.01792759f, 0.08057431f, -0.01752247f, -0.01467674f, -0.58940679f, 0.28402597f, -0.15603626f, -0.24721879f, 
    -0.12007615f, -0.03074496f, 0.05232188f, -0.00157653f, -0.04700890f, 0.02922189f, 0.00436353f, -0.03028188f, 
    -0.61651367f, 0.30251855f, -0.51485044f, 0.11294915f, -0.01491863f, -0.12338626f, -0.01524488f, -0.01755342f, 
    0.02689295f, 0.01112414f, -0.06602222f, 0.03854471f, -0.04233457f, 0.03982956f, -0.16886514f, 0.03513227f, 
    -0.10866307f, 0.05356266f, -0.06642843f, -0.17059694f, 0.05060242f, -0.02751770f, -0.06410242f, -0.04261067f, 
    -0.26032409f, -0.26781216f, 0.05106278f, 0.18486266f, 0.05584393f, 0.09482301f, 0.01161755f, 0.04285736f, 
    -0.09519897f, 0.02270129f, -0.11897258f, 0.02999816f, 0.01765082f, -0.18567963f, -0.09522633f, -0.01901088f, 
    0.19033234f, 0.14390549f, 0.18756226f, -0.02577307f, 0.11301750f, 0.04737426f, 0.10048089f, -0.01512735f, 
    -0.11376102f, 0.07876817f, 0.06174426f, -0.18157738f, -0.34405756f, 0.07573508f, 0.07964893f, 0.15965229f, 
    0.01143012f, -0.03232060f, 0.01860072f, -0.00496587f, 0.01299669f, -0.03677633f, -0.08628415f, 0.14279065f, 
    0.06156336f, 0.13094018f, 0.10995773f, 0.03694588f, 0.06556658f, 0.09015520f, 0.05772245f, 0.20334353f, 
    0.14269833f, -0.28942391f, 0.20518009f, -0.14747337f, 0.17377777f, -0.17914318f, 0.03855849f, -0.03032382f, 
    -0.05524191f, -0.01242247f, -0.21083286f, -0.01252772f, -0.07611846f, 0.06496745f, 0.14150633f, -0.31605333f, 
    0.03876723f, -0.08349008f, 0.09164196f, -0.00947586f, 0.05596128f, 0.07563195f, 0.02057545f, -0.02822522f, 
    -0.42351550f, -0.23569822f, -0.01275009f, -0.31003422f, 0.00494909f, -0.01056473f, 0.08583189f, 0.18779774f, 
    0.06503747f, -0.00880447f, -0.11862946f, -0.02096173f, 0.23746136f, 0.00671307f, -0.06816623f, -0.07993271f, 
    0.11427877f, -0.16918495f, -0.09593248f, 0.01881804f, -0.01584193f, 0.03045537f, 0.14780967f, -0.02920661f, 
    -0.33351821f, 0.12763204f, -0.06581855f, 0.47898465f, 0.15643543f, -0.16043326f, -0.10417317f, -0.05957336f, 
    0.07190960f, -0.20323366f, -0.00297710f, 0.08289107f, 0.22366278f, -0.06766626f, 0.12195026f, -0.21967782f, 
    0.10078832f, -0.08454009f, -0.10016845f, 0.00361682f, -0.11519625f, 0.08033793f, -0.03161392f, 0.02850498f, 
    0.06586727f, -0.07255008f, 0.06619724f, -0.38643509f, -0.12753522f, -0.04036926f, 0.07787323f, -0.15473585f, 
    -0.03377700f, 0.11992475f, -0.00715813f, -0.04087081f, -0.00525635f, -0.05903577f, -0.32468033f, -0.08893926f, 
    0.24237828f, -0.00101899f, -0.02628374f, 0.08804967f, 0.05581818f, -0.07901976f, -0.11947282f, 0.07116832f, 
    0.22762388f, 0.03964914f, 0.14177322f, 0.46991077f, 0.06577995f, 0.05783125f, -0.18547253f, -0.01309869f, 
    0.05511592f, -0.06862771f, 0.01882795f, 0.15223658f, -0.07810409f, 0.16164096f, 0.11100934f, 0.08592136f, 
    0.00485966f, -0.10731190f, 0.09700001f, 0.22245422f, 0.03903392f, 0.10058418f, 0.02832064f, -0.04589902f, 
    -0.04242675f, -0.34622374f, -0.19214973f, 0.03090551f, 0.12594548f, 0.16793467f, 0.13613982f, -0.09871656f, 
    -0.04804491f, -0.13603918f, -0.05119866f, -0.04947923f, -0.10543966f, -0.24917774f, 0.01319417f, 0.00072007f, 
    0.06624676f, 0.20971170f, 0.03462992f, -0.04099632f, 0.01172196f, -0.10298071f, -0.09569294f, -0.20498946f, 
    -0.60262012f, -0.12698743f, 0.11871523f, 0.07474388f, 0.01438517f, 0.25332034f, -0.42623323f, 0.00534575f, 
    -0.15307857f, -0.12732019f, -0.04662831f, -0.20630766f, -0.34714162f, 0.14329703f, -0.19312631f, 0.01783206f, 
    0.04037866f, -0.19421391f, 0.01150312f, -0.12873705f, -0.04581920f, -0.08254046f, 0.04509225f, 0.17184147f, 
    0.00064088f, 0.21486267f, -0.19728145f, -0.17773502f, -0.06238868f, -0.02017844f, 0.03008175f, -0.00141032f, 
    0.04612673f, 0.07008104f, -0.15103705f, 0.04037573f, -0.09447361f, 0.01070238f, -0.25435117f, -0.09067854f, 
    0.12919331f, -0.07816255f, 0.13865963f, -0.03534344f, 0.08792797f, -0.09834442f, -0.10676669f, -0.09104916f, 
    0.03104663f, 0.12906042f, 0.36342958f, -0.08309580f, 0.00184053f, -0.17636909f, -0.01291337f, -0.16470888f, 
    0.05424904f, 0.10335833f, -0.00945204f, 0.03339778f, -0.13377453f, 0.19695307f, 0.05309274f, 0.40642747f, 
    0.06269383f, 0.05989850f, -0.12271014f, 0.00450325f, 0.01156116f, -0.02200123f, -0.00672710f, -0.09213939f, 
    0.04634862f, -0.15025100f, -0.00932673f, -0.02672623f, -0.06958618f, 0.05792097f, 0.02940622f, -0.10365090f, 
    0.02232322f, 0.00041240f, 0.13748558f, 0.15422550f, 0.16679364f, -0.14308356f, 0.07681593f, -0.04388541f, 
    0.07899430f, -0.05630631f, -0.10790815f, 0.11243387f, 0.02253036f, 0.01235614f, -0.11196972f, 0.15771696f, 
    -0.01912453f, 0.03395283f, 0.15004258f, -0.86166030f, -0.15946750f, -0.15035407f, -0.05536469f, -0.18300597f, 
    -0.05999395f, -0.03169417f, 0.00959892f, 0.14300692f, -0.05565400f, 0.06218191f, 0.04851951f, 0.01932225f, 
    0.07248738f, 0.22800301f, 0.01678162f, -0.06947888f, 0.05598066f, 0.03281008f, -0.10956340f, 0.01513132f, 
    -0.09818853f, -0.15986030f, -0.14554220f, 0.03974204f, 0.08628625f, 0.13114841f, 0.09526369f, -0.03043497f, 
    0.07200617f, 0.13370322f, 0.07042968f, 0.09440931f, 0.19886172f, -0.18507774f, 0.03502642f, -0.15513131f, 
    0.08624951f, 0.18386404f, 0.02190294f, 0.09415351f, -0.02867094f, 0.06195307f, -0.07540085f, 0.14583091f, 
    -0.42898440f, 0.01748159f, 0.08151603f, 0.03940174f, 0.06609901f, -0.28915149f, -0.09153173f, 0.09298083f, 
    0.07249323f, 0.02347453f, -0.02789505f, -0.03337421f, 0.48688015f, -0.37724787f, 0.16721909f, -0.25985581f, 
    0.03146937f, 0.05489385f, -0.17333227f, 0.06296831f, -0.03049594f, -0.08673868f, 0.02994993f, 0.01982962f, 
    -0.07100359f, -0.01886828f, 0.12732826f, 0.32955897f, -0.02110748f, -0.02520122f, -0.04997158f, 0.08479185f, 
    0.21809131f, 0.06707570f, 0.06583428f, -0.04343428f, -0.01020642f, -0.03637700f, -0.06396686f, -0.02291724f, 
    -0.06894857f, 0.05434883f, -0.05582136f, 0.00461302f, -0.02404306f, 0.07454342f, -0.19742188f, -0.33631015f, 
    -0.14899763f, 0.12024260f, -0.33784419f, -0.14703800f, -0.14190769f, -0.02153667f, -0.13455373f, -0.03119570f, 
    0.02448642f, -0.15356186f, 0.10502486f, 0.06916957f, 0.27425614f, -0.19096635f, 0.40239397f, -0.52645594f, 
    0.04605299f, -0.17243913f, -0.22934435f, -0.04588718f, -0.21390584f, 0.05229714f, 0.04401765f, 0.09248034f, 
    0.06499825f, 0.04565264f, 0.09452242f, 0.14001833f, 0.04702580f, -0.04929380f, -0.06651830f, -0.03055482f, 
    -0.13511637f, 0.07962061f, 0.08258056f, 0.00305128f, -0.04987204f, -0.13836856f, 0.14203270f, -0.26056746f, 
    -0.19265544f, -0.22459963f, -0.08038902f, -0.25079402f, 0.06776471f, 0.02988116f, 0.11106144f, -0.00778903f, 
    0.06389235f, -0.00771616f, 0.22979598f, 0.23835693f, 0.09022605f, -0.03750478f, -0.01297542f, -0.07851731f, 
    0.03462592f, 0.15566759f, 0.04130823f, -0.01394299f, 0.00298123f, 0.07968425f, -0.34475681f, -0.04603308f, 
    -0.12828463f, 0.17180572f, 0.10089326f, 0.06237306f, -0.00412048f, -0.02540824f, 0.02296912f, 0.08294550f, 
    -0.08234926f, 0.19799642f, -0.52537429f, -0.00790891f, 0.13678932f, -0.16828974f, 0.18653572f, -0.01767937f, 
    -0.02627721f, -0.04802451f, -0.12625487f, 0.05516072f, 0.07528471f, -0.04553758f, -0.19551037f, 0.03243973f, 
    0.10981529f, -0.01562429f, -0.09839256f, 0.25573337f, -0.02578336f, -0.05983819f, -0.07878684f, -0.07130824f, 
    -0.40650731f, -1.00701630f, -0.20617600f, -0.13300362f, 0.03834259f, 0.10463233f, 0.08411125f, 0.16210485f, 
    -0.03062382f, -0.04852042f, -0.06623529f, -0.05994165f, -0.36131498f, -0.09579214f, 0.02842141f, -0.32057926f, 
    -0.02620534f, 0.10009050f, 0.06254324f, 0.19497558f, 0.05204027f, 0.09564802f, 0.02908077f, -0.05890511f, 
    -0.42330644f, 0.43668318f, 0.23885365f, -0.27715552f, -0.03401208f, -0.15023030f, 0.14962573f, 0.02375245f, 
    -0.12088189f, 0.07968549f, -0.01681744f, 0.04465171f, 0.14090198f, 0.05652158f, -0.13448927f, -0.00864901f, 
    0.01333377f, 0.01556799f, -0.16747585f, 0.05130206f, 0.08296105f, -0.08766420f, -0.01755592f, -0.15215759f, 
    -0.14780401f, 0.08644500f, -0.07650504f, 0.21258909f, 0.15857679f, -0.11166204f, -0.05092440f, -0.16013616f, 
    0.12629253f, 0.06764912f, 0.09316445f, -0.14064230f, -0.00999184f, 0.10971878f, 0.26598963f, 0.00743851f, 
    -0.00076891f, -0.13765115f, -0.11482037f, -0.05268163f, 0.02069575f, 0.13231802f, 0.03957603f, 0.04869414f, 
    0.07250988f, -0.18836249f, 0.01777463f, -0.04208726f, -0.12915258f, -0.02102058f, 0.18135652f, 0.08290394f, 
    -0.04068244f, 0.10461797f, 0.01533607f, 0.13580854f, -0.15182665f, -0.02631113f, -0.07515570f, 0.00720445f, 
    -0.11513579f, -0.04263968f, 0.15696797f, 0.11372643f, -0.10365209f, -0.00040426f, -0.13989708f, 0.10274071f, 
    -0.53413910f, 0.31299305f, 0.14484762f, -0.22094831f, -0.09972984f, 0.16010003f, 0.09445539f, 0.22233875f, 
    -0.06784328f, 0.02799896f, -0.22764635f, -0.10861611f, -0.32744196f, 0.20200637f, -0.13241054f, -0.13995419f, 
    0.11401145f, 0.09479680f, -0.06590596f, 0.01856865f, -0.15939353f, -0.17244366f, -0.08472927f, -0.39046204f, 
    0.11795147f, 0.14363648f, 0.14674312f, -0.24549755f, -0.11234447f, 0.22626278f, 0.14471997f, -0.05530893f, 
    -0.01407290f, -0.08863539f, 0.03552784f, 0.02195422f, -0.27370340f, -0.35127014f, -0.06880124f, 0.03715571f, 
    -0.08807896f, 0.04658889f, -0.16886917f, 0.03775856f, -0.20829272f, -0.00288242f, 0.14556323f, -0.07526933f, 
    -0.08373383f, 0.17258909f, -0.02747916f, -0.09568176f, -0.12234864f, 0.02966912f, 0.12529108f, -0.11941978f, 
    0.08270352f, 0.00117499f, 0.20958252f, 0.14105211f, -0.05542195f, 0.13847762f, 0.02992759f, 0.22911495f, 
    -0.18979090f, 0.00273658f, 0.24548034f, -0.11967888f, -0.08984894f, 0.04474445f, 0.17664543f, 0.13972783f, 
    -0.34588996f, 0.42139500f, 0.09401809f, 0.06325658f, 0.05320349f, 0.09884024f, -0.04872136f, -0.01967681f, 
    -0.00647371f, 0.26178607f, -0.00974297f, 0.01283302f, -0.44808516f, 0.17551564f, -0.24191749f, -0.10703668f, 
    -0.07785606f, -0.02318308f, 0.05068059f, -0.02644191f, -0.22172774f, -0.01135583f, -0.05534276f, -0.01565240f, 
    0.02388387f, 0.20151551f, 0.27701589f, 0.11868390f, -0.05596617f, -0.12330726f, 0.14076009f, 0.06183929f, 
    -0.15949127f, 0.12103634f, -0.04979047f, 0.05635851f, -0.03445633f, -0.03240011f, -0.11875358f, -0.09562150f, 
    -0.28201157f, -0.10845295f, 0.08960222f, 0.09544318f, -0.06838895f, 0.10122309f, 0.13008106f, 0.18471603f, 
    -0.29130346f, 0.19522958f, -0.25573027f, 0.00689262f, 0.00191803f, -0.13685465f, -0.01481589f, -0.05554597f, 
    -0.09122126f, 0.03748704f, -0.02546510f, -0.05438896f, -0.13180473f, -0.11988556f, 0.06035320f, -0.12519538f, 
    -0.04883793f, -0.08189945f, -0.02216227f, -0.09180977f, -0.18801862f, -0.06514993f, -0.29970008f, -0.02970436f, 
    0.03028215f, -0.27666196f, 0.11063770f, 0.15024549f, -0.07253473f, -0.06340150f, -0.02413882f, 0.02809813f, 
    -0.02050252f, -0.06068512f, -0.08545486f, 0.04115173f, -0.13926288f, -0.00833697f, -0.21103278f, 0.21072724f, 
    -0.14921746f, 0.16752160f, 0.27198192f, 0.07049815f, 0.01522406f, 0.18863642f, -0.00251787f, -0.08992738f, 
    0.36115515f, -0.34309289f, 0.41842768f, 0.05596226f, -0.17326611f, -0.06973496f, 0.05851394f, -0.01171236f, 
    0.09809157f, -0.08735238f, -0.11508903f, -0.16983929f, -0.08110263f, -0.03196205f, -0.07027283f, -0.12686975f, 
    -0.17096424f, 0.04677660f, 0.14212847f, -0.12801701f, 0.01224478f, 0.03525870f, 0.03398893f, 0.06981540f, 
    -0.48971194f, -0.17992654f, 0.27848783f, 0.09640902f, -0.17778987f, 0.00014547f, -0.05156349f, 0.03398833f, 
    0.08592052f, -0.13567947f, 0.05271540f, 0.02965566f, -0.13575400f, -0.13486759f, -0.27080160f, -0.19442582f, 
    -0.12151457f, -0.00243959f, 0.05408753f, 0.03239650f, -0.05475033f, 0.02074122f, 0.03625145f, -0.10957618f, 
    -0.10376593f, -0.06821702f, -0.10175323f, 0.12505825f, -0.06674213f, -0.01999700f, -0.13758728f, 0.09765690f, 
    0.00703761f, 0.11170643f, 0.07414722f, 0.08458014f, 0.01498133f, 0.09866376f, -0.15080409f, -0.13606273f, 
    -0.06358510f, -0.01042894f, 0.05326309f, -0.09532279f, -0.05301407f, -0.10860489f, -0.53427994f, -0.52095103f, 
    -0.44070065f, 0.27806920f, -0.11109165f, 0.00409297f, 0.03272910f, 0.09538277f, -0.10870942f, 0.16614628f, 
    0.04778814f, -0.00848077f, 0.06079185f, 0.04681618f, 0.04082729f, 0.18499485f, 0.30920014f, 0.04720992f, 
    0.02476668f, -0.10888971f, 0.03404896f, -0.06268067f, -0.23792553f, 0.01596302f, -0.05199527f, -0.05289056f, 
    0.15567678f, -0.24250099f, 0.49785054f, 0.01466002f, -0.12723784f, 0.07313066f, 0.00986309f, 0.07439686f, 
    0.09721807f, -0.09338926f, -0.12964271f, 0.05239714f, 0.15803264f, 0.04524454f, 0.10866873f, 0.10616229f, 
    -0.11641113f, 0.00123442f, 0.01684179f, 0.01185872f, 0.04612994f, 0.03281228f, 0.00924172f, -0.06401101f, 
    0.12235573f, 0.56924593f, 0.27298549f, -0.29871368f, -0.15499371f, -0.11089925f, 0.10015109f, 0.28073502f, 
    -0.08091025f, -0.02498511f, -0.01637032f, 0.16193904f, -0.14385708f, 0.11714275f, 0.08587628f, 0.08959895f, 
    -0.13297178f, 0.04831517f, -0.00773327f, 0.24072136f, 0.15252626f, 0.01394274f, -0.03379508f, -0.01876501f, 
    0.00905647f, 0.12978083f, 0.15502983f, 0.11198255f, -0.03965956f, 0.04974317f, -0.06008298f, -0.05893779f, 
    -0.12197679f, -0.05657749f, 0.00030892f, 0.00059295f, -0.04401988f, -0.19332750f, 0.31257281f, 0.18664689f, 
    -0.06266513f, 0.06082803f, -0.04793426f, -0.02931457f, -0.08528581f, 0.02178635f, 0.16329905f, 0.29137722f, 
    0.01230133f, -0.13215846f, 0.00907822f, -0.01485393f, 0.02474055f, -0.03882089f, 0.02951700f, -0.06453579f, 
    -0.21337686f, 0.06118185f, -0.04292450f, -0.07026409f, -0.12800533f, -0.27586144f, -0.47964659f, -0.04883146f, 
    -0.02934460f, -0.03849631f, -0.26699695f, -0.15846749f, 0.08913264f, 0.00397187f, -0.08768445f, 0.00185011f, 
    -0.12943125f, 0.45994002f, -0.31566003f, 0.33601534f, -0.21099311f, 0.09516136f, 0.07321768f, -0.33046609f, 
    -0.14045428f, 0.05774997f, -0.06287306f, -0.03924198f, -0.02203752f, -0.20625256f, 0.08948034f, -0.06094506f, 
    -0.01608948f, 0.10918031f, 0.02554504f, -0.09770562f, 0.08769443f, -0.00870544f, -0.00938302f, 0.09858558f, 
    0.05544854f, 0.36637264f, 0.34556884f, 0.19774990f, -0.00124787f, -0.07310899f, 0.12702920f, 0.06748880f, 
    0.12376940f, 0.12509735f, 0.11387440f, 0.06554153f, 0.33657014f, -0.03612755f, 0.16565414f, -0.13178621f, 
    -0.12562053f, 0.01696420f, -0.02585494f, -0.01440345f, -0.00986822f, 0.13994706f, -0.20204918f, -0.06519759f, 
    0.03219289f, -0.26816759f, 0.31090763f, 0.25578457f, -0.08418210f, 0.00756463f, 0.07694785f, 0.02663293f, 
    -0.07988472f, 0.05638973f, -0.15068589f, 0.03709678f, -0.33456877f, -0.08376776f, 0.31389901f, 0.11966737f, 
    -0.07666503f, 0.05599771f, 0.07665046f, 0.03173844f, -0.12410375f, -0.00884117f, -0.01394724f, 0.03570936f, 
    -0.08690023f, 0.06048229f, -0.21546365f, 0.00314969f, -0.07044537f, -0.09409923f, -0.02959733f, 0.02438810f, 
    0.01678677f, -0.28032953f, 0.00961771f, -0.07097746f, -0.32040498f, 0.25027078f, 0.02016331f, 0.05101898f, 
    0.04732742f, 0.11745400f, 0.18054834f, -0.07947979f, -0.08564731f, 0.11096498f, 0.07638567f, 0.10666788f, 
    0.21295854f, 0.13938306f, 0.03417766f, -0.00616332f, -0.12474027f, 0.11519164f, 0.00642261f, 0.04291159f, 
    0.00139434f, -0.12121152f, -0.20380877f, -0.36248249f, -0.13436672f, 0.25126740f, 0.15389562f, -0.07856922f, 
    -0.01232740f, 0.13472034f, 0.00131060f, -0.01228113f, 0.01875286f, 0.07856157f, 0.23086564f, 0.18070279f, 
    -0.27445683f, 0.06321610f, 0.12690099f, 0.08410124f, 0.00782796f, 0.02677722f, 0.03776409f, -0.04302875f, 
    -0.13633668f, -0.02811828f, 0.02168518f, 0.01481985f, -0.16990581f, 0.11348785f, -0.13982475f, 0.03363001f, 
    0.00916851f, -0.07505870f, 0.08198589f, -0.06433642f, -0.03840582f, 0.17550291f, -0.12131063f, -0.03334503f, 
    -0.00467860f, -0.33381498f, -0.30592260f, -0.26415658f, -0.08551196f, -0.12519340f, -0.07324361f, -0.09125812f, 
    -0.15700452f, -0.05259241f, 0.04284358f, -0.05963781f, -0.11008617f, -0.18888427f, -0.26620200f, -0.11045162f, 
    -0.03355753f, -0.03432443f, -0.10337531f, -0.05814005f, -0.07576584f, -0.09760554f, -0.14165939f, -0.25938994f, 
    0.11688526f, -0.41195241f, 0.13470362f, 0.22951740f, -0.19017680f, 0.15084435f, 0.01656261f, 0.04803703f, 
    0.20052940f, 0.00502534f, 0.10877333f, 0.12314620f, -0.11509569f, 0.04456758f, -0.17339103f, -0.00910175f, 
    -0.06092839f, 0.19347005f, -0.11139855f, -0.10030604f, 0.10704913f, 0.11895404f, 0.01389888f, -0.10562412f, 
    -0.30184552f, -0.07175427f, 0.07556085f, -0.07277445f, -0.03036181f, 0.10841029f, 0.01885416f, -0.08641838f, 
    -0.04706728f, -0.09669145f, -0.01373398f, -0.20737876f, 0.07218267f, -0.03233298f, 0.38193801f, 0.06217061f, 
    -0.26102701f, -0.01371453f, 0.07397556f, -0.07503902f, 0.11455966f, -0.25716662f, 0.13823779f, 0.10477971f, 
    0.25638932f, 0.18297355f, 0.25644490f, 0.13372701f, 0.10105962f, -0.03964395f, -0.07673942f, 0.14027289f, 
    -0.05844549f, 0.07515769f, 0.09535275f, -0.02459561f, -0.32241100f, 0.04480721f, 0.13020106f, 0.23630989f, 
    -0.00498890f, 0.02402920f, -0.14451274f, 0.11137676f, 0.09198528f, 0.03094288f, 0.10019082f, 0.02933361f, 
    -0.46947980f, 0.06266702f, -0.28480443f, -0.09913462f, -0.11574883f, -0.02166859f, -0.01166014f, -0.13349746f, 
    -0.00477091f, -0.02895651f, -0.14022218f, 0.06078427f, -0.18546878f, 0.00628609f, -0.21559812f, 0.07129514f, 
    0.09595969f, -0.08739497f, -0.13632108f, -0.03848513f, 0.08128332f, -0.06730981f, -0.15865028f, -0.26418519f, 
    -0.02087698f, 0.20582759f, -0.10167941f, 0.09471305f, 0.02296909f, 0.07350784f, 0.16722600f, -0.00158437f, 
    0.05796105f, -0.36112350f, -0.23295516f, -0.24352591f, -0.01572276f, -0.24231382f, 0.08405542f, -0.04625486f, 
    0.01230870f, -0.22169925f, 0.09920049f, 0.06746364f, -0.12272685f, -0.03184781f, -0.18276753f, -0.09592164f, 
    -0.06225545f, -0.10126048f, -0.22682081f, -0.05400729f, -0.19325434f, 0.11951081f, 0.07189780f, -0.06817796f, 
    -0.01786214f, 0.12963180f, -0.17870879f, -0.03029040f, -0.06388932f, -0.06423698f, -0.06560147f, 0.29247895f, 
    0.01240395f, 0.04361238f, 0.06267164f, 0.08652592f, -0.05229667f, 0.22608551f, 0.09430715f, 0.18618955f, 
    -0.58471787f, -0.40501928f, 0.05635503f, 0.17896630f, -0.22542658f, 0.13806440f, -0.04183870f, 0.05117267f, 
    0.13028149f, -0.10862861f, 0.05887659f, 0.12423138f, -0.03138366f, -0.54895097f, -0.29084113f, 0.15338328f, 
    -0.08531108f, -0.02486126f, -0.06532001f, -0.18668598f, 0.11135459f, 0.10531790f, 0.12652656f, -0.07081704f, 
    -0.02260512f, -0.28939369f, -0.00759946f, 0.13750307f, -0.20465043f, -0.12475324f, 0.12948951f, 0.07585752f, 
    -0.05568444f, -0.03263225f, 0.06005501f, 0.07935275f, -0.13760738f, -0.10389218f, 0.12159055f, -0.06227486f, 
    -0.01400526f, 0.05112887f, 0.04587670f, -0.02437021f, -0.11088198f, -0.05215446f, 0.22860099f, 0.08082458f, 
    0.12555444f, 0.05352248f, 0.26447475f, -0.25449610f, -0.07346389f, 0.25789484f, -0.14805034f, -0.03460109f, 
    0.04996042f, 0.18306817f, -0.00889154f, 0.20688051f, -0.14612916f, 0.07430003f, -0.11383505f, -0.03047192f, 
    0.09183659f, -0.10764830f, -0.07147263f, 0.07063875f, -0.14458595f, -0.29030779f, -0.25973207f, -0.12363098f, 
    0.03379845f, 0.04853884f, 0.13879581f, -0.08938171f, -0.00675302f, 0.06340868f, 0.04573717f, -0.01946965f, 
    -0.02107704f, 0.09428731f, 0.12892596f, 0.03131573f, 0.32636875f, -0.42210901f, 0.32639998f, 0.14968103f, 
    0.05207731f, 0.11259914f, 0.22238463f, 0.00865315f, -0.07692483f, 0.03921956f, 0.06553131f, 0.12667942f, 
    0.14701362f, -0.42535344f, -0.03912428f, -0.06314093f, 0.17543693f, 0.12299873f, 0.01045099f, -0.01926783f, 
    0.00479009f, 0.09242444f, 0.28322452f, 0.07061406f, -0.11563676f, -0.12971351f, -0.21645600f, 0.13586521f, 
    0.06755125f, -0.13607696f, 0.04863005f, -0.07564894f, 0.00382637f, -0.04318081f, 0.10332546f, 0.04428286f, 
    -0.00584377f, 0.07678746f, 0.11521693f, -0.04171061f, 0.10489137f, 0.02458999f, -0.17323081f, 0.03711437f, 
    -0.02909939f, 0.06478797f, -0.02652285f, -0.01311084f, -0.06882511f, 0.07950868f, 0.14357582f, 0.06101373f, 
    -0.00137722f, 0.05188053f, -0.04242247f, -0.17516339f, -0.04786112f, 0.02188156f, -0.08210241f, -0.06129609f, 
    0.22407176f, -0.00488210f, 0.14626357f, 0.04173945f, 0.06159889f, 0.01163995f, -0.07453538f, 0.11800179f, 
    -0.08547299f, 0.05295640f, -0.06269303f, -0.29169050f, -0.04990519f, 0.06344332f, -0.10585625f, 0.05150005f, 
    0.06359857f, 0.01152673f, -0.02388832f, 0.12125016f, 0.02852780f, -0.07857743f, -0.06063700f, -0.12643859f, 
    -0.48501727f, 0.21559604f, -0.39042473f, 0.19699343f, 0.22712988f, -0.13056415f, 0.04511529f, -0.11300132f, 
    -0.04570400f, 0.05155422f, -0.15959843f, 0.17043088f, -0.03208786f, -0.29005396f, -0.22165942f, 0.11422942f, 
    0.13153373f, -0.12547863f, 0.07432234f, -0.02425535f, 0.10713423f, 0.13099350f, 0.11711803f, -0.03662839f, 
    -0.20043886f, 0.13282958f, -0.08729618f, 0.04290608f, -0.01981466f, 0.08764669f, 0.06645910f, -0.09549792f, 
    0.00860952f, 0.00046621f, 0.09883704f, 0.02012312f, 0.34198847f, 0.12042267f, 0.27423030f, -0.16247129f, 
    -0.11246873f, 0.13533598f, -0.24373135f, 0.12425585f, -0.13524920f, 0.00885554f, -0.03183158f, -0.10384355f, 
    0.09764056f, -0.09490570f, -0.19781388f, -0.04492668f, -0.01498522f, -0.28350163f, -0.05196550f, -0.07539419f, 
    0.08710165f, -0.00575593f, -0.09976590f, 0.08398537f, 0.21711345f, 0.15379992f, 0.08943698f, -0.16874105f, 
    0.00669107f, -0.03384034f, -0.11349633f, 0.03768547f, -0.00505040f, -0.03466975f, 0.11548895f, 0.10725587f, 
    0.07325058f, 0.03519718f, 0.21871220f, -0.12478483f, -0.03133719f, 0.02204082f, -0.04468225f, -0.00060122f, 
    -0.11555155f, 0.13354228f, 0.14689000f, 0.03292219f, -0.42195877f, -0.33502343f, 0.18902680f, 0.02233168f, 
    -0.03225572f, -0.20241889f, -0.06633167f, -0.09041159f, 0.07095448f, -0.03216782f, -0.00117699f, -0.03028041f, 
    0.18724619f, -0.28874677f, 0.48756292f, -0.36850336f, 0.08737080f, 0.06175248f, 0.01740452f, 0.09863421f, 
    0.02139273f, 0.18360318f, 0.20711239f, 0.04797532f, 0.16997457f, 0.22687170f, -0.03527927f, -0.12764023f, 
    0.18456756f, -0.18409850f, 0.08281101f, -0.03413589f, -0.02320048f, -0.12551273f, 0.00466969f, 0.03440613f, 
    -0.12607169f, -0.03396221f, -0.10464449f, -0.04546743f, 0.02173181f, -0.11924545f, 0.03161537f, -0.06170647f, 
    -0.00152021f, -0.06815100f, -0.09115677f, -0.04089944f, 0.12932487f, 0.14084554f, -0.02888648f, 0.01677133f, 
    -0.03950720f, -0.00223198f, -0.01207593f, 0.10130385f, 0.02151108f, 0.01537897f, -0.10273641f, -0.14246322f, 
    0.00093533f, -0.05263953f, -0.08052181f, -0.16515929f, -0.14215240f, -0.08320439f, -0.14862573f, -0.20956670f, 
    0.06724182f, -0.06106988f, -0.05149215f, -0.10134091f, 0.08206484f, -0.01590357f, 0.12094223f, 0.05118432f, 
    0.05323416f, -0.00308723f, 0.00429265f, 0.04621352f, 0.18174447f, 0.15160839f, 0.19289197f, 0.10290288f, 
    -0.01250999f, -0.04514637f, -0.09960267f, 0.38555133f, 0.03653192f, -0.03546524f, -0.07132194f, 0.13334829f, 
    -0.02183748f, 0.04043410f, -0.02326255f, -0.02240152f, -0.02121842f, -0.00352593f, 0.11275256f, 0.11974257f, 
    -0.01742431f, 0.05597994f, -0.10430709f, 0.09985001f, -0.00175698f, -0.03968777f, 0.27896354f, 0.11870477f, 
    -0.20854998f, 0.18207449f, -0.19724566f, 0.01385351f, -0.20633017f, 0.13796347f, -0.08882261f, -0.29634154f, 
    -0.00033813f, 0.10002743f, 0.13896491f, -0.01159222f, -0.23423630f, -0.12806770f, 0.09145551f, 0.04541957f, 
    -0.06347413f, 0.01401672f, 0.06263835f, 0.09282677f, -0.19310021f, -0.00252225f, -0.09744194f, -0.04605729f, 
    -0.02802148f, -0.35236266f, 0.17148547f, -0.02866977f, 0.13654537f, 0.24081485f, -0.14943038f, -0.02874234f, 
    -0.06475382f, -0.04810571f, 0.03666578f, -0.08393606f, -0.10802180f, -0.26192126f, 0.04490334f, -0.01769548f, 
    0.04560687f, 0.00745073f, 0.08736514f, 0.17264408f, -0.19421020f, -0.13509408f, -0.16533712f, -0.13167863f, 
    -0.27931082f, -0.03875085f, 0.14792667f, 0.11406686f, -0.04313556f, 0.05779218f, 0.03242176f, 0.03374998f, 
    -0.14798519f, -0.03477252f, 0.08362799f, 0.11198385f, 0.02926419f, 0.11965832f, 0.16646661f, -0.08406696f, 
    -0.05984284f, -0.01231110f, -0.00799962f, -0.07950395f, -0.00797190f, 0.08667634f, 0.05439262f, -0.10063560f, 
    -0.51309556f, -0.00487442f, -0.26993418f, 0.11492655f, 0.04296168f, 0.03889233f, 0.13102141f, 0.04365484f, 
    -0.19360197f, -0.01553533f, 0.13388851f, -0.00622651f, -0.03941718f, -0.12985653f, -0.02456928f, -0.30219051f, 
    -0.18726262f, -0.12387358f, 0.08097618f, 0.10830703f, 0.01975782f, 0.08049285f, 0.03926346f, -0.01123668f, 
    -0.09278702f, -0.06162318f, 0.11420342f, 0.20807524f, 0.07911004f, -0.11982446f, 0.16439915f, -0.01986538f, 
    -0.05575225f, -0.05676742f, -0.00754384f, -0.03253056f, 0.07923695f, 0.16888236f, -0.02492009f, -0.23539443f, 
    0.01919428f, -0.07922592f, 0.09841863f, -0.05608483f, -0.00702507f, 0.15866737f, 0.07341640f, -0.02830456f, 
    -0.55582863f, 0.14257851f, -0.36900818f, 0.16702761f, 0.06183239f, -0.01826116f, 0.08774025f, -0.25569871f, 
    0.02776798f, -0.10348459f, -0.10070255f, 0.11582252f, 0.17441431f, -0.34173289f, 0.22508033f, -0.23871799f, 
    0.02705100f, 0.08584926f, -0.05203437f, -0.05656998f, -0.01387491f, 0.02710097f, -0.08560101f, 0.01818928f, 
    -0.01682295f, 0.11131776f, -0.04263452f, 0.12130746f, -0.01290156f, 0.00888411f, -0.07820860f, -0.00968612f, 
    0.06505995f, 0.06083689f, 0.13414262f, 0.01987330f, 0.68875194f, 0.13664174f, 0.10201674f, -0.01486477f, 
    -0.07736389f, 0.26959327f, -0.25972566f, 0.12052272f, -0.07933979f, 0.13417931f, 0.11676858f, 0.00840855f, 
    -0.10604056f, -0.14054449f, -0.08403517f, -0.11209451f, -0.10819011f, -0.01336612f, -0.06395563f, 0.04551656f, 
    -0.12683220f, 0.01899366f, 0.02588794f, -0.03455437f, -0.49021065f, -0.12931082f, -0.21830437f, 0.12404507f, 
    0.10306187f, 0.04233957f, 0.05891113f, -0.09682076f, -0.05190755f, 0.08182567f, 0.17811152f, 0.02749252f, 
    -0.35883328f, 0.16865745f, -0.24381930f, -0.01207651f, -0.06606627f, 0.06599239f, -0.01498890f, 0.05640188f, 
    0.02817901f, 0.13287555f, 0.10049172f, 0.07898476f, -0.07815969f, 0.01843582f, -0.17238031f, 0.04249204f, 
    -0.01911222f, -0.05537075f, 0.09596886f, 0.09788306f, -0.02314989f, -0.20412140f, -0.05580009f, -0.20757914f, 
    -0.11602352f, -0.06797028f, -0.18814212f, -0.05959256f, 0.07331984f, -0.05163207f, 0.18325186f, -0.23986144f, 
    0.10599145f, 0.16068497f, -0.15601650f, 0.06518418f, -0.12290420f, 0.01549341f, -0.00941263f, 0.06118660f, 
    0.05880914f, -0.02445821f, 0.09676623f, -0.05351888f, 0.17102031f, -0.12708107f, -0.08178672f, -0.06786266f, 
    0.25681177f, 0.11030993f, 0.02583539f, -0.04616387f, -0.05666142f, -0.04834370f, -0.03442913f, 0.06171319f, 
    -0.12459028f, -0.01277477f, 0.00669493f, -0.22948560f, 0.07894287f, 0.17898363f, 0.07174873f, 0.02535043f, 
    -0.19798584f, -0.00025417f, -0.00007511f, 0.13490130f, -0.00629343f, 0.07245290f, 0.03001419f, -0.00439440f, 
    0.04801843f, -0.61549640f, 0.18538427f, -0.05135296f, -0.21010758f, -0.21997555f, -0.30680874f, 0.10624501f, 
    0.01932109f, -0.01923432f, 0.09329881f, -0.06736640f, 0.04169009f, 0.48027509f, 0.02945759f, -0.02077973f, 
    -0.12575856f, -0.10037733f, 0.01350945f, 0.02899287f, -0.03141029f, -0.04340267f, -0.04019951f, 0.09342445f, 
    -0.30280504f, 0.17647609f, -0.27175158f, 0.08631655f, 0.01640767f, 0.08295739f, 0.09587202f, -0.09675871f, 
    0.09046760f, 0.06865767f, 0.10830557f, 0.23076279f, -0.20192765f, -0.04187366f, -0.03838984f, -0.25823790f, 
    -0.04852107f, 0.02613950f, -0.09751860f, 0.00322778f, -0.13084491f, -0.03756367f, -0.13894771f, -0.30223086f, 
    -0.31864417f, -0.10471487f, 0.40268660f, -0.10099033f, 0.01330235f, -0.13721181f, 0.04696256f, 0.09830058f, 
    -0.00373298f, -0.04909702f, -0.05701536f, 0.03921624f, -0.71583420f, -0.00914565f, -0.39729908f, 0.15550177f, 
    -0.01971972f, -0.03779620f, -0.08694270f, 0.41879463f, -0.24855915f, -0.02117227f, -0.08269946f, -0.04750614f, 
    -0.34277460f, -0.12386636f, -0.28755188f, 0.15775713f, 0.00003556f, -0.09266776f, -0.00746503f, 0.14124301f, 
    -0.07354239f, -0.01854381f, 0.11817391f, 0.01439177f, 0.16286635f, 0.15973721f, -0.05906606f, -0.30826688f, 
    -0.09714446f, -0.21504195f, 0.09254988f, 0.00930016f, 0.01353652f, -0.08151834f, 0.07331807f, 0.05388451f, 
    -0.32677752f, -0.13392463f, -0.02886221f, -0.08575735f, 0.01520901f, 0.04975693f, 0.04871662f, -0.06323258f, 
    -0.00454201f, 0.02603602f, 0.21691203f, 0.13502392f, 0.21186100f, 0.26141343f, 0.14071633f, 0.14281774f, 
    -0.15923896f, 0.01882386f, -0.06444070f, 0.01994175f, -0.08902889f, -0.06072501f, 0.02951356f, 0.00178376f, 
    0.81014007f, -0.08672521f, 0.13054673f, -0.13146703f, 0.12209570f, 0.11505415f, -0.19476540f, 0.15712830f, 
    -0.03985103f, 0.04548055f, -0.04345315f, -0.04634596f, 0.08593245f, -0.01266239f, 0.09796640f, 0.33267739f, 
    0.11348511f, -0.10856796f, 0.15061343f, -0.07412455f, 0.06316267f, -0.06802062f, 0.03075808f, -0.03473727f, 
    0.11269560f, 0.01733035f, 0.04212628f, 0.04344912f, -0.04757904f, -0.30772698f, 0.00160889f, -0.19719531f, 
    -0.12298335f, -0.03478887f, -0.09696417f, 0.01806912f, -0.24176866f, -0.38137093f, -0.07695207f, -0.03948113f, 
    -0.19210653f, -0.13291793f, -0.14277774f, -0.02280599f, -0.01964890f, 0.03529703f, -0.05659251f, -0.05150620f, 
    -0.01740506f, -0.33376846f, 0.33706692f, -0.06465513f, 0.02221078f, 0.07632528f, 0.02163024f, -0.03467144f, 
    -0.03870445f, -0.05880445f, -0.04243786f, -0.01703815f, -0.15490793f, 0.19184346f, -0.13582802f, 0.03645293f, 
    0.06374301f, 0.05472600f, 0.15815619f, 0.00870624f, -0.03637269f, -0.05217538f, 0.01228307f, -0.10158951f, 
    0.18197978f, -0.11499318f, 0.07427219f, -0.16022953f, -0.00279428f, 0.21414752f, -0.00309828f, 0.11435121f, 
    -0.04683869f, 0.05870375f, 0.13323928f, 0.03734805f, -0.31598803f, -0.39106911f, -0.12410064f, -0.12274393f, 
    -0.10974806f, -0.02748129f, 0.01302412f, -0.05577866f, 0.00403168f, 0.08471359f, 0.01572592f, -0.13679284f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12730305f, 0.10707438f, 0.08354823f, -0.05677126f, -0.08700682f, 0.09655240f, 0.03135113f, -0.09881818f, 
    0.06201941f, 0.03754010f, 0.01640602f, -0.01060291f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
