#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.11096287f, -0.38670728f, -0.36544910f, -0.56258756f, -0.44737637f, -0.56519043f, -0.44281062f, 0.09207661f, 
    0.27428606f, -0.07590061f, -0.35841730f, 0.05709063f, 0.18609545f, -0.32916391f, -0.29874620f, -0.24604477f, 
    -0.06175047f, -0.10336057f, -0.20852654f, -0.36386761f, -0.38647151f, -0.07992896f, -0.29305875f, 0.04016062f, 
    -0.17306891f, 1.04543722f, 0.73266405f, 0.36621183f, -0.37383312f, -0.79856670f, -0.24698675f, -0.23208615f, 
    -0.00591404f, -0.51525074f, 0.04139840f, 0.11254904f, 0.07733674f, -0.06953574f, 0.25006095f, 0.17683731f, 
    -0.11975796f, 0.13656184f, -0.14572327f, -0.15571427f, 0.01566479f, -0.26377955f, 0.01039074f, 0.04055436f, 
    -0.06047078f, 0.09965462f, -0.06686062f, 0.81485748f, -0.02814336f, -0.60663319f, -0.48202595f, 0.16631588f, 
    -0.47353828f, -0.24346738f, -0.21283497f, 0.04455147f, 0.15638801f, -0.00537106f, 0.21348603f, 0.41840333f, 
    -0.16518970f, 0.25851023f, -0.19134641f, 0.18671809f, 0.07622093f, -0.24741666f, -0.12887359f, 0.27168733f, 
    0.10056406f, -0.22195151f, 0.40011182f, 0.78776860f, 0.70957834f, 0.10262699f, 0.00692519f, 0.53225595f, 
    -0.16822813f, -0.06584708f, 0.36760223f, 0.23385052f, 0.41638583f, -0.00058829f, 0.27369434f, 0.00568032f, 
    0.06704830f, -0.27103975f, 0.19619040f, -0.05956221f, -0.13354570f, 0.32374936f, -0.14545184f, 0.11982087f, 
    0.13034685f, -0.11173617f, -0.06946164f, 0.14609173f, -0.05770913f, -0.77259409f, -0.53274477f, 0.30809817f, 
    0.20236529f, 0.65895855f, 1.11831009f, -0.10556880f, 0.45407632f, 0.25896406f, -0.20760362f, 0.06898230f, 
    -0.07682053f, 0.45088676f, -0.15881920f, -0.18276976f, -0.03447042f, 0.07012156f, -0.05679904f, -0.19730955f, 
    -0.00880301f, -0.07384873f, -0.08148871f, -0.21343756f, 0.02826947f, 0.16077591f, -0.59621954f, 0.32302451f, 
    0.79974967f, -0.32367969f, -0.36747438f, -0.41631556f, 0.60571498f, -0.26594868f, 0.12948321f, 0.16757312f, 
    -0.31222087f, 0.04345801f, 0.16328937f, 0.27401969f, -0.23866864f, -0.00084458f, -0.14146452f, -0.45495126f, 
    -0.07666741f, -0.03318011f, 0.29992804f, 0.14806163f, -0.11258481f, 0.15280893f, 0.28812069f, 0.21032768f, 
    0.37408528f, 0.66319281f, 0.49928334f, 0.09907404f, 0.15238251f, 0.38175952f, 0.00303841f, -0.01636276f, 
    -0.54249424f, -0.52388281f, -0.11699256f, 0.23803540f, 0.27264857f, 0.06889109f, -0.31643975f, 0.26569149f, 
    0.19912858f, 0.11733402f, 0.41374263f, 0.08633318f, 0.09557769f, 0.09464844f, 0.05194693f, -0.81406063f, 
    -0.08918346f, -0.60222441f, -0.46806285f, -0.04981841f, 0.09672231f, 0.65959823f, -0.08709486f, 0.53217757f, 
    0.65502536f, 0.42592016f, -0.04263676f, 0.08878633f, -0.38383883f, -0.03211349f, 0.22061314f, -0.08350639f, 
    0.16230619f, 0.17082533f, -0.13682443f, 0.05966524f, -0.04852682f, -0.24098213f, 0.11573463f, 0.04008366f, 
    0.83476943f, 0.45175755f, 0.33976069f, 1.12331223f, 0.54352683f, 0.27725649f, -0.33419356f, -0.24796869f, 
    -0.47215790f, -0.15767193f, 0.02178213f, 0.19689347f, 0.03655998f, 0.03935244f, -0.20473404f, 0.09540349f, 
    0.07982975f, 0.00991509f, -0.06894235f, -0.04848406f, -0.08333898f, 0.05444468f, 0.12204119f, -0.15120263f, 
    0.00045016f, 0.09299288f, 0.53094542f, -0.26617786f, -0.55548197f, 0.75014192f, 0.45162594f, -0.59502530f, 
    -0.85357124f, -0.12635510f, -0.13813460f, -0.12739936f, 0.50373608f, 0.21012653f, 0.20741785f, 0.04563902f, 
    0.02787729f, 0.27429998f, -0.04038031f, 0.03972511f, 0.16748336f, 0.21543837f, -0.09501474f, 0.00635637f, 
    -0.11753497f, -0.23107319f, -0.66376621f, -0.45566332f, -0.07571921f, -0.31600270f, -0.52361357f, -0.53916591f, 
    0.18117443f, 0.11068114f, -0.11929201f, -0.01977501f, -0.15146780f, 0.21474682f, 0.02688768f, 0.30063429f, 
    -0.28237739f, -0.06711224f, -0.10083286f, 0.15866816f, 0.06583889f, 0.05089439f, -0.12812196f, 0.21246977f, 
    0.02058233f, 0.03186757f, 0.33856416f, 0.14803752f, -0.54183054f, -0.60580653f, 0.47268811f, 0.66877592f, 
    -0.97082084f, -0.41681960f, -0.15690784f, -0.30587131f, 0.11826183f, -0.09291478f, 0.27206197f, 0.16268072f, 
    0.12274632f, 0.18867414f, -0.02982127f, 0.15642741f, 0.11967613f, -0.04713204f, -0.01958586f, -0.04324695f, 
    -0.07770485f, 0.07626270f, 0.19133645f, 0.04084431f, -0.54675496f, -0.44306761f, -0.52657163f, -0.04209165f, 
    -0.18158622f, -0.55615896f, -0.07741569f, -0.09841994f, -0.48576668f, 0.02794122f, 0.58833301f, 0.43066901f, 
    0.09998525f, 0.05713534f, 0.09977786f, 0.05811233f, 0.23594467f, 0.11490427f, 0.19398530f, 0.06785490f, 
    0.17102310f, -0.12656502f, 0.04595080f, 0.08135012f, 0.07368067f, -0.53612077f, -0.80573434f, 1.00121140f, 
    0.33127645f, 0.17828742f, 0.67899954f, 0.18424770f, 0.64860713f, 0.39751330f, -0.23371898f, 0.06886987f, 
    -0.21601795f, -0.04247181f, 0.07551598f, -0.33486822f, 0.19292776f, 0.01270702f, 0.08875481f, -0.12612680f, 
    -0.05745914f, 0.04081637f, 0.09451219f, -0.03473249f, -0.08347677f, -0.07932279f, -0.47562757f, 0.43436748f, 
    -0.04378562f, -0.70740217f, -0.74939024f, 0.80508357f, 0.40284228f, -0.05092622f, 0.18662031f, 0.05387912f, 
    0.28254244f, -0.16085406f, -0.07424030f, -0.03946463f, -0.07755893f, 0.09299597f, -0.06254341f, 0.11255650f, 
    0.14621761f, -0.02796995f, -0.16927835f, -0.18802437f, 0.13524738f, 0.12604634f, 0.03447111f, 0.32129410f, 
    0.21652062f, -0.01811051f, -0.59329307f, -0.05081258f, 0.16507275f, 0.53330743f, 0.67313731f, 0.23295180f, 
    -0.18398619f, -0.32466549f, 0.41380507f, -0.08844575f, -0.10705844f, -0.59529430f, -0.33752513f, 0.10637978f, 
    0.17734116f, -0.34147519f, 0.12049366f, 0.15982056f, -0.02392645f, 0.11578279f, -0.12981044f, -0.03009230f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09568514f, 0.00722125f, 0.21781367f, 0.17899653f, -0.00349835f, 0.24065807f, 0.06637508f, 0.32727253f, 
    0.01473158f, 0.23643060f, 0.08092464f, 0.22064455f, 0.20305724f, -0.00767723f, 0.08200979f, -0.06489183f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00716268f, 0.17594363f, 0.02202356f, -0.03249158f, 0.06097147f, 0.12544513f, -0.05547697f, -0.08914363f, 
    0.01969711f, -0.05732440f, 0.04672157f, 0.11503276f, 0.39684951f, 0.29040581f, -0.11339736f, 0.16642751f, 
    0.02060356f, -0.02587499f, -0.11843269f, -0.05042086f, 0.17921332f, 0.00021112f, -0.10566793f, 0.03380493f, 
    0.27724922f, 0.09675851f, -0.16507974f, 0.32306492f, -0.05071384f, 0.05691990f, 0.00314999f, 0.05393382f, 
    0.10319086f, 0.05890532f, -0.00874496f, 0.05030219f, -0.13847651f, 0.40572688f, 0.01004842f, 0.13315839f, 
    0.11318404f, 0.08287557f, -0.11373859f, 0.03224736f, 0.13163108f, -0.00550949f, -0.02835929f, 0.09563752f, 
    0.12558794f, -0.27875257f, 0.00938048f, -0.10462554f, -0.05057868f, 0.03925907f, 0.06395651f, -0.12993230f, 
    0.10415369f, -0.08254623f, 0.09349258f, 0.05739506f, -0.09257238f, -0.00861718f, 0.13977572f, -0.08405414f, 
    0.19310459f, -0.18788379f, 0.27026147f, 0.08637675f, 0.08563741f, -0.02205472f, 0.11288482f, -0.02815562f, 
    0.02750886f, 0.07508614f, 0.30412629f, -0.12759045f, -0.03020897f, -0.12231781f, 0.11215279f, 0.14811417f, 
    -0.09075591f, -0.07300236f, -0.09473678f, 0.00070453f, -0.19118580f, -0.05264890f, -0.10135242f, 0.05429365f, 
    0.03399228f, 0.00870386f, 0.04676240f, -0.02058607f, 0.11201101f, 0.08219831f, -0.04674047f, 0.05559596f, 
    0.16968516f, 0.03673759f, 0.13692912f, -0.10195444f, -0.00020472f, -0.06905228f, 0.02421072f, 0.05301289f, 
    0.10571190f, -0.01642185f, 0.05963286f, -0.06688309f, 0.16880906f, -0.19017534f, -0.09483533f, 0.42278531f, 
    -0.00569575f, -0.03350224f, -0.05713137f, 0.04430192f, 0.06255284f, -0.03496705f, 0.09039591f, 0.08268011f, 
    -0.10841425f, 0.07025073f, -0.04719878f, -0.06701970f, -0.00448828f, -0.08303420f, 0.04008329f, -0.08475558f, 
    0.01545091f, -0.02505607f, 0.19109105f, -0.00577315f, -0.17670606f, 0.31902158f, -0.10405178f, -0.05255385f, 
    0.02352340f, 0.15464520f, 0.00525130f, 0.18647218f, 0.06822212f, -0.04202537f, 0.04201338f, 0.09228764f, 
    -0.00530836f, 0.34997967f, -0.11674617f, -0.01939437f, 0.17115296f, -0.01325975f, 0.06943525f, 0.01541119f, 
    -0.06372105f, 0.04680414f, 0.02429325f, -0.02273275f, -0.18426020f, -0.18471938f, -0.02025225f, 0.01769551f, 
    0.01425815f, 0.03756784f, -0.09177189f, 0.02429193f, 0.01547519f, -0.04159277f, 0.07265899f, 0.05165920f, 
    -0.22175257f, -0.17603326f, -0.27212650f, 0.24811357f, 0.01666539f, 0.00438898f, -0.06941082f, -0.06430658f, 
    -0.02430415f, 0.05381614f, -0.06186111f, -0.01094123f, -0.11545732f, -0.27316600f, -0.02350920f, 0.13426454f, 
    -0.00177180f, 0.01503662f, -0.05382906f, 0.01152403f, 0.10699236f, -0.05437884f, 0.00883760f, 0.04512672f, 
    0.07180380f, -0.09396107f, -0.02377730f, 0.23069356f, -0.05120930f, -0.04675233f, 0.08820639f, 0.06532644f, 
    -0.00485081f, 0.29643595f, 0.18392138f, 0.16226684f, 0.41389850f, -0.17591000f, -0.11406995f, -0.03179558f, 
    -0.07756447f, -0.08365785f, 0.22911850f, 0.08569084f, -0.00768972f, 0.13106646f, 0.09469976f, -0.10535235f, 
    0.05979584f, -0.16308773f, -0.13345486f, 0.18564895f, -0.10727701f, 0.05246147f, 0.13000977f, 0.09995912f, 
    0.02435457f, 0.04481480f, 0.03438214f, -0.02150312f, 0.31499490f, 0.07813376f, 0.03249026f, 0.11599191f, 
    -0.04354505f, -0.00188279f, 0.21806921f, 0.01233714f, 0.00719401f, -0.05570589f, -0.19029370f, 0.08635418f, 
    0.17094152f, -0.34152755f, -0.07324416f, -0.00134004f, 0.06930785f, -0.04808320f, 0.10161952f, 0.02257595f, 
    0.02019702f, 0.00041242f, 0.13799860f, 0.02751795f, -0.14939991f, 0.03509599f, 0.10639486f, -0.07245391f, 
    0.06763615f, 0.11227845f, -0.01866772f, -0.01324832f, 0.12170154f, -0.07886542f, 0.18203436f, -0.02127442f, 
    0.26462585f, 0.32034615f, 0.03017863f, 0.00054744f, -0.06392094f, -0.02931883f, 0.09000873f, 0.12639281f, 
    0.05709640f, -0.09839146f, -0.10495950f, -0.11355514f, -0.05783350f, 0.21413302f, -0.09857323f, 0.12900524f, 
    -0.09427322f, -0.03543405f, -0.06874212f, -0.01086918f, 0.07635377f, 0.03757084f, -0.05329224f, -0.14697401f, 
    0.26779258f, -0.13276707f, 0.22554819f, 0.41883191f, 0.28140843f, 0.27544183f, 0.08210171f, -0.07055365f, 
    0.02523361f, -0.11859073f, -0.02636177f, 0.15222089f, -0.00198367f, -0.27912736f, 0.14036575f, 0.37537852f, 
    0.02679366f, -0.05032370f, 0.06258184f, -0.07668406f, -0.10289843f, -0.08043928f, -0.12605830f, 0.01713741f, 
    -0.06580894f, 0.33079493f, -0.04702188f, -0.02229544f, -0.02616079f, -0.33853143f, 0.00500744f, -0.03144729f, 
    -0.04398433f, -0.00914350f, 0.07039113f, 0.23876475f, 0.22341016f, -0.25365201f, 0.06439143f, -0.12476940f, 
    0.10072260f, 0.20124604f, -0.13315804f, 0.12584686f, 0.10008124f, -0.07224590f, -0.05824336f, -0.07512394f, 
    0.20906730f, 0.06988887f, -0.09553873f, -0.00861696f, 0.09626038f, -0.01446084f, -0.14088979f, -0.06817666f, 
    -0.14325289f, -0.03572713f, -0.15527156f, -0.07117571f, -0.42505565f, 0.09333133f, -0.11596174f, -0.03884820f, 
    -0.13687892f, 0.12190644f, -0.04337339f, 0.04900140f, 0.02419968f, 0.04412702f, -0.02246737f, -0.13010493f, 
    -0.27592349f, -0.08114213f, 0.00610094f, 0.27149811f, 0.02910430f, -0.12815800f, -0.23176372f, 0.12358660f, 
    -0.06734890f, 0.11561621f, 0.01025697f, 0.06999959f, -0.14116016f, -0.02464383f, 0.07664280f, 0.05030563f, 
    0.02621565f, -0.14569254f, -0.09604625f, -0.00993772f, -0.02858859f, -0.19100901f, 0.00825461f, 0.03149666f, 
    0.34347007f, -0.01161245f, 0.03397996f, 0.20511799f, -0.07466840f, -0.02572929f, 0.07670467f, 0.04864939f, 
    -0.16187638f, 0.00952841f, 0.10166258f, 0.01827302f, 0.41512632f, -0.10399862f, 0.05712254f, -0.05765489f, 
    -0.01537533f, 0.07995477f, 0.00564790f, -0.04714156f, -0.05329998f, 0.08409699f, 0.13649178f, 0.02148616f, 
    0.22177477f, -0.04710522f, 0.14726968f, 0.01918673f, -0.06907749f, 0.00306900f, 0.01725557f, -0.00069700f, 
    0.03133319f, -0.05912274f, 0.03516046f, -0.06193536f, 0.11165561f, -0.03200436f, 0.06762864f, -0.01061638f, 
    -0.05180829f, -0.08102502f, -0.04696546f, 0.07153405f, -0.02354515f, 0.02341869f, -0.06536689f, -0.24965690f, 
    -0.68784475f, 0.12456674f, 0.13341971f, -0.02970393f, 0.09877395f, 0.03465477f, 0.14462620f, -0.11188737f, 
    0.01074604f, 0.05915086f, -0.08379372f, -0.00410266f, -0.00862738f, -0.07693373f, -0.17070335f, -0.19643135f, 
    -0.13662578f, 0.05018066f, -0.05299326f, -0.05394956f, -0.05485295f, -0.02498005f, -0.03818570f, 0.03727996f, 
    0.41154665f, 0.13162030f, -0.17914282f, -0.00064816f, 0.06840949f, 0.04414389f, 0.12190221f, 0.02585255f, 
    0.07146186f, -0.04507705f, -0.07677132f, 0.06918314f, -0.07015178f, -0.05061475f, 0.16258773f, 0.02096442f, 
    0.18301730f, 0.14547153f, 0.14467528f, -0.01088428f, -0.02436701f, 0.02142011f, 0.06523630f, 0.00150466f, 
    0.05485227f, 0.33332521f, 0.02096095f, -0.11714930f, -0.12269014f, 0.03329110f, 0.00560781f, -0.00380593f, 
    -0.13101879f, -0.00087571f, -0.06534392f, -0.04067013f, -0.24556579f, -0.04322905f, 0.02084505f, 0.19086789f, 
    -0.10535081f, -0.05745243f, -0.14571652f, -0.00942071f, -0.09675243f, 0.13463047f, -0.05310293f, 0.06793390f, 
    0.18367802f, 0.17022412f, 0.24621537f, 0.31243846f, 0.21042727f, 0.07025433f, 0.04942084f, 0.07396537f, 
    -0.01038659f, -0.03730170f, -0.34436086f, 0.04571845f, -0.40935221f, 0.08871773f, 0.02350890f, 0.11403359f, 
    -0.06303816f, -0.15928917f, 0.04138897f, -0.00980186f, 0.00709766f, -0.04648348f, -0.04281090f, -0.01572896f, 
    -0.07124470f, 0.03592158f, 0.05575385f, 0.30518275f, 0.07405227f, -0.07566076f, 0.09061358f, 0.00117896f, 
    0.15190503f, 0.09681606f, -0.14565551f, -0.12809853f, 0.04160774f, 0.16460080f, -0.04033755f, 0.02542331f, 
    0.08779121f, -0.06453545f, 0.01831359f, 0.00744539f, -0.02334690f, -0.04672031f, 0.03630516f, -0.04491888f, 
    0.18146090f, 0.16980651f, 0.28983518f, 0.22539139f, 0.25022283f, -0.06041545f, 0.08984993f, 0.06744774f, 
    -0.02139774f, 0.10588067f, 0.09934133f, -0.05220900f, 0.09148708f, -0.17234430f, 0.11936213f, 0.13205975f, 
    0.04988496f, 0.15833876f, 0.06098415f, -0.11711420f, 0.04572098f, 0.13994373f, 0.02999741f, -0.16805507f, 
    0.23479235f, 0.35686707f, 0.15281373f, 0.00122882f, -0.18626685f, -0.13555728f, 0.01754844f, 0.04947604f, 
    -0.01326852f, 0.09249935f, 0.00578303f, -0.06146051f, -0.13703570f, -0.40753463f, 0.06568368f, 0.02504750f, 
    0.06021839f, -0.05050896f, 0.05469358f, 0.13551460f, 0.05342943f, 0.01419847f, -0.04189836f, 0.05186717f, 
    0.04433239f, -0.01714418f, 0.10501854f, 0.17131549f, 0.05107803f, 0.12845391f, -0.00184891f, 0.04448207f, 
    0.12797762f, 0.04579740f, 0.10917858f, 0.10917655f, -0.23420288f, -0.28371260f, -0.29972619f, 0.00160320f, 
    -0.06868798f, 0.11412147f, 0.08669518f, -0.10680030f, 0.00651318f, 0.06146100f, -0.09416333f, 0.07739723f, 
    0.29689145f, -0.08348597f, -0.01190298f, 0.11482831f, -0.05194887f, -0.00546186f, 0.02311277f, 0.09681730f, 
    -0.11645962f, -0.04535802f, 0.01384905f, 0.00439635f, 0.14061271f, 0.02154898f, -0.03769823f, 0.02537305f, 
    0.00248667f, 0.03630989f, 0.14090176f, 0.03269914f, 0.03694086f, 0.10346013f, -0.01017632f, 0.03662155f, 
    -0.30478394f, -0.35293788f, -0.07940053f, -0.11890431f, -0.15619193f, -0.03384567f, 0.02806940f, 0.06512544f, 
    0.05934887f, -0.11821076f, -0.03913461f, -0.06617549f, 0.02156677f, 0.27126837f, -0.00033940f, 0.12693939f, 
    -0.04085544f, -0.06925105f, 0.10425521f, 0.09378762f, -0.04392295f, -0.00765210f, 0.10400602f, -0.11443614f, 
    -0.01548967f, -0.39457855f, -0.13165803f, -0.17313115f, 0.06875091f, 0.01032499f, 0.03563490f, 0.02210603f, 
    0.02296238f, -0.12295095f, 0.13810241f, -0.04173291f, 0.23417507f, -0.09398324f, -0.00851125f, 0.06539096f, 
    0.06868556f, 0.05723797f, -0.02222834f, 0.13263863f, 0.01770231f, 0.06914923f, -0.00009935f, -0.13750124f, 
    0.31324723f, 0.26199704f, 0.27035749f, -0.13939175f, 0.05181752f, 0.02097799f, -0.03905879f, 0.04361156f, 
    -0.06537476f, 0.09203707f, 0.05647367f, 0.01492012f, 0.24147038f, -0.07964084f, 0.03145367f, 0.25861111f, 
    0.26334834f, 0.15968861f, -0.07420854f, 0.06999828f, 0.05278423f, 0.03108149f, -0.04894809f, -0.06437690f, 
    0.38830248f, 0.17708433f, 0.09454283f, 0.03672043f, -0.07146624f, 0.12667730f, 0.00993262f, -0.03819387f, 
    -0.00078792f, -0.01005750f, -0.09976904f, 0.01009187f, -0.12921126f, -0.07775860f, -0.04040579f, -0.25607306f, 
    -0.07610518f, 0.09297221f, -0.03876418f, 0.10140765f, -0.03733599f, 0.09771688f, 0.11241075f, 0.06180994f, 
    0.03456156f, 0.07280667f, -0.05068336f, 0.01132346f, -0.12821379f, -0.01017155f, -0.06081036f, 0.07206894f, 
    -0.04445415f, 0.15946065f, 0.12212368f, -0.06698365f, -0.27314425f, 0.08121184f, -0.18500015f, -0.07414473f, 
    -0.00950875f, -0.07126483f, -0.02561383f, -0.01640605f, -0.11389212f, -0.03658448f, -0.05055923f, 0.00359565f, 
    0.09171297f, 0.43389794f, 0.10168773f, -0.17826356f, -0.11268920f, -0.07386956f, 0.03873447f, 0.03778621f, 
    0.11483184f, 0.17924613f, 0.02126971f, 0.11526147f, 0.39979264f, 0.12694983f, 0.16134225f, 0.19786620f, 
    0.11669750f, -0.08993792f, -0.09639457f, 0.14697833f, 0.20951007f, -0.02900659f, -0.07912748f, 0.02119877f, 
    0.26422560f, -0.14735316f, 0.18834925f, 0.15469168f, -0.09366979f, -0.00975067f, 0.17332479f, 0.06897347f, 
    0.08594789f, 0.16926956f, -0.12178539f, 0.04098198f, -0.21226111f, 0.24855119f, -0.18810818f, 0.03043095f, 
    0.03058620f, 0.05175264f, 0.03984890f, -0.03023240f, 0.23251680f, 0.07492591f, -0.01787878f, -0.03177207f, 
    0.20693916f, -0.21268263f, -0.02774880f, -0.04329970f, 0.11053386f, 0.02391729f, 0.17005871f, -0.05420262f, 
    0.01226783f, 0.08274560f, -0.07429510f, 0.15303694f, -0.02265984f, 0.04084814f, 0.05013544f, 0.05749869f, 
    0.17691210f, -0.04662025f, 0.10885829f, 0.10642070f, 0.09823212f, -0.00268147f, 0.15285620f, 0.08162445f, 
    -0.23563689f, -0.20557818f, 0.04035259f, -0.05158305f, -0.04775893f, -0.08507510f, -0.09917988f, -0.01533462f, 
    -0.14689617f, -0.22958624f, -0.09139249f, 0.04190330f, 0.12361660f, -0.17484823f, 0.01878528f, -0.08161907f, 
    -0.01037255f, 0.06033088f, 0.04574027f, 0.09944610f, -0.13307539f, 0.02760526f, -0.13258243f, 0.05382094f, 
    0.36004871f, -0.09418303f, -0.34198678f, -0.45036772f, -0.01357461f, -0.18508217f, -0.16129713f, -0.03922457f, 
    0.03113802f, -0.04053563f, -0.02495540f, -0.18011671f, 0.24075809f, -0.09692684f, -0.02776401f, 0.29859212f, 
    0.26707253f, 0.05783335f, 0.10120457f, 0.17377003f, 0.00746421f, -0.03458368f, 0.05525761f, -0.05004882f, 
    -0.04437783f, 0.37531191f, 0.02241666f, -0.11456452f, -0.32881951f, -0.12717582f, -0.06724941f, -0.10426251f, 
    -0.00776299f, 0.02266730f, 0.10008331f, -0.16230857f, 0.04921309f, 0.28107461f, -0.07529359f, 0.27179021f, 
    0.19482508f, 0.00031946f, -0.01494062f, 0.14308652f, -0.08472282f, 0.01549462f, 0.01388270f, -0.11202413f, 
    0.00877011f, 0.30171546f, -0.14849347f, 0.01010798f, 0.13679278f, 0.06997126f, 0.13223732f, -0.00261996f, 
    -0.12331966f, -0.15460281f, -0.03353145f, -0.28438786f, 0.15215741f, -0.29250440f, -0.01562211f, -0.07981078f, 
    0.09014063f, 0.22802080f, 0.07642929f, 0.16519015f, -0.05985803f, 0.02681515f, 0.11400793f, 0.12559575f, 
    -0.03831374f, -0.35607925f, -0.15055320f, -0.00376474f, -0.25513890f, 0.18721603f, -0.01860527f, -0.04126536f, 
    -0.08877552f, 0.15545011f, -0.00110850f, 0.00903059f, -0.49117267f, -0.04624399f, -0.07537252f, 0.03174408f, 
    -0.05484475f, 0.09156074f, 0.08925003f, 0.02948245f, -0.10708788f, 0.07205982f, -0.06994967f, -0.01840413f, 
    0.11201809f, 0.36483973f, 0.14601816f, 0.18641694f, -0.06862168f, -0.09545098f, 0.03859512f, 0.08613732f, 
    -0.16248471f, -0.12268117f, -0.06715339f, -0.27243495f, -0.20096979f, 0.02290655f, 0.08632760f, -0.06051765f, 
    0.00357477f, -0.05715735f, 0.16121402f, -0.08461601f, -0.08158547f, 0.06204205f, -0.04018858f, 0.00383999f, 
    -0.26661399f, 0.08491832f, 0.01023632f, -0.07888425f, 0.17565884f, 0.02788249f, -0.00606210f, -0.15388295f, 
    0.04096341f, 0.03943994f, 0.04855492f, 0.06770417f, 0.21947931f, 0.03432967f, -0.08144086f, -0.00167230f, 
    0.25133780f, -0.07618012f, 0.07582907f, -0.15318492f, 0.08388044f, -0.15229796f, -0.02252228f, 0.12640096f, 
    0.53899425f, 0.04205908f, 0.20610482f, 0.09963897f, -0.11275896f, 0.04799839f, -0.11555877f, 0.08507027f, 
    -0.03545191f, -0.08911251f, -0.03406270f, -0.14113119f, -0.04781020f, 0.20650785f, -0.24231647f, -0.07082576f, 
    -0.04165827f, 0.02372065f, -0.04373032f, -0.03596181f, -0.01611006f, -0.01776296f, 0.01877639f, -0.04888562f, 
    -0.18547781f, -0.16619447f, -0.07595010f, -0.09380275f, -0.05550759f, 0.04439508f, -0.04788548f, -0.03517007f, 
    -0.04308746f, 0.05615754f, 0.16735955f, 0.06477077f, 0.34123310f, 0.00500306f, 0.07638163f, 0.30951491f, 
    0.07185972f, 0.00798280f, 0.07370782f, 0.04489677f, -0.02556733f, 0.05929936f, 0.03090134f, -0.01483874f, 
    -0.26323849f, -0.22355050f, -0.14017971f, -0.16223653f, 0.11807237f, -0.04215281f, -0.01700532f, -0.20457251f, 
    -0.03408414f, 0.12951626f, 0.04265406f, 0.04307346f, -0.20154770f, 0.07352699f, -0.11345714f, -0.15527260f, 
    0.17703980f, -0.14130563f, 0.06757876f, 0.00558316f, 0.09063943f, -0.10776392f, -0.07288498f, -0.13342135f, 
    0.22394557f, 0.10691359f, 0.08517648f, 0.17234935f, 0.09809154f, 0.05957046f, -0.08001521f, 0.10876279f, 
    0.07417270f, 0.18178886f, 0.10419574f, -0.14556423f, 0.30743930f, -0.24011794f, -0.34595773f, -0.12654692f, 
    0.13076672f, 0.03755271f, -0.08678676f, 0.01076389f, -0.10726540f, 0.10413395f, -0.02923651f, 0.10958344f, 
    0.66081238f, 0.11570693f, 0.23699008f, -0.00453368f, 0.01458254f, 0.10900131f, -0.12617132f, 0.00473090f, 
    -0.03940916f, 0.06368843f, 0.14631343f, 0.08349030f, -0.04629081f, 0.07791950f, -0.05676684f, -0.21880820f, 
    -0.09722148f, 0.07625748f, -0.05941325f, 0.00423810f, 0.03815456f, 0.07644839f, -0.07773713f, 0.02492126f, 
    0.01579818f, 0.21800907f, 0.16022751f, 0.16446035f, 0.05014097f, -0.07451747f, -0.03676570f, -0.03823619f, 
    0.02227175f, -0.06444977f, 0.03132435f, -0.09977628f, 0.11506972f, 0.25872853f, 0.08275875f, 0.03527223f, 
    -0.08004332f, 0.00589143f, -0.03529486f, 0.15753628f, 0.04632887f, -0.05125091f, 0.02927330f, 0.00162884f, 
    0.22044589f, -0.05676341f, 0.01997690f, 0.12191571f, 0.09047929f, 0.20192951f, 0.16383182f, 0.00952170f, 
    -0.00495666f, 0.08023498f, 0.19711173f, 0.15201490f, -0.03463870f, -0.24801651f, 0.05886503f, -0.10310399f, 
    -0.15856762f, -0.06153308f, 0.04518397f, -0.06543700f, -0.02959014f, -0.08881211f, 0.00589392f, 0.10471842f, 
    0.06571098f, 0.26975757f, 0.18449184f, -0.00895685f, 0.06959215f, -0.04854819f, 0.03122409f, 0.02462321f, 
    0.03371383f, 0.07186744f, 0.04099534f, 0.01873024f, 0.16185687f, -0.49922949f, -0.25204080f, -0.21611637f, 
    -0.29042745f, -0.25593409f, -0.16752489f, -0.13965823f, 0.03972461f, 0.17300327f, 0.07161712f, 0.04861033f, 
    -0.22971453f, 0.43726167f, -0.22742179f, -0.05584140f, 0.00262385f, 0.01754857f, 0.12076916f, -0.06611672f, 
    0.05190036f, -0.12565856f, 0.10378367f, -0.00741347f, 0.13534123f, -0.11470641f, -0.00292008f, 0.06236226f, 
    0.01359954f, 0.01839586f, -0.15016276f, 0.00686832f, -0.08225536f, -0.23638052f, -0.06273511f, -0.03579417f, 
    0.12771560f, 0.06095725f, -0.12502117f, 0.06363113f, -0.09866525f, -0.16990843f, -0.20989943f, -0.15636212f, 
    0.03049641f, -0.17322195f, 0.14108928f, -0.05342069f, -0.01171414f, 0.36800495f, -0.04668367f, -0.26933220f, 
    0.23647578f, 0.22093292f, 0.04473921f, 0.00054980f, 0.07755709f, 0.07540048f, 0.02714135f, -0.04334605f, 
    0.46737731f, -0.31926969f, 0.04437388f, 0.38960955f, -0.09801663f, -0.07819461f, -0.08809525f, -0.04027339f, 
    -0.04911566f, -0.00721407f, -0.00410215f, -0.08848581f, 0.20801553f, 0.10011138f, -0.03823193f, -0.18194771f, 
    0.01328104f, -0.00037157f, 0.03108895f, -0.03216078f, -0.07483713f, 0.08272831f, -0.06832700f, -0.05880614f, 
    0.21719752f, -0.06612437f, 0.22666743f, -0.01329942f, 0.16319731f, 0.02875602f, -0.05163040f, 0.15893321f, 
    0.02177368f, 0.06765159f, -0.06214000f, 0.09251212f, 0.07904617f, 0.17696488f, 0.18168508f, 0.37502852f, 
    0.13673335f, -0.02558586f, 0.03077014f, -0.05213647f, 0.01632727f, -0.05300253f, 0.05128660f, -0.09612910f, 
    -0.09761227f, 0.05845886f, 0.07902116f, 0.01585840f, 0.12102882f, -0.10280951f, 0.01924554f, 0.05284965f, 
    0.12407231f, 0.07719082f, 0.07119836f, 0.04069436f, -0.46084920f, 0.14311016f, 0.09303296f, -0.06037098f, 
    -0.00161195f, -0.01485316f, -0.08391992f, -0.11580889f, 0.02443535f, -0.03416382f, -0.13914274f, -0.05351669f, 
    0.37753409f, 0.03343271f, -0.15939303f, -0.15860660f, 0.16820206f, 0.09245086f, 0.15407215f, 0.09624862f, 
    0.08375061f, -0.01873829f, 0.01055706f, 0.12041581f, 0.02633709f, -0.01905395f, -0.06246561f, -0.54576993f, 
    0.00346034f, 0.16665824f, 0.06469445f, -0.15658888f, -0.14845398f, -0.06284094f, 0.05660689f, 0.07916429f, 
    -0.09618217f, 0.02416300f, 0.04225725f, -0.14003901f, -0.04362394f, -0.00123483f, -0.02845754f, -0.04623685f, 
    -0.06739685f, -0.17681964f, -0.11737017f, -0.05140224f, 0.31680605f, 0.11637840f, 0.19675313f, 0.00059873f, 
    0.03623929f, -0.08586098f, 0.12560961f, -0.04661439f, 0.12772514f, 0.13522300f, 0.03676157f, 0.00956386f, 
    -0.10235742f, 0.01595611f, -0.00354439f, -0.22657759f, 0.12957180f, 0.01160754f, 0.12741552f, -0.07096097f, 
    0.16854522f, -0.06778409f, 0.22245651f, 0.10050417f, -0.00124038f, -0.16683157f, -0.02068476f, 0.07620414f, 
    0.08694636f, 0.10107877f, -0.23014867f, 0.06468154f, 0.20165657f, -0.09994550f, -0.07330019f, 0.19708052f, 
    0.29116917f, 0.11102281f, -0.16711491f, 0.07462357f, 0.21659552f, 0.04898236f, -0.11602817f, 0.05420152f, 
    -0.06692863f, -0.08084767f, 0.02479095f, -0.23930630f, -0.56340545f, 0.12935130f, 0.03694109f, 0.15947494f, 
    0.14224982f, -0.03110811f, 0.06082746f, 0.01745630f, 0.08913494f, 0.18008441f, -0.03206881f, -0.02772699f, 
    0.21409248f, 0.10429756f, -0.11968227f, 0.13590309f, 0.11917269f, -0.08862241f, 0.07739316f, 0.08337462f, 
    0.11218220f, 0.19612479f, 0.09769475f, 0.07402352f, 0.09845725f, -0.08241202f, -0.14045919f, 0.11959592f, 
    0.00170834f, -0.02687785f, -0.06021245f, 0.17993191f, 0.12874565f, -0.02750269f, 0.04707609f, -0.01705716f, 
    -0.10970118f, -0.12349731f, -0.20200217f, 0.09197768f, 0.13660920f, -0.11718308f, 0.17502233f, 0.02861786f, 
    0.16262507f, 0.03032301f, 0.13766219f, 0.12305725f, 0.16817203f, 0.00582496f, -0.03841737f, -0.00198102f, 
    -0.00308308f, -0.15293576f, 0.11526898f, 0.07285988f, 0.11507133f, 0.12171447f, 0.08938970f, 0.04882687f, 
    -0.20440300f, -0.05585145f, 0.04659708f, -0.12594077f, 0.00521448f, 0.06231831f, -0.04131230f, 0.17681049f, 
    0.19070470f, 0.19132629f, 0.11207748f, -0.11286904f, -0.38321847f, -0.02927939f, -0.11589622f, 0.14321892f, 
    0.03356644f, 0.00242166f, 0.05806541f, 0.10639222f, 0.15089260f, 0.19392115f, 0.04967661f, 0.12562646f, 
    -0.01399695f, 0.18192081f, -0.08559777f, -0.03621939f, 0.12087268f, 0.12671158f, 0.03827427f, 0.04936175f, 
    0.01841290f, 0.07334402f, 0.31483829f, 0.27429447f, -0.06546609f, 0.35017002f, -0.01861422f, -0.07803927f, 
    0.10400633f, -0.13183266f, -0.16859636f, -0.04119429f, 0.03815471f, 0.08128282f, -0.02099648f, 0.13449402f, 
    -0.51339847f, -0.25638780f, 0.22776075f, -0.22944772f, 0.10542522f, -0.00596307f, -0.05984202f, -0.03027898f, 
    0.12200059f, -0.13956463f, -0.08322356f, -0.07870353f, 0.04742688f, 0.09252274f, 0.05647093f, -0.07854471f, 
    0.01917713f, 0.17522562f, -0.10017092f, 0.15116180f, 0.07392443f, -0.21050878f, 0.03418659f, -0.11193319f, 
    0.00021470f, 0.20666598f, 0.13693984f, 0.08672506f, -0.07410046f, 0.10821283f, 0.06472883f, 0.10629069f, 
    -0.11226042f, 0.21409845f, 0.05978790f, 0.15296413f, 0.39376158f, -0.04026039f, -0.13069867f, -0.25334716f, 
    -0.01150669f, 0.14937824f, -0.07849204f, -0.27166644f, 0.31145599f, 0.18116511f, -0.04795580f, -0.03358225f, 
    0.30751058f, -0.05380008f, -0.10088427f, 0.09408454f, 0.10260861f, -0.08897876f, 0.02196649f, 0.04722830f, 
    0.10006502f, 0.02461248f, 0.07564659f, -0.03016358f, 0.03395103f, 0.17563026f, -0.31902155f, 0.26657194f, 
    0.07727533f, -0.00895492f, -0.03959408f, -0.01818668f, -0.08924865f, 0.19925693f, -0.05518203f, -0.12823518f, 
    0.06154458f, -0.04239962f, 0.16765183f, 0.15327466f, -0.04194638f, -0.00318686f, 0.09067731f, -0.02165588f, 
    0.10762198f, -0.02601960f, -0.03457358f, 0.04933732f, 0.19237055f, -0.11078259f, -0.01074648f, -0.33117235f, 
    -0.02018297f, -0.09606311f, 0.01213644f, -0.02525262f, 0.13737246f, 0.12925103f, 0.05243279f, 0.03673034f, 
    0.12820143f, -0.11966509f, -0.05452181f, 0.16063899f, 0.00403712f, -0.03724257f, 0.11311184f, 0.01571263f, 
    -0.08464385f, -0.04916976f, -0.00226789f, 0.03702730f, -0.39797702f, 0.05937991f, 0.19886288f, 0.35907289f, 
    -0.00057246f, 0.02662413f, 0.19683573f, 0.12813465f, -0.04894689f, 0.09176014f, -0.00968074f, -0.03936398f, 
    -0.13046645f, 0.11174341f, -0.00979379f, 0.02663160f, 0.22475262f, -0.06255574f, -0.10230085f, -0.02800496f, 
    -0.03990264f, -0.09001913f, 0.05149009f, -0.16380717f, -0.09540245f, 0.01186262f, -0.35660210f, 0.31641284f, 
    0.01701704f, -0.08563034f, -0.18873607f, 0.06831865f, -0.06106710f, -0.07323936f, -0.14773819f, -0.15739551f, 
    0.16663487f, 0.06684623f, 0.28978312f, 0.14525241f, 0.03946182f, -0.10879555f, -0.01460051f, -0.02765816f, 
    -0.09197520f, -0.03843219f, -0.22108307f, 0.14988740f, -0.43118489f, 0.22384155f, -0.02323190f, -0.06204296f, 
    0.05467564f, -0.00390855f, -0.08139139f, -0.04840852f, 0.13490123f, 0.05150174f, -0.15120468f, -0.11742022f, 
    0.03998017f, 0.28016672f, 0.22227052f, -0.10482984f, -0.17143200f, 0.10035488f, -0.11113381f, -0.12511989f, 
    -0.14024825f, -0.02543156f, -0.00260163f, -0.09758217f, 0.22457680f, -0.02714794f, -0.03080795f, -0.13945358f, 
    -0.05868736f, -0.06184332f, -0.21959840f, -0.06939704f, -0.19122189f, -0.03230792f, 0.15508319f, 0.01506512f, 
    -0.06581042f, 0.35273540f, 0.14172177f, 0.31559467f, 0.09249695f, -0.04978414f, 0.10908373f, 0.15518446f, 
    -0.21032710f, 0.14193654f, -0.06340706f, 0.04030591f, 0.13224311f, -0.11161604f, -0.04831686f, 0.21367164f, 
    0.02083611f, 0.06826366f, -0.05000326f, 0.05542960f, -0.09246175f, 0.22455601f, 0.08708864f, 0.05882113f, 
    -0.02056438f, -0.21455461f, -0.15564634f, 0.31715429f, -0.04359411f, 0.20725290f, 0.16148475f, 0.10978970f, 
    0.06598943f, 0.36715004f, 0.14963755f, 0.22205971f, 0.26292190f, -0.10035677f, -0.06321564f, 0.07920715f, 
    0.06885131f, 0.11269259f, 0.22004318f, 0.14554003f, 0.09366658f, 0.14769028f, 0.06121294f, -0.03800838f, 
    0.26519316f, -0.24837662f, 0.06484853f, 0.28600106f, -0.23210366f, -0.06824496f, 0.10728490f, 0.01637712f, 
    0.07345564f, 0.03320605f, 0.04970717f, 0.00535901f, 0.05631057f, 0.13985044f, 0.01818446f, 0.01745026f, 
    -0.00511649f, 0.02315094f, 0.08514798f, -0.07957827f, 0.01175780f, 0.05576169f, -0.03618245f, 0.02633564f, 
    -0.58545959f, -0.01355439f, -0.00290916f, -0.17962649f, 0.15961435f, -0.13325970f, 0.20679410f, -0.07357065f, 
    -0.06622091f, 0.01367605f, 0.05275900f, 0.02333921f, 0.12300438f, -0.09321070f, -0.00374970f, -0.32338011f, 
    0.08764452f, 0.12691207f, 0.11505929f, -0.01365132f, -0.06063222f, 0.04191023f, 0.14829090f, 0.03712355f, 
    0.11199371f, 0.16868189f, 0.09722328f, -0.12035220f, 0.06455135f, 0.05106322f, 0.06982350f, -0.04098823f, 
    0.00074978f, -0.11345270f, -0.03932761f, 0.17557579f, -0.42378736f, -0.19399674f, -0.11719434f, -0.04981526f, 
    -0.07268031f, 0.10207254f, 0.00242121f, 0.05126022f, -0.04794947f, 0.01177274f, 0.02406634f, 0.08250029f, 
    0.18528228f, 0.09366159f, 0.09625725f, 0.01676292f, 0.11573569f, 0.12564313f, 0.16768387f, -0.02553945f, 
    -0.05363055f, -0.12284359f, 0.13159284f, 0.10244112f, 0.19898945f, -0.11517270f, 0.02779093f, 0.44196767f, 
    0.00604919f, 0.09597722f, 0.02391215f, 0.00719988f, 0.02908835f, -0.02347786f, -0.06514537f, 0.05490830f, 
    -0.05459419f, 0.01330655f, -0.12039285f, 0.13217913f, -0.10334954f, -0.17055342f, 0.04180280f, 0.02516675f, 
    -0.12404291f, 0.01542205f, 0.07978653f, 0.24001408f, -0.19061798f, 0.17869391f, 0.11775435f, 0.07049744f, 
    0.04147951f, -0.09791975f, 0.06164216f, -0.03647147f, 0.18641756f, -0.01823565f, 0.07703048f, -0.11660327f, 
    -0.28298438f, -0.00996252f, -0.12224442f, 0.11795972f, -0.03345552f, -0.13289486f, 0.04254682f, 0.08749498f, 
    0.07113209f, 0.03898626f, -0.14119534f, -0.06956118f, 0.07273880f, 0.07261811f, -0.10399880f, 0.00773552f, 
    0.04026399f, -0.03232072f, -0.06875030f, 0.02834409f, -0.03057808f, 0.00450691f, 0.03019059f, 0.04521495f, 
    -0.24786605f, -0.16245221f, 0.05158528f, 0.13402142f, 0.17713077f, -0.03689478f, -0.00836095f, 0.09677585f, 
    0.02204607f, 0.02233719f, 0.15140517f, 0.04991905f, -0.18899801f, -0.26145172f, 0.05270366f, 0.22006802f, 
    0.03228534f, -0.05959627f, -0.09824023f, 0.00553672f, -0.11758988f, 0.11096380f, -0.00242733f, 0.22391474f, 
    0.11996913f, 0.14993170f, 0.07776571f, 0.25860298f, -0.06168175f, 0.07110159f, 0.10610298f, -0.04973092f, 
    0.08085100f, -0.06614951f, -0.03481454f, 0.05857601f, 0.20438942f, 0.04552326f, -0.19152436f, -0.07588634f, 
    -0.04530758f, -0.00739358f, 0.01498399f, 0.26485729f, -0.02379530f, -0.03991593f, 0.03012209f, 0.00291744f, 
    -0.18286894f, 0.22538868f, 0.35048276f, 0.14275007f, -0.01474025f, 0.13835371f, -0.12028871f, 0.05690222f, 
    -0.00314325f, 0.01071772f, -0.06613271f, 0.22494391f, 0.08377337f, 0.06461123f, -0.11704089f, -0.29834616f, 
    -0.01737100f, 0.12633480f, -0.12321166f, -0.05977686f, -0.00530777f, 0.10482701f, 0.13152313f, 0.33144164f, 
    0.20839506f, 0.34982610f, -0.13375518f, 0.01864578f, 0.01263343f, 0.02152459f, -0.02527654f, 0.02584959f, 
    0.05224765f, -0.05220077f, 0.20049694f, -0.15853328f, 0.32527381f, 0.14664748f, -0.08765977f, -0.08736170f, 
    0.03154428f, 0.00895668f, 0.06080912f, 0.09003701f, 0.00868941f, 0.07254075f, 0.05923242f, -0.03490087f, 
    -0.42988127f, -0.30399525f, -0.07759984f, -0.38420275f, -0.02717397f, -0.00814200f, 0.02206103f, -0.25653565f, 
    0.09099768f, -0.07045155f, 0.23853214f, 0.09461363f, 0.03094270f, 0.23556094f, 0.08501983f, -0.20524885f, 
    0.04596398f, 0.01534903f, -0.03622133f, -0.07763065f, 0.05013875f, -0.17301568f, 0.10456181f, 0.03450245f, 
    -0.04602789f, -0.51861006f, -0.17480908f, 0.26096740f, 0.08665192f, 0.02335562f, 0.02146141f, 0.05180108f, 
    -0.11627258f, 0.01639237f, 0.07814374f, 0.14828877f, 0.46344608f, 0.09524814f, 0.06535159f, 0.04565197f, 
    0.11674732f, -0.07675682f, 0.14053929f, -0.12160456f, 0.00983460f, 0.03583257f, 0.02333526f, 0.08339547f, 
    0.21393678f, 0.08283687f, 0.14570551f, 0.20733793f, 0.05126328f, 0.04007179f, -0.06403253f, 0.19281942f, 
    -0.08518101f, -0.07538844f, 0.08257300f, 0.20334840f, 0.18343855f, 0.12125500f, 0.08785577f, -0.00038113f, 
    0.06971540f, 0.07203243f, 0.01042551f, -0.03024062f, -0.04860165f, -0.01940443f, 0.06820621f, 0.12234235f, 
    0.02200541f, 0.05750705f, 0.17497720f, -0.03410142f, -0.05257702f, -0.20944437f, -0.14461520f, -0.09048433f, 
    0.02227950f, 0.01734072f, 0.04637692f, 0.26660353f, -0.29942518f, -0.29042572f, 0.46505165f, 0.30337405f, 
    -0.03501204f, -0.20461328f, -0.06849099f, 0.04167747f, 0.12819466f, 0.14382291f, -0.10800107f, -0.18344933f, 
    -0.00405853f, 0.14107628f, 0.15991977f, -0.26444244f, 0.27577618f, 0.05404195f, -0.09634969f, 0.13945225f, 
    0.25419793f, -0.13817064f, 0.08661570f, -0.05735386f, 0.33323377f, 0.21849501f, -0.03820863f, -0.20433834f, 
    0.14864001f, -0.12401643f, -0.09769790f, 0.00675657f, 0.08424479f, 0.10394727f, -0.05846804f, 0.06293795f, 
    0.11459143f, -0.10977924f, -0.00238560f, -0.00838475f, -0.02134060f, -0.07529838f, 0.11739226f, -0.01275765f, 
    -0.13257724f, 0.04288340f, 0.08730044f, -0.07211196f, -0.45674840f, -0.43513674f, 0.29145664f, 0.16554704f, 
    -0.00947263f, 0.05405856f, 0.03013628f, -0.06628362f, 0.25703591f, 0.02795122f, 0.06700644f, 0.00268116f, 
    0.08740568f, -0.18988496f, 0.02226031f, 0.15479003f, 0.14875522f, 0.03461855f, 0.03078220f, -0.08972134f, 
    0.10230590f, 0.01464504f, 0.09043518f, 0.16885762f, -0.23541884f, -0.60027462f, -0.28106493f, 0.01380030f, 
    -0.10191877f, 0.01420308f, 0.05430345f, -0.05857429f, 0.13357672f, 0.06159305f, 0.01580078f, 0.20802979f, 
    -0.27177125f, 0.04329942f, -0.13566810f, 0.21883519f, 0.07751153f, -0.19172364f, 0.14838412f, 0.01712351f, 
    -0.00614481f, -0.17002836f, -0.06065477f, 0.02278218f, -0.04664208f, -0.09378573f, -0.01310280f, -0.02714974f, 
    0.07052340f, 0.02672184f, 0.05376587f, 0.05726857f, 0.03744648f, 0.15081003f, 0.08815493f, -0.04046878f, 
    -0.00921322f, 0.03639843f, -0.22007856f, -0.13660297f, 0.22910778f, -0.16603528f, -0.06691139f, 0.06585456f, 
    0.09290692f, 0.06055967f, 0.16577245f, 0.01502199f, 0.02660319f, 0.01869246f, 0.06604614f, 0.25074175f, 
    0.03423916f, -0.00151669f, 0.00000488f, 0.09515738f, -0.04391674f, 0.00509475f, 0.07658466f, -0.09603561f, 
    0.01491299f, -0.22704472f, -0.05212902f, -0.15593758f, 0.23875751f, -0.13022952f, 0.01608010f, -0.00843138f, 
    0.04958858f, -0.08636945f, 0.07070945f, 0.17561905f, 0.14832073f, -0.03810942f, -0.10716669f, 0.25891933f, 
    0.09022644f, 0.07641587f, -0.02593943f, 0.05557257f, 0.05291284f, -0.00585064f, -0.05682269f, 0.12561257f, 
    0.23934472f, 0.03295035f, -0.02698107f, -0.04261638f, 0.04459841f, -0.11341458f, -0.07707917f, 0.06735475f, 
    -0.05775345f, -0.00999595f, -0.06111306f, -0.07939157f, -0.00973857f, -0.04874023f, -0.05703425f, 0.41494662f, 
    0.14222685f, -0.08396950f, 0.04163998f, 0.10630490f, 0.11190677f, 0.02596337f, 0.05693425f, 0.04870984f, 
    0.20259462f, 0.07053054f, -0.04979896f, -0.08245461f, 0.12443034f, -0.01431116f, -0.13927989f, 0.13887651f, 
    0.05195519f, -0.05033180f, -0.12296580f, -0.00515343f, 0.16444615f, 0.18312457f, -0.32961816f, -0.44336981f, 
    0.22297366f, 0.04204009f, -0.08380745f, 0.17701010f, -0.05257729f, 0.09257125f, 0.00492185f, 0.03937296f, 
    -0.02549240f, -0.05116213f, 0.05356611f, 0.14811824f, 0.00964404f, -0.07330728f, 0.10007510f, 0.10719931f, 
    0.05897832f, -0.11042525f, -0.06035990f, -0.05379056f, -0.34069923f, 0.02938728f, -0.07171554f, 0.03936989f, 
    -0.09186773f, 0.19464307f, -0.07468858f, -0.00586050f, 0.11103651f, -0.11151744f, 0.02428027f, -0.01246876f, 
    0.02196767f, -0.05931464f, 0.06045763f, 0.06198991f, -0.07652954f, -0.00049832f, -0.07507252f, -0.07458904f, 
    -0.01412262f, 0.02498945f, 0.06380838f, -0.02331723f, 0.02250190f, -0.04883981f, -0.06952585f, 0.04279087f, 
    0.02976182f, -0.04797878f, 0.02088233f, -0.01550947f, 0.01085940f, -0.00559599f, 0.04656352f, 0.03857906f, 
    -0.01302368f, -0.06730222f, 0.00555097f, 0.04141784f, 0.06058341f, 0.05715520f, -0.06832735f, -0.05650350f, 
    0.00180509f, 0.03147194f, -0.06179873f, 0.04863798f, -0.00829771f, -0.04404175f, -0.06527347f, 0.01453530f, 
    -0.00188205f, 0.06241527f, -0.05702852f, 0.03945610f, 0.01803687f, 0.04322339f, -0.05372395f, -0.05016784f, 
    0.00525718f, -0.05092151f, -0.06741958f, -0.06899489f, -0.03803814f, -0.07017341f, -0.06363790f, 0.00357203f, 
    -0.02733677f, -0.03885873f, -0.06985714f, -0.02775510f, 0.04425068f, -0.06373026f, 0.02823009f, -0.06556729f, 
    -0.06181753f, -0.04007685f, 0.01090362f, 0.04658818f, 0.01039672f, -0.00715049f, -0.00246225f, 0.05014198f, 
    -0.06076190f, 0.03671120f, -0.03289767f, -0.03947974f, -0.02273311f, -0.02313636f, -0.06516729f, -0.01837499f, 
    0.03616784f, 0.02609693f, -0.04041040f, 0.04691087f, -0.03105959f, 0.02884364f, 0.02266293f, 0.05882420f, 
    -0.07285803f, -0.06846979f, 0.00204540f, -0.00484248f, -0.04421854f, -0.01824452f, 0.00346090f, 0.06135986f, 
    -0.05506358f, 0.02601526f, -0.02462078f, -0.03128454f, 0.05943417f, -0.06247728f, -0.03283975f, -0.02905775f, 
    0.00278707f, -0.07390827f, -0.06578847f, 0.02279954f, -0.00198653f, -0.00724601f, -0.04764678f, -0.02704375f, 
    0.01505904f, -0.02549978f, -0.07730216f, -0.01658739f, -0.02118607f, -0.07780852f, 0.04388493f, -0.05097663f, 
    -0.05739602f, -0.01298335f, 0.00570714f, -0.01600089f, 0.01196914f, 0.02463511f, 0.05938156f, -0.02024768f, 
    -0.02105998f, 0.00711271f, -0.04378054f, -0.04155483f, 0.01349731f, 0.01990668f, -0.00675855f, -0.07549749f, 
    0.04418500f, 0.04027704f, -0.00677551f, 0.00264306f, -0.03492207f, 0.00540342f, -0.07617585f, 0.05520182f, 
    -0.02868005f, -0.05849189f, 0.00714044f, -0.06904360f, 0.01977864f, 0.03607308f, -0.01895745f, -0.03329735f, 
    -0.06839023f, -0.07228260f, 0.03683754f, -0.01665188f, 0.01243398f, -0.03257462f, 0.02428358f, -0.07282804f, 
    -0.06462913f, -0.02143863f, -0.03459226f, 0.00423291f, -0.06137069f, -0.04108563f, 0.04735354f, 0.03409664f, 
    0.03109262f, -0.02304890f, 0.02374913f, 0.00976314f, 0.00017787f, 0.05147345f, -0.06613865f, 0.04024898f, 
    -0.02161613f, -0.04631810f, -0.05504105f, -0.07653201f, -0.04784260f, -0.01565985f, 0.03442160f, 0.04289236f, 
    -0.03243386f, 0.06176569f, 0.04865760f, -0.04006602f, 0.02199383f, -0.04870364f, 0.03409269f, 0.01208026f, 
    -0.01314989f, 0.02495765f, -0.06546448f, -0.03920139f, 0.06318958f, -0.07667846f, 0.03874635f, -0.00271756f, 
    0.02762234f, -0.05060679f, -0.00345440f, -0.03452618f, -0.07255270f, -0.07837912f, -0.03353409f, -0.06599086f, 
    0.01622780f, -0.07078400f, -0.07460158f, -0.02800523f, 0.04302341f, -0.05577167f, -0.03214126f, -0.01917762f, 
    -0.06718937f, -0.00683301f, 0.01094919f, 0.01373239f, 0.04239842f, 0.00850511f, -0.01735292f, -0.01188286f, 
    -0.07521168f, 0.03405869f, -0.06614078f, 0.01591316f, -0.00219650f, 0.00888908f, -0.05770150f, 0.04208820f, 
    0.00956701f, -0.02998086f, -0.03438503f, -0.02598639f, -0.00747900f, -0.07256718f, -0.05244433f, 0.02841863f, 
    0.01454763f, -0.02043607f, 0.02757467f, -0.01266832f, 0.02756576f, 0.06285904f, -0.05445054f, -0.02394903f, 
    0.01863641f, -0.02879605f, 0.04441551f, 0.01262005f, -0.04212337f, -0.04757718f, 0.03189139f, 0.02020067f, 
    0.05285911f, 0.04286158f, 0.00788521f, 0.01909657f, 0.00049294f, -0.03286232f, -0.06358901f, -0.04141743f, 
    0.01893813f, -0.02985187f, 0.06279849f, 0.04027502f, 0.04775815f, -0.03543675f, 0.00361067f, -0.07842427f, 
    -0.02368657f, 0.01475311f, 0.02228034f, -0.07825269f, -0.06261720f, -0.06222484f, -0.03112298f, -0.03722975f, 
    -0.01397428f, 0.05612071f, 0.05934106f, -0.00655510f, -0.05448183f, 0.05026969f, -0.00891400f, -0.06877533f, 
    0.06287778f, 0.03524174f, -0.05292093f, 0.02435351f, 0.06032907f, -0.03410046f, -0.07729943f, -0.06456968f, 
    -0.03966539f, -0.06535854f, 0.04521492f, -0.03609664f, -0.03935604f, 0.04788986f, 0.00295922f, 0.00891392f, 
    -0.00721900f, -0.03326118f, -0.02959574f, -0.06019279f, 0.01461199f, 0.00989759f, -0.07777447f, -0.05702648f, 
    -0.06489491f, 0.00433640f, 0.05062795f, 0.00840736f, -0.03370325f, -0.05326990f, 0.02202401f, 0.00582782f, 
    0.04273005f, -0.01681698f, -0.07086156f, 0.03988506f, -0.05710087f, 0.02993915f, -0.05687371f, 0.05248975f, 
    -0.04148895f, 0.00438588f, -0.06713431f, -0.01615337f, 0.00382590f, 0.05633168f, 0.03170979f, 0.03901623f, 
    -0.03812166f, -0.06045857f, -0.01885604f, 0.03002550f, -0.02831189f, 0.00983400f, -0.04867780f, -0.00652912f, 
    0.02144422f, 0.03212690f, -0.05465147f, 0.03360737f, 0.01966976f, -0.04170647f, 0.03318784f, -0.07774235f, 
    0.05627110f, -0.00411988f, 0.06225935f, -0.06977297f, -0.03932858f, -0.07038393f, -0.02688488f, 0.00205474f, 
    -0.05564260f, -0.03650214f, -0.06176957f, 0.02513858f, -0.01838494f, 0.01945982f, 0.01673421f, -0.01635172f, 
    -0.03751270f, -0.06388025f, -0.02802121f, -0.07764608f, 0.06111514f, -0.05181838f, 0.03783411f, 0.01983050f, 
    -0.02792577f, -0.06306770f, -0.02150433f, 0.03092605f, 0.02057337f, 0.02477789f, -0.00851643f, -0.02478928f, 
    0.11696821f, 0.08062153f, 0.20134705f, 0.07819743f, -0.13818876f, -0.01643036f, 0.03581205f, 0.15706509f, 
    0.02210032f, 0.20376045f, 0.17455427f, 0.15610455f, -0.23896806f, -0.31183994f, -0.14510235f, -0.07361671f, 
    0.00772151f, 0.15650739f, 0.00396707f, 0.05060094f, 0.16172916f, 0.00887952f, -0.01771528f, -0.06427449f, 
    0.34216693f, 0.04320603f, 0.00680868f, 0.08461700f, 0.10695910f, 0.01299237f, -0.07199871f, 0.07229105f, 
    -0.00109172f, 0.13847280f, 0.02622653f, -0.05497593f, -0.14594758f, -0.19479549f, -0.28697136f, -0.07301892f, 
    -0.03108813f, -0.03801097f, 0.09862400f, -0.06007155f, -0.09916291f, 0.18894944f, 0.03382128f, -0.09000108f, 
    -0.10257085f, -0.00803644f, 0.11092317f, 0.06694909f, -0.19668980f, 0.03058287f, 0.14367040f, 0.02587678f, 
    0.03622830f, 0.01631348f, 0.07236890f, 0.21506532f, 0.51881433f, -0.20501207f, 0.07082483f, -0.03317343f, 
    -0.00223664f, 0.15020601f, -0.06697202f, 0.01885298f, 0.00251473f, -0.02921837f, -0.05107413f, 0.02321408f, 
    -0.27396587f, -0.19957089f, -0.05353272f, 0.11495440f, -0.06897917f, 0.03609822f, -0.04958366f, -0.14520921f, 
    0.02548618f, -0.10326549f, 0.09348556f, -0.07472186f, -0.15671214f, 0.22227132f, 0.26907125f, 0.11030781f, 
    -0.05390081f, 0.09656978f, -0.04919677f, 0.00349834f, -0.11331169f, 0.02028159f, 0.02685253f, 0.08363625f, 
    0.09180334f, -0.08997690f, -0.04561324f, 0.16831000f, -0.11843570f, 0.02970591f, -0.07954269f, -0.00378724f, 
    -0.07339020f, 0.00283468f, -0.03690902f, -0.14215562f, 0.21671949f, 0.04372356f, -0.01259652f, -0.04881547f, 
    0.03708051f, 0.08686360f, -0.05009042f, 0.06690335f, -0.05473289f, -0.03485110f, -0.07622170f, -0.00356585f, 
    0.23648937f, 0.03350917f, 0.16478382f, 0.02243615f, 0.03264054f, -0.03650632f, 0.00982840f, -0.01076491f, 
    0.00969486f, -0.05248019f, -0.07455312f, 0.17928065f, 0.05056937f, 0.14475355f, 0.25982699f, 0.22557829f, 
    -0.03035197f, 0.03126799f, 0.03459189f, -0.04868093f, 0.06753230f, 0.04568010f, -0.03927660f, -0.15426214f, 
    0.03108461f, 0.04114596f, 0.16415301f, -0.01070016f, -0.05563324f, -0.03349607f, 0.06334107f, -0.07640946f, 
    -0.01287963f, -0.02677421f, -0.11800815f, -0.07537697f, 0.42764044f, -0.07600924f, -0.01051330f, 0.04898048f, 
    -0.11429820f, 0.10121503f, 0.10647567f, 0.09840728f, -0.07621332f, 0.01253160f, 0.00096638f, -0.11208870f, 
    0.29502997f, 0.28699130f, -0.00038731f, 0.04203478f, -0.07349650f, 0.05985865f, 0.03019170f, 0.16296916f, 
    -0.02256347f, 0.07609134f, 0.04545467f, 0.12352718f, 0.00138288f, 0.09141818f, -0.15661162f, -0.01226613f, 
    0.01451660f, -0.11917199f, 0.10623591f, -0.08203484f, -0.10620752f, 0.28755954f, 0.06246270f, 0.15110990f, 
    0.01466067f, 0.04479507f, 0.00067123f, 0.02243275f, 0.00225718f, -0.07868810f, -0.08027770f, -0.03913936f, 
    -0.05305055f, -0.02607075f, 0.04922009f, 0.01747137f, 0.03795503f, 0.05166790f, -0.02131592f, -0.06976449f, 
    0.02113002f, -0.04485372f, -0.01703640f, -0.01595055f, -0.04485293f, 0.05959546f, 0.03527899f, -0.04302650f, 
    0.03005760f, -0.05994974f, 0.04733702f, 0.04804044f, -0.08242960f, 0.05878728f, -0.06203537f, -0.00161742f, 
    -0.03718082f, -0.02368040f, -0.06930254f, 0.01655894f, -0.07225704f, -0.05931215f, 0.05894196f, -0.07531323f, 
    -0.03846488f, -0.03028164f, -0.02691264f, 0.02050510f, -0.02791744f, -0.00315201f, -0.04353362f, -0.04142718f, 
    0.01960160f, 0.02289494f, 0.04500971f, 0.04108106f, 0.04979381f, 0.05522421f, 0.03591159f, -0.03607253f, 
    0.01709357f, 0.02773153f, 0.04441010f, -0.05749232f, -0.00572610f, -0.00451782f, -0.01076919f, 0.03500579f, 
    -0.03033303f, -0.03537008f, -0.06902353f, 0.02016192f, 0.02217146f, -0.04851176f, 0.05424114f, -0.01470373f, 
    0.00476139f, 0.02584336f, -0.03284985f, 0.03514903f, 0.05485736f, -0.04492897f, -0.07552948f, 0.00913275f, 
    -0.03088853f, 0.00880577f, -0.02511491f, 0.04935003f, 0.00731805f, -0.02230155f, 0.03121402f, -0.05159298f, 
    -0.02900746f, 0.00751899f, 0.01004262f, 0.02474535f, -0.05633038f, 0.00557711f, -0.07324038f, -0.07172895f, 
    -0.00316200f, 0.04101916f, -0.05294304f, -0.07680523f, -0.04218829f, -0.02793309f, -0.06317279f, -0.02831159f, 
    0.01966562f, 0.05399049f, 0.04083080f, 0.03168850f, 0.03814216f, 0.03935872f, -0.04063906f, 0.03922513f, 
    -0.06695794f, 0.03200444f, -0.00780023f, -0.02695820f, -0.00300328f, -0.01983712f, 0.04218086f, 0.00968665f, 
    -0.04932083f, -0.03648332f, -0.00723671f, 0.02755488f, 0.00308129f, -0.02116550f, 0.03695670f, -0.00699976f, 
    0.06059386f, -0.06685081f, -0.04085667f, 0.02146484f, 0.01209651f, 0.03841030f, 0.02640343f, -0.05000636f, 
    -0.01709549f, -0.03572956f, -0.02041695f, -0.06208352f, -0.04527849f, 0.04790484f, -0.07028535f, -0.02805247f, 
    -0.06330780f, 0.03250048f, -0.02860011f, -0.03456773f, -0.04866715f, -0.04503109f, 0.00237515f, -0.06008435f, 
    -0.02034506f, 0.05225624f, 0.04891948f, -0.05735558f, -0.02429712f, -0.05969840f, 0.04775927f, -0.01701956f, 
    -0.04827141f, -0.01224831f, 0.04209968f, 0.00531392f, 0.01686666f, -0.07392235f, 0.05857638f, -0.01967932f, 
    -0.08276316f, -0.04396854f, -0.06573346f, -0.03065242f, -0.07179508f, -0.03894860f, 0.01526407f, -0.01594839f, 
    -0.07023027f, 0.00373068f, 0.00695054f, 0.03361938f, -0.01147480f, -0.07383297f, -0.05129554f, -0.08163714f, 
    -0.02035440f, -0.07013499f, 0.02172196f, 0.04115373f, 0.04503444f, -0.01574396f, -0.02919997f, 0.00374668f, 
    -0.13724777f, -0.27277231f, -0.04886078f, 0.13879204f, 0.20107627f, 0.25738296f, 0.09334526f, -0.12738933f, 
    0.17456968f, 0.03163470f, -0.00853365f, 0.00338301f, -0.11268529f, 0.30424619f, 0.22270580f, 0.36494043f, 
    -0.00205425f, 0.07695445f, 0.02935316f, 0.12788290f, -0.06283963f, -0.18248373f, 0.05463572f, -0.00439245f, 
    -0.11796573f, 0.09890176f, 0.11574017f, 0.35419521f, -0.13907456f, 0.15497966f, 0.15430602f, -0.03717386f, 
    0.11019344f, -0.03159260f, 0.11412013f, 0.08052923f, -0.02396152f, 0.19059341f, 0.35934672f, -0.24712668f, 
    0.06948160f, 0.20189160f, -0.03920160f, -0.07618012f, 0.20356302f, 0.00432065f, 0.15028559f, 0.07616019f, 
    -0.52520764f, 0.17167592f, -0.17752868f, -0.19430825f, 0.22412185f, -0.01013887f, 0.08645655f, 0.07615487f, 
    0.08977646f, -0.02013683f, 0.06792933f, -0.13941029f, -0.07698239f, 0.03276274f, -0.00780144f, 0.10441908f, 
    0.09974578f, -0.03540525f, 0.06176404f, 0.13495043f, 0.06192658f, 0.05749942f, 0.08212604f, 0.12566607f, 
    0.06362636f, 0.24119209f, 0.20920770f, -0.31477723f, 0.22699599f, 0.07423363f, 0.01122892f, 0.04520225f, 
    0.10815341f, -0.04784809f, 0.00011242f, 0.12320571f, 0.09302037f, -0.10705823f, -0.13950033f, -0.18029386f, 
    0.11022251f, 0.02180196f, 0.11518876f, 0.00191141f, 0.01489188f, 0.07092319f, -0.01605582f, -0.03350006f, 
    0.30551416f, 0.21050368f, 0.23837249f, -0.11995869f, -0.08020145f, -0.02790011f, 0.00944038f, -0.07055564f, 
    0.10142838f, 0.07155576f, 0.04432894f, 0.27186373f, 0.09035684f, -0.09072132f, 0.25405923f, 0.15002403f, 
    0.01199590f, 0.21473892f, 0.27739030f, 0.10182120f, 0.05242182f, 0.09794313f, 0.20236197f, 0.27982596f, 
    -0.25225618f, 0.05555045f, -0.29787770f, 0.21490356f, 0.02157563f, 0.04194880f, 0.05183928f, 0.02813155f, 
    -0.01820083f, 0.03174690f, 0.02448876f, 0.00415372f, 0.29164916f, -0.02194016f, 0.09929621f, 0.08505579f, 
    0.03619905f, -0.02204147f, 0.00596385f, 0.13706699f, 0.02647567f, 0.07678039f, 0.12764384f, 0.10569347f, 
    -0.17722456f, -0.11085359f, -0.11721912f, 0.11394099f, 0.18737046f, -0.17167379f, 0.10129900f, 0.16114001f, 
    0.06410106f, 0.10656404f, 0.07876571f, 0.03332396f, -0.43738863f, -0.11578916f, -0.01169374f, 0.09174432f, 
    0.12293769f, 0.05496560f, 0.14287715f, 0.07790800f, 0.04149774f, 0.02251402f, 0.02339346f, 0.12699610f, 
    0.26801872f, -0.27975109f, 0.01406330f, 0.10169883f, 0.16095427f, 0.22075339f, 0.05914584f, 0.01096174f, 
    0.20633768f, -0.03968603f, 0.05199330f, -0.06575357f, -0.02748870f, -0.03042470f, 0.02286036f, -0.07465384f, 
    0.12225398f, 0.12249584f, 0.10577099f, 0.05387989f, 0.17373572f, -0.07882013f, -0.07690824f, 0.06241945f, 
    0.24506421f, -0.28185546f, 0.10542021f, 0.25195873f, 0.20231631f, 0.20318685f, 0.21945493f, 0.12742351f, 
    -0.00159532f, 0.16613331f, 0.16085933f, -0.00084328f, -0.48600724f, -0.34383070f, 0.19586736f, 0.21508619f, 
    -0.02724698f, 0.12023944f, 0.12957855f, 0.04114883f, -0.27930516f, 0.06478710f, 0.15048161f, -0.06108236f, 
    -0.15496056f, -0.18646790f, -0.00779100f, 0.03521022f, 0.02861650f, 0.19392738f, 0.00938437f, 0.04919374f, 
    -0.04479176f, -0.01264292f, 0.11613971f, 0.02952963f, -0.01470623f, -0.19128160f, 0.39778608f, 0.11962632f, 
    -0.07317205f, -0.00280715f, 0.14791016f, 0.10225796f, -0.01159141f, -0.17387933f, 0.00739475f, 0.06281544f, 
    -0.16193424f, 0.11740100f, -0.08802568f, 0.07372835f, 0.02765178f, -0.05716317f, 0.01280951f, 0.18970206f, 
    -0.02278574f, 0.16518733f, 0.02810919f, 0.13014066f, -0.08955737f, -0.10857601f, 0.01846663f, 0.25473714f, 
    -0.07964320f, 0.25319713f, -0.02437869f, -0.04528470f, -0.05884873f, 0.02474004f, 0.04089367f, 0.13805126f, 
    0.24875039f, 0.32413265f, 0.08397609f, 0.10824515f, 0.02979774f, 0.15929712f, 0.04862313f, -0.00570957f, 
    0.08771088f, 0.16320620f, 0.02994777f, 0.03546206f, 0.01305519f, 0.14305317f, -0.02690043f, -0.04466877f, 
    0.24118678f, -0.07691877f, 0.12051591f, 0.02446194f, 0.06852961f, 0.14070466f, 0.13412094f, 0.08488811f, 
    -0.11393133f, 0.34166622f, 0.48339000f, 0.13851643f, 0.01397359f, 0.16031608f, 0.06106539f, 0.03342216f, 
    -0.06930362f, -0.04856426f, 0.04563735f, 0.03600019f, -0.26439446f, -0.02077835f, 0.13959685f, -0.28239697f, 
    -0.09989472f, 0.12890886f, 0.06506196f, -0.01984729f, -0.03595801f, 0.01043312f, 0.00768089f, 0.01419152f, 
    0.11831682f, -0.12995368f, -0.14909190f, 0.06809577f, 0.21323748f, 0.04289815f, 0.19793005f, 0.26525310f, 
    -0.19449359f, 0.06593323f, 0.02665644f, 0.14414513f, 0.23225535f, -0.35505199f, 0.26511475f, -0.00671472f, 
    -0.10927989f, 0.01124418f, -0.01692263f, 0.03146835f, -0.03405640f, -0.01898573f, 0.06639250f, 0.07026504f, 
    0.16050263f, -0.21973599f, -0.01501878f, 0.16151270f, 0.09094592f, 0.06573766f, 0.13224810f, 0.15980752f, 
    0.09475599f, 0.10421959f, -0.07976054f, -0.01946295f, 0.10708083f, 0.09711485f, -0.16235881f, -0.06180555f, 
    -0.07164106f, 0.04591331f, 0.16391870f, 0.00837894f, -0.04169433f, 0.08632830f, -0.02616228f, -0.01001030f, 
    0.17055196f, -0.00804796f, 0.17831601f, 0.16981907f, 0.09167790f, -0.05378868f, 0.22760005f, 0.06054106f, 
    0.09631272f, 0.22498111f, 0.01686914f, 0.10858744f, 0.10165692f, -0.12136307f, 0.05836642f, 0.08379677f, 
    0.01051888f, -0.09753356f, 0.00797124f, 0.01365867f, 0.03170673f, 0.01626967f, 0.09058385f, 0.11371227f, 
    -0.00222844f, -0.07123379f, 0.03026397f, -0.04039701f, -0.03898440f, 0.02918388f, 0.04497909f, -0.02404342f, 
    -0.08005971f, 0.01965360f, -0.02323041f, 0.00937825f, -0.02881123f, 0.03016491f, -0.04184362f, 0.00928385f, 
    -0.01154781f, -0.00042247f, 0.01643860f, 0.02664073f, 0.03169036f, 0.05302140f, 0.06470771f, 0.02535289f, 
    -0.04199550f, -0.02478855f, -0.07439183f, 0.06169602f, -0.06058730f, 0.01400775f, -0.04719683f, -0.05882709f, 
    -0.02357180f, -0.05739271f, -0.04709000f, 0.04306621f, -0.03498694f, 0.05029128f, 0.03656548f, 0.03422564f, 
    -0.01317729f, -0.03960987f, -0.03609898f, -0.05561644f, 0.04032516f, -0.05320257f, 0.06213981f, 0.04804565f, 
    -0.03349284f, -0.01879626f, -0.02408030f, -0.04013992f, -0.03540910f, -0.02363842f, 0.05091359f, -0.03627757f, 
    -0.02245780f, 0.02944813f, 0.00401169f, -0.05181948f, -0.01302138f, -0.07900742f, 0.06674622f, -0.02275555f, 
    0.03553276f, -0.02482296f, -0.02775581f, 0.02486551f, 0.02397958f, -0.01524922f, 0.05302038f, -0.03424877f, 
    -0.04380337f, 0.02737300f, -0.03787095f, 0.02096672f, -0.00750955f, -0.03817610f, 0.01082112f, -0.00856349f, 
    -0.07133529f, 0.03753068f, -0.01831711f, -0.05441317f, 0.00495372f, -0.04666820f, -0.01284969f, -0.06935912f, 
    -0.00510702f, 0.03326602f, -0.05655653f, -0.04512529f, 0.06211647f, -0.01992372f, -0.08149800f, -0.07113666f, 
    -0.06707940f, 0.04880200f, -0.03255482f, 0.05280720f, -0.03727828f, -0.06106528f, -0.02323543f, 0.02379402f, 
    -0.07318451f, -0.01135083f, 0.03777466f, -0.04708936f, -0.01557490f, -0.02277672f, -0.03161024f, 0.00517135f, 
    0.04128549f, 0.01533199f, -0.05063465f, -0.01116223f, 0.02617455f, -0.05946332f, 0.05098335f, -0.01615930f, 
    -0.06404939f, 0.03765881f, 0.04051345f, 0.00050817f, 0.03121514f, 0.05388721f, 0.00818174f, -0.04928484f, 
    -0.03108727f, -0.06033786f, 0.05470888f, 0.01512763f, -0.07870222f, 0.01693469f, 0.05177657f, -0.02097940f, 
    0.04605322f, -0.04700827f, -0.07032433f, 0.02196916f, 0.03211604f, -0.00915361f, 0.02296288f, -0.07270279f, 
    -0.06667938f, 0.06750566f, 0.01372596f, -0.02226712f, -0.07095084f, -0.05120372f, -0.03261601f, -0.06605220f, 
    -0.03872333f, -0.00950826f, -0.03502002f, 0.05134008f, 0.05460218f, -0.02134923f, 0.03120393f, 0.05111321f, 
    0.00526252f, 0.02785267f, 0.00490981f, -0.03938813f, -0.01503259f, -0.08027118f, 0.04700863f, -0.02907221f, 
    0.01190462f, -0.05182337f, 0.01358641f, 0.02127424f, -0.07072629f, 0.05163631f, -0.00475727f, 0.01485005f, 
    -0.05145885f, 0.06244407f, -0.05460203f, 0.01651881f, 0.05608747f, -0.07212885f, 0.01090087f, 0.00869455f, 
    0.02519888f, 0.03838456f, -0.00361088f, -0.08756434f, -0.03003528f, 0.05451531f, 0.05724390f, 0.02695899f, 
    -0.17554493f, -0.06245978f, -0.01060841f, -0.23659268f, -0.10236511f, -0.06927986f, -0.02574735f, 0.13501577f, 
    0.08931179f, -0.14620203f, -0.10354305f, 0.14508434f, 0.32192254f, 0.21068922f, -0.12541251f, -0.11778300f, 
    0.06453761f, -0.01289051f, 0.04944070f, 0.18908167f, -0.02557275f, 0.01533411f, 0.03516938f, 0.12712789f, 
    -0.08354613f, -0.02672392f, -0.01153630f, -0.40273613f, 0.09327113f, 0.08436777f, -0.04232283f, 0.16668513f, 
    0.05055567f, 0.05892152f, 0.05511737f, 0.10770133f, 0.22866601f, -0.03813740f, -0.02029977f, 0.02183625f, 
    0.07543056f, -0.13191722f, 0.00462267f, 0.10474207f, 0.04637076f, -0.02857781f, -0.02259662f, 0.12937514f, 
    0.65485942f, -0.09954397f, -0.07833151f, 0.12682669f, 0.09011281f, 0.05970170f, -0.07277937f, 0.10522126f, 
    0.02497608f, 0.16171090f, 0.07647269f, 0.02400288f, -0.25170803f, 0.12744574f, 0.23862782f, 0.41370535f, 
    0.03167557f, 0.13868532f, 0.01160001f, -0.03011589f, 0.17104851f, 0.05323080f, -0.02406958f, 0.04423114f, 
    0.07973701f, -0.00062670f, -0.04332961f, 0.40127867f, -0.15503867f, 0.06528219f, -0.01158657f, 0.09404667f, 
    0.08344825f, 0.12760350f, 0.08868062f, -0.07390825f, 0.29106331f, 0.15271567f, -0.11068767f, -0.16564891f, 
    -0.00699845f, -0.04828431f, -0.01894824f, 0.09458768f, 0.11875839f, -0.06915819f, -0.04170905f, 0.01130483f, 
    0.15589049f, -0.17172241f, -0.09523989f, 0.48107013f, 0.09710633f, 0.03262039f, -0.00875973f, 0.12688899f, 
    0.09346163f, 0.01360562f, -0.01092832f, -0.05594912f, 0.21699099f, 0.14648303f, 0.04311668f, -0.20901564f, 
    -0.01752173f, -0.06667814f, 0.07841634f, -0.05983496f, 0.12553319f, 0.04862385f, 0.01095499f, -0.04110883f, 
    -0.20550397f, -0.03577156f, -0.01960784f, -0.24782349f, -0.10943511f, -0.02230862f, -0.07425084f, 0.24758136f, 
    0.13806203f, 0.01602300f, 0.21546216f, 0.05248515f, -0.01941365f, 0.02095195f, 0.12868156f, 0.15955135f, 
    0.00002064f, 0.04192704f, 0.05435425f, 0.12367734f, -0.02393296f, 0.13172770f, -0.03074408f, 0.07214607f, 
    0.06090186f, 0.01538779f, -0.06140297f, -0.06125956f, 0.07307161f, 0.11328565f, -0.03506937f, -0.03889246f, 
    -0.13464704f, -0.06522368f, 0.07529515f, 0.05363594f, 0.02352501f, 0.12471809f, 0.14076175f, 0.13496357f, 
    0.01353223f, -0.05782702f, 0.08353305f, 0.00089869f, 0.13682431f, 0.10229617f, -0.02983251f, -0.00330941f, 
    -0.11707613f, -0.15487352f, 0.01904832f, -0.38746864f, -0.11016767f, 0.03681934f, -0.10236980f, 0.01176263f, 
    0.01378606f, 0.09275595f, -0.04330779f, 0.04579723f, 0.02415037f, 0.20701388f, 0.00996604f, -0.13883083f, 
    0.10803699f, 0.07529879f, 0.02045988f, 0.08982489f, -0.08157716f, -0.08922569f, -0.01111955f, -0.03936045f, 
    -0.23107252f, 0.02378836f, -0.15664275f, -0.05461562f, 0.05921736f, 0.05263621f, 0.00797410f, -0.02736698f, 
    0.23916970f, 0.05212908f, 0.04992639f, 0.18559490f, 0.30997804f, 0.56953520f, -0.11151777f, 0.00655932f, 
    -0.01790758f, 0.07249034f, -0.02613495f, 0.06117595f, -0.04601396f, -0.07165361f, 0.02619041f, 0.07060649f, 
    0.10897228f, 0.17997696f, -0.04780176f, 0.15305911f, -0.17505880f, 0.09605303f, 0.03182425f, -0.05337014f, 
    -0.00447783f, 0.01825715f, -0.01536273f, 0.00653495f, 0.10053659f, 0.63176364f, 0.02861330f, -0.10382405f, 
    0.10362818f, 0.17696951f, 0.02873712f, -0.01665121f, 0.09460806f, 0.05801369f, 0.09074657f, -0.03810812f, 
    -0.03063188f, -0.21180147f, -0.00026723f, -0.18245752f, 0.13029301f, 0.00368685f, 0.14938636f, 0.00743243f, 
    0.08830421f, -0.02388044f, 0.00644919f, 0.05673567f, 0.06454735f, -0.04747301f, -0.02673975f, -0.07638812f, 
    0.10039140f, -0.11364567f, -0.01404843f, 0.01387750f, 0.07284331f, -0.06606828f, 0.06212188f, -0.03014272f, 
    -0.12817119f, 0.08855289f, 0.30859113f, -0.25286597f, 0.07329171f, -0.03245240f, -0.14722154f, 0.03248039f, 
    -0.04900417f, -0.09160738f, -0.04883745f, 0.01532871f, 0.04788832f, -0.17710951f, -0.07026325f, -0.07457165f, 
    -0.04669895f, 0.02907237f, 0.06725701f, -0.03240371f, -0.02118103f, 0.02686814f, -0.07088166f, 0.00794238f, 
    0.35896638f, 0.16672260f, 0.12649405f, -0.12094772f, -0.09417310f, 0.04206900f, -0.08554644f, -0.13505483f, 
    0.07105820f, 0.05906134f, 0.02676323f, 0.05411252f, 0.10138836f, -0.02553792f, 0.08922084f, 0.29578826f, 
    0.13775471f, 0.04860894f, 0.16084285f, -0.01649288f, 0.03551503f, -0.05051307f, 0.11481766f, 0.02133063f, 
    -0.25130543f, 0.09430147f, -0.22719038f, 0.03051810f, -0.15934664f, -0.08982068f, 0.11546669f, -0.13180321f, 
    0.03879757f, -0.02915847f, -0.04452214f, -0.01871191f, 0.09735669f, 0.22008094f, -0.07698224f, -0.13419354f, 
    0.12490910f, -0.02441411f, -0.09998897f, 0.13571520f, -0.05127141f, -0.07007715f, -0.03659781f, -0.04094581f, 
    -0.10288136f, 0.13390398f, -0.15914711f, -0.07536062f, 0.04321881f, 0.01375248f, 0.05143644f, 0.07959136f, 
    0.03017575f, -0.02984591f, -0.13116923f, -0.14246915f, -0.26814726f, -0.26943228f, 0.10998201f, 0.06084631f, 
    0.00772735f, 0.16449529f, -0.04874463f, -0.06323957f, 0.00699973f, -0.04184488f, 0.16792908f, 0.08931153f, 
    0.08755197f, -0.14022148f, -0.10810298f, 0.18407385f, -0.12400973f, -0.02108242f, -0.09456196f, -0.09826873f, 
    -0.03714701f, 0.04253136f, 0.01964077f, 0.01170497f, -0.18982832f, -0.00979000f, -0.10017172f, 0.11437381f, 
    0.05794362f, -0.05615407f, 0.02134062f, 0.06772123f, 0.00049019f, 0.09222817f, -0.00213243f, -0.02430851f, 
    0.00636696f, 0.15282668f, -0.06668732f, 0.11586501f, -0.06693269f, 0.15329520f, 0.09859712f, 0.10988589f, 
    0.01214858f, 0.18799411f, 0.21540494f, 0.12251304f, -0.20835762f, -0.09998719f, 0.13016371f, 0.07485599f, 
    0.11336483f, 0.19786200f, 0.07922891f, -0.03157445f, 0.10229278f, -0.00964658f, -0.11581105f, -0.00724303f, 
    0.28949970f, -0.08670454f, 0.09002930f, 0.27678320f, 0.06028253f, -0.07468484f, 0.07392244f, -0.01283832f, 
    0.02580556f, 0.07662880f, -0.06732702f, 0.01814019f, -0.26553312f, 0.16174819f, -0.18889615f, 0.01880486f, 
    0.10771099f, 0.07900899f, 0.09583836f, -0.13515362f, -0.04572030f, 0.13756077f, 0.06096817f, -0.04159500f, 
    -0.42086324f, 0.05931057f, 0.22641203f, 0.07216092f, 0.00254566f, 0.00260400f, 0.10999855f, 0.05927877f, 
    0.09882500f, -0.01019027f, -0.08801101f, 0.04270336f, 0.56218940f, -0.00815489f, -0.16269577f, -0.34528273f, 
    0.01645408f, 0.02911125f, 0.12765022f, 0.07664838f, 0.07020647f, 0.06520507f, 0.06312020f, -0.02420497f, 
    -0.25674933f, -0.18359342f, 0.02563221f, -0.24295081f, 0.17908436f, -0.04742080f, -0.07196350f, -0.14966932f, 
    -0.02258073f, -0.12663572f, 0.08960156f, 0.09297240f, -0.32706043f, -0.20526193f, 0.21187237f, 0.14715408f, 
    0.00028521f, 0.04955723f, 0.03917360f, 0.05615826f, -0.11321879f, 0.15624718f, 0.09192006f, 0.02426752f, 
    -0.30095521f, 0.05962060f, -0.08387523f, -0.33783376f, 0.02756568f, -0.02087197f, 0.05896045f, -0.02172801f, 
    -0.11862789f, 0.13020727f, -0.01632624f, -0.07198053f, 0.08808376f, 0.14778899f, -0.17048016f, 0.18080120f, 
    0.27640209f, 0.01052719f, -0.02034352f, 0.09911996f, 0.04032631f, -0.06655922f, -0.09233797f, 0.08365351f, 
    0.27855256f, -0.07241549f, 0.06918210f, 0.10389114f, 0.05680535f, 0.04808352f, -0.02467480f, -0.21626931f, 
    -0.08391332f, 0.05904169f, 0.04124860f, 0.16528210f, -0.05103762f, 0.30449745f, 0.00549041f, 0.00426416f, 
    -0.03101241f, -0.04588266f, 0.05564189f, -0.04315717f, 0.13131018f, -0.03693194f, -0.03972346f, -0.00004468f, 
    -0.04727403f, 0.11091364f, 0.09121484f, -0.08287303f, -0.05635449f, -0.10653906f, -0.08941221f, -0.13209020f, 
    0.06082089f, -0.01936147f, -0.11625648f, -0.04920163f, 0.79892188f, -0.03037348f, -0.05150392f, -0.08395834f, 
    0.03531271f, 0.04308037f, -0.08878282f, 0.15238033f, -0.00295467f, 0.03430445f, 0.14071053f, 0.05762244f, 
    0.04524707f, 0.18769196f, -0.00467519f, 0.24831048f, -0.00993266f, -0.01979461f, 0.05214716f, 0.06941409f, 
    -0.02686555f, -0.03516272f, 0.07023193f, -0.01930607f, 0.05280843f, -0.13562906f, 0.00759373f, 0.22320312f, 
    -0.01227265f, -0.02601798f, 0.00951659f, 0.23450744f, -0.04193152f, 0.26234666f, 0.05087256f, 0.10144217f, 
    -0.01604325f, -0.04473292f, -0.00753083f, 0.13288470f, 0.02317279f, 0.01990902f, 0.03463427f, 0.08879459f, 
    0.07147321f, 0.13476792f, 0.06998049f, -0.03222636f, -0.22524212f, 0.10798188f, 0.21385716f, 0.01432158f, 
    0.13573755f, 0.28512719f, 0.18369058f, -0.31208798f, -0.03250656f, -0.06082423f, -0.12952474f, 0.11628484f, 
    -0.10055731f, -0.10122326f, 0.14197524f, -0.06355184f, 0.13045469f, 0.03575324f, 0.04602407f, -0.02058212f, 
    -0.00218310f, 0.01300004f, 0.07605684f, -0.03036828f, -0.03345666f, 0.36897051f, 0.12955754f, 0.23257011f, 
    0.26972356f, 0.11605375f, 0.17249642f, -0.11592396f, -0.12315293f, 0.07155161f, 0.03032614f, 0.04602108f, 
    -0.04833132f, -0.02370432f, 0.17975202f, 0.06231988f, -0.05149279f, 0.04953106f, -0.20837575f, 0.16681564f, 
    -0.03136155f, 0.03421138f, -0.10318271f, 0.10931303f, 0.25037214f, 0.18814008f, -0.14893574f, -0.26804388f, 
    0.03334735f, -0.02951367f, 0.07603968f, 0.03067185f, 0.06319977f, 0.10574905f, 0.06084140f, 0.10734318f, 
    -0.07401463f, -0.05006960f, 0.00445615f, -0.10675909f, 0.17223428f, 0.05959601f, -0.13728802f, -0.15021382f, 
    -0.15164247f, 0.10497119f, 0.02136160f, 0.08485062f, -0.13664992f, -0.56033844f, 0.09424827f, 0.19656894f, 
    0.09471783f, 0.09121260f, 0.05630887f, 0.10456760f, 0.01077100f, 0.17520665f, 0.08639093f, 0.05034856f, 
    -0.71608639f, 0.28411710f, -0.23293714f, -0.53688872f, 0.09525422f, 0.05422843f, -0.11321245f, -0.12134915f, 
    -0.04587718f, 0.19703598f, 0.08585215f, -0.08450888f, -0.23789695f, 0.22254054f, -0.11704617f, -0.21032281f, 
    0.05730272f, -0.08642630f, -0.11033069f, 0.12277967f, -0.05084839f, 0.00043244f, -0.06406955f, 0.01570430f, 
    0.12887233f, -0.24022928f, -0.06175521f, 0.05652162f, 0.09468129f, 0.08955723f, 0.04777670f, -0.17705087f, 
    -0.12193477f, 0.00209024f, 0.03023677f, 0.11504751f, -0.17537324f, 0.11660495f, -0.24292137f, -0.20972812f, 
    -0.16838877f, 0.05798068f, 0.00808875f, -0.00708004f, -0.02451334f, 0.07044765f, -0.01923745f, -0.01438915f, 
    0.03503123f, -0.04857224f, 0.15736464f, -0.17095277f, -0.09749773f, 0.10479310f, -0.00028731f, -0.08090468f, 
    0.04649346f, 0.07053252f, 0.01238482f, -0.01064098f, 0.89405024f, 0.10194759f, -0.10789558f, 0.00082275f, 
    0.11371926f, -0.05969043f, -0.05593970f, -0.12269838f, -0.10933334f, 0.04788545f, 0.12549262f, 0.00594992f, 
    -0.26297086f, 0.11411960f, 0.29133889f, 0.17729548f, 0.18030411f, -0.10129790f, 0.16409722f, 0.03390689f, 
    -0.03273146f, -0.11844278f, 0.08638197f, 0.03551376f, 0.36597314f, -0.05905747f, 0.08554745f, 0.21422285f, 
    -0.10163172f, -0.14452623f, 0.02069860f, 0.18492709f, 0.17570616f, 0.17019129f, 0.08982199f, 0.06479848f, 
    0.14830852f, -0.28402048f, 0.04672758f, 0.03956506f, 0.13752195f, 0.10621568f, 0.19194490f, 0.11952034f, 
    -0.10344611f, 0.08308783f, 0.15887488f, 0.04565794f, -0.29204613f, -0.22272334f, 0.17277540f, 0.11962571f, 
    0.04212347f, 0.13229340f, -0.07263088f, -0.07216322f, -0.03640538f, -0.05394066f, 0.01599250f, 0.07135590f, 
    0.12310854f, -0.06075946f, 0.16495420f, -0.01851428f, -0.09888466f, -0.06173303f, 0.00093310f, -0.02014313f, 
    -0.06214375f, 0.01651960f, -0.04677191f, -0.00773440f, -0.27014339f, -0.20872086f, 0.10113010f, -0.01252362f, 
    -0.12877411f, 0.02964573f, -0.00038909f, 0.02613061f, -0.01464274f, 0.08179086f, 0.05980935f, -0.17097959f, 
    -0.75690854f, 0.23263802f, -0.00031627f, -0.11692397f, 0.05030952f, 0.00957406f, -0.01773012f, -0.04405527f, 
    0.03825229f, 0.02358472f, 0.01255650f, -0.05860038f, 0.14134456f, -0.05318961f, 0.07814511f, -0.01250634f, 
    0.02544761f, 0.03413236f, 0.10177292f, 0.01777480f, -0.13772638f, 0.01576110f, 0.01488272f, 0.05668518f, 
    0.13653290f, 0.15965137f, 0.03095311f, 0.02659842f, 0.08176763f, 0.11004459f, 0.03117767f, -0.05602782f, 
    0.07401519f, -0.02996571f, -0.00262096f, 0.13489476f, -0.33478826f, -0.03495670f, 0.05934973f, -0.11883027f, 
    0.19236168f, -0.08029919f, 0.04138433f, -0.08221736f, 0.05121940f, 0.17598836f, 0.04881975f, 0.00405415f, 
    -0.07810798f, 0.26308081f, 0.13139954f, -0.09774831f, -0.14906509f, 0.14682209f, 0.09993150f, 0.09917623f, 
    -0.06436021f, -0.01449507f, 0.03596446f, 0.06625823f, -0.01629435f, 0.06938319f, 0.06975204f, -0.15439755f, 
    -0.07981289f, 0.10598736f, -0.12000605f, -0.02586938f, -0.05191910f, 0.08823416f, 0.08326270f, 0.09270517f, 
    0.19760554f, -0.13932829f, 0.07479198f, 0.14380047f, 0.21743584f, 0.12615456f, 0.03169048f, 0.11598402f, 
    -0.05241010f, -0.05666087f, -0.10137393f, 0.14822489f, -0.15466225f, 0.05179249f, 0.14143586f, 0.08853713f, 
    -0.16778322f, -0.03234985f, 0.08225781f, -0.04142407f, 0.05569905f, 0.01865177f, 0.03889668f, 0.10605437f, 
    -0.27858463f, -0.16617408f, 0.04568107f, 0.16724741f, 0.05017783f, -0.03536981f, 0.13706106f, 0.04132598f, 
    0.16989206f, 0.14590997f, -0.03218522f, 0.04010991f, 0.26306331f, 0.09009355f, 0.01768179f, 0.00536388f, 
    0.03834352f, -0.14264397f, 0.07821892f, 0.00045246f, -0.00584561f, 0.05342906f, 0.07139236f, -0.06022776f, 
    0.09459949f, 0.05855605f, 0.04438264f, 0.08597109f, 0.08461653f, -0.01612985f, 0.13632040f, -0.07499100f, 
    0.12772791f, 0.03107797f, 0.08014423f, 0.06377643f, 0.02995988f, -0.25707158f, -0.00411018f, 0.02459357f, 
    0.07362708f, -0.08138786f, -0.00007009f, -0.04166349f, -0.00649844f, 0.17295098f, 0.04785502f, 0.06547616f, 
    -0.06235036f, 0.06143656f, 0.15935612f, -0.28156570f, -0.12601225f, -0.10683304f, 0.04608187f, 0.10120174f, 
    0.16606471f, 0.05902310f, 0.04478831f, 0.07329780f, -0.43360528f, -0.17641547f, 0.26394933f, 0.10257334f, 
    0.01753583f, -0.00547725f, 0.11384701f, 0.09978618f, 0.00135955f, -0.02894042f, -0.00814483f, 0.05902794f, 
    -0.00543803f, -0.01351593f, 0.01916721f, -0.14865077f, 0.15450180f, 0.05336457f, 0.01604980f, 0.00543690f, 
    0.01455758f, 0.19243108f, 0.03630868f, -0.01821770f, -0.02660742f, -0.15279022f, 0.07419208f, 0.04070153f, 
    -0.01229626f, 0.00980742f, 0.12612110f, 0.02687434f, 0.14941885f, -0.01946570f, -0.02025175f, 0.11574057f, 
    0.33369368f, -0.02500246f, -0.07843651f, 0.15215330f, -0.04318750f, 0.00241793f, -0.00590195f, 0.20974264f, 
    0.03374577f, 0.19005199f, -0.10942166f, 0.20178992f, -0.07400223f, 0.08928321f, 0.09231665f, 0.39176205f, 
    -0.01898738f, 0.20729887f, 0.03186460f, -0.02454568f, 0.05044551f, -0.00375566f, -0.04018205f, 0.09772803f, 
    -0.16232507f, -0.06652214f, 0.00538826f, 0.24891436f, -0.04366685f, 0.05772543f, -0.04830304f, 0.06093841f, 
    -0.03328434f, 0.05157429f, -0.03010930f, -0.01410161f, 0.32383537f, 0.02869915f, 0.02080667f, -0.03886138f, 
    0.06916864f, -0.11300384f, 0.10261969f, 0.11236165f, 0.03312618f, 0.05542059f, -0.07288784f, 0.12945043f, 
    0.03205653f, -0.07523438f, -0.01673982f, -0.04502403f, -0.08151344f, -0.02478645f, -0.16409124f, 0.07558098f, 
    0.16592227f, 0.04981108f, 0.05774005f, -0.13630396f, 0.02559217f, 0.14169210f, 0.10523877f, -0.27733561f, 
    0.04702251f, 0.16986951f, 0.14041956f, 0.02504525f, 0.06551166f, -0.07898604f, -0.02882422f, -0.05172220f, 
    -0.07547326f, 0.02267090f, -0.10298401f, -0.28238410f, -0.15872675f, 0.03413010f, -0.04651236f, 0.09180385f, 
    0.05053073f, 0.05484008f, 0.10714114f, -0.04971433f, 0.44003552f, -0.11145164f, 0.04786769f, 0.29667246f, 
    -0.01503071f, 0.04509483f, 0.10913511f, 0.03683830f, -0.03110995f, 0.13579725f, 0.05792637f, 0.04157330f, 
    0.18600908f, -0.19593577f, -0.00794546f, 0.01222780f, 0.07361940f, 0.19051231f, 0.05246128f, 0.00645780f, 
    -0.07042267f, -0.01334038f, 0.05716411f, -0.08621018f, 0.35012871f, -0.03065291f, -0.10805669f, -0.04040593f, 
    -0.02687036f, 0.15885897f, 0.25997791f, 0.16884562f, -0.02708254f, 0.04394465f, -0.07507986f, -0.00023992f, 
    0.18844083f, -0.16348641f, 0.07976114f, -0.23519106f, -0.20143460f, 0.08008473f, 0.09606221f, 0.09785676f, 
    0.00105385f, 0.20124573f, 0.06660525f, 0.05665061f, -0.21683720f, 0.27071398f, 0.05551608f, 0.00861736f, 
    -0.03482810f, 0.13416693f, 0.09417740f, 0.05187771f, -0.01533995f, -0.03073332f, 0.01949334f, -0.06827130f, 
    -0.09531675f, 0.17977434f, 0.06953727f, -0.10606738f, -0.01350624f, 0.02915566f, -0.01042814f, -0.10572163f, 
    -0.02650766f, -0.01368651f, -0.05372500f, -0.06860377f, -0.01492723f, -0.02617837f, -0.04501548f, -0.24609450f, 
    -0.01821497f, -0.04995763f, -0.11496099f, -0.00178632f, 0.15838595f, 0.06971662f, -0.05043890f, -0.03307452f, 
    0.36070514f, 0.20643544f, -0.34584793f, 0.17741330f, 0.02738469f, -0.00270602f, 0.01025059f, -0.06766837f, 
    0.15886368f, -0.07271816f, 0.11484580f, -0.00896324f, -0.01309300f, -0.01242464f, -0.32947114f, -0.01134669f, 
    0.06310489f, 0.06539329f, -0.03417455f, 0.04222795f, -0.00426080f, 0.21209118f, 0.08625360f, -0.06538986f, 
    -0.07120214f, 0.05761598f, 0.16315325f, 0.07607859f, -0.13375151f, -0.04167737f, 0.23339792f, 0.02094538f, 
    0.15001771f, -0.16549078f, 0.09058398f, -0.09880903f, 0.10397772f, -0.24973160f, -0.05017495f, -0.03971424f, 
    0.10363282f, 0.04050018f, 0.02201073f, 0.05722074f, 0.06762720f, -0.00784857f, -0.11262597f, -0.05386754f, 
    0.01019835f, -0.00860497f, -0.07261166f, 0.00264573f, 0.17142671f, -0.08655240f, 0.01724160f, 0.16973059f, 
    0.08118971f, 0.11956127f, 0.03159097f, -0.11562875f, -0.01132056f, 0.32130969f, 0.17497472f, 0.31626487f, 
    -0.13006121f, 0.02891976f, -0.04329611f, -0.00018592f, -0.02581108f, 0.10982833f, 0.02818648f, -0.09726395f, 
    0.28376758f, -0.14584808f, 0.01801023f, 0.03227768f, -0.01395295f, -0.07117497f, 0.05561492f, 0.02852451f, 
    0.18270285f, -0.04364044f, 0.08681725f, 0.06002310f, 0.08639000f, -0.29912880f, -0.11986098f, 0.24418138f, 
    0.06564552f, 0.02899054f, -0.10128158f, 0.09162638f, 0.02250052f, 0.11977383f, 0.14333248f, 0.01429376f, 
    0.08442722f, 0.02480029f, 0.13565683f, 0.09000701f, -0.07927302f, 0.10215970f, -0.05048050f, -0.08309975f, 
    0.12403054f, 0.02260806f, 0.01095049f, -0.22210556f, -0.08091263f, 0.03984545f, -0.20788699f, 0.16269697f, 
    0.06323537f, 0.14514090f, 0.03557675f, 0.16543695f, 0.16716959f, -0.06831420f, -0.10982497f, -0.06134838f, 
    0.09451175f, 0.10928072f, 0.03643188f, -0.18170141f, -0.04453199f, 0.00199110f, 0.13027881f, -0.02116944f, 
    -0.04400412f, -0.04900252f, -0.01847669f, 0.16380963f, -0.28938994f, 0.13150169f, 0.08233627f, -0.08769973f, 
    -0.03942581f, 0.13688450f, -0.14582850f, 0.24330403f, -0.04767174f, -0.03775379f, 0.05010980f, 0.01288189f, 
    0.33870459f, 0.37460449f, -0.20804651f, 0.39041018f, -0.13654740f, -0.13960403f, -0.03877841f, 0.01620255f, 
    -0.13207507f, 0.08541894f, -0.03397759f, 0.03824681f, -0.16539972f, 0.21372636f, -0.01192325f, -0.09135962f, 
    -0.06727953f, 0.06024747f, 0.04835689f, -0.15421027f, -0.05867719f, -0.03180868f, 0.06915204f, -0.09317420f, 
    -0.32103315f, -0.09799822f, -0.02710376f, -0.23359025f, -0.08522154f, -0.21514879f, 0.05627966f, 0.18791723f, 
    0.07130323f, 0.24994862f, 0.13344650f, 0.13036039f, 0.30245754f, 0.09744794f, 0.03263440f, -0.36593536f, 
    -0.11846241f, -0.07789219f, 0.01437671f, -0.00393075f, -0.04953202f, 0.03660898f, 0.06272918f, 0.07732145f, 
    0.16354935f, 0.01062544f, -0.00150251f, -0.38395593f, 0.04401685f, 0.05708342f, 0.00020924f, 0.05910418f, 
    -0.04771050f, 0.10016096f, -0.03733852f, -0.09414726f, 0.61394221f, -0.06659197f, 0.09136062f, -0.00956639f, 
    -0.04785889f, -0.09564371f, 0.15057398f, 0.08188625f, -0.02966990f, 0.08516759f, 0.04321812f, -0.05579362f, 
    0.07033627f, 0.01722834f, 0.02804374f, 0.36038986f, 0.11568309f, 0.03693365f, 0.04570291f, 0.20390868f, 
    -0.07654756f, 0.14978977f, -0.10147849f, 0.16396870f, 0.04780028f, -0.01746244f, 0.05440095f, 0.30649561f, 
    -0.12836401f, 0.25429791f, -0.23489910f, -0.06515335f, 0.02053275f, 0.08552898f, -0.02818914f, 0.07085522f, 
    0.27950442f, 0.13746031f, -0.14188184f, 0.39233211f, -0.12391833f, 0.03713653f, -0.07950744f, -0.00929441f, 
    0.08625982f, -0.05696321f, 0.05205189f, 0.05633406f, 0.28331974f, 0.10717721f, 0.10055429f, 0.12069815f, 
    0.05035381f, 0.00980350f, 0.11996549f, 0.18626983f, 0.00075371f, -0.15425538f, -0.08970125f, -0.07160676f, 
    0.31372431f, 0.16200937f, 0.00486481f, 0.36281657f, 0.04115605f, -0.01359880f, -0.12541707f, 0.08517125f, 
    0.03341452f, 0.11417831f, -0.01458341f, 0.01050924f, -0.33138400f, 0.16308233f, 0.07745429f, -0.28506759f, 
    -0.03052039f, 0.02851197f, 0.11981393f, -0.08214951f, 0.01272675f, -0.02780507f, -0.15389803f, -0.13203646f, 
    -0.28296012f, 0.04734344f, 0.04710802f, -0.08314534f, -0.11425892f, -0.08487563f, 0.01058017f, 0.08076017f, 
    0.10649012f, -0.13091369f, -0.07939412f, 0.03538272f, 0.12066127f, -0.21294509f, 0.17099884f, 0.26144814f, 
    -0.02929607f, -0.08374683f, -0.03004306f, -0.04497498f, 0.06940041f, 0.21621242f, -0.08260410f, -0.02059258f, 
    -0.11238134f, -0.32587129f, -0.01567192f, 0.00815020f, 0.08894632f, 0.12654157f, 0.01452918f, -0.02814440f, 
    -0.01781333f, 0.02326140f, -0.10154704f, -0.24791063f, 0.18599239f, 0.17362081f, 0.01053978f, 0.03236188f, 
    -0.01187857f, 0.05951209f, 0.21196988f, -0.03658225f, 0.08960436f, 0.02092951f, -0.01244145f, -0.04605522f, 
    0.29446194f, -0.03354549f, 0.14893904f, -0.32375610f, -0.10659029f, -0.01707248f, -0.03627201f, 0.10096011f, 
    -0.13537449f, 0.06280182f, 0.07060971f, 0.01865312f, -0.19897552f, 0.43851948f, 0.03364596f, -0.16292809f, 
    0.20608109f, 0.06191275f, 0.15419814f, -0.16179040f, -0.17622317f, 0.01066892f, 0.00883521f, 0.08586983f, 
    -0.07200936f, -0.07715815f, 0.01632856f, 0.05160747f, -0.04991083f, -0.08211872f, -0.01344195f, 0.15765265f, 
    0.12516177f, -0.02711016f, 0.08714800f, 0.10199557f, 0.61039191f, 0.36644718f, 0.18192598f, -0.08106075f, 
    0.08290541f, 0.03336342f, 0.08452423f, -0.02779460f, 0.01486979f, 0.00935746f, 0.06354527f, 0.05939484f, 
    -0.03164394f, -0.03737283f, 0.27205831f, -0.33390561f, -0.01608381f, -0.01382683f, 0.13557059f, 0.01098844f, 
    0.05168672f, -0.05665168f, 0.02893446f, 0.08413988f, 0.26649791f, 0.10219140f, 0.12407153f, -0.00271700f, 
    0.23915255f, 0.06693139f, -0.09709100f, 0.01805522f, 0.14170030f, -0.06413946f, 0.01225831f, -0.12312678f, 
    -0.42383420f, 0.01911842f, -0.08515320f, 0.05883174f, 0.35621363f, 0.06833378f, -0.01160963f, -0.01205006f, 
    -0.02583087f, 0.13653719f, -0.07203439f, -0.03665493f, -0.25842443f, 0.08786491f, -0.01594874f, -0.01749217f, 
    0.04725083f, 0.05198114f, -0.01914360f, 0.14334515f, -0.02595762f, 0.03791427f, -0.03739014f, 0.04994512f, 
    0.11812612f, 0.06199728f, -0.09579924f, 0.17844065f, 0.06921610f, 0.03806157f, 0.13183464f, 0.03007868f, 
    -0.01419513f, -0.01363818f, -0.07402653f, 0.14522630f, 0.14997807f, -0.25494656f, 0.01301237f, -0.11020292f, 
    -0.00305998f, 0.01538323f, -0.03276975f, 0.08986061f, 0.00589558f, -0.06591093f, -0.01631955f, 0.02634555f, 
    0.00805608f, 0.25324732f, -0.22385794f, -0.10162040f, -0.01506971f, 0.00146386f, 0.13928440f, 0.02601547f, 
    -0.06785904f, 0.08860335f, 0.03027624f, 0.01113162f, -0.12813810f, 0.22612044f, 0.01477252f, -0.05960440f, 
    -0.08576130f, -0.02894625f, 0.12092823f, 0.01939344f, 0.10785154f, 0.00407161f, 0.01557607f, 0.21360664f, 
    -0.35609666f, -0.03983552f, -0.07091858f, 0.09916817f, -0.03156695f, -0.01854807f, 0.00866095f, 0.15077989f, 
    0.07454384f, 0.02337326f, 0.12908083f, 0.02828176f, -0.36677918f, 0.06199333f, -0.00598986f, 0.03646604f, 
    -0.01011196f, -0.15150487f, 0.10195743f, -0.05184659f, 0.00133620f, 0.18247132f, 0.09606795f, 0.15346837f, 
    -0.27210355f, -0.10100650f, -0.05977099f, 0.16728626f, 0.05785075f, 0.01996036f, -0.01903874f, -0.03244703f, 
    0.06760348f, 0.01304872f, 0.08016375f, 0.05327428f, 0.29261175f, 0.12995958f, 0.08648644f, 0.14611696f, 
    0.13143051f, -0.06071322f, 0.05767212f, -0.00559854f, 0.07219867f, -0.06161914f, 0.02192108f, -0.01191644f, 
    -0.14386556f, -0.30469686f, 0.22079813f, -0.33184537f, 0.10784539f, 0.14081316f, -0.02414407f, -0.05307048f, 
    0.02008613f, -0.09856787f, 0.11497849f, -0.03438868f, -0.06017246f, 0.01982200f, 0.06132628f, -0.06167760f, 
    0.12352432f, 0.15998659f, -0.01465462f, 0.14046039f, 0.03507243f, 0.14113204f, -0.04940824f, -0.05038567f, 
    -0.06794948f, -0.04851780f, -0.03097309f, -0.01384621f, 0.06243070f, 0.08882292f, -0.02204616f, -0.07541908f, 
    -0.16855052f, -0.15519954f, -0.01211825f, -0.03527100f, 0.12027119f, -0.13668703f, -0.08367824f, -0.00272455f, 
    0.02830758f, 0.09434088f, 0.02474048f, -0.05153980f, 0.14812273f, 0.17258850f, 0.05990126f, 0.06987581f, 
    0.12516385f, 0.01496642f, -0.17116371f, -0.01943896f, 0.07763922f, -0.09649526f, 0.09393283f, 0.02509393f, 
    0.14964557f, -0.12577632f, 0.18903042f, 0.00152876f, -0.16516307f, -0.30787128f, -0.24545521f, 0.18887207f, 
    -0.01527110f, -0.04920417f, -0.15381774f, -0.07912555f, -0.12052285f, -0.01050979f, -0.02405172f, 0.14324144f, 
    0.17213060f, 0.15210991f, -0.17754620f, -0.01126540f, 0.01051277f, -0.05419600f, 0.06937614f, 0.00560615f, 
    -0.05376030f, -0.10647270f, 0.11355457f, -0.14999306f, -0.24577205f, -0.03350297f, 0.06205139f, -0.04826101f, 
    0.07545040f, 0.03855296f, 0.02533277f, 0.13297777f, 0.11810480f, 0.04192128f, -0.04408640f, -0.08997890f, 
    0.21005169f, 0.09553386f, -0.01758880f, 0.09451628f, 0.06867683f, -0.01565773f, 0.03241060f, 0.03886870f, 
    0.11959366f, 0.24418817f, 0.07906867f, -0.02847180f, -0.34193197f, 0.12128388f, 0.01643818f, 0.06401483f, 
    0.07429660f, 0.04935384f, 0.03828736f, 0.08126347f, 0.09055529f, -0.08872636f, 0.10280899f, 0.00083912f, 
    -0.18227904f, -0.37008831f, 0.15002483f, 0.37586156f, 0.17079216f, 0.01879742f, 0.12337760f, -0.05909929f, 
    0.02532065f, 0.00965821f, 0.15789507f, 0.13551165f, 0.41798767f, -0.11259466f, -0.17141560f, 0.20268409f, 
    -0.02167145f, -0.09571470f, -0.11942332f, 0.10192435f, 0.05757052f, 0.14559358f, 0.02025453f, -0.02910948f, 
    -0.03521133f, -0.08509304f, 0.18218060f, -0.04980261f, 0.25034019f, 0.03425048f, -0.02074774f, 0.07792544f, 
    -0.02520261f, -0.00018106f, -0.01030498f, -0.04870902f, -0.45193186f, 0.11171649f, 0.02342299f, 0.07669266f, 
    0.05067932f, 0.00753935f, -0.03067394f, 0.08918711f, 0.26945060f, -0.08247520f, -0.01644338f, 0.04648080f, 
    -0.07263259f, 0.27537233f, 0.01702615f, -0.17541535f, -0.06348933f, -0.01209230f, -0.14827363f, -0.03499025f, 
    -0.01609582f, 0.09832189f, 0.09134531f, 0.25851113f, 0.00250125f, 0.23066758f, 0.04573135f, -0.09825989f, 
    0.07485244f, -0.14180903f, -0.19740097f, -0.04522783f, 0.01582229f, 0.16928671f, 0.06041142f, 0.08892951f, 
    -0.60693336f, 0.13244617f, 0.14480191f, -0.06652462f, 0.18659467f, -0.00328257f, 0.01051247f, 0.00328291f, 
    0.04929115f, -0.07564449f, -0.05855661f, 0.03738523f, 0.14341141f, -0.10331590f, 0.03098906f, -0.14633296f, 
    -0.08157392f, 0.07277506f, -0.11316680f, 0.14474529f, 0.07628948f, -0.00827892f, 0.20405436f, 0.03117943f, 
    -0.04336344f, -0.16088010f, 0.03283953f, 0.10956377f, 0.17361693f, 0.08765394f, -0.03166768f, -0.08302134f, 
    0.00769064f, -0.33023176f, -0.08451469f, -0.07427529f, 0.27500707f, 0.25635827f, -0.17149025f, -0.10128145f, 
    -0.01189554f, -0.02047151f, 0.08281927f, -0.05761545f, -0.04113129f, 0.03757571f, 0.04344224f, 0.10860978f, 
    -0.26186171f, 0.15986210f, -0.05396482f, -0.17483644f, 0.03959911f, -0.00926676f, 0.02807840f, 0.10324763f, 
    -0.03126732f, -0.10266407f, 0.10244752f, 0.05011133f, 0.18124709f, 0.07220096f, 0.20220958f, 0.08004685f, 
    -0.02629605f, -0.04850877f, -0.18683641f, 0.08979046f, -0.16988249f, -0.20114550f, 0.04105295f, 0.10483620f, 
    0.26598927f, 0.03829641f, -0.10033116f, 0.01963320f, -0.06460266f, 0.00147686f, -0.17114173f, -0.05925749f, 
    -0.04748138f, -0.05301164f, 0.10550512f, -0.07333596f, -0.28040406f, 0.11883131f, 0.04839322f, 0.11832853f, 
    0.00414095f, -0.14926893f, -0.09344382f, -0.01614580f, 0.02729963f, -0.08655366f, 0.00892987f, -0.09283335f, 
    0.31212750f, 0.22087331f, 0.16046077f, 0.18604445f, -0.02637024f, 0.12221859f, 0.07109948f, 0.16600509f, 
    0.03695599f, 0.21613353f, 0.07022517f, -0.07128718f, -0.01989332f, 0.04272430f, -0.15651269f, -0.00767098f, 
    0.12535390f, -0.02459086f, -0.04165349f, 0.07178937f, 0.21632595f, -0.06879520f, -0.02674596f, 0.05342804f, 
    -0.08465625f, -0.05645338f, 0.18232487f, 0.41892597f, 0.11125614f, 0.02034281f, 0.04523272f, 0.09821613f, 
    -0.03159624f, 0.05956280f, -0.00616753f, 0.16555126f, -0.12840503f, 0.01314225f, 0.06587834f, -0.14310518f, 
    -0.10842122f, -0.14524172f, -0.03758172f, 0.01309676f, -0.01921123f, 0.12551408f, -0.04992709f, -0.00021752f, 
    -0.18717265f, -0.15457512f, 0.01003526f, 0.10100085f, 0.21085413f, 0.04771170f, 0.00169639f, 0.17063773f, 
    0.04368846f, -0.04663540f, 0.11552573f, 0.07414176f, -0.19999766f, -0.07821444f, -0.02030247f, -0.25110662f, 
    -0.09515861f, 0.06318940f, 0.05938065f, 0.04914378f, -0.06246948f, -0.07306669f, 0.03785333f, 0.12737790f, 
    0.00583330f, -0.04594728f, -0.03235911f, 0.07481401f, -0.01590798f, -0.03738999f, -0.10638807f, 0.00167094f, 
    0.08708748f, 0.05663411f, 0.17712784f, 0.32085177f, -0.50939184f, 0.18152502f, 0.19374505f, 0.21805197f, 
    -0.05750959f, -0.06670203f, -0.15152399f, -0.26794156f, 0.06898898f, 0.05067594f, -0.06479375f, -0.03995363f, 
    -0.18730076f, 0.04789177f, 0.05401748f, -0.14897823f, 0.19622272f, 0.00552841f, -0.05775968f, -0.09335465f, 
    0.07168164f, -0.10147813f, -0.03836896f, 0.05500520f, 0.44561777f, -0.10626272f, 0.00297928f, 0.01030037f, 
    0.04416365f, -0.00262933f, -0.15531754f, -0.01626183f, 0.14820136f, -0.15473604f, -0.01406240f, -0.04170822f, 
    0.02429686f, -0.03730081f, -0.00919157f, -0.01058526f, -0.01783780f, 0.02055489f, 0.02750287f, -0.01540750f, 
    0.00317362f, 0.04360202f, -0.05636459f, 0.02363398f, 0.03108561f, -0.06073312f, 0.04721193f, -0.08217568f, 
    -0.01435056f, -0.02312285f, -0.00412284f, 0.03065442f, -0.02509301f, -0.03970777f, 0.00077667f, 0.02750769f, 
    0.00741631f, 0.01627842f, 0.06153858f, 0.03374414f, -0.03709525f, 0.02510709f, -0.00180257f, 0.00460448f, 
    -0.04761877f, -0.08035493f, -0.03225856f, -0.08021314f, -0.00126734f, -0.02393996f, -0.00247676f, 0.01046219f, 
    0.03305920f, -0.02893604f, -0.06876681f, 0.02368964f, 0.02666882f, 0.01618908f, -0.05182790f, -0.06314233f, 
    -0.00212541f, -0.04838091f, -0.03568170f, 0.00248358f, -0.03006362f, -0.03972636f, 0.05210492f, 0.03377349f, 
    -0.07166640f, 0.04265212f, -0.02337200f, 0.02369473f, 0.05155983f, -0.05392792f, 0.01013136f, -0.00829689f, 
    0.02312672f, -0.01999273f, 0.03302861f, 0.00753843f, -0.02054535f, 0.01429314f, 0.02971195f, 0.00166323f, 
    0.03902545f, 0.04136585f, 0.01528519f, -0.05442370f, 0.02269628f, -0.02912925f, 0.02438316f, 0.00204806f, 
    0.00468776f, -0.05932029f, 0.05465747f, -0.02700323f, -0.00157345f, 0.03147301f, 0.01361537f, -0.03596504f, 
    0.05446929f, 0.01510412f, 0.02298091f, -0.02401005f, -0.06836874f, -0.00869654f, -0.04070452f, 0.06435918f, 
    0.01654143f, 0.03629277f, -0.00483869f, 0.04162205f, -0.06994963f, -0.05783020f, 0.05073926f, -0.01625488f, 
    -0.06990831f, 0.04637937f, -0.02096453f, 0.06058602f, -0.04311329f, 0.00308828f, -0.06204965f, 0.04569939f, 
    -0.07259332f, -0.07326878f, -0.03512089f, 0.03123564f, 0.02386911f, 0.02637469f, -0.04462082f, 0.01886099f, 
    -0.06334436f, 0.05681295f, -0.00689298f, 0.00239028f, 0.01263803f, -0.08158266f, -0.06600544f, -0.03026145f, 
    -0.00858965f, 0.00950855f, 0.01309991f, -0.03894963f, -0.03136387f, 0.03387926f, -0.06560519f, 0.01295871f, 
    -0.05613429f, -0.01177284f, 0.02662225f, -0.07700573f, -0.07329193f, 0.07454815f, 0.06253583f, -0.05614003f, 
    -0.03137834f, 0.01532027f, -0.02704167f, -0.07834546f, 0.02839969f, 0.04184456f, 0.01668536f, 0.00100826f, 
    0.04275437f, -0.01346375f, -0.03007101f, 0.04684563f, -0.05509445f, -0.02372565f, -0.00499037f, 0.06172274f, 
    -0.07054330f, 0.05121555f, -0.01693567f, -0.04685227f, -0.00921796f, -0.06213762f, 0.06209353f, -0.00023719f, 
    -0.01364012f, -0.02885327f, 0.05263042f, 0.01353880f, -0.07355348f, -0.01735545f, -0.06783662f, -0.04009087f, 
    0.02427417f, 0.04503297f, 0.01591635f, -0.00405728f, -0.05149762f, 0.02616601f, -0.00851965f, -0.05305136f, 
    0.02422987f, -0.07394258f, -0.07609780f, -0.01727627f, -0.05082990f, 0.02363882f, -0.05434356f, -0.07140222f, 
    -0.28902838f, 0.12518680f, -0.06173211f, -0.11926177f, 0.18746053f, 0.00363484f, -0.22076331f, -0.15947837f, 
    0.16780730f, -0.26393867f, -0.04773407f, -0.11162806f, -0.17823191f, 0.44720817f, 0.01988195f, -0.06473288f, 
    0.03753362f, -0.04541660f, -0.01514127f, -0.11411143f, 0.12737939f, -0.02388122f, -0.11305351f, -0.02304615f, 
    -0.09591828f, 0.26344755f, -0.18052474f, 0.13319410f, 0.12311970f, 0.02022814f, 0.04902973f, -0.12658590f, 
    0.05196606f, 0.02265451f, 0.07782550f, 0.02123009f, -0.02430243f, 0.37936595f, 0.07867622f, 0.08948708f, 
    0.23303576f, 0.07556425f, -0.02342109f, 0.07785039f, 0.02230851f, 0.03992518f, 0.04586580f, 0.11346371f, 
    0.44778383f, -0.15304559f, 0.19299178f, -0.04156345f, -0.10443790f, 0.03488356f, -0.03033156f, 0.11678707f, 
    0.10776596f, -0.06214696f, -0.00331131f, -0.00968371f, -0.04179299f, 0.01534889f, 0.04530492f, 0.08724230f, 
    0.12646057f, -0.19485185f, 0.12550020f, 0.07222468f, 0.08349854f, 0.00530127f, 0.03997033f, -0.03577287f, 
    -0.04336539f, -0.03877005f, 0.16086063f, -0.02079881f, 0.08343145f, 0.00130904f, -0.02668057f, 0.22630812f, 
    -0.08016250f, 0.13000280f, 0.12164118f, -0.05991561f, 0.18532021f, -0.07651722f, -0.10240774f, 0.21584807f, 
    0.06839573f, -0.00927483f, 0.01250109f, -0.00351112f, 0.00404047f, 0.02778190f, -0.02750402f, 0.01343097f, 
    -0.08973961f, 0.07532576f, 0.08981830f, -0.00018873f, -0.07874827f, -0.10017435f, 0.01022804f, -0.06211453f, 
    0.10561607f, 0.16137753f, -0.02121861f, -0.02427926f, -0.11861054f, 0.00414766f, 0.02272298f, -0.15022103f, 
    0.16732967f, 0.02044648f, 0.06666403f, 0.08639069f, 0.22444591f, 0.08070976f, 0.14661504f, 0.01887170f, 
    -0.13396868f, -0.24244668f, -0.18076918f, -0.05614425f, -0.00430767f, 0.11305302f, 0.10278097f, -0.15162614f, 
    0.10842354f, 0.15934813f, 0.22638106f, -0.17140566f, 0.24548653f, -0.01034703f, -0.18417855f, -0.15176244f, 
    -0.03893535f, 0.10878713f, -0.07723112f, 0.22131018f, -0.03976912f, 0.03702577f, 0.04183790f, 0.12402672f, 
    0.17377338f, -0.02652935f, 0.03344411f, -0.21349080f, -0.07950934f, 0.09739938f, 0.08682866f, -0.00315270f, 
    0.05452852f, -0.00982440f, 0.29146627f, 0.17627496f, -0.26506737f, -0.10005189f, 0.20180845f, 0.10276330f, 
    0.00908496f, 0.08611598f, 0.01697590f, 0.05086923f, 0.09021649f, -0.00071258f, 0.05200484f, 0.09487125f, 
    0.21698111f, 0.07010071f, -0.30801833f, 0.25987178f, -0.13135038f, -0.07801329f, 0.06997928f, -0.19828187f, 
    0.03056317f, -0.11351258f, -0.13370691f, -0.02544034f, 0.26265290f, 0.15322368f, -0.00110414f, 0.06900758f, 
    -0.11977863f, -0.00637259f, 0.14796163f, 0.08984936f, 0.17900677f, -0.20679405f, 0.00849037f, 0.03704187f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12665032f, 0.01090896f, -0.12702829f, 0.04266828f, 0.05649333f, -0.02607099f, 0.01624294f, 0.16461493f, 
    -0.04144831f, 0.00930701f, 0.01382944f, 0.11058784f, -0.00013789f, -0.01852461f, -0.01023794f, 0.03974312f, 
    0.16625002f, 0.10303792f, 0.01788445f, 0.06991657f, 0.01282954f, 0.10183587f, 0.01712884f, -0.03703864f, 
    0.08383241f, -0.06159561f, -0.05845379f, 0.04851312f, 0.05355949f, -0.00538277f, 0.06251231f, 0.04537825f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02672769f, -0.06440579f, 0.08446207f, 0.05027283f, -0.15266053f, -0.05655184f, -0.16310316f, -0.02341328f, 
    -0.17214140f, 0.11022426f, -0.17383592f, 0.11130743f, 0.06812636f, -0.08252130f, -0.12089502f, 0.14777102f, 
    -0.13726477f, -0.06146083f, 0.02638866f, 0.15348311f, 0.15338372f, -0.13595760f, 0.06509359f, -0.02672728f, 
    -0.13060817f, -0.05636505f, -0.16309156f, 0.07165021f, 0.02092773f, 0.03801209f, -0.07712944f, -0.04129569f, 
    0.08738390f, 0.00203324f, 0.05927422f, 0.13679768f, -0.16629684f, -0.14459178f, -0.07573523f, -0.06053081f, 
    0.06959199f, -0.10365980f, 0.05396343f, 0.16410315f, -0.13183549f, -0.08041815f, -0.03825543f, -0.10504290f, 
    -0.12964952f, -0.17458718f, -0.07072709f, -0.06083748f, 0.12458809f, -0.10819998f, 0.09464769f, -0.05493375f, 
    -0.17707922f, -0.11162069f, -0.03294775f, -0.00243691f, 0.00070895f, -0.16435735f, 0.02979096f, -0.04537602f, 
    0.07003514f, 0.05416073f, -0.12730344f, 0.41239867f, 0.09153444f, 0.15399146f, -0.04375385f, -0.44308671f, 
    -0.10323753f, -0.18336613f, 0.10226882f, -0.06538746f, -0.09854776f, 0.15597376f, 0.48945788f, -0.11284284f, 
    -0.12071310f, 0.25528133f, 0.01224285f, 0.04936960f, -0.02234818f, 0.32826895f, 0.09886640f, 0.11079945f, 
    0.40556270f, 0.05114298f, 0.05801117f, -0.24391773f, -0.31097725f, -0.29579830f, -0.17663854f, 0.11840495f, 
    0.34728169f, 0.27822256f, -0.22984906f, -0.00071533f, 0.40890670f, -0.05718694f, -0.94952661f, -0.17586184f, 
    0.54746860f, 0.20194875f, -0.13136609f, -0.40624613f, 0.04084555f, -0.12584691f, 0.24612336f, 0.00344873f, 
    -0.12894948f, -0.06889700f, -0.04906875f, 0.19688523f, 0.42935139f, 0.22079644f, 0.27420294f, -0.23659280f, 
    0.12008952f, 0.09832112f, 0.20993349f, -0.01569104f, -0.29903236f, -0.05934341f, -0.12337720f, 0.24760427f, 
    0.16865359f, -0.36432782f, -0.03740669f, -0.14246187f, 0.43462858f, -0.13131949f, 0.26595291f, 0.40071511f, 
    -0.47408396f, -0.32266757f, 0.21367179f, -0.01863950f, -0.06482322f, 0.07231753f, -0.01834936f, -0.00745035f, 
    0.22826596f, 0.03075126f, 0.00391018f, 0.36595291f, 0.19246732f, -0.38782048f, -0.29274592f, -0.15348642f, 
    0.16111188f, 0.01299836f, -0.08531061f, 0.27579951f, -0.12442821f, 0.27548060f, 0.13288994f, 0.29543006f, 
    -0.21559614f, 0.39662322f, 0.09180931f, -0.02960603f, 0.21413948f, -0.04684545f, 0.02871052f, 0.09091991f, 
    -0.26515320f, 0.34038100f, -0.11558920f, 0.27819687f, -0.16767354f, 0.09277181f, -0.06213874f, -0.14284155f, 
    0.22774418f, 0.17567174f, -0.07530557f, 0.07750543f, -0.00273977f, 0.01378652f, -0.13854621f, -0.06283949f, 
    0.17664200f, -0.13113905f, 0.16525981f, 0.33371115f, -0.19539073f, -0.21270826f, -0.03867132f, -0.31206754f, 
    -0.13200700f, -0.23101884f, 0.08473263f, 0.29759765f, -0.08619212f, 0.26038352f, 0.19387639f, 0.41243422f, 
    0.17818914f, 0.01830455f, 0.14375609f, 0.02564118f, -0.04980879f, 0.13836408f, 0.12157658f, -0.15795739f, 
    -0.27605101f, -0.05986346f, -0.07379486f, 0.30343044f, -0.44148862f, 0.05215840f, 0.23130751f, -0.02361909f, 
    0.13431951f, 0.06430850f, 0.10831609f, 0.14620776f, 0.50327897f, 0.18893334f, -0.12409233f, -0.04340839f, 
    0.36615473f, 0.18414138f, 0.34989268f, -0.09358218f, -0.12142137f, -0.23419744f, 0.07905611f, -0.15829633f, 
    0.17542951f, 0.32157964f, -0.34542236f, 0.23121819f, 0.10006758f, 0.12992617f, 0.00616709f, -0.02317531f, 
    0.28162917f, 0.03403442f, 0.07645796f, -0.36027563f, 0.43934512f, 0.13784289f, 0.07049510f, 0.20061164f, 
    -0.26987797f, 0.45331886f, -0.34899166f, 0.01468754f, -0.07543007f, 0.00714239f, -0.04894290f, 0.19528975f, 
    0.04970093f, 0.25157630f, 0.03037285f, 0.28441319f, 0.35436055f, 0.37334317f, -0.21494319f, 0.30168423f, 
    0.47381735f, -0.00729064f, -0.56089163f, 0.44332436f, -0.13795631f, -0.00547687f, -0.07626787f, -0.12105822f, 
    -0.14922544f, 0.09212460f, 0.07571237f, 0.01058846f, -0.09088941f, -0.00189498f, 0.18296497f, -0.31737375f, 
    0.28166184f, 0.01196630f, 0.42194101f, 0.01622300f, 0.07928839f, -0.35323778f, -0.01282682f, 0.02444729f, 
    0.20725963f, 0.30404747f, 0.15058158f, -0.22928819f, 0.25657633f, -0.16623606f, -0.06384657f, 0.10384466f, 
    0.20175506f, 0.04688900f, 0.01484517f, -0.38973990f, 0.07108554f, 0.05731386f, -0.14370029f, -0.12899317f, 
    0.19032179f, -0.11117102f, 0.00179318f, 0.12106233f, 0.49907580f, -0.25413841f, -0.32057589f, -0.26061231f, 
    -0.02216437f, -0.02610783f, 0.19724691f, 0.19165848f, 0.15599550f, 0.35314083f, -0.09212895f, 0.00741626f, 
    -0.26128727f, -0.30762559f, -0.07360046f, 0.02971492f, 0.10656779f, 0.51247585f, 0.11526279f, 0.11623728f, 
    -0.42830688f, -0.25372386f, 0.07319169f, 0.16993870f, 0.12925081f, -0.15196961f, -0.17575741f, -0.10306070f, 
    0.11828728f, -0.03215561f, 0.12494033f, -0.06977527f, -0.00357450f, -0.07339276f, 0.13357846f, -0.09616188f, 
    0.18348454f, 0.35712093f, 0.29182863f, 0.07619523f, -0.48091996f, -0.30334181f, 0.16828623f, 0.41456661f, 
    -0.34480411f, -0.11275582f, 0.03228100f, -0.34803969f, -0.39383891f, 0.07297251f, -0.31392306f, 0.04849396f, 
    0.17187542f, -0.15980519f, 0.02805321f, -0.12484823f, 0.01088668f, 0.09693282f, 0.02451672f, 0.02334448f, 
    0.05231234f, 0.09458488f, 0.11185763f, 0.37040731f, -0.01758112f, -0.09089248f, 0.35597116f, -0.09952736f, 
    0.09662999f, -0.30410016f, 0.61182547f, 0.38562173f, -0.20677039f, 0.33493325f, -0.09091268f, 0.08226057f, 
    -0.09410656f, 0.11382320f, -0.05331453f, 0.00399794f, -0.14922440f, -0.19486105f, 0.19511944f, 0.25069478f, 
    0.18444389f, 0.03833931f, -0.03120146f, -0.06310271f, -0.07903372f, -0.10639619f, 0.11250747f, 0.15138911f, 
    -0.06131415f, -0.09345842f, -0.12905695f, 0.42960638f, -0.35525969f, -0.26911554f, -0.33071458f, 0.18805775f, 
    0.10134778f, 0.01111247f, 0.57115060f, 0.31115562f, 0.23764205f, 0.42972109f, 0.03513074f, -0.10783854f, 
    0.23001544f, 0.10467716f, -0.19606981f, -0.28738740f, 0.01264078f, -0.50870931f, -0.41669649f, 0.20887323f, 
    -0.36116907f, 0.16590308f, -0.19717012f, -0.41322732f, -0.04828302f, -0.08963489f, -0.45238775f, 0.11046997f, 
    0.35223719f, 0.23190391f, 0.01988351f, 0.21423188f, 0.05195154f, -0.48102567f, -0.12661031f, 0.34829259f, 
    0.03859786f, -0.52474737f, 0.09866202f, 0.11910105f, 0.06251650f, 0.28567061f, 0.07165811f, -0.05113617f, 
    -0.09679819f, -0.21779330f, 0.07828742f, -0.15527065f, 0.05460425f, -0.24853958f, 0.65710926f, 0.19869532f, 
    -0.40317631f, 0.19788922f, -0.03522894f, 0.59029013f, 0.08819011f, -0.10007209f, -0.05880942f, -0.13926543f, 
    0.27141291f, 0.08671980f, -0.16383462f, 0.10538947f, -0.03358262f, 0.16833903f, 0.05355129f, 0.43514413f, 
    0.21223058f, -0.04544594f, -0.05984565f, 0.31539679f, 0.03036386f, -0.21866059f, -0.15922454f, -0.29254597f, 
    0.16262372f, 0.27259168f, -0.26004145f, 0.35535970f, 0.29430604f, 0.34563026f, -0.31420955f, 0.31150773f, 
    0.11094643f, 0.09166972f, 0.29566097f, 0.07381925f, 0.08747000f, 0.03101410f, -0.22419341f, 0.17605522f, 
    -0.09276945f, -0.09502406f, 0.05657141f, 0.27579552f, 0.05424715f, -0.11851862f, 0.09004446f, -0.38649234f, 
    0.08870657f, -0.23581608f, -0.21656001f, 0.12746966f, 0.27074838f, 0.14098318f, 0.02946266f, -0.00689622f, 
    0.16962835f, 0.18599896f, -0.26201183f, 0.09150521f, 0.29787290f, -0.15693392f, -0.03690709f, 0.14075063f, 
    -0.42162159f, 0.18201894f, 0.25926644f, -0.00634154f, -0.10168103f, -0.12045664f, -0.05465757f, -0.08575374f, 
    0.22445470f, 0.24304229f, 0.00988154f, 0.00420957f, 0.01864254f, -0.01302678f, -0.00483436f, 0.16777448f, 
    0.29520538f, -0.40197229f, -0.26580814f, 0.03261954f, -0.05347933f, -0.16943458f, -0.04181950f, 0.03910498f, 
    -0.06596284f, 0.32196581f, 0.08658482f, 0.07487366f, -0.05604408f, -0.32350892f, 0.36723268f, -0.05418873f, 
    0.21986747f, 0.32777056f, -0.20101136f, 0.40744826f, 0.08317020f, 0.07854303f, 0.19632694f, -0.06291734f, 
    -0.07702320f, 0.17237598f, -0.00252771f, -0.15241823f, -0.17111887f, -0.07375847f, -0.19853948f, 0.08579974f, 
    -0.07661975f, 0.16998640f, 0.29090872f, -0.11905539f, 0.14465520f, -0.21004003f, -0.10722109f, -0.22463286f, 
    0.24698791f, 0.32388127f, -0.18442708f, -0.09820729f, -0.50148231f, 0.16889779f, 0.02539976f, 0.27783567f, 
    0.30554870f, -0.13982421f, 0.04125392f, 0.04982955f, 0.06385241f, 0.10290387f, -0.32805672f, 0.12297500f, 
    -0.04061070f, 0.12082700f, -0.03612392f, 0.19223015f, -0.15920670f, -0.14798769f, 0.19329065f, -0.18577963f, 
    -0.05017834f, 0.35942861f, -0.21127667f, -0.07399499f, 0.45862076f, 0.43895692f, 0.11550915f, 0.38920379f, 
    0.09008174f, 0.23138286f, 0.46170616f, 0.48937210f, 0.32257324f, 0.12944135f, 0.35103238f, -0.15745670f, 
    0.54845405f, 0.01639235f, 0.38794246f, -0.14652972f, -0.03570409f, 0.13606529f, 0.27135199f, 0.11878093f, 
    -0.10075540f, -0.00270523f, 0.17265135f, -0.04561370f, -0.11289439f, -0.01040239f, -0.25347683f, -0.06079027f, 
    -0.15070814f, 0.10812353f, 0.09098456f, -0.20524506f, 0.12965935f, -0.18698941f, -0.03942571f, -0.45423746f, 
    0.31721520f, -0.28969756f, -0.19504608f, 0.30201980f, 0.56051862f, -0.28626239f, -0.25596586f, 0.22217400f, 
    0.38335204f, -0.06470064f, -0.50352824f, 0.52918255f, -0.04050418f, 0.13055362f, 0.03922920f, -0.14141884f, 
    0.10658976f, -0.12982056f, -0.09823015f, 0.13996755f, -0.03578979f, 0.22696307f, 0.00709373f, 0.03695582f, 
    0.25952300f, 0.35211104f, -0.07637934f, -0.03823938f, 0.19576998f, -0.55440795f, -0.17231639f, 0.05760635f, 
    -0.15511197f, -0.03182035f, -0.10263497f, 0.36614564f, 0.46588579f, 0.03480002f, -0.20879854f, -0.33213404f, 
    0.11311173f, 0.15652803f, 0.10097408f, 0.44115654f, -0.05784721f, -0.14852805f, 0.43327928f, -0.10922420f, 
    0.17355449f, 0.20824035f, -0.02577424f, -0.00104774f, -0.16524683f, 0.56309861f, 0.42120019f, 0.15567745f, 
    0.30778712f, -0.22338957f, -0.07946620f, -0.14797638f, -0.30226499f, -0.57929194f, -0.03518163f, -0.14082651f, 
    -0.10244454f, -0.12550014f, 0.24090275f, -0.21296804f, -0.36754256f, 0.25497249f, -0.24720424f, -0.26611078f, 
    -0.09890339f, 0.11453918f, -0.11862824f, -0.22503035f, 0.06367390f, 0.09071153f, 0.00629578f, 0.08155904f, 
    0.21263164f, 0.45701864f, -0.13767858f, -0.01052191f, 0.12671508f, 0.09157239f, 0.39129308f, 0.25153276f, 
    0.25286025f, -0.35983279f, 0.14859019f, 0.09745636f, -0.42987800f, 0.25412789f, 0.06559267f, 0.14067626f, 
    0.32123685f, 0.34013170f, 0.22186431f, 0.21614620f, 0.43780318f, -0.35480350f, -0.06749067f, -0.09523505f, 
    -0.18915614f, 0.11985191f, -0.10108843f, -0.08658855f, 0.01438044f, 0.13874070f, -0.03895327f, -0.10134245f, 
    -0.02569822f, 0.09140628f, 0.06994987f, 0.23653193f, 0.29697257f, -0.30469573f, -0.61069208f, -0.19057491f, 
    0.06835134f, 0.32294977f, 0.21621837f, 0.07184574f, -0.18918775f, -0.20898025f, 0.09181295f, -0.04444382f, 
    0.19619672f, -0.09455235f, 0.20896813f, -0.44183174f, 0.14788939f, -0.03964830f, -0.27525911f, 0.17165224f, 
    -0.11809178f, 0.14966257f, -0.14040922f, -0.20270877f, 0.06511095f, 0.13170700f, -0.28150067f, -0.00266435f, 
    0.31575242f, 0.02709029f, 0.16164067f, 0.04284314f, 0.63157797f, 0.06676104f, 0.25411776f, -0.05440462f, 
    -0.00593053f, -0.23501909f, 0.41573876f, 0.53854805f, -0.23665954f, -0.22516310f, -0.05941151f, 0.04879211f, 
    0.12247400f, 0.22256279f, -0.25868377f, 0.34560457f, -0.26110926f, 0.42995217f, -0.05286009f, 0.31434131f, 
    0.22660786f, -0.09023993f, 0.00653142f, 0.08360806f, 0.06098738f, 0.04130086f, -0.03715049f, 0.16904050f, 
    0.16354601f, 0.03195644f, -0.07573764f, 0.11171827f, 0.04048557f, -0.16137300f, -0.07408907f, -0.26350033f, 
    -0.04378604f, 0.26491234f, -0.17618805f, -0.19565105f, 0.31967255f, 0.44076544f, -0.10762414f, 0.33676368f, 
    0.16681759f, 0.06287023f, 0.48411965f, -0.25952518f, -0.22606058f, -0.08779524f, -0.00330002f, 0.19127262f, 
    0.50436068f, 0.44228587f, 0.03892544f, 0.17561054f, -0.14775236f, 0.08383114f, 0.06743304f, 0.11471581f, 
    -0.04403093f, 0.20940243f, 0.02528587f, -0.26849845f, -0.13132726f, 0.54670060f, 0.54871672f, 0.43368843f, 
    -0.23607291f, -0.16255246f, -0.25204754f, 0.20169170f, 0.39950931f, 0.10073656f, -0.12534562f, -0.21579486f, 
    0.03859468f, 0.45048651f, 0.16469422f, -0.14453076f, -0.04970257f, -0.23446956f, 0.70466977f, -0.07817177f, 
    -0.05006596f, 0.28328070f, 0.18571226f, 0.20742336f, -0.07887422f, 0.09793153f, -0.00334645f, 0.03033123f, 
    0.17712963f, -0.13188209f, 0.07914417f, 0.09855449f, -0.01466098f, -0.01444272f, -0.47099620f, -0.03561803f, 
    -0.19174044f, 0.27343425f, 0.17971793f, -0.02094276f, -0.14237246f, 0.13279165f, 0.13120319f, -0.12792493f, 
    -0.26160878f, 0.14937153f, -0.26203525f, 0.22060284f, -0.50082499f, -0.04004503f, 0.70118475f, -0.00662411f, 
    -0.26573145f, 0.01203957f, 0.32095242f, 0.38637206f, 0.02331387f, 0.13628523f, 0.30842641f, -0.16740805f, 
    0.09935804f, 0.32384709f, -0.08628864f, 0.21178992f, -0.23845038f, -0.17694454f, -0.28482747f, -0.00188488f, 
    0.29972246f, 0.23185131f, 0.25579295f, -0.25728688f, 0.24378005f, 0.00695539f, 0.01615192f, -0.02179166f, 
    0.27533826f, 0.30598584f, -0.41518256f, 0.10500424f, 0.40334174f, 0.21729425f, -0.03572998f, -0.04869519f, 
    -0.23362625f, 0.13286467f, 0.35927528f, 0.02255942f, -0.07443862f, -0.12540385f, -0.10941619f, -0.13824441f, 
    0.19364995f, -0.14254542f, 0.18456173f, -0.06895930f, 0.45898691f, 0.05262817f, -0.07230383f, -0.36216852f, 
    0.04972714f, 0.13855758f, -0.02017334f, -0.13532385f, -0.19029593f, -0.13263674f, 0.14293568f, 0.09208694f, 
    0.34993675f, -0.28991127f, -0.10136663f, -0.16753016f, 0.33428991f, -0.31324995f, 0.18841958f, 0.03600117f, 
    0.24393134f, 0.38163930f, 0.37397611f, -0.04760630f, -0.00328197f, -0.09242410f, 0.26430008f, 0.01549901f, 
    0.14849441f, -0.28324559f, 0.02245720f, -0.01172044f, 0.34550887f, 0.51334912f, 0.22058879f, 0.00831919f, 
    -0.20568790f, 0.21923020f, -0.32815179f, 0.14486410f, 0.25771245f, -0.12446315f, -0.15690826f, 0.13575917f, 
    0.14216007f, -0.20193379f, 0.50708526f, 0.03636621f, 0.09077280f, 0.41946542f, 0.05580279f, -0.16180365f, 
    -0.01277609f, -0.11337726f, 0.09305082f, 0.16895553f, -0.02682429f, -0.15711142f, -0.07476983f, -0.08023108f, 
    -0.04293928f, 0.15693046f, -0.00286169f, -0.31419063f, -0.21569432f, -0.09780658f, 0.20865622f, 0.30650842f, 
    0.14227541f, -0.00606714f, -0.50984734f, -0.07414120f, -0.18304695f, 0.08010259f, -0.14504620f, -0.03173565f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03532175f, 0.05548535f, -0.03327510f, 0.16642416f, 0.21751630f, 0.18684240f, -0.09674826f, -0.12052753f, 
    0.24217796f, -0.06043555f, -0.11475533f, -0.02531686f, 0.10338569f, 0.11189663f, 0.01103322f, 0.00160372f, 
    0.32215357f, 0.04349333f, -0.04152574f, -0.25085831f, 0.09015842f, 0.24003026f, 0.06536330f, -0.16676743f, 
    0.27730855f, 0.14554751f, 0.20182681f, -0.08672980f, 0.19934836f, 0.07910346f, 0.16204159f, 0.03481327f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.14381154f, -0.15088847f, 0.05809433f, -0.44019923f, 0.27376425f, 0.11998195f, -0.05696150f, -0.21576130f, 
    -0.30506659f, 0.06231412f, 0.39438862f, 0.24091193f, 0.34278670f, 0.02802487f, 0.18172629f, -0.51226526f, 
    0.03811614f, -0.00390864f, -0.41505820f, -0.22650680f, -0.37922662f, -0.20007248f, 0.08318106f, 0.22751351f, 
    0.13156119f, -0.31549349f, -0.53632516f, 0.30956483f, 0.36111084f, -0.16429782f, -0.36031243f, -0.22886218f, 
    -0.15812968f, 0.03686482f, -0.16326219f, -0.01893521f, -0.00007288f, 0.06566396f, 0.13958752f, -0.37951803f, 
    0.16662854f, 0.35067496f, -0.45114374f, 0.18466836f, 0.21728852f, 0.55677682f, -0.21045306f, 0.37340245f, 
    0.05844059f, -0.15563720f, 0.19045945f, 0.40220091f, -0.24241656f, -0.34003302f, 0.05242213f, 0.08407918f, 
    0.02039873f, 0.26477870f, -0.11773971f, -0.25618771f, -0.12658180f, -0.21181585f, -0.59141606f, 0.02376240f, 
    -0.14181411f, 0.01778621f, 0.25405478f, 0.30526912f, -0.27737266f, 0.12775855f, -0.20405869f, -0.40664056f, 
    0.28816405f, -0.23997739f, 0.43839797f, 0.35130680f, -0.08620558f, -0.63624954f, -0.33762100f, 0.06092510f, 
    -0.03885747f, -0.39923728f, -0.02889743f, -0.65020525f, -0.31077024f, 0.15908547f, 0.30918506f, -0.29399410f, 
    0.06966959f, 0.16196133f, -0.36198494f, -0.14009893f, 0.20167761f, 0.28700891f, -0.50981706f, -0.43683344f, 
    0.06447630f, 0.03905745f, 0.09421598f, -0.18681552f, -0.20538962f, 0.09575661f, 0.16671126f, -0.36768296f, 
    -0.20413207f, -0.40128630f, -0.88714403f, -0.60445213f, 0.13457486f, -0.50836825f, 0.08097521f, 0.17655209f, 
    0.18018739f, 0.27792752f, -0.26133767f, 0.19827628f, -0.02819261f, 0.12556201f, -0.60909605f, 0.01249802f, 
    -0.74429011f, -0.12864500f, 0.02953674f, 0.28744966f, 0.35786209f, 0.19586410f, 0.26278219f, -0.78244054f, 
    0.13240609f, -0.17083666f, -0.13088705f, -0.29278585f, -0.27037397f, 0.24212962f, -0.05091684f, 0.30870208f, 
    0.30464891f, -0.25772870f, -0.21728231f, -0.04616699f, 0.15233435f, -0.40515569f, 0.25955108f, -0.45132968f, 
    0.00447187f, 0.67754465f, 0.01732848f, -0.11134067f, 0.20127852f, -0.03611762f, 0.02987846f, -0.01982638f, 
    -0.05297455f, -0.19985247f, 0.33712509f, 0.11973012f, 0.12408441f, -0.50630057f, -0.24464504f, -0.01608271f, 
    0.14352266f, -0.15104337f, -0.46277523f, -0.40923044f, 0.03967462f, 0.05952990f, -0.33168021f, 0.22530307f, 
    -0.53819394f, 0.25380751f, -0.07416125f, -0.12034063f, -0.21951906f, 0.18043250f, 0.15657327f, -0.00976599f, 
    0.25263336f, -0.48886630f, 0.19393761f, -0.08786461f, -0.44798481f, -0.24411979f, 0.16663831f, -0.41632348f, 
    0.17119488f, 0.11200340f, 0.31552270f, 0.21161865f, -0.02297871f, 0.11238974f, 0.18106532f, -0.48778942f, 
    -0.06124082f, -0.12297522f, 0.29055905f, 0.50322181f, -0.01636757f, -0.12011883f, -0.60125971f, 0.24023086f, 
    -0.16641563f, 0.09800528f, -0.28846854f, -0.30136162f, -0.33168843f, 0.23597495f, -0.11523605f, -0.14645512f, 
    0.19503665f, -0.24785870f, -0.33557317f, -0.35520780f, 0.25655463f, 0.17216407f, 0.18038803f, 0.12180518f, 
    0.13577053f, -0.24833906f, -0.02862405f, -0.64631885f, -0.38809532f, 0.14838918f, 0.24502744f, -0.02125011f, 
    0.13787830f, 0.06770484f, 0.29896554f, -0.13530977f, -0.56849700f, -0.38103482f, 0.13049470f, 0.25925884f, 
    -0.11738622f, -0.33877489f, 0.42971942f, 0.04725531f, -0.54020178f, -0.10278269f, -0.19278611f, -0.43106684f, 
    -0.39761737f, 0.21457501f, -0.09781476f, 0.36586508f, -0.16511077f, 0.29689008f, 0.08347541f, -0.38414502f, 
    -0.47526187f, -0.02525589f, 0.32312614f, -0.05412003f, 0.03889100f, -0.35368499f, 0.10461985f, 0.36198044f, 
    -0.02093351f, -0.07721109f, -0.25884929f, 0.30064294f, -0.00319263f, -0.85244787f, 0.37523517f, -0.03734503f, 
    -0.01808380f, 0.20668843f, -0.17680345f, 0.27987722f, 0.28963345f, -0.41759974f, -0.43527558f, 0.12474174f, 
    -0.54475039f, -0.62315166f, 0.45092466f, -0.34408498f, -0.02917257f, -0.60082573f, -0.18463714f, -0.45228669f, 
    0.05420211f, 0.29618511f, 0.25617328f, -0.21418129f, -0.19657734f, -0.31025127f, 0.32997796f, -0.09890469f, 
    -0.19484544f, 0.02824126f, -0.17682227f, -0.03039164f, -0.10024806f, 0.17535865f, 0.17015375f, -0.28619525f, 
    0.19475372f, -0.24098107f, 0.03467323f, 0.30569330f, -0.04992168f, -0.12846899f, 0.20698470f, 0.20129718f, 
    0.10261113f, -0.40101939f, -0.62022507f, -0.26588619f, 0.03678041f, 0.25851622f, 0.12964481f, -0.82544744f, 
    0.32813132f, -0.70509911f, 0.38592046f, -0.90249479f, -0.49899152f, -0.37840506f, 0.12018824f, 0.45485222f, 
    0.13652760f, -0.09117373f, 0.08003508f, -0.54269189f, 0.20607592f, -0.15418473f, 0.13377798f, -0.17410472f, 
    0.29995322f, -0.85246539f, 0.39649707f, -0.50316894f, -0.25930187f, -0.41996509f, 0.16261253f, 0.18223177f, 
    0.15458372f, -0.34172243f, 0.12672147f, -0.15232842f, 0.40006837f, 0.13068019f, -0.38778830f, -0.33894566f, 
    -0.50425506f, 0.33449608f, -0.26621729f, -0.43378463f, 0.20622538f, 0.11892568f, -0.01247640f, -0.00431681f, 
    -0.00863358f, -0.08552530f, -0.35094774f, 0.21445067f, -0.01669172f, 0.06102774f, -0.13054061f, 0.23322046f, 
    0.39093891f, 0.40499240f, 0.16658172f, -0.64326423f, -0.12425170f, -0.65873581f, -0.07376051f, 0.19849743f, 
    -0.12579677f, -0.04950485f, -0.27633864f, 0.16665702f, 0.24149269f, -0.15037249f, -0.66181904f, 0.45736602f, 
    0.14733718f, -0.04671700f, -0.16667575f, 0.20442009f, -0.45059317f, 0.33966434f, 0.14011578f, -0.62618071f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.08078539f, 0.10460985f, -0.20691016f, 0.11595302f, 0.07631455f, 0.12252725f, 0.22076288f, 0.10643671f, 
    -0.04462457f, -0.05505968f, 0.10887603f, -0.10991597f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
