#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.97586679f, 0.97875208f, -0.51754135f, -0.31986830f, 0.97146428f, -0.08647458f, 0.20621987f, -0.14324152f, 
    -0.09198153f, -0.54886466f, -0.27183327f, 0.10377727f, 0.84476948f, -0.59048796f, -0.95222902f, -0.14932644f, 
    -0.24500063f, -0.21427450f, -0.87955225f, 0.41712582f, -0.16932963f, 0.10969203f, 0.51952690f, -0.51612777f, 
    0.24045911f, 0.40888882f, 0.16410902f, 0.54247171f, -0.09474991f, 0.67895794f, -0.69088453f, 0.15914164f, 
    -0.62035906f, -0.05782802f, 0.01735854f, -0.05929619f, 0.19757122f, -0.05304642f, 0.09415295f, -0.60796279f, 
    -0.09174527f, -0.19546771f, 0.31201649f, 0.30726141f, 0.59960812f, -0.92688322f, -0.70189846f, -0.07630928f, 
    -0.19513221f, -0.30000862f, 0.02329481f, 0.11734235f, -0.36320353f, 0.33501008f, -0.14097911f, -0.11809862f, 
    -0.45783663f, -0.00069350f, -0.17131801f, -0.47070009f, 0.27050710f, 0.47604781f, 0.70449185f, -0.20609811f, 
    -0.51408339f, -0.51910639f, -0.41056809f, 0.59499067f, -0.43486869f, 0.08106070f, -0.43635383f, -0.44649398f, 
    0.08245101f, -0.74736887f, -0.63414508f, 0.03429679f, 0.71568054f, -0.50727153f, -0.03277323f, 0.05391354f, 
    -0.59065217f, 0.68784761f, -0.80923623f, -0.34033883f, -0.28216055f, 0.51685339f, 0.01186077f, 0.26307744f, 
    0.29555473f, 0.17495042f, 0.50271231f, -0.49231958f, 0.36132631f, 0.36245662f, -0.27111852f, 0.58710665f, 
    -0.36176053f, -0.48936599f, -0.44748637f, 1.04823148f, -0.67511380f, -0.39420152f, 0.53440493f, 0.47518238f, 
    0.41117477f, -0.41066489f, 0.24165395f, -0.21132724f, -0.47424412f, -0.56926322f, 0.49565944f, -0.41649008f, 
    -0.58793414f, 0.53748477f, -0.30236641f, -0.07548065f, -0.48604256f, -0.05251411f, -0.50303894f, -0.80157954f, 
    0.90787834f, -0.28449708f, 0.70951509f, -0.03341517f, 0.48738623f, -0.19130239f, 0.61508667f, -0.72046196f, 
    0.27410075f, 0.21637620f, -0.37657541f, -0.66343820f, -0.47564453f, -0.16150826f, -0.32570919f, -0.02099540f, 
    -0.46545625f, 0.79877156f, -0.01565183f, -0.50409448f, -0.26858151f, 0.14917502f, 0.65213221f, 0.14403582f, 
    0.39674509f, 0.27129197f, 0.57081777f, 0.37616676f, 0.01660448f, 0.17445332f, 0.19790760f, -0.27359125f, 
    -0.37935159f, -0.73817873f, 0.08163108f, 0.93649709f, 0.57212359f, -0.00564836f, -0.18988676f, -0.25241396f, 
    0.17714313f, -0.52722430f, 0.74083900f, -0.76029289f, -0.13700156f, 0.04441464f, -0.23221035f, 0.05679354f, 
    0.40455645f, -0.47628281f, 0.20590551f, 0.21271677f, 0.06740271f, 0.44750163f, 0.50395674f, -0.53204834f, 
    -0.22647347f, -0.23058827f, -0.01691178f, 0.40516216f, 0.28396004f, 0.69036406f, -0.84984255f, 0.19161053f, 
    0.31371897f, -0.02876691f, -0.13444173f, 0.53985947f, -0.32420003f, 0.75956792f, 0.51995540f, 0.58764356f, 
    -0.08316505f, 0.22512759f, 0.16865443f, 0.19508727f, 0.43047228f, -0.58190161f, 0.18870029f, 0.13093801f, 
    0.64659500f, -0.09438402f, -0.60642189f, 0.39252362f, 0.02133552f, -0.07986023f, -0.03369793f, -0.38025579f, 
    0.35637254f, -0.30661041f, 0.59606314f, 0.01442761f, 0.28126264f, 0.03860449f, 0.65160066f, -0.28611857f, 
    0.39490512f, 0.76033998f, 0.09610130f, 0.12842532f, 0.31297120f, -0.48376006f, 0.20847908f, 0.40700042f, 
    0.15086593f, 0.34045362f, 0.27733317f, 0.47639585f, -0.90460992f, 0.29889941f, 0.46645591f, 0.14421709f, 
    -0.02721921f, 0.19325572f, -0.22420987f, -0.20184162f, -0.14780042f, 0.23472096f, -0.72450447f, -0.91055894f, 
    0.36618614f, 0.55229235f, 0.26442114f, -0.33122805f, 0.33074525f, 0.14099625f, -0.28029743f, 0.17817537f, 
    0.72698760f, -0.15006407f, 0.44441149f, 0.39184961f, -0.43991318f, 0.94643402f, -0.60489887f, -0.81278288f, 
    -0.09822652f, -0.09593819f, -0.03607244f, 0.12894471f, 0.26671821f, 0.55430466f, 0.62048608f, 0.02649863f, 
    -0.28158841f, -0.35080442f, -0.14723916f, 0.34010732f, 0.02320107f, 0.26842454f, -0.29064041f, -0.27789506f, 
    -0.57225996f, 0.89700538f, -0.02041569f, 0.65632206f, -0.37821582f, -0.34338501f, -0.12362584f, -0.00243833f, 
    -0.42867795f, -0.45246807f, -0.43239859f, -0.30694476f, -0.71528208f, -0.34128913f, -0.02719372f, 0.45430210f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12149031f, 0.36566186f, -0.16578455f, 0.34587917f, 0.04033571f, -0.15541217f, 0.20007080f, -0.15256357f, 
    0.33117628f, 0.24796779f, -0.24196659f, -0.05919967f, -0.15258193f, -0.14875156f, 0.12442457f, -0.22669517f, 
    0.06042965f, 0.13165775f, 0.44407669f, 0.04337684f, -0.01410570f, -0.36573347f, 0.34236768f, -0.01691174f, 
    0.15446517f, 0.30807334f, 0.13850532f, 0.29739177f, 0.31392732f, 0.38203922f, -0.00292633f, -0.34744579f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.97875476f, 0.04004328f, -0.44105411f, 0.04865086f, -0.30737415f, -0.08250031f, -0.04587599f, -0.10556490f, 
    -0.11689825f, 0.16197304f, -0.27857232f, 0.23970352f, 0.00639208f, 0.04161255f, -0.02076773f, 0.16204269f, 
    0.04293982f, -0.00532180f, 0.74266458f, 0.03780966f, -0.05034712f, 0.03496813f, -0.15788409f, -0.00600605f, 
    0.17852177f, 0.12880006f, 0.01851739f, -0.12033454f, 0.01017060f, 0.19928083f, -0.03283164f, -0.00025237f, 
    -0.00066620f, 0.16530842f, 0.01041786f, 0.13171694f, -0.46445167f, -0.30796140f, -0.16029227f, 0.09242285f, 
    0.01966503f, 0.06637338f, 0.02235350f, 0.03090583f, 0.23180914f, 1.16701138f, -0.00030885f, -0.02888499f, 
    -0.17119782f, -0.09907912f, -0.12818737f, 0.05382385f, -0.01175972f, -0.03910278f, 0.05267255f, -0.41398963f, 
    -0.00451179f, 0.12204857f, 0.09561534f, 0.10235362f, 0.00447979f, -0.07820953f, 0.08936005f, -0.31559590f, 
    -0.02263276f, -0.06306180f, -0.08577465f, -0.12630646f, 0.05420935f, -0.03481499f, 0.02805885f, 0.02861504f, 
    -0.04865012f, -0.27659726f, 0.17523947f, -0.06406216f, -0.08931335f, 0.11306715f, -0.10365788f, -0.03129965f, 
    -0.17374705f, -0.08035135f, -0.18372259f, -0.11556000f, 0.04885207f, -0.05625819f, 0.09524917f, 0.12895635f, 
    -0.00615568f, 0.11356971f, 0.06304683f, 0.03861221f, 0.01941715f, 0.15780216f, -0.08487895f, -0.04849347f, 
    0.02532025f, -0.15065710f, -0.04182277f, 0.10445257f, 0.04197978f, 0.16448365f, -0.20792623f, -0.18358183f, 
    -0.16097176f, -0.11177907f, 0.01532051f, 0.00798081f, 0.03262366f, -0.28742436f, -0.80032635f, -0.02905040f, 
    -0.02036288f, -0.12428326f, 0.08463105f, 0.20469739f, -0.16172551f, 0.21491118f, -0.45234349f, -0.25818101f, 
    -0.13047357f, 0.11333150f, -0.08115897f, 0.07966480f, 0.02883237f, 0.04858447f, -0.14023620f, -0.27480537f, 
    0.11011188f, -0.02016971f, 0.00945804f, -0.08310644f, 0.10338470f, 0.10645720f, 0.00429051f, -0.44094402f, 
    -0.09085555f, 0.09863349f, 0.06753500f, -0.04818582f, -0.10873227f, -0.06690528f, 0.21667704f, 0.24160790f, 
    0.06507652f, 0.13596445f, 0.23326471f, -0.11354767f, 0.02217290f, -0.07372620f, 0.07086781f, -0.12277174f, 
    -0.14135133f, 0.26720655f, 0.19120215f, 0.25045139f, -0.00341098f, 0.14247301f, -0.19099210f, 0.12767456f, 
    0.06435531f, -0.08439481f, 0.19799246f, -0.03394406f, -0.02884337f, 0.09858774f, 0.12413923f, 0.05378265f, 
    0.17174135f, 0.09805541f, 0.09525270f, -0.11840241f, 0.01180803f, -0.08247085f, -0.07772706f, 0.15250961f, 
    -0.04248409f, 0.18528536f, 0.06397363f, 0.01563653f, 0.00087986f, 0.08546146f, -0.02632904f, 0.04618555f, 
    -0.44722363f, 0.06183981f, -0.03379134f, -0.03477828f, 0.00301940f, -0.01659115f, 0.04563021f, 0.24789566f, 
    -0.04745588f, -0.04444575f, -0.14027540f, 0.05526914f, -0.12038703f, 0.01501686f, 0.04348968f, 0.07193200f, 
    0.00572576f, -0.08510835f, -0.02658307f, 0.03917992f, 0.13108541f, 0.10177163f, 0.10443083f, 0.17217453f, 
    0.06268746f, 0.18890977f, -0.16692118f, -0.08922247f, -0.23510838f, -0.06293704f, -0.01768550f, 0.02432210f, 
    -0.12640771f, 0.05367123f, 0.22414336f, -0.00700751f, -0.10449588f, -0.13160104f, 0.06891932f, -0.06215893f, 
    -0.00863707f, 0.01625494f, -0.08041631f, 0.04700596f, 0.02542185f, 0.04041665f, 0.07398619f, 0.01228301f, 
    0.13196214f, 0.14087902f, -0.20977025f, -0.51800591f, 0.08095969f, 0.11470064f, 0.10301200f, -0.05324373f, 
    0.00303776f, 0.00729114f, 0.11625188f, 0.16375889f, 0.24528873f, -0.02383132f, -0.11881573f, -0.18821482f, 
    -0.16852212f, 0.00191970f, -0.03184225f, 0.15892246f, 0.15177055f, -0.32401207f, -0.41678709f, -0.02446517f, 
    -0.02496010f, 0.08170152f, 0.08871502f, -0.01398331f, 0.15627003f, -0.22018234f, 0.02013904f, 0.12416360f, 
    -0.00818547f, -0.04746016f, 0.05002867f, 0.16135766f, -0.01310568f, 0.10613029f, 0.28689075f, -0.30643705f, 
    -0.34297657f, -0.05215878f, -0.12810513f, -0.04355365f, -0.05647296f, -0.02817132f, -0.07793083f, -0.09647679f, 
    -0.23907876f, -0.14874230f, -0.12204291f, 0.01818055f, 0.01733526f, 0.01505618f, -0.01785361f, -0.19825174f, 
    0.26517212f, -0.27170932f, -0.18118861f, -0.05189046f, 0.31686264f, -0.01031801f, -0.00012495f, -0.04956273f, 
    0.09609154f, 0.22861299f, 0.07426104f, 0.10454398f, 0.03826591f, -0.00718003f, 0.02547351f, -0.06344772f, 
    0.07749421f, -0.07062928f, 0.03387402f, -0.14632772f, -0.13393958f, 0.08552518f, 0.10211052f, -0.00724230f, 
    -0.08788042f, -0.02753642f, 0.05039464f, 0.23989758f, 0.23239490f, 0.03074086f, 0.06535362f, 0.01724461f, 
    -0.08452287f, -0.00531680f, 0.08152826f, 0.03914200f, -0.04823733f, -0.11557622f, -0.01300220f, -0.09571788f, 
    0.06491025f, -0.04118820f, -0.17659990f, -0.10543488f, -0.11323056f, 0.12931240f, -0.08357047f, 0.02773270f, 
    0.08124179f, 0.04213954f, 0.14368324f, 0.04520770f, -0.10438847f, 0.05335199f, -0.05993703f, -0.13123724f, 
    0.03611530f, 0.14763123f, 0.11646320f, 0.01020660f, -0.05741769f, -0.00596550f, -0.06302029f, 0.08430979f, 
    0.03416156f, 0.03545145f, -0.05620427f, 0.09025137f, 0.02225284f, 0.00789619f, 0.00664286f, 0.06679706f, 
    -0.05996836f, 0.06756491f, 0.00472999f, -0.08201198f, 0.09273227f, 0.04922856f, 0.04945945f, 0.17118208f, 
    0.18819351f, -0.26474634f, 0.05329252f, 0.08434320f, -0.04082704f, 0.07898472f, -0.02879450f, -0.03378535f, 
    0.06269226f, -0.00638273f, -0.09826329f, 0.06920735f, -0.06170340f, 0.05270728f, 0.09382064f, 0.06592645f, 
    0.01109756f, 0.16776142f, -0.05250352f, -0.34521821f, 0.33043832f, 0.00115316f, 0.08601356f, 0.08241685f, 
    0.16571660f, -0.12307975f, -0.11636302f, -0.14727296f, 0.07748414f, -0.00294349f, -0.07831708f, 0.04585944f, 
    0.21214953f, 0.07577880f, -0.09469046f, -0.00597021f, 0.06644278f, -0.24576393f, -0.39555871f, 0.19630958f, 
    0.06200847f, 0.16453849f, 0.09910214f, -0.07757737f, 0.04888239f, -0.04852737f, -0.02179098f, 0.10702865f, 
    0.14405450f, 0.09047599f, -0.09337969f, -0.05789050f, 0.07386187f, 0.09100588f, 0.10581685f, 0.20458780f, 
    -0.08548099f, -0.07729729f, 0.01190389f, -0.11989169f, -0.15575969f, 0.08452468f, 0.11324362f, -0.35160267f, 
    0.12416958f, 0.23170689f, -0.14696741f, -0.02452682f, 0.01225818f, -0.02135923f, 0.02862621f, -0.03110455f, 
    -0.10676699f, 0.19526741f, 0.03195059f, -0.51711696f, 0.08389845f, 0.09792751f, 0.00990375f, 0.13550487f, 
    -0.06994310f, -0.06236704f, -0.04210771f, 0.15114403f, 0.04860160f, 0.16648556f, 0.16117488f, -0.01062379f, 
    0.25267211f, 0.18276712f, 0.01659130f, 0.32426006f, -0.02651723f, 0.07324260f, 0.06425663f, -0.21897757f, 
    0.05485074f, -0.00257308f, 0.10458525f, -0.25460958f, -0.34198162f, 0.28321517f, 0.01566371f, 0.10391445f, 
    0.03876862f, 0.04413571f, 0.16220160f, 0.24961360f, -0.09749978f, 0.00993440f, 0.20870304f, -0.03890886f, 
    -0.15429789f, -0.04837111f, -0.11768008f, -0.03757375f, -0.17943008f, 0.01355124f, 0.27523467f, 0.15760657f, 
    0.02940598f, -0.09812639f, 0.08880097f, -0.11336077f, 0.02213738f, 0.11854480f, -0.01800467f, -0.08497125f, 
    -0.04666895f, -0.06752279f, 0.03151383f, 0.08140823f, 0.06407530f, 0.00201278f, -0.34055787f, -0.22817686f, 
    0.12154341f, 0.13873900f, 0.00554502f, -0.01194829f, -0.07196063f, -0.00373089f, -0.01834809f, 0.04924858f, 
    -0.08123586f, 0.12949826f, 0.29468650f, -0.03607036f, -0.00208994f, 0.06017383f, -0.09100173f, -0.01049011f, 
    -0.04009818f, 0.14122602f, -0.07874039f, -0.13967307f, -0.10288195f, 0.19589232f, 0.17803200f, 0.16063428f, 
    0.00684524f, 0.10269492f, -0.03331019f, 0.01398773f, 0.01430377f, -0.02768963f, 0.00327436f, 0.04219537f, 
    -0.03160538f, -0.11843430f, -0.29489064f, -0.10620180f, -0.03915047f, 0.13678417f, -0.06051997f, -0.02812370f, 
    0.00956315f, -0.15428112f, 0.08625263f, 0.06793359f, 0.05402700f, -0.01148185f, 0.17266169f, 0.10972673f, 
    0.06145125f, 0.09606108f, -0.10261916f, 0.00593993f, 0.03401091f, -0.05396784f, -0.10375295f, -0.22753660f, 
    -0.01757062f, 0.02851862f, 0.16589017f, 0.17380157f, 0.05752717f, 0.26109239f, 0.02757413f, -0.07668808f, 
    0.02495237f, 0.11602446f, 0.23344195f, 0.23063911f, 0.02734919f, -0.11622357f, 0.08995680f, -0.10641043f, 
    -0.29816717f, -0.15363170f, -0.89429271f, 0.12943043f, 0.10976233f, -0.24157931f, -0.10290270f, 0.03331956f, 
    0.18966512f, -0.28369227f, -0.14573571f, -0.18485802f, -0.05433905f, -0.07154679f, 0.16859916f, 0.12863116f, 
    0.06348627f, 0.05319349f, -0.29104406f, -0.23250104f, -0.29138282f, 0.01400369f, -0.06320444f, -0.07832096f, 
    0.24025030f, -0.13443096f, -0.07565380f, 0.43456665f, 0.43006042f, 0.17795631f, 0.03554512f, -0.08596300f, 
    0.19538471f, 0.00952014f, 0.14754586f, 0.04095436f, 0.05394818f, -0.01903374f, 0.05937515f, 0.00553249f, 
    0.08790468f, -0.04967838f, 0.10617956f, 0.05024612f, 0.16932468f, 0.25031105f, -0.07319410f, -0.30243057f, 
    -0.11081792f, -0.04835998f, -0.04701921f, -0.09936098f, 0.04448606f, 0.07821146f, -0.20900367f, -0.35813820f, 
    -0.03324900f, 0.02561375f, -0.01158111f, 0.03182377f, 0.30119330f, -0.08759896f, 0.00845011f, -0.07318983f, 
    -0.33967900f, -0.44762725f, -0.10790471f, 0.04434180f, 0.00373692f, -0.09196754f, 0.02468004f, -0.03030780f, 
    -0.15515655f, -0.13781933f, -0.53867513f, 0.06029908f, 0.18770450f, 0.06857186f, 0.00739922f, -0.05017509f, 
    0.03250023f, 0.09299035f, -0.05352234f, -0.27536348f, -0.04997744f, 0.21905741f, 0.11789192f, 0.12624139f, 
    0.01549570f, -0.15199828f, -0.21305479f, -0.34718901f, 0.05305720f, -0.05992202f, -0.13140410f, -0.10970679f, 
    0.04046995f, -0.09194589f, 0.10394616f, -0.14831828f, -0.20268841f, -0.23608862f, -0.13395302f, -0.00970927f, 
    -0.04707113f, -0.07502579f, -0.10095955f, 0.00012246f, 0.53185648f, -0.54311198f, 0.42479751f, -0.13430634f, 
    -0.04432295f, -0.07258339f, -0.01530731f, 0.02938564f, 0.02673456f, -0.31097582f, -0.73437124f, -0.04335479f, 
    -0.20302260f, -0.22264528f, -0.05967190f, -0.03665180f, 0.03557595f, -0.23803450f, 0.16737543f, 0.11903232f, 
    -0.07867251f, 0.21040210f, -0.06689250f, 0.19908458f, -0.06401620f, -0.07295766f, -0.09219862f, 0.01024033f, 
    -0.17059527f, -0.25440767f, -0.15505187f, -0.18179213f, 0.06353583f, -0.04567707f, -0.10750607f, -0.26841646f, 
    0.12941408f, 0.04993915f, 0.28569251f, -0.04825595f, -0.07246274f, -0.00699777f, 0.05867489f, 0.07309847f, 
    0.18089104f, -0.19445789f, 0.03336575f, -0.23305577f, 0.10426503f, 0.01496947f, 0.21184020f, 0.02846851f, 
    -0.02522640f, 0.18115506f, 0.18531092f, -0.10203595f, 0.05211893f, -0.01302026f, 0.00421425f, 0.04999405f, 
    -0.06475367f, 0.09690771f, -0.01046762f, 0.23803568f, 0.07107389f, 0.36016724f, 0.13858171f, -0.02184435f, 
    0.00250210f, 0.09713793f, 0.05909853f, 0.06210941f, -0.29970825f, -0.27968162f, -0.16488920f, -0.05810809f, 
    0.16301478f, -0.01426003f, 0.11260819f, -0.04863628f, 0.00093594f, 0.26848161f, 0.21614434f, 0.33090645f, 
    -0.18903790f, -0.11168633f, -0.09521158f, -0.09493051f, 0.00848599f, 0.07140434f, 0.44190997f, 0.08762489f, 
    0.25604087f, -0.02775557f, -0.02442723f, 0.11610217f, 0.04784103f, 0.17824921f, 0.07451496f, -0.11765540f, 
    -0.00121263f, -0.03331002f, -0.15273261f, 0.06140311f, -0.00435785f, 0.01062893f, 0.05377797f, 0.04973157f, 
    0.13872477f, 0.20630659f, 0.14350535f, -0.04573939f, 0.13709168f, -0.19881405f, 0.24557744f, 0.10535477f, 
    -0.19559941f, 0.40402305f, 0.26210931f, 0.20169392f, -0.12949400f, 0.19029833f, -0.05367493f, 0.00238841f, 
    -0.00978064f, 0.06753750f, -0.33328158f, -0.27736801f, 0.09331521f, -0.24543884f, -0.03650245f, -0.17000321f, 
    0.11280286f, -0.14439002f, 0.01898443f, 0.13627937f, 0.02973016f, -0.03431695f, 0.10068477f, 0.18264067f, 
    0.06221005f, 0.12462277f, -0.03267866f, -0.17024828f, 0.26231661f, -0.83668011f, 0.03488395f, 0.11116713f, 
    -0.00584157f, -0.15463239f, 0.04152371f, 0.14088780f, 0.17029211f, 0.37099493f, 0.19243872f, 0.33974367f, 
    -0.00044957f, 0.16130608f, -0.10286793f, 0.00285732f, 0.10093840f, 0.10789621f, -0.39767650f, -0.37764052f, 
    0.03436028f, -0.02771915f, -0.03659198f, -0.10728268f, -0.10095835f, -0.11965986f, 0.05132960f, -0.00484030f, 
    0.04767143f, -0.13601215f, -0.11129938f, -0.15235101f, -0.11439445f, -0.04096444f, -0.07635574f, 0.07974010f, 
    -0.05720715f, 0.04170595f, 0.02990755f, -0.01174984f, 0.01341925f, -0.01039087f, -0.05166317f, 0.03382743f, 
    0.00754562f, -0.04782616f, 0.02290027f, -0.02271484f, -0.00149019f, -0.04171242f, -0.00286753f, 0.02104616f, 
    0.02778023f, -0.02028606f, 0.00493536f, 0.02422250f, -0.01502599f, 0.02959385f, 0.01693964f, -0.01359726f, 
    -0.03358696f, -0.00185130f, -0.05940562f, -0.03705017f, 0.03483415f, 0.00588333f, -0.00417145f, 0.01597093f, 
    0.04338802f, -0.04546958f, 0.02058120f, -0.01717865f, -0.05404539f, 0.04239188f, -0.05718132f, 0.01815502f, 
    0.02963273f, -0.05321811f, -0.03331848f, 0.03914172f, -0.01153347f, -0.03260346f, 0.01510791f, -0.02680113f, 
    -0.02954365f, -0.05475444f, -0.05751147f, -0.01913358f, -0.03235474f, -0.05232346f, 0.04328802f, 0.03064156f, 
    0.01088797f, -0.06382867f, -0.05862700f, 0.02237941f, 0.00386841f, 0.03084969f, 0.02061847f, 0.02698429f, 
    0.03398608f, -0.05211673f, -0.02941172f, -0.04916145f, 0.01977235f, -0.03246358f, -0.05416261f, 0.04174179f, 
    -0.03994573f, -0.05765471f, 0.02239517f, 0.01412552f, -0.02070610f, -0.05470478f, -0.00445280f, -0.05780949f, 
    0.00041479f, 0.05205718f, -0.04183219f, -0.01517442f, 0.01072858f, 0.02797372f, -0.05290797f, -0.05794030f, 
    0.03918557f, -0.03845821f, 0.02630475f, 0.03209033f, 0.02643830f, -0.05100981f, -0.05885265f, -0.00481638f, 
    0.03242324f, 0.04160143f, 0.02490220f, -0.05700243f, -0.01278159f, -0.03993344f, 0.02077314f, -0.00035015f, 
    -0.01714608f, -0.05065763f, 0.02629531f, -0.04026119f, -0.03849013f, -0.02442223f, 0.00319466f, -0.04297819f, 
    0.01078671f, 0.00583013f, -0.06170997f, 0.02710324f, -0.01155320f, 0.01942314f, 0.04195302f, 0.05727519f, 
    -0.02740810f, -0.03452500f, -0.06129977f, -0.05856660f, 0.00169761f, -0.03416157f, -0.03917611f, -0.01041531f, 
    -0.02036756f, -0.05082152f, 0.03092783f, -0.03918687f, -0.05121588f, -0.02713548f, -0.03637177f, -0.05030922f, 
    -0.02292175f, 0.00393657f, 0.02103062f, 0.05543953f, -0.00405440f, 0.00733325f, 0.05121405f, 0.01799583f, 
    -0.03201565f, -0.05548068f, 0.00671644f, -0.04138256f, -0.03185613f, 0.04178805f, -0.01434423f, -0.06012219f, 
    0.02151458f, -0.00779306f, -0.02621833f, -0.00886764f, 0.01041511f, 0.02636869f, 0.04366624f, 0.05334006f, 
    -0.01337657f, -0.06074867f, -0.05639416f, -0.01800277f, 0.04427034f, 0.01346418f, 0.03963305f, -0.04523268f, 
    -0.00709931f, -0.01335552f, -0.02154538f, 0.00049577f, -0.03380015f, 0.01415303f, -0.04680044f, -0.04537464f, 
    0.02058170f, 0.03034097f, 0.00117226f, -0.04150896f, -0.03051553f, -0.02219754f, 0.02619244f, -0.04692491f, 
    0.02304208f, -0.04162353f, 0.02928622f, 0.02975440f, -0.01717665f, -0.01310445f, 0.02855013f, -0.03867802f, 
    -0.02003342f, 0.03273343f, -0.04844679f, 0.01596008f, -0.00838966f, -0.01307489f, -0.00705284f, 0.04625838f, 
    -0.01120995f, 0.04457511f, -0.03659165f, 0.00938820f, -0.01423884f, 0.04540954f, -0.01654914f, 0.03589053f, 
    -0.00604056f, -0.01266071f, 0.00117595f, -0.04263217f, -0.00090644f, 0.02643888f, -0.02797771f, -0.04757975f, 
    0.02901862f, 0.03891436f, 0.02381603f, -0.04052044f, 0.04200656f, -0.01538439f, -0.01116712f, -0.03948712f, 
    -0.05865206f, -0.01876999f, -0.03541199f, 0.01333379f, -0.01595502f, -0.03541148f, -0.04075053f, -0.04607703f, 
    -0.02880844f, 0.00662100f, 0.00519643f, -0.01814694f, -0.00424565f, 0.03233001f, 0.01172605f, -0.00475123f, 
    0.00193065f, 0.03022097f, 0.02544127f, 0.01647336f, -0.04076910f, 0.01277428f, -0.02277964f, -0.05144839f, 
    -0.02316377f, 0.00415165f, -0.04482347f, -0.02117168f, 0.04481119f, 0.04353360f, 0.03629438f, -0.04475622f, 
    -0.04746544f, -0.03395886f, 0.01657377f, -0.01870751f, 0.03746000f, -0.01914172f, -0.04868048f, -0.05582804f, 
    0.04956268f, -0.03905486f, 0.01612392f, -0.02008215f, -0.00560616f, -0.05216688f, 0.00096410f, 0.00681077f, 
    0.02707540f, 0.02227337f, 0.01222660f, 0.04651267f, 0.01407779f, 0.04637896f, 0.02875061f, 0.00683644f, 
    -0.03359490f, 0.04894271f, 0.04374480f, -0.00764544f, -0.06450351f, 0.03955872f, -0.04736296f, 0.01518885f, 
    -0.01700196f, -0.05240396f, -0.01505964f, 0.00600562f, 0.01008342f, 0.03064241f, -0.05946237f, -0.04460088f, 
    -0.03819044f, -0.04457529f, -0.05425213f, 0.04012283f, 0.00536342f, -0.01471569f, 0.03032802f, 0.01098433f, 
    0.04237007f, -0.04786450f, 0.01436059f, 0.00961152f, -0.02785733f, -0.04089133f, -0.01448644f, -0.02712345f, 
    -0.05576046f, 0.00558964f, 0.03918388f, -0.02067227f, -0.02003331f, 0.03654077f, -0.03267486f, -0.01131786f, 
    -0.04503834f, 0.02533403f, -0.04347143f, -0.05583237f, -0.01354320f, -0.01577931f, -0.05363699f, -0.02906254f, 
    -0.00683455f, -0.03515443f, -0.04166096f, -0.02040690f, -0.02531011f, -0.01481013f, -0.00476236f, -0.01196113f, 
    0.03134023f, -0.02631523f, -0.02739473f, -0.03843869f, -0.04794309f, -0.06046060f, 0.02904030f, 0.04135354f, 
    -0.04864452f, 0.01176651f, -0.03977516f, -0.03233222f, -0.05611485f, -0.02334156f, -0.06483893f, -0.00563843f, 
    -0.04973902f, 0.05034861f, -0.01483553f, 0.01467970f, -0.05437981f, -0.00270876f, 0.02880646f, 0.02114326f, 
    -0.04233960f, 0.01906358f, -0.02050677f, 0.03470580f, 0.03233836f, -0.02330263f, -0.02983178f, 0.00372795f, 
    -0.04929115f, -0.01803490f, -0.01313419f, -0.02782575f, 0.00079540f, -0.00884214f, 0.02203882f, -0.01359791f, 
    0.02146365f, 0.04694744f, -0.02920517f, 0.02309668f, -0.05475087f, 0.03351140f, 0.00994518f, 0.01564864f, 
    0.04037175f, 0.05043933f, 0.01850705f, -0.01389605f, -0.01963603f, 0.00605031f, -0.03017202f, -0.02057680f, 
    0.01615123f, 0.01287241f, -0.04450799f, -0.01703077f, 0.05058724f, -0.02101875f, -0.04075523f, 0.03616769f, 
    -0.02345404f, 0.04688089f, 0.01094518f, -0.01078437f, -0.00253370f, -0.02160536f, -0.06334595f, -0.01049258f, 
    0.02741221f, -0.05574456f, -0.03323338f, -0.06539426f, -0.05275258f, 0.03386426f, 0.01941994f, 0.04947574f, 
    0.02480284f, -0.06757488f, 0.03723826f, -0.05149487f, -0.05991930f, -0.02737832f, -0.04355414f, 0.00141420f, 
    0.01547502f, -0.01895412f, 0.00598870f, -0.00641536f, 0.04290140f, 0.02992159f, -0.02741187f, -0.00516159f, 
    0.03527699f, -0.03579710f, 0.04945304f, -0.02349796f, -0.06634822f, 0.02540736f, 0.03732174f, -0.03211496f, 
    -0.03482555f, 0.01684763f, -0.00076561f, -0.03983479f, 0.04762359f, 0.02639369f, -0.04399134f, 0.00687186f, 
    -0.01533370f, -0.02669308f, -0.03305765f, -0.02246703f, -0.02150930f, 0.03424127f, -0.02475845f, -0.05684835f, 
    -0.04194049f, 0.02687499f, -0.05815462f, -0.04918332f, -0.01665268f, -0.04870394f, -0.05030488f, -0.02394809f, 
    0.04461755f, -0.05632880f, 0.00704254f, -0.02302884f, 0.04820362f, -0.02867762f, 0.00537377f, -0.02443398f, 
    0.02953171f, 0.03436807f, 0.04031543f, -0.01249723f, 0.03473602f, 0.01212511f, 0.03949599f, 0.04398796f, 
    0.02123117f, -0.04931881f, -0.02273254f, 0.00820334f, -0.04911365f, -0.04242866f, 0.04244745f, -0.01826452f, 
    0.01314410f, 0.03849713f, 0.02858905f, 0.03256459f, -0.01550389f, 0.04762294f, 0.00381557f, 0.00638358f, 
    -0.03358468f, 0.00402380f, -0.01416689f, -0.02331465f, -0.02954007f, -0.02666827f, -0.00312825f, 0.03176143f, 
    -0.01751979f, -0.05452682f, 0.00116649f, 0.01033503f, 0.03312580f, -0.04709892f, 0.01265887f, 0.04330951f, 
    0.04455942f, -0.00516594f, 0.02705279f, 0.02265701f, -0.06224072f, 0.02650093f, -0.06193107f, 0.04860724f, 
    -0.01485248f, 0.04224256f, -0.03376069f, -0.00535059f, -0.01465376f, 0.00240802f, 0.04860368f, -0.06549395f, 
    -0.02674544f, -0.00059950f, -0.06594715f, 0.00647667f, 0.01458624f, -0.03339024f, -0.02815991f, -0.03433198f, 
    -0.01864308f, -0.06469268f, 0.00833086f, -0.00796281f, 0.00550351f, -0.04623520f, -0.06016669f, -0.01692556f, 
    -0.03981375f, -0.05522142f, -0.01224502f, -0.05644228f, 0.04264188f, -0.05983467f, -0.01471661f, 0.02074699f, 
    -0.04713996f, -0.06654231f, -0.04344407f, -0.02375931f, -0.00646799f, 0.02340297f, -0.03146474f, 0.00182471f, 
    -0.03980925f, -0.04221694f, -0.04916852f, 0.04437810f, 0.02141073f, -0.02194982f, -0.05595861f, -0.03408429f, 
    0.04352086f, -0.01177004f, -0.02432536f, 0.04372391f, -0.03306383f, 0.01322119f, 0.01362642f, 0.02886149f, 
    -0.45630112f, 0.30927131f, -0.01799540f, -0.28708410f, 0.22403875f, 0.21983995f, 0.00077969f, -0.04015106f, 
    0.07073834f, -0.02288458f, 0.12148894f, 0.26922026f, -0.06339872f, -0.06413707f, -0.26718131f, 0.10915776f, 
    0.10975812f, -0.02649456f, 0.09457837f, -0.12371909f, -0.05077897f, -0.04580338f, 0.18469709f, -0.08158398f, 
    0.09237716f, 0.04667831f, -0.00313621f, -0.46942520f, 0.15829922f, 0.20375809f, -0.09042033f, 0.15563418f, 
    0.13999024f, 0.06368691f, 0.00496237f, 0.08236565f, -0.15704829f, -0.14745846f, 0.03318301f, 0.13787852f, 
    0.09985959f, -0.00512492f, -0.12534726f, 0.03525768f, 0.09505387f, 0.05463343f, 0.07578667f, -0.13053401f, 
    -0.05397724f, -0.22391145f, -0.04100559f, 0.06807826f, 0.05054086f, 0.00817516f, -0.07158262f, -0.11312327f, 
    0.15500772f, 0.11541277f, 0.03978777f, -0.05250875f, -0.00096746f, 0.15747230f, 0.14657265f, 0.13851917f, 
    0.22146684f, -0.01167381f, 0.06833036f, -0.15020201f, -0.17189257f, -0.10349245f, 0.02493019f, -0.08477147f, 
    0.26620859f, 0.31002679f, 0.21680519f, -0.02435096f, -0.13287540f, -0.03115188f, -0.06102829f, 0.01809275f, 
    0.16683738f, 0.16309297f, -0.03740858f, 0.09063006f, -0.05483691f, 0.15051779f, 0.10651147f, 0.18065858f, 
    0.03544774f, 0.03009242f, -0.06457788f, -0.05129346f, -0.21805885f, 0.03313909f, -0.03275049f, 0.01177151f, 
    0.04267135f, -0.00777128f, -0.13315350f, 0.27583569f, -0.02407701f, 0.07271655f, -0.20864135f, -0.02084844f, 
    0.20944710f, 0.00744354f, -0.07586997f, 0.09413415f, 0.09985022f, -0.00790409f, -0.31495166f, -0.05100901f, 
    -0.08636140f, -0.02001487f, 0.03855538f, 0.00809324f, 0.08782185f, -0.17949943f, 0.22255673f, 0.39726233f, 
    -0.05403220f, -0.10968706f, -0.09723180f, 0.11873085f, 0.09079589f, -0.04400693f, 0.09354480f, -0.03736001f, 
    0.23432383f, -0.12675820f, 0.10259796f, -0.03911950f, 0.10533722f, 0.06037826f, 0.05360679f, -0.64887166f, 
    -0.69793135f, -0.01675654f, -0.04864204f, -0.02797361f, -0.00411364f, -0.01459408f, -0.05424144f, 0.10994751f, 
    -0.23878005f, -0.05356409f, -0.05774777f, 0.03469823f, 0.00155152f, -0.01215523f, 0.10925414f, 0.07256046f, 
    -0.01934787f, 0.58511668f, 0.22362015f, -0.04564454f, 0.12934652f, 0.16403066f, -0.03789245f, -0.02554242f, 
    -0.02055945f, -0.00392645f, 0.28744510f, -0.06526114f, 0.39767107f, 0.00387477f, 0.01119110f, 0.12333921f, 
    -0.01872499f, -0.00083143f, 0.02420535f, -0.28779954f, 0.25442645f, -0.13075341f, 0.04562277f, -0.02137433f, 
    -0.26847810f, -0.07412444f, 0.29212388f, -0.14951591f, 0.00569366f, 0.20271634f, 0.23434310f, -0.03107897f, 
    -0.05731255f, 0.03738139f, -0.09382480f, 0.10065631f, 0.14850040f, -0.34574500f, -0.05599475f, -0.34344223f, 
    -0.25512683f, -0.36508751f, -0.14982271f, 0.13571237f, 0.09210230f, -0.13247165f, -0.40476888f, 0.13186227f, 
    -0.13246244f, 0.03607247f, 0.02728341f, -0.03120355f, 0.09486350f, 0.22994198f, 0.01969887f, -0.05303970f, 
    -0.04785675f, 0.22029930f, -0.07074367f, -0.03658939f, 0.10387683f, 0.05190123f, 0.05234832f, 0.08235495f, 
    -0.35317424f, 0.26423141f, -0.33949289f, -0.19119459f, -0.15559469f, -0.22031350f, 0.01439997f, -0.06706295f, 
    0.06776245f, -0.44993663f, -0.18757543f, -0.11173172f, -0.02059820f, -0.10481023f, -0.10692296f, -0.01713121f, 
    0.02982971f, 0.13071097f, 0.02416115f, -0.23314910f, 0.33355951f, 0.05525146f, 0.00457804f, 0.01778043f, 
    -0.07019572f, 0.10574862f, 0.15203632f, -0.16605359f, -0.07745377f, 0.06848879f, -0.03504056f, 0.06343141f, 
    -0.04165483f, 0.18332331f, -0.04146797f, 0.05728373f, 0.01112678f, 0.03209471f, 0.14337762f, 0.06142002f, 
    0.24380919f, -0.01018881f, 0.00648088f, -0.14505263f, 0.02897969f, -0.29997087f, 0.06706181f, 0.02606241f, 
    0.06742337f, 0.04975038f, -0.08560631f, -0.03657610f, 0.04715128f, 0.03787306f, -0.18032411f, 0.27166787f, 
    0.17252100f, 0.14135295f, 0.17486645f, 0.12478008f, 0.07648870f, -0.13496019f, -0.18930131f, 0.00038427f, 
    -0.22793807f, 0.28539079f, -0.04795970f, -0.23436610f, -0.12712173f, -0.02816639f, -0.06472535f, 0.06690594f, 
    0.09837238f, 0.19432245f, 0.35910630f, 0.05686172f, -0.03063114f, 0.07237758f, -0.15372765f, 0.00905211f, 
    0.17492025f, -0.03903871f, 0.06198263f, 0.20041114f, 0.07258687f, 0.04026835f, 0.07656519f, 0.07345557f, 
    -0.23466416f, -0.13961180f, -0.00407930f, 0.10947134f, 0.07542636f, -0.10163777f, 0.02540116f, -0.07348848f, 
    0.06457482f, 0.05128343f, 0.20929874f, 0.09465739f, -0.06583080f, 0.02253524f, 0.13497080f, 0.08676791f, 
    0.06974025f, 0.03479439f, 0.20910408f, -0.07085896f, -0.00195324f, -0.02130408f, -0.00561906f, -0.04014606f, 
    0.12308683f, 0.15745449f, 0.03417074f, 0.12296885f, -0.02354984f, -0.09389329f, -0.00076657f, 0.17457736f, 
    -0.13481228f, 0.06403228f, -0.03672240f, 0.14704935f, 0.06007206f, 0.05350797f, 0.12758629f, 0.16965662f, 
    0.15582259f, -0.10473990f, 0.05209871f, -0.05790592f, 0.06144393f, 0.05422694f, 0.15375932f, -0.17815632f, 
    0.12356871f, 0.06445791f, -0.10454687f, -0.12060259f, 0.05059065f, -0.05170469f, 0.12126244f, -0.15092964f, 
    -0.03816573f, 0.17523244f, 0.09385997f, -0.07685587f, 0.08249510f, 0.00057221f, -0.07791313f, -0.03170937f, 
    -0.05624088f, 0.03587036f, -0.16465746f, -0.10534479f, -0.23014057f, 0.03080118f, 0.13310029f, 0.08758424f, 
    0.06120383f, 0.12867351f, -0.10444009f, -0.18234333f, -0.11522104f, -0.10934458f, 0.11183430f, -0.04900457f, 
    -0.41361621f, 0.09199331f, -0.25317267f, -0.08313573f, -0.27578512f, -0.14384758f, -0.17501630f, -0.05580712f, 
    0.04893718f, -0.00881946f, 0.07426059f, 0.07137355f, -0.15718354f, 0.03737328f, 0.15287700f, -0.04121536f, 
    0.20370881f, -0.10031298f, 0.07679081f, 0.01596041f, -0.18473859f, -0.09939358f, 0.19772948f, -0.09097397f, 
    -0.10153487f, 0.17574222f, -0.04246797f, -0.03214904f, 0.11436393f, -0.10701745f, 0.17435874f, -0.10406625f, 
    -0.04852786f, 0.14816707f, 0.06549197f, -0.03109239f, 0.03625252f, -0.15603852f, -0.25576967f, -0.14345767f, 
    0.15539213f, -0.08901819f, 0.01853696f, 0.18809003f, -0.01588578f, 0.08757658f, 0.19666946f, -0.08515484f, 
    -0.31618521f, -0.26043284f, -0.03707111f, -0.10282491f, -0.05776482f, -0.02715534f, 0.09690321f, -0.11368892f, 
    -0.03639669f, -0.50720125f, -0.29132512f, 0.14919019f, 0.01734106f, -0.08380147f, -0.01446493f, 0.03372383f, 
    -0.12517144f, 0.02960066f, 0.12376513f, 0.10736614f, 0.08599856f, 0.02912277f, 0.09327728f, 0.16867208f, 
    0.10807890f, -0.02457647f, 0.13097385f, -0.12010258f, -0.27497733f, -0.22023404f, -0.10565004f, 0.17909947f, 
    -0.04426397f, 0.13537949f, -0.10978200f, -0.04228119f, -0.31872889f, 0.00971771f, -0.32543907f, -0.14112794f, 
    0.24069023f, 0.12877841f, 0.03185061f, 0.06924453f, 0.08406398f, -0.27293855f, -0.16352831f, -0.03157892f, 
    0.10530724f, -0.08123195f, -0.05395174f, 0.12143181f, 0.13738698f, -0.12705967f, -0.12080549f, -0.24992186f, 
    -0.11866228f, 0.03168844f, 0.05465458f, -0.10877205f, -0.05700665f, 0.00482447f, 0.14295441f, -0.10173561f, 
    0.12904586f, -0.23178142f, 0.04211478f, 0.04265158f, 0.01315970f, 0.05430586f, 0.08141755f, 0.02135397f, 
    -0.12184448f, -0.07624308f, -0.19910492f, -0.00410555f, -0.02295027f, 0.02458238f, 0.21782532f, 0.11965670f, 
    0.02696190f, 0.01878772f, -0.25949928f, -0.05863047f, 0.06203908f, 0.05199850f, 0.02021378f, -0.09044739f, 
    0.05308848f, 0.07845572f, 0.11257933f, 0.28955141f, 0.27299115f, -0.08169814f, -0.01955443f, 0.07475558f, 
    0.03947381f, 0.09608211f, 0.09633616f, -0.09726241f, -0.03694620f, -0.09309427f, 0.01605159f, -0.05786305f, 
    -0.02886919f, -0.04101695f, 0.09691412f, 0.07265395f, 0.20319812f, 0.06793723f, 0.11838972f, -0.00802630f, 
    0.20689736f, 0.12518097f, -0.04114686f, 0.09291536f, 0.09016201f, 0.03780938f, -0.26232579f, -0.24691422f, 
    0.10998268f, 0.12097900f, 0.06455075f, -0.00676586f, -0.06773070f, 0.18741615f, -0.10132416f, 0.14493161f, 
    0.04207986f, -0.11488835f, -0.03643025f, 0.10008240f, -0.06217239f, -0.01371931f, 0.00097207f, -0.12904511f, 
    0.18882911f, 0.20035008f, 0.03382551f, 0.09620907f, -0.13365099f, 0.17560074f, -0.07658099f, 0.06531963f, 
    -0.25282854f, 0.21213920f, 0.32839724f, -0.03213308f, 0.10068119f, 0.33533245f, -0.13146809f, 0.12190747f, 
    0.00780252f, -0.29405758f, -0.05203726f, 0.28658184f, 0.01378536f, 0.12115901f, 0.04341432f, -0.04453837f, 
    0.06982847f, 0.12860787f, -0.26790667f, 0.00280795f, 0.21783769f, 0.18445909f, -0.00193816f, -0.08687842f, 
    -0.00803193f, 0.22106652f, 0.03776471f, -0.03105161f, 0.14742996f, 0.21781348f, -0.08970834f, 0.17000456f, 
    0.04652893f, 0.04762991f, 0.11849174f, 0.15398607f, -0.04613275f, -0.09539315f, -0.22186670f, -0.01497603f, 
    0.13931519f, -0.18609732f, 0.13864546f, 0.11208802f, 0.05235871f, -0.38354787f, -0.14468104f, 0.01925058f, 
    -0.28935739f, -0.04446714f, -0.05683516f, 0.02208534f, 0.04537030f, 0.09190405f, -0.22577624f, -0.06894595f, 
    -0.10118345f, -0.08236659f, -0.10771211f, -0.25970644f, 0.08315318f, 0.04806779f, -0.04050902f, -0.37562978f, 
    -0.02988448f, 0.21372747f, -0.08609771f, 0.08185789f, 0.08411878f, -0.21983603f, 0.08270695f, 0.13133261f, 
    0.05334431f, 0.13059875f, 0.32042858f, -0.01958702f, 0.12695645f, 0.16848814f, -0.09419236f, 0.12855053f, 
    0.16407079f, 0.09931591f, -0.05986139f, 0.11238541f, -0.16021244f, 0.17159949f, 0.03127312f, 0.05859426f, 
    -0.00094357f, 0.07129089f, -0.12368571f, 0.03313186f, 0.10576954f, -0.14601594f, -0.09028676f, 0.05067318f, 
    -0.23756486f, -0.33535847f, -0.18948941f, 0.03291481f, -0.34249303f, -0.04521349f, 0.02018723f, -0.01781760f, 
    0.17202093f, 0.06950425f, -0.12112998f, -0.01198726f, -0.08872410f, -0.08372913f, 0.30876580f, -0.05291954f, 
    0.09381398f, 0.18266097f, -0.13269521f, 0.06666107f, 0.25247917f, -0.08452544f, 0.14343286f, -0.01035821f, 
    -0.08945803f, -0.00943823f, 0.05249889f, -0.07038622f, 0.04707897f, -0.00952592f, -0.09269461f, -0.08305394f, 
    0.20739707f, 0.11478467f, 0.28239512f, 0.03955971f, -0.03668744f, 0.12722024f, -0.00804317f, -0.22200558f, 
    -0.18237792f, -0.05281342f, -0.11900251f, 0.12719716f, -0.12661259f, 0.17979230f, -0.08157974f, 0.23674268f, 
    -0.10599570f, -0.05564316f, -0.09800044f, -0.12467516f, 0.00779334f, -0.12860623f, 0.09423068f, 0.10834834f, 
    -0.17570360f, -0.10344183f, -0.00405854f, 0.14310828f, 0.05972262f, 0.29962724f, -0.24386217f, -0.00971944f, 
    -0.11993065f, -0.03615615f, 0.30122945f, 0.19203463f, 0.35415721f, -0.04572022f, 0.04876057f, 0.09340055f, 
    0.06351583f, 0.11712527f, -0.02841782f, -0.06115478f, 0.17743638f, 0.05964263f, -0.09481804f, 0.01793959f, 
    -0.02274569f, 0.24799988f, 0.11184921f, 0.09536031f, 0.41481495f, 0.08582678f, 0.15460409f, 0.03091034f, 
    0.21612677f, 0.18856831f, 0.00738862f, 0.04710215f, -0.01076414f, -0.00159783f, -0.15637375f, -0.05351828f, 
    -0.24943174f, -0.02394934f, -0.11707788f, -0.01927297f, 0.10373268f, -0.13803117f, -0.06823709f, 0.05934953f, 
    -0.03415377f, -0.02316901f, 0.16806406f, 0.01837039f, 0.09326085f, -0.00368425f, -0.00389784f, 0.00057352f, 
    0.02757424f, -0.03915985f, 0.15189204f, 0.13088891f, 0.05827482f, 0.04770801f, 0.10369009f, 0.08615030f, 
    -0.05456171f, 0.00832961f, -0.12325200f, 0.04163427f, 0.07039461f, -0.19020066f, -0.00290162f, 0.24308170f, 
    0.06351787f, -0.14445706f, -0.08735048f, -0.14637822f, -0.07183713f, -0.00697206f, 0.01424134f, -0.06015563f, 
    0.10668960f, 0.07078710f, -0.18495789f, 0.06688056f, 0.05606163f, -0.02503378f, -0.02862285f, -0.08092242f, 
    0.11335067f, 0.02996508f, -0.00206643f, -0.01464413f, 0.00669341f, -0.04813456f, 0.12524821f, 0.05204016f, 
    0.11552256f, 0.10993893f, 0.20523530f, 0.03858197f, 0.03684589f, 0.06094956f, 0.05811755f, 0.12842311f, 
    0.06921513f, 0.23540604f, 0.16280475f, 0.17484938f, 0.08351379f, 0.10093898f, -0.03061396f, -0.02266788f, 
    -0.04467950f, 0.13198280f, 0.06142489f, 0.08089501f, 0.19322999f, 0.08787308f, -0.36963758f, 0.12304262f, 
    -0.16780204f, -0.14399204f, -0.20238952f, -0.18496525f, -0.13984063f, 0.01021065f, 0.02093067f, -0.23132049f, 
    -0.33284777f, 0.02574942f, -0.02491621f, -0.04986796f, -0.04736103f, 0.10194638f, 0.08043868f, 0.06654238f, 
    0.33373845f, 0.12300424f, 0.14059414f, 0.20100600f, 0.02234674f, 0.05261306f, 0.03184360f, -0.18442467f, 
    0.05333741f, 0.04203613f, 0.16312367f, -0.03211131f, -0.00322007f, 0.02053042f, 0.01906460f, -0.15454373f, 
    -0.23377706f, -0.19233146f, 0.11246307f, 0.18266630f, 0.14390682f, -0.00518191f, -0.08022153f, 0.01967589f, 
    0.09674083f, 0.06044923f, 0.02408688f, 0.12293476f, -0.00574950f, 0.05547891f, -0.00129822f, 0.06494263f, 
    0.08644645f, 0.03613051f, 0.11039387f, 0.09611602f, 0.00801423f, -0.02558158f, -0.03899812f, 0.21584360f, 
    0.06961860f, 0.04525432f, 0.05074459f, 0.05686459f, 0.19662185f, -0.29040405f, -0.01423807f, -0.20262414f, 
    0.04807400f, 0.06345385f, 0.02366194f, 0.10993018f, 0.16898121f, -0.05960302f, -0.00354439f, 0.08899206f, 
    -0.02737507f, -0.01441109f, -0.11341199f, -0.01722222f, 0.14821886f, 0.00181508f, 0.09053109f, 0.00230874f, 
    0.14396852f, 0.05625952f, -0.14157310f, -0.11693582f, -0.13694128f, -0.20856528f, 0.09137110f, 0.04906389f, 
    0.01259711f, -0.01637383f, 0.09881294f, -0.05644589f, -0.08252317f, -0.04684681f, -0.20466614f, -0.22091931f, 
    -0.04043472f, 0.29200336f, 0.12347324f, -0.04686890f, 0.05275219f, 0.04113217f, 0.06730650f, 0.07484497f, 
    -0.13806114f, 0.08836512f, -0.03473448f, -0.06352315f, -0.02791102f, -0.06122125f, -0.15488306f, 0.19291766f, 
    -0.11037943f, -0.32934549f, -0.36322495f, 0.18809652f, 0.06313172f, -0.06435014f, 0.01234073f, 0.05324174f, 
    0.12171248f, -0.05432758f, -0.12665701f, 0.00406381f, 0.08709668f, -0.08692837f, -0.00844956f, 0.14718850f, 
    0.04277553f, 0.10065641f, -0.10520648f, 0.03175509f, -0.19775067f, 0.01951656f, 0.18510824f, -0.29784644f, 
    0.07763557f, 0.00260311f, -0.14174245f, 0.09536043f, 0.02466915f, 0.07038289f, 0.07436360f, -0.02506149f, 
    -0.09885360f, 0.10909912f, -0.02770471f, 0.08036193f, -0.25247094f, -0.23652756f, -0.21009745f, -0.01131158f, 
    0.20382568f, -0.03913083f, -0.00187312f, 0.02681810f, 0.01884554f, 0.05804278f, 0.05641565f, -0.06319319f, 
    -0.10532570f, -0.04848702f, -0.07637770f, -0.05643674f, -0.00486969f, 0.06565726f, 0.17687458f, -0.08792505f, 
    -0.08729677f, -0.11174700f, 0.08042625f, 0.16723362f, 0.14449601f, 0.16927639f, 0.10397053f, -0.05345887f, 
    -0.04258722f, -0.32354480f, 0.10243133f, 0.25506482f, 0.05947205f, -0.10189052f, 0.11439108f, -0.04868921f, 
    -0.12981649f, 0.16169800f, -0.03125517f, -0.05060253f, 0.04355165f, -0.12594803f, 0.00011656f, 0.11434887f, 
    -0.05514548f, 0.20621461f, 0.08597293f, -0.10009842f, 0.07532253f, 0.02805301f, 0.01826643f, 0.24108794f, 
    0.03714025f, 0.06064496f, 0.16486694f, -0.14167561f, 0.09146770f, -0.05950451f, -0.11244522f, 0.05555858f, 
    0.03346010f, 0.02021399f, -0.05523013f, 0.21662526f, -0.00505016f, -0.03433502f, 0.04817241f, 0.04991903f, 
    0.11452173f, 0.11987005f, 0.06056833f, -0.00885529f, -0.07615289f, -0.00442922f, 0.10546716f, -0.00549659f, 
    0.03598274f, -0.00422109f, 0.20234291f, 0.14645573f, -0.12277009f, -0.03690087f, 0.05376935f, -0.08245436f, 
    -0.09881812f, -0.15436797f, -0.07462358f, 0.17639594f, 0.07386874f, 0.04781345f, 0.11956517f, 0.03521725f, 
    0.07948811f, 0.11958837f, -0.04575796f, 0.12006865f, 0.02637954f, -0.03300805f, 0.06351833f, -0.07305034f, 
    0.04657039f, 0.11857679f, 0.06890196f, 0.17352775f, 0.01565422f, -0.22377227f, -0.04035068f, 0.05254023f, 
    0.06892212f, 0.10202390f, -0.09195916f, 0.05382912f, 0.07619636f, 0.03902277f, 0.11777860f, -0.04722292f, 
    -0.07908407f, 0.03779259f, -0.09166471f, 0.06982259f, -0.05434733f, -0.03178767f, 0.12579392f, 0.04456308f, 
    0.07162471f, 0.10850027f, 0.04669597f, 0.06435778f, 0.02705348f, -0.04788542f, 0.01925643f, 0.12810494f, 
    0.05543774f, -0.04498149f, 0.00427605f, -0.16126393f, -0.07654724f, 0.04655866f, -0.19971591f, -0.07613581f, 
    -0.15793513f, -0.02567794f, -0.08847400f, -0.07755145f, -0.01475962f, -0.21248348f, 0.02150812f, 0.09680239f, 
    0.02611849f, -0.15325950f, 0.02141520f, 0.06996509f, -0.05814319f, 0.08833180f, 0.02431495f, 0.11738326f, 
    0.00823023f, 0.02075567f, -0.06029873f, 0.04191038f, -0.03257565f, 0.01739433f, 0.02798296f, 0.02923383f, 
    -0.04248572f, 0.04633514f, -0.02543391f, 0.02457946f, 0.05241055f, -0.06096183f, -0.00565866f, -0.03663047f, 
    -0.01876935f, -0.03514434f, -0.01958481f, -0.02208814f, 0.01226556f, 0.04547387f, -0.00602456f, 0.01070188f, 
    -0.00175073f, 0.02273714f, 0.00656418f, -0.00480495f, -0.06367758f, -0.02553532f, -0.00573733f, 0.00157064f, 
    -0.01796062f, -0.01875180f, 0.01106027f, -0.01953011f, 0.04827680f, -0.05750133f, -0.04537378f, -0.05635853f, 
    -0.04397693f, 0.03213619f, 0.03632195f, 0.02351913f, 0.04358884f, 0.00342533f, -0.00894779f, 0.03857055f, 
    0.03957010f, 0.02169230f, 0.00778964f, -0.02362332f, -0.01006080f, -0.03535191f, 0.02423313f, 0.04803320f, 
    -0.01778721f, -0.05525852f, 0.03589353f, 0.03267353f, 0.03591430f, -0.01449422f, -0.03530077f, 0.01529391f, 
    -0.00780626f, -0.06018890f, 0.00598827f, -0.04194720f, -0.02683600f, -0.01176249f, 0.03188045f, -0.01892959f, 
    -0.01528714f, 0.00617092f, -0.04562197f, 0.04060009f, -0.05465794f, -0.04639569f, 0.00070027f, 0.01881115f, 
    0.02663373f, -0.05813392f, -0.00918607f, -0.02698492f, -0.03624099f, -0.04501149f, 0.02853797f, 0.02961115f, 
    -0.00246405f, -0.04657309f, -0.04366220f, -0.02810829f, -0.02468688f, -0.00229803f, 0.03338297f, -0.04710188f, 
    -0.02822473f, 0.04307895f, 0.02096105f, -0.05535318f, -0.01471836f, -0.05126497f, 0.04898988f, 0.00485690f, 
    -0.00775903f, -0.05766113f, -0.00693699f, -0.03672235f, -0.02475875f, -0.06214052f, 0.04785447f, -0.03261868f, 
    0.02349187f, 0.04814297f, -0.05699441f, -0.03141797f, 0.05733412f, -0.02315051f, -0.04511720f, 0.05314530f, 
    0.02119553f, 0.04143464f, -0.01217561f, 0.01552115f, -0.00923045f, 0.01901316f, -0.02306159f, -0.06216161f, 
    -0.04482897f, 0.02577625f, 0.00466895f, -0.04968733f, 0.03676121f, 0.03361857f, -0.01051833f, -0.01500705f, 
    -0.05013816f, -0.01891478f, 0.04847401f, 0.03073503f, 0.02350656f, -0.03012082f, 0.02657714f, 0.00304546f, 
    -0.03150542f, -0.00231211f, 0.03211494f, -0.03126597f, 0.01194619f, 0.03639895f, -0.00929514f, 0.04707784f, 
    0.01504332f, -0.00333748f, -0.01751568f, 0.04193682f, -0.03531472f, -0.00758124f, -0.01990742f, 0.03324968f, 
    0.03679022f, -0.01088986f, -0.02875940f, -0.00642423f, -0.00007147f, -0.06249428f, -0.03784673f, 0.01292594f, 
    -0.06366814f, -0.04651971f, -0.01339873f, -0.03535785f, -0.05021578f, -0.05013671f, -0.05787268f, -0.05887276f, 
    0.01049065f, -0.00656568f, -0.00316433f, 0.01751724f, 0.04090643f, 0.03841887f, -0.02219782f, -0.04162775f, 
    0.03108487f, -0.05344938f, -0.03441061f, 0.02430620f, -0.04163477f, -0.04925312f, 0.03229021f, -0.05541185f, 
    -0.02391533f, 0.01706619f, 0.00505185f, -0.02251297f, 0.05309409f, -0.05278167f, 0.02248445f, -0.01494130f, 
    -0.00272318f, -0.01833688f, 0.02723930f, -0.05395009f, -0.00341671f, -0.04947466f, 0.02635579f, -0.02256864f, 
    0.01065853f, -0.05432241f, -0.02212914f, 0.02964965f, -0.05003254f, 0.03921531f, -0.05019057f, 0.01905034f, 
    0.02467589f, -0.03036602f, -0.04500766f, 0.01726541f, 0.03619668f, -0.05630250f, -0.03158199f, 0.00886137f, 
    -0.03231190f, -0.00270787f, 0.00155881f, -0.01935635f, 0.03163560f, -0.05465505f, -0.05102853f, 0.02199302f, 
    -0.02102303f, 0.00602336f, -0.01972841f, 0.01199362f, 0.04367821f, -0.06324384f, 0.03720959f, -0.06171935f, 
    -0.01370624f, -0.03759532f, -0.00135537f, 0.03900654f, -0.02456188f, -0.00895939f, -0.03869961f, -0.05877107f, 
    -0.03262859f, 0.01306978f, 0.03566113f, -0.02216242f, 0.00114173f, 0.03562410f, -0.03755563f, -0.05756210f, 
    -0.02766707f, -0.05073422f, 0.03658582f, -0.02696472f, -0.03298984f, -0.04336711f, -0.05596781f, 0.01582682f, 
    -0.01881605f, 0.05319572f, 0.00809803f, -0.00065850f, 0.03207287f, -0.00794732f, 0.02050637f, 0.01938269f, 
    0.03530841f, -0.01751722f, 0.04886710f, -0.06213892f, 0.03299275f, -0.00637411f, 0.05147805f, -0.03464268f, 
    0.01024877f, -0.02150064f, -0.04585487f, -0.05267036f, 0.00249821f, -0.02849720f, -0.02034004f, -0.04037711f, 
    0.01553035f, -0.15443408f, -0.21449105f, -0.14594169f, -0.07411089f, 0.09594872f, 0.11108440f, -0.06272063f, 
    -0.01110314f, -0.27847597f, -0.52694935f, -0.00468142f, 0.06973257f, 0.00986126f, -0.02227767f, 0.21504180f, 
    -0.02801670f, 0.06177771f, 0.11003219f, -0.08619951f, 0.16275877f, -0.11863238f, -0.03226826f, 0.09535987f, 
    0.14249167f, -0.10194896f, -0.03180759f, 0.12995675f, -0.63388234f, -0.14573456f, 0.13186494f, 0.16531916f, 
    0.02123870f, 0.19764155f, -0.07047037f, 0.11878265f, 0.00480045f, -0.06356820f, -0.11791918f, 0.05189440f, 
    0.01380250f, 0.09033020f, -0.00066384f, -0.03687875f, -0.10006011f, -0.50895625f, 0.33876020f, 0.50142479f, 
    -0.01965026f, 0.02287477f, -0.10049456f, -0.11275415f, 0.00598574f, -0.04513865f, 0.04855898f, 0.13121782f, 
    -0.09712874f, 0.04769310f, 0.04160870f, 0.11777726f, -0.06446438f, -0.08901764f, -0.11031111f, -0.42746329f, 
    -0.03382014f, -0.24741903f, -0.09953307f, -0.11506362f, -0.04296150f, 0.05777561f, 0.04463860f, 0.02709801f, 
    -0.49400771f, -0.10556479f, 0.24467200f, 0.07346797f, -0.12087502f, -0.08943197f, 0.03175669f, 0.12428065f, 
    0.06918892f, 0.17218786f, 0.22567375f, 0.04622772f, -0.15443569f, -0.01539542f, 0.25630885f, 0.13032919f, 
    0.05308273f, -0.13805848f, 0.14553845f, 0.13191237f, 0.06566425f, -0.13484752f, 0.10508706f, 0.03082817f, 
    0.11195155f, -0.07110319f, 0.22053380f, 0.13904180f, 0.16465288f, 0.01631678f, -0.26772898f, -0.11028235f, 
    0.08769397f, 0.10341837f, 0.03593749f, -0.11466327f, -0.28519592f, -0.35262343f, -0.39520749f, -0.04615401f, 
    0.12583405f, -0.08524752f, -0.18903363f, -0.00278265f, -0.05923530f, -0.32089317f, -0.16510549f, 0.00173386f, 
    -0.06210448f, 0.00476356f, -0.16445738f, 0.09438381f, -0.01731352f, 0.11307227f, 0.02232464f, -0.26006213f, 
    -0.04970130f, 0.16918850f, 0.12817131f, 0.05883795f, 0.14580563f, -0.12795553f, -0.04293535f, -0.51539648f, 
    -0.10147167f, 0.15419079f, -0.02768709f, -0.04852596f, -0.05541714f, -0.01151311f, -0.02694694f, 0.00920539f, 
    0.17502639f, 0.07134000f, 0.03828933f, 0.11665799f, 0.03900801f, -0.08258437f, 0.09355135f, -0.00850654f, 
    0.22046101f, 0.06066445f, -0.06393717f, 0.17709854f, 0.00158812f, 0.01439924f, -0.04350809f, 0.28727713f, 
    0.09393596f, -0.01691885f, 0.36548316f, 0.19281846f, 0.17422841f, 0.19090019f, 0.03849553f, 0.17124966f, 
    0.14204720f, 0.06102338f, -0.08397072f, 0.01322613f, -0.07370508f, 0.13518856f, 0.08001545f, 0.06801598f, 
    -0.01277226f, 0.13505735f, 0.19685404f, 0.24343418f, 0.31310052f, 0.14155281f, 0.04035798f, 0.19587095f, 
    -0.25663078f, 0.17116544f, 0.01142142f, -0.03864960f, -0.02162353f, 0.18727744f, -0.03367372f, -0.02565744f, 
    -0.00536593f, -0.05165214f, -0.10289937f, 0.05444579f, 0.06517734f, 0.12589820f, 0.09255998f, -0.00869180f, 
    0.02626477f, 0.09587868f, 0.24727960f, 0.05667657f, 0.00051528f, -0.01279239f, 0.11582582f, 0.12885424f, 
    0.07147939f, 0.12198263f, -0.09025006f, -0.16646098f, 0.04446964f, 0.04398736f, 0.08047013f, 0.09852253f, 
    0.27389413f, 0.04189855f, 0.07855587f, 0.10962869f, -0.06241988f, 0.00880339f, -0.08829052f, 0.10227191f, 
    0.06818602f, 0.21730570f, -0.23589802f, -0.16432290f, -0.00830588f, 0.01936991f, -0.10681333f, 0.06661844f, 
    0.17636117f, 0.02960995f, -0.33967546f, -0.11024976f, -0.01755143f, -0.06953540f, 0.07549519f, -0.04916822f, 
    0.09494457f, -0.18156752f, 0.07986954f, 0.20306723f, 0.09399286f, 0.01928754f, -0.10516119f, 0.05083401f, 
    0.07632718f, 0.07815512f, 0.05759926f, -0.02660939f, -0.08083567f, -0.47317570f, -0.63353866f, -0.00907645f, 
    0.03928699f, 0.10527851f, 0.17939690f, 0.00690929f, -0.01878058f, 0.21836425f, -0.10859306f, -0.07718771f, 
    0.05163058f, 0.12116375f, 0.04869019f, 0.12197168f, -0.02994467f, -0.01275499f, -0.20778674f, -0.25480920f, 
    -0.18633185f, -0.13616884f, -0.34470198f, -0.23803507f, -0.04635034f, 0.15573865f, 0.11261234f, -0.21502993f, 
    -0.14580503f, -0.30946133f, 0.05467997f, 0.00830397f, -0.02017036f, -0.00473141f, -0.07950322f, -0.01092004f, 
    0.05450006f, 0.34641293f, 0.06275140f, -0.14114690f, -0.16248843f, 0.11413026f, -0.24867421f, 0.22731011f, 
    0.13155122f, -0.07914404f, 0.01495149f, -0.11335737f, 0.05840301f, -0.11089302f, 0.01994962f, 0.01550294f, 
    -0.06847307f, 0.05956629f, -0.00871296f, -0.05204033f, 0.19864105f, 0.02675237f, 0.03083602f, 0.05570063f, 
    -0.00686446f, 0.20310771f, 0.14557943f, -0.16345079f, 0.15791786f, 0.29942274f, -0.00102272f, 0.11835184f, 
    -0.08204692f, 0.01864843f, 0.12911545f, 0.10695297f, -0.03579727f, -0.07957267f, 0.09539434f, 0.06911473f, 
    -0.00245174f, 0.02785090f, 0.15423678f, 0.02774043f, 0.14747161f, -0.22871847f, -0.33120960f, 0.13682383f, 
    -0.22154699f, 0.01760531f, -0.11807972f, 0.15007080f, -0.00088941f, 0.11357372f, -0.18397404f, -0.07471842f, 
    -0.14035301f, -0.12784171f, -0.02204278f, 0.08142877f, 0.20086817f, 0.09076037f, 0.01627450f, -0.21590810f, 
    -0.16669275f, 0.01390718f, -0.09398545f, -0.07063565f, -0.04542033f, -0.16379578f, 0.03876644f, -0.06221743f, 
    -0.09603799f, 0.06052931f, -0.15260093f, -0.01780366f, 0.16787048f, -0.12605016f, -0.07711168f, 0.00297627f, 
    -0.15363117f, 0.02609326f, -0.19161651f, 0.12253160f, -0.10098276f, 0.06737921f, -0.12803252f, 0.01657468f, 
    0.04890179f, 0.19120546f, 0.04706718f, 0.20214006f, 0.10552230f, 0.06072746f, -0.01184925f, -0.05001269f, 
    -0.04146192f, -0.03304267f, 0.01569370f, 0.20291300f, -0.05648567f, 0.04993790f, 0.11044917f, 0.16207445f, 
    -0.02195593f, -0.11373288f, -0.23021431f, 0.03464833f, -0.15740153f, -0.06462089f, 0.07911288f, 0.06874505f, 
    -0.08411339f, 0.01567551f, 0.01228833f, 0.04067538f, -0.07896654f, -0.08059341f, -0.21906888f, -0.19583029f, 
    -0.03957033f, 0.21645847f, -0.26382971f, 0.03255342f, -0.09024984f, -0.07722481f, 0.08256080f, 0.15961020f, 
    0.12153664f, 0.01540754f, -0.05813131f, -0.04525455f, -0.00766493f, -0.17756435f, 0.10789122f, -0.02435895f, 
    0.24598019f, -0.05532769f, -0.00991254f, 0.07523663f, 0.09246611f, 0.13225071f, 0.04326298f, 0.22066885f, 
    -0.10552865f, 0.00770996f, -0.05021424f, -0.06981114f, -0.06719378f, -0.08791893f, 0.01096324f, 0.11518945f, 
    -0.00593981f, -0.05687391f, 0.12933856f, 0.13259894f, 0.05926926f, 0.25928789f, 0.02450665f, -0.22385594f, 
    0.02397630f, -0.04382237f, 0.05274409f, 0.12619874f, 0.16384169f, -0.01929326f, 0.10912984f, -0.09165230f, 
    0.00387735f, 0.03244336f, 0.08813652f, -0.15726678f, 0.02781795f, 0.02007683f, -0.14274253f, -0.00733892f, 
    -0.00747741f, 0.12353619f, 0.00409923f, 0.13264380f, 0.18068692f, 0.15466064f, -0.04263016f, 0.18026626f, 
    0.03332585f, -0.04889546f, -0.22177377f, 0.05318695f, -0.18505052f, 0.04977022f, -0.08255634f, 0.05183858f, 
    -0.12631059f, -0.03630671f, -0.16052242f, 0.00233464f, -0.02951913f, -0.06754177f, -0.18932037f, 0.01583334f, 
    0.16382596f, -0.05174659f, -0.01805391f, -0.07407484f, 0.02927989f, 0.03817653f, 0.14088859f, 0.08063467f, 
    -0.05159530f, -0.04057184f, 0.02798967f, 0.16474263f, 0.03013071f, -0.13225448f, 0.11275695f, -0.03960545f, 
    -0.00340576f, -0.00199324f, -0.05713147f, 0.04992419f, -0.07449100f, 0.03932432f, -0.12706989f, 0.10829811f, 
    0.06087734f, -0.12217760f, -0.18842113f, 0.16428693f, 0.03643729f, -0.12353908f, 0.14020242f, -0.01336114f, 
    0.05845107f, -0.01872236f, -0.08369779f, 0.09591246f, -0.17443977f, -0.01963245f, -0.11347629f, -0.02205420f, 
    0.11141837f, 0.08009861f, 0.11455275f, 0.02301387f, -0.09927193f, 0.15590896f, -0.08370013f, -0.01991820f, 
    0.16649945f, 0.01617801f, 0.09091296f, 0.23099978f, -0.10711665f, 0.25986505f, 0.21411802f, 0.13686918f, 
    -0.04753518f, -0.01718805f, 0.09997355f, 0.18098830f, 0.24106364f, 0.09301373f, -0.03900893f, 0.00825122f, 
    0.01073650f, 0.00519725f, 0.12572783f, -0.05562647f, 0.05711235f, -0.07328575f, -0.07515143f, -0.02827074f, 
    -0.25752845f, 0.05822003f, 0.08659718f, -0.08165789f, -0.03536070f, -0.26496375f, -0.06973048f, -0.16695628f, 
    -0.06777420f, 0.02408927f, -0.10618915f, -0.14643189f, -0.17135657f, 0.10604081f, -0.00134010f, 0.20594993f, 
    0.01668189f, 0.01482505f, 0.00413587f, 0.01874672f, -0.02250081f, -0.02736489f, 0.04591870f, -0.01469735f, 
    -0.04640782f, 0.04580293f, 0.04537182f, -0.05568032f, -0.04529089f, -0.01740237f, 0.00106549f, 0.04198187f, 
    0.00844632f, -0.04906088f, 0.03025232f, -0.03971969f, 0.03599341f, -0.06109942f, 0.04596523f, 0.04466792f, 
    0.04176310f, -0.03430193f, -0.01442501f, -0.02932230f, 0.01142933f, -0.01762242f, 0.02763065f, 0.02517400f, 
    -0.04794114f, -0.04662409f, -0.05281553f, 0.03295960f, -0.05647989f, -0.03618099f, -0.05892756f, 0.03434431f, 
    -0.03155970f, 0.01995089f, 0.01843331f, -0.04073872f, -0.01347685f, -0.00106546f, 0.05894552f, -0.05439810f, 
    -0.04338240f, -0.01476857f, 0.02663428f, 0.01185085f, -0.02783697f, -0.05878408f, 0.00882108f, -0.01622635f, 
    -0.05253678f, -0.05438012f, 0.04466331f, 0.03899978f, 0.00893123f, 0.03435186f, -0.01896757f, -0.02565453f, 
    0.00606188f, -0.04075709f, -0.03857175f, -0.06400141f, -0.04728555f, 0.04925593f, -0.04961207f, -0.04453940f, 
    -0.03804731f, 0.01831285f, -0.02691117f, -0.06414691f, -0.05417109f, -0.05126684f, 0.01818006f, 0.00522124f, 
    -0.03999673f, 0.00298027f, -0.01691137f, 0.01968517f, -0.05749815f, -0.01980092f, 0.01783803f, -0.03524659f, 
    -0.05145327f, -0.05643320f, -0.04749621f, -0.05672555f, -0.00013362f, 0.02083884f, -0.01650471f, -0.01660496f, 
    0.04045652f, -0.02214171f, 0.00753119f, -0.02929333f, 0.04566547f, -0.00356981f, 0.04894785f, 0.02286101f, 
    -0.03444134f, -0.05447207f, 0.02334339f, 0.04118262f, -0.00505039f, 0.00182383f, 0.02930906f, -0.00668597f, 
    0.02905532f, -0.03265269f, -0.02765536f, -0.02492417f, -0.03092642f, -0.01199477f, 0.01634170f, -0.00344320f, 
    -0.00617053f, -0.03524100f, -0.03615614f, 0.00583835f, -0.03588054f, -0.04637604f, -0.05987577f, 0.01710985f, 
    -0.01326234f, 0.02832995f, 0.02750024f, -0.00500688f, -0.00706781f, -0.03894855f, -0.00236792f, -0.02021386f, 
    0.01030256f, -0.05164815f, -0.00322961f, -0.04392473f, -0.03281830f, 0.02708243f, 0.02493852f, -0.05144593f, 
    -0.02907620f, 0.03542578f, -0.01526110f, -0.05380353f, -0.05650499f, 0.03461976f, -0.06156759f, 0.03702958f, 
    0.05236742f, 0.01572588f, -0.06151241f, -0.05903354f, -0.00614768f, -0.04651939f, -0.06187372f, 0.04643230f, 
    0.03741696f, 0.00956713f, 0.04423376f, -0.04323612f, -0.00035296f, 0.04065315f, -0.02465420f, 0.00606057f, 
    0.01884859f, -0.04791236f, -0.00230890f, 0.03408114f, 0.01152998f, -0.00296707f, 0.02552523f, -0.05940765f, 
    -0.01614106f, -0.00074980f, 0.00247842f, 0.05235536f, -0.02028096f, -0.01286484f, -0.02679189f, 0.01343518f, 
    -0.03419413f, 0.00995474f, -0.01498906f, -0.00654895f, 0.00944245f, -0.06132522f, -0.00067393f, 0.03673394f, 
    0.03996599f, -0.03486940f, 0.03335107f, -0.01626355f, -0.02375604f, 0.03247609f, -0.06052474f, 0.03097930f, 
    -0.05302642f, 0.02335787f, 0.01274286f, -0.01810083f, -0.04142411f, -0.01043396f, 0.02859313f, -0.03625800f, 
    0.04737360f, 0.02213536f, -0.01458525f, -0.04657444f, -0.02709532f, 0.02567683f, -0.02986361f, -0.02479552f, 
    0.03632564f, -0.02751176f, -0.04425088f, -0.02573075f, 0.01513204f, -0.03489332f, -0.03818453f, 0.02424117f, 
    -0.01189255f, -0.02550831f, 0.02250857f, -0.05423897f, 0.00585535f, 0.02323800f, -0.01196731f, 0.03360548f, 
    -0.03555458f, -0.04774496f, -0.04473542f, -0.00998990f, 0.04784822f, -0.03332828f, -0.01615423f, -0.00115292f, 
    0.02653014f, -0.00426816f, -0.05801749f, -0.04006095f, -0.03499220f, -0.04875942f, -0.04169787f, -0.05033849f, 
    0.00808617f, -0.06185526f, 0.04177887f, -0.00728367f, -0.05609703f, 0.03392682f, 0.04734404f, -0.03444653f, 
    0.02858659f, 0.01619450f, 0.01884845f, 0.04668364f, -0.03938704f, 0.01025468f, -0.04282695f, -0.00785637f, 
    0.03392861f, -0.03658035f, -0.06449390f, 0.03810319f, 0.00491040f, -0.02305363f, 0.03462753f, -0.02350504f, 
    -0.01055149f, -0.03467951f, 0.02984100f, 0.01475094f, -0.06026328f, -0.03120445f, -0.02285526f, -0.02021585f, 
    0.02632428f, 0.00334549f, 0.02938432f, 0.02435781f, -0.06407110f, 0.01633635f, 0.04445651f, -0.01136709f, 
    -0.04663595f, -0.22565517f, -0.25030443f, 0.03095126f, 0.01943051f, -0.23205055f, -0.04843048f, 0.02845504f, 
    0.12851559f, 0.24128304f, 0.20185384f, 0.18875371f, -0.12781624f, 0.01142916f, 0.04988367f, 0.00526279f, 
    0.03219654f, -0.03961880f, 0.30597359f, -0.26205325f, -0.04474951f, -0.10686110f, -0.15565634f, -0.18179804f, 
    -0.07617346f, -0.16341442f, -0.09257282f, -0.25975522f, 0.17693715f, 0.21276721f, 0.05292591f, 0.00729270f, 
    0.00673552f, 0.02540876f, -0.10092312f, -0.04018616f, -0.01647778f, 0.14290781f, 0.03583980f, -0.09069647f, 
    -0.01533953f, 0.11454634f, -0.05603977f, -0.12175589f, -0.27735794f, 0.17150430f, 0.03690517f, -0.03277681f, 
    0.19111593f, 0.04608003f, -0.11184192f, 0.20781323f, 0.00146262f, -0.10602402f, 0.20435636f, 0.08315080f, 
    0.19848183f, -0.07073532f, -0.01092511f, 0.10270072f, 0.01177594f, -0.09795956f, -0.07479621f, 0.03614992f, 
    0.07180208f, 0.13065061f, 0.07348633f, 0.01983587f, -0.07690200f, 0.11204700f, 0.02464714f, -0.10001962f, 
    0.16427818f, 0.04029877f, 0.17354503f, 0.03984218f, 0.10061011f, -0.06587751f, 0.03858030f, 0.03957224f, 
    0.04539785f, -0.05580872f, 0.19718739f, -0.10530903f, -0.08295897f, -0.04185861f, 0.07970045f, 0.07036912f, 
    0.09424172f, -0.12617040f, -0.28653485f, 0.06328443f, -0.21459323f, 0.04479286f, -0.11117583f, -0.19218177f, 
    0.04145044f, 0.06993619f, -0.01427246f, 0.04549088f, 0.20119996f, -0.16264416f, -0.02635996f, -0.14860973f, 
    -0.13740933f, -0.02629575f, -0.03848579f, 0.13023764f, 0.31281352f, 0.15032509f, -0.29422203f, 0.10288244f, 
    0.03174791f, -0.15802276f, 0.06667301f, -0.04715096f, -0.26222941f, -0.04524600f, 0.40279621f, 0.19785973f, 
    -0.07331344f, -0.00851079f, 0.08009859f, 0.06433337f, 0.00112961f, 0.03791630f, -0.03913053f, 0.22485538f, 
    0.07215764f, -0.07512767f, 0.22123849f, 0.04390256f, 0.00882555f, 0.03374646f, -0.16039999f, -0.07912990f, 
    0.11252181f, 0.16492699f, -0.06896880f, -0.12849240f, -0.07252335f, -0.24262454f, -0.01648543f, -0.11026725f, 
    -0.16115980f, -0.10379962f, 0.06674221f, 0.15912555f, -0.11951348f, -0.15131718f, -0.07618205f, -0.04448495f, 
    0.18728159f, 0.32758805f, 0.10376944f, 0.09754005f, -0.19224213f, 0.04022248f, 0.15117100f, 0.07591510f, 
    0.06979658f, 0.16526636f, -0.12688743f, 0.19857582f, 0.02384955f, -0.08421887f, 0.21553834f, 0.06537052f, 
    0.06589663f, 0.12382638f, -0.04105190f, -0.17862424f, 0.08134244f, -0.19508147f, -0.22721742f, 0.17446499f, 
    0.08084723f, -0.20275031f, 0.31780756f, -0.39801276f, -0.00988662f, -0.16026989f, -0.09587858f, -0.01046799f, 
    -0.03064603f, -0.08506299f, 0.16730428f, 0.01850769f, 0.01633761f, -0.07682294f, -0.11267029f, 0.37644407f, 
    0.09506454f, -0.07627392f, -0.23215765f, 0.04772486f, -0.08009730f, 0.19728504f, -0.27413309f, -0.12970074f, 
    -0.13258207f, -0.05798296f, -0.13463226f, -0.06233067f, 0.03282210f, 0.21845891f, -0.01105585f, 0.07864950f, 
    0.12616751f, -0.05688186f, -0.13839416f, -0.04302600f, -0.19367431f, -0.05136057f, -0.10499325f, 0.17546917f, 
    0.07043581f, -0.28924748f, 0.02299256f, -0.02982592f, -0.06215231f, -0.08395089f, -0.05262577f, -0.07690306f, 
    -0.05512126f, -0.08479783f, -0.05057227f, -0.12551726f, 0.15104662f, -0.20187134f, -0.03722318f, 0.08842739f, 
    0.05139589f, 0.08804851f, 0.15140407f, -0.02253532f, 0.19623986f, 0.07133467f, 0.00401325f, 0.01579484f, 
    -0.01853605f, -0.20691240f, 0.03253898f, 0.03681442f, -0.14161959f, -0.31272390f, -0.20600846f, 0.03605615f, 
    0.04282214f, 0.03050401f, -0.04648297f, 0.07651981f, 0.12112838f, 0.22696082f, -0.09090191f, -0.01176823f, 
    -0.09188101f, 0.10364371f, -0.02603375f, -0.00404067f, 0.01376890f, -0.14505145f, -0.04394965f, 0.14168420f, 
    0.00515259f, -0.11806556f, 0.09468609f, -0.00645312f, 0.03468072f, -0.02410123f, 0.04269426f, 0.18483613f, 
    0.13647626f, 0.15053578f, 0.05363817f, 0.05393854f, 0.01000718f, 0.12394480f, 0.01423599f, 0.11779926f, 
    0.15187596f, 0.25288570f, 0.01968329f, 0.06729990f, 0.03960869f, 0.03953095f, -0.11776872f, -0.09811503f, 
    0.15532474f, -0.11211657f, -0.26044670f, 0.01394773f, 0.02059570f, 0.16773303f, -0.15445460f, 0.01980573f, 
    0.12980166f, -0.09624355f, 0.13169271f, 0.22006276f, -0.01266253f, -0.11240257f, -0.13012235f, 0.08410560f, 
    -0.05631008f, -0.12482860f, 0.12359711f, -0.03357788f, -0.06672291f, 0.05996693f, -0.07037053f, 0.10348962f, 
    -0.00056414f, 0.01749402f, -0.05968501f, -0.07481473f, -0.01133844f, 0.20836651f, -0.11165604f, -0.17562383f, 
    0.08144032f, 0.03415274f, -0.06675227f, -0.00554634f, 0.12538722f, 0.04103941f, 0.10370155f, 0.00598520f, 
    -0.00964964f, -0.22587611f, -0.18775095f, 0.01688291f, -0.33607554f, 0.10003590f, -0.32246226f, -0.09491689f, 
    0.36433133f, -0.00117730f, -0.08676180f, 0.18531410f, 0.04919566f, 0.05180060f, 0.13406868f, -0.01669065f, 
    0.29168314f, -0.06698103f, 0.04433150f, 0.00239039f, -0.01344765f, 0.05685232f, -0.10021790f, -0.12128905f, 
    0.00549657f, -0.04780143f, -0.07314519f, 0.02025230f, 0.02167646f, 0.08408768f, 0.08178497f, 0.05443159f, 
    -0.04613607f, 0.06578430f, 0.10484207f, 0.01148411f, 0.08794594f, -0.04100306f, -0.13818979f, 0.06586315f, 
    0.07729440f, -0.21069910f, -0.05519035f, -0.04921017f, 0.07519058f, 0.02233113f, 0.00674714f, 0.13175526f, 
    0.01119132f, 0.05800421f, -0.05711517f, 0.13827762f, -0.29103372f, 0.08886324f, 0.01698695f, 0.03436764f, 
    0.00577937f, 0.11477143f, -0.08228381f, -0.18545789f, 0.02657657f, -0.23294108f, 0.19881271f, -0.08154013f, 
    0.03714317f, -0.01056318f, 0.19363154f, -0.02851170f, 0.16056056f, -0.12785608f, 0.10593157f, 0.10237265f, 
    0.15578824f, -0.16400701f, -0.02381681f, 0.04188822f, -0.20549214f, -0.51484269f, 0.07543322f, 0.16075243f, 
    0.15831998f, 0.01100515f, 0.14675185f, 0.06712548f, -0.07417063f, 0.17716764f, 0.14134848f, 0.15361775f, 
    0.19958472f, 0.02882118f, 0.15116994f, -0.06500406f, -0.04473778f, -0.11616738f, -0.08469236f, 0.09599021f, 
    0.04678523f, -0.15475987f, -0.01718207f, 0.03733796f, 0.06135139f, -0.08690566f, -0.02729681f, 0.03538405f, 
    0.09277380f, -0.15472236f, -0.03464846f, 0.11509757f, 0.01252976f, -0.09372760f, 0.09145668f, -0.14109768f, 
    0.11601865f, -0.12669027f, 0.02014798f, 0.19787897f, 0.15114544f, -0.01567847f, -0.08959311f, 0.17137414f, 
    -0.09211572f, 0.19290228f, 0.05747255f, 0.21300051f, -0.02665294f, -0.01662753f, 0.06084854f, 0.05914399f, 
    0.09138346f, -0.08098923f, 0.10865191f, 0.01407447f, -0.29493839f, -0.44267580f, -0.23598430f, 0.03226023f, 
    0.14635268f, 0.09712579f, 0.13680017f, -0.17295180f, 0.16252562f, 0.21734490f, -0.64259702f, -0.15393199f, 
    -0.12030490f, 0.22053871f, 0.04029223f, -0.14996032f, 0.16397633f, 0.16049443f, -0.19471017f, 0.12228796f, 
    0.24735083f, 0.14530955f, 0.07954413f, 0.13500521f, -0.07776641f, 0.07122647f, -0.05692791f, -0.24004081f, 
    -0.19734046f, -0.13919918f, -0.03980102f, -0.19233793f, 0.05377281f, 0.11396617f, 0.00864010f, -0.04173089f, 
    -0.02046085f, -0.22760868f, 0.07465614f, -0.04543881f, 0.09611935f, 0.14738367f, -0.10336912f, 0.29106563f, 
    0.02700406f, -0.13106124f, -0.32807457f, 0.07262426f, 0.00397295f, -0.11019081f, 0.07700900f, 0.01255251f, 
    -0.01578368f, 0.07447935f, -0.36141074f, -0.43018281f, 0.13748053f, -0.14803416f, -0.14456007f, 0.00070165f, 
    0.06087648f, -0.11009897f, 0.24716559f, 0.01867835f, 0.20738973f, 0.09162018f, 0.06567395f, 0.11647526f, 
    0.06582831f, -0.10985949f, 0.02207975f, -0.05919374f, -0.23836401f, -0.31364328f, -0.07150929f, -0.03153988f, 
    -0.04434036f, 0.08878157f, 0.09541459f, -0.09235948f, 0.26687208f, 0.21944796f, 0.01739196f, -0.09252553f, 
    0.07996178f, 0.02844061f, -0.14675407f, 0.07169693f, -0.15329249f, 0.12568869f, -0.15632631f, -0.15249270f, 
    -0.07992897f, -0.05786256f, -0.11470069f, 0.10306987f, 0.00439952f, 0.01961889f, -0.11201348f, -0.03864899f, 
    -0.27683651f, 0.13539939f, 0.08202818f, -0.01016097f, -0.07780626f, 0.13210352f, 0.05804704f, 0.22205624f, 
    0.02801240f, 0.39111722f, 0.04673892f, 0.11148852f, -0.01098067f, 0.06964178f, -0.20670052f, 0.00575221f, 
    0.08381171f, -0.42915386f, 0.34077200f, 0.00700167f, -0.04535069f, 0.14192270f, -0.08424085f, 0.14594255f, 
    0.06366655f, -0.03781097f, -0.10114699f, 0.10964788f, 0.03834713f, -0.08406539f, -0.16801763f, -0.03034165f, 
    0.10940130f, -0.00032177f, 0.07661170f, -0.19089797f, 0.12568834f, -0.04108246f, 0.05352096f, 0.08473801f, 
    0.00405959f, 0.03697556f, -0.08419199f, -0.34204727f, -0.07899063f, 0.02395402f, -0.09679988f, -0.07299232f, 
    -0.15534392f, 0.07314818f, 0.07249965f, -0.02002781f, -0.11261938f, 0.13395138f, -0.10067298f, 0.05943724f, 
    0.06123406f, 0.03240244f, 0.12394795f, -0.11830034f, -0.14817637f, 0.09732403f, -0.06590656f, -0.13226135f, 
    0.02929857f, -0.02604103f, -0.24304406f, -0.03398178f, -0.04869666f, 0.02507084f, -0.08325271f, 0.09915271f, 
    -0.10743309f, -0.05603341f, 0.09357052f, -0.08691397f, 0.26591793f, -0.48546579f, -0.09035937f, -0.14273937f, 
    -0.02790033f, -0.12759955f, 0.03392077f, 0.00020018f, -0.12166358f, -0.04645925f, 0.11896509f, 0.18099633f, 
    -0.06022215f, 0.04091578f, 0.01252882f, 0.06164540f, 0.03398892f, -0.02808500f, -0.04541854f, 0.09274425f, 
    0.23491181f, -0.19761743f, 0.09741592f, 0.10555141f, 0.00966095f, -0.06869239f, -0.06839835f, 0.04782240f, 
    -0.03050201f, 0.11083600f, -0.23286739f, -0.47044525f, -0.33392042f, 0.05485377f, 0.06951565f, 0.06481750f, 
    0.02158022f, 0.04570750f, 0.19134080f, -0.04555769f, 0.05775917f, -0.04063337f, 0.08867902f, 0.06888211f, 
    -0.00277433f, -0.10835260f, 0.02590460f, 0.12771077f, -0.08795515f, -0.03735457f, 0.15349062f, 0.14588133f, 
    0.02327567f, -0.05590185f, -0.00738789f, -0.09839968f, 0.20377238f, -0.12568717f, 0.13551404f, 0.27485147f, 
    0.09031037f, 0.04493143f, -0.08393387f, 0.07991707f, -0.11691678f, 0.32211336f, -0.18549684f, -0.00991463f, 
    -0.14770620f, -0.16134335f, -0.16126367f, -0.24262112f, 0.02810830f, 0.13885878f, 0.08759790f, -0.21840875f, 
    0.19083482f, -0.08885267f, 0.12516178f, -0.01564612f, -0.07850477f, 0.15586834f, -0.15158600f, 0.36574015f, 
    0.11582709f, -0.04898132f, -0.04505640f, 0.05138469f, 0.01938591f, 0.09394067f, 0.14322563f, 0.05863959f, 
    -0.01634655f, 0.03207931f, 0.21270023f, -0.02179250f, 0.06993084f, -0.07644946f, 0.01388297f, -0.08490630f, 
    -0.01456155f, 0.06316869f, -0.21100265f, 0.02102272f, -0.00373198f, -0.09258102f, -0.17705745f, 0.07742050f, 
    -0.01134887f, 0.11985204f, 0.13437495f, 0.24827170f, 0.11987272f, 0.02789087f, 0.14589590f, 0.25807446f, 
    -0.01114327f, -0.00242849f, 0.10199732f, 0.15540507f, 0.37553069f, -0.42379901f, -0.14021417f, -0.03576605f, 
    -0.07583877f, 0.11156833f, -0.07009761f, 0.09081742f, 0.09590967f, 0.11028054f, -0.07628448f, 0.03662236f, 
    -0.03249188f, -0.00360181f, 0.10260423f, 0.01210702f, 0.17283703f, -0.08159714f, 0.00462528f, 0.01041008f, 
    0.02034732f, -0.07599385f, 0.05291007f, -0.03439754f, 0.07156090f, 0.06984045f, 0.09475306f, 0.12879726f, 
    -0.10912463f, -0.04616516f, 0.10298120f, 0.02009752f, 0.08327882f, -0.04398996f, 0.03486626f, -0.01046508f, 
    0.24442819f, 0.05949606f, 0.14744359f, -0.07119174f, 0.05907896f, -0.03706047f, 0.07837833f, 0.01731440f, 
    -0.00456005f, 0.02337800f, -0.01023181f, 0.08256391f, 0.09880161f, 0.12552805f, 0.04191178f, -0.05521388f, 
    0.15587443f, -0.01988244f, -0.24885900f, -0.11712376f, -0.12101743f, 0.05681988f, -0.03916951f, -0.04432239f, 
    0.17903146f, -0.07499816f, -0.06804769f, -0.05827870f, -0.01348860f, 0.01353842f, 0.01371504f, 0.16438840f, 
    0.10142437f, 0.00089592f, 0.14164473f, 0.07432045f, -0.06862932f, -0.06320769f, -0.07487193f, 0.18210605f, 
    -0.06745029f, -0.00914396f, 0.04859830f, -0.26811385f, -0.11044439f, 0.01577628f, 0.07546754f, 0.03627040f, 
    -0.07460404f, 0.04000693f, 0.03525956f, 0.11491652f, 0.15734549f, 0.02020015f, 0.08315079f, 0.11730935f, 
    -0.04557390f, -0.03393503f, 0.19740857f, -0.01458076f, -0.06726920f, 0.13054109f, 0.22670677f, -0.13582875f, 
    -0.09470672f, -0.25277233f, 0.11111402f, 0.21197660f, -0.19628932f, -0.06831384f, -0.05577498f, -0.14241312f, 
    0.04798447f, -0.38432187f, 0.01310006f, -0.17477490f, 0.02192291f, 0.18272637f, -0.04354659f, 0.05917252f, 
    0.11418992f, -0.15734273f, -0.15790902f, 0.14700314f, -0.17715326f, 0.07021254f, -0.05586859f, 0.11300432f, 
    0.05256984f, 0.12232400f, 0.06167830f, -0.10139985f, 0.02559884f, 0.03602610f, 0.08902583f, -0.07001302f, 
    0.08137567f, -0.14294674f, 0.11668251f, 0.05295090f, -0.02913530f, -0.22290212f, -0.08886012f, -0.05332661f, 
    -0.02458978f, 0.14541170f, -0.10464144f, 0.01373935f, 0.08345554f, 0.24464084f, 0.17401204f, 0.10850947f, 
    -0.08536888f, 0.00572959f, 0.11911500f, -0.34745842f, -0.45800132f, 0.09600296f, 0.08985949f, 0.06603681f, 
    0.15229233f, -0.06499379f, 0.13535744f, 0.15664957f, -0.19350302f, -0.05973909f, 0.13366227f, 0.11338816f, 
    0.21708857f, 0.19060487f, 0.06941750f, -0.19509259f, -0.01668872f, -0.32523057f, -0.10842618f, -0.09857574f, 
    -0.08197448f, -0.04618014f, -0.05886972f, 0.05357352f, 0.13029681f, -0.03264204f, -0.11147071f, 0.11392138f, 
    -0.00724891f, -0.00873618f, 0.06329136f, -0.05283179f, 0.11910906f, 0.01733481f, -0.10368925f, 0.06916717f, 
    0.10228571f, 0.00723566f, -0.05900161f, 0.19851981f, 0.09904929f, -0.00595205f, -0.10017090f, -0.08269452f, 
    -0.02877796f, 0.02722993f, -0.13301584f, -0.16650385f, -0.17834879f, 0.05765917f, -0.11156274f, 0.07825594f, 
    0.10367622f, 0.10716435f, 0.09187426f, -0.09579734f, 0.09216409f, 0.09379894f, 0.16124961f, -0.13035512f, 
    -0.02006290f, -0.04680517f, 0.07566482f, -0.07186080f, -0.24829681f, 0.02176449f, -0.10542288f, 0.16611560f, 
    -0.11545929f, 0.23244564f, -0.10510635f, -0.06035597f, 0.00781155f, 0.14954416f, 0.25786906f, 0.03345949f, 
    0.12021087f, -0.19227888f, -0.06837488f, 0.12619336f, -0.22419122f, 0.24829999f, 0.02564302f, -0.08223291f, 
    0.12427069f, 0.02908240f, 0.01745703f, 0.14568421f, 0.06890670f, -0.02536530f, 0.22113912f, 0.07367095f, 
    0.13018583f, 0.05698841f, -0.10033394f, 0.07380795f, -0.06464650f, 0.07910763f, -0.30287060f, 0.01316489f, 
    0.12893383f, -0.10339509f, -0.03147681f, 0.12943517f, 0.04085043f, 0.05620722f, 0.14087304f, 0.03556047f, 
    0.00630861f, -0.12952833f, -0.13471679f, 0.02431980f, -0.12914740f, 0.01185273f, -0.12269402f, 0.03990305f, 
    -0.13393560f, 0.07107735f, 0.06801081f, -0.09484763f, 0.13171943f, 0.04746662f, -0.20006487f, 0.14763983f, 
    0.06589748f, 0.08782827f, 0.05166690f, -0.02287148f, -0.07435397f, -0.15508552f, 0.04474735f, 0.13705382f, 
    0.18415849f, -0.00561087f, -0.09532488f, -0.20674826f, -0.09117802f, -0.17888737f, -0.03220920f, -0.03582072f, 
    -0.04470629f, 0.07061563f, -0.03024093f, -0.02023552f, 0.08828364f, 0.16326697f, -0.08392665f, -0.06555927f, 
    0.07848518f, 0.10535388f, 0.15011749f, 0.15591080f, -0.03161255f, -0.13960113f, -0.05989997f, -0.11381985f, 
    -0.54452384f, 0.03747693f, -0.02079224f, 0.09078607f, 0.07011865f, 0.05738647f, 0.03959606f, 0.15791602f, 
    0.01495998f, 0.05420226f, 0.02994471f, -0.11047702f, 0.04879691f, -0.00511828f, -0.14525680f, -0.06145253f, 
    0.14403982f, -0.02202776f, -0.07088734f, 0.06210773f, 0.12857841f, -0.02761441f, 0.03431826f, -0.06338898f, 
    -0.18786740f, -0.08962464f, -0.07733757f, -0.23188676f, 0.16907446f, 0.01785144f, 0.11667743f, 0.25635174f, 
    -0.08077928f, -0.25286937f, 0.15572199f, 0.11236311f, 0.09328699f, 0.12758666f, 0.07637295f, -0.06809458f, 
    0.01337089f, -0.22207569f, 0.04289856f, -0.03123173f, 0.00854295f, -0.07065955f, -0.05535045f, 0.09689417f, 
    0.03684635f, 0.11441147f, -0.06947094f, -0.22462621f, -0.11664297f, 0.19714923f, -0.16101742f, 0.12455714f, 
    -0.09162296f, 0.08144446f, 0.09827568f, -0.13575506f, -0.04900805f, 0.10838329f, 0.02989439f, -0.22458145f, 
    0.01540382f, 0.04112541f, 0.08185633f, 0.06999958f, 0.01862800f, -0.13288122f, 0.13709864f, 0.22110523f, 
    -0.00335361f, -0.09595032f, -0.12763675f, -0.04891004f, -0.03340854f, 0.00884937f, 0.20074239f, -0.02501626f, 
    0.10033700f, 0.19390526f, -0.05783769f, 0.08923638f, -0.13616320f, -0.06299934f, -0.20740515f, 0.02617233f, 
    -0.04515744f, 0.14173719f, 0.32488832f, 0.09098385f, -0.00291901f, 0.05583719f, -0.16131748f, 0.24535441f, 
    -0.20251271f, 0.11996888f, 0.15501386f, -0.12683041f, -0.01718113f, 0.04779197f, -0.07444658f, -0.03663714f, 
    -0.06672191f, -0.14291508f, 0.09953149f, 0.12506263f, 0.14654817f, -0.08421862f, -0.14847194f, 0.06840437f, 
    0.05738824f, 0.11748023f, 0.06109037f, -0.20361747f, -0.13054281f, 0.11776260f, 0.09133193f, 0.05097808f, 
    0.19432299f, -0.09168810f, 0.19003955f, -0.05874227f, 0.12158486f, 0.03303277f, 0.11661182f, 0.05067295f, 
    0.06069220f, 0.10424360f, 0.01603705f, 0.10130398f, 0.15313065f, 0.12938826f, 0.12903452f, -0.01632134f, 
    0.07093216f, 0.01473359f, 0.07659695f, 0.09726261f, -0.01459810f, 0.07474436f, 0.21274219f, 0.14888814f, 
    0.01654597f, -0.05522829f, 0.06644302f, 0.05324132f, 0.03702907f, 0.01200646f, 0.19750834f, 0.04600629f, 
    -0.04095400f, -0.02901649f, -0.02036770f, -0.02532713f, -0.02581533f, -0.01193841f, 0.23324256f, -0.11404063f, 
    0.05262665f, -0.07522608f, -0.06255917f, 0.07632752f, -0.09881899f, -0.08440556f, -0.04711821f, -0.06448708f, 
    -0.14606361f, 0.02160575f, -0.01131110f, -0.04508455f, 0.04438563f, -0.12385327f, 0.06656992f, -0.00868349f, 
    0.01261221f, -0.07467799f, 0.03622027f, -0.09799076f, 0.08434354f, 0.11691667f, 0.00414760f, 0.15579128f, 
    -0.10837082f, -0.09787992f, -0.09802502f, 0.12995937f, -0.10299192f, 0.04932413f, 0.02174589f, -0.25895324f, 
    -0.05051361f, -0.01066669f, -0.14917147f, -0.22530846f, 0.07744823f, 0.03951151f, 0.31268632f, 0.06944019f, 
    0.04884278f, 0.14973977f, 0.11540099f, 0.01340895f, -0.10626794f, 0.21005386f, -0.07862181f, -0.04946722f, 
    0.12109147f, -0.09810201f, -0.04500704f, -0.05869174f, 0.07404262f, -0.08075535f, 0.01656371f, -0.05186805f, 
    -0.00982813f, 0.07044367f, 0.02855501f, 0.15296018f, -0.08456109f, -0.10682307f, -0.39481965f, 0.27565941f, 
    0.23023407f, 0.02030789f, 0.02664604f, 0.16705859f, 0.05690646f, 0.06901784f, 0.12066510f, -0.20684494f, 
    -0.09264800f, -0.00894092f, 0.06299984f, 0.07533839f, -0.03410335f, 0.08947736f, -0.14245592f, -0.26416898f, 
    -0.06378753f, -0.25168657f, 0.01308500f, 0.18997908f, -0.00664604f, -0.03666568f, 0.18904862f, -0.00657878f, 
    -0.07470355f, -0.38901281f, 0.01167615f, -0.14878953f, -0.01051724f, -0.18099695f, 0.02180350f, 0.04081101f, 
    -0.05988146f, -0.08338259f, -0.17846210f, -0.06416579f, -0.26002717f, 0.13684592f, -0.01186904f, -0.01320358f, 
    -0.00400149f, 0.16384748f, -0.26732540f, 0.13002944f, -0.13118638f, 0.10696767f, -0.18678583f, -0.23075463f, 
    -0.06756613f, 0.13344102f, -0.31841218f, -0.08024397f, -0.00797517f, -0.03192579f, 0.06463130f, 0.10416521f, 
    0.12480615f, 0.13181458f, 0.16059555f, 0.03299325f, 0.06405705f, -0.09345889f, -0.19936217f, -0.14145161f, 
    0.04895555f, 0.06367842f, 0.03371653f, 0.11719768f, -0.13791628f, -0.04731825f, 0.02141433f, 0.07187483f, 
    0.04316366f, 0.14248714f, -0.06639685f, -0.01272636f, -0.09495918f, -0.12158962f, 0.00559913f, -0.11463113f, 
    -0.07974280f, -0.04316228f, 0.08204047f, 0.01919551f, 0.00450233f, 0.03998737f, 0.20723636f, 0.16187030f, 
    0.04181995f, -0.06659907f, -0.05799249f, 0.17277957f, -0.00380979f, 0.02939454f, 0.02063191f, -0.12177132f, 
    0.02998660f, 0.07558119f, 0.21149963f, 0.19872779f, 0.17012598f, -0.11335909f, 0.06477720f, 0.11599401f, 
    0.04486016f, 0.00154098f, 0.00578511f, -0.00290607f, 0.07452022f, 0.07511160f, -0.04523737f, -0.13851884f, 
    -0.14800085f, -0.04987840f, -0.01888645f, 0.14783427f, -0.07741886f, 0.04709020f, 0.15107507f, -0.05251636f, 
    0.19413583f, 0.10694015f, -0.09149496f, 0.12360699f, -0.03875468f, -0.20000987f, -0.25781721f, 0.05795358f, 
    -0.06739893f, 0.01895047f, -0.00199814f, -0.07719419f, 0.09562828f, 0.05404666f, 0.10393970f, -0.10555868f, 
    -0.04394182f, -0.03820635f, 0.00787189f, -0.10597423f, -0.07693555f, -0.06345201f, -0.11217552f, 0.14599824f, 
    0.21829118f, 0.19644681f, 0.07864340f, 0.10691012f, 0.06603011f, 0.07040507f, -0.01912152f, 0.10977311f, 
    -0.46557701f, -0.08254388f, 0.19071445f, 0.06773892f, 0.14908528f, 0.02791989f, 0.00158496f, -0.05403465f, 
    -0.24443635f, -0.25948921f, -0.40891388f, -0.27665943f, -0.07068113f, 0.16892608f, -0.00315384f, 0.12138347f, 
    0.00097827f, -0.08828957f, -0.34308684f, -0.15111238f, 0.00201778f, -0.06614296f, 0.23045176f, -0.17508414f, 
    0.15072727f, 0.05399472f, 0.13096149f, 0.31760654f, 0.03004514f, -0.34853679f, 0.17460296f, 0.17508546f, 
    0.09998517f, -0.00604965f, 0.14239447f, 0.08028582f, 0.14430466f, 0.00013403f, -0.00556727f, 0.11476057f, 
    0.13198216f, 0.23412849f, 0.10957307f, 0.10865916f, 0.17319703f, -0.54780537f, 0.14298157f, 0.09983669f, 
    -0.00323810f, -0.10713575f, 0.04621855f, -0.07102547f, 0.05249972f, -0.01226564f, -0.04196902f, 0.00115031f, 
    0.10129270f, -0.08988414f, 0.04251663f, -0.00993394f, 0.06948145f, 0.14738788f, 0.17907616f, 0.31264359f, 
    -0.21114531f, 0.07876521f, 0.00796001f, -0.10622355f, -0.15665598f, 0.07946600f, -0.00314654f, 0.09573650f, 
    0.14435011f, -0.43476775f, -0.08860736f, -0.00713609f, -0.08163398f, -0.12299709f, -0.01123718f, -0.08562497f, 
    -0.01151572f, 0.25566921f, -0.05464151f, 0.34009263f, 0.14383538f, 0.08447439f, 0.09549674f, -0.00803792f, 
    -0.06383912f, 0.06747869f, -0.06300241f, -0.20774674f, -0.16843195f, -0.13357696f, -0.06286276f, 0.04147661f, 
    -0.15655355f, -0.11936966f, 0.05382612f, 0.28502834f, -0.19756639f, 0.19277732f, -0.15482850f, -0.16974342f, 
    -0.08452449f, 0.04202846f, -0.04007065f, -0.11346567f, -0.09986339f, 0.10664277f, -0.37919152f, 0.03663733f, 
    -0.18019697f, 0.17717636f, 0.00114041f, 0.10133370f, 0.06474295f, 0.36664256f, -0.01603444f, 0.38295448f, 
    0.07438736f, -0.16224150f, -0.43702000f, 0.02527742f, 0.00571364f, -0.05209333f, 0.06553254f, -0.53432822f, 
    -0.17966747f, 0.09212435f, 0.10992869f, 0.07149999f, -0.03423092f, -0.01946901f, -0.03166541f, 0.19047695f, 
    -0.20209846f, -0.29859358f, -0.26282138f, 0.16832367f, 0.02393454f, 0.07006288f, -0.09855941f, -0.02374343f, 
    -0.09771338f, -0.18954821f, 0.00539100f, -0.04597182f, 0.08599076f, 0.10353369f, 0.04959256f, -0.00264141f, 
    0.09959713f, -0.53057325f, -0.05343445f, 0.04622757f, -0.13640068f, -0.06416643f, -0.17291294f, -0.06710952f, 
    -0.15940037f, 0.10423585f, 0.20793478f, -0.07523403f, -0.06837985f, 0.10813381f, -0.05420477f, 0.15846479f, 
    0.06219773f, 0.03087259f, -0.12915447f, -0.03503717f, -0.24960063f, 0.05326201f, 0.06603330f, 0.01362377f, 
    0.12402177f, 0.08449521f, -0.10766409f, 0.15469316f, 0.01018005f, -0.06041721f, 0.13143727f, -0.05043548f, 
    -0.04664767f, 0.18570556f, 0.01076784f, -0.09526148f, -0.05383020f, -0.10031916f, -0.06257014f, -0.02775456f, 
    -0.02984507f, 0.07689588f, -0.04579655f, 0.04879062f, 0.16543931f, 0.09895498f, -0.09346648f, -0.15268536f, 
    -0.13488498f, 0.06866327f, 0.09301353f, 0.10175944f, 0.08478644f, 0.12340319f, 0.19660503f, 0.05123970f, 
    0.18445359f, 0.24999693f, 0.00183120f, 0.00467372f, -0.04202509f, 0.03754425f, 0.06391457f, 0.05226050f, 
    0.13957562f, -0.08168909f, -0.00446956f, 0.06319930f, 0.11855336f, 0.14820294f, 0.12320153f, 0.12887439f, 
    0.01229306f, -0.22357973f, 0.13298745f, -0.00855917f, 0.01839862f, 0.10886879f, 0.10453282f, -0.02969483f, 
    0.06468036f, 0.13658400f, 0.28611076f, -0.02312874f, 0.01529107f, -0.23173018f, 0.02442536f, -0.02969427f, 
    -0.16670778f, 0.06898265f, 0.11480318f, -0.13634776f, 0.15456930f, 0.14613444f, 0.12513398f, 0.14789574f, 
    0.01677971f, 0.04684737f, 0.02721128f, 0.02558344f, -0.37512952f, 0.27319965f, -0.43897048f, 0.20100011f, 
    -0.00858037f, 0.25676611f, 0.02238148f, 0.05713717f, -0.06405044f, -0.00639069f, 0.09223127f, -0.31352982f, 
    0.06200185f, -0.02638269f, 0.25811228f, -0.06981439f, 0.08548880f, 0.06803073f, 0.11872491f, 0.03139936f, 
    -0.16985022f, -0.26109248f, -0.40050739f, -0.19448493f, 0.03226961f, -0.10769513f, -0.03295019f, 0.13116594f, 
    0.05303952f, -0.03263357f, -0.18969129f, -0.08757229f, -0.05275428f, 0.05500150f, -0.01776357f, 0.16792920f, 
    -0.05835324f, -0.06143823f, -0.04208313f, 0.03155869f, -0.00874574f, 0.00976910f, -0.02443401f, -0.02929617f, 
    -0.01645268f, -0.04363090f, -0.03013206f, -0.02163225f, 0.00968167f, -0.04452690f, 0.01366721f, 0.00618284f, 
    -0.03254763f, -0.06149319f, 0.02077708f, -0.01197836f, 0.01149616f, 0.00514121f, 0.04514099f, -0.02238415f, 
    -0.00950276f, 0.02043980f, 0.00006278f, -0.05647364f, -0.04806310f, 0.00003960f, -0.01513381f, -0.06216409f, 
    -0.04039865f, 0.03037673f, 0.01622671f, -0.03741658f, -0.01415526f, 0.02230266f, 0.01191465f, -0.00084699f, 
    -0.01957994f, -0.03588988f, -0.02244936f, -0.04485842f, -0.00222010f, -0.01776100f, -0.03098037f, 0.01926265f, 
    -0.06805878f, -0.00731002f, 0.04512841f, -0.01571379f, -0.03587770f, 0.00012096f, 0.03546645f, 0.03176767f, 
    0.04074462f, 0.03501523f, -0.02597355f, 0.04491262f, 0.04164485f, -0.02427912f, 0.03834464f, 0.05129418f, 
    0.02111649f, 0.05341606f, 0.03337863f, 0.03346492f, -0.00366952f, -0.00942048f, -0.01806200f, 0.02843046f, 
    0.01387858f, -0.03149939f, 0.04026774f, 0.04717942f, -0.01659007f, 0.02207027f, -0.02372058f, -0.02113019f, 
    -0.04711978f, 0.02180514f, 0.01707834f, 0.03490274f, 0.01022243f, -0.02802220f, 0.03864967f, -0.01199422f, 
    -0.03726798f, -0.00863025f, -0.01466286f, -0.06746328f, -0.02457778f, -0.01825860f, -0.05125274f, -0.06081536f, 
    -0.00045203f, -0.04483735f, -0.04202589f, -0.03994549f, -0.05455802f, 0.04522920f, -0.03616061f, -0.06248394f, 
    -0.05804174f, -0.06039957f, -0.05482117f, -0.03606585f, -0.04278081f, 0.01902177f, 0.02337509f, -0.04876383f, 
    -0.03918967f, -0.02716714f, -0.00824090f, -0.03828551f, -0.01718142f, 0.01403642f, -0.00129553f, -0.04203365f, 
    0.04697358f, -0.06349362f, 0.03454418f, 0.03935622f, -0.04910794f, -0.00476669f, -0.03954246f, 0.03592090f, 
    0.05479379f, 0.04414313f, 0.04015101f, 0.02625687f, -0.03445083f, -0.02901177f, -0.05169591f, 0.05045008f, 
    0.02641166f, 0.00881196f, 0.00227127f, -0.03102750f, -0.00315971f, 0.00429220f, -0.05650301f, -0.05254203f, 
    -0.00069463f, -0.06155921f, 0.05072569f, -0.03777857f, -0.04170705f, 0.01976688f, -0.02091212f, -0.00241200f, 
    0.03230725f, -0.04713421f, -0.03555534f, -0.01482699f, 0.04040882f, 0.01518135f, -0.04642861f, 0.01946646f, 
    0.00928391f, -0.05171738f, -0.04419205f, -0.03637444f, -0.05807046f, 0.05423608f, -0.00193620f, 0.03474203f, 
    0.02346098f, -0.02245967f, -0.02264515f, 0.02788552f, -0.02493539f, 0.05008863f, -0.00263599f, -0.01374003f, 
    -0.04141315f, 0.02202367f, -0.02341241f, -0.03020745f, -0.02242997f, -0.05276151f, -0.05214674f, -0.01437516f, 
    -0.02568763f, 0.05486462f, 0.04059697f, -0.00928509f, -0.01563165f, 0.00664391f, -0.02532243f, -0.01821990f, 
    -0.03336978f, -0.04439120f, -0.03544468f, 0.01154947f, -0.05525593f, 0.01828591f, 0.04629823f, -0.05888179f, 
    -0.04891129f, -0.05979748f, 0.01737566f, -0.01841409f, -0.00913302f, 0.03863220f, -0.00188016f, 0.03013687f, 
    -0.03679462f, -0.05436133f, -0.04969983f, -0.01550090f, -0.01650459f, 0.03880357f, -0.02596600f, -0.01351098f, 
    0.01625297f, -0.00249575f, -0.03802502f, -0.04400032f, 0.04816525f, 0.00535811f, -0.01389869f, 0.02701541f, 
    -0.03769428f, 0.03641701f, 0.03591954f, -0.02114216f, 0.00637397f, -0.03348652f, 0.02958737f, 0.00739826f, 
    -0.00550216f, 0.00736498f, -0.05703725f, -0.02023309f, -0.01422524f, 0.03818057f, -0.02766276f, 0.00931671f, 
    -0.06195469f, -0.02717418f, -0.05639384f, -0.01293864f, 0.02027427f, 0.00390040f, -0.02073140f, -0.01216139f, 
    0.02738799f, -0.04439804f, 0.01594081f, -0.05849778f, 0.04366413f, 0.03829397f, -0.03813389f, 0.04673900f, 
    0.02475810f, -0.00779966f, -0.02965104f, 0.00697424f, -0.02810488f, -0.02658892f, 0.02700021f, 0.01337625f, 
    -0.01661297f, 0.05489337f, -0.01736615f, -0.03702974f, 0.01387660f, 0.04882492f, -0.02664942f, -0.05360215f, 
    -0.04422817f, 0.01917522f, -0.03829255f, 0.01928923f, 0.03023011f, 0.05232027f, -0.02609881f, -0.02438983f, 
    -0.04214485f, 0.04666555f, -0.05866510f, -0.03050539f, 0.02327291f, -0.06623342f, 0.02334994f, 0.03668274f, 
    0.03282262f, 0.02425669f, 0.04596451f, 0.00091639f, 0.00973023f, -0.00934549f, -0.00538384f, -0.01217066f, 
    0.00892239f, -0.02467248f, 0.05115400f, 0.06308082f, -0.00729214f, -0.01001549f, 0.00548351f, -0.05769917f, 
    -0.00512469f, 0.03535499f, 0.01778161f, 0.02457767f, 0.03545557f, -0.03246318f, -0.05475746f, 0.05252187f, 
    -0.02988095f, 0.02125250f, -0.04120866f, -0.04299156f, -0.00545362f, -0.03096028f, -0.00154454f, -0.01711215f, 
    0.04474828f, -0.04731058f, -0.06111086f, -0.05192974f, -0.01655116f, -0.06235863f, -0.04077225f, 0.05502724f, 
    -0.02480215f, -0.04885311f, -0.01687204f, -0.05842836f, -0.02570775f, 0.04369445f, 0.01256537f, -0.04202352f, 
    0.00922655f, -0.03505610f, 0.04960698f, -0.02135674f, -0.01502093f, 0.02040332f, 0.02461563f, -0.00669362f, 
    -0.02380005f, -0.02543254f, -0.02679512f, 0.02229720f, -0.01939350f, -0.00502239f, 0.03640277f, -0.04643426f, 
    -0.01885278f, 0.04837982f, 0.01041922f, -0.05615705f, 0.03042188f, -0.06038856f, 0.04760893f, -0.05453275f, 
    -0.02605482f, 0.01920224f, 0.04111222f, -0.03486577f, 0.04019646f, -0.03003556f, 0.04321029f, -0.06083312f, 
    -0.00700500f, -0.06459106f, 0.03087155f, -0.01996740f, 0.04228856f, -0.04748845f, -0.04456575f, -0.03415746f, 
    -0.02829926f, -0.01653879f, 0.00207725f, 0.04344828f, 0.03947480f, 0.03005971f, 0.03105621f, -0.06174327f, 
    -0.05815194f, 0.04733828f, -0.03023308f, -0.02127973f, -0.05122860f, -0.00689688f, -0.04563908f, -0.00146099f, 
    0.04172120f, -0.06378090f, -0.01314966f, -0.00859091f, 0.02720766f, 0.03591150f, -0.04935946f, 0.00256761f, 
    -0.05774312f, -0.05705500f, 0.02282925f, -0.02535116f, -0.00448330f, -0.04790059f, 0.02157670f, -0.00913910f, 
    -0.01761134f, -0.02771549f, -0.00339078f, -0.02691210f, 0.04786273f, -0.03411607f, -0.03630343f, 0.03473620f, 
    -0.03839711f, -0.05269633f, -0.04092672f, 0.02880117f, 0.01065943f, -0.04297218f, -0.04232969f, 0.02289668f, 
    -0.00060158f, -0.01615523f, 0.03390172f, -0.00906602f, -0.03618731f, 0.02908477f, 0.01071195f, -0.02538138f, 
    0.02120342f, -0.01362490f, 0.03691378f, -0.00954885f, 0.00162317f, 0.04732163f, -0.02998905f, -0.05811568f, 
    0.00998238f, -0.00247108f, -0.02004015f, -0.03223178f, 0.01371529f, -0.04059733f, 0.01749731f, -0.05152174f, 
    0.03609941f, 0.02127915f, -0.01511178f, -0.00244240f, -0.01306139f, -0.05414803f, -0.01036544f, -0.02436051f, 
    -0.02597373f, 0.00984952f, 0.01923225f, 0.01308406f, -0.04753285f, 0.02338225f, 0.01112875f, -0.05910809f, 
    -0.04789462f, 0.03609043f, -0.02790247f, -0.02266942f, 0.04681153f, -0.01349332f, -0.04566073f, -0.01747435f, 
    -0.05395163f, -0.05226960f, 0.04449423f, -0.02750219f, -0.05992428f, -0.02354775f, 0.04670643f, 0.00347757f, 
    -0.01999059f, 0.02786648f, 0.04066268f, 0.04542312f, -0.01122209f, -0.00484881f, 0.03064965f, 0.02871100f, 
    -0.02326098f, 0.04379129f, -0.01778903f, 0.01879272f, 0.03724813f, -0.05517763f, 0.02719544f, -0.02011996f, 
    -0.00301397f, -0.01753047f, -0.01098883f, -0.02074963f, -0.05352374f, -0.01056216f, -0.01759714f, -0.03409145f, 
    -0.05443601f, 0.01784705f, 0.00877421f, -0.03144578f, 0.04898697f, -0.02560275f, 0.03387332f, -0.06026483f, 
    -0.02577947f, -0.00513597f, 0.00907752f, -0.03045452f, 0.04328565f, -0.00011779f, 0.03815104f, 0.03297026f, 
    -0.05789646f, 0.03971127f, -0.03119039f, -0.01754577f, -0.05593234f, -0.05000120f, 0.00335084f, -0.04246242f, 
    -0.01698239f, -0.02845693f, 0.03136425f, -0.01939224f, 0.01521711f, -0.02032696f, -0.04423949f, -0.03520262f, 
    -0.04800911f, -0.01789941f, -0.02839837f, 0.03742824f, 0.04820552f, 0.05250684f, -0.03518043f, 0.04280126f, 
    0.01206305f, 0.04364694f, -0.03662625f, 0.04265750f, 0.04503405f, -0.03972771f, 0.00078218f, -0.03836969f, 
    -0.00658945f, 0.03905411f, 0.04423841f, -0.02027135f, 0.05286922f, -0.06164989f, 0.04462254f, 0.04996815f, 
    0.01853436f, -0.03161673f, -0.03287342f, -0.01181632f, 0.03022424f, -0.03097367f, -0.02390923f, -0.01615012f, 
    0.02601145f, -0.03875481f, -0.03835854f, -0.04021082f, 0.02515733f, -0.05875251f, -0.03896974f, -0.00493602f, 
    0.47072402f, -0.06300370f, 0.35312355f, 0.21343943f, -0.08906282f, 0.14329204f, -0.02244735f, 0.14662099f, 
    -0.07028369f, -0.27178252f, 0.00421647f, -0.04023216f, 0.15759662f, -0.03667776f, -0.05340028f, 0.04424606f, 
    -0.00917751f, -0.26877886f, -0.05534473f, 0.04945471f, -0.02449666f, -0.03483804f, -0.13764930f, -0.02719191f, 
    0.18929048f, 0.09336226f, 0.18001764f, 0.01809891f, 0.00972913f, 0.05428341f, 0.17491549f, 0.00381468f, 
    0.06039029f, 0.01113672f, 0.13927981f, 0.03380665f, 0.13190486f, -0.03257207f, 0.02624149f, -0.00131645f, 
    0.04737568f, -0.14324036f, 0.11060449f, 0.04871537f, 0.16471031f, 0.10743619f, -0.16597465f, -0.10854693f, 
    0.01273276f, -0.06740863f, 0.00252881f, -0.00465655f, -0.16049044f, 0.04791294f, -0.01981219f, -0.00188512f, 
    0.02293293f, -0.11312196f, -0.05564265f, -0.13021740f, 0.14695518f, 0.11635902f, 0.13980716f, 0.14492399f, 
    -0.08493914f, -0.12619856f, -0.03714531f, 0.02675270f, 0.05094464f, -0.03757631f, 0.09944471f, 0.11776323f, 
    0.15060529f, -0.09836417f, -0.25185040f, -0.04588891f, 0.13525356f, 0.07541862f, -0.09738011f, 0.01001564f, 
    0.08398744f, -0.01976442f, -0.25343516f, -0.06312817f, 0.09268286f, 0.10502946f, -0.03632873f, 0.12710808f, 
    0.02481602f, 0.09691290f, -0.14137819f, -0.02402228f, 0.05363952f, 0.06397728f, -0.03610422f, 0.06529441f, 
    -0.27006993f, -0.04954649f, -0.56201029f, -0.27965459f, -0.15186712f, -0.08260678f, 0.08494653f, 0.21976222f, 
    0.02988589f, 0.01881023f, -0.00193840f, -0.10830593f, 0.39722669f, -0.01048579f, 0.02759796f, -0.06316119f, 
    0.07891942f, -0.08481159f, 0.08330788f, -0.01515648f, -0.27906176f, 0.03522525f, -0.15120453f, -0.08342873f, 
    0.21831131f, 0.12121344f, 0.22051817f, 0.02295761f, 0.04350758f, 0.06224013f, 0.06092886f, -0.09763150f, 
    -0.03523044f, 0.12298093f, -0.05167014f, 0.17001344f, 0.05436834f, -0.14858268f, -0.22560376f, 0.16868538f, 
    -0.00614392f, -0.10223004f, 0.19053246f, 0.19730499f, -0.37033057f, 0.18248078f, 0.06644469f, 0.01321326f, 
    -0.22851659f, -0.01693910f, 0.06676979f, -0.03685696f, -0.01776769f, 0.03517700f, -0.14284004f, -0.18829370f, 
    -0.04669223f, 0.04811604f, 0.16815746f, -0.09983533f, 0.11004282f, -0.03152102f, -0.20133822f, 0.03689050f, 
    -0.20674841f, -0.05590989f, 0.17188284f, -0.27948013f, 0.02108097f, 0.12905236f, -0.06085018f, -0.01948334f, 
    -0.00232492f, -0.10790861f, 0.00697805f, -0.28912175f, -0.16680965f, 0.10484853f, -0.01693827f, -0.17257591f, 
    -0.05809896f, -0.17313696f, -0.11219078f, -0.10454293f, -0.29552567f, -0.23409669f, 0.03635306f, -0.00500809f, 
    0.12151156f, 0.10219191f, 0.19605173f, 0.01592730f, -0.05929229f, -0.29508817f, 0.04971490f, 0.07015751f, 
    0.13645172f, 0.04766725f, 0.13777801f, 0.10830248f, -0.00155093f, -0.17792764f, -0.10835282f, 0.02211365f, 
    0.05865069f, -0.01190031f, 0.09565736f, -0.12403803f, -0.08816214f, -0.03104832f, 0.02147708f, -0.05936338f, 
    -0.01916957f, 0.05344004f, 0.11068297f, 0.02702129f, 0.04116562f, 0.14039347f, 0.13241448f, 0.08751979f, 
    -0.18336032f, 0.03762506f, 0.15112524f, 0.05025740f, 0.01534670f, 0.03395221f, 0.09985158f, 0.08081945f, 
    -0.07107342f, -0.22977856f, 0.11242642f, -0.21686023f, 0.06617269f, 0.00816948f, -0.01180392f, 0.07556932f, 
    0.09312174f, 0.03733379f, 0.09304050f, -0.10427719f, 0.09281968f, 0.01735313f, 0.11591967f, 0.00293902f, 
    0.08403732f, 0.04368214f, 0.13486283f, -0.01609018f, -0.04434428f, -0.07180998f, -0.24452183f, -0.00057520f, 
    -0.09648389f, 0.09177741f, 0.13402843f, 0.10780182f, 0.28012565f, 0.07830445f, 0.11005004f, -0.06002743f, 
    0.14562087f, -0.01494718f, -0.06780957f, 0.18121620f, 0.01920266f, -0.12202834f, -0.00940855f, 0.04604393f, 
    0.13515407f, -0.01768907f, -0.08297212f, -0.04355833f, 0.10951081f, 0.11290109f, 0.12019914f, -0.11472303f, 
    -0.30334833f, 0.19080701f, -0.18164060f, 0.05859556f, -0.12762880f, -0.00343589f, -0.03288337f, -0.04610626f, 
    0.02005930f, -0.01719137f, 0.00203400f, 0.05238231f, -0.10131935f, 0.07646328f, -0.00894300f, 0.05710713f, 
    -0.04551830f, 0.15779792f, -0.33668244f, -0.21005279f, 0.03473265f, 0.14529344f, 0.15133294f, 0.02879246f, 
    -0.14261864f, -0.18484157f, 0.25366154f, -0.10932017f, 0.09578715f, -0.04234518f, 0.04183668f, 0.05641460f, 
    -0.05589958f, 0.16482714f, -0.24513754f, 0.07478063f, -0.18414995f, -0.08724548f, -0.03905085f, 0.04413900f, 
    0.10270214f, -0.04734798f, -0.10088792f, 0.06737879f, -0.18102460f, 0.10893631f, -0.00773820f, -0.11273831f, 
    -0.01707637f, 0.05231078f, -0.09658903f, -0.05646668f, 0.19883671f, -0.06735390f, -0.09763496f, -0.08542050f, 
    -0.04850208f, -0.01418285f, 0.06097933f, -0.10731041f, -0.14693499f, 0.13649568f, 0.09025016f, 0.11208378f, 
    0.05734256f, 0.08042320f, 0.09663304f, 0.10332621f, -0.09195010f, 0.01968349f, 0.15419373f, 0.15553869f, 
    0.00186702f, -0.00165432f, -0.08232717f, 0.10931176f, -0.02240009f, -0.10918905f, 0.10627490f, 0.07953988f, 
    -0.14115657f, -0.10230456f, -0.09797440f, -0.03546133f, 0.25006065f, 0.01383062f, 0.16824351f, -0.06444623f, 
    -0.08804234f, -0.20860308f, -0.03828944f, -0.09582488f, 0.02710458f, 0.22705778f, 0.16591386f, 0.06064333f, 
    -0.07552616f, 0.09030079f, 0.14583580f, -0.25490287f, 0.00717624f, 0.13934208f, 0.12210108f, -0.04969577f, 
    0.13827652f, 0.00182928f, 0.05515271f, -0.21057175f, 0.01395810f, -0.09598623f, 0.10912016f, -0.09270813f, 
    0.00972966f, 0.10655575f, 0.08895336f, -0.28313088f, 0.00568020f, -0.24413848f, -0.16911283f, -0.03441712f, 
    0.05380261f, 0.14347565f, 0.03134270f, 0.10488176f, 0.09608867f, 0.05435151f, 0.06703439f, -0.12718044f, 
    0.05548671f, 0.10527560f, 0.07070456f, 0.19063722f, -0.07831928f, -0.20228031f, -0.13072768f, -0.52380079f, 
    -0.12060442f, -0.02051477f, 0.03749788f, 0.00805408f, -0.02589021f, 0.03476773f, 0.00311434f, 0.01321160f, 
    0.04593345f, 0.08244754f, 0.02190732f, 0.11278836f, 0.03656494f, 0.18109994f, 0.03545157f, 0.08630084f, 
    -0.06486740f, -0.15430625f, -0.12400576f, 0.16121063f, -0.16685046f, -0.10375060f, -0.28190881f, -0.06428741f, 
    -0.04422020f, 0.24840839f, 0.04046598f, 0.10196866f, -0.02214928f, -0.13552314f, -0.12301681f, 0.10012149f, 
    0.10855170f, -0.17450471f, 0.13863516f, -0.14259595f, 0.11396649f, -0.10279146f, -0.00161599f, 0.00189449f, 
    0.05162754f, -0.08579739f, -0.09125377f, 0.17110187f, -0.11746265f, -0.07353131f, 0.16745058f, 0.14499980f, 
    0.04782464f, 0.17280121f, -0.05134097f, -0.15331107f, 0.02351110f, -0.12021496f, -0.13722126f, -0.00681084f, 
    -0.09979606f, -0.08033014f, -0.14586906f, 0.12399355f, -0.26442626f, 0.28231472f, -0.54041207f, -0.13685951f, 
    0.13747033f, -0.09972183f, 0.17349893f, -0.02398110f, -0.03492499f, 0.01327055f, 0.26481804f, 0.15472136f, 
    0.26513979f, -0.08456297f, 0.00097617f, -0.03279894f, -0.02918965f, 0.06897525f, -0.01669912f, -0.14797607f, 
    0.24438718f, 0.11351273f, 0.07761047f, -0.09470847f, -0.00901850f, -0.01205801f, 0.08275463f, 0.08923887f, 
    0.05688389f, -0.32777020f, -0.03049313f, -0.06913250f, -0.04354532f, 0.11764402f, 0.05984528f, 0.04713630f, 
    0.06014574f, 0.13195011f, -0.05947287f, 0.01854158f, -0.06688567f, 0.08060785f, 0.11884240f, -0.01769514f, 
    0.10798411f, 0.06667151f, -0.28367317f, 0.12150726f, 0.05400888f, -0.05604580f, -0.10593833f, 0.13630837f, 
    0.07895803f, -0.05735924f, 0.13425010f, 0.18261042f, 0.13977249f, -0.03414334f, -0.07154780f, 0.02547432f, 
    0.02518458f, -0.04096714f, 0.06564999f, 0.14664461f, -0.17514037f, 0.09520869f, -0.12222585f, -0.00623741f, 
    -0.08717810f, -0.00599919f, 0.00146158f, 0.01632116f, 0.29949677f, -0.06375335f, -0.04007255f, -0.31626740f, 
    0.04705008f, -0.12616117f, 0.26491007f, -0.04695046f, -0.00613898f, 0.23415121f, -0.19153085f, 0.08132587f, 
    0.01291617f, -0.03404959f, -0.08507351f, 0.17455539f, -0.12712443f, -0.04698643f, -0.06123427f, -0.19777659f, 
    -0.27783096f, -0.17995274f, -0.08660084f, 0.07092850f, 0.02671521f, -0.03475433f, 0.04297081f, -0.03113752f, 
    0.10043199f, -0.15695187f, 0.01547869f, 0.06317957f, -0.00133905f, -0.07766361f, -0.01609147f, 0.02327508f, 
    0.37408265f, -0.51370776f, 0.07215107f, 0.02438494f, 0.01679874f, 0.24057221f, 0.04497492f, -0.05050032f, 
    0.09374883f, 0.22103092f, 0.28910288f, -0.22371984f, -0.23392667f, -0.08830227f, -0.07098887f, -0.11352962f, 
    0.01172833f, 0.14261650f, 0.19372255f, 0.13722555f, -0.16734649f, 0.07534830f, -0.01253202f, 0.17861857f, 
    -0.04310377f, 0.20106690f, -0.19209610f, -0.43668702f, -0.01830529f, 0.30687231f, -0.19272523f, 0.09294159f, 
    0.12844028f, 0.08086653f, 0.12703402f, 0.02720158f, -0.13730876f, 0.17035304f, 0.12008811f, -0.18864976f, 
    -0.00131345f, -0.12541381f, 0.05961956f, 0.12624259f, 0.07325962f, 0.39512226f, 0.14997771f, 0.01802545f, 
    0.11239050f, 0.07119996f, -0.06902520f, -0.04321951f, 0.03370577f, -0.04315817f, 0.00890355f, 0.19711351f, 
    -0.17190257f, 0.01947280f, -0.11899824f, 0.14174780f, -0.01018287f, 0.08536559f, -0.07118283f, 0.31676731f, 
    -0.00648816f, -0.05586754f, 0.04463395f, 0.03911364f, 0.13378400f, 0.00012186f, -0.02267797f, 0.04770458f, 
    0.22219805f, 0.04878519f, -0.28057483f, -0.03950093f, -0.08785725f, -0.00181970f, 0.00150246f, -0.01724873f, 
    0.05325212f, -0.36320105f, 0.03538973f, -0.41357815f, 0.00578788f, -0.11527205f, 0.02635144f, -0.04608381f, 
    0.09624963f, -0.14667083f, -0.23233688f, 0.02274696f, 0.12266645f, 0.12213961f, -0.12409885f, 0.04686372f, 
    0.24105069f, 0.04548190f, -0.20892619f, -0.05856722f, -0.53873158f, -0.07965918f, 0.12544723f, -0.33351913f, 
    -0.08377483f, 0.08224525f, -0.01698078f, -0.17844190f, 0.20751579f, 0.26339269f, 0.25051782f, -0.05627346f, 
    0.01227863f, -0.08665802f, -0.10352302f, -0.03744522f, -0.13076641f, 0.18283774f, -0.75264508f, -0.07231009f, 
    0.05552463f, 0.10927019f, -0.09435038f, -0.02122768f, 0.18479072f, 0.16832624f, -0.17108050f, 0.18104362f, 
    -0.06445131f, -0.14043890f, -0.05001858f, -0.02556136f, -0.01936420f, -0.02377971f, -0.02494247f, -0.00123071f, 
    0.07348583f, 0.03841662f, -0.07887262f, 0.20382857f, 0.02092100f, 0.10105731f, 0.13232002f, 0.29448426f, 
    -0.20123234f, -0.10420314f, 0.04484951f, 0.06236842f, 0.02511806f, 0.02915764f, -0.03957330f, -0.05504683f, 
    -0.12575558f, 0.33023539f, 0.69145095f, -0.19201703f, -0.05820529f, 0.04412540f, 0.22049226f, 0.00616466f, 
    -0.13869423f, 0.07436087f, -0.12327044f, 0.05214377f, 0.05431784f, -0.06354355f, 0.01767292f, 0.01068329f, 
    -0.07126565f, 0.05657817f, 0.18909195f, -0.34934509f, -0.15004344f, 0.00180224f, -0.04627512f, -0.07588144f, 
    -0.28334329f, 0.10982998f, -0.10442203f, 0.09371982f, 0.15760291f, -0.22136505f, -0.05515343f, 0.23816280f, 
    0.05477561f, -0.00695112f, -0.02894071f, -0.14783986f, 0.08008836f, 0.24604729f, -0.16547886f, 0.23112704f, 
    0.10602798f, -0.02114419f, -0.04347687f, -0.06701638f, 0.04503270f, -0.02097885f, -0.55169570f, 0.12212057f, 
    0.08938745f, -0.22763628f, -0.07487226f, -0.09162498f, 0.07093338f, 0.02799487f, -0.09440692f, -0.14920165f, 
    -0.29861245f, -0.20606390f, 0.00755467f, -0.00808622f, -0.05170225f, 0.00404276f, 0.13293473f, 0.17178823f, 
    -0.11286613f, -0.15753673f, 0.15810193f, 0.13734481f, -0.04962576f, -0.08655032f, 0.05026203f, 0.04474480f, 
    0.03182045f, -0.33821625f, -0.29967803f, 0.28381526f, -0.12211396f, -0.20755959f, -0.23468503f, 0.02115645f, 
    0.19539928f, -0.06034238f, 0.11064722f, 0.17425741f, -0.16719204f, 0.00778443f, -0.08403289f, 0.05250024f, 
    -0.04762588f, -0.00094236f, -0.01350900f, 0.00471755f, -0.20784388f, -0.15921074f, -0.16518144f, -0.07735544f, 
    -0.22722627f, 0.15815893f, 0.16163471f, -0.00608950f, 0.20565504f, -0.08812123f, 0.06147359f, -0.21986024f, 
    -0.08860148f, 0.08518359f, 0.06003273f, 0.08695789f, 0.07459410f, -0.16789480f, -0.21887434f, 0.17032194f, 
    -0.15003183f, -0.08853547f, -0.10763682f, -0.01545806f, 0.03613377f, -0.00730298f, 0.32543701f, -0.14763774f, 
    -0.08765037f, -0.01371583f, 0.14114463f, -0.04200172f, -0.11448311f, 0.05314205f, 0.02785451f, 0.19124913f, 
    0.26988733f, 0.00165525f, 0.03417685f, -0.16032615f, 0.03297241f, -0.06118079f, 0.08223325f, 0.07973216f, 
    -0.78775144f, -0.35998574f, -0.12936798f, 0.16469148f, -0.08153871f, 0.04045923f, -0.16610208f, 0.15232502f, 
    -0.01747855f, 0.22569327f, 0.11523787f, -0.18590151f, -0.07600749f, 0.03763863f, 0.09083664f, -0.03512751f, 
    0.04887141f, -0.04581113f, 0.01042609f, 0.01365936f, 0.02523273f, -0.01164456f, 0.07279652f, 0.18550935f, 
    -0.23122658f, -0.01561252f, 0.11347025f, -0.16220348f, -0.12456912f, -0.26746947f, -0.26952562f, -0.20371237f, 
    -0.21925530f, -0.01532067f, -0.03754250f, 0.01647262f, 0.05818741f, 0.07541483f, -0.04132672f, 0.06668908f, 
    0.01842566f, 0.01498602f, -0.00735325f, 0.10003299f, 0.16151133f, 0.34711602f, 0.19969541f, 0.11444823f, 
    0.00908458f, 0.18910453f, 0.00340952f, 0.00170833f, 0.05049518f, -0.08717439f, 0.06981235f, 0.11827371f, 
    -0.02828347f, 0.02637846f, 0.00224834f, -0.03573839f, -0.08018893f, 0.00745633f, 0.14666171f, 0.31235242f, 
    0.19285689f, -0.04837823f, 0.09912935f, 0.13072515f, 0.12441612f, -0.03841939f, -0.03494519f, -0.34702662f, 
    0.20966001f, 0.13708217f, -0.08308957f, -0.00088974f, 0.04869529f, -0.01956172f, -0.02305607f, 0.04411405f, 
    -0.08329097f, -0.03243231f, -0.20239349f, -0.20984210f, -0.00140942f, -0.08782863f, 0.12089227f, 0.15568659f, 
    0.01569971f, 0.01845660f, -0.13422245f, -0.01336992f, 0.38301253f, 0.03485699f, -0.01022777f, 0.08601063f, 
    -0.03215368f, -0.10346065f, 0.03434549f, 0.05915182f, -0.37334397f, 0.17988269f, -0.11335310f, 0.07905327f, 
    0.03174898f, 0.09772517f, -0.09687425f, 0.04090172f, 0.17562780f, 0.27784392f, 0.06991299f, 0.03868086f, 
    0.00842810f, 0.04390874f, 0.08274167f, -0.22958092f, -0.10270090f, 0.23882541f, -0.15828934f, -0.05409266f, 
    -0.00925981f, 0.07458456f, -0.00811209f, 0.11286005f, 0.06684851f, 0.09450699f, -0.18446548f, -0.24723473f, 
    -0.39183760f, -0.13394158f, -0.01124782f, -0.08026329f, 0.09153428f, 0.01974339f, -0.07965200f, 0.09710465f, 
    0.15705264f, -0.12993805f, -0.23204415f, 0.31650141f, 0.15569712f, 0.10589246f, 0.08003621f, -0.01451792f, 
    -0.39703026f, -0.35855323f, -0.05796110f, -0.01946317f, 0.07201479f, -0.04008476f, -0.01087482f, -0.04853119f, 
    0.03235181f, -0.05124309f, -0.01459901f, -0.21254502f, -0.07833833f, 0.06635793f, 0.12429550f, 0.00870559f, 
    0.08450370f, -0.10582683f, -0.04522679f, 0.01610968f, -0.04768913f, -0.07611386f, -0.14365883f, 0.01468343f, 
    -0.15291069f, 0.25559327f, -0.07974660f, -0.12440468f, -0.10775139f, -0.24360482f, -0.14254436f, 0.07632336f, 
    -0.15623432f, 0.01870690f, 0.07243107f, 0.02687373f, -0.42119932f, -0.08025954f, 0.10431802f, -0.05079990f, 
    0.07765382f, 0.03278496f, -0.06914058f, -0.16300286f, -0.02790840f, -0.19948296f, -0.05645249f, 0.08177970f, 
    0.04394455f, 0.04043521f, 0.00765979f, -0.00245189f, 0.03020132f, 0.10754559f, -0.60544342f, 0.15570429f, 
    -0.09221070f, -0.03554344f, -0.08633057f, 0.05909428f, 0.09220578f, -0.01576779f, 0.13005497f, -0.19658193f, 
    0.03648128f, 0.10371320f, -0.08870099f, 0.05610368f, -0.03946698f, -0.16830881f, 0.00782354f, -0.01499677f, 
    -0.04596067f, -0.03027513f, 0.02082936f, -0.07305014f, -0.08537592f, 0.09370965f, -0.18057838f, 0.07051254f, 
    0.13133220f, -0.27225769f, 0.10218813f, 0.25644097f, 0.00862686f, -0.03777381f, -0.07093399f, 0.00292364f, 
    -0.04070513f, 0.04987236f, 0.03910444f, 0.15738557f, -0.02347378f, -0.09390619f, -0.00841263f, -0.07961504f, 
    -0.15398960f, 0.06084614f, 0.10233156f, -0.17358528f, 0.09710366f, -0.00140524f, -0.03563095f, 0.14402854f, 
    0.01957416f, -0.08649120f, 0.02312594f, -0.01113901f, -0.21097761f, -0.25816703f, -0.17289558f, -0.20135888f, 
    -0.19396654f, 0.16762900f, 0.03919938f, 0.03963682f, 0.00509343f, -0.20933348f, 0.12697752f, -0.09492198f, 
    -0.17468563f, -0.19274105f, 0.01628129f, -0.01957151f, 0.04849454f, 0.05554398f, 0.44229341f, 0.44294256f, 
    0.19302534f, -0.02083416f, 0.10184564f, 0.03376991f, 0.03398729f, 0.23720284f, -0.27762747f, 0.08594065f, 
    0.16349556f, -0.00262198f, 0.04771913f, 0.03015260f, -0.18071508f, -0.00393094f, -0.01656331f, -0.00394394f, 
    -0.03642638f, 0.09191108f, 0.11387818f, -0.00856521f, 0.09958022f, -0.14092232f, -0.06024380f, -0.12536828f, 
    0.14783941f, -0.15073340f, 0.01080356f, 0.15338150f, 0.10451414f, -0.03040840f, -0.05469573f, -0.00846080f, 
    0.00273321f, 0.01021193f, -0.19303229f, -0.03219498f, 0.24169762f, 0.11715522f, 0.02343908f, -0.10030589f, 
    0.02586219f, 0.09150340f, 0.05862724f, 0.19037570f, -0.00650959f, -0.08221751f, 0.02995959f, 0.02681815f, 
    -0.04870998f, 0.03174085f, 0.10382693f, -0.01840092f, -0.19586493f, -0.00526037f, 0.00755981f, 0.16639011f, 
    0.12754196f, -0.08257166f, -0.04222684f, 0.21635784f, 0.08492914f, 0.09471122f, 0.15872093f, 0.36644199f, 
    -0.14219669f, 0.09266555f, 0.08208164f, 0.03188320f, 0.02936166f, -0.02592344f, 0.01659836f, 0.08404892f, 
    0.12102006f, 0.13931161f, -0.05396158f, -0.06724471f, 0.08497182f, 0.30403024f, 0.17258662f, 0.05953909f, 
    0.08512659f, 0.20544159f, -0.02936386f, -0.13919538f, -0.01677252f, 0.03330902f, -0.11703503f, -0.04205440f, 
    -0.03186788f, 0.14618881f, 0.26518220f, 0.05485035f, -0.04645373f, -0.04510210f, -0.00121870f, -0.09582443f, 
    -0.04745998f, -0.26202786f, -0.07683243f, -0.21421240f, 0.00040699f, 0.04299469f, -0.03615449f, -0.19565594f, 
    0.01751035f, 0.16723986f, -0.25030887f, -0.18267845f, -0.01989145f, -0.03777941f, -0.01552920f, 0.00261061f, 
    -0.12774177f, 0.01230472f, 0.03268410f, -0.07375551f, 0.08206259f, -0.11936131f, 0.11982153f, -0.09580574f, 
    -0.02256198f, -0.10412138f, -0.06742009f, 0.27734405f, -0.13296841f, -0.04495857f, 0.27343181f, 0.09800199f, 
    0.01448415f, 0.00111030f, -0.02416138f, 0.16588889f, 0.01728732f, -0.01484088f, 0.27950722f, 0.29279292f, 
    -0.05414187f, -0.08478448f, 0.05325733f, -0.12069344f, -0.13093650f, -0.03379767f, 0.12006885f, 0.01765591f, 
    -0.26733953f, 0.14827183f, 0.06398057f, 0.08303183f, -0.00584405f, 0.04023263f, 0.06858608f, -0.21751900f, 
    0.24554023f, -0.15345906f, 0.09331639f, -0.04419616f, 0.18446371f, 0.18391466f, 0.25645521f, -0.12658760f, 
    -0.14717901f, -0.13757467f, -0.10822511f, -0.27386954f, -0.10914682f, 0.04314383f, 0.14698806f, 0.08403783f, 
    -0.09552491f, -0.92507541f, -0.58391607f, 0.17558765f, -0.17632987f, 0.18516900f, -0.13523351f, -0.20318246f, 
    0.04064072f, -0.03472874f, 0.00920701f, 0.06156540f, -0.00863119f, 0.15888205f, -0.04628865f, 0.29286858f, 
    0.02897564f, 0.01094515f, 0.00007357f, -0.13020042f, -0.04557448f, -0.07146576f, 0.03195809f, -0.00799000f, 
    0.38097912f, 0.21200447f, -0.03981202f, -0.12138304f, -0.23483512f, -0.29683390f, -0.11864798f, 0.08018504f, 
    0.08817238f, -0.04669365f, 0.02449835f, 0.23285994f, -0.11932319f, 0.01878407f, -0.22316794f, -0.16806297f, 
    -0.08815274f, -0.12197375f, -0.00013939f, 0.18546221f, 0.04611015f, -0.13826197f, -0.01000231f, -0.25484785f, 
    -0.10855784f, -0.10827643f, 0.00678989f, 0.10549188f, -0.03462920f, -0.02410423f, 0.04131056f, -0.03391269f, 
    0.01228840f, 0.03907344f, -0.11265678f, 0.20173749f, -0.08640195f, -0.04837528f, 0.13344312f, -0.15713441f, 
    -0.04321228f, -0.10065255f, 0.09257774f, 0.17561367f, -0.00068271f, 0.05147697f, 0.06664598f, -0.00656457f, 
    -0.04281257f, -0.03648880f, -0.04731181f, 0.08544417f, -0.14800429f, 0.09394801f, -0.20786576f, -0.02823875f, 
    -0.01738565f, 0.07602386f, 0.10992938f, 0.17400560f, 0.24479334f, -0.01239782f, -0.14074020f, 0.02796246f, 
    0.18654439f, 0.21685186f, 0.08219878f, -0.06467628f, 0.01457507f, 0.03521511f, 0.08318706f, -0.01012151f, 
    -0.00484338f, -0.00399770f, 0.11514276f, 0.10077595f, -0.08248431f, -0.18508424f, 0.17026281f, 0.15509728f, 
    0.07007175f, -0.01498382f, -0.07105135f, 0.15506528f, -0.00374643f, -0.09165034f, -0.30913273f, -0.02263745f, 
    0.11659729f, 0.07017452f, 0.04146536f, -0.03738445f, -0.05008894f, 0.09350794f, -0.62076759f, 0.27160695f, 
    0.43663293f, 0.07001590f, -0.08373836f, -0.00068032f, -0.02920240f, -0.18668428f, -0.09087759f, 0.03274234f, 
    0.40462482f, -0.00483479f, -0.08407488f, 0.05260194f, 0.06990758f, 0.13741505f, 0.11992693f, 0.01852235f, 
    0.00050236f, -0.02639712f, -0.01726442f, -0.04988043f, -0.04556756f, -0.00104293f, 0.02064371f, -0.01833167f, 
    0.03206762f, -0.02964602f, 0.03995785f, 0.05138316f, 0.01704611f, -0.05441461f, 0.05030286f, 0.01674742f, 
    0.03251199f, -0.05885150f, -0.01085644f, -0.00927798f, -0.01936496f, 0.03906946f, 0.04592515f, -0.05945729f, 
    0.02094778f, -0.06077708f, 0.00750454f, -0.03356144f, -0.00181502f, 0.01890354f, -0.05392807f, -0.01045996f, 
    -0.00285626f, -0.00553359f, -0.05998484f, 0.02346972f, -0.03035789f, 0.02331057f, 0.03234489f, -0.03430720f, 
    -0.04858595f, 0.02393282f, -0.05568453f, 0.00908337f, -0.00626914f, 0.00952476f, -0.05518477f, 0.00768281f, 
    -0.04294789f, -0.04408238f, -0.00639692f, -0.03702655f, -0.03972936f, -0.04116185f, -0.01534958f, -0.02147420f, 
    -0.06267873f, 0.02739205f, -0.05417579f, -0.02117914f, -0.01435873f, -0.05855364f, -0.04471469f, -0.00603747f, 
    -0.00755727f, 0.05482987f, 0.03439359f, -0.01076330f, 0.00331725f, 0.00825817f, 0.01870411f, -0.05854793f, 
    -0.04755953f, -0.01685038f, -0.02304055f, -0.01178599f, -0.03519115f, 0.02866701f, -0.05385444f, -0.03894684f, 
    -0.01951390f, -0.00287029f, -0.03234730f, 0.00691288f, -0.04468763f, 0.01029928f, 0.00421344f, -0.05972413f, 
    -0.00390814f, -0.03939450f, -0.01113432f, -0.02484165f, 0.04571456f, 0.04204001f, -0.02614152f, -0.01616332f, 
    -0.00642059f, 0.04841518f, -0.01092749f, 0.01625717f, 0.03900823f, -0.04165824f, 0.02492352f, -0.03393522f, 
    -0.01540500f, 0.04916696f, -0.03382405f, -0.00499774f, 0.04577887f, 0.00765024f, -0.03826191f, 0.02362406f, 
    -0.06428516f, -0.02475218f, -0.05699394f, -0.01670004f, 0.02709949f, -0.01430093f, -0.04226601f, -0.01001945f, 
    -0.06019370f, -0.04008429f, 0.02140585f, 0.03490317f, -0.02823850f, -0.04956005f, 0.01323063f, 0.01634926f, 
    -0.03550765f, 0.03454827f, 0.00843670f, -0.04855787f, 0.00043744f, 0.01899657f, 0.02257028f, -0.03352103f, 
    0.01935743f, 0.01980519f, 0.01830482f, 0.02120906f, 0.03600312f, 0.02698628f, -0.01906268f, -0.04451129f, 
    0.01735315f, -0.02776556f, 0.04361577f, -0.02763615f, -0.01286064f, -0.04526995f, -0.00074714f, -0.06134025f, 
    -0.05273079f, 0.00399294f, -0.05264210f, -0.00456536f, -0.00695880f, -0.01707418f, -0.03000023f, -0.00830492f, 
    -0.05328795f, -0.02593971f, -0.02033731f, 0.02774967f, -0.00810596f, -0.01107404f, -0.01151626f, 0.02978297f, 
    -0.04579072f, -0.00669712f, 0.00696750f, -0.00781939f, -0.04482948f, -0.05057752f, -0.02953994f, 0.01048597f, 
    -0.02829020f, 0.02233739f, 0.00513304f, 0.02032846f, -0.02780661f, 0.04451591f, 0.02423796f, -0.01859505f, 
    -0.00031784f, -0.04167859f, 0.04948977f, -0.03408097f, -0.06232954f, 0.03836155f, -0.06364775f, 0.02401298f, 
    -0.01595260f, 0.02749602f, 0.03969300f, -0.04993147f, -0.04220645f, -0.04795629f, -0.05496865f, -0.01443279f, 
    -0.05403931f, 0.01944816f, 0.04369092f, -0.02660628f, -0.03227412f, 0.01539872f, -0.03994766f, -0.02915520f, 
    0.03866792f, 0.02431269f, -0.01304417f, 0.00404834f, 0.02387943f, 0.04869599f, 0.01117756f, 0.04557579f, 
    -0.00382888f, -0.03076090f, 0.04233219f, -0.01709534f, -0.06212940f, 0.01864436f, -0.03144608f, 0.05003596f, 
    0.00063044f, -0.02520262f, 0.02221244f, -0.00196653f, 0.02479239f, 0.03677646f, 0.03296822f, -0.00036441f, 
    -0.02594261f, -0.01090653f, -0.00428483f, 0.00371458f, 0.01489500f, -0.01492260f, 0.02337783f, 0.01350395f, 
    -0.04182246f, -0.00384728f, -0.06130860f, -0.06145209f, 0.01239764f, -0.00228977f, 0.04083418f, -0.03580271f, 
    -0.06186604f, -0.01102586f, -0.04309245f, -0.04245415f, -0.01836883f, 0.00298178f, 0.04035525f, -0.03748709f, 
    -0.00191953f, -0.03086554f, -0.05051796f, 0.03526984f, -0.04363171f, 0.01445359f, 0.04988572f, -0.00403088f, 
    -0.03443058f, -0.05789137f, 0.02207362f, -0.04067150f, 0.00053218f, -0.00613491f, -0.03663277f, -0.04194261f, 
    -0.05117336f, 0.02298078f, 0.01252547f, -0.02828661f, 0.03325377f, -0.05847769f, -0.01917434f, 0.01288478f, 
    -0.00945119f, -0.04901681f, -0.02289900f, -0.02016660f, -0.01124849f, -0.00012879f, -0.02756779f, 0.03805970f, 
    -0.48739770f, 0.28718248f, 0.20437130f, -0.26586771f, 0.07550258f, 0.05547585f, 0.04287502f, 0.03547654f, 
    0.04340488f, -0.06070254f, 0.00691837f, -0.02917117f, -0.04422520f, 0.01182585f, -0.17760953f, -0.04499080f, 
    0.10290500f, 0.06705366f, 0.26976579f, 0.21715358f, 0.11110348f, -0.17213663f, 0.11959305f, -0.05580834f, 
    0.10050145f, 0.03728943f, 0.06436637f, -0.17759545f, 0.08448491f, 0.13055260f, -0.03796931f, 0.03741647f, 
    0.05083603f, -0.02921114f, -0.01891423f, -0.13664113f, -0.01300455f, 0.18492836f, 0.02093649f, 0.06163173f, 
    -0.05682120f, 0.06611617f, -0.07049573f, -0.03949504f, -0.01999537f, 0.36068904f, 0.18254854f, 0.04454562f, 
    0.00187703f, 0.11575146f, -0.12548392f, -0.03974374f, 0.03098271f, -0.04065958f, 0.29639661f, 0.17642814f, 
    0.02455093f, 0.03136325f, -0.00697535f, -0.01446541f, 0.05441944f, -0.02186671f, -0.11694315f, -0.02839117f, 
    0.05707210f, 0.12050892f, 0.01465470f, -0.10133459f, 0.06664926f, 0.16989867f, 0.10767431f, 0.12506521f, 
    -0.08801427f, -0.01455599f, 0.03531941f, -0.00548131f, -0.13272643f, -0.07129221f, -0.03049798f, 0.05532398f, 
    0.12055326f, -0.22801428f, -0.01234515f, -0.03030255f, -0.11500594f, -0.15400399f, -0.00957549f, -0.02196621f, 
    0.09091531f, 0.00403502f, -0.14996891f, 0.10100273f, -0.02404075f, 0.05404649f, 0.05888857f, 0.20126562f, 
    -0.05520595f, -0.07078767f, 0.09768497f, 0.14569417f, 0.15987274f, 0.15356316f, -0.15365542f, -0.16417542f, 
    0.17271067f, -0.06819649f, -0.01608028f, 0.13007995f, 0.04883833f, 0.29145125f, 0.00952159f, -0.02750163f, 
    -0.01747924f, -0.03337706f, 0.04110476f, 0.12853222f, 0.01328500f, 0.03945678f, 0.20667131f, 0.35522741f, 
    -0.27455205f, -0.19541223f, -0.28821966f, 0.09578293f, 0.01009590f, 0.07906802f, 0.09482684f, 0.01916397f, 
    0.02895626f, 0.02058961f, 0.06901523f, 0.16252971f, 0.05696878f, -0.04774467f, -0.07065620f, 0.06418219f, 
    0.33251140f, -0.08121736f, 0.11313913f, 0.29898918f, 0.02377374f, 0.15363762f, 0.11875840f, -0.06132406f, 
    -0.02902620f, -0.04535428f, 0.10985806f, 0.00044652f, 0.07290514f, -0.07705630f, 0.11792634f, -0.07970545f, 
    -0.10826832f, -0.50033331f, 0.04679694f, 0.09515143f, -0.09140075f, 0.09436981f, -0.39270478f, 0.07914949f, 
    0.13728763f, -0.05792396f, -0.17574766f, 0.11559325f, 0.08524574f, -0.06266534f, 0.02581226f, 0.23914318f, 
    -0.07253949f, -0.10415741f, -0.11371288f, -0.35791931f, 0.05837066f, -0.01563937f, -0.16315249f, 0.10866357f, 
    -0.08682094f, 0.17549761f, 0.12199885f, -0.09265380f, -0.21631214f, 0.32332855f, -0.11067155f, -0.08535739f, 
    -0.01378772f, 0.02312746f, -0.14362392f, 0.27105546f, -0.15868996f, -0.03607872f, 0.22336486f, -0.01366608f, 
    0.05600227f, 0.13310127f, 0.01875605f, 0.18747751f, 0.17941703f, -0.02672162f, -0.27874812f, -0.20631850f, 
    -0.20417993f, -0.04507552f, -0.04077006f, -0.11904106f, -0.22289820f, -0.04217964f, -0.04666059f, 0.04495671f, 
    0.15493642f, 0.14670369f, -0.28392974f, -0.06640387f, 0.02282949f, 0.05752162f, -0.01926519f, 0.00050539f, 
    -0.07903392f, 0.11484420f, -0.12112614f, 0.10706995f, 0.06359396f, -0.15176868f, -0.02846240f, 0.13914387f, 
    0.00155412f, -0.13503282f, 0.07113367f, -0.26658180f, 0.03782897f, 0.01057745f, -0.18483855f, -0.05521630f, 
    -0.06438979f, 0.00045145f, 0.39995158f, 0.12472545f, 0.06005671f, -0.02725630f, 0.02159450f, -0.01322338f, 
    0.03105782f, -0.02642208f, 0.07449314f, 0.00026849f, 0.17615782f, -0.25241658f, -0.12344393f, -0.19669604f, 
    0.12874918f, -0.04173873f, -0.06950282f, -0.13925169f, 0.03102156f, -0.02254230f, 0.06207219f, -0.02150923f, 
    0.26184267f, -0.01242370f, 0.11042485f, -0.08555401f, -0.25744024f, -0.39443633f, -0.07792205f, -0.01341021f, 
    0.04130616f, 0.00542043f, -0.05741673f, -0.08560517f, 0.01224905f, -0.02411026f, -0.40599930f, 0.21416672f, 
    0.23978762f, 0.00711220f, -0.03805489f, -0.10610711f, -0.00918582f, -0.03925378f, 0.12281394f, 0.23393185f, 
    0.30084321f, 0.18869023f, -0.00479234f, -0.04625507f, -0.12978016f, -0.02465729f, -0.01949156f, 0.11811681f, 
    -0.17072435f, -0.30042282f, -0.17377482f, -0.16583619f, -0.06016100f, 0.22059420f, 0.13914795f, -0.13709821f, 
    0.12767647f, -0.19282858f, 0.09773372f, 0.36285183f, 0.28964588f, 0.08483750f, 0.05121443f, 0.19429475f, 
    0.21852490f, 0.18833455f, -0.27786928f, -0.23565534f, -0.02771635f, -0.03645644f, -0.05392101f, 0.16940154f, 
    0.02005282f, 0.01107753f, 0.12731178f, -0.02520221f, -0.12361015f, 0.02609543f, 0.01210300f, 0.09272814f, 
    0.25890914f, -0.14625971f, 0.16937108f, 0.23690537f, -0.06640531f, -0.08816203f, -0.11804305f, -0.05050732f, 
    0.08173085f, 0.09190653f, 0.11947411f, 0.10806056f, -0.07698064f, -0.35403609f, -0.11108211f, 0.17490777f, 
    0.10980696f, -0.05027619f, -0.02949768f, 0.18637331f, 0.10432207f, -0.20174815f, -0.39389944f, 0.05763442f, 
    0.16285945f, -0.06574357f, 0.15575230f, 0.12447953f, 0.05207884f, -0.00551489f, -0.06130551f, -0.22913145f, 
    0.20985167f, 0.27650684f, 0.00402847f, -0.07276631f, -0.04984725f, 0.06702060f, -0.11769217f, -0.13181038f, 
    -0.01914160f, 0.33527359f, 0.45656350f, 0.11585569f, -0.06893193f, 0.13767742f, 0.12925959f, -0.00924824f, 
    0.07800788f, 0.05855831f, 0.06508517f, 0.07147854f, -0.08825378f, 0.19780758f, 0.12077356f, 0.03688609f, 
    -0.00821000f, 0.11749277f, -0.02428868f, 0.00849798f, -0.08551641f, 0.01176705f, 0.01673251f, -0.23960632f, 
    -0.21206501f, -0.15431446f, 0.07595806f, 0.01608581f, -0.15351218f, -0.13294448f, -0.01106079f, -0.09549856f, 
    -0.27861238f, -0.06112675f, 0.07084624f, 0.10568479f, -0.15423778f, -0.18679497f, -0.05865518f, 0.19396119f, 
    0.00441722f, -0.04517687f, 0.08596615f, 0.18399467f, -0.23960705f, -0.59138173f, -0.05090129f, -0.15151644f, 
    -0.00723869f, -0.08825345f, 0.14248240f, -0.00977143f, 0.14475191f, -0.05444073f, -0.03218442f, -0.03569610f, 
    0.11926957f, 0.06697494f, 0.10787611f, -0.01795926f, 0.18469688f, 0.14490828f, 0.08505889f, -0.28925741f, 
    -0.31283024f, -0.39340493f, -0.34371099f, -0.11328654f, 0.00600763f, -0.06160125f, -0.09135056f, -0.05048868f, 
    -0.14771999f, -0.16621128f, -0.07871680f, -0.06989389f, -0.06455013f, 0.01574741f, 0.04917430f, 0.08894277f, 
    0.21219999f, -0.07672291f, 0.08823361f, 0.21571800f, -0.12581943f, 0.11389003f, 0.17491420f, 0.14409180f, 
    0.20657159f, 0.11706814f, 0.28923514f, 0.28887397f, 0.11148096f, 0.07986115f, 0.13668284f, 0.18005151f, 
    0.19356927f, 0.08408991f, 0.33880475f, -0.15827399f, -0.29135844f, -0.00632747f, -0.06199160f, 0.03937344f, 
    -0.03615471f, 0.20557331f, 0.19885400f, -0.01024660f, 0.42042759f, -0.31240454f, -0.18500240f, -0.00957436f, 
    -0.08793408f, 0.02606348f, 0.05851390f, -0.11153974f, 0.19884440f, -0.34732196f, -0.25882584f, -0.10754171f, 
    -0.31510344f, -0.13706389f, -0.05169592f, 0.05344285f, -0.01144616f, 0.13264872f, -0.00292541f, -0.15674680f, 
    0.00674445f, 0.01432581f, -0.00436482f, 0.03796433f, 0.09672631f, 0.08061003f, 0.08914291f, -0.13772075f, 
    -0.17972013f, -0.17859717f, -0.03787624f, 0.01323495f, 0.02148145f, 0.10440009f, 0.17127094f, 0.13035218f, 
    -0.20765430f, -0.29028735f, -0.04084168f, -0.16666132f, 0.01261190f, 0.05238731f, 0.07247465f, 0.02346092f, 
    0.09669104f, -0.05174578f, -0.25845516f, -0.12736934f, -0.16205457f, -0.05646399f, 0.03229607f, 0.05983799f, 
    0.10072377f, 0.22222048f, -0.33260280f, -0.00699662f, 0.19560212f, -0.08028238f, 0.10391460f, 0.14083450f, 
    0.15483792f, 0.11878052f, -0.07819155f, -0.07555633f, -0.13062334f, -0.00062121f, -0.01147264f, 0.02964746f, 
    -0.03036017f, 0.26139235f, 0.19287141f, 0.13040027f, 0.19916698f, -0.17897548f, 0.15924704f, 0.22294770f, 
    0.11204141f, 0.16215868f, 0.11807203f, 0.02297316f, 0.30634925f, -0.08893251f, -0.20465590f, -0.08511046f, 
    -0.04938534f, 0.01721840f, 0.13551171f, 0.10434786f, 0.01262684f, 0.14497262f, -0.15517098f, 0.13592327f, 
    0.13761364f, 0.15166207f, 0.00241019f, 0.01142906f, 0.06406363f, 0.01346508f, 0.03333964f, -0.24721846f, 
    -0.26860243f, -0.06586816f, 0.08662719f, -0.04655431f, 0.03018277f, 0.26723325f, 0.07433027f, -0.12569320f, 
    0.21080896f, -0.09611736f, 0.31515571f, -0.17572036f, 0.26413479f, 0.10852136f, -0.05341022f, -0.13257012f, 
    0.29012379f, -0.03609750f, 0.03534043f, 0.10530394f, 0.00784479f, 0.02635795f, 0.04830682f, -0.03361201f, 
    0.13607848f, 0.17628154f, -0.03956872f, 0.03948153f, 0.06222193f, 0.20290202f, -0.16180192f, 0.07084443f, 
    -0.24066232f, -0.07458848f, 0.07578854f, 0.04001691f, 0.23967618f, -0.09555379f, 0.10040054f, 0.07604517f, 
    0.06786096f, 0.02139183f, 0.07253265f, 0.07901964f, 0.00807045f, -0.04064843f, 0.02456610f, -0.00315393f, 
    0.17673162f, -0.18371826f, -0.23929192f, -0.23101568f, -0.35831711f, 0.07405891f, -0.02588214f, 0.08466942f, 
    0.00848958f, 0.07346342f, 0.18632899f, 0.05273102f, 0.09329280f, -0.06105663f, 0.05354296f, 0.01192939f, 
    0.05250213f, 0.10783444f, 0.17227419f, -0.19033399f, -0.11319061f, -0.09982508f, -0.26847386f, 0.06173528f, 
    -0.06399866f, 0.08796412f, 0.06284221f, 0.01858750f, 0.14189437f, 0.08884143f, 0.09463491f, 0.26972541f, 
    0.02189762f, -0.01533714f, 0.11327500f, -0.01592336f, 0.04279683f, 0.28802124f, 0.07375718f, 0.11731621f, 
    0.25451455f, 0.07085111f, -0.02066814f, 0.23316407f, 0.00500866f, 0.00017302f, 0.02916812f, -0.02928001f, 
    0.01905577f, -0.07790003f, -0.31255016f, 0.00598095f, 0.02750283f, -0.01166918f, 0.11172535f, 0.03605128f, 
    0.08220935f, 0.22375932f, -0.06392893f, -0.08630468f, 0.03484326f, 0.29029089f, -0.04756514f, -0.06178759f, 
    0.22060342f, 0.01765484f, -0.02681994f, -0.04525873f, -0.03714195f, -0.00068392f, 0.20801575f, 0.09014168f, 
    -0.02049150f, 0.27325636f, 0.10497843f, 0.08216067f, 0.08637682f, -0.04988866f, 0.00014552f, 0.34766209f, 
    -0.08828362f, 0.02119428f, 0.05689520f, 0.05583695f, -0.02916171f, -0.01066196f, -0.15139616f, 0.07843637f, 
    0.10331276f, 0.10192082f, 0.09928983f, 0.05203153f, 0.06328427f, 0.23269847f, 0.18155508f, -0.08080611f, 
    0.02373496f, 0.04820495f, -0.06461737f, -0.06045730f, 0.12173089f, -0.07083692f, -0.00326215f, -0.36093578f, 
    0.13574885f, 0.12530930f, -0.09543370f, 0.03839566f, 0.13185500f, 0.02194683f, 0.00930532f, 0.14573017f, 
    -0.23702922f, 0.10990302f, 0.25509974f, -0.46178088f, 0.02469349f, 0.09980699f, -0.01307233f, 0.13155803f, 
    0.24072130f, -0.18387118f, -0.07391541f, 0.08602854f, 0.18317971f, 0.00728345f, 0.13345942f, -0.14646757f, 
    0.03142613f, 0.22978117f, -0.03233975f, 0.17013855f, 0.13191342f, 0.17387611f, 0.14773756f, 0.09607443f, 
    -0.10544284f, -0.09291631f, 0.00841455f, -0.10574850f, 0.11143786f, -0.22931308f, 0.12473808f, 0.02639659f, 
    0.12761311f, 0.15858582f, 0.04938918f, 0.20133570f, 0.11609866f, 0.06005366f, 0.01007023f, 0.05782950f, 
    -0.08690351f, 0.06226331f, 0.01213978f, -0.03328160f, -0.04577149f, -0.07248641f, 0.16932604f, 0.17476597f, 
    -0.00838665f, -0.03349612f, 0.01039593f, -0.02223204f, 0.09075732f, 0.11330140f, -0.05832579f, 0.07524315f, 
    -0.06101488f, 0.01791883f, 0.06689359f, 0.02125245f, 0.12333517f, -0.03184901f, -0.07682602f, -0.20436502f, 
    0.08351423f, 0.12214717f, 0.02698774f, 0.01947116f, -0.21112743f, 0.03191112f, -0.06673038f, -0.00629886f, 
    -0.01734252f, 0.11867957f, 0.06897993f, 0.04190603f, -0.00103025f, 0.02808664f, -0.04859008f, -0.04897295f, 
    -0.16611958f, -0.04712886f, -0.07497389f, -0.09975591f, 0.12009879f, 0.00995351f, 0.09201388f, 0.01515787f, 
    -0.07659863f, -0.00454634f, -0.08923573f, 0.11647739f, -0.02063463f, -0.00701428f, 0.04580867f, 0.06544313f, 
    0.00762615f, 0.00753042f, -0.08246519f, -0.29445079f, -0.04674144f, -0.03855307f, 0.09880295f, 0.14484341f, 
    0.12927553f, -0.03021969f, 0.00321967f, -0.12790234f, -0.06069775f, 0.00875644f, 0.07151596f, 0.04338349f, 
    -0.04326765f, 0.01171781f, -0.09304238f, -0.06317498f, 0.03320158f, -0.11273140f, -0.01238278f, 0.00046868f, 
    0.07770064f, -0.06449213f, 0.09697043f, 0.10183236f, 0.10648607f, 0.15565161f, 0.09333954f, -0.09428978f, 
    -0.02256892f, 0.08654352f, 0.09647688f, 0.19447918f, 0.04319439f, -0.04482244f, 0.06720445f, -0.04928368f, 
    0.02431777f, -0.01840864f, 0.01939039f, -0.02342780f, 0.03251155f, 0.01252099f, 0.00214703f, 0.02872476f, 
    0.04682712f, -0.02746596f, -0.05212162f, -0.05033579f, -0.04772680f, 0.02512126f, -0.00590229f, -0.05643339f, 
    0.00585812f, 0.02700531f, -0.03717319f, -0.04929329f, -0.04707721f, 0.04834703f, -0.03845140f, -0.03323923f, 
    -0.01019591f, -0.04460662f, 0.04519976f, -0.00670052f, 0.03608175f, 0.01359904f, 0.01380632f, -0.04958962f, 
    -0.05810791f, 0.01237226f, -0.00984978f, 0.01038297f, -0.05572382f, -0.05688738f, -0.05721411f, 0.02231170f, 
    0.01329772f, -0.01873378f, 0.01467568f, -0.01271246f, -0.04384476f, -0.00215510f, -0.01353235f, -0.02490528f, 
    -0.06064709f, 0.01746637f, 0.01118020f, -0.01419939f, -0.03834502f, -0.04582656f, -0.04277374f, 0.03459991f, 
    0.01955338f, -0.03217363f, 0.01101811f, 0.02979913f, -0.03483633f, -0.05484618f, 0.00384749f, 0.01442997f, 
    -0.05692536f, 0.03860007f, -0.01347442f, -0.04031280f, -0.05443534f, -0.03917405f, -0.03559366f, -0.00567309f, 
    -0.03420836f, 0.03584408f, 0.00882971f, -0.02840646f, -0.02381754f, -0.02483806f, -0.00903430f, -0.04057398f, 
    -0.04054319f, -0.02642729f, 0.00177084f, 0.00328137f, -0.05973792f, 0.02805463f, -0.00496372f, -0.03556149f, 
    0.00794209f, 0.04383260f, 0.03016251f, -0.06026271f, -0.04010604f, 0.04962899f, -0.04219745f, -0.03134695f, 
    -0.04493218f, -0.05287495f, 0.04080535f, -0.02630059f, -0.03002090f, -0.02117986f, -0.04567178f, -0.03464926f, 
    -0.03245450f, -0.03504369f, -0.04794067f, 0.01251440f, -0.01171471f, -0.05526127f, 0.01672115f, 0.04992725f, 
    0.03116775f, 0.04238297f, -0.02497895f, 0.01388875f, 0.03542579f, -0.05059535f, -0.00445743f, -0.02564795f, 
    -0.02967272f, 0.04459528f, 0.00263434f, 0.01003717f, 0.04711086f, 0.02018657f, 0.04837404f, -0.06614269f, 
    -0.01414535f, 0.04404176f, -0.00403019f, -0.01824061f, 0.03645543f, 0.03602214f, 0.03700931f, -0.02250615f, 
    -0.01087726f, 0.04624163f, 0.00131816f, 0.01961233f, 0.01289132f, -0.02633933f, -0.00131080f, 0.01047745f, 
    0.02133868f, -0.04771860f, 0.01756476f, 0.04802319f, 0.00489907f, 0.00065072f, 0.01470287f, 0.03794708f, 
    0.03183005f, -0.00845230f, -0.05088744f, -0.02618393f, -0.03718509f, 0.02590350f, -0.03088480f, -0.05567171f, 
    -0.02157332f, -0.03113974f, 0.01270524f, 0.03839732f, 0.04696327f, -0.02173285f, 0.02446456f, 0.03273999f, 
    -0.05115920f, 0.04390756f, -0.05705134f, -0.05459349f, -0.00048336f, -0.02335038f, -0.00894065f, 0.04986842f, 
    -0.06250378f, 0.00366296f, 0.01432625f, -0.01621744f, -0.05024887f, -0.01548955f, -0.01051072f, 0.03370283f, 
    -0.02755365f, -0.05882435f, -0.01532623f, 0.02466082f, -0.05867474f, 0.00690069f, -0.00516498f, 0.00097360f, 
    0.02113264f, -0.05123225f, -0.04898625f, -0.05323081f, 0.02195685f, -0.05553447f, -0.05838142f, -0.04371219f, 
    -0.03866947f, -0.06365247f, -0.06231031f, 0.02904837f, 0.04447039f, -0.01051152f, -0.00101081f, -0.04891209f, 
    0.04934089f, -0.06483500f, -0.02171120f, -0.02631863f, 0.01083026f, 0.03176581f, 0.00765615f, -0.00337392f, 
    -0.02582927f, 0.01399907f, 0.04776157f, -0.03271198f, -0.05640961f, -0.01655578f, -0.03957934f, -0.03524582f, 
    0.01917524f, -0.06482570f, -0.02365388f, -0.04960158f, 0.04711731f, -0.03735263f, 0.00637475f, 0.03021137f, 
    0.01592179f, -0.05050693f, -0.06749611f, 0.04215623f, 0.03336380f, -0.00269886f, 0.01928435f, -0.05433331f, 
    -0.06053117f, 0.04809583f, -0.05903694f, -0.04705975f, -0.05630756f, -0.05970639f, -0.03052960f, -0.05130288f, 
    0.00559488f, 0.01819825f, 0.00564725f, -0.01817409f, 0.03878423f, -0.02378331f, 0.00008392f, -0.04129352f, 
    0.03896448f, -0.03079770f, 0.04099083f, 0.02831625f, 0.02662369f, -0.01179852f, 0.00367764f, -0.03297067f, 
    -0.03546939f, -0.04352519f, -0.03998349f, 0.03344366f, -0.01670349f, -0.01769436f, -0.04823609f, -0.01020459f, 
    0.03367594f, 0.04172598f, 0.02326757f, -0.05456403f, -0.05270208f, -0.06803484f, 0.04017283f, 0.00536549f, 
    -0.05158779f, 0.02278835f, 0.02620419f, -0.01543532f, -0.02440744f, 0.01681834f, -0.00485526f, -0.05248922f, 
    -1.29838645f, -0.86025435f, -0.29996073f, -0.01320819f, -0.07083861f, 0.10284221f, 0.22943279f, 0.09870657f, 
    0.07251783f, 0.23021209f, 0.16381942f, -0.11066549f, 0.11700159f, 0.03423432f, 0.04883903f, 0.12441643f, 
    -0.00724404f, 0.05088054f, -0.09247740f, -0.37238044f, 0.12422601f, 0.01062139f, -0.13838732f, -0.06162360f, 
    -0.03358452f, 0.05438921f, 0.02686981f, 0.05060886f, -0.05467625f, -0.13866983f, -0.29480538f, 0.03661149f, 
    -0.13502826f, -0.12404034f, 0.03303611f, -0.02879385f, 0.11733790f, 0.12500697f, -0.09349663f, -0.07799575f, 
    0.07309356f, -0.08923281f, 0.06622017f, 0.08597669f, 0.07566028f, 0.18483996f, 0.12980089f, 0.24985467f, 
    -0.27595875f, 0.05368865f, 0.25196257f, 0.07042290f, 0.02537383f, 0.02113993f, 0.13844813f, 0.17526303f, 
    0.02900531f, -0.05393647f, 0.03958426f, -0.05209289f, 0.06317701f, 0.02103484f, 0.05148904f, 0.30772531f, 
    -0.11857685f, 0.33317673f, 0.07883886f, 0.05747978f, 0.06055495f, 0.12769015f, 0.05620446f, -0.05919391f, 
    0.25309002f, -0.20445506f, 0.19657564f, 0.20724854f, 0.07392262f, 0.08973673f, 0.19125809f, 0.09517453f, 
    0.03313874f, 0.19357821f, -0.02990212f, -0.47960803f, 0.07252914f, 0.03718219f, 0.05669753f, -0.06814119f, 
    0.18110277f, -0.05457430f, 0.49731272f, -0.29371402f, -0.10579878f, -0.08657865f, -0.00757539f, 0.08142035f, 
    0.21798989f, 0.04044657f, -0.15907739f, 1.38396323f, -0.25382194f, -0.38728079f, -0.20159665f, -0.21544336f, 
    -0.17888792f, 0.02339662f, -0.01901413f, -0.02860720f, 0.13821991f, 0.27686352f, 0.14368451f, -0.10596412f, 
    -0.14723460f, -0.06934368f, 0.05710084f, 0.06247510f, -0.07355563f, 0.45051688f, -0.54944581f, -0.38684449f, 
    -0.19204795f, 0.13222490f, 0.06912177f, -0.00007368f, 0.00043973f, 0.03011862f, 0.25571862f, -0.03892551f, 
    -0.24544436f, 0.01088702f, -0.01722554f, 0.11189277f, 0.12253597f, 0.03695906f, 0.09475783f, -0.15980606f, 
    -0.04769894f, 0.02786273f, -0.18268166f, 0.03113017f, 0.03801461f, -0.05474916f, -0.04894770f, -0.01774994f, 
    0.06980512f, -0.15270706f, -0.13395791f, 0.07898031f, -0.06259022f, 0.02267544f, 0.00448777f, 0.04382275f, 
    -0.02450560f, -0.52567923f, -0.40272856f, -0.06475791f, 0.02826623f, -0.12252268f, -0.02888778f, 0.04578035f, 
    0.10395139f, 0.06127072f, 0.11988842f, 0.29116464f, -0.07424846f, -0.08595307f, 0.09755232f, 0.02341045f, 
    -0.02773036f, -0.04655638f, 0.15858422f, -0.25790879f, -0.34323776f, -0.25898477f, -0.10426290f, 0.03451671f, 
    -0.06411713f, -0.04628948f, 0.07862538f, 0.00714647f, -0.24385215f, -0.40759239f, -0.38122854f, 0.02070243f, 
    -0.10680078f, -0.15024064f, -0.08592800f, 0.03447884f, -0.31537804f, -0.03447784f, -0.12588133f, 0.03422679f, 
    0.15445121f, 0.06886958f, -0.03220356f, -0.00483996f, -0.00874138f, -0.07034155f, -0.39317092f, -0.21249585f, 
    -0.03511290f, -0.11952089f, 0.02900703f, -0.03708265f, 0.05592497f, -0.01141148f, 0.05297328f, -0.21085423f, 
    -0.35603777f, -0.12020521f, -0.08992555f, -0.20241730f, 0.02224890f, -0.02336501f, 0.13088085f, 0.10519920f, 
    0.05497448f, -0.38888794f, 0.05248252f, 0.12797360f, 0.09411884f, -0.01801009f, 0.10233591f, 0.16574730f, 
    0.05149442f, 0.34953699f, -0.28231683f, 0.03574936f, -0.11030932f, 0.04946924f, 0.01901597f, 0.14649799f, 
    0.00759772f, -0.01846848f, 0.08994596f, 0.19641912f, 0.12343984f, -0.14872587f, 0.01972179f, -0.15852378f, 
    -0.04473775f, -0.00621836f, 0.05961996f, -0.02964750f, -0.28548861f, -0.07202147f, 0.02201767f, 0.21003725f, 
    0.11120813f, 0.20482571f, 0.09653122f, 0.16011854f, -0.10853805f, -0.27497417f, -0.37606227f, -0.08348791f, 
    -0.01615257f, 0.08844893f, 0.08372238f, 0.06996205f, -0.10814539f, -0.10227082f, -0.31321287f, 0.06843409f, 
    0.05937487f, -0.07359312f, 0.03505247f, 0.03802933f, 0.10654719f, -0.03562186f, 0.09462042f, 0.01383677f, 
    0.09880110f, -0.04979033f, 0.13456146f, 0.08005604f, 0.16751477f, 0.06451466f, 0.03245563f, 0.11009936f, 
    0.28815436f, 0.16685860f, -0.05972442f, -0.06056836f, -0.06539176f, 0.12232219f, -0.10094308f, 0.08317669f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09163420f, 0.10009953f, 0.19926198f, -0.00892413f, -0.02940560f, 0.13720916f, 0.06965473f, 0.08523504f, 
    -0.01755066f, -0.03218309f, 0.18527046f, 0.04611126f, -0.00740411f, 0.04927227f, -0.03738663f, -0.07407711f, 
    -0.00448215f, -0.07376717f, 0.17641409f, 0.01747473f, -0.00533210f, -0.07020359f, 0.11060330f, -0.06097464f, 
    -0.09221344f, 0.07139055f, -0.03368258f, -0.10407516f, 0.36289638f, -0.01250818f, -0.01183532f, 0.13336819f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06272758f, 0.32871947f, 0.32936731f, -0.00125878f, 0.02740857f, -0.22448032f, 0.17646596f, -0.16679907f, 
    0.11982799f, 0.14999011f, 0.21006955f, -0.22628130f, -0.09701657f, 0.04800624f, 0.15780814f, -0.17331283f, 
    -0.04452762f, -0.05957172f, -0.07498015f, -0.11922789f, 0.12653254f, 0.12516899f, -0.06459325f, -0.13871367f, 
    -0.24244446f, 0.45719826f, 0.15603723f, 0.05167948f, -0.13208362f, -0.02601268f, 0.15318406f, 0.13250729f, 
    0.01311590f, -0.20626757f, 0.33076686f, -0.13561140f, -0.16046175f, -0.10015016f, 0.25152493f, 0.15003645f, 
    0.28969571f, 0.02218635f, 0.18884124f, 0.23009199f, 0.07257285f, -0.06788874f, -0.22988558f, -0.23670760f, 
    -0.31840807f, -0.25180081f, -0.03687476f, -0.07128625f, 0.11788952f, -0.21186192f, 0.18196461f, -0.26324037f, 
    0.22498170f, 0.28419080f, -0.01491479f, 0.08954023f, 0.19345644f, -0.05033115f, 0.08877640f, 0.40032950f, 
    -0.12466952f, -0.08337299f, 0.30664855f, 0.02429696f, -0.08368349f, 0.27683687f, -0.16514035f, -0.01168418f, 
    0.20499244f, -0.11146326f, -0.27581879f, 0.09037805f, -0.15644147f, 0.13536455f, 0.36722085f, 0.26923209f, 
    -0.16176282f, -0.21589206f, -0.14348882f, 0.11851858f, -0.14501940f, -0.06239224f, -0.02540072f, -0.34849459f, 
    -0.22792909f, 0.01536975f, 0.01555768f, -0.31591639f, 0.33048213f, 0.17611378f, -0.06401854f, -0.08932054f, 
    -0.09373732f, -0.10361223f, 0.07713240f, 0.13105801f, 0.05889785f, -0.31200549f, 0.20895807f, 0.05502744f, 
    -0.01188987f, 0.02130147f, 0.11087064f, 0.34128100f, -0.04000693f, 0.08861834f, 0.22281739f, 0.04157307f, 
    0.14299510f, 0.16404063f, -0.25237486f, 0.07798541f, -0.11542104f, -0.20100707f, 0.16171753f, -0.09812586f, 
    -0.16344152f, -0.13267013f, 0.02729769f, -0.09977551f, 0.12761343f, -0.01262333f, -0.03588808f, 0.21423881f, 
    0.11297921f, 0.04001046f, -0.17738785f, 0.05035139f, 0.12422534f, -0.01439164f, 0.08224547f, -0.14191590f, 
    -0.22895437f, 0.09185559f, -0.02749917f, -0.12768161f, -0.09338351f, 0.16655238f, 0.44343871f, 0.22420852f, 
    0.25758037f, 0.00771416f, 0.11932195f, 0.02474636f, 0.04027256f, -0.07097159f, 0.18551002f, 0.07260804f, 
    -0.23872739f, 0.25474143f, -0.15616839f, -0.26889640f, -0.11767804f, 0.20052981f, -0.05812873f, -0.01798599f, 
    0.23476920f, 0.21329129f, -0.45338497f, -0.00625489f, -0.06711580f, 0.24303229f, -0.02442745f, 0.15289122f, 
    -0.23892683f, -0.04477701f, 0.12999339f, -0.10560892f, -0.00268635f, 0.22134970f, 0.15691248f, 0.05617881f, 
    0.16496477f, -0.28649059f, -0.13570607f, 0.03342110f, 0.09590339f, -0.20134038f, 0.24929698f, 0.17467265f, 
    -0.11127885f, -0.32143140f, -0.14377104f, -0.22668943f, 0.24855287f, -0.07545952f, -0.03457218f, -0.18040553f, 
    -0.10275443f, 0.11989944f, 0.42834848f, -0.06004103f, -0.07241497f, -0.01624040f, 0.19424674f, -0.04674252f, 
    -0.20108862f, 0.13456443f, -0.42520502f, -0.34463897f, -0.07183044f, 0.26030734f, 0.36105058f, 0.02318406f, 
    0.33535773f, -0.07713329f, -0.51309949f, -0.04584266f, 0.00641965f, 0.09684297f, 0.07633375f, 0.17688817f, 
    -0.48038486f, 0.15945046f, -0.04946690f, 0.45570922f, -0.21515237f, 0.22047730f, 0.10390993f, -0.02488788f, 
    -0.12964223f, 0.05241569f, -0.02931140f, -0.03607096f, 0.09034156f, -0.00419099f, 0.00561015f, 0.12524585f, 
    -0.11008652f, 0.11374865f, 0.12142947f, -0.12133538f, 0.16904534f, -0.06261983f, -0.04094010f, -0.09813660f, 
    -0.22319524f, 0.01863599f, -0.17938937f, 0.00378858f, 0.13364756f, 0.05314368f, -0.16785222f, -0.06403871f, 
    -0.16172387f, -0.10549447f, -0.06360863f, -0.04985298f, 0.07314952f, -0.11153238f, 0.06925962f, -0.12067037f, 
    -0.42179823f, 0.15877213f, 0.09480604f, -0.01969270f, 0.14172757f, -0.13227721f, 0.28493214f, -0.24556638f, 
    -0.15766022f, -0.07055639f, -0.43439928f, -0.14739794f, 0.01312832f, 0.44004256f, 0.38896599f, -0.00043011f, 
    0.30092356f, 0.05221258f, 0.23139668f, 0.07485066f, -0.02891202f, 0.21521871f, 0.19619125f, 0.23451497f, 
    0.09301382f, -0.09734157f, 0.15806255f, -0.01091141f, 0.04804362f, 0.17061207f, 0.09259786f, 0.08488591f, 
    -0.04406459f, 0.08044483f, -0.26802525f, -0.07223733f, -0.14306492f, 0.43128476f, -0.07817789f, 0.13952062f, 
    0.05809202f, -0.01415917f, 0.00523251f, 0.29937255f, -0.12773654f, -0.04088684f, 0.10967493f, 0.05421444f, 
    -0.11290484f, 0.19057892f, -0.20007348f, -0.10546039f, -0.11078829f, 0.27265218f, -0.13881294f, 0.55659664f, 
    -0.16142198f, -0.17966361f, -0.12375885f, 0.40223640f, -0.08539593f, 0.09616831f, -0.06664043f, -0.57163584f, 
    0.47807011f, 0.06930756f, -0.16861793f, -0.17842451f, -0.13698468f, 0.50703549f, -0.07923577f, -0.25837550f, 
    -0.13605906f, -0.00118267f, -0.15051302f, -0.08359022f, -0.00390214f, 0.35822165f, 0.24626552f, 0.22970243f, 
    0.16109562f, -0.19029793f, -0.43741801f, 0.04204546f, -0.09450261f, -0.16880496f, -0.26992732f, -0.02288631f, 
    -0.27630711f, 0.19311695f, 0.01969719f, 0.48388046f, -0.00963167f, 0.13016726f, -0.04661346f, -0.36808240f, 
    -0.63038731f, -0.07748574f, -0.50170952f, 0.04342701f, 0.14711736f, -0.01716911f, 0.04570658f, 0.26462266f, 
    -0.23723471f, -0.03155227f, 0.23301154f, 0.21755363f, 0.03747150f, 0.06192217f, -0.00551673f, 0.28256440f, 
    0.33258891f, -0.43744165f, -0.01359448f, -0.17912115f, -0.00944867f, -0.10307766f, -0.00962517f, -0.37655181f, 
    -0.49492124f, 0.18215114f, 0.00703566f, 0.18570532f, 0.23050393f, 0.07475985f, -0.13350841f, 0.15230609f, 
    -0.55814111f, 0.09022731f, -0.06510441f, -0.12042838f, 0.08337999f, -0.10830060f, 0.26709551f, -0.08317076f, 
    -0.28358606f, 0.09254270f, -0.34860870f, -0.15382819f, 0.02616829f, 0.39111212f, 0.32692212f, 0.21146441f, 
    0.33329576f, 0.09928340f, 0.08913054f, 0.12013944f, -0.17197527f, 0.08724858f, 0.25230438f, 0.40879843f, 
    0.04184224f, -0.12300717f, -0.02881681f, 0.27351907f, 0.06034244f, 0.09307954f, -0.09138889f, 0.05946082f, 
    -0.06538076f, 0.17834827f, 0.56153035f, 0.04410215f, 0.05765672f, 0.11346719f, -0.31788918f, 0.26811227f, 
    -0.06368115f, -0.06725642f, 0.12889911f, -0.05479813f, 0.00217931f, -0.11508117f, 0.04114057f, -0.08758797f, 
    0.01210481f, -0.23001502f, -0.15425086f, 0.11966670f, -0.16178559f, -0.41803092f, -0.06860539f, -0.11315292f, 
    -0.25591931f, -0.27573276f, 0.15381579f, 0.21551014f, 0.26007813f, 0.04208530f, 0.03795123f, -0.10319774f, 
    0.04944508f, -0.03933906f, 0.20223868f, -0.05617466f, 0.09093234f, -0.00807816f, -0.00483082f, -0.01569281f, 
    -0.20089351f, -0.04937776f, 0.09821258f, 0.09277445f, 0.11271694f, -0.00736074f, 0.36700046f, 0.19680618f, 
    0.28488138f, -0.03103380f, -0.26497081f, 0.17658754f, 0.00539739f, 0.01321564f, 0.20284063f, -0.20904325f, 
    -0.60489970f, 0.27603650f, 0.09936058f, 0.25642121f, -0.16498816f, 0.05040655f, 0.09853114f, 0.06637236f, 
    -0.09971282f, -0.12906380f, 0.20574217f, -0.14550951f, 0.01645907f, 0.02650457f, 0.10089283f, 0.11134168f, 
    0.01049745f, 0.12135644f, -0.11081371f, 0.14183171f, -0.05098988f, -0.10964667f, -0.03294470f, 0.09112148f, 
    0.13863240f, 0.01270379f, 0.02297850f, 0.14524227f, 0.02548769f, 0.00538131f, -0.12872903f, 0.35161078f, 
    0.00753319f, -0.16907644f, -0.16007964f, 0.05290765f, -0.03947396f, -0.12449194f, 0.05167867f, -0.11553805f, 
    -0.34597188f, -0.05066889f, 0.11316240f, 0.08240525f, 0.00333343f, 0.31346327f, 0.17117198f, 0.01302120f, 
    0.06770831f, 0.01990431f, -0.43715829f, -0.11532193f, 0.00381579f, 0.03319144f, 0.23220746f, -0.11822026f, 
    0.04960693f, 0.06811450f, 0.11322343f, -0.11609196f, -0.09998059f, 0.36917537f, 0.06516217f, -0.29517269f, 
    -0.29513660f, 0.30637389f, 0.10945317f, -0.00303913f, 0.20832567f, 0.02602145f, -0.12123048f, -0.55851430f, 
    -0.07249161f, 0.20424286f, -0.20486529f, -0.02323561f, 0.08017891f, -0.17041534f, 0.04181598f, -0.00168175f, 
    -0.14586730f, -0.17130120f, 0.32768136f, 0.13926303f, -0.16485837f, -0.00397083f, -0.19667803f, -0.02169296f, 
    0.09405094f, -0.28588173f, 0.08476308f, 0.16182055f, -0.04123669f, -0.19059646f, -0.02543959f, -0.56458259f, 
    -0.02111069f, 0.25848895f, 0.01819106f, -0.00845255f, 0.20883976f, 0.09139389f, -0.01321587f, 0.51452911f, 
    -0.15490673f, 0.07627571f, -0.04339345f, -0.13238299f, -0.11452831f, -0.06432212f, 0.06260893f, 0.02354297f, 
    0.00610482f, 0.08612662f, -0.37433943f, -0.32824242f, 0.05582623f, 0.38553041f, 0.30412900f, 0.30402663f, 
    0.32684466f, 0.08427991f, 0.07510389f, -0.13935611f, 0.04568161f, 0.22062308f, 0.12032269f, 0.56031489f, 
    0.09014653f, -0.17955564f, -0.09295645f, -0.09610927f, -0.06942493f, 0.05573872f, -0.01345113f, 0.04422085f, 
    0.34496713f, -0.01030126f, 0.00632342f, 0.06454461f, 0.13107762f, -0.02115682f, 0.05735192f, 0.19598241f, 
    -0.01423887f, 0.11540751f, -0.19923878f, 0.17344359f, 0.07467158f, 0.04245175f, 0.04073924f, -0.04607128f, 
    0.10476340f, -0.25940293f, -0.29842255f, 0.02122776f, 0.03797854f, 0.28123680f, 0.07731258f, -0.12424548f, 
    0.02756130f, -0.07938947f, -0.09999683f, 0.01630622f, -0.09091637f, -0.01966250f, 0.09389185f, -0.23148143f, 
    -0.08736444f, -0.02890354f, -0.14926769f, 0.03680651f, 0.11003073f, 0.06849734f, 0.11647791f, -0.13087818f, 
    0.13072842f, 0.07751294f, -0.07153764f, -0.37221214f, -0.03947362f, 0.12826297f, -0.30086449f, -0.16968963f, 
    0.02814194f, 0.22511481f, -0.02856020f, 0.11471064f, 0.02225402f, -0.19529401f, 0.17778917f, 0.29963443f, 
    0.68115777f, -0.03123249f, -0.06085225f, 0.10067910f, -0.04966741f, 0.14520738f, -0.05547712f, 0.61865228f, 
    -0.05157239f, 0.09221841f, 0.79573268f, 0.03316396f, -0.10149630f, -0.17544535f, 0.23853365f, -0.09153520f, 
    -0.11047329f, -0.02267151f, -0.31588176f, -0.25601029f, 0.16421761f, 0.09511212f, 0.07884895f, -0.13635178f, 
    0.23046657f, 0.20972590f, 0.19451103f, 0.10776604f, 0.17193931f, -0.09006964f, 0.35785180f, 0.02629603f, 
    -0.04271048f, 0.20205526f, -0.08148817f, 0.35906380f, -0.09368487f, 0.09963252f, -0.16546431f, 0.02815042f, 
    0.24944760f, -0.14672087f, -0.39053252f, 0.03922201f, -0.00955680f, 0.20143940f, 0.07602309f, 0.02912214f, 
    0.00560129f, 0.11615407f, -0.11666088f, -0.01630854f, 0.14949670f, 0.41392693f, 0.41838741f, 0.10858365f, 
    -0.13045521f, -0.04995958f, -0.15534589f, 0.16484576f, 0.04962815f, 0.17391777f, 0.26009741f, 0.27413252f, 
    0.42321536f, -0.11879770f, 0.11945987f, -0.34950176f, 0.35165378f, -0.21904787f, 0.04829767f, 0.35189837f, 
    -0.00390270f, -0.18635717f, 0.04697496f, 0.10269520f, -0.03757817f, 0.08434201f, -0.14134985f, 0.03051215f, 
    0.01385215f, -0.07277796f, 0.11762644f, -0.18709086f, 0.16018580f, -0.19215374f, 0.12814265f, 0.04130873f, 
    -0.21356013f, -0.04642564f, 0.01455793f, 0.02744527f, 0.06940994f, 0.12469698f, -0.07057333f, 0.05589002f, 
    0.08710515f, -0.24601267f, 0.06129779f, -0.02155095f, -0.00016290f, -0.15644100f, -0.15758222f, -0.05421088f, 
    -0.19801530f, -0.11703909f, 0.04365573f, -0.16608199f, -0.14045747f, 0.12055322f, -0.18161033f, -0.15033078f, 
    -0.03055296f, 0.04829007f, -0.17347915f, -0.04111547f, -0.00454636f, -0.11617022f, -0.00815132f, 0.12352934f, 
    -0.16363084f, -0.09088570f, 0.09188497f, -0.00534161f, 0.08214933f, 0.07755396f, -0.13986777f, 0.07420459f, 
    0.07286865f, -0.01069065f, 0.03155385f, -0.14023481f, -0.13196380f, 0.06101092f, 0.12192493f, 0.01440725f, 
    -0.27485663f, 0.34669375f, 0.18694015f, -0.01690155f, -0.07989194f, 0.34606412f, -0.11453967f, 0.04531200f, 
    -0.16501099f, 0.08337068f, -0.09765102f, -0.39604151f, -0.15216154f, 0.21669105f, -0.23239833f, 0.20999768f, 
    0.12636273f, -0.49518028f, -0.35818619f, 0.14301249f, -0.01984873f, -0.19964954f, 0.04894642f, -0.03520303f, 
    -0.42699009f, 0.11031545f, -0.01565283f, -0.15954772f, 0.08903214f, 0.46485072f, 0.03142572f, -0.33204603f, 
    -0.14820223f, -0.23060590f, 0.26709452f, -0.06153691f, 0.15886399f, -0.07935557f, -0.11939720f, 0.26501894f, 
    0.13859716f, -0.07040207f, 0.09702782f, -0.09495715f, -0.13283388f, -0.12888084f, -0.06100073f, 0.14047012f, 
    0.05985120f, 0.05223401f, -0.13884446f, -0.03057447f, 0.06624319f, 0.00455881f, -0.13161665f, 0.05047877f, 
    0.10823751f, -0.18704879f, -0.09405170f, -0.08521120f, 0.01217449f, 0.04860537f, -0.10891864f, 0.68245977f, 
    -0.15679280f, 0.44247550f, -0.04248975f, 0.13850732f, -0.06609829f, 0.03927058f, 0.11687025f, 0.03878899f, 
    0.03575811f, 0.12439265f, 0.08135267f, -0.17571519f, 0.00206038f, -0.20938201f, -0.16061893f, -0.08791141f, 
    -0.04249102f, -0.29386941f, 0.34142822f, 0.09654097f, -0.04687164f, 0.37435910f, 0.39358786f, 0.06976798f, 
    -0.36389151f, 0.32320762f, -0.01689316f, -0.01783936f, 0.06154096f, -0.08144477f, 0.14575507f, -0.42110550f, 
    0.19051097f, -0.02146966f, -0.13963141f, -0.14272073f, 0.12702791f, 0.40791595f, 0.41470838f, 0.22578044f, 
    0.07728115f, 0.12435874f, -0.33329350f, 0.19196157f, 0.13179125f, 0.03735468f, -0.09466738f, -0.48863626f, 
    -0.49713495f, 0.23475859f, 0.06917482f, -0.15760209f, -0.09432393f, 0.45075488f, 0.03879042f, 0.52064735f, 
    0.44874278f, 0.09712920f, -0.14934416f, -0.00146560f, 0.05577342f, -0.27716807f, 0.13367830f, 0.14049406f, 
    0.09701171f, -0.26907352f, 0.44216764f, 0.05003724f, 0.12971967f, 0.00294461f, 0.31763920f, 0.34853342f, 
    0.30917254f, -0.02593473f, -0.31590664f, 0.36023000f, -0.00562284f, 0.15953673f, 0.43672478f, -0.02241353f, 
    -0.28632629f, 0.06591939f, -0.32268849f, -0.01627540f, 0.01836626f, 0.12053686f, 0.06899991f, -0.08150738f, 
    -0.28211439f, -0.24639390f, -0.08524042f, -0.45974708f, 0.25977892f, -0.05726917f, -0.08887664f, -0.12849501f, 
    -0.17978832f, 0.15194477f, -0.16544600f, -0.06771096f, 0.05271579f, 0.06290790f, 0.09942144f, -0.12680556f, 
    0.02155280f, -0.17405234f, -0.20660421f, -0.00655913f, 0.01780275f, 0.11330928f, -0.15573937f, -0.10199171f, 
    0.11555035f, 0.23020303f, 0.24220076f, 0.12307769f, 0.16669431f, 0.22755645f, 0.32984522f, 0.49209729f, 
    0.32893032f, -0.15721835f, 0.03286137f, 0.08867880f, 0.00538904f, 0.03267545f, -0.14038099f, 0.25549603f, 
    -0.06979018f, 0.17269796f, -0.37535617f, -0.13530678f, -0.17164041f, -0.09542263f, 0.42681518f, -0.05289663f, 
    -0.05082646f, 0.10493951f, -0.16347472f, -0.04151570f, 0.02403764f, 0.00018662f, 0.35559389f, -0.32951605f, 
    -0.07824936f, 0.27122182f, 0.22543983f, -0.05110435f, 0.08769511f, 0.46926647f, 0.44062361f, 0.29302704f, 
    -0.20626858f, 0.16659699f, 0.08817536f, -0.02363896f, 0.23748636f, -0.20448972f, -0.03892402f, -0.37228528f, 
    -0.16123702f, -0.33813059f, 0.44659993f, -0.09339476f, 0.02944769f, 0.04738358f, 0.32466227f, 0.29723138f, 
    0.13495052f, 0.10212311f, -0.02030097f, 0.15345541f, -0.00776036f, -0.14362729f, -0.10141092f, -0.21862954f, 
    -0.21614118f, 0.10141122f, 0.15131286f, -0.09663033f, -0.08258897f, 0.15600635f, -0.05826890f, -0.25894517f, 
    0.00879459f, 0.20111489f, -0.09973467f, -0.03319565f, 0.06202187f, 0.01541217f, -0.01959542f, 0.14783674f, 
    0.04419943f, 0.14317118f, -0.39816615f, 0.04674210f, 0.09636264f, -0.17231934f, 0.15623556f, 0.09823196f, 
    0.12638102f, -0.12064540f, 0.00775960f, 0.09974588f, -0.02875592f, 0.07501998f, 0.22725525f, -0.13570251f, 
    -0.07382832f, -0.20825844f, 0.16077563f, -0.16616932f, -0.03414985f, -0.15248586f, 0.30290410f, -0.13347648f, 
    -0.09629038f, -0.24066445f, 0.01840989f, -0.41248557f, 0.23656793f, 0.02605684f, 0.02792273f, 0.11342737f, 
    0.02698402f, -0.11059519f, -0.18123709f, 0.07966641f, 0.10427697f, -0.07784727f, -0.03675804f, -0.07855687f, 
    -0.15027119f, -0.03706288f, -0.14526525f, -0.06569637f, -0.14197080f, -0.15803695f, -0.02495984f, 0.02915325f, 
    0.09704100f, 0.12801604f, -0.14736085f, 0.04469027f, -0.09665983f, 0.10940018f, 0.04360663f, -0.16011418f, 
    0.11784651f, -0.15950769f, 0.12147240f, 0.10409730f, -0.15905675f, 0.07524855f, 0.01106589f, 0.07329783f, 
    0.25068533f, 0.10875547f, 0.46170408f, -0.01391650f, -0.07821903f, 0.09995702f, 0.07924744f, -0.00265140f, 
    -0.05900517f, 0.11610676f, 0.14371909f, -0.16159171f, -0.02464395f, 0.05484186f, 0.13899852f, -0.15800595f, 
    0.09909050f, -0.11846121f, 0.04171532f, -0.07570363f, -0.09053104f, 0.00823153f, 0.03148611f, -0.64653754f, 
    -0.03866725f, 0.36750501f, 0.13331488f, -0.33114511f, 0.07490258f, -0.11642727f, 0.11542892f, 0.37513685f, 
    0.08306541f, -0.04129774f, 0.00279824f, 0.09867704f, -0.00178921f, 0.03478630f, 0.02057927f, 0.09386439f, 
    -0.09530262f, -0.03757146f, 0.20162493f, 0.33508611f, -0.11213186f, 0.01891636f, 0.16609615f, 0.00812301f, 
    -0.24925362f, 0.14230216f, -0.27167106f, 0.02548800f, 0.03320863f, -0.25350457f, -0.21435468f, -0.24028769f, 
    -0.07887316f, 0.10048541f, 0.18223983f, 0.45176041f, 0.06354073f, 0.01076164f, -0.15110131f, 0.12238084f, 
    0.17422210f, -0.16607028f, 0.47635067f, 0.11291584f, -0.08268201f, 0.20663674f, 0.04050400f, -0.02484568f, 
    0.16934370f, -0.01750641f, 0.04210700f, 0.09627036f, 0.07824489f, 0.17376110f, -0.16450763f, -0.35995767f, 
    -0.27577043f, -0.09511483f, 0.05350451f, 0.08634850f, -0.05120913f, -0.36653930f, -0.12778850f, -0.30540174f, 
    0.34004456f, -0.03677183f, -0.01833883f, -0.04288359f, 0.18298689f, -0.02936875f, -0.00292146f, 0.39412209f, 
    -0.05886623f, -0.08716296f, -0.18742931f, 0.05176183f, 0.10892174f, 0.07658597f, -0.14491248f, -0.14657214f, 
    0.00795780f, 0.04845819f, -0.07019434f, 0.02120529f, 0.09752425f, -0.10988385f, 0.10453279f, -0.01999575f, 
    0.02451713f, -0.07188680f, 0.05177265f, 0.01399086f, 0.09007778f, -0.17152466f, -0.17668866f, -0.02473445f, 
    -0.20769462f, -0.06209128f, 0.07418835f, 0.10188608f, 0.03509703f, -0.03151273f, -0.02275563f, -0.05451610f, 
    -0.16056012f, 0.17379092f, -0.16068529f, -0.10821959f, -0.13027228f, -0.11416294f, -0.05397202f, 0.08132856f, 
    0.11278982f, -0.02474918f, -0.16772982f, -0.14477015f, 0.10581881f, -0.02803214f, -0.03774429f, -0.15757979f, 
    -0.04685109f, -0.07144961f, -0.11446723f, -0.04209427f, -0.09038370f, -0.00548983f, 0.11172069f, -0.09328057f, 
    0.13992852f, 0.00584283f, 0.06257481f, -0.12559137f, -0.03402004f, -0.10721157f, -0.13623182f, -0.15832733f, 
    -0.11802857f, -0.26200688f, 0.32726696f, 0.08757026f, 0.12399933f, 0.01827911f, 0.00394331f, 0.30847368f, 
    -0.14224769f, 0.01051307f, -0.29819760f, 0.24667189f, -0.09946954f, 0.13893965f, 0.25268620f, -0.02458644f, 
    -0.01640931f, 0.21009845f, -0.03821092f, 0.02938900f, 0.09197111f, -0.20338291f, -0.05861026f, 0.10446916f, 
    -0.21952699f, 0.11869305f, -0.15635526f, 0.35861436f, 0.13002259f, 0.04255730f, -0.12060286f, -0.07927468f, 
    -0.34119841f, -0.38509014f, -0.18257885f, 0.05429194f, 0.02046473f, -0.04696594f, 0.31933692f, 0.08419499f, 
    0.15037957f, -0.13334498f, -0.21777016f, 0.05833333f, 0.02611224f, 0.25835374f, 0.12022265f, -0.09620148f, 
    0.15324433f, 0.21747918f, 0.21515715f, -0.08283542f, -0.04478337f, -0.03745403f, 0.11619034f, 0.16298476f, 
    0.35281175f, 0.06499067f, -0.03653173f, 0.12560536f, 0.01753735f, -0.31198719f, 0.12886350f, 0.82684201f, 
    0.05992923f, -0.32513595f, 0.36247647f, 0.01469033f, 0.00831264f, 0.19037466f, 0.29131904f, 0.44867805f, 
    0.28015855f, 0.03951372f, -0.22070345f, 0.13825445f, 0.11248723f, -0.28764504f, -0.11703603f, -0.02014929f, 
    -0.17258726f, 0.08130644f, 0.06198677f, -0.16933452f, 0.12412596f, 0.00054573f, 0.11383849f, -0.07991109f, 
    -0.05828100f, -0.04107602f, 0.04003636f, -0.65727454f, 0.36803564f, -0.25561967f, 0.07314901f, 0.13035440f, 
    0.29005480f, -0.07278290f, -0.11969090f, 0.06475661f, -0.12348608f, 0.35714695f, 0.26893422f, 0.21870118f, 
    0.11948488f, -0.04170241f, 0.23306978f, 0.21976236f, -0.10581989f, 0.05453226f, -0.09213043f, -0.11363050f, 
    -0.29643601f, -0.29153568f, -0.35502273f, 0.15923838f, -0.07949150f, -0.07767585f, -0.28482488f, -0.41508856f, 
    -0.11186893f, 0.32082024f, -0.02381410f, -0.03341752f, 0.09005091f, -0.11544450f, 0.13355543f, 0.12512948f, 
    0.44291309f, 0.23444857f, 0.05622881f, -0.10173208f, -0.17376490f, -0.07188517f, 0.19482836f, -0.13027790f, 
    0.11780315f, 0.00791991f, -0.12844868f, 0.04123654f, 0.11777521f, 0.19865298f, 0.33809403f, -0.12160039f, 
    -0.13471399f, -0.23011161f, -0.05166326f, -0.09659018f, -0.08423657f, 0.20035423f, 0.42762649f, 0.11581346f, 
    0.00569713f, -0.17815384f, -0.12668307f, -0.05926176f, 0.12954128f, -0.24471407f, -0.05894727f, -0.20736215f, 
    -0.12655959f, 0.06115835f, 0.14402716f, 0.09670243f, -0.06856424f, -0.68105263f, -0.62055844f, -0.15262735f, 
    -0.02489401f, 0.01815069f, -0.13836668f, 0.18312956f, 0.03319337f, -0.29034275f, -0.21835065f, 0.11980719f, 
    -0.00622501f, 0.26787856f, 0.06717203f, -0.12086101f, -0.12161569f, -0.05727924f, -0.07706124f, -0.28116032f, 
    0.05981868f, -0.26031473f, -0.09778623f, 0.25438583f, -0.20899899f, 0.20119254f, -0.05123040f, 0.19394845f, 
    0.21007532f, -0.04057619f, 0.10820927f, -0.00670162f, 0.02616907f, -0.02092511f, 0.03292292f, -0.19436026f, 
    0.18860047f, 0.05210961f, 0.05258628f, -0.11615414f, -0.08931457f, -0.04854868f, -0.10285156f, -0.17829975f, 
    0.07232458f, 0.01014742f, 0.23305897f, 0.02289181f, -0.09448379f, -0.02880597f, -0.55498248f, -0.14994670f, 
    0.06283025f, 0.05310173f, -0.13129388f, -0.19146536f, 0.18900451f, -0.03494692f, 0.10611998f, 0.38513792f, 
    -0.03325468f, 0.09090731f, -0.55402213f, -0.08552366f, 0.14892903f, 0.30424520f, -0.19871223f, 0.09944051f, 
    -0.25083831f, 0.05236452f, 0.10678368f, 0.08694205f, -0.06874498f, 0.16447812f, -0.12316205f, 0.29973033f, 
    0.21062963f, -0.06771975f, 0.11137077f, 0.13733314f, 0.07760899f, 0.06246510f, -0.37785092f, 0.22437768f, 
    -0.00711975f, 0.00763826f, 0.11158893f, 0.05254130f, 0.13134322f, 0.14279495f, -0.04486450f, -0.47090021f, 
    -0.07077120f, -0.29551238f, -0.31105900f, -0.09599338f, 0.07679386f, 0.13191518f, 0.14864920f, 0.34416503f, 
    0.13951966f, -0.01035429f, -0.02549795f, 0.21288373f, -0.08312088f, -0.14320695f, 0.15092123f, -0.16585296f, 
    -0.17676097f, 0.06305269f, -0.13459414f, 0.11083520f, -0.00118329f, 0.09763944f, 0.03014667f, 0.30651379f, 
    -0.35788456f, -0.13219488f, -0.06696372f, 0.12439319f, -0.14741696f, 0.03339154f, 0.01874285f, 0.03466098f, 
    0.25923550f, -0.03273904f, 0.32419601f, 0.14821582f, 0.12945135f, -0.08381963f, -0.06157571f, -0.22270076f, 
    0.18545192f, -0.03501402f, 0.13397650f, 0.18526380f, -0.14051415f, 0.32894689f, 0.27274305f, -0.20082714f, 
    0.08530290f, -0.01781831f, -0.10647770f, -0.09019092f, -0.14967008f, -0.09430787f, 0.27085054f, 0.34762970f, 
    0.46546957f, 0.16780019f, -0.11498649f, 0.32610893f, -0.00847576f, -0.22609358f, 0.02361368f, 0.55212498f, 
    -0.08320986f, 0.14926782f, 0.11918510f, -0.07875437f, 0.09143900f, 0.18319076f, 0.00897355f, -0.21716693f, 
    -0.21485727f, -0.00442952f, -0.15888934f, 0.06910780f, -0.04916651f, 0.22067027f, 0.19665985f, -0.14789149f, 
    -0.12119515f, 0.06576819f, 0.03016940f, -0.05916916f, -0.09449079f, 0.07425872f, -0.21754752f, -0.11525225f, 
    0.04186790f, 0.06062143f, -0.08057626f, -0.05222529f, -0.16973332f, 0.19581841f, 0.15684558f, -0.09776877f, 
    0.09997020f, 0.31320339f, -0.64697278f, 0.16464938f, 0.07833573f, 0.11462132f, 0.09190995f, 0.03539200f, 
    -0.38110006f, -0.04853003f, -0.08344637f, 0.03805240f, -0.10754298f, 0.16432148f, 0.22618982f, 0.08152319f, 
    0.31068182f, -0.36178407f, -0.22021802f, -0.05934827f, 0.06454069f, -0.13564536f, 0.32284540f, 0.09289943f, 
    -0.35891348f, -0.19249235f, -0.16299926f, -0.01966287f, 0.23776510f, 0.21449420f, 0.13769893f, -0.16324660f, 
    -0.19501027f, 0.07547615f, -0.27720499f, -0.11202662f, 0.02516907f, -0.15135734f, 0.03456177f, -0.03871633f, 
    -0.03929080f, -0.15681882f, -0.13259138f, -0.12954743f, -0.07064909f, 0.24429460f, -0.17805508f, 0.16650079f, 
    0.35592812f, 0.15974562f, 0.27994561f, -0.07142890f, -0.13306084f, -0.12140620f, 0.22237325f, -0.10904432f, 
    0.41754439f, 0.11049157f, -0.12111893f, -0.20815846f, -0.06006598f, 0.18346672f, 0.05536306f, 0.31727150f, 
    -0.18736352f, -0.18846598f, -0.04557964f, 0.08183369f, -0.18471301f, 0.44271511f, 0.27048251f, 0.13373771f, 
    -0.20246823f, 0.06824399f, -0.39256167f, 0.07968092f, 0.16494365f, 0.39483026f, 0.22992219f, 0.40038627f, 
    0.10326285f, 0.02879175f, -0.34154359f, 0.01424644f, 0.16352381f, -0.12820981f, -0.19402431f, 0.27599967f, 
    -0.41648665f, 0.11120813f, -0.13265029f, 0.38890010f, 0.21512443f, -0.11455479f, -0.09807166f, -0.20296012f, 
    -0.41782427f, 0.06222598f, 0.55838549f, -0.03231413f, -0.04106835f, -0.35640988f, 0.30146819f, 0.16888444f, 
    -0.01665604f, 0.09026079f, 0.14555633f, -0.13247389f, -0.11116400f, -0.02105745f, -0.14931071f, -0.27683532f, 
    -0.02928831f, -0.18833113f, 0.21444690f, -0.10819630f, -0.06109221f, 0.02319131f, 0.45203459f, -0.24839078f, 
    -0.33120054f, 0.36060628f, 0.03236080f, -0.09905069f, 0.10498311f, 0.09058482f, 0.02963647f, 0.39893824f, 
    -0.05710540f, 0.28145325f, -0.39033619f, 0.15417799f, -0.01796698f, 0.23079644f, -0.22934766f, 0.09021860f, 
    0.06990366f, 0.12114620f, -0.11968236f, -0.14442074f, 0.05231449f, -0.29207993f, -0.50420111f, 0.10146489f, 
    0.06203612f, -0.20778045f, 0.34967434f, 0.09186874f, 0.06598476f, 0.07062601f, -0.09636094f, -0.19826017f, 
    0.19345649f, 0.12339777f, 0.00666054f, -0.28171745f, 0.33977434f, 0.28207594f, 0.14670894f, -0.32596338f, 
    0.19569296f, 0.14600310f, -0.13688213f, -0.16362917f, -0.10122932f, 0.24807684f, -0.29514107f, -0.11886095f, 
    -0.17064758f, 0.17844345f, 0.21319248f, -0.09613851f, -0.02135365f, 0.35450566f, 0.11915451f, 0.18452574f, 
    -0.12375063f, -0.15209264f, -0.01959042f, 0.01330624f, 0.09134369f, -0.33373636f, -0.06879292f, 0.27628663f, 
    0.15328243f, -0.28322822f, 0.17209907f, -0.06883199f, 0.27752003f, 0.13593620f, -0.11150054f, -0.02104730f, 
    -0.33131289f, 0.18801510f, 0.11793391f, 0.07635161f, -0.11625139f, 0.00521779f, -0.06666177f, 0.22069180f, 
    -0.00439778f, 0.05424826f, -0.02406338f, -0.00424591f, -0.03723432f, -0.27128270f, -0.24462946f, 0.18624571f, 
    -0.00658096f, -0.30663964f, -0.29462609f, 0.09873622f, -0.15913315f, 0.16976334f, 0.04936495f, 0.31932288f, 
    0.04622291f, -0.04395281f, 0.17190143f, -0.36045405f, 0.15072528f, 0.20647509f, 0.06063102f, -0.05230559f, 
    -0.15502846f, 0.11111916f, 0.31997904f, 0.15719213f, -0.16655923f, -0.02733188f, 0.08414479f, 0.42101368f, 
    0.27183402f, -0.02211783f, 0.05182539f, 0.13079116f, 0.17123945f, -0.15866916f, -0.16164415f, 0.07135502f, 
    0.07615994f, -0.30630538f, -0.12195106f, 0.02089873f, -0.14542533f, 0.25977108f, 0.19932844f, -0.48113051f, 
    -0.44030631f, 0.22999978f, -0.05101566f, -0.00445675f, 0.34816688f, 0.20948702f, 0.08883652f, -0.24451408f, 
    -0.10590365f, -0.14378344f, -0.02751873f, 0.02307112f, -0.03801469f, -0.09908130f, -0.18063016f, -0.18183938f, 
    -0.01270546f, -0.02448669f, -0.18077217f, 0.08017534f, -0.03475090f, 0.10366261f, 0.14596751f, 0.02874281f, 
    -0.10325177f, 0.03783295f, 0.02008439f, 0.08584164f, 0.15631807f, -0.12737671f, -0.18624158f, 0.06280407f, 
    -0.00096322f, 0.06852119f, 0.08673336f, 0.01181609f, 0.10254098f, -0.15681025f, 0.07836507f, -0.10496725f, 
    0.31574085f, -0.15181257f, 0.31190082f, -0.02668650f, -0.08004437f, 0.03601139f, 0.28037417f, -0.03625774f, 
    0.21156068f, -0.06966750f, -0.09747061f, 0.04683942f, -0.03377200f, 0.14670624f, 0.07210938f, 0.19950189f, 
    -0.04928181f, 0.15528241f, -0.23080949f, -0.14814851f, 0.10671727f, -0.02713548f, -0.30333129f, -0.14030024f, 
    0.13140838f, 0.31500715f, -0.07464123f, 0.43691844f, -0.01415559f, -0.05153070f, 0.00977069f, 0.39041382f, 
    -0.10875633f, -0.03784952f, 0.10788118f, -0.09122825f, 0.11670779f, 0.00297450f, -0.05553297f, 0.12846595f, 
    -0.11415789f, -0.04746972f, -0.04316355f, -0.14442635f, -0.01852909f, 0.09059911f, -0.10334159f, -0.16758011f, 
    0.11598290f, -0.02695215f, -0.10091856f, 0.03337702f, 0.14041592f, 0.05284540f, -0.03005333f, -0.11933936f, 
    0.03759097f, 0.01027718f, -0.15181571f, 0.16625907f, -0.17161526f, -0.13039795f, 0.15682894f, -0.01202249f, 
    -0.46494031f, 0.24353586f, 0.50024480f, 0.16586196f, -0.07599267f, 0.37095663f, -0.20003174f, 0.04957123f, 
    0.02680562f, -0.13811971f, -0.18684217f, -0.35698280f, -0.03151474f, -0.01444469f, -0.18735133f, 0.14967708f, 
    -0.02632870f, -0.25880274f, 0.36683154f, -0.09478895f, -0.03379845f, -0.22576636f, -0.11896168f, -0.20579077f, 
    0.10375137f, -0.12675646f, -0.13726284f, -0.22861022f, 0.13126366f, 0.36128572f, 0.12711516f, 0.04074282f, 
    0.16039626f, 0.04805005f, 0.22640549f, 0.06452943f, 0.15330388f, -0.43087474f, -0.05071364f, 0.07464757f, 
    0.07376522f, 0.01495580f, 0.04837079f, 0.18191549f, 0.13908033f, 0.32217425f, 0.38473243f, -0.06330528f, 
    -0.04274638f, 0.18026166f, -0.04207778f, -0.11781678f, 0.02489747f, 0.06719476f, 0.54291129f, 0.27145538f, 
    -0.02971151f, 0.04772455f, -0.05256933f, 0.02650529f, -0.16389614f, -0.12026060f, 0.00810058f, 0.19031405f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.16608013f, 0.28553948f, -0.05294887f, 0.13834710f, -0.04642367f, 0.06972522f, -0.14447635f, -0.11725207f, 
    0.22622056f, 0.09838614f, 0.06977427f, 0.47911748f, -0.07602872f, 0.15859705f, -0.26737696f, 0.14641565f, 
    0.24002172f, 0.29358214f, -0.01133276f, -0.08112488f, -0.16649139f, -0.02195942f, 0.26674572f, -0.19631511f, 
    -0.14763804f, 0.27928856f, 0.20588717f, 0.20972672f, 0.21776116f, 0.07178535f, -0.22531050f, 0.21003045f, 
    0.06789546f, 0.33123633f, 0.08683256f, -0.05647541f, 0.16044211f, -0.00181267f, -0.14316206f, 0.17265792f, 
    -0.19539565f, 0.04922795f, 0.25775346f, 0.37327012f, 0.15816857f, 0.05068889f, -0.00210359f, 0.15214206f, 
    0.19700827f, -0.04248266f, 0.03533410f, 0.24252866f, 0.24499196f, 0.15861872f, -0.00631628f, 0.19496091f, 
    0.06607518f, -0.08353066f, 0.09669227f, -0.05515134f, -0.08704398f, 0.13301495f, 0.02033318f, -0.12724315f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00560839f, -0.01194007f, -0.58364242f, -0.10097462f, 0.04335373f, -0.14677861f, 0.05593976f, 0.06843860f, 
    0.18432762f, -0.01443533f, -0.14971930f, -0.56584221f, 0.20963030f, 0.50503623f, -0.20007962f, 0.00914585f, 
    -0.60678703f, -0.13907112f, 0.20143875f, 0.02044058f, 0.36900464f, -0.00143062f, 0.13641468f, -0.16660199f, 
    -0.06756198f, -0.40513176f, 0.06973005f, -0.27701256f, 0.14629795f, -0.57016820f, 0.26299807f, -0.06413478f, 
    -0.23196043f, -0.17569757f, -0.05940192f, -0.18300925f, -0.10153367f, -0.17497228f, -0.09445456f, 0.01272560f, 
    -0.01888725f, 0.21154141f, -0.49944839f, -0.44854617f, -0.07370249f, -0.14608118f, 0.06428160f, -0.01246693f, 
    -0.07136558f, 0.25083819f, -0.14519008f, 0.04787395f, 0.18218243f, -0.01257964f, -0.06825007f, -0.05161159f, 
    0.06010684f, 0.25435007f, -0.57265878f, -0.12496728f, 0.06390484f, 0.03793625f, 0.02903149f, 0.20185842f, 
    0.00895862f, 0.30364046f, 0.07192667f, 0.06483288f, -0.12560421f, -0.07208081f, -0.61212736f, 0.06853264f, 
    -0.11738421f, -0.24439992f, -0.39446729f, -0.14387465f, -0.24544439f, 0.36336949f, -0.16542041f, -0.06606373f, 
    -0.45041052f, 0.12324163f, -0.16638795f, -0.11111779f, 0.38490632f, -0.02389971f, 0.20729773f, -0.07268607f, 
    -0.00061181f, -0.74618447f, 0.15944102f, -0.25300506f, 0.09951021f, 0.24186555f, 0.11907414f, -0.20746925f, 
    0.09062058f, 0.16756396f, 0.08626951f, 0.15425251f, 0.11789979f, 0.55940926f, -0.12949611f, -0.03763930f, 
    -0.13444106f, 0.36566079f, 0.21034597f, 0.24963734f, 0.07804614f, 0.15681793f, 0.09085432f, -0.20302339f, 
    -0.13792452f, 0.21022820f, 0.01751085f, -0.36843941f, 0.08495360f, -0.33972484f, 0.06340056f, -0.21638817f, 
    0.05657566f, -0.59471482f, -0.08348380f, 0.06059150f, 0.11159731f, -0.11881410f, 0.02408520f, 0.03161965f, 
    -0.11711019f, -0.07543913f, 0.05045377f, -0.05191441f, 0.17453054f, 0.20783986f, -0.52765328f, -0.08100944f, 
    -0.09888784f, -0.20982070f, 0.38182184f, 0.25840169f, -0.16228175f, -0.35896885f, -0.10884702f, -0.02816130f, 
    0.05092720f, 0.11334043f, -0.30213183f, -0.10832253f, -0.68270987f, -1.07899690f, 0.34224820f, -0.10531174f, 
    0.06354816f, 0.34926176f, -0.00753121f, -0.10664817f, -0.31614119f, -0.06708785f, -0.25321850f, -0.07871657f, 
    -0.14283858f, 0.10675129f, -0.08897980f, 0.15659717f, -0.06253287f, -0.01568436f, -0.06178443f, 0.08102039f, 
    -0.20360106f, -0.86416066f, 0.05305155f, 0.31940097f, -0.15363087f, -0.13498601f, 0.25727260f, 0.15815060f, 
    -0.18366541f, -0.14921236f, -0.12754154f, 0.35640907f, 0.12420406f, 0.24792653f, -0.39140165f, 0.18456671f, 
    0.20697558f, -0.21821538f, 0.00751916f, -0.00343884f, -0.04723784f, 0.07419414f, -0.16111030f, -0.12549040f, 
    -0.07067606f, -0.88966024f, 0.10722318f, -0.33245209f, 0.10561463f, 0.19581974f, 0.16253529f, 0.01000743f, 
    0.21133739f, 0.28571671f, 0.34608194f, -0.43701354f, 0.16179404f, -0.54997569f, -0.16769409f, 0.20614262f, 
    0.19852884f, -0.62739348f, 0.24765076f, -0.09690135f, -0.22826245f, -0.05139415f, 0.16941339f, -0.14899266f, 
    0.00764355f, 0.33847949f, -0.58417034f, 0.01564392f, 0.07886757f, 0.04887951f, 0.11886685f, 0.20208931f, 
    -0.29081854f, 0.01239754f, -0.11378993f, -0.15474233f, -0.21506943f, -0.39542222f, -0.11451884f, 0.07075495f, 
    -0.08254680f, -0.07555710f, -0.22626752f, -0.37421760f, 0.36822930f, -0.48054320f, 0.13176237f, 0.20048270f, 
    -0.21449387f, 0.01113003f, 0.21770963f, 0.21351779f, -0.02531568f, 0.05293971f, -0.81746346f, 0.15091281f, 
    0.31498724f, 0.03695446f, -0.24951603f, -0.06409277f, -0.11992744f, -0.07534136f, 0.12418908f, -0.01258813f, 
    0.24634333f, -0.15148620f, -0.20673382f, 0.09182974f, 0.21730694f, -0.28042504f, 0.36976278f, 0.01751686f, 
    0.15565640f, -0.13673742f, 0.21092984f, 0.31637406f, 0.11791875f, -0.99102366f, 0.42730945f, 0.11964959f, 
    0.10968037f, 0.10488751f, -0.01784083f, -0.12077411f, -0.14901897f, 0.18183665f, -0.13631183f, -0.00942199f, 
    0.07589278f, 0.00837349f, 0.03529757f, -0.12028474f, -0.15427549f, -0.44215575f, -0.09015819f, 0.01941998f, 
    -0.08771963f, -0.18020466f, -0.11565601f, 0.13970037f, 0.09816842f, -0.24418442f, -0.10574798f, 0.02755990f, 
    0.11593979f, 0.09349023f, -0.68514866f, -0.04700873f, -0.23266065f, -0.13270228f, 0.04626902f, -0.02516331f, 
    -0.14216097f, 0.00639510f, 0.06194310f, 0.05824151f, 0.00722447f, 0.15982398f, 0.05020072f, -0.59601194f, 
    -0.29255909f, -0.40810210f, -0.01221459f, 0.04784946f, 0.13310489f, -0.04544958f, -0.64984655f, 0.07750411f, 
    -0.07131378f, -0.03592823f, 0.04621808f, 0.29157326f, 0.02775283f, 0.04456939f, -0.04079081f, -0.09862660f, 
    0.06582963f, 0.09990152f, -0.46141317f, 0.13500662f, 0.08934517f, -0.09183085f, 0.11708757f, -0.07218860f, 
    -0.01624195f, -0.12815011f, -0.03127884f, -0.10521953f, -0.45328587f, -0.16466911f, 0.18932784f, -0.22852303f, 
    -0.01531184f, -0.58556294f, -0.11126676f, -0.09692129f, 0.06137318f, 0.56304365f, 0.02965646f, 0.21265468f, 
    -0.04871399f, 0.21582958f, -0.07240258f, -0.10388368f, 0.10356242f, -0.34308815f, -0.06708851f, -0.09018698f, 
    0.10810076f, 0.15942827f, 0.17709592f, -0.12584370f, 0.24841800f, 0.12822048f, -0.25775129f, -0.09287903f, 
    0.33402768f, -0.01054029f, -0.21275364f, 0.08209039f, -0.01811123f, 0.02034237f, 0.07213628f, -0.40954491f, 
    -0.10211958f, -0.10549727f, 0.06613492f, -0.04932443f, -0.11722905f, 0.12830508f, -1.08694530f, 0.26215854f, 
    -0.03641368f, -0.03028746f, 0.04077207f, -0.05201664f, -0.03387413f, 0.20526779f, -0.55103910f, -0.03142643f, 
    -0.74386322f, 0.10515619f, -0.34708020f, 0.69299847f, -0.67838192f, 0.07691948f, -0.10268471f, 0.04525828f, 
    -0.29373971f, 0.31882256f, -0.97862917f, -0.25644988f, -0.66961884f, -1.05138683f, -0.57587880f, -0.14632633f, 
    -0.00797872f, 0.43169034f, -0.00416176f, 0.21431069f, -0.40103668f, -0.66256255f, -0.37287140f, -0.54709154f, 
    -0.17661382f, 0.19866097f, -0.02504056f, -0.09166809f, -0.01748923f, -0.26946715f, -0.09922983f, -0.04892181f, 
    -0.63477367f, -0.16266857f, -0.43035382f, 0.02081241f, -0.41451424f, 0.00672012f, -0.02618548f, 0.20967640f, 
    -0.01874352f, -0.60514873f, -0.04752167f, 0.26981854f, 0.07511750f, -1.10153222f, 0.19517489f, 0.39176735f, 
    0.12785591f, 0.45795262f, 0.19008790f, 0.06168755f, -0.53652120f, 0.03726369f, 0.17648670f, -0.26803881f, 
    0.26387993f, 0.21448743f, -0.11214592f, -0.06872160f, -0.05539518f, 0.28653049f, 0.37157446f, 0.06345350f, 
    -0.61862665f, 0.06566419f, 0.77446145f, -0.32115433f, -0.64183152f, 0.01830675f, 0.25831071f, -0.02656249f, 
    -0.51752943f, 0.19166815f, -0.52581161f, 0.49449581f, -0.26316148f, -0.25968874f, -0.27971017f, -0.11391737f, 
    -0.13185690f, 0.10940904f, -0.21273485f, -0.00406789f, -0.18863507f, -0.25896400f, -0.55413705f, -0.47027910f, 
    -0.17283702f, -0.10022344f, -0.10494531f, 0.21366560f, 0.25356692f, -0.11725757f, 0.03115599f, -0.08384693f, 
    -0.15118422f, -0.22739899f, -0.43222737f, 0.34353748f, 0.34378237f, 0.01603417f, -0.07526001f, -0.09621527f, 
    -0.14957562f, 0.24733184f, 0.02816572f, 0.28578225f, -0.45109457f, -0.31167012f, -0.15695618f, -0.33767086f, 
    0.25474861f, -0.15648726f, 0.06386066f, -0.05916496f, 0.08080529f, 0.05366208f, -1.03243756f, 0.00948734f, 
    0.26378357f, 0.23467782f, -0.07163545f, -0.26220998f, -0.28489360f, -0.45911634f, -0.47070685f, 0.08372175f, 
    -0.12070046f, -0.00637957f, -0.23067020f, -0.80188948f, -0.52466857f, -0.20791003f, -0.21379101f, -0.25318646f, 
    0.43315762f, -0.07130616f, -0.55409354f, 0.15212667f, -0.83322865f, 0.07938032f, -0.18449797f, 0.09654094f, 
    -0.03477047f, 0.01064151f, -0.13531391f, 0.27088204f, 0.52795589f, 0.19384472f, 0.13122736f, 0.42957106f, 
    0.21464157f, -0.03010183f, 0.06573879f, 0.16622707f, -0.18898140f, -0.06880730f, -0.11506125f, -0.08351425f, 
    -0.14057226f, -0.63551909f, 0.25667500f, 0.14510237f, 0.14681014f, -0.04053369f, -0.11350374f, -0.25234276f, 
    -0.02541125f, -0.09374159f, -0.04158840f, -0.59759182f, -0.21568798f, -0.13096745f, 0.27730364f, -0.00268519f, 
    -0.57433563f, 0.25726825f, 0.23697925f, 0.05930113f, 0.05788900f, -0.10641501f, -0.20077625f, -0.03364325f, 
    0.07677793f, 0.03853223f, -0.12661499f, -0.19302775f, 0.10425632f, 0.02007562f, -0.32362005f, -0.06591745f, 
    0.38823834f, -0.49144375f, -0.57544178f, 0.13588294f, 0.21761385f, -0.17720303f, -0.09734172f, -0.09907846f, 
    0.10450802f, 0.17009184f, -0.03937669f, -0.17495383f, -0.43743113f, 0.31802839f, -0.24837889f, -0.22234783f, 
    -0.00707776f, 0.08289723f, -0.26801193f, 0.31122506f, -0.32413539f, -0.65539688f, 0.09367063f, 0.18617868f, 
    -0.01534505f, 0.26149687f, -0.02795567f, 0.16388661f, -0.26050752f, 0.11976668f, -0.03999168f, -0.08035498f, 
    -0.21347842f, -0.07663543f, -0.11936764f, -0.51598990f, 0.14374045f, -0.44648609f, 0.09080841f, -0.06361910f, 
    -0.13005315f, -0.18188383f, 0.14512378f, 0.07240415f, 0.36859390f, -0.44537717f, 0.36305013f, 0.28435978f, 
    -0.03890314f, -0.31830466f, 0.06538255f, -0.03835000f, -0.52176082f, -0.09475659f, 0.34321067f, -0.06322956f, 
    -0.62643898f, 0.04040986f, -0.16315623f, -0.17514843f, -0.47706851f, 0.03659041f, -0.41996372f, -0.03707136f, 
    -0.39139882f, 0.61784595f, 0.30195433f, 0.14317672f, -0.32036653f, -0.41801366f, -0.15266679f, 0.00755104f, 
    0.06153397f, -0.16545069f, -0.54343271f, -0.11000167f, -0.34690323f, -0.39105815f, -0.09991794f, -0.20259838f, 
    -0.03833879f, -0.36434460f, -0.41809267f, -0.05662006f, 0.37383854f, 0.09653368f, 0.00771043f, -0.04919211f, 
    0.25485119f, -0.11767966f, 0.01954422f, -0.46519727f, 0.34073764f, 0.08879605f, 0.00247052f, 0.02940392f, 
    0.33189857f, -0.05671541f, 0.19490552f, 0.32972234f, -0.16393964f, -0.53023207f, -0.07439344f, 0.27611068f, 
    0.45015180f, -0.23031969f, 0.08498852f, -0.05865149f, -0.30961815f, 0.34228629f, -0.59784073f, 0.05554556f, 
    -0.14496864f, -0.10132627f, 0.00320860f, -0.05659403f, 0.18593857f, 0.07208636f, -0.49508479f, -0.50054699f, 
    -0.25845659f, -0.03745120f, 0.30907324f, 0.06492291f, -0.02952290f, -0.29618493f, 0.28142160f, -0.01311072f, 
    0.04066722f, -0.07771637f, -0.03423981f, -0.10573456f, -0.02493948f, 0.17372479f, 0.12505606f, -0.03146698f, 
    0.12418073f, -0.21993893f, 0.04345996f, -0.24200453f, -0.58984518f, 0.23777997f, -0.69687629f, -0.09185185f, 
    -0.06610456f, 0.33564532f, 0.25413233f, -0.29203850f, -0.71947807f, 0.26630589f, -0.23809043f, -0.62601691f, 
    0.14356272f, -0.23906350f, -0.12165397f, -0.05634492f, -0.07144612f, 0.16231972f, -0.06519783f, -0.09417241f, 
    0.35682204f, -0.55559289f, 0.12477034f, -0.28574073f, -0.55308914f, -0.45674071f, -0.24477853f, 0.03375874f, 
    -0.00493759f, -0.53501600f, 0.00783081f, -0.41534901f, -0.07064912f, 0.07016964f, 0.12361158f, 0.04311060f, 
    0.03746042f, 0.39618784f, 0.19815157f, 0.06103007f, -0.05508140f, -0.07940568f, 0.34347236f, -0.21475230f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02509036f, 0.11231206f, 0.07621562f, -0.01507016f, -0.03321016f, -0.00149511f, 0.22527678f, -0.01601490f, 
    -0.02809533f, 0.03297951f, 0.11258961f, -0.12100812f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
