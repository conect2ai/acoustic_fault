#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.63690126f, -0.41234109f, -0.53696948f, -0.25431612f, -0.59488106f, -0.71826702f, 0.32057637f, -0.25362563f, 
    0.06450480f, 0.25759295f, 0.18132910f, -0.11334176f, -0.45766819f, 0.23714994f, 0.13931099f, 0.02192388f, 
    0.26067778f, -0.01607166f, -0.29385075f, -0.64606202f, -0.09887904f, -0.64894503f, -0.64833009f, -0.41740516f, 
    -0.06490204f, -0.56863016f, -0.34086585f, -0.44213429f, -0.56588060f, 0.80085582f, -0.44937414f, -0.85637385f, 
    0.26021528f, 0.23162580f, 0.38488930f, -0.20610112f, 0.60072279f, 0.39168453f, -0.83208740f, 0.40104190f, 
    0.12289324f, -0.43761811f, 0.12824035f, 0.18969928f, -0.33184606f, 0.32614902f, 0.11572909f, 0.41130370f, 
    0.28060982f, -0.49758849f, -0.45747727f, -0.17482907f, -0.26707113f, -0.14820671f, -0.34046218f, -0.65922880f, 
    -0.25105378f, -0.06798692f, 0.43943188f, -0.17306051f, 0.47374761f, 0.01521454f, 0.43100733f, -0.48563278f, 
    -0.28544766f, 0.65043885f, -0.39622828f, -0.59158599f, 0.54591262f, 0.15286496f, 0.00529365f, 0.19571972f, 
    -0.65481889f, -0.10036668f, -0.69168389f, 0.51452065f, 0.75735235f, 0.27332038f, -0.36687362f, 0.06827489f, 
    -0.30888399f, -0.71936899f, 0.87981921f, -0.34863341f, -0.56453532f, 0.63165200f, -0.43177640f, 0.07277944f, 
    -0.11231729f, -0.27505481f, -0.12253991f, 0.31882292f, -0.44473395f, 0.29377666f, -0.74176055f, -0.48433268f, 
    -0.02120613f, -0.08864573f, -0.03305754f, 0.01761804f, 0.17647865f, 0.35333794f, -0.40220317f, -0.67006868f, 
    -0.84572917f, -0.37081873f, -0.13495100f, -0.61068380f, 0.96880448f, -0.05223241f, -0.52553034f, -0.19086851f, 
    0.14557461f, 0.35589892f, -0.25810704f, 0.32181728f, -0.13783053f, -0.75064367f, -0.63994068f, 0.32532892f, 
    0.59838927f, 0.23523970f, -0.52866501f, 0.01976645f, 0.36691156f, -0.08890826f, -0.03653906f, -0.29204297f, 
    0.59427863f, 0.22941634f, -0.26634824f, -0.62006396f, 0.14491953f, 0.28384405f, 0.43307626f, -1.03934073f, 
    -0.05642420f, 0.83116394f, 0.32793671f, -0.60899287f, 0.09151296f, -0.02152297f, 0.01846597f, 0.27174461f, 
    0.20264371f, 0.52513021f, 0.23568201f, 0.12332405f, -0.47842491f, -0.45667329f, 0.05037322f, 0.09822980f, 
    -0.24998695f, 0.03548375f, 0.17299183f, -0.39242399f, 0.19398345f, -0.55281538f, -0.82391715f, 0.29999399f, 
    0.44401017f, -0.39988160f, 0.52126455f, 0.33308974f, 0.31609431f, -0.40978083f, 0.46858722f, -0.33529744f, 
    -0.25259149f, 0.36212403f, -0.27899706f, -0.20515844f, 0.39677000f, -0.12764394f, -0.28152776f, 0.36162898f, 
    -0.07385165f, 0.00029764f, 0.21543875f, 0.08806621f, 0.16146567f, 0.14145444f, -0.00141574f, 0.18980329f, 
    0.41232818f, -0.45681992f, 0.22736660f, 0.05387580f, -0.20284405f, 0.71658880f, -0.77711487f, -0.12124879f, 
    0.33496317f, 0.62535638f, -0.43135297f, -0.27134243f, -0.35542715f, 0.28014401f, -0.83262426f, -0.49049032f, 
    -0.01700071f, 0.08994608f, -0.46010315f, 0.65774351f, -0.13905196f, 0.17466471f, 0.47362149f, -0.53858018f, 
    0.15809046f, 0.26657933f, 0.29136306f, -0.62735426f, 0.62869090f, 0.27405223f, -0.22620691f, -0.32698259f, 
    0.35852972f, -0.67557079f, 0.37634295f, 0.59361446f, -0.55070734f, -0.10428651f, -0.13596658f, -0.01709064f, 
    0.16635263f, 0.50455499f, -0.67755473f, -0.89163518f, 0.45876110f, 0.49784741f, 0.43134737f, -0.04219883f, 
    -0.13418397f, -0.17687075f, 0.00050858f, 0.19591568f, 0.10706376f, 0.23940256f, -0.19693869f, -0.34400201f, 
    0.63587439f, -0.55817688f, -0.01291409f, 0.43609211f, 0.39133093f, -0.18610147f, -0.39136112f, 0.34725189f, 
    0.47610840f, -0.31701407f, -0.36527860f, -0.21315938f, -1.15558481f, 0.08430996f, 0.95170355f, -0.38769984f, 
    -0.31158477f, 0.36073652f, -0.36829206f, -0.29972181f, -0.17664176f, -0.07695659f, 0.18211482f, -0.02703797f, 
    0.46968967f, 0.30611265f, 0.18961306f, 0.26061043f, -0.18007416f, -0.02758017f, 1.12958205f, -0.91786307f, 
    -0.75513613f, 0.22326720f, 0.14438005f, -0.27908042f, 0.27449071f, -0.32291695f, 0.40596145f, -0.66968644f, 
    -0.22563629f, -0.61620027f, 0.72453761f, -0.25289503f, -0.58806121f, -0.27555543f, -0.18836394f, -0.13822359f, 
    0.27211270f, -0.27231637f, 0.27706820f, -0.54709005f, 0.40223283f, 0.14556240f, 0.20895685f, -0.13661352f, 
    -0.06673189f, -0.37027678f, -0.37141275f, 0.59162670f, 0.24679407f, 0.46904871f, -0.38992223f, 0.03458028f, 
    -0.16841993f, -0.11112185f, -0.88510329f, -0.85616249f, -0.11773875f, 0.65064913f, -0.11634655f, 0.45032904f, 
    0.22039881f, -0.18811908f, -0.08908319f, -0.56909323f, 0.56147146f, 0.12147366f, -0.64884710f, -0.64785796f, 
    0.91414726f, -0.35817495f, 0.16652501f, -0.38990557f, -0.90068388f, 0.82182330f, 0.19112909f, -0.54044157f, 
    -0.20158210f, 0.07576441f, 0.52874142f, 0.17992638f, -0.11519110f, 0.37021992f, -0.46318313f, 0.37445381f, 
    -0.35588750f, -0.47669011f, -0.35150635f, 0.08654877f, 0.04764502f, 0.42280012f, -0.68807691f, 0.21424310f, 
    -0.76121855f, 0.15255938f, -0.02109654f, -0.11862794f, 0.11358801f, 0.17533451f, 0.32786044f, 0.53780824f, 
    0.16857733f, -0.01136417f, -0.42004657f, -0.63791877f, -0.08616044f, -0.42669564f, -0.34913453f, -0.42108369f, 
    -0.03096109f, 0.10539041f, 0.02231728f, 0.27357242f, -0.24646214f, -0.06678214f, -0.40138856f, 0.17774457f, 
    0.31545997f, 0.47485337f, 0.64607728f, -0.01650376f, -0.04636898f, -0.51236051f, -0.41202539f, 0.06867874f, 
    -0.14242753f, 0.24186885f, -1.08693779f, 1.07372856f, -0.30899453f, -0.20949823f, 0.41052023f, -0.14011687f, 
    0.00001849f, -0.04008600f, 0.00338361f, -0.08418379f, -0.19760966f, 0.48213434f, -0.25554433f, -0.32260910f, 
    0.40626475f, -0.52371317f, -0.17329550f, 0.62614858f, 0.61887473f, -0.23471574f, -0.53144079f, -0.25507960f, 
    0.35633850f, -0.55134726f, 0.40298828f, 0.38571298f, -0.32288185f, 0.01963979f, 0.27366170f, 0.16968964f, 
    -0.23507437f, 0.23962921f, -0.08234550f, 0.01518279f, -0.41462412f, 0.02913015f, 0.19140905f, -0.17059456f, 
    -0.02015243f, -0.60286969f, 0.05665316f, 0.50546008f, 0.04742798f, 0.19758521f, -0.14019482f, 0.48687470f, 
    -0.95661533f, 0.18906260f, -0.60234672f, 0.05138754f, -0.28800672f, -0.54751468f, -0.36861843f, -0.37602919f, 
    -0.23540266f, -0.51253599f, -0.18679269f, 0.06853617f, 0.00142576f, -0.23192078f, -0.02580186f, -0.18277043f, 
    -0.45162445f, -0.70586330f, -0.73263258f, -0.54978859f, 0.54264265f, 0.25764966f, 0.05966498f, 0.24164970f, 
    -0.25042590f, 0.08670230f, -0.44541779f, -0.72993469f, 0.32890737f, 0.33577731f, 0.22791785f, -0.33198655f, 
    0.31861737f, -0.40315279f, -0.46177676f, 0.17696714f, 0.46591598f, -1.14415634f, -0.26137245f, 0.85338438f, 
    -0.04930609f, -0.27908504f, -0.04826173f, -0.54892462f, -0.78362572f, -0.48717120f, 0.27432612f, -0.48714611f, 
    -0.10444238f, -0.29296836f, 0.39184308f, -0.52724624f, -0.51680613f, 0.07034439f, 0.59897631f, -0.37868533f, 
    0.00887043f, -0.21534906f, 0.09377468f, -0.17598535f, 0.04422014f, 0.17612867f, 0.00169460f, -0.59995455f, 
    -0.40633562f, 0.44277319f, -0.36653432f, 0.49683353f, -0.08267355f, -0.25171959f, -0.54101819f, -0.71579313f, 
    -0.53710234f, -0.60328519f, 0.67650610f, -0.13773517f, -0.63273627f, -0.45825189f, -0.23641206f, -0.49426988f, 
    -0.12657544f, 0.60678154f, 0.29454008f, -0.50595427f, -0.29649433f, 0.07751620f, -0.03710686f, 0.13714732f, 
    0.18266782f, 0.40487483f, -0.07207845f, -0.13162279f, 0.08714250f, 0.03483707f, -0.11214031f, 0.06498195f, 
    -0.12654200f, 0.30542430f, -0.83183384f, 0.37845239f, -0.01748073f, 0.72098988f, -0.02172013f, -0.44338506f, 
    0.04335166f, -0.16571040f, 0.14760303f, 0.69905049f, -0.34032503f, -0.86639136f, -0.28122765f, -0.32222119f, 
    0.63133335f, -0.38230732f, -0.27775764f, 0.07780594f, -0.12525816f, -0.28285098f, -0.40904659f, -0.62100738f, 
    -0.58484077f, -0.66870576f, 0.10171819f, 0.13991317f, 0.44063139f, -0.51210743f, -0.53425342f, 0.18889534f, 
    -0.00263799f, 0.35126016f, -0.06074982f, -0.01253747f, -0.09781778f, -0.74496233f, 0.21422365f, 0.43863153f, 
    -0.61531025f, -0.48559481f, -0.41633692f, -0.63885945f, -0.28178367f, 0.54540485f, 0.02164827f, -0.25828397f, 
    0.45230705f, -0.01794065f, 0.38832384f, -0.47442117f, 0.55663443f, -0.39416349f, -0.29170465f, -0.08922733f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.32686257f, 0.09528397f, -0.24328865f, 0.16293876f, 0.28023440f, -0.07248642f, -0.00079846f, 0.16344266f, 
    -0.02294522f, 0.06629287f, 0.17721878f, -0.25463724f, 0.03793937f, 0.14424783f, -0.23450895f, -0.05910729f, 
    0.09567094f, 0.18250217f, -0.21760316f, -0.02505348f, -0.00804334f, 0.10055100f, 0.02237379f, -0.11384363f, 
    0.13252288f, 0.04539086f, 0.07654484f, 0.32208538f, 0.08218140f, -0.24281394f, 0.25735804f, -0.28607655f, 
    0.29103753f, 0.10804078f, -0.09859694f, 0.07444267f, -0.01616230f, 0.10114260f, 0.16806288f, -0.10385239f, 
    0.17975813f, 0.02888584f, 0.08789938f, 0.04460657f, 0.11014318f, 0.23905770f, 0.00422744f, -0.13012193f, 
    0.10748454f, 0.33569589f, 0.24313661f, -0.08870628f, -0.19722894f, 0.22241345f, -0.20518327f, -0.42051461f, 
    0.05259312f, -0.09747009f, -0.01713745f, -0.06074787f, -0.03556021f, -0.00742813f, 0.16712946f, 0.14175385f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.33657765f, 0.22916919f, 0.08060783f, -0.30736446f, -0.00989533f, 0.16861379f, 0.23428956f, 0.19385473f, 
    -0.01218259f, 0.07201396f, 0.01643220f, 0.01626119f, 0.02305613f, 0.01943009f, 0.00684646f, -0.02600087f, 
    -0.03084330f, -0.01108412f, 0.08795400f, 0.05973956f, -0.03306215f, -0.04360125f, 0.00522308f, 0.00366728f, 
    -0.03104386f, -0.02301546f, 0.00411585f, -0.02419406f, 0.02546526f, 0.01888571f, -0.02573593f, 0.03328853f, 
    -0.04597973f, -0.04652517f, 0.00919723f, -0.00610729f, -0.15704803f, -0.01840546f, -0.06333072f, -0.04810313f, 
    0.25163090f, 0.15851571f, 0.14658487f, -0.34157839f, -0.02382112f, 0.13536026f, 0.19792759f, 0.10280520f, 
    -0.03815794f, 0.07243840f, 0.02457989f, -0.03042104f, 0.01193116f, -0.07541727f, -0.06740978f, -0.05364351f, 
    -0.08834536f, -0.12340595f, 0.07476863f, 0.04563813f, 0.18690288f, 0.27142659f, 0.38355729f, -0.45843542f, 
    0.08068272f, -0.04891060f, 0.06988367f, -0.04574440f, -0.06049241f, -0.07542151f, 0.12291518f, 0.00802970f, 
    -0.11226760f, 0.00018745f, -0.03280915f, 0.01749760f, -0.01105904f, -0.01951849f, -0.08421315f, -0.14041102f, 
    -0.37475175f, -0.30988070f, -0.42989299f, 0.27821028f, -0.07950830f, -0.01434047f, -0.02385751f, -0.03225151f, 
    -0.00667023f, 0.06178030f, -0.08105757f, -0.06697544f, -0.04172755f, -0.02683434f, 0.01801432f, -0.03913992f, 
    -0.01749281f, -0.03233051f, -0.02944039f, -0.05016353f, -0.04631966f, 0.22688416f, -0.13049325f, -0.04042002f, 
    0.08577208f, -0.01315932f, -0.07245295f, -0.06381149f, 0.01901501f, 0.06081760f, 0.00297674f, -0.00512136f, 
    0.00783693f, 0.02598350f, 0.01802481f, -0.02807201f, 0.05755856f, -0.04723882f, 0.07007227f, 0.05103064f, 
    0.14228153f, 0.22550245f, -0.05217788f, 0.01421262f, 0.09370439f, 0.09591554f, 0.04188970f, 0.14432761f, 
    -0.03128419f, -0.15905362f, -0.07285218f, 0.00527222f, -0.06891847f, -0.00242178f, 0.02932533f, 0.01320912f, 
    0.02708640f, -0.06295209f, 0.03850355f, -0.02714679f, 0.04535687f, 0.09811246f, 0.26795802f, -0.16947326f, 
    0.04740473f, -0.22316904f, 0.03564546f, 0.06927050f, 0.01336049f, -0.08610401f, 0.07099313f, -0.07795314f, 
    -0.05257226f, 0.00348861f, -0.04226409f, -0.00000024f, -0.03512112f, -0.03162635f, -0.06507482f, -0.05919442f, 
    0.18830499f, -0.04551060f, -0.39812657f, 0.01330621f, 0.01179712f, 0.10215519f, 0.05249958f, 0.00534206f, 
    -0.02774044f, -0.03903409f, -0.05925348f, 0.02088767f, 0.04408408f, 0.00486567f, -0.00893194f, 0.04280167f, 
    0.08797668f, 0.02845137f, -0.00177404f, -0.00848072f, -0.05183984f, 0.08555743f, 0.14319709f, 0.02166741f, 
    -0.17087306f, -0.07087632f, 0.05700544f, -0.07141368f, -0.02290520f, -0.00029333f, 0.03041668f, 0.00702011f, 
    0.05102688f, -0.04583224f, -0.03934810f, -0.16968471f, -0.03368028f, -0.11263151f, -0.11064917f, -0.02690045f, 
    0.10965987f, 0.14608915f, -0.11559239f, -0.07584815f, -0.14556150f, -0.04459834f, -0.00924277f, -0.04809965f, 
    -0.00357281f, 0.02286720f, 0.02603913f, -0.02420762f, 0.01446660f, -0.02217117f, 0.04444985f, -0.01897047f, 
    -0.01220602f, -0.07339287f, -0.06166182f, -0.03120458f, 0.05932393f, 0.29389447f, -0.02620425f, -0.23864634f, 
    -0.04350707f, -0.00701199f, -0.02550958f, -0.04213878f, -0.01967267f, 0.07115891f, 0.00895390f, -0.04680014f, 
    0.01975468f, 0.04315946f, 0.00139674f, 0.00626523f, -0.00063778f, 0.11448872f, 0.08537924f, 0.11101393f, 
    -0.68094945f, -0.16694681f, -0.13326788f, 0.01883879f, -0.10122995f, -0.03298796f, 0.03408824f, -0.01017306f, 
    0.01859648f, 0.02584842f, 0.00768185f, 0.04244534f, -0.06473500f, -0.02363078f, 0.07736197f, -0.02642139f, 
    0.01295477f, 0.07876369f, 0.04546922f, 0.01864068f, 0.36039338f, 0.21058729f, -0.11274901f, -0.19268018f, 
    0.09015562f, 0.01921066f, 0.09146538f, 0.02318374f, -0.11740368f, -0.03176407f, -0.05269331f, -0.10553783f, 
    0.01168007f, 0.01968150f, -0.02187261f, -0.04869495f, 0.01754300f, 0.04010915f, -0.04102868f, -0.01963665f, 
    0.08764942f, 0.07226501f, 0.00209972f, -0.01828485f, 0.04841682f, -0.07649577f, 0.12171502f, 0.01010909f, 
    -0.03318202f, 0.02107180f, 0.09356401f, 0.03120854f, -0.01602443f, -0.02955414f, -0.04352800f, 0.02541849f, 
    -0.01566075f, -0.12352534f, -0.03365697f, -0.09256525f, 0.11556539f, 0.11853251f, 0.25584170f, -0.22379895f, 
    0.07312399f, -0.17209923f, 0.09433937f, 0.01964206f, 0.01753699f, -0.09497246f, 0.16382980f, -0.26576975f, 
    -0.03471827f, -0.10760058f, -0.00476583f, 0.03961068f, -0.00862411f, 0.01749859f, -0.10070448f, 0.05917268f, 
    -0.21834196f, 0.11821788f, -0.38724509f, 0.04874235f, -0.16354930f, 0.00238846f, -0.07176816f, -0.05044790f, 
    0.04012832f, 0.06587937f, 0.00637682f, 0.03238811f, 0.02935977f, 0.02156986f, -0.00145614f, 0.03445617f, 
    0.07392911f, 0.01676578f, -0.00668637f, -0.13294616f, 0.23299591f, 0.14833045f, -0.27930030f, -0.12882328f, 
    -0.10916003f, 0.03545187f, -0.03492812f, -0.13766906f, -0.01929268f, 0.09671012f, 0.02941965f, 0.03461878f, 
    0.02217303f, -0.04208193f, -0.06190570f, 0.00445694f, 0.01620538f, -0.10839900f, -0.14164619f, 0.07687389f, 
    -0.13425173f, -0.05096351f, -0.16371901f, 0.03065359f, 0.02059927f, 0.00440717f, 0.04617058f, 0.00365102f, 
    0.03369502f, 0.04804895f, -0.02520369f, 0.03711738f, 0.03399156f, 0.02263803f, 0.02372695f, -0.01684626f, 
    0.08434589f, -0.16268799f, -0.14462037f, -0.00275614f, -0.01396246f, 0.02574620f, 0.04761286f, 0.04944883f, 
    0.01027037f, 0.01027824f, 0.00559535f, 0.05081481f, 0.04789681f, 0.01155973f, -0.04702508f, -0.06108498f, 
    -0.10674570f, -0.08360021f, -0.08415461f, -0.03598141f, -0.04586216f, -0.02874163f, -0.07814012f, -0.01607507f, 
    -0.00370688f, -0.01648912f, -0.10421179f, 0.03048052f, 0.03626679f, -0.03227196f, 0.00463550f, 0.03527024f, 
    0.01801712f, 0.01065695f, -0.07119545f, -0.01782228f, 0.03359779f, 0.06950718f, -0.09015732f, -0.08019358f, 
    -0.06609344f, -0.04226345f, -0.04942558f, 0.00001147f, -0.04445868f, -0.28116173f, -0.10453314f, 0.04416373f, 
    0.01006997f, -0.02207234f, -0.08524993f, 0.05085463f, -0.03023591f, 0.03217512f, -0.10503481f, -0.03391805f, 
    -0.09341582f, 0.04824552f, -0.06223371f, -0.16944928f, 0.11763501f, -0.12483783f, -0.13795227f, 0.01992743f, 
    0.25375974f, 0.16602987f, 0.24656269f, -0.12162483f, 0.12461437f, 0.05694031f, 0.14199495f, 0.09510072f, 
    -0.15120964f, -0.17199621f, -0.13431717f, -0.16322169f, 0.04959955f, -0.00151599f, 0.02979146f, -0.00943803f, 
    -0.03486070f, 0.02637848f, -0.00752389f, -0.01879969f, -0.22858140f, 0.11666487f, 0.38438800f, -0.38410437f, 
    -0.00640252f, -0.04145529f, -0.02535405f, 0.04975398f, 0.09928717f, 0.02272737f, 0.04625905f, 0.09987342f, 
    -0.00754110f, 0.00443993f, -0.09382382f, 0.03164423f, -0.06085699f, 0.00120577f, -0.18358594f, 0.09088080f, 
    0.00218100f, -0.10364264f, -0.15542221f, -0.10189982f, 0.10869314f, -0.17271246f, 0.00806154f, -0.06490652f, 
    -0.15050067f, -0.02196961f, 0.01903355f, -0.09401714f, -0.02128616f, 0.01268552f, -0.11849591f, -0.12652399f, 
    0.12370184f, -0.03779320f, -0.00443982f, -0.12489454f, 0.08339097f, -0.26297772f, -0.49923065f, 0.11993282f, 
    0.04174960f, 0.10754343f, 0.04163896f, 0.02673284f, -0.03741392f, 0.00141423f, 0.04029887f, 0.02579046f, 
    -0.17694187f, -0.12700251f, -0.02564701f, 0.03020488f, 0.09559593f, 0.03585594f, -0.00486007f, -0.02337188f, 
    -0.28789237f, -0.15518370f, -0.04422286f, -0.10961377f, 0.03949931f, -0.05890832f, -0.04984144f, -0.08939306f, 
    -0.01237799f, -0.06493910f, -0.00048417f, 0.03163036f, 0.01678108f, -0.01982518f, -0.00854350f, -0.09189114f, 
    0.06967460f, -0.18418291f, -0.03366323f, -0.04260862f, -0.29863873f, -0.16104554f, 0.15299103f, 0.09816379f, 
    -0.17525433f, -0.00269563f, -0.01736961f, -0.02765911f, 0.06205233f, 0.05053510f, 0.06311557f, -0.02459597f, 
    0.01205158f, 0.02922495f, -0.00647090f, -0.01311850f, 0.07924218f, -0.07404764f, -0.04918696f, -0.06644665f, 
    0.00650122f, 0.10821912f, 0.21911728f, -0.13420106f, 0.13647602f, -0.21861067f, -0.08208729f, -0.05414604f, 
    0.02490298f, -0.13518132f, -0.02180737f, -0.00392033f, -0.01738447f, -0.04048046f, -0.03685929f, 0.01825402f, 
    -0.01702892f, -0.00038666f, 0.08008347f, -0.01387628f, -0.00473908f, -0.04701899f, -0.01579616f, 0.02807294f, 
    0.02583352f, 0.04515922f, 0.00768557f, 0.04397019f, 0.06661625f, 0.07148264f, -0.06415416f, -0.23648497f, 
    -0.20458890f, -0.05654611f, -0.11346225f, 0.01716807f, 0.00978433f, 0.04240242f, 0.00146684f, 0.01135009f, 
    0.13966346f, 0.14669999f, -0.28955287f, 0.05758023f, 0.05727508f, 0.04310782f, -0.01855600f, -0.03235347f, 
    -0.05908350f, -0.10003963f, -0.08070273f, 0.04722810f, -0.17060713f, 0.00104309f, -0.01948005f, -0.05194883f, 
    0.03039650f, -0.07030463f, -0.02866130f, 0.00683169f, 0.22669087f, 0.21494558f, -0.03579034f, -0.18324380f, 
    -0.06231642f, 0.04808110f, 0.10235900f, 0.11283534f, -0.05936973f, 0.06780570f, -0.02664266f, 0.01031014f, 
    0.04395326f, 0.00530762f, 0.08540413f, -0.03319369f, -0.00586708f, -0.04173639f, -0.10420609f, -0.03804282f, 
    -0.23193467f, -0.11831205f, 0.08397344f, 0.03992946f, -0.07498683f, -0.08544629f, 0.01605711f, -0.02585494f, 
    -0.02614468f, 0.01501928f, -0.06998956f, 0.00560167f, 0.01025645f, 0.02331562f, 0.00035731f, -0.07206412f, 
    -0.13797510f, -0.05783818f, -0.09672109f, -0.00424802f, 0.17759368f, -0.21931738f, -0.21014024f, -0.26897630f, 
    -0.09511532f, -0.06488021f, -0.11579453f, 0.03931851f, -0.00241787f, 0.01943008f, 0.02183106f, -0.08188108f, 
    -0.11773951f, 0.03724054f, -0.06996486f, -0.10513625f, -0.03121789f, 0.00034129f, 0.08545874f, 0.08003268f, 
    0.27932966f, 0.10044737f, 0.15002230f, -0.21134672f, 0.06108911f, 0.11313624f, 0.18612687f, 0.15974574f, 
    -0.02969770f, -0.01632002f, -0.01005030f, -0.03949399f, -0.05026383f, 0.02600734f, 0.10750984f, 0.02991112f, 
    0.01334855f, 0.05398588f, 0.00521076f, 0.02139836f, -0.36575785f, 0.22980578f, 0.26900354f, 0.04183779f, 
    -0.15370424f, -0.25575587f, -0.20634635f, -0.16701934f, -0.06844220f, -0.17172731f, -0.03861342f, -0.05639379f, 
    -0.03554538f, 0.05923844f, -0.00759874f, -0.01278024f, 0.01239353f, -0.03688770f, -0.14198570f, 0.00877396f, 
    0.00551974f, 0.13754416f, 0.24435414f, -0.01440574f, -0.04455384f, -0.22295542f, -0.04507140f, 0.05789692f, 
    0.01999144f, -0.14873394f, 0.01858931f, 0.04226149f, -0.05794757f, -0.04468064f, -0.04733570f, -0.04509351f, 
    0.05874727f, -0.00629603f, -0.27980581f, 0.12209783f, 0.15966178f, 0.15992191f, 0.04734661f, -0.14292572f, 
    0.00280753f, -0.10125808f, -0.03560920f, -0.12612791f, -0.07726890f, -0.05625399f, 0.03330429f, -0.00179201f, 
    -0.00249051f, -0.00403765f, -0.06607787f, -0.01619011f, -0.01686842f, -0.04830640f, -0.08134470f, -0.13507697f, 
    0.22855918f, 0.18290384f, -0.08551742f, -0.10111313f, -0.00919231f, 0.08297247f, 0.13341624f, 0.12480184f, 
    -0.07985147f, -0.07155398f, -0.08043259f, -0.09480952f, 0.00316489f, -0.00933485f, 0.05580046f, -0.01122799f, 
    -0.01711526f, 0.00403614f, -0.00023113f, -0.00177529f, -0.11367915f, 0.32441023f, 0.26671916f, -0.20684822f, 
    -0.12065369f, -0.10752983f, -0.16633731f, -0.18079418f, 0.01474413f, -0.01538262f, 0.00451501f, 0.01553941f, 
    -0.02494219f, 0.04673699f, 0.01907332f, 0.13254853f, 0.00154686f, 0.02222986f, 0.11245032f, 0.05207796f, 
    -0.03624998f, -0.16706276f, -0.07764122f, -0.01058990f, -0.03214147f, -0.02099480f, 0.03635158f, -0.08375096f, 
    0.03306239f, 0.00463061f, -0.02762338f, -0.01951425f, 0.01902118f, -0.09556258f, -0.04771832f, -0.09445170f, 
    -0.07776495f, -0.20942588f, 0.08376403f, -0.08854102f, -0.07406758f, -0.10760384f, -0.14902928f, 0.07521905f, 
    -0.05195998f, 0.05546659f, -0.06188506f, -0.07946970f, -0.01524427f, -0.06388948f, 0.03327536f, 0.02706039f, 
    0.03806370f, 0.06872597f, -0.01012412f, -0.01504748f, -0.01008148f, -0.14136414f, -0.00505244f, -0.19160931f, 
    -0.28930670f, 0.05098295f, 0.09658375f, 0.07482608f, -0.07027809f, -0.18235891f, -0.02654593f, -0.00875241f, 
    0.03612236f, -0.04180413f, -0.01118402f, -0.02922970f, 0.00874162f, -0.01404927f, -0.01628260f, -0.11510260f, 
    0.04279048f, 0.03842467f, -0.17627563f, -0.17035480f, -0.40649706f, -0.06492569f, 0.22984514f, -0.06867097f, 
    0.03229782f, -0.07354746f, -0.12746020f, -0.19079649f, -0.01665078f, -0.03002116f, 0.07609306f, -0.04185690f, 
    0.00506233f, 0.02994421f, -0.06201004f, -0.18296075f, -0.02191417f, -0.00638727f, 0.06966247f, -0.20926033f, 
    0.13662899f, 0.13070264f, -0.21651560f, -0.06731962f, 0.01115294f, -0.03002499f, -0.06549054f, -0.12711072f, 
    -0.03945162f, 0.02381685f, -0.05888927f, 0.06282648f, -0.01598104f, -0.00347208f, -0.05129515f, -0.01978828f, 
    -0.07904205f, -0.05219906f, -0.03507645f, 0.11103695f, -0.31505999f, -0.23628807f, 0.01313026f, 0.02776864f, 
    -0.04882905f, 0.00881371f, 0.01109744f, -0.03810090f, 0.06981299f, 0.00869912f, 0.02455068f, 0.02056192f, 
    -0.02245799f, 0.03597651f, 0.02146988f, -0.00594165f, -0.05501414f, -0.10451605f, -0.05752413f, -0.06180765f, 
    -0.02618408f, 0.07018927f, 0.05357105f, 0.02297899f, -0.03141306f, -0.02502750f, -0.07398114f, -0.00244433f, 
    0.02685777f, 0.03867543f, -0.09590622f, -0.03035149f, -0.16856593f, 0.10580577f, 0.02790035f, 0.03582424f, 
    -0.08695961f, -0.00743581f, -0.04182040f, -0.06205764f, 0.18704835f, 0.01178955f, 0.17416134f, -0.20945266f, 
    -0.03709224f, 0.08700781f, -0.06593531f, 0.16890356f, -0.14234316f, 0.02922767f, -0.04390504f, -0.00263814f, 
    -0.05419504f, -0.02512720f, -0.03409516f, 0.10495024f, -0.12665768f, 0.01678281f, 0.12644263f, 0.13066322f, 
    0.21338791f, 0.06229857f, 0.01906797f, -0.12933904f, -0.02348088f, 0.06163119f, 0.04797227f, 0.07766569f, 
    -0.05863130f, 0.05276220f, 0.00805386f, -0.01654001f, -0.03481039f, -0.06247639f, -0.03327119f, 0.05001779f, 
    -0.06003098f, -0.06510486f, -0.04850976f, 0.02877549f, 0.14865038f, 0.04177644f, -0.13614620f, -0.12718047f, 
    0.02966571f, 0.11660254f, 0.13370135f, 0.14300203f, 0.00145909f, -0.05788441f, -0.02714506f, -0.02089926f, 
    -0.03920300f, 0.02054260f, 0.03601286f, 0.00472789f, 0.03295454f, 0.04410102f, 0.00591748f, 0.00192278f, 
    0.24188097f, -0.02420176f, -0.00519161f, -0.19705904f, -0.06432371f, -0.00704474f, 0.00894328f, 0.00613920f, 
    -0.06529210f, -0.01793798f, 0.00293622f, 0.03217214f, -0.15045269f, 0.02380366f, 0.04978562f, -0.07064310f, 
    -0.00574814f, 0.04546892f, -0.05708570f, -0.06364354f, 0.10620509f, -0.00820518f, -0.03589824f, 0.18883409f, 
    -0.31621531f, 0.02782270f, 0.09875569f, -0.11490359f, -0.07209723f, 0.04309036f, -0.03509415f, 0.00093555f, 
    -0.19898620f, 0.08052886f, -0.06184015f, -0.10483154f, 0.17708698f, -0.08700021f, -0.09864822f, -0.05221230f, 
    0.32404447f, 0.13974902f, 0.16758224f, -0.36361346f, 0.00984094f, 0.15288229f, 0.18373190f, 0.06828952f, 
    0.13111725f, 0.03568723f, 0.01042420f, -0.00794370f, -0.01241774f, -0.05008575f, 0.00997040f, -0.00072474f, 
    -0.04951094f, -0.09005696f, 0.06874610f, 0.11369759f, -0.26335901f, -0.25137806f, -0.19528063f, 0.01375710f, 
    -0.12502001f, 0.05316420f, -0.04185392f, -0.02082087f, 0.00573620f, 0.03467073f, -0.05035249f, 0.02741588f, 
    -0.07797091f, -0.00243191f, 0.06890052f, -0.10778762f, -0.06852565f, -0.10200501f, -0.00864403f, -0.12864706f, 
    0.25880921f, -0.04655044f, 0.05748018f, -0.15063044f, 0.01268462f, -0.03057489f, 0.05532287f, 0.05818904f, 
    -0.20163962f, 0.09347972f, 0.00781052f, 0.06069608f, -0.01377057f, -0.00957628f, -0.05171291f, 0.05395581f, 
    -0.02940168f, -0.04002320f, -0.01494838f, -0.02858089f, 0.28723714f, 0.17841344f, 0.02872471f, -0.16944985f, 
    -0.01956700f, 0.11844556f, 0.09794123f, 0.17727025f, -0.08930822f, 0.06123899f, -0.00963614f, 0.03369279f, 
    0.01028454f, -0.05832818f, 0.08555275f, 0.01880999f, -0.03514227f, 0.01252232f, -0.13323690f, -0.03495908f, 
    -0.04488173f, -0.05176592f, 0.04149852f, 0.03639895f, 0.01061989f, -0.08689082f, -0.15208471f, -0.03183865f, 
    0.02873184f, 0.01783190f, 0.02683865f, 0.06902979f, -0.00903997f, 0.03566412f, 0.03192144f, -0.06861740f, 
    -0.02843781f, 0.00681194f, -0.08263671f, -0.07782324f, -0.01749961f, -0.00371014f, -0.00650333f, 0.03584343f, 
    0.06058038f, 0.01121840f, 0.00129687f, 0.03546885f, 0.03820419f, 0.02677586f, -0.06357506f, -0.07672364f, 
    -0.12072419f, -0.03405801f, -0.14011136f, -0.04550339f, -0.05426405f, -0.13730933f, -0.03461600f, -0.07341795f, 
    0.05083486f, 0.05392321f, -0.24444200f, -0.11439095f, 0.04517747f, -0.06896016f, 0.10600648f, -0.03562828f, 
    0.06125297f, -0.10931405f, 0.02450427f, -0.18296975f, 0.05883339f, -0.01897480f, 0.06656408f, -0.09608358f, 
    0.01320389f, 0.04537247f, -0.02027475f, -0.05944795f, 0.07132041f, 0.08751694f, 0.09225176f, -0.00262320f, 
    -0.12326376f, 0.10879942f, 0.05156740f, 0.06051261f, -0.00741523f, -0.04587066f, -0.01792333f, -0.01578707f, 
    -0.02640973f, 0.09837001f, -0.00228339f, 0.06416835f, -0.04091965f, 0.01391581f, 0.10739670f, -0.09281388f, 
    0.27960926f, 0.27977195f, -0.00802718f, -0.31185803f, -0.19462220f, 0.06422508f, -0.02071634f, 0.00333182f, 
    0.04055696f, 0.08840366f, 0.04674771f, -0.03367070f, 0.04594298f, 0.02991700f, 0.02461622f, -0.01885414f, 
    -0.02345498f, 0.02616738f, 0.06501547f, -0.08674360f, 0.26191089f, 0.04674028f, 0.01111765f, -0.15042748f, 
    -0.02877932f, 0.02728867f, 0.01856192f, 0.07015181f, 0.09951111f, 0.07471683f, -0.02535556f, 0.03413879f, 
    -0.13561361f, 0.10735597f, -0.07027440f, 0.00611318f, -0.08197700f, -0.04443107f, 0.02857544f, -0.00104091f, 
    0.09558592f, 0.11511744f, -0.17974736f, -0.16027561f, -0.26824597f, 0.02589155f, -0.01387913f, -0.04256187f, 
    -0.02695077f, 0.10933876f, -0.03104436f, 0.01057183f, 0.04437109f, -0.03290084f, -0.00807118f, -0.02951856f, 
    0.01318437f, -0.04363645f, -0.05354753f, 0.00041655f, -0.37681183f, 0.06254996f, 0.22610810f, -0.04868001f, 
    0.02355903f, -0.03798090f, 0.02028068f, 0.02090003f, 0.02579416f, 0.03373037f, -0.04210667f, 0.01570296f, 
    0.00624076f, 0.01474875f, 0.02505064f, -0.00330328f, -0.04886338f, -0.12746149f, 0.01322662f, -0.06388451f, 
    0.01825573f, 0.18778403f, 0.10540752f, 0.35892862f, 0.05351495f, -0.08544566f, -0.12550823f, 0.09038360f, 
    -0.28472158f, -0.07321211f, 0.02014158f, 0.01297796f, 0.03877534f, -0.02716017f, 0.02459361f, 0.02787275f, 
    0.04621113f, 0.09688462f, -0.18235743f, 0.04796807f, 0.04638887f, 0.02739168f, 0.11612406f, 0.02933474f, 
    -0.01284051f, 0.00013196f, -0.00169618f, -0.06935295f, 0.00454419f, 0.00145498f, 0.01506565f, -0.03124662f, 
    -0.01016992f, 0.09184843f, -0.00092359f, -0.07266209f, 0.09129440f, -0.05803110f, 0.07759902f, 0.00356532f, 
    -0.04719819f, 0.22628593f, 0.01512081f, 0.06772941f, 0.15806338f, 0.00087603f, -0.12289397f, 0.00592804f, 
    -0.01951994f, -0.05453373f, 0.02303156f, 0.02501761f, 0.02577649f, -0.03048003f, 0.07639579f, 0.02965022f, 
    -0.00987048f, 0.13821810f, -0.17622779f, -0.00198490f, -0.92503458f, -0.00068678f, -0.13480459f, -0.24859209f, 
    0.27905956f, 0.05425419f, -0.08712492f, -0.15889040f, 0.37359262f, 0.17655642f, -0.06040462f, 0.08682194f, 
    0.01526539f, 0.01619986f, -0.07065594f, 0.01161622f, 0.00235672f, 0.01599496f, 0.00587254f, 0.08330670f, 
    0.15089485f, 0.07808283f, -0.02669921f, 0.12096296f, -0.15731184f, -0.03929224f, -0.07477445f, 0.00055809f, 
    0.02728739f, -0.07360505f, -0.06464241f, 0.09583092f, -0.03517620f, -0.03568787f, 0.04256792f, 0.04001365f, 
    0.01164620f, 0.10795269f, 0.12859306f, 0.07035735f, 0.29241127f, 0.09627397f, -0.09624769f, 0.08309917f, 
    -0.11519827f, -0.01623370f, -0.02052646f, -0.09214093f, 0.02428898f, -0.07419899f, -0.01160364f, 0.01937107f, 
    0.01340933f, -0.00847837f, 0.06286984f, 0.06788568f, -0.17867008f, -0.07837364f, -0.02399490f, -0.00448034f, 
    -0.08688011f, -0.17046364f, -0.15954572f, -0.08459180f, -0.05398516f, -0.07174554f, 0.09052061f, 0.13716744f, 
    0.05988718f, -0.09176159f, -0.09031790f, -0.02228788f, 0.13157493f, 0.00323890f, -0.02444867f, -0.03902001f, 
    -0.04166714f, 0.02420122f, -0.02855849f, 0.00037888f, -0.45925286f, -0.03322426f, -0.00449924f, -0.13334973f, 
    0.07811946f, -0.03898263f, -0.00366051f, 0.18000966f, 0.16175625f, 0.12362166f, 0.09430501f, 0.10946243f, 
    -0.04076068f, 0.02264892f, -0.04558501f, -0.01793280f, 0.03330693f, 0.05482123f, 0.05671300f, 0.11287281f, 
    -0.06623852f, -0.22442642f, 0.07194376f, 0.01211845f, -0.08107208f, -0.04822662f, 0.01938853f, -0.03801538f, 
    -0.01156221f, -0.09618413f, 0.17630112f, -0.06891011f, -0.12086485f, -0.16986883f, -0.01288517f, 0.06570981f, 
    -0.02479652f, -0.17916870f, 0.08883325f, -0.01556387f, -0.11269405f, -0.33493298f, -0.03552213f, -0.41508123f, 
    0.04619270f, 0.03250654f, 0.08323564f, -0.22619466f, -0.10056509f, 0.18964677f, 0.02163715f, 0.05906146f, 
    -0.06104215f, 0.07423954f, 0.03845315f, -0.01999684f, -0.04289879f, -0.21503635f, -0.10508303f, 0.06557547f, 
    -0.13765422f, 0.15587614f, -0.19679710f, 0.15369508f, -0.14010368f, 0.05406450f, 0.06046797f, -0.13011685f, 
    -0.03566207f, 0.09955118f, -0.12113462f, 0.00827508f, 0.04732227f, 0.08059693f, 0.11302195f, 0.01722571f, 
    0.00492419f, 0.05223858f, -0.10191140f, -0.00514027f, -0.19156042f, -0.21983583f, -0.46485114f, -0.26131412f, 
    -0.47616383f, 0.02609924f, -0.21744525f, -0.14740646f, 0.16196457f, -0.06004828f, -0.05969526f, 0.00303304f, 
    0.01015924f, 0.00335289f, 0.00584240f, -0.14460796f, -0.08613910f, -0.37914011f, -0.08731680f, -0.20279238f, 
    0.52479422f, 0.13169232f, 0.14153859f, 0.04512465f, 0.02342854f, 0.01913678f, -0.00962647f, 0.00470979f, 
    -0.04431909f, 0.01110604f, -0.03976787f, -0.02338000f, -0.05470266f, 0.04955781f, -0.04469497f, -0.12531057f, 
    -0.02339813f, -0.03000536f, 0.08039404f, 0.01648053f, 0.15334079f, -0.06309051f, -0.04717025f, -0.11963119f, 
    0.11845058f, 0.03790417f, 0.01369190f, 0.17380539f, 0.24807090f, -0.01034209f, 0.12051459f, -0.06938716f, 
    -0.01568525f, 0.04292221f, -0.04959175f, -0.03238322f, -0.03798075f, 0.04875002f, 0.02438966f, -0.08281445f, 
    -0.09620970f, 0.05106923f, -0.00398369f, -0.06470148f, 0.04299063f, 0.12677127f, -0.08868220f, 0.03843287f, 
    0.07335555f, -0.02336625f, -0.01973254f, -0.01998980f, 0.03163566f, 0.05697424f, -0.01926873f, -0.09608690f, 
    -0.03131447f, 0.03375748f, -0.02195151f, -0.09216698f, -0.27155659f, -0.02202278f, -0.14319859f, -0.00835392f, 
    0.03914754f, 0.09005528f, -0.09061041f, 0.11039848f, 0.09101515f, 0.01396409f, -0.10769475f, 0.05657553f, 
    0.07044265f, 0.06669144f, -0.00715892f, -0.14421079f, 0.04894641f, 0.03211550f, -0.04593483f, 0.02268966f, 
    0.20164898f, -0.01438390f, 0.03790793f, 0.05658810f, -0.06767511f, 0.03281377f, -0.08610369f, -0.07472663f, 
    0.03090259f, -0.09752238f, -0.03022185f, -0.03971941f, 0.02980206f, 0.03330347f, 0.04407792f, 0.00007443f, 
    0.11536077f, -0.01455999f, 0.14477308f, 0.00299406f, -0.07518869f, -0.03733211f, -0.10046958f, 0.13174197f, 
    -0.26329446f, -0.07206748f, 0.03881898f, 0.07501078f, 0.07661077f, -0.05080190f, -0.09804852f, 0.00168185f, 
    -0.03628854f, 0.05620653f, 0.08929447f, -0.00500770f, -0.00292137f, 0.08765812f, -0.04907156f, -0.11694382f, 
    0.28241557f, 0.07872122f, 0.11104707f, 0.06234982f, 0.11120863f, -0.04971566f, -0.04415759f, -0.05452253f, 
    -0.02209617f, -0.04153313f, -0.02783012f, 0.01228760f, 0.00501815f, -0.00805384f, -0.00360806f, -0.08086925f, 
    0.12035974f, -0.10643573f, 0.05607932f, 0.02671623f, 0.02736650f, 0.00127123f, 0.03356271f, 0.00182177f, 
    0.00967298f, 0.01340293f, 0.02168714f, -0.05654492f, 0.01328295f, -0.01023252f, 0.13614108f, 0.00465226f, 
    -0.02724075f, 0.04767534f, -0.01433887f, -0.09166866f, -0.02927095f, -0.06130182f, 0.03431669f, 0.02244817f, 
    0.13189818f, 0.05114725f, 0.01462530f, 0.08698805f, 0.00693077f, -0.04665643f, -0.00117562f, -0.00552393f, 
    -0.01974551f, -0.00679006f, 0.00835581f, 0.02432672f, -0.03389500f, -0.04038454f, 0.11136000f, -0.03209744f, 
    -0.06531445f, -0.01226950f, 0.05349706f, -0.04581117f, 0.58214271f, -0.12692060f, 0.10767809f, 0.14546700f, 
    0.00050027f, 0.03788506f, 0.04320813f, 0.09395696f, -0.03060516f, -0.11951759f, 0.00524738f, -0.08962873f, 
    0.17933296f, 0.01153778f, -0.22652064f, 0.16704980f, 0.05165522f, -0.01268870f, -0.08313634f, -0.04305632f, 
    -0.68875241f, -0.10643394f, -0.16620699f, -0.02467662f, -0.03470023f, -0.00381860f, 0.13167265f, 0.18266083f, 
    0.00664743f, -0.12681793f, -0.07854939f, 0.02885049f, -0.02967511f, 0.01968740f, -0.02022217f, -0.01785935f, 
    0.03184325f, 0.02005230f, -0.08944518f, 0.04624183f, -0.35163870f, -0.08505482f, -0.11543737f, -0.15711470f, 
    0.06426528f, -0.01601353f, -0.00602698f, 0.00664751f, -0.00932597f, 0.03507554f, -0.06989849f, 0.10543375f, 
    -0.21756351f, -0.01287865f, 0.06311513f, 0.11875703f, -0.05464659f, 0.12286943f, 0.06129263f, -0.21625586f, 
    -0.00171136f, 0.12848738f, -0.12395926f, -0.01287733f, 0.00601023f, 0.04450093f, 0.03655492f, 0.02544295f, 
    0.04925241f, -0.01273759f, -0.08899040f, 0.06292416f, 0.04258277f, 0.03058916f, -0.04718154f, -0.03076768f, 
    0.18892221f, 0.08447122f, -0.05684675f, 0.05633157f, 0.63724315f, -0.07352515f, -0.00016498f, 0.04911578f, 
    -0.13478179f, -0.06434997f, 0.00347251f, -0.02874475f, -0.06866421f, -0.02605268f, 0.18150802f, -0.13254309f, 
    -0.07185858f, -0.09595844f, -0.06763010f, 0.00017009f, -0.05781006f, -0.11581066f, 0.00716385f, 0.03182076f, 
    -0.01000209f, 0.27839708f, -0.01483709f, -0.02609975f, 0.10911885f, -0.10411124f, -0.05645778f, -0.04812610f, 
    0.06937153f, -0.14514220f, -0.00723222f, 0.07323609f, -0.00301670f, 0.02590669f, 0.10713219f, 0.13150170f, 
    -0.01075745f, 0.16355047f, 0.08591114f, -0.03398940f, 0.31141332f, 0.11708815f, 0.27596143f, 0.14464541f, 
    0.16394116f, -0.00295515f, -0.00391803f, 0.04178364f, -0.04456928f, 0.03029078f, -0.03613722f, -0.00931624f, 
    -0.01062946f, 0.02178727f, 0.00837426f, 0.16057163f, -0.12287737f, 0.00081384f, 0.17199297f, 0.05019700f, 
    -0.58035254f, -0.16376370f, -0.12711567f, -0.15335402f, 0.02420442f, 0.20643421f, -0.12163447f, -0.00124831f, 
    -0.06343680f, -0.05236411f, 0.07070195f, 0.02159770f, 0.03508854f, -0.04666357f, 0.02530172f, 0.01216461f, 
    -0.05428612f, 0.02095285f, -0.12989368f, -0.11116423f, 0.13549110f, 0.03620501f, 0.04791468f, 0.07821267f, 
    0.02024709f, -0.04840931f, -0.02975683f, -0.07559517f, -0.02093978f, -0.05368568f, 0.01672009f, 0.04698204f, 
    0.07467762f, -0.01610642f, 0.04134714f, -0.05920789f, -0.08469311f, -0.09512148f, -0.02237855f, -0.03787524f, 
    0.37286824f, -0.02716213f, -0.24848810f, -0.07803309f, -0.31146222f, -0.03026981f, 0.09312451f, 0.14221521f, 
    -0.15750751f, -0.05535197f, 0.22907780f, -0.02392182f, 0.13063623f, -0.03985993f, -0.01236342f, -0.04512614f, 
    0.01829029f, 0.04252570f, -0.00852363f, 0.07090292f, 0.18274273f, 0.34120539f, 0.19376719f, 0.14062193f, 
    0.06203836f, 0.11475261f, -0.07761993f, -0.05497053f, 0.14131331f, -0.22253776f, 0.04834350f, -0.01838620f, 
    0.01491103f, -0.11062118f, -0.04338169f, -0.02979777f, 0.03102317f, -0.01158201f, -0.03233973f, 0.07582767f, 
    0.11253058f, 0.08300442f, 0.07616516f, 0.02315228f, 0.06708981f, -0.04234496f, 0.06749025f, -0.00923353f, 
    -0.00767774f, 0.00111644f, -0.02799584f, -0.03297127f, 0.05372692f, 0.00363761f, -0.01560973f, -0.02619400f, 
    0.04055804f, 0.07580280f, 0.01148906f, -0.04832707f, 0.25192267f, -0.12549168f, 0.08094051f, 0.09499856f, 
    0.19196805f, -0.03458646f, 0.00497371f, 0.03398841f, 0.00420089f, -0.02789638f, 0.05641016f, 0.01146400f, 
    0.13268791f, -0.06453308f, -0.06519359f, 0.12190805f, -0.10846517f, -0.01184677f, -0.01494460f, -0.22704951f, 
    0.01091731f, 0.05622931f, -0.16726041f, -0.07292383f, -0.06235993f, -0.07607595f, -0.03260705f, 0.07885716f, 
    -0.06015161f, -0.03946035f, 0.02933177f, -0.02692159f, -0.06797256f, -0.11743324f, -0.06601195f, 0.05585974f, 
    0.02747915f, -0.01776651f, -0.00209079f, 0.01173086f, -0.58195895f, -0.20483109f, 0.09653188f, -0.24551351f, 
    -0.05805677f, 0.10963256f, 0.10064411f, 0.04935600f, 0.01999933f, -0.12017602f, 0.01954290f, -0.00088597f, 
    -0.04775180f, 0.04663642f, 0.02755873f, -0.05498511f, 0.01088638f, 0.02711989f, 0.00693811f, -0.13783409f, 
    -0.23995207f, -0.34113628f, 0.06837846f, -0.15021989f, -0.02468273f, 0.01364839f, 0.20560768f, -0.13951260f, 
    0.20110139f, 0.08325068f, -0.06386036f, -0.02663777f, 0.07412183f, 0.11303351f, 0.01663890f, 0.02898410f, 
    -0.00793419f, -0.08086163f, 0.21439670f, 0.05946349f, -0.19713886f, 0.11481155f, -0.13799003f, -0.04517888f, 
    0.00669765f, -0.07024326f, -0.01886389f, -0.09733878f, -0.12298401f, 0.08902784f, -0.08066714f, -0.03258524f, 
    0.08242976f, 0.06074527f, 0.05054293f, 0.02300921f, 0.00900332f, 0.01686742f, 0.09851273f, 0.01806026f, 
    -0.20742407f, -0.05865051f, 0.01747945f, 0.19653003f, -0.08904484f, 0.07704184f, 0.10927868f, 0.05743401f, 
    -0.03545779f, -0.02365026f, -0.03223021f, 0.00768037f, 0.03981129f, 0.00575447f, -0.04683157f, 0.01798092f, 
    0.02787917f, -0.01325123f, 0.03392137f, 0.04870781f, 0.14380889f, 0.13448088f, -0.33666509f, -0.20701790f, 
    -0.35013014f, -0.02593888f, -0.03525817f, -0.09922322f, -0.08970612f, -0.01695277f, -0.02085557f, -0.00352452f, 
    -0.01529981f, 0.03343391f, -0.00923370f, 0.02297538f, -0.14356916f, -0.03208485f, -0.14493513f, -0.21247138f, 
    -0.01456990f, -0.01369319f, 0.00794686f, 0.08334990f, 0.06115126f, 0.10807212f, -0.05454596f, 0.05789594f, 
    -0.01925438f, 0.04068905f, -0.05264083f, -0.00301043f, 0.05740272f, 0.10674572f, -0.01344397f, -0.05744032f, 
    0.13961275f, 0.02738319f, -0.00991183f, 0.03542231f, 0.00154836f, 0.06316883f, 0.04852366f, -0.06117897f, 
    -0.02515800f, 0.02435938f, -0.10619896f, -0.16030620f, -0.03166345f, -0.00630178f, -0.01968123f, -0.02323142f, 
    0.04462201f, 0.05549533f, 0.00317441f, 0.05548614f, 0.02060875f, -0.10795735f, 0.08334434f, 0.06943470f, 
    -0.66624314f, -0.40920082f, 0.09763264f, -0.21214792f, 0.01237403f, 0.10457187f, 0.06102644f, -0.18061730f, 
    -0.13654095f, 0.06685293f, -0.00517753f, 0.02804431f, -0.10283294f, 0.12616293f, -0.06554119f, 0.02106577f, 
    0.03723876f, -0.13992047f, 0.07460427f, 0.02984230f, -0.28421593f, 0.20608403f, -0.01508996f, 0.05285934f, 
    -0.01550861f, -0.02162824f, -0.02142291f, 0.09109047f, -0.14844261f, -0.00047197f, 0.00065466f, 0.05161222f, 
    0.05684080f, -0.08127928f, -0.09028897f, 0.08237369f, 0.20482109f, 0.03310139f, -0.04077615f, 0.09959237f, 
    -0.02008644f, -0.04443087f, -0.15276276f, -0.05841446f, -0.17886572f, -0.08424439f, 0.07186585f, 0.01756130f, 
    0.02226148f, 0.04136818f, 0.14451422f, 0.07161010f, -0.03876404f, 0.09654266f, 0.11546386f, 0.03661356f, 
    -0.03173292f, -0.01902227f, 0.07561439f, 0.13503724f, 0.23177464f, 0.03437592f, 0.11655407f, 0.01656927f, 
    0.24733485f, -0.02811837f, -0.04773534f, 0.00008149f, -0.04851249f, -0.01616640f, -0.01739655f, 0.03926985f, 
    0.04303399f, -0.03368582f, 0.00362852f, 0.06236824f, -0.05713727f, 0.05392985f, 0.07641122f, 0.02166620f, 
    -0.00074450f, -0.02833600f, 0.04243473f, -0.00910967f, -0.00105561f, 0.01410648f, 0.02606829f, 0.08367142f, 
    -0.08118898f, -0.00441555f, 0.08790711f, 0.02170554f, -0.01094977f, 0.04151803f, -0.04016292f, -0.05487671f, 
    0.07603961f, -0.00239646f, 0.04719764f, 0.07996279f, -0.17765778f, 0.18454184f, -0.03547210f, -0.13360719f, 
    0.02335820f, -0.03974015f, 0.11944336f, -0.17015067f, 0.02099231f, 0.11364640f, 0.00375709f, 0.02489021f, 
    0.04442531f, 0.01228831f, -0.01637814f, -0.14893101f, -0.33969471f, -0.01843756f, -0.29447407f, -0.09061746f, 
    0.12512273f, 0.12474302f, 0.04234955f, -0.06624254f, -0.04936850f, 0.09776627f, -0.01631605f, 0.00870047f, 
    0.16355468f, 0.16027106f, 0.03183765f, -0.01660443f, 0.03101728f, -0.02885320f, 0.05707008f, -0.02152319f, 
    0.03293026f, 0.08879810f, 0.02845448f, 0.00676798f, 0.08832853f, -0.03692157f, -0.00895628f, -0.05756605f, 
    -0.07175890f, 0.05571056f, -0.01322511f, 0.13292219f, -0.02581787f, -0.09416480f, 0.07004043f, -0.02883687f, 
    0.03846957f, -0.05581047f, -0.02415168f, 0.04317798f, 0.00492372f, 0.02824575f, 0.03768517f, 0.01487323f, 
    0.19246683f, -0.08940831f, -0.15303005f, -0.20851770f, 0.06740943f, -0.01253699f, -0.06671869f, 0.00673190f, 
    0.18488784f, 0.05485494f, 0.13300540f, 0.02764002f, 0.09688314f, -0.08606571f, -0.10280151f, 0.04501541f, 
    -0.05364082f, -0.04500622f, -0.02972979f, -0.10957685f, -0.13777432f, -0.23052366f, 0.21289097f, -0.07738215f, 
    -0.55655754f, -0.04739148f, -0.06912558f, -0.04611036f, -0.09873851f, 0.02056352f, -0.03428805f, -0.03468722f, 
    -0.06346293f, -0.13626537f, -0.05167437f, 0.13146588f, -0.18789491f, -0.27612966f, 0.00900980f, 0.05953334f, 
    -0.03174652f, 0.15489383f, 0.00730755f, -0.02663523f, 0.35353440f, 0.05031975f, -0.06494807f, -0.05337176f, 
    -0.01793969f, -0.06244152f, -0.00793321f, 0.00680099f, 0.03404314f, -0.12095245f, -0.00863950f, 0.06289638f, 
    0.00551927f, 0.15541530f, -0.09287719f, -0.07352907f, 0.01167177f, 0.03936242f, 0.12353358f, 0.04985079f, 
    0.08716585f, 0.05427111f, -0.06848391f, 0.01313627f, -0.03042127f, 0.02117462f, -0.04299330f, -0.01941059f, 
    0.00237037f, 0.07154082f, -0.07448551f, -0.03359118f, -0.00335831f, -0.06202326f, 0.01655209f, -0.00701694f, 
    0.05771821f, 0.36864579f, -0.14556241f, -0.01829060f, -0.20988436f, -0.07170600f, -0.08631316f, 0.09531191f, 
    0.05630049f, 0.00260790f, 0.03244415f, -0.00643237f, -0.00237919f, -0.03513699f, 0.02361956f, 0.07937425f, 
    0.00889420f, -0.18675585f, -0.15724659f, 0.00252044f, 0.30415967f, 0.32797047f, 0.25901672f, 0.12036259f, 
    0.02561929f, 0.10193999f, -0.06465906f, -0.06480876f, 0.20700444f, -0.04237428f, 0.07170499f, 0.00293443f, 
    0.04086630f, -0.06268635f, 0.00608276f, -0.05775204f, 0.00128495f, -0.25932482f, 0.02447408f, 0.11807196f, 
    0.10707201f, -0.03059346f, 0.10774593f, -0.03389560f, 0.03275210f, 0.06449104f, -0.06519169f, -0.07959560f, 
    -0.00473374f, 0.04208956f, 0.00107204f, -0.02810427f, 0.01791489f, 0.06433738f, -0.04189254f, -0.04068353f, 
    0.04404599f, -0.11969896f, 0.05006464f, -0.00873855f, 0.02972423f, 0.00888303f, -0.02280430f, 0.03631676f, 
    -0.00406376f, -0.01876741f, 0.00724342f, -0.01156308f, -0.00979228f, -0.03690129f, -0.03173083f, 0.07000393f, 
    0.08325948f, 0.05878865f, 0.04741288f, -0.07828131f, -0.01685760f, -0.03842149f, 0.00333488f, -0.01936104f, 
    -0.06081407f, 0.12755668f, -0.06599985f, 0.02443327f, 0.07195767f, 0.05021965f, -0.05612481f, -0.03336722f, 
    0.06270122f, -0.14877698f, -0.04861330f, 0.02831136f, -0.06630339f, -0.05546838f, -0.03789638f, 0.03325720f, 
    0.01107379f, 0.04620513f, -0.00482032f, -0.07394055f, 0.33875203f, 0.30792698f, -0.03373425f, 0.25447980f, 
    -0.29926905f, -0.11673951f, 0.04730279f, 0.14901131f, -0.09872054f, 0.12413074f, 0.02250362f, -0.00391870f, 
    -0.00672377f, -0.05753870f, -0.01068415f, -0.01092960f, -0.06208812f, -0.05371108f, -0.22255579f, -0.06762160f, 
    -0.18352222f, -0.00919941f, -0.02185317f, 0.22089706f, -0.04143816f, -0.01189523f, 0.11752363f, -0.10719270f, 
    -0.02455124f, -0.01697988f, 0.00908992f, -0.01752996f, 0.03501071f, 0.03433231f, 0.01130632f, -0.02842281f, 
    0.00192277f, 0.00453801f, -0.11099288f, 0.12355863f, 0.06385168f, -0.04996126f, 0.02441924f, -0.11841238f, 
    0.05714980f, 0.01606192f, 0.02400461f, -0.06140140f, 0.18223032f, 0.08568912f, 0.03398607f, -0.02347258f, 
    0.13189469f, 0.00902411f, -0.03588048f, 0.12801130f, -0.10833952f, -0.17071725f, 0.10146984f, -0.09569717f, 
    -0.15852301f, -0.05004635f, -0.23495057f, -0.01638134f, -0.22638057f, -0.04152786f, -0.01469445f, -0.30252829f, 
    -0.01501842f, 0.04712614f, -0.02355069f, -0.00966031f, -0.01933505f, 0.06498256f, 0.09242804f, -0.04359373f, 
    0.07272651f, -0.05351653f, -0.08274635f, -0.01401486f, -0.10060196f, 0.18088843f, 0.14392824f, 0.20004576f, 
    0.25898835f, -0.02861844f, -0.03773776f, 0.02407644f, 0.02424251f, -0.04202966f, 0.03153370f, 0.02873266f, 
    0.06294363f, -0.03742158f, 0.07854016f, 0.12698987f, 0.01484940f, 0.07846726f, 0.05619220f, -0.11368438f, 
    -0.47471794f, -0.71275514f, -0.35238937f, 0.01901099f, -0.77045172f, -0.02864516f, -0.07239739f, -0.05006932f, 
    0.07373617f, -0.22750144f, 0.00614193f, 0.00737342f, -0.01329797f, 0.00420043f, -0.07502139f, -0.01863974f, 
    -0.00464252f, -0.00529274f, -0.17348817f, -0.04347821f, -0.06296412f, -0.01436033f, 0.00293141f, -0.00171909f, 
    0.05563067f, -0.03262632f, -0.01248525f, -0.06488799f, 0.00260048f, 0.03762663f, 0.04985870f, -0.03872244f, 
    -0.03018342f, 0.06679749f, -0.06826041f, 0.02099779f, -0.11204138f, 0.02352366f, 0.01987069f, -0.01818896f, 
    -0.42505294f, -0.42969248f, -0.52016282f, 0.03233209f, -0.40085319f, -0.01263473f, 0.09652761f, 0.04186035f, 
    0.04710845f, 0.02700935f, 0.00466981f, 0.00820941f, 0.01450217f, 0.00884592f, -0.04974962f, -0.05685350f, 
    -0.01558604f, 0.04986750f, -0.07317945f, 0.11896458f, 0.39271343f, 0.11919122f, -0.43057531f, 0.01675541f, 
    -0.10831341f, 0.07399364f, 0.07738964f, -0.02701326f, 0.04706769f, 0.04662682f, -0.04084398f, 0.02709045f, 
    -0.09653083f, 0.04270218f, -0.01044313f, -0.04629824f, 0.02510289f, 0.04931604f, -0.35972422f, -0.10263558f, 
    -0.04995186f, 0.00555092f, 0.03888359f, -0.36119449f, -0.03738384f, 0.06755808f, -0.07868779f, -0.07015900f, 
    0.00777354f, 0.04091821f, 0.01907386f, 0.00771372f, -0.07436547f, -0.00751268f, 0.00171760f, 0.10720678f, 
    -0.02721307f, -0.14862218f, 0.07887575f, 0.10921152f, -0.33160061f, 0.16795558f, 0.03128016f, -0.16517220f, 
    0.02151801f, 0.05883172f, 0.02572878f, -0.00254238f, 0.01595254f, 0.01905663f, -0.02020217f, 0.04815594f, 
    0.00450478f, -0.00666628f, 0.03653393f, 0.01682157f, 0.02569083f, 0.15473077f, 0.11351968f, 0.01503466f, 
    0.09943008f, -0.02857768f, 0.13389732f, 0.03529349f, 0.10906179f, -0.05087794f, -0.06376814f, -0.00954738f, 
    0.04625297f, -0.27642787f, -0.05613559f, -0.02391438f, 0.09133888f, -0.03436164f, 0.05841703f, 0.03839264f, 
    -0.06994528f, -0.05555905f, -0.00525908f, -0.03560022f, 0.20988904f, 0.14456479f, -0.26347145f, 0.04813296f, 
    0.09681354f, 0.02493424f, -0.00325702f, -0.21357557f, -0.07467353f, 0.03976369f, -0.03997928f, -0.02128575f, 
    0.01779701f, 0.01545614f, -0.06337604f, 0.02634978f, -0.00079389f, 0.07422825f, -0.15340151f, 0.10279204f, 
    -0.12834518f, -0.29491156f, 0.52395236f, 0.06183352f, 0.20532990f, -0.08396310f, -0.04771935f, 0.09481572f, 
    -0.16928947f, -0.02767773f, 0.12629919f, -0.01440537f, -0.03365093f, -0.03348452f, 0.14401048f, 0.05766682f, 
    0.04917750f, 0.01890749f, 0.04161231f, -0.05935912f, 0.44274864f, -0.29405823f, 0.03791638f, -0.14680682f, 
    0.05926934f, 0.17680696f, 0.00135118f, -0.06557564f, -0.04292342f, -0.03575980f, 0.01311248f, -0.02456632f, 
    0.02910594f, -0.00556324f, 0.01506467f, 0.11587635f, -0.05139670f, -0.09675469f, 0.07421041f, 0.16523211f, 
    0.12458835f, -0.12063690f, -0.02435429f, 0.02580620f, -0.14654821f, 0.17429967f, 0.01018418f, -0.05297127f, 
    0.08591713f, -0.08498278f, -0.00907757f, 0.07787045f, -0.03751279f, 0.01438109f, -0.06200337f, 0.02217329f, 
    -0.00188973f, 0.05001312f, 0.09601820f, 0.09867807f, -0.42434978f, -0.20080416f, 0.11161432f, -0.17793338f, 
    -0.10133154f, -0.04502657f, -0.21779381f, -0.16998249f, -0.00913888f, -0.04840951f, -0.01167809f, -0.01894576f, 
    0.03456628f, -0.01442319f, -0.01602780f, -0.12603046f, -0.03652575f, 0.10278381f, 0.07599474f, 0.11057299f, 
    -0.57119423f, 0.16461447f, -0.03877874f, -0.01814539f, -0.05550291f, -0.05617272f, -0.04240678f, -0.01768242f, 
    0.01663720f, 0.18892907f, 0.00903078f, -0.02672600f, -0.11580577f, 0.07242006f, -0.02748006f, -0.03310446f, 
    -0.18294303f, 0.00719964f, 0.08722953f, -0.07881567f, 0.23737468f, -0.12712403f, 0.22399771f, 0.20449787f, 
    0.08888499f, 0.03272480f, -0.12844504f, 0.00096082f, 0.18166146f, -0.06844882f, 0.05246522f, 0.05887468f, 
    -0.00197145f, 0.01973472f, -0.03611231f, 0.03293693f, -0.03257513f, -0.07097086f, 0.06410628f, -0.05583619f, 
    0.01783873f, 0.01545261f, 0.01824350f, 0.01989383f, 0.08133940f, 0.04824215f, -0.43160051f, -0.12669656f, 
    0.04162955f, 0.11603674f, 0.02057320f, -0.14000405f, 0.09671569f, -0.05264302f, -0.09123679f, -0.05221563f, 
    -0.01976705f, -0.03911575f, -0.01231968f, -0.02410478f, 0.39090723f, 0.12217379f, -0.20276193f, 0.20150842f, 
    0.12141431f, 0.13150026f, -0.11840390f, -0.04198914f, -0.02054322f, 0.05751353f, -0.13418621f, 0.09835347f, 
    0.06955546f, -0.00080003f, -0.05641036f, 0.01379305f, -0.03259562f, 0.01049656f, 0.06079512f, -0.05171258f, 
    -0.32359248f, -0.10417108f, 0.13972019f, -0.28927830f, 0.00307674f, 0.08276594f, 0.07515823f, 0.01263638f, 
    0.03937894f, 0.06389355f, -0.00738042f, -0.00857911f, 0.05112781f, 0.00841083f, -0.00850410f, 0.06307707f, 
    -0.11571522f, -0.00884097f, -0.08680813f, 0.12203361f, -0.18367024f, -0.23951960f, -0.16946849f, -0.08862733f, 
    -0.44102252f, 0.14784361f, -0.03565527f, -0.09088019f, 0.13301750f, -0.20638481f, -0.02894407f, 0.04051822f, 
    -0.01188574f, 0.03476212f, -0.05085558f, 0.01663815f, -0.00664424f, -0.01423523f, 0.11088031f, 0.07804857f, 
    -0.30681148f, -0.25923735f, -0.01538895f, -0.33662790f, -0.15784886f, -0.02104391f, -0.00925752f, 0.01991384f, 
    0.03508313f, 0.06338827f, 0.04931132f, -0.04824000f, 0.00778247f, 0.06566427f, -0.00660460f, 0.03575060f, 
    -0.17371143f, -0.02100062f, 0.02340699f, 0.00051471f, 0.07019123f, -0.06354560f, -0.00394351f, -0.01046834f, 
    0.08527311f, -0.00195949f, -0.01102757f, 0.00935687f, 0.02367068f, 0.04985904f, -0.11638356f, -0.13546367f, 
    -0.06749789f, 0.02115250f, -0.03022610f, 0.03790484f, -0.08622973f, -0.05787135f, -0.00608761f, -0.03616878f, 
    0.00514833f, -0.09770834f, -0.01338332f, -0.09867479f, 0.08856224f, 0.02703825f, -0.02665084f, -0.02350136f, 
    0.05290492f, 0.06145093f, -0.00626233f, -0.03545296f, 0.00845456f, -0.08208808f, -0.01799716f, 0.07621335f, 
    -0.05310302f, -0.09619976f, 0.05505241f, 0.01468543f, -0.31137547f, 0.12832619f, 0.02289999f, -0.17658192f, 
    -0.13856930f, 0.10293167f, -0.07268587f, -0.05579652f, 0.01312315f, 0.06126946f, -0.01486401f, 0.10616226f, 
    0.07189497f, -0.12196668f, 0.07608551f, -0.08552423f, -0.02963104f, 0.02468717f, 0.18922791f, -0.06854057f, 
    0.09862231f, 0.14801036f, -0.11622494f, 0.28137040f, 0.09629918f, -0.05841716f, -0.02508228f, 0.13502449f, 
    -0.07700902f, 0.02542618f, 0.00449147f, 0.07182480f, 0.03277329f, 0.01231151f, -0.00682814f, -0.01383921f, 
    -0.01827531f, 0.01365836f, -0.06476355f, -0.03801646f, -0.12445974f, -0.05837276f, -0.57031959f, -0.06440052f, 
    0.13919382f, 0.02432160f, -0.00116345f, -0.01959044f, -0.01675058f, 0.01921841f, -0.08074413f, -0.00448230f, 
    -0.10081774f, -0.06606887f, -0.07648452f, -0.05724278f, 0.09271739f, 0.08069248f, 0.11113483f, 0.11876751f, 
    0.01331321f, 0.39180493f, -0.23128469f, -0.01431826f, -0.01253606f, 0.11129627f, 0.00297263f, -0.15788734f, 
    0.00811907f, 0.05016641f, -0.03335983f, 0.04664098f, 0.06048329f, -0.10767041f, 0.01022330f, -0.19519621f, 
    -0.01993999f, -0.00616779f, 0.04213985f, -0.06998804f, -0.18264697f, 0.25652879f, 0.47604826f, 0.00480758f, 
    0.13305183f, -0.02556910f, 0.01600113f, 0.09068352f, 0.00058406f, 0.07206478f, 0.03408885f, -0.04318559f, 
    -0.10240310f, -0.00342001f, 0.04235887f, -0.00839757f, -0.02945708f, 0.02907647f, 0.04808694f, -0.06997826f, 
    -0.03764818f, -0.02833106f, -0.09967995f, -0.32384479f, -0.23394006f, 0.07361408f, 0.12605792f, -0.03746156f, 
    -0.03080361f, 0.16198678f, -0.00057285f, 0.05531672f, -0.05828553f, 0.07579910f, -0.10175768f, -0.00865729f, 
    -0.02237863f, -0.24307220f, -0.08176046f, 0.06140225f, -0.01566409f, -0.16129498f, -0.01540633f, -0.07959013f, 
    -0.15403248f, 0.04065742f, 0.01110668f, 0.03792260f, 0.04769028f, 0.05817642f, -0.02464997f, -0.02328507f, 
    -0.04115853f, 0.02657207f, 0.00548208f, 0.03674011f, -0.03393079f, 0.06062998f, 0.16357772f, -0.11406098f, 
    0.34349078f, 0.22768137f, -0.34850085f, 0.12313672f, 0.18307365f, -0.06830714f, 0.09939450f, -0.00924952f, 
    0.00333196f, 0.07025725f, -0.05705975f, -0.00283171f, -0.02030070f, -0.00827239f, -0.04080935f, -0.02486675f, 
    0.08931018f, 0.07780470f, -0.10378092f, 0.07935006f, -0.06275182f, -0.12447536f, -0.00985717f, -0.01897603f, 
    0.06989690f, 0.04428025f, 0.03336948f, 0.03981829f, 0.07858801f, -0.01189762f, -0.14696866f, -0.09289833f, 
    -0.08438703f, 0.03325028f, 0.03819590f, 0.03609253f, 0.02015239f, 0.02257057f, 0.03233879f, -0.00180306f, 
    -0.04841525f, 0.19579063f, 0.11765116f, -0.05082234f, -0.14359474f, -0.03991059f, -0.09423562f, -0.09720748f, 
    -0.10658240f, -0.30265254f, -0.03321547f, 0.01687461f, 0.12301853f, -0.07096818f, -0.00185704f, -0.01631350f, 
    -0.00057334f, -0.04341562f, 0.11987407f, -0.13366449f, -0.12390932f, -0.41566315f, 0.33655810f, 0.42309254f, 
    -0.22247738f, 0.03258394f, -0.04582350f, -0.06709500f, 0.10449123f, -0.04932709f, -0.00903612f, 0.04415019f, 
    -0.04710227f, 0.04127363f, -0.05158244f, -0.01182995f, 0.00191948f, -0.02702782f, 0.09512312f, -0.03537595f, 
    -0.00964979f, -0.02052732f, -0.09060852f, 0.03276168f, 0.09347861f, 0.05656520f, -0.04046220f, -0.02332896f, 
    -0.00773759f, 0.06306440f, 0.05274225f, 0.05968389f, 0.01090149f, 0.06066174f, -0.01770334f, 0.05598543f, 
    -0.01153974f, -0.05687178f, 0.04715053f, -0.03905181f, 0.20207544f, 0.11319600f, -0.04320586f, 0.02575534f, 
    0.18695474f, 0.04678265f, -0.02255801f, -0.04547247f, 0.07194220f, -0.05451196f, -0.08207200f, -0.09320607f, 
    0.09749183f, -0.09785756f, 0.07245195f, 0.06603125f, 0.00407055f, 0.00872563f, -0.01131396f, -0.01873310f, 
    -0.17439057f, 0.00317428f, 0.41701138f, 0.25907743f, 0.30091065f, -0.03041305f, -0.04828060f, 0.00736815f, 
    0.13045165f, -0.04778192f, 0.01752122f, 0.06974313f, 0.04364908f, 0.00315925f, -0.01022675f, 0.00856229f, 
    -0.02533343f, 0.00816396f, -0.03707623f, 0.01376693f, 0.08902787f, -0.00483716f, -0.23767792f, 0.04149687f, 
    -0.11099076f, -0.06348896f, 0.10601499f, 0.08860387f, -0.12576765f, 0.19063681f, 0.02684952f, -0.01500306f, 
    -0.04988724f, 0.06133081f, -0.04263193f, -0.06055132f, 0.02883038f, 0.01265552f, 0.07087217f, 0.06504104f, 
    0.07607770f, 0.06500537f, -0.06502206f, -0.09542704f, 0.01086460f, -0.00873733f, -0.01776403f, -0.36583316f, 
    -0.21048579f, -0.00453352f, 0.02561174f, -0.12650114f, 0.00329968f, 0.07300963f, -0.08116233f, 0.07629967f, 
    -0.01513205f, -0.07858682f, 0.13744949f, 0.04811157f, -0.19826360f, 0.00742986f, -0.10058349f, 0.05067254f, 
    -0.02999835f, 0.01017247f, 0.06220103f, -0.08488140f, -0.17949717f, -0.04416529f, 0.04054264f, 0.02550032f, 
    0.02971407f, 0.00934304f, -0.03391494f, -0.01006490f, -0.01336147f, 0.02292936f, -0.10956259f, -0.10628270f, 
    0.21795237f, -0.05626346f, 0.17501938f, 0.26447091f, 0.02469909f, 0.05185988f, -0.18187739f, -0.00750979f, 
    0.03110177f, -0.15427990f, 0.04705355f, 0.06085292f, 0.03438251f, -0.01148016f, 0.04350198f, 0.03029419f, 
    0.01420139f, -0.02316826f, 0.05656722f, -0.06111351f, -0.35814992f, -0.14744847f, 0.33337635f, 0.11132647f, 
    -0.17422070f, -0.01983474f, 0.05207369f, 0.02391088f, -0.00538842f, 0.01707105f, -0.00685731f, -0.01914820f, 
    0.01699190f, -0.01966687f, -0.00845031f, 0.04600874f, 0.08996650f, 0.11667162f, -0.00412199f, 0.14250216f, 
    -0.03872021f, 0.09274232f, -0.08631159f, -0.01824551f, 0.09475196f, 0.03637576f, -0.05624745f, 0.01862368f, 
    0.02232094f, 0.02852459f, 0.11497714f, -0.00337341f, 0.01136248f, 0.07264810f, 0.07257204f, 0.03600713f, 
    -0.06609680f, 0.01965079f, -0.01377941f, 0.02421624f, -0.24414238f, -0.06731572f, 0.17279972f, -0.18091440f, 
    0.03941184f, -0.00794265f, 0.03842694f, -0.07309300f, -0.00996342f, 0.10039644f, 0.01638303f, 0.02299586f, 
    0.01622335f, 0.03018370f, -0.02401804f, -0.02704328f, -0.16096209f, -0.20005426f, -0.06858675f, 0.00582725f, 
    0.68048298f, -0.37690052f, -0.04782841f, -0.04301910f, 0.15030269f, 0.13408269f, -0.01818554f, -0.17426333f, 
    -0.10689232f, -0.04748609f, -0.01740664f, 0.01687543f, 0.06134924f, 0.02300389f, 0.01101834f, 0.08798898f, 
    -0.00252779f, -0.17261066f, 0.10618479f, 0.11283618f, 0.12261561f, 0.22507335f, -0.19701682f, 0.04128132f, 
    0.18240599f, -0.18420880f, 0.19209242f, 0.08141675f, -0.09129587f, -0.13660280f, -0.00111169f, 0.03330681f, 
    -0.02706896f, -0.06152894f, -0.03145783f, 0.02145796f, -0.08417268f, 0.03692171f, -0.16778731f, -0.07426414f, 
    -0.11870851f, 0.03919350f, -0.05077050f, -0.01728000f, 0.01901628f, -0.02192201f, -0.07052709f, -0.28896165f, 
    0.08932073f, -0.09810184f, 0.06267270f, 0.01713700f, -0.06142798f, 0.02732960f, 0.02470478f, 0.01002200f, 
    0.03417770f, -0.03781201f, 0.12375456f, 0.05933383f, -0.12626393f, -0.01673237f, -0.07962257f, -0.18039460f, 
    0.03973905f, 0.07603779f, -0.00512106f, 0.02938610f, 0.01017420f, 0.02442842f, 0.00907709f, 0.02728614f, 
    -0.01722377f, 0.01929228f, 0.04087367f, 0.13805220f, 0.03261298f, -0.04787133f, 0.09756142f, -0.06694064f, 
    -0.01774975f, 0.07387395f, 0.01039244f, 0.00819734f, 0.14285439f, -0.08136848f, 0.09470213f, -0.04845145f, 
    0.00908789f, -0.03005885f, 0.02410683f, 0.06356610f, -0.05944701f, 0.04234860f, 0.02319977f, -0.02787618f, 
    -0.02841475f, 0.03699253f, -0.04025059f, -0.03887188f, 0.00517150f, 0.04092068f, -0.12301491f, 0.19695705f, 
    -0.15217903f, -0.10562199f, 0.01456877f, -0.08143505f, -0.01108273f, 0.10066780f, 0.00223871f, -0.04968080f, 
    0.01884288f, -0.02320668f, -0.05711010f, 0.15252547f, 0.10448055f, 0.01877660f, 0.10509405f, 0.11902612f, 
    -0.06178610f, -0.03712133f, 0.28234136f, 0.17847885f, 0.12491820f, 0.04308169f, 0.01174281f, -0.00153305f, 
    0.07846411f, -0.04518823f, -0.01313640f, 0.04225014f, 0.01079778f, 0.03276105f, -0.00283879f, -0.02216209f, 
    0.03197632f, -0.09032694f, -0.05259697f, 0.02420252f, -0.10913066f, -0.00611090f, 0.40914062f, 0.22419088f, 
    0.23240301f, -0.05972182f, -0.03970971f, 0.04684553f, 0.11094006f, -0.03293929f, 0.03822371f, 0.06685048f, 
    0.03011252f, -0.03286535f, 0.04185672f, 0.01611062f, -0.00122166f, 0.04203672f, 0.01059753f, -0.02341885f, 
    -0.00108508f, 0.10445570f, 0.28366640f, 0.15643942f, 0.21052060f, 0.00548402f, -0.07602903f, -0.10466337f, 
    0.08394613f, -0.11388522f, 0.03948889f, -0.01826798f, 0.10509830f, -0.06644408f, 0.01163993f, 0.05929595f, 
    0.06019035f, 0.02865048f, -0.11012866f, 0.04945444f, 0.32448128f, -0.18285508f, 0.45259064f, -0.22332905f, 
    -0.19617529f, 0.04035390f, -0.19600417f, -0.04417983f, -0.05338571f, 0.15601937f, 0.05795436f, -0.06628063f, 
    0.12296705f, -0.08832469f, 0.15170918f, 0.01890412f, 0.06925359f, -0.07430975f, 0.10465995f, -0.10466116f, 
    -0.11641687f, -0.18869953f, -0.11772008f, 0.05368002f, 0.05817320f, -0.04690171f, 0.09562080f, -0.03916334f, 
    0.18813749f, 0.04490214f, -0.01179700f, -0.03094228f, 0.02899397f, 0.10247823f, -0.07843408f, -0.01287479f, 
    0.02905374f, 0.00190907f, -0.18276942f, 0.13604131f, -0.02229921f, -0.10940251f, 0.07322557f, -0.11732595f, 
    0.04832102f, -0.03060868f, -0.04148661f, -0.02314036f, 0.02333689f, 0.01131568f, 0.05623667f, -0.01902057f, 
    0.00000025f, 0.02474215f, 0.08574606f, 0.05377312f, 0.02226376f, -0.08728569f, 0.03525011f, 0.01152611f, 
    -0.24070930f, -0.05563409f, 0.19043423f, 0.06923264f, -0.06070738f, 0.02275795f, -0.08209310f, -0.08923540f, 
    -0.06135980f, -0.04351535f, -0.03004571f, 0.03528387f, 0.03805587f, 0.00199442f, -0.04342633f, -0.06864674f, 
    0.04478537f, 0.11599619f, -0.05190031f, -0.11061834f, -0.36943093f, -0.37909579f, 0.43973956f, 0.32171190f, 
    -0.15451178f, -0.06606689f, -0.09153946f, -0.07647889f, 0.07528433f, -0.12592676f, -0.01892271f, 0.02682601f, 
    -0.05647325f, 0.03518149f, -0.07970734f, -0.09864125f, -0.01783865f, -0.06313705f, 0.00134796f, -0.10751523f, 
    -0.09568682f, -0.02313381f, 0.09907684f, -0.08039512f, 0.08038906f, -0.07453657f, 0.02499212f, -0.05950860f, 
    -0.03330423f, 0.04363360f, 0.01322858f, -0.05380769f, 0.00518005f, 0.03623306f, -0.00561188f, 0.06488885f, 
    -0.13362552f, -0.00697203f, -0.03136893f, -0.03922898f, -0.14350057f, -0.00684177f, -0.00678457f, -0.04337607f, 
    0.02900744f, -0.00768456f, -0.00973031f, 0.00688916f, -0.01976698f, 0.03157598f, 0.01048755f, -0.08045736f, 
    -0.03622601f, -0.04956659f, -0.08019198f, 0.00304334f, -0.00499174f, -0.03728472f, -0.01998604f, 0.00684832f, 
    0.19858153f, -0.09315009f, 0.09166250f, 0.17953444f, 0.10694800f, 0.14704715f, -0.11686864f, 0.00548845f, 
    0.11146314f, 0.02597065f, -0.03538110f, 0.13363448f, 0.01828605f, 0.01770256f, -0.07089606f, 0.05269491f, 
    -0.08818746f, -0.05914859f, 0.03405814f, -0.02146308f, -0.09088928f, 0.31012389f, 0.18631719f, 0.41356480f, 
    0.05146220f, -0.00619091f, -0.00234816f, -0.03408181f, -0.15757291f, 0.19004157f, 0.00999324f, -0.01206849f, 
    0.04688525f, -0.09963181f, -0.00977586f, -0.07306859f, -0.00011690f, -0.11358958f, -0.02016600f, 0.01087160f, 
    -0.46557793f, -0.51177227f, -0.40789539f, -0.05700357f, -0.33582127f, 0.10152195f, 0.07409212f, -0.04190524f, 
    -0.18419951f, -0.18307258f, -0.01406826f, 0.04079711f, 0.03328810f, 0.00590263f, -0.04682859f, -0.00779600f, 
    -0.01714179f, 0.00908499f, -0.18278663f, -0.04213146f, 0.00943042f, -0.09781522f, 0.29772019f, 0.07723276f, 
    0.29881680f, -0.04663432f, 0.02629586f, -0.09919827f, 0.08536464f, 0.03946873f, -0.03355629f, -0.00209673f, 
    0.01267931f, -0.15556803f, 0.02209218f, 0.00741070f, 0.03327084f, -0.01031205f, -0.13299690f, 0.15278456f, 
    -0.28444681f, -0.48622265f, -0.04278015f, -0.22075737f, -0.18441553f, 0.10300168f, 0.11140558f, -0.10668010f, 
    0.01803929f, -0.08717182f, 0.00496123f, 0.02495597f, -0.05596212f, 0.01777328f, -0.04698065f, 0.04828110f, 
    -0.01403023f, -0.04553856f, -0.01713607f, 0.08615040f, -0.10934100f, -0.19000021f, -0.22948518f, -0.10778696f, 
    -0.05308076f, 0.00698868f, 0.01937957f, 0.02369963f, -0.00527207f, 0.02785781f, 0.02008769f, 0.04893952f, 
    0.00260943f, 0.04474424f, 0.05281105f, -0.01753754f, 0.06135606f, 0.13020213f, 0.06337817f, 0.01600904f, 
    -0.02626909f, -0.20374869f, -0.29651776f, 0.03554433f, 0.24179889f, 0.05369062f, 0.03807025f, -0.07704630f, 
    0.11384479f, 0.01444473f, -0.00732529f, 0.01112990f, -0.00133539f, 0.02263191f, -0.06494145f, -0.04717426f, 
    -0.02944116f, 0.05987627f, -0.01334897f, 0.01192385f, -0.26998195f, -0.00622032f, -0.01010397f, 0.02657315f, 
    -0.13807945f, -0.04732491f, -0.13225639f, 0.00035409f, -0.05424442f, -0.06967635f, -0.03237782f, -0.02441852f, 
    0.00964280f, -0.04820104f, 0.05251759f, -0.04016880f, 0.01586716f, -0.08101304f, -0.00473733f, -0.02956799f, 
    -0.10714840f, -0.05603741f, -0.16767463f, 0.00715177f, 0.13791268f, -0.07013779f, 0.06794558f, -0.05967499f, 
    0.03660129f, 0.03264952f, -0.10171523f, 0.01140235f, -0.09904374f, -0.08136047f, -0.03974132f, -0.03600173f, 
    -0.01010220f, 0.05498040f, -0.13130510f, -0.06959314f, 0.17259116f, 0.11221638f, -0.21805693f, -0.23941158f, 
    0.08156513f, 0.01383649f, -0.00368631f, -0.06605916f, -0.04105663f, 0.00025744f, 0.05438793f, -0.03161407f, 
    -0.09590943f, -0.01758201f, -0.04912854f, 0.06287765f, -0.05018399f, 0.09667390f, -0.19054842f, 0.00815387f, 
    -0.32949349f, 0.14043947f, 0.13321841f, 0.23642340f, 0.07234669f, -0.04751431f, -0.08012466f, -0.15057743f, 
    -0.08170518f, -0.10519569f, -0.00759530f, -0.09611630f, 0.05368562f, 0.03529489f, -0.08700058f, 0.07464467f, 
    -0.00462294f, 0.03206220f, -0.01318663f, -0.07372297f, -0.23829973f, -0.13272268f, 0.30858690f, 0.06881106f, 
    0.15660669f, -0.14755423f, 0.04035893f, 0.06533828f, 0.03102659f, 0.02355674f, 0.06344531f, 0.04386627f, 
    0.00283842f, -0.02585893f, 0.10261820f, -0.02903223f, -0.01352416f, 0.07919611f, -0.07044882f, 0.00680644f, 
    -0.24070655f, 0.00048172f, -0.06379000f, -0.10069109f, 0.27752042f, 0.17117797f, 0.03874390f, 0.01992513f, 
    0.09626215f, 0.07368439f, -0.08465128f, 0.03508592f, 0.01764008f, -0.06992073f, -0.09003419f, 0.13986945f, 
    0.03228747f, 0.03029818f, 0.16376211f, 0.08298973f, 0.20161417f, 0.10557693f, -0.16282532f, -0.26528403f, 
    -0.01833062f, -0.06480680f, -0.01202453f, -0.12248988f, -0.03630473f, -0.11048886f, -0.00113776f, -0.00315567f, 
    -0.08202972f, -0.04839397f, -0.03297297f, 0.10513198f, -0.01037450f, -0.00672056f, -0.09571543f, -0.07134898f, 
    0.34465429f, 0.13802131f, -0.09043132f, 0.00447925f, 0.02474490f, 0.19016406f, 0.06075734f, 0.00463728f, 
    0.03714525f, 0.09895758f, -0.17786829f, -0.04882194f, 0.02694911f, 0.03872564f, 0.01504607f, -0.09127994f, 
    0.05573329f, -0.09346042f, 0.08114532f, 0.05431138f, 0.28111768f, -0.05140554f, -0.10672840f, -0.12068584f, 
    0.12335661f, 0.02318831f, 0.08857296f, 0.03438482f, -0.08025817f, 0.04726283f, -0.02598371f, -0.06292074f, 
    0.04266210f, -0.02057247f, 0.05096675f, -0.03064956f, 0.00910251f, -0.11728175f, 0.03700275f, -0.01320849f, 
    0.01602129f, -0.17614077f, -0.07333735f, -0.05554280f, 0.27006397f, -0.02608320f, 0.06562531f, -0.04983005f, 
    -0.00956950f, 0.00374615f, -0.02247383f, -0.06613693f, -0.06724358f, -0.03248861f, -0.06241984f, -0.08047612f, 
    -0.07107895f, 0.04000603f, -0.04306761f, 0.02864396f, 0.01914964f, -0.04996170f, 0.10747568f, 0.06319831f, 
    0.25496900f, -0.12890761f, 0.09759754f, 0.14712630f, 0.04392930f, 0.11959223f, 0.00077004f, 0.02110211f, 
    0.00766953f, 0.01942194f, 0.02756361f, -0.00530786f, 0.01493148f, 0.08360124f, -0.06596076f, 0.02909353f, 
    -0.37505299f, -0.02337614f, 0.24276292f, 0.17362377f, 0.10029405f, 0.03883123f, -0.08528488f, -0.03156403f, 
    0.02418566f, -0.41806725f, -0.00125555f, 0.07065382f, -0.00080419f, -0.00173330f, 0.00594944f, -0.01159451f, 
    -0.08868302f, 0.15598011f, -0.10423227f, 0.03072227f, -0.45701534f, 0.41933194f, -0.28076902f, -0.00539127f, 
    0.15130256f, 0.13044682f, -0.08030269f, -0.00563746f, 0.02346767f, -0.11209267f, -0.26164097f, 0.05000861f, 
    -0.09340595f, 0.01099874f, -0.02636356f, -0.07330109f, -0.11123081f, -0.01229879f, 0.00538164f, -0.01344185f, 
    0.10958187f, -0.08092608f, 0.10264881f, 0.12468013f, 0.22401005f, 0.09021895f, 0.02960266f, 0.03216843f, 
    0.19979645f, -0.02805619f, 0.06556655f, -0.04706682f, -0.23986764f, 0.07215743f, 0.06467328f, 0.10826652f, 
    -0.10456779f, 0.17791180f, -0.11621859f, -0.11827596f, 0.10705565f, 0.60551363f, 0.09413968f, -0.38165158f, 
    0.31745508f, -0.02279978f, -0.00018376f, -0.09755448f, 0.04743931f, -0.23760639f, -0.04136093f, 0.06762306f, 
    -0.18582717f, -0.01315551f, -0.02716451f, 0.00545811f, 0.03436398f, 0.00702105f, -0.01263733f, -0.20987532f, 
    -0.21801521f, -0.14404500f, 0.30318347f, 0.00759350f, 0.17666708f, -0.12660874f, 0.04086340f, -0.02785633f, 
    -0.02245332f, -0.05456240f, 0.06185250f, 0.01717101f, -0.09375408f, 0.02342714f, 0.07122077f, -0.04119149f, 
    -0.04924506f, -0.00312477f, -0.10388298f, -0.00313944f, -0.04292592f, -0.06819961f, -0.11697889f, -0.02883261f, 
    0.19328655f, 0.03541071f, 0.02692733f, -0.00360534f, 0.10624459f, -0.00625950f, 0.05767519f, -0.06786174f, 
    -0.03860989f, 0.06264605f, -0.08759766f, 0.06623744f, -0.19041526f, -0.06340657f, -0.04940034f, 0.11582953f, 
    -0.36762020f, -0.00863069f, -0.03135242f, -0.31039768f, -0.33587834f, -0.13343005f, -0.23564598f, 0.12166385f, 
    0.04673754f, -0.02990244f, 0.03507606f, -0.07651722f, 0.01629864f, 0.11554755f, 0.00403612f, 0.04286278f, 
    0.00108783f, -0.11924648f, -0.00596830f, -0.08889302f, -0.22827357f, -0.02887791f, -0.07964419f, -0.14331207f, 
    -0.16545498f, 0.05331919f, -0.00689429f, -0.00196059f, -0.14600514f, -0.02231083f, -0.06580736f, -0.00640091f, 
    0.03950406f, -0.12006792f, 0.03429763f, 0.04458212f, 0.06918982f, -0.11778305f, -0.05710468f, -0.01278432f, 
    -0.24640168f, -0.10391553f, -0.25577873f, -0.04448674f, -0.22688860f, 0.03672468f, -0.06590201f, -0.03219759f, 
    0.02366560f, -0.00777631f, -0.06113287f, -0.04150497f, 0.06735411f, -0.02249159f, -0.10677388f, 0.00281854f, 
    0.03470273f, 0.06797166f, 0.12649991f, -0.09963413f, -1.20320714f, 0.84711790f, -0.36924377f, 0.14242910f, 
    -0.23086746f, 0.27270651f, -0.08977139f, 0.19257851f, -0.05342393f, 0.02047451f, 0.06823012f, -0.13796230f, 
    -0.15166423f, -0.23168036f, -0.09413011f, 0.05115499f, -0.04254707f, -0.05245196f, -0.06702677f, -0.21143128f, 
    -0.05734791f, 0.05678863f, -0.23718865f, -0.15827006f, 0.29348052f, 0.17189352f, -0.00641208f, -0.05277827f, 
    0.06694439f, -0.25925741f, -0.07127859f, 0.04720892f, -0.06395160f, 0.09449858f, 0.02791531f, 0.05546815f, 
    0.04013987f, 0.12431883f, -0.00629749f, -0.12811695f, 0.69891149f, 0.24468955f, -0.00042811f, -0.46432808f, 
    -0.39754796f, 0.18439481f, 0.15803050f, 0.13379334f, 0.14074042f, -0.14938305f, 0.05016268f, 0.00352260f, 
    -0.01026867f, -0.10360473f, -0.10782668f, -0.06211782f, 0.04962536f, 0.14497839f, -0.08745601f, -0.10428431f, 
    -0.84635973f, 0.26894212f, 0.18251747f, -0.04688753f, 0.06961792f, -0.02239554f, -0.03806325f, 0.07683102f, 
    -0.11380671f, -0.14511549f, -0.21144848f, -0.03549017f, -0.18829829f, -0.05565310f, 0.06349969f, -0.05245342f, 
    -0.06641788f, 0.14023864f, -0.18410911f, -0.18247890f, 0.21241559f, 0.68041557f, 0.11582521f, 0.03037138f, 
    0.13859504f, 0.22230919f, 0.07851528f, -0.02348496f, -0.01850280f, 0.02951655f, -0.12994634f, -0.08691368f, 
    0.02920168f, 0.04927142f, 0.05232429f, 0.00853164f, -0.06166698f, -0.01149925f, -0.02480191f, -0.06341971f, 
    0.02832239f, -0.27173150f, 0.45863497f, -0.15808742f, 0.17545810f, -0.29896313f, 0.23357503f, -0.08729143f, 
    0.02306175f, -0.04814934f, 0.10769547f, -0.03285603f, 0.06482800f, -0.01064295f, -0.07635734f, -0.16461210f, 
    0.10252482f, 0.03042333f, -0.01264887f, -0.01658735f, 0.10079528f, -0.13801961f, 0.08372089f, -0.00785359f, 
    -0.15701002f, -0.05952755f, 0.01534686f, -0.01931774f, 0.05718128f, -0.00604554f, -0.00715673f, -0.03695691f, 
    0.06157881f, 0.01219363f, -0.02725980f, -0.08405805f, -0.07701238f, -0.09112927f, 0.00496825f, 0.02523782f, 
    0.34507117f, 0.25701877f, -0.02518742f, -0.28291270f, 0.13212234f, -0.00695242f, 0.03902687f, -0.14983325f, 
    -0.00799379f, 0.05927901f, -0.14189456f, 0.02240719f, -0.00974116f, 0.04243590f, 0.02665513f, 0.02057552f, 
    -0.02933313f, -0.06887668f, -0.01897641f, 0.00716108f, -0.15416515f, -0.17390020f, -0.41333240f, -0.12653196f, 
    -0.21571842f, 0.33162752f, 0.22211009f, 0.13454974f, 0.16310525f, 0.05278743f, -0.15087129f, -0.13110340f, 
    0.04800499f, -0.28149131f, -0.06693009f, -0.04596637f, 0.04138752f, -0.15477733f, -0.03913303f, 0.01695079f, 
    -0.54255044f, 0.14899071f, -0.14698888f, 0.21864825f, 0.36167249f, 0.05116501f, -0.14782365f, -0.02296665f, 
    -0.12439124f, -0.00160650f, 0.01967177f, 0.00367185f, -0.02809660f, -0.04783560f, -0.08217351f, 0.16866608f, 
    0.07675035f, 0.08951603f, 0.00694754f, -0.26112133f, 0.07826200f, -0.03246506f, -0.22218381f, 0.08008992f, 
    0.26861387f, 0.07209008f, 0.04218005f, -0.09737453f, -0.06057651f, -0.03515681f, -0.02774405f, 0.09903547f, 
    0.00194627f, 0.05927574f, 0.07295128f, -0.09699013f, -0.04268921f, 0.04508309f, 0.04634786f, 0.03141567f, 
    -0.43978921f, 0.02744904f, -0.08407277f, -0.07683092f, -0.45750579f, 0.02360175f, -0.11641266f, -0.07163671f, 
    -0.00472987f, -0.17990161f, -0.02547575f, -0.00879783f, -0.02061183f, -0.10146468f, -0.18273096f, -0.08806484f, 
    0.02066435f, -0.01083876f, 0.09916674f, -0.07278957f, -0.29528788f, 0.67958111f, 0.12483747f, -0.20082861f, 
    -0.22293951f, 0.07582340f, 0.04228136f, 0.01707145f, -0.10067236f, -0.01928016f, -0.03456768f, -0.09907102f, 
    0.04782900f, -0.13582753f, -0.03770728f, -0.02076854f, 0.00978746f, -0.00821324f, 0.06695844f, -0.01354166f, 
    -0.20763713f, 0.20261012f, -0.02906203f, -0.17029271f, 0.27593958f, 0.19737117f, 0.06707621f, -0.07742158f, 
    0.03623725f, -0.19394901f, -0.17176895f, 0.08153906f, 0.08369634f, 0.11619354f, 0.10153192f, -0.02563625f, 
    0.09000359f, 0.06322243f, 0.02839898f, -0.03603277f, 0.46088102f, 0.06771068f, 0.03691735f, -0.43311185f, 
    0.00817617f, -0.02058488f, -0.05477748f, 0.13512340f, 0.07759196f, -0.15317954f, 0.03850197f, -0.04389464f, 
    -0.15764977f, -0.09466992f, 0.07201859f, -0.01657624f, -0.03353367f, 0.09390979f, -0.00560560f, -0.02874197f, 
    0.48434514f, 0.15712190f, -0.03207708f, -0.42785963f, 0.19320099f, 0.02319914f, 0.01766260f, 0.00690354f, 
    -0.05450838f, 0.00841800f, 0.07838011f, -0.00959498f, 0.02614290f, -0.10112571f, 0.05864777f, -0.07303011f, 
    -0.07589192f, -0.10309613f, 0.11694369f, 0.06939279f, 0.00762237f, -0.09601068f, -0.08247399f, 0.06987070f, 
    0.08877178f, 0.12410226f, -0.01724271f, 0.05036855f, 0.07632113f, 0.05094691f, 0.07710161f, 0.01293211f, 
    -0.12606074f, -0.03390265f, 0.01774895f, 0.01336389f, -0.03362412f, 0.13575144f, -0.11457941f, -0.17459418f, 
    0.03290773f, -0.19809705f, -0.22402030f, 0.06637318f, 0.26931548f, 0.04656802f, 0.08422615f, 0.00975635f, 
    -0.04462389f, -0.02576481f, -0.02007398f, 0.12489749f, 0.02655314f, 0.06777339f, -0.01915279f, 0.01636303f, 
    0.01605709f, 0.09797109f, 0.02261680f, -0.05796098f, -0.13276553f, -0.30630973f, 0.18581779f, 0.09897885f, 
    0.22708203f, -0.15502249f, 0.07105768f, 0.10510992f, 0.11168468f, 0.04720742f, 0.08890913f, 0.01178343f, 
    -0.00797342f, -0.00635397f, 0.10083579f, -0.06808298f, 0.08695014f, 0.04916927f, 0.06532362f, -0.03324449f, 
    -0.21732585f, 0.02921932f, 0.05604726f, -0.24338506f, -0.06481463f, -0.07995556f, 0.04805770f, -0.03018942f, 
    0.00772392f, -0.02715063f, 0.00026656f, -0.08025298f, -0.18393400f, -0.10689943f, 0.03476264f, -0.13677600f, 
    -0.03252843f, 0.06267404f, -0.11301791f, -0.12235175f, -0.49200535f, -0.06189964f, 0.50010872f, -0.00677023f, 
    0.37788624f, -0.13694322f, 0.06007991f, -0.07857256f, -0.06364200f, 0.03240458f, 0.11978620f, 0.04097525f, 
    -0.02965508f, 0.01324475f, 0.09002016f, 0.02443957f, 0.07287788f, -0.00479983f, -0.05380093f, -0.00750719f, 
    0.48722813f, 0.05037594f, -0.01788653f, -0.06826885f, 0.14556943f, 0.10869612f, 0.06087289f, 0.01851638f, 
    -0.23417586f, -0.04427540f, -0.24296767f, -0.06674909f, 0.11952315f, 0.02322911f, -0.08155064f, -0.07765978f, 
    -0.03650289f, -0.10782832f, 0.07751489f, -0.02672044f, 0.03722880f, 0.12260938f, -0.12304536f, -0.28835928f, 
    -0.05522101f, -0.06806611f, -0.03933966f, -0.03247746f, -0.04717184f, -0.13535748f, 0.01796268f, 0.10497648f, 
    -0.01104005f, -0.12173124f, 0.12471948f, 0.08036289f, 0.01414304f, -0.10009670f, -0.16654646f, -0.11286940f, 
    -0.07366273f, 0.14962462f, -0.17600203f, 0.17948270f, 0.08404933f, 0.01464834f, -0.03421530f, 0.05865265f, 
    0.05099232f, 0.07628396f, 0.02614641f, 0.07499295f, 0.11823937f, -0.08647711f, -0.05201638f, 0.09091429f, 
    0.06865974f, -0.01609738f, 0.03079634f, -0.06243654f, 0.06037519f, -0.22075476f, 0.17899916f, 0.02037002f, 
    -0.17489906f, -0.11227634f, -0.03524147f, 0.03899393f, 0.00815986f, 0.04182886f, 0.03302180f, -0.03213965f, 
    0.13893661f, -0.04134811f, -0.06921580f, -0.02418143f, -0.09247350f, -0.09219334f, 0.09584078f, 0.06176988f, 
    -0.00031728f, -0.04512899f, -0.14749087f, -0.16063660f, -0.18389498f, -0.02953730f, -0.02093763f, 0.00439376f, 
    -0.04928941f, 0.00376261f, -0.04680783f, 0.06366160f, -0.13288398f, -0.13591900f, -0.00187780f, -0.01639905f, 
    -0.01366795f, 0.03706930f, -0.02598617f, 0.08307356f, -0.33479854f, 0.13848811f, -0.10386762f, 0.14299083f, 
    -0.04754620f, -0.14497541f, -0.01455654f, 0.08986155f, -0.01996988f, 0.05877189f, -0.07197101f, 0.04798102f, 
    0.01503507f, -0.07291080f, -0.06501770f, 0.06772925f, 0.06363462f, 0.06055741f, -0.02175898f, -0.07606589f, 
    -0.10863491f, 0.07703223f, -0.13214125f, 0.02600736f, 0.16767175f, -0.02826630f, -0.02950561f, -0.03623996f, 
    0.01746737f, 0.03637338f, 0.04330234f, 0.07398506f, 0.05353711f, 0.03835291f, 0.03973123f, 0.00093381f, 
    -0.02223459f, 0.09136494f, -0.04294328f, 0.04679387f, -0.12628822f, 0.06257028f, -0.02278467f, -0.01321793f, 
    0.23446174f, 0.09019752f, 0.02686734f, -0.08232792f, -0.05268056f, -0.07722303f, -0.11162039f, 0.02367446f, 
    0.06732315f, 0.06243218f, 0.08706937f, -0.01291924f, 0.01700376f, 0.00113278f, 0.06294455f, 0.01678820f, 
    -0.29246065f, 0.21670416f, -0.00200711f, -0.14252923f, 0.15560198f, 0.00995364f, 0.04470118f, -0.01585776f, 
    0.01171981f, -0.05438426f, -0.08653770f, -0.01976439f, -0.04007392f, 0.01480192f, 0.05462814f, 0.02728045f, 
    0.01926041f, -0.02130318f, 0.03365678f, 0.01642150f, 0.42374721f, 0.10156582f, -0.21143956f, 0.28692949f, 
    0.05193607f, 0.01539455f, 0.01312276f, 0.00831492f, 0.10872287f, -0.08745696f, -0.15485954f, -0.07149617f, 
    0.12642740f, 0.02013781f, 0.02559200f, 0.02709777f, 0.00399756f, -0.02255320f, 0.05863089f, 0.00304376f, 
    -0.00531941f, 0.05558383f, -0.04032550f, -0.17572144f, 0.11515597f, 0.01011819f, 0.10913990f, -0.10587798f, 
    0.09488060f, -0.02245499f, 0.02896674f, 0.00446367f, 0.01532807f, -0.03345272f, -0.01521064f, -0.12100246f, 
    -0.01040039f, 0.01042559f, 0.03515562f, 0.05879669f, -0.41226926f, -0.02727611f, 0.36691499f, -0.09492910f, 
    0.16311848f, -0.05400850f, 0.03258054f, -0.12197784f, -0.09002963f, -0.02553124f, 0.11929566f, -0.05607024f, 
    0.03180157f, -0.02940266f, -0.00026676f, 0.01227961f, -0.01832480f, 0.05661311f, -0.08453307f, -0.08352004f, 
    -0.05465780f, 0.12668745f, 0.03242155f, -0.16580124f, 0.25719494f, 0.16088431f, -0.00054130f, 0.02311056f, 
    0.08619397f, -0.00045431f, -0.03578050f, 0.03896351f, 0.09517065f, 0.11669365f, 0.06262290f, 0.00648063f, 
    0.14686134f, 0.13113874f, -0.03824785f, 0.00438294f, -0.00637488f, 0.05671968f, -0.23761843f, 0.08992760f, 
    0.26696157f, 0.03717303f, 0.04348635f, -0.00916868f, -0.03473024f, 0.06524814f, -0.04812591f, 0.06425078f, 
    -0.01046187f, 0.04264754f, 0.11120480f, -0.06579426f, -0.03119684f, 0.12056057f, 0.02259471f, 0.05536434f, 
    -0.02296403f, 0.14031062f, 0.43592590f, -0.29520273f, 0.01594576f, -0.21096312f, -0.04632615f, -0.11357633f, 
    -0.07507075f, -0.07437067f, 0.05431445f, 0.04928650f, 0.01261605f, -0.03315681f, 0.15713644f, -0.03848528f, 
    0.00508086f, -0.02934328f, -0.03281048f, -0.08301996f, -0.24842082f, -0.32085553f, -0.15289541f, -0.16496758f, 
    -0.05604762f, 0.05735406f, -0.05191750f, 0.04364237f, -0.03329318f, -0.01308200f, 0.07764775f, 0.00219602f, 
    -0.09481549f, -0.17327616f, -0.11561938f, 0.03687648f, 0.11413942f, 0.18939449f, -0.00548559f, -0.20672190f, 
    0.18715933f, 0.28007635f, 0.15350750f, -0.05913266f, 0.05811302f, 0.19071959f, 0.16265239f, -0.02646468f, 
    -0.10541239f, -0.03938142f, -0.13078879f, -0.04817392f, -0.00173408f, -0.10950677f, 0.03694425f, -0.15398891f, 
    -0.12299370f, 0.00354304f, 0.10733511f, -0.08535416f, 0.06891544f, -0.03243614f, -0.12354747f, 0.15485118f, 
    0.30100217f, -0.14642380f, 0.00836568f, -0.17222223f, 0.03484230f, -0.08965404f, 0.06736630f, 0.08509076f, 
    -0.04019098f, -0.08202635f, 0.05342388f, -0.14971393f, 0.03190324f, -0.06390280f, 0.01345018f, 0.02312478f, 
    0.00923076f, -0.08234885f, -0.26939183f, 0.06886494f, 0.20570503f, 0.08851355f, -0.00000411f, 0.12520549f, 
    0.10548226f, 0.14467786f, 0.00742595f, -0.06006751f, -0.01537328f, -0.02295539f, -0.04960068f, 0.00262469f, 
    -0.08934074f, 0.08955591f, -0.00972940f, -0.05450698f, -0.09623232f, 0.17523274f, -0.13276994f, -0.09737625f, 
    0.12110991f, 0.04528146f, 0.04705168f, 0.00652164f, -0.04060836f, 0.01074792f, -0.05819609f, -0.01197083f, 
    0.00360726f, 0.05529398f, 0.11747152f, -0.01246732f, 0.07445177f, 0.06203993f, 0.01529329f, 0.08491042f, 
    0.01831171f, -0.03751710f, 0.09272119f, 0.05093411f, 0.27046445f, 0.01812886f, 0.00356069f, -0.00026085f, 
    0.01402162f, -0.00799662f, 0.04314048f, -0.08288506f, -0.04593335f, -0.01320633f, -0.03403006f, -0.12349597f, 
    -0.05639149f, 0.04815122f, -0.02857330f, -0.00417551f, 0.36303523f, -0.04311128f, 0.03266573f, -0.18770164f, 
    -0.34537700f, 0.03173237f, 0.13827765f, 0.07209476f, 0.16062230f, -0.02288535f, 0.09577857f, -0.00718023f, 
    0.11202241f, -0.04384322f, -0.07813831f, 0.04115433f, 0.01863278f, 0.15576084f, -0.15232097f, -0.11207663f, 
    0.09278302f, 0.14139405f, 0.23356472f, 0.21025483f, 0.10296938f, -0.12816417f, -0.02646390f, -0.20916942f, 
    0.01570716f, 0.15585183f, 0.04629876f, 0.02833199f, 0.04386139f, 0.06214304f, 0.06441253f, 0.03145886f, 
    -0.02607353f, -0.11325507f, 0.08689968f, -0.06854542f, 0.00163285f, -0.00467561f, -0.04366612f, -0.04519716f, 
    -0.01051672f, 0.10579452f, 0.08261292f, 0.08196809f, -0.03679656f, -0.00745913f, 0.07579950f, 0.03801790f, 
    -0.00043012f, -0.06290012f, 0.07460052f, 0.06112157f, -0.07005422f, -0.03231566f, -0.04271434f, -0.01758373f, 
    -0.06522925f, 0.02410536f, 0.14791179f, 0.10884486f, 0.10205237f, -0.08822444f, 0.07219697f, -0.04333655f, 
    0.04064464f, 0.03516475f, 0.03075025f, 0.02659628f, -0.01929572f, 0.08412100f, 0.07832804f, 0.01371024f, 
    0.05795462f, -0.06047107f, 0.05866721f, 0.13483533f, -0.07099778f, -0.00430905f, 0.01647538f, 0.28558868f, 
    0.00667765f, -0.15348352f, -0.12013117f, -0.01778602f, -0.08077442f, -0.08018140f, -0.02929316f, -0.08060368f, 
    0.12301275f, -0.02998127f, 0.04686585f, 0.02869962f, -0.09723192f, -0.06583446f, -0.10006227f, -0.14041531f, 
    -0.10420798f, -0.01686579f, -0.15411450f, -0.22854237f, -0.14098985f, 0.11915257f, 0.00170244f, 0.06679340f, 
    -0.02483874f, 0.00947066f, 0.01990140f, -0.00924696f, 0.06647424f, 0.09162486f, -0.11311346f, 0.00233633f, 
    -0.00160786f, -0.07916630f, -0.09193125f, -0.01785520f, 0.22309126f, 0.06118872f, -0.11941327f, -0.04290750f, 
    0.10134389f, 0.02161231f, 0.00316286f, 0.03135731f, 0.05704560f, 0.06520908f, 0.02414084f, 0.00163501f, 
    0.00241676f, -0.01500026f, -0.02227549f, 0.03580969f, 0.01132718f, 0.01482838f, 0.00600167f, 0.11765503f, 
    0.16554920f, 0.06322531f, 0.09225316f, 0.16325881f, 0.06846684f, -0.04603215f, -0.04085622f, -0.04928921f, 
    -0.02672073f, -0.00008353f, 0.11606196f, -0.00521416f, -0.07861032f, 0.03344870f, 0.04099114f, 0.03456901f, 
    0.03737760f, 0.04107844f, -0.04309050f, -0.09228832f, -0.19658458f, -0.04767567f, 0.02434208f, 0.13357501f, 
    -0.07553045f, -0.09062468f, -0.06647776f, -0.01677427f, -0.08861162f, -0.00422471f, -0.03800480f, -0.13101374f, 
    0.04741658f, 0.01116528f, 0.05077944f, -0.00203742f, -0.09918702f, -0.09092876f, -0.07911917f, -0.10140877f, 
    -0.20398699f, -0.20199507f, 0.26467460f, -0.03759487f, -0.07264586f, -0.03538175f, 0.03971842f, -0.06734701f, 
    0.05389073f, 0.21613060f, -0.01844065f, 0.01573999f, 0.05117679f, -0.06114622f, 0.04961912f, -0.00323614f, 
    0.04403378f, 0.00680049f, -0.08202563f, 0.04886564f, 0.14434610f, 0.01565215f, -0.04768846f, 0.14384204f, 
    -0.11364648f, 0.03456866f, -0.12925154f, -0.02894662f, 0.00325701f, -0.02008474f, -0.04405876f, -0.00466740f, 
    -0.04143510f, 0.02011781f, -0.04958405f, -0.00959599f, 0.11066525f, 0.09820595f, -0.08220892f, 0.10093140f, 
    0.02303943f, 0.12116571f, 0.18733791f, 0.03984627f, -0.04918836f, -0.02986537f, -0.08681787f, 0.01234544f, 
    0.01570430f, 0.02074026f, -0.02052725f, -0.00052653f, -0.00583863f, 0.01584689f, -0.03740308f, -0.07358007f, 
    0.01060009f, -0.06000435f, -0.06359241f, -0.03198488f, 0.16488138f, 0.06457054f, 0.04949611f, 0.29315203f, 
    0.17314847f, 0.21812156f, 0.20958787f, 0.09994975f, 0.05172139f, 0.18201339f, 0.00915894f, -0.01055799f, 
    0.02365029f, -0.02551769f, 0.02300243f, 0.11097324f, 0.12056667f, 0.02010861f, 0.20669377f, 0.23376587f, 
    -0.00956519f, 0.02925945f, -0.06699789f, -0.11111902f, -0.05346274f, 0.10865711f, -0.00942152f, 0.08676213f, 
    -0.04478883f, 0.02458548f, 0.03359057f, 0.05918315f, 0.02867209f, -0.07912273f, -0.00246802f, 0.22469382f, 
    0.04012050f, -0.09659499f, -0.16928813f, -0.03719608f, 0.18084165f, -0.15516582f, 0.06650926f, 0.08989716f, 
    0.00779119f, -0.09751794f, -0.11249202f, -0.08499427f, -0.19625375f, 0.00073897f, -0.06718881f, -0.04445336f, 
    -0.01787279f, 0.00267114f, -0.00810317f, 0.02804804f, -0.02741699f, 0.08012933f, -0.07750949f, -0.00807232f, 
    0.01203561f, 0.12791692f, 0.02653923f, -0.01524101f, 0.07723008f, 0.15196472f, 0.05698951f, -0.01864524f, 
    0.01335538f, 0.14257987f, -0.07343759f, 0.08075505f, -0.00110561f, 0.01995685f, 0.04584351f, 0.04707702f, 
    -0.06929874f, -0.04517404f, -0.05706000f, -0.08057434f, -0.02865459f, -0.09236870f, -0.24063310f, 0.04031551f, 
    -0.21756533f, 0.00629524f, -0.02110523f, 0.08229048f, -0.10290645f, -0.05456323f, -0.11048104f, -0.00003875f, 
    -0.02854742f, 0.08236433f, 0.04348087f, -0.04124675f, -0.14317524f, -0.03102570f, 0.05435453f, -0.10889006f, 
    0.20737445f, 0.06475510f, -0.15502992f, 0.21410009f, 0.23181415f, 0.03349067f, 0.00258243f, 0.10339722f, 
    -0.00985757f, 0.03494021f, 0.00983518f, -0.01524331f, 0.01501911f, -0.01311097f, 0.03321321f, -0.06284574f, 
    -0.06373975f, 0.00063356f, -0.03081451f, -0.13161939f, 0.02820440f, 0.18926942f, 0.22533891f, 0.08558467f, 
    0.05511598f, 0.00800475f, -0.10976266f, 0.07791793f, -0.14983559f, 0.16765451f, 0.02521977f, -0.04637609f, 
    -0.00557331f, -0.01920351f, -0.03249542f, -0.01747741f, 0.01521644f, -0.10461381f, 0.03136481f, -0.20955209f, 
    0.05533578f, 0.08205620f, -0.02007546f, 0.13795026f, 0.17107968f, 0.06238626f, 0.03525589f, 0.04873993f, 
    0.04190014f, 0.04581222f, 0.08289356f, 0.11119556f, 0.04229734f, -0.02292180f, 0.08341831f, 0.07621926f, 
    -0.05210166f, -0.00201401f, -0.08622878f, 0.03673779f, 0.03467583f, 0.06206029f, -0.01175431f, -0.00707939f, 
    -0.01797776f, 0.04058698f, 0.02415400f, 0.05381301f, 0.02064568f, 0.04613094f, 0.07969989f, -0.05404799f, 
    -0.01223672f, -0.11633665f, 0.05335155f, 0.09605332f, -0.02259516f, -0.01734401f, -0.03677350f, -0.01866117f, 
    0.03672587f, -0.02216025f, 0.00185517f, -0.03720199f, -0.07514723f, 0.11621591f, 0.03973870f, 0.07594468f, 
    -0.01434730f, 0.03904408f, 0.05103296f, 0.02873612f, 0.04393354f, 0.00622159f, 0.05682125f, 0.06313127f, 
    0.09789571f, -0.05012183f, -0.06944374f, 0.02044979f, 0.08347131f, -0.27118009f, 0.02137294f, -0.14288647f, 
    -0.03296058f, 0.06425533f, 0.09676009f, -0.03404650f, 0.04858189f, -0.00792637f, -0.12412325f, 0.04697575f, 
    0.07092196f, 0.08330763f, 0.07943381f, -0.16493903f, -0.15538469f, -0.08382816f, -0.06821381f, -0.27844799f, 
    0.05853422f, -0.00342240f, 0.03817894f, 0.09344866f, 0.05180300f, -0.24941817f, -0.11608715f, 0.04045996f, 
    0.12743279f, -0.01892009f, 0.11940086f, -0.04671709f, -0.00197861f, 0.00407238f, 0.06053552f, -0.00270767f, 
    -0.01801110f, 0.00994325f, 0.00328632f, -0.06609883f, 0.30341583f, -0.46714064f, -0.20873681f, 0.04135065f, 
    -0.20524648f, 0.00467920f, -0.03283763f, 0.05277876f, 0.05121671f, 0.01182393f, -0.01552937f, 0.01538777f, 
    -0.15502836f, -0.05074500f, -0.19170606f, -0.04374165f, -0.02835046f, -0.14070183f, -0.01501837f, 0.02934307f, 
    0.26974037f, -0.23122022f, 0.08589468f, -0.18107191f, -0.00574565f, 0.02366671f, -0.02334793f, 0.11641955f, 
    -0.07435872f, -0.07681260f, 0.01938589f, 0.01920656f, -0.11979070f, 0.05743119f, -0.06016814f, 0.00393902f, 
    -0.27901137f, -0.07730601f, -0.09949574f, -0.02177822f, -0.25127640f, -0.14204164f, 0.08409562f, -0.05958013f, 
    -0.00562447f, -0.10162345f, 0.02605014f, -0.04988875f, 0.07271757f, 0.07425717f, 0.05022765f, -0.07548319f, 
    -0.09236972f, 0.08667681f, -0.07470104f, 0.02106864f, 0.06112419f, 0.05559216f, -0.03272643f, -0.06020523f, 
    0.08295736f, 0.14758688f, -0.12454765f, 0.22056513f, -0.30985194f, 0.19723241f, -0.05589922f, -0.10697503f, 
    0.06924298f, 0.06906283f, -0.01038101f, -0.00247075f, -0.07270708f, -0.01932841f, -0.04716939f, -0.04043447f, 
    -0.04740494f, -0.14612256f, -0.18846953f, -0.13594875f, -0.36450887f, 0.29870847f, -0.31832516f, -0.35050088f, 
    -0.29769507f, 0.09146982f, 0.03419530f, -0.01348301f, 0.07155041f, 0.05349765f, 0.03162627f, 0.03370420f, 
    0.02894424f, -0.00934161f, 0.03415572f, 0.07970174f, 0.01393916f, 0.12003037f, -0.13864456f, 0.14248019f, 
    -0.09248620f, -0.22974934f, -0.08179881f, 0.16301608f, -0.16809838f, -0.07197208f, 0.03806881f, 0.08011954f, 
    -0.27200618f, -0.02897259f, -0.04141555f, -0.06010796f, 0.02622784f, 0.03089775f, -0.04827236f, -0.04382234f, 
    0.06334252f, -0.02224888f, 0.06254765f, -0.01237889f, 0.08383684f, 0.10770926f, 0.06842840f, -0.01124698f, 
    -0.03657309f, 0.03176240f, 0.01384232f, 0.04889355f, 0.05828410f, 0.09909251f, -0.08136836f, -0.11651079f, 
    -0.07478113f, -0.04629528f, -0.09569717f, 0.09551249f, 0.04276234f, 0.01783522f, -0.00258563f, 0.05243581f, 
    0.21021307f, -0.28630096f, 0.26443797f, -0.12158744f, -0.00663974f, 0.00312804f, -0.00148937f, -0.02728864f, 
    -0.16185258f, -0.15131317f, -0.06256440f, -0.16227418f, 0.04554036f, 0.07284131f, -0.01549038f, -0.07133362f, 
    -0.03433580f, -0.10560437f, -0.05798853f, -0.15906097f, -0.04347511f, -0.12930550f, 0.23217803f, 0.09399610f, 
    0.03422374f, -0.09821053f, -0.04089950f, -0.07528096f, -0.01779678f, -0.10908728f, 0.00836277f, -0.02790062f, 
    0.04797896f, 0.01618649f, -0.01116947f, 0.03451121f, 0.10646912f, -0.01060757f, 0.03561322f, 0.04611880f, 
    -0.04928208f, -0.06141481f, -0.02956369f, -0.11386996f, -0.09120840f, 0.02001176f, -0.02959166f, -0.03633129f, 
    0.06873961f, -0.01189031f, 0.07825074f, -0.03576885f, -0.06628309f, -0.02640029f, 0.07499951f, 0.03241790f, 
    -0.06889480f, -0.02384465f, -0.06559098f, -0.01748253f, 0.00956268f, -0.37586883f, 0.04331390f, -0.01196537f, 
    -0.13956726f, 0.04985523f, 0.00840137f, 0.02599099f, -0.09773438f, 0.06716996f, -0.08907165f, 0.00279246f, 
    -0.06489965f, -0.07655116f, -0.09305608f, -0.10429958f, -0.07978112f, 0.02447113f, -0.13862145f, 0.06816804f, 
    0.08964106f, -0.10610431f, 0.15308474f, 0.21482292f, 0.05223176f, -0.17072423f, -0.05834433f, 0.05852383f, 
    -0.12912913f, 0.05812297f, 0.01983175f, 0.03514226f, -0.10779286f, 0.00247939f, 0.03431340f, -0.00405784f, 
    0.04197469f, -0.00029041f, -0.00186824f, -0.00323098f, 0.21481735f, -0.16818146f, -0.11856547f, 0.03784775f, 
    0.03416752f, 0.00190146f, -0.07110051f, -0.11662120f, 0.16627337f, -0.02132574f, -0.01538654f, -0.10906602f, 
    0.06001804f, -0.00826374f, 0.07891766f, -0.03840424f, 0.08182732f, -0.05306130f, -0.10730895f, -0.04803229f, 
    -0.01950493f, 0.10435545f, 0.00330650f, 0.29173762f, -0.04651241f, 0.09887508f, 0.09581341f, -0.11360090f, 
    -0.14802790f, -0.02865440f, 0.06776021f, -0.14359881f, 0.13231875f, 0.01479567f, 0.01464832f, -0.03078106f, 
    0.03944775f, -0.06067304f, -0.37868732f, -0.13173008f, -0.03478771f, -0.00558385f, 0.14262611f, 0.04189743f, 
    0.13155581f, -0.05075496f, 0.04532602f, 0.05338725f, 0.04791801f, 0.19858724f, -0.07040831f, 0.03091157f, 
    -0.06824454f, -0.04271646f, 0.01628714f, 0.01897544f, -0.05359938f, -0.07862917f, -0.09998944f, -0.20535353f, 
    0.10834383f, 0.09581169f, 0.14318539f, 0.11041342f, 0.11001419f, -0.11290477f, -0.10884792f, -0.18142243f, 
    0.02294154f, -0.04396803f, 0.08774148f, -0.00060688f, 0.01502807f, 0.04524957f, 0.08560930f, 0.07071894f, 
    -0.02549613f, -0.04589796f, -0.04775889f, -0.02570348f, 0.12358587f, 0.15121385f, -0.16843075f, 0.01017479f, 
    0.20528157f, -0.09908625f, 0.04129045f, 0.05046693f, 0.09436668f, 0.10707431f, 0.01639256f, 0.01310323f, 
    0.01612435f, -0.00892189f, 0.04485780f, 0.02765721f, 0.14377344f, 0.04027496f, 0.07179350f, 0.20246746f, 
    0.05957656f, -0.00446963f, -0.05183290f, -0.09759369f, -0.08560991f, 0.01918959f, -0.02932432f, 0.02182702f, 
    0.02370501f, 0.01365115f, 0.01238973f, 0.03954393f, -0.03906903f, -0.05025863f, -0.02445312f, 0.03441066f, 
    -0.14989141f, 0.03125687f, -0.05792041f, -0.10918719f, 0.04188002f, -0.02387987f, -0.05772467f, 0.13713551f, 
    0.16782457f, -0.02132252f, 0.05622780f, 0.12075508f, 0.00863211f, -0.00262326f, 0.06026198f, 0.00199237f, 
    -0.00110765f, -0.02688621f, 0.05559785f, -0.10420721f, -0.07482892f, -0.00842349f, -0.03805518f, -0.07338133f, 
    0.33808878f, -0.23075482f, -0.11022513f, 0.17640455f, -0.12323654f, 0.08578273f, -0.20048201f, 0.01198134f, 
    -0.00624256f, -0.08211827f, 0.04099960f, -0.02412329f, -0.06133798f, -0.06417568f, 0.11150499f, -0.04435853f, 
    0.00577042f, 0.04756175f, -0.21284966f, 0.04532864f, -0.18435232f, -0.12413266f, 0.01004636f, -0.17330383f, 
    0.05539588f, -0.16248123f, -0.05006041f, 0.00591104f, 0.10930912f, 0.00723079f, -0.03066114f, -0.12685263f, 
    -0.04754826f, -0.01841642f, 0.09312937f, -0.29389071f, -0.21465455f, -0.04168648f, 0.03334176f, -0.12680256f, 
    0.10806789f, -0.13615130f, 0.13614829f, -0.08037771f, -0.06912062f, 0.03276347f, -0.02458926f, 0.22789569f, 
    -0.20956172f, -0.06474528f, 0.00029805f, -0.05052015f, -0.00512378f, -0.03805283f, -0.06541188f, 0.00538906f, 
    0.00395350f, -0.01060764f, -0.09350973f, -0.31799391f, 0.07985067f, 0.16075890f, -0.12312388f, 0.05947673f, 
    -0.20066239f, 0.04540964f, 0.01765209f, 0.01876839f, 0.07683825f, 0.02984917f, 0.06272639f, -0.00198178f, 
    -0.04867475f, 0.03748141f, -0.00908399f, -0.01878247f, 0.07564619f, 0.02086619f, -0.13076483f, 0.04739613f, 
    0.00394495f, -0.10390134f, 0.03975594f, -0.11653578f, -0.03260070f, 0.01795271f, 0.04087269f, 0.03534043f, 
    0.03565630f, -0.03544980f, 0.10632226f, -0.04706350f, 0.11249177f, -0.10490447f, 0.02554495f, 0.05905655f, 
    -0.09473000f, -0.04271810f, -0.10671701f, -0.00836832f, -0.02229870f, 0.03378382f, 0.06236940f, -0.13565737f, 
    0.18066287f, -0.04141653f, 0.21791776f, 0.06127186f, 0.03148774f, -0.04496740f, -0.00620802f, 0.00065701f, 
    -0.01409088f, 0.00738293f, -0.01900099f, -0.02444625f, 0.20958570f, -0.00399187f, 0.04716511f, 0.13477655f, 
    -0.09738989f, 0.00613028f, 0.04223050f, 0.04389625f, 0.07477777f, -0.07691251f, 0.02359600f, -0.07373504f, 
    -0.14072531f, -0.08747125f, -0.02953149f, 0.00871412f, -0.02760189f, 0.01125003f, -0.01934901f, 0.08513050f, 
    0.12859629f, -0.07784696f, -0.02424163f, 0.09313747f, 0.12380696f, -0.01621652f, 0.16840538f, 0.14042009f, 
    0.05354315f, -0.16027282f, -0.02635109f, -0.09851792f, -0.10320393f, -0.02185133f, 0.00986813f, 0.02969997f, 
    0.01574130f, 0.04344300f, -0.00124777f, -0.01827178f, 0.01896085f, 0.01337049f, -0.00926279f, -0.01634416f, 
    -0.03167156f, -0.06773999f, 0.00922190f, 0.08211008f, 0.01354681f, -0.05454355f, -0.08123678f, -0.03386432f, 
    -0.14986853f, -0.01732110f, -0.13166338f, 0.07663994f, -0.01658118f, -0.07786157f, -0.15628922f, -0.10071550f, 
    -0.04359821f, 0.02576256f, -0.02311865f, 0.12000430f, -0.67476732f, 0.14160392f, -0.02956007f, -0.13704675f, 
    0.13164203f, 0.13384183f, 0.04996238f, -0.07758557f, 0.11042989f, 0.05088165f, -0.05766058f, 0.09359422f, 
    0.08281465f, 0.01044420f, -0.13342756f, -0.10771104f, -0.07716801f, 0.13212761f, -0.21557647f, 0.11396198f, 
    -0.15016015f, 0.00159989f, 0.04474643f, 0.23045123f, 0.02626375f, -0.16772626f, -0.13403054f, -0.03478611f, 
    -0.29404515f, -0.01735832f, 0.00336286f, 0.02315879f, -0.09103430f, 0.08571311f, -0.00637166f, 0.06302741f, 
    0.05427665f, -0.04021464f, -0.05447432f, 0.05196424f, 0.04869896f, -0.00852224f, -0.16378623f, -0.05169611f, 
    -0.01029092f, 0.00666544f, 0.03429478f, -0.00171397f, 0.04704567f, -0.05639070f, 0.04372422f, -0.00533348f, 
    -0.00953419f, -0.11003389f, 0.01645105f, -0.04215712f, -0.02510153f, 0.06508822f, -0.02315218f, -0.01483667f, 
    -0.13181508f, -0.00374555f, 0.05895603f, 0.18333213f, 0.05447599f, -0.06769244f, 0.12593105f, -0.04473817f, 
    -0.08558702f, -0.04372318f, -0.01133697f, 0.04008652f, -0.12159932f, -0.03090457f, -0.00551183f, -0.06548005f, 
    -0.00501197f, 0.03107022f, 0.02578939f, 0.07408899f, -0.06987756f, -0.09818911f, 0.16704985f, 0.10873185f, 
    0.10143584f, -0.09230667f, 0.05834565f, -0.06505831f, -0.09352568f, -0.12608457f, -0.00700703f, 0.02276408f, 
    0.01311926f, 0.02043780f, -0.03039905f, 0.01668139f, 0.13227704f, 0.05981151f, 0.03106500f, 0.09425023f, 
    0.01666284f, 0.02271482f, -0.06413827f, 0.08696040f, 0.10977649f, 0.05040702f, 0.10918049f, -0.04639225f, 
    0.00398186f, 0.00590624f, 0.06654233f, -0.03093543f, -0.00636197f, -0.00601152f, 0.05257612f, -0.09716073f, 
    -0.01153969f, -0.04368258f, -0.00737805f, 0.00242637f, 0.02156910f, 0.00356140f, -0.01144993f, 0.02853703f, 
    0.02794952f, 0.07860257f, 0.07766961f, 0.06374807f, -0.02581651f, 0.05809144f, 0.05483366f, 0.04959651f, 
    -0.00564219f, -0.01760195f, 0.05569651f, 0.06283110f, -0.03110731f, -0.12667176f, -0.04137444f, -0.03399554f, 
    0.19161238f, -0.19948664f, -0.11509357f, -0.05430193f, -0.15563856f, -0.02096733f, -0.18178515f, -0.02174690f, 
    -0.06562655f, -0.05380384f, 0.04232005f, -0.06958278f, -0.01257152f, 0.02335419f, -0.01255318f, 0.10417131f, 
    0.01534065f, 0.01249233f, -0.13473146f, -0.01237306f, -0.26324990f, -0.03597831f, 0.08498116f, -0.16668728f, 
    0.03466839f, -0.06182810f, 0.07332334f, -0.04417818f, -0.10489682f, -0.09043642f, -0.05006145f, -0.03623473f, 
    0.00168913f, 0.07773453f, -0.01729264f, -0.01121458f, 0.02035927f, 0.00301605f, -0.09498142f, -0.00005915f, 
    0.19453907f, 0.20314108f, 0.33010179f, 0.23118336f, 0.22985639f, -0.17763442f, 0.00523009f, 0.04266318f, 
    0.05787400f, 0.22595459f, 0.04002407f, 0.03255240f, -0.01813032f, 0.02658463f, 0.00824399f, -0.03563730f, 
    -0.05901785f, -0.06981371f, -0.04234239f, -0.24364334f, -0.15866521f, -0.08107126f, 0.01245334f, 0.05193647f, 
    0.08006964f, -0.07493269f, -0.02453549f, 0.04619111f, -0.27464378f, -0.01519703f, 0.00273638f, 0.03146050f, 
    -0.16169207f, -0.12456514f, -0.14556468f, -0.05521513f, -0.01159714f, 0.04579768f, -0.05182564f, 0.19430435f, 
    -0.00578441f, 0.19156422f, 0.22444966f, 0.17744501f, 0.15345830f, 0.02259562f, 0.01163366f, 0.11986668f, 
    -0.03267255f, 0.12367272f, 0.03230398f, -0.02531464f, 0.03105601f, -0.05609210f, -0.06622965f, -0.01513536f, 
    -0.01736452f, -0.06628948f, 0.03067105f, -0.09949727f, 0.24884525f, -0.26452950f, -0.21248358f, -0.14476028f, 
    -0.34893826f, 0.05630000f, 0.01719979f, 0.03394256f, 0.07987443f, 0.05144420f, 0.01560769f, -0.01365628f, 
    -0.07967432f, -0.02597931f, 0.06237617f, -0.09742240f, 0.15510657f, -0.02123002f, -0.01367166f, 0.22565430f, 
    -0.10479126f, -0.04945212f, 0.18534513f, -0.11246778f, -0.07452352f, 0.25488961f, 0.11395138f, 0.16873698f, 
    0.05613571f, -0.19342124f, 0.04698556f, -0.03042168f, 0.01628988f, 0.07078342f, 0.01882970f, 0.03366908f, 
    0.04362279f, -0.06749741f, 0.15307260f, 0.04373441f, 0.02815277f, -0.06367593f, -0.21321806f, 0.05715036f, 
    0.06351066f, 0.08420268f, -0.06714484f, -0.04793333f, 0.01891394f, 0.02162330f, -0.05689561f, -0.02388086f, 
    -0.00122433f, -0.00912116f, -0.10245274f, 0.09270286f, 0.02344333f, 0.08726402f, -0.07319929f, -0.04718138f, 
    0.12481147f, -0.08444547f, 0.20211105f, 0.15516719f, -0.19071318f, 0.12546974f, 0.02297550f, 0.03947908f, 
    0.00100465f, -0.04195538f, 0.04047053f, 0.01747443f, -0.01407605f, 0.07556561f, 0.02611773f, 0.00738826f, 
    0.06156320f, -0.12359688f, -0.13102233f, -0.21960026f, 0.34359458f, -0.18133056f, 0.22161189f, 0.21676663f, 
    -0.35700473f, -0.04398275f, 0.08136269f, 0.07996619f, -0.21367940f, 0.00838118f, 0.04786753f, -0.03073895f, 
    -0.00422675f, -0.01765966f, 0.15077166f, -0.06870835f, 0.03255867f, 0.08318979f, 0.18467788f, 0.11972766f, 
    0.35803029f, 0.01887361f, -0.25458398f, -0.47773585f, 0.22087622f, 0.01927225f, 0.07512510f, -0.03269822f, 
    -0.10518387f, -0.04246791f, 0.08413252f, -0.03590153f, -0.01145518f, -0.04499770f, 0.02308163f, 0.01437390f, 
    -0.05126838f, -0.12472305f, -0.02303672f, -0.12209819f, -0.21789433f, -0.06089403f, -0.04314964f, -0.12468710f, 
    0.00418938f, 0.04994539f, 0.04730429f, -0.01780646f, 0.00195807f, -0.00700513f, 0.01719934f, 0.04324291f, 
    -0.01213404f, 0.01209213f, -0.02120686f, -0.12766013f, 0.02020308f, -0.00514500f, 0.04931912f, -0.10447016f, 
    0.04025396f, -0.00788641f, -0.02991428f, -0.11518199f, -0.13892518f, 0.02848968f, -0.03222663f, -0.07069033f, 
    0.07226391f, 0.14815266f, 0.04432374f, 0.02674310f, -0.12585580f, -0.02720753f, -0.01149480f, -0.00101563f, 
    0.04695196f, 0.00346380f, 0.01345098f, 0.12656620f, 0.15580580f, -0.13569231f, 0.03746362f, 0.17727052f, 
    -0.17634025f, 0.13224906f, -0.00916387f, -0.10065701f, -0.03678420f, 0.04797315f, -0.03678505f, 0.00938923f, 
    -0.02912075f, 0.00759893f, 0.08549202f, -0.07343592f, 0.06956286f, 0.02115552f, 0.02388600f, 0.14278059f, 
    -0.30734867f, 0.38497522f, -0.35507125f, -0.31791201f, -0.16335119f, 0.01615634f, -0.15227845f, 0.07572080f, 
    -0.11095189f, -0.05163066f, -0.05086518f, 0.04502304f, -0.02051878f, 0.07303038f, -0.00901541f, -0.08899206f, 
    -0.07431737f, 0.22669241f, -0.08798765f, -0.04769117f, -0.34025830f, 0.52815360f, 0.13782853f, 0.13841774f, 
    0.03807202f, 0.04670598f, -0.06544611f, 0.15204640f, 0.14806974f, -0.13452318f, -0.02008522f, -0.00182812f, 
    0.02371487f, -0.02487619f, 0.00149460f, 0.08390601f, -0.06940827f, 0.17342383f, 0.03605608f, -0.20063412f, 
    0.14480419f, -0.02067856f, 0.15967838f, -0.18109840f, 0.09468461f, 0.03851239f, 0.04943540f, 0.11939102f, 
    -0.00726199f, 0.02010468f, 0.08653765f, 0.02889100f, 0.07327625f, -0.00164823f, 0.01611318f, 0.01188942f, 
    0.00174009f, -0.06110801f, 0.04781208f, 0.08652072f, -0.00551959f, 0.06556426f, 0.34176841f, 0.05517562f, 
    -0.09329438f, -0.11492728f, -0.03431313f, 0.00693507f, 0.06837001f, -0.06731811f, 0.05469105f, 0.03445752f, 
    -0.01029178f, -0.01562661f, -0.00355403f, 0.01655746f, 0.08986030f, -0.01950167f, -0.21050510f, -0.31192315f, 
    0.00199886f, -0.36236897f, -0.26234221f, -0.01444059f, 0.11466922f, 0.07318082f, 0.05373034f, -0.01493561f, 
    -0.06057665f, -0.01426598f, 0.05259978f, -0.05649066f, 0.10347584f, -0.06118571f, -0.01313489f, -0.01082231f, 
    0.03642198f, -0.06892035f, -0.02797952f, -0.09582907f, -0.32964009f, -0.18676735f, 0.08895257f, -0.22776902f, 
    -0.35436931f, -0.01582148f, 0.02762732f, -0.02869415f, -0.01870507f, -0.04810887f, 0.06005644f, 0.14758515f, 
    0.00201762f, -0.13200153f, 0.05960324f, -0.00870430f, 0.02668024f, 0.01056589f, 0.06340559f, 0.08531364f, 
    0.07924764f, -0.01895013f, 0.02492494f, 0.00500200f, -0.04657785f, -0.24383071f, 0.08912928f, -0.05501308f, 
    -0.00590975f, -0.06160463f, 0.04203988f, -0.10502969f, 0.10025030f, -0.05355905f, 0.04028875f, 0.07028488f, 
    0.06633080f, -0.01375058f, 0.01301159f, 0.14679465f, -0.10975468f, -0.28794926f, 0.28139612f, -0.00044786f, 
    -0.21512306f, -0.00165441f, -0.04328976f, -0.18325806f, 0.03451983f, 0.07388159f, 0.11409865f, -0.06684883f, 
    -0.07741515f, -0.10733657f, 0.09092245f, 0.14686613f, 0.01396107f, -0.03040357f, -0.02486814f, 0.04794746f, 
    -0.12888579f, 0.03798084f, -0.11894739f, -0.22640176f, 0.04655138f, 0.04089909f, -0.01475548f, -0.08481953f, 
    0.06030284f, -0.02187120f, 0.04568744f, 0.04118609f, -0.02795002f, -0.00538538f, -0.04390071f, 0.05014027f, 
    -0.04771576f, 0.03533050f, -0.00418827f, 0.03306357f, 0.04206266f, 0.18680491f, 0.17027532f, -0.31763807f, 
    0.22926976f, 0.13965371f, 0.00700566f, -0.05056759f, 0.01212897f, -0.00679303f, 0.11828980f, 0.06124192f, 
    0.05532101f, -0.04950713f, 0.03783451f, 0.03144271f, 0.00139012f, -0.04856989f, 0.11643895f, 0.10112583f, 
    -0.27814046f, -0.19731165f, -0.19265866f, 0.14396480f, 0.06573261f, 0.06340393f, 0.06022501f, 0.05041414f, 
    0.02052709f, 0.03604681f, 0.03535356f, -0.06116960f, 0.00785412f, 0.01958868f, -0.04290041f, -0.00433387f, 
    -0.10443792f, 0.15400746f, -0.02524914f, -0.13416854f, -0.01443294f, -0.00805150f, -0.09738541f, 0.06116630f, 
    0.05797599f, 0.00614054f, -0.05980918f, -0.02421918f, 0.04601795f, -0.05278501f, -0.07080782f, 0.04334627f, 
    0.01357366f, 0.01092336f, -0.04662895f, 0.07168470f, 0.07722868f, 0.11879431f, 0.03298053f, 0.00550527f, 
    -0.08900592f, -0.00576518f, -0.17222621f, -0.13090187f, 0.12552361f, 0.07064065f, -0.01058422f, -0.07830659f, 
    -0.04467047f, -0.05419609f, 0.14301744f, -0.01370694f, -0.08299528f, 0.09604423f, -0.03722879f, -0.06662793f, 
    0.00385847f, 0.00182543f, 0.00038342f, -0.00661473f, -0.05143996f, 0.06616363f, -0.35445917f, -0.38943934f, 
    0.09944360f, -0.26590666f, -0.11518651f, -0.09742296f, -0.16876410f, 0.21719325f, 0.08419905f, 0.16761902f, 
    -0.17731792f, -0.14535670f, 0.08591714f, -0.07965095f, -0.16985741f, 0.08348925f, 0.08668265f, 0.21131653f, 
    -0.01360338f, -0.18827710f, -0.01762079f, 0.04127849f, -0.12756582f, 0.13522433f, -0.08810793f, -0.16204467f, 
    0.08645071f, 0.20536475f, 0.15811124f, 0.01923221f, -0.02638506f, -0.06992538f, -0.08742557f, 0.02552223f, 
    0.06330711f, 0.04271137f, 0.05987581f, 0.09369053f, -0.32008496f, 0.18092823f, -0.11527861f, 0.13915546f, 
    0.08787695f, -0.05685513f, 0.04201080f, -0.04410755f, -0.04005525f, 0.04844896f, 0.01545076f, -0.21284372f, 
    0.13552342f, 0.07629714f, 0.11833717f, -0.02904521f, 0.00632200f, -0.05060708f, -0.10345300f, 0.03256132f, 
    0.12888050f, -0.13580300f, 0.21894597f, -0.02611241f, -0.03437194f, -0.15626441f, -0.06275048f, -0.09694298f, 
    -0.07663660f, 0.11604665f, 0.10117709f, -0.01139842f, 0.02491233f, -0.03371976f, 0.02366098f, 0.17166229f, 
    -0.07835522f, -0.09873714f, 0.16422525f, 0.09309703f, -0.39842033f, -0.29211637f, -0.32150221f, -0.23746483f, 
    0.04116493f, -0.00088343f, -0.05778198f, -0.00925458f, -0.02502669f, -0.04284319f, -0.09964095f, 0.15969378f, 
    0.09223694f, -0.03798353f, 0.10225031f, -0.07087699f, 0.02021189f, 0.13554060f, 0.00397486f, 0.03968040f, 
    0.03856092f, -0.00108879f, -0.04482944f, -0.06390223f, 0.07713836f, 0.24872819f, -0.05218061f, 0.10016094f, 
    -0.11639179f, 0.06530399f, 0.03188053f, -0.06319675f, -0.01341052f, 0.00979880f, 0.03285758f, 0.04894361f, 
    -0.10850929f, -0.00059152f, 0.02903312f, 0.02133534f, 0.13890116f, -0.10916772f, -0.25940830f, -0.00371424f, 
    0.22294699f, 0.03818450f, -0.00408242f, -0.07234671f, 0.00106454f, 0.01508032f, 0.08308295f, 0.00573696f, 
    0.03836758f, 0.02089501f, 0.04100591f, -0.18759032f, -0.01809531f, 0.04520421f, 0.00359782f, -0.11745206f, 
    -0.04856480f, 0.04652737f, 0.23981820f, 0.05155738f, -0.28020206f, 0.02622031f, -0.02937154f, 0.03155923f, 
    0.09112560f, 0.03840266f, 0.00473683f, 0.03134571f, -0.05450528f, -0.04138243f, 0.00821981f, -0.00694095f, 
    -0.01553714f, -0.02691057f, -0.14505801f, -0.04889260f, -0.04251046f, -0.01031387f, -0.12039033f, -0.08284362f, 
    0.05764651f, 0.02010164f, -0.01023464f, -0.02447514f, -0.06728794f, 0.03253408f, 0.16446835f, 0.07204080f, 
    -0.14105988f, 0.13172168f, 0.09807277f, -0.03418070f, 0.05520018f, 0.11109483f, 0.02355249f, -0.01351632f, 
    -0.07278387f, -0.12833628f, -0.01571144f, -0.32361576f, -0.07003165f, 0.00928266f, -0.00424262f, -0.02530571f, 
    -0.07079643f, 0.20843774f, -0.08382052f, 0.07201423f, -0.05715219f, 0.00015180f, -0.03771567f, 0.11387059f, 
    0.02922001f, 0.01633738f, 0.03889086f, 0.17152502f, -0.36030221f, -0.02653156f, 0.05181217f, -0.15879016f, 
    -0.09975316f, 0.07206874f, 0.01086033f, 0.04001106f, -0.12412827f, 0.18804684f, -0.02836841f, -0.00099102f, 
    -0.01480735f, 0.07347685f, 0.02941375f, 0.12598889f, -0.12620772f, -0.10296483f, -0.05919931f, 0.00810819f, 
    0.10501970f, -0.21346647f, -0.12234090f, 0.05832956f, 0.04952428f, 0.08610603f, -0.11801386f, -0.00537504f, 
    -0.00637332f, 0.03925237f, -0.03439864f, 0.07471789f, -0.03480490f, 0.10321378f, 0.04080690f, -0.02942801f, 
    0.05671228f, 0.00654577f, -0.01860562f, 0.01088843f, -0.19211444f, 0.06027153f, -0.18799239f, -0.11087547f, 
    -0.18163770f, 0.03022111f, -0.07755014f, -0.03375252f, 0.00148604f, 0.02992841f, 0.06490772f, 0.06826542f, 
    -0.22349882f, 0.08235383f, 0.14463912f, -0.01455898f, -0.00795553f, 0.00632420f, 0.09860148f, 0.16352294f, 
    -0.38336131f, -0.06231258f, -0.28037748f, -0.01957238f, -0.25825351f, 0.03372109f, 0.05544194f, -0.03464275f, 
    -0.06972441f, -0.08305397f, 0.03743963f, -0.01296721f, -0.01622508f, 0.00424783f, -0.06681333f, -0.05873084f, 
    -0.02656462f, 0.00904386f, -0.00928988f, 0.01230581f, -0.22068648f, 0.07350135f, 0.00945346f, 0.24487828f, 
    -0.02915016f, 0.01611860f, -0.12626213f, -0.12483411f, -0.08818265f, 0.32590762f, 0.02236066f, 0.05373725f, 
    0.00132472f, -0.04503557f, -0.08656586f, 0.00040432f, -0.21811159f, -0.02005986f, 0.01338927f, 0.09757190f, 
    -0.20716839f, 0.26647592f, -0.02460579f, 0.18005446f, -0.16643037f, 0.02641509f, -0.30701187f, 0.02275429f, 
    0.03611073f, 0.01389882f, -0.04949760f, 0.01407603f, -0.14373924f, -0.04522321f, 0.04269183f, 0.00830564f, 
    0.00571515f, 0.21291661f, -0.08911416f, 0.01114173f, 0.12263205f, -0.05278803f, 0.14741841f, -0.02810140f, 
    -0.08793287f, 0.02453803f, 0.07659657f, 0.04577615f, 0.09015545f, -0.07817473f, -0.02577553f, -0.03630852f, 
    0.05139666f, -0.05174855f, -0.01276053f, -0.03268622f, 0.09121256f, -0.00049921f, -0.02925680f, 0.32233423f, 
    -0.16306362f, 0.17007013f, 0.07637189f, -0.21404284f, -0.13019250f, -0.04031369f, 0.00780427f, 0.13381922f, 
    -0.02801497f, 0.16735433f, -0.01384481f, -0.03182243f, -0.05946470f, 0.00717350f, -0.05138586f, 0.01091103f, 
    0.00103186f, 0.02921603f, 0.00144935f, 0.06199237f, 0.14424944f, -0.10783906f, 0.13359135f, 0.11933176f, 
    0.05170427f, 0.13482732f, 0.06594434f, 0.01031151f, 0.01962701f, 0.02421635f, 0.04297394f, 0.07903437f, 
    0.05000089f, 0.00519978f, -0.02419239f, -0.26191062f, -0.07196542f, -0.07749717f, -0.05899991f, -0.14930668f, 
    0.04489019f, -0.09973720f, -0.01090817f, 0.04256052f, -0.03279960f, -0.12244913f, 0.01989378f, -0.06767485f, 
    -0.05077336f, -0.03717147f, 0.02308191f, -0.03829291f, 0.05143140f, -0.09569627f, 0.06957177f, 0.15742593f, 
    -0.03134555f, -0.03731225f, 0.03458542f, 0.15597567f, 0.15979464f, -0.09992328f, -0.22833669f, -0.01473183f, 
    0.08438850f, 0.00327731f, 0.10196526f, 0.08320538f, -0.02522576f, 0.00845229f, 0.00416712f, -0.00637608f, 
    -0.01110096f, -0.08287456f, 0.00079202f, 0.01754156f, 0.03443757f, 0.15389876f, -0.08739439f, 0.04112928f, 
    -0.60596049f, 0.71031034f, 0.07682841f, 0.02782460f, 0.00120823f, -0.12700509f, -0.05842894f, -0.01502549f, 
    0.27838269f, -0.02748972f, 0.04223778f, -0.05475727f, 0.06819465f, -0.05348860f, -0.05518967f, -0.02495315f, 
    0.00171357f, 0.14815795f, 0.17854176f, 0.05089748f, 0.14088376f, -0.39982298f, 0.06324138f, 0.15799500f, 
    -0.15937227f, 0.17081729f, 0.01878959f, -0.07930497f, 0.07852299f, 0.12521532f, -0.02234772f, 0.00586124f, 
    -0.04661913f, 0.08959640f, 0.09165915f, 0.11885892f, -0.08289612f, 0.02139734f, -0.09235864f, 0.30786085f, 
    0.07073897f, 0.02511462f, 0.12628794f, -0.23278925f, 0.05647764f, 0.09311098f, -0.01972521f, 0.00864327f, 
    0.02130101f, -0.03590029f, -0.01808403f, -0.08391036f, -0.01697020f, -0.01958699f, -0.05392237f, -0.02934950f, 
    0.03295980f, 0.04387826f, 0.07955541f, -0.06733844f, -0.13854100f, -0.06598320f, -0.12392007f, 0.08554274f, 
    0.07746792f, 0.09547030f, 0.03440719f, 0.03657947f, -0.01370052f, -0.01748415f, 0.02418464f, -0.02886067f, 
    -0.00744217f, 0.00575095f, 0.01525833f, -0.10332233f, 0.03668202f, 0.06767241f, -0.09520923f, -0.06443513f, 
    0.10608839f, -0.10648432f, -0.11132871f, 0.12274697f, -0.04166110f, 0.05962884f, -0.13568930f, -0.09710552f, 
    0.00194675f, 0.05210898f, -0.05729952f, -0.02220119f, 0.00794332f, 0.03390162f, -0.04473131f, -0.03439771f, 
    0.09360374f, -0.00099174f, -0.03424571f, -0.01207268f, 0.48985445f, -0.05968378f, 0.18338171f, 0.19466344f, 
    -0.18342908f, 0.13139473f, -0.16511311f, -0.10634243f, -0.05872984f, -0.05437361f, 0.09359371f, 0.03016752f, 
    0.05561161f, -0.03429726f, 0.06752778f, -0.12164173f, 0.06336948f, -0.28272167f, -0.11374795f, -0.23229301f, 
    -0.00737739f, 0.00186226f, 0.07383513f, 0.02491955f, -0.05653477f, -0.00884505f, -0.04801201f, 0.00984282f, 
    -0.00527182f, -0.11852389f, -0.01213450f, -0.00019644f, -0.00439458f, 0.00950913f, -0.00699773f, -0.06363736f, 
    -0.06904258f, -0.04711616f, -0.00918781f, -0.11405701f, -0.20888455f, 0.03391339f, -0.11063438f, -0.04837911f, 
    -0.16075054f, -0.00487754f, 0.01610937f, 0.01143616f, -0.07443065f, 0.11228111f, 0.01012288f, -0.00009993f, 
    -0.04075392f, -0.00221000f, -0.00359531f, -0.06413323f, -0.04862953f, 0.00487834f, 0.00330350f, 0.01326186f, 
    -0.09033410f, 0.03545918f, 0.05728914f, 0.06568944f, -0.15637067f, -0.00721155f, 0.07957372f, 0.11595810f, 
    -0.14553654f, -0.11257666f, 0.00992235f, -0.04578540f, -0.07145841f, 0.08494782f, 0.06369998f, -0.04268667f, 
    -0.02380899f, -0.06652401f, 0.09011321f, -0.05809509f, 0.39178389f, 0.34801853f, -0.27941966f, -0.21708351f, 
    0.18047918f, -0.04687883f, -0.09343616f, 0.09648105f, -0.10502249f, -0.06401546f, 0.15518667f, -0.04659819f, 
    -0.15080939f, -0.02542169f, 0.02694254f, -0.11242960f, -0.11191303f, 0.23723976f, 0.05910936f, -0.25360090f, 
    -0.03339320f, -0.04679112f, 0.16784717f, 0.20633510f, -0.25177765f, 0.00839186f, -0.02856580f, 0.24275535f, 
    0.02218051f, -0.09522289f, 0.02404408f, 0.00398192f, -0.00496863f, 0.03403397f, 0.05708661f, -0.10274335f, 
    -0.02525756f, -0.02853157f, -0.08346311f, -0.25035319f, 0.28699124f, -0.01005004f, -0.24333577f, 0.03109515f, 
    0.01263238f, -0.07375941f, 0.14712286f, -0.00242048f, -0.06704696f, 0.03743416f, -0.01156308f, 0.00534761f, 
    0.04044848f, -0.01556501f, -0.01899888f, 0.09531099f, -0.01767890f, 0.04433425f, 0.01681419f, 0.04938552f, 
    -0.00221113f, -0.11251388f, -0.00670632f, -0.03261443f, -0.06568219f, -0.12491682f, -0.00437074f, -0.02657200f, 
    -0.05054197f, -0.12462087f, 0.02386184f, -0.08967809f, 0.03346068f, 0.00594478f, 0.03596998f, -0.16291781f, 
    -0.15736429f, -0.09525885f, 0.11140242f, -0.08317394f, -0.32010931f, -0.05131552f, 0.04970774f, -0.17046399f, 
    -0.18220049f, 0.02566957f, -0.09727190f, -0.03496844f, -0.14711288f, 0.07395282f, -0.01482000f, 0.00009239f, 
    -0.01585634f, 0.02085558f, 0.02651835f, 0.06983369f, -0.05814751f, -0.09374168f, -0.11741785f, -0.07114278f, 
    -0.20732698f, -0.06904332f, -0.12293759f, 0.17022885f, -0.02703124f, 0.02752585f, -0.05492640f, 0.01021093f, 
    0.01392376f, 0.08950763f, -0.07341044f, 0.05372192f, -0.02071458f, -0.01797670f, -0.00600197f, 0.07211793f, 
    -0.04348379f, 0.24517448f, -0.11229876f, 0.00814145f, 0.03073911f, -0.06085458f, -0.09199398f, -0.02362141f, 
    0.05531881f, -0.00289063f, 0.03528013f, 0.01933018f, -0.06023072f, 0.00803866f, 0.04600186f, -0.10775400f, 
    -0.01211764f, -0.12353642f, 0.07366434f, 0.05311469f, 0.04334214f, 0.01396945f, -0.04879415f, 0.08601180f, 
    -0.36999631f, 0.11297250f, 0.05672448f, -0.17092180f, -0.09057049f, -0.09834900f, 0.04849351f, -0.05091455f, 
    0.02415357f, -0.00395373f, 0.13251279f, -0.01158646f, -0.08021663f, 0.08984450f, 0.00116240f, -0.01639319f, 
    -0.05205845f, -0.03383908f, 0.12632036f, 0.14123061f, 0.01689695f, -0.08079011f, 0.12723638f, -0.21280880f, 
    -0.05821546f, 0.19168434f, -0.02740381f, -0.16860308f, 0.09965882f, 0.06922878f, 0.04300296f, 0.01550525f, 
    0.01278319f, -0.03287313f, -0.04145265f, -0.00219898f, 0.05133558f, -0.05504033f, 0.14656524f, 0.13221905f, 
    0.12601277f, -0.02052783f, 0.20646378f, -0.04839984f, -0.11260903f, 0.17143224f, 0.07725752f, 0.00335936f, 
    0.04424847f, -0.17112580f, -0.00586765f, 0.00973564f, 0.02422621f, -0.01387274f, 0.02815238f, 0.03970031f, 
    0.07792324f, -0.01358478f, 0.03404628f, 0.12833878f, -0.02500447f, 0.00331059f, 0.13779305f, 0.09583372f, 
    -0.15690280f, -0.08326634f, -0.07839089f, 0.06972695f, -0.10773684f, -0.19845733f, -0.03005831f, -0.01716513f, 
    -0.10655150f, -0.05779152f, 0.16135167f, -0.20480612f, 0.00856436f, 0.00705581f, -0.09554046f, -0.23827340f, 
    0.30906844f, 0.16046108f, 0.15356708f, 0.07106617f, 0.05310230f, 0.01441268f, -0.00209925f, 0.21057767f, 
    0.01052268f, -0.05750997f, -0.00308242f, -0.00335610f, -0.00687638f, 0.01128950f, -0.01278755f, 0.07438920f, 
    0.00976791f, 0.03613476f, -0.00056734f, 0.06522434f, -0.04308710f, 0.06367928f, -0.13431288f, -0.18651631f, 
    0.07496334f, 0.03516528f, 0.05640877f, -0.04483357f, -0.02102735f, 0.04141805f, -0.03949518f, -0.03647843f, 
    -0.02983027f, 0.07410338f, -0.03658659f, -0.10884000f, -0.12020065f, -0.05007005f, 0.04232147f, -0.05805242f, 
    -0.68387097f, -0.47414461f, -0.41286823f, -0.26939082f, -0.44421712f, -0.24917816f, -0.21577244f, -0.21648492f, 
    -0.23126529f, -0.38797510f, -0.04131160f, -0.00231118f, -0.02107043f, 0.01322669f, 0.04881363f, -0.01163775f, 
    -0.04339290f, 0.01678166f, 0.05782980f, -0.06517334f, 0.13756187f, -0.00257244f, -0.08537174f, -0.06996101f, 
    0.00329325f, 0.00944102f, -0.00962504f, 0.05966405f, -0.00312509f, 0.01692761f, -0.01952246f, 0.01201336f, 
    -0.03828600f, -0.10279468f, -0.03065759f, -0.03582871f, -0.03160023f, -0.08120620f, -0.02007171f, -0.00294302f, 
    -0.43946531f, -0.28401691f, -0.43892875f, -0.30186465f, 0.07597595f, -0.13968915f, -0.01409467f, -0.08693121f, 
    -0.22231671f, -0.25517973f, -0.01214159f, -0.03469977f, -0.00765649f, -0.04220751f, -0.00609121f, -0.05913834f, 
    -0.04298959f, -0.01425623f, 0.19555753f, 0.07710433f, -0.51966572f, -0.42900351f, -0.33341768f, 0.07121541f, 
    0.06922589f, -0.06359776f, 0.04724470f, -0.03933366f, -0.10633192f, 0.01728290f, -0.08022097f, -0.02194458f, 
    0.05483145f, -0.02543177f, 0.04079229f, -0.00412062f, 0.04378489f, -0.06561520f, 0.20567521f, -0.08522992f, 
    0.18146597f, 0.04160739f, 0.02120680f, -0.04422216f, -0.25312924f, 0.10401823f, 0.07823367f, 0.07223984f, 
    0.03509233f, -0.15614766f, 0.01482208f, 0.01562916f, -0.06448568f, -0.00046592f, 0.06864366f, -0.03373542f, 
    -0.00205680f, 0.07957149f, -0.19790822f, -0.04383906f, -0.26950246f, -0.34366044f, -0.11308475f, -0.02882831f, 
    -0.05082079f, 0.02760174f, 0.15281191f, 0.06885240f, -0.02291434f, -0.02974651f, 0.01547851f, -0.03670909f, 
    0.04665354f, 0.03042753f, -0.00961477f, 0.07501884f, 0.06900191f, -0.00712655f, -0.03409099f, 0.04291423f, 
    -0.31236148f, 0.32626337f, 0.29832777f, -0.09398036f, -0.03025257f, -0.08790570f, -0.08397916f, -0.15412915f, 
    -0.17318119f, 0.05098927f, -0.06968075f, 0.01738293f, -0.05612035f, 0.00898839f, 0.02620680f, -0.01155466f, 
    -0.05263981f, -0.02674956f, -0.04249384f, -0.04313915f, -0.14336480f, -0.04649666f, -0.13648260f, 0.04603106f, 
    0.17437781f, -0.09607944f, 0.08460454f, -0.07679644f, 0.03796586f, 0.08099549f, -0.03435749f, 0.01503253f, 
    0.02719773f, -0.01954575f, 0.02866240f, 0.02894275f, -0.03913925f, -0.04711538f, 0.15169954f, -0.18734163f, 
    -0.21675861f, -0.00301216f, 0.35791993f, 0.17787090f, 0.37496626f, -0.02957340f, -0.08319830f, 0.01560322f, 
    0.05004933f, 0.11989237f, 0.03686645f, 0.14695875f, 0.12908790f, 0.08088734f, -0.02886008f, 0.00235882f, 
    0.01710550f, 0.05353718f, -0.01151691f, 0.00439689f, -0.49556026f, -0.09242972f, -0.00548218f, 0.11676512f, 
    0.13371079f, -0.07927417f, 0.06584602f, 0.00668849f, 0.13328350f, -0.07569733f, 0.03571063f, 0.05062517f, 
    0.04162568f, 0.02027717f, 0.14352261f, 0.03737874f, 0.02907977f, 0.09196065f, 0.08481637f, -0.00672773f, 
    -0.39345163f, -0.43581089f, -0.24487251f, 0.12067371f, -0.01866855f, 0.01521741f, -0.13226411f, -0.10178488f, 
    0.03019979f, -0.20349312f, 0.07053833f, -0.05702645f, -0.01240910f, 0.00437107f, 0.02710857f, 0.00985662f, 
    0.02484526f, 0.05567037f, 0.01883247f, 0.12228702f, -0.48145682f, -0.32290778f, -0.64566112f, -0.10493328f, 
    0.08921582f, -0.04261784f, 0.11586355f, 0.04261119f, -0.04517138f, -0.19344160f, 0.02531734f, -0.00382953f, 
    0.00562553f, 0.00957205f, 0.03764278f, -0.04180781f, -0.05427391f, 0.08136910f, 0.15676473f, 0.05215319f, 
    0.20946199f, 0.18220758f, -0.24478509f, -0.33158919f, 0.02066993f, -0.00976895f, -0.06120775f, 0.05250202f, 
    -0.03595429f, -0.03664165f, -0.00312028f, -0.00128333f, 0.01926914f, -0.09360231f, -0.05297877f, 0.05373789f, 
    0.05475708f, -0.12243199f, -0.08066479f, 0.06072168f, -0.30782366f, -0.20032533f, 0.47095069f, 0.19974253f, 
    -0.10209762f, -0.00133646f, -0.10281058f, 0.03196141f, -0.11980366f, 0.02819501f, -0.05299846f, 0.07932539f, 
    0.02067127f, 0.06255607f, -0.01495353f, 0.02801412f, 0.08689338f, -0.00417859f, -0.10015624f, 0.00517346f, 
    -0.02465953f, -0.22510093f, -0.02602102f, 0.02716662f, 0.08411916f, -0.11264683f, -0.01056583f, -0.05063999f, 
    0.01826720f, -0.12286530f, 0.12027904f, -0.06820564f, -0.15004818f, 0.03862629f, 0.02678261f, -0.00664911f, 
    -0.05366688f, -0.02583618f, 0.05098864f, -0.17398016f, -0.32502678f, -0.14182895f, 0.03596878f, 0.21602020f, 
    -0.00504453f, -0.05722576f, 0.13673335f, 0.00852225f, -0.02991311f, 0.10162313f, 0.19899267f, 0.06970847f, 
    0.03360090f, 0.03302487f, -0.04101240f, 0.03520742f, 0.02950617f, -0.04793506f, 0.09630564f, 0.04773452f, 
    0.00141041f, -0.33969069f, -0.23331970f, -0.05848814f, 0.01436066f, -0.01269780f, 0.13593002f, 0.10258862f, 
    -0.03642515f, -0.01020696f, 0.02896906f, -0.00557681f, -0.01112543f, -0.00071970f, 0.01602145f, -0.02513628f, 
    0.08024466f, 0.02332442f, 0.08275329f, 0.10215778f, -0.32220024f, -0.65154052f, -0.21073021f, 0.16463369f, 
    -0.36269715f, 0.06022316f, 0.06652182f, -0.02923268f, -0.00990830f, -0.26128381f, 0.04495966f, -0.08794945f, 
    0.01458356f, -0.04270004f, 0.05013464f, 0.02781910f, 0.01105271f, 0.08908395f, 0.00345873f, 0.08821148f, 
    -0.00330010f, -0.19942918f, 0.02510321f, -0.04097134f, -0.06364793f, 0.01065974f, 0.07476856f, 0.10054646f, 
    -0.10026170f, -0.05258857f, -0.07504883f, -0.08211524f, -0.04711931f, -0.01282194f, -0.01276087f, -0.05527395f, 
    -0.00368043f, -0.02489438f, 0.00467397f, 0.03117675f, 0.02263484f, 0.00677663f, 0.06142505f, -0.05422996f, 
    0.00682903f, -0.03107624f, -0.05211709f, 0.01459817f, -0.00054724f, 0.00320549f, -0.02681348f, 0.08912519f, 
    -0.06615575f, -0.02451945f, 0.00170085f, -0.02808066f, -0.08203907f, -0.07298689f, -0.07706449f, -0.05291431f, 
    0.00786518f, -0.09040000f, 0.00756597f, 0.00404003f, -0.09995558f, 0.02064056f, -0.01440583f, 0.01901499f, 
    -0.02497366f, 0.01267657f, -0.08964113f, -0.05294482f, -0.07811697f, -0.00633208f, -0.11764235f, 0.02416636f, 
    -0.02013298f, 0.06215617f, -0.11321534f, -0.01864350f, -0.21265888f, 0.09473383f, -0.05000461f, 0.17202754f, 
    0.08327023f, -0.00965638f, -0.03564436f, 0.00069563f, 0.08145510f, -0.02718228f, 0.10715394f, 0.02658727f, 
    -0.05910519f, 0.11285988f, 0.06279805f, 0.14597012f, 0.05026109f, 0.04312213f, -0.18470605f, 0.02320812f, 
    -0.33665529f, 0.43124372f, 0.07985153f, -0.04535899f, 0.00365665f, -0.09602099f, -0.02246889f, -0.07476965f, 
    -0.10807305f, 0.16982625f, -0.07165281f, 0.09530601f, 0.02559886f, 0.10583530f, 0.02149651f, 0.02899268f, 
    -0.02041427f, -0.03451046f, 0.08420014f, 0.02181476f, -0.04203863f, 0.35763559f, 0.03711701f, 0.23662470f, 
    -0.00993906f, 0.07413977f, -0.00951333f, -0.13977186f, 0.01477780f, 0.12782723f, -0.03479578f, 0.01490654f, 
    0.22246274f, -0.03982614f, -0.06956653f, -0.00688533f, 0.03532562f, -0.12198979f, 0.06814451f, -0.11344679f, 
    -0.05976603f, -0.03179051f, 0.08232503f, 0.09824614f, 0.06295814f, 0.01204939f, 0.19634338f, 0.03214325f, 
    0.19657096f, -0.01309927f, 0.10429028f, -0.05266451f, 0.01180568f, 0.06325502f, 0.04529940f, 0.05042022f, 
    -0.01627645f, -0.01359476f, 0.03864593f, 0.02275700f, -0.21264535f, 0.32209495f, 0.09218594f, -0.02490241f, 
    0.24917230f, -0.05716829f, -0.02123907f, -0.07202955f, 0.02475266f, 0.02304986f, 0.04174754f, 0.04146257f, 
    0.10770867f, 0.00830265f, -0.04641255f, 0.01317045f, 0.00434683f, 0.00217200f, -0.01232726f, 0.02964884f, 
    0.03190272f, -0.07454462f, -0.00972271f, -0.01433633f, 0.06106094f, 0.06788165f, 0.03484667f, 0.07737212f, 
    0.08944921f, 0.07022091f, -0.01505767f, 0.06351496f, 0.05283382f, -0.04314261f, -0.00466283f, 0.00166126f, 
    0.13605578f, -0.04363279f, -0.05878833f, 0.10823218f, -0.08180582f, 0.05945756f, -0.02483279f, -0.19194227f, 
    -0.01065505f, -0.02348057f, 0.03321467f, 0.02614031f, -0.00023436f, 0.02975496f, 0.00663633f, -0.01564216f, 
    0.00449918f, -0.04986842f, -0.08152547f, 0.03273942f, 0.09498581f, -0.05004610f, 0.02389534f, 0.12974454f, 
    -0.04554212f, -0.10584799f, -0.53257596f, -0.07690180f, 0.21278046f, -0.00755161f, 0.09720474f, 0.05650201f, 
    -0.06971669f, 0.11021817f, -0.04326656f, 0.01003462f, 0.05479164f, 0.04767006f, 0.01040022f, -0.00104421f, 
    -0.03245516f, -0.08134880f, 0.12964356f, 0.02116782f, -0.11876372f, -0.04251450f, 0.10470361f, -0.04056933f, 
    0.00074482f, -0.05558782f, -0.07127868f, -0.03589025f, -0.06118956f, 0.00187051f, -0.03092569f, -0.04207597f, 
    0.01962667f, 0.06220567f, 0.01444956f, 0.00184083f, 0.00402014f, -0.06700228f, -0.08853564f, -0.00932380f, 
    -0.19625485f, 0.50209242f, -0.13232805f, 0.01839997f, 0.17917413f, 0.00237835f, -0.00374731f, -0.23322746f, 
    0.11360928f, -0.04225123f, 0.12015463f, 0.02833054f, -0.11181930f, 0.08182831f, 0.11570957f, 0.07518064f, 
    -0.01604710f, 0.09210521f, -0.10529824f, -0.01422606f, -0.36771181f, -0.36977333f, -0.30829674f, -0.18761131f, 
    -0.16244306f, 0.07778805f, -0.24990346f, -0.07961445f, -0.03577673f, -0.05841317f, -0.00230924f, 0.05529207f, 
    -0.00454048f, 0.05735314f, -0.01351349f, -0.06441174f, -0.00305535f, 0.11068601f, -0.03785910f, -0.00391681f, 
    0.08753838f, 0.06203087f, -0.08203299f, -0.06869383f, -0.00687511f, -0.00673075f, -0.04285422f, 0.06175737f, 
    -0.01490364f, 0.09019195f, 0.03629028f, -0.04282553f, -0.01306760f, -0.00411817f, -0.04055854f, -0.07775242f, 
    0.04804832f, -0.05931563f, -0.06073654f, 0.07822790f, 0.04369799f, -0.01179354f, 0.03582041f, 0.01601236f, 
    -0.04593104f, 0.03746073f, 0.05318950f, -0.06288100f, -0.02522971f, 0.04447886f, 0.01365879f, -0.05285748f, 
    0.07178718f, 0.10826978f, -0.14385612f, 0.04768451f, 0.13569783f, -0.00839526f, 0.03137754f, 0.01433755f, 
    -0.45818534f, 0.02344725f, 0.31679267f, -0.16703822f, 0.28557441f, -0.11949289f, -0.09637438f, -0.05719320f, 
    -0.09874775f, 0.21076065f, -0.09249772f, 0.01904150f, 0.06436752f, 0.00503461f, 0.04466590f, 0.03927878f, 
    0.01974081f, -0.02932784f, 0.05775294f, 0.04154895f, -0.02066790f, 0.19951108f, -0.56154048f, -0.33692813f, 
    0.19046061f, -0.12418364f, 0.03158818f, 0.09271957f, 0.14642224f, 0.08835933f, -0.01520833f, -0.00213056f, 
    0.09301528f, -0.02231537f, 0.00007483f, 0.06840258f, 0.06272101f, -0.19866884f, 0.13927080f, -0.02688641f, 
    -0.22981586f, -0.25343165f, -0.08025920f, -0.14153592f, 0.18209939f, -0.16617025f, -0.01447293f, 0.12865537f, 
    -0.01871905f, 0.01374696f, 0.05803997f, 0.02831506f, 0.07367886f, -0.13252102f, 0.04881713f, 0.01072238f, 
    0.01427272f, -0.00660230f, 0.09450738f, -0.17943768f, 0.08964996f, -0.22899774f, -0.32989019f, -0.00278369f, 
    0.15579844f, -0.04866549f, 0.03019145f, -0.00114044f, 0.09119703f, -0.23902659f, 0.01068395f, 0.01161583f, 
    -0.13526191f, 0.01611911f, 0.05370125f, -0.01549868f, 0.02251823f, 0.09430613f, 0.06819647f, -0.03403181f, 
    -0.73075819f, 0.38090467f, 0.48399287f, -0.13624823f, -0.09498816f, -0.07303315f, -0.03232821f, -0.06357946f, 
    -0.00910291f, -0.00449553f, -0.00409775f, 0.06843558f, -0.04005911f, 0.02400777f, 0.03962571f, -0.00149759f, 
    -0.00668921f, 0.05661171f, 0.01514342f, -0.03076861f, -0.39070797f, -0.13509990f, -0.33395126f, -0.27673507f, 
    -0.13425784f, -0.00519174f, 0.13747863f, 0.11782102f, 0.01103319f, -0.01303046f, -0.00216720f, -0.02118122f, 
    0.01952101f, -0.00956538f, 0.03527388f, -0.04172239f, -0.03219046f, 0.04630300f, 0.06110220f, -0.00684245f, 
    0.02318021f, 0.00591961f, -0.02132488f, -0.02107847f, 0.02215150f, 0.01065258f, -0.00038084f, -0.00950091f, 
    0.00035897f, -0.03376421f, 0.05644046f, -0.07971954f, -0.04143491f, 0.10319839f, 0.01061232f, -0.09659787f, 
    0.06717096f, 0.03680196f, -0.08213322f, 0.00128597f, 0.18994349f, -0.17178746f, -0.22970136f, -0.06189497f, 
    0.10698336f, -0.07665509f, 0.07385662f, 0.24256991f, 0.09074388f, -0.09181163f, 0.00526207f, -0.03403411f, 
    -0.05839940f, -0.00554280f, 0.03180703f, -0.04207200f, -0.02488273f, 0.02629838f, 0.00126674f, 0.02637926f, 
    -0.53410703f, -0.08305828f, 0.26577750f, -0.23604441f, 0.19236280f, -0.03580134f, 0.09303871f, 0.06164991f, 
    0.02604575f, 0.01798165f, 0.12771916f, 0.10879412f, 0.02139645f, 0.03099388f, 0.08368814f, 0.02203831f, 
    -0.00829190f, 0.06119697f, -0.02514555f, -0.05950012f, 0.04005703f, 0.01038101f, -0.18791902f, 0.04602555f, 
    0.16274004f, 0.02409739f, 0.10804456f, 0.05995978f, 0.14191480f, 0.00359622f, -0.06648050f, -0.06378257f, 
    -0.05014037f, 0.04908051f, 0.04698206f, -0.00422432f, 0.08108025f, -0.07799885f, 0.08429009f, 0.03344069f, 
    0.11079992f, 0.14124152f, 0.12310970f, 0.12377460f, -0.07652590f, 0.02314482f, 0.17495324f, -0.06065679f, 
    -0.11026925f, -0.19150497f, 0.04205378f, -0.02159904f, -0.09845760f, -0.03742830f, 0.03859556f, 0.02279993f, 
    0.00003239f, 0.07446648f, -0.06537656f, -0.24626583f, -0.04585920f, 0.02713678f, -0.09367471f, -0.11384250f, 
    -0.04391939f, -0.01236800f, 0.02223726f, 0.03147236f, -0.01424007f, 0.01662985f, -0.00384969f, -0.04486145f, 
    0.00846911f, -0.01341008f, -0.00765250f, 0.03097497f, 0.04684461f, -0.04394400f, 0.01944126f, 0.09373459f, 
    0.07206388f, 0.16031316f, -0.03298964f, -0.02068217f, 0.01739302f, -0.07431925f, -0.09760579f, -0.03785749f, 
    0.02490262f, 0.09340879f, 0.14666490f, 0.04018204f, 0.03085675f, -0.05520694f, -0.00387436f, -0.03688801f, 
    0.00737419f, -0.09196078f, 0.08331058f, -0.01337315f, -0.25220042f, -0.30197558f, -0.36417183f, -0.03048731f, 
    0.02258178f, -0.09108251f, 0.03788961f, 0.01818557f, -0.06086241f, -0.11172854f, 0.06161053f, -0.02794836f, 
    -0.03825718f, 0.05132091f, 0.06714555f, -0.00924511f, 0.08561555f, 0.23263557f, 0.11997993f, 0.05894434f, 
    -0.22623868f, -0.39506257f, -0.28925425f, 0.05413282f, 0.13475598f, -0.01978065f, -0.02221018f, -0.05601527f, 
    -0.02783040f, -0.06371740f, 0.00626108f, 0.02999888f, 0.02046304f, -0.08394527f, -0.10905214f, -0.05165945f, 
    -0.02999225f, 0.05856525f, 0.06822015f, -0.05368101f, -0.43031886f, 0.28966346f, 0.42638448f, -0.12191026f, 
    0.34410688f, -0.08123588f, -0.09123451f, 0.02352468f, -0.00534195f, 0.05974048f, 0.00107723f, 0.05422631f, 
    0.04970845f, 0.03764759f, 0.00794258f, 0.02679122f, 0.02618699f, 0.00272887f, -0.00113994f, 0.02586103f, 
    0.00617744f, -0.03587060f, 0.15577866f, 0.02059717f, 0.07958847f, 0.08641828f, 0.00117789f, -0.05987264f, 
    -0.06263389f, 0.05413831f, -0.04430720f, 0.01756105f, 0.08816649f, -0.01070519f, -0.13725077f, 0.03818328f, 
    0.07712152f, -0.01498859f, 0.07065851f, 0.00079696f, -0.55383319f, -0.02380436f, 0.31422740f, 0.04834649f, 
    0.27415875f, -0.01550842f, 0.13196617f, -0.06635612f, 0.20375563f, -0.09935846f, 0.12412819f, 0.09365308f, 
    0.11659646f, 0.01814740f, -0.03347399f, -0.01258211f, -0.01009128f, 0.03405842f, 0.06285533f, 0.00282934f, 
    -0.59088546f, -0.43855822f, -0.56926322f, -0.13809143f, 0.11630066f, -0.10203847f, -0.03220033f, 0.05856074f, 
    -0.29924691f, -0.11317658f, -0.03490407f, -0.01139531f, 0.01393924f, -0.15861149f, -0.02626346f, -0.01038554f, 
    -0.00467414f, -0.10487460f, 0.17774220f, 0.00078578f, 0.10319123f, -0.00107678f, 0.01544848f, -0.10791634f, 
    0.06483162f, -0.06108829f, -0.03896833f, 0.04451994f, 0.07787013f, -0.01628126f, 0.00701858f, -0.03610158f, 
    -0.01882971f, -0.04588704f, -0.02732459f, -0.02253380f, -0.00344106f, -0.00022892f, -0.04740129f, 0.00747064f, 
    -0.16603327f, -0.29860279f, -0.17937474f, -0.04881280f, 0.25793919f, 0.00944327f, 0.00543785f, 0.05797879f, 
    0.07878160f, 0.06988025f, 0.01311794f, 0.03054575f, 0.08579370f, -0.03918663f, -0.04465204f, 0.03415534f, 
    0.11460999f, 0.08831070f, 0.05181545f, -0.00268823f, -0.19743595f, -0.39016810f, -0.58464152f, -0.23361012f, 
    0.04440571f, 0.04533657f, -0.19091639f, -0.08956786f, -0.03911681f, -0.03235087f, -0.03430367f, 0.04333085f, 
    -0.00386545f, 0.02518031f, -0.13802858f, -0.02458799f, -0.02049244f, 0.13871062f, -0.02173453f, -0.05023491f, 
    0.11987066f, -0.15697110f, -0.25507891f, -0.13282076f, 0.15511850f, -0.06065667f, 0.05272638f, 0.19785531f, 
    0.06337574f, -0.00484021f, -0.05408188f, -0.02820608f, -0.02068511f, -0.08725514f, -0.00421685f, 0.02081531f, 
    -0.00280382f, -0.07955118f, 0.08398677f, -0.00038015f, 0.09476609f, 0.04557132f, -0.08669227f, -0.08889601f, 
    0.03939517f, -0.04250606f, -0.08507036f, -0.01176182f, 0.01741084f, 0.01877632f, -0.12737148f, -0.00162505f, 
    -0.13065086f, -0.01801356f, 0.05481992f, 0.01799116f, -0.10142831f, -0.05075725f, -0.13969262f, -0.05418684f, 
    -0.23763742f, -0.09412123f, 0.34339875f, -0.02051216f, -0.03384232f, 0.01005045f, -0.13101874f, 0.04192779f, 
    -0.01336642f, 0.08700874f, 0.12414135f, 0.06165353f, 0.01711457f, 0.09245225f, 0.00052829f, 0.00577180f, 
    0.07117283f, 0.00192612f, -0.07788265f, 0.04705448f, -0.13026379f, 0.11853429f, -0.02629511f, -0.34427014f, 
    0.33013651f, -0.15196937f, 0.09065214f, -0.03045136f, 0.03220864f, -0.13212810f, 0.06693238f, 0.00402417f, 
    -0.00434986f, 0.01611345f, -0.03405829f, -0.01500749f, 0.07455941f, 0.03371626f, 0.10061388f, 0.00919127f, 
    -0.61983263f, -0.57369769f, -0.51422101f, -0.42615899f, 0.04170521f, -0.21651424f, -0.12450712f, -0.31353688f, 
    -0.17826770f, -0.48962215f, -0.02648484f, -0.04217147f, -0.06781153f, 0.00872547f, 0.04287658f, 0.00273589f, 
    -0.03551421f, 0.06372841f, 0.01973725f, -0.01989302f, 0.00242338f, -0.03540555f, -0.01365918f, 0.14218871f, 
    0.22920881f, -0.14238381f, -0.01389294f, -0.01770371f, -0.03640860f, 0.05286053f, 0.00724323f, 0.00073243f, 
    0.12153734f, 0.02999021f, -0.18606170f, 0.06957945f, 0.07434969f, 0.02842257f, 0.06034861f, -0.06629793f, 
    -0.06249114f, -0.51718271f, -0.66308850f, -0.04588700f, -0.00065190f, -0.00422267f, 0.12109061f, -0.02937720f, 
    0.04469398f, -0.30781955f, -0.00533631f, -0.01936059f, -0.03566711f, -0.01607033f, 0.07573256f, 0.01346223f, 
    -0.02268768f, 0.14283361f, 0.08878459f, -0.02498201f, -0.08358459f, 0.10896795f, 0.13936852f, -0.07144874f, 
    -0.01279855f, -0.04892012f, -0.01268055f, -0.02753351f, 0.00816058f, 0.01243952f, -0.06846997f, -0.04505843f, 
    0.01665124f, -0.04328736f, -0.03295453f, 0.02543226f, 0.04508857f, -0.03835719f, 0.03710170f, 0.00618846f, 
    0.27069625f, -0.28691977f, 0.03466812f, -0.11051092f, -0.06935959f, -0.10870017f, 0.16825461f, -0.05075107f, 
    0.24474548f, 0.16719863f, 0.04016409f, 0.03743063f, -0.01428224f, -0.05366664f, 0.00086475f, -0.03382991f, 
    0.00293129f, -0.10239214f, 0.06691071f, -0.08543628f, -0.04204141f, 0.05148949f, -0.00883671f, 0.00948933f, 
    -0.03601871f, 0.03377907f, -0.03426442f, 0.04315092f, 0.01271387f, -0.01996829f, 0.01753000f, 0.02016600f, 
    0.01066890f, 0.02091408f, 0.02483963f, 0.00929138f, -0.08099924f, 0.01988338f, 0.01252341f, -0.00889529f, 
    -0.13821408f, -0.20353246f, -0.05364474f, 0.23166767f, 0.02836250f, 0.08228604f, 0.07765031f, -0.03597628f, 
    0.11166650f, 0.11909702f, 0.04665923f, -0.02864663f, -0.04421408f, -0.05198582f, -0.08213720f, 0.02025301f, 
    0.04245381f, -0.01062827f, 0.07757036f, -0.03569311f, 0.05442210f, -0.62703001f, -0.07247002f, 0.38585335f, 
    0.10810738f, -0.00079488f, 0.07562571f, 0.04497229f, -0.02605165f, -0.10698959f, 0.04523728f, 0.09414139f, 
    0.07605824f, -0.05274493f, 0.03285005f, -0.00718024f, 0.05533381f, -0.01228835f, -0.15570076f, -0.00718294f, 
    -0.14889309f, 0.05535616f, 0.14414664f, -0.03489865f, 0.12726383f, -0.01584263f, -0.01012746f, 0.00341436f, 
    -0.02272163f, -0.00679217f, 0.06383952f, -0.03767192f, 0.06931948f, 0.00224873f, -0.04058229f, -0.09177425f, 
    -0.10658261f, -0.05568914f, -0.01793925f, -0.05496628f, 0.04279061f, 0.12566745f, 0.06041667f, -0.07564969f, 
    -0.03556654f, 0.03802769f, 0.02921009f, -0.06261453f, -0.02669637f, 0.02367236f, 0.01798231f, 0.01001763f, 
    0.04117387f, 0.00144783f, -0.03929422f, 0.06751622f, 0.04617860f, -0.02383636f, -0.05263454f, -0.07958146f, 
    0.23562132f, -0.18367088f, -0.05109456f, -0.16894214f, -0.00626488f, 0.09325761f, -0.02197304f, 0.02378814f, 
    -0.01368922f, -0.02027338f, 0.09386033f, 0.06955653f, 0.05276227f, 0.07051313f, 0.04097546f, 0.02768560f, 
    0.01448500f, 0.03594952f, 0.04185788f, -0.00305639f, 0.27543476f, -0.12934753f, -0.24850333f, 0.17082907f, 
    -0.18101887f, 0.16202560f, 0.00354939f, 0.04109871f, -0.04588218f, -0.07187568f, 0.01830591f, -0.03196448f, 
    0.01534384f, -0.01441389f, -0.04346091f, -0.02928966f, -0.00371292f, 0.00623517f, -0.11661463f, -0.08058134f, 
    0.44985148f, -0.26063782f, -0.35356832f, -0.06047866f, -0.15124223f, 0.06049439f, 0.02847390f, 0.07105775f, 
    0.15686592f, 0.03975752f, -0.00369646f, -0.01631541f, -0.00619607f, 0.01441844f, 0.03734557f, -0.00222421f, 
    0.04072158f, -0.03987835f, 0.02042093f, 0.07870483f, 0.19130597f, -0.25680065f, -0.21670066f, 0.22516283f, 
    -0.24257022f, 0.00027401f, -0.03049615f, 0.02459631f, -0.02118574f, 0.07440641f, -0.05115210f, -0.05509285f, 
    -0.04669627f, -0.12931699f, -0.02065378f, -0.07339365f, 0.06255010f, -0.01616421f, -0.03842221f, 0.01181884f, 
    -0.17943312f, -0.32233596f, 0.36620739f, 0.00259139f, -0.05406431f, -0.15032329f, 0.05398554f, 0.03676761f, 
    0.02286793f, 0.02120127f, 0.03308202f, -0.02585853f, -0.03202499f, -0.05405482f, -0.05804215f, 0.00508184f, 
    0.00799657f, -0.18131104f, -0.04361272f, -0.08379359f, -0.15834011f, -0.10272090f, 0.17586820f, 0.22625160f, 
    0.07495272f, 0.04839027f, 0.06450137f, -0.05249369f, 0.02395780f, 0.14037959f, 0.03251760f, 0.02952660f, 
    0.00642625f, 0.02039175f, -0.00041305f, 0.06017046f, 0.07714447f, 0.02354191f, 0.00419494f, -0.00484245f, 
    -0.03202675f, 0.07945978f, -0.06500806f, 0.07127931f, -0.05684721f, -0.05508542f, 0.03800337f, 0.07271321f, 
    -0.06782968f, -0.00927703f, 0.04658879f, 0.03171011f, 0.03009551f, 0.02927036f, 0.02041701f, -0.03491312f, 
    -0.05905816f, -0.01435370f, -0.03724433f, 0.10989209f, 0.44101483f, -0.30416223f, -0.03404107f, -0.35823050f, 
    -0.02599446f, -0.03970119f, 0.08836527f, -0.17681399f, 0.00510333f, -0.01952268f, 0.01892086f, -0.01227587f, 
    0.05571737f, -0.03988895f, 0.06634573f, -0.04211792f, 0.01724136f, -0.03405308f, 0.03868672f, 0.03061555f, 
    -0.07345475f, -0.03114732f, 0.04403466f, 0.03900458f, -0.02563821f, 0.01759019f, 0.09251646f, 0.03020312f, 
    0.00535835f, -0.00778871f, 0.01824905f, 0.05806959f, 0.04845880f, 0.00445270f, -0.00375519f, 0.03041972f, 
    0.01014784f, 0.04842218f, 0.01645909f, 0.04806993f, 0.25185564f, 0.05334450f, -0.06397279f, 0.04621933f, 
    -0.05801567f, -0.01557912f, 0.11824932f, -0.07080685f, -0.05003580f, -0.13917252f, -0.01379983f, 0.02041855f, 
    0.09879082f, -0.02558516f, 0.02605968f, -0.01078605f, 0.02798042f, 0.05433468f, 0.00618261f, -0.08704668f, 
    -0.13801391f, 0.11416631f, 0.03024475f, -0.06603140f, -0.11370859f, -0.01238939f, -0.02214317f, -0.08522509f, 
    -0.02520563f, -0.02541568f, 0.05412557f, -0.00850813f, 0.04815007f, -0.00039673f, -0.02108510f, 0.02763089f, 
    -0.00303829f, -0.08277093f, -0.01194132f, -0.03149422f, -0.15081427f, -0.57424444f, 0.22879454f, 0.13324229f, 
    0.02123254f, -0.07005132f, 0.12980902f, -0.08106491f, -0.08543540f, 0.08984247f, 0.03079857f, -0.02452013f, 
    0.02133026f, -0.00449096f, -0.01333125f, -0.06119961f, 0.04406028f, -0.17190345f, -0.01931222f, -0.18654872f, 
    -0.02351206f, 0.12957816f, 0.00772835f, -0.01127461f, -0.08552116f, 0.00655949f, -0.00636435f, -0.01458776f, 
    -0.00217202f, -0.00184196f, 0.03064258f, 0.03403091f, 0.06716770f, 0.03066152f, -0.00194761f, -0.04905998f, 
    -0.14408302f, -0.03063810f, 0.05661365f, 0.02170299f, 0.07286496f, 0.06366388f, -0.01509453f, 0.01669129f, 
    -0.04010655f, 0.01894703f, 0.02459110f, 0.01047558f, -0.00904250f, -0.03135619f, -0.08276033f, -0.23281004f, 
    0.03433755f, 0.00053157f, -0.07958935f, 0.03374732f, -0.00807412f, 0.04680248f, -0.02190788f, 0.01441438f, 
    -0.02264510f, 0.09026901f, 0.06008433f, -0.00481022f, -0.01711773f, -0.02754747f, -0.00053165f, -0.01004871f, 
    0.02485729f, -0.00936074f, 0.03338931f, -0.02858341f, -0.01730266f, -0.04199958f, -0.09439696f, 0.00830507f, 
    -0.02025019f, -0.02364609f, -0.00212715f, 0.01863248f, -0.11336771f, 0.03326417f, 0.19305880f, -0.01147628f, 
    0.09147387f, 0.02550825f, 0.02331075f, 0.10323196f, -0.05924854f, -0.01149566f, 0.04263308f, -0.06470397f, 
    -0.05341457f, -0.06472354f, -0.08227250f, -0.15357406f, 0.05726845f, -0.07342673f, -0.01249880f, 0.02711578f, 
    0.66460603f, -0.36337185f, -0.09512613f, -0.22262076f, -0.18024862f, 0.02015678f, -0.10651141f, -0.17415391f, 
    -0.02499407f, -0.17671224f, 0.05600656f, -0.04960106f, 0.03104299f, -0.05419185f, -0.03997386f, -0.02663372f, 
    -0.05126098f, 0.03973683f, 0.01866052f, -0.01662470f, 0.18651296f, 0.05788185f, 0.11007335f, -0.18450603f, 
    -0.06880035f, 0.04541981f, 0.03510650f, -0.05770033f, 0.05923245f, -0.04213437f, -0.02119141f, -0.05377246f, 
    0.01617071f, -0.04759630f, 0.00561280f, -0.01767232f, -0.05571390f, -0.01059398f, 0.08066125f, -0.03332319f, 
    -0.00363330f, -0.12764688f, 0.15421343f, -0.17943347f, 0.13675602f, -0.01177260f, -0.01696403f, -0.10441662f, 
    -0.01353016f, -0.03385655f, -0.01640134f, -0.00527755f, -0.00384189f, -0.00439301f, -0.05561996f, -0.00062234f, 
    -0.09979242f, 0.06480529f, -0.05036300f, -0.07377060f, -0.02930858f, -0.03895160f, -0.14752074f, -0.05593866f, 
    -0.05305452f, 0.06116183f, -0.00959307f, 0.06820731f, 0.02172614f, 0.01400746f, -0.13774845f, 0.06821963f, 
    0.00658726f, 0.07544751f, -0.01890402f, 0.02884192f, 0.03060955f, -0.00944350f, 0.06859853f, 0.07952984f, 
    -0.06474598f, 0.03170613f, 0.21429180f, -0.15068707f, -0.00481210f, -0.16231881f, 0.03118589f, -0.18648799f, 
    0.08004822f, 0.01509455f, 0.07852910f, -0.01720434f, 0.01751090f, -0.02044953f, -0.06195878f, -0.19362362f, 
    0.01318612f, -0.09678706f, 0.08333463f, -0.04815524f, -0.04711050f, 0.01919672f, -0.03190004f, 0.09928513f, 
    -0.15095046f, -0.01719396f, 0.08148310f, 0.05933433f, -0.05261849f, 0.01031133f, 0.01312758f, 0.03194539f, 
    0.02807231f, 0.00639320f, 0.03181506f, -0.02584420f, -0.00382646f, -0.05596739f, -0.07662696f, 0.01636073f, 
    0.25603154f, -0.01174190f, -0.30286008f, 0.27695772f, -0.17031828f, 0.02112445f, 0.02313666f, -0.10520894f, 
    -0.01358587f, 0.01556008f, -0.00522536f, 0.02724640f, -0.02765494f, -0.07850090f, -0.04859388f, -0.03454723f, 
    -0.00743487f, 0.07121995f, 0.03953556f, 0.06669807f, 0.04613465f, 0.09448311f, 0.00298996f, -0.10551525f, 
    -0.06275573f, 0.02256742f, 0.01203856f, 0.02236665f, 0.03452909f, -0.01802517f, -0.07681064f, -0.25244641f, 
    -0.18263730f, -0.16923317f, -0.13038632f, 0.06807826f, 0.00012187f, 0.02580408f, 0.04309069f, 0.01267563f, 
    -0.28979662f, -0.40735531f, 0.44362646f, -0.27744123f, 0.22464640f, -0.07580910f, 0.01141005f, 0.13784398f, 
    0.09876944f, 0.03665474f, -0.01591591f, 0.08665505f, -0.00880000f, 0.03276667f, 0.07362587f, 0.01171806f, 
    -0.02336631f, -0.08187702f, -0.03458891f, 0.00141787f, 0.21999830f, -0.26948145f, 0.17210484f, -0.28733271f, 
    -0.26337069f, -0.15346724f, 0.16214505f, -0.06129934f, 0.21914668f, 0.07180158f, 0.03017606f, 0.01209394f, 
    -0.01039647f, -0.04614535f, -0.00388347f, -0.04954111f, -0.04241872f, 0.00284266f, 0.02847791f, -0.02145495f, 
    0.01504710f, 0.07834556f, -0.02966346f, 0.02580597f, -0.08799297f, -0.02324370f, 0.02693142f, -0.01295009f, 
    -0.08545447f, -0.05259029f, -0.01431640f, 0.01311692f, -0.02839823f, 0.00094351f, -0.00108099f, -0.05267068f, 
    -0.04755864f, 0.01102447f, -0.02311671f, 0.01390351f, 0.05903362f, 0.08645576f, -0.08287486f, -0.07831479f, 
    -0.08326086f, 0.02714940f, -0.01327048f, -0.04228508f, 0.01472437f, 0.01233427f, -0.08339441f, 0.00145938f, 
    -0.03080063f, -0.10836302f, -0.07054061f, -0.06456060f, 0.08366780f, -0.02994646f, -0.01575023f, -0.02950480f, 
    0.54251432f, -0.40197936f, -0.45766160f, -0.32258463f, -0.22957824f, -0.00321838f, -0.04408091f, -0.30998060f, 
    0.21817467f, -0.07158054f, 0.03318278f, 0.04907873f, -0.03462333f, -0.02271819f, 0.06379884f, -0.02836539f, 
    0.00535354f, -0.03148949f, 0.05745708f, -0.03621691f, 0.00018331f, 0.41047710f, -0.42862746f, 0.17818384f, 
    -0.15467773f, 0.10199056f, 0.02350131f, -0.06514885f, -0.18937115f, -0.14165927f, 0.00523406f, 0.01769011f, 
    -0.06218603f, -0.02065740f, 0.04612373f, -0.07682731f, 0.02696869f, 0.11816367f, 0.01560003f, 0.02097830f, 
    0.32375732f, -0.10306577f, -0.23236084f, 0.18562457f, -0.26564184f, 0.16540296f, 0.01807656f, 0.13544121f, 
    0.03421421f, 0.02769949f, -0.06795938f, 0.04201363f, -0.08785102f, -0.00930876f, 0.01936572f, -0.02233272f, 
    0.08459014f, 0.07748880f, -0.08571967f, -0.14559606f, -0.39437574f, -0.36830711f, 0.06109423f, 0.18835692f, 
    0.02305003f, 0.01793213f, 0.03498630f, -0.05509309f, -0.07294291f, -0.02527519f, 0.05876829f, -0.03313556f, 
    -0.01843284f, 0.01097087f, -0.02227798f, 0.06872036f, 0.00523185f, -0.06979972f, -0.09050259f, -0.06109978f, 
    0.60268170f, -0.48498681f, -0.31776184f, -0.35101169f, -0.15487103f, -0.03709659f, -0.05538329f, -0.05412572f, 
    -0.03151442f, -0.12077551f, -0.00936491f, -0.03859353f, 0.00847934f, -0.00486730f, 0.00433748f, 0.03276045f, 
    0.00895289f, -0.01517449f, -0.06491265f, -0.02916634f, -0.17077079f, 0.12326177f, 0.08869383f, 0.06288473f, 
    0.06717654f, 0.00641851f, -0.01899847f, -0.03767109f, -0.13937208f, -0.06010232f, 0.06352831f, 0.00042309f, 
    0.01849613f, 0.00094192f, -0.01266910f, 0.06702261f, 0.11479439f, -0.02409306f, -0.03791742f, -0.06963556f, 
    0.05003987f, 0.08356477f, 0.01636538f, -0.02960802f, -0.02433173f, -0.13409466f, 0.04850002f, -0.00103792f, 
    -0.06633575f, -0.07491998f, -0.10319891f, 0.04859325f, -0.02126451f, -0.01913558f, -0.13051724f, -0.06870078f, 
    -0.02338809f, 0.02964132f, -0.02976979f, -0.00375711f, -0.08947039f, 0.07696374f, 0.02606157f, 0.01130113f, 
    -0.07101811f, 0.01019619f, 0.01769438f, -0.09296491f, 0.01779825f, 0.01683854f, 0.03253772f, 0.02070778f, 
    0.03002083f, 0.00917623f, -0.00742194f, 0.04630855f, -0.10429629f, -0.09400990f, 0.07791260f, 0.02593135f, 
    0.86815339f, -0.06745815f, -0.43799347f, 0.22048980f, -0.44126186f, 0.02396029f, -0.11660443f, 0.04042008f, 
    -0.03288172f, -0.02639593f, -0.08463379f, -0.05345702f, 0.04126718f, 0.00131105f, -0.00540974f, 0.01743810f, 
    -0.03715796f, 0.03228274f, -0.16202258f, -0.07028196f, 0.21017718f, -0.05572534f, -0.14759883f, 0.03406346f, 
    -0.12501685f, -0.03424797f, 0.04834481f, -0.10273682f, -0.21655919f, 0.03473014f, -0.02289237f, 0.07325977f, 
    0.07556005f, -0.00334035f, -0.04703460f, -0.04991813f, -0.13080515f, 0.09225073f, -0.05365035f, -0.02994790f, 
    -0.31225798f, -0.22728717f, 0.09635815f, 0.02158211f, 0.22565743f, 0.09557304f, -0.11241134f, -0.01208360f, 
    0.00252691f, 0.09488198f, -0.04991960f, 0.00258523f, 0.08376843f, 0.01637256f, -0.00420852f, 0.01339057f, 
    0.04227156f, -0.02164262f, -0.08914922f, -0.04917637f, -0.01019261f, 0.05739379f, -0.00620071f, 0.01960490f, 
    -0.17994204f, 0.01863877f, 0.07445666f, -0.03632559f, -0.03478882f, -0.01971700f, 0.03173951f, 0.02763706f, 
    0.02602251f, 0.02061382f, -0.02828754f, -0.09019759f, -0.02829716f, -0.04917064f, -0.03269037f, -0.06598050f, 
    0.03509383f, 0.03377384f, -0.10259019f, 0.00027634f, -0.07533614f, 0.05233896f, -0.01908274f, 0.03963175f, 
    -0.02407958f, 0.01908297f, -0.11133404f, 0.01059460f, 0.00268753f, 0.06637336f, -0.05564924f, 0.00527897f, 
    -0.03214950f, -0.00177375f, -0.02518883f, 0.03157246f, -0.31243205f, -0.37435287f, 0.19620535f, 0.02120434f, 
    0.28239101f, -0.00114739f, -0.06560531f, 0.15751950f, -0.04875051f, 0.00166465f, -0.00737816f, -0.00098365f, 
    -0.07959907f, 0.03222083f, -0.05507315f, 0.03151141f, 0.10036634f, 0.00992027f, 0.11966923f, -0.02308687f, 
    -0.05170697f, -0.28436267f, -0.19249333f, -0.26750970f, -0.07040378f, -0.04733403f, -0.02112907f, 0.01671822f, 
    0.10899059f, 0.01826466f, -0.01807208f, 0.00140193f, -0.05629196f, -0.07919423f, 0.01733750f, -0.00312773f, 
    0.00043430f, -0.05429383f, 0.03628261f, -0.06435980f, 0.32025859f, -0.38052058f, -0.38775551f, -0.35632539f, 
    -0.19848998f, -0.11428220f, -0.08226500f, -0.05768580f, 0.12262127f, -0.04810294f, 0.01705420f, 0.03733579f, 
    0.01703896f, -0.01088322f, 0.00191552f, -0.01409959f, 0.03483817f, -0.04839999f, 0.06056883f, 0.00947494f, 
    0.03521123f, -0.53998530f, -0.11183269f, -0.31439790f, -0.03654795f, -0.07720283f, -0.03889030f, -0.11891846f, 
    0.06790378f, 0.02187810f, 0.00443321f, 0.06125586f, -0.11470270f, -0.05510695f, 0.13250273f, -0.11374208f, 
    0.01114602f, -0.09469276f, 0.05484205f, -0.00253271f, -0.41321939f, 0.17668837f, 0.01214499f, 0.27789292f, 
    0.05415538f, 0.01667029f, 0.04313978f, 0.12502286f, -0.10401100f, 0.07312393f, -0.07616360f, 0.07527869f, 
    0.00743047f, 0.05262784f, 0.07822579f, -0.09579607f, 0.01375795f, 0.11618918f, -0.04802658f, 0.06990760f, 
    0.32781535f, -0.47853494f, -0.12908855f, 0.11063896f, -0.21317834f, 0.02714208f, -0.01186230f, 0.00416514f, 
    0.14654090f, 0.12346885f, 0.01735687f, 0.04066773f, -0.10374688f, -0.01070375f, 0.01678697f, -0.06844603f, 
    0.01892562f, -0.15624179f, 0.06557661f, 0.06507447f, -0.01685519f, 0.08267944f, -0.05127319f, 0.04500208f, 
    -0.09786520f, -0.04737066f, -0.00341887f, 0.00911640f, 0.00045390f, -0.02808581f, 0.03355126f, -0.01307033f, 
    0.04323246f, -0.01796683f, -0.02280080f, -0.12044877f, -0.08181430f, 0.02399406f, -0.04579445f, 0.00796859f, 
    -0.13984323f, -0.35084757f, -0.14737618f, -0.30317560f, -0.03362760f, 0.05018394f, -0.01172695f, 0.11469407f, 
    0.07771139f, 0.06509597f, 0.00232311f, 0.02444441f, -0.02585724f, 0.08395190f, 0.06638339f, -0.11305456f, 
    -0.05207999f, 0.02554767f, 0.05500772f, 0.00457766f, 0.15870975f, -0.23725387f, -0.00922620f, -0.34660089f, 
    -0.22350717f, -0.07924253f, 0.08288583f, -0.03897483f, 0.25253966f, 0.04084272f, 0.03839416f, 0.02206097f, 
    -0.03738395f, -0.05737602f, 0.00251012f, -0.04310915f, 0.00362005f, 0.03043200f, 0.09001393f, 0.03842071f, 
    0.01309370f, 0.05697237f, -0.07079943f, 0.03201732f, -0.14268373f, 0.02396656f, 0.05117445f, -0.00005597f, 
    0.00345365f, -0.03282579f, 0.05357260f, 0.06438654f, 0.01975323f, -0.00018113f, 0.00839196f, -0.04141425f, 
    -0.00498055f, 0.03015981f, -0.02464736f, 0.01316190f, 0.00330905f, 0.04926865f, 0.06247144f, 0.00089803f, 
    0.02898252f, 0.00940280f, 0.01101085f, 0.01174005f, -0.00675963f, -0.02172115f, 0.03868064f, -0.08903190f, 
    0.00561725f, -0.02561647f, -0.05268515f, 0.00519546f, -0.02715431f, 0.00082355f, 0.03850777f, 0.03685402f, 
    0.28421623f, 0.00598276f, 0.03615743f, -0.21699047f, -0.01101627f, -0.13451408f, 0.13054918f, -0.00350988f, 
    -0.03682804f, -0.06618002f, -0.00040080f, -0.08863607f, 0.08056960f, 0.05243166f, 0.00410297f, -0.05953137f, 
    0.03322612f, 0.01021217f, -0.03187167f, -0.01905679f, -0.47088870f, -0.05340348f, -0.20508602f, -0.04828146f, 
    0.19970404f, 0.16827311f, -0.04760967f, 0.18265945f, 0.00010327f, 0.00124880f, -0.03090579f, 0.07027177f, 
    -0.00793457f, 0.05024665f, -0.02480884f, 0.10555863f, 0.08707438f, 0.12052879f, -0.01924881f, 0.04412535f, 
    -0.28708556f, -0.38949376f, -0.06794470f, 0.30739298f, 0.05908874f, -0.03735660f, 0.08394203f, 0.01886690f, 
    0.08275636f, 0.08959595f, 0.06076393f, -0.01172826f, 0.00520082f, 0.00504933f, -0.03314618f, 0.05565688f, 
    0.01060709f, -0.02813763f, 0.01721290f, 0.00575259f, 0.11222297f, -0.47742024f, -0.34172186f, -0.28171852f, 
    -0.18256326f, -0.00850737f, -0.10487694f, -0.09479912f, 0.08390740f, 0.04708956f, -0.01130172f, 0.01915003f, 
    -0.04436693f, -0.05554645f, 0.03683970f, -0.06310618f, -0.00782771f, -0.04632184f, 0.09636228f, 0.03140854f, 
    -0.49670553f, -0.34842935f, 0.12313468f, 0.12155512f, 0.18689395f, -0.05528889f, 0.00425265f, 0.02012089f, 
    -0.06563551f, 0.05795540f, 0.02192301f, -0.02429277f, 0.01385957f, -0.03590750f, -0.08618238f, 0.03169054f, 
    -0.01638809f, -0.17425609f, -0.04812040f, -0.04381907f, -0.03205793f, 0.02881953f, -0.06926683f, -0.04539577f, 
    -0.08949538f, 0.06341501f, 0.04931169f, 0.01097958f, -0.02962115f, -0.04513516f, -0.00047509f, 0.01335114f, 
    0.01653563f, -0.02562710f, -0.01419177f, -0.12473703f, -0.01290937f, -0.11396031f, -0.07171613f, 0.01912004f, 
    -0.35766193f, -0.58986342f, -0.55839962f, -0.39092171f, -0.09506693f, -0.04602191f, -0.29088077f, -0.02105710f, 
    0.05954902f, -0.21141464f, -0.03577491f, -0.04784885f, -0.03087598f, -0.00961461f, 0.01614939f, 0.03313139f, 
    -0.00739276f, 0.08068717f, 0.08344101f, 0.10544286f, -0.09221548f, 0.07073446f, 0.06184435f, -0.01031064f, 
    -0.07103822f, -0.02284731f, 0.01579379f, -0.02705076f, 0.01276844f, -0.04098275f, -0.01358688f, -0.03601509f, 
    -0.00279794f, 0.05295663f, 0.03877540f, -0.01205455f, 0.09856036f, 0.05475810f, 0.07867247f, 0.05893379f, 
    0.11205021f, -0.16022317f, -0.33849016f, -0.24959920f, -0.10968031f, -0.16086718f, -0.31856197f, -0.11550179f, 
    -0.11467606f, -0.35032588f, 0.01461282f, -0.01001083f, 0.00076925f, 0.02731854f, 0.00770749f, 0.06398012f, 
    0.01562849f, 0.07696001f, -0.10226731f, -0.09481320f, 0.53652960f, 0.09676246f, -0.26083675f, -0.30566794f, 
    -0.10790637f, 0.09488841f, 0.00699598f, -0.05985373f, -0.00835204f, -0.04224515f, 0.05924425f, -0.01172666f, 
    0.14661773f, 0.00909739f, 0.00139091f, -0.02677077f, 0.10292327f, -0.02564183f, 0.13619256f, -0.01091625f, 
    -0.40936035f, -0.09053458f, 0.20461024f, 0.13579839f, 0.05621285f, -0.04943688f, -0.06217677f, 0.03267030f, 
    0.01138484f, -0.02439662f, -0.01751419f, -0.06159087f, 0.06395011f, 0.07861164f, -0.00362020f, -0.09910390f, 
    0.01968663f, 0.00079021f, 0.01757574f, 0.09225371f, -0.25328687f, -0.00094733f, 0.11796541f, 0.03586880f, 
    -0.15947945f, -0.02206880f, -0.15496372f, -0.04301530f, -0.05047429f, -0.06541164f, -0.01874613f, -0.04157282f, 
    -0.05822678f, -0.03703555f, -0.00788543f, -0.09906008f, -0.18389773f, -0.14151394f, -0.15249549f, -0.18945774f, 
    -0.07459953f, -0.23464879f, -0.21353993f, -0.12725504f, -0.06694577f, -0.10167206f, 0.00307272f, 0.00265168f, 
    0.05509787f, 0.13601685f, 0.09992422f, -0.03107275f, -0.09653410f, -0.11320244f, -0.03590640f, -0.02147547f, 
    0.05701397f, 0.05965947f, 0.06967647f, 0.02990274f, 0.28914109f, -0.02498006f, -0.11227629f, -0.07513559f, 
    -0.04715776f, 0.01026548f, -0.02660857f, -0.08768524f, -0.03929804f, -0.05863538f, 0.00506625f, 0.03438410f, 
    0.14824878f, 0.02424421f, -0.01671286f, -0.03386790f, 0.01792226f, 0.01469566f, 0.13776906f, 0.01300569f, 
    0.02286224f, -0.22655945f, -0.15284716f, 0.06163821f, 0.11739248f, -0.18806250f, 0.00219993f, 0.02749713f, 
    0.04894621f, -0.01186894f, -0.01508164f, 0.03084933f, 0.01327040f, -0.05280676f, -0.12585676f, 0.00978568f, 
    -0.04439946f, -0.03169800f, -0.01001815f, -0.09308052f, 0.28742072f, -0.04835081f, -0.01307361f, -0.07331717f, 
    -0.02898023f, 0.00697765f, 0.00922694f, -0.00210184f, -0.01926292f, -0.27328363f, 0.03474671f, 0.07447349f, 
    0.05678144f, 0.09477866f, 0.12052399f, 0.04202956f, 0.05788461f, 0.02294083f, -0.00956209f, -0.13543150f, 
    -0.04829549f, -0.11917902f, -0.02840859f, -0.08323409f, 0.02549530f, 0.08733290f, -0.12243883f, 0.04942115f, 
    -0.03865443f, -0.11129108f, 0.04013167f, 0.03307529f, -0.00654572f, -0.02476823f, 0.04944493f, 0.00414202f, 
    0.06082882f, 0.06187011f, -0.05309477f, -0.01826204f, 0.09842761f, 0.06758174f, 0.21365087f, -0.09310257f, 
    -0.25786820f, 0.00306974f, -0.05525205f, -0.15463457f, -0.07474031f, -0.21208112f, -0.02498442f, -0.01836967f, 
    -0.02668876f, -0.02994436f, -0.02454469f, 0.03423295f, 0.06330474f, -0.12682886f, -0.15443572f, -0.47273603f, 
    -0.49607098f, -0.04929155f, 0.21070485f, -0.00131893f, 0.00075919f, -0.07852891f, -0.00763345f, -0.07238588f, 
    -0.04725459f, 0.00705897f, 0.03148416f, -0.03494936f, -0.00474739f, 0.04425786f, -0.04352893f, -0.02432024f, 
    0.09683190f, 0.03090900f, 0.05586417f, 0.04209793f, 0.02485912f, -0.04850836f, -0.44716316f, -0.03792673f, 
    0.01613523f, -0.00094555f, 0.01802200f, 0.13311373f, 0.16600306f, 0.12258235f, 0.14845912f, -0.07091460f, 
    -0.04610707f, 0.02533403f, 0.04279931f, -0.05499574f, 0.02202004f, 0.00501968f, 0.01907170f, -0.00096454f, 
    0.14236335f, -0.07298603f, -0.04112097f, -0.07660475f, -0.18116006f, -0.14008711f, -0.17680812f, -0.18707247f, 
    -0.12193990f, -0.02616482f, -0.00517765f, 0.13155639f, 0.06347692f, -0.03084944f, 0.07110669f, 0.03861399f, 
    0.13688220f, 0.08298909f, 0.16701049f, 0.16827841f, 0.23134300f, -0.05302019f, -0.15433681f, -0.27466661f, 
    -0.08360903f, -0.06441228f, -0.20058484f, -0.04978089f, -0.02018289f, 0.07392628f, 0.02815404f, 0.13192454f, 
    0.11036559f, 0.01381562f, -0.05162315f, -0.01427024f, 0.05839900f, -0.03218486f, 0.06050082f, 0.09624132f, 
    -0.29334676f, 0.03788673f, 0.16096294f, 0.05070590f, -0.07942642f, 0.04636452f, -0.09466850f, 0.01926978f, 
    0.00356003f, -0.14339986f, -0.01483013f, 0.00367042f, -0.03975259f, -0.02483809f, -0.02744355f, -0.11594238f, 
    0.00354283f, -0.01191591f, -0.06305461f, -0.14036499f, -0.10851966f, -0.10025781f, -0.04475137f, 0.01175790f, 
    0.07090358f, -0.00433491f, -0.04931175f, 0.11476260f, 0.02529388f, -0.06291891f, -0.07681505f, 0.02294360f, 
    -0.02087686f, 0.02894523f, 0.04145719f, -0.01498465f, 0.07848834f, 0.16211118f, 0.11774987f, 0.04713825f, 
    -0.30766755f, 0.14423673f, 0.13201733f, 0.03850900f, -0.21075006f, -0.06591451f, -0.04029319f, -0.07218518f, 
    0.00238243f, -0.03566913f, -0.05737573f, -0.03626036f, -0.02927191f, -0.02804491f, 0.00032578f, -0.02532954f, 
    0.07604923f, 0.04095802f, 0.01697844f, 0.02555056f, -0.00568555f, -0.02539386f, -0.02033088f, -0.02929097f, 
    -0.09366653f, -0.04872778f, -0.03227695f, 0.01533772f, 0.01437237f, -0.01195871f, 0.03783914f, 0.05234483f, 
    0.02960007f, 0.01194469f, -0.01015325f, 0.03016015f, 0.13144495f, 0.03086912f, 0.11509008f, 0.04975295f, 
    -0.13355687f, -0.00370388f, 0.02742350f, 0.02695210f, -0.11300613f, -0.06384475f, -0.03069724f, -0.01187063f, 
    0.02812283f, -0.02388433f, -0.04413226f, 0.02148873f, 0.03506779f, 0.00715606f, 0.07273748f, -0.02492240f, 
    0.01505883f, 0.06315605f, 0.05469214f, 0.07894113f, -0.12133779f, -0.34467500f, 0.02761551f, 0.16843955f, 
    0.01664207f, -0.07648861f, 0.04529897f, -0.10246944f, -0.06526589f, 0.03142048f, 0.04605549f, 0.02562606f, 
    -0.06601658f, 0.11007768f, 0.07393955f, 0.07270079f, 0.05438107f, 0.07585251f, -0.05984916f, 0.05844366f, 
    0.03517551f, -0.42112681f, -0.34806913f, -0.23812962f, -0.11903580f, -0.04634160f, 0.04387001f, 0.14762084f, 
    0.04156112f, 0.14794019f, 0.01587143f, 0.02225375f, -0.04938321f, -0.00215124f, -0.05879880f, -0.01475560f, 
    0.02816674f, -0.03406272f, 0.02491697f, 0.03796607f, 0.18976484f, -0.04973994f, -0.14168443f, -0.07967111f, 
    -0.04643345f, -0.00661046f, -0.09312280f, -0.01584650f, 0.03129119f, -0.10816541f, 0.08679135f, 0.15097083f, 
    0.10903377f, 0.08547726f, 0.04679707f, -0.06626698f, 0.03194990f, -0.17695877f, 0.00214617f, 0.08677144f, 
    0.37607262f, -0.11051655f, -0.02479285f, 0.00749798f, 0.02234957f, 0.10618427f, 0.00496332f, -0.04091659f, 
    0.08754671f, 0.08022652f, 0.01290454f, 0.09277698f, 0.04851222f, 0.03747799f, 0.04588866f, 0.05605596f, 
    0.08034143f, -0.04925225f, -0.02376212f, 0.08362711f, -0.31638604f, -0.37460154f, 0.13436662f, -0.05475881f, 
    0.05992863f, -0.08106595f, 0.04056522f, 0.06865121f, -0.01236606f, 0.00550924f, 0.11790515f, 0.05951062f, 
    0.01722009f, -0.00255599f, -0.03114213f, 0.00730579f, 0.02551825f, -0.02321212f, 0.00937642f, -0.06031797f, 
    -0.06569592f, 0.13741635f, -0.04178768f, 0.00656204f, 0.07108417f, 0.08021161f, -0.08340932f, 0.07543865f, 
    0.10331005f, -0.08852195f, -0.06582952f, -0.00175186f, 0.03606181f, -0.09163980f, 0.01459731f, -0.14730738f, 
    0.03912779f, 0.08176523f, -0.03048239f, 0.14724171f, -0.39242396f, 0.08847021f, 0.23469102f, 0.09922435f, 
    0.02006491f, -0.06037771f, -0.00320950f, -0.07122362f, -0.03427770f, -0.04224588f, -0.09864858f, -0.04364057f, 
    0.01925905f, -0.05448259f, 0.00967846f, -0.10888556f, -0.04068015f, -0.09514279f, -0.03284796f, -0.16509521f, 
    0.41357678f, 0.21998967f, -0.06524919f, -0.10904396f, -0.05547668f, 0.15115954f, 0.00506779f, 0.12127161f, 
    0.14990440f, -0.03628604f, 0.07934564f, 0.01900656f, 0.06691292f, 0.04876174f, 0.01896941f, -0.04948150f, 
    -0.10644854f, -0.08346767f, -0.06899761f, -0.22674367f, -0.12851368f, -0.08054819f, -0.08768184f, -0.08765059f, 
    -0.12371208f, -0.08936040f, -0.01676427f, -0.01666467f, -0.00060200f, -0.04755439f, 0.06196300f, 0.08355663f, 
    0.06884529f, 0.07759368f, 0.05011733f, 0.03012579f, 0.03516035f, 0.00094183f, 0.04883179f, 0.05699636f, 
    -0.05989899f, -0.36898780f, -0.19725823f, 0.11163913f, 0.27212292f, 0.15088128f, 0.01390542f, 0.00995963f, 
    -0.08803438f, 0.08228824f, -0.02304533f, 0.06991177f, -0.10428569f, 0.02764547f, -0.01038230f, -0.02926905f, 
    0.00896457f, 0.04727176f, -0.09533639f, 0.02969522f, -0.06724197f, -0.10847545f, -0.49885231f, -0.21832636f, 
    0.02403401f, 0.12629649f, -0.19783968f, 0.13872485f, 0.01959379f, -0.14640987f, -0.02871762f, -0.00282646f, 
    0.00641217f, 0.00302798f, 0.04206302f, -0.02438116f, -0.01829045f, 0.10964372f, 0.02200443f, -0.01170335f, 
    0.03770881f, 0.15363017f, 0.05135387f, -0.01247280f, -0.02308233f, -0.03602750f, 0.03681573f, -0.05277637f, 
    -0.01281054f, -0.01278385f, 0.05847997f, -0.00662208f, 0.04636379f, 0.05096925f, 0.04245496f, 0.00926058f, 
    0.08104485f, 0.05093950f, 0.00186794f, 0.01875796f, -0.02313048f, 0.08451471f, 0.04933692f, 0.12443806f, 
    -0.16874172f, -0.07457354f, -0.00082147f, -0.03710876f, 0.05905377f, -0.05688618f, 0.02106898f, 0.07507751f, 
    0.09872916f, 0.08450129f, 0.12874283f, -0.08074955f, 0.03770851f, -0.03841715f, -0.06222632f, 0.02040239f, 
    -0.17097089f, -0.48377207f, -0.74840242f, -0.38716725f, 0.02886971f, 0.01169613f, -0.05143842f, 0.18692119f, 
    0.18037830f, 0.07037747f, 0.04219586f, -0.04109534f, -0.05661852f, 0.07407530f, -0.05723754f, 0.00469565f, 
    -0.02294369f, -0.03344196f, -0.06047070f, 0.00383153f, 0.67829573f, 0.21691427f, -0.04023650f, 0.13093790f, 
    0.01528018f, 0.05634813f, 0.16286057f, 0.06478369f, 0.13093023f, -0.04063112f, 0.03286585f, 0.00980458f, 
    0.02338224f, 0.01824220f, -0.02049070f, 0.03387075f, -0.00549294f, -0.12025462f, -0.09976596f, -0.19182551f, 
    0.44201946f, -0.09178314f, -0.10684363f, -0.18498239f, -0.05268089f, 0.07914520f, 0.01380457f, -0.11031781f, 
    -0.09468723f, -0.23559631f, 0.04003724f, 0.09052128f, 0.15936676f, 0.01414168f, -0.01511627f, -0.04407969f, 
    -0.00119050f, 0.09892870f, 0.19615094f, 0.14361918f, 0.46855372f, -0.10621446f, -0.02143291f, 0.01135444f, 
    -0.18696436f, 0.00354329f, -0.10040807f, -0.10035340f, -0.06014121f, -0.01174622f, 0.04572847f, 0.04551008f, 
    0.08374814f, -0.03675260f, 0.03147708f, 0.02941088f, 0.09753299f, 0.09036555f, 0.09152157f, 0.13951831f, 
    -0.07160083f, -0.45626509f, -0.51222944f, -0.20561521f, 0.07352769f, 0.00586540f, -0.02545873f, 0.08003801f, 
    0.13746729f, 0.10908314f, -0.00863817f, -0.01778259f, -0.03238646f, -0.06643190f, 0.00442410f, 0.00777637f, 
    0.03139799f, 0.03794176f, 0.06023841f, 0.00893011f, -0.18645023f, 0.03268955f, 0.19875489f, 0.17399755f, 
    -0.09937946f, 0.05221398f, -0.05197524f, -0.01466419f, -0.07645416f, -0.03390578f, -0.03432170f, -0.02621285f, 
    -0.00317971f, -0.02100743f, -0.01598880f, -0.15202951f, -0.21255656f, -0.07121678f, -0.18319994f, -0.25819281f, 
    -0.03014517f, -0.02503977f, 0.03951794f, 0.00952060f, -0.09127440f, 0.00669945f, -0.02454972f, -0.00862815f, 
    0.05225615f, 0.00460466f, 0.02414230f, 0.09961428f, -0.02177757f, 0.06866419f, 0.05170276f, 0.07429006f, 
    0.14264534f, 0.04899066f, 0.03562002f, 0.07028200f, -0.23127452f, 0.05922524f, 0.09961578f, 0.03715110f, 
    -0.11502054f, 0.00786766f, -0.07039675f, 0.04868726f, 0.00014345f, -0.08003782f, -0.04196518f, 0.00138064f, 
    0.01282832f, -0.00251139f, -0.00838929f, 0.01088378f, -0.01957330f, 0.11275055f, 0.05984722f, 0.09034418f, 
    0.50548172f, -0.18186264f, -0.27621156f, -0.30395976f, -0.07308830f, -0.09296134f, 0.11276620f, 0.05096592f, 
    0.06882204f, -0.11161049f, 0.09328065f, 0.08336961f, 0.04146196f, -0.01408882f, 0.04832182f, 0.01732801f, 
    0.02979899f, -0.01089973f, 0.01326355f, 0.06923746f, 0.32652444f, 0.12185171f, -0.04196671f, 0.00573794f, 
    -0.14949085f, 0.16288890f, 0.00321271f, 0.17036329f, 0.00449157f, 0.03808912f, 0.01761266f, -0.01555983f, 
    0.00404507f, 0.04125329f, 0.00728407f, 0.01800483f, -0.01282529f, 0.04780332f, 0.12563969f, -0.01392771f, 
    -0.05829109f, -0.23336594f, -0.06518874f, 0.12780088f, 0.09327710f, -0.08712419f, -0.03838269f, 0.04181591f, 
    -0.07634822f, 0.08204649f, -0.04660378f, -0.08908913f, 0.03774100f, 0.01591986f, -0.03864076f, -0.06588335f, 
    0.03653781f, 0.11836758f, -0.00343080f, 0.07168660f, -0.22175825f, 0.12376917f, 0.13371561f, 0.09588622f, 
    -0.04706145f, -0.03920456f, -0.04448837f, -0.07756741f, -0.00168721f, -0.01018695f, -0.08786440f, -0.01623957f, 
    -0.01573853f, -0.05943769f, 0.03774336f, 0.03223082f, 0.04404759f, -0.12979969f, -0.07908422f, -0.05390146f, 
    0.05663672f, 0.04157425f, -0.05684116f, -0.04600843f, -0.00752928f, -0.04398036f, 0.07405590f, 0.01705030f, 
    -0.00451020f, 0.00365777f, 0.08059475f, -0.00034246f, 0.05602068f, 0.05184783f, 0.01474495f, -0.00123127f, 
    0.06593297f, 0.07734090f, 0.09292033f, 0.01061834f, 0.54057455f, -0.16803987f, -0.06780336f, 0.02170193f, 
    0.09849678f, 0.07577675f, 0.05860899f, -0.08189191f, 0.05582761f, 0.06528015f, 0.06283224f, 0.02549162f, 
    0.02225908f, 0.02260979f, 0.01428547f, -0.05836439f, -0.15234983f, -0.05167922f, -0.29939964f, -0.34970331f, 
    0.16197182f, -0.04569885f, -0.35400718f, -0.12570448f, 0.05464565f, -0.07489251f, -0.06577712f, 0.04636859f, 
    -0.06849704f, -0.11921509f, 0.01713789f, -0.01713164f, -0.03274859f, 0.05471602f, 0.06456714f, 0.04077904f, 
    -0.04204855f, 0.07407844f, -0.01201205f, -0.05990815f, -0.01466982f, -0.30494490f, -0.52666205f, -0.23834649f, 
    0.11540057f, 0.03903500f, 0.03974268f, 0.15123293f, 0.10211550f, 0.03002132f, -0.03008389f, -0.08313127f, 
    -0.04765194f, -0.01827005f, -0.02830273f, 0.02304291f, 0.02230431f, 0.03133971f, -0.05910447f, 0.00944729f, 
    0.17315562f, 0.03085550f, -0.17951095f, 0.00902055f, -0.00229029f, 0.14938450f, 0.00565134f, 0.01641583f, 
    0.10522254f, -0.01023852f, 0.02455867f, -0.01392787f, 0.03678121f, 0.00122993f, 0.11057662f, 0.02092758f, 
    0.09419491f, 0.11334007f, -0.03264771f, 0.05287471f, -0.05235082f, -0.83003914f, 0.18593414f, -0.04450905f, 
    0.37308344f, -0.15852918f, 0.13618155f, -0.08623239f, 0.08931610f, -0.08991565f, -0.00710960f, 0.01832066f, 
    0.10906982f, -0.01337114f, 0.07601293f, 0.08527108f, 0.01595392f, -0.22242486f, 0.05645652f, -0.09757033f, 
    -0.07101147f, -0.15549834f, -0.53957695f, -0.41202638f, -0.22533630f, -0.09035029f, 0.00676296f, -0.07670822f, 
    -0.01379754f, -0.07335743f, -0.01172337f, -0.02452089f, 0.00092334f, 0.11695952f, 0.02551819f, 0.07837489f, 
    0.01800956f, 0.05231696f, -0.05325387f, -0.03106052f, -0.17080796f, 0.03895072f, 0.09856749f, 0.01427238f, 
    -0.04099619f, -0.05280881f, -0.02136437f, -0.00759958f, 0.05946433f, -0.03090831f, -0.03222722f, 0.00145699f, 
    0.01851728f, 0.01108607f, 0.01986305f, 0.05611175f, 0.07056762f, 0.02771940f, 0.00986832f, 0.05541521f, 
    0.15659557f, -0.19362772f, -0.43221492f, -0.03646613f, 0.16353360f, 0.10797309f, -0.10957514f, 0.06002794f, 
    0.08053267f, 0.08008052f, 0.03453885f, -0.00307207f, -0.03412444f, -0.00193832f, -0.06900175f, 0.00720645f, 
    0.04144137f, -0.06331103f, -0.23699072f, -0.03917771f, 0.00745317f, -0.05797860f, -0.48452413f, -0.24936646f, 
    0.05038485f, -0.09175960f, -0.15423782f, 0.15125296f, -0.09066353f, -0.20910850f, 0.00161805f, -0.04296286f, 
    -0.00155949f, 0.00114396f, 0.05727753f, -0.00402304f, -0.04998277f, 0.06489422f, 0.11924713f, -0.08147472f, 
    0.06581166f, 0.10414826f, 0.05174901f, -0.00879130f, -0.10424216f, -0.02028251f, -0.00111869f, 0.02352203f, 
    -0.00955221f, -0.11043114f, -0.04375699f, -0.02570062f, 0.02197516f, 0.01077196f, -0.00264734f, 0.04288831f, 
    0.08428546f, 0.05896925f, 0.09251605f, 0.08318337f, -0.15173998f, -0.03928024f, 0.00474351f, 0.01761520f, 
    -0.03525250f, -0.00229125f, -0.01028729f, -0.07549722f, -0.04231278f, -0.00577132f, 0.03506242f, 0.05858342f, 
    0.03121318f, 0.12997885f, 0.01951277f, 0.03660508f, 0.02327107f, 0.08189499f, 0.06292519f, 0.10403087f, 
    0.05781745f, -0.10489067f, -0.20944124f, -0.11422465f, -0.09349882f, -0.01240818f, -0.07063811f, 0.12060285f, 
    0.04951506f, 0.11462433f, 0.06742749f, 0.12054113f, 0.01365274f, -0.07050454f, 0.11869317f, -0.04573656f, 
    0.04156845f, 0.04892924f, -0.04588704f, 0.11144899f, -0.01049789f, -0.60231471f, -0.26143581f, -0.00260519f, 
    0.40111077f, 0.03324369f, 0.07586745f, 0.09156696f, -0.02059733f, 0.00125388f, 0.06892201f, -0.04907138f, 
    0.04254784f, 0.02347419f, 0.07063206f, -0.02455452f, -0.08443452f, -0.01149524f, -0.10173885f, -0.16651855f, 
    -0.08686005f, -0.42787299f, -0.35870835f, -0.13019367f, -0.07383522f, -0.04453534f, 0.02977539f, -0.04322987f, 
    0.05546505f, -0.09266312f, -0.07565937f, 0.00281410f, 0.01287248f, -0.02518259f, 0.02734104f, 0.03914567f, 
    0.07812525f, 0.10123076f, 0.10054841f, 0.18692523f, 0.15663654f, 0.11145467f, -0.30840373f, -0.13785467f, 
    -0.08610018f, 0.08740345f, 0.03232461f, -0.01041220f, 0.12926112f, 0.00399170f, 0.02041589f, -0.03848856f, 
    -0.00785270f, 0.12342388f, 0.08381423f, 0.14237922f, 0.11365075f, 0.07070860f, -0.14982854f, -0.10691012f, 
    -0.15158604f, -0.17693491f, 0.04725989f, -0.03104887f, -0.08276638f, 0.10769666f, 0.00841853f, -0.06485154f, 
    0.04343236f, -0.18472719f, 0.00219910f, 0.03498293f, 0.03833759f, 0.04448271f, 0.02919787f, 0.07003046f, 
    0.08927076f, 0.10577983f, 0.07476953f, -0.07172395f, -0.02674636f, 0.03788236f, 0.14725955f, 0.03854750f, 
    -0.00527882f, 0.01049461f, -0.09861057f, -0.07027029f, -0.01919616f, -0.07418179f, -0.04006741f, 0.03137349f, 
    0.00401219f, -0.00371967f, 0.04148193f, -0.20004082f, -0.04982089f, -0.21125872f, -0.26795566f, -0.16625114f, 
    -0.37171805f, -0.53332043f, 0.20457074f, -0.03772229f, -0.33998179f, -0.08745361f, 0.00182288f, 0.03555883f, 
    0.16243514f, 0.32873350f, 0.06802523f, 0.03861063f, 0.03511555f, 0.01285606f, -0.05671105f, 0.00645149f, 
    0.00151175f, 0.03409517f, -0.04073116f, -0.10432931f, -0.08186787f, 0.05682179f, 0.01944329f, -0.10530125f, 
    0.04540489f, 0.04421126f, 0.09460521f, 0.09517788f, 0.06146611f, -0.05005715f, 0.11057319f, -0.02300958f, 
    -0.06428937f, -0.01900124f, -0.03013898f, 0.05207649f, -0.00129982f, -0.03561379f, 0.05209263f, -0.05083670f, 
    -0.08821002f, -0.23741001f, 0.06927136f, 0.15492827f, -0.24837054f, 0.01301468f, -0.25629908f, -0.02662388f, 
    0.15020421f, 0.17731667f, 0.01789000f, 0.05693619f, 0.04021693f, 0.03300435f, 0.01229157f, -0.01860524f, 
    0.04043021f, 0.05163547f, 0.09399060f, 0.08897784f, -0.07220923f, -0.07314111f, -0.10893515f, 0.22112015f, 
    -0.30298391f, -0.00667526f, -0.10233486f, 0.01110679f, -0.16743028f, -0.00907434f, -0.04614708f, -0.03679043f, 
    -0.06702328f, 0.02754088f, -0.06696555f, 0.07604203f, -0.00590999f, -0.11227470f, 0.03990560f, 0.01185419f, 
    0.06040948f, -0.12630188f, -0.04621725f, -0.16384564f, 0.16396655f, -0.19233888f, 0.03678325f, 0.07884211f, 
    0.05139800f, 0.23140188f, -0.03675070f, 0.10439866f, 0.04562749f, -0.08514529f, 0.02569098f, 0.02881633f, 
    0.17196061f, 0.05279619f, -0.02747959f, 0.03619310f, 0.10467183f, -0.24712756f, -0.16497959f, 0.07421589f, 
    0.06874425f, 0.02124013f, 0.08667246f, 0.13816848f, 0.00440418f, 0.12278324f, -0.04218678f, -0.03170237f, 
    -0.04079442f, 0.00548147f, -0.06198860f, -0.06341745f, 0.10982179f, 0.06152634f, -0.07406316f, 0.03886791f, 
    0.07440652f, 0.07272727f, 0.28063142f, 0.19226564f, -0.10442910f, 0.11678365f, -0.02440070f, -0.23009719f, 
    -0.15467121f, -0.12382928f, 0.07878169f, 0.02001372f, 0.07972085f, 0.05998708f, 0.02042488f, 0.00249452f, 
    -0.06259061f, -0.05323574f, -0.05821258f, -0.01075977f, -0.00100679f, 0.10578568f, -0.14541540f, 0.15136944f, 
    -0.16519979f, -0.04091223f, -0.01823611f, 0.02808186f, -0.06847568f, -0.12582745f, -0.02481781f, 0.04046777f, 
    0.01556713f, -0.01925807f, -0.07469630f, 0.00636741f, -0.00991818f, -0.03418247f, 0.08490077f, -0.06146546f, 
    0.11835668f, 0.24026838f, 0.12241127f, 0.28823847f, -0.03689083f, -0.02676309f, -0.05334788f, -0.14141375f, 
    -0.04024670f, -0.18139794f, 0.00567669f, -0.05207463f, 0.08878739f, 0.06606773f, -0.01088275f, 0.09530454f, 
    0.09360901f, 0.02489503f, 0.05651137f, 0.14480552f, -0.46998620f, 0.00967224f, -0.26842105f, -0.22812100f, 
    -0.09628792f, 0.08581881f, -0.05948350f, -0.09982259f, -0.20421755f, 0.12333345f, 0.01898856f, -0.04790562f, 
    0.01331529f, 0.01268264f, -0.00638792f, 0.04380875f, 0.03498390f, -0.04304503f, 0.04147322f, -0.02270513f, 
    0.10577264f, 0.07017890f, 0.01173242f, -0.04322615f, -0.06010541f, -0.11925291f, 0.12195148f, 0.05621788f, 
    -0.07337025f, 0.07337420f, 0.03386485f, 0.01771497f, -0.01887758f, -0.01694142f, 0.02573903f, 0.01332364f, 
    0.02305876f, 0.01113461f, -0.04181222f, -0.06886085f, 0.10097509f, -0.24638087f, -0.53489894f, 0.10963462f, 
    0.01999540f, 0.00100389f, 0.02970777f, 0.16771853f, -0.04698570f, 0.10568202f, 0.00752476f, -0.00792534f, 
    -0.02645440f, 0.02768884f, -0.05976343f, -0.05527319f, 0.04570080f, 0.05267607f, 0.08473181f, 0.19125111f, 
    -0.41796073f, -0.16800112f, 0.03059364f, -0.37138733f, -0.09087584f, 0.07465246f, -0.08626720f, 0.06281158f, 
    -0.00779464f, -0.09524048f, 0.06179890f, 0.00526307f, -0.07930316f, -0.12764896f, 0.10577868f, 0.05453312f, 
    0.00932093f, -0.04150894f, 0.00899225f, 0.02512995f, -0.28678355f, -0.07092737f, 0.04039226f, 0.13364831f, 
    0.10516448f, -0.12677076f, 0.20961294f, -0.33134556f, -0.08332518f, -0.07749980f, 0.04526930f, -0.00119464f, 
    -0.01939906f, 0.05742865f, 0.06024766f, 0.05607037f, 0.04399305f, -0.03142590f, -0.00087456f, 0.01710042f, 
    0.16716345f, -0.05413034f, -0.10437912f, 0.14349386f, -0.03031789f, -0.03727704f, 0.14109001f, 0.05174597f, 
    -0.05278546f, -0.04994749f, -0.05996178f, 0.00262759f, -0.02567512f, -0.10117000f, -0.02488955f, 0.06778486f, 
    -0.06330014f, -0.05655485f, -0.22643463f, -0.08237778f, -0.18630102f, -0.07014282f, -0.17679790f, 0.02210356f, 
    0.01059977f, -0.31514776f, 0.11364589f, -0.04208241f, -0.04190709f, -0.06791796f, -0.01713603f, -0.01794980f, 
    -0.00619276f, -0.03375451f, -0.00751098f, 0.03089298f, -0.08908321f, -0.04131828f, 0.00222681f, -0.10131391f, 
    0.14308116f, 0.04512038f, -0.27979851f, 0.09195812f, 0.02249705f, -0.00810022f, 0.15041392f, 0.15577303f, 
    0.01733370f, 0.12791179f, 0.00501139f, -0.03947445f, -0.04882801f, 0.02074393f, -0.04393137f, -0.02460816f, 
    0.01501803f, 0.00360713f, -0.00283073f, -0.03679436f, 0.32373703f, -0.16747713f, 0.06007548f, -0.10313175f, 
    0.00583750f, -0.19962163f, -0.07073137f, 0.04594181f, 0.11635198f, 0.22209519f, -0.05447128f, 0.03566811f, 
    -0.07897247f, 0.01453631f, -0.11133829f, 0.03177964f, 0.06723838f, -0.01164133f, -0.05411391f, -0.07187200f, 
    -0.21046896f, -0.12841070f, -0.33962160f, -0.39123285f, 0.11281484f, 0.10904106f, 0.09084273f, 0.14388274f, 
    0.11096471f, 0.12764396f, 0.04754143f, 0.00980189f, -0.02726743f, 0.02871529f, -0.04698140f, 0.07174020f, 
    0.00864862f, 0.00268137f, -0.01764977f, 0.06282613f, -0.10760953f, 0.15327539f, 0.06854269f, -0.04055166f, 
    0.04212980f, 0.07791685f, 0.03852299f, -0.01850663f, -0.01151428f, -0.08477563f, 0.06034028f, 0.02166123f, 
    0.06369232f, 0.06597583f, 0.08811764f, 0.08163070f, -0.01705762f, -0.08268227f, -0.02812223f, -0.01548626f, 
    0.02362300f, -0.19544546f, 0.01160958f, -0.06347829f, 0.12891029f, -0.04949347f, 0.12195434f, 0.07742982f, 
    0.00140807f, -0.01165983f, 0.02134725f, 0.13133347f, 0.02267931f, -0.00804492f, 0.03630638f, 0.08164147f, 
    0.02338170f, 0.00676137f, -0.04169931f, 0.06477220f, -0.00343334f, -0.42237172f, 0.06025647f, -0.45348924f, 
    -0.01348875f, -0.06433567f, 0.03925214f, -0.09521691f, -0.07890383f, -0.00792528f, 0.04840349f, 0.00664759f, 
    -0.03816147f, 0.07230105f, -0.04976088f, -0.05388853f, 0.08711261f, -0.01543557f, -0.08846360f, 0.01701661f, 
    -0.07780490f, 0.18431294f, 0.02614531f, 0.32714862f, -0.16237813f, -0.10628672f, -0.15495287f, -0.24053454f, 
    -0.15563148f, -0.09069847f, 0.05353118f, -0.04126819f, 0.00998267f, 0.00910601f, 0.02627612f, -0.05782764f, 
    -0.00745187f, -0.01013979f, -0.02705711f, 0.00278033f, -0.25960338f, -0.12248977f, -0.05249931f, 0.10770276f, 
    0.02815325f, -0.08658131f, 0.05425016f, 0.01522563f, -0.11423084f, -0.23607649f, 0.17072132f, -0.02832315f, 
    0.03976925f, 0.01764555f, 0.01438922f, -0.02904734f, 0.07801153f, -0.06319254f, -0.03359761f, 0.19518545f, 
    0.03091725f, -0.47174811f, -0.04005782f, -0.13271128f, -0.05600412f, 0.01755790f, 0.04838351f, 0.00381459f, 
    -0.10727455f, -0.11482066f, 0.00909368f, -0.01272523f, -0.02331748f, 0.06679627f, -0.06703330f, 0.02772225f, 
    0.00344052f, -0.07614845f, -0.18315001f, -0.07674795f, 0.09025887f, 0.00967913f, 0.26709944f, 0.14662477f, 
    -0.13200383f, 0.06132437f, -0.15823308f, -0.11943708f, -0.00099198f, -0.26562247f, -0.02740106f, 0.06307912f, 
    0.07327282f, 0.04136017f, 0.01859507f, 0.10035639f, -0.00213354f, -0.00134970f, -0.04530879f, 0.11702057f, 
    0.05039084f, -0.48817468f, -0.29148695f, -0.05715239f, 0.05573475f, -0.12219015f, 0.06738340f, 0.12186156f, 
    0.00810774f, 0.10205735f, -0.00633863f, -0.03285589f, -0.06227783f, -0.06920820f, -0.04697709f, 0.10132467f, 
    0.00058141f, 0.07011589f, -0.03432710f, -0.14888670f, -0.18958232f, -0.06545106f, -0.33491957f, -0.03758862f, 
    0.13268368f, 0.04458046f, -0.04153753f, 0.13134848f, 0.05302355f, 0.00742376f, 0.02451980f, 0.02674588f, 
    -0.02677445f, 0.07363578f, -0.02034638f, 0.07340053f, 0.08825368f, 0.00437754f, 0.05265443f, 0.10196213f, 
    -0.49056032f, 0.13702130f, -0.42390484f, 0.14534910f, -0.33244899f, -0.04156680f, -0.08039126f, 0.02507282f, 
    0.07892176f, 0.08377303f, 0.03392268f, -0.01277069f, 0.04735063f, -0.01446329f, -0.04246230f, -0.00789924f, 
    -0.04646997f, 0.02521847f, 0.18272978f, 0.12980705f, 0.02976265f, 0.00524010f, 0.07083791f, 0.12747432f, 
    0.11334401f, -0.03650478f, -0.00037166f, -0.04383532f, -0.01144041f, -0.15489677f, 0.12342610f, 0.08296238f, 
    0.12434714f, -0.01341572f, -0.01716310f, 0.14131191f, 0.06146955f, 0.00315371f, -0.02099604f, 0.01898491f, 
    0.14406815f, -0.05171777f, 0.39965367f, -0.40353730f, -0.51117873f, -0.05311708f, -0.08241799f, -0.00175324f, 
    -0.03726213f, 0.06171397f, -0.00986310f, -0.03273426f, -0.02645935f, 0.00068203f, -0.03816402f, -0.07506059f, 
    0.03696162f, -0.06739049f, -0.13552138f, -0.06124246f, -0.06543458f, -0.31829011f, -0.13069014f, -0.05656797f, 
    -0.28580800f, -0.31046534f, 0.17105879f, -0.05440173f, 0.02757945f, 0.10866851f, 0.08504061f, -0.01272569f, 
    0.04832530f, 0.01572392f, 0.02401467f, -0.00955366f, 0.02953149f, 0.02156811f, -0.01809845f, -0.06531926f, 
    -0.15156180f, -0.09283375f, -0.11285429f, -0.08761784f, 0.09808282f, 0.05220964f, 0.08430313f, 0.04616844f, 
    0.00799046f, -0.12762706f, 0.05066978f, 0.00557506f, 0.04171706f, -0.04877784f, -0.04262566f, 0.13748460f, 
    0.00935819f, -0.08939663f, -0.00748162f, 0.00748474f, -0.35968772f, -0.21748866f, 0.07305188f, 0.16799854f, 
    0.14513296f, -0.11568519f, 0.15651998f, -0.22102354f, 0.09192123f, -0.10201450f, 0.04314321f, 0.00574651f, 
    0.01990093f, -0.04309872f, 0.04069857f, 0.11490821f, 0.11626150f, -0.02001029f, -0.04645082f, 0.02841350f, 
    0.04351993f, 0.16214979f, 0.17916435f, 0.46011770f, -0.60269839f, 0.01305222f, -0.06997830f, -0.28077316f, 
    -0.03814331f, -0.14466341f, 0.10697634f, -0.09042427f, 0.09661874f, 0.08979488f, 0.05619088f, 0.07018124f, 
    0.06041124f, -0.01293344f, 0.03247551f, 0.05090284f, -0.63570780f, 0.03429486f, -0.92229050f, 0.28576112f, 
    -0.16078599f, 0.09724148f, -0.09937733f, 0.14326243f, -0.18224202f, -0.06017743f, -0.03090743f, 0.04565563f, 
    -0.00382078f, 0.00285546f, -0.01818240f, -0.06489081f, 0.06456597f, 0.06753525f, 0.12394021f, 0.19112696f, 
    -0.38317519f, 0.11070621f, -0.19116077f, 0.09354006f, -0.08553486f, 0.02547199f, -0.06250646f, 0.00362432f, 
    -0.12930775f, -0.00919041f, 0.11250276f, -0.02750839f, -0.06928948f, -0.03688620f, -0.05142216f, 0.07581906f, 
    0.02758916f, -0.12160033f, 0.04939660f, -0.17639616f, 0.22975330f, 0.24361561f, -0.14733756f, -0.00481920f, 
    -0.13457671f, 0.07567799f, 0.06247234f, 0.13451742f, -0.04199791f, 0.05680437f, 0.02380279f, -0.05106925f, 
    -0.02958158f, -0.09015977f, -0.00317932f, -0.00868874f, -0.03602203f, -0.06704976f, -0.09815042f, -0.18250801f, 
    -0.08661209f, -0.01194441f, 0.19178131f, -0.02640066f, -0.25968438f, -0.03925802f, 0.00737610f, -0.16009535f, 
    -0.02191356f, 0.08142516f, 0.04213985f, 0.00076843f, 0.08152066f, 0.02525487f, 0.03920261f, -0.01691440f, 
    -0.02124248f, 0.06544285f, -0.02334914f, -0.07862442f, 0.00449133f, -0.36405486f, -0.67745525f, 0.09484279f, 
    0.10783446f, 0.08122113f, -0.04241692f, 0.18836266f, 0.08041171f, 0.08732485f, -0.00131401f, 0.00540917f, 
    0.00231280f, -0.01186158f, -0.05030169f, 0.02569176f, 0.11017215f, 0.04102497f, 0.06321884f, 0.10814666f, 
    -0.07616644f, -0.00266298f, -0.09387449f, -0.01433934f, 0.03192065f, -0.03796628f, 0.00281990f, 0.08507615f, 
    -0.04198838f, -0.03671744f, 0.02844988f, -0.01074697f, 0.03195877f, -0.01045801f, -0.04328649f, 0.06354561f, 
    -0.08696905f, -0.05076919f, -0.08468150f, -0.08061279f, 0.02140763f, 0.19851021f, -0.36204690f, 0.01344369f, 
    -0.12055995f, 0.12509817f, 0.10302962f, 0.14962526f, 0.02038363f, 0.12999548f, -0.00573309f, -0.05068810f, 
    -0.10689592f, -0.05560264f, -0.00824604f, 0.01343886f, 0.03035568f, -0.00386118f, -0.01756638f, -0.09210706f, 
    -0.84030610f, 0.14351973f, -0.14210469f, 0.12325045f, -0.33561578f, 0.06047755f, 0.04383666f, -0.12418110f, 
    -0.20332831f, 0.04709381f, 0.00620859f, -0.10454905f, 0.04716117f, -0.03803212f, -0.05769159f, 0.05602890f, 
    -0.05247386f, -0.04318014f, -0.01950363f, -0.16557053f, -0.26065472f, 0.13023239f, -0.40875566f, -0.03071443f, 
    -0.20843196f, 0.05863360f, -0.08161502f, 0.09869178f, -0.05725430f, 0.00932713f, 0.03118924f, -0.05586657f, 
    -0.01903457f, -0.03885243f, -0.07007471f, -0.12473729f, 0.01830613f, 0.03990870f, 0.03550274f, -0.03687132f, 
    0.06199130f, 0.03942998f, 0.29720393f, -0.37851897f, -0.13335106f, 0.01897794f, -0.12022171f, 0.01669746f, 
    0.16304071f, 0.19107980f, -0.08610306f, 0.02367538f, 0.01518341f, -0.00229979f, -0.13766502f, 0.04278040f, 
    0.08004589f, -0.08025564f, -0.15230951f, 0.01070041f, -0.11279566f, -0.06833715f, -0.17724966f, -0.08189400f, 
    0.04858784f, 0.02807560f, 0.07830966f, 0.11360087f, 0.06853085f, 0.05056273f, 0.01651437f, 0.04540946f, 
    -0.02819818f, 0.02652295f, -0.06124425f, -0.00023050f, 0.05102400f, 0.06859263f, 0.06070215f, 0.03650745f, 
    -0.22987682f, 0.02673715f, 0.12764853f, 0.07512917f, 0.00323582f, 0.08018181f, 0.00871939f, 0.03943613f, 
    -0.06537108f, -0.12251945f, -0.05208644f, 0.04718251f, 0.01161916f, -0.04708454f, 0.02506993f, 0.07038535f, 
    -0.04747544f, -0.09177137f, 0.00178144f, -0.08848868f, 0.01529575f, -0.31331810f, -0.09189898f, -0.09800152f, 
    -0.01158923f, 0.13611686f, -0.13928419f, -0.02992621f, 0.11921845f, 0.01603024f, 0.01963579f, 0.02485294f, 
    0.05640136f, -0.02044908f, -0.00278841f, 0.07648900f, 0.04482827f, -0.03628186f, 0.13188533f, 0.18044049f, 
    0.06475292f, -0.00264989f, 0.12902734f, 0.18769605f, -0.39981002f, -0.05079607f, -0.00809781f, -0.05120025f, 
    0.07338830f, 0.10423526f, 0.01808590f, -0.00374599f, 0.01403219f, 0.01073801f, 0.01906699f, -0.05992011f, 
    0.06833664f, -0.01984455f, 0.04227523f, 0.04869959f, 0.12943588f, 0.02724974f, 0.18814448f, 0.33153909f, 
    -0.47365871f, 0.05306739f, 0.04628874f, -0.25107148f, 0.04784814f, 0.00900669f, 0.02288184f, -0.02489488f, 
    0.02699782f, 0.06089606f, 0.05651446f, 0.04072059f, 0.04980065f, 0.00121211f, 0.04491212f, 0.02236487f, 
    -0.18567863f, -0.05624756f, 0.13110109f, 0.36776415f, -0.16425057f, -0.05483014f, 0.12779777f, -0.20621495f, 
    0.08653405f, 0.00636363f, 0.04399110f, -0.07662883f, 0.03403934f, 0.01914494f, 0.09734689f, 0.05664187f, 
    0.02671022f, 0.00687855f, 0.01491877f, 0.04632825f, -0.08648328f, -0.56274033f, -0.26253238f, -0.62519336f, 
    -0.09968713f, -0.01686848f, -0.18314190f, 0.03872850f, 0.01696855f, 0.03773150f, -0.11867260f, -0.03307283f, 
    -0.01011274f, -0.10424591f, -0.01343193f, 0.08358836f, 0.25961444f, -0.01006522f, -0.03394209f, 0.15095988f, 
    -0.37366924f, -0.00836365f, 0.24343969f, 0.36218974f, -0.51372135f, 0.20802756f, -0.25393102f, -0.08210555f, 
    0.09706458f, 0.16542406f, 0.02871112f, 0.03238408f, 0.06419459f, 0.03398267f, -0.02133639f, 0.06751923f, 
    0.02610879f, 0.01865939f, 0.08883518f, 0.10132568f, -0.21821107f, 0.14935927f, -0.17425707f, -0.01579607f, 
    -0.09162083f, 0.07298584f, -0.04778491f, 0.11368106f, -0.03885096f, 0.02300928f, 0.07703029f, -0.00680744f, 
    -0.03417555f, 0.05232861f, -0.01443126f, -0.03747785f, 0.09028395f, -0.05257889f, -0.00562226f, 0.03606524f, 
    0.19527967f, -0.05475918f, 0.12746342f, 0.24078934f, -0.45039493f, 0.01938801f, -0.13863999f, -0.09472323f, 
    0.09995984f, -0.10807420f, 0.02651248f, -0.05175851f, 0.05763534f, -0.01619739f, 0.05783128f, 0.10506152f, 
    0.04643214f, 0.02896141f, 0.02918089f, 0.11325271f, 0.04859677f, -0.27754486f, -0.15086013f, 0.07611953f, 
    -0.38582349f, -0.21273749f, 0.08958375f, -0.08788574f, 0.04831147f, 0.00972057f, 0.08532208f, 0.01370465f, 
    0.03673268f, 0.05835531f, -0.04912123f, -0.04399350f, 0.08598562f, 0.06585410f, 0.02526255f, -0.04483396f, 
    -0.19936171f, 0.25901726f, -0.44424316f, 0.10025372f, -0.04254443f, 0.02893467f, 0.10557105f, 0.13550547f, 
    0.00218473f, -0.06526461f, 0.05318130f, 0.00026586f, -0.01592167f, -0.04419316f, -0.07776018f, 0.08821587f, 
    0.05579498f, -0.08626424f, 0.03780190f, -0.05208264f, -0.09185918f, 0.04701115f, 0.05835930f, -0.09514962f, 
    -0.10338645f, 0.05572698f, 0.00786323f, -0.01454083f, -0.01628086f, -0.02511799f, 0.10715953f, 0.05697096f, 
    -0.04466577f, 0.01592036f, -0.00058291f, 0.01647241f, 0.01883632f, 0.02315549f, 0.03939339f, 0.02825923f, 
    -0.18143599f, -0.21979468f, -0.06268929f, 0.20747726f, 0.17533155f, -0.20397134f, 0.20009464f, -0.13659324f, 
    -0.21826293f, 0.02724076f, 0.01733873f, -0.04744668f, 0.03385548f, 0.01064198f, 0.00366137f, 0.14658615f, 
    -0.02243989f, -0.05152274f, -0.06673518f, -0.07912997f, 0.14979674f, -0.36030430f, -0.16868699f, -0.09801211f, 
    -0.52604699f, 0.05013814f, -0.32434678f, 0.07045445f, 0.08673152f, 0.03966212f, -0.07981410f, 0.05048501f, 
    -0.01857581f, -0.00201601f, 0.12733394f, -0.06884275f, -0.03182241f, 0.08850791f, -0.02749701f, 0.14615397f, 
    -0.07215977f, 0.20284116f, 0.17186394f, 0.15881045f, -0.30123627f, -0.05062971f, -0.13265997f, 0.18091704f, 
    0.14298899f, 0.21508522f, -0.04792405f, 0.04738642f, 0.04000399f, -0.02601974f, -0.03253635f, -0.00091247f, 
    -0.00035143f, 0.00921965f, -0.03582108f, -0.26131850f, -0.16793177f, 0.14004607f, 0.10430986f, 0.42188847f, 
    -0.25006229f, 0.09524878f, 0.00237407f, -0.13972411f, 0.03460502f, -0.03952669f, 0.07851440f, -0.03724844f, 
    0.02432924f, -0.04825993f, 0.10523701f, 0.11545628f, 0.09252020f, -0.00726175f, 0.05618894f, 0.07474322f, 
    0.10947254f, 0.26322535f, 0.12718645f, -0.15275231f, -0.08441932f, -0.04443521f, -0.08451184f, 0.05086432f, 
    0.08234095f, 0.17979588f, -0.00830116f, 0.04191811f, 0.01380675f, -0.02787824f, -0.08857051f, 0.02155256f, 
    0.03898493f, 0.01124611f, -0.04221235f, 0.01220282f, 0.01016624f, 0.02220914f, -0.33379775f, 0.01198512f, 
    0.03044788f, 0.00702040f, -0.00670160f, 0.14378245f, -0.06147863f, 0.04918835f, 0.02612559f, -0.07087677f, 
    0.03410377f, 0.03525320f, -0.06994159f, 0.07745831f, 0.12406728f, 0.01278456f, -0.03877431f, 0.14342359f, 
    -0.31554720f, -0.05974752f, -0.51497293f, -0.11786154f, 0.10751896f, -0.09539504f, -0.19591764f, -0.05986720f, 
    -0.19848247f, -0.02672419f, -0.00890835f, 0.10854185f, 0.00423458f, 0.02373779f, 0.04034851f, 0.02684298f, 
    -0.05219578f, -0.11940595f, 0.03319248f, 0.01467859f, -0.12436046f, -0.24499127f, 0.05513166f, -0.03873278f, 
    -0.11775617f, -0.02142884f, -0.02045324f, -0.00020671f, 0.05057623f, -0.02554446f, -0.10634550f, -0.01355802f, 
    0.00251023f, 0.00051521f, 0.07755934f, 0.03267544f, 0.04430766f, 0.05202538f, 0.06991182f, 0.00663345f, 
    -0.29840854f, -0.05140062f, -0.40841252f, -0.14364183f, 0.05326362f, 0.00421071f, -0.00865943f, -0.13547136f, 
    -0.04535962f, 0.04571228f, -0.04378986f, 0.04793530f, 0.01095013f, 0.06543404f, 0.03417562f, 0.09314396f, 
    -0.04254199f, -0.12667821f, -0.08552928f, -0.10370706f, -0.40540370f, 0.07196925f, 0.14530152f, -0.02019263f, 
    0.06410529f, -0.04673494f, -0.07803317f, 0.13223639f, 0.13315462f, 0.04097543f, -0.08771235f, -0.02529533f, 
    0.04285413f, 0.09006093f, 0.01777704f, 0.11632183f, -0.05899551f, 0.09135201f, -0.02298344f, 0.08374761f, 
    0.11050922f, -0.06740859f, 0.12092543f, 0.09532359f, -0.12527278f, -0.02196985f, -0.09945545f, 0.11009871f, 
    -0.02091820f, 0.04917803f, 0.05146755f, 0.02153848f, -0.04537638f, 0.03861050f, 0.05447750f, -0.04269040f, 
    -0.00590275f, 0.02465430f, -0.01048445f, 0.04348725f, 0.00183613f, -0.17604083f, -0.15721422f, 0.08049424f, 
    0.03114914f, -0.06796880f, -0.05071158f, 0.00518887f, -0.09605710f, -0.05925054f, -0.06531277f, -0.03027176f, 
    -0.08134641f, 0.00981046f, 0.03610221f, 0.00144553f, -0.14391349f, -0.13803259f, -0.06716747f, -0.07782327f, 
    -0.28150335f, 0.07496759f, 0.06757585f, 0.12193742f, 0.15379727f, -0.10389416f, 0.04211642f, -0.12264520f, 
    -0.03210353f, -0.02401418f, -0.11926875f, 0.03124356f, -0.02233884f, 0.02674190f, -0.03378680f, -0.00168377f, 
    0.04835750f, -0.01739316f, 0.03631585f, 0.16548704f, -0.19661453f, -0.06871294f, 0.12738326f, -0.09290875f, 
    0.00774458f, -0.08007377f, -0.03487072f, 0.06416874f, 0.06556522f, 0.02678557f, 0.00303787f, -0.01666337f, 
    -0.07633159f, 0.05565942f, -0.01090946f, 0.05446453f, -0.04866694f, 0.03925667f, -0.00064275f, 0.04569758f, 
    0.16707656f, 0.04666424f, 0.05962485f, -0.08320869f, -0.10672369f, 0.03415782f, -0.00678936f, 0.00624389f, 
    0.08055902f, 0.00992811f, -0.11357168f, 0.12305618f, -0.08733968f, -0.12111575f, -0.23755178f, -0.02635108f, 
    -0.08564095f, 0.02545625f, -0.09480887f, -0.16356087f, 0.04356117f, -0.13247457f, 0.25368217f, 0.20585702f, 
    0.09377610f, -0.04835851f, 0.04115758f, 0.22671519f, 0.12494463f, -0.03008161f, 0.08048071f, -0.01689909f, 
    -0.11680840f, 0.02495115f, -0.06124242f, 0.07107908f, -0.01332156f, 0.13224488f, -0.01578748f, -0.01411146f, 
    0.00512180f, -0.04576218f, -0.23870263f, 0.02445460f, -0.00117480f, 0.04339130f, -0.12017030f, 0.19920947f, 
    -0.08778736f, 0.02698997f, 0.02393954f, 0.01060660f, 0.06239554f, 0.05332352f, -0.03980515f, 0.06100966f, 
    -0.04970593f, 0.05109952f, 0.00397556f, -0.00839768f, -0.17131752f, -0.16838293f, -0.10280802f, -0.08739085f, 
    0.03352122f, -0.00794005f, -0.04259556f, 0.05404832f, -0.34882313f, -0.17585514f, 0.04570627f, 0.06163381f, 
    0.06526653f, 0.00165903f, 0.01233195f, 0.13669880f, -0.10861669f, -0.19603743f, -0.36051634f, -0.29314053f, 
    -0.29706469f, -0.08106551f, 0.07595050f, -0.03387199f, -0.11150580f, 0.01868907f, -0.07857707f, -0.20428078f, 
    0.02333295f, 0.04678404f, -0.04855945f, 0.01184148f, -0.00950462f, 0.05859090f, 0.02732036f, -0.06571241f, 
    0.04873957f, -0.11863706f, 0.00726143f, -0.08940273f, 0.10790112f, 0.25943327f, -0.00707891f, 0.07820495f, 
    0.08893778f, 0.11049949f, -0.07263227f, 0.06944043f, -0.07692832f, 0.03183789f, -0.14268059f, 0.06202491f, 
    0.01911368f, -0.05824885f, -0.04194422f, -0.03304313f, -0.00382142f, -0.10837174f, -0.04133366f, 0.02445345f, 
    -0.51360762f, -0.25654018f, -0.02895736f, -0.09792919f, -0.08986461f, 0.02275399f, -0.01860571f, 0.07703411f, 
    -0.09580913f, 0.03088317f, -0.00887195f, -0.00556958f, 0.02118111f, 0.04272323f, -0.04265106f, -0.01252535f, 
    0.11609304f, 0.10835677f, 0.09799740f, 0.21676040f, 0.18021651f, 0.07842326f, 0.17905959f, 0.14271431f, 
    0.15065810f, 0.02051555f, 0.05149536f, 0.06390564f, -0.04065233f, 0.08475008f, -0.10266273f, -0.00019871f, 
    -0.09263148f, 0.04966085f, 0.08716206f, 0.04448922f, -0.07871179f, -0.01911043f, 0.03991079f, 0.08481260f, 
    0.01831775f, -0.15279442f, -0.01374316f, 0.03190008f, 0.05532632f, -0.07170387f, -0.09034576f, 0.00829444f, 
    -0.15379803f, -0.00469779f, -0.07083786f, 0.03294012f, 0.01753330f, 0.02289055f, 0.03194116f, 0.00066640f, 
    -0.07761026f, -0.12073982f, -0.09656042f, -0.01212697f, -0.09652873f, -0.00548790f, 0.07342923f, 0.02194498f, 
    0.05326880f, 0.08454186f, -0.06798273f, 0.10096060f, -0.01969004f, -0.07161392f, 0.01206251f, -0.01604340f, 
    0.17183226f, 0.03248364f, -0.00130368f, 0.00891729f, -0.08190332f, 0.11360957f, -0.04952369f, 0.05821434f, 
    -0.03254265f, -0.23704317f, 0.18176664f, -0.10639556f, -0.15313011f, -0.13213027f, -0.22587226f, -0.10705513f, 
    0.04864967f, -0.06192239f, -0.18008728f, -0.00004929f, 0.06326830f, -0.03963990f, -0.02402653f, -0.05521127f, 
    0.06325613f, 0.00183371f, -0.02117263f, -0.03953706f, -0.12654446f, -0.25214836f, 0.10747283f, -0.02330806f, 
    -0.11889839f, -0.14403023f, 0.08885210f, 0.05527616f, 0.03709207f, -0.03980656f, -0.03360699f, -0.07574743f, 
    -0.04749367f, -0.06963328f, -0.04121840f, -0.09918129f, 0.12370405f, 0.08907874f, 0.12914242f, 0.09146201f, 
    -0.00413316f, -0.18616760f, 0.16073219f, -0.01409817f, -0.22543089f, -0.08538142f, -0.10177189f, -0.07478490f, 
    -0.03400213f, -0.01984735f, -0.01738663f, -0.03922614f, -0.04304307f, -0.00615060f, 0.06910815f, 0.02795952f, 
    0.04719693f, 0.05926171f, 0.00569047f, 0.08905239f, -0.26041064f, 0.28666139f, 0.19035080f, 0.10819631f, 
    -0.11682422f, 0.05784342f, -0.08644457f, -0.11104365f, 0.20691983f, -0.06079776f, -0.13841189f, 0.01582292f, 
    0.04754794f, 0.08715363f, 0.07092796f, -0.09291978f, 0.08882236f, -0.02112712f, 0.23672964f, -0.01739064f, 
    0.14002509f, 0.07520676f, 0.16884544f, 0.04273017f, 0.07054707f, -0.02627207f, -0.02968513f, -0.12205237f, 
    0.08552941f, 0.07622237f, -0.07810441f, 0.09581221f, -0.06100110f, -0.08102720f, -0.10818771f, 0.08289734f, 
    0.09630017f, -0.03336862f, 0.15148012f, 0.04096828f, 0.08817971f, -0.09642216f, 0.25547996f, 0.21289738f, 
    0.10478192f, -0.09979611f, 0.03319510f, -0.02786282f, -0.05625360f, 0.02245684f, -0.11014111f, -0.08675780f, 
    -0.22039692f, 0.01018548f, 0.12355811f, -0.04589120f, -0.23428887f, 0.04152784f, 0.03337501f, 0.11462060f, 
    -0.30573520f, 0.14485002f, -0.09423480f, 0.25464600f, 0.06840174f, 0.05410554f, -0.10513782f, 0.11564931f, 
    0.15792605f, 0.09532447f, -0.03502963f, -0.03118942f, 0.00807889f, -0.06805304f, 0.01905407f, -0.07763327f, 
    0.12435375f, -0.08376665f, 0.12740919f, 0.23434325f, -0.04490335f, 0.13781609f, -0.08827713f, 0.04392796f, 
    -0.04575953f, -0.04211369f, -0.05483983f, -0.06892885f, -0.04056087f, 0.02110216f, -0.00961037f, 0.02280069f, 
    0.02590353f, 0.00699071f, -0.06916793f, -0.08684120f, -0.11693891f, -0.03577127f, -0.01099284f, -0.04931132f, 
    0.10600738f, -0.11846478f, -0.26260391f, 0.25108436f, 0.08188010f, -0.14861903f, -0.07247175f, 0.15433988f, 
    -0.20290297f, 0.06068640f, -0.00873797f, 0.05739673f, -0.22863619f, 0.13492997f, 0.06004156f, 0.11740156f, 
    -0.01731916f, 0.11431473f, -0.07268263f, 0.23963647f, -0.04476401f, -0.10845261f, -0.01537347f, -0.07226378f, 
    -0.03486637f, -0.13550206f, -0.02961234f, 0.00998056f, -0.07938634f, -0.15578574f, -0.06688490f, 0.06935141f, 
    -0.02223914f, 0.01006045f, 0.02989017f, 0.02173360f, -0.07703422f, -0.05912989f, -0.20247744f, -0.15926673f, 
    0.10395692f, -0.02354364f, 0.14301296f, 0.11344150f, 0.09879627f, -0.13261068f, 0.11522868f, 0.04999895f, 
    0.01162095f, -0.10500227f, -0.02360943f, -0.02518268f, -0.01468975f, -0.03135262f, 0.03055790f, 0.05766623f, 
    -0.10986423f, -0.02989559f, -0.09324591f, -0.22570966f, -0.04558535f, -0.33019257f, -0.17989124f, -0.02843452f, 
    -0.14841834f, -0.06430972f, -0.04048437f, -0.04981077f, -0.17157917f, -0.06931090f, -0.07881222f, 0.07357612f, 
    -0.11530341f, 0.05341442f, -0.02481429f, -0.16827039f, -0.06529334f, 0.07536358f, 0.00397563f, -0.03480168f, 
    -0.20990357f, 0.30452555f, -0.25107494f, 0.33681735f, 0.18612994f, -0.01373178f, -0.05826446f, -0.02437939f, 
    0.24048157f, 0.09075250f, -0.07312508f, -0.04586731f, 0.05051685f, 0.02071503f, 0.10015812f, 0.06785520f, 
    -0.02117084f, -0.18856570f, 0.20087893f, 0.06949145f, -0.01020700f, -0.00966190f, -0.42436084f, 0.00262966f, 
    0.06893010f, 0.01915497f, 0.02245304f, 0.13861194f, -0.06328773f, 0.08599989f, -0.07247294f, 0.04339122f, 
    0.00885791f, -0.03785190f, -0.02677738f, 0.03275139f, -0.01049355f, -0.16368103f, 0.01479917f, -0.02119190f, 
    -0.12536690f, -0.11229423f, 0.07752668f, -0.01138484f, -0.01764178f, 0.01186137f, -0.00996634f, 0.05738966f, 
    0.06252962f, 0.03097058f, -0.10844506f, 0.03124084f, 0.01416918f, 0.00343383f, -0.00642480f, 0.02102698f, 
    0.02618934f, 0.00512612f, -0.00404580f, -0.04153225f, 0.12867184f, 0.00316482f, 0.22271812f, -0.12874737f, 
    -0.04778136f, 0.11250743f, -0.12324129f, 0.08807518f, 0.01222697f, -0.01455367f, -0.09884363f, 0.00716597f, 
    -0.07171779f, 0.08538613f, 0.05130382f, -0.09851331f, -0.08610225f, 0.01211926f, -0.08414805f, -0.06032673f, 
    0.02835452f, 0.12871641f, 0.11312512f, 0.10992353f, 0.12050898f, -0.04507990f, -0.03489527f, -0.07728317f, 
    -0.02747580f, 0.10152175f, -0.19214553f, 0.12829651f, -0.06973788f, -0.17686468f, -0.08396097f, 0.02151516f, 
    -0.04769951f, -0.02793064f, 0.00483943f, 0.00866900f, -0.03693805f, -0.19835851f, 0.17145321f, 0.01865205f, 
    0.07414270f, -0.08677015f, 0.10785448f, 0.04059560f, 0.05376318f, -0.08135241f, -0.12160903f, 0.07062580f, 
    0.07393544f, 0.02104326f, 0.04871206f, 0.16165063f, -0.08037693f, 0.04213922f, -0.10575005f, -0.32244918f, 
    -0.10226834f, -0.18102153f, -0.06387413f, -0.10597926f, 0.11297251f, -0.22534552f, 0.04383681f, 0.23699152f, 
    0.04545516f, 0.07794710f, -0.04032088f, 0.07760961f, -0.15716389f, 0.05209268f, 0.10512871f, 0.06642175f, 
    -0.02906332f, 0.11026376f, -0.02841542f, 0.12134075f, -0.47836164f, -0.04708381f, 0.06765262f, 0.02514233f, 
    0.01430590f, 0.02287673f, -0.09149499f, 0.06103791f, 0.14938398f, 0.06415269f, -0.08947841f, 0.05931397f, 
    0.03036245f, 0.04915785f, -0.02268919f, 0.06766411f, 0.03047298f, -0.03971770f, 0.20754534f, 0.16476282f, 
    0.04735823f, -0.02177609f, -0.03816814f, -0.04414565f, 0.11706019f, -0.01017732f, 0.10786337f, 0.14247401f, 
    0.10208599f, 0.00192279f, -0.10500123f, 0.03863251f, 0.00099232f, -0.10775267f, -0.05308259f, 0.00653114f, 
    0.03225947f, 0.09409867f, 0.11566508f, 0.05767241f, -0.13647315f, -0.10784502f, -0.27752051f, -0.08681015f, 
    0.05367357f, -0.06793527f, -0.00593665f, -0.09688728f, -0.10222749f, -0.13288774f, -0.05697847f, 0.02910064f, 
    -0.03378604f, 0.04764346f, -0.03791907f, 0.11605362f, -0.19295403f, -0.20698452f, -0.24356639f, -0.17847553f, 
    -0.00159399f, -0.08240797f, 0.01678480f, 0.11090183f, -0.00833471f, 0.09788688f, 0.01655814f, -0.01338232f, 
    -0.05031656f, 0.06832214f, -0.04845845f, -0.08001743f, 0.08156563f, 0.03106528f, -0.02241601f, 0.01781087f, 
    0.08959898f, -0.00396804f, 0.14825509f, 0.01400803f, -0.15633836f, -0.21777336f, -0.24059394f, 0.02297267f, 
    -0.22369803f, -0.03482417f, -0.12873502f, 0.09371271f, -0.07821466f, 0.01865182f, -0.10081244f, 0.05811287f, 
    0.00390031f, -0.04362044f, -0.02100177f, 0.05223905f, -0.01776605f, 0.07127580f, -0.00371892f, 0.02093310f, 
    0.31220236f, -0.18403561f, 0.28618705f, 0.04840854f, 0.10271090f, -0.18658571f, 0.07787504f, 0.29930764f, 
    0.10140368f, 0.04345588f, 0.02610933f, 0.01903444f, -0.07051057f, -0.13126750f, -0.01453741f, 0.00341500f, 
    0.04846410f, 0.12247340f, 0.06301910f, 0.05159880f, -0.13617907f, -0.28476912f, 0.21025190f, 0.09136099f, 
    0.10073557f, -0.04377795f, -0.12032790f, -0.02620162f, 0.14084868f, -0.00246147f, 0.02987586f, -0.09559980f, 
    0.02969493f, -0.04531448f, -0.05773184f, 0.18582463f, 0.09476797f, 0.02432618f, 0.23692138f, -0.03824442f, 
    -0.09167596f, 0.05228291f, 0.13391121f, 0.17626426f, 0.00555754f, 0.06607085f, 0.05203337f, -0.05442329f, 
    0.00916699f, -0.01033549f, -0.15037082f, -0.08296766f, 0.04744283f, -0.03646755f, 0.03976296f, 0.05816698f, 
    -0.06337166f, 0.14794409f, 0.04078251f, 0.17297898f, 0.07627523f, -0.16583531f, 0.15428275f, 0.05031234f, 
    -0.06689303f, -0.16286859f, -0.05668731f, 0.02367715f, -0.09376580f, -0.10911571f, -0.07189043f, -0.01997648f, 
    -0.06562421f, 0.02322684f, 0.01964819f, -0.03902579f, -0.03542084f, -0.01061391f, -0.08863985f, -0.05506578f, 
    -0.28473219f, -0.26756230f, 0.04858700f, -0.04342622f, -0.02757163f, 0.05387834f, 0.08781458f, 0.01673214f, 
    0.06530856f, -0.03704097f, -0.03952154f, -0.06173250f, 0.07152174f, 0.00996183f, 0.15415047f, 0.12807921f, 
    0.00625057f, 0.06001650f, 0.07438590f, -0.05268383f, -0.39899647f, 0.11096871f, -0.16760400f, 0.11274287f, 
    -0.00746800f, 0.03281422f, 0.10536107f, 0.01197589f, 0.12750636f, -0.08170371f, -0.03040203f, 0.06624734f, 
    0.05762993f, 0.03812703f, 0.04066731f, -0.03433608f, -0.03004496f, -0.14194290f, -0.26096940f, -0.27159593f, 
    -0.23595393f, 0.07315610f, -0.22202381f, 0.02065160f, -0.00613591f, 0.06324615f, -0.02016638f, -0.01078045f, 
    -0.04592227f, 0.01255942f, -0.05519575f, 0.00701235f, -0.00357958f, -0.03605589f, 0.02253767f, 0.02011514f, 
    -0.02377529f, -0.01675601f, -0.04808933f, -0.01861303f, -0.03386377f, 0.11672579f, -0.15401323f, 0.02904237f, 
    0.10958514f, 0.01774981f, -0.04209158f, -0.04720291f, -0.01047459f, 0.04510919f, -0.09781307f, 0.06615267f, 
    -0.03678596f, -0.07528961f, -0.05285167f, 0.01293497f, -0.02367456f, -0.05999087f, -0.00331914f, 0.01905804f, 
    -0.07555263f, 0.11501744f, -0.10507501f, 0.05529946f, 0.10714088f, 0.14512016f, -0.05071943f, 0.10813142f, 
    -0.00984470f, 0.06302451f, -0.12268403f, -0.01070324f, -0.03404200f, 0.00204390f, 0.00276307f, 0.01590706f, 
    -0.10820024f, -0.08776011f, -0.05210243f, 0.00465627f, 0.13578945f, -0.03032692f, 0.25699002f, 0.18388847f, 
    -0.06873173f, -0.03141236f, -0.00202452f, 0.10135132f, -0.06735415f, -0.15587646f, 0.12752093f, 0.00657331f, 
    -0.16163315f, 0.17493507f, -0.08386528f, -0.04506554f, -0.09704732f, 0.11704472f, -0.36868370f, -0.15477742f, 
    -0.34373581f, -0.02417678f, -0.28432804f, -0.02644252f, 0.02491507f, 0.03082605f, -0.09321509f, -0.01250903f, 
    0.03323933f, 0.11386680f, -0.12486192f, 0.00395397f, -0.04531483f, 0.05722776f, 0.00791131f, 0.00809777f, 
    -0.06482127f, -0.00952071f, -0.07447185f, -0.02441857f, -0.02992263f, -0.05097042f, -0.06559576f, 0.09623945f, 
    -0.15110379f, -0.00938121f, 0.03202846f, 0.12141688f, -0.02666784f, 0.02752551f, -0.04585943f, -0.01672996f, 
    0.00185313f, 0.04130730f, -0.04636539f, -0.02043037f, -0.01787055f, 0.15502518f, 0.04260432f, 0.02375451f, 
    -0.29194456f, -0.03381480f, -0.00330833f, 0.19119281f, 0.15083224f, -0.02045633f, -0.00915030f, -0.08593772f, 
    -0.00710828f, 0.05608653f, -0.09121225f, 0.04368784f, -0.07892182f, -0.19975951f, -0.05951725f, 0.06420158f, 
    -0.10226887f, -0.00933066f, -0.00997283f, 0.09263799f, -0.17538445f, 0.02537402f, -0.58830041f, 0.03126605f, 
    0.02012201f, -0.01917416f, -0.01942478f, 0.05078300f, -0.12413882f, 0.02404867f, -0.04334809f, 0.06981545f, 
    0.01765307f, -0.06379618f, -0.02079948f, 0.06985454f, 0.02441553f, -0.16695678f, 0.00329907f, -0.04914635f, 
    -0.29998997f, -0.37720966f, 0.02747978f, -0.10785370f, -0.08554722f, -0.11094196f, -0.06342904f, 0.09772985f, 
    -0.00774913f, -0.03613494f, -0.09788533f, 0.05851141f, 0.01416428f, 0.00931169f, 0.03849005f, 0.03809770f, 
    -0.05613555f, 0.07558962f, 0.01886049f, -0.01276500f, -0.09692993f, -0.19196488f, -0.15952456f, 0.13595536f, 
    -0.14286581f, -0.07925600f, -0.07875851f, -0.12463442f, 0.09985135f, 0.03309870f, -0.10834327f, -0.06262320f, 
    0.11550697f, 0.06270900f, 0.01697595f, -0.00329911f, 0.05257590f, 0.05162944f, 0.17746781f, 0.06969330f, 
    0.32925451f, -0.07824677f, 0.05623788f, 0.11845161f, 0.09765305f, 0.15780185f, 0.06004884f, 0.11148273f, 
    0.00731979f, 0.05542936f, -0.04107046f, 0.05372217f, -0.06284902f, -0.00550420f, 0.02809985f, -0.02377741f, 
    0.02939116f, -0.05335480f, 0.10102618f, 0.03896071f, -0.27427888f, 0.05000943f, -0.16316783f, 0.06951185f, 
    -0.01108238f, -0.02029475f, -0.00712549f, 0.04790920f, 0.07493000f, -0.01270488f, 0.09730343f, 0.05536226f, 
    -0.11712250f, 0.10944046f, 0.00442847f, 0.05785356f, -0.07436577f, -0.01819231f, -0.18941897f, -0.02123365f, 
    -0.43077752f, -0.08074313f, 0.01533710f, -0.04581895f, 0.07349856f, 0.05047331f, -0.00842059f, 0.01611889f, 
    -0.14137267f, -0.07494677f, -0.02794270f, 0.06421530f, 0.03088557f, 0.06265196f, -0.00768950f, 0.00486485f, 
    0.03265569f, -0.06621961f, 0.08960544f, 0.13299096f, -0.10163198f, 0.14798491f, 0.01221822f, 0.05154484f, 
    -0.05791158f, 0.14707413f, -0.05918347f, 0.07686464f, 0.02207813f, 0.02733139f, -0.04597261f, -0.00643515f, 
    0.11665440f, -0.05228032f, -0.01264379f, -0.02681333f, -0.11419201f, 0.09670986f, -0.09475493f, -0.05190754f, 
    -0.19206475f, 0.04040521f, 0.15123585f, -0.01713178f, 0.01828456f, 0.04085492f, 0.00104198f, 0.10580214f, 
    -0.09438299f, -0.10151279f, -0.02735374f, -0.02902179f, 0.05405077f, -0.00777603f, -0.01745961f, -0.05374972f, 
    0.05089702f, 0.06119038f, -0.06519777f, -0.00597565f, 0.10685401f, -0.09221774f, 0.13972630f, 0.23234844f, 
    0.05175487f, -0.11757696f, 0.01619380f, 0.05468210f, -0.11336379f, -0.01771229f, -0.09500691f, 0.04521371f, 
    -0.09694199f, 0.06055754f, -0.00756829f, 0.00564330f, -0.24311726f, -0.00118703f, -0.01844959f, -0.07016991f, 
    -0.11360808f, -0.30063680f, -0.23075469f, -0.06080549f, -0.18500090f, -0.07480600f, -0.31285059f, -0.10529284f, 
    -0.19413589f, -0.04776205f, 0.04664094f, 0.04546847f, 0.04734975f, -0.08060890f, -0.07508354f, 0.02628738f, 
    -0.04999304f, 0.00247273f, -0.04177514f, -0.05293986f, 0.13042919f, 0.03111957f, 0.06974196f, 0.06303233f, 
    0.03263244f, -0.01140259f, 0.07155188f, -0.00363498f, 0.01583571f, 0.00585940f, -0.08269414f, 0.01391510f, 
    0.01333752f, -0.02996499f, 0.03952138f, -0.02073789f, -0.02369682f, -0.02397628f, -0.08667602f, 0.03102829f, 
    0.09257461f, -0.25435230f, -0.19288577f, -0.15063103f, -0.00831070f, -0.04679990f, -0.24091160f, -0.06421805f, 
    -0.01346949f, -0.11909383f, -0.01074392f, 0.00051432f, 0.07429626f, -0.05914372f, -0.09085844f, 0.05890843f, 
    -0.05074336f, -0.00036886f, 0.08378746f, -0.03496591f, 0.16346785f, -0.18399037f, 0.18282980f, 0.08019821f, 
    0.13855967f, 0.08184059f, -0.07302052f, 0.14029978f, 0.09476744f, -0.10663383f, 0.07901812f, 0.02029149f, 
    -0.06552929f, 0.05845571f, -0.03805452f, 0.06068310f, -0.03016487f, 0.10856770f, -0.04113485f, -0.10719616f, 
    -0.04341109f, -0.05825850f, -0.05258689f, 0.27427462f, 0.17414813f, 0.00840268f, 0.07185543f, -0.07111103f, 
    0.12601389f, 0.10878436f, -0.05824149f, -0.07621293f, -0.00686902f, 0.07188223f, -0.02695344f, 0.06194202f, 
    0.02595570f, -0.00637015f, -0.01941759f, -0.13641186f, 0.28096300f, 0.03075871f, 0.16922687f, 0.06806827f, 
    -0.13283117f, 0.00277763f, -0.09960931f, 0.07606190f, -0.05917630f, 0.03160859f, -0.05875961f, 0.01160061f, 
    -0.01322307f, -0.03975562f, -0.00405741f, -0.01015635f, 0.04034781f, 0.04822678f, 0.16139890f, 0.00775783f, 
    -0.29797789f, -0.22965549f, -0.26519266f, 0.29197544f, -0.00524196f, -0.06307366f, -0.03114616f, 0.05763401f, 
    -0.02864825f, -0.02832426f, -0.04465343f, -0.05451254f, -0.01985330f, -0.08118621f, -0.06127095f, 0.02489313f, 
    -0.10278468f, -0.04910525f, -0.04801815f, -0.14791475f, 0.04812106f, -0.13950786f, 0.22989264f, -0.01788056f, 
    0.16644114f, 0.15321459f, 0.08813201f, 0.00650420f, 0.01600327f, -0.03761306f, 0.02168585f, 0.01156465f, 
    0.02607965f, 0.02042427f, 0.00108707f, 0.07363632f, 0.04983124f, -0.01802934f, -0.05550047f, -0.03040893f, 
    -0.41695294f, 0.17483844f, -0.41319785f, -0.01285735f, -0.06025847f, 0.12139649f, 0.11149683f, 0.04405693f, 
    -0.06008241f, 0.03290090f, -0.07344599f, -0.13581543f, 0.03787909f, 0.09191427f, 0.02190474f, 0.00391451f, 
    -0.00157459f, -0.06507953f, -0.03662163f, 0.13288929f, -0.15942702f, -0.17134404f, -0.35717055f, 0.19555198f, 
    0.15984857f, -0.12983601f, -0.03571229f, -0.10309995f, 0.02049329f, 0.02359644f, 0.13136031f, 0.08642145f, 
    0.07345841f, -0.11792237f, 0.00687246f, 0.07988339f, -0.03675893f, 0.00460890f, 0.09983728f, 0.03179366f, 
    -0.15484816f, -0.14691308f, -0.05687893f, 0.08547511f, 0.08866072f, -0.07155328f, -0.14895734f, -0.14207841f, 
    0.02890583f, -0.04318847f, 0.05662011f, 0.01476321f, -0.06495900f, 0.01354171f, -0.06758463f, 0.09677770f, 
    0.01319495f, 0.08272668f, 0.12446302f, -0.04317869f, 0.27726662f, 0.01456785f, 0.13187219f, -0.00412613f, 
    0.00356737f, -0.07335258f, -0.17994294f, 0.00901743f, -0.15623128f, -0.18955320f, 0.03581866f, 0.04194831f, 
    -0.01975605f, -0.01771395f, -0.01161123f, -0.01773722f, -0.07130039f, 0.02445213f, -0.06031040f, 0.13230729f, 
    0.21571742f, -0.21218491f, -0.13602260f, 0.40254524f, 0.01836175f, -0.06453996f, 0.22751215f, -0.05780258f, 
    0.29119459f, -0.07760692f, -0.26745918f, -0.02630630f, 0.05836786f, 0.06906871f, 0.02214434f, -0.00665551f, 
    -0.06757052f, 0.11560369f, -0.07171887f, 0.00105789f, -0.53736496f, 0.07570709f, -0.29105768f, 0.27747661f, 
    -0.20937602f, 0.14119530f, -0.02780282f, 0.11961960f, -0.11883954f, 0.11494598f, -0.08966836f, -0.09432410f, 
    -0.02735605f, 0.07643583f, -0.03687676f, 0.05140005f, -0.10396440f, 0.05360287f, 0.03574802f, -0.02470055f, 
    -0.06262162f, 0.23681439f, 0.05693053f, 0.11896900f, -0.15166715f, -0.04226142f, -0.06204325f, 0.12472009f, 
    -0.14608908f, -0.03037995f, -0.11689100f, 0.05839946f, -0.05688007f, 0.04021013f, -0.01349342f, -0.02986460f, 
    -0.19723457f, -0.07060941f, -0.13513771f, -0.09475439f, -0.30839628f, -0.21186714f, 0.06082135f, 0.06922522f, 
    0.15064576f, 0.17967765f, 0.05155890f, 0.07241504f, -0.00662364f, 0.06198676f, 0.00208077f, -0.00558778f, 
    0.01129072f, 0.08493942f, -0.02487762f, 0.01541056f, -0.01387390f, -0.09579655f, -0.00912656f, 0.01131355f, 
    0.29402062f, 0.10726265f, 0.25247806f, 0.06063353f, -0.17100646f, -0.10151745f, -0.02049309f, -0.10438463f, 
    -0.00461648f, 0.01656134f, -0.09188127f, 0.03697647f, -0.05609436f, 0.02659288f, 0.00579906f, 0.00012561f, 
    0.08216130f, 0.11328844f, 0.03017821f, 0.11227374f, -0.08879515f, -0.05261077f, -0.02062926f, 0.22351548f, 
    0.13224161f, -0.23630810f, -0.06721357f, -0.04648490f, -0.15440853f, -0.05024039f, 0.06379441f, 0.03035404f, 
    -0.10077967f, 0.06177048f, 0.02697263f, 0.05472237f, 0.00199449f, 0.16674636f, 0.00766120f, -0.08300688f, 
    0.24626441f, 0.09438487f, 0.01913468f, 0.09870448f, -0.10560021f, -0.01588486f, 0.04144923f, -0.08368288f, 
    0.08737990f, 0.05336888f, -0.04532172f, 0.00790133f, -0.00777042f, -0.03549316f, -0.05158625f, 0.08307949f, 
    0.03086934f, 0.06751302f, -0.03610056f, 0.10851984f, -0.01526562f, 0.00065387f, -0.03254728f, 0.00660622f, 
    0.07619157f, -0.01178407f, 0.04512282f, -0.02561018f, 0.03257232f, 0.02705589f, -0.05607415f, 0.08356631f, 
    0.05455924f, 0.00578063f, 0.06475296f, -0.01438094f, -0.03474575f, -0.05943691f, -0.12824641f, -0.02245822f, 
    -0.01775521f, 0.05124695f, -0.07454388f, 0.00565766f, -0.01986852f, -0.04069122f, 0.05823395f, 0.05591290f, 
    -0.01937471f, 0.08161879f, -0.03116479f, -0.06843479f, 0.00047489f, -0.00583120f, -0.04264778f, 0.07708794f, 
    -0.03877475f, 0.04896184f, -0.06575080f, -0.10701939f, -0.41393337f, 0.13417532f, -0.24575049f, 0.22885418f, 
    -0.12046657f, 0.12422881f, 0.11104862f, 0.00890535f, 0.11204841f, 0.00292261f, -0.12313984f, -0.12735510f, 
    -0.03835332f, -0.02605297f, -0.02826591f, 0.11332230f, -0.04142215f, 0.01640255f, 0.00925790f, -0.01972898f, 
    -0.13781300f, -0.30619973f, 0.20657720f, -0.02436955f, -0.02561558f, 0.11415268f, 0.06951826f, -0.10534997f, 
    -0.03363730f, 0.09592794f, 0.00174601f, -0.04592661f, 0.04748803f, -0.09032913f, 0.07816199f, -0.04052840f, 
    -0.00264622f, -0.07874238f, -0.04578903f, -0.10309033f, 0.03484852f, -0.27683231f, 0.15427725f, 0.16549422f, 
    -0.03867807f, 0.13323744f, -0.00275531f, 0.17573304f, -0.03459400f, 0.06567683f, -0.02825554f, 0.03721157f, 
    0.00316108f, 0.02945214f, 0.00850901f, -0.04152869f, 0.06760048f, 0.13254431f, 0.06223527f, -0.06126124f, 
    -0.15013547f, 0.17262474f, -0.06406897f, 0.20638603f, -0.25868502f, 0.07045869f, -0.12605411f, 0.16354449f, 
    -0.02410599f, -0.05364237f, -0.07802076f, 0.06201416f, -0.01924080f, -0.03945647f, 0.02059389f, 0.03126709f, 
    -0.07222353f, 0.09832260f, 0.10327552f, -0.11339371f, -0.46420154f, -0.03980004f, -0.25494128f, 0.12109183f, 
    -0.17628548f, 0.05344553f, 0.14514944f, 0.05254773f, 0.13974126f, 0.02187260f, -0.15803771f, -0.05476932f, 
    0.11996277f, 0.13292696f, -0.05035879f, -0.00782837f, -0.01770382f, -0.00234529f, -0.02531599f, 0.07938243f, 
    0.07188814f, 0.07369475f, 0.08783209f, 0.16804987f, -0.21226919f, -0.09445713f, -0.03526704f, -0.06484025f, 
    -0.02079695f, 0.01376732f, 0.08027528f, 0.00643022f, 0.10260773f, -0.00398500f, -0.03634759f, 0.01879857f, 
    -0.06336961f, 0.04885942f, 0.12927140f, -0.11951838f, 0.20829853f, -0.12549827f, 0.04626332f, -0.01056417f, 
    0.02898357f, -0.03189835f, 0.03622218f, -0.10156138f, 0.02709009f, -0.12563562f, -0.09363251f, 0.01353791f, 
    -0.05672419f, -0.00832613f, -0.00244926f, 0.07749202f, -0.00277299f, 0.02474941f, -0.00153032f, -0.01684268f, 
    -0.02398843f, -0.39567310f, 0.26260215f, -0.15002780f, 0.28858960f, 0.04750871f, 0.10815641f, 0.07101320f, 
    -0.00111088f, -0.03077702f, 0.03473824f, 0.04182871f, 0.07165788f, 0.04359746f, 0.09219440f, 0.01561755f, 
    0.18314554f, -0.01128823f, -0.06621987f, 0.02966090f, -0.23708387f, -0.12292780f, -0.13366759f, -0.04650472f, 
    -0.09796944f, 0.04775550f, 0.04690249f, 0.05494440f, 0.04046157f, 0.00744255f, -0.10938178f, 0.04886600f, 
    0.06362362f, 0.03295429f, -0.07155454f, 0.00820035f, -0.03530354f, -0.03214332f, -0.07830615f, -0.05883434f, 
    -0.60395432f, -0.22656241f, -0.00063247f, 0.37492728f, -0.19300485f, -0.12209265f, 0.00212528f, -0.02014852f, 
    0.17998917f, -0.01017812f, -0.09269115f, -0.02980964f, -0.00019581f, -0.10342930f, 0.00081459f, 0.00584452f, 
    0.00273047f, 0.08641686f, -0.08477952f, -0.03830027f, -0.20347723f, -0.13708511f, -0.08154657f, 0.16754249f, 
    -0.11729947f, -0.05394888f, -0.10725788f, 0.05483134f, -0.09803835f, 0.02398641f, -0.01686518f, -0.00916685f, 
    -0.01856677f, -0.02174479f, -0.00928121f, 0.07168561f, 0.01749780f, 0.06003303f, 0.07857071f, 0.01966233f, 
    0.02272028f, 0.03889979f, 0.02285906f, 0.07091461f, 0.05136855f, -0.04464743f, 0.07810072f, 0.03132934f, 
    0.06790507f, -0.08686644f, -0.06535853f, -0.08283985f, -0.01299217f, -0.04627671f, -0.05136797f, 0.05991888f, 
    -0.03579371f, -0.02786119f, -0.02358852f, 0.01462969f, -0.40561745f, 0.00806576f, -0.18723090f, 0.08265115f, 
    0.09976267f, 0.08071656f, 0.04032379f, 0.18400761f, -0.15068386f, 0.01843083f, -0.01019752f, 0.02378156f, 
    -0.01377780f, 0.05987643f, 0.03934453f, 0.02049509f, 0.02517009f, 0.12647134f, 0.09332183f, -0.10667777f, 
    -0.28534979f, -0.32336584f, -0.08865210f, -0.04991112f, -0.50183040f, 0.09615851f, -0.07899202f, 0.03233383f, 
    -0.04760827f, 0.08113153f, -0.11980414f, -0.06427260f, 0.10606046f, 0.04002276f, -0.04142805f, -0.03506546f, 
    -0.01197552f, 0.07280687f, -0.00963029f, 0.00030680f, 0.36806461f, -0.68184918f, 0.43807501f, -0.24358663f, 
    0.19618550f, 0.07899915f, 0.11455382f, -0.31900194f, 0.12412120f, -0.05884394f, -0.08957449f, 0.01586287f, 
    0.04272497f, 0.02639585f, -0.03495302f, 0.10206793f, 0.11230315f, 0.08562180f, -0.08686537f, -0.02447845f, 
    0.06435166f, 0.05213384f, 0.04930656f, -0.09060110f, 0.27060002f, -0.06978001f, -0.09598444f, -0.06820416f, 
    0.12471031f, 0.04216006f, -0.03751208f, 0.13130027f, -0.00604234f, -0.07840423f, -0.00912967f, 0.14289813f, 
    -0.05996950f, -0.09701900f, -0.12330501f, 0.14361614f, 0.08080289f, 0.14585617f, 0.17494579f, 0.06417811f, 
    -0.11517059f, -0.09266300f, -0.23535255f, 0.02689025f, -0.07539870f, -0.11979806f, -0.03080088f, 0.05551669f, 
    -0.01392726f, 0.06184653f, 0.05930663f, 0.05552081f, -0.17443138f, -0.00536547f, 0.01403137f, -0.12469910f, 
    -0.21635224f, -0.19148296f, -0.08098038f, 0.10763752f, 0.00410364f, 0.01470326f, -0.22639066f, -0.17482257f, 
    -0.08131588f, 0.00642147f, 0.10603052f, 0.02372117f, -0.05875364f, -0.06241666f, -0.03123833f, 0.03327863f, 
    -0.05218797f, -0.03565882f, -0.02147265f, -0.01724054f, 0.36978784f, -0.24173343f, 0.24279283f, 0.04900040f, 
    -0.07643494f, -0.00054204f, -0.13673043f, -0.13321103f, 0.04371566f, -0.12579699f, -0.05286235f, 0.04074355f, 
    0.02346328f, 0.00557077f, -0.05204023f, 0.10666975f, -0.00143838f, -0.02391845f, 0.00879923f, 0.04153656f, 
    0.05022455f, 0.04379654f, 0.06098005f, -0.01684266f, 0.01637283f, -0.03822489f, 0.09292042f, 0.03995761f, 
    0.04212048f, 0.03353148f, -0.02276937f, 0.06617761f, -0.05681536f, -0.01802063f, -0.00552673f, -0.07288544f, 
    -0.08735093f, -0.03687670f, -0.00828592f, -0.16423491f, 0.29922214f, 0.08327986f, 0.30828339f, 0.00908842f, 
    -0.20055951f, -0.07335992f, 0.01431152f, -0.13679327f, 0.05189764f, 0.00085294f, -0.11011176f, -0.01518629f, 
    -0.01463737f, 0.06576423f, -0.01524282f, -0.03387773f, 0.06192495f, 0.01495208f, 0.05300178f, -0.01028091f, 
    -0.41060579f, -0.35347432f, -0.22542977f, 0.23521227f, 0.41416571f, 0.04002397f, 0.01150741f, -0.18750979f, 
    0.07876808f, 0.16149171f, 0.05259191f, 0.16820163f, -0.00828122f, 0.00596402f, -0.04191072f, -0.00860217f, 
    -0.02886661f, -0.00473851f, 0.03929888f, 0.11078723f, 0.24282226f, 0.04277922f, 0.23767941f, -0.11739537f, 
    0.12736320f, 0.03825674f, 0.17482574f, -0.02447257f, 0.02954573f, -0.00847985f, -0.00627428f, 0.09920982f, 
    0.06355251f, 0.01827425f, 0.04324277f, 0.03700694f, 0.06068682f, -0.12597460f, 0.04707772f, -0.13874206f, 
    -0.09185560f, -0.04391474f, -0.26882130f, 0.30913928f, 0.18885289f, -0.06062231f, 0.07849088f, -0.04370518f, 
    0.10842196f, -0.02737123f, -0.03088826f, 0.03951089f, -0.01946110f, -0.06753638f, 0.07347500f, -0.01944982f, 
    -0.04442399f, -0.04106740f, -0.02090809f, -0.03735019f, 0.16255669f, -0.00392120f, 0.06109335f, 0.01216563f, 
    -0.03043233f, 0.01006330f, -0.05130693f, -0.02481508f, -0.04228659f, -0.03971131f, -0.02057516f, 0.01826419f, 
    0.00527830f, -0.06932081f, -0.03483503f, 0.04149007f, 0.02619929f, 0.04469701f, 0.13401809f, 0.06030374f, 
    0.05595801f, -0.01508061f, 0.03441577f, 0.03114529f, 0.07099035f, -0.03674915f, 0.10127767f, 0.01861760f, 
    0.13557348f, -0.11415537f, -0.07158716f, -0.02501982f, 0.04072012f, -0.01778442f, 0.06001001f, 0.06441576f, 
    -0.04152997f, 0.06597835f, -0.01667117f, -0.05004007f, -0.26728791f, -0.13810094f, -0.32082084f, 0.03884882f, 
    -0.04225928f, -0.03837023f, -0.10280421f, -0.00059389f, 0.04667753f, -0.17004594f, -0.01679309f, 0.02538620f, 
    -0.03073686f, 0.02221290f, 0.01429355f, 0.14822118f, -0.08418643f, 0.10774330f, 0.09467802f, 0.05168653f, 
    -0.08284572f, -0.03884484f, -0.08521762f, 0.00337845f, -0.14789622f, -0.00792374f, 0.01877311f, 0.00865300f, 
    -0.10204788f, -0.02874333f, -0.00792429f, 0.03503755f, 0.10797243f, 0.06974123f, -0.01074191f, 0.03597413f, 
    -0.00604071f, 0.10782839f, 0.01469682f, 0.04324439f, -0.20144385f, -0.10324141f, -0.24436706f, 0.01918166f, 
    -0.39425722f, -0.02096377f, -0.07120656f, -0.01039942f, -0.04228023f, -0.00126080f, -0.09525131f, -0.03267146f, 
    0.11272950f, -0.02288691f, -0.05947961f, 0.01471784f, -0.00585248f, 0.00739677f, -0.00946764f, 0.03435015f, 
    -0.18841808f, 0.05682854f, -0.12407290f, 0.09934197f, -0.16045338f, 0.07438115f, 0.03336613f, 0.03838607f, 
    -0.17297652f, 0.04720487f, 0.03643693f, 0.01155995f, 0.12966996f, 0.09376249f, -0.05482351f, 0.03335144f, 
    -0.04532220f, 0.09252612f, -0.00016028f, 0.00384024f, -0.37210980f, 0.06949901f, -0.64033997f, 0.35463580f, 
    0.36838666f, 0.09854376f, 0.29479420f, -0.16508798f, -0.01053573f, -0.10877787f, -0.07388657f, 0.08759643f, 
    0.05925480f, 0.08670634f, 0.03353067f, 0.10186353f, 0.03154272f, -0.01149413f, 0.10842344f, 0.13541321f, 
    0.07624209f, -0.24290310f, -0.20385465f, 0.01488990f, 0.04918538f, -0.22430769f, 0.04829946f, -0.05000890f, 
    -0.07531822f, 0.02131300f, 0.01262996f, 0.02887003f, 0.11484178f, -0.05702798f, -0.07564045f, 0.02345892f, 
    -0.00059259f, 0.03144105f, 0.07799900f, -0.05805344f, 0.16964042f, -0.13101529f, 0.17597757f, -0.04562959f, 
    -0.03328805f, 0.00743791f, 0.07854796f, -0.14952855f, 0.11441167f, 0.02456091f, -0.02056027f, 0.07833540f, 
    -0.08908054f, 0.00110093f, -0.00263470f, 0.00572022f, 0.07857947f, -0.02251219f, -0.00034910f, -0.06382267f, 
    0.00372368f, -0.21892668f, 0.22395958f, 0.09084199f, -0.34270260f, 0.09268498f, 0.03570773f, -0.06785976f, 
    -0.13766018f, 0.12389375f, -0.05398552f, -0.05622251f, 0.16589335f, 0.10601073f, -0.04647470f, 0.03326092f, 
    -0.00209308f, 0.08060897f, 0.05864590f, -0.00878785f, -0.18635203f, -0.13456975f, -0.17039943f, 0.11372732f, 
    -0.23838378f, -0.10356532f, -0.03202765f, 0.05671970f, -0.16546874f, -0.02640550f, -0.02934231f, -0.00919540f, 
    0.05263082f, 0.04473017f, 0.01450677f, 0.06820621f, 0.04865262f, 0.08231279f, -0.00715752f, 0.03682627f, 
    0.27252042f, 0.07053368f, 0.26165092f, -0.13138567f, -0.06454646f, 0.02359742f, 0.08508339f, -0.07085439f, 
    0.02702069f, -0.00762561f, -0.05942083f, 0.05686280f, 0.03047795f, 0.02025273f, -0.00527617f, -0.07273138f, 
    0.00563406f, -0.07804328f, -0.13413897f, 0.08546285f, 0.03242716f, 0.00795899f, 0.14367792f, -0.01955479f, 
    -0.11699431f, -0.03452785f, 0.05697111f, 0.04866696f, 0.06325656f, 0.02617876f, -0.04764488f, 0.04963374f, 
    -0.01160071f, 0.01696517f, -0.00742761f, -0.08534715f, 0.06049655f, 0.07613558f, -0.15578835f, -0.15217407f, 
    -0.38865873f, -0.10442325f, -0.06862462f, 0.18741219f, 0.08134987f, 0.07816004f, 0.03754726f, 0.09332645f, 
    -0.05224177f, 0.10911810f, -0.17323850f, 0.01966795f, -0.01394789f, 0.02494623f, -0.10367785f, 0.04393522f, 
    -0.04628480f, -0.00192372f, 0.02188694f, -0.11595242f, -0.25367269f, -0.37614167f, 0.18096738f, -0.01195399f, 
    -0.31126508f, -0.11301014f, -0.12767825f, -0.07660095f, 0.05357131f, -0.19762644f, -0.09567750f, -0.00943886f, 
    0.04537355f, 0.03149613f, 0.06761558f, 0.07288970f, -0.05924606f, 0.12460143f, 0.11657631f, -0.03594238f, 
    -0.04304412f, -0.23265046f, -0.08886386f, -0.23818778f, -0.06836718f, -0.02666206f, -0.28360102f, 0.00672992f, 
    -0.13912991f, -0.10476446f, 0.00987747f, 0.03094253f, 0.01164836f, 0.01967610f, 0.02737463f, 0.01814955f, 
    -0.01742735f, 0.00767790f, 0.04525820f, -0.13892199f, -0.01634418f, -0.04849492f, -0.24015264f, -0.10815997f, 
    -0.06610306f, 0.08905391f, 0.13147318f, 0.04833944f, -0.15088950f, 0.02675013f, 0.07920729f, 0.04332809f, 
    0.10467909f, 0.14949170f, -0.04338203f, -0.02865979f, 0.08916704f, 0.09547553f, 0.01001936f, 0.05828827f, 
    0.04760372f, -0.24317084f, -0.01809508f, 0.19148888f, 0.10443957f, -0.06855948f, -0.13991760f, -0.08577124f, 
    -0.05964435f, -0.05691483f, 0.05696124f, 0.08231451f, -0.01735510f, 0.06301416f, 0.04086578f, -0.00817658f, 
    -0.04817570f, 0.02439737f, 0.12882623f, -0.02477472f, 0.02887060f, -0.26200303f, 0.04795815f, -0.11495959f, 
    -0.03846662f, 0.04001870f, 0.03947152f, -0.04536111f, 0.02049424f, -0.00550603f, -0.01932836f, 0.04150387f, 
    -0.07004632f, -0.01756562f, 0.03646931f, 0.14795668f, 0.02457283f, 0.06131086f, 0.08427084f, -0.04852063f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12733921f, 0.09986219f, 0.04483022f, -0.09031856f, -0.04150522f, 0.03630816f, 0.03490620f, -0.05239275f, 
    0.04991477f, 0.05724764f, -0.00397901f, 0.01369239f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
