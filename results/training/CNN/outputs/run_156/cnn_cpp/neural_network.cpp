#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.52318120f, -0.62535584f, -0.44872910f, 0.51735669f, 0.39019161f, 0.59280854f, 0.23905589f, -0.10976813f, 
    0.46855140f, 0.12767729f, 0.12892924f, -0.03352573f, -0.15976988f, -0.71773183f, 0.38432267f, 0.14578125f, 
    -0.66247517f, -0.36118364f, 0.70026356f, 0.40538463f, 0.57574505f, 0.25925967f, -0.60341549f, 0.41465563f, 
    -0.24715979f, -0.08200286f, -0.02650261f, -0.05415054f, 0.25883442f, -0.12457818f, -0.54009640f, -0.46912897f, 
    -0.84481329f, 0.14248006f, -0.20018408f, 0.13652496f, -0.15150025f, -0.27270705f, -0.49987388f, 0.53673542f, 
    -0.22083475f, 0.36642754f, -0.35469306f, -0.06330035f, -0.23673911f, -0.09901784f, 0.30611166f, 0.67091650f, 
    0.57764030f, 0.40831357f, 0.33230829f, 0.08082320f, -0.40604264f, 0.17853101f, -0.79372150f, -0.19680823f, 
    0.50761771f, -0.58303493f, 0.19293900f, 0.34189308f, -0.36866260f, -0.30949059f, 0.27318415f, 0.35838485f, 
    0.62822968f, -0.59785503f, -0.37209550f, -0.75052536f, 0.08552645f, -0.44808742f, 0.01544975f, -0.13588634f, 
    0.59430414f, 0.54197937f, 0.48826399f, -0.39032432f, 0.00318142f, -0.48295039f, -0.41167784f, 0.34105375f, 
    -0.02133831f, 0.70941311f, -0.33076689f, 0.35143557f, -0.50596547f, 0.42208195f, -0.21502230f, 0.01462665f, 
    0.23598535f, 0.44794407f, 0.01976428f, -0.63124251f, -0.47085720f, -0.15083347f, 0.32834259f, -0.46366856f, 
    0.04278344f, 0.11685429f, 0.40012133f, -0.71938783f, 0.18995818f, 0.35938847f, 0.02351715f, -0.56819314f, 
    -0.08587953f, -0.04578387f, 0.04081384f, 0.60051453f, -0.14824995f, -0.82995349f, -0.42986405f, -0.71785688f, 
    -0.74260855f, -0.41615456f, 0.23107445f, 0.27306774f, 0.24445184f, -0.54123652f, -0.30119416f, -0.50050557f, 
    0.01045992f, 0.86540902f, -0.15249933f, -0.10746786f, -0.31201065f, -0.34983581f, -0.83167267f, 0.46535629f, 
    -0.02025365f, 0.36096263f, 0.73117781f, 0.38131547f, 0.36113289f, -0.24738167f, 0.25170690f, 0.42350453f, 
    0.38399714f, 0.53295618f, 0.36778930f, 0.08720338f, 0.48491776f, 0.34458745f, 0.43342376f, -0.00814303f, 
    0.28581148f, 0.52185428f, 0.27583569f, 0.00383931f, -0.18221478f, 0.39716545f, -0.55638093f, 0.06956222f, 
    -0.36656183f, 0.89546674f, -0.80525249f, 0.27077994f, 0.10803166f, -0.22357535f, 0.42122656f, 0.08417847f, 
    -0.42498729f, 0.06715860f, 0.61837220f, 0.08239563f, -0.71109498f, -0.32580709f, 0.59138435f, -0.65406072f, 
    0.22058997f, 0.37437961f, 0.39747119f, -0.90041804f, 0.41562313f, 0.12933706f, -0.23911093f, 0.32911456f, 
    -0.22870170f, -0.01041496f, 0.45473468f, -0.07304253f, -0.57618833f, 0.39438576f, -0.22751456f, -0.45922193f, 
    -0.46429634f, -0.54382926f, -0.52516216f, -0.02510251f, -0.09909359f, -0.17859770f, -0.17952651f, 0.23944205f, 
    -0.48802039f, 0.23995166f, -0.37445831f, 0.39372021f, -0.61000472f, -0.67277050f, -0.82848871f, -0.55025893f, 
    -0.13386238f, 0.25426185f, -0.04396667f, -0.02440827f, 0.42317903f, 0.16180632f, -0.02885175f, -0.33112523f, 
    0.43018916f, 0.71330714f, 0.62804621f, -0.44357875f, -0.30969891f, 0.00011733f, 0.15441710f, 0.27900290f, 
    -0.14333825f, -0.29340833f, 0.25930074f, 0.67076695f, 0.64223570f, 0.18672974f, 0.08271733f, 0.36170894f, 
    -0.00508906f, -0.44094929f, -0.37706017f, 0.37108722f, 0.35683373f, 0.69174486f, -0.76712036f, -0.02112928f, 
    0.11013778f, -0.32697001f, -0.14017956f, -0.43611962f, -0.40809312f, -0.42289436f, -0.02052498f, 0.27208069f, 
    -0.46100879f, 0.20320216f, -0.30587018f, 0.35175940f, 0.93586177f, -0.08874166f, 0.82442880f, -0.42217883f, 
    -0.37234533f, -0.10769778f, -0.38772732f, -0.11416142f, 0.55368030f, 0.67552000f, 0.65900028f, -0.21370144f, 
    -0.31972057f, -0.15292476f, 0.40829104f, 0.02337767f, -0.07717913f, 0.69687080f, 0.06905303f, 0.49753645f, 
    0.39327234f, 0.58088756f, 0.01051616f, -0.60983837f, 0.05362439f, 0.27381855f, -0.26404509f, 0.53023368f, 
    -0.47814733f, 0.15397264f, 0.74913990f, 0.43477553f, -0.27275300f, -0.36291015f, -0.44749558f, 0.26345995f, 
    -0.34747618f, 0.39649528f, 0.56006491f, 0.02521275f, 0.43073255f, 0.44518051f, -0.30916595f, -0.47702488f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02126005f, 0.18660092f, -0.10187344f, 0.07107325f, -0.27782062f, 0.18182412f, 0.03981834f, -0.31254274f, 
    -0.19613644f, -0.25095484f, 0.06874146f, -0.21726273f, 0.06003834f, -0.10801489f, -0.15576492f, 0.15299937f, 
    0.28284416f, 0.02059986f, -0.09130824f, 0.25872979f, 0.30545330f, -0.35361215f, 0.05728637f, -0.09330598f, 
    0.14322451f, -0.19570999f, -0.17857380f, -0.17875327f, -0.13142085f, -0.48429623f, -0.17828509f, -0.28253949f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.00447160f, -0.01298836f, -0.30843255f, 0.31640324f, 0.13669419f, 0.26376119f, 0.02383487f, -0.11494119f, 
    -0.15964489f, 0.05449683f, -0.06364255f, 0.14098291f, -0.12621622f, -0.01530457f, 0.03331939f, 0.28837949f, 
    0.17375487f, 0.13225743f, -0.03102365f, 0.09464245f, 0.20345525f, 0.02650410f, -0.11667124f, -0.01837085f, 
    0.27932286f, -0.06912452f, -0.03079686f, 0.08675057f, 0.04501113f, 0.09740039f, -0.11633061f, 0.02995548f, 
    0.17348897f, 0.01065876f, 0.22070779f, 0.12676895f, -0.12179817f, -0.04509201f, -0.01932784f, 0.12391693f, 
    0.15390970f, 0.12279724f, -0.16984537f, -0.19401738f, -0.07059001f, 0.20481469f, 0.10788704f, 0.09480536f, 
    0.18175584f, -0.00856341f, 0.01914927f, 0.20731752f, 0.04050638f, -0.18813473f, -0.05989806f, -0.06843556f, 
    -0.03487134f, -0.02545997f, 0.07403450f, 0.09887895f, 0.03792651f, -0.01850209f, -0.00270997f, 0.10802399f, 
    0.02364446f, 0.18255214f, -0.17865069f, -0.16755651f, 0.00978941f, -0.14499296f, -0.01745185f, 0.20241994f, 
    0.06203033f, 0.11398944f, 0.10762534f, -0.02579100f, -0.09259398f, 0.08665086f, -0.19263011f, -0.02693672f, 
    0.05368195f, 0.00016805f, -0.00479859f, -0.09056205f, -0.28312200f, -0.08206162f, 0.05450108f, -0.09431882f, 
    -0.21815601f, -0.21699284f, -0.10902846f, -0.00965522f, 0.19799072f, 0.10810420f, 0.05267737f, 0.06659359f, 
    0.03697994f, -0.08065402f, -0.01900708f, -0.06897534f, -0.12341686f, -0.08736482f, 0.13685429f, 0.00288247f, 
    0.10169905f, 0.04241231f, -0.01749984f, 0.08958615f, 0.03604604f, 0.04820677f, 0.01795223f, 0.39476129f, 
    0.05136399f, 0.21982762f, 0.11871546f, -0.15633285f, -0.07582176f, -0.04222388f, -0.00210752f, -0.12341044f, 
    0.08302363f, 0.21182166f, 0.07488448f, -0.13321856f, -0.14657472f, -0.10702421f, 0.10997067f, 0.00180504f, 
    0.05990204f, 0.03731655f, 0.12888539f, 0.12688467f, 0.11265483f, -0.09017933f, -0.18692864f, -0.14281219f, 
    -0.03693829f, 0.03429447f, 0.16277248f, 0.10031047f, 0.03052885f, 0.02854261f, -0.02265390f, -0.20211925f, 
    0.00796549f, 0.14281422f, 0.32564089f, 0.03302378f, -0.00246600f, -0.03334278f, 0.20534508f, 0.05285306f, 
    0.14071919f, 0.20886081f, -0.35307282f, -0.06855749f, 0.05460377f, -0.07408074f, 0.05756958f, -0.19473594f, 
    -0.09456684f, 0.09275657f, -0.16437125f, -0.01588693f, 0.05687313f, -0.08391212f, -0.01635289f, -0.06261600f, 
    -0.12051035f, -0.05815206f, -0.29094234f, -0.04164431f, -0.06276822f, 0.18047117f, 0.16401955f, 0.06813318f, 
    -0.03196693f, 0.03569520f, 0.02272914f, -0.00531349f, 0.09507915f, 0.13622864f, 0.12314773f, 0.02593081f, 
    0.15157580f, 0.08110793f, 0.06024697f, 0.10074244f, 0.23102330f, -0.14529639f, 0.07589594f, -0.08080427f, 
    -0.07002449f, 0.13818386f, -0.00966755f, 0.19487518f, 0.19078431f, 0.10679057f, -0.32036278f, -0.11259395f, 
    -0.01411850f, 0.22338022f, 0.21878006f, 0.04854434f, 0.01518159f, -0.12394884f, 0.01053687f, -0.00689847f, 
    -0.04691508f, -0.04153619f, 0.00673470f, 0.07257340f, 0.06626569f, 0.04529626f, -0.08558074f, 0.06316698f, 
    -0.09645632f, -0.17564335f, 0.14266507f, 0.23097143f, 0.13232300f, 0.02137029f, 0.00685969f, -0.13857540f, 
    -0.08320852f, -0.32525703f, -0.00518575f, -0.06777257f, 0.10636800f, -0.00458482f, -0.00007320f, -0.08119839f, 
    -0.01407449f, 0.11771025f, -0.00866481f, 0.00426842f, 0.10586534f, 0.09044477f, 0.17829792f, -0.03991578f, 
    -0.10863376f, 0.12153839f, -0.08329971f, 0.02567713f, -0.07033760f, 0.24377884f, -0.20158508f, 0.04367834f, 
    -0.02851779f, 0.07917927f, 0.04909469f, -0.05713454f, 0.11928335f, 0.02948630f, 0.25333342f, -0.25971934f, 
    -0.11656523f, -0.09353478f, -0.03252260f, 0.06944165f, 0.11595872f, -0.13853633f, 0.16984591f, -0.02582913f, 
    0.06674186f, -0.11577050f, -0.06617012f, 0.24773172f, 0.07005118f, 0.05116557f, 0.23782513f, 0.13137822f, 
    0.10346622f, -0.03543606f, 0.03547857f, -0.01052164f, 0.01535802f, 0.09047784f, -0.04421601f, -0.13037857f, 
    -0.15473610f, 0.00318063f, -0.01296329f, 0.05792693f, 0.23807390f, 0.17034195f, -0.06362177f, -0.12614541f, 
    0.02924041f, 0.01396097f, 0.15364315f, -0.09585709f, 0.01882360f, -0.08929045f, 0.01278184f, 0.11010332f, 
    0.07737051f, -0.13351251f, -0.08891902f, 0.02843665f, 0.03410897f, 0.05469385f, -0.08217862f, 0.00477698f, 
    -0.10614844f, 0.13510932f, -0.13716333f, -0.01350563f, 0.12573576f, 0.10718270f, 0.17931184f, 0.04120473f, 
    -0.06620166f, -0.01560611f, -0.06473557f, -0.02523015f, -0.22227752f, -0.15749110f, 0.05601826f, 0.05704368f, 
    -0.09445130f, 0.10039888f, 0.08439552f, 0.14302982f, -0.02390577f, 0.06591149f, 0.10917028f, -0.02999454f, 
    -0.20530838f, -0.12233041f, -0.04932118f, 0.01640551f, 0.08583216f, 0.08585776f, 0.00941407f, 0.11252084f, 
    0.04483732f, 0.04024370f, -0.08307873f, -0.09521551f, -0.06492845f, 0.02138071f, -0.05582541f, -0.15066303f, 
    0.34252894f, 0.14133471f, -0.07073120f, -0.07598186f, -0.06890653f, 0.03798969f, 0.03198371f, 0.20289665f, 
    -0.04644134f, -0.22552016f, -0.05037368f, -0.08343703f, -0.08443147f, 0.02717816f, -0.02119921f, -0.01102889f, 
    -0.26572725f, -0.48092610f, -0.10809075f, 0.14579129f, 0.13347608f, 0.00457523f, -0.09309971f, -0.02197083f, 
    0.00448264f, -0.14202382f, -0.05491010f, 0.05633822f, -0.02018023f, -0.13028114f, 0.10967125f, 0.07476909f, 
    -0.00637236f, 0.21265067f, -0.07823349f, 0.25185940f, -0.02347755f, -0.08682146f, -0.08918360f, 0.05645504f, 
    0.10486002f, 0.08405744f, -0.01816309f, -0.08690308f, 0.04313670f, 0.05653587f, -0.07971595f, 0.05317464f, 
    -0.11628632f, 0.11159592f, -0.10034578f, 0.11306755f, -0.14292882f, 0.16432501f, 0.04930735f, -0.36199683f, 
    0.03509763f, -0.08848970f, -0.09969145f, -0.01711404f, 0.22836766f, -0.08962985f, 0.02644049f, 0.13998769f, 
    -0.20313373f, 0.09363859f, -0.02021885f, 0.12309587f, -0.03923010f, -0.18209656f, 0.12456445f, -0.00502303f, 
    0.01059522f, -0.12128483f, 0.15637141f, 0.03526656f, -0.10101752f, -0.02855393f, 0.07847095f, 0.13976088f, 
    0.02854981f, -0.03795795f, 0.26111221f, -0.02637175f, 0.10133003f, 0.07425690f, -0.05386716f, -0.06116606f, 
    -0.02239278f, -0.06113737f, 0.08615126f, 0.13508739f, -0.00906469f, -0.06028325f, 0.03848877f, -0.03375463f, 
    -0.02402043f, -0.30559310f, 0.22013396f, 0.04748417f, -0.01527090f, -0.09498171f, -0.01620024f, 0.16081266f, 
    -0.01638719f, -0.00818781f, 0.07747559f, 0.12586652f, -0.08614739f, -0.07916869f, -0.09790147f, -0.01084678f, 
    0.03249956f, 0.00275811f, 0.00664032f, 0.05534891f, -0.00856361f, 0.11240842f, 0.06045511f, 0.03378601f, 
    0.00320642f, 0.06007528f, 0.08541266f, -0.02974909f, -0.15203364f, -0.18619615f, -0.03747987f, 0.06805865f, 
    0.10063846f, -0.06383543f, 0.17634293f, -0.06781930f, -0.00671463f, 0.00483960f, -0.09348314f, -0.19236374f, 
    0.07562893f, -0.20028432f, 0.00122677f, 0.04218118f, -0.03663705f, -0.20836195f, -0.11388373f, 0.02596164f, 
    0.19975148f, -0.00449817f, -0.04359449f, -0.17630370f, 0.02861077f, 0.03003903f, -0.15819310f, -0.07218492f, 
    0.10330679f, 0.00531465f, -0.00462118f, -0.07281520f, -0.04962815f, 0.13545045f, -0.09471797f, 0.07445877f, 
    0.04039012f, 0.06365801f, 0.02278922f, -0.01901480f, -0.05669795f, -0.00150504f, -0.00409306f, 0.06866294f, 
    -0.09021056f, -0.07179490f, -0.01525402f, 0.14950022f, -0.00023045f, -0.02039072f, 0.10763595f, -0.02815186f, 
    0.04918328f, 0.15972878f, -0.24441174f, 0.28259027f, -0.04425466f, 0.13342227f, -0.05260706f, -0.02272747f, 
    -0.02344250f, 0.08788995f, -0.02409575f, -0.37007752f, -0.11049362f, 0.06500709f, -0.08978679f, 0.08720268f, 
    -0.05026756f, 0.05632772f, -0.18558469f, 0.13212503f, 0.10357963f, -0.12689640f, -0.14991936f, 0.17455393f, 
    -0.00061870f, 0.02588649f, 0.04580156f, -0.07584227f, -0.04321405f, 0.12497483f, -0.20264074f, 0.04951962f, 
    0.00462172f, -0.05237529f, -0.28764096f, -0.07439568f, 0.07328809f, -0.00899103f, 0.18299428f, 0.00056636f, 
    -0.09228040f, -0.08004223f, -0.06832564f, -0.18663976f, -0.07567126f, -0.07558165f, 0.04594480f, -0.10668976f, 
    0.14727856f, 0.01137771f, 0.09522163f, 0.00885252f, -0.07245908f, 0.04030439f, -0.06027384f, -0.13313654f, 
    0.27242157f, 0.06360262f, 0.02372833f, -0.01742538f, -0.04363489f, -0.01484033f, 0.06012444f, 0.13885221f, 
    0.00730587f, 0.25609526f, -0.03436452f, -0.12049667f, 0.03372424f, 0.03574087f, 0.11497463f, 0.07188572f, 
    -0.14583260f, -0.01837354f, -0.11959587f, -0.24984130f, -0.20594643f, 0.02705389f, 0.10061410f, 0.09254557f, 
    -0.04047820f, -0.08147255f, -0.16442932f, 0.13888578f, 0.23679072f, -0.14208373f, 0.14485444f, 0.01988505f, 
    0.00246206f, -0.10943665f, -0.06651330f, 0.01022716f, 0.14065498f, 0.12314764f, 0.23641890f, 0.09214442f, 
    0.06644407f, 0.04674505f, -0.10242006f, 0.14134067f, -0.04986764f, -0.04320360f, -0.17284647f, 0.07358585f, 
    0.06842971f, 0.02171633f, 0.07316442f, 0.06928818f, -0.00805051f, -0.21846096f, -0.27995104f, 0.02068516f, 
    0.14996664f, -0.16920882f, -0.09306125f, 0.07936393f, 0.06573468f, -0.08052745f, -0.04884765f, 0.19697396f, 
    -0.08478148f, -0.09361089f, 0.04963854f, 0.01996400f, -0.03369614f, -0.06336887f, 0.13718182f, -0.28767279f, 
    -0.21468090f, 0.05891226f, -0.11681981f, 0.20150322f, 0.11313865f, -0.08883015f, 0.06831974f, -0.03108751f, 
    -0.13801302f, -0.05084503f, 0.01813677f, -0.02656551f, -0.03471069f, 0.08096781f, 0.00224588f, -0.06781951f, 
    0.07781763f, 0.04336151f, -0.04149934f, 0.15597767f, -0.08184431f, -0.05583253f, -0.18841952f, -0.07590010f, 
    0.00288927f, -0.03606562f, -0.03536375f, -0.06101621f, -0.00799780f, -0.00482511f, 0.06115047f, -0.01682583f, 
    -0.10589844f, 0.19703761f, 0.10536188f, -0.11449184f, 0.20282465f, 0.08502436f, -0.02975074f, -0.08715250f, 
    -0.04515417f, -0.23749709f, -0.01354168f, -0.00253788f, 0.03051501f, -0.18992206f, 0.14004467f, 0.11377943f, 
    -0.03197149f, -0.04322102f, 0.03300186f, 0.11485045f, 0.03121860f, 0.07525343f, 0.17256398f, 0.12791115f, 
    0.05959891f, -0.02938692f, -0.02305035f, -0.04097311f, 0.04047105f, 0.01432295f, -0.01678236f, -0.20096835f, 
    -0.17603512f, -0.12641020f, 0.09138758f, 0.02092826f, 0.02182267f, -0.04918007f, -0.01720436f, -0.16910245f, 
    -0.11741590f, -0.07818855f, -0.10112523f, 0.16367412f, 0.15088320f, 0.09916279f, -0.07895071f, -0.09502302f, 
    -0.07655208f, 0.11103820f, 0.15885538f, -0.16500090f, -0.02905623f, 0.16867189f, 0.10058316f, -0.03145267f, 
    -0.09650265f, -0.15649456f, 0.02069311f, -0.01908005f, -0.06928503f, -0.18202837f, 0.00177901f, -0.07678949f, 
    -0.05455383f, 0.06949589f, 0.08034155f, 0.23161100f, 0.11855721f, -0.03685300f, 0.09001648f, -0.07240184f, 
    -0.01668799f, 0.03840253f, -0.09359061f, -0.08412717f, 0.23343131f, 0.06993399f, -0.05869273f, 0.16181518f, 
    0.08772451f, -0.08060058f, 0.12488829f, 0.01667393f, 0.08180549f, -0.37911016f, 0.11937094f, 0.24005324f, 
    0.09033515f, -0.01511996f, -0.08262862f, -0.08265062f, 0.05352772f, 0.16611513f, 0.08987844f, 0.15627407f, 
    0.08055548f, -0.03676439f, -0.14623909f, 0.03996867f, 0.01517753f, 0.07665251f, 0.12349858f, 0.32520053f, 
    -0.05372892f, -0.00275178f, 0.03235440f, 0.07606672f, -0.13361083f, -0.08833964f, 0.04247243f, -0.04839545f, 
    0.14267448f, 0.12974773f, -0.06605604f, 0.06853771f, 0.10339345f, -0.08328643f, 0.08196437f, -0.04952178f, 
    0.06295935f, -0.17919371f, 0.05776586f, -0.02799917f, 0.04968993f, -0.04624116f, 0.04625740f, -0.04053118f, 
    0.02091630f, 0.11069176f, -0.09594185f, 0.04577848f, 0.14219764f, -0.14869235f, 0.06238751f, 0.07824519f, 
    0.05562506f, 0.09909082f, -0.04356404f, 0.46648702f, 0.11691698f, -0.23268104f, 0.01798410f, -0.02131959f, 
    0.03047759f, -0.03381619f, 0.00086047f, -0.04766676f, -0.23619415f, -0.27527088f, 0.02759110f, 0.11404514f, 
    0.21542031f, -0.00492997f, 0.06800459f, -0.03197826f, -0.08408676f, -0.39479780f, -0.03599813f, -0.12075031f, 
    -0.01645676f, 0.08805284f, -0.04424784f, -0.01387017f, 0.02384295f, -0.08947701f, -0.09507886f, 0.13021469f, 
    0.03502201f, -0.03107821f, 0.08866370f, -0.06838932f, 0.01420017f, -0.01864201f, 0.02035681f, -0.12549593f, 
    -0.03337749f, -0.21469897f, 0.06702124f, 0.02377539f, 0.00869303f, 0.02073326f, -0.04841803f, 0.11462569f, 
    0.06597890f, 0.02849007f, 0.20327353f, -0.07651329f, -0.04452577f, 0.12585548f, 0.04962713f, 0.02254099f, 
    -0.01528331f, -0.00917083f, 0.03593495f, 0.00020158f, 0.02715035f, -0.02519049f, -0.01074634f, -0.03817560f, 
    -0.03893011f, 0.07001533f, 0.05037185f, 0.05465282f, 0.16352639f, -0.00142889f, 0.03744242f, 0.00538662f, 
    -0.11233854f, -0.00631330f, 0.02600763f, -0.21556149f, -0.27493984f, -0.12131494f, 0.08807372f, 0.07000006f, 
    0.05743025f, 0.03025733f, 0.24285309f, -0.00498454f, -0.01963209f, -0.01769632f, 0.09308381f, -0.08677625f, 
    0.02682123f, 0.13294350f, 0.17405292f, 0.02339203f, -0.17827009f, 0.21667977f, 0.10568172f, 0.07229579f, 
    -0.01588501f, -0.07611544f, -0.03996897f, -0.02171217f, 0.09548458f, -0.02009520f, 0.01530663f, 0.07018167f, 
    0.03603246f, -0.05349205f, -0.17746225f, -0.25829810f, -0.11443214f, 0.00469184f, -0.09965670f, -0.00638899f, 
    -0.00347473f, -0.08453480f, 0.12652999f, -0.16347794f, 0.10609997f, 0.00535082f, 0.03813317f, -0.10316146f, 
    0.03863119f, -0.16611515f, 0.05680454f, 0.05321008f, -0.02647344f, 0.05352847f, -0.09085999f, 0.03714143f, 
    -0.06051702f, 0.22609539f, -0.09701290f, -0.10188599f, -0.03553781f, -0.11507677f, 0.07871614f, 0.15196736f, 
    0.01260594f, 0.01480846f, 0.00280780f, 0.17922346f, -0.21130408f, 0.02384841f, -0.04667903f, 0.02397844f, 
    0.01184215f, -0.01908072f, 0.10267848f, 0.12958692f, -0.19659296f, -0.08481769f, 0.08821171f, 0.05932263f, 
    -0.15190814f, 0.01282321f, -0.03007350f, -0.03742772f, 0.00895814f, 0.25239769f, 0.12123213f, 0.07577682f, 
    0.05522107f, 0.08330073f, -0.01778557f, -0.03797385f, 0.19562177f, -0.11308986f, -0.20702069f, -0.14455666f, 
    -0.11190367f, 0.08303104f, -0.00330429f, 0.12124835f, -0.05284859f, -0.06674547f, 0.05735613f, -0.24041088f, 
    0.04043606f, -0.10487835f, -0.05750027f, 0.01049691f, 0.01265521f, 0.09024931f, -0.05454716f, 0.01601226f, 
    0.14915451f, 0.03856735f, -0.01339683f, -0.11715613f, 0.04555399f, 0.05491441f, 0.13072439f, 0.02460430f, 
    -0.01274162f, -0.08221430f, 0.10325220f, 0.06446765f, -0.14841063f, 0.03807162f, 0.09368372f, 0.07768618f, 
    -0.06273811f, 0.27738494f, -0.05165020f, 0.08840210f, -0.06815629f, -0.15979546f, -0.02772043f, 0.09039342f, 
    0.03337687f, 0.13521533f, 0.34173968f, -0.02253909f, -0.29400498f, -0.05659250f, -0.03355862f, 0.10022409f, 
    -0.03004336f, 0.00883345f, 0.07094704f, -0.17535444f, -0.22161990f, -0.08065785f, 0.01187168f, 0.11483622f, 
    -0.06573387f, 0.03316938f, -0.06588537f, -0.05929326f, -0.07757828f, -0.26454982f, -0.25323468f, 0.22212784f, 
    -0.06785173f, 0.03557554f, 0.07023772f, 0.01592475f, -0.14138462f, 0.10392758f, -0.07980604f, -0.14657415f, 
    -0.10222460f, 0.01432921f, 0.15806822f, 0.00546188f, -0.08362296f, 0.24333838f, -0.16553833f, 0.03288936f, 
    0.25129056f, -0.15434726f, -0.19804008f, -0.06379701f, 0.05177980f, -0.04836009f, 0.07036638f, 0.05531057f, 
    -0.02067798f, -0.06943908f, 0.00911848f, -0.01933390f, -0.25316000f, -0.01847815f, 0.06355025f, 0.07259491f, 
    0.02752835f, -0.06065933f, -0.16808087f, -0.00476373f, -0.07696032f, 0.01742754f, 0.09065784f, -0.00782280f, 
    0.03342027f, -0.23767570f, 0.00916920f, -0.02747209f, -0.25563464f, 0.09040031f, -0.02600425f, -0.00442884f, 
    -0.02261419f, 0.04582752f, -0.12137821f, 0.09087101f, -0.02246002f, 0.12086497f, 0.07120061f, 0.08498410f, 
    0.10893132f, 0.05432683f, 0.02603955f, -0.23388042f, 0.04724403f, -0.13719021f, 0.07317831f, -0.02530960f, 
    -0.04213997f, 0.05058708f, -0.05094340f, 0.11156936f, -0.10819794f, 0.07126737f, 0.27596891f, 0.01785245f, 
    0.04768961f, -0.05136866f, 0.13687125f, 0.03837093f, 0.06672381f, 0.19158834f, -0.00581897f, -0.20233756f, 
    -0.15371417f, -0.05725176f, -0.01908021f, 0.05492413f, -0.01890851f, -0.04377469f, -0.03117979f, -0.13194206f, 
    -0.05989548f, -0.15971257f, -0.12680140f, -0.19549720f, 0.01743969f, 0.08237517f, 0.07644587f, 0.00599262f, 
    0.08803365f, -0.00125251f, 0.08184556f, -0.11645278f, 0.04343840f, 0.06297614f, 0.07117621f, -0.06534727f, 
    -0.20994671f, -0.08993790f, 0.02539006f, 0.02671663f, 0.03176951f, -0.01636140f, -0.05247026f, 0.09032089f, 
    -0.02789208f, 0.19417815f, -0.26081216f, -0.14435226f, 0.03400508f, 0.06302062f, -0.02382758f, -0.03830132f, 
    -0.06412747f, -0.02248346f, 0.34757507f, -0.00097652f, -0.19253130f, -0.06585405f, 0.00373743f, 0.16356045f, 
    0.05712167f, -0.04118300f, 0.07607332f, -0.07617737f, -0.14670260f, -0.10478918f, 0.01325546f, -0.07717152f, 
    -0.04636533f, 0.03378972f, -0.01001940f, -0.12993716f, 0.48118705f, -0.01011634f, 0.40726444f, 0.15510198f, 
    0.23751703f, 0.10423933f, -0.02034082f, 0.11768170f, -0.09780957f, -0.31430471f, -0.18504089f, -0.08596135f, 
    -0.12340404f, 0.05480875f, -0.02048955f, -0.07076914f, 0.00259904f, -0.00201366f, -0.13729091f, -0.08110125f, 
    -0.00155830f, 0.02291621f, -0.11204683f, 0.04658503f, -0.11293532f, 0.05625725f, -0.03965403f, 0.15883321f, 
    0.14706041f, 0.07108910f, 0.05829413f, -0.13407421f, -0.12088998f, -0.02247113f, 0.04788680f, -0.00254686f, 
    0.02467860f, -0.06762809f, 0.03268149f, -0.03121371f, -0.03448189f, 0.06134474f, -0.00700041f, -0.20166762f, 
    0.12999836f, 0.20553647f, 0.01542591f, 0.15630101f, 0.01878723f, 0.08654257f, 0.08192748f, -0.06849001f, 
    -0.05293789f, -0.02372856f, -0.02499171f, 0.01314491f, 0.02417978f, 0.02869950f, 0.07432726f, 0.07860095f, 
    0.01151429f, -0.06031175f, -0.21749270f, 0.01707962f, -0.22622077f, 0.04961212f, -0.14509736f, 0.19668749f, 
    0.10383173f, 0.02211594f, -0.07265652f, -0.05375787f, 0.06663336f, 0.05482696f, -0.06457125f, -0.07677849f, 
    0.02681156f, -0.07427412f, 0.06112259f, 0.04317489f, -0.05365498f, 0.12897384f, 0.37177119f, -0.01773193f, 
    0.07906344f, -0.07010891f, 0.13108547f, 0.11170007f, -0.03555174f, -0.00810391f, -0.12953122f, 0.06886815f, 
    0.20577654f, 0.08571624f, -0.00802556f, -0.12813683f, -0.14003269f, 0.04443119f, 0.24891561f, 0.06625976f, 
    0.02343022f, 0.11995645f, -0.06609690f, -0.12570520f, 0.07647282f, 0.02322735f, -0.02904057f, -0.05954348f, 
    0.14070855f, -0.06208538f, -0.02066162f, 0.02664346f, -0.02372649f, 0.03871599f, -0.07308647f, -0.02981894f, 
    -0.03052117f, 0.11292376f, -0.10565207f, -0.01764120f, 0.04491526f, 0.03253427f, 0.00830313f, -0.02003517f, 
    0.03064891f, -0.06184386f, -0.03858933f, -0.01926384f, 0.01158634f, -0.04914420f, -0.03416931f, -0.02456165f, 
    -0.02194217f, -0.05133474f, -0.15642297f, 0.32233685f, -0.06757382f, -0.12924276f, 0.01977401f, -0.08539328f, 
    0.05376045f, 0.09063964f, -0.17329724f, 0.08049214f, -0.06780255f, -0.16135465f, -0.05111358f, 0.00726523f, 
    -0.04798109f, 0.02809624f, -0.00400889f, 0.00794465f, -0.07625099f, 0.05060503f, 0.04510391f, 0.01751444f, 
    0.00637586f, 0.13415399f, 0.09317797f, 0.05640028f, 0.16618682f, -0.02973500f, 0.02010929f, 0.14489956f, 
    0.03656607f, 0.12943324f, -0.04227008f, 0.09564137f, 0.02871054f, 0.00632627f, 0.10817832f, 0.11061079f, 
    -0.13435423f, 0.04411318f, -0.07590290f, 0.00544818f, -0.10089894f, -0.04240877f, -0.04644554f, -0.07483283f, 
    -0.11779042f, 0.00633657f, -0.12140762f, -0.09029553f, 0.00208971f, -0.15263571f, 0.07059544f, 0.00726138f, 
    0.12184621f, -0.04006259f, 0.23203751f, -0.28464785f, -0.06538565f, -0.02833680f, -0.00250849f, -0.01014484f, 
    -0.07787458f, 0.06817483f, 0.11238702f, 0.24378215f, 0.07398261f, 0.08323970f, -0.18381414f, -0.10082898f, 
    -0.03343607f, 0.11732297f, -0.02079251f, 0.38065353f, 0.03689735f, 0.02381375f, 0.01257992f, -0.12015678f, 
    0.05029949f, -0.11996798f, 0.19621156f, 0.06765643f, 0.25674698f, -0.06779676f, -0.24427125f, -0.03770596f, 
    -0.08312214f, 0.10870523f, 0.02215666f, 0.05841514f, 0.00384525f, -0.29495421f, -0.06958440f, -0.19517986f, 
    0.10058671f, 0.04967535f, 0.14690401f, 0.11237695f, 0.01859719f, -0.05796096f, -0.07518537f, -0.04506623f, 
    -0.14145285f, 0.06333163f, 0.07632679f, -0.16774832f, 0.02218534f, -0.05329277f, -0.00169587f, -0.09751851f, 
    -0.04256126f, -0.09550148f, 0.18223424f, 0.00706566f, 0.07347453f, 0.07414270f, -0.01967542f, 0.05238207f, 
    0.17181946f, 0.10321248f, 0.03466810f, -0.02747332f, -0.08820784f, 0.03372205f, 0.07446560f, -0.08755230f, 
    -0.02885005f, 0.00883803f, 0.08978231f, 0.15751278f, -0.09033018f, -0.04815071f, 0.09883543f, 0.08183964f, 
    0.02106779f, -0.07295600f, -0.06775591f, 0.24550791f, 0.15394795f, -0.11880418f, 0.02410789f, 0.14729770f, 
    -0.10817511f, 0.00634569f, -0.17310709f, -0.04468330f, 0.15399760f, -0.00618569f, 0.01477496f, 0.04091755f, 
    -0.08642674f, 0.02950790f, -0.02875070f, 0.08171755f, -0.20046686f, 0.30943978f, 0.19727527f, 0.06814088f, 
    -0.01652495f, -0.08596967f, -0.02449439f, -0.35703844f, 0.09297132f, 0.08496699f, -0.07107447f, -0.00741791f, 
    -0.12173223f, -0.01510221f, 0.21191606f, 0.07379362f, 0.10339131f, -0.20118022f, 0.32799619f, -0.11839256f, 
    0.14979221f, 0.03838182f, -0.04227734f, 0.11236870f, 0.00776236f, -0.02518477f, 0.08818568f, -0.14744051f, 
    -0.24102421f, 0.16855915f, -0.17925780f, -0.01313015f, -0.05653248f, -0.07930636f, -0.00322009f, -0.08070014f, 
    0.04200569f, 0.23418884f, 0.09105016f, -0.19386145f, -0.06981082f, -0.17840785f, -0.02310795f, -0.03110083f, 
    -0.04027465f, -0.11295882f, 0.22420727f, -0.07799216f, 0.00552201f, 0.01959712f, 0.04657969f, 0.02358774f, 
    0.03560492f, 0.03728959f, 0.00130462f, 0.03299266f, -0.09303513f, 0.08438218f, 0.01733603f, 0.08790801f, 
    -0.12266093f, 0.03554624f, -0.08610222f, -0.00691300f, -0.04024081f, -0.06342740f, -0.02457427f, 0.00397356f, 
    0.01730153f, 0.09267763f, 0.09535758f, -0.07239212f, -0.01959869f, -0.22571678f, -0.03379958f, 0.08727539f, 
    0.16904239f, -0.07521787f, -0.01375067f, -0.18394728f, -0.16673611f, -0.08173124f, -0.27491355f, -0.22088495f, 
    0.07854247f, 0.00003527f, -0.13570954f, -0.06505126f, -0.17871955f, 0.04146575f, 0.30279925f, -0.38501692f, 
    -0.10413114f, 0.03551914f, 0.09519042f, 0.09489118f, -0.01990029f, -0.01648656f, -0.07586370f, -0.16570796f, 
    -0.05387752f, 0.10874673f, -0.14488256f, -0.00032911f, 0.19332337f, 0.07468443f, 0.04466598f, -0.09414374f, 
    -0.01843197f, 0.06505765f, 0.09623739f, -0.06629924f, 0.09217780f, 0.03762276f, 0.01397647f, 0.08548810f, 
    0.06341667f, 0.51111454f, 0.19702381f, -0.00141186f, 0.08223484f, -0.14616613f, 0.00644811f, -0.14354292f, 
    0.02514933f, 0.17756121f, -0.10045895f, 0.06694207f, 0.02900862f, 0.04777049f, -0.02287548f, 0.03311049f, 
    -0.23809922f, 0.03549665f, 0.12267540f, 0.15293796f, -0.08753677f, 0.06271040f, 0.01342204f, 0.12837423f, 
    -0.04149465f, -0.08527964f, 0.04246223f, 0.00094253f, -0.01265188f, -0.10249089f, 0.05104285f, -0.07256918f, 
    0.13256533f, 0.00450013f, -0.07068882f, -0.03449718f, 0.07188652f, 0.04425884f, 0.14320451f, 0.12953173f, 
    -0.04790470f, 0.02201696f, -0.09204470f, 0.12963951f, 0.00771254f, 0.16874211f, -0.08251054f, -0.11097132f, 
    -0.06704783f, 0.04147884f, 0.00277996f, -0.08761644f, -0.01925466f, 0.09574971f, 0.05882906f, 0.09022641f, 
    -0.02140140f, -0.16202615f, -0.13086943f, -0.12422487f, 0.09032417f, -0.01839445f, 0.07394830f, 0.02139234f, 
    0.04545927f, -0.22503012f, -0.12336432f, -0.03251666f, -0.01949465f, 0.06443854f, 0.07060323f, 0.08874468f, 
    -0.13174672f, -0.28125173f, -0.24499522f, -0.35052884f, 0.12706497f, 0.02935375f, 0.04853381f, 0.04083758f, 
    0.05985738f, -0.23231192f, 0.02496771f, 0.13565761f, -0.06768835f, -0.10967258f, -0.01635574f, -0.05292956f, 
    -0.00614921f, -0.22661702f, 0.26443306f, -0.30140254f, 0.14025582f, 0.07804082f, 0.19068220f, 0.11460763f, 
    -0.03124971f, -0.09105069f, 0.05352125f, 0.04094948f, 0.01394950f, 0.16560388f, 0.19694412f, -0.05338685f, 
    -0.21217553f, -0.06790145f, 0.08884679f, -0.16818716f, -0.20672795f, -0.34398830f, 0.03820429f, -0.06186812f, 
    -0.11979429f, -0.07898726f, 0.05019793f, 0.02486875f, -0.02404395f, 0.00259452f, 0.02150337f, -0.29376280f, 
    0.21796620f, 0.07694875f, 0.06439633f, 0.00237834f, 0.00910720f, -0.08992703f, 0.08810494f, 0.37296510f, 
    -0.09385604f, -0.21085271f, -0.19441591f, 0.10432434f, 0.22612056f, 0.12956762f, 0.03030097f, 0.09839425f, 
    0.04174320f, 0.00284139f, 0.00296309f, -0.04287212f, -0.04312763f, 0.02350163f, 0.04144910f, -0.01807744f, 
    0.04302369f, -0.07687981f, -0.01491555f, -0.03345370f, 0.00238493f, -0.06448605f, -0.00720088f, -0.02131953f, 
    -0.00245700f, -0.02758113f, 0.01013280f, -0.03796011f, -0.08462940f, 0.00009536f, 0.01922164f, -0.00103799f, 
    -0.07353841f, -0.07373042f, 0.01954455f, 0.00072345f, 0.02333543f, -0.03578306f, -0.04495103f, -0.04763811f, 
    -0.05610793f, 0.01689329f, -0.07023605f, 0.01914294f, -0.05013037f, -0.02002175f, -0.01321596f, -0.00673843f, 
    0.00507426f, -0.07440015f, -0.03643247f, -0.03328229f, 0.00810852f, 0.02076804f, -0.06891705f, 0.01399894f, 
    -0.07060515f, 0.03651439f, -0.01271825f, -0.02661986f, 0.00984609f, 0.01923251f, -0.01544101f, -0.00750714f, 
    0.00840181f, -0.04798219f, -0.04681791f, -0.04755136f, -0.02442685f, -0.02859008f, 0.00210830f, -0.02889482f, 
    0.00857208f, 0.00826205f, -0.01863923f, -0.05760242f, -0.06141971f, -0.04964014f, -0.06558838f, 0.02390917f, 
    -0.00161674f, -0.06907908f, -0.06474824f, 0.00417775f, 0.03861880f, -0.05035533f, 0.01794174f, -0.05475968f, 
    -0.00321090f, 0.01139075f, -0.05903615f, 0.01985580f, -0.01556479f, -0.00822634f, -0.03264048f, -0.02679913f, 
    -0.09528256f, -0.06021579f, -0.00855976f, -0.04372253f, 0.01082760f, -0.02614405f, -0.02409062f, 0.01386585f, 
    -0.06915268f, -0.07072929f, 0.01473416f, 0.03808176f, -0.00569436f, 0.03467070f, 0.02861285f, -0.00058134f, 
    0.08389513f, -0.05115842f, 0.02026653f, -0.03960162f, -0.01411407f, -0.07694104f, -0.05185524f, -0.04013421f, 
    -0.03052623f, 0.03210269f, 0.04068525f, -0.07982198f, -0.03407218f, 0.03092067f, -0.02928517f, -0.01599365f, 
    -0.06889933f, -0.02879338f, 0.02356042f, -0.00815768f, 0.03568140f, 0.03107439f, -0.02402115f, -0.06676388f, 
    -0.04457471f, -0.01350309f, 0.02324623f, 0.02098167f, 0.01350514f, -0.05502021f, -0.01725569f, 0.03577240f, 
    -0.02283271f, -0.06593677f, 0.05656850f, -0.02330146f, -0.04851143f, -0.08486553f, 0.01641874f, 0.04822710f, 
    -0.05365314f, -0.07355272f, -0.05909749f, -0.02052335f, -0.06494989f, -0.04524809f, -0.00346342f, -0.03778999f, 
    -0.00774148f, 0.04850467f, -0.08770375f, 0.03373145f, -0.06883397f, -0.03847534f, -0.01051844f, -0.01455516f, 
    -0.03905411f, -0.03001264f, -0.07964846f, 0.03694247f, -0.06586631f, -0.06581029f, -0.04952582f, -0.00016127f, 
    0.03105500f, -0.05697758f, -0.04386376f, -0.05738026f, -0.01186308f, -0.07856800f, 0.00031262f, -0.05808792f, 
    0.03395420f, -0.03573995f, -0.00988220f, -0.02849103f, -0.05241551f, 0.00871316f, 0.03970579f, -0.00084608f, 
    -0.01269207f, -0.07248575f, 0.00162879f, 0.02141964f, -0.01854868f, -0.09118528f, -0.01261597f, -0.04682027f, 
    -0.01792337f, 0.00694114f, 0.02189336f, -0.04563271f, -0.07049914f, 0.01323422f, -0.03099789f, -0.00397723f, 
    -0.04482578f, -0.00280000f, -0.01770926f, -0.02155382f, -0.01111212f, 0.01491136f, 0.00970238f, -0.03423023f, 
    -0.03932576f, -0.06872560f, 0.02362295f, -0.05261804f, -0.03044796f, -0.04671155f, -0.07015854f, -0.05956698f, 
    0.02934336f, 0.03644763f, 0.01913923f, -0.08257385f, 0.02211883f, 0.03299229f, -0.00308443f, -0.03396738f, 
    0.01289971f, -0.00414240f, -0.06182896f, -0.05846125f, -0.02018199f, -0.06037865f, -0.07960479f, -0.06096689f, 
    -0.00752936f, 0.00151086f, -0.06771076f, 0.00954235f, -0.05705903f, -0.00513000f, -0.03376787f, -0.06587155f, 
    -0.05460740f, -0.07906057f, -0.04639683f, -0.07391654f, 0.01354987f, 0.01816390f, -0.00144449f, 0.03092024f, 
    -0.08968883f, -0.03462347f, 0.02283202f, 0.03171000f, -0.04674689f, 0.03317485f, 0.00119607f, -0.05110674f, 
    0.03435787f, -0.01579461f, 0.00814767f, 0.02627652f, -0.02848055f, 0.02404210f, -0.01593482f, -0.05859028f, 
    -0.00934502f, -0.05414370f, 0.05868852f, -0.06498563f, -0.03686994f, 0.02693411f, -0.01665020f, -0.03747030f, 
    0.01139044f, 0.00342414f, -0.05032399f, 0.01480150f, -0.01705479f, -0.07930533f, -0.01068957f, 0.02418632f, 
    -0.04036367f, 0.01528399f, -0.03100958f, -0.04748925f, -0.05372247f, 0.03265717f, 0.03127042f, 0.02085252f, 
    0.02884170f, -0.01932782f, -0.02985713f, -0.01530981f, -0.04970892f, -0.00071582f, -0.04822795f, -0.04959641f, 
    -0.04381535f, 0.03239140f, -0.03315867f, 0.04995362f, -0.02429949f, -0.00649261f, -0.01232397f, 0.00285671f, 
    0.01127371f, 0.01390532f, -0.02598267f, 0.01640393f, 0.03486110f, 0.02357123f, -0.02666843f, -0.00300280f, 
    0.05673934f, 0.04825383f, -0.03825103f, -0.03223663f, 0.04305404f, -0.06729569f, 0.05322229f, 0.03616861f, 
    0.01319917f, -0.03183532f, 0.02546319f, 0.02833920f, 0.04076557f, 0.00138360f, -0.02919854f, 0.03403016f, 
    0.03436071f, 0.03988243f, -0.00532675f, -0.01515883f, 0.01581713f, 0.01849906f, -0.05374233f, -0.05500897f, 
    -0.00580383f, -0.04963000f, -0.01177344f, -0.02792823f, -0.00550717f, 0.02123100f, 0.03457732f, 0.00966253f, 
    -0.03041944f, -0.05001459f, 0.02048326f, -0.06000564f, -0.00592360f, 0.04334946f, -0.01819581f, 0.01302645f, 
    0.02570467f, -0.00602034f, -0.03007468f, -0.05888741f, -0.02772256f, 0.01355459f, -0.03976912f, -0.02413031f, 
    0.03439870f, -0.04482690f, -0.05370370f, -0.01519560f, 0.03129501f, -0.02562403f, 0.04689089f, -0.02521308f, 
    0.00319298f, 0.00194728f, -0.01819737f, 0.03503963f, -0.05217494f, 0.02094421f, -0.04823650f, -0.04867592f, 
    -0.06225913f, -0.00687424f, 0.03801601f, -0.06162515f, 0.01765624f, -0.03912510f, 0.04249447f, -0.01059883f, 
    0.03094834f, -0.02459782f, -0.04633509f, 0.04263154f, 0.00021233f, -0.05492285f, 0.00228457f, -0.00626743f, 
    0.01021189f, -0.02994697f, 0.02525536f, 0.00757152f, -0.02199683f, 0.04477897f, 0.02789698f, -0.06441443f, 
    0.01332812f, -0.06207297f, -0.04183143f, -0.02444001f, -0.00328844f, -0.01246803f, -0.04216844f, -0.03301284f, 
    0.00231131f, 0.02026258f, 0.04111768f, 0.00722751f, 0.02614268f, -0.03390494f, 0.03682416f, -0.00552543f, 
    0.04790818f, -0.04324610f, 0.00926039f, -0.05442894f, 0.02146293f, -0.03464298f, -0.01991859f, -0.01220034f, 
    0.01790250f, -0.00812262f, -0.04863929f, 0.03309392f, 0.02330488f, 0.01613215f, -0.05716367f, -0.02715037f, 
    -0.05809821f, 0.04293549f, 0.01726764f, 0.04088503f, -0.02196099f, -0.03989211f, 0.01711362f, -0.00710518f, 
    -0.03746806f, 0.04136861f, 0.02533561f, -0.03241342f, 0.05018457f, -0.03905099f, 0.03081135f, -0.00141281f, 
    0.04693889f, -0.03145148f, 0.04711999f, -0.02721195f, -0.02821565f, 0.00275499f, -0.01769246f, -0.02673724f, 
    -0.02487217f, -0.03517613f, -0.05356035f, -0.02783557f, 0.04895930f, -0.03851565f, 0.02262720f, -0.06161800f, 
    -0.00586606f, 0.01386614f, 0.04390531f, -0.05255808f, 0.02156608f, -0.03571614f, -0.01770280f, 0.04736396f, 
    -0.05023472f, 0.03947309f, 0.04287804f, 0.01529439f, -0.04808613f, -0.04906252f, -0.04371265f, -0.01231205f, 
    -0.00912379f, -0.00934256f, 0.05380454f, -0.02138767f, 0.00227150f, -0.05308291f, 0.04276030f, -0.05353664f, 
    -0.02576199f, 0.02727264f, 0.04278343f, 0.00900597f, 0.00043547f, 0.00075517f, 0.01090036f, 0.04586554f, 
    -0.03020301f, -0.02569205f, -0.03853837f, -0.04316732f, -0.05727017f, 0.01358210f, -0.02470689f, -0.00651530f, 
    -0.03725602f, 0.04363964f, -0.03104360f, -0.02073722f, 0.04592160f, -0.05428902f, -0.04772573f, 0.05146530f, 
    0.01100598f, 0.03843023f, -0.01378365f, 0.00054424f, -0.05606549f, 0.01711716f, 0.03037577f, -0.03254562f, 
    -0.01386500f, 0.03391355f, 0.00252981f, -0.01583456f, 0.00051763f, 0.03832427f, -0.00418716f, 0.03063423f, 
    0.01267752f, -0.06192540f, 0.00645466f, -0.02433025f, -0.01947213f, 0.02177777f, -0.05475343f, -0.00105639f, 
    0.00245949f, 0.01352125f, 0.00940028f, 0.04517104f, -0.04033474f, -0.04012665f, 0.00346728f, -0.04750941f, 
    -0.04014402f, 0.04984434f, -0.03842736f, 0.02600846f, -0.00167404f, 0.04216360f, 0.00444497f, 0.04140984f, 
    -0.03927341f, -0.05325022f, 0.01228985f, -0.06250010f, 0.02607463f, -0.01727697f, -0.01165607f, -0.02716353f, 
    -0.00016406f, -0.02290757f, -0.00698716f, -0.05765774f, -0.01362302f, 0.01331357f, 0.02807512f, 0.00218123f, 
    -0.00851442f, -0.06158219f, -0.02844417f, 0.02575031f, -0.02365449f, 0.04827207f, -0.00529015f, 0.03834428f, 
    0.25509751f, -0.10966559f, 0.42397106f, -0.07089903f, -0.09155198f, -0.01886469f, -0.02941661f, -0.06920015f, 
    0.09376538f, 0.16062535f, 0.14358321f, 0.07788397f, -0.02664128f, 0.03177935f, 0.12950930f, 0.19034544f, 
    0.09847556f, -0.01003843f, 0.27763695f, 0.21389869f, -0.26003939f, -0.18250588f, 0.10912408f, 0.06024850f, 
    -0.06528883f, -0.02324345f, -0.09056942f, 0.19032525f, 0.11681304f, -0.13576488f, 0.13796398f, 0.03688174f, 
    0.05224183f, 0.13091077f, 0.10065933f, 0.03714188f, -0.40048620f, -0.11814232f, 0.30825654f, -0.14340709f, 
    0.08284521f, -0.01886835f, -0.13829042f, -0.21614924f, 0.02094081f, 0.06141533f, 0.09820058f, -0.12986065f, 
    -0.04502727f, -0.25602561f, 0.08760070f, -0.06532054f, 0.01235081f, 0.13325547f, -0.14834088f, 0.22890061f, 
    -0.07266912f, 0.19541724f, 0.04203591f, 0.02158969f, 0.07801663f, 0.03438063f, -0.05404187f, -0.10642778f, 
    -0.10714822f, 0.09015743f, 0.10565245f, 0.05735480f, 0.04585700f, 0.11768994f, 0.15591730f, 0.20195127f, 
    0.05322919f, 0.31330547f, -0.13882349f, 0.09273893f, -0.12872112f, -0.06756630f, 0.33217788f, -0.10302532f, 
    -0.06713907f, -0.05839678f, -0.01168379f, -0.04761076f, 0.16243131f, -0.05545166f, 0.02439990f, 0.20986971f, 
    0.06511456f, 0.00823414f, 0.12000873f, -0.34152001f, 0.17934436f, -0.00001098f, -0.12343869f, 0.13613439f, 
    0.04186060f, 0.05421836f, 0.02918156f, -0.22677697f, 0.15559842f, -0.11064871f, -0.16915974f, -0.06855839f, 
    0.04251484f, -0.18036383f, -0.26325369f, 0.08375782f, -0.13420475f, -0.21681698f, 0.14834636f, 0.10732371f, 
    0.00158480f, -0.03631011f, 0.13600539f, -0.08600052f, -0.04086277f, -0.42544597f, -0.17697118f, 0.29477301f, 
    0.07770786f, 0.00470196f, -0.08529270f, 0.04406504f, -0.06839699f, 0.05805052f, -0.00373698f, -0.11620071f, 
    0.03784318f, 0.01350281f, -0.04330500f, -0.00725552f, -0.15057336f, 0.00082344f, 0.00813287f, 0.04878080f, 
    0.00456505f, -0.02206181f, -0.02691563f, 0.01413703f, 0.12635697f, -0.08061457f, 0.03665716f, 0.02808172f, 
    0.11439232f, 0.11769268f, -0.00087601f, 0.03420853f, 0.04528048f, 0.04865550f, -0.02671150f, 0.17533629f, 
    0.03206551f, 0.22225587f, -0.12705550f, 0.18712395f, 0.06983339f, 0.00820553f, -0.07178814f, -0.01647075f, 
    0.10581773f, -0.07279447f, 0.27640098f, -0.09167495f, -0.05295062f, 0.02007664f, -0.03224936f, -0.09294073f, 
    -0.05583638f, -0.03922187f, 0.03503515f, -0.14810021f, 0.19804534f, -0.02261269f, 0.07832890f, -0.05138892f, 
    0.08901569f, 0.00635262f, 0.04336310f, 0.02381503f, -0.07382105f, 0.13174509f, -0.02853597f, 0.24793860f, 
    0.06873159f, 0.14331563f, 0.03873677f, 0.06624431f, 0.14859544f, -0.31156212f, -0.00056488f, -0.12450446f, 
    -0.00436584f, -0.04573979f, -0.03134114f, 0.08422667f, -0.13629654f, 0.03483506f, 0.03671992f, -0.35789466f, 
    0.35444930f, -0.06776363f, -0.02686135f, -0.06824667f, 0.03329677f, 0.06407490f, 0.09761949f, 0.06545676f, 
    0.31015933f, -0.54187417f, -0.14976932f, -0.12617259f, 0.12979667f, -0.10601740f, 0.00768206f, 0.08757339f, 
    0.20778094f, -0.14663464f, -0.00448535f, -0.04670888f, 0.01105276f, 0.00314615f, 0.02054976f, 0.00784852f, 
    0.02328558f, -0.46397558f, -0.29485101f, -0.22817431f, -0.03491106f, 0.03590750f, -0.02019853f, 0.03515315f, 
    0.08294997f, -0.06864758f, -0.24877347f, -0.51685405f, 0.27783743f, 0.07928348f, 0.04140811f, 0.11498503f, 
    0.03981416f, 0.05225855f, 0.11616246f, 0.17916954f, 0.16694134f, -0.54368585f, 0.17266542f, 0.03382831f, 
    0.05709887f, -0.07271010f, -0.03143129f, -0.03145115f, 0.09390008f, 0.31720904f, -0.24231735f, 0.07712714f, 
    -0.16283125f, -0.16215141f, 0.01145658f, 0.14016849f, -0.19729704f, 0.18019122f, -0.12722069f, -0.03140660f, 
    -0.02505736f, -0.13618670f, 0.06253318f, 0.02042751f, -0.11734607f, 0.02398976f, -0.35369915f, -0.08737072f, 
    0.16226244f, -0.04425829f, -0.07253506f, 0.00482630f, 0.14528863f, -0.00077689f, 0.08493519f, 0.10057334f, 
    -0.22301973f, 0.06846198f, -0.17829444f, 0.05569845f, 0.00505423f, -0.14644444f, -0.25650421f, -0.04640140f, 
    -0.02024917f, -0.04130317f, 0.00000027f, -0.03495282f, 0.04287301f, -0.05348966f, 0.05052656f, 0.00135114f, 
    0.05820463f, 0.00364943f, 0.00180855f, -0.00512034f, 0.04414798f, 0.01944314f, -0.00429096f, 0.02458085f, 
    -0.04949281f, -0.00959555f, -0.04764799f, -0.05554424f, -0.02229674f, -0.01053043f, -0.05211142f, 0.05279736f, 
    -0.01618243f, -0.05193129f, -0.00795140f, -0.01626181f, -0.02173880f, 0.03109182f, 0.01666998f, 0.04673636f, 
    -0.01579681f, 0.01042868f, -0.05461079f, -0.00294687f, 0.01327167f, -0.02891760f, 0.02569562f, 0.04172491f, 
    0.01253755f, -0.01513163f, -0.02649144f, 0.04006071f, 0.01828052f, -0.03756144f, -0.02311007f, 0.01394735f, 
    -0.06361873f, -0.03694642f, -0.04202531f, 0.02764509f, -0.02015306f, -0.00348505f, 0.00395070f, -0.03287047f, 
    -0.05073230f, -0.03559911f, 0.05725808f, 0.01319009f, 0.02647355f, 0.04024533f, -0.03751180f, -0.03674940f, 
    -0.04404182f, -0.06125077f, 0.01316537f, -0.02708356f, 0.02756848f, -0.01789185f, 0.03375000f, -0.04436599f, 
    0.05666104f, -0.03271510f, 0.01845737f, 0.04285114f, 0.04452662f, 0.04909736f, 0.04218244f, -0.04522755f, 
    0.00905573f, 0.04366938f, -0.03283005f, -0.02159671f, 0.02596139f, 0.02561812f, 0.00669717f, 0.03844529f, 
    0.01741724f, -0.05284834f, 0.02324717f, -0.00095103f, -0.03322372f, -0.00102233f, -0.06583532f, 0.02254498f, 
    -0.06716134f, -0.03318253f, 0.03763685f, 0.03321972f, 0.05147407f, -0.05384247f, 0.03091990f, 0.04017808f, 
    -0.02721718f, 0.04812681f, 0.02097978f, 0.02766221f, 0.02633894f, -0.02429083f, 0.02326994f, -0.06055091f, 
    -0.04461257f, 0.00836404f, -0.05233449f, -0.03345592f, 0.02473275f, -0.01679257f, 0.02387931f, -0.02759390f, 
    0.05001671f, -0.02908744f, 0.00648634f, -0.01914470f, -0.00050991f, -0.04868279f, -0.01636465f, -0.04765386f, 
    -0.02383550f, -0.00690585f, 0.03682608f, 0.00793725f, 0.05017471f, -0.02333112f, -0.05685841f, 0.00033444f, 
    -0.06894054f, -0.00235800f, 0.02757443f, -0.05942553f, -0.03004835f, -0.03266573f, 0.04231255f, 0.02754448f, 
    0.04236250f, 0.04750891f, 0.00200378f, -0.01499707f, 0.01132243f, -0.03437303f, -0.04738564f, -0.04927420f, 
    -0.02741193f, -0.00430299f, -0.00438359f, -0.04185893f, -0.00045161f, -0.01827121f, -0.06269434f, 0.01530030f, 
    -0.04027658f, -0.03548067f, 0.00201807f, -0.06562515f, 0.02103424f, -0.01698241f, 0.05075163f, -0.02101743f, 
    -0.06253979f, -0.03917135f, -0.06216096f, 0.03356201f, 0.01619844f, 0.04785623f, -0.04684249f, -0.00715865f, 
    0.00318271f, 0.02544470f, -0.01820233f, 0.01590877f, -0.03384573f, 0.01336692f, -0.00224880f, 0.05454776f, 
    -0.03086701f, -0.01812591f, 0.00777210f, -0.00958480f, 0.00061482f, 0.02685646f, -0.00828074f, 0.01904671f, 
    0.00884663f, 0.04248436f, -0.04140814f, 0.00134002f, 0.01700669f, 0.01964365f, -0.03727414f, -0.00022570f, 
    0.02604540f, -0.01132274f, 0.04229804f, -0.04510330f, -0.01770735f, -0.05437848f, -0.04065022f, -0.06202618f, 
    -0.05327433f, 0.04025121f, 0.04553816f, -0.05232840f, 0.01903204f, 0.04092631f, 0.04478142f, -0.00469928f, 
    0.04157566f, -0.04399086f, -0.01122450f, -0.00819246f, -0.06044853f, -0.03438602f, -0.06036648f, -0.03567408f, 
    -0.05671222f, -0.05992701f, -0.06104808f, -0.01790823f, -0.01344392f, -0.03478537f, -0.02662777f, -0.03953376f, 
    -0.01821161f, 0.02596918f, 0.04834781f, -0.05021333f, -0.03629423f, -0.03855472f, -0.00379606f, -0.05820430f, 
    0.02260664f, -0.05394551f, 0.05166060f, -0.00953916f, 0.02152534f, 0.00284697f, -0.01864781f, -0.00713647f, 
    0.02145862f, -0.03991142f, 0.01330218f, -0.03971191f, 0.03840306f, 0.04035445f, 0.00745221f, -0.04916906f, 
    0.00394914f, 0.02911176f, -0.00718448f, -0.00502470f, 0.05137147f, 0.04065774f, 0.04368423f, -0.01913828f, 
    0.02824710f, -0.05012481f, -0.01830210f, 0.02228621f, -0.00756028f, -0.02155218f, -0.05890007f, -0.01159620f, 
    0.04817857f, 0.04906034f, -0.04003209f, -0.01637862f, -0.02477557f, 0.02466767f, -0.03783258f, 0.03028629f, 
    -0.01160419f, -0.03045627f, -0.04672422f, 0.00436969f, -0.00381229f, 0.00884644f, -0.02024632f, -0.06407739f, 
    0.13296619f, 0.10281786f, -0.63317996f, 0.12508897f, 0.18772940f, 0.09429066f, 0.09943708f, 0.02554370f, 
    -0.02698979f, -0.02349211f, 0.05654078f, -0.14357722f, 0.09598147f, 0.12444464f, -0.05891676f, 0.11528549f, 
    0.22504450f, 0.03825838f, -0.09129791f, -0.16291226f, -0.00323157f, -0.10821985f, 0.03927160f, -0.10292625f, 
    -0.05386530f, -0.11284319f, 0.03427303f, -0.28420562f, -0.00252617f, 0.00070700f, -0.16261087f, 0.11119325f, 
    0.20277426f, 0.03884696f, -0.14138916f, 0.00708229f, 0.21601990f, -0.05959063f, -0.43729821f, 0.15700798f, 
    0.23723505f, 0.11812764f, 0.20904487f, -0.12639216f, 0.16530143f, -0.12053526f, 0.08161940f, 0.24585971f, 
    0.09518864f, 0.08607966f, -0.23876667f, -0.04684032f, 0.07564545f, 0.17641138f, -0.27157027f, 0.17309682f, 
    0.13146277f, -0.00232719f, -0.03192174f, -0.04838693f, 0.02026327f, -0.14928268f, -0.00748515f, 0.04394203f, 
    0.08938347f, 0.02515041f, -0.01208619f, -0.03609135f, -0.26123372f, -0.02390793f, 0.00758029f, 0.20705260f, 
    0.03221959f, -0.04458619f, 0.09739361f, -0.07787153f, -0.15168831f, 0.13083524f, -0.15134141f, -0.08720341f, 
    0.18829504f, 0.03072386f, -0.15892591f, -0.05859254f, -0.01535339f, 0.06844960f, 0.13740277f, -0.13312611f, 
    -0.02330577f, -0.05280246f, -0.26924598f, -0.08186368f, 0.15299001f, -0.08216681f, 0.08420483f, 0.07873935f, 
    -0.01339873f, 0.01086736f, -0.15286119f, -0.49077237f, -0.12089766f, 0.03828263f, 0.05496332f, 0.14532197f, 
    -0.18205756f, -0.16196536f, 0.01912472f, 0.07448310f, -0.39983001f, -0.23433426f, 0.31116670f, 0.04909076f, 
    0.05010282f, 0.05041257f, 0.06031351f, 0.15518963f, 0.14463297f, 0.36267221f, 0.32666600f, 0.15611848f, 
    -0.00032383f, 0.02012441f, 0.09274735f, 0.08725134f, -0.04868450f, -0.10835151f, 0.49691829f, 0.33840626f, 
    0.06332444f, -0.15165044f, 0.12097076f, -0.07259138f, -0.05079612f, -0.01208172f, 0.18110959f, -0.01969847f, 
    0.01536448f, -0.14011824f, 0.10454429f, 0.12747435f, 0.06429274f, 0.06469077f, 0.01705520f, 0.01974705f, 
    0.15642051f, 0.07343801f, 0.10404645f, -0.06428581f, -0.00693190f, -0.13714883f, -0.14287178f, -0.09019130f, 
    -0.03719066f, 0.06820325f, -0.26848334f, -0.07244341f, 0.13820095f, 0.09497028f, -0.06501694f, 0.06136904f, 
    -0.03565589f, -0.06188640f, -0.53963399f, -0.29115993f, 0.07017799f, -0.03399114f, 0.09559041f, 0.04402361f, 
    0.02174149f, -0.12569696f, -0.00778251f, 0.13822824f, 0.32136467f, 0.26454023f, 0.16553277f, -0.03959401f, 
    -0.02798456f, -0.01488989f, -0.06371945f, 0.04871297f, -0.28901035f, 0.00390783f, 0.02844092f, 0.00690880f, 
    -0.05998398f, -0.01201668f, 0.02221088f, -0.08358021f, 0.03402387f, -0.25677243f, -0.29206130f, -0.32390505f, 
    0.04101415f, -0.10294896f, 0.16204123f, 0.16067652f, 0.06956097f, -0.10876914f, -0.09093889f, 0.13417570f, 
    0.24501601f, -0.07216637f, 0.02813427f, 0.12649338f, 0.03571649f, -0.03871992f, 0.04123699f, -0.50289428f, 
    -0.05794195f, 0.15014341f, -0.07483985f, 0.07103284f, -0.08876263f, 0.03299442f, -0.04268011f, 0.00781487f, 
    0.11367340f, 0.42578018f, 0.12730171f, 0.00535005f, 0.06762398f, -0.00291883f, -0.03240479f, 0.04555479f, 
    0.04238191f, -0.30583447f, -0.04829779f, 0.26966107f, -0.01253721f, -0.00492796f, -0.00804757f, -0.11241917f, 
    0.04925516f, 0.13198186f, -0.39741457f, 0.00441958f, -0.19424070f, 0.06847043f, -0.13062690f, -0.03816478f, 
    -0.01397998f, 0.04910401f, 0.05424779f, -0.06585071f, 0.04231780f, 0.01804208f, -0.15317804f, -0.03360233f, 
    0.02989687f, 0.29210615f, 0.00812483f, -0.06279142f, -0.01479375f, 0.17913979f, 0.14976574f, -0.45860592f, 
    -0.12882568f, -0.04069676f, -0.09007652f, 0.03871375f, 0.01812627f, 0.22199449f, 0.04843311f, -0.14325459f, 
    -0.04094189f, 0.02865724f, 0.01835582f, 0.27836445f, -0.07020783f, 0.21042341f, 0.45389539f, 0.32808205f, 
    -0.49441671f, -0.04029949f, 0.08453076f, -0.10985638f, 0.04769208f, 0.01085591f, 0.14969257f, -0.05900428f, 
    -0.08155135f, -0.29883796f, 0.16440138f, -0.08027464f, 0.15213750f, -0.13796170f, -0.14457899f, 0.14038305f, 
    -0.00157447f, -0.03233214f, 0.02232978f, 0.04081486f, 0.01687421f, -0.04455172f, -0.00690936f, -0.02816036f, 
    0.04132623f, 0.04826085f, 0.01004814f, -0.02093632f, -0.02681592f, -0.01680746f, -0.06558748f, 0.03960615f, 
    0.05042362f, -0.00081445f, -0.02111361f, -0.01220076f, -0.01872877f, -0.05172261f, -0.08486004f, 0.02177020f, 
    0.03700140f, -0.00476170f, -0.04330034f, 0.02242982f, 0.05671976f, -0.04800599f, -0.00101387f, 0.01934248f, 
    0.01763714f, -0.05598708f, -0.00550230f, -0.04710418f, -0.05693403f, 0.01587180f, 0.05482072f, 0.03916732f, 
    0.04544259f, 0.02363324f, -0.04548244f, 0.00015903f, -0.02515958f, -0.01796109f, 0.05544735f, 0.07096723f, 
    -0.06629731f, -0.06697302f, -0.04984370f, 0.00731212f, -0.04279387f, 0.03001995f, 0.00792933f, 0.01115677f, 
    0.00271268f, -0.03906260f, 0.02668991f, 0.00846392f, -0.01290008f, -0.04043171f, -0.03194465f, -0.00345104f, 
    0.00397517f, 0.05108035f, -0.02868798f, -0.08024992f, -0.06496684f, -0.02388882f, 0.00292383f, 0.01680737f, 
    0.01101762f, -0.00520685f, 0.04583025f, -0.03065180f, -0.07520474f, -0.06087067f, 0.02204208f, -0.01569446f, 
    -0.04829625f, -0.05759520f, 0.01708188f, -0.04465466f, -0.05170107f, 0.02015065f, 0.02069131f, -0.04352867f, 
    0.03585981f, -0.01914830f, -0.02122417f, -0.01459733f, 0.00860248f, -0.04466502f, 0.04556645f, -0.03841983f, 
    -0.09649488f, -0.05356518f, -0.04209805f, 0.05226013f, -0.01382853f, -0.02352656f, -0.01724230f, -0.03848573f, 
    -0.01936602f, -0.04736238f, 0.00963110f, -0.00011041f, 0.05224639f, -0.00692469f, -0.08325293f, -0.05188572f, 
    -0.02580688f, -0.02897246f, -0.01978523f, -0.03010102f, -0.06585418f, 0.05218396f, -0.01941003f, -0.05393640f, 
    -0.00658501f, 0.00448313f, 0.03842380f, 0.00840911f, -0.00868132f, -0.05134618f, 0.03665528f, -0.03067106f, 
    0.00356051f, 0.01487372f, 0.01759944f, -0.07111076f, 0.04824784f, 0.01687850f, -0.03644071f, -0.04858463f, 
    0.00303468f, -0.01360554f, -0.06808102f, -0.05701228f, -0.01975271f, -0.04321133f, 0.00544166f, -0.04539717f, 
    -0.03959308f, 0.00097717f, 0.01385934f, -0.03675226f, -0.08237214f, -0.01956686f, -0.03507549f, 0.03916746f, 
    -0.02582820f, -0.07069921f, -0.00263740f, -0.00748711f, -0.02811174f, -0.06959855f, 0.00317825f, 0.01008506f, 
    -0.00554190f, 0.03892839f, -0.03273585f, -0.01206921f, 0.00119102f, 0.01883893f, -0.02135659f, 0.00384358f, 
    0.01899517f, -0.00245583f, 0.04243421f, 0.03799333f, 0.03260642f, 0.00328877f, 0.02359177f, -0.00486362f, 
    -0.01025439f, -0.02199095f, -0.02278714f, -0.02051756f, 0.00627824f, -0.02181313f, -0.04269896f, -0.06859500f, 
    -0.05843528f, 0.01648363f, -0.04050143f, -0.07739969f, -0.04957108f, -0.01523540f, 0.00204829f, 0.01489988f, 
    -0.00691764f, -0.08829056f, -0.05468408f, -0.02451002f, 0.02743011f, 0.03704767f, -0.01174635f, 0.00393020f, 
    -0.03730430f, 0.01523148f, -0.00418102f, -0.02090126f, -0.04228750f, -0.09744874f, -0.00290203f, 0.02943063f, 
    0.02177649f, -0.07219996f, -0.02787094f, 0.00838286f, 0.02625732f, 0.02820878f, 0.01530949f, 0.01795785f, 
    -0.00452958f, 0.04994868f, 0.04644642f, -0.02363291f, 0.05979639f, -0.04125960f, -0.02296961f, 0.02233774f, 
    -0.04932655f, -0.00045548f, -0.00139157f, -0.05299812f, 0.03702266f, 0.00137656f, 0.01013594f, -0.02587734f, 
    0.04629063f, -0.02295747f, 0.01959074f, -0.01132215f, -0.04533373f, -0.05685122f, -0.01450742f, 0.01482223f, 
    -0.10483117f, -0.06560606f, 0.00035661f, 0.01235277f, 0.03336708f, -0.01346610f, 0.03020774f, -0.05537109f, 
    0.00713773f, 0.01626981f, 0.02981118f, 0.03668080f, -0.01020442f, 0.05946246f, 0.05256164f, 0.03486168f, 
    -0.09006643f, -0.06801982f, -0.04075958f, 0.04016989f, 0.02671407f, -0.07034810f, 0.04935681f, -0.01987877f, 
    -0.06987232f, -0.06558949f, 0.02323443f, 0.03095590f, -0.03859087f, -0.01330590f, 0.04534969f, 0.03854894f, 
    -0.02380820f, 0.02145996f, 0.04048805f, -0.08160842f, -0.03122714f, 0.03750452f, 0.01456280f, -0.03202479f, 
    0.05888988f, -0.00492570f, -0.10495327f, 0.01523927f, -0.05564736f, 0.06557700f, -0.03609029f, 0.00580939f, 
    0.09897172f, 0.18315493f, -0.16587266f, 0.08265496f, -0.00748878f, 0.02333499f, -0.09326178f, -0.04423811f, 
    -0.05789994f, -0.06641906f, 0.09076212f, 0.12936099f, -0.06341082f, 0.10994937f, 0.05381828f, 0.14604540f, 
    0.04412939f, -0.05162008f, -0.00372018f, 0.08467099f, -0.00903279f, -0.04069910f, -0.04038080f, -0.12865964f, 
    -0.02257275f, 0.09958665f, -0.04688897f, 0.08433934f, -0.08462183f, 0.12935373f, 0.12518460f, -0.04922184f, 
    0.13641162f, -0.01640056f, 0.02161262f, 0.21679281f, 0.17510232f, 0.03553883f, -0.20931324f, 0.09862477f, 
    -0.09144644f, -0.20306371f, 0.13447966f, -0.03937741f, -0.13164997f, 0.01079172f, 0.30988514f, 0.11019151f, 
    -0.07089807f, 0.00086283f, -0.11462115f, 0.02969683f, 0.10617262f, -0.03609452f, -0.20787360f, 0.13159999f, 
    -0.04367615f, 0.13093665f, 0.01222652f, -0.01156350f, -0.01818870f, 0.04135317f, 0.03937086f, 0.11055386f, 
    0.07250789f, -0.17050673f, -0.02224487f, -0.17495225f, 0.09816808f, 0.01031054f, -0.13799466f, -0.04180049f, 
    0.18026955f, 0.03110715f, 0.06601582f, 0.07700887f, -0.13542002f, 0.01489875f, -0.01438060f, 0.00225882f, 
    0.15041256f, 0.13715619f, -0.12253509f, -0.10725202f, 0.09931878f, 0.05811672f, -0.07058478f, 0.12951100f, 
    0.00177034f, -0.00438436f, -0.00976729f, -0.33360678f, -0.02895674f, -0.03191499f, 0.13376202f, 0.01839868f, 
    0.18808928f, -0.01929377f, -0.00159064f, 0.01672577f, 0.03154401f, 0.01234037f, -0.10124484f, -0.03751143f, 
    0.15980859f, 0.00138642f, -0.02390311f, 0.17628959f, -0.21415605f, -0.27957070f, 0.10159127f, 0.01838408f, 
    0.08995174f, 0.14111608f, -0.05451031f, 0.01867729f, -0.13274449f, 0.13363160f, 0.00494299f, -0.10923775f, 
    0.00458129f, 0.04164992f, -0.01807924f, -0.00036565f, -0.16054654f, -0.27307159f, 0.14178929f, 0.38430318f, 
    -0.00965979f, 0.08930484f, -0.08815676f, -0.24421325f, 0.10959177f, -0.01883838f, -0.01979937f, -0.00365143f, 
    0.03203286f, 0.04963828f, -0.04435530f, -0.02476935f, -0.13228638f, 0.02363228f, 0.02316852f, 0.05599758f, 
    0.00339725f, 0.01083185f, -0.03162963f, -0.02396674f, -0.13692378f, -0.04317230f, 0.06617047f, 0.08516587f, 
    -0.12994710f, -0.20578951f, -0.08287357f, -0.09028112f, 0.12312540f, 0.08172476f, 0.12740268f, 0.04120916f, 
    -0.08022943f, -0.04107320f, 0.07584313f, -0.33172816f, 0.09350027f, -0.03651364f, 0.00953166f, 0.01212635f, 
    0.10714660f, -0.21384980f, -0.07532596f, -0.07788154f, 0.15879175f, -0.28391963f, -0.01600563f, 0.12915242f, 
    0.24958180f, -0.04730913f, 0.04367671f, 0.07858890f, 0.07340760f, 0.01344494f, -0.16791873f, 0.13012457f, 
    -0.02198602f, 0.11514279f, 0.08588912f, 0.02413926f, 0.01100595f, 0.12383461f, -0.03554942f, -0.20859820f, 
    0.15435047f, -0.04994244f, 0.00291211f, 0.15072291f, -0.11101333f, -0.06891198f, -0.29199293f, 0.13752574f, 
    -0.26721781f, -0.01440366f, 0.03324991f, -0.00279803f, -0.02961559f, -0.00885087f, 0.06436616f, -0.23015101f, 
    -0.06890661f, 0.31801891f, 0.18553595f, -0.00060008f, 0.00404967f, 0.06404173f, 0.03452035f, 0.08160800f, 
    0.03019075f, 0.06038578f, 0.27713260f, -0.13999093f, -0.00689304f, -0.12638390f, -0.01909355f, 0.03460215f, 
    0.01122555f, -0.22981399f, -0.08868881f, -0.00989445f, 0.00367170f, 0.09274988f, 0.09091625f, -0.15979475f, 
    0.04385624f, 0.08826528f, -0.22997481f, -0.23216294f, -0.10897249f, 0.16356730f, 0.07331951f, -0.05059585f, 
    -0.01415823f, -0.07157037f, 0.05098298f, -0.12626469f, -0.08964144f, -0.04679149f, -0.01617852f, -0.11485307f, 
    0.00926764f, -0.02049523f, -0.00547507f, -0.13347284f, 0.00104026f, 0.06091012f, 0.00893510f, 0.03372104f, 
    -0.17593989f, 0.06943180f, -0.03782392f, -0.12683362f, -0.00498190f, 0.10679461f, -0.02272547f, -0.02383624f, 
    -0.12479077f, -0.01247043f, -0.19862168f, 0.06347138f, 0.17760563f, 0.06080616f, 0.29159772f, 0.04015930f, 
    -0.09391284f, -0.10834940f, -0.15145375f, -0.25812432f, 0.16830394f, 0.08860907f, -0.04208720f, 0.01239723f, 
    0.03560685f, -0.07801393f, -0.08197808f, 0.11743336f, -0.21974632f, 0.05893898f, -0.16102456f, 0.13117908f, 
    -0.04392548f, -0.05929026f, 0.03788427f, 0.04727446f, -0.05322309f, 0.04029935f, 0.01048455f, -0.03369604f, 
    0.05250713f, 0.01723379f, -0.00360897f, -0.01304311f, -0.03981896f, -0.01996514f, -0.01092189f, -0.05161561f, 
    0.01258617f, -0.06766167f, -0.03655447f, 0.04436453f, 0.01299990f, -0.04466584f, 0.02092679f, 0.03416213f, 
    0.03000716f, -0.02245945f, 0.00369839f, 0.04794123f, -0.01425288f, 0.03152702f, 0.01823608f, -0.06910261f, 
    0.04210418f, -0.06469375f, -0.06360224f, -0.03794840f, 0.03019371f, 0.04474689f, 0.05828151f, 0.04308495f, 
    -0.00832792f, 0.03897158f, -0.00895357f, -0.06478309f, 0.03010521f, 0.03994124f, 0.01573269f, -0.02704396f, 
    -0.01580997f, 0.02302921f, -0.06526019f, -0.01187692f, 0.00836467f, -0.05848547f, -0.05063168f, 0.03401524f, 
    -0.05461192f, 0.01003767f, 0.02316946f, -0.04191190f, 0.03806501f, -0.03035764f, -0.02394655f, -0.03535971f, 
    -0.00362241f, 0.03455311f, -0.00596936f, 0.02571391f, -0.04082713f, 0.01721380f, -0.04639146f, 0.04497166f, 
    0.04224959f, -0.01964834f, 0.03179226f, 0.00073520f, -0.04106498f, -0.01069774f, 0.02430701f, 0.02062278f, 
    -0.05079240f, -0.00269204f, -0.01163262f, -0.05108638f, -0.01498790f, 0.05101111f, 0.03005169f, -0.06184880f, 
    0.02066488f, 0.00475948f, 0.01438025f, -0.02870756f, -0.04138310f, -0.04964359f, -0.05271240f, -0.01692346f, 
    -0.04740020f, -0.05130950f, -0.05299289f, -0.03211701f, 0.03111930f, 0.01245926f, 0.03555432f, -0.03025775f, 
    -0.05490257f, -0.00187220f, -0.06090475f, -0.02358923f, 0.00174308f, 0.00294925f, 0.04999888f, -0.03201828f, 
    -0.01904665f, -0.05865200f, -0.01764374f, 0.03913187f, 0.02737971f, -0.03482814f, 0.02017710f, 0.01852588f, 
    -0.00482172f, -0.05469949f, -0.04945656f, 0.00030922f, 0.00306804f, -0.06861905f, -0.02024506f, -0.02226788f, 
    -0.03191943f, 0.00163593f, -0.00611281f, 0.03272127f, -0.00688755f, 0.05847353f, -0.01078378f, 0.00690291f, 
    -0.02525144f, 0.03298709f, 0.02780044f, -0.03579712f, -0.00319285f, -0.04914610f, -0.01248796f, 0.03452295f, 
    0.02314768f, 0.02847544f, -0.00302686f, 0.00810856f, -0.06371652f, 0.02465498f, 0.02054892f, 0.05166156f, 
    -0.01321891f, -0.06573997f, -0.01449599f, -0.04529789f, 0.01983478f, -0.01583785f, 0.00872691f, 0.00758408f, 
    0.01455675f, -0.03883287f, 0.04351456f, -0.05393719f, -0.00787044f, 0.03687802f, 0.03118523f, 0.00456838f, 
    -0.04758250f, -0.04449667f, -0.00094635f, -0.03864915f, 0.01435895f, -0.02232152f, -0.02537091f, -0.04339401f, 
    0.02522466f, 0.02530905f, 0.03173653f, -0.01836169f, 0.00318676f, 0.04412092f, -0.03431280f, 0.01283498f, 
    -0.01854926f, -0.02626892f, 0.04926743f, 0.04254258f, 0.02560039f, -0.06769145f, -0.06057520f, -0.05218320f, 
    0.04065891f, 0.04214223f, 0.03901857f, -0.03062693f, -0.04227373f, -0.03188457f, -0.06498139f, 0.02336178f, 
    -0.00766258f, -0.00498878f, -0.05349496f, -0.04106286f, -0.01821142f, -0.04699416f, -0.05974204f, 0.02271587f, 
    0.02796449f, 0.03683560f, 0.02190895f, 0.03812517f, 0.03269723f, -0.01700190f, -0.05409307f, -0.00016939f, 
    0.03508594f, -0.01018481f, -0.02411832f, 0.03196149f, -0.03765788f, -0.05149895f, -0.03011760f, -0.03745583f, 
    0.02659001f, -0.05605001f, -0.04276862f, 0.00344834f, -0.06268887f, -0.00364953f, -0.01115215f, 0.00417317f, 
    -0.06853398f, -0.05750934f, 0.01636803f, -0.00088728f, -0.01140929f, -0.01395773f, -0.02207103f, -0.05097368f, 
    0.03087843f, -0.04601886f, 0.04535883f, 0.01071625f, -0.00621305f, -0.06570954f, 0.03881536f, 0.03999129f, 
    -0.03365688f, 0.04362019f, -0.02827410f, 0.03392192f, -0.04755719f, -0.02630751f, 0.05062341f, -0.05455568f, 
    -0.05190473f, -0.06230101f, -0.00065611f, 0.00405821f, -0.05351853f, 0.02868718f, -0.02392305f, 0.03434383f, 
    -0.02048161f, 0.04119741f, 0.03534279f, -0.05758246f, -0.06502511f, 0.04133375f, 0.02611262f, 0.00599655f, 
    0.01271243f, -0.06743983f, -0.03450694f, 0.00152459f, 0.04304666f, -0.03047923f, 0.02369442f, 0.03857306f, 
    0.03874913f, 0.03504972f, 0.00173336f, 0.02929137f, 0.01829741f, 0.04651594f, -0.02359883f, -0.05452760f, 
    0.00684211f, 0.00910333f, 0.02251062f, -0.07229342f, -0.01657558f, 0.02755625f, 0.02435200f, 0.00696682f, 
    -0.06480234f, 0.03262505f, -0.06439799f, -0.03496324f, -0.01827620f, -0.01953721f, -0.04882244f, 0.02945833f, 
    0.03123031f, 0.03910651f, 0.02955366f, -0.03417165f, 0.00131532f, -0.02760450f, -0.00894720f, -0.02880176f, 
    0.04129178f, 0.00582921f, 0.00776071f, 0.01200131f, 0.00252372f, -0.04029837f, -0.03020958f, -0.01677080f, 
    -0.00653842f, 0.03762758f, -0.00242820f, -0.02289504f, -0.04791232f, -0.04586120f, 0.04223083f, -0.00320826f, 
    0.01386936f, 0.00875107f, -0.05494971f, 0.02498216f, 0.00811836f, 0.00300857f, 0.01742226f, 0.03761453f, 
    -0.05533731f, -0.05799168f, -0.02960008f, -0.03975585f, -0.06625490f, 0.04464213f, -0.04783601f, 0.04047484f, 
    0.04372562f, -0.04349113f, 0.00152974f, 0.00398789f, 0.02208910f, 0.01751546f, -0.01566492f, 0.01810995f, 
    -0.03819097f, -0.06286742f, 0.02690872f, 0.04358546f, -0.05640758f, -0.04541344f, 0.03109516f, 0.03851870f, 
    -0.00735094f, 0.03666559f, -0.04854299f, -0.03213758f, -0.03724947f, -0.05471041f, -0.04308784f, 0.01697374f, 
    -0.04484464f, 0.01909050f, -0.06079859f, -0.00596158f, 0.03711574f, -0.01646335f, 0.03194369f, 0.03156934f, 
    -0.03323983f, -0.06516182f, 0.03597796f, -0.03204167f, 0.03368017f, -0.04020825f, -0.05204362f, -0.02770921f, 
    0.03390978f, 0.00853834f, 0.02648510f, -0.02646181f, -0.05159383f, -0.01088106f, 0.04311024f, -0.01717179f, 
    0.03425963f, -0.06689114f, -0.05616380f, 0.01361324f, -0.05436815f, -0.05854360f, 0.03643587f, -0.02206545f, 
    -0.00526440f, 0.03120120f, 0.02778633f, -0.01652310f, 0.03858650f, 0.00385071f, -0.03551780f, 0.03147031f, 
    -0.05754793f, -0.04908010f, -0.05613207f, -0.00154303f, -0.01054238f, -0.03162708f, -0.00634067f, -0.03281723f, 
    -0.02917073f, -0.01383696f, -0.00957640f, -0.04992457f, -0.00721583f, -0.05404710f, -0.06872931f, 0.05170243f, 
    -0.05755339f, 0.02529185f, 0.03003583f, 0.02812948f, 0.00137132f, 0.03509608f, -0.00211435f, 0.03379305f, 
    0.02611048f, -0.04794302f, 0.02121966f, 0.00124511f, -0.01503164f, 0.04515973f, -0.04277566f, -0.00085439f, 
    -0.01542538f, -0.01937199f, -0.01809094f, -0.02459338f, -0.04527077f, 0.04318493f, -0.04683829f, 0.03592511f, 
    -0.02241235f, 0.02917073f, -0.02551614f, -0.02211453f, 0.01465993f, 0.01713662f, -0.05656254f, -0.00525868f, 
    -0.01923092f, 0.00294254f, -0.06947453f, 0.04355989f, -0.01484075f, -0.07044572f, -0.05348776f, -0.06677093f, 
    0.04012010f, 0.00512493f, 0.00467231f, -0.01469160f, -0.02454911f, 0.02031346f, 0.01036142f, -0.03845258f, 
    -0.07021222f, -0.02635554f, -0.04699582f, 0.01145140f, -0.03645097f, 0.04076752f, -0.05142651f, -0.04988085f, 
    0.01079715f, 0.00584646f, 0.01276423f, -0.01748691f, 0.03855767f, 0.03283149f, -0.05101669f, -0.00060360f, 
    0.03348112f, -0.01246383f, 0.03240578f, 0.01793349f, 0.02610713f, -0.07197492f, 0.02708739f, 0.05298260f, 
    -0.04660882f, 0.03806249f, -0.05958395f, 0.00522253f, 0.04376057f, 0.02411415f, -0.01513017f, -0.02010136f, 
    -0.06975125f, 0.02168262f, -0.02799934f, -0.03200097f, 0.03837953f, -0.01763930f, 0.00434013f, 0.01583386f, 
    0.00405605f, -0.02738453f, 0.03625663f, -0.06111816f, 0.03330727f, -0.04178828f, -0.01690245f, -0.00434009f, 
    -0.01672314f, 0.01670660f, 0.02321124f, 0.03528632f, 0.02573963f, -0.06045812f, -0.02579198f, -0.06077175f, 
    -0.02496531f, -0.05533062f, -0.03674320f, -0.03328710f, -0.00979632f, 0.00280348f, 0.00210906f, 0.00591220f, 
    -0.02020624f, 0.02806295f, 0.04182597f, 0.01771660f, -0.03253337f, 0.02964112f, 0.00999380f, 0.03045879f, 
    0.02057776f, -0.05748539f, 0.04134149f, 0.00317955f, -0.01496944f, -0.05060424f, -0.03226876f, 0.02353257f, 
    -0.03844798f, -0.02325844f, -0.00702765f, 0.02116132f, 0.04919312f, 0.04624536f, 0.02049338f, 0.03455807f, 
    0.04600595f, 0.02011482f, 0.03565193f, -0.06950854f, -0.02219230f, -0.05177070f, -0.04781692f, -0.04551294f, 
    -0.03481784f, -0.03403413f, -0.02908601f, -0.06125502f, -0.01155498f, -0.06829505f, -0.03855303f, -0.01362694f, 
    -0.04591964f, -0.01816337f, 0.01761731f, 0.04086027f, -0.05806886f, 0.03282267f, -0.05308837f, 0.00322816f, 
    -0.03203444f, -0.05167725f, 0.04703109f, 0.00309188f, 0.00516266f, -0.01595222f, 0.04603347f, -0.04452882f, 
    0.03374022f, 0.04928160f, -0.03442127f, 0.00098030f, -0.01975233f, 0.03673543f, 0.03423750f, -0.01270365f, 
    -0.03859587f, -0.05719511f, 0.02585504f, 0.03037564f, -0.02731817f, -0.05808754f, -0.02091856f, 0.01235264f, 
    -0.05216757f, 0.04393963f, 0.01396788f, -0.03170687f, 0.01249555f, 0.03287492f, 0.01018198f, -0.04919915f, 
    0.01359093f, -0.04850053f, -0.05030004f, -0.06229873f, 0.02093550f, -0.02182614f, -0.05898855f, 0.00229019f, 
    -0.02070304f, 0.00720445f, -0.00022018f, 0.03219477f, -0.01439582f, 0.03424866f, 0.02206475f, -0.06244058f, 
    -0.03643381f, -0.00899342f, 0.04848467f, 0.00956260f, 0.04083782f, -0.05602092f, 0.00862256f, 0.03504705f, 
    -0.04137738f, -0.05436363f, -0.00694837f, -0.03264510f, 0.05409591f, -0.06172177f, 0.03189724f, 0.03644321f, 
    0.03172649f, 0.00042209f, 0.03577762f, 0.03375772f, -0.03697281f, -0.04126108f, -0.02673502f, -0.03812585f, 
    -0.03681679f, 0.04509160f, -0.02162987f, -0.02153338f, -0.01506418f, -0.05038428f, 0.00124660f, 0.02781448f, 
    0.01422625f, 0.04180270f, 0.02475297f, -0.00419015f, -0.01044812f, -0.03035775f, 0.01877716f, -0.00593708f, 
    -0.01758976f, -0.00992676f, -0.01371645f, -0.05209624f, -0.05366129f, 0.01704059f, 0.04132544f, -0.05175656f, 
    -0.05073289f, 0.05314114f, 0.01955660f, 0.03579382f, -0.05624140f, -0.05582444f, -0.03312115f, -0.04230656f, 
    0.02036852f, -0.04502383f, 0.02981627f, -0.05213383f, 0.00951492f, -0.05069834f, -0.00071515f, 0.00210584f, 
    -0.04009582f, -0.01533595f, -0.01184404f, 0.02439109f, -0.02406774f, 0.04541925f, -0.06409614f, -0.02046058f, 
    -0.01141687f, -0.04715087f, -0.00718699f, -0.04389993f, 0.04851137f, 0.03125482f, 0.04792920f, 0.05240349f, 
    -0.06235887f, -0.01964170f, 0.04848854f, 0.03051514f, -0.05902739f, -0.03445973f, -0.01200868f, -0.03486032f, 
    0.02185567f, -0.02152706f, 0.03709620f, -0.03245929f, -0.01198249f, 0.04924407f, -0.03919333f, -0.05981186f, 
    -0.05946977f, 0.05868278f, 0.03383541f, -0.01590775f, 0.05631262f, -0.02847082f, -0.00371833f, 0.02909438f, 
    -0.05773376f, -0.01383629f, -0.01869681f, -0.03066245f, 0.04163660f, -0.00269032f, -0.03925321f, 0.04410522f, 
    0.02337838f, 0.03809217f, -0.05916148f, 0.03620608f, -0.05770338f, 0.03187734f, 0.01256751f, 0.03539469f, 
    -0.05540056f, -0.05731819f, 0.04834511f, -0.04625785f, 0.04399029f, -0.00165516f, -0.02568726f, -0.03635106f, 
    0.00876034f, 0.02084039f, -0.03348278f, -0.01455628f, 0.03978451f, -0.01464126f, -0.03616847f, 0.05531484f, 
    -0.03825909f, 0.05614140f, 0.00245400f, 0.02271929f, 0.00909307f, 0.01710906f, -0.05756484f, 0.01078611f, 
    0.03778864f, 0.00837736f, -0.01934861f, 0.03750418f, -0.03630142f, -0.03416220f, -0.04769245f, -0.05512662f, 
    0.04673937f, 0.04802122f, -0.05870325f, 0.03944737f, -0.03406144f, 0.05312309f, 0.00829182f, -0.01407883f, 
    -0.05995351f, -0.04939147f, 0.02057115f, -0.01976288f, 0.02024964f, -0.05562047f, -0.02854582f, -0.05430397f, 
    -0.02097852f, -0.06088133f, -0.05120263f, 0.04333922f, -0.05226944f, -0.02195401f, -0.04828302f, -0.02280493f, 
    -0.03901450f, 0.01587462f, -0.00088190f, 0.00345341f, 0.04339879f, 0.02933301f, 0.02955156f, -0.04891775f, 
    -0.03408336f, -0.02804300f, -0.02957336f, 0.00793133f, 0.01891108f, -0.04709646f, -0.02685182f, 0.00874414f, 
    -0.03310151f, -0.01485109f, -0.00856607f, 0.02200131f, 0.02020418f, 0.04241130f, -0.02319769f, -0.03621196f, 
    0.05081215f, -0.00825795f, -0.03461779f, 0.01819571f, -0.05002462f, -0.01368615f, 0.02083573f, -0.04645164f, 
    -0.00579478f, 0.00675804f, -0.05354001f, -0.00631498f, -0.01188558f, -0.02220750f, 0.02727398f, 0.04287416f, 
    0.01762057f, 0.02114301f, 0.01445251f, -0.00873632f, 0.02566921f, 0.00084571f, 0.03521659f, -0.04839240f, 
    -0.04141947f, 0.01132620f, -0.01353272f, -0.04917734f, -0.03668335f, -0.00627490f, -0.02598670f, 0.04931416f, 
    0.20868978f, 0.24230482f, 0.08014086f, -0.08812728f, 0.02600460f, 0.03051810f, 0.09323892f, 0.13309056f, 
    0.02097853f, 0.02395861f, -0.18084128f, -0.03229257f, 0.10439390f, 0.18422887f, 0.12935184f, -0.22214842f, 
    0.06292663f, -0.05761895f, -0.14072719f, -0.29100710f, -0.03327022f, 0.00476043f, 0.03077921f, 0.05189610f, 
    -0.05181247f, -0.13764769f, 0.23524642f, -0.01931513f, -0.03073044f, 0.09343737f, -0.09789130f, 0.02517254f, 
    0.23512515f, -0.05853418f, -0.02782917f, -0.11013713f, 0.10791376f, 0.27187729f, 0.20895168f, 0.09780599f, 
    0.07011142f, 0.14106096f, -0.00608574f, -0.00725580f, 0.14445660f, -0.22961161f, 0.02474965f, -0.07183241f, 
    0.12314418f, 0.00450293f, -0.04113792f, 0.03052890f, 0.16863419f, 0.10831043f, -0.22867820f, -0.10986558f, 
    0.01863894f, -0.03948383f, 0.12518141f, 0.12936217f, 0.01669954f, -0.01538565f, -0.03899398f, 0.24211600f, 
    0.01727504f, 0.12328313f, -0.16304298f, -0.05349793f, 0.00138098f, -0.08500595f, -0.18029879f, -0.09728294f, 
    -0.38730687f, -0.25699204f, 0.14314978f, -0.11385446f, -0.01259050f, 0.12265801f, -0.09768550f, -0.07661451f, 
    -0.06350525f, -0.32633400f, -0.04520898f, 0.04259235f, -0.06915831f, -0.07171418f, -0.04167696f, -0.10450280f, 
    -0.18826912f, 0.19574335f, 0.12463856f, 0.13529329f, 0.10995702f, 0.02225400f, -0.10083073f, 0.08076833f, 
    0.06554449f, 0.14148387f, -0.09080460f, 0.05874959f, -0.19197802f, -0.07714344f, -0.03915640f, 0.03626444f, 
    -0.03702066f, 0.07160986f, 0.07757136f, 0.11226264f, 0.17777371f, 0.19930567f, -0.04618000f, -0.03686234f, 
    -0.01169190f, 0.08041119f, 0.05136622f, 0.09377285f, 0.05936783f, 0.36300564f, 0.07806829f, 0.11170971f, 
    0.20169277f, -0.06515911f, -0.00302343f, 0.00969567f, 0.10399066f, -0.03447191f, 0.01792355f, 0.04422551f, 
    0.07133017f, 0.03740863f, -0.02155230f, 0.01189148f, -0.07251120f, -0.08848593f, 0.01749151f, -0.35727811f, 
    0.10576202f, -0.08138702f, 0.08766115f, -0.08822493f, -0.04272230f, -0.04391123f, -0.02131125f, 0.23325998f, 
    -0.03037187f, -0.21980081f, 0.22505128f, -0.05394020f, 0.01329891f, 0.01373994f, 0.00220100f, 0.01875140f, 
    0.10530160f, 0.00035964f, -0.06755061f, -0.01280690f, -0.03074511f, 0.07497162f, -0.19506267f, -0.03073735f, 
    0.08675753f, 0.12242809f, -0.14787187f, -0.22470640f, 0.09966847f, 0.07341526f, 0.04674168f, 0.00538434f, 
    0.02480918f, 0.04735217f, -0.04472834f, -0.00016638f, 0.03356631f, 0.15791023f, 0.04690453f, 0.00624131f, 
    0.00717510f, -0.03911260f, 0.05141633f, -0.05341543f, 0.28332835f, -0.11564411f, 0.11442709f, 0.08708587f, 
    0.01827162f, 0.03198197f, -0.04882206f, -0.03008630f, -0.11694501f, 0.01940161f, 0.21565410f, 0.10552964f, 
    0.02420923f, 0.05048602f, -0.00147275f, -0.00680346f, 0.12992933f, -0.02902538f, 0.21476914f, 0.23443678f, 
    0.20086783f, -0.03498694f, -0.02567223f, 0.06205013f, 0.11409771f, -0.03996223f, 0.17118834f, -0.07741694f, 
    -0.20023957f, -0.01392184f, 0.00046438f, -0.00642016f, -0.04382980f, 0.00304978f, -0.01482641f, 0.18941027f, 
    0.15952545f, -0.03447907f, 0.04232845f, 0.04850697f, 0.01540586f, -0.14897031f, 0.20781599f, -0.01538669f, 
    0.03918657f, 0.22461797f, 0.11026444f, -0.07606459f, -0.14614604f, 0.04633170f, 0.00850077f, -0.08939828f, 
    0.00319746f, 0.03343822f, -0.05091854f, 0.31578520f, 0.07917377f, 0.08856042f, -0.14518996f, 0.03800374f, 
    -0.03640709f, 0.12123363f, -0.03697000f, 0.14590600f, -0.03712213f, 0.04526106f, -0.12447576f, -0.05934374f, 
    0.05132261f, 0.07259797f, 0.04169490f, -0.04381740f, -0.42275950f, -0.18952130f, -0.08338936f, 0.01096614f, 
    -0.01282002f, 0.09781604f, -0.09969603f, -0.13710921f, -0.01262476f, -0.08645542f, -0.07574931f, -0.08398538f, 
    -0.05339263f, -0.08999283f, 0.10885264f, -0.00192737f, 0.07271575f, 0.21054107f, 0.05892306f, -0.04032034f, 
    0.01395426f, 0.11936316f, 0.00953551f, -0.12929355f, -0.06493068f, -0.03596115f, 0.05508597f, -0.05119706f, 
    -0.04800501f, 0.13534632f, 0.07377687f, 0.02045763f, 0.10677930f, 0.08798422f, 0.12294940f, 0.07335292f, 
    -0.11913953f, -0.22979073f, -0.09314056f, 0.08459608f, 0.02200510f, 0.06468622f, 0.07193347f, 0.02029975f, 
    -0.01245401f, -0.28573492f, -0.05247682f, 0.11532594f, 0.00938875f, 0.13647856f, -0.01088354f, 0.02224557f, 
    0.02840602f, -0.04713980f, -0.05854692f, 0.39419898f, 0.36549512f, 0.10157628f, 0.12768587f, 0.01936525f, 
    0.11308366f, 0.03261258f, 0.00876743f, -0.01842387f, 0.10583450f, -0.19609930f, 0.09394626f, 0.06163502f, 
    0.10980695f, 0.01907598f, 0.03565002f, 0.10766485f, -0.06579344f, -0.30115560f, -0.13813421f, -0.16916969f, 
    0.05049650f, -0.03344124f, 0.03532969f, -0.04943319f, 0.05074344f, 0.39260423f, 0.04409905f, 0.01256464f, 
    0.05551635f, 0.09365693f, 0.07641058f, -0.02143113f, -0.01835823f, -0.01175299f, 0.04945397f, -0.19557038f, 
    -0.23890066f, -0.07602507f, 0.05287046f, -0.12651838f, 0.04397069f, 0.00496123f, 0.12541899f, -0.07235540f, 
    -0.12105350f, 0.11306386f, -0.12227554f, -0.11731545f, 0.09180454f, -0.06100211f, -0.07122812f, 0.08588329f, 
    0.22393626f, 0.38168848f, 0.11982510f, 0.02724649f, 0.04325603f, 0.08434024f, -0.07830293f, 0.09418833f, 
    -0.00454339f, 0.22749351f, -0.00139883f, 0.01744983f, -0.23854877f, -0.00890389f, 0.05035555f, 0.03859444f, 
    -0.19401301f, 0.04735342f, -0.05466450f, 0.21486983f, -0.24532691f, 0.01267061f, 0.03673565f, -0.00826260f, 
    -0.06104713f, -0.08465391f, -0.08300337f, 0.13548213f, -0.18540348f, 0.00956491f, -0.00707375f, 0.00730775f, 
    -0.05880679f, 0.03385239f, 0.06768113f, 0.05746446f, -0.16559975f, -0.06694270f, -0.38106138f, 0.21455503f, 
    0.10218265f, 0.02451849f, 0.05550462f, -0.11541446f, -0.04334958f, -0.09878986f, -0.40290800f, -0.46471891f, 
    0.07950819f, 0.05880599f, 0.04548368f, -0.04555114f, 0.04072824f, -0.05014182f, 0.07083550f, -0.09855916f, 
    -0.18324970f, -0.01023989f, 0.04554623f, 0.06831411f, 0.10173742f, -0.16322887f, 0.05385778f, -0.03256553f, 
    0.14080608f, 0.32195815f, -0.08018023f, 0.05708732f, 0.12953557f, 0.03711453f, 0.12549205f, 0.02734953f, 
    -0.07794473f, 0.14985518f, 0.15183914f, 0.09026138f, -0.02000549f, 0.12367871f, 0.22867605f, 0.04771316f, 
    0.10430929f, 0.09213765f, 0.02633250f, -0.12417440f, -0.10875642f, -0.09805650f, -0.02239572f, -0.11514310f, 
    -0.01057572f, 0.06135926f, 0.04762540f, -0.24976756f, -0.02678094f, -0.08117224f, 0.03397227f, -0.12294655f, 
    0.01468196f, -0.19223183f, 0.06627198f, -0.13371502f, -0.03100193f, -0.12459456f, 0.04851012f, 0.15890849f, 
    -0.00358706f, -0.06815749f, 0.03241368f, -0.06653740f, 0.00522822f, 0.18106803f, -0.07000507f, 0.02341770f, 
    0.16915165f, 0.14758641f, 0.02024670f, 0.20600714f, 0.14954856f, 0.12880136f, -0.07438622f, -0.05952472f, 
    -0.18381920f, 0.10760583f, -0.05837154f, 0.04277962f, 0.23466346f, -0.02117335f, -0.19590910f, 0.04817853f, 
    -0.29577440f, 0.15312384f, -0.09653264f, -0.17147700f, 0.00727606f, 0.00881786f, -0.00772020f, 0.42528942f, 
    -0.12805860f, 0.09443742f, -0.03848379f, -0.06038028f, 0.05335169f, 0.07841454f, -0.02147033f, -0.03991563f, 
    -0.15890083f, -0.47646847f, -0.07464340f, -0.04628335f, 0.07008437f, 0.13710442f, -0.02775686f, -0.03210736f, 
    -0.07323091f, -0.02382299f, -0.17774960f, -0.35122687f, 0.08880972f, -0.01853628f, 0.00795386f, -0.00966232f, 
    0.03115759f, -0.05166551f, -0.12623359f, -0.06566375f, -0.07937837f, 0.04134024f, -0.07182398f, 0.00981244f, 
    -0.03829246f, 0.17603712f, 0.02242060f, 0.05693862f, 0.09076227f, 0.22492377f, 0.09901266f, 0.00717820f, 
    -0.12242211f, 0.08468264f, -0.01087954f, -0.01363409f, 0.13529964f, 0.34484720f, 0.33577329f, -0.04834978f, 
    0.00478544f, -0.07177614f, 0.10396776f, 0.03546013f, 0.17071433f, -0.34389701f, -0.05014705f, 0.12230927f, 
    -0.05053706f, 0.06563096f, 0.01660646f, -0.01733115f, -0.08679505f, 0.10879971f, -0.06015724f, -0.14915475f, 
    0.02516031f, 0.05489065f, 0.05796514f, -0.03706777f, 0.07708766f, -0.00059210f, 0.00222606f, -0.20000100f, 
    -0.21057984f, -0.00782984f, -0.00754959f, 0.01668781f, 0.13572310f, -0.06941620f, -0.03468925f, -0.08400176f, 
    -0.15097089f, 0.00681110f, -0.02854944f, 0.16344650f, 0.23974767f, 0.04474608f, -0.11266690f, 0.06167433f, 
    -0.00637264f, 0.02771069f, -0.10127577f, -0.14075591f, -0.10663038f, 0.01093541f, 0.16288778f, -0.04823481f, 
    -0.15576503f, -0.13326941f, -0.08917755f, -0.06146162f, -0.21028614f, -0.03149066f, 0.22422193f, -0.01192079f, 
    0.09315974f, -0.08475763f, 0.04467895f, 0.10912547f, 0.13027745f, -0.15593754f, 0.16673931f, 0.00121074f, 
    -0.14599377f, 0.07837100f, 0.03832681f, 0.15518247f, -0.33043101f, -0.13482305f, 0.11403471f, 0.04967449f, 
    0.08081376f, -0.19948322f, -0.11329897f, -0.14784169f, 0.06313710f, -0.22969018f, -0.21083574f, -0.27341899f, 
    0.11304782f, 0.03887010f, 0.08672474f, 0.02594950f, 0.03226461f, -0.07719280f, -0.10966238f, 0.08352650f, 
    0.18798126f, -0.04396087f, 0.01003969f, -0.00496569f, 0.07653482f, -0.00249005f, -0.15018965f, 0.26631510f, 
    0.16437779f, -0.04910222f, 0.15576500f, -0.14219798f, 0.08754814f, 0.06932635f, -0.06940646f, -0.03716608f, 
    0.06314143f, -0.01987404f, 0.09056931f, -0.07348627f, 0.06137335f, -0.01774077f, 0.01125894f, 0.03533947f, 
    0.12436144f, 0.03658118f, 0.09608594f, 0.07824522f, -0.09542300f, -0.10837537f, -0.04684893f, 0.07346348f, 
    0.14270200f, -0.04022244f, -0.04285321f, 0.13973214f, 0.02550558f, 0.03399848f, -0.15916283f, 0.03849993f, 
    0.04979449f, 0.02528403f, 0.09959242f, -0.10676119f, 0.09197995f, 0.17289512f, -0.04715625f, 0.00147555f, 
    0.01118554f, 0.24469073f, -0.05346812f, -0.32120404f, -0.03801785f, 0.12523353f, -0.10932903f, 0.01363786f, 
    0.04288142f, -0.06715866f, 0.09874369f, 0.02415123f, 0.05881594f, -0.31567901f, 0.01016803f, 0.19314009f, 
    -0.11174016f, -0.17198680f, 0.01762477f, -0.31351012f, 0.18035847f, 0.29394421f, -0.02266866f, -0.10976970f, 
    -0.00087901f, 0.08471775f, 0.18909568f, 0.13700557f, -0.19310419f, 0.01443167f, 0.01348512f, -0.08334696f, 
    -0.26687837f, -0.12866072f, 0.03731452f, 0.05837223f, 0.20642108f, 0.01781384f, 0.03565329f, -0.02857163f, 
    0.05164352f, 0.04257996f, -0.15024394f, 0.00825718f, 0.16451882f, 0.15078714f, 0.12208840f, -0.04445173f, 
    0.11168347f, 0.15652737f, -0.07769805f, -0.29445091f, 0.04948695f, 0.01349094f, 0.07543010f, 0.06297325f, 
    -0.03472546f, -0.09458321f, 0.09188418f, 0.19376697f, 0.08745219f, -0.14031291f, -0.02022768f, -0.17467271f, 
    0.03563829f, 0.04260084f, -0.09217092f, 0.21140718f, 0.08847794f, -0.01025409f, -0.10349887f, -0.15473914f, 
    0.13996488f, -0.01035436f, 0.12412745f, -0.04578671f, -0.01659377f, 0.18348387f, 0.05880222f, 0.04701413f, 
    0.02781436f, -0.09250467f, 0.11430386f, -0.06072426f, 0.10367034f, 0.17121840f, 0.03626153f, 0.07416464f, 
    -0.08986693f, -0.03790602f, -0.14663307f, 0.15487392f, -0.10808776f, 0.19285439f, 0.05164554f, 0.02196182f, 
    -0.05661827f, -0.11713234f, -0.03996930f, -0.19543198f, -0.01663513f, -0.14039816f, -0.10567170f, 0.31819162f, 
    -0.05179165f, 0.05247099f, 0.00692346f, 0.04239128f, 0.06049196f, 0.01722474f, 0.02608469f, -0.04672183f, 
    -0.15911406f, -0.19746856f, -0.09666882f, 0.12992015f, 0.04040218f, 0.08384747f, 0.03721593f, 0.09102004f, 
    -0.08118731f, -0.09916496f, -0.04881362f, 0.00083740f, 0.24127945f, -0.21451372f, -0.03248225f, -0.10686079f, 
    0.11193766f, -0.06343476f, -0.17101111f, 0.10908279f, 0.01456190f, -0.17118649f, -0.17404100f, -0.14714828f, 
    -0.12444978f, 0.05512204f, 0.15837206f, 0.49409175f, -0.15558694f, 0.00068795f, 0.16741192f, -0.11434790f, 
    0.11417527f, -0.07339475f, 0.12087974f, -0.06460942f, 0.15784150f, -0.02452738f, 0.18904975f, 0.15102765f, 
    0.10913780f, -0.04231028f, 0.08514238f, 0.10300807f, 0.03452085f, -0.38178217f, -0.11057687f, -0.14346965f, 
    0.07979634f, -0.04299046f, 0.20169468f, 0.22629172f, 0.09137341f, -0.11507171f, -0.22385263f, -0.08854836f, 
    0.13349314f, -0.07987764f, 0.08273119f, 0.13903330f, 0.00593307f, -0.07954279f, 0.04605945f, -0.32720238f, 
    -0.03796755f, -0.17762873f, -0.08039196f, 0.21688631f, 0.20373690f, -0.13783748f, -0.08111706f, -0.23425837f, 
    0.03431871f, 0.05216485f, -0.03104808f, -0.05927379f, -0.07355694f, -0.04714175f, -0.01374385f, -0.00698591f, 
    0.00906932f, -0.00564953f, 0.05006946f, 0.02589242f, 0.01463024f, -0.03977975f, 0.04082784f, 0.00880490f, 
    -0.01713372f, 0.04860938f, 0.04259719f, 0.01267651f, 0.02016559f, -0.02040667f, -0.05398807f, 0.01235490f, 
    0.02442448f, 0.01413244f, -0.02085413f, -0.04493072f, 0.05047938f, -0.00394907f, 0.00051789f, 0.01980561f, 
    -0.01187230f, -0.01881108f, -0.02675186f, -0.00573279f, -0.03526463f, -0.03439573f, 0.00848785f, -0.02066022f, 
    -0.00571195f, -0.06157948f, -0.00732212f, 0.01268704f, 0.02557704f, -0.05807007f, 0.05377692f, 0.03354034f, 
    0.04884041f, 0.02559133f, 0.01233416f, 0.00086673f, -0.01763477f, 0.03122487f, 0.03366325f, -0.02254456f, 
    -0.04200681f, -0.03270506f, -0.04531689f, -0.01785566f, 0.04584628f, 0.01825443f, -0.01431188f, 0.03952449f, 
    0.00466923f, 0.01291425f, -0.01682970f, 0.03759239f, -0.01479492f, -0.06823935f, -0.02953990f, 0.01696416f, 
    0.03113416f, 0.02901322f, -0.02920670f, 0.01670310f, -0.02038763f, -0.05510103f, 0.04178540f, 0.02523649f, 
    -0.01647643f, -0.02580081f, 0.01507778f, 0.00331278f, 0.03094753f, -0.06515644f, 0.00767586f, 0.02152778f, 
    -0.01031891f, 0.00663651f, -0.06106710f, -0.02349621f, 0.05273434f, 0.03932099f, -0.00894060f, -0.03620228f, 
    -0.03235134f, 0.03405971f, -0.03838681f, 0.00665938f, 0.03286805f, 0.01065894f, -0.02073029f, -0.02682851f, 
    -0.03160144f, -0.05589867f, 0.03767420f, -0.04939557f, 0.02815043f, 0.04087778f, -0.01413823f, 0.00421632f, 
    -0.00357542f, -0.02661302f, -0.01541230f, 0.05799216f, 0.04558501f, -0.04081091f, 0.04998595f, 0.02323545f, 
    -0.03533052f, -0.01124743f, 0.03466523f, -0.03844425f, -0.05448119f, -0.00902048f, -0.02642274f, -0.00457491f, 
    -0.04538448f, -0.05977525f, -0.05371438f, 0.04640959f, -0.04565917f, -0.03132525f, 0.01167876f, -0.04667045f, 
    0.04672470f, -0.01907534f, -0.00965458f, 0.05550805f, 0.05134757f, -0.04298187f, 0.03013814f, -0.02496345f, 
    -0.03646633f, -0.02833944f, 0.02522603f, 0.03819747f, -0.01896485f, 0.01881270f, 0.01197519f, 0.00500794f, 
    -0.00320880f, -0.00423033f, -0.00460781f, 0.00392191f, -0.06230061f, -0.05803934f, 0.01062844f, -0.01541159f, 
    0.04766101f, -0.04831659f, -0.01959929f, 0.03035181f, -0.02331433f, 0.01588092f, -0.03616723f, 0.04197691f, 
    -0.03192930f, -0.05492461f, -0.02970535f, 0.00897730f, 0.01258572f, -0.01198291f, -0.03444532f, -0.03284208f, 
    -0.03213082f, -0.05270959f, 0.03331289f, 0.01452968f, -0.04535487f, -0.05970494f, -0.04651035f, -0.03567816f, 
    -0.00045113f, -0.02372589f, 0.00539944f, -0.03905974f, -0.05595894f, -0.02317352f, 0.03319686f, -0.06113633f, 
    0.01843157f, 0.00676587f, -0.05902690f, 0.01174665f, 0.00551844f, 0.05386349f, -0.04694762f, -0.00818188f, 
    -0.03262388f, 0.04665979f, -0.03931386f, 0.01200306f, 0.04925521f, -0.02219382f, 0.03259734f, -0.01596395f, 
    0.00618982f, 0.03587078f, -0.02047267f, -0.00110021f, 0.00516844f, 0.03906870f, -0.04233724f, 0.03230456f, 
    -0.03627538f, 0.04106707f, 0.02286142f, 0.04220564f, 0.05268086f, 0.04731360f, -0.04860803f, -0.03780861f, 
    0.03348276f, 0.01900158f, 0.02227528f, -0.04408503f, -0.02493531f, -0.03864960f, 0.01369530f, -0.05891908f, 
    -0.05045525f, -0.06587863f, -0.05135727f, 0.03235411f, -0.01395802f, -0.01113146f, 0.01551317f, 0.05910139f, 
    -0.04717672f, -0.05687485f, -0.01468761f, -0.01582336f, -0.03590705f, -0.01767849f, -0.02228792f, -0.01758014f, 
    -0.03272439f, -0.00905411f, -0.01130871f, -0.03423268f, -0.01820521f, -0.05640258f, -0.03569302f, 0.01301385f, 
    -0.01684099f, -0.02915100f, 0.01322412f, -0.03268232f, -0.05641586f, -0.02937675f, 0.02157890f, 0.03175569f, 
    0.02856499f, -0.05346498f, -0.03297611f, 0.04985238f, -0.04525293f, 0.00536026f, -0.01660918f, -0.04128648f, 
    -0.04360892f, 0.02169582f, 0.00989302f, -0.04313250f, 0.03286052f, 0.00674058f, 0.03652778f, 0.01931503f, 
    -0.04302711f, 0.01523065f, -0.04439844f, 0.03027791f, -0.03807376f, -0.04920899f, 0.01454002f, 0.03441449f, 
    0.04040266f, -0.05728630f, -0.05660825f, -0.01596617f, 0.04903746f, -0.04549488f, -0.04254817f, 0.00425359f, 
    0.02647414f, 0.02706035f, -0.06031317f, -0.04624527f, -0.05564179f, -0.00902102f, -0.01586453f, 0.00569999f, 
    0.02643038f, -0.04565569f, -0.00682035f, -0.01089624f, -0.00659118f, -0.04987303f, -0.02539166f, 0.01634720f, 
    -0.05671100f, 0.00301793f, -0.01992399f, -0.02940577f, 0.02429645f, 0.05372898f, -0.02890452f, 0.05448861f, 
    -0.04790916f, 0.04257198f, -0.02800411f, -0.04848678f, -0.01151365f, -0.00420032f, 0.03852902f, -0.01127555f, 
    0.01670211f, 0.04514282f, 0.02805712f, -0.00617789f, 0.02421490f, -0.03594404f, 0.02720401f, -0.04230184f, 
    -0.00035670f, -0.03956248f, -0.04125718f, -0.01817190f, -0.01679813f, 0.00752095f, 0.05271560f, -0.00235588f, 
    -0.03281569f, 0.03262085f, -0.04510501f, -0.05518268f, -0.04853215f, 0.03692240f, -0.02557106f, 0.01200802f, 
    -0.03875099f, -0.00115043f, -0.05472306f, -0.00226195f, 0.03844435f, -0.02188728f, -0.01879535f, -0.05980461f, 
    -0.05314245f, 0.04582388f, -0.05422783f, -0.03246107f, 0.05411402f, -0.02249866f, -0.06173625f, -0.02362669f, 
    0.04736909f, 0.00468739f, 0.03067811f, -0.06217017f, -0.03468791f, -0.01311280f, 0.02229426f, -0.01770700f, 
    -0.05285561f, 0.01191449f, -0.04664202f, -0.00902707f, 0.02653794f, -0.01674962f, -0.02345901f, 0.00099783f, 
    0.02154010f, 0.00250570f, -0.01571823f, -0.01872544f, 0.02864596f, 0.05065437f, 0.02520651f, 0.00130186f, 
    -0.04732343f, -0.04406429f, 0.02097684f, 0.04939732f, -0.00052696f, -0.00229969f, 0.02671358f, 0.01819479f, 
    -0.04313442f, 0.04251979f, 0.03638792f, -0.02741316f, 0.03582944f, -0.00845439f, 0.02355309f, -0.02202323f, 
    0.01763954f, -0.05625553f, 0.02827698f, 0.05658986f, 0.00836300f, -0.00165661f, -0.01063637f, -0.00432105f, 
    -0.02721520f, -0.01970571f, -0.02801486f, -0.01695831f, -0.03205673f, 0.02310414f, -0.02299487f, 0.04628089f, 
    -0.05244634f, -0.03995253f, -0.03920128f, -0.03111637f, -0.04928711f, -0.02670803f, -0.05541920f, -0.03649868f, 
    -0.04087183f, -0.02538511f, 0.01293706f, 0.00626188f, -0.00270202f, -0.03767766f, -0.03108343f, -0.02111252f, 
    -0.04017196f, 0.00784835f, 0.01047282f, 0.01444434f, -0.01466601f, -0.03034651f, 0.01294085f, 0.02472981f, 
    0.04572766f, 0.01013629f, -0.02220255f, 0.04720411f, -0.03744951f, -0.03490762f, -0.04693682f, -0.04864641f, 
    -0.01519985f, 0.01481638f, 0.02265720f, -0.04092928f, 0.02263375f, -0.04924244f, -0.00721443f, 0.00530060f, 
    -0.00776031f, 0.03521265f, 0.00005860f, -0.05478765f, 0.02813330f, 0.01159558f, -0.01655041f, -0.01351600f, 
    0.03812645f, 0.01702576f, 0.00327734f, 0.02537878f, 0.01315259f, 0.00289735f, 0.04592174f, -0.03242077f, 
    -0.03610974f, 0.02722447f, 0.04093450f, -0.04666544f, 0.00460416f, -0.01964297f, 0.04147547f, -0.04641162f, 
    0.05178734f, 0.00617709f, 0.00204287f, -0.00534474f, 0.02102377f, -0.02455783f, -0.02835015f, 0.02032341f, 
    -0.05199949f, 0.01744576f, 0.01650003f, -0.06193814f, 0.02302607f, -0.02450500f, -0.00351666f, -0.04684217f, 
    -0.01847041f, 0.01594719f, -0.00760421f, -0.05227056f, 0.01333407f, -0.02693983f, 0.05321801f, 0.02671977f, 
    -0.04301428f, 0.03589818f, -0.03624819f, 0.00458438f, 0.01694310f, -0.04411942f, 0.04359498f, 0.03040643f, 
    -0.04549613f, -0.05489138f, 0.00185177f, 0.02451355f, 0.05154965f, 0.01895043f, -0.05052841f, 0.01067739f, 
    0.03583001f, -0.01550255f, -0.00717950f, -0.03561746f, -0.03883906f, 0.02961325f, 0.04362746f, -0.03583074f, 
    -0.02200042f, -0.00705606f, 0.05223798f, -0.02553563f, 0.00391423f, -0.05080640f, 0.05389858f, 0.05358189f, 
    -0.02175410f, 0.01960832f, -0.04234508f, 0.03543861f, -0.03641371f, -0.00723540f, 0.02505039f, -0.03398126f, 
    0.00530009f, -0.05349397f, -0.04851749f, 0.03302604f, 0.03937175f, -0.02199595f, -0.01188538f, 0.02040198f, 
    0.01209856f, -0.04634045f, -0.00201541f, -0.05667778f, -0.05656865f, -0.04374864f, -0.01537382f, 0.00020018f, 
    0.04422380f, 0.06249889f, -0.05131945f, 0.01834642f, -0.00496015f, -0.02480375f, 0.04320458f, -0.03000579f, 
    0.07888880f, 0.28219977f, 0.12809439f, 0.00134280f, 0.13310820f, -0.14304031f, 0.18434209f, -0.16824979f, 
    0.02130987f, 0.08689899f, 0.09208173f, 0.02145529f, 0.09179389f, -0.06522127f, 0.00528680f, 0.03973516f, 
    0.10104100f, 0.04833747f, 0.17031819f, 0.16474757f, -0.07189618f, 0.13785422f, -0.01545418f, -0.16657138f, 
    -0.07478309f, 0.11463123f, 0.04011440f, 0.26665482f, 0.16526558f, -0.01773692f, 0.10453450f, 0.13630515f, 
    0.30216649f, 0.00824894f, 0.02120090f, -0.12869510f, 0.13150558f, 0.14483368f, 0.05717643f, -0.09335050f, 
    -0.06007165f, -0.08239708f, 0.01658596f, -0.16950901f, -0.06947871f, -0.03520200f, -0.05246525f, -0.20704634f, 
    -0.02061314f, -0.03690657f, 0.00149485f, 0.02262475f, 0.16399141f, 0.12595890f, -0.05904604f, -0.00386506f, 
    -0.02859180f, 0.06421625f, -0.02810519f, 0.04542435f, -0.07905612f, 0.05468921f, -0.04351129f, 0.09050889f, 
    0.30848971f, -0.00188368f, 0.07812460f, 0.26437959f, 0.10175103f, -0.38426438f, -0.05427353f, -0.11375793f, 
    0.18105477f, 0.24786907f, -0.25657636f, -0.08565182f, 0.13951810f, 0.10362196f, -0.03142986f, 0.11343499f, 
    0.07087646f, -0.35397720f, 0.03063065f, 0.09189314f, 0.17439511f, -0.26835698f, 0.07755490f, 0.14789815f, 
    0.15667583f, -0.08689695f, 0.04589488f, 0.02280708f, 0.07077738f, 0.10635656f, -0.01707144f, 0.13184604f, 
    0.07795181f, -0.00523081f, 0.07966894f, 0.09682252f, -0.08284598f, -0.24364746f, -0.00147334f, 0.03627746f, 
    -0.05045101f, 0.05438398f, 0.13491346f, -0.00535395f, 0.06927236f, -0.08094090f, -0.04109177f, 0.21515080f, 
    0.07956607f, 0.09574680f, -0.03256188f, 0.13695523f, -0.17258383f, 0.10449046f, -0.12503047f, -0.21520792f, 
    0.20735057f, -0.02237626f, -0.02704656f, 0.11199205f, -0.36597115f, -0.09038123f, -0.22105783f, -0.19334628f, 
    0.07774462f, 0.04959437f, 0.14909233f, -0.06839047f, 0.07018764f, 0.02740385f, 0.10631637f, 0.24614049f, 
    -0.08177749f, 0.06634507f, 0.05090540f, -0.02891274f, -0.08854502f, 0.26011792f, 0.15907770f, 0.18322766f, 
    0.08582922f, 0.08202297f, 0.03730031f, 0.20496477f, 0.03575615f, -0.08581202f, -0.10849859f, 0.15931404f, 
    0.15613228f, -0.35066897f, -0.09189030f, 0.16012318f, 0.27926236f, -0.18231952f, 0.05609813f, -0.06198894f, 
    0.08366156f, 0.12724854f, 0.02506083f, 0.07886631f, 0.11899303f, 0.19137014f, -0.06672000f, 0.21942081f, 
    0.13693886f, -0.14997047f, -0.00198021f, -0.15592025f, 0.05369702f, 0.04459946f, -0.04965147f, 0.07437612f, 
    0.15168382f, -0.06104936f, 0.07962015f, 0.01709877f, 0.13522068f, 0.06652872f, 0.11573725f, 0.08299120f, 
    0.02478053f, 0.19135192f, -0.19590142f, 0.05254898f, -0.22995517f, 0.15438500f, -0.06303287f, 0.09960120f, 
    0.03347117f, 0.04833460f, 0.17088793f, -0.12876891f, 0.04972581f, -0.05738059f, 0.03408404f, 0.11755100f, 
    -0.00418187f, 0.07141410f, -0.02241823f, 0.22068240f, 0.08689562f, -0.04861108f, 0.05023473f, -0.02414399f, 
    -0.10733341f, -0.16221297f, 0.03873395f, 0.05971232f, -0.05280658f, 0.14110130f, 0.05531069f, -0.12046732f, 
    -0.08436788f, -0.23304984f, 0.23734358f, 0.04796926f, -0.03697039f, 0.13823196f, 0.15073907f, -0.10149375f, 
    0.11120980f, -0.09990285f, 0.08547058f, 0.05181077f, 0.03970573f, 0.06533652f, -0.06171057f, 0.02293265f, 
    -0.06313539f, -0.00473184f, 0.07972790f, 0.17100592f, -0.21073596f, 0.04987627f, -0.13572232f, 0.01642100f, 
    -0.17533432f, -0.02778215f, 0.02247282f, -0.06247952f, -0.13882747f, -0.24972127f, 0.26365563f, 0.04847774f, 
    -0.08216729f, -0.09462500f, 0.00914506f, -0.13369341f, 0.51720357f, 0.11477128f, -0.08769447f, -0.02929790f, 
    -0.01346974f, 0.09442393f, 0.04611715f, 0.12101578f, 0.16663364f, -0.29429430f, -0.03699132f, -0.24097924f, 
    0.19637479f, -0.09407064f, -0.22307666f, -0.18820651f, 0.16374308f, 0.00230283f, 0.06934306f, -0.28095165f, 
    0.05744972f, 0.03563545f, 0.05564611f, -0.21826755f, 0.01971072f, 0.08091188f, -0.06626128f, 0.10860413f, 
    -0.05898672f, 0.05457330f, 0.22351982f, -0.01644516f, -0.00649726f, 0.16055360f, 0.05995230f, 0.05111821f, 
    0.02940143f, 0.04709947f, -0.00328485f, -0.00336723f, -0.05297334f, -0.03849812f, -0.02330959f, 0.04870712f, 
    -0.02064542f, 0.03590017f, -0.02068426f, -0.02072584f, 0.04838546f, 0.00700867f, -0.04767671f, -0.05674523f, 
    -0.01039818f, -0.06150046f, 0.02299900f, 0.05162789f, -0.02496856f, 0.06002915f, -0.02083037f, 0.03286199f, 
    -0.01371441f, 0.01750237f, -0.03087815f, -0.00919621f, 0.02933033f, -0.01161825f, -0.06593013f, -0.00356712f, 
    -0.00472901f, -0.00302871f, 0.00901152f, 0.02054078f, -0.02131347f, 0.01563871f, 0.00795243f, -0.01542709f, 
    0.01692145f, -0.06127824f, -0.00568560f, -0.01215763f, -0.00076046f, -0.04587301f, 0.04825766f, 0.00558957f, 
    -0.02225166f, -0.04073121f, 0.04496474f, 0.02588212f, -0.01093292f, 0.03800613f, 0.01286238f, -0.01616715f, 
    0.01153256f, -0.02800363f, -0.05682021f, -0.02057783f, -0.00125134f, 0.04578359f, 0.00430444f, -0.00277331f, 
    0.04036978f, -0.00910823f, 0.00029910f, -0.00542488f, -0.02883117f, -0.05110883f, -0.00499139f, -0.02322573f, 
    -0.02594644f, 0.06046367f, 0.00436478f, -0.04063847f, 0.04516708f, 0.03745775f, 0.02014913f, -0.06379111f, 
    -0.04012459f, -0.06479671f, -0.01358463f, 0.03916813f, 0.01329739f, -0.03151697f, -0.05191369f, 0.01886648f, 
    -0.04740066f, -0.00617899f, -0.06727959f, 0.03264062f, -0.06073586f, -0.03747560f, -0.00620970f, -0.02857449f, 
    -0.03269130f, -0.05953218f, 0.02568983f, -0.01902789f, 0.03289249f, 0.00048015f, -0.02592622f, -0.01365837f, 
    -0.04628242f, -0.04107839f, 0.04725271f, 0.01009126f, -0.03159463f, 0.00634591f, -0.06183622f, 0.02019462f, 
    -0.04061664f, 0.04941880f, -0.04251901f, -0.04126430f, -0.04380558f, 0.02093536f, 0.04710570f, -0.02665317f, 
    0.03585306f, 0.00455382f, -0.02463973f, 0.04003733f, -0.04817048f, 0.04603038f, -0.03172749f, 0.02459817f, 
    0.02189898f, -0.04181869f, -0.05619836f, 0.05559798f, -0.05647870f, -0.03744907f, 0.00079491f, -0.01321365f, 
    0.04532474f, 0.03617311f, -0.04290896f, 0.00324509f, -0.03366582f, -0.02146178f, -0.02352906f, 0.02026199f, 
    0.00204218f, -0.03924149f, 0.02559731f, 0.03804399f, 0.01307603f, 0.00773158f, 0.01338111f, 0.02541039f, 
    0.05277254f, -0.04824704f, -0.03955375f, -0.03670673f, -0.00765448f, -0.02671386f, 0.03023090f, -0.04388996f, 
    0.04267436f, -0.02955524f, 0.02237043f, 0.03495432f, 0.01672143f, -0.04943943f, 0.03956332f, -0.04203614f, 
    0.04990859f, 0.02705205f, 0.01073989f, 0.00074204f, -0.05299439f, -0.00914151f, 0.04078864f, 0.04562381f, 
    -0.04318436f, -0.06271316f, 0.04306995f, 0.04757150f, -0.05100998f, 0.03105485f, -0.00699280f, -0.02414675f, 
    -0.00173050f, 0.00601350f, -0.05144875f, 0.01221939f, -0.01420613f, -0.04657512f, -0.04516377f, 0.00234478f, 
    -0.05836293f, 0.03808515f, 0.02488402f, 0.04689078f, -0.01048060f, -0.04478006f, 0.00078867f, -0.06046499f, 
    -0.04358565f, 0.00611239f, -0.01239145f, 0.01829385f, 0.04573622f, -0.05623328f, -0.01097344f, -0.05338304f, 
    -0.04773170f, 0.02647364f, -0.00941842f, -0.04686264f, -0.02150299f, 0.01940013f, -0.04844379f, -0.02697244f, 
    0.01980171f, 0.04557778f, -0.04008146f, 0.03647207f, 0.01054414f, 0.01175805f, -0.00275014f, -0.05290779f, 
    0.04603597f, 0.02083031f, -0.02042029f, -0.00788372f, -0.02668286f, -0.01404293f, -0.00340989f, -0.04265719f, 
    0.05287617f, -0.03204008f, 0.04945806f, 0.01518506f, -0.00727474f, -0.01111833f, 0.03113315f, 0.01386926f, 
    -0.04143337f, -0.05932292f, 0.03980876f, 0.01035598f, -0.04030176f, -0.05878255f, -0.00682403f, -0.02356306f, 
    0.03009475f, 0.01518447f, -0.02283075f, 0.01486755f, 0.03401050f, -0.00090076f, -0.04034909f, -0.00439674f, 
    -0.05790209f, 0.04326655f, -0.05410304f, -0.00230050f, 0.05490082f, -0.04636991f, -0.04628168f, -0.01956837f, 
    -0.01650661f, 0.03070340f, -0.01261846f, 0.01474256f, 0.02016501f, -0.03967332f, -0.05991294f, 0.03818677f, 
    -0.04816229f, -0.05738319f, -0.01457987f, 0.03968721f, 0.02262366f, 0.00285319f, -0.01282479f, 0.03804541f, 
    -0.00496058f, 0.00106775f, 0.02851960f, 0.01022524f, 0.00566435f, 0.03961393f, -0.03321269f, -0.01637630f, 
    0.02535278f, 0.02138460f, 0.00616510f, 0.02727570f, 0.00113602f, 0.01251826f, -0.00133422f, -0.01497907f, 
    0.01698318f, -0.00858299f, 0.00012574f, -0.04604277f, -0.00053708f, -0.05739526f, -0.04633942f, 0.04431735f, 
    0.03249285f, -0.03832078f, -0.04725770f, 0.01633867f, -0.03615302f, 0.03931300f, 0.03872277f, 0.04886661f, 
    -0.01579273f, -0.00225650f, -0.04433446f, -0.02004759f, -0.01666642f, -0.01027570f, -0.03347765f, 0.02655780f, 
    -0.05345658f, -0.06305983f, -0.05022282f, -0.04757614f, -0.01189831f, -0.05480028f, 0.00104778f, 0.01767917f, 
    -0.03015113f, 0.02843033f, 0.01736979f, 0.01750472f, -0.02345275f, -0.02684559f, 0.00537680f, -0.01212622f, 
    0.01487030f, 0.00403103f, -0.00596541f, 0.04229528f, -0.05868667f, -0.04091107f, 0.01140647f, -0.04438580f, 
    0.05148286f, -0.00704059f, 0.02979206f, -0.05866208f, 0.05468446f, 0.04957635f, -0.01709034f, 0.02888269f, 
    0.01471501f, -0.02760247f, -0.02985734f, 0.03826483f, 0.04273025f, -0.00033626f, -0.02697112f, 0.02296775f, 
    0.04000780f, -0.06333061f, 0.03388217f, -0.04606155f, 0.03253430f, -0.03796950f, 0.01776580f, -0.05301937f, 
    -0.04269628f, -0.06062774f, -0.03942025f, 0.02222044f, 0.01997427f, 0.02973432f, -0.02063202f, -0.03164453f, 
    -0.05203900f, 0.03227070f, -0.01761940f, 0.04050394f, 0.00673137f, 0.00678350f, 0.05450802f, 0.03800780f, 
    -0.01289303f, -0.06088644f, -0.00635161f, 0.04669599f, -0.04995065f, 0.02270811f, 0.01187725f, -0.03448640f, 
    0.02077169f, -0.05086803f, 0.03765130f, -0.02387439f, 0.03442010f, -0.00054360f, -0.03268666f, -0.01114766f, 
    -0.04900072f, 0.04737662f, -0.00651850f, -0.04250467f, -0.00152616f, -0.05845450f, -0.03331245f, -0.03024296f, 
    -0.01038427f, 0.03882268f, -0.03780763f, 0.00269183f, 0.02447262f, -0.03211672f, 0.04123094f, -0.02758338f, 
    -0.01615667f, -0.05059065f, 0.01050363f, -0.01500980f, -0.05029128f, 0.01984738f, -0.04345967f, -0.04157180f, 
    0.02359135f, 0.02635448f, 0.04114696f, 0.00757230f, 0.01984903f, -0.00037392f, -0.06174467f, -0.05386825f, 
    0.02005279f, 0.04313726f, 0.00405763f, -0.06163386f, -0.03023043f, 0.05169878f, -0.00587850f, -0.04207342f, 
    -0.04782417f, 0.00791054f, 0.01715373f, -0.00476235f, -0.03133151f, 0.03750464f, -0.01157958f, -0.03084414f, 
    -0.01175316f, -0.04334946f, -0.03733609f, -0.03421976f, 0.00775070f, 0.03920613f, -0.02171572f, -0.02708531f, 
    0.03689274f, -0.02525243f, -0.03572888f, -0.01429185f, 0.04656823f, -0.00552689f, 0.01197983f, 0.03811235f, 
    -0.04130436f, 0.01506294f, -0.01224676f, -0.04652825f, -0.01357333f, 0.02806567f, 0.00566394f, -0.02493542f, 
    -0.02650525f, -0.01601860f, 0.00434788f, 0.01070998f, 0.01503306f, -0.04832008f, -0.02798114f, 0.04195910f, 
    -0.05585060f, -0.03203671f, 0.00190813f, 0.02662850f, 0.04114039f, -0.00221815f, 0.03150438f, 0.02256745f, 
    0.04438344f, -0.03969210f, 0.02426441f, 0.03315821f, 0.00251954f, -0.06090898f, -0.04821408f, -0.05488136f, 
    0.03280403f, -0.00101025f, 0.03725071f, 0.01470709f, -0.04921819f, -0.00279325f, -0.05624926f, -0.04666368f, 
    0.01457381f, -0.05965253f, -0.01679981f, -0.03512427f, 0.00300885f, -0.00419655f, -0.04246460f, 0.02098170f, 
    -0.01965663f, 0.02969860f, 0.02457016f, -0.01317607f, 0.00676257f, -0.04744936f, -0.01369836f, 0.02144017f, 
    -0.05852769f, 0.03658962f, -0.00048286f, -0.00636614f, -0.03860558f, -0.02465670f, -0.03898188f, -0.00617140f, 
    -0.01047438f, 0.02183582f, 0.04851991f, 0.01661639f, -0.03124683f, 0.03496400f, 0.00250953f, 0.02955856f, 
    -0.03400288f, 0.03432073f, -0.02073334f, -0.02749730f, 0.04923290f, 0.03974017f, -0.03267843f, 0.05248577f, 
    -0.03098496f, -0.03253140f, -0.00540934f, -0.04481411f, 0.00675591f, 0.04745531f, 0.00179249f, -0.02214840f, 
    -0.02068467f, -0.02565566f, 0.00852112f, -0.04939545f, 0.01397988f, 0.00742885f, 0.04642064f, -0.05967950f, 
    -0.05328069f, -0.03310124f, -0.06171858f, -0.05095141f, 0.00336040f, 0.04139946f, -0.05543913f, 0.02219160f, 
    0.01452516f, -0.00499344f, -0.02417989f, 0.04049505f, 0.02759505f, -0.00210795f, 0.00648446f, 0.01689185f, 
    -0.13504331f, -0.14933760f, -0.22317138f, 0.03369461f, 0.06264443f, 0.02029625f, -0.20442075f, 0.00152087f, 
    -0.10039406f, -0.10766435f, -0.03092422f, 0.03688986f, -0.09388759f, 0.08749162f, 0.05863692f, 0.08225551f, 
    0.10811631f, 0.12531780f, -0.02867487f, 0.21487904f, 0.08466417f, 0.00622469f, -0.05637398f, -0.00983086f, 
    -0.11840718f, 0.14451924f, 0.14523914f, 0.06340305f, 0.06905001f, -0.03767759f, -0.00728713f, -0.08636522f, 
    0.25382015f, 0.20664021f, 0.10384542f, 0.14797615f, -0.17430943f, 0.36714020f, -0.01460521f, 0.14939016f, 
    -0.03729412f, 0.00631492f, -0.08513715f, -0.08503961f, -0.20962475f, 0.10088504f, 0.08289832f, 0.10883837f, 
    -0.08900990f, -0.06990078f, 0.01996155f, 0.03568010f, -0.02886727f, 0.11232132f, 0.04671556f, -0.14590244f, 
    -0.02391812f, -0.05344994f, 0.03860704f, 0.00237015f, -0.00641047f, 0.12578413f, -0.10775273f, -0.05318984f, 
    0.12580951f, -0.09840509f, 0.09617560f, -0.11211988f, 0.16022477f, 0.04643162f, -0.01767953f, -0.09538081f, 
    0.21285865f, -0.04697001f, -0.13014686f, 0.13565233f, 0.08591212f, 0.15573522f, -0.11162937f, 0.17832907f, 
    0.05405147f, 0.12884632f, -0.03580268f, 0.06308872f, 0.06872321f, -0.11860760f, 0.10961254f, 0.02871924f, 
    -0.01591253f, 0.14439827f, -0.25449204f, -0.04732182f, -0.09134021f, -0.07824218f, -0.01893131f, 0.12628332f, 
    -0.03630331f, -0.06058204f, -0.09058554f, -0.03260166f, -0.13808948f, -0.06138117f, 0.06540643f, -0.03770449f, 
    0.00094839f, -0.03476042f, 0.01542103f, -0.06853298f, -0.10271563f, 0.02829295f, -0.03113605f, -0.05679328f, 
    0.05490061f, 0.01683592f, -0.10612530f, -0.00524135f, -0.08666619f, 0.09137793f, -0.21532664f, -0.22857583f, 
    0.10316478f, 0.12356061f, -0.05939398f, 0.05679724f, -0.09301209f, -0.14560635f, 0.01869376f, -0.24798021f, 
    0.08545535f, 0.00651776f, -0.02588625f, -0.07179700f, 0.07811944f, 0.03428908f, 0.11799981f, 0.16140221f, 
    0.19356611f, 0.09490225f, 0.08958513f, 0.03790681f, 0.01627219f, 0.02253013f, 0.09524354f, 0.05552300f, 
    0.11109193f, -0.02859478f, 0.00558972f, 0.05774520f, -0.00742897f, -0.07342275f, 0.05218375f, -0.03678434f, 
    0.11083725f, 0.21026196f, -0.10835247f, 0.06634779f, 0.01090397f, -0.01359465f, 0.01808138f, 0.01421080f, 
    0.02330820f, 0.05592668f, -0.10456067f, 0.16163647f, 0.12689480f, -0.04183277f, -0.10339794f, -0.04364193f, 
    0.01612805f, -0.17086960f, 0.04635045f, -0.20781338f, -0.31009671f, 0.13597701f, 0.02425865f, 0.09571510f, 
    0.01877106f, -0.02574795f, -0.03295130f, -0.04378097f, 0.01831979f, -0.21561439f, 0.11109357f, 0.04499474f, 
    0.01907017f, 0.00280383f, 0.07371230f, 0.05540468f, 0.04850198f, -0.06364766f, -0.14962699f, 0.06197205f, 
    -0.01549044f, 0.04779405f, -0.00246332f, -0.00053019f, 0.10218378f, 0.05214087f, -0.51290411f, -0.06023505f, 
    -0.09676882f, -0.09909533f, 0.14530055f, -0.10613464f, 0.06827629f, 0.09404820f, 0.11774856f, -0.21812026f, 
    -0.08889705f, -0.10110527f, -0.03550547f, -0.11788141f, 0.12523702f, -0.04656840f, -0.02164124f, -0.00084015f, 
    -0.01289166f, -0.07289819f, 0.05015597f, 0.10565084f, -0.11764803f, 0.08371841f, -0.04529094f, 0.05628893f, 
    0.00116822f, -0.29788756f, -0.01911625f, 0.01527122f, 0.07786874f, 0.05248939f, -0.03178508f, -0.01190955f, 
    -0.00484665f, -0.05464867f, -0.12487770f, 0.17427413f, -0.44399124f, 0.04785673f, 0.03892416f, -0.02835130f, 
    0.18705215f, -0.06862643f, -0.11710474f, -0.20509902f, 0.07697215f, -0.02775181f, 0.06571355f, 0.14793324f, 
    0.12252151f, -0.02990389f, 0.07524595f, -0.14459102f, 0.17306866f, 0.11867463f, -0.06902662f, 0.09651667f, 
    -0.10830176f, -0.03450438f, 0.02269216f, 0.00746886f, 0.10674270f, -0.10783955f, 0.01262308f, -0.04743358f, 
    0.03858277f, -0.19862700f, -0.13912271f, -0.11113021f, 0.09421796f, -0.00387504f, 0.21936664f, -0.11583997f, 
    -0.05563266f, 0.09511227f, -0.09988101f, -0.12092800f, 0.22154112f, 0.03198453f, -0.12853840f, 0.43991014f, 
    -0.10359708f, 0.03358353f, -0.15812017f, 0.14905128f, -0.01113543f, 0.20034690f, -0.11061396f, 0.10820024f, 
    0.30771300f, 0.07617451f, 0.23274313f, -0.20668760f, 0.14544515f, -0.09261200f, -0.02615465f, 0.00563083f, 
    0.08135681f, -0.30726242f, 0.05752109f, 0.08512820f, 0.09636068f, 0.04387334f, 0.07577937f, 0.13875540f, 
    0.14824720f, 0.14565207f, -0.21064726f, 0.07240570f, -0.07027727f, 0.13592266f, 0.08404519f, 0.19743861f, 
    -0.07689513f, 0.08313123f, 0.13790643f, 0.23432148f, 0.10208848f, 0.24364588f, 0.14103428f, 0.01119735f, 
    -0.08834941f, 0.00501774f, -0.02864024f, 0.10115031f, 0.08986627f, 0.12402300f, 0.28108817f, -0.08440448f, 
    0.06030083f, -0.01686963f, -0.18764628f, -0.00082301f, 0.16839205f, 0.05442405f, 0.05700070f, -0.14334346f, 
    0.07382809f, -0.00133687f, 0.20540176f, 0.06071715f, -0.01143691f, -0.00462645f, -0.06695728f, -0.07569799f, 
    -0.47012553f, -0.44335473f, 0.13782449f, 0.29167187f, 0.07168626f, -0.11315140f, 0.09995663f, -0.06544685f, 
    -0.01995498f, 0.14742044f, 0.22660013f, -0.00177783f, 0.18676953f, -0.01150830f, 0.12432416f, -0.10201786f, 
    -0.21674922f, 0.14314272f, 0.10515938f, 0.12986091f, -0.00225323f, -0.09913036f, -0.07502142f, 0.02655603f, 
    -0.04931900f, -0.19294490f, 0.16008604f, -0.11203164f, 0.00890051f, 0.06667988f, 0.08095263f, 0.16466579f, 
    0.02680520f, 0.10173803f, 0.10315508f, -0.15579256f, 0.01929258f, -0.04535237f, -0.00827050f, -0.13494702f, 
    0.16838345f, 0.05425131f, 0.07178503f, 0.03853443f, 0.13835457f, -0.18076918f, -0.11978402f, -0.06153829f, 
    -0.05023495f, 0.08483117f, 0.17201631f, 0.07316981f, 0.39643702f, -0.21881925f, -0.09026712f, 0.00946475f, 
    -0.03070696f, -0.12955993f, 0.02420856f, -0.01511472f, 0.00825892f, 0.23998322f, -0.13437814f, 0.05513063f, 
    -0.11864272f, -0.09859326f, -0.04212702f, -0.06637416f, 0.01701346f, 0.12190039f, 0.40103367f, 0.14911126f, 
    -0.13152467f, -0.06034661f, -0.10799974f, 0.08971435f, 0.01128601f, 0.07989717f, 0.08100311f, -0.29571956f, 
    -0.14796528f, -0.12541004f, 0.09719054f, 0.18819368f, 0.06773287f, -0.01145379f, -0.05703896f, 0.00759909f, 
    -0.13533929f, -0.05041169f, 0.07703011f, 0.20371065f, 0.15070540f, 0.11938719f, -0.09557825f, 0.04839412f, 
    0.16173598f, -0.00600878f, 0.13113281f, 0.07932045f, -0.03247568f, -0.03456183f, 0.11438022f, 0.03195934f, 
    -0.01913438f, -0.00177293f, 0.01287684f, 0.01261798f, -0.04085136f, -0.06237752f, -0.13678317f, 0.00475681f, 
    0.01405034f, 0.01981502f, 0.22525978f, 0.25184584f, 0.03594043f, -0.14937863f, -0.16398960f, 0.09396556f, 
    -0.06063719f, 0.00327492f, 0.05458290f, 0.11809234f, 0.24520816f, 0.04171209f, 0.10850254f, 0.01267397f, 
    0.02109329f, 0.06048423f, 0.08787547f, 0.00422870f, 0.09057686f, -0.30152169f, 0.12318610f, -0.03400862f, 
    -0.13893373f, 0.06934685f, 0.06898716f, -0.04920500f, 0.37995940f, 0.01483733f, 0.25565675f, -0.29808441f, 
    0.13354833f, -0.21107668f, 0.11732826f, -0.03628240f, -0.04459675f, 0.01120948f, 0.08151157f, 0.20050554f, 
    0.10143533f, -0.13791496f, -0.23071589f, -0.01213808f, 0.15305467f, 0.00176158f, 0.10003250f, 0.06130629f, 
    0.24429040f, 0.14446537f, -0.00730854f, 0.00434052f, 0.01664258f, 0.11537199f, 0.02741488f, -0.05341254f, 
    0.00231442f, 0.09416580f, -0.13948309f, -0.06657479f, -0.15167446f, 0.10789553f, -0.04639013f, -0.02232775f, 
    -0.05940964f, -0.09920032f, 0.11261939f, -0.02243792f, -0.00566240f, -0.32341132f, 0.07094055f, 0.18391766f, 
    0.04217678f, 0.04751576f, -0.06937529f, 0.14047189f, -0.09855673f, 0.09199103f, 0.02595794f, -0.04250687f, 
    0.08394304f, -0.04737902f, 0.12511364f, 0.07427476f, -0.18502270f, 0.07721633f, 0.04173157f, 0.04499595f, 
    0.11025438f, 0.00508948f, -0.18967395f, 0.03757896f, -0.04463664f, -0.40714508f, -0.02258818f, -0.13381609f, 
    0.10832873f, 0.16118580f, 0.20393506f, 0.22003005f, 0.06725278f, -0.17452197f, 0.38905522f, 0.15882017f, 
    -0.01958999f, -0.04363612f, 0.06483231f, 0.00375173f, 0.09647363f, -0.15709512f, 0.18031479f, -0.03444216f, 
    0.04165800f, 0.03427427f, -0.03412634f, -0.05001821f, 0.09087676f, 0.05748023f, 0.11819636f, -0.16415268f, 
    0.25904542f, 0.27820921f, 0.01242095f, -0.01641605f, -0.10869902f, -0.02621750f, -0.00821284f, 0.12429797f, 
    0.02067228f, -0.26480833f, 0.21164285f, -0.07229014f, -0.10282202f, -0.04748646f, 0.11177295f, -0.08011916f, 
    0.08147739f, -0.24111913f, -0.26981887f, -0.05305116f, -0.10736649f, -0.05346810f, -0.03059512f, 0.09269043f, 
    -0.12277048f, -0.19387467f, 0.15440789f, -0.15561138f, -0.02390708f, -0.23758501f, 0.00701358f, 0.05764944f, 
    -0.00454677f, -0.00905957f, 0.06603977f, 0.16327955f, 0.16514386f, 0.26856500f, 0.01643988f, 0.07621564f, 
    -0.14536154f, -0.17092498f, -0.00164338f, 0.01204063f, -0.00476777f, -0.03114290f, 0.11689354f, 0.09086435f, 
    -0.05412570f, 0.10787606f, -0.02519046f, 0.00767542f, 0.13280185f, -0.02289085f, 0.05118816f, 0.11500420f, 
    -0.21535660f, -0.15929884f, -0.09945028f, 0.09530108f, -0.00672207f, -0.01999263f, -0.02894828f, -0.36897579f, 
    -0.38185811f, 0.12230527f, 0.03015896f, 0.08195771f, 0.06814990f, -0.17834456f, -0.12570196f, -0.01090501f, 
    0.20491110f, 0.21714893f, -0.16499409f, -0.04171867f, 0.04751408f, 0.04893966f, -0.08280377f, 0.01517558f, 
    -0.05632292f, 0.23587520f, -0.00299484f, -0.14550196f, 0.03289798f, -0.00404334f, 0.02050032f, -0.08985355f, 
    0.00644191f, 0.02573466f, 0.09616634f, -0.13497196f, 0.00407394f, -0.12855542f, 0.03850940f, -0.04231808f, 
    0.08271812f, -0.06692211f, -0.15568668f, 0.12413246f, 0.15667564f, -0.30117807f, 0.11269046f, -0.08785849f, 
    0.11135813f, -0.06986222f, -0.00128701f, 0.19970521f, -0.10256936f, -0.09715864f, 0.15085897f, 0.11950196f, 
    0.00192506f, 0.09667846f, -0.11155149f, -0.04170975f, 0.01442759f, 0.17203209f, -0.24532713f, -0.29060477f, 
    0.08901859f, 0.22800387f, 0.15404207f, 0.06064938f, 0.07485177f, -0.18016893f, 0.16180976f, 0.18298146f, 
    -0.05695352f, 0.00356123f, 0.17842881f, -0.02797478f, 0.01539085f, 0.00165334f, -0.04684527f, -0.23595354f, 
    0.03903266f, 0.04790062f, -0.18416727f, 0.00233147f, -0.04494474f, 0.11070198f, -0.01478995f, 0.04667057f, 
    0.15996508f, 0.03275920f, -0.02183681f, -0.00153037f, -0.04529715f, -0.00297659f, -0.00954705f, -0.05552787f, 
    -0.09871427f, -0.41590574f, 0.16847964f, -0.05796957f, 0.02438235f, -0.01407010f, 0.05370034f, -0.00581293f, 
    -0.01613346f, 0.02609807f, 0.25353247f, -0.23979710f, -0.00154408f, 0.10562618f, -0.15770486f, 0.05536649f, 
    -0.09109801f, -0.12469607f, -0.11188895f, -0.05020889f, -0.07118805f, -0.35375166f, -0.02320221f, 0.10279732f, 
    0.27632564f, 0.04624583f, 0.11659960f, -0.17007667f, -0.15232500f, -0.18838024f, -0.27770743f, 0.13137342f, 
    0.13191746f, 0.17840569f, -0.07967736f, 0.00551339f, 0.03599551f, -0.00860844f, 0.09819211f, -0.33648232f, 
    0.18488191f, -0.06412172f, -0.01746708f, -0.05446456f, 0.20865130f, -0.07122867f, 0.22677235f, -0.01444443f, 
    0.18885140f, 0.12940466f, -0.22670850f, -0.00250169f, -0.03703915f, -0.01192513f, 0.00556082f, 0.13012548f, 
    0.05421707f, -0.03935540f, -0.02510726f, 0.11945752f, -0.02287445f, 0.02027727f, 0.06655216f, -0.00713032f, 
    0.32221904f, -0.06779086f, 0.12667774f, 0.06141922f, 0.01285938f, -0.11401768f, -0.04821168f, 0.06528487f, 
    0.07485353f, 0.09822914f, -0.41704732f, -0.17442006f, 0.12875412f, 0.01857890f, 0.01808850f, 0.02241243f, 
    -0.01144507f, 0.14862785f, -0.00688689f, -0.09905612f, -0.11475755f, 0.17274201f, -0.08032103f, -0.00262960f, 
    0.01663300f, 0.15507028f, 0.18830408f, -0.12033049f, -0.37358928f, 0.09025291f, 0.02723769f, -0.03919730f, 
    0.10517436f, -0.29411715f, 0.12458768f, 0.03807537f, -0.13170077f, 0.06612857f, -0.03924939f, -0.23347083f, 
    -0.03866867f, 0.03497554f, 0.03960061f, 0.14667061f, 0.00585352f, -0.19998573f, -0.02699949f, 0.10548485f, 
    0.07491109f, -0.07522029f, -0.07631411f, -0.07364867f, 0.05463294f, 0.19948553f, 0.01921587f, 0.03017336f, 
    0.01644386f, -0.12841418f, -0.02113383f, -0.03423133f, 0.06650869f, -0.02847967f, 0.04480536f, -0.33660975f, 
    0.01253898f, 0.14521785f, 0.10849072f, 0.05849028f, -0.12995188f, 0.01493786f, -0.04626928f, 0.06228162f, 
    0.13498832f, -0.15339409f, -0.00496430f, 0.06441505f, -0.00954832f, -0.01869961f, 0.03139542f, 0.09094982f, 
    -0.03880924f, 0.06959449f, 0.03280418f, 0.05217753f, -0.02904741f, 0.24929790f, 0.04992613f, 0.05768910f, 
    -0.06121132f, 0.04501624f, -0.09638058f, -0.08037990f, 0.01378996f, 0.09375536f, -0.14733049f, 0.19636083f, 
    0.18111403f, 0.04879203f, -0.14184842f, 0.22590344f, -0.06024102f, 0.03296315f, 0.12969719f, 0.07812168f, 
    -0.14024588f, 0.00979927f, -0.14425032f, 0.07224054f, -0.04799151f, -0.33597764f, 0.08153024f, -0.09276333f, 
    -0.05444802f, 0.28750864f, 0.12909694f, 0.03325321f, -0.20263623f, -0.14662088f, 0.04889635f, 0.02859377f, 
    0.09839123f, 0.02199225f, 0.29618043f, 0.04527316f, -0.07101090f, -0.05135975f, 0.16345073f, -0.09068728f, 
    -0.03943935f, 0.14353147f, -0.03131151f, 0.06982370f, 0.03325743f, 0.04583547f, -0.19117448f, -0.15060440f, 
    0.06599510f, 0.14342947f, -0.08740718f, 0.23645455f, -0.25624293f, 0.11329890f, -0.15233879f, 0.04718311f, 
    -0.41162643f, 0.01664008f, 0.25355184f, 0.08730660f, -0.15108886f, 0.00946553f, 0.11407462f, 0.06224928f, 
    0.06731998f, -0.11183587f, -0.15063050f, -0.02839922f, -0.02107524f, 0.01117085f, -0.14543487f, 0.09220347f, 
    -0.00917652f, 0.00919558f, -0.00159832f, -0.08008593f, 0.24941728f, 0.04641198f, -0.08639671f, 0.09988134f, 
    0.02384688f, 0.04898537f, 0.03973337f, 0.13426137f, -0.37379637f, 0.20530954f, 0.08079223f, -0.14833306f, 
    -0.13476892f, 0.02912482f, 0.09809532f, -0.13615817f, 0.11596781f, -0.28124216f, 0.15221094f, 0.09599397f, 
    0.09713805f, 0.09589322f, -0.04708216f, -0.03661924f, 0.05781695f, 0.02088702f, -0.01068729f, 0.04158651f, 
    -0.14880042f, -0.16125701f, 0.02943320f, -0.05376488f, -0.03975843f, -0.01634665f, 0.04869580f, 0.10471629f, 
    0.01323876f, 0.03705219f, -0.08526915f, -0.10438217f, 0.04869501f, 0.20429251f, -0.06650979f, -0.21474305f, 
    -0.03387824f, -0.18986022f, 0.01571645f, 0.05613585f, 0.19877413f, 0.02498010f, -0.00355418f, -0.04623282f, 
    -0.15311265f, -0.00158511f, 0.21477209f, 0.03547136f, 0.04384583f, 0.18882668f, 0.17841782f, -0.09075513f, 
    -0.13138175f, 0.05410694f, 0.04951112f, 0.02289285f, -0.04831069f, 0.06626414f, -0.11121146f, 0.06997765f, 
    0.06676427f, -0.09720230f, -0.14875768f, -0.10738745f, 0.25741893f, -0.04505327f, -0.13309687f, 0.01497642f, 
    0.04677474f, -0.18193071f, 0.07137637f, 0.11609078f, 0.11128506f, -0.08319632f, 0.06709120f, -0.08204484f, 
    -0.03507641f, 0.05070319f, 0.06747423f, -0.07185543f, 0.31081879f, -0.03807768f, 0.09709799f, 0.18660194f, 
    0.03581915f, -0.07581183f, -0.05461021f, -0.08619882f, 0.04872007f, 0.15944046f, 0.09240595f, -0.00351673f, 
    -0.04078418f, -0.18566367f, -0.01427940f, 0.02320956f, -0.10572496f, 0.04744087f, 0.15604953f, -0.17090183f, 
    -0.03159688f, -0.02017255f, 0.11204522f, -0.02673409f, 0.00144308f, 0.07034954f, 0.03597853f, 0.08196852f, 
    -0.19759279f, 0.05957073f, -0.00047012f, -0.16002123f, -0.00140028f, -0.13720128f, 0.03829908f, 0.13531676f, 
    0.03359463f, -0.00335549f, -0.01550744f, 0.06742071f, 0.04429758f, -0.16190712f, 0.17570341f, 0.08509938f, 
    -0.19197425f, -0.09146059f, -0.07329439f, -0.10686169f, -0.05813353f, -0.17797470f, -0.07882158f, -0.09034895f, 
    0.09964392f, 0.14311537f, -0.09910423f, -0.23831844f, 0.10449181f, -0.03360384f, 0.00441781f, 0.13794865f, 
    -0.12973978f, 0.01792066f, 0.02586392f, 0.07817048f, 0.31550515f, 0.02114083f, -0.17666671f, 0.00113118f, 
    0.02914301f, -0.00204018f, -0.09954350f, 0.06783230f, -0.41804963f, -0.01509147f, 0.20299357f, 0.09037434f, 
    0.03060184f, 0.05787764f, 0.07536185f, 0.03896560f, 0.05387506f, -0.16466792f, -0.01666991f, -0.02227376f, 
    0.11968326f, 0.00116053f, 0.09471240f, 0.04145470f, 0.14810701f, -0.10301860f, 0.00922919f, -0.13122338f, 
    0.00222068f, 0.02474548f, 0.13269201f, -0.01857877f, -0.02652845f, 0.00411460f, -0.13050590f, -0.26396969f, 
    0.09325715f, -0.05895153f, -0.05078356f, 0.12360910f, 0.04417543f, 0.04047449f, 0.05073765f, -0.20960252f, 
    -0.03610198f, 0.27104312f, 0.05296204f, -0.05069872f, 0.12164839f, 0.14953977f, -0.07698859f, -0.01724215f, 
    0.00997243f, 0.07260405f, 0.00183253f, 0.00792710f, 0.03491176f, -0.04403498f, -0.00551507f, 0.03113565f, 
    -0.06866428f, 0.11600044f, 0.19146876f, -0.10228895f, 0.10483650f, 0.07827307f, -0.06239460f, -0.04449932f, 
    0.00216067f, 0.05760371f, -0.05223050f, 0.15617999f, -0.09600970f, -0.17658673f, 0.13791364f, -0.06829205f, 
    0.12591036f, 0.02258587f, 0.10961104f, -0.01481019f, 0.04186470f, -0.11598723f, -0.07747685f, -0.20091859f, 
    0.20381005f, 0.01166608f, 0.10761319f, -0.10273088f, -0.13493899f, 0.15001045f, 0.03323257f, 0.12296700f, 
    -0.01033293f, 0.10805466f, -0.07691774f, 0.02682695f, -0.07222918f, 0.02957480f, -0.44835424f, 0.26351038f, 
    -0.12781875f, -0.00645494f, 0.01311966f, -0.06255742f, -0.15274826f, 0.02317551f, 0.14605083f, -0.04248932f, 
    0.13596043f, -0.03514117f, 0.02670523f, 0.00230820f, -0.04726990f, 0.05306631f, -0.30915496f, 0.06805313f, 
    0.13175514f, 0.02993604f, -0.06229664f, 0.07903962f, -0.00356168f, -0.06911856f, 0.17044453f, -0.10519317f, 
    0.13653867f, -0.23953962f, -0.04204425f, -0.19452640f, 0.23664790f, -0.01588601f, -0.06820653f, 0.00708445f, 
    0.18224171f, -0.16913553f, 0.27812269f, 0.08920411f, -0.30148429f, -0.07623536f, 0.00415190f, 0.01208315f, 
    0.11612788f, 0.06358992f, 0.10935967f, -0.45737416f, 0.14418292f, -0.12478450f, -0.05497895f, -0.01169809f, 
    0.12781920f, -0.04576816f, -0.11256456f, -0.06636962f, -0.00193273f, 0.19296733f, -0.26264811f, 0.05838748f, 
    -0.02724599f, 0.10295523f, -0.06515101f, 0.02613139f, 0.04878176f, -0.20307085f, 0.07199393f, -0.29165176f, 
    0.00341145f, 0.03799224f, 0.07074430f, -0.18022847f, 0.10896295f, -0.05569706f, -0.16826767f, 0.09649146f, 
    0.16738880f, -0.09527698f, 0.07251711f, -0.01533499f, -0.05818629f, 0.06457108f, -0.04741571f, 0.25893000f, 
    -0.09853302f, 0.04565646f, 0.02188447f, -0.05466601f, -0.09241835f, 0.01186664f, 0.05998289f, -0.10075648f, 
    0.03364288f, 0.08023188f, 0.01562115f, 0.04001803f, -0.05058115f, 0.01662398f, 0.04648282f, -0.01283993f, 
    -0.03537658f, -0.32681203f, 0.19954756f, 0.11286430f, 0.10743116f, 0.00339199f, -0.01895941f, -0.04780695f, 
    0.13946261f, -0.06563777f, 0.21158299f, -0.11054169f, -0.10970284f, 0.18489413f, -0.06845615f, 0.01080679f, 
    -0.11887316f, 0.07164637f, 0.04129129f, -0.04000763f, 0.10415863f, 0.01895756f, 0.03894031f, -0.01662781f, 
    0.05238126f, -0.01604069f, 0.04934369f, 0.09513412f, -0.26308435f, -0.00819727f, -0.23684704f, 0.01497172f, 
    -0.01147817f, 0.04554136f, 0.02790494f, -0.03023508f, 0.03086868f, -0.06370551f, -0.12651590f, -0.23491907f, 
    -0.07885157f, -0.11981153f, 0.00654840f, 0.07944140f, 0.04761758f, 0.04384585f, -0.27656323f, 0.39838898f, 
    -0.00669263f, -0.03462061f, -0.04947021f, -0.01146231f, -0.12678503f, -0.04358501f, -0.09438418f, -0.09321176f, 
    -0.07555138f, -0.03846923f, 0.00709295f, 0.02086536f, 0.03531253f, -0.09475630f, -0.10070325f, 0.06761654f, 
    -0.12035888f, -0.15653311f, 0.11152630f, -0.00264026f, 0.09576543f, 0.08429941f, 0.03577711f, -0.06211235f, 
    0.05905531f, -0.45823404f, 0.04076383f, -0.27005246f, -0.14914238f, 0.12670660f, 0.05544264f, -0.06360815f, 
    0.02889533f, 0.03274928f, -0.11340380f, 0.05125827f, -0.06380017f, 0.06163399f, -0.12999342f, 0.05393695f, 
    0.12220873f, 0.05291787f, 0.06181077f, 0.11072736f, -0.26511741f, 0.15949696f, 0.02531992f, 0.04459623f, 
    0.02198413f, 0.02257235f, -0.06407923f, 0.03831619f, 0.43613070f, 0.00101535f, 0.07967374f, 0.02847659f, 
    -0.06674758f, 0.06290551f, 0.05461665f, -0.03170569f, -0.00223644f, -0.01475968f, -0.02117399f, -0.06369076f, 
    -0.01035285f, -0.13745660f, -0.12842622f, -0.10230117f, 0.15329592f, -0.13328993f, 0.01767065f, -0.18227796f, 
    0.02118621f, -0.13104165f, -0.10884620f, -0.02653843f, -0.10220354f, 0.08934871f, 0.10192154f, -0.09438138f, 
    -0.03329893f, 0.14839819f, -0.01539405f, 0.10900697f, -0.06039571f, -0.02717589f, 0.04666382f, -0.12893213f, 
    0.01443889f, 0.01970006f, -0.03252080f, 0.04819641f, -0.00397543f, -0.04730590f, -0.03770908f, -0.03197749f, 
    0.03863033f, -0.01000703f, 0.00238410f, 0.01685059f, -0.01988658f, -0.06097387f, -0.05975726f, 0.02007730f, 
    0.00075995f, 0.04313787f, -0.04060633f, -0.04994376f, -0.01992443f, 0.01872255f, 0.00417626f, -0.05609988f, 
    0.00361183f, 0.04847144f, -0.04681277f, 0.03316360f, 0.04551985f, -0.02168996f, 0.02939714f, 0.01736477f, 
    -0.05235734f, -0.00375529f, 0.03746977f, 0.04605295f, -0.03069157f, 0.03728454f, 0.02385959f, 0.01631069f, 
    -0.04693799f, -0.03028229f, -0.05617537f, -0.00651815f, -0.02919722f, 0.02581077f, 0.02205133f, -0.03290786f, 
    -0.02863580f, 0.00739875f, 0.04371337f, -0.02354398f, -0.04156934f, -0.00133929f, -0.04525962f, 0.03904850f, 
    0.02865797f, 0.00750226f, -0.00256165f, 0.04531158f, 0.02568882f, -0.05000905f, 0.02638430f, -0.02843223f, 
    -0.03874458f, -0.02278246f, -0.03885719f, -0.03185946f, -0.05298517f, -0.02379638f, -0.04718589f, 0.03090887f, 
    -0.01268914f, 0.05820594f, 0.04660204f, 0.01494743f, -0.00894704f, 0.02380627f, 0.04728461f, 0.00557467f, 
    -0.02297158f, 0.01386529f, -0.05006043f, -0.04183757f, -0.05051697f, -0.02357801f, -0.05017487f, -0.04558405f, 
    -0.05697313f, 0.01291963f, 0.04492901f, 0.04856509f, -0.04468054f, 0.02760289f, -0.05068504f, 0.03381517f, 
    -0.00833517f, -0.04654293f, 0.05072023f, 0.03763576f, -0.01652107f, 0.00138227f, -0.03106119f, -0.04331441f, 
    -0.04468732f, -0.00420114f, -0.04344558f, 0.02896512f, 0.02765646f, 0.04414501f, -0.00663677f, 0.00446779f, 
    -0.01456934f, 0.04721028f, 0.04151683f, 0.05397402f, 0.01575833f, -0.01528249f, -0.00617395f, -0.05795315f, 
    -0.01774936f, 0.00713483f, -0.05955740f, 0.04988716f, 0.04752625f, 0.01321377f, 0.00509464f, 0.01668742f, 
    -0.03970845f, -0.00490497f, -0.05279494f, 0.04252714f, -0.03649288f, -0.05475027f, -0.05413078f, -0.05177324f, 
    -0.05232446f, 0.05297166f, 0.04844237f, -0.04175916f, -0.03721023f, -0.04506603f, -0.05262019f, 0.03410720f, 
    0.03547318f, -0.00400520f, 0.00273905f, 0.02432769f, -0.02238160f, -0.05524173f, -0.06048816f, 0.04449895f, 
    -0.00289674f, 0.02144797f, -0.02022128f, 0.02471282f, 0.03402159f, -0.02230385f, -0.01147095f, 0.02858931f, 
    -0.01019287f, 0.00053490f, -0.03378420f, 0.04550863f, 0.00601823f, -0.02130632f, -0.05289340f, -0.04055886f, 
    -0.00894136f, 0.03062973f, 0.00519368f, 0.00880657f, -0.04905957f, -0.03273286f, 0.01589541f, -0.01913206f, 
    -0.01933521f, 0.00503102f, -0.03561417f, -0.01582189f, -0.01348141f, -0.00311546f, -0.05228462f, -0.06117213f, 
    0.05233626f, -0.06424087f, 0.00434687f, 0.02641916f, -0.02747519f, -0.03777101f, -0.05615056f, -0.01109686f, 
    -0.02096195f, -0.00546770f, 0.05514234f, -0.00077272f, -0.02245690f, -0.06138536f, 0.02408108f, 0.04044299f, 
    0.02517932f, 0.00228110f, -0.03162435f, -0.06405484f, -0.03118289f, -0.01453564f, -0.05811891f, 0.02304834f, 
    -0.00150413f, -0.02390861f, 0.03426241f, 0.03317985f, 0.02293578f, -0.02960476f, 0.00207344f, -0.04931226f, 
    0.05207462f, -0.01635847f, -0.04504328f, 0.02421802f, -0.06720315f, 0.02072074f, -0.05464079f, -0.04770143f, 
    0.04031105f, 0.03530275f, -0.02895403f, -0.04710393f, 0.02626603f, -0.03012205f, -0.01365858f, -0.06355476f, 
    -0.02061811f, 0.03069179f, 0.01659557f, -0.00229662f, -0.00313430f, -0.01344740f, -0.00775269f, -0.06355607f, 
    -0.03097788f, -0.01587513f, 0.03534777f, 0.04617859f, 0.02462664f, -0.04087289f, 0.02846908f, -0.03161240f, 
    -0.00225503f, -0.02442534f, 0.00167503f, -0.00982061f, -0.01124090f, -0.00685661f, 0.02086615f, 0.01424217f, 
    0.02262623f, -0.03940925f, -0.05355916f, -0.06264378f, 0.01725467f, -0.05911257f, 0.05305233f, 0.01587745f, 
    0.00450066f, 0.00209718f, 0.00047981f, -0.05150992f, 0.02175393f, -0.00889952f, 0.03109424f, 0.04589168f, 
    -0.06980401f, 0.00939579f, -0.01306317f, -0.03128286f, 0.02404041f, 0.02659503f, 0.01057238f, -0.01903234f, 
    -0.03901790f, -0.03687377f, 0.02617744f, -0.00061171f, 0.04976397f, -0.05971820f, -0.01936686f, -0.05304032f, 
    -0.00970779f, 0.00985052f, -0.03268122f, 0.01284194f, -0.00311608f, -0.04558903f, -0.01782230f, -0.00482699f, 
    -0.04975662f, -0.06815986f, -0.04397849f, -0.02589627f, -0.05627285f, -0.05410321f, 0.02521327f, 0.04306642f, 
    -0.00526145f, -0.05468874f, 0.00768327f, 0.03057295f, -0.01158444f, -0.02994664f, -0.02129862f, -0.05844486f, 
    -0.03702295f, -0.00359896f, -0.00461754f, -0.01453859f, 0.01721802f, -0.04052695f, -0.01760774f, -0.02787677f, 
    -0.02250127f, 0.01008393f, -0.04798605f, -0.04941339f, -0.05034284f, 0.02355480f, 0.01771718f, -0.02841888f, 
    -0.02869764f, 0.03302484f, 0.04355754f, -0.00016799f, -0.04633632f, -0.02819156f, -0.05737780f, 0.04273608f, 
    -0.01382443f, 0.05476542f, -0.05076561f, -0.01947661f, 0.01096785f, -0.01851394f, 0.01567210f, 0.03827924f, 
    0.03380357f, 0.02518644f, -0.04166019f, -0.02994365f, 0.02048865f, 0.01534472f, 0.01151736f, -0.00038912f, 
    -0.01943626f, 0.04109363f, 0.01300051f, -0.04122405f, -0.04237669f, -0.01984404f, 0.02499449f, -0.04779057f, 
    -0.03772422f, -0.05700630f, 0.02768223f, -0.02509897f, -0.01250315f, 0.00652139f, -0.01450692f, 0.05797496f, 
    -0.01191688f, -0.03165497f, -0.04781486f, -0.03451654f, -0.05365617f, -0.00006368f, 0.05546708f, -0.03981902f, 
    -0.05475082f, -0.03894681f, -0.02893845f, 0.00645785f, 0.04990213f, 0.05433217f, 0.01366055f, -0.03011828f, 
    -0.03318188f, 0.02518200f, -0.01896347f, 0.01084547f, 0.00599178f, 0.04104211f, -0.04660923f, -0.04729114f, 
    -0.03856955f, 0.01076282f, 0.03339722f, -0.06013890f, 0.02523777f, -0.03260958f, 0.04971188f, -0.05092785f, 
    -0.03882797f, 0.05093517f, -0.00900566f, 0.04323433f, 0.03515097f, 0.03996533f, 0.03711630f, 0.04857274f, 
    -0.02341962f, 0.04691609f, -0.03019485f, -0.00654854f, -0.04435593f, -0.04292345f, 0.02136551f, -0.02742289f, 
    0.04755727f, -0.00086371f, -0.05511189f, -0.04597798f, -0.03649431f, 0.04814940f, -0.06080747f, 0.00796077f, 
    0.02346930f, 0.02197042f, 0.04308229f, 0.01739931f, 0.01626290f, -0.04317555f, -0.05558773f, 0.02896860f, 
    -0.02000460f, 0.02285455f, 0.04241912f, -0.06615463f, -0.04435026f, 0.00028226f, 0.03725269f, -0.04892049f, 
    0.05861247f, 0.02234763f, -0.04882772f, -0.00572147f, -0.00840722f, -0.01726609f, -0.00711995f, -0.00152347f, 
    0.03922181f, 0.02439137f, -0.00168783f, 0.01282667f, 0.03504093f, -0.04575354f, -0.05810415f, 0.01926771f, 
    -0.03174521f, 0.00001723f, 0.01053134f, -0.02212843f, -0.02203097f, 0.00643149f, 0.04611579f, -0.00036604f, 
    -0.03564662f, 0.05115643f, -0.05585574f, -0.03506967f, -0.04710736f, -0.00090486f, 0.00303768f, -0.00816775f, 
    -0.01716705f, -0.03821684f, -0.03787154f, 0.01676517f, 0.01181509f, -0.05885717f, -0.03269885f, 0.03408796f, 
    0.01410925f, -0.02770162f, -0.05419565f, -0.02851248f, 0.03585922f, -0.00530755f, 0.01345958f, 0.02226994f, 
    -0.05762787f, -0.01050834f, -0.00410312f, 0.04054305f, -0.03209339f, -0.03523862f, -0.04669589f, 0.02966969f, 
    0.04196049f, 0.04793926f, 0.00653902f, -0.01644262f, 0.01555019f, 0.01883295f, 0.05180347f, 0.04126985f, 
    -0.03711429f, -0.02977664f, -0.01460662f, -0.01492596f, -0.00974685f, -0.06012901f, 0.00472952f, -0.04554629f, 
    -0.01064290f, -0.00344793f, -0.00006182f, -0.00887998f, -0.00819255f, -0.02932182f, 0.02623109f, 0.04609939f, 
    0.03330608f, 0.02169493f, -0.00031505f, 0.05440830f, -0.02314453f, -0.01173685f, -0.05128205f, -0.04990964f, 
    -0.00271275f, 0.00598378f, -0.05775814f, -0.05198417f, -0.02790586f, -0.01838956f, 0.03469021f, -0.01253862f, 
    -0.04969421f, -0.05226344f, -0.03597625f, -0.02176096f, -0.06009261f, 0.02535096f, -0.01273387f, -0.03485779f, 
    0.00448004f, -0.04441635f, -0.00307714f, -0.04438297f, -0.03056626f, -0.04323754f, -0.01357764f, -0.04953993f, 
    -0.05475420f, -0.00270031f, 0.02611816f, -0.02382645f, 0.06029095f, -0.00179971f, -0.00390214f, -0.05181906f, 
    -0.01168139f, 0.04125792f, -0.03897562f, -0.00557039f, -0.04213225f, -0.01441887f, 0.02823346f, 0.01109334f, 
    0.02937947f, 0.02689636f, -0.05443558f, -0.01136024f, 0.03598388f, 0.04827255f, -0.04890622f, 0.02545779f, 
    0.23860022f, 0.23113036f, 0.20457174f, -0.15544426f, 0.02526368f, 0.12525374f, -0.10274667f, -0.00396186f, 
    -0.03385584f, -0.13061744f, 0.17228651f, -0.00086546f, -0.02134162f, 0.09448213f, -0.07753197f, -0.01962278f, 
    0.04303106f, -0.00837083f, -0.07325974f, -0.13483171f, -0.10003150f, 0.13766935f, -0.00091020f, 0.04970571f, 
    0.05348176f, 0.01564068f, 0.03601516f, 0.00946630f, -0.14256638f, -0.03123774f, 0.01051731f, 0.06836659f, 
    -0.05244197f, 0.07385150f, 0.00592357f, -0.11467583f, 0.12166414f, 0.09781464f, 0.11530070f, -0.10456795f, 
    -0.07122578f, -0.02985217f, -0.12283901f, 0.10217576f, -0.11943612f, 0.10467627f, 0.10353886f, 0.00865168f, 
    0.17168508f, -0.15699525f, 0.04868147f, 0.03568603f, 0.01594064f, 0.10803399f, 0.01059514f, -0.06256398f, 
    -0.00525754f, -0.07314099f, -0.05348442f, 0.08575827f, 0.12511925f, -0.05635136f, -0.05631810f, -0.22425096f, 
    -0.08729582f, 0.02538456f, 0.02311642f, -0.08061577f, 0.09161520f, 0.04572599f, -0.15299134f, -0.04333556f, 
    -0.02521363f, 0.11658809f, -0.21365234f, -0.03411622f, 0.00921465f, 0.03875831f, -0.34798867f, -0.02682154f, 
    0.08053598f, -0.06024797f, 0.05802333f, -0.07843211f, 0.09019788f, -0.02178109f, -0.08256365f, 0.00292190f, 
    -0.08733815f, 0.07954911f, 0.03155644f, 0.04373953f, -0.14710344f, -0.05901818f, -0.05825470f, 0.06571493f, 
    -0.13126376f, -0.03674155f, -0.07522625f, 0.08523799f, 0.04647257f, 0.05709537f, -0.08052091f, 0.01364564f, 
    0.08162937f, 0.01551027f, -0.04904769f, 0.20760387f, 0.23367897f, 0.04965553f, 0.12604813f, 0.03637296f, 
    -0.05793038f, 0.07554247f, 0.06895915f, 0.01496530f, -0.06067373f, -0.01508385f, 0.07147567f, -0.19424197f, 
    -0.01973310f, -0.06986977f, 0.09046948f, 0.06520747f, -0.05814951f, -0.01864891f, 0.33981082f, 0.07282123f, 
    -0.08349048f, 0.05055129f, -0.01007949f, -0.00754044f, 0.12474670f, -0.07111605f, 0.10109567f, 0.00037450f, 
    -0.02391641f, 0.01859085f, 0.09447471f, 0.06200883f, 0.00477978f, 0.05396581f, -0.05881876f, 0.18568088f, 
    -0.04174843f, -0.24274717f, -0.09804956f, 0.03734975f, 0.02709621f, 0.08392435f, 0.00160358f, -0.01198673f, 
    -0.13811545f, -0.00434770f, 0.11054204f, -0.04705608f, -0.02130014f, -0.22590156f, -0.05146749f, 0.16727261f, 
    0.17156300f, -0.13175550f, 0.01440085f, 0.12156958f, -0.08687218f, 0.14629288f, 0.00903766f, 0.09602097f, 
    -0.06711572f, 0.09774819f, -0.13459030f, -0.10742443f, -0.25387841f, -0.10565341f, 0.02384709f, 0.05548613f, 
    0.01748973f, 0.00680866f, 0.13457394f, -0.11788490f, -0.08495292f, -0.11825129f, -0.07464087f, 0.09638522f, 
    -0.04844616f, -0.00796016f, -0.08656660f, 0.12110913f, 0.00274950f, -0.07094351f, -0.21505658f, -0.31759208f, 
    0.16142230f, -0.02137493f, 0.10774817f, -0.04412358f, -0.01748916f, -0.03149313f, 0.00524363f, -0.03210343f, 
    0.21663429f, 0.05142362f, 0.05730313f, -0.04440310f, -0.03171202f, -0.02314021f, 0.15617083f, -0.10157494f, 
    0.05558828f, -0.03679990f, -0.10844917f, -0.03460122f, -0.01467002f, -0.03633206f, -0.08052587f, 0.14870647f, 
    0.23859024f, 0.09734127f, 0.06239769f, 0.00822971f, -0.05619091f, -0.05742225f, 0.07976231f, 0.04657221f, 
    0.10863498f, -0.03559747f, -0.18772317f, -0.05957428f, -0.08280551f, 0.03095296f, 0.06250213f, 0.18310206f, 
    -0.05134777f, 0.01538591f, -0.12591745f, 0.02544961f, 0.05405677f, 0.22468166f, 0.10910766f, -0.02930826f, 
    0.19995522f, -0.09242466f, 0.07505007f, -0.24859583f, -0.18232867f, -0.21271947f, 0.10386799f, 0.07897777f, 
    -0.02553637f, 0.08385859f, -0.10790135f, -0.11173346f, -0.03890523f, -0.05888300f, -0.02867941f, 0.04474198f, 
    0.05577636f, 0.07353939f, 0.04001594f, 0.02619598f, 0.05788545f, -0.10709608f, -0.04887701f, -0.09289781f, 
    0.12830630f, 0.00551130f, 0.01999868f, -0.00211295f, -0.17143326f, 0.11363737f, 0.20473891f, 0.18174924f, 
    -0.10620348f, -0.08053675f, -0.13650662f, -0.07002537f, -0.13474010f, 0.04453494f, -0.07123390f, -0.00742037f, 
    0.26449528f, -0.06617823f, 0.03528508f, 0.01153534f, -0.04724154f, -0.06844975f, -0.14923580f, 0.05001780f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07500395f, 0.02506801f, 0.10020904f, 0.03423967f, -0.09428678f, 0.08696556f, -0.04923577f, -0.05300963f, 
    0.18737072f, 0.04132166f, -0.00605086f, -0.04718072f, 0.08922531f, -0.01998418f, -0.04648648f, -0.02452785f, 
    0.02727489f, 0.01598939f, 0.03185648f, 0.02738758f, -0.05581524f, 0.18024182f, -0.03109287f, -0.01813488f, 
    0.05476823f, 0.10837971f, -0.01710371f, 0.11511677f, 0.00765449f, -0.04745433f, -0.06114121f, 0.01669125f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17708163f, -0.41600513f, -0.18263489f, 0.41656500f, -0.15152274f, -0.02390262f, -0.11798558f, 0.15144971f, 
    0.06597255f, -0.00169455f, -0.22912073f, 0.12205628f, 0.13166034f, 0.10175835f, 0.09851870f, 0.03316312f, 
    0.25026876f, -0.09564786f, -0.23047397f, -0.06524353f, 0.09344885f, 0.16609092f, 0.00181822f, 0.01566812f, 
    -0.13562742f, 0.05972393f, 0.64011544f, -0.03943237f, -0.57096499f, 0.14772555f, -0.06285484f, 0.30556753f, 
    0.16365533f, -0.11134163f, -0.28925556f, 0.32215220f, -0.06789068f, 0.20393345f, -0.14588416f, -0.08206936f, 
    -0.11152338f, -0.05627013f, -0.43122816f, -0.06648232f, -0.04690306f, -0.02069227f, 0.16345289f, 0.12727587f, 
    -0.17374425f, 0.37255099f, 0.06571793f, -0.05272195f, 0.00837808f, 0.24831393f, 0.12406765f, -0.16431269f, 
    0.30159190f, 0.21037588f, 0.06119264f, -0.25903958f, 0.19469833f, 0.13711557f, -0.17077851f, 0.12124833f, 
    0.05607469f, -0.43751296f, 0.17420213f, 0.12590790f, -0.27404618f, 0.25382575f, -0.00680702f, -0.14050430f, 
    0.38134336f, 0.13804735f, 0.12485048f, 0.05353834f, -0.31334743f, 0.02707036f, -0.03341991f, 0.15008017f, 
    -0.32693329f, -0.27788010f, 0.02271399f, 0.08242575f, -0.06550627f, 0.00068551f, 0.07607377f, -0.08054075f, 
    0.07618471f, 0.21699603f, 0.01990133f, -0.04023557f, -0.57721198f, 0.13787608f, -0.10668629f, 0.45888782f, 
    0.09573682f, 0.29222396f, -0.40057206f, 0.34713364f, -0.08433802f, 0.20586860f, -0.09516123f, -0.13993236f, 
    0.12849067f, 0.09412640f, -0.13895918f, -0.15512262f, 0.23750040f, 0.08107381f, -0.16112049f, 0.02050064f, 
    -0.13461506f, -0.13227968f, -0.05307268f, 0.01390785f, -0.16161959f, 0.32722998f, -0.06462763f, 0.07748142f, 
    0.19205287f, 0.08787081f, 0.25322866f, -0.26146063f, 0.23142856f, 0.09800515f, 0.17062134f, 0.38453987f, 
    0.31239733f, -0.19453847f, 0.32533383f, -0.55322641f, 0.12845188f, 0.20217681f, 0.13111153f, -0.01566916f, 
    0.12328770f, -0.08271699f, 0.33636120f, -0.06465881f, -0.25652310f, 0.01347903f, 0.11368798f, -0.13802537f, 
    0.06862593f, 0.13078751f, 0.22033297f, -0.12632234f, 0.02272703f, 0.08981475f, -0.16538575f, 0.12645596f, 
    -0.10007416f, 0.25787237f, -0.41486284f, 0.53380734f, -0.36453736f, 0.02654525f, 0.16316818f, -0.27378884f, 
    0.15652679f, 0.05058244f, -0.14453420f, -0.28920841f, -0.14788736f, 0.42158505f, -0.16835155f, -0.12538126f, 
    0.25019836f, -0.03755240f, -0.25765389f, -0.03593652f, -0.28455743f, -0.04597171f, -0.04028891f, -0.18061437f, 
    -0.37251803f, 0.42030165f, 0.28049597f, -0.08027902f, -0.03713855f, 0.20764576f, 0.10920400f, 0.04482378f, 
    0.07813522f, 0.02081998f, -0.59349322f, -0.11480463f, 0.05227168f, -0.09907661f, -0.16986440f, -0.27992243f, 
    -0.16933766f, 0.10773859f, 0.15550913f, 0.20385973f, 0.42680728f, 0.02300563f, 0.09344313f, -0.14035784f, 
    0.08217352f, 0.08934858f, 0.19654693f, 0.00044399f, 0.23252204f, 0.07346797f, -0.04234300f, -0.10540745f, 
    0.26475352f, -0.42971471f, -0.21828362f, -0.15077145f, 0.16158386f, 0.24225013f, 0.05690848f, 0.04348538f, 
    0.17566913f, -0.09699897f, 0.03226885f, 0.12936604f, 0.13224223f, 0.08977596f, 0.00185308f, 0.36977682f, 
    -0.16657397f, -0.01371132f, 0.02906527f, -0.17655142f, 0.03561453f, 0.10377812f, 0.01448229f, 0.13492513f, 
    -0.00772344f, -0.02577364f, -0.07667217f, -0.07764731f, 0.00858540f, -0.13046075f, -0.16771902f, -0.13575459f, 
    -0.07256615f, -0.19954330f, -0.03524007f, -0.12052056f, 0.14014800f, -0.17831087f, 0.08775570f, -0.10274011f, 
    -0.00023968f, 0.11928833f, 0.13284215f, -0.14035863f, -0.02510495f, 0.06249022f, -0.07037643f, -0.18739222f, 
    0.02489336f, -0.01377788f, 0.42042211f, -0.45102811f, -0.04366241f, -0.17381500f, 0.04960931f, 0.10959218f, 
    0.13979799f, -0.08388148f, -0.15389991f, -0.06151149f, -0.14036486f, 0.06675718f, -0.11557441f, 0.17618196f, 
    0.36383086f, 0.16010772f, 0.37171564f, 0.08556060f, 0.02641143f, -0.01196785f, -0.10110513f, 0.03155560f, 
    -0.32257360f, 0.35826671f, -0.18134834f, 0.47199151f, 0.04352795f, -0.00533668f, 0.05313290f, -0.15865682f, 
    -0.07912914f, 0.03218668f, -0.03242663f, 0.04602132f, 0.03009678f, -0.11776882f, 0.15390463f, 0.10487263f, 
    0.08820439f, 0.01490990f, 0.00977332f, -0.04757258f, 0.11879835f, 0.13516127f, 0.09483399f, -0.07271382f, 
    -0.12859346f, -0.14567953f, 0.09272819f, 0.00192737f, 0.10207146f, -0.06746300f, -0.08518171f, -0.07262421f, 
    -0.04119761f, -0.00116492f, -0.04164657f, -0.15037267f, -0.10765505f, -0.08847150f, 0.04854008f, -0.13671847f, 
    -0.06807306f, 0.46962458f, 0.06935322f, 0.20399398f, 0.76161909f, -0.22370298f, -0.04627931f, -0.16025886f, 
    0.11708495f, 0.05466154f, 0.05778740f, 0.10946272f, -0.19864579f, 0.11128668f, 0.04599586f, -0.12640934f, 
    0.08506265f, -0.13798404f, 0.25287166f, 0.13846825f, -0.03233434f, 0.12202495f, -0.14619906f, -0.02805286f, 
    -0.28090537f, -0.12947018f, -0.10861919f, -0.22998749f, 0.66352499f, -0.02475507f, -0.13059622f, -0.05533604f, 
    0.16137810f, -0.12098195f, 0.12634096f, 0.64380181f, -0.27798375f, 0.34655255f, 0.16283351f, 0.04481557f, 
    0.31005275f, -0.04997731f, 0.30376154f, 0.07988932f, 0.05042009f, -0.11213455f, 0.13056146f, 0.11400907f, 
    -0.08694841f, -0.05815778f, -0.30977577f, 0.13860402f, -0.04132852f, -0.07543144f, 0.11282977f, 0.11986564f, 
    -0.01754561f, -0.14953415f, 0.56420636f, -0.30781096f, 0.07641801f, 0.04960526f, 0.07380953f, 0.34173205f, 
    0.29476592f, 0.55878180f, -0.21769434f, 0.13884725f, 0.04347979f, -0.01914371f, -0.03514545f, 0.01210206f, 
    0.25734100f, -0.16334750f, -0.03747931f, -0.01586163f, -0.07862712f, -0.08097094f, -0.12194496f, -0.07792296f, 
    -0.44020188f, 0.00624512f, 0.25664198f, 0.04678655f, -0.14049789f, 0.16695641f, 0.09557351f, 0.10095434f, 
    -0.05189647f, 0.01655895f, -0.68178117f, -0.05898410f, 0.51670080f, -0.06949448f, -0.02324432f, 0.00879868f, 
    -0.05719253f, 0.48759177f, -0.05106922f, -0.35169661f, 0.23696631f, -0.35097522f, 0.02853016f, -0.16399127f, 
    -0.31706920f, 0.15027627f, 0.31967148f, 0.01862206f, 0.26744783f, -0.00761413f, -0.14567538f, -0.10588153f, 
    0.38115945f, -0.23337820f, -0.11474144f, -0.05155809f, 0.01709243f, 0.21789365f, -0.08343315f, -0.09732523f, 
    0.28644547f, 0.14429468f, -0.36304602f, 0.10462858f, -0.40532643f, -0.05255738f, 0.14760748f, 0.18326819f, 
    0.05250615f, 0.08381540f, -0.10794643f, 0.01384729f, 0.05231685f, 0.01672396f, 0.06394485f, 0.17455268f, 
    -0.04632656f, -0.15261807f, -0.02868852f, 0.04385496f, -0.07512663f, -0.05443680f, 0.13696444f, -0.13021439f, 
    -0.13595310f, -0.10278971f, -0.18584958f, 0.10570657f, 0.13461238f, -0.14324936f, 0.16933577f, 0.12260742f, 
    -0.11243349f, 0.10043496f, -0.05903977f, 0.07898734f, -0.04736057f, -0.03665400f, -0.05819756f, 0.02311736f, 
    -0.26102772f, -0.31036383f, 0.21142639f, 0.10205112f, -0.62860560f, 0.19265272f, 0.16397721f, 0.12523602f, 
    0.20326442f, 0.12002725f, -0.38966665f, 0.10334132f, -0.09081133f, 0.16490392f, 0.14547741f, 0.02173069f, 
    0.09762178f, -0.31436726f, 0.00081651f, -0.14142583f, -0.12812559f, 0.24951605f, 0.10890375f, -0.07919555f, 
    0.09178066f, 0.17240430f, 0.25298345f, 0.09071180f, -0.28313544f, -0.09593650f, -0.02515776f, 0.32311758f, 
    0.13407782f, -0.28109780f, -0.33511543f, 0.18602234f, -0.51991326f, 0.17177925f, -0.01099834f, -0.05031402f, 
    0.27722424f, -0.09078967f, 0.33070570f, 0.17199273f, 0.54093468f, 0.03849804f, -0.02224390f, -0.01693182f, 
    -0.08236738f, -0.14769536f, 0.13825065f, -0.11456968f, -0.04619008f, 0.15970939f, -0.09612937f, -0.09458568f, 
    0.17149331f, 0.06797443f, 0.22728564f, 0.10197423f, -0.16621569f, -0.10302391f, 0.05879595f, 0.01069195f, 
    -0.18002896f, 0.32788196f, 0.38716677f, 0.41491950f, -0.58885580f, 0.10758250f, -0.14544386f, 0.13975658f, 
    -0.02556831f, 0.00229771f, 0.06890982f, 0.07490197f, 0.36559615f, -0.06451241f, -0.07273445f, -0.02813398f, 
    0.00399060f, 0.27205563f, -0.25985956f, -0.08380825f, -0.16996226f, -0.07704651f, -0.12112232f, 0.11454823f, 
    -0.18477781f, 0.08303063f, 0.45262966f, 0.06903403f, 0.53781563f, -0.02409923f, -0.16689764f, -0.00231928f, 
    -0.16308716f, 0.12333218f, 0.00764219f, 0.14517401f, 0.05731236f, -0.16231009f, 0.08385029f, 0.01719877f, 
    0.15083061f, 0.04758460f, -0.07484242f, 0.08851207f, -0.14970790f, 0.04044770f, 0.06833047f, 0.16931036f, 
    -0.01537372f, 0.13954857f, -0.14779164f, 0.09665364f, 0.01280932f, -0.11536317f, -0.07509270f, -0.15120283f, 
    -0.17657366f, -0.01907936f, -0.05294126f, -0.06057732f, -0.18156368f, 0.03587207f, -0.17543402f, -0.17334789f, 
    -0.06122728f, -0.00418632f, -0.19458452f, -0.04473877f, -0.04830318f, 0.00693989f, 0.00479835f, -0.03185888f, 
    0.08263881f, 0.09090338f, -0.13465939f, 0.06136167f, -0.13065296f, -0.00988677f, -0.15867402f, -0.12002496f, 
    -0.02424443f, -0.10268831f, -0.19321033f, 0.14483956f, 0.16447976f, 0.08614264f, -0.05413379f, 0.12293734f, 
    -0.09917007f, 0.03392627f, 0.03089455f, -0.18881832f, 0.10921825f, 0.06199488f, -0.16988386f, -0.15247564f, 
    -0.06742396f, -0.34832355f, 0.27423266f, -0.02545481f, -0.07581982f, 0.39330369f, 0.02348927f, -0.12041643f, 
    0.28313720f, -0.06207588f, -0.43273288f, 0.14859217f, -0.16873716f, -0.09826498f, 0.04638836f, -0.04053724f, 
    -0.38985261f, 0.05857939f, 0.21591292f, 0.01929312f, 0.08182587f, 0.09317331f, -0.09612271f, 0.00241912f, 
    -0.11848991f, 0.34805450f, 0.03056453f, -0.13348399f, -0.18475948f, 0.04810420f, 0.06297553f, 0.25558037f, 
    0.06695008f, 0.15973009f, -0.05560007f, -0.01906790f, -0.05804212f, -0.12092066f, -0.07071612f, -0.08612534f, 
    -0.12466430f, -0.05149982f, -0.07291349f, 0.05396222f, 0.05933766f, 0.04045976f, -0.06607154f, -0.10944395f, 
    0.07621747f, -0.04864565f, 0.04009768f, 0.09962899f, 0.07740715f, -0.14748642f, 0.02552368f, -0.04297695f, 
    -0.16896880f, -0.10453493f, -0.08474228f, 0.03192578f, -0.11190461f, 0.10350626f, 0.08181129f, 0.15331711f, 
    -0.01239684f, 0.19420148f, -0.01630989f, 0.15739207f, 0.26476073f, -0.40396023f, -0.11200519f, 0.03415508f, 
    -0.28534335f, -0.07218625f, -0.00225964f, -0.04458440f, 0.45087546f, -0.10645410f, 0.03537681f, -0.10837970f, 
    -0.08688776f, 0.13124225f, 0.09162545f, -0.00257533f, 0.07432482f, 0.32606003f, 0.08336630f, -0.16551320f, 
    -0.02459897f, 0.03020656f, 0.41460583f, -0.15095311f, 0.69209260f, 0.01174233f, -0.13679010f, -0.13323312f, 
    0.05589924f, 0.14003371f, -0.27868998f, 0.32249346f, 0.41349524f, -0.23326148f, 0.16193846f, -0.01607245f, 
    -0.27812329f, -0.11073806f, -0.13568087f, -0.08926083f, 0.33382878f, -0.09409762f, -0.12409434f, -0.08437175f, 
    0.19340821f, 0.16908816f, -0.19443749f, -0.01289186f, 0.14192770f, 0.17140923f, -0.07040564f, -0.03696207f, 
    0.09300736f, 0.08701721f, 0.26327679f, -0.24506085f, 0.36720899f, -0.01358284f, 0.02354689f, 0.18801019f, 
    -0.16381672f, 0.03706311f, -0.16208220f, -0.06619050f, -0.11046353f, -0.06945436f, 0.04903475f, 0.12402119f, 
    0.12306757f, 0.09197495f, -0.03962995f, 0.16021332f, -0.13964947f, 0.14104116f, 0.05851930f, -0.13130835f, 
    0.07196427f, -0.10902843f, -0.10126480f, 0.12382454f, -0.13476764f, -0.07314616f, -0.09823937f, -0.08375887f, 
    -0.05319097f, -0.04325338f, 0.04999975f, 0.10890959f, -0.08909285f, 0.02248417f, -0.01184760f, -0.07318149f, 
    0.39634597f, -0.52493888f, -0.18159024f, -0.18938808f, -0.26333070f, 0.20464484f, -0.14837720f, 0.17004979f, 
    -0.14610706f, 0.07116657f, 0.54199952f, -0.11188624f, 0.32092446f, -0.07350996f, -0.05785787f, -0.17616461f, 
    0.08993126f, 0.12447742f, -0.12381593f, 0.09294521f, -0.03211145f, 0.04658010f, -0.07438173f, -0.05138696f, 
    0.14864096f, 0.07920979f, -0.07021237f, -0.00450082f, -0.54893166f, 0.16517520f, 0.03754340f, -0.15831055f, 
    0.27404588f, -0.22583283f, -0.29323259f, 0.34056857f, -0.34268638f, 0.33749121f, -0.04292642f, 0.07711672f, 
    0.26571700f, -0.12669872f, 0.48283693f, 0.16599762f, 0.40129074f, -0.06089995f, 0.16435808f, 0.03505168f, 
    -0.28630745f, -0.10983654f, 0.05097152f, -0.09035334f, 0.14377776f, 0.33023849f, 0.07365931f, -0.03375053f, 
    0.42163143f, -0.13551600f, -0.17047580f, -0.06080598f, 0.17306216f, -0.01736671f, 0.03753735f, 0.07431981f, 
    -0.10626190f, -0.02149742f, 0.22364403f, 0.34398854f, 0.21669592f, 0.09001073f, 0.15825416f, 0.11881342f, 
    0.25492042f, -0.13643175f, -0.03499394f, -0.09694804f, 0.11456588f, 0.06336315f, -0.14288178f, -0.16687004f, 
    0.17853847f, -0.34861404f, 0.19267419f, -0.03069659f, 0.07922962f, -0.19307788f, -0.12715435f, 0.06857587f, 
    -0.57818526f, 0.26415789f, 0.33244330f, 0.37125573f, -0.07458156f, 0.01710588f, 0.02697299f, -0.05608174f, 
    -0.00618174f, 0.13664596f, 0.07985009f, -0.01855322f, 0.60065949f, 0.08658939f, -0.11649691f, 0.10761505f, 
    -0.21872142f, 0.00140347f, -0.06475998f, -0.01879986f, -0.34065157f, 0.08622891f, 0.00155149f, 0.09719997f, 
    0.17159656f, -0.37682992f, 0.06925925f, 0.05749158f, 0.12261951f, -0.06602808f, -0.07122816f, -0.18158445f, 
    0.06999811f, 0.01429399f, -0.14517140f, -0.05012713f, -0.35486493f, -0.02357956f, 0.03997105f, -0.09570997f, 
    0.02901239f, 0.33738738f, 0.11425558f, -0.28634524f, 0.32726851f, -0.36636651f, -0.02282273f, 0.04754823f, 
    0.08483136f, 0.09722476f, 0.04508319f, -0.01651519f, 0.09988482f, -0.14603432f, 0.11072561f, -0.16597450f, 
    -0.14159143f, -0.23932852f, 0.00261129f, -0.13772444f, 0.05729093f, -0.04077953f, 0.05148427f, 0.00395038f, 
    -0.64267391f, 0.28409594f, 0.24865671f, 0.40669078f, 0.12342317f, -0.06867307f, -0.11110706f, 0.39430439f, 
    -0.03169436f, 0.37346947f, 0.09009578f, 0.44378927f, -0.25698406f, 0.20591113f, -0.05460638f, 0.12415981f, 
    -0.09790253f, 0.08566193f, -0.35971615f, -0.00562747f, 0.25208741f, 0.01358667f, 0.07352968f, -0.13003571f, 
    0.43163982f, 0.08254645f, -0.21463281f, -0.06146066f, -0.04539146f, 0.20130685f, -0.09632277f, -0.13888976f, 
    0.48489735f, -0.18631832f, -0.08783343f, -0.10067615f, 0.07002622f, 0.10002543f, 0.00273057f, 0.20425692f, 
    -0.07646012f, -0.12445893f, 0.13398199f, -0.19806223f, 0.02883653f, 0.05656131f, -0.06346072f, 0.08627032f, 
    -0.12467086f, -0.10334657f, -0.20716630f, 0.02743948f, -0.13857926f, 0.05318246f, 0.05442686f, 0.00939678f, 
    0.04438126f, -0.15322460f, -0.21161404f, -0.06598545f, -0.00423321f, -0.07916153f, -0.07278026f, -0.01234377f, 
    0.13208394f, -0.11579925f, -0.01553072f, -0.00310143f, -0.18531877f, 0.16131692f, -0.16379514f, -0.05671153f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06340167f, 0.09924649f, 0.00161297f, -0.07077535f, 0.06657790f, 0.25469041f, -0.01918530f, -0.00567047f, 
    0.24012679f, 0.11216985f, -0.06259093f, 0.16145270f, -0.00754629f, 0.23566321f, 0.02556983f, 0.26371688f, 
    0.02190732f, -0.00743072f, -0.05693674f, 0.02488047f, -0.09589703f, 0.09470643f, -0.07720547f, 0.08342804f, 
    -0.05394228f, 0.32423010f, 0.19317891f, 0.11366699f, 0.00715029f, 0.03575575f, -0.12506010f, 0.13210344f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.18199150f, -0.12678848f, 0.66732806f, 0.31459579f, 0.01015682f, -0.18196835f, 0.38034675f, 0.00335571f, 
    -0.36806646f, 0.10069120f, -0.48909852f, 0.56052732f, 0.10726546f, 0.35144717f, -0.04420970f, 0.46265513f, 
    0.37363333f, -0.59076446f, -0.02784058f, -0.04599182f, 0.05007594f, -0.06669727f, -0.48167998f, -0.18598168f, 
    -0.12942782f, 0.43111473f, 0.38150147f, 0.03433023f, -0.14670181f, 0.06984928f, -0.08983347f, 0.02582153f, 
    0.14423749f, -0.41385704f, -0.02321845f, 0.06428327f, 0.17123051f, -0.40527236f, 0.18705183f, -0.05695518f, 
    0.15748322f, 0.01789507f, -0.35576785f, 0.11716972f, -0.21747710f, 0.17352760f, -0.05530404f, -0.10370570f, 
    0.30229878f, 0.21838172f, 0.02274145f, 0.13033235f, -0.41466719f, 0.08479654f, -0.20778279f, -0.21054116f, 
    -0.11206326f, 0.33860913f, 0.17530598f, 0.44977668f, 0.22119118f, 0.20776637f, -0.16421419f, 0.12862426f, 
    0.11487226f, 0.19846618f, 0.28359276f, 0.23684250f, -0.20677339f, 0.12033976f, 0.17101297f, -0.05364736f, 
    0.20787486f, -0.16345799f, 0.18629137f, 0.16353953f, 0.02631622f, -0.28974694f, -0.15067977f, 0.96176034f, 
    -0.01644370f, 0.43713790f, 0.08393448f, -0.08376831f, 0.78073853f, 0.05304840f, 0.07141349f, -0.09114000f, 
    -0.07045441f, -0.18770376f, -0.11748556f, 0.53810054f, -0.57220805f, 0.17857108f, 0.32510048f, 0.08844364f, 
    -0.08583978f, -0.11010577f, -0.14315942f, 0.12465697f, -0.02986593f, -0.30929112f, 0.16646279f, -0.10269856f, 
    0.31514665f, -0.10188466f, 0.51371783f, -0.20551743f, 0.08679264f, 0.02361894f, -0.07806507f, 0.22651759f, 
    -0.04557067f, 0.17634538f, -0.02253569f, 0.11398365f, 0.26142442f, 0.08942749f, 0.48975730f, 0.33194149f, 
    -0.04177096f, -0.15684490f, -0.13629222f, 0.36145562f, -0.07866823f, 0.78635341f, -0.37216961f, 0.09452660f, 
    -0.42831010f, -0.02639397f, 0.20229045f, -0.16511378f, 0.34158736f, 0.36585075f, -0.19545130f, -0.08087687f, 
    0.32269084f, -0.08141249f, -0.12384492f, -0.13365415f, 0.12908643f, -0.13083367f, 0.07370784f, -0.24645360f, 
    0.27217430f, -0.13219212f, -0.12333090f, 0.04887983f, 0.03089477f, -0.09644920f, -0.24868801f, -0.47151941f, 
    -0.06520232f, 0.50064242f, 0.34216812f, -0.00049959f, -0.26328447f, -0.29476759f, -0.20412724f, -0.19373596f, 
    0.52135330f, 0.18968730f, -0.15452813f, 0.22496073f, -0.06370169f, -0.02102445f, -0.00990963f, -0.16404088f, 
    -0.02000164f, -0.07566649f, -0.26944944f, 0.59217680f, -0.34992924f, 0.20133850f, 0.16451356f, 0.19140725f, 
    0.34544873f, 0.52753073f, 0.15456083f, 0.13589887f, -0.10292004f, 0.12122416f, -0.10505527f, 0.22212042f, 
    0.00212020f, 0.49299666f, 0.06608080f, -0.21652503f, 0.22041133f, -0.16594769f, 0.42795128f, 0.12284616f, 
    -0.01015328f, -0.09569000f, -0.38127968f, 0.22081380f, -0.03160909f, -0.13741046f, 0.23050453f, -0.01670174f, 
    -0.06187963f, -0.14240381f, -0.03987850f, 0.35070476f, 0.16773088f, 0.25300404f, 0.10565192f, 0.50909185f, 
    0.32035750f, 0.43212092f, -0.08884821f, 0.05146679f, -0.64828527f, -0.14436319f, -0.01373366f, -0.10692363f, 
    -0.04425221f, 0.12079739f, 0.35410497f, -0.20934188f, -0.43780142f, 0.01339361f, 0.33324316f, -0.08496371f, 
    0.27267286f, 0.15950105f, -0.26529914f, 0.23294680f, -0.19472609f, 0.06122116f, 0.43428242f, 0.00365632f, 
    -0.15096511f, -0.11884178f, 0.37185779f, 0.22287849f, 0.10758777f, 0.10523898f, -0.16227348f, -0.00305649f, 
    0.25990915f, -0.15549164f, 0.21540578f, 0.15081067f, -0.37660012f, 0.07565311f, 0.37032342f, 0.49844179f, 
    -0.18118525f, 0.09633185f, 0.38232499f, -0.16096982f, 0.19133092f, -0.23152408f, 0.47516701f, -0.00946548f, 
    0.27584118f, 0.74532431f, 0.16525233f, 0.61951166f, -0.07976255f, 0.92943227f, -0.14582649f, 0.10133453f, 
    -0.11416163f, 0.01203438f, 0.12812269f, -0.02238951f, 0.59397042f, -0.11326899f, -0.04294014f, -0.00727599f, 
    -0.05269527f, -0.34239033f, 0.10758816f, 0.06559255f, 0.64877439f, -0.03635564f, 0.02982888f, 0.37644055f, 
    -0.13888167f, -0.03305237f, 0.23734882f, -0.23245701f, -0.20691943f, -0.02535100f, 0.06138550f, -0.01503048f, 
    0.13127835f, -0.13029341f, 0.19149625f, -0.04940761f, -0.10505430f, -0.41029045f, 0.32242930f, 0.13983625f, 
    0.24802952f, -0.09563767f, -0.26184624f, -0.61988628f, -0.16784975f, 0.60880065f, 0.09095401f, 0.39974803f, 
    -0.04264171f, -0.30806747f, 0.12612954f, -0.04783589f, -0.07407966f, 0.05845832f, 0.17687671f, 0.27879837f, 
    -0.12040646f, 0.09701809f, 0.02467771f, -0.00280138f, -0.04282444f, 0.51456422f, 0.03405931f, 0.10264499f, 
    0.27048713f, 0.31366950f, -0.43804869f, 0.25592393f, -0.30872926f, -0.27396050f, -0.05639964f, -0.09022605f, 
    -0.08688303f, -0.06241992f, 0.38522732f, 0.24811432f, -0.02977695f, -0.16378386f, -0.10228576f, -0.09350816f, 
    0.07982710f, 0.42437080f, -0.18112735f, 0.08450632f, -0.41174778f, -0.01050232f, 0.39485452f, 0.58675528f, 
    0.13027725f, -0.12988821f, 0.25324455f, -0.00550960f, -0.71323866f, -0.36328205f, 0.57325250f, -0.00277287f, 
    -0.11738563f, 0.11348925f, -0.07204553f, -0.11023384f, -0.13971449f, 0.06755173f, 0.01631676f, -0.10527846f, 
    -0.07206816f, -0.05110832f, 0.07587284f, -0.09379788f, 0.05869051f, -0.12229005f, 0.03697307f, -0.17007998f, 
    0.09204967f, 0.11962121f, -0.05744261f, 0.12964040f, -0.01493175f, -0.14336146f, 0.14030635f, 0.06231884f, 
    -0.02032422f, 0.05066099f, -0.19780101f, -0.14711499f, -0.07637268f, -0.31250647f, -0.08098056f, 0.03999468f, 
    0.03552336f, -0.01866194f, 0.74396282f, -0.03802896f, 0.20914407f, -0.00946764f, 0.16118522f, -0.04181953f, 
    0.02182989f, -0.07604697f, -0.20535789f, 0.40652448f, -0.10985225f, -0.09565625f, 0.08296623f, 0.10419580f, 
    0.10917594f, -0.43892962f, 0.07165881f, 0.12991053f, 0.21930803f, 0.14946581f, -0.35893181f, -0.29626366f, 
    0.16622189f, 0.41018268f, 0.24236326f, 0.06213374f, -0.18857947f, -0.15854403f, -0.28198367f, -0.04433712f, 
    -0.16543218f, -0.22338292f, -0.06394853f, 0.25864574f, -0.06654275f, -0.23407552f, 0.36324349f, -0.14137891f, 
    -0.15779844f, -0.14963230f, 0.39721927f, 0.25750664f, 0.29617092f, 0.18060216f, 0.11316402f, -0.80239862f, 
    0.24863337f, -0.08297972f, 0.11038075f, -0.15535721f, -0.67052519f, 0.13754050f, 0.59925550f, 0.00472308f, 
    -0.06446329f, 0.31319773f, 0.19665906f, 0.14412507f, 0.17961349f, 0.30713114f, -0.50283450f, 0.02024742f, 
    0.22742936f, -0.36088857f, -0.33988053f, -0.21699029f, 0.36326748f, -0.05547239f, 0.06680492f, 0.01071011f, 
    0.50283116f, 0.15468450f, 0.43004358f, -0.32319513f, 0.26686999f, 0.08246904f, -0.13863313f, 0.02269715f, 
    -0.17105959f, -0.10438387f, 0.06523556f, 0.11188082f, -0.04897031f, -0.03506286f, -0.32661000f, -0.08645117f, 
    -0.04885667f, -0.31669125f, -0.36506206f, 0.48711032f, 0.49045235f, 0.52919424f, -0.23151599f, -0.09418666f, 
    0.10134479f, 0.10846855f, 0.09070520f, -0.13309960f, 0.03801230f, -0.16254501f, 0.00251518f, -0.04997621f, 
    -0.06738290f, 0.06654400f, -0.13838838f, -0.01532805f, -0.07999603f, -0.03185494f, -0.15079716f, -0.11634126f, 
    -0.05291652f, -0.16715263f, -0.10489661f, 0.04131864f, -0.03473118f, -0.02432505f, 0.02102323f, -0.17541428f, 
    -0.04569353f, -0.17744344f, -0.13351163f, 0.13134058f, 0.00871679f, -0.00281813f, -0.12608957f, -0.17166939f, 
    -0.10344592f, 0.04078339f, -0.15633370f, -0.15507182f, -0.15904914f, -0.05362016f, -0.16502690f, -0.03898147f, 
    0.09167843f, 0.17227755f, -0.04119888f, -0.01740627f, 0.01265785f, -0.08394583f, -0.07582970f, 0.01892704f, 
    -0.10639710f, -0.13996075f, -0.13750264f, -0.16304024f, -0.14024301f, -0.03874857f, 0.07688714f, 0.10268932f, 
    -0.01406537f, 0.03712525f, -0.14218804f, -0.02220124f, 0.08196173f, -0.08957744f, -0.00178888f, 0.17415161f, 
    0.05492823f, 0.27899781f, 0.75585604f, 0.10098132f, 0.26493347f, 0.33223385f, -0.31132090f, 0.06779592f, 
    0.41492179f, -0.02170026f, -0.63037515f, -0.14333150f, 0.02907280f, -0.04298318f, 0.17452206f, 0.68373483f, 
    0.16210583f, 0.17727022f, -0.08314510f, -0.07425267f, 0.82613057f, -0.05898973f, -0.41892073f, -0.47852618f, 
    0.06200840f, -0.14143167f, 0.08097253f, 0.12436856f, -0.75839376f, 0.24291335f, -0.18337987f, -0.20201284f, 
    0.04748865f, 0.15692626f, -0.61980844f, -0.11829402f, 0.28252801f, 0.33499762f, -0.41232914f, -0.06419313f, 
    0.34769765f, -0.02760662f, -0.06020907f, -0.55643249f, 0.05197988f, -0.09581076f, -0.00019558f, -0.34345424f, 
    -0.06301074f, 0.38529128f, 0.09304538f, -0.00472144f, -0.14900501f, 0.10471549f, 0.30204266f, 0.19301198f, 
    0.04180133f, 0.18980989f, -0.05324930f, 0.12941970f, 0.54507291f, 0.32849410f, -0.33115461f, 0.07156216f, 
    -0.53626841f, 0.12178566f, -0.29895607f, 0.11906255f, 0.20326155f, 0.38055995f, 0.26758885f, -0.12924203f, 
    -0.04844832f, -0.07377935f, 0.51607466f, -0.30019000f, 0.57449305f, 0.41459924f, -0.11282491f, -0.38627213f, 
    0.02374199f, -0.05812397f, -0.07452266f, 0.02698964f, -0.29913494f, -0.05184767f, 0.31852281f, 0.27028084f, 
    0.16443926f, -0.24532753f, 0.14092828f, -0.36923048f, 0.08186412f, 0.29285404f, 0.36632612f, -0.13900451f, 
    0.09322532f, 0.15230145f, 0.38358393f, 0.40125039f, -0.03039698f, 0.38815936f, 0.06842396f, 0.02249253f, 
    -0.06812124f, -0.12428809f, -0.18535018f, 0.49371362f, 0.25358012f, -0.08030451f, -0.05507171f, 0.35879722f, 
    0.10239185f, 0.00888976f, -0.12279195f, -0.06373523f, 0.00414362f, 0.03565370f, -0.31844667f, -0.05025559f, 
    -0.06289810f, -0.04852985f, 0.27153513f, -0.08375441f, -0.15408255f, -0.14571276f, 0.46264520f, -0.13218823f, 
    -0.37263009f, -0.40327224f, 0.20064215f, -0.29950529f, 0.42290497f, -0.04028162f, 0.21251886f, 0.13559493f, 
    0.37481105f, -0.17031822f, -0.02701315f, -0.07020483f, 0.24436207f, 0.27900943f, 0.00187863f, 0.14168350f, 
    -0.15627752f, 0.00488570f, -0.05125265f, -0.15497601f, -0.02338989f, 0.08013598f, -0.18734001f, -0.31738937f, 
    -0.10042634f, 0.04163846f, 0.01372151f, 0.42084634f, -0.02749365f, 0.10419795f, 0.11308664f, -0.08915991f, 
    0.35341108f, -0.33356190f, 0.43900019f, -0.14228965f, 0.15539606f, -0.35563967f, -0.10830828f, -0.09260695f, 
    0.07604365f, -0.16165212f, -0.06186038f, 0.59660763f, -0.17581341f, -0.12269866f, -0.03782808f, -0.38799250f, 
    0.24443787f, 0.11483365f, 0.10939299f, 0.13610053f, -0.13535954f, 0.07016476f, -0.16317277f, 0.03380935f, 
    0.06339227f, 0.27506277f, 0.18245383f, 0.65680373f, 0.10461012f, 0.52735633f, -0.41464478f, -0.01015595f, 
    0.58757609f, 0.37944841f, 0.28248015f, 0.01570038f, 0.14800435f, 0.25725713f, -0.41175538f, -0.12316718f, 
    -0.14102519f, -0.02668803f, -0.63054442f, 0.19543244f, -0.03242358f, 0.09135817f, -0.17037486f, 0.06273358f, 
    0.08029532f, -0.28096735f, 0.16224985f, 0.12779848f, 0.31586009f, -0.13608028f, 0.09208200f, 0.02673179f, 
    -0.12138157f, 0.51950258f, -0.01277937f, -0.17893600f, -0.10897024f, -0.06251283f, -0.31424454f, 0.12752125f, 
    -0.07658611f, -0.02819024f, -0.09416529f, -0.03822764f, 0.02733368f, -0.08023833f, 0.03202987f, 0.03742914f, 
    0.04558784f, -0.08613987f, 0.00032526f, -0.12673005f, 0.12764753f, -0.00553442f, -0.15371299f, -0.01766838f, 
    -0.15501635f, -0.15926479f, -0.13988562f, -0.05964340f, -0.18044536f, -0.10296013f, -0.17117973f, -0.05879013f, 
    0.02622459f, -0.05564485f, -0.03512700f, -0.13753816f, 0.01926878f, -0.03691929f, 0.00142035f, 0.07759650f, 
    0.44479430f, 0.02130638f, 0.63713175f, 0.23979889f, -0.01716980f, -0.12468309f, 0.27369145f, -0.01576500f, 
    -0.23952331f, 0.11921149f, 0.03741227f, 0.23759839f, -0.12317792f, -0.36922231f, 0.00179501f, 0.86716461f, 
    0.36100009f, -0.04605093f, -0.03618632f, 0.15898341f, 0.54490334f, -0.17668752f, 0.12079085f, -0.12796721f, 
    -0.09118440f, -0.22972862f, 0.12481944f, 0.33481964f, -0.63760161f, 0.22360064f, -0.22149308f, -0.02255719f, 
    0.48208293f, -0.08135721f, -0.50545543f, 0.12839775f, 0.05990951f, -0.41770428f, 0.39662924f, 0.00670014f, 
    -0.04558930f, -0.01198679f, -0.06279329f, 0.01663462f, -0.46077934f, 0.38500005f, 0.10301400f, 0.13273223f, 
    -0.03407399f, -0.11437526f, 0.00151007f, -0.05888065f, -0.66113907f, -0.01732002f, 0.06844833f, 0.35144156f, 
    0.10635847f, 0.35815737f, -0.01753484f, -0.16649385f, 0.54537714f, -0.03865707f, 0.32979214f, 0.20630564f, 
    0.40131849f, -0.13917722f, -0.46913534f, -0.38882574f, 0.13570428f, -0.58355546f, 0.45120299f, -0.10089285f, 
    0.39252350f, -0.06678320f, 0.48977667f, -0.10282929f, -0.55620313f, 0.14900197f, 0.06770314f, 0.18830742f, 
    -0.32243967f, -0.02787778f, -0.06404467f, -0.14204608f, -0.06923046f, -0.17813997f, -0.18191358f, 0.02016446f, 
    0.13822727f, -0.03477916f, -0.46149540f, 0.43685132f, 0.44997483f, 0.13589479f, 0.47900563f, 0.06243978f, 
    -0.23281954f, 0.27470213f, -0.30463156f, 0.13310303f, 0.32400817f, 0.66698653f, -0.26433471f, -0.00428638f, 
    0.09347254f, 0.15061951f, 0.30347738f, -0.46862406f, 0.60247421f, 0.01159210f, -0.16654192f, -0.49422225f, 
    0.10791994f, -0.61121565f, -0.02776008f, -0.07477976f, 0.03725396f, -0.12286147f, -0.01350118f, 0.04421204f, 
    0.09321028f, 0.32033497f, 0.27947828f, -0.33311602f, -0.03971799f, -0.24881682f, -0.06752885f, -0.13215481f, 
    -0.22721078f, 0.23944807f, -0.32787418f, 0.23771653f, 0.03883152f, -0.30963975f, 0.44906580f, 0.20186853f, 
    0.00531015f, 0.16578493f, 0.39585304f, -0.58246517f, -0.23799989f, 0.43202826f, -0.13240314f, 0.51137084f, 
    -0.07519216f, -0.02255488f, 0.11739024f, 0.03007158f, -0.00159571f, 0.15064473f, 0.30172470f, 0.29857546f, 
    -0.09806868f, -0.19144836f, 0.00251200f, -0.08720367f, 0.29036179f, -0.12789214f, 0.42862159f, 0.12643477f, 
    0.04100430f, -0.04229931f, 0.11799339f, 0.12990822f, 0.06783215f, -0.18975790f, -0.03677144f, 0.02875002f, 
    -0.03848970f, 0.11285314f, 0.00493019f, 0.02532511f, -0.11537123f, -0.10842003f, 0.05441137f, 0.01760934f, 
    -0.01026921f, 0.14699882f, -0.18035810f, -0.00305315f, 0.04192197f, -0.14759018f, 0.02860807f, -0.16106322f, 
    0.11785893f, -0.12609267f, -0.15435512f, -0.09235604f, -0.06300685f, -0.16772753f, -0.15178013f, 0.13366641f, 
    -0.17651889f, 0.24499869f, -0.66871828f, -0.17206176f, 0.30066174f, 0.45633143f, -0.46175998f, 0.08123483f, 
    0.28110379f, 0.04872403f, -0.21244191f, -0.59199816f, 0.00671038f, 0.01686194f, 0.03072723f, -0.33081931f, 
    0.29235849f, -0.26425967f, -0.14200673f, 0.15424614f, -0.05815116f, -0.03312972f, 0.27646416f, 0.09036721f, 
    0.12207752f, 0.46279669f, 0.14625999f, -0.19582528f, -0.31161356f, -0.26676974f, 0.04816706f, -0.00118892f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.22071087f, 0.00586113f, 0.17656356f, 0.06569231f, 0.30787650f, -0.04757110f, 0.02669977f, 0.07205991f, 
    0.06821611f, 0.19652127f, 0.09370696f, -0.13517869f, 0.07966540f, -0.02351138f, 0.26913401f, -0.17281675f, 
    -0.14940958f, -0.01519159f, 0.04031201f, 0.21902592f, -0.08254311f, 0.20843796f, 0.15352063f, 0.11950918f, 
    -0.18423732f, 0.03922955f, -0.04194759f, 0.05806107f, -0.02339684f, 0.23120171f, 0.02727273f, 0.24113309f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.35764328f, 0.37792149f, -0.66569531f, -0.06598098f, 0.28457466f, 0.12553203f, 0.27557757f, 0.08690891f, 
    -0.58043349f, 0.11685146f, -0.59488267f, -0.00531529f, 0.24904859f, 0.58838665f, -0.19852255f, -0.08616064f, 
    -0.08433771f, -0.23138116f, -0.16714439f, -0.00555218f, -0.17776334f, 0.14809977f, 0.43816590f, -0.01133602f, 
    -0.16727252f, -0.14555545f, 0.08556601f, -0.55401272f, -0.13234580f, -0.32945099f, 0.14386499f, -0.09477456f, 
    0.09435952f, 0.13325706f, 0.15847901f, -0.26562566f, -0.39593041f, 0.28925779f, 0.19685648f, 0.28257135f, 
    -0.02766228f, -0.29305330f, 0.46076095f, 0.04643883f, -0.18598685f, 0.15411411f, -0.02007239f, -0.09922897f, 
    -0.10863994f, -0.35448602f, -0.19965349f, -0.26983917f, 0.15691526f, -0.43840644f, 0.16932119f, -0.06236145f, 
    0.03111074f, 0.26332605f, 0.32921740f, 0.14582182f, -0.22676910f, -0.16616961f, -0.04469887f, -0.12142944f, 
    0.14091514f, -0.23282415f, 0.42903984f, 0.26460621f, -0.31670940f, 0.08046087f, -0.36372262f, -0.08082274f, 
    0.31281489f, -0.00682784f, 0.03127524f, -0.18470867f, 0.24022898f, -0.29386368f, -0.62495428f, 0.09454089f, 
    0.00508297f, 0.35950547f, -0.19415265f, -0.51599252f, -0.03859095f, -0.64837426f, 0.30655801f, 0.42999938f, 
    -0.10926230f, 0.42668650f, -0.42200840f, -1.09754038f, -0.79581332f, -0.41315585f, 0.02554369f, -0.63644266f, 
    -0.39561978f, 0.21715759f, 0.36516106f, 0.17237727f, 0.29779911f, -0.51540941f, -0.27308863f, -0.47951728f, 
    -0.77949792f, 0.02233306f, 0.04719204f, -0.19065250f, 0.11524799f, -0.57847440f, 0.32738549f, 0.13259003f, 
    -0.17699236f, 0.19849654f, 0.08281710f, -0.19211626f, -0.47941536f, 0.40911052f, 0.13825643f, -0.34497574f, 
    -0.20495561f, -0.20978296f, -0.21790227f, 0.17238767f, -0.19282478f, -0.04203109f, -0.16290504f, 0.14044248f, 
    0.02973813f, 0.08405250f, 0.06724593f, -0.07212613f, 0.08424201f, -0.18545148f, -0.04488031f, -0.32746205f, 
    0.11184083f, -0.06803683f, -0.00766175f, -0.04246626f, -0.10438634f, -0.06222629f, 0.33816022f, -0.15087718f, 
    0.11437076f, 0.29686370f, 0.25554332f, -0.00367642f, 0.09175416f, 0.11614712f, 0.29618889f, 0.03065142f, 
    -0.18756874f, -0.01108589f, -0.58730799f, -0.52905709f, 0.13627388f, -0.74260801f, -0.14694613f, 0.06564219f, 
    0.14971124f, -0.04801039f, -0.58120447f, -0.39712453f, -0.04027543f, 0.11244547f, -0.01694234f, 0.19431080f, 
    0.15051430f, 0.18108319f, -0.00007467f, -0.03946601f, -0.06446093f, 0.01180284f, -0.31386781f, -0.04688404f, 
    -0.13125293f, -0.36271158f, 0.04353546f, 0.05948538f, -0.13963620f, -0.42690891f, -0.27432016f, 0.28087136f, 
    -0.06250679f, -0.50334162f, 0.47557956f, 0.16926557f, 0.46847054f, 0.14482324f, 0.06035261f, 0.41433188f, 
    -0.49897680f, -0.34919092f, -0.11691633f, -0.33327952f, 0.37133005f, 0.12011376f, -0.07233142f, -0.01627435f, 
    0.26208061f, -0.52219063f, -0.21695895f, 0.06829201f, -0.13636914f, -0.44868374f, -0.58665401f, 0.09563043f, 
    -0.09495074f, 0.25436932f, 0.45993152f, 0.11374540f, -0.01634784f, -0.17482191f, -0.35669267f, 0.19675747f, 
    -0.10631195f, -0.40250689f, -0.67598999f, -0.74940133f, 0.36005822f, -0.16587627f, 0.08882056f, 0.62215275f, 
    -0.58081889f, 0.11931755f, -0.29085556f, 0.20351994f, -0.55076504f, -0.10705347f, -0.51405483f, -0.10390946f, 
    -0.49890867f, 0.06975623f, -0.25840548f, -0.01240281f, -0.32116792f, -0.05235278f, 0.37436178f, -0.00609557f, 
    -0.09914368f, -0.39034149f, 0.10877320f, 0.09972188f, -0.50093573f, 0.27457815f, 0.15678133f, -0.47942749f, 
    -0.07201269f, -0.68726993f, 0.38250986f, 0.50761002f, -0.19658941f, 0.14910346f, 0.01166461f, -0.59105945f, 
    -0.04712474f, -0.76062083f, 0.33713779f, 0.10862152f, -0.89949125f, -0.08150318f, 0.32476074f, 0.30868945f, 
    0.31951848f, -0.09817288f, 0.46209720f, -0.10319509f, -0.36552545f, 0.08888743f, -0.38578892f, 0.02673639f, 
    0.03658502f, -0.50753796f, -0.58556086f, 0.45814031f, 0.25005540f, -0.29318133f, -0.78242660f, -0.43100652f, 
    -0.20599960f, -0.14016798f, -0.16643922f, -0.47179037f, -0.15605606f, 0.23536587f, 0.03586167f, -0.60612166f, 
    0.46230963f, -0.08889307f, 0.04697046f, -0.80567336f, 0.30765462f, -0.11755079f, -0.07338300f, 0.02110394f, 
    0.27691004f, -0.38488331f, -0.90237176f, 0.11937416f, 0.29953194f, -0.33883384f, -0.55649811f, 0.11503704f, 
    -0.08066156f, 0.24932609f, -0.55787081f, -0.13918638f, 0.29550561f, 0.08206570f, -0.08169105f, 0.06576549f, 
    0.08271247f, 0.18021275f, -0.16254598f, -0.37145206f, 0.23500910f, -0.31417015f, 0.15283512f, -0.14522624f, 
    0.10735621f, -0.00010174f, 0.29259878f, 0.08868684f, -0.53318578f, 0.11619624f, 0.13852753f, 0.01457804f, 
    -0.23327599f, 0.43652481f, -0.29743758f, -0.06120759f, -0.18014827f, -0.43577415f, -0.10774299f, -0.18687139f, 
    -0.04033646f, 0.30773178f, -0.23629569f, 0.05008622f, -0.00991558f, -0.00952783f, -0.30638027f, -0.17634723f, 
    0.02671240f, 0.27432543f, 0.15552713f, -0.07267315f, -0.97494388f, 0.49294576f, 0.05001139f, -0.55339843f, 
    -0.35012642f, -0.28138033f, 0.06202278f, 0.42500785f, -0.12528580f, -0.88590348f, -0.23433982f, 0.12496543f, 
    0.24443537f, 0.14264666f, -0.24343929f, -0.04337475f, -0.34935024f, 0.39514714f, 0.06113938f, 0.07101110f, 
    -0.12972663f, -0.07523453f, 0.16967803f, 0.29810381f, -0.21007934f, -0.07742274f, -0.23196626f, -0.36472329f, 
    0.08373719f, 0.23129076f, -0.29870734f, -0.53626966f, 0.46076518f, 0.20171241f, -0.13039552f, 0.04883030f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.12895933f, 0.01765629f, 0.02236135f, -0.06388041f, -0.08418388f, -0.13116771f, 0.20411149f, -0.06016668f, 
    -0.03657543f, 0.04266423f, -0.03494351f, 0.21273378f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
