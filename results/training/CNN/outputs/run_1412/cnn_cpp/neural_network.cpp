#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.53694755f, -0.18055502f, 0.27422979f, 0.00889119f, -0.13698536f, 0.93143374f, -0.40967092f, -0.43810266f, 
    -0.34699714f, 0.94737315f, -0.46085915f, -0.48801449f, -0.15026009f, -0.06891538f, 0.31765518f, -0.08272393f, 
    0.35764033f, 0.02076163f, -0.23807272f, -0.03746042f, -0.31957209f, -0.09477099f, -1.06671071f, -0.81114620f, 
    0.21990046f, -0.05583666f, 0.02540353f, 0.29158720f, 0.05116806f, 0.43348306f, 0.34774607f, 0.47450209f, 
    0.81518704f, 0.09313581f, 0.28573778f, -0.03709295f, 0.05235669f, 0.72204024f, -0.62827766f, -0.26667365f, 
    -0.20087454f, -0.67426401f, -0.18198793f, -0.52884912f, -0.02218007f, 0.58236802f, 1.12228727f, -0.88835591f, 
    -0.57925826f, -0.02667965f, -0.20832422f, 0.01091656f, 0.25952458f, 0.26837018f, 0.23799890f, -0.52197504f, 
    0.10384656f, 0.40645337f, -0.14557046f, 0.01953921f, -0.28864294f, -0.44540888f, -0.70733237f, 0.70527661f, 
    -0.82030296f, 0.75327706f, -0.32496440f, -0.17270195f, 0.00984937f, 0.10276599f, 0.18561031f, 0.64347577f, 
    -0.08704799f, 0.28211153f, -0.08969519f, -0.48403111f, 0.47234517f, -0.74608707f, 0.63620609f, 0.22696173f, 
    0.35980913f, -0.71487761f, -0.40680429f, -0.04625590f, -0.45373166f, -0.67125571f, 0.49074346f, -0.20032053f, 
    -0.28557566f, 0.08605774f, -0.44600603f, 0.02080889f, 0.29127648f, -0.36430594f, -0.49332577f, -0.17555995f, 
    0.29831779f, 0.65408927f, 0.32340679f, -1.05158854f, -0.56065845f, -0.44416964f, 0.92302704f, -0.01666055f, 
    -0.20571451f, -0.34826291f, -0.52127981f, -0.04384496f, 0.09150311f, -0.04663003f, -0.35182711f, 0.11769246f, 
    0.93636107f, -0.87227070f, 0.18712863f, 0.00226293f, -0.21653338f, 0.28655687f, 0.06080794f, 0.40071425f, 
    -0.61564070f, -0.21546638f, -0.18616532f, 0.58968198f, 0.12220038f, -0.61279446f, -1.52371264f, 1.32471442f, 
    -0.81365800f, -0.18068725f, -0.09923652f, 0.22990520f, 0.16425993f, -0.15630446f, 0.01373885f, 0.75392783f, 
    -0.27757913f, 0.26251885f, -0.78629065f, 0.57929009f, 0.17864147f, -0.20380226f, -0.48667124f, -0.31788498f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17476827f, 0.64709634f, -0.15671778f, 0.03656003f, -0.15601309f, -0.01092054f, 0.13696080f, 0.22956492f, 
    -0.24034941f, -0.09528421f, -0.11441103f, -0.13225089f, 0.36543921f, 0.42982799f, 0.25235462f, -0.12269717f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.00669861f, 0.06356460f, -0.06453092f, -0.05847772f, 0.01660814f, -0.06953535f, -0.04027124f, -0.04362450f, 
    -0.05987343f, 0.03732296f, -0.06034204f, -0.00799394f, -0.04102096f, -0.02600217f, 0.05473898f, -0.05882892f, 
    -0.02388596f, -0.04679525f, -0.11636807f, -0.01647739f, -0.04955590f, 0.01107963f, -0.07890503f, -0.06667548f, 
    -0.04993183f, -0.01398820f, -0.06930255f, -0.04955427f, -0.02958890f, 0.05088156f, -0.04161124f, -0.01652901f, 
    0.01322213f, -0.03335651f, -0.04890658f, 0.08153988f, -0.03792276f, 0.05714902f, 0.00363815f, -0.08738533f, 
    -0.01420647f, -0.02575539f, -0.09564599f, 0.02958186f, -0.00081250f, 0.00116433f, -0.05134079f, -0.07963857f, 
    -0.08333853f, -0.02316266f, -0.04482836f, -0.04661684f, -0.03093345f, 0.05025776f, 0.00357896f, -0.01290002f, 
    0.04570518f, -0.08740208f, -0.02447399f, 0.01974370f, -0.08940323f, -0.01073857f, -0.04082421f, -0.01354063f, 
    -0.02120513f, -0.07885094f, -0.09150650f, -0.01989111f, -0.04313911f, 0.04952251f, -0.08253650f, 0.04978131f, 
    -0.03029359f, 0.05055409f, -0.08262295f, -0.04878895f, -0.03509329f, 0.04964056f, -0.00852618f, 0.05509955f, 
    -0.05943333f, 0.01129442f, -0.09503369f, -0.07178985f, 0.03166635f, 0.06957730f, -0.03709666f, -0.02575441f, 
    -0.08483688f, -0.07430667f, -0.00037284f, 0.03641873f, -0.10535601f, -0.10611600f, 0.06225513f, 0.05506343f, 
    0.02868475f, 0.06294333f, -0.06211225f, -0.03662071f, -0.00714527f, 0.05378048f, 0.04513071f, -0.08420140f, 
    0.07114561f, -0.07807978f, -0.00053878f, -0.07374016f, -0.03875834f, -0.07927060f, 0.00261058f, 0.02670893f, 
    -0.06702410f, -0.02716677f, 0.05933561f, 0.00583185f, 0.02398510f, 0.03147895f, 0.05360242f, -0.08473323f, 
    -0.00524491f, -0.04497985f, -0.07063113f, -0.06276482f, -0.00500370f, 0.04595637f, -0.10064163f, -0.02697216f, 
    0.01201466f, 0.00565238f, -0.01608234f, -0.05418919f, -0.04007573f, -0.04009496f, -0.08941214f, -0.03475701f, 
    0.02183104f, 0.02041693f, 0.03811837f, 0.03317883f, 0.06271187f, -0.04046779f, -0.03050508f, -0.03152080f, 
    0.05845695f, 0.04646005f, -0.04286593f, -0.08991595f, -0.03598022f, -0.07357575f, 0.06835957f, 0.06092175f, 
    0.02254621f, -0.02079442f, -0.07183915f, 0.00360670f, 0.03319532f, -0.08284412f, 0.00617387f, -0.04429017f, 
    -0.06979264f, 0.03297451f, -0.08408459f, -0.00238895f, 0.06542962f, -0.00940031f, 0.04439427f, -0.03169382f, 
    -0.03469452f, -0.04949019f, 0.03119610f, 0.01402047f, 0.00216582f, -0.00889951f, -0.00192553f, -0.08680630f, 
    0.00798872f, 0.02923717f, 0.00086866f, -0.07479559f, -0.05038317f, -0.04356973f, -0.02356415f, 0.06485465f, 
    -0.07573317f, -0.05442137f, -0.06264845f, 0.01872553f, -0.03614292f, 0.03386919f, -0.02606466f, -0.00528046f, 
    0.05009936f, -0.07673225f, -0.08505078f, -0.06199986f, -0.01937530f, -0.01279974f, 0.06250802f, -0.08908154f, 
    -0.01004012f, -0.07888886f, 0.06345594f, -0.08194809f, -0.08764601f, -0.07648167f, 0.01551203f, 0.06458875f, 
    -0.00192975f, 0.06936539f, -0.06187605f, -0.06620738f, 0.00622296f, -0.09025331f, 0.01118351f, -0.01998106f, 
    -0.08037514f, -0.02230956f, -0.03871551f, 0.04147424f, -0.05967744f, -0.07005453f, 0.07350349f, 0.00352197f, 
    0.03465875f, 0.03732752f, 0.04551478f, -0.03838089f, -0.06161552f, -0.01339497f, 0.06053392f, 0.06963044f, 
    -0.00253860f, 0.06399462f, -0.06151998f, -0.05243457f, -0.04870914f, -0.01540088f, -0.05395049f, 0.07294247f, 
    -0.04326754f, -0.08160342f, -0.05030122f, -0.04449673f, 0.04947617f, -0.03083655f, -0.06041040f, 0.04077970f, 
    0.02434294f, 0.01331850f, -0.08443461f, -0.06797359f, 0.01840071f, -0.02267306f, -0.03603051f, 0.01112691f, 
    0.04354899f, -0.04809960f, 0.04152254f, -0.03855748f, 0.01470646f, -0.03443310f, -0.09386743f, -0.06482934f, 
    -0.00705114f, -0.06891004f, 0.06654179f, 0.06094629f, -0.01284718f, 0.01504853f, -0.08349410f, -0.03848325f, 
    -0.02491429f, -0.02482792f, 0.00214636f, 0.03830341f, 0.06866795f, 0.05835566f, 0.00199983f, -0.06378917f, 
    -0.05917897f, 0.06119291f, 0.03978900f, -0.02307077f, -0.00619921f, -0.06176845f, -0.08000463f, 0.00830371f, 
    -0.09010153f, -0.11140242f, -0.15785742f, 0.18970372f, 0.02007630f, -0.06861908f, 0.12898925f, -0.21459466f, 
    -0.17784417f, 0.83628076f, 0.01015903f, 0.20661262f, 0.17310503f, 0.07838815f, -0.00712467f, 0.12710541f, 
    0.10084319f, 0.20990443f, -0.15182130f, 0.02456483f, -0.06444196f, -0.13571636f, -0.03885662f, -0.18701208f, 
    0.13714859f, 0.22964856f, 0.02069874f, -0.16742869f, -0.06975416f, 0.02868990f, -0.22079818f, -0.04925793f, 
    -0.21743242f, 0.04932194f, 0.04036384f, 0.08353987f, -0.21513732f, -0.14256962f, -0.41163024f, -0.20949516f, 
    0.02730112f, -0.11081382f, -0.04176704f, -0.13539732f, -0.11066194f, -0.94215691f, -0.37666425f, -0.16592962f, 
    -0.14222713f, -0.22975764f, -0.09188668f, -0.14204015f, 0.04801567f, 0.10037722f, 0.29903212f, -0.05849084f, 
    0.02337581f, 0.18534948f, 0.07613978f, -0.03227362f, 0.18041658f, -0.20910348f, -0.27218044f, 0.21584433f, 
    -0.56869304f, -0.26961908f, -0.08763260f, 0.15225688f, -0.14284697f, 0.05692841f, 0.23700559f, 0.06781019f, 
    -0.69622260f, -0.13998581f, 0.23927993f, -0.16560477f, 0.16415673f, 0.11673447f, -0.20868888f, -0.17517406f, 
    0.10826880f, 0.06525197f, -0.04317268f, -0.08878661f, -0.09401907f, -0.05165740f, 0.06004228f, 0.04453461f, 
    0.12097540f, 0.01187384f, -0.02510315f, -0.53821695f, -0.19038191f, -0.01628536f, 0.15285993f, -0.01082893f, 
    0.05141474f, -0.15751077f, 0.17878193f, -0.05084221f, 0.77652574f, 0.52936393f, -0.03470114f, -0.10246150f, 
    -0.11203326f, 0.01784322f, -0.05081050f, -0.35148004f, -0.05041093f, 0.02541173f, -0.02224503f, 0.00374882f, 
    0.18222223f, 0.04970689f, 0.26709256f, 0.07808454f, 0.11559832f, 0.18698411f, 0.03712356f, -0.03527757f, 
    0.21414702f, -0.00242888f, 0.00985965f, 0.13267037f, -0.07364196f, 0.35987896f, 0.34724486f, -0.16360800f, 
    -0.04158598f, -0.15526648f, 0.13809428f, 0.27811778f, -0.13142201f, 0.08388193f, 0.09080080f, -0.13126230f, 
    -0.08309221f, 0.34418404f, -0.12518992f, -0.04538197f, -0.04789305f, 0.04372793f, -0.03792040f, 0.21812296f, 
    -0.15064692f, -0.36485672f, -0.13276789f, 0.06261034f, 0.12126708f, -0.10314454f, -0.02975699f, -0.03546884f, 
    -0.21849537f, 0.06496209f, -0.13002346f, -0.21918575f, -0.00181197f, 0.08549081f, 0.09138092f, -0.03523609f, 
    -0.15024388f, 0.20249982f, -0.08493998f, 0.19269609f, 0.43343240f, -0.14620592f, -0.01166475f, 0.17291404f, 
    0.14142591f, -0.02165652f, -0.06335923f, 0.22977532f, 0.22320668f, -0.07561522f, -0.06133666f, -0.25009128f, 
    -0.16439511f, -0.00476819f, -0.09793052f, 0.06000730f, 0.03797904f, -0.00703783f, -0.24942082f, 0.08126905f, 
    0.08149230f, 0.01191455f, -0.01261233f, 0.01251199f, -0.05815756f, -0.12178957f, -0.23553936f, 0.04169942f, 
    -0.16554976f, 0.04574814f, 0.12873064f, 0.04088848f, 0.02733194f, -0.17289765f, -0.27048647f, -0.19587362f, 
    -0.02873258f, -0.08703228f, 0.12132116f, 0.27461046f, -0.11744137f, -0.08421914f, -0.11153228f, 0.03291261f, 
    -0.25225002f, -0.08299572f, 0.09647751f, -0.01152872f, -0.05966935f, 0.11878077f, 0.00052589f, 0.19694836f, 
    -0.20391917f, -0.07535419f, 0.23236580f, 0.20987809f, -0.09333335f, 0.16169706f, 0.13542338f, -0.01054383f, 
    0.21235047f, 0.00593997f, -0.13931705f, -0.02974853f, -0.05123096f, 0.13574119f, 0.02520342f, 0.14219248f, 
    0.06779546f, 0.14542271f, -0.03408032f, 0.05855146f, 0.47693220f, 0.29542828f, 0.21884118f, 0.27970037f, 
    0.12461349f, 0.02856026f, 0.20330282f, -0.24393052f, -0.09092999f, 0.25636622f, -0.19995630f, -0.37260887f, 
    -0.08892903f, 0.09303907f, -0.22060263f, -0.00969953f, -0.26016459f, 0.45746958f, 0.32339212f, 0.17830065f, 
    -0.14090483f, 0.14620568f, 0.14242502f, 0.12439415f, 0.14355478f, -0.20173001f, -0.22088018f, 0.34873340f, 
    0.05596691f, 0.15247212f, -0.05872066f, 0.12422331f, 0.17136455f, 0.06867021f, 0.31438613f, -0.35947302f, 
    0.10574552f, 0.05210059f, -0.13531309f, -0.06998592f, -0.00086638f, -0.19450811f, 0.07419264f, 0.18870306f, 
    -0.09016576f, -0.10275270f, 0.02454062f, 0.13643144f, -0.11089831f, -0.42787170f, -0.00709115f, -0.05091074f, 
    0.12776451f, 0.09133989f, -0.31217194f, 0.01344780f, 0.10559320f, 0.15015152f, -0.00006483f, 0.21691073f, 
    0.37730002f, 0.22118978f, 0.20817170f, -0.49276417f, -0.06943530f, 0.07272322f, 0.27580157f, 0.04789085f, 
    0.09434307f, 0.10754674f, -0.07556216f, -0.01662816f, -0.05613038f, 0.01060329f, 0.07880127f, -0.18112513f, 
    0.07808625f, -0.06088702f, 0.00898637f, -0.00308744f, 0.16060419f, -0.08825836f, 0.02048828f, 0.02366582f, 
    0.14807643f, 0.07878563f, 0.04824961f, 0.12292341f, -0.27723983f, -0.28874439f, -0.65291226f, 0.01264942f, 
    0.10325733f, 0.02533345f, -0.17919278f, 0.08424534f, -0.01198522f, 0.17037752f, -0.21943289f, -0.46829885f, 
    0.21506561f, -0.00963003f, 0.26167935f, 0.06874336f, -0.01798867f, -0.05545735f, 0.09289875f, 0.02554171f, 
    0.03612528f, 0.00430508f, -0.02293255f, -0.04078955f, 0.16434352f, -0.02096555f, 0.30483165f, 0.84421211f, 
    -0.03613245f, -0.24391794f, -0.09278329f, -0.04254608f, 0.15638755f, -0.06924188f, -0.02040690f, -0.17180528f, 
    -0.32808736f, -0.46478963f, 0.22688726f, -0.20201424f, 0.13402282f, -0.00821419f, 0.02864983f, -0.06602296f, 
    -0.30821240f, 0.37049502f, -0.48081055f, -0.92863870f, 0.00790666f, 0.01010988f, 0.04722032f, -0.03836288f, 
    -0.13586664f, -0.10000733f, -0.28032058f, -0.61512160f, -0.22089231f, -0.22374177f, 0.03305498f, -0.23927464f, 
    -0.03003193f, 0.01406407f, 0.04597790f, -0.10754094f, -0.59722680f, -0.00059805f, -0.04609001f, -0.00742567f, 
    -0.03321785f, -0.05880116f, 0.08036853f, -0.12257505f, -0.39208853f, -0.42509446f, 0.24291839f, 0.10408279f, 
    0.00681377f, -0.11260930f, 0.11025019f, -0.08492974f, 0.22290829f, 0.44469145f, -0.01841266f, -0.40887868f, 
    -0.08491524f, 0.09579945f, -0.03655486f, -0.06854956f, 0.11820627f, 0.13432553f, -0.10665143f, -0.70182163f, 
    -0.38342854f, 0.14159082f, 0.06668242f, 0.11500555f, 0.18419082f, -0.06802786f, -0.13335246f, -0.14108248f, 
    0.34660673f, 0.02041619f, -0.15110950f, 0.08562946f, -0.12895447f, 0.10124169f, 0.02392878f, 0.16855152f, 
    -0.45625603f, -0.09386077f, -0.21133403f, 0.00003971f, 0.03704281f, 0.13594247f, 0.16842797f, -0.07142500f, 
    0.04641672f, 0.39224470f, 0.08334801f, 0.18137021f, -0.08929123f, 0.28854188f, 0.07598825f, 0.11929384f, 
    -0.03078019f, -0.07007839f, -0.21957101f, 0.61506617f, -0.01725629f, -0.01563093f, 0.06138216f, 0.00630557f, 
    -0.06006834f, 0.17472692f, -0.06883892f, 0.36943212f, 0.23080598f, 0.14998190f, -0.01034986f, 0.02691390f, 
    -0.11808593f, -0.15398146f, -0.36173788f, -0.15793598f, 0.10742068f, -0.09889437f, -0.39693701f, -0.11253600f, 
    -0.14703102f, 0.14156030f, -0.00239875f, 0.09061054f, 0.01249756f, 0.31778142f, -0.10511797f, 0.05366489f, 
    -0.12838428f, -0.04094061f, 0.21966465f, 0.02385778f, -0.09676863f, -0.06021797f, -0.02296369f, 0.05524108f, 
    -0.22462925f, 0.04896364f, 0.05059733f, -0.00160712f, -0.02392589f, 0.11660524f, 0.09378375f, 0.31899080f, 
    0.04843506f, -0.12803821f, -0.05869565f, 0.26676846f, -0.15230459f, 0.07261465f, -0.04102943f, -0.02907037f, 
    -0.20626669f, -0.31071404f, -0.17986809f, -0.02051470f, 0.13480917f, 0.08009772f, 0.13015339f, -0.06301633f, 
    0.03121616f, -0.06016202f, -0.15928528f, -0.01935200f, 0.04044612f, -0.11033355f, 0.21647370f, 0.18540677f, 
    -0.07709897f, 0.04933983f, -0.42897433f, -0.10585392f, 0.10733166f, -0.00282245f, 0.32592717f, 0.12151961f, 
    -0.09506628f, -0.02237787f, 0.07367826f, -0.23102574f, -0.08082142f, -1.23481226f, -0.08727935f, -0.35734755f, 
    -0.17576969f, 0.05285925f, 0.05446590f, -0.05348975f, -0.01643593f, 0.27833405f, -0.08800888f, 0.32060316f, 
    0.07101040f, 0.12531883f, 0.08454541f, 0.09967239f, -0.14552319f, 0.29973593f, 0.00785050f, 0.49788919f, 
    -0.16384190f, -0.12608701f, -0.32277778f, -0.12978989f, 0.06761753f, 0.10862777f, -0.68194830f, -0.50299603f, 
    -0.54790336f, 0.14017692f, 0.22991526f, -0.03528585f, 0.13793977f, -0.00698571f, -0.05858975f, 0.37209773f, 
    0.22716105f, 0.27998054f, -0.00437424f, 0.07387944f, -0.16877079f, 0.08144926f, 0.02662674f, 0.01153303f, 
    -0.59263605f, -0.03449274f, 0.38545120f, -0.02221964f, 0.01181199f, -0.03704277f, 0.06737480f, -0.22898291f, 
    -0.04156606f, 0.19682658f, -0.21194652f, -0.11659807f, 0.09369545f, -0.02979923f, -0.04543667f, 0.04524835f, 
    0.09796700f, 0.02403424f, -0.12211835f, 0.34783486f, 0.01561841f, -0.14296331f, -0.11700982f, 0.05023884f, 
    0.16510084f, 0.04248555f, -0.01409639f, -0.01651496f, -0.06068984f, 0.11023030f, -0.13179393f, -0.09826566f, 
    -0.18501687f, -0.04051558f, -0.07447822f, -0.03107930f, 0.29254088f, 0.25016031f, -0.03732808f, 0.04794846f, 
    0.07702526f, -0.06460336f, -0.05670014f, 0.20385899f, -0.04957502f, -0.17391564f, -0.94222796f, -0.77225494f, 
    -0.12770209f, 0.12134326f, 0.04476254f, -0.04008665f, -0.11681613f, 0.16590594f, 0.12870890f, -0.15393361f, 
    -0.12841909f, -0.08385722f, 0.01440786f, -0.02208263f, 0.03743474f, -0.18903266f, -0.18612902f, -0.24891816f, 
    -0.00425445f, 0.07734010f, -0.06335101f, 0.13870658f, 0.02794471f, -0.18406942f, 0.05867353f, 0.09048371f, 
    -0.25936154f, 0.36166337f, 0.10647939f, -0.15061539f, -0.02033332f, -0.08318403f, 0.04075875f, 0.11299443f, 
    0.12080775f, -0.02335125f, 0.17550574f, 0.35313994f, -0.13497087f, 0.22122747f, 0.00689431f, -0.02286874f, 
    0.06394942f, -0.03334201f, -0.11203343f, 0.24184495f, 0.20585454f, 0.07336883f, -0.01463929f, 0.06383375f, 
    0.07947392f, 0.16931272f, 0.04400704f, 0.12649810f, 0.01382792f, -0.15793322f, -0.09748007f, 0.19227122f, 
    -0.23227966f, 0.13163310f, -0.06256593f, -0.07286618f, 0.04581106f, 0.24004239f, 0.30299166f, 0.05052105f, 
    -0.07842981f, -0.01579673f, -0.04796188f, 0.02665719f, 0.02771776f, 0.12184259f, 0.27929470f, -0.07659580f, 
    -0.08146258f, -0.10049254f, 0.05365513f, -0.15467758f, 0.04454622f, 0.29719701f, -0.45392916f, 0.00977878f, 
    -0.19426739f, -0.13987017f, 0.02276925f, 0.32784730f, 0.14066270f, 0.13478100f, -0.04168506f, 0.04536943f, 
    -0.02655215f, 0.03156070f, -0.07551078f, -0.03120629f, 0.05760704f, 0.07141623f, -0.00764856f, -0.23948681f, 
    -0.36313465f, 0.42866418f, -0.16490820f, 0.17946844f, -0.03161603f, -0.12721366f, -0.06093932f, -0.15269442f, 
    0.24343124f, 0.03213295f, -0.16519898f, 0.42041659f, 0.10156395f, -0.01798083f, 0.37444821f, -0.04906564f, 
    0.07193823f, 0.07735287f, -0.11248320f, 0.02014493f, 0.68465608f, -0.26511919f, -0.14356998f, -0.18716158f, 
    -0.11606923f, 0.13426550f, 0.02947137f, 0.08409653f, -0.07530677f, -0.24749321f, 0.01401735f, -0.10226333f, 
    -0.02313387f, 0.05386217f, 0.16101991f, -0.01903243f, -0.28880012f, -0.03972367f, -0.36296079f, -0.05833954f, 
    -0.08154028f, 0.10911398f, -0.02362143f, 0.06021534f, -0.26667473f, -0.23358077f, 0.26492149f, 0.08518811f, 
    0.04901449f, -0.09941480f, 0.03506046f, 0.21285024f, -0.08864007f, 0.22774212f, 0.06401232f, -0.28078517f, 
    0.28415799f, -0.12017488f, 0.12051588f, -0.12009415f, -0.04068818f, -0.19524424f, 0.22376226f, 0.32633105f, 
    0.12796280f, -0.14282149f, -0.08575076f, 0.22847940f, 0.08766819f, 0.03747058f, 0.21739845f, -0.25280988f, 
    -0.45416239f, -0.27769580f, 0.20251659f, -0.04502900f, -0.08761092f, 0.04527943f, -0.00442661f, -0.09320734f, 
    -0.11805420f, 0.36479235f, 0.68996340f, -0.05001635f, -0.06299592f, -0.26384479f, 0.20196410f, 0.20031074f, 
    0.26744917f, -0.04556228f, -0.28931221f, -0.31732389f, 0.07313856f, -0.06895571f, -0.03236088f, -0.13894938f, 
    -0.04976477f, 0.03622017f, 0.06519425f, 0.28051218f, -0.13577719f, -0.44689530f, 0.07190603f, 0.10488696f, 
    -0.15637058f, -0.05977801f, 0.10544492f, -0.10861408f, 0.15234171f, -0.16702917f, 0.28704944f, 0.19914006f, 
    0.16203542f, -0.15447830f, -0.11415900f, 0.10864309f, 0.15547332f, -0.12073197f, 0.26334608f, 0.41128749f, 
    -0.01821833f, -0.03448652f, -0.16417812f, -0.07477900f, 0.20254853f, 0.04208896f, -0.15849039f, -0.56951445f, 
    -0.74357802f, -0.22238888f, -0.07018559f, 0.26601616f, 0.07007527f, -0.06219768f, -0.03042695f, -0.07406078f, 
    -0.13989203f, 0.46545818f, 0.02424484f, -0.19372885f, 0.08812189f, -0.20079938f, 0.17239696f, 0.25901002f, 
    -0.26447535f, 0.20919408f, 0.37580925f, -0.06956764f, -0.03005846f, -0.03836412f, 0.17661020f, 0.02758633f, 
    0.21003331f, 0.50435889f, 0.34913641f, 0.23887977f, 0.03713620f, 0.03966319f, 0.29371232f, -0.01537588f, 
    0.08621882f, 0.09475245f, 0.13639523f, -0.04818309f, -0.32062963f, -0.22047687f, 0.00755087f, -0.17173526f, 
    0.04011158f, 0.18676135f, -0.01371593f, -0.02627575f, 0.00137520f, 0.19501038f, -0.10971399f, -0.11372218f, 
    0.02662535f, 0.12281325f, 0.27770510f, 0.09204733f, -0.17936020f, -0.55794120f, -0.84163845f, -0.02936606f, 
    -0.08024243f, -0.06507140f, -0.12082116f, 0.05227458f, -0.10525059f, 0.18996124f, -0.19716711f, -0.75683272f, 
    -0.06568959f, 0.06738043f, 0.19984291f, -0.07627329f, 0.05695847f, -0.13000409f, 0.15705059f, 0.06591338f, 
    0.26685187f, 0.07397467f, -0.01173936f, -0.03818345f, 0.15956894f, -0.11708779f, 0.09211943f, 0.39641422f, 
    0.11074774f, -0.38029531f, 0.07950666f, 0.07643975f, 0.12192345f, 0.00916076f, -0.02520404f, -0.05653216f, 
    -0.19562142f, -0.21937768f, -0.08289002f, -0.14708309f, 0.03550908f, -0.19534746f, -0.08850927f, -0.03995337f, 
    -0.12142798f, -0.06216175f, -0.22676066f, 0.46117890f, 0.06476660f, 0.06384464f, -0.00028996f, 0.05007232f, 
    0.11474244f, 0.02092543f, -0.27732465f, 0.02587479f, -0.10931295f, -0.27148050f, -0.09465211f, 0.12873720f, 
    -0.14473328f, -0.11803264f, -0.13968551f, 0.13051215f, 0.13289903f, 0.05525646f, -0.00412385f, -0.06841066f, 
    -0.24572678f, 0.04001943f, 0.09707555f, 0.04120343f, -0.01429414f, -0.64796942f, 0.09051652f, -0.01266147f, 
    0.29371855f, 0.00682721f, 0.18387344f, 0.21809785f, 0.34191406f, 0.09649322f, -0.16038662f, -0.27952662f, 
    0.06166094f, 0.15132478f, 0.02875064f, 0.04349065f, 0.16511309f, 0.17284963f, -1.57639742f, -0.00252290f, 
    -0.18904881f, 0.12089882f, -0.19207710f, 0.09498955f, 0.07785423f, -0.03516196f, 0.04744408f, -0.33634564f, 
    -0.52460444f, -0.80604005f, -0.06410839f, 0.04553833f, 0.04991295f, 0.02369604f, -0.11918198f, 0.09613928f, 
    -0.05922569f, 0.25089112f, 0.03363824f, 0.13300765f, -0.07625505f, 0.12916511f, -0.16583379f, 0.25699088f, 
    0.16665234f, -0.18443170f, 0.12694858f, 0.05815331f, -0.03529148f, 0.04642621f, 0.07078435f, 0.08081059f, 
    0.10436203f, -0.06408577f, 0.13679431f, -0.10427976f, -0.10141217f, 0.05552055f, 0.30690691f, 0.12646537f, 
    -0.20180939f, -0.07983509f, 0.00565145f, 0.05449667f, 0.10371912f, 0.14978348f, 0.18827216f, 0.13203029f, 
    0.13024206f, -0.09802179f, -0.13417889f, -0.16056754f, -0.03977298f, 0.24450330f, 0.36478356f, 0.12114877f, 
    0.00493912f, 0.18413390f, -0.02250201f, -0.01014705f, 0.15046531f, 0.18959697f, 0.18143579f, 0.16189614f, 
    -0.08482042f, -0.19454999f, 0.12493472f, 0.08592988f, -0.00725899f, -0.04083871f, -0.22859316f, -0.01832543f, 
    -0.14949059f, 0.21849321f, 0.09049071f, -0.06203215f, -0.26040247f, 0.20572461f, 0.14632009f, -0.20140313f, 
    0.28222299f, 0.05823686f, -0.02466617f, -0.09545610f, 0.03668244f, -0.08040568f, 0.17025620f, -0.39957282f, 
    0.37381458f, -0.04284093f, 0.13893908f, 0.24291034f, 0.12183430f, -0.01862702f, -0.27018824f, -0.78326058f, 
    -0.31741917f, -0.02651810f, 0.14572743f, -0.27111575f, -0.13094500f, 0.19444212f, -0.14203605f, -0.00758780f, 
    -0.08558948f, 0.00867549f, -0.01257786f, 0.12538080f, -0.03851864f, 0.11477385f, 0.07723629f, -0.08892846f, 
    -0.41685015f, -0.15707333f, -0.27284136f, -0.07067127f, -0.08891451f, -0.05390076f, 0.03080849f, 0.03484453f, 
    0.12873842f, -0.03403676f, 0.14736621f, 0.19760320f, 0.26163930f, -0.27243954f, 0.26964840f, -0.20525521f, 
    -0.12202542f, 0.08582706f, 0.03197257f, 0.16692895f, -0.00078968f, -0.01204080f, 0.05435942f, 0.11158717f, 
    -0.03775192f, -0.00440520f, 0.07536963f, 0.22544609f, -0.13198937f, -0.13266948f, -0.18412314f, 0.18556221f, 
    0.13029243f, -0.20603231f, 0.29322127f, 0.22877993f, 0.14800839f, 0.07773536f, 0.07432467f, -0.41249800f, 
    -0.36413571f, 0.04390172f, 0.33468601f, 0.07828394f, 0.12546076f, 0.28482300f, 0.04248630f, 0.13850956f, 
    -0.10413051f, -0.14680523f, 0.09490389f, 0.10356769f, -0.09104384f, 0.11884410f, -0.11071508f, -0.27659407f, 
    -0.37268394f, -0.13697457f, -0.30103946f, -0.02541415f, 0.15194142f, 0.14228663f, -0.05446980f, 0.05003027f, 
    0.01114304f, 0.05269128f, -0.00870111f, 0.23709764f, -0.09446224f, 0.02675341f, 0.11002661f, 0.06057445f, 
    0.00271726f, -0.02545761f, -0.16944110f, -0.13164485f, -0.04169470f, 0.00874018f, -0.00988461f, -0.19387037f, 
    -0.43493214f, -0.06790525f, -0.12975310f, -0.08504419f, 0.06939422f, -0.12775575f, 0.11709164f, 0.07793385f, 
    0.09191386f, 0.01544115f, 0.08195539f, -0.00907279f, -0.36597428f, -0.38628492f, -0.29462835f, -0.15574136f, 
    -0.04586021f, 0.06261963f, 0.07973145f, 0.04303325f, 0.02900796f, -0.00269290f, -0.08688470f, -0.17173481f, 
    -0.13754475f, 0.08988067f, 0.01598770f, 0.18713707f, -0.13709581f, -0.20256826f, -0.49492049f, 0.05334503f, 
    0.01744122f, -0.03739420f, 0.10981315f, 0.22911637f, 0.14127712f, 0.14727302f, 0.05245244f, 0.05592666f, 
    0.07441542f, 0.34524396f, 0.13472828f, -0.44020727f, 0.25939220f, -0.01454017f, 0.03337852f, 0.29112968f, 
    0.09771796f, 0.33189565f, 0.38722825f, 0.24979568f, 0.08373758f, -0.04531843f, 0.06839438f, 0.15766767f, 
    -0.04355604f, 0.05145023f, 0.19438697f, 0.09277965f, 0.30964550f, -0.07541418f, 0.01830683f, -0.07223255f, 
    0.09840833f, 0.10211841f, -0.00403983f, 0.78411674f, 0.02287074f, -0.61737442f, -0.08500180f, -0.15935691f, 
    -0.06065996f, -0.05724759f, 0.01654448f, 0.06522027f, -0.02257365f, 0.29963949f, -0.48139393f, 0.25154838f, 
    0.27541506f, 0.26614830f, 0.01241233f, 0.18005930f, -0.01109387f, -0.15317167f, 0.28345782f, 0.03761123f, 
    -0.13204640f, 0.00861637f, 0.18374822f, -0.21033838f, 0.44730324f, -0.15855114f, 0.43430868f, 0.18922713f, 
    0.17517410f, 0.12815344f, 0.01740486f, -0.00843577f, 0.03962878f, 0.09899947f, -0.02588492f, -0.21520220f, 
    -0.22300248f, -0.03737779f, 0.13829164f, 0.04098058f, 0.06345486f, -0.40227538f, 0.21289870f, -0.25514415f, 
    0.11362664f, 0.11504720f, 0.03029260f, -0.08523113f, 0.00810643f, 0.03409978f, -0.20702022f, -0.05244067f, 
    0.20905468f, 0.40764168f, -0.09077577f, -0.08315422f, 0.19374850f, -0.00722446f, -0.09646518f, 0.11677126f, 
    -0.05044366f, -0.05292645f, -0.38747609f, -0.04015918f, -0.15325129f, 0.01929664f, -0.13974734f, 0.01546983f, 
    0.04323630f, -0.01727483f, 0.21689197f, -0.11621302f, 0.01777590f, -0.25663704f, -0.41092452f, -0.15491836f, 
    0.02530780f, 0.06357775f, 0.08610404f, 0.00362869f, -0.00463165f, 0.05476678f, -0.20862648f, 0.19126590f, 
    -0.01341856f, 0.15875165f, 0.30085897f, -0.12362059f, -0.18615970f, 0.54531682f, -0.57513338f, -0.05908512f, 
    -0.08890028f, 0.08662289f, -0.04342026f, -0.03884408f, 0.03661806f, 0.15444893f, 0.20097673f, 0.30877101f, 
    0.16291173f, -0.01939094f, 0.08332578f, 0.07016040f, -0.10388438f, 0.03551307f, 0.18800206f, 0.67970651f, 
    -0.23242396f, -0.20507769f, 0.15353435f, -0.06307933f, 0.17779942f, 0.03009182f, -0.19434538f, -0.06774263f, 
    -0.57655936f, -0.47090897f, 0.14385943f, -0.08290615f, 0.17204821f, -0.33024377f, 0.09270794f, 0.15969276f, 
    -0.17666008f, -0.15383832f, -0.07964293f, 0.00538640f, -0.11370443f, 0.17683275f, -0.01882640f, 0.10793226f, 
    -0.15993486f, -0.04499772f, -0.12330021f, -0.38536450f, 0.09001382f, 0.00884007f, 0.02028515f, -0.13804384f, 
    0.13907902f, 0.00184826f, 0.04601230f, -0.69721073f, 0.19721103f, 0.22623172f, -0.15605503f, 0.01066102f, 
    0.13013063f, -0.04461313f, -0.05522062f, -0.01075762f, -0.44929081f, 0.21927992f, 0.57212311f, 0.04728237f, 
    0.07624286f, 0.02680703f, 0.09021343f, 0.35132670f, 0.17678106f, 0.25024721f, -0.12333246f, -0.04174511f, 
    -0.11864488f, -0.01983197f, -0.01756575f, 0.15125439f, 0.25423616f, 0.13197450f, -0.32585812f, 0.17211775f, 
    -0.22818755f, 0.02221725f, -0.16563667f, 0.18573740f, 0.07165265f, 0.09371257f, -0.12086834f, 0.02741162f, 
    -0.30978492f, -0.15007581f, -0.06426384f, 0.03709285f, -0.16345221f, -0.17629963f, 0.05631520f, 0.00440959f, 
    0.20350918f, -0.06969413f, -0.08433068f, 0.04509427f, 0.29096261f, 0.25827006f, -0.08120486f, 0.18645716f, 
    -0.01687179f, 0.05292527f, -0.07432041f, 0.18656668f, 0.04397165f, 0.09831430f, 0.03952260f, -0.00312228f, 
    0.08246648f, -0.08222373f, 0.18626983f, -0.11433355f, 0.43094161f, 0.36920878f, 0.05232703f, 0.01456332f, 
    -0.07445513f, 0.06924596f, -0.00777717f, 0.02497971f, 0.07528423f, -0.15288353f, 0.24102947f, 0.07230712f, 
    0.01949072f, -0.06227596f, -0.13490827f, 0.02621917f, 0.39440724f, -0.07508718f, 0.43548027f, 0.11771219f, 
    0.02961212f, -0.27798051f, 0.04075403f, 0.02097246f, 0.18162215f, -0.09598301f, 0.58300501f, 0.17389449f, 
    0.09769145f, -0.04848105f, -0.24616341f, -0.00568206f, 0.08172137f, -0.15210354f, 0.01818730f, 0.05823980f, 
    0.11558769f, -0.23366380f, 0.14416488f, 0.05120400f, 0.06080757f, 0.24878269f, 0.15056051f, -0.06807198f, 
    -0.09844071f, -0.14045113f, 0.02038821f, 0.07966338f, -0.15546301f, 0.02852220f, -0.05456470f, -0.26756600f, 
    -0.23409428f, -0.19166747f, -0.08196627f, 0.05720948f, 0.10843920f, 0.03253352f, 0.00756780f, -0.38674423f, 
    -0.17997521f, 0.14374948f, -0.18382695f, 0.12677042f, 0.17021774f, -0.11851235f, 0.06974965f, -0.07945339f, 
    -0.00326024f, 0.04882440f, -0.31948754f, -0.42156413f, -0.14188251f, 0.08607539f, 0.13328718f, -0.13522865f, 
    -0.07308175f, -0.19960050f, -0.20479256f, -0.06348316f, -0.40702131f, -0.15241271f, 0.05607319f, -0.04762372f, 
    0.32161134f, -0.10269515f, -0.16311233f, 0.05678115f, -0.04113718f, 0.28889433f, 0.23115385f, 0.04199965f, 
    0.10044405f, 0.12647648f, 0.13547778f, 0.23304914f, 0.31209061f, -0.00453277f, 0.23670180f, -0.11224567f, 
    -0.05000566f, 0.05294618f, 0.08524547f, 0.21110100f, 0.10788673f, 0.07535432f, 0.60097635f, 0.19423787f, 
    -0.08651914f, 0.20855761f, 0.18681431f, -0.01273261f, 0.01497725f, -0.14603181f, 0.40033332f, -0.17683621f, 
    -0.04826993f, -0.21737263f, 0.11905119f, -0.02551625f, -0.09242063f, 0.09985808f, -0.06860691f, 0.00580017f, 
    0.00308782f, 0.12785430f, 0.20127888f, -0.00719086f, 0.18811610f, -0.03164117f, -0.04939847f, 0.21390615f, 
    -0.01318359f, 0.06863273f, 0.05074381f, -0.19159131f, -0.09895995f, -0.15215391f, 0.09771296f, 0.00713507f, 
    0.03550190f, 0.04232455f, 0.39105651f, 0.08239350f, -0.03422470f, -0.15735061f, -0.07154188f, -0.16120407f, 
    -0.08316679f, -0.02003501f, 0.10581986f, -0.03382579f, -0.25014493f, -0.21446307f, 0.01181523f, -0.06521945f, 
    -0.01135736f, 0.07068774f, -0.10116367f, -0.08569727f, -0.24179269f, 0.04994348f, 0.03551192f, -0.17339137f, 
    -0.21062686f, -0.25282615f, -0.09004419f, 0.10235110f, -0.11071142f, -0.40792662f, -0.12167897f, -0.35917395f, 
    -0.25620353f, -0.34701115f, -0.09829106f, 0.27614865f, -0.02298511f, -0.00098358f, 0.35490504f, -0.04293552f, 
    0.14578706f, -0.26568022f, 0.07426154f, 0.01155316f, -0.09872185f, -0.03502772f, 0.04134968f, -0.18247549f, 
    -0.14103536f, -0.39329779f, 0.05496384f, 0.10001782f, -0.36587501f, 0.01230433f, -0.00109177f, -0.10689899f, 
    -0.06983609f, 0.13655812f, 0.04876471f, 0.16625530f, -0.12737346f, 0.24545522f, -0.16221875f, -0.05908301f, 
    0.13850307f, 0.43977904f, 0.24570876f, 0.09887247f, 0.01595550f, 0.20524126f, -0.04713215f, -0.01280719f, 
    0.12886675f, -0.31080070f, 0.36923742f, 0.24405603f, 0.06770723f, 0.07344598f, -0.03361078f, 0.00960222f, 
    0.13509998f, -0.03559539f, 0.18600364f, 0.76427895f, 0.35142332f, 0.15910387f, -0.01972480f, -0.05499708f, 
    0.22528853f, -0.01499467f, 0.10982613f, -0.08358646f, -0.29374105f, -0.24546871f, -0.33148640f, -0.01731691f, 
    0.06468348f, -0.01956751f, 0.13484079f, 0.01515233f, -0.02305269f, -0.21607035f, 0.13596115f, -0.03675659f, 
    -0.08912080f, -0.02694159f, -0.26144436f, 0.11992060f, -0.12214435f, 0.05305350f, -0.26775795f, 0.07096132f, 
    -0.18265359f, 0.11978969f, 0.02849536f, -0.08124081f, 0.18759736f, -0.08234548f, 0.00461633f, -0.20210750f, 
    -0.11253943f, 0.53522444f, 0.22317131f, -0.06887688f, 0.25266597f, -0.16925056f, -0.01017234f, 0.21040809f, 
    -0.03768584f, 0.10169108f, -0.04118680f, 0.11006483f, -0.14281969f, 0.22703321f, -0.07185315f, 0.01896464f, 
    -0.58322006f, 0.10006797f, -0.40922633f, 0.26829326f, 0.10779152f, 0.02661039f, 0.11192430f, 0.19222797f, 
    0.01955982f, -0.04010642f, -0.27814648f, 0.25588426f, -0.35218707f, 0.12024733f, 0.10730512f, 0.13948637f, 
    0.01261441f, 0.01570333f, 0.17714688f, -0.12510809f, -0.06048374f, -0.05435135f, 0.25165272f, 0.00491380f, 
    0.05125058f, -0.14770620f, 0.07445066f, -0.09267231f, -0.05724148f, 0.23044549f, -0.24052534f, 0.02379452f, 
    -0.03943617f, 0.02101013f, -0.20432578f, 0.08921304f, -0.29854614f, 0.05728263f, 0.40117317f, 0.21208143f, 
    -0.09382627f, -0.02828013f, -0.02123551f, 0.07555663f, 0.16891912f, 0.06524435f, 0.00517693f, -0.01253450f, 
    -0.08439644f, -0.05336215f, -0.08407785f, -0.00783763f, -0.18443312f, -0.38290629f, -0.16771489f, 0.07536208f, 
    0.10299793f, 0.44831461f, 0.02354164f, 0.05808076f, 0.14357363f, -0.18267217f, -0.15718797f, 0.19766992f, 
    0.16726804f, -0.12502369f, -0.31033060f, -0.10653210f, -0.01557119f, -0.08136920f, 0.05306301f, 0.17520055f, 
    0.18113959f, 0.05858064f, -0.34362775f, 0.24311312f, 0.23558891f, -0.04533828f, -0.04705595f, 0.06391890f, 
    0.09622081f, 0.11319798f, 0.16228795f, 0.17693613f, -0.15080203f, -0.15586251f, -0.05532212f, -0.05590193f, 
    -0.06535963f, -0.02928405f, 0.08008509f, -0.18462658f, -0.01496035f, -0.09333248f, 0.14855343f, -0.03055787f, 
    -0.28192607f, -0.00031334f, -0.20335135f, 0.01487906f, 0.17191873f, 0.01869967f, -0.02717432f, 0.23840697f, 
    -0.18746838f, -0.02089788f, -0.13371536f, 0.22499821f, 0.07919267f, -0.01962469f, 0.25520813f, 0.14231430f, 
    0.09045991f, 0.32207850f, 0.19455229f, -0.09924039f, 0.16022442f, -0.11745542f, 0.05722700f, 0.63453978f, 
    0.15658318f, 0.10958371f, -0.15482813f, -0.20536721f, -0.05938576f, 0.13822199f, 0.13726862f, -0.26270983f, 
    -0.11804394f, 0.17894270f, 0.11723159f, -0.01836945f, 0.06259049f, -0.34479117f, -0.06955443f, -0.40425345f, 
    -0.22002323f, -0.12839253f, -0.13473560f, 0.04030049f, 0.08129197f, 0.05726727f, -0.19341026f, 0.12420256f, 
    -0.01749340f, -0.14553501f, 0.00017101f, -0.41953510f, 0.19496340f, 0.06184102f, -0.12291224f, 0.06298067f, 
    0.09739516f, 0.01751233f, 0.33027399f, 0.43225744f, 0.43204290f, -0.01246253f, 0.11738561f, 0.06472251f, 
    0.01090052f, -0.22266063f, -0.02700446f, -0.00737351f, -0.59895456f, -0.37971455f, -0.00813486f, -0.13268836f, 
    0.15079427f, 0.15569559f, 0.03302346f, 0.16144705f, 0.42519787f, 0.29297993f, 0.27540568f, 0.14759265f, 
    -0.11973754f, 0.11842310f, -0.07853280f, -0.11972229f, -0.13062105f, 0.10832155f, -0.11534631f, -0.89083505f, 
    -0.16768648f, -0.06225877f, -0.09247477f, 0.04096145f, 0.04931936f, 0.04486447f, 0.18404143f, 0.13390954f, 
    -0.09724017f, 0.06306516f, 0.09894064f, -0.07540648f, -0.06898770f, -0.07349861f, 0.02351698f, 0.10062792f, 
    0.06409694f, -0.63228697f, -0.00236059f, -0.05336323f, -0.25034302f, -0.04864845f, 0.05591848f, -0.07521666f, 
    0.11882798f, -0.01617929f, 0.17043470f, -0.11273534f, -0.34033075f, 0.17176111f, -0.01277272f, -0.05429714f, 
    -0.19214766f, 0.19892001f, 0.00823969f, 0.19351436f, 0.05039537f, 0.11576617f, -0.01667592f, 0.10189328f, 
    -0.00371095f, -0.09963023f, 0.21086034f, 0.14396186f, 0.45756280f, 0.08594332f, -0.11329638f, -0.21209079f, 
    -0.01642476f, 0.01150435f, 0.04003914f, 0.00340301f, -0.05652407f, 0.19413736f, -0.12592958f, -0.02573157f, 
    0.06007308f, 0.06028055f, -0.09464127f, 0.17353681f, -0.35062638f, -0.01026798f, 0.23014158f, -0.04995145f, 
    0.12090977f, -0.05500760f, 0.31530166f, 0.05996815f, 0.07934895f, 0.04808837f, 0.06778015f, 0.10003924f, 
    0.10634610f, 0.21715188f, 0.10348820f, 0.17872086f, 0.08135656f, -0.14096376f, -0.03102861f, 0.29213437f, 
    -0.02333959f, -0.35298765f, -0.21700859f, 0.19307142f, -0.06548490f, 0.07263280f, -0.04454382f, 0.07543159f, 
    -0.18948172f, -0.48004189f, 0.17157932f, -0.02779473f, 0.03739762f, 0.13351651f, 0.09571879f, 0.28437719f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.08383935f, 0.05585214f, 0.42910790f, 0.14820267f, 0.19716384f, 0.18513270f, 0.03374743f, 0.05631943f, 
    0.53929329f, -0.18954730f, 0.01479674f, 0.36957508f, 0.10506633f, -0.15105435f, 0.09892340f, 0.16105698f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09451619f, 0.21160275f, -0.13254900f, 0.14933214f, -0.16539878f, -0.11739590f, 0.14809090f, -0.07882086f, 
    -0.16991061f, -0.17460458f, -0.21555123f, -0.20261019f, 0.10583079f, -0.00971272f, -0.09625079f, -0.22379336f, 
    0.01653661f, 0.04330118f, 0.24511100f, -0.27072614f, 0.29916015f, -0.49357709f, -0.83591527f, 0.33081597f, 
    0.40464574f, 0.25730917f, -0.06614673f, 0.01472178f, 0.45304999f, -0.00174073f, -0.48320851f, -0.25700253f, 
    0.21989220f, -0.24761726f, 0.43486568f, 0.05634028f, -0.71856827f, -0.41418681f, 0.56227267f, -0.19703838f, 
    0.28542438f, 0.17774016f, 0.25944456f, 0.21400791f, -0.10767372f, 0.22378401f, 0.09134195f, 0.56539685f, 
    -0.02003488f, 0.10973741f, -0.13687132f, -0.10929868f, -0.39626339f, 0.11466325f, 0.18773137f, -0.22241062f, 
    -0.44982272f, 0.31557271f, 0.32467106f, -0.46885598f, 0.13673025f, 0.49379629f, -0.12198872f, 0.48577002f, 
    -0.15433758f, -0.19815899f, 0.46454480f, 0.26389843f, 0.59620011f, 0.30880868f, -0.25118601f, 0.09910288f, 
    0.42765537f, -0.48207682f, 0.12114596f, 0.50704628f, -0.06822542f, 0.33160362f, -0.27680635f, 0.05642517f, 
    -0.21147597f, 0.19701052f, -0.00454582f, -0.19374502f, -0.23438716f, -0.06563023f, -0.24093199f, -0.22678128f, 
    -0.14978024f, -0.00703317f, 0.04258272f, 0.15971433f, 0.01364182f, 0.15196860f, -0.26080745f, -0.17645271f, 
    -0.04883702f, 0.01023567f, 0.10586157f, -1.02898657f, -0.16850668f, 0.11058132f, 0.14266397f, 0.00225132f, 
    -0.09704401f, 0.19486396f, 0.40829539f, -0.42338708f, -0.28080359f, 0.73504859f, -0.19142789f, 0.13517444f, 
    0.09900954f, 0.07448559f, 0.71571213f, 0.21668036f, 0.02088095f, 0.32687747f, -0.05102037f, -0.06120687f, 
    -0.37544999f, -0.09355211f, 0.54406583f, -0.34135905f, -0.20461310f, 0.57001489f, 0.26107234f, 0.13038017f, 
    0.05315538f, -0.04116756f, 0.12411279f, -0.15327534f, 0.13977554f, -0.18359415f, -0.49431351f, 0.34895501f, 
    -0.34772861f, 0.22253497f, 0.08040454f, 0.05889072f, 0.24127552f, -0.14747301f, 0.12222633f, -0.39692405f, 
    -0.11237574f, 0.13205421f, -0.51262116f, -0.17765038f, -0.37864104f, 0.29645523f, 0.20047399f, 0.17480443f, 
    0.64015383f, 0.15796144f, -0.17138475f, 0.13765061f, -0.04811362f, 0.06646793f, 0.15326329f, 0.21392918f, 
    0.18758067f, -0.02265674f, -0.18785018f, 0.30023843f, 0.30789471f, 0.22967759f, -0.16422641f, 0.46120542f, 
    0.01552951f, 0.42547092f, -0.21677306f, -0.29668635f, 0.08149312f, 0.43165404f, -0.33081707f, 0.31822079f, 
    0.05952487f, -0.11386772f, -0.53488976f, 0.27408794f, 0.04205204f, -0.01529975f, 0.12929174f, 0.66048121f, 
    -0.46253648f, 0.11570904f, 0.27946892f, 0.12511991f, 0.25444257f, -0.10795933f, -0.43341318f, 0.52948391f, 
    -0.00206283f, -0.17516169f, -0.10200594f, 0.26009771f, 0.54917401f, 0.38137847f, 0.14382373f, 0.49562675f, 
    0.02715891f, -0.27074027f, 0.16305771f, 0.30208212f, -0.09605493f, 0.21185298f, 0.16271923f, -0.14677447f, 
    -0.18649779f, -0.15388428f, 0.17783961f, 0.22961219f, -0.03143746f, -0.02378388f, 0.36355379f, 0.41946471f, 
    0.06073353f, -0.31278297f, 0.36718571f, -0.32994264f, -0.29666167f, 0.19353725f, 0.26077572f, -0.25846335f, 
    0.19598863f, -0.04661033f, 0.29697862f, -0.23103765f, 0.32077667f, -0.06286854f, -0.26682651f, 0.00164030f, 
    0.31462014f, 0.28230131f, -0.48986238f, 0.53718406f, -0.03782152f, 0.05461179f, -0.05723695f, -0.26868197f, 
    -0.01494886f, 0.19787501f, 0.57236642f, 0.02521265f, 0.54044843f, -0.40292037f, 0.12420311f, 0.05070871f, 
    -0.28113514f, 0.02174435f, -0.17242470f, -0.15097746f, 0.10378437f, 0.20846498f, 0.27962911f, -0.47981375f, 
    0.08753989f, -0.14966765f, -0.18087202f, 0.15536349f, 0.57915354f, 0.30349767f, 0.07891250f, 0.20273787f, 
    -0.21473363f, 0.01565593f, -0.26284444f, 0.10359310f, 0.07709999f, -0.58983451f, -0.13714008f, 0.20017081f, 
    -0.10880301f, -0.15522878f, -0.17425439f, 0.10590362f, 0.01667919f, -0.18464865f, 0.06829650f, -0.04706418f, 
    -0.11129468f, -0.24070840f, -0.08548756f, 0.14255920f, 0.05305172f, 0.15919791f, -0.07515968f, -0.21599990f, 
    -0.06438488f, 0.24325234f, -0.19498816f, -0.28699839f, 0.18114775f, -0.18030225f, 0.15320994f, -0.20458411f, 
    -0.03313287f, 0.25641048f, 0.20172532f, 0.21116519f, 0.14376256f, -0.06107255f, -0.14036298f, 0.33389762f, 
    0.16870426f, 0.21207538f, 0.20592722f, 0.16132642f, 0.48812515f, 0.13021265f, 0.08502018f, -0.47882000f, 
    0.38739619f, -0.02672025f, -0.08123986f, 0.01062696f, 0.28357768f, 0.03882216f, -0.29294908f, 0.26487291f, 
    -0.17686847f, 0.10326450f, 0.08838901f, 0.20171478f, 0.17604977f, 0.00920868f, 0.00364858f, -0.65217572f, 
    0.51649547f, -0.02006717f, -0.25432149f, 0.60448909f, 0.35238609f, -0.36642730f, 0.07083131f, -0.04921871f, 
    0.20001149f, -0.22543317f, 0.16378334f, -0.22581431f, -0.08656761f, -0.09864902f, -0.14062622f, 0.12854975f, 
    -0.15798521f, 0.01573589f, 0.00377902f, 0.16453066f, -0.21246597f, -0.00717893f, -0.18643111f, 0.02256787f, 
    0.18808013f, 0.13209946f, 0.10190481f, -0.21137255f, -0.23753926f, -0.38814932f, -0.32514101f, 0.20467617f, 
    0.67437220f, -0.34521687f, 0.03665992f, 0.18682472f, 0.17294699f, -0.18122150f, 0.53943950f, 0.02335212f, 
    -0.01248512f, -0.14688799f, 0.26826876f, 0.23330256f, -0.34533846f, -0.14435627f, 0.18747510f, 0.03648637f, 
    -0.47696701f, 0.03284468f, 0.30938542f, -0.21337013f, -0.01131274f, -0.48970169f, 0.45236832f, 0.46370360f, 
    -0.07729376f, -0.18150730f, 0.35834134f, 0.28328332f, -0.26345521f, 0.20545074f, 0.00818107f, -0.19387695f, 
    -0.46662396f, 0.26400384f, -0.02769545f, -0.24378823f, -0.00751171f, -0.31590119f, 0.19033518f, 0.46102151f, 
    0.18440427f, -0.12436366f, -0.43480945f, 0.06588114f, 0.21818633f, -0.39415759f, -0.25199857f, 0.14218967f, 
    -0.13175330f, -0.11579387f, 0.21959431f, 0.04545571f, 0.57820225f, -0.18498449f, -0.07837612f, 0.29681680f, 
    -0.03379245f, -0.17939313f, 0.06790812f, 0.32114580f, 0.15957820f, -0.14120886f, 0.07382566f, 0.18636559f, 
    -0.66716534f, -0.30392241f, 0.34561709f, -0.21354732f, 0.05865660f, 0.08974975f, 0.37861580f, 0.33270147f, 
    0.15509453f, 0.14691067f, 0.59771657f, 0.15141714f, -0.29704830f, 0.18357746f, 0.14553232f, -0.14797275f, 
    -0.01624595f, 0.04293980f, -0.00632098f, -0.33235624f, 0.11628304f, 0.57013333f, 0.08418287f, -0.13897578f, 
    -0.07643999f, -0.02972287f, 0.16949579f, 0.14553478f, -0.68241775f, -0.39238766f, -0.33836493f, 0.30706796f, 
    -0.25967550f, -0.01027423f, -0.27318451f, 0.03765516f, 0.43673909f, -0.49367982f, 0.16709529f, 0.11304097f, 
    -0.04508062f, 0.15972461f, 0.04184491f, -0.39353380f, -0.41255626f, -0.17144158f, -0.39404032f, 0.10327811f, 
    -0.09862062f, 0.16135141f, 0.05894292f, -0.04208099f, 0.25805455f, -0.05844526f, 0.38535300f, -0.02076606f, 
    0.12314837f, -0.13790338f, 0.45235541f, -0.18278323f, -0.14271992f, -0.37850976f, -0.25542480f, -0.52382702f, 
    0.47348168f, 0.36941776f, -0.38302580f, 0.05522825f, 0.32021621f, -0.33805445f, -0.03021889f, 0.24898115f, 
    -0.22547340f, 0.00815846f, -0.14902163f, 0.31978205f, -0.44096506f, 0.19915961f, 0.26627186f, 0.38379425f, 
    0.23215230f, -0.29827243f, -0.02306017f, 0.06612920f, -0.22096957f, -0.10744164f, 0.11619581f, 0.73156250f, 
    -0.02226163f, 0.20759109f, 0.31907657f, -0.20910551f, -0.08743884f, -0.22494359f, 0.18809552f, -0.31298465f, 
    0.60392451f, 0.17337349f, 0.02568505f, 0.22924680f, 0.08836964f, -0.26876175f, 0.21025556f, -0.30716768f, 
    -0.10378483f, 0.13421521f, -0.13691351f, -0.29481590f, 0.38259792f, 0.36227816f, -0.14545465f, 0.53457618f, 
    0.30381152f, 0.15356380f, -0.39579758f, -0.04808394f, 0.06971554f, -0.41817862f, -0.25242516f, 0.22554035f, 
    0.14957742f, -0.11882171f, 0.44200325f, 0.07141231f, -0.01401661f, 0.36647373f, -0.11876072f, 0.16925305f, 
    -0.12214033f, 0.00121531f, -0.20651689f, -0.20073943f, 0.14393812f, 0.67131853f, -0.50711757f, 0.49850357f, 
    -0.21223070f, -0.21400888f, 0.33465359f, 0.08852087f, -0.81732064f, -0.73648530f, -0.00277663f, -0.05557312f, 
    0.04544276f, 0.39711571f, -0.15096153f, -0.43239355f, 0.29593432f, 0.38993710f, 0.06578907f, 0.17742606f, 
    -0.00634589f, -0.01445193f, 0.09924296f, 0.36998147f, -0.28898832f, 0.09798858f, -0.55103660f, -0.59043121f, 
    0.52572584f, 0.12526603f, -0.02419594f, -0.58508074f, 0.42381358f, -0.05826837f, -0.27869150f, 0.53288823f, 
    0.02350655f, -0.22045222f, -0.23746227f, -0.13516217f, -0.49458128f, 0.49849838f, 0.26910341f, 0.53363562f, 
    -0.05151104f, -0.10333303f, 0.48902187f, -0.16192783f, 0.05354215f, 0.39531699f, 0.25483796f, 0.20281781f, 
    -0.12327866f, -0.02854017f, 0.19079964f, 0.15473460f, -1.07305801f, -0.26345557f, 0.45365691f, 0.00070919f, 
    -0.19471504f, 0.28240481f, 0.34838519f, -0.22630939f, -0.29012609f, 0.34291357f, -0.06609528f, 0.47158027f, 
    0.09313948f, 0.13183701f, -0.04387387f, 0.30995905f, -0.23249918f, -0.27056974f, 0.00182945f, -0.27136698f, 
    -0.02075182f, -0.19992155f, 0.33970186f, -0.37766340f, -0.06624027f, 0.20784509f, 0.29976505f, -0.34198272f, 
    0.05001941f, 0.02280494f, 0.66229856f, -0.00932254f, 0.42227969f, -0.07100931f, 0.33870018f, -0.22140653f, 
    -0.55661756f, 0.16596046f, -0.49747318f, 0.02960298f, 0.07076780f, -0.10089804f, 0.17898771f, -0.00401812f, 
    0.00148827f, -0.11270627f, 0.05041625f, -0.11926379f, 0.38485157f, 0.26947626f, -0.27238119f, 0.76748657f, 
    0.08027627f, -0.21110237f, 0.18087317f, -0.12310251f, 0.06629626f, 0.55278450f, -0.05091490f, -0.22955437f, 
    -0.23912425f, 0.15091567f, -0.41005871f, 0.15642619f, -0.09947928f, 0.08369032f, -0.58133334f, 0.34586155f, 
    -0.05376406f, 0.24984901f, 0.20596002f, -0.51545054f, 0.27505130f, 0.10989561f, -0.01553819f, 0.04146604f, 
    -0.20700498f, 0.21275201f, 0.18471992f, -0.06958928f, 0.03025677f, 0.34495327f, 0.71184403f, -0.13094983f, 
    -0.10018568f, 0.05103065f, -0.06660656f, -0.16883963f, -0.20768642f, 0.05746308f, 0.22908917f, 0.32733351f, 
    0.14343029f, -0.00750589f, 0.11226179f, -0.01535644f, 0.59009492f, -0.18705426f, 0.33025086f, 0.07091475f, 
    -0.27830952f, 0.07433265f, 0.02921544f, 0.45349008f, 0.06647684f, -0.14011495f, 0.07529469f, -0.54876083f, 
    -0.08293067f, -0.23348317f, -0.17657827f, 0.24075592f, -0.59017652f, 0.12443467f, 0.40417644f, 0.08376910f, 
    -0.04919710f, -0.15115181f, 0.14556710f, -0.19157645f, 0.16432701f, -0.57148826f, 0.26738000f, 0.48896641f, 
    -0.10461077f, -0.04091048f, 0.18607615f, 0.24547151f, 0.43761730f, -0.04892991f, 0.07178228f, 0.20316681f, 
    -0.04891956f, -0.04241347f, -0.26332080f, 0.58678997f, 0.12514004f, -0.86938143f, 0.06336860f, -0.11312660f, 
    0.09783635f, 0.10447316f, 0.17292926f, 0.06932399f, 0.15666628f, -0.18841726f, 0.24746116f, -0.13772845f, 
    -0.17229980f, -0.15563715f, -0.04894165f, -0.24087597f, -0.11051318f, -0.02463062f, -0.14678140f, -0.23648237f, 
    0.24133444f, 0.09544969f, -0.23836742f, -0.45564869f, -0.38728896f, 0.26496291f, -0.25061864f, 0.74601376f, 
    0.20028247f, 0.20126839f, -0.35706934f, -0.02170484f, -0.03418224f, -0.56714696f, 0.20645083f, 0.10753141f, 
    0.12759408f, -0.06292692f, 0.04980254f, -0.12745202f, 0.04101247f, -0.00380487f, 0.46436003f, 0.05017749f, 
    0.09458656f, 0.21005526f, 0.19413392f, -0.26754820f, -0.25996822f, 0.42642790f, 0.24360311f, -0.28278974f, 
    -0.02076815f, 0.22924338f, 0.40515530f, -0.21661894f, 0.31047574f, -0.21707258f, -0.06416305f, 0.36415049f, 
    0.39210290f, -0.00324169f, 0.13985403f, 0.88659042f, -0.20037085f, 0.19269662f, 0.34647983f, -0.49357069f, 
    0.04840900f, 0.00834107f, 0.47522548f, 0.02942801f, -0.16603571f, 0.29884538f, 0.13154727f, 0.05762001f, 
    -0.34379217f, -0.20658031f, 0.16326213f, 0.57922292f, -0.20517561f, -0.36315337f, 0.16984876f, 0.18415952f, 
    0.18068461f, 0.08610225f, 0.50985962f, -0.14123861f, -0.21409416f, -0.16490862f, -0.89227903f, 0.10904571f, 
    -0.08984660f, -0.12167600f, 0.01123988f, 0.02426420f, 0.37084237f, -0.18418576f, 0.08919054f, -0.11833468f, 
    -0.06836137f, 0.07367069f, 0.39977527f, 0.19712114f, -0.32962295f, 0.39017826f, -0.26913354f, 0.47287804f, 
    0.18341337f, -0.03744703f, 0.20804913f, -0.16492820f, 0.02158903f, 0.29566807f, -0.16220634f, -0.40934017f, 
    0.12157115f, -0.17891458f, -0.54752564f, 0.37866160f, -0.17269705f, 0.26413500f, -0.11163836f, -0.06606938f, 
    -0.14061829f, 0.33912396f, -0.24071679f, -0.62719655f, 0.22118860f, -0.47789091f, 0.03308107f, -0.28590122f, 
    -0.02817524f, 0.09342006f, 0.68277270f, 0.24834873f, 0.80288917f, -0.04344341f, -0.71933949f, -0.05979820f, 
    -0.10137936f, -0.56447518f, 0.36483404f, 0.39205179f, -0.05888946f, -0.02916759f, 0.07642748f, 0.21750319f, 
    0.24085321f, -0.00552253f, 0.18561375f, 0.12407348f, -0.05753310f, -0.12383720f, -0.75174415f, 0.49334294f, 
    -0.69269490f, -0.21757813f, 0.24551983f, 0.34595719f, 0.24115306f, -0.40898263f, -0.09538226f, 0.19654889f, 
    0.23836288f, -0.02712882f, 0.08613084f, 0.03691554f, 0.07872064f, -0.18866114f, 0.04399122f, -0.16698892f, 
    -0.25002542f, -0.23463282f, -0.19088705f, 0.09175232f, 0.17457597f, -0.15151896f, -0.24965277f, -0.18991426f, 
    0.10233876f, -0.01319894f, -0.01397114f, -0.09165300f, -0.11703804f, 0.08422914f, 0.05327891f, -0.23852697f, 
    -0.25596216f, -0.10123854f, -0.22877774f, -0.04411137f, 0.14669812f, 0.15139808f, -0.08615133f, -0.08356302f, 
    -0.02298182f, -0.24245864f, 0.09492417f, 0.26468942f, -0.32088703f, -0.28479001f, 0.14711320f, 0.11527689f, 
    -0.00557380f, 0.00071291f, -0.07864939f, 0.27052170f, -0.14416638f, -0.45116293f, -0.13859826f, 0.38006228f, 
    0.03052714f, -0.05765444f, 0.37773505f, -0.00573871f, -0.50372529f, 0.14953129f, 0.35299414f, 0.31285658f, 
    -0.33040136f, -0.05836037f, 0.00888236f, 0.40456313f, -0.19869289f, 0.10478780f, 0.40199789f, -0.23904432f, 
    -0.01243681f, 0.21642800f, -0.08529028f, -0.01234328f, 0.02825045f, 0.00350179f, 0.19120285f, -0.12780771f, 
    0.09353038f, -0.01252275f, -0.11761963f, -0.26224789f, -0.16349888f, 0.10166220f, -0.19534662f, -0.10557897f, 
    0.19406468f, -0.15916060f, 0.18168338f, 0.24824861f, 0.43739274f, -0.21834904f, 0.08818208f, -0.61705267f, 
    0.86730236f, -0.17602217f, 0.12758701f, 0.28154066f, 0.02456584f, 0.33602223f, -0.19082083f, 0.34306377f, 
    0.13026652f, -0.07074609f, 0.29479921f, -0.04167102f, -0.19957490f, 0.32120633f, -0.44045967f, 0.53444993f, 
    -0.36112154f, 0.14097978f, 0.31290382f, -0.51629061f, 0.35233888f, 0.39389780f, -0.43778411f, 0.35288137f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00427635f, 0.37017754f, 0.20195810f, 0.00896838f, 0.11373340f, -0.00088482f, -0.47194088f, 0.09323300f, 
    0.26048753f, 0.21670493f, -0.02022241f, -0.31763563f, -0.21080771f, 0.14764938f, -0.12585768f, -0.02380241f, 
    -0.33385199f, -0.09321640f, -0.54339778f, -0.06386653f, 0.24199052f, -0.21230161f, 0.62974292f, 0.02859396f, 
    -0.03090496f, -0.04799136f, 0.07880642f, 0.05491992f, 0.14228256f, -0.07102086f, 0.33803919f, 0.06918103f, 
    0.62231570f, -0.18592107f, -0.18764804f, 0.40810546f, 0.36717829f, 0.22447111f, 0.09352435f, -0.04095716f, 
    0.11756402f, -0.06656171f, 0.16179602f, 0.37457609f, -0.23449960f, 0.42030370f, -0.05069886f, 0.12974803f, 
    0.37480208f, -0.45775068f, 0.27323937f, 0.34991601f, 0.39876580f, 0.23281920f, -0.06919217f, 0.20194037f, 
    0.09283578f, -0.10702196f, -0.21846727f, 0.26671636f, 0.27221256f, 0.19450395f, 0.07956329f, 0.10141859f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00582226f, -0.03915308f, 0.20576359f, 0.21431415f, -0.03036826f, 0.09168371f, 1.06732750f, 0.14329602f, 
    -0.25941369f, 0.06136560f, 0.15441617f, -0.02696417f, -0.15100683f, 0.06815534f, 0.04132332f, -0.05998622f, 
    0.18110484f, 0.06731068f, 0.19694933f, -0.19381934f, -0.34723270f, 0.07217880f, -0.32598057f, -0.12580554f, 
    -0.01990451f, -0.43406191f, -0.00994701f, 0.16709352f, -0.51167393f, 0.02831837f, -0.23260607f, -0.29691198f, 
    -0.04771683f, -0.38282612f, 0.14980200f, 0.19860004f, -0.28529117f, 0.10890522f, 0.28464645f, 0.10890921f, 
    -0.17036955f, 0.08326579f, -0.03174099f, 0.15323974f, -0.00736842f, -0.16765513f, 0.01483949f, 0.09967567f, 
    -0.64767331f, 0.52939749f, -0.02614626f, -0.48573178f, -0.64847308f, -0.12749617f, -0.11824901f, -1.02467573f, 
    -0.78762424f, 0.04102084f, -0.06451225f, -0.20697622f, 0.01404350f, 0.05080703f, 0.13993967f, 0.19532101f, 
    -0.09174708f, -0.43392107f, 0.09042848f, -0.10677791f, 0.49999437f, 0.11456620f, -1.65416706f, 0.23316625f, 
    -0.22351967f, 0.11523325f, -0.03733809f, -0.35119799f, 0.05314579f, 0.26892233f, -0.12294625f, 0.16102785f, 
    0.18070665f, 0.02527396f, -0.24759232f, -0.02247400f, -0.05519368f, 0.01151636f, -0.07338520f, -0.14355090f, 
    -0.08216640f, -1.03677738f, -0.13586478f, 0.17892186f, -0.46168295f, -0.26649356f, -0.18390016f, 0.22016296f, 
    0.01622680f, 0.18213999f, 0.24921155f, 0.19934683f, -0.05631779f, 0.14160547f, 0.21239392f, 0.29522327f, 
    0.17144524f, 0.19128595f, -0.18924116f, 0.25366321f, -0.26181442f, 0.00449556f, -0.23391953f, -0.00013383f, 
    0.08120819f, -0.08745239f, -0.01577046f, 0.22791047f, -0.10049768f, 0.25911531f, 0.03296228f, 0.35888955f, 
    -0.64490598f, -0.13847347f, -0.09727127f, -0.19505550f, 0.16686907f, -0.02573939f, 0.26387385f, -0.14233342f, 
    -0.05978760f, 0.25475013f, 0.17875767f, -0.37450847f, 0.13855946f, 0.10478348f, -1.45079672f, -0.23645474f, 
    0.11463084f, -0.54384595f, 0.00966294f, -0.35473338f, -0.33111975f, -0.67416859f, 0.21326539f, 0.17169429f, 
    -0.32534376f, 0.00257718f, -0.09557065f, -0.04963697f, 0.19249295f, 0.01429075f, -0.09922814f, -0.14586267f, 
    0.06443734f, -0.34830326f, -0.42671978f, 0.12560324f, 0.28038850f, -0.03660550f, 0.54710847f, -0.94054818f, 
    0.18238747f, -0.49828768f, 0.18027870f, 0.14320445f, -0.03764486f, -0.88707256f, -0.37101418f, -0.20115574f, 
    0.61822003f, -0.54279160f, -0.28196004f, -0.15330860f, 0.01243197f, -0.28297922f, 0.16046214f, -0.11815988f, 
    -0.40361726f, 0.32985765f, 0.07053301f, 0.20832232f, 0.42229888f, -0.07405339f, 0.26969126f, 0.29288316f, 
    0.44971919f, -0.03406934f, -0.02041549f, 0.28768557f, 0.13825418f, -0.02286501f, -0.08740080f, -0.16222708f, 
    -0.06866155f, 0.56450558f, -0.14171967f, 0.11816958f, -0.70839596f, 0.07066607f, 0.07629449f, 0.17677701f, 
    0.47014126f, -0.86048955f, 0.08359776f, -0.05853504f, -0.56655771f, -0.15977074f, -0.48610592f, 0.17676900f, 
    -0.20616806f, -0.00395290f, -0.03764963f, -0.09331190f, -0.44658002f, 0.05620837f, -0.06348524f, 0.08507665f, 
    0.06622197f, 0.06990484f, 0.09394825f, 0.11983018f, 0.18115743f, 0.35617515f, 0.26471645f, -0.55743062f, 
    -0.12308989f, -0.71676129f, 0.11132608f, 0.19834845f, 0.38633424f, -0.05802685f, 0.01942597f, 0.41108826f, 
    -0.07074064f, 0.02626402f, 0.34477612f, -0.21352641f, 0.03853131f, -0.04888907f, -0.44896910f, -0.12143978f, 
    -0.95646435f, -0.23709936f, -0.39722547f, -0.43636170f, 0.36967087f, 0.17152843f, -0.57211798f, -0.02622619f, 
    0.19620641f, 0.08203588f, -0.06653948f, -0.52660722f, -0.40593755f, -0.11300588f, -0.33788955f, 0.34852016f, 
    -0.12379076f, -0.69674706f, 0.15747085f, 0.14533758f, -0.73618841f, 0.00766713f, -1.20041490f, -0.13119599f, 
    -0.17894360f, 0.21658958f, 0.22587441f, 0.35947624f, -0.10010120f, 0.05144175f, -0.10030717f, -0.09556201f, 
    -0.20935079f, 0.04347914f, 0.05449266f, 0.03171527f, -0.24294972f, 0.04094529f, -0.52378142f, 0.13178392f, 
    0.08630908f, 0.14191410f, 0.12662454f, -0.08512840f, 0.21760005f, -0.16147839f, -0.00960570f, 0.34953845f, 
    -0.16510621f, -0.00084363f, 0.15548810f, 0.19913156f, 0.22094159f, -0.04183600f, 0.20571719f, -0.09139125f, 
    0.27204192f, -0.46825987f, 0.15672307f, 0.17722857f, -0.26638922f, 0.34638187f, -0.42698377f, 0.05508790f, 
    0.27622160f, -0.35591364f, -0.63696104f, -0.22283636f, -0.61420971f, -0.38093567f, -0.18166021f, -0.84049922f, 
    -0.40196353f, -0.05881265f, -0.03762673f, 0.43193227f, -0.24583028f, 0.04903275f, 0.06289629f, 0.10729795f, 
    -0.10125996f, -0.86413914f, 0.18371727f, 0.01368790f, -0.02322703f, 0.09259205f, 0.04859207f, 0.08790470f, 
    -0.21289322f, 0.11447828f, -0.33780622f, -0.04022226f, -0.13114370f, 0.00175601f, -0.27178997f, -0.40728879f, 
    0.01626206f, -0.00802819f, 0.11316897f, -0.12448309f, 0.09312380f, -0.07136706f, 0.22959884f, 0.18830435f, 
    0.01784187f, -0.05144146f, 0.08620555f, -0.09177995f, 0.01385219f, 0.04837570f, -0.09950829f, 0.38004783f, 
    0.02406362f, 0.17673717f, -0.15557368f, -0.21044505f, 0.02849274f, 0.15444426f, 0.14784709f, -0.88995981f, 
    -0.41763729f, -0.40013719f, -0.12426851f, 0.10601268f, -0.13954546f, 0.27304381f, 0.03540778f, -0.04131396f, 
    0.37462360f, -0.42915836f, -0.08472066f, 0.32559204f, -0.00283224f, -0.24327193f, 0.33965611f, 0.21979204f, 
    0.21653368f, -0.02585268f, -0.06795357f, 0.22832274f, 0.07351270f, 0.01386246f, 0.26812994f, -0.29943666f, 
    0.04486585f, 0.29483896f, -0.43337214f, -0.00956854f, 0.12100603f, -0.00015657f, -0.11161150f, -0.58974349f, 
    0.01107082f, 0.01127040f, 0.14622688f, -0.12299833f, 0.03930161f, -0.20724763f, 0.36797255f, 0.23906299f, 
    0.23539606f, 0.06806058f, 0.15486692f, 0.33579096f, 0.33344185f, 0.11601251f, 0.15996334f, -0.48258236f, 
    -0.38286275f, 0.30031505f, -0.52797079f, -0.51081693f, -0.37573871f, -0.11386496f, 0.20491920f, -0.36094689f, 
    0.13101770f, 0.10994888f, -0.54925489f, -1.58598161f, 0.08470965f, -0.66322595f, -0.09741629f, -0.07044088f, 
    0.14023118f, -0.11285512f, -0.07573882f, -0.16145761f, 0.25690314f, -0.37018350f, 0.20291854f, -0.10961323f, 
    -0.39133185f, 0.09349371f, 0.18982118f, -0.41384023f, -0.10018998f, -0.30953515f, -0.05463898f, 0.11867730f, 
    -0.28016543f, 0.06882180f, 0.09750918f, -0.16277903f, -0.24456909f, 0.06970789f, 0.55655044f, -1.13514578f, 
    0.10709675f, -0.10019099f, -1.38119304f, -0.17224342f, -0.01097838f, 0.06550549f, -1.27028167f, 0.19516812f, 
    -0.07675187f, -0.29018617f, 0.26399103f, 0.43553028f, 0.09586195f, -0.06547362f, -0.47628337f, -0.14717874f, 
    0.15106227f, -0.04508894f, 0.00380112f, -0.00058690f, -0.00926834f, 0.07465711f, -1.41271281f, 0.00867576f, 
    0.10694583f, 0.35130307f, 0.37288710f, 0.00443299f, -0.03867919f, -0.10954128f, -0.58255577f, 0.09291294f, 
    -0.56426650f, -0.05929069f, 0.50033075f, -0.74355888f, 0.11930954f, 0.16662461f, -0.77956212f, -0.10386959f, 
    0.06329273f, 0.10131782f, 0.18443531f, -0.17822579f, -0.15618452f, 0.05366639f, 0.05934786f, -0.06043601f, 
    -0.40499800f, -0.08927903f, -0.37479827f, -0.04462063f, -0.06637087f, 0.19258444f, -0.16277716f, 0.24195144f, 
    0.68523133f, -0.02924804f, 0.00101806f, -0.31739092f, -0.11230721f, 0.09980664f, -1.27267349f, 0.43105415f, 
    0.06300899f, -0.10295700f, -0.23307543f, -0.21049190f, 0.36391187f, 0.07876687f, -0.67417383f, 0.23035371f, 
    0.07618696f, -0.40946463f, -0.13714309f, -0.04445913f, 0.24916351f, 0.27710235f, -0.19327143f, 0.32998377f, 
    -0.03196094f, -0.04972575f, -0.13370566f, -0.06965530f, 0.08851004f, -0.06735082f, -0.09518026f, 0.12448198f, 
    -0.18035032f, -0.02379644f, 0.37045205f, -0.06233613f, -0.10162760f, -0.25655329f, -1.01014483f, -0.22807619f, 
    0.02542705f, -0.45132899f, -0.27522296f, -1.01175964f, -0.48509842f, -0.16225684f, -0.99547923f, -0.13115703f, 
    0.02453014f, 0.19988391f, -0.01710551f, 0.03579240f, 0.26091003f, -0.13285401f, 0.30080977f, -0.02080606f, 
    -0.33624044f, -0.00513728f, 0.24036625f, 0.17534843f, 0.13457426f, 0.02997367f, 0.14117284f, 0.44348800f, 
    0.37883615f, 0.03051986f, 0.05761215f, 0.04603836f, -0.03504395f, 0.04911042f, 0.24939682f, 0.05086123f, 
    0.04294153f, 0.35378832f, 0.22532319f, -0.73331499f, -0.14346771f, 0.07320349f, -1.00218081f, -0.67902774f, 
    -0.04154130f, 0.44905293f, 0.05570449f, -0.16323897f, -0.18084185f, -0.26351905f, -0.20917508f, -0.99745518f, 
    -0.39921123f, -0.02957523f, -0.10039643f, 0.10591018f, 0.29304814f, -0.00599875f, 0.32065162f, -0.44431511f, 
    -0.31434122f, 0.19770649f, -0.89710939f, 0.07103768f, 0.12453727f, 0.15093283f, 0.26208857f, 0.00327055f, 
    0.33493307f, -0.20717275f, -0.24712256f, -0.13965128f, 0.58186078f, 0.00354799f, -0.63720107f, -0.01490466f, 
    -0.99354964f, -0.01457399f, 0.27427712f, -0.28272510f, -0.48720664f, 0.16501692f, -0.11375332f, -0.06374481f, 
    0.00404737f, -0.42119938f, 0.01568324f, -0.75475836f, 0.22991192f, 0.25675747f, 0.30475557f, -0.50240272f, 
    -0.46036357f, -0.03633371f, -0.04758475f, 0.10898764f, -0.41066670f, 0.06500708f, 0.42644775f, -0.18615726f, 
    0.10595325f, -0.57394630f, 0.06919019f, -0.32466507f, -0.87920225f, -0.01658894f, -0.00840015f, 0.06678920f, 
    0.23348534f, -0.19319075f, -0.77026165f, -0.34445873f, -0.00448294f, 0.17657886f, -0.02104532f, 0.37071761f, 
    -0.39809918f, -0.02828057f, -0.19017367f, -0.75145191f, 0.02694607f, -0.11441703f, 0.31604847f, 0.36610103f, 
    0.13872549f, -0.29014447f, 0.33690357f, 0.14732975f, 0.24032338f, 0.54975337f, -0.19954579f, -0.21446443f, 
    0.22336960f, -0.52087164f, -1.02722836f, 0.14435600f, -1.16307890f, 0.28152636f, -0.01552736f, 0.06176715f, 
    0.67182082f, -0.18304874f, -0.16262560f, 0.25094247f, 0.32593662f, 0.29093376f, 0.10596116f, 0.06951290f, 
    -0.28388402f, 0.45525271f, 0.14860757f, 0.16884334f, 0.02644049f, -0.12336193f, -1.01910508f, -0.17784153f, 
    -0.35710940f, -0.00259692f, 0.04644686f, -0.14657800f, 0.51320261f, 0.07018348f, -0.55494827f, -0.92564350f, 
    0.09116147f, 0.23753476f, -0.25930923f, -0.37984338f, -0.03584066f, 0.10523482f, -0.49531829f, -0.60502738f, 
    0.29473057f, 0.07844497f, 0.09714410f, 0.33552906f, 0.09450086f, 0.01576643f, 0.21046004f, -0.31947732f, 
    0.04301905f, -0.03506956f, -0.07443156f, -0.38106784f, -0.15240015f, 0.09562857f, 0.26932156f, -0.36541402f, 
    -0.50829268f, 0.14900905f, -0.33950490f, -0.50508827f, 0.23138401f, 0.20491767f, -0.45685408f, -0.00534270f, 
    -0.08961400f, 0.35604024f, -0.28309816f, 0.09479624f, -0.71571130f, 0.16643929f, 0.14625755f, -0.01157707f, 
    -0.73888683f, 0.34999847f, 0.06887484f, -0.40859371f, 0.06344829f, -0.16013786f, 0.16248782f, -0.00169713f, 
    0.53314084f, -0.17130904f, 0.34679386f, 0.08389864f, 0.18397999f, 0.22417347f, -0.87066573f, -0.23970819f, 
    0.51066417f, -0.04769486f, 0.00326185f, 0.14495291f, 0.10328263f, -0.01638901f, -0.77163255f, -0.06172851f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17923610f, 0.12339829f, 0.14580637f, 0.16542880f, 0.02007765f, -0.03420942f, -0.19845989f, -0.36607984f, 
    0.07299228f, 0.29498318f, -0.07226087f, -0.08073778f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
