#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.15147451f, -0.09643847f, -0.41006821f, -0.45649424f, -0.36176503f, -0.19589846f, -0.18098070f, -0.04066743f, 
    -0.22088864f, -0.41754159f, 0.07630152f, -0.05052651f, 0.19084695f, -0.07379231f, -0.03776928f, -0.22859694f, 
    -0.16277467f, 0.07737440f, -0.09251519f, -0.22045541f, 0.18599758f, 0.17868498f, 0.15932158f, 0.42258006f, 
    0.64004797f, 0.13932000f, 0.39688489f, 0.30418056f, 0.34149975f, 0.32859439f, -0.21737058f, -0.20267846f, 
    0.03601561f, 0.18233374f, 0.26780981f, 0.21377778f, 0.17214407f, -0.34647572f, -0.10617575f, -0.13134372f, 
    0.13292125f, 0.22508933f, -0.07225940f, -0.12810697f, 0.04080260f, -0.37874189f, -0.16546988f, -0.38237190f, 
    -0.31210843f, -0.28463045f, 0.56840664f, -0.69273454f, 0.15773158f, -0.18101077f, 0.05895374f, -0.23289862f, 
    0.08039637f, 0.11994847f, 0.30197543f, -0.08584332f, -0.34148595f, 0.34424841f, 0.07671249f, -0.49325845f, 
    0.23499459f, -0.33709943f, 0.49936277f, 0.24177530f, -0.02124088f, -0.50592601f, -0.02858648f, 0.26548207f, 
    -0.22220756f, 0.25233811f, -0.03800005f, 0.29472467f, 0.28094193f, 0.00433493f, -0.19585428f, 0.04507776f, 
    -0.01333695f, -0.01098431f, 0.14068061f, 0.20529726f, -0.21308930f, 0.06280161f, 0.11223460f, 0.07122016f, 
    0.24188414f, 0.06576411f, 0.20174678f, 0.19164993f, -0.05634019f, 0.15352641f, -0.12174466f, -0.21070054f, 
    0.05726217f, -0.28340960f, -0.05908391f, 0.38106570f, -0.68028462f, 0.06814694f, -0.42336673f, -0.56179273f, 
    0.18174344f, 0.75027001f, -0.51329374f, -0.77581733f, 0.22753808f, -0.01371101f, -0.15444683f, -0.16312832f, 
    -0.13546869f, -0.56021541f, -0.19665746f, 0.31684864f, 0.50017077f, 0.44954753f, 0.07100926f, 0.25949153f, 
    -0.10732593f, -0.20882502f, -0.16155732f, -0.39911315f, -0.23694386f, -1.00262034f, -0.22399783f, 0.65973806f, 
    -1.11577868f, -0.92005062f, 0.34076813f, 0.62966549f, -0.33330113f, 0.79437381f, -0.07371586f, -0.05206566f, 
    0.00649857f, 0.13371365f, -0.06374901f, -0.34988746f, 0.03971044f, 0.09989606f, -0.04103363f, -0.28101978f, 
    -0.08709148f, -0.01033288f, 0.03288354f, 0.02966816f, 0.05684521f, -0.04927628f, -1.02902055f, 0.50413889f, 
    -0.00751505f, -1.42325902f, -0.55571967f, 0.37018242f, 0.43759334f, 0.79711336f, -0.16266914f, 0.05179423f, 
    -0.09354660f, -0.01994193f, -0.22797461f, 0.09072313f, 0.23546836f, -0.02139913f, -0.01940379f, 0.00007218f, 
    0.00609569f, 0.08265775f, -0.00705648f, 0.04507350f, -0.17461692f, -0.16229333f, -0.32323688f, 0.06885929f, 
    0.09529150f, 0.34222373f, -0.38823214f, -0.25796410f, 0.68969101f, -0.23852363f, 0.12720327f, 0.46572953f, 
    0.34599021f, -0.18691969f, 0.22762969f, -0.28321397f, -0.23048878f, 0.13352518f, -0.12666668f, -0.28433540f, 
    0.26790106f, -0.13933814f, 0.17160757f, -0.13514781f, 0.12531774f, 0.37993783f, -0.37434730f, -0.46669969f, 
    -0.28582737f, -0.36982745f, -0.48721924f, -0.24078950f, -0.18505646f, -0.23711194f, -0.52203846f, -0.59921145f, 
    -0.60258043f, -0.84622586f, -0.22655444f, 0.00940490f, 0.16081996f, 0.26383328f, -0.36433402f, -0.13446014f, 
    -0.71135908f, -0.25511447f, 0.23541702f, -0.21792126f, 0.13764772f, -0.14358696f, -0.32422000f, 0.24827576f, 
    0.07828122f, -1.05000615f, -1.04920197f, -0.53208548f, 0.41762924f, 0.20793186f, 0.73167098f, -0.04551721f, 
    -0.01899350f, 0.05352301f, 0.59540653f, 0.58564293f, -0.04746668f, -0.19289029f, 0.26964423f, 0.14038691f, 
    -0.29582569f, -0.23246782f, 0.19799413f, 0.31364208f, -0.25734752f, -0.02594049f, 0.12114372f, 0.00826604f, 
    -0.10869486f, -0.15443283f, 0.96867275f, 0.00055251f, -0.71347100f, -0.51019746f, -0.70918107f, 0.22734670f, 
    0.35002005f, 0.18476534f, 0.11752909f, -0.02235251f, 0.28357598f, 0.60863996f, -0.37541282f, 0.01887887f, 
    0.06497657f, 0.02333157f, -0.06985638f, -0.35805297f, -0.16280836f, 0.07830523f, 0.07938853f, -0.06744295f, 
    0.22612225f, 0.20363811f, 0.34665611f, -0.54494464f, -0.67597538f, -0.80682796f, -0.37855068f, -0.37532771f, 
    0.32627597f, 0.18961827f, 0.19300893f, 0.32052910f, 0.58127457f, 0.08494230f, 0.01151007f, 0.29772297f, 
    0.15845229f, -0.07714209f, -0.17971885f, -0.02267999f, -0.10205097f, -0.23908271f, -0.26854268f, -0.22167110f, 
    -0.47126874f, 0.10010321f, -0.21073203f, -0.20106755f, 0.36731935f, 0.71281552f, 0.46847707f, 0.36745167f, 
    -0.88621938f, -0.00446134f, -0.50216413f, -0.51654887f, -0.55006933f, -0.38661376f, 0.21300802f, 0.01012631f, 
    0.20396931f, 0.41577795f, 0.20201364f, -0.04498404f, -0.10822070f, 0.20490555f, -0.20904854f, 0.13109116f, 
    0.13745798f, 0.05191183f, -0.05906123f, -0.19864990f, -0.28667790f, -0.14635642f, 0.37201414f, 0.28380623f, 
    0.40374127f, 0.56704253f, 0.22245015f, 0.23274280f, 0.34374419f, 0.41348705f, 0.31611007f, 0.23026143f, 
    -0.27360570f, 0.08957780f, 0.15560126f, -0.30260387f, 0.11576091f, 0.19226655f, -0.10866879f, -0.00952674f, 
    -0.07011541f, -0.18824555f, -0.38552299f, -0.15326159f, 0.28515029f, -0.04995231f, -0.32271141f, 0.27386963f, 
    -0.04064656f, -0.13863619f, 0.25456741f, -0.04810594f, -0.02182622f, -0.18513177f, 0.23473413f, 0.01285181f, 
    0.27069736f, 0.31019858f, 0.00019417f, -0.27499977f, 0.14407223f, -0.03402891f, -0.41649163f, 0.12311671f, 
    -0.04975056f, 0.03442498f, 0.05054419f, 0.33164290f, 0.03308861f, 0.27774447f, -0.01145784f, 0.52507097f, 
    0.05470228f, -0.87221396f, -0.62243915f, -0.81643325f, -0.06667142f, -0.11944682f, 0.17412633f, 0.29547986f, 
    0.13537447f, 0.06281117f, 0.39106914f, 0.09731250f, -0.39168873f, -0.50843686f, 0.00645788f, 0.13414420f, 
    0.28902468f, 0.21449664f, 0.05667090f, -0.09503883f, -0.09340240f, -0.13776785f, -0.48926604f, -0.35532844f, 
    0.04190403f, -0.34810519f, -0.47595748f, -0.68715733f, -0.43646318f, -0.55686039f, -0.38766214f, 0.13204046f, 
    -0.05519321f, -0.04086394f, 0.25913501f, 0.37946329f, -0.15112376f, -0.25372055f, -0.20975986f, -0.58980983f, 
    -0.35637906f, -0.42806920f, -0.40906447f, -0.21842678f, -0.12839533f, -0.13133456f, 0.05057874f, 0.43036687f, 
    0.46498588f, 0.14771067f, -0.02554191f, 0.12378433f, -0.19873874f, 0.26894906f, -0.48211038f, 0.05417214f, 
    0.46671587f, 0.12159228f, -0.01377241f, 0.28328067f, 0.06573791f, -0.01980608f, -0.44600150f, 0.12936245f, 
    -0.23044141f, -0.12701331f, -0.31433341f, -0.36686745f, -0.71075332f, 0.07272466f, 0.30948564f, -0.23244908f, 
    -0.40825841f, -0.13603358f, 0.47648761f, 1.28597879f, 0.34433180f, -1.17761302f, -0.49950567f, -0.25729707f, 
    0.08553774f, 0.23028414f, -0.79083371f, -0.74638355f, -0.26571476f, 0.45133573f, 0.12724873f, -0.11204912f, 
    0.22112153f, 0.12401288f, 0.23288074f, 0.39487085f, -0.10576920f, 0.01239507f, 0.02253986f, -0.16382742f, 
    -0.43867782f, 0.18994537f, 0.18306568f, -0.92747116f, -0.26476130f, 0.23829253f, -0.21972713f, -0.00072922f, 
    -0.44252801f, -0.37535107f, -0.11072273f, 0.66202480f, -0.21729985f, -0.22232167f, -0.40134236f, 0.23619527f, 
    -0.62813085f, 0.10746878f, -0.03079453f, -0.35385817f, -0.07755611f, 0.17824115f, 0.23743391f, -0.24264839f, 
    0.12985821f, -0.26875213f, -0.09545562f, 0.08854935f, -1.06458127f, -0.49057958f, -0.06767373f, -0.22918189f, 
    -0.08003458f, 0.48335373f, -0.14318684f, -0.76752830f, -0.66548407f, -0.58542830f, -0.21788810f, -0.12022849f, 
    -0.20581688f, -0.38901940f, -0.36862871f, -0.36728436f, -0.25748038f, -0.06341635f, -0.35888389f, -0.20205109f, 
    -0.00642533f, 0.13525066f, -0.28549868f, -0.08913221f, 0.13670883f, 0.11872680f, 0.18873230f, 0.54545999f, 
    -0.16102351f, -0.16739130f, -0.56793672f, -0.32729721f, 0.32013944f, -0.17150098f, 0.34849083f, -0.33540049f, 
    -0.18896283f, 0.60151881f, 0.05916940f, -0.14018397f, -0.25179860f, 0.01198335f, 0.00382630f, -0.10927231f, 
    0.41297394f, 0.19699727f, -0.14636582f, -0.20065609f, 0.29546329f, 0.03378846f, 0.14617845f, -0.11698542f, 
    0.20002767f, -0.23573467f, 0.65931159f, -0.00378323f, -0.02743649f, 0.23276952f, 0.29660413f, 0.30849990f, 
    0.20513202f, -0.37317061f, 0.23466273f, 0.14473945f, -0.01697387f, 0.02163198f, -0.19266920f, 0.02940797f, 
    -0.10505316f, -0.30508909f, -0.10538605f, 0.15898333f, 0.07345971f, 0.28996307f, 0.31690174f, 0.40403247f, 
    -0.36582312f, 0.14271057f, 0.55239761f, 0.81000686f, 0.03480683f, 0.03393253f, -0.62710333f, -0.56841928f, 
    -0.10149298f, 0.09184866f, -0.15901162f, 0.14193833f, -0.12550271f, -0.24257433f, -0.52021205f, 0.17891268f, 
    -0.03017560f, 0.17094181f, -0.26993978f, 0.01951975f, -0.01091393f, -0.24528311f, 0.19762082f, 0.39060277f, 
    0.72424740f, 0.42920557f, 0.22686416f, -0.15002862f, -0.03794057f, 0.12271114f, 0.28380650f, 0.39029902f, 
    -0.19744447f, -0.31631881f, -0.36984748f, -0.16073321f, -0.14454468f, 0.12614450f, -0.32488298f, 0.30811471f, 
    -0.18739361f, -0.11852027f, 0.15323308f, -0.11003368f, 0.07436164f, -0.27952164f, -0.44878694f, -0.54481655f, 
    -0.66435713f, 1.06311786f, 0.21582647f, -0.18265520f, -0.64919668f, -0.81974369f, 0.46764639f, 0.14575091f, 
    0.08442101f, -0.05920170f, -0.24926440f, -0.32605955f, -0.34296754f, 0.74931395f, -0.24969748f, -0.03032707f, 
    -0.13185947f, -0.03222309f, 0.22390081f, -0.11441489f, -0.63860786f, -0.41730112f, -0.03639513f, -0.03933129f, 
    -0.04980655f, 0.05879499f, -0.49840990f, -0.56198424f, -0.44055399f, 0.04503631f, 0.47317308f, -0.46558902f, 
    -0.60355204f, -0.41824394f, -0.38807428f, -0.18430236f, 0.04569664f, -0.10762488f, -0.11118278f, 0.77577972f, 
    -0.56641203f, 0.15106480f, -0.23846146f, -0.06122511f, -0.37588751f, -0.45642924f, -0.51858997f, 0.22452743f, 
    0.12488046f, -0.32205707f, -0.36225370f, -0.66212010f, 0.11491058f, 0.36507425f, 0.08485048f, 0.41466162f, 
    -0.60424536f, -0.06982071f, 0.63859260f, -0.22290877f, 0.15697579f, -0.35809246f, 0.04844179f, 0.72620690f, 
    -0.44263774f, -0.14948192f, -0.25595433f, -0.08490811f, -0.10034993f, 0.14688303f, 0.37271506f, 0.32180274f, 
    -0.14408381f, -0.06724069f, -0.06755982f, -0.12779765f, -0.77184272f, -0.21872056f, 0.80372238f, -0.01429667f, 
    -0.18671507f, 0.19874361f, 0.59169763f, -0.71411192f, -0.58451676f, 0.61846334f, 0.09633987f, 0.00743016f, 
    -0.12467542f, -0.24476250f, 0.07918242f, -0.04305981f, -0.07000612f, 0.07687272f, -0.06790309f, -0.18851599f, 
    0.00986083f, 0.28909892f, -0.14418963f, 0.27453610f, 0.17937839f, 0.86836880f, 0.58840030f, -0.09698743f, 
    -0.10043121f, 0.04289808f, 0.06198567f, 0.15971166f, -0.33282635f, 0.24159659f, -0.24014305f, -0.36076543f, 
    0.24644463f, -0.11419316f, -0.18132029f, -0.13182738f, -0.04153745f, -0.15676844f, 0.07260380f, 0.02801926f, 
    -0.13961455f, -0.17919523f, 0.02927143f, 0.32737422f, 0.10691714f, -0.07103809f, -1.07884097f, 0.46933246f, 
    -0.11838298f, 0.44383398f, 0.18358120f, -0.73973972f, -0.74872535f, 0.09751590f, 0.59293580f, 0.55276507f, 
    -0.14450714f, -0.60719192f, 0.04768552f, 0.35802740f, 0.27959901f, 0.12855344f, -0.09261919f, 0.12093280f, 
    0.05700051f, 0.03211350f, -0.35961333f, 0.03319911f, -0.16108465f, -0.25034815f, -0.44179171f, 0.82907587f, 
    0.64832938f, 0.01674471f, 0.39995715f, -0.24478540f, -0.55524331f, -0.29309648f, -0.02276603f, 0.23634140f, 
    0.19359134f, 0.38683447f, 0.24140966f, -0.08558093f, -0.37976936f, -0.38476506f, -0.01134606f, 0.15664160f, 
    -0.00047579f, 0.06112169f, -0.39821798f, -0.02406383f, 0.02611688f, -0.10486715f, 0.01661585f, 0.20406713f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16584057f, -0.03720311f, 0.29654026f, -0.01264447f, 0.00914392f, 0.17608488f, 0.25734532f, 0.23312449f, 
    -0.16700056f, 0.23495482f, 0.25829944f, 0.10713196f, 0.08327993f, -0.23613520f, 0.16214426f, 0.34567913f, 
    -0.25470549f, 0.25288931f, 0.17971811f, 0.30637446f, -0.10656413f, 0.34436283f, 0.09178896f, 0.22453053f, 
    0.25937906f, 0.23391841f, -0.08787506f, 0.25351429f, 0.19211948f, 0.24181171f, 0.08888405f, 0.48765975f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15318726f, -0.15375096f, -0.19594084f, -0.09895694f, 0.09553912f, -0.05213858f, -0.15812926f, -0.06079436f, 
    -0.03959021f, -0.02426280f, -0.22686231f, -0.10929409f, 0.16935357f, 0.02674469f, 0.07255043f, -0.11003375f, 
    -0.09331033f, -0.03930883f, 0.01907992f, 0.11004583f, -0.02488236f, 0.02578370f, 0.02416020f, 0.03533443f, 
    -0.00498364f, -0.07398129f, -0.03343591f, 0.06268576f, -0.05829736f, 0.08451474f, 0.19772020f, 0.08347837f, 
    -0.02564069f, 0.08008363f, 0.00992272f, -0.12770000f, 0.20637389f, -0.11643580f, -0.03892005f, -0.07680984f, 
    -0.15001437f, 0.01468087f, -0.14174618f, 0.03522521f, -0.00600067f, -0.04400684f, -0.10152628f, -0.13434714f, 
    -0.02561191f, 0.06229508f, 0.31236732f, 0.21380033f, -0.14921255f, 0.02825975f, 0.14411749f, 0.13918395f, 
    0.09524309f, -0.00062780f, 0.12243322f, -0.00611426f, -0.02550934f, -0.46035448f, 0.21948937f, -0.06452137f, 
    -0.01947719f, 0.19653581f, 0.24144179f, -0.20847556f, 0.15751903f, 0.05028911f, -0.01123464f, 0.00218676f, 
    0.17486544f, -0.10209463f, -0.03760534f, -0.29703319f, -0.05597651f, 0.07124721f, 0.15492064f, -0.02875232f, 
    -0.10132287f, -0.00761757f, 0.01264550f, 0.12635799f, -0.01302041f, -0.19035801f, 0.08157160f, -0.02904701f, 
    0.05294012f, 0.06347667f, -0.03997011f, 0.04579517f, 0.06755449f, 0.09078763f, 0.15794909f, 0.04301808f, 
    -0.01609295f, -0.41301379f, -0.05935046f, 0.11721293f, 0.06148621f, -0.14110871f, -0.12588023f, 0.06414005f, 
    -0.06931747f, -0.04498274f, -0.06844338f, 0.05701960f, -0.00213765f, 0.00177892f, -0.47774652f, 0.02000010f, 
    0.02276080f, -0.08404085f, 0.15730625f, 0.02399700f, 0.03601217f, 0.07694265f, 0.12810253f, 0.16686407f, 
    -0.13614073f, -0.13448414f, -0.20395982f, 0.52198005f, -0.06862465f, 0.01352206f, 0.10456798f, 0.18876584f, 
    -0.17995644f, -0.08652743f, 0.06677165f, -0.03780476f, -0.14860690f, -0.17081758f, -0.40308860f, -0.29291025f, 
    -0.06684516f, -0.01039865f, 0.00011026f, 0.03297504f, 0.09640986f, 0.01540578f, -0.06844296f, 0.03943383f, 
    -0.10854334f, -0.23691469f, 0.29096308f, 0.04587977f, -0.06533708f, -0.04123770f, 0.02149531f, -0.14306390f, 
    -0.03029797f, -0.04916557f, 0.06031403f, 0.08884425f, 0.07077777f, 0.00314183f, 0.02299742f, -0.24044666f, 
    -0.10600889f, -0.01899991f, 0.09861186f, 0.11102036f, 0.00143134f, 0.08031583f, -0.05597761f, -0.17460372f, 
    0.16931422f, 0.08866849f, -0.11397812f, -0.12246522f, -0.19039454f, -0.03239127f, -0.08537947f, -0.02717140f, 
    -0.15533428f, 0.02880232f, -0.00839447f, -0.18802303f, -0.00715802f, -0.24055392f, -0.22855146f, 0.15825374f, 
    -0.00132785f, 0.13267674f, 0.17038348f, 0.03448195f, 0.03650403f, 0.10052817f, 0.13359854f, 0.09855632f, 
    -0.15047690f, -0.28829068f, -0.31083810f, 0.26031834f, 0.04785311f, -0.17272466f, 0.02833645f, 0.02262707f, 
    -0.04684496f, 0.08690410f, 0.02581026f, 0.08936763f, 0.04616290f, 0.04167647f, -0.03453603f, -0.12850676f, 
    -0.01135506f, 0.03457181f, -0.03094922f, 0.07788909f, 0.08570008f, 0.07215213f, 0.28009063f, 0.10266487f, 
    0.11719885f, 0.18912710f, 0.24179284f, 0.01496431f, -0.07095245f, -0.11453877f, 0.02328329f, 0.09329118f, 
    0.00713108f, 0.11808737f, 0.08143916f, -0.05328693f, 0.61729395f, -0.28102633f, 0.15201409f, -0.15887800f, 
    0.15989789f, -0.13424666f, -0.00161322f, 0.04244413f, 0.04596198f, -0.03513517f, 0.13158393f, 0.08599874f, 
    -0.15838200f, -0.33091429f, 0.02666772f, 0.06535818f, -0.09969599f, -0.20199080f, -0.10087124f, -0.06684150f, 
    -0.05839860f, -0.06772315f, 0.02554707f, 0.03479657f, 0.35054979f, -0.07289641f, 0.25440848f, -0.18650977f, 
    -0.01199381f, -0.01185051f, 0.15232569f, -0.06964574f, -0.14597012f, 0.13747911f, -0.10376954f, -0.06446540f, 
    0.03044693f, -0.04293776f, 0.01889926f, -0.18876374f, -0.08675490f, -0.02664940f, -0.09507203f, 0.04827942f, 
    -0.01400160f, -0.09702513f, -0.08661286f, -0.21743910f, 0.22761559f, 0.44429669f, 0.03511158f, -0.22979291f, 
    0.05289608f, -0.16903836f, -0.18315332f, 0.03380278f, -0.05363083f, -0.08629902f, 0.15645868f, -0.00678724f, 
    0.10574349f, -0.00258633f, 0.01335803f, 0.06465903f, -0.02848686f, 0.18672881f, 0.02281859f, 0.06186361f, 
    0.07442661f, 0.05269387f, 0.22092694f, 0.15593800f, -0.19611558f, 0.22776502f, 0.31134877f, 0.12650268f, 
    -0.04847449f, 0.15154397f, 0.07924477f, 0.05676926f, 0.08450434f, 0.10089699f, 0.13452077f, 0.08373319f, 
    0.20813197f, -0.43451768f, -0.09013458f, 0.06204995f, -0.11652026f, 0.04656447f, -0.15649827f, -0.06824885f, 
    0.04421227f, 0.03459504f, 0.08712341f, 0.00462349f, 0.23178406f, 0.16257535f, 0.08888170f, -0.22782534f, 
    0.02183055f, 0.11580602f, 0.03824447f, -0.02429946f, -0.00537075f, 0.11677591f, 0.00908789f, 0.03261499f, 
    -0.35345736f, 0.43470174f, -0.40772879f, 0.15185805f, 0.28665039f, -0.05051860f, 0.27096006f, -0.18076693f, 
    -0.02334879f, -0.05225263f, -0.00102964f, -0.07648833f, 0.20886458f, 0.12910506f, 0.08494129f, -0.00755832f, 
    -0.02538623f, -0.15462667f, -0.14590545f, 0.06685516f, -0.12425584f, -0.01565292f, 0.05279181f, -0.00554361f, 
    0.47450185f, -0.19426286f, 0.17716672f, -0.12570162f, -0.01267077f, 0.23048940f, -0.02659126f, 0.04610876f, 
    0.05088083f, 0.14017104f, 0.26572531f, 0.06494373f, 0.18781142f, 0.06292916f, 0.16307528f, -0.00938097f, 
    -0.03546283f, -0.22784233f, -0.04061286f, 0.06547640f, -0.23071602f, 0.04242210f, -0.05715995f, -0.21610872f, 
    0.01788826f, -0.04326282f, -0.05016050f, -0.03170482f, -0.00671346f, 0.01887982f, 0.03680611f, -0.03847909f, 
    -0.03937449f, -0.01036982f, 0.02343002f, -0.01763173f, -0.01953797f, -0.02727755f, -0.01552368f, -0.04407128f, 
    0.00888344f, -0.00856816f, -0.04785421f, 0.02712797f, 0.02054832f, 0.04501629f, -0.04494416f, 0.03759234f, 
    -0.04818580f, -0.04064052f, -0.05502421f, 0.02955875f, -0.05021567f, 0.05016175f, -0.02982546f, -0.05304262f, 
    0.02886772f, -0.01730890f, -0.05572388f, -0.03191514f, 0.00274830f, 0.03485844f, -0.02493152f, 0.01870334f, 
    -0.00078396f, 0.02586877f, 0.03492095f, -0.04799199f, -0.04776352f, 0.02917537f, 0.03158782f, -0.00224781f, 
    -0.02502777f, -0.05261132f, 0.00664655f, -0.03648481f, 0.02696711f, 0.00119182f, 0.01753028f, 0.02086636f, 
    -0.00113504f, -0.02090504f, -0.00429476f, -0.05274332f, 0.05088306f, -0.01712167f, -0.03927864f, -0.03436922f, 
    -0.02226588f, -0.03058908f, -0.01780107f, -0.00331815f, 0.00572807f, -0.03139425f, -0.01494250f, -0.01403374f, 
    -0.00779404f, 0.03345985f, 0.01145006f, -0.04655373f, -0.04986667f, -0.01953822f, -0.01755133f, -0.04395012f, 
    -0.02952501f, 0.01824311f, -0.04323141f, 0.00167504f, -0.05003139f, -0.00053269f, -0.05457108f, -0.02940222f, 
    -0.05549492f, 0.01846947f, -0.05161711f, 0.00466636f, -0.05677601f, 0.00228880f, 0.01857612f, 0.03348341f, 
    -0.02125584f, 0.04862106f, -0.03808951f, -0.00002061f, 0.00462581f, -0.03740808f, -0.02229955f, 0.04062003f, 
    -0.04849214f, -0.03242251f, -0.02959816f, -0.00446909f, 0.01563414f, 0.01665292f, -0.04890006f, -0.02702738f, 
    0.04439466f, 0.02069744f, -0.00206197f, 0.00906282f, -0.01058904f, 0.00771303f, -0.05371479f, -0.04353637f, 
    0.03970391f, 0.03561898f, -0.05601982f, -0.00493312f, -0.00470209f, -0.04896003f, -0.04318521f, 0.02272476f, 
    -0.04859413f, 0.00661332f, -0.03381157f, 0.01775260f, 0.03226930f, 0.02872464f, 0.01949851f, -0.04122956f, 
    0.04453330f, -0.01515189f, 0.04463295f, 0.02117145f, -0.00547479f, 0.02102447f, 0.00745291f, -0.01948197f, 
    -0.04101412f, 0.04209180f, -0.04315949f, -0.02302136f, -0.04853021f, 0.01562946f, 0.02505303f, -0.00849887f, 
    0.01991674f, -0.04143268f, -0.05271162f, -0.04470403f, 0.01364968f, 0.02874141f, 0.02603461f, -0.00832453f, 
    0.01355541f, 0.01149823f, -0.01177219f, -0.03970288f, -0.02588358f, 0.00357627f, -0.01796969f, 0.02784291f, 
    -0.02386128f, -0.00479291f, 0.01427172f, 0.00059728f, 0.01445667f, 0.02260940f, 0.02346705f, -0.01471404f, 
    0.04185352f, 0.01283557f, -0.03254830f, 0.00172076f, -0.04091192f, -0.03114194f, -0.04932598f, 0.04011146f, 
    -0.00334095f, 0.04257112f, 0.02173061f, 0.03689876f, -0.03897807f, -0.02633588f, 0.03241524f, -0.00223930f, 
    0.03317334f, 0.03055065f, -0.00529226f, 0.03803264f, 0.03805827f, 0.02283217f, 0.02721302f, 0.04638054f, 
    0.04329916f, -0.02224828f, 0.03478212f, 0.00700607f, -0.02808077f, -0.02721987f, -0.04652693f, 0.03903195f, 
    -0.04597611f, -0.03496291f, 0.03502895f, 0.05430384f, -0.03792222f, 0.04226465f, -0.04440828f, 0.03930401f, 
    -0.01098031f, -0.03623021f, -0.03858482f, -0.00742746f, -0.00539124f, 0.05879149f, -0.02396840f, -0.02404179f, 
    0.00601130f, -0.04410266f, 0.01555555f, -0.00445446f, 0.03190044f, 0.03045845f, 0.00837632f, -0.03341211f, 
    -0.02588854f, 0.01678286f, 0.02286408f, -0.04330228f, 0.01513588f, 0.04840580f, 0.02768129f, 0.02989375f, 
    0.03082580f, 0.01345875f, 0.02199824f, -0.04330190f, -0.00588733f, -0.03006749f, 0.02074517f, -0.04065345f, 
    -0.01325258f, -0.03336116f, -0.01600536f, -0.01278636f, -0.03819135f, -0.03793070f, 0.03542425f, -0.00368518f, 
    -0.02737308f, 0.00739351f, -0.03211864f, 0.00799403f, 0.04104536f, -0.00775025f, -0.00175460f, 0.02245102f, 
    -0.00347220f, 0.04122074f, -0.03933620f, -0.04679564f, 0.01499200f, -0.04249454f, 0.01767795f, -0.02234133f, 
    -0.01360003f, -0.05195442f, 0.00463033f, 0.03678026f, 0.01975431f, -0.03239521f, -0.03036081f, 0.01779263f, 
    0.01156119f, 0.02598758f, -0.04656275f, 0.04463089f, 0.01134935f, -0.03417795f, -0.02354116f, 0.03555920f, 
    -0.02645054f, 0.03795290f, -0.03948189f, -0.05078519f, 0.04503724f, -0.04092679f, -0.01323681f, 0.03552960f, 
    -0.02855056f, -0.03050877f, -0.05124386f, -0.01452083f, -0.00625550f, 0.01702447f, -0.02055893f, -0.03974807f, 
    -0.00856122f, -0.00774506f, -0.01142136f, 0.01584225f, 0.03264031f, 0.01574624f, 0.04823104f, -0.00764819f, 
    -0.03069963f, -0.00581608f, -0.02677223f, 0.00478212f, -0.01270581f, -0.01002129f, -0.02692964f, -0.01258734f, 
    -0.02952261f, -0.01816978f, -0.03585439f, 0.01389259f, -0.05685888f, -0.04829158f, -0.04187101f, 0.00541903f, 
    0.04673507f, -0.04564326f, -0.01931378f, -0.00562365f, -0.03137983f, 0.05257884f, 0.04620940f, -0.03276013f, 
    -0.04532885f, -0.01714664f, 0.00169001f, -0.02363584f, -0.02136280f, 0.00197055f, -0.04245337f, 0.02459408f, 
    -0.00603184f, 0.01338029f, -0.00324084f, 0.01855567f, 0.01442207f, -0.02549293f, 0.01669486f, -0.01193755f, 
    0.02492268f, -0.05654871f, -0.03352118f, 0.03699896f, -0.05131160f, -0.02235922f, -0.02754637f, -0.05059190f, 
    -0.05043508f, -0.00943379f, 0.02695533f, -0.05336735f, -0.00783919f, -0.04917388f, -0.04902833f, -0.01617618f, 
    0.04862232f, 0.01855252f, 0.04341598f, 0.02132343f, 0.00400035f, -0.05496656f, 0.00980806f, 0.00108496f, 
    -0.00737323f, -0.05322058f, 0.03987763f, 0.00388457f, 0.01817654f, 0.01200098f, -0.03068339f, 0.00123455f, 
    0.03389161f, 0.03155722f, -0.05100848f, -0.05095107f, -0.03395040f, -0.04082833f, -0.05266171f, -0.01576776f, 
    0.03550103f, -0.00533674f, 0.03656914f, -0.02013987f, -0.05579711f, 0.01278259f, -0.02813756f, 0.01497627f, 
    -0.03723417f, 0.03050200f, 0.03432513f, 0.00715852f, 0.00001187f, -0.04119374f, 0.01592458f, 0.02318429f, 
    -0.02426755f, -0.01551095f, 0.03243913f, -0.04139446f, 0.02617828f, -0.03840056f, 0.04050471f, -0.05449799f, 
    -0.02104672f, -0.04635129f, 0.01276744f, 0.03302550f, 0.03936549f, -0.04053422f, -0.03856134f, 0.05222290f, 
    0.03066644f, 0.03751735f, -0.00539801f, -0.03574440f, 0.03397586f, -0.03013826f, -0.01204866f, -0.04258839f, 
    0.03505304f, -0.01382887f, 0.00105964f, 0.03586697f, 0.03856406f, 0.03127542f, -0.04587657f, 0.00958024f, 
    -0.01988851f, 0.00219630f, -0.04381833f, 0.01428161f, -0.00626711f, -0.03981972f, 0.03376542f, 0.03797125f, 
    0.03931874f, -0.02425396f, 0.03463075f, 0.01054273f, -0.03110578f, 0.00925427f, 0.04397484f, 0.01799222f, 
    0.00524870f, -0.03593161f, -0.03136153f, 0.01815722f, -0.01287721f, -0.02570882f, 0.01213947f, 0.00940535f, 
    -0.01635253f, -0.04243021f, -0.05492915f, 0.01727638f, -0.01941953f, -0.04475759f, 0.02862326f, 0.00416605f, 
    0.01392523f, -0.00819085f, 0.03695040f, -0.03068197f, -0.05101553f, 0.00325418f, 0.02565533f, -0.04551199f, 
    -0.02645694f, -0.01379852f, -0.03999452f, -0.00327007f, -0.03014938f, -0.01270010f, 0.03646942f, 0.00371192f, 
    -0.04974167f, -0.03755947f, 0.01530213f, -0.03505519f, -0.01712805f, -0.00570691f, -0.05248111f, 0.03615943f, 
    0.03528623f, -0.01145383f, -0.02664542f, -0.03658760f, 0.02513520f, 0.00686053f, 0.02251258f, 0.04354823f, 
    -0.03942953f, 0.03460949f, 0.02601131f, -0.00373729f, -0.03942287f, -0.03503059f, 0.02653475f, -0.04329322f, 
    -0.03483278f, 0.02525137f, -0.04061289f, -0.01384496f, 0.04512551f, -0.03355503f, -0.03033964f, -0.04321293f, 
    0.00060309f, 0.01355057f, 0.02082863f, -0.04416810f, 0.03700892f, 0.00906315f, 0.03330981f, -0.01803847f, 
    -0.04804192f, -0.04655185f, 0.00195916f, 0.05478920f, -0.00590636f, 0.03567687f, 0.01916183f, 0.03233957f, 
    -0.01757826f, -0.05107458f, -0.04874058f, -0.00515829f, -0.02081886f, -0.05527031f, 0.03943475f, 0.04078514f, 
    -0.05496409f, -0.01156858f, -0.04812172f, -0.01909050f, -0.03849717f, -0.02142331f, 0.01066681f, -0.00525228f, 
    0.03777818f, 0.00710907f, 0.03383644f, -0.03762131f, 0.00496646f, -0.03921106f, -0.00936791f, -0.02767152f, 
    -0.05613081f, -0.04182906f, 0.02757038f, 0.03706301f, 0.00197306f, -0.03861715f, -0.05448066f, -0.00766976f, 
    0.00741026f, 0.00377288f, 0.01731265f, 0.02108169f, -0.04825338f, 0.04483661f, -0.05212802f, -0.01147297f, 
    -0.00078976f, 0.00288202f, -0.01040654f, -0.01801536f, -0.00242150f, -0.01208044f, -0.04632965f, -0.03017080f, 
    -0.02786914f, -0.01040091f, 0.03496347f, 0.03807339f, -0.04659739f, 0.01114859f, -0.03156110f, -0.00150257f, 
    0.02356304f, -0.05058054f, -0.05075793f, -0.01565184f, 0.04385085f, 0.01506372f, 0.03261680f, 0.03556303f, 
    0.02096767f, -0.00306534f, 0.00121334f, -0.05131040f, -0.04525819f, 0.02825343f, -0.00352431f, 0.03488765f, 
    -0.02663099f, 0.04472046f, 0.00236889f, -0.02268844f, 0.04117952f, 0.01977859f, -0.02971981f, -0.04903186f, 
    -0.02824258f, 0.01734642f, -0.02124669f, -0.01679969f, 0.00372880f, -0.02072258f, -0.00915272f, 0.03603633f, 
    0.00051766f, -0.04707773f, -0.00857911f, 0.03202711f, -0.01850957f, 0.00156609f, 0.03688484f, -0.00211423f, 
    -0.05657384f, -0.03568335f, -0.03475687f, -0.00629059f, -0.04299951f, 0.05304889f, 0.00290214f, 0.00039638f, 
    0.03519259f, 0.01376338f, -0.02369734f, -0.00433479f, -0.01796432f, 0.04272355f, 0.01454300f, -0.04341056f, 
    -0.00754619f, -0.02446619f, -0.02396220f, -0.02681180f, 0.04858711f, -0.01902034f, -0.00458294f, 0.04774976f, 
    0.00084399f, -0.05175877f, 0.00028669f, -0.04171675f, -0.01428364f, -0.00477942f, -0.00278925f, 0.04347182f, 
    -0.02213454f, 0.03908012f, 0.00915850f, 0.01991582f, -0.03119632f, -0.03215320f, -0.03653171f, -0.03533940f, 
    -0.04277500f, 0.02320311f, 0.00529842f, 0.00187554f, 0.02013815f, -0.01174519f, -0.03667939f, -0.01009854f, 
    0.03959009f, -0.03502102f, -0.00153341f, -0.01923325f, -0.04137279f, -0.00262886f, -0.01284550f, 0.01470115f, 
    -0.01987819f, 0.03969751f, 0.04136194f, 0.03813802f, 0.01256936f, 0.04866973f, -0.05007823f, -0.03881721f, 
    -0.03311472f, 0.03060752f, -0.05037114f, 0.00970544f, -0.00629919f, -0.02568722f, 0.03923285f, 0.01664489f, 
    0.02591112f, 0.02869075f, 0.02843919f, -0.02665824f, -0.02500691f, -0.00298020f, -0.04641549f, 0.03962971f, 
    -0.03385011f, -0.00414835f, 0.01130219f, 0.02129393f, 0.04068993f, -0.05389214f, -0.03570959f, -0.01867174f, 
    0.01110966f, 0.00391182f, -0.04554856f, 0.04786944f, 0.03020066f, -0.02441715f, 0.02228547f, -0.03057324f, 
    -0.05085129f, -0.04248657f, -0.01897383f, 0.00623321f, -0.03330681f, -0.04369028f, -0.04352850f, -0.02147342f, 
    -0.01338898f, 0.01095763f, 0.03532051f, -0.00746988f, 0.02367558f, -0.01270903f, 0.04392786f, -0.01073095f, 
    0.04216330f, -0.04446287f, -0.02474022f, 0.02185269f, -0.03387371f, -0.00614792f, -0.00606914f, 0.04262516f, 
    -0.02714858f, -0.03289394f, -0.02034143f, -0.04519326f, -0.04050900f, -0.04133594f, 0.02947157f, -0.00918355f, 
    0.01577556f, 0.02895553f, -0.03149407f, -0.00465370f, -0.02674234f, -0.03700170f, 0.02361711f, 0.00947780f, 
    -0.04088508f, 0.02477748f, -0.05760707f, -0.04970261f, 0.04336075f, 0.00140215f, -0.03137706f, 0.02237039f, 
    0.00294824f, -0.02064659f, -0.00811605f, -0.04636028f, -0.02178039f, -0.00811412f, -0.05229555f, -0.02345838f, 
    -0.03688058f, -0.03476465f, -0.04365469f, -0.05880371f, -0.02804063f, -0.04663102f, -0.01166754f, 0.00038934f, 
    0.03893287f, 0.02750788f, -0.00365972f, -0.04950357f, 0.01200505f, 0.01348912f, -0.04664283f, 0.03550338f, 
    0.01840602f, -0.04854487f, 0.03813743f, 0.00501349f, -0.00744637f, -0.04649757f, -0.04657580f, -0.03992261f, 
    0.03276070f, -0.01138455f, -0.00554000f, -0.05490585f, -0.02463744f, 0.03671663f, 0.04584114f, -0.04187735f, 
    -0.01406355f, 0.02771222f, -0.04186812f, -0.03081878f, 0.01202339f, -0.02298383f, -0.03384750f, -0.00435612f, 
    0.03537908f, -0.02938524f, 0.02176576f, -0.00049890f, 0.01795037f, -0.00030889f, 0.02623939f, 0.00823471f, 
    -0.00662846f, 0.02712233f, 0.00491288f, 0.03967685f, 0.00388961f, -0.00213562f, -0.04944568f, -0.00861885f, 
    -0.01275999f, -0.01715733f, 0.03531461f, 0.03505446f, 0.03929647f, 0.02928075f, -0.06067744f, -0.01218720f, 
    -0.03393248f, -0.00576513f, -0.06000916f, 0.00894570f, 0.03923562f, -0.01801808f, 0.03236939f, 0.02640259f, 
    0.00410630f, -0.02050915f, 0.01682056f, 0.03169684f, -0.04447077f, 0.01948090f, 0.00670509f, 0.02212267f, 
    0.03392160f, -0.03240942f, 0.03606338f, -0.02448607f, -0.03828060f, 0.04140962f, -0.02305316f, -0.05741630f, 
    0.02830298f, 0.00782340f, -0.06161360f, -0.02550493f, -0.00896671f, -0.03676524f, 0.00909275f, -0.00041052f, 
    0.01708670f, -0.03586450f, 0.01959242f, -0.01181810f, -0.04325449f, -0.00541907f, -0.00386572f, 0.02870199f, 
    0.01731987f, 0.02040607f, 0.02914855f, 0.02948936f, -0.04225759f, 0.02892129f, 0.03816378f, -0.00651680f, 
    -0.00196530f, -0.00819512f, 0.02980280f, -0.00530528f, 0.01090480f, 0.03975683f, -0.04581021f, -0.05641638f, 
    -0.05266032f, -0.02389390f, -0.00441512f, -0.02217368f, -0.03346587f, -0.03008903f, -0.02442658f, -0.05340588f, 
    0.00736957f, -0.06018474f, -0.03242358f, -0.05416760f, -0.03030363f, -0.01952016f, -0.06150035f, -0.01674822f, 
    -0.01459045f, -0.03467723f, -0.00943950f, -0.05755407f, -0.00969905f, -0.01893547f, -0.05629010f, 0.02441200f, 
    0.01177734f, 0.03413313f, 0.03777567f, -0.02121765f, -0.04348518f, -0.03346445f, -0.02856581f, -0.04599006f, 
    -0.02589524f, 0.01024106f, -0.00797445f, 0.03325845f, 0.03082771f, -0.01514990f, -0.03797669f, 0.03521309f, 
    -0.05846775f, 0.03561369f, -0.03157326f, 0.03548826f, -0.03775360f, -0.04495883f, -0.05380420f, -0.01311049f, 
    -0.00430792f, -0.00436934f, 0.03402270f, -0.00056259f, -0.02763245f, -0.00776090f, -0.03104066f, -0.00763741f, 
    0.01080193f, -0.03239566f, 0.01367855f, -0.01849642f, 0.00259307f, 0.03711881f, -0.02282402f, 0.03655244f, 
    0.02857769f, 0.02769409f, -0.01156941f, 0.00655720f, -0.00654526f, 0.02427327f, 0.01344400f, -0.04923752f, 
    0.00134527f, -0.02186462f, 0.03540504f, 0.00073306f, -0.03310927f, -0.03792570f, -0.01646788f, 0.01757738f, 
    -0.02320039f, 0.03707350f, -0.05234088f, -0.03927578f, -0.03166358f, -0.03525342f, 0.02096183f, -0.04794782f, 
    -0.00539316f, 0.04006768f, -0.01500611f, -0.00748412f, 0.00973635f, 0.01425552f, -0.05928760f, 0.02103574f, 
    0.01605021f, 0.03507366f, -0.03697300f, 0.00884721f, -0.02347988f, 0.02326933f, 0.00277805f, -0.03044406f, 
    0.02215707f, 0.03343618f, -0.03521539f, -0.06059472f, -0.05317561f, -0.04336293f, 0.02514858f, 0.01409779f, 
    0.01418058f, -0.05814643f, 0.00433639f, -0.02208261f, -0.00466062f, 0.03483643f, 0.00670301f, 0.01104313f, 
    0.00986587f, -0.00205168f, 0.01243556f, 0.00878000f, -0.05286867f, 0.01964671f, 0.00991387f, 0.01797222f, 
    -0.04189377f, 0.00006423f, 0.01820886f, 0.00420858f, -0.02415202f, 0.03703952f, -0.02409670f, -0.05192446f, 
    0.00102649f, -0.00765530f, -0.04060373f, -0.02140043f, -0.00675878f, 0.01292388f, 0.02545088f, 0.01389830f, 
    0.01742745f, 0.00886649f, -0.02901748f, -0.03147873f, -0.05095157f, -0.04813880f, -0.03992322f, -0.02979134f, 
    -0.03000699f, 0.02403921f, 0.02991109f, 0.02346319f, -0.04250801f, 0.01339409f, 0.00709692f, 0.00325402f, 
    0.03418610f, 0.00250132f, -0.04212009f, -0.02075186f, -0.00939514f, -0.01826997f, 0.00679736f, 0.02604678f, 
    -0.05998601f, -0.04117030f, -0.06078467f, -0.00104066f, -0.02922580f, 0.03143147f, 0.00718631f, -0.04334604f, 
    0.04112344f, -0.02836708f, 0.04181342f, 0.01545813f, 0.01580063f, 0.02534597f, 0.03508462f, -0.02539134f, 
    -0.02907139f, -0.05625249f, -0.04062803f, -0.05427534f, -0.00302040f, -0.01655666f, 0.04074151f, 0.00161081f, 
    0.03136303f, -0.02166445f, -0.04331316f, 0.03858711f, -0.03302443f, -0.03396270f, -0.04834109f, 0.04090790f, 
    0.04102830f, -0.03013621f, -0.01161531f, -0.05014044f, 0.04465689f, 0.03828774f, -0.03248591f, 0.03819231f, 
    0.01397322f, -0.05371695f, 0.03680645f, 0.03061685f, -0.05395367f, -0.03805393f, -0.03338416f, 0.03243407f, 
    -0.01386046f, -0.00165162f, -0.00126209f, -0.05788842f, -0.00265009f, 0.03093405f, 0.01817762f, -0.02867760f, 
    0.00441983f, 0.00420017f, -0.00351073f, -0.04697430f, 0.02467540f, -0.03303426f, -0.01626130f, 0.01864791f, 
    0.04786063f, 0.00653702f, -0.03398906f, -0.02494766f, 0.01860996f, -0.05576976f, 0.00786672f, 0.03251459f, 
    0.03912240f, -0.02088653f, -0.01352145f, 0.01910515f, -0.00369800f, -0.00222474f, 0.02040712f, -0.01296152f, 
    0.03994259f, 0.03838352f, 0.04431493f, 0.00062764f, -0.03083791f, 0.03146345f, -0.04881549f, 0.02164513f, 
    -0.03177228f, -0.02586934f, -0.03823167f, -0.03348107f, 0.01691479f, 0.02243542f, -0.03421060f, -0.01308443f, 
    -0.02246090f, -0.01980196f, 0.00912478f, -0.01114663f, 0.00971555f, -0.01419561f, 0.03339305f, -0.03691826f, 
    0.01743992f, -0.00581214f, -0.04482291f, 0.00840419f, 0.01097862f, -0.05150664f, 0.04097877f, -0.04540898f, 
    0.00434421f, -0.01647070f, 0.03707853f, -0.00291638f, -0.03325424f, 0.04506860f, 0.01170123f, 0.00599131f, 
    0.03345293f, -0.01655391f, -0.01228401f, -0.01988276f, -0.02687229f, 0.01016098f, 0.02037493f, 0.04673902f, 
    -0.00364545f, 0.01337117f, 0.00126460f, -0.00922916f, -0.00381127f, -0.02089754f, 0.03969671f, -0.03894708f, 
    -0.02555028f, 0.02471954f, 0.01967902f, 0.02293005f, -0.03410239f, -0.03440582f, 0.01492660f, -0.04963573f, 
    -0.03489212f, 0.02376260f, -0.01086962f, -0.00804407f, -0.02902195f, -0.00273536f, -0.02673667f, 0.01164048f, 
    -0.04326917f, 0.02911815f, 0.02887495f, -0.05166354f, 0.01401798f, -0.01140262f, -0.03402284f, -0.03989784f, 
    0.04470789f, -0.04022546f, -0.04798742f, -0.02145290f, -0.02499502f, -0.05147824f, 0.02691840f, 0.02978490f, 
    0.01413638f, -0.01836062f, -0.00264297f, 0.03699147f, -0.02915730f, 0.00062876f, -0.03588656f, -0.04417910f, 
    0.00130518f, -0.02432489f, 0.01720256f, 0.03719339f, 0.04510856f, 0.02489033f, 0.02051364f, -0.00577328f, 
    0.03817971f, -0.03958681f, -0.04531259f, 0.03595353f, 0.03515845f, -0.03640227f, 0.04257735f, 0.00746704f, 
    0.03561379f, -0.04770288f, 0.04192587f, -0.01180176f, 0.01780730f, 0.01262352f, 0.01505407f, 0.00918811f, 
    0.01736198f, 0.03539767f, -0.01884061f, -0.04608138f, 0.04854615f, 0.01720377f, 0.02350725f, 0.01859397f, 
    -0.05657456f, -0.04936791f, 0.02582030f, -0.00677450f, -0.04728506f, 0.00984137f, -0.05279800f, -0.04386593f, 
    0.01783238f, 0.02380250f, -0.05859452f, -0.05051545f, -0.04444961f, 0.01475279f, 0.01257241f, -0.02236075f, 
    -0.01031828f, 0.04549904f, -0.05204360f, -0.04961930f, 0.00050055f, -0.02712846f, 0.00839868f, -0.01570967f, 
    -0.01237862f, -0.05476054f, -0.04571835f, -0.02774391f, -0.04291754f, 0.01300212f, -0.02756762f, -0.04095617f, 
    -0.03764248f, 0.00623933f, -0.00393990f, -0.04734700f, 0.03531247f, -0.03713752f, -0.02367628f, 0.03982092f, 
    -0.00284493f, -0.00352242f, -0.01854124f, -0.05521250f, -0.00903894f, 0.02978796f, -0.02367507f, 0.02578832f, 
    -0.01260873f, -0.03878792f, 0.00807789f, -0.00780784f, 0.01647554f, 0.04333178f, -0.02926191f, -0.02391416f, 
    -0.04296004f, -0.04989941f, -0.01732504f, -0.03833587f, -0.04355663f, 0.02972556f, -0.04669069f, 0.00745936f, 
    0.01269944f, 0.03148498f, -0.01826501f, -0.03308250f, 0.00350294f, -0.03684840f, 0.01986526f, 0.04065976f, 
    -0.02433845f, -0.02971174f, 0.02990881f, -0.02999675f, -0.03955634f, -0.04761206f, 0.01502954f, 0.04827580f, 
    0.03947126f, -0.03855717f, 0.00319654f, -0.03445859f, -0.02634406f, -0.00276396f, -0.00291242f, 0.04007202f, 
    -0.03971206f, -0.02231338f, -0.04238289f, 0.01039607f, 0.04162897f, -0.03736191f, 0.04074906f, 0.01230133f, 
    -0.00881104f, -0.00903098f, -0.02572425f, -0.04599331f, 0.00231467f, 0.02250355f, 0.03708515f, -0.05259082f, 
    -0.04158490f, -0.02432262f, -0.00169588f, -0.00583405f, -0.05020272f, -0.03375983f, -0.00074926f, -0.02356976f, 
    -0.00628884f, -0.04598887f, -0.03263082f, -0.02785833f, 0.00838088f, -0.00068938f, 0.00496539f, 0.00821922f, 
    0.01373545f, 0.02416873f, -0.01145216f, -0.01947590f, 0.03529570f, -0.00334205f, -0.02148205f, 0.01464354f, 
    -0.01527344f, 0.04199632f, 0.04809430f, 0.02285146f, 0.01594880f, 0.01889873f, -0.02059732f, 0.01540805f, 
    -0.01652741f, -0.02419597f, -0.01345931f, -0.03090873f, -0.02718834f, -0.00000100f, 0.02771365f, 0.00877755f, 
    -0.02059143f, 0.02505086f, 0.01030212f, 0.01652052f, -0.01645841f, -0.05260047f, -0.04649558f, -0.00773753f, 
    -0.01556467f, -0.03056413f, 0.01956605f, 0.02205566f, -0.03065172f, -0.05230985f, 0.04097183f, 0.04054419f, 
    -0.03713118f, -0.01578102f, 0.03422751f, -0.03390482f, 0.03171457f, 0.01230942f, 0.03050983f, -0.02613077f, 
    0.03840811f, -0.04489794f, -0.03958774f, 0.03688473f, 0.03867795f, 0.03603871f, 0.04454289f, 0.04404493f, 
    -0.01672223f, -0.02422602f, 0.02788175f, -0.03286746f, -0.02922393f, 0.01119757f, 0.03495859f, 0.01536927f, 
    -0.04960033f, -0.03670893f, -0.04242681f, -0.01295601f, 0.01404099f, 0.01773823f, 0.01521220f, -0.01697305f, 
    -0.04332181f, -0.01947417f, -0.04337210f, -0.02812101f, 0.01189750f, 0.01182632f, -0.03389324f, 0.04368088f, 
    -0.05186882f, -0.02461439f, 0.04131262f, -0.04214502f, -0.04135983f, 0.03294321f, 0.02996199f, 0.02021044f, 
    -0.00267408f, -0.00611051f, 0.02637430f, 0.00824196f, 0.00818809f, 0.03726311f, 0.03661023f, -0.05019983f, 
    -0.04935141f, 0.03467774f, 0.01202683f, 0.00493202f, -0.03163392f, -0.02347141f, -0.03316588f, -0.04780129f, 
    0.01407020f, -0.05393855f, 0.02103717f, -0.02005586f, -0.03834466f, -0.00889343f, 0.00629248f, -0.01333448f, 
    0.02258649f, -0.05378166f, -0.03080001f, -0.00616263f, -0.03359554f, 0.01143730f, 0.02729282f, 0.04316032f, 
    -0.05375514f, -0.05078647f, -0.01342830f, 0.01138389f, -0.04840921f, -0.01656947f, 0.02307309f, -0.00214495f, 
    0.00646269f, -0.05574700f, 0.04192951f, -0.00634105f, 0.03784447f, -0.05414512f, 0.02052847f, -0.04274175f, 
    0.08523405f, 0.02553899f, -0.02699324f, 0.12409324f, 0.04163112f, 0.28717637f, 0.13149969f, 0.02759117f, 
    0.12404967f, -0.00918179f, 0.08103489f, 0.08067449f, -0.24182035f, -0.09974154f, 0.14327195f, 0.05586859f, 
    -0.05960239f, -0.10577396f, -0.08012573f, -0.13776188f, 0.02287512f, 0.11917710f, -0.02089410f, 0.05857567f, 
    -0.60458517f, 0.11766472f, 0.22964533f, -0.00319123f, -0.28383091f, 0.10995502f, 0.03368125f, 0.02566458f, 
    -0.03724126f, 0.06299592f, 0.18661934f, -0.07993916f, -0.29962188f, -0.01414138f, -0.06697581f, 0.02801206f, 
    -0.08059307f, 0.03773344f, 0.01259392f, -0.08899067f, 0.02292958f, 0.08271052f, -0.01706233f, -0.06859398f, 
    0.22230636f, 0.06418679f, -0.21379814f, 0.18724154f, 0.01186842f, 0.08719140f, 0.10027197f, 0.04169542f, 
    -0.11500797f, 0.09682322f, 0.18099533f, 0.11500442f, 0.64310908f, 0.03880529f, 0.29401621f, 0.20636468f, 
    0.00354014f, 0.04602176f, 0.04908036f, 0.15246867f, -0.01085020f, -0.04505700f, 0.07195441f, 0.17093472f, 
    0.64660263f, 0.07374968f, 0.09088073f, 0.51484209f, -0.07643890f, -0.05077959f, 0.09031381f, 0.07909047f, 
    0.06301804f, 0.09747887f, -0.07829729f, 0.02482799f, 0.23034486f, -0.17111756f, -0.02421005f, 0.10399503f, 
    0.00216876f, -0.11198068f, 0.11792912f, 0.04538529f, 0.07519043f, 0.15983544f, -0.04235667f, 0.11495170f, 
    0.01704177f, 0.08829641f, -0.17800933f, -0.09216917f, 0.25292745f, 0.18138106f, 0.15692267f, 0.21124965f, 
    0.08758070f, 0.03946435f, 0.00315981f, -0.15431887f, -0.00762893f, 0.25854886f, 0.15346810f, -0.19925550f, 
    0.06836742f, 0.01519453f, -0.13302813f, 0.13264729f, 0.01842789f, 0.13018458f, 0.03196233f, -0.07606608f, 
    -0.32497686f, 0.17104980f, 0.11314570f, 0.16565233f, -0.13970846f, -0.21381898f, -0.00995034f, -0.18467018f, 
    0.05274083f, 0.09986377f, -0.16881882f, 0.04606806f, -0.13926660f, -0.00708548f, 0.04270474f, 0.20519786f, 
    0.06317821f, 0.02167876f, 0.14171001f, 0.14786506f, -0.07004250f, -0.07918370f, 0.01472700f, -0.05296240f, 
    -0.44643217f, -0.27264759f, 0.00639943f, 0.13425009f, 0.24411027f, 0.20023914f, 0.01592219f, -0.14069520f, 
    0.16841339f, -0.02808114f, -0.02451398f, -0.00374482f, -0.11277340f, -0.10441430f, -0.03212951f, -0.08618139f, 
    -0.12251040f, 0.04403277f, -0.11351609f, -0.04304487f, 0.01442037f, 0.01267368f, -0.04126199f, -0.01212151f, 
    -0.05165790f, -0.01061652f, -0.05822378f, -0.33124292f, -0.15549470f, 0.05385216f, -0.12131135f, -0.00475027f, 
    0.00287214f, -0.11922769f, 0.16958460f, -0.11417837f, -0.07043256f, -0.05912036f, -0.31450790f, 0.25506279f, 
    0.16631965f, -0.04077122f, 0.10445850f, 0.08785455f, 0.11895484f, -0.06014048f, 0.07279153f, 0.17455639f, 
    0.08738979f, 0.14527564f, 0.10393246f, 0.13453910f, -0.01416525f, 0.14541586f, -0.06266969f, -0.11640186f, 
    -0.02983104f, 0.07360227f, 0.02309368f, 0.00781795f, 0.26121113f, -0.10964754f, 0.01001863f, 0.27963206f, 
    -0.00426265f, -0.11837702f, 0.04081449f, -0.16646850f, -0.06560144f, -0.05512637f, 0.05498211f, 0.15686290f, 
    -0.06765511f, -0.28248253f, 0.30920607f, 0.16385348f, 0.19916475f, -0.08358927f, 0.00801187f, -0.01367633f, 
    -0.03691550f, 0.01026134f, 0.06876305f, -0.14353542f, 0.27354375f, 0.06367575f, 0.19138527f, -0.04297360f, 
    -0.01376566f, 0.16527455f, -0.06511818f, 0.01696574f, -0.07970499f, 0.16801693f, -0.02850989f, -0.06639273f, 
    0.16815171f, 0.26722756f, -0.22065403f, -0.11512291f, 0.24617109f, 0.08748795f, 0.10546922f, 0.19330882f, 
    -0.13597676f, -0.09501515f, 0.01221416f, -0.12634656f, -0.41360539f, -0.19853473f, 0.03939163f, -0.02935566f, 
    -0.16796096f, -0.01522333f, -0.24111488f, -0.09308401f, 0.14361817f, -0.07066104f, 0.01097307f, -0.08263577f, 
    -0.12256210f, -0.20585799f, -0.05597201f, 0.08595446f, -0.16197753f, 0.07344639f, -0.20149381f, -0.10666920f, 
    -0.15438735f, -0.05053738f, 0.00321005f, 0.07406253f, -0.26922143f, 0.30711424f, -0.02274451f, 0.22573307f, 
    0.04690228f, -0.02982353f, -0.06044837f, 0.09355478f, 0.03601736f, -0.00300724f, 0.00515442f, -0.01851465f, 
    -0.03209961f, -0.04352382f, 0.03629817f, 0.18282765f, -0.07875965f, -0.10638834f, -0.00292177f, -0.14319065f, 
    0.19860214f, -0.04400257f, -0.11014432f, -0.12864457f, -0.39378256f, -0.02930111f, 0.02172522f, 0.39901426f, 
    0.05319565f, -0.02346324f, 0.04672835f, -0.02444035f, 0.02427501f, -0.20379835f, 0.15335679f, 0.08068433f, 
    0.20026350f, 0.31646380f, -0.01468776f, -0.09479480f, 0.07559698f, 0.08719295f, -0.01789721f, 0.07804527f, 
    -0.03578083f, -0.02905031f, -0.01417486f, 0.06668872f, 0.10408661f, 0.13177480f, 0.16165890f, -0.04307755f, 
    0.02336903f, -0.06074829f, -0.13572708f, 0.03123351f, -0.08500090f, -0.05456232f, 0.06464200f, -0.13397671f, 
    0.79477400f, 0.00496432f, 0.56607926f, -0.28641632f, 0.13673757f, -0.30025876f, 0.06046135f, 0.21705426f, 
    -0.07516953f, -0.11370460f, 0.16077106f, 0.02015606f, -0.45159110f, 0.20305049f, 0.10985322f, -0.06825109f, 
    0.07839799f, 0.02073951f, -0.11348879f, 0.03055749f, 0.05676740f, -0.01536342f, -0.06497498f, 0.02809205f, 
    0.04420755f, 0.08128758f, 0.27917591f, -0.12421858f, -0.29324841f, 0.05306156f, -0.04648555f, 0.01869597f, 
    -0.18772890f, -0.04885573f, -0.12234408f, -0.00447033f, -0.35277566f, -0.01171300f, -0.02305870f, -0.05640162f, 
    -0.02679290f, 0.02229715f, -0.24110220f, 0.03043609f, -0.08509580f, -0.04081546f, 0.09185934f, 0.04260287f, 
    0.00947808f, 0.08980855f, 0.02148812f, 0.04445809f, 0.07342207f, 0.22306968f, 0.07141448f, -0.02867362f, 
    -0.05068601f, 0.03307722f, 0.10646018f, -0.08978888f, -0.05184471f, 0.15993707f, 0.11113244f, 0.04063024f, 
    -0.15575154f, -0.16470030f, -0.20266448f, -0.06331106f, 0.00915340f, -0.04322518f, -0.16854000f, 0.13340385f, 
    0.10528501f, 0.22351235f, 0.00769574f, 0.16512014f, 0.01600379f, 0.02122140f, 0.02153938f, -0.12178636f, 
    -0.04868655f, 0.28770465f, 0.07805382f, 0.07574105f, -0.07176825f, -0.12827875f, 0.10917292f, 0.05122530f, 
    -0.07684053f, -0.00136035f, -0.14230931f, -0.06115180f, 0.17946111f, 0.03535924f, -0.08355967f, 0.04935236f, 
    0.05837735f, 0.07782342f, 0.21207190f, 0.10432408f, 0.23869891f, -0.19417220f, -0.04016376f, 0.05553412f, 
    -0.00507471f, -0.02453249f, -0.14071374f, 0.08796915f, 0.58292294f, -0.12655397f, -0.12369405f, 0.26294440f, 
    0.18137638f, 0.01013722f, 0.09615798f, -0.05154689f, -0.02394628f, 0.02666529f, 0.13137445f, 0.06704904f, 
    0.21274453f, -0.01268188f, 0.12436605f, 0.00110719f, 0.10623290f, -0.05929307f, -0.00908401f, 0.01178496f, 
    -0.03381144f, 0.03318851f, 0.09676641f, -0.07837347f, -0.03611970f, 0.18371625f, 0.03173233f, -0.07026800f, 
    0.10139617f, 0.06948923f, 0.06234102f, 0.08523455f, -0.08568735f, 0.10679978f, -0.02619108f, -0.12806968f, 
    -0.13266382f, -0.21089996f, 0.05367124f, 0.18748182f, 0.04601776f, 0.08775418f, -0.02496348f, -0.10801623f, 
    -0.05624879f, -0.00001592f, 0.17192802f, 0.00784475f, -0.30871889f, -0.11056324f, -0.23608106f, -0.01129559f, 
    0.01272866f, -0.02960098f, 0.01511060f, 0.09342718f, -0.16120557f, -0.13841538f, 0.17372124f, 0.01342998f, 
    -0.22761531f, -0.06941567f, -0.17452931f, -0.00924871f, -0.05517972f, 0.19973336f, 0.02906140f, 0.05886463f, 
    0.14575058f, 0.18282503f, -0.12100134f, 0.19968283f, -0.33411577f, -0.25808352f, -0.05906931f, 0.11887471f, 
    0.04349691f, 0.03926503f, 0.12512024f, -0.13909915f, -0.07084455f, -0.05851087f, 0.00631955f, -0.14811981f, 
    -0.29439530f, 0.02051452f, 0.36648598f, -0.17298867f, 0.02482429f, -0.10411835f, -0.31162429f, -0.10962357f, 
    -0.06916044f, -0.01218651f, 0.05060174f, 0.08603902f, 0.08620339f, -0.13861939f, 0.04380389f, -0.07059677f, 
    -0.18753712f, -0.22111513f, -0.01198205f, -0.07205822f, 0.06296974f, -0.02192268f, 0.19001496f, -0.04331642f, 
    0.04785940f, -0.05394176f, -0.07437205f, -0.00911872f, 0.02301183f, 0.01284450f, -0.05589836f, 0.07360242f, 
    -0.05810860f, 0.19388972f, 0.00978135f, -0.02691710f, 0.22803390f, 0.01866136f, -0.04239115f, 0.03047731f, 
    -0.04731986f, 0.13772106f, -0.10849737f, -0.11309167f, -0.01782715f, -0.13610077f, 0.06820784f, 0.05161346f, 
    0.01787787f, 0.09128984f, -0.16384675f, 0.01680406f, 0.07544307f, 0.19816799f, 0.12972751f, 0.01850875f, 
    -0.04602027f, 0.10365414f, -0.16747491f, 0.12638351f, -0.07423192f, 0.01755946f, -0.03980014f, -0.00971071f, 
    -0.06928905f, 0.02519861f, -0.13297987f, 0.05273943f, 0.00768587f, 0.15658511f, -0.30005383f, -0.05270575f, 
    0.11467811f, -0.36196315f, 0.48256689f, -0.16012944f, -0.04027436f, -0.00057187f, -0.31609789f, 0.10517689f, 
    0.01987628f, 0.15494837f, 0.02228530f, 0.07170960f, 0.28023157f, -0.03034272f, -0.13827857f, 0.13618194f, 
    0.13081545f, 0.01533314f, -0.05186079f, 0.04305224f, -0.03320146f, 0.02213202f, -0.06574675f, -0.01734853f, 
    -0.11577657f, 0.07881886f, 0.11869243f, 0.14865118f, 0.05113116f, -0.00868791f, 0.00659280f, 0.00710595f, 
    0.00421641f, 0.05405465f, -0.05078746f, -0.08877034f, 0.40147758f, 0.11243621f, 0.32433346f, -0.11826845f, 
    0.08684092f, -0.15058784f, -0.01314413f, -0.00332166f, -0.07718366f, 0.15963796f, 0.07278643f, -0.02743600f, 
    -0.07954587f, 0.05566505f, 0.03070187f, -0.00395750f, -0.07449838f, -0.13961042f, -0.01473176f, 0.04287833f, 
    0.07328560f, -0.01810376f, 0.12350181f, 0.00255486f, 0.16489568f, 0.97266167f, -0.10463193f, 0.17937623f, 
    -0.25885749f, -0.30014378f, -0.05074260f, -0.02262206f, -0.04505979f, -0.06324138f, 0.15531510f, 0.03311613f, 
    0.30599090f, 0.04020065f, 0.30087307f, 0.09363892f, -0.09793870f, 0.01729923f, -0.26017365f, 0.04139695f, 
    -0.07432846f, -0.12360755f, 0.17395896f, -0.15573868f, 0.01914513f, 0.05803480f, 0.11669154f, 0.00014527f, 
    -0.00995009f, 0.21934104f, -0.06891277f, -0.16436376f, 0.14667024f, 0.03231348f, 0.25795323f, -0.36833224f, 
    -0.02742451f, -0.23964155f, -0.13667867f, 0.05811049f, -0.02007967f, -0.07746062f, 0.12777205f, 0.08818624f, 
    -0.03308496f, -0.16699645f, 0.03832183f, 0.00524106f, 0.41598740f, 0.04923384f, -0.02379484f, 0.09374202f, 
    0.10690586f, -0.01734615f, -0.00784286f, -0.00652841f, 0.13025378f, 0.03250789f, -0.00362017f, -0.02421617f, 
    0.09017914f, 0.20085050f, -0.01386413f, 0.27587226f, 0.41737443f, 0.08197426f, -0.16818635f, 0.23483908f, 
    0.03838694f, 0.08442941f, 0.09608333f, 0.06933130f, 0.30166155f, 0.21335880f, 0.33355576f, 0.11183062f, 
    -0.20564446f, -0.13067465f, -0.20515212f, -0.01369272f, -0.05186051f, 0.08764458f, -0.04032661f, -0.02810216f, 
    -0.11656991f, -0.07863601f, -0.03940936f, -0.07101497f, 0.22497937f, -0.13138703f, -0.17139941f, 0.05138643f, 
    -0.05732916f, 0.16101861f, 0.06033345f, -0.09183519f, 0.06699553f, 0.26034868f, 0.51539671f, 0.27730760f, 
    -0.04331238f, -0.22155350f, -0.20542867f, -0.10834688f, -0.02537291f, -0.00408408f, -0.02778058f, 0.07602794f, 
    -0.08252708f, -0.06755839f, -0.10942159f, 0.05037284f, 0.12085209f, 0.06957373f, 0.13074352f, 0.11206684f, 
    0.02585713f, 0.09890686f, 0.08895899f, 0.00504918f, -0.07715881f, 0.13884771f, 0.01352307f, -0.17531696f, 
    -0.12306996f, -0.07013159f, -0.07578697f, -0.04930176f, -0.18140230f, -0.03622742f, -0.32242692f, -0.11718281f, 
    -0.13257213f, 0.28872019f, -0.03788204f, 0.09608859f, 0.02381245f, 0.06758513f, -0.04573707f, 0.03267679f, 
    -0.05674540f, 0.36444300f, 0.00146786f, 0.31935564f, -0.14037362f, -0.07426209f, 0.05098848f, -0.03718491f, 
    -0.12216278f, -0.04174358f, 0.05651766f, 0.06434063f, 0.11864614f, 0.05521030f, 0.06081291f, 0.05623448f, 
    0.23179720f, 0.24961343f, -0.18964562f, -0.02212533f, 0.11939681f, -0.00476204f, 0.15407208f, -0.03164715f, 
    -0.01727623f, 0.04133273f, -0.25992504f, -0.17479546f, 0.51668012f, -0.07603434f, -0.01789270f, 0.07313698f, 
    0.03285972f, 0.30350250f, -0.10442269f, 0.24589776f, 0.04187394f, 0.01680070f, -0.02183431f, 0.10441664f, 
    0.48389015f, -0.23644136f, 0.03668828f, 0.16480918f, 0.05495567f, 0.18223529f, 0.09974574f, 0.06609318f, 
    -0.16769294f, 0.12682001f, 0.05010080f, -0.10080115f, -0.08610748f, 0.06928501f, 0.12199351f, -0.14852580f, 
    -0.05664724f, -0.01833654f, -0.03249731f, 0.00116201f, -0.10770842f, 0.08108524f, -0.15337884f, -0.09041583f, 
    0.04848440f, -0.18567520f, -0.16833055f, 0.13180085f, -0.03146225f, 0.08455419f, 0.04615973f, -0.07574044f, 
    -0.01903475f, 0.00293479f, 0.22513258f, 0.01002019f, 0.03496835f, -0.08551453f, -0.37330616f, -0.32087922f, 
    0.02524552f, 0.05475433f, 0.03211218f, 0.02916595f, -0.07873774f, -0.06252275f, 0.14120182f, -0.01189271f, 
    -0.29086325f, -0.04821066f, 0.00801930f, 0.15730655f, -0.13013278f, 0.00112083f, 0.16905768f, -0.05986753f, 
    0.05088906f, 0.16030101f, -0.01703748f, 0.15239652f, -0.10784459f, -0.27540717f, -0.25823930f, -0.11687501f, 
    0.13526970f, 0.07746968f, -0.00597196f, -0.07440328f, -0.01058463f, -0.02789131f, -0.05280568f, -0.21862540f, 
    -0.27341989f, 0.00741052f, 0.25750229f, -0.24338947f, -0.15542805f, -0.13109709f, -0.14227372f, -0.08726725f, 
    -0.11398091f, -0.10545124f, 0.02038485f, 0.03154672f, 0.13028683f, -0.01135174f, -0.04189726f, -0.16238897f, 
    -0.12828864f, -0.08284983f, 0.00480712f, -0.15322128f, 0.14379887f, 0.08333733f, 0.23371865f, 0.08322416f, 
    0.07324831f, -0.05457152f, -0.06017094f, -0.02994761f, 0.01426068f, -0.00511979f, 0.04660701f, -0.00328538f, 
    0.00999390f, 0.10993748f, 0.14776367f, 0.14092149f, -0.05054300f, -0.15400745f, -0.08598930f, 0.08419202f, 
    0.05248117f, 0.10640363f, -0.02998896f, -0.00908930f, -0.07209176f, -0.17194790f, -0.13954939f, -0.04610531f, 
    -0.01703533f, -0.01307068f, -0.12085159f, 0.06156469f, 0.15327740f, 0.06842500f, 0.19382973f, 0.06532104f, 
    0.13731353f, 0.06704503f, 0.10002408f, 0.14451151f, -0.16667232f, 0.14702663f, 0.10921216f, 0.10315225f, 
    -0.08595574f, 0.04015018f, -0.11309981f, 0.00714052f, -0.01209259f, 0.11646583f, -0.25084695f, -0.08935363f, 
    -0.22740836f, -0.35604873f, 0.67703843f, 0.05893065f, -0.23077928f, -0.15143248f, 0.00400782f, 0.27690479f, 
    0.01020881f, 0.03816625f, -0.12186237f, 0.13836545f, 0.39686167f, 0.11916385f, 0.00672548f, -0.02758236f, 
    0.20080762f, 0.04287715f, 0.03984579f, 0.14352036f, 0.13588782f, 0.05105821f, -0.04300006f, 0.02116631f, 
    -0.00351295f, 0.02793833f, -0.18543984f, 0.04422946f, -0.05312786f, 0.04008959f, 0.01466025f, 0.13057360f, 
    0.03371649f, 0.08977310f, 0.04021643f, -0.04893043f, 0.25541252f, 0.23522750f, 0.10977330f, -0.08916128f, 
    0.19760257f, -0.18515769f, 0.14063013f, -0.05096322f, 0.00700850f, 0.10984389f, 0.17339191f, 0.13113697f, 
    0.01064866f, 0.10328907f, -0.13202046f, -0.21502662f, -0.07949783f, -0.07614922f, 0.03777586f, -0.01180290f, 
    0.14645150f, 0.18875919f, 0.20322956f, 0.21188541f, 0.18289153f, 0.64602143f, -0.16873594f, -0.00507140f, 
    -0.25468358f, -0.21042493f, -0.02807008f, -0.21043532f, 0.06014210f, 0.04280161f, 0.24682912f, 0.02427365f, 
    -0.03133128f, -0.14091165f, 0.33240646f, 0.11231506f, -0.16289105f, -0.04664059f, -0.16587783f, 0.08491112f, 
    -0.11880425f, -0.14336564f, -0.02346893f, -0.03485718f, -0.17404102f, -0.13891865f, 0.14173834f, 0.41498202f, 
    0.04128866f, 0.10124907f, -0.06641480f, 0.06430567f, 0.06832441f, 0.19474360f, -0.11984107f, -0.15787740f, 
    0.09278829f, -0.00905536f, -0.48883301f, -0.03262511f, 0.02320295f, -0.03449744f, 0.07363830f, 0.11696584f, 
    0.07391385f, 0.04874145f, -0.08638103f, 0.01693194f, 0.31021678f, 0.16309994f, -0.05883919f, -0.05704227f, 
    0.03096360f, 0.10458523f, 0.00302883f, -0.10835148f, 0.12775534f, 0.08333849f, -0.02051454f, 0.03330558f, 
    0.11283710f, -0.02360647f, 0.22128710f, 0.01838623f, 0.06380206f, 0.06352652f, -0.16838627f, 0.29521030f, 
    0.13127713f, 0.13442029f, 0.09044509f, 0.16063115f, -0.14330032f, 0.33091033f, 0.34162316f, 0.07121938f, 
    -0.14004174f, -0.16371454f, -0.13076249f, 0.02529898f, -0.13126008f, 0.11876575f, 0.02233742f, 0.13669121f, 
    0.15511411f, 0.06606363f, -0.06133359f, -0.34649476f, 0.31361878f, 0.05662336f, 0.02153631f, 0.00332856f, 
    -0.10887159f, 0.05133435f, -0.13744433f, -0.02306476f, -0.23029703f, 0.40870944f, 0.30286440f, 0.13932423f, 
    -0.06482837f, -0.01253398f, -0.20974813f, -0.13365284f, -0.13288403f, 0.03656193f, 0.03203834f, 0.17960644f, 
    -0.00730670f, 0.03835875f, 0.02996087f, -0.05025663f, 0.03479533f, -0.03356703f, 0.03557864f, -0.02132421f, 
    -0.05301207f, -0.04593583f, 0.00744448f, -0.05404146f, -0.01504355f, 0.01294605f, -0.00633247f, -0.03237352f, 
    -0.01975640f, -0.01772919f, -0.02099466f, -0.02820131f, 0.02974923f, -0.00614476f, -0.05504574f, -0.00601915f, 
    -0.04450361f, 0.04474250f, 0.00130954f, -0.05095177f, -0.04299839f, -0.04830425f, -0.01034553f, -0.01355678f, 
    0.01592348f, 0.01898196f, -0.03840985f, 0.02787066f, 0.03265203f, -0.04608955f, -0.02262928f, 0.03564755f, 
    -0.03908880f, -0.03345952f, -0.03638930f, -0.01424300f, 0.03457949f, -0.00316609f, -0.03943618f, -0.00793850f, 
    -0.00884691f, -0.01879295f, -0.00622252f, -0.01746331f, 0.04740679f, 0.00977238f, 0.02042099f, -0.00236784f, 
    -0.02981385f, 0.00406366f, -0.03568492f, -0.01333014f, -0.02467834f, -0.04756917f, -0.02536265f, -0.03982635f, 
    -0.04759525f, -0.02373211f, 0.03775519f, -0.03840157f, -0.05163058f, 0.02084051f, 0.02471711f, -0.02273752f, 
    -0.04048800f, -0.00083058f, 0.03384637f, 0.01542357f, -0.03962695f, -0.03987643f, -0.03199482f, -0.03567129f, 
    0.01104062f, -0.03396441f, 0.02476814f, -0.04489561f, 0.02235833f, 0.03151327f, 0.01049781f, 0.03527043f, 
    -0.02934578f, -0.03486919f, -0.04990619f, 0.02114412f, 0.00218504f, 0.04139359f, -0.03434996f, 0.01360893f, 
    0.02520210f, -0.01127219f, 0.00717615f, 0.01198693f, -0.01641899f, -0.03897185f, -0.02558927f, 0.01089079f, 
    0.03106830f, -0.04790495f, 0.03131761f, 0.01795017f, 0.01809988f, 0.00171684f, 0.04486391f, 0.01276938f, 
    0.01322359f, -0.03749012f, 0.03029007f, 0.03642277f, -0.03774654f, -0.05547810f, -0.02541169f, 0.03495295f, 
    -0.02879519f, 0.03891581f, -0.03352064f, -0.05489632f, 0.02945417f, -0.01666509f, -0.04706168f, -0.00906043f, 
    0.03878920f, -0.05398675f, 0.03605308f, 0.00264418f, 0.03665086f, -0.00932081f, -0.01085969f, 0.03840217f, 
    0.01092780f, -0.03513721f, 0.01312480f, -0.01348141f, -0.02862272f, 0.02062361f, 0.00300169f, -0.03307945f, 
    0.04677638f, 0.02436002f, -0.01269789f, -0.01331991f, -0.03078143f, -0.04870508f, 0.00967944f, -0.03144231f, 
    -0.00229781f, -0.00129357f, -0.04969934f, -0.00811447f, -0.01956888f, 0.03018447f, 0.02027852f, -0.04945337f, 
    0.05047043f, 0.02415888f, -0.05461419f, 0.02345678f, -0.00481045f, 0.04249592f, -0.02399074f, -0.04447120f, 
    -0.03773192f, 0.00478946f, -0.02027896f, -0.04067812f, 0.00142254f, 0.03944855f, -0.01199424f, 0.01073741f, 
    0.03230101f, 0.01161083f, -0.05349519f, 0.01713611f, 0.03141285f, -0.03401283f, -0.02523859f, 0.01160974f, 
    -0.03544318f, -0.00543293f, -0.03089759f, -0.04979697f, -0.03409568f, -0.00189026f, -0.00655500f, -0.05107020f, 
    0.01629462f, -0.02426924f, 0.04404956f, -0.04048663f, -0.00289449f, 0.03859717f, 0.04810693f, -0.02625083f, 
    -0.02851253f, 0.01707267f, -0.00881294f, -0.04325209f, -0.02498770f, -0.02940927f, -0.04304267f, -0.04257319f, 
    0.03005670f, 0.01545785f, -0.02712999f, 0.00774100f, 0.02306410f, -0.04674156f, -0.01221452f, 0.01835549f, 
    0.02899247f, 0.01036519f, -0.00098114f, -0.04489682f, 0.01490056f, -0.03576695f, -0.04491885f, 0.03445274f, 
    -0.00518260f, 0.01799790f, -0.02098325f, -0.04942010f, 0.02812265f, 0.01420796f, 0.03551820f, -0.04820283f, 
    0.00609958f, -0.00961641f, -0.01709535f, 0.00248294f, 0.01841880f, -0.02279247f, 0.00524302f, 0.01685552f, 
    -0.00217456f, 0.02185524f, 0.01327487f, -0.02942702f, -0.03010828f, -0.05584428f, 0.00544340f, -0.02849570f, 
    0.00152567f, 0.02760866f, 0.03146543f, -0.02873288f, 0.04295710f, -0.00651920f, 0.01987127f, 0.02472471f, 
    -0.00581460f, -0.03404823f, -0.03040601f, -0.01798172f, 0.03651965f, 0.01661897f, -0.00513964f, 0.02671180f, 
    0.01538488f, -0.04654468f, -0.02957072f, -0.00302453f, 0.02541333f, -0.02993111f, -0.02270015f, 0.03276643f, 
    -0.03335883f, 0.03267523f, 0.00812935f, 0.02492133f, 0.04047067f, -0.05191289f, -0.01342209f, -0.00503212f, 
    -0.02343947f, 0.03836169f, -0.00751301f, 0.00424549f, -0.02483052f, -0.02612217f, -0.00450980f, -0.01172386f, 
    0.03113246f, -0.02973640f, -0.01875595f, 0.02994660f, 0.00469003f, -0.04928417f, 0.01798023f, 0.03695722f, 
    0.02956566f, -0.02849253f, -0.02173926f, -0.03913798f, 0.04457154f, -0.02617609f, 0.02825159f, -0.00281097f, 
    0.03711284f, -0.01310673f, 0.00508214f, 0.00383765f, 0.04030854f, -0.05415685f, -0.03331047f, -0.01659707f, 
    -0.04167685f, -0.02522085f, 0.01586537f, -0.01822954f, -0.00701186f, 0.02271652f, 0.02555168f, 0.00237248f, 
    0.00958429f, -0.01454724f, 0.00324214f, -0.01334723f, -0.03680722f, 0.00181575f, -0.03001868f, -0.00474868f, 
    0.01865520f, -0.02282360f, 0.02733854f, -0.00577188f, -0.05234045f, -0.03116601f, -0.00510303f, -0.01830947f, 
    -0.01763673f, 0.01952902f, -0.00973568f, -0.00958078f, -0.00342374f, 0.04113518f, 0.01388895f, -0.01431034f, 
    -0.01575039f, -0.02696229f, -0.00351679f, -0.05141815f, -0.05384594f, -0.04844994f, 0.02691141f, -0.01219782f, 
    -0.00610181f, -0.00541870f, 0.03621326f, 0.04496092f, -0.02009035f, 0.01579467f, -0.01695097f, 0.04135801f, 
    -0.01003657f, -0.04859770f, -0.04173701f, -0.01971219f, 0.03393704f, -0.03171274f, 0.00898888f, -0.05016800f, 
    -0.03708236f, -0.01180168f, -0.00056452f, -0.04521662f, 0.01403969f, 0.04036278f, 0.00062863f, -0.03217923f, 
    -0.03748390f, 0.00361215f, -0.03234941f, 0.02373070f, -0.01176252f, 0.01060829f, -0.01657929f, 0.02999073f, 
    0.00594456f, 0.07523398f, 0.01985560f, -0.02409282f, 0.14006029f, 0.18592297f, 0.12120835f, 0.01085234f, 
    0.07121381f, 0.01179218f, -0.02659960f, 0.04987365f, 0.08605912f, 0.02613053f, 0.10281844f, 0.10515616f, 
    0.10513291f, -0.08960636f, 0.01079647f, -0.03113115f, 0.13753498f, 0.04500162f, 0.14230196f, -0.01644930f, 
    0.61896586f, -0.24512251f, -0.03811279f, 0.02867929f, -0.05186184f, 0.19674613f, -0.01884444f, 0.02540861f, 
    0.22552647f, 0.00942263f, 0.15110205f, 0.06709892f, -0.00098203f, 0.03881219f, -0.13376077f, 0.00190668f, 
    0.09158523f, -0.00452494f, 0.01647747f, -0.06047468f, -0.01826660f, 0.03827943f, -0.07128615f, 0.22245452f, 
    -0.18574575f, 0.25756097f, 0.32372162f, -0.23662984f, 0.09264217f, 0.00477269f, 0.04605095f, 0.29715234f, 
    -0.01284240f, -0.21379155f, 0.12089450f, 0.05561758f, -0.67878193f, -0.16173656f, -0.31850064f, -0.10878882f, 
    -0.01380168f, 0.25828406f, -0.01471934f, 0.03320574f, -0.10241181f, 0.08293654f, -0.13472854f, 0.07058030f, 
    -0.64714718f, 0.33056048f, -0.42526445f, -0.05728988f, 0.02992701f, 0.07259385f, -0.10469559f, 0.18435065f, 
    0.09579507f, 0.00672818f, -0.01403760f, 0.23944721f, 0.12149430f, 0.25765234f, 0.17662562f, -0.07713210f, 
    -0.06597225f, -0.05356175f, -0.15094937f, 0.04559137f, 0.09924240f, 0.03072032f, 0.21381120f, -0.02475565f, 
    0.05219491f, 0.20943584f, 0.16630483f, -0.05828889f, 0.17649066f, 0.10589464f, 0.05935420f, -0.07332253f, 
    0.06393286f, 0.09108475f, -0.09569617f, 0.11793407f, 0.24721940f, -0.20688286f, 0.13430792f, -0.43203777f, 
    -0.04109761f, 0.03811450f, -0.00843103f, 0.08371111f, 0.20076667f, -0.03708357f, -0.09770509f, -0.10074644f, 
    0.30069312f, 0.09670312f, -0.03457766f, -0.10545760f, 0.02473037f, -0.00365592f, 0.19204144f, 0.11753798f, 
    0.28616560f, 0.07650145f, 0.10993427f, -0.08938663f, 0.14253123f, -0.21598309f, 0.04158989f, -0.29624978f, 
    -0.10254047f, 0.05717086f, -0.04552143f, 0.09458436f, 0.19530597f, 0.08588578f, 0.08707193f, -0.00595190f, 
    0.03685625f, -0.10867541f, -0.36721957f, 0.00909570f, 0.04211763f, 0.12100615f, 0.21291323f, 0.46784061f, 
    -0.00292219f, 0.05782177f, 0.11314683f, 0.00854095f, 0.11255336f, 0.17656583f, 0.19172896f, -0.01776451f, 
    -0.04441376f, -0.08880170f, -0.10843347f, -0.07039484f, -0.07080777f, -0.12265600f, 0.05899540f, -0.00293861f, 
    0.03805051f, 0.00007225f, 0.05836904f, -0.00910068f, 0.03262654f, -0.11510571f, -0.02182438f, 0.00939778f, 
    -0.00790171f, -0.04026967f, -0.07561935f, -0.07055432f, 0.15561028f, 0.19449572f, -0.12806836f, -0.14461334f, 
    -0.05569821f, 0.10079835f, -0.01092404f, 0.20329189f, -0.05026483f, -0.19219689f, -0.01293429f, -0.00405511f, 
    0.00721515f, -0.07853404f, -0.11656697f, 0.20168717f, 0.05005733f, 0.02368382f, -0.15140478f, 0.00797378f, 
    0.02886244f, -0.11118455f, 0.04902937f, -0.10290066f, 0.20135781f, 0.05428470f, 0.12426248f, 0.01773642f, 
    0.00739700f, -0.04696709f, -0.06405420f, -0.03100185f, 0.09078120f, 0.23783785f, 0.08450592f, -0.01667573f, 
    -0.06474188f, 0.45411950f, -0.55746585f, 0.22387271f, 0.16537519f, 0.21815914f, 0.05095727f, -0.00757160f, 
    0.01454479f, -0.04061075f, 0.07148534f, 0.16910307f, -0.23234724f, 0.12571758f, -0.10524002f, 0.31045553f, 
    0.01333343f, 0.16540976f, 0.04429311f, 0.09198491f, 0.05336815f, 0.02293232f, -0.03659841f, 0.14268923f, 
    0.05217852f, 0.14788926f, 0.36077294f, -0.17084725f, 0.01082223f, -0.03659463f, 0.01873977f, 0.05738996f, 
    0.01843496f, 0.01100745f, 0.04364564f, 0.03562298f, -0.04613092f, -0.06967741f, -0.14294551f, 0.34644449f, 
    -0.05774371f, 0.08174971f, -0.16781555f, -0.13630700f, -0.03737677f, 0.04509703f, 0.03550669f, 0.04048011f, 
    0.08236002f, 0.13026609f, 0.15854914f, 0.07551062f, -0.05040470f, -0.01314397f, -0.08258582f, -0.05110776f, 
    0.05377574f, -0.02604709f, 0.03658663f, 0.06789733f, 0.30552271f, -0.19728398f, 0.28073102f, -0.20974021f, 
    0.09204701f, -0.09398786f, 0.00684907f, 0.03498956f, 0.05244282f, -0.00986186f, -0.13188410f, 0.07933526f, 
    0.09677269f, 0.21950510f, -0.14772238f, 0.22204307f, 0.01778872f, -0.01180869f, 0.10401721f, -0.10093784f, 
    0.08392657f, 0.24171685f, 0.14754099f, -0.03900214f, 0.61079460f, 0.13132615f, -0.32817572f, -0.10247673f, 
    0.08103185f, 0.25817314f, 0.09679051f, 0.06553432f, 0.07917219f, 0.12684241f, 0.08743403f, 0.08251701f, 
    0.12018301f, 0.02135445f, 0.28241551f, -0.15214248f, 0.09495635f, 0.06062292f, 0.10868541f, 0.01878472f, 
    0.21379575f, 0.07127604f, -0.01631135f, -0.00783215f, 0.17624463f, 0.27204537f, -0.21819022f, 0.24653991f, 
    -0.05350154f, -0.11823081f, 0.09350925f, 0.07059713f, 0.00478581f, 0.18327174f, 0.06901671f, 0.10747866f, 
    0.10148257f, 0.01543630f, 0.14321534f, -0.16240115f, -0.06197248f, -0.12118006f, 0.31752259f, 0.29412049f, 
    0.07992122f, 0.09882386f, 0.08924402f, -0.06351922f, 0.27395391f, 0.23151684f, 0.07390829f, 0.07685218f, 
    -0.03457835f, -0.01680806f, 0.00985404f, -0.02324943f, 0.18054649f, -0.04976638f, 0.00643119f, 0.02488200f, 
    -0.06454790f, -0.23528121f, 0.07268333f, 0.04518209f, 0.08972040f, -0.01494372f, -0.01881658f, 0.07147888f, 
    0.03207735f, -0.04498579f, -0.05345686f, 0.08251308f, 0.33994994f, 0.09448045f, 0.11029741f, 0.06423477f, 
    0.08451045f, -0.02887703f, -0.05609208f, -0.03266049f, 0.06721570f, 0.06729486f, 0.01684347f, 0.04928324f, 
    0.06220244f, 0.00747032f, 0.04758108f, 0.15373525f, 0.11872110f, 0.17187881f, 0.13810319f, 0.20763752f, 
    -0.04951871f, 0.05536728f, 0.02018944f, 0.07133334f, -0.03869486f, 0.05881358f, 0.13487411f, 0.04458548f, 
    -0.01525255f, -0.07773483f, -0.09082110f, -0.07390624f, 0.09860872f, 0.18175559f, 0.05049993f, -0.00926398f, 
    0.07948931f, 0.12496047f, 0.07725678f, 0.10187533f, 0.11591163f, -0.14157933f, -0.04046958f, 0.09260891f, 
    0.07339825f, 0.25720817f, 0.30407479f, 0.34352300f, -0.14909665f, -0.04951907f, -0.03500749f, -0.03069857f, 
    -0.09480598f, -0.08852901f, 0.02502080f, -0.04851784f, 0.12228061f, 0.20052971f, 0.01109639f, 0.09424000f, 
    0.22406827f, 0.27054837f, -0.15790051f, -0.25723684f, 0.18018740f, 0.02627286f, 0.13991170f, 0.01666954f, 
    -0.18099964f, -0.08823733f, -0.06272174f, 0.04020071f, 0.11797949f, -0.20059650f, -0.14576879f, -0.34467146f, 
    0.15902051f, 0.20896126f, -0.13231586f, 0.08063931f, -0.00945461f, 0.20833035f, -0.11141720f, 0.09040397f, 
    0.15146750f, 0.05806173f, -0.36659735f, -0.09685151f, 0.08628018f, -0.09454583f, 0.07665370f, -0.05009711f, 
    0.01875351f, 0.10957374f, -0.02260724f, -0.07264563f, 0.19140713f, 0.10405847f, 0.09808171f, -0.08844537f, 
    -0.09109212f, -0.00357602f, -0.01744213f, -0.05365900f, -0.05966660f, -0.04093560f, 0.11800630f, -0.19336616f, 
    0.01444177f, 0.17583109f, 0.08570207f, 0.05395010f, 0.01507794f, 0.15307114f, -0.04297656f, -0.00541750f, 
    0.07453375f, 0.04379281f, 0.13057981f, 0.10673197f, 0.08701786f, -0.09280274f, -0.20110589f, -0.20138906f, 
    0.00751987f, 0.04335789f, -0.04987799f, 0.06820241f, -0.09747929f, -0.05354288f, 0.05500979f, -0.06226964f, 
    0.10928252f, -0.10026945f, 0.00878612f, -0.08885503f, -0.02294292f, -0.05651934f, 0.02683881f, 0.00696275f, 
    0.30534232f, 0.25717744f, 0.08918718f, -0.05224843f, 0.02811042f, -0.29370755f, -0.28754246f, -0.29159257f, 
    0.02131171f, -0.01272115f, -0.10585370f, -0.09982990f, -0.03233335f, -0.11154842f, -0.07319376f, -0.29141587f, 
    -0.06534196f, 0.07741064f, -0.04813652f, -0.00167313f, -0.02474593f, 0.24990781f, 0.19607814f, 0.01136538f, 
    -0.08175755f, -0.10808145f, -0.01584769f, -0.01199209f, 0.01999682f, 0.05000484f, 0.10709825f, 0.04850581f, 
    -0.07177594f, -0.06052966f, -0.11334839f, -0.15287329f, 0.11236873f, 0.07719260f, 0.17840974f, 0.02820954f, 
    -0.06815381f, -0.02868896f, 0.00740645f, -0.05777771f, -0.10574549f, 0.03189604f, -0.00233349f, -0.06523153f, 
    0.10044466f, 0.06169653f, 0.11970977f, 0.03162372f, 0.15509732f, -0.13839969f, -0.07017260f, -0.19549042f, 
    0.07160008f, -0.08061612f, -0.08427346f, 0.04739741f, -0.19405410f, -0.07852286f, -0.05064289f, -0.02165717f, 
    0.01446697f, -0.10311527f, 0.05269450f, 0.00909998f, 0.04222721f, 0.12100585f, 0.05024913f, -0.02077697f, 
    0.14719322f, 0.01502290f, 0.08575550f, 0.16706480f, 0.09056421f, -0.09224376f, 0.32028079f, 0.32463917f, 
    -0.03097801f, 0.02177095f, -0.08741387f, -0.00588777f, 0.03836995f, 0.04974690f, -0.20685989f, -0.25902864f, 
    -0.10357720f, -0.12598458f, 0.28120649f, 0.05929390f, 0.05205853f, -0.00572009f, 0.16526309f, 0.27355638f, 
    -0.10792670f, 0.01209370f, -0.14198366f, 0.21005271f, 0.12336253f, -0.02288521f, 0.10609740f, -0.11013988f, 
    0.12925622f, 0.17549400f, -0.02112204f, 0.10632703f, 0.01045832f, 0.09065692f, -0.05063299f, 0.01616731f, 
    0.10350549f, 0.18941820f, 0.09467292f, -0.03089107f, -0.00484478f, 0.03638975f, -0.05914424f, 0.09026653f, 
    0.19764504f, 0.00840782f, 0.02040274f, -0.02426095f, 0.04302233f, 0.23376852f, 0.09813690f, -0.01616933f, 
    0.20514584f, -0.02921919f, 0.08783877f, -0.02385479f, -0.01190393f, 0.05272558f, 0.09631301f, 0.09090428f, 
    0.03830897f, 0.07445937f, 0.03280592f, -0.01620366f, -0.08915804f, -0.09862676f, -0.04165716f, -0.15209806f, 
    0.09521146f, 0.11966398f, 0.21972315f, 0.23381922f, 0.18978092f, 0.38863251f, 0.00446719f, 0.10828026f, 
    -0.31739256f, -0.05150978f, 0.04004063f, -0.16340268f, 0.03091753f, 0.01440782f, 0.01965133f, 0.12040745f, 
    0.12440436f, 0.08376938f, 0.08986708f, 0.18817277f, -0.18336442f, -0.10490175f, 0.04572024f, 0.17968293f, 
    -0.11564308f, -0.05447049f, -0.00177037f, -0.07778832f, 0.32444867f, -0.12632237f, -0.20101871f, 0.28508481f, 
    0.03916697f, 0.02154502f, -0.04673142f, 0.29178810f, 0.25644448f, -0.04861521f, -0.23150128f, -0.20153446f, 
    -0.06861433f, 0.17505680f, -0.23909222f, 0.07734663f, 0.03798212f, -0.05890705f, 0.18877982f, 0.05999243f, 
    0.02026166f, 0.07591414f, -0.23936005f, -0.10359216f, -0.24434994f, 0.02474256f, 0.24147277f, 0.04061007f, 
    -0.07816274f, 0.14599395f, -0.09113674f, 0.02679691f, 0.15697514f, 0.03496621f, 0.06805686f, 0.11404521f, 
    -0.10534342f, -0.10277388f, 0.11018040f, -0.18235332f, -0.09626915f, 0.16710596f, -0.06995162f, 0.28557643f, 
    0.13803633f, -0.03609579f, 0.08442806f, 0.24273315f, 0.37787256f, 0.29814255f, 0.11058851f, 0.19308314f, 
    -0.15998106f, -0.06437705f, -0.00275572f, 0.01171553f, 0.02096026f, 0.07124637f, 0.03750152f, 0.08625859f, 
    -0.17047735f, 0.03985078f, 0.11010932f, -0.12026769f, 0.08459969f, -0.02895704f, -0.06731828f, 0.08067988f, 
    -0.10055926f, 0.05076473f, -0.24445356f, -0.23252520f, 0.18228996f, 0.24925117f, 0.22825392f, 0.25507978f, 
    -0.08309866f, -0.01105860f, -0.09829836f, -0.10884354f, -0.07471491f, 0.02626486f, 0.04698813f, 0.11217412f, 
    0.30049446f, 0.26390347f, -0.00943777f, 0.08865635f, 0.12419698f, 0.09172317f, 0.04655180f, 0.13514492f, 
    -0.08873206f, -0.13367805f, -0.12625366f, -0.04803542f, -0.16311938f, -0.25316450f, 0.00872023f, 0.23371142f, 
    0.02283278f, 0.05873232f, -0.02607334f, -0.17451945f, 0.13135469f, 0.13680308f, 0.21253720f, 0.15280628f, 
    -0.08530644f, -0.31053683f, 0.16708183f, -0.11981696f, -0.01466666f, -0.11432932f, -0.19327956f, -0.16477948f, 
    -0.00007796f, -0.04419551f, -0.10953749f, -0.11668083f, -0.22445771f, -0.03665922f, -0.05772376f, 0.02204758f, 
    -0.03985819f, 0.00133727f, 0.12083602f, 0.03484659f, 0.06333819f, 0.11674858f, 0.13361596f, 0.05546916f, 
    0.32430968f, 0.04685183f, 0.06979220f, -0.09230182f, -0.02953328f, 0.21242526f, 0.14681908f, 0.05828796f, 
    0.14330326f, 0.07736602f, -0.01858645f, 0.23394895f, -0.30608258f, -0.17997639f, -0.43429691f, -0.42987716f, 
    0.04514609f, 0.04971136f, -0.07509220f, 0.12390276f, -0.07207785f, 0.07282827f, 0.06475158f, 0.12304913f, 
    -0.13096978f, 0.23939940f, -0.38865080f, -0.16132116f, -0.04924455f, -0.06856700f, -0.01638582f, -0.14916043f, 
    0.14444809f, -0.06033907f, 0.06112846f, 0.22109754f, -0.04812641f, -0.17826095f, -0.06235723f, -0.16608296f, 
    -0.09942748f, 0.14082140f, 0.05823094f, -0.19213569f, 0.14610088f, 0.01696656f, 0.11697104f, 0.16553910f, 
    0.30438659f, 0.44447184f, -0.00869610f, -0.23994428f, 0.10375514f, 0.08407652f, 0.22312461f, 0.27523321f, 
    0.03659839f, -0.08066940f, 0.02967044f, -0.00168151f, 0.49893254f, 0.07331339f, 0.34856442f, 0.20827504f, 
    0.14617756f, -0.00885234f, -0.21909972f, -0.15501641f, 0.07798541f, 0.03722629f, 0.06932205f, 0.13931665f, 
    -0.30939254f, -0.15769377f, -0.24042137f, -0.45738763f, 0.20382850f, -0.09975754f, -0.21531601f, 0.02513493f, 
    0.01358179f, 0.05518380f, -0.10686252f, -0.00339065f, 0.42131409f, -0.04469691f, 0.10927448f, 0.12730978f, 
    0.10499481f, -0.01935077f, -0.11961330f, -0.26400867f, -0.06163061f, 0.01608537f, 0.13038327f, 0.20972577f, 
    0.28767759f, 0.64320123f, -0.05594886f, 0.17698592f, 0.06071712f, 0.12011652f, 0.04712640f, 0.08883440f, 
    0.06455121f, -0.02659533f, 0.01874710f, -0.08457835f, -0.23801950f, -0.20023072f, -0.02174769f, 0.32043403f, 
    0.03944070f, -0.00036184f, -0.00088170f, 0.00785184f, 0.05994780f, 0.12096362f, 0.19581421f, 0.03469384f, 
    -0.18366295f, -0.04949251f, 0.02556363f, -0.21795085f, 0.06231583f, 0.11125880f, 0.02946837f, -0.08273613f, 
    0.18711311f, -0.07781570f, -0.23242313f, -0.00732873f, 0.04665769f, -0.01832702f, 0.25637403f, -0.27269939f, 
    0.15419789f, -0.09654340f, 0.05920813f, 0.14915171f, -0.05051164f, 0.18387452f, 0.20002310f, 0.20176739f, 
    0.30734056f, 0.29100549f, 0.30967814f, -0.03691061f, 0.00380094f, -0.01448559f, 0.03847021f, 0.09212554f, 
    -0.09290272f, 0.08908141f, -0.05517010f, 0.10361126f, -0.15132181f, -0.13825095f, 0.05337111f, 0.26323393f, 
    0.04197965f, -0.00638600f, -0.08407866f, -0.18547428f, -0.12680578f, 0.05085791f, 0.07765925f, 0.05669340f, 
    -0.20365472f, 0.55834639f, -0.18548141f, 0.32516930f, 0.08125149f, 0.04601701f, -0.04060150f, 0.03947784f, 
    -0.05231011f, 0.03071629f, -0.11411197f, -0.06916872f, 0.11894856f, 0.00159057f, 0.09524646f, -0.23680189f, 
    0.09046122f, 0.07440536f, 0.02348809f, 0.18084329f, 0.06466343f, 0.00482220f, -0.03283383f, 0.09654845f, 
    0.23599024f, 0.44750702f, 0.03075736f, -0.13468356f, 0.02326425f, 0.26577958f, 0.06673817f, 0.10441095f, 
    -0.03803543f, -0.00244300f, 0.02010025f, 0.07359205f, -0.32871738f, 0.01609956f, -0.26767224f, -0.08833609f, 
    0.22472535f, 0.05383332f, 0.00587526f, -0.19891426f, 0.13275062f, 0.00801350f, -0.09877281f, -0.11799716f, 
    -0.10065277f, -0.04575084f, 0.04118983f, 0.13071558f, 0.12797622f, -0.10628148f, -0.11617380f, -0.38830572f, 
    0.00646484f, 0.03508053f, -0.11888106f, -0.15319337f, 0.01532847f, -0.27833399f, 0.24026817f, 0.08454237f, 
    0.07143006f, -0.11784780f, 0.13984060f, -0.17779271f, -0.07510093f, -0.05267045f, -0.23325728f, -0.06124242f, 
    -0.25205028f, -0.06016856f, -0.08675411f, 0.15115976f, 0.05150673f, -0.00639685f, 0.19692528f, 0.17565377f, 
    0.18595353f, 0.05858605f, 0.07429362f, 0.12443183f, -0.02463178f, -0.07799989f, -0.25981811f, 0.07357304f, 
    -0.14313443f, 0.01422105f, -0.01499136f, 0.06642327f, 0.02670916f, 0.04269857f, 0.04759924f, -0.00950921f, 
    0.41426423f, 0.21638116f, 0.21276148f, -0.08867572f, 0.13794583f, 0.07657835f, 0.06042562f, 0.05999763f, 
    -0.05744033f, -0.04809288f, 0.12087456f, 0.07897288f, -0.59323001f, -0.22519280f, 0.03584568f, 0.11179470f, 
    0.15050113f, 0.13165760f, -0.11813670f, 0.06966137f, -0.01259487f, 0.10339966f, -0.02922918f, -0.11448615f, 
    -0.21733694f, -0.12517957f, -0.22725250f, -0.26530889f, -0.13048184f, 0.15026979f, -0.20812272f, -0.14067863f, 
    0.19820471f, -0.07441750f, -0.23380585f, 0.03448054f, 0.08423471f, -0.18659830f, -0.38010558f, 0.05359463f, 
    0.11719021f, 0.07155214f, 0.01884998f, 0.10365845f, 0.05868501f, -0.14163616f, -0.10041816f, 0.03920264f, 
    -0.00697006f, 0.25184140f, 0.44204494f, 0.21131516f, 0.06901279f, -0.17086735f, -0.11727625f, -0.17381172f, 
    0.15621947f, 0.03335979f, 0.06637743f, -0.04687003f, -0.13033648f, -0.17342088f, -0.03652630f, 0.18472371f, 
    -0.07042976f, 0.16770369f, -0.13398007f, 0.17441590f, 0.04065445f, -0.02511052f, -0.00008394f, -0.01010421f, 
    0.03898907f, 0.02569080f, 0.05669569f, 0.24902934f, -0.13179253f, -0.16331410f, -0.14636025f, -0.04124617f, 
    0.03738950f, -0.03003779f, -0.08420424f, -0.05133307f, -0.04556711f, -0.22135356f, -0.30353251f, -0.25966296f, 
    -0.17416739f, -0.05513066f, -0.00337941f, -0.09719679f, 0.07472051f, 0.22815493f, 0.25607947f, -0.01160163f, 
    -0.11866455f, 0.03295214f, 0.00807332f, -0.06942417f, -0.00779461f, -0.11868796f, 0.16834868f, 0.03600756f, 
    -0.10833336f, -0.19311325f, -0.09089448f, 0.00369587f, 0.03311222f, 0.03010977f, -0.12938625f, -0.01073027f, 
    -0.00498279f, 0.06403366f, 0.05116707f, 0.13934226f, 0.09879422f, 0.06113174f, 0.23160221f, -0.02881376f, 
    0.07667823f, -0.40866858f, 0.19063377f, 0.19845301f, -0.09294523f, 0.00715378f, 0.11288973f, 0.01211843f, 
    -0.04628119f, 0.00698075f, 0.02306369f, 0.09792654f, -0.05985634f, -0.13464460f, 0.44048271f, 0.38673878f, 
    0.14842275f, -0.20700152f, 0.27844331f, -0.32809383f, 0.05766288f, 0.01389339f, 0.02812726f, -0.05939920f, 
    0.36092010f, 0.06442434f, 0.11537413f, 0.17449588f, -0.03486375f, -0.17597805f, 0.19084497f, -0.00995378f, 
    -0.06893990f, -0.18871391f, 0.04872684f, 0.04533690f, -0.06835221f, -0.35911772f, -0.30028111f, 0.05851087f, 
    0.07470406f, 0.16912434f, 0.04673771f, -0.05834233f, 0.19768769f, -0.08731218f, 0.11444369f, 0.10483253f, 
    -0.17075102f, -0.05354843f, 0.10776435f, 0.05215832f, -0.04316387f, -0.01483338f, 0.04031642f, 0.16013196f, 
    0.12281748f, 0.10713649f, -0.10415208f, 0.00149190f, -0.46070838f, -0.07327911f, 0.07981635f, 0.23594624f, 
    0.15420614f, -0.05748321f, -0.06515540f, -0.10764261f, 0.04491614f, 0.07840572f, 0.04614560f, -0.04221719f, 
    -0.23443943f, 0.20825438f, 0.02034743f, 0.15919536f, 0.07333115f, 0.12207612f, 0.02677215f, 0.07902701f, 
    -0.02931872f, -0.02441238f, 0.22995733f, 0.01389527f, -0.29026526f, 0.05499415f, 0.05562857f, 0.14882421f, 
    -0.02341140f, -0.08566933f, 0.08836309f, 0.08533343f, -0.08717527f, -0.04088470f, -0.12638479f, 0.08422474f, 
    0.04924250f, 0.09523800f, 0.33069187f, 0.62223852f, 0.28244570f, 0.17452094f, 0.03439053f, -0.13421729f, 
    0.08937950f, 0.03289727f, -0.19268267f, -0.17320076f, -0.16060303f, -0.21463946f, -0.24860775f, -0.20973584f, 
    0.14413305f, -0.02988206f, 0.02918661f, 0.15052426f, 0.08238679f, 0.18053681f, 0.01156953f, 0.13807262f, 
    0.05758660f, 0.08871158f, -0.08699946f, -0.13034256f, 0.00367951f, -0.00952647f, -0.01523989f, -0.02562444f, 
    0.10895561f, -0.01368159f, 0.02643932f, 0.05827074f, -0.01312673f, -0.02359788f, 0.03530350f, 0.21492203f, 
    0.07205809f, 0.14069366f, 0.17844918f, 0.14233582f, -0.02944292f, 0.07003069f, 0.11416095f, -0.00604383f, 
    -0.09808782f, -0.01465497f, 0.04463624f, 0.20539449f, -0.08503310f, -0.05735463f, 0.04258871f, 0.08548179f, 
    -0.01273049f, 0.32117036f, 0.12695168f, -0.06336701f, 0.22943339f, 0.17245851f, -0.13575952f, -0.15524022f, 
    0.05554372f, -0.10607740f, 0.01883493f, -0.14082307f, 0.02796171f, -0.10679751f, 0.24644168f, 0.09153435f, 
    -0.18671724f, 0.46965611f, 0.26369229f, 0.15683365f, 0.10028394f, 0.19305483f, -0.04075371f, -0.05209617f, 
    -0.20284110f, -0.04280638f, 0.11372897f, -0.10801444f, 0.00997911f, -0.44637251f, 0.18879606f, -0.02488676f, 
    -0.01461649f, -0.10065403f, 0.08065931f, 0.06470373f, -0.03568845f, 0.02074099f, 0.14401504f, 0.09621731f, 
    -0.32443509f, -0.16529818f, 0.08144071f, 0.11074845f, 0.04587350f, -0.02650516f, 0.04809323f, -0.11023945f, 
    -0.07880700f, 0.14602961f, 0.07459167f, 0.07705659f, 0.08259358f, -0.20825990f, -0.06380396f, 0.01911832f, 
    0.00586738f, 0.02085728f, 0.08390108f, 0.06225235f, -0.00115115f, 0.00578140f, -0.10442884f, -0.04469839f, 
    0.01238322f, -0.14353442f, 0.00738327f, -0.04353328f, 0.10748351f, 0.01690710f, -0.11976632f, 0.10663221f, 
    0.04819904f, -0.03170755f, 0.01039457f, -0.04991221f, 0.01881272f, 0.05103113f, 0.29357365f, 0.29168096f, 
    0.21378942f, -0.10138201f, -0.08928309f, 0.03030013f, -0.11304621f, 0.08413050f, -0.14392054f, -0.10889963f, 
    -0.02492337f, 0.21511145f, 0.15755321f, -0.21493721f, -0.02702071f, 0.06694076f, 0.10998792f, 0.02616194f, 
    0.23582093f, 0.11597426f, 0.14297114f, -0.02963003f, -0.32813874f, 0.35240102f, 0.03258257f, 0.11447844f, 
    -0.05435105f, -0.01146325f, 0.03414833f, 0.08537216f, 0.01579918f, -0.01589674f, 0.24085097f, -0.06138011f, 
    -0.13335621f, -0.03020959f, 0.14301018f, -0.00697292f, -0.03738480f, 0.09279308f, -0.23789382f, -0.00373442f, 
    0.15216592f, 0.03856560f, 0.18071440f, 0.10497037f, 0.11015259f, -0.08835371f, 0.21871836f, -0.23739202f, 
    0.09212536f, 0.06241265f, -0.09114518f, 0.04705854f, 0.04640784f, -0.11387672f, -0.13512246f, -0.06481505f, 
    -0.38145858f, 0.34428069f, -0.17214835f, 0.35781848f, 0.27423564f, -0.17514898f, 0.03258103f, -0.48170331f, 
    -0.00389155f, -0.03987245f, -0.09918138f, -0.08445347f, -0.03148292f, -0.08184344f, 0.06771680f, 0.19184291f, 
    0.00060292f, 0.16335237f, -0.15348108f, -0.10290007f, 0.00098449f, -0.14163212f, 0.07230749f, 0.05567275f, 
    0.44328657f, -0.18625547f, -0.28813997f, -0.00138668f, -0.15272905f, 0.06413911f, 0.09518971f, 0.04215057f, 
    0.07820969f, 0.07478376f, 0.21132746f, 0.21283941f, 0.19610323f, -0.15429921f, -0.18158609f, 0.04480891f, 
    -0.10800686f, -0.14052789f, 0.13792846f, 0.06277998f, 0.07938819f, 0.10891920f, 0.01171407f, -0.20352277f, 
    0.02440684f, -0.05031217f, -0.04810901f, -0.01516245f, 0.00919328f, 0.04277030f, -0.03076706f, -0.00759522f, 
    0.00942991f, 0.01648846f, -0.04663075f, -0.03359684f, -0.04650598f, -0.00525003f, 0.03463512f, -0.01652449f, 
    -0.04725444f, -0.00864180f, 0.02906576f, -0.02077951f, 0.01838189f, -0.04073513f, 0.01546428f, -0.00719250f, 
    -0.01319613f, -0.00290336f, -0.05831620f, 0.02836144f, -0.02334004f, -0.02950897f, 0.01660053f, 0.02885051f, 
    0.02241372f, 0.01753513f, 0.02590746f, 0.00761551f, 0.00009459f, -0.02041903f, -0.02620918f, -0.00125039f, 
    0.02353026f, -0.03378831f, 0.03269247f, -0.02061098f, -0.03259623f, 0.04277723f, -0.02912339f, 0.00455628f, 
    -0.03337482f, 0.02578524f, -0.05524196f, -0.02103183f, -0.04156705f, -0.00722473f, 0.03256882f, -0.05376571f, 
    0.02909909f, 0.00050186f, 0.03348486f, -0.03151549f, -0.02964140f, 0.04147891f, -0.04971021f, 0.02144733f, 
    0.04097599f, -0.04682662f, -0.02331338f, 0.02465809f, -0.05225433f, -0.01136039f, 0.00885451f, -0.05301929f, 
    0.00132487f, -0.03659836f, 0.01534924f, -0.01011801f, 0.02887111f, -0.05481053f, -0.00439979f, 0.00675766f, 
    0.00786343f, -0.03907531f, 0.00856231f, 0.04017383f, -0.01022498f, -0.05495768f, 0.02668435f, 0.02151024f, 
    0.03663755f, -0.03229314f, 0.02515159f, -0.00275349f, -0.00218386f, 0.00131667f, -0.05467685f, 0.02395290f, 
    0.04085710f, -0.02574641f, 0.00492494f, -0.03020241f, -0.04542616f, -0.03784050f, -0.03818228f, -0.05637180f, 
    -0.02421888f, -0.00902273f, -0.04627958f, 0.01585377f, -0.01949336f, -0.05427910f, -0.03828400f, -0.05407358f, 
    0.03506901f, -0.01067650f, -0.00201375f, 0.01967398f, -0.00440909f, -0.04306319f, 0.00074344f, -0.01541565f, 
    -0.05391913f, -0.02558232f, -0.04901452f, 0.02544292f, -0.00558197f, 0.02120017f, -0.03339823f, -0.03590446f, 
    0.03930340f, 0.04292363f, -0.00478890f, 0.03895241f, -0.00541194f, -0.02906199f, 0.01518954f, -0.03411990f, 
    -0.02100237f, -0.02905710f, -0.00839415f, -0.03235374f, -0.01444610f, 0.01987897f, 0.03035931f, -0.02117685f, 
    0.02939132f, 0.01595343f, 0.03100877f, 0.01103173f, -0.04016228f, -0.03473075f, 0.03840838f, 0.01433675f, 
    -0.02564377f, -0.03042787f, -0.04151058f, 0.00943716f, 0.01425376f, -0.02656292f, -0.00308911f, 0.03859533f, 
    0.00346171f, -0.02109159f, 0.00113949f, -0.01038535f, 0.02059693f, 0.00844181f, -0.05203876f, -0.01779636f, 
    -0.04214591f, 0.01490485f, -0.02591372f, 0.03273619f, 0.00174224f, 0.00919416f, 0.03209639f, 0.00860396f, 
    0.03814564f, -0.02646631f, -0.02354287f, 0.01198514f, 0.03417815f, 0.02924266f, -0.01283755f, -0.05118573f, 
    -0.03596294f, -0.05042823f, -0.02915181f, 0.01820500f, 0.01315832f, -0.00830161f, -0.05671280f, -0.03719039f, 
    -0.04861918f, 0.02083739f, -0.03017168f, 0.01694005f, -0.03294908f, -0.01371346f, 0.01534975f, -0.00897238f, 
    -0.00104805f, 0.00414215f, 0.00753159f, -0.01248389f, -0.04734417f, -0.02340728f, -0.03128394f, -0.00625969f, 
    0.01710673f, -0.01408852f, -0.04961373f, -0.00812691f, 0.03111434f, -0.01373978f, 0.01276134f, -0.01393283f, 
    0.01080588f, -0.01714827f, 0.03101935f, 0.03805388f, 0.02738485f, -0.02237914f, 0.02338371f, 0.02777131f, 
    0.00916942f, -0.04321985f, 0.03926879f, 0.02574873f, -0.04321097f, 0.02378852f, -0.03527007f, -0.03096437f, 
    0.00704576f, 0.01765758f, -0.03956929f, 0.04202022f, -0.05231329f, 0.01706427f, 0.02496001f, 0.02252902f, 
    -0.01628768f, -0.03225569f, 0.03425501f, -0.00023902f, -0.04940738f, -0.00474462f, -0.00996483f, 0.04365999f, 
    -0.02095894f, 0.00671653f, -0.03011660f, -0.04965761f, 0.03306225f, 0.03607334f, 0.03749899f, -0.01642611f, 
    -0.02875794f, -0.04996679f, -0.00381110f, -0.00152988f, 0.03470137f, 0.01080269f, -0.05508986f, -0.05704841f, 
    0.04271352f, -0.04529959f, 0.03841302f, -0.04770410f, -0.04101196f, 0.00865413f, 0.04364710f, -0.00938572f, 
    -0.03221657f, -0.03097987f, -0.04843496f, 0.02702838f, 0.00551064f, -0.02299653f, -0.02598208f, 0.00458746f, 
    -0.04497545f, -0.03073494f, 0.02684738f, -0.02469692f, -0.03540255f, 0.01093909f, 0.03013944f, 0.00810365f, 
    0.02523900f, -0.03376209f, -0.00788391f, 0.02810528f, 0.00769261f, -0.05331686f, -0.05444872f, 0.00454142f, 
    -0.00435481f, -0.00577640f, 0.01828631f, 0.02932638f, 0.02771698f, -0.05189217f, 0.02339902f, -0.03587611f, 
    0.00693770f, -0.04204569f, 0.03318820f, 0.01751621f, -0.04144094f, 0.02372829f, 0.04331076f, -0.02032539f, 
    0.04296716f, -0.02473602f, 0.00889682f, -0.05276132f, 0.04112126f, -0.00037870f, 0.00177168f, 0.03958751f, 
    0.03147044f, -0.02901265f, 0.01040483f, -0.01246639f, -0.04171399f, -0.04438356f, -0.01471556f, -0.04970799f, 
    0.01328211f, -0.02703563f, 0.02128708f, -0.01633939f, -0.02628452f, -0.04255632f, 0.02049556f, -0.01436680f, 
    0.00366048f, -0.04303360f, 0.01236581f, 0.00045346f, -0.00729538f, 0.01938747f, -0.00165834f, -0.02076036f, 
    -0.04472283f, 0.01429352f, 0.00864394f, -0.01532475f, -0.02558432f, 0.03918483f, 0.00555358f, -0.00905425f, 
    -0.03097872f, -0.01894426f, -0.01766593f, -0.03453878f, -0.01733014f, 0.04364614f, -0.04864237f, -0.04133319f, 
    0.01992827f, -0.02421935f, 0.01773748f, 0.03857693f, 0.02827974f, -0.05544066f, -0.02676972f, 0.01264328f, 
    -0.02042852f, 0.00539730f, -0.05500216f, 0.02711304f, -0.03971270f, -0.05245358f, 0.03538469f, -0.05597045f, 
    0.02903914f, -0.04902244f, -0.03907944f, -0.03377061f, -0.02259434f, -0.04587337f, -0.01926757f, -0.05638843f, 
    0.20094247f, 0.20029683f, 0.18210933f, -0.14178914f, -0.07509630f, -0.10581011f, -0.05746102f, -0.01127306f, 
    -0.07865676f, -0.14716528f, -0.06485542f, -0.12316203f, 0.02305413f, -0.03242750f, -0.04165038f, 0.11166576f, 
    0.09329865f, 0.02368452f, 0.10756154f, 0.01662917f, 0.13193180f, 0.03101913f, 0.09978538f, 0.18836442f, 
    -0.02209096f, 0.31004879f, 0.06142185f, -0.02078085f, 0.16401380f, -0.04660259f, 0.14070727f, 0.00601870f, 
    -0.07792275f, -0.00488951f, -0.01995462f, -0.09700529f, 0.10676508f, 0.04702117f, 0.01372926f, 0.00502778f, 
    0.02474119f, 0.00648963f, -0.03983458f, 0.02829964f, -0.02015667f, 0.03205212f, 0.01057740f, -0.09926312f, 
    -0.06010111f, 0.02950461f, -0.04397460f, 0.16696095f, 0.07889862f, 0.07082878f, -0.10545737f, -0.11263835f, 
    0.00037049f, 0.13114510f, 0.22601442f, 0.07051112f, 0.07458641f, 0.46968925f, 0.31242117f, -0.00707058f, 
    -0.06696510f, -0.37842810f, 0.26527706f, -0.02351872f, -0.04495011f, -0.08049218f, -0.01351976f, -0.12456534f, 
    -0.23276813f, 0.08051371f, 0.40765113f, -0.26463181f, -0.11436822f, -0.03514080f, -0.19893134f, 0.02027048f, 
    0.19316097f, 0.00049819f, 0.05413120f, 0.04207096f, 0.18916583f, 0.06006021f, -0.05035998f, 0.18064772f, 
    -0.09897208f, -0.05582603f, 0.02043272f, 0.00024795f, 0.01239734f, -0.01965046f, 0.12942727f, 0.16147630f, 
    0.15681583f, 0.12753227f, 0.12624118f, 0.04702323f, -0.09837046f, -0.14668441f, -0.09301887f, 0.04485215f, 
    0.04265656f, 0.05985647f, -0.00977374f, -0.03333163f, -0.24240464f, 0.28131825f, 0.14585477f, 0.50736302f, 
    -0.18813398f, -0.09736092f, -0.06777754f, -0.02447139f, 0.10583018f, 0.08792994f, 0.05501923f, 0.14006366f, 
    0.55456638f, -0.06596745f, 0.17366035f, -0.13866155f, -0.02210194f, 0.02684708f, -0.03403789f, 0.03485278f, 
    -0.11626470f, -0.08459239f, -0.19769670f, -0.09441886f, -0.06246322f, 0.50170368f, 0.27362734f, 0.10117821f, 
    -0.09742203f, -0.11747845f, -0.02158184f, 0.01523005f, -0.04287161f, 0.04675183f, 0.13176109f, 0.12527990f, 
    0.20745756f, -0.02232295f, -0.01775461f, -0.20014693f, 0.00561461f, 0.15963942f, 0.03718365f, -0.15395342f, 
    -0.02423288f, 0.09276096f, -0.03612926f, 0.11077356f, -0.00324183f, -0.06564826f, -0.01001360f, 0.23228960f, 
    0.04229736f, -0.01505775f, -0.06046876f, -0.00181335f, 0.13608979f, 0.12267573f, -0.05212300f, 0.10422329f, 
    -0.04390601f, 0.08073353f, 0.04551873f, 0.05859600f, 0.02974055f, 0.05446113f, -0.06029337f, 0.05023951f, 
    -0.01038044f, -0.06835735f, -0.09026877f, 0.00896473f, 0.12455670f, -0.00519487f, 0.14076209f, -0.22722383f, 
    0.14342065f, -0.12030413f, 0.04036924f, -0.13189246f, 0.14197610f, 0.23159778f, 0.03859544f, 0.01603337f, 
    0.13251764f, 0.07410299f, 0.16471067f, -0.26567951f, 0.00996929f, -0.02645149f, -0.04871658f, 0.08260181f, 
    -0.04208245f, 0.02079646f, -0.19677776f, -0.09889350f, -0.03533488f, -0.06362613f, 0.07921508f, 0.04232254f, 
    -0.06079479f, 0.02527762f, -0.02464218f, 0.06890029f, 0.05735967f, 0.07062959f, 0.22873722f, 0.19594902f, 
    0.61016744f, -0.29203621f, -0.24838011f, -0.34308928f, 0.08960433f, 0.27838406f, 0.13886651f, -0.10863645f, 
    0.06186207f, 0.07088161f, 0.01601079f, -0.07201459f, -0.20063856f, 0.12989387f, 0.16310166f, 0.06934981f, 
    -0.11833211f, -0.01986488f, 0.13815403f, -0.18371761f, -0.00900576f, 0.05316557f, 0.09007140f, -0.09038708f, 
    0.18696348f, -0.02501000f, -0.04573167f, 0.20567647f, 0.03740906f, 0.08323663f, 0.04982533f, -0.06380917f, 
    0.08290024f, 0.04655878f, 0.04035797f, -0.04866012f, -0.05262724f, 0.03880126f, 0.22758028f, -0.04460635f, 
    0.06413446f, 0.11317743f, 0.10821483f, -0.04959262f, 0.02585726f, -0.11864446f, -0.14353041f, 0.01417551f, 
    0.06078396f, 0.05624215f, 0.08598249f, 0.12799764f, -0.01590695f, 0.04625525f, 0.04969115f, 0.02102376f, 
    -0.09494435f, -0.01075159f, -0.14263761f, -0.06304274f, -0.18694381f, -0.21306565f, -0.01814579f, 0.33022130f, 
    0.04830562f, 0.17349540f, 0.00771697f, 0.14490333f, -0.07905319f, -0.06067360f, -0.08838771f, -0.10012084f, 
    0.13416503f, -0.00399592f, 0.05573611f, -0.13484211f, 0.04170547f, 0.06406631f, 0.07424407f, 0.04931045f, 
    0.01720971f, 0.11950746f, 0.10496478f, 0.19562824f, 0.31384227f, -0.05564077f, 0.35756373f, -0.38873097f, 
    0.12010016f, -0.10051905f, 0.00867134f, -0.00245035f, -0.09043454f, 0.10509074f, -0.02881784f, 0.19489764f, 
    -0.00505916f, 0.22979304f, 0.26707593f, 0.09367685f, -0.00904191f, 0.00438638f, 0.05674876f, -0.06876475f, 
    -0.01409697f, 0.08844062f, 0.11040100f, 0.02332510f, -0.37552679f, -0.16208850f, 0.46280923f, 0.13144206f, 
    0.04525142f, -0.05044375f, -0.01248584f, 0.09656115f, 0.10076179f, -0.19021988f, 0.02664481f, 0.18532060f, 
    -0.10434457f, -0.10005422f, -0.14141178f, 0.18268213f, -0.03451093f, 0.14706105f, 0.20795852f, -0.14407197f, 
    -0.02420179f, -0.07814676f, 0.01953808f, -0.06385709f, 0.43804875f, -0.03356676f, 0.01825545f, 0.19771297f, 
    0.04255894f, -0.03306888f, 0.01998099f, -0.03500322f, -0.14638768f, 0.01790456f, -0.10025103f, -0.09775499f, 
    -0.49848923f, 0.03319361f, -0.05317279f, 0.18490143f, -0.15517440f, -0.03937602f, 0.02959263f, 0.23078947f, 
    0.20797421f, 0.10793270f, 0.07703708f, 0.25661996f, 0.25538030f, -0.00030327f, 0.03453832f, 0.03492822f, 
    0.01772791f, 0.03443949f, 0.12057400f, 0.03576611f, -0.04970411f, -0.06390924f, 0.02566209f, -0.07677613f, 
    -0.40390462f, -0.13094038f, -0.11219370f, -0.18532918f, 0.00092493f, -0.08836930f, 0.12543233f, -0.00726835f, 
    -0.09480670f, -0.05991586f, 0.01979804f, -0.06466205f, 0.05049312f, -0.05748918f, -0.10566956f, -0.05254938f, 
    -0.03030305f, 0.02175828f, -0.00040933f, -0.00218392f, 0.00644429f, 0.01535614f, 0.00988732f, 0.17053360f, 
    0.05310544f, 0.33882487f, -0.02327610f, 0.01153862f, 0.25695747f, -0.06174524f, 0.03121864f, 0.14576548f, 
    0.09135658f, 0.06669018f, -0.04645007f, 0.23339763f, 0.02230405f, 0.02280031f, 0.01981631f, -0.00703312f, 
    -0.00068465f, -0.00921597f, -0.02000440f, 0.07553922f, 0.19513085f, 0.12934154f, 0.08438700f, 0.08848571f, 
    -0.36797941f, -0.35992870f, -0.06022937f, 0.12893806f, 0.12229329f, -0.15716434f, -0.06791228f, -0.06935089f, 
    0.06559361f, 0.04353064f, -0.13742179f, 0.00734461f, 0.01398315f, 0.42279375f, -0.08171875f, 0.27255982f, 
    -0.17633380f, -0.15721062f, 0.07978138f, 0.05552312f, 0.13394785f, 0.08685862f, -0.01580193f, 0.12575562f, 
    0.09965816f, 0.15550363f, 0.36258477f, -0.02338919f, -0.04384232f, -0.14683117f, 0.13226578f, 0.03438984f, 
    0.12548529f, 0.11282489f, 0.17778146f, 0.17384610f, 0.00288265f, 0.54312271f, 0.08570629f, 0.00830658f, 
    -0.11551553f, -0.05878732f, -0.00689816f, -0.11365869f, 0.11235899f, 0.15815538f, 0.04404213f, 0.15489405f, 
    -0.25116494f, -0.31532183f, 0.07450591f, 0.05784991f, -0.14283079f, -0.06550726f, -0.07347924f, -0.08462459f, 
    -0.07257222f, -0.03602690f, 0.02823076f, -0.00457717f, 0.20460057f, -0.09185783f, 0.18935615f, 0.30817842f, 
    -0.09643137f, -0.07113101f, -0.08699309f, 0.03788956f, 0.05642156f, 0.07852772f, 0.10473607f, 0.19198258f, 
    0.08284383f, 0.17728993f, 0.12293474f, -0.08973018f, -0.11374350f, 0.10151893f, 0.07109728f, 0.18132822f, 
    0.00252094f, 0.12384001f, -0.10914167f, 0.13616361f, 0.38509104f, 0.32689252f, 0.29961905f, 0.16875850f, 
    -0.15011686f, -0.12189377f, -0.02478716f, -0.02575279f, 0.13955818f, 0.09248436f, 0.02478223f, 0.06473915f, 
    -0.06177659f, 0.03817475f, -0.03126689f, -0.19034512f, 0.06694317f, -0.19848394f, -0.14146674f, 0.07721275f, 
    0.07828846f, 0.02360989f, 0.04438491f, 0.15081407f, 0.18376364f, 0.06131481f, -0.03065899f, -0.09701871f, 
    0.00316771f, -0.08698858f, 0.01562515f, -0.00000676f, 0.16770819f, 0.22500050f, 0.23660679f, 0.10207294f, 
    0.04327797f, -0.07220037f, -0.08841866f, 0.00263079f, 0.14386547f, -0.04321890f, 0.10593956f, 0.09092869f, 
    -0.00127353f, 0.10330682f, -0.04744847f, 0.12098336f, -0.25321069f, 0.13197236f, 0.20085983f, -0.02670160f, 
    0.04368411f, 0.16437122f, 0.14504662f, -0.05572689f, 0.13221414f, 0.33584437f, -0.12056205f, 0.01023511f, 
    -0.24188881f, -0.11029195f, -0.20961916f, -0.04522631f, -0.02740544f, 0.05453224f, 0.27917787f, 0.11941664f, 
    0.21432301f, 0.13712032f, -0.18431622f, 0.10966878f, -0.10423805f, 0.31510073f, -0.16313989f, -0.18742031f, 
    -0.02410612f, -0.04202275f, -0.05103108f, 0.05509673f, 0.13379630f, 0.13477290f, -0.04705943f, 0.12854238f, 
    -0.14831536f, -0.05168519f, 0.12213516f, -0.39460993f, -0.14057989f, 0.05191622f, 0.07543399f, 0.16150449f, 
    0.15796587f, 0.16294532f, -0.12935475f, 0.08656331f, -0.22145624f, 0.01679686f, -0.32744211f, 0.24289805f, 
    -0.00385410f, 0.00314782f, 0.12479398f, -0.01257006f, 0.03573214f, 0.05995285f, -0.01533865f, -0.04098549f, 
    -0.25424063f, -0.36561358f, 0.16596483f, 0.20190656f, -0.02248855f, -0.13355035f, -0.13637310f, 0.08022720f, 
    0.08229590f, 0.05762950f, -0.04019057f, -0.04539745f, 0.22764491f, 0.22850664f, -0.14328748f, 0.02294912f, 
    -0.02009497f, 0.09178869f, 0.33629799f, 0.13660508f, 0.05976550f, -0.01523808f, 0.01912615f, -0.02449242f, 
    0.00587257f, 0.05710953f, -0.09395938f, -0.01159542f, 0.04801560f, -0.06607259f, 0.05775032f, 0.05358261f, 
    -0.00086886f, 0.13943999f, 0.07336022f, -0.03852869f, -0.00177715f, -0.07272566f, 0.11684038f, -0.06717051f, 
    0.13492741f, 0.09048039f, 0.02474808f, -0.02254654f, -0.00359716f, -0.01003307f, 0.01237784f, -0.13311604f, 
    0.12850522f, 0.13009802f, 0.07486814f, -0.14564967f, -0.03265786f, -0.04497081f, 0.00010899f, 0.01543391f, 
    0.05034200f, -0.03111498f, 0.15474193f, 0.44605997f, 0.06964432f, 0.37513438f, 0.40592778f, -0.33643085f, 
    0.07414623f, -0.10705680f, 0.09000932f, 0.00541262f, 0.03403387f, 0.24478674f, 0.11607899f, -0.00843225f, 
    -0.41331670f, -0.41379648f, -0.14774732f, 0.19732773f, 0.04927148f, -0.01523050f, -0.02373741f, 0.03997542f, 
    0.12704812f, -0.05869079f, 0.22142518f, 0.02684926f, 0.47087413f, 0.31056011f, -0.40578887f, 0.14383978f, 
    -0.06483480f, 0.31120658f, 0.15952331f, -0.06102721f, 0.24104905f, -0.00115867f, 0.08181069f, 0.02017888f, 
    0.00511737f, -0.20719820f, -0.02377191f, 0.24836606f, 0.19828001f, 0.61771166f, -0.23416498f, 0.37013870f, 
    0.00273531f, 0.21064430f, -0.06020781f, 0.05008502f, -0.13573678f, -0.08200397f, 0.26959506f, -0.25611651f, 
    0.02288318f, -0.07322551f, 0.10169064f, -0.01093758f, -0.01505225f, -0.00870849f, -0.01879026f, -0.03147799f, 
    0.12436775f, -0.05339863f, -0.38948116f, 0.00700411f, 0.18769792f, 0.08695495f, -0.09087804f, -0.07980023f, 
    0.18138301f, 0.21241099f, 0.24394065f, 0.14420596f, -0.22498634f, 0.08214102f, 0.38778862f, -0.01507860f, 
    -0.02251623f, 0.03967277f, 0.11416952f, 0.00795569f, 0.04466736f, 0.01921032f, 0.03060840f, -0.00131517f, 
    -0.03335392f, -0.03139598f, -0.01079260f, -0.05088719f, -0.01932014f, -0.00905659f, -0.00716596f, -0.00581424f, 
    -0.02866745f, -0.00294343f, -0.01855843f, -0.04890399f, -0.01509476f, 0.05082976f, -0.01362504f, -0.02607136f, 
    0.03639756f, 0.01703872f, -0.00035593f, -0.00501778f, 0.01516908f, -0.04648704f, 0.01560273f, 0.03268984f, 
    -0.02378552f, 0.00157521f, 0.02955437f, -0.03785853f, -0.00690219f, 0.01516968f, -0.01092749f, 0.02724230f, 
    -0.02351584f, 0.01655328f, -0.03133136f, -0.02872718f, -0.02128762f, 0.02177314f, -0.01837885f, -0.00513565f, 
    -0.05233207f, 0.01330837f, -0.05436556f, 0.02917111f, -0.04694148f, -0.05139053f, -0.00418085f, 0.03830720f, 
    -0.00061594f, 0.02566411f, -0.02232640f, -0.02284577f, 0.03987471f, -0.02345296f, 0.01877246f, -0.00558075f, 
    -0.04374755f, -0.01481933f, -0.03533060f, -0.00401108f, -0.02959366f, -0.02558095f, 0.01502170f, 0.04305362f, 
    -0.00687595f, -0.04721648f, -0.05797843f, 0.01373962f, 0.00048464f, -0.00199019f, -0.02203707f, -0.05664856f, 
    0.00084521f, 0.02394072f, -0.01599576f, 0.02435690f, 0.04232042f, -0.04776226f, -0.04376135f, -0.05387549f, 
    -0.05123058f, -0.01778213f, 0.03189305f, 0.03430592f, 0.01463712f, 0.04933695f, 0.00074555f, -0.04533869f, 
    -0.02383514f, -0.01448849f, -0.01190701f, 0.04502158f, -0.03434690f, -0.05747495f, 0.03842227f, 0.00613395f, 
    -0.01357959f, -0.02973472f, -0.01272526f, 0.00907266f, -0.05321501f, 0.00650696f, -0.00217652f, -0.01174028f, 
    0.01081446f, -0.04347778f, 0.03636127f, 0.04323500f, 0.03856083f, 0.02953259f, 0.03191185f, -0.02445930f, 
    -0.02752492f, -0.02256759f, -0.04238190f, -0.04721483f, 0.00332308f, 0.00028854f, 0.03992682f, 0.02892865f, 
    -0.04287567f, -0.03961527f, -0.05601670f, -0.02630501f, 0.03470884f, 0.03446670f, -0.03984072f, 0.00444566f, 
    -0.01324654f, -0.03854210f, 0.02772445f, 0.00423004f, -0.05530873f, 0.02997475f, -0.01467454f, -0.01535436f, 
    -0.04323592f, 0.03226165f, -0.01144964f, 0.01591127f, -0.05174973f, 0.01066004f, 0.02425881f, -0.00224012f, 
    0.00377866f, -0.03549140f, -0.03567736f, 0.03488283f, -0.03952352f, -0.03561009f, -0.01097610f, -0.05551542f, 
    -0.03568792f, 0.01861174f, 0.03227777f, -0.00506958f, 0.01097481f, 0.02471562f, -0.02751254f, -0.01718849f, 
    0.00079807f, 0.02571486f, -0.03308419f, 0.00567931f, 0.03398005f, 0.00050372f, 0.02813661f, 0.03538943f, 
    -0.03755660f, -0.00654175f, -0.02447164f, 0.05452387f, 0.02425497f, -0.00179377f, -0.02798680f, 0.01053232f, 
    -0.00926905f, 0.04341353f, -0.04757649f, 0.04426313f, 0.00881756f, 0.00378292f, 0.01916882f, 0.02985794f, 
    0.00809995f, -0.00996933f, -0.02318319f, -0.01307832f, 0.02272728f, 0.00672566f, -0.03874846f, 0.03904522f, 
    -0.00222286f, -0.04246315f, -0.02076385f, 0.03751462f, 0.02326042f, 0.04380634f, 0.00838407f, -0.00306596f, 
    0.00688770f, -0.01459455f, -0.02027582f, 0.03386057f, -0.02649902f, -0.00868778f, -0.04910984f, 0.00982638f, 
    0.01776255f, 0.02859701f, 0.00341434f, 0.02758904f, -0.02453525f, 0.00943106f, 0.00926876f, 0.02647123f, 
    -0.03930118f, -0.02481061f, 0.02281781f, 0.00221775f, -0.04359772f, 0.00790877f, -0.05871157f, 0.00342195f, 
    -0.05316659f, -0.00490993f, 0.03009527f, -0.02168619f, -0.00597364f, 0.02376692f, 0.03771281f, -0.04228594f, 
    -0.03161113f, 0.02803600f, 0.02347129f, -0.00610326f, -0.03096551f, -0.03250486f, -0.00100827f, -0.02508914f, 
    -0.01315207f, -0.01026941f, -0.05104595f, 0.01121393f, 0.04470029f, 0.01674220f, -0.02430940f, -0.01542011f, 
    0.02540139f, -0.03751178f, -0.02345931f, 0.00806540f, -0.00300055f, 0.04308661f, 0.02757331f, -0.01857300f, 
    0.00457303f, -0.00702844f, 0.02191967f, 0.02039233f, -0.01525261f, 0.00948101f, 0.01746440f, -0.01764775f, 
    -0.05083876f, 0.00275784f, 0.01134058f, -0.02716679f, -0.01206269f, 0.00929085f, -0.00251575f, 0.01592286f, 
    -0.00255934f, -0.02998491f, -0.04066553f, -0.00293212f, -0.01859944f, -0.04635516f, -0.02319985f, 0.00842116f, 
    -0.00547757f, 0.00041061f, 0.03303913f, 0.01912669f, -0.00279200f, -0.04279310f, 0.00407889f, -0.01114030f, 
    -0.04400750f, -0.03360483f, 0.03166534f, -0.00573748f, -0.01415690f, -0.00153451f, -0.05723404f, 0.04385321f, 
    0.03380118f, 0.01897485f, -0.01665414f, 0.03194264f, -0.01214902f, 0.02033009f, -0.02408249f, 0.00108524f, 
    -0.01653763f, -0.02281320f, -0.01186254f, 0.02661043f, 0.01813922f, -0.03567063f, -0.05094103f, -0.02444248f, 
    0.02905745f, -0.02749028f, 0.00313876f, -0.00004266f, 0.01967260f, -0.05336722f, -0.03430098f, -0.04487314f, 
    0.04372986f, -0.00111024f, -0.04321151f, -0.00569583f, -0.05348303f, 0.04234004f, -0.02431552f, -0.02250214f, 
    -0.04208029f, -0.02310098f, -0.05298790f, -0.05030482f, 0.03258514f, -0.05460731f, -0.00525431f, -0.04241843f, 
    0.00827705f, 0.00226617f, -0.03436530f, -0.01626802f, -0.02794456f, 0.01812987f, 0.00728200f, -0.02497153f, 
    -0.05779122f, 0.02265152f, -0.05332791f, 0.03648725f, 0.01197821f, -0.03992672f, -0.05882458f, 0.02902577f, 
    0.02344613f, -0.05704296f, -0.01570208f, 0.03673442f, 0.04146272f, -0.03092676f, -0.04561570f, 0.03509353f, 
    -0.01995366f, 0.02912879f, 0.02295826f, -0.03127201f, 0.01182440f, 0.04042044f, 0.00083554f, -0.05600899f, 
    0.02403833f, 0.01914068f, 0.03326724f, -0.03468483f, -0.02940423f, -0.01302791f, -0.01026947f, 0.04248862f, 
    -0.01442024f, -0.01284175f, 0.01962788f, -0.04503877f, -0.02279891f, -0.05905282f, 0.00412429f, -0.04610543f, 
    0.01917756f, -0.01974111f, -0.01147986f, 0.02435653f, 0.00796966f, 0.02664947f, -0.04896605f, 0.02381950f, 
    -0.01011912f, -0.04861863f, 0.03451112f, -0.01873142f, 0.00406518f, -0.03655304f, 0.03497749f, 0.00283146f, 
    0.02163333f, 0.01668363f, -0.05421293f, -0.00294699f, -0.04411818f, 0.01319036f, -0.05829625f, 0.00264538f, 
    -0.01297423f, 0.00632254f, 0.00373156f, -0.03327952f, -0.02183821f, -0.01353998f, 0.04087852f, -0.00492236f, 
    0.01496153f, -0.01698826f, 0.03869777f, -0.05273573f, -0.03160162f, -0.01781667f, 0.03752216f, -0.05093148f, 
    -0.00094112f, -0.00556826f, -0.03946908f, -0.01127422f, -0.01664245f, -0.05126261f, 0.02330331f, -0.01464085f, 
    -0.02435095f, -0.03342876f, -0.03049078f, 0.03916886f, 0.00989135f, -0.02767998f, -0.00910731f, -0.05489654f, 
    -0.04080466f, 0.02284037f, -0.04136762f, -0.04071621f, -0.01926027f, -0.00825847f, -0.04216901f, -0.02498155f, 
    -0.04770792f, 0.01102735f, -0.04352976f, -0.01275324f, 0.01699831f, 0.00378756f, -0.04591823f, -0.01397263f, 
    -0.04854551f, 0.03617427f, -0.00413663f, 0.02126222f, 0.03431375f, -0.05531134f, 0.00724680f, 0.02834143f, 
    -0.04966810f, 0.04439219f, 0.00997102f, 0.03999367f, -0.02948995f, 0.01262959f, -0.04497678f, -0.03829112f, 
    -0.03060728f, -0.02376887f, -0.01092392f, -0.04468768f, -0.02690258f, -0.00359795f, -0.03734626f, -0.01020734f, 
    0.02302070f, 0.01446825f, -0.02401081f, -0.03260467f, 0.03421467f, -0.03091195f, 0.01654495f, 0.01039031f, 
    -0.01650655f, -0.03690210f, 0.03859464f, 0.04076129f, 0.01411352f, 0.02651917f, -0.04622717f, -0.05790887f, 
    -0.03013775f, 0.00140335f, -0.02910249f, -0.05481734f, -0.04228206f, 0.03208506f, 0.00433269f, -0.04320950f, 
    -0.03583657f, -0.00175807f, 0.02871181f, -0.02162811f, -0.00822621f, 0.01993362f, -0.00403632f, 0.04002489f, 
    0.03789526f, -0.02606050f, -0.04807409f, -0.05020846f, -0.02248431f, -0.03552928f, 0.01431182f, 0.03497468f, 
    -0.04815566f, 0.01077681f, 0.02289562f, -0.05558296f, -0.01013553f, 0.00906593f, 0.02357196f, 0.01428718f, 
    -0.03929516f, 0.00753077f, 0.01527704f, 0.04015857f, 0.02120905f, -0.04099489f, -0.04136202f, -0.02716165f, 
    -0.04992281f, 0.02482899f, 0.03886070f, -0.05183829f, 0.03141096f, 0.03407361f, 0.00212512f, -0.01829560f, 
    -0.01948605f, -0.02813475f, -0.04855787f, 0.00314614f, 0.01298669f, -0.01220244f, -0.02676196f, -0.05753471f, 
    -0.04243915f, -0.01534524f, 0.04042406f, 0.00158454f, 0.02054759f, -0.05095192f, -0.04762349f, 0.01137692f, 
    0.01442685f, 0.04714340f, 0.03174954f, 0.02717742f, -0.00808535f, -0.03468546f, -0.00121624f, 0.01342729f, 
    -0.05750451f, -0.00299031f, -0.00500907f, 0.00080228f, -0.05399192f, 0.01769833f, -0.00555291f, 0.00666221f, 
    -0.03299724f, 0.03095772f, 0.03106848f, -0.02506228f, 0.03295603f, -0.05311630f, 0.00297040f, 0.03198208f, 
    -0.01472475f, 0.04008017f, 0.01674988f, 0.02352512f, 0.02366520f, 0.02642455f, -0.01565765f, 0.01386223f, 
    -0.05079098f, 0.01839088f, -0.05382925f, -0.02087660f, -0.00302084f, -0.02588622f, -0.00722472f, 0.02922740f, 
    0.00784902f, 0.00731676f, -0.02316920f, -0.00789797f, -0.04788694f, 0.02444688f, 0.02180439f, 0.00391879f, 
    -0.00474653f, 0.04087377f, 0.02225611f, -0.03225847f, -0.00476113f, 0.02490882f, 0.01611028f, 0.01244133f, 
    0.02473103f, 0.02063687f, -0.04659543f, -0.03376186f, -0.03186480f, -0.03451587f, -0.01986362f, -0.02513553f, 
    0.03035783f, 0.01468648f, -0.02476176f, -0.01529309f, 0.02556033f, 0.03454253f, -0.05705952f, -0.03067672f, 
    0.02029175f, 0.01859550f, 0.03973548f, -0.05232165f, 0.00953534f, 0.04602965f, -0.00165420f, 0.01558512f, 
    -0.02831795f, -0.03594195f, -0.05114879f, -0.02400531f, 0.01007078f, -0.00704539f, 0.03769780f, -0.00238879f, 
    -0.03598673f, 0.05264544f, 0.02446483f, -0.04215658f, 0.00811573f, -0.00994330f, 0.00459808f, 0.03863085f, 
    -0.04590957f, 0.00579354f, 0.03680694f, -0.03446986f, -0.05421402f, -0.00691239f, -0.02736680f, -0.03651299f, 
    -0.01771105f, -0.02126558f, 0.00236833f, -0.03841896f, -0.00419381f, -0.02865901f, -0.03653686f, -0.03851214f, 
    0.02971293f, -0.03043069f, -0.01555711f, -0.01630276f, 0.00808330f, -0.01409833f, 0.03270938f, -0.00929002f, 
    -0.01470267f, -0.05199046f, -0.04309598f, -0.02653115f, -0.05580151f, 0.03403493f, -0.00691091f, -0.00945765f, 
    0.01267558f, 0.02478215f, -0.01143982f, 0.04352152f, -0.01770354f, 0.04331812f, -0.01469240f, -0.01302292f, 
    -0.01313479f, 0.01383739f, -0.03164158f, 0.03331246f, -0.03635335f, -0.01280898f, -0.03670918f, -0.00807226f, 
    -0.04706787f, -0.00620378f, -0.05230977f, -0.01521323f, -0.03449591f, -0.04172758f, 0.02592399f, -0.00418255f, 
    -0.04255825f, 0.04013530f, -0.04019003f, -0.02023542f, 0.00319423f, -0.05760703f, -0.01896370f, -0.00805970f, 
    0.04012095f, 0.02610098f, -0.01255222f, 0.04111813f, -0.00217324f, -0.03302491f, 0.01334693f, 0.00631520f, 
    0.03540687f, 0.01546453f, 0.03394669f, -0.05050306f, -0.00374789f, 0.04664642f, 0.00078039f, 0.00174869f, 
    -0.01298616f, -0.04488087f, -0.00594602f, 0.03848920f, 0.03117795f, 0.01442819f, -0.03252706f, 0.02586285f, 
    -0.02644917f, -0.04382391f, 0.01699704f, -0.03183210f, -0.00959815f, 0.02723381f, -0.02539060f, 0.00168496f, 
    0.01164046f, 0.04052462f, 0.01963079f, -0.00810356f, -0.01810569f, -0.03115417f, -0.02269109f, -0.00680133f, 
    0.01458562f, 0.02414609f, -0.01040064f, -0.05720503f, 0.01619569f, -0.05673704f, 0.02280777f, -0.02748164f, 
    -0.15844041f, -0.02879582f, 0.04932361f, 0.11721371f, -0.12876193f, -0.12971270f, 0.04797965f, -0.00544023f, 
    -0.32717273f, -0.13153628f, -0.18281075f, -0.24826838f, 0.02078156f, -0.17458786f, -0.00438209f, -0.02135869f, 
    -0.21034071f, 0.11489707f, 0.26604408f, 0.01396294f, 0.19374260f, 0.05156269f, 0.25190285f, 0.31144956f, 
    -0.04601798f, -0.04575454f, 0.02446667f, -0.43740684f, 0.01869980f, -0.04605781f, 0.11713275f, -0.20172533f, 
    -0.08211428f, -0.17846283f, -0.26186386f, -0.11444265f, -0.13465704f, -0.06641323f, -0.12008823f, -0.14677157f, 
    -0.00818534f, -0.07189626f, 0.01268504f, -0.00360629f, 0.00538335f, -0.13322029f, -0.02359131f, -0.29553375f, 
    0.00670462f, -0.42523354f, 0.10249056f, -0.10945088f, -0.02256013f, 0.07477157f, 0.07680797f, -0.02793153f, 
    0.16217723f, 0.01103558f, -0.05256512f, -0.00438877f, 0.00049696f, 0.02889090f, 0.06088370f, 0.05153588f, 
    -0.09488442f, 0.02390177f, -0.02355899f, -0.04052264f, 0.03615900f, 0.00866041f, -0.02626407f, 0.14633618f, 
    0.44683206f, -0.09706663f, -0.06551194f, 0.14246856f, 0.10150086f, -0.16429970f, 0.09670356f, -0.15991873f, 
    0.05665530f, 0.07001921f, 0.06952769f, 0.29503658f, 0.07619029f, 0.10885005f, 0.13127600f, -0.00253594f, 
    -0.10626663f, -0.00908131f, 0.03359554f, -0.21437234f, 0.21381855f, -0.03434758f, 0.02451163f, 0.17524898f, 
    -0.27239749f, -0.13993357f, 0.15485397f, 0.09954468f, -0.17398754f, -0.05625011f, 0.08829428f, 0.20261845f, 
    -0.05016863f, 0.06964749f, -0.02349835f, 0.04495266f, 0.31924722f, 0.01688665f, 0.21128765f, 0.17665829f, 
    -0.01271641f, -0.01592835f, -0.15402286f, 0.11369485f, 0.00418776f, 0.00683793f, 0.07699956f, 0.01987868f, 
    -0.07031929f, 0.29492030f, -0.01366552f, -0.12729749f, -0.01194887f, -0.11193208f, -0.09471557f, -0.15647490f, 
    -0.20478292f, -0.07523241f, -0.04701355f, -0.13303047f, 0.41431478f, 0.09009720f, 0.16466886f, 0.20886031f, 
    -0.17818360f, -0.10917456f, 0.08674917f, -0.04058446f, 0.00315260f, 0.11000558f, 0.08182216f, 0.30745161f, 
    0.06133410f, 0.49683940f, 0.25211671f, 0.30827796f, 0.12158293f, -0.07408841f, 0.09597147f, 0.13039728f, 
    0.01515508f, -0.09541584f, -0.19002269f, -0.14301921f, -0.05848389f, 0.06746435f, -0.10671274f, -0.12073839f, 
    -0.44822836f, -0.11401547f, 0.05131403f, 0.08372141f, 0.08397376f, 0.23288734f, 0.04032037f, 0.00962798f, 
    -0.02868511f, -0.14103819f, -0.10500000f, -0.14373553f, 0.11004376f, -0.25673303f, 0.00859688f, -0.31434700f, 
    -0.14595309f, -0.25773162f, -0.42242563f, -0.15146221f, -0.30032021f, 0.01239120f, 0.23527035f, -0.08012021f, 
    0.02850986f, 0.12210979f, 0.20373192f, 0.03661432f, 0.14042979f, 0.15014191f, 0.14291716f, 0.09829107f, 
    -0.29791170f, 0.04220932f, 0.15291852f, 0.24907760f, -0.12162410f, -0.07817436f, 0.09612160f, 0.08442929f, 
    -0.12172855f, 0.09327276f, 0.04139729f, -0.01035427f, 0.18302533f, 0.20208071f, 0.01202326f, 0.02769318f, 
    0.04359819f, -0.13022397f, 0.06603328f, -0.09616631f, 0.09826659f, 0.19087578f, -0.00333416f, 0.09649697f, 
    -0.11705118f, 0.45918104f, 0.22967795f, 0.07363424f, 0.04537644f, -0.11816720f, 0.25980273f, 0.15212154f, 
    0.00675550f, 0.06870605f, -0.22901775f, -0.03193744f, -0.15208802f, -0.26993546f, -0.10331967f, -0.04658381f, 
    0.01387488f, -0.01468981f, 0.06964940f, 0.14374343f, -0.07775293f, -0.02555216f, 0.04825163f, 0.12635565f, 
    -0.34069571f, -0.24170768f, 0.14881156f, 0.11094121f, 0.06893662f, 0.03020286f, -0.06029818f, 0.17063393f, 
    0.00624270f, 0.16473441f, 0.00199750f, 0.13222718f, -0.08638673f, 0.15871304f, -0.34719548f, 0.03892053f, 
    0.01552653f, 0.01302928f, -0.02376935f, -0.18648492f, -0.08149089f, 0.03932769f, -0.15219355f, -0.12846541f, 
    -0.03878448f, -0.03768634f, -0.07958522f, -0.06943036f, -0.08969171f, -0.19664752f, -0.11728105f, -0.24596453f, 
    -0.15511385f, 0.03953753f, -0.23907308f, -0.60549581f, 0.17419618f, -0.14215305f, 0.31234732f, 0.30475000f, 
    0.14777933f, 0.04555925f, 0.01108837f, -0.07833787f, -0.21241570f, -0.07107582f, -0.21854815f, -0.22333467f, 
    0.18231486f, 0.13815010f, 0.13895981f, 0.20534883f, 0.16471453f, -0.15524013f, 0.19018637f, 0.00956304f, 
    0.30790704f, 0.09183469f, 0.23128240f, 0.31991753f, -0.02930930f, 0.37235987f, 0.16530405f, 0.03026808f, 
    -0.08248638f, 0.14694692f, -0.06099262f, 0.08209477f, 0.08844172f, 0.08448243f, 0.24353556f, -0.03749372f, 
    -0.23227437f, -0.23394272f, -0.11070012f, 0.27286470f, -0.06480602f, 0.06161468f, -0.02329023f, 0.10869385f, 
    0.03675527f, 0.11589950f, 0.22665867f, 0.03576107f, -0.09538438f, 0.21748741f, -0.28133848f, -0.01294328f, 
    0.13186765f, 0.06757987f, 0.02518308f, 0.02898636f, 0.03885498f, -0.00351961f, -0.12115615f, 0.04116526f, 
    -0.11911494f, -0.12907237f, -0.16274041f, 0.21128675f, 0.08128572f, 0.15371720f, -0.19510090f, -0.17515650f, 
    0.02993720f, -0.08354134f, -0.03089860f, 0.04732505f, 0.22796744f, 0.05859268f, 0.10568792f, -0.09553847f, 
    -0.06992832f, -0.19764592f, -0.16697678f, -0.12789065f, -0.10024393f, -0.10616297f, 0.12738395f, 0.03447027f, 
    0.30291080f, 0.06454583f, -0.27907977f, 0.26043746f, -0.05508530f, 0.22797213f, 0.15215497f, -0.30366701f, 
    0.07784911f, 0.03982932f, 0.14121914f, 0.18390371f, -0.00113824f, -0.04155732f, 0.08079398f, -0.02586112f, 
    -0.04938896f, 0.00540049f, 0.05060065f, 0.12913342f, -0.00151454f, 0.00707782f, -0.04504301f, -0.14670162f, 
    0.10468467f, 0.25244033f, 0.24047281f, 0.25950545f, 0.06807997f, 0.07447568f, 0.16207390f, 0.04391848f, 
    -0.05293111f, -0.04381282f, 0.00403757f, -0.10865733f, -0.16372354f, -0.13895427f, 0.00349744f, -0.08312879f, 
    -0.08921597f, -0.12529625f, -0.03816628f, -0.02909401f, 0.05182651f, 0.07596492f, 0.02647076f, 0.30653155f, 
    -0.18189697f, 0.02215095f, 0.02467482f, -0.19175726f, -0.02841021f, 0.03007717f, 0.13827680f, -0.13295655f, 
    -0.10750752f, 0.14548473f, -0.26333523f, -0.15148222f, -0.03588767f, -0.18401684f, 0.08028487f, -0.06382816f, 
    -0.03864906f, 0.05425587f, -0.04027939f, -0.09619106f, 0.04096062f, 0.03768497f, -0.01847366f, -0.02878044f, 
    0.18051311f, 0.10204492f, 0.15531032f, 0.01079349f, 0.06201353f, 0.04218802f, -0.07077859f, 0.03955429f, 
    0.09244745f, 0.02141071f, -0.12100124f, 0.04436584f, 0.55864370f, 0.18324046f, -0.02217715f, 0.27292791f, 
    0.05527214f, -0.02538088f, 0.05844693f, 0.01438020f, -0.02020680f, 0.07614560f, 0.06800655f, 0.14576380f, 
    0.29513913f, 0.07848998f, 0.06266456f, 0.29248944f, 0.22289237f, 0.01449909f, 0.00457549f, -0.09302174f, 
    -0.03761439f, 0.03405578f, 0.12557884f, 0.12321811f, 0.00332500f, 0.05167121f, -0.07733817f, -0.10693837f, 
    0.05810277f, -0.00669829f, 0.09063645f, -0.03461111f, -0.03124484f, -0.13666569f, -0.08980498f, 0.10370813f, 
    0.05946225f, 0.05503997f, 0.28789154f, 0.29530856f, -0.01302921f, 0.03047902f, 0.01253749f, 0.16785067f, 
    0.00513404f, 0.03015037f, 0.07551321f, 0.00565578f, 0.05262173f, 0.02170305f, 0.09192433f, 0.05844343f, 
    0.02280848f, 0.03473071f, 0.04503321f, 0.10640320f, -0.06331504f, -0.08192904f, 0.01333056f, -0.06023322f, 
    0.09977695f, 0.02218585f, -0.11409048f, -0.05141142f, 0.00709902f, 0.06824383f, 0.02070504f, -0.10228608f, 
    -0.12733884f, -0.03758067f, -0.13533498f, 0.13538460f, 0.21781978f, 0.10184023f, 0.22984643f, 0.34447575f, 
    0.04544985f, 0.04711645f, 0.08659729f, -0.07029250f, 0.11832368f, 0.13199311f, 0.15379493f, 0.05964362f, 
    -0.23805347f, 0.22715098f, -0.01550268f, 0.03641314f, 0.14471769f, 0.01198043f, -0.32223681f, 0.03850615f, 
    -0.07553279f, 0.02901049f, -0.03515375f, 0.11959153f, -0.42867538f, -0.29097974f, -0.17690036f, -0.23053467f, 
    -0.15917236f, 0.01413385f, 0.05176493f, -0.02877743f, 0.00245859f, 0.18081923f, 0.06618851f, -0.00660790f, 
    -0.09708702f, -0.13336810f, -0.02145916f, 0.01250420f, 0.11927260f, -0.06953024f, 0.01653666f, 0.01878378f, 
    -0.19550444f, 0.05925785f, -0.19192027f, -0.13951248f, 0.09154464f, 0.21687408f, 0.10194580f, 0.04121148f, 
    0.01141718f, 0.08952915f, 0.05940587f, -0.08881249f, 0.12969333f, -0.05822321f, 0.07690619f, 0.11599899f, 
    0.10605679f, 0.24979052f, 0.06549664f, 0.26344684f, -0.02538243f, 0.08781861f, 0.04690339f, 0.07532638f, 
    -0.04060415f, 0.07194939f, -0.13647556f, 0.06479268f, -0.16276753f, -0.03686218f, -0.24013261f, -0.06873189f, 
    -0.06020602f, -0.09539402f, -0.07164861f, 0.05270212f, 0.09050944f, 0.16622722f, -0.25122449f, 0.05287127f, 
    0.17271103f, 0.08699072f, 0.00782100f, -0.06567319f, 0.04480981f, 0.06173195f, -0.01405020f, 0.06386343f, 
    0.05672794f, -0.00783524f, -0.09275782f, -0.05899117f, 0.05476254f, 0.04980978f, -0.14919356f, 0.15008700f, 
    -0.04395962f, -0.06825784f, 0.02989769f, -0.10640211f, -0.03490171f, 0.10543180f, -0.07761025f, -0.09052274f, 
    0.02092022f, 0.06466518f, 0.26807410f, 0.36891836f, 0.06474620f, 0.05438023f, 0.02426369f, 0.16473769f, 
    0.05931225f, 0.08982515f, -0.09144065f, 0.07607806f, -0.11326452f, -0.16429642f, -0.29535270f, -0.22536215f, 
    0.01128732f, -0.04767900f, -0.09662799f, -0.19068098f, -0.02331193f, 0.07828463f, -0.02579670f, -0.02674462f, 
    -0.34880278f, -0.11326983f, -0.21529548f, -0.11306146f, -0.02102341f, 0.05667928f, 0.06575564f, 0.00049646f, 
    -0.04210435f, -0.02956676f, -0.00177566f, -0.21437842f, -0.36248755f, 0.06227470f, 0.01164324f, 0.17451240f, 
    -0.02100269f, -0.13560316f, 0.02132775f, 0.05204001f, -0.01867053f, -0.11576305f, -0.04343931f, -0.13027842f, 
    0.23358798f, 0.08199953f, -0.11827821f, -0.03212957f, 0.03455196f, -0.08196472f, -0.16254117f, -0.07385138f, 
    0.02111277f, 0.09044804f, 0.08888786f, 0.20202976f, 0.13684902f, 0.18296100f, 0.06948870f, -0.13543223f, 
    0.06895581f, 0.05891320f, -0.06148792f, -0.17027904f, -0.00125374f, -0.05143184f, 0.14288461f, -0.09042277f, 
    0.02550365f, -0.02762874f, 0.01717192f, 0.28859419f, 0.01154750f, -0.08443980f, 0.05948675f, 0.19931322f, 
    0.10165840f, -0.05201236f, 0.11277869f, 0.02650258f, 0.04011912f, -0.03408857f, -0.52530360f, -0.04004236f, 
    0.12923193f, -0.21987572f, 0.13249929f, -0.03046775f, 0.01260484f, 0.02202901f, -0.09823628f, -0.04360320f, 
    0.25373602f, 0.11343078f, 0.07392739f, 0.23002964f, 0.24844427f, 0.00411007f, -0.10172827f, 0.05211355f, 
    -0.08227246f, 0.11407793f, 0.03978073f, -0.09303322f, -0.22257930f, -0.34610763f, -0.16817090f, -0.35512084f, 
    0.00470700f, -0.13214131f, -0.03990159f, -0.03951085f, -0.09123041f, 0.00837922f, -0.03143447f, -0.12031751f, 
    -0.02258030f, 0.00232248f, -0.19274573f, 0.03645865f, 0.17037353f, -0.02536515f, -0.14279118f, -0.16948326f, 
    0.04741726f, 0.14487098f, 0.05997290f, 0.20405072f, -0.81469375f, -0.34695408f, 0.21428061f, -0.20882112f, 
    -0.03598798f, -0.06093173f, -0.02336493f, -0.01536372f, -0.04780973f, -0.02283439f, 0.03853903f, -0.04465822f, 
    0.04343057f, -0.06281666f, -0.02432221f, -0.01271076f, 0.02394952f, 0.03687113f, -0.03748675f, -0.03816985f, 
    -0.03549047f, -0.04777746f, 0.01024156f, 0.00105356f, -0.03290915f, -0.02515933f, -0.08863527f, -0.00278186f, 
    -0.06858943f, -0.03719736f, -0.08835068f, -0.00926620f, -0.07859376f, -0.04931933f, -0.07903787f, -0.00862740f, 
    -0.00864958f, -0.01280663f, 0.01430694f, -0.02936874f, -0.04456339f, -0.04788158f, -0.04259061f, -0.02111398f, 
    -0.03480660f, -0.03456344f, -0.00650777f, -0.03214918f, 0.01216677f, 0.00104441f, -0.03529742f, -0.01688430f, 
    -0.01897676f, -0.05292954f, -0.07104217f, -0.02506054f, -0.02097748f, 0.01664489f, -0.06370634f, -0.06679893f, 
    -0.06279901f, 0.00021816f, -0.05152378f, 0.05791251f, 0.01482985f, 0.00376589f, 0.01695509f, 0.05804830f, 
    0.00480029f, -0.00883870f, -0.04724853f, -0.00363215f, 0.02600373f, -0.00172801f, -0.04483655f, -0.01009139f, 
    -0.02661622f, -0.00674964f, 0.01297448f, 0.02122408f, -0.06853227f, -0.06062284f, -0.06443269f, -0.02507434f, 
    -0.04778680f, -0.01110449f, 0.00075451f, -0.05060608f, -0.02751215f, -0.05628782f, -0.01081483f, 0.00029097f, 
    0.00093967f, 0.00742417f, -0.04121406f, -0.02585841f, -0.03001825f, -0.04760899f, -0.08993345f, -0.06147614f, 
    -0.07676230f, -0.07675008f, 0.00506602f, -0.09342350f, -0.02614190f, 0.05354302f, 0.03963739f, 0.04834260f, 
    -0.04283154f, -0.02798082f, 0.03813414f, 0.01742977f, 0.03101770f, -0.00912420f, -0.02416715f, 0.00103799f, 
    -0.00196229f, -0.08028556f, -0.06805736f, 0.00529911f, -0.07005624f, 0.00402500f, -0.02366902f, -0.00016548f, 
    0.00028008f, 0.00077140f, -0.03006308f, -0.07406121f, 0.00211826f, -0.02708910f, 0.01308883f, 0.01616302f, 
    -0.07983644f, -0.00669832f, -0.00923577f, -0.03040437f, -0.04266536f, -0.04545731f, -0.07474857f, -0.03746118f, 
    0.01365365f, -0.01535024f, 0.02179954f, -0.06698905f, 0.03252253f, -0.06054930f, -0.06665936f, 0.01361905f, 
    0.01406594f, 0.00634331f, 0.01297525f, -0.08445749f, 0.05562004f, -0.04240569f, -0.01928575f, 0.00046694f, 
    -0.07913718f, -0.01122503f, -0.04320336f, -0.03577930f, 0.02901573f, 0.01682551f, -0.00165614f, -0.04777182f, 
    -0.06658026f, -0.06623089f, -0.06812025f, -0.07336505f, -0.04172992f, -0.05205888f, -0.02405534f, -0.07693323f, 
    -0.03161790f, -0.00863904f, -0.03027116f, -0.00670533f, -0.00621442f, -0.06286089f, -0.02063915f, -0.02444909f, 
    0.00854360f, -0.07453158f, -0.06276019f, -0.03915274f, -0.03672848f, 0.01308359f, -0.05937216f, -0.01322306f, 
    -0.05029409f, -0.04929173f, -0.07457600f, -0.02878563f, 0.01919560f, -0.06737485f, -0.04389250f, -0.01612221f, 
    0.04148888f, -0.01547212f, -0.04426818f, -0.03980110f, -0.08194174f, -0.02535140f, -0.03150205f, 0.01884043f, 
    -0.04278064f, -0.04370105f, 0.03877829f, -0.00456890f, 0.02749359f, 0.00728672f, -0.06674430f, 0.05160901f, 
    -0.02515252f, -0.05567228f, 0.00727257f, -0.06162829f, 0.01432063f, -0.01677063f, 0.03845147f, -0.05067594f, 
    0.00421279f, -0.05799178f, -0.02539452f, -0.01928241f, -0.06089512f, -0.00545379f, -0.02981626f, -0.02376867f, 
    -0.02593549f, -0.07625551f, -0.03440810f, -0.03803032f, -0.04316739f, 0.02020787f, -0.01523439f, 0.02145201f, 
    -0.01689307f, 0.01809823f, -0.01735829f, -0.00770388f, 0.05646404f, -0.00429678f, -0.03751646f, 0.02560355f, 
    0.03028679f, -0.05026896f, -0.02603971f, -0.02128701f, -0.00011493f, -0.02593562f, -0.08881895f, -0.02565720f, 
    -0.00231443f, -0.05743380f, -0.00085462f, -0.00363793f, 0.01979969f, 0.04199559f, -0.04885503f, 0.00148827f, 
    -0.01370106f, -0.07078181f, -0.03594566f, -0.03234304f, -0.04614587f, -0.07750874f, 0.01802061f, 0.01017738f, 
    -0.02037874f, -0.04233710f, 0.02887383f, -0.07324123f, -0.04204132f, -0.03304467f, -0.00037580f, 0.01217748f, 
    -0.04387196f, -0.08146115f, -0.01785965f, -0.00819204f, -0.06497046f, 0.00463350f, 0.00876714f, -0.00770960f, 
    -0.01026305f, -0.01352733f, -0.04113960f, 0.00236345f, 0.03640125f, 0.02158609f, -0.04400087f, -0.00445512f, 
    -0.04553898f, -0.03956835f, -0.05822111f, -0.03287891f, -0.00429862f, 0.01033012f, -0.00655137f, -0.00830321f, 
    -0.01219088f, -0.04507550f, -0.03302055f, -0.05183282f, -0.08161520f, -0.03814138f, -0.07084420f, -0.01454329f, 
    -0.06138323f, -0.03071717f, 0.00491244f, -0.04989292f, 0.02908775f, -0.00311705f, -0.01570956f, 0.03184022f, 
    -0.04709101f, -0.01973701f, -0.06507759f, -0.00077576f, -0.03327724f, -0.04215892f, -0.02608796f, -0.05236194f, 
    -0.04780097f, -0.04979668f, -0.04887310f, -0.05017384f, -0.04783311f, -0.03326087f, -0.00516900f, 0.04022927f, 
    -0.02375668f, -0.08032530f, 0.02597564f, 0.00926329f, 0.00190811f, -0.07364754f, -0.00145012f, -0.03584773f, 
    -0.00608754f, -0.03624734f, -0.03015039f, -0.04224116f, -0.05180513f, -0.01951637f, -0.00727832f, -0.02878022f, 
    -0.02208653f, -0.04176926f, -0.03006197f, 0.00016034f, 0.01115019f, 0.00486810f, -0.03539407f, -0.05487425f, 
    0.00434952f, -0.02055732f, 0.00394480f, -0.04989058f, -0.06680749f, -0.03890221f, -0.04319602f, -0.01169927f, 
    -0.03935860f, -0.08902493f, -0.00683706f, -0.02075899f, -0.04201478f, -0.03103401f, -0.04727798f, -0.05145021f, 
    -0.05697910f, -0.02900261f, -0.01902287f, -0.01673541f, -0.07863139f, -0.06350464f, -0.02108682f, -0.01348521f, 
    0.05796222f, 0.02435623f, 0.00103410f, 0.01843792f, -0.04868584f, 0.01684546f, -0.00922019f, -0.03895701f, 
    -0.00173705f, -0.08312220f, -0.01544635f, -0.00314492f, -0.00931285f, -0.05098910f, -0.01286936f, -0.05631211f, 
    -0.09420327f, -0.08114369f, -0.04547275f, -0.14898644f, -0.08083637f, -0.01598067f, -0.00634960f, -0.10154152f, 
    -0.00113987f, -0.04582126f, -0.01087304f, 0.01308120f, -0.14956518f, -0.12427125f, -0.23913988f, -0.14581607f, 
    -0.13000852f, -0.01973271f, 0.01145999f, -0.05203347f, 0.00658082f, 0.18549486f, 0.14723477f, -0.10802326f, 
    -0.21938097f, 0.29294896f, -0.07054891f, 0.13969286f, -0.15592602f, -0.07064720f, 0.02397212f, 0.11393436f, 
    -0.00561897f, 0.07006781f, 0.20996550f, 0.16329013f, -0.16069852f, -0.02021730f, -0.15480375f, -0.10043846f, 
    -0.08428743f, -0.04466166f, -0.01223004f, 0.11217538f, 0.02023530f, 0.03777013f, 0.11866062f, -0.05459035f, 
    -0.08236028f, -0.22089900f, -0.17108616f, 0.10141017f, 0.09499469f, 0.00244452f, 0.24126993f, 0.08045641f, 
    -0.14028049f, 0.08181508f, 0.08648604f, 0.10525041f, 0.41223314f, 0.17282933f, 0.46480268f, 0.21351284f, 
    0.16172142f, -0.03754450f, -0.04249156f, 0.12793258f, 0.02355045f, 0.08084051f, -0.02020782f, 0.12884879f, 
    0.62480462f, 0.13344418f, 0.28139684f, 0.33472517f, -0.11475708f, -0.10899630f, 0.17308554f, 0.00668247f, 
    -0.01361985f, 0.13178489f, 0.05629170f, 0.07535044f, 0.10427377f, 0.01943019f, -0.13104776f, 0.20086022f, 
    -0.00320069f, 0.02334903f, 0.07305812f, 0.00670509f, 0.17426319f, 0.24929690f, 0.15584587f, 0.06699776f, 
    -0.32080060f, -0.18604749f, -0.26319718f, -0.21772543f, 0.11893670f, -0.03976798f, 0.07569930f, -0.09158725f, 
    0.03390800f, -0.02582791f, 0.00758120f, -0.10114590f, -0.54821736f, 0.06415560f, 0.41490325f, 0.10126793f, 
    0.12348076f, -0.07437188f, -0.05927273f, 0.04833988f, -0.00149080f, 0.10504087f, 0.22146745f, 0.06196035f, 
    0.01745278f, 0.63135064f, 0.26541522f, 0.04317962f, -0.18449545f, -0.18970244f, -0.06543315f, -0.00948307f, 
    0.05793822f, 0.07376244f, 0.05040275f, -0.05833390f, -0.15663564f, 0.14228000f, 0.19153845f, 0.10101665f, 
    -0.01066882f, -0.03612898f, 0.01710955f, 0.09708752f, -0.04498896f, 0.15263021f, 0.04198342f, 0.12898333f, 
    -0.00838492f, -0.39775386f, 0.08484568f, 0.02423125f, 0.13196747f, 0.19424915f, 0.24233398f, -0.05848356f, 
    0.05468417f, 0.02074836f, -0.05824243f, 0.04641134f, -0.12304059f, -0.03360221f, -0.14902046f, -0.23371057f, 
    -0.02383462f, -0.00629374f, -0.12102348f, -0.01310398f, -0.01064312f, 0.04832614f, 0.12002403f, -0.05968308f, 
    -0.06290562f, -0.03053537f, -0.05139725f, -0.08131935f, -0.09965581f, 0.00848822f, 0.01536495f, -0.05533498f, 
    0.02503685f, 0.08757225f, 0.16816165f, -0.06782090f, 0.02168000f, 0.15830357f, 0.05568471f, 0.19893596f, 
    -0.01556801f, 0.06516080f, 0.16840632f, 0.20171548f, -0.13154408f, 0.20850883f, -0.08567650f, 0.03570645f, 
    -0.19782886f, -0.00370670f, -0.06126340f, -0.20770587f, -0.02786234f, -0.00624767f, 0.08392662f, -0.02895082f, 
    -0.05890973f, 0.08998179f, 0.11652575f, -0.01031394f, 0.19078723f, 0.28441170f, -0.10906492f, 0.03651057f, 
    0.06045222f, -0.03159507f, 0.06854871f, 0.00260509f, -0.06430043f, 0.12820181f, 0.24777375f, 0.11297429f, 
    -0.20532560f, -0.52054149f, 0.51289093f, -0.36807168f, -0.06108839f, -0.05921101f, 0.10094630f, 0.04873914f, 
    -0.13150606f, -0.05634262f, 0.00223710f, 0.18306540f, 0.05433013f, -0.12535012f, 0.14276682f, 0.05514893f, 
    0.17619129f, 0.04635656f, 0.03797121f, 0.12489788f, -0.04547808f, 0.03027382f, 0.05024240f, 0.19137475f, 
    -0.30500776f, -0.08127165f, -0.23945968f, -0.16863231f, 0.10382235f, 0.03306020f, -0.01484139f, -0.08340551f, 
    -0.09456796f, 0.03577040f, 0.03551988f, -0.08094821f, 0.07746421f, -0.11306798f, -0.02673569f, 0.01080389f, 
    0.06206716f, 0.02281512f, 0.18738034f, 0.08938777f, 0.04522263f, 0.03574207f, 0.01027874f, 0.02785821f, 
    0.02243555f, -0.07744739f, -0.06912865f, -0.01573925f, -0.11493392f, -0.14890102f, -0.04041839f, 0.03876748f, 
    -0.04077124f, 0.02500521f, 0.06983963f, 0.08083234f, -0.31516573f, -0.00295021f, -0.27160439f, 0.33739284f, 
    0.01838207f, 0.04791185f, 0.00715582f, -0.09354272f, -0.06902592f, 0.04145972f, 0.07099526f, 0.04774382f, 
    -0.06385900f, -0.04867639f, 0.25593242f, -0.22741444f, -0.07337294f, -0.02819278f, 0.06640773f, 0.03868989f, 
    0.05903289f, 0.17519633f, 0.04151273f, -0.08052345f, -0.15727307f, 0.29936078f, -0.04358875f, -0.03405683f, 
    0.00256056f, -0.04511499f, 0.08285292f, 0.18052843f, 0.13087177f, 0.19301990f, 0.09728130f, 0.06734679f, 
    -0.26973805f, -0.04862322f, -0.29936314f, -0.15924779f, 0.06441523f, -0.01643287f, -0.06250776f, 0.02575993f, 
    -0.04548854f, 0.09307753f, 0.09079440f, 0.08368474f, -0.01387499f, -0.08591606f, 0.09987260f, -0.14259039f, 
    0.03402954f, 0.20457502f, -0.12314780f, 0.07019128f, 0.02793083f, 0.10577346f, 0.06074871f, -0.05902904f, 
    0.05384691f, -0.20880714f, 0.28413042f, 0.10312446f, 0.08237598f, -0.15317740f, -0.13078366f, 0.18273591f, 
    0.06947325f, -0.04189757f, 0.00845875f, 0.08035865f, -0.22447789f, -0.05708187f, 0.32810247f, -0.09400198f, 
    -0.07750671f, 0.08307794f, -0.03997955f, -0.04177630f, -0.05517645f, 0.04392045f, 0.04187791f, 0.14858127f, 
    0.09125078f, -0.09506541f, -0.23114884f, -0.07595094f, -0.12893416f, -0.02327150f, 0.08734892f, 0.21064028f, 
    0.16506915f, 0.01480209f, 0.08219501f, -0.03080504f, 0.10995297f, -0.08897266f, -0.24339892f, 0.04445041f, 
    -0.03449789f, 0.01864170f, 0.04114551f, -0.08996549f, -0.03492062f, 0.09203336f, -0.03053009f, -0.02856698f, 
    -0.07768040f, -0.05949429f, 0.01972242f, -0.06567548f, 0.06501141f, 0.12599340f, -0.05061563f, 0.06577054f, 
    0.06273756f, 0.01337469f, -0.00698302f, 0.02259964f, 0.03349398f, 0.05633641f, -0.04685161f, 0.01578310f, 
    0.09210798f, -0.07180610f, -0.05248088f, -0.07127742f, -0.15076929f, -0.18040541f, -0.08054291f, -0.27552605f, 
    0.21069996f, 0.15169823f, -0.15272149f, 0.36988157f, -0.01027457f, 0.18151018f, -0.00636948f, 0.25171661f, 
    0.13659362f, -0.05506520f, 0.47756392f, 0.14667949f, -0.01684821f, -0.08849231f, -0.13449630f, -0.15853520f, 
    -0.08883027f, -0.08376839f, -0.07042528f, -0.02745258f, 0.09313843f, 0.13010247f, 0.01497481f, 0.06476575f, 
    -0.38740325f, 0.03521052f, 0.03049510f, 0.06313027f, 0.18233816f, -0.00325249f, 0.10905708f, 0.19215980f, 
    -0.10164351f, 0.00872235f, 0.34013239f, 0.01181697f, -0.22892903f, 0.06838307f, 0.33128998f, -0.02455001f, 
    0.22103126f, -0.03103706f, 0.15434933f, -0.05829727f, 0.09155594f, 0.09780249f, 0.12611516f, 0.10424716f, 
    -0.34921381f, 0.10569993f, 0.02855433f, -0.31869784f, -0.11686131f, -0.05865415f, 0.03713222f, 0.12931475f, 
    0.11068925f, 0.15895692f, -0.05495152f, -0.06563219f, -0.01062168f, -0.07875596f, -0.20529991f, 0.22583908f, 
    -0.13922112f, 0.03049219f, -0.13354839f, -0.06244620f, 0.07482760f, 0.16878918f, 0.27633518f, -0.00748480f, 
    -0.02572701f, 0.03428122f, 0.03694060f, -0.02354643f, 0.16391303f, -0.03333217f, -0.11493783f, -0.21708256f, 
    0.09559394f, 0.02458195f, -0.04324070f, 0.14556278f, -0.67205536f, 0.06091719f, -0.19950435f, -0.00317527f, 
    0.00710935f, -0.08962380f, 0.04071837f, -0.02736997f, 0.21174347f, 0.14658131f, 0.21240081f, 0.00789844f, 
    0.14167482f, 0.01082304f, 0.04815269f, 0.02014818f, -0.12007924f, 0.07190484f, 0.06683403f, 0.07751338f, 
    0.13863105f, 0.00209600f, 0.07665323f, -0.05695328f, -0.56644225f, 0.00413542f, -0.24865070f, -0.25767717f, 
    0.06494132f, -0.04742569f, -0.10755092f, 0.11773965f, 0.03572524f, 0.00597626f, 0.06101719f, -0.05588869f, 
    0.13333699f, -0.36130688f, 0.03780026f, -0.12566197f, -0.14380418f, 0.12868735f, 0.19412190f, -0.18405378f, 
    -0.07859610f, 0.09008339f, -0.00887769f, -0.08169206f, 0.08860642f, -0.05073261f, -0.01678406f, -0.03064895f, 
    -0.04787517f, -0.16912602f, -0.24468751f, -0.09845351f, -0.11992712f, -0.15533052f, -0.07352179f, -0.12147948f, 
    -0.10551599f, -0.00514790f, -0.10845002f, 0.00086246f, -0.18221845f, 0.05078186f, -0.07018045f, -0.06393132f, 
    0.08148403f, 0.12696448f, 0.19909222f, -0.06346565f, 0.23917064f, -0.04404953f, -0.22671436f, -0.08311373f, 
    0.00487639f, 0.10288161f, -0.02081682f, 0.23509216f, 0.02212377f, 0.09953602f, -0.05517735f, -0.01573997f, 
    -0.03795773f, -0.28216004f, -0.03222704f, -0.09806259f, 0.00305290f, -0.05880919f, -0.11609470f, 0.06351297f, 
    0.03674370f, -0.07043424f, 0.04379050f, 0.00600408f, 0.19325644f, 0.13051279f, 0.16905509f, 0.03336981f, 
    0.01107541f, -0.01423728f, 0.00823624f, 0.11497223f, -0.04174275f, -0.00058216f, 0.29232085f, 0.00977472f, 
    0.16550462f, -0.31980848f, -0.04973841f, -0.22643110f, -0.03692348f, 0.23509125f, -0.02341184f, 0.16658227f, 
    -0.18482175f, -0.03382122f, 0.29133010f, 0.07737806f, 0.12166915f, -0.01448764f, 0.39381269f, 0.19451895f, 
    0.19920188f, 0.06273708f, 0.13573265f, 0.14073601f, 0.08130638f, 0.06307112f, 0.10082497f, 0.22721097f, 
    -0.01020233f, 0.07557868f, 0.05755302f, -0.13040346f, -0.04906823f, -0.05022879f, 0.04988899f, -0.25073278f, 
    0.08183856f, 0.05992686f, 0.15751706f, 0.08021443f, 0.29715452f, -0.10972794f, 0.25700954f, 0.01830267f, 
    0.15615456f, 0.02893184f, 0.12602793f, 0.16032439f, -0.08379355f, 0.08084908f, -0.02858757f, -0.00031861f, 
    -0.00636338f, 0.00648200f, 0.08152860f, -0.03544655f, -0.07237876f, -0.14847852f, -0.13220248f, 0.02809401f, 
    0.10966980f, 0.02925715f, 0.11500252f, 0.32316625f, 0.13842523f, 0.05776675f, -0.24106610f, 0.01759537f, 
    0.00969945f, 0.09170362f, -0.02050038f, -0.03808902f, 0.05358253f, 0.01344514f, 0.01513891f, 0.17546365f, 
    0.17974249f, 0.03361611f, 0.10132166f, -0.12926401f, -0.13072056f, 0.10997353f, 0.03765918f, 0.03839388f, 
    -0.28408483f, -0.01617081f, -0.09673840f, -0.20791559f, 0.42392075f, -0.02296400f, -0.02406250f, -0.08223421f, 
    0.04579114f, 0.08353914f, 0.15861960f, 0.24268468f, 0.07502417f, 0.08999240f, 0.02097601f, 0.01308342f, 
    -0.04599148f, 0.11561020f, 0.11902897f, -0.16210769f, 0.10278382f, -0.11346536f, -0.01790230f, -0.04636573f, 
    0.11911234f, 0.15669692f, 0.02262280f, 0.03238343f, 0.10477926f, -0.16361803f, 0.50553793f, -0.12573361f, 
    -0.05291241f, 0.11342605f, -0.11677563f, 0.16172716f, -0.05523404f, 0.07927925f, 0.04535813f, 0.04842215f, 
    -0.47176549f, 0.09538616f, -0.02317620f, 0.07408600f, 0.08129084f, -0.17147213f, 0.18591930f, 0.06611286f, 
    0.13234055f, -0.15266038f, 0.12532927f, 0.16981839f, 0.26125285f, 0.10489184f, 0.11159495f, 0.26426268f, 
    -0.12204318f, 0.17650343f, -0.02429602f, -0.03775173f, -0.02333673f, 0.05220718f, -0.04921020f, 0.02678258f, 
    -0.26118231f, -0.23894553f, -0.11026653f, -0.08329304f, -0.08250052f, -0.14946254f, -0.07083657f, 0.28878340f, 
    0.06732076f, -0.00710410f, -0.03352736f, -0.04090321f, 0.54103851f, 0.16390640f, -0.02769408f, 0.24276090f, 
    0.07254491f, 0.01182531f, 0.06643143f, -0.05369543f, -0.05026636f, 0.01978503f, 0.04910016f, 0.03929388f, 
    0.12533481f, -0.02790713f, -0.06143781f, -0.04194226f, 0.06709432f, 0.00927728f, -0.07513176f, 0.04707001f, 
    0.08563037f, 0.00773499f, -0.09456087f, 0.04644209f, 0.03106972f, -0.13920821f, -0.05998902f, -0.09427606f, 
    0.15921114f, 0.06443587f, -0.02750975f, -0.07525306f, -0.01306753f, 0.08320211f, 0.13300547f, 0.01019025f, 
    0.14092757f, -0.34709007f, 0.00479413f, 0.24905269f, -0.06656235f, -0.01539048f, -0.27366805f, -0.01616616f, 
    0.11855795f, -0.17635585f, 0.13832764f, -0.00833462f, -0.19241250f, -0.24061528f, -0.10634330f, -0.02125767f, 
    -0.09711617f, 0.03067449f, 0.02890199f, 0.13341305f, -0.04386947f, -0.06211132f, 0.08041246f, 0.04115506f, 
    -0.03608574f, 0.12248059f, 0.16824643f, -0.01601338f, -0.08596471f, 0.15904924f, 0.28117412f, 0.01156634f, 
    0.00931993f, 0.08218228f, 0.10778593f, 0.00211353f, -0.49342340f, -0.11591664f, -0.16854665f, -0.00217824f, 
    0.07127908f, 0.29640764f, 0.06235466f, 0.06014602f, 0.03919134f, 0.06488323f, 0.05097425f, -0.00965532f, 
    -0.34344405f, 0.19968379f, -0.11297370f, -0.09541494f, -0.03427341f, 0.11566202f, 0.05401853f, 0.05631668f, 
    0.11592756f, -0.05296762f, -0.10902201f, 0.06465874f, -0.12489395f, -0.37906852f, 0.09165197f, -0.01376376f, 
    -0.09950119f, 0.13128974f, -0.14206228f, -0.10786425f, 0.25795758f, 0.07324163f, 0.08400919f, 0.12653813f, 
    0.21373239f, 0.21824503f, -0.19732329f, -0.32482654f, 0.18291953f, -0.04471149f, 0.05984335f, 0.27224511f, 
    0.06165636f, 0.02067977f, -0.03452130f, -0.02828045f, 0.30364239f, -0.13379855f, 0.10704764f, 0.07363201f, 
    0.10747065f, -0.04771996f, 0.02086717f, -0.01200400f, 0.13425489f, 0.02158096f, 0.05843082f, 0.12779069f, 
    -0.63645542f, -0.04559902f, -0.06261304f, 0.10206215f, -0.16569996f, -0.03802629f, -0.01343166f, 0.00392595f, 
    -0.10584437f, -0.02068708f, -0.07008082f, -0.04964039f, 0.02893514f, -0.22797735f, -0.06914654f, 0.02825689f, 
    0.03217473f, -0.04286009f, -0.05927680f, -0.00626448f, 0.04821744f, 0.03480169f, 0.01379726f, -0.02992837f, 
    -0.13768020f, 0.09706535f, 0.13260257f, 0.15291342f, 0.15518095f, 0.15033661f, 0.14335820f, -0.05500839f, 
    0.02704437f, 0.04748414f, 0.04883031f, -0.16089836f, -0.08928873f, -0.14914951f, -0.12425748f, -0.08047978f, 
    0.04338294f, -0.13332039f, 0.02867386f, 0.16586426f, -0.06258400f, -0.03288326f, 0.04929508f, 0.08539371f, 
    0.14201961f, 0.03594000f, -0.07980115f, -0.24714361f, -0.25716820f, 0.06123257f, -0.03072496f, -0.08140180f, 
    0.09700184f, 0.00529403f, 0.07971031f, -0.13717179f, -0.07134710f, -0.02364940f, -0.00444006f, 0.00294297f, 
    0.11299548f, 0.07374529f, 0.18102233f, 0.21671331f, -0.24906963f, 0.16596751f, 0.07311004f, -0.02320018f, 
    0.20047283f, 0.04312684f, -0.00769712f, -0.02381206f, 0.02696714f, -0.10611269f, -0.04919297f, -0.07145669f, 
    0.00929855f, 0.08694679f, 0.06907376f, -0.01063953f, 0.01823233f, -0.03159786f, -0.00659272f, 0.14427224f, 
    0.11371803f, 0.07129194f, -0.00638114f, -0.13013904f, -0.03290953f, -0.05935928f, 0.30877745f, 0.08488762f, 
    -0.48512942f, 0.58915341f, -0.12202363f, 0.44481951f, 0.12499364f, 0.11585180f, -0.02967658f, 0.10116948f, 
    -0.09034605f, -0.02192547f, 0.04489454f, -0.04087806f, 0.36196136f, 0.11864114f, 0.21119915f, -0.02547294f, 
    0.11949070f, 0.03444953f, 0.07286447f, 0.24097189f, 0.03029913f, -0.07461115f, 0.00806298f, 0.15130785f, 
    0.19431145f, 0.24212734f, -0.06563032f, -0.29869032f, -0.02894830f, 0.05937848f, 0.19732124f, 0.02323896f, 
    -0.02302972f, -0.05590991f, 0.07238320f, -0.09958564f, -0.11387921f, -0.04094001f, 0.14255944f, 0.03526059f, 
    0.24855308f, -0.10772506f, -0.01191677f, -0.01057110f, -0.10666329f, -0.09921065f, -0.07554902f, 0.01226452f, 
    0.11828379f, -0.20880686f, 0.05149331f, -0.10953856f, 0.14077431f, -0.09507322f, -0.15722929f, -0.18029758f, 
    0.06504759f, -0.06497797f, -0.05058287f, 0.07835447f, 0.37637946f, 0.10566614f, 0.43858668f, -0.27665517f, 
    0.05139384f, -0.18873622f, -0.03238140f, -0.05985077f, -0.10856487f, 0.10089169f, -0.03597794f, -0.02628945f, 
    -0.46374270f, -0.05226612f, -0.10887488f, -0.04657295f, -0.04326884f, 0.08234475f, 0.09409044f, 0.12768795f, 
    0.07130189f, 0.01854763f, -0.00168062f, -0.17414358f, -0.48101148f, -0.02476886f, 0.07015776f, 0.29234147f, 
    -0.02667851f, 0.13676141f, 0.05547732f, 0.13714328f, 0.02377022f, -0.05213455f, 0.05982565f, 0.06583937f, 
    0.39560187f, 0.05439293f, 0.18709879f, -0.22128594f, 0.09099685f, 0.02481765f, -0.15940325f, -0.09269035f, 
    0.03297740f, -0.15965359f, 0.04999800f, -0.05822554f, -0.00126397f, 0.15860726f, 0.12858827f, -0.10646795f, 
    0.03191794f, 0.02883174f, -0.12117317f, 0.21929170f, 0.03531469f, -0.11281727f, -0.02449324f, -0.09100694f, 
    -0.26369402f, 0.17579302f, -0.05744763f, -0.00365738f, 0.04521806f, -0.13903113f, -0.07678148f, -0.10990870f, 
    0.07489847f, -0.04960780f, -0.17668273f, -0.02551684f, -0.10955786f, 0.11264461f, -0.16211468f, 0.10634347f, 
    0.17913227f, 0.02630918f, -0.11950320f, 0.10095661f, 0.05870596f, -0.22164875f, -0.03165569f, -0.00191863f, 
    0.45492330f, -0.08815902f, 0.27302307f, 0.03061509f, 0.04006926f, -0.07498296f, 0.11849927f, 0.03936557f, 
    0.09201259f, -0.08164555f, 0.13790101f, 0.00850835f, 0.14278640f, 0.12004188f, 0.01328955f, 0.24865916f, 
    0.12822771f, 0.08853222f, -0.13354826f, 0.15675417f, -0.07414344f, -0.07492456f, 0.05631268f, -0.03270419f, 
    0.16605529f, 0.25839588f, 0.22315051f, 0.12459853f, 0.06919322f, 0.16151969f, 0.05149475f, -0.00538104f, 
    -0.02232809f, 0.05480960f, -0.04663809f, -0.02714330f, -0.16963655f, -0.24399924f, -0.01684442f, 0.04084183f, 
    0.03500693f, -0.05623880f, -0.03092553f, 0.07321282f, 0.16620392f, -0.09034049f, 0.05939448f, 0.09762258f, 
    0.17172270f, -0.30746204f, 0.05594264f, 0.28885266f, 0.07130020f, 0.16323969f, -0.13931413f, -0.00518779f, 
    0.17344005f, -0.05315913f, 0.34946951f, 0.17754743f, -0.06198512f, -0.09722406f, -0.02906837f, 0.04763981f, 
    0.06692285f, 0.06690018f, 0.02140930f, 0.08212327f, 0.04203549f, 0.19161668f, 0.10966913f, 0.13018307f, 
    -0.19686897f, 0.23375522f, 0.33663854f, 0.01415704f, 0.10704577f, 0.08019700f, 0.05329859f, 0.14017735f, 
    -0.04581615f, -0.00315737f, 0.05915655f, -0.02328318f, -0.10731728f, 0.24835603f, -0.07506894f, 0.18409660f, 
    0.14566381f, 0.02882244f, 0.08835620f, 0.03090194f, -0.04348748f, 0.00989394f, -0.15337773f, -0.00679864f, 
    -0.42544505f, 0.38171697f, 0.06590738f, -0.07444261f, 0.11867566f, -0.00562264f, 0.12473730f, 0.01531834f, 
    0.17788887f, -0.03596096f, -0.17393364f, -0.16058040f, -0.39429486f, -0.23815364f, -0.27226284f, 0.02920020f, 
    -0.00419500f, -0.03072591f, 0.01663888f, 0.02791183f, 0.06203854f, 0.12521854f, 0.13570930f, 0.02167468f, 
    0.10641104f, 0.21302991f, 0.17888768f, -0.01925230f, 0.20459560f, 0.03419159f, -0.00049682f, 0.07277393f, 
    0.00578948f, -0.01424795f, -0.05051168f, 0.03549164f, -0.06537760f, 0.14636114f, 0.18163292f, 0.18838733f, 
    0.02185390f, -0.02445557f, 0.02785948f, 0.19555907f, 0.09053539f, 0.07519141f, 0.05050875f, -0.08999283f, 
    -0.03633449f, -0.06108565f, -0.07549473f, -0.14105812f, -0.02927801f, 0.01749680f, -0.03411742f, 0.04243690f, 
    0.21411805f, 0.08464873f, -0.31910959f, -0.03767541f, -0.07672385f, -0.09456786f, 0.10083263f, 0.14529723f, 
    0.00772698f, 0.09476727f, 0.06276982f, 0.03185625f, -0.04944087f, -0.04014958f, 0.11924142f, -0.06759477f, 
    -0.01479661f, 0.04193376f, 0.00052780f, -0.25113052f, 0.03166851f, -0.09245339f, -0.01688467f, -0.07857697f, 
    -0.00710541f, 0.02303406f, -0.00602961f, -0.05112471f, -0.25350726f, -0.27284035f, -0.08893832f, -0.02619519f, 
    -0.02564799f, 0.02981753f, -0.01737791f, 0.09242848f, 0.01888251f, -0.00921981f, 0.11646817f, 0.13348523f, 
    -0.13608676f, -0.07735121f, -0.04052870f, -0.02366231f, -0.02366634f, 0.03572957f, -0.03479002f, 0.09055554f, 
    0.09463099f, 0.00930779f, 0.04238921f, 0.00962703f, 0.27568462f, 0.16925469f, -0.05714998f, 0.02030299f, 
    0.06643678f, 0.06273672f, 0.02760216f, -0.02984924f, -0.02183048f, 0.00048843f, 0.04537630f, -0.04724297f, 
    0.19949028f, 0.05892612f, -0.00365671f, 0.03022742f, -0.09637632f, 0.04994669f, -0.18431525f, -0.15445822f, 
    -0.03635034f, -0.08203591f, -0.37139928f, -0.10462487f, -0.01708687f, -0.29286832f, -0.03005035f, 0.19716343f, 
    0.00647559f, -0.02388697f, -0.05153442f, 0.03700800f, 0.04623586f, 0.14130947f, 0.00937493f, 0.04519306f, 
    0.21431534f, 0.12925877f, -0.22145121f, 0.00894953f, 0.20898245f, 0.06583073f, -0.12778333f, 0.05144867f, 
    -0.06373645f, 0.00432420f, 0.02349262f, -0.00364388f, 0.10818848f, 0.27853355f, 0.18871096f, 0.35283369f, 
    -0.00487897f, 0.09055473f, -0.04729308f, 0.14700356f, 0.03965901f, 0.04554920f, -0.06411732f, 0.04144673f, 
    0.18816036f, 0.27403682f, 0.25656608f, 0.03542349f, -0.06980161f, -0.02882192f, 0.15007368f, 0.03135688f, 
    0.08279056f, -0.04450731f, 0.05277076f, -0.10627110f, -0.01334838f, -0.08014204f, 0.12983565f, 0.08962793f, 
    0.07988812f, 0.05897805f, 0.02247012f, 0.05382337f, -0.02970731f, 0.06314842f, 0.06008170f, -0.06019324f, 
    -0.17211355f, -0.17419052f, -0.07535869f, -0.05320297f, -0.00915381f, 0.04467004f, -0.06274160f, 0.05233100f, 
    0.02874687f, 0.02804875f, 0.15469129f, 0.12141761f, 0.16093200f, 0.09630395f, -0.06877913f, -0.42785054f, 
    -0.12961327f, -0.00477743f, -0.00928373f, 0.16695423f, 0.04926558f, -0.04871844f, 0.04098727f, 0.01076187f, 
    -0.23056547f, -0.25565737f, -0.52351725f, -0.26755893f, 0.03746781f, 0.02976247f, -0.03996994f, -0.03981796f, 
    -0.09215754f, -0.10751615f, -0.02329617f, -0.21456987f, 0.15131699f, -0.03222856f, 0.19096227f, -0.17916936f, 
    -0.05482425f, 0.00838557f, 0.03341050f, -0.06082982f, -0.02474526f, -0.17547296f, 0.18742464f, -0.15149574f, 
    0.20564504f, 0.21652772f, 0.39257675f, -0.03693688f, 0.02858195f, -0.07078368f, -0.03719850f, -0.02434459f, 
    0.03313914f, -0.12652929f, 0.02556240f, -0.05671734f, -0.05766784f, -0.23601988f, -0.03375609f, 0.02979166f, 
    -0.03479661f, 0.02058491f, 0.08446781f, 0.22718000f, -0.00252097f, 0.00591950f, 0.12137147f, -0.04362272f, 
    0.03309701f, 0.15218100f, 0.04944081f, 0.05889671f, 0.17263183f, -0.07252441f, -0.00288921f, 0.30102760f, 
    0.07580453f, -0.00713963f, 0.08578776f, 0.00243313f, 0.26801372f, -0.12567185f, -0.23747544f, -0.24928510f, 
    0.04339497f, -0.02936378f, -0.03825457f, 0.06023495f, 0.02139051f, 0.00609282f, 0.00742740f, -0.02224485f, 
    -0.25591904f, -0.08185269f, 0.04561017f, 0.17895226f, -0.02929855f, -0.03629974f, 0.03951278f, 0.15401584f, 
    0.01867162f, 0.05779205f, -0.04507456f, -0.17398088f, 0.15570782f, -0.13368340f, -0.04493390f, 0.07012752f, 
    0.04798057f, -0.03032301f, -0.00677847f, 0.08053210f, 0.09901936f, -0.08780652f, 0.11317601f, 0.12870628f, 
    0.11692163f, -0.00886663f, 0.09925198f, 0.12777907f, -0.03199267f, 0.06522532f, 0.11460948f, 0.29347372f, 
    0.04685897f, -0.03214707f, 0.12054443f, 0.07454223f, -0.19754519f, -0.05091264f, -0.10799266f, -0.11073355f, 
    0.09551606f, -0.05151814f, -0.01634027f, -0.09208823f, -0.13119930f, -0.03440682f, -0.11701938f, -0.12477507f, 
    0.21114843f, -0.16067195f, 0.06280960f, 0.09541757f, 0.14025165f, 0.09129018f, -0.03452419f, -0.00542257f, 
    0.18333569f, 0.00986409f, 0.10306295f, 0.01770852f, -0.11396229f, -0.00890414f, -0.05350903f, 0.03628609f, 
    0.11448587f, 0.02054758f, 0.06328060f, 0.03515262f, -0.06363754f, 0.02536008f, -0.03566613f, -0.04329102f, 
    0.03609478f, 0.02054651f, -0.22415209f, 0.13763836f, 0.03166035f, 0.13669232f, 0.00682918f, 0.08084001f, 
    0.07446299f, -0.02622868f, 0.07718574f, -0.07345658f, -0.09113389f, 0.27404496f, -0.06263407f, 0.19462024f, 
    -0.12070497f, 0.00695389f, 0.09683961f, 0.19786032f, 0.01415621f, -0.16350515f, 0.17187981f, -0.03522310f, 
    -0.29930919f, -0.21597205f, 0.21218748f, 0.13222247f, -0.01176905f, 0.06762406f, -0.05158659f, 0.17534658f, 
    -0.01079000f, 0.18951473f, 0.04179173f, -0.02557248f, -0.06934418f, -0.05945750f, 0.02845598f, 0.01296369f, 
    -0.03742787f, -0.15417644f, 0.03620910f, -0.00255831f, 0.07262612f, 0.14678070f, -0.00162855f, 0.12144796f, 
    0.21889724f, 0.15008326f, -0.01038999f, -0.05519307f, 0.01049148f, 0.05273604f, 0.12380468f, 0.14673296f, 
    0.04664021f, 0.05468839f, 0.06890497f, 0.05082133f, 0.22630112f, 0.09046621f, -0.10214871f, -0.10253092f, 
    -0.05990815f, 0.07285418f, 0.02577889f, -0.04270089f, 0.22473885f, 0.18818435f, -0.10663928f, 0.08122420f, 
    -0.27001631f, -0.22977716f, 0.18810250f, -0.09245789f, -0.00521080f, 0.04738060f, 0.02964920f, -0.12161543f, 
    0.01310413f, -0.05742301f, 0.20107494f, 0.01020059f, 0.06504187f, 0.05412850f, -0.03634019f, 0.05610205f, 
    0.00972302f, 0.01987273f, 0.04819928f, 0.05757879f, 0.05529534f, -0.09589569f, 0.01545767f, 0.06977546f, 
    -0.16789931f, -0.04464871f, -0.20860381f, -0.08535488f, -0.00355857f, -0.00420204f, -0.08245612f, -0.24473055f, 
    -0.08267452f, 0.20937236f, -0.08804609f, -0.12602030f, 0.01571337f, 0.05294453f, -0.07458832f, -0.09846782f, 
    -0.01992273f, 0.03699131f, -0.00468677f, -0.00859216f, 0.10303093f, -0.04751037f, -0.00943732f, 0.14147885f, 
    -0.02420063f, 0.04350318f, 0.04753281f, -0.01762711f, -0.07564760f, 0.04576640f, 0.01647353f, -0.08390369f, 
    0.04785905f, -0.05766414f, 0.10804854f, 0.01172037f, -0.06242524f, -0.12434443f, -0.02865160f, 0.08589109f, 
    0.18592618f, -0.01970818f, 0.00797182f, 0.16233037f, -0.02702932f, -0.16278748f, 0.08854131f, -0.06060264f, 
    0.10017570f, -0.06584387f, 0.17058860f, -0.05853821f, -0.01573827f, 0.02598550f, -0.01842444f, 0.10305204f, 
    0.07752811f, -0.15588278f, 0.23248532f, 0.01616389f, -0.01926827f, -0.01434047f, 0.34327784f, 0.29985836f, 
    0.00582536f, -0.02101765f, 0.03590795f, -0.05269821f, 0.03595273f, -0.03165594f, -0.02805745f, 0.16608262f, 
    -0.15943180f, 0.01726373f, -0.20130754f, 0.18628198f, 0.02363529f, 0.13577279f, 0.24289837f, -0.00059351f, 
    -0.13645677f, -0.07194215f, 0.16604361f, -0.29326925f, 0.08789306f, 0.23665491f, 0.05100213f, 0.02647740f, 
    -0.03316824f, 0.02032635f, 0.09493592f, -0.00821415f, 0.04220046f, 0.01639024f, 0.07702436f, -0.00896128f, 
    0.26791081f, 0.04959871f, -0.20559336f, -0.07187577f, -0.04433208f, -0.00103227f, 0.06740227f, 0.07100523f, 
    0.09155871f, -0.01581921f, 0.09322076f, 0.00274754f, -0.24494269f, 0.08149210f, -0.00680028f, 0.08669279f, 
    0.10549629f, 0.06497010f, -0.16542503f, 0.16858548f, 0.06727601f, -0.05488839f, 0.01369762f, 0.06550819f, 
    -0.03464135f, 0.06325884f, 0.01956667f, -0.08028493f, -0.00129416f, 0.01175566f, -0.01094316f, 0.04972360f, 
    0.10226865f, 0.02607111f, 0.06075567f, 0.26905581f, 0.13328570f, -0.34876323f, 0.14502570f, 0.03640528f, 
    -0.06204762f, 0.06530968f, 0.00901851f, 0.12804048f, 0.04791699f, 0.08624853f, 0.10414553f, 0.03739125f, 
    -0.44590753f, -0.23295440f, 0.06984827f, 0.00749653f, 0.01160642f, -0.03619123f, -0.04342111f, -0.14914443f, 
    -0.03413028f, 0.04719101f, -0.19449203f, 0.02688015f, -0.29874143f, -0.39095205f, -0.01022758f, 0.46606776f, 
    0.06193605f, 0.00723980f, -0.07625482f, 0.03162608f, -0.14027081f, -0.07891842f, -0.23560438f, 0.24008729f, 
    0.16990103f, 0.29980206f, 0.11688723f, -0.12636769f, 0.06712589f, 0.04429372f, 0.05877931f, 0.00509586f, 
    0.09986833f, 0.13671905f, -0.16570051f, 0.13213769f, -0.03203512f, -0.08598317f, 0.22399296f, 0.03587731f, 
    0.03920169f, -0.21303752f, -0.00540446f, 0.09485063f, 0.01139176f, -0.04120082f, -0.05811179f, 0.01808757f, 
    0.27183974f, -0.00369249f, 0.29205137f, -0.06755159f, -0.27448377f, 0.05663812f, 0.07424475f, -0.12803030f, 
    -0.08359380f, 0.01075429f, 0.10516677f, 0.04585002f, -0.36391506f, 0.12523751f, 0.05795084f, 0.07402524f, 
    0.11738162f, 0.04795528f, -0.04189947f, -0.05038215f, 0.00485193f, 0.01721290f, 0.07402189f, 0.06497032f, 
    -0.14409040f, 0.06083026f, 0.09330559f, -0.09995486f, -0.02048786f, 0.04274090f, 0.14343397f, -0.03872043f, 
    0.06232433f, -0.07221512f, -0.23473151f, 0.07936665f, -0.14013521f, 0.18440953f, -0.24658078f, 0.01605904f, 
    0.03731460f, 0.01288818f, -0.01106279f, 0.12540579f, 0.11644785f, 0.06132735f, 0.08914606f, 0.04968356f, 
    0.14433470f, 0.05398664f, -0.05354157f, -0.03620964f, -0.00476449f, -0.11620110f, -0.09333821f, -0.15771361f, 
    -0.14437601f, -0.10684852f, -0.09548592f, -0.13106380f, -0.07393923f, 0.06824512f, 0.00393167f, -0.07544278f, 
    -0.08687126f, 0.00331978f, -0.03573204f, 0.11244525f, 0.06523007f, 0.16246538f, 0.02503341f, 0.19826746f, 
    -0.30964634f, 0.48063239f, -0.24735631f, -0.14641295f, -0.07267196f, 0.01704654f, 0.08174103f, -0.01279502f, 
    -0.23906396f, 0.22034900f, -0.31014076f, 0.08970193f, 0.08851119f, 0.04992738f, 0.02358496f, -0.00773381f, 
    -0.09274222f, 0.07232722f, -0.00958573f, 0.07591806f, -0.06594173f, -0.02703949f, -0.01835405f, -0.14374827f, 
    0.37564924f, 0.30398250f, -0.14476454f, 0.08194181f, -0.06700757f, 0.11277862f, 0.03344519f, -0.00299955f, 
    0.02138050f, 0.08906146f, -0.04373499f, -0.08925188f, 0.47974750f, -0.08765276f, 0.15129553f, -0.12329563f, 
    0.12709722f, 0.22034781f, -0.02519361f, 0.05305722f, -0.03334376f, -0.00263171f, 0.03020444f, 0.07488836f, 
    0.39472419f, -0.40420428f, 0.22765477f, 0.26169270f, 0.10407045f, 0.27636796f, -0.24117652f, -0.04295233f, 
    -0.08348182f, 0.07329466f, 0.09969033f, 0.16175489f, 0.08971376f, -0.00269495f, -0.04119198f, 0.08702637f, 
    0.03472364f, 0.04298546f, -0.00159437f, 0.15577549f, -0.05592865f, 0.08290904f, -0.10712195f, -0.01922671f, 
    0.09835225f, -0.12457441f, -0.33593521f, 0.00431431f, -0.04226892f, 0.09929090f, 0.13038304f, -0.07993048f, 
    -0.07891812f, -0.06950858f, -0.04322587f, -0.07709277f, 0.04014816f, 0.32941055f, -0.12674801f, -0.06446639f, 
    0.07410536f, 0.02121023f, 0.13165286f, 0.00806903f, -0.12285331f, -0.08353195f, 0.12825140f, 0.07915100f, 
    0.18922417f, 0.03121813f, -0.13705248f, 0.47455510f, -0.04729510f, -0.05341242f, 0.11529712f, -0.10824652f, 
    -0.21213825f, -0.01601763f, -0.21070985f, -0.08928650f, -0.11646672f, 0.05040250f, -0.08089572f, 0.07653303f, 
    0.01587432f, 0.10061620f, 0.05530992f, -0.06987499f, 0.10326973f, 0.15517773f, 0.01284166f, 0.05059802f, 
    0.05996339f, -0.26707357f, 0.24275815f, -0.06012738f, -0.03911488f, 0.14668618f, -0.09211475f, -0.11581933f, 
    -0.01708849f, -0.10901113f, 0.11413690f, 0.10597476f, 0.01544991f, 0.01865903f, 0.04641581f, -0.11998063f, 
    0.03219745f, 0.06292687f, 0.07416105f, 0.06866641f, 0.09297756f, 0.23691241f, 0.06149309f, 0.05840315f, 
    0.01886705f, 0.07992662f, 0.00528532f, 0.03792311f, -0.03418913f, 0.05239332f, -0.15115727f, 0.02733423f, 
    -0.14960717f, -0.05937047f, 0.05229992f, -0.10830395f, 0.04348087f, -0.04154545f, -0.13216883f, 0.16688848f, 
    0.03606480f, 0.14449495f, 0.05712438f, -0.13348725f, 0.09011514f, 0.13776159f, 0.01095519f, 0.14674868f, 
    0.08838563f, 0.07153574f, -0.09699295f, -0.06172213f, 0.12042246f, -0.03635870f, 0.19923976f, 0.09265748f, 
    -0.09619428f, 0.01577171f, -0.10878614f, -0.02943715f, -0.05171421f, 0.12588087f, -0.07044108f, -0.02149100f, 
    -0.01112640f, 0.06970514f, -0.08364040f, 0.09865434f, -0.05499040f, 0.19214436f, 0.02715157f, 0.14596927f, 
    0.40924963f, -0.70075250f, 0.58361560f, 0.02186655f, -0.09537505f, -0.10892928f, 0.04010661f, -0.02634262f, 
    -0.02948467f, 0.09007622f, -0.07685445f, 0.01203269f, 0.23751542f, 0.12043712f, -0.03085116f, -0.20596074f, 
    0.02667952f, -0.04245352f, 0.06063692f, -0.10802682f, 0.00910302f, 0.01519689f, -0.05920937f, -0.08541708f, 
    0.19580114f, 0.03247699f, -0.36972615f, 0.02938967f, 0.11326185f, 0.13855593f, 0.07029628f, 0.03897189f, 
    -0.08295124f, -0.06419127f, -0.21841376f, 0.02621043f, 0.20248090f, -0.05078064f, 0.29721946f, -0.14096345f, 
    0.02168761f, -0.11206370f, -0.00124362f, -0.01476004f, -0.01242600f, -0.05590705f, 0.08232184f, 0.03422874f, 
    -0.02716778f, 0.01861104f, -0.06913795f, -0.05311013f, 0.01837007f, 0.06601234f, 0.00615680f, 0.05588888f, 
    -0.07001026f, 0.09961974f, -0.02585907f, -0.01210093f, -0.25009283f, 0.53761578f, -0.16358346f, 0.20898341f, 
    0.06049490f, -0.10154704f, 0.01562306f, -0.00562032f, -0.01391953f, 0.02546426f, 0.07270784f, -0.00178239f, 
    -0.10843333f, -0.21978405f, 0.11068568f, 0.10290051f, -0.07677640f, 0.03711662f, -0.11499340f, 0.03063674f, 
    0.06954449f, 0.09794375f, 0.28646135f, 0.09569695f, -0.07329150f, -0.08995333f, 0.11018088f, 0.10689723f, 
    0.11363366f, -0.02427436f, -0.07966883f, -0.07729805f, -0.03371810f, 0.25368467f, -0.09851095f, 0.18894422f, 
    0.22861049f, -0.02620475f, -0.30739984f, 0.00158561f, 0.05678533f, 0.16782872f, 0.05620232f, 0.10286640f, 
    -0.05853365f, 0.01947829f, -0.02667143f, -0.03175271f, 0.04744081f, 0.30852726f, 0.08326598f, -0.09608805f, 
    0.04665266f, -0.00066811f, 0.19910720f, -0.16064428f, 0.07403049f, 0.04834665f, -0.05805089f, 0.07418803f, 
    0.15469073f, 0.16184485f, -0.04495198f, -0.07411700f, -0.06361929f, -0.17807156f, 0.11796854f, 0.05281529f, 
    -0.14973247f, -0.12838444f, -0.10804800f, -0.18721189f, -0.14713840f, -0.06978912f, 0.18730630f, 0.08282387f, 
    -0.04644805f, -0.00591038f, -0.05495277f, -0.02398868f, -0.18877883f, 0.04762316f, -0.07335317f, -0.00263955f, 
    -0.02545156f, 0.13442886f, 0.15387154f, -0.31180245f, -0.12476670f, 0.09233063f, 0.03291021f, 0.16536507f, 
    -0.02791272f, 0.07004007f, 0.17556369f, 0.13020308f, -0.13949285f, -0.01055768f, 0.12864390f, -0.20788002f, 
    -0.02214449f, 0.03029583f, -0.04593194f, 0.01049384f, -0.22652620f, 0.12481388f, -0.04238578f, -0.03435247f, 
    0.25603411f, 0.08095239f, 0.09777667f, 0.00622826f, -0.04228794f, -0.09293991f, -0.02301276f, 0.18784837f, 
    -0.00585829f, 0.05261626f, -0.02330499f, -0.00463692f, 0.03254228f, 0.06957678f, 0.06069083f, 0.06587725f, 
    0.03300337f, -0.00760991f, 0.01789255f, -0.03577339f, 0.07699469f, 0.07351047f, 0.09906858f, 0.03989348f, 
    -0.04512545f, 0.06325041f, 0.21331306f, -0.00053542f, 0.13691242f, -0.04637788f, 0.14205214f, 0.09359932f, 
    -0.18638076f, 0.19323468f, -0.10319827f, -0.02149406f, 0.11078777f, -0.03708414f, 0.07114353f, -0.02628235f, 
    0.00971986f, 0.02074386f, -0.04953166f, 0.02712587f, 0.05501708f, 0.11835599f, -0.09554525f, -0.08433535f, 
    0.21436733f, 0.01572982f, -0.05153513f, 0.19356103f, -0.10723282f, 0.11465625f, -0.11703151f, -0.20175162f, 
    -0.03903437f, -0.02807206f, -0.09695528f, -0.16472347f, 0.02914049f, 0.26965353f, 0.18938334f, -0.31377655f, 
    -0.12814565f, -0.25444201f, 0.14666706f, -0.00840126f, -0.01081713f, -0.16268679f, 0.04010878f, -0.19753201f, 
    -0.00860638f, -0.17051157f, 0.11141404f, -0.40296236f, -0.12782615f, -0.06558475f, -0.03627979f, 0.09820829f, 
    -0.07343227f, -0.02387579f, -0.08375578f, -0.12145314f, 0.15665095f, -0.12516704f, 0.02073731f, -0.11735142f, 
    0.03188090f, -0.05526128f, 0.13327558f, -0.06228143f, -0.09090406f, -0.11719919f, -0.15208709f, 0.06651983f, 
    0.28617284f, 0.02935474f, 0.14953969f, 0.19334251f, -0.29265210f, -0.05450637f, -0.13276275f, 0.27825752f, 
    0.01271154f, -0.02906993f, -0.02808434f, -0.00481274f, 0.08929165f, 0.02276292f, -0.47972363f, 0.25822034f, 
    -0.08719549f, -0.08584341f, -0.00032761f, -0.11505108f, -0.03161927f, 0.10880958f, -0.02720906f, -0.08915512f, 
    0.17911012f, -0.40460011f, -0.00114771f, 0.03028042f, -0.07314003f, 0.11699288f, 0.05926820f, 0.10739143f, 
    -0.28720763f, 0.06238932f, 0.03622229f, 0.06877650f, 0.18200940f, 0.12514170f, -0.20555034f, -0.22730032f, 
    -0.00886452f, -0.15536925f, -0.05632955f, -0.00566140f, -0.01544376f, -0.10626010f, -0.04355842f, 0.00264877f, 
    0.09359359f, 0.18758681f, 0.27414316f, -0.19161221f, 0.01020457f, -0.05759936f, -0.01080916f, -0.02490771f, 
    -0.08326510f, 0.05151007f, 0.04724716f, 0.07117327f, 0.01649482f, -0.04236592f, 0.03158827f, 0.09855624f, 
    -0.01607887f, 0.03656814f, 0.03516683f, -0.04854447f, 0.17891398f, 0.15193519f, -0.06302328f, 0.05324024f, 
    0.07453382f, 0.14696577f, 0.06080187f, -0.00909211f, 0.05280752f, 0.15158758f, 0.00530627f, 0.00306848f, 
    -0.06743119f, -0.07129778f, 0.01626543f, 0.00789799f, -0.05391682f, -0.23270047f, 0.09216452f, -0.18429172f, 
    0.13122462f, -0.10842722f, -0.02991271f, -0.18161666f, -0.00523542f, -0.03765325f, 0.10013055f, -0.07531923f, 
    0.12869255f, -0.02730690f, 0.28070211f, 0.00767923f, 0.07894231f, -0.00566154f, 0.03050873f, -0.01085742f, 
    0.15871429f, -0.01362527f, 0.06970158f, 0.10409898f, -0.09868572f, -0.15810785f, 0.16566479f, 0.11641438f, 
    -0.02386254f, 0.10764536f, -0.01827374f, -0.04581470f, 0.10207020f, -0.15327014f, 0.03011314f, -0.00116146f, 
    0.19972983f, 0.24120794f, -0.19302349f, -0.01099856f, 0.02068570f, 0.13137102f, 0.15351357f, 0.08463915f, 
    -0.06316810f, 0.18468606f, 0.04838695f, -0.04065897f, 0.02179191f, 0.03105055f, 0.19392255f, -0.21281742f, 
    -0.03693411f, -0.12486065f, 0.10722924f, -0.00935006f, 0.09976625f, 0.05627585f, 0.10253842f, -0.14400436f, 
    0.27076039f, -0.07887272f, -0.01033448f, 0.32548812f, -0.08364368f, 0.11146943f, -0.02689658f, 0.08380061f, 
    0.13790357f, -0.01252674f, -0.02145211f, 0.08026225f, -0.07296318f, 0.15670085f, 0.36499438f, -0.16014513f, 
    0.10151347f, -0.07220206f, -0.09926183f, -0.12722510f, 0.01279897f, 0.01180942f, 0.00895886f, -0.03407024f, 
    0.20467320f, 0.04757751f, 0.12827335f, 0.03660800f, -0.00663484f, 0.12401269f, 0.07453570f, -0.06883943f, 
    0.03251670f, -0.05360083f, -0.04934110f, -0.05777316f, 0.15875652f, 0.26684952f, 0.00042685f, 0.08496375f, 
    -0.12559628f, 0.05719478f, -0.05834093f, 0.01970305f, -0.06263300f, -0.00089664f, 0.05587411f, -0.08636631f, 
    0.18246795f, 0.01127374f, 0.04362825f, -0.02486376f, -0.03855363f, -0.00809786f, -0.03562908f, 0.14574926f, 
    0.03010381f, -0.00727417f, -0.10885800f, 0.30147836f, -0.07291958f, -0.21213827f, 0.47473747f, 0.17033418f, 
    -0.03569747f, -0.03222218f, -0.06019486f, 0.12505123f, -0.16223364f, -0.11910552f, -0.13457575f, 0.02077242f, 
    0.10288192f, 0.24758136f, -0.01339612f, 0.28031105f, 0.05398046f, 0.02018838f, -0.00206893f, 0.01929149f, 
    0.01507590f, 0.17344722f, -0.02135137f, 0.04289968f, -0.24625711f, -0.21543801f, 0.47869849f, 0.07689018f, 
    -0.01580633f, -0.03005233f, -0.08426803f, -0.01147577f, 0.09819775f, -0.13306783f, -0.05154142f, 0.11205154f, 
    -0.36887607f, 0.27539167f, -0.36373243f, 0.09199032f, 0.07668028f, 0.21930750f, 0.39013949f, -0.32008499f, 
    -0.02006122f, -0.08225513f, -0.11808291f, -0.06063722f, 0.45620966f, 0.13182533f, -0.06082882f, 0.29657206f, 
    -0.07134668f, -0.00086394f, 0.00330726f, 0.04452051f, -0.05418897f, 0.08352991f, -0.02715752f, 0.00050575f, 
    -0.10386692f, 0.04247585f, 0.11149191f, -0.12112008f, 0.07776014f, 0.00140959f, -0.02215109f, 0.01170183f, 
    -0.01946995f, 0.11867445f, -0.01368042f, 0.03390086f, 0.14925840f, 0.28983417f, 0.21297440f, 0.20762201f, 
    -0.08259699f, 0.02655810f, -0.04131570f, 0.05946281f, -0.07132811f, -0.08527221f, 0.06700624f, 0.01530758f, 
    0.22451724f, 0.23090096f, 0.19473988f, 0.36239386f, 0.02403484f, -0.04362057f, 0.07596649f, 0.14127260f, 
    0.05968470f, 0.04231836f, 0.09365778f, 0.02124090f, -0.17338181f, -0.01571421f, -0.04764917f, -0.25585890f, 
    -0.10724933f, -0.10292933f, -0.02362405f, -0.07877924f, -0.00555859f, 0.07648262f, 0.09808933f, -0.02433183f, 
    -0.21417031f, 0.23514009f, 0.06796313f, -0.19361557f, 0.14522126f, -0.06464043f, 0.14747259f, 0.06058004f, 
    -0.13957483f, 0.20430757f, -0.26463628f, 0.04356738f, -0.06849290f, -0.08733571f, -0.10180928f, -0.08798152f, 
    0.00124003f, -0.02381844f, -0.02043388f, -0.14526404f, 0.01866990f, 0.05728501f, 0.03604159f, -0.02600657f, 
    0.32517964f, 0.12600131f, 0.08533422f, 0.01808642f, -0.04236140f, 0.03292663f, -0.08974891f, -0.12481658f, 
    -0.07226255f, -0.08799437f, -0.13556902f, -0.09000574f, 0.49191022f, -0.07803614f, 0.28364000f, 0.06426248f, 
    0.14822836f, -0.15140846f, 0.17579372f, 0.04050772f, -0.05425469f, 0.04468776f, -0.03614689f, 0.01327556f, 
    0.41206470f, -0.25573507f, -0.02810239f, 0.16736142f, 0.22203943f, -0.02537037f, -0.02624294f, 0.03078560f, 
    -0.09953394f, 0.02477898f, 0.16798061f, 0.00493698f, -0.04207055f, 0.00137176f, -0.09973431f, -0.16638701f, 
    0.04484031f, -0.01327660f, 0.08697313f, 0.04456444f, -0.12693381f, -0.14158022f, -0.11888127f, -0.11439637f, 
    0.10290638f, 0.09107908f, 0.27812073f, 0.37275314f, -0.15068005f, 0.11712345f, -0.02246179f, 0.00190365f, 
    -0.00551263f, -0.00833182f, -0.04396201f, 0.06634753f, 0.01970951f, 0.05390868f, -0.33865204f, -0.10449427f, 
    -0.05811938f, 0.12228047f, 0.00145420f, -0.15823340f, -0.08423892f, -0.02693222f, -0.02532018f, -0.10861664f, 
    0.15334193f, -0.33610216f, -0.04029936f, 0.17510270f, 0.10768002f, 0.14162707f, 0.01407982f, -0.02615188f, 
    0.06336088f, 0.20791955f, 0.28408694f, 0.04220098f, 0.08094836f, 0.05970304f, -0.08875952f, 0.07754933f, 
    0.05108444f, 0.05065081f, 0.02139974f, -0.08068541f, 0.16565153f, 0.04597871f, -0.03463855f, -0.07669354f, 
    -0.18395786f, 0.08990873f, -0.05495167f, 0.33002627f, 0.02997433f, 0.11818329f, 0.02213614f, 0.17130375f, 
    -0.00204483f, -0.03311925f, -0.01064678f, 0.17466134f, -0.24763082f, -0.19576091f, -0.07600056f, -0.18815929f, 
    -0.02052571f, -0.00417196f, -0.01697529f, -0.09826063f, 0.11303963f, 0.05489535f, -0.03496024f, 0.03316767f, 
    -0.10668872f, -0.02951965f, -0.03681727f, -0.07563651f, 0.11410332f, 0.00581167f, 0.07001401f, -0.02325735f, 
    0.04150481f, 0.09379632f, 0.07850458f, 0.14783290f, -0.02343666f, -0.12960429f, 0.04616683f, 0.06313008f, 
    0.00343563f, 0.02859289f, -0.01574703f, -0.10355031f, 0.06079336f, -0.14896287f, -0.11948391f, -0.07169490f, 
    0.10052896f, 0.07436568f, 0.19733846f, 0.29044858f, 0.14972250f, 0.11284661f, 0.10704633f, 0.09918504f, 
    0.04012147f, -0.01136991f, 0.12843435f, -0.03690870f, -0.24517277f, -0.01963649f, -0.00368466f, -0.01445504f, 
    -0.07030662f, -0.05509556f, -0.02386890f, -0.02515455f, -0.05082244f, -0.09779371f, -0.23563145f, -0.13621511f, 
    -0.03614889f, 0.02672961f, 0.03866711f, 0.21120277f, 0.01638534f, 0.04431593f, 0.12762327f, 0.07257470f, 
    0.15591304f, 0.02632624f, -0.00070212f, 0.09033754f, 0.02212543f, -0.05515457f, 0.03551253f, -0.09044071f, 
    -0.08335544f, -0.03325421f, 0.06675494f, -0.15023337f, -0.05780132f, -0.00257789f, -0.04776901f, -0.09100346f, 
    0.04440746f, -0.01575796f, 0.11731652f, 0.26546752f, -0.01371915f, 0.06762821f, 0.02242480f, 0.10640338f, 
    0.04097415f, -0.03608142f, -0.02438458f, 0.17184889f, -0.22724956f, -0.05873172f, -0.04024981f, -0.20077148f, 
    -0.10614905f, -0.13316540f, -0.08581798f, -0.11072703f, 0.14514463f, 0.06785933f, 0.08637045f, 0.07779393f, 
    -0.27639830f, -0.05388124f, -0.07613765f, -0.02812351f, 0.00694716f, 0.09130248f, 0.11399781f, -0.01717740f, 
    0.09867013f, 0.05700408f, 0.18847913f, 0.06708664f, -0.26932216f, 0.03856296f, -0.02570510f, 0.24440747f, 
    -0.01642890f, -0.01617862f, -0.00964653f, -0.04241485f, 0.08105760f, 0.04212585f, -0.04042239f, 0.01946770f, 
    0.11510850f, 0.08842107f, -0.05555844f, -0.00801515f, -0.02156446f, -0.07764436f, -0.13779269f, -0.02299623f, 
    -0.01387479f, -0.03844943f, -0.12208565f, 0.21551403f, 0.11763529f, -0.21601321f, -0.01660018f, 0.26854882f, 
    0.03363127f, -0.05430117f, -0.13646565f, -0.06558535f, 0.00621210f, -0.04810035f, -0.09551961f, -0.03854983f, 
    -0.05801593f, 0.14571279f, -0.02097188f, 0.31568170f, -0.05122095f, -0.00207988f, 0.12249348f, 0.07173041f, 
    -0.04188850f, 0.13234267f, -0.07064316f, 0.07666189f, -0.17959957f, -0.13963395f, 0.00628677f, 0.00984457f, 
    -0.00079161f, -0.08702800f, 0.11320028f, -0.14931108f, 0.14323112f, -0.08056059f, -0.08347486f, 0.13203403f, 
    -0.02065495f, 0.24289453f, -0.11372408f, -0.00617744f, 0.03077298f, 0.07005075f, 0.24798897f, -0.19111985f, 
    -0.04045392f, 0.05120510f, 0.08200984f, -0.00593962f, -0.21828435f, -0.32746053f, -0.28045365f, 0.01676256f, 
    -0.13256897f, -0.01473906f, -0.06412312f, 0.02788584f, 0.06050495f, 0.11898984f, -0.00678885f, 0.04976603f, 
    -0.01530738f, 0.07857844f, 0.02412792f, -0.18096969f, 0.01970936f, -0.05709955f, 0.01998933f, -0.07189544f, 
    -0.01929920f, 0.02999912f, -0.17452562f, 0.14442784f, -0.57794476f, -0.25180861f, -0.03844317f, -0.25560591f, 
    -0.17469834f, -0.16382545f, -0.04748062f, 0.01292305f, -0.01225812f, 0.04321265f, 0.01164698f, -0.01249467f, 
    -0.01010437f, 0.00495078f, -0.00822302f, 0.01998216f, 0.03456251f, -0.05400639f, -0.04724434f, -0.02127513f, 
    -0.00812306f, -0.04840992f, 0.02715750f, -0.05303923f, 0.02825487f, 0.01149508f, 0.04236339f, -0.03663568f, 
    -0.02352887f, -0.02497443f, -0.03960753f, 0.00314769f, -0.01053696f, -0.05005713f, -0.01674997f, -0.00632641f, 
    -0.00135338f, 0.00960210f, -0.00384706f, -0.05418363f, -0.00635145f, -0.02592802f, 0.00414855f, -0.02371359f, 
    0.05038784f, -0.05326058f, -0.02825310f, 0.03316854f, -0.01910260f, -0.01885739f, -0.01942972f, 0.02171815f, 
    -0.00219768f, 0.04292712f, -0.02210095f, 0.00932849f, 0.02435791f, -0.01048788f, -0.04501950f, -0.02431357f, 
    0.02569444f, 0.02016213f, 0.01843422f, -0.01917633f, 0.03832588f, 0.01490708f, -0.01412643f, 0.02828325f, 
    -0.00176725f, 0.02809894f, -0.02683258f, -0.04039465f, -0.00533747f, -0.01187683f, 0.04348927f, -0.02285180f, 
    0.03373432f, 0.03128503f, -0.00091852f, -0.00852993f, 0.00396243f, 0.02156010f, 0.02287627f, -0.03479830f, 
    0.00530577f, 0.02828271f, 0.03668311f, 0.01693774f, 0.00561442f, 0.00467845f, 0.01207360f, -0.02292445f, 
    0.01851655f, 0.03268721f, -0.01485509f, -0.05369987f, -0.05293858f, 0.04239606f, -0.01980924f, -0.03351634f, 
    0.02424416f, -0.00195298f, 0.03391112f, 0.03281263f, -0.02077675f, 0.02764319f, 0.03889067f, 0.00401687f, 
    0.01167270f, 0.02898246f, -0.04552201f, -0.03591338f, -0.00100818f, 0.00712662f, -0.01212907f, 0.02025670f, 
    -0.00370744f, 0.00110351f, -0.01906379f, 0.00741354f, 0.00146735f, 0.01182739f, -0.03564929f, 0.01970216f, 
    0.04430739f, -0.04004940f, -0.02157229f, 0.04088435f, -0.00478734f, 0.04683644f, 0.03708139f, -0.03170710f, 
    -0.04514956f, -0.02065306f, 0.00934141f, -0.03645000f, -0.03271926f, -0.03929501f, -0.02226763f, -0.00366950f, 
    -0.02024394f, 0.02526565f, 0.00992249f, 0.02793990f, -0.00039770f, 0.01460243f, 0.00493236f, -0.02903609f, 
    -0.02955520f, 0.00939873f, -0.00348887f, -0.03700015f, 0.03620477f, 0.03835928f, 0.00886694f, -0.01801603f, 
    0.04020331f, 0.03337369f, 0.01826493f, 0.02581511f, 0.04343881f, 0.02930887f, 0.00546143f, -0.01961239f, 
    0.01990417f, -0.04665747f, -0.04286856f, 0.03708716f, -0.04702929f, 0.01921136f, 0.00717604f, 0.02402817f, 
    -0.04614544f, 0.02974373f, 0.02179232f, 0.04126950f, -0.03368494f, -0.03534223f, 0.00266094f, -0.00847173f, 
    0.04112694f, -0.01617411f, -0.02050542f, -0.04830176f, -0.02825448f, 0.01525611f, 0.00316220f, -0.00201851f, 
    0.01870813f, 0.01464571f, -0.04974911f, -0.00394518f, -0.02658628f, 0.01214519f, 0.03589882f, -0.03169772f, 
    -0.03213678f, -0.03862574f, 0.00385312f, 0.01414202f, -0.01714019f, -0.03661956f, 0.04302951f, -0.01970040f, 
    -0.03461137f, 0.02079704f, -0.05254489f, -0.02645834f, -0.02219744f, -0.00669202f, 0.03038077f, -0.05182822f, 
    0.02348648f, 0.03845902f, -0.04872449f, -0.03293306f, -0.04019894f, -0.05207885f, -0.03169848f, -0.01260207f, 
    -0.04564589f, -0.03782487f, -0.02834170f, -0.03590903f, -0.05371526f, 0.01910424f, -0.00396121f, -0.00210489f, 
    0.00903281f, 0.02504014f, 0.04179055f, -0.03631882f, -0.04219386f, 0.03369769f, -0.01123790f, 0.02557407f, 
    -0.04128468f, -0.04463500f, 0.03486958f, -0.03885662f, 0.00265376f, 0.02778136f, 0.01547458f, -0.02231109f, 
    0.01689182f, -0.02352876f, 0.03264663f, 0.04245540f, -0.04847001f, 0.00249833f, -0.04407569f, -0.02189243f, 
    -0.04301564f, 0.04961138f, -0.04334148f, -0.03948213f, 0.03333164f, 0.04104616f, -0.01391745f, 0.04363897f, 
    -0.03300084f, 0.03997448f, 0.01457398f, -0.04295132f, -0.04265337f, -0.03356908f, -0.02138886f, 0.03590915f, 
    -0.04337646f, 0.02162015f, 0.01088714f, -0.02784600f, -0.04413945f, -0.00789462f, -0.04843773f, -0.03624864f, 
    0.02295421f, -0.04969323f, -0.04239035f, -0.02911110f, -0.01939737f, 0.03586273f, 0.01257861f, -0.00645995f, 
    -0.00379608f, -0.01424443f, 0.00866766f, -0.00825315f, -0.05157045f, -0.05272935f, 0.00492247f, -0.05023852f, 
    0.01246473f, -0.01870563f, 0.01327390f, 0.03559244f, 0.03971973f, 0.00289271f, 0.00416080f, 0.03751405f, 
    -0.04046838f, 0.02225173f, -0.02402246f, -0.02688911f, 0.02067620f, -0.03720109f, -0.00474104f, -0.05141288f, 
    -0.03946795f, -0.02342799f, 0.02479923f, -0.05197958f, -0.00022354f, 0.01243317f, -0.03013566f, -0.00796831f, 
    -0.04674513f, -0.05025829f, 0.00223915f, 0.02653989f, 0.03383554f, -0.04092904f, -0.05692326f, -0.04016914f, 
    -0.04643276f, 0.01150220f, 0.01509575f, -0.03177576f, -0.01078108f, -0.01316924f, 0.01523214f, -0.03133018f, 
    -0.01252956f, 0.01365242f, -0.02631112f, 0.00718770f, 0.02747879f, 0.03281299f, -0.01481494f, 0.00748391f, 
    -0.05443354f, -0.01104672f, -0.01150139f, -0.00587591f, -0.01674074f, 0.03309553f, 0.01916352f, -0.00541825f, 
    -0.02573927f, -0.01971830f, -0.03146399f, -0.04251191f, -0.02101919f, -0.03711620f, -0.01272217f, 0.00945474f, 
    -0.04810815f, -0.03266311f, 0.02551905f, -0.04392924f, -0.02044554f, -0.03425735f, -0.01629031f, -0.03184415f, 
    -0.01333624f, 0.02084499f, -0.01422144f, 0.01827621f, 0.00944835f, 0.01815217f, 0.00096853f, 0.00771050f, 
    0.04205516f, 0.03269095f, -0.02432363f, 0.02364299f, -0.00191032f, 0.00560391f, -0.03419364f, 0.03997015f, 
    -0.03548940f, 0.02478524f, 0.01167270f, 0.00933428f, 0.03324153f, -0.00684056f, -0.03020312f, -0.04511565f, 
    -0.02633745f, 0.01205391f, -0.04363703f, 0.00131915f, -0.01883404f, -0.05116653f, 0.02770297f, -0.05283708f, 
    0.02213468f, -0.01877495f, -0.01519367f, -0.02803740f, 0.03258869f, -0.05569910f, -0.01338212f, -0.05863928f, 
    -0.03325902f, -0.04972797f, -0.04749856f, 0.03748719f, -0.01953780f, -0.00598091f, -0.05942554f, -0.04784066f, 
    -0.03633287f, 0.03550715f, 0.00931369f, 0.01703300f, -0.04800707f, 0.03060652f, 0.01583572f, 0.01326479f, 
    0.00242869f, 0.02685357f, 0.00493790f, 0.02392684f, -0.01056410f, 0.02378054f, 0.01330849f, 0.03952422f, 
    0.04013605f, -0.00845936f, -0.00187334f, -0.04750605f, 0.03909851f, -0.00326742f, 0.00456949f, -0.04967074f, 
    -0.03641921f, -0.00528687f, -0.01351783f, -0.00359808f, -0.00440274f, -0.06026896f, -0.05903025f, 0.03875883f, 
    -0.01180057f, 0.02752002f, 0.02153466f, 0.02355884f, -0.05100777f, 0.03103304f, -0.04588570f, -0.00798360f, 
    -0.02867092f, -0.03264082f, 0.02386842f, -0.01918287f, -0.03565346f, 0.02173310f, -0.02482025f, 0.00629598f, 
    -0.00264790f, -0.02917075f, 0.02578592f, -0.00881282f, 0.00671885f, -0.04038063f, -0.03661269f, 0.01966246f, 
    0.00492286f, 0.03027620f, -0.01045436f, -0.05215455f, 0.02994446f, -0.03711332f, 0.00653394f, -0.04583925f, 
    -0.02762924f, 0.02098307f, 0.02994019f, -0.05838556f, -0.03496343f, -0.01757653f, -0.01827043f, -0.02395871f, 
    0.02010359f, 0.00049850f, 0.04029013f, -0.00819491f, -0.05057397f, 0.00174621f, -0.04323336f, -0.03209199f, 
    -0.01672810f, 0.03468644f, 0.02840460f, -0.02823981f, -0.02025370f, -0.03787907f, -0.00727424f, -0.02487213f, 
    0.01497306f, 0.04465729f, -0.05314050f, 0.02005920f, -0.04979191f, 0.00341529f, 0.01655107f, 0.03988513f, 
    0.01931300f, -0.04648237f, -0.05559876f, 0.00378222f, 0.03049885f, -0.04231114f, 0.04333670f, -0.02845520f, 
    -0.05297923f, -0.00930238f, -0.04215047f, -0.03040439f, -0.01595201f, -0.04580885f, 0.01845602f, 0.00487763f, 
    -0.01457980f, -0.03254077f, -0.03675513f, -0.01776610f, 0.02037573f, 0.00738885f, -0.05075772f, -0.00677022f, 
    -0.00115408f, -0.03839590f, 0.01713589f, -0.05135676f, -0.02714100f, 0.01097822f, 0.01676145f, -0.05684027f, 
    -0.04397531f, -0.03645151f, 0.01022564f, -0.02652889f, 0.00889154f, 0.00180084f, 0.00171049f, -0.05599672f, 
    0.02235148f, 0.01108008f, 0.01681408f, 0.00194056f, 0.01533659f, -0.01203196f, -0.00309469f, 0.02286348f, 
    0.03495704f, -0.03100764f, -0.04375595f, 0.02442976f, 0.00945600f, -0.02423054f, -0.03349945f, -0.05846384f, 
    0.03760975f, 0.02871793f, -0.03890415f, 0.01125249f, -0.04574675f, -0.02474298f, -0.00137712f, 0.02293936f, 
    -0.01553208f, -0.05978145f, 0.02878002f, -0.02613127f, -0.01151562f, 0.02618637f, 0.03339152f, 0.04079603f, 
    -0.06081447f, -0.04813327f, -0.03654621f, 0.02859425f, -0.03147310f, -0.01530646f, 0.04194637f, 0.01115859f, 
    0.01385119f, -0.05443822f, -0.01599354f, 0.02080043f, -0.01293952f, -0.01094668f, -0.01784313f, 0.00721360f, 
    0.01092745f, 0.02490683f, -0.01291780f, -0.01005595f, -0.01209804f, 0.02273771f, 0.00078132f, -0.02690245f, 
    -0.05535981f, -0.01575762f, -0.04043727f, 0.04188299f, -0.02120984f, -0.03546143f, 0.03625243f, -0.04600168f, 
    -0.00457439f, -0.05451933f, -0.05057672f, -0.01870269f, -0.04358852f, -0.05555973f, -0.00406638f, -0.01566496f, 
    -0.01301403f, 0.01605794f, -0.00983743f, 0.03157178f, -0.00930345f, 0.04212962f, -0.03841557f, 0.01794181f, 
    -0.03415326f, -0.01491306f, -0.01379364f, 0.00391951f, 0.04206162f, -0.04906528f, -0.04849321f, -0.05078647f, 
    -0.04526348f, -0.03423868f, -0.04184256f, -0.05060803f, 0.03526701f, -0.03854598f, -0.04490791f, -0.01683773f, 
    -0.01480774f, -0.02628284f, -0.02807514f, -0.03622140f, 0.00609317f, 0.02324194f, 0.01767056f, -0.05522240f, 
    -0.00459411f, -0.05052250f, 0.02549689f, -0.03930801f, -0.01138872f, -0.04434362f, -0.03527669f, 0.02659261f, 
    -0.02005047f, 0.03920651f, -0.03340479f, -0.01743122f, 0.03212944f, -0.04613131f, -0.02578416f, -0.00401954f, 
    -0.03944572f, 0.00665824f, 0.01188379f, 0.02138067f, -0.01480681f, -0.03252735f, -0.01150971f, -0.05816307f, 
    0.00605302f, -0.01119475f, 0.01717084f, -0.02160827f, -0.02986051f, 0.03272743f, -0.04258106f, 0.02095710f, 
    0.00699644f, 0.03679243f, 0.01605509f, 0.02501577f, 0.02326580f, -0.03032195f, 0.02137789f, 0.02098092f, 
    -0.00488037f, -0.01924183f, -0.02321024f, 0.02398829f, -0.04112869f, 0.00423344f, -0.03892613f, 0.03322378f, 
    -0.01916698f, 0.01532028f, 0.04137876f, 0.03335868f, -0.04863489f, -0.03754193f, -0.04701107f, 0.04304263f, 
    0.01727721f, 0.01606934f, -0.01307589f, 0.00572402f, 0.03383666f, -0.05653720f, 0.01786309f, 0.00494438f, 
    0.02320384f, -0.05538070f, 0.00635859f, -0.03107698f, 0.03005479f, 0.03239276f, -0.01107956f, -0.05375786f, 
    0.03000546f, -0.04631996f, -0.01383835f, 0.03034755f, 0.01973936f, -0.02661681f, 0.01718794f, 0.03065266f, 
    0.00597512f, -0.02620608f, 0.01117183f, 0.00702590f, -0.04263097f, 0.02232008f, -0.05210073f, 0.00837208f, 
    -0.01721244f, 0.02105004f, -0.02182550f, -0.02565571f, -0.04025811f, -0.02810186f, -0.03690441f, -0.05488638f, 
    -0.00599919f, 0.02659883f, -0.01184362f, -0.04648953f, -0.00136704f, -0.01614848f, -0.05634863f, -0.01668923f, 
    0.00553707f, -0.02126024f, 0.00919875f, -0.01672076f, 0.02152045f, 0.04155735f, -0.00799217f, 0.00647126f, 
    -0.01759235f, -0.05445697f, 0.02905441f, 0.00345945f, 0.00117498f, 0.01929197f, -0.04079712f, -0.02587003f, 
    -0.04233584f, 0.00825043f, -0.01553218f, 0.01656224f, -0.03623636f, -0.01379840f, -0.04794251f, -0.05068853f, 
    0.00098776f, 0.03287026f, -0.04631269f, 0.02283351f, 0.02646274f, 0.00926341f, 0.03582094f, -0.05315464f, 
    -0.04695110f, -0.01567193f, -0.03708400f, -0.04701703f, -0.00797656f, 0.02999541f, 0.04368683f, -0.03716865f, 
    0.04108849f, 0.00389017f, -0.01884254f, -0.03186812f, 0.02424542f, -0.06014372f, 0.03610860f, -0.05446689f, 
    0.01658946f, 0.01960682f, -0.00612759f, 0.02698394f, -0.02329778f, 0.00413147f, 0.03619212f, -0.04065825f, 
    -0.05116586f, 0.01292857f, 0.00807029f, -0.05159166f, 0.02881426f, 0.01459983f, 0.00458497f, 0.03407937f, 
    0.01817177f, -0.02518354f, -0.00203350f, -0.02766692f, -0.00614750f, 0.01712518f, -0.03742719f, 0.04212730f, 
    0.03984377f, -0.04599186f, -0.01042730f, 0.03563899f, 0.03566874f, -0.00088648f, -0.03594882f, -0.02213076f, 
    -0.01230460f, -0.00795567f, 0.03404614f, -0.00309085f, 0.02174042f, 0.04169217f, -0.03636356f, -0.00023812f, 
    -0.02871562f, -0.01719316f, -0.00222631f, -0.05409938f, -0.04884099f, -0.00447151f, 0.00168504f, -0.05146265f, 
    -0.01321262f, -0.01319038f, -0.04407043f, 0.02649651f, -0.03741737f, -0.05219691f, -0.00056382f, -0.01916164f, 
    0.00100730f, -0.01236260f, 0.02723084f, -0.04383079f, -0.04260309f, 0.01285014f, 0.01142108f, 0.00138866f, 
    0.00890464f, -0.01642571f, 0.02097191f, -0.00017976f, -0.03467364f, -0.02713311f, -0.04340258f, -0.01234612f, 
    0.01290947f, -0.05420925f, -0.02147962f, -0.02042666f, -0.03610543f, 0.00145559f, -0.03231637f, 0.03948022f, 
    -0.03653773f, 0.00109271f, 0.01612114f, -0.00151734f, -0.02948428f, 0.00464372f, -0.04949344f, -0.00418082f, 
    0.01407032f, -0.01360469f, 0.01767495f, -0.04371715f, -0.03523847f, -0.00359529f, 0.04072588f, 0.01986948f, 
    -0.01535773f, -0.02771290f, -0.05341030f, 0.01292840f, 0.01845300f, 0.01951365f, 0.02933740f, -0.00043616f, 
    -0.01821030f, -0.01432138f, 0.02809237f, -0.00627823f, -0.02247059f, 0.00916034f, 0.00372318f, -0.02100409f, 
    -0.01307232f, -0.03724059f, -0.04673664f, -0.00941837f, -0.00411077f, -0.05488136f, 0.01060588f, -0.02891334f, 
    0.02134280f, 0.00785145f, 0.01852195f, 0.02149573f, 0.01682108f, -0.01193253f, 0.02551593f, -0.02673153f, 
    -0.05561040f, -0.00944624f, 0.02306667f, -0.02826433f, -0.01657248f, 0.00724258f, -0.01885295f, 0.03807102f, 
    -0.03128942f, -0.01099269f, -0.00608922f, 0.00169481f, 0.01441351f, -0.00895779f, 0.00635984f, -0.04091774f, 
    0.04384086f, -0.00732033f, 0.03488640f, -0.04002000f, -0.04863776f, 0.02489529f, -0.01092272f, 0.02476073f, 
    0.03404377f, 0.00841330f, 0.00570453f, -0.01867389f, -0.03661750f, -0.05160893f, -0.03572465f, -0.02830020f, 
    0.00095460f, -0.04034869f, -0.03736845f, -0.00743216f, 0.03139095f, -0.05036204f, -0.05084226f, 0.02382833f, 
    0.02020361f, 0.01951029f, 0.04820737f, -0.03483471f, 0.02126969f, 0.02155172f, 0.01785614f, -0.05758647f, 
    -0.02765954f, -0.05498938f, -0.05080292f, 0.02515134f, -0.02202764f, 0.01979952f, -0.01169491f, -0.02218829f, 
    -0.05122859f, -0.01251736f, 0.01565376f, -0.03100069f, -0.00298436f, 0.00809505f, 0.01242014f, -0.03224944f, 
    -0.05890719f, -0.01941044f, -0.00932045f, -0.01983954f, -0.02601939f, 0.00161360f, -0.00639698f, -0.03229186f, 
    0.04488385f, -0.05412678f, -0.03102965f, 0.01255022f, 0.00712983f, 0.01974996f, -0.03326068f, -0.04339959f, 
    -0.04942222f, 0.04323861f, -0.05236031f, 0.01960314f, -0.05709344f, -0.00762402f, 0.00738003f, -0.00243212f, 
    0.01888051f, 0.00603546f, -0.03986398f, -0.03319311f, -0.00703967f, -0.05504831f, -0.03831257f, -0.00745622f, 
    0.04298267f, 0.01887939f, -0.00133659f, 0.02470571f, -0.04626344f, -0.03871625f, -0.05394515f, 0.03996861f, 
    0.03859241f, 0.03980004f, 0.03241374f, -0.00391510f, -0.03883407f, 0.00888305f, -0.04924259f, -0.02615995f, 
    -0.01527953f, -0.00932969f, 0.00663262f, -0.03227428f, -0.02156776f, -0.03852633f, -0.02856308f, 0.00317602f, 
    0.00801433f, -0.04083098f, 0.00800052f, 0.00586629f, -0.03373555f, -0.04390495f, 0.01366915f, -0.01853654f, 
    0.03851559f, -0.01311540f, 0.01105737f, -0.02674366f, -0.05155408f, -0.01896655f, -0.02881696f, -0.01766256f, 
    0.00192504f, -0.05318556f, -0.04591629f, 0.00187385f, 0.01047321f, -0.00201725f, 0.00568944f, -0.05450397f, 
    -0.00331203f, 0.01847437f, -0.03104364f, -0.01352672f, -0.00280093f, 0.02030510f, -0.03342647f, 0.04150633f, 
    -0.01687679f, 0.03028836f, -0.01893378f, -0.01443646f, -0.05449042f, -0.00365400f, -0.00741481f, -0.00121467f, 
    0.02549680f, 0.03018302f, 0.02176959f, -0.03751837f, 0.01604150f, -0.02724867f, -0.05676010f, 0.00152667f, 
    -0.04105412f, 0.01721342f, 0.01043841f, 0.00869748f, 0.00814697f, 0.02445396f, 0.01151815f, -0.05300615f, 
    0.03863500f, -0.05395723f, -0.02978723f, -0.01342322f, 0.03658312f, -0.05800869f, 0.04144788f, -0.03514541f, 
    0.03487687f, 0.00424593f, -0.01937268f, -0.01847450f, 0.03115295f, 0.01682396f, -0.02485160f, -0.05275147f, 
    -0.01187361f, 0.02045565f, 0.00180656f, -0.01892080f, -0.04260230f, -0.01991345f, -0.05620271f, -0.00335647f, 
    0.04024550f, -0.00256975f, 0.01546507f, -0.01497414f, 0.01274506f, -0.04039706f, 0.02921817f, -0.02037890f, 
    -0.05209265f, -0.00069905f, -0.01385577f, -0.01974207f, -0.00927334f, 0.00588332f, -0.00966398f, -0.04073022f, 
    0.02842663f, -0.02594981f, 0.03210370f, 0.00588016f, 0.01200457f, -0.04930201f, -0.00813477f, 0.01143598f, 
    0.03872351f, 0.01589763f, 0.00739652f, 0.03775723f, -0.02618809f, -0.03192732f, 0.02049075f, 0.04132023f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04723964f, 0.02378089f, -0.02668546f, 0.02534745f, 0.00526168f, -0.03453600f, 0.17855065f, 0.08898906f, 
    -0.05440442f, 0.14274240f, 0.11088450f, 0.02698386f, -0.01958941f, 0.00710467f, 0.14791946f, 0.20422341f, 
    -0.05491534f, -0.02598466f, 0.02878370f, -0.05800788f, -0.03949635f, 0.12256108f, 0.21023497f, -0.00749030f, 
    0.16002683f, 0.03571066f, -0.16440342f, -0.00929423f, -0.03239979f, -0.02186591f, -0.00426914f, 0.03606228f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.38184005f, 0.02878052f, 0.06801654f, 0.14989033f, 0.10337361f, 0.33038554f, -0.26291493f, -0.06929272f, 
    0.05574517f, -0.06748535f, -0.13109550f, 0.33258024f, -0.70638049f, -0.16979732f, 0.11966006f, -0.42332608f, 
    -0.09979968f, -0.07410445f, -0.61033362f, -0.01565623f, -0.01013437f, -0.31052336f, -0.28656146f, 0.30643708f, 
    0.15496594f, 0.18596420f, 0.38788277f, 0.06583695f, -0.08921270f, 0.06476333f, 0.12042358f, -0.10795230f, 
    0.02919311f, -0.02808664f, 0.03598272f, -0.08404619f, -0.02023158f, -0.25736302f, 0.37739420f, 0.13213262f, 
    -0.15038523f, 0.14065441f, 0.27152655f, -0.16767734f, -0.93522179f, -0.05414930f, 0.15612136f, 0.03760701f, 
    0.09199335f, 0.06147495f, -0.18889503f, 0.31653538f, -0.17062080f, -0.39340189f, 0.07150340f, -0.91706645f, 
    0.12755382f, -0.10074817f, 0.07927746f, 0.12490879f, 0.28612322f, -0.00258750f, -0.02933903f, -0.15164824f, 
    -0.33984032f, 0.16703461f, -0.13594609f, 0.06238048f, 0.14376967f, 0.32793126f, 0.48754308f, 0.00598465f, 
    -0.12581252f, -0.20637281f, -0.41823032f, -0.25262910f, -0.07325429f, -0.15393822f, 0.11050033f, 0.33220556f, 
    0.04718565f, -0.00558459f, 0.07353117f, 0.16738555f, -0.13187039f, 0.28871375f, -0.23593687f, -0.18769467f, 
    0.09020282f, -0.18249126f, -0.03857831f, -0.40694681f, -0.80562717f, -0.06760617f, -0.12393973f, -0.14106447f, 
    0.15944634f, -0.07231490f, 0.09551697f, -0.15730315f, 0.04246799f, 0.24709971f, 0.36219415f, 0.29771647f, 
    0.09765047f, -0.28685412f, 0.13829133f, 0.12556557f, 0.31246105f, -0.17574236f, -0.29663077f, -0.24631834f, 
    0.14148812f, -0.14441958f, 0.28538501f, 0.22138222f, -0.06398776f, 0.13234667f, -0.41545647f, -0.26321605f, 
    -0.29897538f, -0.25795096f, 0.27908361f, -0.19091234f, 0.29929668f, -0.14441770f, 0.07838073f, 0.12552467f, 
    -0.27135542f, 0.14647880f, -0.05414842f, -0.15140522f, 0.12883997f, 0.01156782f, -0.23553641f, -0.61078000f, 
    0.08726348f, 0.08252400f, -0.37304544f, 0.05482298f, 0.40494758f, -0.14492716f, 0.21937738f, -0.04647782f, 
    -0.02625022f, 0.05603341f, 0.15339796f, 0.19261532f, -0.16700368f, -0.46701619f, -0.29159138f, -0.11483619f, 
    -0.08147213f, 0.17006032f, -0.33328709f, 0.31853056f, 0.23857334f, -0.01777720f, 0.12883635f, 0.13642591f, 
    -0.43747556f, 0.10687002f, -0.07625531f, 0.03905759f, -0.04905014f, 0.01924111f, 0.05313111f, -0.24028279f, 
    -0.09216899f, 0.31528535f, 0.23112324f, 0.20532574f, -0.07815186f, -0.02383382f, -0.05357542f, -0.26807195f, 
    -0.15341577f, -0.11243050f, -0.68219090f, -0.13963668f, 0.15029360f, -0.07032312f, 0.36344340f, 0.28836003f, 
    0.28104299f, -0.01815676f, -0.70542425f, -0.31701702f, -0.16784690f, -0.04987444f, -0.09281059f, 0.06628791f, 
    0.06616375f, 0.03625348f, 0.03043971f, 0.15871912f, 0.14589301f, -0.32213077f, -0.51799780f, -0.43518317f, 
    -0.14860784f, 0.14230733f, -0.27472484f, -0.58360416f, 0.27594423f, -0.04253102f, 0.25822300f, 0.22091930f, 
    0.09154073f, -0.05075557f, 0.03567839f, -0.64840865f, -0.20792806f, 0.47858247f, 0.28661221f, -0.48272076f, 
    -0.48210028f, -0.41559079f, 0.01368836f, -0.66607982f, -0.27988186f, 0.10864963f, 0.15586956f, -0.10359343f, 
    0.32144040f, -0.09529010f, -0.17262910f, -0.03518060f, -0.02901878f, -0.00136964f, -0.44036445f, 0.10641187f, 
    -0.00168548f, 0.35350806f, 0.09937687f, 0.11538901f, -0.25204343f, 0.08181953f, -0.54756111f, 0.20008206f, 
    0.10620522f, 0.03852465f, 0.36853933f, -0.51314533f, -0.08893189f, -0.40369928f, -0.43085000f, 0.41435781f, 
    -0.41335857f, -0.18928191f, -0.17333682f, -0.03557600f, -0.17134428f, -0.08033552f, -0.13062991f, 0.06324252f, 
    0.13051768f, -0.14152844f, -0.06462928f, -0.08643354f, -0.07432131f, -0.11851203f, 0.13976277f, 0.55586815f, 
    0.11853117f, -0.06509653f, 0.11261450f, -0.71283835f, -0.21696001f, 0.07823586f, -0.62051576f, 0.17741972f, 
    -0.06156550f, 0.15139344f, -0.49486485f, -0.68365812f, -0.01536846f, 0.02134197f, 0.05608585f, 0.53602868f, 
    -0.28387114f, 0.34096935f, 0.00131872f, -0.24331577f, -0.19037451f, -0.04864447f, 0.17145188f, 0.07304710f, 
    -0.70982760f, -0.15733784f, -0.08612295f, -0.10709731f, 0.15168656f, -0.51272988f, -0.75584430f, -0.37786284f, 
    -0.03950838f, -0.11359277f, 0.06329491f, 0.64424640f, 0.08089413f, -0.16133626f, 0.28278491f, 0.27078342f, 
    -0.00715935f, 0.09143912f, 0.35948604f, -0.14130123f, -0.16466759f, 0.14910521f, -0.32304558f, 0.14644757f, 
    -0.24540979f, -0.03244537f, -0.71209413f, 0.07498816f, -0.33095869f, 0.05173187f, -0.03553391f, -0.10829883f, 
    -0.40425381f, 0.03712874f, -0.10825580f, 0.04939823f, 0.06761462f, 0.46628922f, -0.24145111f, 0.21765925f, 
    0.09689886f, -0.45249325f, 0.29919463f, -0.60520095f, -0.01133132f, 0.16663125f, 0.17638984f, -0.21122311f, 
    0.10021510f, 0.12627614f, -0.46283773f, -0.31808868f, -0.08333103f, 0.44323784f, 0.34061003f, -0.67306304f, 
    -0.19719392f, 0.21822093f, -0.02371322f, 0.32626259f, 0.26016620f, -0.09485698f, -0.15085796f, -0.11294448f, 
    0.73123586f, -0.04795830f, 0.10679947f, -0.06531578f, 0.11688679f, -0.47742808f, 0.24342611f, -0.01802310f, 
    -0.04789533f, -0.34759265f, -0.12393451f, -0.18347709f, 0.37011832f, 0.02970114f, 0.09773120f, 0.00736442f, 
    -0.00956569f, 0.07332684f, -0.18538024f, -0.31613356f, 0.15896821f, 0.01233852f, 0.26748541f, 0.31044865f, 
    -0.06629284f, -0.65704477f, 0.13897802f, 0.42664456f, -0.24864577f, 0.01232311f, -0.13762571f, 0.06725461f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18380648f, -0.03299377f, 0.09865816f, -0.01007541f, 0.16688618f, 0.19526477f, 0.20128314f, -0.01738518f, 
    -0.06003977f, -0.00075998f, -0.07027178f, -0.17342375f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
