#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.60727608f, -0.35377350f, 0.66448206f, 1.21493781f, 0.67481673f, 0.22006962f, -0.48742068f, -0.68574911f, 
    -0.51398754f, -0.18628152f, -0.10323796f, -0.20512107f, 0.08137804f, 0.35953283f, 0.08218933f, 0.06569554f, 
    -0.26483721f, -0.19129762f, -0.03302491f, 0.40614545f, -0.28866816f, 0.07700431f, 0.08623506f, 0.11789644f, 
    -0.22570956f, 0.13354702f, 0.71565664f, 0.52026826f, 0.11867012f, 0.33561671f, -0.27197772f, -0.47393194f, 
    -0.25584051f, 0.50483453f, 0.08023455f, 0.23498434f, -0.06367612f, -0.11394828f, -0.17683820f, -0.25305781f, 
    -0.20970766f, 0.00850818f, 0.12740272f, -0.20445965f, 0.09728257f, 0.03592749f, -0.05853313f, -0.01924494f, 
    0.03530614f, 0.03285314f, -0.13280874f, 0.78869385f, -0.11260584f, -0.33073184f, -0.19409038f, -0.53422242f, 
    -0.56577671f, -0.16807808f, -0.16145925f, -0.56998169f, 0.09387866f, -0.51387584f, -0.15721509f, -0.20859270f, 
    0.02114226f, 0.11427961f, 0.04522080f, 0.21193609f, -0.20607893f, 0.19737692f, -0.08192407f, -0.01751488f, 
    0.04496353f, 0.44586864f, 0.35228723f, -1.26245463f, -0.75420165f, 0.50993830f, -0.23358023f, 0.15749453f, 
    0.90208471f, 0.74547708f, 0.00056676f, -0.24881804f, -0.01064339f, -0.44865671f, -0.34268549f, -0.04347797f, 
    0.22215600f, -0.12806036f, 0.11832968f, 0.18555608f, -0.46053687f, 0.00210893f, 0.28822079f, -0.11661652f, 
    -0.19893555f, 0.10822255f, -0.01028483f, -0.38586500f, -1.21627021f, -0.85951996f, -0.56484926f, -0.51939309f, 
    -0.44046050f, -0.04022442f, -0.42110643f, -0.70653933f, -0.51908088f, -0.18172760f, 0.01552695f, -0.11866695f, 
    0.34252477f, 0.57147437f, -0.24619409f, -0.10808066f, -0.21961936f, -0.53785956f, -0.09190305f, 0.17137507f, 
    -0.04248152f, 0.32624367f, 0.39570579f, 0.07864383f, 0.02481234f, 0.18937479f, 0.53249067f, 0.46371892f, 
    0.18851767f, -0.23660721f, 0.02639054f, -0.30955338f, -0.14127772f, 0.22884068f, -0.35342720f, 0.05240938f, 
    -0.09150679f, -0.43147966f, -0.33583966f, 0.29513028f, 0.09188075f, -0.13930069f, 0.00451636f, 0.59522301f, 
    0.00050409f, 0.18989128f, -0.04345394f, -0.11798077f, -0.28480530f, -0.22635864f, -0.14350934f, -0.14695716f, 
    -0.36357519f, 0.05486681f, 0.64345145f, -0.39608997f, 0.22642595f, 0.25931129f, -0.01184193f, -0.09153806f, 
    0.49478456f, -0.42327479f, -0.27560201f, 0.02708991f, 0.18034349f, 0.21819085f, -0.11588556f, -0.39020079f, 
    -0.30710727f, 0.21475121f, 0.04982037f, 0.28512490f, -0.07286954f, 0.03948923f, 0.00118483f, 1.39874399f, 
    0.05790934f, -0.02621412f, -0.45023558f, -1.07128084f, 0.05335425f, 0.17644185f, 0.26863277f, 0.14466789f, 
    -0.21746281f, -0.30747920f, -0.20324256f, 0.09840632f, -0.21227023f, 0.22737651f, -0.05843014f, 0.18927450f, 
    -0.07645797f, -0.31801131f, -0.45913461f, -0.52825058f, -0.37528995f, -0.38081336f, -0.30585837f, -0.57729864f, 
    -0.22633892f, 0.60010654f, -0.39780006f, -0.08404572f, -0.35913417f, 0.71663725f, 0.30981717f, 0.05883682f, 
    -0.33106461f, -0.20781560f, 0.14374688f, 0.19175395f, -0.17985925f, -0.13652904f, 0.01075899f, 0.35657942f, 
    -0.51619381f, 0.16723916f, 0.13743004f, -0.18767169f, -0.14591840f, 0.06747229f, 0.16533798f, -0.29420894f, 
    0.06333067f, 0.14057094f, -0.89391369f, 0.12540455f, 0.09937907f, 0.18667060f, 1.03123581f, -0.42531058f, 
    -0.76215011f, -0.53266871f, 0.45550135f, 0.33772388f, 0.00049537f, -0.49356771f, -0.14094192f, -0.41575482f, 
    0.29588783f, 0.04744076f, 0.28927702f, 0.04554898f, -0.23370475f, -0.38420072f, 0.39208645f, -0.11655274f, 
    -0.25046590f, -0.32234234f, 0.65282136f, 0.41059399f, 0.15924658f, -0.28743276f, -0.28573355f, -0.09513302f, 
    0.24095537f, 0.23246357f, -0.07837802f, -0.12620202f, -0.21406032f, 0.21163735f, 0.12064549f, 0.05053809f, 
    -0.35399157f, -0.11626221f, -0.30028170f, -0.34675014f, 0.05083757f, 0.10482682f, -0.16171356f, -0.17674966f, 
    -0.13829544f, -0.09667063f, 0.59456968f, -1.46156776f, -0.50559872f, 0.14594550f, 1.08079863f, 0.42803311f, 
    0.39416873f, -0.13480897f, -0.05881467f, 0.60400003f, 0.49063030f, -0.25334671f, -0.35599378f, -0.47463289f, 
    0.32264015f, -0.09023023f, 0.03857352f, 0.16388960f, -0.12494432f, 0.05608516f, -0.20471621f, -0.05730784f, 
    -0.27948982f, -0.08585773f, 0.13472703f, -0.00069835f, 0.04872573f, -0.59342682f, -0.08326218f, -0.05482918f, 
    0.06260435f, 0.28773227f, -0.26201099f, 0.17308056f, 0.62705553f, 0.17934752f, -0.14833875f, 0.13682811f, 
    0.19589499f, 0.05605998f, 0.09327186f, -0.19232097f, 0.00273931f, 0.04779257f, -0.18149078f, -0.12770118f, 
    0.12483454f, -0.10775435f, 0.39021525f, -0.08293448f, -0.26126742f, -0.01971064f, -0.80650920f, -0.23816133f, 
    -0.52317804f, -0.63615859f, -0.49376404f, -0.05280899f, 0.03773290f, 0.05842185f, -0.18809405f, -0.35330942f, 
    0.39060256f, -0.44094005f, -0.29653427f, -0.14072914f, 0.11813343f, -0.55572438f, -0.17381354f, -0.28876826f, 
    0.09058184f, -0.08757053f, -0.18768869f, -0.16205588f, -0.22827117f, -0.27053139f, 0.44858786f, 0.58861494f, 
    -0.56956100f, 0.44106719f, -0.38014075f, -0.56146109f, -0.59120709f, -0.94666660f, -0.69636089f, -0.79506350f, 
    0.07189244f, 0.15219980f, 0.36366668f, -0.25585830f, 0.08428355f, -0.09574389f, 0.01493789f, 0.20960884f, 
    0.11103462f, 0.09908387f, 0.13067654f, -0.13725327f, -0.01152072f, -0.26103005f, 0.25556681f, -1.00825465f, 
    -0.66547728f, -0.09459472f, -0.24041940f, -0.16881335f, 0.55971330f, 0.50657445f, -0.34933582f, -0.39689186f, 
    0.71030611f, 0.38769034f, 0.40450639f, -0.67369699f, -0.31041679f, -0.63536161f, -0.16487697f, 0.18362065f, 
    -0.20312303f, -0.41444016f, -0.02836773f, -0.29088312f, -0.37440515f, -0.07992169f, 0.06233763f, -0.29843426f, 
    -0.83419126f, -0.12244517f, 0.28046644f, -1.09576857f, -0.84824944f, 0.04445361f, 0.17554995f, 0.25220421f, 
    0.39824986f, 0.61516935f, 0.05711475f, -0.11305049f, -0.17570698f, -0.06140909f, 0.34766173f, 0.08546356f, 
    0.15031518f, -0.03527979f, 0.04077354f, 0.16835994f, -0.02339436f, 0.04650383f, -0.20715329f, -0.20726418f, 
    -0.19237250f, -0.73749447f, -0.23186655f, -0.23255308f, -0.48399055f, 0.15631072f, 0.50950402f, -0.58349210f, 
    0.18776226f, 0.81633836f, 0.18951933f, 0.30566674f, -0.37841177f, 0.10226115f, -0.32223344f, -0.22425389f, 
    -0.34035239f, -0.10439999f, -0.00861192f, 0.26796320f, 0.03225194f, -0.02536295f, 0.15397778f, -0.09153878f, 
    -0.20455323f, 0.69381499f, 0.72272545f, -0.45454228f, -0.73100746f, -0.50816917f, -0.26197484f, 0.55427468f, 
    0.29700547f, 0.21743141f, 0.00970716f, -0.13695462f, 0.16016729f, 0.10951933f, 0.22737668f, -0.49742180f, 
    0.04296177f, -0.27097359f, 0.04446094f, -0.18721576f, -0.29376054f, 0.34942007f, 0.13780881f, -0.14410868f, 
    -0.14737943f, 0.14301538f, 0.50103313f, 0.14704528f, -0.05373177f, -0.50169170f, -0.19214423f, 0.43718618f, 
    0.18798634f, -0.09668074f, -0.76304579f, -0.50626129f, -0.42799780f, 0.41680464f, 0.65431845f, 0.44209278f, 
    -0.01263559f, 0.01164942f, 0.15014498f, 0.22320296f, -0.08520343f, -0.26183912f, -0.09544864f, 0.04522718f, 
    -0.22830132f, -0.24194773f, 0.24003221f, -0.15166953f, -0.88676327f, -0.54444838f, -0.77631462f, -0.08870296f, 
    0.24112652f, -0.04948640f, -0.48144868f, -1.02921391f, -0.72459686f, -0.30524239f, -0.41577277f, -0.34408599f, 
    -0.17391802f, -0.17268918f, -0.54398841f, -0.38861620f, -0.58497107f, -0.13032302f, -0.21098523f, -0.55843234f, 
    0.20418106f, -0.04968762f, -0.22602993f, 0.06560230f, 0.09054625f, -0.87989306f, -0.54888725f, -0.73173928f, 
    -0.84922379f, -0.75817168f, 0.70066273f, 0.46955991f, 0.19977449f, 0.24300519f, 0.28046238f, -0.01895651f, 
    -0.05510663f, -0.35761636f, 0.00489409f, -0.16061909f, -0.18538496f, -0.30929527f, -0.08120646f, -0.31202531f, 
    -0.59598881f, -0.20039812f, -0.13933372f, -0.08870176f, -0.11405465f, -0.12359628f, 0.99824756f, -0.45746088f, 
    -0.43012735f, -0.36089316f, -0.05741474f, 0.26571882f, 0.18195379f, 0.26107308f, 0.20547307f, 0.14294615f, 
    -0.09230033f, 0.12976462f, -0.02364153f, 0.02934624f, -0.11684489f, -0.03967413f, -0.21266407f, 0.12647916f, 
    0.10838851f, -0.27946767f, 0.19814166f, -0.46393359f, 0.17897594f, 0.32951340f, 0.00705755f, -1.59240019f, 
    1.09938741f, 0.46889690f, -0.93699455f, 0.13087796f, -0.70447463f, 0.91835803f, -0.10751096f, 0.42732185f, 
    -0.53795242f, -0.05041022f, -0.08838731f, -0.50414515f, 0.09840596f, 0.12887627f, -0.09439864f, -0.15541615f, 
    -0.04076607f, 0.12316310f, -0.14989004f, -0.09765748f, -0.03511437f, 0.24145596f, -0.16069944f, -0.29780033f, 
    -0.15665385f, -1.15133429f, 0.24105068f, 0.20878899f, -0.31471244f, -1.06116307f, -1.37989843f, -0.86666340f, 
    0.13095969f, -0.86299038f, 0.49531108f, 0.08109591f, 0.21892330f, 0.88593966f, 0.23709118f, -0.05403372f, 
    0.00871400f, -0.23570688f, -0.38411462f, -0.32069629f, 0.01746678f, 0.08611351f, 0.11571448f, -0.08266206f, 
    0.11086723f, 0.49889919f, -0.27790412f, -0.91575700f, -0.80802190f, -0.26129571f, -0.35134894f, -0.28863919f, 
    -0.06710104f, -0.03832243f, 0.15148826f, 0.55144584f, 0.24790423f, 0.41857919f, -0.02567652f, 0.30384827f, 
    0.20671906f, 0.06453194f, -0.10294561f, -0.11451824f, -0.12156588f, 0.09202816f, -0.53672421f, 0.00232435f, 
    0.16570202f, -0.20805134f, 0.38166857f, -0.10099641f, -0.14955629f, -0.06493286f, -0.25342390f, -0.40196705f, 
    -0.24845804f, -0.45354989f, -0.64374340f, -0.55162627f, 0.41765293f, -0.04979018f, -0.36015493f, -0.43930185f, 
    -0.06414650f, -0.37402257f, -0.34122708f, -0.02066017f, -0.47384483f, -0.07186956f, -0.43801907f, 0.09241083f, 
    -0.23669621f, -0.25367147f, -0.57132930f, -0.69720739f, -0.15034570f, -0.08672086f, 0.52904361f, -0.19576742f, 
    -0.48024189f, -0.16858424f, 0.25061885f, 0.66264713f, 0.12867032f, -0.41204479f, -0.29539651f, 0.05654965f, 
    0.67167354f, -0.21637581f, 0.35974267f, 0.16839585f, -0.08685416f, -0.32990220f, -0.40225795f, -0.24410118f, 
    0.37682697f, 0.22100042f, -0.38949418f, 0.10219856f, 0.45829159f, 0.00586621f, 0.30658552f, -0.26453182f, 
    -0.09905748f, -0.33561668f, 0.16215387f, -0.13330980f, -0.19453019f, 0.18232156f, -0.13100456f, 0.32760602f, 
    0.50340688f, -0.39934590f, -0.34171158f, 0.10736424f, 0.20105298f, -0.20533186f, -0.03228520f, -0.02644890f, 
    -0.43803564f, 0.48415446f, 0.16730906f, 0.01459583f, 0.06178654f, -1.38616228f, -0.70399368f, 0.18054512f, 
    -0.29812112f, -0.48177379f, 0.21899125f, 0.31724769f, 0.00335498f, 0.29505736f, 0.78946924f, 0.30700505f, 
    0.08828589f, 0.18382706f, 0.00485598f, 0.03321297f, -0.22448249f, -0.09727605f, -0.05832022f, -0.16522220f, 
    -0.26015979f, 0.06992201f, 0.01813745f, 0.16307299f, -0.02011739f, 0.05466237f, -0.24912390f, -0.79748589f, 
    -0.04098902f, -0.17822829f, -0.45863155f, -0.65244591f, -0.38080040f, 0.13358867f, -0.36005989f, -0.22461198f, 
    0.20134088f, 0.04197904f, -0.09891728f, -0.35705313f, -0.00615599f, 0.14837366f, 0.20720892f, 0.23897623f, 
    0.29503438f, 0.39885700f, -0.35219678f, -0.11467300f, -0.16404539f, -0.10263687f, 0.21988501f, 0.13194524f, 
    -0.56873661f, -0.58662033f, 0.23308538f, 0.21167618f, 0.05481858f, 0.07116141f, 0.21025605f, 0.22896077f, 
    -0.25558782f, -0.27670830f, 0.34196949f, 0.00767527f, 0.00395893f, 0.37075171f, -0.34388366f, -0.35746363f, 
    0.29615131f, -0.05185061f, 0.07561558f, 0.45290184f, 0.66351140f, 0.26526493f, -0.08718401f, -0.40668783f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.33612773f, 0.14193994f, 0.34416288f, 0.09077875f, -0.29767871f, 0.15586913f, 0.46851197f, 0.28743923f, 
    0.40331331f, 0.45207739f, 0.42680237f, 0.32912275f, 0.11636726f, 0.47109199f, 0.18006314f, -0.02435932f, 
    -0.04164249f, 0.45943478f, 0.50413299f, 0.00618251f, -0.11200123f, -0.14607768f, 0.42404649f, 0.35021853f, 
    0.09045543f, 0.56869900f, -0.40859440f, 0.40391845f, 0.21454047f, 0.41689724f, -0.17084439f, 0.10548271f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17436819f, -0.19381732f, -0.06176497f, -0.24480563f, 0.04926302f, -0.24518475f, -0.01658543f, -0.03332874f, 
    -0.01402103f, -0.00079515f, -0.03474577f, 0.03272049f, -0.43927863f, -0.16728751f, -0.19340613f, 0.19212137f, 
    0.04182214f, 0.01435106f, 0.04068813f, 0.05816453f, -0.02339202f, -0.01060788f, -0.04004144f, -0.00754247f, 
    0.07700562f, 0.18939646f, -0.01661307f, -0.15956926f, -0.03428564f, 0.05464723f, -0.02397964f, -0.04521634f, 
    -0.05662439f, -0.03395759f, 0.00596422f, -0.04319767f, 0.62077731f, -0.26094979f, -0.52912009f, -0.19908869f, 
    -0.03359671f, 0.08104561f, 0.07019269f, 0.06670044f, -0.02172016f, 0.09706519f, 0.05431624f, 0.07061759f, 
    0.44615492f, 0.23837620f, -0.14330630f, -0.33143759f, 0.15314814f, 0.21020056f, -0.04904842f, 0.01585329f, 
    -0.04709032f, -0.02016333f, -0.01974032f, 0.05431092f, -0.66361499f, 0.13634528f, -0.02879077f, 0.15287097f, 
    -0.03724540f, 0.05428175f, 0.03864870f, -0.05870070f, 0.04730019f, 0.02005128f, 0.01624651f, 0.00044558f, 
    -0.27710903f, -0.11365993f, -0.18579052f, -0.23445131f, -0.09872562f, -0.02182035f, -0.01421286f, -0.07910563f, 
    -0.04550277f, -0.07391774f, -0.18030800f, -0.13327955f, -0.57113367f, -0.64880711f, 0.00862795f, 0.11583520f, 
    -0.01806439f, 0.06040594f, -0.07475203f, 0.01950368f, -0.02361804f, 0.01595348f, 0.02765708f, 0.17854127f, 
    -0.22889891f, -0.31567717f, -0.42352021f, 0.08543453f, -0.00588878f, -0.00141673f, -0.04914985f, -0.05438757f, 
    -0.11740179f, -0.12746285f, -0.17461747f, -0.05006769f, 0.27525336f, 0.09755904f, -0.37258995f, -0.26252133f, 
    -0.09026936f, 0.04756833f, -0.06792940f, -0.21938719f, -0.02207603f, 0.11106591f, 0.03876762f, -0.00422751f, 
    -0.59990042f, -0.79389089f, -0.38408500f, 0.34581256f, 0.00153327f, -0.03353063f, -0.03117826f, 0.00916542f, 
    -0.02626152f, -0.07321306f, -0.00522908f, -0.10297215f, 0.65082335f, -0.03021076f, 0.29967847f, -0.33017564f, 
    0.01078566f, 0.00245928f, 0.13652059f, 0.12511951f, -0.00455909f, 0.03982103f, -0.14903072f, -0.26054391f, 
    0.00271245f, -0.06931304f, -0.00280322f, 0.10789758f, -0.00870040f, 0.02837290f, 0.00117377f, 0.04994044f, 
    -0.15555644f, -0.01497136f, 0.00252240f, -0.02674362f, 0.26756114f, 0.13064641f, 0.09210289f, -0.07673789f, 
    0.02938688f, 0.08497136f, 0.16846029f, 0.00152304f, -0.20043468f, -0.13982044f, -0.07325105f, 0.05111037f, 
    0.24442498f, 0.13402209f, -0.30482152f, -0.11199001f, 0.09575585f, -0.04264852f, 0.08996061f, 0.10903342f, 
    0.05759218f, 0.07440639f, 0.06727619f, 0.02426040f, 0.40281698f, 0.17713894f, -0.03133853f, -0.14532045f, 
    -0.01652723f, 0.06393851f, 0.05497514f, -0.08496439f, -0.03271322f, 0.14621116f, 0.01353524f, -0.00237003f, 
    -0.10019082f, -0.03097755f, 0.14537778f, 0.06569004f, 0.06889392f, 0.24569248f, -0.01158710f, 0.01813874f, 
    0.02428946f, 0.01881036f, 0.04780855f, 0.00838005f, -0.00898075f, -0.03339816f, 0.19649792f, -0.39874989f, 
    -0.25394252f, 0.03520202f, -0.02228601f, 0.08202384f, 0.19377559f, -0.03781752f, 0.10961023f, -0.21793377f, 
    0.06753288f, 0.02275554f, -0.41292292f, 0.00824411f, 0.02641970f, -0.04510960f, -0.13769853f, -0.32853472f, 
    -0.11140204f, -0.17998321f, -0.07517792f, -0.20193452f, 0.32667753f, 0.26437101f, -0.54446483f, 0.02570261f, 
    -0.05211922f, -0.17748480f, -0.24246822f, 0.06996932f, -0.04174637f, -0.02970694f, -0.02576299f, -0.03474279f, 
    0.46010628f, 0.36356589f, -0.04046509f, -0.30437639f, 0.11826853f, 0.14455993f, 0.09943321f, -0.17277458f, 
    -0.08959359f, -0.16628082f, -0.18585275f, -0.06082781f, 0.12639908f, -0.06916820f, -0.13120481f, 0.01362724f, 
    0.13871410f, 0.20170398f, -0.00849820f, -0.18570365f, -0.10645941f, 0.07080512f, -0.03039889f, 0.17438924f, 
    -0.14890952f, -0.23051585f, -0.45415536f, 0.17149405f, -0.01476802f, 0.02191128f, -0.05475921f, -0.08061012f, 
    -0.12116852f, -0.33921510f, -0.54608077f, -0.04585932f, -0.49223036f, -0.13897671f, 0.04127637f, -0.15181890f, 
    -0.46993506f, 0.18388580f, -0.01620971f, -0.09543910f, -0.04482820f, 0.00910560f, 0.01798278f, 0.17926005f, 
    0.39145175f, 0.29107028f, 0.05516920f, -0.57397950f, -0.03876456f, 0.06016901f, 0.04932192f, 0.06948140f, 
    0.09365243f, -0.02411060f, -0.01892175f, -0.02022245f, 0.28586933f, 0.16614471f, -0.10579716f, -0.04657009f, 
    0.09249646f, 0.08055512f, -0.12358940f, -0.06658967f, -0.19615109f, -0.07450683f, 0.01384231f, 0.00866724f, 
    0.37356406f, 0.15579931f, -0.02100195f, -0.07311926f, -0.21758065f, -0.24130735f, -0.05112218f, 0.07909200f, 
    -0.14028952f, -0.06308737f, 0.00931889f, 0.01411156f, -0.27807322f, -0.00773628f, 0.22613029f, -0.34168750f, 
    -0.16371633f, -0.22628342f, 0.03711579f, -0.04336025f, -0.04927819f, 0.00849592f, -0.09092180f, -0.31093398f, 
    -0.06842333f, -0.08664334f, -0.10841954f, -0.00281992f, -0.11370055f, -0.23486294f, -0.04608480f, -0.01638961f, 
    -0.18235998f, -0.02836200f, 0.02430454f, 0.05573108f, 0.04044875f, 0.06003572f, 0.12114965f, -0.07956994f, 
    0.04292900f, 0.17477430f, 0.06928121f, 0.09798105f, -0.02870227f, 0.00220685f, -0.17266804f, 0.01337936f, 
    0.48748651f, 0.23898977f, 0.09776298f, -0.43663248f, 0.23066957f, 0.13410382f, 0.11690249f, 0.03693490f, 
    -0.00581612f, 0.08316165f, 0.04098424f, 0.09357730f, -0.03523596f, 0.12794924f, -0.02841082f, 0.05492844f, 
    -0.04160288f, -0.01010178f, -0.06997328f, -0.08897903f, -0.26561671f, -0.22226064f, -0.11548804f, -0.06949746f, 
    -0.05138494f, 0.14241904f, -0.19147207f, -0.04508738f, 0.03720958f, -0.21476535f, 0.19588880f, 0.01606121f, 
    -0.08997201f, 0.07783724f, 0.15027142f, -0.01686739f, 0.12692513f, 0.23034398f, 0.23577972f, 0.19331631f, 
    0.01915685f, -0.01057441f, -0.03565348f, 0.01271391f, 0.06064641f, 0.01119334f, -0.00352264f, 0.05355930f, 
    0.09168926f, 0.09800925f, 0.10238434f, -0.21986233f, 0.03269409f, -0.03962776f, 0.06447402f, -0.14408801f, 
    -0.10756078f, 0.04087919f, -0.04552380f, 0.00256342f, 0.43094736f, -0.22527096f, 0.23202112f, 0.00034517f, 
    0.08536097f, 0.00337855f, 0.00445181f, -0.06284462f, 0.11973342f, -0.11526594f, 0.05360543f, -0.53429925f, 
    0.12297020f, 0.21771690f, 0.39818960f, 0.48740652f, 0.10672334f, 0.01770906f, 0.05499450f, -0.10095277f, 
    -0.08062848f, -0.07598823f, 0.04690137f, -0.02385629f, 0.15441906f, 0.02214614f, 0.02036030f, -0.16399677f, 
    -0.05595451f, -0.03286796f, 0.12681100f, -0.06021369f, -0.00058989f, -0.04886470f, 0.05832040f, -0.22754641f, 
    -0.14087170f, -0.09413821f, 0.16178395f, 0.15152775f, 0.08241296f, 0.04054875f, -0.00305817f, -0.00061979f, 
    0.00243261f, 0.12823585f, 0.15895642f, 0.02730587f, 0.49259764f, -0.25245818f, 0.19094266f, -0.15390156f, 
    0.01311084f, 0.03448623f, -0.04659428f, -0.11461315f, -0.14070855f, 0.01978358f, -0.34638420f, -0.19083798f, 
    -0.04905524f, 0.05213086f, 0.21407738f, 0.16614227f, -0.01967362f, -0.04935099f, -0.09855823f, -0.07299937f, 
    -0.05559240f, 0.11769771f, 0.00727714f, 0.04426287f, 0.13931249f, 0.13658857f, -0.36098352f, 0.06365990f, 
    0.03751151f, -0.01324813f, -0.06811388f, 0.21663542f, -0.01260013f, -0.14817964f, -0.04905866f, 0.05602280f, 
    0.83141661f, 0.16693889f, 0.47554383f, -0.07526125f, -0.02956150f, 0.09801954f, 0.01914152f, 0.02131645f, 
    0.05305395f, -0.01646582f, -0.02253890f, 0.06771772f, -0.00122786f, 0.17999791f, 0.10490681f, 0.16289036f, 
    -0.02546237f, -0.03648673f, 0.04060656f, -0.07941547f, 0.20071630f, -0.24763963f, -0.28077045f, 0.05028926f, 
    0.06670433f, 0.02649196f, 0.04060539f, -0.03880462f, -0.04950064f, 0.01722864f, -0.03551908f, 0.03828778f, 
    -0.16030705f, 0.09843780f, 0.15098934f, -0.12846978f, -0.10737266f, 0.19942258f, -0.02000332f, -0.04753459f, 
    -0.07421071f, 0.18807475f, -0.19827412f, 0.08155619f, -0.02335619f, -0.01188228f, -0.06729834f, -0.01092834f, 
    -0.03571757f, 0.19739369f, -0.36297914f, -0.09829251f, -0.34173554f, -0.37346634f, -0.16391437f, -0.11658627f, 
    -0.07588550f, -0.07538115f, 0.02321405f, 0.13894348f, 0.54147834f, -0.09813542f, -0.26522484f, -0.22195528f, 
    -0.03660537f, 0.02411620f, -0.11920650f, -0.00728431f, -0.11187541f, -0.22247481f, -0.47244710f, -0.10791747f, 
    -0.02725631f, -0.02368562f, 0.00644070f, -0.21004349f, 0.09285156f, 0.10256533f, -0.53346288f, -0.26555848f, 
    -0.28226927f, 0.07886173f, -0.00286931f, -0.09876966f, -0.51255053f, 0.55105931f, -0.33136988f, -0.35043138f, 
    0.00774047f, 0.11251256f, -0.07691126f, -0.03303502f, 0.00486631f, 0.18298550f, 0.07263394f, -0.16997752f, 
    0.56571209f, -0.15452251f, -0.30983382f, 0.01313763f, 0.02560155f, 0.07740580f, 0.27192816f, -0.05070471f, 
    0.04480089f, 0.07693505f, -0.02367462f, -0.05092683f, -0.23191695f, -0.15616298f, -0.34852290f, 0.13644829f, 
    0.09962254f, 0.03611639f, 0.18021581f, -0.01566160f, 0.24098000f, 0.06152564f, -0.02630363f, 0.17212282f, 
    0.08456571f, -0.00712530f, 0.20803012f, 0.32191277f, 0.09817261f, -0.05263650f, 0.04705872f, 0.17443945f, 
    0.08815029f, -0.00923133f, -0.04354974f, -0.00473087f, 0.14295051f, -0.01046641f, -0.16215068f, -0.16370568f, 
    0.01057189f, 0.01421085f, -0.08607303f, 0.09698962f, 0.02325493f, 0.02176336f, -0.03012635f, -0.11270617f, 
    0.58084887f, 0.07918023f, 0.14035684f, -0.01878659f, -0.00814877f, 0.01167899f, 0.07893968f, -0.00449305f, 
    0.20956580f, 0.00992643f, 0.18632701f, -0.08903842f, -0.53092295f, -0.59209961f, -0.16130398f, -0.59050697f, 
    0.16989878f, -0.05992981f, -0.31315723f, 0.17686428f, 0.09587100f, 0.12918532f, -0.01696593f, -0.01931022f, 
    -0.50775069f, 0.10124598f, -0.17127129f, -0.04953242f, -0.08376574f, -0.25635818f, -0.00578455f, 0.13372545f, 
    -0.11310305f, 0.01612600f, 0.05631232f, 0.04330847f, -0.16629227f, -0.20205727f, -0.02692855f, -0.03130861f, 
    0.10006356f, 0.15472813f, 0.13150755f, -0.06550155f, 0.34968388f, -0.01720559f, 0.01596540f, 0.08827026f, 
    0.10882034f, -0.03977833f, -0.01897707f, -0.45498586f, -0.10836802f, -0.18848822f, -0.11616578f, 0.32838339f, 
    0.03289229f, -0.06430045f, -0.21429285f, -0.09945323f, -0.86494839f, 0.18024416f, 0.18085197f, -0.04752577f, 
    0.02062910f, 0.12240322f, 0.06931195f, 0.03762721f, 0.06818935f, -0.08320408f, 0.14528950f, 0.08919930f, 
    0.23561120f, -0.11179553f, 0.07615191f, 0.00217163f, 0.17060830f, 0.01815950f, -0.02714991f, 0.12237602f, 
    -0.16338977f, 0.02958560f, -0.05187880f, 0.01973242f, -0.10470614f, -0.24766403f, -0.30220142f, -0.30675268f, 
    -0.03298027f, 0.10414824f, -0.01671161f, 0.10161945f, -0.25092798f, 0.03656127f, 0.16596749f, -0.04485257f, 
    0.00439755f, 0.33661354f, 0.05788998f, 0.07032056f, -0.15597111f, 0.03610539f, -0.10354710f, -0.41700640f, 
    -0.08236676f, -0.10350480f, -0.10264024f, -0.00527067f, 0.12595953f, 0.00539935f, 0.05233841f, 0.02067308f, 
    -0.06052394f, -0.02791127f, -0.01863478f, 0.18206316f, -0.25290048f, -0.01101367f, 0.07196849f, -0.08186772f, 
    -0.14241621f, 0.53635645f, -0.39937288f, 0.07141772f, 0.06438280f, -0.07585143f, 0.01290246f, 0.08587840f, 
    -0.04481426f, 0.06879744f, 0.03685737f, -0.08232331f, -0.54140329f, -0.26243675f, 0.20105919f, -0.34177199f, 
    0.01787049f, -0.06534637f, 0.04336289f, 0.12471239f, 0.02133506f, -0.00240393f, -0.05099083f, 0.06473933f, 
    -0.13348882f, -0.07023605f, 0.28073180f, -0.45130643f, 0.05838817f, -0.05754113f, -0.19061667f, -0.16056296f, 
    -0.10511306f, -0.00803480f, -0.00763268f, -0.03243961f, 0.18475269f, -0.17498629f, 0.51271075f, 0.35149354f, 
    0.00607195f, -0.09453013f, 0.05770057f, 0.05924885f, 0.07616230f, 0.06223382f, 0.18786480f, -0.01686045f, 
    -0.44247961f, -0.48572764f, 0.24905561f, 0.19294441f, -0.06347857f, -0.10922036f, 0.17510825f, 0.05704078f, 
    -0.00360913f, -0.08286566f, 0.00095910f, -0.08015470f, -0.22459687f, -0.03470322f, -0.20180854f, -0.39903167f, 
    -0.01580986f, -0.00977480f, -0.01649187f, 0.16469087f, 0.05124417f, -0.12077061f, -0.06983545f, 0.04077115f, 
    0.25590628f, -0.08228891f, -0.29582113f, 0.21231364f, -0.04062442f, -0.04391165f, 0.02391648f, 0.03779591f, 
    -0.04143301f, 0.07942352f, -0.22719811f, 0.25920412f, -0.33513227f, 0.18685673f, -0.01540398f, -0.10640312f, 
    -0.02982685f, 0.01595894f, -0.02425776f, -0.13703580f, 0.19452749f, 0.37699324f, 0.02316874f, 0.17022243f, 
    0.13825136f, -0.06540320f, 0.15475576f, -0.09565579f, 0.06901965f, -0.01672415f, 0.09788904f, -0.07657013f, 
    -0.04182637f, -0.09068858f, 0.05795843f, 0.16870168f, -0.23386037f, -0.02454373f, 0.26479951f, -0.09686126f, 
    0.02953319f, 0.08024437f, -0.21066192f, 0.14620429f, 0.04822291f, 0.15035307f, -0.05147053f, 0.03356902f, 
    -0.45078361f, 0.01144968f, -0.16880828f, -0.33883941f, -0.06509046f, -0.01328739f, -0.05818710f, -0.03228072f, 
    -0.08278957f, -0.14195487f, -0.03603160f, -0.32663336f, -0.29138288f, -0.13112737f, -0.20332019f, 0.23940085f, 
    -0.02354833f, 0.00962403f, -0.02052263f, 0.12997065f, 0.11393447f, -0.05498316f, -0.19593637f, 0.04177427f, 
    -0.06623451f, 0.10316088f, -0.09458035f, 0.11745217f, -0.01216213f, -0.02081079f, 0.09572628f, 0.01743206f, 
    -0.16753806f, 0.10562822f, 0.11733624f, 0.14424980f, 0.10744929f, 0.46168652f, 0.12707250f, 0.30107984f, 
    -0.07943498f, 0.03175265f, 0.11043943f, 0.02449479f, -0.04850059f, 0.02371734f, -0.14686629f, 0.02310032f, 
    -0.56422406f, -0.21883960f, 0.26916108f, -0.40210980f, 0.14554852f, 0.02133758f, -0.30420238f, -0.05805661f, 
    0.05630799f, 0.01614096f, 0.03455995f, -0.06334341f, -0.04208929f, -0.02204421f, 0.33786371f, 0.00584506f, 
    0.04215394f, -0.06971388f, 0.07084569f, 0.09787488f, 0.03151901f, -0.00698525f, -0.21493006f, 0.04207988f, 
    0.29603261f, 0.28646764f, 0.18098727f, 0.26429781f, 0.00836600f, 0.12647766f, -0.02157632f, 0.20864038f, 
    0.03901115f, 0.09445661f, -0.02251336f, 0.16268581f, -0.13514593f, 0.45997164f, -0.48586714f, 0.15872417f, 
    0.18573299f, 0.11822502f, -0.17460495f, 0.09247594f, -0.06554502f, 0.12253404f, -0.15797296f, 0.09750841f, 
    -0.09287326f, 0.23161404f, 0.10931873f, -0.02891715f, 0.04516796f, 0.05935489f, -0.00894878f, -0.04501647f, 
    -0.02739740f, 0.00793474f, -0.32074991f, -0.04770150f, -0.07644064f, -0.17602001f, 0.06345572f, -0.10438186f, 
    -0.02627519f, -0.35742891f, -0.29394022f, 0.04562403f, -0.00778880f, -0.16518269f, -0.07645435f, -0.01511124f, 
    -0.37551469f, -0.43517214f, -0.01594447f, -0.25380746f, 0.07738856f, -0.09939127f, -0.04532637f, -0.04325667f, 
    -0.02756803f, -0.02768899f, 0.03489335f, -0.22938886f, -0.12749994f, 0.60563016f, 0.64058983f, 0.23040649f, 
    -0.03382261f, 0.01427799f, 0.14580576f, 0.14894435f, -0.01142618f, -0.18225577f, 0.00838370f, 0.01944472f, 
    -0.39123598f, 0.20603265f, 0.12052944f, 0.05367336f, -0.13634117f, -0.02452889f, 0.05993620f, -0.09529949f, 
    -0.21316200f, -0.21669048f, 0.07205135f, -0.14171067f, 0.40185291f, 0.06180599f, 0.06588606f, -0.03428104f, 
    0.08424542f, -0.01601839f, -0.02157654f, -0.08737808f, -0.18404648f, -0.02033572f, 0.01052254f, -0.04585758f, 
    -0.87122679f, -0.74053812f, -0.51829576f, -0.15453617f, -0.02984907f, -0.04590575f, -0.08725312f, -0.32383466f, 
    -0.03926122f, -0.01520325f, -0.05874367f, -0.00345430f, -0.05397727f, -0.01570320f, 0.13149488f, 0.11288068f, 
    -0.05500716f, -0.03820141f, 0.07988071f, -0.24049155f, 0.09800414f, 0.17326646f, -0.02351824f, 0.10401389f, 
    -0.73713857f, 0.01224063f, 0.12745544f, -0.30660126f, 0.02897084f, 0.09677272f, -0.11608914f, -0.21899927f, 
    0.06370803f, 0.05307721f, -0.12633385f, 0.09307041f, 0.04287423f, -0.27128807f, -0.18679275f, 0.32108116f, 
    -0.00501541f, 0.21514596f, 0.07530177f, -0.03407075f, 0.07553978f, -0.17709206f, 0.07810031f, 0.09055609f, 
    0.04469405f, -0.14641252f, 0.01481925f, -0.13980345f, -0.03501746f, 0.04361406f, -0.03671413f, 0.02323899f, 
    0.05590113f, -0.07175522f, -0.07117440f, -0.06830078f, 0.51386726f, 0.21538104f, 0.34208721f, 0.39176345f, 
    0.04231175f, 0.04144405f, 0.03098592f, -0.05007591f, -0.15520936f, -0.13960004f, 0.08473801f, 0.06832592f, 
    -0.27769741f, -0.02731491f, -0.08562043f, -0.22572765f, 0.02093739f, 0.13534497f, -0.02866457f, 0.00325340f, 
    -0.00386653f, 0.01307528f, 0.05805111f, 0.00562629f, -0.06661116f, -0.06400269f, 0.01551280f, 0.05814458f, 
    0.05626627f, -0.05839275f, 0.09557941f, -0.06614967f, 0.20042244f, 0.02720186f, -0.11776446f, -0.12802982f, 
    -0.35778320f, 0.79173535f, 0.03202151f, 0.18894452f, -0.27540922f, -0.07267865f, -0.16721253f, 0.10772407f, 
    -0.07246511f, -0.03746229f, 0.11358675f, 0.12525906f, -0.32556933f, -0.17083596f, 0.27223057f, -0.31490809f, 
    -0.41231111f, -0.05370892f, -0.04639009f, -0.00795364f, 0.11986244f, 0.16109610f, -0.10894413f, -0.13091740f, 
    0.25690424f, -0.15866642f, 0.27247989f, 0.12318367f, -0.19135967f, 0.02663500f, -0.00656855f, -0.06492072f, 
    0.05632909f, -0.00477076f, -0.10511323f, -0.21753433f, 0.13458158f, 0.69753540f, -0.00110218f, -0.13099839f, 
    0.20456772f, 0.14337875f, -0.02024970f, -0.02168805f, -0.32584572f, -0.00189217f, 0.03650185f, -0.17780060f, 
    0.02039710f, -0.11838533f, -0.17674296f, 0.26249659f, 0.12468386f, 0.12551814f, 0.03593527f, 0.03897901f, 
    -0.01146895f, 0.05979348f, -0.02666957f, -0.00068164f, 0.01340112f, -0.51835376f, 0.52084970f, -0.05058245f, 
    -0.33181718f, -0.07679325f, -0.26267406f, 0.04833361f, 0.29079449f, -0.12426371f, 0.10439881f, 0.08275688f, 
    0.16614127f, 0.13753092f, -0.42157850f, -0.63672096f, -0.01341379f, -0.14473158f, 0.11380029f, 0.05062003f, 
    -0.18238580f, -0.11030950f, -0.05954033f, -0.23344615f, -0.45548138f, -0.19216487f, 0.10136843f, 0.05435751f, 
    -0.25785801f, -0.05509935f, -0.02524082f, 0.03520159f, 0.02934415f, 0.16139171f, -0.09177475f, 0.02054949f, 
    -0.16150485f, -0.02569171f, -0.33755428f, 0.19609994f, 0.15047190f, 0.18822511f, -0.23218910f, -0.14781289f, 
    -0.10975707f, -0.12936345f, 0.36861613f, -0.28228256f, -0.39428896f, 0.26524675f, -0.17981781f, 0.06458067f, 
    -0.00318959f, -0.07960960f, 0.08167545f, -0.04737717f, -0.13062522f, 0.03325282f, 0.00085346f, 0.16290331f, 
    -0.47163662f, 0.10804545f, 0.25526866f, -0.01476245f, 0.15407857f, -0.01653864f, -0.35265777f, -0.15104517f, 
    -0.10648020f, -0.00470959f, 0.17933331f, -0.13060419f, -0.26138255f, 0.77977669f, -0.37750030f, -1.00807548f, 
    0.21731178f, 0.14111428f, 0.07305430f, -0.07084282f, -0.41710326f, -0.01322743f, 0.05069093f, -0.10269453f, 
    -0.12913710f, -0.61892617f, -0.04106469f, -0.41705629f, 0.23616634f, 0.17993720f, 0.17247777f, -0.09145005f, 
    -0.09487295f, 0.06782310f, -0.38334110f, -0.05297333f, -0.16881591f, -0.21232006f, -0.08830695f, 0.12254021f, 
    -0.01989453f, 0.00217811f, 0.03327242f, -0.09626875f, -0.00646527f, 0.10560133f, 0.11787490f, 0.01715271f, 
    0.05023034f, -0.27265325f, 0.11792141f, 0.29256266f, 0.03767290f, 0.28341180f, -0.12839711f, 0.02140932f, 
    0.11637699f, 0.01853298f, -0.02811462f, 0.06085425f, -0.31541494f, -0.15041305f, -0.14116496f, 0.10486841f, 
    0.17702438f, 0.08150334f, 0.06002155f, -0.06066816f, -0.00827797f, 0.08066250f, -0.05377637f, 0.05160081f, 
    0.78463817f, -0.07618650f, 0.16778411f, 0.39217120f, 0.15427050f, 0.10397479f, -0.03112876f, -0.15135927f, 
    -0.02006920f, -0.05143083f, -0.09600572f, 0.16538140f, 0.31173405f, -0.43292210f, -0.07501879f, -0.13191074f, 
    0.10776073f, 0.03768787f, -0.13841331f, 0.02125211f, -0.00472288f, -0.04474744f, -0.02940955f, -0.01269258f, 
    -0.40350607f, 0.25977215f, -0.08161806f, 0.39732531f, 0.12863465f, -0.23009250f, 0.03881943f, -0.06270099f, 
    -0.03089542f, -0.03706661f, -0.02011174f, 0.00873357f, -0.26359746f, -0.04939324f, 0.02478221f, 0.36865523f, 
    0.14241529f, 0.06897908f, 0.25348982f, 0.12404019f, -0.09011047f, 0.17448854f, -0.08762685f, 0.07911369f, 
    -0.03826186f, -0.10245465f, -0.16146122f, 0.15279911f, 0.11956246f, 0.04445538f, -0.05541967f, 0.01947629f, 
    -0.08598137f, -0.05269126f, -0.17554656f, -0.04223731f, 0.06384891f, -0.24429628f, 0.08844645f, 0.29468700f, 
    0.16257887f, 0.12403657f, 0.07418918f, 0.02575911f, -0.02579037f, 0.06809797f, 0.10560187f, 0.13392471f, 
    -0.64874005f, -0.01354390f, -0.01489012f, 0.13529748f, 0.13767618f, -0.03088293f, 0.41784450f, -0.22042385f, 
    -0.07670745f, -0.11963595f, 0.17444222f, 0.03813702f, 1.25206244f, -0.03027809f, -0.03667170f, -0.24568376f, 
    -0.04268835f, 0.00874641f, -0.17147328f, -0.27659598f, -0.18672356f, -0.36149967f, 0.15778109f, 0.03606415f, 
    -0.00138707f, -0.29652774f, -0.05034927f, 0.11506817f, 0.11806362f, 0.11250994f, 0.01552828f, 0.22057132f, 
    -0.00172942f, -0.01657748f, 0.10859329f, -0.20281072f, -0.19208965f, -0.10200279f, -0.15653016f, 0.19968040f, 
    -0.06350568f, -0.01895804f, 0.28440160f, -0.09160682f, -0.03234185f, 0.02804055f, 0.06987619f, 0.06366456f, 
    -0.15319505f, -0.02753399f, 0.12627406f, 0.26331118f, -0.05806709f, -0.02754934f, 0.05271935f, 0.08203171f, 
    0.00578316f, 0.11454238f, -0.07480258f, 0.08391658f, 0.25936717f, -0.07579773f, -0.08244820f, -0.24352190f, 
    -0.32979190f, -0.18276677f, -0.08753878f, 0.07453637f, -0.12235969f, -0.05540144f, 0.00358603f, -0.10836647f, 
    -0.36320373f, 0.02331203f, -0.23380230f, 0.07792387f, -0.11372480f, -0.24723148f, -0.08773932f, -0.06001663f, 
    -0.21481588f, -0.09900268f, -0.26184368f, 0.01336492f, 0.27036643f, -0.12319438f, 0.11409268f, 0.02075344f, 
    0.16111714f, 0.00501698f, -0.10447708f, -0.04460404f, 0.01034955f, 0.02713262f, -0.04648643f, -0.05341094f, 
    -0.15667160f, -0.19960518f, -0.13937132f, 0.23873189f, -0.01725853f, 0.02602577f, -0.01141140f, -0.09576245f, 
    0.08630373f, -0.11193025f, -0.05790482f, 0.03965052f, -0.03053379f, -0.01489023f, -0.03058548f, -0.19194721f, 
    -0.00859918f, 0.08088718f, -0.21619613f, -0.05008811f, 0.00508545f, -0.10907725f, 0.10171729f, -0.13787788f, 
    -0.01817828f, -0.32721978f, 0.40625483f, 0.39975613f, -0.12756208f, 0.01187775f, -0.10860420f, 0.00963779f, 
    0.00805021f, -0.01577657f, -0.03739756f, 0.08373760f, 0.27739662f, -0.03646297f, -0.08979743f, 0.21704304f, 
    0.06412879f, 0.01466241f, 0.06025830f, 0.08752438f, 0.08356113f, -0.01384125f, 0.08973315f, 0.06414944f, 
    -0.06984979f, 0.14118743f, -0.10814441f, 0.25240859f, 0.01985982f, 0.07887258f, -0.12389342f, 0.16243158f, 
    0.01229975f, -0.09495832f, -0.01775812f, -0.05429234f, -0.57108712f, -0.45146778f, 0.12688558f, -0.26242682f, 
    -0.08420032f, -0.18684070f, 0.12390006f, -0.03456681f, -0.00482214f, -0.00750122f, -0.04737807f, 0.16671185f, 
    0.13994744f, 0.06324723f, 0.05474940f, 0.11910048f, -0.27426562f, -0.09557060f, -0.06732228f, 0.15047356f, 
    0.03166867f, 0.06891216f, 0.05826646f, -0.00120956f, 0.43784302f, 0.24057931f, -0.27543968f, 0.45970908f, 
    0.17907833f, -0.06041053f, -0.04378138f, -0.12051132f, 0.12099941f, 0.10808966f, -0.00653361f, 0.07792165f, 
    0.03090535f, -0.35922450f, 0.26140851f, -0.27966252f, -0.11217555f, 0.03996262f, -0.12178395f, 0.05115015f, 
    0.03184115f, -0.13646296f, -0.09738394f, -0.20584278f, -0.13078941f, 0.14110592f, -0.18267614f, -0.06743850f, 
    0.02938589f, -0.14197913f, -0.05063937f, -0.05172641f, -0.03481498f, 0.12031794f, 0.15054296f, 0.35510272f, 
    0.09236366f, -0.08688583f, -0.11527856f, 0.08082686f, 0.07372832f, -0.12688419f, -0.00645581f, 0.01331373f, 
    0.00229453f, -0.14299726f, -0.17318407f, -0.18759239f, 0.15200645f, -0.26596740f, 0.03492090f, -0.06330558f, 
    0.02112924f, -0.07319209f, -0.14200512f, -0.38215655f, 0.01582047f, -0.07932793f, -0.06881224f, -0.14154600f, 
    -0.46869543f, -0.37186441f, -0.63258314f, -0.33847582f, -0.01478929f, -0.02229318f, 0.00614508f, 0.01532723f, 
    0.01049546f, 0.06838360f, 0.04688733f, -0.13751166f, 0.26721770f, -0.69545239f, -0.04879946f, -0.15019616f, 
    0.02211501f, 0.12960468f, 0.15552303f, 0.00088594f, -0.20935714f, 0.22816209f, -0.12089021f, 0.07059927f, 
    -0.00629123f, 0.05660460f, -0.03838601f, -0.02261510f, 0.09600879f, 0.00369635f, 0.08413024f, 0.06916157f, 
    0.13950734f, -0.06958536f, -0.31845614f, 0.17567147f, -0.10334235f, -0.03108851f, -0.04247347f, 0.01504375f, 
    -0.00741843f, -0.14642619f, -0.10886076f, -0.00683371f, 0.10219230f, -0.00968637f, 0.00889254f, 0.14536393f, 
    0.01608091f, 0.39912161f, 0.35529542f, 0.13354942f, 0.18113086f, -0.04773800f, -0.05873407f, 0.11078740f, 
    -0.00134894f, -0.06725799f, -0.04243736f, -0.18208164f, 0.02156744f, -0.05099098f, 0.00561435f, 0.16111039f, 
    -0.08746648f, -0.16373385f, 0.09659436f, -0.08733668f, -0.03049599f, 0.05992747f, 0.18146850f, 0.15508099f, 
    -0.27139187f, 0.12140518f, -0.07301274f, 0.05032582f, -0.17481554f, -0.24811803f, 0.03060337f, -0.06501841f, 
    -0.15579882f, -0.04462753f, -0.00792509f, 0.04676978f, 0.01086668f, 0.09110714f, -0.08063204f, 0.09040368f, 
    -0.25612131f, -0.00460047f, -0.03365955f, -0.01359304f, -0.04377643f, -0.13538419f, -0.18304825f, -0.20227060f, 
    0.05614815f, 0.04517052f, 0.09282812f, -0.03939627f, -0.04115780f, -0.04046420f, -0.31882077f, -0.10360467f, 
    -0.13708302f, -0.11940882f, -0.04899545f, 0.02556168f, 0.30611706f, 0.10329803f, 0.20954856f, -0.20062710f, 
    0.15476167f, -0.13253006f, -0.22345611f, 0.11812168f, 0.10825557f, 0.09158190f, 0.11551999f, -0.01193563f, 
    -0.10633637f, -0.04129719f, 0.17545196f, 0.10740450f, -0.06493008f, 0.14259535f, -0.11769904f, -0.02979830f, 
    -0.05784139f, 0.02206411f, 0.03631523f, 0.09545327f, 0.03034897f, 0.07951787f, 0.12265646f, 0.21747351f, 
    -0.10734953f, -0.22497381f, 0.03211707f, -0.02648433f, 0.23704921f, -0.10632811f, -0.02068033f, 0.10082833f, 
    -0.02627715f, 0.04316944f, 0.00323025f, 0.06390385f, -0.02845291f, -0.01063664f, -0.07567031f, 0.08553223f, 
    -0.06766676f, -0.22432706f, -0.35291636f, 0.02022419f, 0.07161038f, -0.33509967f, -0.29398724f, 0.17285740f, 
    0.07473090f, -0.34812838f, -0.06677248f, -0.28912720f, -0.00541682f, -0.14369558f, -0.05306597f, -0.02545595f, 
    0.13641226f, 0.24705684f, 0.37764797f, 0.24580017f, -0.20610699f, 0.06774561f, 0.06231677f, 0.08084768f, 
    -0.01135224f, 0.00939279f, -0.07606633f, -0.01716275f, 0.17034237f, -0.00892260f, 0.06994831f, 0.12399010f, 
    0.01705088f, -0.00095094f, -0.16387518f, -0.07296420f, -0.01266102f, -0.09935446f, -0.01556937f, 0.00010394f, 
    0.11157805f, 0.23950304f, 0.13761736f, 0.12934706f, 0.16297312f, 0.08227605f, 0.08471409f, -0.11092099f, 
    0.06536213f, -0.02969882f, 0.17381094f, -0.03734526f, 0.09793651f, -0.32927972f, -0.13779916f, -0.09155638f, 
    -0.20196575f, -0.03134653f, 0.07505146f, -0.19853611f, -0.10621541f, -0.05434155f, -0.00162078f, -0.17450845f, 
    0.07860971f, 0.04746413f, -0.15654771f, 0.01788924f, -0.08226355f, 0.12191176f, 0.12525985f, -0.16009164f, 
    0.03188574f, -0.11498002f, -0.06160042f, -0.17885403f, 0.15747826f, 0.32572398f, -0.13076763f, 0.04003448f, 
    -0.02263024f, -0.14812395f, 0.06280887f, -0.18268341f, 0.16752216f, -0.13572139f, 0.00010958f, 0.00625020f, 
    -0.08978162f, 0.07525580f, 0.02391252f, 0.26000398f, -0.18645270f, -0.17364949f, -0.10609157f, 0.07508208f, 
    0.03585765f, 0.09036972f, 0.05747633f, -0.01626869f, 0.12374151f, -0.08089472f, 0.07366082f, -0.06094748f, 
    0.02390359f, 0.03625528f, -0.05632509f, -0.13427460f, 0.18875052f, -0.12833177f, -0.16888517f, 0.06731248f, 
    -0.06792558f, -0.43171820f, 0.23149155f, 0.07491621f, -0.08722297f, 0.02832958f, 0.08387785f, -0.08487283f, 
    0.07364575f, -0.09368031f, -0.14060199f, -0.02344541f, -0.38423228f, -0.05226824f, -0.01913266f, 0.15279213f, 
    0.06303865f, -0.03173763f, -0.01928196f, -0.01613243f, -0.09380476f, -0.08085379f, 0.10895796f, -0.05488389f, 
    0.01064375f, 0.07904465f, -0.01422960f, -0.00254128f, 0.07590152f, 0.21006013f, 0.07599583f, 0.19905671f, 
    0.07182673f, 0.08326372f, 0.08788111f, 0.11452962f, -0.44957280f, 0.12950730f, -0.30156267f, -0.06128165f, 
    -0.02751255f, -0.00454548f, -0.12251966f, 0.01905651f, 0.02642165f, 0.20163122f, -0.35050121f, 0.04893000f, 
    -0.22078125f, 0.08634935f, 0.00528896f, -0.18752731f, 0.25522038f, 0.15938653f, 0.12569711f, -0.20328513f, 
    0.12893960f, 0.02437777f, -0.10844012f, 0.08514900f, -0.22636370f, -0.22661564f, -0.08224995f, 0.21200916f, 
    0.12755208f, -0.09895337f, -0.07324154f, 0.28580984f, -0.19201095f, 0.10746011f, -0.07303860f, 0.01660768f, 
    -0.19522151f, 0.16731626f, 0.11880945f, 0.08152786f, 0.09232782f, -0.21247326f, 0.01024682f, -0.03238093f, 
    0.04942146f, -0.03372901f, -0.06393665f, 0.27267012f, 0.14265777f, -0.18914922f, -0.29665884f, 0.05129037f, 
    -0.00589916f, 0.06255306f, 0.00018008f, 0.08838791f, 0.10979511f, -0.49970040f, -0.15271953f, -0.58250457f, 
    0.14326343f, 0.17188983f, -0.45925894f, -0.52972710f, 0.02761411f, 0.09234796f, 0.04016825f, 0.13239247f, 
    0.26697895f, 0.04695123f, -0.13182081f, 0.21918279f, -0.03949978f, 0.07712455f, 0.25047424f, -0.39803752f, 
    0.02109917f, -0.03460802f, 0.10634957f, 0.03389512f, 0.11599735f, -0.08317488f, -0.08904509f, 0.00587974f, 
    -0.23563837f, -0.26415053f, -0.36314946f, 0.53604877f, 0.05343315f, -0.01943675f, -0.06603058f, 0.00003732f, 
    0.08738022f, 0.01040289f, -0.05359420f, 0.36063078f, -0.50628799f, -0.46664235f, 0.37126568f, 0.15238789f, 
    -0.05205744f, -0.03245187f, -0.09841663f, 0.01670574f, -0.06003570f, -0.24146807f, 0.01622338f, -0.09565089f, 
    0.06071967f, -0.20085113f, 0.03908274f, 0.11772307f, 0.00787077f, -0.03787358f, -0.12484748f, -0.05514590f, 
    0.12116308f, -0.05425106f, 0.33254036f, -0.09686127f, 0.36569077f, 0.06717922f, 0.04464229f, 0.17329562f, 
    0.04654131f, -0.06688555f, 0.03088413f, -0.08411134f, 0.05947832f, -0.11419317f, -0.02124623f, -0.08080572f, 
    0.25420770f, -0.09615397f, 0.02987175f, -0.17152682f, 0.06801933f, 0.14519981f, 0.01851449f, 0.16097042f, 
    -0.04699986f, -0.00248259f, 0.08141705f, 0.04791034f, -0.42886677f, 0.08349252f, -0.12999190f, -0.16237105f, 
    0.03757599f, 0.07940582f, 0.03863539f, -0.00992863f, 0.21851873f, -0.14142515f, 0.04742044f, 0.02477059f, 
    -0.40669301f, -0.18597877f, -0.18527514f, -0.03130269f, -0.01855607f, -0.17808688f, 0.10404751f, 0.33880410f, 
    0.04018810f, -0.12771322f, -0.15043356f, -0.02141466f, -0.29657042f, -0.37631214f, 0.08378984f, 0.16807479f, 
    -0.00147809f, 0.00269154f, 0.03956753f, 0.02730350f, -0.06619063f, 0.01899051f, 0.09783289f, 0.49175295f, 
    -0.31827101f, -0.16216998f, 0.00026690f, -0.19327381f, -0.04893787f, 0.07882696f, -0.14778514f, -0.03033879f, 
    0.15855323f, 0.12579164f, 0.11824679f, 0.10510048f, 0.14909247f, 0.11459725f, 0.23569937f, -0.76798868f, 
    -0.10932356f, -0.00523490f, -0.00026043f, -0.09641664f, -0.22246313f, -0.27850643f, 0.06624584f, -0.07958066f, 
    -0.04276818f, 0.37844151f, 0.17394610f, -0.26396605f, -0.00434642f, -0.04514804f, 0.02255644f, 0.06127538f, 
    0.08968136f, 0.00105018f, -0.01208152f, 0.19801782f, -0.18882333f, -0.09273821f, -0.37505129f, -0.51651764f, 
    -0.05483494f, 0.02318835f, 0.01776830f, -0.09090067f, -0.00491129f, -0.22761913f, -0.09054775f, -0.17354332f, 
    -0.10679807f, -0.08628889f, -0.14359045f, -0.12278709f, -0.03058855f, 0.04063114f, -0.10417863f, -0.00212584f, 
    0.19326326f, 0.15939364f, 0.02588155f, 0.12922007f, -0.81655771f, 0.74785209f, 0.13483368f, 0.28864747f, 
    -0.00752756f, -0.14413987f, 0.18154868f, 0.24548522f, 0.08278177f, 0.10872076f, -0.18642376f, -0.12969774f, 
    0.33847341f, 0.07651066f, 0.12287985f, 0.06985458f, 0.13789107f, 0.19493325f, -0.04183012f, -0.42599121f, 
    0.07717226f, 0.03886205f, -0.07160002f, -0.03984336f, 0.08898364f, 0.09276126f, 0.04295721f, -0.33671933f, 
    -0.02653005f, 0.02104857f, -0.01280681f, 0.09809661f, -0.09451099f, -0.02614207f, -0.12937573f, -0.09659028f, 
    0.09181482f, -0.00640495f, 0.08863582f, 0.11442353f, 0.05252071f, -0.02973561f, -0.00331794f, -0.10627379f, 
    -0.10743348f, -0.11240859f, -0.05749026f, -0.09229071f, 0.19782144f, -0.39298904f, -0.15681595f, 0.12375081f, 
    0.20878305f, 0.01225785f, -0.06104720f, 0.11143532f, 0.10938112f, -0.01552336f, -0.04880556f, 0.29265451f, 
    -0.13472667f, 0.01590889f, -0.11411344f, 0.00969938f, 0.04444524f, -0.08364715f, 0.00393067f, 0.01152544f, 
    0.18515904f, 0.02869529f, 0.12737407f, 0.15712833f, -0.48471826f, -0.23732977f, -0.02607569f, -0.05151566f, 
    -0.09056840f, -0.09579966f, -0.08885671f, 0.05685438f, 0.14640515f, 0.00683733f, -0.06257864f, -0.14985649f, 
    0.21369687f, -0.08576185f, 0.02731767f, 0.11754579f, 0.27036053f, 0.13985896f, -0.05301864f, 0.18721417f, 
    -0.00805335f, 0.06465115f, 0.11039347f, 0.12888253f, 0.02571935f, -0.23073801f, -0.00874818f, -0.03939315f, 
    -0.03912313f, -0.06871557f, 0.18784693f, -0.25545901f, 0.04637294f, 0.22906348f, 0.14843753f, -0.03371209f, 
    -0.49829063f, -0.39478293f, -0.28559718f, 0.48206407f, 0.15449664f, 0.34121844f, -0.00940439f, 0.05650475f, 
    -0.00658809f, -0.05591713f, -0.01671608f, 0.06139015f, 0.11208832f, -0.08828682f, -0.24385174f, -0.10542945f, 
    0.04054150f, 0.05070847f, 0.08608883f, -0.05151593f, 0.01003296f, -0.00924549f, -0.00275474f, 0.01078099f, 
    -0.58312285f, -0.48355484f, -0.47196031f, -0.32008493f, -0.18398486f, -0.06924288f, -0.18958616f, -0.21075647f, 
    0.00982211f, -0.06799370f, -0.00306135f, 0.08099817f, -0.00312503f, -0.04094708f, 0.29739344f, -0.12251152f, 
    -0.09070595f, 0.07432843f, -0.05952810f, 0.05880844f, 0.06826095f, -0.01441069f, 0.20172516f, 0.15869033f, 
    -1.11434507f, -0.63129401f, -0.05978863f, -0.33932319f, -0.02213538f, -0.21719074f, -0.30987972f, -0.39826754f, 
    -0.08636128f, 0.04312259f, -0.01957695f, 0.05565946f, 0.15965733f, -0.10525003f, -0.04909994f, 0.09866749f, 
    0.05245296f, 0.17868948f, 0.14483277f, -0.29981419f, 0.04678923f, -0.07216246f, 0.17572807f, -0.00310483f, 
    -0.00406060f, 0.07062968f, -0.04945033f, -0.19857320f, 0.00968683f, -0.10159431f, -0.10885637f, 0.17571548f, 
    0.02999837f, -0.13002653f, 0.34625930f, -0.22485276f, 0.43421414f, 0.25695202f, -0.15188916f, -0.09975284f, 
    -0.05758676f, -0.03031444f, 0.06584825f, 0.07570381f, 0.07558063f, 0.17010531f, 0.40226933f, 0.20114142f, 
    0.00128867f, -0.02683110f, 0.23547979f, -0.03486497f, 0.01561289f, -0.02865897f, 0.07285940f, 0.07696434f, 
    0.05213005f, -0.06709366f, -0.07708269f, -0.17088155f, 0.06453431f, -0.23428027f, 0.19279581f, 0.05266518f, 
    0.24695694f, 0.25643095f, 0.01501747f, -0.01915311f, 0.03012762f, 0.13448858f, 0.19471437f, -0.36661914f, 
    0.15965582f, 0.16422512f, 0.08520646f, -0.42575419f, 0.08591075f, -0.04485278f, 0.01223178f, -0.04304970f, 
    -0.03550945f, -0.01470582f, -0.14329234f, -0.07226092f, 0.11270197f, -0.04460011f, -0.05172716f, 0.07379814f, 
    0.04490688f, -0.04493274f, -0.10550470f, 0.08894216f, 0.05354455f, 0.23353994f, 0.17880923f, 0.07879665f, 
    -0.03562641f, 0.11874662f, -0.01827127f, -0.00014242f, -0.02634209f, 0.00326661f, -0.15437081f, 0.14839791f, 
    0.08703271f, 0.00422856f, -0.00041464f, 0.00558546f, -0.38987371f, -0.16200611f, -0.08099838f, 0.22979526f, 
    -0.08264562f, 0.19467874f, -0.09654020f, -0.20689014f, 0.02915667f, 0.00313835f, 0.00179036f, 0.04322086f, 
    -0.26699683f, -0.88081020f, -0.57959902f, 0.15215376f, 0.08639341f, 0.25945067f, 0.23541632f, -0.18847260f, 
    0.09455993f, -0.09186167f, -0.06359374f, 0.12456497f, -0.07098048f, 0.08019836f, 0.39073282f, 0.13675176f, 
    -0.02977928f, 0.03582521f, -0.03152898f, 0.02594623f, -0.24517651f, 0.12600909f, 0.15114784f, 0.07300289f, 
    0.15066837f, -0.16838339f, 0.03790440f, 0.29610360f, 0.04410225f, 0.01366702f, 0.11349298f, 0.18214810f, 
    0.11620255f, -0.08968473f, 0.03706925f, 0.06202789f, -0.27290338f, 0.14930093f, 0.50463355f, 0.36979449f, 
    -0.20007777f, -0.21900064f, 0.07231712f, 0.12476636f, -0.11822853f, 0.05430362f, 0.16672951f, 0.05021233f, 
    -0.30432597f, 0.36616895f, 0.07341529f, 0.18090290f, -0.00683212f, -0.23906551f, 0.03310711f, 0.12630795f, 
    0.00802466f, -0.00398645f, -0.00247560f, -0.12376410f, -0.24849044f, 0.10084258f, -0.08605190f, 0.11236513f, 
    -0.12060761f, -0.09428704f, -0.22119008f, -0.17594689f, 0.03940894f, -0.18565100f, 0.01252497f, -0.04134302f, 
    -0.59062266f, -0.73202717f, -0.98246038f, 0.06769535f, -0.13614886f, -0.14435142f, 0.08919925f, -0.28667852f, 
    -0.04202363f, 0.09384064f, -0.13737254f, -0.03367661f, -0.52006376f, 0.33673307f, 0.48602718f, -0.10058422f, 
    -0.03798124f, -0.05770573f, 0.07118034f, -0.21035476f, -0.07886507f, 0.31128162f, 0.05686863f, 0.04692567f, 
    -0.01712003f, 0.19415627f, -0.25768033f, -0.08908413f, 0.03892282f, -0.12003798f, 0.03893940f, 0.09138796f, 
    0.04698631f, 0.14284042f, -0.05540422f, -0.08225843f, -0.56550145f, -0.08485202f, 0.73218495f, -0.12257776f, 
    -0.21756527f, 0.17538175f, -0.03930091f, -0.17329694f, 0.04753102f, -0.02738408f, 0.16466938f, -0.03963047f, 
    -0.78762293f, -0.80704963f, -0.59199971f, -0.33436689f, -0.12285629f, -0.16645662f, -0.31834999f, -0.35398513f, 
    -0.06813688f, -0.13476449f, 0.04750561f, 0.03959305f, 0.26722434f, 0.34635240f, -0.26089114f, -0.23384245f, 
    -0.17113198f, -0.00309977f, -0.21925910f, 0.27044806f, 0.13491753f, -0.00511349f, -0.01275028f, -0.14868689f, 
    -0.78124774f, -0.89528936f, -0.27171054f, -0.15201198f, 0.02401237f, 0.11532907f, 0.07378442f, -0.39058721f, 
    0.05495483f, 0.02060678f, 0.16093177f, 0.14976236f, 0.05967703f, 0.30419895f, 0.12534569f, -0.18891349f, 
    -0.10334434f, -0.02551247f, 0.04598733f, 0.05931872f, -0.01584727f, 0.12260259f, 0.01226495f, 0.08884107f, 
    0.27038142f, -0.12146629f, -0.17455477f, -0.03945637f, -0.15503208f, 0.15963988f, 0.06559508f, 0.01863467f, 
    -0.04946637f, -0.03613682f, -0.14258774f, -0.08400074f, -0.55783963f, 0.14133196f, 0.48503661f, 0.14190455f, 
    -0.08682340f, -0.06926349f, -0.01819078f, -0.02047769f, -0.14302857f, 0.18733795f, 0.01396139f, 0.05203290f, 
    -0.55666381f, -0.34338313f, -0.44199333f, -0.14681619f, -0.44080493f, -0.16132143f, 0.01693333f, -0.13124840f, 
    0.00924721f, -0.01665156f, 0.04407000f, -0.03429039f, -0.22700053f, 0.13817370f, -0.03473244f, 0.01347666f, 
    -0.02221427f, 0.15157428f, -0.22292939f, -0.09091301f, -0.04808173f, -0.06091870f, -0.09779285f, 0.08014026f, 
    0.17276034f, -0.30156970f, 0.05982311f, -0.30939087f, 0.05067745f, -0.12014335f, -0.08573241f, -0.03784404f, 
    0.05824702f, 0.05152330f, 0.04721019f, -0.09201729f, 0.13100106f, -0.08119597f, 0.08137845f, -0.14950761f, 
    0.07172828f, 0.04577145f, -0.03412982f, -0.04865340f, 0.09001309f, 0.02196414f, 0.06680644f, -0.03997130f, 
    -0.88753635f, 0.31054935f, -0.13890252f, 0.49388275f, -0.11111719f, -0.04750014f, 0.05628594f, -0.05938154f, 
    0.01209723f, -0.04991912f, 0.08896465f, -0.03612797f, 0.23177180f, 0.22047043f, -0.60863310f, 0.18485686f, 
    -0.05115175f, 0.08314008f, -0.46766475f, 0.08110793f, 0.10734701f, 0.03308406f, 0.00735203f, 0.03796473f, 
    0.42933285f, -0.49552965f, -0.29944956f, -0.17439288f, 0.01212776f, -0.02410952f, -0.05381289f, 0.17243072f, 
    0.06192610f, 0.05943803f, 0.02249225f, -0.03890577f, 0.11131398f, 0.19403437f, 0.00182677f, -0.09117084f, 
    0.01210691f, 0.03081995f, -0.17934194f, -0.05581357f, 0.01537428f, 0.09776519f, 0.00531765f, 0.04808907f, 
    0.22337794f, 0.10734241f, -0.04876104f, -0.03731681f, 0.03812110f, -0.08076271f, 0.08056169f, -0.06619824f, 
    0.01749119f, 0.07581822f, -0.35787162f, -0.20395665f, -0.00294381f, 0.05257040f, 0.00585110f, 0.21326710f, 
    -0.07380780f, 0.04508715f, 0.01757291f, -0.07280747f, -0.06914680f, -0.03954238f, 0.01711615f, -0.14117695f, 
    0.04630635f, 0.15552236f, 0.14862406f, 0.03265362f, 0.00465021f, -0.02373335f, 0.06552404f, -0.04026084f, 
    -0.05986242f, -0.36909664f, -0.13184759f, -0.14857237f, 0.13436750f, -0.49230605f, 0.58671057f, -0.50448543f, 
    -0.18354268f, -0.01365289f, -0.20296983f, -0.06307710f, -0.04183081f, -0.13403673f, 0.08951899f, 0.05920347f, 
    -0.08386812f, 0.10290919f, -0.16651332f, 0.13514021f, 0.03865305f, 0.07766915f, 0.00537195f, -0.01703231f, 
    -0.01317660f, 0.06194953f, -0.04304159f, -0.15293670f, 0.50586426f, -0.18426429f, 0.14070942f, -0.48030654f, 
    -0.02617883f, 0.05581181f, -0.00903007f, 0.02722061f, -0.01662492f, 0.18475860f, -0.10660992f, -0.23638675f, 
    0.18307234f, -0.02679426f, 0.03127661f, -0.08916418f, 0.03462721f, -0.00608240f, -0.10236137f, -0.04977314f, 
    -0.09179214f, -0.29864287f, -0.10311311f, -0.08852864f, -0.64315146f, -0.19388129f, -0.47556430f, -0.15957430f, 
    -0.03276358f, -0.11606829f, 0.12806489f, 0.07869259f, -0.00363808f, -0.02676344f, -0.01613439f, 0.03190583f, 
    -0.95178491f, 0.12553471f, 0.26967323f, -0.19169550f, -0.06730737f, -0.06542908f, -0.13803436f, 0.04197725f, 
    0.06473072f, -0.01624307f, 0.02504545f, -0.02946027f, 0.39289454f, -0.16509521f, 0.12425290f, -0.14086679f, 
    -0.00000137f, -0.13479191f, -0.22993225f, 0.13629662f, 0.22635555f, 0.15762626f, 0.07407165f, -0.14396816f, 
    0.07154062f, -0.04528211f, -0.13693810f, -0.13691294f, 0.07778406f, 0.01994429f, 0.03361839f, -0.18888400f, 
    0.15140156f, 0.06270050f, -0.06744464f, 0.02849268f, 0.49570999f, -0.36935255f, 0.06933595f, -0.88553828f, 
    0.06531625f, 0.23785719f, -0.03225735f, 0.03869290f, -0.03578255f, -0.10986950f, -0.13798468f, -0.05838456f, 
    -0.13095148f, -0.06394108f, 0.00592839f, -0.02533772f, -0.14132319f, 0.02245714f, 0.13883203f, 0.00988641f, 
    -0.08030488f, -0.00453472f, -0.03965313f, 0.08391889f, -0.38815808f, -0.05313440f, 0.33289438f, 0.23065729f, 
    0.15293179f, 0.25003099f, 0.12513256f, 0.18226737f, -0.16912381f, -0.07093544f, 0.10258853f, 0.01421275f, 
    -0.22769387f, -0.22717872f, 0.75384706f, 0.21099396f, -0.08369327f, -0.09004247f, -0.01722590f, 0.12518616f, 
    -0.07249983f, -0.10135685f, -0.11812371f, -0.03598769f, 0.18352361f, -0.76327789f, -0.74037284f, -0.49113348f, 
    0.08259733f, -0.08469037f, -0.14224316f, 0.10694052f, 0.19100742f, 0.10710104f, 0.01402107f, 0.04688251f, 
    0.01113269f, -0.06383187f, -0.09950629f, 0.03308112f, 0.06546358f, 0.06707443f, 0.10864430f, -0.05478226f, 
    -0.10419788f, -0.02979096f, -0.21516000f, -0.03696372f, 0.05871989f, 0.50346994f, -0.34796113f, 0.68728447f, 
    -0.22931711f, -0.01065150f, 0.18577932f, -0.16549456f, -0.11210779f, -0.14308512f, -0.08947667f, -0.00575761f, 
    -0.91350955f, -0.69938987f, 0.24886239f, 0.69032627f, -0.00535652f, -0.00616156f, 0.08443398f, 0.01699734f, 
    0.05185582f, 0.08522128f, -0.03466978f, 0.07508820f, -0.36158720f, -0.21088402f, -0.09895166f, -0.15646610f, 
    0.06253845f, -0.09514182f, -0.04523931f, 0.12431195f, -0.14567617f, 0.05875071f, -0.00097245f, 0.02066283f, 
    -0.43791807f, 0.11856013f, -0.00073879f, 0.20250791f, 0.00281123f, 0.01216486f, 0.14249989f, 0.12456129f, 
    0.03307451f, -0.14625382f, 0.17700477f, -0.14391090f, 0.39493522f, -0.04666512f, 0.06610714f, 0.14718696f, 
    -0.24802914f, 0.07833797f, 0.01431722f, -0.23647080f, -0.04251504f, 0.05296487f, -0.01829527f, -0.29334572f, 
    -0.14055072f, 0.11029105f, 0.07312287f, 0.00062415f, -0.03844485f, -0.04480785f, 0.11878044f, -0.01743257f, 
    0.03002334f, -0.01813821f, 0.03895770f, -0.02822700f, 0.74827331f, -0.65929109f, -0.63669872f, -0.50995123f, 
    -0.00802074f, 0.02108593f, -0.23231272f, -0.02950853f, 0.01955012f, 0.00029756f, 0.10381182f, -0.01654271f, 
    0.05298105f, -0.23851886f, -0.35919726f, 0.19489430f, 0.01702783f, -0.18827954f, 0.18078208f, 0.17943980f, 
    0.02116664f, 0.05292397f, -0.05725061f, -0.03467691f, 0.13590410f, 0.04122584f, -0.01933690f, -0.11562641f, 
    0.04039964f, 0.00834778f, -0.03846139f, 0.00647966f, 0.04899605f, 0.03496890f, 0.06619001f, 0.03049066f, 
    0.39395064f, 0.22365567f, 0.11884654f, -0.31575146f, -0.06686875f, 0.02479804f, -0.03253726f, -0.18741514f, 
    0.13324256f, 0.02364379f, -0.03961415f, 0.00817062f, 0.12676035f, 0.19766325f, 0.05087076f, -0.24700719f, 
    -0.02134280f, -0.23172805f, 0.01779672f, -0.00420252f, -0.11263744f, -0.01981152f, -0.04412593f, 0.04955149f, 
    0.05874232f, 0.13021524f, 0.15553476f, 0.38380605f, 0.09052735f, -0.24628727f, 0.05429845f, -0.12308364f, 
    0.10085321f, 0.02596379f, 0.13422836f, 0.14069794f, 0.16998212f, -0.02272520f, -0.41033298f, 0.01310963f, 
    -0.12262437f, -0.08477473f, 0.17821790f, 0.19020590f, 0.11010032f, -0.13791011f, -0.05182550f, -0.09822155f, 
    -0.14889786f, -0.98404551f, -0.84073943f, -0.26132759f, -0.19156052f, 0.06558570f, 0.19577241f, 0.08021813f, 
    -0.04070615f, -0.00960043f, 0.01661825f, 0.02802006f, -0.42409411f, -0.05165517f, 0.26622453f, -0.16000353f, 
    -0.01743886f, -0.04018000f, -0.11970350f, -0.01704448f, -0.33159357f, -0.11501148f, -0.14643632f, -0.19920604f, 
    0.04009139f, -0.03567340f, -0.04101485f, -0.44779381f, -0.05823764f, -0.02187706f, 0.04860443f, -0.14651124f, 
    -0.01521709f, 0.08506986f, 0.08430185f, 0.08081564f, -0.75961953f, -0.13160208f, 0.03760169f, 0.16704191f, 
    -0.02038925f, 0.02269226f, -0.08337743f, 0.00681690f, -0.02896579f, -0.15832782f, -0.19362310f, -0.31471178f, 
    -0.16089869f, -0.18512373f, 0.19389556f, 0.19694240f, -0.11319765f, 0.00368722f, 0.05266394f, 0.06944662f, 
    0.07584661f, 0.26770648f, -0.06583033f, -0.10800771f, 0.04669192f, 0.08752736f, 0.00545675f, 0.07004094f, 
    0.16908957f, 0.01385058f, 0.07531767f, 0.18157956f, 0.03169496f, 0.10743353f, -0.25309381f, 0.01967346f, 
    -0.58474171f, 0.01066347f, 0.11648314f, 0.13341087f, -0.07002652f, -0.02336185f, 0.01486455f, 0.02744405f, 
    -0.00279020f, 0.00335268f, 0.15714327f, 0.12802970f, 0.39297909f, 0.09360460f, -0.33415961f, -0.58669686f, 
    0.00236662f, -0.18472190f, -0.03011132f, -0.02650456f, 0.20354649f, 0.09901961f, 0.30215859f, 0.00804240f, 
    -0.17929663f, 0.03162852f, 0.04222567f, -0.16968638f, 0.03128182f, 0.03221881f, -0.00868501f, 0.05938864f, 
    0.16533159f, 0.05658600f, -0.00274062f, 0.00189345f, 0.54653418f, -0.47652695f, -0.23148093f, 0.13353205f, 
    0.06458386f, 0.18071005f, -0.01910562f, -0.05018866f, -0.13039893f, -0.10266496f, -0.12050000f, -0.19875920f, 
    -0.20520011f, -0.11302708f, -0.02855559f, 0.32302621f, -0.03579682f, 0.14600512f, -0.28499517f, -0.31207430f, 
    0.05856981f, -0.01538258f, 0.06430361f, 0.06631043f, -0.14574192f, -0.11245113f, 0.11287466f, 0.11658125f, 
    -0.10071789f, 0.13710275f, 0.11705396f, 0.03895763f, -0.16284780f, -0.17561637f, -0.13396606f, -0.28004819f, 
    -0.44361588f, -0.37078574f, -0.12648901f, -0.02083320f, 0.00109166f, 0.20640096f, 0.05461250f, 0.32131082f, 
    -0.11837333f, -0.14168467f, 0.00302240f, -0.22120780f, 0.25948474f, 0.03170540f, -0.18610933f, -0.08348025f, 
    0.02659996f, -0.23729268f, 0.14258096f, -0.03186085f, 0.02790859f, 0.18510953f, 0.08852180f, 0.01994580f, 
    -0.37207556f, -0.19492087f, 0.10317409f, 0.27002263f, -0.06503917f, 0.05010920f, 0.19087979f, 0.01416962f, 
    0.05666472f, 0.06767852f, 0.24692000f, 0.13179347f, -0.27654302f, -0.09929959f, -0.03598527f, 0.09426288f, 
    -0.49045986f, -0.11894240f, 0.00159910f, -0.30853489f, 0.21287878f, 0.00757678f, -0.11985589f, -0.04001168f, 
    0.31173086f, -0.20805424f, -0.55018145f, -0.78621620f, -0.09099776f, -0.38022202f, 0.00733795f, -0.07682262f, 
    0.12043710f, 0.07809667f, 0.09974096f, 0.09387310f, -0.58490998f, -0.40498793f, -0.12597562f, 0.27516922f, 
    0.00013716f, 0.14113328f, 0.05301172f, 0.11287761f, -0.09396494f, 0.12053922f, -0.02957996f, -0.24472217f, 
    -0.28799534f, -0.06474576f, 0.17508535f, 0.04078421f, 0.02165197f, -0.01926185f, -0.06082817f, -0.15332064f, 
    0.18432918f, 0.11954437f, 0.27054262f, 0.24461827f, 0.26318991f, 0.23910932f, 0.00620032f, 0.08826096f, 
    0.14312026f, 0.17421284f, 0.04480740f, 0.22862841f, 0.02531251f, 0.14680684f, 0.11424229f, 0.16096538f, 
    0.62713504f, -0.78506666f, -0.10289492f, -0.25697654f, 0.00874931f, -0.01971473f, -0.02023175f, 0.13272868f, 
    0.11840056f, -0.00413829f, 0.02311849f, 0.05036549f, -0.15463556f, -0.45087773f, -0.23325466f, -0.06110495f, 
    -0.04382818f, -0.08946449f, -0.05414946f, 0.14726305f, -0.15632157f, -0.28515697f, -0.07926638f, -0.17353657f, 
    -0.23612563f, -0.26637971f, -0.28382367f, -0.27005205f, 0.21077330f, 0.04413371f, 0.10505999f, -0.08376349f, 
    0.02497889f, 0.00944214f, 0.04054832f, -0.05129519f, 0.19976543f, 0.15846801f, -0.05537157f, -0.19775678f, 
    0.36688927f, 0.19927622f, 0.00210223f, 0.09280119f, -0.09016851f, 0.12579255f, -0.00384482f, 0.15541619f, 
    -0.13692839f, 0.02815220f, 0.04775189f, 0.10117970f, 0.08024742f, 0.03642791f, -0.11546284f, -0.09052667f, 
    0.04303327f, 0.26062056f, -0.01630084f, 0.17232077f, -0.36708590f, -0.43798265f, -0.60814273f, 0.06844749f, 
    0.08123012f, 0.18598634f, 0.08092639f, 0.11492430f, 0.23651557f, 0.05126263f, 0.00420392f, 0.00660554f, 
    0.02739432f, -0.21105014f, -0.40178654f, -0.00908155f, -0.04063736f, -0.04282248f, 0.07199636f, -0.07040196f, 
    -0.00497798f, -0.12564072f, -0.09807307f, -0.04851412f, -0.15633421f, -0.28874126f, -0.04733783f, -0.20147845f, 
    -0.05455611f, 0.10758884f, 0.05915638f, -0.04818802f, 0.01153878f, 0.18477282f, 0.10551191f, 0.21121779f, 
    0.25076756f, -0.90905172f, 0.10882463f, -0.14673659f, 0.13372539f, 0.29115662f, -0.07354442f, -0.00888366f, 
    -0.10332165f, -0.22052200f, -0.10375000f, -0.14254932f, -0.37675020f, -0.41825446f, -0.65248913f, 0.27877021f, 
    0.10977764f, 0.18653969f, 0.23906770f, -0.07686964f, -0.03200490f, 0.03137853f, -0.03293081f, -0.10085095f, 
    -0.20824853f, -0.01492549f, -0.64122522f, 0.07465513f, -0.02706491f, -0.19782378f, 0.22628786f, 0.09131979f, 
    -0.06007640f, 0.00345623f, -0.04661961f, -0.05723866f, -0.41936144f, 0.31338647f, 0.00930712f, 0.46452239f, 
    -0.12204719f, 0.03235494f, -0.39486116f, 0.04235864f, 0.14455369f, -0.15992895f, 0.07418350f, 0.16212749f, 
    -0.53372514f, -0.07777779f, -0.07441439f, -0.18501824f, -0.28624818f, -0.02908220f, -0.07192297f, 0.38077444f, 
    0.05533640f, -0.01286054f, 0.08605814f, 0.02553691f, -0.04831545f, -0.32311955f, -0.28640270f, -0.01067226f, 
    -0.14161739f, 0.23892692f, 0.05496640f, 0.07888652f, -0.02811542f, -0.13951737f, -0.05363518f, 0.10656523f, 
    -0.17842056f, -0.03914061f, 0.19678773f, 0.28792435f, 0.18752283f, -0.11635508f, 0.10834689f, -0.13907762f, 
    0.02297901f, 0.03089078f, -0.02599492f, -0.26326495f, -0.00286505f, 0.19888918f, -0.02337013f, -0.08482976f, 
    0.02980032f, -0.02771254f, 0.07906546f, 0.08134037f, 0.07104041f, 0.10814465f, 0.16010764f, 0.29098567f, 
    0.10413325f, 0.11617982f, 0.11865492f, 0.01964326f, -0.09973998f, -0.01765776f, -0.14275099f, 0.03798430f, 
    0.08419511f, 0.20858875f, 0.08167873f, -0.07019999f, 0.16695070f, -0.80122131f, 0.06440846f, -0.13714954f, 
    -0.26722509f, 0.00026192f, -0.32250232f, 0.01197080f, 0.16205522f, 0.06105432f, -0.03611962f, 0.05381470f, 
    -0.38862813f, 0.02816978f, -0.26219305f, -0.06826133f, 0.06058688f, -0.19291052f, 0.14160541f, 0.14045598f, 
    0.10608022f, 0.03917857f, 0.03667888f, -0.12145638f, -0.01957926f, 0.20052445f, 0.14359254f, 0.64959443f, 
    0.02377096f, 0.07894344f, -0.09182063f, -0.12854528f, -0.05808845f, -0.04325269f, 0.04573394f, -0.06718143f, 
    0.18189293f, 0.16447492f, 0.25938821f, 0.14946912f, 0.05847734f, -0.11096086f, -0.02804081f, -0.20455074f, 
    0.05037900f, -0.04647561f, -0.09463450f, 0.10924589f, -0.33745447f, 0.09417362f, 0.16247457f, -0.56812131f, 
    0.05287047f, -0.22357850f, 0.11569284f, 0.12478355f, 0.02867436f, 0.04913790f, 0.08594727f, -0.07359412f, 
    0.14784114f, 0.27909708f, -0.56592393f, -0.33773589f, -0.04215699f, -0.12675136f, 0.04363445f, 0.13138095f, 
    -0.05948841f, 0.02803519f, -0.02452338f, -0.08667633f, -0.40831232f, -0.29847693f, 0.21139918f, 0.01382172f, 
    0.06750884f, 0.13865003f, -0.21054909f, -0.03883044f, 0.08469192f, 0.09829877f, 0.11543362f, 0.06835601f, 
    -0.29717571f, 0.38750634f, 0.05919124f, -0.26726028f, -0.40851766f, -0.17749304f, 0.06137966f, -0.32996750f, 
    0.20420524f, 0.02741899f, 0.23565412f, 0.08116784f, 0.08608922f, -0.27359867f, 0.22068615f, -0.16499978f, 
    0.15814348f, -0.26391727f, 0.18184268f, -0.32009384f, 0.12955628f, -0.06376253f, -0.29198444f, 0.05604468f, 
    0.24806352f, 0.08931544f, 0.31598604f, -0.81754464f, 0.06473015f, -0.24548203f, -0.10040463f, -0.02283778f, 
    -0.27488726f, -0.11880644f, 0.01650594f, 0.00749441f, 0.35637876f, -0.14741518f, 0.04411727f, -0.26968971f, 
    0.00277124f, 0.09244918f, 0.06291089f, 0.20726544f, -0.13840172f, 0.06900354f, 0.07069770f, -0.10913180f, 
    -0.15939578f, -0.41964817f, 0.33537424f, 0.19534332f, -0.06974927f, 0.06943791f, -0.01162284f, -0.03504736f, 
    0.09212477f, 0.15879959f, 0.14821967f, -0.10197983f, 0.28500473f, 0.00675259f, -0.01928762f, 0.03893360f, 
    -0.03649817f, -0.08601034f, -0.09803363f, -0.04660547f, -0.03555638f, 0.02237069f, 0.04545887f, 0.07089470f, 
    0.23394690f, -0.10519436f, 0.59237957f, -0.34726399f, 0.23901600f, -0.08186911f, -0.02066668f, -0.15065144f, 
    -0.32493573f, 0.10235399f, -0.10393426f, -0.13849470f, -1.07346046f, 0.09828243f, -0.71725130f, 0.01274895f, 
    0.12224821f, -0.17171259f, -0.12826322f, -0.14424585f, -0.05969622f, -0.32951304f, 0.01967695f, -0.11234898f, 
    0.34956193f, 0.41427377f, -0.53229994f, -0.06343472f, -0.02394409f, -0.20817545f, 0.05441226f, 0.15905552f, 
    -0.04089494f, 0.07416293f, -0.01908690f, -0.05390614f, -0.14256252f, 0.18741415f, 0.65526086f, -0.38168740f, 
    -0.02464657f, -0.25285274f, -0.04609389f, 0.02051982f, -0.13847005f, 0.10946069f, 0.17080320f, 0.06918104f, 
    0.10050451f, -0.20402341f, -0.13955021f, -0.12052205f, -0.02721016f, 0.02614802f, 0.05098385f, 0.17201094f, 
    0.12724257f, 0.18503663f, 0.00927954f, -0.00292784f, -0.15245825f, 0.26556075f, -0.54211998f, 0.51716948f, 
    0.04230194f, -0.21371445f, -0.19268027f, -0.08181806f, 0.18646808f, 0.00237762f, 0.01672829f, -0.27325526f, 
    -0.42009106f, -0.12261061f, -0.10016907f, -0.04592688f, 0.30135104f, 0.03582408f, 0.10637916f, 0.12482615f, 
    0.26421484f, -0.13704807f, 0.03279117f, -0.08888903f, 0.03889920f, 0.15586352f, 0.27220774f, 0.10315847f, 
    -0.03280988f, -0.13915505f, -0.29327026f, -0.15462127f, 0.03743932f, -0.00162236f, 0.00831501f, 0.19506657f, 
    -0.14157619f, -0.04386979f, 0.20537524f, -0.08737779f, -0.02466266f, -0.23821193f, 0.00412318f, 0.02866414f, 
    0.04271724f, -0.03025558f, 0.11872768f, 0.03871434f, 0.13712566f, -0.08166497f, 0.19712517f, -0.05010819f, 
    0.34405765f, -0.15771182f, -0.13885957f, 0.03252792f, 0.09856595f, -0.13496381f, -0.11756174f, 0.13612336f, 
    -0.68946892f, 0.20448910f, -0.22844033f, 0.08656400f, -0.30359408f, 0.25092849f, 0.04691533f, -0.16062786f, 
    0.10261956f, 0.05348496f, -0.14922841f, 0.09352612f, -0.19018626f, 0.10316589f, -0.70938820f, -0.10233080f, 
    -0.33366126f, -0.16766267f, -0.04996236f, -0.18577288f, 0.03161024f, 0.04759704f, 0.00285423f, -0.01467549f, 
    0.06958484f, -0.38395268f, -0.18993007f, 0.06883939f, -0.01065651f, 0.16600688f, 0.17837271f, -0.07004679f, 
    -0.00167640f, 0.03312402f, 0.09648960f, 0.23002478f, 0.31488422f, -0.13879113f, 0.20398796f, -0.15834485f, 
    0.15387866f, -0.08651051f, 0.05318503f, -0.04918344f, -0.14920156f, 0.08482338f, -0.27977374f, -0.10500818f, 
    -0.26517507f, 0.27189749f, -0.03850605f, 0.10720294f, 0.00206014f, -0.09048632f, -0.17080238f, 0.18233436f, 
    -0.10991193f, 0.21739851f, 0.04006261f, 0.08781240f, 0.18374321f, 0.00067881f, -0.04165678f, -0.13028690f, 
    -0.18705893f, -0.09589902f, -0.13045028f, -0.10901690f, 0.13749972f, 0.07946689f, -0.35771716f, -0.06247314f, 
    -0.18121140f, 0.08720844f, 0.04161863f, 0.32867891f, -0.28879920f, 0.23585720f, 0.15468587f, -0.04306387f, 
    -0.06742372f, -0.04769364f, 0.09674691f, 0.17707309f, -0.17172439f, 0.23176457f, -0.06489313f, -0.03087685f, 
    0.00898643f, -0.05172908f, -0.17940035f, 0.20090263f, -0.33497474f, -0.28905281f, -0.22746523f, -0.54354912f, 
    0.33001223f, -0.41005072f, 0.13058393f, 0.31006920f, -0.04246940f, 0.00114526f, 0.12686041f, -0.01161664f, 
    -0.06736872f, 0.17227565f, -0.16874535f, 0.22706319f, -0.20685530f, 0.22140414f, -0.40690753f, 0.46812317f, 
    0.12695411f, -0.25183153f, 0.11918176f, -0.00041474f, -0.18470778f, 0.05825144f, -0.04334417f, 0.01531192f, 
    -0.07221460f, -0.10762510f, 0.07638323f, -0.25837460f, -0.14240398f, -0.13170263f, 0.02039491f, 0.08774436f, 
    0.13274704f, -0.22781961f, 0.12282331f, 0.11600806f, -0.61798668f, 0.47784129f, -0.19115222f, -0.33286336f, 
    0.05770296f, 0.13815397f, -0.07957507f, -0.08223098f, 0.17597714f, -0.11278891f, 0.13996206f, -0.14941233f, 
    -0.41591290f, 0.26714185f, -0.17262347f, -0.10256293f, -0.09314322f, -0.25769410f, 0.07429186f, 0.11501902f, 
    -0.11254302f, -0.09636789f, -0.02437065f, -0.04689745f, -0.06058457f, -0.24151130f, 0.12397864f, 0.07836941f, 
    0.01768842f, 0.02482015f, -0.18916863f, 0.14382182f, -0.04580259f, 0.01560976f, -0.20965604f, -0.22939311f, 
    -0.11701644f, -0.39365044f, 0.16683635f, 0.14096609f, -0.01655284f, 0.11172961f, 0.22705415f, -0.13310468f, 
    0.02455546f, 0.01940494f, 0.12181152f, -0.07635551f, -0.18036968f, 0.01599077f, 0.16397184f, -0.03644026f, 
    0.17744508f, -0.19538394f, -0.08392731f, 0.02850139f, -0.20140472f, -0.12829521f, -0.35396707f, -0.32899705f, 
    0.39293471f, -0.26361039f, 0.02656446f, -0.25108901f, -0.10427970f, -0.38906649f, 0.11882039f, 0.03730177f, 
    0.00792043f, 0.19742733f, -0.05472886f, -0.29290435f, 0.03433218f, 0.18348624f, 0.02521860f, 0.28367156f, 
    -0.05856024f, 0.00769229f, 0.12679279f, -0.07627383f, -0.03165862f, 0.05019813f, -0.06377747f, -0.01668803f, 
    0.04482366f, 0.18414938f, 0.23694406f, 0.26036978f, -0.15451486f, -0.09931342f, 0.00590832f, 0.16799223f, 
    0.06233348f, -0.03448476f, 0.25942600f, 0.06812225f, -0.44002023f, -0.20457028f, -0.06417413f, 0.05472573f, 
    -0.01723970f, 0.06694251f, -0.06305642f, -0.03128269f, -0.00011977f, -0.02688125f, 0.12387487f, -0.02591643f, 
    -0.24834317f, -0.12794513f, -0.66622394f, 0.09679531f, -0.10449598f, 0.06871340f, 0.11915192f, 0.01556836f, 
    0.08353485f, 0.11303348f, 0.03250174f, 0.07688028f, 0.19337879f, -0.18165094f, -0.25993186f, -0.27050564f, 
    0.04470732f, -0.11615580f, -0.11749235f, -0.00171181f, 0.02514598f, -0.02946239f, -0.40753073f, -0.61402935f, 
    -0.29597017f, 0.17185692f, -0.05298740f, 0.01338735f, -0.06668641f, 0.05590088f, -0.19193968f, 0.21979807f, 
    0.20135260f, 0.17392483f, 0.04308105f, 0.14683786f, 0.86802030f, -0.13585289f, 0.60246164f, 0.18826027f, 
    -0.11360665f, 0.14804918f, 0.20538063f, 0.12684181f, 0.04694684f, 0.05720391f, -0.15280114f, -0.01347688f, 
    -0.59298986f, 0.35499927f, -0.39206439f, 0.11606728f, 0.10340992f, -0.19615386f, 0.01219959f, 0.02129202f, 
    -0.19936076f, 0.19834921f, -0.10853554f, 0.06138458f, -0.24406989f, 0.12982965f, -0.28676552f, 0.45062169f, 
    0.08561269f, 0.11382933f, -0.16897295f, 0.12106290f, 0.03271529f, -0.09827456f, -0.10951052f, -0.00445491f, 
    -0.09572799f, 0.11082025f, -0.42831361f, 0.11876647f, 0.08810288f, 0.09641707f, -0.11373439f, 0.02331024f, 
    -0.01299274f, 0.00839245f, -0.00247685f, -0.12069027f, -0.06660417f, 0.65332472f, -0.02928179f, -0.00499740f, 
    -0.08606081f, 0.03946250f, 0.07043388f, 0.17224835f, -0.14147241f, 0.04121597f, -0.46570569f, -0.05551937f, 
    -0.10441780f, 0.01049210f, 0.11153142f, -0.14544812f, -0.20135505f, -0.14901431f, 0.26076186f, 0.18274830f, 
    -0.18615724f, 0.06970476f, 0.15687343f, 0.01696264f, 0.11323160f, 0.16334330f, 0.17999786f, -0.32495767f, 
    0.00314374f, -0.21348275f, 0.03929098f, 0.04760021f, -0.17998105f, 0.02500851f, 0.01505568f, 0.09926014f, 
    -0.33329543f, -0.23051673f, 0.22367859f, -0.07396824f, 0.04186653f, 0.18228853f, -0.01974867f, 0.05253537f, 
    -0.24656652f, 0.00932912f, 0.03498910f, -0.07839458f, -0.46259952f, 0.24555986f, -0.09582112f, 0.08897881f, 
    -0.07977498f, 0.03252898f, 0.03575497f, 0.02740098f, -0.06865520f, 0.11741689f, 0.23921095f, 0.28535381f, 
    0.03137193f, 0.43994528f, -0.03251487f, -0.37586522f, 0.21137434f, -0.17333291f, 0.00210913f, -0.10407609f, 
    0.01133230f, -0.06010019f, 0.04635710f, 0.13017629f, 0.51079345f, 0.07752185f, 0.25614351f, -0.00517660f, 
    0.00123401f, 0.10851226f, -0.11341131f, 0.13105068f, -0.25467569f, -0.03450849f, -0.22414973f, -0.17436405f, 
    0.47530839f, -0.18847291f, 0.20891044f, -0.33684438f, -0.07402197f, -0.07856228f, -0.38504946f, 0.20794366f, 
    -0.13047150f, -0.05347438f, -0.20046929f, -0.15104724f, -0.76054895f, -0.04290485f, -0.21038260f, -0.17286375f, 
    0.21036069f, 0.18087792f, 0.13699558f, -0.35813531f, -0.06251362f, -0.21184562f, 0.18014511f, 0.24538536f, 
    -0.03910197f, -0.44222409f, 0.03377541f, -0.18108524f, 0.05558288f, -0.06201493f, -0.11330350f, -0.26005813f, 
    0.07377516f, -0.05482658f, -0.12230131f, -0.04194974f, 0.38540500f, 0.31830195f, 0.11090065f, 0.13997759f, 
    -0.05249968f, 0.03832012f, 0.05073456f, -0.02868623f, -0.02961718f, -0.01943794f, 0.01636907f, 0.12180042f, 
    0.02022598f, -0.07157589f, -0.26402178f, 0.24836026f, -0.00851967f, 0.42286497f, -0.21688539f, 0.12041884f, 
    0.18062869f, -0.21619293f, -0.01373408f, -0.02555670f, 0.03461535f, -0.15190938f, 0.19397555f, 0.03442401f, 
    0.06194169f, 0.06813354f, 0.00864197f, 0.20386273f, 0.01246596f, 0.10217036f, 0.06016688f, 0.15380053f, 
    -0.39464319f, -0.04724303f, -0.06145633f, -0.01344149f, 0.00021354f, 0.17483294f, -0.23825026f, -0.06581116f, 
    -0.16417083f, -0.05049625f, 0.23228565f, 0.11066656f, -0.37786540f, 0.48675337f, -0.37615898f, 0.49642757f, 
    0.02127196f, -0.10333423f, 0.31481290f, 0.04813549f, -0.03948382f, 0.01184626f, 0.23684196f, 0.18970962f, 
    0.46906188f, -0.11495437f, 0.41210791f, -0.04035249f, -0.02831403f, 0.05429056f, -0.13368115f, 0.06152738f, 
    -0.28273264f, 0.01354830f, 0.00667314f, -0.05929385f, -0.55963916f, -0.34904462f, -0.36236522f, 0.40524510f, 
    0.21370178f, -0.09016836f, 0.18271618f, -0.10715952f, -0.01239335f, 0.31419519f, 0.24232607f, 0.18829225f, 
    -0.09164022f, -0.22025561f, -0.03832053f, 0.28624871f, -0.00180753f, 0.08246318f, 0.06297324f, -0.00732675f, 
    0.08206474f, 0.05255050f, -0.03237916f, -0.05201813f, -0.01756835f, -0.42714098f, 0.05497009f, -0.22649188f, 
    0.03463483f, -0.22881705f, 0.15715373f, 0.10281921f, 0.12820661f, 0.11131305f, 0.18589529f, 0.11111120f, 
    0.19772390f, -0.19252852f, 0.33028233f, 0.06087503f, -0.23929432f, -0.33719829f, 0.23281251f, -0.14998449f, 
    -0.03633783f, 0.12157156f, -0.02830904f, -0.00920518f, -0.22119904f, 0.50071925f, -0.72019863f, -0.01132404f, 
    0.16532543f, 0.01891410f, -0.02732563f, -0.21064658f, 0.02561264f, 0.11632307f, 0.26099968f, 0.11110757f, 
    0.13869721f, 0.22444057f, -0.04516082f, -0.34486309f, -0.12710489f, -0.05800654f, 0.39078733f, -0.17700340f, 
    0.10110840f, -0.06725938f, -0.15670267f, -0.13598774f, 0.40865105f, -0.42850679f, 0.19446452f, 0.35971090f, 
    0.08521764f, -0.05655065f, -0.22172388f, 0.14236896f, -0.05996889f, -0.12594633f, -0.00236952f, -0.26173136f, 
    -0.41831580f, -0.15482554f, 0.17623146f, -0.01451326f, -0.05923291f, 0.02951960f, 0.09831548f, 0.19712465f, 
    -0.28047320f, -0.04084878f, -0.39445660f, -0.28042680f, -0.09905771f, -0.05486615f, -0.03087462f, 0.42251909f, 
    -0.18522705f, 0.13746113f, 0.25356132f, -0.23104477f, -0.14010127f, 0.17977901f, -0.06385691f, -0.02885145f, 
    -0.26370233f, -0.55837595f, -0.50437272f, 0.38093930f, -0.12013901f, -0.13740326f, -0.06484417f, -0.18461020f, 
    0.02648378f, 0.12067427f, 0.11980007f, -0.10616203f, -0.46871164f, -0.05000189f, -0.35686535f, -0.50504011f, 
    0.00998066f, -0.12402293f, -0.19199458f, -0.17942266f, -0.18641731f, -0.05383787f, 0.11078894f, 0.02985644f, 
    -0.29018292f, -0.19555025f, -0.12997806f, 0.13264847f, 0.00013307f, 0.09490333f, -0.07075279f, 0.29946619f, 
    -0.56213510f, -0.00588184f, -0.00118789f, -0.09460057f, 0.19839427f, -0.22329967f, -0.00694720f, 0.17096905f, 
    -0.11017234f, 0.31405184f, 0.18946899f, 0.09157375f, 0.06164918f, 0.10103142f, 0.09768903f, -0.06580070f, 
    -0.34617859f, -0.51098317f, 0.56111425f, 0.27935314f, 0.10776308f, -0.17398158f, 0.04518177f, -0.08362243f, 
    0.05120682f, -0.09554823f, 0.12443267f, 0.06036007f, -0.30878013f, -0.15822425f, 0.20237139f, 0.02740879f, 
    -0.08403964f, -0.12250936f, 0.07683262f, -0.06374224f, 0.06932415f, 0.13770673f, -0.09475587f, -0.07471440f, 
    -0.36204353f, -0.29520258f, -0.01985878f, -0.01497889f, -0.04958972f, -0.02412253f, -0.11208957f, -0.25786921f, 
    0.09497272f, 0.16262640f, -0.04686556f, 0.08412342f, 0.25060612f, -0.62577873f, 0.24501197f, 0.09247153f, 
    0.02871822f, 0.06766265f, -0.02100646f, 0.09846791f, 0.10992881f, 0.01599528f, 0.31596282f, -0.09090710f, 
    0.16556302f, 0.40648028f, 0.44546625f, -0.05821453f, -0.10061552f, 0.21866329f, 0.00919950f, 0.01434938f, 
    -0.39006856f, -0.00890047f, 0.12542756f, -0.00522951f, -0.55671048f, 0.07518075f, -0.57486975f, 0.16338512f, 
    0.05865204f, -0.07512158f, 0.17244816f, -0.25309289f, -0.02838545f, 0.01081842f, -0.17616372f, -0.16550454f, 
    0.30144414f, -0.11861490f, 0.14117870f, -0.49771321f, -0.13454197f, -0.06348990f, -0.04078235f, 0.04646838f, 
    0.06164156f, -0.10736058f, -0.17295836f, -0.16412394f, -0.10652076f, 0.06959905f, -0.01972051f, 0.38125414f, 
    -0.02791100f, 0.04887787f, 0.13017994f, 0.19697450f, 0.05077431f, -0.32358700f, -0.02017323f, -0.29781660f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18885057f, 0.10443746f, 0.07765718f, -0.11828113f, -0.14827918f, 0.14191598f, 0.01997440f, -0.14102483f, 
    0.07867602f, 0.04554730f, 0.07361796f, -0.05256036f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
