#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.23643947f, 0.98463750f, -1.21520770f, -0.99459112f, -0.59865409f, 0.55660057f, 0.42033413f, 0.43567452f, 
    -0.51627839f, -0.80098885f, -0.33329955f, 0.52912301f, -0.48822755f, 0.22893800f, 0.16000855f, -0.02458194f, 
    -0.94835520f, -0.21155156f, -0.34099588f, -0.71318448f, 0.36842525f, 0.23630407f, 0.25175759f, 0.29816911f, 
    0.36171383f, -0.41562650f, -0.65091109f, -0.25976309f, 0.18153943f, 0.55853605f, -0.12059096f, 0.14874907f, 
    -0.11934653f, 0.60901499f, -0.28102046f, 0.33483884f, 0.47090614f, 0.12073528f, -0.56848568f, 0.13957450f, 
    -0.24421816f, -0.08906373f, 0.04543570f, -0.22890319f, 0.10737785f, 0.04166315f, 0.72184360f, 0.33422646f, 
    0.00207518f, 0.60888165f, 0.08643602f, 0.64665616f, -0.56024462f, -0.86777139f, -1.12393022f, 0.65991384f, 
    -0.39771366f, -0.05536832f, 0.45178977f, 0.86856753f, -0.05094071f, -0.02021369f, -0.53223962f, -0.19381687f, 
    0.16585393f, -0.45931926f, 0.25401941f, 0.18977882f, 0.15012361f, -0.36298892f, -0.13497959f, 0.24536209f, 
    0.29672697f, 0.19421828f, 0.07650504f, 0.27766481f, 0.79792494f, 0.51122445f, -0.33740318f, -0.08034011f, 
    -1.03483546f, -0.42096621f, -0.70844513f, 0.10046747f, 0.93752611f, 0.08185500f, 0.27732730f, 0.00318529f, 
    -0.39322901f, 0.27526131f, -0.24011527f, 0.23170492f, 0.04467238f, -0.05594999f, 0.00545233f, -0.15756162f, 
    0.50992274f, 0.20859249f, -0.43006366f, -0.00846364f, -0.85399967f, -0.75163698f, -0.22206846f, -0.88264436f, 
    -0.32415417f, 0.35422978f, -0.64362043f, -1.46717417f, -1.34175515f, -1.03818023f, 0.19632824f, 0.18103507f, 
    0.09707418f, -0.12271253f, -0.22105542f, 0.33871859f, 0.29083920f, 0.50488156f, 0.57283318f, 0.14487971f, 
    -0.18604149f, 0.12861820f, -0.08607545f, -0.15352246f, -0.28292161f, -1.07650542f, -1.13056171f, -1.19596875f, 
    -0.53837854f, -0.51589942f, 0.93178570f, 0.78127712f, 0.50460654f, 0.51638317f, 0.46513230f, 0.15172824f, 
    0.72690159f, -0.05311164f, -0.03899435f, -0.46925712f, -0.20733495f, 0.02244501f, -0.08419508f, -0.09155957f, 
    -0.41856077f, -0.20119917f, 0.03676553f, -0.11307824f, -0.01099593f, 0.09779059f, -0.79766428f, 0.61196107f, 
    1.53598964f, -1.29909813f, -1.15734100f, -0.74527794f, 0.35971847f, 0.68140155f, 0.52341855f, -0.09170184f, 
    -0.21018325f, 0.30277610f, 0.14226294f, -0.06240585f, -0.10292794f, 0.23342851f, -0.16195664f, -0.12879673f, 
    -0.33770779f, -0.06876093f, -0.04754352f, 0.16512860f, -0.00192846f, -0.17789474f, 0.29845482f, -1.26595902f, 
    -0.64431620f, -0.83511740f, 0.42747849f, -0.55501992f, 0.33405662f, -0.57035917f, -0.35682431f, -0.46804678f, 
    0.95715946f, -0.35042182f, 0.01480582f, 0.32258978f, 0.42761701f, -0.25084245f, 0.06077334f, 0.24308287f, 
    0.09109934f, 0.18163040f, 0.19132105f, 0.47191477f, 0.52965826f, -0.14449005f, 0.12837431f, -0.06997698f, 
    -1.41251171f, -0.21530426f, -1.34825420f, -1.84442961f, -0.50351864f, 0.58151001f, -0.27802771f, -0.17891321f, 
    0.42838687f, 0.08625647f, -0.74055338f, -0.89265645f, -0.59602273f, -0.40971279f, -0.33238840f, 0.35324141f, 
    -0.09269606f, -0.26237679f, 0.04532998f, 0.11945873f, -0.00328591f, -0.05755989f, -0.13676699f, -0.04063446f, 
    -0.39285409f, 0.67047769f, 0.92664146f, 0.66895580f, -0.22960478f, -0.15865204f, 0.16325040f, -0.30899510f, 
    -0.11931935f, 0.33834386f, -0.23444566f, -0.34511790f, -0.25002512f, -0.10127774f, 0.27104557f, -0.23590472f, 
    0.07447501f, 0.26243776f, -0.02438123f, -0.14360572f, -0.06312492f, -0.40703079f, -0.21198760f, -0.55980140f, 
    -0.70195132f, -0.47724494f, -1.60332024f, -0.37652335f, 0.21101062f, -0.95087373f, -0.23838590f, 0.35316613f, 
    -0.16754003f, -0.40491053f, 0.32312503f, -0.00937284f, -0.43023643f, -0.71481180f, -0.46229443f, -0.32002613f, 
    -0.25770795f, 0.09859703f, -0.21731408f, -0.30739212f, -0.35774794f, -0.62622285f, -0.19416071f, -0.49918887f, 
    -0.09186339f, -0.18370245f, -0.51657081f, 0.44078732f, 1.64147234f, 0.76467645f, -0.69815570f, -0.42379051f, 
    -0.84809440f, -0.79607296f, -0.26018837f, -0.73388630f, -1.29192472f, 0.44801867f, -0.22488077f, 0.10859094f, 
    -0.15379988f, -0.10696452f, 0.08943643f, -0.00363133f, 0.19914055f, 0.41459832f, -0.54898685f, -0.12739787f, 
    -0.07348378f, -0.11873786f, -0.16732328f, 0.22984344f, 0.92016256f, 0.28816992f, 0.56509751f, 0.66888493f, 
    0.72527522f, -0.10430646f, -0.45790634f, -0.05292461f, 0.38089660f, 0.36379153f, -0.16100278f, 0.12246138f, 
    -0.00615905f, 0.06298232f, 0.34970155f, -0.20476660f, -0.35381874f, 0.09777706f, 0.23776963f, -0.05843196f, 
    -0.10114051f, -0.05753743f, 0.10423668f, -0.14085864f, 0.09198844f, 0.14322138f, 0.66398591f, 0.62060422f, 
    0.05881668f, 0.50111604f, 0.34058923f, -0.03819023f, -0.47313929f, 0.04804439f, 0.25703198f, 0.29576728f, 
    0.27861542f, 0.17736451f, -0.71657717f, -0.61268640f, -0.28676087f, -0.20963381f, -0.08996622f, -0.33555010f, 
    -0.13648799f, 0.33714941f, -0.07012115f, 0.03486184f, 0.25851399f, -0.50872624f, -1.22451222f, -0.33146212f, 
    -0.28364134f, 0.20915419f, -0.46855029f, -0.94163001f, -0.53208095f, -0.68604493f, -0.70333302f, -0.37059796f, 
    0.00546776f, -0.55641550f, -0.11737916f, -0.69148743f, -0.23850261f, -0.40730980f, -0.37491179f, -0.03655419f, 
    -0.40373755f, -0.49396071f, -0.01036968f, -0.42946994f, -0.12880926f, 0.26614729f, 0.73020566f, -1.37331903f, 
    -0.34074345f, -0.77076322f, -0.28513554f, -0.03328443f, 0.01726712f, -0.16520593f, 0.30409414f, 0.93298918f, 
    0.51718378f, 0.28181985f, 0.23322739f, 0.23679328f, 0.34873018f, 0.57354593f, -0.04360889f, -0.39043295f, 
    -0.28552663f, 0.12366112f, 0.11259826f, -0.38020864f, -0.22640915f, 0.22330087f, 0.34026474f, -0.58337599f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35265568f, 0.39720342f, 0.74028164f, 0.69550198f, -0.30401716f, 0.18643726f, 0.49089041f, 0.39497605f, 
    -0.66042614f, 0.35434023f, -0.15842110f, 0.59217286f, -0.07871480f, 0.34021586f, 0.06729642f, 0.34548771f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20174998f, -0.19587129f, -0.53675795f, -0.06449990f, 0.16104873f, 0.08100504f, -0.13563870f, -0.46787256f, 
    -0.24415974f, -0.12284735f, -0.18120490f, 0.04896638f, 0.04947749f, 0.21678972f, 0.08112826f, -0.02667327f, 
    -0.22664139f, -0.04806903f, -0.24285100f, -0.27131751f, -0.10332938f, -0.27537531f, 0.01980225f, -0.09485319f, 
    -0.03066029f, -0.46334127f, -0.07710194f, -0.28495508f, -0.20176786f, -0.08812787f, -0.14929554f, -0.13842916f, 
    -0.11096054f, -0.14756061f, -0.21959241f, -0.09126596f, 0.01285308f, -0.07057152f, 0.03965713f, -0.26799002f, 
    -0.19695045f, -0.08090958f, -0.42944425f, -0.64592463f, -0.08747024f, -0.13909245f, -0.02266384f, 0.01721331f, 
    0.81420636f, 0.43389711f, -0.64090061f, -0.21407621f, 0.02704153f, 0.08182353f, 0.05742564f, 0.18573669f, 
    -0.01303354f, 0.01168419f, -0.02049018f, 0.10928214f, 0.31484500f, -0.09476797f, -0.24628964f, 0.02657800f, 
    0.14703774f, 0.17814298f, 0.12454165f, -0.27963093f, -0.07659025f, 0.09900478f, -0.13016143f, -0.01486084f, 
    -0.19288906f, -1.13829708f, 0.46590558f, -0.21272564f, -0.23565343f, 0.01030864f, -0.10323603f, -0.00806163f, 
    -0.07088828f, -0.37548828f, -0.16161227f, -0.45163336f, 0.34878018f, 0.28056809f, 0.02050390f, -0.21399397f, 
    -0.01297123f, -0.11647853f, -0.12783974f, -0.25217691f, 0.01920031f, 0.02566903f, 0.08487976f, -0.02416158f, 
    0.26429576f, 0.23278572f, -0.01354273f, -0.25311238f, 0.16074239f, 0.53460246f, 0.11130787f, 0.11892481f, 
    0.00871125f, -0.02183546f, 0.02730219f, 0.03679759f, -0.55391443f, -0.15751500f, -0.17183147f, 0.24217151f, 
    0.07088238f, 0.10592489f, -0.08784080f, 0.09620962f, -0.14389119f, 0.07982407f, -0.02386693f, 0.16191491f, 
    0.27809083f, 0.35617164f, 0.07335312f, -0.13043495f, -0.04509019f, 0.35380921f, 0.09460075f, 0.29238230f, 
    -0.28151098f, -0.09407073f, -0.13378739f, 0.15567639f, 0.09239475f, 0.16273880f, -0.17411487f, -0.00050888f, 
    -0.02247033f, -0.07815563f, -0.27736229f, 0.05295653f, 0.04492230f, 0.03204222f, -0.11687961f, -0.10784007f, 
    -0.31798187f, -0.16585872f, -0.02503687f, 0.21955632f, 0.10139249f, 0.09267861f, 0.08988030f, -0.03659805f, 
    -0.03153105f, 0.05170378f, -0.00515692f, -0.11340958f, -0.90247625f, -0.48329893f, -0.10658818f, 0.46574241f, 
    0.06765292f, 0.00677714f, 0.04158190f, 0.10256977f, -0.04214988f, -0.01348328f, -0.00601028f, 0.07088855f, 
    0.54252034f, 0.47692046f, -0.07982145f, -0.51422006f, 0.16167396f, -0.07562321f, 0.12464406f, 0.07778636f, 
    -0.09268790f, -0.23389536f, -0.20922861f, -0.37596148f, 0.21918596f, 0.00561283f, 0.03815915f, 0.02329398f, 
    0.02809972f, 0.06111539f, 0.01313297f, -0.02021555f, 0.18548729f, -0.07486534f, -0.05269861f, 0.15240873f, 
    0.24211302f, -0.22712739f, 0.33395427f, -0.02942945f, -0.28393194f, 0.34859014f, 0.20301265f, 0.20142113f, 
    -0.13712795f, 0.05380241f, -0.08122918f, 0.00694983f, -0.11162043f, 0.09473516f, -0.17757168f, 0.08377504f, 
    0.13719313f, 0.02758708f, -0.00800474f, 0.17281944f, -0.12457259f, 0.13458481f, -0.04844414f, 0.13242109f, 
    -0.22422062f, 0.39947501f, 0.39307505f, -0.89533633f, 0.16359816f, 0.13921215f, -0.00048735f, 0.02849573f, 
    -0.15466174f, 0.14276280f, 0.06613009f, -0.18976079f, 0.08747841f, -0.08970026f, 0.37758884f, -0.27441072f, 
    0.43812221f, 0.14573359f, -0.56955099f, 0.02723546f, 0.09534565f, -0.03687729f, -0.13014048f, 0.03725622f, 
    0.13063975f, 0.19571249f, 0.10375688f, 0.07222933f, -0.13721667f, -0.00460391f, -0.27368701f, 0.00034857f, 
    -0.07270215f, -0.02147875f, 0.03834228f, 0.05841627f, 0.25391427f, -0.24029289f, -0.63793206f, -0.10973898f, 
    -0.04888217f, 0.04028639f, 0.04172183f, -0.20147692f, 0.11429334f, -0.11045082f, -0.12836429f, -0.00921811f, 
    -0.21642192f, -0.35423857f, 0.01162379f, -0.40845540f, 0.03512366f, 0.15130267f, -0.08289492f, 0.07492948f, 
    0.01916666f, 0.30952954f, 0.06859849f, 0.10772169f, -0.39934510f, 0.14774072f, 0.17601804f, 0.17100106f, 
    0.03714642f, 0.01776259f, -0.10726728f, 0.14391503f, -0.11750457f, -0.14609729f, 0.05082957f, 0.03352449f, 
    0.15780586f, 0.68388247f, 0.13698742f, 0.11134752f, 0.06231514f, -0.21401034f, -0.05492795f, -0.40894645f, 
    -0.02425478f, -0.09828782f, -0.05720296f, -0.20411855f, 0.20691955f, 0.16950656f, 0.08112375f, -0.01981444f, 
    0.05322775f, -0.07144804f, -0.11921978f, 0.04669078f, -0.07445046f, 0.03865898f, -0.09140902f, -0.03513190f, 
    0.15272787f, 0.19541042f, 0.02982519f, -0.06730636f, 0.20945238f, -0.25263444f, -0.16026622f, 0.22673957f, 
    0.03872017f, -0.00228762f, -0.12355070f, -0.42559436f, 0.20896973f, -0.59815741f, -0.27712849f, -0.74219751f, 
    -0.36642537f, -0.20702122f, -0.11147568f, -0.06036729f, -0.08022059f, -0.07620589f, -0.05966476f, 0.11267464f, 
    -0.03197923f, 0.22860505f, 0.09364371f, 0.20925857f, -0.12951380f, 0.03313048f, -0.17402968f, -0.04754647f, 
    -0.05006503f, 0.04824564f, 0.06905819f, -0.02925602f, 0.75010920f, 0.20440333f, 0.22195365f, 0.66397762f, 
    0.03904628f, -0.04156657f, 0.00575951f, 0.02800898f, -0.05232960f, 0.02601290f, -0.02147292f, 0.09271701f, 
    -0.29258171f, -0.06562714f, 0.08623358f, -0.32831448f, 0.07638822f, 0.22152236f, -0.10498392f, 0.08599087f, 
    0.07484611f, 0.10234535f, 0.01671853f, -0.01866894f, -0.33057761f, 0.03731842f, -0.11367076f, -0.22204778f, 
    0.00000202f, 0.03805052f, -0.00259730f, 0.07161715f, -0.11256686f, 0.09626365f, 0.01846416f, -0.18161461f, 
    -0.04977637f, -0.08215560f, 0.18808867f, -0.38251656f, 0.04016999f, -0.12412568f, 0.05275441f, -0.19056910f, 
    0.05128084f, -0.19612165f, -0.20220278f, 0.02533834f, -0.03023050f, -0.11580214f, -0.12252921f, 0.03606614f, 
    0.02198813f, 0.16498236f, -0.18789148f, -0.06649009f, -0.02596616f, -0.05480433f, -0.16201378f, -0.13140434f, 
    0.02806364f, 0.28749537f, 0.17724943f, 0.06535267f, 0.21871895f, 0.22349903f, -0.22950499f, 0.14160180f, 
    -0.08688207f, 0.13266051f, -0.22097804f, 0.38597709f, -0.06722655f, -0.34783292f, 0.29400444f, -0.00180149f, 
    0.03592440f, 0.24437912f, -0.44905317f, 0.25903201f, 0.14502110f, -0.02318659f, -0.05601261f, 0.06493343f, 
    -0.91033936f, -0.92397362f, -0.03930029f, -0.71930414f, 0.19590746f, -0.07037196f, -0.20329988f, 0.06615578f, 
    0.06398945f, -0.01914871f, 0.08919934f, -0.08117677f, -0.03592523f, 0.53867626f, 0.45051128f, 0.27550411f, 
    -0.13534884f, -0.03427446f, 0.22802991f, 0.09537870f, 0.03208501f, -0.23493740f, -0.07119493f, 0.12800722f, 
    0.99129885f, 0.43690810f, -0.30874285f, -0.27075651f, -0.05726145f, -0.02882166f, -0.31056461f, 0.06976720f, 
    0.02612150f, -0.03945881f, -0.14445522f, -0.00490151f, 0.08481184f, -0.26105389f, 0.30717170f, 0.33526012f, 
    -0.12550333f, -0.20071131f, -0.25317988f, 0.34311783f, -0.01691307f, -0.05018466f, 0.01832567f, -0.04608473f, 
    -0.92447883f, 0.33115879f, 0.44798139f, 0.78207725f, 0.19043423f, -0.35439119f, 0.12668772f, 0.15096234f, 
    0.03618164f, 0.06016026f, -0.02169834f, 0.04928416f, -0.16252470f, 0.06218689f, 0.08081338f, -0.29216021f, 
    0.04309091f, -0.02352838f, -0.02296320f, -0.04901307f, 0.04141190f, -0.05237525f, -0.05896382f, 0.01875332f, 
    0.14789037f, 0.13933142f, 0.44118500f, 0.40119848f, 0.06327441f, 0.00078424f, 0.10242537f, -0.09861995f, 
    -0.08591212f, -0.01391100f, -0.12850472f, -0.03013041f, -0.59535259f, -0.34410703f, 0.62975538f, -0.61058354f, 
    0.02410986f, -0.34391123f, -0.34408563f, -0.27009636f, 0.04212342f, -0.06316335f, 0.09449280f, 0.04091638f, 
    -0.54023945f, -0.01873000f, 0.13886274f, -0.06590546f, -0.12740701f, -0.06499737f, -0.01469248f, -0.00441339f, 
    -0.05535936f, 0.01749449f, -0.09981645f, -0.12076638f, -0.02887105f, 0.11290376f, 0.17244792f, -0.55932796f, 
    0.02181988f, -0.09379505f, 0.13950488f, 0.13610858f, 0.00108052f, -0.15338448f, 0.05423826f, 0.03695220f, 
    -0.26653332f, -0.31334630f, -0.52999651f, -0.41561669f, 0.09158405f, -0.04826050f, -0.15002213f, -0.07500990f, 
    -0.14937149f, -0.15061995f, 0.01892898f, -0.01348535f, 0.14075868f, 0.20812148f, 0.12895259f, 0.34319356f, 
    -0.01903297f, -0.06071696f, 0.18986180f, -0.20021923f, -0.35040846f, 0.35011768f, 0.17936243f, 0.08981040f, 
    0.18400554f, -0.31166241f, -0.03576348f, 0.56731027f, 0.14805840f, -0.15829311f, -0.07372500f, -0.08878680f, 
    -0.00239496f, -0.07144229f, 0.35616526f, 0.07723485f, -0.16091904f, -0.08842749f, -0.13406457f, -0.32245156f, 
    0.10399574f, -0.10095928f, -0.03178083f, 0.08816034f, 0.29241368f, 0.33195928f, 0.11518899f, -0.03815902f, 
    0.32878995f, -0.42937681f, 0.01446764f, 0.19045885f, -0.02083516f, -0.02973106f, -0.26749241f, -0.19765261f, 
    -0.02532599f, -0.09104827f, -0.20877440f, 0.11949648f, -0.04925281f, -0.10488358f, -0.02740993f, -0.58374417f, 
    -0.00203027f, -0.07599293f, -0.17412731f, -0.15540391f, -0.18054807f, -0.13652571f, -0.43283495f, -0.14163348f, 
    -0.19480672f, -0.21658561f, -0.09288713f, 0.44896087f, 0.06113114f, 0.00846955f, 0.05817593f, -0.15190430f, 
    0.05821643f, 0.17101406f, -0.13782410f, 0.21058203f, -0.03095698f, -0.34876847f, -0.17080244f, 0.17940633f, 
    0.37448618f, 0.10020830f, 0.08599791f, 0.20889507f, -0.20345926f, 0.02991310f, -0.08015037f, 0.14129086f, 
    1.18591404f, 0.26236722f, 0.37666157f, 0.30614674f, -0.21263766f, -0.26199111f, -0.53354651f, -0.22954859f, 
    -0.11224098f, 0.03107464f, 0.03114836f, -0.04754221f, -0.12144726f, -0.40166658f, -0.30301723f, -0.21496150f, 
    -0.03504665f, 0.12189320f, -0.13197759f, -0.49588200f, -0.25607800f, -0.03547095f, -0.16799875f, 0.10856383f, 
    0.75304419f, -0.43893588f, -0.15691671f, 0.30459642f, -0.02914073f, -0.09292992f, 0.11732247f, 0.05646690f, 
    0.10424130f, 0.09229028f, 0.09478030f, 0.09466760f, -0.07101048f, -0.14879677f, 0.82747728f, -0.04881030f, 
    -0.40519887f, 0.09808207f, 0.02407342f, 0.00571530f, 0.20530710f, 0.13011774f, 0.09330168f, -0.03775677f, 
    0.30882919f, -0.35599321f, 0.09547738f, 0.22337884f, 0.00683436f, -0.04717828f, -0.06688152f, -0.19583310f, 
    -0.00184459f, 0.10286859f, 0.19749171f, 0.17146254f, 0.00288048f, -0.34417054f, 0.58261698f, 0.09585164f, 
    -0.30931613f, 0.20926771f, -0.46737161f, 0.01975738f, 0.12958814f, -0.05476720f, 0.06473833f, -0.06359854f, 
    -0.97583961f, -0.39252940f, -0.08321472f, -0.24984057f, 0.10967135f, 0.05901385f, -0.06347946f, -0.37163886f, 
    0.14974856f, 0.16473493f, -0.11323567f, 0.27831385f, -0.05682883f, 0.49338943f, 0.35088181f, -0.31182802f, 
    -0.21409033f, 0.20018618f, -0.24135877f, -0.31831405f, -0.04984810f, 0.24165982f, -0.24099749f, 0.13811420f, 
    -0.03041748f, -0.17301175f, -0.07304212f, 0.12590985f, -0.00386500f, 0.03234388f, 0.06257368f, -0.15126483f, 
    -0.36592376f, 0.05699987f, -0.14503968f, -0.29936662f, 0.45522207f, -0.12744139f, -0.13355292f, -0.05842517f, 
    0.10391565f, 0.00539990f, 0.32783815f, -0.08484672f, -0.14343978f, -0.04927348f, -0.04324057f, -0.11808892f, 
    0.02648412f, -0.00222924f, -0.15130281f, 0.19000886f, -0.03070651f, -0.08519914f, -0.11569407f, -0.07206744f, 
    -0.04159863f, 0.00070544f, -0.01010316f, -0.11795828f, 0.26878694f, 0.07980393f, 0.10333499f, -0.06761982f, 
    0.07194912f, -0.03259083f, -0.08817281f, -0.03078740f, 0.09754307f, -0.12769103f, -0.11980197f, -0.07894045f, 
    -0.26364204f, 0.18250829f, -0.44697067f, 0.16566564f, 0.02126060f, -0.33497104f, 0.11498248f, -0.04500086f, 
    -0.07427710f, -0.22172475f, -0.07579684f, -0.04149391f, -0.27443117f, 0.00911093f, -0.33805951f, 0.25537369f, 
    -0.35746619f, -0.13437933f, 0.04627433f, -0.64455479f, 0.03945689f, -0.19365734f, 0.07099564f, -0.16439582f, 
    0.12749070f, 0.08516740f, 0.40067613f, 0.19235915f, 0.12775669f, -0.06874220f, -0.07847960f, 0.03918392f, 
    0.06212936f, -0.00027739f, -0.00608274f, -0.00752581f, 0.50034279f, 0.02686872f, 0.30646574f, 0.07586645f, 
    -0.09139779f, -0.08282286f, -0.02204791f, 0.08341946f, 0.04059137f, -0.11965510f, 0.00463480f, -0.07248573f, 
    -0.46061823f, -0.04498520f, -0.20829341f, -0.22948602f, -0.03700683f, -0.14301533f, -0.24308038f, -0.18478808f, 
    -0.02007706f, -0.40478915f, 0.06388300f, -0.30058533f, 0.01674927f, 0.16344258f, -0.10422733f, -0.24582481f, 
    -0.41174808f, -0.11367692f, 0.24851727f, -0.03280960f, 0.18632790f, 0.04464466f, -0.02641288f, 0.02097196f, 
    -0.44078124f, -0.17799997f, 0.00861859f, 0.16139650f, -0.06638792f, 0.16339208f, -0.37524265f, -0.01131566f, 
    -0.08905629f, 0.07037370f, -0.03700299f, 0.14939164f, 0.39559859f, 0.25286981f, -0.42633408f, 0.38843733f, 
    0.04161582f, -0.08985310f, -0.02296805f, -0.07969766f, 0.17015672f, 0.12480318f, 0.05792894f, 0.27274582f, 
    -0.15928984f, -0.12904277f, -0.19070017f, 0.20003727f, -0.08753271f, -0.13709731f, 0.13948694f, -0.13410465f, 
    0.08045789f, 0.01136540f, 0.19427425f, 0.19879574f, 0.20793605f, 0.71348351f, -0.08234168f, 0.35968766f, 
    0.25163606f, 0.04322055f, 0.22367567f, 0.03345171f, -0.05331920f, -0.15928991f, -0.09109274f, -0.19971733f, 
    0.04355706f, -0.18403004f, -0.00717266f, 0.12261285f, 0.15534335f, 0.03560777f, 0.17320678f, 0.11278680f, 
    -0.00243944f, 0.09490295f, 0.08206024f, 0.03848931f, -0.00250809f, -0.21782398f, -1.20804155f, -0.25634840f, 
    0.11216693f, -0.04273571f, 0.15955265f, -0.01497551f, 0.05659307f, -0.06116676f, -0.12550963f, 0.03431681f, 
    0.01211823f, 0.15588380f, 0.25075516f, 0.27617422f, 0.02151396f, -0.01652962f, 0.08510661f, 0.03926719f, 
    -0.15135740f, -0.01972232f, -0.03330411f, 0.02788779f, -0.13977715f, 0.05749794f, -0.01553321f, 0.05274551f, 
    -0.07106170f, -0.07525292f, -0.06331503f, -0.00645846f, -0.01610884f, -0.10827522f, -0.28021535f, 0.25220370f, 
    -0.06522699f, 0.62716812f, -0.20761409f, -0.41912064f, 0.12713815f, -0.04102707f, -0.15714520f, -0.19850028f, 
    0.18175581f, -0.10340799f, 0.01904921f, -0.00464911f, -0.06676347f, -0.07106752f, 0.09801731f, -0.00080048f, 
    -0.08313616f, 0.01840462f, 0.30337262f, -0.30221203f, 0.14135699f, -0.07502087f, 0.09269149f, 0.12388786f, 
    0.17926034f, -0.29358286f, -0.27160996f, 0.02891318f, -0.10603700f, -0.01919323f, -0.21398056f, 0.13894519f, 
    0.30947071f, -0.05846048f, 0.21346071f, 0.21212108f, -0.43573564f, 0.24308737f, -0.09120674f, 0.35622078f, 
    -0.08425894f, -0.57548118f, 0.26512086f, 0.62139016f, 0.03914420f, 0.13067068f, 0.04136945f, 0.03431785f, 
    -0.19151706f, 0.44902021f, 0.35065633f, -0.58976501f, 0.15625717f, -0.10065487f, 0.20952658f, 0.00675286f, 
    -0.07456524f, 0.02231724f, 0.09458351f, 0.02093956f, -0.77968532f, -0.34467107f, -0.36390662f, -0.49705991f, 
    0.05532719f, -0.06672160f, -0.01330793f, -0.11431397f, 0.10819192f, -0.17053595f, 0.21203205f, -0.09156100f, 
    -0.58580267f, 0.01243367f, -0.45919505f, 0.52887183f, 0.17411111f, -0.16333885f, 0.15045376f, 0.04323908f, 
    0.10986578f, -0.00199196f, -0.30603966f, 0.01706890f, -0.04602885f, -0.17084497f, 0.14908893f, -0.26565543f, 
    0.23254688f, 0.13307965f, -0.02685737f, 0.24162988f, 0.02502317f, 0.16618322f, -0.04670761f, -0.11918483f, 
    -0.35106647f, 0.18659270f, 0.18102720f, -0.52902412f, 0.14508392f, -0.28962788f, -0.13361143f, -0.04792082f, 
    -0.04617768f, -0.12152985f, -0.05461217f, 0.05368675f, -0.09149878f, -0.35435024f, -0.27166954f, 0.08303442f, 
    0.10927007f, 0.14634368f, 0.10511082f, -0.00504315f, 0.16979091f, -0.27737892f, -0.15306121f, -0.40850011f, 
    -0.35129848f, 0.19845089f, 0.27795765f, -0.29599923f, -0.14306179f, -0.07116794f, 0.04668437f, 0.00762086f, 
    0.01987510f, -0.09589606f, -0.30429336f, -0.18339264f, -0.01772200f, 0.40145445f, -0.41752073f, 0.22444928f, 
    0.27728769f, 0.10558091f, 0.04621719f, 0.00398348f, -0.01812792f, 0.08171584f, -0.03987858f, -0.00011805f, 
    -0.23735583f, -0.30534533f, 0.17135032f, 0.07253202f, 0.15498891f, 0.01409958f, 0.00764519f, 0.04772273f, 
    -0.04399635f, -0.17220846f, -0.18161024f, 0.13083352f, -0.58193678f, -0.25311074f, -0.28882018f, 0.02281922f, 
    0.02037939f, -0.16755563f, -0.15382527f, -0.01960260f, 0.00964280f, -0.06701152f, 0.31349933f, -0.12339584f, 
    0.27380738f, 0.36209372f, 0.30915725f, 0.08559993f, 0.07392659f, 0.15118305f, -0.00289045f, 0.24749944f, 
    0.19090737f, 0.02588885f, 0.12393858f, 0.26354861f, -0.12479925f, -0.25596488f, 0.06398726f, 0.03652171f, 
    -0.09575220f, -0.11431105f, 0.03251058f, 0.06426725f, 0.04836761f, -0.01220941f, 0.06450359f, -0.36009222f, 
    -0.61442614f, -0.12812795f, 0.58508778f, -0.66707468f, -0.03136649f, -0.52487385f, -0.01808979f, 0.13916665f, 
    0.05723092f, 0.13493726f, -0.00040012f, -0.10573281f, -0.24324706f, -0.06543113f, 0.17330141f, 0.07311102f, 
    -0.24109402f, -0.28972375f, -0.35198405f, 0.20940840f, -0.13798261f, -0.12503254f, -0.15991478f, -0.07506320f, 
    0.53978562f, 0.08836029f, -0.22778806f, 0.81986940f, 0.17275678f, 0.05387612f, 0.11340868f, 0.14892805f, 
    0.24659546f, -0.15191670f, 0.15602772f, -0.19702964f, 0.66848278f, -0.64946485f, -0.50121820f, 0.11093889f, 
    -0.16270153f, 0.37532061f, 0.36415252f, 0.25757247f, 0.13777938f, 0.21880472f, -0.05142352f, -0.24906284f, 
    -0.78140122f, -1.03525376f, -0.33793315f, 0.15067685f, -0.06771994f, 0.00889186f, -0.09496572f, -0.43048000f, 
    0.00892150f, 0.04499124f, -0.01699237f, -0.11471868f, -0.87539351f, 0.82980889f, 0.81961858f, 0.31855673f, 
    -0.14851680f, -0.16260669f, -0.09927331f, -0.08341824f, -0.29025167f, 0.35262299f, -0.21833605f, 0.01037751f, 
    0.61140263f, -0.09352246f, -0.27279550f, 0.02141778f, 0.01155310f, -0.05084543f, 0.12668610f, -0.12786366f, 
    -0.11049978f, 0.16729178f, 0.26227060f, -0.02170555f, -0.43622699f, -0.37785462f, 0.10744101f, 0.32909754f, 
    0.26418999f, -0.29895949f, 0.09075629f, 0.06825840f, 0.01102005f, -0.02258157f, -0.18842961f, -0.06474941f, 
    -0.33273384f, -1.51167810f, -0.42985886f, 0.40990460f, 0.20264907f, 0.11679818f, -0.13917580f, 0.25176713f, 
    -0.01192925f, 0.01645960f, 0.08184360f, 0.06941401f, 0.20371337f, 0.04269474f, 0.01368119f, -0.15331846f, 
    0.08942909f, 0.15813011f, 0.10805722f, 0.09084553f, -0.08578692f, 0.01380400f, 0.08741563f, 0.05919123f, 
    -0.23338898f, -1.00028288f, 0.06352924f, -0.22697893f, -0.24031599f, 0.18600138f, 0.04316673f, 0.16158471f, 
    -0.09321575f, 0.03115140f, 0.25733691f, 0.18821305f, 0.08950208f, -1.08323777f, -0.35478356f, -0.69188416f, 
    0.11098509f, 0.25152999f, 0.27197635f, -0.45358744f, 0.06381392f, 0.09197480f, -0.01826894f, 0.12306390f, 
    0.01820374f, -0.24629912f, -0.30125961f, 0.17237960f, 0.03445462f, 0.00657748f, 0.07946126f, -0.02830097f, 
    -0.09040711f, -0.20347749f, -0.14521405f, 0.02803438f, -0.01219600f, -0.27829203f, -0.12347339f, -0.06232655f, 
    0.17811029f, 0.05652899f, -0.08803172f, -0.14849046f, 0.01137465f, 0.13016091f, 0.05659974f, 0.01532743f, 
    -1.29205978f, -1.30482268f, -0.71113318f, -0.52381706f, -0.10455389f, -0.35319674f, -0.09437512f, -0.29615957f, 
    -0.17672531f, 0.09849023f, -0.10634505f, -0.13401887f, -0.30330506f, 0.30347165f, 0.06399417f, -0.04918348f, 
    -0.18536903f, 0.01597053f, -0.13745241f, 0.27339473f, -0.08089577f, -0.04829076f, 0.28701928f, 0.21621640f, 
    -0.82722306f, 0.75776237f, -0.26127920f, -0.14916919f, 0.26771161f, -0.28790706f, 0.42765769f, -0.16529863f, 
    -0.06680299f, 0.02294687f, 0.04344097f, 0.14558846f, 0.18175903f, -0.03179034f, -0.03786759f, -0.08446585f, 
    -0.27722833f, -0.23619124f, 0.06046834f, 0.04413007f, -0.02660314f, 0.06746734f, 0.09605612f, 0.03821623f, 
    -0.13806990f, -0.38710585f, -0.02005132f, -0.75432181f, -0.18286869f, 0.03727531f, 0.18708849f, 0.08616117f, 
    0.05039878f, -0.01197568f, -0.12559356f, -0.26473731f, -0.20378399f, -0.30442154f, -0.12408977f, 0.05368950f, 
    -0.14249159f, 0.21595681f, 0.04415336f, -0.00338800f, 0.13288321f, -0.05155612f, 0.18141454f, -0.04287450f, 
    -0.85897112f, -0.91123688f, 0.20209990f, -0.24045493f, 0.21606010f, 0.15746199f, -0.19383188f, 0.11149237f, 
    0.10990427f, -0.09609708f, 0.00611279f, 0.06995076f, 0.93349051f, -1.26828933f, -0.38684931f, -0.41242662f, 
    0.01280408f, -0.20233622f, 0.00789738f, 0.16869055f, 0.26053205f, -0.10620566f, 0.13233149f, -0.05205982f, 
    -0.49655059f, 0.62465787f, -0.48291394f, 0.77191591f, -0.21519794f, 0.12142576f, -0.06034994f, -0.13475287f, 
    -0.06501967f, -0.05164948f, 0.12854013f, 0.20734344f, 0.65617335f, -0.23770984f, -0.10423406f, -0.31333354f, 
    -0.20666029f, -0.22291350f, -0.51301336f, -0.21759593f, 0.02407599f, 0.05514120f, 0.02798349f, 0.02457640f, 
    -0.47690028f, -0.17550409f, -0.72566080f, -0.65256441f, -0.03357947f, 0.14717764f, 0.15092862f, 0.22177023f, 
    -0.00230145f, -0.11683324f, -0.12213051f, -0.03329653f, 0.15709123f, 0.21970685f, 0.01875339f, 0.04116676f, 
    -0.07310114f, 0.00366128f, 0.07440633f, -0.04783255f, 0.01587805f, 0.09419322f, 0.16152447f, 0.08640184f, 
    0.10398047f, -0.41251495f, -0.17526935f, -0.14752415f, -0.02787644f, 0.23287159f, -0.21859708f, 0.26797158f, 
    0.14197531f, -0.01155246f, -0.09335212f, 0.12987140f, -1.10284638f, 0.68897402f, -0.64626575f, 0.16832514f, 
    -0.11959094f, -0.12902299f, -0.19128785f, 0.00011908f, -0.01702768f, 0.06546219f, -0.02427232f, -0.07952273f, 
    0.16352004f, -0.03977469f, 0.01372939f, -0.18550055f, -0.02103381f, -0.13181266f, -0.10711075f, -0.03952322f, 
    0.09063012f, 0.03647577f, 0.01772879f, -0.05555038f, -0.03219846f, 0.08211655f, -0.05325721f, -0.25339574f, 
    0.01440950f, 0.04285374f, -0.03601603f, 0.05195726f, 0.16108203f, 0.03552686f, 0.05257829f, -0.10347813f, 
    -0.40823695f, -0.73730600f, 0.65731359f, 0.63882786f, -0.11990625f, -0.14961523f, -0.37046674f, 0.10638120f, 
    -0.06071030f, -0.06206046f, -0.16074614f, -0.07197224f, 0.72959542f, -0.37862816f, -0.38362378f, -0.46688196f, 
    0.01913566f, 0.07808809f, -0.00846518f, -0.08304689f, 0.10130458f, -0.26073587f, -0.07687137f, 0.04958042f, 
    -0.96969920f, -0.50432658f, 0.15058675f, 0.38517988f, 0.04187462f, 0.18549517f, -0.14410903f, 0.16927177f, 
    0.07590216f, 0.24931589f, 0.20117840f, 0.09433155f, 0.04247082f, -0.13447830f, -0.16776313f, -0.06749240f, 
    -0.04991578f, 0.01480458f, 0.08163479f, 0.02180231f, 0.07613273f, 0.11823442f, 0.14056371f, 0.29596952f, 
    -0.85116678f, -0.50303781f, 0.10312060f, 0.81917673f, 0.15077575f, -0.01184450f, 0.07670412f, 0.01605681f, 
    0.09602337f, 0.22463284f, 0.09725376f, 0.17770554f, -0.16143909f, 0.23449484f, 0.06008744f, -0.23963104f, 
    0.04528475f, -0.28397262f, -0.13830960f, 0.07724811f, -0.16329639f, 0.16722451f, 0.17323688f, 0.10136341f, 
    -0.12805131f, -0.54128879f, -0.66258556f, 0.13835707f, 0.15271091f, -0.00613554f, -0.01188644f, -0.02679170f, 
    -0.13926663f, -0.07462327f, -0.15686452f, 0.01785143f, -0.60412961f, -0.59311962f, -0.54817677f, 0.35561252f, 
    -0.00910284f, 0.13430057f, 0.09996817f, 0.13329558f, 0.16119544f, 0.10895505f, -0.11774039f, 0.00695923f, 
    -0.30359775f, 0.39486897f, -0.13273260f, 0.40003842f, 0.00040734f, 0.07658145f, -0.22235866f, 0.29256669f, 
    -0.00788705f, 0.07719098f, 0.22220697f, 0.23986980f, 0.27697071f, -0.39767039f, -0.41405490f, 0.09499681f, 
    0.19063532f, -0.13357456f, 0.18791112f, -0.07076849f, -0.05692659f, -0.15623812f, 0.01607426f, 0.05372538f, 
    0.65789294f, -0.87285036f, -1.18751800f, 0.40104693f, -0.30837810f, -0.01659144f, 0.24159893f, -0.13418372f, 
    -0.02851286f, -0.04088114f, -0.00169801f, -0.13072035f, -0.99632889f, 0.01663105f, 0.13778526f, -0.13751939f, 
    -0.07337757f, -0.10819465f, -0.27321741f, -0.01732079f, -0.48324761f, -0.33769450f, -0.32591674f, -0.19659922f, 
    0.10873447f, -0.43775597f, -0.56571120f, -0.30347738f, 0.21715629f, -0.11907543f, 0.07682220f, -0.00240551f, 
    0.07447144f, 0.11685442f, -0.24113953f, -0.43083942f, -0.62399143f, 0.24913059f, 0.32790831f, 0.39758146f, 
    0.15593147f, 0.06821276f, -0.02425765f, -0.03677627f, -0.04014943f, -0.01977728f, 0.09982664f, 0.08734332f, 
    -0.11544772f, 0.18021725f, 0.04343113f, -0.41300493f, 0.06212944f, -0.12184686f, 0.02389246f, -0.16097097f, 
    0.03153123f, -0.01955451f, 0.05753439f, 0.15559258f, 0.06120493f, 0.21953961f, 0.16762735f, -0.24032748f, 
    -0.26730853f, -0.23513032f, 0.05179807f, 0.04642705f, -0.16660510f, 0.12734176f, 0.02241724f, -0.05721157f, 
    0.45247388f, -0.29523075f, -0.51794541f, -0.68244773f, -0.09483352f, -0.36623287f, 0.07680338f, -0.16504355f, 
    0.28295434f, 0.18296191f, 0.12947722f, 0.28975782f, 0.07105744f, -0.42443347f, -0.39343676f, -0.41775227f, 
    0.02891121f, 0.33579701f, 0.11710850f, 0.20688471f, 0.19161163f, -0.14358507f, -0.21499455f, -0.35146019f, 
    0.15593573f, 0.17033376f, 0.05521299f, -0.68998420f, 0.00798077f, -0.39182994f, 0.15354757f, -0.28314224f, 
    0.00157703f, -0.00802294f, -0.08147652f, 0.00190300f, -0.01883511f, -0.21469390f, 0.20021549f, -0.19739819f, 
    0.40943140f, -0.24793237f, -0.03169231f, 0.15410097f, -0.03506503f, -0.12044714f, -0.08709476f, -0.02884820f, 
    0.30579260f, -0.03221372f, 0.20334798f, -1.06057954f, -0.30811980f, -0.05515034f, 0.31683058f, -0.32111573f, 
    0.00603665f, 0.04780325f, 0.00211185f, -0.03156391f, 0.15770641f, 0.45707244f, -0.48808348f, 0.08724001f, 
    -0.01521926f, 0.18940607f, 0.15850410f, -0.50701064f, 0.13935412f, -0.12472004f, -0.11548556f, 0.02951833f, 
    -0.77801579f, -0.29444876f, 0.49196386f, -0.13663283f, -0.40278906f, 0.28008673f, -0.03658982f, 0.37334776f, 
    0.09849023f, -0.00371489f, 0.02830760f, -0.07253440f, 0.44388136f, 0.24310146f, 0.52579653f, 0.03956120f, 
    0.12224851f, -0.26025167f, -0.48182786f, 0.01440593f, -0.10442599f, 0.20601743f, 0.05802169f, 0.14087734f, 
    -1.28777957f, 0.77361828f, -0.80551809f, -0.27675056f, -0.00887166f, -0.17294177f, -0.13107164f, -0.01474379f, 
    0.00440808f, -0.21504600f, -0.01313446f, -0.25618991f, 0.23895267f, -0.08159401f, -0.26916003f, -0.06212841f, 
    -0.19940774f, 0.34388989f, 0.01503474f, -0.21094257f, 0.28695637f, -0.32791585f, -0.14319085f, -0.07726356f, 
    -0.14198068f, -0.20809504f, 0.24520622f, -0.12747580f, -0.31250787f, 0.02714896f, 0.02443791f, -0.14655340f, 
    0.05587781f, 0.00557982f, 0.07902965f, 0.03192196f, -0.15160583f, 0.03423417f, -0.44063577f, 0.19971904f, 
    0.03712641f, -0.01525272f, 0.37352821f, -0.02525979f, -0.09317269f, 0.19717765f, 0.07614352f, 0.34122619f, 
    -0.42579561f, 0.05407703f, -0.25885293f, 0.27230841f, -0.03936943f, 0.22569276f, -0.06186837f, -0.04992419f, 
    0.15056339f, 0.07644802f, 0.05334448f, 0.15480611f, -0.30071935f, 0.58864176f, -0.93360674f, 0.06046608f, 
    -0.13751093f, -0.17172612f, 0.50093883f, 0.05676258f, -0.09520179f, 0.02905144f, -0.20989500f, -0.02122351f, 
    0.09807141f, -0.34346741f, -0.24669681f, 0.06199429f, 0.15579824f, 0.17451900f, 0.22811598f, -0.23262385f, 
    -0.01903813f, -0.05492321f, 0.08108569f, 0.00586203f, -0.32736549f, -0.80365670f, 0.01391948f, 0.44299328f, 
    0.04027894f, 0.28767708f, 0.11489822f, -0.19824761f, 0.07468694f, -0.02064867f, -0.15266246f, -0.03046411f, 
    -0.54675591f, -0.16859576f, 0.08861315f, 0.10197304f, -0.05494127f, -0.10775715f, 0.32449120f, 0.16784143f, 
    -0.05393200f, 0.00118797f, 0.20980489f, -0.06292385f, -0.02712803f, 0.22021474f, 0.60212386f, 0.28974473f, 
    -0.01272863f, -0.14383218f, -0.20281808f, -0.33741632f, 0.08996237f, -0.15902048f, 0.22844148f, 0.39177859f, 
    0.33147773f, -0.11354486f, 0.60596049f, 0.08506747f, -0.20584898f, 0.12468924f, 0.53726220f, 0.36766011f, 
    0.19173171f, 0.14140661f, 0.06520333f, 0.26874131f, -0.26376814f, 0.31608543f, 0.33422434f, 0.12137839f, 
    -0.41805041f, -0.07889597f, 0.20822528f, -0.18302178f, 0.06076922f, 0.01185691f, 0.33806458f, 0.22026883f, 
    0.08743279f, 0.40826139f, -0.10646515f, 0.29875645f, -0.00637798f, -0.01879595f, 0.06711249f, -0.40312529f, 
    -0.05090854f, 0.10958253f, -0.04247817f, 0.16992930f, -0.24392620f, 0.37395838f, -0.34263268f, -0.01237616f, 
    -0.11853644f, -0.44863194f, 0.43965283f, -0.30114597f, -0.26709902f, 0.15562621f, 0.13097814f, 0.36877039f, 
    0.08073756f, -0.71464479f, -0.48084921f, 0.03782319f, 0.03803432f, -0.12094717f, -0.04745895f, -0.16608569f, 
    -0.05102289f, -0.09546125f, -0.09159224f, 0.05633129f, 0.01666349f, 0.33034718f, 0.06799895f, -0.20636582f, 
    0.10373575f, -0.25716403f, -0.23541534f, -0.03478624f, -0.14377683f, 0.07561208f, -0.11068907f, -0.25834167f, 
    1.00583148f, -0.48687682f, 0.58602464f, -0.10429268f, -0.38922596f, 0.12806746f, 0.46879217f, 0.17881161f, 
    -0.05628674f, -0.12530765f, 0.07860553f, 0.18551907f, -0.72506249f, 0.31463394f, 0.05669264f, 0.16440687f, 
    0.03143637f, 0.12746184f, 0.03262696f, -0.16239092f, -0.16921313f, 0.19943251f, 0.21054229f, 0.02753438f, 
    0.03548024f, -0.59069288f, -0.38475999f, 0.00719156f, -0.21234481f, -0.09115782f, -0.05015922f, -0.00605216f, 
    0.04850290f, 0.11033051f, -0.10609144f, -0.48212281f, -0.03260889f, 0.17353041f, -0.38040787f, 0.03938888f, 
    -0.26281103f, -0.45938531f, 0.05546413f, -0.15288565f, -0.32031140f, -0.25576860f, -0.59541565f, -0.48444760f, 
    0.25327384f, -0.13559094f, -0.19763815f, -0.04347040f, -0.01639176f, -0.02223342f, 0.23435372f, 0.10417885f, 
    -0.12809724f, -0.12677118f, -0.46897253f, -0.52630275f, 0.10667878f, -0.80052799f, 0.19670841f, 0.12409987f, 
    0.02212702f, 0.21181776f, 0.39389274f, -0.28648755f, 0.04940892f, 0.23695849f, -0.28629223f, -0.06415049f, 
    -0.76838756f, -0.16354842f, -1.19012415f, -0.85881925f, -0.56365138f, -0.24919215f, 0.15198126f, 0.32811400f, 
    -0.09808495f, 0.00963411f, 0.19824609f, -0.04000543f, -0.20299169f, 0.04482452f, -0.27342105f, -0.27612558f, 
    -0.18077074f, -0.14148101f, 0.10561414f, 0.01222136f, -0.00243793f, -0.19306943f, 0.03965527f, 0.06548516f, 
    -0.38572806f, -0.51090193f, -0.16636413f, 0.17245734f, -0.37953857f, 0.20470470f, 0.15576294f, 0.04799167f, 
    0.05622805f, 0.17700289f, 0.27326104f, 0.05386375f, -0.45393798f, 0.39509058f, 0.03463437f, -0.33895722f, 
    0.05442071f, 0.13393655f, 0.09344660f, 0.20773752f, 0.00662001f, -0.07351776f, -0.27414647f, -0.18204547f, 
    -0.50854814f, 0.01899486f, -0.05831440f, -0.21224375f, -0.12928008f, 0.27364159f, -0.46252075f, 0.24728788f, 
    -0.13591801f, -0.16233279f, -0.03181714f, 0.03077579f, -0.12946579f, -0.19530320f, -0.13012131f, 0.25535375f, 
    0.22857112f, 0.41621658f, -0.02615005f, 0.05079091f, -0.10472346f, -0.33584067f, 0.06722034f, -0.98931444f, 
    -0.25575957f, 0.26426533f, 0.40091723f, 0.20018302f, 0.16320425f, 0.08490607f, -0.07011393f, 0.11773894f, 
    -0.47209245f, -0.01275375f, -0.07214089f, -0.27136180f, 0.41642627f, 0.25136989f, 0.36337194f, 0.24430433f, 
    0.15764745f, 0.31770405f, 0.19584650f, 0.20373558f, -0.33656704f, 0.18720411f, 0.19973017f, 0.07582569f, 
    -0.36273211f, -0.24743283f, -0.18151170f, 0.28615701f, -0.45298871f, 0.08488594f, 0.28951696f, -0.45115164f, 
    -0.06053406f, 0.02629425f, -0.12011816f, -0.10532046f, -0.75588793f, 0.03512947f, -0.41080299f, -0.34325296f, 
    0.06948160f, -0.16281763f, -0.33860475f, 0.05576439f, -0.30568770f, -0.05774130f, -0.03796199f, -0.07682539f, 
    0.01196669f, -0.31468683f, 0.40264270f, -1.02804267f, 0.30617508f, 0.23225208f, 0.74511456f, -0.11765447f, 
    -0.00190317f, 0.12964477f, -0.06148064f, 0.04757653f, 0.02125691f, 0.82945573f, -0.33918989f, 0.27870512f, 
    0.06170776f, -0.26255119f, 0.06755327f, 0.13732672f, 0.19948520f, -0.14160484f, -0.10101137f, -0.25154224f, 
    0.01083188f, -0.07047042f, 0.41841137f, -1.01437092f, -0.19918746f, 0.19670789f, 0.32383993f, 0.17831133f, 
    0.09372018f, 0.13719502f, 0.20083702f, 0.07681496f, 0.34371030f, -0.24997443f, 0.33132368f, -0.35766876f, 
    -0.11362542f, 0.07194060f, -0.01571995f, 0.18068266f, -0.05884175f, 0.26833484f, 0.26318151f, 0.12945335f, 
    -0.27519280f, -0.23126788f, 0.01562570f, 0.16207507f, -0.11252518f, -0.06953911f, 0.24049476f, -0.37651062f, 
    -0.10258206f, 0.03788165f, 0.16077010f, 0.09074334f, 0.37870190f, -0.26928949f, 0.82821667f, -0.41291016f, 
    0.06387009f, -0.25930560f, -0.55542016f, 0.39054960f, -0.08827657f, 0.12636502f, 0.03558544f, 0.08612121f, 
    0.65474170f, 0.30688393f, -0.30501583f, -0.07189409f, -0.10000639f, -0.01809708f, -0.02055366f, 0.22005546f, 
    -0.21453701f, -0.22542176f, -0.04726024f, -0.19283374f, -0.00818957f, 0.34174743f, 0.15337916f, -0.35245231f, 
    -0.10156805f, -0.00195112f, -0.06364740f, -0.03814811f, -0.19957937f, 0.19270149f, -0.04761681f, -0.00552677f, 
    0.15135579f, -0.59924155f, -0.37521973f, 0.45422286f, -0.00723575f, -0.57197714f, -0.26638442f, -0.16829498f, 
    0.08745616f, 0.11076412f, 0.04618264f, -0.11632808f, 0.11758495f, -0.63587737f, 0.14918241f, 0.02431727f, 
    0.04027418f, -0.14137655f, -0.04181208f, -0.23677897f, -0.06817309f, 0.15332298f, -0.13510762f, 0.15558684f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.32346052f, 0.13136043f, 0.09595967f, -0.13990536f, -0.17346303f, 0.23419312f, 0.15080866f, -0.25746983f, 
    0.04747670f, 0.02889420f, 0.01393819f, -0.01057845f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
