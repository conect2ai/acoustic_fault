#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.04983079f, -0.58719093f, 0.77672982f, 0.26733086f, 0.49757138f, 0.67431319f, 0.03402603f, -0.42107394f, 
    -0.13393146f, -0.01273245f, -0.19656733f, -0.19927703f, -0.15116793f, 0.49513134f, -0.15083781f, 0.05230317f, 
    0.00358205f, -0.08708105f, 0.07142434f, 0.05078410f, 0.11906884f, -0.08109604f, -0.13941339f, 0.02572892f, 
    0.11710015f, -0.13170555f, -0.20451355f, -0.42456666f, 0.09574164f, -0.32803488f, 0.12139858f, -0.24018565f, 
    0.11267565f, 0.28600657f, 0.39021817f, 0.55760115f, -0.17452042f, -0.20860828f, -0.51886594f, -0.14649817f, 
    0.16468912f, 0.26143265f, 0.23774245f, 0.02666296f, 0.01563195f, -0.38341695f, -0.19028684f, -0.05543128f, 
    -0.04637469f, -0.11234684f, -0.54900360f, 0.29095900f, 0.58356220f, 0.31637505f, -0.05414411f, -0.55064130f, 
    -0.42261076f, 0.31394589f, 0.24658923f, 0.11159009f, 0.09834251f, 0.03102555f, 0.24132900f, 0.05332793f, 
    -0.13589399f, -0.09345157f, 0.12688744f, -0.08396754f, -0.55078340f, -0.45147932f, 0.22027881f, 0.05196866f, 
    0.27122793f, 0.14527781f, -0.03581985f, -0.05942292f, 0.09063891f, -0.10184628f, -1.06174302f, -1.00897574f, 
    0.44292173f, 0.17209738f, 0.11699725f, 0.05425646f, 0.32863083f, -0.08592767f, 0.16823594f, 0.01677759f, 
    0.09089718f, 0.28525132f, 0.22512572f, 0.15324311f, -0.03638519f, -0.31717002f, -0.16284309f, 0.24563468f, 
    -0.17689165f, -0.24714087f, -0.03540968f, 0.11516965f, -0.06940468f, 0.09100617f, -0.02558883f, 0.10493885f, 
    -0.36829910f, 0.26377195f, -0.58596331f, -0.42098063f, -0.58362317f, -0.74940282f, -0.18175480f, 0.24817409f, 
    -0.01791653f, -0.28774321f, -0.07765076f, 0.13234662f, -0.16236685f, 0.09074610f, 0.17112130f, 0.12681451f, 
    -0.04152637f, 0.03990739f, -0.08366615f, -0.14226831f, -0.07790295f, -0.32257670f, -0.30485603f, 0.18911132f, 
    0.08838827f, 0.36903840f, 0.22021301f, -0.49989530f, -0.19354722f, -0.04184611f, 0.56623554f, -0.08445878f, 
    -0.10344352f, -0.19715245f, 0.06844504f, 0.27994302f, -0.12631227f, -0.12727793f, -0.26924360f, -0.04405372f, 
    -0.25301710f, -0.20540117f, -0.25672472f, -0.02000334f, 0.23192184f, -0.36585507f, -0.91543657f, -0.43437591f, 
    0.27268368f, -0.65811157f, -0.45283729f, 0.34789535f, 0.01479456f, -0.00367792f, -0.08479633f, 0.30555826f, 
    0.13089193f, 0.05890787f, -0.03801078f, 0.14950433f, -0.33800614f, 0.07558669f, -0.25905558f, -0.26097456f, 
    -0.09362332f, -0.11551961f, -0.07858767f, 0.34526959f, 0.27496618f, -0.10261285f, -0.06417188f, 1.09800112f, 
    0.12524213f, -0.00990385f, -0.23031108f, -0.38892266f, 0.60071403f, -0.50968820f, -0.14251702f, -0.49249551f, 
    0.15632714f, -0.01386041f, -0.11231046f, 0.07318596f, -0.11801944f, -0.11068164f, -0.09486230f, 0.14358725f, 
    0.22796471f, 0.15535198f, -0.24755268f, 0.13577056f, -0.17084432f, 0.00192078f, 0.21462595f, -0.09157939f, 
    0.72813576f, 0.40951714f, 0.16382651f, 0.07644238f, 0.36398745f, -0.30058578f, -0.55666119f, -0.30019900f, 
    0.57371283f, -0.06670088f, 0.05159646f, 0.00023776f, -0.17747542f, 0.05113422f, 0.08330631f, 0.20347871f, 
    -0.18176787f, 0.03727229f, 0.07554357f, 0.05064763f, 0.15130293f, 0.05690648f, -0.13421406f, 0.30899546f, 
    -0.02097083f, -0.31158516f, -0.16305119f, 0.18598950f, -0.49154410f, -0.07157885f, 0.03046812f, -0.01726703f, 
    -0.35415068f, 0.02644429f, 0.01843980f, -0.30461228f, -0.17981948f, 0.41672987f, -0.39299661f, 0.03779586f, 
    -0.05948634f, 0.13843763f, -0.09794156f, -0.12323997f, -0.01835971f, -0.09761633f, 0.00708518f, 0.32726866f, 
    0.17016220f, 0.37226066f, -0.77139163f, -0.03116412f, -0.14181744f, 0.20205851f, 0.02544643f, 0.44326553f, 
    0.53875685f, 0.05744145f, 0.24752133f, -0.01209267f, 0.22970697f, -0.00272263f, -0.10731785f, 0.22761361f, 
    -0.10030537f, -0.21500459f, -0.17020756f, -0.28924683f, 0.15758006f, -0.46888635f, 0.20474266f, 0.02591866f, 
    0.39636064f, 0.23391365f, -0.03825694f, -0.66451979f, -0.38893366f, -0.43454072f, 0.48193356f, 0.59222376f, 
    0.50973606f, -0.13057078f, 0.23916996f, 0.44003418f, 0.40495566f, 0.41262916f, 0.08757915f, 0.12321740f, 
    0.05215337f, -0.07338253f, -0.16472356f, 0.27229837f, 0.33467361f, 0.25892505f, 0.04137501f, -0.06102619f, 
    0.17679384f, -0.11836240f, -0.05887257f, 0.02784637f, 0.58856779f, 0.05177259f, 0.04046147f, 0.40121883f, 
    0.04098870f, -0.20215419f, -0.24938263f, -0.11809269f, 0.03320101f, 0.33148691f, 0.03367773f, 0.39643857f, 
    -0.29570481f, -0.20901261f, -0.16300434f, 0.09644520f, -0.14961849f, 0.09613077f, -0.07634113f, -0.24223542f, 
    -0.40887398f, -0.08159422f, -0.14164439f, -0.09855603f, -0.25573093f, -0.56590009f, -0.23734538f, -0.57365113f, 
    -0.18481734f, 0.40932697f, -0.20881654f, -0.30193883f, -0.34573692f, -0.19930324f, -0.07723082f, -0.07623146f, 
    -0.29876432f, 0.11483542f, -0.22004741f, -0.00026518f, 0.14022724f, 0.06167259f, -0.09624158f, 0.28039899f, 
    0.25901291f, 0.16131444f, 0.12082770f, 0.18747023f, -0.13927177f, -0.00281107f, -0.74965990f, -0.54659009f, 
    -0.40111595f, -0.10798491f, -0.01319127f, 0.32188314f, 0.07897074f, -0.45165473f, 0.05267071f, 0.05380920f, 
    0.02725667f, -0.18492946f, -0.10332432f, -0.10627752f, -0.15459472f, 0.08812892f, 0.01790750f, 0.04146226f, 
    0.15413602f, -0.19913515f, -0.18969075f, -0.19628546f, -0.29069096f, -0.14513160f, -0.07586503f, 0.18072979f, 
    0.16815339f, 0.19129981f, 0.17691526f, 0.09724253f, 0.10563038f, -0.22756225f, 0.13777314f, 0.06359772f, 
    0.14816765f, -0.08953610f, -0.10855903f, -0.21033189f, 0.05221485f, -0.25304344f, -0.31256336f, 0.11591788f, 
    0.16004515f, 0.13607134f, -0.05258986f, 0.26026496f, 0.11226348f, -0.03820316f, -0.43045810f, -0.35169283f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07807650f, -0.21504518f, 0.18638068f, 0.24109657f, -0.22751772f, 0.13859460f, -0.04856374f, 0.08887497f, 
    0.25584492f, 0.11321829f, -0.26281795f, -0.28032151f, 0.00050809f, -0.20348613f, -0.15587430f, -0.11274295f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.10270660f, 0.36962119f, 0.03247227f, 0.17664571f, 0.13282762f, -0.02252313f, 0.23518641f, -0.04920882f, 
    0.00891281f, -0.04980903f, 0.08344763f, 0.17974824f, -0.35513833f, -0.08016678f, -0.24139084f, 0.08887858f, 
    0.01701074f, 0.09413557f, 0.03745005f, 0.04627691f, -0.06439032f, 0.00781624f, -0.00414184f, -0.05093684f, 
    -0.01665097f, 0.09801320f, -0.02233318f, -0.27216381f, 0.11587697f, 0.04029756f, 0.01785906f, 0.05969150f, 
    -0.04135339f, 0.17880411f, 0.27344817f, 0.07720821f, 0.20773372f, -0.04482387f, -0.08058903f, 0.02779540f, 
    0.14276655f, -0.08300779f, 0.03008644f, 0.19109651f, -0.04689937f, -0.12033551f, 0.02813730f, -0.01183385f, 
    -0.10259187f, -0.49013829f, -0.23952755f, 0.02079173f, 0.07500418f, 0.01738086f, -0.13799310f, -0.40081114f, 
    -0.03190266f, 0.06526770f, 0.11052664f, 0.12102733f, -0.06961913f, 0.19965659f, -0.16597235f, -0.15696746f, 
    0.09478340f, 0.09164361f, 0.22160475f, 0.25378862f, 0.06903718f, 0.23346181f, 0.04219312f, -0.10726959f, 
    -0.13675112f, 0.01853644f, 0.19342883f, -0.06968468f, 0.04798675f, 0.00342089f, 0.17761020f, 0.07009988f, 
    -0.12802665f, 0.24615034f, -0.08353119f, -0.09157483f, 0.35450667f, 0.08841693f, -0.05374643f, 0.21998471f, 
    -0.01120890f, -0.19148257f, -0.10199816f, 0.00101976f, 0.10420533f, 0.02295374f, 0.02817614f, 0.08504072f, 
    0.09551027f, 0.17608991f, 0.10388703f, 0.03178209f, -0.11510198f, -0.00056867f, 0.03703946f, -0.08181395f, 
    -0.03190545f, 0.00421345f, 0.07367777f, 0.01534503f, -0.03127677f, -0.09915739f, 0.27281389f, 0.14491491f, 
    0.02642447f, -0.18467808f, 0.08151742f, 0.07488793f, 0.03934836f, 0.09737249f, 0.16577671f, 0.18325022f, 
    -0.38293585f, -0.05524591f, 0.22760607f, -0.08476949f, -0.11703210f, -0.06658993f, -0.12199809f, 0.09424500f, 
    0.27099666f, 0.33852744f, 0.06659110f, 0.29674357f, -0.32311583f, 0.02321965f, -0.21368143f, -0.18496580f, 
    -0.07878929f, -0.13030466f, -0.05006534f, -0.16590618f, -0.04698492f, -0.08656015f, 0.09985495f, 0.00378928f, 
    0.14353293f, 0.31111476f, -0.26667893f, -0.04952519f, -0.06349213f, -0.05402548f, 0.02454229f, 0.09585353f, 
    -0.03111889f, -0.02361985f, -0.23552841f, -0.07212690f, -0.11433316f, -0.11165118f, -0.28659618f, -0.07794215f, 
    0.02679262f, -0.05542369f, -0.07172056f, -0.20069720f, 0.05546016f, 0.09133612f, 0.07038484f, 0.03442471f, 
    -0.20356740f, -0.02667052f, 0.10604847f, -0.05381868f, 0.00717186f, -0.14760420f, 0.00963255f, -0.21726806f, 
    -0.03217430f, 0.10461970f, -0.04039974f, -0.25389808f, 0.01845471f, 0.28749207f, -0.11956532f, 0.04411507f, 
    -0.05302964f, -0.07567151f, -0.18424989f, -0.02556389f, -0.07796887f, -0.02556130f, 0.06484310f, 0.04898573f, 
    -0.14749271f, 0.08554795f, 0.24907954f, 0.16913366f, 0.02010391f, 0.02962015f, -0.00059223f, 0.10553437f, 
    0.12154260f, -0.00196884f, 0.12105940f, 0.04149541f, -0.08407701f, -0.00144372f, 0.04059318f, 0.04738633f, 
    -0.03580883f, 0.12693292f, -0.08567440f, -0.05572851f, 0.00009263f, -0.20834298f, -0.02232119f, 0.13799536f, 
    0.19153233f, 0.05936952f, -0.43550211f, 0.11166470f, -0.03098543f, -0.06651354f, 0.07846053f, 0.02917970f, 
    0.16241291f, 0.20860530f, 0.15144227f, 0.02053725f, -0.01618437f, 0.25596964f, -0.04188460f, -0.40658137f, 
    0.11122221f, 0.00694535f, -0.00302968f, 0.10380642f, 0.10006408f, -0.04575267f, 0.11850712f, -0.02692156f, 
    -0.28528059f, -0.00237431f, -0.08499374f, -0.28844944f, -0.12350241f, 0.01628402f, -0.19980256f, -0.17205612f, 
    -0.13069375f, -0.16362885f, 0.04232341f, 0.10005185f, 0.15232001f, -0.23075704f, 0.41529170f, 0.19086786f, 
    0.07096633f, -0.03547698f, 0.16395760f, 0.10199177f, 0.02881610f, 0.06466354f, 0.03448289f, -0.23819640f, 
    -0.06221965f, -0.08909325f, -0.04530811f, -0.09374088f, -0.01689110f, 0.16060761f, 0.04790539f, 0.23639321f, 
    -0.05195682f, 0.02256390f, 0.02898275f, -0.07743549f, 0.33820075f, -0.05423309f, 0.23177667f, -0.53288978f, 
    -0.12614553f, 0.02933241f, -0.03547204f, 0.06522518f, 0.23784004f, -0.09048486f, 0.21177869f, -0.04597889f, 
    -0.11872045f, -0.02623593f, 0.11354232f, -0.26014289f, -0.08398075f, -0.19104266f, 0.00911958f, -0.04030582f, 
    0.21948488f, 0.16914786f, 0.00399334f, 0.21400556f, 0.15329956f, 0.00073879f, 0.12828717f, 0.10316075f, 
    0.00666157f, 0.07896876f, 0.06784862f, 0.21957351f, 0.18105862f, 0.02668678f, 0.13092208f, 0.15988594f, 
    -0.26088583f, -0.21769007f, 0.01221324f, -0.08675377f, -0.07327616f, -0.03116650f, -0.10099907f, 0.05904281f, 
    0.01455736f, 0.11870026f, 0.03827916f, 0.01402279f, -0.38811710f, -0.24809468f, -0.35112387f, -0.31612167f, 
    -0.05077776f, -0.14873974f, -0.10051175f, -0.09998285f, 0.06078033f, 0.02494223f, 0.19562179f, 0.25902838f, 
    -0.04629781f, 0.02035960f, -0.10494860f, -0.15180784f, -0.01167328f, -0.10571869f, -0.01052903f, -0.07629395f, 
    0.12386921f, -0.25284594f, -0.22040032f, -0.24322131f, -0.11811808f, 0.02187851f, 0.02798111f, 0.01398491f, 
    -0.00827845f, -0.13228941f, 0.19365399f, 0.06146209f, -0.02028688f, -0.15772069f, -0.12985259f, 0.03540479f, 
    -0.04435873f, 0.10968040f, 0.19700681f, -0.04186152f, 0.10037396f, -0.17246695f, -0.01789313f, 0.12300050f, 
    -0.11530658f, -0.23369759f, -0.07834562f, -0.06125792f, -0.05063294f, 0.15914638f, -0.10458431f, -0.24505034f, 
    0.00394956f, -0.20676558f, -0.15594119f, 0.03214469f, -0.07673408f, 0.01016194f, -0.01580637f, -0.22393566f, 
    0.01954099f, 0.00273723f, 0.03327645f, -0.07655384f, -0.04066747f, -0.02247671f, 0.02580948f, 0.05782096f, 
    -0.02537063f, -0.03602371f, 0.02175561f, -0.03383602f, 0.06446636f, -0.07397918f, -0.05397483f, -0.03924427f, 
    -0.01663280f, 0.01553767f, 0.05228911f, 0.00941292f, 0.01944223f, -0.01889757f, 0.00858036f, -0.02568006f, 
    -0.06816610f, -0.05007274f, -0.04206332f, -0.05585666f, 0.00350551f, -0.04435886f, 0.01144452f, 0.05448070f, 
    0.01312707f, -0.01645256f, 0.03587948f, -0.00603203f, -0.00292308f, -0.04599511f, -0.00288268f, -0.01445559f, 
    -0.01845111f, -0.05473725f, 0.02228232f, -0.03948065f, -0.00328730f, -0.04372647f, -0.07392556f, -0.04192246f, 
    0.03766546f, 0.01338119f, 0.01042689f, -0.05011540f, -0.04975604f, 0.03097314f, -0.06540383f, -0.03814439f, 
    0.02358660f, 0.03959116f, -0.05681151f, 0.04494243f, -0.07251461f, -0.05286942f, -0.00647406f, -0.07183389f, 
    -0.06877134f, 0.05480809f, -0.06400825f, 0.03745708f, -0.04030862f, 0.00845530f, -0.03287620f, -0.00321618f, 
    0.02133286f, 0.05357438f, 0.00268494f, 0.04414922f, -0.06483799f, -0.07284816f, 0.02168207f, 0.00027852f, 
    0.05067988f, 0.01414552f, 0.04504964f, -0.05145341f, -0.02882264f, 0.05808784f, 0.01831518f, -0.05967836f, 
    -0.02646375f, 0.00008166f, 0.03618234f, 0.03204712f, 0.03006784f, -0.07341278f, -0.00728407f, -0.04263443f, 
    0.04502268f, 0.06064388f, 0.04326716f, 0.02155640f, -0.06408799f, 0.05834322f, 0.02688261f, -0.06501407f, 
    0.00854587f, -0.00904094f, -0.00657154f, -0.01427733f, -0.06622121f, -0.04397193f, -0.01256495f, -0.07304288f, 
    -0.04353619f, 0.05575261f, 0.00475381f, -0.02892057f, -0.03233691f, 0.00120312f, 0.02744859f, -0.04432124f, 
    0.02960035f, 0.06189240f, 0.01405109f, -0.02353091f, -0.04990815f, -0.02337140f, 0.01851835f, -0.03982133f, 
    0.03251392f, 0.05347208f, 0.05531909f, -0.02640970f, 0.03929950f, -0.03300703f, -0.06741743f, -0.07596858f, 
    -0.03202609f, -0.01906800f, 0.06618887f, 0.03801298f, -0.00257536f, 0.00615972f, -0.06836207f, -0.05495527f, 
    0.05840455f, 0.02006739f, -0.00540668f, 0.03795698f, -0.00881780f, 0.05560905f, -0.02082936f, -0.03328943f, 
    0.03133076f, -0.04065081f, 0.03282189f, -0.04142257f, 0.04279974f, -0.01674038f, 0.05379346f, -0.06359250f, 
    -0.07465555f, 0.06643099f, 0.05743909f, -0.04265397f, -0.06233730f, -0.04199034f, -0.05926853f, 0.04364552f, 
    -0.04282275f, 0.03308428f, -0.06124184f, 0.01596650f, 0.03045308f, 0.05537836f, -0.00641453f, 0.05314014f, 
    0.04431998f, 0.02455078f, 0.03011735f, 0.00204535f, 0.00929527f, -0.05462401f, -0.06888408f, -0.04895836f, 
    -0.00176153f, 0.01520132f, -0.02238854f, -0.04456381f, 0.02000037f, 0.03570312f, 0.02668593f, -0.02340029f, 
    -0.08212942f, -0.09469472f, -0.03928947f, -0.02047200f, -0.05965993f, 0.00043668f, -0.02850549f, -0.00751159f, 
    -0.05419062f, -0.03479908f, -0.09623735f, -0.00205999f, -0.06136008f, -0.00909705f, 0.01526398f, -0.00125819f, 
    -0.05134840f, -0.07389933f, 0.01445935f, 0.01855189f, -0.02885472f, -0.03451030f, 0.04594767f, -0.05804961f, 
    -0.09845192f, 0.02487589f, -0.00633518f, -0.03359480f, 0.03012312f, -0.00944518f, -0.06175153f, -0.00814480f, 
    -0.06618092f, -0.04218788f, -0.06655161f, 0.03179820f, -0.00681381f, -0.02544824f, 0.02747824f, -0.05945060f, 
    -0.02094909f, -0.05881164f, 0.01114848f, 0.02456153f, -0.02169917f, -0.01028818f, -0.02404029f, -0.05922010f, 
    -0.07560848f, 0.03923670f, 0.00202830f, -0.10733248f, 0.03415392f, 0.05390029f, 0.01976299f, -0.04280851f, 
    0.02070976f, 0.02938139f, -0.03518833f, -0.01331277f, -0.03917822f, -0.02510632f, -0.04671065f, -0.00720907f, 
    0.02734784f, -0.00219488f, 0.02780278f, -0.08056123f, -0.10978858f, -0.00452953f, 0.04685843f, -0.09859397f, 
    -0.00807754f, -0.01415689f, 0.05160360f, -0.03870807f, -0.08812369f, -0.00825831f, -0.04855444f, -0.06993799f, 
    -0.02704046f, 0.01574050f, -0.02942882f, 0.06395369f, -0.06889277f, -0.10674382f, -0.00992373f, -0.05425825f, 
    0.05930189f, -0.00082089f, -0.05046636f, -0.08146165f, -0.06823251f, -0.08491213f, 0.02245335f, -0.05354944f, 
    -0.09238250f, 0.02548574f, 0.02580744f, -0.06840015f, -0.07834962f, -0.08499315f, -0.04942501f, -0.00973482f, 
    0.02319678f, -0.10063244f, 0.02611504f, -0.04989804f, 0.02245975f, -0.00341521f, -0.03851356f, 0.03253446f, 
    -0.01764831f, -0.02025288f, -0.05984427f, 0.00814205f, 0.00534817f, -0.08201050f, -0.01530314f, -0.03255706f, 
    -0.02996097f, -0.04245989f, 0.03771687f, -0.02031473f, -0.08186965f, 0.02141939f, -0.05393819f, -0.05939955f, 
    0.04785950f, 0.02529008f, -0.06566965f, -0.03311348f, -0.09278969f, -0.07950652f, -0.02704989f, 0.02659739f, 
    0.03305656f, -0.03283177f, 0.02458989f, 0.00775316f, 0.05075297f, -0.01323747f, -0.04989678f, 0.02723355f, 
    -0.05167748f, -0.00797347f, -0.05278182f, -0.03356761f, -0.04867253f, -0.04360781f, -0.01628006f, -0.01525920f, 
    0.02631437f, -0.07357728f, 0.01218935f, -0.04371089f, -0.06873251f, 0.00157478f, -0.09645490f, -0.03303371f, 
    0.02600582f, -0.07067748f, -0.05790196f, -0.01874482f, -0.06441968f, 0.01629131f, 0.00089870f, -0.03364848f, 
    0.03306711f, 0.01832187f, -0.01621778f, -0.00254528f, -0.06523523f, -0.06921820f, -0.02555233f, -0.08862866f, 
    -0.07250890f, -0.01727071f, -0.04751920f, -0.00719358f, -0.05597898f, -0.06073287f, 0.05233103f, -0.06727389f, 
    -0.01091746f, 0.04453742f, -0.08648860f, -0.10078905f, -0.06820811f, -0.09794821f, -0.03438213f, -0.02303490f, 
    -0.18870494f, 0.13083826f, 0.09919954f, -0.14955625f, 0.11769263f, -0.10578050f, -0.06946840f, 0.17012665f, 
    0.17681123f, -0.08760896f, 0.03394028f, 0.05598681f, 0.06268261f, 0.19553554f, 0.03633993f, -0.12782113f, 
    0.10147778f, 0.04283629f, -0.03450100f, 0.03012241f, 0.01079999f, -0.06480846f, -0.00046599f, -0.22357960f, 
    -0.22271949f, -0.02294947f, 0.29114339f, -0.13264424f, -0.04237202f, -0.01496957f, 0.08677571f, 0.05401478f, 
    0.12555586f, 0.10169771f, 0.04551732f, 0.06914553f, 0.18437992f, -0.22718507f, -0.05285178f, -0.04541657f, 
    0.11090658f, 0.00033826f, -0.13739072f, 0.04895905f, 0.05238938f, 0.06513942f, 0.05210087f, -0.01562880f, 
    0.09004915f, 0.23385516f, -0.08257144f, 0.12455525f, -0.18688045f, -0.00919624f, -0.10300674f, -0.02838611f, 
    -0.08021080f, 0.01242868f, -0.05044999f, 0.06571085f, 0.05074948f, 0.09047423f, 0.05756475f, -0.17268024f, 
    0.01106593f, 0.06858643f, -0.05932492f, 0.00086722f, -0.12625536f, -0.10910858f, 0.00880407f, -0.21858035f, 
    0.19148488f, 0.02308712f, -0.08911204f, 0.07588291f, 0.07026562f, 0.21842772f, 0.05807184f, 0.23761928f, 
    -0.17687477f, 0.07621020f, -0.05843518f, -0.02048505f, 0.09531564f, 0.00337840f, -0.25071794f, 0.03212882f, 
    -0.16265538f, -0.14108793f, 0.02192406f, 0.03549346f, -0.08081378f, -0.05105189f, 0.01260194f, 0.04311465f, 
    -0.24689171f, -0.10064362f, -0.13569927f, -0.27825975f, -0.07903408f, -0.06645210f, 0.09165042f, -0.28944129f, 
    0.05253953f, 0.04771547f, 0.17648825f, 0.01830398f, 0.32488930f, 0.06165411f, 0.00855241f, 0.11310249f, 
    0.04488369f, -0.10647046f, 0.14363018f, 0.16938360f, 0.06574016f, 0.06436774f, -0.00606994f, 0.13516504f, 
    0.09320482f, 0.17359865f, 0.01055148f, -0.05112211f, -0.07788572f, 0.01018346f, -0.01264457f, -0.00940834f, 
    -0.01919463f, 0.13243262f, 0.18179613f, 0.17791624f, -0.33164591f, -0.08111680f, -0.13223283f, -0.29345465f, 
    0.07522025f, 0.10390864f, 0.06825051f, -0.09937659f, 0.06069555f, 0.10129789f, 0.04785458f, -0.03752427f, 
    -0.16056709f, 0.11027834f, 0.17982258f, -0.13713354f, 0.00656741f, -0.11577649f, 0.00984288f, 0.01320844f, 
    -0.17066251f, -0.04433547f, -0.03844965f, -0.14743993f, 0.06535014f, 0.23905279f, -0.05292257f, 0.15228702f, 
    -0.05153146f, -0.09012602f, 0.00163133f, 0.01249351f, 0.05242570f, 0.10458666f, -0.07860915f, -0.03257181f, 
    0.31348649f, 0.29173091f, -0.17106190f, 0.02121814f, 0.10290696f, 0.03833932f, 0.17349909f, 0.07440639f, 
    0.00994634f, -0.08160097f, -0.08450275f, -0.23360062f, -0.30691320f, -0.15825400f, -0.10050702f, 0.08480531f, 
    -0.07707344f, -0.15094364f, -0.17465961f, -0.01317512f, -0.04589310f, -0.05264901f, -0.11868776f, -0.14283051f, 
    0.12793970f, 0.08699862f, 0.07497951f, 0.26594651f, 0.18052948f, 0.22677501f, -0.12471096f, 0.13154514f, 
    0.07582205f, -0.06160777f, 0.18409559f, -0.10395800f, -0.16443232f, -0.09082642f, 0.05102513f, 0.14350739f, 
    0.05142654f, -0.00024774f, 0.19739288f, -0.04599971f, -0.12500304f, 0.16355999f, 0.10270898f, 0.07313766f, 
    0.20426638f, -0.07805996f, -0.12883227f, -0.00622638f, -0.10851298f, 0.11940647f, 0.02436044f, -0.03420860f, 
    -0.13698871f, -0.11633178f, -0.05990328f, 0.06047304f, 0.55951357f, 0.23773843f, 0.10780184f, 0.18210636f, 
    0.05275209f, 0.04458657f, 0.07254008f, -0.02630469f, -0.00767281f, 0.11892068f, -0.15128817f, 0.11188025f, 
    -0.83243769f, -0.51620632f, -0.28240547f, -0.11033799f, 0.05860788f, 0.02222815f, -0.06692738f, -0.31264856f, 
    -0.04261950f, -0.05315438f, -0.03613084f, -0.18605651f, 0.00955910f, -0.02468981f, 0.00175628f, 0.35274372f, 
    -0.02674705f, 0.02024794f, -0.08079930f, -0.00623070f, -0.09014825f, 0.14003323f, 0.29698318f, -0.04162956f, 
    -0.34028074f, -0.09369702f, 0.50026244f, 0.02330578f, 0.02095728f, -0.11266614f, -0.11642789f, 0.02560079f, 
    -0.01877422f, -0.04874640f, -0.08426179f, -0.05562784f, 0.19407228f, -0.01851703f, 0.46285129f, -0.21628694f, 
    0.11641285f, -0.15141343f, -0.11382615f, 0.01323217f, 0.00407501f, -0.03317508f, 0.05097321f, -0.03076044f, 
    0.03429654f, 0.12598974f, 0.17019902f, 0.19993471f, -0.00953099f, 0.16048653f, 0.21821587f, 0.13848700f, 
    -0.02114081f, 0.00743418f, -0.04937662f, 0.00183436f, -0.24866840f, -0.42265731f, -0.11275564f, -0.12851371f, 
    0.11209548f, -0.02078515f, 0.07766249f, -0.04036506f, -0.20059277f, -0.09835015f, -0.22080126f, -0.03868316f, 
    -0.33686763f, -0.10848609f, 0.21167393f, -0.03125285f, 0.01826811f, -0.17473853f, 0.08617932f, 0.15690352f, 
    -0.17960799f, -0.06104889f, 0.01175400f, -0.01647435f, -0.18722095f, 0.14565457f, 0.15972148f, 0.11506122f, 
    -0.02022701f, -0.05870570f, 0.00798076f, 0.19992712f, -0.10354313f, -0.21191743f, 0.15376630f, 0.13612804f, 
    0.04967088f, -0.02769816f, -0.26627645f, 0.15136287f, -0.12646623f, 0.04450691f, 0.04138078f, -0.07068890f, 
    0.17668778f, 0.21976453f, 0.00928380f, 0.13941373f, -0.36717951f, -0.66938019f, -0.47430262f, -0.31238368f, 
    0.17248198f, 0.00390141f, 0.01985676f, 0.08282567f, -0.22333485f, -0.18178576f, -0.06531738f, -0.19871770f, 
    -0.33852863f, -0.17747289f, 0.34079182f, -0.08125474f, 0.02017811f, -0.16490299f, 0.19219194f, 0.00903025f, 
    0.04254279f, 0.16430624f, 0.01685901f, 0.11062422f, 0.15280797f, 0.06566355f, -0.07353492f, -0.10730352f, 
    -0.08264360f, 0.08706263f, 0.07678701f, 0.17516087f, 0.11548514f, 0.04461308f, 0.01266039f, 0.10805053f, 
    0.15241058f, 0.13507360f, -0.06122805f, 0.10325958f, 0.27577567f, -0.02622342f, 0.18439941f, 0.04887255f, 
    0.12013018f, 0.00319934f, 0.16633619f, 0.12577869f, -0.21129298f, 0.17799690f, -0.19549096f, 0.02538914f, 
    -0.12190928f, -0.11682542f, 0.08036926f, -0.16086590f, 0.02737642f, 0.09785210f, 0.01371784f, 0.04429667f, 
    0.10301201f, 0.01926707f, 0.13571350f, -0.37618449f, 0.04611069f, -0.09492831f, 0.08891883f, 0.01768240f, 
    -0.05327091f, 0.05129386f, 0.25360024f, 0.15350240f, 0.29560611f, -0.07528563f, 0.02456482f, 0.22301209f, 
    -0.01632263f, 0.10353744f, 0.11738745f, 0.01054998f, -0.01774478f, -0.01912676f, 0.03932355f, 0.02266877f, 
    -0.26194134f, -0.30318961f, -0.36885679f, -0.26873386f, -0.05664223f, -0.04465112f, -0.01643752f, 0.00288073f, 
    -0.10955002f, -0.00918713f, -0.06195699f, -0.08823951f, 0.14958145f, 0.07581677f, -0.19355738f, -0.03731718f, 
    0.14865519f, -0.08769606f, 0.03572509f, -0.03283615f, 0.05756322f, 0.03787716f, 0.13207747f, -0.04227847f, 
    -0.00031951f, -0.16667718f, 0.10249148f, 0.23546647f, -0.02857630f, 0.14224383f, 0.01135080f, 0.09757065f, 
    -0.17429431f, 0.07759970f, 0.05582647f, 0.10355435f, 0.14227848f, 0.15462194f, 0.49886373f, 0.03467845f, 
    0.07836624f, -0.18551627f, -0.13464215f, -0.10371941f, -0.04956174f, 0.02642331f, 0.20630965f, 0.01091018f, 
    0.27168244f, 0.36451471f, 0.63284588f, 0.17172910f, -0.08962895f, -0.11860805f, -0.26624256f, 0.04237221f, 
    -0.18554780f, -0.02482695f, 0.06328034f, 0.05444405f, -0.04371971f, -0.01987607f, 0.04805644f, 0.10089878f, 
    0.12399554f, -0.00499110f, -0.02847047f, -0.00696953f, 0.03450076f, -0.07317895f, 0.01316602f, -0.07199974f, 
    -0.10989470f, -0.14918184f, -0.12227970f, -0.17981292f, -0.12545152f, -0.00883958f, 0.25719133f, 0.10570516f, 
    -0.01512235f, 0.00332605f, 0.03751187f, 0.12409939f, -0.19610533f, 0.17213987f, -0.29138619f, -0.16148552f, 
    -0.09096116f, -0.07229082f, 0.16112733f, -0.00046583f, -0.04833664f, -0.05370729f, -0.11655284f, -0.01420026f, 
    0.08279601f, 0.23945035f, -0.06664670f, 0.04507423f, -0.11361019f, -0.08122585f, -0.04170590f, -0.11086591f, 
    -0.03419887f, 0.05400455f, -0.00216299f, 0.09657466f, -0.04703179f, -0.14644738f, -0.29322037f, 0.10035015f, 
    0.06544187f, -0.04434611f, -0.03415462f, -0.26083848f, -0.22242090f, -0.08737497f, -0.06735697f, -0.32226875f, 
    0.04849683f, 0.03439379f, 0.08429185f, 0.14299838f, -0.06027396f, -0.11707113f, 0.03211689f, 0.01687552f, 
    0.05947186f, -0.02908617f, 0.07505924f, -0.20331617f, -0.06165239f, 0.36813614f, 0.18770950f, 0.02755813f, 
    -0.07570592f, -0.10971709f, -0.17147791f, 0.03683119f, 0.04929022f, 0.04871833f, 0.08282976f, 0.04771965f, 
    0.00443008f, 0.01540904f, 0.05320599f, -0.06657144f, -0.09250607f, -0.02709750f, -0.06435802f, 0.02604041f, 
    -0.01111356f, -0.07315198f, -0.02518996f, -0.09960488f, -0.08380123f, -0.03221027f, 0.02484770f, -0.03220053f, 
    -0.00881280f, -0.04006263f, 0.01613843f, -0.04564203f, -0.02494150f, -0.02030412f, -0.06070374f, -0.06095769f, 
    -0.01952159f, -0.06800121f, -0.03877504f, 0.01470405f, 0.04037391f, -0.02413076f, -0.09045251f, -0.03439923f, 
    -0.08506653f, 0.03983191f, -0.05641738f, -0.05446744f, -0.04908321f, 0.03480470f, 0.04727510f, -0.02719085f, 
    -0.00711116f, -0.08240737f, -0.08983437f, -0.01574819f, 0.02923327f, 0.00632834f, -0.06524415f, 0.03803113f, 
    0.03019999f, 0.00149178f, -0.06565493f, -0.04808575f, -0.08589693f, -0.10570257f, -0.04984482f, -0.01326298f, 
    -0.03214842f, 0.00177271f, -0.05907248f, -0.04083784f, -0.07222970f, 0.03742974f, -0.04117956f, -0.06568523f, 
    0.04922051f, 0.02773108f, 0.05484940f, -0.06690966f, -0.00348079f, 0.04066858f, -0.02052829f, -0.08504350f, 
    -0.05584529f, -0.02462459f, -0.07078360f, -0.07353875f, -0.02529205f, -0.07888792f, 0.02500830f, -0.06376542f, 
    -0.08662168f, 0.00713106f, -0.06440067f, -0.02316128f, -0.09478226f, -0.07052500f, -0.00735296f, -0.01586415f, 
    0.00629154f, -0.03296665f, -0.04075859f, -0.05477961f, 0.01620520f, 0.03926730f, 0.03229250f, 0.02283223f, 
    -0.09464694f, 0.00782209f, 0.02133084f, -0.08222708f, -0.08000460f, -0.06330320f, 0.03539249f, 0.02668262f, 
    -0.08196782f, -0.04302764f, 0.01174958f, -0.03090324f, -0.01783347f, -0.05200493f, 0.03450485f, -0.03767096f, 
    -0.08116473f, -0.04476392f, -0.05317534f, -0.08560545f, 0.00523567f, -0.00844936f, -0.05627181f, -0.00531403f, 
    -0.06880573f, 0.01856508f, -0.04131157f, 0.02610264f, -0.08911005f, 0.00218356f, -0.07672606f, 0.00171901f, 
    0.00523010f, 0.02920445f, 0.01700352f, -0.03757153f, 0.02555028f, -0.06266767f, 0.04120116f, -0.01798505f, 
    -0.01844575f, -0.09810930f, -0.08320180f, -0.06407624f, 0.02223970f, -0.01942418f, 0.02346156f, -0.09007106f, 
    0.04324676f, -0.01421154f, -0.05438367f, -0.01962472f, 0.02888696f, -0.04595118f, -0.06956510f, 0.07080619f, 
    -0.01260381f, -0.03280940f, -0.01698489f, -0.02623701f, 0.00839953f, 0.04634310f, -0.02085541f, -0.03627029f, 
    0.02056906f, 0.04819303f, -0.09754629f, 0.00972584f, -0.02812533f, 0.01260545f, 0.03066914f, -0.02731574f, 
    -0.02058777f, -0.01161882f, 0.02461977f, -0.02834167f, -0.01182318f, 0.00691608f, 0.06548428f, 0.01403657f, 
    -0.04106561f, 0.02150198f, 0.03620571f, -0.00748369f, -0.05487599f, 0.02366857f, -0.08714870f, -0.02057515f, 
    -0.08152874f, -0.04825726f, -0.04378777f, -0.06544238f, -0.03328859f, 0.03210299f, -0.06162319f, -0.08638068f, 
    0.15926884f, 0.20829476f, -0.14522170f, 0.12626642f, 0.04895101f, -0.15000822f, 0.13554250f, 0.04050895f, 
    0.07032869f, 0.07535709f, 0.03670799f, 0.11156085f, -0.13412204f, 0.34529182f, -0.06364639f, 0.08362343f, 
    0.17130318f, 0.00122793f, 0.03468336f, -0.06173534f, 0.02814113f, 0.09562562f, 0.04410018f, 0.13123432f, 
    -0.37091869f, -0.01831805f, 0.28965369f, -0.25182343f, -0.00470302f, -0.04042927f, 0.07535874f, 0.09518788f, 
    -0.16431795f, -0.12292611f, -0.00034986f, -0.08066155f, 0.38994291f, -0.15026778f, 0.23290455f, 0.13324127f, 
    -0.10446068f, 0.02861929f, -0.03180395f, -0.09521709f, -0.03095128f, 0.13226153f, 0.00449452f, -0.12231199f, 
    0.04382521f, -0.04807045f, -0.24981473f, 0.14338295f, -0.02051845f, 0.01349352f, -0.13233058f, 0.15698753f, 
    -0.05191086f, 0.03090919f, -0.07895559f, 0.02147144f, -0.12628973f, 0.32890889f, -0.14105944f, 0.05976128f, 
    0.08113804f, 0.03147409f, -0.00606101f, -0.05715037f, -0.10353861f, -0.04919000f, -0.23941858f, -0.01994020f, 
    0.39179033f, 0.33200073f, -0.00302833f, 0.07945462f, 0.05770684f, -0.02166346f, 0.02136281f, 0.16189983f, 
    -0.15600175f, -0.06281418f, -0.05293842f, 0.05382981f, -0.01542139f, 0.07105773f, -0.10935412f, 0.48000282f, 
    0.01266027f, -0.13177067f, 0.10372167f, -0.10298175f, -0.13783492f, 0.00337567f, -0.06710547f, 0.07169610f, 
    -0.15986302f, 0.21670933f, 0.06765792f, 0.18212090f, -0.13807058f, 0.10573854f, -0.12458935f, 0.01011935f, 
    -0.08740663f, 0.01163202f, -0.17132957f, -0.05828932f, 0.13743351f, 0.12202388f, 0.09744370f, -0.06199185f, 
    0.02938264f, -0.01118900f, 0.11245811f, -0.01507435f, -0.01256034f, -0.08227043f, -0.01196595f, -0.00472980f, 
    0.04320979f, 0.03391377f, 0.10758109f, -0.09792732f, -0.02632836f, 0.00826319f, 0.18565257f, 0.09876018f, 
    0.02343633f, -0.04149421f, -0.15192515f, 0.15372492f, -0.29225916f, 0.05920043f, -0.19706318f, 0.26866785f, 
    -0.04310811f, 0.09780692f, 0.11590031f, -0.13674234f, -0.00843598f, 0.10383328f, -0.10515136f, -0.11279612f, 
    -0.22110794f, 0.28411070f, 0.20239823f, 0.04952446f, -0.09614210f, 0.08425183f, -0.02230570f, 0.06032461f, 
    -0.09452637f, 0.05206249f, -0.00710690f, -0.00612251f, 0.04243738f, -0.00715519f, -0.08860467f, 0.15131718f, 
    -0.03655156f, 0.11256619f, -0.09349611f, -0.07827398f, -0.11670309f, 0.02303317f, -0.00926260f, -0.15746906f, 
    0.19363290f, 0.16418338f, -0.10065774f, 0.00348520f, 0.05439044f, 0.14602523f, -0.00434688f, 0.05879272f, 
    0.17321536f, 0.05758242f, 0.21010073f, -0.04519607f, -0.02665980f, 0.17397362f, -0.16612750f, 0.23251256f, 
    -0.09512640f, -0.14020647f, 0.06069677f, 0.00719919f, -0.02915622f, -0.02314527f, -0.01016894f, 0.12158413f, 
    -0.19210675f, -0.01368271f, 0.10847212f, 0.12542906f, 0.16592789f, -0.01952897f, -0.03713071f, 0.20777917f, 
    0.20179980f, 0.01936449f, 0.06303106f, -0.04370346f, 0.14403051f, 0.11056307f, 0.21194598f, -0.02346594f, 
    0.09305806f, 0.09088049f, -0.06297778f, -0.12170748f, 0.07660757f, -0.09278579f, -0.04404471f, 0.00876501f, 
    -0.30266881f, 0.02266076f, -0.12510510f, -0.18942733f, -0.06445081f, 0.05374324f, 0.08154660f, 0.08086111f, 
    0.17941578f, 0.21378210f, 0.04308177f, 0.20998158f, 0.12601623f, -0.09753195f, 0.08424709f, -0.26828834f, 
    0.18924338f, 0.09688993f, -0.01038370f, 0.02530837f, 0.00238856f, 0.04121150f, 0.08711905f, -0.08258006f, 
    -0.09912555f, 0.10691606f, -0.25279245f, -0.20080803f, -0.21442533f, 0.06701232f, -0.36198330f, -0.03024177f, 
    -0.07571145f, -0.08117200f, 0.06841829f, 0.07842155f, 0.22492059f, -0.28352025f, 0.18678847f, -0.08264181f, 
    0.06329866f, -0.01365895f, 0.00606347f, -0.04664219f, -0.21038729f, 0.04438162f, 0.05690052f, -0.23625478f, 
    0.09449212f, 0.03266083f, 0.04973685f, 0.00160410f, 0.17811435f, 0.24442981f, 0.02165334f, 0.21083230f, 
    -0.20019472f, -0.03881662f, -0.10469019f, -0.02499035f, 0.13179548f, -0.15634087f, -0.04687011f, -0.71171999f, 
    -0.22773604f, -0.22577579f, -0.08635679f, -0.09580741f, 0.07720561f, -0.15020101f, 0.13840619f, 0.06256247f, 
    -0.41630691f, -0.08826419f, 0.40241832f, -0.20150858f, 0.01292029f, -0.19060840f, 0.07023279f, -0.26358163f, 
    0.07050373f, 0.06751762f, 0.18480232f, 0.04958313f, 0.25096735f, 0.17851990f, 0.06961780f, 0.09098646f, 
    0.02456796f, 0.00310364f, 0.14744234f, 0.19397734f, 0.12062224f, 0.00338941f, 0.12558943f, 0.01163689f, 
    -0.43078128f, -0.33691788f, -0.00476393f, -0.27317157f, -0.01355142f, -0.11706604f, 0.19602729f, 0.13448313f, 
    -0.05228152f, 0.09058259f, 0.23323900f, 0.14697137f, -0.55342907f, -0.18799424f, -0.41486803f, -0.18798266f, 
    -0.01587115f, -0.02832717f, 0.07915334f, -0.07300656f, 0.05539566f, 0.11691869f, -0.03458309f, 0.09708926f, 
    -0.16966715f, 0.06977532f, 0.29972130f, -0.55335408f, 0.02374285f, -0.09757193f, -0.02563415f, -0.01258373f, 
    -0.13331927f, -0.19498388f, -0.05373344f, -0.22963631f, 0.14557764f, 0.16043626f, 0.05004159f, 0.05654013f, 
    -0.01882974f, -0.05840208f, -0.02518609f, -0.11013205f, 0.01639473f, -0.03921971f, -0.12670620f, -0.11250173f, 
    0.27468407f, 0.32263491f, 0.04948865f, 0.01122121f, 0.16761225f, 0.11512711f, 0.17172758f, -0.06217641f, 
    0.01626842f, -0.13899919f, -0.02340188f, -0.22768064f, -0.15841240f, 0.33491257f, -0.22309552f, -0.20046377f, 
    -0.10485391f, -0.24247172f, -0.21202952f, 0.12478018f, -0.28083131f, -0.12592551f, -0.02741991f, -0.11100774f, 
    0.28344396f, -0.47952202f, -0.00334944f, 0.05767866f, -0.05661979f, -0.16215326f, 0.05655145f, 0.21647492f, 
    0.12503637f, -0.04924202f, -0.06256248f, 0.00312301f, 0.15740608f, 0.24783541f, -0.07167735f, 0.08843049f, 
    -0.04231912f, -0.12199647f, -0.19440576f, -0.08078326f, 0.02748483f, 0.05410989f, 0.06225547f, 0.08691481f, 
    -0.49912843f, -0.00029723f, 0.43287069f, 0.02959191f, -0.02866474f, 0.04198665f, 0.09525272f, 0.13034311f, 
    -0.01607906f, 0.01936693f, 0.03487838f, 0.10141964f, -0.06661016f, -0.25804433f, -0.14906490f, -0.22187203f, 
    0.07118302f, 0.18219368f, -0.20898737f, -0.12313908f, 0.02625060f, -0.03059447f, 0.08950557f, -0.06657839f, 
    0.19422610f, 0.26402101f, -0.24941598f, -0.12596042f, -0.00442986f, 0.07057597f, -0.05305972f, 0.14585382f, 
    -0.12644482f, 0.09251370f, 0.03151769f, 0.01765933f, 0.09768263f, -0.00765883f, 0.01641290f, -0.03230921f, 
    -0.03793622f, 0.00403120f, 0.03274970f, -0.05043765f, -0.14547031f, -0.00149724f, -0.02097790f, -0.17577659f, 
    -0.03735807f, 0.02254639f, -0.09925275f, -0.02334505f, 0.07427561f, 0.11877988f, 0.15908590f, 0.03570247f, 
    -0.08145546f, -0.06151142f, -0.10568435f, -0.07916553f, 0.43484166f, -0.03969900f, -0.31963018f, -0.13173875f, 
    -0.08327579f, -0.11634660f, -0.14739975f, -0.00860307f, -0.02339736f, 0.01257437f, 0.03405980f, 0.11265422f, 
    0.04876762f, 0.14297655f, 0.16601081f, 0.15245718f, -0.10814428f, -0.04846813f, -0.13660809f, -0.04611347f, 
    -0.04416673f, -0.03846613f, -0.02172675f, -0.00506562f, 0.13823259f, 0.13898404f, -0.01604113f, -0.19828574f, 
    0.09034505f, 0.08780123f, 0.07780210f, -0.07253809f, -0.03569309f, 0.03454360f, -0.03283883f, -0.07737355f, 
    -0.12133151f, -0.28290141f, -0.09884048f, -0.01821242f, 0.07132321f, -0.06378844f, 0.13269967f, 0.00943512f, 
    -0.10844150f, -0.02813302f, -0.03441846f, 0.02528742f, -0.05859720f, 0.03953823f, -0.01684311f, 0.29117128f, 
    -0.16057697f, -0.02120293f, 0.07379559f, 0.02044569f, -0.12194603f, -0.10889660f, -0.18550280f, -0.12923324f, 
    0.07912242f, 0.01172648f, 0.26164818f, 0.10040631f, 0.09851996f, 0.01813087f, 0.03658718f, 0.02817490f, 
    -0.06950218f, 0.00230857f, 0.01059937f, 0.02370358f, 0.22655718f, 0.30268604f, 0.08758765f, -0.01192822f, 
    0.06573211f, 0.12568404f, -0.03234481f, -0.04598995f, -0.03419202f, -0.04201858f, -0.06589073f, -0.00096210f, 
    0.28297108f, 0.22280417f, 0.01097461f, -0.10106430f, -0.01917956f, 0.11564455f, 0.04469385f, 0.05810424f, 
    0.06390412f, -0.00839586f, -0.03382255f, -0.05537651f, -0.05036109f, 0.01393548f, -0.03462260f, 0.02151440f, 
    0.00841931f, -0.06200483f, 0.01564397f, 0.20559965f, 0.03464652f, 0.02069461f, 0.03660817f, -0.01528984f, 
    0.07618777f, -0.33423665f, 0.06523392f, 0.13074672f, -0.04264034f, 0.08713654f, 0.10541518f, -0.13627188f, 
    0.05923659f, 0.07162283f, -0.02434287f, 0.14688094f, 0.05884293f, 0.03703846f, -0.09337199f, -0.01416605f, 
    0.11897596f, 0.05309585f, -0.00575462f, 0.20266025f, 0.00669844f, -0.07265074f, -0.03408143f, 0.03468278f, 
    -0.35210365f, -0.13359663f, -0.13300496f, 0.07118333f, -0.01053652f, -0.04381756f, -0.01537517f, -0.07296979f, 
    -0.06236207f, -0.12571599f, -0.11878928f, -0.01838895f, 0.16175593f, 0.21910150f, 0.10162935f, 0.05529727f, 
    0.03648813f, 0.02073367f, 0.08760560f, 0.04905875f, -0.05125212f, 0.04068679f, 0.02858539f, -0.02398380f, 
    0.25179249f, 0.01798522f, 0.15905529f, 0.21138294f, 0.09222606f, -0.07103790f, -0.00415558f, 0.04639256f, 
    0.11140511f, 0.01723671f, -0.01408159f, -0.01580906f, -0.25073797f, 0.13726477f, -0.09694243f, 0.21574767f, 
    -0.09553296f, 0.06579125f, 0.01990709f, 0.10247112f, -0.03289722f, -0.09685095f, -0.26267856f, 0.00770735f, 
    0.15914029f, 0.33387458f, 0.04170583f, -0.02657300f, 0.02622721f, -0.17262448f, 0.21730739f, -0.07286973f, 
    0.03502576f, -0.00607180f, -0.03750030f, -0.00401649f, 0.00825546f, -0.01004541f, -0.24715047f, 0.24246106f, 
    0.08976173f, 0.02071871f, 0.06370971f, -0.08713263f, -0.04991306f, 0.15169120f, -0.04206735f, -0.12663676f, 
    -0.01714755f, -0.18272409f, -0.28773582f, 0.04736021f, -0.05107661f, 0.18944432f, 0.10887752f, 0.09213568f, 
    0.12608345f, 0.10960969f, -0.03906357f, -0.08066972f, 0.04079137f, 0.20883669f, 0.12196756f, 0.12737128f, 
    0.02658336f, -0.05497701f, 0.10975530f, 0.12094976f, -0.00231723f, -0.04961181f, -0.06078054f, -0.09628551f, 
    0.09929761f, 0.23529753f, 0.14077333f, 0.12940525f, 0.07051698f, -0.01636621f, -0.16568500f, 0.02369132f, 
    0.02332014f, 0.05264139f, -0.10599286f, 0.07940808f, -0.17551656f, -0.15706711f, -0.03483100f, 0.07833466f, 
    0.09012281f, 0.09330205f, -0.07378851f, 0.02146585f, 0.04506541f, 0.07372954f, -0.01495239f, 0.08606825f, 
    0.00032220f, -0.22870252f, -0.10922699f, -0.01156182f, -0.01108137f, -0.02102632f, -0.09932227f, 0.06429943f, 
    0.11815067f, 0.12972762f, 0.13398214f, 0.14243884f, -0.12500601f, -0.04890448f, 0.34289619f, 0.19310331f, 
    -0.20984833f, 0.06282981f, -0.10831194f, 0.10626901f, 0.06024250f, 0.02411255f, 0.06574004f, 0.05065700f, 
    -0.06753433f, -0.05306950f, 0.03992644f, 0.10123040f, -0.00335342f, 0.14239244f, -0.08848234f, 0.04194291f, 
    -0.02419951f, 0.10420787f, 0.09071457f, 0.08169566f, -0.08891165f, -0.16353649f, -0.30029580f, -0.04034168f, 
    0.05778137f, -0.02990706f, 0.07566973f, -0.13286251f, 0.19075753f, 0.01642728f, -0.09736086f, 0.01794021f, 
    -0.04039395f, -0.08496708f, 0.10691121f, 0.03404670f, 0.13969536f, 0.06584170f, 0.20823091f, -0.02949038f, 
    -0.13870113f, 0.24572305f, 0.02258020f, 0.22014934f, 0.03122579f, -0.09639511f, 0.12150715f, 0.11528770f, 
    -0.01038274f, 0.10395001f, 0.29639661f, 0.33682209f, -0.08309991f, 0.04788050f, 0.12164120f, -0.02178838f, 
    0.15304157f, -0.13778850f, -0.08796294f, 0.12854326f, 0.08036355f, -0.01267197f, -0.05339753f, -0.09388392f, 
    -0.08376931f, 0.03716454f, 0.01476938f, -0.15438205f, -0.13627636f, 0.34134677f, -0.03519373f, -0.07581010f, 
    0.02096108f, -0.01038999f, 0.15602262f, 0.13589650f, 0.03087445f, 0.02978693f, 0.03639424f, -0.06054351f, 
    0.01360349f, 0.03611515f, 0.26264822f, -0.03296141f, 0.12901081f, -0.01980248f, 0.27976301f, -0.23255265f, 
    -0.11265273f, -0.11149307f, -0.02323445f, -0.06211694f, -0.07981528f, -0.10994926f, 0.07797716f, 0.20276204f, 
    -0.03993814f, -0.00353282f, 0.09825077f, 0.11411835f, 0.13710295f, 0.07231976f, 0.10793766f, 0.30660042f, 
    -0.24399939f, -0.20494252f, 0.07369028f, -0.33530903f, 0.08457726f, -0.04375190f, -0.00913855f, -0.16615555f, 
    0.12210865f, 0.13631442f, 0.18793336f, 0.02011669f, 0.09969741f, 0.07393664f, 0.27516600f, 0.08122514f, 
    0.06068056f, 0.07481286f, 0.26584363f, 0.13512990f, 0.03559979f, 0.15420230f, -0.05755595f, -0.18203519f, 
    0.32171786f, -0.17258243f, -0.08084784f, 0.05496125f, -0.00978911f, 0.01856862f, 0.11352387f, 0.11060253f, 
    -0.07962744f, 0.08258846f, -0.03264592f, -0.16234428f, -0.17777365f, -0.16865018f, 0.06274503f, -0.12919545f, 
    0.03570761f, -0.02592898f, -0.14929715f, 0.03022598f, 0.05788327f, 0.00848177f, -0.12228265f, 0.03194560f, 
    -0.13590689f, -0.06414098f, -0.39482197f, -0.08113713f, 0.20650877f, 0.08351201f, 0.03641341f, -0.08842751f, 
    -0.16874065f, -0.00435587f, -0.08427046f, -0.10289731f, 0.07963849f, -0.11458658f, 0.02671192f, -0.03965192f, 
    0.10300745f, -0.04202908f, 0.00677145f, 0.10720050f, -0.01987277f, -0.09202493f, -0.01306136f, -0.07066416f, 
    0.19580774f, 0.04678345f, -0.11041599f, 0.13052833f, 0.01418704f, -0.01594547f, 0.01051517f, 0.10564603f, 
    -0.00399831f, -0.04923002f, 0.00647457f, -0.12453994f, -0.04646126f, -0.10272273f, 0.08705586f, -0.16456075f, 
    0.04837878f, -0.03950984f, 0.05018725f, 0.00579726f, -0.00493290f, -0.00331877f, 0.11608853f, 0.10781664f, 
    -0.25408441f, -0.18814385f, 0.04740384f, -0.18380141f, 0.00229437f, 0.09274910f, 0.02892822f, 0.07964124f, 
    -0.17020139f, 0.03305036f, 0.16195536f, 0.03905692f, 0.18351559f, -0.15964270f, 0.05701061f, 0.04790603f, 
    0.00640274f, 0.09705852f, 0.16789450f, -0.02240275f, 0.04862658f, -0.01974298f, -0.04786330f, -0.11030885f, 
    0.04050275f, 0.06156160f, -0.03234554f, -0.04596779f, -0.05141064f, -0.02739195f, 0.00191800f, -0.02445608f, 
    -0.01685590f, -0.01120875f, -0.03640974f, -0.02791073f, 0.04835374f, 0.01039274f, 0.00096710f, -0.02974929f, 
    0.03268790f, 0.03554531f, 0.03499536f, 0.03032217f, -0.02617641f, 0.02442545f, 0.03401273f, -0.02822736f, 
    -0.04503494f, -0.05138500f, -0.05218292f, -0.01867886f, -0.01697833f, -0.06695898f, -0.06105829f, 0.03642437f, 
    0.04122413f, 0.00399449f, 0.01003752f, 0.06200811f, 0.05511405f, -0.05855941f, -0.07345339f, 0.01080358f, 
    0.02371669f, -0.03127760f, 0.04701382f, -0.08149555f, 0.02086719f, 0.02398699f, 0.01661087f, -0.05609363f, 
    0.06534256f, -0.02152315f, 0.03692498f, 0.04845972f, -0.02441815f, 0.01233265f, -0.00505041f, 0.02669305f, 
    -0.03866126f, 0.00148934f, -0.07176373f, -0.07101379f, 0.00861027f, 0.06265419f, -0.01467816f, 0.01753407f, 
    -0.01152398f, -0.05229489f, 0.00253798f, -0.01246160f, -0.03662635f, -0.07681490f, -0.04623898f, -0.03599329f, 
    -0.02090129f, -0.00186453f, 0.00829836f, -0.04319875f, 0.06843669f, 0.04483799f, -0.01416945f, -0.01585835f, 
    0.04294187f, -0.04636984f, 0.00734793f, 0.00791121f, -0.05128170f, 0.06024691f, -0.04312190f, -0.05852062f, 
    0.00034271f, -0.06572451f, -0.07165999f, 0.00816800f, -0.06268958f, -0.00794846f, 0.03306282f, 0.02943065f, 
    -0.03888069f, -0.05285916f, 0.03454071f, -0.07943138f, 0.05339357f, 0.01990069f, -0.01478201f, 0.06639892f, 
    -0.07904664f, 0.04218534f, -0.06682456f, 0.04249052f, -0.07399776f, -0.00761570f, -0.05874619f, 0.05394169f, 
    -0.06186952f, 0.03147633f, 0.02585478f, -0.03466170f, 0.01942478f, -0.03275376f, 0.05705395f, 0.02407650f, 
    -0.02430685f, -0.07327098f, -0.02773291f, -0.04920843f, -0.04125415f, 0.00681872f, -0.04049004f, -0.06992903f, 
    0.04109944f, -0.03815867f, -0.03308172f, -0.05481768f, -0.02182282f, -0.06082714f, 0.03968169f, -0.05268481f, 
    0.00314802f, -0.06926870f, -0.00547013f, 0.04417542f, -0.03298322f, -0.03892017f, 0.00217967f, -0.00863150f, 
    -0.04646273f, 0.03485416f, 0.01675363f, 0.00639150f, -0.05476589f, -0.03551918f, -0.01062568f, 0.05151382f, 
    -0.06475656f, 0.00329570f, -0.03496093f, -0.06660213f, 0.02875576f, 0.00368175f, 0.01116267f, -0.02456001f, 
    -0.02716891f, 0.00184438f, -0.04639858f, -0.05612401f, 0.00381604f, -0.02779943f, -0.05082584f, 0.02394131f, 
    -0.05198427f, -0.05829957f, 0.04138754f, -0.05354286f, 0.04443400f, -0.06345762f, -0.01801327f, 0.03382732f, 
    -0.04370881f, -0.01104250f, -0.01979994f, 0.00952795f, 0.03222642f, 0.01667548f, 0.05296757f, 0.00749920f, 
    -0.00863297f, 0.04374158f, -0.05008525f, -0.01536045f, -0.02447815f, -0.07446131f, 0.06117786f, -0.00950411f, 
    0.18939228f, 0.43774924f, -0.18821308f, -0.13345626f, 0.10939047f, -0.11926418f, -0.01994815f, 0.07811417f, 
    0.16817687f, -0.16696234f, 0.00532893f, 0.08381358f, -0.25449887f, -0.06664294f, -0.27471408f, -0.00560465f, 
    -0.02008135f, -0.01639811f, -0.04542809f, 0.17566583f, 0.00477323f, -0.04797744f, -0.22608802f, -0.15797919f, 
    0.40430841f, 0.07370164f, -0.21326053f, -0.11616950f, 0.02224771f, -0.05882711f, -0.13822424f, -0.03214228f, 
    -0.02706711f, 0.03126938f, 0.14886229f, 0.16067834f, 0.14739034f, -0.12496071f, -0.04320725f, 0.53126872f, 
    0.15552546f, 0.06268191f, 0.06233667f, -0.02585005f, 0.05556378f, -0.01798519f, -0.09577733f, -0.05856146f, 
    -0.18448541f, -0.34694815f, 0.01824302f, -0.00884877f, 0.13697229f, 0.05799382f, -0.03958432f, -0.21344453f, 
    -0.07592431f, -0.09915354f, -0.04473288f, -0.14079405f, 0.11848864f, 0.12590893f, -0.02724113f, -0.07016574f, 
    0.02599933f, -0.02658706f, 0.00987185f, 0.22987059f, 0.08432429f, 0.04373798f, -0.12196828f, 0.11809684f, 
    0.07122009f, -0.04744671f, 0.13125049f, 0.14188281f, -0.04684902f, 0.10383563f, 0.13646276f, 0.03545745f, 
    -0.03478387f, 0.27927637f, 0.04519659f, -0.02082755f, -0.33463669f, 0.19017108f, 0.13323849f, 0.16262996f, 
    0.14234138f, 0.04054468f, -0.00205394f, -0.23336202f, -0.01956220f, 0.06568578f, 0.01564543f, -0.05331237f, 
    -0.24594969f, 0.13863921f, 0.23995827f, 0.06817565f, 0.02194439f, -0.16265284f, -0.03266865f, 0.03555243f, 
    -0.02974304f, 0.02211792f, 0.06684347f, 0.18539651f, 0.03968109f, -0.31889248f, 0.08045544f, 0.30590254f, 
    0.03577309f, -0.06037246f, 0.04638433f, -0.03351597f, -0.01398612f, -0.03384495f, 0.20206720f, 0.13969263f, 
    0.17984116f, 0.03639643f, 0.14862084f, -0.31063482f, -0.30849066f, 0.04208948f, 0.08519938f, -0.02637418f, 
    0.16254252f, 0.23228066f, -0.01291254f, 0.07821177f, -0.02831499f, 0.10025956f, -0.13333659f, -0.13721363f, 
    -0.02224454f, -0.16471153f, 0.00719981f, 0.00270406f, 0.04629736f, 0.13567306f, 0.02735964f, 0.23488739f, 
    -0.12316867f, 0.25840080f, 0.01804900f, -0.09385581f, -0.15200631f, -0.06734636f, -0.06174311f, -0.08608031f, 
    0.04847154f, 0.02512258f, -0.24277395f, -0.04374816f, -0.18536524f, -0.25532424f, -0.13507798f, 0.16214070f, 
    0.03945755f, -0.03573218f, 0.10475421f, 0.04387429f, -0.03499230f, -0.02476281f, -0.08556906f, -0.06138927f, 
    -0.29888448f, -0.07199945f, -0.07283158f, -0.05706155f, -0.08395899f, -0.13217074f, 0.00877125f, -0.07000497f, 
    -0.03947056f, 0.01039053f, 0.03090317f, -0.07977599f, -0.16755669f, 0.28480005f, 0.10623072f, -0.04216537f, 
    0.01429003f, -0.04804901f, -0.07870776f, -0.20168439f, -0.17969245f, -0.10081797f, -0.22245371f, -0.12464587f, 
    -0.06888837f, 0.51892304f, -0.07819258f, -0.23568079f, 0.12448727f, 0.01389937f, 0.03133363f, -0.02636717f, 
    0.00767730f, -0.01190955f, -0.04489227f, 0.04529615f, -0.26307878f, -0.05657084f, -0.01812570f, 0.07858784f, 
    0.05177276f, 0.05680854f, 0.13209210f, 0.13969946f, -0.05727081f, 0.13485172f, 0.04806538f, -0.13348143f, 
    0.47071815f, 0.03893116f, -0.00052388f, -0.22312565f, 0.00593427f, 0.02028754f, -0.09035529f, 0.11924229f, 
    0.04569593f, 0.16703965f, -0.06953583f, 0.10089471f, -0.06900715f, -0.12273782f, -0.04262167f, 0.32227570f, 
    0.15695658f, 0.03026515f, -0.00454498f, 0.15836942f, 0.00522842f, 0.00225453f, -0.00709431f, 0.00825091f, 
    -0.10192222f, -0.20589222f, 0.11157102f, 0.13307829f, 0.02999041f, 0.00809242f, -0.02638299f, -0.17309675f, 
    -0.03828667f, -0.07150874f, 0.05103343f, 0.05900322f, -0.04398847f, 0.07308312f, 0.06596946f, -0.19476780f, 
    0.13450128f, 0.00256977f, 0.05084504f, 0.09887311f, 0.25239456f, 0.13089450f, 0.04959917f, 0.05505667f, 
    -0.21888687f, -0.36034364f, 0.03131874f, -0.06805905f, 0.10630280f, 0.03149267f, -0.06847166f, 0.07573846f, 
    0.03470847f, 0.13382854f, 0.09205488f, 0.08613031f, -0.46612671f, 0.08430878f, 0.25983873f, 0.18041767f, 
    -0.02272785f, 0.01681886f, 0.06761229f, 0.10278347f, -0.00981305f, -0.10166464f, 0.15047197f, 0.00267624f, 
    -0.13511495f, -0.02078528f, 0.12719707f, -0.23599686f, -0.03725301f, -0.05567143f, -0.02815699f, 0.00399796f, 
    -0.16691588f, -0.01484931f, 0.02273836f, 0.19586076f, 0.06679341f, -0.31909302f, -0.02102921f, 0.10951193f, 
    0.13555571f, -0.07061869f, -0.02416618f, -0.05568323f, 0.01727830f, 0.06470447f, 0.04781602f, 0.22185138f, 
    -0.04587648f, -0.04830395f, -0.02886874f, -0.18090160f, -0.05742879f, -0.02831055f, 0.07339617f, -0.04017730f, 
    0.20219365f, 0.15221643f, 0.24231477f, 0.12376571f, 0.03187370f, -0.00820005f, -0.15518454f, -0.32972395f, 
    -0.14078984f, -0.12084274f, -0.06253016f, -0.06868571f, -0.07210514f, 0.06046909f, 0.02566162f, 0.08792478f, 
    -0.14195326f, 0.21301408f, -0.15463373f, -0.06268795f, 0.00494841f, -0.14177863f, 0.03520342f, -0.08018309f, 
    -0.00980726f, 0.00226261f, -0.11760374f, 0.07877064f, 0.12867104f, -0.05720034f, -0.39088875f, -0.06676521f, 
    0.27211004f, -0.01603062f, 0.11365861f, 0.07137357f, 0.04908770f, 0.05341307f, 0.02820013f, 0.00893493f, 
    -0.19125637f, -0.07328925f, -0.12836236f, -0.17112267f, 0.13328524f, -0.04827454f, 0.15362807f, -0.11266541f, 
    -0.10711202f, 0.07079764f, -0.00624828f, -0.00290103f, -0.07776374f, 0.09036110f, 0.21859357f, -0.10211112f, 
    -0.05088124f, -0.05694622f, -0.08051040f, 0.01396039f, -0.06656693f, 0.13338120f, -0.07772687f, 0.05632723f, 
    -0.07866690f, 0.01732333f, -0.02009047f, -0.02816061f, -0.05589709f, -0.02931115f, -0.05567436f, 0.03453954f, 
    -0.05405738f, -0.05452792f, -0.07386038f, 0.04045248f, -0.00419843f, -0.02499914f, -0.03805320f, 0.01540758f, 
    -0.01335545f, 0.12090996f, -0.00047043f, -0.09240577f, 0.04753754f, 0.04551084f, -0.03646568f, -0.17041300f, 
    0.02724582f, -0.00735337f, 0.02536103f, 0.05701757f, -0.06586926f, -0.00576030f, 0.01064520f, -0.03597222f, 
    -0.04753324f, 0.00790424f, -0.05611715f, 0.00138685f, -0.06123313f, 0.05140668f, -0.02259845f, 0.05414528f, 
    0.05468961f, 0.00660377f, 0.07240101f, -0.02555450f, -0.10095771f, 0.05832668f, 0.05118011f, 0.07378842f, 
    -0.16820787f, -0.04597731f, 0.04616748f, -0.01280813f, -0.10991810f, -0.09914397f, 0.01082796f, -0.05590506f, 
    -0.06261250f, -0.06662164f, 0.05504938f, 0.06888162f, 0.05965947f, -0.08361262f, -0.02502795f, -0.15733649f, 
    0.06803590f, -0.03740025f, 0.00509335f, -0.00582801f, 0.00606726f, -0.03342290f, -0.04416338f, -0.03996321f, 
    -0.09509788f, -0.05882525f, -0.04853455f, -0.04423348f, -0.07986763f, -0.03068858f, -0.10016446f, -0.06060470f, 
    0.02148746f, 0.01435836f, 0.01689485f, -0.02333429f, -0.06896375f, 0.00848890f, 0.05877444f, -0.03248364f, 
    0.03399788f, -0.01976248f, 0.04361619f, 0.02880707f, 0.01968692f, -0.07843460f, 0.02390259f, 0.05595133f, 
    -0.04587984f, -0.01586719f, 0.02511827f, -0.04587100f, 0.03416276f, -0.03675300f, -0.08541200f, 0.03022091f, 
    0.00792432f, 0.02025566f, 0.01019821f, 0.05817522f, 0.03554862f, 0.07105126f, -0.06229321f, -0.02186723f, 
    -0.03722230f, -0.11821970f, 0.09188050f, 0.00117073f, 0.00062921f, -0.05199391f, -0.02063324f, -0.07410967f, 
    -0.04056434f, 0.01226693f, -0.06161427f, -0.08965499f, -0.01307940f, -0.04060840f, 0.03391558f, -0.05963481f, 
    -0.10812060f, -0.14474243f, -0.08117906f, -0.07442383f, -0.06210987f, -0.07172792f, -0.03918209f, -0.04903163f, 
    -0.07291763f, -0.03430009f, -0.00656770f, -0.05579300f, -0.01331484f, 0.04639753f, -0.04354338f, -0.01628822f, 
    -0.00146456f, 0.03746282f, 0.04892521f, 0.04931611f, -0.06463523f, -0.04218468f, -0.05763825f, 0.00440285f, 
    0.03027609f, -0.04897835f, -0.09135688f, -0.06241761f, -0.06816512f, -0.03258630f, 0.05089641f, 0.03803892f, 
    -0.04685313f, -0.06725096f, -0.14013815f, 0.00299294f, 0.04368076f, 0.04211178f, -0.05741639f, 0.03012115f, 
    -0.10134433f, -0.12013597f, 0.02463158f, -0.08671564f, 0.01389498f, -0.11143542f, -0.06255261f, -0.09033439f, 
    0.00327846f, 0.05042181f, 0.02841140f, 0.00656242f, -0.03954844f, 0.04409128f, -0.05938724f, 0.01518143f, 
    0.02111370f, 0.03416899f, -0.10442410f, -0.08810657f, -0.00411367f, -0.03881467f, -0.01088473f, 0.00696047f, 
    -0.36793390f, 0.20747346f, 0.03399490f, -0.09643669f, -0.02058535f, 0.16456228f, -0.29806367f, 0.06463434f, 
    -0.06450924f, 0.13536541f, 0.07987805f, -0.02446114f, 0.08091984f, -0.27038518f, 0.14554024f, -0.25895402f, 
    0.07707003f, -0.09171983f, -0.08212019f, -0.06176775f, 0.05696600f, 0.04276457f, 0.14062569f, 0.28600278f, 
    -0.03486795f, 0.08114340f, -0.08288712f, 0.36895543f, 0.04055469f, -0.05357332f, -0.12422944f, -0.14483605f, 
    -0.03398965f, -0.17057477f, -0.04882718f, -0.16049975f, -0.13627847f, 0.11117109f, 0.17877951f, -0.02188701f, 
    -0.05528425f, -0.00575012f, 0.02890231f, -0.04578722f, 0.08301722f, 0.07953753f, -0.13596740f, 0.27283436f, 
    0.07440873f, 0.09639730f, 0.17045681f, 0.11303181f, -0.01606080f, 0.07570190f, 0.05664307f, 0.34574726f, 
    0.04578127f, 0.05215790f, 0.00943000f, -0.00237439f, 0.04058701f, -0.07794833f, 0.09252071f, 0.02267638f, 
    -0.06018575f, 0.01868989f, -0.09500019f, -0.08957890f, -0.00182410f, 0.07339405f, 0.09992778f, 0.01440171f, 
    0.19896963f, 0.11851048f, -0.06383565f, 0.09524513f, -0.07284278f, -0.12475281f, -0.11239594f, 0.06800363f, 
    0.14965425f, -0.15335339f, -0.01572346f, 0.08085781f, -0.09960175f, 0.03036235f, -0.11097376f, -0.01039769f, 
    0.04137542f, 0.07352909f, 0.01853785f, -0.01548336f, -0.00162431f, 0.03354076f, -0.14769520f, 0.04976612f, 
    -0.16130993f, -0.07599547f, -0.24961725f, 0.03149914f, 0.12043473f, 0.09155004f, -0.00121921f, -0.09198410f, 
    -0.04007532f, -0.26310718f, 0.00504846f, -0.08522768f, 0.00557926f, 0.04401902f, -0.14072573f, 0.12641470f, 
    -0.03404702f, 0.12858433f, -0.07944864f, 0.13816445f, -0.17876621f, 0.04260067f, -0.18791977f, -0.08389304f, 
    0.10135794f, 0.04655849f, 0.06061056f, 0.34098923f, -0.06275205f, -0.01810444f, -0.22138378f, -0.14908820f, 
    -0.07366917f, -0.20943050f, -0.00466857f, 0.05672649f, 0.21131518f, -0.10480351f, 0.10702419f, 0.19577956f, 
    -0.03329888f, -0.05396990f, -0.19830629f, 0.04401436f, 0.13210046f, 0.01398734f, 0.05939459f, -0.10090166f, 
    -0.17058377f, -0.26909775f, 0.10147533f, 0.01882904f, 0.05403136f, 0.06192787f, -0.07218706f, -0.06165337f, 
    0.12909867f, 0.05544337f, 0.07703318f, 0.11136958f, -0.12485543f, -0.10634542f, 0.05135055f, 0.08803199f, 
    -0.08675013f, 0.12140451f, -0.01895386f, 0.08243994f, -0.05569069f, -0.06898276f, -0.00860842f, 0.06270529f, 
    0.00661994f, -0.11125346f, -0.10652547f, 0.25404683f, 0.11823771f, 0.08051012f, -0.00190286f, 0.00904215f, 
    0.16298059f, 0.08420072f, 0.16116454f, 0.20278296f, 0.10721221f, -0.07429872f, -0.04899982f, -0.01214979f, 
    -0.08733496f, 0.08820591f, 0.07932635f, -0.06157889f, 0.15373245f, -0.07984167f, 0.08716175f, 0.10575753f, 
    -0.17888075f, 0.64761961f, 0.20480512f, 0.08584590f, -0.03094001f, 0.20892541f, -0.13373938f, 0.10530844f, 
    -0.10120269f, -0.00136470f, -0.02444432f, -0.15663952f, -0.01969244f, -0.12776551f, 0.11611123f, 0.00367935f, 
    0.11569827f, -0.00009889f, 0.12003799f, -0.02062052f, -0.06807575f, 0.03033272f, 0.08412781f, 0.13660997f, 
    0.39120525f, -0.09341270f, 0.09313528f, 0.13096030f, -0.18576954f, -0.00221134f, -0.11317567f, -0.06236112f, 
    0.02423592f, 0.05734676f, -0.11240669f, -0.05953484f, -0.06104746f, 0.14290772f, -0.04115186f, -0.08924322f, 
    0.09934456f, 0.03552456f, 0.09947405f, 0.23720594f, 0.09912044f, -0.00962374f, -0.10126223f, 0.03420151f, 
    -0.20676260f, -0.01954111f, 0.12253438f, -0.01737952f, -0.04756263f, 0.08994815f, -0.03458840f, -0.00880751f, 
    -0.07141618f, -0.00852464f, 0.10525798f, 0.06405272f, -0.11144990f, -0.06345241f, 0.40782261f, -0.00653262f, 
    -0.22010808f, 0.01563632f, -0.07532827f, -0.08399729f, -0.00770838f, 0.12778005f, 0.14739676f, 0.01599025f, 
    -0.13864982f, -0.21041383f, -0.00566495f, -0.05539019f, 0.07270487f, 0.00853773f, -0.03633156f, 0.25000808f, 
    0.13582113f, 0.18827489f, -0.06052001f, -0.03388418f, -0.09726083f, 0.31367719f, -0.07324388f, -0.21032122f, 
    -0.02105795f, 0.00753438f, -0.14898866f, 0.14560105f, 0.19378583f, -0.03131185f, 0.03502496f, -0.07012453f, 
    -0.29144609f, 0.18183687f, 0.01972019f, -0.21741346f, -0.11855001f, -0.15365483f, 0.00170276f, -0.05819267f, 
    -0.00753253f, -0.03286226f, -0.05249111f, -0.01166329f, 0.05884092f, -0.10927958f, 0.05931086f, 0.03000282f, 
    -0.00806367f, 0.09492180f, 0.00814197f, -0.09923670f, 0.12840346f, -0.04576964f, -0.03703779f, 0.21804985f, 
    0.01888540f, -0.15841533f, -0.00814497f, -0.05089468f, 0.11195134f, -0.07602138f, -0.09063449f, -0.17890564f, 
    -0.05783432f, -0.01499217f, 0.15272331f, -0.07547368f, 0.14068212f, -0.18231165f, 0.17798047f, -0.14409275f, 
    -0.06816968f, -0.14952713f, -0.17412461f, -0.04866100f, 0.01536530f, 0.04104256f, 0.18978754f, 0.11742568f, 
    -0.04837332f, -0.03592529f, -0.03827482f, 0.09514277f, -0.03007848f, -0.02663217f, -0.08564390f, 0.03290862f, 
    0.12823284f, -0.10897581f, -0.10474643f, 0.00220761f, -0.01321214f, -0.02442975f, -0.19271420f, -0.02024664f, 
    0.24794005f, 0.01086372f, 0.09991869f, 0.10017803f, -0.00731875f, -0.04652682f, -0.07304607f, 0.12026387f, 
    -0.04108117f, 0.03575274f, 0.03757805f, -0.13511768f, 0.13071336f, -0.09125615f, 0.17602721f, 0.07036148f, 
    -0.13632087f, -0.08481773f, -0.06704371f, 0.01182521f, -0.04313855f, -0.04548585f, 0.19897914f, -0.06484119f, 
    -0.13467468f, 0.04735195f, -0.06927078f, 0.24288984f, -0.05843443f, 0.01584138f, -0.05868819f, -0.04395601f, 
    -0.04101792f, -0.04740759f, -0.07230040f, 0.03488726f, -0.02885646f, 0.02370407f, -0.07920879f, -0.03985487f, 
    0.05128180f, -0.06357715f, 0.02085401f, -0.03433041f, 0.01506790f, 0.01135522f, -0.02965954f, -0.01020828f, 
    0.05722670f, 0.02328259f, -0.07098123f, -0.04737021f, -0.01886283f, -0.04951838f, 0.02532462f, -0.06932028f, 
    -0.07546659f, 0.03592120f, -0.00859811f, -0.06834749f, -0.00019226f, 0.02232166f, 0.00943541f, 0.03713984f, 
    -0.07024696f, 0.03227761f, -0.02384574f, -0.01866468f, 0.01309095f, -0.01501376f, 0.00159936f, 0.01315321f, 
    -0.07799506f, -0.06242508f, -0.07909346f, -0.03696490f, -0.03374028f, 0.04284222f, -0.04361778f, 0.01247393f, 
    0.02601282f, -0.03073990f, -0.03277708f, -0.06492001f, 0.03872850f, 0.03383927f, 0.00610551f, 0.06482390f, 
    0.00792134f, -0.04562494f, 0.06813346f, -0.07576109f, -0.03028453f, -0.04750877f, 0.03635463f, 0.02703776f, 
    0.00047170f, 0.03358356f, -0.02878940f, 0.02184202f, -0.03823221f, -0.04426866f, -0.00759447f, 0.01435399f, 
    -0.00538225f, -0.06693175f, -0.07962885f, -0.02520382f, -0.04720913f, -0.02521813f, -0.04676706f, 0.05330626f, 
    0.03577641f, -0.05619625f, 0.01509041f, 0.06468464f, -0.00893907f, 0.04305693f, 0.04008983f, 0.02810528f, 
    -0.03718697f, -0.05435722f, -0.00298813f, 0.06376884f, -0.06109031f, -0.01135603f, -0.00449120f, 0.02379625f, 
    0.00051071f, -0.02281679f, -0.00932211f, -0.00586709f, -0.05728906f, -0.00299718f, -0.08020139f, -0.03481482f, 
    -0.06111896f, -0.04680503f, 0.00604865f, 0.00410345f, -0.01993881f, -0.06994648f, 0.05263920f, 0.03885241f, 
    0.05986756f, -0.04784552f, 0.02681253f, -0.07090574f, -0.07687326f, -0.06742156f, -0.05014580f, -0.07282271f, 
    -0.01630064f, -0.07690569f, 0.00387924f, -0.04449300f, 0.05653557f, -0.06736362f, -0.01456808f, 0.07239938f, 
    0.02201626f, -0.00247753f, 0.05778819f, 0.05713048f, -0.03850754f, 0.00024854f, -0.00585633f, -0.05132971f, 
    0.02985765f, -0.08100573f, 0.04684576f, 0.04088750f, -0.00508850f, 0.01594552f, -0.01402474f, 0.03540071f, 
    -0.01627591f, -0.07573773f, 0.04333430f, 0.04407453f, -0.00208057f, -0.05071742f, -0.02638505f, -0.03872164f, 
    0.03007834f, -0.04568532f, -0.05644007f, 0.05103817f, -0.00980249f, 0.04810273f, -0.00018562f, -0.02318237f, 
    0.00363680f, 0.05622777f, 0.05651050f, -0.04498053f, -0.04302771f, 0.06795305f, 0.06020315f, -0.04077070f, 
    -0.05528678f, 0.03412253f, -0.07262986f, 0.04823045f, -0.06170212f, -0.04654460f, 0.03465215f, -0.04944923f, 
    0.03433260f, -0.02453410f, 0.00417252f, 0.05036126f, 0.06135013f, -0.05857087f, 0.03050988f, 0.05826818f, 
    -0.06622148f, -0.03185631f, 0.06074368f, -0.02525946f, -0.05762847f, -0.04686036f, 0.03756876f, -0.03842094f, 
    0.15761511f, -0.26581383f, 0.23803900f, -0.11511770f, 0.05811955f, -0.02473733f, -0.07185531f, 0.14479728f, 
    0.17220224f, 0.02889167f, 0.10651435f, 0.13707766f, 0.06595952f, 0.14190011f, -0.15213551f, -0.20712917f, 
    0.20661050f, 0.06954604f, 0.11468316f, -0.00182526f, 0.02707839f, 0.15889680f, 0.15691793f, 0.05369432f, 
    -0.32601836f, -0.27253878f, 0.31943464f, 0.20323177f, -0.06390089f, 0.05811891f, 0.07493710f, 0.11388307f, 
    0.05542492f, 0.05402454f, -0.09197561f, -0.06265242f, 0.01527041f, 0.05543704f, 0.11615875f, -0.01958585f, 
    0.03322219f, 0.20089436f, 0.01285325f, -0.00908716f, 0.01506291f, 0.06527546f, 0.00660503f, 0.06984756f, 
    0.07515053f, 0.37673178f, -0.01986734f, 0.04077741f, 0.07328063f, 0.04517345f, -0.07696824f, 0.17181957f, 
    -0.14621566f, 0.02291236f, -0.02206479f, 0.12303680f, 0.09227234f, -0.02050191f, 0.24439098f, 0.11123282f, 
    -0.00314605f, -0.06673615f, 0.06385556f, -0.15675972f, -0.01922592f, -0.03577188f, 0.23261730f, 0.13532804f, 
    0.09576696f, 0.10182005f, 0.02548991f, 0.12395386f, 0.01402259f, 0.07648960f, 0.00542529f, 0.02978950f, 
    -0.02027619f, -0.06623961f, -0.14112668f, 0.00642925f, -0.12905990f, -0.04755388f, -0.11447332f, -0.23911409f, 
    -0.08362482f, 0.08848983f, -0.24052057f, -0.06305536f, 0.05954038f, 0.11569270f, 0.09447887f, -0.17914754f, 
    -0.27351370f, -0.39902583f, 0.17453130f, 0.06960836f, -0.29185599f, 0.01084329f, -0.11041512f, -0.08361672f, 
    0.01547334f, -0.02080966f, -0.03927046f, -0.12592554f, 0.20664133f, 0.23653691f, 0.00481971f, 0.05503738f, 
    0.11549253f, 0.03864198f, 0.05823751f, -0.03617565f, 0.04595431f, 0.00882338f, -0.16349459f, -0.02706547f, 
    -0.11476420f, -0.19048688f, -0.20196344f, 0.00820225f, -0.09978206f, -0.14130622f, 0.09119302f, 0.01413348f, 
    -0.13233650f, -0.04544648f, 0.04334143f, -0.14736921f, -0.22721493f, -0.26448742f, 0.01152009f, 0.08746570f, 
    -0.01533297f, -0.03875048f, -0.05012366f, 0.25437117f, -0.02428508f, 0.14499657f, -0.05028227f, -0.08134990f, 
    -0.26849049f, -0.19414352f, 0.11060721f, 0.23254995f, -0.00998281f, -0.06522340f, 0.04203979f, -0.15030472f, 
    -0.05740502f, -0.09902745f, 0.03588515f, 0.08110707f, 0.22684908f, 0.25480783f, 0.19307293f, 0.12447324f, 
    -0.00853764f, 0.03452313f, 0.08787148f, 0.05519664f, 0.06791453f, -0.10682674f, -0.11753312f, -0.09043391f, 
    0.28220862f, 0.23636186f, 0.10076943f, 0.08096658f, 0.15671071f, 0.18151751f, 0.16901770f, 0.13105041f, 
    0.06118120f, 0.09262767f, 0.03374545f, 0.11864468f, -0.11394468f, -0.25655243f, -0.04005068f, 0.04582789f, 
    0.01041170f, -0.05095442f, -0.20503698f, 0.02293623f, 0.09957140f, -0.13737872f, 0.01766728f, -0.10372798f, 
    0.03285359f, -0.01520534f, -0.02232081f, -0.06499806f, -0.01567372f, 0.03937894f, -0.04092965f, 0.05525824f, 
    0.06117402f, 0.01656947f, -0.05716015f, 0.00824338f, -0.07522911f, 0.01877168f, 0.02448035f, 0.02742581f, 
    0.04664756f, 0.01191094f, 0.04305010f, 0.00352672f, -0.08374102f, -0.03997675f, -0.06969313f, 0.03461774f, 
    0.03267073f, -0.03059685f, -0.05770985f, -0.00505205f, -0.03306929f, -0.05425926f, 0.05812909f, -0.03768325f, 
    -0.02919625f, 0.01288860f, 0.06433236f, 0.01989619f, -0.00979172f, -0.06154731f, -0.04774708f, -0.05815166f, 
    -0.05919303f, -0.00309489f, -0.05876839f, 0.00919587f, 0.04286845f, -0.01796374f, -0.06645609f, -0.03273020f, 
    0.04591947f, -0.01461918f, -0.05669289f, 0.04573118f, 0.04918009f, 0.01624760f, -0.02119444f, -0.04437293f, 
    0.02257755f, 0.01051224f, 0.02039945f, 0.00836091f, -0.02751419f, -0.02134148f, -0.01514506f, 0.04798907f, 
    0.07038204f, -0.02529410f, 0.02566278f, -0.06864785f, 0.02209295f, -0.01808459f, 0.00847451f, -0.06284356f, 
    -0.02820506f, -0.06622437f, 0.02368186f, 0.05639506f, -0.02614999f, 0.00267091f, -0.02430919f, -0.04571374f, 
    0.02112704f, 0.01521383f, 0.01362422f, -0.02777532f, 0.06040794f, -0.02730723f, 0.04914130f, -0.04208388f, 
    -0.06664907f, 0.02573086f, 0.05768738f, -0.00378395f, -0.03857179f, -0.05771939f, -0.01459338f, 0.06335811f, 
    -0.00630485f, 0.06656258f, -0.01658584f, 0.04500067f, -0.00805226f, -0.06292716f, 0.03830911f, -0.07058256f, 
    -0.02968707f, -0.04348707f, -0.02514110f, -0.01336871f, -0.01215233f, 0.01502377f, -0.01900550f, 0.02995442f, 
    -0.02350717f, -0.05078680f, -0.06661463f, 0.06402259f, -0.00780139f, -0.06358559f, -0.01759382f, -0.01412936f, 
    -0.05958755f, -0.05286732f, 0.00337709f, -0.03236004f, 0.04758657f, 0.02288969f, -0.05946070f, -0.05338461f, 
    0.03076070f, -0.02624953f, 0.04480564f, -0.07247847f, -0.03536178f, -0.00383577f, -0.05967864f, -0.07640650f, 
    -0.04582018f, 0.05980840f, 0.00568479f, 0.03852635f, 0.03069315f, 0.00759743f, -0.06367701f, 0.04468796f, 
    -0.01289245f, 0.02536343f, 0.06312536f, -0.01560996f, -0.00969717f, -0.00701311f, -0.03577707f, -0.00919272f, 
    -0.03343095f, -0.05562632f, 0.01074841f, -0.01157278f, 0.02969561f, -0.07156722f, -0.04204355f, 0.02438951f, 
    0.06398978f, 0.02619624f, 0.03941210f, -0.02306518f, -0.05836548f, 0.03076798f, 0.04899165f, -0.05559207f, 
    0.02613246f, -0.00321453f, -0.00441776f, -0.05842436f, 0.02928616f, 0.06473723f, 0.02443122f, -0.07221124f, 
    -0.04807334f, 0.00895839f, -0.03111407f, 0.06089634f, -0.01589575f, 0.06096736f, -0.04545939f, -0.04122790f, 
    -0.04193509f, 0.03549228f, -0.02006347f, -0.05566184f, -0.01908130f, -0.05810980f, 0.04422586f, -0.04531334f, 
    -0.51026803f, 0.47091603f, 0.01942570f, 0.10625608f, 0.17274734f, -0.00947188f, 0.04230529f, 0.03988966f, 
    -0.14021270f, -0.08285261f, 0.12324735f, 0.06599785f, -0.12217683f, -0.07222040f, -0.00033711f, -0.09211251f, 
    0.14045717f, 0.04462269f, 0.14890096f, -0.10367651f, -0.13591042f, -0.18139245f, 0.02529640f, 0.14306715f, 
    0.01077195f, 0.03486461f, 0.04138731f, -0.15695770f, 0.16809027f, -0.20520045f, 0.01563237f, 0.07136317f, 
    0.05087547f, -0.00116992f, 0.00809769f, 0.07241450f, 0.02711873f, 0.12938717f, 0.20271043f, 0.33577681f, 
    0.02609811f, 0.04451575f, 0.09458815f, 0.01364880f, -0.04564931f, -0.03908438f, -0.14151445f, 0.12144315f, 
    -0.01432497f, -0.12266415f, 0.24467050f, 0.26006013f, 0.03404673f, 0.03553993f, 0.03989204f, 0.22194916f, 
    0.07018165f, 0.04203613f, -0.14605002f, 0.03578446f, -0.36042258f, 0.23447724f, 0.02301669f, 0.05283618f, 
    0.11853668f, -0.03459505f, 0.07994745f, -0.10377239f, 0.03442271f, -0.04730473f, -0.18723603f, 0.08857185f, 
    0.22031118f, 0.28972286f, -0.04010014f, 0.21728343f, 0.07130529f, -0.14501218f, 0.13068961f, 0.21217418f, 
    -0.02773865f, 0.06726846f, -0.03553355f, 0.04350926f, -0.43750510f, 0.32009366f, 0.13166019f, 0.41111925f, 
    0.06869140f, 0.08234759f, 0.14176428f, -0.07624529f, 0.03550378f, -0.02368950f, -0.03498006f, -0.08363828f, 
    0.02733313f, -0.11967923f, 0.07276613f, 0.00897949f, -0.06220441f, 0.07788806f, -0.01209605f, 0.07241044f, 
    -0.02566016f, 0.00073184f, 0.05273259f, -0.10325086f, 0.12129870f, 0.12828840f, 0.24984065f, 0.37860647f, 
    0.02232756f, 0.05572347f, 0.06039876f, -0.05505155f, -0.04205183f, 0.19924979f, -0.04091696f, 0.04024697f, 
    0.11889983f, 0.26576024f, -0.02438327f, 0.09458782f, 0.04751521f, -0.01814287f, -0.10557419f, -0.08608685f, 
    -0.04529891f, 0.04542292f, 0.10280083f, 0.02923039f, -0.23153497f, -0.00704715f, -0.30701137f, -0.01718834f, 
    0.10034327f, -0.06277978f, 0.00367682f, -0.01532262f, -0.15438187f, -0.02353664f, -0.09618691f, 0.01810883f, 
    -0.29960600f, 0.16458909f, -0.06731336f, -0.01535473f, -0.03717207f, 0.05021788f, -0.11552668f, -0.01602573f, 
    0.06033478f, 0.11964541f, 0.11560947f, 0.03256611f, -0.20857699f, -0.14055619f, 0.06502400f, 0.33059931f, 
    -0.14926243f, 0.04562834f, 0.04167772f, -0.01542037f, 0.03263665f, 0.02792505f, 0.08351471f, -0.00031585f, 
    -0.11059973f, 0.03333256f, 0.10471684f, 0.31698450f, 0.17615041f, 0.11489096f, -0.01926566f, 0.01057636f, 
    -0.06847644f, -0.03684579f, 0.05583846f, -0.00368004f, 0.11250030f, -0.06158407f, -0.17569306f, -0.07342939f, 
    0.04442820f, -0.05268082f, -0.02362432f, -0.09998200f, 0.21498673f, 0.13260688f, -0.10431293f, 0.06066319f, 
    0.21538171f, -0.04540907f, 0.10135471f, 0.16893476f, 0.04198245f, 0.11330751f, 0.08742015f, -0.01800089f, 
    0.06511433f, -0.01847691f, 0.00887479f, 0.04810650f, -0.22329754f, -0.24028552f, 0.07544433f, 0.10432692f, 
    -0.06102531f, 0.08898821f, 0.07896299f, 0.23285596f, -0.07355832f, -0.09064983f, -0.11381569f, -0.08241593f, 
    0.29576471f, 0.10799987f, -0.25254139f, 0.02441440f, -0.06210839f, 0.02112452f, -0.03899582f, -0.12894472f, 
    -0.00611770f, -0.00682467f, -0.02461732f, -0.01424022f, 0.01360060f, 0.30671436f, -0.03435887f, 0.07258666f, 
    0.05875186f, -0.11008354f, 0.10199354f, 0.09465059f, 0.05541463f, -0.00869572f, 0.03653379f, -0.11200190f, 
    0.02879135f, -0.12283652f, 0.20906170f, 0.00800157f, 0.15478806f, -0.05924774f, 0.18464446f, -0.23024905f, 
    0.00494954f, -0.07074162f, -0.01191692f, -0.00461578f, 0.04926848f, -0.08124267f, -0.08041117f, 0.11380699f, 
    -0.00675464f, 0.08247206f, -0.01125095f, 0.14142977f, 0.11155351f, 0.22600430f, -0.00964385f, 0.07238953f, 
    -0.25086796f, -0.11943340f, 0.03920125f, -0.09925000f, -0.00013660f, -0.00360951f, 0.06347994f, -0.14416188f, 
    -0.04637282f, 0.03558192f, 0.07733752f, 0.00985698f, 0.34370688f, -0.00715978f, 0.19736707f, 0.11557087f, 
    0.12784389f, -0.01765040f, 0.10844474f, 0.13299276f, 0.04426133f, -0.02640687f, 0.02973633f, -0.07762371f, 
    0.25437358f, 0.07829089f, -0.14202887f, 0.06071550f, 0.08663859f, 0.01367794f, 0.16167529f, 0.07891120f, 
    -0.00445693f, 0.05234982f, 0.04124074f, -0.01435385f, -0.17001714f, -0.09878029f, 0.15892138f, 0.05968791f, 
    0.03037187f, -0.09116967f, -0.02483302f, 0.09633963f, -0.00296693f, -0.05944055f, 0.02106898f, 0.07566193f, 
    -0.06520989f, -0.00644629f, 0.28912932f, 0.11024129f, -0.08339148f, -0.01334841f, -0.18309489f, 0.06936154f, 
    0.27120742f, 0.16190588f, 0.01678579f, -0.04133840f, -0.04508390f, -0.02176441f, 0.07004390f, -0.07202582f, 
    -0.08344247f, -0.11273911f, -0.10095932f, -0.05515509f, 0.03901343f, 0.05160386f, 0.05644801f, 0.15469117f, 
    0.31580347f, -0.03591073f, -0.28430650f, 0.04853673f, 0.02420549f, -0.02740494f, -0.06672063f, 0.03114214f, 
    0.16671063f, 0.08603682f, -0.07654997f, -0.14249502f, -0.15010281f, -0.16787228f, 0.17923534f, -0.06684110f, 
    -0.03148482f, -0.02860070f, 0.00640304f, 0.10959644f, -0.04477514f, 0.01569163f, -0.03389011f, -0.01159710f, 
    -0.11564965f, -0.14414553f, 0.12328254f, 0.00463866f, -0.04033161f, -0.09069180f, 0.06985573f, 0.00935317f, 
    -0.09303178f, 0.05798693f, -0.05846314f, -0.07718320f, 0.05865763f, 0.04410177f, 0.07689247f, 0.01784726f, 
    -0.01187802f, 0.05015494f, -0.02302827f, -0.10464939f, -0.00446336f, -0.03935837f, 0.02438544f, 0.00415980f, 
    0.05323834f, -0.49518186f, 0.01722720f, 0.05691980f, 0.02495957f, 0.17118701f, -0.07281940f, -0.00194125f, 
    0.09291179f, 0.09182770f, 0.00279355f, 0.01967517f, 0.23388007f, -0.02841363f, 0.13242856f, -0.07584599f, 
    0.06704083f, -0.00508205f, -0.07148227f, -0.05080124f, 0.21286571f, 0.09193178f, 0.15593749f, 0.21495116f, 
    -0.45506045f, -0.05223403f, 0.04423761f, 0.36227709f, 0.13212729f, 0.10364798f, 0.07861535f, -0.15361334f, 
    0.03689759f, -0.25280818f, -0.07285279f, -0.14092842f, 0.05018884f, 0.19515935f, 0.14878497f, -0.08050925f, 
    -0.20043238f, 0.00051785f, -0.06201785f, -0.10521604f, 0.15578040f, 0.02421924f, 0.11166511f, 0.08056854f, 
    0.22054932f, 0.32344636f, 0.04327280f, -0.11199009f, 0.17530325f, -0.00398106f, 0.03239273f, 0.25050214f, 
    0.04632240f, 0.01063330f, 0.01916515f, 0.02560077f, 0.13731271f, -0.01852640f, 0.16185769f, 0.13630985f, 
    0.04952179f, 0.11776368f, -0.10788863f, -0.13043568f, -0.12015606f, 0.00672143f, 0.04764285f, 0.13154468f, 
    0.16233087f, 0.27944988f, -0.04901815f, -0.00794141f, -0.01885409f, -0.00663016f, 0.01127236f, -0.11811733f, 
    0.17616291f, -0.13491198f, -0.07837965f, 0.07579333f, 0.11224788f, -0.08421359f, -0.24344204f, -0.07276442f, 
    0.01446565f, 0.04149226f, -0.02325935f, 0.07923081f, 0.04586115f, -0.04797253f, -0.11437465f, 0.01741157f, 
    -0.12938324f, -0.13866165f, -0.26566312f, 0.02746178f, 0.04382742f, 0.11301333f, 0.12253437f, -0.05955421f, 
    0.07666422f, -0.05119727f, -0.11462889f, 0.00072522f, 0.10639106f, 0.32586974f, -0.06248629f, 0.02400589f, 
    -0.05148176f, 0.23219302f, 0.10317109f, 0.17795669f, -0.05246482f, 0.06941272f, -0.12073839f, -0.11592899f, 
    0.23183280f, 0.05018338f, 0.12556745f, 0.30060533f, -0.11269134f, -0.13737249f, -0.16940716f, -0.18185276f, 
    -0.03713509f, -0.18894608f, -0.09511345f, -0.10822090f, 0.22780597f, -0.10566024f, 0.22909756f, 0.33391726f, 
    -0.06062353f, 0.00763657f, -0.14610080f, -0.02229557f, 0.13267840f, 0.05686985f, 0.16097842f, 0.04359166f, 
    -0.12391517f, -0.36739001f, 0.13824028f, -0.01930200f, -0.00978408f, 0.15984130f, -0.04305226f, -0.09787585f, 
    0.05096039f, -0.04317598f, 0.08726686f, 0.16708513f, 0.11444405f, 0.12227285f, 0.38544479f, -0.00079792f, 
    0.01380926f, 0.14515626f, 0.03636146f, 0.13723731f, 0.13152307f, -0.01444699f, -0.00914861f, 0.04336346f, 
    0.16679741f, 0.13810089f, 0.10729948f, 0.14523900f, 0.01625564f, 0.14674635f, -0.04924710f, 0.10479309f, 
    0.25284913f, -0.03629301f, 0.00053975f, 0.09591319f, 0.02446148f, -0.15852834f, -0.20144573f, -0.02082083f, 
    0.07893813f, 0.02942408f, 0.04812641f, -0.04422241f, 0.12453990f, -0.14329237f, -0.06241928f, 0.03205919f, 
    -0.04048440f, -0.04439430f, 0.17073040f, 0.29348773f, -0.00624349f, -0.14952740f, -0.31560183f, 0.09378787f, 
    0.02273023f, -0.00862766f, 0.18066622f, -0.02824963f, 0.00829753f, 0.02740206f, -0.08327165f, -0.06839745f, 
    0.14961779f, 0.07248791f, 0.11380716f, -0.04380481f, -0.03708743f, 0.07456104f, -0.08118960f, 0.29862782f, 
    0.09740550f, -0.08797996f, -0.29882616f, 0.12645587f, 0.12922584f, -0.19700791f, 0.06756754f, 0.04631361f, 
    0.11324578f, 0.00165147f, -0.14862174f, 0.10355017f, 0.21318781f, 0.24687521f, 0.19204301f, 0.33980507f, 
    0.00784677f, 0.15022045f, -0.10789265f, -0.04454928f, 0.13932748f, 0.09015879f, -0.07158662f, 0.18509187f, 
    -0.37875202f, 0.13832228f, -0.11923775f, -0.15145735f, 0.02664307f, -0.03458567f, -0.16874169f, 0.18374437f, 
    0.06674840f, 0.02377502f, 0.05578293f, -0.05759173f, -0.16232404f, -0.17027698f, 0.24879409f, 0.15969989f, 
    0.07637848f, -0.02001661f, -0.10327988f, -0.09098355f, -0.07891490f, -0.08858348f, 0.06177757f, -0.07472908f, 
    0.32791391f, 0.26779497f, 0.24895367f, 0.43337712f, 0.09673077f, 0.01048290f, -0.15010066f, 0.01361775f, 
    0.26924416f, -0.12342912f, 0.00909985f, 0.04895764f, -0.54907870f, 0.08087922f, 0.24371196f, -0.42405760f, 
    0.15604882f, 0.17069377f, -0.16331010f, -0.12272415f, 0.12178857f, -0.13161950f, -0.01086837f, -0.07037713f, 
    -0.62038153f, -0.10563119f, 0.44878000f, 0.13536908f, -0.04258744f, -0.09159078f, -0.18208283f, -0.01021956f, 
    -0.01824315f, -0.06867777f, 0.08146627f, 0.08318271f, 0.06014539f, -0.01038051f, -0.06576471f, 0.36872908f, 
    -0.05801283f, 0.08837097f, 0.09593529f, -0.04154100f, 0.09703894f, -0.05190479f, -0.07417881f, -0.05521920f, 
    -0.13587995f, -0.14324561f, -0.05646305f, -0.09961396f, -0.02449951f, -0.11762553f, 0.13486929f, 0.02842352f, 
    0.08015148f, -0.13024464f, -0.00929429f, -0.13057506f, -0.18025371f, -0.23389767f, -0.21088545f, 0.06382295f, 
    -0.02325689f, -0.17166214f, -0.12489209f, 0.09864689f, -0.07942732f, 0.07262131f, -0.10751355f, -0.03568913f, 
    -0.40950608f, -0.04995980f, 0.14591072f, 0.07230268f, -0.10534821f, -0.03413226f, -0.07247286f, -0.13747740f, 
    0.16621721f, -0.06213989f, -0.07589418f, -0.03050891f, -0.32231343f, -0.25118297f, 0.20972930f, 0.42167056f, 
    -0.12127601f, 0.06801893f, 0.11076941f, 0.26752988f, 0.03927090f, 0.04177528f, -0.06032664f, -0.08461661f, 
    -0.15074752f, -0.00354203f, 0.21478173f, 0.18821634f, 0.01132243f, 0.00899895f, 0.01079364f, -0.11085624f, 
    0.17839052f, 0.06032224f, 0.01980853f, 0.06352272f, 0.12115639f, 0.05730831f, -0.08573067f, -0.16327047f, 
    -0.10495304f, -0.15449053f, -0.18592495f, -0.01944352f, 0.20469037f, -0.22302870f, -0.13479640f, -0.06295864f, 
    0.37934366f, -0.16748737f, -0.05505055f, 0.07747453f, 0.19994561f, -0.15186508f, 0.00993365f, 0.04856578f, 
    -0.00855035f, 0.02463574f, -0.18040074f, 0.01730788f, 0.01080942f, 0.07757941f, -0.10934024f, -0.12468774f, 
    -0.09774981f, -0.19208290f, 0.04809994f, -0.07415407f, 0.06254536f, 0.06487780f, 0.05132288f, 0.14493454f, 
    -0.01651810f, -0.05335461f, 0.20269975f, 0.14339179f, 0.11906097f, -0.07214047f, 0.08104739f, 0.03671185f, 
    0.02322631f, 0.07302070f, 0.05875901f, 0.06663697f, -0.38574144f, -0.07907281f, -0.20019484f, -0.07364023f, 
    0.06565450f, 0.22475252f, -0.03106588f, 0.04120813f, 0.08931164f, -0.07326785f, -0.08816010f, -0.00500050f, 
    -0.03540250f, 0.43740690f, -0.15334933f, -0.30325955f, -0.00682289f, -0.15457594f, -0.08276772f, 0.18840337f, 
    -0.11891541f, 0.06515133f, 0.03957142f, -0.09099313f, 0.11717650f, -0.06068236f, 0.15805623f, -0.03842139f, 
    0.10466754f, -0.05027909f, 0.00437900f, -0.07660329f, 0.13112240f, 0.03012865f, -0.01563057f, 0.01437973f, 
    -0.05529936f, -0.17576876f, -0.16955839f, 0.05003490f, 0.04495534f, 0.17672355f, 0.02198108f, 0.02853311f, 
    0.17063837f, 0.00155173f, -0.08844496f, -0.04185797f, 0.12622994f, 0.00283291f, 0.22944827f, -0.32018024f, 
    -0.02464929f, 0.01746478f, -0.25663358f, 0.01738288f, 0.08753765f, -0.01040996f, 0.12791811f, -0.00618037f, 
    -0.02982394f, 0.14649652f, 0.47024333f, 0.19099368f, 0.00022421f, -0.08696439f, -0.29397145f, 0.06407665f, 
    0.02583160f, -0.04064690f, -0.03777176f, 0.06291783f, 0.03262944f, 0.10708456f, -0.17211559f, -0.10760220f, 
    0.03871294f, 0.11136843f, -0.11083942f, -0.20473854f, 0.00725488f, 0.04714685f, 0.06073552f, -0.06077494f, 
    0.07351279f, -0.35988739f, -0.35557088f, -0.00917253f, 0.02511265f, -0.00050855f, 0.12105656f, 0.01940078f, 
    -0.05688237f, 0.05897488f, 0.13088778f, -0.10290386f, 0.14355819f, -0.11806256f, -0.09655912f, -0.08557306f, 
    -0.01090592f, 0.06826720f, 0.03697297f, 0.07764217f, -0.04082911f, -0.00645174f, 0.08907165f, -0.11402490f, 
    0.00135946f, 0.11311886f, 0.28205243f, 0.04221704f, 0.08304247f, -0.07213351f, 0.02937463f, -0.06768453f, 
    0.11153941f, 0.01610342f, 0.01422954f, 0.19126745f, 0.19586812f, 0.19264081f, 0.21899511f, -0.01414698f, 
    0.03770717f, -0.05779384f, 0.14807384f, 0.02768327f, -0.02362749f, -0.11367964f, -0.06457488f, -0.03674483f, 
    0.21744414f, 0.16736172f, 0.07829010f, -0.03983168f, 0.04672534f, 0.00036931f, 0.07490411f, -0.04755691f, 
    0.07008747f, -0.17005673f, -0.01117142f, 0.09707630f, -0.05275964f, 0.07224486f, 0.24627632f, -0.08652488f, 
    0.04560142f, 0.07266209f, -0.01597805f, 0.10916531f, 0.11929075f, 0.03183780f, -0.02069733f, -0.01855881f, 
    0.05780191f, 0.22783045f, 0.11015857f, 0.08545025f, 0.04493099f, 0.27113038f, -0.14058743f, -0.08144857f, 
    -0.05888033f, 0.19686197f, 0.01160895f, 0.01126454f, 0.01612455f, -0.11790457f, 0.05936790f, -0.17313026f, 
    0.09765363f, -0.03386449f, 0.25398871f, 0.07963334f, 0.03986752f, 0.01732267f, 0.05173946f, 0.19507577f, 
    0.33071500f, -0.03967780f, -0.10235440f, 0.29716188f, 0.00441804f, -0.08339243f, -0.04466726f, -0.09672797f, 
    0.03310291f, -0.12157613f, -0.18373516f, -0.15611565f, -0.24122770f, 0.24403971f, 0.08850450f, 0.03529811f, 
    0.02706922f, 0.08728240f, 0.09385207f, 0.09917030f, 0.07827348f, -0.02501251f, -0.16089918f, 0.19429696f, 
    -0.08219654f, 0.06260661f, 0.35496283f, -0.12393313f, 0.09136710f, -0.10419776f, 0.07830860f, 0.09920181f, 
    -0.04222726f, -0.05263157f, 0.00615583f, -0.12443129f, 0.16463403f, -0.11061583f, 0.17505507f, 0.13913555f, 
    -0.04032881f, 0.01260315f, -0.21209599f, -0.09247663f, 0.06451827f, 0.21874063f, 0.17387170f, 0.27766344f, 
    -0.07237858f, -0.14334567f, -0.04180642f, -0.00754878f, 0.01637648f, -0.18794300f, -0.04419311f, -0.10042836f, 
    0.33230084f, -0.03261748f, 0.15098871f, -0.04523750f, -0.12537108f, 0.13836102f, 0.23726277f, -0.27747145f, 
    0.11394221f, 0.12098215f, -0.15041760f, 0.11082393f, 0.03610478f, 0.00295398f, -0.06963310f, -0.16461112f, 
    0.02577216f, -0.07516231f, 0.07789399f, -0.05803504f, -0.00294143f, -0.04778617f, -0.14518884f, 0.03237847f, 
    0.01345106f, -0.07871893f, 0.05276869f, -0.08202506f, -0.02446171f, -0.14360577f, -0.08030345f, 0.10820360f, 
    0.02719057f, 0.11275126f, -0.17329818f, -0.00925702f, -0.02717494f, -0.02459043f, -0.14433618f, -0.02580813f, 
    0.09383149f, -0.02006873f, -0.20873831f, 0.08317133f, -0.00166580f, -0.01046599f, -0.04767722f, -0.12640525f, 
    -0.05137188f, -0.03656536f, 0.02871247f, -0.15256211f, 0.24890412f, -0.12072275f, -0.01478417f, -0.17832097f, 
    0.06972481f, 0.06770675f, -0.20374192f, 0.07378380f, -0.00015276f, -0.04776981f, 0.04860370f, -0.02655747f, 
    0.06199136f, -0.29258952f, 0.02407198f, 0.11748403f, 0.00103144f, -0.07230096f, -0.05277954f, -0.02236525f, 
    0.19628145f, -0.00234513f, 0.05895174f, 0.02467114f, -0.04877690f, -0.12229573f, 0.10039106f, -0.04962323f, 
    0.03915782f, -0.01649901f, 0.04049817f, 0.17755657f, 0.02769574f, -0.16393094f, -0.06701377f, 0.13664851f, 
    -0.15825827f, -0.28263915f, 0.14766963f, 0.03613564f, 0.09494545f, -0.00557964f, 0.14193223f, -0.01725237f, 
    0.04644409f, -0.05478470f, 0.00254648f, 0.26091641f, 0.07942069f, -0.10933571f, 0.20787688f, -0.11969265f, 
    -0.06153025f, 0.06107090f, -0.01964556f, -0.02584517f, 0.15706438f, 0.05480845f, 0.12096815f, -0.03385795f, 
    -0.86245269f, 0.15435934f, 0.03622102f, 0.01540036f, 0.01740459f, 0.23280172f, -0.01464908f, 0.06776402f, 
    0.08710021f, 0.01089431f, 0.10055170f, 0.02885079f, 0.04540519f, -0.04485191f, 0.25691921f, -0.25064701f, 
    -0.02819532f, 0.03044078f, -0.02522016f, -0.38059124f, 0.12275888f, -0.02458965f, 0.10171419f, -0.01952713f, 
    -0.11574650f, 0.20883895f, 0.02246673f, 0.04603847f, 0.08529088f, 0.07412215f, 0.11139674f, -0.09897250f, 
    0.11978251f, -0.07031907f, 0.06055576f, 0.01416014f, -0.09322502f, -0.10170448f, 0.16878411f, -0.09205049f, 
    -0.09865231f, -0.02287732f, 0.15464513f, -0.01860030f, 0.03627269f, 0.13132304f, 0.07435498f, -0.00817886f, 
    0.08831926f, -0.20481874f, -0.14936489f, 0.10485668f, -0.35440692f, 0.02972278f, -0.09400100f, 0.47489464f, 
    -0.03465682f, -0.08406424f, -0.07716043f, 0.05055948f, 0.25471762f, -0.05337296f, 0.10386125f, -0.17366251f, 
    0.04459310f, 0.08248542f, -0.06138096f, -0.26232186f, -0.04490464f, -0.13943686f, 0.13556126f, -0.05233886f, 
    0.25564489f, 0.08472423f, -0.21837844f, 0.22303624f, -0.14068288f, 0.09487789f, -0.08308907f, 0.29629818f, 
    -0.06600668f, -0.04558527f, 0.05623537f, 0.08776469f, 0.10608218f, 0.04719707f, -0.05495404f, 0.01266121f, 
    -0.25912291f, -0.13829082f, 0.09889642f, -0.15062883f, -0.18231186f, 0.05311065f, -0.10679141f, 0.17000388f, 
    0.16305044f, 0.01445023f, -0.15777406f, -0.01356116f, 0.10575001f, -0.08610755f, -0.01345589f, -0.23989023f, 
    0.02272179f, -0.12854975f, 0.06123465f, 0.03344368f, 0.14369379f, 0.21955493f, -0.09953514f, 0.02529237f, 
    -0.02635874f, 0.09421157f, -0.08849623f, 0.28158453f, -0.00591964f, 0.09324467f, -0.05197621f, 0.04404968f, 
    0.10780572f, 0.15202330f, 0.20951651f, 0.35893190f, 0.02024449f, 0.15720081f, -0.05545538f, -0.11596844f, 
    -0.04208601f, -0.10558423f, 0.24203569f, 0.13518189f, -0.05177222f, -0.04215987f, -0.08059605f, -0.03653826f, 
    0.12841347f, 0.11061553f, 0.02256781f, -0.21930638f, 0.10360263f, 0.07884166f, 0.07409825f, -0.04026453f, 
    -0.00147292f, -0.24131460f, 0.20583814f, -0.16135149f, -0.14497645f, 0.14009315f, -0.14296013f, 0.04913907f, 
    0.06731695f, 0.02867707f, 0.08708075f, 0.04012570f, 0.04683420f, -0.09163131f, -0.15014057f, 0.03414874f, 
    -0.20893939f, -0.08034090f, -0.08014687f, -0.14925686f, -0.09840870f, -0.10672317f, 0.02832941f, -0.07021404f, 
    0.25629368f, 0.17340277f, -0.07077005f, 0.30010006f, 0.31206307f, 0.02449924f, -0.04880710f, 0.11883283f, 
    0.10941181f, -0.08420680f, 0.14733119f, 0.03099367f, 0.07650401f, 0.12569483f, -0.07578404f, -0.02879522f, 
    -0.15317079f, 0.08997612f, 0.00940334f, -0.02741025f, -0.07119385f, 0.07326432f, 0.01855518f, 0.09342641f, 
    -0.00916748f, -0.23606136f, -0.06470405f, 0.34140047f, -0.05756884f, 0.05666949f, 0.37164319f, 0.03607382f, 
    0.12562537f, -0.14477295f, 0.16512036f, -0.03184729f, 0.10980337f, 0.02534901f, 0.14346878f, 0.13595852f, 
    -0.23367850f, 0.03507637f, -0.03166261f, -0.26841956f, 0.14856137f, -0.00824377f, -0.15734461f, -0.05399837f, 
    -0.17175841f, 0.07263926f, -0.09497043f, -0.28288972f, -0.08124727f, 0.08198691f, 0.11373213f, 0.07510091f, 
    -0.03358826f, -0.03279204f, 0.10533305f, 0.07875422f, 0.28193584f, 0.03227298f, 0.07252445f, -0.05311827f, 
    -0.01359193f, 0.02373053f, 0.00140171f, 0.01717436f, 0.02002214f, 0.08766738f, 0.06034789f, -0.00106975f, 
    -0.23676740f, -0.45586544f, -0.36171344f, 0.04187076f, -0.09995844f, -0.06769094f, -0.11008179f, 0.04067635f, 
    0.14265211f, 0.06053755f, 0.01786073f, 0.07216886f, 0.05770865f, -0.01700250f, -0.26536539f, -0.04562217f, 
    0.10628878f, 0.17103085f, 0.19482978f, 0.08840104f, -0.05382940f, -0.02776076f, 0.05602696f, -0.22798395f, 
    0.10666479f, 0.20427923f, 0.17428096f, 0.13701314f, -0.07057150f, -0.14573337f, -0.01698975f, 0.10609361f, 
    -0.26590693f, -0.01722145f, -0.11263146f, -0.01093558f, 0.34155193f, -0.10682318f, 0.12267872f, 0.07850750f, 
    -0.10601713f, -0.28953931f, 0.10239459f, 0.03307772f, -0.04549183f, -0.02327880f, 0.13682070f, 0.05210931f, 
    0.13584009f, 0.22025158f, -0.05932291f, 0.11779257f, -0.11161553f, 0.05133295f, -0.03359587f, -0.02523435f, 
    0.03136027f, -0.01930469f, -0.03222798f, 0.03708684f, -0.03085242f, 0.04247903f, 0.14105816f, -0.02987822f, 
    -0.03690499f, -0.11628459f, 0.17922142f, 0.22658736f, 0.08997802f, 0.04434552f, 0.11602680f, -0.10020420f, 
    -0.21650922f, -0.15307482f, 0.12508279f, -0.08935905f, -0.11385915f, -0.03168412f, 0.04008757f, 0.13981679f, 
    0.11316835f, 0.02794650f, 0.02506837f, 0.08342133f, -0.31210873f, 0.01140722f, -0.03077167f, 0.13361093f, 
    -0.03946444f, 0.01943182f, -0.02394885f, -0.09604715f, -0.05752587f, -0.00428288f, -0.10958953f, 0.09479889f, 
    0.20525199f, 0.13410909f, -0.07108869f, 0.02412403f, -0.01690747f, 0.08566612f, 0.04355269f, -0.01214095f, 
    -0.04770451f, 0.11896719f, -0.09408943f, -0.13309062f, -0.06560110f, -0.13721950f, -0.10037328f, 0.08789896f, 
    -0.07438052f, -0.00281415f, -0.09796152f, -0.20476182f, 0.03213911f, 0.00197651f, 0.02031208f, -0.12895322f, 
    0.14611205f, 0.10538553f, -0.02051393f, 0.08900628f, -0.11795545f, -0.18846014f, -0.20736748f, -0.02292012f, 
    0.12202708f, 0.10317087f, -0.00441755f, -0.26641920f, -0.04997793f, 0.27040991f, -0.14415807f, 0.15922904f, 
    -0.02725218f, -0.05362293f, -0.11594684f, -0.02668510f, -0.04880513f, 0.00699921f, 0.06755931f, 0.11149287f, 
    0.37703460f, -0.57066113f, 0.05613100f, 0.09278584f, -0.01804193f, 0.08455443f, 0.22850522f, 0.01460849f, 
    0.17733596f, 0.00197153f, -0.00184011f, 0.14320000f, -0.01330446f, -0.05063164f, -0.31719553f, -0.02280242f, 
    0.01066750f, 0.05010143f, -0.10885252f, 0.20682409f, 0.06827670f, -0.01002370f, 0.01136499f, -0.01545688f, 
    -0.37474024f, -0.23754016f, 0.22473477f, 0.15671371f, 0.00024617f, 0.23804474f, 0.01064857f, -0.05022664f, 
    0.01237139f, -0.04276979f, 0.05785287f, 0.01587761f, -0.13087992f, 0.15235832f, -0.11024139f, -0.37072670f, 
    0.04370798f, -0.05026383f, 0.01022453f, 0.09463845f, -0.01590811f, -0.07188103f, 0.12636000f, -0.03820160f, 
    0.20221595f, 0.36650327f, 0.03905424f, -0.02713221f, 0.17507824f, 0.05765171f, 0.09462326f, -0.00487487f, 
    -0.12183841f, 0.03863785f, 0.04673734f, 0.03480925f, -0.13282678f, -0.05055835f, 0.22353622f, 0.21840806f, 
    -0.09882712f, 0.04179430f, 0.05601824f, 0.10944971f, 0.01623575f, 0.09895711f, -0.06743406f, 0.01580434f, 
    -0.17330278f, 0.02904044f, -0.08801366f, -0.27811649f, -0.01365038f, -0.04797459f, 0.27470115f, -0.05471309f, 
    0.06703184f, -0.01431854f, -0.21596502f, -0.08055215f, 0.26742056f, -0.03202784f, -0.50901145f, 0.08735349f, 
    0.00378966f, 0.07296555f, -0.28130263f, 0.26564580f, 0.06672802f, 0.00971902f, 0.02992221f, -0.08315076f, 
    0.04059327f, -0.11107721f, -0.36471957f, -0.15185063f, -0.15765251f, 0.14584182f, -0.01901966f, -0.03425671f, 
    0.27476847f, 0.14831212f, -0.06241333f, 0.12287651f, -0.03193836f, 0.06411281f, 0.22511365f, -0.02404972f, 
    -0.05662520f, 0.15636422f, 0.21455343f, 0.15354326f, 0.06585838f, -0.00601030f, 0.09593713f, 0.06189886f, 
    -0.13059779f, -0.02959801f, -0.02999689f, -0.04376447f, -0.23441756f, -0.16128701f, -0.12168057f, -0.01830642f, 
    0.19243139f, 0.12706146f, -0.11852702f, -0.01999477f, -0.40071133f, -0.28327724f, -0.02570758f, -0.05175170f, 
    -0.07768823f, -0.05298287f, -0.20432372f, 0.11753973f, 0.15482791f, 0.06254389f, 0.15976997f, 0.08169441f, 
    0.24369118f, -0.33261052f, 0.08581986f, 0.00521604f, -0.01209024f, -0.00536236f, -0.11566185f, 0.01236839f, 
    0.00919590f, -0.36158502f, -0.05305063f, -0.07568903f, 0.06511616f, 0.33080393f, 0.35717124f, 0.02472842f, 
    -0.05401494f, 0.09607332f, 0.06331678f, 0.15113625f, -0.02305332f, 0.09964133f, -0.05764455f, 0.22762214f, 
    0.11205111f, 0.16303027f, 0.11836784f, -0.11380693f, -0.03230438f, 0.14972997f, 0.03894117f, 0.03645727f, 
    -0.02482614f, -0.16965044f, -0.15201400f, -0.07842746f, -0.05452977f, -0.20998356f, -0.14119381f, -0.03601902f, 
    -0.06472500f, -0.30401868f, -0.04225310f, -0.01679117f, 0.03978569f, -0.09366006f, 0.04951658f, -0.10762887f, 
    0.39320204f, 0.58590275f, -0.35518521f, -0.36598575f, 0.02388141f, 0.15915984f, -0.07892627f, 0.00818768f, 
    -0.16501424f, -0.03393207f, 0.09225018f, -0.03657554f, -0.22960475f, 0.00273195f, 0.09470001f, -0.25737008f, 
    0.13580251f, -0.01322892f, -0.04750172f, -0.06928685f, -0.00212944f, 0.07012147f, -0.05950449f, -0.07440588f, 
    0.19668548f, 0.06976831f, 0.28847894f, -0.02204370f, -0.13055217f, -0.00855532f, -0.03950706f, 0.10314686f, 
    0.03924018f, -0.03324435f, 0.02018907f, -0.04858837f, -0.13396676f, -0.44583902f, -0.20495385f, 0.19981195f, 
    -0.00541060f, 0.18676887f, 0.14526577f, 0.00416681f, 0.12572825f, 0.02818228f, -0.02769683f, 0.07761535f, 
    0.04350575f, 0.15628003f, 0.04795892f, -0.04985915f, -0.01508760f, 0.14703105f, 0.02178762f, 0.16791268f, 
    -0.04422164f, -0.10603535f, 0.08547761f, 0.09582039f, 0.23123750f, 0.13861659f, 0.06011503f, -0.39901969f, 
    -0.07484608f, 0.03708118f, -0.21538886f, -0.00867211f, -0.03303273f, -0.07458348f, 0.12663345f, 0.02567883f, 
    0.06603721f, -0.23383348f, -0.09454205f, 0.00369485f, 0.08266361f, 0.17068174f, -0.13826315f, 0.14482565f, 
    -0.08395457f, 0.04122746f, 0.00962665f, -0.01684564f, -0.06836402f, 0.12287622f, 0.10084417f, 0.01309898f, 
    -0.25362575f, -0.20145522f, -0.12155576f, 0.04632191f, 0.05945612f, 0.08822242f, -0.05190392f, 0.13573088f, 
    -0.02889323f, 0.18612929f, 0.18015638f, -0.04190262f, -0.17124403f, -0.11398480f, -0.20966221f, -0.00150594f, 
    0.04478941f, 0.02589356f, 0.03592913f, 0.01804185f, 0.05693275f, -0.12833996f, -0.25957236f, 0.00756261f, 
    0.05430596f, 0.10615101f, -0.01004238f, 0.03022193f, -0.04975940f, -0.02262967f, -0.00707860f, -0.02110067f, 
    0.51091087f, -0.01091646f, -0.09939381f, -0.19366908f, -0.02549048f, 0.03137898f, 0.12438324f, 0.02735683f, 
    0.04284476f, -0.04117776f, 0.09261304f, 0.12588292f, 0.29153341f, 0.05148842f, 0.10163642f, -0.15859242f, 
    -0.02287469f, 0.00879022f, 0.02595416f, 0.09053886f, -0.11956017f, -0.14712353f, 0.04826182f, -0.01396904f, 
    -0.13704270f, 0.05197003f, 0.08953597f, -0.06932414f, -0.15390117f, -0.09538167f, -0.03373896f, -0.03045303f, 
    -0.02730979f, 0.09482112f, 0.04241943f, 0.09232448f, 0.27618852f, 0.07532672f, -0.38403776f, -0.11552402f, 
    0.28434059f, -0.05995417f, -0.10737093f, -0.03252188f, -0.05486727f, -0.13208172f, 0.01496356f, -0.07910559f, 
    0.28222156f, 0.09991790f, -0.14539617f, -0.04611176f, 0.15205455f, 0.14931507f, 0.30863309f, 0.13441239f, 
    0.00524792f, -0.10291066f, -0.14276603f, 0.06575505f, -0.04864003f, 0.21817216f, 0.08030582f, -0.09939341f, 
    -0.03997241f, 0.07080185f, -0.08687258f, 0.08392031f, 0.02372205f, 0.01575913f, 0.20622435f, 0.14234160f, 
    -0.05248230f, -0.09241121f, -0.02583988f, 0.04683143f, -0.14622168f, 0.09902301f, 0.08450460f, -0.11890704f, 
    0.13978302f, 0.13857196f, 0.06545410f, 0.09411113f, -0.11153154f, 0.08841117f, 0.20220117f, 0.08882536f, 
    -0.06675115f, 0.11607274f, 0.11089081f, 0.11398576f, 0.07258782f, 0.07304639f, 0.14946067f, -0.10046446f, 
    -0.01188382f, 0.08959766f, -0.35000026f, -0.02526375f, -0.06993127f, 0.05911959f, -0.04319885f, -0.19502634f, 
    -0.10986487f, -0.00292911f, -0.01096779f, -0.11481103f, 0.16950057f, 0.18187177f, 0.13293597f, -0.10417169f, 
    0.04863181f, -0.08730812f, 0.29960772f, 0.13616337f, -0.03847742f, 0.07441357f, -0.00477151f, -0.06464051f, 
    0.01079927f, -0.32330659f, 0.07094439f, 0.09621403f, 0.17023732f, 0.01191356f, 0.12103495f, -0.06141961f, 
    0.11098750f, -0.10787520f, 0.04810601f, 0.03618351f, 0.13684818f, -0.10193311f, -0.12523414f, 0.17792346f, 
    -0.07065029f, 0.16967390f, 0.01826954f, 0.07241835f, 0.16780308f, 0.11392321f, 0.06113030f, 0.09191108f, 
    -0.10261699f, 0.13909908f, 0.13660033f, -0.06454753f, -0.14569752f, -0.13868578f, -0.12879100f, 0.07026524f, 
    -0.12874632f, -0.14256102f, 0.14132093f, 0.04799209f, 0.38293019f, 0.05021881f, 0.16687565f, 0.12417851f, 
    0.04506890f, 0.02801217f, 0.18935381f, 0.16561827f, -0.20973222f, 0.03151692f, -0.07459530f, 0.05207881f, 
    0.17830001f, -0.11846808f, -0.27872947f, -0.07169588f, 0.01752066f, 0.01823001f, 0.17532595f, -0.13767181f, 
    0.03346167f, -0.07140918f, 0.00463863f, -0.15405186f, -0.13224430f, 0.06074947f, 0.06385267f, -0.02294864f, 
    0.07779381f, 0.11513286f, -0.02806474f, 0.26208809f, -0.13962448f, -0.03380056f, -0.07527673f, -0.05803268f, 
    0.01845778f, 0.25692576f, 0.18983859f, -0.06482649f, -0.14417839f, -0.05130638f, -0.08800720f, 0.01679913f, 
    0.00454307f, 0.00081990f, -0.05780950f, 0.10792594f, 0.00454397f, -0.01068148f, 0.17685334f, -0.12932441f, 
    -0.01845658f, 0.14017628f, 0.02833817f, -0.11167891f, -0.01124416f, -0.02680760f, 0.00545076f, -0.09942218f, 
    0.16674639f, -0.19114405f, -0.21302474f, -0.08900307f, -0.13998164f, 0.04410081f, -0.05174949f, -0.10193530f, 
    0.13366765f, -0.02510668f, 0.20694382f, 0.07014285f, -0.21288209f, -0.19071731f, -0.09128267f, -0.07812061f, 
    -0.04539923f, -0.04326236f, -0.19032542f, 0.02515765f, -0.14724460f, -0.15851036f, -0.06515624f, 0.03332685f, 
    -0.07372807f, -0.25341958f, -0.08843327f, -0.02702210f, -0.07684501f, -0.09370355f, 0.04929716f, 0.26257417f, 
    0.03288248f, 0.07842596f, -0.06171203f, 0.05162986f, 0.03334413f, -0.06910206f, -0.04587610f, -0.01338361f, 
    -0.18077448f, -0.00722561f, 0.12901688f, -0.06073359f, -0.06289814f, 0.10226639f, 0.09539594f, 0.22387239f, 
    -0.17311771f, 0.24811321f, -0.07411094f, 0.01870410f, -0.00780178f, 0.09671967f, 0.17756349f, -0.10101540f, 
    -0.17871423f, 0.00060883f, 0.00645942f, 0.04577830f, 0.03419105f, 0.03527253f, -0.10930206f, 0.02780372f, 
    0.14077587f, -0.05144854f, 0.09991264f, -0.04710017f, -0.09963515f, 0.11119613f, 0.16755597f, 0.14184566f, 
    -0.02538061f, 0.11828946f, 0.03646186f, -0.07330573f, 0.01573326f, 0.04256169f, 0.06195880f, -0.10387793f, 
    -0.13420355f, -0.05357471f, -0.12985387f, -0.08047029f, 0.12513702f, 0.01898153f, 0.27422020f, 0.21308826f, 
    -0.05910104f, -0.01180721f, 0.05536817f, -0.01219795f, -0.06143760f, 0.04967560f, -0.04559228f, -0.01548880f, 
    0.13355114f, -0.12510461f, 0.15273947f, 0.29488379f, 0.04565649f, -0.01207447f, 0.14228684f, 0.16869368f, 
    -0.03063656f, -0.02951631f, -0.13008188f, -0.09131734f, -0.28161436f, 0.22379987f, -0.29574421f, 0.02541007f, 
    -0.12614118f, 0.01092054f, 0.03881318f, -0.08855058f, 0.02359471f, -0.03247529f, -0.04351499f, 0.28239951f, 
    0.25076878f, 0.23334847f, 0.09913495f, 0.09134591f, -0.06844556f, -0.06599484f, 0.03714866f, 0.08694825f, 
    0.01107231f, -0.07713247f, 0.01336684f, -0.01667093f, -0.18540031f, 0.18633150f, 0.03267486f, 0.56531519f, 
    0.00476428f, -0.13373886f, 0.25558138f, -0.12512743f, -0.14813350f, 0.00611874f, 0.00798739f, -0.13979356f, 
    0.20551264f, 0.09519989f, -0.13403679f, 0.08237509f, -0.05835664f, 0.10856086f, 0.08499274f, 0.01256290f, 
    -0.13099886f, -0.13902275f, -0.05927108f, -0.17769575f, -0.04303678f, 0.04254067f, -0.00183285f, 0.08006708f, 
    0.03538023f, 0.09393364f, -0.04718681f, -0.01708858f, -0.14060339f, -0.08827433f, -0.24214327f, -0.03343399f, 
    -0.08051933f, 0.20917276f, 0.02283743f, 0.24655195f, 0.11895692f, -0.01792234f, -0.03731652f, -0.06767523f, 
    -0.09804312f, -0.19473521f, -0.17580758f, -0.00633686f, -0.13727771f, 0.13450889f, -0.00175747f, 0.30844206f, 
    0.09668872f, 0.14667286f, -0.00948475f, -0.05037358f, -0.04389311f, -0.04891299f, -0.07300879f, 0.04920862f, 
    -0.09064788f, 0.02054738f, -0.10600200f, 0.16567010f, -0.13708133f, -0.02995332f, -0.01960230f, 0.07108586f, 
    0.03300849f, 0.27710408f, 0.16694842f, 0.23685822f, 0.02033265f, -0.07375371f, -0.04970689f, -0.01630309f, 
    -0.04355829f, 0.03022700f, 0.00049382f, -0.01091644f, -0.12364320f, -0.10818070f, 0.04227892f, -0.08045315f, 
    -0.01191453f, -0.09317102f, 0.01988989f, 0.15152794f, -0.01491854f, 0.05202796f, 0.01896841f, 0.03626005f, 
    -0.00892918f, 0.23092540f, 0.21648741f, 0.22169347f, 0.08558458f, 0.04471041f, -0.02358522f, 0.09644041f, 
    -0.13450626f, -0.03408266f, 0.09394723f, -0.03734174f, 0.13851692f, 0.07838447f, 0.08980840f, 0.24408068f, 
    -0.77232558f, 0.39255047f, 0.28376886f, -0.13369407f, 0.09854092f, 0.07566795f, -0.33462685f, 0.04562866f, 
    0.20332839f, -0.08968253f, 0.00609610f, 0.07947937f, 0.13295393f, -0.01810179f, 0.15162845f, -0.20204604f, 
    -0.01338957f, -0.02222249f, 0.04256074f, -0.07942625f, -0.08599608f, -0.03456237f, 0.01182482f, -0.00954845f, 
    -0.06089137f, 0.07464189f, 0.09937225f, 0.13792515f, -0.03824666f, -0.17541756f, -0.01212724f, 0.12453213f, 
    0.11366687f, 0.06687392f, -0.10077928f, 0.26636627f, -0.00332577f, -0.07800890f, 0.04308957f, 0.12579533f, 
    0.02371029f, 0.09066691f, -0.07537599f, 0.19985406f, -0.02428238f, 0.06805891f, -0.02135995f, 0.05164068f, 
    -0.13068751f, -0.00787420f, 0.04084396f, 0.17827135f, -0.14012086f, 0.17006443f, 0.01094973f, 0.12410493f, 
    0.08836024f, 0.07852597f, -0.04611202f, 0.01350052f, -0.00343286f, -0.06047528f, 0.26125163f, -0.06586496f, 
    0.06887312f, -0.01008070f, -0.04906080f, -0.14248684f, -0.01499591f, 0.02938527f, -0.02930398f, -0.04763999f, 
    0.12014904f, -0.01121561f, -0.14880520f, 0.09162119f, -0.03513537f, 0.11991497f, -0.07180107f, 0.30026886f, 
    0.17402951f, -0.02783328f, -0.03339876f, 0.07448454f, -0.18801469f, -0.06964535f, -0.35150087f, -0.04307313f, 
    0.13267580f, 0.12634109f, 0.07557112f, -0.20294525f, 0.05231995f, -0.02721025f, -0.06231796f, 0.05367880f, 
    -0.48035660f, -0.39140067f, -0.28767508f, -0.21573535f, 0.03709897f, -0.04019427f, 0.00855353f, -0.17305836f, 
    0.03840341f, -0.04915454f, 0.16496089f, 0.05836243f, 0.25498530f, 0.08961667f, -0.05851537f, 0.12628192f, 
    0.07903366f, 0.02127829f, 0.02523728f, 0.01620962f, 0.14241269f, 0.13598534f, -0.05006861f, 0.11526781f, 
    0.01586122f, 0.18689409f, 0.00714896f, 0.10676261f, 0.04662672f, -0.00641785f, -0.06965695f, 0.00462181f, 
    -0.11395808f, 0.02577447f, 0.26748008f, 0.17553651f, -0.05582379f, -0.06366511f, 0.06283525f, -0.14475225f, 
    0.18583830f, 0.03946064f, -0.08439395f, -0.01641775f, -0.07170500f, 0.05062024f, 0.06589656f, 0.16130227f, 
    -0.16001199f, -0.19325234f, 0.04142356f, -0.13538484f, 0.02381527f, 0.08861987f, -0.01040445f, -0.06481013f, 
    0.08249816f, -0.05255404f, 0.05129724f, 0.06059536f, -0.03071981f, 0.07897430f, -0.08561433f, 0.16208211f, 
    -0.03485803f, -0.07674240f, 0.15561640f, 0.03898815f, 0.15790670f, 0.01065125f, 0.05911032f, 0.08584150f, 
    -0.11605638f, 0.10213533f, -0.13845474f, 0.01279097f, 0.18333077f, -0.02542056f, 0.11648481f, 0.02060235f, 
    0.09237543f, -0.04886463f, -0.00361722f, 0.16875219f, -0.19644764f, -0.13398963f, 0.08769590f, -0.14452508f, 
    0.01204660f, 0.00896150f, -0.11825795f, 0.00755347f, 0.02815190f, -0.05183688f, 0.05944984f, 0.03323653f, 
    -0.43318164f, -0.24180521f, 0.26145753f, 0.20421642f, 0.02063181f, 0.14644060f, 0.15236361f, -0.06528830f, 
    0.08566372f, -0.13202257f, 0.00741725f, 0.02873602f, 0.17000888f, -0.24655035f, -0.08345214f, -0.25700164f, 
    -0.17530616f, -0.10608030f, 0.12269251f, -0.09164624f, 0.00701879f, -0.04567406f, 0.02115314f, -0.00475934f, 
    0.17147946f, 0.17653333f, -0.03525683f, 0.03383011f, 0.17318919f, -0.07651528f, 0.09021130f, 0.00828296f, 
    0.09282611f, -0.01911128f, 0.14600217f, 0.02833897f, -0.56629753f, 0.19975533f, -0.00998193f, -0.33480072f, 
    0.00863614f, -0.10685506f, 0.09175388f, 0.03631869f, 0.00306319f, -0.04187267f, -0.02156357f, -0.01203301f, 
    0.08249868f, 0.03171087f, 0.14845483f, -0.14451744f, -0.09221694f, -0.05058453f, 0.06235332f, 0.05948159f, 
    0.06268996f, 0.04441898f, -0.11621410f, -0.00694760f, 0.14062490f, -0.06290989f, 0.06237734f, -0.00397749f, 
    0.10013077f, -0.01717838f, -0.01544816f, -0.13971150f, 0.07808930f, 0.25576678f, 0.07036952f, 0.10270188f, 
    -0.11206574f, -0.18544005f, -0.34172720f, 0.03243570f, -0.08454469f, -0.02574489f, 0.17070740f, 0.07292238f, 
    0.06905418f, 0.03219402f, -0.10234337f, -0.08382200f, 0.12807465f, -0.00675627f, 0.23281300f, 0.01891857f, 
    -0.11655210f, -0.10111672f, -0.02554840f, 0.10027584f, -0.02697620f, -0.00154129f, -0.03323200f, 0.01728638f, 
    0.54111439f, -0.01018982f, 0.10156423f, 0.10607423f, 0.12809460f, -0.01299617f, 0.05548593f, -0.03060281f, 
    -0.04380975f, -0.06825200f, 0.04418772f, -0.05166224f, 0.01582302f, 0.06634092f, 0.02107853f, -0.09796952f, 
    -0.03209354f, 0.05434512f, -0.14202861f, -0.07358430f, 0.09295180f, -0.04660534f, 0.02144486f, -0.07550003f, 
    -0.00352177f, -0.23712966f, -0.23858234f, 0.37214956f, 0.04991567f, -0.05114185f, -0.07210924f, -0.10405564f, 
    -0.00272602f, -0.03683861f, 0.14580305f, -0.12754036f, -0.06554601f, -0.08369201f, -0.15590411f, 0.01085617f, 
    0.04451088f, 0.01623802f, 0.11536800f, -0.08226980f, 0.15625338f, 0.03132737f, 0.11492759f, 0.08171716f, 
    0.31432268f, -0.00808030f, 0.11099681f, 0.14866041f, -0.01365540f, -0.00958944f, 0.05585265f, 0.08226831f, 
    0.10501958f, 0.08742901f, 0.12461621f, -0.02358335f, 0.09100270f, -0.00866208f, 0.26068673f, -0.07890606f, 
    -0.23496692f, -0.04191758f, 0.01362244f, -0.12551361f, -0.09936295f, -0.11187004f, -0.07290087f, -0.00860220f, 
    0.00522138f, 0.02569036f, 0.12983476f, 0.13158394f, 0.13839409f, -0.00073224f, -0.14522570f, 0.05689465f, 
    -0.04121971f, -0.02395289f, 0.15338719f, 0.09393941f, 0.13395852f, -0.03058322f, 0.09860009f, 0.08456922f, 
    0.07616775f, 0.02145585f, 0.15405247f, 0.04844140f, 0.09517784f, 0.10948318f, -0.05378294f, -0.10003235f, 
    -0.07799789f, 0.00666727f, -0.04507573f, -0.05166556f, 0.03781506f, -0.07280441f, -0.06519724f, -0.08322667f, 
    0.01297090f, -0.07378822f, -0.06364118f, 0.04105289f, -0.05136744f, -0.08229162f, -0.03787736f, 0.00273220f, 
    -0.00784149f, -0.05436901f, 0.04504011f, 0.03101242f, -0.05558375f, -0.03455668f, -0.00224892f, 0.02172668f, 
    -0.05931335f, 0.00060811f, 0.03468440f, 0.01794174f, -0.04944993f, -0.02936702f, 0.00950455f, -0.02778136f, 
    0.03388580f, -0.03509978f, -0.00971989f, 0.03579662f, -0.05821190f, -0.05805678f, 0.00742205f, 0.04451872f, 
    -0.01270251f, -0.09697538f, 0.02090779f, -0.00997883f, -0.02859687f, -0.01887041f, -0.01637884f, -0.01338969f, 
    0.02140151f, -0.08330481f, 0.03430765f, 0.05311393f, -0.04876910f, -0.04849946f, 0.05476576f, 0.02686110f, 
    -0.02654835f, 0.03811774f, 0.02596482f, -0.04178738f, 0.01136457f, 0.01718347f, -0.04224781f, 0.00063041f, 
    -0.09530471f, 0.03479011f, 0.00149614f, -0.00667348f, -0.09527503f, -0.05162862f, -0.00286057f, 0.03424099f, 
    0.02570233f, 0.03121428f, -0.06146613f, -0.01622783f, -0.05707780f, 0.00211118f, 0.05443594f, 0.00762273f, 
    -0.00253267f, 0.03764537f, -0.05224498f, -0.05319589f, 0.02569933f, -0.00159476f, -0.09851153f, -0.08403023f, 
    -0.08574513f, -0.04174068f, -0.04316881f, -0.09712581f, -0.08668416f, 0.01829324f, 0.00786273f, -0.07584951f, 
    -0.06219538f, 0.00470663f, 0.03175556f, -0.03830432f, -0.03511883f, -0.07868671f, 0.00837502f, -0.09252739f, 
    -0.08110627f, 0.00246069f, 0.00652029f, -0.07377964f, -0.07078496f, -0.07575205f, -0.05889926f, -0.05222673f, 
    -0.00904405f, -0.06358763f, -0.04976309f, -0.04214543f, 0.03568893f, -0.00843565f, 0.02698942f, -0.09183551f, 
    -0.04104333f, -0.04717494f, 0.01821635f, -0.06735478f, -0.00703769f, -0.00620108f, -0.06515349f, -0.03642413f, 
    0.05071334f, -0.08339955f, -0.08611678f, 0.01775656f, -0.00253953f, -0.02506750f, -0.03552287f, 0.01481478f, 
    0.02685682f, 0.02845537f, -0.06296658f, -0.01287872f, -0.02646472f, -0.05677507f, -0.05991590f, -0.08577348f, 
    -0.03034584f, -0.02420107f, 0.03030546f, -0.00085917f, -0.06739234f, -0.03807373f, -0.03300879f, -0.03828760f, 
    -0.04450588f, -0.01971206f, 0.01146304f, 0.00287604f, -0.04387996f, 0.03983835f, -0.01836843f, -0.04124888f, 
    -0.06483550f, -0.00555168f, 0.01947693f, -0.00801963f, 0.03544534f, -0.07950771f, -0.06416173f, -0.06585893f, 
    0.01365614f, 0.02050079f, -0.07815171f, 0.03278510f, 0.03364431f, -0.00530001f, -0.05106917f, -0.00527692f, 
    0.02403138f, -0.04789352f, -0.08883779f, -0.02917121f, -0.02744475f, -0.01117854f, -0.06191349f, -0.01712136f, 
    0.02367435f, -0.04545729f, -0.03671039f, 0.03181477f, 0.03668193f, -0.00534969f, -0.03788079f, 0.00742503f, 
    -0.03334267f, -0.12308991f, 0.03483663f, 0.06201355f, -0.32484645f, -0.01875430f, 0.02419109f, 0.09999434f, 
    -0.16484845f, 0.02119354f, -0.08071507f, 0.18076238f, 0.18891297f, 0.04201038f, 0.17553166f, -0.04569658f, 
    0.16087228f, -0.09026010f, -0.09398410f, -0.05782306f, -0.06686178f, -0.33964986f, -0.09040551f, 0.10684650f, 
    -0.02592306f, 0.08108535f, 0.17775990f, 0.10722711f, -0.06167869f, 0.08583608f, 0.09728243f, 0.07232101f, 
    0.04860587f, -0.11623624f, -0.04202130f, 0.15031894f, -0.19105385f, -0.06260347f, 0.14773366f, -0.15390441f, 
    0.05220214f, -0.10487295f, -0.23478171f, -0.07367144f, 0.03662804f, -0.00023687f, 0.09135022f, -0.14034647f, 
    0.05398706f, 0.12608005f, 0.12058959f, 0.09412286f, -0.05244269f, -0.09199018f, -0.13501942f, 0.19205819f, 
    -0.06882150f, -0.04578235f, -0.11303046f, -0.06274667f, -0.09343509f, -0.06200008f, -0.10359424f, -0.00737182f, 
    -0.17625435f, 0.03044323f, 0.01542247f, 0.00749689f, -0.24489415f, -0.13233200f, -0.17461881f, -0.14218079f, 
    0.15808071f, 0.33893609f, -0.30215529f, 0.01704229f, -0.22383779f, -0.05884450f, 0.22597657f, 0.11999911f, 
    -0.16479963f, -0.13022800f, -0.30625319f, -0.21448074f, 0.06110084f, 0.18821386f, -0.40985838f, 0.20567380f, 
    -0.11326543f, 0.07237811f, 0.14849384f, -0.17560093f, 0.05905751f, 0.17548999f, -0.07192290f, 0.00650850f, 
    0.12710270f, 0.14925380f, -0.03819052f, 0.07904760f, 0.01045287f, -0.08486848f, 0.08976627f, 0.08813708f, 
    0.20483984f, 0.12364896f, 0.09104282f, 0.11987156f, 0.00627555f, 0.15183102f, -0.15171987f, 0.01478203f, 
    -0.17942205f, -0.01138888f, 0.14416620f, -0.04315606f, -0.04915714f, -0.01416136f, -0.02245842f, -0.04088412f, 
    0.24722278f, 0.05454208f, 0.05174724f, 0.06098212f, 0.02878137f, 0.13048068f, 0.03094300f, -0.02180918f, 
    -0.01434350f, -0.01128575f, -0.15911902f, 0.06576759f, 0.09651607f, -0.00743299f, 0.03152823f, 0.21725939f, 
    0.05477355f, 0.22142124f, -0.02626143f, -0.05649060f, -0.09822592f, -0.06727573f, -0.16767299f, 0.13899772f, 
    -0.05611072f, -0.11409609f, 0.10720538f, -0.07636546f, 0.10600803f, 0.04500700f, -0.00985746f, 0.06352630f, 
    0.24147278f, 0.06738602f, 0.07536574f, 0.19435596f, -0.29710376f, -0.02115589f, 0.15080048f, 0.17652223f, 
    -0.16839804f, -0.06233315f, -0.19136281f, -0.01087265f, -0.11189757f, -0.00107489f, 0.01086723f, 0.02286809f, 
    -0.14051665f, 0.07423519f, -0.16912709f, 0.02795584f, -0.01563711f, 0.14971444f, -0.00766328f, 0.13412465f, 
    -0.24159747f, -0.22742788f, -0.19027437f, -0.05892655f, 0.05177855f, 0.01313720f, -0.06895650f, 0.11612487f, 
    0.10944917f, 0.00017467f, 0.14603247f, 0.14582823f, 0.26831281f, -0.02467885f, -0.00903464f, 0.05365973f, 
    -0.08807494f, 0.67950785f, 0.03911588f, -0.46756303f, -0.03256488f, 0.17151132f, -0.16915318f, -0.01234998f, 
    -0.05841096f, 0.02016100f, -0.14403331f, 0.04598650f, -0.00254597f, -0.37487203f, 0.13968712f, -0.03799663f, 
    0.21854827f, 0.23354235f, 0.23193081f, 0.32322776f, -0.01052703f, -0.03327759f, -0.00329195f, -0.07336114f, 
    0.50594503f, -0.05498622f, 0.07095485f, 0.25278831f, -0.09102260f, 0.08087137f, -0.26039693f, -0.02297667f, 
    0.03128755f, 0.03987295f, -0.22265723f, -0.00225504f, -0.04881804f, 0.04459240f, -0.09852057f, 0.31423396f, 
    0.11271759f, 0.03995523f, 0.04607719f, 0.18150069f, -0.06517439f, 0.00207074f, -0.08719587f, 0.16600932f, 
    0.06779141f, 0.06929855f, 0.23636939f, 0.16344999f, 0.07248770f, 0.15760100f, 0.11783912f, -0.02515968f, 
    0.03233158f, 0.06561638f, -0.05364707f, -0.01651037f, 0.01600966f, -0.00178756f, 0.29143268f, -0.09155586f, 
    0.03642443f, 0.04136888f, -0.10487184f, 0.08405977f, 0.13187599f, 0.06713197f, 0.07113699f, 0.25209296f, 
    -0.04006642f, -0.21158722f, -0.03258709f, -0.00961336f, 0.09051260f, 0.02783200f, -0.07195738f, -0.03265980f, 
    0.08392042f, -0.02377225f, 0.03158087f, -0.03661549f, -0.31512180f, 0.21280141f, -0.04072381f, 0.07254944f, 
    -0.00588012f, 0.14873056f, 0.20286465f, 0.01371031f, 0.03086941f, -0.01791103f, -0.07458732f, -0.07141034f, 
    -0.29356894f, -0.21138440f, -0.13441829f, -0.24103889f, -0.00689704f, -0.10617929f, 0.11465671f, -0.01690130f, 
    0.03709027f, -0.10870049f, -0.08365131f, 0.00173526f, 0.07394746f, -0.16397928f, -0.04713735f, 0.14094052f, 
    0.11920416f, 0.10049022f, -0.08822305f, 0.01386129f, 0.06281648f, 0.03037974f, -0.16700727f, 0.28890041f, 
    0.28047973f, 0.14813451f, -0.04400856f, -0.12775131f, 0.05762945f, 0.08147476f, -0.07346435f, -0.14294747f, 
    0.05893447f, 0.14458388f, 0.11389796f, 0.00625066f, 0.20968103f, -0.10674587f, 0.21402988f, -0.42803028f, 
    -0.02973337f, 0.06418090f, -0.05400530f, 0.00724355f, 0.02215422f, -0.06273502f, 0.03557169f, 0.03543365f, 
    -0.10706997f, -0.13565908f, -0.00338641f, -0.02180285f, -0.02873399f, 0.09453586f, 0.06051661f, 0.00154591f, 
    -0.00510601f, 0.00303930f, 0.06761595f, 0.03984188f, 0.14787836f, 0.00179673f, -0.16271566f, 0.02331758f, 
    0.23527890f, -0.06449138f, 0.05025825f, 0.14256667f, 0.12638803f, -0.05647621f, 0.03103019f, 0.18092956f, 
    -0.22181639f, -0.14946610f, -0.16605175f, -0.10448988f, 0.12095112f, 0.09791114f, 0.17487277f, 0.06001072f, 
    -0.08502048f, 0.03405151f, -0.02041727f, 0.11944373f, -0.07260405f, -0.10330848f, 0.13232917f, -0.04283462f, 
    -0.08713694f, 0.14527102f, 0.09131942f, -0.08111743f, 0.06134679f, 0.04781111f, -0.00554249f, 0.12426728f, 
    -0.04486206f, -0.25981039f, 0.15300211f, 0.09146164f, -0.05755587f, 0.24977228f, -0.07504088f, -0.11925519f, 
    0.09299178f, 0.04665662f, 0.08939283f, 0.04473190f, 0.01653515f, -0.23154475f, 0.17450547f, 0.04438943f, 
    -0.08012531f, 0.07513976f, 0.11208833f, 0.17564623f, 0.05785276f, 0.15017925f, -0.02970303f, -0.21043555f, 
    0.29585513f, -0.10995953f, -0.35986143f, 0.17162469f, -0.00696629f, 0.05030172f, -0.03939779f, -0.14044052f, 
    0.07171166f, -0.05039512f, -0.03231682f, -0.16547050f, 0.05215586f, 0.32007104f, 0.04522418f, -0.02037622f, 
    0.00261064f, -0.16139799f, 0.17404474f, -0.02397429f, 0.12929846f, 0.09671821f, 0.04675440f, 0.03905541f, 
    0.00654746f, -0.04633826f, 0.19901660f, 0.06333321f, 0.12387358f, 0.00581974f, 0.09512471f, -0.11632797f, 
    0.04575305f, 0.07042537f, 0.05625847f, 0.01432596f, 0.25602856f, -0.27559555f, 0.11749190f, 0.10658583f, 
    0.00268310f, 0.03994679f, -0.01993442f, 0.11884816f, 0.00638572f, 0.08690360f, 0.29990581f, 0.06317080f, 
    -0.21936536f, -0.18760477f, 0.13594173f, -0.03247639f, 0.00408352f, -0.11861991f, -0.10821216f, -0.09596582f, 
    0.13544144f, -0.02709662f, 0.12294672f, 0.00584665f, 0.13873057f, -0.11280206f, 0.16966045f, -0.27185237f, 
    -0.02955016f, 0.03086540f, 0.19801587f, 0.04001984f, 0.04162945f, -0.00823024f, -0.04632890f, 0.02887119f, 
    0.16858578f, -0.15289722f, -0.23095661f, -0.08623110f, -0.02425523f, 0.03004540f, 0.08727916f, -0.03074179f, 
    0.07323408f, -0.07853612f, -0.06667114f, -0.04729168f, -0.15250716f, -0.04999324f, 0.01214917f, -0.05113160f, 
    0.03169242f, -0.00261240f, -0.03949160f, 0.14930634f, 0.10054273f, -0.00882486f, 0.01940853f, -0.07833969f, 
    -0.14157407f, 0.01705433f, 0.12941690f, 0.16269815f, 0.01562057f, -0.05709709f, -0.14672466f, -0.08355743f, 
    0.01388470f, -0.02222497f, 0.06478795f, -0.01872728f, 0.07886744f, -0.08113327f, 0.22874774f, -0.17294924f, 
    -0.05698062f, -0.08266738f, -0.09446537f, 0.00303029f, 0.02056576f, 0.01322725f, 0.03275389f, 0.11221579f, 
    0.30615488f, -0.17579268f, -0.24397567f, -0.07360186f, -0.07832409f, 0.05586321f, -0.07840433f, 0.05502091f, 
    0.10186081f, -0.16383265f, -0.14682940f, -0.12540936f, -0.10504227f, -0.17474592f, 0.20775509f, -0.03623422f, 
    0.00802482f, 0.03722343f, -0.08844288f, 0.04659867f, 0.08948990f, -0.01071565f, -0.02211227f, 0.12446629f, 
    -0.13887510f, -0.18608038f, 0.13902818f, 0.04126766f, -0.01317190f, -0.07679494f, 0.10872634f, -0.04123201f, 
    0.11812282f, 0.06614736f, -0.10033943f, 0.04500207f, 0.14986974f, -0.03657508f, 0.04499073f, -0.15077108f, 
    0.01628161f, 0.14249378f, 0.04961104f, -0.16344570f, -0.10730650f, -0.09649727f, 0.04533868f, 0.04621354f, 
    0.01339631f, -0.56668711f, 0.26586935f, 0.38544825f, -0.04882101f, 0.15909983f, -0.15935689f, 0.05920745f, 
    0.13223732f, 0.11004028f, 0.23163480f, -0.08360141f, -0.09226567f, 0.00264711f, 0.00325757f, -0.11254624f, 
    -0.03139365f, -0.01766257f, 0.19771470f, 0.00701695f, 0.19857499f, 0.11475524f, 0.05732546f, 0.13300198f, 
    -0.17632960f, 0.01476962f, -0.31732646f, 0.16128348f, 0.07205851f, 0.04941089f, 0.04741335f, -0.11596593f, 
    0.06045367f, -0.09724689f, -0.10089148f, -0.12937213f, 0.37850177f, 0.40050298f, 0.21359949f, -0.17128502f, 
    -0.01755899f, -0.16707259f, 0.11078452f, 0.03086285f, 0.10671304f, -0.04129766f, 0.04231770f, 0.07070727f, 
    -0.21540672f, -0.09523565f, -0.06870382f, -0.15573214f, 0.07089952f, -0.08277769f, -0.08775232f, -0.08227633f, 
    0.04874223f, 0.06038581f, 0.04874673f, 0.00299940f, 0.07657318f, -0.13933600f, 0.02680008f, 0.30967852f, 
    -0.05439113f, 0.05670220f, -0.02279420f, 0.09096700f, -0.10320388f, 0.20098382f, 0.25069273f, -0.03442111f, 
    -0.16265891f, 0.10784960f, 0.21842586f, 0.08943702f, -0.11267190f, -0.09300847f, -0.06259500f, -0.02610587f, 
    -0.00377285f, -0.02670500f, 0.10634270f, 0.04563275f, 0.59960049f, 0.00463838f, 0.22330007f, -0.54260677f, 
    0.20861864f, 0.01999214f, -0.06008779f, -0.07382298f, 0.12515077f, 0.07603894f, -0.06178694f, -0.01745906f, 
    0.12013561f, -0.05485479f, -0.03751609f, 0.21678418f, -0.02623472f, 0.05161087f, 0.16600761f, -0.00456168f, 
    -0.00140003f, 0.01211180f, 0.00514401f, -0.10204851f, -0.18548599f, 0.11909614f, 0.00945774f, -0.03529457f, 
    -0.01539587f, 0.05724099f, 0.14717713f, 0.20451762f, 0.00014432f, -0.09999263f, -0.12316453f, -0.05512032f, 
    -0.14851619f, 0.01358259f, 0.36886919f, 0.17338400f, -0.07684854f, -0.17413458f, -0.12182393f, 0.10964239f, 
    0.02141986f, 0.14068420f, -0.05656195f, 0.09124819f, -0.10598765f, -0.06762069f, 0.07215324f, 0.09336180f, 
    0.02985228f, -0.03972714f, -0.17606057f, -0.00359595f, 0.03576908f, 0.05979295f, 0.01903965f, 0.05523504f, 
    0.23639500f, -0.14809197f, -0.06299815f, 0.08962743f, -0.00928544f, -0.02770569f, -0.06519789f, -0.09072373f, 
    0.12878212f, 0.08531922f, 0.03602012f, -0.02334366f, -0.37943003f, -0.28892708f, 0.25541165f, 0.10448045f, 
    -0.07773482f, 0.00387198f, -0.18025047f, -0.04747374f, -0.08804725f, -0.00347648f, -0.08351583f, 0.03214176f, 
    -0.16826405f, -0.05828616f, 0.23841527f, 0.09212781f, -0.08283699f, -0.01927002f, -0.11427676f, 0.02161475f, 
    0.08810864f, 0.01787764f, -0.03947230f, -0.02685605f, 0.32684940f, 0.11468210f, -0.10255777f, -0.06207781f, 
    -0.08107203f, -0.06485251f, -0.15403233f, -0.00136376f, 0.10873117f, -0.08991485f, 0.08995755f, 0.06295994f, 
    -0.29653016f, 0.38806713f, 0.25645414f, 0.14975022f, 0.12924474f, 0.01119039f, 0.10478753f, -0.22834483f, 
    0.00472287f, -0.03678710f, 0.10354235f, 0.13385430f, -0.18612935f, -0.14348353f, -0.26909211f, 0.15093482f, 
    -0.07868411f, 0.00557740f, 0.15766929f, 0.12212501f, -0.12907077f, -0.04188103f, 0.02681065f, -0.01319870f, 
    0.29124832f, 0.04214470f, -0.12886725f, -0.24496004f, 0.04476752f, -0.06241279f, 0.02096832f, -0.00687861f, 
    0.01542651f, 0.02540088f, 0.12544487f, 0.04573816f, 0.00570718f, 0.31541920f, -0.09436734f, 0.15138038f, 
    0.15184753f, -0.20570314f, 0.16679884f, 0.23644854f, 0.04827527f, -0.02915634f, -0.04243680f, -0.10034481f, 
    -0.04235282f, -0.36730969f, 0.22454402f, 0.18331270f, -0.04495267f, -0.04365682f, 0.12250294f, -0.25523409f, 
    0.00665073f, -0.10585444f, -0.03414767f, 0.02569389f, -0.21292098f, 0.23052157f, 0.05546682f, 0.08376076f, 
    -0.00412408f, 0.03318014f, 0.13527496f, 0.18513027f, 0.16391017f, 0.14301597f, -0.15987737f, 0.11368852f, 
    -0.18408066f, -0.06810693f, 0.10464062f, -0.09482908f, -0.04078994f, -0.14987703f, 0.15015450f, 0.01644167f, 
    -0.04429212f, 0.18895949f, 0.05209994f, -0.08242030f, -0.11941811f, 0.11017519f, 0.19029614f, 0.36521256f, 
    0.07769302f, 0.07768840f, 0.08824837f, 0.04774160f, 0.09299274f, 0.04587620f, -0.04016979f, -0.17857146f, 
    0.32532302f, 0.00108710f, -0.04805867f, 0.09818406f, -0.05408775f, 0.19050381f, 0.10197671f, 0.13429473f, 
    -0.05558072f, 0.15370625f, 0.00679425f, -0.09030694f, -0.09919373f, -0.10366515f, 0.23822246f, 0.21385831f, 
    0.13428490f, -0.18282038f, 0.08243669f, -0.05495880f, 0.07923215f, 0.07265591f, 0.14463015f, 0.06298308f, 
    -0.35126558f, 0.06117880f, 0.13174497f, 0.02863849f, -0.00953439f, -0.12372844f, -0.21628416f, -0.07996868f, 
    0.06100568f, 0.24373887f, 0.03177777f, -0.04309352f, -0.43720827f, 0.02634947f, -0.17071766f, -0.11915146f, 
    0.03553674f, -0.18883725f, -0.01458862f, -0.13042139f, -0.01595839f, 0.05620323f, 0.16837847f, 0.07913385f, 
    0.17617565f, 0.23459406f, -0.38479021f, 0.12625624f, -0.03539088f, -0.11389134f, 0.09583569f, 0.03711729f, 
    0.00372670f, 0.07420934f, -0.05459058f, -0.09019184f, -0.10218915f, -0.05197909f, 0.01448279f, 0.07582364f, 
    -0.10401887f, -0.11909643f, 0.03338296f, -0.05862198f, -0.07856926f, -0.07511918f, -0.06629241f, -0.04882018f, 
    -0.27856269f, -0.08707736f, 0.08774112f, -0.02103771f, 0.00409110f, -0.12308237f, -0.09948825f, -0.01037388f, 
    -0.14071229f, 0.07617907f, 0.01946882f, 0.05403804f, -0.06931694f, 0.00527108f, -0.04505858f, -0.04335829f, 
    -0.02611830f, 0.05778779f, -0.00326962f, -0.07465906f, -0.02758012f, 0.11898711f, -0.05768045f, -0.12821847f, 
    0.02500458f, -0.29576495f, -0.09460659f, 0.16447274f, 0.06250598f, -0.02580599f, 0.38318732f, -0.05914359f, 
    0.04344944f, -0.06183729f, -0.07062707f, 0.00057732f, -0.09268580f, 0.18597914f, -0.15937857f, -0.05486734f, 
    -0.12160695f, -0.09203358f, -0.16888760f, -0.28968233f, 0.09175545f, -0.07382334f, 0.01096331f, 0.01362460f, 
    -0.33247072f, 0.18885642f, 0.08648042f, -0.25650263f, 0.08814931f, -0.05102182f, 0.07420414f, -0.11589248f, 
    -0.11519996f, -0.03464040f, 0.04531604f, 0.07617858f, -0.02541518f, -0.07448843f, 0.11448388f, -0.28271759f, 
    -0.03266916f, -0.09974263f, 0.16172780f, -0.07227599f, 0.01633037f, 0.07855217f, 0.20784841f, -0.14523254f, 
    0.10887185f, -0.14977892f, -0.08486952f, 0.04043325f, -0.00536404f, -0.03183137f, 0.02968821f, 0.10222240f, 
    -0.04370014f, 0.06273905f, -0.00032011f, -0.16132209f, -0.09312310f, 0.42884398f, -0.28029957f, 0.21558949f, 
    -0.00184858f, 0.09891991f, 0.00941972f, -0.06867578f, -0.11175258f, -0.10444839f, -0.14055489f, -0.05840872f, 
    -0.03035243f, 0.29561022f, -0.10018364f, 0.02053657f, -0.13656884f, 0.01814578f, 0.25342092f, 0.04858424f, 
    -0.09828807f, -0.00104135f, -0.00934146f, 0.02757156f, 0.44187331f, 0.02351980f, -0.05087700f, 0.51746875f, 
    0.05233587f, -0.12525304f, 0.00246770f, 0.01136798f, -0.12305189f, 0.13172744f, -0.04534917f, -0.01101322f, 
    0.36968797f, 0.32111800f, -0.03514177f, 0.14768913f, 0.05145604f, -0.02787184f, -0.01963904f, 0.06745139f, 
    -0.06062047f, -0.03535287f, -0.03108675f, -0.03356066f, 0.02988872f, 0.18061063f, 0.18180385f, -0.13134094f, 
    -0.06514669f, -0.00022931f, 0.19616356f, 0.15787670f, -0.12994739f, 0.06413259f, 0.23469910f, -0.00115032f, 
    0.08595173f, 0.03080739f, 0.05773804f, 0.08633982f, -0.18352281f, -0.04118977f, -0.08294920f, 0.00126071f, 
    0.09278723f, 0.00623961f, -0.09332503f, 0.14705211f, -0.15657663f, 0.06415858f, -0.22791998f, 0.18298745f, 
    0.08342624f, 0.00804625f, -0.00467741f, -0.25635827f, -0.01686413f, -0.01359288f, -0.08527816f, 0.07147540f, 
    0.23201264f, 0.16762462f, 0.18673697f, 0.02533087f, -0.06204899f, 0.08992502f, -0.05370118f, -0.02371426f, 
    0.00939521f, -0.12229142f, -0.15693454f, -0.06889630f, 0.02631655f, -0.05031494f, 0.07696407f, 0.09952239f, 
    -0.05542710f, 0.16549930f, -0.11690588f, -0.12031182f, -0.22509713f, -0.01405966f, 0.01900238f, -0.00208421f, 
    0.17101379f, 0.17660543f, 0.10895962f, 0.18284325f, -0.08081077f, -0.03359126f, -0.17204668f, 0.10721760f, 
    0.01971105f, -0.01349806f, 0.05185025f, -0.07057417f, 0.18333665f, 0.28345793f, -0.05179810f, -0.04081419f, 
    0.01535955f, -0.13649486f, -0.13991407f, -0.03709323f, -0.06876785f, 0.03039280f, 0.03924322f, 0.02260251f, 
    0.52886605f, -0.16718237f, -0.20928019f, 0.05436377f, 0.11563544f, -0.05743645f, 0.11921386f, 0.15901196f, 
    0.11194346f, -0.16128099f, -0.06083397f, -0.04724152f, -0.17068040f, -0.17356665f, -0.28806624f, -0.04157096f, 
    0.08572426f, 0.05643316f, -0.37376481f, -0.26662922f, 0.09515079f, 0.02443022f, -0.06507255f, 0.05822115f, 
    -0.16761066f, -0.01833874f, 0.36312294f, 0.00603867f, -0.13243233f, 0.01127206f, 0.03750102f, -0.16814981f, 
    -0.07945872f, -0.07066855f, 0.07774170f, 0.03657999f, -0.04159083f, -0.26699960f, -0.19961329f, -0.25652349f, 
    0.11472611f, 0.01590802f, -0.16900286f, 0.10332839f, 0.08586392f, -0.01844322f, 0.21504411f, -0.03018310f, 
    0.09767479f, 0.02094851f, -0.21420325f, -0.16289826f, 0.07327250f, -0.02438093f, -0.07076250f, 0.09911703f, 
    -0.11583076f, 0.05892634f, 0.03888023f, 0.02804312f, -0.03842133f, 0.22600320f, 0.01227568f, 0.07210596f, 
    -0.09459107f, -0.03510537f, 0.07136960f, 0.04336191f, -0.28006771f, -0.03858843f, -0.17259468f, -0.10278556f, 
    -0.12468883f, 0.03706025f, -0.16252084f, -0.14826731f, 0.10157833f, 0.16861898f, 0.29100195f, 0.09061555f, 
    -0.00439363f, 0.10141852f, -0.02293034f, 0.04315766f, 0.55283767f, 0.04576671f, -0.32981345f, 0.32595932f, 
    -0.06633774f, 0.01369885f, -0.10705068f, 0.16943584f, 0.11302163f, 0.02299051f, -0.09405712f, 0.14896370f, 
    0.10016501f, 0.26559222f, 0.12618893f, 0.18607514f, -0.02501769f, 0.05864138f, -0.16913556f, 0.01531853f, 
    -0.00867749f, -0.01798991f, -0.14916958f, -0.03717185f, 0.02859726f, -0.06590395f, -0.05425553f, -0.17300169f, 
    0.13894317f, 0.06381444f, 0.27929565f, 0.03176592f, -0.06810838f, 0.05887223f, 0.08058351f, 0.14185402f, 
    0.12444761f, -0.12572765f, 0.16807072f, 0.13267758f, -0.19989350f, -0.18047941f, 0.04636968f, -0.06591511f, 
    0.07806800f, 0.07411752f, -0.13992828f, 0.08007582f, -0.03798176f, -0.02110003f, -0.00841815f, 0.12038465f, 
    -0.13802521f, -0.14177018f, -0.07268000f, -0.06833337f, -0.06460112f, -0.11511823f, 0.07644463f, -0.06031068f, 
    0.08504200f, 0.24450605f, 0.27749294f, 0.24742317f, 0.01878341f, -0.06121307f, -0.07636874f, -0.04868402f, 
    -0.03430871f, -0.01778392f, -0.09992355f, -0.00156681f, 0.06835075f, 0.05482837f, 0.00575830f, -0.11687840f, 
    0.05610570f, 0.13767955f, -0.00457548f, -0.06091941f, -0.15241940f, 0.07890024f, -0.08685144f, 0.15131758f, 
    0.13726774f, 0.20276003f, -0.04513424f, -0.06897749f, 0.03074285f, -0.05818845f, -0.00850321f, 0.07170014f, 
    0.10162120f, 0.08018266f, -0.05156500f, -0.05040175f, 0.10525262f, 0.20847027f, 0.06954659f, 0.14148645f, 
    -0.05570851f, -0.04653831f, -0.00824802f, 0.04303696f, 0.01604709f, -0.09710472f, 0.03254292f, -0.03622076f, 
    0.31041691f, 0.26310480f, 0.02229873f, -0.34992445f, 0.07594110f, 0.04999642f, -0.16026425f, 0.08001096f, 
    0.02242121f, 0.17716356f, -0.11154166f, 0.02061007f, -0.08243852f, -0.03458608f, 0.07058262f, -0.23374847f, 
    0.14246275f, 0.11595375f, -0.06443889f, 0.19523934f, -0.04573359f, -0.00140166f, 0.09374709f, 0.07652338f, 
    0.07190213f, 0.00925932f, 0.35147303f, 0.41715002f, -0.00733654f, -0.00872279f, -0.16870096f, 0.00819646f, 
    -0.01973390f, -0.07099816f, 0.02288033f, -0.01005161f, -0.24412332f, -0.19472499f, -0.33955592f, -0.15551238f, 
    0.07347592f, 0.10465248f, -0.11595988f, 0.19375440f, 0.05140794f, 0.07675219f, -0.00200825f, 0.02771103f, 
    0.14636968f, 0.46252307f, 0.10570481f, -0.04818916f, 0.12305653f, 0.15689972f, -0.03262201f, 0.02920187f, 
    -0.08148193f, -0.08941140f, 0.12035232f, -0.05158282f, 0.12019196f, -0.01276413f, 0.35460266f, -0.17850526f, 
    -0.08206675f, 0.03084361f, -0.06898606f, -0.07517412f, 0.01245007f, -0.03803899f, 0.01664107f, 0.00064782f, 
    -0.03991965f, -0.13059887f, -0.13476169f, -0.20348062f, 0.14795499f, 0.20280944f, 0.09992068f, 0.05712973f, 
    0.19481929f, 0.17006746f, 0.05117130f, -0.10538032f, -0.08312397f, 0.04902434f, -0.29419044f, -0.01911915f, 
    0.01781254f, 0.27939069f, 0.01359994f, 0.16689548f, 0.03694632f, -0.00145223f, -0.02200506f, 0.06610569f, 
    -0.25573066f, -0.05037770f, 0.00249675f, -0.11733046f, 0.06320342f, 0.01547030f, -0.02926980f, -0.07356235f, 
    0.08564239f, 0.06749605f, 0.04512682f, -0.01352313f, 0.10976540f, -0.10269401f, 0.00426184f, -0.00202807f, 
    0.06646334f, 0.08078392f, 0.01607393f, -0.05732187f, 0.05998647f, 0.04310239f, 0.04980787f, 0.06584542f, 
    0.37345803f, 0.26011816f, 0.00495978f, -0.12070161f, -0.03636878f, 0.05790244f, -0.01587447f, -0.07471476f, 
    -0.04229670f, 0.08024220f, 0.11787932f, -0.03983589f, 0.37486658f, -0.00623563f, 0.07983078f, -0.21026582f, 
    -0.08713217f, 0.00804719f, -0.04634099f, -0.02370241f, 0.02172737f, 0.00726282f, 0.19577709f, 0.02921473f, 
    -0.01909911f, 0.03034731f, 0.28184262f, -0.11662333f, 0.13806465f, -0.02800312f, 0.01653791f, -0.07599077f, 
    -0.05123707f, -0.15984800f, -0.04089580f, 0.02523032f, 0.17054127f, 0.26951104f, 0.08478173f, -0.13182014f, 
    0.23448628f, -0.03955546f, 0.05939116f, 0.17132489f, 0.07818046f, 0.04579797f, -0.04550077f, 0.10636017f, 
    0.16085026f, 0.10576586f, -0.18083625f, -0.32223615f, 0.06084723f, 0.13913201f, 0.10476875f, 0.07562114f, 
    -0.09038758f, -0.21825235f, -0.18639374f, 0.07329859f, 0.03349679f, -0.14140825f, 0.17817016f, 0.11781336f, 
    -0.03957564f, -0.03787607f, 0.09154993f, -0.04645311f, -0.03289196f, 0.05122497f, -0.05079104f, -0.08122105f, 
    -0.00351787f, -0.06353462f, -0.00391537f, -0.00744316f, 0.04993475f, -0.03886328f, -0.02325555f, -0.01567870f, 
    -0.05106849f, 0.04028621f, -0.05268045f, -0.05946242f, 0.04667172f, -0.07829488f, -0.06992690f, 0.02795123f, 
    -0.03692909f, 0.02401709f, -0.04813899f, 0.04527740f, -0.05839930f, 0.01743953f, -0.06015040f, -0.06349852f, 
    -0.00451813f, -0.03089114f, 0.01018049f, 0.03464370f, -0.02780076f, 0.06741263f, -0.04955789f, -0.05062857f, 
    0.05188245f, 0.03330258f, 0.00601855f, -0.05946731f, -0.05537613f, 0.01343398f, 0.06134377f, -0.02126545f, 
    0.05908424f, -0.06097884f, -0.05718194f, 0.04636194f, -0.06265365f, -0.07810809f, -0.03811818f, 0.05227104f, 
    -0.05763505f, 0.00970553f, -0.01883221f, 0.05154852f, -0.04352687f, 0.04412828f, 0.03176810f, -0.03179121f, 
    -0.00892010f, 0.04052424f, -0.01686455f, 0.00531648f, 0.02013227f, -0.07090133f, -0.03285828f, -0.03142737f, 
    -0.01340537f, 0.04020052f, 0.00583101f, -0.04077952f, -0.06000662f, -0.00558012f, -0.02926285f, -0.01040993f, 
    0.01662859f, -0.04706177f, 0.04823321f, 0.01008485f, -0.01615498f, -0.03541216f, -0.06720161f, -0.00616211f, 
    -0.02077070f, -0.02984170f, 0.06401037f, -0.03151748f, 0.04271923f, -0.05971353f, -0.03168104f, -0.06939270f, 
    -0.02620050f, 0.00297448f, -0.00275867f, -0.04451976f, 0.01608194f, -0.05607344f, -0.01683109f, -0.02436563f, 
    -0.06431630f, -0.04257503f, 0.02153961f, -0.02774846f, 0.02197814f, 0.04603997f, -0.04878542f, -0.07777391f, 
    0.02576315f, 0.01496912f, -0.06804065f, -0.05222716f, -0.06896558f, -0.04352243f, 0.02111981f, 0.02670979f, 
    -0.02183340f, -0.03704391f, 0.03879734f, -0.04535359f, -0.03051883f, -0.01374084f, 0.00723222f, -0.04307822f, 
    -0.06835646f, -0.02116308f, -0.05339617f, 0.01577491f, 0.03594164f, -0.07379434f, 0.03079360f, 0.04852986f, 
    0.05042131f, -0.06153898f, -0.02909053f, 0.02574330f, -0.06712800f, 0.03685362f, -0.02925288f, -0.05345157f, 
    0.02804414f, -0.05466320f, -0.02137914f, -0.06140254f, -0.01934094f, 0.07060054f, -0.06043006f, 0.07043206f, 
    0.00644240f, 0.05836982f, -0.06257369f, 0.05586186f, -0.00975845f, 0.01167095f, 0.03727313f, 0.05032145f, 
    0.03457600f, -0.01299402f, -0.02551690f, 0.03405869f, 0.03438851f, -0.00880105f, 0.02509614f, 0.03478881f, 
    -0.06710754f, -0.00041705f, -0.00740015f, -0.00465902f, 0.04112303f, -0.01770362f, 0.00895591f, -0.04171455f, 
    0.00370968f, 0.02419896f, 0.01115392f, -0.03872974f, -0.07555169f, -0.02092226f, -0.04750152f, -0.02919465f, 
    0.04234324f, 0.05584027f, -0.03353392f, -0.07259430f, -0.07611968f, -0.02137670f, 0.06131323f, 0.02107929f, 
    0.03272193f, -0.01353629f, -0.04456058f, 0.00371634f, 0.00958129f, -0.07435201f, 0.04547114f, 0.01225726f, 
    0.29953969f, 0.31883779f, 0.06470259f, 0.25528485f, 0.17678246f, -0.16902308f, -0.01161418f, 0.11546365f, 
    0.08607596f, 0.01116322f, 0.04289293f, -0.01114454f, -0.06748943f, 0.06178563f, -0.27577680f, 0.16753954f, 
    0.13441265f, 0.21663591f, -0.16197978f, 0.04802386f, -0.05707892f, -0.15192546f, 0.00788376f, 0.18282577f, 
    -0.02133093f, -0.02298170f, 0.12022597f, 0.08066560f, 0.06129600f, 0.06298435f, 0.10606015f, 0.16850072f, 
    -0.02688997f, -0.06594862f, 0.08436017f, 0.20631705f, 0.15975647f, 0.10329843f, -0.01682613f, -0.13772598f, 
    0.05041951f, 0.02032961f, -0.10541556f, 0.13215955f, 0.05391237f, -0.09518179f, -0.05934151f, 0.02463488f, 
    -0.16499285f, -0.06846161f, -0.22977680f, -0.05328508f, 0.05530397f, 0.11774675f, -0.16273664f, -0.14558899f, 
    -0.12044216f, -0.11362370f, 0.01018144f, 0.02957811f, -0.10125034f, 0.17756270f, 0.30980867f, -0.01787914f, 
    0.02567954f, -0.06533131f, 0.06699190f, 0.05262585f, -0.08664405f, -0.05397978f, -0.22306931f, -0.25285104f, 
    0.08707538f, 0.21647036f, 0.14419949f, -0.06915182f, -0.02027376f, 0.09404333f, 0.19020921f, 0.15866649f, 
    -0.02805063f, -0.00522535f, -0.21491151f, -0.12243310f, -0.19880839f, -0.02525371f, -0.09055740f, 0.01278439f, 
    -0.00198895f, 0.12904286f, -0.21083440f, 0.13841212f, 0.09629171f, -0.10665713f, 0.11108670f, -0.04577806f, 
    -0.56390452f, 0.07116477f, 0.21689859f, -0.06419927f, -0.09871300f, 0.05936150f, 0.15117478f, -0.01696768f, 
    -0.01369167f, 0.10695233f, 0.05014195f, 0.12929127f, 0.19649582f, -0.10914954f, 0.28478009f, 0.21019942f, 
    -0.03809983f, 0.02078339f, 0.25686786f, 0.01323200f, 0.11932557f, 0.12823133f, 0.21486489f, 0.17628022f, 
    -0.05922587f, 0.13800399f, 0.21743236f, -0.17688550f, -0.18844977f, -0.17136632f, -0.03460642f, -0.00295328f, 
    0.20729518f, 0.09570727f, 0.16079012f, -0.04433350f, -0.28262785f, -0.11657038f, -0.11563575f, 0.07204994f, 
    -0.29619321f, -0.10185841f, -0.11300929f, -0.18629302f, -0.08068526f, 0.03930199f, 0.03243619f, 0.04525623f, 
    -0.29698312f, 0.27539799f, 0.16554581f, 0.06631633f, 0.10525022f, 0.02770827f, 0.03136400f, -0.03922165f, 
    0.01867222f, -0.32258791f, -0.12101957f, -0.04665512f, -0.15081668f, 0.12620375f, -0.11203572f, 0.15877949f, 
    0.11358292f, -0.00526919f, 0.17499003f, 0.14824028f, 0.00096256f, 0.15494387f, -0.11915261f, 0.02278763f, 
    -0.02473192f, 0.18469968f, 0.02780451f, -0.28283098f, 0.06374924f, -0.07486875f, 0.02538460f, -0.05282591f, 
    -0.05645621f, -0.12276777f, -0.16039051f, -0.29454049f, 0.07284753f, 0.15994862f, -0.11418001f, 0.09250434f, 
    -0.12280782f, -0.18691175f, -0.03339187f, 0.04826396f, -0.05491534f, -0.15445492f, -0.22333245f, -0.11164934f, 
    -0.18510072f, 0.00532908f, 0.00363891f, -0.22510746f, 0.03356798f, -0.08655565f, -0.16718809f, -0.13896425f, 
    -0.11211625f, 0.05356901f, -0.14116614f, -0.06386796f, 0.09975262f, 0.06898273f, 0.15900853f, 0.12324060f, 
    0.13092116f, 0.13681926f, 0.08489057f, 0.14344494f, 0.11796144f, 0.25509283f, 0.15518129f, 0.05678069f, 
    0.05634918f, 0.02676344f, -0.23253234f, 0.21708804f, 0.11369384f, 0.03387911f, -0.10296665f, -0.05875000f, 
    -0.05209805f, -0.06454562f, -0.01673969f, 0.05110482f, 0.08916451f, 0.15072957f, 0.25867319f, 0.32036355f, 
    -0.01250621f, 0.07240153f, 0.06088124f, -0.02398653f, 0.04956947f, 0.29909918f, 0.06368194f, 0.22627500f, 
    0.03551719f, -0.02712490f, 0.10710444f, 0.33788007f, -0.07780454f, 0.06288420f, 0.06036173f, -0.06171865f, 
    0.10683265f, -0.00312511f, 0.03412016f, 0.06676921f, -0.17464377f, -0.09326882f, 0.06266175f, 0.14887233f, 
    -0.05825929f, 0.05025317f, -0.01656732f, 0.00282717f, -0.03983380f, -0.10234489f, 0.05902528f, 0.11123506f, 
    0.18666516f, 0.28556889f, 0.02545963f, 0.08301447f, 0.05546330f, -0.12825739f, -0.12331109f, -0.05459151f, 
    -0.00699731f, -0.06794735f, 0.24673487f, 0.28773618f, -0.45586121f, -0.11509602f, -0.03199625f, 0.23216510f, 
    0.02876105f, 0.30209422f, 0.31931213f, -0.09519574f, 0.00727471f, 0.03766651f, -0.16083960f, -0.06459731f, 
    -0.04900547f, -0.26796511f, -0.28011143f, -0.06512120f, 0.07119346f, 0.15456678f, 0.22357990f, 0.02016536f, 
    -0.00906016f, 0.01027218f, -0.05745593f, -0.01196361f, 0.14492548f, 0.12343541f, -0.09131877f, 0.03179432f, 
    -0.05628541f, -0.02705996f, -0.15975806f, 0.08813937f, -0.03507218f, -0.13021651f, -0.07000310f, 0.09131323f, 
    -0.01629952f, 0.17383996f, -0.05827964f, 0.09549263f, 0.16304031f, 0.12238222f, 0.00769878f, -0.07887211f, 
    -0.25303394f, -0.18536004f, -0.03346343f, 0.11177590f, -0.02999706f, -0.02890089f, 0.10903420f, 0.09689345f, 
    0.11364940f, 0.07887046f, 0.02397080f, -0.06244812f, -0.02470705f, 0.06390549f, -0.07298539f, 0.08718888f, 
    -0.05151724f, -0.20175537f, -0.04213565f, -0.06370016f, -0.07490474f, -0.00407870f, 0.06868915f, 0.01785165f, 
    -0.15546443f, -0.01404517f, 0.12939803f, 0.09877063f, 0.09622504f, 0.00359974f, -0.03824813f, 0.02392182f, 
    -0.01380967f, 0.01689262f, -0.00076876f, 0.09336785f, 0.04933854f, -0.03082267f, 0.00118438f, 0.03311880f, 
    -0.04612908f, -0.07639193f, -0.06643391f, 0.10596342f, 0.08894902f, 0.05893403f, 0.02036208f, -0.09134737f, 
    -0.05341253f, 0.08260792f, 0.22810066f, 0.15375212f, 0.13863663f, -0.14930052f, -0.09719593f, 0.07033707f, 
    0.06460010f, 0.06719904f, 0.11231668f, -0.13663319f, 0.02481547f, -0.07785497f, -0.11858948f, -0.03759879f, 
    0.03967751f, 0.13622460f, -0.11996344f, -0.03959791f, 0.25213912f, -0.10162426f, 0.21421853f, 0.13912842f, 
    0.11618787f, -0.11778504f, 0.08204590f, 0.03919832f, -0.00169846f, 0.11040740f, -0.14124233f, -0.07528333f, 
    0.05934503f, -0.08412444f, -0.09117272f, -0.18441986f, 0.04820331f, -0.00360815f, -0.04122211f, -0.00113285f, 
    0.00155412f, 0.06122601f, 0.29423693f, -0.30817500f, 0.05944934f, -0.06327102f, 0.12653129f, 0.13308403f, 
    0.08912483f, 0.10558047f, 0.09713233f, 0.19110438f, -0.03316419f, -0.16985209f, -0.05453606f, -0.03276883f, 
    0.18523856f, 0.07291000f, 0.00238730f, 0.06536822f, 0.10526198f, 0.04260504f, 0.16146047f, -0.01909835f, 
    0.01426315f, 0.09791134f, -0.28881642f, -0.24199302f, -0.16165404f, 0.03527401f, -0.15856643f, -0.03678026f, 
    -0.06168459f, 0.01286659f, -0.09174492f, 0.00847309f, 0.15695041f, 0.09953625f, 0.04047512f, -0.23451841f, 
    0.19028908f, -0.15274674f, -0.00077914f, -0.05981488f, -0.07903222f, 0.02859856f, 0.03471361f, -0.13799223f, 
    -0.09648131f, -0.17374349f, -0.13446091f, 0.04025225f, 0.01648009f, 0.26035753f, 0.13215753f, 0.20419912f, 
    -0.10396608f, 0.12025865f, -0.04522589f, 0.09708831f, -0.01616704f, 0.04633278f, 0.14084291f, 0.02269134f, 
    -0.02694957f, 0.00880901f, -0.01016426f, 0.05598669f, 0.05417006f, -0.04022030f, 0.17746864f, 0.06047243f, 
    -0.03653617f, 0.16902383f, 0.39888710f, 0.05272456f, 0.06556711f, -0.11598763f, -0.25826249f, -0.04920590f, 
    -0.03499832f, -0.03933356f, 0.04919590f, 0.11627958f, 0.17336075f, -0.00275284f, 0.00482968f, 0.01453730f, 
    0.03765291f, 0.07288965f, 0.05311578f, 0.00805076f, 0.17090069f, 0.01166874f, 0.18307164f, 0.07229604f, 
    -0.10856406f, -0.39878213f, -0.08998793f, -0.08610398f, -0.03813092f, -0.07335195f, 0.16476782f, 0.01560029f, 
    0.04370010f, 0.14143857f, 0.22881231f, 0.07716414f, -0.29743287f, 0.03057967f, -0.43387216f, -0.23250334f, 
    -0.08665748f, -0.20741905f, 0.01131324f, -0.28991789f, 0.05445467f, 0.00143365f, 0.05492130f, 0.11512579f, 
    -0.11214687f, 0.40327016f, 0.23454687f, 0.02660757f, -0.04179152f, -0.07998263f, -0.01843614f, -0.04197778f, 
    -0.30924463f, -0.04465621f, -0.21589927f, -0.08493072f, 0.26054752f, 0.10745708f, -0.14558220f, 0.01263281f, 
    0.08642614f, 0.01647027f, 0.19353582f, -0.20810814f, -0.03043996f, 0.11830174f, -0.13878129f, -0.04968455f, 
    0.11732571f, 0.28100210f, -0.01617579f, 0.01932515f, 0.14545797f, 0.01342634f, 0.04801185f, -0.11092600f, 
    -0.03866494f, -0.05285716f, -0.05833979f, -0.17130072f, -0.13758531f, 0.22054861f, 0.22279136f, 0.08417797f, 
    0.02249307f, -0.18508346f, -0.18696767f, 0.04967104f, -0.23567908f, -0.04837690f, -0.10076165f, -0.10316538f, 
    0.07869356f, -0.11898673f, 0.08871309f, -0.09140582f, 0.06381240f, -0.19843823f, 0.26656964f, -0.03448868f, 
    0.03748546f, -0.04344192f, -0.10230740f, 0.12464409f, -0.12948304f, -0.13219412f, -0.40526497f, 0.06775932f, 
    -0.00055668f, 0.06537499f, -0.04296385f, 0.09282349f, -0.20150356f, -0.15236138f, 0.04429705f, -0.06969336f, 
    0.19446582f, 0.05073021f, 0.17084852f, -0.21721351f, 0.09599439f, 0.10979357f, -0.10969596f, 0.00762664f, 
    -0.03427373f, 0.08513442f, 0.20520698f, 0.04911535f, -0.33040616f, 0.00526386f, -0.32799709f, -0.30127829f, 
    0.08725124f, -0.13702570f, -0.00578819f, 0.02006577f, -0.00489174f, -0.09359558f, 0.10170710f, -0.16093618f, 
    0.19510724f, 0.12847567f, -0.00105262f, 0.02881585f, 0.01546940f, -0.03059181f, 0.12783062f, -0.31801018f, 
    -0.09556144f, 0.07127022f, 0.00962018f, 0.02303859f, -0.26738912f, 0.08799548f, 0.13173340f, -0.07219469f, 
    0.03886380f, -0.09794942f, 0.14561862f, 0.07328227f, 0.22211540f, 0.14922939f, -0.06542041f, 0.07657338f, 
    -0.33197284f, -0.24160731f, -0.10683291f, -0.24322098f, 0.09101174f, -0.02049496f, 0.19768135f, -0.08330204f, 
    -0.00353575f, 0.23092780f, 0.01012381f, -0.12506203f, 0.14048514f, 0.03788383f, -0.16184804f, 0.29579645f, 
    0.02082304f, 0.06729108f, -0.21738620f, 0.17893012f, 0.08849490f, -0.01759036f, 0.00707689f, -0.15426512f, 
    0.44143581f, 0.17448615f, 0.08216061f, -0.07037680f, 0.11755957f, 0.01130142f, -0.02199921f, 0.13163483f, 
    -0.07510390f, 0.04484522f, -0.00945265f, 0.06426640f, -0.04463368f, -0.06182177f, 0.27230921f, -0.06503712f, 
    0.02633003f, -0.04460064f, 0.05131115f, -0.17779706f, 0.11151339f, 0.06138437f, 0.22332126f, 0.17153402f, 
    -0.07114041f, -0.18602560f, -0.13749073f, 0.03165735f, 0.02766599f, -0.02436429f, -0.22607702f, -0.11919795f, 
    0.01822270f, 0.30899900f, 0.04240413f, -0.03285511f, -0.14408220f, -0.10104515f, -0.18644935f, -0.01211276f, 
    -0.00946053f, -0.04893504f, 0.07329074f, -0.04787860f, 0.13413501f, 0.00622754f, 0.15844601f, 0.08849147f, 
    0.26624519f, 0.16650392f, -0.03678021f, 0.18486202f, 0.05128299f, -0.04259288f, 0.06289861f, 0.11043822f, 
    0.05155012f, -0.04188494f, 0.01162157f, -0.12443118f, 0.24835899f, 0.33616266f, 0.20893589f, -0.09179650f, 
    0.14453764f, 0.11307995f, 0.25030804f, -0.02162038f, -0.07950228f, 0.02749475f, 0.10136781f, 0.08428889f, 
    -0.04270623f, 0.02645917f, 0.03026971f, -0.21286586f, 0.03897278f, 0.15011822f, -0.10143881f, -0.08997991f, 
    -0.30891132f, -0.09725267f, -0.02163792f, -0.08295050f, -0.00329585f, -0.13592148f, 0.10464187f, 0.06929425f, 
    0.01268807f, -0.12793715f, 0.14846759f, -0.03416832f, 0.03821522f, 0.22508834f, -0.09779508f, -0.08676390f, 
    0.25930154f, 0.19613378f, -0.19649144f, 0.00453946f, 0.15368770f, -0.59654218f, -0.12800214f, -0.02354812f, 
    0.00525545f, 0.05642404f, -0.18168835f, -0.01146078f, -0.11173791f, 0.14514199f, -0.25997674f, -0.04126886f, 
    0.13812271f, 0.05759811f, -0.01561255f, 0.09650989f, -0.01667527f, 0.03473831f, -0.09034087f, 0.19275269f, 
    -0.04806934f, -0.10641418f, -0.21956317f, -0.13310263f, 0.18496689f, -0.08704484f, -0.06406005f, -0.10801132f, 
    -0.03799599f, 0.13703039f, 0.12305579f, 0.18144579f, 0.05908717f, 0.11049104f, 0.19439751f, 0.50965267f, 
    0.07227425f, 0.15279312f, 0.00639699f, -0.07222411f, -0.02120190f, -0.12683997f, -0.10261113f, -0.03323486f, 
    -0.00431121f, 0.19204637f, -0.07438763f, -0.15044455f, 0.16411987f, -0.09305343f, 0.04444084f, -0.02832118f, 
    0.01556595f, 0.04291072f, 0.02292790f, -0.15304808f, -0.28371605f, -0.01327768f, -0.12790208f, 0.15274209f, 
    0.08588881f, -0.05229272f, 0.06587662f, -0.02720884f, 0.12332492f, -0.09092665f, -0.22537895f, 0.20642398f, 
    0.23815423f, 0.30154270f, 0.16844222f, 0.17116007f, 0.12064777f, 0.03550791f, 0.09556255f, -0.08772232f, 
    0.23408462f, -0.00037555f, -0.03053245f, -0.03120424f, -0.49029949f, 0.08493631f, 0.06483685f, 0.17532825f, 
    0.08861070f, 0.27120954f, -0.24816903f, -0.07129414f, 0.02117156f, -0.19339989f, 0.08280648f, -0.00717913f, 
    -0.42219684f, -0.09241037f, 0.25002614f, -0.05102495f, 0.07879066f, 0.12181068f, -0.11628067f, 0.17804973f, 
    0.04801137f, 0.14018439f, 0.04475746f, 0.15499817f, 0.32420713f, 0.09087788f, 0.11690886f, 0.31971318f, 
    -0.05511470f, 0.09887585f, -0.15213744f, -0.13525905f, 0.00783558f, -0.05666170f, 0.11627036f, -0.01485695f, 
    -0.20716088f, -0.15951979f, -0.26526785f, -0.29131579f, 0.05911440f, 0.14122508f, 0.09251346f, 0.00788549f, 
    -0.12058158f, -0.04416812f, -0.08897753f, -0.03423966f, -0.07071999f, -0.01539106f, -0.21912815f, -0.03723614f, 
    0.08686369f, 0.05294685f, 0.12445166f, 0.14973103f, 0.06419024f, 0.07321308f, 0.03793466f, 0.07832980f, 
    -0.27663460f, 0.11178134f, -0.08731131f, -0.02854511f, -0.06724437f, -0.12001276f, 0.06897378f, -0.08316114f, 
    -0.01382415f, -0.07962262f, 0.04312237f, 0.00461501f, 0.13485762f, 0.18655187f, 0.20898387f, 0.28169489f, 
    0.02530367f, 0.03229122f, 0.21309364f, 0.15959069f, 0.06986031f, 0.08120490f, 0.07392309f, -0.01883573f, 
    -0.10425616f, -0.08884069f, 0.05699412f, 0.03910165f, -0.09011630f, -0.00605024f, 0.04183772f, -0.11831798f, 
    0.04687274f, -0.06702579f, 0.04677725f, 0.18806860f, -0.29082295f, -0.15631938f, -0.02152270f, -0.04760517f, 
    0.06366704f, -0.07242177f, 0.02784290f, 0.00925778f, 0.00393209f, 0.09112392f, -0.04764394f, -0.09360991f, 
    -0.12690604f, -0.25132161f, 0.20325266f, 0.37622544f, 0.22961380f, 0.12857202f, 0.14421102f, -0.05725648f, 
    0.06847923f, -0.08593953f, 0.11637262f, 0.07696996f, -0.14665575f, -0.07531743f, -0.16363375f, -0.09610511f, 
    -0.14104736f, -0.08763779f, 0.12848011f, -0.19453284f, 0.02683697f, -0.04958700f, 0.00620900f, 0.00096724f, 
    0.02393236f, 0.01913081f, -0.21105599f, -0.16672228f, 0.15553555f, -0.03854664f, 0.09667516f, -0.03461819f, 
    0.00158863f, 0.01041926f, 0.04219348f, -0.06056613f, 0.00401358f, 0.13726373f, 0.11723363f, -0.06062412f, 
    0.07257582f, -0.13992406f, 0.18169484f, -0.08448749f, 0.10669952f, -0.10391022f, -0.00877758f, -0.06656642f, 
    -0.03228110f, -0.27028471f, -0.04178192f, -0.06574052f, 0.00682938f, -0.09050889f, -0.06100306f, 0.05132396f, 
    -0.05452618f, -0.05534049f, 0.04453584f, -0.08334689f, 0.14051139f, -0.10860555f, -0.09916496f, 0.16211785f, 
    0.03859862f, -0.04661131f, 0.02919055f, 0.00621169f, -0.05508951f, 0.11287536f, 0.10577313f, -0.05295262f, 
    -0.05068516f, -0.00635367f, -0.07928956f, 0.11582787f, -0.04227857f, -0.11361197f, 0.13925184f, 0.08177575f, 
    -0.06279580f, 0.00470941f, 0.10291691f, 0.02795878f, 0.36522296f, 0.03198695f, 0.38765249f, -0.18600431f, 
    -0.04611166f, -0.20893490f, -0.07571903f, -0.14572375f, 0.05934742f, 0.05975052f, 0.12529290f, 0.00300596f, 
    0.40619010f, 0.04132628f, 0.10608985f, 0.16038944f, 0.03028764f, -0.05174720f, -0.07672516f, 0.09885430f, 
    -0.01070807f, 0.03164183f, -0.00860152f, -0.02301077f, -0.09167136f, -0.03770363f, -0.06673965f, -0.02325809f, 
    -0.00829634f, 0.02866112f, 0.06082738f, 0.06827941f, -0.08302007f, -0.05357827f, 0.02682955f, -0.04050330f, 
    -0.19405103f, -0.11183053f, 0.02387811f, 0.13883194f, -0.06726781f, -0.05759491f, 0.00707910f, -0.02102726f, 
    0.05155489f, 0.07973791f, -0.05558189f, 0.11189771f, -0.25779688f, -0.01429003f, -0.09180542f, 0.00145605f, 
    0.08274970f, 0.01285233f, -0.01199063f, 0.00849301f, -0.06476253f, 0.02297081f, 0.03650711f, 0.12898543f, 
    0.19807053f, 0.04287072f, -0.03505179f, 0.07798441f, -0.14951172f, 0.01627276f, -0.09335260f, -0.04524558f, 
    0.22538124f, 0.12280548f, 0.06757868f, -0.03449823f, -0.11708285f, -0.18851307f, 0.13903455f, -0.05142054f, 
    -0.24710366f, -0.12109184f, -0.10335720f, -0.19898614f, -0.22949542f, -0.13253550f, -0.10912763f, -0.16099684f, 
    -0.07847285f, -0.10908124f, 0.20484465f, 0.21795867f, 0.01384525f, -0.04209055f, -0.07265265f, 0.03809515f, 
    -0.01600486f, 0.04126874f, 0.07552271f, 0.05548256f, 0.07940549f, 0.26421291f, -0.06471764f, -0.03311994f, 
    -0.02443141f, 0.01125356f, -0.11568764f, -0.02457152f, 0.12878110f, -0.00244351f, 0.07823811f, -0.03350058f, 
    -0.50520730f, -0.14298664f, 0.35073274f, 0.20660004f, 0.25206190f, 0.01231461f, 0.17502514f, -0.15568814f, 
    -0.04868408f, -0.11643358f, 0.10107532f, 0.12479483f, 0.19164753f, -0.14052495f, -0.15406615f, 0.07950115f, 
    -0.10120390f, -0.15680394f, 0.24475981f, -0.00848947f, -0.14646959f, 0.01941935f, 0.02729307f, 0.02459809f, 
    0.14616786f, 0.04784793f, -0.07865515f, -0.06419714f, 0.13275474f, -0.06369574f, 0.01568514f, -0.07675936f, 
    0.03806422f, 0.12117369f, 0.11794689f, -0.09078861f, -0.35228434f, 0.12634873f, 0.05685004f, -0.01056958f, 
    0.00628396f, -0.08772780f, 0.08879247f, 0.06593540f, -0.03577130f, -0.07837389f, 0.02983421f, 0.06189947f, 
    0.07337762f, 0.03490489f, 0.26280665f, -0.01305846f, -0.10940201f, -0.20673704f, 0.07914161f, -0.10524932f, 
    -0.01784148f, 0.09227107f, -0.05799090f, 0.02568350f, -0.19817415f, -0.03204255f, -0.04479214f, 0.01551715f, 
    0.01234242f, -0.11738368f, 0.17895402f, -0.01694451f, 0.22695337f, 0.18825583f, -0.00926357f, 0.00287780f, 
    -0.17980409f, -0.03989337f, 0.00933273f, 0.12536694f, 0.09876182f, -0.03923211f, 0.08744346f, -0.08155680f, 
    0.16969462f, 0.12348209f, 0.11646960f, 0.11835133f, -0.01084971f, 0.03828256f, 0.26524997f, -0.02230919f, 
    0.03129115f, 0.03271574f, 0.08944190f, -0.01019504f, 0.05033451f, 0.01824106f, 0.06050488f, -0.15390095f, 
    0.53273499f, -0.07094252f, 0.19432764f, 0.16279839f, 0.09225566f, -0.04552912f, 0.03376533f, -0.00382740f, 
    -0.03139976f, -0.11977472f, -0.03263925f, -0.10657028f, -0.00109632f, 0.12792028f, 0.05626670f, 0.06337563f, 
    0.02097823f, -0.10802397f, -0.08870175f, -0.09499731f, 0.10288280f, 0.08368204f, -0.03895794f, -0.03186206f, 
    -0.31804910f, -0.25470847f, -0.25368065f, 0.26534903f, 0.20409378f, 0.07530329f, -0.02864516f, -0.00830561f, 
    -0.01175604f, 0.01067110f, 0.11412578f, 0.01692732f, -0.25729242f, -0.07392044f, -0.29179037f, -0.06678481f, 
    0.09680098f, -0.11570762f, 0.06509007f, 0.03601046f, 0.14975923f, 0.14550191f, 0.09121413f, 0.10865592f, 
    0.22788852f, 0.18645558f, -0.10352904f, 0.21752228f, -0.01356112f, -0.08028524f, 0.09541113f, 0.02084236f, 
    0.10421131f, 0.11713514f, 0.13046423f, -0.02810915f, 0.02922118f, 0.00898094f, 0.18880531f, 0.08520570f, 
    -0.26967749f, -0.08346364f, 0.12221991f, -0.23473427f, 0.00914709f, 0.03067077f, -0.02187336f, -0.01130234f, 
    -0.11866175f, -0.03564848f, 0.22270447f, 0.19375002f, 0.10452795f, 0.01732009f, -0.06325856f, -0.14865519f, 
    -0.08282652f, 0.09755848f, 0.34138969f, 0.06680736f, 0.07481691f, 0.05793639f, 0.13381971f, 0.14140995f, 
    -0.00349247f, 0.08343300f, 0.12752572f, -0.12419265f, 0.07147283f, 0.06891095f, 0.00601093f, -0.08247968f, 
    -0.03857709f, 0.05222435f, -0.08045515f, 0.04013233f, 0.04700518f, 0.00926933f, -0.05607470f, 0.02443952f, 
    -0.06508376f, 0.06479144f, -0.05835090f, 0.01864081f, -0.05450785f, -0.06935794f, -0.08354167f, -0.02232268f, 
    0.03411765f, -0.00494855f, 0.04491546f, 0.01388280f, 0.05529292f, -0.02389585f, -0.04642506f, 0.00186450f, 
    -0.01935904f, -0.01261971f, 0.01439919f, 0.02435918f, 0.04197428f, 0.01190392f, 0.04715703f, -0.03123260f, 
    0.00011819f, -0.04698933f, 0.02968991f, -0.01773546f, -0.03115272f, 0.05141301f, 0.03955098f, 0.01469530f, 
    -0.07623810f, -0.05304293f, 0.05866005f, -0.01424879f, -0.01016754f, -0.07661756f, -0.02197689f, -0.00816632f, 
    -0.08058660f, 0.04107276f, -0.01605044f, 0.04187424f, 0.05452386f, 0.02623566f, 0.00648685f, -0.06087781f, 
    0.04435349f, -0.05339475f, -0.04783881f, -0.03762326f, 0.00631494f, -0.00219539f, -0.04499589f, -0.02628885f, 
    -0.07998816f, -0.07158049f, -0.05943208f, 0.00664014f, 0.03229132f, 0.02007273f, 0.05581779f, -0.07664993f, 
    -0.01270784f, 0.04092421f, -0.05552566f, -0.06579893f, 0.03871974f, -0.05274555f, -0.07372036f, -0.02356280f, 
    -0.00463472f, -0.06586356f, 0.04375941f, 0.01147496f, 0.04632289f, -0.04045415f, -0.00063052f, 0.04350438f, 
    0.06134296f, -0.03691389f, -0.00669559f, -0.00449266f, -0.07198286f, 0.03774180f, 0.04311054f, 0.02609646f, 
    0.01633311f, -0.05512223f, -0.05320083f, 0.01603453f, 0.02564691f, -0.04982232f, -0.06424552f, -0.03786603f, 
    0.02119785f, 0.00069003f, -0.06242669f, 0.05505274f, -0.06701767f, -0.08083786f, 0.00624588f, 0.00076095f, 
    -0.06798723f, -0.03516265f, 0.05338305f, 0.01933384f, 0.01109018f, -0.05447030f, -0.08072233f, -0.05575096f, 
    0.01580284f, 0.01350666f, -0.02977621f, -0.00076788f, 0.00449220f, -0.00115467f, 0.05580878f, 0.04860825f, 
    -0.03393226f, -0.03350395f, -0.05773599f, 0.05477053f, -0.07816666f, 0.00181329f, -0.07682844f, -0.00684095f, 
    0.04631402f, 0.03784937f, -0.02495644f, -0.04942646f, -0.05061834f, -0.07711877f, 0.01078598f, 0.04421315f, 
    0.00078517f, -0.07904990f, -0.00330046f, -0.07473705f, 0.02569981f, 0.03208543f, 0.01948296f, -0.03881643f, 
    0.04988467f, 0.01569820f, 0.02147211f, 0.04574550f, -0.07813151f, -0.07747980f, 0.05596206f, -0.03260068f, 
    0.02346680f, -0.05025100f, -0.01864956f, 0.03068309f, 0.01836478f, -0.05178975f, -0.01594447f, 0.04134548f, 
    -0.00557962f, -0.04241055f, -0.01440273f, 0.04788650f, -0.00292083f, -0.04416127f, 0.00199316f, -0.06173353f, 
    0.02601243f, -0.02666404f, -0.06165111f, 0.00381587f, 0.03413570f, 0.02796714f, 0.03433615f, -0.02470080f, 
    0.01595697f, -0.01164416f, -0.07044435f, 0.04736067f, -0.06864653f, -0.03860037f, 0.05748576f, -0.04543225f, 
    -0.02436128f, -0.04165751f, 0.06300738f, -0.04869069f, -0.02567293f, -0.07810846f, 0.03280079f, -0.07457647f, 
    -0.00448839f, 0.00805302f, -0.08469502f, -0.07021099f, 0.00453955f, -0.08382951f, 0.03563699f, 0.05931426f, 
    -0.05749507f, 0.06641249f, 0.02489754f, -0.02488435f, -0.08084699f, -0.02017432f, -0.07617922f, -0.01618988f, 
    0.04121388f, 0.02416554f, -0.01475012f, 0.00984089f, -0.04967302f, 0.03372449f, -0.04005714f, -0.07257856f, 
    0.04954594f, 0.05032204f, -0.03856010f, -0.00404996f, -0.04421469f, -0.08034100f, 0.05028429f, -0.04318363f, 
    -0.02137132f, -0.04642954f, -0.04700110f, 0.03403808f, 0.00822480f, 0.03725223f, -0.07302096f, -0.00367317f, 
    -0.01245664f, 0.03052250f, 0.04871752f, 0.04222464f, -0.02970812f, -0.07225942f, -0.01074122f, -0.01313978f, 
    -0.01377984f, 0.04930946f, 0.05892248f, -0.02363394f, -0.05412876f, -0.00862792f, -0.01943322f, -0.08275928f, 
    -0.02408394f, 0.01937431f, 0.06618400f, 0.05483854f, -0.02140159f, -0.02819497f, 0.03650698f, -0.07136995f, 
    -0.06075839f, -0.01255744f, 0.01612699f, 0.07190353f, -0.06589514f, -0.02509768f, -0.03798553f, -0.03824922f, 
    0.00772298f, -0.05959973f, 0.00862230f, 0.04242290f, -0.01108831f, -0.07301208f, -0.06518907f, -0.06201428f, 
    -0.08155370f, 0.01273697f, 0.04802714f, 0.03480254f, -0.07152273f, -0.07161531f, 0.03704618f, 0.01716123f, 
    -0.03996035f, -0.01163607f, 0.00533438f, -0.07153863f, -0.08671266f, -0.03616978f, -0.07719459f, 0.00044876f, 
    0.00790753f, 0.03934912f, -0.06222855f, -0.06554761f, 0.01935695f, 0.05267346f, -0.07298241f, -0.03433233f, 
    0.06056618f, -0.01685710f, 0.00377316f, 0.04194215f, -0.05672341f, -0.01023559f, -0.02473519f, 0.07228537f, 
    -0.08902050f, -0.00848818f, -0.08875214f, -0.00381041f, -0.07126355f, 0.03271454f, -0.05840459f, -0.02547687f, 
    0.04717727f, 0.03816568f, -0.06086361f, -0.07762804f, 0.04386451f, 0.00389010f, -0.08417153f, -0.10185651f, 
    0.02213753f, 0.05605852f, -0.06956910f, -0.04763002f, 0.03106496f, 0.03664364f, -0.02646298f, -0.02634859f, 
    -0.03115543f, -0.08669797f, -0.02861983f, 0.01883396f, 0.02810399f, -0.06309304f, 0.02816212f, 0.05154246f, 
    0.06418345f, 0.01028348f, -0.00413900f, -0.01264684f, -0.05716398f, 0.01810507f, -0.01873063f, -0.01904862f, 
    0.05712209f, 0.03277826f, -0.01991536f, -0.04613842f, -0.05155067f, -0.05129599f, 0.02691389f, -0.00853385f, 
    0.02306179f, 0.00224514f, -0.07120253f, -0.05641490f, -0.05691293f, -0.06026410f, 0.04626850f, -0.05613607f, 
    -0.08165936f, 0.01051238f, -0.01483008f, 0.06274706f, -0.06480322f, 0.02689424f, 0.04503028f, -0.01697292f, 
    0.02465388f, -0.03914370f, -0.04678572f, -0.02752506f, 0.03540639f, 0.01663149f, 0.01945374f, -0.01117812f, 
    0.15963261f, 0.15096721f, 0.02385830f, 0.14771405f, -0.07406999f, 0.10236014f, -0.15593500f, 0.24771981f, 
    -0.04475007f, 0.18882452f, 0.12851311f, -0.04574949f, -0.11034995f, 0.10959645f, 0.16826205f, 0.23365575f, 
    0.07509253f, 0.07484469f, 0.06247091f, -0.04483308f, 0.08502177f, -0.11430942f, 0.08703795f, 0.14726417f, 
    -0.13264392f, -0.02543462f, -0.41810080f, 0.04751169f, -0.05480016f, -0.18183221f, 0.08381586f, -0.10309599f, 
    -0.06304128f, -0.00223933f, 0.00521665f, 0.16578680f, 0.67657667f, 0.08137330f, 0.26416570f, 0.24586803f, 
    0.08644246f, 0.06272615f, 0.09519602f, 0.13968869f, 0.10024409f, 0.04825267f, -0.07398601f, 0.03116321f, 
    -0.29955512f, -0.36198446f, -0.13548583f, 0.04298005f, 0.13517022f, 0.04578763f, -0.24597122f, 0.07789306f, 
    0.09474751f, -0.06244496f, -0.04967656f, 0.03153425f, 0.02087286f, 0.10504391f, -0.01236778f, 0.10848041f, 
    0.03681701f, 0.08690579f, -0.13438581f, 0.12678550f, -0.12726668f, 0.14797918f, -0.01454496f, -0.09346109f, 
    0.31757697f, 0.38339749f, 0.30467495f, 0.24203159f, 0.01383012f, 0.01760712f, -0.08313724f, 0.16680922f, 
    0.03100660f, 0.04141853f, 0.04283775f, -0.02271846f, 0.02210292f, 0.18357609f, 0.02798362f, -0.12050210f, 
    0.14081506f, 0.01891094f, -0.09406488f, -0.04075962f, 0.07103898f, -0.09230370f, -0.04712031f, 0.06723321f, 
    -0.61120236f, -0.00894673f, -0.03160278f, 0.01042804f, -0.12600091f, 0.07540995f, -0.00900478f, -0.23441446f, 
    0.07243089f, -0.01879873f, 0.05940159f, -0.10755758f, 0.08140337f, -0.05084502f, -0.01111717f, 0.29410183f, 
    0.01224591f, 0.19448861f, 0.23712015f, 0.19486012f, 0.06728125f, 0.02444569f, -0.01611935f, -0.10853352f, 
    0.23322989f, 0.40907413f, 0.46450201f, -0.17058215f, -0.26700163f, -0.11923139f, 0.10759369f, 0.11431286f, 
    0.16517608f, -0.07141177f, -0.03734930f, 0.15371577f, -0.09404402f, -0.03168746f, -0.14016995f, -0.06657282f, 
    -0.35927093f, -0.06818257f, -0.28047425f, -0.05897306f, 0.00905040f, 0.07702912f, -0.07113642f, -0.04424576f, 
    -0.24834642f, 0.04598189f, 0.07052675f, -0.14616746f, -0.10243997f, -0.04135843f, -0.16426015f, -0.13342069f, 
    0.14734383f, -0.05193599f, 0.12749359f, 0.11023435f, -0.60791135f, -0.51412892f, -0.11443901f, 0.31887913f, 
    0.05087348f, 0.07432269f, -0.14783202f, 0.13906808f, 0.07467305f, 0.08879148f, 0.00504540f, -0.16071524f, 
    -0.14502779f, -0.11892787f, 0.03831635f, 0.09089057f, -0.07184604f, -0.04286795f, 0.09192862f, 0.15870711f, 
    0.21600924f, 0.15120310f, -0.02199024f, -0.07641251f, 0.20557538f, 0.13083622f, -0.15487047f, -0.05024881f, 
    -0.12949836f, -0.17754924f, -0.12771305f, -0.00999506f, 0.00582665f, 0.01406215f, 0.03213776f, 0.18994287f, 
    0.06672452f, -0.49192840f, 0.31938651f, 0.11063672f, -0.03293750f, 0.02547069f, -0.03947176f, 0.08635527f, 
    0.08543294f, 0.12735863f, -0.08870294f, 0.02332207f, 0.00340388f, -0.18947437f, 0.02000855f, -0.06360316f, 
    0.09476819f, 0.13700403f, 0.11781661f, 0.22996393f, -0.04557839f, 0.05132015f, 0.14306134f, 0.08499236f, 
    -0.14272280f, -0.10594206f, -0.12049054f, 0.34403041f, 0.09968872f, 0.20572443f, -0.10973728f, 0.08732137f, 
    -0.04378922f, -0.03300789f, -0.07382601f, -0.05096031f, -0.01634378f, 0.33067119f, -0.12379069f, -0.40407866f, 
    0.14595687f, -0.03516162f, -0.09764259f, 0.11612450f, 0.07401344f, 0.03812747f, 0.06631277f, -0.10753698f, 
    -0.00912685f, 0.23269740f, 0.00749018f, -0.24746190f, 0.06090521f, 0.06148693f, 0.00054821f, -0.26474956f, 
    -0.02062829f, 0.01566528f, 0.04632289f, -0.01205144f, 0.11692898f, -0.19735056f, 0.27938342f, 0.18222785f, 
    -0.09472070f, -0.10985330f, 0.05674932f, 0.12103470f, 0.15196267f, 0.10625996f, 0.06769637f, 0.03459245f, 
    -0.37129048f, 0.00476320f, 0.07709273f, -0.25177538f, -0.06731958f, 0.06338735f, 0.06948628f, -0.15118256f, 
    0.18501684f, 0.06263173f, 0.02944389f, -0.08949700f, 0.29540396f, -0.15986784f, -0.33881065f, -0.41244343f, 
    0.05537935f, 0.18435842f, -0.03192781f, 0.16595152f, 0.18345115f, 0.06306547f, -0.06156476f, -0.12708865f, 
    -0.05867048f, -0.22751485f, -0.31217167f, 0.07933488f, 0.16042356f, 0.17286721f, 0.21993704f, -0.02560372f, 
    0.05928038f, 0.04535860f, -0.00601413f, 0.00559236f, -0.11026604f, 0.01825422f, 0.08955862f, -0.11569958f, 
    0.03480728f, 0.14351369f, 0.07415123f, 0.03906567f, -0.03048357f, 0.01035672f, -0.05513379f, 0.09697864f, 
    -0.29405576f, 0.05027230f, 0.31423876f, 0.34318057f, 0.03020327f, -0.13731855f, -0.17200848f, -0.12326626f, 
    -0.04297683f, 0.24569014f, 0.05668630f, -0.01821008f, -0.05479150f, -0.13703635f, 0.20566350f, 0.16511029f, 
    -0.06717718f, -0.15460223f, -0.18058912f, -0.00076099f, 0.15708256f, 0.00528105f, 0.09409438f, -0.01312890f, 
    0.28098577f, -0.20517887f, -0.11898013f, 0.12216811f, 0.15242977f, -0.01821319f, 0.09570591f, 0.03043497f, 
    0.17054847f, -0.01430022f, -0.03364320f, -0.10041371f, -0.05503820f, 0.07524968f, 0.19741410f, -0.09813671f, 
    -0.00207097f, 0.09159889f, 0.11655889f, 0.09188047f, 0.02248845f, -0.02210055f, -0.06657121f, 0.13603707f, 
    -0.18001807f, -0.03716867f, 0.14746024f, -0.26790679f, -0.10715849f, 0.06133821f, 0.08863457f, -0.08936857f, 
    -0.02152898f, -0.00681928f, -0.17138660f, 0.10464998f, 0.03981674f, -0.13931079f, -0.11496960f, -0.10871171f, 
    0.06323911f, -0.08848811f, 0.17382880f, 0.07753222f, 0.06271888f, 0.06301299f, 0.05762873f, -0.04092206f, 
    -0.12180948f, 0.34775907f, -0.18386519f, 0.09516022f, -0.02234864f, -0.32311973f, -0.16392311f, 0.09456299f, 
    0.07530407f, -0.03480141f, -0.01200801f, 0.02148042f, -0.05388406f, 0.04743531f, -0.05368355f, 0.01071964f, 
    -0.02697973f, 0.24219982f, -0.14908037f, 0.01311345f, -0.04545212f, -0.17453887f, -0.03105339f, 0.04999042f, 
    0.07251726f, 0.12615697f, -0.34148163f, -0.12778214f, 0.19400598f, -0.06218382f, -0.13042641f, 0.08500773f, 
    -0.02761879f, 0.12147169f, 0.15248092f, 0.32247117f, 0.31417111f, -0.13047633f, 0.06986735f, 0.18304536f, 
    0.00653815f, 0.10092060f, -0.04707149f, 0.15335222f, 0.06261940f, -0.00177197f, -0.12148783f, 0.02477524f, 
    -0.35163596f, -0.31146282f, -0.17888214f, -0.04517909f, -0.16507770f, 0.06086449f, -0.24585561f, -0.03615937f, 
    0.11796624f, 0.06696072f, 0.11376156f, 0.09533043f, -0.03865441f, 0.01098798f, -0.03121925f, -0.11369437f, 
    0.07485151f, 0.03157111f, 0.10763315f, 0.16257231f, 0.01467562f, -0.19755715f, -0.05317388f, -0.22801158f, 
    0.26415429f, 0.30747387f, 0.15773126f, 0.27390155f, 0.10963884f, 0.11421853f, -0.07305116f, 0.16611785f, 
    -0.03098935f, -0.00702968f, 0.09006863f, -0.00267585f, -0.42096838f, -0.07957445f, 0.05106072f, 0.06510567f, 
    0.17399727f, 0.05615237f, -0.14088830f, 0.05581581f, 0.06938677f, -0.15186709f, 0.03276757f, 0.12379360f, 
    -0.39397064f, -0.06043692f, 0.15735127f, -0.11376315f, 0.07116018f, -0.02304072f, 0.00192438f, -0.01872925f, 
    0.03070861f, 0.02851839f, -0.02808226f, 0.12535581f, 0.20083505f, -0.01020652f, 0.13407224f, 0.41665003f, 
    -0.10022636f, 0.01701674f, 0.11242171f, 0.20819983f, 0.05029578f, 0.11635876f, 0.15514942f, 0.06671660f, 
    0.01111168f, 0.01180445f, 0.02588581f, -0.32418859f, -0.13389429f, 0.05965230f, -0.00909688f, 0.15078498f, 
    0.24270214f, 0.08531686f, 0.09191275f, 0.09839936f, -0.00417887f, -0.06032120f, -0.13690715f, -0.12941034f, 
    -0.03852176f, -0.10067385f, -0.01247812f, -0.07342084f, 0.08042184f, 0.16954663f, 0.06562787f, 0.07679716f, 
    -0.23446375f, 0.15770178f, 0.00704103f, -0.04537709f, -0.02911422f, 0.00086254f, -0.07015663f, 0.00827068f, 
    -0.16759789f, -0.29870746f, -0.12320186f, -0.15467735f, -0.23610133f, -0.14506042f, -0.10666179f, 0.25624135f, 
    -0.00065094f, -0.18512388f, -0.00810225f, 0.06200327f, 0.05488294f, 0.07548330f, -0.01077105f, 0.06830555f, 
    -0.31282184f, 0.00325364f, -0.02948767f, -0.00555567f, -0.10042218f, -0.04395789f, 0.07916501f, -0.04413597f, 
    0.16034834f, -0.00477626f, -0.01627157f, -0.12792100f, -0.03440802f, 0.20560791f, 0.01314078f, 0.01249024f, 
    -0.05037975f, -0.10647133f, -0.07438375f, -0.06392281f, -0.16946147f, -0.05613084f, -0.19810773f, 0.02572411f, 
    0.05840933f, 0.02949844f, 0.00140369f, 0.04249187f, 0.00323740f, 0.03898823f, -0.05636674f, 0.05550750f, 
    -0.05456022f, 0.03602475f, -0.01749865f, -0.06172285f, 0.04457374f, -0.05050804f, -0.04595776f, -0.01031531f, 
    -0.03205338f, -0.01346750f, 0.00223851f, 0.00939881f, -0.05135856f, -0.06550331f, -0.06185459f, 0.03010689f, 
    0.01911978f, 0.04242848f, -0.06458434f, -0.07031178f, 0.00403026f, -0.02149273f, -0.06394581f, -0.05299037f, 
    0.00575579f, -0.01217487f, -0.01840985f, 0.05853999f, 0.01241659f, -0.05031791f, 0.02491716f, -0.02038320f, 
    -0.03767404f, -0.01995721f, 0.01289199f, -0.00030405f, -0.01018027f, -0.07615780f, 0.03205997f, 0.00497640f, 
    0.01579169f, 0.02638362f, -0.04125073f, -0.00816047f, -0.02303332f, -0.03659007f, 0.05831852f, -0.02473360f, 
    0.05817304f, 0.03621165f, -0.03978522f, -0.03543607f, -0.06022441f, -0.07855311f, 0.04334995f, 0.04658899f, 
    0.04356660f, 0.06809031f, 0.01276797f, -0.01733051f, -0.00454873f, 0.00472790f, 0.05191566f, -0.05379575f, 
    0.04899235f, 0.05032293f, 0.01838877f, -0.02529670f, -0.03010974f, -0.01670589f, -0.07343177f, -0.01471575f, 
    -0.00510867f, -0.06459167f, -0.05579310f, -0.03482116f, -0.02387247f, -0.06394589f, -0.07641650f, 0.05842188f, 
    -0.06945775f, -0.03733515f, -0.03818765f, 0.04818367f, -0.02547019f, -0.06079482f, -0.01161956f, -0.05400632f, 
    -0.02255181f, -0.03833473f, -0.02990004f, -0.03731566f, -0.07840473f, 0.03534912f, -0.01520919f, 0.02760096f, 
    -0.01168888f, -0.04436504f, 0.01973297f, -0.01497633f, 0.04034947f, 0.04099512f, -0.01436539f, -0.05381918f, 
    -0.07596047f, 0.03877115f, -0.00408000f, -0.05984120f, -0.05049438f, -0.00691175f, 0.05284455f, -0.02328547f, 
    -0.04490803f, -0.02546353f, 0.01763641f, -0.02028302f, -0.04882871f, 0.00802162f, -0.00597954f, 0.04705737f, 
    -0.05234782f, -0.07064803f, -0.04141782f, -0.03029504f, 0.00388511f, -0.04650314f, 0.03933758f, -0.01255645f, 
    0.02334093f, 0.02316871f, -0.06157080f, 0.00895291f, 0.01116487f, 0.02768152f, 0.00444414f, -0.04327185f, 
    -0.04019538f, 0.00002440f, -0.05202452f, 0.01715437f, 0.06034962f, 0.00676565f, -0.05839945f, 0.04971958f, 
    -0.04306515f, 0.00528133f, -0.01491619f, 0.01079728f, -0.04989976f, 0.00625830f, 0.02638580f, -0.01595520f, 
    0.05367810f, 0.03528786f, -0.01926615f, 0.04332039f, 0.04191535f, -0.00673887f, -0.06664135f, -0.03725066f, 
    -0.03472751f, -0.03321700f, 0.04806630f, -0.05345655f, 0.00769740f, -0.06301891f, -0.02745371f, -0.00351384f, 
    -0.02814357f, -0.01669990f, 0.02105642f, 0.02193168f, -0.03184607f, -0.03846154f, 0.00899138f, -0.06969306f, 
    0.04869330f, -0.07155313f, 0.02780689f, 0.04638436f, -0.03193165f, -0.06384688f, 0.04292765f, -0.01787043f, 
    0.28224599f, 0.32579491f, -0.13126764f, -0.13553165f, 0.05616092f, -0.28980327f, 0.08840832f, 0.11002640f, 
    0.03264798f, 0.14783883f, -0.16259624f, 0.02257893f, -0.18597174f, 0.28907529f, -0.10818059f, -0.03459473f, 
    0.07015038f, 0.15056850f, -0.18370737f, -0.11080732f, -0.00690779f, -0.11807225f, -0.02425063f, -0.05482911f, 
    -0.00492981f, 0.01293089f, 0.18746164f, -0.03484668f, -0.04398008f, 0.09964023f, -0.11395102f, 0.10501379f, 
    -0.11166860f, 0.17097718f, 0.16325979f, 0.15532899f, -0.08906427f, -0.31476417f, -0.17964683f, -0.11820308f, 
    0.11927676f, 0.18253399f, 0.08242365f, 0.22129498f, -0.02046386f, -0.04166456f, 0.03746202f, -0.13243130f, 
    0.04002605f, 0.08330101f, -0.11888805f, -0.17503525f, 0.00053887f, 0.10139762f, -0.10055903f, -0.20781317f, 
    0.01007125f, -0.04649286f, 0.10492479f, 0.10806636f, 0.11123018f, 0.07898879f, 0.24260406f, -0.16967493f, 
    0.18057732f, -0.07318602f, 0.06014364f, 0.03057623f, 0.13523610f, -0.01620217f, -0.14127386f, -0.16292441f, 
    -0.06945259f, -0.06418762f, -0.11605439f, -0.15291233f, -0.01851817f, 0.22318415f, 0.10223486f, 0.20738688f, 
    -0.18810393f, 0.20872220f, 0.04257879f, -0.01862675f, 0.07425158f, -0.06976160f, -0.27737674f, 0.21707156f, 
    0.01989058f, 0.07969636f, -0.15100050f, 0.18620701f, 0.10268948f, -0.02719527f, 0.12946473f, 0.04182531f, 
    -0.13245396f, 0.12024381f, 0.05595836f, -0.21324036f, 0.04545582f, -0.11375597f, -0.09983237f, -0.07400038f, 
    0.07720047f, 0.14444472f, 0.02525134f, 0.06498862f, 0.13746934f, -0.01333589f, 0.04415067f, 0.08192033f, 
    0.09132036f, 0.07458393f, -0.03143560f, 0.06540224f, 0.02120162f, 0.11121865f, 0.23738132f, 0.14566116f, 
    0.16766855f, 0.03178907f, 0.00716012f, -0.15728574f, -0.09413452f, 0.09777859f, 0.04199241f, 0.02192232f, 
    0.18839899f, 0.19857311f, 0.20520313f, 0.08968734f, 0.10377887f, 0.07564489f, -0.16745611f, -0.24849810f, 
    -0.09797879f, -0.01841229f, 0.06057869f, -0.10013864f, -0.07941998f, -0.05393126f, 0.17231235f, -0.04020065f, 
    -0.10187677f, 0.28072569f, 0.12260351f, -0.09332928f, 0.10432714f, -0.04089212f, -0.07670695f, -0.10246185f, 
    -0.14637290f, -0.20131166f, -0.11254490f, -0.04385852f, 0.21262403f, 0.26692781f, -0.11494946f, -0.19380489f, 
    0.16830541f, 0.03310626f, 0.12699623f, -0.06047429f, 0.01580240f, 0.04216928f, -0.01601425f, 0.04204139f, 
    0.20011127f, 0.22401413f, -0.17129961f, -0.09794118f, -0.04744933f, -0.01596814f, 0.06119206f, -0.01012961f, 
    -0.11822578f, -0.14406374f, -0.19161478f, -0.20151271f, -0.07804118f, 0.06673491f, 0.15350984f, 0.08633496f, 
    0.01677230f, -0.10007435f, -0.11603395f, 0.02817702f, -0.23534930f, 0.15748614f, -0.09039161f, -0.09672891f, 
    -0.38207752f, 0.43915859f, 0.30419379f, -0.05977823f, -0.03639414f, 0.31200275f, -0.17002378f, -0.02645012f, 
    -0.01096927f, 0.01928230f, -0.05351461f, -0.01448711f, 0.03289734f, -0.35876653f, 0.11171801f, -0.03212789f, 
    0.09613588f, 0.13080440f, 0.08213518f, 0.17147475f, -0.01479775f, -0.02145297f, 0.00773774f, 0.06774721f, 
    0.47481263f, 0.10601082f, -0.25565460f, 0.22736274f, 0.06590607f, -0.00104250f, -0.13880955f, -0.06120854f, 
    0.06535418f, 0.06750576f, -0.04526094f, 0.02533559f, -0.17007394f, 0.14203244f, -0.01220383f, 0.03045720f, 
    0.12474481f, -0.10098162f, 0.10691801f, 0.25401324f, 0.06797362f, -0.03651811f, 0.01166744f, 0.02326450f, 
    -0.05646531f, -0.10849991f, 0.32941252f, 0.07524909f, -0.00100037f, 0.08896564f, 0.03882297f, -0.01708608f, 
    -0.01625598f, 0.00749007f, -0.02042094f, 0.02179222f, -0.03466003f, -0.07884433f, 0.36440828f, -0.07647402f, 
    -0.01246196f, 0.10050724f, -0.05889472f, 0.12062325f, 0.11339801f, 0.12620112f, 0.02372355f, 0.03732971f, 
    -0.10948579f, -0.10052501f, -0.05468547f, -0.09161990f, 0.08039778f, -0.02784466f, 0.02585621f, 0.06281754f, 
    0.13790256f, 0.06416349f, -0.01612940f, -0.06487101f, -0.01612231f, 0.02824730f, -0.04290928f, -0.01804303f, 
    0.03203437f, 0.05140956f, 0.16781224f, 0.12406567f, 0.18141963f, -0.06443454f, -0.06857354f, -0.08023340f, 
    -0.01741068f, -0.26308900f, -0.34556934f, -0.25994149f, 0.01373839f, 0.00465020f, 0.21337686f, -0.06948499f, 
    -0.04247725f, 0.06174330f, -0.05220776f, -0.07558421f, 0.01161623f, -0.18066111f, 0.04353279f, 0.13940309f, 
    0.06648485f, 0.04811286f, -0.09916428f, 0.01670411f, 0.05349779f, 0.12672281f, -0.01839599f, 0.14673063f, 
    0.07903876f, 0.28684059f, 0.06424090f, 0.17636898f, -0.02581089f, 0.00594355f, -0.20970033f, -0.16973490f, 
    0.03562568f, 0.03985725f, 0.16313362f, 0.04455959f, 0.02493183f, -0.13271031f, 0.13046806f, -0.13787340f, 
    0.10898115f, -0.15297550f, -0.15763387f, -0.05612021f, 0.03259100f, -0.11532664f, 0.18218553f, 0.16431713f, 
    0.15227194f, -0.14671084f, -0.14950007f, -0.00992980f, 0.05847402f, -0.08434133f, -0.05886754f, 0.00336712f, 
    0.17967547f, -0.09379552f, 0.01137908f, -0.08829518f, -0.09142260f, -0.10253707f, -0.02129474f, -0.02329737f, 
    0.06876923f, -0.07561199f, 0.08781111f, 0.06334309f, 0.14041980f, -0.02166829f, 0.09836339f, 0.25147918f, 
    -0.16770142f, -0.07827645f, -0.07174481f, -0.08808756f, 0.10634068f, -0.04992571f, -0.01456138f, -0.00613739f, 
    -0.05223443f, -0.05593422f, -0.00721201f, 0.04709355f, -0.04423397f, -0.13443126f, 0.05918906f, -0.05878140f, 
    -0.10672430f, 0.05737411f, -0.01734126f, -0.04835390f, -0.06611863f, 0.03075549f, -0.07628716f, -0.16318642f, 
    -0.18878621f, 0.59155965f, -0.02042257f, -0.07037966f, 0.23172957f, -0.03245956f, 0.02292839f, -0.02650612f, 
    -0.14225546f, 0.04630319f, -0.00968780f, 0.12366406f, -0.10937692f, 0.03128904f, -0.05149919f, 0.04272081f, 
    0.15546775f, 0.00384844f, 0.39048153f, 0.20580629f, -0.07291782f, 0.01547132f, 0.06212481f, 0.13877930f, 
    0.35877511f, -0.00514624f, 0.09766419f, -0.04997456f, 0.09038190f, -0.08581953f, 0.03593373f, 0.04461055f, 
    -0.13092917f, -0.03864726f, -0.16387199f, -0.02369434f, 0.10302804f, -0.02021951f, 0.14619040f, 0.51593816f, 
    -0.02135951f, 0.18333504f, 0.12472408f, 0.15917668f, -0.07086102f, 0.02260775f, -0.17493014f, 0.15310282f, 
    -0.03513976f, -0.09974973f, 0.18680649f, 0.21754594f, 0.07069784f, 0.00138210f, 0.05235953f, -0.02492991f, 
    -0.02054049f, 0.05185364f, -0.15591584f, -0.03259176f, -0.11330784f, 0.04931002f, 0.00865162f, 0.06020198f, 
    0.11678754f, -0.04855448f, 0.02773118f, -0.03552809f, 0.19584659f, 0.03995441f, 0.00382519f, 0.14220689f, 
    0.23923640f, 0.02781045f, 0.23101857f, 0.14642943f, 0.08931389f, -0.09754573f, -0.16827568f, 0.10659776f, 
    0.12652498f, 0.01035210f, 0.10278109f, 0.13303514f, -0.66569382f, 0.30080312f, 0.40794700f, 0.22268537f, 
    0.10797601f, 0.09296291f, -0.00536909f, -0.13516112f, -0.12308378f, 0.02466002f, 0.09741930f, -0.11642455f, 
    -0.12328402f, -0.18921658f, 0.35484642f, -0.01211249f, -0.11037848f, -0.06345576f, -0.07998572f, 0.08262157f, 
    -0.13791451f, -0.07142334f, -0.05703682f, -0.08771616f, 0.07646011f, -0.01959927f, 0.11189320f, 0.28394964f, 
    0.10612361f, -0.03733679f, -0.09055410f, -0.15442988f, 0.02820177f, 0.01689730f, -0.05821247f, -0.01729800f, 
    0.10476791f, 0.02573633f, -0.21715844f, -0.36225933f, 0.11286950f, -0.02095172f, 0.17625733f, 0.09314498f, 
    0.01928286f, 0.06318837f, 0.17579544f, 0.04953216f, -0.00341156f, -0.00106083f, -0.16057624f, -0.23541185f, 
    -0.02996341f, -0.12072121f, 0.13016769f, 0.12419212f, -0.10469887f, 0.00918774f, -0.06113979f, -0.00405749f, 
    -0.13089675f, 0.12507813f, -0.09585916f, 0.08219630f, -0.18260236f, -0.11669610f, -0.04535191f, 0.05766907f, 
    -0.08962589f, 0.22190651f, 0.01691107f, 0.17441444f, -0.05847781f, -0.02486373f, -0.24876744f, 0.11392321f, 
    0.07798738f, -0.11814008f, 0.11522059f, 0.01523916f, 0.00327320f, -0.03011995f, -0.02814060f, -0.11804469f, 
    -0.13723458f, -0.08827279f, -0.00270510f, 0.12831977f, 0.00322237f, 0.08828726f, 0.12940340f, 0.00281279f, 
    -0.02212558f, 0.00700127f, 0.16542639f, 0.12530801f, -0.01869832f, 0.10579234f, 0.21396849f, 0.04168399f, 
    -0.01164991f, 0.00668292f, -0.02731955f, -0.09887742f, 0.16789041f, 0.01350238f, -0.13407442f, 0.04037530f, 
    0.41638628f, -0.16044818f, -0.03066842f, 0.00259640f, 0.02452659f, 0.19253241f, -0.11739370f, 0.02359830f, 
    0.01335117f, 0.27969989f, 0.06668197f, -0.00999696f, -0.24186341f, 0.05290500f, 0.04347584f, -0.01988739f, 
    0.00987383f, 0.02248356f, 0.09642714f, 0.01980614f, 0.10452257f, 0.08593000f, 0.01162307f, -0.19678459f, 
    0.13193819f, 0.04907709f, -0.02371966f, 0.07452734f, -0.09649897f, 0.07782285f, 0.05879649f, 0.01026008f, 
    -0.01369122f, -0.04821431f, 0.06441914f, -0.17764653f, 0.18367866f, 0.10411351f, -0.11114391f, -0.05219562f, 
    -0.07071684f, -0.03482339f, 0.22565579f, 0.14731432f, 0.21728998f, 0.13371496f, 0.16393390f, 0.07643833f, 
    -0.32542253f, -0.26959133f, -0.08041232f, -0.23553459f, 0.13108414f, 0.08552797f, 0.05243813f, -0.01708796f, 
    -0.02585036f, -0.00919107f, 0.10182880f, 0.15315589f, 0.19087352f, -0.15063068f, 0.12873651f, 0.17850499f, 
    -0.03872991f, -0.00089287f, -0.09866199f, 0.11012810f, -0.05812412f, 0.03452032f, 0.31678262f, 0.04552421f, 
    -0.22517416f, -0.36938822f, 0.20105970f, -0.11990303f, -0.15860416f, -0.13802950f, -0.15101698f, 0.02315294f, 
    -0.05697127f, 0.16749641f, 0.21408843f, 0.07257060f, 0.31832513f, 0.05979408f, 0.22516409f, -0.20950072f, 
    0.14894208f, 0.10644770f, 0.04794619f, 0.10777001f, 0.02477259f, 0.06783309f, 0.01780552f, 0.07958512f, 
    0.10775319f, 0.13874300f, 0.02734082f, 0.03312960f, 0.00653776f, 0.02618472f, -0.06058672f, -0.10463981f, 
    0.01440567f, -0.00447327f, 0.03813983f, -0.00235025f, -0.34982532f, -0.28111020f, -0.07294521f, -0.24677980f, 
    0.02789137f, 0.14096260f, 0.06981704f, 0.26751551f, 0.00216006f, -0.02823552f, -0.01929404f, -0.05916329f, 
    0.14055471f, 0.12517467f, 0.10678741f, -0.06278457f, -0.08553656f, -0.12592891f, -0.05152966f, 0.00692937f, 
    0.07826299f, 0.02389923f, -0.12476324f, 0.05313419f, 0.21656527f, 0.03865650f, 0.08408567f, -0.22182189f, 
    0.01939716f, -0.12727219f, -0.13506226f, 0.01818808f, -0.00294344f, -0.07315709f, -0.10700431f, -0.09114517f, 
    0.16580619f, 0.00565311f, 0.04132917f, 0.07896800f, -0.07023336f, -0.05127258f, 0.02744234f, -0.09398212f, 
    -0.01421280f, -0.15124968f, -0.04421448f, 0.08724649f, -0.33909574f, -0.45797428f, -0.35530496f, -0.23380436f, 
    0.14960890f, -0.00201790f, -0.05712329f, 0.01043120f, 0.04235046f, 0.05927490f, 0.01269514f, 0.04300673f, 
    -0.20957559f, -0.29633904f, 0.01090758f, -0.03482497f, -0.11355693f, -0.08068743f, 0.06664579f, 0.26958367f, 
    0.03589310f, 0.10847422f, 0.04591797f, -0.03229868f, 0.16557266f, 0.08438848f, 0.08487146f, 0.07500634f, 
    -0.09367345f, -0.01164003f, -0.00172072f, 0.03294916f, -0.09070571f, -0.01812259f, 0.11776625f, 0.06509726f, 
    -0.19182740f, -0.44793287f, -0.02438294f, 0.39068341f, 0.22904487f, -0.06012648f, 0.22664748f, -0.01892754f, 
    -0.11659095f, -0.05301331f, 0.14987285f, 0.06507534f, 0.07666421f, 0.25917694f, -0.15119487f, -0.00589589f, 
    -0.08972973f, -0.13642767f, 0.24389386f, -0.16487280f, 0.01942580f, 0.06320145f, 0.02804548f, 0.20730785f, 
    -0.02252380f, 0.06244665f, -0.10048271f, -0.06284602f, 0.33508411f, -0.08186306f, 0.25359705f, 0.08141932f, 
    -0.01912248f, 0.09610829f, -0.01295589f, -0.15666844f, -0.07912684f, 0.32895866f, 0.31449875f, 0.01608396f, 
    -0.10847749f, -0.03021622f, 0.13808581f, 0.01012528f, 0.04168390f, -0.03789268f, -0.04979233f, 0.05038198f, 
    -0.11114346f, -0.09616711f, -0.06803091f, -0.10157086f, -0.11135468f, -0.08309859f, -0.03547517f, 0.16299382f, 
    0.06653523f, -0.01993671f, -0.08256859f, 0.00705839f, 0.02010772f, -0.00014579f, -0.05928772f, 0.34679461f, 
    0.25635755f, -0.16810066f, 0.06485067f, -0.04144790f, 0.01246859f, 0.09013784f, -0.04011765f, 0.00369394f, 
    0.11975295f, 0.15654193f, 0.05719859f, 0.21594311f, -0.08930021f, -0.15044519f, 0.05344712f, 0.03989775f, 
    0.03589186f, -0.16287673f, 0.12703289f, 0.00882683f, 0.03398830f, 0.04800132f, 0.48191711f, -0.02926444f, 
    0.00772781f, -0.19359311f, 0.01463993f, -0.05740867f, -0.14806136f, -0.08096135f, 0.15834527f, -0.03998167f, 
    0.34914276f, -0.03085576f, 0.29304391f, 0.24633393f, 0.02920539f, 0.08839781f, -0.09849966f, 0.13435696f, 
    -0.19942799f, 0.00033814f, -0.04298606f, -0.08665489f, -0.06835195f, 0.16987672f, 0.14482614f, 0.01831128f, 
    -0.06349318f, -0.01989586f, 0.10645698f, 0.03750842f, -0.03854037f, -0.09148082f, -0.08109785f, -0.28847992f, 
    -0.31795180f, -0.24852474f, -0.23181373f, 0.20198959f, 0.08213677f, 0.00426533f, -0.08977617f, -0.03040751f, 
    -0.08762866f, -0.06418961f, -0.11407487f, -0.15570877f, -0.32122657f, -0.06899025f, -0.34571964f, 0.18913965f, 
    0.11099785f, -0.01260041f, 0.09283280f, -0.11231000f, 0.03451465f, 0.09125898f, -0.05818048f, -0.11009095f, 
    0.10181414f, 0.03933100f, 0.03483446f, 0.13547781f, 0.02631794f, -0.09430408f, -0.03540838f, 0.05743258f, 
    0.04323618f, -0.00083103f, 0.03582271f, -0.06196884f, -0.15716915f, -0.21665619f, 0.20668755f, 0.16112264f, 
    -0.33162972f, 0.01977614f, -0.00253060f, -0.10950691f, -0.18144451f, -0.13206920f, 0.00669849f, -0.15725973f, 
    -0.01924340f, 0.02768302f, 0.28886026f, 0.31601286f, -0.04662049f, 0.03545447f, -0.02242064f, 0.04521791f, 
    -0.02650236f, 0.08597112f, 0.11482117f, 0.16925433f, 0.09869245f, 0.08615302f, -0.04743987f, 0.01480148f, 
    -0.04589363f, -0.08028119f, -0.14869057f, 0.01835035f, 0.08353291f, -0.00098272f, 0.03693493f, -0.06117328f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13350224f, 0.25100568f, -0.04931274f, -0.05085894f, -0.07067174f, 0.29549238f, 0.11017591f, 0.03694770f, 
    -0.06286111f, -0.03184553f, -0.05747095f, -0.04540633f, 0.01427970f, 0.00722574f, 0.06015183f, 0.07312221f, 
    0.00834762f, 0.04609971f, 0.12244769f, 0.05557226f, -0.01726371f, 0.05715060f, 0.04615952f, 0.17026940f, 
    0.08618943f, 0.16037455f, 0.02252617f, 0.08935644f, 0.09399324f, 0.05889801f, 0.03248565f, -0.00156541f, 
    0.07170080f, -0.07217986f, -0.01582646f, 0.11815069f, -0.06271202f, -0.10876719f, -0.06881868f, 0.09026136f, 
    0.19489521f, 0.10584724f, 0.05464742f, 0.16216135f, -0.01207445f, -0.04433729f, 0.16769183f, -0.16035460f, 
    0.16995347f, 0.00263688f, -0.07143012f, 0.27127168f, 0.13289772f, -0.01537673f, 0.04862769f, 0.06448126f, 
    0.22978467f, 0.09556178f, 0.02332844f, 0.02348615f, 0.09640934f, -0.00917623f, 0.17954774f, 0.13741949f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.15418193f, 0.35743818f, -0.09006817f, 0.04802900f, 0.03603588f, 0.38387874f, -0.04928039f, 0.05439707f, 
    0.00052408f, 0.21991585f, -0.16248989f, 0.15553087f, -0.13682450f, 0.01889458f, 0.17077138f, -0.31336963f, 
    0.01748785f, 0.12309255f, 0.00545859f, -0.09837481f, -0.18411615f, 0.01678848f, 0.12475686f, 0.02146936f, 
    0.08791396f, 0.07454912f, -0.10123529f, -0.06954490f, 0.01100518f, 0.10556507f, 0.16327921f, -0.22788149f, 
    0.38353345f, -0.12665336f, 0.18548527f, -0.08767726f, -0.07138849f, 0.06893975f, -0.07266719f, 0.13887121f, 
    0.55650514f, 0.07527316f, 0.23946796f, 0.03520270f, -0.23888902f, 0.09357853f, 0.16259256f, -0.05335544f, 
    -0.19136073f, -0.24065532f, -0.10222443f, 0.20436406f, -0.22340152f, -0.08444710f, -0.08032438f, 0.32256395f, 
    0.18994097f, 0.33170459f, 0.01278384f, -0.06766416f, 0.22754440f, -0.07586573f, 0.18033442f, 0.05386834f, 
    0.21008840f, -0.25977302f, 0.03956512f, -0.06702720f, 0.02631498f, 0.07674406f, 0.28483775f, -0.01549682f, 
    0.16143410f, -0.40299344f, -0.26410639f, 0.21005479f, 0.04903989f, 0.03031899f, 0.25735977f, -0.00958523f, 
    -0.00917248f, 0.06323136f, -0.03904133f, -0.00162698f, -0.18141958f, -0.11773132f, 0.21538971f, -0.05114617f, 
    -0.14937098f, 0.01390432f, -0.19043152f, -0.06854193f, -0.05392759f, 0.16530235f, -0.18510637f, -0.12629476f, 
    0.15412566f, 0.30396959f, 0.11824462f, -0.09323095f, 0.01122642f, -0.10881465f, -0.04117371f, -0.03807737f, 
    0.03672751f, 0.20117888f, 0.14248306f, 0.02357339f, -0.20386332f, 0.12952597f, 0.01353035f, 0.14582893f, 
    -0.07366405f, -0.11419499f, -0.01126121f, 0.25044358f, 0.28847399f, 0.11590407f, 0.08508230f, 0.23620713f, 
    -0.21267733f, 0.08993395f, 0.08246440f, -0.04722841f, 0.03859212f, 0.24780633f, -0.04708882f, 0.08414990f, 
    -0.05086011f, -0.15306161f, -0.01614841f, -0.10047251f, 0.00167735f, 0.00214513f, 0.03017126f, -0.13025157f, 
    -0.04125851f, -0.14398646f, -0.20850253f, -0.11669674f, 0.07756586f, -0.04484010f, -0.05895746f, 0.09783803f, 
    0.11229570f, 0.11596843f, -0.08764308f, -0.00207491f, -0.23885642f, -0.05975772f, -0.02877248f, -0.05865492f, 
    -0.10223734f, -0.01730499f, -0.11356029f, -0.10020033f, 0.02725077f, -0.10720306f, -0.11703290f, 0.13988695f, 
    0.02863639f, 0.08701778f, -0.19610947f, 0.04863615f, -0.08195621f, -0.06474911f, 0.09811542f, -0.08552634f, 
    -0.09548911f, 0.16672106f, 0.03312816f, 0.07107341f, -0.05302917f, -0.04065640f, -0.22297731f, 0.01180147f, 
    0.12514590f, -0.00009776f, -0.21373385f, 0.10590088f, 0.14364594f, 0.03642825f, 0.10231926f, -0.05424563f, 
    -0.10113818f, -0.12715435f, -0.08722511f, -0.03372797f, 0.05074164f, 0.07203290f, 0.14103448f, -0.05588418f, 
    0.22561885f, 0.22538304f, 0.04611683f, -0.00800860f, 0.00329307f, -0.11936658f, -0.14022952f, 0.10170382f, 
    -0.06316507f, -0.01361263f, -0.01578891f, 0.19614248f, 0.03958559f, 0.07621174f, 0.03213916f, -0.36358687f, 
    -0.06490375f, -0.03569221f, -0.27310255f, 0.04716169f, -0.19724411f, -0.02882596f, 0.13319142f, 0.17056505f, 
    0.04333701f, -0.05659637f, -0.09717499f, -0.03871848f, 0.10769571f, 0.11555719f, 0.45484537f, -0.37400770f, 
    0.17231207f, -0.08665434f, -0.00408913f, 0.05373313f, -0.03323138f, 0.03429622f, -0.17118502f, -0.06505358f, 
    0.33306313f, 0.17955166f, 0.17128663f, 0.25412208f, 0.01520113f, 0.08297976f, 0.00482763f, 0.00917881f, 
    -0.11389913f, 0.18200926f, -0.11548152f, 0.16481623f, 0.11073963f, 0.01259143f, -0.01412385f, 0.08038925f, 
    0.39996403f, 0.08076694f, 0.08563520f, 0.01889048f, 0.10346207f, -0.26251882f, -0.00925723f, 0.04226733f, 
    0.10597830f, 0.22269946f, -0.00054977f, 0.08415843f, 0.14182699f, 0.04906826f, -0.00828752f, 0.12151708f, 
    0.09981922f, 0.28132421f, 0.05988972f, -0.12740323f, -0.18630186f, 0.07799723f, 0.15448692f, 0.28236431f, 
    -0.12338731f, -0.07152473f, 0.31617731f, -0.07809599f, 0.09145784f, -0.06791662f, -0.00196279f, -0.16164114f, 
    -0.14550735f, 0.02537615f, -0.00532796f, 0.07490925f, -0.06318182f, -0.24311702f, 0.20294192f, -0.01937299f, 
    -0.08480473f, -0.13870801f, 0.12956637f, -0.04862418f, 0.06034344f, -0.19293602f, 0.24213222f, -0.07773761f, 
    -0.17630467f, 0.02892489f, -0.09492420f, 0.02478355f, 0.31959605f, -0.07353699f, 0.20777410f, -0.02089657f, 
    0.30759665f, 0.19775929f, -0.08596411f, -0.21484925f, -0.18754877f, -0.05697598f, 0.07623339f, 0.02011633f, 
    0.16904216f, -0.12884727f, -0.11574068f, 0.16583090f, 0.14663030f, 0.10370242f, 0.16951375f, -0.20792150f, 
    -0.09282568f, 0.28811243f, -0.03587188f, 0.05445029f, 0.07599318f, 0.25310624f, 0.36743712f, 0.09142538f, 
    0.02279173f, 0.27495250f, 0.06206331f, -0.10597906f, -0.11978890f, -0.11264227f, -0.14879094f, -0.28674862f, 
    -0.07635777f, -0.09613540f, -0.03980195f, 0.01590818f, 0.04256595f, -0.07685950f, -0.11177006f, 0.05550046f, 
    0.13058877f, 0.23327717f, -0.10343503f, -0.00191732f, 0.20223087f, 0.21998192f, -0.20029280f, -0.18696743f, 
    0.22073832f, 0.04785817f, -0.01242458f, 0.12745345f, 0.11475185f, -0.20673595f, -0.33362699f, 0.06433603f, 
    0.31694132f, -0.10106813f, 0.27016389f, -0.01954834f, -0.29708424f, 0.00322749f, -0.10674008f, 0.14471021f, 
    0.02776936f, -0.32496172f, -0.05395954f, 0.25876176f, 0.06307259f, 0.12828238f, -0.07981795f, 0.20501846f, 
    0.00035582f, 0.20871787f, 0.03740374f, -0.17722917f, -0.12071653f, -0.10324360f, 0.05776210f, 0.30707347f, 
    0.20289809f, 0.22917072f, -0.00197377f, 0.04813449f, 0.09180050f, 0.18362528f, -0.02048950f, -0.07039369f, 
    0.09176420f, 0.38028640f, 0.07098319f, 0.10926187f, 0.03174879f, -0.11350378f, -0.10418665f, 0.04418023f, 
    0.00741325f, -0.20108615f, -0.16594921f, -0.06488590f, 0.12094170f, -0.02514788f, -0.09585494f, -0.13075422f, 
    0.09331669f, -0.03509491f, 0.15894014f, -0.03257139f, 0.04786945f, -0.01042621f, 0.49993351f, -0.08383367f, 
    0.00237796f, -0.07445921f, -0.24079162f, 0.16191888f, 0.04462396f, -0.26182234f, -0.26176438f, 0.07162774f, 
    0.23816533f, 0.21256863f, 0.16975270f, 0.07841706f, -0.09589677f, -0.10562271f, 0.02142056f, -0.05201062f, 
    0.30375549f, 0.22825563f, -0.07298745f, 0.16065027f, 0.31002590f, 0.03948926f, -0.05580704f, -0.22815679f, 
    0.38780969f, -0.33077729f, 0.03146672f, 0.04068009f, -0.20570110f, -0.07867198f, 0.11796552f, 0.29747203f, 
    0.12940679f, 0.23564909f, 0.00323835f, 0.04623392f, 0.10485334f, 0.00520330f, 0.06719462f, -0.08398631f, 
    -0.04008113f, 0.46839392f, 0.08293226f, -0.10032932f, -0.16196215f, 0.06058230f, 0.18344963f, 0.05904089f, 
    -0.03418945f, -0.17592943f, 0.04521025f, -0.01285489f, -0.12367106f, 0.13968641f, 0.03838883f, 0.02539229f, 
    -0.05308250f, -0.01964846f, -0.06279684f, -0.13591757f, 0.20179711f, 0.07287595f, -0.19433491f, 0.25910866f, 
    0.18824948f, -0.06953879f, -0.06125740f, -0.22259744f, -0.05705637f, -0.10922499f, 0.09693859f, -0.15443838f, 
    -0.08412268f, -0.11966989f, 0.07593901f, 0.18278566f, 0.11040496f, 0.10644732f, 0.05812639f, -0.02933040f, 
    0.17047827f, -0.19152077f, -0.06687649f, -0.05971198f, -0.20974615f, -0.03784162f, -0.12940241f, 0.23924363f, 
    -0.23756561f, 0.10327873f, 0.08059881f, 0.21130383f, 0.00859345f, -0.02564634f, 0.11777448f, -0.05358687f, 
    -0.17045154f, -0.03038653f, -0.01633458f, -0.09771331f, -0.26069605f, 0.41222793f, 0.18183939f, 0.12237881f, 
    -0.22777882f, -0.21867959f, 0.03891961f, -0.00753761f, 0.07899613f, -0.11500460f, -0.07595127f, -0.04116931f, 
    0.12692152f, -0.08125714f, -0.12692553f, 0.11669245f, -0.37331808f, 0.10910301f, -0.31231499f, -0.10574994f, 
    -0.01675494f, -0.08865301f, 0.04874225f, -0.07030927f, -0.06988376f, 0.06491918f, -0.21796565f, 0.03360233f, 
    0.10863690f, 0.27775589f, 0.16508055f, -0.14479363f, -0.06755111f, 0.07498355f, -0.39496005f, -0.01820504f, 
    -0.18106107f, -0.22232051f, 0.03954522f, -0.14814627f, -0.23138723f, 0.01018244f, -0.13776816f, 0.19685476f, 
    -0.31045935f, -0.28840756f, 0.20595932f, 0.04716300f, -0.12150017f, -0.08201800f, -0.12403345f, -0.16836153f, 
    -0.03329374f, 0.00359647f, 0.05988967f, -0.12903057f, -0.15779938f, -0.32768074f, -0.42007855f, -0.05506759f, 
    -0.28045607f, -0.17060129f, -0.03818529f, 0.03473533f, 0.30058065f, -0.37778002f, -0.32203117f, 0.08609265f, 
    0.01729232f, 0.19564539f, 0.11888458f, 0.11920609f, -0.14418334f, -0.02655461f, -0.26930359f, -0.14910334f, 
    -0.04545716f, 0.32382682f, -0.13527048f, -0.02473267f, 0.44334596f, 0.00518145f, 0.16129947f, -0.19044946f, 
    0.39090577f, 0.05190099f, 0.34391260f, 0.13175230f, 0.24340881f, -0.30445841f, 0.20603132f, 0.12890431f, 
    -0.00417285f, -0.04783593f, 0.27441007f, 0.24107870f, 0.09449434f, -0.01968630f, 0.14373122f, -0.03273437f, 
    0.03592436f, -0.20277557f, -0.14347103f, -0.18277702f, 0.24797195f, 0.00930628f, -0.22899152f, 0.12525445f, 
    0.19718006f, 0.03302653f, -0.04501495f, 0.01573629f, 0.31623787f, -0.04043232f, 0.05271814f, -0.09179382f, 
    0.23897144f, -0.18037485f, -0.01786756f, -0.11012053f, -0.02016000f, 0.07870623f, -0.04753846f, 0.07686499f, 
    -0.12927605f, 0.06510887f, -0.11441360f, 0.01357383f, -0.14754210f, 0.36482576f, -0.29968604f, -0.11119185f, 
    -0.23811129f, -0.16211857f, -0.39290968f, 0.06132523f, 0.02483408f, -0.09669299f, 0.00454330f, 0.02091424f, 
    0.14011355f, 0.06950642f, 0.17869298f, -0.09477568f, -0.05886546f, -0.12565225f, 0.11124223f, 0.20142990f, 
    0.14377339f, 0.20786956f, -0.19504827f, 0.31323573f, 0.11313329f, -0.27051294f, -0.06753559f, -0.00993939f, 
    0.24637678f, -0.01248767f, 0.01008356f, -0.12525530f, -0.06047624f, -0.25900695f, 0.26766169f, 0.28771508f, 
    0.37169495f, 0.20589921f, -0.37190118f, -0.28227976f, 0.09163785f, -0.00498994f, 0.03982154f, -0.05926256f, 
    -0.30029514f, -0.31748465f, 0.07457218f, 0.12493903f, -0.11939532f, -0.05970871f, -0.07139216f, 0.29066643f, 
    0.17842886f, 0.05154807f, 0.09264868f, -0.25269750f, 0.25711724f, 0.11357828f, 0.22115979f, -0.00713819f, 
    -0.11131497f, -0.04556425f, 0.08830837f, 0.02428763f, 0.10024729f, 0.11597257f, 0.06402329f, 0.03850495f, 
    0.31551442f, 0.32253268f, -0.01585088f, 0.08174747f, -0.28188595f, 0.08204950f, -0.17232013f, 0.11594900f, 
    -0.02955161f, 0.04495123f, 0.18338303f, 0.03677038f, 0.04895447f, 0.10727933f, 0.20642476f, -0.23871574f, 
    0.08482971f, 0.14611422f, -0.00932806f, 0.06389865f, 0.25094464f, -0.02152444f, -0.25080907f, 0.19810499f, 
    -0.01997388f, 0.09587790f, 0.12639093f, -0.12494151f, 0.10801519f, -0.12374424f, 0.15319501f, -0.23770382f, 
    -0.03604712f, -0.21947117f, -0.15074033f, -0.03220012f, 0.05798141f, 0.04116818f, 0.07575391f, 0.10885641f, 
    0.05232642f, -0.27302474f, -0.06149408f, -0.15106510f, -0.27910390f, 0.11072765f, -0.09638894f, 0.16281839f, 
    -0.20356061f, 0.01693094f, 0.03906454f, -0.08003369f, 0.02275029f, 0.20993911f, 0.12851749f, 0.10025907f, 
    0.14855517f, 0.42085564f, 0.04577630f, 0.09955013f, -0.00364538f, 0.58800775f, 0.17499863f, 0.06642526f, 
    -0.14339277f, 0.47699401f, -0.10190677f, -0.01177368f, -0.05992297f, 0.12234636f, 0.11879513f, 0.18986323f, 
    0.05981884f, 0.03619314f, 0.26397446f, 0.03290096f, -0.03740919f, 0.00693093f, -0.04228133f, 0.02352267f, 
    -0.16258740f, -0.02489862f, 0.13631827f, 0.18582024f, 0.01333755f, -0.07874182f, -0.04888837f, 0.02933244f, 
    -0.13645072f, -0.14351805f, 0.05477707f, 0.17473155f, 0.02807415f, -0.21293736f, 0.02824323f, 0.00122908f, 
    0.26516733f, 0.15508373f, -0.07033970f, -0.01067524f, -0.02238083f, 0.07405508f, 0.11361038f, -0.02883219f, 
    0.18225788f, 0.01488817f, -0.10626546f, 0.18669912f, 0.22418976f, 0.04189127f, -0.02030291f, 0.05224867f, 
    0.26910558f, 0.04497731f, 0.09783646f, -0.14552915f, 0.03750120f, 0.02425507f, 0.29503554f, -0.06345093f, 
    -0.14970523f, -0.06056555f, -0.06369004f, -0.11990689f, -0.03524030f, -0.39209285f, 0.13825212f, -0.12049855f, 
    0.12928820f, 0.05624606f, 0.09302454f, -0.14194818f, 0.04660734f, 0.08734718f, 0.01357146f, 0.01559040f, 
    0.02426725f, -0.17576031f, -0.05407642f, 0.09683606f, 0.02647895f, 0.03514645f, 0.13241355f, 0.07558640f, 
    -0.20049207f, 0.05574920f, 0.15653183f, -0.02478837f, -0.09831908f, 0.06956965f, 0.19759987f, -0.13904062f, 
    -0.07678957f, -0.33433923f, 0.03305465f, -0.16068237f, 0.10396281f, 0.09525725f, 0.06587226f, -0.07981210f, 
    -0.04762430f, -0.02092050f, -0.08092238f, -0.28165892f, -0.16412754f, 0.01202480f, -0.06075130f, -0.10425117f, 
    0.01283497f, -0.15853804f, 0.34014285f, 0.01837252f, -0.11672799f, -0.09818487f, -0.05226104f, -0.14678396f, 
    -0.26095062f, 0.06572020f, -0.06124845f, 0.02441894f, -0.25793865f, 0.06418472f, -0.24524380f, 0.09035376f, 
    0.10382786f, -0.14618221f, -0.08271307f, -0.07240997f, -0.11298002f, 0.10871111f, 0.03733681f, 0.06166608f, 
    -0.08022929f, -0.17652050f, 0.03142355f, -0.01736516f, 0.12180477f, 0.06348399f, 0.12558179f, 0.18545121f, 
    0.03152996f, 0.05234469f, 0.13014638f, -0.05362805f, -0.40877524f, 0.04110051f, -0.19760129f, 0.20514065f, 
    -0.05588954f, -0.41831928f, 0.15483426f, 0.16758837f, -0.08703823f, 0.02621114f, 0.16524515f, 0.31318122f, 
    0.29260981f, -0.10694872f, -0.24707355f, 0.01834199f, 0.05389806f, 0.06616448f, 0.12752810f, 0.09616739f, 
    0.22767936f, 0.02837436f, -0.08842858f, 0.20585936f, 0.32298195f, -0.10490310f, -0.26338789f, -0.18608961f, 
    -0.09410287f, 0.08165225f, -0.38554403f, 0.02294901f, -0.19043538f, 0.05316149f, 0.05454202f, 0.06183340f, 
    0.16571400f, -0.21981265f, 0.11722504f, 0.23848099f, 0.14643878f, -0.11227792f, 0.30303666f, -0.34501919f, 
    0.24086739f, 0.22440952f, 0.05612960f, -0.11715813f, 0.06396732f, 0.27675197f, 0.22352147f, -0.06129807f, 
    0.14789902f, 0.43303147f, 0.01804845f, -0.16988036f, -0.23029955f, -0.06777921f, 0.09968386f, 0.15138498f, 
    -0.00419701f, 0.02601824f, 0.27181283f, 0.01711280f, 0.04437337f, 0.00243674f, 0.03843891f, -0.03877252f, 
    -0.10337541f, 0.12240222f, 0.15173490f, 0.07255821f, -0.00953868f, 0.01998569f, -0.06785233f, 0.09419937f, 
    -0.12515867f, -0.10891275f, 0.07536557f, -0.09694958f, -0.06158809f, -0.04572050f, -0.10304619f, -0.11735541f, 
    0.01370596f, -0.03608102f, 0.08651485f, 0.16136813f, 0.00793636f, -0.11612537f, 0.14068015f, -0.13197725f, 
    0.28779775f, -0.14710505f, 0.07180255f, 0.15829225f, -0.10653690f, 0.05778730f, 0.05463115f, 0.26326120f, 
    -0.06334846f, 0.12491470f, 0.09124992f, 0.03787242f, 0.03937335f, 0.01151534f, 0.15733282f, -0.06966295f, 
    -0.11766562f, 0.04020197f, -0.11425373f, 0.01133631f, -0.09393537f, -0.00574082f, -0.00179011f, -0.00267737f, 
    -0.00823656f, -0.09263372f, -0.10927546f, -0.09481602f, 0.01547844f, -0.00590242f, -0.06354273f, -0.06467813f, 
    -0.02044842f, -0.03202055f, -0.08447368f, -0.08051974f, 0.03614369f, 0.05003749f, 0.09133520f, 0.09981775f, 
    0.09730092f, 0.06356190f, -0.06250604f, 0.06417249f, 0.01043465f, -0.01285440f, -0.07230008f, -0.04301869f, 
    -0.07266888f, 0.02178930f, -0.10663269f, 0.01763846f, -0.06305028f, -0.13743080f, -0.08153412f, 0.11832903f, 
    -0.00193006f, -0.10268472f, -0.05934791f, -0.10633452f, -0.10108797f, -0.06465659f, -0.03813551f, -0.12369584f, 
    -0.12338485f, 0.06306253f, 0.12605637f, -0.11503070f, -0.11874638f, -0.08518846f, 0.12382862f, -0.05111690f, 
    -0.01061200f, -0.10510740f, -0.05254893f, 0.06048321f, -0.10828067f, -0.04168014f, -0.12259997f, 0.08766732f, 
    -0.19090414f, -0.44643661f, -0.08132909f, -0.02344060f, -0.10031171f, 0.11332634f, 0.21992411f, 0.05991044f, 
    0.21395861f, -0.37431967f, -0.01803064f, 0.09604161f, -0.14123483f, -0.06366149f, 0.21096446f, -0.05674534f, 
    0.14276081f, 0.13926414f, -0.06581055f, 0.02632352f, 0.26483917f, 0.01203445f, 0.20424329f, -0.27382794f, 
    0.16143772f, 0.23839706f, 0.08546523f, 0.06983022f, 0.00139253f, -0.36020967f, 0.06622727f, 0.22765611f, 
    -0.08993522f, 0.18803047f, -0.15469712f, -0.36490181f, 0.03679218f, -0.15705971f, 0.18507709f, -0.25696829f, 
    0.04934582f, -0.01751332f, -0.22197928f, 0.10607291f, 0.08240560f, 0.05705534f, 0.06709426f, 0.01479309f, 
    0.03764373f, -0.31439003f, 0.30733600f, -0.10819587f, -0.22265725f, -0.02245595f, 0.08829997f, 0.23413049f, 
    -0.00322178f, 0.13331974f, 0.10558383f, -0.10458620f, -0.27826652f, 0.30865610f, -0.20453095f, 0.16395329f, 
    -0.48370317f, -0.17002527f, -0.11803374f, -0.01994727f, 0.13132229f, -0.41380087f, -0.25893867f, 0.07451313f, 
    -0.12847762f, -0.18748210f, 0.01638607f, 0.06241233f, 0.18528306f, -0.01069136f, -0.15133499f, 0.05762630f, 
    -0.12604578f, 0.12384533f, 0.22770944f, 0.01635819f, 0.12009824f, 0.07156882f, -0.08693740f, -0.08148098f, 
    0.29723102f, -0.07625174f, 0.23791689f, 0.25768912f, 0.02738691f, -0.21835305f, 0.37254077f, 0.13576089f, 
    0.07581869f, -0.09182942f, -0.08641891f, -0.05865344f, -0.02560605f, -0.05920924f, 0.27848467f, 0.06466126f, 
    -0.07324243f, -0.30663788f, -0.21079032f, -0.01668014f, 0.43940532f, 0.04336262f, -0.05737104f, -0.04037248f, 
    -0.00098807f, 0.08363134f, 0.03508060f, -0.01654124f, -0.00413358f, 0.09665074f, -0.09857270f, -0.02855879f, 
    0.29889941f, -0.20858933f, 0.07704696f, 0.15131983f, 0.09571560f, 0.10517457f, 0.03989995f, -0.10437430f, 
    -0.03456623f, 0.38140756f, -0.13173831f, 0.08263111f, 0.08112422f, 0.21551378f, -0.29567325f, -0.00177787f, 
    -0.21838354f, 0.06691141f, -0.14353938f, -0.00327038f, -0.08575708f, 0.07260060f, -0.10999878f, 0.06580053f, 
    -0.00874197f, -0.06399100f, 0.20216019f, -0.04166674f, 0.08513058f, -0.06082046f, -0.08820400f, 0.17996828f, 
    -0.11053305f, -0.13656425f, -0.19016677f, -0.09969589f, 0.13936128f, -0.18629956f, 0.26397985f, -0.07214282f, 
    0.01010170f, -0.07640461f, 0.18383887f, 0.22811568f, 0.04301125f, -0.11909468f, 0.08231193f, 0.10300503f, 
    0.10352281f, 0.35984930f, 0.01457363f, 0.07964201f, 0.05251201f, -0.09392514f, 0.16955492f, -0.12135769f, 
    0.17018192f, 0.13880032f, -0.06408875f, 0.14653258f, 0.08837543f, -0.03696507f, 0.12663656f, 0.00362670f, 
    0.32659838f, -0.03177955f, 0.05664911f, -0.05622482f, 0.30638948f, -0.16600616f, 0.01230589f, 0.06794631f, 
    -0.11688302f, 0.08311773f, -0.04104871f, -0.11926255f, 0.09990937f, -0.13474303f, 0.10771777f, -0.05329093f, 
    0.06764194f, 0.27316839f, -0.06343121f, 0.12239258f, -0.09790500f, -0.04496734f, -0.02726572f, -0.28578717f, 
    -0.13164744f, 0.02784053f, -0.06746899f, 0.04688784f, 0.27671784f, -0.07373185f, 0.19386910f, -0.00785775f, 
    0.17572999f, 0.22111286f, 0.23118544f, 0.12544942f, 0.16789055f, -0.12258522f, 0.05201892f, -0.20922855f, 
    -0.17042454f, 0.02751408f, 0.14381370f, 0.04365330f, 0.00272116f, 0.03306893f, -0.10622934f, -0.08934591f, 
    0.07844400f, 0.07146598f, 0.28311205f, -0.04388246f, -0.04015193f, -0.08055155f, -0.04063567f, -0.16505103f, 
    0.25224119f, -0.15404379f, 0.00333310f, 0.13911137f, 0.15978402f, -0.07244121f, 0.02451525f, -0.11756487f, 
    -0.04429701f, -0.03431577f, 0.05043549f, -0.27641183f, -0.08952579f, 0.11987894f, -0.17140675f, 0.30150327f, 
    -0.25875950f, -0.23084080f, -0.05445989f, 0.02148410f, 0.26362294f, -0.13876641f, -0.01169271f, 0.00676453f, 
    0.17540865f, 0.06277248f, -0.06248451f, 0.13593613f, -0.17543487f, -0.09987976f, -0.04332776f, 0.01798255f, 
    0.04776566f, 0.21421516f, -0.02073824f, 0.05541163f, 0.08413154f, -0.00057494f, 0.20561866f, -0.21426782f, 
    0.22952555f, 0.08157362f, -0.05410527f, 0.12992142f, 0.13476005f, -0.19433731f, -0.23784710f, 0.16679737f, 
    0.19169955f, 0.28377724f, 0.30849648f, -0.16139156f, 0.02349199f, 0.04202503f, 0.04464273f, -0.18109022f, 
    0.11236160f, -0.28129569f, 0.15092963f, -0.20651025f, 0.13389277f, 0.01165411f, 0.15232986f, 0.21351703f, 
    0.02464149f, -0.39092174f, 0.16225629f, 0.00537986f, -0.03726264f, 0.05263597f, -0.11393772f, 0.26847202f, 
    -0.30737501f, 0.16692391f, 0.08041746f, -0.14394265f, -0.01168696f, 0.27320993f, -0.03079760f, 0.05448457f, 
    0.11794098f, 0.20496026f, -0.05880106f, 0.01286168f, -0.20475954f, 0.06756940f, 0.35927412f, 0.04386292f, 
    -0.15046133f, 0.13265106f, 0.00842164f, -0.16900884f, 0.00453883f, 0.09076496f, 0.01817535f, 0.09711771f, 
    0.00968863f, -0.09961801f, -0.12647332f, 0.09502234f, 0.01072149f, 0.03728481f, -0.00461526f, 0.06143564f, 
    0.02940645f, 0.20710108f, 0.23072445f, 0.06586213f, -0.01813190f, 0.11931758f, -0.00029997f, -0.16313130f, 
    -0.05495947f, -0.12782642f, -0.09521441f, 0.28196433f, 0.02337718f, -0.23416568f, -0.31524649f, 0.04894247f, 
    0.09161513f, 0.08238476f, 0.09110596f, 0.08329888f, -0.18845476f, 0.07643767f, -0.06417266f, -0.08372098f, 
    0.31158546f, 0.25124159f, 0.13711248f, 0.15151025f, 0.24439725f, 0.12234354f, 0.02496014f, -0.23270044f, 
    0.15329871f, 0.07798323f, 0.02534207f, 0.00731720f, -0.12591219f, 0.11112615f, -0.02598290f, 0.41363251f, 
    -0.11451656f, 0.03256533f, 0.09486970f, -0.03925525f, 0.11321390f, -0.10612362f, -0.27620015f, -0.00683791f, 
    0.06381466f, 0.06255332f, -0.02212145f, 0.10603705f, 0.04842580f, -0.01899006f, -0.07635584f, 0.15272912f, 
    -0.03127901f, 0.12516950f, 0.20024306f, -0.04919079f, 0.16015095f, -0.01207558f, 0.16038212f, -0.23640159f, 
    0.16498223f, -0.07059480f, 0.01254390f, 0.01866098f, 0.01437639f, -0.30634907f, 0.29780638f, 0.20918252f, 
    -0.14118905f, 0.16664407f, 0.11837435f, -0.12364619f, -0.00680071f, -0.05357222f, 0.20447265f, -0.26517051f, 
    -0.20175533f, 0.02629474f, -0.25997829f, 0.09200452f, 0.44807702f, -0.10950093f, 0.17381459f, 0.04690201f, 
    -0.01843698f, -0.02746840f, -0.05002905f, -0.22930409f, -0.16322631f, -0.00348694f, -0.06322830f, -0.08108089f, 
    0.04395990f, -0.04439672f, -0.03811841f, 0.19186220f, 0.13562649f, 0.17565854f, 0.11680616f, -0.23792471f, 
    -0.20654228f, -0.31453511f, 0.10218034f, 0.05627381f, -0.02238672f, -0.02386144f, 0.16748165f, 0.03567036f, 
    0.18822309f, -0.40671983f, 0.04066603f, 0.08316570f, 0.12411282f, -0.08989882f, -0.09585195f, -0.20243429f, 
    -0.08010346f, 0.16632025f, -0.09932794f, 0.00514764f, 0.16332220f, 0.00441251f, 0.08788972f, -0.02110110f, 
    0.01262414f, -0.02384916f, 0.24850906f, 0.04349228f, 0.10900109f, -0.06406321f, -0.29505461f, -0.06016355f, 
    -0.13167994f, 0.21361938f, -0.18611865f, 0.27712688f, -0.07817426f, 0.13227125f, 0.01668843f, -0.12636341f, 
    -0.15985480f, 0.09887082f, 0.16189785f, -0.14362882f, -0.21555230f, 0.05299059f, -0.37213284f, 0.06356866f, 
    0.06668549f, -0.00578585f, 0.05907092f, 0.19103967f, 0.34775186f, -0.10944754f, -0.08360024f, -0.11951835f, 
    -0.25519457f, -0.44903144f, -0.06457952f, -0.30949759f, -0.05141356f, 0.31012866f, 0.03963642f, 0.40217283f, 
    -0.00508609f, 0.02542325f, -0.04879973f, 0.11914352f, 0.03978599f, -0.21989967f, -0.10437730f, -0.05070567f, 
    -0.13257895f, -0.14813475f, -0.24638210f, -0.16414087f, 0.15183148f, 0.03213126f, -0.13197482f, 0.13563159f, 
    0.03069446f, 0.03655848f, 0.07007106f, -0.00188857f, -0.23792736f, 0.02959028f, 0.03638498f, 0.08710451f, 
    0.13205439f, -0.47476581f, -0.14504501f, 0.06478631f, 0.15892753f, 0.00354791f, 0.12754346f, 0.28221112f, 
    0.22676869f, 0.05664035f, 0.07555182f, 0.13094543f, 0.05699955f, -0.06217375f, 0.26923338f, 0.09660304f, 
    -0.04904224f, 0.02904923f, 0.27787545f, 0.17327087f, 0.23401029f, -0.05116415f, -0.47862506f, -0.04480221f, 
    -0.07964893f, 0.12357162f, -0.46502104f, 0.04360285f, -0.01036444f, -0.09314847f, -0.10959665f, -0.00147504f, 
    -0.09683017f, -0.25663576f, -0.11165237f, 0.09081654f, 0.15485589f, 0.04309953f, 0.23906983f, -0.08218262f, 
    0.33079037f, 0.25411120f, 0.06712377f, 0.05555775f, 0.17013337f, -0.15309446f, -0.22623467f, -0.08456932f, 
    -0.05885037f, 0.15638883f, 0.00121583f, -0.06550040f, -0.15582474f, 0.09373400f, 0.20051487f, 0.27044228f, 
    -0.02644824f, 0.06628399f, 0.08244338f, -0.03855761f, 0.09098043f, 0.09832641f, 0.10604987f, -0.05574451f, 
    0.04636127f, 0.13570774f, 0.02661228f, -0.15144192f, -0.09353016f, -0.10737855f, 0.24834885f, -0.10733326f, 
    -0.14672652f, -0.24867746f, 0.04282288f, -0.09625431f, 0.11839173f, -0.00011213f, 0.19784391f, -0.12278622f, 
    -0.16033259f, 0.19524796f, -0.18447268f, 0.15638369f, 0.16060343f, 0.02801854f, 0.46249303f, -0.10885888f, 
    0.07559980f, 0.02720272f, 0.26484495f, -0.14228939f, -0.02827699f, -0.07856684f, 0.10412993f, 0.19633566f, 
    0.06390864f, 0.15973239f, -0.06550346f, 0.21092536f, 0.21661548f, -0.00520422f, -0.04373345f, -0.15191340f, 
    0.07633080f, -0.03664729f, 0.07148156f, 0.00779459f, -0.07622275f, 0.04240293f, -0.03905627f, 0.11259328f, 
    -0.13187593f, 0.05696960f, -0.03642798f, -0.12184582f, 0.01914966f, -0.09564240f, -0.08902307f, 0.07530172f, 
    -0.11422084f, -0.11864316f, -0.03120331f, 0.05717248f, 0.01012816f, 0.05836728f, -0.04788212f, 0.07113814f, 
    -0.12285323f, -0.08589636f, -0.00235769f, -0.00728934f, -0.06284723f, 0.03049348f, -0.04532678f, -0.00960459f, 
    0.05027274f, -0.00786120f, -0.03655914f, -0.05231157f, -0.05974076f, -0.13779743f, 0.05435615f, -0.02520313f, 
    0.05713953f, 0.04273711f, -0.04321397f, -0.09563211f, -0.13206187f, -0.03626822f, -0.10615411f, 0.04465891f, 
    -0.04994800f, -0.10028787f, -0.14512163f, -0.04592874f, -0.09372272f, 0.08794083f, 0.01747372f, -0.04776431f, 
    -0.08610009f, -0.10251123f, 0.03648420f, 0.00250488f, -0.10767514f, 0.09741243f, -0.11565833f, -0.11158925f, 
    0.18998225f, -0.11990219f, 0.01367835f, 0.05602244f, -0.11057816f, 0.41416165f, 0.34056279f, 0.12392090f, 
    0.06813274f, 0.16675133f, 0.19371901f, 0.04756842f, 0.17523226f, 0.04867029f, -0.07660776f, -0.25165671f, 
    -0.11814448f, -0.11209717f, -0.01065823f, -0.00670273f, 0.05602327f, -0.01093276f, -0.05970760f, -0.07930566f, 
    0.15872915f, 0.11441825f, -0.02821168f, -0.02914283f, -0.08705552f, 0.13053295f, 0.08191450f, -0.21362628f, 
    -0.06939606f, 0.20059441f, -0.18047495f, -0.06519797f, 0.27509362f, -0.04669868f, -0.23072863f, -0.02027848f, 
    0.41037598f, -0.11452889f, 0.07025106f, 0.09531036f, -0.25822601f, -0.07751814f, -0.00990183f, 0.00036949f, 
    0.10276542f, 0.07130109f, -0.02004176f, -0.03522770f, 0.08838154f, -0.09791565f, -0.13365898f, 0.13121822f, 
    0.32135680f, -0.09025183f, 0.01844591f, -0.08011813f, -0.14296034f, 0.06329162f, -0.06674150f, 0.29016146f, 
    -0.09833181f, -0.03815710f, 0.03477387f, 0.08520866f, -0.35305268f, 0.45310143f, 0.00027164f, -0.07430334f, 
    0.11946768f, -0.35001072f, -0.37059030f, -0.03906877f, -0.02005777f, -0.05326618f, -0.02662343f, -0.04200232f, 
    -0.07951012f, 0.20863439f, 0.23344021f, 0.12559390f, 0.10334075f, -0.10053325f, -0.19525376f, 0.03437703f, 
    0.20126350f, 0.25678110f, -0.00238219f, 0.29090542f, -0.05305919f, -0.12208376f, -0.33189103f, 0.10262751f, 
    0.27856034f, -0.03283433f, -0.12898767f, -0.21396565f, 0.09760242f, -0.25028244f, 0.22006679f, 0.05947718f, 
    0.40471762f, -0.19785042f, -0.26251835f, -0.01042541f, 0.08882753f, -0.04011097f, 0.13573240f, -0.02042270f, 
    -0.30423129f, -0.50095719f, -0.09742441f, -0.00847272f, -0.31606132f, -0.09742787f, -0.12935001f, 0.27596992f, 
    0.29414210f, -0.00859317f, 0.09611800f, -0.23955974f, -0.00216331f, 0.14438727f, 0.16726227f, -0.04904569f, 
    -0.05722989f, 0.05330343f, 0.07702911f, -0.01066289f, -0.04895979f, -0.15060192f, -0.00846312f, 0.08185755f, 
    -0.06481427f, 0.05727699f, -0.09257197f, -0.00804412f, -0.21360861f, 0.04576342f, 0.07986169f, -0.23925464f, 
    -0.03239088f, -0.01786228f, -0.08391210f, -0.11494750f, 0.06177443f, 0.02192712f, -0.17193627f, -0.00748062f, 
    -0.09839892f, -0.05340284f, -0.01748264f, -0.10668820f, -0.02317899f, 0.02503286f, 0.01011608f, -0.07135426f, 
    -0.00831345f, -0.05513029f, -0.11445373f, -0.05784756f, -0.12289986f, -0.00121047f, -0.07666612f, -0.10322911f, 
    0.01349092f, -0.11459313f, -0.04057127f, 0.00541204f, -0.15206715f, 0.03690526f, -0.10386920f, -0.02178356f, 
    0.09748276f, -0.16438638f, 0.08789531f, -0.04817422f, 0.03150325f, -0.10330275f, -0.12359296f, 0.10836899f, 
    -0.00194128f, 0.02106488f, 0.08479086f, -0.03362502f, -0.19538420f, -0.12503199f, -0.11382352f, 0.12870988f, 
    -0.08381388f, -0.32987198f, -0.05080424f, 0.08337451f, 0.12417732f, -0.23455597f, -0.09945985f, -0.04255477f, 
    0.30813450f, -0.08306102f, -0.01136010f, 0.26027575f, -0.10056955f, -0.09757458f, -0.08336782f, -0.15296941f, 
    -0.13877583f, 0.21957153f, -0.23590249f, -0.05307928f, 0.07332346f, -0.08108694f, 0.05341246f, -0.11773068f, 
    0.12229275f, 0.12085050f, -0.19062601f, -0.13215996f, 0.24178194f, -0.00042233f, -0.14166309f, -0.05813843f, 
    0.21929228f, 0.18069315f, 0.12051924f, -0.05954499f, 0.09973065f, 0.05247702f, 0.22334853f, 0.05699600f, 
    -0.07451782f, -0.02349234f, 0.08343695f, 0.07559942f, 0.00712532f, -0.06389299f, 0.01916089f, 0.24279179f, 
    -0.15281330f, -0.27118370f, 0.15920402f, -0.22863378f, -0.21415982f, 0.04396542f, 0.03739727f, 0.05784976f, 
    -0.08065088f, 0.16750553f, 0.06531993f, 0.06437702f, -0.07663896f, 0.07706214f, -0.17859627f, -0.11859440f, 
    0.04842815f, -0.08166502f, -0.07337111f, -0.11530244f, 0.03065836f, -0.06218935f, -0.01826791f, 0.01388100f, 
    -0.03938627f, 0.07774310f, -0.18179952f, -0.08403569f, -0.10657944f, -0.07957647f, -0.09660691f, 0.02546481f, 
    0.00326351f, -0.02854359f, -0.16893733f, 0.07929917f, 0.03350724f, 0.02904639f, -0.01673428f, 0.12407824f, 
    -0.06292250f, -0.15218121f, -0.02162275f, -0.06612840f, -0.07753562f, -0.08811791f, -0.00445131f, -0.01950381f, 
    0.10111528f, -0.00920495f, 0.05465828f, -0.12902811f, -0.01273882f, -0.11753295f, -0.01652350f, 0.08706668f, 
    -0.07748605f, -0.10857296f, -0.11332818f, -0.01696366f, -0.10171846f, -0.02423772f, -0.10776363f, -0.14848882f, 
    0.05299365f, -0.09481529f, -0.01385061f, -0.07396746f, -0.05488013f, -0.01506792f, 0.03839367f, -0.06976299f, 
    0.05755025f, 0.00227965f, 0.06251906f, -0.06655653f, -0.02359108f, 0.02634204f, 0.02662016f, -0.12425542f, 
    0.16084990f, 0.16936378f, 0.08220518f, 0.04202034f, -0.16934168f, 0.32418990f, -0.14365789f, -0.02671297f, 
    -0.08198207f, -0.00033503f, 0.08422489f, 0.11683284f, 0.16591270f, -0.09987943f, -0.05257159f, -0.22308530f, 
    -0.05550241f, 0.14115055f, -0.07672011f, -0.06040477f, 0.02997290f, 0.00250986f, -0.11467759f, 0.15360491f, 
    0.19939910f, 0.01594296f, -0.05391978f, 0.14732608f, 0.04288783f, 0.10955735f, 0.32390162f, -0.17209513f, 
    0.16879179f, -0.16265942f, 0.04717141f, -0.06518109f, -0.13142043f, -0.02344664f, -0.01722774f, 0.24998824f, 
    0.45754507f, -0.14682981f, -0.05030298f, -0.17526762f, 0.09669906f, -0.02063705f, -0.03332373f, 0.04649970f, 
    -0.36796895f, 0.01035705f, -0.10403851f, 0.09685113f, 0.03023778f, -0.08870582f, -0.03689904f, 0.22679399f, 
    0.48362985f, 0.01788824f, 0.03510585f, 0.07997245f, 0.10977133f, -0.15668391f, 0.33325914f, -0.09984497f, 
    0.21663789f, -0.24414872f, -0.02104495f, -0.03738154f, 0.00363802f, 0.15585355f, 0.03673248f, -0.04853322f, 
    0.17513764f, -0.39853644f, -0.32632679f, 0.05915632f, 0.07195958f, 0.13192053f, 0.43998462f, 0.48019212f, 
    0.23502979f, -0.13276537f, -0.13770710f, -0.06185457f, -0.23356016f, -0.01740444f, 0.19007602f, 0.13631497f, 
    0.00479221f, 0.00481458f, -0.23594451f, -0.09930583f, -0.08221421f, -0.15047231f, -0.35689515f, 0.18504608f, 
    -0.05793112f, 0.18459938f, -0.03871174f, -0.26033789f, -0.11531111f, -0.12768568f, 0.36669844f, 0.00761250f, 
    -0.25478041f, 0.31529739f, -0.19272399f, -0.03629988f, 0.11584175f, -0.10128844f, 0.16115105f, 0.13226663f, 
    -0.02264396f, 0.02463342f, 0.23707089f, -0.06155371f, 0.01957138f, 0.06616946f, -0.07532366f, 0.11728154f, 
    -0.25167164f, 0.19950235f, 0.02338343f, 0.03221539f, 0.08024150f, 0.31826687f, -0.07853878f, -0.16487281f, 
    0.09465024f, 0.12713629f, 0.02607150f, -0.04498700f, -0.04607229f, 0.37343967f, -0.18171474f, 0.05342225f, 
    0.06792112f, -0.36007684f, -0.18551876f, 0.02583597f, 0.35056445f, -0.11199069f, 0.04710559f, 0.05353782f, 
    0.01858944f, 0.10395440f, -0.04204644f, -0.11720030f, -0.06594286f, 0.03018624f, 0.17775096f, 0.18767637f, 
    -0.00634108f, 0.08707906f, -0.20941706f, 0.15902300f, 0.04764111f, -0.11830669f, -0.09215353f, -0.24451406f, 
    0.04042912f, 0.13471738f, 0.04338199f, 0.12959206f, -0.11238445f, -0.02282279f, 0.07991766f, 0.09962020f, 
    0.21670870f, 0.45626339f, -0.07953530f, -0.33344758f, -0.13553724f, 0.11816877f, -0.08579390f, 0.14862114f, 
    -0.27531290f, 0.08836308f, 0.06683676f, 0.03348132f, 0.15183663f, -0.00209859f, 0.09800027f, 0.09674571f, 
    0.05706722f, -0.04985922f, -0.07694680f, -0.29010066f, 0.23963572f, 0.12441489f, -0.06351701f, 0.18295915f, 
    -0.08875411f, -0.09728803f, 0.09633520f, 0.10262407f, -0.13740751f, -0.01721024f, -0.00643090f, -0.10688861f, 
    0.05016961f, -0.00094705f, -0.08978650f, 0.06548109f, -0.14234672f, -0.10890014f, -0.08032233f, 0.11562593f, 
    0.02693058f, -0.06771567f, -0.11790561f, 0.11676726f, -0.05178431f, -0.09673059f, -0.13629015f, -0.05656962f, 
    -0.15180589f, 0.02623077f, -0.12674657f, -0.13863112f, 0.05665550f, 0.06719940f, -0.07103861f, 0.09472737f, 
    -0.07441979f, 0.05565531f, -0.00814746f, -0.02529912f, 0.05005790f, -0.08387156f, 0.02567227f, -0.18455689f, 
    -0.12912144f, -0.04398497f, 0.01174213f, -0.00337312f, -0.09375037f, 0.08674048f, -0.10993788f, 0.03472599f, 
    -0.02903493f, -0.08667319f, 0.04659658f, -0.04696397f, -0.17799073f, -0.04376869f, -0.10593760f, 0.02644920f, 
    -0.14907931f, -0.01515550f, 0.09189376f, -0.00258925f, -0.01688930f, -0.08762702f, 0.06555425f, 0.01488565f, 
    0.02035606f, -0.15029681f, -0.07130072f, 0.07726680f, -0.15383901f, 0.02237426f, 0.30040491f, 0.08088383f, 
    -0.17753422f, -0.15166299f, -0.24646698f, -0.12319490f, 0.11500859f, -0.10533504f, 0.00062219f, 0.37620509f, 
    0.00693425f, 0.15276477f, 0.25852391f, -0.00878452f, 0.01601836f, 0.10399670f, 0.13151564f, -0.09877627f, 
    -0.18698004f, -0.03382453f, -0.16161120f, 0.20988619f, 0.15006250f, -0.02057694f, -0.52465540f, 0.25286034f, 
    0.12554443f, 0.13383207f, 0.00139169f, 0.09167665f, 0.06085220f, -0.33244780f, 0.33963171f, 0.04890669f, 
    0.05349660f, 0.06042179f, -0.21897282f, -0.32352039f, -0.12400147f, -0.06225991f, -0.29128903f, 0.03241079f, 
    0.07147077f, -0.06939816f, -0.14002110f, 0.12059054f, 0.13673973f, 0.08765393f, 0.06221231f, -0.07522182f, 
    -0.30279714f, -0.03025284f, 0.01607982f, -0.20667994f, 0.07588175f, 0.24556898f, 0.11674031f, 0.17944562f, 
    0.21578960f, 0.15987961f, 0.04715364f, 0.12519756f, 0.06713060f, 0.08795332f, 0.20337316f, -0.08527761f, 
    0.12988211f, -0.02122760f, 0.14336061f, -0.08159607f, 0.09786468f, 0.03197166f, 0.12987395f, 0.23150213f, 
    -0.04287468f, -0.19449256f, 0.24975841f, 0.07075586f, 0.11440907f, -0.04021163f, 0.17949790f, 0.04401968f, 
    -0.21014899f, 0.08025310f, 0.19299309f, 0.08964604f, -0.19790113f, -0.11152882f, 0.30335781f, -0.13226797f, 
    -0.14205667f, 0.00367974f, -0.10321410f, 0.03003098f, 0.04352881f, -0.15190473f, -0.11838090f, -0.17128879f, 
    -0.08838414f, 0.26183388f, 0.18579936f, 0.23059107f, 0.09303952f, 0.00881115f, 0.27279136f, -0.10711822f, 
    0.24173672f, 0.32117969f, 0.26776326f, 0.08864612f, 0.18708706f, -0.05558354f, -0.10736706f, -0.06354985f, 
    -0.08423632f, 0.00389474f, 0.08950990f, 0.17173967f, -0.13134623f, 0.08475342f, -0.05370189f, 0.06741572f, 
    0.14536010f, 0.08350631f, 0.06513823f, 0.08239245f, 0.12129168f, 0.19892474f, 0.14245053f, -0.10150325f, 
    0.06492850f, 0.00743898f, 0.09175452f, -0.10796441f, 0.14217091f, 0.04635060f, -0.03515455f, -0.09939732f, 
    -0.10797895f, 0.09730919f, 0.17605755f, 0.08333756f, -0.25188184f, 0.02320735f, -0.13836858f, 0.03950821f, 
    0.15837568f, -0.43002349f, 0.08714125f, 0.14092477f, 0.12506291f, -0.15957570f, 0.05721679f, 0.20988294f, 
    -0.04479607f, 0.24235663f, 0.04300831f, 0.02579366f, -0.04814751f, -0.04444756f, -0.12797980f, -0.06898678f, 
    0.00912964f, 0.03937343f, 0.31897151f, 0.37275720f, 0.05061056f, -0.11841916f, -0.17520313f, -0.31404757f, 
    0.14450079f, 0.01408558f, -0.26578310f, 0.17601089f, -0.02992357f, 0.11116842f, -0.06489853f, -0.13376921f, 
    -0.00373913f, -0.34422031f, 0.10407679f, -0.13366814f, 0.17467217f, -0.21810944f, -0.04741691f, -0.27107513f, 
    0.04267728f, 0.17300232f, 0.05042908f, -0.08870124f, 0.05652315f, -0.04844036f, 0.25660619f, -0.02461509f, 
    0.02143253f, 0.18617760f, -0.20342584f, -0.09993760f, -0.09629826f, 0.02566316f, 0.42508587f, 0.23834518f, 
    -0.06154986f, -0.05489600f, -0.08911581f, -0.06375220f, -0.13103689f, -0.08874269f, 0.15320556f, -0.02199338f, 
    -0.06627965f, 0.22504345f, 0.19555114f, 0.09714940f, 0.10246399f, -0.01318382f, -0.39271903f, 0.26159593f, 
    -0.18803078f, -0.18370363f, -0.08096689f, 0.15041472f, -0.05866112f, -0.12757470f, 0.01802698f, -0.05956180f, 
    0.07911660f, 0.10117169f, 0.16073085f, 0.15937534f, -0.01681299f, 0.09717803f, 0.00305461f, -0.22493437f, 
    0.37549248f, -0.10380381f, 0.08420511f, 0.11594135f, 0.11810313f, 0.05687703f, 0.00086643f, 0.18112628f, 
    -0.47993612f, 0.13282655f, 0.02421197f, 0.12324799f, -0.02123296f, 0.10825841f, -0.00960198f, 0.17066836f, 
    -0.03422730f, 0.06378336f, -0.01153996f, 0.00892956f, -0.10648547f, 0.24210416f, -0.14782935f, 0.06083592f, 
    -0.19719197f, -0.28336051f, -0.41841540f, 0.16951177f, 0.29069757f, -0.01272033f, -0.03062330f, 0.01826708f, 
    0.03071751f, 0.12128739f, 0.06091850f, 0.02643167f, -0.10796069f, 0.08682220f, 0.16428563f, 0.15395826f, 
    0.17812839f, 0.12899312f, 0.00643244f, 0.29809067f, -0.00617113f, -0.02678948f, 0.03845814f, -0.23582076f, 
    0.20379548f, 0.11699880f, 0.00873838f, 0.25042528f, -0.04027223f, -0.25421590f, 0.16564080f, 0.37133455f, 
    0.18594557f, 0.29240066f, -0.14520651f, -0.38674489f, -0.25115514f, -0.10321718f, -0.17433602f, 0.14442769f, 
    -0.37486726f, -0.19026090f, 0.04351399f, 0.06991480f, 0.24425001f, -0.04359944f, -0.02340052f, 0.04367588f, 
    0.11914244f, -0.06139200f, 0.10831290f, -0.41690907f, 0.19868630f, 0.02209597f, -0.02731803f, 0.25641385f, 
    -0.18818088f, -0.14348873f, 0.04428621f, -0.09658626f, -0.05654558f, 0.07947399f, -0.00581824f, 0.02717121f, 
    -0.07827610f, 0.06069130f, -0.11520746f, -0.13642454f, -0.05547421f, -0.08434138f, 0.08440142f, 0.10713026f, 
    -0.08324377f, -0.08131236f, 0.09138194f, 0.08715664f, -0.12296560f, 0.05389763f, -0.13164040f, 0.01888024f, 
    -0.00728590f, -0.08810280f, 0.01252062f, 0.07186326f, -0.14626563f, -0.11193844f, 0.04589944f, -0.14123033f, 
    -0.08569433f, -0.17629620f, 0.02887365f, -0.02762266f, 0.01288329f, -0.01249185f, 0.03893922f, 0.02961728f, 
    0.04502134f, 0.09766383f, -0.00931558f, -0.11389031f, -0.13934880f, 0.07335770f, -0.02077655f, 0.08614138f, 
    -0.13366456f, 0.00749539f, -0.09784494f, -0.12829889f, 0.02427003f, -0.11401647f, 0.04541939f, 0.05349705f, 
    -0.19176535f, 0.02268276f, 0.02205704f, 0.04191021f, -0.07526739f, -0.12290705f, 0.01485870f, -0.06888974f, 
    0.11037998f, 0.19194350f, 0.11514447f, -0.11896220f, -0.05649741f, 0.03442773f, 0.15334345f, -0.08731849f, 
    -0.16430950f, -0.06729902f, -0.09223987f, -0.03260630f, 0.16268568f, -0.04459077f, 0.19070846f, 0.41916594f, 
    -0.06714512f, -0.32433459f, -0.09718046f, -0.09815115f, -0.22555909f, -0.06580327f, -0.11711250f, 0.14012392f, 
    -0.26401594f, -0.11863034f, 0.01041362f, 0.00543871f, -0.19245513f, -0.07888717f, 0.12699024f, -0.11718574f, 
    0.13408312f, -0.15049258f, -0.16823322f, -0.02994110f, -0.00086216f, -0.04242093f, 0.18893051f, -0.06215219f, 
    -0.06269885f, 0.20159405f, -0.29501599f, -0.10595531f, 0.13778682f, 0.03010211f, 0.11844613f, 0.12522404f, 
    0.20064247f, 0.09956092f, 0.06837422f, 0.01304848f, 0.00977446f, -0.07145947f, -0.07906188f, -0.18333466f, 
    0.27003235f, 0.06289854f, -0.03473477f, 0.13971035f, 0.11208196f, 0.24161915f, 0.16415556f, -0.03255360f, 
    -0.13196927f, 0.10330804f, -0.04278772f, 0.06353080f, 0.01939446f, 0.00588451f, 0.02046534f, 0.00143287f, 
    -0.07714634f, -0.03422468f, -0.05094247f, -0.11187368f, -0.12592818f, 0.00776875f, 0.09456126f, 0.01974433f, 
    -0.02782116f, 0.00752760f, 0.11427522f, -0.07599676f, -0.04982594f, -0.12214507f, 0.08219805f, 0.03354026f, 
    -0.07572784f, 0.08949127f, -0.09827680f, -0.08782811f, -0.13505894f, 0.06104397f, 0.01259059f, -0.11003203f, 
    0.10900451f, -0.08151978f, -0.02174674f, -0.07412170f, -0.07473312f, -0.03992666f, 0.10198302f, 0.02705665f, 
    0.04149467f, -0.08171865f, 0.06236590f, 0.05341989f, -0.09086861f, 0.02273609f, -0.07502949f, -0.12859121f, 
    -0.10585573f, 0.04273856f, -0.12420297f, -0.01823627f, -0.12101553f, -0.08542958f, -0.04906399f, 0.11512153f, 
    0.04794594f, -0.08071486f, -0.04944469f, -0.12227731f, 0.05846788f, -0.04949327f, -0.13326554f, -0.04201123f, 
    0.09814586f, -0.18101902f, 0.08713594f, -0.09451012f, -0.03273106f, 0.12892343f, 0.27163342f, -0.08119878f, 
    -0.15404855f, -0.17652953f, 0.01810973f, -0.04595528f, 0.03758438f, -0.08598559f, 0.36265102f, 0.14958820f, 
    0.09047412f, -0.27330479f, 0.05972890f, 0.02452655f, -0.41451746f, 0.08105376f, -0.27118322f, 0.17926510f, 
    -0.18207787f, -0.42767709f, 0.13186176f, 0.13742241f, -0.00694340f, -0.05741834f, -0.10634864f, 0.43385285f, 
    -0.04876332f, -0.18788637f, -0.29621857f, 0.17961496f, -0.00845530f, 0.11833160f, 0.07165379f, 0.05709684f, 
    -0.04576048f, 0.09823974f, 0.10537612f, 0.30911687f, 0.21491630f, 0.12291537f, -0.12948239f, -0.36618266f, 
    0.20504083f, 0.14041710f, -0.19008769f, 0.13381836f, -0.07529207f, -0.02614891f, 0.04590001f, 0.02606492f, 
    0.09815737f, -0.13541181f, 0.08932377f, 0.08248337f, -0.09614995f, -0.11571102f, 0.08371845f, -0.39524227f, 
    0.06802987f, 0.02631859f, 0.04380661f, 0.04291391f, 0.15729484f, 0.01757372f, -0.17284234f, 0.03493204f, 
    0.34403938f, -0.07314713f, -0.06376972f, 0.20781539f, -0.20342675f, 0.01594268f, -0.25515455f, -0.10161950f, 
    -0.09243601f, -0.05748065f, 0.11393338f, -0.10562386f, 0.00015399f, -0.01017397f, 0.20343892f, -0.02905157f, 
    0.21029323f, -0.17549570f, -0.39841732f, -0.06452077f, 0.28433898f, 0.14047085f, 0.01764430f, -0.10995013f, 
    0.23611318f, 0.29653209f, 0.03081808f, 0.14553112f, -0.00243687f, 0.02605986f, 0.02184003f, -0.16202059f, 
    0.09345774f, 0.27760765f, 0.49851739f, 0.19919644f, -0.03569385f, 0.07416699f, 0.13593420f, -0.00353082f, 
    0.02371072f, 0.07086329f, -0.29561386f, -0.02600129f, -0.24572062f, 0.01401997f, -0.06165167f, 0.07030188f, 
    0.02363995f, -0.11585691f, 0.11403479f, -0.08619647f, 0.10323633f, -0.15313202f, 0.10107314f, 0.08760119f, 
    0.15188344f, 0.28155276f, -0.10338598f, 0.01504381f, 0.37930375f, -0.48846689f, -0.08811849f, -0.10112724f, 
    0.04733986f, 0.56912494f, 0.01792231f, 0.02350146f, -0.47932476f, -0.07348397f, -0.09016119f, -0.11998533f, 
    -0.07420390f, -0.02512981f, -0.10417534f, -0.02714409f, 0.27014706f, 0.06332166f, 0.00456949f, -0.16524781f, 
    0.12113251f, 0.16890895f, -0.16136923f, -0.33904707f, 0.28059801f, -0.11325790f, 0.16695960f, -0.08830428f, 
    -0.08480355f, -0.03373892f, 0.20303755f, 0.00199569f, -0.04638353f, -0.11871247f, 0.04315452f, -0.06755836f, 
    0.06295718f, -0.05960301f, 0.03132540f, -0.25680959f, 0.18085091f, 0.05342825f, 0.26600972f, 0.00801371f, 
    0.13885300f, -0.21671210f, -0.01108819f, -0.07806919f, -0.06485481f, -0.00068952f, 0.09465866f, 0.18748008f, 
    -0.01855514f, 0.13495831f, 0.10120697f, -0.00849922f, 0.09365079f, 0.06198565f, -0.17980154f, 0.11032687f, 
    -0.14958300f, 0.14375982f, -0.07572881f, 0.07032381f, -0.02668947f, 0.05011325f, -0.08023603f, -0.08136811f, 
    0.13859457f, -0.16957720f, 0.16932292f, 0.10508626f, 0.09847121f, -0.11798825f, -0.25099382f, -0.27985063f, 
    -0.05178180f, 0.18153077f, 0.21188124f, 0.00256433f, 0.13817929f, -0.11255720f, 0.15673462f, -0.03459604f, 
    0.28467083f, 0.16811040f, -0.03419966f, 0.04387778f, -0.08097125f, -0.05210219f, 0.35491648f, -0.17340510f, 
    -0.02188021f, 0.09899171f, -0.02420949f, 0.05150291f, -0.10349932f, 0.08382915f, -0.05559308f, -0.01368054f, 
    0.33135131f, -0.01781847f, 0.13798417f, 0.39536428f, 0.03012709f, -0.11623859f, 0.23406710f, 0.08586879f, 
    -0.17477891f, 0.06008226f, 0.11045176f, 0.05086824f, 0.03694415f, 0.02958929f, 0.09680285f, 0.19451559f, 
    0.47491491f, 0.01383378f, -0.08319853f, -0.24695712f, -0.04495046f, 0.02162285f, 0.09349665f, 0.22301719f, 
    -0.09896530f, 0.27505156f, 0.09802823f, 0.00835255f, -0.05950976f, -0.14386305f, -0.21247037f, 0.01708327f, 
    -0.22537006f, -0.18861999f, -0.29750994f, -0.07893296f, 0.13339601f, 0.03587602f, 0.04630255f, 0.03582960f, 
    0.04348752f, 0.13328408f, 0.32836172f, 0.06185129f, -0.08405042f, 0.02796252f, 0.05232153f, 0.12372518f, 
    0.08718422f, 0.06593962f, 0.12559956f, 0.28946078f, 0.13574553f, -0.31711546f, -0.01571919f, -0.15702961f, 
    0.04428797f, -0.11728664f, -0.01524604f, 0.25599584f, 0.07422902f, -0.15535636f, 0.25640529f, 0.01179725f, 
    -0.10460474f, 0.16113718f, -0.23157488f, -0.07902117f, 0.25823930f, 0.09483049f, 0.04550574f, 0.02900883f, 
    -0.15617293f, 0.19147249f, -0.01488496f, -0.04996109f, 0.05855275f, 0.02908283f, 0.03587873f, -0.02126353f, 
    0.28499424f, 0.02557821f, -0.12355053f, -0.00372305f, 0.36179107f, 0.07366681f, -0.15619697f, -0.04175785f, 
    0.08057825f, 0.11740407f, 0.05525360f, 0.08354528f, -0.15891652f, 0.38906112f, -0.05246731f, 0.02563965f, 
    -0.04210941f, -0.02692023f, -0.04861725f, -0.10396771f, 0.07606875f, -0.07312667f, -0.00552561f, 0.13154016f, 
    0.09568203f, 0.09522144f, 0.11889345f, 0.07485797f, -0.18818891f, 0.11182837f, -0.15185991f, 0.05544986f, 
    0.17096955f, -0.02152428f, -0.06760348f, 0.17113984f, 0.09740467f, 0.03296506f, -0.42114055f, 0.22891603f, 
    0.03136452f, 0.15324414f, -0.00347163f, -0.03568701f, -0.00386242f, -0.00318936f, 0.03882812f, 0.13545588f, 
    0.18763705f, 0.00081776f, 0.06962622f, 0.01994872f, -0.19306733f, 0.07740723f, -0.24929859f, 0.09601417f, 
    -0.22031079f, -0.17256981f, -0.16280100f, 0.20020024f, -0.15060261f, 0.10851000f, 0.10835806f, -0.09251753f, 
    0.09557778f, -0.17990147f, -0.08195005f, -0.22990049f, 0.10066938f, -0.13000803f, 0.29660231f, 0.21416676f, 
    -0.12782890f, 0.07394897f, 0.00471492f, 0.05229842f, -0.04805866f, -0.00843527f, -0.07149528f, -0.05140249f, 
    0.08790327f, 0.07262938f, -0.02742477f, -0.10828087f, -0.02547506f, -0.05611644f, -0.00775365f, -0.15936378f, 
    0.09739830f, -0.06119451f, -0.01458989f, 0.13752609f, -0.05973487f, -0.13002394f, 0.06589171f, -0.13741969f, 
    -0.10523666f, 0.07421395f, -0.02736234f, 0.06090895f, -0.05828854f, -0.11557278f, -0.03934391f, -0.07560010f, 
    0.04729502f, 0.05254120f, -0.07789340f, -0.15940405f, 0.08760825f, -0.05020313f, -0.06987981f, -0.10813312f, 
    -0.12008302f, 0.08521003f, 0.01517991f, 0.01386801f, -0.14164276f, -0.08121277f, -0.08635949f, 0.06665490f, 
    -0.15820187f, -0.19783971f, 0.01804597f, -0.01329162f, -0.04294441f, 0.07794517f, -0.00266483f, -0.04362363f, 
    -0.00647431f, -0.03793390f, -0.03738306f, 0.04931205f, 0.05302853f, -0.14637081f, 0.07138197f, -0.05325067f, 
    0.21017607f, -0.11597489f, 0.05401528f, -0.02746298f, 0.10719350f, 0.04169483f, 0.25523046f, 0.11214474f, 
    0.10306838f, 0.00914102f, -0.16973311f, -0.01271831f, 0.05021390f, -0.05605875f, -0.05610998f, -0.12401430f, 
    -0.02187642f, -0.08770140f, -0.08393481f, 0.04531019f, -0.31695914f, 0.09036179f, 0.07115708f, 0.07443281f, 
    0.10969336f, -0.47644117f, 0.00266379f, 0.05681618f, 0.13121846f, 0.05616584f, 0.09493036f, 0.15217806f, 
    0.38411823f, 0.26534045f, -0.12058407f, 0.23594724f, 0.03905012f, -0.10775342f, -0.05886138f, 0.13812718f, 
    0.11346859f, 0.29465869f, 0.31158611f, 0.15201740f, 0.07268810f, -0.06079184f, -0.42469400f, -0.08334178f, 
    0.05898745f, 0.02480823f, -0.52107334f, 0.17579539f, 0.23686996f, 0.06735507f, -0.03483023f, -0.19092363f, 
    0.00438861f, -0.45525044f, -0.02237171f, -0.03488134f, 0.15172786f, -0.15379873f, 0.16322543f, 0.03280534f, 
    0.00833886f, -0.21957962f, -0.02967503f, -0.07127121f, 0.25436518f, -0.28861868f, 0.17978548f, -0.05500903f, 
    0.28357613f, -0.03243317f, 0.06660613f, 0.15926944f, -0.15806158f, 0.08740918f, 0.42726758f, -0.06629620f, 
    -0.00329468f, -0.04366750f, -0.20620072f, 0.06528100f, 0.03570712f, 0.03771479f, 0.09300540f, -0.02094875f, 
    0.10569142f, 0.04738557f, 0.19205193f, -0.01234343f, 0.07685476f, 0.10563848f, 0.25808847f, 0.07952707f, 
    -0.11230075f, -0.03859171f, -0.10924198f, 0.02423257f, 0.11599457f, -0.05925353f, 0.00163452f, -0.19588223f, 
    -0.07272951f, 0.01380628f, 0.36703908f, 0.40616682f, 0.04967575f, -0.06777770f, 0.23972677f, -0.04399222f, 
    0.38089767f, 0.25679275f, 0.33035171f, 0.12470282f, -0.06515209f, 0.00798147f, 0.00366453f, 0.15144993f, 
    -0.13868052f, 0.06358457f, 0.01503839f, 0.07547686f, -0.14675301f, 0.03058057f, -0.12128750f, 0.04444967f, 
    -0.01259792f, -0.05113964f, -0.10898852f, 0.03479147f, -0.05202388f, -0.14576672f, -0.10014209f, 0.02788752f, 
    0.00678491f, -0.04133471f, -0.00355369f, -0.06139039f, -0.09042627f, -0.05068065f, -0.04583544f, 0.05896097f, 
    0.04141911f, -0.06696459f, 0.07964981f, -0.05700572f, -0.12627795f, 0.07237279f, -0.03950340f, -0.04516068f, 
    -0.03328499f, 0.02830108f, -0.14198215f, 0.08272419f, -0.06382719f, -0.14193377f, -0.09667929f, 0.04663606f, 
    0.04496141f, 0.06931680f, -0.06353879f, -0.18233106f, -0.00581238f, -0.16764356f, -0.01315467f, -0.01870312f, 
    -0.14655076f, 0.09988280f, -0.09298621f, -0.01639077f, 0.05075491f, 0.06367363f, 0.08349672f, 0.05954942f, 
    -0.02319141f, -0.04048274f, -0.00515367f, -0.13095783f, -0.14416407f, -0.07333777f, -0.03318027f, 0.01244587f, 
    -0.16251782f, 0.04301360f, 0.06363501f, -0.07870494f, -0.03374257f, 0.09888570f, -0.07810292f, 0.00794322f, 
    -0.07769159f, 0.06259689f, 0.10271278f, 0.04711297f, -0.08781736f, 0.01141306f, 0.06702545f, -0.01369190f, 
    0.09832881f, 0.06877179f, 0.05469839f, -0.13102289f, 0.02959142f, 0.03956641f, -0.10515927f, -0.03342110f, 
    -0.00237351f, -0.01674194f, -0.15555520f, -0.03688101f, 0.08832130f, -0.11451676f, -0.15719181f, 0.06117863f, 
    -0.11280343f, 0.01256407f, 0.00743492f, -0.15139513f, 0.00681533f, -0.09784593f, -0.01779563f, -0.02596324f, 
    -0.12808116f, -0.13646095f, -0.14796276f, -0.07530516f, 0.04382477f, -0.16126123f, 0.04779349f, 0.02674701f, 
    0.02204108f, -0.07310080f, -0.03416955f, 0.02867183f, 0.03401838f, 0.08457828f, 0.02191259f, -0.07267059f, 
    -0.08575995f, 0.00130097f, -0.04613560f, -0.12201986f, 0.00096079f, -0.00983698f, -0.03490380f, -0.08673540f, 
    -0.00885034f, -0.11159510f, 0.02160685f, 0.00322343f, 0.03488981f, -0.00100773f, -0.04457583f, -0.11176100f, 
    -0.00808263f, 0.24483728f, -0.07542317f, -0.11411484f, 0.13139683f, -0.04775476f, 0.14694941f, -0.10554559f, 
    -0.24804673f, 0.45738670f, -0.12193657f, -0.23377222f, -0.14053737f, -0.03413481f, 0.19099896f, 0.16492008f, 
    0.06330935f, 0.16140953f, 0.24720480f, 0.04837278f, 0.06436698f, 0.12872900f, 0.08573224f, -0.07210664f, 
    0.00189069f, 0.19520228f, 0.21684565f, 0.11740363f, -0.01880855f, 0.04532004f, -0.40557876f, 0.26663354f, 
    -0.25496033f, -0.12711662f, 0.37088069f, 0.29308474f, 0.06940991f, -0.17783867f, 0.18232812f, 0.18544763f, 
    -0.11083428f, -0.22364651f, -0.38071588f, -0.07432896f, 0.19550365f, 0.01883233f, -0.09311882f, 0.05760268f, 
    0.25110617f, -0.04658549f, 0.10115591f, 0.11531230f, 0.17062038f, 0.12447183f, 0.07514896f, -0.08315529f, 
    -0.02170061f, 0.23116010f, 0.04694883f, 0.14639340f, 0.20231582f, -0.08655816f, 0.03926219f, -0.08974926f, 
    -0.51364410f, -0.51454735f, -0.06142355f, 0.07638406f, 0.12846987f, -0.08023122f, -0.68273818f, 0.04160745f, 
    0.02746448f, -0.30112609f, -0.17575294f, 0.15780711f, -0.11142334f, -0.08597352f, 0.15489496f, -0.38350949f, 
    0.09002350f, 0.16581826f, -0.10638995f, 0.11674459f, 0.10307258f, 0.12167868f, 0.13813542f, -0.08443510f, 
    0.20960309f, 0.18236873f, -0.25195503f, 0.06227682f, 0.05851393f, -0.50691098f, 0.08004037f, -0.02994104f, 
    -0.08877020f, 0.17841129f, 0.16798218f, 0.09607618f, -0.06667333f, 0.07084899f, 0.22131231f, 0.14437678f, 
    0.20755512f, -0.23859096f, -0.00048272f, 0.06804325f, 0.20550649f, -0.02403505f, -0.11082147f, 0.22700627f, 
    -0.17920528f, 0.02435823f, 0.03157448f, -0.05515954f, -0.19941707f, -0.02404550f, 0.10164375f, 0.21226470f, 
    0.15021715f, 0.03149005f, -0.00598155f, -0.48081899f, 0.20588732f, -0.04409798f, -0.13147555f, 0.02966031f, 
    0.27731258f, 0.02080862f, -0.02745767f, 0.02485428f, 0.07215872f, 0.15417825f, -0.04464868f, 0.11538371f, 
    -0.03027832f, -0.08433283f, -0.03671146f, 0.19100635f, 0.04316131f, -0.10243913f, 0.08595034f, 0.13787115f, 
    0.07295350f, -0.05244778f, 0.07919461f, -0.05400778f, 0.10691428f, 0.09362523f, 0.12155350f, -0.05205273f, 
    -0.10181914f, 0.16318317f, 0.03411530f, 0.09509403f, -0.05602143f, -0.19039308f, 0.05917154f, -0.28941804f, 
    -0.19337094f, 0.11421203f, 0.14607503f, -0.06448247f, 0.10119133f, -0.15982114f, -0.06461544f, -0.09970631f, 
    0.14272477f, 0.45138150f, -0.15772964f, 0.13101439f, -0.16612568f, -0.01738525f, 0.18517606f, -0.02806263f, 
    0.09726512f, -0.19849142f, 0.10403805f, 0.11213252f, 0.24799776f, -0.08231659f, 0.09609742f, -0.10215979f, 
    0.16313022f, -0.11871015f, -0.07863428f, -0.13694456f, 0.15170822f, -0.00234662f, -0.13305664f, 0.08918146f, 
    0.30124617f, 0.03265248f, 0.06467452f, -0.00622311f, 0.06286946f, 0.02851595f, -0.06695143f, 0.04638457f, 
    0.07869607f, -0.07581025f, -0.41085082f, 0.07522748f, -0.00874449f, -0.05846381f, 0.09762219f, 0.32783973f, 
    0.09905752f, 0.12335410f, 0.23651008f, 0.12268918f, -0.08346383f, -0.04886913f, 0.10833806f, -0.01101368f, 
    -0.17756364f, -0.05498781f, -0.33461827f, -0.02022589f, 0.07119077f, -0.06185011f, -0.02926256f, -0.14648072f, 
    0.12391162f, 0.14376876f, 0.14194348f, -0.10711086f, 0.06156073f, -0.08418349f, 0.29311436f, -0.11473047f, 
    -0.34730551f, 0.35290548f, -0.06067298f, -0.07929204f, 0.00587717f, 0.07101388f, -0.01771503f, 0.15681069f, 
    0.06427120f, 0.22631638f, -0.11922677f, -0.08259930f, 0.02314039f, -0.08539950f, 0.02544629f, -0.12159907f, 
    -0.01968893f, 0.06382183f, -0.00796290f, 0.06011421f, 0.29403073f, 0.08004034f, -0.11072344f, -0.04514040f, 
    0.31148836f, 0.13887455f, -0.07501903f, 0.11916197f, 0.12893027f, 0.24455957f, 0.27730501f, -0.03615307f, 
    0.07496182f, 0.31172964f, -0.31845790f, 0.04608070f, -0.16275829f, -0.03817016f, 0.41860142f, 0.40114948f, 
    -0.00908704f, -0.14177831f, 0.02363569f, -0.07941788f, -0.23341654f, -0.02260497f, 0.11525658f, 0.05340375f, 
    -0.14183947f, 0.13454100f, -0.13951579f, -0.10326724f, 0.05039160f, -0.03536190f, -0.19002600f, -0.09791885f, 
    0.05741757f, 0.09120780f, 0.05568461f, -0.06126752f, 0.04944955f, -0.20466912f, 0.00303368f, -0.00068356f, 
    0.03097111f, 0.41019198f, 0.11660679f, -0.08653302f, -0.20639554f, -0.05096050f, 0.05968884f, -0.09066468f, 
    0.36211360f, -0.05791645f, -0.01067622f, 0.05276411f, 0.02770861f, -0.04702689f, -0.11498398f, 0.17539050f, 
    -0.02130980f, 0.20132074f, 0.01605227f, 0.16421773f, 0.10265137f, 0.06729338f, 0.13934568f, -0.02317417f, 
    -0.31438065f, 0.06465686f, 0.02904524f, -0.01145126f, 0.14317216f, 0.16459411f, -0.10266627f, 0.02535440f, 
    0.01970986f, 0.20647079f, 0.05401524f, -0.09425386f, -0.14116722f, 0.09820353f, -0.01906336f, -0.07344983f, 
    0.13165784f, 0.23236781f, 0.26477626f, 0.01697487f, 0.14707334f, -0.07683493f, 0.01861771f, -0.10065053f, 
    0.19253977f, 0.27922359f, 0.31599981f, 0.15121409f, 0.11366779f, -0.15310040f, -0.17881434f, 0.29804280f, 
    -0.16165307f, 0.03661110f, 0.14394255f, 0.04466150f, -0.10080723f, 0.09130254f, 0.13083607f, -0.02764238f, 
    0.01249034f, -0.16533889f, -0.29808822f, 0.23088208f, 0.29325897f, 0.10662805f, 0.06608684f, 0.03039143f, 
    0.12746285f, -0.20877498f, 0.17846856f, -0.14540955f, -0.20360668f, -0.12947765f, -0.05042665f, 0.07960695f, 
    0.05029907f, -0.06149291f, -0.03293021f, -0.14706798f, 0.16664863f, -0.03398635f, -0.05780015f, 0.03205867f, 
    0.05431816f, 0.19686882f, 0.05398042f, -0.10979515f, 0.05197691f, -0.01080951f, -0.08756585f, -0.07357366f, 
    0.12097814f, 0.22107407f, -0.03725896f, 0.10104226f, -0.11639220f, 0.03365258f, -0.07541467f, -0.33028886f, 
    -0.01968341f, 0.05146680f, 0.07635603f, -0.04532004f, -0.12053449f, -0.08402928f, 0.14393319f, -0.06105693f, 
    0.18937787f, -0.06833535f, -0.10648624f, -0.16215160f, 0.07457746f, 0.17529593f, 0.32728103f, -0.16299841f, 
    0.00720451f, 0.12123534f, -0.07602446f, 0.15362178f, 0.05149165f, 0.14805755f, -0.27360421f, -0.18329945f, 
    0.18276724f, 0.18230085f, 0.43446484f, 0.35542604f, 0.07772723f, 0.12086761f, 0.25238177f, -0.16507700f, 
    0.10690011f, 0.02608392f, -0.05677355f, 0.01148313f, -0.18312606f, -0.09137878f, -0.12386834f, 0.06546105f, 
    0.25832486f, 0.02106420f, 0.04238851f, -0.14073829f, -0.00435706f, -0.03841365f, -0.05241293f, 0.14032802f, 
    0.17839137f, 0.33466619f, 0.00248151f, -0.03695253f, -0.08172719f, 0.26287180f, 0.32358992f, -0.04884033f, 
    0.14658293f, 0.36488557f, -0.33792913f, -0.00261035f, 0.05232418f, -0.04231531f, 0.25724795f, 0.21874258f, 
    -0.08077931f, -0.02600602f, 0.22791202f, 0.08453705f, -0.17979050f, -0.02437968f, 0.25068662f, -0.12602244f, 
    -0.26235357f, 0.18027729f, -0.08959391f, 0.14881274f, 0.16454582f, -0.03405149f, -0.39995894f, 0.08045118f, 
    -0.07373749f, -0.04234508f, -0.10223246f, 0.15796818f, -0.05086525f, -0.43047559f, -0.04400665f, 0.06816877f, 
    0.14408432f, 0.28490010f, -0.03481926f, -0.26026121f, -0.25815457f, -0.04853565f, 0.20305155f, -0.08801492f, 
    0.23090482f, -0.25027594f, 0.05559693f, 0.11555701f, 0.15978035f, 0.07791634f, -0.09706975f, 0.21636187f, 
    -0.28938013f, 0.23520157f, 0.03153424f, -0.04878106f, 0.16404308f, 0.28783470f, 0.19887872f, 0.18928877f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.15418488f, 0.09019715f, -0.07173456f, 0.20820180f, 0.09949894f, 0.06184221f, 0.20556252f, -0.06107965f, 
    0.02693905f, 0.00099531f, 0.13357200f, 0.05272279f, 0.18240032f, -0.11389004f, 0.07774118f, -0.04088947f, 
    0.01501163f, -0.14266416f, -0.13995646f, 0.07602552f, 0.08072817f, -0.04937691f, 0.20722863f, -0.17281723f, 
    0.02394871f, -0.07613183f, 0.08860013f, 0.09080315f, 0.04059889f, 0.16335428f, -0.09575178f, -0.09716766f, 
    0.00461474f, 0.07961117f, 0.07898408f, 0.14003922f, -0.09176093f, -0.01692614f, 0.07384469f, 0.14509158f, 
    -0.01504594f, 0.08984526f, -0.06426559f, 0.10459824f, -0.02043601f, 0.06767071f, 0.20844813f, -0.01240075f, 
    0.17884070f, 0.08888435f, 0.32875016f, -0.09652716f, 0.14795262f, -0.02555335f, -0.14618249f, -0.12516399f, 
    0.15432206f, 0.02526204f, 0.23104632f, 0.14842372f, 0.08385611f, -0.00716539f, 0.04931625f, 0.03920424f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.39459604f, -0.25037092f, -0.06834012f, -0.15084773f, 0.15098298f, -0.19667439f, 0.03012991f, 0.00263751f, 
    0.13000952f, 0.21209100f, -0.45313436f, 0.25083089f, -0.41410303f, 0.09147877f, -0.32831749f, -0.11328969f, 
    -0.10998451f, 0.24648191f, 0.29697117f, -0.27044663f, 0.05014163f, 0.13931262f, -0.19691637f, 0.21865119f, 
    -0.02544429f, -0.31179222f, 0.01291248f, -0.01851503f, 0.04084006f, 0.06065917f, -0.00526120f, 0.16545314f, 
    -0.04469943f, -0.09480915f, -0.06318141f, -0.54354262f, -0.01381954f, -0.26734853f, 0.02183189f, -0.65390027f, 
    -0.13037987f, -0.61391586f, 0.07789015f, 0.04912008f, 0.03066618f, -0.49818629f, 0.08129324f, 0.06955374f, 
    0.13043630f, -0.37875330f, -0.21627386f, -0.08973642f, -0.04749607f, 0.15846972f, -0.12139676f, -0.06717614f, 
    -0.06839120f, 0.15452872f, -0.08764469f, -0.13558100f, -0.44164410f, 0.18709832f, 0.06667934f, -0.59142733f, 
    0.13164912f, -0.13314584f, -0.04040692f, 0.09846678f, -0.04764078f, 0.24470353f, 0.11499495f, 0.12893131f, 
    0.18466823f, 0.03571178f, -0.34511888f, 0.16420209f, 0.12691370f, 0.00957036f, 0.14380457f, 0.18885976f, 
    0.07978100f, -0.11449335f, -0.24232414f, 0.06849834f, 0.18463312f, 0.13810827f, 0.03746375f, -0.10422086f, 
    -0.27506864f, 0.18994184f, 0.01924789f, 0.07468380f, 0.11316784f, -0.42098552f, -0.01360823f, -0.00411378f, 
    0.07012637f, -0.02510536f, -0.50095683f, -0.27759659f, -0.07686004f, -0.30891705f, 0.05138057f, 0.43339619f, 
    0.07732008f, -0.48752591f, -0.02945406f, -0.28038746f, 0.01635952f, 0.23716137f, 0.00585362f, 0.30224249f, 
    0.03987318f, -0.32495302f, 0.14045030f, -0.01171796f, 0.34416559f, 0.09563133f, -0.02625111f, -0.11948738f, 
    0.05391923f, -0.67717606f, 0.04878991f, -0.28296947f, 0.06486782f, 0.06826989f, 0.12660103f, 0.02618116f, 
    0.20515865f, 0.00849488f, -0.01421627f, -0.09832666f, -0.04301818f, 0.15317598f, -0.14867781f, -0.01223625f, 
    0.09127247f, -0.38317817f, 0.19172464f, 0.19128790f, 0.09975640f, -0.28916991f, -0.43310034f, 0.22713673f, 
    0.06853892f, 0.27839592f, -0.19907044f, -0.21787670f, 0.04157286f, 0.03532250f, 0.12206049f, -0.14033169f, 
    0.12267298f, -0.69069046f, -0.01740677f, 0.01669922f, 0.23206100f, 0.34713864f, -0.08073784f, -0.07554942f, 
    -0.12798825f, 0.03971669f, -0.05841592f, 0.00655868f, -0.27474746f, 0.06736222f, -0.01388436f, -0.21569096f, 
    0.14338990f, 0.06002430f, -0.09169663f, -0.03650101f, 0.03770357f, -0.39222959f, -0.15108199f, -0.48775429f, 
    0.20831375f, -0.03035358f, 0.06957211f, -0.01262381f, -0.43909645f, -0.16372970f, -0.08677164f, 0.05883162f, 
    0.10986555f, -0.49873760f, 0.08275697f, -0.14269075f, -0.04918556f, 0.12846939f, 0.03318959f, 0.22525400f, 
    -0.23836890f, 0.18835191f, -0.09329292f, -0.43744615f, -0.04800852f, -0.42893022f, -0.47982693f, 0.03118222f, 
    -0.72108001f, 0.13169008f, 0.07256376f, 0.22725002f, -0.10888366f, -0.29609948f, -0.35845226f, -0.05397040f, 
    -0.04874878f, 0.08691895f, -0.03620883f, -0.07400535f, 0.00531453f, 0.19552170f, -0.36048722f, 0.16498734f, 
    0.14638548f, -0.04182221f, 0.04260551f, 0.10748895f, -0.27533233f, -0.02352758f, -0.08184276f, 0.12866430f, 
    0.01637963f, -0.69787043f, 0.32704675f, 0.04063549f, -0.03995926f, 0.36938179f, -0.06408797f, 0.10205316f, 
    0.05702159f, -0.03149571f, 0.00844935f, -0.21016687f, -0.05391800f, -0.24816898f, -0.04988474f, 0.09700619f, 
    -0.12348769f, 0.09415863f, -0.12085216f, 0.04098882f, -0.21219254f, -0.08511049f, 0.06601456f, 0.03562260f, 
    0.22277412f, -0.00498344f, 0.10381747f, 0.13903323f, 0.04297759f, 0.12534684f, -0.16656175f, 0.04046983f, 
    0.01749734f, 0.15066002f, -0.07663560f, 0.16113926f, -0.39914805f, -0.15660661f, -0.09744223f, -0.33096442f, 
    -0.45003024f, 0.18899618f, 0.05001817f, -0.12987342f, -0.34652272f, -0.16833399f, 0.16894294f, -0.38442981f, 
    -0.04673737f, 0.18695943f, 0.18081757f, -0.16349328f, 0.13571393f, 0.11742190f, -0.00031153f, -0.05152066f, 
    0.20148659f, -0.18402146f, -0.08073376f, 0.08996015f, 0.07650109f, -0.04162747f, -0.06280500f, 0.12157818f, 
    -0.05112908f, 0.02306102f, 0.10849389f, 0.13917121f, -0.00782968f, -0.38174808f, -0.02765286f, 0.07769238f, 
    -0.04763906f, 0.19014122f, -0.16667804f, 0.02400559f, -0.03859640f, 0.23383071f, -0.02924663f, -0.10230070f, 
    0.17601591f, 0.01550172f, -0.36963722f, 0.09461144f, -0.35428447f, 0.11220194f, -0.08954937f, 0.05523942f, 
    -0.18480077f, 0.28918907f, 0.10530964f, -0.15758100f, -0.34181812f, -0.00149167f, 0.02642354f, -0.31448349f, 
    -0.00595375f, -0.22664434f, -0.08818848f, 0.14700170f, 0.13567398f, -0.43076634f, 0.17745574f, -0.20576382f, 
    -0.27382919f, 0.06860954f, 0.07182120f, -0.12164253f, 0.13087128f, 0.05410806f, -0.02925503f, -0.05619336f, 
    0.06518893f, -0.10180917f, 0.14778805f, 0.26395318f, 0.10450980f, -0.22029890f, 0.04874570f, 0.13736133f, 
    -0.33052585f, -0.25716037f, 0.17150070f, -0.05531038f, -0.02516860f, -0.16901737f, -0.09878094f, -0.18339612f, 
    0.08981366f, 0.08100220f, -0.12452882f, 0.02698477f, 0.05353373f, -0.25149968f, 0.18968858f, -0.25167364f, 
    -0.17285591f, 0.00041544f, -0.02323574f, 0.16800599f, 0.03958806f, -0.15630017f, -0.05033944f, 0.07648066f, 
    0.13033864f, 0.21664400f, -0.26861969f, -0.02126666f, -0.25910726f, -0.00734253f, -0.11412282f, 0.13056937f, 
    0.06267539f, 0.15714978f, 0.17733319f, 0.01313097f, -0.09293161f, 0.07130378f, 0.08797214f, -0.17270097f, 
    0.21539479f, 0.06249410f, 0.04928887f, 0.16077173f, -0.11987733f, 0.10978532f, 0.07793359f, 0.11971991f, 
    -0.28834751f, -0.80768323f, 0.28700200f, -0.42690337f, 0.14881620f, -0.18304187f, 0.06080211f, -0.07356790f, 
    -0.09201883f, -0.28438681f, -0.30504200f, 0.10341176f, -0.57939446f, -0.61794126f, -0.10617488f, -0.41597161f, 
    -0.28317085f, -0.08823343f, -0.17836793f, -0.10450433f, 0.22040223f, 0.25899714f, -0.13943832f, -0.17747520f, 
    0.04339461f, 0.20422457f, 0.16250315f, 0.19400801f, 0.02618862f, 0.12400416f, -0.29485032f, -0.16229060f, 
    -0.42347834f, 0.19532889f, -0.11652506f, 0.21605365f, -0.08587758f, -0.12554261f, 0.01555069f, -0.28472468f, 
    -0.00493782f, -0.07859338f, 0.21943656f, 0.09701493f, 0.00316091f, -0.46168664f, -0.07376494f, -0.01158155f, 
    -0.39431342f, -0.78698516f, 0.01972555f, 0.03593518f, 0.16493599f, -0.48034197f, -0.02445057f, 0.13361265f, 
    0.02447879f, -0.59041464f, -0.00515810f, -0.31334314f, 0.09543168f, -0.11913344f, -0.20282352f, 0.14963044f, 
    0.02155887f, 0.11357276f, 0.24049184f, -0.16338639f, -0.04690391f, 0.04231080f, 0.27418303f, 0.03048603f, 
    -0.12185702f, -0.11527529f, 0.43420124f, -0.11907480f, -0.36071104f, 0.00185455f, -0.23614362f, 0.15382506f, 
    -0.14199749f, 0.24446930f, -0.13345291f, -0.08293042f, -0.28439257f, 0.18375280f, -0.08833792f, -0.37504271f, 
    0.01211276f, 0.11458465f, -0.09721860f, -0.25283247f, 0.04641474f, 0.16496275f, -0.04344400f, -0.14340092f, 
    0.02932946f, 0.01493343f, -0.13314749f, 0.15157095f, -0.02481392f, 0.13515374f, -0.48765486f, -0.42325696f, 
    -0.25463063f, 0.20947473f, 0.04735712f, 0.00839787f, -0.01308307f, -0.14646608f, -0.06480995f, -0.05385127f, 
    0.10638853f, -0.22938018f, -0.55609769f, -0.22802308f, -0.33641651f, 0.11985743f, -0.35339010f, 0.03202587f, 
    -0.15986162f, -0.14912152f, -0.06694141f, -0.18119635f, 0.11326068f, 0.01767574f, -0.05257136f, 0.14911321f, 
    -0.25718856f, -0.38552535f, -0.09914486f, -0.17066598f, 0.12382131f, -0.40705508f, -0.21207424f, 0.10534861f, 
    -0.05778297f, -0.28531981f, -0.11992384f, 0.05367381f, -0.16587728f, -0.43671545f, 0.21893853f, -0.24221274f, 
    -0.21265541f, -0.23023549f, 0.10175046f, -0.08823189f, -0.46217859f, -0.24867259f, -0.09187283f, -0.13479757f, 
    -0.05046200f, -0.15366031f, 0.28885442f, -0.16257229f, -0.03672079f, 0.04495227f, 0.01541914f, -0.18585035f, 
    0.26974383f, -0.30277362f, -0.06653509f, 0.28665385f, -0.02553376f, 0.09037061f, -0.30630898f, -0.41659102f, 
    -0.66936004f, 0.06382334f, 0.04882012f, -0.01548134f, -0.19599172f, 0.09909295f, 0.08386120f, -0.06123475f, 
    0.36379984f, -0.24528450f, -0.12143998f, 0.04458638f, 0.29931945f, -0.01019235f, -0.13880204f, 0.20756079f, 
    0.21751121f, -0.17514935f, -0.02290428f, 0.19902128f, -0.48938441f, 0.26869240f, -0.13320507f, -0.09967555f, 
    -0.55337691f, 0.17542015f, 0.14398502f, 0.03528405f, 0.00706028f, -0.47627255f, -0.10742445f, -0.17558992f, 
    0.07529114f, -0.43643835f, 0.07429922f, 0.15867673f, -0.04231612f, 0.10944615f, -0.04003757f, -0.28876495f, 
    0.05160101f, 0.11672094f, -0.23723854f, -0.10661113f, -0.02673917f, 0.10488392f, -0.06836107f, 0.09234821f, 
    -0.06852146f, 0.14957078f, -0.56016809f, 0.13203488f, 0.01795187f, -0.01234092f, -0.56274712f, 0.17870979f, 
    -0.41801956f, 0.20791747f, -0.01291568f, -0.38261092f, 0.09822229f, -0.22092307f, 0.23797843f, -0.30883110f, 
    0.18938082f, 0.23911197f, 0.21360488f, -0.05374151f, 0.03956332f, -0.52605617f, -0.01161766f, 0.06176802f, 
    0.03544438f, -0.05973859f, -0.12777688f, 0.02288064f, -0.35608289f, 0.01277719f, 0.15772314f, -0.11785266f, 
    0.25338686f, 0.30183139f, -0.14385846f, 0.27008435f, -0.01820483f, -0.27878758f, -0.13192374f, 0.19396128f, 
    -0.77092451f, -0.66176242f, -0.16335700f, 0.02902284f, -0.15462808f, -0.41183335f, -0.28176537f, 0.05506269f, 
    0.04344995f, -0.10636654f, -0.39265084f, 0.09647033f, -0.09597045f, 0.01798039f, -0.25354984f, 0.08019710f, 
    -0.25494123f, 0.03387544f, 0.11548606f, -0.08272631f, -0.19350450f, -0.44029656f, -0.06497957f, 0.14148793f, 
    -0.08985835f, -0.31002411f, 0.35296550f, 0.05797210f, -0.09485370f, -0.32110193f, 0.16022366f, -0.51997167f, 
    0.02017416f, -0.14455396f, -0.14125551f, 0.06440754f, 0.08535436f, -0.60442787f, 0.34648404f, -0.00382594f, 
    -0.03603489f, -0.02485333f, -0.39148536f, -0.06212315f, -0.10499921f, 0.26572740f, 0.03430191f, 0.04122997f, 
    -0.43680164f, -0.05349548f, 0.05318690f, 0.22428145f, 0.22031470f, -0.27568331f, 0.32167062f, 0.07228981f, 
    -0.20375073f, 0.14093579f, 0.10385238f, -0.03172819f, -0.20603810f, 0.12299374f, 0.32598063f, -0.11954381f, 
    -0.15207806f, 0.14699857f, -0.36480296f, -0.43616879f, 0.06466749f, -0.78110451f, -0.22727536f, -0.11761109f, 
    0.07876778f, -0.38985452f, -0.13505124f, 0.02313014f, 0.22276157f, -0.56139040f, 0.38017064f, -0.40524593f, 
    0.56972319f, 0.05052779f, -0.65209544f, -0.09243784f, 0.23263684f, -0.61247170f, 0.11186296f, -0.23397543f, 
    0.09959293f, -0.18677580f, -0.06853035f, 0.17416905f, -0.08822092f, 0.35753509f, 0.14004138f, -0.07729458f, 
    0.02106376f, 0.24582949f, 0.08073581f, 0.01847306f, -0.09251171f, -0.18050832f, -0.00566564f, -0.37177876f, 
    -0.14580943f, -0.08774938f, 0.03413976f, -0.04466572f, 0.25194368f, -0.07994866f, -0.06129379f, -0.02623420f, 
    -0.14092344f, -0.45980841f, 0.09142408f, 0.02346739f, 0.09801374f, -0.35028148f, 0.00672118f, 0.24783188f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.14482330f, 0.14264169f, 0.08541495f, -0.17416333f, 0.03210938f, 0.15359834f, 0.01182268f, -0.02676657f, 
    -0.05426432f, 0.07244111f, -0.03538628f, -0.08498104f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
