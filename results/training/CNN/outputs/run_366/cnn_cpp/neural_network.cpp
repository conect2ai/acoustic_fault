#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34818456f, -0.93010789f, 0.90075225f, 0.81208998f, 0.31113979f, 0.59301490f, -0.61885518f, -0.04277631f, 
    -0.04672994f, 0.26335090f, -0.84487885f, -0.88632190f, -0.33026332f, -0.38670513f, -0.81124020f, -0.51672190f, 
    0.46599609f, 0.24535263f, 0.77337319f, -1.17662537f, 0.09938794f, 0.27064949f, 0.02741163f, 0.71491808f, 
    0.28096911f, 0.15031439f, -0.67782074f, -0.49104887f, 1.05362630f, 0.60925537f, 0.66475600f, 0.56064534f, 
    0.69710404f, 0.13704143f, -0.01475567f, 0.02670184f, 0.01069278f, 0.59844464f, 0.21762626f, 1.03638887f, 
    -0.82339996f, -1.18759620f, -0.07889227f, 0.35247767f, 0.30309427f, -0.30843431f, -0.91240370f, 0.66061240f, 
    -0.89774996f, 0.23848623f, 0.07722805f, 0.23357598f, -0.47918645f, -0.26508275f, -1.50979614f, 0.61056542f, 
    0.95499271f, 0.29303077f, 0.75790864f, 0.05765615f, -0.03752209f, 0.03505603f, 0.56698042f, 1.31816471f, 
    0.83716291f, 0.53168160f, -0.84499168f, -0.45060414f, -0.72495043f, -0.10151204f, 0.05531735f, 0.24598406f, 
    -0.33721831f, -1.01917434f, -0.24110857f, 0.69127494f, -0.45839211f, 0.55908877f, -0.12113152f, -0.10801161f, 
    -0.30292696f, -0.04773558f, -0.90028185f, 0.54466558f, -0.42410108f, -1.25466645f, -0.62227613f, 0.45322853f, 
    0.35250455f, -0.50112933f, 1.11546254f, -1.19243824f, 0.57806200f, 0.05875001f, -0.61327291f, -0.44225708f, 
    -0.03354688f, -0.37416112f, 0.32521796f, -0.26738602f, 1.40860271f, -0.58959311f, -0.21535809f, -0.06664111f, 
    -0.90825993f, -0.03211421f, -0.36009857f, -0.13542093f, 0.74441326f, 0.49653694f, 0.65453047f, -0.64136457f, 
    -0.75859886f, 0.79656047f, -0.47212368f, -0.61682129f, -0.32508183f, -0.99974036f, 0.41869065f, -0.28843689f, 
    0.73062605f, 0.49740356f, -0.92207319f, 0.25374895f, -0.42741373f, -0.50587535f, -0.14461881f, -1.48988235f, 
    -0.72910255f, 0.26205644f, 1.26396477f, 0.38353842f, -0.70677555f, 0.01001680f, -0.56988144f, 0.03182042f, 
    0.80674863f, 0.18973209f, -0.52860564f, 0.85422325f, -0.21938428f, 0.26279625f, 0.59903133f, 0.47440362f, 
    -0.50331682f, -0.70640647f, -0.05010008f, -0.87664860f, -0.29743123f, 0.86335820f, 0.52848637f, 0.29398108f, 
    -0.09459864f, -0.74074709f, -0.92302418f, -0.55053878f, 0.02489491f, -0.14650850f, 0.45872271f, 0.25186750f, 
    -0.18407409f, -0.05491487f, 0.70166099f, 1.09635127f, 0.11441945f, 0.22898529f, -0.83638710f, 0.56204247f, 
    0.46979710f, 0.16232328f, -0.39944178f, 0.89672041f, 0.54610926f, 0.49313962f, -0.10213009f, -0.60800540f, 
    0.60886389f, -0.19329795f, 0.31136766f, 0.72121227f, -0.56457663f, -0.96584499f, -0.51981133f, 0.87575525f, 
    -0.03359385f, 0.54373890f, -0.46334568f, -0.08673219f, 0.54041791f, -0.78318936f, -1.28991556f, -0.13743709f, 
    0.58330309f, 0.43587935f, -0.72271985f, 0.12915872f, 0.46832225f, -0.14167172f, -1.04272974f, 0.60759795f, 
    0.94471180f, -1.08378839f, 0.75347549f, -0.46671230f, -0.44991922f, 0.55679464f, -0.32295138f, 0.91578913f, 
    0.71504408f, 0.92640597f, 0.30229911f, -0.52641439f, -0.09763213f, 0.51677090f, 0.01655392f, -0.02039829f, 
    -0.16952351f, -0.25382197f, -0.69499099f, -0.53978205f, -0.63677752f, -0.53097469f, -0.71542329f, 0.07062858f, 
    -0.66780972f, 0.87885642f, -1.19217658f, -0.43159571f, -1.15692818f, 0.39545172f, 0.36238912f, 0.06512921f, 
    0.00576301f, 0.12124433f, -0.81260186f, 0.09759589f, 0.15464646f, 0.62799007f, 1.04655671f, 0.67991817f, 
    -0.02952700f, 0.42299619f, -0.15385002f, 1.37105274f, -0.42199245f, -0.85155851f, 0.50903255f, -0.17133819f, 
    -0.41734654f, 0.15012863f, -0.30743986f, 0.55780113f, 0.08252772f, -0.10847365f, 0.91767943f, -1.18952012f, 
    -0.52873147f, -0.65869647f, 0.62224066f, 0.29512143f, 0.44824463f, 0.98507845f, -0.23807347f, 0.11600342f, 
    0.39470235f, 0.73854953f, 0.17123801f, -0.20496640f, -0.44912401f, -0.43159631f, 0.82921332f, -0.43699616f, 
    1.14923608f, 0.71286529f, -0.18290685f, 0.02506416f, -0.11732680f, 0.23509647f, -0.68367189f, 1.29087234f, 
    0.68701482f, -1.21575022f, -0.35260484f, 0.18610606f, 0.67048031f, 0.16845599f, -0.25598097f, -0.07096423f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02763070f, 0.31013522f, 0.00690991f, 0.29921460f, 0.08023976f, 0.13961476f, 0.29844674f, -0.05970130f, 
    0.11333201f, 0.36113346f, 0.10559874f, -0.06942040f, 0.18481958f, -0.23268402f, 0.14565918f, -0.06461017f, 
    0.08102513f, 0.08841924f, 0.09781233f, 0.13853590f, 0.19186877f, 0.30659959f, 0.16118440f, 0.27664259f, 
    -0.00748123f, -0.10677809f, -0.02789780f, 0.33330667f, 0.12175396f, 0.26506793f, 0.03002786f, 0.16676688f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05067457f, 0.18769595f, 0.03650821f, 0.03349173f, -0.16283067f, -0.02941460f, -0.13116856f, -0.02394828f, 
    -0.03470123f, -0.11118355f, 0.02736985f, 0.02837055f, -0.02465251f, -0.11971239f, 0.05418993f, -0.00529307f, 
    0.01591742f, 0.09231029f, 0.03432137f, 0.08549931f, 0.09121440f, 0.06351645f, 0.08614398f, 0.20074736f, 
    -0.11832103f, -0.01925053f, -0.12940863f, -0.06059106f, -0.09381735f, 0.11948241f, 0.11198030f, 0.11630221f, 
    0.16573267f, 0.11791207f, -0.06105008f, -0.06820983f, 0.00346921f, -0.11835483f, 0.02024196f, 0.00482780f, 
    -0.31865954f, 0.26291677f, -0.08800302f, -0.00153196f, -0.29047891f, -0.03609747f, 0.14906213f, -0.15233760f, 
    -0.14367267f, 0.04412992f, -0.01134124f, 0.02016449f, -0.15255718f, -0.05384488f, -0.05727166f, -0.06916991f, 
    -0.06353170f, 0.01312103f, 0.00397414f, -0.02472970f, -0.23196621f, -0.07179448f, 0.19194166f, 0.02626891f, 
    0.15760867f, 0.10842752f, -0.15265559f, -0.06418578f, 0.04279050f, -0.00367314f, 0.00187572f, -0.06688254f, 
    -0.07166676f, -0.03172888f, -0.00105591f, -0.00689819f, 0.00068214f, 0.05912444f, 0.08711075f, 0.12876479f, 
    0.09666502f, -0.06627420f, -0.04386519f, 0.35065162f, -0.00309192f, 0.11583287f, -0.14686957f, 0.12944652f, 
    0.02636162f, 0.00004534f, -0.08414981f, 0.06651013f, -0.10942117f, 0.07122441f, 0.03725195f, 0.05622571f, 
    0.07474507f, 0.11581676f, 0.12216511f, -0.03664096f, -0.34421006f, 0.08764999f, 0.11979464f, -0.09415837f, 
    0.18653679f, 0.05122083f, -0.01432511f, -0.03200918f, 0.06736703f, -0.04908021f, -0.10855462f, -0.00062371f, 
    0.01588383f, -0.05875747f, 0.02005144f, -0.03636525f, 0.03022621f, 0.00299942f, -0.01334289f, 0.04974812f, 
    -0.30854312f, 0.00080940f, 0.40491989f, 0.08992083f, -0.16681449f, 0.07409150f, -0.01221205f, -0.09147119f, 
    0.03675882f, -0.12273245f, 0.03117589f, 0.03194412f, 0.06284984f, -0.06127217f, 0.00961581f, -0.04148189f, 
    0.11485375f, 0.01073211f, 0.09413020f, 0.03958503f, 0.10517475f, -0.12176558f, -0.15781006f, -0.02626251f, 
    0.42174682f, -0.01078174f, -0.04015368f, -0.05805137f, -0.00756651f, 0.01254428f, 0.15120359f, -0.07610994f, 
    0.06290650f, 0.08340243f, 0.07803083f, 0.07096595f, 0.06073624f, 0.13122258f, 0.15363051f, -0.06677605f, 
    0.17055757f, 0.14449884f, 0.06078917f, 0.02114226f, -0.15608956f, 0.01045261f, 0.05451377f, 0.12680830f, 
    0.08015643f, -0.02296512f, 0.01216789f, 0.07000225f, 0.04250348f, -0.10488002f, -0.14628506f, 0.08135857f, 
    -0.09436455f, 0.04130586f, -0.03283471f, -0.09724395f, 0.01788149f, -0.18331724f, 0.12807278f, 0.19937828f, 
    0.23001662f, -0.09673782f, -0.11006118f, -0.00846930f, 0.06202713f, 0.06511957f, 0.07625064f, 0.17294332f, 
    -0.07401744f, -0.04675704f, 0.15425864f, 0.00847592f, 0.09759631f, -0.00046879f, -0.10936572f, -0.17655270f, 
    0.11162541f, 0.01000399f, 0.19544658f, 0.34352437f, 0.08809423f, -0.06648033f, -0.13690184f, -0.04718825f, 
    0.08478106f, 0.02956530f, -0.08753610f, 0.07711522f, -0.13549733f, 0.10618108f, -0.06181821f, 0.10393954f, 
    0.03099906f, 0.06648225f, 0.01948484f, -0.07886340f, 0.31719929f, 0.37656757f, 0.00543441f, 0.35178453f, 
    0.07010119f, 0.07506087f, -0.11598541f, -0.12346104f, 0.04327119f, 0.15810502f, 0.06078284f, 0.12045728f, 
    0.05019092f, 0.01009794f, 0.00277569f, -0.02424320f, -0.06607513f, -0.16531649f, 0.05960510f, 0.01153548f, 
    0.10331280f, -0.24504116f, -0.11737021f, -0.03036399f, 0.27624440f, -0.09118368f, -0.08444075f, -0.17597350f, 
    -0.09088907f, -0.01069370f, 0.02172282f, 0.11071136f, 0.18918018f, 0.13551331f, 0.10432652f, 0.02638945f, 
    0.05590552f, 0.10056408f, 0.02841271f, 0.10387614f, 0.53715461f, 0.33541965f, 0.39850041f, 0.08114525f, 
    -0.30834273f, 0.00779647f, -0.01639527f, 0.14811958f, 0.09869280f, -0.07352864f, 0.06645218f, 0.08682274f, 
    0.05242005f, 0.09701277f, -0.00744046f, -0.13096227f, 0.07140492f, -0.00288318f, 0.05222660f, -0.03334726f, 
    -0.14808390f, 0.39064589f, -0.00534483f, -0.03635773f, -0.20478882f, -0.06095510f, 0.10486829f, 0.11674816f, 
    -0.03012751f, 0.07067527f, 0.04818510f, 0.03385584f, -0.04449014f, -0.09682816f, -0.00918122f, -0.10985893f, 
    0.10553297f, 0.02547136f, 0.07092777f, 0.01850516f, -0.10104359f, -0.15428485f, -0.13044378f, 0.07085034f, 
    -0.03293280f, 0.10332830f, 0.02175215f, 0.01477696f, 0.04285177f, 0.25375813f, 0.03828974f, 0.08842113f, 
    -0.00345809f, 0.07401791f, -0.07363819f, 0.00789694f, 0.06083874f, -0.13257204f, -0.02821928f, 0.00358664f, 
    -0.33508974f, 0.04234499f, 0.12840591f, -0.10388930f, 0.01009266f, -0.04677149f, 0.02838811f, -0.06635724f, 
    -0.06167097f, -0.11818439f, 0.03558384f, 0.09189620f, -0.06085610f, 0.16561057f, 0.05475388f, -0.00547189f, 
    0.03356735f, -0.02718840f, -0.24852245f, 0.09082043f, -0.12492909f, 0.05015001f, 0.21402338f, -0.19787760f, 
    -0.23031582f, 0.06275482f, 0.08565464f, 0.04920011f, -0.03970264f, -0.09121180f, -0.02937916f, 0.06671469f, 
    -0.01842089f, -0.00666432f, -0.11855361f, 0.11369714f, 0.01276661f, 0.02979237f, -0.09910279f, -0.12634173f, 
    0.15224369f, -0.03206086f, -0.19017267f, -0.08017835f, 0.04619719f, 0.02847749f, 0.08703563f, -0.14046744f, 
    0.05216796f, 0.03608119f, -0.01988502f, -0.03122117f, -0.15026660f, 0.04498177f, 0.05842268f, 0.02682719f, 
    -0.02652925f, 0.03969183f, 0.13836257f, 0.05454744f, 0.39460042f, -0.27453080f, -0.17339465f, -0.16236782f, 
    0.12349664f, 0.14391045f, -0.01892630f, -0.13147418f, 0.04088147f, 0.00402362f, 0.04882151f, -0.00640393f, 
    -0.06428855f, 0.09596525f, -0.07061686f, 0.02751663f, -0.00693279f, 0.12359519f, -0.01306980f, 0.20753515f, 
    0.10770968f, 0.15177533f, 0.00579115f, -0.05402289f, -0.16680640f, 0.01462470f, 0.17311366f, 0.02838622f, 
    0.13127859f, -0.15902308f, -0.00881239f, 0.03239452f, 0.14092804f, -0.18902533f, 0.02311465f, 0.09556170f, 
    0.02954236f, 0.17627835f, -0.06581580f, 0.00868020f, -0.60433763f, 0.32036331f, 0.29001322f, -0.08003899f, 
    -0.22890322f, -0.06055129f, -0.02514207f, -0.02408467f, 0.07326908f, -0.09245048f, -0.00624090f, 0.09419952f, 
    0.09437526f, -0.10228737f, 0.03095626f, -0.02337814f, 0.01286577f, -0.05531254f, -0.04634439f, -0.08655727f, 
    -0.24761201f, 0.18431823f, 0.07333638f, 0.22457296f, -0.17008005f, 0.01322078f, 0.00722089f, -0.10570544f, 
    0.10903409f, 0.01765341f, -0.03744795f, 0.09976009f, -0.10153303f, 0.16061530f, 0.10982469f, 0.03730851f, 
    -0.04931766f, 0.00153028f, 0.07258014f, -0.11008931f, 0.06343098f, -0.27231959f, -0.22941621f, 0.02498377f, 
    0.17233501f, 0.10266880f, 0.05050130f, 0.00097710f, 0.01697120f, -0.04292933f, 0.02911711f, 0.00602360f, 
    -0.08559152f, -0.00916078f, -0.00809904f, 0.05303176f, -0.00410847f, 0.15981174f, 0.12840742f, -0.05489974f, 
    0.24805368f, -0.04974099f, 0.21031018f, 0.18648486f, 0.22642763f, 0.12271230f, -0.07678726f, -0.06531883f, 
    -0.05678435f, 0.02471058f, -0.07236300f, -0.00499580f, -0.05698211f, -0.04430489f, 0.04490798f, 0.00806734f, 
    -0.03279257f, 0.07989743f, -0.03470024f, -0.11382345f, -0.45389038f, 0.40183008f, 0.34780565f, -0.03982818f, 
    0.01157260f, -0.01870679f, 0.06239218f, -0.04336429f, 0.05640582f, -0.09318151f, 0.09839980f, 0.08624576f, 
    0.01994762f, -0.04091663f, 0.01549214f, -0.05110747f, -0.00433639f, -0.06508046f, -0.04645102f, 0.03225572f, 
    -0.14665312f, 0.32784688f, 0.26697835f, -0.07574727f, -0.06516128f, -0.00874404f, 0.02631195f, 0.04166066f, 
    0.02773757f, -0.14640202f, 0.05665243f, -0.07702471f, -0.02519933f, -0.01447456f, 0.00416585f, 0.13895991f, 
    0.11085162f, 0.06438929f, 0.11974506f, -0.03832323f, 0.01261853f, 0.21959725f, 0.00175756f, 0.07385997f, 
    0.05361719f, -0.08508477f, -0.00600881f, 0.07465491f, 0.10908388f, -0.01819517f, 0.08621435f, 0.04347172f, 
    0.04665480f, 0.03139083f, -0.13515052f, -0.01329433f, -0.03432696f, -0.03302359f, -0.01641600f, 0.09381526f, 
    0.13281122f, -0.03838916f, 0.10270211f, 0.13741578f, 0.27703837f, -0.06299944f, -0.09463480f, -0.01948134f, 
    0.00313844f, -0.07670703f, -0.04062010f, -0.03458219f, 0.04298647f, 0.05897310f, 0.04964364f, 0.11107247f, 
    0.12321246f, 0.14900164f, -0.10418965f, 0.04129401f, -0.12463725f, 0.10715267f, -0.05774142f, -0.02128141f, 
    -0.07863604f, -0.22832300f, 0.03426744f, 0.05047562f, -0.08984268f, -0.08175876f, -0.01788182f, 0.14267240f, 
    0.00631323f, -0.03275286f, 0.12372126f, -0.06611460f, -0.00797211f, 0.06714252f, 0.08285681f, 0.04649090f, 
    -0.09812149f, -0.29477254f, -0.10288055f, 0.32080618f, -0.00355331f, 0.03943279f, -0.16698496f, -0.00538866f, 
    -0.09312817f, -0.07160125f, 0.06866210f, 0.04743632f, -0.03364984f, 0.12449718f, -0.10101330f, -0.04243958f, 
    -0.09044895f, 0.11232900f, -0.06240667f, -0.24970479f, -0.15807025f, 0.18696238f, -0.14837825f, -0.13549687f, 
    0.30711097f, 0.01159240f, 0.18319573f, -0.10934518f, -0.14146635f, 0.08345599f, -0.06869627f, -0.05078805f, 
    0.06006787f, -0.08205290f, 0.03188881f, -0.02472963f, 0.07596301f, 0.01996586f, 0.08194880f, 0.05837756f, 
    0.02081360f, 0.02946355f, -0.02262855f, 0.02408603f, 0.03068924f, -0.04153727f, 0.01245692f, 0.01210952f, 
    -0.03993667f, 0.00210034f, 0.00025509f, 0.03263142f, 0.02932553f, 0.00878919f, 0.01383215f, -0.03207308f, 
    -0.00200522f, 0.00763965f, -0.00044550f, -0.01670459f, -0.00032086f, -0.00638039f, 0.01502254f, -0.00592703f, 
    0.00914977f, 0.02492241f, -0.01110495f, -0.04650130f, 0.03873630f, -0.03971406f, -0.03495062f, -0.03614955f, 
    0.00956590f, 0.01135927f, -0.01316554f, 0.00817653f, -0.01674144f, 0.00210192f, -0.00981495f, -0.02161545f, 
    0.02256820f, -0.01325966f, 0.02298702f, 0.01994084f, -0.00202155f, -0.00633901f, 0.03082854f, -0.02532177f, 
    -0.02725181f, 0.00064904f, -0.01630952f, -0.00623878f, 0.01812585f, 0.02245142f, -0.02870852f, 0.02332582f, 
    -0.01063466f, -0.03588759f, 0.02485841f, 0.01843409f, 0.03470754f, 0.01913795f, -0.04063259f, -0.02447689f, 
    0.02361148f, 0.01471939f, 0.01102960f, -0.01057729f, 0.02983256f, 0.02910522f, 0.01885402f, 0.02948250f, 
    0.00167220f, -0.01218402f, 0.00197568f, -0.00074183f, 0.01498855f, 0.02869181f, -0.00878058f, -0.03004591f, 
    0.01495895f, 0.00094942f, 0.03215011f, 0.02563629f, 0.01869565f, 0.02785329f, -0.03809992f, -0.03584659f, 
    -0.01023280f, 0.00136659f, -0.00592193f, 0.00272924f, 0.00383470f, 0.01723011f, 0.02624270f, -0.01309944f, 
    -0.00985951f, 0.03298414f, -0.00416537f, -0.03887672f, -0.01441940f, -0.00530503f, 0.01231082f, 0.01495889f, 
    0.01653743f, -0.03584274f, -0.04246798f, -0.03765216f, -0.02422203f, -0.02601092f, -0.03391021f, 0.02218211f, 
    -0.02145880f, -0.04055598f, -0.01590436f, -0.02308770f, -0.04187112f, -0.01546244f, 0.00027169f, -0.00534047f, 
    -0.03799491f, 0.00095673f, 0.03424001f, 0.02571619f, -0.01217826f, -0.03313749f, -0.02894814f, -0.01992638f, 
    -0.01662640f, 0.03312717f, -0.01779765f, -0.03021269f, 0.01519261f, -0.01434269f, 0.00662303f, 0.01746402f, 
    0.00016406f, -0.00216330f, 0.02706669f, -0.02162863f, -0.01271844f, 0.00365488f, 0.00020998f, 0.02518215f, 
    -0.02018780f, -0.02568815f, -0.00846547f, 0.01442993f, -0.02457497f, 0.00445016f, -0.01964510f, -0.01311798f, 
    -0.03978088f, 0.01663441f, 0.01803614f, -0.01121186f, -0.02281052f, -0.02382594f, -0.02564752f, -0.00643760f, 
    -0.00884664f, 0.01248664f, -0.04310816f, 0.00101406f, 0.00484135f, -0.04177357f, 0.02316901f, 0.02080177f, 
    0.02687664f, 0.03802333f, 0.03585372f, 0.03286864f, 0.02803040f, 0.01375226f, -0.03888429f, -0.02367249f, 
    0.00961438f, 0.00932248f, -0.01278878f, 0.01553636f, -0.01221753f, 0.02160253f, -0.03271098f, -0.03258429f, 
    0.02658878f, 0.02272144f, -0.02065422f, -0.01481626f, 0.01500465f, -0.02494530f, -0.03917296f, -0.03761544f, 
    0.00349006f, -0.02991437f, 0.02229415f, -0.03508994f, -0.03200650f, -0.01921531f, -0.03606289f, -0.02888376f, 
    0.00333992f, -0.01473422f, 0.01327525f, -0.02929365f, 0.02256714f, -0.01739315f, 0.00099790f, -0.02666435f, 
    -0.00394700f, -0.00136824f, -0.02439034f, 0.02386442f, 0.01464425f, -0.03277324f, -0.02574935f, -0.03959655f, 
    -0.02673925f, -0.01648321f, -0.01443230f, 0.02741216f, 0.00339399f, -0.00136999f, -0.01420910f, 0.01889866f, 
    -0.01941154f, 0.01850311f, -0.03184934f, -0.00001007f, -0.03454743f, 0.01320212f, -0.04298975f, 0.00946647f, 
    0.02980515f, 0.01567524f, -0.00257226f, -0.03516427f, 0.00148605f, -0.00620006f, 0.00663591f, -0.03069100f, 
    -0.01091520f, -0.00790453f, 0.00389233f, -0.01663916f, -0.00447015f, -0.03096227f, 0.02692159f, -0.00875092f, 
    0.03427552f, 0.01533918f, -0.03899695f, -0.03381538f, -0.01799872f, -0.00135761f, -0.02630552f, -0.00836594f, 
    0.01213188f, -0.03954455f, 0.01816434f, -0.02911873f, 0.00364340f, -0.02092533f, 0.00087797f, -0.00373314f, 
    -0.02416356f, 0.01641460f, -0.02639667f, 0.01457157f, 0.00800708f, 0.01743144f, -0.01887356f, -0.03847810f, 
    -0.02999740f, -0.02175792f, -0.03871962f, 0.02830909f, 0.03690889f, -0.02684411f, 0.03562392f, -0.02581965f, 
    -0.01491764f, 0.02608328f, 0.00475306f, -0.00005230f, -0.03268572f, 0.01417343f, -0.04319701f, -0.00294412f, 
    -0.00974518f, -0.00814004f, 0.01931495f, -0.01351776f, -0.02393621f, 0.00895722f, -0.02059715f, 0.01797379f, 
    0.00372419f, 0.01195504f, -0.03913681f, -0.00625004f, 0.03195383f, -0.02404561f, -0.04110647f, -0.03465487f, 
    0.02400274f, 0.02987652f, -0.03362846f, 0.00782120f, -0.00371034f, -0.01744491f, -0.00798606f, 0.02655432f, 
    0.02863471f, -0.00847728f, -0.00151268f, 0.02432178f, 0.01759727f, -0.01318339f, 0.00421856f, 0.00093925f, 
    0.03457101f, -0.02685936f, -0.01382279f, 0.02008938f, 0.01772280f, -0.02889225f, -0.01948416f, 0.01460930f, 
    -0.04694861f, -0.00299276f, 0.02858860f, -0.00082825f, -0.01894188f, 0.00262063f, 0.00282869f, 0.01737633f, 
    -0.02881796f, -0.01851187f, -0.02628580f, 0.01052609f, 0.02501051f, -0.03119027f, -0.04274806f, 0.01463274f, 
    0.03116329f, -0.03013951f, -0.03385324f, -0.00372835f, 0.00109484f, 0.02851352f, -0.02111949f, 0.01984996f, 
    0.01331745f, 0.02109744f, -0.03830127f, -0.00891672f, -0.03848043f, -0.03617262f, 0.02763610f, 0.03079842f, 
    0.02359400f, -0.03547536f, -0.03846737f, -0.04113289f, 0.01591893f, 0.03083704f, -0.01885795f, 0.00863274f, 
    -0.03434915f, -0.03158491f, -0.03075553f, -0.04513947f, 0.01075070f, -0.02707221f, -0.00698316f, -0.02512740f, 
    0.00009353f, -0.01028052f, -0.04139715f, -0.01929811f, 0.00125570f, -0.00112563f, -0.03303206f, -0.01612469f, 
    0.00466001f, -0.02053252f, -0.03254067f, 0.01073584f, -0.02121122f, -0.02820699f, -0.02797212f, 0.01445748f, 
    -0.00255729f, -0.02099370f, 0.01061427f, 0.03582129f, -0.00749358f, 0.02976126f, -0.02283479f, 0.03384163f, 
    -0.01301283f, 0.01112324f, -0.00878503f, 0.02483020f, 0.01756008f, 0.00630632f, -0.01889418f, -0.03518163f, 
    -0.03209597f, -0.03303529f, -0.02546047f, 0.01065114f, 0.02233011f, -0.00697737f, -0.03497180f, 0.00537988f, 
    -0.01229652f, 0.03162907f, -0.00542894f, -0.03932500f, -0.00546992f, -0.01833487f, -0.01414883f, -0.01934789f, 
    0.01157073f, -0.00335246f, 0.00204854f, 0.02906860f, -0.03466271f, -0.02322442f, -0.04504579f, 0.02446659f, 
    0.03520111f, 0.00884341f, 0.00302478f, 0.01479558f, -0.02976007f, -0.03430517f, 0.00924483f, -0.01753044f, 
    -0.01809577f, 0.02151066f, -0.00005857f, -0.02431948f, -0.00193693f, -0.01949705f, -0.04295421f, -0.03485986f, 
    -0.04001255f, -0.03200623f, -0.03940262f, 0.02252053f, -0.03891761f, -0.00894178f, -0.04207522f, 0.00136918f, 
    0.02364179f, -0.04423629f, -0.04012746f, 0.02412741f, -0.02952105f, 0.02012808f, -0.00458913f, 0.01931362f, 
    -0.00899735f, 0.02947947f, 0.01903052f, 0.02565800f, 0.03241491f, -0.00983533f, -0.02738818f, -0.00024950f, 
    -0.04106346f, 0.02759451f, 0.01165958f, 0.00977384f, 0.01362236f, 0.01494292f, -0.01891771f, 0.00418114f, 
    0.02384525f, 0.01534738f, 0.00221616f, -0.00085623f, -0.00524967f, -0.00109257f, 0.02278993f, -0.02662909f, 
    0.00227110f, 0.01871829f, -0.02168155f, -0.03325903f, -0.00227773f, -0.00008016f, -0.01109772f, -0.03788027f, 
    -0.02870062f, -0.04359394f, 0.02780920f, 0.02353349f, 0.00042725f, 0.00597879f, -0.01108413f, -0.00804549f, 
    -0.00451928f, -0.00390520f, -0.01783040f, -0.04512993f, -0.02175153f, 0.00154520f, 0.01065874f, -0.00818743f, 
    -0.03226405f, 0.01098961f, 0.01557543f, 0.00673909f, 0.00477545f, -0.00683599f, 0.03500065f, -0.01584996f, 
    0.00229141f, 0.03056735f, -0.03877687f, -0.01293480f, 0.01983789f, 0.00527841f, -0.03835058f, 0.03093193f, 
    -0.00341681f, -0.01264692f, -0.02253973f, 0.01553748f, 0.01773012f, -0.02535081f, 0.03313979f, -0.03508403f, 
    0.03468617f, 0.01769862f, -0.04448688f, -0.01839609f, -0.03863758f, -0.04015352f, -0.00273332f, -0.03284963f, 
    -0.03412884f, -0.04434723f, -0.03098015f, -0.02599082f, 0.01697788f, 0.01362750f, 0.01533057f, 0.02043501f, 
    0.00819055f, -0.02043303f, -0.00935036f, 0.02539999f, -0.02426675f, -0.01952164f, 0.01511261f, 0.03239514f, 
    -0.03262646f, -0.01294548f, 0.01229214f, -0.04372001f, 0.02614933f, -0.02463592f, -0.00648561f, 0.02769235f, 
    -0.02942188f, -0.00662756f, -0.04047094f, -0.00157197f, 0.00952302f, 0.00722724f, 0.01909112f, 0.03235173f, 
    -0.00069643f, 0.01912347f, -0.02194979f, 0.03042440f, -0.02443077f, 0.02551710f, -0.00506844f, 0.01862979f, 
    -0.00864738f, -0.03027146f, -0.01602609f, -0.01758222f, 0.03333627f, 0.00303168f, -0.01695829f, -0.01980481f, 
    -0.00209876f, -0.00277652f, -0.04215467f, -0.01216691f, -0.03679056f, -0.02311662f, -0.02471992f, -0.02767398f, 
    0.00997200f, -0.03113794f, 0.03902399f, -0.04322701f, 0.02697263f, 0.01386547f, -0.01866706f, -0.03465251f, 
    -0.00920074f, 0.00437727f, -0.01784334f, -0.00466024f, 0.01872974f, -0.02783539f, -0.00933677f, -0.01735597f, 
    0.00052029f, -0.01127695f, 0.01346513f, 0.00956361f, 0.01237813f, -0.03655452f, 0.02635020f, -0.01102661f, 
    -0.00259632f, -0.00505095f, 0.02209232f, -0.03652436f, -0.01242153f, 0.02378156f, 0.02855434f, 0.03091306f, 
    -0.03005395f, -0.01576876f, 0.00719213f, -0.00804048f, 0.00430678f, -0.03602213f, 0.01715353f, 0.01549987f, 
    -0.29954702f, -0.10082778f, 0.12027128f, 0.11640083f, 0.07236031f, -0.09851114f, -0.04261175f, -0.00694418f, 
    0.05468129f, 0.16217676f, -0.02833791f, -0.04604029f, -0.00366008f, 0.07996114f, -0.00235597f, 0.00778771f, 
    -0.11881643f, 0.03858205f, 0.01534829f, -0.07714351f, 0.00584011f, 0.24974924f, -0.09805331f, -0.08625297f, 
    0.07779480f, -0.00170592f, -0.11114702f, -0.03524495f, -0.04137724f, 0.05139998f, 0.02369644f, -0.00985768f, 
    0.10467456f, -0.00323650f, -0.01398016f, -0.08790103f, -0.00520333f, 0.04561146f, 0.08141429f, -0.00837689f, 
    -0.41753522f, 0.02620856f, 0.00933611f, -0.07772011f, 0.11557491f, -0.00240118f, -0.02567655f, -0.09993519f, 
    -0.01690736f, 0.04914922f, 0.01293637f, -0.02696583f, -0.01645158f, 0.04532725f, -0.07019287f, 0.11407430f, 
    -0.09754761f, -0.02803481f, 0.03005463f, -0.08868399f, 0.03846660f, 0.25301930f, 0.09934048f, 0.37676996f, 
    -0.15985018f, -0.09410235f, 0.00377996f, -0.03753854f, 0.00073833f, 0.01675650f, 0.05640724f, 0.05677445f, 
    0.08885832f, -0.05017244f, -0.09839422f, 0.05794875f, -0.04675695f, 0.01914136f, 0.05949138f, -0.02557506f, 
    0.16460499f, -0.31534803f, -0.06322167f, 0.31698340f, 0.05152624f, -0.08043049f, 0.18923186f, 0.01758456f, 
    0.04912149f, -0.11926180f, 0.16994691f, -0.03290058f, -0.01048507f, 0.04958461f, 0.04595272f, -0.09725475f, 
    0.10304604f, -0.10232886f, 0.20001736f, 0.10742798f, -0.35522190f, 0.08674767f, -0.03159495f, -0.21351169f, 
    0.03022827f, 0.17474797f, 0.02600995f, 0.04761272f, 0.03469741f, 0.05104094f, 0.02021644f, -0.06134449f, 
    0.08863624f, 0.02712255f, 0.06925760f, -0.05308422f, 0.04038663f, 0.04933015f, -0.15319538f, -0.01603217f, 
    -0.54149485f, -0.18391249f, 0.02379940f, 0.04072551f, -0.19625454f, 0.06109399f, 0.06498561f, 0.06956363f, 
    0.00128109f, 0.01351704f, -0.10561131f, 0.02864359f, -0.03028932f, -0.04157371f, -0.17973781f, -0.01974022f, 
    0.01708823f, -0.01917312f, 0.07441247f, -0.00309508f, 0.57965368f, 0.21912822f, -0.10097206f, 0.30150753f, 
    0.13971107f, -0.01941333f, -0.03866524f, 0.17208114f, -0.04111378f, 0.06601750f, -0.05120560f, -0.14579369f, 
    0.06151890f, 0.10436083f, 0.14712085f, 0.02758023f, -0.00865210f, -0.03099187f, -0.08283107f, 0.14779706f, 
    -0.53526956f, -0.09151080f, -0.21093951f, -0.12312071f, 0.05256199f, 0.02151560f, 0.05233760f, -0.01777264f, 
    -0.08200629f, -0.01261082f, 0.10574301f, 0.08815686f, 0.00441962f, 0.00843935f, 0.01002720f, 0.00073730f, 
    -0.01507810f, 0.00483590f, -0.02379170f, -0.04168514f, -0.34540430f, 0.01272836f, -0.08730405f, -0.05945244f, 
    0.42203730f, 0.04675122f, -0.00315263f, -0.05936265f, 0.21664901f, 0.09539720f, -0.00126933f, -0.05669051f, 
    -0.02178265f, 0.17069997f, 0.18685724f, -0.03940357f, -0.04034865f, 0.05791619f, -0.01340130f, -0.02138295f, 
    0.08414514f, 0.13881460f, -0.10237638f, -0.03890204f, 0.54065216f, -0.05715344f, -0.05757582f, 0.06505970f, 
    0.04989242f, 0.03317964f, 0.14248219f, -0.04842024f, 0.08362669f, 0.02584902f, -0.06367562f, 0.08293295f, 
    -0.04862364f, 0.05226257f, 0.00089150f, 0.05053025f, 0.13072324f, 0.01144332f, -0.20776926f, 0.43960202f, 
    -0.35805535f, 0.05008048f, -0.02209513f, 0.00231050f, 0.03811616f, 0.06824269f, 0.01346186f, -0.04667985f, 
    0.06657495f, 0.15859978f, -0.00097883f, -0.00456313f, 0.09711589f, -0.21862032f, 0.22310483f, 0.14174716f, 
    0.03562482f, 0.24787448f, 0.06852716f, -0.11205103f, 0.19123596f, 0.11447730f, 0.04076631f, 0.11097805f, 
    0.08520682f, 0.20155576f, 0.07069775f, -0.06042268f, -0.00005643f, 0.09853147f, -0.07726790f, 0.01256268f, 
    -0.14336751f, 0.24510214f, 0.09285357f, -0.11508254f, -0.31150314f, -0.01206601f, -0.00707596f, -0.12540314f, 
    -0.06587932f, 0.00663174f, 0.06883108f, 0.09191337f, 0.07816707f, -0.04516995f, -0.14521614f, 0.02489937f, 
    0.00968716f, -0.09745876f, -0.01153533f, -0.07394056f, 0.09162782f, 0.05236192f, -0.10114384f, 0.25432554f, 
    -0.11613852f, -0.02860848f, -0.14680348f, -0.05433914f, 0.06164479f, 0.13785447f, 0.08144549f, 0.00551049f, 
    -0.00313657f, -0.13021383f, 0.06124792f, 0.07632200f, -0.03105570f, 0.05471195f, 0.00021739f, 0.03560238f, 
    0.03191623f, -0.01015521f, 0.09054685f, 0.04437149f, 0.11604245f, 0.29071385f, 0.00440602f, 0.04393438f, 
    -0.08907451f, 0.00146165f, 0.05820091f, 0.12825447f, -0.03507712f, 0.01010585f, 0.07374018f, -0.09874216f, 
    -0.03848179f, 0.07113945f, -0.06822180f, 0.07997128f, -0.07840126f, -0.25083828f, -0.02816325f, -0.07294828f, 
    -0.36089796f, -0.19767778f, 0.03124574f, -0.19318175f, -0.03583259f, 0.09058499f, -0.06405777f, 0.06722560f, 
    0.07124780f, -0.02922652f, -0.02310957f, -0.02814117f, -0.11127323f, 0.10794257f, 0.00264910f, 0.07848588f, 
    -0.12508364f, 0.02286770f, -0.16891290f, -0.04175792f, -0.39768791f, -0.03846178f, -0.04745127f, -0.14550947f, 
    0.05317365f, 0.08829626f, 0.08703624f, 0.04969994f, -0.11583337f, -0.02768675f, 0.06202318f, 0.06261569f, 
    -0.03976321f, 0.10546063f, -0.05761101f, 0.06505275f, 0.07814526f, -0.00983275f, -0.07297756f, 0.02666363f, 
    0.18890224f, 0.29972011f, -0.13086402f, 0.47115150f, -0.05679712f, -0.02529798f, 0.02340563f, -0.04789934f, 
    0.01053613f, -0.01113437f, -0.00944836f, 0.00690040f, 0.10029644f, 0.00219701f, -0.06875785f, -0.02283561f, 
    -0.02429174f, -0.02579938f, 0.06263145f, 0.07491525f, 0.51038456f, 0.41834265f, 0.18480678f, 0.35244870f, 
    0.04248592f, -0.00021422f, -0.00853342f, 0.00431003f, 0.07457764f, 0.13123049f, 0.00927458f, 0.05426989f, 
    0.01616600f, -0.05893354f, -0.03216852f, -0.01695947f, -0.07771078f, 0.16128564f, -0.00496949f, -0.06925103f, 
    -0.35234338f, -0.19095610f, -0.02560255f, -0.12311621f, 0.02591716f, -0.01800281f, 0.19733974f, -0.01757567f, 
    -0.01052642f, -0.07824225f, 0.08920229f, 0.08329739f, 0.10816857f, -0.02428282f, 0.01091257f, 0.01574331f, 
    0.19533163f, -0.14776199f, 0.03924188f, 0.01998853f, -0.08124658f, -0.00364549f, -0.10062581f, -0.07774714f, 
    0.05520320f, 0.05028331f, 0.20114706f, -0.04061155f, -0.05737448f, -0.11598326f, -0.01976623f, 0.08228030f, 
    0.01293471f, 0.08880609f, -0.01589012f, 0.11954441f, 0.05526668f, -0.02535645f, -0.07771565f, 0.07875017f, 
    -0.00790694f, 0.21075049f, -0.20958504f, -0.18189338f, -0.30525374f, 0.00626717f, -0.03284902f, 0.01785059f, 
    -0.09838016f, -0.12363438f, 0.00677939f, -0.05619205f, 0.03189932f, 0.08889711f, 0.03683257f, -0.03740919f, 
    0.00119081f, 0.08459795f, 0.03821322f, 0.01292145f, 0.47249550f, 0.24873626f, 0.08965856f, 0.49210483f, 
    0.07893697f, 0.00305770f, 0.09586771f, 0.07038467f, 0.07239993f, -0.00325314f, 0.04874264f, 0.04387141f, 
    0.04816152f, -0.01620658f, -0.02367973f, -0.05510023f, 0.08903778f, 0.05914215f, 0.10236549f, -0.03050716f, 
    0.00397039f, 0.28784132f, -0.26404774f, -0.25219160f, 0.17244974f, 0.08652260f, 0.01528410f, 0.00021160f, 
    -0.02000991f, 0.00760283f, 0.00220289f, 0.11941194f, 0.04810787f, 0.01163187f, 0.04337807f, -0.13259459f, 
    0.07782830f, 0.16642419f, 0.07683492f, 0.03513217f, -0.08451086f, 0.01436531f, 0.11143238f, -0.23026651f, 
    0.29825380f, 0.08345894f, -0.20889527f, -0.05228372f, -0.00477665f, -0.08164221f, 0.08418676f, 0.00367024f, 
    0.03895582f, -0.03032492f, -0.11725151f, 0.04631268f, 0.09076694f, 0.04046550f, -0.08697861f, 0.04870171f, 
    -0.47715920f, -0.21631634f, -0.09138466f, 0.11864462f, 0.01700415f, -0.13465571f, 0.06242843f, 0.18661532f, 
    -0.07666440f, -0.09375692f, 0.03417604f, -0.01633394f, -0.05781032f, 0.06939559f, 0.03245762f, 0.13070108f, 
    -0.05141587f, 0.02383665f, -0.13094459f, -0.04890774f, 0.39064670f, 0.09745212f, -0.13556819f, -0.10669581f, 
    0.15764107f, 0.02655528f, -0.18179521f, -0.10356185f, -0.03832032f, 0.06468108f, 0.23931599f, 0.05609515f, 
    0.01348035f, 0.01733760f, -0.11298715f, -0.11945205f, 0.00477145f, -0.11302951f, 0.10494914f, -0.03446006f, 
    -0.09192031f, -0.18624966f, -0.00349342f, 0.01403347f, 0.17204589f, 0.01728473f, -0.05390843f, 0.08031894f, 
    0.01603495f, -0.14316663f, 0.04097669f, -0.05738697f, -0.09702618f, 0.16962698f, 0.14079073f, 0.00498446f, 
    -0.04699632f, -0.04908402f, -0.21516943f, 0.01196775f, 0.37895414f, 0.06530415f, 0.17793271f, -0.00288513f, 
    0.17740527f, 0.13810767f, -0.00458369f, -0.01264526f, -0.00479671f, 0.03579193f, -0.03295762f, 0.09498002f, 
    -0.02384385f, 0.19401732f, 0.05644357f, -0.06945015f, 0.02217455f, -0.02471710f, -0.01008224f, -0.01029834f, 
    -0.00080260f, 0.38205650f, 0.32862189f, 0.33311328f, 0.48377606f, 0.00495827f, -0.01005202f, -0.03583733f, 
    0.00633603f, 0.14941578f, -0.01207229f, -0.15043421f, -0.02943796f, -0.04651592f, 0.08542897f, -0.09369272f, 
    0.07142697f, -0.08593173f, 0.03769390f, -0.10421535f, 0.44450939f, 0.32360080f, -0.09900028f, 0.24527164f, 
    -0.15998797f, 0.10412250f, 0.00167719f, 0.00693131f, -0.03908493f, 0.13073020f, -0.09967605f, 0.06827807f, 
    -0.09747651f, -0.02515638f, -0.07238704f, 0.07151573f, -0.01191187f, -0.07713304f, -0.00698078f, 0.09722526f, 
    0.12500639f, 0.18434960f, -0.11964489f, -0.05041424f, 0.03648527f, 0.13313313f, -0.03168542f, 0.05498504f, 
    0.01460890f, -0.20160413f, 0.01666419f, 0.04655338f, -0.07668681f, 0.25019592f, -0.13631682f, 0.08739273f, 
    -0.00099444f, -0.06182960f, 0.01977427f, 0.08176570f, -0.21721402f, 0.25207937f, -0.04580251f, 0.38026580f, 
    0.09178130f, -0.01219534f, -0.02757365f, -0.04801054f, -0.05262236f, 0.05587112f, 0.05239511f, 0.08305225f, 
    -0.04142396f, -0.00384988f, 0.08601870f, -0.01681654f, -0.04186135f, 0.06281447f, 0.14441425f, 0.09375447f, 
    -0.09306823f, 0.15243548f, -0.19155440f, 0.11690558f, -0.12374409f, 0.02940726f, -0.05965233f, 0.12719046f, 
    -0.08708706f, -0.01528648f, 0.14389409f, 0.00149287f, 0.06019203f, -0.04992270f, 0.10239531f, 0.08389954f, 
    -0.00391820f, 0.07537611f, -0.02349930f, 0.03833331f, 0.07783617f, -0.11530475f, 0.03255564f, 0.07030765f, 
    -0.26809707f, 0.16147029f, 0.00247927f, 0.04008450f, 0.05860837f, -0.10375698f, -0.00318141f, -0.03424815f, 
    -0.05084212f, 0.01288201f, -0.12668264f, 0.01399668f, 0.02117983f, -0.06383115f, 0.06953170f, -0.00164374f, 
    -0.25192350f, 0.45026165f, -0.00136759f, -0.19474073f, -0.15765868f, -0.09873529f, -0.07680544f, -0.07915363f, 
    0.16440478f, 0.06525490f, -0.10353736f, -0.07760000f, -0.04562323f, 0.02798053f, -0.01715245f, -0.01176210f, 
    0.14230265f, 0.05533482f, 0.04196952f, -0.08041680f, 0.28054842f, -0.15591353f, -0.02182856f, -0.09444335f, 
    0.11632811f, -0.02093442f, 0.12881100f, 0.10076773f, 0.01071646f, 0.06100203f, -0.02990227f, 0.04921737f, 
    0.09152562f, 0.00414969f, -0.07064372f, 0.02367803f, 0.05285856f, 0.02979204f, 0.19163339f, 0.06560064f, 
    0.26879343f, -0.06608136f, -0.03744181f, -0.06289259f, -0.15227965f, 0.27818418f, -0.07195262f, 0.10288060f, 
    -0.02522458f, -0.08295143f, 0.06884000f, 0.03677419f, 0.01099308f, 0.07714413f, 0.00907468f, -0.01138243f, 
    0.03476836f, -0.09539924f, -0.01293427f, -0.04447776f, -0.41455472f, -0.37746269f, 0.24678385f, 0.17120656f, 
    -0.13295357f, -0.19398327f, 0.09744130f, -0.00975825f, -0.05808280f, 0.03209118f, -0.06247142f, -0.04317536f, 
    -0.01108850f, -0.09057278f, 0.04521707f, -0.16296084f, -0.04994281f, -0.02754247f, 0.09420242f, 0.06821325f, 
    -0.06872466f, -0.08888803f, -0.28015167f, 0.13933381f, 0.23728943f, 0.16153842f, 0.03727985f, 0.01215571f, 
    0.07475543f, 0.09541085f, -0.01941671f, 0.01372501f, 0.00011836f, -0.07776312f, 0.00758022f, 0.07565275f, 
    -0.09685440f, 0.07662060f, 0.00315484f, 0.03375349f, 0.32523912f, -0.15612148f, -0.15004258f, 0.05832736f, 
    0.25755247f, -0.01132438f, 0.02457296f, -0.04196815f, -0.03542213f, 0.08949029f, 0.20009078f, 0.07452507f, 
    -0.04726296f, -0.05305755f, -0.01867637f, -0.03429157f, 0.09028713f, 0.05175830f, -0.00578998f, -0.04172099f, 
    0.27430385f, 0.26168966f, -0.21514586f, 0.14729345f, 0.01839229f, -0.20601280f, -0.02055503f, -0.05442081f, 
    0.07152809f, -0.08467281f, -0.19011670f, -0.14679602f, -0.12268761f, 0.15254562f, -0.06567883f, 0.08358337f, 
    0.02531726f, 0.15668254f, -0.14052093f, 0.14274558f, -0.25314301f, -0.19105877f, 0.72551757f, 0.25555229f, 
    -0.27062163f, -0.17913543f, 0.04260984f, 0.02669242f, 0.03363652f, 0.01501900f, -0.15493831f, 0.02456778f, 
    -0.15646058f, -0.01528477f, -0.07613406f, -0.05492581f, 0.13197744f, 0.08157540f, -0.01999187f, 0.16089794f, 
    0.31047264f, -0.24926841f, 0.15518919f, 0.12695439f, -0.09171221f, -0.07084599f, 0.04933935f, -0.02344777f, 
    -0.09080564f, -0.03920088f, 0.03297202f, 0.10705113f, 0.15760359f, -0.04788335f, 0.03584684f, 0.05295871f, 
    0.13684268f, -0.01194505f, 0.01313656f, 0.06762132f, -0.14355171f, 0.28402326f, 0.36032560f, -0.01030424f, 
    0.16423887f, -0.01181407f, 0.15194958f, 0.15083909f, -0.04672293f, 0.06721024f, 0.06931702f, -0.01361829f, 
    0.12298605f, -0.02733500f, -0.13291803f, -0.08858050f, 0.07430246f, 0.08254224f, 0.02123735f, 0.24171793f, 
    -0.53555262f, 0.40829289f, 0.02584123f, 0.13404568f, 0.21067913f, 0.16570416f, 0.04635328f, 0.03014389f, 
    0.04940782f, 0.11563887f, -0.05681016f, -0.01711851f, 0.01693236f, 0.03523357f, 0.16860083f, -0.04231346f, 
    0.04133627f, 0.01361435f, 0.09038722f, -0.13039541f, -0.10856188f, -0.33951813f, 0.21457396f, 0.04914334f, 
    0.07183840f, 0.00585830f, -0.04793364f, 0.05850081f, 0.08222131f, 0.02199657f, -0.02482152f, 0.03114484f, 
    0.00761547f, 0.04909522f, -0.08949648f, -0.01761910f, -0.08616178f, -0.04337158f, 0.10535739f, 0.07151655f, 
    0.37616932f, -0.27140069f, -0.13288546f, 0.14517565f, 0.11557359f, -0.01629922f, -0.09571244f, -0.04650772f, 
    -0.02906224f, 0.09229901f, 0.07341282f, 0.06733081f, -0.07412800f, -0.08805531f, 0.04561483f, -0.05979805f, 
    0.01563033f, -0.07338675f, 0.01433309f, 0.02529277f, -0.19091003f, -0.19683650f, -0.27395174f, 0.10802741f, 
    0.33755258f, 0.19088228f, 0.09652346f, 0.14108850f, 0.02919248f, 0.01053295f, -0.05556970f, 0.06855093f, 
    0.06416461f, -0.14138491f, 0.01070284f, 0.07614872f, -0.04048532f, 0.11656173f, -0.00738068f, -0.02147973f, 
    -0.15045901f, -0.13430697f, 0.02422737f, -0.12336630f, -0.40176788f, -0.05834534f, 0.01902714f, 0.11005931f, 
    0.01197179f, 0.05011944f, 0.03353697f, -0.03634293f, -0.06153159f, -0.12692359f, 0.12796509f, 0.08716425f, 
    0.07516801f, 0.07950519f, -0.03594749f, 0.00310111f, -0.01173749f, -0.21645722f, 0.00646631f, 0.08952825f, 
    -0.29574046f, -0.21797703f, 0.02374119f, 0.13091190f, 0.06008961f, -0.03174429f, -0.04359152f, -0.06315377f, 
    -0.09787423f, -0.04084917f, -0.12730719f, -0.09081217f, 0.01954128f, -0.16659750f, 0.03412253f, 0.16722822f, 
    -0.34209341f, -0.15241934f, -0.13791305f, 0.01899560f, 0.15872803f, 0.16983321f, 0.07354457f, -0.00378868f, 
    0.05546969f, 0.15586048f, -0.05551909f, 0.07054750f, 0.00421923f, 0.02357994f, 0.10463016f, 0.03738451f, 
    -0.07366380f, 0.09112040f, 0.04131398f, 0.04797515f, -0.52404016f, -0.03728227f, -0.15673913f, 0.08374550f, 
    0.33614853f, 0.18738006f, -0.03307645f, -0.00951511f, -0.12367469f, 0.15262383f, 0.15152188f, 0.12453108f, 
    0.05951057f, -0.08996514f, 0.04348180f, -0.02111502f, -0.00433648f, -0.04258557f, 0.12379809f, -0.11589143f, 
    0.35725281f, -0.41070473f, 0.45484132f, 0.07567344f, -0.00178685f, 0.06468993f, -0.02378777f, 0.03518388f, 
    0.02505215f, -0.09836027f, 0.00096378f, -0.00527655f, -0.06721587f, 0.00943923f, 0.24353279f, -0.04111833f, 
    -0.00684689f, -0.09037491f, 0.03359215f, -0.06806161f, -0.16997588f, -0.10045773f, 0.17472106f, -0.09980726f, 
    -0.17014599f, 0.08587611f, 0.12721957f, -0.02482445f, -0.00783384f, 0.11341900f, -0.10186142f, -0.06886423f, 
    -0.09144240f, -0.06427801f, 0.08910920f, -0.01056657f, 0.02151125f, -0.03885949f, 0.03702544f, 0.01296680f, 
    0.11274903f, 0.16126619f, 0.22523847f, 0.35983035f, 0.16631041f, -0.06153163f, 0.09882607f, 0.01428835f, 
    0.09661781f, 0.03855719f, 0.03296066f, 0.10557663f, -0.00216607f, -0.00512773f, 0.28320423f, 0.02706094f, 
    -0.09359404f, 0.02083827f, 0.14429118f, 0.01364996f, -0.27454698f, 0.24582832f, -0.08244892f, 0.17785913f, 
    -0.27625299f, -0.03000268f, 0.02533673f, -0.10655286f, -0.00826891f, -0.00359680f, -0.08429708f, -0.03542957f, 
    0.00955444f, 0.08694937f, 0.03278207f, 0.07267092f, 0.04506468f, 0.07183587f, -0.00798476f, -0.10909975f, 
    0.01798406f, -0.14388269f, 0.05265506f, 0.03290550f, 0.01430746f, 0.17452146f, -0.01162783f, 0.07108856f, 
    -0.00786451f, -0.04171715f, 0.16947003f, -0.00076619f, 0.12697521f, 0.03533533f, -0.05090676f, 0.03254624f, 
    0.10525887f, -0.05208072f, 0.10110118f, -0.12334102f, -0.08105659f, 0.55144221f, -0.16076814f, 0.13556695f, 
    -0.01145293f, -0.06352550f, 0.07646082f, 0.00978761f, -0.03556685f, -0.08933115f, -0.07443407f, -0.11401818f, 
    0.01514839f, 0.10384982f, 0.05697173f, 0.05802863f, 0.10473698f, 0.10353262f, -0.09803856f, 0.06603166f, 
    -0.01900081f, -0.04184024f, 0.25916797f, -0.03451306f, 0.03916793f, -0.18431276f, -0.02527604f, 0.00009959f, 
    -0.13247442f, 0.16336033f, -0.09210257f, -0.14579237f, 0.02507729f, 0.05384916f, 0.04842192f, -0.09912503f, 
    -0.02991858f, 0.17845549f, -0.01478649f, 0.10133854f, -0.15439489f, 0.38533491f, -0.02294546f, 0.04142170f, 
    -0.13160440f, -0.03846210f, 0.03958784f, 0.00027359f, 0.08166874f, 0.02933050f, 0.05797820f, -0.04374750f, 
    0.08246626f, 0.00149179f, 0.22060357f, 0.10341378f, -0.00547726f, -0.03060442f, -0.06439617f, -0.01337116f, 
    0.13612936f, 0.14425367f, 0.03420442f, -0.06761893f, -0.00180408f, 0.10825870f, 0.02831793f, 0.01616153f, 
    0.05013064f, -0.21763495f, 0.00730569f, 0.01281442f, -0.16894051f, 0.15296939f, -0.05991447f, 0.09875859f, 
    0.00139600f, -0.16915919f, -0.11947258f, -0.20189674f, -0.03841783f, 0.14448996f, 0.14396663f, -0.00567286f, 
    -0.18029857f, 0.05048187f, -0.03603783f, 0.11499848f, -0.07962710f, 0.13774149f, -0.08888397f, -0.00062085f, 
    0.12401881f, -0.02981672f, -0.02151398f, 0.24157417f, 0.08423564f, 0.18660831f, -0.03330849f, -0.03534904f, 
    -0.26802322f, 0.44337347f, 0.15095906f, 0.10773055f, -0.09009186f, 0.00422287f, -0.03225009f, -0.02054981f, 
    0.00808664f, -0.10993140f, 0.11806664f, -0.00790885f, 0.04624062f, -0.02153973f, 0.01990886f, -0.01722491f, 
    -0.08754975f, 0.15278743f, 0.03364450f, 0.13197936f, 0.13162613f, -0.16458923f, 0.09697028f, 0.16424407f, 
    -0.15784967f, 0.04048418f, 0.07598557f, 0.08687906f, 0.20660163f, 0.21290724f, -0.15180568f, -0.04861989f, 
    0.16519731f, 0.04938277f, -0.06125284f, -0.07374392f, 0.11652701f, -0.20882243f, -0.00400252f, -0.03256571f, 
    -0.33204487f, 0.01245501f, 0.17813291f, -0.03174002f, -0.14585102f, -0.02259537f, -0.01910292f, -0.13330363f, 
    -0.00676698f, 0.13491054f, 0.13092203f, -0.11565014f, -0.00771281f, -0.04508277f, -0.13706201f, 0.16110197f, 
    -0.00010043f, -0.06138876f, 0.09135705f, -0.05645575f, 0.02124782f, 0.48537016f, 0.00173404f, 0.00981371f, 
    0.31309435f, 0.15000720f, 0.06183675f, 0.09817186f, -0.06763259f, 0.10738874f, 0.00256431f, 0.03891969f, 
    -0.02292568f, 0.00866194f, -0.00657631f, 0.05935583f, 0.02857001f, 0.19017166f, 0.01729458f, 0.09658757f, 
    -0.33742467f, -0.04641452f, 0.24029641f, -0.20363031f, 0.12993762f, -0.05294379f, 0.07394363f, 0.02421157f, 
    -0.11405961f, 0.09160364f, -0.05953073f, 0.00141012f, 0.08539384f, 0.07199719f, 0.07285292f, -0.10659251f, 
    0.07914829f, -0.14990763f, 0.04069981f, 0.11215076f, -0.18500300f, -0.00944877f, -0.16301803f, -0.00944636f, 
    -0.30348954f, 0.06111957f, 0.08962952f, -0.08768462f, 0.08028628f, 0.03303052f, 0.03899189f, 0.03012481f, 
    -0.10457153f, -0.05308400f, -0.02213625f, -0.00542499f, -0.09060172f, -0.04856392f, -0.17932281f, 0.01446970f, 
    -0.44414899f, 0.35629246f, -0.27650666f, -0.16967523f, -0.05838877f, -0.02175769f, 0.05075312f, 0.09030823f, 
    -0.00953150f, 0.04079652f, -0.02558901f, 0.01288409f, 0.08269629f, -0.05462228f, 0.02483592f, 0.04991464f, 
    0.06521105f, 0.10598338f, 0.09671547f, 0.00675184f, 0.10071814f, -0.29223025f, 0.26616606f, 0.23373966f, 
    0.09482360f, -0.01021571f, -0.12879066f, 0.15356158f, 0.03481828f, 0.06442514f, -0.02255294f, -0.05648451f, 
    0.02865373f, 0.10155846f, 0.10040071f, 0.03577965f, 0.06888662f, -0.17676264f, -0.00744796f, -0.02510249f, 
    -0.40559149f, -0.05798826f, 0.00805952f, 0.12372169f, -0.00046950f, 0.06464730f, 0.05287518f, 0.09932278f, 
    0.10161042f, 0.20284066f, 0.26093680f, 0.12003399f, -0.15623662f, -0.06257009f, 0.00695789f, 0.04285662f, 
    0.10829420f, -0.09299450f, 0.02486574f, 0.12418091f, -0.04435987f, -0.04236889f, 0.24534988f, 0.24885489f, 
    -0.12472147f, 0.02560616f, 0.02542591f, -0.17339686f, 0.12945312f, 0.04253037f, 0.13322343f, -0.01333150f, 
    0.14699565f, 0.16678312f, 0.07742424f, 0.03448798f, 0.06160114f, -0.07807079f, -0.16392241f, -0.01855971f, 
    -0.14320737f, -0.21314718f, 0.28865737f, 0.07775895f, -0.39255419f, 0.08469126f, 0.00435333f, 0.07883236f, 
    -0.07682222f, -0.02581387f, 0.10401248f, 0.12585606f, -0.01406751f, -0.01417596f, 0.04841173f, 0.02940005f, 
    -0.07945599f, -0.07704391f, 0.01494191f, -0.10130070f, -0.21648642f, -0.13569885f, 0.11492548f, 0.13528924f, 
    -0.07224640f, 0.01425776f, -0.14183261f, 0.05355303f, -0.15067257f, 0.14269459f, 0.05425182f, -0.08008262f, 
    0.07176974f, -0.06283444f, 0.19050632f, -0.17307001f, -0.12956651f, -0.23070255f, 0.04131693f, -0.10031659f, 
    -0.00038375f, 0.11626061f, 0.12022230f, 0.07482300f, 0.14513531f, -0.03618340f, -0.06739810f, -0.00264771f, 
    -0.07257842f, 0.09186266f, 0.05878868f, 0.01024460f, 0.01734241f, 0.10342358f, -0.00076822f, -0.01481917f, 
    -0.04206353f, 0.16091926f, 0.00467805f, 0.02739416f, 0.05887154f, -0.04271750f, -0.05088417f, -0.29238582f, 
    -0.40543386f, 0.14117680f, -0.05595952f, 0.17333765f, -0.02738159f, 0.03417176f, -0.07298967f, -0.01444522f, 
    -0.03360552f, -0.11827280f, -0.00996243f, -0.18629639f, -0.06118145f, -0.09857200f, 0.07559570f, 0.00670147f, 
    0.06702905f, 0.26391295f, 0.01156438f, 0.03825213f, 0.07211415f, -0.09800267f, -0.01925194f, -0.06629775f, 
    -0.03159167f, -0.04690553f, 0.05655951f, 0.10679197f, -0.06128539f, -0.02383495f, -0.05836744f, -0.03489439f, 
    0.16668561f, 0.01895948f, 0.10843128f, -0.04796987f, -0.32071856f, 0.11022558f, -0.12909901f, -0.07392524f, 
    0.14510402f, -0.13319863f, -0.00813445f, 0.09862529f, -0.04411558f, 0.08220490f, 0.22254673f, -0.07990140f, 
    -0.01945331f, 0.07186701f, 0.05165672f, 0.07804191f, 0.10181044f, -0.01625935f, -0.10111979f, 0.01643138f, 
    -0.03547878f, -0.05725827f, -0.17109998f, 0.02202944f, -0.04188113f, 0.08267450f, 0.03509264f, -0.07041071f, 
    0.22219855f, -0.12443778f, -0.02652691f, 0.10794291f, -0.05945334f, 0.14789227f, -0.22263628f, -0.00130629f, 
    0.00974799f, 0.11932416f, -0.10631158f, 0.12292235f, -0.14110640f, 0.08088127f, -0.06692798f, 0.14731020f, 
    0.02682933f, 0.16635525f, 0.12637435f, -0.02324001f, 0.20221835f, 0.18100791f, 0.13283521f, -0.02148068f, 
    -0.11349824f, 0.13887757f, -0.11058678f, 0.05446590f, 0.21388099f, 0.01349099f, 0.00019888f, -0.05516298f, 
    -0.30434337f, 0.01678044f, 0.12942845f, 0.13435185f, 0.23766360f, -0.11492779f, -0.17821921f, 0.00917826f, 
    -0.11442094f, 0.04326997f, -0.08823920f, -0.01705773f, 0.01069719f, 0.17022523f, -0.08305058f, 0.13715290f, 
    0.00034832f, 0.04212837f, 0.10553170f, 0.05729125f, -0.06313804f, -0.05286650f, 0.16706082f, 0.09535839f, 
    0.28157502f, -0.12895240f, -0.14149995f, -0.04176407f, -0.08634575f, 0.01876014f, 0.01243345f, -0.05041981f, 
    0.03028643f, 0.14483039f, 0.08038713f, 0.06908227f, 0.05826038f, 0.16198057f, 0.09379856f, 0.12703399f, 
    -0.24044658f, 0.11421767f, -0.09050705f, 0.04971494f, -0.08057442f, -0.01765551f, 0.06535839f, 0.04512476f, 
    0.01884007f, 0.08570961f, 0.15894121f, 0.13163006f, -0.03378876f, -0.11997512f, 0.07278696f, 0.05649761f, 
    0.14830142f, -0.02787995f, 0.10264491f, 0.11627244f, -0.01007864f, 0.15899703f, -0.09513458f, 0.05751664f, 
    -0.24896249f, 0.01029275f, -0.02305649f, -0.00833456f, 0.13446295f, 0.12415057f, -0.02963134f, 0.00935212f, 
    -0.01673753f, 0.04624136f, 0.06783751f, 0.21016587f, 0.15792695f, 0.04651058f, -0.01824704f, 0.11192100f, 
    -0.38523921f, 0.17639828f, -0.34462762f, -0.06522071f, -0.12132894f, -0.06077074f, 0.01378636f, 0.01270215f, 
    -0.02823159f, 0.11277796f, 0.05389187f, 0.07139638f, -0.08758770f, -0.02602143f, 0.03160510f, -0.07530869f, 
    -0.06239073f, 0.09782647f, -0.17503144f, -0.02257863f, -0.44307721f, 0.15056448f, 0.22499844f, 0.08707836f, 
    0.28039396f, -0.04489810f, -0.00912190f, 0.00689227f, -0.07732396f, 0.05912695f, -0.08740292f, -0.01878873f, 
    0.00435188f, 0.07020085f, 0.06536037f, -0.01330393f, -0.00028916f, -0.00375169f, 0.02420741f, 0.07364063f, 
    0.16499317f, -0.13401228f, 0.02890076f, 0.09450448f, 0.01322365f, 0.30475378f, 0.05779846f, 0.12348533f, 
    0.23832345f, 0.20141485f, -0.04336113f, -0.03533335f, 0.03666657f, 0.03396171f, 0.01898062f, -0.07970160f, 
    0.05789883f, -0.27572733f, -0.10616808f, 0.00910835f, 0.23360837f, -0.54945642f, -0.10249916f, -0.07517497f, 
    -0.04389153f, -0.10183278f, 0.09593506f, -0.02273086f, 0.00101023f, -0.12266683f, 0.05167118f, -0.03286999f, 
    0.10101460f, -0.09209424f, -0.07070825f, -0.03869765f, -0.17700136f, 0.03673428f, -0.01192517f, -0.08374456f, 
    0.03457157f, 0.46943524f, 0.00376742f, 0.00802285f, 0.18475516f, -0.05893334f, -0.04780578f, 0.13558279f, 
    0.11148325f, -0.01594935f, 0.07196647f, 0.04466613f, -0.20355344f, 0.03165096f, -0.03222874f, 0.03328306f, 
    0.04044069f, 0.09901074f, 0.09647982f, 0.02030234f, 0.11616443f, -0.22518486f, 0.08715607f, -0.04585084f, 
    -0.09946843f, 0.01593838f, -0.10994320f, 0.06634007f, -0.00879787f, 0.04596247f, 0.10130470f, 0.04204276f, 
    -0.02151687f, 0.02184910f, -0.03415013f, -0.00805577f, -0.05149622f, -0.05844707f, 0.14758632f, 0.03046665f, 
    -0.11481695f, -0.20944014f, 0.01297192f, 0.10207174f, -0.08100930f, 0.00642130f, -0.05073564f, 0.00091974f, 
    -0.07827637f, 0.00229289f, -0.00660829f, 0.03562066f, 0.02837534f, 0.09303812f, 0.13148612f, 0.08281292f, 
    0.00384689f, -0.16470675f, -0.11843555f, 0.01234932f, 0.38726145f, 0.12411661f, 0.31818193f, -0.03222547f, 
    0.16225731f, -0.00905249f, -0.03659753f, -0.04511704f, -0.03018561f, -0.07865311f, 0.14006086f, 0.00792597f, 
    0.05472482f, 0.00564187f, 0.02208320f, -0.10762370f, 0.10184301f, 0.04135527f, 0.17466100f, 0.02035884f, 
    -0.31564003f, 0.34357253f, 0.48020101f, -0.01663662f, -0.06155365f, 0.07769925f, 0.09532119f, 0.02248893f, 
    -0.04678996f, 0.15982431f, 0.11532504f, -0.09244075f, 0.14777581f, -0.01099059f, 0.09065565f, -0.07106528f, 
    0.00433419f, -0.05731953f, -0.00970656f, 0.16146162f, 0.48178527f, -0.42299250f, -0.07123572f, -0.22302303f, 
    0.04390262f, -0.15463546f, -0.19043700f, -0.03728329f, -0.11410170f, -0.01481429f, -0.07655848f, -0.03328729f, 
    -0.10372979f, 0.03408032f, 0.05628490f, -0.02605087f, 0.00865368f, 0.10588235f, 0.01920595f, -0.01437823f, 
    0.01784077f, -0.03873707f, -0.00769025f, -0.02675786f, 0.00389696f, -0.01687705f, -0.00356311f, -0.02707584f, 
    0.01160966f, 0.01022678f, 0.01548447f, -0.00685228f, -0.00698352f, 0.00496902f, 0.01990177f, -0.01245726f, 
    -0.01134251f, -0.00005145f, -0.02420489f, -0.02009529f, 0.00818854f, -0.00345139f, -0.03397667f, 0.03998322f, 
    0.03583440f, 0.00957173f, -0.02170651f, 0.03250782f, 0.02848579f, 0.00507555f, -0.02526386f, -0.00492088f, 
    -0.04509754f, 0.01129756f, -0.01705787f, -0.04020408f, 0.03172041f, -0.00995629f, -0.02955856f, 0.02614959f, 
    -0.01129343f, -0.00382458f, 0.01924574f, 0.03316698f, 0.00614100f, 0.02189305f, 0.02608150f, -0.02635958f, 
    -0.01432578f, 0.02390974f, -0.03616397f, -0.00735996f, -0.00766644f, -0.04057106f, -0.01749893f, -0.00373042f, 
    -0.04389089f, -0.01021552f, 0.03599182f, -0.01023357f, 0.03875664f, -0.03001657f, 0.01889517f, 0.02270112f, 
    -0.02737598f, -0.00278989f, 0.02462499f, -0.00054791f, 0.03714614f, -0.03596686f, -0.02626603f, -0.03189470f, 
    0.02009919f, 0.00982293f, 0.01473073f, -0.00304230f, -0.03225563f, -0.00241723f, -0.01760973f, -0.02486352f, 
    -0.01123495f, -0.03107545f, 0.00437910f, -0.01116488f, -0.04284728f, -0.02382273f, 0.01536818f, 0.00342051f, 
    -0.01659969f, 0.00690414f, 0.01620068f, -0.03273534f, -0.00370578f, -0.00592600f, -0.04383141f, 0.01560929f, 
    -0.02623271f, 0.02416895f, -0.01917361f, -0.02210234f, 0.04513852f, -0.00995067f, -0.03321514f, 0.03172215f, 
    -0.03835810f, 0.02504573f, 0.02769970f, 0.03553865f, 0.01762238f, 0.03138943f, 0.01962558f, -0.03533723f, 
    0.01443969f, 0.00469307f, 0.00851476f, -0.00112129f, -0.02454633f, 0.02302461f, -0.01339587f, 0.01179854f, 
    -0.01555379f, 0.02615181f, 0.02865381f, -0.02155737f, -0.02363121f, -0.00564853f, -0.01112371f, -0.01523220f, 
    -0.02437759f, 0.02945887f, -0.00720287f, -0.02611475f, -0.02265984f, 0.01638310f, -0.01812009f, 0.02185684f, 
    0.01725027f, -0.01144253f, -0.01211727f, -0.01356573f, -0.04870179f, -0.00549958f, -0.02139096f, 0.01122239f, 
    0.01036495f, -0.00959094f, -0.03607054f, 0.01639414f, -0.00614650f, -0.03309464f, -0.01547288f, -0.01957015f, 
    0.00936727f, -0.03818442f, -0.01588719f, 0.00640690f, -0.00742849f, -0.03873486f, -0.02165276f, 0.02817852f, 
    -0.03082520f, 0.01421208f, -0.03561908f, -0.02126700f, -0.01378506f, -0.02924005f, -0.03164145f, -0.00327030f, 
    0.04292374f, 0.01232580f, -0.03498341f, -0.00485013f, -0.00242777f, 0.00511499f, -0.00089981f, -0.01110074f, 
    -0.03460981f, 0.00540308f, 0.00842271f, -0.03073027f, -0.01637088f, -0.00539135f, 0.00008515f, 0.02697388f, 
    0.03896912f, 0.00517598f, -0.01482328f, 0.01477843f, 0.01580239f, 0.02558629f, -0.01087569f, -0.03235094f, 
    -0.03811787f, -0.02750791f, -0.03760091f, 0.01322943f, -0.00296920f, -0.03577095f, 0.02368279f, 0.01317408f, 
    -0.01806669f, 0.00679093f, 0.01716601f, -0.01945114f, -0.02725022f, 0.03533548f, 0.00622116f, 0.03466531f, 
    -0.00921287f, 0.03025866f, 0.01024699f, -0.04346460f, -0.02327930f, 0.01363518f, 0.02450914f, -0.01918731f, 
    -0.02303712f, 0.02106226f, -0.02548713f, 0.03224779f, -0.04424136f, -0.02113357f, 0.01276013f, 0.02616558f, 
    -0.00720706f, -0.02202442f, -0.00580539f, 0.03149289f, 0.03071670f, -0.02697673f, 0.01622880f, 0.02611186f, 
    -0.03831936f, -0.00435111f, 0.03692754f, 0.02275743f, 0.01236602f, 0.01767583f, -0.01646590f, -0.02145376f, 
    -0.02720295f, -0.01683688f, -0.01191582f, -0.00682808f, 0.02158769f, 0.03986168f, 0.02695493f, 0.00465568f, 
    -0.00349864f, 0.02178364f, 0.03280767f, -0.01678477f, 0.02512708f, 0.02449118f, 0.03805199f, 0.00958734f, 
    0.00762673f, 0.00885711f, -0.01967720f, 0.02254422f, -0.00771018f, -0.02643436f, -0.01420681f, 0.00459098f, 
    -0.02933509f, -0.00581712f, -0.00395165f, 0.02786156f, -0.01756895f, -0.00231468f, 0.00703763f, 0.02963469f, 
    0.00337825f, -0.00924962f, -0.03339928f, 0.01096158f, -0.02461583f, -0.02533167f, 0.02045789f, 0.03889508f, 
    -0.01571878f, 0.01231852f, -0.02333081f, -0.00787861f, -0.01950760f, -0.02249580f, 0.01486580f, -0.03968655f, 
    0.01977785f, 0.02975808f, 0.03057797f, 0.01585913f, 0.02859323f, -0.01483847f, -0.01890500f, -0.03281132f, 
    0.03198363f, 0.03063961f, -0.03995362f, 0.02648109f, 0.00445366f, 0.01680753f, -0.04109539f, -0.02403580f, 
    -0.04411733f, -0.02653537f, 0.00686167f, 0.00613341f, -0.03889848f, -0.01025166f, -0.02035444f, -0.03883032f, 
    -0.04970134f, 0.00759280f, -0.04953442f, -0.00274201f, -0.02935574f, -0.04534652f, -0.04233212f, 0.02514538f, 
    0.04347548f, -0.03053995f, 0.00638094f, -0.01780903f, 0.01068430f, -0.03460471f, -0.01969796f, -0.04012906f, 
    0.04199703f, 0.00315208f, 0.00318525f, 0.03454968f, -0.03386811f, -0.01576857f, -0.04297490f, 0.02333272f, 
    -0.00648065f, -0.04777567f, -0.01346469f, -0.00689266f, -0.00960584f, -0.00097302f, -0.04068814f, 0.00466504f, 
    0.03507189f, -0.01839617f, -0.03415073f, -0.02159767f, 0.00022813f, -0.00527403f, 0.02029124f, -0.04223262f, 
    0.01929929f, -0.00874871f, 0.01475947f, -0.00293728f, 0.00503444f, 0.01669564f, -0.03495597f, 0.01584115f, 
    0.01697046f, 0.03663008f, -0.03221630f, -0.01238776f, -0.03506795f, -0.00022727f, 0.00441558f, 0.01082005f, 
    -0.03621858f, 0.02903912f, 0.01361774f, -0.00269297f, 0.01975090f, 0.01216818f, -0.00006090f, -0.02354825f, 
    -0.03711440f, 0.02976808f, 0.02286320f, -0.01225104f, -0.00146691f, 0.03975710f, -0.03958144f, -0.00633239f, 
    -0.00923391f, 0.02269642f, 0.02657061f, -0.03329815f, -0.03142838f, -0.00912757f, 0.03066256f, -0.04022638f, 
    0.01379125f, -0.02524444f, -0.00692363f, -0.01735915f, 0.00964712f, 0.01632145f, 0.00135972f, 0.01798770f, 
    0.00088794f, -0.01713480f, -0.01033711f, 0.00151150f, -0.01492934f, 0.01627722f, 0.00112150f, 0.02501986f, 
    0.00277959f, 0.03335465f, 0.02186832f, 0.01057585f, -0.04051787f, -0.04410267f, -0.02956580f, 0.02647067f, 
    -0.01552224f, -0.01915993f, -0.03790324f, -0.00576022f, -0.03315417f, 0.02231850f, -0.00292114f, 0.03054363f, 
    0.02081547f, -0.03833264f, -0.01783087f, 0.00934055f, -0.03502050f, -0.01521398f, -0.02716632f, -0.02504383f, 
    0.01382244f, -0.03104299f, -0.00663538f, -0.04461367f, -0.03006831f, -0.02396806f, 0.03218950f, -0.00789200f, 
    0.02928640f, -0.04272274f, -0.02179466f, 0.02673055f, -0.03328536f, 0.02200993f, -0.00052640f, -0.00708506f, 
    -0.02180405f, 0.03504674f, -0.00226931f, -0.04225504f, 0.02371811f, 0.02492696f, 0.01757036f, 0.02247417f, 
    0.00291559f, -0.02335489f, -0.04182443f, -0.00497419f, -0.04102898f, -0.00143776f, 0.03598111f, -0.03147048f, 
    -0.02779249f, 0.01463413f, -0.03461301f, -0.04005207f, 0.02198673f, 0.02422878f, -0.03290978f, 0.03614631f, 
    -0.03551856f, 0.00193093f, -0.04588812f, -0.03694012f, 0.00970748f, -0.01745615f, -0.03986745f, 0.01601862f, 
    0.03009210f, 0.01296519f, 0.00482145f, 0.00484119f, 0.00321853f, 0.01635871f, 0.00687604f, -0.03381575f, 
    -0.00648566f, -0.01395423f, 0.00020605f, 0.02265283f, -0.03698299f, -0.02258700f, 0.01637384f, 0.02424261f, 
    -0.00405144f, -0.03243601f, 0.00198144f, 0.01174474f, 0.04440847f, -0.02349320f, 0.01910480f, -0.04364865f, 
    -0.02660655f, -0.00122228f, 0.03506593f, 0.01720299f, -0.00312118f, -0.00461648f, 0.01993938f, -0.00296636f, 
    -0.01664250f, -0.00261476f, -0.03021185f, -0.03471820f, 0.03158825f, -0.01145342f, -0.01324151f, 0.02089731f, 
    0.01904859f, 0.03004427f, -0.02338578f, 0.00787400f, 0.01576206f, -0.00358219f, -0.03035880f, -0.02964566f, 
    -0.04038674f, 0.02827968f, -0.01584118f, -0.02125322f, 0.00545443f, -0.01219591f, -0.03690911f, -0.00823228f, 
    0.01634664f, -0.01637569f, 0.00596766f, -0.04552238f, -0.02274320f, 0.02241003f, -0.00156395f, -0.03345918f, 
    -0.00977703f, -0.01208171f, -0.00424099f, -0.00885003f, -0.00330054f, -0.02719624f, -0.01814447f, -0.03910512f, 
    0.02414083f, -0.02811024f, -0.01271876f, -0.04525951f, 0.00735171f, -0.00482936f, -0.01930042f, 0.03051932f, 
    0.00443815f, -0.01455567f, 0.02603419f, -0.00203552f, -0.00230778f, 0.02502840f, -0.00758076f, -0.03600021f, 
    -0.01123576f, 0.02035705f, 0.02028503f, -0.00248203f, 0.00979156f, -0.00128806f, -0.04987637f, -0.04001157f, 
    -0.03224876f, -0.03841033f, 0.01039239f, -0.03315222f, -0.03275480f, 0.04225282f, 0.02527152f, 0.00327623f, 
    0.01412579f, -0.04257651f, 0.02715515f, 0.00453633f, 0.01642127f, 0.03147088f, 0.00517049f, -0.02961594f, 
    -0.03887286f, 0.02610966f, 0.03263003f, -0.00379509f, -0.03166395f, 0.00538419f, 0.02487505f, 0.02924254f, 
    0.00903843f, 0.03862264f, -0.03898921f, 0.00774139f, 0.02540629f, -0.01305356f, 0.03826495f, 0.02433351f, 
    0.02809446f, -0.00400036f, -0.02044003f, -0.04090434f, 0.03108465f, 0.03115926f, 0.00124799f, -0.03469485f, 
    0.02150531f, -0.03269182f, 0.00867915f, 0.00385333f, -0.02562647f, -0.01975935f, 0.02382087f, -0.02076427f, 
    0.02313819f, 0.02810592f, -0.03242313f, 0.01403110f, 0.02823397f, -0.01567664f, -0.00172915f, 0.01182340f, 
    -0.01973347f, -0.01311139f, 0.02440273f, 0.02165869f, -0.01513707f, -0.02283070f, -0.03419681f, -0.03356419f, 
    -0.00243729f, 0.01658730f, -0.02184470f, -0.03044657f, 0.02025122f, -0.02976629f, -0.02669371f, 0.02205384f, 
    -0.00779303f, -0.04015732f, 0.00755474f, 0.00392914f, -0.02706686f, -0.01497042f, 0.00931271f, -0.03342232f, 
    -0.03035072f, -0.00466216f, 0.01216144f, 0.01716401f, -0.00484371f, 0.01187301f, -0.01164493f, 0.01780621f, 
    0.01475189f, -0.01865702f, -0.00480442f, -0.02601813f, -0.04301861f, -0.03048299f, 0.01232464f, -0.04186730f, 
    0.01607177f, -0.02070091f, -0.03653147f, -0.02736157f, -0.01911600f, -0.03835883f, 0.01607085f, -0.02781437f, 
    0.00369475f, 0.03593416f, 0.00388432f, 0.01492860f, -0.02953869f, 0.00729905f, 0.01572802f, 0.00861251f, 
    -0.03526374f, -0.01935600f, 0.01872487f, -0.02767270f, -0.04410346f, -0.03179646f, -0.00247233f, -0.00713200f, 
    -0.04044050f, -0.04577006f, -0.01069457f, -0.02884241f, -0.01931869f, 0.03946007f, 0.00696088f, -0.00586921f, 
    -0.00902075f, 0.01556782f, -0.03576127f, 0.03276509f, 0.03141162f, -0.03675587f, -0.00606972f, -0.01249100f, 
    -0.01014078f, 0.02142111f, -0.02194631f, 0.04187015f, 0.01633491f, -0.00823353f, -0.02251016f, 0.02467886f, 
    -0.02730763f, -0.04738760f, 0.02265591f, 0.02986519f, 0.00443245f, 0.00349740f, -0.01035451f, -0.03668903f, 
    0.01455225f, 0.02543040f, 0.02898458f, 0.03055425f, -0.01214112f, -0.01903295f, 0.02005773f, -0.01283752f, 
    -0.01984021f, -0.00124838f, -0.02877093f, 0.02125191f, -0.02333832f, 0.03003591f, -0.04059389f, 0.02380597f, 
    -0.01497499f, -0.01085005f, 0.02936243f, -0.01894951f, -0.02197403f, -0.03108424f, 0.01757199f, 0.01788614f, 
    0.00768466f, -0.02036452f, -0.03780957f, 0.01536567f, -0.00714291f, 0.00991659f, -0.03900848f, -0.00859885f, 
    -0.01976824f, 0.03738910f, 0.02538080f, 0.01638207f, 0.03394279f, -0.00466193f, 0.00588472f, -0.02562403f, 
    -0.04312799f, 0.02103287f, 0.01770356f, 0.01113631f, -0.03590143f, -0.02058806f, -0.03492536f, 0.02039945f, 
    0.03302575f, 0.02263329f, -0.03276079f, -0.02842150f, 0.02330198f, 0.01940416f, 0.02026869f, -0.05001451f, 
    -0.03080613f, -0.01547168f, -0.00178649f, 0.02764143f, 0.02026355f, -0.02198838f, 0.00412628f, 0.00763687f, 
    -0.02117700f, -0.03240912f, -0.04682922f, 0.02832079f, -0.03299081f, -0.02382952f, -0.01034176f, -0.01997165f, 
    0.00121064f, 0.02871818f, 0.04338292f, -0.02735417f, -0.01584143f, -0.00395391f, -0.03276581f, 0.01196487f, 
    0.01584537f, -0.02042001f, 0.01702309f, -0.01246233f, 0.01783206f, 0.02499489f, -0.02531651f, -0.01812810f, 
    0.00197659f, 0.03632003f, -0.03486627f, 0.00505997f, 0.01190373f, -0.01906596f, -0.03141090f, -0.01668991f, 
    -0.01997538f, -0.01205628f, 0.01267946f, -0.01314572f, -0.01511904f, 0.00070595f, -0.00714417f, -0.00091926f, 
    0.02090308f, -0.01696337f, -0.03139979f, -0.02417775f, -0.00020873f, 0.01881257f, -0.04438814f, 0.01290234f, 
    0.00229984f, -0.01449523f, -0.03042046f, -0.00502412f, 0.02418500f, 0.02752181f, -0.01865813f, -0.01240509f, 
    -0.00116689f, -0.00585149f, 0.01932611f, 0.01468399f, 0.02909237f, -0.03649677f, -0.02637081f, -0.03276693f, 
    -0.03139690f, -0.03611926f, 0.02814836f, -0.03029943f, -0.00150001f, 0.01341400f, -0.02892156f, -0.00440076f, 
    -0.00406442f, -0.02195494f, -0.00353717f, -0.00459936f, -0.04176503f, 0.01022593f, -0.01506752f, 0.00622860f, 
    -0.01378336f, -0.02709782f, -0.04287952f, -0.03661205f, 0.00873801f, -0.04509926f, -0.02224029f, -0.00081870f, 
    -0.00881454f, -0.00881952f, -0.04519761f, 0.01053588f, 0.01277708f, -0.03505971f, 0.03285407f, 0.01313692f, 
    0.03703829f, -0.00035886f, -0.00423756f, 0.01001261f, -0.01431502f, -0.04049563f, -0.02781955f, -0.01526653f, 
    0.02146327f, -0.04097269f, 0.02440684f, 0.00641261f, 0.02480808f, 0.00201499f, -0.03197326f, -0.03210036f, 
    -0.01748605f, 0.00001025f, 0.00174427f, -0.01847505f, 0.00816672f, -0.02118640f, 0.02912562f, -0.03800089f, 
    0.00674957f, -0.01309442f, 0.02319438f, -0.04361548f, 0.02295085f, 0.00672266f, 0.02926333f, -0.04600945f, 
    0.00224363f, 0.00880143f, -0.03726964f, -0.02823478f, -0.04535387f, 0.03003213f, -0.01537226f, -0.00055365f, 
    -0.01242866f, 0.00527120f, -0.01913303f, 0.00791015f, 0.02043143f, -0.01583979f, -0.00574581f, 0.00254012f, 
    -0.00078842f, 0.00475591f, -0.00402939f, 0.02409562f, 0.04450627f, -0.02266589f, 0.00207309f, -0.02503587f, 
    0.02415578f, -0.01163130f, -0.03208928f, -0.04439979f, -0.00203072f, 0.01062406f, 0.01345978f, 0.02382825f, 
    -0.01744807f, -0.01294196f, -0.02639813f, 0.02281655f, -0.02048458f, -0.01024849f, 0.01950240f, -0.00621728f, 
    -0.04905233f, 0.01922545f, -0.01648631f, 0.00901918f, -0.02396640f, 0.01410426f, 0.00406145f, 0.00960360f, 
    -0.01582325f, 0.00254846f, -0.00926168f, -0.03166363f, 0.00107309f, 0.02646639f, -0.01220021f, -0.03083042f, 
    0.02499094f, -0.01367081f, 0.01799096f, 0.02229618f, -0.03035075f, -0.00418403f, 0.04161940f, -0.00313193f, 
    -0.01273471f, 0.02136949f, 0.02683460f, -0.01646111f, 0.02585781f, -0.02367031f, 0.01738131f, -0.02895471f, 
    0.00146656f, 0.03759681f, 0.00552936f, -0.03929283f, -0.02961867f, -0.02627733f, 0.02232132f, 0.02906572f, 
    0.00090969f, -0.01491645f, 0.03052392f, 0.02614425f, 0.01837561f, 0.00307034f, -0.02187843f, 0.01166858f, 
    0.00987863f, -0.02245508f, -0.03587504f, -0.00429619f, -0.00373123f, -0.04053319f, -0.03855709f, -0.00794571f, 
    0.01985855f, -0.01073884f, 0.02740788f, -0.01961952f, -0.01077515f, 0.01362262f, 0.00737530f, -0.01297679f, 
    0.00463151f, -0.00925230f, 0.02700247f, 0.02083484f, 0.01063560f, -0.00858377f, 0.02654159f, -0.02497280f, 
    -0.02113616f, 0.03744784f, -0.00801621f, -0.01348046f, -0.02928516f, 0.03920972f, 0.02252152f, -0.02991496f, 
    0.01414136f, 0.01090117f, 0.04110384f, -0.00381529f, -0.02282807f, 0.01611717f, -0.02017680f, 0.00951317f, 
    -0.03875019f, 0.01358372f, -0.02635296f, -0.04342088f, -0.04170909f, 0.02770288f, -0.01132870f, -0.03317169f, 
    -0.00359295f, 0.00609057f, 0.00471532f, -0.00802282f, 0.01687910f, 0.02058479f, -0.02362356f, -0.04097603f, 
    0.02547434f, -0.00329725f, -0.04136903f, -0.04155586f, 0.00255434f, -0.02687002f, -0.04841695f, -0.02310375f, 
    0.00171021f, 0.03421586f, 0.01870793f, 0.03095591f, -0.04205764f, -0.03870061f, -0.00882472f, -0.02190566f, 
    -0.00241884f, -0.03065458f, 0.00473056f, 0.01220524f, 0.02489432f, -0.00077426f, -0.01985975f, 0.00235112f, 
    -0.00804996f, 0.01332253f, -0.03965693f, 0.00322329f, -0.02292787f, 0.02495041f, 0.01348410f, 0.00219390f, 
    0.01426841f, 0.02440070f, -0.03112348f, 0.01615500f, 0.00048580f, 0.00827650f, 0.02666162f, -0.01443135f, 
    0.01650279f, -0.00102264f, 0.01238859f, -0.03755512f, 0.03219680f, 0.02323076f, 0.01210815f, 0.00538003f, 
    0.00554386f, -0.01592541f, -0.04161770f, -0.01198492f, 0.03904264f, 0.01252878f, -0.02930564f, 0.03040219f, 
    0.00887241f, -0.04996893f, -0.04649281f, -0.04575967f, -0.04527136f, 0.01859329f, -0.04642642f, -0.01794845f, 
    0.01704950f, -0.02461725f, -0.01025835f, 0.01462105f, -0.04310364f, -0.02411317f, -0.04969417f, -0.00432378f, 
    0.01182097f, -0.01132144f, -0.04531386f, 0.01197594f, -0.00027864f, -0.03712711f, -0.00515822f, -0.02814961f, 
    -0.04460871f, 0.00566344f, 0.02729113f, -0.01735641f, -0.04535288f, 0.01624722f, 0.01031347f, -0.00846773f, 
    -0.03550657f, -0.01757824f, -0.00910885f, -0.02310287f, 0.02606423f, 0.01350551f, -0.02944967f, -0.01621355f, 
    0.01757711f, -0.02208117f, 0.03919615f, 0.02691982f, -0.02383226f, 0.01215915f, 0.00961916f, -0.01037061f, 
    -0.02389503f, -0.02846521f, 0.02384697f, -0.02870530f, -0.02831766f, -0.02739391f, 0.00655240f, -0.03163777f, 
    0.03428589f, -0.02722989f, -0.00355737f, 0.01382713f, -0.03964061f, 0.01994160f, 0.00037229f, -0.03951567f, 
    0.00784079f, 0.01529304f, 0.02627421f, -0.03389687f, 0.02402544f, 0.01972720f, -0.02182234f, 0.02365964f, 
    0.02557848f, 0.03099449f, -0.00779728f, -0.04426681f, 0.02749649f, 0.02246665f, -0.02518546f, 0.02439360f, 
    -0.02041937f, 0.02727619f, -0.04136336f, 0.03203528f, -0.01760336f, 0.00934875f, -0.00878685f, 0.01790746f, 
    -0.01393338f, -0.01334196f, -0.02836142f, -0.03043249f, -0.03171777f, -0.01512834f, 0.02303406f, -0.01960920f, 
    0.03498892f, 0.00402033f, 0.00838209f, -0.01787356f, -0.00182374f, -0.02881821f, 0.01866795f, -0.02223359f, 
    -0.01628380f, -0.02733282f, -0.00701732f, 0.00244873f, 0.00208059f, 0.02960077f, -0.03026784f, -0.04648628f, 
    -0.01883369f, -0.04114931f, -0.03297078f, 0.02060783f, 0.03187995f, 0.01187678f, -0.00645276f, -0.04267691f, 
    0.02698935f, -0.00580640f, -0.01245824f, 0.01833808f, 0.02743122f, 0.01175839f, 0.02806907f, -0.01789621f, 
    -0.03371182f, 0.03344715f, -0.00366101f, -0.02361387f, 0.02978289f, -0.02200510f, -0.00392256f, 0.00680255f, 
    0.01000855f, 0.02117284f, 0.03898370f, 0.01624610f, -0.00357817f, -0.04271201f, -0.03822454f, -0.03412429f, 
    0.00731538f, 0.01536898f, 0.02656248f, -0.04139778f, 0.02451504f, -0.00092611f, -0.04569243f, 0.00034277f, 
    0.01583701f, 0.00340339f, -0.02608653f, -0.05080155f, 0.00668963f, -0.02187384f, 0.01287588f, 0.01876593f, 
    0.02234735f, 0.01504496f, -0.03673536f, -0.02365394f, -0.02192982f, -0.00570482f, 0.02028556f, 0.02696909f, 
    -0.00197890f, -0.01332168f, 0.00393825f, -0.03805465f, 0.03387943f, -0.01823099f, 0.03146052f, -0.00251776f, 
    0.03707206f, -0.00092097f, 0.02969325f, -0.01936200f, 0.02588640f, 0.01908709f, 0.01417634f, -0.03385916f, 
    0.02011156f, -0.02724347f, -0.00644836f, 0.02667983f, -0.00618838f, -0.00070835f, 0.01763366f, -0.00381604f, 
    0.00945119f, 0.01742621f, -0.02311577f, -0.01113170f, -0.01517723f, 0.00122188f, 0.01518577f, -0.00224101f, 
    -0.01934540f, 0.03846404f, -0.01013005f, -0.02690314f, 0.03301262f, 0.01924728f, 0.03532677f, 0.03635225f, 
    -0.04449695f, 0.01663985f, -0.01620106f, 0.00990259f, 0.00959052f, -0.00143294f, 0.02252508f, 0.03291757f, 
    -0.03084821f, -0.03370354f, -0.04338430f, 0.00113826f, -0.02682264f, -0.01456464f, 0.02313252f, 0.00636033f, 
    0.02433643f, -0.00162789f, -0.02906440f, 0.01902407f, 0.01454837f, 0.01606724f, -0.02069661f, 0.01281040f, 
    -0.02571594f, 0.01473347f, -0.02771259f, -0.01538527f, -0.00482085f, -0.02577586f, 0.02043408f, -0.00889108f, 
    0.03803703f, 0.01668929f, 0.00444260f, 0.03208715f, -0.01906743f, -0.01862204f, -0.01754567f, -0.00484779f, 
    0.01867576f, 0.03086229f, -0.02194804f, -0.03980910f, 0.03538376f, 0.02774832f, 0.02931394f, -0.00193691f, 
    0.01870586f, -0.03277463f, 0.02431766f, -0.01864430f, 0.02274390f, -0.01074238f, -0.02365629f, -0.02049294f, 
    -0.01835074f, -0.04041977f, -0.00664038f, 0.00706059f, -0.01081161f, 0.00960868f, -0.00459653f, 0.01375180f, 
    -0.03523833f, -0.02725885f, 0.02927640f, -0.00550568f, -0.02960173f, -0.01369628f, -0.00218106f, -0.02214830f, 
    0.02201557f, 0.01152798f, -0.00356405f, -0.00755128f, -0.02523066f, -0.01503511f, -0.02696546f, -0.03826933f, 
    0.00523501f, 0.00610810f, 0.02327769f, -0.03902746f, 0.01898823f, 0.00550586f, 0.03453444f, -0.02457531f, 
    -0.02022842f, -0.03565425f, 0.01465457f, -0.01485089f, -0.00881079f, 0.01928198f, -0.00849362f, -0.00060204f, 
    -0.03046687f, 0.03629940f, 0.00906108f, -0.03448111f, -0.02318176f, -0.01073775f, 0.02928684f, -0.00980408f, 
    0.01638945f, 0.02241088f, -0.01597065f, 0.00411598f, 0.02147228f, -0.03710553f, 0.03162601f, 0.03411761f, 
    0.02605662f, -0.00972596f, -0.00645805f, 0.02900258f, -0.03509481f, -0.00986971f, 0.01669957f, -0.02995490f, 
    0.00988586f, -0.00309461f, 0.00775973f, -0.00745097f, 0.01242549f, -0.03020946f, -0.03735335f, 0.01519695f, 
    -0.00406813f, 0.01697734f, 0.03012295f, 0.00693099f, 0.01956671f, -0.01883562f, -0.02657260f, -0.00494337f, 
    -0.00460936f, 0.02355387f, 0.00625048f, -0.00155462f, -0.01973356f, 0.03492937f, 0.00456567f, 0.02668347f, 
    0.03394882f, -0.04088636f, 0.02613785f, -0.02192713f, 0.02512138f, 0.00180801f, -0.03870347f, 0.01267960f, 
    0.01742307f, 0.00448740f, -0.02722566f, -0.00374780f, -0.04428917f, -0.01743385f, 0.01885720f, 0.00288626f, 
    -0.04203390f, -0.02892643f, 0.03424191f, -0.00803322f, 0.02908826f, -0.01799508f, -0.03103327f, 0.03357436f, 
    -0.04032330f, -0.01320691f, 0.02236491f, -0.02396455f, -0.03918587f, 0.01753775f, 0.00386899f, -0.03639422f, 
    0.03163350f, 0.01145132f, -0.03100035f, -0.04189901f, 0.01694131f, -0.01789649f, -0.03810158f, 0.03051982f, 
    0.02898395f, 0.01517479f, -0.03804616f, -0.01934045f, 0.02342349f, -0.03531571f, 0.01840017f, -0.02205939f, 
    0.02440987f, -0.04091572f, -0.00408189f, -0.03071672f, 0.03040486f, -0.01305794f, -0.03849572f, 0.02109800f, 
    -0.04341458f, 0.01534946f, -0.01875256f, 0.01499723f, 0.00246698f, -0.01489821f, -0.02804251f, -0.02056172f, 
    -0.03407627f, 0.02634905f, -0.01154451f, -0.03251466f, -0.02927357f, 0.01598365f, -0.02859221f, -0.02881368f, 
    0.01984912f, -0.01616326f, 0.01235030f, 0.03473105f, -0.03331284f, -0.00728903f, -0.03580445f, 0.00518490f, 
    0.03021414f, -0.02243851f, -0.03076126f, 0.03233359f, 0.02933081f, -0.02106862f, -0.00246929f, 0.00120699f, 
    0.00883406f, -0.02150487f, 0.01581579f, -0.03135340f, -0.01316141f, -0.00442190f, -0.00187842f, -0.00830534f, 
    -0.01392491f, -0.03826356f, -0.03048334f, 0.00949532f, 0.00427614f, -0.00094848f, 0.03129105f, 0.01327210f, 
    -0.04303735f, 0.02358924f, -0.03233834f, 0.03254945f, 0.00979549f, 0.01410815f, -0.03504216f, 0.01987575f, 
    0.01829061f, 0.01398293f, 0.02904545f, 0.00231712f, 0.00482435f, 0.03376459f, 0.02553752f, -0.04093080f, 
    -0.03694898f, -0.03294913f, -0.01293093f, 0.00582196f, 0.01003201f, -0.03983799f, -0.04498497f, 0.00246412f, 
    0.01540540f, -0.03082715f, -0.00022405f, -0.04555057f, 0.03206825f, -0.03921631f, -0.04067280f, -0.02669213f, 
    0.02772063f, -0.01713402f, -0.01600615f, -0.02655582f, -0.00053926f, 0.02079572f, 0.02860856f, 0.02723872f, 
    0.02332335f, -0.03606177f, 0.01239948f, -0.02031424f, -0.04216738f, 0.03491203f, -0.00390957f, 0.02126329f, 
    -0.03254561f, 0.00693322f, 0.01574251f, -0.00590971f, -0.01536781f, -0.00748460f, -0.03116691f, -0.01329529f, 
    0.02023861f, -0.03902933f, 0.02234605f, -0.03892966f, -0.02462098f, 0.01163184f, 0.02395895f, 0.03412811f, 
    -0.03601946f, -0.03441262f, 0.01695193f, 0.00882550f, -0.04311310f, -0.01610687f, 0.00353880f, 0.02013088f, 
    0.01183137f, -0.01644029f, 0.03529505f, 0.01534952f, -0.02801196f, -0.02330964f, -0.00828805f, -0.03258548f, 
    0.01062348f, -0.02580066f, -0.00520999f, 0.00493191f, -0.00088448f, 0.02578831f, 0.03041374f, 0.01861371f, 
    -0.01662572f, 0.01989199f, -0.03710889f, 0.00080789f, -0.03835382f, 0.00021068f, 0.00809168f, -0.00978838f, 
    -0.02327914f, -0.02390400f, -0.02166303f, 0.02449586f, -0.02145339f, -0.03182456f, -0.02984506f, 0.00898351f, 
    0.02816317f, 0.02804199f, 0.02286118f, 0.01492407f, -0.00719864f, -0.00983191f, 0.00578122f, -0.04504677f, 
    0.01034950f, -0.00652233f, -0.02832079f, -0.02010170f, -0.00041638f, -0.03906292f, -0.01105271f, -0.00622923f, 
    -0.00795639f, -0.02607553f, -0.02900845f, -0.02079808f, 0.01859717f, -0.00733005f, 0.02368050f, 0.00005300f, 
    0.00955152f, -0.02769409f, 0.00222642f, -0.02548558f, 0.02429144f, 0.02145432f, 0.02906394f, -0.01626150f, 
    0.02363973f, 0.02484445f, -0.03062437f, 0.01994555f, -0.00409673f, 0.02581665f, 0.03015858f, 0.00804421f, 
    0.03123494f, 0.03527448f, 0.03328772f, -0.00890268f, -0.02548718f, -0.03478258f, -0.01690103f, 0.01995577f, 
    0.01354702f, 0.01768070f, 0.02422494f, -0.03101704f, 0.00683268f, -0.02160970f, 0.03695531f, -0.01547828f, 
    0.02502549f, 0.00931132f, -0.03151279f, 0.00530265f, -0.04222325f, 0.02937303f, -0.02412817f, -0.04025066f, 
    -0.02397589f, -0.02427281f, 0.02085049f, 0.00733736f, -0.00281806f, -0.03484490f, -0.02197228f, -0.00741770f, 
    0.03155991f, 0.01481724f, -0.01937727f, -0.03239236f, 0.02285311f, -0.02986688f, 0.02868306f, -0.01494273f, 
    -0.03318670f, 0.01951556f, -0.01745955f, -0.01580296f, -0.03372132f, -0.00631475f, 0.02261099f, -0.01869101f, 
    0.03170033f, -0.03841843f, -0.00921643f, 0.03119577f, 0.00709224f, -0.01298854f, -0.02330958f, -0.01837366f, 
    0.02791919f, -0.03733629f, 0.01227367f, -0.00918802f, -0.00881796f, -0.01268880f, -0.04178071f, 0.01626589f, 
    -0.03852558f, 0.00908643f, 0.03947312f, 0.01359178f, 0.01379488f, 0.02261643f, 0.00900018f, 0.03400857f, 
    -0.02923612f, -0.03100451f, -0.02597638f, -0.04033956f, 0.00354761f, -0.03927824f, -0.03667111f, 0.01625357f, 
    -0.00291281f, 0.00606951f, 0.00643502f, -0.00520858f, -0.00652773f, -0.00150746f, 0.02639266f, -0.00067451f, 
    0.01202461f, -0.03512778f, -0.01964660f, -0.03223336f, -0.03633227f, 0.02362291f, 0.02942610f, 0.00741703f, 
    0.01271058f, -0.03581064f, -0.04539611f, -0.00732568f, 0.02341378f, -0.01676559f, -0.00979941f, 0.01446259f, 
    -0.01920773f, -0.02025966f, -0.00925441f, 0.00708675f, 0.02039318f, -0.03470441f, 0.00979407f, 0.01660639f, 
    -0.03805045f, -0.02374239f, -0.00674993f, -0.00206279f, -0.01017911f, -0.00111814f, -0.02465803f, -0.01222215f, 
    0.01561414f, 0.01006292f, -0.04412673f, 0.00512802f, 0.00807616f, -0.03860163f, 0.03201392f, -0.02753285f, 
    0.01740766f, 0.01138686f, -0.01042725f, 0.02843544f, -0.02264590f, -0.03440505f, -0.00693006f, 0.02117764f, 
    -0.00897249f, -0.02785796f, -0.01217894f, 0.02869363f, -0.01567770f, -0.02985005f, 0.00839598f, 0.02098943f, 
    -0.03652203f, -0.02478092f, -0.00487021f, -0.04273799f, -0.03073576f, 0.01027238f, 0.00801227f, -0.04090713f, 
    -0.00110690f, -0.00774710f, -0.01164187f, -0.00877386f, 0.02050604f, 0.02948526f, -0.01559022f, -0.03953205f, 
    0.00388004f, 0.00356202f, -0.04446397f, 0.03035342f, 0.00449339f, -0.01335429f, -0.04277313f, -0.00923035f, 
    -0.02400088f, -0.03997159f, -0.02946373f, -0.04014918f, -0.00819503f, 0.00711198f, -0.00429546f, -0.02958348f, 
    0.03442051f, -0.00777526f, 0.02800542f, 0.02972800f, -0.04417185f, 0.02406662f, 0.01182072f, 0.02066367f, 
    0.02593416f, -0.01603344f, 0.01170257f, 0.02178177f, 0.00976214f, -0.03623374f, -0.03894533f, -0.00141869f, 
    0.03090956f, -0.02774112f, -0.01511350f, -0.01350719f, 0.03388140f, 0.00211312f, 0.01869399f, -0.03092287f, 
    0.02163906f, -0.01914941f, -0.00099096f, 0.02391352f, -0.03641945f, 0.02930926f, -0.01485734f, -0.03258681f, 
    -0.02700384f, 0.01617075f, -0.00443665f, 0.03124968f, -0.01017825f, -0.03989821f, -0.04154559f, -0.04615226f, 
    -0.00014887f, -0.01571775f, -0.00663595f, -0.00848094f, -0.03114722f, -0.04280559f, 0.00324453f, 0.02175194f, 
    -0.03084362f, 0.01439281f, -0.01887731f, -0.01444863f, -0.03548636f, 0.02363801f, -0.03319024f, -0.02071040f, 
    -0.01392716f, 0.00582453f, -0.01301816f, 0.01457490f, -0.02263055f, 0.00801999f, -0.01044245f, -0.02890297f, 
    -0.03666360f, -0.01321288f, 0.01228138f, 0.01927116f, -0.03246514f, 0.01006645f, -0.04441100f, -0.01866963f, 
    -0.02718583f, -0.02426413f, -0.04338052f, -0.00721036f, -0.03985302f, 0.02147239f, -0.03364370f, -0.01196430f, 
    0.00745416f, 0.01523145f, 0.02212326f, 0.01355226f, 0.00625850f, -0.03808623f, -0.00475068f, -0.02120324f, 
    -0.00122284f, -0.02320326f, -0.03684606f, -0.02394578f, 0.02266560f, -0.00688928f, -0.04532405f, 0.02754842f, 
    -0.02211840f, -0.02549994f, -0.04352323f, -0.04088915f, 0.01683113f, 0.01796520f, -0.03066830f, -0.01680857f, 
    -0.00841366f, -0.02256442f, 0.01998089f, 0.00635741f, -0.00682548f, 0.01636801f, 0.00671648f, 0.02305608f, 
    -0.04244961f, -0.00790774f, -0.04302133f, 0.00471683f, 0.01135952f, -0.00013103f, -0.00539490f, 0.00177220f, 
    -0.04502375f, 0.01039407f, 0.01347009f, -0.00571110f, -0.04327511f, -0.03647477f, -0.02773436f, -0.04258744f, 
    -0.02962301f, 0.03251040f, 0.01657151f, 0.02963691f, 0.01677262f, 0.01502706f, 0.00581887f, -0.00462097f, 
    -0.02201694f, -0.02427324f, 0.01538038f, -0.04040157f, 0.00255010f, -0.00563450f, -0.02475989f, 0.02648176f, 
    0.00368840f, 0.02100847f, 0.01265779f, 0.00140592f, 0.00378205f, 0.02195828f, 0.00781455f, -0.04018608f, 
    -0.02282047f, -0.01756687f, -0.02942622f, -0.03302895f, 0.01995033f, -0.00343163f, -0.02188461f, -0.00245800f, 
    -0.02917719f, -0.04428966f, -0.03076425f, -0.00043142f, 0.02807192f, -0.02009354f, 0.02756127f, -0.02195038f, 
    0.02647449f, 0.01231619f, 0.01173847f, -0.00258374f, -0.02837297f, -0.03420531f, -0.01706603f, 0.03214856f, 
    -0.04294966f, 0.00392040f, 0.00413536f, -0.01451962f, -0.04174318f, 0.02594321f, 0.00681042f, -0.00010110f, 
    -0.02568279f, 0.00268595f, 0.03182288f, -0.00695490f, -0.01749784f, 0.00784484f, 0.01033557f, 0.01364529f, 
    -0.01014750f, 0.00995059f, -0.01281772f, -0.02273726f, -0.01583445f, -0.04574102f, -0.00197423f, -0.02850584f, 
    -0.04070344f, -0.03052155f, -0.01902738f, -0.03306215f, 0.01304830f, 0.01460489f, 0.00071519f, -0.00576098f, 
    0.02872302f, 0.02886936f, -0.01291220f, -0.01143723f, -0.01895384f, -0.02961074f, -0.00858035f, -0.00728647f, 
    0.01324071f, 0.02945579f, -0.01408097f, 0.02508264f, -0.04627517f, 0.01067546f, -0.02968625f, -0.00108558f, 
    -0.00686285f, -0.01835726f, 0.01413656f, -0.02475641f, -0.03812210f, 0.02059298f, 0.02474086f, -0.00837354f, 
    -0.03356568f, -0.01926553f, 0.00139844f, -0.03834585f, -0.02555730f, 0.00854518f, -0.03530191f, -0.04430267f, 
    -0.00471436f, -0.03229504f, -0.01981127f, 0.02430489f, -0.01128086f, -0.02483997f, 0.00956212f, 0.01409551f, 
    -0.04058095f, -0.02863812f, 0.03094914f, 0.02615162f, -0.02029663f, 0.00700876f, 0.01767942f, -0.04417091f, 
    0.03063195f, 0.00645543f, 0.02981663f, -0.04064592f, -0.00350108f, -0.03741883f, 0.02559100f, -0.03146425f, 
    -0.00449946f, -0.01659989f, -0.00553961f, -0.02989484f, -0.04129031f, 0.01070342f, 0.02264748f, -0.00898471f, 
    0.02131986f, 0.00758859f, -0.04112735f, 0.01747004f, -0.01830170f, -0.01891866f, -0.00144046f, -0.00125291f, 
    -0.03792315f, -0.02238492f, -0.03372167f, 0.00126498f, 0.02372999f, -0.03948709f, 0.02073273f, 0.02147316f, 
    -0.01430408f, 0.00226117f, -0.02279957f, -0.03081176f, 0.00455858f, -0.03660227f, 0.01707225f, -0.02152545f, 
    -0.04012303f, -0.02804090f, -0.01856438f, -0.00913040f, -0.01668076f, -0.02832815f, -0.01387167f, 0.01875934f, 
    0.00698790f, -0.02937798f, 0.02682933f, -0.01676317f, -0.02853765f, 0.01965424f, -0.01936701f, 0.02235986f, 
    0.01878529f, 0.01220668f, 0.00476668f, -0.00601696f, 0.01749929f, -0.00496547f, 0.01157159f, 0.00200815f, 
    -0.02745960f, -0.03825814f, -0.02082743f, 0.01977919f, -0.00895917f, 0.00153365f, 0.00354109f, 0.00468014f, 
    -0.02666363f, 0.02653599f, 0.02046853f, -0.03817004f, -0.02238710f, -0.03963357f, 0.01406381f, -0.01629115f, 
    -0.00819083f, 0.01233798f, -0.00676479f, 0.00773092f, -0.01228509f, -0.02590556f, 0.01162567f, -0.03867699f, 
    0.00079462f, -0.03208094f, -0.03813486f, -0.02156556f, -0.00995019f, -0.00638890f, -0.01029229f, -0.01955753f, 
    0.01717332f, 0.00311936f, -0.04305042f, 0.00236749f, -0.00457072f, 0.01471933f, -0.03724999f, 0.00786219f, 
    0.01355097f, -0.00548136f, -0.04708798f, 0.00261252f, 0.00807794f, 0.01608274f, 0.00924552f, 0.00563980f, 
    0.02598141f, -0.03201509f, -0.01428708f, 0.02249039f, -0.02253033f, 0.03154541f, -0.00648331f, -0.04074060f, 
    -0.04055911f, -0.00338912f, -0.01603698f, -0.03860493f, 0.02823693f, -0.00883146f, 0.00355106f, -0.03783624f, 
    -0.00736095f, 0.02643849f, -0.00464744f, -0.01242005f, -0.00235248f, -0.00702274f, -0.01978025f, 0.02264912f, 
    -0.02107088f, -0.00566624f, -0.02246848f, 0.00671496f, 0.00335600f, 0.00583151f, -0.01318275f, 0.00138969f, 
    -0.00733797f, -0.03641456f, 0.02618060f, -0.03854376f, -0.03642752f, 0.00886453f, 0.00204146f, -0.03766590f, 
    -0.04339151f, -0.00088936f, 0.02792180f, 0.03204828f, -0.03060967f, -0.03715609f, -0.01633049f, -0.03253787f, 
    -0.02465397f, 0.01962269f, 0.01632156f, -0.03216809f, 0.01510225f, 0.00199791f, 0.02167853f, 0.01594628f, 
    0.02787082f, 0.01382649f, 0.01301025f, -0.04514139f, -0.02635907f, 0.02485686f, 0.01046822f, 0.02952504f, 
    -0.02529266f, -0.02872249f, -0.02206169f, -0.03212861f, 0.01529885f, 0.02164466f, 0.01451427f, 0.01900930f, 
    0.02538341f, -0.03027641f, -0.03043284f, 0.01851706f, -0.00463842f, -0.00766246f, -0.01614521f, -0.00535359f, 
    0.00716303f, 0.00295491f, 0.02308489f, -0.00501778f, -0.02337402f, 0.01029673f, -0.00550738f, -0.00984816f, 
    0.02296063f, -0.04261458f, 0.02788620f, 0.00115684f, -0.04316051f, 0.00990186f, 0.00143629f, -0.00863468f, 
    -0.02452373f, 0.00084821f, -0.03268946f, 0.00354683f, -0.01958892f, -0.02914536f, -0.02936026f, -0.00020072f, 
    -0.00626544f, 0.01030415f, -0.00259486f, 0.02425724f, -0.02359123f, 0.00539363f, -0.01222292f, -0.04296177f, 
    -0.03167028f, 0.02268074f, 0.01757246f, -0.04141083f, -0.03960289f, 0.01683873f, 0.01307389f, 0.02846593f, 
    -0.00625252f, 0.00897528f, -0.01236649f, -0.02360024f, 0.02522684f, 0.02065453f, 0.01326904f, -0.00689737f, 
    -0.02265691f, -0.02955801f, -0.03692231f, -0.03196200f, -0.00861287f, -0.02579220f, -0.01511843f, 0.02186854f, 
    -0.03855557f, -0.00235530f, -0.00042355f, -0.02630196f, 0.01996250f, -0.02017085f, 0.01999091f, -0.01906462f, 
    0.00536727f, 0.01382093f, 0.01194921f, -0.04166121f, -0.02921796f, 0.00755548f, 0.00309548f, 0.02541379f, 
    0.00305631f, 0.01139485f, -0.02199074f, -0.03760951f, -0.03071820f, 0.00123679f, -0.02986754f, 0.01982428f, 
    -0.00641189f, -0.02329144f, 0.00585237f, -0.00330630f, 0.00059958f, 0.00188188f, -0.01287332f, -0.02611594f, 
    0.01513458f, -0.02142408f, 0.02324649f, -0.02949307f, -0.04256039f, -0.04447359f, 0.00826526f, -0.04190370f, 
    -0.02055129f, -0.01454526f, -0.00682185f, 0.02662184f, -0.00426933f, 0.01703641f, -0.03905866f, 0.01813935f, 
    -0.02852763f, -0.02580941f, 0.01692840f, -0.01728495f, 0.01691888f, 0.03238398f, 0.00329691f, -0.04277309f, 
    0.01847483f, -0.01178538f, -0.01332670f, -0.02313743f, -0.00944455f, -0.00098784f, 0.00205376f, -0.02271551f, 
    -0.00222234f, -0.00610188f, -0.03104314f, 0.02883613f, 0.01053253f, -0.01869348f, 0.01987683f, 0.00858656f, 
    0.02099101f, 0.00771113f, -0.02181185f, -0.02619312f, -0.01672210f, -0.03971886f, -0.01140154f, -0.04432798f, 
    -0.03580853f, 0.02540121f, -0.04523700f, -0.00670359f, 0.01635795f, 0.01382713f, 0.01059736f, -0.03012312f, 
    0.01150037f, -0.00507008f, 0.02908382f, -0.03188190f, 0.00118869f, 0.02502243f, 0.00627693f, 0.01297683f, 
    0.02954997f, -0.03724077f, -0.02980213f, 0.01102113f, -0.02786647f, 0.01732903f, -0.00666999f, 0.00050262f, 
    0.00186149f, 0.02694789f, -0.02817997f, 0.02014102f, 0.00044831f, -0.01373084f, -0.01300637f, 0.01588229f, 
    -0.00696854f, 0.02118547f, -0.03842017f, 0.03162845f, 0.01326596f, 0.00517137f, -0.04266843f, -0.02260217f, 
    0.00161933f, -0.01418338f, -0.03355518f, -0.00583638f, -0.02870897f, -0.04504026f, 0.02499785f, 0.03025265f, 
    -0.04310869f, 0.01100666f, -0.00880377f, 0.00309179f, -0.00064576f, -0.04332259f, -0.02677395f, -0.00256917f, 
    -0.03003827f, -0.03660577f, -0.03931726f, 0.02692882f, -0.00005740f, -0.01516215f, -0.04195672f, 0.00005961f, 
    -0.01173457f, 0.00655099f, 0.01576840f, 0.02887668f, 0.02884849f, 0.01780951f, 0.00414442f, -0.03014275f, 
    -0.04329936f, 0.02845629f, -0.03740784f, -0.04551361f, 0.01509980f, 0.00013525f, 0.01781067f, -0.01501264f, 
    0.00145152f, -0.00469148f, -0.03413597f, 0.00057496f, -0.01977001f, -0.04296646f, -0.02496474f, 0.02521983f, 
    0.02771269f, -0.01096852f, 0.02720716f, -0.02150802f, -0.02398228f, 0.00221067f, -0.00927873f, -0.01827663f, 
    0.00612249f, 0.02409666f, -0.01182807f, -0.03344066f, 0.02999911f, -0.03432851f, 0.00361626f, 0.02623364f, 
    -0.04182740f, -0.01801156f, -0.03633362f, -0.03833914f, -0.02643018f, 0.01886792f, 0.00693116f, -0.01257616f, 
    -0.01028024f, -0.01689461f, -0.03149203f, 0.03164784f, -0.00322839f, -0.01148889f, 0.00269694f, -0.00896330f, 
    -0.03303373f, 0.01363011f, 0.00755287f, -0.02938323f, -0.03453699f, -0.02870842f, -0.02389771f, -0.04684467f, 
    0.01685325f, 0.00594072f, 0.00203135f, 0.00369629f, -0.04216170f, 0.00449847f, 0.03275161f, 0.00025371f, 
    0.00510361f, -0.00801477f, 0.01803997f, -0.02846306f, 0.02582874f, 0.00557049f, 0.02663298f, 0.00023973f, 
    -0.03218282f, -0.00218664f, 0.03081353f, -0.01757625f, 0.00123220f, -0.00683103f, 0.02268199f, -0.00733540f, 
    -0.00567989f, -0.03036129f, -0.02605370f, -0.04066072f, -0.02302315f, 0.01802955f, -0.02268534f, -0.03598042f, 
    0.01860335f, -0.00003818f, -0.01001723f, -0.03826190f, 0.03040408f, -0.03647294f, 0.01657514f, 0.00149107f, 
    -0.01096508f, 0.00283240f, 0.01467095f, -0.01344963f, 0.02687955f, -0.01525539f, 0.00772781f, -0.00484667f, 
    -0.03077497f, -0.01513846f, -0.01441351f, -0.02697431f, -0.01061105f, -0.01623578f, -0.01321637f, -0.00173021f, 
    0.00818402f, 0.02055983f, 0.02443439f, -0.00059639f, 0.00324915f, -0.03004655f, -0.03861703f, 0.02090240f, 
    -0.01542139f, 0.04251532f, 0.01880516f, 0.00898823f, 0.01293030f, 0.00819487f, -0.00798515f, 0.03297596f, 
    0.00645749f, -0.01519744f, -0.00359250f, -0.02148583f, -0.01640215f, -0.01441012f, -0.02779703f, 0.00502491f, 
    0.00006501f, 0.02651510f, -0.00252133f, -0.04719584f, 0.01208347f, -0.01363695f, -0.00099709f, 0.01152566f, 
    -0.02786714f, -0.03396437f, 0.03140933f, 0.00091003f, -0.03470374f, 0.03000619f, 0.02920171f, 0.02492908f, 
    -0.00375850f, 0.02058519f, -0.01059944f, 0.01684931f, 0.00442666f, 0.00965822f, -0.01746723f, 0.02525863f, 
    0.02451449f, 0.00161637f, -0.03655724f, 0.00609909f, 0.00063155f, 0.01436006f, 0.02838504f, 0.01572699f, 
    -0.00271274f, -0.01451816f, 0.00094387f, -0.02079301f, -0.03655414f, 0.01018752f, 0.02258752f, -0.02070157f, 
    -0.01887108f, -0.03660341f, -0.03311082f, -0.02642654f, 0.00058011f, 0.01004098f, 0.01712746f, -0.03369166f, 
    0.01594949f, -0.00146724f, 0.03148194f, -0.01764261f, -0.03605029f, 0.01599634f, -0.00904185f, 0.02014913f, 
    -0.02071820f, -0.03993223f, -0.04337645f, 0.02539855f, 0.00510576f, -0.02854696f, -0.01182875f, 0.03493827f, 
    0.00710728f, -0.00355306f, -0.01235554f, 0.01300505f, 0.02040672f, 0.00725546f, 0.02258905f, 0.03796892f, 
    0.02717132f, 0.00595848f, 0.00977954f, 0.02386689f, 0.00191347f, 0.00522890f, 0.00428390f, 0.01327734f, 
    -0.03186220f, 0.01369446f, -0.03968808f, 0.02790050f, 0.01823468f, -0.02728806f, -0.03927857f, -0.00132242f, 
    0.02122750f, -0.00233600f, 0.02659858f, 0.00701423f, 0.00915509f, 0.01789806f, -0.04536226f, 0.02776739f, 
    -0.02254354f, -0.04202956f, -0.01122068f, 0.04125144f, -0.01975761f, -0.01122550f, -0.03502479f, -0.02807510f, 
    -0.03345073f, -0.01530507f, -0.00757104f, 0.01900615f, -0.02973033f, 0.01315723f, -0.00976650f, 0.03866066f, 
    -0.02669800f, 0.01891690f, -0.00318284f, -0.00500607f, -0.01994384f, -0.02449011f, 0.00616376f, 0.03107817f, 
    -0.01018184f, -0.03764713f, 0.01020066f, 0.02414694f, -0.00091590f, 0.00117806f, 0.01101327f, -0.02665178f, 
    0.02267533f, 0.03595232f, -0.01118012f, -0.02830349f, -0.04252731f, 0.02793473f, -0.01596518f, 0.00800755f, 
    -0.02815357f, -0.01182641f, -0.01777843f, 0.02898129f, -0.03316108f, 0.03421983f, 0.01120859f, -0.03448067f, 
    0.02086783f, -0.02402481f, 0.00209540f, -0.03327610f, -0.02386774f, -0.02253645f, 0.01160473f, -0.01004647f, 
    -0.00366368f, 0.00752355f, -0.00932580f, 0.02402710f, 0.03347245f, 0.00640600f, 0.00558766f, -0.02997200f, 
    -0.00124727f, 0.02746542f, 0.00115666f, 0.02078184f, 0.01850192f, -0.01446543f, -0.01189873f, -0.03921663f, 
    -0.03318277f, -0.01757224f, -0.03139642f, 0.02838536f, -0.04144160f, -0.02897149f, -0.02864981f, -0.02294234f, 
    -0.03080337f, -0.02184636f, -0.02282567f, -0.02977245f, -0.03692883f, -0.03364110f, 0.01817610f, -0.00340954f, 
    0.01333116f, -0.00830296f, -0.02619006f, -0.03542075f, -0.03540419f, 0.03139864f, -0.02880458f, -0.02799712f, 
    0.00695523f, -0.00788498f, 0.01868958f, 0.03251655f, 0.01975866f, -0.04381656f, 0.02787602f, -0.04223906f, 
    0.01111611f, 0.01439743f, -0.04088074f, -0.02220089f, 0.02387033f, 0.01332252f, -0.02991969f, -0.00974548f, 
    -0.00109828f, 0.00488995f, -0.02123493f, 0.00737482f, 0.02126574f, -0.02345594f, 0.03277594f, -0.03421729f, 
    0.01318158f, -0.01146298f, 0.01373650f, 0.02204278f, -0.01166119f, 0.03643266f, -0.03787722f, -0.03497938f, 
    -0.03623153f, -0.01849460f, -0.01108112f, 0.02844064f, -0.04143052f, 0.00475226f, -0.00356398f, -0.01427689f, 
    0.01322487f, -0.02981593f, -0.02888429f, 0.02040472f, 0.02390720f, -0.02470192f, -0.03843717f, 0.02052162f, 
    0.00825815f, -0.02046462f, -0.00493097f, 0.01080423f, -0.01215102f, -0.03574640f, -0.00076509f, -0.02430285f, 
    0.00545258f, 0.03731096f, -0.03102716f, 0.00330386f, 0.00518590f, -0.02811941f, 0.01331891f, 0.00532110f, 
    0.01798679f, 0.00820499f, -0.02853012f, -0.03820099f, 0.03358566f, 0.00986251f, -0.03105085f, 0.00893062f, 
    0.01706438f, 0.00679086f, 0.00443596f, -0.03385665f, -0.02895121f, 0.01432894f, -0.02161363f, 0.00280412f, 
    -0.01046616f, 0.02714817f, -0.03153963f, -0.00316506f, 0.01250591f, -0.02069413f, -0.01459680f, -0.04317885f, 
    -0.00389953f, -0.00086176f, -0.02581305f, 0.00593301f, 0.00495199f, 0.03390324f, 0.00105964f, 0.03360448f, 
    0.00556352f, -0.02430545f, 0.01927373f, -0.01996138f, -0.04463296f, 0.01766471f, -0.02550132f, -0.00083626f, 
    0.00352286f, -0.02264481f, -0.01651465f, -0.02965526f, -0.01810628f, 0.01558952f, 0.00173034f, 0.00009966f, 
    -0.01917366f, -0.03609153f, -0.00910425f, 0.01254356f, 0.01622974f, -0.00126432f, 0.03532175f, 0.00622532f, 
    -0.00373557f, -0.01490822f, -0.01621703f, -0.02068040f, 0.01772858f, 0.01982059f, -0.03063152f, 0.01370701f, 
    -0.04157632f, -0.00570351f, 0.02721730f, -0.04548181f, -0.03203234f, -0.01163991f, 0.03298988f, -0.02483031f, 
    0.01669864f, -0.04139969f, 0.03417024f, -0.02155094f, 0.00253866f, 0.01717640f, -0.03672362f, -0.03149836f, 
    -0.03577046f, -0.03547328f, -0.00000489f, 0.00194996f, 0.03054284f, 0.02110355f, -0.03215830f, 0.02800164f, 
    0.00596584f, 0.01186109f, -0.00883918f, 0.02213865f, -0.02614279f, -0.00134906f, 0.02907688f, -0.02925594f, 
    0.00442578f, -0.02684314f, -0.02010229f, 0.00473346f, -0.01681228f, 0.01385608f, -0.00759467f, -0.01337747f, 
    0.03780124f, 0.01456071f, 0.01980479f, 0.03422061f, -0.03780707f, 0.02255957f, 0.02625850f, -0.01744565f, 
    0.00669366f, 0.00173174f, -0.02165792f, -0.00372761f, -0.01704521f, -0.01634229f, -0.03736348f, 0.01311639f, 
    0.01351010f, 0.01326209f, -0.04549018f, -0.00740352f, -0.03158049f, -0.03038630f, 0.03062168f, 0.03565690f, 
    0.01861520f, -0.03282794f, -0.02286095f, 0.00623903f, 0.00784159f, -0.00102419f, -0.00241470f, 0.01872730f, 
    -0.00237311f, -0.00088322f, 0.01674212f, -0.03390865f, -0.00433653f, -0.02974695f, 0.02663964f, -0.01591073f, 
    -0.02858299f, 0.00416967f, -0.01666583f, -0.03925311f, -0.03709039f, 0.00085847f, -0.00119562f, -0.01943387f, 
    0.02190956f, 0.02600153f, 0.00092425f, -0.03023833f, -0.00597362f, 0.02224092f, -0.00557724f, -0.03711754f, 
    -0.02888020f, 0.01235892f, -0.01955968f, -0.03522478f, -0.04367620f, -0.02465594f, -0.02187948f, -0.02755543f, 
    -0.01712535f, 0.01428769f, 0.03451489f, 0.00072687f, -0.03629563f, -0.01164825f, -0.04405106f, 0.02742158f, 
    0.00302494f, -0.03286359f, -0.02224559f, -0.02180365f, -0.01232829f, -0.03498472f, -0.01670469f, 0.02397546f, 
    0.01779552f, -0.04145845f, 0.02650918f, -0.02032213f, -0.03732985f, 0.03208522f, 0.03564616f, 0.01078395f, 
    -0.00244609f, 0.02579917f, -0.00200668f, -0.02650038f, -0.04181698f, 0.02269553f, -0.03613554f, -0.03920466f, 
    0.01155843f, -0.01558041f, 0.02355289f, -0.03229490f, -0.02843241f, -0.01987149f, 0.03719947f, 0.00947493f, 
    -0.02907042f, -0.02596904f, 0.03239125f, 0.00893419f, 0.01345998f, -0.02933288f, -0.01913156f, -0.03806004f, 
    0.01643481f, -0.00077330f, 0.01520140f, -0.03722735f, -0.02028289f, 0.00365809f, -0.02947276f, 0.02312861f, 
    0.00134752f, 0.02578875f, -0.00555324f, 0.02928396f, 0.01531289f, -0.03091196f, 0.01892832f, 0.03078413f, 
    -0.01643442f, -0.01631909f, -0.01232161f, -0.02578837f, -0.03666987f, 0.00940755f, 0.01816565f, 0.00883571f, 
    -0.04225559f, -0.03629380f, -0.02806957f, -0.03530634f, 0.00187725f, 0.03253058f, -0.02462778f, -0.03523431f, 
    -0.02575630f, 0.03139271f, -0.01808750f, -0.00805655f, -0.01936062f, 0.00864998f, 0.03544955f, -0.01519728f, 
    -0.00128800f, -0.00187212f, -0.01371063f, -0.00536094f, 0.02644000f, -0.01082397f, 0.02129417f, 0.00037695f, 
    0.00623679f, -0.02202417f, 0.02501831f, 0.02013161f, 0.00166469f, 0.01175022f, -0.02122222f, -0.01466365f, 
    -0.02259370f, 0.01030045f, 0.00285669f, -0.01306222f, -0.02132004f, -0.02708799f, 0.03246328f, -0.04348658f, 
    0.01184041f, 0.03346523f, -0.03599268f, -0.00778885f, -0.03888085f, -0.04204601f, 0.03015161f, -0.02218951f, 
    0.03131656f, 0.00772892f, 0.01964632f, -0.04439874f, -0.01201993f, -0.03891169f, -0.03742069f, -0.03314333f, 
    -0.01144875f, -0.01884138f, 0.00956741f, 0.02760918f, 0.02645910f, 0.01680268f, -0.02798500f, -0.01493052f, 
    -0.00234888f, -0.02566729f, -0.00029295f, -0.03160337f, 0.00301058f, 0.03122324f, -0.01280224f, 0.01611103f, 
    0.00276550f, -0.00385134f, -0.04205672f, 0.02575981f, 0.01967395f, -0.00666701f, -0.03799054f, 0.03276811f, 
    0.00637163f, -0.01053433f, 0.01953153f, -0.02919064f, 0.00586779f, -0.01191529f, 0.01555232f, 0.00755252f, 
    -0.03792506f, -0.01505455f, 0.03335221f, 0.00948055f, -0.00108579f, -0.02250080f, -0.03369137f, -0.02670641f, 
    -0.00372451f, -0.01436008f, -0.00558982f, -0.01520086f, -0.01386476f, -0.03511743f, 0.01905926f, 0.03288364f, 
    0.03009454f, -0.01604837f, -0.01017933f, 0.00226983f, -0.01344661f, -0.04261085f, 0.02799916f, 0.01243243f, 
    -0.02937756f, -0.02939751f, -0.01058780f, -0.03441707f, 0.03036417f, 0.02510578f, -0.03953852f, -0.00918097f, 
    -0.04195267f, -0.00989080f, 0.00984666f, 0.00121100f, -0.04489659f, -0.00944976f, -0.00556989f, -0.00673361f, 
    -0.02338744f, -0.00362270f, 0.01444192f, -0.03987001f, 0.00908531f, -0.04013544f, -0.01106643f, 0.02513898f, 
    -0.00091907f, -0.00885358f, -0.00202020f, -0.01466368f, 0.02177709f, -0.03380091f, -0.02710612f, 0.00617323f, 
    0.02953879f, -0.00516606f, -0.04338421f, -0.02018799f, 0.01448262f, -0.03159364f, 0.03030681f, 0.03004033f, 
    -0.02343669f, 0.03087534f, -0.03834887f, 0.02276314f, 0.02564164f, 0.00181038f, -0.03470786f, -0.02740803f, 
    0.01765878f, 0.00243671f, 0.03281096f, -0.03081650f, 0.00964298f, 0.02138335f, -0.02139098f, -0.03331268f, 
    -0.03256862f, 0.00022986f, 0.00419280f, 0.03492403f, -0.03336137f, 0.00701103f, -0.01983379f, -0.01254046f, 
    -0.00464529f, -0.01267471f, -0.04551946f, -0.02140803f, -0.01706044f, -0.03038247f, -0.01208467f, 0.03230302f, 
    -0.01384714f, 0.00867269f, -0.01807035f, -0.01111584f, -0.03421389f, 0.02690625f, 0.01241920f, 0.03123380f, 
    -0.04259782f, 0.00898039f, -0.03940259f, 0.02137812f, -0.00508776f, -0.03903943f, 0.02352894f, 0.03250344f, 
    0.02142127f, -0.02338830f, -0.03717105f, -0.01143921f, -0.02021582f, 0.01931269f, 0.00883563f, -0.03467393f, 
    -0.00188785f, 0.01163617f, -0.01366883f, -0.03344671f, -0.01591698f, -0.02187364f, 0.00222819f, 0.00137223f, 
    0.01958358f, -0.02631567f, -0.02570922f, 0.02843743f, -0.01400917f, -0.00300219f, -0.03346783f, 0.00102909f, 
    -0.01407713f, -0.04365268f, -0.01692030f, 0.02048913f, -0.01103489f, -0.03696912f, -0.04532723f, -0.03117709f, 
    -0.00337086f, -0.03125086f, 0.00142400f, 0.00266881f, 0.00354616f, 0.02851877f, -0.00506040f, 0.02078889f, 
    0.00873516f, 0.01785867f, 0.00314265f, 0.00356671f, 0.03183034f, -0.02235204f, 0.01909368f, 0.01323604f, 
    -0.00239433f, 0.01674043f, 0.01843360f, -0.02308970f, 0.01020523f, 0.00107595f, -0.03925581f, 0.02746137f, 
    -0.01912696f, 0.02309733f, 0.02793158f, -0.00183557f, 0.02407696f, 0.02830500f, 0.01074912f, -0.01624005f, 
    -0.01058390f, -0.02801805f, 0.00937551f, -0.00149517f, -0.02209819f, -0.00155262f, -0.03300614f, 0.02510372f, 
    0.00711871f, 0.00495595f, 0.01028995f, 0.03345796f, -0.00981802f, -0.01108422f, 0.02199588f, -0.02009143f, 
    -0.02976181f, 0.00775260f, -0.02357562f, 0.02104226f, -0.02938359f, 0.00446938f, 0.01964409f, 0.03341446f, 
    0.03840654f, -0.00636327f, -0.01370325f, 0.02057518f, -0.02036298f, -0.02133839f, 0.02217065f, 0.03707510f, 
    -0.03512889f, -0.03881583f, 0.00863458f, -0.04157890f, -0.03786139f, -0.00123724f, -0.02423691f, -0.03090153f, 
    0.01901805f, -0.00235846f, 0.00546850f, 0.01217648f, 0.01167054f, 0.01697627f, -0.02887310f, -0.04429825f, 
    -0.03108375f, 0.01229513f, -0.01277949f, -0.03406792f, -0.00324026f, 0.01509784f, 0.00777811f, -0.04520991f, 
    -0.02777996f, -0.03580411f, 0.03065218f, 0.02876141f, 0.02374133f, -0.00902306f, -0.00548869f, 0.02033393f, 
    -0.04467538f, -0.01694032f, 0.01749812f, 0.02814519f, 0.00817651f, 0.03116436f, 0.02466835f, -0.03098899f, 
    0.01395808f, -0.02920406f, -0.03221837f, 0.01698763f, -0.02845176f, -0.04351967f, 0.02917981f, 0.00493993f, 
    0.02124519f, -0.04349846f, -0.02391299f, -0.03585165f, 0.00151863f, 0.02312051f, 0.02596852f, -0.00385256f, 
    0.00028132f, -0.04296073f, -0.00483475f, -0.00818696f, 0.01585876f, -0.04172851f, 0.02507026f, 0.02197975f, 
    -0.03628221f, 0.01930408f, 0.02073472f, 0.00986248f, -0.01747041f, 0.03531849f, -0.04453897f, 0.00248547f, 
    0.03639662f, -0.03412682f, 0.00645449f, 0.00340346f, 0.02522044f, -0.02476497f, -0.03768726f, 0.00479586f, 
    -0.03469187f, 0.01273180f, -0.02154211f, -0.03580989f, -0.01767878f, -0.03645695f, -0.00545591f, -0.04139442f, 
    0.01935783f, 0.00457770f, 0.02099091f, -0.01182522f, -0.04281654f, -0.00257196f, 0.00294086f, -0.03062546f, 
    -0.02152244f, 0.00600472f, -0.01460364f, -0.01858440f, 0.01567043f, -0.03375791f, -0.01995442f, -0.00390799f, 
    -0.00734371f, -0.01005701f, -0.01375955f, -0.04076306f, 0.01490179f, 0.00713904f, -0.03948696f, -0.00662469f, 
    -0.01496410f, -0.01771544f, -0.03965864f, -0.02483168f, 0.03136949f, -0.02435924f, -0.00814424f, -0.01116096f, 
    0.00406571f, -0.03493845f, -0.02754931f, -0.03452052f, -0.02499053f, -0.02010284f, -0.02306832f, -0.03912353f, 
    0.00516038f, -0.04381098f, -0.04506741f, 0.02989648f, -0.01017164f, -0.02461815f, 0.02402397f, -0.03751012f, 
    0.02880270f, -0.00394540f, -0.02408485f, -0.01383703f, 0.03108480f, -0.02092364f, 0.00799183f, 0.01233273f, 
    0.00418602f, 0.00657955f, -0.04196100f, -0.02293804f, -0.01030073f, -0.00510261f, 0.02104322f, -0.03126131f, 
    -0.03087892f, 0.00818929f, -0.03829363f, -0.03880166f, 0.03285778f, 0.02912916f, -0.04267995f, -0.01225956f, 
    0.02481942f, -0.00246700f, -0.00671803f, 0.00718354f, 0.02195472f, 0.00196046f, -0.03004761f, 0.02016697f, 
    0.00552195f, 0.00889109f, 0.00518465f, -0.02873732f, -0.03833953f, -0.01660063f, 0.02747298f, -0.01977050f, 
    0.01910299f, 0.01705885f, 0.01619483f, -0.04196438f, -0.01150012f, 0.00925507f, -0.01541368f, 0.00211819f, 
    -0.03790779f, -0.01835919f, -0.03778356f, 0.02196415f, 0.01407161f, 0.01531585f, -0.03830910f, 0.00497165f, 
    -0.00197468f, 0.02392166f, -0.00314735f, -0.04425228f, -0.04448952f, -0.02720879f, 0.02003850f, -0.02844928f, 
    0.01638656f, 0.02645613f, 0.02761821f, -0.03590191f, 0.00842360f, 0.00555810f, -0.02249031f, 0.03787784f, 
    0.02874667f, 0.02742952f, -0.03449585f, -0.00726266f, 0.03282012f, 0.01700183f, -0.04496032f, 0.02665786f, 
    -0.04351876f, -0.02111574f, 0.00693196f, 0.01959735f, -0.02381770f, -0.00595344f, -0.02394783f, -0.03628645f, 
    0.03089205f, -0.02790402f, -0.03039309f, -0.00096196f, -0.03702741f, -0.03177459f, -0.02312007f, -0.03391607f, 
    -0.01584855f, -0.00880866f, 0.02748837f, -0.01471772f, 0.02884201f, 0.01339503f, 0.02425781f, 0.00321464f, 
    0.00392234f, 0.01071391f, -0.01529913f, 0.02770231f, -0.01370175f, -0.02579499f, -0.02074405f, -0.00425402f, 
    0.01208490f, 0.02308299f, -0.02404753f, 0.00053324f, 0.00588079f, 0.02455152f, 0.01362603f, -0.00773417f, 
    0.02929052f, -0.03060900f, 0.01472823f, -0.02370985f, -0.01121705f, -0.03472199f, 0.01077812f, 0.01552030f, 
    -0.02770337f, 0.02929930f, -0.00896344f, 0.00509957f, 0.02874896f, 0.01951620f, 0.00179974f, 0.02652783f, 
    -0.03295651f, 0.01194707f, -0.00737976f, 0.03309808f, 0.00147212f, -0.04469360f, 0.02564409f, -0.00514217f, 
    -0.03107338f, 0.01325305f, 0.01392630f, 0.01301145f, -0.01324292f, -0.02955058f, -0.02774258f, -0.03540555f, 
    -0.00769531f, -0.02134595f, -0.03598968f, 0.02329480f, 0.02813978f, 0.01117694f, -0.01693578f, 0.00618656f, 
    -0.03625663f, 0.00875880f, 0.01917330f, -0.02657350f, -0.04069397f, 0.00317485f, 0.01690817f, -0.02810610f, 
    -0.04493606f, -0.03011469f, 0.02608510f, 0.02191501f, -0.02923288f, -0.04443560f, -0.03115608f, -0.01364989f, 
    -0.02664519f, -0.02691019f, 0.00457640f, -0.02792086f, 0.02501992f, -0.04493479f, -0.00828285f, 0.01816047f, 
    -0.02715857f, 0.00863174f, 0.00700539f, -0.04309919f, -0.01513840f, -0.02924823f, 0.02116671f, -0.01781354f, 
    0.01174237f, -0.01014315f, 0.02639501f, 0.02461382f, -0.04203071f, -0.02821018f, 0.02808228f, 0.03272561f, 
    -0.02998999f, 0.02710230f, 0.02557524f, 0.00404617f, 0.01022710f, -0.03986333f, -0.03654024f, -0.02711687f, 
    0.01164447f, -0.03172342f, -0.02131992f, 0.02843233f, 0.01223594f, -0.03661215f, -0.02615817f, 0.00541735f, 
    -0.00489546f, -0.03797915f, -0.01608852f, 0.01221143f, 0.02724900f, 0.01398942f, -0.03855112f, 0.01884405f, 
    -0.01236210f, 0.01963906f, -0.03927573f, -0.01307693f, -0.03790313f, 0.02930933f, -0.02691028f, 0.00471305f, 
    0.02497260f, -0.01505428f, -0.02205496f, 0.02866287f, -0.01847065f, -0.03707932f, 0.01404682f, 0.01785762f, 
    0.02312172f, 0.02001175f, -0.01686645f, 0.00687108f, 0.02282767f, -0.00119575f, 0.02468550f, -0.00573958f, 
    -0.02403610f, -0.03317477f, -0.00781569f, -0.02489905f, 0.02898514f, -0.03000056f, -0.03509185f, -0.02820692f, 
    0.00250469f, -0.00139527f, -0.00354912f, -0.02326225f, 0.01429259f, -0.00503342f, -0.03549232f, -0.00407371f, 
    -0.02342452f, -0.03078176f, 0.00314734f, -0.03452527f, 0.01737521f, 0.03076198f, -0.01449821f, -0.00339977f, 
    -0.01730453f, 0.01457913f, 0.01395320f, -0.04810175f, 0.01463636f, -0.01163267f, -0.02798415f, -0.01170740f, 
    0.01246330f, -0.03828261f, -0.01450098f, 0.00700163f, -0.01857282f, -0.04305378f, -0.02964447f, 0.00925990f, 
    -0.02131455f, 0.02913304f, 0.00862427f, -0.01312126f, 0.02691518f, 0.00989239f, 0.02122539f, 0.00328465f, 
    0.01030073f, -0.02627495f, -0.03085072f, -0.02292881f, -0.04651187f, 0.01791820f, -0.01198932f, 0.02230485f, 
    0.00428697f, -0.03475617f, 0.02398435f, -0.01640918f, -0.03215772f, -0.03241863f, 0.00785610f, -0.03215568f, 
    0.02877166f, 0.03452653f, -0.00255015f, -0.04224094f, -0.00973598f, 0.01882507f, 0.00440147f, -0.02432696f, 
    -0.04162737f, -0.03672922f, -0.01541224f, 0.00485973f, 0.01662794f, -0.03274951f, 0.02210018f, -0.03972238f, 
    -0.02182914f, -0.03847418f, -0.01162588f, -0.03927809f, 0.01689051f, -0.01508159f, 0.00455714f, -0.01179796f, 
    -0.03892981f, -0.01147813f, -0.02053142f, -0.01114850f, -0.03869442f, -0.02988190f, -0.03011184f, 0.00341932f, 
    0.00955129f, 0.01932534f, -0.04613608f, -0.00707073f, -0.02141013f, -0.01118776f, 0.02681218f, -0.03325234f, 
    -0.04460087f, 0.01568091f, -0.00396233f, 0.00012380f, -0.03670764f, -0.00289924f, -0.01090056f, 0.00245177f, 
    -0.00502239f, 0.02368456f, -0.01260733f, 0.01166908f, 0.01226349f, -0.00334554f, -0.01677790f, -0.00642139f, 
    -0.02096319f, 0.02518767f, 0.01284827f, -0.02353113f, -0.00981956f, -0.03029232f, -0.01146449f, -0.03938670f, 
    -0.02575343f, -0.03547964f, -0.03967892f, -0.04047303f, 0.03278019f, -0.02659193f, -0.02978323f, -0.04076708f, 
    0.00717727f, -0.00587228f, -0.02907188f, 0.00717908f, 0.02559458f, -0.01337884f, -0.04140195f, -0.04010900f, 
    -0.02896284f, -0.00430483f, 0.00534345f, -0.01179237f, 0.00240091f, -0.01743001f, -0.00624681f, -0.00872112f, 
    -0.02393253f, 0.00299316f, -0.02462258f, -0.03782447f, 0.00852728f, 0.00424148f, 0.00242060f, -0.01635566f, 
    0.02781985f, 0.02462701f, -0.02643662f, 0.02702961f, -0.01670828f, -0.02563976f, 0.02294363f, -0.01906544f, 
    -0.03263563f, -0.02327131f, 0.01699178f, -0.04841780f, -0.02136138f, 0.00713134f, -0.02776294f, 0.02049661f, 
    0.01597518f, 0.01039428f, -0.04128122f, 0.01108377f, -0.01487736f, 0.00408889f, -0.04015816f, 0.00827128f, 
    0.00583747f, -0.02389300f, -0.03465839f, -0.04283248f, 0.01060587f, 0.03679577f, -0.03043256f, -0.00225740f, 
    0.01608072f, 0.02641212f, -0.00062224f, 0.02156914f, 0.00420318f, -0.04494594f, -0.03999573f, -0.01787078f, 
    -0.03233811f, -0.03804025f, -0.00006550f, -0.00335239f, 0.02265139f, 0.01085765f, -0.01569545f, -0.00260214f, 
    -0.00880743f, -0.01414356f, 0.01089391f, -0.04204488f, -0.02878208f, -0.04707545f, -0.02801533f, -0.01718789f, 
    -0.01679971f, -0.02473868f, -0.00625914f, -0.00025064f, -0.02860898f, -0.03350227f, 0.01626030f, -0.01445005f, 
    0.00565192f, -0.00694216f, -0.04015059f, 0.02844886f, -0.04339863f, 0.01173434f, 0.01088363f, 0.02328247f, 
    0.01048287f, -0.01106491f, 0.02871863f, -0.00022815f, 0.00066625f, -0.01389798f, 0.00260769f, 0.01301016f, 
    -0.02923392f, -0.01821834f, 0.00212571f, -0.00579333f, -0.00648547f, -0.04780822f, -0.00932879f, 0.03163095f, 
    0.02085165f, 0.00316638f, -0.04547174f, 0.00755217f, -0.03618388f, -0.00736062f, 0.02909715f, -0.00134508f, 
    0.00786385f, -0.04598596f, 0.01182940f, 0.00287813f, -0.04085217f, -0.04182383f, 0.02298321f, -0.01281212f, 
    0.02911429f, 0.02852871f, 0.01141762f, 0.00895227f, -0.02503089f, 0.02133449f, 0.00368059f, 0.01655531f, 
    -0.01300606f, -0.01448128f, -0.00666219f, -0.01543610f, -0.00988756f, -0.02484084f, -0.02587243f, 0.00673492f, 
    -0.03193746f, -0.02618249f, 0.02448637f, 0.01663872f, 0.02755512f, -0.03498017f, 0.02877256f, 0.02083070f, 
    -0.02284284f, 0.02206630f, -0.00581599f, -0.03141478f, -0.04422597f, 0.02101989f, -0.04797761f, 0.03036111f, 
    -0.00160320f, -0.02622722f, -0.02242824f, 0.02843331f, 0.02907134f, -0.03807411f, -0.04028757f, -0.02307998f, 
    0.02432130f, -0.00953312f, -0.03816146f, 0.01772622f, -0.01559117f, -0.01764933f, -0.02066237f, -0.00105572f, 
    -0.03396498f, -0.00295136f, 0.00889806f, 0.01037530f, -0.01466195f, 0.00919439f, 0.00826275f, 0.00361814f, 
    0.00889615f, 0.02645988f, 0.00161870f, -0.00890931f, 0.00538548f, -0.00236767f, -0.00861079f, 0.00025790f, 
    0.01138034f, -0.02854004f, 0.02087560f, -0.00588241f, -0.03344373f, -0.01759564f, -0.00710855f, 0.01145672f, 
    0.02061580f, -0.02994456f, -0.03145045f, -0.02478865f, 0.00170346f, -0.02564264f, -0.01218827f, 0.02326816f, 
    -0.00955163f, 0.03165974f, -0.00380737f, -0.04003206f, 0.01163829f, -0.04072347f, 0.00821162f, -0.01326489f, 
    0.00209910f, 0.02177438f, 0.01746636f, -0.01990137f, 0.01930001f, 0.00453892f, -0.02401977f, -0.00975771f, 
    0.02324084f, -0.00365878f, 0.02692916f, -0.02565772f, -0.04236890f, -0.00435287f, -0.03923667f, -0.01696760f, 
    0.00335609f, 0.02146757f, -0.02351483f, -0.00598122f, 0.02278770f, -0.00585161f, 0.01892017f, 0.02152300f, 
    -0.03243619f, 0.01672176f, -0.02746306f, -0.00354687f, -0.01713090f, 0.01241229f, -0.02500051f, -0.01864649f, 
    0.01948780f, 0.02480057f, 0.02322685f, 0.02317025f, 0.00477072f, 0.01963855f, -0.00456312f, 0.00486155f, 
    0.00257295f, -0.03412585f, 0.00232638f, -0.02865775f, -0.01421426f, 0.01568250f, -0.02970528f, 0.02461362f, 
    0.00574800f, -0.03845524f, -0.03512294f, -0.04801274f, -0.02172702f, -0.01872161f, 0.01743287f, -0.03813710f, 
    0.00951660f, -0.00260033f, -0.02142365f, 0.00510862f, -0.01511174f, 0.02222318f, -0.01360541f, 0.01522413f, 
    -0.02487047f, 0.02328922f, -0.04661777f, -0.00279041f, 0.02745591f, 0.00869724f, 0.00200547f, -0.03252227f, 
    -0.04436480f, -0.02759763f, 0.02182936f, -0.02009302f, -0.04884187f, 0.02589574f, -0.01276631f, 0.00413515f, 
    -0.03259236f, -0.02731553f, 0.01829173f, -0.04150749f, -0.03111026f, 0.01839690f, -0.04366472f, -0.03437430f, 
    -0.02214504f, -0.03853652f, -0.00944640f, 0.00708722f, -0.01849541f, 0.01488071f, -0.00006154f, 0.02206670f, 
    -0.02686253f, 0.01337215f, 0.02180530f, -0.01758267f, -0.04379773f, 0.00085270f, 0.00430086f, 0.01172088f, 
    -0.00261999f, -0.01462555f, -0.00945673f, -0.02860637f, 0.01943127f, 0.00390589f, -0.01270028f, 0.00151172f, 
    -0.00945780f, -0.03556086f, -0.00184376f, 0.00649063f, -0.03599326f, -0.00826439f, 0.00373287f, -0.00780273f, 
    -0.00128044f, -0.01405151f, -0.02037397f, 0.00124787f, -0.00295333f, -0.04089851f, 0.01723175f, -0.02683932f, 
    0.02984550f, -0.03247031f, -0.04938230f, -0.00404154f, -0.00095008f, -0.02976401f, 0.00886250f, 0.00827315f, 
    -0.00916131f, -0.02556808f, -0.00346692f, -0.04590901f, -0.00938698f, -0.01047059f, -0.03087651f, -0.00101867f, 
    -0.02470006f, 0.02614150f, -0.03830263f, 0.03038124f, -0.02887537f, -0.00586939f, -0.03549601f, 0.01391531f, 
    -0.00795262f, -0.01716371f, -0.04917504f, 0.02397788f, -0.02544514f, -0.03071288f, -0.00161701f, -0.00735980f, 
    0.01417379f, -0.01405322f, 0.01158320f, -0.02083326f, -0.01321685f, 0.00105536f, -0.00089109f, -0.01629322f, 
    -0.01082455f, -0.04291373f, -0.02689555f, -0.00550334f, -0.01318749f, 0.02538089f, 0.02955075f, 0.02522729f, 
    -0.02925091f, -0.00885599f, -0.01807753f, -0.04819795f, -0.02181958f, -0.04283572f, -0.02055859f, 0.03448152f, 
    -0.03383113f, 0.00440757f, 0.00287475f, 0.01749906f, 0.00590058f, -0.03826432f, 0.02640546f, -0.01153233f, 
    -0.01412266f, -0.00345236f, 0.01858886f, 0.00181366f, -0.01199767f, 0.02565873f, -0.02264744f, -0.00717036f, 
    -0.02149107f, -0.00277998f, -0.04815514f, 0.02781994f, 0.02419168f, -0.03823634f, -0.01265649f, 0.03147171f, 
    0.02324153f, -0.00989376f, -0.04547492f, -0.01388683f, 0.00309373f, 0.02263723f, -0.00590100f, -0.04286521f, 
    -0.03386233f, -0.04398460f, 0.02418683f, 0.01884758f, -0.01805326f, -0.00405182f, -0.03781633f, -0.03786213f, 
    0.03920585f, -0.04081283f, -0.02420767f, -0.03137909f, -0.03462679f, 0.00046159f, 0.00670520f, -0.00698046f, 
    -0.03747899f, -0.03549519f, -0.01374447f, 0.03167221f, 0.02630841f, -0.02544742f, 0.02217843f, -0.01768636f, 
    -0.04291710f, -0.00001375f, -0.04425402f, 0.02625599f, 0.02705208f, 0.00968252f, 0.01356303f, -0.03659611f, 
    0.02400044f, 0.02912967f, -0.00735915f, -0.00681031f, -0.04273915f, 0.00040075f, 0.00499014f, 0.01091617f, 
    -0.04944723f, 0.02050866f, -0.00311048f, 0.02866103f, -0.03160635f, -0.04715807f, -0.02188767f, -0.01128586f, 
    0.03079967f, 0.01224271f, -0.03693595f, -0.04457487f, -0.04295617f, -0.02432661f, -0.01570257f, -0.04279564f, 
    -0.02309640f, 0.02257016f, -0.02385553f, -0.00221404f, 0.03497569f, 0.00523591f, -0.01597760f, -0.02714989f, 
    -0.01203052f, -0.02232158f, -0.01589959f, 0.02719080f, 0.02949247f, -0.03904681f, -0.04503878f, 0.01050991f, 
    -0.02756292f, 0.02242036f, -0.01119440f, 0.00549448f, 0.00166791f, 0.00494330f, -0.04346174f, -0.03469780f, 
    0.02215356f, 0.02174229f, -0.01121970f, 0.01667160f, 0.00845000f, -0.03208102f, 0.00342134f, 0.01338244f, 
    0.02362569f, 0.02318279f, 0.01502641f, -0.02525450f, -0.03886711f, 0.01068253f, 0.00693272f, 0.02851198f, 
    -0.02015976f, -0.00614856f, -0.01018938f, 0.01884222f, 0.01855942f, -0.03568546f, -0.02678043f, -0.01735637f, 
    -0.03437249f, 0.02647574f, 0.01240939f, 0.01861040f, -0.03115227f, 0.01149957f, 0.00724850f, 0.01505771f, 
    -0.03518435f, -0.04013202f, -0.04285876f, 0.00388572f, 0.01342850f, -0.00273928f, -0.01613904f, -0.02744459f, 
    0.01787168f, 0.03502368f, 0.03236743f, -0.00639455f, -0.04541411f, -0.04494550f, 0.01315528f, -0.01266930f, 
    0.03039841f, 0.02577275f, 0.03088476f, -0.02586748f, -0.04058243f, -0.02229934f, -0.02606539f, 0.02574252f, 
    -0.04285630f, 0.02297426f, -0.03177409f, -0.02181124f, -0.02149503f, -0.02326680f, -0.01796446f, -0.01807882f, 
    0.02733129f, 0.01468211f, 0.02038348f, -0.02322806f, 0.02146236f, 0.01316538f, 0.01770421f, -0.00893457f, 
    -0.02340947f, -0.00678730f, 0.00308042f, -0.00267980f, -0.03365462f, -0.00707390f, -0.04209740f, 0.01270259f, 
    -0.02550572f, -0.01934977f, 0.01127199f, -0.00412493f, 0.01100572f, -0.02390915f, -0.03783003f, -0.02890080f, 
    -0.02102835f, 0.02409493f, 0.01478013f, -0.03230227f, -0.00987143f, -0.01563075f, -0.03292392f, 0.03320241f, 
    0.02352424f, -0.03729244f, 0.01675121f, 0.03204874f, 0.00788729f, -0.01875183f, -0.00280760f, -0.02819649f, 
    -0.00335595f, -0.00354005f, 0.00852257f, -0.00497862f, 0.00253683f, 0.01160494f, 0.01061683f, -0.03439063f, 
    0.02604606f, 0.01638447f, -0.03800881f, -0.03897830f, -0.04164349f, 0.00058315f, -0.03095491f, -0.03816988f, 
    -0.00415553f, 0.01160827f, -0.02380357f, 0.03302031f, -0.01660180f, -0.00487032f, 0.00275091f, -0.01520836f, 
    -0.02405049f, 0.02851032f, -0.02178660f, -0.01560564f, -0.02193933f, -0.00801944f, -0.03138509f, 0.00394205f, 
    0.01172005f, -0.00239039f, -0.03241291f, 0.02609563f, 0.01496537f, 0.02573205f, 0.01425193f, 0.00845501f, 
    0.03001926f, -0.04489144f, -0.02032136f, -0.01927367f, -0.01557244f, -0.04515791f, -0.02523217f, -0.04296577f, 
    -0.02727457f, 0.02625741f, 0.00202182f, -0.02271579f, -0.03037601f, 0.00794811f, 0.00442970f, 0.01432240f, 
    0.01706196f, 0.01268644f, -0.03862504f, -0.02051535f, 0.01101683f, -0.01356470f, 0.01373574f, 0.00259796f, 
    0.02038668f, -0.03346088f, -0.00113736f, -0.02579991f, -0.02158738f, -0.02852940f, -0.04190492f, -0.00347652f, 
    -0.02852781f, -0.03654341f, 0.01062970f, -0.00548712f, -0.00738159f, -0.01962315f, 0.03101467f, -0.04187677f, 
    -0.01203994f, -0.03593666f, 0.02346460f, 0.00700559f, 0.00313937f, 0.03115447f, 0.00644355f, 0.01333195f, 
    0.03110418f, 0.03171130f, -0.01667278f, 0.00817382f, -0.04209413f, 0.02134776f, -0.02484204f, -0.00688342f, 
    0.00364890f, 0.01492770f, 0.02271339f, -0.00305139f, 0.02942299f, 0.00082080f, 0.00546875f, 0.00042824f, 
    -0.00622285f, 0.01730503f, -0.01420137f, -0.04379998f, -0.01583631f, 0.00700020f, -0.04259403f, 0.01626526f, 
    -0.02506159f, 0.01110800f, -0.03131988f, 0.03146367f, 0.02200220f, 0.02532306f, 0.00777004f, 0.00242351f, 
    -0.01766247f, 0.02706584f, 0.02907505f, -0.03139996f, -0.03412027f, 0.02813927f, 0.00368661f, -0.00688492f, 
    -0.04300149f, 0.00051847f, -0.04049652f, 0.01960709f, -0.01007262f, -0.04086934f, 0.03575427f, 0.01881299f, 
    -0.00601643f, 0.01148904f, 0.00773060f, 0.02280304f, 0.00950017f, -0.04490064f, 0.00408746f, -0.01793130f, 
    0.00742279f, -0.03602969f, 0.02792990f, -0.03972147f, -0.01182687f, 0.01419671f, 0.01232484f, -0.01851195f, 
    0.02767145f, -0.01711004f, 0.01701021f, -0.03845632f, 0.03206093f, -0.03959026f, -0.00575896f, -0.04150896f, 
    -0.01536736f, -0.00396500f, -0.00838333f, 0.00056098f, 0.01730491f, -0.03262237f, -0.02204834f, -0.02327646f, 
    -0.04377802f, -0.01561332f, -0.00572964f, 0.01195220f, -0.00836538f, 0.02249996f, 0.00298564f, 0.01833164f, 
    0.00995089f, -0.01398630f, -0.03716512f, 0.00690073f, 0.02070343f, -0.03024932f, -0.00267209f, -0.03271890f, 
    -0.02764862f, -0.00102213f, -0.00570727f, -0.01281987f, 0.00550072f, -0.00121380f, -0.03535260f, -0.02707087f, 
    -0.00996004f, 0.00675090f, -0.02031839f, -0.03726678f, -0.03186241f, -0.01639649f, -0.00470732f, 0.01117624f, 
    0.03764457f, 0.02935692f, 0.01343665f, -0.01085426f, -0.03080135f, -0.03072646f, 0.01746349f, 0.04513372f, 
    0.01325921f, 0.00043991f, 0.00570051f, -0.03961626f, 0.01347975f, -0.02483611f, 0.02977206f, -0.04518956f, 
    -0.03508368f, -0.03165067f, -0.04092199f, 0.00930499f, -0.03980209f, -0.01593182f, -0.02080294f, -0.03368017f, 
    0.02294034f, -0.00953337f, 0.02796876f, 0.01431936f, -0.01012973f, 0.00744253f, 0.02557756f, 0.01310614f, 
    0.02580590f, -0.03536231f, -0.03752312f, 0.03260628f, -0.00777053f, -0.03598995f, -0.03210452f, -0.02447027f, 
    0.02469595f, -0.03049944f, -0.03081205f, -0.00509860f, 0.03245123f, -0.01910763f, -0.04266133f, -0.00788737f, 
    -0.01350723f, 0.03280532f, -0.03819324f, -0.02168877f, -0.03885429f, -0.00365400f, -0.01521943f, -0.02700225f, 
    0.00496971f, 0.02844770f, 0.02564599f, -0.01616150f, -0.03963488f, -0.03196776f, 0.01864385f, -0.03507488f, 
    0.02424122f, 0.00446286f, -0.03389513f, -0.02446805f, -0.00505123f, -0.03015326f, -0.00389521f, -0.00061771f, 
    0.00885023f, -0.04148555f, -0.03645377f, -0.03801051f, -0.01678187f, -0.02792586f, 0.02775328f, -0.00609807f, 
    -0.03852225f, -0.02673325f, -0.04425845f, -0.02482332f, 0.03303443f, 0.01383947f, -0.00532929f, -0.00209422f, 
    -0.03484413f, 0.00411181f, -0.00931808f, -0.00060562f, 0.02872107f, 0.02200098f, -0.03503918f, -0.02208650f, 
    -0.00003348f, 0.02299023f, -0.00883673f, 0.01856112f, -0.01886458f, 0.01755062f, -0.03040256f, -0.04052837f, 
    -0.02515061f, -0.03459281f, 0.00579283f, 0.01736859f, 0.01565656f, -0.04404251f, 0.02397864f, -0.00710743f, 
    0.02468764f, 0.01692508f, 0.03327396f, -0.01415350f, -0.03453010f, 0.03334165f, -0.01520751f, -0.02582096f, 
    0.01083970f, -0.01600730f, -0.03329225f, -0.01345657f, -0.03927377f, 0.02574664f, -0.02862138f, -0.03624923f, 
    -0.00570863f, -0.02756554f, -0.01134128f, -0.03435971f, 0.01102616f, 0.01512137f, -0.02561901f, -0.02744686f, 
    -0.01017814f, 0.04007711f, -0.02012226f, 0.01300326f, 0.00219426f, -0.03337034f, -0.02661511f, -0.00890108f, 
    0.00938072f, -0.04302271f, -0.01009998f, -0.00735308f, 0.00066594f, 0.01394891f, -0.01900844f, -0.02353850f, 
    -0.04521868f, -0.01494098f, -0.03923051f, 0.00239334f, 0.00548329f, 0.02521759f, -0.03885016f, 0.01615073f, 
    0.00755715f, -0.03492733f, -0.00714053f, -0.02240941f, 0.01834718f, 0.01302573f, 0.02699418f, 0.03147453f, 
    0.02364292f, -0.00612679f, -0.02913491f, -0.02153948f, 0.03193673f, -0.02714541f, 0.00582152f, 0.01271655f, 
    0.00843592f, -0.02617400f, -0.03696483f, 0.01495452f, -0.04388098f, 0.03148551f, 0.00333216f, -0.00402698f, 
    0.00542723f, 0.01860099f, 0.01597097f, 0.03151871f, 0.03161701f, -0.00432459f, -0.00390390f, -0.01649199f, 
    0.01774240f, -0.00833003f, -0.01713205f, 0.03157122f, -0.00953739f, -0.03914705f, -0.03742381f, -0.01445869f, 
    -0.04533320f, 0.02829633f, 0.02791381f, -0.01526123f, -0.02828101f, -0.04014097f, -0.01402608f, 0.02533704f, 
    -0.00013437f, 0.01058885f, 0.00957621f, -0.00359266f, 0.00748932f, 0.00783452f, -0.02647633f, -0.01541991f, 
    0.01217851f, 0.00525691f, 0.00385049f, 0.01958798f, -0.01700311f, -0.02760293f, 0.00324365f, -0.01985548f, 
    0.01151968f, 0.02480396f, -0.00283451f, 0.01628042f, 0.00954709f, -0.02510375f, 0.00180559f, -0.02558046f, 
    0.01059832f, -0.04424147f, 0.02690360f, 0.02040557f, -0.01632522f, -0.03968243f, 0.01067520f, -0.04004019f, 
    -0.02537267f, -0.01712189f, -0.04306328f, 0.02382999f, -0.02584121f, -0.04446375f, -0.02333679f, -0.01960368f, 
    0.00486489f, 0.00190033f, 0.01389632f, 0.02951190f, 0.02666022f, 0.01525361f, -0.04293209f, 0.02059639f, 
    -0.00365638f, -0.03847599f, 0.03106336f, 0.02327186f, -0.02124703f, 0.00271079f, -0.01045782f, -0.00142420f, 
    -0.02119308f, 0.00453791f, -0.01385644f, 0.03438618f, 0.02302471f, -0.04526426f, 0.02181007f, 0.01454035f, 
    -0.01145732f, 0.00349034f, 0.02222161f, -0.02086024f, 0.02607655f, 0.03978551f, 0.00327767f, -0.02473378f, 
    0.02758422f, -0.02769818f, 0.03162644f, -0.04348679f, -0.04184071f, -0.00973786f, -0.04417441f, 0.02844362f, 
    0.00200819f, -0.01002764f, -0.03790814f, -0.00184518f, 0.01815009f, 0.00813388f, -0.03387836f, -0.00798107f, 
    0.01314487f, 0.00544654f, -0.00046435f, -0.02378784f, 0.02050026f, -0.00482490f, 0.00457948f, -0.04478796f, 
    0.03329677f, -0.00136321f, -0.02631691f, -0.03794443f, -0.02505292f, -0.02678905f, -0.01940982f, -0.03190089f, 
    -0.00016714f, -0.03458526f, 0.02668299f, 0.00081990f, 0.00802984f, -0.00653451f, -0.03028211f, -0.04250772f, 
    0.02870962f, -0.02519604f, 0.02776534f, -0.03635141f, 0.00071383f, 0.01591333f, 0.02826659f, 0.03311574f, 
    0.02280940f, 0.00382282f, 0.02204066f, 0.01120739f, 0.03259329f, -0.04171336f, 0.01124785f, -0.01224435f, 
    -0.02361866f, -0.00919023f, 0.02339674f, -0.02306913f, -0.03122001f, -0.03204213f, 0.03669295f, 0.00944607f, 
    0.03070101f, 0.00522737f, 0.00317620f, -0.03435191f, -0.00545964f, -0.01033294f, 0.01955291f, -0.03008293f, 
    0.01445389f, -0.03791618f, -0.02419036f, -0.00735767f, -0.01306417f, 0.01984904f, -0.03508403f, -0.02362211f, 
    -0.01980533f, -0.02752545f, 0.00657379f, 0.03096903f, -0.03357317f, -0.02236492f, -0.03566539f, -0.02406177f, 
    0.00277537f, 0.00703080f, -0.03118530f, -0.01846392f, 0.00720838f, -0.02036679f, -0.02566795f, 0.01160594f, 
    -0.00118385f, -0.01121712f, 0.00663806f, -0.04375227f, -0.00163307f, -0.01368401f, 0.02783347f, -0.01057611f, 
    0.03179982f, -0.02135873f, 0.02035205f, -0.01140302f, 0.01186625f, 0.00289007f, -0.04004961f, 0.02360559f, 
    0.01561372f, -0.01218951f, -0.04359237f, -0.03604243f, -0.01233991f, 0.01592425f, -0.04243627f, 0.00549670f, 
    -0.01004755f, -0.02349506f, -0.00545708f, -0.02527106f, -0.01659119f, 0.02041130f, -0.02670125f, -0.02953573f, 
    -0.01482978f, -0.02598325f, -0.01184674f, 0.02939020f, -0.01548698f, -0.00772998f, -0.04223893f, -0.00544916f, 
    -0.02271479f, 0.02996012f, -0.04090142f, 0.00337008f, -0.04005640f, 0.01118649f, -0.01704839f, 0.00085409f, 
    0.01834905f, 0.02705399f, -0.02422109f, -0.03527416f, -0.02548811f, -0.04474655f, -0.04150202f, -0.02322988f, 
    -0.03278424f, 0.02259116f, 0.02006050f, -0.00233426f, 0.00822025f, -0.04128981f, -0.00771064f, 0.00615845f, 
    -0.02657376f, 0.02873084f, -0.02861465f, 0.02311997f, 0.01852897f, 0.03848435f, 0.04778112f, -0.00224450f, 
    0.02124801f, -0.01482932f, 0.03343430f, -0.02427057f, 0.04021214f, -0.02409470f, -0.04392391f, -0.01959391f, 
    -0.01603713f, 0.01809361f, -0.03908882f, 0.00444504f, -0.00629546f, -0.03949923f, 0.00751401f, -0.02906369f, 
    -0.01695834f, 0.01096933f, 0.00776694f, -0.04079542f, 0.00586341f, 0.01425329f, -0.01177844f, -0.03366845f, 
    0.00837834f, 0.01498821f, 0.01094847f, 0.01355782f, -0.01360140f, 0.03307318f, 0.02203508f, 0.01871045f, 
    -0.02015531f, -0.01665175f, -0.04033452f, -0.00469274f, 0.03144510f, 0.00334041f, -0.03130687f, 0.02960074f, 
    -0.04041075f, -0.03514818f, -0.02950598f, -0.01722477f, -0.03957364f, -0.01953322f, 0.00411440f, 0.02211206f, 
    -0.00567428f, 0.02235248f, -0.00436615f, 0.01693315f, -0.02252427f, 0.02811455f, -0.02060696f, 0.00065169f, 
    0.01795129f, 0.02733304f, -0.02444044f, -0.02289524f, 0.00166154f, -0.02218111f, -0.02743013f, 0.00450018f, 
    0.02085375f, -0.00689765f, 0.01249653f, 0.01604945f, -0.01444745f, -0.01568589f, 0.00744023f, 0.00335604f, 
    -0.01902208f, 0.03400647f, -0.00476993f, -0.00779571f, 0.04347805f, 0.00814284f, -0.00643051f, 0.00395373f, 
    -0.02142627f, 0.00026125f, -0.01082712f, 0.03300515f, -0.02627153f, -0.02524992f, 0.02346890f, -0.03569924f, 
    0.00180621f, -0.03401016f, -0.02780179f, -0.02067623f, -0.00624789f, -0.01278066f, -0.01170737f, -0.02595656f, 
    -0.00853665f, 0.00508784f, 0.01503015f, 0.02401251f, -0.03487270f, -0.03352745f, 0.00492202f, 0.00591354f, 
    -0.01127592f, 0.03353576f, -0.01946071f, -0.02280563f, -0.02933065f, -0.00620407f, 0.03066733f, 0.01280259f, 
    0.00315774f, -0.02015895f, 0.00821066f, -0.01149377f, 0.03025465f, -0.00655620f, 0.02516088f, -0.03355689f, 
    0.02615416f, -0.02347508f, 0.00868812f, -0.01599516f, -0.03037144f, 0.00433520f, -0.02839093f, 0.00482618f, 
    -0.01275930f, -0.00797592f, 0.00862780f, 0.03535168f, 0.01363167f, -0.00265271f, 0.03448414f, 0.00977254f, 
    0.01873255f, 0.02528323f, -0.03907580f, 0.01984191f, 0.02011496f, 0.01260886f, -0.03981424f, -0.01203807f, 
    0.00244501f, 0.00772376f, 0.00834414f, 0.00815068f, -0.01602057f, -0.04077705f, 0.00903898f, -0.02123435f, 
    0.01418934f, -0.01087650f, 0.00758663f, -0.03726237f, -0.00142603f, -0.02146444f, 0.02192894f, -0.01718074f, 
    0.01586351f, 0.00537831f, -0.02981293f, 0.03073319f, -0.02159174f, 0.02239551f, 0.03668068f, -0.03500343f, 
    -0.00352386f, 0.01799891f, -0.01697369f, -0.02482827f, 0.01273527f, -0.00497875f, -0.02297117f, -0.03162661f, 
    -0.02020648f, 0.03351841f, -0.01777018f, -0.02355837f, -0.04365814f, -0.01934851f, -0.00136935f, 0.00008236f, 
    -0.00450839f, -0.00022999f, -0.00079873f, -0.00228860f, 0.02427459f, -0.02044123f, 0.02217297f, 0.02293414f, 
    0.03597374f, -0.02652836f, -0.04435804f, 0.02673807f, 0.02169144f, -0.03632309f, 0.00698026f, -0.03820968f, 
    0.00696259f, 0.01596614f, 0.02532471f, -0.03349117f, -0.02524436f, 0.00642982f, -0.03967058f, -0.01291733f, 
    0.01934408f, -0.04391080f, -0.02982891f, -0.00790889f, -0.04628175f, -0.01741995f, 0.00949058f, -0.03478786f, 
    0.01983440f, -0.00351383f, 0.01563526f, 0.00441133f, -0.00251399f, -0.00488740f, -0.00590168f, -0.00181862f, 
    -0.01478711f, 0.03229996f, 0.02614897f, -0.03386055f, 0.01104065f, 0.02286842f, 0.01030014f, 0.01670211f, 
    0.03224026f, -0.00553052f, -0.01709818f, -0.01583411f, -0.01985548f, -0.02191301f, -0.01594933f, -0.02425380f, 
    -0.03398545f, 0.01753955f, -0.03144372f, 0.00613819f, 0.00792694f, 0.00275525f, -0.00541515f, 0.00676300f, 
    -0.03478637f, 0.03068973f, -0.01776803f, -0.02274609f, 0.00279303f, -0.01867845f, 0.00585522f, 0.01533405f, 
    -0.01996457f, -0.01062856f, -0.02374945f, -0.01302893f, -0.00752819f, 0.00915952f, -0.03386965f, -0.01259966f, 
    -0.01107797f, -0.00819904f, 0.03175423f, -0.04273584f, -0.00296318f, 0.00070774f, -0.03805589f, -0.02250832f, 
    0.00209566f, -0.04426160f, 0.01154165f, -0.00714862f, -0.01525931f, 0.00720483f, 0.00667951f, -0.02384964f, 
    0.00499605f, 0.01026042f, 0.00637928f, -0.03272795f, 0.02030103f, 0.03420304f, -0.02799155f, -0.00033663f, 
    -0.02049578f, 0.01755505f, -0.01856611f, -0.01002062f, 0.03089450f, 0.02105862f, -0.03297646f, -0.02541955f, 
    -0.04150767f, -0.03817115f, -0.02089468f, -0.00826497f, 0.02394489f, -0.01626253f, 0.01954964f, -0.03655286f, 
    0.03373857f, -0.00218415f, 0.02531896f, 0.01070216f, -0.03880338f, -0.00590820f, 0.01769979f, -0.02302923f, 
    -0.02834292f, 0.02318724f, -0.02660599f, -0.00298925f, 0.03364587f, -0.04310365f, 0.02114873f, -0.00176592f, 
    0.02083248f, -0.03533914f, 0.01016144f, -0.01051353f, 0.01660758f, 0.00727589f, 0.02343737f, 0.00647006f, 
    -0.01257289f, 0.01221722f, 0.02968098f, 0.01237358f, 0.01627119f, -0.00276526f, -0.00904032f, -0.02325673f, 
    -0.02924749f, 0.02802585f, 0.02607555f, -0.02755175f, -0.01497141f, -0.01787721f, 0.02615681f, -0.01156042f, 
    -0.01904606f, -0.02890521f, -0.03904671f, 0.00235448f, 0.02776205f, 0.03571916f, -0.01843107f, 0.01960197f, 
    -0.01309820f, 0.04019959f, 0.00047698f, 0.00791940f, -0.02806631f, -0.02624016f, -0.01451038f, 0.03604729f, 
    -0.04744513f, -0.04164346f, 0.00865759f, -0.02604478f, -0.01177525f, -0.02922963f, 0.01108048f, -0.03205238f, 
    0.02392543f, -0.02196941f, 0.00471458f, 0.00095288f, -0.01124382f, -0.02034785f, 0.01932573f, -0.01126991f, 
    -0.01058568f, -0.00553033f, 0.03143751f, -0.03735719f, -0.00518459f, 0.01807125f, -0.01420993f, -0.04582768f, 
    0.02096533f, -0.01715862f, 0.02688396f, -0.01393839f, -0.00759301f, -0.03992581f, 0.03331038f, 0.00558985f, 
    0.03271416f, 0.02038736f, 0.03400213f, -0.02437719f, -0.00977533f, 0.01197432f, 0.01119226f, 0.00842224f, 
    0.02563458f, 0.03309981f, -0.00041164f, 0.01938213f, 0.02776746f, -0.03977408f, -0.03819899f, 0.00930153f, 
    0.02843023f, 0.01406361f, -0.03202966f, -0.01482575f, 0.03277452f, 0.02272397f, 0.00809607f, -0.02497427f, 
    0.02056448f, 0.02423728f, 0.01850968f, 0.02872484f, 0.02621100f, 0.01938063f, -0.01253531f, 0.00970772f, 
    0.02891092f, -0.03783486f, -0.00301381f, -0.00798636f, 0.01984459f, -0.04580153f, -0.04389046f, -0.03089211f, 
    -0.00774600f, -0.01230252f, 0.03045221f, -0.01373431f, -0.02757632f, 0.00573259f, -0.03310890f, -0.01471051f, 
    0.02518388f, -0.02381213f, 0.02775558f, 0.01247715f, -0.02569810f, -0.03277396f, -0.03635634f, 0.02665128f, 
    -0.00279046f, 0.02802465f, -0.00843316f, -0.04281019f, -0.00208654f, -0.02759939f, 0.00958160f, -0.01452774f, 
    0.03919561f, 0.02771335f, -0.00658525f, -0.02509370f, 0.00470081f, -0.01052965f, 0.01910020f, -0.04063808f, 
    0.01940243f, -0.02174051f, 0.02260114f, 0.00176323f, 0.02396155f, 0.00214737f, -0.00483191f, -0.01654520f, 
    -0.01936478f, 0.00701607f, 0.00981766f, -0.01756939f, 0.00277441f, 0.03247872f, -0.01354871f, -0.01477626f, 
    -0.01401996f, -0.00088599f, -0.02644754f, -0.03338317f, 0.01236538f, 0.02857355f, -0.01152938f, -0.03605194f, 
    0.00877734f, -0.03696833f, 0.02877131f, -0.02198776f, -0.00098390f, 0.03177613f, -0.03291937f, 0.02209128f, 
    0.00726463f, 0.02215115f, 0.03186575f, 0.00568490f, 0.03093496f, 0.02720572f, -0.01469546f, 0.00975158f, 
    0.01873768f, -0.02651921f, -0.02082607f, -0.02902206f, -0.02770612f, -0.04156732f, -0.02176180f, -0.03643388f, 
    -0.01800639f, -0.01224928f, -0.01243501f, 0.02152895f, 0.00014069f, 0.00314273f, 0.02874151f, -0.00671458f, 
    -0.02497021f, -0.03460285f, -0.02403187f, -0.04165913f, 0.02987721f, 0.01238399f, 0.01522965f, -0.04653494f, 
    -0.02701341f, -0.00854504f, -0.01759580f, -0.03382546f, 0.00254517f, -0.04069329f, 0.02931174f, -0.02046708f, 
    0.02046855f, -0.04568249f, 0.01955690f, 0.02274382f, -0.03158536f, -0.02989655f, -0.03477701f, -0.03888046f, 
    0.02664945f, 0.01317999f, 0.02971370f, -0.01489699f, 0.01529109f, -0.00597020f, 0.01118018f, -0.02222450f, 
    -0.01602979f, -0.01227979f, 0.02010138f, -0.04096391f, 0.03124680f, 0.00935358f, -0.01433238f, 0.02859774f, 
    0.03017695f, 0.00262642f, 0.01956605f, -0.00681518f, 0.00599980f, 0.00728354f, 0.00093799f, -0.00110999f, 
    -0.04512630f, 0.01039772f, -0.00114807f, -0.04508806f, 0.00191117f, 0.02298636f, -0.01428783f, -0.00696376f, 
    0.00991347f, -0.01526015f, -0.02091933f, -0.00406998f, -0.03572493f, 0.00775391f, -0.04623547f, 0.02266216f, 
    -0.01475414f, 0.02129914f, 0.00481002f, -0.03104997f, -0.02851447f, -0.03057221f, 0.02733231f, -0.01916266f, 
    -0.03800429f, -0.02299440f, 0.02251579f, 0.01008604f, -0.03362292f, 0.01968063f, -0.00581655f, 0.02104201f, 
    -0.01684483f, -0.02879759f, -0.04701428f, -0.01807882f, -0.00636625f, 0.00474346f, -0.03369609f, 0.01979327f, 
    0.00876029f, -0.00613998f, 0.01470419f, 0.00942320f, -0.02902172f, 0.00692814f, -0.03519757f, 0.00855237f, 
    0.01034132f, -0.02598632f, 0.00327870f, 0.02719394f, 0.01546884f, -0.00235464f, -0.00203069f, 0.00847082f, 
    0.02465409f, 0.03087486f, -0.02031314f, 0.00488253f, -0.03955422f, -0.03074174f, 0.01001858f, -0.01045281f, 
    0.00519746f, -0.00465885f, -0.02664610f, -0.00840933f, -0.01761138f, 0.01355175f, 0.01023728f, -0.04394580f, 
    0.02861344f, -0.02189953f, 0.01705846f, 0.02367067f, -0.04602701f, -0.01397363f, -0.03015634f, -0.00403892f, 
    -0.02442317f, 0.00760668f, 0.01515287f, -0.02864078f, -0.02057772f, 0.00440253f, -0.02446930f, 0.01807903f, 
    -0.04518132f, -0.00070574f, -0.00318507f, -0.01441933f, 0.00285731f, 0.01903575f, -0.01362320f, -0.04021676f, 
    0.00278149f, -0.01244126f, -0.00917095f, 0.02404118f, -0.02648882f, 0.02560380f, -0.04161243f, -0.01069318f, 
    0.02866371f, 0.01842429f, 0.01813114f, 0.02121281f, -0.00828950f, -0.01310447f, 0.00136428f, -0.04726236f, 
    0.01365422f, 0.00694401f, -0.02642546f, 0.00781016f, 0.02465674f, -0.04387358f, -0.00953280f, -0.00391792f, 
    0.02922483f, -0.01769910f, -0.01023251f, -0.00931419f, 0.00684220f, 0.00230498f, -0.03222203f, -0.02919460f, 
    -0.00435108f, -0.03821973f, 0.01792983f, 0.01758290f, 0.02012456f, 0.02592686f, -0.02808907f, -0.02129569f, 
    0.02748129f, -0.04776769f, -0.02284628f, -0.03217893f, -0.01963742f, -0.02073817f, -0.02368002f, 0.00114144f, 
    -0.02513082f, -0.01651711f, -0.04621263f, -0.01597762f, -0.02977500f, 0.00422871f, -0.02316049f, -0.01915771f, 
    -0.04307467f, 0.01811955f, 0.00834057f, 0.01750896f, -0.02973687f, -0.02939898f, -0.03325162f, 0.02782484f, 
    -0.03214426f, -0.02829341f, 0.02804210f, -0.01281909f, -0.00548452f, 0.02009082f, 0.00422719f, -0.02819959f, 
    -0.03078365f, -0.00490510f, 0.02386811f, -0.00715082f, -0.00206369f, -0.03956191f, 0.02957636f, 0.01586083f, 
    0.00384143f, -0.01888411f, 0.01723345f, -0.02951021f, -0.03265429f, -0.03418199f, 0.00599329f, -0.04243229f, 
    -0.02583730f, 0.01067792f, 0.01109844f, -0.01239494f, -0.02012219f, 0.01835826f, -0.00130348f, -0.03667249f, 
    -0.04126320f, 0.00587572f, 0.01745671f, 0.00686785f, 0.01775166f, -0.02617215f, -0.02734569f, 0.02483774f, 
    -0.01579431f, 0.00682628f, 0.01484786f, 0.00151274f, -0.03739125f, -0.03654104f, -0.04562508f, 0.01169602f, 
    0.01811208f, 0.01502524f, -0.01799461f, -0.03648943f, -0.03159171f, 0.02731319f, -0.00847364f, -0.00893456f, 
    0.00188558f, 0.03181427f, 0.01810713f, -0.04046504f, 0.02437008f, 0.01007860f, -0.01354512f, -0.02000473f, 
    0.02487629f, 0.01673733f, 0.02939313f, -0.02032403f, -0.00741980f, 0.01670409f, -0.00090176f, 0.01760292f, 
    0.02897534f, 0.02843114f, -0.03535637f, 0.00514665f, -0.02202385f, 0.01832702f, -0.02080126f, 0.01479771f, 
    -0.00384231f, -0.00629454f, -0.03459302f, 0.02025243f, -0.01230083f, 0.00063379f, 0.00873227f, -0.03224870f, 
    0.00421716f, -0.00315290f, -0.00169398f, -0.00575573f, -0.02402478f, 0.02011404f, -0.00860809f, -0.01921152f, 
    -0.01562318f, 0.00266076f, 0.01877747f, 0.04397782f, 0.00061312f, -0.02026091f, 0.03599283f, -0.02426475f, 
    -0.02177974f, -0.02658004f, 0.00749431f, 0.02464650f, -0.00869274f, -0.01207325f, -0.01240825f, 0.00163873f, 
    0.02905987f, -0.04475354f, -0.01978968f, 0.00502602f, -0.00078389f, -0.04004818f, -0.03108173f, -0.02042056f, 
    -0.00394752f, 0.00389100f, -0.00637565f, -0.00163815f, -0.00148208f, -0.03118050f, -0.03518445f, 0.03092598f, 
    -0.00028588f, 0.01509392f, 0.01245892f, -0.04717479f, -0.01601288f, 0.03062306f, -0.02995734f, -0.02832551f, 
    -0.03991777f, -0.03137050f, -0.03031461f, 0.00008525f, -0.02455601f, 0.00531189f, 0.02698845f, 0.00413868f, 
    -0.03695116f, 0.02216586f, -0.01924244f, 0.01535617f, 0.00511549f, 0.03284039f, 0.03004477f, -0.01066312f, 
    -0.03763293f, -0.04608472f, -0.03937675f, -0.02903854f, -0.02622554f, 0.01288483f, -0.02398043f, -0.04611223f, 
    -0.03564166f, 0.01648687f, -0.04257125f, -0.03625303f, 0.00283658f, 0.01152362f, -0.00263471f, -0.04257544f, 
    0.00389628f, -0.00909658f, 0.00247938f, 0.02000883f, -0.02985906f, -0.03243427f, -0.03425406f, 0.00719975f, 
    -0.02698657f, -0.01358990f, -0.02352109f, 0.02632791f, 0.00863397f, -0.01528805f, -0.01338197f, -0.03120771f, 
    -0.00077969f, -0.02734303f, 0.02834185f, 0.01868192f, 0.01995226f, -0.03805431f, -0.00820807f, 0.00789646f, 
    0.02606896f, 0.02684592f, 0.02189716f, 0.01086549f, -0.00993968f, -0.02253802f, 0.01465555f, 0.02710827f, 
    -0.04502760f, 0.00821764f, -0.03543817f, -0.01909755f, -0.02722255f, -0.03582414f, 0.00914461f, 0.00048155f, 
    0.01550387f, -0.02599033f, 0.00271890f, -0.03299860f, 0.01307073f, -0.04274034f, -0.02325215f, -0.04451141f, 
    -0.03896416f, 0.02683567f, 0.01521957f, -0.04272502f, -0.04299687f, -0.03530600f, -0.01374084f, -0.02714053f, 
    -0.01827590f, 0.02382792f, 0.02858346f, -0.01487504f, -0.00438078f, 0.02644648f, -0.04742650f, 0.02561832f, 
    -0.02665778f, -0.02025309f, -0.00685805f, -0.00413071f, -0.02844297f, 0.00121613f, 0.00718980f, -0.02371031f, 
    0.00045982f, -0.03269953f, -0.02029078f, -0.00670636f, -0.01333234f, 0.02380653f, -0.03371693f, -0.00001815f, 
    0.00788986f, -0.03380989f, 0.01217011f, -0.03405068f, -0.01903277f, -0.03987846f, 0.01283009f, -0.02080481f, 
    -0.04065248f, 0.02887172f, -0.02822340f, 0.00062893f, -0.03524872f, -0.01986793f, -0.03665482f, -0.03895346f, 
    0.01586767f, -0.02401694f, -0.01168219f, 0.00431631f, 0.01716012f, -0.03458088f, -0.00947363f, -0.03577974f, 
    0.01244629f, -0.03734901f, -0.02115218f, -0.00068846f, 0.00777018f, 0.03072019f, 0.01222740f, -0.03549110f, 
    -0.00621193f, -0.00578462f, -0.03440266f, -0.02960814f, -0.02948705f, -0.01491192f, -0.03792612f, 0.01549436f, 
    -0.04341266f, 0.01573940f, -0.02521882f, -0.01121266f, -0.02930307f, -0.00861534f, 0.02356945f, 0.00362738f, 
    -0.02919320f, -0.00844494f, -0.01497177f, -0.02073034f, -0.03688955f, 0.00764695f, 0.00329149f, -0.00401798f, 
    0.01018262f, -0.03438058f, -0.03026086f, 0.00143202f, -0.03818637f, -0.02151177f, -0.02219857f, -0.04523301f, 
    0.02284803f, -0.01928192f, -0.02242139f, 0.00014519f, -0.01339010f, 0.02050531f, 0.01225713f, -0.01251263f, 
    -0.00912615f, -0.01820015f, -0.01074123f, -0.03144674f, -0.04388170f, -0.03513449f, -0.03221109f, -0.02959953f, 
    0.00506348f, -0.04163769f, 0.01739267f, -0.01223949f, 0.01724501f, 0.03107012f, -0.04326631f, 0.00070622f, 
    0.02372330f, 0.00732561f, -0.00177310f, -0.01794269f, 0.01932886f, -0.00976980f, 0.03044225f, -0.02937416f, 
    -0.04596017f, -0.02936416f, -0.04450199f, -0.01829241f, 0.02119258f, 0.01099596f, -0.04679351f, -0.00980545f, 
    -0.02543187f, 0.02450907f, 0.00510069f, -0.01802107f, -0.03761503f, 0.01694534f, 0.03116785f, -0.01016711f, 
    0.01880242f, 0.02522728f, -0.03660105f, -0.00427534f, -0.04455777f, -0.00021124f, 0.02576298f, 0.02538934f, 
    -0.00427231f, 0.01439001f, -0.02237866f, 0.00840386f, -0.02279108f, -0.01968056f, 0.02780979f, 0.00907416f, 
    -0.03420087f, 0.01469162f, -0.02626811f, -0.04482403f, 0.02378844f, -0.00216642f, 0.02289434f, -0.01737969f, 
    0.02397459f, 0.00164045f, -0.03589446f, -0.02599089f, 0.02989654f, -0.02270335f, -0.00865132f, -0.01032882f, 
    0.02736078f, 0.00701047f, -0.00716399f, -0.02996453f, -0.03811499f, -0.01720043f, 0.02937078f, -0.00599186f, 
    0.00476299f, -0.02884260f, 0.00415421f, -0.00116578f, -0.00671375f, -0.01572865f, -0.00389730f, -0.03074531f, 
    0.45488778f, -0.00340183f, -0.07422172f, 0.17497122f, -0.30255017f, 0.10751033f, 0.13241404f, 0.05302993f, 
    0.00148979f, 0.08031084f, 0.03797221f, 0.08172527f, 0.13964605f, -0.00374257f, -0.05680814f, 0.08064394f, 
    0.10647666f, 0.03618129f, -0.00836633f, 0.07292432f, 0.11474153f, -0.28699002f, 0.07996260f, -0.01617454f, 
    0.05268571f, -0.05533040f, 0.09222449f, 0.09851842f, 0.00342168f, 0.09676006f, -0.10909212f, -0.06110210f, 
    0.03630827f, 0.05788552f, 0.06069471f, 0.06049828f, -0.03569881f, -0.06697160f, 0.06889590f, 0.03777002f, 
    0.52986693f, -0.28153226f, -0.05152486f, 0.05376452f, -0.02065187f, -0.04167600f, 0.12877338f, 0.06425242f, 
    -0.02297221f, -0.09213545f, -0.01851504f, -0.00330003f, 0.02106722f, -0.01485576f, -0.01806033f, -0.05798115f, 
    0.01799635f, -0.03529458f, -0.05392672f, 0.05962044f, -0.28868976f, -0.15359357f, 0.03662935f, -0.08494519f, 
    -0.00396838f, -0.05175655f, -0.04586716f, 0.01816176f, -0.07219260f, -0.01444625f, 0.11547586f, 0.03348773f, 
    0.06677857f, 0.01487434f, 0.11363330f, 0.02936584f, 0.10164040f, -0.02514783f, 0.00401590f, -0.01457298f, 
    0.17646594f, 0.09478077f, 0.12628075f, -0.00781678f, 0.25293723f, -0.01880084f, -0.00650092f, 0.06063277f, 
    -0.06727690f, 0.07966940f, -0.04213475f, 0.04658899f, 0.03070343f, -0.03450998f, -0.05080613f, 0.05922432f, 
    0.06276131f, -0.05294733f, -0.08129470f, -0.01097094f, -0.02937032f, 0.10485318f, 0.04256741f, 0.35274085f, 
    -0.23013912f, 0.06080139f, -0.11141673f, -0.00367376f, 0.07160187f, -0.09525442f, 0.07937707f, 0.05224042f, 
    -0.03323120f, 0.01385608f, -0.01351479f, -0.01746308f, -0.03791259f, 0.01901576f, -0.02702904f, 0.03692001f, 
    -0.25954646f, 0.04390947f, 0.18600987f, -0.05314375f, 0.08829146f, -0.05062472f, 0.00236360f, -0.01157059f, 
    0.01863406f, -0.08936614f, 0.04377032f, -0.04275002f, -0.04661973f, -0.03416368f, -0.00477734f, 0.03256987f, 
    -0.02859988f, 0.11087408f, 0.00003592f, -0.00877488f, 0.26135939f, -0.16112356f, 0.31300578f, 0.02832093f, 
    -0.03092660f, 0.06428877f, -0.03388441f, -0.02214231f, 0.08611612f, 0.08006876f, 0.04072236f, 0.02792210f, 
    -0.08418923f, 0.05055532f, -0.09925889f, 0.00729359f, -0.09089313f, -0.00557714f, -0.02788941f, -0.08286134f, 
    0.42771631f, -0.09140337f, -0.18420681f, -0.24796887f, -0.34015882f, 0.06509678f, 0.02367332f, 0.06582027f, 
    -0.07590151f, 0.08696113f, 0.02941279f, 0.01732329f, 0.09958050f, 0.08889486f, 0.02994038f, -0.00948122f, 
    0.07003526f, -0.04773173f, 0.05957444f, -0.00476706f, 0.04097228f, 0.33034649f, 0.01858366f, 0.11882874f, 
    -0.30751005f, -0.03749106f, 0.15295407f, 0.07934863f, 0.07636511f, 0.03878606f, -0.07103597f, 0.06231272f, 
    -0.00844819f, 0.04064048f, -0.00075190f, -0.10195619f, 0.07454509f, 0.01938816f, 0.14041516f, 0.07945135f, 
    0.12534800f, -0.26749158f, 0.16817580f, 0.13248363f, -0.17974527f, 0.02569555f, 0.27130067f, 0.04356906f, 
    0.01631618f, 0.10581098f, 0.04113406f, 0.01571530f, 0.04275557f, -0.05163331f, 0.09046784f, -0.05534203f, 
    0.01271276f, -0.06562355f, 0.09239514f, -0.00665765f, 0.38997498f, 0.10851398f, -0.00904290f, -0.36023590f, 
    0.50757539f, -0.07281265f, 0.19876182f, 0.12725645f, 0.11391378f, 0.13972729f, 0.06130458f, 0.00456980f, 
    -0.00950423f, 0.01084488f, 0.10358358f, 0.01699226f, 0.04587635f, 0.09823942f, 0.00201549f, 0.03506553f, 
    0.21099994f, -0.16235000f, 0.10093612f, 0.39730281f, 0.09855650f, -0.04266305f, -0.03396434f, 0.08001735f, 
    0.05195998f, 0.07214464f, -0.07837622f, 0.02730870f, -0.07367764f, -0.01290926f, 0.00899419f, 0.23204800f, 
    -0.09150580f, -0.05093773f, 0.04583935f, 0.02605615f, 0.03661099f, 0.04956860f, -0.27145541f, -0.03282493f, 
    0.18493389f, 0.07850905f, -0.15065549f, -0.06057241f, 0.09430177f, -0.01881882f, -0.00991350f, 0.00954017f, 
    -0.11580644f, -0.04325452f, 0.12832294f, 0.02381432f, 0.06769705f, 0.04201505f, 0.11793585f, -0.01560005f, 
    0.13227268f, -0.20536739f, -0.17550457f, -0.07321122f, -0.44056702f, -0.00725592f, 0.10542242f, -0.08570194f, 
    -0.07710230f, -0.05304309f, -0.00031223f, 0.04421083f, 0.12043062f, -0.00984863f, 0.00060257f, 0.16379941f, 
    0.01960985f, -0.00986393f, -0.02066203f, 0.16535334f, -0.35216817f, -0.09310739f, 0.02491852f, -0.05231230f, 
    0.14187732f, -0.09202745f, -0.01228226f, -0.05166326f, 0.00831979f, 0.09012969f, 0.09730365f, 0.00811890f, 
    -0.10631489f, -0.02262865f, 0.10872421f, -0.02924909f, 0.06611076f, 0.08259124f, -0.03508286f, 0.04959355f, 
    -0.16224150f, -0.05722556f, -0.00991391f, 0.13956957f, -0.06612577f, -0.04308974f, -0.06045366f, -0.08364769f, 
    0.03732536f, -0.06392787f, -0.06865469f, -0.09346595f, 0.09381736f, -0.03523657f, 0.03242028f, -0.07462447f, 
    0.12201892f, -0.05994108f, 0.00231561f, 0.07840005f, 0.43608534f, -0.11270393f, -0.33925799f, -0.19240527f, 
    -0.43244001f, -0.13693944f, -0.08785787f, 0.01312864f, 0.02405409f, 0.17422362f, -0.05949711f, -0.01439101f, 
    -0.00001907f, 0.06091639f, 0.07015678f, -0.03918175f, 0.09957886f, -0.04381338f, 0.06086056f, 0.04657086f, 
    0.05660819f, -0.01023768f, 0.19765551f, 0.25617912f, 0.30012441f, -0.12450530f, -0.01201929f, 0.04909729f, 
    0.05803796f, 0.02207812f, 0.00058707f, -0.01392786f, 0.02673897f, -0.01252673f, 0.00276813f, -0.04349560f, 
    0.02390295f, -0.00265435f, -0.01671850f, 0.01303030f, 0.26999238f, -0.26275378f, 0.10481911f, 0.12333003f, 
    0.15300140f, -0.07623158f, -0.07150515f, 0.03646141f, -0.02818305f, -0.11593631f, 0.00482277f, -0.07171490f, 
    -0.04408475f, 0.04648170f, 0.01675243f, 0.15494011f, -0.00075969f, -0.00645331f, -0.03434445f, -0.09079486f, 
    0.24313337f, 0.05688890f, -0.25632083f, -0.13818738f, -0.47778535f, 0.03959451f, -0.01939339f, 0.07523481f, 
    -0.01938722f, 0.05611823f, -0.03550728f, 0.00358317f, 0.02461744f, 0.07755175f, 0.00698166f, 0.10150011f, 
    -0.03106390f, 0.00455717f, -0.00474929f, 0.05696268f, 0.01070443f, 0.00329014f, -0.44428560f, 0.05923649f, 
    -0.40365040f, 0.04507241f, -0.18976936f, -0.04966381f, 0.17543778f, 0.23412088f, -0.13453123f, 0.00702291f, 
    0.05778775f, -0.01461054f, 0.03030227f, 0.03430109f, 0.11410160f, 0.06096562f, -0.04840636f, 0.17630789f, 
    -0.50257421f, 0.29383168f, 0.15203214f, 0.00375033f, 0.34478843f, 0.09761512f, 0.18644109f, 0.03380154f, 
    0.08767843f, 0.06218678f, -0.01242450f, 0.03145380f, 0.05322530f, -0.04762621f, -0.22145632f, -0.05768486f, 
    0.02722189f, 0.18304642f, -0.04862745f, 0.17174204f, -0.07484665f, -0.02914024f, 0.01415482f, 0.02414933f, 
    -0.12993269f, -0.13063148f, -0.17527856f, 0.04384509f, 0.02932813f, 0.08502505f, -0.06476091f, -0.03794282f, 
    0.05329264f, -0.00355780f, -0.02039672f, 0.03102351f, -0.03573646f, 0.01426994f, -0.00724672f, 0.04418990f, 
    0.01459368f, -0.24903090f, 0.16650793f, -0.01084544f, -0.09280141f, -0.08940856f, -0.04280302f, 0.02133094f, 
    -0.09389786f, 0.25536653f, -0.10460289f, -0.14815214f, 0.04214520f, 0.02433991f, -0.04874482f, 0.07074511f, 
    0.13870138f, 0.02677222f, -0.09578617f, 0.15011883f, -0.16872889f, -0.66215724f, 0.03237524f, 0.42459613f, 
    0.13388011f, -0.12426120f, -0.00111445f, -0.03579460f, -0.01513808f, 0.04538985f, 0.00283067f, -0.00941063f, 
    0.07038618f, -0.01555858f, 0.05347775f, 0.04906501f, -0.24153407f, 0.00033338f, -0.11035691f, 0.01054017f, 
    -0.38170364f, 0.12609442f, 0.05489289f, -0.15070641f, -0.34393501f, 0.12530558f, 0.07362927f, -0.09904926f, 
    -0.06629444f, -0.00264378f, -0.04056929f, 0.05578774f, -0.01787783f, -0.01258015f, 0.13402398f, 0.01338024f, 
    0.08195518f, -0.01089511f, -0.02878329f, 0.09710161f, 0.08175866f, -0.35069346f, 0.23264414f, 0.12682188f, 
    0.23717885f, 0.13363583f, 0.08830574f, 0.04962994f, 0.11477515f, -0.00987968f, 0.04463288f, 0.01168153f, 
    -0.00218059f, -0.04993739f, 0.12060760f, 0.10436107f, -0.01510997f, -0.04296377f, -0.01670559f, -0.00155418f, 
    -0.27547783f, 0.21986131f, 0.02111968f, 0.11794019f, -0.11483349f, 0.12840244f, 0.10186324f, 0.09385246f, 
    0.06136926f, 0.08864243f, 0.03726791f, 0.14903273f, 0.02920506f, -0.07194438f, -0.07472245f, 0.03655120f, 
    -0.00051083f, -0.02465787f, 0.15231523f, -0.01090644f, 0.16152635f, -0.22808579f, -0.08829720f, 0.17313644f, 
    0.06561992f, -0.02673490f, -0.00615514f, -0.06435303f, -0.03875148f, 0.00657727f, 0.04149523f, 0.07007118f, 
    -0.04463354f, 0.04199289f, -0.06198749f, 0.13898635f, 0.07377785f, -0.01342868f, 0.00059306f, 0.23966478f, 
    0.19410157f, -0.21194509f, -0.05779728f, 0.13746601f, -0.30588940f, -0.21975325f, -0.17929257f, 0.11264366f, 
    0.03636957f, 0.04063025f, -0.05968026f, -0.00680926f, 0.05423623f, -0.00976415f, 0.00779882f, -0.03542792f, 
    0.12377439f, 0.08348618f, 0.04914664f, 0.15528774f, 0.16066223f, -0.47870812f, 0.32579809f, -0.01077050f, 
    0.47551107f, -0.21506929f, -0.00289367f, -0.14195044f, 0.07048477f, -0.09848214f, 0.11918373f, 0.00406908f, 
    -0.09826200f, 0.08000855f, 0.03652319f, -0.05001087f, -0.04536068f, 0.00645810f, 0.00990291f, -0.00744020f, 
    -0.29715043f, -0.29940394f, 0.06922211f, 0.01427569f, 0.11648101f, -0.13979080f, 0.12442063f, 0.05270747f, 
    -0.00299915f, 0.17266335f, 0.03796604f, 0.04453002f, 0.05232951f, -0.02846876f, 0.16290082f, -0.09550661f, 
    -0.05679557f, -0.02838021f, -0.03724539f, 0.04194173f, 0.13160698f, -0.15424041f, -0.00860387f, -0.22827487f, 
    0.37340376f, 0.07943448f, 0.08026875f, 0.01029037f, -0.04724106f, -0.00873644f, 0.06095104f, -0.00943885f, 
    -0.09087768f, -0.08510379f, -0.07441031f, 0.03947841f, 0.10262643f, 0.24845046f, 0.07280676f, -0.10123931f, 
    0.04660711f, -0.08791824f, 0.15630414f, -0.00586001f, 0.32001036f, 0.06197784f, -0.05934354f, 0.02598593f, 
    0.24068262f, 0.00002876f, -0.06910191f, 0.09811506f, -0.03574134f, -0.01471578f, 0.11869464f, 0.04507017f, 
    -0.07964983f, 0.02997964f, -0.00062456f, 0.11690135f, -0.14124380f, -0.13937193f, -0.00825826f, -0.10473397f, 
    -0.32557169f, -0.18236150f, 0.13317551f, 0.06183562f, 0.07108411f, 0.02840823f, 0.01028557f, -0.00750462f, 
    0.00446572f, 0.07053316f, -0.01939345f, 0.00699269f, -0.07511390f, 0.05323087f, -0.00934224f, -0.07848997f, 
    0.29543850f, -0.01728636f, -0.08043819f, 0.44201365f, 0.08853972f, 0.18720518f, 0.11130431f, 0.18521695f, 
    0.01124963f, -0.05089996f, 0.00125764f, 0.12685588f, -0.01850144f, -0.08314835f, -0.17837609f, 0.06852899f, 
    -0.01990949f, 0.09437253f, -0.03843032f, 0.00071064f, 0.45940104f, 0.27252477f, -0.07249536f, 0.08323319f, 
    0.25964603f, -0.12562737f, 0.09749404f, 0.03060236f, -0.02428890f, -0.00977414f, -0.07660424f, 0.02503174f, 
    -0.00142512f, 0.05488984f, 0.01708221f, 0.15187553f, 0.01297224f, -0.01918878f, 0.10087609f, -0.09134766f, 
    0.21551549f, -0.20224378f, -0.15231168f, 0.22590208f, -0.08857936f, -0.01330685f, 0.01993053f, -0.01269683f, 
    0.06751841f, 0.08908780f, 0.01468630f, 0.03846546f, 0.06233214f, 0.01628502f, 0.04070755f, 0.00282702f, 
    0.00650369f, 0.10083640f, 0.04974296f, 0.02661184f, -0.19294168f, 0.41862801f, -0.15790679f, -0.12153044f, 
    -0.05740177f, 0.10254193f, 0.03199344f, 0.03637776f, -0.01736567f, 0.00059902f, -0.14848970f, 0.03036848f, 
    0.01783995f, 0.01643198f, -0.04360415f, 0.13059951f, -0.02360062f, -0.01881633f, -0.05042848f, -0.07161036f, 
    0.11310980f, 0.17465237f, 0.07321107f, 0.08975355f, 0.12306576f, -0.01480762f, 0.05690778f, -0.04609925f, 
    0.06538294f, -0.07145057f, -0.10655288f, -0.04562779f, 0.02417656f, -0.01597006f, 0.01413562f, -0.01492235f, 
    -0.07075170f, 0.08046111f, 0.04425586f, 0.03950046f, 0.14955308f, 0.29775694f, -0.11565261f, 0.13069697f, 
    0.24917439f, 0.07926949f, 0.00012258f, -0.03098884f, -0.00117565f, -0.03825162f, -0.02711293f, -0.05201411f, 
    0.09358303f, -0.02372475f, 0.08427969f, 0.09860110f, 0.03164072f, 0.04635603f, 0.15452641f, 0.06978009f, 
    -0.06532440f, 0.13529532f, -0.17556913f, 0.08092947f, 0.43918869f, 0.09465674f, -0.09435596f, 0.05025240f, 
    0.03062500f, 0.21405934f, 0.01822605f, 0.05383519f, 0.04793788f, -0.03740718f, 0.05247531f, 0.14320138f, 
    -0.02600468f, 0.11360344f, 0.03265977f, 0.03042838f, 0.00537128f, 0.03052804f, -0.02817902f, 0.22505353f, 
    0.13088945f, 0.11686542f, -0.01193371f, 0.07840577f, 0.06003041f, -0.02980625f, -0.06182486f, 0.00506874f, 
    -0.08315687f, 0.16178337f, -0.09933660f, 0.11899570f, -0.13172345f, 0.16174527f, -0.12798832f, -0.06990197f, 
    -0.40917847f, 0.22751182f, -0.21685039f, -0.11610743f, -0.06511976f, 0.07529449f, 0.00903941f, 0.08698298f, 
    0.05886239f, 0.00016115f, -0.05964978f, -0.04257824f, 0.02237071f, 0.09992861f, 0.04997228f, -0.06847441f, 
    -0.06890739f, -0.14857283f, -0.04473085f, -0.01647822f, 0.22004214f, 0.12478928f, 0.21592543f, 0.35042259f, 
    0.31070766f, 0.09911443f, 0.07863678f, -0.03355814f, 0.10619162f, 0.05139971f, -0.01746714f, -0.00192782f, 
    0.00837297f, -0.01463420f, -0.01373718f, 0.16767275f, -0.12427296f, 0.11421350f, -0.00112996f, -0.01782184f, 
    0.48894870f, -0.36047593f, 0.04861969f, -0.09443775f, 0.19406764f, -0.04744121f, -0.04319752f, 0.02412442f, 
    0.10479790f, -0.07430056f, 0.07587937f, 0.02374867f, 0.02444013f, -0.00483266f, -0.05159593f, -0.08982707f, 
    -0.13381316f, 0.06874671f, -0.10611295f, 0.05356597f, 0.16238397f, 0.16267303f, 0.13170923f, -0.08337057f, 
    -0.20302498f, 0.07619472f, 0.03610084f, -0.03895295f, 0.01712086f, -0.00969740f, -0.07251127f, -0.01498100f, 
    0.11110052f, -0.06693171f, 0.06264400f, -0.03026477f, 0.07186365f, 0.22943333f, 0.05783805f, -0.04702772f, 
    0.40405169f, 0.26674825f, 0.06707538f, 0.05660149f, -0.04963138f, 0.04364410f, 0.06280912f, 0.00378370f, 
    -0.11276156f, 0.04308478f, 0.01046814f, -0.02282958f, 0.10068984f, -0.09647284f, 0.09069762f, 0.04760647f, 
    0.04928122f, -0.01696324f, 0.19277243f, -0.08194003f, 0.19003004f, 0.04208261f, -0.00423090f, 0.06592539f, 
    0.10634250f, 0.00184179f, -0.02816888f, -0.05725200f, -0.07004240f, -0.12810802f, 0.04612373f, 0.02901525f, 
    0.01676260f, -0.06744956f, -0.00187381f, 0.10342553f, -0.10257962f, -0.03512335f, 0.04936745f, 0.05841202f, 
    -0.22193302f, 0.01538329f, -0.12166996f, -0.16962086f, -0.11677549f, 0.07910228f, 0.07722997f, 0.13918430f, 
    0.02902189f, 0.00273811f, 0.00649301f, 0.07567415f, 0.14951757f, 0.03265838f, 0.05671537f, -0.03560126f, 
    0.08296477f, 0.02541852f, -0.07608591f, 0.13383831f, -0.62570816f, 0.29920319f, 0.05599445f, -0.02983443f, 
    -0.16985455f, 0.09767488f, 0.13071296f, 0.10378645f, 0.02160012f, 0.04568583f, -0.25690421f, 0.00828131f, 
    0.07026594f, 0.02397252f, -0.02618073f, 0.11947411f, -0.01460470f, 0.04520372f, -0.03363942f, -0.10023633f, 
    0.25725579f, 0.12708180f, 0.00962161f, 0.13549656f, 0.18942256f, -0.11315528f, -0.05253525f, -0.05170513f, 
    0.02813415f, -0.10424720f, -0.13834672f, -0.01148281f, 0.01165855f, 0.09027240f, 0.01035277f, -0.11080328f, 
    0.01777208f, -0.05831634f, 0.07458014f, -0.06354430f, 0.55510467f, -0.02837007f, 0.13143237f, -0.02293050f, 
    0.26802206f, 0.04060801f, 0.13603474f, -0.08393791f, -0.01262175f, -0.10944768f, 0.03622933f, -0.03378395f, 
    -0.00963206f, -0.06447230f, 0.02808182f, 0.01001796f, 0.04927635f, 0.17772484f, 0.03618325f, 0.14090668f, 
    0.42314202f, -0.02376710f, -0.20428374f, 0.08228865f, -0.06627101f, 0.14263771f, 0.08440284f, 0.05749737f, 
    0.06813951f, 0.04581836f, -0.05618878f, 0.05722404f, 0.13760547f, -0.04302867f, -0.03659138f, 0.05411256f, 
    0.06964990f, 0.08418462f, 0.10424525f, -0.02854009f, -0.24372265f, -0.02431378f, -0.24887323f, -0.05298056f, 
    -0.11506195f, -0.01374341f, 0.11896867f, 0.12946290f, 0.04650091f, -0.07506032f, -0.01618923f, 0.07707469f, 
    -0.03266630f, 0.09576944f, 0.05468204f, 0.04921309f, -0.04566630f, -0.01030676f, -0.12554236f, 0.04523413f, 
    0.04728944f, 0.02381638f, 0.08372924f, 0.08098979f, 0.26007274f, 0.04401873f, 0.09003780f, -0.03282530f, 
    -0.05138410f, -0.06797949f, 0.07651715f, 0.09961198f, -0.08146653f, 0.01554464f, -0.06163547f, 0.13043629f, 
    -0.08602718f, 0.14044170f, 0.04574178f, -0.01490731f, 0.45730317f, 0.11557625f, 0.11391136f, 0.00347230f, 
    0.36857617f, 0.07507646f, 0.04477979f, 0.19573507f, -0.03217841f, 0.04193233f, 0.00878628f, 0.11806694f, 
    -0.03568232f, 0.02362817f, -0.01517567f, -0.00435689f, 0.23209713f, 0.04530282f, 0.02405913f, 0.14415196f, 
    0.16315712f, -0.05540061f, -0.00267753f, -0.13850269f, -0.17384386f, -0.03548407f, -0.05401478f, -0.10312480f, 
    0.02845665f, 0.03225141f, 0.03336917f, 0.07040325f, 0.12332005f, 0.06172621f, -0.04993463f, -0.11009338f, 
    -0.12447483f, 0.07121887f, -0.10180707f, 0.03042264f, -0.08446788f, -0.24625517f, -0.03259166f, -0.08694311f, 
    0.31808344f, 0.06373599f, 0.01164581f, 0.00146399f, -0.02885858f, 0.17118660f, 0.02134736f, 0.09530630f, 
    0.02366797f, 0.03495923f, -0.04864969f, 0.18540709f, 0.00993386f, 0.16317536f, 0.08954789f, 0.03085845f, 
    0.46568722f, 0.41160223f, -0.02053107f, 0.15245086f, 0.06163439f, 0.04317426f, 0.09604922f, -0.05210083f, 
    0.11107156f, 0.03903903f, -0.01052746f, -0.02397907f, 0.04955177f, -0.06192359f, -0.10132220f, 0.10303240f, 
    0.09541769f, 0.10610953f, 0.04867902f, 0.03218260f, -0.41828611f, -0.29016647f, -0.05064669f, -0.15865871f, 
    0.03288516f, 0.02669807f, 0.01628108f, 0.01927379f, 0.06290447f, 0.07091194f, -0.13740212f, 0.00441637f, 
    0.01313367f, 0.07161818f, -0.06176645f, 0.00335693f, -0.11459545f, -0.02094994f, -0.05195616f, -0.01785418f, 
    -0.60810333f, -0.16643697f, -0.19780420f, -0.05499898f, 0.10753550f, -0.01860913f, 0.14250341f, 0.00632016f, 
    0.00888733f, 0.04884760f, -0.06442472f, 0.03667544f, 0.01384409f, -0.07630243f, 0.18752182f, 0.06295728f, 
    -0.00591001f, -0.01707954f, -0.03645794f, 0.09285609f, -0.36885470f, 0.01832390f, 0.00518122f, 0.12804458f, 
    0.04901957f, 0.10562718f, 0.05712073f, 0.11954872f, 0.02819368f, 0.04129660f, -0.01519660f, 0.05842602f, 
    -0.01000911f, 0.01164904f, -0.09083030f, -0.00202611f, 0.10509686f, 0.00627261f, 0.07228983f, 0.07036568f, 
    0.02533393f, 0.01420017f, -0.00069664f, 0.02719489f, -0.01333537f, 0.01284161f, -0.03940880f, 0.01971274f, 
    0.01719451f, 0.01952531f, -0.04140387f, 0.02560298f, -0.01846239f, 0.00445792f, 0.02030179f, 0.01171935f, 
    0.00409082f, -0.00785328f, 0.01189932f, -0.00883723f, -0.02129512f, -0.02729210f, -0.01165544f, 0.00052971f, 
    -0.00982574f, 0.00888547f, -0.04612741f, -0.01666144f, 0.02418907f, -0.03400126f, -0.00057908f, 0.01101547f, 
    -0.03796744f, 0.03324957f, 0.01663320f, 0.00391228f, -0.02597624f, 0.00229563f, -0.03566182f, -0.01058217f, 
    -0.00424157f, -0.02222678f, -0.04286367f, -0.03258971f, -0.03237339f, -0.02771174f, -0.04472342f, 0.02961191f, 
    0.03709779f, -0.03718088f, 0.03436658f, 0.00237588f, -0.03397551f, 0.01657890f, -0.01507038f, -0.02953092f, 
    0.02272504f, 0.00461553f, 0.03296253f, 0.00192739f, -0.00323235f, -0.00472104f, -0.00327824f, 0.01816194f, 
    -0.04031927f, -0.00943567f, -0.00959351f, 0.00852340f, -0.00525189f, -0.03351377f, -0.01024722f, 0.00411030f, 
    -0.00904109f, -0.00888518f, -0.01935778f, -0.00188672f, -0.00343284f, 0.02754569f, -0.02821469f, -0.00088305f, 
    0.01984297f, 0.01813336f, -0.01303079f, 0.03156546f, 0.01621806f, 0.02622380f, -0.02056259f, 0.03199251f, 
    -0.02720660f, -0.02039687f, 0.02852765f, 0.00363664f, -0.02222919f, -0.03648318f, 0.00457234f, -0.03891302f, 
    -0.02848396f, -0.02857466f, -0.01197503f, -0.01261930f, -0.02858059f, -0.02842975f, -0.02608528f, 0.03299274f, 
    -0.01549263f, -0.03260615f, -0.01438559f, -0.03110223f, 0.00179750f, 0.00316122f, -0.04096078f, -0.02442590f, 
    0.01802024f, 0.02282053f, -0.00469328f, 0.01743124f, 0.01070239f, 0.00350330f, 0.02366197f, -0.03167101f, 
    0.03194174f, -0.04769713f, -0.02531391f, -0.02166767f, 0.00452121f, 0.01487100f, -0.01882465f, -0.03603787f, 
    -0.01999836f, -0.00868245f, 0.01492115f, 0.00971100f, -0.00755420f, 0.00866234f, 0.01653353f, -0.04544576f, 
    0.00525480f, 0.01755722f, 0.02351401f, -0.02642429f, 0.02086086f, 0.01024515f, -0.02808244f, -0.02309053f, 
    0.02433060f, 0.03951160f, 0.02632371f, -0.03704333f, 0.01439914f, -0.00500101f, -0.03615102f, -0.01656998f, 
    -0.00795278f, -0.02843361f, 0.02961363f, 0.00140010f, -0.01639859f, -0.02459537f, 0.00690928f, -0.02251495f, 
    -0.01258152f, -0.03060817f, -0.04057602f, -0.03167357f, 0.02923320f, 0.00943186f, 0.00812340f, -0.00276099f, 
    0.02889471f, -0.01083272f, -0.02203029f, 0.02698740f, -0.02946382f, -0.01700659f, -0.03918901f, 0.00209594f, 
    0.01799299f, 0.00000239f, 0.02601484f, 0.02684551f, 0.00289339f, -0.02879982f, 0.01447757f, 0.03413458f, 
    -0.01002482f, -0.01256023f, 0.02861314f, -0.04578397f, 0.00424398f, -0.02414704f, -0.00149939f, 0.02881527f, 
    0.02231849f, 0.01879970f, -0.00977319f, -0.00733207f, -0.01200335f, -0.04319604f, 0.00950341f, -0.01657418f, 
    -0.01188697f, -0.01142635f, -0.02752399f, -0.00006725f, -0.00030223f, 0.02351566f, 0.03105565f, 0.02219425f, 
    -0.02425365f, 0.02213716f, 0.02024745f, 0.00337306f, -0.01292752f, -0.01912866f, -0.03099768f, -0.03739181f, 
    0.01650186f, -0.00832366f, -0.04051150f, -0.02424007f, -0.02843999f, 0.01111777f, 0.03481412f, 0.02413837f, 
    -0.01960224f, -0.03029936f, -0.02410425f, -0.00663801f, -0.01148749f, -0.01722147f, -0.03987627f, 0.01111082f, 
    0.02227413f, -0.03665197f, -0.00170258f, -0.00824290f, -0.01593259f, -0.04019425f, -0.01642949f, 0.00340817f, 
    -0.03901054f, -0.02377285f, 0.00724925f, 0.01474221f, 0.00695533f, 0.00245248f, -0.01672931f, -0.04630638f, 
    0.01189192f, -0.01734844f, -0.00777223f, -0.00383849f, 0.00777020f, -0.01045500f, 0.01414076f, -0.01767075f, 
    0.00820560f, -0.04277422f, -0.02043587f, 0.01568355f, 0.01462029f, 0.04525758f, 0.02695116f, -0.02011443f, 
    0.03045227f, 0.03777300f, -0.03270464f, 0.02762584f, -0.02940087f, -0.03844410f, -0.03548983f, -0.01144279f, 
    0.00950741f, 0.02012487f, 0.02299896f, 0.01058817f, -0.04313194f, -0.02835475f, 0.02388575f, -0.00989671f, 
    -0.04082502f, -0.03211726f, -0.01650455f, -0.01062171f, -0.04263597f, -0.04019314f, 0.02642501f, 0.02027569f, 
    0.02763763f, -0.03814906f, -0.02262070f, 0.02173621f, 0.03130600f, 0.02825010f, 0.00529193f, -0.01683208f, 
    0.00887957f, 0.00374416f, 0.01230741f, -0.03665616f, -0.02221529f, -0.03629787f, -0.01570099f, 0.00562121f, 
    -0.01304252f, -0.01115349f, 0.02687100f, -0.04300841f, -0.00112561f, -0.03807469f, -0.00393367f, -0.01658593f, 
    0.01253074f, 0.02197707f, 0.02900455f, 0.01616834f, 0.01030716f, -0.00907681f, 0.01104341f, -0.04491207f, 
    -0.02006510f, 0.03099924f, 0.01940729f, -0.04212115f, -0.03983776f, 0.00250424f, -0.03883529f, 0.01471369f, 
    0.00251933f, 0.01904219f, -0.03034718f, -0.02684307f, -0.04210657f, 0.01699577f, -0.01425203f, -0.00920940f, 
    -0.01832320f, 0.03652591f, -0.01029572f, -0.03374347f, -0.02242089f, -0.01734495f, -0.03323629f, 0.02545115f, 
    0.02818209f, -0.01309561f, -0.04822380f, -0.02343113f, -0.02527042f, 0.01313235f, -0.00287242f, -0.03127212f, 
    -0.01690499f, 0.03384082f, -0.02557926f, -0.04302658f, 0.01571555f, 0.01213906f, -0.04730656f, 0.01978905f, 
    0.02171524f, 0.01089937f, 0.01623292f, -0.01173200f, 0.00622366f, -0.03967861f, 0.00214159f, 0.03260655f, 
    -0.01595487f, -0.00991087f, -0.03799594f, -0.02062567f, 0.01646233f, -0.04239077f, 0.02466470f, 0.01402008f, 
    0.02589003f, -0.00286120f, -0.02374611f, -0.03549711f, -0.01774242f, -0.00414660f, -0.02599338f, 0.02834813f, 
    -0.03139466f, 0.01682429f, 0.02809911f, -0.00421790f, -0.01846341f, 0.02352360f, -0.03752151f, -0.01672717f, 
    -0.01503567f, -0.00671615f, -0.03597642f, -0.04198270f, -0.00480259f, 0.01732318f, -0.03159447f, -0.01910606f, 
    -0.02417429f, -0.03320798f, 0.00787732f, -0.01600958f, -0.02007276f, -0.00047108f, 0.00527781f, -0.01714377f, 
    -0.00679341f, -0.04573740f, 0.00959623f, -0.04270123f, -0.03934961f, 0.02560410f, -0.03084217f, -0.02024641f, 
    -0.00931289f, -0.02741962f, -0.04472966f, 0.01483511f, 0.03485130f, -0.00778828f, -0.03066039f, 0.01383123f, 
    -0.01788973f, 0.02772542f, -0.02502929f, 0.02511374f, -0.00115088f, 0.02207255f, 0.00892104f, -0.02746190f, 
    -0.03321115f, -0.02867419f, 0.00248568f, -0.01050927f, 0.02766703f, -0.04684729f, -0.02178481f, -0.01502849f, 
    -0.01471524f, 0.00468542f, 0.00982317f, -0.01554491f, 0.02044882f, 0.00065499f, -0.00508977f, -0.01334074f, 
    0.00451084f, -0.02475846f, 0.00303703f, -0.00791251f, 0.01453995f, 0.01718820f, 0.00958612f, -0.00491944f, 
    0.03115901f, 0.00959411f, -0.00068684f, -0.02140081f, 0.01870967f, 0.01036977f, -0.04564620f, -0.03687438f, 
    -0.01522568f, -0.02566302f, 0.01975915f, -0.03432150f, -0.03818134f, -0.02197281f, -0.00182764f, 0.03059660f, 
    0.02379463f, 0.02620908f, 0.01900446f, -0.01935168f, 0.01172173f, -0.04961837f, 0.01469281f, -0.00031431f, 
    0.00743511f, 0.01898081f, -0.01219953f, -0.04256690f, 0.00371293f, -0.03329218f, 0.01328571f, -0.02799298f, 
    0.03132827f, 0.02362204f, 0.00403891f, 0.02394681f, -0.01886714f, -0.00569672f, -0.01072891f, -0.01191047f, 
    0.01063989f, 0.00905407f, -0.00535035f, -0.00549408f, 0.02127888f, -0.03253913f, -0.03610915f, -0.03760548f, 
    -0.03793213f, -0.02150210f, 0.02648668f, -0.02845330f, -0.01185687f, 0.02030713f, 0.02215029f, -0.04003795f, 
    -0.00956432f, 0.00489764f, -0.03205230f, -0.04148988f, -0.02337213f, -0.00344077f, -0.04157007f, 0.00462060f, 
    0.02450304f, -0.00084906f, -0.04307065f, 0.02886967f, 0.02801034f, -0.02761060f, 0.01561865f, -0.03898185f, 
    -0.02664955f, -0.02624235f, -0.04009681f, 0.01373049f, -0.01568593f, -0.02232674f, 0.02925152f, -0.00859460f, 
    -0.04692007f, -0.00948700f, 0.01986635f, -0.00956120f, 0.00803413f, 0.03767757f, -0.04566336f, -0.01576317f, 
    -0.03105910f, -0.00692376f, -0.00814701f, -0.04060742f, 0.00832660f, 0.01715390f, -0.00429424f, 0.00510411f, 
    -0.03731665f, -0.02102802f, -0.01612339f, -0.03486495f, -0.00996190f, 0.02831470f, 0.01945155f, -0.01168484f, 
    -0.03912196f, -0.00928867f, 0.02539457f, 0.01108251f, -0.03001324f, -0.02998228f, -0.01907513f, 0.02134757f, 
    -0.02674783f, -0.00445162f, 0.02165983f, -0.00673439f, -0.02384702f, -0.04269967f, 0.01929231f, -0.00320805f, 
    -0.01751229f, -0.03911585f, 0.00019843f, -0.03375931f, 0.01683961f, -0.01427938f, -0.00722792f, -0.03945718f, 
    0.02742682f, -0.03002040f, 0.02421374f, -0.02778234f, 0.02698365f, -0.00452801f, 0.00667664f, 0.01756914f, 
    -0.04017484f, -0.00011427f, -0.03219756f, -0.04688587f, -0.01882760f, 0.01547746f, 0.02886934f, -0.02211865f, 
    0.01860492f, -0.00712491f, -0.00995950f, 0.00269302f, 0.01271287f, -0.01545150f, 0.00766679f, 0.01505275f, 
    -0.00104754f, 0.02367427f, -0.04196845f, -0.00535276f, -0.00984639f, -0.01044941f, -0.02131185f, -0.04463629f, 
    0.00879323f, 0.01621877f, -0.02985393f, -0.00049479f, 0.01087302f, -0.03369774f, -0.03894891f, 0.01931645f, 
    -0.02977970f, 0.00128664f, 0.01997796f, -0.02995400f, -0.04037599f, -0.04749436f, -0.00949246f, -0.04526941f, 
    -0.03951238f, -0.02110385f, -0.00688417f, -0.00395727f, 0.01711524f, -0.03259176f, -0.02897003f, 0.01313702f, 
    0.02630102f, 0.02196287f, -0.03361924f, -0.02185307f, 0.01114533f, 0.03032526f, 0.02016289f, 0.01166013f, 
    -0.02869247f, 0.02227324f, -0.03267135f, 0.02446378f, 0.01224794f, -0.00296432f, -0.00265848f, -0.03927516f, 
    -0.02594174f, 0.02579357f, 0.02963610f, -0.02246043f, -0.00310603f, 0.00066134f, 0.01652580f, 0.01242836f, 
    0.02768189f, -0.03717073f, -0.00962327f, -0.03255762f, 0.01836921f, -0.03301769f, 0.00767101f, -0.02490892f, 
    -0.03204224f, 0.02526979f, 0.01546727f, 0.02106421f, 0.02772565f, -0.02587102f, -0.03772148f, -0.03677236f, 
    -0.04484135f, 0.00863601f, -0.00379681f, -0.03450827f, -0.04286183f, -0.03601371f, -0.02783627f, 0.02706011f, 
    0.01888593f, -0.01089455f, -0.01790216f, -0.03185625f, -0.02442388f, -0.00006322f, 0.01284970f, -0.01312540f, 
    -0.01798290f, 0.01404850f, 0.00111693f, -0.03158420f, 0.00271616f, 0.00932316f, -0.01216302f, 0.02914730f, 
    -0.01273429f, -0.04301599f, -0.00401847f, 0.01664709f, -0.02414514f, 0.00000536f, -0.03500284f, -0.01146892f, 
    -0.03822334f, 0.00547914f, -0.03238548f, -0.02923536f, 0.00901838f, 0.02005663f, -0.02971980f, -0.01419789f, 
    0.02730062f, 0.01710855f, -0.02795178f, 0.01308770f, 0.01280132f, -0.01619587f, -0.03253179f, -0.01976173f, 
    -0.03045305f, 0.00800971f, -0.01489799f, 0.03410529f, -0.04462919f, 0.03327868f, -0.00018102f, -0.02142441f, 
    0.02950058f, 0.02375622f, -0.01876217f, 0.00421068f, 0.00753776f, -0.02117519f, 0.01509925f, 0.02312835f, 
    -0.01920838f, 0.03079239f, -0.04010767f, -0.02878934f, 0.03401668f, -0.03839789f, 0.02962891f, 0.00556654f, 
    -0.03787460f, -0.01735306f, 0.02824392f, -0.01767062f, -0.00771144f, 0.00645075f, -0.04053592f, -0.03444547f, 
    0.01053010f, 0.00036181f, 0.00436437f, -0.01474007f, 0.00355562f, 0.02363965f, 0.01489305f, 0.01266349f, 
    -0.00549226f, 0.00458526f, 0.02260182f, 0.01220355f, 0.00218058f, 0.00086290f, -0.00673851f, -0.01249234f, 
    0.00806143f, 0.03150729f, 0.00815355f, -0.02411160f, 0.01950673f, -0.00653373f, 0.01038348f, 0.00315572f, 
    -0.04106480f, -0.00581713f, -0.03480446f, 0.01233847f, 0.00117732f, -0.03576568f, -0.00601030f, -0.00372598f, 
    0.02161084f, 0.01946566f, 0.01545251f, -0.01181103f, 0.01986479f, 0.00135343f, -0.00073713f, 0.02908579f, 
    0.01758092f, 0.01863774f, -0.04070915f, 0.01030771f, -0.00762925f, 0.02792557f, -0.02814498f, -0.02941488f, 
    -0.02842379f, -0.00790956f, 0.00064205f, 0.02904104f, -0.02077411f, -0.04237265f, 0.03223393f, 0.00514318f, 
    0.00921382f, -0.01092511f, -0.03846723f, 0.00069022f, 0.00768313f, 0.00361552f, 0.00876713f, 0.02770456f, 
    -0.02928084f, -0.02215443f, 0.02949370f, 0.01012285f, 0.01464127f, 0.03334421f, -0.01271114f, -0.02638753f, 
    -0.00410050f, 0.00912943f, -0.03267148f, -0.03066397f, -0.04381783f, -0.01015502f, 0.00943016f, -0.02265095f, 
    0.00956544f, -0.04438303f, 0.01757327f, -0.00226645f, 0.03253435f, 0.01686767f, -0.01815497f, 0.01695181f, 
    -0.00350406f, -0.00518015f, -0.03894338f, -0.02904858f, -0.03057490f, 0.00510794f, 0.03240380f, 0.02421285f, 
    -0.01420873f, 0.00976917f, 0.01460903f, 0.01402745f, -0.03038666f, 0.00074178f, -0.00484436f, -0.02988590f, 
    0.02450299f, 0.03177207f, -0.00740732f, 0.01637048f, -0.02794083f, 0.01329931f, -0.04299820f, 0.00546275f, 
    -0.04084206f, -0.01832581f, 0.02158627f, -0.00749642f, -0.02146044f, 0.03344930f, -0.00949410f, -0.02409170f, 
    -0.01254359f, 0.02408147f, 0.03030567f, -0.03576640f, -0.00671564f, -0.00602552f, -0.01919802f, 0.00132381f, 
    -0.00045068f, -0.01139282f, -0.00340652f, 0.02878156f, -0.01818807f, -0.01196071f, -0.01445367f, -0.01882413f, 
    0.02353495f, -0.02481665f, -0.03211349f, 0.01659317f, 0.02726879f, -0.02402964f, 0.01013202f, 0.02371367f, 
    -0.03314024f, -0.00559856f, -0.03166489f, -0.03041680f, 0.00005053f, 0.02399813f, 0.00332177f, 0.01844677f, 
    0.03470236f, -0.03856787f, -0.02415170f, -0.01427062f, -0.00217968f, -0.03528884f, 0.00637982f, 0.02992879f, 
    -0.03394864f, -0.03163549f, -0.02047307f, 0.02510009f, 0.01398082f, -0.01419779f, 0.00707175f, -0.03407677f, 
    -0.03998384f, 0.00225853f, -0.00650710f, 0.00947642f, 0.00836525f, 0.02054983f, 0.01305269f, -0.03201261f, 
    -0.00085037f, -0.02722336f, 0.03414041f, -0.02977247f, 0.00328841f, 0.03249464f, -0.02307351f, -0.01133006f, 
    0.00347103f, 0.02443280f, -0.00060105f, 0.00929901f, -0.04424842f, 0.03019887f, -0.02536826f, 0.02839776f, 
    0.01239082f, 0.01502723f, 0.01099105f, -0.02848463f, 0.01378460f, -0.03675165f, -0.01821514f, 0.00769294f, 
    -0.02005356f, 0.01599419f, 0.00452568f, 0.00080045f, 0.01194593f, -0.02942408f, 0.01772757f, 0.02156335f, 
    -0.02252530f, -0.01911191f, -0.02708077f, 0.02110996f, 0.01158012f, -0.04131370f, 0.01083865f, -0.04125321f, 
    0.01840783f, -0.03080465f, 0.01257685f, 0.01368690f, -0.03681258f, 0.00233270f, -0.01448981f, -0.01061155f, 
    -0.02265484f, -0.04166275f, 0.00965168f, -0.03579228f, 0.00656941f, -0.02049732f, -0.02436708f, 0.03910818f, 
    0.03087064f, -0.04218313f, 0.01443470f, 0.00639817f, 0.01005158f, 0.00069349f, -0.01347368f, -0.02312443f, 
    -0.00211320f, -0.03921386f, 0.00103699f, -0.03326020f, -0.04219757f, -0.02068436f, -0.01837594f, -0.00987613f, 
    -0.00610701f, -0.03911655f, 0.03330784f, -0.03653734f, -0.00943882f, -0.03821893f, 0.02634521f, 0.03114474f, 
    0.00002316f, -0.02393827f, 0.01483838f, -0.02472053f, 0.03009516f, 0.02187572f, -0.03835259f, 0.01262883f, 
    -0.01095187f, 0.02183485f, -0.03112676f, 0.02418616f, -0.01760240f, 0.00692454f, -0.01603304f, -0.01130757f, 
    -0.02946275f, 0.01279378f, -0.03540421f, -0.03420873f, 0.00960074f, -0.01312829f, -0.03131603f, -0.03648441f, 
    0.01196813f, 0.01019213f, -0.04066814f, 0.01155807f, 0.01963761f, -0.03292553f, -0.03419910f, 0.02488785f, 
    0.00329895f, 0.02617929f, 0.01307939f, -0.00012292f, 0.00408782f, 0.03380874f, 0.02596271f, 0.00767647f, 
    -0.04137332f, -0.03970829f, 0.02467506f, -0.03533999f, 0.01260155f, -0.04069821f, -0.02590417f, -0.03670617f, 
    0.03226886f, -0.03207690f, -0.04107699f, 0.00345992f, -0.00718215f, -0.03912578f, 0.01227330f, 0.01725459f, 
    -0.03371947f, -0.02423925f, 0.00314980f, 0.02937744f, 0.00583644f, -0.00198282f, -0.01659407f, -0.03865397f, 
    -0.00422215f, -0.01607185f, 0.00608569f, -0.02098754f, -0.02519247f, 0.03319715f, -0.02059100f, -0.04281812f, 
    0.03222659f, 0.02667716f, -0.02916540f, 0.02681757f, 0.01449548f, -0.02872052f, 0.02419483f, -0.03395176f, 
    -0.02517571f, 0.02658169f, 0.02345781f, -0.00119960f, -0.00209401f, 0.01273656f, -0.04231472f, -0.02230556f, 
    0.03151868f, -0.00283381f, 0.00681389f, -0.02529961f, 0.02640654f, -0.01129851f, 0.01628718f, 0.00697099f, 
    0.00014659f, 0.01090859f, -0.02353322f, 0.01726004f, 0.01332927f, 0.00030074f, -0.00876073f, 0.01844018f, 
    0.02024411f, -0.00392193f, -0.04146351f, 0.02686639f, 0.02682657f, 0.01944919f, 0.02760720f, -0.01725720f, 
    -0.02960090f, -0.01333854f, 0.00973025f, 0.03214268f, -0.04235793f, -0.03369489f, -0.02708902f, 0.02252398f, 
    0.02432043f, -0.03460608f, -0.03317983f, -0.01560323f, -0.04533691f, -0.00636293f, -0.03973014f, -0.01641467f, 
    0.00293998f, 0.00313990f, -0.00994972f, -0.03226667f, 0.00677950f, 0.01954841f, 0.00219988f, -0.01869389f, 
    -0.00823134f, -0.03923969f, -0.00156818f, 0.01308219f, 0.02845162f, -0.00583017f, -0.02756549f, -0.01790919f, 
    -0.00622994f, -0.03858476f, -0.01046557f, -0.03751306f, -0.00252373f, 0.00284372f, -0.01644804f, 0.02260119f, 
    0.00512432f, -0.00434037f, 0.00912558f, -0.04186814f, 0.01237291f, -0.02505188f, -0.04003184f, 0.01755216f, 
    0.02274837f, 0.00011590f, 0.01520607f, -0.00560753f, -0.01014088f, 0.00282855f, 0.01797194f, 0.02893846f, 
    -0.01699435f, 0.03410837f, -0.04541600f, 0.00604043f, 0.01641362f, 0.01144965f, -0.03727898f, -0.00281825f, 
    -0.02851620f, -0.00975210f, -0.03448236f, 0.02326737f, -0.02289003f, 0.01744546f, 0.01680245f, 0.01378967f, 
    0.01599207f, -0.02762247f, -0.04143231f, -0.02265934f, 0.01558399f, -0.03607930f, 0.01707371f, 0.03004095f, 
    -0.02852540f, 0.01283823f, -0.03020090f, 0.03447746f, 0.00218009f, -0.04033230f, 0.01629732f, -0.02602406f, 
    -0.00947567f, -0.00789326f, 0.00181308f, -0.02912381f, -0.02886802f, 0.02628753f, -0.04405041f, -0.00073398f, 
    -0.04032328f, -0.00463273f, -0.01392462f, -0.03476097f, 0.02919531f, 0.02873153f, -0.00932332f, -0.01376748f, 
    -0.02617809f, 0.01310185f, -0.03801677f, -0.03156608f, 0.02404766f, -0.03300372f, -0.03388028f, -0.00467233f, 
    -0.04315118f, -0.03170402f, 0.02415387f, 0.01031504f, -0.04328118f, -0.01735274f, -0.02658490f, -0.01654084f, 
    -0.03113318f, -0.03878103f, -0.01596453f, -0.04488961f, -0.00750547f, 0.00492301f, 0.00422320f, -0.02957841f, 
    0.00823257f, -0.00031552f, 0.02530079f, -0.00868133f, -0.00484891f, -0.03415035f, -0.03933204f, 0.01950644f, 
    -0.01880451f, -0.01177977f, -0.02675055f, -0.03158156f, 0.00116813f, 0.02598865f, 0.01986415f, -0.03078581f, 
    0.02117586f, 0.01245057f, -0.00278101f, 0.01419000f, 0.00293648f, 0.00281512f, 0.01792446f, 0.02974738f, 
    -0.02440809f, -0.02153895f, 0.00956149f, -0.04304926f, 0.01000513f, 0.03116991f, -0.01940410f, 0.00595318f, 
    -0.04435537f, 0.01428930f, 0.00340348f, -0.01616281f, 0.03140497f, -0.04157484f, 0.02200667f, 0.01757621f, 
    -0.02202727f, 0.03202233f, -0.03279978f, -0.01703824f, -0.01243970f, -0.02534116f, 0.03394284f, 0.02565286f, 
    0.00300594f, -0.04379518f, 0.01492511f, -0.03867038f, -0.04008712f, -0.00502912f, -0.01097592f, 0.02214329f, 
    -0.01863849f, -0.01414748f, 0.00637749f, 0.01291349f, 0.03911478f, 0.01381869f, -0.00288826f, -0.03042655f, 
    -0.03768956f, -0.00149004f, 0.00668638f, 0.02537787f, -0.03958762f, 0.02863281f, -0.03597125f, 0.02221085f, 
    -0.02439370f, 0.04451550f, -0.03167168f, -0.03612734f, 0.02827591f, -0.01175036f, 0.00458413f, 0.01397092f, 
    -0.00129177f, -0.02943207f, -0.01705962f, -0.03577003f, -0.02975964f, -0.00328281f, 0.00910258f, 0.03202476f, 
    -0.00850032f, -0.03932130f, 0.03384460f, -0.03238367f, 0.00614694f, -0.02018816f, -0.01706715f, 0.00129550f, 
    0.01722600f, -0.04430625f, 0.02641743f, -0.02851237f, -0.03321635f, 0.03120088f, 0.01143981f, -0.00714466f, 
    -0.03982575f, -0.03094142f, -0.00679635f, 0.00949752f, 0.01831505f, -0.02865154f, 0.03334533f, -0.04330668f, 
    -0.03653974f, 0.01979663f, 0.00092103f, 0.00135934f, 0.00403139f, -0.02072116f, -0.03189150f, -0.02937450f, 
    -0.04365797f, -0.04211211f, -0.00697512f, -0.02374667f, -0.03688252f, -0.00684461f, -0.00530105f, 0.01901247f, 
    -0.03365649f, -0.04062660f, -0.02037484f, -0.03398414f, -0.02708385f, -0.03652005f, 0.00160239f, -0.01932506f, 
    0.02929270f, -0.02790315f, 0.01674557f, -0.03943084f, 0.01859774f, 0.00384631f, -0.01984208f, -0.04261664f, 
    0.00009978f, -0.02141582f, -0.00064494f, -0.03049506f, 0.03375715f, -0.00601660f, 0.00446317f, 0.01154248f, 
    -0.03344375f, -0.02067565f, -0.00985856f, -0.02935757f, 0.01718184f, -0.03417089f, 0.00382118f, 0.00573824f, 
    -0.00866490f, -0.04161240f, -0.00703396f, 0.02508214f, -0.01524208f, -0.02566788f, -0.04043965f, -0.03394602f, 
    -0.04225516f, -0.01912028f, 0.01752962f, -0.01928485f, 0.02186492f, -0.00994006f, -0.01755399f, -0.03058451f, 
    -0.04064995f, 0.00469811f, 0.02957068f, 0.03021933f, -0.02246242f, -0.01974601f, 0.02005840f, 0.03006991f, 
    0.00021471f, 0.03042148f, 0.01339077f, -0.03479493f, 0.02836399f, 0.01411700f, -0.01906230f, -0.01489971f, 
    -0.01234588f, 0.02978287f, -0.03147236f, 0.00977920f, -0.04179162f, -0.00155221f, 0.02369169f, -0.00743614f, 
    -0.02604663f, 0.01354264f, 0.01853758f, -0.01827711f, -0.00164757f, 0.00610943f, 0.00020957f, 0.02886390f, 
    -0.03566600f, 0.02998658f, 0.02066526f, 0.01677353f, 0.03296570f, -0.02576047f, 0.03096982f, 0.02041217f, 
    -0.04186080f, -0.02948144f, 0.00647407f, -0.04467258f, 0.01375725f, -0.01841873f, -0.03120642f, 0.01450397f, 
    0.01901826f, 0.03923504f, 0.02790014f, -0.00974001f, 0.03175722f, -0.03051021f, 0.00586175f, 0.00839610f, 
    0.00395084f, 0.02080844f, -0.02326582f, -0.01718644f, 0.02053559f, 0.00816904f, 0.00738444f, -0.01663707f, 
    -0.01723765f, -0.01813260f, -0.02357664f, -0.03586594f, 0.01795427f, -0.04147352f, 0.03286386f, 0.02235294f, 
    0.02300770f, 0.00608156f, -0.01905246f, 0.00386227f, 0.02514150f, -0.01583943f, 0.00732524f, -0.04165422f, 
    -0.02083951f, -0.00733147f, 0.00669649f, -0.00880854f, 0.00877396f, -0.03263926f, -0.01347595f, -0.00060933f, 
    0.01773800f, 0.01064185f, -0.00987008f, 0.01309064f, -0.02331774f, -0.03079824f, 0.01794690f, -0.04291150f, 
    -0.00077215f, -0.03388305f, -0.00880275f, 0.01757730f, 0.02158874f, -0.00202392f, -0.04333314f, 0.00138641f, 
    0.03147346f, -0.00472097f, -0.02215713f, -0.03926260f, 0.00831625f, 0.02155689f, -0.02399513f, -0.00613544f, 
    0.00993542f, 0.01605518f, -0.02037066f, 0.02359645f, 0.00223887f, 0.00774357f, -0.04097948f, -0.02784153f, 
    -0.01923102f, -0.01157984f, 0.01353592f, 0.01516776f, -0.03009137f, 0.00835279f, -0.01880115f, -0.03069583f, 
    0.01097260f, 0.02077831f, 0.00625841f, -0.03655847f, -0.01960900f, -0.00955991f, 0.02759144f, -0.04223426f, 
    -0.00702937f, -0.01095127f, 0.00958591f, 0.00956552f, -0.01279013f, -0.01109497f, -0.00631066f, -0.03672921f, 
    0.01966725f, -0.00356999f, -0.03997310f, -0.04181459f, -0.03034155f, -0.01330855f, -0.01931447f, 0.03096312f, 
    0.01937472f, -0.01067373f, -0.04305435f, 0.01181305f, 0.00703133f, -0.02500071f, 0.02195705f, -0.02833782f, 
    -0.04002364f, -0.01134602f, -0.04111085f, 0.02036363f, 0.02504379f, 0.00370536f, -0.02499324f, -0.04217749f, 
    -0.00461795f, 0.01115929f, 0.03746285f, 0.02557613f, 0.03676456f, 0.00853146f, -0.03357181f, 0.01134976f, 
    0.01934956f, 0.01799040f, 0.00891240f, 0.01169996f, -0.01938577f, -0.00793563f, 0.02895890f, -0.03542684f, 
    -0.00915513f, -0.00088293f, -0.02236235f, 0.02257068f, 0.03418150f, 0.02621442f, -0.00205166f, 0.03228747f, 
    0.02081269f, -0.02565016f, -0.03426950f, 0.00547577f, -0.02503257f, 0.02935352f, 0.01650766f, 0.01518552f, 
    -0.00487373f, -0.02342912f, -0.03479882f, -0.02081443f, -0.02773440f, -0.01472123f, -0.03565893f, -0.01850818f, 
    0.02167728f, -0.03040807f, -0.02533063f, 0.02720131f, -0.01273345f, -0.01264634f, -0.01174775f, -0.04135591f, 
    -0.00435545f, 0.02653095f, 0.00287118f, 0.00836525f, 0.01488738f, 0.02860573f, -0.01331809f, -0.01935466f, 
    -0.00210416f, 0.01298280f, -0.00464494f, 0.01772123f, -0.03238172f, 0.03263062f, -0.00179910f, -0.03366767f, 
    0.00577930f, 0.00273772f, -0.01292754f, 0.03365833f, 0.04331953f, -0.00907734f, -0.03245718f, -0.02910576f, 
    -0.02181701f, 0.03927168f, -0.04410704f, 0.03128747f, 0.03485272f, -0.01402735f, 0.01813027f, -0.02961417f, 
    -0.04392432f, 0.00064330f, -0.04314815f, -0.04365129f, -0.00718953f, 0.00059838f, 0.01334114f, 0.00127728f, 
    -0.02045108f, -0.01913149f, 0.02390748f, -0.01484002f, -0.02889968f, 0.00133485f, 0.00686297f, -0.02316477f, 
    -0.00602090f, 0.02677833f, -0.01594096f, -0.02930859f, 0.00051759f, 0.00256991f, -0.01138776f, -0.02328480f, 
    0.01935560f, -0.03333858f, -0.01192814f, 0.01898096f, 0.03119668f, 0.01851166f, -0.04247518f, 0.00462399f, 
    -0.01241256f, -0.04199679f, -0.01042652f, -0.03243811f, 0.02871530f, 0.01704706f, -0.00476235f, -0.00757325f, 
    -0.00884714f, 0.01778266f, 0.00286440f, 0.00876526f, -0.00305568f, -0.00724948f, -0.02721875f, -0.02060150f, 
    -0.00488366f, 0.03063998f, 0.02639717f, 0.01571038f, -0.03108618f, -0.02443543f, -0.02600230f, -0.00707146f, 
    0.02424566f, -0.00593641f, -0.03799620f, 0.01728835f, -0.04343590f, 0.02456566f, -0.00746667f, -0.03898826f, 
    -0.01534243f, 0.02378398f, 0.02495114f, 0.02207992f, -0.03391587f, 0.03166503f, -0.03602683f, 0.01454737f, 
    -0.03067681f, 0.00822100f, 0.00609891f, 0.00985205f, 0.01050396f, 0.00839925f, -0.01103754f, -0.02551594f, 
    -0.01606596f, 0.00457425f, 0.01616901f, -0.01663704f, 0.01601819f, 0.02951297f, 0.02756646f, 0.02118615f, 
    -0.02522558f, -0.03288506f, 0.02112518f, 0.01080481f, -0.03849313f, -0.01334646f, 0.03024392f, 0.02471554f, 
    -0.00022008f, -0.01136004f, 0.00485774f, 0.01890222f, -0.01860630f, 0.02850928f, 0.01830493f, 0.01742046f, 
    -0.02245808f, -0.00782218f, -0.00129162f, -0.00645357f, 0.01271523f, -0.01166372f, 0.02553974f, -0.01890973f, 
    0.02193194f, -0.01817604f, -0.03399171f, -0.03721724f, -0.03170041f, -0.01265674f, 0.01212809f, -0.02748495f, 
    -0.04451467f, -0.03655297f, -0.00241816f, -0.01797653f, -0.03852933f, 0.02558728f, 0.04158983f, 0.03934107f, 
    -0.02852006f, 0.03412427f, 0.02694221f, 0.02482053f, -0.02807646f, 0.01376116f, 0.02671670f, 0.01650122f, 
    -0.02856256f, -0.00441133f, -0.03193372f, -0.02665966f, 0.00037116f, -0.00965386f, -0.02274675f, -0.03542249f, 
    0.01004801f, -0.01144795f, 0.02289061f, 0.01377596f, 0.01439315f, -0.03603508f, -0.03911320f, -0.00789260f, 
    -0.03111635f, -0.04286740f, -0.03483304f, 0.00396086f, -0.03889918f, -0.01093196f, -0.03731925f, -0.03854922f, 
    0.03325954f, -0.01197768f, -0.01983889f, -0.02002447f, -0.00885785f, -0.02346991f, 0.00002902f, 0.03402818f, 
    -0.00764766f, 0.02695124f, 0.03255898f, 0.01239569f, -0.00761315f, -0.02499126f, -0.00922109f, -0.03701019f, 
    0.01821255f, 0.03379010f, -0.03403169f, -0.01126805f, -0.02166854f, -0.03728647f, -0.03321538f, -0.00917980f, 
    0.02146492f, 0.01532943f, -0.02384608f, 0.00387077f, -0.00203889f, -0.02704320f, -0.00500341f, 0.02215864f, 
    -0.04264255f, 0.03277120f, -0.03414082f, -0.00064478f, -0.01904300f, 0.00010898f, -0.01304511f, 0.02119606f, 
    -0.00849789f, 0.01054887f, 0.02228779f, -0.00624697f, 0.04316805f, -0.04062911f, -0.02881887f, 0.00279918f, 
    0.03143021f, -0.03102051f, -0.00374478f, 0.02158874f, 0.02676371f, -0.03348920f, 0.03240265f, -0.03885939f, 
    0.03391593f, -0.00095642f, -0.00968277f, -0.01771237f, -0.02124586f, -0.00226997f, -0.03640419f, 0.00157735f, 
    0.00154602f, 0.01000356f, 0.02040897f, -0.01180041f, -0.01565197f, 0.01840911f, 0.01955553f, -0.00698285f, 
    0.02318371f, -0.02824506f, -0.03166854f, -0.03921170f, 0.02990235f, 0.03199194f, -0.02508315f, 0.00186824f, 
    0.02946061f, 0.01772049f, -0.02168405f, -0.02507405f, 0.01850535f, -0.02070749f, 0.00245307f, -0.00741988f, 
    -0.03271846f, -0.01105825f, 0.02619567f, -0.00652133f, 0.00731708f, -0.02280533f, -0.01428851f, 0.00183286f, 
    -0.03643354f, 0.00512264f, -0.02567538f, 0.00895965f, -0.02501474f, -0.03325899f, -0.00399894f, -0.00509699f, 
    -0.00835738f, 0.02219345f, -0.01342661f, 0.00489289f, -0.02234186f, -0.03842181f, -0.01565460f, 0.02688249f, 
    -0.04003426f, -0.04325427f, 0.00126827f, -0.03821739f, -0.00139193f, 0.00457474f, -0.02364787f, -0.00412950f, 
    -0.00749768f, -0.01975340f, 0.01844900f, -0.04500799f, 0.03025945f, -0.02255309f, -0.01846645f, -0.02029874f, 
    -0.00332098f, 0.01823064f, 0.02220377f, 0.00869830f, -0.02455538f, 0.00477514f, 0.01025736f, 0.00428257f, 
    -0.04358853f, 0.00880558f, 0.03141983f, -0.01950917f, -0.03047941f, 0.01443681f, -0.04052165f, 0.02549536f, 
    -0.02533198f, -0.02138584f, -0.03735030f, 0.01551781f, -0.03895916f, 0.00986241f, 0.01080321f, 0.03067435f, 
    -0.03129311f, -0.03619034f, -0.01381284f, 0.00219922f, -0.01930335f, -0.02902171f, -0.03281439f, -0.02005130f, 
    0.03281905f, -0.02452131f, 0.01427450f, 0.00934809f, 0.02021889f, 0.02077895f, -0.00932075f, -0.00905658f, 
    -0.01756578f, 0.00777414f, -0.02191561f, 0.02678464f, -0.00937615f, -0.03419818f, -0.00893459f, -0.04291256f, 
    -0.01559452f, 0.02443860f, -0.00440640f, -0.02457128f, -0.03022158f, 0.01002262f, -0.01922690f, 0.02979922f, 
    -0.01288333f, -0.02439298f, -0.01993657f, 0.01676876f, 0.01970221f, -0.04479486f, -0.02488343f, -0.03499690f, 
    0.02672854f, 0.00065715f, 0.00984642f, 0.02567878f, 0.02012490f, 0.03276364f, 0.02774221f, 0.00500011f, 
    -0.00943705f, -0.01574658f, 0.00193851f, -0.00041287f, -0.00927333f, -0.02729455f, 0.00370590f, -0.04422831f, 
    -0.03169839f, 0.02592380f, -0.01956455f, -0.01265813f, 0.00619722f, -0.03550579f, 0.03225274f, -0.02979776f, 
    0.01722233f, -0.03159553f, -0.04000168f, 0.03230648f, -0.03509837f, -0.03223385f, 0.00445412f, -0.02847516f, 
    -0.01620558f, 0.01143724f, 0.00202497f, 0.01771078f, -0.01522928f, -0.03629340f, 0.01540126f, -0.00702038f, 
    -0.02328628f, 0.00004397f, 0.00441089f, -0.01687818f, 0.01014267f, -0.04245292f, -0.02625539f, -0.03372221f, 
    -0.01530288f, 0.01031679f, 0.02567053f, 0.02691662f, -0.02920425f, -0.00356168f, -0.04500649f, -0.01250157f, 
    0.02211094f, 0.01005590f, -0.03235616f, -0.01967145f, 0.00199925f, 0.00092618f, -0.03940454f, 0.03166473f, 
    -0.03721396f, -0.03813878f, -0.02261335f, 0.00710575f, -0.04157856f, 0.00074160f, 0.00129234f, 0.01228458f, 
    0.03007144f, -0.00613739f, 0.00914474f, 0.01503472f, -0.04058718f, 0.02536851f, -0.00455175f, -0.03603867f, 
    0.02118951f, 0.01132036f, -0.00781270f, 0.00101947f, -0.00767591f, 0.00767261f, -0.01795939f, -0.00812573f, 
    -0.00492120f, 0.01658054f, 0.01887051f, -0.00223151f, 0.00961644f, 0.00000225f, -0.03972272f, -0.02092979f, 
    -0.02249724f, -0.03550972f, 0.02415961f, -0.04262998f, -0.00905073f, -0.01777925f, -0.03862461f, -0.01194194f, 
    -0.03231055f, 0.02852025f, 0.00973106f, -0.02080052f, 0.02512246f, -0.03310699f, -0.00329154f, -0.01668534f, 
    0.00532566f, -0.03472442f, 0.03003112f, -0.01531813f, 0.02533262f, 0.00870679f, -0.02398159f, -0.03330798f, 
    -0.02806245f, -0.02322284f, -0.04130871f, -0.00721169f, -0.03258018f, -0.03869010f, -0.02978751f, 0.02849497f, 
    -0.04488042f, -0.00007966f, 0.03218279f, 0.02773521f, 0.02760330f, -0.03993658f, -0.00617449f, -0.00780304f, 
    -0.00351830f, 0.00700048f, 0.02687747f, -0.02102844f, 0.00819278f, -0.02954156f, 0.02968226f, 0.02559985f, 
    0.01802346f, 0.02780135f, 0.03001352f, 0.00287527f, -0.01811868f, -0.03448654f, 0.03315979f, 0.01974767f, 
    -0.00230399f, 0.00863285f, -0.01249819f, -0.00753555f, 0.03119441f, -0.01477416f, -0.02187414f, 0.02786743f, 
    0.02189224f, -0.01996665f, 0.01755893f, 0.02376498f, -0.01569618f, -0.02083277f, 0.00146844f, -0.02918352f, 
    0.01573870f, 0.01798589f, -0.01076069f, 0.00123717f, 0.00133416f, -0.02097058f, 0.00310098f, -0.01992448f, 
    -0.00885213f, 0.00502170f, 0.00918503f, 0.03092950f, -0.03161655f, 0.01380168f, -0.04168084f, -0.00421802f, 
    -0.02981410f, 0.02939583f, 0.02618507f, 0.01459173f, -0.01949004f, 0.00318128f, 0.02080993f, -0.02700217f, 
    -0.02110266f, -0.02380922f, 0.00331204f, -0.03041317f, -0.00299801f, 0.00265457f, -0.03107404f, -0.04134952f, 
    0.00131715f, -0.01127820f, -0.03492858f, 0.01407612f, -0.01956097f, -0.01644164f, -0.03427266f, 0.01142721f, 
    0.02705248f, 0.03364233f, -0.01882996f, -0.00788849f, 0.00035564f, 0.03527162f, 0.00772898f, -0.03713546f, 
    0.02101548f, -0.01292010f, 0.02207765f, -0.01119824f, 0.02363474f, 0.02004035f, -0.00804526f, 0.01003614f, 
    0.01168026f, 0.01807827f, -0.01551050f, -0.02350465f, -0.00061011f, -0.00812231f, -0.02411228f, 0.02555918f, 
    -0.02072385f, 0.00290529f, -0.00297250f, 0.01083621f, 0.03587674f, -0.02246248f, 0.02320346f, -0.02600353f, 
    0.00807722f, -0.01203332f, 0.01455770f, -0.04357778f, -0.03582897f, -0.03390115f, 0.02216042f, -0.00159622f, 
    -0.02854482f, 0.03253334f, 0.00669521f, 0.01144492f, 0.00655285f, -0.00272207f, -0.04310907f, 0.00257628f, 
    0.01636430f, -0.02670778f, -0.03838940f, -0.02124551f, -0.02507410f, -0.01507812f, 0.01371731f, -0.02332028f, 
    0.01758060f, 0.02110119f, -0.00529474f, 0.01426296f, -0.03986422f, -0.04227572f, 0.02387988f, -0.03834181f, 
    -0.01233190f, 0.02142755f, 0.03069935f, 0.02152372f, 0.01611131f, -0.03448739f, -0.01003561f, 0.03117228f, 
    -0.02040623f, -0.01230492f, -0.03041516f, -0.03727477f, 0.00140110f, -0.04322189f, 0.01952355f, 0.01473197f, 
    0.02145038f, -0.04303201f, 0.02178575f, -0.04348621f, -0.03069731f, 0.02353430f, -0.01669168f, 0.00489545f, 
    -0.02143580f, -0.04464795f, 0.01995952f, 0.00337079f, -0.02732952f, -0.03693947f, -0.00478188f, -0.02181146f, 
    -0.04382036f, -0.03745878f, -0.00689743f, -0.00250977f, -0.03738236f, 0.00487119f, 0.02697607f, -0.03844673f, 
    -0.04298800f, 0.00708885f, -0.00365767f, 0.01517061f, -0.02805999f, 0.01816582f, -0.01263917f, 0.01442642f, 
    -0.01826443f, 0.03113870f, -0.02371209f, -0.04428785f, -0.00992304f, -0.03496937f, -0.00932339f, 0.01711400f, 
    0.00271210f, -0.03424629f, -0.03693048f, 0.00349195f, -0.03593999f, -0.03634838f, -0.01390542f, 0.03211579f, 
    -0.00449629f, -0.03251008f, 0.01049821f, 0.00797165f, -0.03846974f, -0.03812560f, -0.01286592f, 0.00776355f, 
    -0.03683411f, -0.00613519f, -0.03695565f, -0.00022595f, 0.03256992f, -0.04010844f, 0.00143584f, -0.01310544f, 
    0.01023481f, -0.03298418f, 0.00444433f, 0.00330115f, 0.02991402f, -0.04228118f, -0.03876740f, 0.00336002f, 
    -0.02231447f, -0.01112021f, -0.01921752f, 0.02990356f, 0.03655306f, 0.01460015f, -0.02831570f, -0.00413803f, 
    -0.02562246f, -0.03738385f, 0.02537625f, 0.02573910f, -0.03031015f, -0.03525382f, -0.00238340f, -0.00206649f, 
    -0.04202913f, -0.01484333f, 0.02666298f, 0.00124490f, -0.01123272f, -0.03256996f, 0.02201895f, 0.02003912f, 
    -0.03839102f, -0.03600790f, 0.02460261f, -0.03130934f, -0.03869654f, 0.00277169f, -0.01336335f, 0.01688787f, 
    -0.02624421f, -0.01798890f, 0.02980589f, 0.01063466f, 0.00396497f, -0.00549089f, -0.00720240f, -0.00141417f, 
    0.00727171f, -0.00207978f, -0.01938296f, 0.02950188f, -0.00064603f, -0.04438003f, -0.02730633f, -0.04137980f, 
    -0.02177453f, -0.01266738f, -0.00964797f, 0.01531450f, 0.03147974f, 0.01377277f, 0.00858074f, 0.02099588f, 
    -0.03496646f, -0.02168100f, -0.04080231f, 0.00437580f, 0.02024363f, 0.00939534f, -0.03514051f, 0.01735608f, 
    0.00002692f, 0.02201919f, -0.01708380f, -0.00708238f, -0.02789248f, 0.02482947f, -0.03890502f, -0.02989371f, 
    -0.03636725f, -0.02299832f, 0.02028794f, 0.00211764f, 0.01674445f, -0.00597631f, -0.03548010f, -0.04542912f, 
    -0.04317571f, -0.02665365f, 0.01574991f, -0.03559851f, -0.00073917f, -0.03383809f, 0.01011864f, -0.04441407f, 
    -0.03614688f, 0.00899063f, 0.00485330f, -0.01242520f, -0.04528024f, -0.03805314f, 0.00245709f, -0.00525618f, 
    -0.01322477f, -0.01092511f, -0.04216581f, -0.00908478f, 0.00247034f, 0.03227691f, 0.00606640f, -0.01823345f, 
    0.03178446f, -0.01545584f, 0.01235508f, -0.01185218f, 0.02082188f, 0.01052659f, 0.01957882f, -0.00040278f, 
    0.01653950f, 0.02593720f, -0.02279994f, -0.03202941f, 0.03186971f, 0.01752131f, 0.00644756f, 0.00018215f, 
    -0.01675583f, -0.00460561f, 0.01757134f, 0.00223278f, 0.01875632f, 0.00224097f, -0.00308718f, -0.01988980f, 
    0.00893857f, -0.03123297f, -0.00197830f, -0.03043446f, -0.01749825f, 0.01941888f, -0.01663227f, -0.02238217f, 
    -0.04243422f, -0.02566071f, 0.02714405f, -0.03088977f, -0.01877633f, -0.03158540f, -0.01669372f, -0.01591839f, 
    0.02789278f, -0.03687333f, 0.03326529f, -0.01248818f, -0.03320858f, -0.00497328f, 0.00672741f, -0.04174366f, 
    -0.02187199f, 0.02849741f, -0.02020575f, 0.01383121f, -0.01237054f, 0.01794451f, 0.02263254f, -0.04368753f, 
    -0.00723544f, -0.02258992f, -0.04387133f, -0.02607867f, -0.01781503f, -0.02252777f, -0.02155125f, -0.00193500f, 
    -0.22541672f, 0.02533264f, -0.04413969f, -0.04314729f, -0.03411643f, 0.18727221f, 0.05888334f, 0.17503549f, 
    0.12271184f, 0.06144328f, -0.18376982f, -0.04250088f, -0.07255428f, 0.13935082f, -0.07759634f, 0.04568802f, 
    0.15272692f, -0.17109102f, -0.09460584f, -0.11394526f, -0.26491302f, -0.20180495f, -0.11573502f, 0.06174169f, 
    -0.14520754f, 0.12689957f, -0.16500641f, 0.11046941f, -0.02196279f, -0.07558176f, 0.06894423f, 0.14717443f, 
    -0.01336490f, -0.00089448f, 0.06619909f, 0.13556705f, 0.01988024f, 0.08661188f, 0.10507430f, 0.07989484f, 
    -0.04215550f, -0.01331524f, -0.15119298f, -0.17690876f, -0.19606876f, 0.22023986f, 0.03561932f, 0.27383459f, 
    -0.14520545f, 0.04537563f, -0.17525883f, -0.07535084f, -0.02350549f, -0.00210839f, -0.00579403f, -0.01798519f, 
    0.10489704f, -0.07118745f, -0.05585885f, 0.09910925f, 0.15592402f, -0.21712443f, -0.04041708f, 0.01376067f, 
    0.22603798f, 0.04498241f, 0.15409721f, 0.15157184f, 0.06350657f, 0.04611961f, -0.04005086f, 0.02690553f, 
    0.10071940f, -0.05877260f, 0.11019500f, -0.14716157f, 0.01212711f, -0.12514360f, -0.01801831f, -0.04321932f, 
    -0.02473651f, -0.05706800f, 0.19353580f, -0.06015790f, -0.14330551f, -0.00292256f, 0.01767112f, 0.02234251f, 
    0.04762952f, -0.06507012f, -0.01715999f, -0.08192169f, -0.00729995f, 0.26739600f, 0.08827872f, 0.01658190f, 
    0.02178274f, 0.02960875f, 0.02762287f, 0.00557646f, -0.35674286f, 0.02166057f, -0.20819029f, 0.03603429f, 
    0.04767806f, -0.05310198f, -0.07706030f, -0.00080523f, 0.13266931f, 0.15847129f, 0.09187623f, 0.07422582f, 
    0.08078460f, 0.04759024f, 0.00359748f, -0.02052141f, 0.02951918f, 0.08107133f, 0.23837841f, 0.16483790f, 
    -0.01773174f, 0.14441547f, 0.10690510f, -0.04083278f, 0.19262120f, -0.00914788f, 0.12470987f, 0.06934608f, 
    0.05282847f, -0.01962529f, 0.05191147f, 0.02039256f, 0.01440285f, 0.13954559f, 0.05853766f, -0.03260424f, 
    -0.00951954f, -0.05669125f, -0.05749118f, -0.01640261f, 0.33471069f, 0.51840252f, 0.22237349f, -0.03585558f, 
    -0.05949431f, -0.08970030f, -0.03739881f, -0.17110305f, 0.05055332f, -0.00387827f, 0.20471010f, 0.13020508f, 
    0.00568498f, -0.05115935f, -0.03545663f, -0.07727706f, 0.01953435f, 0.15591232f, 0.11580225f, 0.12964995f, 
    0.17143287f, -0.21137333f, -0.07369850f, -0.21784267f, -0.06298043f, 0.04205579f, 0.02354092f, 0.02368095f, 
    0.09274421f, -0.04422680f, -0.11800320f, -0.15258607f, 0.00499127f, 0.06976620f, -0.04262291f, 0.08831710f, 
    0.05350839f, 0.00112418f, -0.02637567f, 0.08160888f, 0.16328685f, -0.28596327f, -0.05389657f, -0.07011248f, 
    0.01515397f, 0.03894065f, -0.04557579f, 0.15115435f, 0.04430861f, 0.02422008f, -0.03515774f, 0.00316038f, 
    -0.07491194f, -0.04207650f, 0.10476683f, 0.10597798f, 0.01599476f, 0.04725540f, 0.15915044f, 0.10902658f, 
    0.13073769f, -0.37463301f, 0.25104794f, -0.07931871f, -0.06182010f, 0.19269298f, -0.08261387f, 0.02658405f, 
    0.20290972f, -0.00673347f, -0.12743938f, -0.00606760f, -0.00394910f, 0.12112577f, 0.05769684f, 0.00747685f, 
    0.07319978f, 0.15259531f, 0.06523452f, 0.03563037f, 0.16413952f, -0.08831403f, 0.11209453f, -0.12441689f, 
    -0.25599757f, -0.19331142f, 0.20366760f, 0.09216256f, -0.07977270f, -0.16690500f, 0.03895234f, 0.07657696f, 
    -0.08870481f, -0.04314077f, 0.04988498f, 0.11591365f, 0.26706272f, 0.13289218f, -0.09671793f, 0.06717005f, 
    0.17495622f, 0.12662394f, 0.16832806f, 0.02350022f, -0.17526619f, -0.01201684f, -0.04145591f, 0.01993644f, 
    0.07267886f, 0.04118674f, 0.12467899f, 0.04413046f, 0.09038959f, -0.16845782f, 0.11749327f, 0.22289109f, 
    0.20609641f, -0.05247670f, 0.00639913f, 0.12757336f, 0.31725100f, -0.48076794f, 0.07834332f, -0.24680324f, 
    0.00412615f, -0.33611792f, -0.00902136f, 0.10082549f, -0.16114575f, -0.07631624f, 0.01436476f, 0.08901912f, 
    -0.09402525f, 0.05041029f, -0.10976014f, 0.05881352f, -0.04748515f, -0.00117291f, -0.10458967f, 0.01817792f, 
    -0.48641792f, 0.30262476f, -0.04915075f, 0.20077237f, -0.05131956f, 0.23204142f, -0.03137615f, 0.00109462f, 
    0.02578592f, -0.00440467f, -0.05958798f, -0.05091583f, 0.08287798f, 0.04190707f, 0.04813775f, 0.02697523f, 
    0.06167449f, -0.01589136f, -0.07479916f, -0.06814036f, 0.01801784f, -0.29405707f, -0.10207525f, 0.08258540f, 
    0.21005574f, 0.20421275f, -0.04909803f, 0.12280209f, -0.01337187f, 0.07881537f, -0.10782348f, -0.09044784f, 
    0.01421742f, -0.02126519f, 0.15746066f, -0.12489233f, -0.15719621f, 0.14344357f, -0.02359877f, -0.08704627f, 
    -0.61719102f, 0.28426319f, -0.40821037f, -0.06472963f, 0.08321602f, -0.17760879f, 0.12707546f, 0.08619216f, 
    -0.02105478f, 0.19482186f, 0.15399171f, 0.13060726f, 0.03180888f, -0.22997122f, 0.15251823f, 0.08039245f, 
    -0.02170036f, -0.01895443f, 0.01496371f, -0.05168555f, -0.00706552f, 0.04092673f, -0.27533120f, -0.22626716f, 
    -0.14917499f, -0.05606679f, -0.06971244f, 0.01093096f, 0.10579492f, -0.04906645f, -0.05332268f, -0.04782176f, 
    0.08098862f, -0.03676147f, -0.03712967f, 0.02477715f, 0.02291045f, 0.15021531f, 0.07167131f, 0.09425239f, 
    0.55484676f, -0.06059242f, 0.32038760f, -0.05146038f, -0.07103784f, -0.08654317f, 0.06079145f, -0.02453152f, 
    -0.00729951f, 0.13643235f, 0.20578760f, -0.04119021f, 0.10930005f, -0.06266589f, 0.07065623f, 0.09852569f, 
    -0.04034314f, -0.01426888f, -0.03222290f, 0.04303842f, 0.24109140f, 0.19700907f, 0.05890654f, -0.15312681f, 
    -0.02521834f, -0.03913311f, 0.15379056f, -0.05553028f, 0.02342772f, 0.01816842f, 0.13874070f, 0.17582992f, 
    -0.01254443f, -0.01113898f, 0.03734240f, -0.21430090f, 0.00962173f, -0.16848943f, -0.05136541f, 0.02540630f, 
    0.00289197f, -0.11354194f, -0.01383851f, -0.14809488f, -0.01577581f, 0.15213560f, 0.05446886f, -0.03862818f, 
    0.11062425f, 0.04164815f, 0.06192275f, -0.11976887f, -0.04459795f, 0.13101348f, -0.00765155f, 0.02547874f, 
    -0.04042652f, 0.05293280f, -0.09078269f, 0.07785035f, -0.44198951f, -0.05107995f, -0.14155360f, -0.06873786f, 
    -0.08170948f, 0.02766113f, -0.13832872f, 0.05164510f, 0.10474067f, -0.00152966f, -0.00737760f, 0.03600200f, 
    -0.11241230f, -0.03864681f, -0.05274360f, 0.01972535f, -0.05226231f, 0.01984778f, 0.01557030f, -0.04153272f, 
    -0.14120211f, 0.09533536f, 0.21726306f, 0.12651245f, 0.17294121f, -0.26493570f, -0.07627501f, -0.02184702f, 
    0.00415369f, 0.02511116f, 0.04814051f, 0.04102190f, 0.07899623f, 0.01747917f, 0.01734780f, 0.11391117f, 
    -0.02691224f, -0.01341526f, 0.00124452f, -0.01586669f, 0.65291905f, 0.17613350f, 0.24057806f, -0.15626626f, 
    -0.13838699f, -0.03017285f, -0.06108947f, -0.11382275f, 0.01803670f, 0.11460846f, 0.18478136f, -0.00582813f, 
    0.01946436f, 0.02244246f, 0.11873597f, 0.09552833f, 0.04776636f, -0.01423368f, 0.02098317f, -0.02493851f, 
    -0.04591114f, -0.15162309f, -0.15309118f, 0.13533916f, -0.15123688f, -0.14454927f, -0.22322167f, -0.07294445f, 
    -0.05316059f, -0.07767126f, 0.04507205f, 0.04148103f, 0.10927901f, 0.06054400f, 0.07318338f, 0.10579466f, 
    0.07593741f, 0.08377653f, 0.22493477f, -0.02943170f, -0.69899309f, 0.10545211f, -0.23846114f, 0.06070487f, 
    -0.10812157f, 0.20865194f, -0.13466378f, 0.02677979f, 0.00405360f, -0.02499284f, -0.04501063f, 0.02399088f, 
    0.17753910f, 0.04759040f, 0.07542346f, -0.00719848f, -0.02709804f, -0.04711737f, -0.06105508f, -0.05511192f, 
    -0.23449685f, -0.03995321f, 0.09807351f, -0.01247511f, 0.09384330f, 0.16195548f, 0.19493790f, -0.00076373f, 
    0.04506308f, 0.09036695f, -0.07466464f, -0.04050993f, 0.09820613f, 0.02684991f, 0.06191947f, -0.10106227f, 
    -0.04280638f, -0.04515131f, -0.05575028f, -0.06395464f, 0.02172628f, -0.10273287f, 0.13302699f, 0.11056437f, 
    0.01088840f, 0.16884844f, -0.03452245f, 0.16085371f, 0.11315325f, -0.10595276f, 0.00854735f, -0.02897356f, 
    0.05651147f, 0.09678230f, 0.05516715f, 0.05430437f, 0.06754158f, 0.11468476f, -0.11873250f, 0.04099410f, 
    0.07209168f, 0.00036185f, 0.03794929f, 0.07409074f, 0.19581389f, 0.02119849f, 0.01081717f, -0.02303820f, 
    0.07110868f, 0.04989576f, 0.07494837f, 0.02370835f, 0.03028592f, 0.02525790f, 0.09226129f, -0.18976070f, 
    -0.05482838f, 0.09289680f, 0.25542736f, 0.02126258f, -0.02908566f, -0.00911431f, 0.15471476f, 0.12253929f, 
    0.00198799f, 0.22666188f, 0.11115851f, 0.20861594f, 0.08429369f, 0.14447986f, -0.03166148f, -0.01843538f, 
    0.09465840f, 0.09598130f, 0.08796213f, 0.01088963f, 0.05112730f, -0.03584687f, -0.06961679f, 0.01140422f, 
    0.46261543f, -0.23062494f, 0.07575166f, -0.07793810f, -0.18373466f, 0.19636749f, -0.07384444f, 0.15228553f, 
    0.06792504f, 0.08196671f, 0.02134893f, 0.09525526f, -0.03550223f, 0.17090936f, -0.07792322f, 0.23434126f, 
    0.13369584f, 0.07296868f, -0.01463848f, -0.11740550f, -0.07402249f, 0.36830962f, 0.19883348f, 0.19857769f, 
    -0.05868927f, 0.12572864f, 0.08454123f, 0.10096429f, -0.02027037f, 0.06472415f, 0.05545807f, -0.11432356f, 
    0.16495505f, 0.06773991f, 0.03937203f, 0.01415392f, 0.06632598f, 0.04299654f, -0.06306206f, 0.01332567f, 
    0.33521029f, 0.08888056f, 0.04805632f, -0.22117178f, -0.17280254f, 0.05573701f, 0.06889306f, -0.01259769f, 
    -0.01053544f, -0.05191978f, 0.09639880f, 0.09002604f, -0.06298458f, -0.00116929f, -0.09361396f, 0.05863930f, 
    0.02667209f, -0.03628080f, 0.03047692f, 0.04520759f, 0.00185442f, -0.01043611f, 0.12518430f, 0.01855097f, 
    -0.11623450f, -0.05183806f, 0.07863164f, -0.00580742f, 0.09361391f, 0.04966973f, 0.03114201f, 0.02637010f, 
    0.04024137f, -0.01865366f, 0.02235887f, 0.14956032f, -0.06266443f, 0.08536845f, -0.04979264f, -0.01737035f, 
    0.15753588f, 0.11560558f, -0.05542962f, 0.12958319f, -0.26169991f, -0.02429079f, 0.20269719f, 0.07666353f, 
    0.14953659f, 0.03572964f, 0.03225791f, 0.02338001f, 0.10857375f, 0.13368052f, -0.05368468f, 0.08044418f, 
    0.05287627f, -0.11473744f, -0.03257094f, -0.07642397f, 0.22238025f, 0.06304032f, 0.17593563f, -0.19124518f, 
    0.33092526f, -0.02242262f, 0.01959483f, 0.02132137f, -0.04801410f, -0.10882261f, -0.03632448f, -0.07050537f, 
    0.01195616f, 0.07527091f, -0.05805695f, -0.00075267f, 0.04445925f, -0.16433950f, 0.01803821f, -0.02132281f, 
    -0.05982709f, -0.08886439f, 0.09118598f, -0.27053970f, 0.09242311f, 0.01455462f, -0.06817497f, -0.01706639f, 
    0.01436898f, 0.15686451f, -0.09474409f, 0.12960468f, -0.01901174f, -0.05127699f, -0.03424003f, 0.16629204f, 
    -0.12993202f, -0.03754133f, -0.09611483f, -0.14942099f, -0.11788508f, -0.08532652f, 0.01290488f, 0.21346381f, 
    0.05159236f, 0.00852907f, 0.04605882f, -0.04877112f, 0.03655828f, -0.04397610f, 0.06194535f, 0.07159470f, 
    -0.03105950f, 0.06928905f, 0.02700353f, -0.01768066f, -0.04300898f, -0.06903914f, 0.15131761f, -0.08877617f, 
    0.13480990f, 0.26595071f, 0.26193652f, -0.10765027f, 0.04216393f, -0.01127242f, 0.10236128f, -0.00159577f, 
    0.00678004f, -0.10564683f, -0.02221272f, -0.01992325f, 0.02652013f, 0.07600553f, 0.01832162f, 0.07482181f, 
    -0.10904208f, -0.15067694f, 0.04113038f, 0.06856112f, 0.30271053f, -0.02624514f, -0.32674882f, -0.01381549f, 
    0.53466809f, -0.01705017f, -0.01595940f, -0.00690128f, -0.02517462f, -0.07276553f, 0.00594440f, 0.11236614f, 
    -0.06813227f, -0.19279163f, -0.02559868f, -0.05995863f, 0.09514990f, 0.15337172f, 0.08950555f, 0.08562292f, 
    0.32436138f, 0.16349971f, 0.20171197f, 0.32385474f, 0.02312457f, 0.02346076f, 0.00269422f, -0.19256650f, 
    0.12302935f, 0.04552725f, 0.08342004f, -0.08114958f, 0.03602947f, 0.09494691f, 0.00130612f, 0.06889632f, 
    0.06324516f, 0.00256958f, 0.06667011f, -0.02122482f, -0.21659853f, -0.22382662f, -0.06647780f, 0.14560235f, 
    -0.20499694f, -0.00004201f, 0.08509965f, -0.01501284f, -0.03122896f, 0.01480196f, 0.04283573f, 0.05194559f, 
    -0.01395321f, -0.05188921f, -0.01807621f, -0.02704336f, -0.03083735f, -0.02781187f, 0.04547425f, 0.05565136f, 
    -0.09335102f, -0.04148351f, -0.03733990f, -0.05159257f, -0.25612247f, 0.10703084f, 0.18956690f, -0.04945572f, 
    -0.01259571f, -0.11991043f, 0.08121250f, -0.00055176f, -0.04628181f, 0.01086203f, -0.06836165f, -0.12440290f, 
    0.14770718f, -0.00480284f, 0.01400510f, -0.03459561f, 0.26938173f, -0.04966516f, -0.18857749f, -0.53083676f, 
    0.35930458f, 0.00951525f, 0.00463695f, 0.06830220f, -0.09764691f, 0.09155756f, 0.07321133f, -0.03438710f, 
    0.06072865f, -0.00624766f, -0.10173817f, 0.03077096f, 0.11140247f, 0.17857251f, -0.01775761f, 0.03475772f, 
    0.39319971f, -0.11161749f, -0.23278058f, 0.14377999f, 0.24416511f, -0.18521816f, -0.05567565f, 0.05146709f, 
    -0.03246583f, -0.08259051f, -0.05197527f, 0.04043012f, 0.02512303f, -0.02804407f, -0.05969824f, 0.02220800f, 
    0.08213789f, 0.00253927f, -0.05638785f, 0.13303153f, -0.00608462f, -0.01743455f, -0.03795862f, -0.10699113f, 
    -0.01944007f, 0.01391863f, -0.13540550f, -0.04813844f, 0.00603741f, 0.08652590f, 0.02796926f, 0.00355480f, 
    0.01541456f, 0.04772155f, 0.02025784f, 0.21146412f, 0.03701640f, -0.07397728f, 0.15458384f, -0.09260189f, 
    -0.05285122f, 0.03149700f, 0.20539790f, 0.13676961f, -0.14119667f, -0.02192423f, -0.01464349f, 0.03837649f, 
    0.03624959f, 0.23439117f, -0.03823712f, 0.05300330f, 0.00139022f, 0.12301774f, 0.08049996f, 0.09811963f, 
    0.02148090f, 0.14019355f, 0.03692684f, -0.00587238f, 0.16727395f, 0.12766163f, 0.02169064f, -0.10299931f, 
    0.00695783f, -0.05812562f, -0.07115760f, -0.04808344f, 0.04417307f, -0.12137856f, 0.07559675f, 0.13984057f, 
    0.08637501f, -0.04767885f, 0.06668896f, -0.13008954f, -0.04570010f, -0.02642383f, -0.06293850f, 0.03533220f, 
    0.25700995f, -0.08379479f, 0.08726671f, 0.29254124f, -0.12167533f, -0.26272470f, 0.02891097f, -0.09928268f, 
    -0.00438575f, 0.05618127f, -0.00092602f, -0.01976627f, 0.03879606f, -0.04740986f, -0.02255096f, 0.08080600f, 
    -0.03401851f, -0.02915068f, 0.13058081f, -0.11114020f, 0.49822444f, 0.10684039f, 0.18993755f, 0.46031103f, 
    -0.08331723f, -0.11475387f, 0.07225399f, -0.05026850f, 0.06222764f, 0.12438972f, 0.12555185f, -0.03543702f, 
    0.06651178f, -0.03295992f, 0.06617810f, -0.01496032f, 0.00668404f, 0.04105971f, 0.12155516f, -0.03421970f, 
    0.32832095f, -0.13695776f, 0.22185484f, -0.04187593f, 0.26578826f, 0.01045703f, -0.01665257f, 0.09932083f, 
    0.05802794f, 0.06415998f, 0.06015432f, 0.00484314f, 0.02630806f, 0.06639238f, 0.02651724f, -0.08387317f, 
    -0.00781960f, -0.15878601f, -0.04664292f, -0.10062397f, 0.30957887f, -0.01599593f, -0.18810321f, -0.13691792f, 
    0.03496602f, -0.01549259f, -0.08008674f, 0.08345129f, -0.02976970f, -0.20150864f, 0.05016661f, -0.00711162f, 
    0.02036299f, -0.06136919f, -0.01521202f, -0.07072397f, -0.02133680f, -0.12079555f, -0.03296502f, 0.06219140f, 
    0.22712375f, 0.25592434f, 0.12296969f, 0.31031790f, -0.03069532f, 0.04604309f, -0.09963433f, -0.10177359f, 
    0.06479713f, 0.12058171f, 0.09863783f, -0.09870102f, -0.08527364f, 0.03161978f, 0.01456551f, -0.02080915f, 
    -0.09223885f, 0.14074445f, -0.03362996f, 0.04527456f, 0.05463168f, -0.27250597f, 0.22867511f, 0.18477505f, 
    0.09995356f, -0.09830654f, -0.08246178f, 0.02183437f, 0.14793640f, 0.24332276f, -0.11060189f, -0.04858986f, 
    -0.08227947f, 0.05694983f, 0.04636957f, -0.10141293f, 0.03897213f, -0.02475031f, 0.15521076f, -0.03603348f, 
    0.06575003f, 0.18350552f, 0.03461523f, 0.00099851f, 0.08744747f, -0.07540806f, 0.04810201f, -0.04592192f, 
    0.00525013f, 0.00562778f, -0.00330220f, -0.15307260f, -0.01326865f, 0.01246620f, -0.10279314f, -0.03719214f, 
    0.02751493f, -0.10030816f, 0.07828333f, 0.02330316f, 0.31077087f, -0.15117201f, -0.05443701f, -0.13527666f, 
    0.39864150f, -0.10601848f, -0.00866131f, 0.02521616f, -0.04301617f, -0.06978691f, -0.03863329f, -0.08226237f, 
    -0.00874546f, -0.01556812f, 0.00249729f, 0.02829002f, -0.05565346f, -0.06601283f, -0.02314705f, 0.03285401f, 
    -0.09568736f, -0.01503010f, 0.10071216f, -0.04186214f, -0.22039834f, -0.12606475f, -0.04554109f, -0.07612953f, 
    0.00556508f, -0.02469716f, 0.04662602f, -0.04448896f, 0.05704198f, 0.12907839f, -0.08985282f, 0.12155452f, 
    0.04331366f, 0.05695667f, 0.05131599f, 0.09604346f, 0.34913012f, 0.16136630f, -0.14493661f, 0.11020599f, 
    -0.30839375f, -0.03454684f, 0.17591651f, 0.03262079f, 0.14594354f, 0.14201197f, -0.04286270f, 0.10635965f, 
    -0.13224129f, 0.04875605f, 0.06495468f, 0.04063494f, -0.13115169f, 0.17257410f, 0.14996132f, -0.07269196f, 
    0.04240349f, 0.42335933f, 0.26714998f, -0.01290413f, 0.17170931f, 0.03653722f, -0.10263254f, -0.03737199f, 
    -0.02384954f, 0.01393550f, -0.02206381f, 0.02198043f, 0.06678100f, -0.11057203f, -0.05282018f, -0.02879103f, 
    -0.08714562f, -0.09759599f, 0.10490422f, 0.13627762f, 0.03682018f, 0.04223546f, 0.25600162f, -0.01750812f, 
    -0.34023201f, -0.04415994f, -0.00050953f, -0.05884511f, 0.01556425f, -0.06622466f, -0.19346751f, 0.00593649f, 
    -0.06262369f, -0.03711753f, 0.10412165f, -0.07497961f, 0.01635602f, 0.04348087f, -0.03705905f, -0.16133362f, 
    -0.31079197f, -0.21588302f, -0.22432551f, 0.12206474f, -0.01434316f, 0.03276484f, 0.05948223f, 0.03204843f, 
    -0.09226210f, -0.08702818f, 0.03135227f, 0.06799222f, 0.05078247f, -0.10348363f, -0.05552382f, -0.11529928f, 
    0.00349050f, -0.01431767f, 0.12921552f, -0.02257194f, -0.07040262f, 0.05726580f, -0.02398689f, 0.02117876f, 
    -0.04366843f, -0.05248664f, -0.07171205f, 0.02656717f, -0.01542060f, 0.09468822f, -0.02335855f, 0.06828260f, 
    -0.00184155f, -0.01732505f, -0.04824761f, 0.07393999f, 0.05678685f, -0.05421166f, 0.00719769f, 0.00529893f, 
    0.52090847f, -0.17049225f, -0.20753784f, -0.25147036f, -0.00316768f, -0.02448065f, 0.12416544f, 0.00978992f, 
    0.06142163f, -0.12666661f, 0.06039027f, -0.01987834f, 0.04515974f, -0.05037711f, -0.08260217f, 0.11483272f, 
    -0.07859287f, 0.10170846f, 0.03162739f, 0.09205612f, 0.41621515f, -0.00594895f, 0.11699203f, -0.20003057f, 
    -0.11231864f, -0.14798953f, 0.01903631f, 0.09283477f, 0.14367008f, 0.04696207f, 0.05266342f, 0.00528615f, 
    0.08163702f, -0.00853530f, 0.10479790f, -0.07094847f, -0.07483374f, -0.00105348f, -0.02121376f, -0.04914398f, 
    0.03260712f, -0.00233074f, 0.03217198f, 0.02491942f, 0.01477270f, -0.04078504f, -0.01386364f, 0.02861726f, 
    0.00367087f, 0.00050263f, 0.03000453f, 0.01968432f, -0.00094005f, -0.00094239f, 0.02088764f, -0.02672912f, 
    -0.00362429f, -0.02197421f, -0.01269486f, -0.03674963f, 0.02843066f, 0.00129028f, 0.03390654f, -0.02782100f, 
    -0.00542317f, 0.02344063f, 0.02292125f, -0.01063939f, 0.02244611f, 0.01573808f, -0.02137295f, 0.00041390f, 
    -0.00937837f, 0.02590251f, -0.02117289f, 0.01824023f, 0.02030688f, -0.00942826f, -0.03914049f, 0.00923739f, 
    0.00425297f, -0.00740113f, -0.03691703f, 0.02369377f, -0.02433396f, -0.02125699f, 0.01002778f, -0.01120493f, 
    -0.02123778f, 0.01903804f, -0.01800786f, -0.02491212f, 0.01884778f, 0.00965380f, -0.01093354f, 0.00706269f, 
    -0.00396673f, -0.00541721f, -0.02788555f, -0.03995919f, 0.03292851f, -0.02808864f, 0.03145067f, 0.01176406f, 
    0.02495779f, -0.00779184f, 0.00375129f, -0.03418450f, -0.01439175f, 0.00142418f, -0.02296357f, 0.01134447f, 
    -0.00441012f, 0.02266183f, 0.03195517f, 0.03415244f, 0.01313113f, 0.02800795f, -0.00472626f, -0.03569610f, 
    -0.02263039f, 0.00671933f, 0.01360414f, -0.03727974f, 0.01448144f, -0.00979273f, -0.00118299f, -0.02598965f, 
    -0.01859834f, -0.02333961f, -0.01173917f, -0.03185548f, -0.00787668f, -0.01511928f, -0.02191210f, -0.00277160f, 
    -0.01996272f, 0.00067600f, -0.00651948f, -0.03290477f, 0.00159827f, -0.02766586f, -0.03362953f, 0.03514219f, 
    -0.00309244f, -0.03475535f, -0.01919959f, 0.01767350f, 0.02646036f, -0.03523013f, 0.03319070f, 0.01604413f, 
    -0.00380585f, -0.03969670f, -0.02258273f, -0.00359916f, -0.01817190f, -0.03098802f, 0.03078041f, 0.02788179f, 
    0.02169540f, -0.00954864f, 0.02661078f, 0.00308139f, -0.03871891f, -0.02211902f, -0.00068521f, -0.03805745f, 
    -0.03861114f, 0.02715849f, 0.01354158f, 0.02488004f, 0.01226275f, -0.03657499f, 0.00277263f, 0.01674069f, 
    0.00655355f, -0.03969022f, 0.02401341f, -0.03777327f, 0.01835754f, 0.03357211f, 0.01250287f, 0.01306521f, 
    -0.02599059f, 0.00820842f, -0.00715437f, -0.00144135f, -0.01303376f, 0.02597476f, -0.03831851f, -0.03340306f, 
    -0.01195019f, -0.04188436f, 0.00891657f, 0.01776649f, 0.00530926f, -0.02017222f, 0.02202934f, 0.02054163f, 
    0.01994915f, -0.01517006f, 0.03504475f, -0.02229184f, 0.02096528f, -0.02481366f, -0.03353086f, -0.04002377f, 
    -0.01368447f, 0.02185139f, -0.01663491f, -0.03668124f, 0.00960079f, -0.04008779f, -0.00627336f, 0.02462215f, 
    -0.03073315f, 0.01480663f, -0.04008264f, 0.00680691f, -0.02492373f, -0.00387470f, -0.03095991f, 0.03057473f, 
    -0.01629310f, 0.01741109f, 0.03278944f, 0.00788201f, 0.02238967f, -0.00420822f, -0.00591077f, -0.03842567f, 
    -0.02442092f, 0.00998974f, 0.03408927f, -0.02466725f, 0.00533543f, -0.02583406f, -0.02641049f, -0.00782339f, 
    0.03500857f, -0.02703977f, 0.01438207f, 0.02955478f, 0.00088825f, 0.01525637f, -0.01837831f, -0.03056303f, 
    0.03473557f, 0.01545682f, -0.00567944f, -0.00989979f, -0.02814147f, 0.01489929f, -0.01948852f, 0.00256781f, 
    -0.02590952f, 0.02580096f, -0.00110159f, -0.01190253f, -0.00274721f, -0.03856154f, 0.03294314f, 0.02895384f, 
    0.03780841f, 0.00423804f, -0.02913001f, -0.02328558f, -0.00123051f, -0.00682451f, -0.02414422f, -0.03662273f, 
    0.00824719f, 0.00878842f, -0.00221142f, -0.00151568f, -0.00817001f, -0.03278184f, 0.03437633f, 0.00083295f, 
    -0.00457985f, 0.03013722f, -0.04719092f, -0.01123254f, -0.01602527f, -0.00538290f, -0.01425536f, 0.01275709f, 
    0.01449317f, 0.00192593f, -0.02312235f, 0.00164708f, 0.01569133f, 0.00885071f, -0.03416314f, -0.00134930f, 
    -0.02926228f, -0.01293517f, 0.02795665f, -0.02772710f, -0.00647277f, -0.00237699f, -0.03463573f, -0.02887989f, 
    -0.01672870f, 0.01776641f, -0.00988366f, 0.02329530f, 0.01901199f, -0.02120925f, 0.01908541f, 0.01022495f, 
    -0.01531894f, 0.01807280f, 0.00122610f, 0.00929154f, 0.02262998f, 0.02019803f, -0.02289456f, 0.01876616f, 
    -0.00065470f, 0.01222060f, 0.01979729f, -0.01016018f, 0.02838071f, 0.00545346f, 0.01647957f, 0.01888317f, 
    0.02659486f, -0.04218526f, -0.03541148f, 0.03133820f, -0.03046747f, 0.03342332f, -0.03951497f, 0.03266161f, 
    0.02393049f, -0.00017734f, 0.00465906f, 0.00195895f, 0.02024706f, 0.00859930f, -0.03641305f, 0.03085371f, 
    0.01547227f, -0.03100303f, -0.02488725f, 0.00396910f, -0.02506238f, -0.00981565f, 0.02208932f, 0.03868502f, 
    0.01042984f, 0.00369475f, -0.03524769f, -0.03787846f, -0.00601525f, 0.04021180f, -0.03785103f, -0.03917043f, 
    -0.01056270f, 0.00606921f, -0.02492480f, 0.00680186f, 0.02530080f, -0.03358231f, 0.00800301f, -0.01282229f, 
    0.01910285f, -0.02185410f, -0.00477167f, -0.00889027f, -0.03598011f, -0.00001303f, -0.04441516f, 0.00392492f, 
    0.01929328f, -0.04250168f, 0.01316489f, -0.01422497f, 0.01407137f, 0.02742320f, -0.00495818f, -0.02639762f, 
    0.02590904f, -0.01703780f, 0.01252152f, -0.01752049f, -0.02755807f, 0.00044192f, -0.02626258f, -0.01308863f, 
    0.01207574f, -0.02802667f, -0.01213758f, -0.02638764f, -0.01313192f, -0.01698647f, 0.00528955f, 0.01564066f, 
    0.03133996f, -0.01554916f, -0.03453039f, 0.00644866f, -0.04116331f, 0.03385586f, -0.02324721f, 0.01933321f, 
    0.01437235f, -0.01946487f, 0.02394157f, -0.01926333f, 0.00763834f, -0.00901816f, 0.00583142f, -0.02556293f, 
    -0.02584589f, -0.04374451f, 0.00294983f, 0.02942363f, -0.02385603f, 0.03055392f, 0.02204237f, 0.00026577f, 
    0.03237266f, -0.01544422f, 0.03484963f, 0.01516289f, 0.01605837f, 0.01176781f, 0.01348728f, -0.01172606f, 
    -0.02773602f, -0.01022141f, 0.00185665f, 0.03028430f, -0.01926224f, -0.00101259f, -0.03368903f, 0.03414217f, 
    0.04508480f, 0.03213543f, 0.00604327f, -0.04501071f, 0.02614503f, -0.02147073f, 0.00905089f, 0.01757680f, 
    -0.01281217f, -0.02348069f, 0.00471426f, -0.02577573f, -0.04339681f, 0.00227526f, -0.00286160f, 0.02469231f, 
    0.00498538f, 0.01816129f, 0.01140174f, 0.01630985f, 0.03162945f, -0.01800298f, 0.02426126f, 0.01971070f, 
    -0.04909781f, 0.03373865f, -0.00496055f, -0.03308655f, 0.00004667f, 0.02112891f, -0.00099059f, 0.01693385f, 
    0.02759782f, -0.01724345f, -0.01620870f, -0.01045745f, -0.01852817f, -0.02482598f, 0.01274987f, -0.03242967f, 
    0.02789718f, 0.01490618f, 0.00031884f, -0.03110811f, -0.01793248f, -0.02151339f, 0.01287592f, 0.00783359f, 
    -0.00630982f, 0.01004813f, -0.03133279f, -0.02031015f, -0.00198651f, -0.01153831f, -0.03209854f, 0.02751228f, 
    0.03094612f, -0.02573193f, -0.01414314f, -0.02921121f, -0.03539314f, 0.00632775f, -0.03018282f, -0.03685850f, 
    0.03912153f, -0.02046585f, -0.00529144f, 0.00714551f, -0.02734483f, 0.00791839f, -0.02030141f, 0.01037784f, 
    -0.03753796f, 0.02630901f, 0.01452803f, -0.01735359f, 0.00402607f, 0.00517279f, -0.02367710f, 0.00188721f, 
    -0.01253133f, 0.02090898f, 0.00309151f, 0.01281982f, -0.03078985f, 0.00758560f, 0.02794380f, 0.00614727f, 
    -0.00394036f, 0.01207696f, -0.02402502f, 0.00781202f, -0.01172665f, -0.02305578f, -0.04278370f, -0.03862893f, 
    0.01229142f, 0.00079645f, 0.00374103f, 0.01444709f, 0.03408121f, 0.04415984f, -0.01373245f, -0.04655477f, 
    -0.04015357f, 0.02391124f, -0.00960725f, -0.01224714f, -0.01276120f, 0.01144876f, 0.02255468f, -0.03327729f, 
    -0.00730846f, 0.02529719f, -0.03327768f, 0.00194026f, -0.02638646f, -0.02745577f, 0.02079912f, 0.02490162f, 
    0.04019149f, 0.01396692f, 0.01855275f, -0.01283300f, 0.00930227f, -0.01024358f, -0.00147364f, 0.03057828f, 
    -0.04740913f, -0.00192980f, -0.01615343f, 0.02974264f, 0.01302868f, 0.02999693f, -0.02156187f, 0.02982481f, 
    -0.03485207f, 0.02530137f, 0.03436320f, -0.04053767f, -0.00645279f, -0.00281102f, -0.00893761f, -0.04317772f, 
    -0.01208500f, -0.03941984f, -0.00833024f, 0.01861579f, 0.03475708f, -0.04080478f, 0.01652222f, 0.03264982f, 
    -0.00430614f, -0.03688744f, 0.01260694f, 0.00134197f, -0.03623349f, 0.00053398f, -0.02180620f, -0.02902255f, 
    0.01140187f, 0.02361967f, -0.01047516f, -0.01513870f, -0.02988262f, 0.01289381f, -0.02181070f, -0.04288077f, 
    -0.01851367f, -0.02708821f, -0.02943377f, 0.01607647f, 0.01686855f, 0.02097666f, 0.03368288f, -0.01098078f, 
    -0.02763116f, -0.02290856f, -0.01985054f, 0.01435524f, -0.03920260f, -0.00639879f, -0.02255109f, 0.01224666f, 
    -0.00393003f, -0.03862167f, -0.02699483f, -0.03506184f, -0.03276043f, -0.00725246f, -0.00314069f, 0.02075319f, 
    0.02878026f, 0.00253076f, -0.01075631f, -0.00323464f, 0.03696398f, -0.00008774f, 0.03541030f, 0.00955598f, 
    -0.02188971f, 0.01785891f, -0.03257553f, -0.02869866f, -0.01641201f, -0.01113948f, -0.01678506f, -0.02735979f, 
    -0.02349528f, 0.03157703f, -0.02027529f, -0.03025378f, -0.01007835f, -0.01141219f, -0.02643532f, 0.00074810f, 
    0.01747075f, -0.02691732f, -0.00875147f, 0.00891648f, 0.02534229f, 0.03148333f, -0.03011899f, -0.02118896f, 
    0.02610427f, -0.00429893f, -0.02333095f, 0.00753216f, -0.01373955f, 0.00690767f, -0.03378930f, 0.02469015f, 
    -0.02185364f, 0.03118731f, -0.03691006f, -0.02581571f, 0.01152737f, 0.01028493f, -0.02304162f, -0.01512665f, 
    0.01001912f, 0.03240747f, -0.00621522f, -0.03327347f, 0.02238776f, -0.00231181f, 0.00212302f, 0.00841427f, 
    -0.03427418f, -0.03893698f, 0.00622520f, -0.00696766f, -0.02267618f, -0.02002435f, -0.00517991f, -0.03550123f, 
    -0.04352569f, -0.01401524f, -0.01222047f, -0.04522065f, 0.03153815f, -0.00236760f, -0.01846540f, -0.00916621f, 
    0.01843785f, -0.00296807f, 0.02309781f, -0.00093075f, 0.00929786f, -0.01249342f, -0.01946082f, -0.00657344f, 
    -0.03742443f, 0.03341990f, -0.00929406f, -0.01569011f, 0.00689894f, -0.03393337f, -0.03257687f, -0.03603926f, 
    0.03112881f, -0.00195349f, -0.00308320f, 0.00839550f, 0.02387040f, 0.01726833f, 0.02850947f, 0.01034224f, 
    -0.03336345f, 0.02133252f, 0.03003989f, -0.03962477f, -0.02925047f, -0.02766521f, 0.03105695f, 0.02440255f, 
    -0.04015092f, -0.03208714f, -0.03416776f, -0.01246291f, -0.03519810f, 0.01879260f, -0.00160820f, 0.02176861f, 
    -0.03778550f, -0.04433273f, -0.01084574f, -0.00523803f, 0.02346500f, 0.01506327f, -0.03781870f, -0.00448129f, 
    0.02323495f, -0.02101165f, -0.01530127f, 0.01591184f, -0.00989322f, -0.01352980f, 0.02205109f, 0.01948596f, 
    0.02064985f, -0.03111123f, 0.03301648f, 0.00108169f, -0.03151822f, 0.01772252f, -0.04156936f, -0.00699792f, 
    0.03121698f, 0.02879941f, -0.04187931f, 0.01658537f, -0.01512084f, -0.00959163f, 0.01246532f, -0.00079873f, 
    0.03081314f, -0.01406225f, 0.00289894f, 0.02287221f, -0.00256242f, 0.02205833f, -0.02971683f, 0.02179690f, 
    0.02033819f, -0.00579828f, -0.01840310f, -0.04078441f, -0.02218914f, 0.02536133f, -0.00363174f, -0.02531962f, 
    -0.04200463f, 0.00678645f, 0.02016786f, -0.03714544f, 0.03269023f, -0.01746829f, -0.03922063f, 0.02440178f, 
    -0.00306181f, 0.02950583f, -0.00018244f, -0.03887498f, -0.03247239f, -0.01027337f, -0.03147033f, 0.03297592f, 
    -0.00149035f, 0.00157376f, -0.04440803f, -0.01790116f, -0.00201796f, -0.04508680f, 0.02431543f, 0.03142654f, 
    -0.00299070f, -0.01751097f, -0.02248742f, 0.02885784f, 0.00168241f, -0.00027622f, -0.04094812f, -0.01271819f, 
    -0.00765666f, 0.00611273f, -0.03678435f, -0.02386254f, 0.02128796f, 0.00223663f, -0.02039313f, -0.01794582f, 
    -0.00823143f, 0.03292548f, 0.02712900f, -0.03973414f, 0.01149048f, -0.03094256f, 0.00817612f, 0.00178249f, 
    -0.03564970f, -0.02838694f, -0.01561682f, -0.01242890f, 0.00441628f, -0.02482904f, -0.01013066f, 0.02017186f, 
    0.01031792f, 0.01216680f, -0.01780456f, -0.04064903f, 0.02394523f, -0.01998973f, -0.02581043f, -0.01875813f, 
    0.03131677f, 0.00697883f, -0.03838696f, 0.00543837f, -0.01732982f, -0.02922953f, 0.03238981f, -0.04296943f, 
    0.03000397f, -0.03777028f, 0.02819070f, 0.01412588f, 0.00343283f, -0.04084522f, 0.02525631f, 0.02165074f, 
    -0.01081514f, 0.01256136f, 0.01529329f, 0.00131683f, 0.00439457f, -0.03123039f, 0.00613778f, -0.02696225f, 
    0.01139036f, 0.01623512f, -0.03126710f, -0.02612535f, -0.01626568f, -0.01724766f, 0.00810847f, -0.00619544f, 
    -0.03589016f, 0.02638630f, -0.03603415f, 0.02753968f, -0.00051303f, -0.02054438f, -0.01461044f, -0.02034057f, 
    -0.02594024f, 0.03381676f, -0.02118754f, 0.02186502f, -0.02457807f, -0.02457153f, 0.00458963f, 0.02969340f, 
    0.02037381f, -0.02782512f, -0.04226743f, 0.02038418f, -0.01588125f, -0.02387426f, -0.01448687f, -0.01957344f, 
    -0.01971286f, -0.02316209f, -0.03664428f, -0.00879633f, -0.04359321f, -0.00364372f, 0.03361707f, -0.01500379f, 
    -0.00802387f, -0.01458413f, -0.00544882f, 0.02246372f, 0.02947358f, 0.00511446f, 0.02686490f, 0.00640961f, 
    -0.00703462f, 0.03056922f, -0.04479386f, -0.01300535f, -0.02710831f, 0.03301380f, 0.03010269f, -0.01785477f, 
    0.00788519f, -0.00773029f, 0.03339547f, 0.00328906f, 0.00893413f, -0.00783256f, -0.00856315f, -0.02785754f, 
    -0.03960571f, -0.04305615f, -0.00933155f, -0.03290373f, -0.00694053f, -0.01148882f, 0.02409608f, -0.01583323f, 
    -0.01064321f, 0.02888059f, 0.02494393f, -0.00781908f, -0.02601703f, 0.02483959f, -0.02524335f, -0.03778242f, 
    -0.02038181f, -0.03308648f, 0.00729283f, -0.03250496f, 0.01480122f, 0.00049327f, -0.02946148f, -0.04457579f, 
    0.00518255f, 0.01927867f, -0.03531836f, 0.00156004f, -0.04514522f, -0.00810745f, -0.03646102f, -0.01642671f, 
    -0.03844950f, 0.00268595f, 0.01406501f, -0.02493517f, 0.01488987f, 0.01833226f, -0.01235500f, -0.04137847f, 
    -0.02071114f, -0.03927982f, 0.01400213f, -0.04275258f, 0.02748728f, 0.00558902f, -0.01550473f, -0.02543508f, 
    -0.01377769f, 0.00962354f, -0.00183899f, 0.01562904f, 0.01048885f, 0.01107244f, 0.03211879f, -0.04269511f, 
    -0.00361884f, -0.03155917f, -0.01746315f, 0.01807037f, 0.00787667f, -0.04512716f, 0.00698472f, -0.02353274f, 
    0.00713370f, 0.02255510f, -0.01539320f, 0.02029326f, 0.02353862f, -0.04166257f, -0.04153335f, -0.01572677f, 
    0.02493954f, 0.03048448f, 0.02456125f, -0.03671486f, 0.01440379f, -0.03565696f, -0.02438173f, -0.00380599f, 
    -0.04332673f, 0.00187971f, 0.00780495f, 0.00941493f, 0.01356082f, 0.01715372f, -0.01473453f, -0.02997402f, 
    0.00611668f, -0.03839621f, -0.01055593f, -0.00107971f, 0.01498990f, -0.02413463f, -0.01236836f, 0.01443921f, 
    0.02378980f, -0.03200999f, 0.00331555f, -0.02350539f, -0.00072207f, -0.01428470f, -0.03747693f, -0.04306911f, 
    -0.03334177f, -0.00886227f, -0.02682082f, -0.03769411f, -0.01603523f, -0.00397702f, 0.01418361f, 0.00018346f, 
    0.02093520f, -0.00521997f, 0.00660432f, -0.03243252f, 0.00385417f, 0.00432929f, -0.02056408f, 0.01420978f, 
    0.01536343f, -0.01522194f, 0.00196133f, 0.01590374f, -0.03382730f, -0.00914896f, -0.04464731f, -0.04302036f, 
    -0.00871082f, -0.02281428f, -0.03721803f, -0.00802283f, 0.01048991f, -0.01005650f, 0.02857222f, 0.01843039f, 
    0.00515674f, -0.03609661f, 0.00310176f, 0.01864947f, 0.01951368f, 0.02952142f, -0.00500966f, -0.01612965f, 
    -0.02026615f, 0.00299273f, -0.02926054f, -0.02508274f, -0.03484786f, -0.00525951f, 0.02579151f, 0.02705920f, 
    -0.04184608f, -0.01332028f, 0.00120016f, -0.00988521f, -0.01101660f, -0.00635286f, 0.01293570f, 0.02302237f, 
    -0.02542426f, -0.03148371f, 0.00648828f, -0.00497366f, -0.00007215f, -0.00731874f, -0.04179049f, 0.02033498f, 
    0.03279931f, -0.03937406f, 0.02995948f, 0.00202647f, 0.01645489f, -0.01055177f, -0.00554320f, 0.01150222f, 
    -0.01633541f, -0.02250610f, 0.01883283f, 0.02896685f, -0.01450186f, 0.01030452f, 0.00473960f, 0.01867588f, 
    0.01643238f, -0.00601290f, 0.00989343f, -0.04386242f, -0.00593618f, -0.03875456f, -0.00393432f, 0.00487320f, 
    0.02535922f, -0.00319977f, -0.04200050f, -0.01054808f, 0.02807117f, -0.01687860f, 0.01954628f, -0.02998448f, 
    -0.02858811f, -0.01035077f, -0.02416082f, -0.04021771f, 0.00379449f, -0.01149784f, -0.01497253f, 0.01308504f, 
    -0.01124236f, -0.02989490f, 0.00975045f, -0.04279608f, 0.02439057f, -0.01354833f, 0.02704598f, 0.01919237f, 
    0.00029486f, -0.02661187f, 0.02735467f, -0.01438603f, 0.00177559f, -0.02849543f, -0.04538948f, 0.03311848f, 
    -0.02410651f, -0.03362361f, -0.02531751f, -0.04364613f, -0.01484804f, -0.02668385f, -0.02613089f, 0.03021018f, 
    -0.00368227f, 0.00300871f, -0.02293966f, -0.00226115f, 0.02162394f, -0.02430245f, -0.02141620f, 0.02695426f, 
    0.02799136f, 0.02044721f, 0.03083006f, -0.03081829f, 0.01748610f, -0.02297562f, -0.03225356f, -0.03965747f, 
    -0.03738482f, -0.03625032f, -0.01135308f, 0.00541387f, -0.03798157f, -0.00120403f, 0.03342569f, -0.00945324f, 
    0.02306023f, -0.00340523f, 0.02138332f, 0.02930765f, -0.03121031f, -0.04132720f, -0.01662424f, -0.00791535f, 
    -0.01870904f, -0.01461908f, -0.00125279f, -0.03156551f, 0.03317461f, -0.01337658f, -0.01609029f, -0.04172528f, 
    -0.00948165f, -0.03054705f, 0.02618281f, 0.02340537f, 0.00367462f, 0.02220742f, 0.02948758f, -0.01351395f, 
    0.02501407f, 0.00312665f, 0.01701056f, -0.04184732f, -0.03314269f, 0.01454548f, -0.01369613f, -0.03279495f, 
    -0.00220049f, 0.00552523f, -0.03991168f, 0.00122377f, 0.02614295f, -0.04455531f, 0.02488455f, 0.02628721f, 
    -0.02605847f, 0.00878276f, 0.01985621f, 0.00778953f, -0.01905259f, -0.00546931f, 0.01201912f, 0.02114339f, 
    -0.04194411f, 0.02935230f, 0.00397184f, -0.03839961f, 0.01364303f, -0.03397529f, 0.01720681f, -0.03779323f, 
    -0.02687568f, 0.00283427f, 0.02364158f, 0.00330178f, -0.01388265f, -0.00556804f, 0.00030237f, -0.01952908f, 
    -0.01877820f, -0.04458785f, -0.01090570f, 0.02614111f, -0.04268798f, -0.00381638f, -0.03938951f, -0.00369608f, 
    -0.00535477f, -0.00737793f, -0.04317192f, -0.03298358f, -0.02779145f, 0.00127601f, 0.01227299f, 0.02510185f, 
    0.02209654f, -0.03355987f, 0.00379381f, 0.01685372f, -0.02262371f, -0.04248140f, 0.00914677f, 0.03110330f, 
    0.03285559f, -0.01985574f, 0.02320891f, -0.02203422f, -0.03823552f, -0.01134906f, 0.02927193f, 0.02379386f, 
    0.00567843f, -0.04332162f, -0.02765475f, 0.00840010f, 0.01475038f, 0.02689092f, -0.03820203f, 0.00284324f, 
    -0.02867292f, -0.03754556f, 0.03175968f, -0.04035806f, 0.01374949f, 0.02524753f, -0.02671653f, -0.00215418f, 
    -0.03791225f, 0.02851259f, -0.03676458f, -0.01912515f, -0.01411521f, 0.02244219f, 0.00962250f, -0.02381749f, 
    0.29265955f, -0.02297994f, -0.04376490f, -0.15593654f, 0.06018282f, -0.03875027f, -0.03029575f, -0.08826221f, 
    0.03361211f, 0.06249790f, 0.04117475f, 0.00859815f, 0.03489544f, -0.07752302f, -0.13605103f, -0.02655229f, 
    -0.11730962f, 0.17637882f, 0.08909453f, -0.04084615f, -0.00187364f, 0.49744555f, -0.07894368f, -0.07683443f, 
    -0.08612694f, 0.03727844f, 0.06058893f, 0.02777256f, 0.06867359f, 0.04697294f, 0.00561938f, 0.00879436f, 
    0.10404323f, -0.05919885f, 0.02733599f, 0.11283384f, -0.01664290f, -0.21796623f, -0.02092277f, 0.14848889f, 
    -0.10390807f, -0.01787258f, -0.00026436f, 0.16794437f, 0.24542823f, -0.00715226f, -0.03821246f, 0.12881519f, 
    0.12074608f, 0.04524711f, 0.10993754f, -0.01825717f, 0.12585454f, 0.10569748f, 0.01974446f, -0.00429922f, 
    0.17740150f, 0.02898251f, -0.02919908f, -0.03198471f, -0.26970410f, 0.14297521f, -0.10757879f, -0.10604602f, 
    -0.05818080f, 0.14016183f, 0.19691330f, -0.20944993f, -0.04070407f, -0.03212019f, 0.04478045f, 0.11084256f, 
    0.06674358f, 0.01748954f, 0.03719652f, 0.01473810f, 0.14552775f, 0.17993601f, -0.00143138f, 0.04548410f, 
    0.01059564f, 0.00072182f, -0.15611294f, -0.23871496f, 0.11624552f, 0.01217543f, 0.05333908f, -0.01702446f, 
    0.05362477f, 0.12914784f, 0.31601030f, 0.03629212f, 0.20408158f, -0.03748112f, 0.14857526f, -0.02169209f, 
    -0.00546085f, -0.09162229f, 0.15340155f, 0.06127209f, -0.26337567f, 0.05316285f, 0.31724095f, -0.10896412f, 
    0.24845596f, 0.24308473f, 0.05037889f, -0.03914937f, -0.00690386f, 0.07831421f, -0.00511850f, 0.13496111f, 
    0.05446288f, 0.10897670f, 0.01390878f, 0.09873503f, 0.04588960f, 0.03039719f, -0.12920095f, -0.02388251f, 
    -0.25384063f, 0.19706468f, -0.16684331f, -0.07775073f, 0.20274001f, -0.06882540f, 0.11698592f, -0.03254315f, 
    -0.05049633f, 0.15304866f, -0.05943964f, 0.04925754f, 0.11193333f, 0.07336545f, 0.06442348f, 0.03636584f, 
    -0.09412546f, 0.00790645f, 0.04814145f, 0.08736992f, -0.08067901f, -0.35315728f, -0.08531404f, -0.12669954f, 
    -0.14714642f, 0.18441498f, 0.07685295f, -0.03092531f, -0.07948528f, -0.13035209f, 0.06834532f, 0.06777479f, 
    -0.00101674f, 0.07724138f, 0.07836739f, 0.00982884f, -0.05219350f, -0.03597325f, -0.13019641f, -0.09133052f, 
    0.05911846f, 0.21035908f, 0.16658080f, 0.19926395f, 0.21258688f, -0.08680641f, -0.15932404f, -0.00066977f, 
    -0.04273924f, 0.01689606f, 0.07315213f, 0.08767235f, 0.00225522f, 0.07158381f, 0.03639438f, -0.01800342f, 
    0.01754516f, 0.06979553f, -0.07557485f, -0.06338364f, 0.08649423f, 0.46699825f, 0.29928163f, -0.29244271f, 
    -0.01739076f, 0.05366330f, -0.07912127f, 0.03833702f, 0.07850245f, 0.03859317f, -0.06831373f, 0.01402275f, 
    0.22221223f, 0.18604524f, 0.05768457f, 0.10690360f, 0.18212008f, -0.14469667f, -0.03986173f, 0.05585006f, 
    -0.38694313f, 0.27634433f, -0.15370229f, -0.09629486f, -0.09676475f, 0.00385183f, 0.00941147f, 0.11321394f, 
    -0.02528096f, -0.03849010f, 0.25546670f, 0.04871163f, 0.12102454f, -0.04506936f, -0.01327201f, -0.08635994f, 
    0.16305952f, -0.28858516f, -0.10988170f, 0.05598684f, -0.35483295f, -0.31764033f, -0.25251803f, 0.00916344f, 
    0.01112849f, 0.11065392f, -0.00102397f, -0.18365479f, 0.01653886f, -0.10979342f, 0.23584297f, -0.08317783f, 
    0.20086882f, -0.10398041f, 0.18626943f, 0.01781191f, 0.09951641f, -0.27446529f, -0.09129811f, -0.03426054f, 
    -0.23040313f, -0.10419513f, -0.02563321f, -0.11171383f, -0.19725145f, 0.10379881f, 0.18259433f, 0.17116454f, 
    -0.05215156f, 0.06600303f, 0.09097086f, -0.02279967f, -0.08881657f, 0.03607345f, -0.00545949f, -0.12702094f, 
    -0.09357169f, 0.25012502f, -0.02923016f, -0.07508863f, -1.03824556f, 0.00012712f, -0.41117820f, 0.07158493f, 
    0.08565427f, 0.11896463f, -0.17166747f, -0.17099720f, -0.03291436f, 0.01370677f, 0.01544888f, -0.08633247f, 
    -0.21013324f, 0.03919098f, 0.00488148f, 0.04636902f, -0.06338681f, -0.11987408f, 0.05921139f, 0.00918462f, 
    0.23629779f, -0.10312793f, -0.03400799f, 0.16899006f, -0.01347937f, -0.11377283f, 0.01063335f, 0.05768564f, 
    0.03645714f, 0.05411388f, 0.03154160f, -0.01172413f, -0.08069569f, -0.11689354f, 0.01913300f, 0.03049313f, 
    -0.05542658f, -0.03960928f, 0.15019891f, -0.08064395f, 0.40283099f, 0.12942994f, -0.16422442f, -0.09294730f, 
    -0.10668300f, -0.21222585f, -0.02396314f, 0.05285096f, 0.14906010f, 0.07253829f, 0.06199432f, 0.06103892f, 
    0.07497230f, 0.04766987f, -0.00983892f, 0.17899968f, 0.03817523f, 0.00047285f, 0.08934481f, 0.31783694f, 
    0.04054130f, 0.17120185f, 0.13776338f, -0.27576989f, 0.18520856f, 0.22778425f, 0.03065852f, 0.00991912f, 
    0.15530671f, 0.07192107f, -0.13017690f, 0.09128106f, -0.02226312f, 0.08214747f, -0.04714439f, 0.01509821f, 
    0.06839707f, 0.14358962f, -0.19472605f, 0.18393563f, 0.40614957f, 0.08791504f, 0.34551069f, 0.16146621f, 
    0.10102329f, -0.14129910f, -0.09282888f, 0.09628855f, -0.02402874f, 0.02355508f, 0.03928119f, -0.01048122f, 
    0.00507166f, 0.08010074f, -0.01320353f, -0.10081165f, 0.11710194f, -0.00014714f, -0.17960551f, 0.04023445f, 
    -0.17733374f, 0.04586370f, -0.10652898f, 0.12974744f, -0.04996222f, 0.35462934f, -0.04492309f, -0.01698573f, 
    -0.04545264f, -0.00239908f, 0.04220609f, 0.06940225f, 0.00547315f, 0.10289690f, 0.00281669f, 0.00043144f, 
    0.11316177f, 0.06600501f, 0.06168409f, -0.07126693f, -0.01638430f, -0.13005605f, -0.09366372f, 0.03779347f, 
    0.08720982f, 0.21987334f, 0.06259496f, 0.06289679f, -0.07706709f, -0.05648550f, 0.18857913f, -0.00664988f, 
    0.03447419f, 0.03496076f, 0.08822900f, 0.12020882f, 0.08249956f, 0.18627283f, -0.03549268f, 0.01158637f, 
    0.09500048f, 0.20472427f, 0.21291657f, 0.21390603f, 0.11362799f, 0.04868461f, -0.16452445f, 0.15095590f, 
    -0.06343768f, 0.14508095f, 0.04472652f, -0.09700308f, -0.00348659f, -0.07195672f, -0.08217870f, 0.04469586f, 
    -0.01770008f, 0.00293107f, -0.05130541f, 0.02596426f, 0.43130580f, 0.02992633f, 0.00356222f, 0.22426605f, 
    0.06739835f, -0.06371352f, -0.02048156f, 0.15578391f, -0.14173549f, 0.14764361f, -0.00896473f, -0.07027651f, 
    -0.03204430f, 0.21649472f, -0.07524574f, 0.13152377f, 0.01380256f, 0.04226813f, -0.07822842f, 0.00332794f, 
    0.01782021f, 0.06369813f, -0.12415082f, -0.14202803f, 0.16778113f, -0.08252204f, -0.11040496f, 0.02702195f, 
    0.02778698f, 0.07050000f, 0.13408348f, 0.03703255f, 0.03163186f, -0.05294233f, 0.06066522f, 0.01240276f, 
    0.09057923f, -0.00753637f, -0.14622639f, 0.25123706f, -0.02865854f, -0.13918707f, 0.07219256f, -0.04658381f, 
    -0.08906935f, 0.27564105f, 0.06982571f, -0.03557176f, -0.09838533f, 0.06578786f, -0.06010710f, 0.01567764f, 
    0.17010289f, 0.02620481f, 0.05728098f, 0.00788034f, 0.04274032f, -0.00077735f, -0.00217789f, -0.05276701f, 
    -0.10452385f, 0.25886673f, 0.02937907f, -0.25321829f, -0.18784231f, -0.12884629f, 0.05125447f, 0.09410376f, 
    0.04983076f, -0.11076596f, 0.04075544f, 0.10779247f, -0.04318362f, 0.05788174f, -0.14123976f, 0.03506263f, 
    -0.01001825f, -0.31988221f, -0.13338454f, 0.12638012f, -0.28893295f, -0.18926507f, -0.11346460f, -0.07365172f, 
    0.11889508f, 0.14811391f, 0.07646342f, -0.08905052f, 0.05218899f, -0.00608297f, 0.00966099f, 0.10060117f, 
    -0.01897386f, 0.05224247f, 0.08083403f, -0.02391607f, 0.11219631f, -0.00287160f, -0.01202554f, 0.10641547f, 
    0.00848061f, -0.08182709f, -0.20944259f, 0.08997936f, 0.18440099f, -0.03577816f, -0.04763878f, -0.05658217f, 
    -0.05426576f, 0.05085453f, -0.09817250f, 0.09990562f, -0.05846756f, -0.13881446f, -0.06023574f, -0.11155289f, 
    -0.01644497f, 0.11462044f, -0.03775031f, 0.15997683f, -0.16440235f, 0.25014922f, 0.04795827f, -0.01613514f, 
    -0.21603116f, 0.18307398f, 0.00171566f, -0.05734152f, -0.07101682f, 0.03917534f, 0.13826500f, 0.04581585f, 
    -0.08028651f, -0.01432353f, 0.19466595f, -0.10847488f, 0.03944148f, -0.11088376f, 0.13475546f, -0.07377347f, 
    -0.02618570f, 0.03552621f, -0.06111236f, -0.35185301f, 0.02989468f, 0.11361036f, -0.03936639f, 0.03521393f, 
    0.14318603f, -0.02562663f, -0.00606435f, 0.08299381f, 0.04513048f, 0.05577835f, 0.08827233f, 0.08778531f, 
    -0.01711058f, -0.06236214f, -0.07702041f, 0.11635562f, 0.15408134f, 0.00379707f, -0.17284770f, 0.04802745f, 
    -0.12311444f, 0.13074595f, 0.02228803f, 0.08688881f, -0.12009403f, -0.04037817f, 0.17045875f, -0.00184326f, 
    -0.00382870f, -0.08079332f, -0.05526385f, -0.03805491f, 0.08986381f, 0.02485052f, 0.12091468f, 0.00856641f, 
    0.16271921f, 0.00881045f, 0.07691960f, -0.25083089f, -0.09067523f, 0.10868006f, 0.11256666f, -0.05786711f, 
    -0.15496194f, 0.10149379f, 0.03794843f, -0.06775524f, 0.13000561f, -0.08736853f, 0.04830757f, -0.01249076f, 
    0.15170196f, 0.05299097f, 0.10506435f, 0.10714200f, -0.02458713f, -0.09292214f, 0.06331932f, -0.13054945f, 
    -0.16944964f, 0.12654412f, 0.08059680f, 0.05720341f, -0.01930759f, -0.09202468f, 0.14725900f, 0.07479846f, 
    -0.07173732f, 0.12468982f, 0.09893277f, -0.08582783f, -0.04980139f, 0.06319392f, 0.03970236f, 0.12934527f, 
    -0.34003019f, -0.26776618f, -0.26206511f, -0.06238671f, 0.20880903f, 0.03207079f, -0.02760344f, 0.03263564f, 
    0.12975374f, -0.11262316f, 0.01492057f, -0.03628844f, 0.05501885f, 0.13327198f, 0.13440350f, 0.02253783f, 
    0.06738747f, -0.05538949f, -0.07789950f, -0.09313145f, 0.20290150f, 0.35374194f, -0.10682052f, 0.07561734f, 
    -0.02672698f, -0.02277975f, 0.03012544f, -0.07796408f, 0.02339573f, -0.24932949f, 0.08811496f, -0.04552489f, 
    -0.17411157f, -0.06360959f, 0.01181228f, 0.14360113f, 0.03382720f, 0.20150074f, 0.03433581f, 0.15079568f, 
    -0.06971347f, -0.06614099f, 0.12037940f, -0.14154889f, 0.11531533f, -0.01919930f, -0.07919992f, -0.11803836f, 
    -0.06297545f, 0.00919390f, -0.09123585f, 0.08792428f, 0.08628032f, -0.02627734f, 0.01939059f, -0.10388961f, 
    0.08422898f, 0.04592630f, -0.04881791f, 0.13893591f, 0.23206754f, 0.09051399f, -0.24323541f, 0.08604066f, 
    0.10363799f, 0.01837475f, -0.02286181f, 0.08090628f, 0.13996351f, 0.08809413f, -0.04469913f, 0.05315210f, 
    0.02891900f, -0.03888831f, -0.02187676f, -0.02392635f, -0.02055587f, -0.09935033f, -0.02098142f, -0.05850436f, 
    0.18311903f, 0.05559827f, 0.00952324f, 0.20813030f, -0.10965750f, 0.02358234f, 0.14231677f, -0.11815991f, 
    0.12154477f, -0.13840912f, -0.01072312f, -0.10266460f, -0.11486443f, 0.06186720f, -0.05227149f, -0.11985739f, 
    0.09832097f, 0.14384258f, -0.12473217f, 0.13486710f, 0.08881297f, -0.01160521f, 0.24330837f, -0.08161357f, 
    0.11051483f, 0.03254615f, -0.08128111f, 0.00439921f, -0.04418627f, 0.03442141f, -0.03180863f, -0.14202505f, 
    0.03601018f, -0.03588231f, 0.05460183f, -0.10081810f, 0.12974542f, 0.01835906f, 0.27607173f, 0.09821129f, 
    0.38897425f, 0.35584569f, -0.18581606f, -0.07359614f, 0.17387412f, -0.03158840f, -0.07810418f, 0.15518676f, 
    0.02404615f, 0.11947057f, -0.02190197f, -0.03523216f, -0.11477520f, 0.00177329f, 0.02339636f, -0.04905652f, 
    0.13159570f, -0.15747757f, -0.06738871f, 0.00427927f, -0.40931991f, -0.19763035f, 0.17353909f, 0.27174744f, 
    -0.27559415f, 0.09864860f, 0.15908612f, 0.03348926f, -0.01357029f, 0.05540383f, 0.27379388f, 0.27432674f, 
    -0.04120086f, -0.11102541f, -0.17217290f, 0.16015469f, 0.10401580f, 0.09884410f, 0.06121496f, 0.00166388f, 
    -0.05624257f, -0.15056901f, 0.00616503f, -0.04754228f, 0.19179052f, -0.05771951f, -0.04617796f, 0.04426719f, 
    0.07408379f, -0.00955794f, -0.08627150f, -0.03551897f, -0.02153441f, 0.02509784f, 0.10825999f, -0.12427387f, 
    -0.05447656f, 0.03296743f, 0.14786868f, 0.13114460f, 0.08949213f, -0.04245440f, 0.12909153f, -0.04123221f, 
    -0.11757812f, 0.06058607f, 0.00246655f, -0.01200309f, -0.16592994f, 0.01392158f, -0.01870935f, 0.07302921f, 
    -0.25997239f, -0.13399433f, -0.26303080f, -0.10615703f, -0.19996338f, 0.19797944f, 0.12498303f, 0.19277468f, 
    -0.08982780f, 0.28669375f, 0.09873372f, -0.06196785f, -0.02361222f, 0.15601778f, 0.01524068f, 0.00838152f, 
    -0.13081585f, 0.01882936f, 0.06872817f, 0.04302623f, 0.02511181f, -0.04425868f, 0.03375258f, -0.14114042f, 
    0.09059526f, 0.17809002f, 0.15952894f, 0.12255785f, 0.14105360f, 0.33747727f, 0.03035237f, 0.04885347f, 
    -0.00251235f, 0.06446975f, 0.21856481f, 0.00295774f, 0.07934705f, -0.07709382f, -0.11176834f, 0.11390533f, 
    0.05848671f, 0.04829284f, -0.00019809f, 0.01159431f, 0.09485568f, 0.22111562f, 0.14014445f, 0.07903321f, 
    -0.03719874f, -0.09933562f, 0.11642446f, -0.02247673f, -0.00915270f, 0.09229821f, 0.09614249f, 0.09193730f, 
    -0.01646002f, -0.09686384f, 0.04058091f, 0.10405909f, -0.13584074f, 0.02797011f, 0.02969311f, -0.01298032f, 
    0.20565827f, -0.19482985f, 0.07447908f, 0.03152261f, 0.44887209f, 0.24008563f, -0.09754504f, 0.04947880f, 
    0.03866280f, -0.14839801f, 0.17287941f, -0.09231593f, 0.07066476f, -0.00863646f, 0.02269227f, 0.08979532f, 
    0.20491181f, 0.08935743f, 0.22069083f, -0.15672265f, 0.15598370f, 0.05483362f, -0.00232080f, -0.00326147f, 
    -0.21971475f, -0.18816824f, 0.29108196f, 0.12038953f, 0.12965946f, 0.01989610f, -0.15184179f, 0.03065932f, 
    0.07774760f, 0.12568794f, -0.02532163f, 0.06251644f, 0.15510204f, 0.14219990f, 0.05015609f, 0.12130969f, 
    0.03195251f, 0.06366341f, -0.01424021f, 0.06890526f, -0.50053763f, -0.10589342f, 0.18346936f, 0.17692249f, 
    0.17045292f, 0.09031810f, 0.06857759f, 0.04442792f, 0.01856062f, -0.23826267f, -0.10469973f, 0.01969818f, 
    -0.04607540f, 0.03344460f, -0.05168107f, -0.10167624f, 0.05131381f, 0.09788942f, -0.03733439f, -0.21798225f, 
    -0.03358206f, 0.09982785f, 0.11312018f, -0.03638021f, 0.27548000f, 0.02400245f, 0.08664010f, 0.01429106f, 
    -0.17287026f, -0.00220083f, -0.00235641f, -0.08553455f, 0.04693002f, -0.06459240f, 0.06268932f, -0.03315865f, 
    0.06944162f, -0.08160833f, 0.29545271f, -0.18613963f, -0.01022859f, 0.13694580f, 0.20166996f, -0.12414356f, 
    0.26174894f, 0.01217034f, -0.15820691f, -0.09815142f, 0.00838660f, -0.02233643f, -0.05593890f, -0.06600346f, 
    0.14276235f, 0.02579207f, 0.05451719f, -0.19703487f, -0.08317141f, 0.06983303f, 0.23239541f, 0.06986049f, 
    -0.21323058f, -0.13308555f, -0.24536610f, 0.00464811f, 0.02490288f, -0.11551781f, 0.05783224f, 0.01288442f, 
    -0.03639858f, -0.03223300f, 0.09915463f, 0.00895505f, 0.01706822f, -0.09789644f, -0.01676133f, 0.04280338f, 
    -0.14712583f, -0.00848177f, -0.05385993f, 0.07017713f, -0.15907143f, -0.37089318f, 0.03755052f, 0.07096118f, 
    0.12763633f, -0.02795576f, 0.10768870f, -0.14709866f, 0.05108712f, 0.05341876f, 0.05376315f, 0.12750278f, 
    0.08900969f, -0.07331715f, 0.11269160f, -0.25237960f, 0.09999958f, -0.12342478f, 0.02700099f, -0.26332381f, 
    0.09548002f, -0.14930715f, -0.09316919f, -0.02826190f, 0.12449382f, -0.10752834f, -0.04214556f, 0.07319479f, 
    -0.08199905f, -0.02610221f, 0.02120569f, 0.03069827f, -0.13935818f, 0.15452608f, 0.02317055f, -0.03708186f, 
    -0.08339283f, 0.06246220f, 0.04123361f, -0.04804131f, 0.16518636f, 0.23027574f, 0.31873760f, -0.19670965f, 
    0.07568047f, -0.00056820f, -0.04658360f, -0.11924678f, 0.06468455f, -0.19859891f, 0.07778886f, -0.06587955f, 
    -0.06442715f, 0.03831337f, -0.07539675f, -0.09851536f, -0.15423523f, -0.02437906f, 0.10303405f, 0.13259262f, 
    -0.24942431f, 0.31360227f, 0.29262850f, 0.07073969f, 0.23589553f, 0.09528057f, -0.07590719f, 0.08828822f, 
    -0.00573224f, 0.01084475f, -0.00014076f, 0.04410015f, 0.03751896f, -0.00557745f, -0.08776207f, 0.17057210f, 
    -0.06462394f, -0.11634759f, 0.11725731f, 0.01072019f, -0.32970470f, -0.06627835f, -0.05438251f, 0.00333117f, 
    0.01321772f, 0.07204644f, -0.06010866f, -0.16895139f, 0.04322223f, 0.03231978f, 0.11485632f, 0.12572923f, 
    -0.05391300f, -0.03378821f, -0.13338967f, -0.02760160f, -0.05973700f, 0.03217629f, 0.07808898f, -0.03986713f, 
    0.21163140f, 0.10024776f, -0.20852548f, 0.19390923f, -0.00431962f, -0.06057754f, -0.01172591f, 0.11342595f, 
    0.16196620f, 0.04311124f, 0.06844822f, -0.11511695f, 0.02025645f, -0.01142015f, 0.08267984f, 0.21169750f, 
    -0.01508669f, 0.21664132f, 0.28037748f, 0.07390570f, -0.06765404f, 0.64577007f, 0.05630717f, -0.21729754f, 
    0.04321700f, -0.03297645f, -0.05917617f, 0.00976158f, -0.01737296f, 0.02381995f, 0.00867326f, -0.07679486f, 
    0.10100465f, -0.04815562f, 0.05495776f, 0.11354417f, 0.12657921f, 0.05180454f, 0.15949990f, -0.09309224f, 
    0.15571991f, -0.25783166f, -0.09652227f, 0.15067174f, 0.07828274f, -0.07400241f, 0.03444992f, 0.06382897f, 
    0.00834584f, 0.18472724f, -0.10267184f, 0.00357383f, 0.06664211f, 0.06004526f, 0.07249512f, -0.00739136f, 
    0.15663630f, 0.05664217f, 0.03584808f, -0.12472288f, 0.03126570f, 0.27064201f, -0.21251251f, -0.01810512f, 
    -0.22371492f, -0.16438237f, 0.18609120f, 0.10322264f, -0.09175655f, -0.11974925f, -0.06391351f, 0.02198416f, 
    0.05294423f, -0.00480982f, -0.08106868f, -0.05970710f, 0.04364456f, 0.22976722f, 0.00441962f, 0.02971342f, 
    -0.13770078f, -0.21875533f, 0.10991505f, 0.19210434f, 0.08192708f, 0.10795263f, 0.05892038f, 0.01497982f, 
    -0.09394105f, -0.07982361f, 0.07510811f, 0.06199695f, -0.08813947f, -0.12870196f, -0.13087285f, -0.07420731f, 
    -0.12287071f, 0.04336154f, 0.17440739f, 0.03216778f, -0.30349356f, -0.09387534f, 0.08567206f, -0.03076187f, 
    -0.11075808f, 0.03311617f, -0.02828997f, -0.07451972f, 0.05868526f, 0.02951275f, -0.02992322f, -0.14314747f, 
    0.19502687f, 0.06648064f, 0.02901109f, 0.06014968f, 0.09785596f, -0.00934976f, -0.07981539f, -0.01536181f, 
    -0.30713069f, 0.08238462f, -0.17630525f, -0.28224921f, 0.12185033f, 0.16924408f, -0.01262954f, -0.05767114f, 
    -0.01236868f, -0.08488954f, 0.06073575f, -0.01101998f, -0.03820667f, 0.01126057f, -0.04768450f, -0.01037293f, 
    -0.13725233f, -0.04359563f, -0.01175032f, 0.12801056f, -0.10323159f, -0.13565230f, -0.31264466f, 0.13304330f, 
    -0.20283434f, 0.04353225f, 0.13634084f, 0.07876056f, 0.02722770f, -0.02714060f, 0.04789484f, 0.02645738f, 
    0.05655050f, -0.09227563f, 0.02184299f, 0.01803978f, 0.07686850f, -0.09490729f, -0.04982013f, 0.00777911f, 
    -0.00080785f, -0.01449280f, -0.02200955f, 0.02357512f, -0.01045927f, -0.03100127f, 0.01985633f, 0.00965814f, 
    0.00066739f, -0.01070193f, -0.01631111f, -0.03158270f, -0.03109024f, -0.01940905f, -0.00140708f, -0.03344097f, 
    0.00859069f, 0.01024497f, -0.04457768f, -0.02363620f, -0.02337387f, -0.00200529f, -0.00864773f, 0.02022610f, 
    -0.02563264f, -0.04387666f, -0.02619515f, -0.03759144f, 0.01309602f, 0.02011429f, -0.02364406f, 0.00395678f, 
    -0.01421572f, 0.00990786f, 0.00792863f, 0.00238481f, -0.03802516f, 0.00727433f, 0.00454566f, 0.02879857f, 
    -0.04552442f, -0.03056068f, -0.02004940f, 0.01358524f, 0.01084638f, 0.00400223f, 0.03047156f, -0.02557119f, 
    -0.04316804f, -0.04576157f, -0.00025443f, -0.02874719f, 0.02472454f, 0.00314932f, 0.01771912f, -0.01536593f, 
    0.01163801f, 0.02629549f, 0.01808154f, -0.02314980f, -0.01847642f, -0.00008145f, 0.02321998f, -0.01260702f, 
    0.03196598f, -0.04050019f, 0.03235268f, 0.03291287f, -0.00943703f, 0.01861881f, -0.04146685f, -0.02434781f, 
    0.02554927f, -0.01780370f, 0.00037239f, -0.02316878f, -0.03917366f, -0.04281649f, -0.00223583f, -0.04647148f, 
    -0.03603715f, 0.00423308f, 0.02686324f, 0.01444545f, -0.03436599f, 0.00139331f, 0.01925870f, -0.03878239f, 
    -0.03566019f, -0.00384359f, 0.02884878f, -0.01457016f, 0.03133963f, -0.01700333f, 0.00844548f, 0.03056774f, 
    -0.02989231f, -0.00268149f, -0.01227528f, 0.02795568f, 0.00107042f, -0.00115295f, 0.00534359f, -0.02421569f, 
    -0.03832888f, 0.01562571f, -0.03339754f, -0.03379172f, 0.03110469f, 0.02113376f, -0.03059023f, -0.00844706f, 
    -0.04304106f, 0.01493693f, 0.03225860f, -0.00474527f, 0.01144222f, 0.00565400f, -0.00498741f, -0.00881195f, 
    0.03422177f, 0.02180327f, -0.00838755f, -0.00891150f, -0.04584580f, -0.02251389f, -0.03026106f, -0.03210986f, 
    0.02487894f, -0.03913115f, 0.01601312f, -0.04076817f, 0.01465188f, -0.00308036f, -0.01865186f, -0.00067839f, 
    0.00483700f, -0.02190824f, -0.03461108f, -0.02728844f, -0.02588576f, -0.00936586f, 0.01026586f, 0.01168370f, 
    -0.02370600f, 0.00308354f, -0.00110875f, 0.03312750f, -0.02589601f, 0.02958566f, 0.00041918f, -0.02135708f, 
    0.00733976f, -0.02542504f, 0.01475574f, 0.03043608f, -0.02106620f, -0.02978224f, 0.00360047f, 0.01413518f, 
    -0.01973236f, -0.04411883f, -0.03577749f, 0.03224791f, 0.00943700f, -0.00285440f, 0.00025930f, -0.02363071f, 
    0.03422543f, -0.01043067f, 0.02308502f, -0.01704882f, -0.02087252f, -0.01325406f, 0.01773379f, -0.04208053f, 
    -0.01566177f, 0.01061882f, -0.02323582f, -0.02282304f, 0.02064168f, 0.01160112f, 0.02604434f, -0.02746935f, 
    -0.04038679f, 0.03023978f, 0.02383146f, -0.02719851f, -0.01042395f, 0.02623631f, -0.02740659f, -0.03329397f, 
    0.00367700f, -0.01005865f, 0.00839549f, 0.00601424f, -0.04372060f, -0.01696357f, 0.01883457f, -0.00961043f, 
    0.02260362f, -0.01267101f, -0.04311584f, -0.02723499f, -0.03453459f, -0.04480189f, 0.02115302f, 0.01554130f, 
    0.00276033f, -0.00173152f, 0.00438160f, -0.00162215f, -0.01317178f, 0.03033472f, 0.02550193f, 0.01648591f, 
    0.01080246f, -0.00642056f, -0.01324749f, 0.01749112f, -0.00292682f, 0.02146227f, -0.03311746f, 0.01019998f, 
    -0.01012065f, 0.03117459f, 0.02176025f, 0.03116897f, -0.03241965f, 0.01473800f, -0.02485305f, -0.02444272f, 
    0.01636090f, -0.02589122f, -0.02377496f, -0.01060207f, 0.00511132f, 0.01840889f, -0.03061092f, -0.00655078f, 
    -0.01058253f, 0.02310893f, -0.03110205f, -0.00035558f, 0.01326102f, 0.01148490f, -0.02397541f, -0.03894866f, 
    0.02663334f, 0.02088052f, 0.03053828f, 0.00465283f, 0.02233523f, -0.00773237f, 0.01295991f, -0.02014525f, 
    0.03063355f, 0.02939804f, -0.04617596f, 0.00439021f, 0.01489188f, -0.03761614f, 0.02062886f, -0.01851419f, 
    -0.01929237f, -0.01242599f, 0.02521244f, -0.00662624f, 0.02745267f, 0.00752936f, -0.00918974f, -0.01922826f, 
    0.01046175f, -0.02581175f, 0.00699290f, -0.01295136f, 0.00937967f, -0.01802960f, -0.01999844f, -0.01052822f, 
    -0.03155296f, 0.03239091f, -0.00757017f, 0.01350845f, 0.00447337f, 0.00066302f, -0.02143808f, -0.01884606f, 
    0.01487734f, 0.00468448f, -0.01266553f, -0.01951255f, -0.02347554f, 0.01828362f, 0.01096530f, 0.00378339f, 
    -0.02414311f, -0.00387109f, 0.00005422f, -0.02685987f, -0.00693682f, 0.02800536f, 0.01343864f, 0.00930303f, 
    -0.02879179f, -0.03183495f, 0.02431361f, -0.03414776f, -0.02904830f, 0.01533594f, 0.02086010f, 0.00982784f, 
    -0.01516388f, -0.02734150f, -0.00646988f, -0.03460446f, 0.01636495f, 0.01285363f, 0.01994652f, 0.03167446f, 
    -0.00575383f, -0.02440911f, 0.00247798f, 0.02842838f, 0.01748378f, -0.01749962f, 0.02159709f, -0.02428211f, 
    -0.00494988f, 0.01379333f, -0.02813821f, -0.01762586f, -0.01058227f, 0.01755070f, -0.00717912f, -0.03256499f, 
    -0.01686137f, -0.03691011f, -0.01543688f, -0.01550034f, 0.00285933f, 0.01764026f, -0.00490501f, -0.03274526f, 
    0.01547894f, -0.04005382f, -0.03981777f, 0.01411814f, -0.03754591f, -0.04083357f, -0.04071040f, -0.02416756f, 
    0.01917528f, 0.02205644f, -0.04290706f, 0.02324250f, -0.02071400f, -0.03242896f, 0.00553071f, 0.02067359f, 
    0.02371165f, 0.01741564f, 0.01785847f, 0.00300657f, -0.00175580f, 0.02083032f, -0.02882820f, 0.02562097f, 
    -0.00820010f, 0.01499037f, 0.03023023f, 0.02371723f, -0.00757577f, -0.04401615f, 0.02573313f, -0.02936489f, 
    -0.00073489f, -0.03059450f, -0.04132523f, -0.02775788f, -0.02812324f, 0.00284786f, -0.01134525f, 0.01543090f, 
    0.02921356f, 0.02865704f, -0.02953940f, 0.02256417f, -0.02631392f, 0.01555191f, -0.02593882f, -0.02521002f, 
    0.03169875f, 0.02981410f, -0.01491935f, -0.03824327f, -0.03904491f, -0.02588598f, -0.03204079f, -0.02347301f, 
    0.01313983f, -0.02208693f, 0.00544025f, -0.03440308f, 0.02200133f, -0.02223014f, -0.01466581f, -0.00563511f, 
    0.03015507f, 0.00519723f, 0.00889139f, -0.04399646f, 0.02999406f, -0.03617258f, 0.00891319f, 0.02254253f, 
    -0.01944109f, -0.04294420f, 0.01415376f, 0.02854388f, -0.04126133f, -0.04086568f, -0.01391229f, 0.00637759f, 
    0.00670342f, -0.01787313f, 0.02010361f, -0.03040845f, -0.00170916f, -0.01591716f, 0.01014315f, -0.03264021f, 
    -0.01415823f, 0.03127231f, -0.00305003f, -0.03593256f, -0.02655060f, -0.00954264f, 0.00703052f, 0.01920775f, 
    0.00965360f, 0.02820493f, -0.00026496f, -0.02253910f, -0.00015769f, 0.00441516f, -0.02424560f, 0.01307018f, 
    -0.04486393f, -0.00374405f, -0.01451902f, -0.02459009f, 0.01114177f, -0.00932213f, 0.02335922f, -0.01946802f, 
    0.01671544f, -0.00365476f, -0.03779491f, 0.02461834f, 0.01028237f, -0.04004982f, 0.02340332f, -0.03390514f, 
    -0.00503119f, -0.02960993f, -0.02539570f, 0.00099469f, -0.04385370f, -0.00351373f, -0.02999687f, -0.04146192f, 
    -0.01410588f, 0.00724436f, -0.00601435f, 0.02715028f, 0.03135016f, -0.02919355f, 0.02482560f, 0.00917878f, 
    -0.02364622f, -0.03348494f, -0.03758170f, -0.01138822f, -0.02181055f, -0.03409098f, 0.03641731f, -0.02041929f, 
    -0.02261842f, 0.01847272f, -0.04054452f, 0.02980564f, -0.00271580f, 0.01910901f, -0.00711017f, -0.04246498f, 
    0.01034685f, 0.01508301f, -0.03095529f, 0.01197556f, -0.03515409f, 0.00260526f, 0.03108164f, 0.01252451f, 
    -0.00295498f, -0.00798580f, 0.02188976f, 0.03134413f, -0.02873402f, 0.01540768f, -0.00490177f, -0.04148380f, 
    0.00460148f, 0.01984707f, 0.02210007f, -0.04384040f, 0.03059857f, 0.01726502f, -0.02580316f, -0.02301649f, 
    0.03171290f, -0.03486648f, -0.01982685f, 0.02080444f, 0.03223755f, 0.02396418f, 0.03096664f, 0.02754763f, 
    0.03114534f, 0.01480434f, 0.01479432f, -0.04377660f, 0.00588404f, -0.01266265f, 0.02839254f, -0.03588201f, 
    0.02836264f, 0.01374821f, -0.01899609f, -0.02017816f, 0.01715971f, -0.03630354f, -0.02113709f, -0.02813412f, 
    -0.02845657f, 0.01797284f, -0.02266300f, -0.00589596f, -0.00111615f, 0.01160546f, -0.04258135f, 0.03180683f, 
    0.02169548f, 0.02077269f, 0.00479160f, -0.01951599f, -0.01373140f, -0.04092110f, 0.01738089f, 0.00069941f, 
    0.00846554f, 0.00087208f, 0.02372493f, -0.02252655f, 0.01347171f, -0.01801885f, -0.01581549f, -0.00507087f, 
    0.00949810f, -0.01645983f, -0.00034290f, -0.03052273f, -0.02503221f, 0.02661690f, -0.02737041f, -0.00909409f, 
    -0.02110312f, -0.04183272f, -0.03886231f, 0.00924059f, 0.02288371f, 0.01891352f, -0.00880532f, 0.01806930f, 
    -0.01579286f, -0.03778908f, -0.02317443f, -0.04292310f, -0.00086305f, -0.03253187f, -0.02620270f, 0.03136422f, 
    -0.01484960f, 0.01615441f, 0.00915811f, 0.00726999f, -0.00769660f, -0.00810211f, -0.04294147f, -0.01800053f, 
    -0.04260137f, -0.02784606f, -0.03310812f, -0.01923948f, 0.00562909f, 0.03243935f, 0.01218242f, 0.00018476f, 
    -0.04156899f, -0.03891196f, -0.03722833f, -0.04414450f, -0.02465469f, -0.00524127f, -0.03933154f, 0.01026043f, 
    -0.03152717f, 0.01345966f, 0.02294891f, 0.01115201f, -0.03672604f, 0.01968177f, 0.02076112f, -0.02870418f, 
    -0.02117739f, -0.02947119f, 0.01539679f, 0.00977726f, 0.00138828f, -0.02138408f, 0.00604134f, -0.00596473f, 
    0.01806415f, 0.00241576f, -0.01076932f, 0.01889114f, -0.00514458f, -0.02094257f, 0.01288904f, -0.03034289f, 
    -0.02044330f, -0.01913069f, -0.01303428f, 0.02325320f, 0.02921204f, -0.03812379f, -0.01980927f, 0.01686934f, 
    -0.01377014f, -0.01891852f, 0.02644143f, -0.04146789f, -0.00663108f, -0.03637748f, 0.00483351f, -0.02667032f, 
    -0.01988083f, -0.01642093f, 0.00186098f, 0.01404618f, -0.00762889f, -0.02950554f, -0.01910124f, 0.02777633f, 
    -0.01042356f, 0.00029230f, -0.03373784f, 0.03219353f, -0.01869472f, -0.01208475f, 0.02850956f, -0.00626004f, 
    -0.01709918f, -0.00661901f, 0.00372813f, -0.00144161f, 0.02699348f, 0.01400381f, 0.02328982f, 0.01271017f, 
    0.01546325f, -0.03406419f, 0.02751216f, -0.04188658f, -0.02104441f, -0.00525709f, 0.01196900f, 0.01941564f, 
    -0.04010188f, -0.00593456f, -0.03824493f, 0.03500007f, -0.01686908f, -0.00457942f, -0.03783439f, -0.01702996f, 
    0.02933959f, 0.00300863f, -0.01982490f, 0.00122036f, 0.03710923f, -0.01539579f, -0.02388367f, 0.01379133f, 
    0.02047643f, 0.03463665f, 0.00240443f, 0.00808638f, -0.02525678f, -0.00573151f, 0.00115970f, -0.04093459f, 
    -0.04152714f, -0.03426428f, -0.04492432f, 0.02254730f, 0.01092794f, 0.00379483f, -0.04143538f, 0.02667858f, 
    -0.03099287f, -0.03833913f, 0.02515208f, -0.04173354f, 0.01196612f, 0.02587229f, 0.01968194f, 0.00252481f, 
    -0.02526095f, -0.01825251f, -0.01030931f, -0.00825591f, 0.01066016f, 0.01242965f, -0.03454440f, 0.03303959f, 
    0.02059579f, -0.02463435f, 0.00806718f, -0.00970972f, 0.00481074f, 0.03044984f, 0.02754625f, -0.01014002f, 
    0.01105297f, 0.01997981f, -0.02372293f, -0.03317225f, -0.04518090f, 0.02779854f, -0.01720972f, -0.01816325f, 
    0.03987560f, -0.00410293f, -0.01237503f, -0.04180409f, -0.03170491f, 0.00963338f, -0.04118675f, -0.01203872f, 
    -0.02867596f, 0.01533761f, 0.03023831f, 0.02576571f, -0.02008926f, 0.00931663f, -0.00824641f, 0.00514694f, 
    0.00488997f, 0.02066505f, -0.02330137f, -0.00322798f, 0.02142488f, -0.01381644f, 0.01148343f, -0.03708961f, 
    -0.02122885f, -0.02151273f, -0.04216364f, 0.02301180f, -0.01651903f, 0.01791647f, -0.02185347f, -0.02292433f, 
    0.02130985f, -0.01254601f, -0.00433084f, -0.02302178f, -0.00609889f, 0.02402760f, -0.00069547f, -0.03041568f, 
    -0.00280812f, -0.00938286f, -0.01698818f, -0.03693011f, 0.00285505f, 0.03156171f, -0.02371601f, -0.02614356f, 
    0.01162439f, -0.00827487f, 0.02029836f, -0.00069286f, -0.01551795f, 0.01745871f, -0.02902635f, -0.03431500f, 
    0.00613305f, -0.03589855f, -0.01886846f, 0.02431405f, 0.00519710f, -0.02119682f, -0.01439813f, 0.01606277f, 
    -0.02746468f, -0.01954101f, 0.02914231f, 0.03056160f, -0.02384226f, -0.00638505f, 0.02742760f, 0.02905060f, 
    0.01575153f, -0.03104277f, -0.03475476f, -0.01091893f, -0.03460038f, 0.01218297f, -0.02134345f, -0.00929770f, 
    0.03624315f, -0.02080563f, -0.03244274f, 0.03373952f, -0.01107503f, 0.02683332f, -0.00981748f, -0.02008643f, 
    0.01868904f, 0.00927126f, 0.01807524f, -0.04479227f, 0.02268759f, -0.04028961f, -0.01925581f, -0.00118428f, 
    -0.01718169f, 0.02354488f, -0.01041948f, -0.00431809f, 0.01094491f, -0.02938347f, -0.01426882f, -0.00289403f, 
    0.02384329f, 0.01261577f, 0.01777419f, 0.01706381f, 0.03971607f, -0.02765719f, 0.02751124f, 0.01487231f, 
    0.02354998f, 0.02246617f, 0.01210986f, -0.00626749f, 0.03248975f, 0.02431966f, 0.02326339f, 0.01321957f, 
    0.00793118f, -0.03979382f, 0.02681187f, -0.02199198f, 0.01741686f, 0.00711893f, 0.01503824f, 0.00959821f, 
    -0.03822137f, -0.03598335f, 0.00570854f, 0.03199882f, 0.03660842f, 0.02741783f, 0.01836148f, 0.01663285f, 
    -0.03532286f, -0.03338552f, 0.00511942f, -0.00777311f, -0.00332750f, -0.00599607f, 0.01825052f, -0.00954736f, 
    -0.03596603f, -0.01603177f, -0.00115121f, -0.03370877f, -0.01186689f, -0.02640525f, -0.02007767f, -0.00128624f, 
    -0.00769900f, 0.01586783f, -0.01620649f, -0.01023879f, -0.02782538f, -0.02089952f, 0.00915040f, -0.03259159f, 
    -0.03553960f, 0.03059711f, -0.02614756f, -0.03407928f, 0.01867871f, -0.03300972f, -0.04139347f, 0.00209163f, 
    0.03102967f, 0.03174780f, -0.03142144f, -0.02987035f, 0.02682990f, -0.03605673f, -0.04076575f, 0.01471729f, 
    -0.02371890f, -0.03087926f, -0.03945220f, -0.01374042f, 0.00898098f, -0.00110245f, 0.02324371f, -0.01492343f, 
    -0.02739040f, -0.01276520f, 0.00524784f, 0.02700353f, 0.01653483f, -0.00509060f, -0.03390797f, -0.02634788f, 
    0.00079849f, -0.00365786f, 0.02464820f, -0.01815289f, -0.00219081f, -0.02581649f, -0.03900228f, 0.03330792f, 
    0.01392459f, -0.01493587f, -0.00111326f, 0.02481432f, 0.02007139f, 0.00304639f, -0.03241724f, 0.03067170f, 
    0.00349550f, 0.01785763f, 0.03045147f, -0.02634910f, -0.01043259f, -0.03295654f, -0.02199115f, -0.03156380f, 
    -0.02730070f, 0.01938935f, 0.00693571f, -0.03027929f, 0.01619733f, 0.00971570f, -0.02395009f, 0.01006925f, 
    -0.01192222f, 0.00722014f, -0.01145898f, 0.00839609f, -0.02917521f, -0.04420130f, -0.03555041f, -0.03356184f, 
    -0.00561015f, -0.01203225f, -0.00387438f, -0.01097256f, 0.00725328f, 0.01143824f, 0.02767841f, 0.02832123f, 
    0.01956566f, 0.00576840f, 0.02505304f, 0.01754728f, -0.02907443f, -0.01577885f, -0.03573804f, 0.02758867f, 
    -0.03823559f, -0.02945517f, -0.00451258f, 0.03081930f, -0.03037249f, -0.03954591f, -0.00093623f, 0.02968362f, 
    -0.03306782f, -0.03052166f, 0.00677008f, -0.04244404f, 0.01105213f, 0.01342134f, -0.04636852f, 0.02789763f, 
    0.01322794f, 0.00033809f, 0.01757638f, 0.00131463f, -0.04433629f, -0.01751483f, -0.00594610f, 0.00781459f, 
    -0.03478666f, -0.02405501f, 0.01228334f, -0.03925141f, 0.00780064f, -0.03408038f, -0.02159082f, 0.01248609f, 
    -0.00598090f, 0.02310297f, -0.03772947f, 0.01561967f, -0.01876802f, 0.01152760f, 0.01468582f, -0.02560980f, 
    -0.01748806f, 0.01346363f, -0.04342308f, -0.03010275f, -0.01486289f, 0.01170294f, -0.03241183f, -0.01674470f, 
    -0.04405193f, 0.02224863f, 0.01328794f, 0.00935046f, 0.00311998f, 0.03298173f, 0.01392369f, -0.02305136f, 
    0.02967911f, -0.00736484f, 0.02783405f, -0.03817154f, 0.03371335f, -0.04097096f, 0.02641513f, -0.00948989f, 
    -0.01941457f, 0.00656697f, 0.02028329f, -0.01928017f, 0.01304173f, 0.03600745f, -0.00921869f, -0.00179621f, 
    -0.01735655f, -0.00345492f, -0.03181129f, 0.01207162f, -0.02500969f, -0.00629843f, -0.03836097f, -0.00165523f, 
    -0.00371595f, -0.02761189f, -0.02566756f, -0.02880891f, -0.00001991f, 0.02785877f, 0.00141733f, -0.03093121f, 
    -0.01984144f, -0.00843009f, 0.00241244f, -0.01891269f, -0.01082698f, -0.02187642f, -0.00656607f, -0.03994064f, 
    -0.00904836f, -0.04462956f, 0.01744989f, 0.01522307f, -0.01302155f, 0.03321968f, -0.00760074f, -0.00009126f, 
    -0.03019797f, -0.01992487f, 0.03350475f, -0.00760158f, -0.01706559f, 0.00241495f, 0.00269448f, -0.03337232f, 
    -0.04056741f, -0.04409219f, 0.01787838f, 0.01611213f, -0.01603898f, -0.00263684f, -0.03912814f, -0.01238993f, 
    0.00576387f, -0.00403023f, 0.02251534f, 0.03205677f, 0.02524895f, -0.00268301f, -0.02042921f, 0.02440917f, 
    0.00442105f, 0.02475075f, -0.04349228f, 0.00720446f, -0.02784499f, 0.00844981f, 0.03156611f, -0.00449315f, 
    0.02493653f, 0.00542101f, 0.03444676f, 0.01509230f, -0.02310282f, -0.00804764f, -0.03284976f, 0.02089623f, 
    0.01722524f, 0.00597440f, -0.00247496f, -0.00381703f, 0.00785042f, -0.00354415f, -0.00974545f, -0.01169609f, 
    0.00795832f, -0.02277983f, -0.03240686f, -0.03751570f, -0.02462514f, -0.03317985f, -0.01533417f, 0.00899833f, 
    -0.00087620f, 0.03656032f, -0.00225032f, 0.02209331f, -0.02971772f, 0.00561325f, 0.02408030f, -0.02483847f, 
    -0.03096247f, 0.01759287f, 0.02967289f, -0.04504561f, 0.00179374f, -0.00613292f, 0.01827522f, -0.03862908f, 
    -0.03017079f, -0.03441473f, -0.04233975f, 0.00962747f, 0.00629203f, 0.02401808f, -0.00448417f, 0.01905247f, 
    -0.01856068f, 0.01899103f, 0.02207931f, -0.03500618f, 0.00814601f, 0.03487418f, 0.00510294f, -0.00249311f, 
    0.01334460f, 0.01798847f, -0.01936042f, -0.03855878f, -0.03885719f, -0.03447386f, 0.01823839f, -0.00313852f, 
    0.00710839f, -0.00691279f, 0.01234351f, -0.00780499f, -0.01862997f, -0.01145638f, 0.00707294f, -0.01790968f, 
    0.00807129f, 0.01928861f, 0.01277137f, 0.02407710f, -0.01016504f, -0.02310176f, 0.01205395f, -0.02190712f, 
    -0.02247849f, -0.03814872f, -0.00981643f, -0.01582715f, 0.02654173f, 0.03214021f, -0.00692624f, -0.04194178f, 
    -0.00455268f, -0.01287677f, 0.00224873f, 0.00590106f, -0.04292779f, 0.00987763f, -0.01777632f, -0.02491964f, 
    -0.03211477f, -0.00321364f, -0.00139117f, 0.02748869f, 0.00130354f, 0.02975081f, 0.00128411f, 0.00571366f, 
    0.02587572f, 0.02512435f, -0.03112129f, -0.02810005f, -0.04066222f, 0.00992688f, 0.00021743f, 0.01798849f, 
    0.00885894f, -0.02839338f, -0.01307611f, 0.00791656f, -0.02299932f, 0.02378184f, 0.00897190f, -0.02117779f, 
    -0.00464336f, -0.00694563f, 0.00234467f, -0.01393052f, 0.01154940f, -0.02678810f, 0.01098544f, -0.02698616f, 
    0.00059313f, -0.02869138f, 0.02526377f, -0.01942742f, -0.03722627f, 0.02387590f, -0.02747518f, 0.00331962f, 
    0.00408500f, -0.00520155f, -0.01303091f, -0.01202711f, 0.00857931f, 0.02067509f, 0.00316500f, -0.03158472f, 
    0.01023206f, 0.02369367f, 0.02223284f, -0.00574836f, -0.02395820f, -0.01362255f, -0.02105830f, 0.01087370f, 
    -0.03032172f, -0.00551375f, 0.03473199f, -0.00874588f, 0.02886918f, 0.02592080f, -0.03086896f, -0.02169332f, 
    0.01398737f, -0.03542409f, 0.03433794f, 0.00635985f, 0.01387341f, -0.03479321f, -0.01268386f, 0.00546281f, 
    -0.02004302f, -0.01212600f, -0.00000446f, 0.00538093f, -0.03057769f, 0.02751487f, 0.02147072f, 0.02314075f, 
    0.00095528f, 0.02910652f, -0.02128415f, 0.02034739f, -0.02820652f, -0.03546830f, -0.01307610f, -0.00237706f, 
    -0.02910083f, 0.02770595f, -0.00983219f, 0.03166320f, -0.03929947f, -0.00747205f, -0.01542085f, -0.00306932f, 
    -0.03940557f, 0.02176434f, 0.01463107f, -0.00712003f, -0.02363073f, 0.03033732f, -0.04347781f, 0.01433461f, 
    -0.00301266f, -0.03983660f, -0.02386629f, -0.03242802f, 0.03664543f, 0.04278834f, -0.03097883f, 0.04093037f, 
    0.02082986f, 0.02638539f, -0.04141647f, -0.00744410f, -0.01241330f, -0.01459538f, -0.03116917f, 0.02102155f, 
    -0.01212763f, -0.02878452f, 0.02462322f, -0.04098989f, 0.03103844f, -0.00584970f, 0.01879474f, 0.00234311f, 
    -0.01551533f, -0.00950745f, -0.01779739f, 0.03354221f, -0.01468127f, -0.04105721f, -0.02523288f, 0.00122782f, 
    0.00705530f, -0.00117560f, -0.02246876f, -0.00833993f, -0.03632044f, 0.01482305f, 0.00920209f, -0.00816455f, 
    0.00813074f, -0.00066161f, 0.03337821f, 0.01858689f, 0.00902633f, 0.01511626f, -0.02593748f, -0.03629079f, 
    0.01639042f, -0.02329731f, -0.01132391f, 0.02166355f, -0.01158634f, -0.02679986f, -0.01660052f, 0.00407710f, 
    -0.01647449f, -0.00700202f, -0.01722040f, 0.01988870f, -0.03486538f, -0.01365232f, -0.02707071f, -0.00722894f, 
    0.01054744f, -0.03541004f, -0.00805200f, 0.02228883f, -0.02291246f, 0.00702213f, -0.00602962f, -0.00494952f, 
    0.02878353f, -0.02552016f, -0.04247030f, -0.00344438f, -0.01459272f, -0.03026423f, -0.01109757f, -0.02709748f, 
    -0.01780781f, 0.03126940f, -0.02154990f, 0.00325534f, -0.03449917f, -0.02952335f, 0.02088631f, 0.00661359f, 
    -0.02572121f, -0.02425009f, 0.00111194f, -0.00851768f, 0.01737263f, 0.02717473f, 0.00177351f, -0.02330364f, 
    0.02718342f, -0.02070381f, -0.02459063f, -0.02214618f, -0.00970952f, -0.02343549f, 0.02040989f, 0.02753609f, 
    0.02638252f, -0.03022210f, -0.01124139f, -0.01354930f, -0.01741348f, -0.01927380f, -0.02482557f, -0.02986978f, 
    -0.01300976f, 0.01493260f, -0.02175605f, -0.04493261f, 0.02548108f, 0.01351611f, 0.01577853f, 0.02472468f, 
    -0.00219994f, -0.02764565f, 0.02942894f, 0.01229837f, -0.00657982f, -0.01215261f, 0.02772751f, 0.02935555f, 
    0.02793317f, 0.01426182f, -0.02008423f, -0.03577355f, 0.02182032f, -0.03334037f, 0.03172700f, -0.02399212f, 
    -0.03854732f, -0.01807885f, 0.02159692f, -0.04038849f, -0.01024344f, 0.02382974f, -0.01986775f, 0.00357806f, 
    0.00717693f, -0.01928895f, 0.00546623f, 0.01110360f, -0.03856057f, -0.03397942f, -0.01395100f, -0.01069762f, 
    0.01696490f, 0.03473025f, 0.02527981f, 0.01477364f, 0.00061781f, -0.00227178f, -0.04091243f, -0.01398041f, 
    -0.01049071f, -0.00760462f, -0.02914746f, 0.02569122f, -0.00150722f, -0.03684263f, -0.00456396f, 0.01912320f, 
    -0.03575297f, -0.01245705f, -0.03965420f, -0.00756688f, -0.00171166f, 0.02150702f, -0.00741567f, -0.00565668f, 
    0.00602042f, 0.02557264f, -0.00560884f, 0.01518312f, -0.00791877f, 0.01269708f, -0.02457310f, 0.02013819f, 
    0.01467407f, 0.00016048f, 0.01740639f, 0.01310143f, -0.02188060f, 0.03920823f, -0.02691927f, -0.02977533f, 
    0.03198380f, -0.00707605f, 0.00037848f, 0.03210502f, 0.03037814f, 0.02775347f, 0.00003130f, 0.00953478f, 
    -0.02287837f, -0.00134252f, -0.02497504f, -0.00657536f, -0.01881280f, -0.00564118f, -0.01689665f, 0.03333666f, 
    -0.04097204f, 0.02009542f, 0.01899391f, -0.04263551f, 0.02975948f, -0.01265918f, 0.02671203f, 0.00639433f, 
    0.01048753f, -0.02134573f, -0.03368758f, -0.00306702f, -0.03768858f, -0.04523953f, -0.02995593f, -0.04297433f, 
    -0.01072652f, -0.03680351f, 0.02460272f, 0.00129366f, -0.01063464f, -0.04099229f, 0.01872239f, 0.02341680f, 
    0.00066012f, -0.02445246f, -0.04311559f, -0.00862346f, 0.02405587f, 0.00218025f, 0.00528816f, -0.02723751f, 
    0.02766021f, -0.03091873f, 0.03482738f, -0.02139836f, -0.02620354f, 0.02618653f, -0.01895811f, 0.01851095f, 
    0.00900703f, 0.00605031f, 0.02361858f, -0.02098010f, 0.00669709f, -0.03106975f, 0.01301270f, -0.02953359f, 
    -0.02771331f, 0.01753429f, 0.00830743f, -0.00625438f, -0.00476679f, -0.01085245f, 0.03271783f, 0.00241818f, 
    -0.01810035f, -0.04081004f, 0.01030777f, -0.00028717f, 0.00601111f, 0.02271637f, -0.00072720f, -0.02747116f, 
    -0.00096117f, -0.01819284f, -0.01572637f, -0.01409316f, -0.03911920f, -0.03670716f, -0.01093470f, -0.01531391f, 
    0.01811814f, 0.02845624f, -0.01547224f, 0.03231141f, 0.01573692f, -0.03695057f, 0.01544987f, 0.02410284f, 
    -0.04298837f, -0.01660818f, -0.03743374f, -0.01022474f, -0.03645122f, 0.00545130f, -0.02711283f, 0.02039218f, 
    -0.00864045f, 0.02664772f, 0.01441980f, -0.00503303f, -0.04357154f, 0.00046673f, 0.00419958f, 0.02216111f, 
    -0.01884555f, 0.02137272f, -0.02642237f, 0.03073978f, -0.02740184f, 0.01188113f, -0.03869599f, 0.03288503f, 
    -0.00817871f, -0.01958690f, -0.00557206f, -0.02958161f, -0.03475424f, -0.00932334f, 0.01464281f, -0.01850503f, 
    -0.00452241f, 0.02028909f, -0.01807954f, -0.00856101f, 0.03214653f, -0.01593938f, -0.01389148f, 0.01065710f, 
    0.03000228f, -0.00236087f, -0.00588148f, 0.01552925f, 0.00073970f, 0.02450115f, -0.00497679f, 0.03449202f, 
    0.01620037f, -0.01422825f, 0.00540386f, -0.02619622f, -0.01605441f, 0.00288262f, 0.02539518f, 0.01675166f, 
    0.00879884f, -0.00285545f, 0.03610114f, -0.00721662f, -0.03996980f, -0.02050684f, 0.03370200f, -0.02747321f, 
    0.01774370f, -0.00365477f, 0.03815811f, 0.03553265f, -0.02464401f, -0.03501120f, -0.01120380f, -0.02135877f, 
    -0.02242990f, -0.00873834f, -0.03187076f, -0.01290524f, -0.03983232f, 0.00749903f, 0.03058225f, -0.02170238f, 
    0.01777534f, -0.02247177f, 0.01694027f, -0.03210069f, 0.01289787f, -0.01225909f, -0.01174945f, 0.00260793f, 
    -0.00266895f, -0.03240450f, -0.02351433f, 0.03024476f, -0.01832052f, 0.02445508f, 0.01889751f, 0.02380628f, 
    -0.04013781f, 0.01439118f, 0.03207539f, 0.02406755f, -0.02990697f, 0.00017551f, 0.00062226f, 0.03543753f, 
    -0.03486237f, -0.01495112f, 0.00517869f, 0.02605752f, -0.00271863f, -0.00139065f, 0.02308587f, -0.03938162f, 
    -0.02588054f, 0.02471766f, -0.01041242f, -0.00271849f, 0.03187964f, 0.01111927f, -0.02013438f, -0.03331549f, 
    0.00434191f, 0.02896683f, -0.00142769f, -0.01452630f, 0.03793953f, -0.01058617f, -0.02590479f, 0.00824050f, 
    0.02195427f, -0.03730214f, -0.00091304f, 0.01048239f, -0.03336867f, 0.01340759f, -0.02875602f, 0.00959687f, 
    -0.03761495f, -0.01497134f, -0.01026637f, -0.01036751f, 0.01468641f, 0.00252251f, 0.00541512f, -0.02148133f, 
    0.00522286f, 0.00967628f, -0.02781824f, -0.00016055f, -0.03639144f, -0.02396480f, -0.00006618f, -0.00979581f, 
    -0.04152804f, -0.04105333f, -0.03101802f, 0.01902585f, 0.01560763f, 0.03055113f, 0.01419564f, -0.03764389f, 
    -0.03222524f, -0.01675428f, -0.00147915f, -0.02026421f, 0.01938135f, -0.00946847f, 0.01876141f, 0.03012857f, 
    -0.01194093f, 0.02305386f, -0.00938892f, 0.03625989f, -0.03596886f, -0.01808427f, 0.03880389f, 0.01737418f, 
    -0.03960950f, 0.03326723f, 0.00128720f, 0.01028218f, 0.00474900f, 0.00894317f, -0.03793741f, -0.02440965f, 
    -0.04402896f, -0.03228659f, 0.01372841f, 0.00603505f, 0.01654005f, -0.00078374f, -0.00906543f, -0.01420349f, 
    0.00799742f, 0.03291389f, -0.00134091f, -0.01990943f, -0.03184573f, -0.00465699f, 0.02903235f, -0.03614020f, 
    -0.01349806f, -0.04134817f, 0.02398029f, 0.02379018f, 0.01683703f, -0.01151270f, 0.03080524f, -0.02919225f, 
    -0.04053605f, 0.00439868f, 0.00720612f, 0.02635942f, -0.02857275f, 0.01689233f, -0.00116434f, 0.01964193f, 
    0.01698846f, -0.00071483f, 0.03267751f, 0.01800857f, 0.03508017f, -0.03104721f, 0.01374852f, 0.01978881f, 
    0.03586629f, -0.00983828f, 0.00796744f, -0.01532654f, 0.00572757f, 0.01738046f, 0.02197286f, -0.03415979f, 
    0.01663023f, -0.01374421f, 0.01276927f, 0.01031245f, 0.01237418f, -0.00897372f, -0.03624756f, 0.00508161f, 
    0.01224178f, -0.00726807f, 0.00331054f, 0.00556224f, -0.01548858f, 0.00685506f, -0.04382921f, -0.01290732f, 
    0.03291493f, -0.00879537f, 0.00193824f, -0.00139823f, 0.00467829f, -0.02543801f, 0.00704727f, 0.01742011f, 
    -0.01580012f, -0.00631633f, -0.01502679f, 0.02557890f, -0.02788525f, 0.02699256f, 0.03104822f, -0.03078951f, 
    0.01553739f, 0.00024329f, -0.03166250f, -0.01643622f, -0.02168025f, 0.02731740f, -0.00657594f, -0.02852477f, 
    0.00679571f, -0.01499803f, 0.00779551f, -0.01313228f, -0.03208272f, -0.00795853f, -0.03748523f, 0.03736696f, 
    -0.04306939f, -0.03301879f, -0.01147144f, 0.01161976f, -0.03831904f, -0.00717086f, 0.00158821f, -0.02899499f, 
    0.00318582f, 0.02043986f, 0.03073241f, 0.01657020f, -0.02373201f, -0.03001203f, -0.00860650f, 0.03400254f, 
    0.44554248f, 0.19060043f, 0.25461915f, 0.16228771f, 0.27071464f, 0.04802063f, 0.02159881f, -0.01385820f, 
    -0.10690657f, 0.07632127f, -0.01089865f, 0.02599744f, -0.01599948f, 0.00387408f, 0.12404731f, -0.09716694f, 
    0.18179184f, -0.07692589f, 0.00672112f, -0.01497928f, -0.26846167f, -0.25959158f, -0.05782461f, -0.26550087f, 
    -0.03753012f, -0.03992165f, 0.05777998f, 0.05244435f, 0.01751217f, -0.03934042f, -0.06462651f, -0.02674347f, 
    -0.12474941f, 0.03419963f, 0.00415390f, -0.05547020f, 0.00587167f, 0.01251386f, 0.02017072f, -0.02685667f, 
    0.56351155f, 0.06386375f, -0.01500785f, 0.06870171f, 0.08439106f, 0.01989998f, -0.06455170f, 0.06444157f, 
    0.05491866f, -0.02988006f, 0.06479195f, -0.07713686f, 0.06081969f, 0.05413812f, 0.20204090f, -0.03963653f, 
    -0.03745975f, 0.11939685f, 0.11157654f, 0.10186961f, 0.45955247f, 0.04831868f, 0.05797111f, 0.12556727f, 
    0.18587138f, -0.07097656f, -0.01005417f, 0.06442630f, -0.04181407f, -0.01546455f, -0.01169932f, -0.02321886f, 
    -0.02902319f, 0.03215775f, -0.02936111f, -0.01544646f, -0.07730207f, 0.01085087f, -0.04012221f, 0.01238445f, 
    -0.06457412f, 0.06233577f, 0.04180759f, -0.18027224f, -0.11743917f, -0.10734682f, 0.02143760f, 0.03449921f, 
    -0.11201493f, 0.01394250f, 0.08801682f, 0.17465523f, 0.14673169f, -0.13139544f, 0.06774508f, 0.06275491f, 
    -0.10096796f, 0.07697184f, -0.03066691f, -0.01128070f, 0.40082240f, -0.30003583f, -0.11669406f, -0.02614871f, 
    -0.35671869f, -0.07902610f, -0.03507818f, 0.04134548f, -0.04428084f, 0.00741051f, 0.06948312f, 0.01513431f, 
    0.01319090f, -0.02185312f, -0.08257823f, 0.08119108f, -0.05534056f, 0.07893924f, 0.01306043f, 0.15275139f, 
    0.62940371f, -0.53200686f, 0.10789292f, 0.18321449f, 0.12035720f, -0.01902963f, -0.08052538f, 0.00530166f, 
    0.00480358f, 0.14954352f, -0.01075790f, -0.02904531f, 0.05517900f, -0.01331235f, -0.00507406f, 0.02733979f, 
    -0.03998682f, 0.13538802f, 0.00065056f, -0.03583617f, -0.11345703f, 0.35103226f, 0.20885076f, -0.22268140f, 
    -0.21984142f, 0.03251155f, 0.02394376f, -0.03389624f, 0.04861074f, 0.04772988f, -0.08418787f, -0.02462872f, 
    0.06328147f, 0.08718838f, -0.01256739f, 0.01270171f, 0.02054213f, 0.04306335f, 0.05570352f, -0.05472654f, 
    -0.15006210f, -0.03417975f, 0.17456125f, -0.22729434f, -0.19608916f, -0.03300762f, 0.06693754f, 0.02108111f, 
    0.00130872f, 0.02116937f, -0.07693183f, -0.04463090f, -0.03624059f, 0.05814621f, 0.08856186f, -0.01699854f, 
    0.06861308f, -0.02245914f, 0.03967797f, 0.00618280f, -0.14329949f, -0.07576880f, -0.11738998f, -0.25338283f, 
    -0.27534071f, -0.10540920f, -0.01364690f, 0.10594001f, -0.04814674f, -0.06087349f, -0.00025750f, 0.00333769f, 
    0.02109904f, 0.03163403f, -0.12343086f, 0.03101870f, -0.01328569f, 0.07998306f, -0.06497304f, 0.01199265f, 
    0.00794772f, -0.26187935f, -0.05528566f, -0.16045800f, -0.15729702f, -0.07419272f, 0.04720321f, -0.05144417f, 
    -0.03235893f, 0.00792458f, -0.14388503f, 0.02774037f, 0.10513290f, -0.02404664f, 0.10733824f, 0.07297096f, 
    -0.12854910f, 0.05487097f, 0.04670052f, 0.04887151f, -0.28673741f, -0.18491289f, 0.11274207f, 0.00943161f, 
    0.16650043f, 0.10386629f, 0.01972671f, -0.01495966f, 0.05711927f, -0.01943243f, 0.00410221f, 0.08085972f, 
    -0.05710554f, -0.04986036f, -0.08771690f, 0.06596380f, -0.16369733f, 0.16604324f, 0.01042762f, -0.14700958f, 
    -0.21799728f, 0.30611867f, 0.17439495f, 0.13079287f, 0.05844693f, 0.14377090f, -0.00859911f, -0.08753581f, 
    0.03951960f, -0.04654669f, 0.00462878f, 0.04597748f, 0.01130030f, -0.15147318f, -0.01847742f, 0.04806753f, 
    0.04856790f, -0.09024133f, -0.00938802f, 0.00208299f, 0.06702597f, -0.26737493f, 0.10722663f, 0.11740040f, 
    0.02732143f, 0.08446623f, 0.08238200f, -0.06035813f, 0.06476922f, 0.15004186f, 0.01652750f, 0.02474219f, 
    -0.01305325f, 0.01572019f, 0.02722897f, 0.22089404f, 0.00413568f, 0.01328191f, 0.00057197f, -0.03508016f, 
    0.33854911f, -0.06104250f, -0.02186953f, -0.23054980f, 0.11518671f, -0.02456868f, 0.05963795f, -0.03086185f, 
    0.13507695f, -0.08025842f, 0.11720176f, -0.07748412f, -0.05586959f, 0.06703350f, 0.03417658f, 0.04903994f, 
    -0.00845708f, 0.02461757f, -0.09922699f, 0.02206932f, 0.25892270f, 0.08329871f, -0.10834198f, 0.00707186f, 
    -0.01101813f, 0.14792512f, 0.00474224f, -0.07775133f, -0.11319450f, -0.10926897f, 0.00949889f, -0.02081846f, 
    0.10169034f, -0.02577501f, -0.02460454f, -0.02530687f, -0.11189774f, 0.10468446f, 0.06014628f, -0.06862006f, 
    0.19847120f, -0.17376482f, -0.05149633f, 0.01323705f, -0.11958846f, 0.04500036f, -0.03732336f, 0.10686014f, 
    0.08248275f, 0.03369893f, 0.12179119f, -0.07324837f, 0.19427565f, 0.09488054f, 0.07250563f, 0.12324340f, 
    -0.01693439f, 0.06648332f, 0.03679949f, 0.11401718f, -0.28440484f, -0.07444337f, 0.06185063f, -0.11392520f, 
    -0.09351211f, 0.03080067f, 0.01973672f, 0.03204659f, 0.04916961f, 0.06614758f, -0.06783563f, 0.01064107f, 
    0.01040016f, 0.02826434f, 0.10388431f, 0.06424627f, -0.02307696f, 0.05504727f, 0.03711136f, 0.06748289f, 
    -0.02405463f, 0.31767228f, 0.28997457f, -0.09103586f, -0.00027766f, -0.05580486f, 0.07777930f, 0.02248928f, 
    0.08672144f, -0.06181412f, -0.01930818f, -0.02354969f, 0.11255156f, 0.05387320f, -0.01517464f, -0.00763042f, 
    0.12993099f, 0.00442823f, -0.05691435f, -0.06066162f, -0.17497107f, 0.35762510f, 0.21705243f, -0.02968245f, 
    0.00683572f, 0.00867465f, 0.09645639f, -0.09487581f, -0.05853375f, -0.02556491f, -0.13641809f, 0.03499099f, 
    -0.00691178f, 0.00722980f, -0.11967513f, 0.09670415f, 0.06879050f, -0.06979074f, 0.04882348f, -0.08595486f, 
    -0.04395075f, -0.13558474f, 0.19157399f, -0.15334962f, -0.01220198f, -0.06084980f, -0.03733356f, -0.06860441f, 
    0.03592445f, 0.03589552f, -0.09837798f, 0.01524219f, -0.05450414f, 0.03499622f, 0.01737703f, -0.00297489f, 
    0.10053317f, -0.06496519f, 0.07102887f, -0.03154915f, 0.01609726f, -0.27422976f, 0.07087770f, -0.08408449f, 
    -0.12622803f, -0.00508140f, 0.09824482f, 0.08186318f, 0.00754489f, 0.14925162f, 0.04875802f, 0.10859531f, 
    -0.00218936f, -0.06682859f, 0.01083587f, -0.00190336f, 0.05081545f, -0.06271110f, 0.03175049f, 0.13407739f, 
    0.32155326f, -0.61832780f, -0.10469108f, -0.08014780f, 0.03669023f, 0.18656231f, 0.14227587f, 0.04858845f, 
    -0.10624021f, -0.04867724f, -0.04405216f, -0.04415995f, -0.03402931f, -0.06275525f, 0.05180040f, -0.03428536f, 
    0.03849936f, 0.15367912f, 0.07955493f, -0.06782873f, 0.07131041f, 0.42623240f, 0.17051971f, 0.06504134f, 
    0.06322286f, -0.02833436f, 0.03648268f, 0.04938580f, -0.00432573f, -0.06905133f, 0.05963146f, 0.02037682f, 
    -0.02397026f, 0.04591000f, -0.12485318f, -0.05914823f, 0.11180449f, 0.03219677f, -0.05201521f, -0.00888473f, 
    -0.28381395f, -0.15758383f, -0.17397238f, -0.18768948f, -0.14301229f, -0.00183728f, 0.10190979f, -0.12682484f, 
    -0.00591366f, 0.02684347f, 0.06389981f, 0.03596767f, 0.03204594f, 0.04780490f, 0.07975995f, -0.09260914f, 
    0.05102482f, 0.04960425f, -0.19242667f, -0.04043806f, 0.41868168f, -0.10444405f, -0.14134437f, 0.06850192f, 
    -0.18363567f, -0.02551536f, 0.03952475f, 0.09346084f, -0.05347216f, 0.03146377f, 0.04522386f, -0.07610032f, 
    -0.01504177f, 0.07144877f, 0.01718023f, 0.05992488f, -0.00786476f, -0.06582630f, 0.08661753f, 0.12040901f, 
    0.55081320f, -0.11430675f, 0.04265984f, 0.13410927f, 0.10270444f, -0.01536202f, 0.05109335f, 0.01034037f, 
    0.01127838f, 0.08580919f, 0.05607627f, -0.14586914f, 0.01209846f, 0.10406105f, 0.09582549f, 0.14658982f, 
    -0.07840599f, -0.03651894f, 0.01436569f, 0.02336257f, -0.23709553f, -0.17110397f, -0.02695761f, -0.05303251f, 
    0.07549813f, -0.12962252f, 0.15666606f, -0.06502856f, 0.02915222f, 0.06503644f, 0.01174312f, 0.02955783f, 
    0.06395456f, 0.08466484f, -0.01704811f, 0.19577198f, -0.06346063f, 0.03015582f, 0.07684840f, 0.10145923f, 
    0.27086866f, 0.14055213f, -0.09439597f, -0.34229913f, -0.32221565f, -0.02198060f, -0.00562776f, -0.13264847f, 
    -0.01788863f, -0.01295018f, 0.06247463f, 0.06413583f, -0.01164243f, -0.04393072f, -0.08427860f, 0.02734951f, 
    0.10232098f, 0.04756167f, 0.06892330f, -0.06672266f, 0.40926728f, 0.16893624f, -0.00758182f, 0.10877617f, 
    0.31968409f, 0.00536777f, 0.05726792f, -0.02989608f, -0.02620375f, -0.04926408f, 0.03556352f, 0.02340567f, 
    -0.02793307f, 0.01263910f, 0.01606084f, 0.15816930f, -0.08151013f, 0.07822234f, -0.02394426f, -0.03824241f, 
    0.33136997f, 0.30914667f, 0.25461498f, 0.28992662f, 0.10110664f, -0.08050513f, 0.01159476f, -0.00464046f, 
    -0.01871431f, -0.04137418f, -0.16086958f, 0.11059184f, 0.02110613f, 0.01789951f, 0.10761096f, -0.09089675f, 
    0.11368731f, 0.06578689f, 0.05395499f, -0.00993137f, -0.16759406f, 0.19461456f, 0.02019617f, 0.26065829f, 
    0.09968007f, 0.04867832f, -0.03534634f, 0.01605465f, 0.19596653f, -0.13727549f, 0.09283074f, -0.01526583f, 
    0.05442945f, 0.02675376f, -0.04987201f, 0.01167674f, 0.01756360f, -0.00954580f, 0.09868874f, -0.07522886f, 
    0.02634250f, -0.02323137f, -0.04542613f, 0.00908379f, 0.01541274f, -0.01404833f, -0.01845352f, -0.03986959f, 
    0.01556662f, 0.00163238f, -0.04867357f, 0.02864660f, 0.02419067f, -0.04609031f, -0.00130028f, -0.04398767f, 
    -0.00614822f, -0.02439626f, -0.00973618f, -0.03528525f, 0.00735362f, 0.02029065f, 0.02451498f, -0.01924105f, 
    -0.00221286f, 0.02623560f, -0.00843574f, 0.02474237f, -0.01232812f, -0.00650117f, -0.04426949f, 0.00593200f, 
    -0.04143044f, -0.04432831f, 0.00147549f, 0.00357607f, 0.03005318f, -0.00335748f, -0.00338420f, -0.04169654f, 
    0.02360223f, -0.01556513f, 0.02648783f, 0.02027924f, -0.00672976f, -0.03370246f, -0.00836643f, 0.03013887f, 
    -0.01641663f, -0.01575354f, -0.00130181f, 0.00468047f, -0.03550225f, 0.01988467f, 0.02445189f, -0.04203212f, 
    -0.01240704f, -0.03324766f, -0.02484876f, 0.01526157f, -0.02796544f, 0.01798244f, 0.00150688f, -0.00968963f, 
    -0.04506954f, 0.02344653f, 0.02414626f, 0.00982608f, 0.01042938f, -0.04482378f, -0.01115885f, 0.01780837f, 
    0.01019948f, -0.01074470f, -0.03251299f, 0.00744253f, -0.02749551f, -0.03697211f, -0.01130128f, -0.00691561f, 
    0.00586213f, -0.02410239f, -0.01786477f, -0.04052024f, -0.01192114f, 0.02801595f, -0.00077832f, 0.03053546f, 
    -0.03836057f, 0.00413446f, -0.02447709f, -0.03274347f, 0.00540050f, -0.03093877f, -0.01225250f, -0.00920036f, 
    0.02937533f, -0.00461672f, -0.03276822f, 0.02641677f, -0.01430005f, 0.00177670f, 0.01818231f, -0.00715555f, 
    0.04070858f, -0.03930351f, -0.01590980f, 0.01327204f, 0.02783612f, -0.01489548f, 0.00853112f, 0.03135353f, 
    -0.00284054f, -0.03122785f, -0.00790402f, 0.00782679f, 0.01360397f, -0.02856447f, 0.00664463f, -0.03024197f, 
    -0.03129330f, -0.00271217f, 0.00261010f, -0.02056753f, -0.03828990f, -0.01136297f, -0.00755427f, -0.04569510f, 
    -0.00585770f, -0.00654849f, -0.04534265f, -0.03338296f, -0.04641816f, -0.03690801f, -0.04117088f, -0.03048652f, 
    -0.03396588f, 0.02502343f, -0.03960478f, -0.00245714f, -0.01627946f, -0.01994243f, 0.01519944f, 0.02030638f, 
    0.01201541f, -0.03077387f, 0.02793281f, 0.00095550f, -0.01657023f, -0.01035221f, -0.03948528f, -0.03948615f, 
    0.02437400f, 0.01495786f, 0.03328614f, -0.00952316f, -0.00749749f, -0.01717526f, 0.00390868f, -0.00973127f, 
    0.02526297f, -0.02631294f, -0.00472676f, -0.01237669f, -0.02758908f, -0.03067275f, -0.02661750f, 0.01622859f, 
    0.02650668f, -0.04048937f, -0.01075914f, -0.03182083f, -0.03231268f, 0.01398777f, 0.02505029f, 0.00849582f, 
    0.00383513f, -0.00393297f, 0.00224100f, -0.03690642f, -0.03830325f, -0.01608530f, 0.00752576f, -0.01686984f, 
    -0.00175027f, 0.01819053f, 0.01882783f, 0.03094030f, -0.00022118f, -0.01583274f, 0.02813854f, -0.00799866f, 
    -0.00543102f, -0.00361843f, -0.01152428f, 0.00701166f, -0.01671207f, -0.01891743f, 0.02087874f, -0.01237196f, 
    0.02355964f, 0.01399860f, 0.00144961f, -0.02517708f, 0.03439983f, 0.02141954f, 0.00173767f, -0.00003065f, 
    0.00075678f, 0.01196339f, 0.00627940f, -0.00151804f, 0.01661249f, -0.03207911f, 0.02915838f, 0.01658096f, 
    0.01540857f, 0.02537545f, -0.02924926f, -0.03256083f, -0.04219300f, -0.02774284f, 0.00907119f, 0.03004937f, 
    -0.03895013f, 0.00696912f, -0.03486146f, 0.00502629f, -0.02253663f, 0.02534920f, 0.03318372f, 0.02574569f, 
    0.02179762f, 0.02990787f, 0.00591612f, -0.03959553f, -0.03752812f, -0.00892620f, -0.00546659f, -0.01303531f, 
    -0.04141867f, -0.04238087f, -0.00812001f, -0.00052771f, -0.02102824f, -0.03104573f, -0.03017448f, -0.03781120f, 
    0.02771433f, -0.02995102f, -0.00240820f, -0.02171184f, -0.01506955f, -0.00521889f, 0.02137442f, 0.02971111f, 
    -0.01514853f, -0.00932294f, -0.00297860f, -0.02863938f, -0.01073018f, -0.01906728f, -0.02291131f, -0.02658854f, 
    -0.03426528f, -0.02869281f, 0.02591151f, -0.02685938f, -0.03160201f, -0.00757103f, 0.02703342f, -0.01476246f, 
    0.02291510f, -0.03452372f, -0.02112028f, 0.00642796f, -0.03399680f, -0.01428316f, -0.04015322f, 0.03406627f, 
    -0.02251797f, 0.00635468f, -0.01486160f, -0.01215207f, -0.02413900f, -0.02010832f, -0.02974516f, 0.00763375f, 
    0.00253314f, 0.01933322f, -0.04011742f, 0.02959607f, -0.02534490f, -0.00316583f, 0.02815844f, 0.02453521f, 
    0.02684763f, 0.01514733f, 0.03135057f, -0.03982282f, -0.03593185f, -0.00278525f, -0.03253241f, 0.02832903f, 
    0.01602962f, -0.04160071f, 0.00595890f, -0.01769554f, 0.02075830f, -0.00879959f, 0.00817827f, -0.01591022f, 
    -0.04714598f, -0.04055611f, -0.00312044f, -0.01640406f, -0.04698231f, -0.03880648f, 0.02568239f, 0.01727453f, 
    0.01501638f, -0.03133800f, -0.00772383f, -0.03773429f, -0.00275744f, 0.00126275f, 0.03329147f, 0.01130516f, 
    -0.04161246f, 0.00581759f, 0.00313511f, 0.02384985f, -0.00944530f, 0.01787967f, -0.02114371f, 0.01895267f, 
    -0.02921345f, 0.00379678f, -0.02344188f, 0.01998459f, -0.02444860f, 0.03584754f, -0.02760833f, -0.00821071f, 
    0.02802949f, 0.00609556f, 0.01330148f, 0.01334433f, 0.01199352f, -0.02843322f, -0.03863186f, -0.04097845f, 
    0.01654355f, 0.02136532f, 0.01310102f, -0.00642028f, -0.03663950f, -0.02779807f, 0.00557824f, -0.01200874f, 
    -0.01823760f, -0.01986496f, -0.04663663f, 0.01561487f, -0.02804252f, -0.03146409f, -0.00780856f, -0.00414431f, 
    0.01725687f, -0.03768755f, -0.03919759f, -0.03855564f, 0.01640211f, -0.03052704f, -0.01915237f, -0.03722147f, 
    0.02800088f, 0.02576820f, 0.02265887f, 0.02008519f, 0.01234566f, 0.00503992f, -0.00093192f, 0.02459523f, 
    0.01442056f, -0.01359357f, 0.01483870f, 0.01671051f, -0.00756053f, 0.00334958f, -0.00902793f, 0.00615436f, 
    -0.02569018f, -0.00019908f, -0.01793674f, -0.03191070f, -0.00883923f, -0.04698147f, -0.03201267f, 0.02764286f, 
    -0.02973289f, -0.04175646f, -0.02718194f, -0.03874517f, -0.01066177f, -0.01293001f, -0.02222245f, -0.03384607f, 
    0.01882898f, 0.01401371f, -0.01425924f, -0.02384880f, -0.01089645f, -0.01671724f, -0.02092249f, 0.00677352f, 
    -0.01717931f, 0.02060296f, 0.02559049f, 0.01892709f, -0.03157409f, 0.00989723f, 0.02727906f, 0.03270127f, 
    -0.02995606f, -0.02646143f, -0.03149558f, -0.02937052f, -0.01990264f, -0.04421299f, 0.01933544f, 0.00067723f, 
    -0.03983627f, -0.04432231f, -0.03490901f, 0.00762408f, 0.01064547f, -0.01131634f, -0.03872973f, 0.00184396f, 
    -0.01898002f, -0.03907165f, 0.00085064f, -0.02452518f, -0.03665826f, -0.01595722f, -0.03207539f, -0.04779722f, 
    -0.01345281f, 0.03141023f, 0.00369596f, 0.02029222f, -0.03239800f, -0.04058410f, -0.04058380f, -0.00852573f, 
    0.00891794f, -0.04339122f, 0.00762752f, 0.00004576f, -0.04160160f, 0.00330433f, -0.03164123f, -0.03158166f, 
    0.00779794f, 0.00318822f, -0.01299355f, 0.02573789f, 0.02261597f, -0.00226458f, -0.02229346f, 0.02181438f, 
    0.00694191f, -0.02110739f, 0.00068342f, -0.01383731f, -0.04208300f, -0.02081604f, 0.01141882f, -0.04834079f, 
    0.00904796f, 0.00453283f, 0.00956428f, 0.00742876f, -0.04745956f, 0.01198938f, 0.00093718f, -0.00107602f, 
    0.00294425f, -0.00777490f, 0.02763212f, 0.01083117f, -0.02055017f, -0.00484487f, 0.02196014f, 0.00177470f, 
    0.00095373f, 0.00604435f, -0.00688741f, 0.01134229f, 0.01925961f, -0.01837931f, -0.01277899f, -0.02741548f, 
    -0.03620897f, -0.01927873f, 0.01070763f, -0.03440605f, -0.02545680f, 0.02268291f, 0.00694907f, 0.00509094f, 
    -0.02132086f, 0.01797054f, 0.02148834f, -0.03362267f, 0.02140119f, -0.00881582f, -0.01413526f, 0.01821635f, 
    0.02720509f, -0.00888407f, 0.02123254f, 0.00945874f, 0.02477453f, -0.00149509f, -0.03502379f, -0.04093516f, 
    0.00007911f, -0.03159122f, -0.03742383f, 0.03259041f, -0.02054065f, 0.01227581f, 0.03382817f, -0.05189200f, 
    -0.01418177f, -0.00140938f, 0.02541318f, 0.02405933f, 0.02069350f, -0.00084329f, -0.00501653f, 0.00542417f, 
    0.01836853f, 0.02750883f, -0.00274826f, -0.03767239f, 0.02631013f, -0.03643524f, 0.02734435f, -0.04227617f, 
    -0.01873506f, 0.01423106f, -0.01638652f, -0.02583165f, 0.02279877f, -0.02316284f, -0.02912952f, -0.01567451f, 
    0.02007077f, -0.01494318f, -0.00363518f, 0.00531735f, -0.04287440f, 0.01244200f, -0.01522551f, -0.04464557f, 
    -0.03174765f, -0.02222416f, -0.03179853f, -0.02118941f, -0.00511837f, -0.00633528f, -0.01392962f, -0.02659815f, 
    -0.01660829f, -0.02522249f, 0.02107275f, -0.01943499f, 0.02743906f, -0.04263072f, 0.01599267f, 0.02165830f, 
    -0.04670561f, -0.04021761f, -0.03417607f, -0.03672678f, -0.03412926f, 0.03315336f, -0.01642222f, 0.01096352f, 
    -0.00787436f, 0.02623530f, -0.03066692f, 0.02358377f, 0.00975433f, 0.00754787f, 0.02370995f, 0.00088498f, 
    0.02118088f, -0.01115506f, 0.02790366f, -0.01969808f, -0.01775497f, -0.00611666f, 0.02919938f, -0.02488684f, 
    0.02269268f, 0.00059671f, 0.02212508f, -0.03355969f, -0.02686836f, -0.02158962f, -0.01299871f, 0.00500295f, 
    0.00886345f, 0.00998388f, -0.02805256f, 0.02276956f, 0.02411173f, -0.00857808f, -0.01630516f, 0.00122386f, 
    0.00472444f, 0.02653323f, 0.02868341f, -0.01858166f, 0.00121443f, -0.02745481f, 0.01994671f, 0.02987328f, 
    0.00726675f, -0.02442002f, 0.02308061f, -0.03188345f, -0.03142174f, 0.00473024f, 0.01470774f, 0.03290047f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04309875f, 0.03430566f, 0.02785156f, 0.00465961f, 0.10854670f, 0.01608888f, -0.04513441f, -0.01826293f, 
    0.02074080f, 0.01409361f, -0.03150006f, -0.00901424f, -0.01827036f, -0.01614427f, -0.01392522f, 0.04895808f, 
    -0.05209040f, -0.00301664f, -0.00011041f, -0.00246083f, -0.01116811f, 0.07367269f, -0.07712644f, -0.01073555f, 
    0.02452934f, 0.08567164f, -0.00726880f, -0.01886002f, 0.00094641f, 0.02537486f, -0.07064693f, -0.03926413f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.32453665f, 0.04954423f, -0.42426470f, -0.24219869f, 0.07947900f, -0.08371382f, 0.04149544f, -0.02556229f, 
    -0.08232558f, -0.02232002f, -0.01180197f, -0.03014394f, 0.06175618f, 0.13919674f, -0.14068343f, 0.40665537f, 
    -0.21152678f, -0.15412857f, 0.02080648f, -0.07719882f, 0.13882217f, 0.21613269f, 0.24185792f, 0.16671555f, 
    0.02267462f, -0.70008641f, -0.22194694f, -0.10990334f, 0.11785282f, 0.01149270f, 0.16698079f, -0.07457376f, 
    -0.44997615f, -0.10838638f, 0.17298928f, -0.60871589f, 0.34220186f, -0.01877376f, 0.08114401f, -0.03801817f, 
    0.02621001f, -0.08486064f, -0.15815455f, -0.10817323f, 0.12627369f, -0.06370446f, -0.15659241f, 0.42827317f, 
    -0.15408535f, 0.06206304f, -0.10079647f, -0.10773728f, 0.14157420f, -0.18457319f, 0.26509395f, -0.08172434f, 
    0.15804924f, 0.17129458f, -0.39328584f, 0.03260301f, -0.11329798f, 0.04066749f, -0.06587486f, -0.08427790f, 
    -0.71568453f, -0.14436337f, -0.26277933f, -0.34002462f, 0.14267968f, 0.16699360f, 0.01503493f, -0.06598470f, 
    0.00585641f, 0.06990358f, 0.07846542f, -0.12386096f, -0.03628206f, -0.04944810f, 0.10648887f, -0.57148361f, 
    0.35569382f, 0.06539293f, 0.11059883f, 0.14286304f, 0.06747925f, -0.21316104f, 0.36910728f, 0.15504611f, 
    0.03881838f, -0.12934344f, -0.08945870f, 0.12173617f, 0.12358863f, 0.08270979f, 0.34650543f, -0.05502253f, 
    0.28946343f, 0.00557398f, -0.13991679f, -0.15439200f, -0.37021118f, -0.16189437f, -0.12882398f, 0.06262124f, 
    -0.04936567f, 0.16488707f, -0.08068508f, -0.05356346f, 0.10131068f, -0.08895416f, 0.06055677f, 0.40710881f, 
    0.03280926f, -0.10897344f, -0.03296067f, 0.08021086f, 0.07048161f, -0.33828849f, 0.25256705f, -0.13649757f, 
    -0.09807874f, -0.08706529f, 0.36555681f, 0.11682555f, 0.12836634f, -0.00834930f, -0.92635792f, 0.00134643f, 
    -0.12152264f, -0.15265445f, 0.00961342f, 0.38251027f, 0.33861759f, 0.02633972f, -0.12411736f, 0.06017847f, 
    -0.16540776f, 0.01531104f, -0.18266691f, -0.07797401f, 0.15794246f, 0.15112777f, -0.05858509f, -0.28585485f, 
    -0.33536100f, 0.05640813f, -0.10261613f, 0.02348748f, -0.08365595f, 0.15438044f, 0.01083586f, -0.12974966f, 
    -0.05368820f, -0.18655485f, 0.50712252f, 0.00440966f, -0.07828537f, 0.02844306f, -0.41865090f, 0.14915149f, 
    0.27354956f, -0.04118026f, 0.38788521f, 0.24956067f, 0.24013075f, 0.08465622f, -0.16476850f, 0.00433948f, 
    0.16536888f, -0.03404278f, -0.06757567f, -0.16534464f, -0.07507976f, -0.03785776f, -0.16285476f, -0.12077867f, 
    -0.09376547f, -0.13215183f, 0.11492093f, 0.15474211f, -0.11494450f, -0.03996701f, -0.44392890f, -0.14399819f, 
    0.12910676f, -0.17347386f, -0.67850262f, 0.17085586f, -0.01573838f, -0.00139700f, -0.09199175f, -0.09434858f, 
    -0.49369875f, -0.05818276f, 0.15722591f, -0.11018464f, -0.35458186f, 0.17271283f, -0.15033069f, -0.18284489f, 
    0.06138713f, -0.17533745f, -0.14733467f, 0.03620198f, -0.07030361f, -0.15536325f, 0.01101047f, 0.03300387f, 
    0.18244131f, -0.01248898f, -0.05129496f, 0.12475875f, 0.00335346f, -0.01557213f, -0.58130324f, -0.03151468f, 
    -0.01285274f, -0.30017099f, 0.40553778f, 0.03465604f, 0.11934888f, -0.00539604f, 0.35895699f, -0.05634654f, 
    0.09963853f, -0.05644951f, -0.21869479f, 0.29673085f, -0.26745114f, 0.11971381f, -0.09247147f, -0.03827481f, 
    -0.12217794f, -0.06558022f, -0.01940900f, -0.15767752f, 0.05499981f, 0.07426554f, -0.04172676f, -0.56459993f, 
    0.34234604f, 0.10337754f, -0.13803983f, -0.11743636f, -0.14453803f, -0.84306633f, 0.27287182f, 0.13519067f, 
    -0.13726428f, -0.07553047f, 0.14682469f, -0.03613172f, -0.02157554f, -0.08625003f, -0.22831334f, 0.10715198f, 
    0.24416555f, 0.00186219f, 0.19856654f, -0.34275174f, 0.04076305f, -0.08462412f, 0.15539175f, 0.11276434f, 
    0.06432962f, -0.15452324f, 0.12837863f, 0.03228374f, 0.00201664f, -0.14231423f, -0.04722979f, -0.65692192f, 
    -0.44069839f, 0.01300983f, -0.09476940f, -0.03598788f, -0.08999563f, -0.23742983f, 0.09439556f, 0.13487099f, 
    -0.00102107f, 0.36092103f, 0.02509376f, 0.00818993f, 0.15962039f, 0.11301679f, 0.26508361f, -0.07691547f, 
    -0.54609901f, 0.11033469f, -0.42695653f, 0.52607870f, -0.57861155f, 0.15243059f, 0.00545087f, 0.08420060f, 
    0.04568224f, -0.18190917f, 0.03993001f, 0.08049763f, 0.10043812f, 0.05268406f, -0.15014338f, 0.17843951f, 
    -0.16094851f, -0.02819920f, -0.17644590f, -0.15460415f, -0.10797895f, 0.16927150f, 0.20346867f, -0.10199753f, 
    -0.01005216f, 0.20617399f, -0.22596495f, -0.09709932f, 0.12144360f, -0.15994753f, 0.12453362f, 0.08898211f, 
    -0.00608874f, -0.11493507f, -0.61179835f, -0.31719428f, 0.34516141f, -0.17256655f, -0.03238403f, 0.14854221f, 
    -0.06422123f, -0.09944415f, -0.04789402f, 0.11811707f, 0.00503739f, 0.04941576f, -0.04511523f, 0.19714783f, 
    0.19296710f, 0.17357221f, -0.04881971f, -0.09069262f, -0.08123297f, -0.29196274f, -0.49673817f, -0.03566848f, 
    0.01101840f, 0.50401318f, 0.09752044f, 0.06958479f, 0.06024768f, -0.06168469f, -0.29484388f, 0.04294814f, 
    0.08067653f, -0.09824141f, 0.19769952f, -0.46025842f, -0.66685224f, -0.16567865f, 0.15144929f, -0.14220406f, 
    -0.08387651f, -0.04283681f, -0.16480899f, -0.08164034f, 0.13798891f, -0.03474955f, -0.08168902f, -0.28742063f, 
    0.09757290f, -0.09862641f, -0.07208983f, 0.14613982f, -0.11690523f, 0.46403402f, 0.11319605f, 0.04318442f, 
    -0.03656137f, 0.10384619f, -0.02618866f, -0.16017120f, 0.08430144f, 0.09122415f, -0.62609261f, 0.13144967f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.26021519f, 0.10565796f, 0.08579854f, -0.14476641f, -0.12936182f, 0.06253187f, -0.02251304f, -0.26441783f, 
    -0.13507202f, -0.17593692f, 0.10931050f, 0.17978661f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
