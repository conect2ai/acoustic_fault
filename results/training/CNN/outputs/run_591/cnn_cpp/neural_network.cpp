#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.51487094f, -0.35967848f, -0.34597921f, 0.24156085f, 0.51884121f, 0.00047915f, 0.04029049f, -0.20891853f, 
    -0.13700725f, 0.47110873f, 0.58527720f, 0.14709580f, -0.30359098f, -0.32579756f, 0.23616420f, 0.23049517f, 
    -0.18585117f, -0.37771416f, 0.25804734f, 0.36244619f, 0.59923977f, 0.07246110f, 0.15813076f, -0.25132316f, 
    -0.25294811f, -0.23913065f, -0.30974290f, 0.40883613f, 0.29294488f, -0.66340435f, 0.16000940f, 0.59265763f, 
    -0.35134161f, 0.08522301f, -0.12284546f, -0.04746621f, -0.42224413f, -0.31896776f, 0.21906570f, 0.67108977f, 
    0.67008281f, 0.28474474f, -0.02097993f, -0.03544914f, 0.21539159f, 0.33253369f, 0.04173126f, -0.48087463f, 
    -0.37904993f, -0.15577796f, 0.21506520f, -0.31493527f, 0.09054228f, 0.24951440f, -0.36096865f, -0.37724614f, 
    -0.51736599f, 0.13191211f, -0.46357110f, 0.24743976f, -0.33594680f, -0.01203152f, 0.02297162f, 0.02232279f, 
    0.34838906f, 0.19228940f, -0.09023337f, -0.69599575f, -0.73820597f, 0.02861182f, 0.38491982f, 0.19040282f, 
    -0.15117782f, 0.07071469f, -0.25196525f, -0.73635924f, -0.37659082f, -0.49615818f, 0.41767430f, -0.15492789f, 
    0.17562564f, -0.27512854f, -0.13639204f, -0.38118184f, -0.25608790f, -0.26552665f, -0.31146455f, 0.07568078f, 
    -0.07717501f, -0.53319699f, 0.48741639f, 0.50651455f, 0.11920367f, -0.28502542f, 0.37856585f, -0.38041794f, 
    -0.19840144f, 0.08754259f, 0.15418130f, 0.51050222f, -0.61560464f, -0.10410203f, -0.44777301f, 0.26632518f, 
    0.19130076f, -0.17294310f, -0.27283254f, -0.40049034f, -0.34366837f, -0.39173391f, -0.54006863f, -0.27974629f, 
    0.01607539f, 0.22725487f, 0.28599325f, -0.08642796f, 0.13454439f, 0.61443043f, 0.51177150f, 0.59015423f, 
    -0.59898549f, -0.11836956f, -0.36682612f, 0.10274399f, 0.06146821f, 0.08520667f, 0.36129946f, -0.32914358f, 
    0.55044079f, 0.13770388f, -0.20537424f, 0.44486630f, 0.38803744f, -0.44773647f, -0.39555019f, -0.46078810f, 
    -0.60748351f, -0.63462043f, 0.19872554f, -0.05558411f, 0.32717189f, 0.09664194f, -0.03432579f, -0.13955705f, 
    0.59183443f, 0.21501212f, 0.25410929f, 0.44591668f, -0.18754673f, 0.11092415f, -0.00395088f, 0.41136414f, 
    -0.21894157f, 0.41433397f, 0.42134526f, -0.58806789f, 0.37005508f, 0.20378000f, -0.15409105f, 0.30587986f, 
    0.22452079f, -0.15311600f, 0.68328911f, -0.09450452f, 0.18452066f, 0.05691064f, 0.25710526f, 0.17957422f, 
    0.23966366f, 0.55534935f, 0.19743571f, -0.57655215f, -0.52282971f, -0.20661476f, 0.12305422f, -0.26309615f, 
    -0.28229898f, 0.36910748f, 0.08703856f, -0.16923232f, -0.74058211f, 0.73600972f, 0.15607278f, 0.10474438f, 
    0.07709005f, 0.06640103f, -0.07828368f, -0.10071833f, -0.34349057f, 0.04752555f, -0.49987435f, -0.10483979f, 
    -0.71487206f, -0.52485383f, -0.12492416f, -0.25789422f, -0.01577113f, 0.15702218f, -0.40926874f, 0.67622524f, 
    -0.34287456f, 0.48824182f, -0.15120113f, -0.33814716f, -0.05956369f, 0.08397308f, -0.21329090f, 0.03099117f, 
    0.20937300f, 0.24784505f, 0.64549100f, -0.24488972f, -0.53493720f, -0.18627891f, -0.32779050f, 0.14891122f, 
    -0.67053932f, -0.30752552f, 0.20250759f, 0.21927059f, -0.35217088f, -0.05844136f, -0.01940858f, 0.22566715f, 
    -0.17548457f, -0.48342741f, -0.35469785f, -0.42716980f, 0.33792490f, -0.28969333f, -0.12388283f, -0.09019811f, 
    0.37538600f, 0.44104892f, -0.24524927f, -0.09885228f, -0.24335609f, 0.47940019f, 0.64783102f, 0.37137538f, 
    -0.26498955f, -0.04873059f, -0.37636647f, -0.18635879f, -0.46766126f, -0.21173206f, 0.07604988f, 0.74528146f, 
    -0.46949607f, -0.07382920f, -0.06963294f, -0.43346149f, -0.56283283f, 0.24821989f, -0.45602044f, -0.56189477f, 
    0.05046276f, 0.43778965f, -0.01320177f, 0.29483989f, 0.11725412f, 0.21709892f, 0.33719754f, 0.51286632f, 
    -0.20516703f, -0.35698569f, 0.44078150f, 0.24662022f, 0.15417054f, 0.23730211f, -0.11949457f, -0.58968771f, 
    -0.10207471f, 0.02034848f, 0.32396728f, 0.60608739f, 0.21052970f, -0.06634622f, 0.41546118f, 0.35996881f, 
    0.13834421f, -0.33120874f, 0.45288655f, 0.35620582f, 0.50560123f, 0.32396081f, -0.40291658f, 0.16070430f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.05655691f, -0.08989779f, -0.09171664f, -0.28901649f, -0.09512085f, -0.37728652f, -0.18201034f, -0.22201444f, 
    0.27661824f, 0.16357660f, 0.06762134f, -0.30195370f, 0.14317049f, 0.22444111f, -0.10100228f, -0.26085535f, 
    0.23896804f, 0.01250677f, -0.48630542f, -0.16776739f, 0.00197912f, 0.00050516f, 0.02602427f, -0.19275948f, 
    0.13248754f, -0.19346158f, 0.06813098f, -0.26962557f, -0.14470264f, -0.21644068f, -0.31000718f, 0.01122545f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.12949067f, 0.01050103f, -0.15564516f, -0.06041574f, 0.01500926f, -0.12901977f, -0.14661704f, 0.00571727f, 
    0.16451833f, 0.17430660f, -0.05839882f, -0.03100092f, 0.01233849f, 0.04700016f, 0.01591525f, 0.04458189f, 
    0.02554076f, 0.14596801f, 0.09569128f, -0.06085247f, 0.09726669f, -0.04182063f, -0.12530121f, 0.11464410f, 
    -0.01916470f, -0.02949583f, 0.10090381f, -0.07786436f, -0.35363349f, 0.05172626f, 0.13298562f, 0.08809520f, 
    0.06621595f, -0.11428097f, -0.08973594f, -0.21221486f, -0.23902562f, 0.10717919f, -0.06660131f, 0.10417697f, 
    0.04977192f, 0.04265548f, -0.00662694f, -0.00805234f, -0.00481227f, 0.11798860f, 0.01867621f, 0.10368047f, 
    -0.18292932f, -0.10457332f, -0.21634595f, 0.08493488f, 0.00459887f, -0.05382254f, 0.11790715f, -0.08474921f, 
    0.07295858f, -0.06914581f, 0.22698264f, -0.02183446f, 0.15182763f, 0.01491207f, -0.03876590f, 0.11814524f, 
    0.06060424f, 0.10295719f, -0.21538875f, -0.12099230f, 0.11843431f, 0.04687283f, 0.05398514f, 0.04898620f, 
    0.03200349f, 0.05850024f, -0.04597364f, 0.01874875f, -0.03852732f, 0.06623646f, -0.08655015f, 0.05896337f, 
    -0.02869153f, 0.01455164f, -0.15920833f, -0.17314783f, -0.11213709f, 0.15307334f, -0.01816402f, 0.03507442f, 
    0.20198922f, -0.07367631f, 0.12338421f, -0.05543347f, 0.05828025f, 0.13536328f, 0.07826732f, 0.04270311f, 
    0.09269781f, -0.00860752f, 0.06533816f, -0.02733143f, 0.00384903f, -0.30356696f, 0.13039735f, -0.20945640f, 
    -0.11845075f, 0.02178773f, -0.02727100f, -0.06792054f, -0.04453124f, 0.11468698f, 0.06212910f, 0.10490078f, 
    -0.01128928f, -0.10517658f, 0.06945579f, 0.04005010f, 0.09463755f, 0.17104414f, 0.05238370f, 0.23625024f, 
    -0.07796329f, -0.05208642f, 0.13778961f, 0.16286071f, 0.12785704f, 0.15005021f, -0.34528273f, -0.15610334f, 
    0.16533412f, 0.03086538f, 0.03716493f, 0.18851745f, -0.08155451f, 0.17916225f, 0.07409143f, 0.09833761f, 
    -0.01875436f, -0.14000830f, 0.04308426f, 0.05961696f, -0.17832562f, 0.09523718f, 0.06955198f, 0.05756262f, 
    -0.11038341f, -0.16815819f, 0.08800195f, 0.10965078f, 0.12520199f, -0.01684260f, 0.10530211f, 0.08537498f, 
    0.08876115f, -0.09567326f, -0.17191313f, -0.06091159f, 0.06912680f, 0.05378815f, -0.00416387f, 0.00668333f, 
    0.06693257f, -0.13600791f, -0.23438594f, 0.01741979f, -0.03021489f, 0.11670109f, 0.04407988f, -0.06972754f, 
    0.26344103f, 0.07996416f, -0.16627009f, -0.04529134f, -0.13123266f, -0.26664519f, -0.18171559f, 0.03406815f, 
    -0.08592413f, -0.06556293f, 0.06807067f, 0.04974573f, -0.17062837f, 0.01614303f, -0.04304523f, -0.06851459f, 
    0.11313082f, 0.03115788f, -0.01549938f, -0.03184076f, 0.15114446f, 0.02419513f, -0.01765083f, -0.17467411f, 
    -0.14472455f, -0.17585035f, 0.04534222f, -0.02756173f, -0.05338532f, 0.04138400f, -0.01828715f, 0.08529871f, 
    0.01778681f, 0.11068302f, 0.07525746f, 0.01251601f, -0.05247148f, 0.00001082f, -0.04136756f, -0.16119741f, 
    -0.09754415f, -0.04865156f, 0.07120132f, 0.02076732f, -0.11456391f, -0.01159299f, -0.02346120f, 0.10394868f, 
    -0.05787261f, -0.00256150f, -0.16494101f, -0.03828014f, -0.13094001f, -0.01318774f, -0.06592093f, 0.01292070f, 
    -0.04364046f, 0.07841182f, -0.05275758f, -0.03110379f, 0.05528586f, 0.15707262f, 0.10170420f, 0.18404846f, 
    -0.01170485f, -0.03460867f, 0.07608752f, -0.03114207f, 0.03278136f, 0.04859027f, 0.07404347f, 0.01725824f, 
    -0.15103343f, 0.01284734f, -0.01949075f, -0.03066811f, -0.09842647f, -0.06270659f, -0.04029598f, -0.02305393f, 
    -0.00276675f, -0.22646679f, 0.00282746f, -0.31869543f, -0.17244096f, -0.03130914f, -0.04007592f, -0.11642106f, 
    -0.03698872f, -0.10181185f, 0.04058898f, -0.10793932f, -0.16271202f, -0.21589184f, -0.01400767f, 0.19024299f, 
    0.09346166f, 0.07059880f, 0.11768831f, 0.17114837f, 0.05404624f, 0.13930403f, -0.18235403f, -0.02194428f, 
    0.11469518f, 0.14188437f, 0.05793281f, -0.19162534f, 0.15296853f, -0.06790613f, 0.19915664f, -0.03078429f, 
    -0.11163972f, 0.03550537f, -0.05426000f, 0.11793718f, 0.02528761f, 0.05211591f, 0.01860652f, 0.05808469f, 
    -0.02502012f, -0.05577710f, 0.01799121f, 0.03194077f, -0.02053336f, 0.02781300f, 0.01701882f, 0.02764737f, 
    -0.05697429f, -0.06505527f, -0.01656572f, -0.05869092f, 0.03634527f, -0.02405377f, -0.00385516f, 0.03872791f, 
    0.03455652f, -0.01295585f, 0.02598431f, -0.02313219f, -0.02251399f, -0.04221225f, 0.02961248f, -0.02889744f, 
    -0.04007916f, -0.02268442f, -0.02116162f, -0.01704694f, -0.00127180f, -0.02229344f, -0.01850268f, -0.05589760f, 
    -0.00594421f, -0.04074117f, 0.03890028f, 0.01472868f, 0.04703597f, -0.01690850f, -0.02222463f, 0.03964503f, 
    -0.01832900f, 0.03684431f, -0.00947297f, -0.01061182f, -0.01738459f, -0.04914819f, 0.04395302f, 0.01231418f, 
    0.03990498f, -0.00043679f, -0.02644768f, 0.02893035f, -0.04574716f, 0.00150292f, -0.03909170f, 0.02764477f, 
    -0.02611259f, -0.05491532f, 0.02140058f, 0.02348948f, -0.01036940f, 0.03523036f, -0.00143397f, -0.03249405f, 
    0.03915673f, 0.05122823f, -0.05363050f, 0.01758391f, -0.03439834f, 0.00789812f, 0.02351829f, -0.05595300f, 
    0.01470083f, -0.00991580f, 0.03545495f, -0.05335807f, -0.03376204f, -0.01484125f, -0.02599340f, 0.03470230f, 
    0.00556869f, 0.01366108f, 0.01035947f, -0.03801025f, -0.03968702f, -0.04891101f, -0.05951265f, -0.04470848f, 
    -0.06706247f, -0.05433026f, 0.00001693f, -0.03527616f, 0.03592169f, 0.05294641f, 0.02150266f, -0.00776324f, 
    0.02409453f, -0.05411475f, 0.04025089f, -0.06000747f, -0.02850650f, 0.03903756f, -0.00488098f, -0.06005480f, 
    -0.02378685f, -0.05509488f, -0.02335111f, -0.02057500f, -0.02951061f, -0.03480127f, 0.02930586f, 0.04560534f, 
    0.04466859f, -0.05368796f, -0.02551800f, -0.00101727f, 0.04062227f, 0.04540027f, -0.00546308f, -0.06569495f, 
    -0.05327303f, 0.03392918f, -0.03396633f, -0.00597037f, 0.02310727f, 0.03132339f, 0.04552692f, 0.03741897f, 
    0.03982971f, -0.05226394f, 0.03809245f, -0.06488757f, -0.03507934f, -0.02548372f, 0.03210768f, 0.00647310f, 
    -0.00416404f, -0.03396529f, -0.02610603f, -0.01087399f, -0.00642363f, -0.04570746f, 0.04345844f, 0.03104428f, 
    0.05112575f, 0.03209484f, -0.06671096f, -0.03955036f, -0.04243337f, -0.02738582f, -0.00666342f, -0.06459481f, 
    -0.03389949f, 0.05664226f, -0.04266351f, -0.00978199f, -0.03652059f, 0.02117765f, -0.01553913f, 0.03389281f, 
    0.01464499f, 0.03121504f, -0.04520849f, -0.04127903f, -0.03083486f, -0.04892934f, 0.04813953f, -0.03812224f, 
    0.01002254f, 0.03171838f, 0.01045963f, 0.02174804f, -0.05186540f, 0.00626898f, 0.02696518f, -0.01280536f, 
    -0.06265879f, -0.05328714f, -0.05878185f, 0.04208684f, 0.00618685f, 0.01799104f, 0.02793890f, 0.01243462f, 
    -0.04579108f, -0.04217998f, -0.01341841f, 0.00963614f, 0.02408499f, -0.05311310f, -0.00175428f, 0.04141995f, 
    -0.00171721f, 0.00526130f, -0.05890858f, 0.01068282f, -0.04072601f, -0.01520257f, 0.00067529f, -0.06040463f, 
    0.01914810f, -0.02777017f, 0.03175561f, 0.01137462f, -0.03443214f, -0.00289360f, -0.06747942f, 0.00533171f, 
    0.03710888f, -0.02764041f, -0.02856114f, -0.02160704f, -0.05370419f, -0.01160819f, -0.04746067f, 0.03230584f, 
    0.04716713f, -0.05479684f, -0.00289966f, -0.04364448f, -0.05874240f, 0.03420696f, -0.03228773f, 0.00885577f, 
    0.05068080f, 0.02160373f, 0.02432986f, 0.03283359f, -0.05957191f, 0.03537741f, -0.03535069f, 0.04170587f, 
    -0.00104544f, 0.00515576f, -0.03155739f, 0.03424291f, -0.04348081f, 0.04021941f, -0.05852533f, -0.04287487f, 
    0.00683383f, -0.01382750f, -0.03481764f, -0.01270203f, 0.02180824f, -0.03893147f, 0.03721059f, -0.02230619f, 
    0.01889694f, -0.00753367f, 0.03539597f, -0.03432345f, -0.02461677f, -0.02939259f, -0.02246470f, -0.02207264f, 
    0.02050662f, 0.03389564f, -0.05631050f, -0.04541331f, 0.00408058f, -0.03962613f, 0.00581790f, 0.03256196f, 
    -0.04541436f, 0.00354370f, -0.03216601f, 0.03616812f, 0.00770474f, -0.03384525f, -0.06059894f, 0.02154056f, 
    0.05446055f, 0.01455684f, -0.01589854f, -0.01303678f, -0.04075316f, -0.03226039f, -0.03136033f, 0.01158157f, 
    0.04766048f, -0.04796767f, 0.04574299f, -0.03354584f, 0.02161516f, 0.01860940f, 0.00476744f, -0.05213663f, 
    -0.19291635f, -0.12351679f, 0.08356380f, -0.33317241f, 0.00879251f, -0.05528148f, 0.01413900f, -0.09950150f, 
    -0.08560648f, 0.15818308f, -0.00065052f, 0.12783271f, 0.09209643f, 0.05321592f, -0.00162785f, -0.04739492f, 
    0.02110903f, -0.00061429f, 0.00370446f, -0.13493112f, -0.17666204f, 0.16869080f, 0.09229299f, 0.08662066f, 
    0.11267620f, 0.06883151f, -0.09629907f, 0.08231283f, 0.16271715f, -0.26979840f, -0.07857418f, 0.01231677f, 
    -0.03421680f, 0.03706623f, -0.16550432f, 0.04105443f, 0.08539052f, -0.02979826f, 0.13005134f, -0.28588960f, 
    -0.09094149f, 0.00648692f, -0.08491622f, -0.04689207f, 0.17927784f, 0.08470799f, -0.02905854f, -0.05477353f, 
    0.14622638f, -0.04152904f, 0.03477323f, -0.06079967f, 0.28691974f, 0.05768837f, -0.11012037f, -0.06114664f, 
    0.09935215f, -0.11832734f, 0.04625180f, 0.09302052f, 0.00586871f, 0.13486958f, -0.00186917f, 0.24083208f, 
    -0.08398011f, -0.13683957f, -0.00213248f, 0.02283824f, 0.02318831f, -0.01558329f, -0.07287931f, -0.03011732f, 
    0.13809334f, -0.00920615f, -0.05919146f, 0.13289025f, 0.01152280f, 0.12099035f, 0.01105872f, 0.08227891f, 
    -0.02825736f, -0.01737447f, -0.01428731f, -0.01716082f, 0.07215659f, -0.02465206f, 0.01956156f, 0.04260970f, 
    -0.02501413f, -0.13587354f, -0.10504182f, 0.11101008f, -0.25976980f, 0.07592828f, 0.08437406f, -0.00415598f, 
    -0.08162194f, 0.05317040f, 0.09033664f, -0.12293366f, 0.14547348f, -0.03791762f, 0.16518936f, -0.06673901f, 
    0.14933510f, 0.12519084f, -0.01397421f, -0.05115752f, -0.07772189f, 0.09907017f, 0.09418255f, -0.02270162f, 
    0.00410960f, -0.06653185f, 0.06305128f, 0.10145551f, 0.00280989f, 0.20989555f, -0.13795592f, -0.10158494f, 
    0.11982214f, 0.12661546f, 0.06747611f, 0.06247679f, -0.05361716f, -0.05714406f, -0.04461037f, 0.11977173f, 
    0.16473813f, 0.14551076f, -0.00230874f, -0.06377930f, 0.03815771f, -0.00053160f, 0.08099107f, -0.22943217f, 
    0.01719218f, 0.15996116f, -0.21310864f, -0.04003313f, -0.07806377f, 0.00185579f, 0.08806545f, -0.03043835f, 
    -0.06783078f, 0.03185830f, -0.10435451f, 0.18912861f, 0.09474271f, -0.04942634f, 0.03772192f, 0.16079731f, 
    0.01106987f, 0.04700743f, 0.11931574f, -0.20901257f, 0.07492052f, 0.03774391f, -0.14451867f, 0.04512114f, 
    0.00780083f, -0.04779604f, 0.06239855f, 0.17266779f, -0.14994159f, 0.02179548f, 0.04410576f, -0.05558037f, 
    0.05749070f, 0.08393908f, 0.20571519f, -0.07184020f, -0.04354915f, 0.17874499f, 0.08816030f, 0.00140961f, 
    -0.00021868f, -0.00751515f, 0.08455604f, -0.11487661f, 0.03159868f, -0.09090932f, -0.13313596f, 0.01208057f, 
    0.03325058f, -0.05764532f, 0.04682010f, 0.00142188f, -0.04152444f, 0.15811215f, -0.01265325f, -0.03911637f, 
    0.23212369f, -0.04506041f, 0.14337549f, 0.02869575f, -0.01182137f, -0.00388450f, -0.11292896f, -0.13362363f, 
    -0.23662819f, 0.09075850f, -0.01314228f, -0.03401486f, 0.04311074f, -0.06891394f, 0.03205771f, -0.03874619f, 
    -0.11797657f, -0.06487662f, 0.07532027f, 0.10320553f, -0.14213368f, 0.00115735f, -0.23996033f, 0.12784435f, 
    -0.12363850f, -0.00870368f, 0.14168541f, 0.02136540f, -0.01686223f, -0.00974643f, -0.00311087f, 0.01145007f, 
    -0.04507572f, -0.10059337f, -0.12249607f, 0.06308992f, -0.16404323f, -0.09255403f, 0.04218324f, -0.02196169f, 
    -0.04632316f, 0.06031646f, 0.03187932f, -0.04118433f, 0.10935225f, -0.23459490f, 0.03496810f, -0.03279030f, 
    -0.12673722f, 0.05079622f, 0.03220608f, -0.09738053f, -0.07594349f, -0.05971989f, -0.10075842f, 0.09145124f, 
    0.11952836f, 0.07237954f, -0.12312408f, -0.08729457f, -0.11894769f, 0.11174402f, 0.08530183f, -0.03817191f, 
    0.05846927f, -0.10059521f, 0.10175356f, 0.13826291f, -0.02849221f, 0.18748522f, 0.07149258f, 0.09412553f, 
    0.11729523f, -0.09282431f, -0.02412352f, 0.02760151f, -0.11499390f, 0.03605077f, 0.05796132f, 0.06431912f, 
    0.19923776f, -0.22867294f, -0.08456249f, -0.01716260f, -0.06588373f, 0.09522818f, 0.12241844f, 0.11406910f, 
    0.14346375f, 0.05428607f, 0.05281175f, -0.01678740f, -0.00539858f, -0.09707371f, 0.01024437f, 0.09131068f, 
    -0.00434311f, -0.04772025f, -0.02167070f, -0.02928459f, -0.04758342f, -0.03306429f, -0.03488954f, -0.02027317f, 
    -0.04076012f, -0.06535953f, -0.03964077f, -0.01207091f, -0.02601924f, -0.01008170f, 0.03522183f, 0.03913224f, 
    -0.05733708f, -0.05701434f, -0.02570986f, -0.03690585f, -0.03071459f, -0.03819169f, 0.01844019f, 0.00019654f, 
    -0.02197852f, -0.06133138f, -0.07317517f, 0.00841449f, -0.06834511f, -0.02877425f, -0.05268535f, -0.01559736f, 
    0.01955978f, -0.03627489f, -0.03928054f, -0.05482045f, 0.03715298f, -0.05002661f, -0.01032564f, 0.03507152f, 
    0.03415956f, 0.03642889f, 0.02968531f, -0.03994520f, -0.03520855f, -0.03770856f, -0.02676719f, 0.01386759f, 
    -0.01813481f, 0.01802166f, -0.03494501f, -0.03536347f, -0.06058878f, 0.01166603f, 0.02405126f, 0.02506124f, 
    -0.02508168f, 0.03371501f, -0.05342649f, 0.01192800f, 0.04472795f, -0.02861787f, -0.01459556f, -0.06748641f, 
    -0.04461993f, -0.06377559f, -0.00446743f, -0.05548908f, -0.05273293f, -0.00385780f, -0.05752309f, 0.04011724f, 
    -0.01722247f, 0.00689554f, 0.01786573f, 0.01044092f, -0.05356252f, 0.02906047f, 0.00916348f, -0.01414725f, 
    -0.01994904f, -0.05119516f, 0.00671243f, 0.00865049f, -0.07451217f, -0.01877573f, 0.02381954f, -0.04167685f, 
    0.03122302f, -0.01386307f, -0.00279272f, 0.04174121f, -0.04036718f, -0.06654083f, 0.01677842f, -0.06672700f, 
    -0.05853915f, -0.06895015f, -0.05852110f, -0.05151197f, -0.00100988f, 0.03125557f, -0.03720973f, 0.01513054f, 
    -0.05350205f, -0.02950930f, -0.00309932f, 0.04684122f, 0.03223717f, -0.01809774f, -0.06351443f, -0.00460314f, 
    0.00028626f, -0.00035087f, -0.00653222f, -0.06559771f, 0.03442523f, -0.01836188f, -0.04195419f, -0.02451111f, 
    -0.00893441f, -0.05167550f, -0.01016917f, -0.03837274f, 0.02715852f, 0.04162211f, -0.00013583f, 0.03753252f, 
    -0.00830712f, 0.02799098f, -0.07848164f, -0.00703725f, -0.07383530f, -0.04326252f, 0.04433696f, -0.00739868f, 
    -0.05553823f, -0.01649558f, 0.01324843f, 0.03914131f, -0.03479625f, -0.04248848f, -0.07926501f, 0.00049836f, 
    0.00911305f, -0.07445420f, -0.01350728f, -0.06293835f, 0.00966125f, -0.00919185f, -0.00966107f, 0.04188279f, 
    0.02404287f, -0.03426856f, 0.03844892f, 0.01104674f, -0.01025869f, 0.02291095f, -0.03649689f, -0.04205685f, 
    -0.00731807f, -0.05108704f, 0.04557179f, 0.02301533f, -0.07038239f, -0.02810353f, 0.00219758f, -0.00928204f, 
    -0.02082872f, -0.03015291f, -0.05346293f, 0.00196544f, 0.03006680f, -0.06012764f, -0.01399310f, -0.05442040f, 
    -0.05351150f, 0.02847656f, -0.04441939f, -0.06096520f, -0.05651965f, 0.04745604f, 0.04318151f, 0.02275795f, 
    -0.04462697f, 0.01121885f, -0.04249765f, -0.06028722f, -0.02284551f, 0.01295338f, -0.02010688f, 0.00689165f, 
    -0.01930457f, 0.01531068f, -0.03849979f, -0.02352910f, -0.04840510f, -0.00688489f, -0.05317420f, -0.05579926f, 
    -0.04650439f, 0.03283602f, 0.02392224f, -0.05589708f, -0.04533061f, -0.05321170f, -0.01670396f, -0.03296356f, 
    -0.02125771f, -0.04459514f, -0.01256498f, -0.03102632f, 0.00820291f, 0.05285209f, 0.01696011f, 0.00952883f, 
    -0.06359291f, 0.03761059f, 0.03084324f, -0.02846783f, -0.04095824f, -0.00089876f, 0.01045036f, 0.03200446f, 
    -0.04883469f, 0.01291042f, 0.04025239f, -0.02054802f, -0.02692006f, -0.03652937f, 0.00394755f, -0.00444821f, 
    0.02384157f, 0.01532693f, 0.02327542f, 0.02581130f, 0.03202154f, 0.03307124f, -0.04268065f, 0.01093641f, 
    -0.06554151f, -0.02210651f, -0.00464253f, 0.04185364f, -0.01127926f, 0.03639229f, 0.03047174f, -0.03350376f, 
    -0.04477344f, 0.02066815f, 0.03434056f, -0.03480259f, 0.02397692f, 0.01889522f, -0.07555541f, -0.05371890f, 
    -0.03008727f, -0.01423996f, -0.06010657f, 0.04343906f, 0.03333358f, -0.05142045f, -0.05120838f, 0.02910145f, 
    -0.00668171f, -0.04715987f, 0.01110339f, 0.02532182f, 0.03727700f, -0.06527945f, 0.01440954f, -0.04643704f, 
    -0.01467855f, -0.05740081f, -0.07364947f, 0.03351180f, -0.02954205f, -0.03925456f, -0.00934813f, -0.00145581f, 
    -0.01556699f, -0.04564756f, -0.03221712f, 0.03619908f, -0.06298979f, -0.01176619f, -0.04378512f, 0.03683291f, 
    -0.09142912f, 0.06159448f, 0.13204570f, -0.09267188f, -0.06858677f, 0.08320833f, -0.02228978f, 0.17278574f, 
    0.09036940f, -0.03276040f, -0.23346677f, -0.01545330f, 0.05947360f, 0.14704591f, 0.04362769f, 0.04693248f, 
    -0.06481659f, -0.17164277f, -0.02975522f, -0.03402536f, -0.08699670f, 0.24030955f, -0.07653145f, 0.21870059f, 
    0.11514281f, -0.03715776f, 0.08528277f, 0.13121246f, -0.06938104f, 0.09176275f, -0.18188125f, -0.05962992f, 
    -0.03981949f, -0.07204396f, 0.05038590f, 0.09017619f, 0.00762613f, -0.11351053f, -0.04123349f, -0.10157078f, 
    0.05490470f, -0.02718574f, 0.00497555f, -0.00686816f, -0.20639335f, 0.13051815f, 0.04425254f, 0.07948558f, 
    -0.08030722f, 0.14389701f, -0.07106594f, 0.19946237f, 0.06789282f, -0.04916537f, 0.00782016f, -0.02459816f, 
    0.10033993f, 0.01477385f, -0.08217953f, 0.00039019f, 0.00815576f, 0.03607738f, 0.08255400f, 0.19144091f, 
    -0.10705070f, 0.26228413f, 0.00853164f, -0.09594313f, -0.21535219f, 0.08549396f, 0.02430734f, -0.08044056f, 
    0.10392058f, 0.07597883f, 0.02495346f, 0.08658057f, -0.00279174f, -0.07484448f, -0.01703176f, 0.02641396f, 
    0.05677538f, -0.01782916f, 0.07355181f, -0.01593998f, 0.00833968f, 0.17103550f, -0.02713944f, -0.12275784f, 
    0.04584100f, 0.10945733f, 0.00078303f, -0.03935466f, 0.00648943f, 0.04593668f, -0.07010934f, -0.00972058f, 
    0.03820046f, -0.07651701f, 0.04478471f, -0.01259478f, 0.16515760f, 0.06003753f, -0.00608703f, 0.12847425f, 
    0.17390172f, 0.04516164f, -0.00136909f, 0.01041361f, -0.01085459f, -0.09846300f, -0.01207927f, 0.00798257f, 
    0.02100791f, -0.13724954f, -0.04864809f, -0.01277186f, -0.01739713f, -0.03239105f, -0.06090404f, 0.04712293f, 
    0.16996393f, 0.09252007f, 0.00595723f, -0.03385374f, -0.05498331f, -0.02333880f, 0.02253990f, 0.01658659f, 
    -0.05550785f, -0.00769157f, 0.17772983f, 0.05805668f, -0.01135853f, -0.18010075f, -0.09894624f, -0.00597055f, 
    -0.04475114f, 0.08973794f, 0.04701918f, 0.04674327f, -0.07391407f, 0.02834244f, -0.04548728f, 0.04600873f, 
    -0.17385694f, -0.12470683f, -0.08556406f, 0.06392852f, -0.04826897f, -0.03155950f, 0.02778251f, -0.02953267f, 
    -0.05945858f, 0.20652226f, -0.03168673f, 0.16155860f, -0.16567747f, -0.01331700f, 0.00036166f, -0.19888623f, 
    0.08002020f, -0.08690650f, -0.16552986f, -0.06324440f, -0.01892141f, -0.01424578f, 0.06574702f, 0.15521064f, 
    -0.14882343f, 0.02473340f, -0.00664406f, 0.08826594f, 0.05224671f, -0.02765594f, -0.19159366f, 0.13107623f, 
    -0.12221721f, -0.06546658f, -0.02064107f, 0.07412273f, 0.27174565f, 0.12547205f, 0.02497182f, -0.11315513f, 
    -0.03175060f, 0.00199331f, 0.04818020f, -0.01248736f, -0.11849988f, 0.10323760f, 0.16922072f, 0.04733109f, 
    0.05177723f, 0.00866204f, -0.10730692f, -0.00811751f, 0.05178068f, 0.07343431f, 0.34887481f, 0.00791822f, 
    0.02596015f, -0.03444052f, -0.05573134f, 0.05182308f, -0.03097103f, 0.03952112f, 0.07577084f, 0.11074970f, 
    -0.15802619f, -0.04113959f, -0.00591717f, 0.01887551f, 0.02067798f, -0.12765378f, 0.21768208f, 0.03357480f, 
    0.08278712f, -0.02113700f, 0.01632497f, -0.15372491f, 0.00497118f, 0.00914270f, 0.09024712f, 0.00091171f, 
    0.03499300f, 0.07085321f, -0.10194327f, 0.14428782f, -0.13343701f, 0.00687395f, -0.07460231f, 0.10238630f, 
    -0.06564754f, 0.04700951f, -0.19011642f, -0.05042011f, -0.02190690f, 0.01505532f, -0.03239165f, 0.10700559f, 
    0.01428515f, -0.00265071f, -0.00179478f, -0.04419717f, 0.11545964f, 0.11082773f, -0.06254590f, -0.18383154f, 
    0.00524731f, -0.09986017f, 0.22157991f, 0.23840140f, 0.01765632f, 0.05299884f, -0.06576640f, -0.16092186f, 
    0.05493379f, 0.01515679f, 0.01792214f, 0.08483550f, -0.07155797f, -0.09330741f, -0.14784028f, -0.04826350f, 
    0.01498482f, 0.09124666f, 0.01184488f, 0.05173143f, -0.24317370f, -0.23367806f, 0.13573070f, -0.09526335f, 
    0.10728087f, -0.01814989f, -0.02425312f, -0.17115954f, 0.01978910f, -0.07307925f, -0.06951813f, -0.26702315f, 
    0.07393116f, -0.07770244f, 0.03858909f, 0.04905102f, 0.10293540f, -0.16038793f, -0.12045833f, -0.01907003f, 
    0.12103301f, 0.19492602f, -0.05405876f, -0.04500149f, 0.05208743f, -0.06243078f, -0.02772610f, 0.04686459f, 
    -0.09633074f, 0.02203758f, 0.07789624f, -0.05826133f, -0.02359545f, -0.11640958f, 0.02907793f, -0.05368860f, 
    0.04413296f, 0.15155430f, -0.05757415f, -0.14742234f, 0.00553874f, 0.02444013f, -0.00383650f, -0.02334916f, 
    -0.09431792f, -0.04124508f, -0.06334373f, 0.13453287f, -0.35746691f, -0.04753048f, 0.00300788f, -0.12789848f, 
    -0.09403334f, -0.01201079f, -0.08317225f, -0.06138836f, 0.08545800f, 0.13824224f, -0.01442544f, -0.12723888f, 
    0.11437840f, -0.10139310f, 0.03643367f, 0.06480957f, -0.01132690f, -0.02800542f, -0.25575361f, 0.00949754f, 
    -0.09737137f, -0.14157693f, -0.05874592f, -0.00508179f, -0.12557265f, 0.13024364f, -0.11512391f, 0.20596205f, 
    0.01866566f, 0.01297978f, -0.15196377f, 0.07140739f, -0.06166879f, 0.10960258f, -0.06431800f, -0.31273341f, 
    -0.35322851f, -0.06829011f, -0.07818822f, 0.14060168f, 0.09285509f, 0.01784998f, -0.05960962f, 0.08525769f, 
    0.06509059f, -0.20595901f, -0.32395801f, 0.03235939f, -0.02320374f, 0.16917679f, 0.00053149f, -0.05134491f, 
    -0.01520018f, 0.09125751f, 0.06805164f, -0.25082505f, 0.06111161f, -0.02141667f, 0.05029951f, -0.04212046f, 
    0.07123280f, -0.01916554f, 0.01853443f, -0.06787276f, -0.10861229f, -0.15718399f, 0.01124474f, 0.10822610f, 
    0.00972269f, 0.02083362f, 0.04072760f, 0.12068821f, -0.26955155f, 0.11862140f, 0.09823597f, -0.00662893f, 
    0.04532183f, 0.03814609f, -0.00033580f, -0.14435442f, 0.31402862f, 0.12949432f, -0.09483683f, 0.05194258f, 
    0.00581969f, 0.03110168f, 0.00188878f, 0.05641314f, 0.05922650f, -0.00926519f, -0.13473172f, -0.02337373f, 
    0.03591996f, 0.02142022f, 0.04958126f, -0.05084402f, -0.00057567f, 0.04245793f, -0.13146098f, 0.15137528f, 
    0.06868900f, 0.08576552f, -0.05084793f, -0.08216269f, -0.09694139f, -0.04872008f, -0.09036436f, 0.15414351f, 
    0.29216075f, 0.19285198f, 0.13171439f, -0.12358011f, 0.03401485f, 0.09081883f, 0.07341603f, 0.11037293f, 
    0.00363683f, 0.00117550f, 0.10676125f, -0.00312652f, 0.05495328f, -0.04079615f, 0.01641554f, -0.05760298f, 
    0.06333391f, 0.03417131f, -0.29798162f, 0.02090793f, -0.04817478f, -0.08315258f, -0.02429236f, -0.10391560f, 
    0.02661952f, 0.19819845f, 0.10661472f, -0.10167864f, 0.11742806f, 0.07483500f, -0.03034543f, -0.04866863f, 
    0.13518542f, -0.11321978f, 0.19284040f, -0.08445603f, 0.29157731f, 0.03095016f, 0.08815400f, -0.02930456f, 
    -0.00456045f, 0.01691805f, 0.02750802f, 0.05950106f, -0.09435852f, 0.03128787f, -0.29434860f, 0.03397794f, 
    0.13783300f, -0.05289334f, 0.00735801f, 0.00492135f, -0.09049486f, -0.09773037f, -0.10866933f, -0.07265990f, 
    0.07733912f, -0.02033469f, 0.19912821f, -0.06517276f, -0.12061732f, 0.04994399f, -0.26627997f, -0.31430563f, 
    -0.15583386f, 0.02888827f, -0.04302918f, 0.00477507f, 0.00653284f, 0.02649590f, 0.02805258f, -0.43456519f, 
    -0.13163829f, 0.08603709f, 0.08237114f, -0.07275879f, -0.06164020f, -0.02650132f, 0.03221569f, 0.07618620f, 
    -0.03902113f, 0.11455098f, 0.02527582f, 0.16956772f, 0.01829737f, -0.03326605f, 0.04641058f, -0.01680072f, 
    0.08582532f, 0.01743606f, 0.15612271f, -0.06794441f, 0.01765323f, -0.06896957f, -0.06610728f, 0.00524538f, 
    0.03382805f, -0.06696185f, 0.12558760f, 0.05799307f, 0.02212890f, -0.03013605f, -0.00668695f, -0.11232565f, 
    0.10578138f, 0.11576629f, -0.06706142f, 0.05840186f, -0.11650968f, -0.31707048f, 0.02474634f, 0.07058101f, 
    0.10569136f, 0.03842586f, -0.00743877f, -0.04799142f, 0.00430056f, -0.02242078f, 0.10526703f, 0.09189767f, 
    -0.14436373f, 0.05579377f, 0.07484401f, 0.01734368f, 0.17185515f, 0.01532652f, 0.22631051f, -0.06331559f, 
    -0.05157218f, -0.12663786f, -0.03933226f, 0.06928690f, -0.11747548f, 0.03582589f, -0.01474287f, 0.11675260f, 
    0.00682551f, 0.03054296f, 0.17141090f, -0.01700561f, 0.12920216f, -0.01749732f, -0.02885283f, 0.16099821f, 
    -0.05375929f, 0.09033430f, 0.05026644f, 0.02136550f, -0.02126381f, -0.02537384f, 0.14187747f, -0.03940622f, 
    -0.01935644f, -0.00497081f, -0.06568726f, -0.01980859f, -0.05332680f, 0.02098783f, -0.01866441f, -0.04119861f, 
    0.02392315f, 0.01215120f, 0.00237644f, -0.02569213f, 0.02199392f, 0.04706490f, 0.03174945f, 0.03214004f, 
    -0.00089875f, 0.01716273f, -0.01700288f, 0.03886625f, 0.05155107f, -0.04666435f, -0.05635374f, 0.04327624f, 
    -0.00214040f, 0.01266974f, -0.00229901f, -0.00956243f, 0.00220259f, 0.05289765f, -0.00477502f, 0.00947609f, 
    0.03271347f, -0.05111682f, -0.00560343f, 0.00301796f, 0.00290886f, 0.00293693f, -0.05799215f, 0.04489121f, 
    -0.04349173f, 0.01122623f, -0.05859093f, 0.05130549f, -0.04867176f, -0.01279189f, -0.05203613f, 0.01072150f, 
    -0.01928877f, -0.01430361f, 0.00848161f, 0.00381538f, 0.03205266f, 0.01559520f, -0.06027159f, 0.02270070f, 
    -0.05023882f, -0.04951172f, 0.00008988f, 0.00310578f, -0.03618173f, -0.04133727f, -0.01522655f, 0.02357562f, 
    -0.06291928f, 0.02099386f, 0.02744166f, -0.03222175f, -0.06270480f, -0.00178480f, 0.01305269f, 0.02048212f, 
    -0.01934005f, 0.02567505f, 0.02417867f, 0.05052987f, 0.01231963f, 0.02419053f, 0.03320545f, -0.02824954f, 
    -0.01719979f, -0.02143337f, 0.04620774f, 0.01029417f, 0.04710377f, 0.04197821f, 0.04214039f, 0.04625891f, 
    -0.01367585f, -0.02990731f, 0.04009232f, -0.05667313f, -0.01630940f, -0.01688712f, 0.04117941f, -0.04799749f, 
    0.00949577f, 0.01320858f, 0.01343733f, -0.00204387f, -0.05884342f, 0.00505728f, -0.05778327f, -0.00683773f, 
    0.03311842f, 0.02323513f, -0.06553078f, -0.03976318f, -0.04212601f, 0.03234811f, -0.00834866f, -0.03591431f, 
    -0.02947653f, 0.02507875f, -0.00008258f, -0.00479537f, -0.01717981f, -0.06401051f, -0.00958439f, -0.03837126f, 
    -0.04627212f, -0.06082548f, -0.04336438f, -0.06013545f, -0.02928607f, 0.04098278f, 0.03648420f, 0.03437930f, 
    0.04370038f, -0.01845636f, -0.05212561f, 0.04185292f, 0.00491039f, 0.02331378f, -0.03870329f, 0.03740090f, 
    -0.02179962f, 0.01238033f, -0.04053587f, -0.05549595f, -0.05214205f, -0.06474406f, -0.00952570f, -0.03979824f, 
    -0.04283366f, 0.00655890f, 0.01339800f, -0.02062536f, -0.05852695f, 0.03670169f, -0.04208668f, 0.00431916f, 
    -0.04485015f, 0.02313223f, 0.04976636f, 0.03855325f, -0.03972196f, -0.02824059f, 0.00280765f, 0.02422480f, 
    0.00889247f, -0.00178252f, -0.00305535f, -0.06283332f, -0.04398981f, -0.04531318f, 0.04399929f, -0.04355707f, 
    -0.06498768f, -0.04031635f, -0.02850995f, 0.01649059f, -0.06312396f, 0.00576878f, 0.04621628f, 0.04875406f, 
    0.03174028f, -0.04215512f, -0.01304929f, -0.06407492f, -0.05955481f, -0.04389255f, -0.03877984f, 0.04069251f, 
    0.05092542f, -0.04480759f, -0.04063079f, -0.04504133f, -0.06284349f, -0.01115410f, -0.03373626f, -0.02056463f, 
    -0.02968375f, -0.06600312f, -0.02311524f, 0.02485946f, -0.03181517f, -0.03959537f, -0.03273876f, -0.03428314f, 
    0.02635448f, -0.03705019f, -0.03445258f, -0.02427870f, -0.02343939f, 0.02892435f, -0.05263476f, 0.02106748f, 
    -0.05301506f, -0.05077047f, 0.02914947f, 0.04024457f, -0.02789266f, 0.02580498f, 0.04918401f, -0.04603841f, 
    -0.01641112f, -0.03200708f, 0.00077664f, 0.03769603f, -0.06090876f, -0.06684286f, -0.05409516f, 0.00677777f, 
    -0.02855537f, -0.00754925f, -0.01306263f, -0.00790362f, -0.05149775f, -0.01104865f, 0.04226480f, 0.03493576f, 
    -0.04595524f, -0.05600518f, 0.02544709f, 0.02459141f, -0.00480979f, -0.06421715f, -0.03931878f, -0.01639748f, 
    -0.06499485f, -0.03334782f, -0.06603177f, 0.05254799f, 0.01662289f, 0.02761723f, 0.01685263f, 0.04947476f, 
    0.01196954f, -0.02082389f, 0.00508804f, -0.03821512f, -0.02871734f, -0.01796624f, -0.05525140f, 0.02732010f, 
    0.02528208f, -0.04469273f, 0.04584217f, 0.02887997f, 0.00018888f, 0.00792410f, 0.02421276f, -0.05464532f, 
    0.04324689f, 0.00358889f, -0.01719223f, -0.00421211f, -0.01722186f, -0.06152619f, -0.03308778f, -0.00100853f, 
    -0.05344296f, -0.01997625f, 0.03791629f, -0.06473544f, 0.03913484f, 0.04029147f, -0.03442376f, -0.04883748f, 
    0.00989976f, -0.04645079f, -0.03935108f, 0.01177775f, -0.03367462f, -0.03984242f, -0.00352723f, 0.01372530f, 
    -0.05440705f, -0.05181764f, -0.05323753f, -0.06840129f, 0.02061360f, -0.05256822f, -0.05746865f, -0.00882842f, 
    0.04436842f, -0.05475374f, -0.05704879f, -0.04501548f, 0.02115480f, 0.00702788f, 0.00996273f, -0.05316182f, 
    -0.05921018f, -0.00845848f, -0.05286028f, 0.03712524f, 0.00038597f, -0.05844772f, -0.02060089f, 0.02229718f, 
    -0.04066279f, -0.03818844f, 0.01033064f, 0.02434205f, 0.03807131f, 0.02468704f, -0.03480069f, 0.01519062f, 
    -0.04988033f, 0.02222383f, 0.02793224f, -0.05943825f, -0.01051845f, 0.01304197f, -0.00114815f, 0.04229297f, 
    -0.05109866f, 0.03622048f, -0.00670293f, -0.02632038f, 0.03973555f, 0.03201788f, -0.03555016f, -0.02588363f, 
    0.04232685f, -0.04500943f, -0.06148670f, -0.01081828f, -0.04750739f, -0.03512740f, -0.02099637f, 0.00404560f, 
    0.00925179f, 0.03058191f, -0.00938379f, -0.00239938f, -0.02017311f, -0.05343653f, -0.03900224f, -0.02503366f, 
    -0.01945736f, 0.01455031f, -0.02301817f, -0.04443996f, 0.01986007f, 0.01733958f, -0.06492610f, 0.03675094f, 
    0.01698954f, 0.04182767f, -0.02918828f, -0.04394904f, -0.02493021f, -0.04612492f, -0.00906088f, 0.03785599f, 
    -0.04332943f, 0.02049944f, 0.03373497f, -0.01475827f, -0.04923620f, -0.04987787f, 0.00420266f, 0.02506326f, 
    -0.05618118f, -0.06306478f, -0.00829581f, -0.02157244f, -0.06060081f, 0.02625244f, 0.02083138f, -0.06417158f, 
    0.00489851f, -0.06790980f, -0.00336975f, 0.01319907f, -0.04312591f, -0.00072291f, -0.04255853f, -0.02842660f, 
    0.00443418f, 0.00133853f, 0.01358235f, 0.00493873f, 0.01123654f, -0.04617966f, 0.03363324f, 0.00605566f, 
    0.03235841f, -0.01785688f, -0.06805861f, -0.01480001f, 0.00284866f, -0.06225746f, -0.00852500f, -0.05135394f, 
    0.02002911f, -0.03020318f, -0.04800605f, -0.00153547f, -0.03729380f, 0.03516836f, -0.02841418f, -0.06994376f, 
    0.01091180f, -0.02363124f, 0.01522629f, -0.03607955f, -0.07176319f, 0.00474561f, -0.05582795f, 0.03443010f, 
    -0.03554405f, 0.00310297f, -0.00828027f, -0.06859636f, -0.02752833f, -0.03077097f, 0.05046431f, -0.01150687f, 
    0.00333425f, 0.00841921f, 0.01532295f, -0.03093205f, -0.06738536f, -0.06679425f, 0.00871764f, -0.06906494f, 
    0.02136182f, 0.03847530f, 0.02169008f, -0.02869914f, 0.00379123f, -0.02910134f, -0.05621332f, -0.02397905f, 
    -0.05362863f, 0.00381788f, -0.02114267f, -0.04167496f, 0.03906533f, -0.04228341f, 0.01826161f, 0.04301909f, 
    0.03489951f, 0.00177964f, -0.01286437f, 0.03077384f, 0.00442239f, -0.00330287f, -0.02614473f, 0.00495830f, 
    0.03543247f, -0.05201093f, 0.04009308f, -0.00349038f, -0.04048028f, -0.01755540f, -0.01353448f, -0.03739864f, 
    -0.03396465f, 0.01357777f, 0.03703353f, -0.06035281f, 0.01483419f, 0.03804977f, -0.04316160f, 0.01508624f, 
    0.03408457f, 0.03846603f, -0.05259058f, -0.02561584f, -0.02319426f, 0.04754543f, -0.05675893f, -0.04657228f, 
    -0.00271897f, -0.03055394f, -0.03145555f, 0.02515059f, 0.01880218f, -0.06762124f, -0.02734879f, 0.04090382f, 
    -0.03854989f, -0.01252816f, 0.02494043f, 0.04667332f, -0.01839054f, -0.05619108f, -0.04529516f, -0.00802908f, 
    -0.00931609f, -0.00429652f, -0.03542434f, 0.00729814f, -0.01665206f, -0.05792212f, -0.06184676f, -0.01487452f, 
    0.01789464f, -0.06429219f, -0.01662909f, -0.04452840f, -0.05108557f, 0.00197028f, 0.01808180f, 0.04468053f, 
    0.02260951f, 0.00601366f, -0.03637253f, 0.01715264f, -0.06157169f, 0.03230779f, -0.05100304f, -0.02166939f, 
    -0.06357256f, -0.07194091f, 0.03126611f, -0.02337915f, 0.00367213f, 0.00557975f, -0.04599755f, -0.03368718f, 
    -0.00984142f, -0.01882975f, 0.02166905f, -0.00743384f, -0.05147294f, -0.00603813f, 0.02264054f, -0.00841731f, 
    0.00291404f, 0.02624286f, 0.02279211f, 0.02010733f, -0.03607659f, 0.01878695f, 0.01007673f, -0.03567691f, 
    0.04351595f, -0.04203406f, 0.00982128f, -0.05443574f, -0.06444345f, 0.03763536f, -0.01684241f, -0.01142377f, 
    -0.02990516f, 0.00113658f, -0.00007953f, -0.01832723f, -0.05435738f, -0.02013056f, 0.02972441f, -0.03086680f, 
    0.00685799f, 0.02724093f, -0.02091923f, -0.02092801f, -0.00268956f, -0.03474724f, 0.00654355f, 0.03418830f, 
    -0.21236481f, -0.06609068f, 0.14094904f, -0.10148108f, 0.03881728f, 0.02822435f, -0.11678512f, 0.14272103f, 
    0.08922596f, 0.38774580f, 0.05254464f, -0.16336516f, 0.03295649f, 0.04145873f, -0.03529909f, -0.06574122f, 
    0.07998151f, 0.01004328f, 0.21273254f, -0.01967764f, -0.17348948f, -0.02796462f, 0.11058295f, -0.10123482f, 
    -0.03082085f, -0.00782493f, 0.14514208f, 0.13833416f, -0.19950898f, 0.10139307f, 0.02273005f, 0.11968554f, 
    0.15569335f, -0.13431501f, -0.13076273f, 0.01270346f, -0.25419900f, -0.21067575f, -0.05514039f, 0.10415019f, 
    0.09856194f, 0.11891831f, -0.04964647f, 0.02256890f, 0.04548851f, -0.03459939f, 0.14380442f, -0.10834495f, 
    -0.09324692f, 0.00061002f, -0.10482284f, 0.09900022f, -0.00414427f, -0.19914769f, 0.00052256f, 0.12984149f, 
    0.05962168f, 0.00553973f, -0.07920416f, -0.05128985f, 0.06750783f, -0.08394846f, 0.05381873f, 0.16101471f, 
    0.01968509f, -0.00404347f, 0.04846752f, -0.03691392f, -0.05528000f, 0.14474760f, -0.03168602f, 0.03244649f, 
    -0.05196479f, 0.07591517f, -0.13620059f, -0.07056701f, 0.05570124f, -0.02633883f, 0.05914378f, -0.00521240f, 
    -0.03157062f, 0.00394987f, 0.14317289f, -0.09024952f, -0.03169726f, 0.02811442f, -0.05785719f, -0.00521440f, 
    0.10290945f, -0.04556978f, 0.22261666f, 0.08127635f, -0.19784321f, 0.13138758f, 0.01567582f, 0.04692026f, 
    0.02406612f, -0.11578432f, -0.02088398f, -0.16549943f, 0.08799841f, 0.00675337f, -0.00675683f, -0.04251709f, 
    0.07247131f, 0.07499478f, -0.06169857f, -0.04559392f, -0.11123718f, -0.03273066f, 0.05692320f, -0.05330361f, 
    0.07894348f, -0.02883201f, -0.07828563f, 0.03689933f, -0.01667490f, 0.45647648f, 0.19413541f, -0.04339348f, 
    0.02034682f, 0.05037357f, -0.05280573f, 0.08581159f, 0.09730656f, -0.02141643f, 0.05990006f, 0.00266939f, 
    -0.12967105f, 0.11459940f, 0.01190480f, -0.09947475f, 0.04857221f, -0.07135000f, -0.02987864f, -0.01465023f, 
    0.09386125f, -0.04452906f, 0.01256217f, 0.16543323f, -0.05265220f, 0.01786361f, 0.11647262f, -0.03246100f, 
    0.09690062f, -0.09987596f, 0.01874241f, 0.07978979f, 0.00795428f, 0.03607000f, -0.03493045f, 0.02477432f, 
    -0.03059074f, 0.20865735f, -0.01000601f, 0.16928518f, 0.06441793f, 0.00643091f, -0.06254186f, 0.08156647f, 
    -0.03667411f, -0.04343340f, -0.06896303f, 0.04281798f, -0.15751174f, 0.03950698f, -0.12985440f, -0.00088233f, 
    0.10390214f, 0.14849363f, -0.08186274f, 0.14874585f, 0.05718214f, -0.02181613f, -0.10781059f, -0.05996410f, 
    0.00118425f, -0.08306977f, 0.02034672f, -0.04876585f, -0.11776076f, -0.09859436f, -0.07978354f, -0.12896423f, 
    0.10166248f, -0.03548765f, -0.12175956f, 0.07439129f, 0.01135557f, -0.22378543f, 0.11908756f, -0.15189694f, 
    0.07112712f, -0.19558220f, -0.00144403f, -0.01257418f, 0.04871309f, 0.07116522f, -0.01591362f, -0.09102947f, 
    0.11305049f, -0.05060963f, 0.00122193f, 0.04022743f, 0.04276657f, -0.04443758f, 0.05594571f, 0.11492668f, 
    -0.13922042f, -0.22005278f, -0.00919424f, 0.09576468f, 0.04525371f, 0.05919007f, 0.03859302f, -0.00612196f, 
    -0.18610585f, 0.11939360f, -0.04494396f, -0.07842386f, 0.01764249f, -0.00581590f, -0.04665529f, -0.02695221f, 
    -0.03718004f, 0.17098613f, 0.04466365f, -0.06300031f, -0.02639939f, 0.04013490f, 0.00570940f, 0.19987178f, 
    -0.03687154f, -0.09024636f, -0.21030679f, -0.02532629f, 0.06366339f, 0.04611136f, 0.00813931f, 0.09325893f, 
    -0.13308088f, 0.03119118f, 0.02222127f, -0.24461599f, 0.13548946f, -0.06546974f, -0.03589550f, -0.09533022f, 
    -0.03467916f, -0.12223590f, 0.10794333f, -0.04482546f, -0.31486943f, 0.13999125f, 0.01719320f, -0.06067834f, 
    0.11623202f, -0.09603179f, -0.04249406f, -0.09447864f, -0.01385716f, 0.12627932f, -0.14526728f, -0.04510577f, 
    0.11277942f, -0.00907902f, 0.00149788f, 0.11934053f, -0.01861083f, -0.01675386f, -0.29554597f, 0.00297492f, 
    0.05971537f, 0.08394396f, 0.02903702f, -0.01497855f, -0.08568630f, -0.02356943f, 0.09143491f, -0.10539038f, 
    -0.34810707f, 0.03181425f, 0.10567334f, 0.07371283f, 0.03360994f, -0.03657029f, -0.00084362f, -0.03547227f, 
    -0.22862357f, -0.11231995f, -0.33923814f, 0.00711798f, -0.16731237f, 0.16822642f, -0.09311479f, -0.09325671f, 
    -0.07764262f, -0.08261041f, 0.08447331f, -0.11722735f, 0.07277916f, -0.06398234f, -0.02886174f, 0.07952705f, 
    0.07093202f, -0.07632117f, 0.05343051f, -0.00671817f, 0.10737494f, -0.06376382f, 0.10057870f, -0.03963730f, 
    0.06969876f, 0.20096068f, -0.03739029f, -0.40536800f, -0.12178969f, 0.20892249f, -0.09739798f, -0.02982680f, 
    -0.05023989f, 0.08247223f, 0.06045843f, -0.13871539f, -0.20384388f, -0.07251069f, 0.03296335f, -0.04391952f, 
    -0.02659741f, 0.02562836f, -0.07467181f, -0.12837039f, 0.05630352f, -0.04982255f, -0.13630530f, -0.13293909f, 
    -0.00124901f, -0.08635166f, -0.18737784f, -0.06197459f, 0.00478356f, 0.09873929f, -0.23090529f, -0.04924753f, 
    -0.17761719f, -0.00859154f, 0.15089406f, 0.00304385f, -0.19032441f, 0.09698586f, -0.07602330f, 0.12783521f, 
    -0.01513319f, -0.12123474f, 0.02178879f, 0.08546835f, 0.00529799f, -0.06156529f, -0.01575780f, 0.18776907f, 
    -0.03745792f, 0.04006779f, -0.00596379f, 0.09688808f, 0.00621567f, 0.08998080f, 0.12703085f, 0.03264324f, 
    0.11866304f, -0.07713278f, -0.06524546f, -0.01547738f, 0.10345338f, 0.01115354f, 0.06121764f, 0.19179295f, 
    0.18079256f, -0.13741225f, -0.04027896f, 0.04827372f, 0.09752219f, -0.06455951f, 0.03044630f, 0.08115616f, 
    -0.06821345f, 0.03370011f, 0.16397879f, -0.09849424f, -0.02821783f, -0.22892219f, 0.15934889f, 0.09433064f, 
    -0.04914114f, 0.01926479f, 0.11645550f, -0.13429832f, -0.39886940f, -0.19007903f, 0.02147149f, 0.03852589f, 
    0.00407120f, 0.03904792f, 0.00192118f, -0.04105605f, 0.02830696f, 0.04124255f, 0.14378947f, 0.12865952f, 
    -0.01354335f, 0.04239659f, 0.12879300f, 0.04947276f, -0.06285653f, 0.10395428f, -0.11621135f, 0.01716180f, 
    0.03021511f, 0.09070423f, -0.02863910f, 0.01470177f, 0.05267044f, 0.05324696f, -0.01668957f, -0.39771298f, 
    0.14138888f, -0.31691524f, 0.02126670f, 0.01687198f, 0.05666387f, -0.08536044f, -0.10513871f, -0.17225048f, 
    -0.07981034f, 0.10543056f, 0.15201494f, -0.00151624f, -0.01324033f, 0.16266221f, 0.01673684f, 0.07099259f, 
    -0.09698457f, -0.20924453f, 0.00136167f, -0.00741641f, -0.00533356f, 0.08850929f, -0.10026006f, -0.00335348f, 
    -0.19419219f, 0.05059748f, -0.05010699f, 0.12736553f, 0.07274256f, -0.07048982f, -0.03889077f, 0.07083116f, 
    -0.19928251f, -0.06608820f, 0.01970885f, -0.07922776f, -0.07017298f, -0.20889346f, 0.05359516f, -0.04820602f, 
    -0.00294563f, 0.13348860f, 0.10756019f, 0.05922062f, 0.00952307f, -0.15786739f, -0.01604694f, -0.05290865f, 
    -0.00186678f, 0.05993096f, 0.16017313f, 0.17652902f, -0.07913223f, -0.10747441f, -0.03351174f, -0.09836416f, 
    0.14009959f, 0.00787457f, 0.02539760f, 0.07044320f, 0.05331910f, 0.04768823f, -0.15095203f, -0.03576196f, 
    0.03584434f, 0.08265613f, 0.04414039f, 0.07111340f, -0.06837276f, -0.08360241f, -0.01907061f, 0.15203014f, 
    -0.19928329f, 0.04603102f, -0.06224111f, -0.13667975f, 0.12546457f, 0.10197847f, 0.16147318f, 0.12608825f, 
    -0.02120781f, -0.36210814f, -0.11786123f, 0.02716833f, 0.12944964f, 0.12988465f, -0.02685135f, 0.05156437f, 
    0.03328669f, -0.36430117f, -0.18654028f, -0.29518932f, -0.05273098f, 0.03641607f, -0.11560033f, -0.04919653f, 
    0.06014486f, 0.15321909f, 0.02062646f, 0.09194867f, 0.11033584f, 0.00255078f, -0.02776277f, 0.01551336f, 
    0.07793011f, -0.09738200f, -0.12856179f, 0.00025338f, -0.03574022f, -0.38944051f, 0.05224326f, 0.05388846f, 
    0.16359748f, -0.09968881f, -0.05747037f, -0.05610680f, -0.22706550f, -0.23766175f, -0.11062428f, -0.01390250f, 
    -0.03721967f, 0.03150645f, 0.01918982f, 0.02155275f, 0.04021192f, -0.09776373f, 0.09853125f, -0.23181044f, 
    0.00034917f, 0.04013485f, 0.06020350f, -0.04294237f, -0.15797158f, -0.02710030f, -0.35484833f, -0.15790555f, 
    0.04091997f, 0.09060480f, -0.14014010f, -0.08080574f, -0.08083506f, -0.15836796f, 0.04162510f, 0.05077844f, 
    0.20340218f, 0.03357980f, 0.03035226f, -0.00417661f, 0.03524690f, -0.04420149f, 0.07867528f, -0.14638080f, 
    0.04567538f, 0.01405595f, -0.01571683f, -0.01967328f, -0.02235044f, -0.04756265f, -0.00799706f, -0.02006725f, 
    -0.05813778f, 0.02162213f, -0.05944179f, 0.04542052f, -0.00620204f, -0.02484806f, -0.03175541f, -0.01098723f, 
    0.01817978f, -0.04456945f, -0.04003857f, 0.04177150f, 0.03065358f, -0.02819606f, 0.03928196f, -0.05029001f, 
    -0.02655943f, 0.03403848f, 0.01916353f, -0.00068429f, 0.04741565f, 0.05175291f, 0.04852267f, -0.01144753f, 
    0.03289065f, -0.05466842f, 0.03538715f, -0.02495900f, 0.00880205f, 0.00331837f, -0.02184282f, -0.05962170f, 
    -0.01422139f, 0.01425071f, 0.02875400f, 0.01068309f, 0.02755459f, 0.02837520f, -0.01554772f, -0.01324888f, 
    -0.02849440f, 0.02593269f, -0.03019442f, -0.06305733f, 0.00517034f, -0.04401036f, -0.01115581f, 0.04275902f, 
    -0.02177589f, -0.03337798f, 0.02910662f, -0.00550552f, -0.02837170f, -0.05527543f, -0.05933498f, -0.00971057f, 
    -0.03567037f, 0.00743549f, -0.00566971f, -0.05927605f, -0.01673411f, 0.02581080f, -0.03870184f, -0.05840350f, 
    -0.02510802f, -0.04205076f, 0.00199443f, -0.05719320f, -0.00723354f, -0.03055523f, -0.06032233f, -0.04314572f, 
    0.05039378f, -0.01715429f, -0.03149881f, -0.03162859f, -0.05287411f, -0.04917191f, -0.03786661f, -0.01772901f, 
    -0.00596443f, 0.02991736f, -0.03437342f, -0.00424912f, -0.05910210f, 0.01391162f, -0.05027280f, -0.02186795f, 
    0.02361783f, -0.06261941f, 0.01287651f, -0.06437184f, 0.01255799f, -0.00028042f, -0.05406643f, 0.00374646f, 
    -0.06341449f, -0.03454471f, -0.04294223f, 0.02319290f, -0.04898247f, 0.02332951f, 0.03300747f, 0.04797858f, 
    -0.01500160f, -0.00739804f, -0.00654914f, 0.00898044f, 0.03384063f, 0.05157292f, 0.03407400f, -0.00668173f, 
    0.04889796f, -0.00224951f, 0.05115532f, -0.06304482f, -0.04664468f, 0.04781929f, 0.01517255f, -0.02792377f, 
    -0.04770510f, -0.05579819f, 0.03923716f, -0.05964623f, 0.05049197f, 0.00402598f, 0.01465554f, 0.02968772f, 
    -0.04183258f, -0.01000309f, -0.06128130f, 0.04638933f, 0.04197490f, 0.01756603f, -0.00950871f, 0.03402512f, 
    -0.02574743f, -0.02948422f, 0.03631507f, -0.04882961f, -0.03373867f, 0.04271619f, -0.06264789f, -0.05143789f, 
    -0.02698859f, -0.05565660f, -0.05639654f, -0.03204839f, 0.03662045f, -0.04349179f, -0.00290438f, -0.00682663f, 
    -0.00132625f, -0.05183671f, 0.04900562f, -0.03637627f, -0.01477136f, 0.04026381f, -0.01145092f, -0.03074085f, 
    0.00338033f, -0.05234708f, -0.05644507f, 0.01436047f, 0.03735990f, -0.02458795f, 0.03426981f, -0.00141227f, 
    -0.04290440f, -0.00441505f, -0.03193421f, 0.03707204f, -0.04487575f, 0.02553780f, 0.04600387f, 0.03960656f, 
    -0.02425804f, -0.00911986f, 0.03320448f, -0.03874955f, -0.03594030f, 0.03482598f, -0.05267771f, -0.03030069f, 
    0.04231031f, -0.05890404f, 0.01639100f, -0.05313425f, -0.02746541f, -0.06116842f, 0.00415021f, -0.01129469f, 
    -0.06141449f, 0.04583150f, 0.04855058f, -0.05040784f, -0.00603539f, -0.03044789f, 0.02671161f, 0.01752357f, 
    0.00494464f, 0.01720305f, -0.01289935f, 0.01963101f, -0.00014830f, -0.03157489f, 0.02142905f, -0.01711161f, 
    -0.03034364f, 0.04023236f, -0.00252721f, -0.00604462f, -0.02973128f, -0.04121206f, -0.05144364f, 0.03001328f, 
    0.01718942f, -0.04706062f, -0.05311523f, -0.04951881f, -0.00453535f, 0.01126061f, 0.03161773f, 0.01252592f, 
    -0.03757316f, -0.06286959f, -0.01982377f, 0.00321327f, -0.00494700f, 0.04156447f, -0.04147301f, 0.03133712f, 
    0.00003198f, -0.03399463f, -0.01305410f, 0.01206914f, 0.03425892f, -0.02418775f, -0.04039726f, 0.01863548f, 
    -0.00933460f, -0.02169927f, 0.02329952f, 0.03935469f, 0.00827910f, -0.02454403f, -0.04581712f, 0.00124104f, 
    -0.04857661f, -0.04956741f, -0.04965233f, -0.04498583f, -0.04918604f, 0.02204258f, -0.04721355f, -0.04491883f, 
    0.01097637f, 0.00928563f, -0.02662355f, 0.01095787f, 0.01358732f, -0.01131561f, -0.04128589f, -0.01680032f, 
    0.03400044f, 0.01249938f, 0.00206173f, -0.01850821f, -0.03149349f, -0.01566448f, 0.03246517f, -0.02274567f, 
    0.05164978f, -0.05537180f, -0.02839790f, -0.03843900f, 0.03293088f, 0.03476716f, 0.02300532f, -0.02906201f, 
    0.23788288f, 0.15824009f, 0.09408797f, 0.07927166f, -0.12031592f, 0.09833252f, 0.03751859f, 0.03968917f, 
    -0.12672997f, -0.13909447f, -0.43031469f, -0.04349030f, 0.06971465f, 0.01936147f, 0.01042884f, -0.08402163f, 
    -0.02326540f, -0.04762290f, -0.16720690f, -0.08641984f, 0.15088862f, -0.09906875f, 0.08667520f, -0.03222260f, 
    -0.15212652f, 0.04717983f, 0.11149586f, 0.06314661f, 0.08354402f, -0.07716856f, -0.07484549f, -0.01298194f, 
    -0.06500322f, -0.00193971f, 0.04622171f, -0.13921942f, 0.06721918f, -0.03396688f, -0.06164414f, 0.00047129f, 
    0.00189368f, -0.11714525f, 0.06159434f, 0.09963150f, 0.04732881f, -0.09097985f, 0.06159209f, -0.01294326f, 
    -0.07349385f, -0.00508759f, 0.01376371f, 0.00191538f, 0.12481152f, -0.04455599f, 0.01337895f, 0.15977226f, 
    0.05882124f, 0.05813672f, 0.04243167f, 0.05516680f, -0.00725406f, 0.11923229f, -0.06203145f, 0.10498111f, 
    -0.13753197f, -0.05041340f, -0.01276775f, -0.00003929f, -0.02242658f, 0.03351614f, -0.04295377f, -0.06812730f, 
    0.14176396f, 0.11724634f, -0.01413033f, -0.04705361f, -0.02885354f, 0.15730399f, -0.04241969f, -0.05592240f, 
    -0.12607566f, -0.00941854f, 0.11278243f, 0.07170962f, -0.03620450f, -0.01914028f, 0.08223389f, 0.02281737f, 
    -0.01225877f, -0.05385147f, -0.24639712f, -0.23803343f, 0.00578169f, -0.05310148f, -0.01248108f, 0.14447981f, 
    -0.06875195f, -0.03565447f, -0.07431745f, 0.04739329f, 0.03686199f, 0.08976277f, 0.03418140f, 0.17038526f, 
    -0.13854001f, 0.00843844f, -0.05504320f, -0.07995445f, -0.09228496f, 0.07106080f, -0.01477432f, 0.08333812f, 
    -0.02394870f, 0.05919633f, -0.00272408f, -0.03074297f, 0.04027015f, -0.12057724f, -0.31330961f, 0.13245974f, 
    0.02928910f, -0.02415055f, 0.10078508f, -0.07476999f, -0.13036719f, -0.06179783f, 0.02122787f, -0.02668758f, 
    -0.01099490f, 0.08157256f, 0.07885541f, -0.13032624f, -0.00830247f, 0.00105643f, 0.06099596f, -0.07653197f, 
    0.11196479f, 0.04581618f, 0.07556147f, 0.02538406f, 0.04961650f, 0.05704195f, 0.11776154f, 0.02271381f, 
    -0.22312160f, -0.35819802f, 0.01663524f, -0.03519232f, -0.05602948f, -0.04023784f, -0.03490998f, -0.09347758f, 
    -0.01901278f, -0.03550215f, 0.06451439f, -0.01780968f, -0.20650312f, -0.11385997f, 0.00026942f, -0.04026807f, 
    0.12613337f, -0.01550290f, -0.11588819f, -0.24810588f, 0.08731516f, 0.06285674f, -0.22231932f, -0.05138488f, 
    0.12827359f, 0.03882381f, 0.13143134f, -0.02470768f, 0.17469852f, 0.17035143f, 0.00886629f, -0.00132455f, 
    -0.01584725f, 0.04342702f, 0.11318714f, -0.03394487f, -0.03696244f, 0.00582305f, 0.07017603f, 0.18454623f, 
    0.05433994f, -0.03060917f, 0.03386160f, -0.07265282f, -0.08553571f, 0.26716685f, 0.22128792f, 0.10586106f, 
    0.08012010f, 0.00275459f, 0.01917688f, 0.00679243f, 0.02396552f, -0.12562241f, 0.35944036f, 0.00284992f, 
    0.09065247f, 0.00394200f, 0.03066832f, 0.00226932f, -0.05402676f, -0.02258254f, -0.15204525f, 0.08545430f, 
    -0.04503822f, 0.17865723f, -0.06705067f, -0.00515701f, 0.03281379f, -0.03267754f, -0.04040636f, -0.07951918f, 
    -0.13046840f, 0.08073009f, 0.10486430f, 0.03989723f, -0.01648564f, 0.02239065f, -0.05607921f, -0.03987575f, 
    -0.03973360f, 0.15935995f, 0.10441123f, 0.09493808f, -0.04752902f, -0.15177192f, -0.03065469f, 0.02609627f, 
    0.02664188f, 0.08486264f, 0.13584316f, 0.00421481f, 0.04378802f, 0.09971686f, 0.02564923f, -0.03190318f, 
    0.02724051f, 0.08231425f, 0.06237603f, 0.24496920f, 0.13661875f, 0.11613452f, 0.07221948f, 0.02689197f, 
    0.14622411f, -0.10850985f, -0.05456497f, -0.06040614f, -0.20670164f, 0.02175617f, 0.06329023f, 0.01121947f, 
    0.02404835f, -0.03267446f, 0.08835384f, -0.06837633f, 0.12368006f, -0.19269726f, -0.23713066f, -0.18209498f, 
    0.09733815f, -0.06696922f, 0.02074626f, -0.06522169f, -0.13248071f, 0.09222904f, 0.09746225f, 0.10643885f, 
    -0.17237207f, -0.03601267f, -0.02428278f, -0.10348233f, -0.00798010f, 0.10921000f, -0.00424074f, 0.00355539f, 
    -0.06556977f, -0.06480784f, -0.09071020f, -0.02746926f, -0.03051249f, 0.02998560f, 0.05183227f, 0.05188528f, 
    -0.01870185f, -0.04219794f, 0.03477981f, -0.13861538f, -0.09433737f, -0.07407828f, 0.02802404f, -0.14544049f, 
    0.00312074f, -0.21643409f, 0.00326994f, 0.16826540f, 0.07768790f, 0.04538184f, -0.04315842f, 0.02434646f, 
    0.03043082f, 0.17807241f, -0.21630569f, -0.15292993f, -0.28279859f, 0.10030173f, 0.08779570f, -0.05085786f, 
    0.03595474f, -0.05697996f, -0.03684947f, 0.13058472f, -0.12458410f, -0.00623085f, -0.01024802f, -0.07933477f, 
    0.13372928f, -0.05765337f, 0.06478542f, 0.03372656f, 0.08743823f, 0.10900797f, -0.00722282f, -0.07056272f, 
    -0.14024818f, 0.00108529f, 0.05560214f, -0.04813212f, 0.02586587f, 0.02227186f, 0.05503739f, -0.03001750f, 
    0.22975527f, -0.04024203f, -0.08223320f, 0.12124590f, -0.24637686f, -0.05634385f, -0.14042741f, 0.02129939f, 
    -0.12806343f, -0.06798422f, 0.03014135f, -0.13625360f, 0.00337924f, -0.02881513f, 0.02468988f, 0.38901383f, 
    0.08063080f, 0.03074563f, 0.04515735f, -0.03829807f, -0.10071548f, -0.05366393f, -0.01723766f, 0.07960492f, 
    0.13083261f, 0.13638370f, -0.08655466f, 0.10767730f, -0.15930492f, -0.06833879f, 0.12013370f, 0.06637714f, 
    0.07153541f, 0.01422344f, 0.04626539f, 0.00345798f, 0.07800551f, 0.01416672f, -0.04122476f, 0.01055972f, 
    0.02797510f, 0.06366237f, -0.06437029f, -0.17544739f, -0.10432708f, 0.11123688f, 0.01756039f, -0.05821356f, 
    -0.06028795f, -0.04825946f, -0.00953006f, 0.23625003f, -0.23892316f, 0.05735695f, -0.19565770f, 0.03059903f, 
    0.09143062f, 0.14768288f, 0.01637636f, -0.06336221f, 0.02525220f, 0.06964457f, 0.09835895f, -0.03276747f, 
    0.04953286f, -0.01016664f, -0.01373387f, 0.16043697f, 0.09759881f, -0.04268421f, 0.04154572f, 0.02327028f, 
    0.23533575f, 0.05436768f, 0.06750780f, -0.04401364f, -0.03838663f, -0.02181124f, -0.11031178f, 0.10906356f, 
    0.03924944f, 0.09188551f, -0.11118554f, -0.08887088f, 0.06184155f, 0.03412971f, 0.00384046f, 0.00520911f, 
    0.06346238f, -0.03117176f, -0.15387255f, -0.04385947f, 0.02900746f, -0.10369085f, 0.01815205f, -0.05102941f, 
    0.04258915f, 0.00244013f, -0.10995813f, 0.03801659f, 0.11138842f, 0.04514740f, 0.11328251f, 0.02650052f, 
    0.10542201f, 0.23015551f, -0.12917215f, -0.02769413f, 0.00977312f, -0.00301352f, 0.06236913f, 0.00072626f, 
    0.10021084f, -0.02300534f, 0.00180749f, -0.09755278f, -0.05447856f, -0.02151131f, -0.00302475f, 0.00004382f, 
    0.18885595f, 0.04751112f, 0.08493657f, -0.12372784f, 0.13156728f, 0.02012927f, 0.03035381f, -0.04611604f, 
    -0.00116158f, -0.03226396f, 0.15837765f, 0.08956156f, -0.15739438f, -0.01522927f, -0.05851454f, 0.03966902f, 
    -0.04825902f, 0.09699588f, -0.07061125f, -0.11279059f, 0.00289685f, 0.04590075f, 0.06415163f, 0.08101720f, 
    0.02064352f, 0.01652595f, -0.04125830f, 0.07647999f, 0.03419900f, 0.01216329f, -0.13195090f, -0.12583371f, 
    -0.01289213f, -0.05873088f, -0.06259387f, 0.14289296f, 0.01453657f, -0.09260992f, -0.01424462f, 0.01161799f, 
    -0.22285931f, 0.22469921f, 0.00740494f, 0.00964318f, -0.19772637f, 0.15540962f, -0.22234492f, 0.03426111f, 
    -0.20523256f, 0.17846483f, 0.04822942f, -0.10413001f, 0.07891005f, 0.13790163f, 0.00492830f, -0.01140726f, 
    0.03269641f, -0.04747451f, 0.13665417f, -0.10716695f, -0.05000699f, -0.12791209f, -0.12747988f, 0.04120546f, 
    0.03235072f, 0.08314211f, 0.14270212f, -0.03638407f, -0.08758222f, -0.07300866f, -0.21587896f, 0.04576377f, 
    -0.05492259f, -0.09206719f, -0.05863780f, -0.02735943f, -0.12131414f, -0.00603353f, -0.19983780f, 0.08991354f, 
    -0.04063861f, 0.05423914f, -0.05335092f, -0.02335837f, 0.12758559f, 0.00570825f, 0.06074193f, -0.09568604f, 
    -0.03026226f, -0.13586366f, -0.06074279f, 0.05159885f, 0.05076839f, 0.10923310f, 0.14464514f, 0.01612022f, 
    0.06191788f, 0.03920149f, -0.05566709f, 0.09820832f, 0.00685460f, 0.00807145f, 0.18360247f, 0.17202501f, 
    0.29458430f, -0.05425458f, -0.13447940f, -0.08237334f, -0.09784581f, 0.13448957f, -0.02948375f, 0.10914360f, 
    -0.03363672f, -0.05876705f, -0.07479554f, -0.15033588f, 0.13594861f, 0.12557171f, 0.06416518f, -0.09867547f, 
    -0.13902266f, -0.03909764f, 0.09019597f, 0.17436169f, 0.03898825f, 0.08635909f, -0.10420433f, 0.04653764f, 
    0.05469935f, -0.14739956f, -0.07943263f, -0.06340483f, -0.13270205f, 0.09067796f, 0.01518852f, 0.11188066f, 
    0.05034727f, -0.04975245f, 0.05257750f, -0.03556248f, -0.01863816f, 0.05500241f, -0.03564503f, 0.16656151f, 
    0.10156876f, 0.06841390f, -0.16691320f, -0.01063279f, 0.11398502f, -0.02551234f, -0.04489289f, 0.03407146f, 
    0.05015395f, 0.15554102f, 0.02026931f, -0.04390659f, -0.05633518f, -0.00117474f, -0.22314148f, 0.29205379f, 
    0.02457717f, 0.07984610f, -0.07035759f, -0.05962486f, -0.01465961f, 0.13795680f, -0.03777621f, -0.08211657f, 
    0.05465034f, -0.00660850f, -0.07583584f, 0.08362690f, 0.00387687f, -0.15251029f, 0.13100356f, 0.03859936f, 
    0.11774520f, 0.01750882f, 0.04372980f, 0.05070165f, -0.02863996f, 0.00475998f, 0.06638874f, 0.09568229f, 
    -0.06243357f, 0.07650918f, -0.19457585f, -0.01821848f, -0.13081907f, 0.02909860f, -0.06721586f, 0.03645675f, 
    0.12598920f, 0.08999444f, 0.10540096f, 0.03120361f, -0.04432431f, -0.07539763f, 0.07802399f, 0.02765650f, 
    0.06815619f, 0.12911911f, 0.05303108f, 0.09532169f, 0.07569627f, -0.02696486f, 0.07153223f, 0.07568460f, 
    0.13166773f, 0.04122947f, 0.06941574f, 0.03089976f, 0.06398118f, 0.07768500f, -0.04075271f, 0.00250757f, 
    0.01794551f, 0.08814292f, -0.06721617f, 0.16812654f, 0.04725109f, 0.00471074f, -0.12429737f, 0.02959628f, 
    0.07677432f, 0.08681779f, -0.06566669f, -0.01710675f, -0.03564939f, -0.00120993f, -0.01874754f, 0.08556474f, 
    0.18070135f, -0.01723280f, -0.08590590f, -0.07961059f, 0.06715731f, 0.02478850f, 0.03304169f, 0.00008867f, 
    -0.12051696f, 0.05695165f, -0.03121592f, -0.03659644f, 0.11103488f, -0.01366925f, -0.06740431f, 0.00288105f, 
    -0.08547702f, -0.05453778f, 0.09520350f, 0.16863862f, 0.01495310f, 0.01304295f, -0.07496663f, -0.04954446f, 
    0.08306373f, 0.17139718f, 0.22418620f, 0.12781385f, 0.05852170f, -0.07821097f, -0.13266426f, 0.04537845f, 
    -0.08309362f, 0.03228005f, -0.07040834f, 0.08275260f, 0.11864451f, -0.01721255f, -0.09876444f, 0.02761788f, 
    -0.02207974f, 0.12183001f, 0.14912574f, 0.06633937f, 0.15038730f, 0.00007643f, -0.05530882f, 0.06248775f, 
    0.03188246f, 0.02226782f, 0.05223121f, 0.11822357f, 0.03950160f, -0.04718909f, 0.09723052f, -0.06628857f, 
    -0.12610993f, -0.00790446f, 0.00241388f, -0.14063999f, 0.00644924f, 0.11901641f, 0.16148704f, -0.02735081f, 
    0.03723221f, 0.13456225f, 0.06900398f, 0.00710595f, 0.14634961f, 0.02303202f, 0.04018347f, -0.09575010f, 
    0.06290709f, 0.17073697f, 0.08312429f, 0.03059656f, -0.06999132f, 0.08748099f, -0.02975410f, 0.09572411f, 
    0.14216283f, -0.10889924f, 0.04542156f, 0.24275129f, -0.01354508f, -0.08041494f, 0.28310886f, 0.21052264f, 
    0.07122861f, -0.18562199f, 0.22170430f, 0.17275217f, -0.06271356f, 0.13076571f, 0.04781389f, 0.10739105f, 
    0.03387731f, -0.14936215f, -0.02787377f, 0.03137467f, 0.07685751f, 0.00064666f, 0.16382955f, -0.05124024f, 
    -0.03805877f, -0.06909855f, 0.08667748f, 0.11320788f, -0.00554305f, -0.02214613f, 0.13735764f, -0.05966864f, 
    0.02148087f, -0.18695977f, 0.03983868f, 0.10660923f, 0.12518425f, -0.03596749f, 0.14105724f, 0.08136864f, 
    -0.12687248f, -0.08358697f, 0.09681445f, 0.13627221f, -0.05173691f, 0.19024855f, -0.05879010f, 0.12956549f, 
    0.05966116f, 0.01591715f, 0.00550549f, -0.11986303f, 0.14201593f, 0.10454763f, 0.12484085f, -0.04722352f, 
    0.00476706f, -0.09092423f, 0.00871158f, 0.01830887f, -0.10249880f, 0.14603026f, 0.03120831f, 0.04028188f, 
    0.09790009f, 0.00371272f, -0.05298384f, -0.12240563f, -0.01575010f, 0.01159555f, -0.00804766f, -0.03305022f, 
    -0.00609211f, 0.02737155f, -0.14765601f, 0.01032967f, -0.06414966f, -0.08433666f, 0.04250383f, -0.12976266f, 
    -0.09260093f, 0.17925164f, -0.04688752f, -0.09700428f, 0.00512158f, -0.18459062f, -0.16986112f, -0.20414948f, 
    0.24431409f, -0.13378999f, 0.16196109f, -0.02512594f, 0.11457466f, 0.03808219f, -0.08374805f, 0.02389822f, 
    -0.03093514f, -0.05389752f, 0.00548688f, -0.03853846f, -0.00024226f, -0.05082520f, 0.02198708f, 0.04281985f, 
    -0.04907541f, 0.04037463f, 0.04601566f, -0.00418503f, -0.01607886f, -0.00256975f, -0.04610008f, -0.03279188f, 
    0.01924284f, 0.03566800f, 0.04631627f, -0.04446935f, 0.02327169f, 0.03528313f, 0.03565593f, 0.04686164f, 
    0.04779213f, -0.03884831f, 0.02113562f, -0.00725516f, -0.04100404f, 0.03479989f, -0.02166672f, 0.02732494f, 
    -0.01295773f, 0.04613988f, 0.04063557f, 0.03258714f, -0.01914056f, 0.00467201f, 0.04454007f, -0.03247184f, 
    0.04652111f, 0.04869466f, -0.01396649f, -0.02849922f, 0.02266344f, -0.02281767f, 0.02301138f, -0.06448154f, 
    -0.01458099f, 0.04976545f, 0.04385626f, 0.03095929f, -0.05630031f, 0.03848350f, 0.02827789f, -0.00616025f, 
    -0.05053205f, 0.01742266f, -0.04588638f, -0.02666543f, 0.02554485f, 0.04637439f, -0.01530610f, -0.06192185f, 
    0.04243653f, -0.04677308f, -0.04110069f, 0.02868246f, -0.01042173f, -0.03076921f, 0.04178580f, -0.00403726f, 
    -0.03737932f, -0.04407065f, -0.04452235f, -0.02078505f, -0.02369217f, -0.00473823f, -0.00104554f, 0.03053309f, 
    0.04474866f, -0.03048706f, -0.01785734f, -0.02572542f, -0.02382427f, -0.04812609f, 0.01368921f, -0.04775970f, 
    0.05218899f, -0.02685889f, -0.00019382f, -0.02138309f, -0.05337359f, -0.05370653f, 0.05393364f, -0.03335796f, 
    -0.04745376f, -0.02321436f, -0.03357795f, -0.02068525f, -0.03747300f, -0.00363964f, 0.00933073f, 0.00993240f, 
    -0.05953129f, 0.02556394f, -0.06058313f, -0.05918153f, 0.02025059f, 0.00507570f, -0.04449701f, 0.04727876f, 
    0.02959426f, -0.03099449f, -0.02576446f, -0.00894828f, 0.02293423f, -0.01092053f, -0.03714138f, -0.04715783f, 
    0.04116355f, -0.05806351f, 0.02257643f, -0.00569068f, 0.03692158f, -0.03998166f, 0.01492453f, -0.05442297f, 
    0.01533169f, -0.00522880f, 0.03288058f, -0.00711691f, -0.05752387f, -0.04450128f, 0.04823850f, -0.04364528f, 
    -0.04855323f, -0.03192328f, 0.04155210f, -0.05489831f, 0.04253127f, -0.02111408f, -0.04288196f, -0.05789963f, 
    0.00797130f, 0.00483632f, 0.00552814f, -0.00073231f, 0.01290973f, -0.05104662f, -0.02209954f, -0.02794543f, 
    -0.02676218f, 0.02892791f, -0.04939066f, 0.04874861f, 0.00621307f, -0.03776324f, 0.04604899f, -0.00461709f, 
    -0.01429191f, 0.01325064f, -0.03705068f, -0.05278718f, -0.00716556f, 0.01406527f, -0.03852089f, 0.04764418f, 
    -0.01780397f, 0.03622631f, -0.00964098f, -0.04092933f, 0.01703973f, 0.04967562f, 0.02678427f, 0.03032972f, 
    0.03456793f, 0.05882411f, -0.02931962f, -0.03257215f, 0.03259359f, -0.02302241f, -0.00191273f, -0.02772843f, 
    -0.06185391f, -0.04421663f, -0.03196131f, -0.04932915f, -0.04149195f, -0.05677418f, -0.04764573f, -0.04158782f, 
    -0.00059683f, -0.05581437f, -0.00372305f, -0.00106526f, -0.05549336f, 0.05173158f, 0.01168518f, 0.03248321f, 
    -0.02858539f, 0.04864499f, -0.03726992f, -0.00329792f, -0.05224814f, 0.00237493f, 0.00937461f, -0.03552541f, 
    -0.00242929f, -0.01966998f, 0.00366553f, 0.02431967f, -0.05833385f, 0.01047158f, 0.04407600f, -0.02643055f, 
    -0.06254379f, -0.00714214f, -0.02090888f, -0.00680804f, 0.03648008f, -0.02372340f, -0.02688391f, -0.04752025f, 
    0.05639154f, -0.00997559f, -0.00487095f, 0.03447161f, -0.03713296f, 0.01786008f, -0.01085036f, -0.03502363f, 
    -0.02005623f, 0.01355479f, 0.00600138f, -0.03381133f, -0.01218696f, 0.01410062f, -0.02518358f, 0.04347452f, 
    -0.02925660f, -0.06169005f, 0.01686765f, -0.06400173f, -0.05411945f, -0.00255507f, 0.03189003f, 0.03012769f, 
    0.00282445f, -0.03503000f, 0.00288579f, 0.05077180f, 0.00526414f, -0.06417398f, -0.03752735f, 0.02080822f, 
    -0.02773684f, -0.00379702f, 0.01627408f, 0.02149367f, -0.01825974f, -0.05456693f, -0.04835495f, 0.03841358f, 
    0.01657978f, 0.03091275f, 0.00663091f, -0.04087740f, -0.04888852f, 0.06235018f, 0.03747424f, -0.02800523f, 
    -0.05407025f, -0.06074868f, -0.05150297f, 0.03189278f, 0.04307386f, 0.03442040f, 0.00127203f, -0.04719353f, 
    -0.05862696f, 0.01839451f, -0.00089678f, 0.03410518f, 0.04818236f, 0.00430481f, 0.00628407f, 0.02385473f, 
    0.23535886f, 0.20859538f, 0.16421337f, 0.11387526f, -0.02914572f, 0.04514714f, 0.05287533f, -0.03290514f, 
    -0.03598525f, -0.30561686f, -0.05789363f, -0.07122985f, 0.01896289f, 0.03589850f, 0.00657617f, -0.05514530f, 
    0.01605326f, -0.02064789f, -0.11430557f, 0.07837784f, -0.01852464f, -0.04157574f, 0.06219363f, 0.08156963f, 
    -0.06221213f, -0.11421739f, 0.03038314f, 0.04453014f, -0.05633442f, 0.17144866f, 0.03799496f, -0.00652316f, 
    -0.21737546f, 0.03406577f, -0.02652565f, -0.07659917f, 0.18081324f, 0.02335582f, 0.10305702f, -0.01799549f, 
    0.09892499f, 0.01701448f, 0.09597709f, -0.04522528f, 0.06112944f, -0.29325417f, 0.18184364f, 0.05735566f, 
    0.12098245f, 0.11743918f, -0.02896089f, -0.02449686f, -0.02927397f, 0.10403504f, 0.07609738f, 0.26899803f, 
    0.08870832f, 0.07190403f, -0.00410205f, -0.06970454f, -0.04752506f, -0.05240170f, -0.02504302f, -0.13578144f, 
    -0.03138024f, -0.29067791f, 0.01380882f, -0.01754589f, 0.01332367f, 0.04588499f, 0.00953314f, 0.10235921f, 
    -0.13889657f, -0.05182965f, -0.11273225f, 0.02168665f, -0.10766873f, 0.05119080f, -0.10867316f, 0.01753064f, 
    -0.10585064f, 0.03558769f, 0.05040323f, -0.00005850f, -0.00864477f, -0.10290508f, -0.03753860f, -0.00475414f, 
    0.02094049f, 0.04534588f, -0.12213860f, -0.04647767f, -0.03059721f, -0.00966384f, 0.06996570f, 0.00524457f, 
    0.04714849f, 0.02628617f, -0.03326392f, -0.09813576f, 0.02157724f, 0.15123273f, 0.01934689f, 0.11002941f, 
    -0.07571158f, -0.08565180f, 0.05269873f, 0.08520004f, 0.13510254f, 0.09026776f, 0.01793538f, 0.03484765f, 
    0.01504813f, 0.02848781f, 0.09851913f, 0.00133106f, -0.04180173f, -0.34398460f, 0.03374919f, -0.08373267f, 
    -0.03110924f, -0.07528111f, 0.07829850f, -0.08648475f, -0.06293353f, -0.10300507f, -0.14260989f, -0.13796838f, 
    -0.01144752f, 0.02509890f, -0.03374606f, -0.05239505f, -0.10168090f, 0.10975002f, -0.02495004f, 0.06652747f, 
    0.10031592f, 0.09621913f, 0.04859908f, 0.01573294f, 0.10244068f, 0.12756284f, -0.04004527f, 0.04128605f, 
    -0.05434547f, -0.00121816f, -0.14368401f, -0.02897836f, -0.01683683f, 0.02125733f, 0.17155439f, -0.10118312f, 
    -0.00485724f, 0.03187707f, 0.05106647f, 0.05307794f, -0.03406137f, -0.01995910f, -0.09646036f, 0.15277803f, 
    -0.07576809f, 0.12790866f, -0.12092796f, 0.01033282f, -0.06762928f, 0.09314027f, -0.02539407f, -0.02638033f, 
    0.18731463f, -0.13323686f, 0.26525670f, 0.15464340f, 0.01223599f, 0.12282249f, -0.14271273f, -0.03746724f, 
    -0.08424757f, 0.00592850f, 0.01302021f, -0.00251620f, -0.11077942f, -0.00364429f, -0.18608876f, 0.05591195f, 
    0.15158238f, -0.08294746f, -0.05354356f, 0.03643502f, -0.01194166f, -0.03861094f, 0.07412392f, -0.02220915f, 
    -0.03149404f, -0.05727031f, -0.14686283f, -0.05908289f, 0.08388440f, -0.00959293f, -0.03771400f, 0.06376372f, 
    -0.10781728f, -0.06817996f, 0.08058061f, -0.08479857f, 0.19065200f, 0.00880686f, -0.00643680f, -0.08119369f, 
    0.21031748f, -0.22746460f, -0.07602657f, -0.01157206f, -0.06548594f, 0.06998432f, 0.01017985f, 0.03398933f, 
    0.14036550f, -0.02473853f, 0.07910521f, -0.04431973f, 0.02818429f, -0.02997494f, -0.00098976f, 0.04859404f, 
    -0.11799621f, 0.16603634f, 0.08533929f, 0.10841827f, 0.04469107f, -0.07096194f, 0.02389931f, -0.04516824f, 
    -0.03574861f, 0.18076079f, 0.14524850f, 0.15207717f, -0.08955742f, 0.15874545f, 0.03021644f, 0.06063680f, 
    0.11970873f, 0.02937096f, 0.00162631f, 0.22813767f, 0.12349603f, 0.04478644f, -0.01678979f, -0.13615508f, 
    0.03074358f, -0.05731686f, 0.01118986f, 0.00242384f, 0.07693154f, -0.09008855f, 0.08677685f, 0.16558519f, 
    0.03993717f, 0.10305345f, -0.12418153f, 0.14080283f, -0.05745304f, -0.20081203f, 0.02860668f, -0.16744629f, 
    0.00572990f, -0.00561249f, -0.16636460f, -0.10279343f, -0.00844019f, -0.00706459f, 0.07815208f, 0.02592311f, 
    -0.10955908f, 0.02682357f, 0.05969394f, 0.02083538f, 0.13303865f, -0.14412959f, -0.12862571f, -0.02950112f, 
    0.01589478f, -0.06656016f, -0.01296736f, 0.06332580f, 0.01166863f, -0.00377207f, 0.04924430f, -0.06820100f, 
    -0.05844400f, -0.04805987f, 0.02920567f, -0.00345255f, 0.00170517f, 0.01680581f, 0.02604788f, -0.00537590f, 
    0.02380091f, -0.05107500f, -0.01716477f, -0.05010331f, -0.04864160f, -0.06979401f, 0.02733461f, 0.00902967f, 
    0.03694525f, -0.04779085f, -0.01332732f, -0.05245608f, 0.01423004f, 0.03551906f, -0.04972765f, -0.03590629f, 
    -0.00490070f, -0.04658355f, 0.00325389f, -0.03387147f, -0.02144642f, -0.01404581f, -0.02771427f, -0.03037143f, 
    -0.06161929f, -0.04589408f, 0.03481172f, -0.01022003f, 0.03015437f, -0.06022551f, -0.01144647f, -0.01142610f, 
    0.02597302f, -0.01118919f, 0.00166414f, -0.00349352f, -0.01496565f, 0.00410887f, -0.00681969f, -0.03570315f, 
    -0.00922239f, 0.03734817f, -0.03660861f, 0.04433481f, 0.05378862f, -0.02564931f, 0.01257578f, -0.03568800f, 
    0.01023315f, -0.00838241f, -0.04621671f, 0.03944877f, 0.03621819f, -0.04521357f, 0.00187607f, 0.03711130f, 
    0.03522144f, 0.00493870f, -0.05940687f, -0.03915928f, 0.03885627f, -0.01937518f, -0.04729874f, -0.00723781f, 
    0.03573107f, -0.03716090f, -0.06156248f, -0.05934303f, -0.04626751f, 0.00212576f, 0.02175983f, -0.02763546f, 
    -0.06507070f, -0.05806573f, 0.03181734f, 0.03854718f, -0.03640151f, -0.06050527f, -0.01588626f, 0.03572783f, 
    -0.04796889f, -0.02485709f, -0.00488876f, 0.00477283f, 0.03122395f, -0.04862694f, 0.04747246f, -0.04958281f, 
    0.01293936f, 0.02237933f, 0.03632921f, 0.04370724f, -0.04245424f, -0.02723740f, 0.01810670f, 0.01870731f, 
    0.03521559f, 0.02257670f, -0.00881696f, -0.00043888f, -0.03877997f, -0.05784934f, -0.06171043f, 0.04054178f, 
    -0.05094099f, 0.04396510f, 0.02549451f, -0.00631892f, -0.03783191f, 0.00708654f, 0.04042121f, 0.00228535f, 
    -0.01098306f, -0.01983833f, -0.06278410f, -0.05422109f, -0.03661144f, -0.05789442f, -0.02948336f, -0.03562849f, 
    0.03041450f, -0.03237845f, 0.02003207f, 0.00951550f, -0.00189056f, -0.04947232f, -0.01021766f, 0.04095008f, 
    0.01771600f, -0.02094715f, -0.02142661f, -0.01689753f, -0.00829213f, 0.02530709f, 0.04044089f, 0.03442558f, 
    0.04319683f, -0.02002283f, -0.01714793f, -0.02105695f, -0.00617332f, -0.03796342f, 0.00970699f, -0.04449799f, 
    0.02594439f, -0.01830545f, -0.02307186f, -0.00622390f, 0.00224833f, 0.04702679f, 0.04061419f, 0.00080776f, 
    -0.02890655f, -0.05024774f, 0.00188619f, 0.03022936f, 0.04213602f, 0.03968607f, -0.06288274f, 0.00333267f, 
    -0.02973842f, 0.03268054f, 0.01729213f, -0.03359864f, 0.00496895f, -0.00544012f, -0.00685802f, -0.00500652f, 
    0.02483754f, -0.03824669f, -0.05777129f, 0.01275917f, 0.01014295f, -0.04784419f, -0.02294144f, -0.00024396f, 
    -0.05259627f, -0.01605782f, 0.03786133f, 0.00300719f, -0.02342701f, -0.02532826f, -0.04839188f, -0.00982928f, 
    -0.02121067f, -0.03013626f, -0.03968873f, -0.00024984f, 0.03784534f, 0.04695182f, -0.05411976f, -0.01102365f, 
    0.05106109f, 0.02355321f, 0.04582402f, -0.01898140f, -0.04473139f, -0.00842487f, 0.04554385f, 0.01829044f, 
    -0.04690471f, -0.05791187f, -0.00874316f, -0.00268948f, 0.03314303f, -0.00048864f, 0.02454078f, -0.04330148f, 
    0.01801592f, -0.06430075f, -0.01717634f, -0.03131076f, 0.00018582f, -0.02892442f, -0.01798284f, 0.03864961f, 
    0.00814088f, -0.04064151f, -0.02462665f, 0.00496931f, 0.01576028f, 0.04397424f, -0.04749868f, 0.02947125f, 
    -0.02197517f, 0.01620615f, -0.05521978f, 0.03257284f, 0.04821006f, 0.03469185f, 0.02326041f, -0.06041257f, 
    -0.00934343f, 0.00788932f, -0.03294555f, -0.00746942f, 0.02893401f, -0.02075711f, 0.01683376f, -0.02491921f, 
    -0.03502878f, 0.01795740f, 0.02818664f, 0.02540355f, -0.05371742f, -0.00177927f, -0.03724793f, 0.05206806f, 
    0.01616007f, -0.05882587f, 0.03035828f, -0.04521734f, -0.00416751f, 0.00525682f, -0.03373933f, -0.04840901f, 
    -0.05644799f, -0.02335817f, 0.03653624f, -0.02095264f, 0.01380873f, 0.03101246f, 0.01977653f, 0.03710016f, 
    -0.02535714f, -0.06892059f, 0.02042598f, 0.00702867f, -0.04085394f, 0.03802821f, -0.00006360f, -0.06053468f, 
    0.00007008f, 0.00611628f, -0.00595882f, 0.00046684f, -0.06219125f, 0.03084639f, 0.03051803f, -0.03990096f, 
    0.14751065f, -0.00950717f, -0.32126820f, -0.02978177f, 0.01290622f, -0.05369673f, 0.04444773f, -0.10054829f, 
    -0.02235196f, 0.08810103f, 0.10585554f, 0.05496999f, -0.01374567f, 0.00955009f, -0.03076759f, 0.11543697f, 
    -0.02610166f, 0.05888331f, -0.08829074f, -0.11511679f, 0.13041192f, 0.03957660f, 0.05842124f, 0.02265476f, 
    0.17260444f, 0.14416164f, 0.07809164f, -0.13232331f, 0.10727849f, -0.26817995f, -0.00157993f, 0.12790368f, 
    0.13611312f, 0.03621874f, -0.10896739f, 0.18195334f, 0.15303196f, 0.09073988f, -0.07253398f, 0.02456837f, 
    -0.05513471f, 0.00850388f, -0.02238374f, 0.05909818f, 0.03896504f, -0.45675200f, -0.08306035f, -0.01721176f, 
    0.11553217f, -0.24660036f, 0.15575103f, -0.12927306f, 0.02953609f, -0.14943333f, 0.01148811f, 0.12544292f, 
    -0.16390596f, 0.00318936f, 0.03061996f, 0.01908709f, 0.01970220f, -0.00295060f, -0.09429616f, -0.06679770f, 
    0.03673659f, -0.07966590f, 0.00916441f, 0.02151283f, 0.01084868f, 0.05701954f, 0.04492845f, 0.10089660f, 
    -0.19580534f, 0.05246313f, -0.12089414f, 0.04572476f, -0.01655382f, 0.18476832f, -0.07390187f, 0.02355402f, 
    0.01693820f, -0.11478122f, -0.06297543f, 0.05197072f, 0.01526917f, -0.01569859f, 0.15891568f, 0.04375285f, 
    -0.07886913f, -0.12192243f, 0.07516905f, -0.04852719f, -0.14267428f, -0.01567443f, -0.00167003f, 0.16305856f, 
    -0.01505193f, 0.14505450f, 0.06570851f, -0.06811363f, -0.12877789f, -0.02338838f, 0.05840889f, 0.08822777f, 
    -0.06787437f, 0.08711022f, -0.10080604f, -0.00379125f, 0.11401749f, -0.01948567f, -0.05865790f, -0.03453445f, 
    0.05549071f, -0.01084974f, 0.02142736f, 0.00511047f, -0.02867782f, 0.09397320f, -0.05955315f, -0.04116413f, 
    0.10431214f, 0.07433099f, 0.07703058f, -0.11041456f, 0.03416990f, 0.09699236f, 0.17444880f, 0.01499945f, 
    -0.00684186f, -0.03309308f, -0.09004796f, -0.03346120f, 0.07927953f, 0.04655217f, 0.02559418f, 0.13172600f, 
    0.04503961f, -0.26686195f, -0.02361408f, -0.09635819f, 0.10658576f, 0.02943225f, 0.07826605f, 0.01257708f, 
    0.12733941f, 0.12885734f, 0.09969012f, -0.01351466f, -0.04096202f, -0.04900734f, -0.01304335f, 0.15237044f, 
    0.12447335f, -0.00168979f, 0.15893088f, 0.00379683f, 0.03225677f, 0.01098301f, 0.04700622f, -0.04653487f, 
    -0.05811135f, 0.22103694f, 0.13335414f, -0.01936597f, -0.27050623f, -0.11315659f, -0.00385099f, 0.03451172f, 
    -0.00354240f, 0.10413971f, -0.02312126f, -0.19815667f, -0.25711349f, 0.10687210f, -0.00559843f, -0.01394329f, 
    -0.00723275f, 0.03737594f, 0.07396993f, -0.01968880f, -0.04527351f, -0.04101561f, 0.00978257f, 0.00384090f, 
    0.05543551f, -0.11002433f, 0.02809290f, -0.06264953f, 0.01637444f, -0.27625275f, 0.01468332f, 0.02925764f, 
    0.02699138f, 0.05137152f, 0.09226958f, 0.01766918f, -0.01827067f, -0.05553932f, -0.20558962f, 0.01300912f, 
    -0.11445883f, -0.02621425f, 0.09092902f, 0.03007373f, 0.07283628f, -0.06990620f, -0.07270674f, -0.13519375f, 
    0.03989364f, 0.12181448f, 0.09360915f, -0.11661371f, -0.00674865f, -0.05614634f, 0.08512660f, 0.06324074f, 
    -0.12134793f, 0.08695709f, 0.18116534f, 0.06678960f, 0.06850187f, -0.00753858f, 0.05945027f, -0.08879715f, 
    0.02127192f, -0.10654638f, -0.12998854f, -0.08344116f, 0.04950801f, -0.02210715f, -0.08959535f, -0.03177772f, 
    0.11330337f, -0.07692473f, 0.13234806f, 0.07493197f, -0.19675542f, -0.02074368f, -0.04769425f, -0.07036755f, 
    0.14055410f, -0.03343210f, -0.03354146f, -0.09051540f, -0.26892489f, -0.12961924f, 0.02614519f, 0.00687782f, 
    0.10073700f, 0.00841456f, -0.05616558f, -0.10226381f, 0.10000569f, -0.32083997f, -0.15158148f, 0.01711810f, 
    0.00921323f, -0.04505119f, 0.03642360f, -0.04877730f, -0.16898341f, 0.06917055f, 0.12510869f, 0.06495617f, 
    -0.07259712f, 0.06879079f, -0.04716473f, -0.13814943f, 0.10643991f, 0.13622493f, 0.08430542f, -0.12163230f, 
    -0.08006879f, -0.10287382f, -0.02933178f, -0.04805328f, -0.02215945f, 0.09511242f, -0.06378637f, -0.08680145f, 
    0.12340366f, -0.12537315f, 0.11616839f, 0.04902175f, -0.02707167f, 0.11875245f, 0.13742484f, 0.06342295f, 
    0.09815832f, 0.20081624f, -0.03908857f, 0.06113626f, -0.09153934f, -0.18228914f, 0.12039711f, 0.03893169f, 
    0.09132160f, 0.10346930f, -0.35928723f, -0.01279880f, -0.03221020f, 0.05949657f, -0.08166555f, -0.01075135f, 
    -0.00901241f, -0.15710028f, -0.01341706f, -0.14263816f, -0.05683683f, 0.02521713f, 0.10237052f, -0.00083689f, 
    -0.10934552f, -0.02212091f, 0.04096033f, 0.01580130f, -0.10233722f, -0.32015184f, 0.10645670f, -0.03403616f, 
    -0.13008177f, 0.02086363f, 0.06805968f, 0.02933325f, -0.08438824f, 0.07958228f, 0.02245408f, 0.00841341f, 
    -0.00788861f, -0.05983150f, 0.15733327f, 0.07817593f, 0.03713074f, -0.01318065f, -0.09580653f, 0.00899357f, 
    -0.15096876f, 0.01056816f, -0.09232187f, 0.10038216f, 0.03558101f, 0.11513268f, 0.22096254f, -0.07764756f, 
    -0.02546943f, -0.09534871f, 0.01705630f, 0.06207672f, -0.17908987f, 0.13784689f, 0.03437043f, 0.34082615f, 
    -0.11999580f, 0.04477724f, 0.07905589f, -0.05927224f, -0.00430388f, -0.01349526f, -0.06874450f, 0.12411153f, 
    0.21179484f, 0.03807428f, -0.02038522f, 0.01273454f, -0.00797629f, 0.07202523f, -0.11082875f, 0.03035653f, 
    0.03049785f, -0.06020336f, -0.01233532f, -0.10550303f, 0.02815625f, 0.04934268f, 0.01762219f, -0.05634797f, 
    -0.00142978f, -0.07721423f, -0.15874900f, -0.07137562f, -0.05995748f, 0.18020003f, 0.18084894f, 0.05408662f, 
    -0.01725617f, -0.07333898f, 0.16674414f, -0.03256487f, 0.09624293f, -0.11685508f, 0.03155787f, 0.03888640f, 
    -0.04873567f, 0.03921483f, -0.07228924f, -0.17624050f, -0.05738502f, -0.06270334f, -0.19518887f, 0.04553187f, 
    0.05333232f, -0.15383877f, -0.02550190f, 0.07182716f, 0.04894994f, 0.23256759f, -0.14192037f, 0.10798992f, 
    0.12191501f, 0.09683243f, 0.05814679f, -0.00763104f, 0.01397547f, 0.09348202f, 0.03849283f, -0.25079361f, 
    0.07499479f, 0.05934462f, 0.16344811f, 0.05481211f, 0.02262675f, 0.08545563f, -0.03660106f, 0.17533235f, 
    -0.00905782f, -0.17536800f, -0.00612522f, -0.03567683f, -0.08566739f, -0.07925660f, 0.16733865f, 0.00796769f, 
    -0.29102325f, -0.24432471f, -0.11693352f, 0.03027969f, 0.04236390f, 0.04612021f, 0.10709015f, 0.00067525f, 
    0.04036716f, -0.05268122f, -0.02552431f, -0.04798553f, -0.07915352f, -0.08288366f, -0.11416208f, 0.08609454f, 
    0.00984893f, 0.14450648f, -0.22339745f, -0.17548522f, -0.13123477f, -0.01549545f, -0.10139441f, -0.03366664f, 
    0.17662553f, 0.01895039f, 0.11551288f, -0.05491841f, 0.00116428f, -0.09907933f, -0.09097680f, 0.04418252f, 
    0.03528744f, 0.00912151f, -0.03437983f, 0.03831130f, -0.00770131f, 0.04461308f, -0.00678507f, 0.13005289f, 
    -0.05168021f, -0.04915527f, -0.01206714f, 0.04046204f, -0.11160979f, 0.21681985f, 0.26587278f, -0.05085449f, 
    -0.05279962f, -0.00001041f, 0.00834495f, 0.00063082f, 0.03743155f, -0.06214926f, 0.25664434f, -0.21022516f, 
    -0.00866194f, -0.03514735f, 0.01223010f, -0.09224988f, 0.04234957f, -0.04932923f, -0.09820242f, 0.00445978f, 
    -0.22481278f, -0.06417380f, -0.09652644f, 0.08312283f, 0.04444760f, 0.03207295f, -0.09431349f, 0.10282366f, 
    -0.05204966f, 0.08236128f, 0.00584458f, -0.18666740f, -0.03182045f, 0.08427735f, 0.04295106f, -0.02189119f, 
    0.10157023f, 0.08719960f, -0.11343180f, 0.10199495f, -0.17645502f, -0.02543476f, 0.05868977f, -0.03243325f, 
    -0.01655418f, 0.04276596f, 0.06041005f, 0.06686305f, -0.04625496f, 0.09425157f, 0.08905850f, -0.02799927f, 
    0.00608988f, 0.08387391f, 0.12179512f, 0.06847722f, 0.08530089f, -0.15633906f, 0.00565446f, 0.01667100f, 
    -0.06810715f, -0.01946270f, 0.01394070f, -0.11761419f, -0.16639017f, -0.00303077f, -0.04627803f, 0.09774756f, 
    -0.02182252f, -0.03146509f, 0.09304167f, 0.00233420f, 0.07177307f, -0.10612147f, -0.29237792f, 0.02636156f, 
    -0.00922049f, 0.00099690f, 0.19506499f, 0.06514905f, -0.02043558f, 0.06830201f, 0.13781771f, -0.04593779f, 
    -0.04347927f, 0.08003929f, -0.11241005f, -0.17251849f, -0.00400383f, 0.11494936f, 0.03782617f, -0.05935895f, 
    -0.20430484f, -0.06062111f, 0.08613233f, 0.09066106f, -0.00340669f, 0.01790787f, 0.08044148f, -0.00845192f, 
    0.24597231f, -0.08365774f, -0.05968725f, -0.15251528f, -0.03144303f, 0.08637649f, 0.05759514f, -0.01229659f, 
    0.00461496f, -0.20884046f, 0.14586347f, -0.00984146f, 0.02715988f, 0.02724175f, 0.10741963f, 0.06632102f, 
    0.04353815f, 0.11063689f, -0.12197597f, 0.01652372f, -0.06460422f, 0.03601290f, 0.13294555f, -0.00816776f, 
    0.01797898f, 0.09482470f, 0.11039662f, 0.16903560f, -0.41203803f, -0.06664055f, -0.14547345f, -0.12235270f, 
    -0.03411210f, -0.05698840f, -0.07347212f, 0.06945804f, 0.37076461f, -0.04076545f, 0.12155485f, -0.02243910f, 
    -0.09214544f, 0.00503383f, -0.01849131f, 0.03554579f, -0.00708704f, -0.00525289f, -0.21105322f, -0.17645539f, 
    -0.01099015f, -0.04000957f, 0.06731340f, 0.09420157f, 0.02436106f, -0.06662083f, -0.14652634f, -0.11875388f, 
    -0.00372014f, -0.04650708f, 0.06426769f, 0.01583911f, 0.04377721f, -0.03545571f, 0.02965676f, 0.06590240f, 
    0.11847433f, -0.19016246f, 0.15447243f, -0.03643968f, -0.01106188f, 0.02706881f, 0.08136710f, -0.08502718f, 
    0.22551925f, 0.06567580f, -0.03924156f, 0.03503340f, 0.08577313f, 0.01009501f, -0.02636509f, 0.15150256f, 
    0.07752569f, -0.20281839f, -0.29087180f, -0.01085202f, 0.11321038f, 0.07370611f, 0.06362724f, 0.03120821f, 
    -0.04422799f, 0.07775407f, -0.06702331f, 0.19225107f, -0.04122208f, -0.00110685f, 0.06394653f, 0.08298413f, 
    -0.05731619f, -0.00909164f, 0.02728422f, 0.09474216f, -0.02783126f, -0.41568980f, 0.05666882f, -0.14374821f, 
    -0.02576790f, -0.05709941f, -0.01627843f, 0.13751797f, 0.27228409f, -0.16648389f, 0.07425508f, -0.11271950f, 
    0.12436565f, 0.00878143f, -0.04098346f, -0.00994793f, 0.05481525f, 0.09861945f, 0.33674711f, -0.05779239f, 
    0.09046300f, 0.08440614f, 0.01953105f, 0.04805887f, 0.07273832f, -0.04355169f, -0.55688673f, 0.19740687f, 
    -0.11975998f, -0.05754129f, -0.00821717f, -0.03846541f, 0.04671130f, 0.11184908f, 0.14745599f, 0.10924771f, 
    -0.05209818f, 0.09493928f, -0.08953695f, 0.11132115f, -0.00950458f, -0.07342981f, -0.09026261f, 0.03477062f, 
    -0.20188020f, 0.04043950f, 0.00268081f, 0.04645090f, 0.08616696f, 0.03490645f, -0.09187145f, 0.16767456f, 
    0.03109988f, 0.20318554f, -0.30601120f, 0.04223246f, -0.01801936f, 0.01158262f, -0.01910242f, -0.03669458f, 
    0.02412469f, -0.07825104f, -0.33751693f, 0.31429571f, 0.16140896f, -0.04786476f, -0.03915257f, 0.02503128f, 
    -0.22090766f, 0.08478326f, -0.06953939f, -0.04219138f, -0.11668004f, 0.03011051f, -0.06864658f, -0.04117946f, 
    0.02249620f, -0.09600865f, 0.00399594f, -0.03494658f, 0.25384915f, -0.06663527f, -0.47218707f, -0.12702730f, 
    0.15254323f, 0.06348673f, -0.12741858f, 0.06896418f, 0.11764502f, 0.35884044f, -0.09039751f, 0.09060520f, 
    0.06291457f, 0.09051789f, 0.04765438f, 0.02046376f, -0.00391349f, -0.00508068f, 0.04025584f, -0.27446291f, 
    -0.05878682f, -0.09756769f, 0.11411848f, 0.01636025f, -0.04574636f, -0.10217381f, -0.09685922f, -0.10208042f, 
    -0.24949715f, 0.06753496f, -0.00987282f, 0.21136847f, -0.17813772f, -0.10151248f, 0.10675053f, 0.01062431f, 
    0.17746289f, 0.01497404f, -0.13707930f, -0.07424591f, 0.00879313f, 0.05527282f, 0.00609413f, 0.01881087f, 
    0.04252725f, -0.09107365f, -0.12777622f, 0.03273638f, -0.02842198f, -0.18255852f, -0.13432413f, -0.08284273f, 
    0.07906762f, -0.19023462f, 0.24730980f, 0.06117209f, 0.03602508f, -0.11076395f, -0.15499222f, 0.00844258f, 
    0.05532293f, 0.05862089f, 0.08157127f, 0.08335765f, -0.14451997f, -0.21632884f, 0.13082232f, 0.06580388f, 
    0.09002726f, -0.01825906f, -0.05504972f, -0.00097046f, 0.26547715f, -0.02963443f, -0.29251733f, -0.17266536f, 
    0.06754728f, 0.07180700f, 0.04597370f, -0.01369587f, 0.01804094f, -0.34563097f, 0.11904626f, -0.22309275f, 
    0.08572250f, -0.01766350f, -0.06920341f, -0.10570057f, -0.01636017f, -0.08027484f, 0.31906193f, 0.02914790f, 
    0.02413484f, -0.28717899f, 0.04586272f, -0.03526967f, -0.00614683f, -0.08122181f, 0.04935430f, -0.07039589f, 
    0.08773854f, -0.01150836f, 0.04727927f, -0.06829327f, 0.00890541f, 0.08625720f, 0.03064655f, 0.00759382f, 
    -0.00211373f, -0.21597244f, -0.14076863f, 0.04846267f, 0.02737422f, -0.07699596f, -0.05421874f, 0.03653115f, 
    0.00729841f, 0.08322381f, -0.08202816f, 0.12104774f, -0.01132116f, 0.00075018f, 0.05380657f, -0.01709628f, 
    0.13440803f, 0.01501822f, -0.21255867f, -0.10711633f, -0.02167868f, 0.01327066f, 0.11224961f, -0.06929064f, 
    0.08790661f, 0.16101234f, 0.02257272f, -0.25688255f, 0.23833404f, -0.08203106f, 0.01045888f, -0.16924310f, 
    -0.01338443f, -0.01757134f, -0.07037055f, -0.00532319f, 0.15377335f, -0.15378377f, -0.20068778f, -0.00506292f, 
    -0.01177497f, -0.02380453f, -0.12438177f, 0.03640614f, -0.04220872f, -0.31867838f, -0.08842483f, -0.08638467f, 
    0.02258750f, -0.05203941f, -0.09424350f, -0.05273536f, -0.04970405f, -0.15597896f, -0.17728268f, 0.16487205f, 
    0.00287795f, 0.02614665f, -0.10816890f, -0.06034779f, 0.13295694f, 0.14852333f, -0.02506626f, 0.16608027f, 
    0.02696353f, 0.05140623f, 0.13794006f, 0.05233495f, -0.04051386f, -0.14817554f, 0.14428799f, 0.05009033f, 
    0.07581276f, 0.09361307f, -0.01258123f, -0.07495590f, 0.02871765f, 0.06677230f, 0.08809107f, 0.07424322f, 
    0.03675224f, -0.14190687f, -0.10207655f, 0.04685289f, -0.04574116f, 0.19521688f, 0.13216341f, 0.01841798f, 
    0.06857013f, -0.09121017f, 0.00241771f, 0.00843221f, -0.05852761f, 0.16805248f, -0.00773120f, 0.13608827f, 
    0.09222415f, -0.10494350f, 0.13992414f, 0.15345143f, 0.11890385f, -0.09024443f, -0.09350616f, -0.15321934f, 
    -0.06593426f, 0.08512453f, -0.03833885f, 0.07058901f, -0.23299716f, -0.05641490f, 0.08656358f, -0.09829242f, 
    0.06985191f, -0.01354513f, -0.00012015f, -0.00236114f, 0.03206900f, 0.00115389f, -0.04063775f, 0.08030102f, 
    0.05257791f, -0.00931524f, 0.06360649f, -0.02925926f, 0.09066031f, 0.21455821f, 0.20068204f, 0.01133025f, 
    -0.02186702f, -0.13111275f, -0.01281266f, -0.02674329f, 0.05344743f, 0.05585530f, 0.12538409f, -0.06821737f, 
    -0.10123266f, -0.09664338f, 0.00513790f, -0.01143708f, -0.05759828f, -0.04438453f, -0.03845452f, -0.01350061f, 
    0.08597474f, 0.16639178f, 0.19438617f, 0.00061098f, 0.09006252f, 0.06671435f, -0.05846189f, 0.09357167f, 
    0.08314196f, -0.06291170f, 0.12779643f, 0.13007186f, 0.08164547f, -0.01702255f, -0.09515256f, -0.12376218f, 
    0.10492495f, 0.09879862f, 0.02188807f, 0.15306436f, -0.11414042f, -0.04371238f, 0.02269910f, -0.18003115f, 
    -0.01108388f, -0.19567452f, -0.11146194f, -0.34094119f, -0.20235659f, 0.09353638f, -0.01106219f, 0.15960604f, 
    -0.09370384f, -0.04749757f, 0.08168447f, -0.01870410f, -0.08680387f, -0.32114586f, 0.14449704f, 0.07697231f, 
    -0.06343114f, -0.08543886f, -0.01279376f, 0.10164070f, 0.04956590f, -0.08022659f, 0.23126705f, -0.17209244f, 
    0.02882127f, 0.04479715f, 0.01590235f, -0.16867186f, 0.01497567f, 0.09327905f, -0.11665376f, -0.08207494f, 
    0.12485226f, -0.02180752f, 0.12120886f, -0.03369272f, -0.10643321f, -0.02454837f, -0.10938937f, -0.17712718f, 
    0.03586941f, 0.10097320f, -0.01178120f, 0.07962070f, -0.03563422f, 0.03102380f, -0.02355902f, -0.12196359f, 
    -0.00191827f, -0.06115208f, 0.05948439f, -0.02312577f, 0.11415801f, -0.03736940f, -0.06418430f, -0.04546802f, 
    0.12343612f, -0.37018707f, -0.13711461f, 0.15512684f, 0.02064096f, 0.03391694f, -0.13715817f, -0.03833865f, 
    -0.02508052f, -0.17975973f, 0.12799644f, 0.00207040f, -0.03378352f, 0.10074846f, -0.11309401f, -0.09330243f, 
    0.17490998f, -0.01242509f, -0.00922618f, -0.11878383f, -0.25846156f, -0.31256989f, 0.02405606f, 0.00879004f, 
    0.14361803f, -0.08572364f, -0.05601897f, -0.02655321f, 0.00929553f, -0.38075745f, 0.09583163f, 0.00299810f, 
    -0.05053350f, -0.09841261f, 0.09353442f, -0.03276730f, -0.00267658f, 0.05215699f, 0.15495630f, -0.08899309f, 
    -0.02554273f, 0.05373194f, 0.15598984f, -0.00368694f, 0.03631718f, 0.04618794f, 0.03726443f, -0.11836281f, 
    -0.13527864f, 0.02455975f, 0.01643258f, -0.08832120f, -0.09580266f, -0.05564830f, -0.16015013f, -0.12054601f, 
    0.09219544f, -0.11055862f, 0.05474872f, -0.17560324f, 0.10325523f, 0.04252744f, 0.03247095f, -0.04302356f, 
    -0.06237467f, -0.01532470f, -0.00222841f, 0.01284265f, 0.03706430f, -0.06365009f, -0.00893088f, 0.04536520f, 
    0.01540645f, 0.04453627f, 0.04683054f, 0.03607390f, -0.00762659f, -0.02767406f, -0.00143876f, -0.01755162f, 
    -0.04793822f, 0.01712797f, 0.03827552f, 0.02672889f, -0.03350638f, 0.03061073f, 0.02862212f, -0.03837248f, 
    0.02785962f, 0.04680846f, 0.00847298f, 0.00626486f, 0.05039692f, 0.02925861f, -0.04075241f, -0.03291772f, 
    0.03727151f, 0.03273582f, -0.04938829f, 0.01616785f, 0.01803947f, -0.03725512f, -0.03957541f, 0.01243840f, 
    0.03448207f, -0.03904771f, -0.05816954f, 0.00296944f, -0.06219397f, -0.04437802f, -0.01509890f, -0.01245945f, 
    -0.06478462f, 0.04145678f, -0.03545855f, 0.04336457f, -0.05987124f, -0.05393962f, -0.02949009f, -0.02462245f, 
    -0.04700393f, -0.05853197f, -0.02592146f, -0.05311828f, 0.00064866f, -0.06593068f, -0.02125325f, -0.06400529f, 
    -0.00922438f, 0.05068665f, 0.04814538f, -0.03731032f, -0.06123525f, -0.03366810f, 0.04825516f, 0.04173070f, 
    -0.06051644f, -0.00361214f, -0.05908758f, 0.01661061f, -0.04900738f, -0.00667267f, -0.00686850f, -0.03723005f, 
    -0.03748221f, -0.00408359f, -0.03206868f, 0.01695858f, -0.03817929f, 0.04991155f, -0.03713072f, 0.04924221f, 
    -0.05180638f, -0.00541313f, -0.06398486f, -0.00631460f, -0.02265573f, 0.01111201f, -0.02481314f, -0.01930874f, 
    0.01855238f, 0.01221937f, 0.00497862f, 0.03574130f, -0.06010579f, -0.06264530f, 0.02403808f, -0.01037218f, 
    -0.00332032f, -0.02668981f, 0.01917702f, -0.04454923f, -0.04443322f, 0.04156544f, -0.00163076f, 0.00304939f, 
    -0.00623733f, 0.00567844f, 0.02532128f, -0.00853290f, -0.00154910f, 0.04341451f, -0.00189961f, 0.00727507f, 
    -0.03305409f, 0.02415212f, -0.04564757f, 0.02415586f, -0.03925343f, -0.06378148f, 0.01129302f, 0.02092963f, 
    -0.05920058f, -0.00240493f, 0.01666262f, -0.03645455f, 0.03432577f, 0.03735469f, -0.05200018f, -0.02998095f, 
    -0.05405872f, -0.05571060f, -0.05371029f, 0.05080289f, -0.02987345f, -0.00973144f, 0.03002135f, -0.01051126f, 
    0.02284838f, -0.05051780f, 0.02606225f, 0.04669190f, -0.00919828f, -0.03717277f, -0.04166818f, -0.06158242f, 
    0.00488318f, -0.00974164f, 0.03007259f, 0.01086805f, -0.04462799f, 0.01548132f, -0.05409912f, -0.04265907f, 
    -0.06215179f, 0.01961943f, 0.00933876f, -0.02753504f, -0.04292899f, -0.01808206f, 0.01191841f, 0.04335988f, 
    0.04629086f, 0.04032511f, -0.01422122f, 0.01650987f, 0.03625533f, -0.02851330f, 0.02514901f, -0.02391414f, 
    -0.00769151f, 0.02541035f, 0.03674874f, -0.03253379f, 0.00122006f, -0.05844719f, -0.03085449f, 0.04511248f, 
    0.00697952f, -0.06111198f, -0.05159491f, -0.00922542f, 0.04178459f, -0.04343076f, 0.03615106f, 0.04766147f, 
    -0.04658294f, 0.02208532f, 0.00458905f, 0.01849357f, -0.04940566f, -0.05230961f, 0.02558285f, -0.01673657f, 
    -0.01981870f, -0.06473225f, -0.02357796f, -0.01291930f, -0.05718093f, -0.04154048f, -0.04524779f, 0.03414296f, 
    0.02751961f, -0.02027199f, -0.03305014f, 0.01040260f, 0.00316892f, -0.05528834f, -0.01171206f, -0.04673785f, 
    -0.00407900f, -0.05579160f, -0.01386974f, -0.04781456f, 0.03749723f, -0.03552713f, -0.04526779f, -0.02725705f, 
    -0.00134701f, -0.04711169f, 0.02251068f, 0.04256346f, -0.04282410f, 0.04405898f, -0.00289017f, 0.00189442f, 
    -0.05546919f, -0.01355583f, -0.00887232f, 0.03366097f, -0.03681041f, 0.02018258f, -0.03238970f, -0.01977322f, 
    -0.06410841f, 0.04259469f, -0.06636569f, 0.00203488f, -0.02661261f, -0.06673713f, 0.01510474f, -0.04018933f, 
    0.03764686f, 0.02275440f, 0.04254911f, 0.01705107f, 0.00893966f, -0.00755571f, -0.05674150f, -0.02064578f, 
    -0.00867808f, 0.03730753f, -0.04395781f, -0.04461858f, -0.03083440f, 0.04009128f, -0.04948881f, 0.00789222f, 
    -0.05702380f, -0.00758758f, -0.02751237f, 0.05044251f, -0.04036714f, 0.02576806f, 0.00970520f, 0.00552114f, 
    -0.00709844f, -0.05156399f, 0.01051027f, 0.02593772f, -0.04404641f, -0.00856889f, 0.03828905f, -0.00052242f, 
    0.02246326f, -0.04567405f, 0.01266382f, -0.01125384f, -0.05006953f, 0.02404851f, -0.02817309f, -0.01111124f, 
    -0.19237867f, -0.36477721f, 0.36475009f, 0.02982654f, -0.01637467f, 0.05073018f, -0.14946727f, -0.11517407f, 
    0.00900683f, -0.17982610f, 0.22621402f, -0.13670594f, -0.09979882f, -0.03833371f, -0.07189292f, -0.02229713f, 
    0.20800892f, -0.25989139f, -0.00678863f, 0.05999520f, -0.32783443f, 0.09071584f, -0.09200523f, -0.01920046f, 
    0.02937014f, 0.00160601f, 0.25172946f, 0.28748885f, 0.07133165f, 0.09808218f, -0.06346169f, 0.03903627f, 
    -0.08212463f, -0.09366761f, 0.10294449f, 0.06643572f, -0.01208678f, -0.05649150f, 0.14816506f, -0.00847633f, 
    -0.18035646f, 0.03014655f, -0.10689522f, -0.09107340f, 0.06087223f, 0.05321546f, -0.06122059f, 0.03023246f, 
    0.01965647f, -0.12479115f, 0.03349656f, 0.06864277f, -0.12911049f, 0.08010317f, 0.05940363f, -0.14735132f, 
    0.12881820f, -0.08330054f, 0.01882036f, -0.05029686f, -0.02892481f, 0.03893582f, 0.08018803f, 0.18245351f, 
    -0.07054942f, -0.38778883f, -0.10372746f, 0.04444028f, -0.07756519f, -0.04652916f, 0.02695246f, -0.06398031f, 
    -0.04821795f, 0.05857692f, -0.21565722f, 0.04757262f, 0.04498161f, 0.02783746f, -0.01065299f, 0.03623984f, 
    -0.08284729f, -0.06163259f, 0.08208570f, 0.15370880f, 0.18722442f, -0.04570552f, 0.00939451f, 0.09417900f, 
    0.01687459f, -0.05521153f, 0.01980614f, -0.06224361f, -0.16953434f, 0.07907545f, -0.04215050f, -0.00516048f, 
    -0.07425805f, -0.08622104f, 0.04929979f, 0.16889060f, -0.28842217f, 0.11753801f, -0.03069230f, 0.07780658f, 
    0.02114164f, 0.00300992f, 0.09113414f, 0.14143676f, -0.25475493f, -0.13347250f, 0.21904650f, -0.02437840f, 
    0.08149359f, 0.04899179f, -0.04479124f, 0.06064698f, 0.09829719f, -0.16808403f, 0.13232064f, -0.15750597f, 
    0.18632856f, 0.08797751f, 0.02010903f, 0.00706361f, 0.05206296f, -0.03797534f, 0.06838439f, -0.01794339f, 
    -0.09534756f, 0.02385083f, 0.13099596f, -0.15418816f, 0.07049678f, 0.02635237f, 0.02204525f, -0.20429276f, 
    -0.09913138f, 0.33592090f, 0.04531268f, 0.06824785f, 0.13627692f, -0.09923577f, 0.08747395f, -0.00924744f, 
    0.27556404f, -0.03534032f, 0.00312172f, 0.04791414f, 0.12112337f, 0.02052035f, 0.13404368f, 0.04184829f, 
    -0.10681114f, 0.32854119f, 0.30558112f, -0.05114277f, 0.05862917f, -0.14120735f, -0.04881268f, -0.02336647f, 
    0.08079696f, 0.01437884f, 0.15270947f, -0.10035940f, -0.05773447f, -0.00271621f, 0.06308404f, 0.01294717f, 
    -0.03998348f, 0.03185112f, -0.08521827f, -0.06037539f, -0.08338048f, 0.17434302f, 0.12051746f, 0.08521526f, 
    -0.02969430f, -0.01737802f, 0.15949662f, 0.01968979f, -0.30814523f, 0.02915167f, -0.09121511f, -0.02800477f, 
    0.00962033f, 0.00301958f, -0.05033110f, -0.06173195f, -0.03384612f, 0.10832498f, -0.08561321f, -0.00157446f, 
    0.06350864f, -0.13822299f, -0.02414207f, 0.12642859f, -0.03238729f, 0.09602392f, -0.09528796f, 0.08017506f, 
    -0.25626683f, 0.11690351f, 0.02423389f, -0.06768357f, -0.00442324f, 0.03413358f, -0.01521624f, 0.08949204f, 
    -0.04276865f, -0.41602352f, -0.02764359f, -0.12420325f, 0.07103982f, -0.02583179f, -0.06665018f, 0.08173773f, 
    0.01892816f, -0.26459038f, 0.03484001f, -0.20240729f, 0.03987411f, -0.07087291f, 0.07263477f, 0.14951347f, 
    0.06016788f, -0.11978960f, -0.06406835f, 0.18994109f, 0.07794122f, 0.00396876f, 0.03207238f, 0.03126819f, 
    -0.18131499f, -0.09934595f, 0.04136849f, -0.11667433f, 0.08434106f, 0.00181428f, 0.00601510f, 0.14293563f, 
    0.11661392f, 0.10528167f, 0.06654267f, -0.18478711f, -0.25957713f, -0.12393199f, 0.04589630f, -0.19577394f, 
    0.16742909f, -0.01458326f, -0.01485219f, -0.06980267f, -0.36086643f, -0.06718337f, 0.08000375f, -0.02637800f, 
    -0.00208964f, 0.09750743f, 0.10005578f, 0.01654446f, -0.14963295f, 0.08258111f, 0.29356802f, -0.22240824f, 
    0.08519946f, -0.04929129f, -0.05290058f, -0.11335237f, 0.05118040f, -0.01951525f, -0.00621652f, -0.03330534f, 
    0.23994870f, -0.02402780f, -0.06454604f, 0.12399038f, -0.02661564f, 0.07019364f, 0.04218609f, -0.07455838f, 
    0.16885921f, 0.11409614f, -0.03790965f, 0.09223463f, -0.06366312f, 0.05710466f, -0.05374143f, 0.01330582f, 
    -0.07282589f, -0.05379150f, 0.02795460f, 0.00081988f, -0.05310116f, -0.01988313f, -0.00484018f, 0.01580472f, 
    0.01572301f, -0.01381298f, -0.01582717f, 0.01490487f, 0.03568659f, 0.00650748f, 0.02159329f, -0.03801273f, 
    -0.01069687f, -0.01699423f, 0.01576027f, 0.04207491f, 0.02650488f, -0.04865531f, 0.01256835f, -0.05410121f, 
    -0.01526771f, -0.07013059f, 0.01152077f, -0.05812994f, 0.00936934f, -0.03372141f, -0.07643412f, -0.00508614f, 
    -0.02309874f, 0.05505351f, 0.03837647f, -0.06160485f, 0.00587212f, 0.02763828f, -0.03265719f, 0.00332651f, 
    -0.08810546f, -0.01706172f, -0.01974361f, -0.00506271f, 0.02313870f, -0.00096107f, -0.00610801f, 0.02894183f, 
    0.02222925f, -0.01840978f, 0.01406934f, -0.03193939f, -0.06858775f, 0.00135949f, -0.05182623f, 0.00132981f, 
    -0.01019676f, -0.01442602f, -0.04738225f, -0.09055393f, -0.02929948f, -0.09073044f, -0.03934949f, 0.00180084f, 
    0.03169885f, -0.06330290f, 0.02512899f, -0.05281473f, -0.05711024f, -0.07444269f, -0.08459325f, 0.00047774f, 
    -0.08462962f, -0.00991924f, 0.00765708f, -0.07333018f, -0.07255373f, -0.04677731f, 0.01289770f, -0.00243086f, 
    -0.06720052f, -0.09372382f, -0.09636234f, -0.07964750f, 0.00749509f, -0.02816846f, -0.01512499f, -0.00853957f, 
    -0.04771554f, -0.04521661f, 0.02235447f, 0.01105381f, -0.01063830f, 0.02423614f, -0.07502951f, -0.06453375f, 
    -0.05126555f, -0.01433657f, -0.02612098f, -0.05387545f, -0.09690818f, 0.02440123f, -0.05974540f, -0.08339585f, 
    -0.04455797f, -0.06856304f, -0.06576382f, 0.01991873f, -0.04130717f, -0.01934353f, -0.00822360f, -0.06935767f, 
    -0.09166288f, -0.02581975f, -0.01984267f, 0.00664905f, -0.02034647f, -0.06670056f, 0.03881063f, -0.01325347f, 
    -0.02842564f, 0.01992566f, -0.02780785f, -0.03738736f, -0.00111094f, 0.00298287f, -0.03152096f, -0.03959936f, 
    0.02142987f, -0.06325955f, 0.00540519f, 0.02849647f, 0.02230598f, -0.08061741f, -0.01849649f, -0.04770548f, 
    -0.07196667f, -0.01980139f, -0.04994026f, -0.06402063f, -0.00408520f, -0.00103615f, -0.04903256f, -0.03949239f, 
    0.00490107f, 0.02375139f, -0.00649480f, -0.03236413f, -0.01380554f, 0.00501296f, -0.00708368f, -0.05419183f, 
    -0.03742479f, 0.02065364f, 0.00910636f, 0.00916808f, 0.05846043f, -0.00269188f, -0.05705726f, -0.06935190f, 
    0.01626131f, 0.02366905f, 0.01795066f, 0.01044570f, 0.05491609f, -0.00975528f, -0.02984806f, -0.08124543f, 
    0.02486212f, 0.01706295f, 0.00801331f, -0.03852165f, -0.06028118f, -0.03814789f, 0.00114654f, -0.03714187f, 
    -0.07751478f, -0.04710390f, -0.05667283f, 0.00137653f, 0.00734365f, -0.03644730f, 0.01256556f, -0.07974330f, 
    -0.04112063f, -0.03832226f, -0.08194261f, -0.07693817f, 0.02162949f, 0.00289931f, -0.08550528f, 0.01015927f, 
    -0.07105256f, -0.04888986f, -0.07950439f, -0.03773379f, -0.05022806f, -0.07342967f, 0.01271190f, 0.05233602f, 
    -0.02453615f, -0.04788982f, -0.00797185f, -0.07042992f, -0.03637297f, -0.04378353f, 0.00699722f, -0.03770637f, 
    -0.04472005f, -0.05359536f, -0.08646634f, 0.01045491f, -0.08259509f, -0.06327378f, -0.03426563f, 0.00365816f, 
    -0.09054063f, -0.05138813f, -0.07302662f, -0.04948302f, -0.03199949f, -0.02449995f, 0.02155438f, -0.06041210f, 
    0.01852981f, -0.04610633f, -0.01452948f, -0.01792924f, -0.09726504f, -0.10045487f, 0.01728517f, -0.00212800f, 
    -0.06229850f, -0.01337363f, -0.00751812f, 0.02609779f, -0.02239877f, -0.06796021f, -0.02609858f, 0.00278528f, 
    -0.01012461f, -0.02061777f, -0.03637362f, -0.05177175f, -0.06853243f, 0.02640343f, -0.06861977f, -0.05075626f, 
    -0.08203303f, 0.03054308f, 0.03809267f, -0.03844031f, -0.07882196f, 0.03719006f, -0.03012947f, -0.07594612f, 
    -0.02765766f, -0.08682466f, -0.02480390f, -0.02203195f, -0.06567403f, -0.05000745f, 0.02780831f, -0.05586788f, 
    0.01482613f, 0.03346233f, 0.02409433f, -0.05697679f, -0.00603924f, -0.00171407f, -0.08182901f, 0.05579337f, 
    -0.05675390f, 0.01955333f, -0.07820121f, 0.01682259f, -0.06568251f, 0.03394783f, 0.02164554f, -0.02758293f, 
    -0.05674689f, 0.01054240f, 0.00161246f, -0.03266269f, -0.04012496f, 0.04566339f, 0.00569072f, -0.01376838f, 
    0.07817416f, -0.07113650f, -0.06529777f, 0.05412052f, 0.04302495f, 0.07312863f, -0.07012174f, -0.06803272f, 
    0.02728485f, 0.10853612f, 0.22982021f, 0.08621200f, -0.21329311f, -0.03734109f, -0.01874298f, 0.09912319f, 
    0.08768795f, 0.12880783f, 0.21170150f, 0.15448111f, 0.02584468f, -0.18232022f, -0.02458739f, -0.13585831f, 
    0.07881450f, 0.02375131f, 0.08125359f, -0.03989397f, -0.21686736f, -0.10121471f, 0.08194533f, 0.06566246f, 
    -0.08404294f, -0.11769532f, -0.03428953f, 0.14320683f, 0.04488172f, 0.07832937f, 0.02209703f, 0.15882108f, 
    0.07433262f, -0.06308688f, -0.12958588f, -0.04604045f, -0.16726869f, -0.00002480f, 0.00236187f, -0.09899027f, 
    -0.07839157f, 0.04409089f, 0.00169358f, -0.07030236f, 0.07737006f, -0.02539813f, -0.11324278f, -0.13751790f, 
    0.00172019f, 0.11967571f, 0.08722346f, 0.11571512f, 0.11566688f, -0.01440647f, 0.11079752f, -0.10775269f, 
    0.17103328f, -0.02772931f, 0.03532302f, -0.00955408f, -0.09393402f, -0.09685275f, 0.06724969f, 0.06221240f, 
    -0.14850059f, -0.04267571f, -0.00962027f, 0.19668962f, 0.07860513f, 0.11793044f, 0.11826331f, -0.01183563f, 
    0.03248400f, -0.11880738f, -0.01729364f, 0.11759168f, 0.02388747f, 0.05902789f, 0.08937878f, 0.23641944f, 
    -0.02170604f, 0.14879005f, 0.23927432f, 0.06145208f, -0.05912762f, -0.10087613f, 0.01366339f, 0.03125743f, 
    0.08902671f, -0.01827194f, 0.02849430f, -0.05615874f, -0.15622814f, -0.08601118f, 0.01847589f, -0.28830746f, 
    -0.00010319f, 0.08913077f, -0.06523653f, 0.14248255f, 0.06699792f, 0.05145694f, -0.09120885f, 0.08992536f, 
    0.08269883f, 0.13272704f, 0.02128253f, -0.10611828f, -0.00983437f, 0.16170923f, 0.07900832f, 0.17032580f, 
    -0.14425278f, -0.11070289f, -0.12377143f, 0.13546143f, -0.03668913f, 0.07454751f, 0.00828049f, -0.05344414f, 
    0.03564180f, -0.04528343f, -0.11331959f, -0.01701812f, 0.21925190f, 0.06471860f, 0.02340640f, 0.04242827f, 
    -0.01031499f, 0.01465991f, -0.02629291f, 0.05372298f, 0.07446723f, -0.01680917f, -0.11815654f, 0.04459498f, 
    0.24759120f, 0.03156612f, -0.04896313f, -0.00398842f, 0.04623309f, 0.08202038f, 0.09142318f, 0.00820694f, 
    -0.02750291f, -0.01707272f, -0.21779057f, -0.17003267f, -0.05330650f, 0.07687750f, -0.09034429f, 0.08290192f, 
    0.06402329f, -0.00748981f, 0.13261250f, -0.01145117f, -0.20761004f, -0.18400465f, -0.15568526f, -0.13671573f, 
    0.15011939f, -0.11973720f, -0.16848303f, -0.19521889f, -0.10483850f, 0.16984369f, 0.07681514f, -0.06629311f, 
    0.00669017f, 0.03371758f, -0.21745925f, -0.02129453f, 0.16529869f, 0.03189965f, -0.04319761f, 0.05244314f, 
    0.04102590f, 0.06282983f, 0.01942795f, -0.02483765f, 0.04353534f, -0.13455133f, -0.07583823f, -0.02550015f, 
    0.04786267f, 0.15349402f, 0.03717379f, 0.07859491f, 0.07183757f, 0.00218250f, 0.00999962f, 0.07188937f, 
    -0.14508948f, -0.02387395f, 0.06723820f, -0.03026433f, 0.13615344f, 0.07660133f, 0.09583439f, 0.01088197f, 
    0.06162542f, 0.00033448f, -0.12813975f, -0.04894350f, 0.03342309f, -0.04518867f, -0.00775959f, 0.09748516f, 
    -0.19878347f, 0.09888702f, -0.03928360f, 0.06420031f, -0.06078883f, -0.02043602f, 0.02865115f, -0.11780486f, 
    0.09529925f, -0.08974471f, -0.08904965f, -0.14250898f, 0.00388987f, 0.01961558f, 0.00331436f, 0.00022102f, 
    -0.20245035f, -0.19783489f, 0.10170227f, -0.10980918f, -0.09800729f, 0.06736705f, -0.02034471f, 0.17925292f, 
    0.02985822f, -0.05305426f, -0.03662583f, -0.00210026f, -0.12915647f, -0.12715949f, 0.07835054f, 0.11011378f, 
    0.09012462f, -0.05937434f, -0.09833514f, -0.05866113f, -0.14826418f, 0.04899891f, -0.50669068f, 0.04716768f, 
    0.14777826f, 0.08880190f, -0.19179742f, 0.03831773f, -0.17148821f, -0.20826888f, -0.07829268f, -0.01696513f, 
    0.08476397f, 0.00234195f, 0.08109258f, -0.04488046f, 0.01167754f, -0.10751007f, 0.04424462f, 0.17747121f, 
    -0.07147087f, 0.13058485f, 0.06278906f, 0.07081027f, -0.24314350f, -0.20934884f, -0.12499651f, -0.11237883f, 
    -0.02373445f, -0.00939126f, 0.07583372f, 0.11775088f, 0.12945487f, -0.18222316f, -0.10661308f, -0.00770304f, 
    0.09424087f, -0.07828695f, -0.03829683f, -0.02177172f, -0.01924207f, -0.03632341f, 0.07321708f, -0.10172183f, 
    -0.18233880f, 0.37497529f, -0.04459724f, 0.05270727f, -0.12412924f, -0.09038971f, 0.08157495f, 0.04474282f, 
    -0.01163856f, 0.01679288f, 0.11370444f, -0.05591513f, -0.09808288f, -0.22102574f, -0.09333987f, -0.03238754f, 
    0.07193182f, 0.07087794f, -0.02286130f, -0.01524435f, -0.03467911f, -0.05479344f, -0.05948422f, 0.07958598f, 
    -0.07444237f, -0.00636176f, -0.05284350f, 0.01708952f, -0.11674838f, -0.02655351f, -0.08353051f, -0.03972273f, 
    0.00974809f, -0.12748216f, -0.02853813f, -0.07239541f, -0.02865508f, -0.18302622f, 0.10491593f, 0.03237846f, 
    0.15387689f, -0.13637829f, 0.14058949f, -0.11240780f, -0.02132529f, 0.25890711f, 0.03011274f, 0.07333531f, 
    -0.21460570f, 0.20136860f, 0.11673219f, -0.02129388f, -0.02757493f, 0.05364767f, 0.05844481f, 0.08385598f, 
    0.08598128f, -0.12290033f, 0.12425508f, -0.00652515f, 0.19397907f, -0.01501604f, -0.01585352f, -0.14436929f, 
    0.11314470f, 0.07724319f, -0.02383579f, 0.06974581f, 0.10681996f, 0.18426293f, 0.07436908f, -0.11669061f, 
    -0.19285505f, -0.05582272f, 0.05610170f, 0.08379596f, 0.03937047f, 0.24121588f, 0.13488063f, 0.01386700f, 
    -0.16059600f, -0.06763647f, 0.09364116f, 0.25316358f, -0.05617566f, -0.03312220f, -0.00142044f, 0.05599013f, 
    -0.14916758f, 0.05049704f, 0.21496478f, -0.22486453f, -0.06469768f, -0.04050339f, 0.19149955f, -0.17204911f, 
    0.06182940f, -0.00669919f, -0.03714332f, -0.08925056f, 0.13591258f, 0.15442529f, 0.03144017f, 0.01986109f, 
    -0.06664737f, 0.15156065f, -0.00350201f, 0.08107709f, -0.04075834f, 0.26332694f, 0.16820548f, -0.05217828f, 
    -0.00966431f, -0.00217257f, 0.16709390f, -0.01456110f, -0.03478728f, 0.01605325f, 0.08114343f, 0.08894642f, 
    0.16964562f, -0.09837750f, 0.03512254f, -0.10673470f, 0.22446482f, -0.01901836f, 0.02793366f, 0.12356696f, 
    0.18417391f, -0.09728929f, 0.02055833f, -0.02498546f, 0.16102941f, 0.06889632f, -0.04689881f, -0.02358010f, 
    0.16679227f, 0.12078638f, 0.07349522f, -0.02219565f, -0.01501236f, -0.01837393f, 0.03493378f, 0.12173008f, 
    0.09517725f, -0.00047146f, -0.10029089f, 0.06268911f, -0.01431546f, -0.02547438f, -0.09056766f, -0.00199257f, 
    0.10135648f, 0.15963429f, -0.02127711f, -0.24296890f, -0.01295613f, -0.00195842f, 0.07505509f, -0.22322543f, 
    0.00254831f, 0.05916702f, 0.05787770f, -0.04078069f, -0.02912129f, 0.01511036f, 0.01868804f, -0.02273315f, 
    0.13091633f, -0.00776410f, 0.11601591f, 0.02523288f, -0.17215167f, -0.10731371f, 0.13073477f, 0.14645897f, 
    0.09263135f, -0.00942308f, 0.02080142f, 0.09874108f, -0.01808295f, 0.01883959f, 0.05549199f, -0.08532535f, 
    0.20920780f, 0.16843715f, 0.15188153f, -0.07459787f, 0.13568407f, -0.14369883f, -0.19756651f, -0.15580328f, 
    0.03110376f, 0.19363753f, 0.11033171f, -0.12545176f, -0.12208617f, 0.05687479f, 0.02350785f, -0.11017641f, 
    0.07825020f, 0.02914765f, 0.03339062f, 0.04036568f, 0.05150360f, -0.10870768f, 0.11955374f, -0.06247251f, 
    -0.11887984f, 0.10466436f, 0.06193688f, 0.12224614f, 0.11370207f, 0.04037400f, 0.06591159f, 0.09292193f, 
    -0.01834117f, 0.02183955f, -0.26984024f, 0.05988124f, 0.08588681f, 0.00183177f, 0.00193799f, 0.01905772f, 
    -0.12161231f, -0.00081851f, 0.05841072f, 0.02532007f, 0.00006633f, 0.04907000f, -0.15163495f, -0.18004236f, 
    0.11262118f, -0.03926235f, -0.04685470f, 0.02497103f, -0.20459424f, -0.05658886f, 0.02603924f, 0.21734980f, 
    0.02217082f, 0.19412726f, -0.29464936f, -0.06192155f, -0.18862319f, 0.18717800f, 0.01661882f, 0.06893674f, 
    -0.07862583f, 0.04491391f, -0.11529431f, 0.02446641f, 0.10909343f, 0.10619120f, 0.13731974f, -0.05341635f, 
    0.09479890f, -0.16819522f, -0.16698095f, 0.11474985f, -0.01747612f, 0.02508178f, -0.00558694f, -0.00025322f, 
    0.24754107f, 0.04139490f, -0.12894297f, -0.02403381f, 0.00589612f, -0.11689155f, -0.05926567f, -0.03013633f, 
    -0.03139429f, 0.08018795f, -0.10939372f, 0.00587258f, -0.13992427f, 0.17670444f, 0.07822630f, -0.11055542f, 
    0.01470111f, -0.31017962f, -0.16431837f, -0.02370563f, -0.01671860f, -0.05212623f, -0.00403092f, 0.09196655f, 
    -0.01729215f, 0.04722868f, 0.07762101f, 0.15285257f, 0.00881466f, -0.00843674f, -0.13628444f, 0.13679683f, 
    -0.01128804f, -0.01621161f, 0.05298854f, 0.21682705f, 0.03776750f, 0.12822795f, 0.00256895f, -0.10903323f, 
    -0.08130343f, -0.03699273f, -0.02681668f, -0.11553653f, -0.30266461f, 0.21668699f, 0.03326083f, -0.07652112f, 
    0.05195206f, -0.06944149f, 0.02251968f, -0.00272144f, -0.07921062f, -0.45882496f, -0.12490050f, -0.00671689f, 
    0.03454542f, -0.01938236f, 0.03167036f, 0.06426021f, 0.03429034f, -0.12938757f, -0.08026942f, 0.14701907f, 
    0.00396637f, -0.10791238f, -0.00225771f, -0.14690651f, -0.12843260f, 0.08830830f, -0.12583156f, -0.03224691f, 
    -0.19742529f, 0.00343496f, 0.01289717f, -0.01902073f, -0.13293050f, -0.01405127f, 0.12682423f, 0.11742311f, 
    0.16953605f, -0.03368601f, -0.09275858f, 0.08016828f, 0.08566483f, -0.02273301f, -0.04749553f, 0.08416428f, 
    0.02316722f, 0.00082540f, -0.01356933f, -0.01515847f, 0.04766558f, -0.07103680f, 0.04355289f, -0.12212431f, 
    0.01277767f, -0.04020818f, 0.06480449f, -0.12046564f, 0.04217175f, 0.00595044f, -0.03522212f, 0.06325994f, 
    -0.11450140f, 0.01716518f, 0.12450209f, 0.22682354f, 0.08357476f, 0.04445944f, 0.01756367f, 0.09406943f, 
    -0.13520293f, 0.01616039f, -0.01051608f, 0.38358334f, -0.05713771f, -0.07452824f, 0.05344888f, -0.06611354f, 
    -0.00511729f, -0.06514212f, -0.02896683f, 0.13628326f, 0.02581282f, -0.11587308f, -0.05922540f, -0.07003508f, 
    -0.05230761f, 0.06219924f, 0.07017681f, -0.05329205f, -0.07079396f, 0.22798234f, 0.21422075f, 0.28070265f, 
    -0.11187387f, -0.07657859f, -0.05320587f, -0.01671635f, 0.04409062f, 0.04363152f, 0.18257788f, 0.05266086f, 
    0.13058399f, 0.04936117f, 0.07738943f, 0.06895595f, 0.00227472f, 0.07173879f, 0.01354461f, 0.03680864f, 
    -0.00885453f, -0.15062799f, 0.02822711f, -0.04120407f, -0.02929694f, -0.03901872f, 0.03072267f, 0.04664948f, 
    0.09015526f, 0.17765643f, 0.21215974f, -0.01113932f, 0.02078778f, 0.06226692f, 0.14107317f, 0.01541326f, 
    -0.04367276f, 0.11593546f, -0.24204522f, 0.09289169f, 0.02244278f, -0.07258476f, -0.14412759f, -0.02163978f, 
    -0.00960864f, -0.02559401f, 0.07392250f, -0.10444547f, 0.02476430f, -0.10287367f, -0.00076308f, -0.06423945f, 
    -0.07035096f, 0.05776910f, -0.05319414f, 0.00093209f, 0.13757025f, -0.01123756f, -0.00134871f, -0.01170739f, 
    -0.17846169f, -0.06369404f, 0.10714171f, -0.14317761f, 0.01300643f, -0.07109109f, -0.16412890f, -0.05071892f, 
    -0.03767989f, 0.02385822f, -0.04643013f, 0.01868527f, -0.03029527f, -0.02673463f, 0.08353443f, -0.27649361f, 
    -0.00072932f, 0.02759424f, 0.11766362f, -0.11608700f, -0.04654273f, -0.07523146f, -0.10605640f, 0.14294596f, 
    -0.10476612f, -0.04393958f, 0.09821237f, 0.06580821f, 0.01624239f, 0.01263363f, 0.10286788f, 0.09419456f, 
    0.13625173f, -0.03761668f, 0.04366124f, 0.04065755f, 0.06668630f, 0.14449079f, -0.00544101f, 0.02469050f, 
    0.05016901f, -0.05595718f, -0.06587040f, -0.04967133f, -0.02292091f, 0.03202645f, -0.06676668f, 0.04701830f, 
    -0.05329815f, 0.04447735f, 0.08681753f, -0.20691450f, -0.03734540f, 0.05507289f, -0.04628573f, -0.02749480f, 
    -0.08438125f, -0.07390285f, -0.01947801f, -0.32848522f, -0.03853820f, 0.05946272f, -0.05120162f, -0.08412392f, 
    0.00467182f, -0.01811871f, 0.00968274f, -0.00787923f, -0.22430232f, -0.27724043f, 0.13374563f, 0.03109271f, 
    0.08143827f, 0.14487332f, 0.05265141f, 0.05287222f, 0.00628866f, -0.10988370f, -0.06575198f, -0.12977515f, 
    0.01868404f, -0.01881862f, 0.01587144f, 0.02101834f, -0.04569994f, 0.06635156f, 0.04839816f, 0.20854039f, 
    -0.00221654f, 0.00541633f, 0.04166076f, 0.08010726f, 0.00200476f, 0.02359681f, 0.27398235f, -0.10929803f, 
    -0.06424353f, 0.14574359f, -0.01749004f, 0.03343341f, 0.09392901f, -0.04386244f, -0.01910189f, -0.20410068f, 
    -0.05362513f, 0.19108048f, -0.02499389f, 0.03470321f, 0.06166190f, 0.03731961f, 0.00592521f, -0.09801459f, 
    -0.12510641f, 0.02929025f, -0.15907516f, 0.10626508f, 0.06745657f, 0.05280497f, 0.04231898f, -0.04691024f, 
    0.03264764f, -0.21663371f, -0.05824643f, 0.13458911f, 0.02927932f, -0.08508492f, 0.01959796f, -0.02265199f, 
    -0.13990337f, 0.00258342f, -0.01285602f, 0.08533173f, 0.17766953f, 0.00795650f, 0.13212694f, -0.12922713f, 
    -0.01348869f, -0.02781930f, 0.02662241f, -0.13334796f, -0.06669649f, 0.10486615f, 0.06946786f, -0.00877006f, 
    -0.18027580f, 0.00179586f, 0.03041521f, -0.02566753f, 0.05536671f, -0.06118749f, -0.06628335f, 0.03409752f, 
    0.09259602f, 0.07223766f, 0.01374541f, 0.01381922f, -0.10442971f, -0.13671280f, -0.08569716f, -0.03958392f, 
    -0.09710561f, 0.03186866f, 0.00926177f, 0.03985777f, -0.01343784f, 0.03876099f, -0.21864700f, -0.11791665f, 
    0.04436034f, 0.07554080f, 0.11489830f, -0.09160852f, 0.05024580f, -0.12346491f, 0.08692352f, 0.21484558f, 
    0.08896651f, -0.08216760f, -0.14416473f, 0.09767950f, -0.13018557f, -0.09243038f, 0.07167103f, 0.05001228f, 
    0.09843883f, 0.12580599f, 0.05768622f, 0.03971035f, 0.05075504f, -0.01096693f, -0.07546577f, 0.15543997f, 
    0.01927873f, -0.10530124f, 0.06658971f, 0.02488947f, 0.00496305f, 0.05308857f, -0.08126326f, 0.04318188f, 
    0.07508294f, -0.11235832f, -0.01504674f, 0.11896665f, 0.04149456f, 0.00535355f, -0.05507697f, -0.00321082f, 
    -0.08520813f, 0.01510851f, 0.04283303f, 0.21707836f, 0.00935065f, -0.04508232f, -0.02842889f, -0.08908115f, 
    0.01773798f, -0.06568855f, -0.15149020f, 0.08686158f, -0.30096269f, 0.04255848f, -0.02042413f, 0.03771975f, 
    0.09892365f, 0.04143484f, -0.02913082f, 0.06095969f, -0.07640372f, -0.04195895f, 0.12383645f, 0.22652793f, 
    -0.13023014f, -0.03787467f, -0.05730219f, -0.10219538f, -0.07443248f, 0.00663875f, 0.07619219f, -0.21178646f, 
    0.06726127f, -0.05011385f, -0.05477919f, 0.18021972f, -0.01950096f, -0.08434188f, 0.15304752f, -0.34283519f, 
    0.12103398f, 0.01576226f, -0.04394842f, 0.18560725f, 0.04758089f, 0.02398699f, -0.02276672f, -0.05535993f, 
    -0.04835949f, 0.09000697f, 0.15234710f, -0.04250536f, 0.09375764f, 0.08535410f, -0.00485432f, 0.10178930f, 
    0.01232630f, -0.18718658f, 0.16337655f, -0.03230397f, 0.05520590f, 0.10922778f, -0.14484145f, 0.02537272f, 
    -0.10336514f, 0.04479071f, 0.12022030f, -0.20324565f, -0.14251442f, -0.10799373f, -0.08316321f, -0.04410118f, 
    0.00274609f, 0.02954775f, -0.15199430f, -0.20521027f, 0.07663345f, -0.00865928f, 0.16514631f, 0.05904899f, 
    0.02911572f, 0.12082101f, -0.00106095f, -0.02073823f, 0.03561351f, -0.22507243f, -0.07486138f, -0.11515752f, 
    -0.09146089f, -0.00647948f, -0.00756751f, -0.08950091f, 0.10604557f, 0.08333679f, 0.03539953f, -0.08384722f, 
    0.13288471f, -0.04134473f, 0.01497128f, -0.08122241f, -0.05827623f, 0.00104355f, -0.12383434f, -0.11376498f, 
    0.02479167f, 0.07818948f, 0.06651037f, -0.18587975f, 0.07594049f, 0.00030131f, -0.02153459f, -0.06448807f, 
    0.00114819f, 0.07176711f, -0.07512330f, 0.02414609f, -0.02266296f, 0.09665085f, 0.04075873f, -0.00084643f, 
    0.02849965f, 0.03455150f, -0.19543697f, 0.10426018f, 0.05047655f, 0.03821661f, 0.01527668f, -0.12847234f, 
    0.03256243f, -0.35550472f, -0.12605721f, -0.10985304f, 0.11384344f, -0.00591841f, 0.04604324f, 0.03150808f, 
    0.01200153f, -0.06414236f, 0.11358169f, 0.06939241f, -0.07922073f, 0.01729401f, 0.02414075f, 0.02327611f, 
    0.01566251f, 0.01226015f, -0.02270648f, -0.28939706f, -0.04477341f, -0.17946787f, 0.22444731f, 0.13784862f, 
    0.00978561f, -0.15975186f, -0.09744735f, -0.03283848f, 0.02072345f, -0.17699005f, 0.07814059f, 0.07389147f, 
    0.06325383f, -0.01056829f, -0.03713182f, -0.03934829f, 0.14089763f, -0.30677935f, -0.04784617f, 0.03027506f, 
    0.00359227f, 0.02801784f, 0.08512694f, -0.06651703f, -0.01012969f, 0.02991132f, 0.00946969f, -0.00478507f, 
    -0.02175952f, 0.18115272f, 0.06930547f, -0.04700223f, 0.00616819f, -0.01680330f, -0.06120113f, 0.06969383f, 
    -0.20005763f, 0.08021147f, -0.00072643f, 0.17252192f, 0.14323393f, -0.02984876f, -0.02232061f, 0.00748062f, 
    0.24108517f, 0.31183258f, 0.07092413f, 0.07403669f, 0.10415071f, 0.09625746f, -0.05987127f, -0.09363681f, 
    -0.06185244f, 0.05776633f, 0.04906206f, -0.01351418f, -0.05109955f, -0.01094690f, -0.00992829f, 0.21645190f, 
    0.07839941f, 0.07549474f, 0.06639764f, 0.03970005f, 0.21014637f, -0.01806678f, 0.11433984f, -0.00163889f, 
    0.04866501f, 0.10198613f, -0.04204404f, -0.28700513f, -0.04649020f, -0.01417119f, 0.05612640f, -0.05665188f, 
    -0.01496456f, 0.03018952f, 0.08846738f, -0.00398790f, 0.15759505f, 0.32637036f, 0.13286911f, -0.04959442f, 
    0.04245999f, 0.07920858f, 0.05459477f, 0.05127287f, 0.04700214f, -0.18356094f, -0.01161541f, 0.01884910f, 
    -0.04451579f, 0.00214274f, -0.01538503f, -0.01593930f, 0.16601694f, 0.16733702f, 0.10393789f, 0.16810234f, 
    0.13865961f, 0.04751217f, 0.04418068f, 0.00835771f, 0.09280573f, -0.09372224f, 0.01886648f, -0.20730361f, 
    0.05109159f, -0.12123389f, -0.13720539f, 0.01705076f, -0.25110590f, -0.03760435f, 0.11398751f, 0.06151926f, 
    -0.17354496f, -0.16084321f, 0.13032152f, -0.01602462f, 0.02740193f, -0.05091317f, 0.01586594f, 0.02749380f, 
    -0.02896032f, -0.27195954f, -0.11022586f, 0.01982508f, 0.05330759f, 0.04110965f, 0.08817699f, 0.00727955f, 
    0.02411008f, -0.05387896f, -0.10635842f, 0.05615789f, -0.00127987f, -0.11338264f, -0.00657626f, 0.10753804f, 
    -0.05013116f, 0.02718353f, -0.01356584f, -0.00312838f, -0.08202063f, -0.01441576f, -0.01906995f, 0.10183915f, 
    -0.14299703f, 0.04163853f, 0.04586873f, 0.03592060f, 0.02330423f, 0.22887342f, -0.04956799f, 0.06310138f, 
    0.09660891f, -0.04622401f, 0.02428192f, 0.01983018f, 0.06735523f, -0.01420886f, 0.02158874f, 0.01378680f, 
    -0.13617015f, -0.08881997f, -0.06526516f, -0.13351373f, -0.12424576f, -0.03792927f, -0.05217801f, -0.08473697f, 
    -0.20836830f, 0.07809196f, 0.01656053f, -0.11997543f, 0.07662519f, 0.07234117f, 0.02780754f, 0.00296273f, 
    0.25710621f, 0.04652930f, 0.02110445f, 0.13327444f, 0.03231215f, 0.16541737f, -0.06878231f, 0.00337350f, 
    0.12252793f, -0.00086902f, 0.01881250f, 0.04606348f, -0.00045115f, -0.01276863f, -0.00476264f, -0.01154540f, 
    -0.06923148f, -0.34746665f, -0.05497828f, 0.01258397f, 0.04964897f, -0.03860909f, 0.01601513f, 0.11532668f, 
    0.05026957f, 0.08997604f, -0.26760828f, 0.06602590f, -0.16419233f, 0.00796104f, -0.07534533f, 0.03096235f, 
    0.13166806f, 0.09497785f, -0.04635056f, -0.41916814f, 0.07632641f, 0.01330710f, -0.05820839f, 0.05706445f, 
    0.12551269f, 0.03929502f, 0.03760020f, -0.11995786f, 0.14685264f, 0.08264729f, -0.01246310f, 0.04056412f, 
    0.05975644f, -0.15063621f, 0.07884605f, 0.07089350f, 0.07654520f, 0.04070450f, -0.16050270f, 0.15675779f, 
    -0.00210076f, 0.01336274f, -0.09057788f, -0.07854201f, 0.04724054f, 0.02813428f, 0.11461442f, -0.05778497f, 
    0.01593750f, 0.08253872f, 0.00057968f, -0.07069046f, 0.00379498f, -0.04603618f, -0.10368917f, 0.01636689f, 
    0.22343570f, -0.04784445f, -0.15695417f, 0.04883964f, -0.02861312f, 0.12755474f, -0.02382536f, 0.13862777f, 
    -0.06394518f, 0.08309775f, 0.01576376f, 0.15860063f, -0.00165649f, 0.00294287f, -0.09184300f, 0.01513937f, 
    -0.18783814f, -0.18221855f, -0.00831945f, -0.13619108f, 0.05917524f, 0.05669950f, 0.05301562f, 0.00965561f, 
    0.14209628f, -0.03526870f, 0.22701818f, 0.23703474f, 0.06113737f, -0.06063847f, -0.04808308f, -0.05140312f, 
    0.02607573f, 0.06967180f, 0.10175955f, -0.28690344f, 0.11344431f, 0.10208797f, -0.03816569f, -0.03187917f, 
    0.10494797f, -0.14812031f, -0.04171534f, -0.16671661f, 0.00006276f, -0.08690307f, -0.07532606f, 0.14221026f, 
    0.07443792f, -0.02516323f, -0.05500341f, -0.03162782f, 0.01980272f, -0.08990899f, -0.00350521f, -0.20958044f, 
    -0.15690878f, -0.00582599f, -0.18347707f, -0.11506167f, 0.01900794f, -0.03480768f, -0.05080136f, 0.12183056f, 
    -0.22460558f, -0.01367149f, 0.02638244f, -0.10388783f, 0.03775458f, -0.01195613f, 0.03675953f, 0.06624133f, 
    0.06190641f, -0.07027671f, -0.07651737f, 0.00482703f, -0.02121747f, 0.03545753f, -0.07253339f, 0.07306834f, 
    0.24528113f, 0.19149776f, 0.26044661f, -0.04988842f, -0.10541328f, 0.03869592f, 0.02179726f, 0.07423697f, 
    -0.03891629f, -0.33552748f, -0.12180896f, -0.05342679f, 0.04400574f, -0.00960550f, 0.05649215f, -0.07676663f, 
    -0.02552591f, -0.17131509f, -0.27333814f, 0.01112870f, -0.16175015f, 0.16281092f, 0.09888658f, 0.16967203f, 
    -0.02548716f, -0.11473338f, -0.01066484f, -0.11051305f, 0.12707128f, 0.11301065f, -0.10389453f, -0.08510859f, 
    0.00240533f, -0.07531286f, 0.02989586f, -0.15859888f, 0.12289053f, 0.12387235f, 0.07439175f, 0.00098497f, 
    -0.05608837f, -0.12534893f, 0.06823324f, -0.00207403f, -0.02507036f, -0.12525545f, -0.25323805f, 0.07112297f, 
    -0.02360999f, 0.18489875f, -0.12587859f, 0.07989585f, 0.03364714f, -0.03332387f, 0.18403743f, 0.09030926f, 
    0.15333253f, -0.02631810f, -0.03353901f, 0.02065997f, 0.02149528f, -0.01061075f, 0.03637719f, 0.10537560f, 
    -0.14776886f, 0.03286791f, -0.14631931f, -0.02087993f, -0.00068600f, 0.07177685f, 0.05282889f, 0.01209368f, 
    0.07200354f, -0.00526321f, -0.03759263f, 0.03070081f, -0.03994524f, -0.03241031f, -0.04556764f, -0.01264106f, 
    -0.02505687f, -0.00050930f, -0.11374574f, 0.12728354f, -0.09461084f, 0.03460328f, 0.03920672f, -0.09079192f, 
    0.09570976f, 0.04961285f, -0.22237824f, 0.03137984f, -0.07452572f, 0.04013081f, 0.03646794f, 0.06821734f, 
    0.07497694f, -0.10539056f, 0.04461801f, -0.22143465f, -0.11376190f, 0.17172156f, -0.09486365f, 0.13841984f, 
    -0.06913989f, 0.04532712f, -0.01690623f, -0.03574745f, 0.03791888f, -0.04140147f, 0.06011493f, 0.00825628f, 
    -0.07752214f, 0.10268378f, -0.01474481f, -0.03098451f, 0.07475042f, -0.04788588f, -0.06653517f, 0.04975670f, 
    0.05716243f, -0.02611873f, 0.10385392f, 0.00895032f, -0.00509513f, 0.06165526f, -0.08953532f, -0.01090552f, 
    -0.04830186f, 0.07144625f, 0.11310206f, -0.04253749f, -0.08286656f, 0.08845639f, -0.04980377f, 0.19406030f, 
    0.00727687f, 0.16069867f, -0.04411284f, -0.01325701f, 0.09537841f, 0.07882645f, 0.06432439f, 0.06913052f, 
    -0.20892286f, -0.05092892f, -0.11005902f, 0.02819989f, 0.05154409f, 0.01886985f, 0.07473312f, -0.03986748f, 
    0.03639744f, -0.08878284f, 0.06764949f, 0.13309397f, -0.12964129f, -0.02657825f, -0.01893116f, 0.10333750f, 
    -0.05410280f, 0.06238433f, 0.07806414f, -0.06732678f, 0.02857146f, -0.19886571f, 0.04182849f, 0.05055995f, 
    0.13321525f, -0.05517963f, 0.22581232f, 0.10631023f, 0.01169004f, 0.10437906f, -0.01858125f, -0.10636005f, 
    -0.07437537f, -0.02082331f, -0.05933483f, -0.01313186f, -0.06746773f, 0.03318480f, -0.21041778f, 0.09530659f, 
    -0.02157548f, -0.12809891f, 0.05413559f, 0.08404882f, -0.01891424f, 0.08087489f, -0.08296742f, -0.00999430f, 
    0.05146078f, 0.04381306f, -0.09616353f, 0.08610075f, 0.03274421f, -0.04706019f, 0.14480895f, 0.14046338f, 
    -0.11535534f, 0.00219612f, 0.07874390f, -0.05744189f, 0.06447206f, 0.12954348f, 0.05610377f, -0.12238757f, 
    -0.08900566f, -0.10519043f, 0.01093601f, 0.01166578f, 0.11280083f, 0.10361229f, 0.04139738f, -0.05253966f, 
    -0.01291680f, 0.07436441f, 0.08403406f, -0.06059112f, -0.07931013f, -0.06607886f, -0.00697870f, -0.00888087f, 
    0.00616864f, 0.13435979f, 0.07394513f, 0.13243130f, -0.25162980f, -0.12488469f, 0.04260942f, 0.05501376f, 
    0.02268845f, 0.05652830f, 0.15913346f, 0.18409066f, 0.11439440f, -0.00049800f, -0.05139096f, 0.01735820f, 
    0.00287381f, 0.03303600f, 0.02339695f, 0.13436626f, 0.10060343f, 0.15946254f, -0.16213870f, -0.02130978f, 
    0.04611535f, 0.05272497f, -0.07051755f, -0.10333440f, -0.04511413f, -0.00288728f, -0.02496005f, -0.01347130f, 
    -0.05621398f, -0.15916330f, -0.02466933f, 0.04293614f, -0.15842479f, -0.14493892f, -0.14001559f, -0.08483122f, 
    -0.03090733f, 0.08482239f, 0.15087906f, -0.23677920f, 0.01960910f, 0.03812340f, 0.33069411f, 0.06037318f, 
    -0.07751918f, -0.08870398f, -0.15791513f, -0.17426017f, -0.03199260f, 0.06154062f, 0.10039534f, -0.08935317f, 
    0.14682621f, -0.05313048f, 0.10769850f, 0.06733633f, 0.18697010f, -0.07625394f, 0.01998758f, -0.07229955f, 
    -0.00848314f, -0.26170886f, -0.05614978f, -0.02920624f, 0.06596239f, 0.06375661f, 0.07478094f, -0.06195401f, 
    0.02548732f, -0.00081239f, 0.00061836f, 0.19477169f, 0.04452085f, 0.11523014f, -0.08184679f, 0.11842881f, 
    0.13264099f, 0.07644185f, 0.01544012f, 0.19029769f, 0.11997154f, 0.02815660f, -0.09273150f, 0.12982979f, 
    0.15160842f, 0.02481924f, 0.03989054f, -0.17223243f, 0.00904806f, 0.10894076f, 0.12206338f, 0.00189698f, 
    0.01928284f, -0.16068801f, 0.11876576f, -0.05213433f, 0.09847791f, 0.04787791f, -0.04644458f, 0.10088795f, 
    -0.01064419f, 0.03482622f, 0.14287236f, 0.05346020f, -0.11754806f, -0.13695687f, -0.20543255f, -0.09630806f, 
    0.06308667f, 0.01129869f, -0.09995691f, -0.03792490f, 0.08475798f, -0.18356638f, -0.02004833f, -0.22065149f, 
    -0.02842747f, 0.02477462f, -0.01680657f, -0.05409276f, -0.10788269f, -0.04667029f, 0.19372573f, 0.04600226f, 
    0.07542558f, 0.03785918f, -0.12255015f, -0.09682878f, -0.15876874f, -0.02766052f, 0.01902186f, 0.02175098f, 
    0.00209370f, 0.02295556f, 0.09071462f, 0.00982153f, -0.00241293f, -0.08106484f, 0.03697041f, 0.08292039f, 
    0.11459041f, 0.07007113f, 0.07030359f, 0.01731459f, -0.04601814f, 0.00848458f, 0.02403071f, 0.13119149f, 
    0.14662230f, 0.02344675f, -0.01599904f, -0.03015667f, 0.14343740f, 0.08118614f, -0.10029106f, 0.02363559f, 
    0.04140146f, -0.01131588f, -0.03235275f, 0.05316079f, -0.12592101f, -0.03048698f, -0.08761338f, -0.04437775f, 
    -0.18114653f, -0.02797138f, 0.22929458f, -0.07164564f, 0.12728992f, -0.05655706f, -0.08587620f, 0.00999504f, 
    0.04279834f, 0.03101533f, 0.13527015f, -0.09360461f, 0.01724829f, -0.00801847f, 0.00976538f, 0.26344591f, 
    0.02379324f, 0.02848180f, -0.16356729f, -0.00371888f, 0.08930275f, 0.05597237f, 0.13831949f, 0.04922666f, 
    -0.01616664f, -0.08188044f, 0.08119749f, -0.01325687f, 0.01286769f, -0.03883084f, 0.00912626f, -0.05582485f, 
    -0.29350597f, -0.04404440f, 0.04498874f, 0.09432486f, -0.02674838f, -0.07572066f, -0.10127456f, 0.06413301f, 
    0.06037795f, -0.03004878f, 0.02509829f, 0.09217732f, 0.12255300f, 0.03004768f, -0.08924229f, 0.05529708f, 
    0.06747591f, -0.11469249f, -0.00360866f, 0.07380034f, 0.07661393f, -0.00354727f, -0.05412971f, -0.03744373f, 
    -0.00546522f, -0.03938217f, -0.08161671f, -0.04191609f, -0.05600823f, 0.14335179f, 0.06852662f, -0.02186494f, 
    -0.04195965f, -0.10948676f, -0.11838990f, 0.13946137f, 0.00097410f, -0.16064933f, 0.09909961f, -0.00239042f, 
    -0.05108494f, 0.07592624f, -0.00634403f, -0.09422421f, 0.18518057f, -0.02162032f, 0.21539012f, -0.03464161f, 
    -0.09044183f, 0.21821010f, 0.04811952f, -0.07321077f, 0.08274492f, -0.15884343f, -0.10891519f, 0.03115753f, 
    -0.00157324f, -0.05945183f, 0.05503304f, 0.05088382f, 0.02326963f, 0.00823071f, 0.24415281f, 0.18750396f, 
    0.10507676f, -0.12715487f, -0.09504993f, 0.06222302f, 0.11120871f, 0.07170054f, 0.02175784f, -0.09056881f, 
    0.07529706f, -0.07524216f, -0.12433923f, -0.22249290f, 0.00699334f, 0.10463848f, 0.05229006f, 0.11368138f, 
    0.11897188f, -0.10554994f, -0.08123858f, 0.19748114f, 0.00733846f, -0.00945219f, -0.03325853f, -0.01692595f, 
    0.01838779f, 0.14466992f, -0.23240729f, 0.04771194f, 0.00745405f, -0.10369576f, 0.01548058f, 0.00735241f, 
    -0.10091539f, -0.08550029f, -0.07674487f, -0.13294758f, -0.01236712f, 0.01263446f, -0.08422424f, 0.25550261f, 
    -0.03326533f, 0.02864943f, 0.10454696f, -0.17543100f, -0.07790678f, -0.06370243f, 0.00498898f, -0.07154468f, 
    -0.19818839f, -0.06113105f, 0.10735119f, 0.12763874f, -0.21488431f, -0.09304010f, -0.13839315f, 0.00086378f, 
    0.05344737f, 0.02116792f, 0.01469325f, -0.02966352f, 0.07891744f, -0.11921652f, -0.06066271f, 0.06106188f, 
    -0.08495154f, -0.01280938f, -0.03058849f, -0.07631239f, -0.00954786f, -0.09576237f, 0.07923619f, -0.08358095f, 
    -0.28629136f, 0.04557777f, -0.02625947f, 0.04119565f, -0.07892697f, 0.04430122f, -0.19980368f, -0.04135744f, 
    -0.12776780f, -0.13670225f, 0.11575665f, 0.00362940f, 0.19804624f, -0.17856528f, -0.01531838f, 0.12432407f, 
    0.01242949f, 0.04626015f, 0.04879893f, 0.00255027f, 0.05184885f, 0.04671647f, -0.00501632f, -0.01628620f, 
    -0.02383761f, -0.04132632f, -0.06512439f, 0.04905249f, -0.06035534f, 0.02997131f, 0.03630826f, -0.03113886f, 
    -0.04296868f, 0.01980407f, 0.03428978f, -0.05027355f, -0.00746535f, 0.02566928f, -0.06812035f, 0.04842279f, 
    -0.02019937f, -0.04486183f, -0.02029337f, -0.06141945f, 0.03521112f, -0.02497508f, 0.03123648f, 0.02717635f, 
    -0.01470102f, -0.01153649f, 0.04095618f, 0.04796710f, 0.02230490f, -0.01967717f, 0.01027532f, 0.02938893f, 
    0.03808317f, -0.05138206f, -0.00955310f, -0.02087411f, 0.03549106f, 0.04609410f, -0.01867513f, -0.00376557f, 
    0.04199101f, -0.05926544f, -0.00430387f, -0.06005748f, -0.05526714f, 0.04426320f, 0.03435726f, -0.02471430f, 
    0.01863660f, 0.03709484f, 0.00272607f, -0.04317143f, 0.01833883f, 0.04229058f, 0.02523529f, 0.00290402f, 
    0.01346265f, 0.01543233f, 0.03227914f, -0.02018082f, 0.02576814f, -0.06550117f, 0.01539702f, 0.05436765f, 
    -0.05402326f, -0.01369280f, -0.03147009f, -0.01326930f, -0.06091105f, 0.00524968f, -0.04835340f, 0.03721332f, 
    0.04314023f, -0.05020501f, 0.00804966f, 0.03315473f, -0.02991263f, -0.01725398f, -0.01129740f, 0.03340763f, 
    0.03158381f, -0.03466571f, 0.03190062f, -0.02344309f, 0.00841402f, -0.06099191f, 0.00552855f, -0.00031447f, 
    -0.03682113f, 0.03828187f, 0.03098276f, -0.00242723f, -0.02605833f, 0.03763957f, -0.06743876f, -0.00147007f, 
    0.03411913f, 0.01605022f, -0.00322895f, -0.00769054f, 0.04936549f, 0.02310085f, 0.00105765f, -0.06681868f, 
    0.03869750f, -0.02282365f, -0.06385829f, -0.00559001f, 0.01920389f, -0.03432513f, 0.04133194f, -0.05588111f, 
    -0.04892309f, -0.03011050f, 0.00639400f, -0.04169228f, -0.05284810f, -0.02746589f, -0.04587671f, -0.01861975f, 
    -0.00719437f, -0.01085030f, -0.03448493f, -0.01408323f, 0.04023090f, 0.00415129f, 0.01712753f, -0.01362839f, 
    -0.03064894f, 0.00626144f, 0.02015991f, -0.00932164f, -0.02158468f, 0.00817051f, -0.00954905f, -0.01262092f, 
    -0.00467882f, -0.05298228f, 0.04444996f, -0.05928618f, -0.06810492f, 0.02866064f, 0.03236350f, -0.00594529f, 
    0.02917337f, -0.01846272f, -0.05140540f, 0.01760816f, -0.03069165f, 0.01847593f, -0.03354218f, -0.01529554f, 
    -0.03713208f, -0.01066786f, -0.05383465f, -0.00340852f, 0.01615483f, -0.06147959f, -0.03345582f, -0.01526371f, 
    0.00153435f, 0.03496944f, -0.05988230f, 0.05262801f, 0.02311513f, 0.04860055f, -0.05764132f, 0.02051159f, 
    -0.01475746f, 0.00494040f, 0.00029974f, -0.03354134f, 0.02540163f, -0.01188610f, -0.01431559f, -0.02082005f, 
    0.00655452f, 0.04896504f, 0.00614907f, -0.00397923f, -0.04999960f, 0.03005862f, -0.01594581f, -0.00859371f, 
    -0.00979249f, -0.05106085f, 0.02162325f, -0.06828436f, -0.00895536f, -0.03310189f, 0.05155334f, -0.02110824f, 
    0.03115996f, 0.00246053f, -0.00551275f, -0.03615322f, -0.05644125f, -0.04791344f, -0.01284534f, 0.00553353f, 
    0.01724132f, -0.06191195f, -0.02350677f, 0.04520738f, -0.00075955f, -0.04910403f, -0.01558143f, 0.02017721f, 
    0.02066340f, 0.01931510f, -0.02321184f, -0.01600961f, -0.01534683f, -0.01090892f, -0.03877566f, 0.02122512f, 
    -0.01403709f, -0.00282005f, 0.02797415f, -0.05176451f, 0.01113900f, 0.02100406f, -0.04543398f, -0.04133856f, 
    0.01387530f, -0.01150277f, -0.06471568f, -0.06707318f, -0.05640680f, 0.01908496f, 0.01960372f, -0.00968717f, 
    0.02485415f, 0.04111059f, 0.01291047f, -0.03793119f, -0.03365847f, -0.01312775f, 0.00783686f, -0.06676329f, 
    -0.00335016f, 0.01041656f, 0.05474943f, 0.03615993f, -0.03872775f, 0.01050730f, 0.00034543f, -0.02428251f, 
    0.04665419f, -0.03485189f, 0.03152392f, -0.03812890f, 0.00125248f, 0.01122052f, -0.01827932f, 0.00013128f, 
    -0.00452694f, -0.04553785f, -0.02327136f, -0.00482586f, -0.01679151f, 0.02304693f, -0.05455259f, 0.03017484f, 
    -0.03112255f, -0.05185156f, -0.04705967f, -0.04077801f, -0.04496307f, -0.02167000f, -0.01085148f, -0.06163881f, 
    0.00265180f, 0.03997521f, 0.02822743f, -0.06280389f, 0.00554031f, -0.02503885f, -0.05562021f, 0.02085075f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.05589036f, 0.04422538f, 0.06815346f, 0.00042062f, -0.04956041f, 0.02468467f, -0.01460494f, -0.05996368f, 
    0.01529771f, 0.17775737f, -0.05973486f, -0.05471380f, 0.04262508f, 0.01866546f, 0.00474881f, -0.05943203f, 
    -0.05945108f, 0.10879359f, 0.09887441f, -0.00394951f, 0.09774820f, -0.03017785f, 0.10061099f, -0.06269445f, 
    0.10798484f, 0.07789154f, -0.01207608f, 0.02335266f, -0.00081627f, 0.03566971f, 0.04952054f, 0.04143355f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01646194f, 0.02655976f, 0.44777107f, 0.12383418f, 0.04850002f, 0.55273634f, 0.00772897f, -0.04719598f, 
    -0.30534190f, -0.06379443f, 0.00559578f, 0.18356583f, 0.06528429f, -0.11325004f, -0.15531519f, 0.10209213f, 
    -0.17546394f, 0.22021431f, -0.13412204f, 0.32603589f, -0.01632851f, -0.09778686f, 0.11013794f, 0.11467788f, 
    0.00874875f, 0.11573633f, -0.13499285f, -0.37739184f, 0.04475822f, 0.04148257f, -0.10567553f, 0.00434971f, 
    -0.07180031f, 0.00986455f, -0.14873341f, 0.12982810f, 0.41267383f, -0.40457335f, 0.03157910f, 0.00778882f, 
    0.36219102f, -0.01517558f, 0.04319506f, 0.06398782f, 0.10031742f, 0.21510252f, 0.01113937f, 0.17795749f, 
    -0.09243735f, -0.13378009f, -0.14556277f, -0.22495887f, -0.39060295f, 0.07976035f, 0.10403361f, 0.01834388f, 
    0.19989118f, 0.04233988f, 0.12424313f, 0.18647128f, 0.03395927f, 0.16139637f, 0.27055469f, 0.12507667f, 
    0.31261423f, 0.04200503f, 0.41323543f, 0.15506896f, 0.20317116f, -0.09448390f, 0.08193614f, -0.01866481f, 
    0.39585209f, 0.35243419f, 0.09316491f, -0.03869447f, 0.17681669f, 0.22339885f, -0.16038898f, -0.36503705f, 
    -0.11892738f, -0.24680519f, 0.14446399f, 0.09739104f, -0.19626603f, -0.14621294f, 0.02376763f, 0.04187958f, 
    0.20262770f, 0.11348219f, -0.15381938f, -0.28981584f, -0.17593580f, 0.06829280f, -0.08431666f, -0.11761518f, 
    0.25149351f, -0.10598896f, -0.23955879f, -0.10877433f, -0.13490842f, 0.09174968f, 0.14847288f, -0.12985417f, 
    0.17655160f, 0.52481860f, -0.06961440f, -0.14260755f, -0.11965501f, 0.22753717f, 0.06281419f, -0.03596762f, 
    -0.14924583f, 0.20514655f, -0.13975021f, -0.22223791f, 0.25304955f, -0.09146610f, -0.33277375f, 0.10138149f, 
    0.24640115f, 0.24579774f, 0.11864494f, 0.23530467f, 0.25518727f, -0.17060427f, -0.08846862f, 0.03222698f, 
    -0.11039352f, -0.05587113f, -0.18824168f, -0.11655540f, -0.06687666f, -0.28850761f, -0.00595124f, -0.16042344f, 
    -0.04743847f, 0.43129063f, 0.01761024f, 0.14612977f, -0.12308840f, 0.10883196f, -0.07649691f, 0.14799994f, 
    -0.03972698f, 0.11937757f, 0.03094181f, -0.14635852f, 0.61780035f, 0.13092355f, 0.01224270f, 0.02064936f, 
    -0.14078078f, 0.21255757f, 0.41316223f, 0.37695414f, -0.21183316f, -0.16292951f, 0.02891294f, -0.15587510f, 
    0.08865000f, -0.05528883f, -0.05190218f, 0.02014406f, 0.08599550f, -0.16613257f, -0.08371101f, -0.14542945f, 
    -0.14667426f, 0.03877474f, -0.02155116f, -0.10204355f, -0.01069872f, -0.07944299f, 0.04053182f, 0.15097092f, 
    0.08523650f, 0.16862100f, -0.10533161f, -0.12908880f, -0.13102275f, -0.16534373f, -0.13916215f, 0.03019482f, 
    -0.10768821f, -0.08133126f, -0.09228352f, 0.00832466f, -0.06455138f, -0.00366526f, -0.14478965f, -0.12822196f, 
    -0.08726981f, 0.04971949f, -0.09318165f, -0.09167827f, 0.16431130f, -0.04934236f, 0.00605490f, 0.10134037f, 
    -0.14324300f, -0.09339759f, 0.03540557f, 0.16303205f, 0.15068090f, 0.05190762f, -0.08797554f, 0.13458388f, 
    0.06698530f, -0.03093901f, 0.24263081f, -0.17118357f, -0.05650245f, -0.01419509f, 0.05774617f, 0.07825319f, 
    -0.33560166f, 0.01499707f, -0.20143750f, 0.05701490f, 0.20412798f, -0.12530980f, -0.08588806f, 0.15429810f, 
    -0.06766517f, -0.12719573f, -0.10824984f, 0.04523481f, -0.08562833f, 0.24608026f, -0.02072434f, -0.12789251f, 
    0.25051317f, 0.21773918f, -0.13453852f, 0.04944472f, 0.15487887f, 0.02028760f, 0.12610181f, 0.08802076f, 
    0.09422062f, 0.08109370f, -0.08332153f, -0.22931674f, 0.60239750f, -0.13271533f, 0.41809344f, 0.00214594f, 
    -0.09929302f, 0.17542051f, 0.00424421f, 0.20939599f, -0.19280551f, -0.08744084f, 0.00303564f, 0.12022743f, 
    -0.05430196f, 0.07567290f, 0.14000326f, 0.08606071f, -0.08706956f, -0.07603574f, 0.07834301f, -0.18140171f, 
    -0.20026925f, 0.11663587f, -0.02566631f, -0.31271407f, 0.19487172f, 0.16904657f, -0.11830403f, 0.25461629f, 
    -0.08549818f, 0.08916229f, -0.43108037f, 0.27071619f, -0.11692787f, -0.02237247f, -0.04934572f, 0.09122097f, 
    0.16729382f, -0.06756803f, 0.18109889f, 0.37760592f, 0.35909462f, -0.08697476f, -0.06221058f, -0.00299884f, 
    -0.13132620f, -0.10691158f, 0.17934610f, 0.05496397f, -0.24640296f, 0.38540035f, -0.05488884f, -0.09746829f, 
    -0.18010756f, -0.10739242f, -0.13840345f, 0.16192298f, 0.14404991f, -0.07493252f, 0.12081626f, 0.06749527f, 
    -0.00461619f, 0.27973428f, 0.02714069f, 0.06924392f, 0.14114504f, 0.10549420f, 0.27976826f, -0.10837164f, 
    0.03412174f, 0.30187938f, -0.04985030f, 0.10376737f, 0.16036020f, 0.18447484f, -0.20097557f, 0.07126382f, 
    0.14125529f, -0.15289021f, -0.07258829f, -0.09149547f, 0.02001880f, -0.06726597f, -0.15289296f, 0.09779613f, 
    -0.24211062f, -0.18734543f, -0.16834252f, 0.19187795f, -0.29048708f, 0.08769914f, -0.11874851f, 0.17197043f, 
    0.11125621f, -0.05930556f, -0.09253336f, -0.05521004f, 0.03421322f, 0.00972022f, -0.28112912f, 0.13905771f, 
    0.14277276f, -0.08999188f, -0.07210042f, 0.35508785f, -0.25625536f, 0.12479679f, 0.08836246f, -0.07715193f, 
    -0.19458106f, 0.12888628f, 0.15575227f, -0.05488320f, -0.04190030f, 0.23207636f, -0.16521858f, -0.12429617f, 
    0.19214317f, -0.13968775f, 0.12728053f, -0.03576517f, -0.13496433f, -0.07069104f, 0.13673441f, 0.03375695f, 
    -0.11312525f, -0.15487792f, -0.30447131f, 0.48644045f, -0.44745576f, -0.06685312f, -0.17560963f, 0.05895390f, 
    0.28630772f, 0.15035348f, 0.10604841f, -0.01296212f, 0.04759527f, 0.13216516f, 0.02981668f, -0.10982376f, 
    0.02278902f, 0.03008853f, -0.14565553f, 0.14477354f, 0.31512815f, -0.13862099f, 0.11678662f, 0.16570292f, 
    -0.11534230f, -0.49296632f, -0.04291290f, 0.13420390f, -0.10971539f, 0.20125604f, 0.11416369f, -0.24513881f, 
    -0.02651360f, -0.08356830f, 0.17861965f, 0.22183351f, -0.40467611f, -0.16533913f, 0.16847356f, -0.17890228f, 
    0.16551368f, -0.02887238f, -0.22318529f, 0.07730106f, 0.12088802f, 0.01077527f, 0.42819259f, 0.05017470f, 
    0.09951818f, -0.06236267f, -0.07494824f, -0.00712564f, 0.05718126f, 0.04765102f, 0.10404257f, 0.16030078f, 
    -0.08812375f, -0.10057411f, 0.06285663f, -0.06645149f, -0.18817240f, -0.13645637f, 0.11539457f, -0.10016802f, 
    0.07108215f, -0.10895328f, 0.10569783f, 0.07846146f, -0.09783757f, 0.09255781f, 0.09605697f, 0.05645130f, 
    -0.00770383f, -0.18334098f, 0.01297267f, -0.18669739f, 0.01571268f, -0.02331499f, -0.18732689f, 0.09197915f, 
    0.12383860f, 0.10257533f, -0.00731226f, -0.02279361f, 0.37109667f, -0.40230432f, 0.10965325f, -0.10200363f, 
    0.14578839f, -0.19587609f, -0.05836374f, 0.23837207f, 0.01005859f, 0.02072372f, -0.18004966f, -0.04911008f, 
    -0.12259483f, 0.01761606f, 0.38876238f, 0.04728271f, -0.23094460f, 0.02165897f, -0.14127782f, -0.03466135f, 
    -0.04384961f, -0.12650697f, 0.00031572f, -0.00658261f, 0.00672852f, 0.20855048f, 0.20171070f, -0.03869336f, 
    -0.09459177f, -0.11159956f, 0.07970777f, -0.00081235f, -0.04060424f, -0.04989986f, 0.05863853f, 0.07418208f, 
    -0.16102812f, -0.01720166f, -0.06480504f, 0.10747253f, -0.12033702f, -0.02772122f, 0.17476049f, -0.03806423f, 
    -0.00155441f, -0.07125241f, -0.19177556f, 0.03862835f, -0.15183653f, 0.10257725f, 0.03066150f, -0.03311896f, 
    -0.12898980f, -0.11517669f, -0.11955033f, 0.14903292f, -0.00935905f, -0.10092664f, -0.09951741f, 0.15702142f, 
    0.11909972f, -0.12083628f, 0.11855538f, -0.16354951f, -0.19511466f, 0.53563404f, 0.04162641f, -0.14478685f, 
    -0.25325274f, 0.09312309f, 0.11942629f, -0.14329225f, 0.18707244f, -0.10481245f, 0.11061671f, 0.06908651f, 
    0.02242865f, 0.06762795f, 0.07337910f, -0.00941818f, 0.33013701f, 0.04242217f, 0.28063095f, -0.06512967f, 
    0.25718829f, 0.16022623f, -0.21691906f, 0.04489835f, 0.10706917f, -0.14846531f, -0.03151217f, 0.05936924f, 
    -0.18604821f, -0.07112198f, 0.08103038f, -0.02413277f, 0.27006376f, 0.53516763f, 0.01195052f, 0.13995872f, 
    0.00386848f, -0.15327892f, -0.16905858f, 0.23624243f, -0.16372272f, 0.01729553f, 0.01168700f, 0.42213848f, 
    -0.05815639f, -0.02403546f, -0.06947020f, 0.02914677f, -0.43262750f, 0.12167816f, -0.05825431f, 0.01145517f, 
    -0.17271382f, -0.28524664f, 0.15344207f, 0.09016219f, 0.11673019f, 0.26077777f, -0.06743693f, -0.17491104f, 
    0.12287456f, 0.01063551f, 0.04503617f, -0.05579381f, 0.26356348f, -0.24837704f, 0.00625403f, 0.07428015f, 
    0.42600277f, -0.01896969f, -0.09291377f, -0.14359567f, 0.28451043f, 0.15394160f, -0.06030589f, -0.28624657f, 
    -0.11718979f, -0.23349325f, 0.20856966f, 0.24352723f, -0.27987307f, 0.15994278f, -0.08356997f, 0.00808353f, 
    0.00957664f, 0.14014962f, 0.06151107f, -0.13918863f, -0.24742186f, -0.10425121f, 0.08489128f, -0.03507672f, 
    0.16024882f, -0.14206724f, 0.11104274f, -0.02758396f, -0.27540335f, 0.13123611f, -0.04463354f, -0.09834939f, 
    -0.12282863f, 0.54329342f, 0.06337724f, 0.04011966f, -0.22519265f, 0.00630396f, -0.08521573f, 0.24293162f, 
    -0.05916509f, 0.27496013f, -0.09761263f, 0.28606483f, 0.06704695f, 0.04116255f, -0.44933072f, 0.13382873f, 
    -0.02153675f, 0.16293097f, -0.13010460f, -0.13550721f, 0.25613818f, 0.17694320f, -0.14126791f, 0.02532108f, 
    -0.19623986f, -0.06610680f, -0.14923543f, -0.01478370f, 0.14594933f, 0.02505115f, -0.01983233f, -0.08363332f, 
    0.01030522f, -0.53778636f, -0.02910935f, -0.20251313f, -0.17809680f, -0.08813842f, 0.00070655f, 0.04969032f, 
    0.13862409f, 0.40548831f, -0.24674736f, 0.15284719f, 0.05498943f, -0.12840794f, 0.08147068f, -0.12974873f, 
    0.37903771f, 0.10536247f, -0.12045774f, -0.16430059f, 0.21257967f, -0.00186988f, 0.26672554f, 0.09701625f, 
    0.07866683f, -0.03239260f, 0.08609480f, 0.03130086f, 0.14266479f, -0.00101810f, 0.15339185f, -0.08847781f, 
    -0.06683585f, -0.22172967f, 0.01538530f, 0.18620789f, 0.06424420f, 0.12967587f, -0.14035670f, -0.12847349f, 
    -0.16050529f, 0.19369926f, 0.41909671f, -0.25235045f, 0.19605941f, -0.15927754f, -0.02542894f, 0.21018982f, 
    -0.17857997f, -0.01862972f, -0.10314573f, -0.16842438f, -0.10042117f, 0.20568070f, 0.10556441f, 0.04545175f, 
    -0.12962115f, 0.11997161f, 0.21194479f, -0.10778943f, -0.15957253f, 0.28038800f, -0.11288313f, -0.03274931f, 
    0.02851622f, -0.51024288f, 0.14322980f, 0.06444228f, 0.05885872f, 0.11989277f, -0.12446517f, 0.38228559f, 
    0.17603901f, -0.17229193f, 0.03040891f, -0.06376734f, -0.09525558f, -0.06802894f, 0.22510177f, -0.03403873f, 
    -0.26774907f, 0.00714094f, -0.12393216f, -0.18530086f, 0.02073885f, 0.15829700f, -0.35492232f, -0.13136271f, 
    -0.22988164f, 0.03080711f, -0.10144985f, -0.08068783f, -0.39625669f, 0.35905191f, -0.01881934f, 0.16976614f, 
    -0.29577276f, 0.17223355f, 0.09788562f, 0.17967390f, 0.14032069f, -0.03981868f, 0.03523956f, 0.28915733f, 
    -0.02034113f, 0.30274057f, 0.12609591f, 0.04931157f, 0.56349462f, -0.03253146f, -0.18480138f, -0.12444702f, 
    0.01481850f, 0.30859724f, 0.00895249f, -0.08550926f, 0.16082956f, 0.08984158f, -0.06533924f, -0.13916932f, 
    -0.28385210f, -0.14432102f, 0.12647112f, 0.16405557f, -0.12151031f, -0.55249429f, -0.17576565f, 0.12590966f, 
    0.02348398f, -0.00351054f, 0.13444039f, -0.33442941f, 0.38399300f, 0.17180267f, -0.12706558f, -0.19926323f, 
    0.04513707f, 0.09815654f, -0.10104179f, 0.29267377f, 0.08597767f, -0.05876900f, 0.43850946f, 0.05848452f, 
    -0.09531981f, -0.01365314f, 0.05058574f, 0.23656008f, -0.07266152f, -0.15049130f, 0.07621475f, -0.03911660f, 
    -0.20880364f, 0.01420869f, 0.00102451f, -0.02313592f, 0.01411770f, -0.12290947f, -0.02624684f, 0.15277836f, 
    0.00908269f, -0.18505698f, -0.09506910f, -0.17888112f, -0.13952808f, -0.18988748f, -0.04158910f, 0.20757318f, 
    0.17042556f, 0.07710225f, -0.07410535f, 0.10035168f, -0.05384906f, 0.03424594f, -0.00528957f, -0.09068470f, 
    -0.16471356f, 0.02445218f, 0.04190164f, 0.03040852f, -0.00514247f, -0.08826505f, 0.04642304f, -0.03064133f, 
    -0.08525783f, -0.01550376f, 0.08617049f, -0.06696597f, 0.11865328f, -0.10999706f, 0.13882798f, 0.00469027f, 
    -0.07173597f, 0.09553563f, 0.13968337f, -0.34451577f, 0.16268604f, 0.17266212f, 0.16710779f, 0.09886052f, 
    0.02183926f, 0.00445841f, -0.19410470f, 0.19823192f, 0.03521957f, 0.13141519f, 0.38332352f, 0.05138405f, 
    -0.01317635f, -0.15192842f, 0.11638025f, 0.23046221f, -0.03226789f, -0.10129074f, 0.20562083f, -0.16281873f, 
    0.33713070f, -0.00427638f, -0.20293176f, 0.01923311f, 0.21522360f, -0.32582259f, 0.09200745f, -0.09839603f, 
    -0.01945544f, 0.40791959f, 0.12392798f, 0.26522264f, -0.10432554f, 0.25386140f, 0.16654551f, -0.04375136f, 
    -0.14046958f, -0.15938474f, 0.06689347f, -0.34781832f, 0.21371645f, 0.05873144f, 0.09970117f, 0.01672259f, 
    -0.11152065f, 0.11380085f, 0.17979716f, 0.27932030f, 0.03135227f, 0.19256894f, 0.04596779f, 0.07576606f, 
    -0.16868037f, -0.02349605f, -0.05644817f, -0.04776077f, 0.02988175f, -0.15586486f, 0.02776358f, -0.06692730f, 
    -0.13168700f, -0.20299786f, -0.13944978f, -0.02889576f, -0.04407458f, -0.03722493f, 0.09041096f, 0.11763872f, 
    0.17256038f, 0.06432905f, -0.02557920f, -0.21829382f, 0.00037247f, -0.16381201f, -0.13566594f, -0.09890417f, 
    -0.04139747f, -0.02549013f, 0.05428004f, 0.00313341f, 0.13641530f, -0.14080548f, -0.01482331f, -0.16629358f, 
    0.33442992f, 0.17425749f, 0.09812879f, -0.10202295f, 0.06153877f, -0.26390457f, -0.15480962f, -0.13185786f, 
    0.34070006f, 0.25260323f, 0.12501182f, 0.03242619f, 0.12742206f, 0.10859206f, 0.07335676f, -0.21217746f, 
    -0.10345876f, -0.16349530f, 0.28462723f, -0.16455571f, -0.26309484f, -0.00495445f, -0.09265975f, -0.02832946f, 
    -0.02596002f, 0.15905975f, -0.35271943f, -0.24142531f, 0.08957388f, 0.10102505f, 0.01660639f, 0.02730467f, 
    -0.04937444f, -0.02515708f, 0.02753803f, 0.03720452f, 0.04917318f, 0.17371503f, -0.14421938f, -0.16362275f, 
    0.03522814f, -0.41863060f, -0.14063816f, -0.24853499f, -0.05120284f, 0.20312640f, 0.12792654f, -0.16597554f, 
    0.02046228f, 0.24668604f, -0.31508270f, -0.15233320f, 0.14142264f, -0.17030646f, 0.50484407f, -0.03010952f, 
    0.31787732f, 0.08158235f, 0.05097049f, -0.01029810f, 0.27131096f, -0.21431683f, 0.00967924f, -0.14889073f, 
    -0.06269789f, 0.13011754f, -0.12926427f, 0.03946104f, 0.08808256f, -0.31873336f, 0.13047747f, -0.00223223f, 
    -0.17067304f, -0.03576577f, 0.13388994f, -0.17753240f, -0.21970373f, 0.16920951f, -0.00758806f, 0.03744376f, 
    0.08423738f, 0.10494890f, -0.07586199f, 0.26401058f, -0.29118627f, -0.01054519f, 0.06060718f, -0.03991120f, 
    0.15882875f, -0.05139991f, 0.26014701f, 0.05375308f, 0.07611142f, -0.03813811f, 0.40259281f, 0.06516849f, 
    -0.01651751f, 0.02713872f, 0.22013046f, -0.15558884f, 0.13741726f, -0.08642178f, 0.15451759f, 0.03883745f, 
    0.07360307f, -0.08036203f, 0.09846468f, 0.04486857f, 0.33641410f, -0.09319807f, -0.15881722f, -0.14641619f, 
    -0.11731326f, -0.03785217f, -0.07337116f, 0.28591272f, 0.07860318f, -0.03034765f, 0.36365312f, 0.01514830f, 
    0.06733696f, 0.19280617f, 0.19697474f, 0.05775880f, -0.22877242f, -0.04931948f, -0.00204061f, -0.16763052f, 
    -0.19519040f, 0.01727603f, -0.01847129f, -0.11668088f, 0.28367680f, 0.05580926f, 0.07586215f, 0.02882093f, 
    -0.33192313f, -0.23059177f, -0.15232980f, 0.17065297f, -0.23107086f, 0.25621057f, 0.02093293f, 0.20354055f, 
    0.01015809f, 0.08057884f, 0.16491716f, -0.20920342f, -0.09576822f, 0.17941697f, 0.33390048f, 0.04795626f, 
    0.20262276f, -0.31015566f, -0.32489860f, -0.16062582f, 0.06027511f, 0.13763995f, 0.33832183f, -0.12817430f, 
    -0.27409393f, 0.09359031f, 0.00684671f, -0.08823968f, -0.14090984f, -0.08110880f, 0.06813352f, 0.00628490f, 
    -0.09982505f, 0.09738540f, -0.02594575f, -0.13129358f, -0.03168458f, 0.29568776f, -0.11571246f, 0.12576164f, 
    -0.07398448f, 0.09697779f, -0.02427352f, -0.21027760f, 0.13634247f, 0.07233605f, 0.16478288f, -0.10200562f, 
    -0.09981935f, 0.08627321f, -0.58844841f, -0.01374121f, 0.44086802f, 0.21575393f, 0.11427575f, -0.02360822f, 
    -0.04718243f, -0.07785460f, 0.01111648f, -0.15779333f, -0.01190651f, 0.09583650f, -0.14747861f, -0.07774964f, 
    0.00590132f, -0.17369133f, -0.07303056f, -0.14168957f, -0.14490351f, -0.10462340f, -0.09812195f, -0.07526936f, 
    0.02330847f, -0.09931719f, -0.10158328f, -0.00287342f, 0.06850806f, 0.11059523f, -0.12285267f, -0.14665076f, 
    -0.07213762f, -0.15992975f, 0.00866200f, 0.05703383f, -0.00582729f, 0.06308452f, -0.02211076f, 0.07351582f, 
    -0.05976563f, -0.15343213f, -0.28291494f, 0.10706893f, -0.08193214f, 0.22362691f, 0.01813977f, 0.15805233f, 
    -0.00577173f, 0.01191684f, -0.00047519f, 0.30874133f, -0.13610396f, 0.12268236f, 0.06146739f, 0.32989526f, 
    0.11964511f, -0.19035393f, 0.19386546f, 0.04886435f, 0.09774514f, 0.14120221f, -0.33331114f, -0.06960839f, 
    -0.25512141f, -0.09724801f, -0.01472013f, 0.37928709f, 0.32607967f, 0.21246585f, -0.27579847f, 0.11388057f, 
    0.40343708f, 0.03882558f, 0.22092062f, -0.12999907f, -0.17925289f, 0.23821488f, -0.16602485f, -0.15073092f, 
    0.38227731f, 0.47818139f, 0.08645409f, -0.12006951f, 0.04945230f, 0.17401811f, 0.03227172f, -0.05516135f, 
    0.11246443f, -0.06754208f, -0.03190307f, 0.07181694f, -0.10337092f, 0.16497169f, -0.34545588f, 0.05294248f, 
    0.28740430f, 0.26999933f, -0.00905872f, -0.06347238f, -0.18220456f, -0.18042053f, -0.08591919f, 0.15166230f, 
    -0.03032253f, 0.02754821f, 0.39103720f, 0.13970794f, 0.10947706f, 0.20954485f, -0.10793334f, -0.02213805f, 
    -0.16095003f, -0.08015735f, 0.08794937f, 0.36319125f, 0.35296920f, -0.12268751f, -0.16454460f, 0.14355943f, 
    0.10329037f, -0.19176950f, 0.46378615f, 0.16239268f, 0.01256813f, -0.14565122f, 0.28829068f, -0.11300719f, 
    -0.27781683f, -0.06218438f, 0.00795884f, -0.07969670f, -0.24322829f, 0.22737613f, -0.11762572f, -0.10968947f, 
    -0.05610839f, 0.09978807f, -0.22253944f, -0.11749990f, 0.04503007f, -0.46853921f, -0.08230904f, 0.04052302f, 
    -0.06361356f, 0.21613410f, -0.00329801f, -0.05337520f, 0.05508524f, 0.03823387f, -0.06047746f, 0.24433899f, 
    0.14402790f, -0.18346080f, 0.06576621f, 0.33875060f, -0.13034454f, -0.13980921f, -0.17351870f, 0.02567569f, 
    0.14631316f, 0.14708996f, 0.17998277f, 0.32760632f, 0.27867097f, 0.18974265f, 0.30150521f, -0.01441908f, 
    0.25508013f, -0.14846323f, -0.02929981f, 0.06992333f, 0.02204614f, -0.29304886f, 0.12216496f, 0.16151105f, 
    -0.24023257f, 0.32316074f, 0.04635362f, 0.26239324f, -0.34863606f, 0.14031570f, 0.00838129f, 0.10577978f, 
    0.18504108f, 0.09831005f, 0.08519544f, 0.12694088f, 0.06561767f, -0.15610735f, -0.38132393f, 0.03737639f, 
    0.16486797f, -0.08088890f, 0.13847879f, -0.12334662f, 0.22614941f, 0.14619981f, 0.17517351f, 0.08011886f, 
    0.06266473f, 0.00082751f, 0.17930880f, 0.03352166f, 0.27469262f, -0.09667036f, -0.11635417f, 0.13550432f, 
    0.08885872f, -0.29927823f, 0.03998612f, 0.21230091f, 0.14213856f, -0.03433147f, -0.11660644f, -0.10954397f, 
    -0.14588340f, -0.16678095f, 0.24037586f, 0.38431302f, -0.15394741f, -0.00011013f, -0.06115284f, 0.09051824f, 
    -0.07794626f, 0.05799977f, -0.20180732f, -0.33712447f, -0.09923201f, 0.31091657f, -0.06673975f, 0.08765104f, 
    -0.13435206f, 0.11603282f, 0.07533699f, -0.03341537f, -0.15427969f, -0.01221179f, 0.14446147f, 0.10205691f, 
    0.03805391f, -0.00508313f, -0.07976626f, -0.08284880f, 0.01664491f, -0.04142968f, -0.05647685f, -0.11532629f, 
    -0.14490315f, -0.15432785f, -0.07234345f, -0.17295368f, -0.03576771f, 0.17485777f, -0.12729202f, -0.14479893f, 
    0.08887431f, 0.08361308f, -0.13867332f, -0.00747958f, 0.03189002f, -0.19714959f, -0.13488072f, 0.10077067f, 
    -0.02571933f, -0.05212110f, -0.04824975f, -0.10178404f, -0.08940274f, -0.33227071f, -0.07461914f, 0.05432930f, 
    -0.15132189f, 0.46902376f, -0.01983492f, -0.27440116f, 0.09704506f, 0.06271363f, -0.13197765f, 0.21607909f, 
    0.14498441f, 0.07142861f, -0.23837799f, 0.04638827f, 0.02254318f, 0.05983395f, 0.05307170f, 0.05992199f, 
    0.13276814f, -0.03400949f, 0.08450216f, 0.48443463f, 0.20438875f, 0.03800997f, 0.16177057f, -0.10193763f, 
    -0.15561691f, -0.10728396f, 0.28988293f, 0.06657112f, 0.21456762f, 0.30526727f, -0.01622662f, -0.13706370f, 
    0.12837122f, -0.33272091f, 0.04930121f, 0.21693970f, 0.21933161f, -0.12844707f, -0.12480859f, 0.23755036f, 
    -0.17359446f, -0.01138527f, 0.09454053f, 0.32156107f, -0.25156310f, 0.00512598f, 0.21548696f, 0.01253475f, 
    0.05095295f, 0.17049548f, -0.11422803f, -0.21917428f, 0.04145686f, 0.20005758f, -0.10486507f, -0.07990383f, 
    -0.11935796f, -0.14066917f, -0.16880086f, 0.03849862f, 0.03685608f, 0.12313085f, -0.01760680f, -0.07805742f, 
    -0.15181860f, 0.13829157f, 0.09880987f, -0.03633530f, 0.01301108f, -0.17488918f, -0.15205829f, 0.09691972f, 
    0.14001264f, 0.08285675f, 0.10202608f, -0.11568791f, 0.10132208f, -0.02701371f, -0.18611501f, 0.05047059f, 
    -0.09568177f, 0.14311895f, -0.17053740f, 0.03658861f, -0.06064817f, -0.11325821f, 0.00424571f, 0.11726443f, 
    -0.17190699f, -0.17460565f, -0.11764836f, 0.03261030f, -0.16329311f, 0.04236659f, 0.07655703f, -0.16478139f, 
    0.15858626f, 0.00440428f, 0.03637920f, 0.02663181f, -0.01749936f, -0.12011985f, 0.07255137f, 0.05776787f, 
    0.15926583f, -0.21352293f, 0.08462111f, 0.11699191f, -0.05345225f, 0.04645308f, 0.02787617f, 0.10563961f, 
    -0.06979783f, 0.00895214f, 0.07864252f, 0.01467015f, -0.17239462f, -0.22417703f, -0.08045735f, -0.00753694f, 
    -0.05803323f, -0.11402170f, -0.07343547f, 0.17113550f, 0.08259410f, -0.18050168f, 0.10290541f, 0.04359868f, 
    -0.17495295f, 0.13659167f, -0.16643326f, -0.06754798f, 0.04162351f, -0.17312220f, -0.15348978f, -0.07451857f, 
    0.13950038f, 0.12415454f, -0.15991800f, -0.06161545f, 0.14911243f, -0.06264039f, 0.03554024f, 0.00180886f, 
    0.02161564f, -0.09888966f, 0.06793451f, 0.14542580f, 0.11594280f, -0.13997768f, -0.16139954f, -0.09193485f, 
    -0.11960596f, 0.08750473f, -0.02616378f, 0.05659166f, 0.14960757f, 0.17931427f, 0.09558644f, -0.06361285f, 
    0.13643783f, -0.02205153f, -0.10919785f, -0.40595248f, -0.06236906f, 0.02214553f, 0.10819060f, 0.02399864f, 
    -0.03521286f, 0.13776489f, -0.02708777f, 0.38476419f, 0.03763744f, -0.13659136f, 0.04046777f, 0.11562710f, 
    -0.07776287f, -0.08620451f, -0.02961944f, -0.13745202f, 0.15831746f, -0.04209356f, -0.24914461f, 0.03597278f, 
    -0.07150030f, -0.13762379f, 0.27553314f, 0.06648801f, -0.19699539f, 0.46144035f, 0.03658321f, 0.16969743f, 
    0.07991712f, 0.03274333f, 0.03184262f, 0.13621014f, 0.04243216f, -0.10764812f, 0.01465218f, 0.11789542f, 
    0.13578705f, 0.31142125f, 0.02322829f, -0.11755404f, 0.26699913f, 0.05938565f, 0.12274739f, 0.09429887f, 
    0.19122684f, 0.20725894f, -0.21061623f, 0.00412302f, -0.07199936f, -0.07309289f, -0.23577763f, -0.05775408f, 
    0.01605393f, -0.15396136f, -0.03582233f, 0.04942210f, -0.00297193f, -0.06632685f, 0.03060728f, 0.03987235f, 
    -0.33470386f, -0.32557738f, -0.01433009f, 0.04603817f, 0.00435106f, 0.05052440f, -0.07258519f, 0.13838030f, 
    0.05344928f, 0.01054323f, 0.03002700f, 0.32545614f, 0.01214152f, 0.00968229f, 0.12940121f, 0.15195073f, 
    -0.19555461f, -0.03697627f, -0.36917418f, 0.11523514f, 0.37378091f, 0.19661814f, 0.21331833f, -0.13326266f, 
    0.00902743f, 0.12738214f, 0.07852430f, 0.05421888f, -0.11158293f, -0.09856209f, -0.14615539f, 0.10819190f, 
    0.20903569f, 0.33024827f, 0.03491225f, -0.08311282f, 0.10120925f, -0.00119523f, 0.13860312f, -0.01594215f, 
    -0.06130138f, 0.03585113f, -0.19142479f, 0.20143482f, 0.28927973f, 0.04302309f, -0.20923498f, -0.08315784f, 
    0.29308388f, 0.32463899f, 0.23340739f, -0.11836263f, -0.15291460f, -0.03658000f, 0.16286026f, -0.09698578f, 
    -0.06657683f, -0.01200050f, -0.09131604f, -0.03180869f, 0.35226682f, -0.02940140f, 0.01294976f, 0.01020205f, 
    0.07061882f, -0.03260623f, 0.07923498f, -0.08648000f, 0.19712915f, 0.21588549f, -0.00356005f, -0.09321449f, 
    -0.15999952f, -0.28305191f, -0.08142038f, -0.02566304f, -0.03109494f, 0.06975967f, 0.53364009f, -0.13459668f, 
    0.13277511f, -0.19161461f, 0.33433068f, 0.40018326f, -0.10531176f, -0.07850681f, 0.18930408f, -0.16087992f, 
    0.16993561f, -0.02202782f, 0.01508186f, -0.16320269f, 0.23333861f, -0.34011039f, -0.03126986f, -0.07096465f, 
    0.46983451f, 0.08021151f, -0.15570748f, -0.17575967f, 0.26976371f, 0.16619381f, -0.08319052f, -0.20733975f, 
    -0.02256690f, -0.33163831f, 0.03218146f, 0.10160612f, -0.11717922f, -0.14864200f, 0.07885362f, -0.02289115f, 
    0.03924484f, -0.05534995f, -0.12256720f, 0.07138720f, -0.20086010f, 0.06219324f, 0.18092705f, 0.08267166f, 
    0.01752771f, 0.10576811f, -0.11429197f, -0.14923444f, -0.04801108f, 0.09948196f, 0.09753156f, 0.15208161f, 
    -0.04117654f, -0.03126075f, 0.15276161f, 0.04422380f, -0.14947304f, -0.07821671f, -0.15843268f, 0.02318114f, 
    0.13681589f, -0.16054417f, -0.11345195f, 0.05214616f, 0.11952239f, 0.09526070f, -0.04634569f, -0.10403861f, 
    0.05943529f, -0.16981471f, -0.18445228f, 0.10948848f, -0.04313330f, -0.16543835f, -0.00347501f, 0.06210340f, 
    0.26041812f, -0.05604523f, -0.20327757f, -0.02263106f, 0.06336369f, -0.03483519f, -0.00291465f, 0.03864603f, 
    -0.09920750f, 0.29833007f, 0.07543825f, 0.19142483f, -0.19704850f, 0.27517763f, 0.17319964f, 0.26160753f, 
    0.13398148f, -0.29148528f, -0.08195630f, -0.06951024f, -0.23976217f, 0.12821192f, 0.05476279f, 0.17795941f, 
    -0.02866795f, -0.28843993f, -0.07635302f, 0.12844025f, 0.27445629f, 0.13653457f, 0.14867011f, -0.13753669f, 
    -0.17866731f, -0.17310086f, 0.15225482f, 0.06626666f, -0.24175583f, 0.30888990f, 0.11048582f, 0.02246381f, 
    -0.24279901f, -0.28945804f, -0.07188651f, 0.05888840f, -0.05934242f, -0.08511677f, -0.11015963f, 0.35906148f, 
    -0.02154411f, 0.19512078f, -0.08622515f, 0.10880864f, 0.15288229f, -0.12511943f, 0.11638224f, -0.07880815f, 
    0.25012407f, 0.12894544f, 0.09981067f, 0.23614892f, 0.04211323f, -0.09055542f, 0.22425933f, -0.11163577f, 
    0.20811225f, 0.11847431f, -0.11103138f, 0.10656460f, -0.03602073f, -0.47947720f, 0.01505662f, -0.10891462f, 
    -0.21348754f, -0.02955674f, -0.12055389f, -0.08690206f, -0.10441049f, 0.22773001f, 0.16095528f, 0.00542124f, 
    -0.06731872f, 0.09363581f, 0.28237027f, -0.18492432f, -0.00702740f, 0.04154818f, 0.25726646f, 0.02410094f, 
    -0.08742095f, 0.09405486f, -0.35327062f, -0.11955706f, 0.22166608f, 0.23360017f, 0.33118799f, -0.04177763f, 
    -0.17926718f, 0.11616507f, -0.17605147f, 0.12615415f, -0.16079499f, -0.15527689f, 0.15962665f, 0.04100323f, 
    -0.08373126f, 0.05832873f, -0.05837359f, 0.05901076f, -0.10829076f, 0.09780398f, -0.17291535f, 0.09725401f, 
    -0.06097572f, -0.16739918f, -0.07077890f, -0.13464732f, -0.03772274f, -0.07167353f, 0.10881948f, -0.04718511f, 
    0.05362437f, 0.04292760f, -0.05711662f, -0.23455743f, -0.18289167f, -0.15003273f, 0.04675160f, -0.03131754f, 
    -0.11178184f, 0.02104438f, 0.05412671f, -0.10321067f, -0.14899510f, -0.10438441f, -0.02626847f, -0.14433387f, 
    0.10777583f, 0.11944522f, -0.17425729f, -0.11782949f, -0.11591697f, -0.09968737f, -0.03960610f, -0.10947098f, 
    -0.09109216f, -0.05717850f, -0.07306798f, -0.16123672f, -0.00833264f, 0.01709310f, -0.11457173f, 0.13630040f, 
    0.07692550f, 0.03224556f, -0.03008845f, -0.03465472f, -0.09772405f, -0.10377282f, 0.13411780f, -0.11445690f, 
    0.20349132f, -0.02970459f, -0.05098692f, -0.07260577f, 0.05194943f, 0.36275992f, -0.11909951f, 0.02538784f, 
    -0.20485616f, -0.04620152f, 0.07284194f, 0.25529689f, -0.36557695f, -0.11365052f, 0.00728330f, 0.12818697f, 
    -0.06688511f, 0.32660270f, -0.15827456f, 0.15993220f, -0.08934394f, -0.00113118f, -0.32298955f, -0.04428386f, 
    0.45886415f, 0.20315453f, 0.13527685f, -0.06422185f, -0.01221601f, -0.17232957f, 0.15582734f, -0.06897954f, 
    -0.17227346f, -0.00171426f, -0.19284074f, -0.12793301f, -0.14056291f, -0.07808758f, 0.11922157f, 0.01859793f, 
    0.15069394f, 0.01201840f, -0.09304170f, 0.01952743f, -0.12349378f, -0.09628469f, 0.13039504f, -0.12435345f, 
    0.09440287f, 0.14410636f, -0.17104147f, 0.11257940f, 0.09686617f, -0.13007118f, 0.00652546f, -0.01833917f, 
    0.01455962f, -0.07405416f, -0.17545341f, 0.01876687f, 0.07048874f, -0.19165455f, -0.10991152f, -0.14737584f, 
    0.27241445f, 0.10056719f, 0.18705691f, -0.03039158f, -0.16118212f, 0.04313515f, 0.14644538f, -0.00786785f, 
    0.34671402f, 0.30972070f, 0.03197176f, -0.18724799f, 0.21043757f, 0.15389040f, 0.07605455f, -0.21978803f, 
    -0.10041811f, -0.20719817f, -0.08401605f, 0.02285881f, 0.08662806f, 0.14742517f, -0.19431868f, 0.15654156f, 
    0.26530614f, 0.32474622f, 0.20260730f, -0.04945352f, -0.02918315f, -0.16210139f, -0.22019783f, -0.04367797f, 
    -0.16510031f, -0.03530638f, 0.15590526f, -0.09398169f, 0.12674199f, 0.03356706f, -0.10467216f, 0.08120129f, 
    0.09681705f, -0.48310944f, -0.07876314f, -0.26720038f, 0.31302872f, 0.19083372f, 0.07009642f, -0.04627692f, 
    0.00524953f, -0.12253933f, 0.05296506f, 0.23650651f, 0.32471725f, 0.13206427f, 0.56829149f, 0.03080404f, 
    0.01525206f, 0.02249734f, -0.08978210f, 0.04246594f, 0.04105672f, -0.14932361f, -0.22797890f, 0.13469796f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00869406f, 0.03454744f, -0.02880723f, 0.21947159f, 0.05859536f, -0.17456293f, -0.18049531f, -0.10831544f, 
    -0.06801289f, 0.18748856f, -0.11913305f, -0.06120780f, -0.05704750f, -0.10270555f, 0.00642193f, 0.14038837f, 
    0.13269280f, -0.11017619f, 0.01223740f, 0.08337232f, -0.07053129f, 0.20554060f, 0.13703246f, 0.21511416f, 
    -0.01704963f, -0.04653428f, 0.17639479f, 0.17131385f, 0.00862679f, 0.30494785f, -0.05720209f, -0.08713032f, 
    0.15353613f, 0.18156970f, 0.09199158f, 0.03783529f, 0.08207532f, 0.06410034f, 0.22663428f, 0.00712243f, 
    0.06112755f, 0.11854126f, -0.16898599f, 0.27152681f, -0.05549702f, -0.17725424f, -0.17762053f, -0.14156319f, 
    0.10420866f, 0.11961828f, 0.22636299f, 0.16103202f, 0.05085646f, 0.06703703f, -0.08447725f, 0.08456394f, 
    0.20289826f, 0.21543555f, -0.14177470f, 0.11694388f, 0.27842340f, -0.11022579f, 0.09010407f, 0.12624592f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.17708021f, 0.15172097f, 0.07301765f, 0.48565423f, 0.42037624f, 0.04236400f, -0.18106648f, 0.00990802f, 
    0.12564762f, 0.01575387f, -0.03561141f, 0.19428660f, 0.02466694f, -0.10600222f, -0.18210052f, -0.12218914f, 
    -0.07432427f, -0.09606619f, -0.04147277f, 0.11052744f, 0.01405013f, -0.20744075f, -0.06354754f, 0.26099849f, 
    0.02754955f, 0.08757072f, 0.25914502f, 0.23954248f, -0.03970725f, -0.05839174f, 0.00562452f, 0.20545730f, 
    0.13472712f, -0.18070881f, -0.16471538f, 0.00028962f, 0.14036846f, 0.10559078f, -0.22278467f, 0.25157839f, 
    0.22461031f, -0.34923053f, 0.05851851f, 0.30074281f, -0.19243421f, 0.05498745f, -0.02023975f, -0.03913723f, 
    -0.23941413f, 0.02739521f, -0.05433653f, 0.27995089f, 0.02062493f, -0.11772633f, -0.08135097f, -0.06258701f, 
    0.26911634f, 0.07115252f, 0.06765185f, 0.08382639f, 0.29036072f, -0.08926946f, 0.21055111f, -0.25620189f, 
    -0.15370551f, 0.04441125f, 0.12590337f, 0.16961619f, 0.02093046f, 0.12373646f, 0.14151829f, 0.10953169f, 
    -0.16439092f, -0.04062795f, -0.28702551f, -0.01200716f, 0.11829466f, -0.12422603f, 0.04402457f, -0.04613739f, 
    0.01518349f, -0.10531691f, 0.20608120f, -0.26849216f, 0.04829911f, 0.06554899f, -0.06124594f, -0.13919629f, 
    -0.14967513f, -0.05627231f, 0.06527170f, 0.08837286f, 0.08290575f, 0.17599000f, 0.23817392f, 0.02444392f, 
    0.00674603f, 0.12350848f, -0.25363699f, -0.08257526f, -0.34884861f, 0.14945294f, 0.07645268f, 0.02986292f, 
    -0.01023254f, -0.00782132f, -0.08978117f, -0.08686521f, -0.07503346f, -0.23416404f, -0.09681083f, 0.05999672f, 
    -0.05719671f, 0.00913278f, -0.36030143f, -0.08109661f, 0.40511978f, 0.27969980f, 0.07035896f, -0.00198249f, 
    -0.17643374f, -0.08509413f, -0.03319610f, 0.07909944f, 0.18906347f, -0.10324341f, 0.09488843f, 0.11254399f, 
    -0.13286416f, -0.08373001f, -0.14190958f, 0.05092376f, -0.06472509f, 0.08117072f, -0.08969621f, -0.08888262f, 
    0.08650842f, -0.02798142f, 0.06222929f, 0.01541036f, -0.03489910f, 0.11985475f, 0.05573512f, 0.06515412f, 
    -0.01049960f, -0.10770351f, -0.06735164f, -0.00426485f, -0.04476735f, -0.00075665f, 0.00390381f, 0.04304544f, 
    -0.01805389f, -0.12413786f, -0.06584726f, -0.14481658f, 0.11646625f, 0.07881510f, 0.06748655f, 0.01913372f, 
    -0.01792684f, 0.06480596f, 0.10728795f, 0.09092768f, 0.06526193f, -0.03016782f, 0.04845756f, 0.07856835f, 
    -0.11141428f, 0.06223945f, 0.00941653f, -0.07683755f, -0.02208498f, -0.00201664f, -0.02669610f, 0.04742692f, 
    0.07565298f, 0.07709586f, -0.08463335f, 0.02528077f, -0.02961401f, -0.10566361f, 0.01860103f, -0.04310454f, 
    0.01602601f, 0.06368163f, -0.05194480f, 0.08158003f, -0.05514357f, -0.07139042f, -0.08202223f, -0.11324657f, 
    0.04470931f, 0.15813966f, 0.08755370f, 0.18238756f, 0.46933097f, -0.02252477f, 0.34015602f, 0.21142426f, 
    0.00906797f, -0.09204468f, 0.10709948f, -0.33920109f, -0.02307734f, -0.00972283f, -0.00413258f, 0.05399267f, 
    0.09134042f, 0.60452187f, -0.18634793f, 0.01567302f, 0.09015841f, 0.18976898f, 0.19806491f, -0.05626785f, 
    -0.17237948f, 0.04840255f, 0.03804157f, 0.33652812f, -0.09990651f, -0.10577042f, 0.17688228f, 0.23420733f, 
    -0.06915862f, 0.44631013f, -0.11567122f, -0.12115695f, 0.37491578f, 0.10125958f, -0.10382755f, -0.05373039f, 
    0.13085595f, -0.12523299f, -0.11656933f, 0.14315137f, -0.18959153f, -0.03054259f, 0.06657991f, -0.07297414f, 
    -0.38170201f, 0.04585913f, -0.08634978f, 0.15927601f, 0.24652897f, -0.13872860f, 0.01074410f, 0.50823593f, 
    0.05605581f, 0.19997631f, -0.11495790f, -0.08583638f, 0.23469670f, -0.12156744f, -0.01306557f, -0.25076687f, 
    -0.14872612f, -0.01467228f, 0.02402896f, -0.13116190f, -0.13870026f, -0.09099545f, 0.08808180f, 0.02864195f, 
    0.07037235f, -0.09640401f, 0.05580362f, -0.05932923f, -0.06714515f, 0.04889871f, -0.00221209f, -0.05905498f, 
    -0.05010109f, -0.08549794f, 0.06997097f, -0.02395126f, -0.12027574f, -0.10725271f, -0.01111310f, 0.07718947f, 
    0.06102770f, -0.09908532f, 0.02727219f, 0.01530095f, 0.01262170f, 0.00533729f, -0.11344419f, 0.00483200f, 
    -0.01187556f, -0.15979604f, 0.03141296f, 0.04331771f, -0.17991239f, -0.04301925f, -0.01942950f, -0.01929315f, 
    -0.06195809f, -0.08287100f, -0.07713199f, 0.08196813f, 0.03308727f, 0.07561150f, -0.07559804f, -0.09975570f, 
    0.11777145f, -0.00784501f, 0.04079483f, -0.10617343f, -0.11121742f, 0.05609458f, 0.01717694f, -0.12380096f, 
    -0.07626141f, -0.10270115f, 0.03528820f, 0.05423092f, -0.00227225f, 0.06435430f, -0.15565677f, -0.10244603f, 
    0.31687763f, -0.15337288f, 0.20599762f, -0.20285909f, 0.04274002f, 0.05689681f, -0.03970306f, -0.02566445f, 
    -0.27281779f, 0.20387906f, -0.11133333f, 0.14752589f, 0.10642957f, -0.03436146f, 0.08164024f, -0.11593211f, 
    0.05569245f, -0.08151615f, 0.11187118f, -0.00469442f, 0.02227535f, 0.23110133f, 0.15052825f, 0.20105520f, 
    -0.35736802f, 0.07089146f, -0.24967596f, -0.15431011f, -0.02601898f, 0.12238691f, -0.03126528f, -0.06538273f, 
    0.10553055f, 0.04319884f, -0.32123464f, -0.04820508f, -0.26513082f, 0.18812627f, 0.42939818f, 0.02803334f, 
    -0.01006735f, 0.18765548f, 0.06423739f, -0.31962711f, 0.14835176f, -0.07053351f, -0.03158882f, 0.13494307f, 
    0.00095645f, 0.16022266f, -0.05873730f, 0.20062165f, -0.22310179f, -0.00269097f, -0.08790796f, -0.35212639f, 
    0.08816683f, -0.03892056f, -0.06442381f, 0.00600395f, 0.21923891f, -0.01189671f, 0.11991985f, 0.10887256f, 
    -0.00280407f, -0.06447972f, 0.03313562f, 0.21485974f, -0.01148165f, 0.02716845f, -0.17491572f, -0.03152802f, 
    0.03809874f, 0.10028877f, 0.12199259f, 0.37438580f, -0.01879829f, -0.01097146f, -0.05286452f, -0.02396268f, 
    -0.07991410f, -0.40336928f, 0.22420816f, 0.29329589f, 0.17781641f, -0.07276726f, 0.23843895f, 0.19723083f, 
    0.00785267f, -0.05396028f, -0.06963262f, -0.02500616f, 0.09367027f, 0.21668306f, -0.28663445f, -0.07288434f, 
    0.15472206f, -0.24929506f, -0.12349670f, 0.09932941f, -0.14459036f, 0.30961680f, 0.06476328f, 0.07135206f, 
    0.03877723f, 0.18118936f, 0.06944863f, 0.05468139f, 0.08064597f, 0.06997405f, -0.06419642f, -0.09071982f, 
    0.17625307f, 0.16491815f, -0.05222477f, 0.29802442f, -0.29090062f, 0.22570454f, 0.04252065f, -0.27671584f, 
    0.01153228f, 0.14070173f, -0.01834101f, 0.13586877f, 0.13163805f, 0.01018031f, 0.32467589f, 0.09449721f, 
    -0.02342385f, -0.04176453f, -0.21749067f, 0.01914660f, -0.00596393f, 0.03624617f, 0.06509306f, 0.07309929f, 
    -0.07270627f, 0.22149397f, 0.16423407f, -0.43001911f, 0.06492420f, 0.02947675f, -0.02258120f, 0.07160263f, 
    0.08511841f, -0.10841250f, -0.26666039f, 0.23980658f, 0.05351960f, 0.15322852f, -0.08852428f, 0.39991191f, 
    0.13889392f, -0.05292438f, -0.02567591f, -0.06510607f, 0.13743319f, -0.08715955f, 0.10436542f, 0.00214674f, 
    0.03821591f, 0.07604386f, 0.47327095f, -0.01088642f, 0.32637423f, -0.02319456f, -0.03484327f, 0.11673483f, 
    0.15847114f, -0.04474688f, 0.08202923f, 0.12418997f, 0.01605485f, -0.03748753f, 0.05358955f, -0.08766877f, 
    0.07119066f, 0.25633517f, 0.40022117f, 0.02963786f, -0.17525347f, -0.29505494f, -0.12149284f, 0.01496683f, 
    0.12508371f, 0.19910681f, 0.12943314f, -0.09274269f, 0.05073457f, 0.05546748f, -0.12914234f, -0.02858987f, 
    0.06805198f, -0.20597902f, 0.12293098f, 0.17679666f, 0.08351537f, 0.01906371f, 0.02156247f, -0.08450484f, 
    0.38728264f, -0.04115940f, 0.14820895f, 0.30608273f, -0.12393466f, 0.10530032f, -0.18452469f, -0.06133527f, 
    -0.06976365f, 0.28122658f, -0.10829013f, 0.56519771f, -0.19509934f, -0.20190378f, 0.16016951f, 0.22527757f, 
    0.47892439f, -0.08798564f, 0.27464733f, 0.02621777f, 0.12506178f, -0.01939688f, -0.17957580f, 0.12225863f, 
    -0.00177230f, -0.00795975f, 0.20145755f, -0.06316611f, 0.19657210f, 0.06758333f, 0.02525114f, 0.10786202f, 
    0.18008187f, 0.01625996f, -0.01484029f, 0.10811885f, 0.02934116f, -0.11438940f, 0.03256189f, 0.06797969f, 
    0.09872288f, -0.24695589f, 0.20119609f, 0.09521765f, -0.23229641f, 0.03632476f, -0.08291510f, 0.23614968f, 
    0.09381337f, -0.08801833f, -0.08998893f, -0.02308461f, -0.00328181f, -0.05841020f, 0.05165818f, -0.10881338f, 
    0.08615932f, -0.07545590f, 0.06807240f, 0.05766945f, -0.06358127f, -0.02904080f, -0.16342954f, 0.03915578f, 
    -0.13209063f, 0.23798659f, -0.05689578f, -0.19364060f, 0.08663198f, -0.00927972f, 0.04671626f, -0.09289423f, 
    0.17245544f, -0.48968399f, -0.17137389f, 0.18596230f, 0.07421393f, 0.25442863f, 0.03279204f, 0.28534210f, 
    -0.48051789f, -0.06853554f, -0.30901670f, 0.02955000f, 0.13920920f, 0.08712339f, -0.04156295f, -0.24709116f, 
    0.06346320f, -0.09043176f, 0.24389118f, -0.04166999f, -0.10609423f, 0.07016221f, 0.06887672f, -0.00194661f, 
    0.01720133f, 0.11396321f, -0.00114329f, -0.01195873f, 0.25294742f, -0.08808825f, -0.09327184f, 0.02687070f, 
    -0.26065293f, 0.44730785f, 0.16397209f, 0.15992285f, -0.21671726f, -0.21372192f, -0.07261383f, -0.31275564f, 
    0.05528383f, 0.06578733f, 0.06219888f, 0.02814696f, 0.15456577f, -0.05664090f, 0.06537933f, -0.05948577f, 
    0.17000687f, 0.18496241f, 0.17100480f, -0.06016126f, 0.16602629f, 0.01372992f, 0.01354967f, 0.19786310f, 
    0.03908770f, 0.10740981f, -0.20161243f, 0.28385881f, 0.02693214f, 0.05235400f, -0.13950524f, -0.11565995f, 
    0.22003785f, -0.33085123f, 0.40368751f, -0.17004980f, 0.05546178f, -0.15294035f, -0.16013902f, 0.11274242f, 
    0.16610374f, 0.06745435f, 0.20933470f, -0.08615280f, 0.08675425f, -0.18583418f, -0.11093463f, 0.07016131f, 
    0.33445117f, -0.18046646f, -0.34109592f, 0.05502965f, -0.12482812f, 0.14215848f, 0.15608083f, 0.13504501f, 
    -0.05359760f, 0.04994540f, 0.07111023f, 0.13699335f, 0.16620068f, -0.06370381f, 0.11444137f, -0.06554415f, 
    0.00679990f, 0.06721661f, 0.00610897f, 0.28064957f, 0.16465943f, 0.28118792f, 0.08201548f, -0.19779919f, 
    0.23280749f, -0.00241312f, -0.10195641f, -0.10201834f, 0.12564307f, -0.08631810f, 0.19843356f, 0.28065959f, 
    0.28940925f, -0.26924044f, 0.09904571f, 0.07823170f, 0.10490651f, 0.00301550f, -0.00067748f, 0.34720612f, 
    0.08788639f, 0.09468887f, 0.00270414f, -0.27219006f, -0.24299130f, 0.03504604f, -0.57740378f, -0.08399215f, 
    0.29961810f, -0.12665188f, -0.02048414f, -0.04151205f, 0.13455530f, -0.00513134f, 0.38013926f, 0.05751429f, 
    -0.05321798f, -0.13778974f, 0.08721812f, -0.15976404f, -0.07673212f, 0.04533109f, 0.21627218f, -0.14036250f, 
    0.06723297f, -0.04522036f, -0.02711707f, 0.01532544f, -0.51114184f, 0.19712907f, -0.06325758f, -0.31626657f, 
    -0.10315995f, -0.31111336f, 0.09829295f, -0.00161330f, 0.06133646f, 0.11559539f, -0.08066426f, -0.04959457f, 
    -0.03854909f, 0.45945451f, -0.39161360f, 0.14973202f, -0.02261132f, -0.18169059f, 0.04916319f, -0.58759838f, 
    0.09167243f, 0.03310751f, -0.00053123f, 0.04123345f, 0.16314776f, 0.06984543f, 0.16905420f, 0.25486997f, 
    -0.19680506f, 0.23831096f, 0.08267333f, 0.37770599f, 0.17501073f, -0.09487790f, 0.10547688f, 0.20877557f, 
    -0.06994044f, 0.02221114f, -0.16599202f, -0.21684854f, -0.05891287f, 0.03442154f, 0.22836362f, -0.06512900f, 
    -0.01206664f, 0.25069731f, 0.14545281f, 0.03788060f, 0.05030131f, 0.23933055f, 0.12563922f, -0.18049628f, 
    -0.29902965f, -0.06901830f, -0.10943875f, 0.29766032f, -0.05229478f, 0.35591495f, 0.22242945f, 0.11940390f, 
    -0.16463628f, 0.10576647f, 0.21091278f, -0.10806519f, 0.14004441f, 0.16914672f, -0.21738954f, -0.03645467f, 
    0.14851473f, -0.05793281f, 0.03114841f, 0.09687499f, -0.03701158f, -0.14084536f, -0.04092797f, -0.11430478f, 
    -0.20468101f, -0.09502089f, -0.30927134f, 0.03465340f, -0.01235509f, 0.18672669f, 0.07310418f, 0.34663361f, 
    -0.07134517f, 0.15615252f, -0.01870888f, 0.14289367f, 0.10747346f, -0.06911757f, 0.04064446f, -0.12956797f, 
    0.02788724f, 0.00679223f, -0.12387551f, -0.04034515f, -0.13192752f, 0.05258730f, 0.08666925f, 0.01661509f, 
    -0.03619302f, -0.06389143f, -0.15161335f, 0.02814166f, -0.03132745f, -0.04080880f, -0.03397907f, 0.02859258f, 
    0.09059753f, -0.03248867f, -0.00941510f, -0.03304056f, 0.03817795f, -0.07269678f, 0.07495511f, -0.10376006f, 
    0.05290150f, 0.05998796f, 0.06113171f, 0.00880406f, 0.10121457f, 0.02782780f, 0.01081541f, -0.08625233f, 
    -0.13473488f, 0.02100588f, -0.10670717f, 0.08974825f, 0.00627331f, -0.11611192f, 0.00261021f, -0.11628200f, 
    0.05391643f, 0.05689363f, -0.02643232f, 0.05349506f, -0.03710748f, 0.05493348f, 0.09485433f, -0.08235592f, 
    0.02291423f, -0.05056188f, -0.03748510f, 0.02195961f, 0.02095525f, -0.02986287f, 0.09484354f, -0.05890198f, 
    -0.00525793f, -0.13975292f, -0.05005611f, 0.10489468f, 0.01414848f, -0.06021012f, -0.10234637f, -0.04804524f, 
    -0.03222088f, 0.03563584f, 0.07978014f, -0.09061552f, -0.06697199f, -0.03921501f, -0.10360533f, -0.13294871f, 
    0.01784033f, -0.03336772f, -0.10379317f, -0.03509876f, -0.11688004f, -0.11286637f, -0.00493969f, 0.11362201f, 
    0.06190565f, 0.02683380f, 0.07603442f, -0.03936385f, 0.09179221f, -0.01155798f, -0.11694343f, -0.11202364f, 
    -0.07364324f, -0.08820961f, 0.00735314f, -0.04898402f, 0.06739835f, -0.04149023f, -0.03342572f, 0.06829487f, 
    -0.03850472f, 0.06040963f, -0.05096605f, -0.03636792f, -0.03813895f, 0.05442333f, 0.04185040f, -0.12240920f, 
    -0.04113553f, -0.03737592f, 0.03151046f, 0.11546544f, -0.02840020f, -0.08712648f, 0.04850398f, 0.02806827f, 
    -0.03805649f, 0.06806710f, 0.06793190f, -0.04848789f, -0.10425498f, -0.02041523f, -0.11406620f, 0.10226911f, 
    -0.13488626f, -0.05808651f, -0.11574490f, 0.07535532f, -0.11973666f, 0.04254115f, -0.02642662f, 0.09411559f, 
    -0.10855129f, 0.01164761f, -0.02652644f, 0.46417251f, 0.25085524f, -0.06075026f, -0.07637013f, 0.48626691f, 
    -0.04889803f, 0.21305004f, 0.27208862f, -0.21765432f, -0.02856904f, -0.02366349f, -0.19264506f, -0.04161094f, 
    0.38170880f, 0.13242470f, -0.16637906f, 0.12873903f, 0.18799973f, 0.04645911f, 0.15245728f, 0.26828274f, 
    -0.03255572f, 0.02762429f, -0.16235088f, 0.15464921f, 0.04616572f, 0.03887871f, 0.28549379f, -0.16551395f, 
    -0.12291417f, 0.02068572f, 0.17787461f, -0.06520528f, 0.15506263f, 0.21412496f, -0.30114645f, 0.01205857f, 
    0.05510685f, -0.26776856f, -0.07544733f, 0.03847615f, -0.09071397f, 0.01510808f, -0.07764502f, -0.07776126f, 
    -0.24695677f, 0.32421783f, 0.00812043f, 0.18652211f, -0.21821231f, -0.11286397f, -0.04033950f, -0.08412345f, 
    0.21230753f, 0.20425913f, -0.06206800f, -0.07000408f, 0.10677098f, -0.03961553f, 0.08741011f, 0.07283123f, 
    0.34918684f, -0.07265493f, -0.08741066f, 0.10765428f, -0.07667208f, 0.02248305f, -0.03238796f, -0.40485755f, 
    0.24580821f, -0.00417599f, -0.38738251f, 0.46328050f, 0.23130326f, 0.06501547f, -0.08658276f, 0.03880356f, 
    0.16627552f, -0.14269800f, 0.00590566f, 0.30583504f, 0.51375556f, -0.12884344f, -0.45292321f, 0.03409630f, 
    -0.33713210f, -0.00777941f, -0.03362297f, -0.24654862f, 0.11166427f, -0.07440206f, 0.15556943f, 0.24125132f, 
    -0.14383638f, 0.23247808f, 0.23718862f, 0.05983078f, -0.49957195f, -0.00884172f, -0.47007269f, 0.09551941f, 
    0.18606180f, -0.15542886f, 0.02738614f, -0.06835916f, 0.01930116f, 0.03975219f, -0.02754144f, 0.03299693f, 
    0.28851494f, 0.08459126f, 0.22780445f, 0.15690354f, -0.29544368f, -0.32516286f, 0.04031894f, -0.39940411f, 
    0.18538307f, -0.05839057f, -0.13007520f, -0.09380434f, 0.29132771f, -0.04876420f, 0.03698236f, -0.17201301f, 
    0.08154715f, 0.12547123f, -0.08114707f, 0.13327064f, 0.01455966f, 0.00794627f, -0.34793213f, -0.15615921f, 
    0.42227119f, 0.06877161f, -0.22395042f, 0.47308409f, 0.17728594f, 0.08814721f, -0.15673111f, 0.07979668f, 
    0.02913843f, -0.13082686f, 0.11884449f, -0.07518592f, 0.31918290f, -0.27619177f, -0.05147897f, 0.06603827f, 
    0.30535707f, -0.09308057f, 0.14237346f, 0.05498126f, 0.05133614f, -0.31511939f, 0.34438705f, 0.26943469f, 
    0.10360523f, 0.00977379f, -0.08628389f, 0.07137196f, -0.25507757f, 0.06290961f, -0.32068342f, 0.04430481f, 
    -0.02142428f, -0.03478968f, 0.08321906f, 0.12863909f, 0.01977934f, 0.06050010f, 0.03367268f, 0.05151961f, 
    0.23010476f, -0.09530026f, 0.00904649f, 0.24514431f, 0.24726343f, 0.18631960f, -0.03280993f, -0.13958427f, 
    0.15882659f, -0.16685894f, -0.04591613f, 0.04167385f, 0.23736957f, 0.14465205f, 0.17665575f, 0.04227225f, 
    -0.11686788f, -0.08606285f, -0.06529784f, 0.02734431f, -0.01178310f, -0.04286769f, 0.07512391f, 0.02929568f, 
    -0.00834250f, -0.10204748f, -0.11627945f, -0.09326665f, -0.08670877f, -0.01503243f, 0.00144241f, 0.06579268f, 
    0.00450149f, -0.12209766f, -0.10565276f, -0.03806046f, 0.05188185f, 0.05816673f, 0.08788720f, 0.00921512f, 
    -0.11742985f, 0.09085855f, 0.09939811f, 0.07828632f, -0.10796918f, -0.01303596f, 0.08162674f, -0.13714075f, 
    -0.09935032f, -0.05571192f, 0.05598045f, 0.10386316f, -0.07541239f, 0.00457331f, -0.02493141f, -0.08553606f, 
    -0.08872443f, -0.00966895f, 0.00670213f, -0.05763406f, 0.09320863f, -0.01037094f, -0.01828699f, 0.04540400f, 
    0.09742850f, 0.08848098f, 0.04675142f, 0.06792130f, 0.07510912f, -0.01548570f, 0.11118975f, -0.13053371f, 
    -0.08798943f, 0.04789813f, -0.11294951f, 0.07040575f, 0.01107209f, -0.06657645f, -0.06736287f, -0.11897297f, 
    -0.06242069f, 0.01327274f, -0.02401476f, 0.05087474f, -0.03374531f, 0.11301553f, -0.05128071f, -0.06340241f, 
    0.04550757f, -0.04331431f, 0.08333699f, 0.05008236f, -0.04648320f, 0.05275320f, -0.05707566f, -0.00319058f, 
    -0.10618808f, 0.11751920f, -0.00222237f, 0.01721344f, 0.10430028f, -0.10253714f, -0.02171108f, 0.05078102f, 
    -0.01105478f, -0.06127198f, 0.04677274f, -0.13323487f, 0.02452995f, -0.03038599f, -0.06574868f, -0.07461182f, 
    0.02506984f, -0.07031381f, 0.02285646f, 0.04800199f, 0.08198261f, 0.10647964f, -0.03379239f, -0.04102535f, 
    -0.09759083f, 0.05741456f, -0.01361367f, -0.01875391f, -0.04155446f, -0.05267082f, 0.08777992f, -0.05301234f, 
    -0.06348243f, -0.00732511f, -0.10361847f, -0.09730602f, -0.08169730f, -0.07493342f, 0.09239386f, -0.04940829f, 
    -0.01047386f, -0.10428087f, 0.07773629f, 0.05276248f, -0.06814526f, -0.08010389f, 0.03212398f, -0.01942074f, 
    -0.22006810f, 0.11347036f, 0.00235670f, 0.22920589f, 0.13819408f, -0.05827674f, 0.07967347f, 0.09310206f, 
    -0.06876568f, 0.07931657f, 0.13316487f, -0.46519819f, 0.07388536f, 0.10688210f, 0.28957248f, -0.11552799f, 
    -0.00291982f, 0.01406807f, -0.02041952f, 0.08348536f, -0.09520782f, 0.33823532f, -0.27064875f, -0.03878083f, 
    -0.03542658f, 0.07025766f, -0.11598967f, 0.32894599f, -0.06129895f, 0.30953866f, 0.04385769f, 0.03724246f, 
    -0.04597297f, 0.40286574f, 0.25956711f, -0.05689394f, 0.30631381f, -0.14553502f, 0.06652719f, 0.05548045f, 
    0.22060506f, -0.02009232f, -0.09674306f, 0.20488624f, -0.15596510f, 0.00294959f, -0.00567566f, -0.11225265f, 
    -0.25543252f, 0.00040690f, 0.24662428f, -0.02718691f, 0.06622390f, 0.01191099f, 0.02695016f, 0.44901052f, 
    -0.10811118f, 0.37236571f, 0.06524553f, 0.13314943f, -0.13917367f, 0.09151956f, -0.01342421f, -0.16841619f, 
    0.32783583f, -0.06780108f, 0.04120420f, -0.17086694f, -0.28200457f, 0.04503022f, -0.08756831f, -0.14806059f, 
    0.35217062f, 0.22674507f, 0.08964849f, 0.60316354f, 0.07530577f, 0.13693656f, -0.18170340f, -0.05059033f, 
    0.29880637f, 0.39103496f, -0.22136863f, 0.03471668f, 0.25471967f, -0.27391037f, -0.01699627f, -0.11032077f, 
    0.12844594f, 0.09240312f, 0.33324897f, -0.20112205f, 0.05484075f, -0.36168164f, 0.33108348f, 0.08217283f, 
    0.14139812f, 0.26698050f, 0.21077375f, -0.04382065f, -0.19551550f, 0.11570141f, 0.00885642f, -0.12204873f, 
    -0.10758626f, -0.10563274f, -0.02604038f, 0.14543760f, 0.15183097f, -0.00704596f, 0.05987312f, -0.05341183f, 
    0.37393925f, 0.31128785f, 0.27054790f, 0.00186277f, 0.16467084f, -0.03125605f, -0.02060561f, -0.02998212f, 
    0.30050710f, -0.00347368f, -0.00839136f, 0.12185034f, 0.12391431f, 0.05710278f, 0.06136906f, 0.29525319f, 
    0.17076313f, 0.16313218f, -0.06313588f, 0.46997795f, -0.02955029f, 0.07439832f, -0.16218239f, 0.08849350f, 
    0.41090879f, 0.23016246f, 0.09209514f, -0.13862644f, -0.18759218f, 0.02806174f, -0.15912320f, 0.08685701f, 
    0.20957249f, 0.23453541f, -0.35284227f, 0.44680876f, 0.08261252f, -0.16816397f, 0.11132807f, 0.29764605f, 
    0.00110793f, -0.03886656f, 0.01508824f, 0.10111832f, -0.09235966f, 0.08282556f, 0.11746833f, -0.08609954f, 
    -0.17865205f, 0.00058447f, 0.47297600f, -0.11394541f, 0.37969255f, 0.22959483f, -0.30102849f, 0.14204623f, 
    0.02139915f, -0.31763691f, -0.08602998f, 0.23123533f, 0.06962686f, 0.04217741f, -0.04042609f, -0.04945731f, 
    -0.10262531f, 0.30288282f, 0.03909979f, 0.00899494f, -0.11911254f, -0.28700158f, -0.00968255f, 0.25560006f, 
    0.25566360f, 0.19618170f, -0.12247395f, 0.05614604f, 0.12428289f, 0.04608016f, 0.13277377f, -0.24032883f, 
    -0.15044415f, 0.00357644f, -0.04198213f, 0.14962333f, 0.12119924f, -0.08288953f, 0.16076167f, 0.13867070f, 
    0.20804684f, 0.05970573f, -0.48419005f, 0.08098715f, -0.02286259f, -0.06933882f, 0.13260172f, -0.07978284f, 
    0.11736900f, -0.41070816f, -0.17230998f, -0.11345735f, 0.48068833f, -0.00222998f, -0.25735307f, 0.21074966f, 
    -0.11841652f, 0.08998898f, -0.05270269f, 0.09010483f, 0.06322379f, -0.25824532f, 0.28403270f, 0.28995842f, 
    -0.01843246f, 0.12435523f, -0.08903795f, -0.10529779f, -0.36123613f, -0.15540701f, -0.16999152f, 0.05264292f, 
    0.10866548f, -0.15876184f, 0.08283913f, 0.07994983f, 0.14806063f, -0.01788956f, -0.00101181f, -0.11063778f, 
    -0.04398799f, 0.18616496f, -0.01655188f, 0.09386758f, 0.04751394f, -0.38053861f, 0.05630876f, -0.35646623f, 
    0.14401208f, -0.05792976f, 0.15474099f, -0.02411988f, 0.20859332f, -0.04093460f, -0.11536817f, 0.01148939f, 
    0.24198186f, 0.08984509f, 0.11207590f, -0.29591230f, -0.33932242f, -0.07825087f, 0.01899988f, -0.22521128f, 
    -0.00768212f, 0.05189579f, 0.07708644f, -0.00603827f, 0.21343887f, -0.11690152f, 0.16464859f, -0.09542148f, 
    0.07678206f, 0.08605653f, 0.00051783f, -0.10452500f, 0.01714429f, 0.27792624f, 0.02184503f, -0.10511130f, 
    -0.15439035f, -0.08691081f, 0.03111881f, 0.12971421f, 0.01178303f, 0.10500406f, -0.06446765f, -0.00543799f, 
    0.03444588f, 0.25854215f, 0.29391536f, 0.11469634f, -0.07594588f, -0.10535476f, 0.34776220f, -0.05198504f, 
    0.02005690f, 0.32581180f, 0.03012336f, -0.05694884f, 0.29863897f, -0.08322095f, -0.02888337f, 0.08293794f, 
    0.34040737f, 0.05796865f, 0.29781172f, -0.00509897f, 0.04167434f, 0.01115214f, 0.01239751f, -0.02160743f, 
    0.10760249f, 0.21459813f, -0.08130751f, -0.10762205f, 0.00212573f, -0.01259980f, -0.11228126f, 0.14533588f, 
    -0.05214347f, 0.11202203f, 0.21597511f, -0.29308212f, -0.01981332f, 0.04220784f, -0.05699678f, -0.14775674f, 
    -0.21366715f, -0.02293347f, 0.02937319f, -0.23431456f, 0.17506097f, 0.02836728f, 0.37791771f, -0.11247651f, 
    -0.08277685f, -0.36751899f, 0.33179197f, -0.15379877f, -0.14683758f, 0.11301968f, -0.12924889f, -0.10922370f, 
    -0.03958219f, -0.16288634f, -0.08022351f, 0.20612276f, -0.05790694f, 0.44613418f, -0.26789039f, 0.02267855f, 
    0.09340217f, -0.02249853f, -0.09174597f, 0.07802244f, -0.08789180f, 0.15366288f, 0.25838491f, 0.02258701f, 
    0.20156427f, 0.39373752f, 0.10707410f, -0.07734483f, 0.06699991f, 0.07248941f, 0.00276923f, -0.10086811f, 
    0.03343019f, -0.17688543f, 0.06817838f, -0.00678368f, -0.11284248f, 0.32611993f, -0.06667686f, 0.10310102f, 
    -0.10646296f, 0.27693626f, -0.04898280f, -0.00417851f, 0.00879961f, 0.00394090f, 0.00721000f, 0.13030753f, 
    0.02877215f, -0.05376211f, -0.02502616f, -0.08527899f, 0.07392865f, 0.09958109f, 0.10674779f, -0.00525123f, 
    0.12474370f, -0.09595565f, -0.04515244f, -0.11205851f, -0.08766893f, 0.01366879f, 0.03342490f, 0.11388005f, 
    0.11327659f, -0.11131717f, 0.02015898f, -0.03841916f, 0.00741693f, 0.07537039f, 0.11141630f, -0.08528164f, 
    0.01489231f, -0.03975497f, -0.02947092f, -0.09674715f, 0.05508730f, -0.06482379f, 0.10123479f, 0.01420860f, 
    -0.07640469f, -0.05592538f, 0.03665741f, 0.09379990f, -0.02499817f, -0.12318233f, -0.10775723f, -0.03477833f, 
    0.11466421f, 0.06974083f, -0.09766480f, -0.09252170f, 0.08005580f, -0.09813268f, -0.00901982f, -0.09592573f, 
    0.06394789f, -0.03259173f, -0.06795114f, 0.11656092f, -0.08214152f, 0.00287811f, -0.06084982f, -0.02346151f, 
    -0.09236796f, -0.06311736f, -0.00252542f, -0.10028005f, 0.05454744f, 0.01959850f, 0.06832296f, -0.01788750f, 
    -0.16759202f, 0.11896656f, -0.02356742f, 0.14186881f, 0.13696790f, 0.07572429f, 0.05929183f, 0.15752855f, 
    -0.16979593f, -0.04833448f, 0.40737939f, -0.24088441f, 0.33136672f, 0.06000001f, 0.19865257f, 0.04646849f, 
    0.14233908f, 0.32283178f, -0.07547034f, -0.16292854f, 0.12265797f, 0.11833029f, -0.04387977f, -0.09408884f, 
    0.12679417f, 0.06334455f, 0.07660791f, 0.23263836f, 0.03232478f, 0.10243783f, 0.19201653f, 0.04990733f, 
    -0.16976066f, 0.51346678f, 0.42722145f, 0.04548314f, 0.18781266f, 0.06333811f, -0.05883612f, 0.09899723f, 
    0.22927573f, -0.07404349f, 0.01553665f, -0.06630434f, -0.17414598f, -0.03397361f, -0.02542277f, 0.05347774f, 
    -0.18284190f, -0.10803545f, 0.15328898f, -0.17204493f, 0.03139339f, 0.11611618f, -0.05212335f, 0.49376124f, 
    0.08194441f, 0.18458641f, -0.03253063f, 0.04299459f, 0.07571895f, -0.09478109f, -0.11904138f, 0.01939857f, 
    0.00361375f, 0.08012071f, 0.24837340f, -0.16103914f, -0.42004699f, 0.03494208f, -0.23447721f, 0.02479189f, 
    0.12895903f, 0.11468923f, -0.05033494f, 0.36868250f, 0.11961740f, 0.01080173f, -0.00279825f, 0.09980002f, 
    0.17961738f, -0.21920650f, 0.26248258f, 0.07326387f, -0.01482640f, -0.00161646f, 0.08291595f, -0.19144566f, 
    -0.02476523f, -0.10283718f, 0.00135284f, -0.17148295f, 0.03696762f, 0.29150644f, -0.01713208f, -0.00536471f, 
    0.05786544f, -0.19682239f, 0.02684628f, -0.07837154f, -0.24557438f, 0.09480450f, 0.11875459f, 0.00364692f, 
    -0.02900827f, 0.27059907f, -0.06706689f, -0.16041331f, 0.28081685f, 0.04672645f, -0.10003597f, -0.02711025f, 
    0.26690641f, 0.05270031f, -0.01785423f, -0.01908493f, -0.11256962f, 0.33168432f, -0.05740646f, -0.14390770f, 
    -0.03348714f, -0.04647440f, -0.01134102f, 0.05098811f, -0.16623694f, 0.03940363f, 0.14632720f, 0.08195034f, 
    -0.32205868f, 0.19452323f, 0.24924718f, 0.33008948f, 0.17539960f, -0.09659868f, -0.15561365f, -0.00010847f, 
    -0.03246496f, -0.19152229f, -0.21329740f, 0.23192121f, -0.15393864f, 0.05024546f, 0.11682060f, -0.11393643f, 
    -0.11177042f, -0.03728852f, 0.26729032f, 0.16963848f, -0.14261608f, -0.06506457f, -0.18685071f, -0.12937964f, 
    0.10872003f, -0.00862144f, -0.05145779f, 0.15438285f, -0.07911010f, 0.35018948f, -0.12197808f, -0.04759483f, 
    0.08925362f, -0.44230348f, -0.19786462f, 0.02637844f, -0.00763836f, 0.28096044f, -0.40113723f, 0.07780357f, 
    0.14426756f, -0.00437885f, -0.06229565f, 0.20954324f, -0.12251344f, 0.12495123f, -0.06771517f, -0.10238753f, 
    -0.09529857f, -0.09163830f, -0.27942011f, 0.24330382f, 0.08901615f, 0.51365316f, 0.08158378f, 0.14479576f, 
    -0.28355229f, -0.02066361f, -0.13561006f, -0.03804472f, -0.09689710f, -0.04100981f, 0.31314525f, -0.05491995f, 
    0.23567766f, 0.05968751f, -0.00314834f, -0.42099962f, 0.20175770f, 0.10980006f, 0.36696842f, 0.22318652f, 
    -0.15754795f, 0.05902563f, -0.38128769f, -0.08558597f, -0.13491778f, -0.08190037f, 0.09585502f, -0.10919058f, 
    0.31869471f, 0.18551312f, -0.07412981f, 0.12783748f, -0.14432366f, 0.23454957f, 0.41867787f, 0.29508951f, 
    -0.12794027f, -0.02508207f, -0.10355169f, 0.01501817f, -0.07403541f, -0.11769256f, -0.25228876f, -0.27877426f, 
    0.01309565f, 0.18787821f, 0.21915250f, -0.07480958f, 0.10166997f, -0.28270790f, 0.48986074f, 0.02114928f, 
    -0.15089960f, 0.18587977f, -0.05076046f, -0.12613875f, 0.20776480f, 0.09426465f, -0.00619483f, -0.09569740f, 
    -0.01048617f, 0.20367837f, 0.14961407f, -0.06776374f, 0.04218080f, -0.06932770f, -0.08309885f, -0.04801547f, 
    0.16818929f, -0.03230030f, -0.09572686f, 0.03294119f, -0.22935307f, 0.00668043f, -0.08673879f, 0.23554388f, 
    0.23306157f, -0.04052781f, 0.24470501f, -0.01865255f, 0.04807372f, -0.10424639f, 0.00107815f, 0.07003567f, 
    -0.18440069f, 0.05426053f, -0.28112647f, 0.04728298f, -0.13622367f, -0.03968815f, 0.20637210f, -0.02462412f, 
    -0.06675288f, -0.00213131f, 0.34279743f, 0.14349090f, -0.14497326f, 0.26427653f, 0.18940713f, -0.11510634f, 
    -0.36662024f, -0.15980695f, -0.09880446f, 0.17492676f, 0.05528336f, 0.20954157f, -0.15165345f, -0.06291126f, 
    0.21121733f, -0.21373248f, -0.41254306f, 0.05393980f, -0.28323051f, 0.26567012f, 0.38200176f, 0.02162941f, 
    0.18728121f, 0.24013619f, 0.11237250f, -0.15433869f, 0.00498844f, 0.05777151f, 0.04136702f, 0.10604276f, 
    -0.33317000f, 0.35681066f, -0.40422094f, 0.16322336f, 0.01811505f, 0.07771450f, 0.14598499f, 0.06675406f, 
    -0.01027979f, -0.11646205f, 0.08364014f, 0.02174982f, 0.30736327f, 0.01228574f, 0.17034814f, -0.13830331f, 
    -0.20753579f, -0.00999417f, 0.03231445f, 0.21847770f, -0.11124370f, -0.06198476f, -0.00210022f, 0.12338683f, 
    -0.20891568f, -0.10464070f, -0.19895202f, 0.19632907f, 0.04072192f, -0.09776126f, -0.01552554f, -0.04289506f, 
    -0.18573065f, -0.41384250f, 0.26845366f, -0.14384583f, -0.05291259f, 0.00239556f, 0.13552715f, -0.07998067f, 
    0.09073488f, -0.04915145f, -0.08329669f, 0.10396772f, -0.11692034f, 0.06857712f, 0.23059441f, 0.01396818f, 
    0.01682150f, -0.51484680f, -0.24391377f, -0.00368302f, -0.22153494f, 0.27421066f, -0.19775291f, 0.01885258f, 
    -0.04609688f, 0.10722619f, 0.07731511f, -0.10486235f, 0.10041359f, -0.04827886f, -0.10474888f, 0.02498400f, 
    0.06659453f, 0.16473299f, -0.31400841f, 0.19372287f, -0.01038340f, 0.19037537f, 0.10279800f, -0.29910576f, 
    -0.21511899f, 0.01248098f, 0.09215053f, -0.02648620f, -0.11357471f, 0.02826485f, 0.16820288f, 0.15930191f, 
    -0.09981866f, 0.01417329f, 0.04867637f, -0.11355682f, -0.12043126f, 0.12349412f, 0.05336431f, -0.05831704f, 
    -0.09016398f, -0.08841980f, -0.01302110f, -0.03817072f, -0.07950678f, 0.03908578f, -0.03917215f, 0.07747051f, 
    0.04169323f, -0.12351811f, 0.05255049f, 0.05736703f, -0.09839712f, 0.08650836f, 0.09458997f, -0.04119999f, 
    -0.06033861f, -0.02118412f, -0.12101085f, -0.12265191f, 0.07140918f, -0.07361119f, 0.04648852f, -0.10369605f, 
    0.02076454f, -0.03869851f, 0.10163744f, -0.08883657f, -0.09676477f, -0.04355268f, 0.05303082f, 0.00116239f, 
    -0.11108781f, -0.06007996f, -0.07127775f, -0.12563729f, -0.03436795f, 0.12189066f, 0.01362480f, 0.06391323f, 
    0.06716684f, 0.05883262f, -0.04811234f, 0.04664901f, 0.02380496f, 0.04472313f, -0.04577740f, 0.00711033f, 
    0.07825191f, -0.07993697f, 0.08556893f, -0.02350605f, 0.05995863f, -0.07901883f, -0.06422255f, 0.04341518f, 
    0.05838647f, -0.06597158f, -0.00100139f, -0.11870812f, -0.05673622f, 0.02892962f, -0.00693676f, 0.11527379f, 
    -0.11900230f, -0.03467879f, -0.03115234f, -0.05914763f, 0.02062409f, -0.08367519f, 0.01206997f, 0.09695143f, 
    -0.03428616f, -0.08452000f, -0.02969518f, -0.02290900f, -0.08072069f, -0.01561993f, -0.09098820f, -0.11875768f, 
    0.08045715f, 0.03773519f, 0.05884892f, 0.02774963f, 0.00859252f, -0.12006819f, -0.10771333f, -0.02371664f, 
    -0.06065857f, -0.01916434f, -0.06560364f, -0.06338580f, -0.03469534f, -0.08579032f, -0.10878363f, -0.05790383f, 
    0.11692478f, -0.01130725f, 0.09875423f, -0.07064137f, -0.04693684f, -0.09940535f, -0.10951647f, -0.11602040f, 
    0.05239214f, 0.06652139f, -0.08688653f, 0.05584309f, -0.00185852f, 0.03493652f, -0.07149483f, 0.02152938f, 
    -0.06339812f, -0.02921334f, 0.06497619f, 0.09090067f, -0.05730653f, -0.02439855f, 0.10431479f, -0.07865714f, 
    -0.03530078f, 0.20963486f, 0.31035790f, 0.23046727f, -0.05368990f, 0.01276663f, -0.21493153f, 0.22389796f, 
    -0.21311328f, 0.08460820f, -0.25302866f, 0.02731260f, -0.04359457f, 0.09362189f, 0.21190044f, -0.09173587f, 
    0.02055039f, -0.14323281f, 0.47097945f, -0.20432414f, -0.18544330f, 0.00179352f, 0.04029125f, -0.21331775f, 
    -0.47006810f, 0.08137016f, -0.04866118f, 0.07534444f, 0.11220177f, 0.36070728f, -0.07824107f, -0.16916052f, 
    0.18567750f, -0.21056995f, -0.37112620f, -0.02769487f, -0.26671898f, 0.40415680f, 0.18010353f, 0.08540699f, 
    -0.03540562f, 0.05444692f, 0.05912399f, -0.15042324f, 0.20472333f, -0.07358677f, 0.01337754f, -0.08413386f, 
    -0.29729912f, 0.11721992f, -0.36240971f, 0.08394773f, 0.13183719f, 0.36336046f, -0.08284335f, 0.02186612f, 
    0.00527099f, -0.09432625f, 0.10905133f, 0.05841657f, 0.13205504f, 0.12010837f, 0.24881110f, -0.06191942f, 
    -0.00745882f, 0.19107586f, 0.21987388f, -0.01995344f, -0.20422478f, 0.11248422f, -0.18735811f, -0.31080946f, 
    0.16482376f, -0.04881517f, -0.08722257f, 0.25242245f, 0.35405186f, 0.05478452f, 0.10179812f, 0.05648026f, 
    -0.07298123f, -0.26818705f, 0.28349444f, -0.04970364f, 0.05297985f, -0.14125019f, -0.39961910f, -0.33567086f, 
    0.17124406f, 0.12808427f, -0.01672744f, 0.01166022f, 0.08866891f, 0.24274269f, 0.09707035f, 0.27433234f, 
    -0.06619807f, 0.10594285f, 0.00086481f, 0.10465948f, -0.26056832f, 0.21907695f, -0.11763363f, 0.08624011f, 
    0.15036818f, 0.03044627f, -0.05886574f, 0.16640171f, -0.03317415f, 0.01903302f, -0.03780342f, 0.07519494f, 
    0.24444243f, -0.30198970f, 0.11378038f, 0.11535839f, 0.22737946f, 0.30946618f, -0.14083345f, 0.11561867f, 
    -0.03385202f, 0.04528736f, 0.01954054f, 0.11420601f, 0.14082286f, -0.10808352f, 0.15488704f, 0.10811161f, 
    0.22689360f, -0.04552432f, 0.21990329f, 0.27424622f, -0.06323112f, 0.04665986f, -0.24872090f, 0.00239380f, 
    -0.06171983f, 0.24529773f, 0.21262844f, 0.03349163f, -0.24655502f, -0.11908415f, -0.07976307f, -0.13693404f, 
    0.29007462f, -0.11406922f, 0.09513208f, 0.51619774f, 0.12853111f, 0.15175249f, 0.30565917f, 0.33903018f, 
    -0.33230892f, -0.08242729f, -0.14856207f, 0.04233977f, -0.02150273f, 0.21504544f, -0.07831985f, -0.18637286f, 
    0.09670033f, -0.23043326f, -0.04007623f, -0.00650786f, 0.01129435f, 0.24571712f, 0.04526063f, -0.08494119f, 
    0.01412750f, 0.20054291f, 0.13546403f, -0.06202829f, 0.14150859f, 0.16768149f, -0.05972769f, 0.09986913f, 
    -0.03066855f, 0.29603770f, -0.05967249f, 0.06868623f, -0.47031206f, -0.00565285f, -0.03434064f, -0.18286134f, 
    -0.03489546f, 0.01410162f, 0.02255059f, -0.03669532f, 0.12792809f, -0.01075717f, 0.22253719f, -0.08373968f, 
    -0.26610869f, -0.06749970f, 0.02498466f, -0.11919998f, 0.42114753f, 0.12398180f, 0.05424689f, 0.29304186f, 
    -0.00241507f, 0.04952220f, -0.04920029f, -0.55956340f, 0.08497552f, 0.02056017f, 0.08960006f, -0.13584660f, 
    0.10919923f, -0.22346076f, 0.16077854f, -0.16186468f, -0.08222862f, 0.16134958f, -0.06164609f, 0.04046728f, 
    0.41898784f, 0.02848188f, 0.22944357f, 0.31149125f, 0.02857635f, -0.02454911f, -0.07152978f, 0.11399556f, 
    0.13913178f, -0.02492410f, -0.00018336f, 0.11013417f, 0.18640631f, -0.14686246f, 0.22166167f, 0.00676130f, 
    0.03424402f, 0.05955566f, 0.04899775f, 0.15775280f, 0.02313324f, 0.07251946f, -0.09734283f, -0.12251142f, 
    -0.37435988f, -0.14332941f, 0.14853857f, -0.06517392f, 0.16320360f, 0.25970247f, -0.07102598f, 0.13161457f, 
    -0.09183683f, 0.17450880f, -0.09349270f, 0.04884115f, -0.26805604f, 0.07502721f, 0.07522317f, -0.02644216f, 
    0.04014337f, 0.14484677f, -0.13760090f, 0.08808915f, -0.10600470f, -0.09572126f, 0.12142257f, 0.03421662f, 
    0.09013397f, 0.13697563f, 0.14959767f, -0.13723569f, 0.28525653f, -0.09683070f, 0.05114005f, -0.05740910f, 
    0.16663426f, 0.63450480f, -0.33936974f, -0.17904955f, 0.33364892f, 0.26839814f, 0.13067962f, 0.00476748f, 
    -0.26873785f, 0.13081467f, 0.14185758f, 0.12283817f, -0.01599986f, -0.07269017f, 0.27501190f, -0.01857322f, 
    -0.11135776f, 0.58189547f, 0.27531621f, -0.02411045f, 0.23296608f, -0.21717550f, 0.13334358f, -0.00971489f, 
    0.12441631f, -0.17939685f, -0.16416036f, -0.04515902f, 0.14812560f, -0.04017956f, -0.12689061f, -0.12249830f, 
    -0.12182739f, 0.10294253f, -0.03110690f, -0.24803892f, 0.24008310f, -0.10798536f, 0.01157229f, 0.26022714f, 
    0.16138366f, 0.17471635f, -0.02036328f, -0.05702514f, 0.13247076f, -0.04087391f, -0.26682049f, -0.00308913f, 
    0.12372129f, 0.01506919f, -0.06657592f, -0.02946828f, 0.34396353f, 0.11750765f, -0.06384318f, 0.48032191f, 
    0.15135704f, 0.22277388f, -0.10751365f, 0.05761357f, -0.32530549f, -0.07643323f, -0.33376825f, 0.09305456f, 
    0.37192658f, 0.24079648f, -0.08564491f, -0.19522014f, -0.06279286f, -0.09953795f, 0.30967686f, 0.18497336f, 
    0.43607298f, -0.08346581f, 0.26766661f, 0.07829437f, 0.00279818f, -0.32082248f, 0.08866110f, -0.05221672f, 
    0.24176909f, -0.14533785f, -0.12343465f, 0.12185186f, 0.03913796f, 0.12263365f, 0.21324031f, -0.07942820f, 
    -0.06243548f, -0.13062735f, 0.01323427f, 0.08254658f, 0.03605412f, -0.08510462f, -0.03135506f, 0.03654338f, 
    -0.13727154f, 0.30056754f, -0.16524343f, 0.11229601f, 0.22988316f, -0.13052826f, 0.11207759f, -0.05475333f, 
    0.21621147f, -0.22672667f, -0.10907884f, -0.08994552f, 0.03792574f, -0.00151474f, 0.01037794f, 0.27478588f, 
    -0.04333971f, 0.07485563f, -0.08445904f, 0.01044637f, -0.09926739f, -0.06574562f, 0.11351129f, -0.08763505f, 
    -0.13847096f, -0.01375099f, 0.06469226f, 0.03739164f, 0.01557535f, 0.11722432f, -0.02848266f, -0.00208874f, 
    -0.05237656f, 0.09209499f, 0.08878363f, -0.05898324f, -0.09409626f, -0.09968268f, 0.03369778f, -0.12855133f, 
    0.07051064f, 0.08615930f, 0.01169153f, -0.12284832f, -0.07909459f, -0.02983380f, 0.03642233f, -0.05009402f, 
    0.08431194f, -0.15641774f, -0.04539789f, 0.10166208f, -0.14126571f, 0.09284150f, -0.03466690f, -0.08512315f, 
    -0.17146324f, -0.10269118f, -0.06548604f, 0.01095874f, 0.05017007f, 0.10622245f, -0.00862442f, 0.05866282f, 
    0.07737113f, 0.07462463f, -0.11494922f, -0.10166954f, -0.12905526f, 0.00723394f, 0.02809997f, 0.03042658f, 
    -0.07356460f, 0.07635907f, 0.10185909f, -0.11174121f, -0.03741634f, 0.00944903f, -0.08960627f, 0.04793140f, 
    0.12263190f, 0.03260249f, 0.16417979f, -0.01020434f, -0.02358669f, 0.00363743f, -0.07504739f, 0.39538857f, 
    0.05414000f, 0.17929575f, -0.07294520f, -0.41796750f, -0.23905089f, -0.05592856f, -0.24076575f, 0.04515180f, 
    0.30110359f, 0.09097090f, 0.00567345f, -0.23006882f, -0.09794525f, 0.01998930f, 0.22648349f, 0.00142284f, 
    0.41930723f, -0.03558740f, 0.08144919f, -0.06360488f, 0.01685907f, 0.04995853f, 0.28847075f, -0.28807595f, 
    -0.02613859f, 0.26277283f, 0.51381052f, 0.04001406f, 0.17537093f, -0.00543783f, 0.16868438f, -0.24951799f, 
    -0.31071693f, -0.31984335f, 0.04786183f, 0.12002434f, -0.08120812f, 0.07471406f, -0.07467557f, 0.08373360f, 
    -0.13401972f, 0.25196901f, -0.19254018f, -0.01522987f, 0.06870212f, 0.02203226f, 0.03370243f, -0.14963245f, 
    0.03128526f, 0.09454248f, -0.08462445f, -0.06380894f, -0.34049931f, -0.06475197f, 0.15319575f, 0.32281354f, 
    0.00596675f, -0.04871710f, 0.15585014f, 0.00167186f, -0.18458217f, -0.10769071f, -0.17787066f, -0.11016341f, 
    0.00081205f, 0.01258206f, 0.31886223f, -0.19670723f, 0.14761408f, -0.03452101f, 0.11464250f, -0.10524973f, 
    0.08572730f, -0.22417831f, 0.09396206f, 0.04079742f, -0.09417678f, 0.06623460f, -0.21506047f, -0.06491687f, 
    0.05353174f, -0.08749164f, 0.11999654f, 0.12792993f, -0.01018630f, 0.47365072f, -0.23334518f, -0.07699601f, 
    -0.11479264f, 0.06281350f, 0.42226288f, -0.01789878f, 0.25642294f, -0.01370500f, -0.11564909f, 0.13389577f, 
    0.11098723f, 0.13446592f, -0.04138962f, 0.15130696f, -0.07253265f, -0.03849204f, 0.07867252f, 0.07214665f, 
    0.03966572f, -0.09275170f, 0.42276511f, 0.11730463f, -0.07532618f, 0.35046536f, -0.04766523f, 0.42128658f, 
    -0.16507195f, 0.29087383f, -0.08660457f, -0.01009844f, -0.12246752f, 0.06536907f, -0.01639595f, 0.03464407f, 
    -0.04730185f, 0.16980653f, -0.09792618f, 0.08486974f, 0.10936702f, -0.07202624f, 0.09926739f, -0.08419158f, 
    -0.04020620f, -0.14270699f, 0.03248999f, 0.10805631f, 0.45624253f, -0.09159791f, 0.18800573f, 0.04722128f, 
    -0.00217576f, 0.02657636f, -0.05058171f, -0.10541727f, 0.38738447f, -0.05241391f, 0.05705654f, 0.01471535f, 
    0.12147739f, -0.06157465f, 0.20098022f, -0.02665412f, -0.04404747f, -0.01583920f, 0.08123007f, 0.36888546f, 
    0.00968603f, 0.56649864f, 0.27110416f, 0.01074450f, 0.01131715f, -0.06130588f, -0.15365395f, 0.13790150f, 
    0.25277606f, -0.04165984f, 0.02725493f, 0.14948954f, -0.00189484f, -0.12276658f, -0.02098675f, -0.00783367f, 
    0.07475816f, -0.20163219f, 0.33326301f, 0.07740649f, 0.08706474f, 0.22131220f, -0.09239533f, 0.28072736f, 
    0.09476119f, 0.35747528f, 0.05338090f, -0.00501800f, 0.17206989f, -0.01681503f, -0.12471479f, -0.03472808f, 
    0.51924551f, -0.25018606f, -0.01471663f, -0.14830495f, -0.07850689f, 0.04371345f, 0.04168980f, -0.02999101f, 
    0.11650017f, 0.20773207f, 0.18307766f, 0.38432211f, 0.05466191f, -0.03673794f, -0.04456871f, 0.00484213f, 
    0.23329279f, 0.34790111f, -0.12357849f, 0.38393798f, 0.25473377f, 0.03285064f, 0.13244514f, 0.27410761f, 
    -0.14971559f, 0.09575332f, -0.03320053f, -0.05807806f, 0.10281432f, 0.03669474f, 0.11163842f, -0.10282280f, 
    -0.07296377f, 0.26690727f, 0.24826355f, -0.02763054f, -0.01787011f, 0.10734639f, 0.22041452f, -0.15295327f, 
    0.16361102f, 0.22798963f, -0.01982268f, -0.01308457f, 0.24152669f, -0.01411067f, -0.00388208f, 0.13963529f, 
    0.30741102f, 0.22802536f, 0.22377484f, 0.09918242f, -0.28161418f, -0.21667585f, -0.06065116f, -0.05499336f, 
    0.14916684f, -0.18570320f, 0.03583823f, 0.12280923f, 0.16711055f, -0.02765043f, -0.08699090f, -0.01377257f, 
    0.08851381f, -0.12586185f, -0.09124985f, 0.07013348f, -0.11858046f, 0.02455129f, 0.05200802f, -0.09955336f, 
    -0.02162691f, -0.11028618f, -0.07806969f, 0.04135474f, -0.01388572f, -0.11291814f, -0.05709219f, -0.07110022f, 
    -0.03187928f, -0.12565227f, -0.00827758f, -0.01198721f, -0.14898095f, -0.00290065f, 0.02369494f, 0.00709669f, 
    -0.06710006f, -0.11647455f, 0.06156961f, -0.08437461f, -0.08864036f, -0.11405700f, 0.00384789f, -0.07221571f, 
    -0.03473162f, -0.02389616f, 0.05831744f, 0.10555826f, 0.01198020f, 0.01819546f, 0.01407338f, -0.11995144f, 
    0.08396240f, 0.04229936f, -0.11598195f, 0.00049888f, -0.10314862f, 0.03364362f, -0.12376072f, -0.02182297f, 
    -0.13072138f, -0.04043317f, -0.00672295f, -0.07487104f, -0.04796651f, 0.05934058f, -0.01331162f, -0.14571027f, 
    0.06199108f, 0.08872291f, 0.07024531f, -0.11834951f, 0.05914657f, 0.09634990f, 0.08472783f, -0.12053426f, 
    -0.02466326f, -0.01521101f, -0.13520855f, -0.06171269f, 0.24516091f, -0.10378093f, 0.34868073f, -0.07677968f, 
    -0.06290098f, 0.16083182f, 0.30335447f, -0.29737800f, 0.05237567f, -0.03383367f, 0.25125262f, -0.03744048f, 
    0.01401117f, 0.49024755f, -0.21472161f, 0.23600323f, -0.45579824f, 0.26954594f, 0.30963823f, 0.19906589f, 
    -0.25621769f, 0.10203063f, -0.24166854f, 0.11590938f, -0.06970099f, -0.03532434f, -0.29659620f, -0.11231782f, 
    -0.22218429f, 0.18204477f, 0.13542694f, 0.12402543f, 0.32270426f, 0.00841385f, 0.35559306f, 0.04264369f, 
    0.25998992f, 0.23796789f, 0.05295129f, 0.08357408f, 0.08065570f, -0.12489805f, 0.00684838f, -0.07140134f, 
    -0.11432584f, 0.04280620f, 0.37365866f, -0.17159911f, -0.04301418f, -0.15942688f, -0.08842870f, 0.44383737f, 
    -0.08611767f, 0.09025111f, 0.05915164f, -0.08267888f, -0.03572085f, 0.06809695f, -0.21888599f, -0.11177931f, 
    0.02734325f, 0.10756236f, -0.10989041f, -0.11093830f, -0.16257349f, 0.10843652f, -0.09156015f, 0.06750115f, 
    0.13379665f, 0.00983224f, 0.02661035f, -0.00295471f, 0.21543840f, 0.01940978f, 0.16961223f, 0.02612704f, 
    -0.02735865f, -0.28411338f, 0.16063794f, -0.26146182f, 0.08946565f, 0.17961200f, -0.20890521f, -0.05625085f, 
    0.41840959f, 0.11266357f, 0.17990391f, 0.10630615f, -0.09263039f, 0.17665029f, 0.13397460f, -0.11283568f, 
    0.13963029f, -0.10206243f, 0.28099376f, 0.00388780f, 0.05261135f, -0.16614524f, 0.27748877f, 0.06123812f, 
    -0.18143409f, 0.34021297f, 0.07231481f, 0.12968089f, 0.10663891f, -0.08176146f, 0.05394154f, -0.11735441f, 
    0.18972546f, -0.08876231f, 0.29816854f, -0.10420898f, 0.13520178f, 0.29842305f, -0.09060682f, -0.11149690f, 
    0.03679143f, 0.21646565f, 0.00720755f, 0.07562184f, -0.28819484f, -0.04396872f, -0.00065728f, 0.46626097f, 
    0.07730997f, 0.17348507f, 0.26654923f, -0.18258108f, -0.33916938f, -0.02178675f, -0.00810622f, -0.10148989f, 
    -0.28093895f, -0.03843040f, 0.25066167f, 0.06278034f, 0.29450899f, -0.13688345f, 0.13883843f, 0.00294277f, 
    0.06382879f, -0.05158784f, -0.01271254f, -0.04834837f, 0.20388114f, 0.26120189f, 0.01038782f, -0.15385340f, 
    -0.41996875f, -0.16966863f, -0.22312729f, 0.01859198f, 0.14533229f, 0.38024449f, 0.15038672f, -0.12264005f, 
    -0.13956350f, 0.43581545f, 0.41936654f, -0.11518104f, -0.03882989f, 0.07552078f, -0.07122980f, -0.13149880f, 
    0.04024676f, 0.16580890f, -0.03384412f, -0.09532192f, 0.23455220f, 0.04988585f, -0.00845531f, -0.08938023f, 
    -0.05842266f, 0.11451103f, 0.20874050f, -0.10699009f, -0.03354749f, 0.27040055f, 0.00943063f, 0.25303751f, 
    -0.13694721f, 0.15820555f, -0.09200972f, -0.01288050f, 0.05783904f, -0.01517135f, -0.03385912f, -0.02762126f, 
    0.02554990f, 0.01806730f, 0.24353233f, 0.07215262f, -0.14389558f, 0.03624479f, -0.24325019f, 0.20251144f, 
    -0.06873829f, -0.05428552f, -0.21577159f, -0.40696037f, -0.10993481f, -0.01697978f, -0.16408557f, 0.05064702f, 
    0.22175246f, -0.10004706f, 0.17884381f, -0.29285195f, 0.08612360f, 0.07854361f, -0.02843716f, -0.22266720f, 
    0.47609100f, 0.04736213f, 0.28181696f, 0.00030439f, -0.13956839f, 0.18876921f, 0.37048241f, -0.21019407f, 
    0.14136717f, 0.06384183f, 0.10172116f, -0.07227553f, -0.33241883f, 0.16621034f, -0.14274876f, -0.29533452f, 
    -0.35600701f, -0.13069844f, -0.07650849f, -0.13917288f, -0.13265707f, 0.15745203f, -0.07841321f, 0.10554908f, 
    0.21651514f, 0.27680662f, -0.03718496f, 0.09537065f, 0.23087731f, 0.30385396f, 0.01433010f, -0.01816898f, 
    -0.12193502f, 0.03389727f, -0.08802488f, -0.04359135f, -0.21520458f, -0.07816812f, 0.13526616f, 0.34370610f, 
    -0.24895070f, 0.26843691f, 0.14875035f, -0.16301370f, -0.10268912f, -0.07790153f, -0.08988643f, -0.07699811f, 
    0.01350309f, 0.02127423f, -0.15403229f, 0.08027162f, 0.40694785f, 0.13289726f, 0.17514423f, 0.10867251f, 
    -0.08473763f, -0.18473968f, 0.30425203f, -0.49070445f, 0.33577582f, 0.07549155f, -0.29238614f, -0.24509333f, 
    0.17354272f, 0.07838199f, 0.10754194f, 0.00134682f, 0.09663096f, -0.06068291f, 0.42022789f, 0.29332650f, 
    0.14690360f, 0.19748065f, 0.03905297f, -0.06685133f, -0.16192009f, -0.09256783f, -0.03292772f, 0.16996925f, 
    -0.02956864f, 0.08992501f, -0.07339475f, 0.13018654f, 0.18908866f, -0.02359546f, 0.11925741f, 0.06625292f, 
    0.03245893f, -0.24119969f, 0.02317454f, -0.14154661f, 0.57043380f, 0.51479089f, -0.04781411f, 0.20641798f, 
    -0.05792293f, 0.12696695f, -0.00655455f, 0.09572349f, -0.09820078f, -0.14709517f, -0.11048757f, 0.24255696f, 
    0.12345114f, 0.13480969f, 0.18213712f, -0.16142198f, -0.30484295f, 0.09728014f, -0.13637757f, -0.25030792f, 
    -0.02299904f, 0.11727716f, 0.14371538f, 0.13170552f, 0.13506587f, -0.09782146f, 0.31322560f, 0.04738906f, 
    -0.20282182f, -0.26224324f, 0.35565731f, 0.10604036f, 0.26812726f, 0.05938531f, -0.05859436f, -0.02926455f, 
    0.10352907f, 0.05592562f, -0.09480764f, -0.14318879f, -0.08277952f, 0.21872595f, -0.25020581f, 0.14890461f, 
    0.01147152f, -0.05548100f, 0.33109248f, 0.05156186f, -0.18433978f, -0.04164300f, 0.08239777f, 0.18617928f, 
    -0.03802151f, 0.36369407f, 0.01053933f, -0.14904810f, 0.25757176f, -0.03796153f, -0.08737831f, -0.07339511f, 
    0.24736610f, -0.10494386f, 0.43745574f, 0.07956048f, -0.24759430f, 0.14514212f, -0.07614843f, -0.11746501f, 
    -0.07605765f, 0.23355383f, -0.03675908f, -0.03228935f, -0.09967188f, -0.08257037f, -0.08612643f, 0.24345186f, 
    0.19826151f, 0.00999641f, 0.11323041f, -0.28465554f, -0.12465295f, -0.11724067f, 0.41449773f, -0.05268798f, 
    -0.48088226f, 0.11254279f, -0.47372711f, 0.09118272f, 0.24060850f, -0.01426769f, 0.07641335f, 0.02958768f, 
    -0.03054299f, 0.16493171f, 0.18659160f, -0.03986457f, -0.19571273f, 0.20212351f, 0.79938507f, 0.01675713f, 
    -0.36770275f, 0.08318411f, -0.16226189f, 0.11200400f, 0.02887386f, 0.40224427f, -0.05704832f, -0.28802389f, 
    -0.08344604f, 0.13879697f, 0.03384379f, 0.01001741f, 0.17033097f, 0.05115160f, 0.34195316f, -0.03780137f, 
    0.05379790f, 0.50156647f, -0.13983762f, -0.45557866f, 0.16872194f, -0.11717487f, 0.10812722f, -0.02512905f, 
    -0.09121478f, -0.02980471f, 0.14019638f, -0.22657283f, -0.23901567f, 0.15930113f, -0.01319860f, 0.21390213f, 
    -0.07264627f, 0.24442804f, -0.00108250f, 0.09251976f, -0.16436972f, 0.11744359f, 0.04817582f, 0.04972972f, 
    0.11135680f, 0.00526415f, 0.02496646f, -0.10411651f, -0.04609101f, -0.11931497f, -0.08170417f, -0.11401278f, 
    0.19682734f, 0.13207424f, -0.22301120f, 0.32559088f, 0.24030465f, -0.05499842f, 0.01744862f, -0.11566927f, 
    0.04934102f, -0.03763193f, 0.25703901f, -0.10726339f, 0.08460018f, -0.22169919f, -0.35585162f, -0.16973853f, 
    0.10468378f, 0.04610446f, 0.10780271f, -0.04954987f, -0.12527318f, -0.20440744f, -0.00873482f, 0.31849948f, 
    0.18095468f, -0.08442640f, -0.44196025f, -0.11756331f, -0.09711900f, -0.01997330f, 0.33270049f, 0.15254572f, 
    -0.08587640f, 0.19673131f, 0.02207413f, 0.15494691f, 0.14684598f, -0.02506520f, 0.08834542f, 0.02543804f, 
    0.33054805f, -0.26161119f, 0.14228544f, 0.16000018f, 0.27562544f, 0.16840781f, 0.00377966f, 0.00935040f, 
    0.20724456f, -0.10748298f, -0.03447364f, 0.10202875f, -0.01519458f, 0.12516679f, 0.01967723f, 0.17747240f, 
    0.00707721f, 0.18281496f, 0.10601642f, -0.22151338f, -0.17159331f, 0.09972255f, 0.11413276f, -0.15681973f, 
    0.23110148f, -0.10345758f, -0.12580255f, 0.11892734f, 0.24536933f, -0.05429461f, 0.14585863f, -0.03623128f, 
    -0.18025565f, 0.03226914f, 0.17211936f, -0.28335744f, 0.05569308f, 0.05646730f, -0.40569171f, -0.24885292f, 
    0.33063599f, 0.14826916f, 0.19284615f, 0.07601992f, -0.01781520f, 0.05779427f, -0.03218287f, 0.35188451f, 
    0.16120742f, 0.23420486f, 0.10157306f, -0.07171240f, 0.03422115f, -0.01315757f, -0.00405289f, 0.15293337f, 
    0.04063622f, 0.15189236f, 0.16743381f, 0.05562646f, 0.17618565f, -0.14954004f, 0.09589525f, 0.08664154f, 
    0.27006128f, -0.36124235f, 0.21339764f, -0.01235309f, 0.41489834f, 0.39045930f, 0.00424313f, 0.36895031f, 
    -0.00203183f, 0.03565023f, -0.03640030f, -0.07672026f, -0.12001659f, -0.00106582f, -0.19561067f, 0.11681894f, 
    -0.03907448f, -0.06458088f, -0.08643913f, -0.11440690f, 0.08191867f, 0.05660602f, -0.12153420f, -0.13662601f, 
    0.08286791f, -0.08410076f, 0.01235771f, 0.06561923f, -0.13620472f, -0.04672873f, -0.03226291f, -0.05268785f, 
    -0.13172549f, 0.05721182f, -0.00855276f, -0.12692438f, 0.09486636f, 0.00851522f, -0.08513952f, -0.09993971f, 
    0.00995041f, -0.06383470f, 0.11213814f, -0.01779936f, -0.07660118f, -0.04609150f, 0.02890335f, 0.07510084f, 
    -0.02791227f, -0.09139109f, -0.03204782f, 0.11520140f, -0.05391274f, -0.05310202f, 0.02930556f, -0.11372249f, 
    0.02528553f, 0.06675106f, -0.04668157f, -0.00121541f, -0.11528637f, -0.09818442f, 0.00970072f, 0.06440456f, 
    -0.01093967f, -0.06285792f, 0.04995134f, 0.02458354f, -0.05632528f, 0.05065154f, 0.08752152f, -0.02555743f, 
    0.01035434f, -0.00002801f, 0.00841013f, -0.04127097f, -0.07093917f, 0.05925228f, -0.03479708f, -0.08537024f, 
    0.26339096f, -0.13406633f, 0.07898512f, 0.04716576f, -0.11773111f, 0.02692021f, -0.18352076f, 0.02318353f, 
    -0.18649019f, 0.04220590f, 0.14628580f, 0.08820740f, 0.21326737f, 0.09781087f, -0.10070192f, 0.08538177f, 
    0.41148126f, -0.35169858f, -0.12950097f, 0.14906842f, 0.30493063f, 0.12825404f, -0.04039387f, 0.27361721f, 
    -0.28639010f, 0.06655151f, 0.02349762f, -0.21764468f, -0.06101745f, 0.15731472f, 0.11279404f, -0.00099202f, 
    0.08867747f, 0.26847780f, 0.16082816f, 0.11273964f, -0.24716887f, 0.02150345f, 0.13117902f, -0.01722918f, 
    -0.01559008f, 0.14066021f, -0.10993421f, -0.05459467f, 0.10880359f, 0.04426899f, 0.10639220f, 0.06988046f, 
    0.06403664f, 0.46415001f, 0.32636824f, -0.09207606f, -0.30268016f, -0.35017255f, 0.06812567f, -0.20252456f, 
    0.21044189f, 0.11370904f, -0.04252409f, -0.00745790f, 0.29020470f, -0.07231563f, -0.01538451f, 0.08076849f, 
    -0.25260368f, -0.10026612f, -0.02104618f, 0.19381799f, 0.32606232f, -0.07414742f, 0.30538744f, 0.32350954f, 
    0.07548594f, -0.07820468f, 0.32339227f, -0.06063438f, 0.06640584f, 0.02398442f, -0.26107937f, -0.03178826f, 
    0.06450390f, -0.24105380f, -0.05958792f, -0.04933484f, 0.12226859f, -0.05642696f, -0.59152353f, 0.16142483f, 
    0.46256140f, 0.01953167f, 0.01971856f, 0.12947883f, 0.00620511f, -0.36436015f, 0.17873649f, -0.00656130f, 
    0.04007245f, -0.13201717f, -0.07288901f, -0.00040768f, -0.07526084f, -0.08296160f, -0.30374497f, -0.04013450f, 
    0.03330686f, -0.34148729f, -0.13407293f, 0.10988478f, -0.25512815f, 0.09580602f, -0.08371876f, 0.00912886f, 
    0.19071768f, 0.11746948f, -0.28454140f, 0.21111859f, 0.12982072f, -0.04713056f, 0.00329755f, -0.34471920f, 
    0.07304966f, 0.08263729f, -0.01481759f, -0.08274140f, -0.05466048f, -0.02795753f, -0.05228557f, 0.28437084f, 
    0.00074721f, -0.00095726f, 0.11663199f, -0.05985503f, -0.06287117f, -0.08504091f, 0.00502498f, -0.10010436f, 
    0.19468293f, 0.11620723f, 0.18539616f, -0.15830217f, 0.07367514f, 0.03298090f, 0.25234398f, -0.11311454f, 
    0.06017258f, -0.22600874f, -0.08413835f, 0.15975417f, 0.07347476f, 0.04634257f, -0.28241682f, 0.02399983f, 
    0.25940502f, -0.01989087f, 0.18414272f, 0.15342273f, 0.14147609f, 0.25873101f, -0.17231007f, 0.16993608f, 
    -0.11219379f, 0.28740528f, 0.56875777f, -0.08160900f, 0.27324268f, -0.11216222f, -0.12937340f, 0.22992332f, 
    0.08606611f, 0.01524688f, 0.02347812f, 0.25173798f, -0.13195509f, 0.04055312f, -0.05754530f, 0.09438653f, 
    0.03020368f, -0.15274097f, 0.45550001f, -0.10309091f, -0.20402652f, -0.01313890f, 0.06540045f, 0.43758461f, 
    0.01438772f, 0.37931967f, 0.03635202f, 0.01612061f, -0.02143784f, -0.06125916f, -0.18022747f, -0.11929436f, 
    -0.20530006f, -0.04484735f, 0.05259559f, 0.30643728f, 0.21782696f, 0.12328647f, -0.16464949f, -0.12422352f, 
    0.06026741f, -0.03707266f, 0.21357828f, -0.03192554f, 0.20575300f, -0.03432063f, 0.06133204f, -0.09152080f, 
    0.02162653f, -0.24608694f, 0.24235134f, 0.06206739f, -0.18624257f, -0.21161768f, -0.22091094f, -0.09563916f, 
    0.29055649f, 0.06232248f, -0.06097649f, 0.17839754f, 0.09299252f, -0.01473534f, 0.25072515f, 0.24311672f, 
    0.09053600f, -0.09424590f, -0.18334769f, 0.08934744f, 0.10186287f, 0.26271200f, -0.05642771f, 0.14968832f, 
    0.19394971f, -0.13137107f, 0.07307043f, 0.12204848f, -0.16923898f, 0.05491301f, 0.09879416f, -0.09050373f, 
    0.06390107f, -0.26919109f, -0.18290956f, 0.23192239f, 0.11034287f, 0.23248307f, 0.05284426f, -0.07198445f, 
    0.05269501f, 0.10720298f, 0.11930799f, 0.08172490f, 0.15078913f, -0.09967414f, 0.30163684f, 0.09242705f, 
    0.10722928f, 0.02678743f, -0.03751394f, 0.17070469f, 0.42931524f, -0.03339392f, 0.06582455f, 0.31846029f, 
    0.37156361f, 0.27613321f, -0.03202210f, -0.00567635f, -0.19839995f, -0.14791475f, -0.25741234f, 0.03453832f, 
    0.17946644f, 0.19090194f, -0.24286011f, -0.04045779f, 0.03306850f, -0.09652548f, 0.32314357f, 0.34522593f, 
    0.38487107f, 0.11981142f, 0.12386314f, -0.02564314f, 0.00747020f, -0.31794882f, 0.13190898f, -0.04305088f, 
    0.07096244f, -0.30518776f, 0.06154136f, 0.02204244f, 0.21424730f, -0.01816088f, 0.04575333f, 0.17593658f, 
    -0.06728658f, -0.24006802f, 0.00228910f, 0.16520187f, 0.10090595f, 0.08003814f, -0.10311218f, -0.02105457f, 
    0.00893547f, 0.22947218f, 0.08051630f, 0.15088208f, 0.13785157f, -0.17428711f, 0.09558795f, -0.18631738f, 
    0.31272399f, -0.04183635f, -0.02165033f, -0.11002143f, 0.13644111f, -0.08068040f, 0.18574144f, 0.23316976f, 
    0.02616002f, -0.07307055f, -0.03027984f, -0.20631920f, 0.27034026f, -0.09076658f, 0.21959144f, 0.35322011f, 
    -0.12991309f, 0.22202224f, -0.28693074f, -0.36292014f, 0.03131323f, -0.09514270f, 0.13737716f, -0.01844585f, 
    0.19398044f, -0.23854929f, -0.05724871f, -0.63806117f, 0.19985484f, 0.06070623f, -0.23483738f, 0.01513736f, 
    0.25107259f, 0.02109385f, 0.11580250f, 0.11481590f, 0.01479183f, -0.25030944f, 0.22025938f, -0.03866335f, 
    0.25032869f, 0.07055075f, -0.02588922f, 0.12473020f, -0.03243455f, -0.18897903f, 0.28745010f, -0.04609307f, 
    -0.19724987f, -0.12143939f, -0.06797387f, 0.01293963f, 0.09927804f, 0.04905746f, 0.01631355f, -0.08631909f, 
    -0.08774331f, 0.07923444f, 0.07193215f, 0.07534841f, 0.21489874f, 0.02203652f, 0.03064905f, -0.06501735f, 
    0.15045777f, -0.02377859f, -0.03903748f, 0.05142032f, 0.09667508f, -0.02200449f, 0.07063628f, 0.30137753f, 
    0.08694429f, -0.13904576f, 0.10348395f, 0.14812864f, 0.22960390f, 0.02831739f, -0.10156316f, 0.45311761f, 
    0.13965486f, 0.21261720f, -0.19646999f, -0.01518697f, -0.29705131f, 0.09142776f, -0.25722247f, -0.01058654f, 
    0.15517212f, -0.15851322f, 0.07387697f, -0.03002461f, -0.26050216f, -0.09582530f, 0.17254038f, 0.06404056f, 
    0.43385494f, 0.07272585f, 0.09569528f, 0.10706235f, 0.07135281f, 0.10319670f, 0.12137891f, -0.31271118f, 
    0.10404607f, -0.47947425f, 0.05259500f, 0.06691916f, 0.15839265f, 0.20745276f, 0.23498918f, 0.11049531f, 
    -0.19096921f, 0.01763653f, 0.00130993f, -0.02728278f, 0.11565954f, -0.00255766f, 0.12292274f, 0.00136828f, 
    -0.15600836f, 0.20174073f, -0.14718179f, 0.05709548f, 0.01013629f, -0.05745687f, 0.04672972f, -0.10964800f, 
    0.01849434f, -0.10820130f, -0.02127773f, -0.06127704f, -0.15152220f, 0.05550376f, 0.04362678f, 0.27784038f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.17060824f, -0.03961523f, 0.01524968f, 0.02305557f, 0.01507051f, 0.19529970f, 0.10432909f, -0.06788561f, 
    0.11499668f, 0.02992648f, 0.18959108f, -0.00998507f, -0.03426243f, 0.09403925f, -0.08398642f, 0.14628144f, 
    0.14653887f, 0.09093254f, -0.09885905f, -0.05030156f, 0.12981142f, -0.11021919f, 0.13016182f, -0.10204913f, 
    0.05869078f, 0.26271400f, -0.08409360f, -0.03124277f, -0.04596351f, 0.09215836f, 0.00511581f, 0.06611122f, 
    0.04725190f, 0.04362281f, -0.11717100f, 0.21358022f, -0.01138603f, 0.01521445f, 0.09299790f, -0.17148951f, 
    0.11512347f, -0.03163776f, 0.02831387f, 0.14424512f, 0.21282007f, 0.08149912f, -0.00581196f, 0.00395988f, 
    0.00141230f, -0.02208203f, -0.13350295f, 0.10722852f, -0.03349389f, 0.12908138f, -0.00129392f, 0.05835893f, 
    -0.14104423f, 0.10666098f, 0.04909584f, 0.20742765f, 0.06838173f, -0.07433438f, 0.12333571f, 0.10313352f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.06637609f, -0.40378231f, -0.05807082f, -0.01399191f, -0.08682742f, -0.13637780f, -0.02017105f, 0.28625342f, 
    -0.06349338f, 0.22246787f, -0.11413428f, -0.66356736f, 0.03584760f, 0.11297067f, -0.13266818f, 0.16979343f, 
    0.50175798f, 0.08966526f, 0.01039292f, 0.07618849f, -0.01897600f, 0.07752790f, 0.21700154f, 0.32866535f, 
    0.01655906f, -0.15493774f, -0.07675228f, 0.11458873f, -0.30690902f, -0.36096126f, -0.26938349f, -0.45971057f, 
    -0.33898190f, 0.11667044f, 0.07760820f, -0.44356677f, 0.00871744f, -0.01256728f, -0.22224157f, 0.16214433f, 
    -0.22802746f, 0.02279460f, -0.33535522f, -0.04944510f, 0.21895410f, 0.12599397f, 0.04436540f, -0.22278370f, 
    -0.05356098f, 0.10661126f, -0.58958739f, 0.06177450f, 0.08889157f, -0.30822998f, -0.12749562f, -0.08255696f, 
    -0.14476177f, 0.34152216f, -0.49257734f, 0.20978396f, -0.01122157f, -0.04113616f, -0.16805974f, -0.50649476f, 
    0.07906421f, 0.03286656f, -0.02452801f, 0.12151288f, -0.03711450f, 0.26293525f, 0.07070269f, -0.00023740f, 
    0.08307738f, 0.05761208f, 0.09348171f, 0.28499022f, -0.08689062f, -0.09284464f, -0.13212423f, 0.15483360f, 
    0.27399823f, 0.15536870f, 0.02601542f, -0.07569093f, -0.33099321f, 0.16066553f, 0.01975294f, 0.11759169f, 
    -0.14518501f, -0.29830298f, -0.09198311f, -0.02524648f, -0.18380110f, -0.14838484f, 0.02920276f, 0.14461491f, 
    -0.14288712f, 0.07247040f, -0.06832008f, -0.03999344f, -0.13244173f, 0.20783867f, -0.43524358f, 0.00632293f, 
    0.15589868f, -0.06775257f, -0.39204684f, -0.43774509f, 0.02266447f, 0.25346115f, -0.02115220f, -0.01949763f, 
    -0.53151000f, -0.02257091f, -0.29586041f, -0.32370809f, -0.33769220f, 0.25228536f, -0.07354460f, -0.37898502f, 
    -0.02870392f, 0.26293886f, 0.11377030f, -0.22729011f, 0.05347346f, 0.10687333f, -0.10179794f, -0.06068968f, 
    -0.07128153f, -0.16560422f, -0.12250158f, -0.56849742f, 0.10341243f, 0.04760401f, 0.14500658f, -0.06032524f, 
    0.30111524f, -0.26109633f, 0.22435464f, -0.35217613f, -0.58433682f, 0.09353271f, 0.06759907f, -0.30443221f, 
    0.14127268f, 0.24699773f, -0.11421779f, -0.11727563f, -0.63141316f, 0.25411317f, -0.13882922f, 0.03440664f, 
    -0.00564195f, -0.08766990f, 0.04251994f, -0.36396867f, 0.20176415f, -0.01136956f, -0.17422327f, -0.19760913f, 
    0.05304742f, -0.11157618f, 0.00418243f, -0.18317664f, 0.10998123f, -0.04573335f, -0.05833258f, -0.51431435f, 
    0.03565879f, -0.05527023f, -0.48001724f, -0.13175516f, -0.02519658f, 0.14055602f, 0.10241279f, -0.47278717f, 
    0.22588633f, -0.31326070f, -0.20419566f, 0.11231299f, 0.26567703f, -0.28648654f, 0.30626979f, 0.14265354f, 
    0.03623577f, -0.01396408f, 0.00380605f, -0.01796077f, 0.08669011f, 0.16164020f, -0.11003111f, 0.08270451f, 
    -0.35638288f, 0.21430814f, -0.10536655f, -0.00440379f, -0.00009936f, 0.17429727f, -0.20556512f, -0.10900003f, 
    -0.37241563f, -0.02668876f, -0.07185991f, -0.10063994f, 0.01447723f, -0.01871902f, 0.05206833f, -0.58680952f, 
    -0.28394306f, -0.35970223f, 0.00180674f, -0.01297075f, 0.15106675f, -0.47637591f, -0.72432154f, 0.10138284f, 
    0.27558193f, 0.31162465f, -0.03884587f, 0.08813848f, -0.06746741f, -0.21094586f, 0.10614103f, 0.21160755f, 
    -0.43959764f, -0.02807559f, -0.05882885f, 0.03101441f, -0.00994050f, -0.19180016f, 0.23492835f, -0.01360526f, 
    -0.50292081f, 0.02958026f, -0.29983109f, -0.00716681f, 0.08681263f, -0.03676660f, -0.01151625f, 0.09335506f, 
    0.14855400f, 0.10109130f, -0.10342918f, 0.23220199f, 0.10678712f, 0.26064420f, 0.04655194f, 0.19504146f, 
    -0.12167823f, 0.03755128f, -0.05971076f, 0.08773372f, -0.03767858f, -0.57563382f, 0.13038315f, -0.33655187f, 
    0.01816474f, 0.00195881f, 0.04168151f, 0.08727661f, -0.03185310f, -0.38708088f, -0.14653578f, -0.16658798f, 
    0.02784130f, -0.45144936f, 0.04989768f, -0.07600655f, 0.09743223f, -0.03598912f, 0.09803762f, -0.10924204f, 
    -0.16172275f, 0.02838549f, -0.02052516f, -0.11292616f, 0.08628940f, 0.15651210f, 0.04509144f, -0.41861835f, 
    -0.00615331f, 0.07079972f, 0.08450297f, 0.17520806f, -0.09862851f, 0.09824754f, -0.40938288f, -0.18833140f, 
    -0.50689256f, 0.08269918f, -0.09934752f, -0.00088877f, 0.26341391f, -0.34321180f, 0.00632823f, 0.01584289f, 
    -0.09390362f, 0.00397372f, -0.06390934f, 0.25170344f, 0.22136626f, -0.12682535f, -0.03469979f, -0.15172787f, 
    0.01248552f, 0.03571325f, 0.13050906f, 0.23143952f, -0.10557085f, -0.38392258f, 0.06676370f, 0.26812953f, 
    -0.00297711f, -0.05479495f, -0.61556232f, 0.17759722f, 0.03796384f, -0.17855965f, -0.13558909f, -0.25305364f, 
    0.15085432f, -0.19154702f, 0.07653355f, 0.17680459f, -0.03022217f, -0.22201551f, 0.06531059f, 0.22082098f, 
    0.25848469f, 0.03566276f, -0.14582245f, 0.06458348f, 0.19011937f, 0.04450859f, -0.04590039f, 0.24410059f, 
    -0.33475235f, -0.14826827f, -0.08843307f, -0.05847878f, 0.22757812f, -0.30338728f, 0.28281823f, -0.27161592f, 
    -0.35409245f, -0.10274973f, 0.01349859f, 0.09591561f, -0.35424730f, 0.23747833f, -0.21516511f, -0.06463043f, 
    0.14661056f, 0.07787152f, 0.05528082f, -0.19262291f, -0.16576993f, 0.21747994f, 0.13126999f, -0.18381380f, 
    0.03978987f, 0.05554582f, 0.13676578f, 0.14739451f, -0.08599694f, -0.10594386f, -0.10388937f, 0.32547104f, 
    -0.34909183f, -0.36416498f, 0.26931959f, -0.51650739f, -0.28548104f, 0.06321002f, -0.34095889f, -0.40100721f, 
    -0.09295086f, -0.08715173f, 0.17290173f, 0.21631256f, 0.17687407f, 0.09259520f, -0.27922454f, 0.17519793f, 
    0.32188264f, 0.14680722f, 0.01513777f, 0.17156617f, -0.11483236f, -0.06437759f, 0.04806481f, -0.34163523f, 
    -0.04611408f, -0.25285760f, 0.23987383f, -0.65169227f, 0.21040215f, 0.00279196f, 0.00381830f, 0.02038614f, 
    -0.08420859f, 0.18592311f, -0.03450113f, 0.09044011f, -0.06921675f, -0.20218450f, -0.00796619f, 0.16657040f, 
    -0.50039321f, -0.03576329f, 0.07907893f, -0.06177754f, -0.22613004f, 0.36138082f, 0.06178894f, 0.17567027f, 
    0.17097005f, 0.00412135f, -0.12117814f, 0.29596746f, 0.06032971f, -0.19403081f, 0.11106191f, -0.32240734f, 
    0.13136074f, -0.13928472f, -0.76394659f, -0.28983045f, 0.10041807f, -0.48309770f, 0.10936815f, -0.40142566f, 
    -0.15761703f, -0.62081856f, -0.28690073f, 0.16422302f, -0.24249327f, -0.45329204f, 0.14963266f, 0.02423337f, 
    -0.01242013f, -0.50937659f, -0.07590175f, -0.14229731f, 0.11765774f, 0.11718953f, 0.01023985f, -0.01960797f, 
    -0.24879777f, -0.22228967f, -0.10137575f, 0.22596844f, -0.07442778f, -0.28659838f, -0.45971841f, 0.07688250f, 
    0.19298127f, -0.24975504f, -0.53150398f, 0.17278300f, 0.18000589f, -0.03398247f, 0.02618632f, -0.17696168f, 
    0.04421062f, -0.23567216f, -0.00415569f, 0.06579867f, 0.10084144f, -0.07676772f, 0.02847554f, -0.08811080f, 
    0.13789569f, -0.04658314f, 0.02719368f, 0.16869423f, -0.23329753f, -0.13726719f, 0.24069534f, -0.14557338f, 
    -0.12904073f, -0.09111039f, 0.02103794f, -0.58328098f, -0.42605701f, -0.16000479f, -0.12575576f, 0.23168772f, 
    0.01328612f, 0.03364440f, 0.34612995f, -0.01955352f, 0.14053577f, 0.16911812f, 0.09723455f, 0.29920027f, 
    -0.01501838f, 0.09645095f, -0.44656608f, -0.12871003f, 0.05034997f, 0.14411452f, -0.31545952f, 0.09779608f, 
    0.00584588f, -0.20036168f, -0.05414231f, 0.14915140f, -0.41376650f, -0.06281332f, -0.40303403f, -0.10118707f, 
    -0.15041313f, 0.19262236f, 0.07816181f, -0.14398479f, -0.04682520f, 0.16650501f, -0.13645749f, -0.05121740f, 
    -0.25280941f, 0.24267812f, 0.08969110f, 0.44385564f, -0.16346434f, 0.10659865f, 0.06887706f, 0.06421050f, 
    -0.42571607f, -0.11241941f, -0.06426722f, -0.00276339f, -0.31128800f, 0.16464475f, 0.12142957f, -0.17861462f, 
    0.07679575f, -0.23465493f, 0.09276177f, -0.43348333f, 0.07443355f, -0.30382645f, 0.21087949f, 0.15155061f, 
    0.25520539f, -0.05015166f, 0.03198501f, 0.19017383f, -0.47781920f, 0.17263953f, -0.33126467f, 0.02024314f, 
    0.25581884f, 0.10426988f, 0.48226279f, -0.56891662f, -0.59592015f, 0.17256851f, 0.07956830f, 0.15076423f, 
    -0.03565711f, -0.07715358f, 0.32593364f, -0.16976033f, -0.26753899f, -0.14514972f, -0.00447989f, -0.26325679f, 
    -0.13253862f, 0.14233676f, -0.17222187f, -0.48548537f, -0.23216088f, 0.17732415f, 0.15443940f, 0.23408966f, 
    -0.03490231f, -0.04799993f, 0.05426779f, 0.12008458f, 0.10302933f, -0.22786920f, -0.18858571f, 0.16103464f, 
    -0.18435763f, -0.31445977f, 0.04315603f, 0.00710300f, -0.02527936f, 0.05844408f, 0.02190225f, 0.18715398f, 
    -0.54704708f, 0.05664396f, -0.03830217f, -0.13017270f, 0.08027434f, 0.05849069f, -0.04298864f, 0.18612424f, 
    -0.21800815f, -0.22906403f, 0.03519435f, 0.18312402f, -0.33058256f, -0.20510036f, 0.21846853f, -0.59594363f, 
    -0.12342937f, -0.01791074f, 0.01299286f, -0.30131963f, -0.14045814f, -0.49712047f, 0.28917083f, 0.14082578f, 
    0.25886637f, -0.01182232f, 0.28118652f, -0.12382595f, 0.12472736f, -0.30892745f, 0.01051176f, 0.13822383f, 
    0.20665522f, -0.35722336f, 0.29072696f, 0.22970591f, -0.27295172f, -0.03927900f, -0.06789439f, 0.01456105f, 
    0.06337869f, -0.10658280f, 0.40351987f, -0.00266993f, 0.02588810f, 0.23139326f, 0.35524863f, 0.14445098f, 
    -0.16167262f, -0.36733323f, 0.03647729f, -0.37092003f, 0.05103039f, 0.20106684f, 0.22121206f, 0.14527482f, 
    0.05375230f, 0.25358582f, 0.15937319f, -0.24266540f, -0.19685005f, 0.09971759f, 0.08487250f, -0.05998795f, 
    -0.26302755f, -0.29315662f, -0.06079314f, -0.04456861f, -0.09669524f, -0.15291817f, -0.14922211f, -0.40139392f, 
    0.04496372f, 0.17038423f, -0.03428677f, -0.18709075f, 0.10296437f, -0.19051732f, 0.24147849f, 0.06567869f, 
    -0.22582725f, -0.01186360f, 0.10829811f, -0.00904050f, -0.27049920f, 0.26126602f, 0.07717915f, -0.31853983f, 
    0.08602466f, -0.06974834f, -0.10632448f, 0.10305322f, -0.00583079f, 0.10231429f, -0.07361072f, 0.02799143f, 
    0.13315313f, -0.09207060f, -0.49296966f, -0.23028512f, 0.18792565f, 0.15879513f, -0.08887836f, -0.11797541f, 
    -0.00117152f, 0.24537531f, -0.12742662f, 0.10669310f, -0.22474420f, -0.02943620f, 0.02922335f, 0.19903934f, 
    -0.25073573f, 0.18422577f, -0.09239854f, -0.28623566f, -0.04014302f, 0.08208435f, 0.16968521f, -0.42037213f, 
    -0.31783298f, -0.02167375f, -0.04694776f, -0.04504329f, 0.23796552f, -0.07993332f, 0.01837921f, 0.00084719f, 
    -0.21521963f, -0.07644780f, -0.04213926f, -0.02020472f, -0.10410096f, -0.19208729f, -0.22873992f, -0.37320781f, 
    0.04486008f, 0.15273485f, -0.02792820f, 0.02605637f, 0.25200772f, 0.30860779f, -0.33590364f, 0.13697149f, 
    0.32500309f, -0.06784903f, -0.12051737f, 0.34859943f, 0.14102542f, 0.19148973f, -0.19188091f, -0.30326986f, 
    -0.33281189f, -0.07523193f, -0.02337238f, 0.08495915f, -0.09563851f, -0.11518789f, -0.01780436f, -0.56514060f, 
    0.11265130f, 0.24400970f, 0.32890701f, 0.13356932f, 0.17696010f, 0.09776668f, -0.21251644f, -0.08872663f, 
    -0.02155386f, -0.00580889f, -0.34449717f, -0.15597457f, 0.04553363f, -0.30612543f, -0.21002819f, -0.02037049f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.08968488f, 0.03214489f, -0.03512401f, -0.03097370f, 0.16309603f, -0.03416249f, 0.13516326f, -0.25655213f, 
    -0.05330927f, -0.01683372f, 0.06921660f, 0.00249002f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
