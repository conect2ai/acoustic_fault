#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.76873356f, -0.70594001f, -0.84318101f, 0.27226701f, -0.22424528f, 0.19926290f, -0.16001673f, -0.11059150f, 
    -0.15616308f, 0.53650945f, 0.25470164f, 0.02651195f, -0.74344355f, -0.64888453f, -0.65557313f, 0.14429313f, 
    0.20453009f, 0.26969659f, 0.25068137f, 0.19621326f, 0.31087223f, 0.45799923f, 0.51708448f, 0.53395081f, 
    -0.02410689f, -0.14044501f, -0.09431361f, 0.77820462f, 0.12556997f, -0.20898202f, 0.43542254f, 0.16459852f, 
    -0.12730423f, -0.14411400f, -0.02828313f, -0.16143537f, -0.84821320f, 0.25428846f, -0.43802685f, -0.26929161f, 
    0.38374594f, -0.13990977f, 0.01619067f, 0.20855018f, -0.27692062f, -0.08955154f, 0.64102328f, 0.45381713f, 
    0.27786946f, 0.12119173f, -0.47805324f, -0.16603056f, 0.01659983f, -0.06642512f, 0.52858591f, -0.57953924f, 
    0.37434897f, 0.32979569f, -0.28626877f, 0.02608067f, 0.10433303f, -0.06535160f, 0.34980300f, -0.49760929f, 
    -0.39992648f, 0.53162229f, -0.33025503f, 0.05303081f, -0.30836317f, 0.25505856f, 0.18131956f, -0.13836272f, 
    -0.14214550f, -0.03187169f, 0.02982818f, -0.53581876f, -0.49677169f, -0.58076626f, -0.20380099f, -0.48958078f, 
    0.06447285f, 0.34974793f, -0.16914171f, -0.44412509f, -0.51837593f, 0.49108723f, -0.50197238f, -0.22483669f, 
    0.08990337f, 0.19831163f, 0.39916492f, 0.62299109f, 0.10745864f, -0.26669568f, -0.02212694f, 0.30449679f, 
    -0.47206697f, 0.22448350f, -0.35539916f, -0.56322557f, -0.30539829f, -0.21613088f, -0.10058803f, 0.38292599f, 
    0.65772718f, 0.35633647f, -0.11296000f, 0.33868563f, 0.52422875f, 0.37297657f, 0.66786349f, -0.01178266f, 
    -0.39013854f, -0.14599453f, 0.08760925f, -0.12741503f, -0.18632647f, -0.60380965f, -0.39411458f, -0.14138179f, 
    0.48101473f, 0.77939361f, 0.04180010f, -0.12850213f, -0.19847806f, -0.29563001f, -0.57706237f, -0.67479289f, 
    -0.25435993f, -0.43051639f, -0.36195058f, 0.08349685f, 0.13902290f, 0.16075517f, 0.12487169f, 0.45250401f, 
    0.36101925f, 0.36028782f, -0.05701719f, -0.33133379f, 0.21996062f, 0.18413129f, 0.28030396f, 0.25135794f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.15003204f, -0.00844482f, 0.24154501f, -0.19902316f, 0.31783855f, 0.13546775f, -0.14110975f, -0.11819342f, 
    0.13460673f, -0.06049609f, -0.31119111f, -0.11058792f, 0.01703385f, 0.01244901f, 0.16301052f, -0.15578924f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02276498f, -0.01510899f, -0.35260737f, -0.32084242f, -0.02955597f, 0.07713214f, -0.08531401f, -0.06422526f, 
    -0.04837205f, 0.43661651f, 0.42803362f, 0.13395698f, 0.08017445f, 0.00309132f, 0.00816058f, -0.02545087f, 
    -0.02080568f, -0.01653195f, -0.12752883f, -0.11805889f, -0.02876855f, 0.09915691f, -0.02197730f, -0.15424515f, 
    -0.04417317f, -0.11203273f, 0.14675000f, -0.61898702f, -0.27676696f, -0.08727179f, -0.04912316f, 0.24193849f, 
    0.05922903f, -0.20772651f, 0.00542534f, -0.21208191f, 0.04896227f, -0.10239295f, -0.01346295f, -0.06816322f, 
    0.01429407f, 0.00833623f, 0.11864468f, -0.05769385f, 0.02786380f, 0.04144445f, -0.12322096f, -0.29684597f, 
    0.12032279f, 0.02994954f, 0.14920117f, 0.11969438f, -0.06815357f, 0.08520386f, -0.22787413f, -0.02873158f, 
    0.21560270f, -0.02071892f, -0.00056087f, -0.13059451f, -0.17852038f, 0.15777768f, -0.16361386f, 0.19758496f, 
    0.16337749f, 0.24659827f, -0.09487598f, 0.16964431f, -0.06862085f, -0.10004640f, 0.11698997f, 0.10622858f, 
    0.14984924f, 0.17460895f, 0.14417161f, 0.16746677f, 0.10440909f, -0.09073490f, -0.17990425f, -0.09766427f, 
    -0.01203194f, -0.14830820f, 0.12907831f, 0.00180546f, -0.01436561f, 0.11354972f, -0.00000303f, 0.19683470f, 
    0.06679609f, 0.10450174f, -0.17060201f, 0.06706430f, -0.16788718f, 0.15304500f, -0.13842618f, 0.09074751f, 
    -0.07017724f, -0.15789065f, 0.03623943f, 0.14877930f, 0.03170501f, -0.18445674f, 0.00794491f, -0.16263402f, 
    -0.08952615f, 0.03727663f, 0.08612661f, -0.00488895f, -0.39598045f, -0.13017070f, 0.20552245f, 0.04880161f, 
    0.18698142f, 0.05673976f, -0.15508364f, -0.10590902f, -0.00682396f, 0.06711628f, -0.06747906f, -0.03337077f, 
    -0.11675844f, -0.15822391f, 0.01286545f, -0.01784256f, -0.02930637f, -0.08546142f, 0.02288730f, 0.18635970f, 
    -0.12252306f, 0.06647322f, -0.02865980f, 0.05430944f, 0.15986760f, 0.03418206f, 0.15307993f, -0.41959310f, 
    0.01052076f, -0.05007575f, 0.02640691f, 0.24800484f, 0.04626555f, -0.07255615f, -0.00402364f, 0.06171128f, 
    0.07408892f, 0.24739191f, 0.14927265f, 0.19640686f, 0.31689665f, -0.07719591f, -0.08549739f, -0.03733212f, 
    -0.01927419f, 0.10882930f, 0.09376112f, 0.18771864f, -0.40208745f, -0.07857603f, -0.13237920f, 0.03373920f, 
    -0.18625572f, 0.00995598f, -0.23317711f, 0.09050144f, 0.04986859f, 0.10142929f, 0.16663253f, 0.02903183f, 
    0.18190587f, 0.00951146f, 0.09168509f, 0.13002115f, 0.11872410f, -0.19188215f, -0.13690147f, -0.06813073f, 
    0.19149260f, 0.08627109f, -0.00765161f, 0.00262949f, -0.23280592f, 0.19455005f, 0.24331285f, 0.13641313f, 
    -0.01552630f, -0.02167805f, -0.08469894f, 0.00344809f, 0.10850038f, -0.04959188f, 0.22693978f, 0.24776168f, 
    0.16639946f, -0.05146458f, 0.00452059f, 0.06171202f, -0.06371829f, 0.05307654f, 0.04813045f, -0.30149278f, 
    -0.15681693f, -0.07150315f, -0.10971241f, -0.05400081f, 0.07493797f, 0.14597070f, -0.18435045f, 0.15941416f, 
    -0.06985702f, -0.08842471f, 0.14845017f, -0.08850794f, 0.01285823f, 0.22730933f, -0.12260495f, 0.10818721f, 
    0.18822846f, -0.09982572f, 0.09231293f, -0.01677957f, 0.05284682f, -0.18451829f, 0.21403503f, -0.02071010f, 
    -0.20220917f, -0.14393923f, 0.14885777f, -0.15478118f, 0.00125161f, 0.08769462f, -0.18532762f, 0.03552885f, 
    -0.05452055f, -0.06910080f, -0.29708734f, -0.01393329f, 0.06674628f, -0.03983023f, 0.30345488f, -0.10668071f, 
    0.08675240f, -0.00554054f, -0.16134986f, -0.15568732f, -0.03946716f, -0.21201028f, 0.19900931f, -0.06934769f, 
    -0.19476388f, 0.11403834f, 0.09059633f, -0.04067909f, -0.15182383f, 0.14196026f, 0.09687901f, -0.01150909f, 
    -0.01201362f, 0.02777857f, 0.07970928f, -0.18421631f, 0.17589605f, 0.19522859f, 0.07556872f, -0.07519012f, 
    0.03709544f, 0.01107810f, 0.12281256f, -0.17692733f, 0.05807578f, -0.09667312f, -0.09774956f, 0.01961808f, 
    0.32519391f, 0.19827686f, -0.00625749f, 0.02712414f, 0.08266821f, 0.14009739f, 0.15337089f, -0.26538229f, 
    0.01753730f, -0.03364582f, -0.10202261f, 0.17154770f, 0.09459587f, -0.16015732f, 0.03028850f, -0.05422023f, 
    0.19165763f, 0.05697757f, 0.39670750f, -0.07002193f, -0.10197866f, -0.01261622f, -0.00986387f, 0.05362051f, 
    0.13039874f, -0.18707116f, 0.01626088f, -0.22121553f, -0.03833748f, -0.01468801f, -0.03028140f, -0.18833759f, 
    0.07324073f, -0.12775742f, 0.23838313f, 0.21589270f, 0.15328066f, 0.14338373f, -0.17180321f, 0.00762170f, 
    0.12932062f, 0.05807425f, 0.18654729f, 0.11693078f, -0.11268421f, 0.06314918f, -0.03199767f, -0.04873457f, 
    0.02103404f, -0.20703274f, 0.01756267f, 0.14992920f, 0.06024072f, -0.16052237f, -0.39033040f, -0.05976263f, 
    0.01482881f, -0.00370726f, 0.11444681f, 0.02408115f, -0.07635223f, -0.06883748f, -0.11108480f, -0.23397487f, 
    0.01107728f, 0.21337377f, 0.08749611f, 0.00656366f, -0.07944518f, 0.11279188f, -0.47558373f, 0.06912331f, 
    -0.15522923f, -0.01063756f, 0.11384399f, -0.23167105f, 0.06109592f, -0.06331642f, -0.00608192f, 0.05947632f, 
    -0.23893826f, -0.13061118f, -0.00630067f, -0.09279630f, -0.04630582f, 0.06670834f, 0.02723140f, -0.04671488f, 
    -0.47036305f, -0.17011786f, -0.29398593f, 0.12072323f, 0.13505995f, 0.02155593f, 0.02566512f, 0.08446337f, 
    0.12862165f, 0.21374217f, -0.03790075f, -0.14980398f, -0.01921394f, 0.01460280f, -0.01580912f, -0.08788908f, 
    -0.12705082f, -0.09122961f, -0.11439147f, -0.08818271f, 0.09172564f, -0.07139020f, 0.18879716f, 0.25572276f, 
    -0.10763661f, 0.13443053f, -0.05472915f, 0.40964130f, 0.05546182f, 0.14154992f, 0.13311015f, 0.03478983f, 
    -0.02488095f, -0.02250931f, 0.11110666f, 0.13166362f, -0.22804432f, 0.12341893f, -0.03487647f, -0.06848543f, 
    0.16660747f, 0.10194981f, -0.16465731f, 0.00532234f, 0.06311476f, 0.20694484f, 0.12028676f, 0.00354819f, 
    0.00698709f, -0.15263094f, -0.03561373f, 0.04833276f, 0.11457759f, -0.11227340f, 0.19481379f, -0.11488672f, 
    0.37344229f, 0.05747152f, 0.00982375f, 0.00991880f, -0.01801670f, 0.05892685f, 0.07440154f, -0.35702756f, 
    0.07139929f, -0.02573865f, 0.14545886f, 0.08583315f, 0.10357356f, -0.06885126f, -0.04106684f, -0.04720050f, 
    -0.17645879f, 0.15924253f, -0.08758671f, 0.00603733f, 0.03599408f, -0.00749374f, 0.03341128f, -0.10763901f, 
    -0.06129087f, 0.18972668f, 0.01320567f, 0.08588703f, -0.06649361f, 0.07424308f, 0.05054867f, 0.00279417f, 
    0.07080961f, 0.03585235f, 0.06523553f, 0.14423107f, 0.21188940f, 0.14159475f, -0.01944667f, 0.10423971f, 
    0.18611643f, -0.06950585f, -0.03722100f, -0.14596762f, 0.15294346f, -0.04918997f, -0.23385614f, 0.02729395f, 
    -0.08668014f, -0.13130634f, 0.07442254f, 0.02939857f, -0.11715217f, -0.08833566f, -0.13788441f, 0.11215294f, 
    0.13337849f, -0.05759915f, -0.14729716f, -0.02906373f, 0.02333112f, 0.04455538f, 0.09263240f, -0.04751984f, 
    0.18441884f, 0.03409939f, -0.04149219f, 0.06865790f, 0.04896799f, 0.10377117f, -0.20689368f, -0.15980847f, 
    -0.17209002f, -0.18325596f, 0.00479186f, 0.02163390f, -0.00650730f, -0.06763481f, 0.12084223f, -0.22091568f, 
    -0.26491609f, -0.13625513f, 0.05501880f, 0.04602524f, -0.12533216f, -0.03489883f, 0.20887029f, 0.13853700f, 
    0.06149669f, 0.18501978f, -0.03404006f, -0.05775255f, -0.00558215f, -0.03876675f, 0.14283456f, 0.21296808f, 
    0.24583790f, -0.13716997f, -0.13309310f, 0.02724678f, -0.04755398f, -0.07059322f, 0.10310772f, 0.01073751f, 
    -0.15605973f, -0.00743571f, -0.07906488f, 0.18549547f, 0.22709271f, -0.05629161f, -0.13685964f, 0.09315397f, 
    0.06780936f, 0.05407086f, 0.10252700f, -0.35093731f, -0.26596913f, -0.09500088f, 0.13713822f, 0.09027041f, 
    -0.02401803f, -0.01262682f, -0.13993207f, -0.04005802f, 0.24430509f, 0.08109356f, 0.38892159f, 0.11289851f, 
    0.04144246f, 0.02034717f, 0.07791985f, 0.01749252f, 0.13457976f, -0.14613180f, -0.30656108f, -0.34201044f, 
    -0.00105301f, -0.00919970f, 0.05108402f, 0.13897561f, -0.11028893f, -0.07771842f, -0.18291746f, -0.24899779f, 
    -0.15608504f, 0.22336096f, 0.11045454f, -0.05706137f, 0.02697111f, 0.05423192f, -0.02416444f, -0.13625424f, 
    0.15084064f, 0.00499721f, -0.09822717f, -0.08132201f, -0.02157852f, -0.08794711f, 0.11118090f, 0.04526174f, 
    -0.08542536f, 0.20710258f, 0.06933943f, -0.23047888f, -0.04138690f, -0.07952325f, 0.00497276f, 0.08176021f, 
    0.06658835f, 0.28734547f, 0.09863075f, -0.17191468f, 0.15474917f, -0.09365329f, 0.07015245f, 0.04943873f, 
    0.20108876f, -0.08420423f, 0.05459680f, 0.02984570f, 0.01876443f, -0.01464670f, 0.00960315f, 0.02259141f, 
    -0.09952082f, 0.00722158f, 0.09298608f, 0.24364503f, -0.23726384f, -0.18255295f, 0.05102075f, -0.06494529f, 
    -0.01335699f, -0.01201735f, 0.06799998f, 0.04224010f, 0.20764183f, -0.15061934f, -0.23311311f, -0.07958398f, 
    0.07913409f, 0.02783496f, -0.11930591f, 0.03626978f, 0.03360841f, 0.12483028f, -0.09597304f, -0.00247256f, 
    -0.07597362f, 0.05404563f, -0.10216639f, 0.08862834f, -0.01067983f, 0.10718516f, -0.43872598f, 0.04029012f, 
    0.04315483f, -0.06455069f, -0.03149984f, -0.03467862f, 0.16060476f, 0.00115337f, 0.09033276f, 0.12764454f, 
    -0.36974019f, -0.23892465f, 0.12851579f, 0.14974102f, 0.11412340f, 0.05214293f, -0.14072333f, -0.10079214f, 
    -0.12199020f, -0.10150675f, -0.02486816f, -0.03102028f, 0.12572008f, -0.11151388f, 0.00918974f, 0.09266319f, 
    0.15074183f, 0.38964778f, 0.14308222f, -0.30985761f, -0.04924143f, 0.10289631f, 0.03182832f, -0.08927923f, 
    -0.11853664f, -0.17327040f, 0.21737531f, 0.03317505f, -0.06142841f, -0.09628121f, -0.11481506f, 0.15957378f, 
    -0.07010051f, 0.01534470f, -0.04241380f, 0.10091893f, 0.04249581f, 0.21993162f, -0.30844346f, 0.03915736f, 
    0.01332048f, 0.12272466f, -0.02196901f, -0.12100648f, -0.03167566f, 0.18624343f, 0.08928588f, 0.11602786f, 
    0.09752535f, -0.13277543f, 0.01449093f, -0.07827566f, -0.03501252f, 0.22131011f, -0.39923480f, -0.03619957f, 
    -0.01628257f, -0.08141717f, -0.02695476f, 0.05531213f, -0.03157192f, -0.01439957f, 0.36916637f, -0.00336466f, 
    -0.11285903f, -0.00794423f, 0.13886201f, -0.10803017f, 0.08626588f, -0.02200151f, -0.12540278f, 0.04754426f, 
    0.25165680f, -0.03677763f, 0.00767737f, 0.06420033f, -0.15573621f, -0.01274120f, 0.02113366f, 0.07265695f, 
    -0.22809909f, 0.03265305f, 0.22278991f, 0.08841863f, -0.09158209f, -0.04775481f, 0.03213666f, 0.02116844f, 
    -0.09711251f, -0.00635609f, 0.05827614f, -0.28320882f, 0.12541465f, -0.03585821f, 0.09117680f, 0.05761255f, 
    0.01530236f, -0.02951292f, 0.01876181f, 0.05783383f, -0.11131306f, 0.06154585f, -0.01839495f, -0.13003826f, 
    0.05269507f, -0.09673352f, 0.11842760f, 0.32419541f, 0.07345749f, 0.27448499f, -0.09007619f, -0.05264897f, 
    -0.04833173f, -0.00304257f, 0.03502275f, 0.02804396f, -0.75734597f, 0.02074689f, 0.13293326f, 0.07914461f, 
    0.16306360f, -0.07946098f, -0.05605478f, -0.02576110f, 0.13262796f, -0.11382238f, 0.12294880f, -0.33898973f, 
    0.14518017f, 0.01882997f, -0.11188318f, -0.01174843f, 0.04174020f, 0.10177960f, -0.08458313f, -0.13899921f, 
    0.06509358f, 0.01157780f, -0.00877256f, 0.01995057f, 0.12549984f, 0.00157132f, 0.07053944f, 0.03519497f, 
    -0.19198312f, -0.03654480f, 0.14625108f, -0.07960146f, -0.00831973f, -0.02341284f, -0.07731485f, 0.08398486f, 
    -0.24473254f, -0.00063581f, -0.27860382f, 0.23227960f, 0.06778807f, 0.13785504f, 0.17800711f, 0.14727220f, 
    0.22630243f, 0.19154777f, 0.16532378f, -0.35787919f, -0.07529141f, -0.02050420f, 0.03834601f, 0.07081535f, 
    -0.02610779f, 0.00926219f, -0.05888906f, -0.17021535f, 0.11802474f, 0.04556967f, -0.08108705f, 0.01284648f, 
    0.20843422f, 0.06504044f, -0.09307037f, 0.02269247f, -0.21400426f, 0.22346309f, -0.14960697f, -0.03756788f, 
    0.04156787f, -0.08279064f, 0.04306665f, 0.03316482f, -0.20576064f, 0.08150157f, -0.05079133f, 0.05248541f, 
    0.08958051f, -0.02012361f, 0.02208776f, 0.17117313f, 0.08343383f, -0.22695254f, -0.27762982f, -0.11836622f, 
    -0.06741881f, -0.15782876f, -0.03656774f, -0.07073189f, -0.07475078f, -0.05052847f, -0.05560895f, 0.01216782f, 
    0.16389725f, -0.00524771f, 0.10323499f, -0.02120920f, -0.09285635f, -0.16446640f, 0.09695949f, 0.25748402f, 
    0.36643189f, 0.03701139f, 0.12579109f, -0.01177392f, -0.08337875f, 0.09606338f, 0.04761775f, -0.02100411f, 
    0.16299579f, 0.34179088f, -0.02365307f, 0.07820503f, 0.13912371f, -0.04870774f, 0.04146010f, 0.13181551f, 
    0.02774693f, -0.02468929f, -0.12364461f, -0.16486375f, 0.12054180f, -0.02922219f, 0.10911804f, -0.00269994f, 
    -0.07900786f, 0.03395794f, 0.14454430f, 0.10714419f, 0.10572819f, -0.08743560f, 0.15355738f, -0.15633032f, 
    -0.00284503f, 0.11987182f, 0.03790337f, -0.19838059f, -0.40153879f, 0.04773056f, -0.00614765f, 0.01130831f, 
    0.03018926f, -0.00770891f, -0.08143535f, -0.02902146f, 0.04230717f, -0.09114107f, -0.41386589f, 0.14162001f, 
    0.08852007f, 0.21409716f, 0.14770550f, 0.11175938f, -0.09540574f, -0.10934017f, -0.04026033f, -0.06328852f, 
    -0.11268894f, 0.02028153f, 0.05368645f, 0.00609782f, 0.12218841f, 0.02504306f, -0.41582030f, -0.04175207f, 
    0.09425937f, 0.00503767f, -0.01906714f, -0.03364386f, 0.15026483f, -0.12394168f, 0.18140987f, -0.27246618f, 
    -0.15193477f, -0.14996986f, -0.12317567f, -0.00952347f, -0.01372848f, -0.04856552f, -0.02113220f, 0.01721183f, 
    -0.06262593f, 0.09492249f, -0.04876826f, 0.09740984f, 0.03966371f, 0.17884851f, -0.25701097f, 0.00097172f, 
    -0.08285653f, 0.04953450f, -0.14873777f, -0.13275999f, -0.05287255f, 0.07493052f, 0.17940289f, 0.05955209f, 
    -0.11700851f, -0.04651285f, 0.14047937f, 0.09192006f, -0.07086913f, 0.13242356f, -0.24323328f, 0.00239061f, 
    -0.00463368f, 0.08196732f, -0.05720053f, 0.17300723f, 0.30485791f, -0.12814291f, 0.01728948f, -0.16362779f, 
    -0.07455128f, -0.14405774f, -0.03466021f, -0.07843388f, -0.03758884f, 0.11750192f, -0.05286537f, -0.03570981f, 
    0.01140522f, 0.12801649f, 0.07913166f, 0.04632157f, -0.04726047f, 0.01729999f, -0.08983593f, -0.29875392f, 
    -0.01936560f, 0.03862505f, -0.19890836f, -0.03305404f, 0.07513758f, -0.10025597f, 0.06152381f, -0.04109190f, 
    0.00518045f, -0.10185955f, 0.10246184f, 0.05113666f, 0.09823469f, -0.05200890f, -0.14929703f, -0.01832625f, 
    0.11301678f, -0.09451532f, -0.03988322f, -0.18939981f, -0.01097402f, 0.04011455f, 0.00685316f, 0.15091118f, 
    -0.10591999f, 0.27492967f, -0.20998055f, -0.05527273f, 0.08562031f, -0.23376375f, 0.03855632f, 0.00178650f, 
    0.15112562f, 0.01549748f, 0.08512123f, -0.12673390f, 0.05723568f, -0.07933176f, 0.34249744f, -0.03252548f, 
    -0.11442443f, -0.12825774f, 0.14206329f, 0.15775990f, 0.11981549f, -0.07562528f, -0.10327518f, -0.18001558f, 
    0.05824349f, 0.24531971f, 0.11513482f, -0.10015833f, 0.20314653f, -0.11206314f, 0.14869259f, -0.01755999f, 
    -0.17049277f, -0.12143302f, 0.14360073f, -0.05565994f, -0.17315760f, -0.08388245f, 0.04683574f, -0.02425135f, 
    0.22639611f, -0.06662680f, -0.01376104f, -0.02787765f, -0.09674134f, 0.00266564f, 0.05974121f, -0.05160104f, 
    0.10651735f, 0.07158599f, -0.10353625f, 0.05232634f, -0.07180168f, 0.08854470f, 0.21607877f, 0.03664429f, 
    0.23232837f, -0.00126040f, 0.11593883f, -0.05930219f, 0.08347512f, 0.11134967f, 0.18282180f, -0.07089126f, 
    -0.10171732f, 0.10593867f, -0.07264962f, -0.09416609f, 0.12911698f, -0.03454161f, 0.08053475f, -0.09547001f, 
    0.00634954f, -0.28037292f, -0.04438690f, 0.11760627f, -0.09756158f, 0.05140734f, -0.00424366f, 0.00998356f, 
    -0.16788986f, -0.23200102f, 0.25760832f, -0.19709922f, 0.06863511f, -0.11235987f, 0.03968771f, 0.10230475f, 
    0.04472955f, -0.02640496f, 0.15347365f, -0.28683481f, 0.05886525f, 0.12759519f, 0.12723172f, 0.02492033f, 
    0.16641414f, -0.02561075f, -0.00856303f, -0.12855524f, -0.09951606f, 0.09847736f, -0.13341926f, 0.02889517f, 
    -0.09084405f, -0.01802473f, 0.16089016f, 0.00044203f, 0.17117916f, 0.14818186f, 0.02327634f, 0.04122474f, 
    -0.06071337f, 0.07730506f, -0.13134463f, -0.19607222f, -0.07717538f, -0.18573211f, -0.14729671f, -0.07836872f, 
    -0.07774398f, -0.04129995f, 0.01882262f, 0.06353297f, -0.04748235f, -0.04494509f, 0.10904276f, 0.44649500f, 
    -0.12755434f, 0.10117599f, -0.08534417f, 0.14684202f, 0.03464738f, 0.08220515f, -0.20679912f, 0.39713952f, 
    0.24586508f, -0.02537934f, 0.17250852f, -0.21608633f, -0.06384229f, 0.01798765f, 0.17331235f, 0.25321066f, 
    0.04823746f, 0.07389990f, 0.19126210f, -0.13309583f, 0.08888608f, 0.08420534f, -0.00817170f, -0.01855152f, 
    0.10394134f, 0.33223501f, 0.11350283f, -0.07018034f, 0.18463567f, -0.11485787f, -0.16743198f, 0.14256799f, 
    -0.01817812f, -0.15700990f, -0.34400737f, -0.15097554f, -0.22032112f, 0.04104583f, 0.06066022f, 0.31452969f, 
    -0.09119008f, 0.19766691f, 0.01207594f, -0.05867100f, 0.11768845f, -0.12043156f, -0.00504171f, -0.07771847f, 
    0.06843811f, 0.06929368f, 0.09140740f, -0.10438525f, 0.00068659f, 0.14152883f, -0.01836273f, -0.24027674f, 
    0.05314065f, -0.10141979f, -0.12976721f, -0.02138562f, 0.04319645f, 0.44060436f, -0.19344155f, -0.04987742f, 
    0.05956309f, 0.03388539f, 0.01932608f, 0.09503680f, -0.18594351f, -0.13607275f, 0.05250442f, 0.06965004f, 
    -0.15005967f, 0.18914925f, -0.07654089f, 0.15663487f, -0.00614685f, 0.05445827f, -0.31846231f, -0.06815596f, 
    0.26069069f, -0.09183156f, 0.02701500f, -0.07211935f, -0.03293693f, -0.11741115f, 0.16479847f, 0.05595022f, 
    -0.19200778f, 0.05065516f, -0.16932754f, 0.15673414f, 0.11415296f, 0.15377744f, 0.10303766f, 0.01133596f, 
    -0.03396685f, -0.06689434f, 0.11901435f, -0.06300311f, -0.03267711f, -0.09520303f, 0.01938567f, 0.02900079f, 
    -0.06548002f, -0.10355753f, -0.02307946f, 0.06864716f, 0.11613375f, 0.24675849f, 0.08445344f, 0.02537684f, 
    -0.00939895f, -0.05501346f, 0.15920705f, -0.31026325f, 0.02105840f, 0.04544329f, -0.08773653f, 0.09252741f, 
    -0.05831896f, -0.05154799f, -0.00101828f, -0.04330465f, 0.32974568f, -0.10007577f, 0.07433966f, 0.07627459f, 
    0.04829652f, -0.11940560f, -0.09698864f, 0.14360000f, -0.03798274f, -0.30159360f, -0.02243895f, 0.07634714f, 
    -0.08304099f, 0.04052794f, 0.08844323f, -0.30788767f, 0.05250267f, 0.07704229f, -0.14276977f, 0.15103032f, 
    0.01818526f, 0.02404320f, 0.06398199f, -0.18400683f, -0.10240679f, 0.08327102f, 0.06013912f, 0.20729581f, 
    -0.23746382f, 0.00443830f, 0.24896994f, 0.00166463f, 0.07207289f, 0.02778814f, 0.06417692f, -0.09251662f, 
    -0.02107116f, -0.28032407f, -0.33504683f, 0.03719047f, 0.17271033f, 0.00278716f, 0.02309203f, -0.06642108f, 
    0.01993287f, 0.24255691f, -0.27692840f, 0.28662404f, 0.00923946f, -0.14871956f, 0.02232398f, 0.08993132f, 
    0.07183877f, 0.15112555f, 0.08550414f, 0.03834930f, 0.03077227f, 0.18166479f, 0.06343579f, 0.09745043f, 
    -0.04931851f, -0.08840712f, -0.02919832f, -0.15194142f, 0.11324342f, -0.08076116f, 0.02829828f, 0.19419803f, 
    -0.15660536f, -0.06293007f, -0.04783163f, -0.06415658f, 0.00274139f, 0.06416237f, 0.04363078f, -0.21675511f, 
    0.07679570f, -0.05433329f, 0.01771191f, -0.16971146f, 0.08255285f, -0.12982939f, 0.06326804f, -0.03277731f, 
    -0.08053490f, -0.04913889f, -0.02637661f, 0.10720818f, 0.18006532f, 0.10659930f, -0.17289305f, -0.11817064f, 
    -0.08364570f, 0.12139100f, -0.04647620f, 0.19359298f, -0.02108556f, 0.03569492f, 0.12884921f, -0.03578508f, 
    -0.05678541f, -0.16647759f, 0.00713591f, -0.30735460f, 0.14955074f, 0.11471049f, 0.05139390f, 0.04384572f, 
    0.22969750f, -0.02269514f, 0.01604794f, -0.23560274f, -0.01941479f, -0.11256201f, 0.09910164f, 0.18723901f, 
    0.11265490f, -0.07690135f, 0.02771293f, 0.23602469f, 0.08820418f, 0.03060940f, -0.09692818f, 0.19407798f, 
    -0.05001788f, 0.05407647f, 0.00150149f, 0.05726507f, -0.06657121f, 0.11758583f, 0.14647065f, 0.10820404f, 
    0.14949986f, -0.01635751f, -0.22696775f, 0.11121096f, 0.16047797f, 0.01768167f, 0.05662013f, -0.14767173f, 
    -0.02712816f, -0.08069115f, 0.12870298f, -0.03816499f, -0.32503894f, 0.11089147f, -0.09805574f, 0.14452624f, 
    0.10559156f, 0.07142199f, 0.16701600f, 0.14340384f, 0.11160816f, -0.13170184f, 0.01795999f, -0.04256026f, 
    -0.18964387f, -0.19133361f, -0.02579701f, -0.15376523f, 0.11015660f, -0.02557847f, 0.09445696f, -0.06665982f, 
    -0.17867307f, -0.00811342f, 0.01315304f, -0.25397611f, 0.11753564f, 0.10111790f, 0.06750992f, -0.11379934f, 
    -0.35934266f, -0.19836167f, 0.30806980f, 0.15552028f, 0.04708019f, 0.13018440f, -0.16209677f, 0.15774243f, 
    -0.19462810f, -0.39959484f, 0.48832408f, 0.25511271f, 0.02757638f, 0.10062826f, -0.20791192f, -0.07845509f, 
    0.08568501f, 0.01476168f, 0.11283117f, -0.34295818f, -0.01748672f, 0.04435715f, -0.33734724f, 0.18113697f, 
    0.02240147f, -0.01159228f, -0.09548941f, -0.21586472f, 0.07270909f, 0.09498388f, 0.08180089f, 0.12094214f, 
    0.07911769f, -0.04468285f, 0.04911553f, 0.46725944f, 0.24770649f, 0.15876357f, -0.14911334f, -0.07810174f, 
    0.09446737f, -0.13845246f, 0.14505753f, -0.15241109f, -0.21572390f, 0.27471936f, 0.26345336f, 0.02780771f, 
    -0.09127522f, -0.13704814f, 0.14007625f, 0.15890482f, 0.05711662f, 0.22875696f, 0.11081158f, -0.47264197f, 
    0.10886257f, -0.16028263f, 0.13899457f, -0.03278905f, -0.12221953f, 0.01984077f, 0.22275782f, 0.02248114f, 
    -0.17664333f, -0.17256440f, 0.11188673f, -0.00570797f, -0.10532612f, 0.11203265f, -0.00105043f, -0.01580655f, 
    0.04515189f, -0.31936038f, 0.05888453f, -0.20568676f, -0.10721358f, 0.02907557f, 0.09292141f, 0.13905312f, 
    0.02830007f, 0.14243211f, 0.03045135f, -0.03178251f, -0.06746158f, -0.01299158f, -0.03676905f, 0.04903911f, 
    0.19865182f, 0.18405637f, -0.10519295f, 0.08538781f, -0.25407234f, 0.10716344f, -0.00798984f, 0.00250679f, 
    -0.02898158f, -0.03679053f, -0.14041755f, 0.24123430f, 0.10071829f, 0.05861361f, -0.09069858f, -0.06519429f, 
    0.08034019f, 0.04718894f, -0.12564623f, 0.13090886f, -0.26669723f, 0.04245632f, -0.00118081f, 0.07422791f, 
    0.10009858f, 0.05034778f, -0.18511546f, -0.04415676f, -0.05319195f, 0.05119915f, -0.19207411f, -0.00719538f, 
    0.00098612f, -0.12257838f, -0.03966519f, 0.01067418f, 0.01864314f, -0.10478350f, -0.15910329f, 0.21795829f, 
    0.03340160f, -0.23421244f, 0.16095869f, -0.14751531f, 0.08582137f, 0.14153361f, -0.04607823f, -0.18278870f, 
    0.13021700f, 0.07893343f, 0.01386320f, -0.10587788f, 0.02659732f, 0.05970667f, -0.17057213f, -0.23275243f, 
    -0.10955103f, -0.10075698f, 0.01163912f, 0.00262730f, -0.01030934f, -0.00543680f, 0.05631242f, -0.17298757f, 
    0.24533275f, 0.32169330f, 0.22911306f, 0.14532900f, 0.04643616f, 0.09379844f, 0.01141566f, 0.32906336f, 
    -0.00675281f, 0.05306855f, -0.22565478f, -0.10314588f, -0.03898579f, -0.11271600f, -0.00814449f, -0.08264109f, 
    -0.14134006f, 0.04446708f, -0.03787858f, -0.05048841f, -0.06236117f, 0.04452745f, 0.04004264f, -0.04647930f, 
    0.06630001f, 0.22111830f, 0.05660294f, -0.10911696f, 0.09170434f, -0.05261581f, -0.03393999f, 0.18939890f, 
    -0.15177356f, 0.09062804f, -0.03636925f, -0.01355787f, -0.09418014f, 0.22240013f, 0.06013148f, 0.03873328f, 
    0.04923413f, -0.01866222f, 0.00940329f, -0.10426668f, -0.12134103f, 0.01892816f, -0.06409053f, -0.13158947f, 
    0.01160495f, -0.01510266f, 0.02012883f, -0.12773761f, 0.02629739f, 0.02224491f, -0.08383819f, 0.03024316f, 
    -0.14789338f, -0.01347085f, -0.01201589f, -0.05119672f, 0.02140782f, -0.00223561f, 0.03140837f, -0.01835009f, 
    0.31845155f, 0.05867000f, 0.07129119f, -0.28218365f, 0.03105781f, -0.04466844f, 0.08507524f, -0.02342561f, 
    0.08219469f, -0.04406629f, 0.06731515f, 0.10439952f, 0.08353045f, 0.02705081f, 0.07274733f, -0.04263636f, 
    0.00160818f, -0.21891600f, -0.21877602f, -0.05315339f, 0.11803105f, 0.07432888f, 0.03944558f, -0.08462269f, 
    0.03591247f, -0.16393471f, -0.24751469f, -0.02814821f, -0.09791462f, 0.00111638f, -0.18973225f, -0.10518296f, 
    -0.07544748f, -0.05920450f, -0.12882918f, 0.01638239f, 0.21129605f, 0.15897526f, 0.06084691f, 0.09215980f, 
    -0.06811886f, 0.07991434f, 0.03918555f, 0.05204836f, -0.37799376f, -0.21248543f, 0.04586570f, -0.09090316f, 
    0.02906539f, 0.17236777f, 0.03584485f, -0.00434317f, -0.09178445f, 0.35870308f, 0.25899878f, -0.08325945f, 
    -0.05466942f, 0.13078897f, -0.12471911f, 0.05607830f, 0.07438994f, -0.01558980f, -0.14982635f, 0.08767700f, 
    0.02217848f, -0.13046370f, -0.01346124f, -0.25227958f, 0.02764914f, 0.07143207f, 0.05295928f, -0.31422332f, 
    -0.40666562f, 0.14544013f, 0.15818147f, -0.19600379f, 0.06811380f, -0.00286859f, 0.16392459f, 0.10114092f, 
    -0.12610394f, 0.20372014f, -0.28400391f, 0.13014232f, 0.03346162f, 0.07721476f, 0.08462790f, 0.16300543f, 
    0.04814478f, -0.00943396f, -0.10461941f, 0.08076546f, -0.20364334f, 0.02828190f, -0.00146634f, 0.02426143f, 
    0.00500191f, 0.04856928f, 0.03515807f, 0.16583641f, -0.17418019f, -0.11469241f, -0.02031291f, -0.02085391f, 
    0.19506337f, 0.16813833f, 0.18246520f, 0.30601385f, 0.07441832f, -0.12021791f, -0.23807503f, -0.17582001f, 
    -0.17443183f, -0.04766203f, 0.21532187f, 0.13761777f, 0.39148745f, -0.03538242f, 0.05447577f, 0.15310477f, 
    0.03092522f, -0.01253075f, -0.02826617f, -0.24934790f, -0.14154164f, -0.18659429f, 0.15842929f, 0.16626740f, 
    0.03514479f, 0.02292850f, -0.08215471f, 0.01516895f, 0.28979644f, -0.02020319f, 0.19650383f, -0.06397028f, 
    -0.09291452f, -0.02095499f, 0.24797714f, 0.02813192f, -0.08676387f, -0.05949995f, 0.06611126f, -0.52865446f, 
    -0.34341070f, -0.12933642f, 0.05177464f, -0.05919957f, -0.03453432f, -0.16563492f, -0.00698695f, -0.09423645f, 
    0.09936374f, -0.11417449f, 0.13559450f, 0.02393257f, 0.19263208f, -0.08209248f, 0.06350777f, 0.11390508f, 
    0.03625317f, -0.26530641f, -0.31399727f, 0.12609538f, 0.00143696f, 0.01439018f, 0.23091632f, -0.07105567f, 
    0.01928763f, -0.17013396f, -0.01590634f, 0.07104003f, -0.07181545f, -0.24523628f, 0.10908507f, -0.11208540f, 
    0.03292140f, 0.00048866f, 0.18771298f, 0.06268451f, 0.35529479f, -0.08048678f, 0.06854981f, -0.02459828f, 
    -0.09596406f, 0.07390621f, 0.02194573f, -0.15563014f, 0.02251092f, 0.09595163f, 0.04573307f, 0.00031797f, 
    -0.11083370f, 0.02616496f, 0.07750642f, -0.04170339f, -0.10106155f, 0.34796602f, 0.12912612f, 0.14118922f, 
    -0.02722931f, 0.04252657f, -0.05163439f, 0.01816170f, -0.06548687f, 0.04244173f, -0.41932875f, -0.20850700f, 
    0.05296385f, 0.02760033f, -0.06199800f, -0.08877767f, 0.00499992f, 0.05764489f, -0.04097307f, -0.06926865f, 
    0.10214911f, -0.21945475f, -0.04270803f, -0.23853382f, -0.11015065f, -0.16020358f, 0.05158940f, -0.05393089f, 
    -0.07389196f, -0.04636821f, 0.06730354f, -0.03638968f, 0.04089868f, -0.02193944f, 0.03259224f, -0.02809049f, 
    0.06912987f, 0.04320281f, -0.05624433f, 0.03264588f, -0.07516029f, -0.07678798f, 0.03808121f, -0.03734040f, 
    -0.00645404f, 0.05015250f, 0.04298657f, 0.01864547f, -0.04585611f, -0.00588309f, -0.08660797f, -0.02261021f, 
    -0.08722756f, -0.01396067f, -0.01659476f, 0.03015354f, -0.02981878f, -0.08143653f, -0.01620474f, 0.05649683f, 
    -0.03855015f, 0.01140505f, -0.06341097f, -0.05322254f, 0.05845518f, 0.02652408f, 0.01102497f, -0.06314950f, 
    -0.06606419f, -0.08537685f, -0.04932927f, -0.01993850f, -0.06550885f, 0.04221907f, -0.04409538f, -0.03708140f, 
    -0.00848385f, -0.04628932f, -0.07818703f, 0.05625537f, 0.06531272f, 0.05011287f, -0.04394647f, -0.08811514f, 
    -0.05399278f, -0.04807238f, -0.03409535f, 0.00394304f, -0.08495724f, -0.04090115f, -0.05809453f, 0.06399187f, 
    0.04023944f, -0.05245482f, -0.06844231f, 0.05128045f, 0.05249710f, 0.07143844f, 0.01703448f, -0.00887282f, 
    0.02712956f, -0.05720457f, 0.06436688f, -0.07186107f, 0.08034714f, 0.04460876f, -0.07078330f, 0.04364923f, 
    -0.07021184f, -0.04982170f, -0.07452120f, -0.02842129f, -0.01326777f, 0.03353051f, 0.01556133f, -0.08141377f, 
    0.04316093f, -0.00566460f, 0.04893552f, -0.00302882f, -0.02516392f, 0.02154685f, 0.00854654f, -0.06612610f, 
    0.06119023f, 0.07184429f, 0.03699465f, 0.00906659f, -0.07656810f, -0.04838587f, -0.04948208f, -0.06039254f, 
    -0.00420440f, 0.07407974f, -0.06746104f, -0.01012897f, -0.06966142f, -0.03516038f, 0.04934950f, -0.03171240f, 
    0.06656358f, 0.00641570f, -0.00283414f, -0.00420206f, -0.00593758f, 0.04026040f, -0.03934189f, -0.04021516f, 
    -0.07800792f, -0.03355047f, 0.04179469f, 0.03770299f, -0.03845496f, -0.00191102f, 0.03682579f, 0.00112475f, 
    -0.07414759f, -0.01705184f, -0.04011861f, -0.05511047f, 0.01360982f, -0.00695974f, 0.00807833f, -0.03002403f, 
    -0.03120000f, -0.06396466f, 0.01592514f, -0.02753687f, 0.05164120f, 0.00941288f, 0.04786395f, 0.03895681f, 
    -0.08020115f, 0.02257124f, 0.05540087f, -0.08422329f, 0.01994046f, -0.02483998f, 0.05200272f, 0.07446457f, 
    0.05022124f, -0.03865546f, -0.04154733f, -0.06577595f, -0.06680109f, -0.08549636f, -0.07983367f, -0.06178021f, 
    0.04888462f, -0.07855622f, -0.00983276f, -0.02404287f, -0.02678128f, 0.06260999f, -0.06318880f, 0.06201908f, 
    -0.02402626f, 0.02866128f, 0.03039676f, -0.07436504f, 0.05335832f, 0.04573237f, -0.02565930f, -0.04992794f, 
    -0.00248460f, -0.06421886f, -0.00670667f, -0.06894344f, -0.03735437f, -0.01029966f, -0.08527093f, 0.02577749f, 
    -0.07259713f, 0.04398013f, -0.07948423f, -0.08621687f, -0.05988315f, 0.01837699f, -0.07414053f, -0.07871354f, 
    0.02585904f, 0.00923672f, -0.00043869f, 0.06115668f, 0.03473168f, -0.00517722f, -0.05398852f, 0.05678260f, 
    0.02592600f, -0.01132345f, 0.01828901f, -0.05287062f, 0.03879879f, 0.06077916f, -0.00807928f, -0.07395903f, 
    0.03095861f, 0.00103574f, -0.03975162f, -0.00039496f, -0.01529483f, 0.03848141f, -0.04253010f, -0.05791373f, 
    0.07111088f, 0.08328672f, 0.00205257f, -0.04522302f, 0.06723843f, 0.02713250f, 0.05326680f, -0.04758880f, 
    0.01557049f, -0.04011246f, -0.05282028f, -0.07289361f, -0.00114081f, -0.05648018f, 0.05669192f, -0.04116191f, 
    0.00301366f, 0.05233854f, -0.08348683f, 0.00069203f, -0.04703404f, 0.03556503f, -0.09370412f, -0.05699081f, 
    0.04433736f, -0.02239237f, -0.01430442f, -0.07028514f, 0.00678063f, 0.01381753f, -0.08068501f, -0.00193713f, 
    0.03049439f, -0.06430168f, -0.08861651f, -0.04724453f, 0.00055645f, 0.02710426f, 0.03729053f, -0.03802731f, 
    -0.07568129f, -0.03540495f, -0.07972808f, 0.06649560f, 0.07232065f, -0.07317533f, 0.01364397f, 0.04928551f, 
    0.05424234f, -0.01071385f, 0.05766340f, 0.04961630f, 0.05456564f, 0.04543569f, 0.01266631f, 0.00603543f, 
    -0.05843503f, -0.01279499f, -0.06100007f, -0.08799045f, 0.01786817f, -0.07914608f, 0.03733048f, -0.08123297f, 
    0.01188760f, -0.04725972f, -0.04316315f, -0.00757801f, -0.05336637f, 0.02789051f, -0.07766815f, 0.04029071f, 
    -0.01100779f, -0.22407131f, 0.11540902f, -0.09773185f, -0.01234599f, 0.04150358f, 0.01371684f, -0.18555458f, 
    0.14911896f, -0.05291752f, -0.04887164f, 0.12261040f, 0.04463881f, 0.07906333f, -0.25010350f, -0.00186873f, 
    0.02310643f, 0.15002763f, -0.56646639f, 0.03006525f, 0.12036615f, -0.10415281f, 0.00162196f, 0.14315638f, 
    -0.03709378f, -0.15553734f, -0.03276146f, 0.11869937f, -0.05486832f, 0.00876444f, -0.07568847f, -0.09002324f, 
    0.11901265f, -0.07229813f, -0.02488505f, -0.18029702f, 0.18953034f, 0.10612598f, -0.15418875f, -0.19646615f, 
    -0.05438848f, 0.12975246f, -0.03572872f, 0.00737505f, 0.08926687f, 0.31131777f, 0.08159891f, 0.09369102f, 
    0.02150431f, -0.00291667f, 0.15855104f, 0.12975031f, 0.08610613f, -0.00546651f, 0.02548737f, 0.10779437f, 
    -0.03573066f, 0.07221040f, 0.13180314f, -0.00580048f, -0.22558081f, 0.27108273f, -0.00519006f, 0.18227798f, 
    -0.15787321f, 0.08347364f, -0.11069497f, -0.25170568f, -0.16784517f, -0.10998673f, -0.08158879f, -0.15684699f, 
    0.01099693f, 0.05411202f, 0.14332521f, 0.11238872f, -0.09142210f, -0.08505332f, -0.15778090f, -0.01338550f, 
    -0.02051681f, 0.21114030f, -0.10704602f, 0.15428120f, 0.03807530f, -0.02181088f, -0.05311643f, 0.06381208f, 
    0.10122462f, 0.03398914f, -0.40239498f, 0.28988820f, -0.01782227f, 0.10336649f, 0.10408994f, 0.13428612f, 
    0.10517246f, -0.08470251f, -0.00105306f, 0.19975387f, -0.03422825f, -0.20311543f, -0.05945881f, 0.17349538f, 
    -0.10173067f, -0.12262116f, -0.11083726f, -0.12193862f, -0.09154551f, 0.05908546f, 0.26907766f, -0.00638378f, 
    0.09639897f, -0.01456184f, 0.21222450f, -0.01189751f, -0.16370603f, 0.16074477f, -0.13508366f, -0.08235586f, 
    0.06099343f, -0.07320349f, 0.00401589f, 0.05131804f, 0.12699001f, -0.00428164f, 0.06181592f, -0.06317759f, 
    0.18201761f, -0.01904663f, -0.00645826f, 0.15480639f, 0.04033536f, -0.02640534f, -0.01854157f, -0.37310103f, 
    0.04164194f, 0.25291783f, -0.06855369f, 0.16933332f, 0.06489687f, -0.20391671f, -0.07013849f, -0.16495337f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.07503864f, 0.08062544f, -0.02826016f, 0.09485466f, 0.14407854f, 0.24167147f, 0.20453610f, 0.07313825f, 
    -0.04074126f, 0.18071161f, 0.10144105f, -0.09972357f, 0.00870633f, -0.08776526f, 0.04707775f, -0.01438165f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.33707407f, 0.06511448f, -0.43676823f, -0.19585820f, 0.03497733f, -0.27902168f, -0.07736580f, 0.08127416f, 
    0.55902684f, -0.03276538f, -0.08307397f, 0.05932200f, 0.57820851f, 0.14356619f, 0.13038453f, -0.13867386f, 
    -0.34186390f, 0.39259315f, -0.03776436f, 0.32740423f, -0.29580116f, -0.10597824f, 0.16668779f, -0.14876483f, 
    -0.31738675f, -0.08069848f, -0.08342730f, 0.15776615f, 0.26367110f, 0.23601437f, 0.07874647f, 0.20192344f, 
    -0.04162287f, 0.23201458f, 0.05143379f, 0.16650757f, -0.07338893f, -0.03200258f, 0.43718252f, 0.21168433f, 
    -0.10171853f, 0.13515922f, -0.55151159f, 0.34039003f, 0.08038458f, 0.01649681f, 0.14896215f, -0.44498605f, 
    0.37910452f, -0.21157253f, -0.54351860f, -0.27539167f, 0.18219718f, -0.41433123f, 0.10781770f, 0.30106089f, 
    0.11300011f, 0.37113720f, 0.28578725f, 0.18335316f, -0.27748567f, -0.19787318f, -0.23925038f, 0.13422246f, 
    -0.23223856f, 0.02623709f, 0.26196921f, -0.16855375f, 0.49869621f, 0.16320011f, -0.29727519f, 0.23295982f, 
    0.46288490f, -0.34201288f, -0.05507584f, -0.37472147f, 0.06311561f, -0.16958052f, -0.18148747f, -0.24329963f, 
    0.25801966f, -0.18653269f, -0.28926450f, 0.36899248f, 0.16556013f, 0.69520646f, -0.13370509f, -0.07033566f, 
    0.14984399f, -0.00531710f, 0.46982488f, -0.00885036f, -0.12750567f, 0.04598045f, -0.06418884f, 0.02388120f, 
    -0.18411793f, 0.14320002f, 0.31023154f, -0.38628688f, -0.38588837f, 0.25653455f, -0.37972105f, 0.25643900f, 
    -0.11552266f, 0.17324188f, 0.19804887f, 0.18261917f, 0.26736230f, 0.02654609f, 0.09655428f, -0.05678496f, 
    0.01850160f, -0.20363265f, -0.43805391f, -0.08683375f, 0.13963255f, 0.04171182f, 0.45496786f, 0.35657775f, 
    -0.06446200f, 0.14963762f, 0.18753369f, -0.03451111f, 0.21061273f, 0.23112197f, 0.10298452f, 0.21110076f, 
    -0.15437138f, 0.13243067f, 0.45533752f, -0.15295051f, 0.17061260f, 0.34381625f, -0.19876929f, 0.20584562f, 
    0.13646622f, -0.13975219f, 0.32580149f, -0.23108611f, -0.17895934f, -0.20204443f, -0.21665610f, -0.30082914f, 
    0.31781930f, -0.24159552f, 0.23783502f, -0.28952938f, 0.26708144f, 0.48548785f, 0.24341142f, 0.24813747f, 
    -0.10647652f, 0.11703694f, -0.01680739f, -0.11671215f, 0.12185034f, -0.15078743f, -0.16259268f, 0.25027129f, 
    -0.02578548f, 0.13107859f, 0.03891576f, 0.48660436f, -0.07036638f, 0.33092287f, -0.29334262f, -0.06558924f, 
    0.44433096f, 0.29336771f, 0.25954258f, -0.24946186f, -0.32929039f, -0.03975805f, 0.07235607f, -0.58714885f, 
    -0.09426489f, -0.12352972f, -0.24970575f, -0.23673739f, 0.01871892f, -0.08445087f, 0.06606437f, 0.01316141f, 
    0.13209306f, -0.22006039f, -0.02019199f, -0.01444407f, 0.07903297f, 0.10867132f, 0.04768805f, -0.21600151f, 
    0.07863584f, 0.17546861f, 0.43545261f, -0.23349966f, 0.12612469f, 0.05994017f, 0.02361520f, -0.01908539f, 
    0.23196687f, -0.21942443f, -0.18474232f, 0.30066347f, 0.05262929f, -0.12345994f, 0.18076053f, -0.08649906f, 
    0.25307268f, -0.19240722f, 0.31237027f, 0.18209146f, 0.09349592f, 0.23390195f, -0.56674689f, -0.37711883f, 
    0.15826656f, -0.17234647f, 0.42426041f, -0.05300403f, -0.16299301f, -0.08313448f, -0.07456467f, 0.30753374f, 
    0.17928213f, 0.01543224f, 0.24493030f, -0.44053051f, 0.29527637f, -0.12486562f, 0.46391860f, 0.34142289f, 
    0.28550634f, -0.17996123f, -0.40321344f, 0.05924689f, 0.00571448f, -0.08105735f, 0.10867690f, 0.02029325f, 
    -0.03356894f, 0.32763240f, -0.20254333f, 0.22766797f, -0.41926798f, 0.01480820f, -0.23692618f, -0.32279593f, 
    -0.22871947f, -0.05839868f, 0.52658600f, 0.25951427f, 0.16548319f, 0.18117963f, -0.11026523f, 0.17579669f, 
    -0.23776075f, -0.23206758f, 0.38673723f, -0.17791767f, -0.05936331f, 0.17718814f, 0.17132162f, 0.14886539f, 
    0.40577284f, 0.54572213f, -0.10599402f, -0.22538781f, -0.21007992f, -0.22719809f, -0.01074731f, -0.35377267f, 
    0.10607462f, 0.22994755f, -0.19112253f, 0.04781896f, -0.24406603f, -0.40520346f, -0.48234451f, -0.27503476f, 
    0.29581875f, 0.50941223f, 0.39803046f, 0.28419697f, -0.14874452f, -0.16674942f, -0.10830988f, 0.09903625f, 
    0.02780798f, -0.14989474f, -0.16092810f, 0.27327845f, 0.26494128f, 0.46132198f, 0.32226983f, 0.21839239f, 
    -0.40234566f, -0.11006246f, 0.06094120f, 0.02215577f, 0.25808221f, -0.16500629f, 0.05674075f, -0.05770775f, 
    0.41912571f, 0.07946821f, -0.35194883f, -0.20840614f, -0.07216478f, 0.19596781f, 0.06272595f, -0.20500232f, 
    -0.25504136f, 0.16949581f, 0.17628430f, 0.25642577f, 0.43043333f, 0.16714914f, 0.16214366f, 0.36527270f, 
    -0.22174524f, 0.13025379f, 0.08919995f, 0.01306479f, 0.36053503f, -0.18371831f, -0.26272547f, -0.01857871f, 
    0.21614724f, 0.07281903f, 0.10511387f, -0.41602418f, 0.10506233f, -0.20381387f, 0.08424943f, 0.45414415f, 
    -0.34776804f, 0.14725097f, 0.17403537f, 0.27102298f, -0.04038330f, 0.26715201f, 0.26776707f, 0.18872371f, 
    -0.23421495f, -0.29795322f, 0.10943482f, -0.32551149f, -0.06912157f, 0.15631443f, -0.08838331f, 0.32306555f, 
    -0.09804147f, 0.12555011f, -0.22980936f, 0.46412909f, 0.42326522f, 0.04751576f, 0.36337748f, 0.33879736f, 
    0.37578642f, -0.09118081f, -0.28652185f, -0.04189280f, -0.34708050f, 0.05614525f, 0.18782791f, 0.04741813f, 
    -0.26535922f, -0.17999378f, 0.23437543f, 0.10534013f, -0.28569874f, 0.53749639f, 0.00310689f, 0.21122725f, 
    0.18092176f, -0.30583584f, 0.28657222f, 0.00816321f, 0.51446658f, 0.06205759f, -0.09006219f, -0.18136588f, 
    0.32284456f, -0.23303917f, 0.20610121f, 0.27206191f, 0.47860807f, 0.10387453f, 0.31242275f, 0.41638452f, 
    -0.07797422f, -0.46282715f, 0.01538066f, -0.07101382f, 0.02207874f, 0.18292402f, 0.03660462f, -0.27858093f, 
    -0.33051807f, -0.32726493f, 0.57789767f, 0.33064377f, 0.14409128f, -0.18324946f, 0.14442730f, 0.14381509f, 
    -0.20412646f, -0.12683387f, 0.08721983f, -0.45439506f, 0.01388138f, 0.02709771f, -0.02358429f, 0.48149961f, 
    -0.22649851f, 0.42424339f, -0.26230970f, 0.39272547f, -0.00218185f, -0.29961491f, -0.12027916f, 0.26452076f, 
    -0.30009422f, -0.11328659f, -0.06015802f, -0.35416234f, 0.44117463f, 0.13253674f, -0.09958329f, -0.05506098f, 
    -0.26034528f, -0.23379414f, -0.24101900f, 0.17020696f, -0.16878276f, 0.22545539f, 0.04305245f, 0.00132715f, 
    0.08300974f, 0.19600058f, 0.29547432f, -0.23020406f, -0.01066245f, -0.19228837f, 0.22285283f, -0.01207223f, 
    -0.44797376f, -0.18670993f, 0.43171266f, -0.11706358f, -0.08487339f, 0.15370297f, 0.57156640f, 0.15035363f, 
    -0.26792294f, -0.29642683f, 0.23574796f, 0.25705281f, 0.31607398f, -0.08152172f, -0.07625642f, 0.01298142f, 
    0.30945760f, -0.17718177f, 0.32902801f, -0.26704833f, 0.35907096f, 0.43316671f, 0.30290109f, 0.17661574f, 
    -0.10407285f, 0.08282758f, 0.01517266f, 0.10917640f, -0.01658879f, 0.06596062f, 0.08922032f, -0.21516813f, 
    0.09751572f, -0.09900682f, -0.14622599f, -0.05893293f, -0.14075361f, -0.00007388f, -0.20645881f, -0.09360415f, 
    -0.06778866f, -0.22233286f, -0.15305716f, -0.26376453f, 0.07479002f, -0.23244539f, 0.13433421f, 0.21797903f, 
    -0.01087992f, -0.04888330f, 0.07920150f, -0.23298794f, 0.35146436f, -0.01895344f, -0.29897371f, 0.13346900f, 
    0.21898983f, 0.10815485f, 0.55871105f, -0.42007697f, 0.26897392f, 0.23252097f, 0.02563898f, 0.16301756f, 
    0.23014514f, -0.06349512f, 0.14550298f, -0.07839217f, -0.12484126f, -0.26909739f, 0.35961872f, 0.31837010f, 
    -0.16143800f, -0.11632881f, 0.14729348f, 0.52987117f, -0.29394260f, 0.04073966f, 0.12657787f, -0.02894420f, 
    -0.07578521f, 0.19762351f, 0.13570994f, 0.43423069f, -0.21134800f, -0.27184275f, 0.04296245f, -0.65186298f, 
    -0.27981290f, -0.18044299f, 0.32246131f, 0.21487212f, 0.20468555f, -0.13028435f, 0.10744744f, 0.25738469f, 
    0.16189077f, 0.16304232f, -0.06415895f, -0.05353012f, -0.12066550f, -0.19678771f, 0.47830227f, 0.29099110f, 
    -0.48825350f, -0.04285076f, -0.01621845f, 0.20378126f, 0.11514968f, -0.14444228f, -0.14116468f, -0.23045200f, 
    0.20375255f, 0.32805780f, -0.14256857f, 0.34222108f, 0.07050565f, 0.27521083f, 0.03602710f, 0.05177574f, 
    -0.48363772f, -0.07270425f, -0.16511016f, -0.06182809f, 0.12065755f, 0.07697742f, -0.08831353f, -0.42751589f, 
    -0.38813627f, 0.05829083f, 0.31298447f, -0.31500727f, 0.17982773f, -0.88487893f, -0.05860881f, -0.10626681f, 
    -0.00103078f, 0.11274631f, 0.33755293f, 0.36478773f, 0.27276540f, 0.02880482f, -0.12395097f, -0.02592028f, 
    -0.46101284f, 0.30362833f, 0.20112860f, 0.41635728f, -0.28094396f, 0.09669247f, 0.08435673f, 0.09317461f, 
    -0.18083434f, -0.30080244f, -0.12475500f, -0.05040020f, -0.06625942f, -0.11664575f, 0.03525314f, 0.35548922f, 
    -0.09920971f, -0.12701192f, 0.03752480f, 0.34487632f, -0.17266841f, 0.32080519f, 0.12876715f, 0.17519131f, 
    0.16165800f, -0.39680183f, -0.05743493f, 0.18644187f, 0.35488367f, -0.14984636f, -0.22643907f, -0.32986781f, 
    -0.09001721f, 0.10099454f, 0.16058370f, 0.13322210f, 0.04783436f, 0.38896367f, 0.03510714f, -0.34491974f, 
    -0.25149110f, 0.12518983f, 0.28285989f, -0.46239120f, 0.38008952f, -0.04950202f, -0.07988736f, 0.12455132f, 
    0.07530336f, 0.28241271f, -0.16049853f, 0.27960679f, 0.23964407f, 0.41913307f, 0.20278049f, -0.06002398f, 
    -0.00498224f, 0.17860265f, -0.09336010f, -0.35996273f, -0.14688547f, -0.16476198f, -0.19137135f, -0.38393185f, 
    0.12138287f, -0.04823780f, -0.03318032f, 0.07814826f, -0.14882796f, -0.04991100f, -0.08371380f, -0.14040442f, 
    0.07529598f, -0.08142621f, -0.03886146f, -0.10945955f, 0.06576086f, 0.00381121f, 0.15320030f, -0.04365642f, 
    0.16776913f, 0.11269592f, -0.09171260f, 0.11451738f, 0.30429378f, -0.48591927f, -0.18485348f, 0.08537778f, 
    -0.11252695f, 0.14904711f, 0.16300507f, 0.39825970f, -0.40722781f, 0.21005076f, 0.00724520f, 0.49611831f, 
    0.16486958f, 0.20478590f, 0.06935107f, -0.02392439f, 0.01355302f, -0.35830730f, 0.20335938f, -0.08832302f, 
    -0.37304699f, 0.30665061f, -0.28298709f, -0.13393119f, 0.48347870f, -0.22382544f, 0.24116261f, -0.13070002f, 
    -0.41077760f, 0.19419634f, -0.35093674f, -0.33859640f, 0.08602495f, 0.43742725f, -0.19178228f, 0.18171322f, 
    0.32100308f, 0.08473445f, 0.52678978f, 0.34568667f, -0.24242617f, -0.08758967f, 0.08193225f, -0.15944415f, 
    0.36897105f, 0.20191801f, 0.29407421f, -0.16486439f, -0.12575604f, -0.38284835f, -0.29310930f, -0.26619953f, 
    0.02097209f, 0.09353080f, 0.24374336f, 0.35736969f, 0.14325821f, 0.05328560f, -0.22116941f, 0.30714107f, 
    0.26933613f, 0.11288077f, 0.10193565f, -0.37413266f, 0.14084268f, -0.55254668f, -0.18385279f, -0.04157764f, 
    0.30246240f, 0.36182541f, 0.25969818f, 0.27704909f, -0.17832638f, -0.02547484f, -0.21240893f, -0.09771261f, 
    -0.38807553f, 0.31166258f, -0.20495522f, 0.38879755f, -0.10881349f, -0.30338290f, -0.16433029f, -0.07885797f, 
    0.09692600f, 0.32085744f, 0.13241854f, -0.35473919f, 0.04184261f, -0.23025085f, -0.06962904f, 0.31016445f, 
    0.19661431f, 0.26579276f, 0.26091236f, -0.21104456f, 0.44558123f, -0.27380663f, -0.10742377f, -0.43195835f, 
    0.21504247f, -0.21221264f, 0.10689922f, -0.45407787f, 0.26221249f, 0.21621510f, 0.10435100f, 0.09427380f, 
    -0.25931063f, 0.06149879f, -0.52929437f, 0.36388713f, 0.13471958f, -0.23672390f, 0.17147361f, 0.10169452f, 
    0.71173668f, 0.23798679f, -0.22322744f, -0.07261112f, -0.25280011f, -0.05709529f, 0.18014847f, 0.23883365f, 
    0.27736416f, 0.10718072f, -0.22238415f, 0.00797941f, -0.23452610f, 0.54462796f, 0.31817448f, 0.23231511f, 
    -0.55298907f, 0.28547692f, -0.16027984f, -0.03832246f, 0.32461143f, -0.20145904f, 0.17739603f, -0.24140380f, 
    -0.05963898f, 0.22624697f, -0.23905925f, 0.17378581f, 0.28404325f, 0.52861977f, -0.20057742f, 0.27910540f, 
    -0.07445616f, -0.15223324f, -0.19218557f, -0.46481073f, 0.35271767f, -0.00091177f, -0.19780852f, -0.09914321f, 
    -0.03575060f, 0.35488027f, -0.15696257f, 0.17855334f, -0.23347719f, -0.31148979f, 0.23834233f, -0.18887565f, 
    -0.33528832f, 0.35678509f, -0.30985790f, -0.09393205f, 0.44482389f, -0.17524815f, 0.08757494f, -0.17522602f, 
    0.01755644f, -0.33622506f, -0.00562779f, -0.01657225f, -0.10995916f, 0.45161092f, -0.10513196f, 0.41913834f, 
    0.23767425f, 0.41182518f, -0.35497937f, 0.36126292f, -0.05224035f, 0.19039613f, 0.17085218f, -0.50784945f, 
    0.31125399f, 0.09719507f, 0.28863868f, 0.20785330f, 0.46859178f, 0.29497546f, -0.51217049f, -0.10985593f, 
    0.04706597f, -0.30054194f, 0.20432964f, -0.26524577f, 0.06654540f, -0.23403089f, -0.03051857f, 0.18744288f, 
    -0.25167707f, 0.18087302f, -0.14891271f, 0.35084590f, 0.33866331f, -0.37465844f, 0.43324077f, -0.28458640f, 
    0.47223422f, -0.06403813f, -0.41917107f, -0.17500274f, 0.11664923f, 0.11804687f, 0.15871629f, 0.28056997f, 
    -0.09115481f, 0.21689513f, 0.05098322f, -0.32396767f, -0.06398091f, -0.10399527f, 0.08653150f, -0.44264671f, 
    0.23590477f, -0.15964736f, 0.44489217f, 0.46400139f, 0.49246028f, 0.08819687f, 0.14313267f, -0.14479379f, 
    -0.26440668f, -0.10341849f, -0.32044759f, 0.36102915f, -0.11877183f, 0.54180390f, 0.29083127f, 0.01194022f, 
    -0.09376588f, 0.10782358f, 0.40853292f, -0.17164074f, 0.29610747f, 0.04523527f, 0.07012171f, -0.02497690f, 
    0.46247783f, -0.40413192f, 0.21730816f, 0.06755313f, 0.22387984f, -0.24597782f, -0.09902734f, -0.08345000f, 
    0.24497968f, 0.30921787f, 0.05851842f, 0.09557850f, -0.00530091f, -0.06003704f, 0.02020593f, 0.00673755f, 
    -0.05536729f, -0.14430022f, 0.18876755f, -0.47868225f, 0.20819198f, -0.23973562f, -0.07408478f, 0.07542445f, 
    0.16585009f, -0.16549855f, -0.03108713f, 0.11937375f, 0.52377725f, 0.00284611f, 0.16387588f, 0.22330353f, 
    -0.15690161f, -0.10623092f, -0.03757033f, 0.12547809f, 0.26002789f, -0.12640329f, 0.53512502f, -0.22273743f, 
    0.54691464f, 0.41980332f, -0.16715203f, -0.50968015f, 0.00967274f, 0.11989704f, 0.04740873f, 0.24607831f, 
    0.04575016f, -0.25074172f, -0.17891081f, 0.21093233f, -0.23175420f, 0.34575966f, -0.30066636f, 0.01911353f, 
    0.14529982f, -0.09594287f, 0.17676069f, -0.26698789f, -0.00325176f, 0.16608185f, -0.08218044f, 0.14465642f, 
    -0.24202314f, 0.36944461f, -0.28332803f, -0.09020249f, 0.03889088f, 0.05459424f, -0.30161405f, 0.13267787f, 
    0.30398521f, 0.13022393f, 0.20613700f, 0.30351579f, -0.37977192f, -0.08338738f, -0.04727900f, -0.11967401f, 
    0.19955491f, -0.07217798f, 0.35078704f, -0.46621749f, 0.17134890f, 0.27014744f, 0.29369783f, 0.09008856f, 
    0.39552337f, 0.11462382f, -0.20179421f, 0.25929657f, -0.17022023f, -0.09733897f, -0.04576759f, -0.22910592f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07705861f, -0.09009022f, -0.12376924f, 0.32785806f, -0.23138930f, -0.16316684f, -0.44668582f, 0.52927870f, 
    0.12924437f, 0.34092245f, 0.00226671f, 0.12510248f, -0.14111958f, 0.17096250f, 0.12055930f, -0.08612511f, 
    0.19420339f, 0.03862187f, 0.04662178f, 0.15174049f, -0.12111013f, 0.33004743f, -0.05368737f, 0.27454495f, 
    -0.14129704f, 0.10887123f, 0.24817915f, -0.04743627f, 0.06498767f, 0.45731011f, -0.05041232f, 0.47324580f, 
    -0.23391990f, -0.17916232f, -0.05936199f, 0.50096792f, -0.30208284f, 0.09014070f, -0.15148541f, 0.47008681f, 
    0.47574043f, -0.24605198f, 0.05223004f, 0.15333970f, 0.10903089f, -0.11751273f, -0.28155237f, 0.31109941f, 
    0.26366496f, -0.01832441f, 0.39380670f, 0.25670335f, 0.39037958f, -0.18797512f, -0.26296529f, -0.05410572f, 
    -0.05393697f, 0.16725141f, -0.18960552f, 0.07323029f, 0.01749026f, 0.26409841f, 0.14683516f, 0.15659353f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13777140f, -0.15957469f, -0.15763533f, 0.03290530f, 0.05916858f, -0.14557034f, 0.00283572f, 0.00783973f, 
    -0.19490676f, -0.12277978f, -0.09333169f, -0.01405287f, 0.09142093f, 0.05505104f, -0.00549051f, -0.16554609f, 
    -0.03083936f, -0.05480253f, 0.05202164f, -0.05445329f, -0.08824858f, -0.14226614f, 0.00902823f, 0.05206335f, 
    0.06898010f, -0.02335536f, -0.01950748f, 0.09357610f, 0.03075945f, -0.08843144f, -0.09819885f, -0.09170770f, 
    -0.15751071f, -0.15393379f, 0.06389782f, -0.01852969f, 0.04046455f, -0.04005054f, -0.09194673f, 0.02303506f, 
    -0.06584373f, 0.02336998f, -0.12487677f, -0.04032336f, -0.18057336f, -0.04183294f, -0.09175454f, -0.03701436f, 
    0.06178666f, -0.10729136f, 0.04323533f, -0.15185739f, -0.13008170f, 0.00207483f, -0.10621333f, -0.14984119f, 
    0.14253247f, 0.05091144f, 0.06039628f, 0.18318909f, 0.12062103f, -0.12036201f, -0.05201471f, -0.07119850f, 
    -0.05971906f, 0.02479948f, -0.10221116f, 0.05796777f, 0.29527399f, 0.37915960f, -0.30885994f, 0.06473905f, 
    0.51990038f, -0.03428566f, 0.47226435f, -0.11842012f, -0.25933427f, 0.39473373f, -0.17107837f, 0.17880602f, 
    -0.12871307f, 0.22416966f, 0.02595925f, 0.02538159f, 0.27733600f, 0.29886189f, 0.04204240f, 0.31130043f, 
    -0.17638892f, -0.14908053f, 0.30146465f, 0.08710966f, -0.00630688f, -0.04026140f, 0.09952150f, 0.24652128f, 
    -0.33203363f, 0.06441993f, -0.26690161f, 0.04664606f, -0.47547919f, 0.06386857f, -0.09193184f, 0.21120258f, 
    0.48543876f, -0.04636662f, 0.02162527f, -0.16465142f, 0.05268116f, -0.04421593f, -0.06759237f, 0.40870908f, 
    0.02614545f, 0.42120826f, -0.02635041f, 0.09007977f, -0.00035591f, -0.66285783f, 0.12146006f, 0.17542195f, 
    -0.29474157f, 0.32647583f, 0.03614838f, -0.34469706f, 0.19562410f, 0.06355048f, 0.12206358f, -0.13344638f, 
    0.02493882f, 0.10557395f, -0.12444603f, 0.04877220f, -0.08609082f, 0.12037525f, -0.10141043f, -0.11872217f, 
    0.11244500f, 0.01247321f, -0.05896080f, -0.11298418f, -0.02881731f, -0.07568437f, 0.05070011f, 0.00007193f, 
    -0.05492257f, 0.06381086f, -0.10210611f, -0.07786764f, 0.03543857f, 0.09897912f, -0.10375622f, -0.08918332f, 
    0.02784935f, -0.10894530f, -0.06514038f, 0.02625380f, 0.06083597f, 0.00200000f, -0.11607897f, 0.00100976f, 
    -0.00287403f, -0.02200188f, -0.03131199f, -0.11292240f, 0.08109336f, -0.10936378f, -0.02010916f, -0.10971084f, 
    0.00368015f, 0.03313598f, -0.01407349f, -0.09076148f, -0.08379242f, -0.04891683f, -0.02991775f, 0.09520490f, 
    -0.10285920f, -0.07656071f, 0.02415018f, -0.04105447f, 0.07603183f, 0.06053203f, -0.05698617f, -0.06079759f, 
    0.05024679f, 0.00934033f, 0.05957036f, -0.09873132f, 0.08013193f, 0.11131497f, -0.03435266f, 0.09770437f, 
    0.08131655f, -0.13643213f, -0.30459446f, 0.29319093f, 0.06809692f, 0.18237972f, -0.09753586f, 0.17159939f, 
    0.05821365f, -0.00890495f, 0.24178775f, -0.05985641f, -0.20311931f, 0.50168234f, 0.07401675f, 0.09985388f, 
    0.08784474f, 0.38544664f, -0.24905252f, -0.04475885f, 0.41434813f, -0.01508334f, 0.15023938f, -0.11575050f, 
    -0.50345325f, 0.03035955f, -0.16099870f, 0.10677378f, -0.37500924f, -0.05800802f, 0.01853196f, 0.15958402f, 
    0.01802444f, 0.01006433f, -0.43634775f, -0.02257268f, -0.17014165f, -0.11535813f, -0.45230249f, -0.02604622f, 
    0.04104877f, 0.10232747f, 0.31595489f, -0.11578638f, 0.04518411f, 0.18883774f, 0.41448712f, 0.31832656f, 
    0.32459155f, 0.22991166f, -0.16253641f, -0.06798980f, -0.37745965f, -0.14882223f, 0.20907857f, 0.02616324f, 
    -0.20609659f, 0.04514081f, 0.29383600f, 0.01742417f, 0.20729046f, 0.10117654f, 0.12372944f, -0.02782145f, 
    -0.10269534f, -0.27748734f, -0.21502312f, 0.58975995f, -0.66107655f, 0.24456733f, -0.36054274f, 0.43786871f, 
    -0.22018270f, 0.22432712f, 0.14321569f, -0.02348872f, -0.58377051f, 0.09694764f, -0.04212979f, -0.02048104f, 
    -0.16552472f, 0.25541633f, 0.24639075f, 0.24676800f, 0.21151245f, 0.10981645f, 0.09499332f, -0.01071003f, 
    -0.29499236f, 0.08453948f, 0.11498684f, 0.06713105f, 0.01281053f, 0.09228117f, -0.02817371f, 0.17034762f, 
    0.08355720f, -0.12000222f, -0.15517083f, -0.00483574f, -0.69943482f, -0.08602846f, -0.45620796f, 0.00644275f, 
    0.14575996f, 0.11006855f, 0.36223438f, -0.13180608f, 0.17138878f, -0.05287132f, 0.08247064f, 0.28134951f, 
    -0.12818815f, 0.31097496f, 0.10529038f, -0.02556534f, -0.15576331f, -0.04748776f, 0.06373899f, -0.09370231f, 
    -0.41218591f, 0.25821969f, 0.08435697f, -0.33733797f, 0.07597608f, 0.11137699f, 0.22415738f, -0.14771669f, 
    -0.16584723f, -0.19784032f, -0.01157968f, 0.29379973f, 0.20213224f, 0.37574181f, -0.24647029f, 0.13362221f, 
    0.24722579f, 0.17180680f, -0.04427043f, -0.07706210f, 0.14452682f, 0.46798676f, 0.36257678f, -0.29168627f, 
    -0.13225032f, -0.19179787f, 0.25916129f, -0.16129887f, 0.22565329f, 0.12170548f, 0.13990338f, -0.07307908f, 
    0.23559740f, 0.28756067f, -0.13513491f, -0.14205237f, 0.44971532f, 0.23376331f, -0.14955831f, 0.22476387f, 
    -0.17251363f, -0.06875940f, -0.05154564f, 0.05591339f, -0.46998698f, 0.01202072f, 0.15024336f, 0.03628903f, 
    -0.04840356f, -0.01725277f, 0.15785919f, -0.06956662f, 0.00241354f, -0.02948108f, 0.05789765f, -0.12926416f, 
    0.04881154f, 0.00054685f, -0.15451054f, 0.05316954f, -0.14492913f, -0.18262489f, 0.26202404f, 0.20529881f, 
    -0.14184947f, -0.04005573f, 0.28102762f, 0.25188497f, 0.18826230f, -0.13770497f, -0.06699669f, 0.29270852f, 
    0.25119317f, 0.08057762f, 0.00113246f, -0.40425530f, 0.03207356f, -0.05564844f, 0.11861904f, 0.09054173f, 
    0.06887347f, 0.07684000f, -0.00251271f, 0.02102536f, -0.07715918f, -0.21660395f, -0.05235429f, 0.26329589f, 
    0.03393424f, -0.06051914f, 0.23257056f, 0.10789848f, -0.04067265f, 0.30947497f, -0.12774032f, 0.18750228f, 
    0.22441864f, -0.08988394f, 0.28777209f, 0.19287513f, -0.14552793f, -0.00879855f, 0.02899475f, 0.05076149f, 
    -0.13436304f, -0.03630449f, 0.19559459f, 0.38810164f, 0.40349811f, 0.20971154f, -0.06821976f, 0.22173283f, 
    0.30745494f, -0.02418538f, -0.24658929f, 0.33109507f, -0.27949679f, -0.00372698f, -0.10841319f, 0.09251472f, 
    0.03563258f, -0.25884444f, 0.22674458f, 0.33600035f, 0.18552516f, -0.30770621f, 0.10218947f, -0.04746565f, 
    0.20431381f, 0.24851654f, -0.44619712f, 0.00404964f, 0.01395349f, 0.20368055f, -0.08945008f, -0.13732930f, 
    0.08315729f, 0.49626958f, -0.05846154f, -0.18189552f, -0.68025899f, -0.07929881f, 0.04344359f, -0.06650421f, 
    -0.43609488f, -0.51972032f, -0.19525616f, 0.06671506f, 0.23835671f, -0.00969572f, -0.29422066f, 0.60331267f, 
    -0.80808520f, 0.36216235f, -0.35815799f, 0.28709081f, -0.01669418f, -0.04773296f, -0.13477865f, -0.35008389f, 
    -0.28358924f, -0.64789575f, 0.16083780f, -0.36770108f, -0.29431719f, -0.47949815f, 0.07611065f, -0.20477718f, 
    0.15452304f, 0.41436461f, 0.16692601f, 0.17164139f, 0.39910191f, 0.14687513f, -0.04891366f, -0.04244542f, 
    -0.16807130f, 0.07967030f, 0.34793204f, 0.08492333f, 0.12956567f, 0.42451108f, 0.16932267f, 0.06073967f, 
    -0.03100258f, 0.21553743f, -0.17638621f, -0.31295481f, 0.13861933f, -0.21524535f, 0.03409488f, 0.08254185f, 
    0.43960240f, 0.06736331f, 0.03244071f, 0.13810684f, -0.24329492f, 0.10657763f, 0.32974064f, -0.24331786f, 
    -0.07158148f, -0.12208015f, 0.04911860f, -0.14204845f, -0.07699420f, 0.05999231f, 0.07714446f, -0.06910423f, 
    0.07469571f, -0.10964923f, 0.06444516f, -0.03041153f, 0.08401041f, -0.11304711f, 0.08748808f, -0.13555241f, 
    0.01868117f, 0.08179551f, -0.10102030f, -0.06151695f, -0.00584249f, -0.09710584f, -0.01978431f, -0.13579874f, 
    -0.12982164f, 0.01317294f, 0.05538868f, -0.09490275f, 0.02147910f, 0.08375271f, -0.09564941f, -0.13160175f, 
    0.09006305f, -0.05304019f, -0.00159622f, 0.09707491f, -0.03730567f, -0.05009923f, -0.08212189f, 0.00128122f, 
    0.00727516f, -0.10193506f, -0.12153009f, -0.04156090f, -0.02662985f, -0.11099478f, -0.12881267f, -0.12199748f, 
    -0.09706307f, 0.03330152f, -0.15194696f, -0.00858131f, 0.04284404f, -0.11183272f, -0.11143608f, -0.14072154f, 
    0.05425889f, -0.05620262f, 0.01103210f, -0.10366569f, -0.06198213f, -0.08028300f, -0.00019619f, -0.07712863f, 
    -0.32704604f, 0.15245782f, 0.01332327f, -0.26292700f, -0.60668546f, -0.09555072f, 0.00433356f, -0.04696990f, 
    -0.25626487f, 0.02511422f, -0.08403781f, -0.11632068f, 0.07790966f, 0.03383766f, 0.05693992f, 0.06835348f, 
    -0.01002114f, -0.10650305f, -0.04099130f, 0.06059986f, 0.02729748f, 0.13912751f, 0.02914403f, 0.00716014f, 
    0.41335145f, 0.33037671f, 0.11041827f, -0.37309098f, 0.04363743f, 0.02885235f, 0.03697463f, -0.05087821f, 
    0.21042928f, 0.35445911f, 0.24241389f, 0.03801863f, 0.23805532f, 0.16116610f, -0.18739025f, 0.04076848f, 
    -0.01243768f, -0.09630220f, 0.10428002f, 0.18574187f, -0.30235672f, 0.11354807f, -0.12692101f, -0.02879516f, 
    0.15505862f, -0.16918367f, 0.18384808f, 0.16292796f, 0.19062939f, -0.02639280f, 0.14746112f, 0.17932348f, 
    0.24947837f, -0.06013385f, 0.10639925f, -0.02196271f, 0.23643513f, 0.08099240f, -0.03458155f, 0.08274332f, 
    -0.10586564f, -0.10779946f, -0.08311493f, -0.12110167f, 0.09889717f, 0.02865979f, -0.08926164f, -0.15258496f, 
    -0.11173609f, -0.05886485f, 0.01657678f, -0.06471677f, 0.08127449f, -0.07295252f, -0.05983298f, -0.08549068f, 
    -0.07910271f, 0.07301056f, 0.07278430f, -0.11606993f, 0.04548170f, 0.03681701f, 0.05572145f, -0.06289203f, 
    -0.10702525f, 0.07065456f, 0.07869736f, 0.09335227f, 0.02571528f, -0.03622368f, -0.03082092f, 0.04608559f, 
    -0.00341392f, -0.08681504f, -0.07458311f, 0.03599235f, -0.12352899f, -0.13560259f, 0.06506340f, -0.01999718f, 
    -0.15220445f, -0.01522988f, -0.06600638f, -0.06263256f, 0.07783777f, 0.02484127f, 0.05301705f, 0.04451805f, 
    -0.13908170f, 0.00946751f, -0.04627158f, -0.07867426f, 0.00568600f, -0.04508597f, -0.07393685f, -0.03495539f, 
    -0.09396119f, -0.07077658f, -0.05877216f, -0.11722697f, -0.12785961f, 0.00151187f, -0.01422999f, -0.11149738f, 
    -0.07886288f, -0.24370281f, 0.06172901f, 0.37654445f, -0.19800539f, -0.26811522f, 0.40779343f, 0.07147422f, 
    0.29240912f, 0.04313497f, 0.01485789f, 0.04001723f, 0.14245543f, -0.07515670f, 0.23612531f, -0.00867908f, 
    0.58528465f, 0.20206159f, -0.45113474f, 0.05524701f, 0.04372233f, -0.13228415f, -0.03473420f, 0.22679809f, 
    -0.16654068f, -0.03074207f, -0.41063458f, -0.13954322f, 0.30446661f, -0.02941665f, -0.14386006f, 0.02926018f, 
    0.14581886f, -0.14374124f, -0.04045499f, -0.51297855f, 0.25918403f, -0.23368263f, 0.14055181f, -0.35454440f, 
    -0.15859218f, 0.10151998f, 0.09477558f, -0.14150371f, 0.48847312f, 0.15672925f, 0.15418644f, 0.02167405f, 
    -0.06476478f, 0.40185586f, -0.18468677f, -0.12488437f, -0.14176944f, 0.35742712f, -0.12487782f, -0.04025995f, 
    0.50513685f, -0.23430902f, 0.03832318f, 0.20720346f, 0.24548288f, -0.23605035f, 0.15007456f, 0.37550250f, 
    -0.50763816f, 0.04954648f, -0.05100229f, 0.17375238f, 0.20001210f, 0.55694497f, -0.39024097f, 0.16974127f, 
    0.27267849f, 0.00688236f, 0.41558751f, -0.08953540f, -0.41050184f, 0.16975822f, -0.51944739f, 0.18569884f, 
    -0.53646827f, 0.06791084f, 0.24758360f, 0.15132084f, -0.22983310f, 0.27686816f, -0.04773545f, 0.24948840f, 
    0.34557366f, -0.35745826f, 0.14367385f, 0.36712250f, -0.24182014f, 0.26842019f, 0.02602622f, 0.10115830f, 
    0.19312604f, 0.12878235f, 0.13754204f, 0.44047371f, -0.27897549f, -0.02569381f, -0.11133292f, 0.31730500f, 
    0.36371207f, 0.03426799f, 0.21849026f, -0.25480562f, 0.18442495f, -0.16761021f, -0.12454534f, -0.00945636f, 
    -0.22856066f, -0.07147585f, 0.17878392f, 0.18387863f, -0.11079910f, -0.12876710f, 0.16139570f, -0.29481620f, 
    -0.44270313f, 0.37780398f, 0.07728027f, -0.73574275f, -0.37782863f, 0.16985379f, -0.01016174f, -0.15979676f, 
    -0.07624055f, 0.06676795f, -0.06488656f, -0.07883617f, -0.09169187f, -0.04571171f, 0.05160666f, -0.00656582f, 
    -0.01596338f, 0.06588652f, -0.01338490f, 0.08520263f, -0.03049906f, -0.11275434f, 0.10122088f, 0.05529486f, 
    0.10501089f, -0.02024850f, -0.12363122f, -0.03549083f, -0.07083148f, -0.10786823f, 0.03938098f, 0.00017031f, 
    -0.01742538f, -0.00893804f, -0.07250754f, 0.04720613f, -0.07272359f, -0.12843868f, 0.03614216f, -0.03311913f, 
    -0.12731753f, -0.11980904f, 0.07787415f, 0.01919838f, -0.09826402f, 0.00763520f, -0.08087971f, 0.00021035f, 
    0.10286706f, 0.00297970f, 0.04134224f, -0.01755637f, -0.12543450f, -0.15307792f, -0.02003239f, 0.09439241f, 
    0.04966061f, 0.01322311f, 0.02003456f, -0.02397003f, -0.12473112f, -0.01202816f, -0.00406728f, 0.09535933f, 
    0.11541787f, -0.05504955f, -0.02480525f, -0.12113141f, -0.03402331f, 0.09052822f, -0.08881506f, -0.00158649f, 
    0.43188792f, 0.20369649f, -0.12193635f, 0.41038465f, -0.25645259f, -0.08159930f, 0.28871667f, 0.18172640f, 
    -0.24976100f, 0.21699171f, -0.58901274f, 0.10910836f, -0.02105561f, -0.09533174f, 0.22165631f, 0.07865995f, 
    -0.23421800f, 0.00071611f, 0.32909185f, 0.53740180f, -0.10826042f, -0.18007432f, -0.48450488f, 0.13178952f, 
    0.12336875f, -0.46075010f, 0.07069088f, 0.08673437f, 0.40159002f, 0.12721905f, -0.08726328f, 0.03167388f, 
    -0.32993925f, 0.01394288f, 0.11635389f, 0.05433122f, 0.26176822f, -0.19685349f, 0.00957833f, 0.04418388f, 
    -0.15309772f, -0.04880571f, 0.02533208f, 0.27988032f, 0.27676526f, 0.16620700f, 0.04180252f, -0.14777860f, 
    0.02601721f, -0.32814193f, 0.20970491f, -0.07013728f, 0.25520176f, -0.00119879f, -0.10788853f, -0.07099988f, 
    0.37563217f, -0.03450187f, -0.10108062f, 0.30986270f, -0.21400152f, 0.03598166f, 0.14120403f, 0.17077890f, 
    0.13989094f, 0.28552806f, 0.06518643f, -0.42074302f, -0.29382831f, 0.09801789f, -0.08605041f, 0.29625264f, 
    -0.09519637f, 0.08838548f, -0.08504802f, 0.12191436f, -0.39302129f, -0.13131966f, -0.22983390f, 0.35768735f, 
    0.01599097f, 0.13761611f, 0.24192268f, 0.32375053f, 0.01971954f, 0.20628031f, 0.11182719f, 0.06497475f, 
    -0.26542068f, -0.26326814f, 0.21568185f, 0.49586147f, -0.29925576f, -0.16998158f, 0.08907722f, 0.15348671f, 
    0.00656924f, 0.17896658f, 0.18315586f, 0.21065240f, 0.09742219f, 0.26152340f, -0.11414788f, 0.24452072f, 
    0.29663998f, -0.04189642f, -0.20604874f, 0.00946879f, -0.23844332f, -0.03188346f, -0.25511274f, 0.36537582f, 
    -0.08877007f, 0.12056843f, 0.27048764f, 0.08806560f, 0.34107539f, -0.43564144f, -0.19724436f, -0.02268904f, 
    0.02878742f, 0.34488854f, -0.32179642f, -0.42802978f, 0.20026658f, 0.07327879f, -0.12040210f, -0.24425229f, 
    0.23848975f, 0.07264059f, 0.36275023f, -0.23706405f, -0.25568742f, -0.08401460f, -0.21746445f, 0.13003616f, 
    -0.15182976f, -0.13282773f, 0.20995820f, -0.02313410f, -0.03066909f, -0.24065743f, 0.27869380f, -0.15768506f, 
    0.33545971f, 0.02513577f, -0.00627672f, -0.13491990f, -0.02669708f, -0.13515754f, 0.45106018f, -0.20828007f, 
    -0.21380450f, -0.28587568f, 0.08070589f, -0.04095085f, -0.06913710f, -0.19444746f, -0.04102115f, -0.05034212f, 
    0.03533892f, 0.18876052f, 0.10246214f, -0.05031059f, -0.00387555f, -0.08786466f, 0.29833278f, -0.06202504f, 
    0.15285067f, 0.06670613f, 0.06556390f, 0.30529192f, -0.22532102f, -0.02975592f, 0.04280137f, 0.17635766f, 
    -0.07155129f, 0.75538528f, -0.06666701f, -0.08335832f, 0.32318017f, -0.03334349f, -0.12091371f, 0.61217111f, 
    0.00557114f, -0.03163845f, -0.01907608f, -0.18172693f, 0.38683620f, -0.20227420f, -0.07509322f, 0.09723876f, 
    0.04574586f, 0.20598032f, 0.18856235f, 0.09482692f, -0.86479974f, -0.01604818f, -0.14599244f, 0.16673833f, 
    -0.32223377f, 0.06338160f, 0.00840115f, 0.01886086f, -0.20534605f, -0.21626538f, 0.13423924f, 0.30949211f, 
    -0.01317616f, -0.04276157f, 0.15456198f, 0.12760694f, -0.25703603f, 0.01076185f, 0.21494730f, 0.01980888f, 
    0.06281202f, 0.03432953f, 0.31887507f, -0.01168656f, 0.27406996f, -0.01651463f, 0.05250663f, 0.07937269f, 
    0.50286978f, 0.32913789f, 0.47996473f, 0.26192206f, 0.14010736f, 0.25063506f, 0.05633847f, 0.08645557f, 
    -0.03188112f, 0.10184520f, 0.08409531f, 0.25101939f, 0.18842396f, -0.02643408f, -0.08242952f, 0.18422030f, 
    -0.14078453f, 0.27665153f, 0.10458995f, -0.08252418f, 0.35270566f, -0.10459568f, -0.16434693f, -0.06771252f, 
    0.10285828f, 0.25316972f, 0.09256027f, -0.24085557f, -0.13362716f, 0.06920835f, 0.10342082f, 0.00741719f, 
    0.04827622f, -0.41579467f, -0.22781332f, -0.06585290f, 0.78054285f, 0.42346925f, -0.00181005f, 0.01261531f, 
    0.50967509f, 0.24828547f, 0.31335601f, -0.03161700f, -0.19619033f, 0.24554466f, -0.00677709f, -0.37136248f, 
    0.07987382f, -0.16574956f, 0.23869407f, -0.06557722f, 0.10171864f, 0.00618653f, 0.04367991f, 0.12123315f, 
    0.14365765f, -0.08713893f, -0.17223461f, 0.13550638f, -0.65524906f, 0.34191331f, -0.06075440f, 0.17640443f, 
    -0.75141233f, -0.80955523f, -0.51117742f, 0.18494886f, -0.27112097f, -0.19442730f, -0.00209870f, 0.21322612f, 
    0.39386746f, -0.00818949f, -0.46083817f, -0.46896970f, 0.10805950f, -0.34633920f, 0.06326563f, -0.11391823f, 
    0.27566674f, 0.16930555f, 0.10172798f, 0.33666059f, -0.34786674f, 0.01051647f, 0.15579250f, -0.20696184f, 
    -0.57212627f, 0.23513624f, -0.21589528f, -0.34433541f, 0.12699004f, 0.01065834f, -0.07472641f, 0.01703592f, 
    0.45990965f, -0.07908271f, 0.26219106f, 0.25950304f, 0.24215160f, 0.23232198f, -0.21467263f, 0.14937866f, 
    0.02132182f, 0.23567235f, 0.00960033f, 0.02272828f, 0.00946442f, -0.03597378f, 0.33175063f, 0.01317766f, 
    -0.55801660f, -0.01863874f, 0.12638664f, -0.01699445f, 0.01247865f, 0.00495832f, 0.27831408f, 0.04710551f, 
    0.38635480f, -0.37577167f, -0.03905877f, 0.23489569f, -0.01299318f, 0.25817981f, 0.05177283f, -0.00278169f, 
    -0.08792853f, -0.41193414f, 0.03906358f, 0.05926992f, -0.39033028f, -0.21191961f, 0.27944496f, -0.15209565f, 
    0.03409196f, -0.02695812f, 0.04520820f, -0.15150887f, 0.12152957f, -0.08112196f, -0.04943732f, -0.16205010f, 
    0.10704877f, 0.26316032f, 0.01270400f, 0.06904344f, -0.13999742f, -0.41649848f, 0.04556632f, 0.16085429f, 
    -0.16680069f, -0.13363546f, 0.02328336f, 0.24902537f, -0.23668475f, 0.31690371f, -0.00964702f, 0.26202255f, 
    -0.18684039f, 0.01985626f, 0.17752112f, 0.46807882f, 0.01475640f, 0.29286075f, 0.06749452f, 0.13990732f, 
    -0.02325016f, 0.03510502f, 0.21756037f, -0.00306184f, 0.11799917f, -0.04465986f, 0.09524417f, 0.15403222f, 
    -0.14008294f, 0.23811753f, 0.13289401f, 0.00827512f, -0.25133139f, -0.21413583f, 0.48059824f, 0.01823642f, 
    0.32772875f, -0.20388180f, -0.02285656f, -0.01302720f, -0.30150461f, 0.22722928f, 0.01917455f, -0.04870833f, 
    0.51628840f, -0.16700542f, -0.08481081f, 0.14520907f, -0.27481696f, 0.01218167f, 0.32660297f, -0.21842434f, 
    0.11354383f, -0.00237714f, 0.33244056f, -0.15023948f, 0.50166535f, 0.21579872f, 0.12683633f, -0.24310434f, 
    -0.10570255f, 0.27096125f, 0.11973400f, 0.07373157f, -0.22361961f, 0.75740910f, 0.22144486f, -0.26953995f, 
    -0.28504845f, 0.13498098f, 0.19811615f, -0.14102782f, -0.36221668f, -0.00011431f, 0.51748329f, 0.17596041f, 
    -0.01648373f, 0.03567996f, -0.06007548f, -0.04038848f, -0.25946075f, 0.00029653f, -0.03530938f, 0.13879254f, 
    0.13950293f, 0.14118820f, -0.24615116f, -0.03067370f, -0.05140484f, 0.08724535f, 0.12002496f, -0.18464981f, 
    -0.11162642f, -0.11676229f, 0.11935092f, 0.13292009f, 0.08117422f, 0.26923609f, -0.13076898f, -0.01439025f, 
    0.31271079f, 0.46178892f, 0.34079543f, 0.10334532f, 0.18316914f, 0.23718025f, -0.08988157f, 0.15959369f, 
    -0.00737950f, -0.04261113f, 0.40446150f, 0.33932623f, -0.08197178f, -0.03356156f, -0.26198840f, 0.34029216f, 
    0.18162577f, 0.04435685f, -0.01437990f, 0.23148257f, -0.22530803f, 0.03355331f, -0.26359490f, -0.08951919f, 
    0.16963579f, -0.58993673f, 0.23805422f, 0.26211259f, 0.26438031f, -0.45936358f, 0.11686420f, 0.07172048f, 
    -0.01312217f, -0.12649892f, 0.08945628f, 0.33519819f, -0.07425091f, 0.13779970f, -0.32618961f, 0.01708726f, 
    -0.19098561f, 0.07745443f, 0.05615988f, 0.23085099f, -0.40838587f, -0.00265279f, -0.51593065f, 0.23932506f, 
    -0.29092959f, -0.04538329f, 0.01216100f, 0.09877724f, -0.28182936f, -0.14922000f, 0.06423506f, -0.00801329f, 
    0.16877954f, 0.28390810f, 0.23709284f, 0.09190063f, 0.05655105f, 0.13007043f, 0.29982167f, -0.29885009f, 
    -0.16321528f, -0.34942219f, 0.25942838f, 0.00019682f, -0.50268584f, -0.01958758f, 0.02016348f, 0.06910386f, 
    -0.11707967f, -0.21184047f, 0.07157422f, 0.34334633f, -0.64802933f, -0.07649694f, -0.18255582f, 0.13397847f, 
    0.27203706f, 0.07431850f, 0.26817289f, 0.23735082f, 0.04041409f, -0.17305601f, -0.19448169f, 0.24873360f, 
    -0.12894936f, 0.68499190f, 0.30879423f, 0.21191111f, 0.41240457f, -0.36838964f, -0.06029454f, 0.32306948f, 
    -0.41583842f, 0.20209478f, -0.28797132f, -0.35372207f, 0.25494054f, 0.10242901f, 0.25048879f, -0.07464929f, 
    -0.16140205f, -0.10237833f, -0.01372380f, 0.00848346f, 0.08925407f, -0.10489003f, -0.00661546f, 0.03344247f, 
    0.05729932f, -0.05057751f, 0.03476606f, 0.04539080f, 0.08780611f, -0.09787202f, -0.12100556f, -0.03189427f, 
    -0.01212998f, -0.13781446f, -0.14008400f, 0.03829252f, 0.05107138f, 0.00331166f, -0.02148248f, 0.00402540f, 
    0.04415815f, -0.07838866f, -0.00495935f, -0.10145009f, 0.06497858f, -0.07223248f, 0.04641046f, -0.03231646f, 
    -0.05644762f, 0.07072099f, 0.08027930f, 0.01130026f, -0.06764773f, -0.05403249f, 0.03346041f, -0.06480242f, 
    0.06671312f, -0.08989431f, -0.10133739f, -0.07806259f, -0.05462943f, -0.05549445f, -0.11487247f, 0.06187933f, 
    -0.11691091f, 0.00472380f, -0.00167660f, -0.07306573f, -0.06147836f, -0.18096676f, -0.01969506f, 0.09114100f, 
    0.10824601f, 0.07654815f, 0.00232463f, -0.10879838f, 0.03589579f, 0.01021972f, 0.01796422f, -0.08958369f, 
    -0.04761771f, 0.12359317f, -0.17191620f, 0.27610862f, -0.22632639f, 0.15858211f, 0.23920140f, 0.07432270f, 
    -0.14329740f, -0.12469227f, 0.04398151f, -0.02883269f, -0.19000860f, 0.24831571f, -0.13812435f, 0.23022424f, 
    -0.04013605f, 0.29404983f, -0.05615164f, 0.04796825f, 0.28750992f, 0.16058598f, -0.10635075f, 0.16551037f, 
    -0.54304814f, 0.02136431f, 0.08421180f, 0.05810693f, 0.36875913f, -0.20680532f, 0.07330684f, 0.20561209f, 
    0.13488719f, 0.15180144f, -0.01683305f, -0.20556837f, 0.56775737f, 0.22027282f, -0.11418767f, 0.18402697f, 
    -0.07775527f, 0.11195334f, 0.17357856f, -0.25041971f, 0.35719472f, 0.24077803f, 0.14567129f, 0.41654709f, 
    0.03953236f, 0.09643847f, -0.05230850f, -0.09085926f, -0.06552170f, -0.21513399f, 0.05044200f, 0.10896974f, 
    0.24271329f, 0.21830925f, -0.09804792f, -0.04412957f, 0.21636076f, -0.03110798f, 0.28391129f, -0.23259079f, 
    -0.04566194f, 0.10020331f, -0.01073996f, -0.03389485f, 0.00282722f, -0.11725440f, 0.02321833f, 0.08239418f, 
    -0.01279188f, -0.09628584f, 0.01058358f, 0.03049727f, 0.06737667f, -0.02694849f, -0.03545586f, -0.04342185f, 
    -0.01543208f, -0.12909627f, 0.05656643f, -0.03457866f, -0.13436970f, 0.05927404f, -0.07320520f, 0.02502142f, 
    0.01386993f, 0.04210507f, 0.06748767f, -0.12418161f, -0.09706964f, -0.15307933f, -0.10341081f, -0.06800687f, 
    0.00756332f, -0.00010786f, 0.08150599f, -0.12263342f, -0.06836272f, -0.14115553f, 0.00342428f, 0.05647411f, 
    -0.05782885f, -0.06798564f, -0.00433515f, -0.15548500f, 0.05687879f, -0.09141304f, -0.10111509f, -0.04750247f, 
    -0.10466196f, -0.10768845f, 0.00364927f, -0.12686503f, -0.01442590f, -0.04619908f, -0.13900740f, -0.09276351f, 
    -0.11484033f, 0.08829043f, 0.02825360f, 0.09588805f, 0.03959907f, 0.09819113f, -0.08499924f, 0.07128337f, 
    -0.05429268f, 0.01232408f, 0.14205754f, -0.40574965f, 0.28843126f, -0.34569517f, 0.37619495f, -0.02755374f, 
    0.16680975f, -0.04759571f, -0.06488674f, -0.06331863f, 0.37405783f, -0.56458288f, 0.02683229f, -0.13864486f, 
    0.99121243f, -0.07643933f, 0.01133808f, -0.11137770f, -0.14844443f, -0.23619473f, 0.20735304f, 0.11770549f, 
    0.04096869f, 0.04131445f, -0.19941778f, -0.24862802f, -0.13347177f, -0.07029506f, 0.09775180f, 0.02093756f, 
    -0.18211442f, -0.04349090f, 0.10815440f, 0.03311832f, 0.64833647f, -0.04747224f, 0.45622879f, -0.05667217f, 
    0.03874125f, -0.05145694f, -0.07010886f, 0.14390866f, 0.06266151f, -0.17484100f, 0.06535511f, -0.04263603f, 
    0.04336711f, 0.28027391f, -0.04808576f, -0.05299802f, 0.29287878f, 0.32498193f, -0.02632945f, 0.25388405f, 
    0.45473820f, 0.02558904f, -0.07643087f, 0.01847792f, 0.37482813f, -0.01181112f, -0.08975323f, 0.18496673f, 
    -0.04601710f, 0.36763179f, -0.11647397f, -0.01715647f, -0.28969792f, 0.01692856f, 0.14206818f, 0.06715114f, 
    -0.15297079f, -0.15087318f, 0.25637117f, -0.10097791f, -0.32504943f, 0.06345984f, -0.06755640f, 0.22266713f, 
    0.05644703f, 0.38367403f, -0.17255518f, 0.06625628f, 0.19848691f, 0.11413147f, 0.17669560f, 0.19026181f, 
    -0.45688114f, -0.06527018f, 0.41918597f, 0.42308268f, -0.36452878f, -0.28517258f, 0.07029611f, 0.08607192f, 
    0.22139966f, 0.34418902f, 0.05498993f, 0.14713091f, 0.39128149f, 0.32065529f, -0.07400377f, 0.12877901f, 
    0.17239484f, 0.01592298f, 0.15585327f, -0.08984660f, 0.00470124f, 0.20104691f, 0.05549875f, 0.47763991f, 
    0.06016690f, 0.35021427f, 0.16293642f, 0.21343879f, 0.27106416f, -0.23347053f, 0.05820237f, -0.02569670f, 
    0.11162739f, 0.19449146f, -0.16798766f, -0.32959715f, -0.00602543f, 0.08362211f, 0.37163061f, -0.28081751f, 
    0.16594020f, 0.16763481f, 0.37671092f, 0.01238775f, -0.30984440f, -0.20629990f, -0.41705865f, 0.14457321f, 
    -0.31903177f, -0.16384763f, -0.16202712f, 0.07352412f, -0.08525054f, -0.25843641f, 0.04340848f, -0.13917647f, 
    0.13946071f, -0.04550745f, 0.14876010f, -0.03259527f, 0.02552662f, -0.02002596f, 0.27516618f, -0.02659731f, 
    0.10619492f, 0.08100943f, 0.29010332f, 0.10221412f, -0.12312460f, -0.05797131f, 0.04983845f, -0.19612427f, 
    0.16355157f, 0.14414845f, 0.32309452f, 0.24233398f, 0.46577722f, 0.06551971f, 0.26271197f, -0.22387020f, 
    0.14600731f, 0.06141426f, 0.11141790f, 0.23374753f, -0.14132209f, -0.24070850f, -0.17860137f, 0.16517092f, 
    0.02808226f, 0.49501312f, 0.20462993f, -0.01171166f, 0.33314884f, -0.15272452f, -0.17001988f, 0.27035877f, 
    0.06989832f, -0.05786090f, -0.25994879f, -0.03901168f, 0.24002798f, 0.12389406f, -0.00320166f, -0.09943655f, 
    0.27395162f, -0.30654204f, -0.33252186f, 0.33846650f, -0.50144106f, 0.32169029f, 0.27876249f, 0.02650612f, 
    -0.19769150f, 0.19500363f, 0.07927522f, 0.06655170f, 0.24256214f, 0.27656245f, 0.05076279f, 0.19544327f, 
    0.23186190f, 0.26015651f, -0.15112509f, 0.18755727f, -0.17209673f, -0.38334414f, -0.12865382f, 0.18082100f, 
    -0.04271000f, -0.12936263f, -0.48910800f, -0.19924022f, 0.26033527f, 0.12040903f, 0.02394464f, 0.07444020f, 
    0.18717249f, -0.12971409f, -0.11843368f, -0.55444205f, 0.16964075f, -0.32459676f, 0.13592522f, -0.23676492f, 
    -0.15851134f, -0.06047706f, -0.11031293f, -0.38843027f, 0.33415678f, 0.16142939f, 0.29040125f, -0.26730296f, 
    0.04779710f, 0.18544443f, -0.06826932f, -0.31082338f, -0.49542484f, 0.46518120f, 0.06797791f, -0.08223251f, 
    0.57736427f, -0.00400192f, 0.49134001f, 0.22568083f, 0.16606724f, -0.34435570f, 0.10542483f, 0.27533117f, 
    -0.08877950f, 0.10086296f, -0.04876824f, -0.03270210f, 0.18842134f, -0.09585425f, 0.26727173f, -0.05416086f, 
    0.34478092f, -0.13207395f, 0.40028960f, -0.03912742f, -0.12048902f, -0.36463508f, -0.17241283f, 0.27931213f, 
    0.31327885f, 0.29354805f, -0.11893107f, -0.03477748f, -0.17330813f, -0.09765393f, -0.10054459f, 0.15381972f, 
    -0.31018516f, -0.17537917f, -0.08174153f, 0.15297090f, -0.10882295f, -0.15113564f, -0.00196353f, 0.08558459f, 
    0.10903593f, 0.02547360f, -0.01816143f, 0.13043591f, 0.56052911f, -0.15631847f, 0.20993167f, 0.14974321f, 
    0.31110567f, -0.07346410f, 0.07022591f, 0.00237165f, 0.36725640f, 0.08781478f, 0.31619060f, 0.26938766f, 
    -0.14318816f, 0.20710441f, 0.12519360f, -0.07458284f, 0.09951398f, 0.40466723f, -0.06827030f, -0.20097156f, 
    0.16844574f, 0.20511942f, -0.09736748f, -0.30160841f, 0.11962181f, -0.15644696f, 0.42121542f, 0.01356409f, 
    0.04130576f, 0.14060770f, 0.31318966f, 0.02987792f, 0.00172562f, -0.51262212f, 0.37533912f, -0.23411597f, 
    0.04563692f, -0.00972561f, -0.10139892f, -0.08854774f, 0.21659242f, -0.55590713f, 0.13476400f, 0.02182835f, 
    0.30754310f, 0.21947204f, 0.06051139f, 0.25652143f, -0.22596619f, -0.14306355f, -0.13723414f, -0.43526393f, 
    0.20450729f, 0.05421238f, 0.08378541f, 0.04403093f, -0.21203330f, -0.00816548f, 0.09818608f, 0.06182368f, 
    0.54811198f, -0.00462998f, 0.55459970f, 0.20543189f, 0.66249919f, -0.07311681f, 0.04558875f, -0.31041309f, 
    -0.26636466f, -0.05793920f, 0.17795411f, 0.30236349f, 0.09173447f, 0.36124054f, 0.34560895f, -0.09059279f, 
    0.04381555f, -0.45978600f, 0.11870456f, -0.33646432f, 0.33498392f, -0.01242146f, -0.03994197f, -0.32684821f, 
    0.22308938f, -0.37807739f, -0.00855946f, 0.22815907f, -0.47417602f, 0.02502890f, 0.19661388f, 0.21087009f, 
    0.08117238f, -0.04225044f, -0.09882970f, 0.05161407f, 0.04697271f, -0.07609294f, -0.01145901f, -0.11519392f, 
    -0.08940721f, -0.04920764f, 0.00793906f, -0.01446286f, -0.07414447f, -0.08836488f, 0.06285360f, 0.01874102f, 
    -0.05902958f, 0.01366164f, -0.01615795f, -0.12376072f, -0.05054098f, -0.03347684f, -0.04835349f, 0.02264336f, 
    -0.10896721f, 0.06625541f, 0.09718444f, 0.10678750f, -0.03849276f, 0.06956168f, 0.11504014f, 0.07540894f, 
    -0.00409146f, -0.00736037f, 0.01044750f, -0.06466123f, 0.02610206f, 0.07603597f, -0.03264842f, 0.07590867f, 
    -0.08668488f, 0.07181916f, -0.02529556f, -0.12246507f, 0.07498146f, -0.03162136f, 0.06129846f, -0.01068653f, 
    -0.04870166f, 0.02720818f, -0.07814551f, -0.02338074f, -0.09058265f, -0.06329933f, -0.09271493f, 0.02399996f, 
    -0.04721974f, -0.07941408f, 0.05463506f, 0.10501283f, -0.03334071f, 0.01838399f, -0.11757207f, -0.08224578f, 
    0.73440796f, 0.03371792f, 0.05743252f, 0.00899363f, 0.40293929f, 0.17156078f, 0.11912355f, 0.05574881f, 
    0.03752745f, -0.08858632f, 0.25921482f, -0.04423353f, -0.15135737f, 0.13523138f, -0.29361948f, 0.12172457f, 
    -0.10505158f, 0.14691530f, -0.02469721f, -0.04902940f, 0.07914537f, -0.15617222f, -0.39712656f, 0.49891058f, 
    -0.38278377f, -0.37515485f, 0.34976310f, 0.34803271f, -0.24100851f, -0.14505757f, 0.02855999f, 0.22412544f, 
    -0.62640649f, 0.07374554f, -0.22873485f, 0.17820646f, -0.16100402f, 0.00113371f, 0.32340947f, 0.12880546f, 
    0.06057104f, -0.12254339f, -0.30675605f, 0.11278623f, -0.00887191f, 0.04484931f, 0.10949545f, 0.12436541f, 
    0.22133078f, -0.10776067f, 0.06686664f, 0.33516213f, 0.25136366f, 0.09491012f, 0.14931211f, -0.19234021f, 
    0.03551132f, 0.20021947f, 0.01286006f, -0.03750188f, -0.13075513f, -0.00045054f, 0.10465686f, -0.32597154f, 
    -0.08616041f, 0.08295504f, 0.09008063f, -0.11580974f, 0.72588003f, -0.02059731f, -0.28774646f, 0.01316709f, 
    0.31768844f, -0.16324936f, -0.03573482f, -0.03296391f, 0.02141535f, -0.11533688f, 0.27823862f, -0.15550877f, 
    -0.15713029f, -0.15974303f, 0.13809234f, -0.09020343f, 0.17655812f, 0.10046410f, 0.43406907f, -0.09101111f, 
    0.16629249f, -0.16011047f, 0.27421075f, 0.24704571f, -0.07845693f, 0.08987498f, 0.11256866f, 0.17184517f, 
    -0.27323678f, -0.20220496f, -0.09598181f, 0.17203742f, 0.13776670f, -0.04753870f, 0.06081396f, 0.06908635f, 
    0.16991466f, 0.01524958f, -0.17513032f, 0.19195057f, -0.03770773f, -0.06533770f, -0.13201261f, 0.09661188f, 
    0.17402355f, 0.44006735f, -0.02856762f, 0.35761586f, 0.21409267f, -0.70153445f, 0.02289384f, 0.53105867f, 
    -0.17293940f, -0.01210280f, -0.17894132f, 0.01651806f, 0.11730532f, 0.42050767f, -0.08417712f, 0.15265132f, 
    -0.21162280f, 0.19966938f, -0.02380059f, -0.47266850f, 0.22585219f, -0.15615182f, 0.18244722f, 0.00435677f, 
    0.30466765f, 0.03035171f, 0.03964736f, -0.05206939f, 0.42316163f, -0.06850680f, -0.03047328f, 0.16474138f, 
    0.15044123f, -0.18043189f, -0.06679801f, -0.15893556f, 0.23002617f, 0.17311108f, 0.02094525f, 0.02594434f, 
    0.13266096f, 0.25323871f, 0.35905603f, -0.23957519f, 0.30679333f, 0.06471065f, 0.04685791f, -0.04001317f, 
    -0.07231561f, 0.36962184f, 0.24313027f, 0.11203623f, 0.68398088f, 0.12711899f, 0.17864212f, 0.21424505f, 
    0.15623075f, -0.02154377f, -0.05019331f, 0.14231561f, -0.11513270f, -0.16315803f, -0.09553371f, 0.08751269f, 
    0.27622786f, -0.05337838f, -0.18088503f, 0.26166359f, 0.20229182f, -0.29664257f, 0.10785477f, 0.23497887f, 
    0.28362975f, -0.04348923f, -0.13431054f, 0.17699927f, 0.31339896f, -0.00573574f, -0.10993762f, 0.06737393f, 
    -0.04173271f, -0.12946752f, -0.30549407f, 0.17856887f, -0.29090711f, 0.18005218f, -0.10273702f, 0.07669510f, 
    0.01630243f, 0.11991397f, -0.01017283f, 0.09897251f, -0.10514639f, -0.08716809f, -0.20918074f, 0.32185289f, 
    -0.26613662f, 0.23677902f, 0.08301793f, 0.46243635f, -0.04602727f, -0.13185261f, -0.20667352f, -0.22317500f, 
    -0.00200752f, -0.53200626f, -0.18968673f, -0.21645823f, -0.23676828f, 0.24644707f, -0.06253555f, 0.06185859f, 
    -0.01275694f, 0.18621162f, -0.07146326f, 0.05153506f, -0.26617041f, -0.17267168f, -0.66138387f, 0.34583777f, 
    0.10489616f, -0.08989278f, 0.20019366f, 0.03013465f, -0.03070566f, 0.28679767f, 0.13270910f, -0.07227505f, 
    0.24492417f, -0.45851928f, 0.24409553f, -0.23590496f, 0.00536497f, 0.01574091f, 0.04361384f, -0.32226211f, 
    0.09578425f, 0.16070156f, 0.12626724f, -0.13087103f, -0.18020128f, -0.05737797f, 0.28015313f, 0.03015188f, 
    0.28777614f, -0.00880616f, 0.06670571f, 0.18148525f, 0.43720797f, -0.00797210f, 0.03491464f, 0.10278491f, 
    0.07472953f, 0.19458885f, -0.13806838f, -0.05065164f, 0.10036063f, 0.08072788f, 0.24320252f, -0.04450207f, 
    -0.33281103f, -0.08566722f, 0.32134467f, 0.12605141f, -0.07772546f, 0.01307918f, -0.01764606f, 0.01393837f, 
    0.69328624f, 0.07005879f, -0.00461715f, 0.07993130f, 0.00535375f, 0.39012837f, -0.06718647f, 0.17301238f, 
    -0.12655331f, -0.06151225f, 0.06274900f, 0.19926365f, -0.26667714f, -0.18651056f, -0.13120729f, 0.04003897f, 
    0.10506798f, 0.05929676f, -0.08550584f, 0.17491771f, 0.03355986f, -0.02415519f, -0.07309517f, -0.13411915f, 
    0.09068751f, -0.45588294f, 0.16507004f, 0.27985761f, 0.14473215f, -0.17221707f, 0.21056269f, -0.14918827f, 
    -0.10238086f, 0.00551648f, 0.03629346f, 0.22528408f, -0.26599309f, 0.18693601f, 0.00075324f, 0.13147189f, 
    0.25938740f, -0.30900028f, -0.01019198f, 0.09559341f, 0.17117189f, -0.15912434f, -0.09594299f, -0.08804635f, 
    0.17124303f, 0.18459584f, 0.39221761f, 0.08965548f, 0.18586832f, 0.17688018f, 0.17330773f, -0.06922054f, 
    0.42034730f, 0.12977928f, -0.08536873f, -0.00178877f, -0.07151016f, -0.17542987f, -0.05506193f, -0.31119218f, 
    0.37016347f, 0.21790001f, -0.13092057f, -0.00770689f, -0.50652939f, 0.34669232f, 0.03416013f, 0.14074413f, 
    -0.09350881f, 0.11028949f, -0.13124853f, 0.29185498f, -0.37866831f, -0.18747449f, -0.30396467f, 0.08046868f, 
    0.23007759f, 0.04170378f, 0.00408118f, 0.30859157f, -0.35596016f, 0.15664393f, 0.00010246f, -0.02301812f, 
    0.16436362f, -0.22512363f, 0.13829108f, 0.10154662f, 0.26825926f, 0.06918095f, 0.10507566f, -0.21906072f, 
    -0.12202907f, -0.39046723f, 0.17776941f, 0.19960026f, 0.01421220f, -0.09942831f, -0.25193083f, 0.19772767f, 
    -0.33838180f, -0.00354990f, 0.01669607f, -0.37998602f, 0.61419106f, 0.03456877f, -0.22018495f, -0.06200666f, 
    0.47749126f, -0.01372161f, 0.40161699f, -0.10492366f, -0.06958815f, 0.19515669f, 0.04035258f, -0.00910023f, 
    0.20114793f, -0.06931394f, -0.26267809f, -0.23351541f, 0.32071063f, 0.09189671f, 0.31856340f, 0.04331014f, 
    -0.07069755f, -0.15221234f, 0.23697938f, 0.19048208f, -0.20103297f, 0.02881482f, 0.10093807f, 0.21712391f, 
    -0.22522533f, 0.01290849f, -0.02993246f, 0.24253234f, 0.21137185f, 0.12857917f, -0.29065466f, 0.25747207f, 
    0.57070750f, -0.05980483f, -0.06208960f, 0.14152159f, -0.03346848f, -0.15684713f, -0.06281839f, 0.42289668f, 
    0.23602760f, 0.39551917f, 0.05553372f, 0.42667407f, 0.26450759f, -0.90056664f, 0.22008201f, 0.51621789f, 
    -0.07964525f, 0.11508774f, -0.10287055f, -0.15293336f, 0.44921413f, 0.40255445f, 0.06348255f, 0.01500309f, 
    0.05765868f, 0.00479051f, -0.10460639f, -0.05147868f, -0.09117177f, 0.10233049f, -0.09574036f, -0.08490694f, 
    0.03506684f, -0.09066050f, -0.06840129f, 0.02519229f, -0.01719143f, -0.11243324f, -0.12175886f, -0.10238835f, 
    -0.06021591f, -0.12738195f, -0.00819128f, 0.03776548f, 0.03218316f, -0.05190599f, -0.12466068f, -0.10235454f, 
    0.06391965f, 0.00230500f, -0.07322953f, 0.00748357f, -0.09186468f, -0.14485590f, -0.01828806f, 0.04785630f, 
    -0.12691768f, -0.09796567f, 0.08017936f, -0.00103776f, -0.12230109f, 0.02949999f, -0.08729790f, -0.11168104f, 
    -0.05871582f, -0.09417129f, -0.12296225f, 0.07867665f, -0.00612517f, 0.02565082f, -0.13778403f, -0.00621687f, 
    -0.08454209f, -0.05558906f, -0.10105351f, 0.02540326f, 0.04070158f, 0.00928511f, -0.10610186f, 0.04836621f, 
    0.08988115f, -0.09436269f, -0.03807688f, -0.07516474f, -0.02500565f, -0.00921154f, 0.03128292f, 0.03555764f, 
    -0.46779719f, -0.03379685f, -0.12943700f, -0.49049374f, 0.21718219f, 0.19299597f, 0.44901836f, 0.14097942f, 
    0.52040106f, 0.25349933f, 0.02071170f, -0.11153048f, 0.11314852f, 0.00960414f, 0.12218376f, -0.27333564f, 
    0.31753543f, -0.42790294f, 0.16742094f, 0.09807981f, 0.09488466f, 0.20597683f, -0.04996515f, 0.14931910f, 
    0.21057908f, 0.06308035f, -0.28090954f, -0.01594172f, 0.43359983f, 0.30262351f, -0.08154598f, 0.09493697f, 
    0.09408113f, -0.26944777f, -0.04060088f, 0.06538737f, 0.01568893f, 0.01649769f, -0.07048299f, 0.30122653f, 
    0.10463490f, -0.05152551f, -0.19428428f, -0.05731410f, -0.01037658f, -0.35949111f, -0.12909675f, -0.32825604f, 
    0.15882589f, -0.35764942f, 0.33072221f, 0.22913136f, -0.21780275f, 0.33940414f, 0.17213011f, -0.21620129f, 
    -0.09816356f, 0.09453038f, -0.23732916f, -0.25083384f, 0.01578167f, -0.10425102f, -0.17494218f, 0.34626845f, 
    -0.08422025f, 0.15276659f, 0.04833471f, -0.33995336f, 0.11178852f, -0.47259974f, 0.16051446f, -0.10533363f, 
    -0.06540433f, -0.05829972f, -0.10543939f, 0.05718743f, 0.12736620f, -0.12473460f, 0.05564471f, -0.06141029f, 
    0.28572011f, -0.00963639f, -0.17716075f, -0.00764809f, 0.23466936f, 0.23701182f, -0.16814557f, -0.13997228f, 
    -0.35856178f, 0.32163739f, 0.40633887f, -0.30840063f, 0.09554380f, -0.01642457f, -0.11136145f, 0.10118604f, 
    -0.08606958f, 0.20718528f, 0.16580161f, -0.13280973f, 0.79304421f, 0.23188873f, -0.31135312f, 0.22958428f, 
    0.02748444f, 0.09047637f, 0.10733057f, 0.27880427f, -0.39295232f, 0.28930014f, 0.01744162f, 0.19122076f, 
    0.27890715f, -0.40219620f, -0.13042642f, -0.08846022f, 0.21983856f, -0.42879230f, -0.00834186f, 0.35960090f, 
    0.44476971f, -0.02405198f, -0.04370758f, 0.34226760f, 0.43559730f, -0.03908780f, -0.19081102f, -0.15793154f, 
    0.30183241f, 0.26903760f, 0.21662301f, -0.20775422f, 0.06978021f, 0.02758470f, 0.28427184f, -0.08154652f, 
    0.33045030f, -0.23503463f, 0.19700655f, -0.04983256f, 0.12729496f, -0.21741673f, -0.35610369f, 0.15108745f, 
    0.11453696f, 0.17368846f, -0.15501492f, 0.18314847f, -0.26991409f, 0.14642878f, -0.22272348f, 0.22815605f, 
    0.08613519f, -0.10976806f, 0.36961636f, 0.14450379f, -0.13196757f, -0.04009907f, -0.09020573f, 0.00686817f, 
    -0.03856931f, 0.18819554f, 0.00127048f, 0.52526021f, 0.26179445f, 0.05228973f, 0.07366519f, 0.26026240f, 
    0.22356771f, -0.01498950f, -0.25271016f, 0.32629520f, -0.12901376f, 0.01117375f, 0.04073199f, 0.08256461f, 
    0.03810420f, -0.42932048f, 0.26570106f, 0.32770976f, 0.28398696f, 0.09537643f, 0.06085440f, -0.14384383f, 
    0.29578382f, 0.03067987f, -0.24868315f, -0.06387381f, -0.29082909f, 0.31324682f, 0.11339612f, -0.09784921f, 
    0.33569020f, 0.13359846f, 0.03899314f, -0.21654285f, 0.35371640f, 0.50948846f, 0.51451218f, -0.09902341f, 
    0.17573828f, -0.02761401f, -0.00878374f, 0.01135367f, 0.26960912f, 0.11045571f, -0.06448057f, 0.13424708f, 
    -0.05980285f, -0.18402548f, 0.22195177f, -0.11988579f, -0.30331814f, 0.10353692f, 0.01823463f, 0.61963385f, 
    0.19285862f, -0.26703900f, -0.04539771f, 0.19858806f, 0.37839198f, 0.08510749f, -0.05362622f, -0.09109037f, 
    0.11442152f, -0.06025491f, 0.20324424f, 0.09591941f, -0.07976603f, 0.14132032f, 0.77256644f, -0.06484779f, 
    -0.14164254f, -0.03348017f, -0.38260439f, -0.38698196f, 0.41996810f, -0.18978931f, -0.22700879f, -0.41239285f, 
    -0.44010127f, 0.09692298f, 0.12074139f, -0.00583458f, -0.38036153f, 0.39348984f, -0.04269347f, -0.22154979f, 
    0.26300889f, 0.19384821f, -0.15492567f, 0.07675520f, -0.36757362f, -0.19134733f, 0.19319877f, 0.10248931f, 
    0.21036179f, -0.02635305f, 0.37354687f, 0.44931123f, -0.58450335f, -0.08981098f, -0.41556719f, 0.24592666f, 
    -0.29140660f, 0.16807182f, -0.22412796f, 0.01858108f, 0.13050023f, -0.20125876f, 0.34471557f, -0.07474937f, 
    -0.38753292f, -0.18059781f, 0.39606136f, 0.07658244f, -0.22311723f, -0.03632898f, 0.22548498f, -0.36917925f, 
    0.66513681f, 0.06129342f, 0.15040275f, -0.10948130f, -0.17784671f, 0.32993281f, 0.10916795f, -0.04205207f, 
    0.38481668f, -0.30725640f, 0.39383295f, 0.36720142f, -0.71812916f, -0.04378420f, -0.24279201f, -0.25676343f, 
    0.13258365f, 0.05806129f, 0.13223070f, 0.18621777f, 0.03985466f, -0.12174755f, -0.00021144f, -0.06620324f, 
    -0.30374327f, 0.08566707f, 0.38169533f, 0.17062435f, 0.19889566f, 0.24895047f, -0.10766035f, -0.19343801f, 
    -0.35352018f, -0.18190804f, 0.17636701f, 0.05360739f, -0.19880798f, -0.06840093f, 0.25505707f, 0.28059781f, 
    0.20534912f, -0.26354390f, -0.12319531f, 0.03361304f, 0.67947805f, 0.12038145f, 0.08217880f, 0.07566333f, 
    0.39872259f, 0.09500125f, 0.31014103f, -0.11844966f, 0.10359583f, 0.03077741f, -0.03558823f, -0.06442930f, 
    0.19273800f, 0.04898907f, 0.13234441f, -0.14209333f, 0.09560547f, -0.04847508f, -0.26987132f, 0.28278986f, 
    0.01865736f, -0.31235346f, -0.25073639f, -0.09513287f, 0.03043107f, 0.15047723f, -0.08407579f, 0.21592088f, 
    -0.40600890f, -0.47755763f, -0.32850680f, -0.16210437f, 0.07176354f, -0.28770524f, 0.08533560f, 0.17250077f, 
    0.34488481f, -0.04026192f, -0.30993378f, -0.00458415f, 0.01910573f, 0.00892326f, 0.36382377f, -0.02492752f, 
    0.33224565f, -0.14059715f, -0.16448413f, -0.06065895f, -0.12290289f, -0.15915069f, -0.03813827f, 0.11539051f, 
    0.03435024f, -0.01946083f, 0.11050101f, -0.14075974f, 0.11870459f, -0.06085388f, 0.01554961f, 0.10913272f, 
    -0.31150559f, -0.28714088f, -0.00838329f, 0.04665473f, 0.09891776f, -0.31867072f, 0.31868240f, 0.00992544f, 
    0.26758176f, -0.04574645f, 0.04145900f, 0.09293281f, 0.24168478f, -0.16536926f, -0.15108517f, 0.05243922f, 
    0.39725673f, 0.07794227f, 0.15116809f, -0.14254503f, -0.32685602f, -0.19314052f, -0.17417932f, -0.13250414f, 
    0.61273688f, 0.08849394f, -0.21572937f, -0.01971429f, -0.12765716f, 0.33557796f, 0.02919996f, 0.00186463f, 
    0.19824018f, 0.02398929f, 0.27795547f, 0.35084864f, 0.53353113f, -0.49823850f, -0.06254110f, -0.05779944f, 
    0.23672549f, 0.00302023f, -0.02460620f, 0.19201159f, 0.22226058f, 0.14936218f, 0.24012622f, -0.26456854f, 
    -0.03603662f, -0.56576115f, 0.22169130f, -0.05488055f, 0.23969491f, 0.47323588f, -0.08551423f, -0.75232428f, 
    0.27101043f, 0.09241042f, -0.09073534f, -0.01840241f, -0.47471452f, -0.09826134f, 0.08096305f, 0.24248098f, 
    0.17868531f, 0.30482191f, 0.17219532f, 0.00221563f, -0.26166999f, -0.10744502f, 0.34611019f, 0.19034904f, 
    -0.11714362f, 0.02665529f, -0.36007303f, -0.08111187f, -0.03561108f, -0.44568056f, 0.19569185f, 0.10137044f, 
    0.36523375f, -0.02311782f, 0.16349769f, 0.20509791f, -0.23483562f, 0.12985860f, -0.10201901f, 0.26655409f, 
    0.36577582f, 0.23719479f, 0.03659692f, -0.08155546f, 0.70857024f, 0.19252133f, -0.08642656f, -0.14418289f, 
    0.13436596f, 0.10629486f, 0.52062184f, -0.07784072f, 0.38319004f, 0.03556176f, 0.15573610f, -0.07948072f, 
    -0.12213168f, 0.06009556f, -0.17993303f, 0.04817660f, -0.00618157f, -0.06391142f, -0.15330590f, -0.07588902f, 
    -0.29683441f, -0.01520563f, 0.15877506f, -0.09925723f, 0.29975164f, 0.05332807f, -0.19093578f, 0.06779914f, 
    0.54884797f, 0.16871792f, -0.23250632f, 0.09750342f, 0.07610743f, -0.21729863f, -0.13284467f, 0.14159331f, 
    -0.12694207f, -0.13050145f, -0.16289952f, 0.34545174f, 0.24125324f, 0.09197696f, -0.00068622f, -0.06488121f, 
    0.10893068f, 0.05092106f, 0.36362806f, 0.02991917f, 0.11311363f, 0.44752339f, -0.19724385f, -0.01939331f, 
    -0.21542479f, 0.26288238f, -0.11434881f, -0.07983244f, 0.21028282f, -0.14515494f, 0.11547427f, -0.19258390f, 
    -0.12191336f, 0.17082764f, -0.18581897f, -0.00287671f, -0.15196431f, -0.09342252f, -0.01354075f, 0.12230073f, 
    -0.00501834f, 0.02188242f, -0.19769619f, -0.02776480f, -0.33436674f, -0.03930554f, -0.24386008f, -0.02038740f, 
    0.09871481f, -0.09129111f, 0.28725576f, -0.04193970f, 0.40557578f, 0.14217250f, 0.18823959f, -0.03925322f, 
    0.20535266f, 0.18269028f, -0.13960354f, -0.08763240f, -0.12653397f, 0.28999978f, 0.20075163f, 0.09030865f, 
    -0.00155279f, -0.05220549f, 0.30964428f, 0.01022872f, 0.03846565f, -0.07166625f, 0.34697354f, -0.12248568f, 
    0.37948474f, 0.06454452f, -0.23397283f, 0.00508112f, -0.28469938f, 0.04790858f, 0.09986233f, 0.02972119f, 
    -0.24689710f, 0.18208399f, 0.05598469f, 0.04782518f, -0.27785045f, 0.45426357f, -0.11789481f, 0.17668545f, 
    0.05672082f, 0.20871708f, -0.13140014f, 0.37449017f, 0.35289630f, 0.13653487f, -0.34088665f, -0.08785364f, 
    -0.33861539f, 0.20129710f, 0.14011101f, 0.16795714f, -0.04760011f, -0.06504104f, -0.10942933f, 0.25886726f, 
    -0.13769382f, 0.22339600f, -0.06238639f, 0.10687638f, -0.24253781f, 0.12056996f, -0.17310674f, 0.25058836f, 
    -0.04018620f, -0.06473158f, 0.22048433f, 0.30707708f, -0.09747671f, 0.23997727f, 0.06079623f, 0.20694274f, 
    0.19167195f, -0.50512254f, 0.15104951f, -0.02290386f, 0.04315231f, -0.22758618f, 0.23047592f, 0.10868399f, 
    0.15864196f, 0.01842890f, 0.22245605f, 0.33547428f, 0.05195563f, 0.01990307f, -0.22821777f, -0.18922189f, 
    -0.44219783f, -0.10754753f, 0.03256734f, -0.36788592f, 0.06935982f, 0.29662338f, 0.11315502f, 0.20876199f, 
    0.18685231f, 0.39311999f, -0.07982540f, -0.02226803f, -0.02844643f, -0.00529383f, 0.04397185f, -0.18337414f, 
    0.09276550f, -0.36971331f, 0.40008146f, 0.07591955f, -0.07239900f, 0.24965231f, 0.21591720f, 0.13779755f, 
    0.53078502f, 0.16192023f, -0.01835231f, -0.23351113f, 0.17276324f, 0.33959550f, 0.00489182f, 0.11062317f, 
    -0.30680123f, -0.20722121f, 0.15659104f, 0.30890521f, -0.60525197f, 0.10303159f, -0.04249486f, 0.06944598f, 
    0.16499551f, -0.02560411f, -0.21873029f, 0.10033286f, 0.03787594f, -0.25644335f, -0.17913455f, 0.00393124f, 
    0.01743014f, -0.07564525f, 0.16256012f, 0.39279553f, -0.07781851f, 0.34911495f, 0.19309945f, -0.16011856f, 
    -0.88580394f, 0.31553978f, -0.19125330f, -0.34646124f, 0.00059737f, 0.10664655f, -0.34408200f, -0.01166220f, 
    0.39043537f, 0.02360484f, -0.02685420f, 0.02179746f, 0.24933757f, -0.27111533f, 0.11322037f, 0.00029518f, 
    -0.08236889f, -0.04702323f, 0.03014553f, 0.05948924f, -0.07179044f, -0.34457147f, 0.14264928f, 0.15014127f, 
    0.77562714f, 0.25675669f, -0.16075633f, 0.07456487f, 0.01087364f, -0.20918638f, -0.34318769f, -0.03806366f, 
    -0.04768543f, -0.24690434f, 0.01151979f, -0.11692669f, -0.22410855f, 0.15107960f, -0.07423022f, 0.06140709f, 
    -0.08377656f, 0.16851951f, 0.01538751f, 0.06790265f, 0.57678449f, -0.28746668f, 0.24670924f, 0.12262549f, 
    0.12339573f, 0.09473504f, -0.13147512f, 0.35863718f, 0.02589920f, 0.02307194f, 0.26781917f, 0.17378360f, 
    0.20032813f, -0.06121876f, 0.23876566f, -0.14836554f, 0.39531818f, 0.40065956f, -0.16018243f, 0.11152493f, 
    0.46262559f, -0.12428180f, 0.01387826f, 0.07589956f, 0.29320654f, -0.00918373f, 0.06634380f, 0.20161332f, 
    0.28467670f, -0.50984859f, -0.04936865f, 0.49554944f, 0.02693322f, 0.04175681f, -0.06719470f, 0.10236929f, 
    -0.01858574f, 0.18048699f, 0.20698567f, -0.07699162f, 0.09230017f, -0.11647115f, 0.38260868f, -0.20496972f, 
    0.32149541f, 0.07931731f, -0.04188935f, 0.00811187f, 0.01374401f, -0.41805243f, 0.13872735f, -0.52928990f, 
    0.24978963f, -0.46659797f, -0.67696440f, -0.08180380f, -0.58565569f, 0.23579314f, -0.01172183f, 0.15612312f, 
    -0.01497614f, -0.41123548f, -0.01040493f, -0.13829575f, -0.32164970f, -0.61315495f, -0.22099771f, -0.26635370f, 
    0.10239968f, -0.03032879f, 0.20071585f, -0.09245008f, 0.32641339f, -0.02059724f, 0.32174522f, -0.20093885f, 
    -0.05917175f, 0.28700531f, -0.01599498f, -0.31098768f, -0.27350578f, 0.47818711f, -0.08804934f, -0.13554296f, 
    0.00249096f, -0.34941655f, 0.34542429f, 0.11546829f, 0.29118243f, -0.16454522f, 0.19944781f, 0.43635330f, 
    -0.39658767f, 0.10319722f, -0.14056954f, 0.20598777f, -0.40043610f, 0.04335890f, 0.05784436f, -0.14877546f, 
    -0.10624774f, -0.03582744f, -0.49995878f, 0.09110923f, 0.37560457f, 0.33796975f, 0.04802144f, 0.30273962f, 
    -0.82605380f, 0.14224248f, -0.25732234f, 0.12452838f, -0.02724303f, 0.08507366f, -0.15632103f, -0.36634094f, 
    -0.06085852f, 0.07399516f, -0.15146923f, -0.31660581f, 0.29369679f, 0.01017595f, 0.01971007f, 0.05840081f, 
    0.29904574f, 0.20993322f, 0.01619925f, -0.07038565f, 0.64176613f, 0.34115106f, -0.20006883f, -0.19891891f, 
    -0.46247989f, -0.04544012f, 0.35421243f, -0.23184505f, 0.12618205f, 0.35793114f, 0.23483928f, -0.24156483f, 
    0.06769822f, -0.32595000f, -0.33434907f, -0.48240337f, -0.37176880f, 0.16706078f, 0.21451788f, -0.13949299f, 
    0.25407284f, -0.00671859f, -0.05829217f, 0.23855299f, -0.58822793f, 0.06530170f, 0.26138213f, 0.20590690f, 
    -0.00160959f, -0.05269270f, 0.04646081f, -0.07808321f, 0.21288808f, 0.08746950f, 0.06180294f, -0.07521009f, 
    -0.07973348f, 0.10127562f, -0.08979964f, -0.03655687f, -0.16444115f, -0.24046063f, -0.10217200f, -0.36658418f, 
    -0.06854847f, -0.23937513f, 0.03323447f, -0.11132380f, 0.05783704f, 0.08923421f, 0.16141316f, 0.13916712f, 
    0.05587696f, 0.08099426f, 0.08874127f, 0.26351953f, -0.41565311f, 0.02388978f, -0.01660612f, -0.11017411f, 
    -0.29586601f, -0.49343812f, -0.31992143f, -0.01042234f, -0.28553081f, -0.05683150f, 0.08081700f, -0.02402949f, 
    -0.00567476f, -0.09559682f, -0.13712917f, -0.08370345f, 0.00648872f, -0.28430387f, -0.12425651f, 0.04192694f, 
    -0.06567469f, 0.19872022f, 0.07735141f, 0.16746518f, -0.13888998f, 0.13392055f, -0.16790619f, -0.09425233f, 
    -0.23115221f, 0.07127408f, -0.26079628f, -0.33437312f, 0.11697826f, 0.18056218f, 0.03414232f, 0.06541656f, 
    -0.00447226f, 0.04690550f, -0.06555014f, 0.03335649f, 0.01843452f, -0.11336629f, 0.04855616f, -0.01158127f, 
    0.03741053f, 0.09547177f, -0.09419113f, -0.09065834f, 0.01798269f, -0.00488721f, -0.02309436f, 0.01302323f, 
    -0.09216249f, 0.00092116f, -0.07114605f, 0.03031704f, 0.08939938f, -0.12187304f, -0.14980829f, -0.14472094f, 
    -0.00081519f, -0.00190173f, 0.03408793f, -0.06035599f, 0.02857342f, -0.02605663f, -0.08163936f, 0.01335862f, 
    0.06397252f, -0.02577824f, -0.06943768f, -0.07122957f, -0.12035410f, 0.09699052f, -0.00487725f, -0.04052912f, 
    -0.09871298f, 0.03512261f, -0.11402590f, 0.00796405f, 0.01051888f, 0.04408682f, -0.01800050f, -0.04195312f, 
    -0.11820757f, 0.03163916f, 0.00511891f, -0.05324227f, 0.07339834f, 0.09471367f, -0.07289584f, 0.08068272f, 
    -0.08128446f, 0.04469021f, 0.03258950f, -0.03795789f, 0.05660175f, -0.06134850f, -0.13551524f, -0.03908177f, 
    -0.01635662f, 0.20293950f, -0.02442556f, -0.20580521f, 0.59168488f, 0.18572441f, 0.54287302f, -0.02530946f, 
    0.39347526f, 0.01780829f, -0.13070574f, -0.05074444f, 0.06408063f, 0.05109710f, -0.11795384f, 0.23960572f, 
    -0.24231906f, -0.12633856f, 0.25687408f, 0.18532912f, 0.08251044f, 0.08944400f, -0.13573949f, 0.37435618f, 
    -0.18910393f, -0.20945172f, 0.01195556f, 0.17298801f, 0.65973473f, 0.07467213f, -0.01429111f, 0.06754093f, 
    0.01414165f, 0.16988195f, 0.05139108f, -0.15520687f, 0.78126884f, 0.12569806f, 0.14043921f, 0.07934584f, 
    -0.03824318f, 0.06233957f, -0.10843188f, -0.21213536f, 0.31753871f, 0.19356364f, 0.08657160f, -0.08915597f, 
    0.09775509f, -0.35309154f, 0.12512381f, 0.17610900f, -0.25491324f, 0.03990284f, 0.12417823f, -0.21920405f, 
    0.57635146f, 0.25996774f, -0.31873667f, 0.05630349f, -0.00852539f, 0.03008266f, 0.15039341f, -0.12130862f, 
    0.01648080f, -0.07983932f, -0.04457839f, 0.10376953f, -0.00160417f, -0.02386126f, 0.04620721f, -0.01710444f, 
    0.02450025f, 0.02656309f, -0.05821166f, 0.03773277f, -0.06622514f, -0.03696323f, 0.00655024f, -0.03893444f, 
    0.00694486f, -0.07158811f, -0.03227073f, -0.11360423f, -0.01507873f, -0.06020500f, -0.02674071f, -0.10970414f, 
    0.05076462f, 0.03069496f, 0.01660473f, 0.11816080f, -0.13294126f, 0.02882146f, -0.10766125f, 0.09045064f, 
    -0.12431319f, 0.02022231f, 0.06313217f, -0.04431342f, -0.06919717f, 0.00633098f, 0.03393064f, 0.05082532f, 
    -0.04227008f, 0.10205507f, -0.09069876f, -0.11300253f, 0.06985205f, 0.00019087f, -0.05921831f, -0.05869706f, 
    0.03453121f, -0.05816808f, -0.12256068f, -0.01941220f, -0.07741395f, -0.08802261f, -0.13913669f, 0.10207870f, 
    0.08955823f, 0.00554338f, -0.07291378f, -0.13610399f, 0.07422741f, 0.05763988f, 0.05967442f, -0.09418944f, 
    0.04779568f, -0.08553309f, 0.04503911f, 0.23929210f, -0.23244733f, -0.16792813f, -0.08127504f, 0.01936008f, 
    -0.11429347f, 0.29254770f, -0.10349104f, 0.04343178f, -0.00716428f, 0.26012880f, 0.29521197f, -0.04771668f, 
    0.39395523f, -0.01363065f, -0.03692172f, 0.15849952f, -0.05337862f, -0.02278767f, 0.04857237f, -0.17649068f, 
    0.03499621f, 0.40941045f, -0.12665056f, -0.13194367f, 0.14853263f, 0.25032032f, -0.10627531f, 0.14135914f, 
    -0.12869640f, 0.24207413f, 0.12278384f, -0.06541444f, -0.01188533f, -0.01247334f, -0.31272081f, 0.12119222f, 
    -0.10783426f, 0.02684201f, 0.15901533f, 0.13838984f, -0.02780539f, 0.22402284f, 0.06583987f, -0.03492568f, 
    0.20544991f, -0.20706756f, -0.03526601f, -0.12020936f, 0.03538995f, 0.23603652f, 0.01086039f, 0.02177407f, 
    0.23700011f, -0.16790771f, 0.43731451f, 0.15902199f, 0.27497283f, -0.19428985f, -0.09978799f, 0.29274443f, 
    0.11061002f, -0.04332314f, -0.00086189f, -0.07765638f, 0.14165871f, 0.12039153f, -0.09637072f, -0.11333583f, 
    -0.08111552f, 0.10204294f, 0.07339988f, -0.04294185f, 0.03198832f, -0.01027195f, -0.03579899f, -0.09005917f, 
    -0.04591983f, 0.04863011f, 0.07663643f, -0.14326431f, -0.04851191f, -0.15323178f, -0.06795886f, -0.00742478f, 
    0.04370955f, -0.10561820f, 0.01568413f, 0.07622553f, 0.05250462f, -0.05874684f, -0.05273004f, -0.14267480f, 
    -0.00651589f, -0.14341654f, -0.05419879f, -0.00985750f, -0.12783784f, -0.16728562f, -0.12283387f, -0.03703150f, 
    -0.13397029f, 0.09281127f, 0.05462244f, 0.07537954f, -0.10620829f, 0.02895719f, -0.03239177f, -0.02927670f, 
    -0.06676318f, -0.04422302f, 0.04119335f, -0.12565453f, -0.05801784f, -0.02694958f, -0.05397382f, -0.07832374f, 
    -0.13886894f, -0.08221839f, -0.08432444f, 0.03437475f, -0.12497985f, -0.01142763f, 0.01635615f, -0.05775170f, 
    -0.01966985f, -0.05800058f, -0.09686282f, -0.05641675f, 0.00544867f, -0.08165419f, -0.04498911f, 0.11647481f, 
    -0.01624744f, -0.01098104f, 0.00730470f, -0.08148839f, 0.02472809f, 0.03662123f, -0.05109280f, -0.05316718f, 
    0.09936531f, -0.05124870f, 0.09304290f, 0.07749096f, 0.10398862f, -0.10091254f, -0.00146472f, 0.03091924f, 
    -0.09570244f, -0.03504688f, -0.07475811f, 0.11490612f, -0.00584365f, 0.06346588f, -0.07408568f, -0.03214648f, 
    0.02602990f, -0.09687945f, 0.02715243f, -0.09142567f, -0.08232221f, -0.02367771f, -0.08386633f, -0.07984114f, 
    0.11714485f, -0.05202258f, -0.09762707f, -0.03591777f, -0.09375569f, 0.00937806f, 0.06666294f, -0.10640746f, 
    0.07445706f, 0.08980198f, 0.03112410f, -0.02068923f, -0.06649093f, -0.09526661f, -0.11345257f, -0.01476999f, 
    0.04377918f, -0.10030732f, -0.01871364f, -0.06656298f, -0.09977092f, -0.03703603f, 0.00990812f, -0.01608874f, 
    0.17586413f, -0.03112778f, -0.17643665f, 0.48427913f, -0.00256619f, 0.21753985f, -0.22138149f, 0.21834630f, 
    -0.10944349f, 0.10346242f, -0.01905484f, 0.00210976f, 0.04341525f, 0.37455815f, 0.08172926f, -0.08272766f, 
    -0.20381775f, 0.02829398f, -0.05579962f, 0.00945493f, 0.32037598f, 0.12662446f, 0.16534714f, -0.07752808f, 
    -0.05149781f, 0.50351191f, -0.06512720f, 0.13302152f, 0.32039681f, 0.08867931f, -0.04801513f, 0.27177659f, 
    -0.04733215f, -0.06012190f, -0.10817908f, -0.25069258f, -0.35116237f, -0.04360823f, -0.18943003f, 0.13880360f, 
    -0.10471781f, 0.07238922f, 0.39311430f, 0.04244170f, 0.27851909f, 0.07516611f, 0.01494623f, 0.01414482f, 
    0.24126422f, 0.01059848f, -0.08565694f, 0.01482609f, -0.28838226f, -0.28144637f, 0.22512862f, 0.13440001f, 
    0.07450216f, -0.02680952f, 0.31420416f, 0.49144652f, 0.10696272f, -0.09585701f, 0.03508805f, 0.03113270f, 
    0.35644719f, -0.08765657f, -0.26835689f, 0.39129648f, -0.06108035f, 0.12459172f, 0.21831751f, 0.20983896f, 
    -0.00080491f, 0.11328789f, -0.03857280f, -0.06528200f, -0.11340782f, 0.01747224f, -0.18010987f, 0.31773227f, 
    0.18232612f, 0.14382455f, -0.13660027f, 0.29859123f, -0.05393685f, -0.11857662f, -0.34116441f, 0.21777676f, 
    -0.46107316f, -0.46103907f, -0.10027064f, 0.09580121f, 0.27866322f, 0.01207634f, 0.09163809f, 0.15396003f, 
    -0.35819319f, 0.08814595f, -0.21127824f, -0.10712010f, 0.17002131f, -0.13286677f, 0.00522564f, 0.22012419f, 
    -0.05157789f, -0.03140816f, 0.07166900f, 0.11914177f, 0.43200901f, 0.33492911f, 0.11954992f, 0.03706873f, 
    0.25766355f, -0.09037422f, 0.10523727f, -0.17836133f, 0.00999886f, 0.25779474f, 0.09743600f, -0.25617662f, 
    0.48840296f, 0.01412715f, 0.29490143f, 0.23027267f, 0.08440393f, -0.28499684f, 0.29407749f, -0.10105706f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16671808f, 0.33598337f, -0.11043218f, 0.20879348f, 0.19319721f, 0.10465170f, 0.01757929f, -0.08214687f, 
    -0.05306027f, -0.10282907f, -0.08028189f, -0.14196967f, 0.31844240f, -0.14162011f, 0.14988638f, 0.17261432f, 
    0.18764880f, 0.22207661f, 0.18683174f, 0.29510513f, 0.08679479f, 0.24313331f, 0.44571492f, -0.13984762f, 
    -0.09980822f, 0.04286995f, 0.04195141f, 0.26471162f, 0.23785980f, -0.18077420f, 0.06051304f, -0.23281215f, 
    0.06855270f, 0.32077682f, 0.17278634f, 0.04290811f, 0.26316825f, 0.27246076f, 0.35176498f, 0.18121241f, 
    0.04978804f, 0.06223146f, -0.11040000f, 0.07212991f, -0.29482535f, 0.24448466f, -0.04186625f, 0.24697565f, 
    -0.04749921f, -0.07653148f, 0.15103677f, 0.10836293f, 0.30373430f, 0.15695965f, -0.08268708f, -0.02528390f, 
    -0.12884237f, -0.21843611f, -0.12023152f, 0.06638234f, -0.07779038f, -0.12099174f, 0.10242955f, 0.14922304f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.16086940f, 0.03885736f, 0.07740140f, -0.18397132f, -0.49724054f, -0.19798058f, 0.25289974f, -0.22056344f, 
    0.01996046f, -0.00590902f, -0.00661497f, -0.58644855f, -0.20627896f, -0.11343156f, 0.46959162f, 0.15649505f, 
    -0.15955389f, 0.17804654f, -0.44959235f, 0.06063345f, -0.59212679f, 0.28453970f, -0.35923761f, 0.00698137f, 
    0.06346496f, 0.03282687f, -0.10899469f, 0.07003094f, 0.06033822f, -0.30191472f, -0.01873774f, -0.04953019f, 
    -0.09102952f, 0.36738208f, -0.12881865f, 0.06517487f, -0.17811544f, 0.12233602f, 0.07671367f, -0.05222468f, 
    0.00922214f, -0.09826545f, 0.23547821f, 0.37439543f, -0.13312486f, -0.02302244f, -0.19227014f, -0.08960987f, 
    0.28185764f, -0.10734843f, 0.27116674f, -0.61567634f, 0.16967045f, -0.52263808f, -0.67312139f, -0.18393582f, 
    0.06189604f, 0.09898616f, 0.04714604f, -0.01606248f, -0.07027833f, -0.00779337f, -0.05813054f, 0.25215510f, 
    0.07821417f, 0.07229564f, 0.02326885f, -0.67154616f, 0.03991578f, 0.11103333f, 0.10651261f, -0.47255352f, 
    -0.12619574f, 0.21867621f, 0.05268439f, 0.27933919f, -0.13024372f, 0.09238340f, 0.23278686f, 0.09482261f, 
    0.16555481f, 0.19628526f, -0.24069034f, 0.02568144f, -0.29880849f, 0.22389618f, 0.27061483f, 0.03355062f, 
    -0.11930207f, -0.09996866f, 0.09597556f, -0.26108959f, 0.23743026f, 0.60405546f, -0.39990765f, -0.43343768f, 
    -0.02556652f, -0.58950919f, 0.14797874f, 0.11598044f, 0.08627571f, 0.04930844f, -0.15292823f, 0.05975351f, 
    0.07195698f, 0.21226494f, 0.07583702f, -0.13161550f, -0.29850176f, 0.19785494f, 0.09417383f, 0.01723112f, 
    0.28945488f, -0.46856204f, -0.20684049f, 0.27446947f, -0.20943381f, -0.28707880f, 0.26678607f, -0.21795189f, 
    -0.08500643f, -0.08282961f, -0.06021516f, 0.05987012f, -0.04455038f, 0.11965866f, -0.09159697f, 0.01289633f, 
    0.04247703f, -0.01086653f, 0.12157811f, 0.21502359f, -0.28278595f, 0.33717826f, -0.02129953f, -0.71772331f, 
    -0.07023155f, 0.06856519f, -0.04299996f, -0.46540132f, 0.02355654f, -0.06237427f, -0.24382177f, -0.46360058f, 
    -0.26625836f, -0.77368623f, 0.15536973f, 0.13000526f, -0.36360532f, 0.26229429f, -0.61277682f, -0.06625918f, 
    -0.29227561f, 0.07880768f, 0.00735509f, -0.54345548f, -0.57798934f, -0.25885516f, -0.64049375f, -0.54091662f, 
    -0.08178700f, -0.20309369f, 0.21323271f, 0.12078738f, -0.12691674f, 0.26429513f, 0.33059829f, 0.16843010f, 
    0.07819096f, 0.09837477f, 0.20156986f, -0.03938278f, -0.37837800f, -0.08272627f, 0.11121031f, -0.20101152f, 
    -0.53455877f, 0.21713142f, 0.16094376f, -0.02120776f, -0.04701880f, 0.08838007f, -0.81666213f, -0.04556269f, 
    0.09967063f, -0.06794197f, 0.01580683f, 0.29329517f, -0.08725032f, 0.06013261f, 0.35513863f, -0.20359644f, 
    -0.07109366f, -0.29323441f, -0.02258782f, 0.22400925f, 0.23733203f, -0.01358421f, -0.46386325f, 0.05998650f, 
    -0.11531057f, -0.11362790f, 0.01792159f, 0.17623076f, -0.87472093f, 0.03918314f, 0.02323814f, -0.21197464f, 
    -0.03104208f, 0.05368532f, -0.65708810f, 0.04194007f, 0.22783543f, -0.22580469f, -0.14949438f, 0.01232171f, 
    0.12000994f, -0.11050531f, -0.48086712f, -0.07057825f, 0.03129566f, 0.26109099f, -0.16583982f, -0.08417488f, 
    -0.05911857f, 0.07404603f, -0.42348331f, -0.55139595f, 0.10921714f, -0.13542399f, -0.17696917f, -0.52387947f, 
    -0.04779154f, -0.16289346f, -0.13364688f, -0.51861596f, 0.28117570f, 0.19217566f, 0.09362906f, -0.53602684f, 
    -0.02607892f, 0.14356771f, 0.23912863f, 0.02629303f, -0.10562070f, 0.19853458f, 0.24738225f, -0.09448462f, 
    -0.02590305f, -0.05899713f, -0.03869030f, 0.12836227f, -0.00695137f, -0.05500640f, 0.25129840f, 0.20921452f, 
    -0.01143770f, 0.15225138f, 0.10594124f, 0.27941981f, 0.07609671f, -0.05505725f, -0.13443951f, 0.41413984f, 
    -0.02266510f, 0.07651534f, 0.00419204f, -0.00110536f, -0.01957306f, -0.11343979f, -0.60844672f, 0.20887834f, 
    0.04912783f, -0.00028486f, -0.01904292f, -0.35969573f, -0.28261638f, -0.10016919f, 0.00115556f, 0.07066215f, 
    0.17959481f, -0.01644765f, 0.17584729f, 0.18182480f, -0.11820873f, -0.37279326f, 0.19548462f, -0.35253266f, 
    -0.03753837f, 0.23765071f, -0.13808553f, 0.01475803f, 0.19297679f, -0.27084881f, 0.02710660f, 0.11911307f, 
    -0.02341759f, 0.23177673f, 0.14345607f, 0.07500582f, -0.68733960f, -0.79261589f, -0.07212916f, -0.45153660f, 
    -0.20724222f, 0.05726342f, 0.14401498f, -0.12499365f, 0.18334971f, -0.40350777f, 0.04313082f, 0.11544263f, 
    -0.08942083f, -0.03584242f, 0.09467228f, 0.06692849f, -0.08056924f, -0.08727272f, -0.01602182f, 0.13440201f, 
    -0.02772299f, -0.07646679f, -0.04835463f, -0.25912258f, -0.14402133f, -0.34033006f, 0.24685541f, 0.54686648f, 
    -0.01178398f, 0.07322706f, 0.03000498f, 0.28182811f, 0.13002652f, -0.12124240f, -0.44640228f, 0.24297819f, 
    0.32631186f, 0.17942204f, 0.48175874f, 0.04431303f, -0.11788030f, -0.01104762f, 0.33753052f, -0.02917745f, 
    -0.24518219f, 0.10674444f, 0.24631111f, 0.16835625f, 0.26224464f, -0.02953532f, 0.07112930f, 0.57142073f, 
    -0.08264457f, -0.12002418f, 0.13669692f, 0.03779919f, -0.37081107f, -0.11597782f, 0.04982056f, 0.12155848f, 
    -0.04177411f, 0.01751154f, 0.08701360f, 0.17354959f, -0.13722323f, -0.12803112f, -0.19919978f, 0.31831950f, 
    -0.09664792f, -0.39822066f, -0.11539619f, 0.12631889f, -0.00783689f, -0.15463752f, -0.12114279f, 0.15122226f, 
    -0.08600470f, -0.30560601f, -0.08000961f, -0.24106114f, -0.04693745f, -0.03121328f, -0.55740982f, -0.63039881f, 
    -0.02622017f, 0.26361483f, 0.09761564f, 0.20691223f, 0.35010386f, 0.09614649f, -0.09601723f, -0.68635374f, 
    0.04013149f, -0.02392767f, -0.01171472f, -0.15638947f, 0.26235241f, -0.00965490f, -0.83324021f, 0.07715712f, 
    0.06558368f, 0.22130299f, -0.44081655f, 0.11522344f, 0.16456527f, 0.08087725f, 0.38256451f, -0.01647715f, 
    0.10558002f, -0.04180676f, -0.57339996f, 0.25391355f, 0.08750990f, -0.72768986f, -0.05301779f, 0.08981661f, 
    -0.12746489f, 0.05238451f, 0.19840857f, -0.03976913f, -0.52942789f, -0.04208124f, -0.00532361f, 0.17129534f, 
    -0.05253621f, -0.81745809f, -0.18732779f, 0.00263307f, -0.59021050f, 0.11788096f, -0.63103873f, -0.91077572f, 
    -0.61687541f, 0.17936243f, -0.02911841f, -0.11726380f, -0.59070426f, -0.14890240f, -0.58815527f, -0.19181050f, 
    -0.11184528f, -0.40727088f, -0.05305434f, -0.14516771f, -0.02401113f, -0.00201139f, 0.17055613f, -0.30931199f, 
    0.05931509f, -0.63142842f, -0.08409721f, -0.08853185f, -0.31854710f, -0.37133539f, -0.17224765f, 0.44508946f, 
    -0.02363594f, 0.18828423f, -0.03741900f, 0.23076048f, -1.02246761f, 0.01401503f, -0.10399589f, -0.34152022f, 
    -0.63233268f, 0.06506690f, -0.30584291f, -0.73700547f, 0.00272702f, -0.24318314f, -1.02638996f, -0.07081496f, 
    0.14990345f, -0.05856556f, 0.08773963f, -0.00091507f, -0.06059176f, 0.19888514f, 0.16738704f, 0.13199429f, 
    -0.07049187f, -0.45648307f, -0.56180501f, -0.07385063f, 0.09852910f, -0.50925285f, -0.57004613f, -0.46829990f, 
    0.02282095f, 0.13330066f, 0.10803293f, -0.04486808f, 0.03643720f, -0.28672570f, -0.33417308f, 0.19439824f, 
    0.19552256f, 0.08904762f, -0.11490966f, 0.47103569f, 0.04276225f, -0.17499314f, 0.26200023f, -0.08590623f, 
    -0.03253850f, 0.21513383f, 0.01813099f, 0.06159994f, 0.07376877f, 0.02441715f, -0.02783512f, 0.15996121f, 
    -0.06217685f, 0.06008654f, -0.05300260f, -0.47974211f, -0.59654486f, 0.13134880f, -0.05224483f, -0.28211111f, 
    0.08160811f, -0.09908830f, -0.05255757f, -0.26689285f, 0.12383964f, -0.11372142f, 0.08748484f, -0.66572082f, 
    0.01519256f, 0.15814696f, 0.27107000f, 0.06298846f, 0.34333158f, -0.29325190f, -0.46059456f, -0.15235054f, 
    -0.54497635f, -0.02440885f, 0.21687739f, -0.47340035f, -0.01776172f, -0.11850452f, 0.05375079f, -0.25635150f, 
    -0.00104170f, -0.09196517f, 0.01088522f, 0.03641950f, -0.37710297f, 0.14248617f, -0.01064876f, -0.08201847f, 
    -0.05427156f, 0.29958519f, -0.72927499f, 0.17997327f, 0.68887693f, 0.07867958f, 0.12491570f, 0.34600043f, 
    0.08704270f, 0.02005868f, -1.01571810f, 0.20774668f, -0.21444111f, 0.07990313f, -0.52068532f, -0.25080189f, 
    0.11858294f, 0.29569277f, -0.10405568f, -0.23167239f, -0.15626621f, 0.09933341f, -0.38813093f, -0.36195120f, 
    -0.21345545f, 0.15482505f, -0.12223703f, 0.05684550f, 0.15447116f, -0.10404456f, 0.05126522f, 0.06113890f, 
    -0.11415306f, -0.45012560f, 0.03406766f, -0.57086587f, 0.42182061f, -0.02224075f, 0.17912899f, 0.18830478f, 
    -0.40833032f, -0.14714187f, 0.35043898f, 0.06336644f, -0.07242394f, -0.15278351f, -0.08235428f, -0.14160219f, 
    0.19034198f, -0.05798907f, -0.34880182f, 0.02376751f, -0.29914838f, -0.64298159f, 0.16334148f, 0.50372124f, 
    0.04670679f, 0.31494704f, 0.11786049f, -0.09972785f, 0.27050176f, 0.02180232f, -0.32989895f, 0.12271097f, 
    -0.13293713f, 0.00295347f, -0.01572461f, 0.05686960f, 0.19249651f, -0.47552496f, 0.33072779f, -0.07593748f, 
    -0.27117556f, -0.04880656f, -0.07865161f, -0.17753896f, -0.06087882f, -0.71763301f, 0.15905349f, 0.02839138f, 
    0.10936850f, 0.41476828f, -0.13406843f, -0.34387827f, -0.09252194f, -0.04027000f, -0.04129553f, 0.16358130f, 
    0.04608270f, -0.73121500f, 0.09956209f, -0.06079931f, 0.04047158f, -0.08360183f, -0.23429690f, -0.24978602f, 
    0.05374689f, -0.09692496f, -0.12041330f, 0.06127759f, 0.02090730f, -0.12507878f, 0.16266033f, -0.26455230f, 
    -0.34755123f, -0.01713834f, -0.41399926f, 0.05919526f, 0.28239211f, 0.12987943f, -0.04353430f, 0.04490006f, 
    -0.34539795f, -0.10743014f, -0.00764411f, -0.38429144f, -0.19944786f, 0.02692828f, 0.11467276f, 0.24393472f, 
    -0.02720924f, 0.13055310f, -0.27281085f, -0.51898396f, 0.33958086f, 0.24434319f, 0.32781795f, -0.37499908f, 
    0.11201482f, -0.28627366f, -0.54560673f, -0.04774491f, -0.88173127f, 0.44427708f, -0.11740376f, 0.59152532f, 
    -0.02988220f, -0.00332180f, -0.15892322f, 0.00419034f, 0.24866158f, 0.37179169f, -0.03869280f, 0.02780066f, 
    -0.12180393f, -0.42552078f, -0.10312194f, 0.21737486f, 0.07911631f, 0.07412164f, -0.07041766f, -0.01816162f, 
    0.03838974f, 0.05670005f, -0.01382466f, 0.16074190f, 0.15621227f, -0.02988304f, -0.67969322f, -0.39554513f, 
    0.09008610f, -0.49094924f, -0.13817436f, 0.24758644f, -0.37878019f, 0.05553029f, -0.17893201f, -0.36116153f, 
    0.39687246f, -0.19709107f, -0.03940778f, 0.08013365f, -0.03325178f, -0.40898442f, 0.20864916f, -0.14371353f, 
    0.01877799f, -0.11765085f, 0.23398356f, -0.10888385f, 0.25789320f, 0.06084358f, 0.24134931f, -0.16513401f, 
    0.06230229f, -0.03110509f, 0.12221268f, -0.17011607f, -0.11042547f, -0.21889600f, 0.03315019f, 0.06470920f, 
    0.05884331f, -0.36482802f, -0.08187205f, -0.41720167f, 0.25664735f, -0.19233099f, 0.22122221f, -0.03039266f, 
    -0.03916666f, 0.13388851f, -0.04587241f, -0.91593301f, 0.27151585f, 0.29805502f, -0.85958511f, -0.20050621f, 
    0.07453220f, -0.19511877f, 0.00266612f, 0.10326724f, 0.07389475f, -0.08020321f, 0.17430617f, 0.07117920f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.05316353f, -0.00320174f, -0.09654300f, -0.16539432f, 0.17856571f, 0.07750474f, 0.21652754f, -0.52599150f, 
    -0.18182318f, -0.01378888f, 0.12839997f, 0.13389099f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
