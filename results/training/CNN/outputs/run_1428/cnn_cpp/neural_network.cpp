#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.59090221f, 0.75756508f, 0.17828281f, -0.45350024f, -0.26331866f, -0.13828675f, 0.34143573f, 0.44897744f, 
    -0.01706108f, 0.03946019f, -0.07102342f, -0.26586059f, -0.10461995f, -0.87029588f, -0.12174777f, 0.47589263f, 
    -0.07719567f, -0.25763771f, 0.07835688f, -0.05829327f, -0.06049410f, -0.07775139f, -0.45624521f, -0.46273074f, 
    -0.64734554f, 0.66984665f, 0.97293484f, 0.67372912f, -0.06121948f, -0.68962228f, -0.09799296f, -0.31175944f, 
    -0.26741579f, 0.11013974f, -0.13455503f, 0.23612140f, -0.28887579f, -0.19301312f, 0.12942176f, -0.53849339f, 
    0.28407615f, 0.26800808f, 0.18237346f, -0.17243578f, -0.08083270f, -0.22771172f, -0.04949383f, -0.11858270f, 
    0.14025421f, 0.17798731f, -0.79605365f, 0.96793330f, 0.38918093f, -1.47197676f, -0.03559615f, 0.70157677f, 
    -0.26455906f, -0.53169942f, -0.60666752f, -1.02711678f, -0.31133491f, 0.21422528f, 0.00782862f, -0.01946373f, 
    -0.05499231f, 0.18801641f, -0.67723060f, -0.34777915f, -0.17043266f, -0.45600677f, -0.04067225f, 0.53805399f, 
    0.02137057f, -0.05246181f, 0.14635216f, -0.20493408f, 0.06196363f, 0.42565766f, 0.11513240f, 0.20528646f, 
    -0.10398617f, 0.31433660f, 0.58639258f, 0.05184782f, 0.45751184f, -0.29747295f, -0.16625877f, 0.58491468f, 
    0.29701981f, -0.16725092f, -0.25628230f, 0.18038400f, -0.43118280f, -0.16018720f, -0.16658187f, 0.06299179f, 
    -0.41001293f, -0.16771209f, 0.08894292f, 0.32983181f, -0.50910854f, -0.67736202f, -0.69910663f, -0.63037771f, 
    -0.60312480f, -0.21131468f, -0.61787033f, -0.32386717f, -0.64877874f, -0.61871684f, 0.17110741f, 0.31539559f, 
    0.32835811f, 0.22767411f, 0.31851780f, -0.04476355f, -0.05771006f, 0.18897755f, 0.09842957f, -0.02031838f, 
    -0.06162693f, -0.41471764f, 0.14746788f, 0.11190989f, 0.11787732f, 0.00477683f, -0.49757516f, 0.41617653f, 
    0.17158516f, -0.32160503f, -0.72422945f, -0.36762759f, 0.61073542f, 0.03869678f, 0.02881528f, 0.23317514f, 
    -0.05026407f, -0.32964644f, -0.21561450f, 0.42463002f, 0.23956661f, -0.09116971f, -0.50962299f, -0.10961742f, 
    -0.21053503f, 0.20268966f, -0.46254066f, -0.13519104f, 0.10026097f, 0.57810909f, -0.76623148f, -0.62224835f, 
    -0.67739058f, -0.22284666f, -0.68099964f, -0.18562189f, -0.53444576f, -0.36796895f, -0.28490284f, 0.00556693f, 
    -0.38872892f, -0.45445821f, -0.31493878f, -0.43098485f, -0.40546748f, 0.08599687f, 0.00813847f, -0.26369688f, 
    0.30603033f, 0.01338513f, -0.28060412f, 0.12243476f, -0.28524029f, -0.40628824f, -0.14316042f, -1.50595570f, 
    -0.42220548f, -0.32816866f, -0.39353505f, -0.75982404f, 0.32422924f, 0.37488115f, 0.36662498f, 0.74761480f, 
    1.03976667f, 0.08212718f, 0.05018340f, 0.20226403f, -0.01611140f, 0.23191820f, -0.31713334f, 0.14260417f, 
    -0.26057988f, -0.27618533f, 0.02056924f, -0.02826227f, 0.08829483f, 0.48568806f, -0.04033837f, -0.04855490f, 
    -0.05017531f, 0.08233413f, 0.08332314f, 0.25874877f, -0.22953682f, 0.30627829f, -0.02599899f, 0.09976278f, 
    -0.06367301f, 0.53531027f, 0.21599278f, -0.05444167f, -0.23356450f, 0.59026396f, -0.24545610f, -0.47550693f, 
    0.01210928f, -0.11319097f, 0.18246621f, 0.22119634f, -0.11257052f, 0.49131936f, 0.45837140f, -0.12378982f, 
    -0.25897503f, 0.46411934f, 0.93329990f, -0.32455397f, -0.45359838f, -0.38316038f, -0.74206012f, -0.19161931f, 
    -0.09761652f, -0.10259691f, 0.14234744f, 0.10559959f, 0.00484824f, 0.38936111f, -0.40817145f, 0.02509589f, 
    -0.10813019f, 0.06265336f, 0.03582005f, -0.12100157f, -0.25237381f, -0.25700504f, -0.29187092f, -0.61032426f, 
    -0.64389426f, -0.68510610f, -0.97869635f, -0.38072002f, -0.37444410f, -0.53369498f, 0.37361252f, -0.56143481f, 
    -0.32567918f, -0.08993875f, -0.24487917f, -0.23428053f, 0.68105102f, -0.00478445f, -0.20852937f, -0.07552025f, 
    -0.29914600f, -0.44589296f, -0.48091453f, -0.34419194f, -0.29471627f, -0.72446275f, -0.07649919f, 0.14594379f, 
    0.17443641f, -0.06672056f, -0.36162621f, 0.56192333f, 0.77529836f, 0.41085202f, -0.44869602f, -0.05140898f, 
    -0.56287110f, -0.68390185f, -0.18424518f, 0.12934251f, -0.58288795f, 0.50817603f, -0.37231568f, 0.56581336f, 
    -0.29391024f, 0.42335606f, 0.10186978f, 0.01124395f, 0.26515323f, -0.20828660f, -0.18650825f, -0.16741610f, 
    0.27259222f, -0.20017461f, -0.08408459f, 0.44813022f, 0.85422689f, 0.59140533f, 0.41964063f, -0.08341879f, 
    0.01671515f, 0.05296147f, 0.54252791f, 0.47399288f, -0.19886407f, -0.16377206f, -0.38054430f, 0.24409869f, 
    0.44225991f, -0.14617977f, -0.38109574f, -0.00737879f, 0.03246637f, -0.28952259f, 0.08579276f, -0.33616441f, 
    -0.14131716f, -0.22199447f, -0.26875913f, 0.13417186f, -0.05761173f, 0.76977658f, -0.45178348f, -0.74976265f, 
    -0.72738200f, -0.80014074f, 1.35472810f, 0.49794155f, 0.17451994f, -0.35064173f, 0.12084766f, 0.31932139f, 
    0.21185866f, -0.02072144f, -0.16483013f, 0.00508637f, 0.20535202f, 0.18742657f, 0.00945042f, -0.12759435f, 
    -0.31005955f, 0.01947242f, -0.12991518f, -0.11680936f, -0.09928796f, 0.17150584f, -1.03582144f, -0.96502268f, 
    0.02985139f, 0.56501865f, 0.65132314f, 1.34238875f, 0.87980092f, -0.93652749f, -0.99476558f, 0.09189113f, 
    0.18815970f, 0.05737291f, -0.36415797f, -0.30074596f, -0.69173151f, -0.08407034f, 0.07501440f, 0.03601786f, 
    0.14172792f, 0.10077779f, 0.12171201f, -0.21147543f, -0.03231551f, 0.16770245f, -0.13754100f, 0.94647700f, 
    0.02649228f, -0.59947503f, -0.37581897f, 0.19247875f, 0.08825667f, -0.48522085f, -0.43656623f, -1.02336085f, 
    -0.90484720f, 0.32968011f, -0.22524214f, 0.02553079f, -0.24655031f, -0.06401145f, 0.03437174f, 0.22517493f, 
    0.15036681f, 0.06890073f, 0.13385482f, -0.36417213f, 0.04885978f, 0.29102024f, -0.08155382f, 0.10724789f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.30279645f, 0.46566948f, 0.35966858f, 0.35520461f, -0.29911560f, 0.64007604f, -0.09074216f, 0.28621611f, 
    0.30918363f, 0.00667107f, 0.07897726f, 0.25765109f, 0.23620057f, 0.48825732f, 0.44428965f, 0.30746245f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16007529f, -0.07863157f, 0.04101561f, -0.28146449f, 0.17550477f, -0.04084272f, -0.01408498f, 0.16248888f, 
    -0.07254840f, -0.07317398f, -0.11224543f, -0.14707571f, 0.20226890f, 0.12230764f, -0.45551431f, -0.04115809f, 
    -0.14138758f, -0.00215308f, -0.06651016f, -0.13735741f, 0.01649156f, 0.00539652f, -0.00510418f, 0.05267814f, 
    0.80029905f, -0.15579148f, 0.25381479f, 0.10136176f, 0.07076973f, -0.03118473f, 0.19827360f, 0.00009953f, 
    0.13111150f, -0.02045114f, 0.08493231f, 0.04792653f, -0.18454002f, -0.37072369f, 0.04267245f, -0.19527493f, 
    0.00999593f, -0.00640214f, 0.02011448f, -0.10300487f, -0.05183835f, -0.08117276f, 0.15427549f, -0.03664180f, 
    0.14504670f, 0.19826867f, -0.20114076f, 0.15932733f, 0.15505424f, 0.26163578f, -0.10185751f, 0.02960825f, 
    -0.01576208f, 0.07652381f, 0.08136809f, -0.01536105f, -0.12442217f, -0.02584163f, 0.37720555f, -0.30554175f, 
    -0.02832182f, -0.07376554f, 0.00600409f, 0.37359098f, -0.02474005f, -0.04273940f, -0.08459279f, 0.01316708f, 
    0.14192927f, -0.11192454f, -0.15927410f, 0.06835110f, 0.19204444f, 0.06181972f, -0.01717477f, -0.06850459f, 
    0.09228705f, 0.03679952f, 0.06953071f, -0.03646924f, -0.12784505f, 0.05479420f, 0.02583512f, -0.24823764f, 
    0.16788098f, -0.01891096f, 0.07856966f, 0.11160903f, -0.04593840f, 0.32075554f, -0.01915264f, -0.17640278f, 
    -0.14631143f, -0.30062523f, -0.20937909f, 0.06666990f, -0.03880515f, -0.00529320f, -0.14566545f, -0.09758931f, 
    0.12723830f, 0.21643890f, -0.01845817f, 0.07910920f, 0.18059967f, 0.10182481f, 0.03966863f, 0.15387453f, 
    -0.05727151f, -0.11615238f, 0.22400250f, 0.19205761f, -0.12336729f, -0.10152733f, -0.03460348f, -0.13424672f, 
    0.15194343f, 0.18975770f, 0.23276453f, 0.07619140f, -0.14492317f, 0.00604405f, 0.01288841f, 0.09157837f, 
    0.03107878f, -0.00440004f, 0.09152759f, 0.03774182f, 0.37572226f, -0.04204264f, -0.03239965f, 0.03007130f, 
    -0.09492429f, 0.32665387f, 0.60513932f, 0.14335310f, -0.03889161f, 0.10127184f, 0.12262026f, 0.14889543f, 
    -0.06702924f, -0.34985355f, -0.22849901f, -0.20165823f, -0.09245189f, -0.04038212f, -0.02542326f, -0.03159872f, 
    0.00806112f, 0.08471896f, -0.05994710f, -0.01398224f, 0.20268661f, 0.00382088f, -0.54996657f, 0.14590696f, 
    0.20172426f, 0.02850886f, 0.00629191f, -0.16078478f, 0.09933572f, -0.18551047f, 0.04536175f, -0.24275568f, 
    -0.31682476f, 0.27426237f, -0.17001159f, -0.08749343f, 0.15988941f, -0.09883002f, -0.00627376f, 0.04789742f, 
    -0.09371302f, 0.12612064f, 0.01077038f, 0.02934630f, 0.35806340f, -0.01223370f, -0.30704194f, 0.62007844f, 
    -0.03433896f, 0.08469798f, 0.02276487f, 0.09884428f, 0.10484256f, 0.03649449f, 0.03863614f, 0.03388339f, 
    -0.50558859f, 0.31777126f, -0.13822939f, 0.10182253f, 0.06288055f, -0.03661165f, -0.15116876f, -0.04489383f, 
    0.13319124f, -0.13162489f, -0.06761604f, -0.07370264f, 0.18955511f, 0.10287616f, -0.09826010f, 0.46706390f, 
    0.09033012f, -0.03751472f, -0.03692039f, -0.07175858f, 0.08980800f, -0.13119593f, 0.04046176f, 0.08785799f, 
    -0.36313134f, 0.64445311f, -0.40822592f, 0.16511077f, -0.05201875f, 0.09178171f, 0.23046118f, -0.03366540f, 
    -0.17994234f, -0.02133846f, 0.00168770f, -0.00943789f, 0.06079419f, -0.19922902f, 0.02318043f, 0.26215234f, 
    0.09352601f, 0.02134584f, 0.00597455f, 0.00468694f, 0.01107488f, 0.01320812f, -0.08388860f, -0.14951496f, 
    0.70452178f, 0.58991688f, 0.18450068f, 0.06923597f, 0.16405272f, 0.08881795f, -0.02043896f, -0.03138452f, 
    0.06017971f, -0.03336193f, 0.02405765f, 0.09035999f, 0.01295252f, -0.09845262f, 0.23042762f, 0.10996580f, 
    0.17068914f, 0.07836988f, -0.04708185f, -0.16545635f, -0.04615260f, -0.01858457f, -0.17541535f, 0.17443958f, 
    0.37441033f, 0.43317872f, 0.33254409f, -0.01698273f, 0.06082038f, -0.01351945f, -0.17600499f, 0.13592570f, 
    -0.01564411f, -0.08885628f, -0.05958384f, 0.04647373f, 0.02118659f, -0.29818928f, -0.21151946f, -0.27383652f, 
    -0.02412982f, 0.00714002f, -0.10920566f, 0.18019997f, 0.13979481f, -0.05653681f, 0.03009437f, -0.06723735f, 
    0.06697375f, 0.01324050f, -0.03413824f, 0.14403933f, 0.04452398f, 0.01504729f, 0.08935221f, -0.01099307f, 
    0.02353066f, 0.03275056f, -0.03281225f, 0.04560021f, -0.00049706f, 0.00867304f, -0.07869481f, -0.04168824f, 
    0.07172956f, 0.04864972f, -0.00737934f, 0.07675164f, 0.11370329f, -0.14907467f, 0.07719030f, -0.08928280f, 
    0.19743541f, 0.10075462f, 0.00775950f, 0.03939211f, -0.02203313f, 0.20181903f, -0.01783413f, 0.04986343f, 
    0.08231969f, -0.07859840f, 0.09741353f, 0.06265058f, 0.06091751f, 0.25783044f, -0.11535910f, 0.10875855f, 
    0.02825955f, 0.15757786f, -0.20556125f, 0.08066382f, 0.02677665f, 0.06295580f, 0.03731708f, 0.02660440f, 
    0.24345082f, 0.00793008f, -0.14632778f, 0.30717978f, 0.04360853f, 0.04498741f, -0.01454019f, -0.04557406f, 
    0.14102966f, 0.10892574f, 0.20432225f, 0.09551889f, 0.03612652f, -0.29430792f, -0.50924188f, -0.25825337f, 
    0.00161509f, 0.02990123f, -0.07384812f, 0.22861335f, 0.16784818f, -0.22194117f, -0.04858537f, 0.07809380f, 
    0.42126587f, 0.06158664f, 0.00066454f, -0.08207425f, -0.13832170f, -0.08335424f, 0.09992844f, 0.18925907f, 
    0.11087958f, 0.02302054f, -0.11956609f, -0.05348346f, 0.48420113f, 0.29312780f, 0.00822012f, -0.41110456f, 
    0.12766758f, -0.03062349f, 0.08043834f, 0.07077451f, -0.09817348f, 0.13100357f, 0.09948279f, -0.08517266f, 
    -0.13280223f, 0.07714351f, 0.33996397f, 0.16848896f, 0.01375452f, 0.02798810f, -0.39553422f, -0.03139567f, 
    0.02243056f, 0.33350325f, -0.09072148f, 0.11630391f, -0.48076898f, 0.03242885f, 0.21427056f, -0.66505623f, 
    0.07445283f, -0.09624130f, -0.00991135f, 0.08652281f, 0.07683718f, 0.01892677f, -0.07021712f, 0.04019604f, 
    -0.40906692f, -0.42591336f, 0.35315785f, -0.06762111f, 0.01688630f, 0.03641798f, -0.12408908f, 0.20520951f, 
    0.02061712f, 0.09582027f, 0.08603454f, 0.13287514f, 0.00858526f, 0.10625822f, -0.00297558f, 0.12816374f, 
    -0.04373944f, 0.08066160f, 0.06168808f, -0.04461164f, 0.26818728f, -0.05040720f, 0.25768477f, 0.13657168f, 
    -0.61172801f, -0.33224201f, 0.27078545f, -0.08818416f, -0.14566293f, 0.06610772f, 0.16134205f, -0.02698936f, 
    0.03704337f, 0.05021990f, 0.04047499f, -0.07848535f, 0.05620870f, 0.24134238f, -0.29038405f, 0.17295215f, 
    0.35892901f, 0.28955349f, 0.45996812f, 0.05552948f, 0.39989176f, 0.02696791f, 0.27107015f, 0.11215503f, 
    -0.13471982f, 0.13339958f, 0.03840087f, 0.15922092f, -0.04677224f, 0.07403604f, 0.03933940f, -0.21711855f, 
    0.02755849f, 0.08402108f, 0.05210542f, -0.19892183f, -0.31337076f, 0.61909467f, 0.33848324f, 0.29700333f, 
    -0.07780948f, 0.14040285f, -0.00300856f, -0.18069991f, -0.06634399f, 0.03479670f, 0.05834144f, 0.10999400f, 
    0.02988867f, -0.01314807f, -0.10019555f, -0.16177015f, 0.05631613f, 0.02280418f, 0.05154612f, 0.13185669f, 
    -0.03609869f, -0.07341018f, 0.12742344f, 0.16512091f, -0.12359869f, -0.12141234f, 0.02634350f, -0.42604530f, 
    0.11105367f, 0.08441826f, -0.16754289f, 0.10261703f, -0.17805758f, 0.08843421f, -0.21283373f, 0.17632326f, 
    -0.38557011f, -0.11403982f, -0.03563226f, -0.14210650f, 0.12911117f, -0.01966205f, 0.16643055f, 0.28718174f, 
    0.18937007f, 0.27612224f, -0.24772385f, -0.00636088f, -0.17703481f, -0.13085687f, -0.16043070f, -0.32310924f, 
    0.22869585f, -0.33762273f, -0.14477253f, -0.05448678f, -0.01018485f, 0.18413143f, -0.04424222f, 0.11230041f, 
    -0.07607105f, 0.02037761f, 0.24505612f, -0.13095419f, -0.08710323f, -0.03481386f, -0.07774016f, -0.00829646f, 
    -0.03797823f, -0.19543037f, 0.11325509f, 0.20980708f, 0.62749892f, 0.23594156f, 0.61307710f, -0.08051733f, 
    -0.07717210f, -0.04342921f, 0.11428713f, -0.14876835f, -0.08566820f, 0.38201612f, 0.06763863f, 0.13492273f, 
    0.26457068f, -0.49893954f, 0.03963197f, -0.06414683f, -0.14160796f, 0.00909084f, -0.03855483f, 0.11488772f, 
    0.22725202f, -0.04295939f, 0.31775853f, 0.10824387f, -0.07468107f, -0.17360844f, -0.15070362f, -0.46559915f, 
    -0.13437298f, -0.06838198f, 0.15455393f, -0.09149920f, -0.04548898f, -0.03411214f, -0.14044781f, 0.10712491f, 
    -0.14224420f, -0.12315708f, -0.14019148f, 0.17939101f, 0.02710151f, 0.06954513f, -0.15330268f, -0.09939289f, 
    0.12740557f, -0.01977450f, -0.07007438f, 0.13650580f, -0.08302022f, -0.07121477f, -0.18749891f, 0.33047193f, 
    0.10978831f, 0.11230627f, 0.00924907f, -0.04556407f, -0.02314405f, -0.16534759f, -0.11148069f, -0.06571401f, 
    0.08165730f, 0.55357766f, -0.19972898f, 0.57510674f, -0.23220737f, 0.16941036f, 0.06053101f, -0.01947208f, 
    -0.01735776f, -0.09175421f, -0.01853775f, 0.11619407f, 0.01735775f, 0.09843601f, -0.09825132f, 0.33442149f, 
    0.01421161f, -0.00691834f, -0.13435216f, -0.24219279f, 0.00915359f, -0.09930370f, -0.04991671f, -0.19190645f, 
    0.41410980f, 0.30733541f, 0.26501518f, 0.14448354f, -0.05861237f, 0.03992493f, 0.08317884f, 0.27447736f, 
    0.16681966f, 0.12279311f, -0.02908213f, -0.03940014f, -0.26243472f, 0.05283678f, 0.32651365f, 0.19462977f, 
    0.01925489f, -0.00532658f, 0.01120673f, -0.09622615f, -0.14224868f, 0.06116904f, -0.15549724f, -0.22563784f, 
    0.12655486f, 0.23235331f, 0.15029438f, -0.05974827f, -0.00016137f, 0.21762893f, -0.09639974f, 0.13235901f, 
    0.06713478f, 0.00944828f, 0.08814882f, 0.14560980f, 0.63078398f, 0.22873482f, -0.31771120f, -0.42059082f, 
    -0.13800886f, -0.13827613f, -0.05230921f, -0.20581834f, 0.21572731f, -0.07604833f, -0.00397356f, 0.04523630f, 
    0.09614960f, 0.04130079f, -0.09303872f, -0.06485877f, 0.03004976f, 0.19126356f, 0.08237624f, -0.30542061f, 
    0.05686771f, -0.25248080f, -0.18010923f, -0.00500117f, -0.17320755f, 0.47139716f, 0.13021888f, -0.07969689f, 
    0.13680843f, -0.03128537f, 0.05556724f, -0.15213035f, 0.23674104f, -0.00294681f, 0.13963179f, 0.11794868f, 
    0.09887853f, 0.11143377f, -0.03798944f, 0.33577684f, 0.14244087f, 0.01112252f, 0.05992742f, 0.16281147f, 
    0.07611489f, 0.01067417f, -0.09574595f, 0.05561836f, -0.31001577f, 0.62591296f, 0.01365377f, 0.37531286f, 
    0.00603076f, 0.04108163f, 0.11115004f, 0.12674741f, -0.11746150f, -0.16050309f, -0.09250633f, -0.26751339f, 
    0.08569349f, 0.15638258f, -0.04638292f, 0.41496474f, 0.07528076f, -0.31486395f, 0.03859510f, 0.01924187f, 
    0.01869938f, -0.05716904f, 0.14509416f, 0.07193665f, 0.40540949f, -0.42948905f, 0.03660950f, -0.33111057f, 
    -0.12790306f, -0.25696525f, -0.03209679f, -0.25355333f, 0.14167240f, 0.03298429f, -0.01156212f, 0.15378433f, 
    0.35410187f, -0.63678598f, 0.19714157f, -0.15033993f, -0.21103676f, 0.04176199f, -0.32270715f, 0.07427745f, 
    0.10476479f, 0.15472718f, -0.09824479f, -0.16721837f, 0.31422472f, 0.18770464f, -0.21416047f, -0.13654192f, 
    0.08915113f, -0.15425323f, 0.12582341f, 0.18658143f, -0.24506727f, 0.01777180f, -0.00245122f, -0.13879117f, 
    -0.31402117f, 0.20233881f, -0.25741488f, 0.13314606f, -0.05177727f, 0.00915842f, 0.41607139f, 0.00612656f, 
    0.18279231f, -0.10605118f, 0.27619624f, 0.26580629f, 0.13641794f, -0.10457031f, 0.25197303f, 0.04651156f, 
    0.11618961f, 0.13155922f, 0.04780775f, 0.06181266f, -0.04430270f, 0.04622117f, -0.07126685f, -0.03930673f, 
    -0.57444918f, 0.27969384f, 0.18404977f, -0.27967468f, 0.11145499f, 0.12243018f, 0.05854059f, -0.16048193f, 
    0.14132427f, 0.10078037f, -0.05914709f, 0.02498149f, 0.18187764f, 0.20132902f, -0.06548569f, -0.09426121f, 
    0.06975227f, -0.09868898f, -0.08884669f, -0.05974229f, -0.18212380f, 0.04200160f, -0.07896980f, 0.16511069f, 
    -0.27525893f, -0.06994762f, 0.03042004f, -0.10089367f, 0.06534652f, -0.04448975f, 0.22173882f, 0.08979616f, 
    0.14099297f, -0.04770789f, -0.08221299f, 0.08632110f, 0.38329348f, 0.03585729f, -0.11496016f, 0.27945951f, 
    0.12627706f, -0.10926113f, 0.03024733f, 0.03170087f, -0.10921139f, 0.11399020f, -0.03112224f, 0.14981644f, 
    -0.37313607f, -0.24684735f, 0.09933118f, -0.00015585f, -0.09003700f, -0.24984197f, 0.29309115f, 0.04420432f, 
    0.07257736f, 0.04016315f, 0.13291293f, 0.15971452f, -0.02206636f, -0.29557523f, -0.23276097f, 0.23969342f, 
    0.08562712f, -0.09723527f, -0.09245317f, -0.17720632f, 0.25929135f, -0.07019514f, 0.03041779f, 0.20258553f, 
    0.00549403f, 0.02567682f, 0.11483960f, 0.02467156f, 0.00122504f, -0.04659792f, 0.02552878f, 0.02605193f, 
    0.07749975f, -0.16059102f, 0.03916252f, -0.02801882f, 0.27212968f, -0.04747681f, 0.05084095f, -0.05734572f, 
    0.01235766f, 0.14463620f, -0.01125577f, -0.01177567f, 0.15590584f, 0.30417752f, 0.42513245f, 0.06247754f, 
    -0.20287116f, -0.12379396f, 0.19390197f, 0.14600904f, -0.07940169f, -0.17953598f, -0.11002961f, -0.23552108f, 
    0.02431259f, -0.07290263f, 0.25140655f, -0.00162812f, 0.18789972f, 0.15651670f, -0.05678848f, 0.02226959f, 
    -0.00106399f, 0.01801462f, -0.14913543f, 0.33873552f, 0.08968391f, -0.09520023f, -0.03855149f, -0.03052191f, 
    0.13042146f, 0.29561442f, 0.15008286f, 0.10630199f, 0.03726973f, 0.05062861f, -0.03767188f, 0.03498149f, 
    -0.03967733f, -0.01301552f, -0.04113529f, -0.16202745f, -0.58167857f, 0.42711216f, 0.35189134f, -0.22575104f, 
    -0.05775872f, 0.13159919f, 0.13439833f, 0.06801283f, 0.11870959f, -0.15792176f, 0.09038636f, 0.13993198f, 
    -0.47416413f, 0.11146859f, -0.02194883f, 0.25543344f, 0.27286273f, 0.10772762f, 0.10693806f, 0.13904558f, 
    0.12548105f, 0.23530306f, -0.04393843f, 0.01100318f, -0.17217717f, 0.23683164f, 0.86117971f, -0.12079230f, 
    0.09614358f, 0.18860799f, 0.01580809f, -0.07906210f, 0.13957043f, -0.18143184f, 0.08826828f, 0.04231295f, 
    0.46003315f, 0.01711088f, 0.06702662f, 0.19605899f, 0.10535822f, -0.06940921f, -0.19939294f, -0.16807194f, 
    -0.07735158f, -0.05237520f, -0.20919526f, 0.23355626f, -0.55183470f, 0.00488615f, -0.00884825f, -0.36672616f, 
    0.04693324f, -0.08064978f, -0.20121358f, -0.11397515f, 0.06686144f, 0.02496634f, -0.14651795f, 0.01913058f, 
    0.71877271f, 0.15454820f, 0.24007443f, 0.16306046f, 0.26664418f, -0.11897915f, 0.00416743f, 0.30260295f, 
    -0.06191524f, -0.17987788f, 0.02315408f, 0.05810614f, -0.21809098f, -0.46571171f, -0.44668347f, 0.13199106f, 
    -0.00290225f, 0.02300102f, -0.04294210f, -0.15478316f, 0.07289118f, -0.17204736f, 0.04004619f, -0.12748735f, 
    -0.32197833f, -0.06362598f, 0.39943916f, 0.47219425f, -0.25706050f, 0.15545002f, 0.04056529f, 0.16990544f, 
    -0.01923762f, 0.17682262f, 0.08109994f, -0.08220434f, -0.21034132f, 0.17243548f, 0.14420976f, 0.49682209f, 
    0.09225544f, 0.31641182f, -0.09299754f, -0.00010790f, 0.09496469f, 0.15645741f, -0.32045391f, 0.32976556f, 
    -0.63576573f, 0.11153127f, 0.16216926f, 0.21463212f, -0.12434939f, 0.20099774f, -0.10576996f, 0.04381930f, 
    0.05319033f, -0.01153958f, -0.16087884f, -0.08985792f, 0.64379823f, 0.61644965f, 0.34025005f, 0.24277735f, 
    -0.10818066f, -0.08052758f, 0.13762227f, -0.04341540f, -0.05487290f, -0.03072897f, -0.05595889f, 0.07035663f, 
    -0.04914211f, 0.08935010f, -0.44089684f, -0.48974270f, -0.00209643f, -0.10851274f, 0.02164329f, 0.04798157f, 
    0.28553930f, -0.02645412f, 0.09165002f, 0.15328532f, -0.01360027f, 0.13559879f, 0.04438854f, 0.02217694f, 
    0.13676207f, 0.01901707f, -0.19688952f, -0.15568440f, 0.24691246f, -0.08755131f, -0.09115759f, 0.14197238f, 
    -0.01982666f, 0.28733507f, 0.04244000f, 0.32866323f, 0.06666084f, -0.03751227f, 0.16849963f, 0.12817657f, 
    0.01717144f, -0.04708833f, -0.13446186f, -0.12340962f, -0.94634163f, -0.08915204f, 0.21510586f, -0.06187674f, 
    0.10509507f, 0.08566150f, 0.04949236f, -0.17479017f, -0.00082889f, 0.12741882f, 0.20473610f, 0.22529657f, 
    -0.05472372f, -0.50605321f, -0.28665739f, -0.21115731f, -0.21958743f, -0.15597901f, -0.13311352f, -0.21992628f, 
    -0.05338397f, -0.20128779f, -0.01597255f, -0.15044285f, 0.36794594f, 0.30390587f, 0.39770293f, -0.04367156f, 
    -0.06043430f, -0.19307895f, 0.14437383f, -0.25844967f, 0.11098517f, 0.15297525f, 0.11917270f, 0.11996001f, 
    -0.35690907f, -0.16319917f, 0.43147436f, -0.30938634f, 0.04081409f, -0.00880400f, -0.01523486f, 0.20036027f, 
    0.13100779f, 0.13246526f, -0.09594317f, -0.09022804f, -0.32086211f, 0.13809903f, -0.00878670f, 0.00320332f, 
    -0.09841345f, 0.02259492f, -0.11195991f, -0.08976880f, 0.12949254f, 0.03322398f, 0.03969236f, -0.04108600f, 
    -0.54450166f, 0.26034656f, -0.10119063f, -0.02709104f, -0.11034618f, 0.03626682f, 0.20303270f, 0.06949261f, 
    -0.00887184f, -0.04456474f, 0.13525063f, 0.17710645f, -0.01655664f, -0.02491556f, -0.11162509f, -0.19259557f, 
    0.13165751f, 0.04921847f, 0.06110552f, 0.05479994f, -0.09014327f, -0.05113892f, 0.07927268f, -0.02687176f, 
    -0.52705234f, 0.28753909f, 0.13283180f, -0.64318967f, 0.14597857f, 0.01456221f, 0.08725639f, -0.14809652f, 
    0.16409105f, 0.13142599f, -0.01381748f, 0.00920841f, 0.20093407f, 0.16350231f, -0.07011749f, 0.00769351f, 
    -0.12017617f, -0.06292712f, -0.14818537f, 0.02836777f, -0.08199961f, 0.10083531f, 0.10981300f, 0.30649957f, 
    -0.34208113f, -0.02617578f, -0.07618437f, -0.28809711f, 0.16007550f, 0.06314380f, 0.07154813f, -0.11522841f, 
    0.00708580f, -0.05926592f, -0.06892996f, 0.01013615f, 0.25760296f, -0.11819443f, -0.17737857f, 0.28345177f, 
    0.27342743f, 0.11397675f, 0.18100503f, 0.12738928f, -0.04080767f, 0.17793028f, 0.22974476f, 0.24556138f, 
    -0.20971110f, -0.07011592f, 0.16236140f, 0.04225178f, 0.07575334f, -0.20885520f, 0.26267916f, 0.20366600f, 
    0.08439147f, 0.00479647f, 0.06210123f, 0.04033345f, -0.29639471f, -0.39647394f, -0.02203006f, 0.29411438f, 
    0.00872899f, 0.05916288f, -0.03713641f, -0.09144745f, 0.11507443f, 0.03115702f, 0.12460826f, 0.02099691f, 
    -0.09606276f, -0.04373484f, 0.07505950f, 0.02444836f, -0.01253179f, -0.08824606f, 0.02406973f, 0.12473040f, 
    0.00609304f, 0.01808091f, 0.27678645f, 0.15674803f, 0.25774774f, -0.07731444f, -0.14970317f, -0.23782502f, 
    -0.02374503f, 0.00662753f, -0.00340023f, 0.12532546f, 0.00181283f, 0.23206449f, 0.02120560f, -0.35289094f, 
    -0.17789495f, -0.08625110f, 0.14600074f, 0.02342109f, -0.02558565f, 0.01891406f, -0.14394827f, -0.23368607f, 
    0.16041541f, -0.22517689f, 0.13042948f, -0.05916868f, -0.06005301f, -0.04675791f, -0.29894665f, -0.04772032f, 
    0.10069089f, 0.16491137f, 0.03743165f, 0.12983306f, 0.10120900f, -0.03343006f, -0.01363103f, 0.05993366f, 
    0.02368316f, 0.13915183f, -0.04160481f, 0.01269227f, -0.05999504f, 0.04594171f, 0.03685555f, 0.05711391f, 
    -0.02043915f, -0.02971966f, -0.08331124f, -0.07742459f, -0.36068705f, 0.35785675f, 0.49201339f, -0.42453089f, 
    -0.13684160f, 0.07779463f, 0.18709515f, 0.07677386f, 0.21959087f, 0.11888241f, 0.06864080f, 0.12014773f, 
    -0.54242170f, 0.08799249f, 0.13609074f, 0.04649941f, 0.34406102f, -0.03279504f, 0.07614789f, 0.32478833f, 
    0.10078537f, 0.21454705f, 0.07981692f, -0.10606265f, -0.14162225f, 0.06617472f, 0.38448727f, -0.39018115f, 
    0.13582669f, 0.16759928f, 0.31292999f, -0.04369586f, 0.03054498f, -0.09060578f, 0.06315956f, 0.07130238f, 
    -0.03876305f, 0.02290503f, -0.02211411f, 0.00355899f, -0.04392339f, 0.06002458f, 0.04401053f, 0.01935966f, 
    0.00030527f, -0.07194318f, -0.02802860f, 0.04473884f, -0.05512410f, -0.04744567f, -0.03768786f, -0.02330334f, 
    0.05603346f, -0.01609120f, 0.01016901f, -0.05192709f, 0.01583884f, -0.02331721f, -0.06903843f, -0.03522744f, 
    -0.05217164f, 0.05490996f, -0.03006837f, -0.03823774f, 0.02227512f, -0.01630161f, 0.03994592f, -0.07488840f, 
    -0.02291441f, 0.01301354f, -0.07171796f, 0.05262754f, -0.02298431f, 0.05844476f, 0.02825866f, -0.03681405f, 
    -0.00945537f, -0.01181238f, -0.05446885f, -0.00544577f, 0.04984602f, 0.00517521f, 0.03768633f, 0.05105510f, 
    0.00643735f, 0.06293350f, 0.00405414f, 0.04985746f, 0.00721687f, -0.01304327f, 0.03407977f, -0.06851263f, 
    0.04942123f, -0.01428357f, -0.04013221f, 0.01023989f, -0.02968662f, -0.03125555f, -0.03739378f, -0.02273896f, 
    0.01805026f, -0.03237913f, 0.01263919f, -0.01525269f, -0.02955146f, 0.05094553f, -0.03907933f, 0.00374347f, 
    0.03121198f, 0.04700605f, 0.04308778f, -0.03360721f, -0.03209436f, 0.03941384f, 0.00273409f, -0.00735593f, 
    0.05651975f, -0.03157503f, 0.05628427f, -0.02250753f, -0.07196597f, 0.05763322f, 0.04688948f, -0.04738069f, 
    0.04768029f, 0.04148417f, -0.01395248f, -0.04567853f, 0.01809850f, -0.02932809f, -0.01384059f, -0.00413115f, 
    0.03211785f, 0.01274044f, -0.04837691f, -0.00512870f, -0.00391699f, -0.03716135f, 0.00302622f, -0.06476489f, 
    0.05603942f, -0.01985796f, -0.04932694f, -0.05783531f, -0.05916376f, -0.01563644f, 0.05838578f, -0.07351300f, 
    -0.02454184f, -0.00531970f, -0.04154394f, -0.07158993f, -0.03747316f, -0.06292262f, 0.00199786f, -0.00171420f, 
    0.02403835f, 0.00742315f, -0.05443482f, 0.02384295f, -0.07601486f, 0.03582273f, -0.04399620f, -0.05898506f, 
    -0.03291899f, 0.04585988f, -0.03689665f, 0.05007526f, -0.01653978f, -0.05457284f, 0.04901745f, 0.01465080f, 
    -0.05842193f, 0.01457988f, -0.00654676f, 0.00451653f, -0.07167384f, -0.07125706f, -0.02387891f, 0.03783058f, 
    0.01902836f, -0.04156598f, -0.00994881f, 0.05052821f, 0.04265536f, -0.04706132f, -0.00692406f, -0.06231784f, 
    -0.02840164f, 0.01324060f, 0.00021346f, 0.01787678f, 0.01313714f, 0.04459058f, -0.01984335f, 0.05174757f, 
    -0.05822009f, 0.04460945f, -0.01814520f, -0.01278539f, -0.06578423f, -0.06824237f, 0.01748249f, 0.01617614f, 
    0.04856875f, -0.02244502f, 0.03022135f, -0.01864965f, -0.01711471f, -0.01747627f, -0.00593639f, -0.02347753f, 
    -0.07992435f, 0.00214286f, -0.05861156f, -0.04637590f, 0.04243763f, -0.06426227f, -0.06692301f, -0.00136494f, 
    0.04021145f, 0.02911940f, -0.00606396f, -0.07167398f, -0.05567763f, 0.06099160f, -0.00888854f, 0.00394269f, 
    -0.01648222f, 0.00000731f, -0.09220659f, -0.09324986f, 0.02368107f, -0.04200169f, 0.02570418f, -0.01989289f, 
    -0.06259903f, -0.00771872f, -0.10020497f, -0.07666315f, -0.05720780f, -0.06267884f, 0.01594443f, -0.08807958f, 
    0.07065520f, -0.00624285f, -0.05732836f, 0.04939161f, -0.03733249f, 0.01138429f, -0.01175595f, 0.05746424f, 
    -0.00588849f, -0.02835867f, -0.03912123f, -0.05098645f, -0.01108540f, -0.03269395f, 0.03459226f, -0.01494994f, 
    -0.03861866f, 0.05338520f, -0.07883930f, -0.06415480f, 0.03898444f, -0.02326438f, 0.05701181f, 0.04507316f, 
    0.02431920f, 0.05775217f, -0.03520876f, -0.04946458f, -0.03186933f, -0.04983156f, -0.05654969f, -0.03262482f, 
    0.03507309f, -0.03559021f, -0.10461336f, -0.01382854f, -0.10616035f, -0.03099565f, -0.05179102f, 0.05233897f, 
    0.05454662f, -0.04988877f, -0.10052860f, 0.02249805f, -0.01737504f, 0.02913213f, -0.00756344f, 0.05899419f, 
    -0.06089921f, 0.05823556f, 0.04470843f, 0.05663286f, 0.03200043f, -0.04996782f, 0.01397104f, -0.08793319f, 
    0.04257173f, -0.03495851f, -0.08831840f, -0.10033021f, -0.07108491f, -0.06556750f, -0.09424918f, -0.05275746f, 
    -0.03155609f, -0.07076126f, 0.02012258f, -0.07198117f, -0.06938794f, -0.00828888f, 0.03104731f, -0.07491289f, 
    -0.03751374f, 0.02555594f, 0.04424913f, -0.00685375f, -0.05892291f, -0.02239165f, -0.00107724f, -0.00430087f, 
    -0.00943045f, 0.00334283f, -0.06041475f, -0.02612951f, 0.01175949f, -0.04652976f, 0.01675869f, 0.02194604f, 
    -0.04978484f, -0.01655227f, -0.05100471f, -0.02841768f, -0.04102094f, 0.06010871f, -0.02864379f, -0.08995084f, 
    -0.08988771f, -0.01797887f, 0.01513795f, -0.09439087f, -0.08956609f, -0.03664693f, -0.05180133f, -0.09857854f, 
    -0.06387764f, -0.00280216f, 0.02891538f, 0.00717991f, -0.04203006f, 0.02480331f, -0.02714309f, -0.01899139f, 
    -0.06992873f, -0.04814415f, 0.05344066f, 0.01674085f, -0.03492787f, -0.00181907f, 0.00957643f, 0.01560427f, 
    -0.04147115f, -0.09182960f, -0.08573657f, 0.05049816f, 0.04909281f, -0.04547317f, 0.04840269f, -0.00984064f, 
    -0.08526775f, -0.01843182f, 0.00037337f, 0.03024683f, -0.02320700f, 0.06668248f, -0.05677835f, -0.06234116f, 
    0.03470064f, -0.02551695f, -0.07934166f, -0.00629375f, 0.02089575f, -0.11694352f, 0.07404903f, 0.00024334f, 
    -0.03269222f, -0.09081181f, 0.04007917f, -0.06869312f, 0.01836788f, 0.04536175f, -0.04580541f, -0.03058201f, 
    -0.04769901f, -0.00068708f, 0.01989200f, -0.02385380f, -0.05577900f, 0.00426017f, -0.05430739f, -0.06167525f, 
    -0.02532113f, 0.07970892f, 0.03908828f, -0.01451839f, -0.06724303f, -0.00845867f, -0.08379342f, 0.02738761f, 
    -0.01482621f, -0.05823340f, -0.02294639f, 0.01453880f, -0.03502046f, 0.06223629f, -0.05905378f, -0.07393200f, 
    0.42799762f, -0.11857757f, 0.07895336f, -0.18244575f, 0.06368204f, 0.01917760f, -0.15215300f, -0.05232637f, 
    0.18464758f, 0.29837263f, 0.42679474f, 0.22541746f, 0.18757977f, -0.12657674f, 0.27254120f, -0.17893019f, 
    0.01405018f, -0.00376532f, 0.06388294f, 0.00987490f, -0.12067708f, 0.13996522f, -0.07009275f, -0.06716172f, 
    0.43559873f, -0.30831873f, -0.25980100f, 0.29119816f, 0.23755091f, 0.17547396f, -0.22316092f, -0.05661555f, 
    -0.13299687f, -0.16124246f, -0.06283525f, 0.00211560f, -0.15655084f, -0.26882908f, 0.17321852f, -0.20429178f, 
    0.03907473f, 0.05814686f, 0.13390261f, 0.12803447f, 0.13872904f, -0.02388616f, 0.03036720f, -0.24396347f, 
    0.37964314f, 0.05048201f, -0.00529777f, 0.05584946f, -0.14600830f, 0.03835840f, -0.07362115f, -0.00392194f, 
    0.02364734f, 0.04101376f, 0.05834055f, 0.01840822f, -0.10978226f, 0.06002290f, 0.31671953f, -0.11061915f, 
    -0.27395618f, 0.08327363f, 0.14068447f, 0.02534683f, -0.02560002f, -0.05975239f, -0.26314637f, -0.30438107f, 
    0.21396320f, 0.22752994f, -0.00924709f, -0.04662243f, 0.03752416f, 0.21027945f, 0.10622218f, -0.10258140f, 
    0.02855982f, 0.01424321f, 0.05742168f, 0.05210868f, -0.13972281f, 0.52538800f, 0.21823041f, -0.03327365f, 
    -0.03087979f, 0.00833049f, 0.19306082f, -0.00284204f, -0.06450717f, 0.00125688f, -0.10210226f, 0.09037191f, 
    -0.00244606f, 0.10833070f, 0.07514353f, 0.21666147f, -0.15735431f, -0.01470048f, 0.01839880f, -0.10143890f, 
    -0.06423011f, -0.19292499f, -0.14833252f, -0.12990916f, -0.01898961f, -0.00885531f, 0.07607558f, 0.01488554f, 
    0.14547153f, -0.03075920f, -0.15738551f, -0.18064092f, 0.16809677f, 0.17941031f, 0.14745469f, 0.58706725f, 
    0.08642904f, 0.18811493f, 0.02789708f, 0.01383833f, 0.10738958f, -0.03470719f, -0.10075600f, 0.06951198f, 
    -0.15880263f, 0.08248158f, -0.01363404f, 0.18652266f, 0.44273555f, -0.13411784f, 0.60107690f, -0.15384604f, 
    -0.14932279f, 0.07251396f, -0.09667300f, -0.10554493f, -0.00972347f, -0.07470345f, 0.02566846f, -0.05427410f, 
    0.31958658f, -0.14191526f, 0.21573557f, -0.27920821f, 0.06748478f, -0.00120781f, 0.09947558f, 0.18340613f, 
    -0.02557296f, 0.08935120f, 0.20548680f, -0.04220241f, 0.18669346f, 0.05407639f, -0.43898821f, 0.47687328f, 
    0.05228765f, -0.00671279f, -0.13242526f, -0.01837822f, -0.14966094f, 0.04947444f, 0.03438008f, 0.09128573f, 
    0.13680093f, -0.01145866f, -0.29798809f, 0.27907211f, -0.12477695f, -0.09047689f, 0.20259127f, -0.40286276f, 
    -0.16117001f, -0.04675258f, -0.00040022f, 0.00800211f, 0.02582569f, 0.08400851f, -0.18538943f, 0.14697722f, 
    -0.14126384f, 0.10590512f, -0.17074780f, 0.25922203f, -0.08022925f, -0.01013565f, -0.07777288f, -0.01440634f, 
    -0.33681342f, 0.10284754f, 0.10110503f, -0.06209022f, -0.13528652f, 0.02324104f, -0.08387285f, -0.05262791f, 
    0.05429457f, -0.41862458f, -0.28361398f, -0.15421295f, 0.33087125f, 0.00044178f, -0.23394448f, 0.40278006f, 
    -0.06038604f, -0.15592158f, 0.18227810f, -0.20258264f, 0.05819004f, 0.04032923f, -0.14773214f, -0.06882717f, 
    -0.05160379f, 0.12434662f, 0.04086390f, -0.02319125f, -0.02846308f, 0.10838030f, 0.45405161f, 0.18063024f, 
    0.15466525f, 0.06291391f, 0.08920414f, 0.16950408f, 0.01285178f, -0.07354391f, 0.33513644f, 0.19982021f, 
    -0.09015084f, -0.10330249f, -0.07270119f, -0.07284941f, 0.08911156f, 0.15482688f, 0.12068287f, 0.36139819f, 
    -0.05809377f, 0.36060718f, 0.33776796f, 0.10366721f, -0.06226342f, -0.05553456f, -0.14581855f, -0.00251502f, 
    -0.18250547f, -0.10227694f, 0.01353249f, -0.08980704f, 0.26438838f, -0.10232081f, 0.48990330f, 0.11177450f, 
    0.39293152f, 0.12585245f, 0.02525471f, 0.51698315f, 0.03783863f, -0.16557439f, 0.19961153f, 0.19056669f, 
    0.04371693f, 0.11645113f, 0.08417536f, -0.01301084f, -0.00533356f, -0.07358449f, 0.00239323f, -0.04844671f, 
    -0.13185374f, 0.11621837f, -0.06017681f, -0.13535388f, -0.77610844f, 0.14457352f, -0.26445040f, -0.23091105f, 
    -0.26698905f, -0.32005313f, 0.05161851f, -0.00319864f, -0.01360040f, -0.00887905f, 0.01829328f, -0.22180197f, 
    -0.03307102f, 0.20399249f, 0.03063471f, 0.39488831f, -0.01210644f, -0.06285433f, 0.05031726f, -0.01898967f, 
    -0.02552544f, 0.47902608f, 0.10467603f, 0.03213535f, 0.11868157f, 0.08598659f, 0.24035358f, -0.09912721f, 
    0.17243090f, -0.13818060f, 0.04381046f, 0.02735918f, -0.18899456f, -0.45732570f, -0.14134994f, -0.43894055f, 
    -0.19660482f, 0.05695787f, -0.05412044f, 0.23572955f, -0.02471509f, 0.04379518f, -0.06232474f, 0.02048380f, 
    0.24482976f, -0.27233708f, 0.04316950f, -0.00725207f, -0.07621467f, 0.25962996f, 0.03014756f, 0.33136889f, 
    0.15101855f, 0.05953085f, 0.15390746f, 0.08088951f, -0.05692495f, 0.16269659f, 0.10787345f, 0.16642179f, 
    0.17353339f, -0.06987849f, 0.19790013f, 0.00695021f, -0.16228259f, -0.03732701f, -0.19150312f, 0.00127208f, 
    -0.01560516f, -0.03318766f, -0.03633429f, 0.04892208f, 0.02793366f, -0.01309444f, -0.06044155f, -0.30824459f, 
    -0.07097825f, -0.16118148f, -0.18437321f, 0.06746080f, -0.01609562f, -0.00361386f, -0.04387917f, -0.08577198f, 
    -0.45363837f, -0.27514756f, -0.01108803f, 0.38158491f, -0.07100141f, 0.15758057f, 0.04509871f, -0.06872471f, 
    0.21732825f, 0.08396205f, -0.11999032f, -0.07316853f, 0.55215222f, 0.08909802f, -0.16969633f, -0.00388571f, 
    -0.05811771f, 0.13634712f, 0.00220845f, 0.35075188f, -0.02710227f, -0.02010573f, -0.00546422f, -0.00631273f, 
    -0.02082195f, 0.04973653f, 0.03721356f, -0.04646724f, -0.05589912f, -0.06281874f, -0.04248603f, -0.04555247f, 
    -0.01545629f, -0.07226056f, 0.06020541f, 0.06051927f, 0.03183971f, 0.06378338f, 0.01884368f, -0.03953368f, 
    -0.02562501f, -0.07168159f, -0.01042617f, -0.07382707f, 0.03437001f, -0.04575275f, -0.01004197f, -0.01602813f, 
    0.03943632f, -0.06055472f, 0.04533098f, -0.06546538f, 0.01183099f, 0.04880626f, -0.01857644f, 0.00252455f, 
    0.02568761f, 0.00860777f, 0.03176679f, 0.00728991f, -0.07230441f, -0.00916421f, -0.01379495f, 0.06750476f, 
    0.06052393f, 0.05229581f, 0.03115412f, -0.05200955f, 0.02165951f, 0.04832638f, 0.01752414f, -0.03457551f, 
    -0.05830452f, 0.03482688f, 0.01383515f, -0.00029012f, 0.01632052f, 0.01684649f, 0.03537205f, 0.00227304f, 
    0.00954925f, -0.01918569f, -0.03871745f, -0.06403786f, -0.02287720f, 0.03623468f, -0.06651396f, 0.04237619f, 
    -0.01903928f, -0.05060462f, -0.00460396f, -0.07106020f, -0.04765078f, -0.07242654f, -0.02839173f, 0.02994180f, 
    0.05074836f, 0.03057351f, -0.00368783f, -0.02047700f, -0.02365118f, -0.07136243f, -0.02818724f, 0.02447448f, 
    -0.02362270f, -0.01879993f, 0.00629189f, 0.05616875f, -0.06008386f, -0.05625421f, -0.00854235f, 0.00852450f, 
    0.01784655f, 0.03528427f, 0.05769657f, 0.05862084f, -0.03071911f, -0.05146019f, -0.05056027f, -0.06112132f, 
    0.01978999f, 0.05180231f, -0.04133096f, -0.07346291f, -0.07527173f, -0.06536913f, -0.05409729f, -0.04433889f, 
    -0.01493261f, -0.06745551f, 0.01517387f, -0.01620500f, -0.05340238f, 0.03624614f, 0.00869118f, 0.03117735f, 
    -0.04521164f, -0.02273952f, -0.04005533f, 0.06333139f, -0.07265640f, 0.04944731f, -0.01809383f, -0.01330158f, 
    -0.03471040f, 0.02620588f, -0.00134520f, 0.00576564f, 0.05759662f, 0.05883781f, -0.01912296f, -0.05559612f, 
    -0.04947338f, 0.03771691f, 0.00354913f, 0.03831381f, -0.04207738f, -0.06041034f, -0.01719163f, -0.02536646f, 
    -0.07085884f, 0.00704877f, 0.03217620f, 0.05627554f, -0.01374897f, -0.01315040f, 0.00544624f, -0.03663689f, 
    -0.02829593f, 0.00229677f, 0.01154934f, 0.00402854f, -0.02446703f, -0.00644610f, -0.01516182f, 0.03947482f, 
    0.03351539f, 0.03941430f, 0.02207095f, 0.01241324f, -0.03397492f, -0.06471343f, 0.02625951f, -0.06623191f, 
    0.01152194f, -0.04620737f, 0.02274663f, 0.00903144f, 0.00476181f, -0.05710032f, 0.06161614f, 0.04219404f, 
    -0.06147302f, -0.04632713f, 0.01890828f, -0.04787689f, 0.00870515f, -0.00465334f, -0.03660203f, -0.00259752f, 
    0.04655403f, -0.06102213f, 0.00727830f, -0.02967457f, -0.07550990f, 0.04732356f, -0.02205070f, 0.02388990f, 
    0.03278179f, -0.00935797f, 0.01049650f, -0.01473760f, 0.01494031f, 0.03845737f, 0.01568464f, 0.00168172f, 
    -0.05404595f, 0.05144250f, -0.02551495f, -0.04651079f, -0.07197849f, -0.05264422f, 0.01063940f, 0.01509920f, 
    -0.02083965f, -0.05312696f, 0.00279485f, 0.05925184f, 0.05792123f, -0.02808246f, 0.06719381f, 0.03418642f, 
    0.05990528f, 0.05782263f, 0.04283042f, -0.07013820f, 0.02080127f, 0.01566801f, -0.03077404f, -0.02622382f, 
    0.02048093f, 0.02328343f, -0.01746250f, 0.03530356f, 0.03297261f, -0.05511118f, -0.01317211f, -0.07005549f, 
    0.04265283f, 0.06216521f, -0.05975465f, -0.06391771f, 0.03282552f, -0.02676259f, 0.03077015f, 0.05161015f, 
    -0.05648506f, 0.01206999f, -0.02695988f, 0.01545430f, -0.01498407f, -0.04067259f, -0.05740130f, -0.02943762f, 
    -0.03292761f, 0.04565695f, 0.06420713f, -0.04112955f, -0.05038977f, 0.00233502f, -0.00907364f, 0.01135414f, 
    0.03687533f, -0.00162952f, -0.04415617f, 0.06324591f, 0.03928563f, 0.06818286f, -0.01932961f, -0.05857462f, 
    0.01975651f, 0.00909933f, 0.00389853f, -0.05869570f, -0.02951774f, 0.06365442f, 0.01770497f, -0.06694853f, 
    -0.02863307f, 0.03003909f, 0.00862849f, 0.03814013f, 0.00182666f, 0.04176465f, 0.06897739f, -0.00238546f, 
    0.02803436f, -0.06878047f, -0.06186092f, -0.04599528f, 0.00727220f, 0.04328538f, -0.04487474f, 0.00899368f, 
    -0.04735848f, 0.05506931f, -0.02957051f, -0.00198334f, -0.03901651f, 0.02817646f, -0.06696366f, 0.02752636f, 
    -0.04251448f, -0.06870729f, 0.05853534f, -0.02481907f, -0.06499864f, 0.04130148f, 0.03271390f, -0.06818344f, 
    0.01125730f, 0.07075965f, 0.02059019f, 0.04868222f, -0.04421267f, -0.00572627f, 0.05654831f, -0.03428391f, 
    0.00569781f, -0.01985828f, -0.05323102f, 0.02661446f, 0.01059149f, 0.00208136f, 0.02660328f, 0.03674668f, 
    -0.01820431f, -0.01866290f, -0.03819413f, -0.06307446f, 0.03008786f, -0.03081603f, 0.04594526f, -0.05555757f, 
    -0.03429124f, -0.04511858f, 0.05114586f, 0.05110078f, -0.05929744f, -0.04088219f, -0.04173298f, -0.04004682f, 
    0.03391203f, -0.06398824f, 0.03772797f, -0.02284857f, 0.04296626f, -0.06108852f, 0.04714432f, -0.02006563f, 
    -0.07185025f, -0.04528094f, 0.02462700f, -0.03836937f, -0.05215743f, -0.02516013f, 0.03374347f, 0.00286826f, 
    0.04804228f, -0.02996567f, 0.03954238f, -0.06342604f, 0.02203773f, -0.02345738f, -0.02125506f, 0.00117989f, 
    -0.01617004f, -0.01894646f, -0.03560417f, 0.00209426f, -0.07147298f, 0.03489436f, -0.07214764f, 0.02337300f, 
    0.03954440f, -0.03145635f, -0.00550114f, 0.01155274f, 0.04597377f, -0.06168978f, -0.05566769f, 0.04768587f, 
    -0.02306070f, -0.01513088f, -0.02550361f, -0.01339943f, -0.04926202f, 0.04339974f, -0.05594000f, 0.02824187f, 
    0.05596833f, -0.03099917f, -0.02175232f, -0.01175671f, 0.03624707f, -0.02068702f, -0.03426245f, 0.04458513f, 
    -0.68243992f, -0.17294586f, 0.12317225f, -0.02567622f, -0.05200166f, 0.13771163f, 0.27829489f, 0.01817331f, 
    0.12248401f, -0.04133958f, 0.41110563f, 0.13947663f, 0.55419952f, -0.07934417f, -0.05878546f, 0.15758230f, 
    -0.11409846f, 0.03434172f, 0.14875038f, -0.04677308f, -0.06829140f, 0.08274455f, -0.10661860f, -0.04805405f, 
    -0.38955122f, -0.72943938f, -0.10049593f, -0.52969384f, -0.13937829f, -0.05792497f, -0.06913774f, -0.19939800f, 
    -0.03972906f, -0.01452088f, -0.02621650f, -0.04750142f, 0.25846010f, 0.23120049f, 0.29377735f, 0.14230023f, 
    0.01820981f, -0.04197115f, -0.06099289f, -0.01002682f, 0.06068207f, 0.06108895f, -0.02547265f, 0.13091534f, 
    -0.07865608f, 0.15034917f, 0.00395191f, -0.33868524f, 0.06336761f, -0.16435580f, -0.10683168f, -0.07987414f, 
    -0.04136061f, -0.04733273f, -0.16001713f, -0.12473857f, -0.04023548f, -0.15955792f, -0.02676415f, -0.48958680f, 
    -0.20333689f, 0.07697687f, 0.15881488f, 0.15413262f, -0.00693374f, -0.22571819f, 0.23550855f, 0.01040859f, 
    -0.07786962f, -0.05574832f, -0.09386469f, -0.22668746f, 0.05583752f, 0.09223767f, -0.06875691f, -0.16659997f, 
    0.06155310f, 0.15572846f, 0.24974960f, 0.12945072f, -0.95262098f, 0.25033116f, -0.01364165f, 0.20444338f, 
    -0.20007779f, -0.11330040f, -0.15237308f, 0.05035926f, -0.24227519f, 0.15748382f, 0.25222993f, 0.01931170f, 
    0.08802450f, 0.08381626f, 0.04042359f, 0.24602465f, 0.05517970f, 0.03743701f, -0.00197217f, -0.00863738f, 
    -0.10541099f, -0.16131832f, -0.19672294f, -0.18303822f, 0.06800912f, -0.02896240f, 0.09143452f, -0.25725895f, 
    0.02187173f, 0.06344283f, 0.26954833f, 0.21445060f, -0.03099641f, 0.09372780f, -0.06700284f, 0.18081962f, 
    -0.94277519f, -0.30232584f, 0.08304219f, -0.56458610f, 0.15629309f, 0.05840483f, -0.26226258f, 0.03479271f, 
    0.00030136f, 0.02576150f, 0.19315800f, 0.14650866f, 0.60414082f, -0.13199037f, -0.09201707f, -0.19025482f, 
    0.16703071f, 0.52119064f, 0.37203956f, 0.10478878f, -0.16377175f, -0.04830412f, -0.18569708f, -0.13216029f, 
    0.39440712f, 0.16423362f, 0.25060153f, 0.01394854f, 0.05940358f, -0.00532150f, 0.04208695f, -0.10257161f, 
    0.00010239f, 0.14342043f, 0.15294068f, 0.18868457f, 0.39912254f, 0.14611064f, -0.15335490f, -0.35989830f, 
    0.03739056f, -0.04689280f, -0.12072917f, 0.23785433f, 0.05190467f, 0.22189429f, 0.22414397f, 0.01544514f, 
    -0.15310687f, -0.24741745f, 0.13708296f, 0.22439073f, 0.05247969f, 0.49699879f, -0.14969344f, 0.13610783f, 
    0.03776207f, 0.19959296f, 0.14710876f, 0.18350752f, 0.68602872f, -0.54744041f, -0.19986647f, -0.01803017f, 
    -0.10409483f, 0.11833529f, 0.13981561f, 0.00601693f, -0.12348022f, -0.01961483f, -0.15871105f, -0.08702996f, 
    -0.12593056f, 0.23573388f, 0.07628463f, -0.09364295f, 0.15419024f, 0.16870327f, -0.11412836f, 0.04560880f, 
    0.02945978f, -0.08337177f, -0.14077671f, -0.06712516f, -0.16603662f, -0.11634026f, 0.16820340f, 0.42474908f, 
    -0.09525423f, -0.04805597f, 0.10746941f, -0.12998159f, -0.02440280f, -0.11326434f, -0.03835599f, -0.03549025f, 
    -0.02499922f, 0.23950663f, 0.06961086f, -0.03253119f, -0.21454464f, 0.30033612f, 0.20925291f, 0.19132477f, 
    0.04551386f, 0.04421521f, 0.07286058f, 0.18787016f, 0.03294133f, 0.01063026f, 0.26306960f, 0.09111331f, 
    0.04149138f, -0.08352073f, -0.07917143f, -0.17074746f, -0.06303856f, 0.02851788f, 0.12677082f, 0.10464574f, 
    0.18251765f, 0.05389153f, -0.10686449f, -0.19310474f, 0.28529018f, 0.08545437f, -0.07723192f, -0.00536583f, 
    -0.06201164f, -0.08129218f, -0.04592689f, -0.15905370f, 0.02437814f, 0.02183452f, 0.41171250f, -0.03174614f, 
    0.40666342f, 0.18711518f, 0.04792726f, 0.20462775f, 0.14119378f, 0.06953692f, 0.13854511f, 0.14448990f, 
    0.42724591f, 0.21000402f, 0.07678288f, -0.10087188f, 0.03829249f, -0.16162495f, 0.01702411f, 0.21325853f, 
    0.04240859f, 0.04390448f, -0.09377762f, -0.00598530f, 0.14045419f, -0.41370136f, -0.14345148f, -0.45986235f, 
    0.00576704f, -0.11834836f, 0.01715994f, -0.00123352f, -0.01224344f, 0.12906571f, -0.02945271f, -0.11528036f, 
    -0.23625940f, 0.00818731f, 0.09051639f, 0.20131788f, -0.03795206f, -0.18472563f, -0.08833136f, -0.15444359f, 
    -0.07380623f, 0.22467607f, -0.03933993f, -0.03760889f, -0.15554546f, 0.10282759f, 0.09757435f, 0.06815982f, 
    0.05119265f, 0.07403098f, -0.06552219f, 0.20962381f, -0.11284934f, -0.14756097f, -0.12121707f, -0.42676282f, 
    0.15461580f, -0.02817323f, -0.18337585f, 0.15999784f, 0.03632938f, 0.20564757f, 0.02052566f, 0.17108820f, 
    0.20757097f, 0.05273122f, -0.01215238f, -0.06765976f, 0.17689510f, 0.03311677f, -0.21616566f, 0.12487166f, 
    0.05023567f, 0.11402843f, 0.05628686f, 0.25656199f, -0.02817870f, 0.17849165f, -0.03976241f, 0.14136714f, 
    -0.00676489f, 0.19904202f, 0.29151100f, 0.21166624f, -0.00307620f, -0.01385882f, -0.06876912f, 0.02931455f, 
    0.04435762f, 0.01756492f, -0.13289823f, 0.04339834f, -0.42838046f, -0.25510719f, -0.32197860f, -0.19308990f, 
    -0.12547481f, -0.12717429f, -0.16305888f, 0.32848376f, -0.14082383f, 0.05040998f, -0.03787495f, -0.12113550f, 
    -0.31605056f, 0.63169384f, -0.26654944f, 0.00072560f, -0.04345191f, 0.15827833f, 0.00271145f, 0.01478348f, 
    0.02815294f, -0.01529987f, 0.05106612f, 0.04008070f, 0.40099615f, -0.03752514f, -0.20688985f, 0.14225732f, 
    -0.07829361f, 0.08817783f, 0.18521670f, 0.09149025f, -0.04698654f, 0.16428557f, -0.07920843f, 0.10997000f, 
    -0.05932935f, 0.06244741f, 0.06218905f, 0.05280496f, 0.02078104f, -0.00984137f, -0.06465082f, -0.01141863f, 
    -0.00225798f, 0.02985677f, -0.04875950f, 0.05433419f, -0.05401874f, 0.01216702f, 0.00735879f, 0.03550196f, 
    0.00745315f, 0.02892075f, -0.04049822f, -0.06337420f, -0.02993576f, 0.01933951f, -0.04765604f, -0.06308849f, 
    -0.02242844f, 0.05898296f, -0.06318301f, -0.07259367f, -0.06486902f, 0.06208685f, -0.02069385f, -0.02149143f, 
    -0.00284157f, 0.02100321f, 0.01873058f, -0.05441133f, 0.03357243f, -0.00384111f, 0.02516158f, -0.07224461f, 
    -0.00699860f, -0.06966186f, -0.02729898f, -0.06076933f, -0.07070006f, 0.03612896f, -0.04624102f, 0.01504285f, 
    -0.07777780f, -0.03557806f, -0.03371006f, 0.05046030f, -0.01798890f, -0.01868486f, -0.02582962f, 0.00603100f, 
    -0.04060569f, -0.04210643f, 0.03096684f, -0.00543515f, 0.04867206f, -0.05640981f, 0.05108566f, -0.04464100f, 
    -0.00602657f, -0.04680110f, -0.05611983f, -0.03119036f, -0.00194102f, -0.07456019f, -0.02810544f, 0.01321090f, 
    -0.05431242f, 0.01822650f, -0.07768486f, -0.06400434f, 0.05006792f, -0.04926412f, 0.03534241f, -0.04276426f, 
    -0.07136719f, 0.02094886f, 0.00075571f, 0.04628087f, 0.01103203f, 0.02047107f, -0.07408513f, -0.02296989f, 
    -0.04542222f, 0.05241612f, -0.00171423f, 0.01089551f, -0.06281143f, -0.04931553f, -0.04989433f, -0.04521856f, 
    -0.05088486f, 0.03143534f, 0.03928147f, -0.06175681f, -0.07655865f, 0.00308955f, -0.02949043f, 0.02973264f, 
    -0.07548893f, -0.05993529f, -0.05982716f, -0.00185466f, 0.04902873f, 0.02014775f, 0.02212211f, -0.02305964f, 
    -0.04058103f, 0.02995468f, 0.02164245f, -0.03127247f, -0.01141331f, 0.04091932f, 0.05044613f, 0.00799696f, 
    -0.00108540f, -0.07521580f, 0.03346173f, -0.01285160f, 0.05022613f, 0.05248930f, 0.03621296f, -0.05895082f, 
    0.00625464f, -0.04568040f, -0.03760193f, 0.04970917f, -0.05616382f, -0.02472673f, -0.06433565f, -0.05268566f, 
    0.04870310f, 0.00993612f, 0.05784845f, -0.04123171f, 0.00265673f, 0.00528508f, -0.01079877f, -0.06938154f, 
    0.01259765f, -0.03451572f, -0.06279336f, -0.03472673f, 0.01806749f, 0.01674071f, 0.06164612f, -0.07411061f, 
    0.02247915f, 0.05771544f, 0.06193398f, -0.04179729f, -0.02432236f, -0.02858756f, 0.03833158f, 0.03687928f, 
    0.06397907f, -0.00131711f, 0.01136237f, -0.06085990f, 0.00154319f, 0.05884089f, -0.06626013f, 0.03137552f, 
    -0.03254972f, 0.05816709f, 0.03724241f, -0.06303856f, 0.01047627f, -0.00100271f, 0.00319291f, 0.00245330f, 
    -0.03586306f, -0.00594984f, -0.07150353f, 0.05487710f, 0.04505845f, -0.05263915f, -0.06553593f, 0.03955378f, 
    -0.00095234f, -0.05950709f, -0.00813059f, 0.02674626f, -0.03358046f, -0.02568274f, -0.02461223f, 0.02135126f, 
    -0.30905640f, -0.17354295f, 0.07594864f, -0.00193295f, -0.04063524f, -0.05122373f, -0.06689333f, 0.02069132f, 
    0.05771883f, 0.05231355f, 0.03392303f, -0.11416440f, 0.45101091f, -0.16010304f, -0.48880151f, -0.16325638f, 
    -0.10927267f, 0.04148550f, 0.14785592f, -0.18160032f, 0.04593526f, 0.08224947f, -0.11743809f, -0.00335276f, 
    -0.07910996f, 0.09106334f, 0.12019543f, 0.24677122f, 0.01246762f, -0.09936244f, 0.15220314f, -0.05692024f, 
    0.07536061f, 0.02189419f, 0.13008127f, 0.08550868f, 0.04317699f, 0.18650077f, 0.00346607f, -0.05068101f, 
    -0.08073263f, 0.06079724f, -0.05753848f, -0.07852235f, 0.06388391f, 0.17426252f, -0.12815090f, 0.03638278f, 
    -0.00693127f, 0.18816362f, 0.38238418f, 0.03508806f, -0.25231209f, -0.07527076f, -0.06721575f, 0.00949005f, 
    0.03330363f, 0.04260037f, 0.02397982f, -0.01219710f, -0.06806259f, 0.11625064f, 0.06773009f, -0.08002090f, 
    -0.01134263f, 0.03218531f, 0.37503606f, 0.05918555f, 0.07106651f, -0.10271474f, 0.12247387f, -0.15963696f, 
    -0.18210927f, 0.07936865f, 0.01475980f, 0.03391328f, -0.02833417f, 0.20143364f, -0.12620920f, -0.33318493f, 
    -0.05937605f, 0.09506913f, -0.02291028f, 0.02779526f, -0.20535548f, 0.55528063f, -0.02745847f, -0.15741114f, 
    -0.22385992f, -0.09176861f, -0.16184767f, 0.05186812f, 0.00209901f, 0.00462817f, 0.13579623f, 0.01960499f, 
    0.29004359f, 0.27997351f, -0.00781492f, 0.00519476f, -0.00106663f, 0.21016966f, 0.08816221f, -0.07753146f, 
    0.11039755f, -0.06922933f, 0.03406713f, -0.05317649f, 0.09860325f, 0.13336672f, -0.07477796f, -0.16311692f, 
    0.13235319f, -0.06490254f, 0.14898455f, 0.04988461f, 0.15572548f, 0.03740968f, 0.05113617f, 0.04251670f, 
    -0.36814222f, -0.05913004f, 0.02250773f, 0.17052448f, -0.02326565f, 0.14183512f, -0.08849208f, 0.11778750f, 
    -0.02034173f, 0.01012207f, -0.00934786f, 0.05616606f, 0.20709555f, 0.12226000f, 0.03574346f, -0.01084132f, 
    -0.07825299f, -0.15361981f, 0.33304000f, -0.10219714f, -0.03649154f, -0.06787176f, -0.07561394f, -0.04042412f, 
    0.58127832f, 0.10061637f, -0.03737927f, -0.23395409f, -0.05223804f, -0.03996392f, -0.00646818f, -0.09813072f, 
    0.02210394f, 0.13993569f, 0.03112787f, 0.06146950f, 0.81427890f, 0.09840892f, 0.14536434f, -0.17722416f, 
    -0.07287512f, -0.27570310f, -0.08318318f, -0.03821097f, 0.06537384f, 0.12476571f, 0.05088511f, -0.04893579f, 
    0.34635618f, -0.92332929f, 0.47511873f, 0.37150088f, -0.04084995f, 0.14590701f, -0.06162560f, -0.01302703f, 
    0.02437349f, -0.01019052f, 0.07339148f, -0.06098420f, 0.29279083f, 0.11215393f, -0.15188248f, -0.22068715f, 
    -0.01162191f, -0.19735615f, 0.07428170f, 0.11708999f, -0.13992748f, -0.03769527f, -0.04075025f, 0.02877005f, 
    0.58176512f, -0.05545045f, 0.31268302f, -0.07325542f, 0.13935983f, 0.10136247f, -0.13075742f, 0.00064272f, 
    -0.13606466f, 0.08181467f, -0.07480160f, -0.20668000f, 0.06744313f, -0.03870521f, 0.89184713f, -0.33166009f, 
    -0.24596676f, -0.23479971f, -0.20312019f, -0.22214457f, 0.03443024f, 0.06445126f, 0.01439907f, -0.11436471f, 
    0.34397194f, -0.53263491f, 0.31704298f, 0.15088175f, 0.08206098f, 0.03301556f, -0.06647407f, 0.11962109f, 
    -0.21143572f, 0.23610762f, 0.18588851f, 0.18225180f, -0.02575072f, 0.20756643f, 0.21903071f, -0.43855169f, 
    -0.10178213f, 0.00471736f, 0.11360514f, -0.03402958f, 0.04063524f, -0.00927514f, 0.16683410f, 0.15140088f, 
    -0.04752275f, -0.24274027f, -0.12770867f, 0.01552820f, 0.17973363f, 0.21193013f, -0.10491838f, -0.16060555f, 
    -0.04782530f, -0.00366948f, -0.01401511f, -0.17809291f, -0.04417473f, 0.24275559f, 0.11133339f, -0.12919874f, 
    0.06046546f, 0.22930112f, 0.18942305f, 0.07379413f, 0.20097327f, 0.05317792f, 0.22964385f, 0.12240428f, 
    0.19059516f, 0.11263451f, -0.11713015f, 0.13700747f, 0.02193400f, -0.04623178f, 0.04679047f, -0.11429041f, 
    -0.09191859f, 0.07504547f, -0.03950367f, -0.18265839f, 0.16508688f, -0.09708782f, 0.21913408f, -0.18577664f, 
    0.14730453f, 0.27294186f, -0.07607216f, -0.00895548f, -0.13078347f, 0.20819157f, -0.04008614f, -0.02406916f, 
    0.02616281f, 0.14748235f, 0.12994318f, -0.10006298f, -0.15825979f, -0.12076711f, -0.12231209f, 0.00094036f, 
    -0.01313520f, -0.02880142f, 0.02828151f, 0.05371195f, -0.02769041f, -0.39192051f, 0.20310932f, 0.05823340f, 
    -0.02805191f, -0.01692614f, -0.12316120f, 0.06018380f, -0.15972361f, -0.02288577f, -0.15684801f, -0.01996056f, 
    0.13001773f, -0.16953333f, -0.10305848f, -0.11058593f, 0.10100234f, 0.12624335f, 0.06464607f, 0.20320272f, 
    -0.19401343f, 0.05878884f, -0.09848429f, 0.02402978f, 0.26651490f, -0.53381175f, 0.42600673f, -0.41934636f, 
    0.00175947f, 0.04091996f, -0.14080606f, -0.04166995f, -0.17604446f, 0.06974819f, 0.14493267f, 0.18801142f, 
    0.41559049f, 0.24178055f, 0.46495709f, -0.04520410f, -0.24791430f, -0.15300307f, -0.16887367f, -0.19292830f, 
    -0.08187175f, -0.09267996f, 0.02009603f, -0.01191234f, -0.00651519f, 0.03384035f, -0.27275667f, 0.45256057f, 
    -0.03579471f, 0.05671167f, 0.09110952f, 0.01937838f, 0.01001398f, 0.19409822f, -0.03346144f, 0.08071967f, 
    0.07316909f, 0.63510329f, -0.41187593f, -0.00889758f, 0.25329924f, -0.09120667f, 0.39102161f, 0.13235639f, 
    -0.11479711f, -0.02257232f, 0.10173042f, 0.07753532f, -0.14844896f, -0.14920411f, -0.22912164f, 0.45879012f, 
    -0.22390187f, 0.06195217f, 0.05112536f, -0.01021564f, 0.00854228f, 0.12837169f, -0.12480135f, -0.03736029f, 
    0.02850252f, 0.05174652f, 0.06129583f, -0.00614998f, 0.00199641f, 0.00885725f, 0.02918578f, 0.01981414f, 
    -0.03922948f, -0.05152968f, -0.02729251f, -0.05444187f, 0.03466637f, 0.01978893f, -0.01542149f, -0.00063425f, 
    -0.00967243f, -0.07485775f, 0.00123331f, 0.05532613f, 0.01766780f, 0.05062325f, -0.05400161f, 0.03075051f, 
    0.02155758f, -0.06076827f, 0.05870136f, 0.00144338f, -0.03856338f, -0.06708498f, -0.02330460f, -0.03608838f, 
    -0.07287223f, -0.05707858f, -0.04806398f, 0.00496434f, -0.00263012f, -0.03241208f, 0.02848876f, 0.03171708f, 
    -0.04827258f, 0.04986159f, -0.01598753f, -0.05869947f, -0.03656324f, -0.02780471f, -0.04198518f, -0.05222438f, 
    -0.07067626f, 0.05745333f, -0.05853410f, -0.06788170f, -0.03359495f, 0.00450733f, -0.00949421f, 0.01490428f, 
    -0.04290717f, 0.01550065f, -0.05263101f, 0.04278931f, -0.05915837f, -0.04630343f, 0.01453620f, 0.03044372f, 
    -0.03389537f, 0.04043190f, -0.00504271f, -0.04907306f, 0.01505513f, -0.03591292f, -0.06494121f, -0.05239199f, 
    0.01561415f, -0.01100849f, 0.04776173f, -0.05398863f, -0.01489199f, 0.00412241f, -0.02214761f, 0.02385298f, 
    -0.00679105f, -0.06614754f, -0.02945124f, 0.03928186f, -0.04957630f, -0.00073842f, 0.05951953f, 0.00856088f, 
    -0.01077252f, -0.00624843f, 0.03227081f, 0.02513627f, -0.03934509f, -0.02566409f, 0.04743440f, 0.05818188f, 
    -0.05541408f, -0.05807706f, 0.00664680f, 0.00759816f, 0.05217522f, -0.01240192f, -0.03383009f, -0.02084693f, 
    -0.04556839f, 0.00843427f, -0.06448181f, 0.06600374f, 0.06343591f, 0.01710748f, 0.05547768f, -0.04862836f, 
    0.04482243f, -0.06985794f, -0.06351257f, -0.02116698f, -0.03843121f, 0.01863778f, -0.02180771f, 0.04425317f, 
    -0.03218196f, -0.04190641f, 0.00253980f, 0.04500854f, 0.01421474f, 0.00104779f, -0.06628140f, 0.04519234f, 
    -0.07295461f, -0.05587922f, 0.06376816f, -0.00863498f, 0.05185943f, 0.01740754f, -0.06176270f, -0.04091351f, 
    0.05417687f, -0.01868799f, 0.05987082f, 0.04872010f, -0.05192473f, 0.01110100f, -0.02947252f, 0.01683337f, 
    -0.06893457f, -0.04104688f, -0.02807432f, -0.05456380f, -0.05633049f, -0.04521720f, -0.05658650f, -0.04191518f, 
    -0.04130062f, -0.06220644f, 0.05991166f, -0.04522554f, 0.05034399f, 0.04263396f, 0.04302940f, -0.05676159f, 
    -0.05329334f, 0.00020815f, -0.05652381f, -0.00715992f, -0.03846594f, -0.01725479f, 0.03809432f, 0.02234516f, 
    0.04233718f, -0.07231178f, 0.04623470f, 0.01245318f, 0.03839588f, -0.05368549f, 0.02274678f, -0.05070006f, 
    -0.06619623f, -0.02870574f, -0.02004289f, -0.03373908f, 0.00586759f, -0.06098593f, -0.01802527f, 0.02446229f, 
    0.05736098f, 0.05179171f, 0.04455836f, -0.07723302f, -0.00577946f, -0.04684835f, -0.03747441f, 0.03739683f, 
    -0.02754152f, 0.05452426f, 0.02787567f, -0.07377449f, -0.03415167f, 0.02368616f, 0.02234332f, -0.02352669f, 
    0.06112836f, -0.03064620f, -0.00074553f, 0.00637859f, 0.03147358f, 0.02640979f, 0.01056445f, -0.05152800f, 
    -0.02092746f, -0.04622635f, -0.07408211f, -0.01455079f, 0.03954541f, 0.05002624f, 0.05222154f, -0.07318079f, 
    -0.03426554f, -0.00082253f, -0.03814331f, 0.05928772f, -0.01318947f, -0.05653220f, 0.06391264f, -0.01673654f, 
    -0.04414531f, -0.04707079f, 0.03609550f, 0.06235718f, -0.07336126f, 0.06425735f, -0.05742834f, 0.02193986f, 
    -0.01987273f, -0.05894431f, -0.03969060f, -0.00047355f, 0.05274485f, 0.02786104f, -0.04086608f, -0.02834196f, 
    0.05071490f, -0.02595564f, -0.03931011f, -0.01563923f, -0.02001705f, -0.01242822f, -0.04993641f, -0.06847192f, 
    0.03841317f, -0.05745278f, -0.02620842f, 0.05746624f, -0.01766156f, -0.06491174f, -0.06055553f, -0.03455557f, 
    -0.06896570f, 0.04457664f, 0.02015886f, 0.03516275f, 0.02973369f, -0.02625321f, -0.01169963f, 0.02806920f, 
    0.02115779f, 0.03631810f, -0.07497822f, -0.06519093f, 0.03746968f, -0.06773024f, -0.01808809f, 0.01235160f, 
    -0.07842524f, 0.00024041f, -0.00589001f, 0.03749383f, 0.04955393f, -0.02202895f, -0.01770449f, -0.08499132f, 
    0.03249351f, -0.03428856f, 0.01404305f, -0.04663412f, -0.01412759f, -0.07390137f, 0.04110112f, -0.02810301f, 
    -0.02963666f, 0.00537137f, -0.07660807f, 0.00596295f, -0.03372655f, 0.01367920f, -0.01243908f, -0.03916483f, 
    0.01813894f, 0.05658033f, -0.02204845f, -0.02282473f, 0.03496549f, 0.06032655f, 0.00742456f, 0.02446380f, 
    -0.02227242f, 0.02919273f, -0.05517057f, -0.03984262f, -0.01130961f, -0.00389468f, -0.03168840f, -0.04492901f, 
    -0.04097968f, -0.05866874f, 0.00371606f, 0.05636555f, -0.04648739f, -0.06039230f, -0.05217117f, -0.05494419f, 
    -0.05093385f, -0.04576586f, -0.02823444f, -0.04689433f, -0.00334038f, 0.00560080f, 0.05614131f, 0.02982099f, 
    0.04766761f, -0.04806075f, 0.02153600f, -0.01931545f, -0.02273284f, -0.05470397f, 0.01022447f, 0.03004748f, 
    0.06435740f, 0.03773304f, -0.07314924f, -0.01937148f, -0.01249731f, -0.00205669f, -0.01292875f, 0.01509661f, 
    -0.01673284f, -0.01914242f, 0.00206815f, -0.08012714f, 0.05239587f, 0.04702286f, -0.00611383f, -0.05361297f, 
    0.02203127f, 0.02503897f, -0.03280283f, -0.03969481f, 0.05053813f, -0.05005704f, 0.04766858f, -0.07976995f, 
    0.04941135f, -0.06594118f, -0.01106762f, -0.01345573f, -0.02888568f, 0.04661220f, -0.01615321f, -0.05018662f, 
    0.04907623f, 0.01168050f, 0.00148752f, 0.01828787f, -0.04845715f, -0.03737890f, 0.05446261f, 0.05378822f, 
    0.01103639f, -0.03995464f, -0.04630170f, -0.02189701f, -0.03856869f, 0.02578532f, 0.05130619f, 0.05698494f, 
    -0.05512498f, -0.07451834f, 0.05436178f, 0.02194642f, -0.05175127f, -0.01018303f, -0.04611486f, 0.04647262f, 
    -0.02647635f, -0.03963900f, 0.04733092f, -0.01572656f, 0.04927174f, -0.07668523f, -0.02351545f, 0.02629221f, 
    -0.02504008f, 0.06366920f, -0.05153094f, 0.03737577f, 0.04884172f, 0.01609512f, 0.02089367f, 0.05160347f, 
    0.03166516f, 0.02229880f, 0.01125090f, -0.04828908f, -0.05659516f, -0.06154801f, -0.01109193f, -0.02017697f, 
    -0.05776090f, 0.01462259f, -0.01202026f, -0.00895664f, -0.05765021f, 0.00602360f, -0.02163757f, 0.06338711f, 
    0.06064000f, -0.03565971f, 0.05364221f, 0.00995672f, -0.01273405f, -0.02670551f, -0.01436477f, -0.00414976f, 
    -0.01980452f, -0.04959780f, 0.01620380f, -0.00542635f, 0.05094725f, 0.03266759f, 0.02952119f, 0.03960982f, 
    0.03093757f, 0.04631929f, -0.04958332f, 0.07454047f, 0.04741171f, -0.03150686f, 0.02551827f, 0.00762267f, 
    -0.02143702f, -0.02810928f, 0.00273508f, -0.02653765f, -0.03656303f, -0.07738510f, -0.06425184f, -0.04606919f, 
    0.03207516f, 0.06411332f, 0.06049085f, -0.06668703f, 0.03366948f, 0.02932829f, 0.02694288f, -0.04130434f, 
    -0.04421312f, 0.01166138f, -0.02804030f, -0.02685655f, -0.06899551f, -0.00180060f, 0.00521947f, -0.03440573f, 
    -0.08338019f, 0.04526884f, -0.06862942f, -0.04850600f, 0.04721988f, -0.07238815f, 0.02144230f, 0.04070371f, 
    -0.06892758f, -0.06094254f, -0.00446739f, -0.03786115f, 0.01363385f, 0.02008336f, -0.07803832f, -0.08047921f, 
    0.01818173f, 0.01721577f, -0.07142682f, -0.04255268f, -0.02932549f, -0.04658999f, -0.00766989f, 0.00393798f, 
    -0.04017134f, -0.05206509f, -0.00143679f, -0.02441812f, 0.00720586f, 0.01351542f, -0.03155379f, -0.03372460f, 
    -0.04359187f, -0.07522087f, 0.01089904f, 0.03539424f, 0.06122697f, 0.02531124f, 0.05199796f, 0.05730259f, 
    -0.06310689f, -0.00088619f, -0.01188449f, 0.02496747f, -0.03798251f, -0.06647007f, -0.00325611f, -0.02407249f, 
    -0.07949369f, -0.03956802f, -0.04632495f, 0.03844225f, 0.05152984f, -0.00690072f, 0.02606246f, -0.08156961f, 
    0.02924190f, -0.02008955f, -0.00791143f, 0.03124464f, 0.00330884f, -0.01164526f, 0.04856579f, -0.04445661f, 
    -0.01449107f, 0.00030067f, 0.02959465f, -0.01006112f, -0.03435403f, 0.01656985f, -0.00136588f, -0.07200412f, 
    -0.01031203f, -0.02642422f, 0.03754698f, -0.04400132f, -0.06210567f, -0.01372997f, -0.07012542f, -0.02522114f, 
    0.03083042f, 0.00438971f, -0.01335405f, 0.02038059f, -0.00645863f, 0.00897975f, -0.06512981f, 0.06146719f, 
    0.02180624f, 0.03724604f, 0.02992431f, -0.05519497f, 0.06305056f, 0.03509340f, -0.07048631f, 0.01364444f, 
    -0.03799111f, 0.01963380f, -0.00583018f, -0.00281447f, -0.06515440f, 0.04481276f, -0.06803274f, 0.02039740f, 
    0.24395229f, -0.10725784f, -0.03322061f, 0.19013102f, 0.03081212f, -0.02637840f, 0.28810588f, 0.11572196f, 
    0.06590924f, -0.15523277f, -0.07689870f, 0.15679036f, 0.26930329f, 0.08852147f, -0.42305613f, -0.12611206f, 
    -0.06421346f, 0.20209830f, 0.19478698f, -0.04505501f, -0.03268147f, 0.12068567f, 0.02006604f, 0.07679885f, 
    0.57036817f, 0.05244783f, 0.08466214f, -0.05906179f, -0.03742346f, -0.17373385f, 0.14989053f, -0.00764450f, 
    0.10023088f, -0.20063441f, -0.02178296f, 0.01332098f, 0.14399691f, 0.13675007f, 0.08184921f, 0.10020588f, 
    -0.06029990f, -0.03266790f, 0.01079411f, 0.08707403f, -0.15580246f, -0.03961157f, -0.37132725f, -0.22406118f, 
    -0.42205256f, -0.18489961f, 0.02564971f, 0.03952833f, -0.15150541f, 0.01964174f, -0.03505245f, 0.14088638f, 
    0.04057321f, 0.11268204f, 0.13082924f, -0.07256036f, -0.28451401f, -0.01272043f, -0.09618057f, -0.05961294f, 
    -0.23945896f, 0.03883014f, -0.15753676f, 0.07304633f, -0.06811878f, -0.01051557f, 0.04008085f, -0.19398627f, 
    -0.60213506f, -0.28909588f, -0.14512202f, -0.03231588f, -0.20389082f, 0.22085170f, 0.06864834f, 0.03913036f, 
    -0.05242883f, 0.02466841f, -0.03295178f, -0.01628373f, 0.68853682f, 0.50117725f, 0.44343874f, 0.14323622f, 
    -0.09087957f, -0.18088046f, 0.02038350f, -0.00653548f, -0.05329892f, -0.09420692f, 0.30982685f, 0.23785836f, 
    0.10535995f, 0.15410012f, -0.02328761f, -0.01571328f, 0.09662070f, -0.01336069f, 0.05296776f, 0.01724152f, 
    0.18271731f, 0.04494800f, -0.00934109f, -0.14424929f, 0.06276171f, 0.23154604f, -0.12385264f, -0.02402456f, 
    -0.15470782f, -0.16937231f, 0.19358267f, -0.09029515f, 0.32924491f, 0.15802772f, 0.02182180f, 0.16846272f, 
    -0.13065104f, 0.22917484f, 0.21107771f, 0.41850293f, 0.11161241f, -0.01183275f, 0.02568337f, -0.10632728f, 
    -0.07972668f, -0.10148931f, 0.05328327f, 0.03316112f, -0.36211827f, 0.16856392f, -0.14620073f, 0.13620497f, 
    -0.13726944f, 0.07592545f, 0.47275150f, -0.05192994f, 0.14150159f, -0.01068997f, 0.05354173f, 0.12146130f, 
    0.03000215f, 0.04093888f, -0.06830119f, -0.08976765f, -0.01166419f, 0.00001207f, -0.01222773f, 0.02315859f, 
    0.15229219f, -0.06007627f, -0.09607001f, -0.15534687f, 0.35513464f, 0.32636121f, 0.48464936f, -0.00012608f, 
    0.09652787f, -0.08679166f, 0.02929262f, 0.00236352f, 0.02607477f, 0.03703894f, 0.01191431f, 0.22413260f, 
    -0.28781623f, -0.36375552f, 0.47970492f, 0.17192228f, 0.29968986f, 0.41400462f, -0.27769455f, -0.06943120f, 
    0.05302684f, 0.14479983f, -0.10317347f, -0.09602395f, -0.21225749f, -0.13087380f, 0.05457114f, 0.17969103f, 
    0.09944499f, -0.13419697f, -0.08166840f, 0.08102027f, 0.02809200f, -0.08638689f, 0.05877166f, 0.00865193f, 
    0.41480273f, -0.09813905f, 0.07805458f, -0.20266780f, -0.04239266f, -0.01947070f, 0.24594727f, 0.19479881f, 
    0.09514230f, -0.00532654f, -0.03601649f, -0.02492003f, -0.10715680f, 0.02396234f, 0.11291273f, 0.27212876f, 
    0.12611662f, -0.08046041f, -0.03312397f, 0.08973196f, -0.02695893f, 0.10460646f, 0.01282167f, -0.15996581f, 
    0.29034477f, -0.24621724f, 0.01079293f, -0.23083024f, 0.18006606f, -0.09197206f, 0.18880333f, 0.04329461f, 
    0.15221286f, 0.18401381f, -0.10023223f, 0.08840135f, -0.04301178f, -0.11369057f, 0.01872399f, -0.32366964f, 
    0.00605980f, -0.17351399f, -0.14489816f, -0.00745750f, 0.09829487f, 0.15369584f, 0.21294725f, 0.27250159f, 
    -0.13969606f, -0.03272919f, 0.01915335f, 0.10203338f, -0.12872046f, -0.17345582f, 0.02340134f, -0.02967637f, 
    -0.12466440f, -0.06392138f, -0.16794977f, -0.14892410f, 0.40822342f, -0.09003355f, 0.29386896f, 0.13796844f, 
    -0.02403126f, -0.15234807f, -0.01317269f, 0.36942694f, 0.12266845f, -0.13980879f, 0.16449979f, 0.11846584f, 
    -0.35964549f, -0.40780410f, -0.19205561f, -0.06273311f, -0.03416976f, -0.15788384f, 0.18766485f, -0.04598049f, 
    -0.03259837f, 0.08520053f, 0.04691191f, -0.05620713f, -0.42201051f, 0.02577160f, -0.08991487f, 0.27338371f, 
    -0.08877543f, -0.08406656f, 0.25764418f, 0.16868661f, 0.20791771f, 0.07033499f, -0.02460810f, -0.02277518f, 
    -0.13182805f, 0.26123282f, 0.12069424f, 0.10503385f, -0.13665292f, -0.16360526f, -0.05923750f, -0.02878759f, 
    -0.12390307f, 0.35815150f, 0.20075884f, 0.29521561f, 0.12160415f, 0.02295841f, 0.12747389f, 0.13288234f, 
    0.15290664f, -0.13500111f, -0.00665287f, -0.02922600f, -0.18943779f, -0.08414134f, -0.05095384f, -0.25407597f, 
    -0.03161147f, -0.00947321f, -0.13202851f, 0.03699312f, -0.06944378f, -0.02842910f, 0.20362185f, -0.13449243f, 
    0.26410845f, 0.15404923f, 0.25592062f, 0.00899027f, -0.21874593f, 0.12341866f, 0.39863953f, 0.41192639f, 
    0.04411769f, -0.00286741f, 0.02252444f, 0.15635964f, 0.00659545f, 0.00242574f, 0.10765685f, 0.07627919f, 
    -0.39097166f, -0.14978373f, 0.03413231f, -0.27760676f, -0.12938209f, 0.03165660f, -0.13674399f, 0.08070737f, 
    -0.07375902f, 0.00256208f, -0.04359514f, -0.16954367f, -0.66218811f, 0.34870011f, 0.29290280f, 0.29698202f, 
    -0.02230695f, 0.04486208f, 0.08498401f, -0.03036697f, 0.01179203f, 0.01186678f, -0.08051189f, -0.06882481f, 
    -0.48991683f, 0.31792378f, -0.14970109f, 0.09542093f, 0.03714428f, 0.03608921f, 0.05147482f, -0.02606049f, 
    -0.06252351f, 0.02928727f, -0.03224566f, 0.08422785f, -0.21652047f, 0.12731150f, 0.30984077f, 0.54992288f, 
    0.18798973f, 0.18144211f, -0.08238123f, 0.14749014f, 0.15878323f, -0.10502929f, 0.02418959f, 0.03476311f, 
    0.04670314f, 0.21838227f, -0.06747933f, 0.10419694f, 0.06479276f, 0.03665631f, 0.04576335f, 0.10050642f, 
    0.08334526f, -0.02243257f, 0.26702139f, 0.42332214f, -0.05663773f, -0.35770610f, 0.05933799f, 0.38521135f, 
    0.01902771f, -0.10797515f, 0.00407550f, -0.02108015f, 0.00498623f, -0.04751709f, 0.07562545f, -0.22252086f, 
    0.23011075f, 0.37114170f, -0.21820849f, -0.16338918f, 0.17994057f, 0.01385068f, -0.18624234f, 0.12037212f, 
    -0.01772447f, -0.35943300f, -0.21246274f, -0.22984686f, -0.33722621f, -0.42062843f, -0.29957190f, 0.01380989f, 
    0.31442678f, -0.06292257f, 0.09652750f, -0.14597712f, 0.04676813f, -0.00666693f, 0.16229489f, -0.27143443f, 
    0.59660023f, 0.07589756f, 0.10033128f, 0.10949559f, -0.05654040f, -0.02594966f, 0.00850793f, 0.37608233f, 
    -0.00976250f, 0.04354959f, -0.01356970f, -0.08649874f, 0.24071124f, 0.02863074f, 0.13301574f, 0.02207147f, 
    -0.04342365f, -0.07544579f, -0.15724671f, -0.01676450f, -0.11529914f, -0.06379019f, -0.34231141f, -0.12611552f, 
    0.15046509f, 0.08804113f, 0.34829295f, 0.06187825f, -0.15607055f, -0.04243079f, 0.14659090f, 0.34347630f, 
    0.22424291f, -0.02386640f, 0.17171615f, 0.17458612f, 0.23135994f, 0.32809937f, 0.38870749f, 0.35028023f, 
    0.14412914f, -0.09034376f, 0.20660493f, -0.28940052f, -0.02968883f, -0.00307268f, -0.12089377f, 0.11780412f, 
    -0.14845459f, -0.38169843f, -0.17981228f, -0.02857899f, 0.36539060f, 0.18632063f, -0.10071748f, 0.01657761f, 
    0.07158087f, -0.06365980f, -0.06698914f, -0.11803342f, -0.16312353f, 0.24993165f, 0.35118175f, 0.02285716f, 
    -0.10666330f, 0.16780736f, -0.03402540f, -0.06635778f, 0.10243908f, 0.16702031f, 0.32089490f, 0.31960425f, 
    0.17161241f, 0.25685498f, 0.26681507f, 0.22786631f, 0.15895902f, -0.08135560f, 0.06659417f, -0.03065413f, 
    -0.11364404f, 0.00937407f, 0.01663103f, 0.22645900f, 0.34628060f, 0.25967249f, 0.25546566f, -0.18173394f, 
    -0.02262284f, 0.21526945f, 0.01856240f, 0.34028074f, 0.04467033f, -0.05603047f, -0.18347755f, -0.38527659f, 
    -0.29797202f, -0.42428446f, -0.25489548f, -0.30056137f, 0.08008782f, -0.13788682f, 0.08523666f, 0.02714326f, 
    0.15013050f, 0.12844375f, 0.27845308f, 0.09533617f, -0.41632158f, -0.02852597f, 0.01508831f, -0.05988505f, 
    0.09101122f, 0.12431915f, -0.00926723f, 0.01436020f, 0.01335369f, 0.05291440f, 0.09141020f, 0.14830896f, 
    -0.60007578f, 0.18599236f, -0.15132469f, -0.03581061f, -0.02068939f, 0.13505884f, -0.04990255f, -0.12908025f, 
    -0.28229818f, 0.12049339f, -0.01473570f, 0.21331307f, 0.40882120f, 0.16609316f, 0.25359923f, -0.15877143f, 
    -0.11434756f, -0.05627668f, -0.27360484f, -0.03505692f, -0.09259745f, -0.07384019f, -0.01364922f, -0.24221395f, 
    -0.07360069f, 0.33928037f, 0.06170137f, 0.05386676f, 0.06575968f, -0.04781260f, -0.14741741f, 0.10703051f, 
    -0.16960973f, -0.24422844f, -0.50237387f, -0.34161082f, -0.14158042f, 0.27012816f, 0.07408421f, 0.10772897f, 
    0.08070294f, -0.19322333f, -0.03420085f, -0.09755976f, 0.06137540f, -0.08163442f, -0.14903682f, 0.06051748f, 
    -0.10664564f, 0.10143213f, 0.17012329f, 0.05091834f, 0.08964099f, 0.09074526f, 0.06898951f, 0.30107388f, 
    -0.07906696f, 0.10118198f, 0.12309610f, 0.05576923f, 0.05488361f, 0.18141769f, 0.25149488f, 0.23837803f, 
    -0.06725897f, -0.12504432f, -0.00564351f, -0.22203173f, 0.14752334f, -0.05559719f, 0.28362417f, 0.21377328f, 
    0.10292710f, 0.10058951f, -0.03242734f, 0.00710311f, 0.24919638f, 0.19925100f, 0.04208038f, -0.25460827f, 
    -0.03007947f, -0.15382104f, 0.12581623f, 0.02436238f, 0.22263454f, 0.12508716f, 0.01813781f, 0.07351144f, 
    0.43187079f, 0.16580673f, -0.04231657f, 0.13125263f, 0.04021484f, 0.01346342f, -0.00820447f, 0.34250775f, 
    0.28562030f, 0.28836957f, 0.17325678f, 0.09085280f, 0.22492234f, -0.25061712f, -0.08897601f, 0.20099938f, 
    -0.00730638f, 0.00448307f, -0.13073105f, -0.22434472f, -0.09598031f, -0.57822973f, -0.28419986f, -0.34413052f, 
    0.01537422f, 0.09680165f, -0.10014792f, 0.07391695f, 0.09080122f, 0.17261033f, 0.16349293f, 0.11121379f, 
    0.04240500f, 0.03007432f, -0.10788248f, 0.02870459f, 0.01209682f, -0.12936732f, -0.05259535f, 0.02749775f, 
    -0.07532740f, 0.35808972f, 0.06502391f, 0.10463789f, -0.03133955f, -0.16734068f, 0.07480620f, 0.17505263f, 
    -0.03092076f, 0.04877866f, -0.21092950f, 0.15772575f, -0.28209722f, -0.39185256f, -0.36836982f, -0.49507636f, 
    0.21573256f, 0.06791038f, -0.02980871f, -0.12295428f, 0.04049866f, 0.16640350f, 0.21472120f, 0.19716479f, 
    0.04953472f, -0.04342439f, -0.09612606f, -0.05604904f, -0.27778015f, -0.15224099f, -0.30942917f, 0.03800810f, 
    0.24535860f, 0.14628431f, 0.03838608f, -0.03379461f, -0.01666945f, 0.19463280f, 0.09997034f, 0.22099631f, 
    0.00960494f, 0.16645193f, 0.17777333f, 0.37558159f, -0.06329974f, 0.05943598f, -0.10816804f, -0.16491799f, 
    0.01167610f, -0.06395070f, -0.13698594f, 0.09625801f, -0.08948154f, -0.45339420f, -0.41095960f, -0.19613589f, 
    -0.08440146f, -0.02831537f, -0.12891823f, 0.01078402f, 0.17001101f, 0.00340828f, 0.02395825f, -0.01932582f, 
    0.34500808f, 0.44362950f, -0.08826613f, -0.21285552f, -0.22133315f, -0.02661525f, 0.10543858f, 0.20115197f, 
    0.15363248f, 0.06690922f, -0.08533027f, 0.03292348f, 0.00931633f, 0.06064758f, -0.18584269f, 0.13025841f, 
    0.03938120f, 0.11787482f, 0.22997977f, -0.09893729f, -0.08730155f, 0.03651365f, -0.08297078f, 0.13059147f, 
    0.24952552f, -0.07911913f, 0.02734174f, 0.16322061f, 0.17157324f, 0.02022179f, 0.14859894f, 0.13501213f, 
    0.07938553f, 0.21196738f, -0.01007756f, 0.08677612f, -0.36004397f, 0.11191740f, 0.03672680f, 0.13416348f, 
    -0.12415475f, 0.06475642f, 0.02637623f, -0.04031770f, 0.00406766f, -0.01585265f, 0.19678302f, -0.00913221f, 
    -0.14244349f, 0.06512244f, 0.52541947f, 0.09721164f, -0.26812574f, 0.08205393f, -0.07044771f, 0.01843575f, 
    0.08465645f, 0.05296427f, 0.05861404f, -0.11362177f, -0.08223753f, 0.20772220f, -0.15432273f, -0.00322839f, 
    -0.03469819f, -0.04785783f, -0.00222073f, -0.14152569f, -0.00018763f, -0.00927789f, 0.06252699f, -0.00804179f, 
    -0.41066182f, -0.39651740f, -0.15951647f, -0.03862827f, 0.02720233f, 0.01765634f, 0.21594667f, 0.37052682f, 
    0.01779548f, -0.09064261f, 0.04745495f, 0.03911104f, -0.07181425f, 0.14590879f, -0.29253349f, 0.03357358f, 
    0.15229343f, -0.06444032f, -0.14579196f, 0.08306199f, 0.24065715f, 0.08958544f, 0.15228938f, -0.07316040f, 
    -0.30728585f, -0.39019948f, -0.19157504f, 0.15640171f, 0.04843995f, 0.04011689f, 0.16184153f, 0.22977012f, 
    0.08451413f, 0.03682861f, 0.02985703f, -0.03632465f, 0.82627666f, 0.02855287f, 0.14473850f, 0.03423016f, 
    0.00809051f, -0.05347755f, -0.06842593f, -0.05779833f, 0.18726052f, 0.12161319f, 0.25463530f, 0.36646926f, 
    -0.06777550f, -0.01539971f, 0.10581198f, -0.27646309f, 0.12797847f, 0.06949328f, 0.07475707f, -0.05305135f, 
    0.16448931f, -0.07019021f, -0.07858548f, -0.00412446f, -0.30813414f, 0.12580651f, 0.04084134f, -0.05126452f, 
    -0.08643514f, 0.06703470f, 0.06545775f, 0.04898973f, -0.10844800f, 0.23622160f, 0.05193432f, 0.05058740f, 
    -0.00845292f, -0.22061256f, -0.07096212f, 0.25869858f, -0.00318047f, -0.02117519f, 0.16470625f, 0.00904120f, 
    0.05250265f, 0.21543121f, -0.03673112f, 0.06519854f, -0.21074343f, 0.18765913f, -0.22668412f, 0.12042815f, 
    0.04040358f, 0.03365533f, 0.25957498f, 0.24806698f, -0.00926365f, -0.05810798f, -0.15414351f, -0.05645379f, 
    -0.47361812f, 0.19373031f, 0.19277667f, -0.04815972f, 0.01563216f, -0.17816068f, 0.03690333f, 0.07204165f, 
    0.07643317f, 0.09991317f, -0.08334237f, 0.25805643f, -0.30027404f, -0.06068478f, 0.61558372f, 0.04553019f, 
    0.00836830f, -0.04539799f, -0.10128852f, 0.20660502f, 0.10767959f, 0.12909140f, 0.16423473f, 0.06781774f, 
    -0.37867498f, 0.23017266f, -0.08158402f, -0.25132680f, -0.06240874f, 0.36090830f, -0.12838712f, 0.00013887f, 
    0.01701680f, -0.06874562f, 0.29360667f, 0.09419923f, -0.35274330f, -0.25628036f, 0.27146837f, 0.29883817f, 
    0.02156587f, -0.13211663f, 0.04169258f, -0.05515687f, -0.00242797f, -0.12216310f, -0.02748969f, -0.03952072f, 
    0.37158975f, -0.30565816f, 0.13785532f, -0.08737752f, 0.04993633f, 0.00118514f, 0.04276034f, 0.06929632f, 
    0.06917543f, -0.09345900f, -0.03597841f, -0.11475197f, 0.24464628f, -0.00902570f, 0.48108345f, 0.13446555f, 
    -0.01330135f, 0.02848228f, -0.05000906f, -0.10815881f, 0.10013030f, 0.09807102f, 0.00784768f, -0.04258480f, 
    0.11449446f, -0.03516864f, 0.46756715f, 0.17960767f, -0.10857479f, 0.05645576f, 0.06802563f, 0.05140422f, 
    -0.00786640f, 0.08389573f, 0.09962719f, 0.28971004f, 0.02165015f, 0.24699306f, -0.13360350f, -0.38123950f, 
    -0.01455268f, 0.04453629f, -0.08314359f, -0.08604958f, 0.08359586f, -0.04080180f, 0.02334375f, 0.03558517f, 
    -0.18603963f, 0.02841760f, 0.28366718f, 0.26290208f, -0.12391609f, -0.03971377f, 0.07643483f, 0.04973019f, 
    -0.03843844f, -0.05199984f, -0.03310441f, -0.01835936f, 0.02456033f, 0.07927091f, 0.12940596f, 0.07769734f, 
    -0.08190085f, -0.00482484f, -0.06705301f, 0.19131863f, 0.12094560f, 0.00254880f, 0.19391766f, -0.08602611f, 
    -0.19942062f, -0.24852055f, -0.01655860f, 0.13164777f, 0.00061507f, 0.02217322f, 0.11619204f, -0.25936282f, 
    0.06662832f, 0.00751471f, -0.05414748f, -0.01327957f, 0.32212311f, 0.04322522f, -0.29590365f, -0.21634585f, 
    -0.00681060f, -0.03368387f, 0.02849755f, -0.03910709f, 0.00466773f, 0.01403414f, -0.05441010f, -0.02527948f, 
    0.10097028f, 0.21753031f, 0.11604977f, -0.09449665f, 0.01149209f, 0.01300941f, 0.10935470f, -0.00916730f, 
    0.03538214f, 0.00143184f, 0.00073115f, 0.08579136f, 0.03804279f, 0.00460990f, 0.12814450f, -0.00943728f, 
    0.08062062f, 0.00067320f, 0.07427153f, -0.05296800f, -0.04542907f, -0.07049227f, 0.07326982f, -0.15734653f, 
    -0.16504344f, -0.20008695f, -0.12418023f, 0.26910147f, -0.00957869f, -0.00982221f, 0.12118510f, 0.08703391f, 
    0.13670936f, 0.24283417f, 0.16664629f, 0.25850317f, 0.20679420f, 0.28795925f, 0.39848769f, 0.19654012f, 
    -0.08547354f, -0.27348420f, -0.07577941f, 0.21359815f, -0.06495398f, -0.04752535f, -0.03466286f, 0.05448342f, 
    0.28254777f, 0.37330255f, 0.32573175f, -0.26512948f, -0.03435162f, -0.02698566f, -0.12756231f, 0.05899621f, 
    0.11305867f, 0.10348583f, 0.00643552f, -0.03991246f, -0.14415301f, 0.11419270f, 0.23444504f, 0.13844068f, 
    -0.01028458f, -0.05411404f, 0.08674140f, 0.04162572f, -0.11742105f, -0.01310679f, 0.00469985f, -0.06311825f, 
    -0.33564943f, 0.06059554f, -0.11135413f, 0.14463234f, 0.01109596f, 0.25586793f, 0.12995692f, -0.22711924f, 
    -0.13084571f, -0.04209472f, -0.00538256f, 0.06063784f, -0.07123799f, 0.37450433f, 0.38680962f, 0.23560494f, 
    0.09073442f, -0.13869257f, -0.22611573f, -0.08422160f, 0.05008372f, -0.10312589f, 0.03538387f, 0.01796531f, 
    -0.00660239f, -0.03992493f, -0.04679336f, -0.02485135f, -0.00162562f, 0.01582322f, 0.06078431f, -0.07635626f, 
    0.02794008f, 0.02616510f, -0.03249605f, -0.05133182f, 0.03164832f, 0.00873331f, 0.03417052f, -0.06298595f, 
    -0.06766426f, -0.07029796f, -0.03044460f, -0.00058397f, 0.05952476f, -0.02729721f, 0.06313031f, 0.03767213f, 
    0.00661323f, -0.06361410f, -0.01615329f, 0.02045026f, -0.07039478f, 0.06229819f, -0.03003713f, 0.03085734f, 
    0.00271881f, 0.01836266f, 0.05286985f, -0.00320702f, -0.04979920f, -0.07241370f, -0.00808736f, 0.05467146f, 
    -0.05471093f, -0.04692444f, 0.06244243f, 0.03934342f, -0.02067243f, 0.00082881f, -0.02436906f, 0.04135334f, 
    -0.00743195f, -0.05848320f, -0.03524051f, 0.04053636f, -0.06913290f, 0.03394816f, -0.05717220f, 0.05635049f, 
    0.04588913f, 0.00464917f, 0.02209779f, -0.03162934f, -0.03403917f, -0.07423759f, -0.04146116f, 0.03713306f, 
    0.04282450f, -0.02989406f, -0.03317299f, -0.02367160f, 0.02660011f, -0.01758717f, -0.07085044f, 0.03070981f, 
    0.02623338f, -0.07543233f, 0.01751490f, -0.03050003f, -0.02236049f, -0.02474761f, -0.00148572f, 0.01120792f, 
    -0.06211477f, -0.05654617f, 0.05850153f, -0.04745210f, -0.02038251f, 0.01611022f, 0.03795167f, -0.07530288f, 
    0.03806995f, 0.02217036f, -0.01343900f, 0.00250633f, 0.05831258f, -0.00916252f, 0.01848074f, -0.04931137f, 
    0.02999619f, -0.05401401f, -0.07303227f, -0.04403789f, 0.02603863f, -0.03027682f, 0.06318827f, 0.04574054f, 
    -0.06752758f, 0.01130357f, -0.00826939f, 0.03759528f, 0.03853332f, -0.06420287f, 0.05034597f, -0.06867043f, 
    0.02662821f, -0.00740477f, 0.02999962f, 0.06223161f, -0.01806131f, -0.00837340f, 0.00033373f, -0.05352862f, 
    -0.02688359f, -0.07759146f, -0.06510680f, -0.05164044f, -0.04124324f, 0.01234457f, -0.03447713f, -0.02922411f, 
    0.02729824f, 0.01216694f, 0.03095008f, 0.06107548f, -0.01795222f, -0.07498780f, 0.05774225f, -0.00424715f, 
    -0.05549308f, -0.01020391f, -0.01396433f, 0.03731340f, 0.01405905f, 0.02364054f, -0.06054293f, -0.01198272f, 
    -0.04758582f, 0.06157109f, -0.07137265f, 0.02357782f, 0.02245963f, -0.06508531f, -0.03571892f, -0.03651888f, 
    -0.00951194f, 0.00025640f, 0.02385104f, -0.04690608f, 0.04592836f, 0.01984824f, -0.00140511f, -0.03619578f, 
    -0.07519625f, -0.01122962f, -0.02614108f, -0.04510157f, -0.00004096f, -0.07074538f, -0.04464210f, -0.07721575f, 
    -0.04194359f, -0.00255250f, -0.06452882f, -0.06483175f, 0.01553774f, 0.03823423f, 0.03212934f, -0.02607945f, 
    -0.05765867f, -0.01989190f, -0.00769719f, 0.04412479f, -0.01162148f, -0.03753147f, -0.01388009f, 0.00190221f, 
    0.01988659f, -0.00096045f, -0.03532533f, 0.01075704f, -0.01444763f, -0.06657412f, -0.05199838f, -0.00758535f, 
    -0.15922873f, 0.21298867f, -0.11945505f, 0.16613849f, -0.16293427f, -0.05759364f, 0.44698259f, 0.19339633f, 
    0.10034414f, 0.00514668f, 0.17638065f, 0.32756168f, 0.22027579f, -0.05062091f, -0.56816041f, 0.13448940f, 
    0.03887439f, 0.10796177f, 0.00814076f, 0.14899099f, 0.03507063f, -0.03774970f, -0.01769533f, -0.03470378f, 
    0.04145407f, 0.16949239f, -0.25761712f, -0.34287816f, 0.43392608f, -0.03274361f, -0.04042242f, -0.08301638f, 
    0.11356752f, -0.13705225f, -0.24767968f, -0.22577174f, 0.16699620f, -0.05084015f, 0.04135052f, 0.06994310f, 
    -0.07356991f, -0.15935497f, -0.19337381f, 0.17057021f, -0.09904584f, 0.12696904f, -0.06741411f, 0.16241787f, 
    0.11976286f, 0.10053278f, -0.07851671f, 0.05143791f, 0.16065449f, 0.05355456f, 0.10136683f, -0.06011055f, 
    -0.05901321f, -0.12650177f, 0.00077768f, 0.06810897f, 0.29354072f, -0.10832235f, -0.05121933f, 0.12327897f, 
    -0.13482550f, 0.06998434f, -0.14993839f, 0.02007367f, -0.32371303f, -0.01889080f, -0.23873885f, -0.06543713f, 
    -0.21520606f, -0.11695012f, 0.09844792f, 0.07728195f, 0.04897057f, -0.10740875f, 0.01217931f, 0.21299551f, 
    0.02784953f, -0.01179700f, 0.13516966f, 0.20951252f, -0.22786121f, -0.04057340f, 0.26281190f, 0.54836959f, 
    -0.13683546f, -0.17967424f, 0.03773948f, 0.18298158f, 0.11170718f, -0.10631713f, -0.08206175f, 0.02960645f, 
    -0.16581726f, -0.26752695f, -0.00809556f, 0.27575552f, 0.00960706f, -0.10529447f, -0.11293022f, 0.13914900f, 
    0.05545239f, 0.05979534f, 0.00199784f, -0.07966746f, 0.15971205f, -0.03521759f, -0.20581029f, 0.29519221f, 
    0.10296227f, 0.14694704f, -0.04338203f, -0.02251550f, 0.29832852f, 0.23873886f, 0.23143284f, 0.21364728f, 
    0.12793022f, 0.23994435f, 0.48473129f, -0.01136085f, 0.14183435f, -0.00495772f, -0.02158021f, -0.22544158f, 
    0.10738422f, -0.04972803f, 0.20481619f, 0.10113927f, -0.21226157f, -0.22481735f, -0.39067289f, 0.07970908f, 
    0.03837910f, 0.30330941f, -0.00144147f, -0.08849023f, 0.04127208f, -0.06540146f, 0.01784669f, -0.19332848f, 
    -0.17918317f, -0.41041225f, -0.35396618f, 0.05519925f, 0.15175323f, 0.09161540f, 0.01990768f, -0.14231533f, 
    0.06400920f, 0.13327107f, -0.05316776f, -0.09870002f, -0.30819333f, 0.42721519f, 0.13499519f, -0.14145525f, 
    0.20013584f, -0.04316231f, -0.12891829f, 0.12326200f, 0.25420761f, -0.03581752f, 0.05031590f, 0.23006074f, 
    -0.57992113f, 0.12602004f, 0.20795910f, -0.15223791f, 0.12685275f, 0.09707119f, -0.04532671f, -0.08513135f, 
    0.00621407f, 0.31175861f, 0.03962598f, -0.04529867f, -0.20922762f, 0.03702099f, 0.49851349f, 0.25186753f, 
    0.26903293f, 0.21762176f, 0.07557739f, 0.03984056f, 0.02118763f, -0.13198012f, -0.09167526f, -0.17402007f, 
    -0.30592659f, 0.30304408f, 0.13366322f, 0.04337773f, -0.06910004f, 0.08841331f, -0.09141216f, 0.20090871f, 
    -0.19791116f, -0.03495591f, -0.42639384f, -0.28717816f, -0.18958312f, 0.35084686f, -0.23385997f, 0.00208431f, 
    0.20254333f, -0.00571098f, -0.16751808f, 0.01008240f, 0.00763582f, -0.06231789f, 0.03622412f, 0.11656883f, 
    -0.08690699f, 0.20521373f, -0.39534432f, 0.01395464f, 0.16579822f, -0.10905652f, 0.18884639f, 0.30866089f, 
    -0.03870049f, 0.20113263f, 0.09154674f, 0.08892258f, -0.03338081f, -0.13485064f, 0.14610185f, 0.28200534f, 
    -0.08967756f, -0.05568444f, -0.00868673f, -0.02400152f, 0.22659819f, 0.01555581f, 0.14515637f, 0.12996106f, 
    0.27741170f, 0.21082565f, -0.07766871f, -0.21595168f, 0.07508421f, 0.13589531f, -0.05160616f, -0.11999904f, 
    0.00772374f, -0.08410914f, -0.00329024f, -0.04142603f, 0.06424794f, 0.15899365f, -0.00844800f, 0.07378241f, 
    0.32595974f, 0.15099138f, 0.16165748f, 0.08207820f, 0.17684986f, -0.09263192f, 0.28330022f, 0.30425206f, 
    0.39088199f, 0.38433582f, 0.01804654f, -0.07077137f, 0.20890187f, 0.07860243f, -0.16488092f, 0.16457506f, 
    -0.11115737f, 0.01659974f, -0.14800577f, -0.08871759f, -0.29022807f, -0.18420671f, -0.08564320f, -0.05897991f, 
    -0.07139086f, 0.13593622f, 0.01621228f, 0.10262754f, 0.07421231f, 0.12320401f, -0.00250011f, -0.12226963f, 
    0.00612928f, 0.01519516f, -0.10255717f, -0.15411459f, 0.02848513f, -0.12502821f, 0.01366457f, 0.04782840f, 
    -0.08094978f, 0.31960493f, 0.14398041f, 0.21695799f, -0.10023040f, -0.03449639f, -0.17180268f, 0.05316620f, 
    0.16652039f, 0.05606077f, 0.02631497f, 0.11232065f, -0.25013983f, -0.18496476f, -0.23479849f, -0.15507181f, 
    0.16456890f, 0.19315842f, -0.08990713f, -0.33347809f, 0.01269124f, 0.14766718f, 0.29904911f, 0.27360687f, 
    0.20338772f, 0.04942359f, -0.04890972f, 0.06260674f, -0.48519066f, -0.01216570f, -0.19834647f, 0.11266047f, 
    0.17439614f, -0.12330182f, 0.07227774f, -0.20824741f, 0.04414166f, 0.15174532f, 0.10333270f, 0.16167030f, 
    -0.31804177f, -0.11467387f, -0.25566477f, 0.31199536f, -0.02224344f, 0.04395283f, 0.04148613f, -0.11156495f, 
    0.05091731f, -0.13378757f, -0.08069146f, 0.05538000f, 0.40192837f, -0.34440589f, -0.32279226f, -0.02486640f, 
    0.04982876f, 0.11130704f, 0.07871652f, -0.03637719f, 0.17188862f, 0.07350962f, -0.07743225f, -0.14860681f, 
    1.03165448f, -0.19395451f, 0.19505587f, -0.09715482f, -0.24838026f, -0.33902723f, -0.07469006f, 0.10824237f, 
    0.11819214f, -0.08996273f, -0.00005088f, -0.04557849f, 0.11598758f, 0.04976238f, -0.35248628f, -0.13622026f, 
    0.20191979f, 0.02056802f, 0.25420797f, 0.13632283f, -0.09160544f, 0.12648687f, 0.03235950f, 0.02050687f, 
    0.17748666f, -0.06647796f, 0.21035169f, 0.02495388f, 0.09514944f, -0.09995434f, -0.13357241f, -0.17590488f, 
    -0.04273043f, -0.06254195f, -0.24377136f, -0.25330737f, 0.15775904f, -0.03385363f, 0.83390498f, -0.29536399f, 
    -0.08563653f, -0.12466533f, -0.06719317f, -0.09633899f, 0.15581600f, 0.00653530f, 0.02099493f, -0.03061944f, 
    -0.27654833f, -0.08900954f, 0.55667734f, 0.31824481f, 0.17596944f, -0.02266447f, -0.05045150f, 0.13791610f, 
    -0.15334822f, 0.11053592f, 0.00980363f, 0.16765235f, 0.06334341f, 0.19032499f, -0.08199284f, -0.14397535f, 
    -0.12581854f, 0.06317841f, 0.10050739f, -0.00566747f, 0.21198934f, -0.06071161f, 0.10632208f, 0.00309202f, 
    -0.25126967f, -0.21753693f, 0.36594966f, 0.26120540f, -0.03392998f, 0.20051278f, 0.16245037f, -0.21231571f, 
    -0.15813634f, -0.00605688f, -0.07596963f, -0.06581320f, 0.18396606f, 0.25173491f, -0.07652148f, 0.21051604f, 
    -0.05139405f, 0.17824768f, 0.32558733f, -0.05609379f, 0.07339167f, 0.19403589f, -0.13308401f, 0.12516357f, 
    -0.15315640f, -0.01206441f, 0.11439089f, 0.19006124f, -0.07529861f, -0.08261474f, -0.02285459f, -0.17424119f, 
    -0.10510062f, -0.05995692f, -0.17119399f, -0.12032342f, 0.06232109f, -0.16844182f, -0.25352946f, -0.24040683f, 
    0.08295831f, 0.08367346f, -0.02288872f, -0.09575173f, -0.15640935f, 0.14301994f, -0.06315562f, -0.09783448f, 
    0.13822018f, 0.13483094f, 0.05433834f, -0.18201399f, 0.03408654f, 0.06107431f, 0.03259915f, 0.15456155f, 
    -0.09497507f, 0.03584670f, 0.19077717f, 0.05511655f, 0.04786646f, -0.34561625f, 0.03217316f, -0.23567438f, 
    0.18435699f, 0.11338502f, -0.24817373f, 0.11353434f, -0.02105697f, -0.15301165f, -0.13673145f, -0.00901549f, 
    -0.25696343f, -0.30859762f, -0.03591429f, 0.00093553f, -0.11087314f, -0.01549085f, 0.21383685f, 0.34928864f, 
    0.11456636f, 0.20117840f, -0.05506985f, 0.12013958f, 0.22845991f, -0.02766777f, 0.27157041f, -0.27524701f, 
    0.07428554f, -0.13085936f, -0.19296077f, 0.07986569f, -0.09914184f, -0.07453145f, 0.09436337f, 0.15336663f, 
    0.41214317f, 0.28497919f, 0.35234889f, -0.02733676f, -0.11053778f, 0.04096110f, -0.10350146f, -0.13067858f, 
    0.06926462f, 0.10783794f, 0.14037785f, 0.01638107f, 0.02087542f, 0.02560118f, 0.02506838f, -0.04485966f, 
    -0.04045562f, 0.00934903f, 0.14143114f, -0.10055479f, 0.18406780f, 0.07358915f, 0.00717306f, 0.02749983f, 
    0.04662105f, 0.10586613f, 0.03346648f, 0.00463224f, 0.15381470f, 0.10960327f, 0.31966382f, 0.04636803f, 
    0.06524424f, -0.12428768f, 0.03043443f, 0.05876467f, -0.19838670f, 0.25198686f, 0.25133109f, -0.11169674f, 
    0.04308890f, -0.00144819f, 0.08937458f, -0.20929928f, 0.00475179f, -0.03261286f, -0.00100522f, -0.01130926f, 
    0.00022350f, -0.03675795f, -0.00241653f, -0.01568150f, -0.00534388f, 0.01509566f, -0.01142289f, 0.02555970f, 
    0.02071037f, -0.05898142f, -0.05322113f, -0.03150333f, 0.05467467f, 0.01988682f, -0.01353930f, -0.03864603f, 
    0.00454178f, -0.03821081f, 0.06016510f, 0.02549828f, -0.04164726f, 0.00323650f, -0.03239755f, -0.07573775f, 
    -0.05067767f, 0.02031268f, -0.04679351f, -0.06106874f, 0.01475608f, -0.06917515f, 0.03793253f, 0.01200985f, 
    -0.02924699f, -0.02731075f, -0.06325682f, 0.04413789f, 0.05826690f, -0.04192103f, 0.02440372f, -0.07832076f, 
    0.03077831f, -0.00790375f, -0.00674580f, -0.01610081f, 0.02841890f, -0.05017987f, -0.05665185f, -0.04875555f, 
    -0.04704762f, -0.04977275f, 0.03158550f, -0.05400454f, -0.04297015f, -0.01003587f, -0.03857005f, -0.01281568f, 
    0.00743461f, 0.03960445f, 0.00480976f, -0.05106568f, -0.04495811f, 0.03060718f, 0.02930233f, 0.06820393f, 
    0.05925658f, 0.02318642f, -0.05218348f, -0.06290587f, -0.03048798f, 0.05417427f, 0.02212190f, -0.04177729f, 
    -0.01113959f, 0.03879934f, 0.06245695f, 0.03312074f, -0.06256354f, 0.01247937f, 0.01219130f, -0.04782670f, 
    -0.01261567f, 0.04775257f, -0.02003143f, 0.05799528f, 0.00549064f, 0.05053490f, 0.05359190f, -0.05611756f, 
    -0.05405672f, -0.04073437f, -0.07221732f, 0.05421876f, -0.00462047f, 0.05303900f, -0.03652495f, -0.03805330f, 
    0.04399072f, -0.04355383f, 0.05644668f, 0.01089078f, 0.00247492f, 0.03452158f, -0.05871635f, -0.06423193f, 
    0.04530493f, -0.02802210f, 0.02222954f, -0.04871774f, 0.06720207f, 0.00511923f, 0.01100678f, -0.00293207f, 
    -0.06449671f, -0.06091461f, 0.03730605f, 0.03699500f, -0.05181181f, -0.01207242f, -0.02753397f, -0.01942186f, 
    -0.00086986f, -0.01744642f, -0.04248764f, -0.01937767f, 0.01235320f, 0.04093866f, -0.05717943f, -0.00558472f, 
    -0.00913918f, -0.00304177f, 0.04738625f, -0.01996564f, -0.02011007f, 0.04282137f, -0.07518149f, 0.04782245f, 
    -0.00907695f, 0.04386850f, 0.04772216f, -0.04953079f, -0.00005304f, -0.02286016f, 0.03481435f, -0.06750917f, 
    -0.02269850f, -0.04794819f, -0.02189952f, 0.03355841f, 0.04663452f, -0.03222040f, -0.00753851f, 0.00186080f, 
    0.02562630f, 0.00510626f, -0.04807173f, 0.00007593f, -0.00637837f, -0.03292564f, -0.04480712f, -0.01905899f, 
    -0.01138648f, 0.05164422f, 0.04139888f, 0.01582981f, -0.04395689f, -0.04157781f, 0.03686224f, -0.04285458f, 
    0.00704101f, -0.05474164f, 0.00824367f, -0.04409019f, -0.08015138f, -0.00223438f, -0.05717618f, 0.06107556f, 
    -0.04505764f, -0.05394801f, -0.08291615f, -0.00025258f, 0.01761286f, 0.00361262f, -0.00108328f, -0.01894219f, 
    -0.01631305f, -0.05420469f, 0.06003181f, 0.04995990f, -0.07311042f, -0.03543889f, 0.01405865f, 0.00211107f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05600980f, -0.07431312f, 0.29900634f, -0.13756838f, 0.05381805f, 0.05913598f, 0.24889122f, 0.04822326f, 
    -0.04231022f, -0.14327776f, 0.21959648f, -0.03204321f, -0.05181736f, 0.20101769f, 0.05569002f, -0.01057694f, 
    0.14713603f, 0.13774154f, 0.03022340f, 0.03204227f, 0.04919517f, 0.10689203f, 0.10217579f, 0.00671304f, 
    0.22643927f, -0.00518105f, 0.06183698f, -0.04318349f, 0.08776224f, 0.18303242f, 0.21118093f, -0.03239917f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10563740f, 0.34601143f, -0.37206796f, 0.22122422f, -0.43794298f, -0.09372446f, -0.36498982f, -0.07730856f, 
    -0.01981161f, 0.36534360f, -0.22930403f, -0.16005053f, -0.15588273f, 0.01903331f, 0.25657853f, -0.14778668f, 
    -0.31661788f, 0.17069872f, -0.17473905f, 0.09410184f, 0.03123668f, -0.17747968f, -0.52343875f, 0.16564606f, 
    0.05374921f, -0.54198372f, -0.68390024f, -0.03480309f, 0.01186772f, 0.36641356f, -0.70879537f, -0.17937054f, 
    0.06332152f, 0.19654585f, 0.25264561f, 0.12774034f, -0.25538597f, 0.26364735f, -0.13714062f, -0.14883158f, 
    -0.12230093f, -0.04656973f, 0.16102530f, -0.16183569f, 0.03222514f, 0.53033203f, 0.02323971f, 0.07157586f, 
    0.30877683f, 0.26930445f, -0.15316299f, -0.08794867f, -0.13786542f, -0.22595870f, -0.58726358f, -0.17443572f, 
    0.24418963f, -0.39950857f, -0.06045715f, 0.12227061f, -0.57187182f, 0.20071240f, 0.44622231f, -0.13115004f, 
    -0.27293882f, -0.35771978f, 0.34654647f, -0.55627710f, 0.05409969f, 0.61519957f, 0.23384465f, -0.03088727f, 
    0.04882578f, -0.11306304f, -0.35886148f, -0.07789388f, -0.08522253f, -0.46054021f, -0.59422660f, 0.01143642f, 
    -0.23910353f, 0.18274918f, 0.16950320f, 0.10041039f, 0.11483627f, 0.22169451f, 0.12705368f, -0.00705242f, 
    -0.33693868f, -0.05484440f, -0.26088342f, -0.14970304f, 0.21059781f, 0.02605061f, -0.01045890f, -0.05601963f, 
    0.27505749f, -0.16911884f, -0.48574612f, -0.33520928f, -0.15145266f, 0.08293639f, -0.26517510f, 0.13363764f, 
    -0.02353278f, 0.06490666f, -0.48245618f, 0.17721944f, 0.05738984f, -0.85741681f, 0.09379918f, 0.00969137f, 
    -1.15004909f, 0.55554020f, -0.07130225f, 0.14701964f, -0.14455570f, 0.02587474f, 0.08314443f, 0.28512514f, 
    0.06051312f, 0.33326909f, 0.04005535f, -0.02610622f, 0.12685384f, -0.48307943f, 0.16095519f, 0.03219394f, 
    0.00859787f, 0.21201330f, -0.59905005f, 0.36620846f, 0.01043139f, 0.15843073f, -0.37362584f, -0.07319447f, 
    0.00809843f, 0.18119702f, -0.01047919f, -0.01373587f, -0.10902024f, -0.46122777f, -0.56246215f, 0.00362378f, 
    0.30665752f, -0.64848870f, -0.10220020f, -0.16597898f, 0.09688593f, 0.09281954f, 0.18788779f, 0.27460575f, 
    -0.47718978f, -0.24277274f, 0.08388165f, 0.06141478f, 0.25928363f, -0.16706768f, 0.02372320f, 0.07782393f, 
    0.11793199f, 0.36283243f, -0.36526343f, -0.26205289f, 0.08328545f, -0.08214827f, 0.36410436f, 0.01995960f, 
    -0.03779035f, -0.40819538f, 0.49886712f, 0.15747543f, 0.13078430f, -0.08806271f, 0.34438831f, -0.09489328f, 
    -0.23506604f, -0.34860626f, -0.04221425f, -0.11744587f, -0.07198221f, -0.18210201f, 0.07017867f, -0.02313007f, 
    0.42182627f, -0.34580487f, -0.25841093f, -0.08989946f, 0.27263421f, 0.23489900f, -0.16028582f, -0.03131146f, 
    -0.09100477f, -0.47313064f, 0.09901942f, -1.28868914f, 0.23391365f, -0.97073108f, 0.36734051f, 0.04880955f, 
    -0.01608541f, -0.24411279f, -0.34959847f, 0.08949306f, -0.12783678f, 0.37741393f, -0.58697134f, 0.12755446f, 
    0.35634458f, 0.05328108f, -0.09097314f, 0.10209420f, 0.15590377f, 0.22424297f, 0.05516705f, -0.73663664f, 
    -0.58590269f, -0.07812627f, -0.16441619f, -0.03237061f, 0.35349968f, -0.25223401f, -0.00095994f, -0.05818534f, 
    -0.77748489f, 0.26331598f, -0.35386744f, 0.61130875f, 0.21764520f, -0.89655453f, 0.17889161f, 0.06770824f, 
    -0.08796597f, -0.38352618f, -0.30945316f, -0.12002128f, 0.16548878f, -0.61630321f, 0.22607827f, -0.13721374f, 
    -0.06688609f, -0.04469215f, 0.10986567f, 0.11098575f, 0.11679361f, 0.13040468f, -0.29314867f, -0.81422949f, 
    0.00713669f, 0.26657411f, 0.11308071f, -0.11726095f, -0.22890376f, -0.04636386f, 0.26045999f, 0.01245708f, 
    -0.30486748f, -0.07203519f, 0.21725613f, -0.76434684f, -0.01837284f, -0.99209559f, 0.04512637f, 0.09923793f, 
    0.14430155f, -0.46083316f, 0.02927743f, 0.07715785f, 0.08303338f, -0.42995596f, 0.23159967f, 0.04718685f, 
    -0.40562582f, 0.18033129f, -0.14153036f, 0.16677381f, -0.09835218f, -0.61195278f, 0.53010243f, -0.72311091f, 
    0.38923433f, 0.16228579f, 0.15299135f, 0.06455023f, -0.58072513f, 0.44773436f, 0.19166067f, 0.08479697f, 
    -0.15354960f, -0.03749451f, 0.28010479f, 0.51673996f, -0.07902022f, -0.22449893f, 0.07579600f, -0.10948648f, 
    0.02087665f, -0.39679864f, 0.11284596f, 0.02398439f, 0.03173677f, 0.29841462f, 0.08550860f, 0.07408839f, 
    0.31031737f, -1.05310249f, -0.13012818f, -0.04658621f, -0.02953061f, 0.28692362f, -0.59761894f, 0.47106180f, 
    -0.84254968f, 0.36256883f, -0.24395761f, -0.03432179f, -0.05123452f, -0.19964258f, -0.63878274f, -0.07618625f, 
    0.43154159f, -0.47848359f, -0.30463260f, -0.13504805f, -0.62249786f, 0.27054149f, -0.35335040f, -0.06198009f, 
    0.00666664f, 0.00945859f, 0.59058613f, 0.00696158f, -0.10824733f, -0.49374601f, 0.19148791f, -0.13082457f, 
    0.30821797f, 0.31778869f, -0.10684787f, -0.06843060f, -0.02123810f, 0.45057243f, 0.60526639f, -0.56121176f, 
    -0.15590346f, -0.13131161f, 0.27068746f, 0.03846680f, -0.54288614f, -0.06099413f, -0.26221538f, -0.10023323f, 
    -0.22812672f, -0.12791812f, -0.11571045f, -0.50579733f, 0.29045430f, -0.87280685f, 0.26753247f, -0.08073729f, 
    -0.13634801f, 0.39440915f, 0.36035651f, 0.06046627f, 0.07331486f, 0.20069030f, 0.39730066f, -0.13187151f, 
    -0.19073732f, 0.32969543f, 0.03183386f, 0.02167080f, -0.09883383f, -0.47675392f, 0.28794771f, 0.33490807f, 
    -0.31515643f, -0.24092466f, 0.21406730f, 0.14255957f, -0.35463166f, -0.95705974f, 0.28910771f, -0.04858338f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01662577f, -0.09914304f, -0.03485438f, -0.13235638f, -0.18382344f, -0.02552662f, 0.22086757f, -0.25982347f, 
    0.02953105f, 0.05101174f, -0.14709213f, -0.21911381f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
