#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.67086869f, -0.26320162f, 0.71408260f, -0.76655304f, -0.91859859f, -0.01605414f, -0.24715121f, 0.27028370f, 
    -0.30238566f, -0.55803770f, -0.18540028f, 0.36538652f, -0.21695222f, 0.12831254f, 0.53564602f, 0.07892379f, 
    0.43622515f, -0.13082804f, -0.24912553f, 0.24519341f, -0.07792273f, 0.22674029f, 0.26934493f, 0.24799508f, 
    0.80794233f, 0.72183090f, 0.78144163f, 0.97722375f, 0.56381482f, 0.78567278f, 0.18225771f, -0.86842173f, 
    0.32845649f, -0.21261951f, 0.25024924f, 0.63284475f, 0.25822031f, -0.64357883f, -0.17794582f, 0.18860392f, 
    -0.07407570f, 0.12649763f, -0.45152903f, 0.07073987f, 0.39582574f, 0.51410174f, -0.31642839f, -0.01248629f, 
    -0.13570307f, 0.38754508f, 1.36273623f, 0.68519372f, -0.64111167f, 0.82892376f, 1.21167266f, 0.19370328f, 
    0.30973548f, 0.40263924f, 0.46243563f, -0.21687755f, -0.44917163f, -0.25235841f, -0.00688000f, -0.25510508f, 
    -0.12546264f, -0.15292157f, -0.19642673f, -0.20646304f, -0.22196843f, -0.28848457f, 0.35759217f, -0.12375916f, 
    0.12677769f, 0.20212257f, -0.03678390f, 0.21056975f, 0.74982703f, -0.50296825f, -0.20952921f, 0.72128326f, 
    -0.69154161f, -0.60974133f, -0.21660936f, -0.42288512f, 0.34927937f, 0.48036143f, -0.39061084f, -0.53232038f, 
    0.06949312f, 0.22390708f, 0.52816725f, 0.20129183f, 0.09898561f, -0.06564049f, 0.40634698f, -0.24149615f, 
    -0.28623644f, -0.06891003f, -0.65080303f, 0.21895178f, 0.03126189f, 0.09281193f, -0.95727658f, -0.78678769f, 
    -0.21982376f, -0.31744260f, -0.64324206f, 0.12335973f, -0.52314472f, -0.22620142f, 0.53389114f, -0.04759150f, 
    0.55011785f, 0.44921637f, -0.38105774f, 0.41156116f, -0.11017830f, -0.40523261f, 0.16122754f, 0.22127277f, 
    0.02657312f, 0.13111889f, 0.47417077f, 0.00492711f, 0.52454954f, 0.60441822f, 0.54037207f, -1.21685553f, 
    -0.99214047f, -0.28413904f, 0.68990672f, -0.28424221f, 0.07623463f, 0.53632200f, 0.11672250f, -0.64946795f, 
    -0.12975414f, -0.01515222f, 0.22588529f, -0.04868471f, 0.22845475f, 0.11138077f, 0.00551090f, 0.06226606f, 
    0.34251234f, 0.44571152f, -0.00027198f, -0.11672653f, -0.17837414f, 0.27495527f, 0.97683126f, 1.24111247f, 
    0.52497184f, -0.46277741f, -0.36432114f, 0.06427304f, 0.09484134f, 0.05040522f, -0.82515591f, -0.40501857f, 
    0.18557438f, 0.24494755f, -0.20508860f, 0.43474889f, 0.11832283f, 0.31160015f, -0.15378091f, -0.05249618f, 
    0.16343597f, 0.06574102f, 0.00861576f, 0.52250576f, 0.34988579f, 0.03491231f, 0.40857694f, 0.79017818f, 
    -0.57498902f, -0.29496211f, -0.50048250f, -0.70947331f, 0.67954332f, -0.01402701f, 0.59326190f, 0.06589473f, 
    -0.77864343f, 0.59818608f, 0.38013169f, 0.19686763f, -0.11389048f, 0.27110291f, -0.11575875f, -0.66087711f, 
    0.06103233f, -0.44961232f, -0.12087753f, 0.31418803f, 0.18198566f, 0.22459996f, 0.16011523f, 0.10745910f, 
    0.63838577f, -0.58685517f, 0.63643354f, 0.66775012f, 0.45751786f, 1.09023142f, 0.24912508f, 0.13205819f, 
    0.08861786f, -0.35121983f, 0.08860382f, 0.34141308f, 0.23233436f, 0.19431223f, 0.26303640f, 0.43396986f, 
    0.23679411f, 0.23879762f, -0.10179190f, 0.11781253f, -0.05662636f, -0.10747205f, -0.13838781f, 0.21627158f, 
    0.44834572f, 0.96678412f, -0.66479409f, -0.64563149f, -1.11098194f, -0.20721501f, 0.73516101f, -0.35021666f, 
    0.42675304f, 0.00266255f, 0.13063501f, -0.39759007f, 0.31440887f, -0.22605574f, -0.20468690f, 0.11277749f, 
    -0.39795157f, 0.12243936f, 0.18223739f, 0.02699408f, 0.16123489f, -0.08230288f, -0.14101937f, -0.19342360f, 
    -0.02450214f, 0.02133401f, 0.37063730f, 0.31489620f, -0.14972445f, -0.51059163f, -0.31661439f, 0.60129112f, 
    -0.90464872f, 0.00348783f, -0.02449306f, 0.60599935f, -0.79192722f, -0.59948599f, 0.10746827f, 0.35280639f, 
    -0.37036869f, -0.58595604f, 0.27246565f, -0.06021147f, -0.29268944f, -0.10350949f, -0.44023028f, -0.14127782f, 
    0.22635987f, -0.47681266f, 0.37420118f, 0.67889994f, 1.17070651f, 0.25908688f, -0.15261889f, 0.58410680f, 
    -0.67023808f, -0.64519495f, 0.36559820f, 0.07750297f, -0.35014215f, 0.04278030f, -0.31973881f, 0.12028343f, 
    0.26871127f, 0.03493615f, -0.30649394f, 0.07265250f, -0.28187996f, -0.53195816f, -0.20479597f, 0.15775283f, 
    0.43217683f, 0.38414174f, 0.19576770f, -0.28610101f, -0.94491959f, -1.14666915f, -0.44625005f, -0.23105675f, 
    -0.68913436f, 0.25467667f, 1.39642358f, 0.72555727f, -0.60818332f, 0.46998152f, -0.30497721f, -0.28189647f, 
    0.09127287f, -0.21109065f, 0.01955329f, -0.08429639f, -0.03061019f, -0.17801057f, -0.02191923f, -0.05009500f, 
    -0.01901437f, 0.18371622f, 0.18612348f, 0.13281374f, 0.17250860f, 1.27981830f, 0.84389526f, -0.93605375f, 
    -0.64584029f, -0.83190328f, -0.64621139f, -0.05288006f, -0.45414439f, 0.36242360f, 0.05811639f, -0.14301376f, 
    -0.27231032f, -0.12874137f, -0.20894265f, 0.00381882f, -0.01985673f, -0.14206779f, 0.21249726f, 0.19172172f, 
    -0.02546079f, 0.40928793f, 0.13650712f, -0.06367501f, 0.06016422f, -0.12130293f, -0.74497890f, 1.02062178f, 
    0.25667188f, -0.26634967f, -0.15970795f, -0.40355057f, -0.47176793f, 0.03351949f, 0.11497628f, -0.71278912f, 
    -0.32850486f, 0.15304174f, 0.08275293f, -0.45320511f, -0.71490377f, -0.79292804f, 0.05459081f, -0.33570972f, 
    0.07990450f, -0.10678076f, 0.07131110f, -0.18194617f, -0.53888601f, -0.05837929f, -0.15020895f, 0.14820255f, 
    -1.13158071f, -0.75804573f, -0.67456126f, 0.53472668f, -0.18265767f, 0.09400973f, -0.83504385f, -0.13803247f, 
    0.32266027f, -0.15243369f, -0.00638952f, 0.20796014f, 0.28651094f, 0.13307984f, -0.13394780f, 0.01330845f, 
    -0.36291957f, -0.07134127f, -0.06209223f, 0.40404168f, 0.16909622f, 0.56885469f, -0.07491214f, -0.33655432f, 
    -1.05201590f, 0.47661340f, -0.07598572f, -0.36393145f, 0.49474186f, -1.01236069f, 0.49871904f, 0.85774618f, 
    -0.13057603f, 0.05893435f, -0.02032797f, 0.72005731f, -0.42324674f, 0.49558225f, -0.09705254f, -0.26620084f, 
    -0.26195192f, -0.47807199f, -0.38283297f, -0.23961064f, 0.05526108f, -0.03681382f, 0.25939018f, 0.08555016f, 
    -0.58379138f, 0.02107901f, -0.57776648f, -0.81929517f, 0.81283313f, 0.28646439f, 0.09977169f, -0.16005351f, 
    -0.37400496f, 0.45650196f, 0.09149254f, -0.36020112f, -0.15275742f, -0.06746953f, 0.23799033f, -0.14453650f, 
    0.55365795f, 0.20020376f, 0.04481447f, 0.40505332f, 0.77272892f, 0.25057223f, -0.20299955f, -0.48570082f, 
    -0.27266550f, -0.28618106f, -1.16778016f, -1.24020267f, 0.70140386f, 0.57755214f, -0.08784313f, 0.49497250f, 
    -0.16058557f, 0.62749225f, -0.39311677f, -0.73615688f, 0.30081838f, -0.34753585f, 0.00305409f, 0.58871067f, 
    0.34730124f, 0.36779195f, 0.29184228f, -0.23195142f, -0.18011683f, -0.01839928f, 0.18577163f, 0.11617880f, 
    0.32570750f, 0.19834593f, -0.18880334f, -0.18558343f, -0.26923543f, 0.85486674f, 0.92592382f, 0.57529885f, 
    -1.49297810f, -0.07465126f, -0.81574726f, -0.91515046f, -0.17150074f, 0.60891348f, 0.20150806f, 0.26767048f, 
    0.46561536f, 0.10885261f, -0.31386232f, 0.27313614f, 0.36299831f, 0.03503228f, -0.05794228f, 0.08548021f, 
    0.13662212f, 0.08765224f, 0.06463089f, 0.14890593f, 0.71982068f, 0.16913819f, 0.83277202f, 0.26072651f, 
    0.25124663f, 0.47410354f, -0.02834556f, 0.77835917f, 0.85353649f, 0.49304917f, -0.90959895f, -0.28471935f, 
    -0.58502704f, -0.20574890f, 0.11752801f, -0.01626381f, -0.12788822f, -0.42812988f, -0.38218734f, 0.20466575f, 
    -0.55628133f, -0.12946413f, -0.55642796f, 0.04383387f, -0.42670548f, -0.21152468f, -0.94531566f, -0.48212183f, 
    -0.73780364f, -0.61331296f, 0.19185457f, -0.77090549f, -0.68973184f, -0.63649327f, -0.06899402f, 0.19966872f, 
    -0.10556038f, -0.10971170f, -0.06975809f, -0.05320705f, -0.21265508f, -0.02344250f, 0.00010269f, 0.25643241f, 
    0.68955165f, 0.31426346f, -0.20946705f, -0.13122943f, -0.09778622f, 0.00445101f, -0.42070979f, -1.26891196f, 
    -0.85654575f, -0.08874174f, -0.80445743f, -0.05323568f, 0.52613282f, 0.42001411f, 0.61205608f, 0.74151343f, 
    0.26810849f, 0.17825848f, -0.27098367f, 0.14927509f, -0.18114080f, 0.07979275f, -0.02580004f, 0.01868657f, 
    0.02325046f, 0.10508651f, -0.11446265f, -0.34450969f, 0.10023452f, -0.38968036f, -0.13583228f, 0.88768250f, 
    -0.80663788f, 0.13001263f, 1.39197576f, -0.02794381f, -0.44136909f, 0.23156339f, 0.25393620f, 0.37610838f, 
    0.37917957f, -0.20548256f, 0.13027094f, -0.20036669f, -0.24723198f, 0.31391290f, -0.78739595f, -0.26528230f, 
    0.11030447f, 0.06759771f, -0.39636528f, 0.00559061f, -0.05707268f, -0.30096903f, 0.04995809f, -0.02695443f, 
    -0.19291337f, -1.00971222f, -0.88697600f, 0.82121521f, 1.02074575f, 0.70829046f, 1.34597600f, 0.40344110f, 
    0.73435861f, 0.25071192f, -0.18130724f, -0.25049677f, -0.42328274f, 0.14601754f, -0.09977526f, 0.07740107f, 
    -0.21556959f, -0.00361224f, -0.11153574f, -0.41518143f, -0.00620734f, -0.05349438f, -0.04938680f, -0.29385859f, 
    -0.12041194f, 0.40750113f, 0.23151435f, 0.56613976f, 0.77252269f, -0.93263280f, -0.44834667f, -0.18391134f, 
    0.58641791f, 0.24661231f, -0.67355597f, -0.06888803f, -0.48083374f, -0.75179070f, 0.26266271f, 0.24802074f, 
    -0.12103260f, 0.20675382f, 0.39629418f, -0.35629368f, 0.22168896f, 0.30196068f, 0.32440567f, -0.00708240f, 
    0.22889872f, -0.73235667f, 0.19663979f, 1.07440472f, 1.18900084f, 0.92724317f, 0.99241120f, 0.76172221f, 
    0.13709971f, -0.03396353f, -0.59700203f, -0.14146826f, 0.28685674f, -0.17808104f, 0.19956008f, 0.48770514f, 
    -0.23453884f, -0.06689352f, -0.13159238f, 0.16096568f, 0.16336501f, 0.22292386f, -0.10869621f, -0.09545238f, 
    0.13703321f, -0.32166332f, -0.17573564f, 1.01867521f, 1.02479327f, -0.74024141f, -0.83883846f, -0.29594380f, 
    0.36130011f, -0.53376347f, 0.07346456f, 0.23149391f, 0.41864604f, 0.19482425f, 0.23028585f, -0.10775256f, 
    -0.19740717f, -0.48222980f, 0.24646568f, -0.17116009f, 0.05442113f, -0.42551544f, -0.10195890f, -0.32934400f, 
    0.03858781f, -0.09016285f, 0.08023888f, 0.08831156f, -0.30192873f, -0.16023257f, -0.16860345f, 0.25637850f, 
    -0.11167914f, -0.86381376f, -0.43973091f, -0.10102385f, -0.63847041f, -0.25717488f, -0.31640220f, -0.02224122f, 
    -0.36133328f, 0.43378168f, -0.19213514f, -0.04341220f, -0.11176345f, 0.12233637f, 0.45579770f, -0.27001446f, 
    0.00055471f, -0.11738209f, 0.47126085f, 0.56226301f, 0.55639684f, 1.39373446f, 0.16158985f, -0.68920189f, 
    1.46424246f, 0.27483281f, -0.24286416f, -0.00812290f, 0.26830789f, -0.02632329f, 0.08707987f, 0.07072326f, 
    -0.77546483f, 0.18538167f, -0.24246444f, 0.19363642f, 0.25034112f, 0.15536405f, 0.23819439f, -0.11808206f, 
    0.74052447f, -0.21071772f, 0.18394452f, 0.18494457f, -0.34499794f, -0.03417742f, 0.99638182f, 0.65818506f, 
    0.81431407f, 1.20226085f, 0.54568321f, 0.66244519f, -0.30166152f, -0.98930597f, 0.35575747f, -0.02406171f, 
    -0.25363344f, -0.06879874f, -0.21277517f, -0.00372596f, -0.20050700f, 0.06383055f, 0.39968327f, 0.35868707f, 
    -0.45885444f, 0.02164675f, -0.03872138f, 0.05571073f, 0.14297539f, 0.13975176f, 0.45625877f, -0.96762508f, 
    0.77830487f, 0.01674245f, -0.80369222f, 0.44038340f, -0.71925646f, 0.34032145f, 0.38397834f, -0.52709496f, 
    -0.37018499f, -0.33090150f, -0.30051044f, 0.13364281f, -0.70099217f, -0.36023542f, 0.49929100f, -0.15259376f, 
    0.21266800f, -0.30269411f, -0.51268548f, -0.20992777f, 0.06880020f, -0.09624451f, -0.04496516f, 0.30984297f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10598692f, 0.30236694f, -0.00192218f, 0.27866736f, 0.49146283f, 0.27177075f, 0.04966620f, 0.07426658f, 
    0.26773310f, 0.08976773f, -0.00786478f, 0.23128738f, 0.29143688f, 0.28080928f, 0.12653361f, 0.57900381f, 
    0.09882978f, 0.09677839f, 0.25515404f, 0.41116694f, 0.24770239f, 0.10639268f, 0.03731531f, 0.15300500f, 
    0.22989243f, 0.07989592f, 0.09376650f, 0.04108139f, 0.36887363f, 0.17974529f, 0.16179825f, 0.16626315f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.22380759f, 0.09968531f, -0.03069535f, -0.05485373f, 0.22817531f, 0.24996199f, -0.12936844f, 0.12561885f, 
    0.28195843f, 0.10519592f, -0.15888518f, -0.14057356f, 0.20479073f, -0.03855161f, 0.17762218f, -0.14656298f, 
    -0.17956524f, -0.07353321f, -0.04540812f, 0.07437689f, 0.11224979f, -0.01220593f, 0.04440496f, -0.10596842f, 
    0.29860789f, 0.03458980f, 0.11515693f, 0.25434166f, -0.21271221f, 0.12500320f, -0.05499117f, 0.17893174f, 
    -0.12349101f, 0.12475035f, 0.06011561f, -0.08660305f, 0.24856012f, -0.08947960f, 0.21153690f, -0.03871259f, 
    -0.01165542f, -0.03275536f, 0.18447249f, -0.06338143f, 0.06012424f, 0.13034159f, 0.08443649f, -0.12823790f, 
    -0.36605111f, -0.34802476f, 0.09239039f, -0.00475935f, -0.10874466f, -0.09567501f, 0.15108804f, 0.07597823f, 
    -0.00864331f, -0.07720325f, -0.04713794f, -0.02676007f, 0.28857306f, -0.16672482f, -0.09158952f, -0.33077827f, 
    0.06119756f, -0.08828752f, 0.14166196f, -0.02575081f, 0.08373718f, 0.01083518f, 0.00050915f, 0.27329746f, 
    -0.02915772f, 0.32986146f, 0.11524684f, -0.50673825f, -0.19827381f, 0.03388414f, -0.04474873f, 0.21878549f, 
    -0.23352219f, -0.08629905f, -0.14365293f, 0.00361452f, 0.06741063f, -0.24322508f, -0.26960209f, -0.06019771f, 
    -0.13962299f, 0.13573386f, 0.00209702f, -0.20503440f, -0.09275142f, 0.07416055f, -0.07524148f, 0.04617399f, 
    0.17138356f, -0.17855798f, -0.09320393f, 0.19068046f, 0.10307030f, -0.07391217f, 0.00878792f, 0.02262674f, 
    0.12161008f, -0.11146663f, 0.01835676f, -0.13210224f, 0.40120658f, -0.26996562f, -0.03779259f, -0.61560261f, 
    -0.03590205f, 0.02651096f, -0.00513338f, 0.08233063f, -0.13871095f, -0.10439117f, -0.11686361f, 0.14074899f, 
    0.35924765f, -0.18812428f, 0.20107783f, -0.17809136f, 0.08966096f, 0.05307678f, 0.08833802f, 0.15065911f, 
    -0.12552823f, 0.05553820f, 0.02833259f, -0.15442011f, 0.14606994f, 0.15332775f, 0.21595307f, -0.37185395f, 
    -0.16489692f, -0.13192743f, -0.02405927f, -0.11017755f, -0.01216849f, 0.03104973f, -0.09992044f, -0.16335493f, 
    0.10203305f, 0.33398467f, 0.30695587f, -0.43688485f, 0.08942565f, 0.03857370f, -0.08006833f, 0.12307794f, 
    0.13778606f, 0.02701208f, -0.05693806f, 0.17263480f, -0.37824172f, 0.29193559f, -0.00128556f, -0.37017128f, 
    -0.01285026f, 0.03652933f, -0.08567588f, -0.06666178f, -0.05184509f, 0.07113548f, 0.08499639f, 0.03539344f, 
    -0.42217678f, 0.15190414f, 0.03167009f, 0.10637128f, 0.03065338f, 0.08080869f, 0.03773568f, -0.18937211f, 
    0.06473229f, -0.17279877f, -0.16484347f, 0.01163735f, -0.34676516f, -0.27662027f, 0.16423963f, -0.10500319f, 
    0.03895688f, 0.08630250f, -0.03071619f, -0.09560383f, -0.16355328f, 0.13598289f, -0.09157459f, -0.12819064f, 
    -0.45705661f, 0.10066272f, 0.00570681f, -0.02005536f, -0.13247204f, 0.08382730f, 0.03708327f, -0.14515385f, 
    0.06118429f, -0.05696577f, 0.10672373f, -0.01847631f, 0.05756430f, 0.13775751f, 0.26478186f, 0.16772605f, 
    0.13994548f, 0.11158921f, -0.07993189f, -0.07448585f, 0.09538454f, -0.19377068f, 0.06844795f, 0.17710473f, 
    -0.42552510f, 0.04568448f, -0.13464601f, 0.18665005f, 0.10894187f, 0.20443192f, -0.01957010f, 0.03500839f, 
    0.03170837f, -0.02952205f, 0.00260884f, -0.15386309f, 0.13935448f, -0.08642969f, -0.35090986f, 0.22066098f, 
    -0.13047402f, -0.24018760f, -0.05405623f, -0.24652211f, -0.13035229f, -0.03747076f, -0.06228930f, 0.00730140f, 
    0.20458899f, -0.12595351f, -0.06296339f, 0.16512524f, -0.12773328f, -0.12329671f, 0.01468610f, 0.09609448f, 
    -0.01851660f, -0.09191375f, 0.02688017f, 0.16446121f, -0.33458212f, -0.53666198f, 0.10310534f, -0.15166843f, 
    0.10467993f, -0.03282526f, 0.10751875f, -0.04438889f, -0.02794236f, -0.07972516f, 0.01786852f, 0.07020228f, 
    0.02077476f, 0.16896376f, -0.42808425f, -0.21957973f, 0.03272476f, 0.02689012f, 0.22891861f, 0.07107739f, 
    0.05708488f, -0.11976127f, 0.00783116f, -0.05742556f, 0.20019171f, -0.40288436f, -0.34270278f, 0.47529775f, 
    -0.03947239f, -0.00114660f, 0.03953976f, -0.12310294f, -0.04721311f, -0.03650416f, -0.12394703f, 0.17480557f, 
    -0.27531889f, 0.43705112f, 0.13058965f, 0.24366862f, -0.01341239f, 0.11270831f, 0.06848954f, -0.18444550f, 
    -0.04152775f, -0.00290651f, 0.03058705f, -0.04375491f, 0.07159438f, 0.22714213f, -0.23915514f, 0.45399526f, 
    -0.14960960f, 0.22673486f, -0.09589077f, -0.14858410f, -0.09638514f, -0.07630239f, 0.09776646f, -0.11611442f, 
    -0.02129281f, -0.00503070f, -0.16787440f, 0.02234284f, -0.28879958f, -0.03361043f, 0.08909264f, 0.06773195f, 
    0.01485466f, -0.04343370f, -0.04536182f, -0.07179903f, 0.02872538f, -0.16044006f, 0.18324660f, -0.35289264f, 
    -0.24541661f, 0.02405648f, 0.01635931f, 0.13902065f, 0.05467619f, -0.06823483f, -0.07317239f, -0.09505574f, 
    -0.07786790f, -0.06494991f, 0.06090228f, 0.34006813f, 0.09044202f, 0.00117186f, -0.03273661f, 0.04975320f, 
    -0.17406212f, 0.03923583f, -0.04180933f, -0.06510706f, 0.30742553f, -0.13031581f, -0.21324052f, 0.39183840f, 
    -0.19948740f, 0.15960503f, -0.21792611f, 0.06030386f, -0.18079624f, -0.05173252f, -0.04385887f, -0.20258337f, 
    0.09349620f, -0.15235712f, -0.00973758f, 0.44696555f, -0.14840607f, -0.20095293f, 0.06026609f, 0.05385562f, 
    -0.04137526f, 0.09854763f, -0.17521954f, 0.09537721f, -0.23652343f, 0.02674359f, 0.16527770f, -0.08147551f, 
    -0.15032153f, -0.27962223f, -0.07057244f, -0.04829870f, -0.02719924f, -0.00443036f, 0.08151445f, -0.08163917f, 
    -0.49126360f, 0.13845503f, -0.03730505f, -0.10412927f, -0.13228057f, -0.01053413f, 0.05037460f, 0.15154816f, 
    0.11564784f, 0.16276230f, -0.00717268f, -0.03319068f, 0.12339322f, 0.03814622f, 0.18295227f, 0.25508946f, 
    -0.06247665f, -0.05633968f, 0.01278236f, 0.07878815f, -0.21453665f, 0.00750339f, -0.04278808f, 0.06757008f, 
    0.13441904f, -0.01462817f, 0.09670160f, 0.32328531f, -0.13993964f, 0.05703441f, -0.06291535f, 0.08852012f, 
    -0.00023832f, 0.07855897f, -0.25630438f, 0.12898821f, -0.11298554f, -0.03140137f, -0.24701867f, -0.39663231f, 
    0.04468319f, -0.09332722f, -0.29089126f, 0.01996453f, 0.04376201f, -0.02520360f, -0.18581970f, 0.09407403f, 
    0.04771130f, -0.25679344f, -0.04568847f, -0.31360057f, 0.02702573f, 0.00204520f, 0.10827791f, 0.09737627f, 
    -0.21364485f, 0.19927311f, 0.02473990f, 0.02563718f, -0.17182267f, -0.49209324f, 0.15811932f, -0.50705755f, 
    -0.04903109f, -0.16107117f, -0.00547936f, 0.09754419f, -0.06820431f, -0.04435068f, -0.06179645f, -0.20030308f, 
    0.26516223f, 0.17839707f, 0.07301307f, -0.10861824f, -0.16275749f, -0.00054978f, 0.02569646f, -0.07761414f, 
    0.04223337f, 0.16542949f, 0.00224753f, 0.03087426f, 0.15172058f, -0.37523666f, 0.04100901f, 0.08042814f, 
    -0.08067587f, 0.18719037f, -0.03778728f, 0.13254926f, -0.05765260f, -0.02968336f, -0.21164621f, -0.01243467f, 
    0.12809019f, 0.08250259f, 0.06452844f, 0.02289050f, -0.23081367f, 0.14048274f, -0.00490314f, -0.03583109f, 
    0.08814564f, 0.10956057f, 0.01903414f, 0.08089726f, 0.13547131f, -0.11242160f, 0.34641048f, -0.26029104f, 
    0.14404073f, 0.28460675f, 0.13117261f, 0.19772188f, -0.01278074f, 0.02931224f, 0.13331008f, 0.04011559f, 
    -0.05259027f, 0.10195444f, -0.17283730f, -0.13287865f, -0.18882240f, -0.23737037f, 0.07386166f, -0.04135771f, 
    -0.20409653f, -0.22339757f, 0.09288399f, -0.37330541f, -0.12842706f, -0.01431501f, 0.02745125f, 0.03493858f, 
    0.13790499f, -0.11047642f, 0.16063251f, 0.03825185f, -0.08771603f, -0.01760763f, -0.08673281f, 0.13377751f, 
    0.02822314f, -0.12468258f, -0.36693966f, 0.08100443f, -0.07195035f, -0.05633238f, -0.02426211f, -0.06853551f, 
    0.05249531f, 0.08074459f, -0.04290620f, -0.12995934f, 0.48934919f, -0.15119080f, 0.00541195f, -0.36558065f, 
    0.02443237f, -0.14031896f, 0.09762236f, 0.19923964f, -0.03654379f, -0.07332647f, -0.07909874f, 0.07999767f, 
    -0.02805908f, -0.23115805f, -0.38968658f, -0.35447156f, -0.08320399f, 0.01558589f, 0.02816814f, -0.02893748f, 
    -0.20232937f, -0.02456469f, 0.02454909f, -0.23222129f, 0.33466998f, -0.12623286f, 0.04130101f, -0.31111193f, 
    -0.05096064f, -0.08268544f, 0.08330373f, -0.08666130f, -0.04448662f, 0.12289441f, 0.01349343f, 0.02548221f, 
    -0.20819291f, 0.13228948f, -0.11851285f, -0.24263386f, 0.03822152f, 0.04487470f, -0.08284980f, 0.04336147f, 
    0.00169899f, -0.11729040f, -0.12881179f, -0.21362315f, 0.13169926f, -0.46597731f, -0.22761689f, -0.19448528f, 
    0.07368246f, -0.00226539f, -0.08029864f, 0.23235023f, -0.11952484f, 0.27299258f, 0.02297056f, 0.00737267f, 
    -0.13398805f, 0.27596223f, -0.34517395f, 0.25597480f, -0.07364050f, -0.11943945f, 0.00937558f, -0.13225451f, 
    -0.01778212f, 0.03003423f, -0.12290929f, 0.06096904f, -0.28806585f, -0.22978982f, 0.03800301f, 0.01157729f, 
    0.05076265f, 0.09106793f, -0.04678919f, 0.11534933f, 0.15221263f, 0.00101942f, 0.21460693f, -0.07150542f, 
    0.23892727f, 0.09333182f, 0.11115869f, 0.18446714f, -0.02434991f, 0.05638299f, 0.03911471f, -0.06564793f, 
    0.07983835f, 0.11622324f, -0.00922567f, -0.36440998f, -0.01535872f, 0.20935792f, 0.10309570f, 0.13829030f, 
    0.00314004f, 0.04387592f, -0.10482106f, 0.01821053f, -0.07319447f, 0.01662754f, 0.09514433f, 0.15056802f, 
    0.23998888f, -0.12335337f, -0.17684339f, -0.01688417f, -0.10434454f, -0.01650625f, -0.05518237f, -0.00431333f, 
    -0.03595813f, 0.08280057f, 0.03502342f, 0.16529058f, 0.14691466f, -0.02257433f, 0.04373315f, 0.20047545f, 
    -0.17224421f, 0.10734125f, -0.06764198f, -0.13648377f, 0.01150982f, -0.19629949f, -0.04639092f, 0.00408273f, 
    0.42399368f, -0.31335270f, -0.09208419f, -0.03080081f, 0.16009960f, 0.12120900f, -0.11166256f, 0.11936041f, 
    -0.03755026f, 0.29216221f, -0.02376642f, -0.06894218f, -0.27172628f, 0.00564870f, -0.19855255f, 0.13688803f, 
    -0.16562153f, -0.36161649f, -0.08593293f, 0.14240633f, 0.17280476f, 0.10606282f, -0.09442448f, 0.13835754f, 
    0.29831806f, 0.06521574f, 0.24444011f, 0.19905360f, -0.06598769f, 0.00211713f, 0.02733519f, -0.18883249f, 
    -0.00399476f, -0.03339228f, 0.04958750f, 0.07247172f, 0.22698298f, -0.11211035f, 0.01020939f, -0.37834707f, 
    -0.03161345f, -0.12256183f, 0.00784625f, -0.08076728f, 0.02731981f, -0.01357646f, 0.04800281f, 0.13286337f, 
    -0.23802128f, -0.04396199f, -0.28691468f, -0.10847984f, -0.09393807f, 0.05007577f, -0.03775886f, 0.04075214f, 
    0.08169334f, 0.06153082f, 0.01067025f, 0.10921057f, 0.19686595f, -0.14712991f, 0.19165389f, 0.18671651f, 
    -0.12099633f, -0.14111225f, -0.02658887f, 0.02974919f, 0.04576127f, 0.09721772f, 0.07032669f, 0.18777139f, 
    0.28950781f, -0.06359985f, 0.05665235f, 0.03860336f, -0.13811077f, 0.09277225f, 0.06366061f, 0.02148114f, 
    -0.02840005f, -0.07801396f, 0.17983294f, -0.19920439f, 0.02143790f, 0.07687985f, -0.29477054f, -0.84109545f, 
    0.01571229f, 0.32492328f, -0.09998786f, 0.02599186f, 0.07131436f, -0.17564838f, -0.10140729f, 0.03914429f, 
    -0.28548998f, 0.02288904f, -0.28171679f, -0.32915148f, -0.03483053f, -0.07244637f, -0.19561169f, 0.15125385f, 
    -0.04258098f, -0.07780734f, 0.05313044f, -0.08787867f, -0.13125618f, 0.18132266f, -0.15263917f, 0.09500650f, 
    0.05327406f, 0.09086954f, 0.10117851f, -0.10178265f, 0.07334968f, -0.04717783f, 0.18486592f, -0.04299812f, 
    0.25020298f, -0.18264639f, -0.02953879f, -0.43881321f, 0.25941801f, -0.18345681f, 0.14728020f, 0.05477109f, 
    0.05696948f, 0.04536362f, 0.07161082f, 0.00358624f, -0.02274201f, -0.20691314f, -0.04378285f, 0.10998795f, 
    -0.10118359f, 0.04209358f, 0.12743507f, -0.09657680f, -0.17416897f, -0.07752284f, -0.06626441f, -0.07697946f, 
    -0.66331768f, 0.14328972f, -0.07994960f, -0.10592741f, -0.05907404f, -0.03803338f, -0.02618475f, -0.11882612f, 
    -0.04942115f, -0.00511989f, -0.07140672f, -0.03797162f, 0.05094179f, 0.08151644f, -0.13655411f, 0.19641669f, 
    -0.02520410f, -0.01727552f, 0.06963942f, -0.06040310f, -0.08699901f, -0.13865750f, 0.01883819f, -0.02451622f, 
    -0.39856088f, -0.05210521f, -0.02100672f, -0.34535778f, 0.05093125f, 0.05724316f, 0.17569631f, -0.02858399f, 
    -0.09266371f, -0.05050409f, -0.03084021f, -0.02461178f, -0.16575599f, 0.19973591f, 0.15694471f, -0.00709661f, 
    -0.14554340f, -0.09418612f, 0.09983139f, -0.02612197f, 0.04669194f, -0.18532914f, 0.08908314f, 0.00863414f, 
    0.02208247f, -0.14731695f, 0.14029688f, 0.03782390f, 0.10085337f, 0.08332695f, -0.01915924f, 0.01945596f, 
    -0.11384571f, -0.12037229f, -0.02399195f, -0.10331444f, -0.41611516f, 0.30878460f, 0.26331103f, 0.05119349f, 
    0.01307122f, -0.20239466f, 0.14236745f, -0.05654832f, -0.14961746f, -0.08797836f, -0.11535566f, 0.05766722f, 
    -0.37976506f, 0.10927507f, 0.00906025f, 0.11946189f, 0.30861825f, 0.19201884f, 0.01653944f, -0.17719887f, 
    -0.06930954f, 0.16450322f, -0.09707011f, 0.00214116f, -0.38338664f, 0.14987564f, -0.21167158f, -0.11325920f, 
    0.05612703f, 0.10410216f, 0.04907589f, -0.19889925f, 0.03574247f, 0.08853077f, 0.08110210f, -0.00187752f, 
    0.57382464f, 0.11770818f, 0.22904840f, 0.30500433f, -0.29460779f, -0.25373253f, 0.01179333f, 0.13344450f, 
    0.15323570f, -0.01222748f, -0.01610800f, -0.04053205f, 0.10274392f, -0.09288624f, -0.01958864f, -0.04399434f, 
    -0.01187550f, 0.00472322f, 0.11550114f, 0.03015350f, 0.02830275f, -0.04235506f, 0.08279061f, -0.00223312f, 
    0.22233818f, 0.02022929f, -0.28195426f, -0.18293138f, 0.07086583f, 0.04162225f, 0.15680589f, -0.11108348f, 
    -0.17475799f, 0.12705432f, -0.02556523f, -0.07625569f, 0.09313582f, -0.35831556f, -0.00538091f, -0.15742408f, 
    -0.24530914f, 0.03530189f, -0.10335859f, -0.00983202f, 0.04952268f, -0.11540340f, -0.07721493f, -0.03188878f, 
    0.41199556f, 0.08764066f, -0.25275588f, -0.11427405f, 0.10743582f, 0.15000452f, -0.14657259f, -0.08420973f, 
    -0.11754552f, -0.17732836f, 0.23408580f, 0.06087373f, -0.20955251f, -0.39403078f, 0.19150621f, 0.05837015f, 
    -0.22825512f, 0.21096601f, 0.09106796f, 0.01122826f, 0.00741136f, -0.23277943f, -0.00772721f, -0.13699684f, 
    0.25847739f, -0.17193997f, -0.27161109f, -0.20695913f, -0.23339915f, 0.02888216f, -0.10392212f, -0.00329995f, 
    0.15282215f, -0.26049143f, -0.06530558f, -0.19508488f, 0.57996869f, 0.07079029f, -0.37590101f, -0.01663742f, 
    0.03790229f, 0.18745959f, -0.06459595f, 0.00908320f, -0.08128094f, 0.00629791f, -0.09696444f, -0.07177919f, 
    -0.18128440f, 0.17113890f, -0.05744516f, 0.00042509f, 0.11393546f, -0.03481569f, 0.09526640f, 0.05981844f, 
    -0.04029373f, -0.03746973f, 0.06780828f, -0.04965058f, -0.67763197f, -0.19032736f, 0.24422835f, -0.58836550f, 
    -0.18273987f, -0.03844637f, -0.17695726f, -0.12420413f, 0.06217201f, 0.01382766f, 0.11460718f, -0.20897071f, 
    0.48063618f, -0.08016069f, 0.32729033f, 0.26509243f, -0.27155116f, 0.06174304f, 0.07536445f, 0.28984761f, 
    0.00473857f, -0.02190377f, -0.02361246f, -0.17698550f, 0.07358988f, 0.24426417f, -0.08807006f, 0.07809851f, 
    0.06062917f, 0.01886101f, 0.00185580f, 0.05303008f, 0.17479537f, 0.24109907f, 0.08303759f, -0.16327572f, 
    0.13664654f, -0.28499523f, 0.13647573f, 0.15472637f, -0.02885749f, 0.06036230f, 0.01351686f, 0.00194059f, 
    0.08316102f, 0.03501603f, -0.02777565f, 0.06169111f, -0.61359531f, 0.06215087f, -0.26727182f, -0.21191370f, 
    -0.01950453f, 0.09070355f, 0.04112254f, 0.06541315f, -0.02435118f, -0.09424565f, 0.08311991f, 0.11508302f, 
    0.18490981f, 0.05566811f, -0.03774660f, 0.24649017f, 0.21307792f, 0.09440213f, -0.10723373f, -0.15053411f, 
    0.09764544f, 0.08025577f, -0.12497362f, 0.05636427f, 0.15602858f, -0.25463977f, 0.01105229f, -0.07691353f, 
    -0.01463221f, -0.20827715f, 0.20140882f, -0.01748789f, -0.11125156f, 0.02227577f, 0.11549188f, -0.08088849f, 
    0.03474690f, -0.24687734f, -0.39775598f, -0.32464045f, -0.06349795f, -0.02614030f, -0.30286106f, 0.02029245f, 
    -0.17612262f, 0.01709855f, 0.00803272f, 0.03893625f, 0.12257964f, -0.06107329f, -0.14428334f, 0.05119352f, 
    0.05217741f, -0.06906024f, -0.07882614f, 0.09114742f, -0.04936669f, -0.06440683f, 0.02210096f, -0.05752723f, 
    0.13084805f, -0.19552843f, -0.01493325f, 0.00046398f, 0.18775693f, 0.04988069f, 0.03142879f, -0.05022553f, 
    0.04034197f, 0.05105539f, -0.01583012f, -0.01197141f, 0.37443143f, -0.14225538f, -0.38401383f, -0.08670644f, 
    0.19360256f, 0.04423564f, 0.08897175f, 0.00934602f, -0.02337693f, 0.11931410f, -0.10172013f, 0.07947332f, 
    0.39100638f, -0.00819939f, 0.07162175f, -0.25661367f, 0.15507308f, -0.16715963f, -0.04885379f, -0.00827768f, 
    0.04812146f, -0.07217445f, -0.09292825f, -0.01713125f, -0.56540084f, -0.56211907f, -0.45577955f, 0.35468307f, 
    -0.11126927f, 0.06254282f, -0.01868555f, -0.01878050f, -0.12511815f, -0.11611014f, 0.10360820f, -0.04915047f, 
    -0.18939726f, -0.65105593f, -0.13099451f, -0.16812977f, -0.03043723f, -0.05593637f, -0.08071228f, -0.05458663f, 
    -0.00468021f, 0.03225261f, 0.01730492f, 0.00967801f, 0.07602180f, 0.21408753f, 0.03294649f, 0.19862473f, 
    -0.01567414f, 0.13802059f, 0.08141296f, -0.06206809f, 0.05941863f, -0.12422051f, -0.05022158f, -0.15253671f, 
    0.28597686f, -0.00429347f, -0.04394222f, 0.10501318f, -0.11260869f, -0.06790469f, -0.02491625f, 0.04347389f, 
    0.11978161f, 0.12152959f, -0.08927147f, 0.03780492f, -0.03171745f, -0.03019973f, 0.05438845f, 0.03619057f, 
    -0.04947684f, 0.05254417f, 0.02295848f, -0.01069892f, -0.09332395f, 0.07706369f, -0.11465228f, -0.05657899f, 
    -0.10360304f, -0.37326804f, 0.11361298f, -0.00630830f, -0.09471621f, -0.12377209f, -0.07141568f, 0.20414093f, 
    -0.14803459f, -0.01907477f, 0.00340457f, -0.17744891f, 0.16919824f, 0.05832107f, -0.18090732f, 0.02064870f, 
    -0.03174716f, 0.15872331f, 0.12753683f, -0.05768331f, 0.01168088f, 0.03548770f, 0.07881889f, 0.00080687f, 
    -0.57271034f, -0.22933111f, -0.23882087f, 0.00139286f, 0.03866912f, -0.16092433f, 0.05250281f, 0.08130618f, 
    -0.00996027f, 0.02398054f, -0.10919919f, -0.12763438f, -0.09399034f, -0.14745489f, -0.00327178f, 0.21715318f, 
    -0.07719351f, -0.02961850f, 0.04211295f, -0.00469600f, -0.11177778f, 0.03757172f, -0.02961562f, 0.05770243f, 
    0.10702986f, 0.20467767f, -0.02053922f, 0.16033532f, -0.00449753f, -0.01816110f, -0.14028116f, 0.14581294f, 
    0.16881497f, 0.02051737f, -0.04218642f, 0.13136515f, 0.00483332f, -0.18980366f, -0.12980127f, -0.02664461f, 
    0.04879462f, -0.02745727f, -0.12813054f, -0.06647705f, -0.02104941f, 0.01134575f, -0.00678405f, -0.08090302f, 
    0.22843169f, -0.17312618f, 0.21938148f, -0.19259645f, -0.06493625f, -0.20087656f, 0.04524261f, -0.05515391f, 
    -0.18681058f, -0.10909776f, -0.01081291f, 0.05381845f, 0.07808337f, -0.36238763f, 0.27457839f, -0.07210906f, 
    -0.06515143f, 0.15299119f, -0.02822603f, -0.00509489f, 0.05527600f, 0.04695166f, -0.01085266f, 0.15762298f, 
    0.19055368f, 0.38732451f, 0.01211736f, 0.14507636f, 0.08314922f, 0.05435199f, 0.08153104f, 0.19994548f, 
    -0.05492774f, 0.19659340f, -0.03025922f, 0.07856934f, 0.17550173f, 0.19315514f, 0.03773344f, 0.17186356f, 
    -0.13045610f, 0.13658717f, -0.00990880f, -0.01661584f, 0.01475038f, 0.05554339f, 0.13437761f, -0.09742479f, 
    -0.37991378f, 0.40898517f, 0.40838268f, 0.01096637f, -0.02535435f, 0.03313583f, 0.00400917f, -0.20422384f, 
    -0.08372608f, 0.11482643f, 0.04171918f, 0.09475543f, 0.22838894f, -0.03020511f, -0.24138132f, -0.03809614f, 
    0.09978056f, -0.07358133f, 0.07660653f, -0.17695640f, -0.07171162f, 0.08678683f, 0.02638962f, -0.05305797f, 
    0.35038123f, -0.06746678f, 0.20525755f, -0.04369532f, 0.00373197f, -0.07422598f, -0.03658506f, 0.05098312f, 
    -0.05322273f, -0.04174486f, -0.07288547f, -0.01740766f, -0.67949879f, 0.23134917f, 0.32236409f, 0.37336263f, 
    0.13696767f, 0.06150497f, 0.07265746f, -0.11819839f, -0.19501267f, -0.03718282f, -0.18172503f, -0.10347229f, 
    -0.57517707f, -0.31682816f, -0.19594106f, -0.17359106f, -0.14928900f, -0.10993050f, 0.06783625f, 0.03168483f, 
    -0.06152080f, 0.10044380f, 0.17754281f, -0.01672829f, 0.12964761f, 0.08111528f, -0.04068282f, -0.15686406f, 
    -0.01159546f, 0.02524234f, -0.08469294f, 0.00305795f, -0.00845701f, -0.09187000f, 0.02935085f, 0.00359571f, 
    0.12671964f, -0.18682882f, -0.01439191f, -0.33798486f, -0.09747348f, 0.10936779f, -0.13694850f, -0.00943800f, 
    0.00077652f, 0.00799899f, 0.06549478f, -0.08976967f, 0.00399528f, -0.16265438f, 0.04144580f, -0.08120123f, 
    -0.19072577f, 0.13477033f, 0.00150329f, 0.01828410f, 0.04680219f, 0.14984237f, 0.00024981f, -0.02604383f, 
    0.13052565f, 0.07111483f, -0.30481929f, -0.09108710f, 0.03889743f, -0.12307462f, 0.10176871f, -0.07531011f, 
    -0.10917448f, 0.04933200f, -0.01881393f, -0.01584236f, -0.11591110f, -0.33948520f, 0.00071843f, -0.07052738f, 
    -0.05062639f, 0.13475573f, 0.10809805f, 0.19757143f, -0.02606977f, -0.12489352f, 0.15801190f, 0.03860237f, 
    -0.02304436f, -0.64617562f, 0.27986270f, 0.27552384f, -0.07462642f, 0.04488642f, 0.02539966f, -0.02555884f, 
    0.01279151f, -0.10732169f, -0.05018982f, -0.00613705f, -0.12205818f, 0.06717777f, 0.07559799f, 0.14226495f, 
    -0.20056699f, 0.04352352f, -0.11992958f, 0.10488847f, 0.02263237f, 0.06415834f, -0.12183896f, -0.04636027f, 
    0.14022245f, 0.17657004f, 0.33868486f, 0.03991305f, 0.13085715f, -0.11352298f, 0.09191374f, -0.01954639f, 
    -0.01278388f, -0.04605100f, -0.02801425f, 0.09573977f, 0.53947133f, -0.18031968f, -0.01093859f, -0.18746044f, 
    -0.06155883f, 0.10727524f, 0.22110289f, -0.10529459f, -0.04818538f, -0.14320917f, 0.13906190f, 0.00370137f, 
    0.12956814f, -0.53881580f, -0.45479903f, 0.24000098f, -0.07611404f, -0.07949107f, -0.10559046f, -0.04849919f, 
    -0.02083862f, -0.13222563f, -0.17108455f, 0.17749935f, -0.26637810f, 0.07940451f, 0.23365769f, 0.11055043f, 
    0.15460174f, -0.21220897f, -0.04078872f, 0.06678089f, 0.00619175f, 0.18286787f, 0.03122931f, -0.01553643f, 
    0.23476367f, -0.14647616f, 0.01126366f, -0.28777081f, -0.06267820f, -0.00062804f, 0.01761259f, 0.05140248f, 
    -0.29500300f, -0.13089769f, 0.02910209f, 0.04064843f, -0.09017347f, -0.16720603f, 0.03989441f, -0.00199152f, 
    -0.08754200f, 0.00550702f, -0.02448680f, -0.15863915f, 0.10010776f, -0.02489407f, -0.14857957f, -0.17798214f, 
    0.78442663f, -0.18363208f, -0.06847219f, 0.02623007f, -0.02571288f, 0.03446051f, 0.05208731f, 0.10818202f, 
    -0.07417522f, -0.05163165f, -0.09980882f, -0.00522529f, 0.14218482f, -0.04389604f, -0.06377225f, 0.19595508f, 
    -0.11927267f, -0.12721467f, 0.08474966f, -0.00719300f, -0.00972900f, 0.03017958f, 0.09066352f, -0.07564857f, 
    0.17357005f, -0.07751673f, -0.28214258f, 0.01643841f, -0.07076343f, 0.03999750f, 0.11095092f, 0.17167547f, 
    0.00629502f, 0.04774237f, 0.13275677f, -0.02726749f, 0.10462622f, -0.33304363f, -0.21674316f, 0.21297143f, 
    -0.10883854f, -0.00440706f, 0.08628508f, -0.00978875f, 0.02431933f, 0.01309889f, -0.02752155f, 0.03448205f, 
    -0.43202761f, -0.09545565f, 0.18670857f, -0.18398277f, 0.04695655f, -0.12376111f, -0.02840867f, -0.08918110f, 
    0.09553110f, -0.06442889f, 0.05984959f, -0.09704135f, -0.14460061f, 0.40234494f, -0.29108018f, -0.37771931f, 
    -0.06041145f, 0.06431082f, -0.11458734f, -0.16320533f, -0.22890964f, 0.02293732f, 0.07564982f, 0.03149208f, 
    -0.16842349f, 0.19922453f, -0.15910950f, -0.32932845f, -0.10181762f, -0.14083661f, -0.03630789f, 0.05703947f, 
    -0.05591571f, -0.10883906f, -0.05099541f, -0.17611697f, -0.30784264f, -0.09802694f, 0.08800882f, 0.21572781f, 
    0.05984798f, -0.06901406f, -0.01338657f, -0.24117729f, 0.07965650f, 0.03166555f, 0.00409551f, -0.03238396f, 
    -0.15234524f, -0.34548903f, -0.06588198f, 0.23540556f, -0.01991474f, 0.00443364f, -0.00747776f, 0.03436263f, 
    -0.10584936f, 0.02101666f, 0.15040089f, 0.19696820f, 0.17992112f, -0.21401876f, 0.05304850f, 0.29555380f, 
    -0.28420290f, 0.03314515f, -0.12766498f, -0.24701372f, 0.02720443f, 0.09418088f, -0.05561596f, 0.07525764f, 
    -1.14308774f, -0.02136110f, 0.20552360f, 0.22086750f, 0.07205951f, -0.05344577f, -0.04647604f, 0.13574272f, 
    0.02964421f, -0.11900657f, 0.00515296f, 0.09858865f, 0.00642107f, -0.13428910f, -0.04944311f, 0.02395760f, 
    -0.14969362f, -0.19225058f, 0.04873585f, -0.27413845f, 0.03164948f, 0.00339275f, -0.09417436f, -0.02703620f, 
    0.07818092f, -0.11013927f, 0.07141632f, -0.06922128f, 0.04921309f, 0.02180328f, 0.21003513f, 0.10127749f, 
    -0.02012156f, -0.05522587f, 0.02696791f, 0.10042652f, -0.14097123f, 0.08561723f, -0.01034404f, 0.09782272f, 
    0.16218631f, -0.08226930f, 0.04037285f, 0.10460005f, -0.05159247f, 0.03291197f, -0.19803454f, -0.05877144f, 
    0.30621290f, 0.14224252f, -0.08699262f, 0.23036952f, -0.00571872f, 0.02945213f, 0.19183090f, -0.05063529f, 
    -0.09517693f, 0.08143145f, 0.05846272f, -0.01599872f, 0.09613211f, 0.20664938f, -0.19389890f, 0.14388567f, 
    -0.10413766f, 0.16372298f, 0.09880278f, 0.07375820f, 0.11238144f, -0.10302009f, 0.03538309f, -0.06108086f, 
    -0.25315931f, 0.03762627f, -0.07268801f, -0.47382820f, -0.00866401f, -0.08129057f, -0.12413108f, 0.05515084f, 
    0.01332429f, -0.08225931f, 0.05309038f, 0.05378647f, -0.53694701f, -0.26669335f, 0.40454081f, 0.23490675f, 
    -0.01805311f, 0.03857568f, -0.09676162f, -0.21353032f, 0.03925936f, -0.00724489f, -0.10843482f, 0.07750393f, 
    -0.07136443f, -0.13829149f, 0.04934879f, -0.01310552f, -0.00036447f, 0.07507651f, 0.04390846f, 0.09180174f, 
    0.04038830f, 0.07102367f, 0.11597153f, 0.12483563f, 0.02579457f, 0.01118118f, 0.25968805f, 0.17811823f, 
    -0.11642940f, 0.02505170f, 0.11166503f, 0.02736476f, 0.09789782f, 0.01268232f, 0.00983018f, 0.14209357f, 
    -0.50146902f, 0.22276957f, 0.16159120f, 0.40666831f, 0.08313048f, 0.12164449f, -0.01310843f, 0.12265753f, 
    -0.11111616f, 0.05432418f, 0.05183344f, -0.00569519f, -0.14313693f, 0.15862748f, -0.01494137f, -0.00632995f, 
    -0.00974148f, 0.02123259f, 0.07675395f, -0.02568267f, -0.01701406f, 0.06093213f, -0.01773694f, 0.03384959f, 
    -0.38869542f, 0.05109253f, -0.14618170f, 0.05167586f, -0.08487470f, 0.06996596f, 0.15789628f, -0.06416490f, 
    0.11437899f, -0.06332766f, 0.11067426f, 0.19213443f, 0.10492283f, -0.13682924f, 0.17710617f, -0.31193346f, 
    -0.01274913f, 0.15268552f, 0.11234690f, -0.13019150f, -0.04760035f, -0.20844506f, -0.07014965f, 0.12031392f, 
    -0.24782065f, 0.20285557f, -0.16922234f, 0.11759137f, -0.07014598f, 0.10094887f, 0.13349149f, 0.22515196f, 
    -0.02504952f, -0.01695290f, 0.19011898f, -0.00565729f, -0.21625565f, -0.40490469f, -0.28021199f, 0.04084203f, 
    -0.08882726f, -0.09397797f, 0.03256030f, 0.13783640f, -0.22034399f, 0.05366390f, 0.00543233f, 0.00279195f, 
    -0.00412632f, -0.07343350f, -0.05389254f, 0.10032380f, 0.15264471f, -0.03708741f, 0.01837838f, 0.12067185f, 
    -0.08904117f, 0.01297936f, 0.06553712f, 0.03192242f, 0.38018399f, 0.10463877f, -0.15480340f, 0.01813579f, 
    0.16652632f, 0.11873735f, 0.08425793f, -0.04193904f, 0.14467411f, -0.07841145f, 0.06665207f, -0.06907181f, 
    0.13441323f, 0.17925844f, 0.23702295f, -0.05363862f, -0.16548866f, 0.08454110f, 0.01820107f, 0.04985984f, 
    0.01712655f, -0.02593218f, -0.04412948f, 0.13206482f, 0.07038456f, 0.17425255f, 0.12557974f, -0.01675429f, 
    -0.15119484f, -0.16242221f, 0.02615628f, -0.16848075f, -0.07189070f, -0.04141505f, -0.12960795f, 0.03832219f, 
    -0.42636883f, -0.15014963f, 0.09454829f, 0.28049517f, -0.07082331f, -0.08861957f, 0.12707755f, 0.02866535f, 
    0.00053266f, 0.08842240f, -0.04677982f, 0.18012509f, -0.01515585f, 0.00853036f, 0.00690701f, 0.14851624f, 
    0.04017866f, 0.10983369f, -0.09820066f, 0.04147174f, -0.04684702f, 0.17773597f, -0.23867704f, 0.15674849f, 
    -0.14405544f, 0.09622063f, 0.25733247f, -0.47588590f, -0.11827666f, -0.06471178f, -0.07839629f, -0.16228051f, 
    0.11796065f, -0.12325453f, 0.06418373f, -0.07522640f, -0.10236868f, -0.08613453f, -0.00874793f, 0.09466429f, 
    -0.15117212f, -0.01471561f, -0.07590768f, -0.09250496f, -0.14072984f, 0.03447720f, -0.06560337f, 0.24975038f, 
    -0.22668193f, -0.02577806f, 0.25462511f, 0.33257273f, 0.05374600f, -0.01534422f, -0.21633455f, -0.00809532f, 
    0.12594414f, -0.09325961f, 0.01181974f, 0.15448669f, 0.33351880f, 0.14379275f, -0.18456057f, -0.16900347f, 
    0.09849349f, 0.01704480f, -0.10156451f, -0.03547949f, 0.00559651f, 0.20123546f, -0.00794392f, -0.00772563f, 
    -0.02147902f, 0.19295703f, 0.09929718f, 0.22353253f, -0.29673466f, 0.03138530f, 0.10660378f, 0.03794799f, 
    0.09890144f, 0.00645986f, 0.14221597f, 0.05442590f, -0.12916255f, -0.00777461f, -0.01274328f, -0.01966716f, 
    -0.12741387f, -0.23903093f, 0.08324404f, 0.21376002f, 0.16503501f, 0.05943239f, -0.02023964f, -0.05931626f, 
    -0.08632100f, 0.16275534f, 0.24577202f, 0.21618457f, -0.00580273f, 0.09759824f, 0.06795799f, -0.04924677f, 
    0.06737860f, -0.03799894f, 0.01144589f, 0.18862072f, -0.10125373f, -0.25432089f, 0.00253588f, -0.09112412f, 
    -0.02730977f, -0.15573341f, -0.32480907f, -0.14186279f, 0.19060984f, 0.02886878f, 0.12334332f, -0.08613107f, 
    0.12065715f, 0.02545273f, 0.23425673f, -0.10798419f, 0.03689617f, -0.18870838f, 0.00844228f, -0.10842413f, 
    0.11373834f, -0.22908024f, -0.15714501f, -0.23718601f, 0.11787027f, 0.03087572f, 0.06332531f, 0.17819062f, 
    -0.13526961f, -0.15875503f, 0.10426078f, 0.23313090f, 0.09518223f, -0.22722971f, 0.01091480f, 0.02220999f, 
    -0.42701992f, 0.09882417f, -0.46965596f, -0.14413609f, 0.07367542f, 0.09816290f, 0.18860857f, 0.13830671f, 
    -0.00422458f, 0.00040550f, 0.05517698f, -0.04813564f, 0.02874741f, -0.12863204f, -0.03546594f, -0.00793075f, 
    0.08549830f, 0.07648522f, -0.03966225f, -0.01971098f, -0.03930752f, 0.03761019f, 0.06575952f, -0.07429335f, 
    -0.16365296f, -0.13761407f, 0.18124813f, 0.31190383f, 0.04482844f, -0.12898912f, -0.14394528f, 0.04161478f, 
    -0.15588817f, -0.03127750f, 0.01398067f, -0.12976836f, -0.22947453f, -0.18794252f, -0.12925878f, 0.02716083f, 
    0.10785714f, 0.11317434f, 0.15892935f, 0.15870650f, 0.15144470f, 0.04347071f, 0.02030135f, -0.01294598f, 
    -0.04377420f, -0.14761600f, 0.03989665f, 0.01515001f, -0.00719390f, -0.20452766f, -0.03226499f, 0.21064664f, 
    0.03223129f, 0.08262396f, -0.27091634f, 0.04364873f, -0.14264019f, 0.21408927f, 0.03276781f, -0.25730965f, 
    -0.05287036f, -0.20436972f, -0.14321186f, -0.10649902f, -0.04605899f, 0.18858080f, 0.00174765f, 0.06140077f, 
    -0.49697965f, -0.25062230f, 0.15322503f, -0.06092646f, 0.08799344f, 0.14134113f, 0.21599184f, 0.04288408f, 
    0.01328769f, 0.15610488f, -0.00787341f, 0.11855941f, 0.24965408f, 0.13046183f, 0.11612109f, -0.19581027f, 
    -0.09652060f, -0.12788565f, 0.06165286f, 0.08168525f, -0.09813521f, 0.02944252f, 0.16472563f, 0.16815850f, 
    0.19967301f, 0.18626018f, 0.24579997f, 0.07172044f, 0.08083177f, -0.18003425f, -0.00753741f, -0.30872044f, 
    -0.19796756f, -0.03231452f, -0.12636140f, -0.14866377f, -0.13671039f, -0.08737870f, -0.31597242f, 0.19908355f, 
    0.19664794f, -0.18915376f, 0.10755248f, 0.02976357f, 0.09328741f, 0.17937316f, 0.04430323f, -0.00303458f, 
    -0.42152044f, -0.14314590f, -0.42258811f, 0.04021779f, 0.19026881f, -0.13386221f, -0.04684542f, -0.41154933f, 
    0.11715872f, -0.16464537f, -0.14395836f, 0.02802447f, -0.12736759f, -0.00624154f, -0.02110842f, -0.35578716f, 
    -0.12506735f, -0.02328338f, -0.32509971f, 0.16649605f, -0.09833320f, -0.05302945f, 0.21670809f, -0.51480693f, 
    -0.26072299f, 0.48549932f, 0.03317299f, -0.46195218f, -0.06635693f, -0.07762659f, -0.06979988f, -0.14510024f, 
    -0.00113376f, -0.20000507f, -0.16491424f, -0.14129677f, 0.07121212f, -0.03645563f, -0.04382655f, 0.02014066f, 
    -0.09287598f, -0.07993034f, -0.13357010f, 0.16461261f, 0.06780432f, 0.31408894f, 0.12465736f, -0.18155649f, 
    -0.15438339f, -0.03902005f, 0.18570314f, 0.06499038f, 0.11115730f, 0.15040302f, 0.09861322f, 0.00319398f, 
    -0.07109848f, 0.16817237f, -0.01055855f, 0.12441183f, 0.06548462f, 0.12068855f, -0.04605596f, -0.09410306f, 
    0.11999509f, -0.00901442f, -0.00923300f, -0.18427844f, -0.07723784f, -0.19190691f, -0.06376561f, -0.05596801f, 
    0.13752094f, 0.19875057f, -0.09507850f, 0.16092917f, -0.07431388f, -0.07913104f, 0.03991539f, 0.01495148f, 
    0.10428763f, -0.17859566f, 0.09062017f, -0.09410310f, -0.12663563f, 0.21154687f, 0.03346131f, -0.35411674f, 
    0.03322941f, -0.17327087f, -0.08947337f, -0.10518263f, -0.09202370f, 0.10489015f, 0.05432546f, 0.18678145f, 
    0.01625350f, -0.13579668f, -0.04209105f, 0.07139393f, 0.01237978f, -0.07607584f, 0.05834920f, 0.01815107f, 
    0.02436859f, 0.06514096f, 0.00420976f, 0.11034679f, -0.08869033f, -0.15278131f, 0.06192730f, 0.32256198f, 
    0.11005919f, 0.20287348f, 0.14466043f, -0.10709193f, 0.09104037f, -0.00272308f, -0.02224135f, -0.03205922f, 
    -0.02743882f, -0.25645578f, -0.16474982f, 0.16145237f, 0.00048789f, -0.05472545f, -0.09436861f, -0.31452107f, 
    -0.02585069f, -0.23865731f, 0.11990713f, -0.30713144f, 0.00447158f, 0.28836116f, 0.17392765f, -0.23340891f, 
    -0.14052381f, 0.06164303f, 0.10209243f, 0.11554460f, 0.15983182f, -0.05526822f, 0.16417322f, -0.04763337f, 
    -0.65042335f, 0.22396913f, 0.08254077f, 0.10796832f, -0.14798932f, 0.00308186f, 0.18139534f, 0.12445355f, 
    -0.19341202f, -0.05491304f, 0.07769920f, -0.00203360f, 0.05081244f, 0.23330019f, 0.18220849f, -0.10797212f, 
    0.03211025f, 0.20599106f, 0.16730876f, 0.13124463f, 0.03724580f, -0.06374950f, 0.00181346f, -0.11732905f, 
    0.09634055f, 0.00408575f, -0.18725771f, -0.04128705f, 0.01108741f, 0.04185450f, -0.12653708f, -0.19065131f, 
    0.07109409f, -0.25731006f, -0.06632899f, -0.01500290f, -0.18462619f, -0.10770626f, 0.03483180f, 0.20695750f, 
    -0.12968518f, 0.04148515f, 0.15423317f, -0.08543822f, 0.06135805f, -0.07057565f, 0.05026761f, -0.04985173f, 
    -0.27470922f, -0.02520896f, -0.33473966f, 0.17253339f, 0.14598098f, 0.08417886f, -0.15172443f, 0.07960457f, 
    -0.12726568f, -0.08914628f, -0.07621139f, -0.01037632f, -0.01007842f, 0.05400914f, -0.02854530f, 0.27209210f, 
    0.12026900f, -0.04518779f, 0.13185538f, -0.04552695f, -0.17221923f, -0.05356986f, 0.16112466f, -0.04797193f, 
    0.05631471f, -0.12693389f, -0.11365286f, -0.09432230f, -0.14105396f, 0.11564500f, 0.03571647f, 0.06843026f, 
    -0.01292534f, 0.05688495f, 0.06641512f, -0.29263124f, -0.01769006f, -0.02073548f, -0.21300775f, 0.02121093f, 
    0.13020095f, -0.05179281f, 0.26709920f, 0.00037951f, -0.05375710f, -0.09946301f, -0.10688625f, 0.00392154f, 
    -0.05599665f, 0.30414027f, -0.04547549f, 0.15047224f, -0.01404055f, 0.24655132f, 0.21803883f, 0.03394247f, 
    0.00860237f, 0.00314979f, -0.13600476f, 0.13563210f, -0.41010973f, 0.20097782f, -0.04539031f, -0.19537318f, 
    0.00513906f, -0.17117365f, -0.14419968f, -0.05107605f, -0.16611339f, 0.15493894f, 0.03972709f, 0.07540672f, 
    0.24153325f, -0.66695237f, -0.14957809f, -0.18698050f, 0.06438459f, 0.05052768f, -0.00752122f, -0.26980636f, 
    0.02207377f, -0.11827537f, 0.05647362f, 0.09825908f, -0.22551243f, -0.12623194f, -0.11180300f, 0.51786327f, 
    0.12516885f, 0.08523773f, 0.11589215f, 0.08372303f, 0.04207307f, -0.11301630f, 0.02611186f, -0.03481566f, 
    0.11132572f, 0.06618968f, 0.04053228f, -0.08292235f, 0.02176148f, -0.14254202f, 0.09546706f, -0.23636860f, 
    0.20373520f, 0.03705718f, 0.14751585f, 0.26552176f, 0.01516282f, 0.27740997f, 0.07643389f, -0.42343271f, 
    0.03965886f, -0.19347513f, -0.24043302f, -0.09466296f, 0.11783548f, -0.04262885f, 0.12234575f, 0.05460828f, 
    -0.12983258f, -0.14537610f, -0.01875185f, 0.16704850f, -0.01529953f, 0.04119251f, -0.07098374f, -0.06228147f, 
    0.10153808f, -0.07896362f, 0.25278482f, 0.08496168f, -0.32411385f, 0.06954943f, 0.14281738f, -0.09318680f, 
    -0.12274725f, 0.10084569f, 0.06184857f, 0.02883798f, 0.04581379f, -0.20717286f, 0.02173109f, -0.32178840f, 
    -0.03278584f, -0.28863353f, 0.09328234f, -0.26064909f, 0.05830843f, -0.03620167f, -0.02377725f, -0.17922495f, 
    -0.05537807f, 0.01566842f, -0.08011418f, -0.17661455f, 0.25828779f, 0.14665432f, -0.11560024f, -0.25652370f, 
    0.11006299f, 0.00393808f, 0.13584055f, 0.03809494f, 0.09063478f, 0.04337313f, -0.14814247f, 0.01365995f, 
    -0.35234436f, 0.21158661f, -0.00381050f, 0.02469725f, -0.10389300f, -0.00529799f, 0.07680044f, 0.27526817f, 
    0.11292867f, 0.00941821f, -0.03418404f, 0.19054796f, -0.23109913f, 0.03303515f, -0.27621785f, -0.27927938f, 
    -0.04069798f, -0.00926082f, 0.10914198f, 0.18740489f, -0.17020808f, -0.09429953f, -0.08051998f, -0.06416743f, 
    -0.29178187f, -0.21590804f, -0.05897907f, -0.29053041f, -0.10328474f, -0.07352325f, -0.04684272f, -0.05670719f, 
    -0.05077632f, 0.02442979f, 0.17599317f, -0.01993739f, 0.57303220f, -0.01560692f, 0.30799353f, -0.42150104f, 
    -0.00726185f, 0.06071047f, 0.16032884f, -0.08499790f, -0.05426670f, 0.10144184f, 0.00270852f, 0.14877126f, 
    0.11299643f, -0.75459820f, 0.10791219f, -0.08342975f, 0.13602550f, 0.06432515f, 0.00289266f, 0.26602849f, 
    0.10770749f, 0.01708548f, 0.13421056f, 0.14469479f, -0.10069707f, 0.18856919f, 0.15097649f, -0.05412018f, 
    0.16238485f, 0.02419897f, 0.04611976f, -0.10699364f, 0.01807516f, -0.09758721f, -0.16825502f, 0.27222148f, 
    0.32428965f, 0.08653664f, 0.18245842f, -0.45663926f, -0.20456563f, -0.07989585f, 0.01383867f, 0.08702984f, 
    0.18255107f, -0.13153419f, -0.03231896f, -0.10039060f, 0.03637873f, 0.07270788f, -0.11109414f, 0.42041472f, 
    -0.05907417f, 0.18175013f, -0.11439358f, 0.09824247f, 0.18180537f, 0.09487662f, -0.14621444f, 0.01241044f, 
    -0.15107520f, 0.07185356f, -0.05586394f, -0.40480164f, 0.00006068f, 0.06994326f, -0.04837488f, -0.01825139f, 
    0.00813255f, 0.11839139f, -0.09439375f, -0.12263121f, -0.16472581f, 0.23524269f, 0.14406011f, -0.04452447f, 
    -0.00606221f, 0.10097411f, -0.11789557f, 0.14950204f, -0.10240050f, -0.05876919f, -0.10839017f, -0.20449881f, 
    -0.15702122f, 0.32159913f, -0.00372537f, -0.34607244f, -0.14080821f, 0.02943583f, 0.15006076f, 0.09534939f, 
    0.18474655f, -0.00215675f, -0.02804552f, -0.03715331f, -0.21377155f, -0.24770735f, -0.31255245f, -0.06379278f, 
    -0.11726876f, -0.13454692f, 0.15036730f, 0.04238379f, -0.11165542f, -0.11994191f, -0.06474509f, 0.06674083f, 
    0.21378650f, 0.03809261f, 0.08902922f, 0.36398414f, 0.18770452f, 0.02475356f, -0.03570243f, 0.05615952f, 
    -0.04879795f, -0.03659163f, 0.01210034f, -0.08277144f, -0.27752748f, 0.05783534f, -0.31117317f, -0.24304770f, 
    0.11442395f, -0.01648492f, -0.00677059f, -0.13574548f, -0.09845353f, -0.04766681f, -0.00314265f, -0.10057870f, 
    -0.18319178f, 0.28182787f, 0.00488545f, -0.05881472f, 0.02676458f, 0.04683214f, -0.07728544f, -0.03909953f, 
    -0.01797686f, -0.07562385f, -0.09522840f, -0.18049935f, -0.18439953f, -0.11190458f, -0.04539483f, 0.02936667f, 
    0.06924415f, -0.04391422f, -0.07775646f, 0.02847554f, -0.00400684f, -0.13641438f, 0.02839781f, 0.01232182f, 
    0.07824788f, 0.23534441f, 0.12633863f, 0.19559613f, 0.04322157f, -0.03036461f, -0.10682359f, -0.02819989f, 
    -0.03219826f, -0.09410207f, -0.11627527f, -0.07023622f, 0.25730768f, 0.26804608f, -0.31572533f, 0.14734901f, 
    0.04431945f, 0.05619855f, -0.01018709f, 0.00180422f, -0.00720441f, 0.12356023f, 0.04699390f, 0.05143267f, 
    -0.28934634f, -0.25244990f, -0.08623151f, -0.06919809f, -0.00738989f, -0.07285735f, -0.02542802f, -0.06322224f, 
    -0.01912697f, 0.02288071f, -0.05265318f, -0.06460831f, -0.10006902f, -0.00031155f, -0.01751117f, 0.01376197f, 
    -0.18328607f, 0.06786694f, -0.03720011f, 0.02519071f, 0.00726968f, -0.04599770f, -0.01574021f, -0.05704153f, 
    -0.29319593f, 0.11381199f, 0.05708877f, -0.11653000f, -0.06936698f, -0.06460338f, 0.01095314f, -0.09491809f, 
    -0.05690066f, -0.10868100f, -0.09009958f, -0.07297232f, 0.06943183f, 0.02459341f, -0.10871956f, 0.19532803f, 
    -0.07179164f, 0.12876160f, -0.13809395f, 0.02586325f, 0.01237937f, 0.08612235f, -0.08453427f, -0.11647601f, 
    0.22751573f, 0.18182114f, -0.20165932f, 0.05281670f, -0.12658662f, 0.09293062f, 0.03683480f, -0.01065814f, 
    -0.07642711f, 0.14001964f, 0.07175063f, 0.08376551f, -0.26005006f, -0.02954405f, -0.09468049f, -0.03760572f, 
    0.14032809f, 0.04049469f, -0.18300740f, 0.00823691f, -0.15252423f, -0.00195597f, 0.03927930f, -0.08247247f, 
    0.13517921f, 0.21480949f, 0.29590034f, 0.19869076f, 0.18262105f, 0.13459194f, 0.17611325f, 0.05200062f, 
    -0.06706706f, 0.05267000f, 0.00033781f, -0.04578403f, -0.07583468f, 0.11943492f, -0.39895123f, 0.13400277f, 
    0.05382448f, -0.08570857f, -0.14055377f, -0.06667864f, 0.05215648f, -0.03019188f, 0.03268977f, -0.10776404f, 
    -0.00038664f, -0.03590324f, 0.13395740f, 0.13110799f, 0.00348874f, -0.09025914f, -0.06181719f, -0.03187921f, 
    -0.03124145f, 0.02460782f, -0.03472445f, -0.07197207f, -0.15367755f, 0.05829660f, 0.16418657f, 0.07775920f, 
    -0.12373007f, -0.01545327f, -0.07023512f, 0.02105569f, -0.08677673f, -0.09109178f, -0.04836580f, -0.03498054f, 
    0.15988314f, -0.44461527f, 0.10887790f, 0.07157204f, 0.03332771f, -0.13437295f, -0.05640087f, -0.06070604f, 
    -0.13660719f, -0.04562695f, 0.00707819f, 0.02806718f, 0.10437477f, 0.12271591f, 0.10399800f, -0.26130429f, 
    0.03693730f, 0.05505527f, 0.20825580f, 0.06866711f, -0.02207721f, 0.06261839f, -0.11717919f, -0.05091712f, 
    0.18813014f, -0.16371864f, 0.15303117f, 0.07641622f, 0.00780634f, -0.01411060f, -0.02453655f, -0.00080614f, 
    -0.11707879f, 0.12859522f, 0.00143772f, -0.04428313f, 0.22583611f, -0.33295661f, 0.02944638f, -0.06002342f, 
    -0.10728288f, -0.15557475f, 0.00246980f, -0.05116922f, -0.07442852f, -0.00834908f, -0.08806281f, -0.04772632f, 
    0.20640790f, -0.11469808f, -0.17943992f, -0.19818954f, -0.16119348f, -0.04761513f, -0.04335587f, -0.06673837f, 
    0.03586172f, 0.03765675f, -0.06057597f, -0.03249234f, 0.08233307f, 0.12764136f, -0.03838797f, 0.37681267f, 
    0.12205006f, -0.05815796f, -0.07043587f, -0.06764872f, -0.05306410f, -0.01235607f, -0.11277609f, -0.13106957f, 
    0.08324536f, 0.26278460f, 0.21938679f, 0.24671015f, 0.07077891f, 0.10965260f, 0.07334793f, 0.03820846f, 
    -0.08791085f, 0.03341255f, -0.10978165f, -0.04067829f, 0.21060354f, 0.32261822f, -0.21996091f, -0.15146422f, 
    -0.06502482f, 0.04378440f, 0.03521876f, -0.04590142f, -0.02343970f, -0.16518196f, -0.11858833f, -0.15734200f, 
    -0.26021793f, -0.00013659f, 0.21575114f, -0.15264176f, -0.16626643f, 0.07805988f, -0.08066355f, -0.04015725f, 
    -0.05228623f, -0.04275589f, 0.04921856f, -0.10540301f, 0.25984901f, 0.00293165f, -0.11598726f, 0.01381932f, 
    -0.08834116f, 0.01598362f, 0.09279444f, -0.06593753f, 0.07709142f, 0.01870453f, 0.10427479f, -0.19554098f, 
    -0.19648722f, 0.05079750f, -0.11402525f, -0.11644516f, -0.04358042f, 0.04143461f, 0.00497859f, -0.13162786f, 
    -0.09201819f, 0.07260160f, 0.04678665f, -0.17035541f, -0.07360142f, 0.14593904f, -0.23461507f, 0.04427370f, 
    0.11698861f, 0.01863031f, -0.15036847f, 0.08383530f, 0.15780362f, 0.09762038f, 0.09327091f, -0.18103655f, 
    0.12438694f, 0.04180567f, 0.17784514f, 0.15570216f, -0.00083860f, -0.07603377f, -0.03345023f, -0.07192761f, 
    -0.03997897f, 0.09045010f, -0.04969113f, -0.08168051f, -0.29988277f, 0.35371673f, 0.01250947f, -0.24555695f, 
    -0.09047781f, -0.06136367f, -0.10434334f, -0.08386163f, 0.00023463f, -0.06640004f, -0.04934762f, -0.17748329f, 
    -0.64267087f, 0.24908330f, -0.10575133f, -0.22822157f, -0.02882777f, -0.02228323f, -0.03882208f, -0.07535710f, 
    -0.07449763f, 0.10196730f, -0.01072421f, 0.01322707f, 0.22547992f, -0.14843091f, 0.26221600f, 0.37581825f, 
    0.09414326f, -0.00838411f, -0.09243190f, -0.02515123f, -0.00835683f, -0.07320204f, -0.05000789f, -0.14061113f, 
    0.05881340f, -0.13408372f, 0.06078270f, -0.28661177f, 0.08432977f, 0.10347993f, 0.01835102f, -0.06909238f, 
    -0.03443172f, 0.10836048f, -0.03346367f, 0.07451669f, -0.01658689f, 0.03947946f, 0.00521364f, 0.14741737f, 
    0.14091329f, -0.04268361f, -0.13021357f, -0.01380640f, -0.00282884f, 0.10254285f, -0.17209351f, 0.07583923f, 
    0.38452223f, -0.21902868f, 0.00787898f, 0.15784638f, 0.00468152f, -0.07454821f, -0.07802992f, -0.02545615f, 
    -0.08797027f, -0.02943684f, 0.07410225f, -0.20192868f, -0.19494849f, 0.05238527f, -0.20249347f, -0.12162485f, 
    0.22567859f, -0.04310756f, -0.18095835f, 0.05888370f, -0.04774432f, 0.00022671f, 0.02024371f, 0.17570318f, 
    -0.13931701f, 0.42271951f, -0.08724236f, -0.24650419f, -0.02125656f, 0.02898378f, -0.08589897f, 0.04831631f, 
    0.03749468f, -0.13698187f, 0.20046127f, 0.08271270f, -0.16776353f, 0.27988106f, -0.04161721f, -0.02370519f, 
    -0.12311109f, 0.02136954f, -0.36170849f, 0.03639542f, 0.05676444f, -0.08768843f, 0.06406709f, -0.23448069f, 
    0.24238457f, 0.23671231f, -0.43802619f, 0.02127916f, 0.00760415f, 0.10304901f, -0.10131977f, -0.04136579f, 
    0.11535897f, 0.01229103f, -0.03863177f, 0.15128618f, 0.08769574f, 0.28776550f, 0.04021169f, -0.15847085f, 
    0.15333192f, 0.02068584f, 0.02389327f, 0.14691320f, 0.15248941f, 0.16143541f, -0.01308852f, 0.04219475f, 
    0.05070135f, 0.09497330f, 0.12438223f, 0.02028407f, 0.00686508f, 0.10955674f, 0.03973662f, -0.15295334f, 
    -0.02210784f, -0.00863508f, 0.03698250f, 0.06594012f, -0.04246635f, 0.36820012f, -0.20541340f, -0.17311409f, 
    -0.21470973f, -0.02051286f, -0.18212768f, -0.09312737f, 0.08501350f, 0.19033575f, -0.13040724f, 0.12606803f, 
    -0.42568776f, 0.12409074f, -0.06922056f, -0.15121053f, 0.00520021f, -0.00454587f, -0.21059978f, -0.13276765f, 
    0.02176705f, -0.11815357f, -0.01690058f, -0.21612306f, -0.10901703f, -0.16043383f, -0.11025694f, -0.09395529f, 
    0.00977452f, 0.00049574f, -0.10508669f, 0.14328369f, 0.17872898f, -0.09226355f, 0.05946910f, -0.13125071f, 
    -0.10238131f, -0.20736744f, 0.21021076f, -0.06977978f, -0.22346357f, 0.02721404f, 0.06732453f, -0.05984714f, 
    -0.04188541f, -0.06891140f, -0.04557566f, -0.19716585f, -0.09627273f, 0.08152930f, -0.47374696f, -0.24912244f, 
    -0.00985414f, -0.04926103f, -0.23436494f, 0.06408192f, 0.06465468f, -0.04943224f, 0.05230680f, -0.21665336f, 
    -0.02897931f, 0.00001041f, -0.00748059f, -0.42561987f, 0.00224312f, -0.14545020f, -0.25446287f, 0.04046737f, 
    0.02404892f, -0.03511734f, -0.01077925f, -0.01691625f, -0.26156771f, 0.32341415f, 0.07353564f, -0.06329253f, 
    -0.08549052f, -0.12056263f, -0.07220513f, 0.02459672f, -0.00171914f, -0.01989185f, 0.00819779f, -0.17590855f, 
    -0.20600192f, 0.06078537f, -0.10654429f, 0.10747001f, 0.09743989f, 0.16548698f, 0.01101534f, -0.26491845f, 
    0.10375491f, 0.09979579f, -0.09877837f, 0.30802238f, -0.18679209f, -0.16130620f, -0.04655664f, 0.13068068f, 
    0.03268070f, -0.24893284f, -0.03064533f, 0.04801869f, -0.08559827f, 0.03295261f, 0.11401763f, 0.08444126f, 
    -0.43160939f, -0.22091530f, 0.17645220f, -0.18566124f, -0.11662603f, -0.10277865f, 0.03206386f, -0.06257968f, 
    -0.00763677f, 0.08440382f, -0.10418715f, 0.18946481f, -0.15776478f, -0.18949473f, -0.25604036f, -0.17674111f, 
    -0.00251906f, -0.04502793f, 0.05109918f, -0.00393233f, 0.12360684f, 0.08362946f, 0.07637078f, 0.11689959f, 
    0.26845098f, 0.04296574f, 0.03822440f, 0.02486773f, -0.03543746f, -0.03991178f, -0.18101032f, -0.12671256f, 
    -0.09990738f, 0.08596913f, -0.17012435f, -0.09655236f, -0.15563944f, 0.13463241f, 0.04522730f, -0.28141069f, 
    -0.13458368f, -0.03926098f, -0.04374110f, -0.08772173f, 0.04069231f, 0.02731191f, -0.09955427f, -0.12728368f, 
    -0.11980078f, -0.07553164f, 0.47611925f, 0.19778676f, -0.14253999f, -0.06002305f, -0.33249602f, -0.05336120f, 
    0.03404627f, 0.05534790f, -0.00525049f, 0.06079126f, 0.04932382f, 0.06860965f, 0.08783580f, 0.05796088f, 
    -0.04006258f, -0.08476670f, -0.03700032f, 0.01147171f, -0.02839401f, -0.02619185f, -0.01014218f, -0.25623003f, 
    0.18928839f, 0.04442311f, 0.15868671f, 0.21597677f, -0.08044182f, -0.05889961f, 0.10480584f, -0.07780164f, 
    -0.02814990f, -0.10237563f, -0.10771882f, -0.09302980f, 0.15171297f, -0.14899950f, -0.06399085f, -0.02063732f, 
    0.06513691f, -0.16401474f, -0.02263107f, 0.16030918f, 0.00489213f, 0.11043901f, -0.02504952f, -0.14006206f, 
    0.15360492f, -0.01282369f, 0.05050635f, 0.29376417f, 0.11719862f, -0.05357894f, -0.12578127f, -0.00648557f, 
    0.04088629f, 0.13130309f, 0.14847711f, -0.11459985f, -0.07273838f, 0.41138002f, -0.19338426f, -0.08713777f, 
    0.15713103f, -0.05669511f, -0.29451916f, -0.03586922f, 0.07466881f, -0.09132094f, -0.09603040f, 0.20684189f, 
    -0.17294477f, -0.24925341f, -0.10229000f, -0.51348132f, -0.10469857f, 0.08075880f, 0.05588108f, -0.26269084f, 
    0.08238236f, -0.08460426f, 0.10733452f, 0.09963010f, 0.01979454f, -0.19267146f, -0.02249098f, 0.14286529f, 
    0.08902786f, -0.07333059f, -0.00763894f, -0.04985346f, 0.14722681f, 0.18082298f, 0.01804491f, 0.11324713f, 
    -0.05288944f, -0.04530220f, 0.30161989f, 0.30171561f, 0.20268625f, 0.03230400f, -0.08646568f, -0.09569860f, 
    0.13936208f, -0.04249363f, 0.21251665f, 0.08756729f, -0.06729848f, -0.09247313f, 0.03030635f, -0.12749912f, 
    -0.03588410f, 0.02584867f, -0.30587065f, -0.06659673f, -0.10060676f, 0.01065899f, 0.08445115f, -0.11919474f, 
    0.17884377f, -0.06559067f, -0.04458070f, -0.02918517f, 0.12126872f, -0.06153036f, -0.03228971f, -0.05335665f, 
    -0.19669162f, -0.08749592f, -0.01062390f, 0.16625674f, 0.00373844f, -0.09769055f, -0.04680035f, -0.16314580f, 
    -0.00785997f, -0.09172896f, 0.12020447f, 0.09165769f, -0.06832062f, -0.08030098f, 0.07531116f, -0.07926133f, 
    -0.65410239f, 0.33309826f, -0.30484024f, 0.00032409f, 0.01788368f, 0.04829145f, -0.01095710f, -0.03696425f, 
    -0.03194902f, 0.05857788f, 0.15657194f, 0.11280473f, -0.01369619f, -0.35363081f, 0.28284496f, -0.17762199f, 
    -0.17620705f, 0.05617350f, 0.04482068f, 0.06921946f, 0.23014601f, -0.05344656f, 0.04184993f, -0.11507456f, 
    -0.29340672f, -0.27929276f, 0.21261731f, 0.04618400f, -0.08962413f, 0.03633081f, 0.05577482f, 0.01750692f, 
    0.01877215f, 0.03837341f, -0.17732203f, -0.02391485f, -0.51799691f, 0.32123411f, 0.39884010f, 0.11866048f, 
    0.02715351f, -0.01904444f, -0.05785415f, 0.26397014f, 0.01568275f, -0.13613662f, 0.00774243f, 0.19372422f, 
    0.06683614f, -0.25447908f, 0.24515508f, -0.01257986f, 0.10111771f, 0.19726086f, -0.02773755f, 0.05360628f, 
    -0.24425188f, -0.13247751f, -0.03787407f, -0.07480613f, 0.13917306f, 0.07884036f, 0.32152990f, 0.20853990f, 
    0.09027857f, -0.04312726f, -0.02010429f, 0.01887417f, 0.12856273f, -0.03031871f, -0.05985862f, -0.01167156f, 
    0.32483274f, 0.27460432f, -0.49303728f, -0.26748797f, 0.23847783f, -0.12226390f, 0.07217115f, -0.00880647f, 
    -0.05237952f, 0.04653660f, -0.00129402f, -0.00292973f, -0.01261775f, 0.33847177f, -0.03077955f, 0.28692359f, 
    -0.06317637f, 0.08170836f, -0.00393415f, 0.19147268f, 0.07742907f, 0.09303547f, -0.04407940f, 0.02772542f, 
    0.11350915f, -0.02317988f, 0.09641674f, -0.22469854f, -0.19581859f, -0.01977266f, 0.00924914f, 0.02289758f, 
    0.10112118f, 0.17197171f, 0.01735222f, 0.22083175f, 0.19196123f, -0.28210080f, 0.07322878f, -0.06623303f, 
    -0.03488672f, 0.13622679f, 0.00885324f, -0.03882637f, 0.01557537f, 0.05633821f, 0.08168265f, -0.05136959f, 
    0.09491440f, -0.11930106f, -0.08437909f, -0.05987269f, 0.08694878f, -0.11972105f, -0.19278498f, -0.01728259f, 
    -0.03168783f, 0.15530673f, -0.06019205f, 0.04174236f, -0.16717429f, 0.14797765f, 0.23590910f, -0.08077684f, 
    -0.15235302f, -0.00201168f, -0.07115164f, 0.01561049f, -0.09594905f, 0.02590990f, -0.03753426f, 0.01167732f, 
    0.01623025f, -0.30355763f, -0.03056558f, -0.08025275f, -0.26728857f, -0.11252385f, -0.00768545f, 0.05235052f, 
    -0.10173047f, 0.21680082f, 0.10340044f, 0.09802586f, -0.41927320f, -0.08141533f, -0.29341957f, 0.38708133f, 
    -0.02294792f, 0.11027697f, -0.20548104f, -0.09023888f, -0.06393734f, -0.12343846f, 0.05016308f, 0.08099046f, 
    0.34818435f, -0.90146714f, 0.08959825f, 0.03855779f, -0.15620932f, -0.10528491f, -0.10498890f, 0.04041950f, 
    0.02212126f, 0.13058378f, 0.09882133f, -0.15739654f, -0.08366448f, 0.09470674f, 0.10010182f, 0.09523989f, 
    0.02657837f, 0.04346069f, 0.10579462f, -0.11792912f, -0.04355434f, 0.09876393f, -0.10596196f, 0.12292679f, 
    0.91314578f, 0.17027487f, -0.56477672f, -0.00600190f, 0.07528621f, -0.02159985f, -0.02912567f, 0.16630927f, 
    -0.00807703f, 0.00494538f, 0.06522101f, 0.02507765f, -0.17617664f, 0.07498127f, -0.07109654f, -0.48355711f, 
    -0.00958118f, 0.04861510f, 0.03866397f, -0.04002392f, -0.03487164f, -0.05895130f, 0.02709407f, -0.11978664f, 
    0.11017215f, 0.00166488f, 0.08053178f, -0.05881567f, 0.18364443f, -0.00068000f, 0.01623606f, 0.03512935f, 
    0.16663453f, -0.19515285f, 0.02643667f, 0.11227004f, 0.19249623f, -0.20446149f, -0.13925341f, -0.21491905f, 
    0.08234665f, 0.14549854f, -0.04412565f, 0.02444534f, -0.01281303f, -0.06124821f, -0.03416183f, -0.09818055f, 
    -0.43073490f, -0.30140921f, -0.20962304f, -0.25104630f, 0.12171615f, 0.12578709f, 0.10354040f, 0.18246226f, 
    0.00139017f, 0.05868803f, -0.03910706f, -0.16954213f, -0.58801746f, 0.01651563f, 0.00031626f, -0.10987374f, 
    0.07547801f, -0.13076448f, 0.04423605f, 0.02879863f, 0.09029870f, -0.03603413f, -0.04783666f, 0.23296814f, 
    -0.24207962f, 0.26807913f, -0.07407132f, 0.21750407f, 0.22381458f, 0.02729834f, -0.10281041f, -0.03844877f, 
    -0.01268437f, 0.00326156f, 0.06639252f, -0.00321330f, 0.24477038f, 0.17336969f, 0.09499891f, 0.24479128f, 
    0.15793739f, 0.19263725f, 0.04433789f, -0.00554878f, 0.06033246f, -0.00281385f, 0.04539905f, -0.20046468f, 
    -0.24407277f, 0.22416650f, -0.29379818f, -0.50903356f, 0.05361827f, 0.04149136f, -0.14673989f, 0.08858623f, 
    0.09658162f, -0.00243765f, -0.31595755f, 0.00785106f, 0.06270936f, 0.14732136f, 0.36598572f, 0.03970820f, 
    -0.15432480f, 0.05921305f, 0.07988191f, 0.04101071f, -0.12815976f, -0.01882464f, 0.20947903f, -0.07567400f, 
    -0.06042905f, -0.21816245f, -0.00209464f, 0.00223234f, 0.03367197f, -0.04740037f, 0.04042222f, -0.13699241f, 
    0.01614622f, -0.06228131f, -0.03198604f, 0.12088679f, -0.47517616f, 0.01410070f, -0.10941645f, -0.07008360f, 
    -0.01730266f, 0.09609743f, 0.18763736f, -0.17585364f, -0.06132443f, -0.26145980f, -0.02512507f, -0.07826938f, 
    -0.33758140f, 0.24522021f, -0.07615907f, -0.52534652f, 0.07585151f, -0.02017892f, -0.21091996f, -0.11066536f, 
    -0.15666017f, -0.26243448f, -0.10731667f, -0.17669064f, 0.31040940f, -0.47679067f, -0.19242373f, 0.05908421f, 
    0.15728599f, 0.02106085f, 0.01755213f, 0.18978027f, -0.05948487f, 0.16788654f, 0.19279569f, 0.13083929f, 
    0.03930511f, 0.05356073f, -0.04917176f, 0.00132927f, 0.11136442f, 0.19906434f, 0.10117064f, -0.02164946f, 
    0.16328652f, 0.19705540f, 0.00106286f, 0.18101837f, -0.47820061f, 0.09224376f, -0.02062177f, -0.29150817f, 
    0.06772815f, 0.00498463f, 0.01136767f, 0.01649678f, -0.05189487f, 0.07194855f, -0.18181735f, 0.21053541f, 
    -0.40767011f, -0.23839159f, -0.31667742f, -0.05490084f, -0.05680475f, -0.02546921f, -0.04483970f, -0.00292554f, 
    0.16049154f, 0.05944889f, -0.07348070f, 0.05144203f, 0.05729656f, 0.20030460f, -0.12772381f, 0.02941308f, 
    0.16645581f, -0.13108151f, 0.02919807f, 0.05186765f, -0.03655405f, 0.08353213f, 0.03790148f, 0.26790157f, 
    0.25443497f, -0.01275944f, 0.09813762f, -0.22995302f, 0.17596094f, 0.16459426f, 0.03485729f, -0.07653959f, 
    -0.01833885f, 0.09088162f, -0.00078820f, 0.05070530f, -0.25224024f, -0.19160557f, 0.12199546f, 0.11962195f, 
    -0.06690590f, 0.05441109f, -0.04614856f, 0.07290583f, 0.11714361f, 0.03472995f, 0.00999661f, 0.06162686f, 
    -0.53497612f, -0.19402075f, -0.06900002f, -0.02930544f, 0.11042728f, -0.01265864f, -0.05780778f, -0.03781660f, 
    0.08468205f, 0.04139824f, -0.01841093f, 0.16606358f, 0.02140945f, -0.32965106f, 0.14525266f, -0.05014366f, 
    -0.02494304f, -0.12824474f, 0.04816552f, 0.01880926f, 0.04232665f, -0.00207598f, -0.02587040f, 0.07130772f, 
    -0.24228135f, -0.09889518f, 0.09300164f, 0.03382441f, 0.01668501f, 0.16822827f, -0.07519833f, 0.07488190f, 
    0.06848151f, 0.06020687f, 0.22236530f, 0.26348931f, 0.02824777f, 0.02220854f, -0.12931679f, -0.09507196f, 
    0.00220616f, 0.14221045f, -0.01870081f, 0.04153191f, 0.16333522f, -0.05573546f, 0.04664132f, -0.12936102f, 
    -0.51143342f, -0.02174064f, 0.09237187f, 0.10980281f, 0.03841497f, 0.02643985f, 0.09448095f, -0.05355152f, 
    0.05620473f, -0.15260808f, -0.30938029f, -0.13617149f, -0.18369228f, 0.11503863f, 0.02935142f, -0.13836172f, 
    0.21049221f, 0.11606144f, 0.02397520f, -0.01517507f, -0.02132196f, 0.01873809f, -0.01573904f, 0.08805936f, 
    0.33854949f, 0.19756564f, -0.20950863f, 0.02464853f, -0.26535743f, 0.04523606f, -0.07068206f, -0.13390182f, 
    0.07825565f, 0.01727354f, 0.06259021f, -0.10620017f, -0.49773329f, -0.10620987f, 0.32429832f, 0.14997870f, 
    0.07380915f, 0.06453984f, -0.03075295f, 0.02946450f, 0.08845498f, -0.03836319f, -0.00723931f, -0.05499844f, 
    0.06482878f, -0.01701679f, -0.01829380f, -0.10148184f, 0.06300634f, -0.04484180f, -0.24669968f, 0.00221611f, 
    0.09953623f, -0.24149323f, -0.00027942f, -0.26553389f, 0.30825132f, 0.07757950f, -0.03595281f, 0.07452035f, 
    -0.01923688f, -0.10904873f, 0.08779912f, 0.04782375f, 0.05820252f, 0.06127136f, -0.02785795f, 0.07192574f, 
    0.02853009f, 0.04308129f, -0.13095993f, -0.08898024f, 0.15379338f, 0.16591889f, 0.01298797f, -0.00218167f, 
    -0.12124781f, -0.02953330f, -0.24101274f, -0.00924497f, 0.10092065f, -0.14310016f, 0.12628743f, 0.13892403f, 
    0.00167135f, -0.20935626f, -0.19366123f, 0.29708830f, -0.02877149f, -0.06119662f, 0.07294743f, 0.16757956f, 
    -0.02769525f, 0.08991519f, -0.09301536f, 0.26004949f, 0.04909000f, 0.04431501f, 0.01242221f, 0.06120058f, 
    0.03278111f, -0.03761398f, 0.10638072f, -0.03395217f, 0.23984800f, 0.26245287f, 0.10021013f, -0.08843930f, 
    -0.06545077f, 0.15108673f, 0.04990792f, 0.15763544f, -0.09741410f, 0.03104375f, 0.25154686f, 0.00694127f, 
    -0.33538252f, -0.26963180f, -0.21163739f, -0.27001533f, 0.04036048f, 0.10856155f, -0.24359423f, -0.12903303f, 
    0.05886718f, -0.03428299f, -0.18524222f, 0.02173690f, 0.26134285f, 0.03549064f, 0.03691417f, 0.03061964f, 
    0.02018876f, -0.03820899f, 0.08471300f, -0.13233463f, 0.18108864f, 0.09750244f, -0.05450729f, -0.00732858f, 
    0.28068420f, 0.16472885f, 0.15399669f, -0.11951987f, -0.12799659f, -0.23000053f, -0.00122869f, -0.09917379f, 
    -0.03813263f, -0.14874858f, -0.07922143f, 0.18895128f, -0.27134916f, -0.59788120f, 0.08866458f, 0.08937911f, 
    0.05820673f, -0.00979839f, -0.05588359f, -0.04077380f, -0.06425063f, -0.03522716f, -0.15779278f, 0.04858511f, 
    0.44063437f, -0.00480510f, -0.12278128f, 0.11008883f, -0.06859239f, -0.05944394f, -0.01625188f, 0.13747078f, 
    -0.05043013f, -0.07805081f, -0.12168659f, -0.04157211f, -0.20708637f, 0.07061201f, 0.11200363f, 0.12708406f, 
    -0.03727959f, -0.17337081f, 0.01372943f, -0.16250238f, -0.11626071f, 0.22271298f, -0.02169410f, 0.11701845f, 
    -0.83999217f, -0.12946410f, -0.34484786f, -0.55346072f, 0.14304689f, -0.19278242f, -0.13030306f, -0.02417125f, 
    0.04364516f, -0.08255372f, 0.08762059f, -0.07360708f, -0.49156976f, -0.34277990f, -0.09992370f, 0.19802402f, 
    0.06995390f, 0.08460651f, 0.01565367f, -0.26147017f, 0.07479030f, -0.22020754f, -0.15604304f, 0.06452254f, 
    0.23816557f, 0.08419832f, -0.03465383f, 0.01272664f, 0.02515359f, 0.16920094f, -0.06856529f, 0.02192291f, 
    0.08667482f, 0.10522033f, 0.00123977f, 0.07977864f, -0.56980562f, -0.66652167f, -0.09788307f, -0.02596839f, 
    -0.04853786f, -0.08233630f, 0.05578602f, -0.00737044f, 0.02776287f, 0.11352863f, -0.02112937f, 0.07564790f, 
    -0.69283211f, -0.36227658f, -0.07994278f, -0.31594020f, 0.01503176f, 0.03070058f, -0.00712887f, 0.00993084f, 
    0.12330065f, -0.02290222f, 0.17417872f, 0.01868268f, -0.05263569f, 0.23288965f, 0.00080621f, -0.09464371f, 
    -0.14662588f, 0.16926810f, -0.12682177f, -0.00344083f, 0.16395736f, -0.03691383f, 0.02601511f, 0.04730471f, 
    -0.14948052f, 0.12694943f, -0.06522281f, 0.06290182f, -0.31594598f, -0.22417955f, 0.00826347f, 0.08502807f, 
    -0.06337178f, -0.10515835f, 0.10235871f, 0.04732702f, 0.63826787f, -0.15999500f, -0.20324165f, -0.17363299f, 
    0.11434710f, -0.00254570f, -0.01489851f, 0.13551624f, -0.02497109f, 0.06105253f, 0.12765178f, -0.04748581f, 
    -0.45741656f, 0.10958108f, -0.05014279f, 0.03361160f, 0.15629603f, 0.06265982f, 0.10852972f, -0.05902398f, 
    0.17905049f, -0.00997331f, 0.06462807f, 0.08696454f, 0.10042424f, 0.11939579f, -0.07309885f, 0.25479871f, 
    0.15783267f, 0.14275314f, -0.08797128f, 0.12106302f, -0.05992702f, 0.09039970f, -0.07659417f, -0.16512316f, 
    0.17624573f, 0.09156201f, -0.22367877f, 0.14636275f, 0.17664292f, -0.09433917f, -0.03913417f, -0.08426458f, 
    0.00628594f, 0.03769133f, -0.13963062f, -0.13312410f, 0.00993468f, 0.15106657f, -0.24421577f, 0.25689411f, 
    0.15550718f, 0.02281683f, -0.07286296f, -0.16034129f, -0.10271806f, -0.08017414f, 0.02274028f, 0.10158101f, 
    0.77931362f, -0.15667665f, -0.27367237f, 0.25179157f, 0.20455545f, -0.12238577f, 0.03266023f, -0.01735192f, 
    0.12775829f, -0.01094465f, 0.01384658f, -0.12872517f, -0.50133598f, -0.36217779f, 0.08783823f, 0.15636638f, 
    0.24698000f, -0.08398134f, -0.18680102f, -0.09657248f, -0.09876909f, -0.02752041f, 0.06265951f, -0.09342515f, 
    0.01038215f, -0.52271956f, 0.28748024f, 0.06425030f, -0.03652184f, -0.08240740f, -0.10944127f, 0.07090051f, 
    -0.17854474f, 0.05389159f, -0.08795347f, 0.00990415f, -0.04995635f, -0.09790663f, -0.25923881f, 0.00706124f, 
    -0.14613162f, -0.20493087f, -0.09162726f, -0.17819345f, -0.14457683f, 0.07244137f, 0.02719425f, -0.01672987f, 
    0.28785947f, -0.22640760f, -0.15435027f, -0.02229569f, -0.10647261f, 0.02989520f, -0.22963350f, 0.02886679f, 
    0.10571510f, 0.10642180f, 0.08836325f, 0.02435800f, 0.43803644f, 0.22638124f, -0.10581282f, 0.05824947f, 
    0.11346362f, 0.19611967f, -0.04915297f, 0.09351080f, 0.18558824f, -0.06250373f, -0.00739123f, -0.01162780f, 
    -0.31339213f, -0.01845293f, -0.04358131f, 0.24026589f, -0.06976922f, 0.08614481f, -0.03516561f, 0.06515792f, 
    0.05033395f, -0.08366292f, 0.00710043f, -0.18834414f, 0.22269677f, 0.53186423f, -0.06650715f, 0.01860863f, 
    0.03006672f, 0.10885326f, -0.15289994f, -0.13911845f, -0.01948511f, 0.18151763f, -0.05594820f, 0.07111201f, 
    -0.04631139f, 0.15277702f, 0.14871220f, 0.09232980f, -0.06588311f, 0.36331633f, -0.05366142f, -0.12234362f, 
    0.17108175f, -0.05007459f, -0.12433118f, 0.06247586f, 0.29477906f, 0.05888563f, -0.05443890f, 0.06463168f, 
    0.05784271f, -0.12148984f, 0.09718434f, 0.01380696f, 0.00992785f, 0.00583187f, 0.11908744f, 0.09142166f, 
    -0.41484585f, 0.26527682f, -0.02171126f, -0.22043030f, 0.00698686f, -0.03202600f, 0.16607098f, 0.21560165f, 
    -0.05806002f, -0.02397186f, 0.06452696f, -0.17781177f, 0.24435388f, 0.02839318f, 0.03548400f, 0.04543632f, 
    -0.16237657f, 0.00309865f, -0.03592486f, -0.18234986f, -0.03470014f, -0.07774648f, -0.04909384f, 0.11165517f, 
    -0.43014440f, 0.15810090f, 0.26999989f, -0.19000095f, -0.22570264f, -0.00120986f, -0.13441668f, -0.06429779f, 
    -0.12402963f, -0.14102584f, 0.17207783f, 0.09658361f, 0.07216615f, 0.07439607f, -0.45244604f, 0.03579525f, 
    0.16893882f, -0.09207237f, 0.03593246f, 0.12560198f, -0.03680080f, -0.02573210f, -0.17974742f, 0.00041759f, 
    -0.41389844f, -0.17291713f, -0.25346133f, -0.34566739f, -0.05775526f, 0.01947319f, 0.04765432f, 0.21594976f, 
    0.02696243f, -0.09156818f, 0.05492872f, 0.00514643f, 0.13889293f, -0.31854647f, -0.16712011f, 0.08434293f, 
    -0.21384406f, -0.03412606f, -0.11732793f, -0.06386346f, -0.05942324f, -0.12822728f, -0.00037296f, -0.08074094f, 
    -0.05550058f, 0.17384611f, -0.03627754f, -0.06238863f, -0.01095974f, -0.12040251f, -0.05002032f, -0.01126082f, 
    0.00023236f, 0.09720641f, -0.12376141f, -0.20130290f, -0.36566177f, 0.23105699f, -0.09050382f, -0.21044408f, 
    0.40494955f, -0.25748935f, 0.03451121f, -0.00162272f, 0.05336908f, -0.04010859f, 0.03006755f, 0.21931031f, 
    -0.09914246f, -0.36187011f, 0.08939312f, -0.14992972f, 0.02367228f, -0.18033430f, 0.10120732f, 0.04409790f, 
    -0.01726912f, 0.01458637f, 0.04808804f, -0.06029419f, 0.14921238f, -0.10566311f, 0.19317503f, -0.39487052f, 
    0.10025799f, 0.05145814f, 0.09723902f, -0.16957174f, -0.13188416f, -0.17865942f, -0.17024067f, -0.11157898f, 
    0.35974804f, -0.40302628f, -0.25954801f, -0.09393378f, -0.08735233f, -0.11577456f, 0.01016922f, 0.01705647f, 
    -0.11516926f, 0.01420339f, 0.10843232f, 0.06862643f, 0.19822556f, -0.07475267f, 0.12253377f, 0.04880602f, 
    0.28697580f, -0.04067692f, 0.00401549f, -0.07146061f, -0.02015244f, 0.19033591f, 0.04851797f, 0.05136800f, 
    -0.12870070f, 0.14620173f, -0.02881152f, -0.01354694f, 0.10318465f, -0.01532879f, 0.11489211f, 0.00273354f, 
    -0.00276880f, -0.08010262f, 0.01882818f, -0.03219044f, -0.33830345f, -0.07156795f, 0.18266316f, 0.04797320f, 
    0.14893407f, -0.03939504f, 0.07992411f, -0.03884961f, 0.03246908f, 0.00984186f, -0.10877205f, -0.08048796f, 
    0.31540886f, -0.27300581f, -0.10367291f, -0.14427051f, 0.04881962f, -0.05707897f, -0.02601141f, 0.06174761f, 
    -0.09108953f, 0.06585144f, -0.08216738f, -0.09174733f, -0.45831841f, 0.17405494f, -0.04214702f, 0.13274577f, 
    -0.15153916f, -0.19763553f, 0.08147684f, 0.07762318f, -0.11392730f, -0.03318274f, 0.25087315f, -0.04156998f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10722816f, 0.01261412f, -0.07163388f, 0.01558477f, 0.03527543f, 0.00985734f, 0.06310812f, -0.04182704f, 
    -0.02602389f, 0.02598977f, 0.13923794f, 0.06201109f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
