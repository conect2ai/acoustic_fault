#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.26012570f, 0.06319349f, 0.30302387f, 0.27406323f, -0.22944288f, -0.17419983f, 0.21983798f, 0.06534836f, 
    0.25747743f, -0.30614883f, -0.34512779f, 0.37449905f, -0.35535002f, 0.60393006f, -0.37848663f, 0.12174274f, 
    0.16367023f, -0.31620723f, -0.11057016f, -0.02802524f, 0.09739775f, 0.02334363f, 0.13198724f, 0.17296195f, 
    -0.27388397f, 0.00916027f, 0.14093673f, 0.32568327f, 0.04374616f, -0.46959332f, 0.47608024f, 0.35913637f, 
    -0.30442575f, -0.57781351f, 0.02556301f, 0.10309999f, -0.00055628f, -0.11703126f, -0.36188143f, -0.23090857f, 
    0.01253824f, -0.06437808f, 0.07845145f, -0.27777171f, -0.01162298f, -0.18599541f, -0.41394466f, -0.01277541f, 
    -0.16680349f, 0.11153949f, -0.68333966f, 0.02756814f, -0.03867731f, 0.31585392f, 0.37900645f, -0.10294426f, 
    -0.37748632f, 0.44727468f, -0.09699795f, 0.26865247f, -0.31459296f, -0.13314271f, -0.09027203f, 0.46405506f, 
    -0.28869188f, 0.07579884f, -0.22865880f, -0.21614048f, 0.12564197f, 0.28220758f, -0.19541758f, 0.15444638f, 
    -0.07311260f, -0.17915748f, -0.19846039f, -0.19808139f, 0.21688524f, 0.52177227f, 0.48364222f, -0.17443526f, 
    0.19515635f, -0.07100026f, -0.17937401f, -0.33348793f, -0.27027011f, -0.12486767f, -0.27565074f, -0.18639371f, 
    0.21163628f, 0.07455835f, 0.36152884f, 0.31315106f, -0.09113520f, -0.08010930f, -0.16002187f, -0.25766343f, 
    -0.09775164f, -0.16705981f, -0.02890207f, -0.21295154f, 0.25303087f, -0.23309188f, 0.21622191f, -0.59914511f, 
    -0.51185793f, 0.57054591f, 0.00940442f, -0.09667504f, -0.36270675f, 0.42885131f, 0.21010651f, 0.33769605f, 
    -0.16418113f, -0.05394321f, -0.14778295f, -0.24744327f, 0.37642214f, 0.09625047f, -0.24866271f, 0.08165123f, 
    -0.13556227f, -0.07270306f, -0.04137357f, 0.32570857f, -0.26844802f, 0.48584762f, 0.09568480f, 0.05278340f, 
    0.22040321f, -0.14037107f, -0.19503327f, -0.04797423f, 0.28767288f, -0.33192205f, -0.30439469f, 0.09810979f, 
    0.12402195f, -0.26590580f, -0.04623010f, 0.13295163f, -0.30874521f, -0.08094689f, 0.03585679f, -0.04179319f, 
    0.25249070f, 0.04543266f, -0.15916660f, -0.05665580f, -0.11294407f, -0.27579838f, 1.01950920f, 0.09088960f, 
    -0.25713491f, -0.35278624f, -1.10576069f, 0.66253227f, -0.04611210f, 0.12348425f, -0.24499749f, -0.03273265f, 
    0.13697523f, -0.08739847f, -0.16259937f, 0.36074159f, -0.25967109f, -0.03161596f, 0.17955439f, 0.23722085f, 
    -0.11763509f, -0.32143351f, 0.05810132f, -0.06960132f, -0.32860452f, -0.02250756f, 0.02733260f, 0.39416930f, 
    0.12334717f, -0.82973421f, -0.70433122f, -0.69593799f, 0.25636846f, 0.44997841f, 0.38496846f, 0.38505527f, 
    -0.12076048f, -0.00229050f, -0.12586564f, 0.03795701f, -0.04347404f, -0.02669520f, -0.25033596f, -0.34381536f, 
    0.15811451f, -0.01649036f, 0.31334123f, -0.16544428f, -0.08404452f, 0.36026892f, -0.12819116f, 0.05245458f, 
    -0.92248785f, -0.57309884f, -0.13195744f, -0.45748675f, -0.80336815f, 0.32825643f, 0.31436720f, 0.04056079f, 
    0.06093635f, 0.10985597f, -0.19372605f, -0.13238607f, 0.00691211f, 0.29990044f, -0.00251778f, -0.05731893f, 
    -0.30785525f, -0.22195107f, -0.38738555f, -0.28116161f, -0.13512044f, 0.05158338f, 0.18966515f, 0.03242435f, 
    -0.24985817f, -1.21434760f, 0.41780680f, -0.20125395f, -0.29301223f, 0.31441885f, -0.09987578f, -0.00496063f, 
    -0.04246065f, 0.70781946f, 0.39395958f, -0.06760497f, -0.28524658f, -0.22822043f, -0.20680130f, 0.15336199f, 
    0.36917624f, -0.07773417f, 0.13819264f, -0.18661429f, 0.18849237f, -0.10335419f, -0.11802817f, 0.15912573f, 
    -0.04785050f, 0.02231735f, -0.72416019f, -0.72049773f, 0.34132123f, 0.64076287f, 0.49335381f, 0.64893740f, 
    0.47121695f, -0.51504838f, -0.50070542f, -0.18769646f, -0.11084118f, 0.04351602f, -0.18023705f, -0.03775385f, 
    -0.23799187f, 0.00295613f, -0.20424636f, 0.08120735f, -0.01684061f, -0.00452746f, -0.19972236f, 0.14230323f, 
    0.00124260f, 0.06842503f, -0.11658738f, 0.50422680f, -0.11583667f, 0.13271064f, 0.20665851f, -0.12949538f, 
    0.48643494f, 0.06836367f, -0.14649430f, -0.36369562f, -0.46062329f, -0.13253589f, -0.07617927f, 0.25723088f, 
    -0.02050287f, -0.18799448f, -0.09425899f, -0.33854979f, 0.26443687f, 0.26565316f, -0.18166482f, -0.04211525f, 
    -0.10441974f, 0.32799020f, -0.24966758f, 0.10668747f, -0.59739953f, 0.00943894f, 0.07956006f, -0.35767832f, 
    -0.13589120f, -0.31111819f, 0.10052066f, 0.21591710f, 0.44995910f, 0.37014556f, 0.20956247f, 0.14491007f, 
    -0.26714849f, -0.25193444f, -0.10781424f, -0.18668407f, -0.06847598f, 0.13048069f, -0.01256070f, 0.00384940f, 
    0.18494579f, 0.39107376f, 0.39749199f, -0.04246766f, -0.24460867f, -0.73413396f, -0.48529917f, -0.18632966f, 
    0.02986239f, 0.36858261f, 0.54691672f, 0.37747717f, -0.38969386f, 0.04674746f, 0.64208335f, 0.13601388f, 
    0.25311288f, -0.24049999f, -0.04354628f, -0.30950633f, -0.32351616f, 0.12424444f, 0.13559180f, -0.14716469f, 
    0.06561191f, -0.04489262f, 0.09591376f, -0.05391896f, 0.23730223f, -0.13065819f, -0.60037279f, -0.54105920f, 
    -0.66078919f, -0.22058250f, -0.53841203f, 0.11766563f, 0.13050076f, 0.31721693f, 0.40135440f, 0.33411890f, 
    0.09889100f, 0.16224670f, -0.06781724f, 0.30614692f, -0.28699145f, -0.13591836f, 0.04826370f, -0.13339105f, 
    -0.03099423f, 0.20014594f, -0.21628994f, -0.26937196f, -0.00230790f, 0.06992243f, -0.38429195f, -0.41272879f, 
    -0.00284640f, 0.45997930f, 0.67925364f, 0.34613484f, -0.43179491f, -0.32243055f, -0.24250998f, -0.16299571f, 
    -0.12307612f, -0.33098200f, -0.00220778f, -0.06076140f, 0.12278106f, -0.17574367f, 0.05522471f, 0.20341222f, 
    0.12494761f, -0.00538121f, 0.29817495f, -0.16874515f, -0.16481718f, -0.20526733f, -0.04243306f, -0.00830062f, 
    -0.59355158f, -0.61271250f, -0.48425591f, -0.36046195f, 0.23057704f, -0.64985907f, -0.70205927f, 0.26728812f, 
    -0.06668083f, -0.53863305f, 0.12142354f, 0.35259733f, 0.20622675f, 0.02915240f, -0.50869489f, -0.11469379f, 
    -0.18178482f, -0.30283031f, -0.29718485f, 0.05887608f, -0.05428114f, 0.10587699f, -0.11716460f, -0.42136109f, 
    0.59371948f, 0.02163860f, -0.31686684f, 0.30415860f, 0.07797068f, -0.21051782f, 0.26465476f, 0.18297021f, 
    -0.37046185f, -0.18036410f, 0.13897726f, -0.00037920f, -0.31789798f, -0.20117538f, -0.06493826f, 0.35698488f, 
    -0.07618413f, -0.49783230f, -0.11899529f, 0.37083441f, 0.20882198f, -0.06776275f, 0.12802689f, -0.24800934f, 
    0.02586426f, 0.24357992f, 0.30645400f, 0.61001426f, 0.23398668f, -0.18932797f, -0.26077455f, -0.24154131f, 
    -0.16556112f, -0.10634666f, -0.06573329f, -0.18282796f, 0.17617272f, 0.17497715f, 0.13981384f, -0.09476174f, 
    -0.13374725f, -0.06976367f, -0.09567703f, 0.16338895f, -0.19586432f, 0.03789523f, 0.22308794f, 0.02697106f, 
    -0.28949612f, -0.16701539f, -0.24819812f, 0.23153408f, 0.02610822f, -0.17311172f, 0.09477523f, -0.08265063f, 
    0.17519185f, -0.27553162f, -0.09042589f, 0.28576869f, -0.15610594f, 0.28145850f, -0.21601336f, -0.24924034f, 
    0.12914579f, 0.10024072f, -0.40011501f, -0.02790074f, 0.25335565f, -0.02407569f, 0.06573166f, 0.05669050f, 
    0.07994734f, 0.18475048f, -0.18141694f, 0.02487764f, 0.98942816f, -0.42309937f, -0.65676051f, 0.10721870f, 
    -0.04483781f, 0.13159589f, 0.37838110f, -0.01101427f, -0.24167302f, 0.09950235f, -0.38670149f, 0.08830781f, 
    -0.05274075f, -0.41148958f, 0.17039990f, 0.22663315f, -0.02805350f, -0.19526023f, -0.26103160f, -0.16462220f, 
    -0.33556086f, -0.36644441f, -0.35099289f, -0.42237291f, -0.38046691f, -0.09640448f, -0.13196556f, -0.38114089f, 
    -0.27655387f, -0.23346882f, -0.34147158f, -0.04858084f, 0.18811858f, -0.73388517f, -0.78069139f, 0.07459120f, 
    -0.00141160f, -0.12671044f, 0.48017228f, 0.48843020f, -0.05427888f, -0.52185178f, -0.38077706f, -0.49748608f, 
    -0.23666261f, -0.06189585f, -0.26111102f, -0.03362563f, -0.03066765f, -0.29170275f, 0.56107527f, -0.12333415f, 
    -0.19886592f, 0.15392977f, -0.70748478f, -0.11752056f, -0.07613342f, 0.01551683f, 0.25419557f, 0.23451521f, 
    -0.34897289f, 0.25743067f, 0.10911493f, -0.17407972f, -0.27320039f, 0.00450992f, -0.12589468f, 0.07141148f, 
    -0.23466371f, 0.10585830f, -0.12805791f, -0.40908992f, -0.12814581f, -0.29148188f, -0.57577735f, 0.27439603f, 
    -0.18695696f, 0.06497763f, -0.10803464f, 0.16555242f, 0.12718581f, 0.17140563f, 0.23214741f, 0.03239699f, 
    -0.03733031f, -0.19451879f, -0.25227755f, -0.05563796f, 0.32668319f, 0.16367523f, -0.08385346f, -0.02239569f, 
    -0.03234492f, 0.00960507f, -0.04689833f, 0.35707679f, 0.05247413f, -0.03994483f, -0.24221809f, -0.25998530f, 
    0.02879195f, 0.48530394f, 0.35554561f, -0.19767067f, -0.34396023f, 0.18472275f, 0.32275510f, -0.27439192f, 
    0.00793163f, 0.14603910f, 0.12058728f, 0.17517978f, -0.06671243f, -0.26402593f, -0.18251453f, -0.12979238f, 
    -0.04693973f, 0.09769813f, -0.17387302f, -0.05799172f, -0.10960109f, 0.14592817f, 0.43383154f, 0.05195438f, 
    -0.44587174f, 0.99653119f, -0.66888678f, -0.23612976f, -0.24154039f, -0.41813299f, -0.67529750f, -0.49111944f, 
    0.08098374f, 0.32189617f, 0.14691396f, 0.20050357f, 0.22320054f, -0.18619679f, -0.23095654f, 0.01832158f, 
    -0.13065277f, -0.21333082f, -0.26137599f, -0.14832534f, -0.40489542f, -0.10425328f, -0.09827004f, -0.08618564f, 
    -0.38696879f, -0.15293543f, 0.36511287f, -0.74204051f, -0.37498343f, 0.24818958f, 0.39280635f, 0.05789430f, 
    0.36339810f, 0.03242724f, -0.21120487f, -0.27886072f, -0.16009520f, -0.02766087f, 0.28892118f, 0.04536470f, 
    0.29928565f, -0.14428924f, -0.19217640f, -0.05942008f, -0.20509239f, -0.14785737f, 0.07006403f, 0.08330207f, 
    0.31945980f, 0.10291578f, 0.02235661f, 0.46521434f, -0.40287217f, 0.27630582f, -0.09334687f, -0.59604478f, 
    -1.12914872f, -0.77828008f, -0.36239973f, -0.05696084f, 0.12154789f, 0.43563718f, 0.00983747f, 0.25295737f, 
    0.27654389f, -0.01910267f, -0.33106095f, -0.21317975f, -0.21421875f, 0.20134382f, -0.74908090f, -0.16799760f, 
    -0.11160892f, 0.10567649f, -0.11831633f, -0.18455406f, -0.34605172f, 0.35174641f, 0.37786925f, -0.59418803f, 
    -0.61752707f, -0.09783239f, -0.35852662f, -0.09735034f, -0.31418806f, 0.06012744f, 0.42043692f, 0.13507429f, 
    0.41618836f, 0.25504142f, 0.23968773f, 0.00072893f, 0.15560918f, 0.04006032f, -0.20577368f, -0.12650253f, 
    0.18995978f, 0.14061595f, -0.17031157f, -0.24644397f, -0.20077367f, 0.37857038f, 0.34270871f, 0.46463859f, 
    0.38103282f, 0.16288340f, -0.23209247f, -0.34728587f, -0.09088504f, -0.43254590f, -0.39752463f, 0.16133536f, 
    -0.22407310f, -0.11849286f, -0.05044645f, 0.29158828f, 0.11415780f, 0.23559724f, -0.28854331f, -0.31985596f, 
    0.25658551f, -0.10182524f, 0.04478897f, 0.08144400f, 0.05683796f, -0.16447853f, -0.11085669f, 0.63223088f, 
    -0.46459344f, -0.21112764f, 0.01525769f, -0.16796385f, 0.45140848f, -0.31445068f, -0.40141761f, -0.08577818f, 
    -0.04878775f, -0.00025602f, -0.06426924f, -0.26354975f, 0.20720394f, 0.19124857f, -0.17469481f, 0.16729921f, 
    -0.21855503f, -0.08420257f, -0.02696781f, 0.12259148f, 0.13722655f, 0.03295376f, 0.25819063f, 0.05009455f, 
    -0.44967526f, 0.23026711f, 0.08952840f, -0.10464359f, 0.15859523f, 0.47136173f, -0.05022212f, -0.55643231f, 
    0.23506889f, -0.01759154f, 0.05184645f, -0.03731703f, -0.19241659f, -0.04007204f, 0.08071452f, 0.06421302f, 
    -0.12834977f, 0.01666030f, 0.10228564f, -0.02498060f, -0.09061219f, -0.01076225f, -0.12713957f, 0.00951493f, 
    -0.41591865f, -0.36911607f, -0.35355273f, -0.22446361f, -0.04254293f, 0.04944640f, -0.37180176f, -0.62215471f, 
    -0.25502574f, -0.37985364f, 0.04326164f, 0.44654751f, -0.15383290f, -0.19362304f, 0.38314098f, 0.12541865f, 
    -0.15094176f, -0.12028988f, 0.01925701f, -0.00966768f, 0.15014869f, 0.22045445f, 0.18285936f, 0.20316994f, 
    0.10711750f, -0.51335877f, -0.33255982f, -0.40125558f, -0.47385910f, -0.30977029f, -0.34110662f, -0.18192907f, 
    0.02777591f, 0.09383550f, 0.37599283f, 0.23935689f, 0.00574992f, 0.45640382f, -0.36601266f, -0.15645111f, 
    -0.03502160f, 0.07944191f, 0.02971058f, 0.06760184f, 0.38751826f, 0.17161334f, 0.13602509f, -0.31740323f, 
    0.18073946f, -0.27479842f, -0.29958734f, 0.06588145f, 0.34913677f, -0.10770188f, 0.03611480f, -0.04252741f, 
    0.21230619f, -0.16847923f, -0.13422813f, -0.04648241f, 0.14278838f, 0.02590788f, -0.10135993f, -0.06679379f, 
    -0.08331510f, 0.21506265f, 0.09508796f, -0.09590252f, -0.35092899f, 0.31685910f, -0.24358478f, -0.09703784f, 
    0.24045378f, 0.03455419f, -0.01203076f, -1.05357504f, -0.33534569f, -0.54517561f, -0.77528822f, -0.54256105f, 
    0.46002963f, 0.26871455f, -0.36156794f, -0.11141697f, 0.57393366f, -0.27648613f, -0.41987026f, -0.27511701f, 
    -0.18194076f, -0.05791816f, 0.39708808f, 0.22267039f, -0.16836508f, 0.07830152f, -0.07707096f, 0.01576158f, 
    -0.15704097f, -0.03747447f, -0.11658682f, -0.13506863f, -0.51878113f, -0.28981164f, -0.09160802f, -0.35139927f, 
    -0.20665827f, -0.17346187f, -0.52799398f, -0.70514715f, -0.40260899f, -0.35231647f, 0.19364715f, 0.25447047f, 
    -0.14233480f, -0.36325675f, -0.32098302f, 0.08450973f, -0.10463654f, 0.04659569f, 0.15980797f, 0.03508359f, 
    -0.14127970f, -0.04734928f, -0.25368023f, -0.21937598f, -0.22844246f, -0.32904774f, 0.14305055f, -0.30570748f, 
    -0.26218274f, 0.25520512f, 0.12549360f, -0.12520830f, 0.09676096f, -0.08188529f, -0.24397819f, 0.39627144f, 
    0.19643202f, -0.25571907f, -0.31332946f, 0.26048425f, -0.17583339f, 0.23722935f, -0.29562664f, -0.04336094f, 
    -0.28320214f, 0.25586727f, 0.08768201f, 0.27656171f, 0.16482000f, 0.09182077f, 0.27020496f, -0.00529700f, 
    -0.07856397f, 0.46445465f, 0.30518410f, 0.47051910f, 0.24341659f, 0.38629130f, -0.11686303f, -0.02460426f, 
    0.18123043f, 0.21088171f, 0.00135045f, -0.04267573f, -0.27658567f, 0.09460304f, -0.20086606f, 0.00190794f, 
    -0.17505863f, -0.11016500f, -0.11141292f, 0.37437853f, -0.00291005f, -0.11103774f, -0.07112467f, -0.06917942f, 
    0.22979343f, 0.16949713f, 0.15919122f, 0.02613331f, 0.28018355f, 0.19411671f, -0.13454466f, -0.04213257f, 
    0.21957333f, 0.25277874f, -0.15978234f, -0.11606167f, -0.07960384f, 0.07982641f, 0.20655115f, 0.01800772f, 
    0.18112914f, 0.09046661f, -0.00414673f, -0.02345996f, 0.01106881f, -0.19298188f, 0.08226668f, -0.08653796f, 
    -0.56113684f, 0.04734707f, -0.14118864f, 0.69811964f, 0.00950081f, 0.39891329f, -0.66382247f, 0.04136044f, 
    0.56537777f, -0.08961070f, -0.18808280f, 0.04645776f, 0.24610864f, 0.08946198f, -0.31800836f, -0.02502945f, 
    0.01437959f, 0.15962645f, -0.38764545f, 0.23989056f, -0.27067372f, 0.10327254f, 0.26131314f, 0.10972406f, 
    -0.27881092f, 0.05958990f, -0.29110962f, -0.47138140f, 0.19750541f, 0.46902931f, -0.14343065f, -0.53086197f, 
    -0.27174860f, 0.62779486f, 0.08045653f, -0.21783276f, -0.23183283f, 0.06391228f, 0.22073032f, -0.20065039f, 
    0.06012477f, -0.15503548f, 0.21250388f, -0.18826886f, -0.36064860f, -0.01363862f, 0.11445899f, -0.25298938f, 
    -0.16273379f, 0.19776511f, 0.81950045f, 0.22146359f, -0.37219515f, -0.62952793f, -0.66896719f, -0.00514674f, 
    -0.02265927f, 0.48697969f, -0.12844411f, 0.02329235f, 0.17511883f, -0.17253461f, 0.45847452f, -0.07247826f, 
    -0.05218981f, -0.01962722f, 0.06133237f, -0.39725307f, 0.13657339f, -0.22797914f, 0.02889248f, -0.11583989f, 
    0.15659676f, 0.08713592f, 0.29902831f, -0.83072495f, -0.03531199f, -0.57947093f, -0.34770268f, -0.36729532f, 
    0.43981132f, 0.45032609f, -0.08541806f, -0.11302853f, 0.41767785f, 0.13190287f, 0.23720910f, 0.15202750f, 
    -0.05328777f, -0.01365540f, 0.04010514f, -0.23927028f, -0.12869725f, 0.17791227f, 0.10331441f, 0.13950634f, 
    0.03338830f, 0.04009311f, -0.06077662f, 0.04488458f, 0.56360573f, 0.23745978f, 0.07600331f, 0.04038790f, 
    -0.09054655f, -0.20138992f, -0.19865228f, -0.13463557f, -0.02114991f, -0.29540220f, 0.08332484f, -0.02915834f, 
    0.20156507f, -0.28608903f, -0.10174908f, 0.05229639f, -0.04899251f, 0.15501715f, 0.22379923f, -0.16785669f, 
    -0.06925065f, -0.09516089f, -0.26521096f, -0.18734065f, -0.03129828f, -0.10714339f, 0.00065864f, -0.44410950f, 
    -0.48691279f, -0.37889683f, -0.63823724f, -0.68261600f, -0.37859794f, -0.44419804f, -0.56284618f, 0.32743382f, 
    0.08706595f, 0.00819677f, 0.35943019f, 0.04128935f, -0.05465909f, -0.13528839f, -0.01194357f, 0.17401585f, 
    0.10521714f, -0.03910204f, 0.01994990f, 0.12444606f, 0.07453853f, 0.20836641f, -0.91212070f, 0.50898135f, 
    0.02716701f, -0.39916676f, -0.11051192f, 0.45055145f, 0.10569228f, 0.09095117f, 0.21039031f, -0.36375645f, 
    -0.08479286f, 0.14033197f, 0.26388592f, -0.14881094f, 0.00057528f, 0.16413738f, 0.08372165f, -0.14281766f, 
    0.18098448f, -0.09349003f, 0.02158966f, 0.19032840f, -0.14459471f, -0.24963200f, -0.08095620f, 0.40395698f, 
    0.20030090f, -0.49593994f, -0.20504367f, 0.45822790f, -0.57201505f, 0.02233395f, 0.32312781f, -0.03432939f, 
    0.18654658f, -0.32321459f, -0.00994553f, 0.38840717f, -0.45271412f, -0.26211929f, 0.14364332f, -0.07178734f, 
    -0.14979927f, 0.26311064f, -0.13121551f, -0.24152777f, -0.13475552f, 0.19450909f, 0.08185554f, -0.06337983f, 
    -0.82748747f, -0.27262756f, 0.53303015f, 0.21467713f, 0.18369707f, 0.02066802f, 0.16486603f, -0.03309974f, 
    0.08089931f, -0.29663017f, -0.13350078f, 0.04253605f, -0.37827045f, 0.46401060f, -0.02099008f, -0.24120235f, 
    -0.05173095f, 0.14746384f, -0.10074976f, -0.07998755f, 0.08378137f, -0.01302727f, -0.00817498f, 0.01577886f, 
    0.16708109f, 0.15287304f, 0.63088578f, 0.51081252f, -0.37899372f, 0.12943457f, -0.36749431f, -0.15277846f, 
    -0.13001570f, -0.17826736f, -0.46838531f, -0.05070131f, 0.23058677f, 0.04401504f, -0.07282443f, 0.33341530f, 
    -0.05039863f, -0.01436030f, -0.16801672f, 0.04208220f, 0.24095577f, -0.23805524f, 0.36828107f, 0.06486173f, 
    -0.27421460f, 0.17640311f, -0.00877799f, -0.59400177f, 0.39421988f, 0.09305798f, -0.01948711f, -0.21044604f, 
    -0.34114397f, -0.50361311f, -0.19452088f, -0.21043584f, 0.01120864f, 0.16212273f, 0.07187013f, -0.24794585f, 
    0.35457644f, 0.10979299f, 0.08712814f, -0.16365695f, -0.25912648f, 0.11827080f, -0.06597035f, -0.07456674f, 
    -0.07754003f, 0.03275132f, -0.11047147f, 0.38793463f, 0.11131634f, 0.28383616f, -0.24754146f, -0.23375832f, 
    -0.10007563f, -0.14388375f, 0.28836668f, -0.03963594f, -0.22246538f, -0.47855520f, 0.07247948f, -0.15476634f, 
    -0.03723741f, 0.42144099f, 0.19940129f, 0.14867690f, 0.11976201f, -0.41389149f, 0.04372361f, 0.01831253f, 
    -0.29271242f, -0.26735449f, 0.02510851f, 0.11458603f, -0.67708766f, -0.23282132f, -0.59752697f, -0.43498322f, 
    0.02313985f, 0.06648120f, 0.35687470f, 0.18394278f, 0.41747150f, 0.44398579f, 0.12693542f, -0.09264754f, 
    -0.21051908f, 0.25279686f, -0.31232810f, -0.07284106f, -0.12080305f, -0.46389359f, 0.24544902f, -0.18685083f, 
    0.15976585f, -0.05043382f, -0.09936838f, 0.35966304f, 0.24075031f, 0.50509006f, -0.38412520f, -0.16864163f, 
    0.05625391f, -0.00467872f, 0.27868775f, 0.11893642f, 0.03444012f, 0.04714590f, 0.11866196f, 0.25572786f, 
    0.13394164f, -0.07502618f, -0.27493346f, -0.06016838f, -0.05036056f, -0.14991634f, -0.04996336f, -0.13763015f, 
    0.02117929f, -0.23756522f, 0.19426079f, 0.12705053f, -0.25329301f, 0.24465570f, -0.28153822f, -0.10213525f, 
    0.27340358f, 0.28771609f, 0.10786358f, 0.22449984f, -0.71320593f, -0.54727799f, -0.05514529f, -0.32791212f, 
    -0.29587525f, 0.11085789f, -0.15313549f, -0.38400418f, -0.28259644f, -0.21897075f, -0.13046595f, -0.14946803f, 
    -0.22846140f, -0.28212088f, -0.02891829f, -0.10260566f, -0.14115798f, -0.09292477f, -0.05958027f, -0.65434849f, 
    0.00212514f, 0.50305349f, 0.04739970f, 0.47374323f, -0.05364827f, -0.39171302f, -0.08822375f, -0.46750641f, 
    0.47418109f, 0.09691207f, -0.43234423f, -0.09601932f, -0.11181543f, 0.24703737f, -0.08233433f, -0.25951138f, 
    -0.04988243f, 0.09622682f, 0.43348363f, -0.03544937f, -0.01047456f, -0.32152647f, 0.12040925f, -0.37971073f, 
    0.96799546f, -0.43762940f, -0.81049466f, -0.22966801f, -0.23479249f, 0.62153512f, 0.13382985f, 0.16503447f, 
    -0.04389067f, -0.18745555f, 0.03431223f, -0.15682232f, 0.01486984f, 0.04670854f, 0.14606956f, 0.12333990f, 
    -0.06551829f, 0.10229973f, -0.20030849f, -0.26619235f, 0.15126634f, 0.04624639f, -0.18697293f, 0.23265414f, 
    0.16023700f, 0.07483031f, 0.50790381f, 0.09645204f, -0.24048656f, -0.19752802f, -0.06649496f, 0.12717310f, 
    0.37247133f, -0.20201626f, -0.41430318f, -0.26101544f, -0.37434539f, 0.19986190f, 0.06856632f, -0.19942123f, 
    0.33708441f, 0.06465107f, -0.00825470f, -0.09258289f, -0.22981310f, -0.10176563f, 0.10052911f, 0.23562147f, 
    0.13380338f, 0.00486469f, -0.67660826f, -0.60143864f, -0.39591089f, -0.02469298f, -0.03700765f, -0.35619590f, 
    -0.26339906f, -0.24826403f, -0.63439381f, -0.68066096f, -0.24282053f, 0.21786390f, -0.24660121f, 0.20138931f, 
    -0.43727884f, -0.11540456f, -0.13586822f, 0.02134578f, 0.10518295f, -0.27241224f, -0.27039161f, -0.03611686f, 
    -0.37266722f, -0.05627805f, 0.23377447f, -0.47600785f, -0.84758228f, -0.34141481f, 0.28376824f, 0.10880889f, 
    -0.13321772f, 0.12845249f, 0.01363873f, 0.27147231f, -0.05126511f, 0.10690642f, -0.11236931f, -0.31745791f, 
    0.23690809f, -0.17705514f, -0.15920733f, -0.15490761f, -0.16925195f, -0.09375433f, -0.00428647f, -0.33786845f, 
    -0.09218089f, -0.16777542f, -0.43875286f, -0.37887233f, 0.04549990f, -0.72174257f, -0.68360513f, -0.48707330f, 
    -0.62365746f, 0.44885927f, 0.57252824f, -0.37260166f, -0.06693168f, 0.02781496f, 0.10850202f, -0.07795854f, 
    -0.36713436f, -0.28352037f, -0.36316940f, 0.07359194f, -0.31251091f, -0.18555982f, 0.19238436f, 0.06038079f, 
    -0.23410065f, -0.18842751f, 0.28518164f, -0.04886962f, -0.11268695f, 0.16154666f, -0.49223712f, -0.76501912f, 
    0.33734953f, 0.42180768f, 0.51712078f, -0.16436443f, -0.32022420f, -0.37134725f, 0.37737963f, 0.18985774f, 
    -0.23295039f, -0.12342691f, 0.25866872f, 0.10393627f, 0.07703259f, -0.23677798f, 0.57529861f, -0.00103052f, 
    -0.51485205f, -0.09436972f, -0.15391754f, 0.05802829f, -0.11885116f, 0.33365452f, 0.01606551f, 0.39437431f, 
    0.25742796f, -0.06553768f, 0.21901777f, -0.06101839f, 0.11081767f, -0.12058683f, 0.06661376f, -0.29239476f, 
    -0.17327245f, -0.13015948f, -0.05518021f, 0.19575962f, -0.04474556f, -0.16270965f, -0.14108430f, 0.01410585f, 
    0.01874696f, 0.08303665f, -0.03166758f, -0.19981356f, -0.20569746f, -0.36251804f, -0.58244944f, 0.31445098f, 
    0.01079222f, -0.34606421f, -0.43446180f, -0.62756085f, 0.28895730f, 0.33290243f, 0.19351821f, -0.22934279f, 
    -0.50585067f, 0.27447236f, 0.37979990f, -0.17173007f, -0.18065535f, -0.29813936f, -0.46069327f, -0.09767959f, 
    -0.16265596f, -0.22120616f, -0.07895885f, 0.05996343f, -0.17763908f, 0.02734919f, 0.37383148f, 0.37220556f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19756106f, -0.17824171f, 0.15436435f, -0.09688055f, 0.12883557f, -0.03735802f, 0.27968973f, 0.21991688f, 
    -0.11966836f, 0.09772761f, 0.33715281f, 0.31811199f, 0.08997402f, 0.04165627f, 0.00000184f, -0.06436348f, 
    0.11195357f, 0.32544884f, 0.04976791f, 0.25667778f, -0.13797915f, -0.06465040f, -0.10479698f, 0.07131579f, 
    0.16824993f, -0.00551750f, -0.00306399f, 0.00500080f, 0.15151346f, 0.14940271f, 0.04359968f, 0.08688854f, 
    -0.19768544f, -0.16955890f, 0.06737202f, -0.43361306f, -0.41428310f, 0.05312953f, -0.11740568f, -0.16732803f, 
    0.21791290f, 0.32045987f, 0.28350946f, 0.04576132f, -0.12959278f, -0.03374325f, -0.03807340f, 0.29213414f, 
    0.23998468f, 0.02691560f, 0.12063868f, 0.13848293f, 0.07539445f, 0.37534085f, -0.19283175f, 0.04501310f, 
    0.08394192f, 0.05734754f, -0.31384751f, 0.13473363f, -0.05295746f, 0.36201653f, -0.15364257f, 0.37343594f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23051873f, -0.39282036f, 0.03283219f, -0.09513763f, -0.01957949f, -0.11386622f, 0.07784125f, 0.07155697f, 
    -0.03414269f, -0.03290839f, -0.29974279f, -0.06621327f, 0.19678411f, 0.23694521f, -0.33999348f, -0.11794522f, 
    -0.06629781f, -0.03363178f, 0.01976185f, -0.00896510f, -0.11266949f, -0.10977016f, 0.05917543f, 0.06962094f, 
    0.08408154f, 0.00655275f, 0.21335605f, -0.22871259f, -0.00113202f, 0.02961847f, 0.01684323f, 0.00691971f, 
    0.07432491f, -0.09480488f, -0.08333220f, -0.02039220f, 0.00935187f, -0.23951270f, -0.02857864f, -0.10664249f, 
    0.02821786f, -0.02856600f, 0.02494180f, -0.02293644f, -0.08698794f, -0.06075301f, 0.14503118f, 0.14125422f, 
    0.16722548f, -0.11891322f, -0.22260092f, -0.06286047f, -0.02884751f, 0.04953494f, -0.01943968f, -0.02530684f, 
    0.00241233f, 0.00330640f, -0.03144355f, -0.13534556f, -0.18423510f, -0.24365629f, 0.06905340f, -0.07162523f, 
    -0.05886153f, -0.01151855f, 0.00106666f, 0.07858349f, -0.05040901f, 0.05160075f, 0.07523656f, -0.00801560f, 
    -0.03969653f, -0.53052098f, -0.58049226f, 0.07767759f, -0.00176578f, 0.00901573f, -0.14756843f, -0.02028662f, 
    -0.15532167f, 0.09301262f, 0.00060361f, 0.06383350f, 0.03205767f, -0.38825476f, -0.25148946f, 0.12883939f, 
    0.08271707f, 0.02503574f, -0.19057994f, 0.14474878f, 0.05078721f, -0.11014125f, -0.09665504f, -0.02861160f, 
    0.14890198f, 0.00438953f, -0.04739258f, -0.06155637f, 0.13919452f, 0.14980946f, -0.08261303f, -0.01414269f, 
    -0.16245511f, -0.12545879f, -0.08362642f, 0.07037054f, -0.26449355f, 0.16177075f, 0.20274612f, -0.21325423f, 
    -0.02481763f, 0.15927033f, 0.00611050f, 0.15217327f, 0.00464617f, 0.08284004f, 0.12430578f, -0.04667963f, 
    0.64159417f, 0.01209268f, -0.12595065f, -0.34815422f, -0.06034243f, -0.16912977f, 0.13924766f, -0.11078453f, 
    -0.08902200f, -0.12781522f, 0.02444624f, -0.04781532f, -0.18490265f, -0.45713475f, -0.23301513f, -0.02481996f, 
    -0.00202374f, -0.02633410f, 0.02864888f, 0.02522679f, -0.04314349f, -0.00480499f, -0.00790458f, 0.05719817f, 
    -0.06336747f, -0.05166889f, 0.08335394f, -0.15213281f, -0.10584761f, 0.04698722f, 0.01584584f, 0.01322808f, 
    -0.04147923f, -0.01941189f, -0.11140776f, 0.05269200f, 0.21513842f, 0.07983247f, -0.05890707f, -0.06198652f, 
    0.01649016f, 0.03080913f, 0.06714127f, 0.00889801f, -0.00151243f, 0.04028194f, -0.11793822f, -0.26911676f, 
    0.20122254f, 0.04164523f, 0.05659821f, 0.01090106f, 0.15339997f, 0.13042633f, 0.03704048f, -0.11360226f, 
    0.00890001f, 0.08313093f, 0.07803664f, -0.00013620f, 0.21471862f, 0.10731421f, 0.04240126f, -0.25458381f, 
    0.05194353f, -0.14101049f, -0.06505980f, 0.02706099f, 0.02809248f, -0.02591885f, 0.00911158f, 0.01411751f, 
    0.28205162f, 0.28117535f, 0.00182118f, -0.17219542f, 0.07666028f, 0.02870510f, 0.11308892f, 0.00690244f, 
    -0.05238187f, -0.11456432f, 0.02979486f, -0.00254692f, 0.04392345f, -0.03596511f, -0.07187654f, -0.05875160f, 
    -0.16297273f, -0.05606364f, 0.07922540f, -0.00590280f, -0.06148256f, -0.07134338f, 0.00637294f, 0.00653062f, 
    -0.10661057f, -0.05603937f, -0.12332352f, 0.11626343f, 0.00836247f, 0.06818812f, 0.00378732f, 0.01004929f, 
    -0.01320782f, 0.01570676f, 0.03564484f, 0.02432088f, -0.11919796f, -0.05998941f, -0.02229550f, -0.01827840f, 
    -0.24318047f, -0.04781611f, -0.00609708f, 0.09387042f, -0.04362892f, -0.00687152f, -0.05006592f, -0.03206308f, 
    -0.27932760f, -0.19821848f, -0.10185900f, 0.15738505f, -0.06368067f, 0.02156628f, -0.01332710f, -0.04615287f, 
    0.03730904f, 0.10580192f, -0.03402105f, 0.01828058f, 0.28786317f, 0.09553020f, -0.07495905f, -0.05808907f, 
    -0.11942119f, -0.08639999f, -0.10310318f, -0.02441850f, -0.06082278f, -0.05095065f, -0.09610096f, -0.10563587f, 
    -0.27062365f, -0.17157753f, 0.12718894f, 0.08038477f, 0.05304219f, -0.01477049f, -0.14764300f, -0.00429522f, 
    0.01510530f, 0.03476990f, 0.09468306f, 0.23240234f, -0.06887963f, -0.08126327f, -0.00168784f, 0.08398793f, 
    0.03469322f, -0.05563539f, 0.05801848f, 0.01778296f, -0.01873423f, 0.00406489f, -0.20823243f, -0.08127589f, 
    -0.27941540f, -0.58342355f, -0.20877141f, 0.01198899f, 0.05422693f, -0.07671822f, 0.06467754f, 0.08089833f, 
    -0.07408429f, 0.01940793f, -0.02713082f, 0.02438480f, 0.05625546f, 0.04380331f, 0.03016866f, -0.11543574f, 
    -0.02355481f, -0.12823884f, -0.06291657f, -0.05943381f, -0.18956466f, -0.00683395f, 0.01300427f, 0.15619110f, 
    -0.04502894f, 0.14512195f, -0.02196640f, 0.05839672f, 0.00683802f, 0.04206322f, 0.05845466f, -0.08260399f, 
    0.04928550f, -0.01402832f, -0.11202215f, -0.10331188f, 0.22294317f, 0.17653638f, 0.03971608f, -0.30880809f, 
    0.03883685f, -0.08089697f, -0.03068698f, 0.02026169f, -0.08497889f, -0.16581081f, -0.07430342f, -0.06723267f, 
    0.14351635f, 0.06718694f, -0.02242342f, -0.09740556f, -0.02782638f, 0.01315219f, -0.18017954f, -0.06776743f, 
    0.13523801f, -0.04751002f, 0.06889676f, 0.03569565f, -0.22974640f, -0.22633621f, 0.12089790f, -0.14675055f, 
    0.02768817f, -0.04983694f, 0.00235945f, -0.02087246f, 0.02980254f, -0.01956018f, 0.00871192f, 0.03457917f, 
    0.11424798f, 0.07846973f, -0.07431970f, 0.03759854f, 0.01047001f, -0.07956039f, 0.02243146f, -0.13555044f, 
    -0.05591388f, 0.03623169f, 0.01221859f, -0.02876319f, 0.09226909f, 0.00681972f, -0.04227348f, -0.03976107f, 
    -0.01063958f, -0.00362168f, 0.02669642f, 0.00680240f, -0.01126073f, -0.04166571f, 0.07888155f, -0.12460956f, 
    0.34257638f, 0.24583839f, -0.12840027f, -0.07609825f, -0.05429849f, -0.00911941f, -0.08351616f, 0.07503639f, 
    -0.06020622f, 0.01826742f, 0.01379532f, -0.03942694f, 0.27803040f, 0.27698129f, 0.11929603f, -0.14536718f, 
    0.11280330f, 0.08568981f, -0.05710848f, -0.04721856f, 0.00427524f, 0.01243384f, 0.11886986f, 0.03668594f, 
    -0.04876803f, -0.04230570f, -0.07152638f, -0.03392786f, 0.01532905f, -0.15655380f, 0.02136603f, 0.01644498f, 
    -0.07434759f, -0.00071817f, -0.06830326f, -0.06548470f, 0.30203798f, 0.21909219f, -0.09964868f, -0.12379038f, 
    0.14802338f, 0.30364704f, 0.13011524f, 0.18647958f, -0.01306682f, 0.08842863f, 0.05910645f, 0.00176064f, 
    0.32725462f, 0.34562895f, -0.10879994f, -0.09719398f, 0.14356138f, 0.23528300f, 0.15721872f, 0.11754376f, 
    0.02838992f, -0.00101122f, 0.02108419f, 0.02608922f, 0.16510816f, 0.05395656f, -0.06933969f, 0.00084764f, 
    -0.01696595f, 0.22022890f, -0.05534509f, -0.18376024f, -0.09200865f, -0.07430371f, -0.08976975f, -0.10213873f, 
    -0.11033297f, -0.13319631f, -0.02555494f, 0.06125603f, 0.03095951f, 0.03312359f, 0.07228828f, 0.02180964f, 
    0.01803725f, 0.05592608f, -0.07322355f, -0.06311058f, 0.00606606f, 0.06269872f, 0.04895546f, 0.06585227f, 
    0.05057204f, 0.00000759f, -0.01411543f, 0.02826750f, -0.24646892f, -0.24068992f, -0.03793917f, 0.09656166f, 
    -0.10200599f, -0.00584862f, 0.15118615f, -0.16450886f, -0.00950882f, 0.00807569f, -0.01652524f, 0.03003310f, 
    -0.13355377f, 0.04832397f, -0.02290478f, -0.25475004f, -0.11241202f, 0.09845417f, 0.06817750f, -0.19634286f, 
    -0.10276337f, -0.01455581f, 0.03968218f, -0.04099408f, 0.00477712f, -0.03883205f, -0.10251978f, -0.18554041f, 
    0.07272170f, -0.19913091f, -0.27211070f, 0.01395425f, 0.10095616f, -0.05555384f, -0.13870950f, -0.18427256f, 
    -0.11939076f, -0.21441543f, -0.19445793f, -0.06567454f, 0.16011375f, 0.03381357f, -0.14423653f, 0.02871051f, 
    0.07622448f, 0.08239411f, -0.02292761f, -0.03469163f, -0.00486782f, -0.07708570f, -0.00245202f, -0.02169783f, 
    -0.14750533f, -0.10326273f, -0.23859005f, 0.16476421f, -0.00389517f, -0.00418262f, -0.08032668f, -0.00434098f, 
    -0.02494376f, 0.05456654f, 0.01301147f, 0.09257348f, 0.27677837f, 0.18661773f, -0.18605037f, -0.16073875f, 
    0.04072798f, -0.05101203f, -0.11070956f, 0.12471456f, 0.01457122f, 0.02772639f, 0.03367146f, 0.00848394f, 
    0.05469680f, 0.13873708f, -0.07133308f, -0.00728682f, -0.11077597f, 0.19031636f, -0.12977222f, -0.03229677f, 
    -0.03266282f, 0.03100290f, 0.01012167f, -0.02166520f, -0.60354859f, 0.42260647f, -0.24925101f, 0.28098941f, 
    -0.03348264f, -0.02295325f, 0.01203477f, 0.04073450f, -0.03477678f, -0.14970616f, -0.01367428f, 0.03085324f, 
    0.12406556f, -0.15395802f, 0.12311626f, -0.27217242f, -0.13199608f, -0.07133923f, 0.09293026f, -0.00337949f, 
    -0.04758848f, -0.11360741f, -0.17199466f, -0.06945023f, 0.01226060f, -0.05101737f, -0.01352896f, 0.04501830f, 
    -0.10626695f, -0.13360514f, -0.03821142f, -0.05996280f, 0.03017746f, 0.03923452f, 0.01838076f, -0.04487839f, 
    0.21005502f, 0.11824943f, -0.09120131f, -0.28420958f, -0.01643884f, 0.02653231f, 0.03901833f, 0.02883523f, 
    0.00952556f, 0.06449574f, 0.01816846f, 0.03420555f, -0.18746549f, -0.09549220f, 0.10967699f, 0.01314939f, 
    -0.09713319f, 0.01021238f, -0.05830329f, -0.01499231f, 0.03658462f, -0.06877159f, 0.08376943f, -0.07670026f, 
    -0.21256779f, -0.02082249f, -0.06279427f, 0.02608342f, 0.12457097f, 0.10482393f, -0.01199391f, -0.01281942f, 
    0.09296329f, -0.00019331f, -0.10085902f, -0.15660019f, -0.23413239f, 0.01355073f, -0.31867325f, 0.11476448f, 
    -0.04267818f, -0.00276371f, 0.01693632f, -0.03346731f, -0.05873192f, -0.00797769f, -0.16926713f, -0.21169271f, 
    0.24294369f, 0.38988870f, -0.11810413f, -0.02112127f, -0.22125822f, -0.20594183f, -0.07287686f, -0.00142387f, 
    -0.01378777f, -0.02087016f, 0.01609460f, -0.04542681f, 0.24769422f, 0.22761744f, 0.01530646f, -0.26809004f, 
    -0.10849265f, -0.02484982f, -0.06196630f, -0.12539582f, -0.00537378f, -0.06622256f, -0.02084444f, -0.07070281f, 
    0.08255507f, -0.10914152f, -0.36583635f, 0.05857182f, 0.04502116f, -0.02623734f, -0.06075407f, -0.22126690f, 
    -0.20815870f, -0.07515980f, -0.08319238f, -0.04093456f, -0.19310412f, -0.09863909f, 0.08404893f, 0.02421942f, 
    -0.07629935f, -0.00329368f, 0.02950351f, 0.05701731f, -0.05108565f, 0.07132868f, 0.00323915f, -0.00154897f, 
    0.39305967f, 0.19364417f, -0.10101829f, -0.15666351f, 0.13014121f, 0.11338902f, 0.18963553f, 0.08855318f, 
    -0.01561720f, -0.06343121f, 0.02691657f, -0.03814705f, 0.22202203f, 0.00989170f, -0.05851433f, -0.09879897f, 
    0.01033996f, -0.01268078f, 0.05916963f, -0.06057686f, 0.01545189f, 0.04108282f, 0.03458684f, 0.10859788f, 
    0.27278185f, 0.05006083f, -0.16599044f, -0.04117527f, 0.11370502f, 0.07518826f, 0.09396415f, -0.00350629f, 
    0.00956003f, 0.01362424f, -0.11608770f, 0.00867100f, 0.09790222f, 0.19412880f, -0.25446993f, -0.08446453f, 
    -0.07691396f, 0.03404501f, 0.07872617f, -0.38041353f, 0.01994892f, -0.06772882f, -0.06168334f, 0.03042815f, 
    -0.06710956f, -0.04303001f, 0.03280058f, 0.10831374f, 0.05503230f, 0.04264156f, 0.04247876f, 0.01974094f, 
    -0.05552743f, -0.05680110f, 0.11665492f, 0.08536427f, 0.11929377f, -0.25604573f, -0.44861951f, -0.09017674f, 
    0.10654968f, -0.03339725f, -0.07933878f, -0.10538572f, -0.12073191f, -0.17612888f, -0.24104138f, -0.16121937f, 
    -0.03096682f, -0.21448983f, 0.15193476f, -0.10659476f, -0.03911837f, 0.02004848f, 0.10772970f, 0.09822416f, 
    0.07731324f, -0.22375947f, 0.10372037f, 0.10233333f, 0.36330220f, -0.05496793f, 0.26333416f, 0.05202800f, 
    -0.08424601f, 0.01594585f, -0.06973877f, 0.01028424f, 0.03959869f, -0.25620523f, -0.17917486f, 0.06487610f, 
    -0.17310137f, -0.01181465f, -0.03846919f, 0.08843062f, 0.00323215f, -0.00933266f, -0.01419748f, 0.04577249f, 
    -0.14730762f, 0.09480445f, 0.06699522f, 0.01711404f, 0.01668542f, 0.04158068f, 0.00611759f, -0.01934034f, 
    0.02066688f, -0.03981148f, -0.03053499f, 0.06424298f, 0.07349406f, 0.18450020f, -0.26454100f, -0.02177610f, 
    0.50972152f, -0.13371615f, -0.18063925f, -0.40764487f, -0.04366991f, -0.01339075f, -0.24560632f, -0.10373421f, 
    -0.05795667f, -0.10578216f, 0.08127326f, -0.16206621f, 0.21203293f, 0.09944189f, 0.08069039f, -0.20426574f, 
    0.03072670f, -0.11526625f, -0.05104439f, 0.00012647f, 0.02573266f, 0.00852774f, 0.00730493f, 0.05294384f, 
    0.52628857f, -0.33945301f, -0.06743827f, -0.24581954f, 0.00677508f, -0.07149795f, 0.00444503f, -0.02049100f, 
    0.05512209f, -0.04330830f, 0.02288063f, 0.08318168f, 0.12676021f, -0.04900034f, -0.15034877f, -0.15383214f, 
    -0.02527305f, -0.03522314f, 0.05132874f, -0.16841319f, 0.00228045f, 0.05414610f, -0.07268852f, -0.11454099f, 
    -0.00982094f, 0.06360696f, 0.22330542f, -0.02551209f, 0.07605095f, 0.11126930f, 0.01242680f, -0.00088550f, 
    0.02578537f, -0.00837001f, 0.15153478f, -0.11067993f, -0.68679291f, 0.20154636f, -0.04773521f, -0.12280622f, 
    0.12868591f, -0.02025181f, -0.10632961f, -0.12266498f, 0.03758768f, 0.02285481f, -0.26621422f, -0.10048076f, 
    0.37005907f, -0.28685915f, 0.15084906f, 0.10433894f, -0.08736273f, 0.00759886f, 0.04058159f, 0.13578583f, 
    -0.01241361f, 0.10406034f, 0.04913007f, -0.05434461f, 0.42259264f, 0.06618763f, 0.16924511f, 0.04561102f, 
    -0.06416283f, 0.03408058f, -0.16244330f, -0.03006941f, 0.00034906f, 0.00165610f, 0.08520792f, 0.02501879f, 
    -0.12208944f, 0.02230742f, 0.08127534f, -0.18596794f, 0.14524695f, 0.03211388f, -0.10764805f, 0.03071244f, 
    -0.19410409f, -0.01099254f, -0.09071040f, 0.01862178f, 0.18084349f, 0.07078097f, -0.14397970f, -0.02324908f, 
    -0.07588679f, -0.02305406f, -0.04203668f, 0.04332101f, 0.03958016f, -0.03334488f, -0.10375771f, 0.10083261f, 
    0.04981976f, -0.05445698f, -0.11547026f, -0.03144483f, -0.05354854f, 0.01189671f, 0.11594777f, -0.28152701f, 
    0.13116829f, -0.14625785f, 0.03664867f, -0.08532264f, -0.17719406f, 0.16753258f, -0.16778353f, -0.23508877f, 
    0.03356515f, 0.03649997f, -0.00094635f, -0.03437175f, -0.02184056f, 0.02431393f, -0.01953467f, -0.00880726f, 
    -0.37437785f, 0.10954715f, -0.14338188f, 0.12372203f, 0.07238077f, 0.06660134f, 0.10585136f, -0.15472901f, 
    -0.06438464f, 0.05607457f, 0.01852885f, 0.09241569f, 0.02796344f, -0.04836363f, -0.04772888f, 0.05092353f, 
    -0.10210413f, 0.04746736f, 0.01615679f, -0.01927744f, 0.08042637f, 0.03893720f, 0.16491207f, -0.10938705f, 
    0.07056537f, -0.04434120f, 0.08741167f, -0.07634261f, 0.01749506f, -0.06917885f, 0.00127972f, 0.07425660f, 
    0.05909760f, -0.07156176f, -0.03652134f, 0.10027909f, 0.06627613f, 0.04523141f, -0.00560614f, -0.01011639f, 
    0.16025551f, 0.00600138f, -0.04855150f, 0.04139679f, -0.07137235f, 0.01761422f, 0.04212591f, 0.00545460f, 
    0.48987532f, -0.13363940f, -0.00533904f, -0.02762234f, -0.01378636f, 0.03061343f, -0.03805857f, -0.00396530f, 
    -0.09781361f, -0.32825398f, -0.12266734f, -0.17403138f, -0.20130569f, -0.13270101f, 0.30834907f, -0.20702747f, 
    -0.00940817f, 0.20964631f, 0.06769025f, 0.13128079f, -0.03223475f, -0.01882657f, 0.02899725f, 0.01659504f, 
    0.18021311f, 0.05258761f, 0.05252711f, -0.19273640f, -0.00656932f, 0.00817438f, -0.11978015f, -0.00876894f, 
    -0.08531179f, -0.26192105f, 0.11150002f, -0.30881819f, 0.15881191f, 0.12077253f, 0.09114153f, 0.10625658f, 
    -0.03656776f, 0.02730621f, -0.09914062f, 0.06798222f, 0.08141671f, -0.10527552f, 0.08874156f, -0.07907198f, 
    0.25910434f, 0.06109621f, 0.27273023f, -0.03321604f, -0.01876642f, -0.01676616f, 0.01935776f, 0.06234399f, 
    -0.07053903f, 0.00458310f, -0.10386659f, -0.02814817f, -0.16935357f, -0.08691068f, -0.02541393f, -0.13818410f, 
    -0.00265994f, 0.06254724f, -0.05019203f, 0.00242604f, 0.09641896f, -0.06985646f, -0.17535955f, -0.11113851f, 
    0.12674622f, -0.06234103f, 0.05731224f, 0.06816951f, -0.17047234f, 0.04002752f, 0.08123992f, -0.00297740f, 
    -0.08997159f, 0.03074344f, 0.12601638f, -0.01385210f, -0.33197609f, -0.11636611f, -0.05252084f, -0.31321037f, 
    -0.20530526f, 0.04997481f, -0.07680961f, 0.15489000f, 0.11097610f, -0.09625324f, 0.01397271f, -0.06188622f, 
    -0.28125989f, -0.19795376f, -0.00879543f, -0.09827121f, 0.10730220f, 0.10366949f, -0.11845590f, 0.18548426f, 
    -0.08791310f, 0.08375330f, 0.02353390f, 0.08381961f, 0.15677841f, 0.12312997f, -0.03283105f, -0.05083649f, 
    -0.06044167f, -0.17311566f, 0.01569819f, 0.01813691f, -0.05027266f, 0.05039588f, -0.03627340f, 0.03900642f, 
    -0.00565391f, -0.02347134f, 0.15194234f, -0.03244218f, -0.16033627f, 0.31335744f, -0.10456182f, -0.08490628f, 
    -0.06878477f, 0.06394988f, -0.01472856f, 0.02941531f, 0.08177202f, 0.07011015f, -0.08065706f, 0.05909900f, 
    -0.04515813f, 0.07856575f, -0.00502968f, -0.06456742f, 0.14718702f, -0.05948095f, 0.15649937f, -0.04558896f, 
    0.01343527f, 0.15436867f, 0.13902588f, 0.24607418f, -0.05315490f, 0.18361770f, -0.06207433f, 0.22260226f, 
    -0.04218660f, 0.00192737f, 0.01619481f, -0.03968816f, -0.01473170f, 0.08906759f, -0.07958797f, 0.21037552f, 
    -0.09942219f, 0.13153674f, -0.28762823f, -0.22805971f, -0.09700037f, -0.06513915f, 0.03310708f, 0.03837985f, 
    0.15783639f, -0.01422028f, -0.03820444f, -0.04292608f, 0.04587369f, 0.06687699f, 0.00584423f, -0.08905355f, 
    0.01849210f, 0.08117725f, -0.12594233f, 0.01070355f, 0.47663105f, 0.22139354f, 0.12823832f, 0.03802023f, 
    0.02805913f, -0.13295586f, -0.31357399f, -0.39331731f, -0.02654077f, -0.01545030f, -0.08943277f, -0.21158569f, 
    0.00867964f, 0.12921324f, 0.04114670f, 0.10046159f, -0.21287318f, -0.11081640f, -0.28722107f, 0.09586821f, 
    -0.01854010f, -0.03010590f, -0.04539110f, 0.05484519f, -0.08960667f, 0.01154020f, 0.02542789f, 0.09976111f, 
    0.20335644f, 0.10393755f, 0.03584488f, 0.15455425f, -0.04140345f, 0.07243792f, -0.08534840f, 0.04003733f, 
    0.26555362f, 0.10473204f, 0.13379274f, 0.22074631f, -0.06143769f, -0.02745021f, -0.05541968f, -0.02780779f, 
    -0.12743987f, 0.11420962f, -0.09227906f, 0.09930409f, 0.06160711f, 0.08198842f, 0.03548244f, 0.11033089f, 
    -0.06388052f, -0.03182777f, -0.03541061f, 0.02164845f, 0.12686194f, -0.00626807f, 0.05769445f, -0.04865514f, 
    -0.20808312f, 0.24216792f, 0.03844199f, -0.11494813f, 0.03833992f, -0.08679289f, 0.03001767f, 0.05042305f, 
    -0.26221752f, 0.15700190f, -0.03160622f, 0.06450986f, -0.28423986f, 0.24182235f, -0.23952468f, 0.13491184f, 
    0.01477398f, 0.03282552f, -0.01007404f, -0.00823624f, 0.05045049f, 0.08241647f, -0.00463924f, -0.05756807f, 
    0.35762200f, -0.29562673f, -0.17994292f, -0.22777055f, -0.06457205f, 0.11702948f, 0.17950423f, 0.03087971f, 
    0.02324605f, 0.07329644f, -0.05834354f, -0.07639878f, -0.09128419f, -0.01934820f, -0.15579377f, -0.00099226f, 
    -0.03541092f, -0.00609809f, -0.05987540f, 0.04988801f, -0.15214317f, 0.01416940f, 0.03407704f, -0.03516066f, 
    0.05574075f, 0.06467321f, 0.00841480f, -0.16017884f, -0.06021167f, -0.01392788f, -0.17338793f, -0.24258982f, 
    0.01180208f, -0.08199285f, 0.00263501f, 0.06402115f, 0.02904351f, -0.01853488f, 0.17006007f, 0.15527494f, 
    0.01344092f, 0.01798319f, 0.06743242f, -0.02937246f, -0.04253773f, -0.04563836f, -0.00324277f, 0.04940043f, 
    -0.23201865f, -0.11374424f, -0.00502531f, -0.01114567f, 0.10599864f, -0.01379385f, -0.09946592f, 0.07262593f, 
    -0.30177054f, 0.03332162f, 0.06495494f, 0.01901002f, 0.08320168f, 0.11199817f, 0.07569055f, 0.25595716f, 
    -0.01713824f, -0.05388393f, 0.04322838f, -0.05646225f, 0.04755246f, -0.00737740f, 0.03292347f, 0.02178808f, 
    -0.16728300f, -0.35447499f, 0.04217550f, 0.02868265f, -0.05222751f, -0.04787736f, 0.01988988f, 0.14293490f, 
    0.09751388f, -0.02376188f, 0.07421926f, 0.05983644f, 0.21447361f, -0.04362100f, -0.03694599f, -0.04047433f, 
    -0.00847144f, -0.09592901f, -0.14039399f, 0.04541393f, -0.12934475f, 0.07791764f, 0.01209588f, 0.04863823f, 
    -0.08571968f, 0.04852765f, -0.09333075f, -0.16827366f, -0.03195395f, -0.03387439f, -0.02687174f, 0.08036122f, 
    0.03919359f, -0.03651554f, 0.02115856f, 0.02834503f, 0.31961527f, -0.07930380f, 0.12010670f, -0.10120872f, 
    0.00399403f, -0.02097833f, 0.08285617f, -0.15287775f, 0.21507509f, 0.23828904f, -0.22337265f, -0.14584199f, 
    -0.16012022f, -0.17297447f, -0.17686117f, -0.27593693f, -0.03459528f, -0.06399317f, 0.08067954f, 0.01517045f, 
    -0.00138488f, -0.21271670f, 0.15029879f, 0.08371700f, 0.34075525f, 0.16319047f, -0.00792463f, 0.06013815f, 
    -0.05536692f, -0.02681706f, 0.00672872f, 0.00998001f, 0.05432080f, 0.21661778f, -0.06993598f, 0.07304186f, 
    -0.26034692f, -0.14820020f, -0.59085691f, -0.15436338f, 0.10071336f, 0.01489895f, 0.00331852f, 0.09867150f, 
    -0.03368668f, -0.03976173f, 0.00186801f, -0.04887381f, 0.07817788f, 0.06329746f, -0.46716255f, -0.18361193f, 
    0.07706420f, -0.10434373f, -0.04732014f, 0.11071088f, -0.00954414f, 0.06241725f, 0.09546354f, -0.28279206f, 
    0.63553500f, -0.03207839f, 0.11339872f, -0.11155142f, -0.09451399f, 0.04761237f, 0.02557397f, -0.09854051f, 
    0.08466375f, -0.00774364f, 0.05790007f, -0.15295382f, 0.10092797f, -0.06225681f, 0.15260944f, -0.07254396f, 
    -0.07501882f, -0.11282053f, 0.07536893f, -0.01589152f, -0.03650008f, 0.03871264f, -0.00685385f, -0.01697857f, 
    0.00174766f, 0.04028034f, 0.16857736f, 0.18737239f, -0.11371785f, 0.10388868f, 0.09199027f, -0.13191491f, 
    0.04224502f, -0.00001677f, -0.04546708f, 0.03711960f, -0.11529759f, 0.03976781f, -0.12130386f, 0.02849138f, 
    -0.01423094f, 0.02981317f, 0.06118661f, -0.03788084f, -0.30027685f, -0.21505934f, -0.15358600f, -0.05961844f, 
    0.21343145f, 0.25185278f, -0.17580129f, -0.10026586f, -0.09994186f, -0.09619556f, 0.10661069f, -0.06945718f, 
    0.05621184f, -0.06564984f, -0.04005828f, -0.05935672f, 0.09267295f, 0.02773999f, -0.24733424f, 0.11305621f, 
    0.13293409f, 0.11025368f, 0.08983246f, -0.16989723f, 0.23848113f, -0.04561904f, 0.14039749f, 0.01048952f, 
    0.08718288f, 0.07357623f, 0.05042027f, 0.06741639f, 0.00906522f, -0.04839309f, -0.10111557f, 0.01247105f, 
    -0.12105934f, 0.02845049f, 0.11761138f, -0.03245079f, 0.32813755f, -0.44872987f, -0.06055924f, -0.22776416f, 
    0.17261781f, 0.08802737f, 0.20640492f, 0.08133616f, 0.08726550f, -0.01745510f, -0.14856645f, 0.13340537f, 
    0.07265468f, -0.10344800f, -0.22742359f, 0.01264970f, -0.02871337f, 0.02096925f, 0.18372919f, -0.03771269f, 
    -0.04563748f, -0.03616124f, 0.04937011f, 0.26636225f, 0.01021335f, 0.11400317f, 0.09410860f, -0.40719542f, 
    0.02115042f, -0.05022877f, -0.02894422f, -0.02498560f, -0.02047651f, 0.11511175f, -0.07950550f, 0.00973331f, 
    -0.04207436f, -0.01577535f, -0.35585335f, 0.13001080f, 0.01069680f, 0.04271274f, 0.02319448f, 0.02719139f, 
    -0.04635110f, 0.01978476f, 0.05991457f, -0.04226386f, -0.00878833f, 0.04257519f, -0.12691034f, -0.12720111f, 
    0.05866474f, 0.04005232f, -0.09145974f, 0.02268654f, -0.03584814f, 0.00146082f, -0.05861619f, 0.06578810f, 
    0.07567359f, 0.09361117f, 0.01383526f, -0.07288087f, 0.03730590f, -0.13672855f, -0.05247648f, 0.03902567f, 
    0.12019531f, -0.04809841f, -0.02636727f, 0.18427300f, -0.11922408f, 0.01787582f, -0.03340794f, -0.05018530f, 
    -0.02580168f, -0.05363278f, -0.03482036f, 0.05630335f, 0.00293095f, 0.06399292f, -0.10366778f, 0.10105386f, 
    -0.23359521f, 0.36845905f, 0.16647266f, -0.26530820f, -0.00314485f, 0.01676664f, -0.19692865f, -0.09775443f, 
    0.05236262f, -0.01262918f, 0.08384471f, 0.13283934f, -0.33716482f, 0.59466726f, 0.25039417f, 0.02949804f, 
    -0.08597357f, 0.00349360f, 0.06821664f, -0.19357751f, 0.04575860f, 0.05762275f, -0.05850717f, -0.19859794f, 
    0.25445020f, 0.32680798f, 0.56940323f, 0.44170815f, -0.03459999f, -0.04145011f, 0.16203792f, -0.00201389f, 
    -0.06632787f, -0.16651025f, 0.00245208f, 0.01541490f, 0.16439077f, 0.16052155f, -0.16701715f, 0.20106608f, 
    0.03039414f, 0.02040116f, -0.01916028f, -0.04791626f, 0.03596662f, 0.10336357f, -0.19540252f, 0.18808477f, 
    -0.03296683f, 0.40306121f, -0.06820214f, 0.12768106f, 0.08141118f, -0.06124203f, -0.01808238f, 0.11525401f, 
    -0.01486746f, -0.00424281f, 0.01775151f, -0.12576081f, -0.20153631f, 0.24921724f, -0.01555047f, -0.43661755f, 
    0.02608847f, -0.05419282f, 0.07161649f, 0.00409261f, 0.01331566f, -0.00785623f, 0.13564222f, -0.15109079f, 
    -0.00626447f, 0.11662670f, -0.14127325f, 0.04057050f, 0.25411311f, 0.12493882f, -0.12495247f, 0.05506054f, 
    0.07472154f, -0.03378453f, -0.14332861f, 0.08032791f, -0.14299096f, -0.27599692f, 0.00028870f, 0.04076236f, 
    0.05507560f, -0.06453474f, 0.06377067f, 0.05748162f, 0.05204013f, -0.10080053f, 0.00492656f, -0.06112925f, 
    0.04720709f, 0.31385347f, 0.09462768f, 0.21117491f, -0.06842736f, -0.08603329f, 0.11057916f, -0.05178444f, 
    -0.08305392f, 0.01184397f, 0.03043980f, 0.01690552f, -0.23784019f, 0.23555917f, -0.22073421f, -0.04457066f, 
    0.10547996f, 0.06806543f, 0.01216183f, -0.00910343f, -0.01414761f, 0.00982115f, -0.02236398f, -0.02522299f, 
    -0.00757927f, 0.25146213f, -0.41894639f, 0.11126804f, 0.06252375f, 0.12603341f, 0.03407118f, -0.03352326f, 
    0.00286883f, -0.01403978f, -0.05481382f, -0.02441795f, -0.03181930f, 0.12436932f, -0.08436295f, 0.03477970f, 
    -0.02801046f, 0.04314544f, -0.14787616f, 0.12069729f, -0.10544534f, 0.04795609f, 0.03862781f, -0.03265812f, 
    -0.06444611f, 0.01884678f, 0.15703663f, -0.13716348f, 0.03876482f, -0.08424202f, -0.21091330f, -0.02638211f, 
    0.06599879f, -0.00897242f, -0.03560026f, 0.07896441f, -0.12182061f, 0.16169296f, -0.08883470f, -0.10915257f, 
    -0.04026412f, 0.05208780f, 0.04043527f, 0.01079740f, -0.01218485f, 0.06196514f, 0.00959043f, -0.02686192f, 
    -0.02381855f, 0.01047407f, 0.08836235f, -0.01392269f, 0.01461443f, -0.00932778f, 0.00035306f, -0.13686256f, 
    0.07395612f, 0.13741687f, -0.04134647f, 0.03460866f, -0.40984496f, -0.22931904f, 0.10432927f, -0.14815331f, 
    -0.03295391f, -0.13470177f, 0.09698629f, -0.13943304f, -0.02013356f, 0.01599938f, -0.06668646f, -0.08185147f, 
    -0.15581214f, 0.19178490f, -0.08717103f, 0.11384779f, -0.04061320f, -0.05233777f, -0.01553824f, -0.15769465f, 
    -0.02434843f, 0.14006767f, 0.07864293f, 0.07189861f, 0.04933139f, 0.06514098f, -0.10902783f, 0.02119039f, 
    -0.02196472f, 0.03110153f, 0.00381097f, 0.05460131f, -0.02894085f, 0.06650260f, 0.02325865f, -0.02320268f, 
    -0.06268917f, -0.04059928f, 0.18219340f, -0.36668342f, 0.01692250f, -0.08479834f, 0.03811376f, 0.04404612f, 
    0.00696376f, -0.01446129f, -0.00742280f, 0.00091311f, -0.45897371f, 0.28168651f, -0.16026384f, 0.20835528f, 
    -0.03451886f, 0.01015485f, -0.01472815f, -0.11583391f, 0.06113242f, 0.09329073f, -0.05432475f, 0.22391616f, 
    -0.00178188f, -0.03821202f, -0.06045774f, 0.06377453f, -0.11589199f, 0.03915193f, 0.06473386f, -0.02006883f, 
    -0.03937272f, 0.01985642f, -0.06198817f, -0.12613569f, -0.78911763f, -0.11350983f, -0.25408432f, -0.10611994f, 
    0.05405422f, 0.14413829f, -0.12558115f, -0.21975316f, 0.07733235f, -0.11434565f, -0.07032845f, 0.05219109f, 
    0.10667653f, -0.04319553f, 0.01266271f, 0.09120268f, -0.02586363f, -0.08209308f, -0.03720057f, -0.35558391f, 
    0.06006263f, -0.01462219f, -0.06067499f, 0.08907579f, -0.27022368f, 0.09864702f, -0.11499064f, -0.04492129f, 
    -0.02269443f, 0.06336173f, 0.10249591f, -0.05791055f, 0.00508720f, 0.03674143f, -0.05846169f, 0.05671023f, 
    0.06679622f, -0.22381234f, 0.07492846f, -0.11867552f, 0.06239533f, 0.07463782f, -0.04213272f, -0.02275424f, 
    -0.06128740f, -0.03628447f, -0.00241289f, -0.00983364f, 0.04054105f, -0.06979519f, 0.01825139f, -0.02002781f, 
    -0.04128066f, 0.02002505f, 0.00602670f, -0.02822925f, 0.02433135f, 0.09952453f, -0.00013858f, 0.01128691f, 
    -0.32129428f, -0.40978551f, -0.02432772f, -0.06080238f, -0.00462904f, -0.22307821f, 0.07068948f, 0.10415720f, 
    -0.02878556f, -0.01447511f, -0.12060635f, 0.06353974f, 0.00811731f, 0.06632750f, -0.13009790f, 0.31194022f, 
    -0.06199453f, -0.26850578f, 0.11382494f, 0.07535623f, -0.00166983f, 0.05383398f, 0.06925710f, -0.03621477f, 
    0.06626536f, -0.03104119f, 0.02226572f, -0.03860326f, -0.06185747f, -0.02660936f, 0.04362572f, 0.00063696f, 
    -0.05926133f, 0.10534342f, -0.02473240f, 0.04453121f, -0.11132423f, -0.01238417f, 0.65782028f, 0.53478777f, 
    -0.05498084f, -0.00945819f, 0.04818236f, 0.05616621f, 0.07627952f, 0.01517738f, -0.02169188f, 0.07032751f, 
    -0.61094576f, -0.32118815f, -0.35579145f, -0.21653473f, 0.09286439f, -0.03598685f, -0.21686505f, 0.08715188f, 
    0.02285899f, 0.01649128f, 0.03349182f, -0.00936443f, -0.05549414f, -0.08478552f, -0.06131907f, 0.00011311f, 
    -0.07809400f, -0.18203972f, 0.05529948f, -0.12004629f, 0.03286949f, -0.01203387f, -0.15688711f, 0.07433926f, 
    -0.10840172f, -0.11960910f, -0.20140749f, 0.03486345f, -0.00255861f, -0.06793854f, 0.04779498f, 0.07959974f, 
    -0.01706258f, -0.14428329f, 0.03248130f, 0.04257504f, -0.05604209f, -0.05945785f, -0.01954796f, -0.05006742f, 
    -0.00415115f, -0.00260795f, 0.00151739f, 0.06676880f, -0.20985717f, -0.00966387f, -0.03788673f, 0.04305864f, 
    -0.10919883f, 0.13604106f, -0.25316009f, 0.22011124f, 0.09211873f, -0.07783745f, 0.01346904f, 0.04866020f, 
    0.00849797f, 0.01659108f, -0.11224174f, -0.03115411f, -0.02707754f, 0.17661649f, 0.06772009f, 0.02771591f, 
    -0.02719906f, -0.00111324f, -0.01007331f, 0.06779688f, -0.04318038f, -0.03192878f, 0.10427058f, -0.16507585f, 
    -0.54631954f, 0.32470259f, -0.21061724f, -0.15968183f, -0.16485292f, 0.14185245f, -0.08510297f, -0.09434853f, 
    0.00571298f, -0.09139914f, -0.00870791f, -0.03329814f, 0.29915687f, 0.00984057f, 0.28036061f, 0.23108022f, 
    -0.03017118f, -0.05496619f, -0.03081404f, -0.00904825f, 0.18120624f, 0.08507860f, 0.09962843f, 0.03869608f, 
    -0.22708930f, -0.06557055f, 0.17719680f, -0.11605599f, 0.06773704f, 0.01377185f, -0.14085659f, -0.12158906f, 
    0.05930399f, -0.13645664f, 0.10350711f, -0.01759460f, -0.65332168f, -0.30626220f, -0.33036569f, -0.29483187f, 
    -0.02778362f, 0.02280275f, -0.03640908f, -0.04093881f, -0.02363102f, 0.01180739f, -0.03309939f, 0.00151727f, 
    0.10483380f, -0.06936228f, -0.04692016f, 0.16482124f, 0.04147269f, -0.18097869f, 0.02665425f, -0.01458810f, 
    0.03796055f, 0.06300402f, 0.04968888f, 0.07231420f, 0.14257646f, -0.06974692f, 0.16000319f, 0.14862758f, 
    -0.02338403f, 0.02985894f, 0.07117229f, -0.04686310f, -0.04564495f, -0.05065874f, 0.10080852f, -0.02628529f, 
    0.16342635f, 0.08927581f, -0.23657610f, 0.04973555f, 0.08534826f, 0.09686136f, -0.05097612f, 0.07526964f, 
    -0.09916224f, 0.07261851f, 0.04937088f, -0.13219960f, -0.07760527f, -0.06482889f, 0.04149878f, -0.07874047f, 
    -0.07200218f, -0.06204874f, -0.05370471f, -0.03609164f, 0.02092096f, 0.04349512f, -0.04252655f, 0.01011397f, 
    -0.04479329f, -0.11854938f, -0.09727417f, -0.06507596f, -0.04768888f, 0.00622481f, -0.05913660f, -0.13287801f, 
    -0.03330229f, 0.04729450f, -0.02359762f, -0.00371848f, -0.01074733f, 0.00668768f, 0.02479648f, -0.18452591f, 
    -0.02746963f, -0.01842446f, 0.00856974f, 0.02635953f, 0.02239332f, 0.10135923f, -0.06329213f, -0.03292051f, 
    0.00532756f, 0.19776726f, 0.17360203f, 0.06217703f, -0.01486047f, 0.07891940f, 0.01579212f, -0.02459573f, 
    0.09627093f, -0.22699378f, 0.10838475f, -0.05617474f, -0.20841183f, 0.05931639f, -0.03113086f, 0.03647939f, 
    -0.02147353f, 0.01128556f, -0.04076428f, 0.03843230f, 0.01934903f, -0.02506061f, -0.10737877f, 0.06978393f, 
    -0.06135045f, 0.37089008f, -0.18178856f, -0.25033170f, 0.05134088f, -0.04318997f, -0.04218266f, 0.04579860f, 
    0.01049577f, -0.03076044f, -0.00549908f, -0.01368123f, 0.19483477f, 0.05102308f, -0.25848386f, 0.08404528f, 
    -0.03741531f, 0.13041426f, -0.05670869f, -0.00966586f, -0.16146201f, 0.02022612f, -0.01997237f, 0.03512403f, 
    -0.54701918f, 0.14487804f, 0.23207301f, 0.05686613f, -0.04889550f, 0.02742970f, -0.12842016f, -0.04942065f, 
    -0.02874829f, 0.03573185f, -0.04476857f, 0.04934789f, 0.07270051f, -0.22716786f, -0.01103637f, -0.12498075f, 
    0.07908571f, 0.01490218f, 0.04951754f, 0.00086389f, 0.01041717f, -0.06831336f, 0.03492361f, -0.00153678f, 
    -0.55224490f, -0.36842215f, -0.13681795f, -0.25348297f, -0.05442801f, -0.03251728f, 0.03889520f, 0.04072502f, 
    0.00135288f, -0.04631406f, -0.00704495f, -0.01153557f, 0.00692078f, 0.00687719f, 0.05160397f, 0.03209945f, 
    -0.05702170f, -0.01631159f, 0.01656499f, 0.02171200f, 0.04582839f, 0.01585471f, 0.07381895f, 0.08604869f, 
    -0.21331330f, 0.33863968f, 0.41379601f, 0.02428975f, -0.04479890f, -0.02133343f, 0.06535880f, 0.02511822f, 
    0.04251944f, 0.01685380f, 0.00720207f, 0.00330050f, -0.16380383f, -0.05911136f, 0.16375014f, 0.10328421f, 
    0.00800420f, 0.09525925f, -0.14540473f, 0.15273835f, -0.05408895f, -0.06520382f, 0.09058382f, 0.10180362f, 
    0.03062500f, 0.00361967f, -0.01468544f, -0.04537317f, -0.00679534f, -0.07026287f, 0.00163388f, 0.02802571f, 
    -0.02508752f, 0.01197492f, -0.11996805f, -0.02918339f, -0.02505713f, 0.18338346f, 0.15111959f, -0.38148236f, 
    -0.09125105f, 0.01095719f, -0.13011448f, -0.06115380f, -0.02021946f, 0.09146453f, -0.22036129f, -0.10201290f, 
    0.24003410f, 0.23965679f, -0.08070093f, -0.36045620f, -0.24775791f, -0.19432156f, -0.01127388f, -0.07648043f, 
    -0.18068647f, -0.05695796f, 0.06516965f, -0.02238928f, -0.27317369f, 0.07898714f, 0.12742013f, 0.22292845f, 
    -0.05591944f, -0.01059081f, -0.05206507f, -0.07475679f, -0.01395286f, 0.02862080f, 0.07646187f, -0.03857860f, 
    0.13190982f, 0.21303977f, -0.32012606f, -0.49710831f, -0.03404677f, 0.05276366f, -0.00277119f, 0.09947090f, 
    -0.05567101f, 0.00830420f, 0.15291850f, -0.17643875f, 0.11229202f, 0.51020420f, 0.38587901f, 0.42142823f, 
    -0.20135629f, -0.05637250f, 0.07998376f, 0.04943252f, 0.03488449f, 0.10998910f, 0.20560852f, 0.09590630f, 
    -0.42847571f, -0.27663359f, -0.01409534f, 0.19504488f, 0.00356773f, -0.06867559f, 0.11503488f, 0.04540682f, 
    -0.06257298f, 0.07171987f, -0.23736525f, 0.26449332f, -0.18395081f, -0.08766196f, 0.12565359f, 0.29821512f, 
    -0.11856862f, -0.03689569f, -0.08056235f, -0.00687556f, 0.07843338f, -0.11665642f, -0.15522765f, 0.07964570f, 
    -0.52061963f, -0.21501212f, 0.15620147f, 0.24619485f, -0.13861537f, 0.06695416f, -0.00243728f, -0.02418391f, 
    -0.04558680f, -0.02341247f, 0.05120428f, 0.12075800f, 0.33962828f, -0.02886659f, -0.08494850f, 0.34609029f, 
    0.12698464f, 0.04780583f, -0.06628270f, -0.00326544f, 0.13273893f, -0.06434899f, 0.08288934f, 0.04057079f, 
    0.08861092f, -0.03206240f, 0.15937878f, 0.20089428f, 0.03445041f, 0.04590677f, -0.04924371f, -0.00726283f, 
    -0.00920927f, 0.10086190f, 0.03932364f, 0.05447075f, 0.89996254f, -0.01608362f, -0.11086880f, -0.19752711f, 
    0.10493935f, -0.05158184f, 0.00662041f, -0.08894316f, -0.13582239f, -0.04856117f, -0.11577911f, 0.01817484f, 
    -0.63386387f, 0.71366137f, -0.40009493f, -0.08510946f, 0.10284503f, 0.03969914f, -0.08200987f, 0.00047196f, 
    -0.25777522f, -0.05456916f, -0.04461899f, 0.07937311f, -0.28089246f, 0.04607585f, 0.10064371f, 0.40639997f, 
    -0.04894792f, 0.02958123f, -0.10354165f, -0.10988947f, 0.02647929f, -0.01793526f, 0.05343261f, -0.07340359f, 
    0.60570389f, 0.02179388f, -0.00764802f, -0.06409824f, 0.11082286f, 0.06931724f, 0.04507253f, 0.06170583f, 
    -0.04975506f, -0.00307674f, 0.00023931f, 0.02627212f, -0.30454010f, 0.20922323f, -0.39256066f, -0.56157851f, 
    0.31781226f, 0.15571657f, 0.01023813f, 0.05380972f, -0.15216476f, 0.10957685f, -0.10361495f, -0.02247087f, 
    -0.03720445f, -0.19359466f, 0.07507850f, 0.13344653f, 0.10673046f, 0.13444449f, 0.05752426f, -0.09196494f, 
    0.03045334f, -0.05810493f, -0.06681100f, -0.00935679f, 0.02952999f, 0.28510484f, 0.11706271f, 0.01335704f, 
    -0.09726658f, -0.05839850f, 0.13729520f, -0.02208210f, 0.04004819f, 0.08655539f, 0.01447340f, 0.10180132f, 
    0.00204345f, -0.17818032f, -0.09630644f, 0.08018105f, 0.09854005f, 0.06264244f, -0.02874551f, 0.04981640f, 
    0.03175405f, 0.10610479f, -0.02131176f, -0.09079338f, -0.47619584f, 0.01682244f, -0.05301782f, 0.05195595f, 
    0.03807103f, -0.07936826f, -0.17861517f, -0.06719541f, 0.00363470f, -0.37198752f, 0.05531234f, -0.20093462f, 
    -0.29737154f, -0.15750477f, 0.28253868f, -0.19029438f, -0.10462975f, -0.06079880f, -0.10865144f, 0.04101153f, 
    0.09739514f, 0.11509060f, -0.07719330f, 0.01039348f, -0.19825330f, -0.21406665f, 0.05741863f, -0.14901119f, 
    -0.24670921f, 0.00906796f, -0.30439916f, -0.18832667f, -0.05554882f, -0.25757203f, -0.11098970f, 0.00425205f, 
    -0.21043776f, 0.42953858f, -0.29019120f, 0.18695685f, -0.07699302f, 0.04052980f, -0.01401572f, -0.01464049f, 
    -0.06541328f, 0.21525972f, -0.06683514f, 0.03096511f, -0.00234409f, -0.11284802f, -0.09540196f, 0.17329469f, 
    0.07175850f, 0.00779433f, 0.13633972f, 0.18228060f, -0.01237260f, -0.13030328f, 0.14499217f, -0.10112644f, 
    -0.17218572f, -0.12238430f, -0.04118187f, 0.02649644f, -0.05458759f, 0.13897125f, 0.12728579f, 0.01019763f, 
    0.17942831f, 0.05881684f, 0.03107372f, 0.01908072f, -0.07927001f, -0.16004956f, -0.18915996f, -0.15095967f, 
    0.07239910f, 0.10746696f, -0.02666513f, -0.06407867f, -0.07198221f, -0.20215723f, -0.06227576f, -0.04593629f, 
    -0.09627163f, 0.07483514f, -0.13118780f, -0.07885504f, 0.03292922f, 0.13658474f, -0.00893152f, -0.05056797f, 
    0.00418104f, 0.00425731f, -0.17758657f, 0.06246242f, -0.26145703f, 0.06797097f, -0.00532345f, 0.11328069f, 
    -0.12661323f, 0.14739311f, -0.10424908f, -0.09950333f, -0.08557978f, 0.12214785f, -0.02080172f, 0.03526742f, 
    -0.08247329f, 0.34311309f, -0.16606201f, 0.04636195f, 0.08552050f, -0.18650962f, -0.03566726f, -0.09351007f, 
    -0.13654475f, -0.11689951f, 0.00140003f, -0.03757609f, 0.07781710f, 0.00046002f, 0.11422307f, 0.08683104f, 
    0.00909330f, 0.09735161f, 0.01145929f, 0.03086985f, -0.06257050f, 0.00286304f, 0.09458063f, -0.10951865f, 
    0.01948120f, -0.02405012f, 0.05012918f, 0.15359384f, 0.09962627f, 0.09700281f, -0.00830190f, -0.03049386f, 
    -0.04391602f, 0.05236240f, -0.03123408f, 0.05188946f, -0.01438411f, -0.39457038f, 0.14746706f, 0.24714674f, 
    -0.15187900f, -0.06265373f, -0.16094658f, 0.07392813f, 0.08411445f, -0.02075593f, -0.05243533f, 0.07511423f, 
    0.06967309f, -0.14717613f, -0.05086484f, 0.12031142f, -0.04348689f, -0.11135912f, -0.15978794f, -0.13642778f, 
    -0.09385350f, -0.05055284f, 0.08861616f, -0.09420183f, -0.40055498f, 0.28239202f, -0.22329719f, -0.04660421f, 
    0.10640115f, -0.09614882f, -0.09311178f, -0.11968079f, -0.09000541f, -0.10355047f, -0.14994155f, -0.01924604f, 
    -0.01149278f, -0.15005513f, -0.12069044f, 0.07985655f, 0.06007222f, 0.09027375f, 0.00679108f, 0.13110380f, 
    0.09877361f, -0.00438124f, 0.04443493f, -0.06136794f, 0.03024494f, -0.13612014f, -0.09185690f, 0.09173755f, 
    0.01533986f, 0.01140161f, 0.05344469f, -0.13289152f, -0.01481310f, 0.00458225f, -0.01900285f, 0.08011770f, 
    0.21922643f, 0.27424109f, 0.06010839f, -0.13726808f, -0.07111921f, -0.14188835f, -0.18164170f, -0.03677908f, 
    -0.00644702f, 0.04292358f, -0.11092947f, -0.10423333f, 0.32327032f, -0.14408104f, -0.03032502f, 0.26092246f, 
    0.11689536f, -0.01325315f, -0.04072420f, -0.18090872f, -0.01705337f, 0.12253829f, 0.14241694f, 0.17278673f, 
    -0.12743542f, -0.10834685f, -0.09613894f, 0.12647705f, 0.08399815f, 0.05618526f, 0.03215742f, 0.01607049f, 
    0.03513068f, -0.07070518f, -0.06068801f, 0.04886040f, -0.05188104f, -0.04069257f, -0.08446343f, 0.09050116f, 
    -0.05564779f, -0.02834226f, 0.09628106f, -0.14866729f, 0.03356479f, 0.14102751f, 0.16435450f, 0.14379145f, 
    -0.28139696f, -0.38470218f, -0.10836675f, -0.33278763f, 0.00885312f, -0.04130417f, -0.12629972f, 0.07205184f, 
    -0.20752694f, 0.02909855f, 0.03902323f, -0.14758709f, -0.07554173f, -0.12854829f, -0.12506698f, -0.07485405f, 
    -0.19395380f, -0.00642627f, 0.06205815f, -0.04399770f, 0.03839194f, -0.00410389f, 0.08119640f, -0.26952231f, 
    -0.22884519f, 0.19475280f, -0.03692992f, -0.62039840f, -0.07196288f, 0.04119413f, -0.15202251f, 0.10327310f, 
    -0.17929597f, 0.05770200f, -0.14955637f, -0.18542038f, 0.19180119f, -0.02973254f, -0.22934911f, 0.05942949f, 
    0.02400492f, -0.17020093f, -0.17417227f, 0.04198768f, -0.16931419f, 0.03066150f, -0.09078218f, -0.03968783f, 
    -0.25899759f, 0.07825433f, 0.05386915f, 0.44752103f, -0.04520204f, -0.01927997f, -0.21193437f, -0.19446440f, 
    -0.09371823f, 0.06901806f, 0.07703904f, 0.09930663f, -0.02351118f, -0.29307064f, -0.15039042f, 0.14526461f, 
    0.05884669f, 0.08907981f, -0.00584148f, -0.17161815f, -0.08629843f, -0.03646380f, 0.02011230f, -0.11129901f, 
    -0.07768305f, 0.21058336f, 0.11942997f, 0.11243044f, -0.11585064f, 0.17362458f, -0.01383530f, 0.16496988f, 
    0.17818186f, 0.23468862f, -0.07523227f, 0.00025313f, -0.01851781f, -0.13371576f, -0.00943317f, 0.06593031f, 
    0.12482819f, 0.18283646f, 0.08385784f, 0.00845925f, 0.07491762f, -0.11483419f, 0.07128484f, -0.16495727f, 
    0.55444330f, -0.15177462f, 0.23842710f, 0.09939817f, 0.17309487f, 0.09181536f, -0.04977293f, -0.13301498f, 
    -0.10936903f, -0.09756791f, 0.18445495f, 0.09947331f, 0.18970102f, 0.14195710f, -0.16580024f, 0.07009812f, 
    -0.07552892f, -0.23687457f, -0.02704598f, -0.05879863f, 0.02871852f, 0.09648774f, -0.07465449f, -0.06777458f, 
    -0.04883289f, 0.46192268f, -0.23295222f, -0.34339002f, -0.06683281f, -0.01689774f, -0.18349202f, -0.10900535f, 
    -0.11088576f, 0.02444715f, -0.04478768f, 0.01346004f, -0.07436445f, -0.32866001f, 0.37470552f, -0.12564228f, 
    0.00126329f, 0.13033149f, -0.22324839f, -0.01540000f, -0.02673745f, -0.24195731f, 0.05553629f, -0.06829430f, 
    -0.03540897f, -0.10762955f, -0.04773051f, 0.22757873f, 0.02231531f, 0.06834230f, 0.03671089f, 0.01984805f, 
    -0.00210540f, 0.10700131f, -0.25706518f, 0.04494765f, -0.07302260f, -0.24401455f, 0.20846590f, -0.15299506f, 
    -0.08944380f, -0.07904618f, -0.01956735f, 0.02680182f, -0.06631777f, 0.12621067f, 0.00464586f, -0.08565281f, 
    0.23079777f, -0.04147215f, -0.15512177f, 0.12993938f, 0.11067710f, 0.05826694f, 0.17156765f, 0.05593719f, 
    -0.09966888f, -0.03066637f, 0.02667633f, -0.04353396f, -0.53734601f, 0.02977458f, -0.23626575f, -0.27412999f, 
    0.04217385f, 0.11527734f, -0.18241405f, -0.15306234f, -0.14013787f, 0.10539921f, 0.04826096f, -0.08604131f, 
    -0.08853265f, 0.05328232f, 0.01755429f, 0.12286263f, 0.02075204f, 0.01352248f, 0.04384861f, 0.01512590f, 
    -0.07016230f, 0.02108553f, -0.21290661f, -0.03331262f, 0.04860117f, -0.01998644f, -0.00980951f, -0.21176812f, 
    0.04956922f, -0.10018427f, 0.00293542f, -0.09962843f, 0.06934104f, -0.00866264f, 0.13228098f, 0.00042706f, 
    -0.26171428f, 0.21374235f, 0.15832162f, 0.29589456f, 0.11298891f, -0.05429372f, 0.05262793f, -0.08486422f, 
    -0.13362154f, 0.01038928f, 0.10710961f, -0.06001107f, 0.22594002f, -0.14323270f, 0.18390051f, 0.13823748f, 
    -0.19457185f, 0.00649686f, -0.20703100f, -0.02674846f, -0.01457848f, -0.06310222f, 0.20463501f, 0.03462975f, 
    -0.10877064f, -0.12430476f, -0.14085864f, 0.06878857f, 0.08173382f, 0.01905695f, 0.02156935f, 0.02292238f, 
    -0.02792291f, -0.07692369f, 0.04974828f, -0.01345041f, -0.13397473f, 0.00967727f, -0.07094182f, 0.06635614f, 
    0.09467812f, 0.07751308f, -0.04328239f, 0.00007903f, -0.11574137f, -0.02679178f, 0.01216499f, -0.01269659f, 
    -0.12776576f, 0.03906284f, -0.13228479f, 0.18152222f, 0.05939727f, 0.03973947f, 0.06225082f, -0.02676161f, 
    0.09917068f, -0.01934022f, 0.08921343f, 0.01231123f, 0.13187067f, 0.13574068f, -0.23899369f, 0.03360867f, 
    0.19503844f, -0.10777234f, -0.16006851f, -0.12473476f, -0.10346280f, 0.09083787f, 0.09914607f, -0.17932649f, 
    0.06454746f, -0.05765057f, 0.17488968f, -0.10685247f, -0.13014954f, 0.01493897f, 0.06586988f, -0.00572477f, 
    0.09978104f, -0.06305394f, -0.01150593f, -0.02848927f, -0.17154150f, 0.09905738f, 0.05765377f, 0.32783836f, 
    0.06154480f, -0.16652621f, 0.01571182f, 0.03469536f, -0.13162479f, 0.04389531f, -0.03798495f, 0.13567249f, 
    0.00125355f, -0.11492513f, 0.01495930f, -0.00378632f, 0.05610411f, 0.16442104f, -0.11915246f, -0.08148774f, 
    0.07382792f, 0.07613447f, -0.17887694f, -0.25724745f, 0.04138494f, -0.13797757f, -0.07465589f, -0.01868140f, 
    0.05353940f, -0.04468426f, 0.04970942f, 0.02490505f, -0.09784634f, 0.16330621f, -0.03858479f, -0.12424097f, 
    -0.14919661f, -0.43164924f, 0.14517388f, -0.11994974f, -0.02603044f, -0.00447458f, -0.02176976f, 0.00980640f, 
    -0.07879351f, -0.05199405f, -0.11366659f, 0.13483110f, 0.11827034f, 0.01735970f, -0.03182357f, 0.16112044f, 
    0.05261326f, 0.03351529f, -0.08650315f, -0.07840083f, 0.13063625f, -0.00305153f, -0.18704012f, 0.03601448f, 
    -0.02580883f, 0.08404783f, -0.09451737f, 0.02090136f, 0.18563463f, -0.11603164f, -0.14678913f, -0.18559539f, 
    -0.22877653f, -0.08268595f, -0.06837311f, -0.07268368f, -0.01450782f, 0.10176661f, -0.04530738f, 0.13867883f, 
    0.05035124f, -0.02695061f, 0.04449726f, -0.09772702f, 0.00677950f, -0.00961460f, 0.09438216f, 0.00090022f, 
    -0.09853010f, 0.15517592f, 0.03996613f, 0.02820825f, 0.13190340f, -0.08098346f, -0.20295659f, -0.17585881f, 
    0.02624927f, -0.08394361f, -0.19425662f, 0.08501631f, -0.42017177f, 0.04597478f, 0.29489356f, -0.06453706f, 
    -0.03699121f, -0.13369617f, -0.14675543f, -0.05178098f, -0.13440096f, -0.23233601f, -0.05110237f, 0.06256581f, 
    0.09177829f, 0.08227823f, 0.03860381f, 0.13246398f, -0.09158254f, -0.21929839f, 0.06692239f, -0.06304840f, 
    0.10528249f, -0.11254697f, -0.02276066f, 0.04129121f, -0.16935839f, -0.33789513f, -0.28128448f, -0.01017812f, 
    0.10858202f, -0.05762865f, 0.11122996f, 0.08944464f, -0.03275406f, -0.04760049f, 0.01784493f, -0.07321467f, 
    0.00515407f, -0.70290279f, 0.25657669f, 0.02202804f, -0.04720737f, 0.04936483f, -0.18389443f, -0.16674741f, 
    -0.06403115f, -0.00400739f, -0.04157249f, 0.01759407f, -0.02800430f, -0.20965374f, 0.02734907f, -0.02201229f, 
    0.07138520f, 0.01563241f, 0.12327652f, 0.03996718f, 0.00829937f, -0.02647431f, 0.01839271f, -0.04750388f, 
    0.00361217f, 0.03879491f, -0.12090302f, -0.11107189f, -0.07255791f, -0.12260599f, 0.14491484f, -0.01687175f, 
    0.10929699f, 0.02637928f, -0.03104786f, -0.00205507f, 0.21960188f, 0.10015595f, -0.07155052f, -0.05696254f, 
    -0.05118145f, -0.05170465f, 0.02370622f, -0.06148540f, -0.00478299f, -0.10187057f, -0.01408787f, -0.19524951f, 
    0.01955885f, 0.14396271f, 0.07359818f, 0.04298190f, -0.08706275f, -0.07118089f, 0.06171131f, 0.14167437f, 
    -0.00556611f, 0.04482335f, -0.11145419f, 0.06085185f, 0.07982992f, -0.18096051f, 0.29306921f, 0.35720173f, 
    -0.07305048f, 0.13469288f, -0.06706545f, 0.17643255f, 0.03392471f, -0.05717693f, -0.01371481f, -0.00077877f, 
    0.07951097f, 0.00798285f, 0.20744760f, 0.07062794f, -0.17672704f, -0.10194970f, -0.09489091f, -0.08414280f, 
    0.08149619f, -0.09643715f, 0.03557391f, -0.05113240f, -0.03669316f, -0.05305709f, -0.07085969f, -0.02290908f, 
    -0.07757713f, -0.04990014f, -0.01671174f, 0.08283155f, -0.11306129f, 0.04953892f, -0.07611736f, -0.05052667f, 
    0.09001132f, 0.07196743f, -0.07907853f, 0.17623590f, 0.00867822f, 0.01534874f, 0.06269362f, -0.07605190f, 
    0.11741517f, 0.00226336f, 0.11684120f, -0.02729543f, 0.04353989f, -0.01518638f, 0.03300482f, -0.05220782f, 
    0.03279804f, 0.00989810f, 0.14070435f, -0.01597710f, 0.04320898f, -0.09711663f, -0.05209366f, -0.07261634f, 
    -0.07271069f, -0.07961918f, 0.14936918f, -0.16605131f, 0.01857856f, 0.01269064f, 0.00550331f, -0.02676253f, 
    0.15382260f, 0.01819092f, 0.15001640f, 0.36747092f, 0.18100634f, 0.19302489f, 0.12331137f, 0.18084371f, 
    -0.16807330f, -0.00337906f, 0.04574228f, 0.11479177f, 0.00490830f, -0.02300802f, -0.04390575f, 0.12082261f, 
    -0.02567382f, -0.03264225f, -0.05309642f, -0.05420992f, 0.06826406f, -0.02347915f, 0.09054901f, 0.00172617f, 
    0.09484996f, 0.18257049f, -0.04824491f, 0.19393289f, -0.00624368f, 0.02436227f, -0.07172776f, -0.13142690f, 
    0.02052233f, 0.03091202f, 0.06583396f, 0.05861857f, 0.15132318f, -0.01985482f, -0.03109211f, 0.05381275f, 
    0.42959341f, 0.08045799f, -0.44356537f, -0.04709952f, 0.10741865f, -0.08091228f, 0.00091341f, -0.08049421f, 
    0.03502437f, -0.13465101f, 0.07079254f, -0.06260040f, 0.07245753f, -0.01379228f, 0.16351303f, -0.06398903f, 
    -0.01389140f, 0.07555435f, 0.09553199f, -0.12330942f, 0.11888678f, 0.06532012f, 0.04211610f, 0.09612475f, 
    0.14533877f, -0.22900911f, 0.01410366f, -0.01020584f, 0.08141202f, -0.05132176f, -0.03090459f, 0.04246199f, 
    0.08352307f, -0.08234724f, -0.04676275f, 0.00921867f, -0.03376247f, 0.20430624f, 0.22238784f, 0.32628816f, 
    -0.11542991f, 0.09757768f, 0.05998814f, -0.08297421f, -0.09479014f, 0.10167543f, -0.00317698f, 0.04545924f, 
    -0.02676518f, 0.14677685f, 0.13264938f, 0.20073798f, -0.05166975f, 0.01045537f, -0.17842397f, -0.18545035f, 
    0.13833752f, 0.00935990f, -0.00742653f, -0.06828003f, 0.11453637f, 0.24148244f, 0.18293859f, 0.29055458f, 
    -0.10791431f, 0.15030795f, 0.01045639f, 0.08715475f, -0.00262468f, -0.04653976f, -0.00090571f, -0.04910657f, 
    0.04496482f, 0.05725893f, -0.15960200f, 0.13525289f, 0.17739980f, -0.13588391f, -0.12147819f, 0.09958468f, 
    0.02994539f, 0.02822163f, -0.04425062f, -0.05812143f, 0.00439992f, -0.03328621f, 0.00881728f, -0.01330309f, 
    -0.00723453f, 0.02776079f, -0.01353680f, -0.01945291f, -0.14449830f, 0.00592915f, -0.01176801f, 0.01276566f, 
    0.10814184f, 0.10655710f, 0.12167776f, 0.09244591f, -0.00924793f, -0.08368047f, -0.00080637f, 0.02142171f, 
    0.05095211f, -0.00656335f, 0.00797897f, 0.10779036f, 0.00891944f, 0.11726797f, -0.00517087f, 0.06906936f, 
    -0.02725415f, -0.18148255f, 0.03820240f, -0.04122961f, 0.09477830f, 0.04622996f, -0.12278137f, 0.04317947f, 
    -0.06261546f, 0.02831304f, 0.01046215f, 0.09288585f, -0.11337522f, 0.03316115f, 0.13151455f, -0.03010678f, 
    -0.07793119f, -0.13031417f, -0.01370502f, -0.07542711f, -0.29712075f, -0.03732454f, 0.02402383f, 0.19355583f, 
    -0.11133686f, -0.05824087f, 0.05931601f, -0.00434828f, 0.02372498f, 0.07739366f, 0.05428377f, 0.09257018f, 
    0.11992830f, 0.09122545f, 0.21261746f, 0.16415708f, -0.04348987f, -0.15759498f, -0.08117710f, -0.02490587f, 
    -0.00204923f, -0.01430768f, 0.07651974f, 0.03683423f, 0.23272222f, -0.05981801f, 0.06096511f, 0.06967933f, 
    0.12543491f, -0.16747987f, 0.01996784f, -0.06126315f, -0.09406576f, -0.01508026f, -0.10008329f, -0.02971184f, 
    0.09270440f, 0.04497961f, -0.03251458f, -0.14393999f, 0.03960563f, 0.06635635f, 0.01004383f, -0.04872516f, 
    0.10646826f, -0.06961907f, 0.01988537f, 0.03431708f, 0.06647820f, 0.01409288f, -0.00284653f, 0.03808551f, 
    0.17570658f, 0.08081833f, 0.02410367f, 0.03597044f, 0.00881471f, 0.01959509f, -0.04576420f, 0.12363454f, 
    0.26041040f, -0.34164548f, 0.00602925f, -0.03771274f, -0.02631283f, -0.01385920f, 0.04951739f, -0.01456958f, 
    0.08019661f, 0.03668508f, -0.14817150f, 0.01031682f, -0.25717899f, -0.20835790f, 0.11273099f, -0.11588741f, 
    -0.08144220f, 0.05110574f, -0.08150482f, -0.00870558f, -0.12452482f, -0.15860923f, 0.01242611f, -0.00618174f, 
    -0.09018508f, -0.13993244f, 0.05146005f, -0.06984519f, 0.05893964f, -0.06272711f, -0.32651460f, 0.05027567f, 
    -0.14570361f, -0.18247394f, 0.09601101f, -0.17819431f, 0.12117360f, 0.15823434f, 0.08635045f, 0.10748249f, 
    -0.05186075f, -0.14896603f, -0.03463540f, 0.06044185f, 0.04374756f, -0.05196530f, 0.00549708f, 0.01858413f, 
    0.27248234f, 0.02262151f, 0.18075389f, 0.06615779f, 0.01625160f, -0.10350963f, 0.12420879f, 0.06239811f, 
    0.10098214f, -0.01749568f, 0.06939983f, 0.00572007f, 0.07995694f, 0.20891424f, 0.21640164f, 0.19312838f, 
    -0.20469795f, -0.04819510f, 0.01114012f, 0.21378902f, 0.09977929f, 0.03195582f, 0.01486084f, -0.02359639f, 
    0.16366063f, -0.13930258f, 0.04993033f, 0.00867207f, -0.15099618f, -0.22271833f, -0.09886635f, 0.08221392f, 
    0.00670396f, -0.02497885f, -0.03457850f, -0.06249220f, -0.39598608f, -0.54598975f, -0.16039640f, -0.87457037f, 
    0.05869056f, 0.05993504f, 0.02894598f, 0.03339398f, 0.00461653f, -0.07018716f, 0.00111885f, -0.21500589f, 
    0.05829300f, -0.50118047f, -0.02373741f, 0.07502479f, 0.02107431f, -0.05217152f, -0.06812423f, -0.16796127f, 
    -0.05952523f, 0.02542805f, -0.09994329f, -0.07828543f, -0.01266597f, 0.10206509f, 0.02183635f, 0.16365768f, 
    -0.00654052f, 0.10037947f, 0.08128258f, -0.06375819f, 0.06563211f, -0.02298001f, 0.01035525f, -0.07190215f, 
    0.08093892f, 0.16113162f, 0.18685283f, 0.13166671f, -0.09180467f, 0.00721937f, -0.04021527f, -0.07234018f, 
    -0.14970268f, -0.02911949f, -0.00056527f, -0.03352406f, 0.02239226f, 0.15025501f, -0.30986318f, -0.05134489f, 
    -0.06344660f, 0.12906419f, -0.13472623f, -0.03832843f, -0.07491986f, 0.00725264f, -0.04994662f, 0.05048828f, 
    0.18160971f, 0.19251283f, -0.07226507f, 0.11327170f, -0.10296030f, -0.05935010f, -0.06005325f, 0.08627179f, 
    -0.15882786f, -0.07410735f, -0.28516796f, -0.01709006f, 0.08146512f, -0.27350381f, -0.07351401f, -0.11957236f, 
    0.06233675f, 0.01114802f, 0.00942042f, 0.08048448f, -0.04621089f, -0.21233824f, -0.09780528f, -0.02721461f, 
    0.16823778f, -0.08617134f, 0.16659494f, 0.06970845f, 0.06614009f, 0.00917242f, 0.01313791f, 0.12402123f, 
    -0.03743072f, -0.03078666f, -0.01740545f, 0.00184164f, -0.13897596f, -0.06759050f, -0.11634944f, 0.20884940f, 
    -0.06701706f, -0.00008331f, -0.06109299f, -0.22612658f, -0.10707930f, -0.04878625f, -0.06478149f, 0.19342853f, 
    0.10543449f, -0.28125787f, 0.06836503f, -0.00069894f, 0.00943566f, -0.07550108f, -0.11496137f, 0.06298152f, 
    0.05366261f, -0.00151307f, 0.05834883f, 0.11890107f, 0.05149607f, 0.12172089f, -0.11386947f, 0.13514422f, 
    0.11381122f, 0.09927227f, -0.05499411f, 0.09308321f, 0.02169266f, -0.02666846f, 0.02136700f, -0.13914113f, 
    -0.01189301f, -0.01549508f, 0.19019385f, 0.07316685f, -0.16042659f, 0.01197249f, -0.11080407f, -0.04532647f, 
    -0.01818457f, 0.03584258f, 0.03028038f, -0.06098212f, 0.01072298f, -0.05585892f, 0.08798652f, -0.06472174f, 
    -0.10157452f, -0.05149598f, -0.00676376f, -0.03371897f, 0.13029778f, 0.17510910f, 0.00421218f, 0.13008299f, 
    -0.20357859f, -0.01955809f, 0.05046700f, 0.15520853f, 0.02437027f, -0.06604832f, -0.20846738f, -0.04622787f, 
    -0.08508290f, -0.04102664f, -0.01840788f, -0.02339444f, -0.11169144f, -0.15893205f, 0.09857292f, -0.06516625f, 
    -0.11033340f, -0.03782148f, -0.24147125f, -0.12734708f, -0.24221127f, 0.03731060f, -0.27485710f, -0.16221017f, 
    0.05121283f, -0.01335028f, -0.03611739f, 0.10072522f, 0.02323937f, -0.03271883f, 0.05991708f, -0.05247832f, 
    0.06666104f, 0.05556047f, 0.05065949f, 0.36254671f, 0.02775797f, 0.07990203f, 0.07847130f, 0.05358050f, 
    -0.05078641f, -0.03208410f, -0.10243993f, -0.09623238f, -0.20472756f, -0.12863681f, 0.01839435f, -0.22203574f, 
    -0.01343933f, 0.03027650f, -0.03737308f, 0.27694914f, 0.10309185f, 0.02968250f, -0.07596941f, -0.14093548f, 
    -0.09274439f, 0.15968753f, 0.02306342f, 0.00970273f, -0.11386323f, -0.03604112f, -0.46021742f, -0.12134702f, 
    0.02406088f, 0.02191271f, 0.00298434f, 0.06461513f, 0.15421681f, -0.07872139f, -0.02288593f, -0.09130053f, 
    -0.28182948f, -0.13631961f, 0.14504068f, 0.08157816f, 0.07463165f, -0.10336233f, 0.00984985f, -0.04489902f, 
    0.11571950f, 0.01391607f, -0.02204419f, -0.23195969f, -0.08072293f, -0.13069114f, 0.03416428f, 0.00107324f, 
    -0.03277650f, 0.04528703f, -0.14311536f, -0.10809461f, -0.00426786f, -0.18073520f, 0.27409708f, -0.14206102f, 
    -0.14366093f, 0.01698980f, -0.06096411f, -0.01805825f, -0.00524101f, 0.14747615f, 0.09157977f, 0.11657310f, 
    0.17699303f, -0.00268338f, 0.28877354f, 0.05490859f, -0.06108850f, -0.16560948f, -0.11747718f, 0.13916627f, 
    0.11260162f, 0.11769097f, -0.02135977f, 0.02886670f, -0.04821511f, 0.00793494f, -0.08383372f, -0.12941320f, 
    0.02267850f, 0.12867019f, -0.30156261f, -0.23623700f, -0.03556703f, 0.24048574f, -0.05370780f, 0.13818504f, 
    0.05844990f, -0.13010234f, -0.00088922f, -0.30176076f, 0.25755039f, -0.20467877f, -0.53592658f, -0.21700828f, 
    0.02458966f, 0.14122331f, -0.02858472f, 0.12071870f, 0.16992515f, 0.01862106f, 0.05047498f, 0.02708329f, 
    -0.24403140f, -0.05054630f, -0.25405410f, -0.24303605f, 0.07457886f, 0.01662738f, -0.02403567f, -0.03774834f, 
    0.10003654f, 0.04398922f, -0.15710190f, -0.23464043f, -0.61499536f, 0.04196034f, 0.14460865f, 0.22215357f, 
    -0.20517820f, -0.07162189f, -0.01421373f, 0.13071319f, -0.13477448f, -0.12468800f, -0.08265183f, 0.14569798f, 
    -0.11192399f, 0.08449531f, 0.21882786f, -0.13191144f, -0.00010770f, -0.17513067f, 0.06822697f, 0.05469506f, 
    0.16951440f, -0.10046209f, -0.13934219f, -0.00648013f, 0.01210900f, 0.07235595f, -0.53983057f, -0.03812339f, 
    -0.01711244f, -0.03578738f, 0.04158583f, 0.02310784f, 0.02602182f, 0.02721937f, -0.12554067f, 0.02617949f, 
    -0.08127250f, -0.06314891f, -0.08862378f, 0.19786590f, -0.27725521f, -0.12107802f, 0.02071796f, -0.05441707f, 
    0.03088758f, 0.06664353f, 0.25257903f, -0.08533549f, -0.44645935f, -0.24073251f, 0.24483624f, 0.01693946f, 
    -0.01663873f, 0.04175787f, -0.00524929f, -0.02064967f, 0.10992123f, -0.04390157f, 0.12459647f, 0.07877000f, 
    -0.22401477f, -0.22390209f, -0.18094574f, -0.04907147f, 0.04079407f, 0.04179200f, -0.08923008f, 0.13593878f, 
    -0.10411994f, 0.01411983f, 0.12949397f, -0.12300294f, -0.05084901f, -0.42615449f, 0.26426092f, 0.19185688f, 
    -0.09353685f, -0.18106151f, -0.04254332f, -0.01775592f, 0.07548300f, -0.02829485f, 0.04214832f, -0.03484121f, 
    0.19376175f, -0.00303095f, 0.16792625f, 0.10705224f, 0.07409582f, 0.26088649f, 0.05491554f, 0.04535693f, 
    0.05546840f, 0.03662953f, -0.00121003f, 0.06760487f, 0.05088920f, -0.07146403f, 0.08695452f, -0.00386977f, 
    0.24751437f, -0.13379225f, 0.02566907f, 0.00661440f, 0.02231537f, 0.04051038f, -0.15984251f, 0.16829930f, 
    -0.00979738f, 0.02453918f, -0.18173103f, 0.10951059f, 0.01984498f, -0.00574081f, 0.01806385f, -0.01876432f, 
    -0.10385311f, -0.05863560f, 0.07211419f, -0.14830753f, 0.12156610f, -0.07541251f, -0.12946630f, 0.06352603f, 
    -0.01357754f, 0.04515204f, -0.03056824f, -0.06528056f, 0.03303447f, 0.11335365f, 0.03237675f, -0.01820437f, 
    -0.01794275f, -0.20360029f, -0.10298023f, -0.07743634f, -0.00634393f, -0.00661610f, 0.12687793f, 0.03640089f, 
    0.02031900f, -0.33808374f, -0.26308411f, -0.54111195f, 0.07467677f, 0.16145846f, -0.08836956f, 0.05939843f, 
    0.11454526f, -0.14043327f, -0.08977062f, -0.14124517f, -0.06327442f, 0.11582849f, -0.06981775f, -0.03763001f, 
    0.21034247f, -0.25568485f, -0.09350986f, 0.08142251f, -0.02736971f, 0.03272583f, 0.02386217f, -0.04445940f, 
    -0.16686000f, -0.40846604f, -0.10953934f, -0.31810552f, -0.11567590f, -0.17289634f, 0.03010358f, -0.05164156f, 
    0.03249053f, -0.02611789f, 0.00569352f, -0.05059559f, -0.18346925f, 0.26201111f, 0.11788513f, -0.07020701f, 
    -0.36632380f, -0.12878011f, -0.57111895f, 0.21199730f, -0.00259933f, 0.04530910f, -0.06769513f, 0.03624795f, 
    0.07044940f, 0.02596519f, 0.12836587f, 0.02219728f, 0.33450082f, -0.10375831f, 0.04379341f, 0.13576247f, 
    0.04216567f, -0.03439981f, -0.04896171f, 0.09396426f, -0.03822770f, -0.20319048f, 0.00978732f, -0.20627415f, 
    0.03198408f, -0.06825620f, -0.02837305f, -0.06220491f, 0.10409489f, -0.06628732f, -0.03671024f, -0.05471609f, 
    0.02199432f, 0.03261460f, -0.05747854f, -0.04958920f, 0.24993341f, 0.04337912f, 0.09874886f, 0.03878026f, 
    0.12384462f, -0.12256973f, -0.03401677f, -0.07829109f, -0.05906512f, 0.07352923f, -0.02969941f, -0.07362056f, 
    0.06525639f, 0.11502115f, -0.05038480f, -0.00630559f, -0.06700365f, 0.00702962f, 0.11054602f, 0.14001609f, 
    -0.07959742f, -0.08162791f, -0.02123094f, -0.11687516f, -0.21157295f, -0.22515018f, -0.17087106f, 0.07857045f, 
    0.22416022f, 0.01036434f, -0.03105724f, -0.05487459f, -0.01535766f, -0.05278780f, 0.06036511f, 0.01187553f, 
    -0.05967610f, 0.25040248f, -0.06436047f, -0.24084599f, 0.06396571f, -0.03451416f, 0.17413449f, 0.06317554f, 
    0.07206363f, -0.01741299f, 0.04425341f, 0.11451084f, -0.04953254f, -0.06879649f, 0.03540832f, -0.01521887f, 
    0.06220589f, -0.12477104f, -0.06828362f, 0.15659836f, -0.04728870f, 0.09056599f, -0.11947638f, 0.04037125f, 
    -0.03245585f, 0.02373626f, 0.09338972f, -0.17103495f, 0.14886963f, 0.10323358f, 0.20464669f, -0.11320907f, 
    0.05348639f, 0.06769974f, -0.00951647f, -0.00341542f, -0.07085165f, -0.13158323f, -0.01326522f, -0.18915719f, 
    0.03102316f, 0.17708191f, 0.09452356f, 0.26798111f, -0.07361589f, 0.03120787f, 0.03642188f, -0.04250737f, 
    -0.15368313f, -0.06919911f, -0.01761143f, 0.12934120f, 0.09311300f, 0.08250042f, -0.14046387f, 0.10753506f, 
    0.05917036f, -0.09687225f, 0.13647406f, 0.05578892f, -0.53724182f, 0.01786743f, -0.04069662f, -0.44357464f, 
    0.06958637f, -0.17957669f, -0.03222798f, 0.14965913f, -0.05816418f, -0.06389127f, -0.01568797f, 0.06232006f, 
    -0.04304648f, 0.13670184f, 0.21786745f, -0.04614936f, 0.05448943f, 0.02477421f, 0.09162769f, -0.11204958f, 
    -0.05999930f, -0.04104576f, 0.04118802f, -0.00466009f, -0.07104949f, 0.09978650f, 0.02525438f, -0.23051775f, 
    -0.23080060f, 0.00883162f, 0.11874389f, -0.07826248f, 0.05368924f, -0.01955042f, 0.18918709f, 0.02912324f, 
    -0.06447311f, -0.07424089f, -0.20729062f, -0.04354143f, 0.02150421f, -0.01503253f, -0.00347830f, -0.00893950f, 
    0.09944123f, -0.06645949f, 0.12912780f, -0.15205814f, -0.08014174f, -0.04981885f, 0.01379870f, -0.02539204f, 
    0.03939908f, -0.11621265f, -0.06970634f, -0.00967823f, -0.00780619f, 0.03744408f, -0.09282670f, -0.02921976f, 
    0.16270693f, -0.35634249f, 0.05783312f, 0.25230095f, -0.11028052f, 0.02578012f, -0.01983319f, -0.10096165f, 
    0.30511349f, -0.30247900f, 0.29720342f, 0.03083297f, 0.15125954f, 0.01435249f, 0.30509186f, -0.10855167f, 
    -0.01996667f, 0.01902058f, 0.09928698f, 0.02952323f, 0.01988937f, -0.00136340f, 0.10704397f, 0.14440469f, 
    0.06965414f, 0.02491495f, 0.05243417f, -0.11055063f, 0.03944833f, 0.05429766f, -0.11580712f, -0.14302763f, 
    0.27719334f, 0.15893070f, -0.00828019f, 0.01520696f, -0.48293984f, -0.09161534f, -0.19857812f, -0.22741356f, 
    0.03611737f, -0.01885704f, 0.09055682f, -0.03232208f, 0.11048806f, 0.03247593f, -0.06489613f, -0.03786768f, 
    0.09435984f, -0.02425564f, -0.26907536f, 0.13766590f, 0.01677064f, 0.08195528f, -0.02789021f, 0.09331778f, 
    -0.01842524f, -0.02563683f, -0.06467894f, -0.09449828f, 0.03007483f, 0.09846979f, 0.06904898f, -0.04058046f, 
    0.13237445f, 0.12926072f, -0.00385246f, -0.21679561f, 0.04257081f, 0.06070850f, 0.03727643f, 0.02966171f, 
    -0.25208554f, 0.24231234f, -0.12834439f, -0.13926251f, 0.13241710f, 0.10767742f, 0.09952734f, 0.01109506f, 
    0.27759877f, 0.03005155f, -0.08036274f, 0.00482855f, 0.37401837f, -0.08433088f, 0.14446492f, 0.04255408f, 
    -0.01218576f, 0.14414221f, -0.04826793f, -0.00556719f, 0.07255259f, 0.11572717f, -0.09645183f, 0.06063828f, 
    0.13263924f, 0.01692719f, 0.29041263f, 0.10684274f, 0.08974182f, -0.08950815f, 0.00245571f, -0.03653949f, 
    0.02059742f, 0.05597353f, 0.01549296f, -0.00263096f, -0.32815853f, 0.00557053f, -0.16243578f, 0.09688260f, 
    0.06571994f, -0.01903818f, 0.12863635f, 0.03935036f, 0.05441467f, -0.03888668f, 0.00934832f, 0.06556860f, 
    0.13222079f, -0.08051432f, 0.13882649f, -0.00894156f, 0.10449729f, 0.05291031f, -0.08551441f, 0.03512692f, 
    -0.01962320f, -0.05180121f, 0.09404995f, -0.03827897f, -0.26779148f, -0.10474088f, -0.15038528f, 0.25497195f, 
    0.10549264f, -0.07086914f, -0.09609079f, 0.14691916f, -0.02950143f, -0.17081465f, 0.13284256f, 0.10885074f, 
    -0.53813410f, -0.20812276f, 0.04540323f, -0.03627443f, -0.09941139f, 0.02915488f, -0.02502333f, -0.11736421f, 
    0.04367683f, 0.16566230f, 0.01067545f, 0.12621476f, -0.01689505f, -0.21139580f, -0.19293328f, -0.08088808f, 
    0.08063704f, 0.02775116f, 0.07882284f, -0.00664713f, 0.01334512f, -0.07796277f, -0.01377765f, 0.03763447f, 
    0.11791597f, 0.01248060f, 0.26423103f, -0.07886011f, -0.07089411f, 0.04199929f, -0.04144298f, -0.11034567f, 
    0.06903228f, 0.01133547f, 0.03858100f, 0.10269118f, -0.40356442f, -0.05955932f, 0.55673438f, 0.28622869f, 
    -0.01196061f, -0.16271666f, -0.06444170f, 0.22289017f, 0.10841192f, 0.01426424f, -0.12403805f, 0.02095432f, 
    -0.27791241f, 0.00568474f, -0.23350126f, -0.23436013f, -0.02351681f, 0.05639359f, -0.00036676f, 0.11469834f, 
    0.19535728f, -0.08843341f, -0.05946082f, -0.03112085f, -0.00918670f, 0.09065074f, -0.26358834f, 0.08450781f, 
    0.22715652f, 0.10167577f, -0.07559080f, -0.03962099f, 0.10369454f, -0.06612428f, 0.04370698f, 0.06853776f, 
    0.03944643f, 0.19266412f, 0.05963052f, -0.02127038f, 0.20624030f, 0.07596581f, 0.02068090f, -0.11478347f, 
    0.01866274f, 0.02423872f, 0.06197232f, 0.07719973f, 0.00977401f, -0.14919388f, 0.02662132f, 0.02254420f, 
    0.05458895f, 0.02227692f, -0.06118692f, 0.09512100f, 0.01286838f, -0.04747739f, 0.00863316f, -0.17467850f, 
    0.09782447f, -0.03662864f, 0.00818838f, -0.20826843f, -0.02547907f, 0.06305163f, -0.02678868f, 0.03536619f, 
    -0.03256057f, 0.07135355f, -0.03184328f, 0.03558797f, 0.00570884f, 0.05238831f, 0.17056935f, -0.39495215f, 
    -0.10496975f, 0.00393897f, 0.08973011f, 0.16915873f, 0.04503163f, -0.16096640f, -0.05932928f, 0.18582749f, 
    -0.10634009f, -0.03919599f, -0.04868279f, 0.00701496f, 0.06750914f, 0.06386121f, 0.01458811f, -0.00273759f, 
    -0.02402101f, -0.04661736f, -0.32255369f, -0.73909175f, -0.07514711f, 0.12150376f, -0.19231388f, 0.04976191f, 
    -0.22364087f, 0.09544051f, -0.10254856f, -0.13082646f, 0.16707553f, -0.01498537f, 0.09596488f, 0.04139872f, 
    -0.01055565f, -0.04098174f, 0.20887895f, -0.01429271f, -0.00501303f, 0.12735321f, -0.19349693f, -0.01881274f, 
    -0.00267256f, 0.02957766f, 0.01862220f, -0.12164531f, -0.07867946f, -0.14008118f, 0.05447479f, -0.13336891f, 
    0.01813652f, 0.02488265f, -0.01464866f, -0.12693138f, -0.05674108f, 0.12763825f, 0.05817987f, 0.21819468f, 
    0.10366938f, -0.00763569f, -0.04075340f, 0.02532699f, -0.05558657f, 0.01738822f, -0.03088138f, 0.10290038f, 
    -0.05865822f, -0.04554932f, 0.13849318f, 0.03339336f, -0.04450363f, -0.11076646f, -0.07477617f, 0.01131263f, 
    0.04466840f, 0.13156533f, -0.00316932f, -0.02402658f, -0.10175710f, -0.04152319f, 0.03323196f, 0.04347277f, 
    0.21502157f, -0.07425202f, 0.19699746f, 0.21296448f, 0.07711344f, -0.04051057f, -0.07696960f, -0.00781741f, 
    -0.06515434f, 0.00743225f, 0.01382955f, -0.02363092f, -0.01383387f, -0.03904524f, 0.00961876f, -0.03660113f, 
    0.09809726f, 0.01203950f, 0.10839696f, -0.01804890f, -0.03681868f, -0.06517146f, 0.06481753f, 0.00631707f, 
    0.43703985f, 0.22177835f, 0.00500693f, -0.12173127f, 0.09126282f, -0.09174924f, 0.14275447f, -0.07840890f, 
    0.13853008f, 0.08258392f, 0.07184803f, 0.04900113f, 0.21695134f, 0.37493879f, 0.10697596f, 0.38462427f, 
    -0.09656121f, 0.10300311f, -0.11624137f, 0.15153030f, 0.03131210f, -0.05365479f, -0.03601779f, 0.11943046f, 
    -0.37032044f, -0.14259891f, 0.27681226f, -0.34907144f, 0.01699482f, 0.04580362f, -0.07690070f, -0.08063703f, 
    -0.11195181f, 0.09755443f, 0.06758534f, 0.12692033f, 0.07737752f, -0.19321509f, 0.03110592f, 0.19578698f, 
    -0.13761920f, -0.07925282f, -0.06912310f, 0.19843125f, 0.00133372f, -0.02081248f, 0.31724435f, -0.10331196f, 
    -0.24645697f, -0.37010482f, -0.08770289f, 0.21661229f, 0.11943215f, 0.11226248f, -0.05031530f, -0.04001011f, 
    0.04578111f, -0.01593854f, 0.02236292f, 0.01560381f, -0.35347059f, -0.13662666f, 0.05978901f, 0.02791193f, 
    0.04610223f, 0.06213043f, -0.01684693f, -0.07542575f, 0.02024251f, -0.02057881f, -0.08997203f, 0.10795993f, 
    -0.02016812f, -0.06363460f, -0.11489138f, 0.13585077f, -0.05097584f, -0.01860511f, -0.26971796f, 0.03388510f, 
    0.03791940f, 0.08191440f, -0.01978476f, -0.18236446f, -0.21036954f, -0.09680129f, 0.23311487f, 0.14860103f, 
    0.04376539f, -0.05857757f, -0.09103553f, 0.02583108f, -0.09619206f, 0.05733501f, 0.04992300f, 0.09432054f, 
    -0.42161545f, 0.13951667f, 0.36351207f, 0.11099147f, -0.12571277f, 0.06306657f, -0.08170601f, 0.00385784f, 
    -0.02030430f, 0.05333661f, -0.00159908f, 0.00326557f, -0.33532879f, -0.19350623f, -0.34880182f, 0.04959558f, 
    0.03608922f, 0.12997702f, 0.04431709f, -0.06241433f, -0.07270853f, -0.06328544f, 0.03355241f, 0.08123030f, 
    -0.84278035f, -0.66485405f, 0.05077932f, -0.51007384f, -0.24286903f, -0.41175950f, -0.04976255f, -0.14726213f, 
    0.01259813f, -0.01421020f, 0.02740241f, -0.03245411f, -0.02809169f, -0.05495515f, -0.06891007f, 0.12015524f, 
    0.10541361f, 0.03159901f, 0.09423701f, -0.05988098f, -0.02394500f, -0.08238910f, 0.04326720f, 0.10299066f, 
    0.17116168f, -0.13025044f, -0.05697444f, -0.16278800f, 0.00913685f, 0.07373446f, 0.12767182f, 0.04960370f, 
    -0.00136411f, 0.03633273f, -0.00344257f, -0.04948968f, -0.04429670f, 0.07943851f, -0.02833878f, 0.06843710f, 
    0.06425285f, 0.07801643f, -0.03941049f, 0.01206718f, 0.01371130f, -0.08207373f, -0.01499612f, -0.00109636f, 
    0.07678833f, 0.21100582f, -0.06301661f, 0.00157523f, -0.03674158f, 0.00669739f, 0.03297613f, 0.06223716f, 
    0.04504973f, 0.15284057f, 0.34423441f, 0.13555694f, -0.41826141f, -0.20053950f, -0.18553033f, -0.22090350f, 
    -0.02737719f, -0.06112941f, -0.10032590f, -0.22197787f, -0.04642290f, -0.10044781f, 0.14123979f, 0.01980760f, 
    0.11164209f, 0.09625494f, -0.11242104f, 0.03639505f, -0.04837075f, 0.04121096f, 0.02607935f, 0.01520699f, 
    0.09094042f, 0.16099550f, 0.00823541f, 0.11455669f, -0.05741589f, 0.05146408f, -0.01193031f, -0.08622081f, 
    -0.03602351f, 0.01512611f, -0.01401236f, -0.02028881f, -0.06689421f, -0.04913281f, 0.00775610f, 0.04692812f, 
    0.05186300f, -0.03899747f, -0.00918931f, -0.03441937f, 0.00391212f, 0.04116587f, -0.07855341f, -0.04719199f, 
    0.03202406f, 0.04150930f, 0.03370070f, -0.07931419f, 0.31210381f, 0.34085464f, -0.44136870f, -0.10813425f, 
    -0.03444490f, 0.04483182f, 0.07809222f, 0.07193411f, 0.06045439f, 0.08663706f, 0.08413830f, 0.10327649f, 
    -0.39430299f, 0.09875625f, 0.00772306f, 0.04323956f, 0.05261301f, -0.03100821f, -0.11082985f, 0.07319072f, 
    -0.03247970f, 0.02293039f, -0.00230750f, 0.06273337f, 0.45154881f, -0.57784390f, -0.58841026f, -0.59480876f, 
    0.00314140f, -0.05915176f, -0.00569341f, -0.05903666f, -0.01723920f, 0.12954918f, -0.16726628f, -0.00297766f, 
    0.15098001f, -0.15686497f, -0.02694319f, -0.27018541f, -0.03315450f, 0.00402488f, -0.01304122f, -0.04690024f, 
    0.09170412f, 0.03090970f, 0.00588275f, 0.01797895f, -0.09263976f, -0.28002539f, -0.00049850f, -0.01555156f, 
    0.00941323f, 0.13164073f, 0.05653824f, -0.08466462f, -0.00763022f, -0.06378090f, -0.00605743f, -0.04078381f, 
    -0.08841794f, -0.26376903f, 0.04898108f, -0.00479241f, -0.08485119f, -0.11306273f, -0.01481283f, 0.19350533f, 
    -0.01375272f, -0.06515779f, 0.00140853f, -0.06700999f, 0.05759820f, 0.02770706f, 0.01793632f, -0.00331613f, 
    0.01685877f, 0.03226594f, 0.02205697f, 0.00737374f, 0.07387826f, -0.02944985f, -0.00540862f, -0.01936271f, 
    -0.72224993f, -0.43030924f, -0.29009098f, -0.24228619f, -0.06634158f, -0.25776699f, -0.25264943f, -0.38121331f, 
    -0.02127284f, -0.03337945f, 0.03560665f, -0.02663564f, -0.47975317f, 0.01711855f, 0.13103659f, 0.02088816f, 
    -0.16905016f, 0.19046153f, -0.00916449f, -0.07887688f, 0.00273710f, 0.05613629f, -0.12895368f, 0.03258965f, 
    0.03326217f, -0.12237369f, 0.05261251f, 0.01972339f, 0.01868218f, 0.06693866f, -0.09453546f, 0.00254433f, 
    0.02831156f, -0.23170623f, 0.11206529f, 0.02785644f, -0.61718166f, -0.49673903f, -0.29179749f, -0.00807962f, 
    -0.07646155f, -0.13651660f, 0.13979402f, 0.06266254f, 0.02439870f, 0.03921277f, 0.07245997f, -0.02445421f, 
    -0.32310590f, -0.55083388f, -0.27520123f, 0.16356394f, -0.06439803f, 0.16198203f, 0.02013352f, -0.22597803f, 
    -0.01571994f, 0.01992145f, -0.00893015f, -0.05434668f, -0.14391321f, -0.06009599f, 0.07207623f, -0.04607467f, 
    -0.13292305f, -0.27177137f, -0.26077834f, 0.09863772f, 0.03828514f, -0.09788387f, -0.00432745f, -0.11839286f, 
    -0.05932670f, -0.08589686f, -0.00987633f, -0.05214837f, 0.05627115f, -0.04122917f, -0.04118149f, 0.01611459f, 
    0.01280230f, -0.07453020f, -0.13647173f, -0.16888624f, 0.00811708f, -0.02130043f, -0.03022731f, -0.04974492f, 
    0.00143937f, -0.01712926f, -0.01040299f, 0.02371954f, -0.17896418f, -0.04893666f, -0.05333109f, -0.12378655f, 
    -0.08469614f, -0.00300013f, 0.04526277f, 0.02013576f, -0.17704920f, 0.09071124f, -0.10684239f, 0.06796236f, 
    0.11445346f, 0.07772859f, -0.00964384f, 0.03808849f, -0.03222794f, -0.01738187f, -0.35272446f, -0.12809801f, 
    -0.02767255f, 0.02217822f, -0.02537626f, 0.03731016f, -0.00365292f, 0.09264331f, -0.00323014f, 0.10355555f, 
    0.74977100f, 0.35861778f, -0.19524837f, 0.01769563f, 0.03402833f, -0.28079242f, 0.07377050f, 0.13786499f, 
    0.09177658f, -0.02141905f, -0.04383923f, -0.17108172f, -0.33222011f, 0.12314375f, 0.34609884f, 0.05310659f, 
    -0.02978657f, -0.06419843f, 0.03538549f, -0.03203854f, -0.01172781f, 0.05866171f, -0.02906030f, 0.06673660f, 
    0.10351317f, -0.07892835f, -0.14411603f, -0.14413917f, 0.04518963f, 0.03794749f, 0.25388262f, 0.05433991f, 
    0.01484931f, 0.04800704f, -0.04890948f, 0.04141970f, -0.52721012f, -0.64240092f, -0.34086147f, -0.33133057f, 
    -0.11244618f, -0.19409338f, -0.29858431f, -0.21513590f, 0.01037220f, -0.08054026f, 0.00350217f, -0.01209418f, 
    -0.13722266f, 0.03191013f, 0.08418921f, -0.17915852f, 0.06386461f, -0.10707612f, 0.15913941f, -0.11858149f, 
    0.09022523f, 0.07290097f, -0.08203821f, -0.01963672f, 0.11871188f, -0.05932856f, -0.28952104f, -0.12025139f, 
    -0.03330113f, -0.03710935f, -0.04835229f, 0.18946838f, -0.08704352f, 0.06324933f, -0.04991759f, -0.01294399f, 
    -0.25680545f, -0.14172478f, 0.09675319f, 0.03136696f, -0.03095402f, 0.03703492f, 0.00198692f, -0.06867424f, 
    0.03340812f, -0.03711139f, 0.01557011f, 0.15715621f, -0.02065043f, -0.25166634f, -0.06806353f, -0.00901323f, 
    -0.02545277f, 0.16965093f, 0.15599424f, 0.02625616f, -0.02064361f, -0.11773691f, 0.00754889f, 0.04469081f, 
    -0.31736061f, -0.14318009f, -0.46926683f, 0.29862690f, -0.04539471f, 0.12912108f, -0.00253572f, -0.17028658f, 
    0.07195068f, -0.10397636f, 0.08568660f, 0.02370099f, 0.15721133f, -0.00223769f, 0.08208042f, -0.09182616f, 
    -0.08708994f, 0.01604607f, 0.12573099f, -0.03386526f, 0.01880929f, -0.11414061f, 0.17099532f, 0.09898850f, 
    -0.15664981f, 0.06822439f, 0.27096128f, 0.15509614f, -0.03918894f, -0.12323980f, -0.05071865f, 0.13496938f, 
    0.09418444f, 0.18228242f, 0.08698352f, -0.09865125f, -0.09242763f, 0.07340507f, 0.10271904f, 0.03912751f, 
    0.06735965f, -0.04300088f, -0.03298616f, 0.06652375f, -0.03204845f, -0.02248710f, 0.22003005f, 0.11122595f, 
    -0.34103653f, -0.52302414f, -0.34067559f, -0.09683126f, 0.08717187f, 0.08435436f, -0.01703702f, -0.03850926f, 
    0.00378832f, -0.02188362f, 0.05580027f, 0.08739288f, 0.14514183f, -0.13265435f, 0.08473405f, 0.52975899f, 
    0.01942961f, 0.14148532f, 0.20064569f, 0.09846865f, -0.01291229f, -0.01693315f, 0.11001367f, 0.07828852f, 
    0.11309973f, 0.43130323f, -0.01099345f, -0.25627169f, 0.01630002f, -0.14599185f, 0.08854810f, 0.03685443f, 
    0.06479778f, -0.03052736f, 0.03910010f, -0.07355934f, -0.14502236f, -0.03204634f, -0.02246986f, -0.31792438f, 
    -0.11233746f, 0.08216672f, -0.01279261f, 0.05309700f, 0.02074993f, 0.03745843f, -0.06067256f, -0.02621775f, 
    -0.35433275f, -0.53562027f, -0.41676861f, 0.09305971f, -0.28203642f, -0.37121952f, 0.08072495f, -0.47844800f, 
    -0.01165500f, 0.03269629f, -0.06375212f, -0.02155716f, -0.24916652f, 0.15285890f, 0.09849481f, -0.06687003f, 
    -0.04749800f, 0.10177753f, 0.00438148f, 0.04939111f, 0.03652719f, 0.05208794f, 0.06128114f, -0.02920989f, 
    -0.28176799f, -0.31719962f, 0.20766026f, 0.24939778f, 0.04780572f, 0.04701646f, -0.09924331f, -0.07004554f, 
    -0.00518009f, 0.03857802f, 0.10071918f, -0.11007915f, -0.17201906f, -0.03984636f, 0.14791551f, 0.12110705f, 
    0.05500281f, -0.09703860f, 0.07876071f, 0.14777771f, -0.10690518f, 0.17116411f, -0.03185745f, -0.15249150f, 
    -0.02585238f, -0.07475059f, 0.03175614f, 0.01320849f, -0.01452252f, 0.03093200f, 0.03667426f, 0.01310309f, 
    -0.03620242f, -0.02986637f, 0.12893131f, -0.00638399f, -0.28770104f, 0.03844210f, 0.29179418f, -0.10973273f, 
    -0.00584936f, -0.20329735f, 0.05289691f, -0.08619934f, 0.02686196f, 0.09671237f, 0.04146370f, -0.08485484f, 
    -0.01619687f, 0.07699491f, -0.26981944f, 0.14333405f, -0.10613588f, -0.04953339f, -0.04306541f, -0.04149986f, 
    -0.04480939f, 0.07297954f, -0.03554826f, -0.14056173f, 0.31782246f, 0.26581332f, 0.02191160f, 0.16751598f, 
    0.03097506f, 0.01645924f, 0.01253699f, 0.11482981f, -0.08636309f, 0.05585565f, 0.06498325f, 0.00402194f, 
    0.21552506f, 0.09427552f, -0.19530183f, -0.03615708f, 0.00497131f, 0.01402284f, -0.03401349f, -0.12921514f, 
    -0.04431162f, 0.02649455f, -0.13743512f, 0.00009150f, 0.10128325f, -0.01373711f, -0.04476466f, 0.03385484f, 
    -0.07143609f, -0.09084573f, -0.01084775f, 0.00560578f, -0.08187474f, 0.01117571f, 0.09122721f, 0.02588703f, 
    -0.14342707f, -0.08297013f, 0.32094166f, -0.11734257f, -0.16388530f, -0.00936622f, 0.03802920f, 0.05739032f, 
    0.04790412f, 0.00196799f, 0.00199162f, -0.08952949f, 0.08434827f, 0.13872896f, -0.14085707f, -0.07928505f, 
    -0.04788717f, -0.01027847f, 0.04359214f, 0.00258561f, 0.10055035f, -0.00172242f, 0.07467608f, -0.05700860f, 
    -0.11300074f, 0.13033789f, 0.18345426f, 0.02470500f, -0.11720263f, 0.02202952f, 0.11523157f, 0.08050680f, 
    -0.09044699f, 0.06172356f, -0.04296938f, -0.05602014f, -0.56615603f, -0.05487148f, -0.46136937f, 0.10803320f, 
    -0.00368967f, -0.07166084f, 0.22061314f, -0.12622045f, -0.14759402f, -0.01538514f, 0.07051682f, -0.05111441f, 
    0.30520138f, -0.60129684f, -0.42359161f, -0.61683691f, -0.00520091f, -0.09453646f, -0.02641268f, 0.10828527f, 
    0.06937669f, 0.14984517f, 0.01568452f, 0.06498887f, 0.62583685f, -0.40867168f, 0.01577705f, -0.34018308f, 
    -0.05830235f, 0.08807439f, -0.02123333f, -0.02154220f, 0.01031963f, -0.00803437f, 0.00155053f, -0.06070046f, 
    0.17955159f, -0.23356473f, -0.09906366f, -0.24557167f, 0.00844873f, -0.13595718f, 0.07231778f, 0.05818452f, 
    0.00750524f, 0.04404727f, 0.06208823f, -0.24337249f, -0.00688822f, 0.11130629f, -0.01794043f, -0.13413812f, 
    0.06455474f, -0.07364845f, 0.00566502f, 0.02463866f, 0.00646563f, 0.00079019f, 0.05422357f, -0.01711574f, 
    0.18023612f, -0.05739254f, -0.02379251f, -0.04588358f, -0.00755425f, -0.11944202f, 0.06449100f, 0.05242293f, 
    0.01544994f, 0.00387749f, 0.03745785f, -0.07015954f, 0.26127946f, -0.00190838f, 0.11423629f, -0.22672261f, 
    0.03100839f, 0.06197992f, -0.00097696f, 0.00666794f, -0.14215821f, 0.00407662f, 0.01678610f, -0.27402157f, 
    0.37436402f, -0.44978556f, -0.10725816f, -0.36918217f, -0.06152657f, -0.14683692f, -0.11212752f, 0.14676125f, 
    0.06820522f, 0.02975401f, -0.04581001f, -0.00510162f, 0.16626464f, -0.13042922f, -0.14710625f, -0.04212263f, 
    0.02156113f, -0.13648695f, -0.11675276f, -0.06365874f, -0.02048870f, 0.05674227f, 0.02790280f, -0.01097015f, 
    -0.17449591f, -0.36333966f, -0.28032097f, 0.20780924f, 0.08796532f, -0.05562591f, -0.03111689f, 0.06025158f, 
    0.02470539f, -0.02290282f, -0.01332485f, 0.01378353f, 0.04289332f, 0.05534204f, 0.06571898f, -0.08345300f, 
    -0.08755164f, 0.03909853f, 0.05051362f, -0.10608723f, 0.01782907f, 0.03772889f, -0.04159874f, -0.03339625f, 
    -0.04531097f, 0.12272585f, -0.04947519f, -0.04862669f, -0.00484321f, 0.01014968f, 0.07270547f, 0.05057639f, 
    -0.04251720f, 0.06330890f, 0.10109916f, 0.01187333f, 0.07952154f, -0.01977265f, 0.07943405f, -0.04455306f, 
    -0.09788647f, 0.04665226f, 0.00282169f, -0.00921732f, 0.04494825f, -0.01643805f, 0.00799326f, -0.06990083f, 
    -0.20861506f, -0.01540567f, -0.01003163f, 0.12158813f, -0.03181574f, -0.10674211f, 0.04372994f, 0.00025584f, 
    0.02771273f, 0.10309541f, 0.23429514f, 0.01993636f, -0.45636454f, 0.71764189f, -0.41645125f, 0.31056151f, 
    0.18106140f, -0.04255626f, 0.09611820f, -0.00532696f, -0.04633609f, 0.04317031f, -0.03647881f, -0.02166170f, 
    -0.12686649f, 0.01543477f, 0.01860605f, 0.06224313f, -0.03390794f, -0.05989509f, -0.00535279f, 0.06098968f, 
    0.02610144f, 0.04440978f, 0.07674745f, -0.00589681f, 0.01688471f, 0.04182000f, 0.03956122f, 0.02628992f, 
    -0.02393863f, -0.05055510f, -0.00325096f, -0.08803665f, -0.11891226f, -0.09094910f, -0.06651627f, -0.03831642f, 
    -0.01247482f, 0.14372103f, 0.03876229f, -0.01233077f, 0.03116076f, 0.01720475f, -0.01674981f, 0.06995957f, 
    0.09556136f, -0.01385060f, 0.04453557f, -0.11142614f, -0.00887854f, -0.59626102f, -0.05199078f, -0.00573522f, 
    -0.08477783f, -0.04162589f, 0.07837240f, -0.09595234f, -0.02807558f, 0.02763797f, 0.03127333f, -0.02546104f, 
    -0.00745316f, 0.06608938f, 0.13317886f, -0.10385416f, 0.03137584f, 0.01229307f, 0.04611643f, 0.01714648f, 
    0.04367212f, -0.03533680f, 0.05915760f, 0.00412696f, -0.84149611f, -0.58500314f, -0.33337477f, 0.63334370f, 
    0.01340589f, 0.19295867f, -0.04233758f, -0.08783916f, -0.04160827f, -0.10691051f, -0.00078785f, -0.01554531f, 
    -0.23879702f, -0.17431924f, -0.23558751f, 0.10408709f, 0.09876906f, 0.03592812f, 0.16190380f, 0.06355223f, 
    0.07951439f, 0.04653137f, 0.08877681f, 0.04445787f, 0.03512432f, 0.01435237f, -0.04266315f, -0.07343356f, 
    -0.04476988f, -0.07328844f, -0.15043189f, -0.02654349f, 0.06412737f, 0.01113439f, -0.01616605f, -0.02869670f, 
    -0.17681292f, 0.09259850f, 0.05755756f, 0.06062238f, 0.09212500f, -0.25898203f, 0.13384695f, -0.09917381f, 
    0.00005391f, 0.01724460f, 0.03969069f, -0.06034755f, 0.02697371f, 0.00342412f, 0.04183714f, 0.04222380f, 
    0.00740755f, -0.06814997f, -0.00585814f, 0.01057018f, -0.16451591f, -0.07609481f, -0.10221819f, -0.01427111f, 
    -0.52139449f, -0.54513854f, 0.01290147f, 0.07380858f, 0.03161845f, 0.04264405f, -0.01097275f, -0.00372511f, 
    0.04900860f, 0.04047845f, 0.01857268f, -0.01393054f, 0.00542227f, -0.55532187f, -0.19912401f, -0.18320879f, 
    0.14202178f, 0.02309644f, -0.02570744f, -0.01762193f, 0.03152808f, -0.03993716f, -0.02039909f, 0.05911619f, 
    -0.00720013f, 0.11989522f, -0.02644967f, 0.03739085f, -0.13348517f, -0.05329627f, -0.04973279f, 0.02046026f, 
    -0.14667965f, 0.01188380f, -0.01348492f, -0.10345509f, 0.02258506f, -0.60589457f, -0.40938878f, -0.29222980f, 
    0.00224501f, 0.21231562f, 0.06766552f, 0.23980790f, 0.11840928f, -0.00060477f, -0.00887814f, -0.01381740f, 
    -0.29249880f, -0.38545474f, 0.06746204f, -0.12949163f, 0.11034902f, 0.11871489f, 0.14071900f, 0.20862730f, 
    0.01929233f, -0.04270569f, -0.05098904f, -0.03957669f, 0.07732727f, 0.06519259f, 0.01141806f, 0.10776997f, 
    0.07891949f, -0.07838776f, 0.10581154f, 0.06853602f, 0.00037510f, -0.03468812f, 0.02152572f, -0.04212881f, 
    0.03408472f, 0.03884955f, 0.01525898f, -0.10609250f, -0.00983727f, -0.00140565f, 0.02027490f, -0.03715483f, 
    0.13003656f, -0.05788719f, -0.11449756f, -0.16520037f, 0.05625392f, 0.00230191f, 0.04710254f, -0.09583956f, 
    -0.01222405f, 0.05300311f, -0.04563844f, -0.05972402f, -0.14036968f, -0.08709981f, 0.00698961f, 0.04041825f, 
    0.22195095f, 0.02848308f, 0.02087595f, -0.08800697f, -0.03365253f, 0.00586299f, -0.06013689f, -0.06759441f, 
    -0.15906371f, -0.08180108f, 0.10165127f, -0.19358405f, 0.14117922f, -0.40275690f, 0.23066811f, -0.13749222f, 
    0.06426138f, -0.02886833f, 0.00649936f, -0.07423067f, 0.02766164f, -0.08876850f, -0.03991360f, 0.00246848f, 
    -0.54667014f, 0.10417719f, -0.28032690f, 0.23780988f, 0.06814544f, -0.03746568f, 0.13829143f, 0.10893777f, 
    -0.07479847f, 0.05554500f, 0.04417707f, 0.08011505f, 0.56943756f, -0.15862373f, -0.27965790f, -0.11327770f, 
    -0.01793532f, -0.03783974f, -0.02007754f, 0.02717633f, 0.07709153f, -0.05385113f, 0.02329360f, 0.07649487f, 
    -0.02057002f, 0.10126556f, -0.01677867f, -0.13564397f, 0.02919680f, -0.12670647f, -0.05311080f, 0.02950094f, 
    -0.04362884f, 0.07962935f, 0.04749281f, 0.02511844f, -0.38978845f, -0.24330501f, -0.34218189f, 0.37472427f, 
    0.05394027f, -0.02921347f, 0.03002996f, 0.01433483f, 0.01994984f, -0.00745985f, -0.03148647f, -0.00456401f, 
    0.23176442f, 0.08555885f, -0.08146945f, -0.01472271f, -0.14923389f, 0.05484153f, 0.06703227f, -0.14248496f, 
    0.10382839f, -0.17361178f, 0.00372785f, 0.08159018f, -0.38677549f, 0.09967507f, -0.20847113f, -0.02229943f, 
    0.06823547f, -0.05806687f, 0.07646732f, -0.09527200f, 0.06030243f, 0.03791733f, 0.00297669f, 0.00044289f, 
    0.12044892f, 0.21602742f, -0.12675476f, -0.07101090f, -0.12669933f, 0.04767092f, 0.04697618f, -0.07354843f, 
    -0.06434788f, 0.11341619f, -0.05450817f, -0.15186755f, -0.10930751f, 0.12310945f, -0.06080914f, -0.01774543f, 
    -0.09032573f, -0.08057051f, 0.02495013f, 0.00111203f, 0.05094848f, 0.01072134f, 0.01749920f, -0.06483180f, 
    -0.38251397f, -0.49947175f, 0.12648259f, 0.06366908f, 0.03826308f, -0.02951903f, 0.08968791f, -0.00589739f, 
    0.02248636f, 0.07931638f, -0.03002672f, -0.05197486f, -0.03521911f, 0.04837001f, -0.10587320f, 0.12799206f, 
    -0.06786311f, 0.00646948f, -0.01914028f, -0.04902667f, -0.08052404f, -0.08006057f, -0.13462286f, -0.02826301f, 
    0.38775802f, -0.03054905f, -0.49356973f, -0.23007023f, 0.00439241f, 0.08341040f, 0.01921681f, 0.01975918f, 
    -0.06127004f, 0.09619672f, -0.16329254f, 0.07112221f, -0.03215646f, -0.05061931f, 0.11209957f, -0.17783234f, 
    0.03536592f, -0.01583392f, 0.01302797f, -0.04355318f, 0.09057332f, -0.17909338f, 0.03592600f, -0.26124641f, 
    0.15891005f, -0.03326203f, 0.36826849f, 0.04169196f, -0.15851586f, -0.18914504f, -0.18321706f, -0.04868981f, 
    -0.00556087f, 0.04279355f, -0.04282410f, -0.01085891f, 0.16591914f, -0.26664823f, -0.27516544f, -0.03060723f, 
    -0.02486040f, -0.18774791f, -0.07132245f, -0.09462798f, -0.04152241f, 0.09377136f, 0.00973556f, -0.04101061f, 
    -0.00537903f, 0.14897546f, 0.15972948f, -0.01406875f, -0.01579816f, -0.04278041f, 0.09162595f, 0.03958740f, 
    -0.05230326f, 0.15729499f, -0.03857282f, 0.08135200f, -0.19019252f, 0.20572145f, -0.17927130f, 0.14963658f, 
    0.02908279f, 0.09484680f, 0.13028553f, -0.01874800f, -0.01234281f, -0.02675646f, 0.03436208f, 0.00303138f, 
    -0.42909569f, -0.30445814f, -0.23172317f, -0.17210340f, 0.16185430f, -0.06182387f, -0.03918577f, 0.19269349f, 
    0.03236571f, -0.06169624f, -0.01752869f, -0.02158176f, 0.21279468f, -0.28015450f, -0.23973608f, -0.32948822f, 
    -0.03492724f, -0.13070489f, 0.00210824f, 0.03804512f, 0.14010416f, 0.05207232f, 0.02218729f, -0.00908992f, 
    -0.33679986f, -0.32341123f, -0.08276266f, -0.27789304f, 0.05457490f, -0.10714325f, 0.04201843f, 0.08588639f, 
    -0.05509485f, -0.03521418f, -0.02671744f, 0.03331856f, 0.22861153f, -0.28952277f, 0.35824892f, -0.46863595f, 
    -0.14306422f, 0.02772767f, -0.00792753f, 0.03570272f, 0.07312328f, 0.12249061f, -0.06403578f, -0.02587559f, 
    0.09330212f, 0.09411514f, -0.08635440f, 0.01776840f, -0.05999453f, -0.00881173f, 0.02270696f, 0.00541301f, 
    0.13427131f, 0.05796669f, 0.13238963f, 0.01145847f, -0.27044129f, 0.37423173f, -0.19052415f, 0.10223616f, 
    0.01194647f, -0.01571782f, 0.06171576f, 0.00226826f, -0.13902190f, -0.03150786f, -0.00304923f, 0.00215272f, 
    0.05360185f, 0.00667947f, -0.02925431f, -0.08141804f, 0.02288426f, 0.07726970f, -0.07764144f, 0.04530904f, 
    0.02527523f, 0.05795526f, -0.01925437f, 0.04731721f, -0.25210023f, -0.10821055f, 0.03205076f, 0.02081079f, 
    -0.04862786f, -0.04831200f, 0.00223794f, 0.00422469f, -0.03901370f, 0.00247821f, 0.07663745f, -0.11089382f, 
    0.35399157f, 0.03379492f, -0.12862509f, -0.04845195f, -0.05522486f, -0.00950932f, -0.03661332f, -0.02433791f, 
    -0.01049394f, -0.03112257f, 0.09821957f, -0.03102701f, -0.18606000f, 0.04833662f, 0.02151940f, -0.05610605f, 
    -0.03326061f, -0.10456626f, -0.02298388f, -0.03840147f, -0.13490079f, -0.02275742f, -0.17361270f, -0.15754949f, 
    -0.44605300f, -0.11011627f, -0.07383720f, 0.41778097f, 0.00562534f, 0.16139238f, -0.03413720f, 0.13699704f, 
    -0.00614822f, -0.15116793f, -0.23868062f, 0.00480471f, -0.27458903f, 0.07481157f, 0.10647026f, -0.00611855f, 
    0.04417409f, 0.02934235f, -0.07414409f, -0.09211277f, -0.07695708f, -0.10264854f, -0.02247014f, -0.10166313f, 
    -0.65932518f, -0.01555041f, 0.21819787f, 0.25805598f, 0.10121089f, 0.02976064f, -0.00859104f, 0.02050062f, 
    0.08608956f, 0.02389997f, -0.05959873f, -0.06708290f, -0.15693292f, -0.45987311f, 0.45112547f, 0.22196950f, 
    -0.07101291f, 0.21610655f, 0.00699825f, 0.05095319f, -0.12673789f, 0.07420805f, -0.03710670f, 0.08777137f, 
    -0.53070998f, -0.52141368f, -0.57030547f, -0.07633203f, 0.08623963f, 0.20526877f, 0.18505727f, 0.23794279f, 
    0.04697860f, 0.11673072f, -0.02090287f, -0.00533298f, 0.31901833f, -0.01251513f, -0.34079957f, -0.33416158f, 
    -0.00237194f, 0.01079520f, -0.05086271f, -0.07111682f, 0.14453220f, 0.09187934f, -0.07855809f, -0.09515736f, 
    0.28877440f, 0.26675287f, -0.04865648f, -0.31381562f, -0.11651597f, -0.09431063f, -0.02559779f, -0.01126830f, 
    0.06395844f, 0.07550056f, -0.00615532f, 0.19848256f, -0.06758292f, 0.01962783f, 0.13061543f, 0.04030564f, 
    -0.07645878f, -0.00361311f, -0.11708056f, -0.01883770f, 0.00237814f, -0.02827044f, -0.12060651f, 0.03817803f, 
    -0.04245608f, -0.06176389f, -0.05049830f, 0.15251711f, -0.00009644f, 0.06879839f, -0.00961283f, 0.10898314f, 
    0.06673218f, -0.01820177f, 0.03735700f, 0.11405510f, -0.11174439f, -0.06926195f, -0.14614256f, 0.01022676f, 
    -0.09923951f, -0.03572802f, 0.09729351f, 0.02621089f, 0.10109583f, 0.04441638f, 0.10801273f, 0.12799817f, 
    -0.10678735f, -0.11766531f, -0.13294709f, 0.01004699f, 0.04787553f, 0.13262989f, 0.10696393f, 0.07524672f, 
    -0.05849749f, -0.08205909f, -0.05984894f, -0.06601016f, 0.26772797f, 0.23720926f, 0.01262256f, -0.15274832f, 
    0.07264290f, 0.01189900f, -0.02839098f, -0.22717394f, 0.10606958f, -0.06190384f, -0.01904499f, -0.02836530f, 
    0.08688286f, -0.57092708f, -0.68007612f, -0.04545776f, -0.25712636f, -0.05069730f, -0.02830135f, -0.03478931f, 
    0.02169561f, -0.00193538f, -0.01029518f, 0.02237864f, 0.13720158f, -0.00484516f, 0.05855663f, -0.04051558f, 
    0.05018909f, -0.00170150f, 0.01786793f, 0.03637893f, 0.01628325f, 0.03748589f, 0.06942930f, -0.03666643f, 
    -0.17978847f, 0.06001507f, 0.01734074f, 0.10274202f, -0.01087254f, -0.03012621f, -0.14502117f, -0.03163575f, 
    -0.32134503f, 0.02362460f, -0.14743900f, -0.11347128f, -0.03053632f, 0.02259201f, 0.05631981f, -0.07485846f, 
    0.15199348f, 0.02226659f, 0.00119198f, 0.03802484f, -0.00719340f, 0.05552822f, 0.05012018f, 0.18045916f, 
    -0.15770297f, -0.24579570f, 0.04314056f, 0.01519541f, 0.03025336f, 0.03941909f, -0.03678521f, -0.02606923f, 
    -0.12013403f, -0.18045129f, -0.00426308f, -0.35131440f, -0.44954401f, -0.59734559f, -0.40120465f, -0.17928685f, 
    0.07237427f, 0.19330299f, 0.01611757f, 0.08406430f, 0.15502769f, 0.09572846f, 0.06757148f, 0.04650239f, 
    -0.13126683f, 0.08832721f, -0.01391827f, 0.15764534f, 0.00415697f, 0.03636367f, -0.01703684f, -0.01331999f, 
    -0.19191922f, -0.17488536f, -0.32990259f, -0.26533797f, -0.12020770f, -0.05226936f, 0.10224359f, -0.08619434f, 
    -0.03268867f, 0.03489688f, 0.02515670f, -0.06329051f, -0.03615298f, -0.03870634f, 0.01109850f, 0.12569773f, 
    -0.25957161f, 0.20743874f, 0.09967545f, 0.12202255f, -0.13083762f, -0.02377386f, -0.07735539f, 0.08170984f, 
    -0.02012272f, 0.12744108f, -0.05863718f, 0.14362083f, 0.33383077f, -0.06476024f, -0.05584485f, 0.02143572f, 
    0.12689732f, 0.08395746f, 0.06595536f, 0.04875230f, 0.06041627f, -0.02545091f, -0.08694376f, -0.34350201f, 
    -0.10072973f, -0.17411059f, -0.12683660f, -0.16260974f, -0.09319577f, 0.12387966f, 0.00331150f, 0.00216761f, 
    0.03115881f, 0.14199783f, 0.06250648f, 0.19832008f, 0.44162124f, -0.10222364f, -0.51187724f, -0.08983386f, 
    0.30492193f, 0.00291917f, -0.09910082f, 0.10064588f, 0.10006491f, 0.08064731f, 0.21917890f, -0.03011876f, 
    -0.14421523f, -0.18819803f, -0.07381123f, 0.03116105f, -0.05054124f, 0.00016047f, -0.02314464f, 0.11786310f, 
    -0.28052065f, -0.05839784f, -0.05959436f, -0.08072525f, -0.25277728f, 0.14733171f, 0.07597613f, -0.00367043f, 
    0.01917501f, -0.08312681f, -0.01180401f, -0.08309980f, 0.01762682f, -0.01444420f, 0.04268071f, 0.01181043f, 
    -0.18076155f, -0.16173288f, 0.01033531f, 0.04826543f, -0.08205198f, -0.03976059f, -0.00011753f, 0.04833370f, 
    0.03617527f, 0.01131694f, 0.06849995f, 0.02264061f, -0.00228601f, -0.06561238f, 0.07740621f, 0.04793347f, 
    -0.01547879f, 0.03484119f, -0.02085201f, -0.02933618f, 0.02898382f, 0.02785001f, 0.06149406f, -0.07306407f, 
    -0.07681604f, -0.64384127f, -0.29480031f, 0.07027499f, -0.00425868f, 0.05821013f, 0.05785880f, 0.03933185f, 
    -0.06332036f, 0.00069115f, 0.01261143f, 0.01700606f, 0.02477445f, -0.35970646f, -0.34320644f, 0.11125757f, 
    0.23422979f, -0.01630378f, 0.22519848f, 0.16520418f, -0.05448246f, -0.21314801f, -0.01720284f, -0.05321405f, 
    0.01757606f, 0.04229357f, 0.03118005f, -0.05685874f, -0.05186358f, 0.00027662f, -0.01950974f, 0.05887194f, 
    0.05923154f, -0.03300505f, -0.02911093f, 0.01973376f, 0.00658770f, -0.45218301f, -0.59977579f, -0.06027605f, 
    -0.14564522f, 0.20051031f, 0.06976330f, -0.05572914f, -0.06569337f, -0.05055814f, -0.07705691f, -0.05392475f, 
    0.01783364f, -0.20412777f, -0.36645949f, -0.00619498f, -0.06853983f, -0.09631439f, -0.02991455f, -0.18296953f, 
    -0.08117148f, -0.00062980f, -0.05501787f, -0.10570534f, -0.06424083f, -0.17452085f, -0.13719806f, -0.10073295f, 
    -0.04370281f, 0.07313067f, 0.05542114f, 0.00436403f, 0.05556409f, 0.05520709f, 0.09273469f, 0.04479154f, 
    -0.31460169f, -0.03775526f, -0.13772666f, -0.19873947f, -0.09269950f, -0.02180366f, -0.02235867f, 0.00400872f, 
    -0.03182818f, 0.01663750f, -0.02206823f, 0.08283786f, -0.07927674f, -0.04798954f, -0.03511177f, -0.07207582f, 
    -0.00646793f, -0.03925668f, -0.01924834f, 0.01215183f, -0.00523939f, 0.05144560f, -0.01490562f, -0.02110839f, 
    0.18135791f, 0.06201366f, -0.06954952f, -0.16682094f, 0.02999696f, -0.09900317f, -0.02276899f, -0.02525002f, 
    0.17776112f, 0.12993322f, -0.16992570f, 0.22934087f, 0.20801987f, -0.02867122f, -0.01168904f, -0.30680358f, 
    0.11469449f, 0.00411449f, 0.07981350f, -0.00281463f, 0.06034192f, 0.04027346f, -0.01335679f, 0.17661123f, 
    -0.66562182f, -0.17888334f, -0.05064140f, 0.27321512f, 0.22039038f, 0.13050252f, 0.08404598f, -0.01369849f, 
    0.00598750f, 0.08308510f, 0.11465517f, 0.18678384f, -0.08466364f, -0.30961898f, -0.26163214f, 0.10988898f, 
    -0.08835974f, 0.17867731f, 0.11974242f, 0.10702053f, 0.00078146f, -0.00898346f, 0.05342099f, -0.13571960f, 
    -0.20363615f, -0.10741406f, -0.04049610f, 0.15500541f, 0.03117913f, 0.01751448f, -0.09446353f, -0.22113067f, 
    -0.27925405f, -0.21267620f, -0.10583763f, -0.08286075f, -0.24948938f, -0.41579005f, 0.01673849f, 0.12442794f, 
    -0.11056347f, 0.00449105f, -0.01720344f, 0.13369836f, 0.00125457f, 0.02774416f, 0.08155610f, -0.00082433f, 
    -0.07296034f, 0.00687196f, -0.12658000f, 0.04150705f, -0.12219049f, -0.13640772f, 0.16147386f, 0.14069682f, 
    -0.06931830f, 0.09310281f, -0.11184654f, -0.05004102f, -0.01039633f, -0.09821253f, -0.06251723f, 0.08258092f, 
    -0.04224740f, 0.03769753f, -0.01176583f, -0.04229410f, 0.00195571f, -0.07336863f, -0.04426292f, 0.15575722f, 
    0.19354348f, 0.13764407f, -0.27042323f, -0.13707164f, -0.06335712f, -0.07557647f, 0.03151133f, 0.11637996f, 
    0.06908590f, -0.01974327f, 0.10614607f, 0.16703814f, -0.12140685f, 0.05351243f, 0.12507182f, -0.06090767f, 
    0.00112460f, -0.03460253f, -0.10004794f, 0.00856939f, -0.00118780f, 0.05347630f, 0.07430253f, 0.12527612f, 
    0.27532932f, 0.06052382f, -0.00976204f, 0.22097725f, -0.08608335f, 0.08044687f, -0.09931112f, 0.01050844f, 
    0.07494241f, -0.05512882f, -0.00077238f, -0.03260792f, -0.28722557f, -0.09126403f, 0.06562965f, 0.05461390f, 
    0.03195456f, -0.05262855f, 0.00641543f, 0.07650251f, -0.10504470f, -0.07947435f, 0.09546059f, -0.15344933f, 
    -0.14306888f, -0.24179809f, -0.06576807f, -0.12009844f, -0.01616785f, 0.06071730f, 0.02971250f, -0.00481152f, 
    0.14723043f, 0.08771795f, 0.18546475f, -0.00425876f, -0.06605244f, -0.02214233f, 0.05531614f, -0.00294393f, 
    -0.05629752f, -0.00834288f, 0.01661719f, -0.00485368f, 0.06979121f, 0.12051243f, 0.06940653f, 0.20039748f, 
    0.16785984f, -0.15069810f, -0.02557337f, -0.58146667f, 0.02884822f, 0.02380172f, 0.03127538f, 0.03408208f, 
    0.05124217f, 0.07302176f, -0.00473609f, -0.03820672f, 0.42100358f, 0.09801595f, 0.04318818f, -0.21667990f, 
    0.14247781f, 0.00428439f, 0.00592864f, 0.01390308f, -0.05042152f, -0.01497895f, -0.03495051f, -0.00804599f, 
    -0.49178258f, -0.29274014f, 0.01290102f, -0.04911261f, 0.16123596f, 0.07793601f, 0.16271600f, 0.01789904f, 
    0.12551640f, 0.03310996f, -0.05185489f, 0.10659175f, -0.39443186f, 0.11901915f, 0.16741028f, 0.17267697f, 
    0.06622474f, -0.13179027f, -0.09395057f, 0.02117801f, 0.00863994f, 0.05848159f, 0.06127382f, 0.02840525f, 
    0.09552662f, 0.00150079f, -0.47648281f, -0.21173702f, -0.26305625f, -0.16602831f, -0.06343640f, -0.11477423f, 
    0.00687444f, -0.03701930f, 0.00015575f, 0.01592024f, 0.12940647f, 0.04179332f, 0.05548432f, -0.04838962f, 
    0.06665422f, 0.09860175f, 0.10496417f, 0.07240104f, -0.09239885f, -0.20574972f, -0.18779008f, -0.41009790f, 
    0.17235342f, -0.32591811f, -0.01914735f, 0.05473096f, 0.05399394f, 0.06492141f, 0.05177789f, -0.09419528f, 
    -0.00857605f, -0.03726602f, 0.02109514f, -0.01787367f, 0.00913989f, -0.26872331f, 0.05798552f, -0.14605759f, 
    -0.08750486f, -0.01841172f, 0.08678402f, 0.13485043f, 0.01089014f, -0.00629809f, 0.01299108f, 0.11603279f, 
    -0.14653873f, -0.05280920f, 0.01060007f, -0.08291044f, -0.03683921f, -0.00172617f, -0.04380301f, -0.05221377f, 
    -0.28460178f, 0.01579810f, -0.31554329f, -0.14209959f, -0.48187032f, -0.03635461f, 0.04750540f, 0.19756933f, 
    -0.06706142f, 0.15273847f, 0.11001594f, -0.01589609f, 0.15406629f, 0.01924718f, 0.24442622f, 0.24548592f, 
    -0.16368853f, 0.14462565f, -0.40265819f, -0.00689003f, 0.02971369f, -0.16113247f, 0.00817524f, 0.04608994f, 
    0.17851539f, -0.12613758f, -0.04734206f, -0.00256031f, -0.22825165f, -0.35443288f, 0.07207411f, -0.02065059f, 
    0.05012962f, 0.04408123f, 0.03591640f, 0.15761976f, 0.03937517f, 0.04305633f, 0.05302787f, -0.06246014f, 
    -0.26386166f, 0.02443128f, -0.06132716f, 0.26639810f, 0.11610378f, -0.00987503f, -0.01254313f, -0.09778900f, 
    0.03750885f, -0.10779916f, 0.02264699f, 0.18306348f, -0.06146624f, -0.09435499f, -0.02933739f, 0.01626962f, 
    0.10112563f, 0.06363950f, 0.23636334f, 0.18496141f, 0.04970488f, 0.00475812f, -0.01809172f, -0.01787824f, 
    -0.03952357f, 0.09806280f, 0.22230749f, -0.62409878f, -0.08132467f, 0.02148223f, -0.08176481f, 0.04358269f, 
    0.06637724f, 0.15120101f, -0.04183757f, 0.18555556f, 0.00148248f, -0.08199961f, -0.17012842f, -0.03761213f, 
    -0.08864862f, 0.19634515f, 0.08196170f, 0.16346154f, 0.10566845f, -0.00331731f, -0.00218780f, 0.01806622f, 
    -0.08593608f, 0.05563865f, 0.03187997f, -0.35447502f, -0.17219114f, -0.08970990f, 0.10871699f, 0.12833463f, 
    -0.02934421f, 0.10649864f, -0.02741976f, -0.10159374f, 0.02572584f, 0.04208147f, 0.13451146f, -0.81230032f, 
    0.14008066f, -0.38581094f, 0.01532369f, -0.06745639f, -0.09429168f, -0.00057037f, 0.09239917f, 0.09356289f, 
    -0.15282975f, 0.13786522f, -0.42285040f, 0.13122341f, -0.18857253f, -0.08314565f, -0.07944997f, 0.00013627f, 
    0.01344749f, 0.01506201f, 0.06724779f, 0.05237786f, -0.31028849f, 0.20541392f, 0.32788232f, 0.25937450f, 
    0.09556788f, -0.00708233f, -0.13244344f, -0.32096609f, 0.14562656f, 0.00339323f, -0.00161712f, -0.03341082f, 
    -0.28279066f, -0.27936086f, 0.20849663f, 0.04415037f, -0.04762465f, 0.26150939f, -0.26794422f, 0.16904932f, 
    -0.02401022f, -0.10355499f, 0.00215387f, -0.07773405f, 0.01944068f, -0.29816467f, 0.08822730f, -0.04863647f, 
    0.02032225f, 0.05593068f, 0.04751775f, 0.07790441f, 0.05062877f, -0.01949536f, -0.02940775f, 0.05754109f, 
    -0.03210123f, 0.05233184f, 0.28264266f, 0.14691609f, 0.10291156f, -0.02994390f, 0.06662529f, -0.08030063f, 
    0.08816088f, -0.15223287f, -0.11719057f, 0.08608950f, 0.20503172f, -0.10505316f, 0.20351110f, 0.15681753f, 
    -0.00226875f, 0.14988558f, -0.16043402f, -0.13443272f, -0.01249938f, -0.05420151f, -0.06425038f, 0.02361483f, 
    0.13804860f, 0.08025487f, 0.14376369f, 0.07957642f, -0.01849349f, -0.09500223f, -0.23537053f, -0.13072975f, 
    -0.00945752f, -0.01870878f, 0.08425977f, 0.18209764f, -0.09496865f, -0.36743626f, -0.16039090f, 0.01463401f, 
    0.13906923f, 0.05706891f, 0.15127625f, 0.11050986f, -0.03217134f, -0.01344163f, -0.00068189f, -0.05696442f, 
    -0.54132450f, 0.11146086f, -0.03884688f, 0.00797896f, -0.03928964f, -0.26879004f, -0.01032230f, 0.13606885f, 
    -0.00693783f, -0.00051011f, 0.06104552f, -0.00561771f, 0.07122710f, -0.32795930f, 0.08798096f, -0.24946977f, 
    0.01370155f, 0.07503293f, -0.10237153f, 0.10411563f, -0.00677206f, -0.09953636f, -0.04240153f, 0.00359543f, 
    -0.14460821f, 0.20294635f, -0.24201560f, 0.12615146f, 0.04086730f, 0.19778466f, 0.19579531f, 0.07887430f, 
    0.16742635f, 0.05096023f, -0.16183355f, -0.00630415f, 0.10237703f, -0.25854421f, -0.12170082f, -0.06118279f, 
    0.04146217f, -0.07351194f, 0.05459993f, -0.07895084f, -0.03152825f, -0.05011486f, -0.07396856f, -0.10324682f, 
    0.03561284f, -0.08586834f, 0.27464697f, -0.29006007f, 0.07584453f, -0.02113201f, -0.03772164f, 0.01663324f, 
    0.01373312f, -0.00878212f, 0.06527106f, 0.22198464f, -0.10453059f, 0.17063929f, -0.08331983f, -0.07327674f, 
    -0.05268667f, -0.07504173f, -0.01766386f, 0.00511768f, 0.09029740f, 0.00857738f, 0.02396044f, 0.03937997f, 
    0.02676682f, 0.08350645f, 0.29334158f, -0.25106019f, 0.01081563f, -0.05646041f, -0.05084936f, -0.01986518f, 
    -0.06708539f, 0.01236500f, 0.10323719f, 0.20349641f, 0.00140590f, -0.06353912f, -0.03229742f, 0.06120911f, 
    0.12024324f, -0.02236005f, 0.04596552f, -0.04822275f, 0.16797413f, -0.03496711f, 0.02730182f, 0.13163708f, 
    -0.18597881f, -0.36822233f, -0.19780496f, 0.07095505f, -0.00212729f, 0.09656597f, 0.03590162f, -0.02308272f, 
    0.06356600f, -0.04566916f, -0.08052301f, -0.00455402f, -0.06459738f, -0.01752651f, 0.42085177f, -0.17137669f, 
    -0.03596364f, -0.11490294f, -0.01836661f, -0.09437154f, -0.01268294f, 0.10149661f, 0.10220546f, -0.08582690f, 
    0.16000703f, -0.30439210f, 0.21213236f, -0.06436176f, 0.13659224f, -0.08324651f, -0.06600427f, -0.12511855f, 
    0.01635155f, -0.18277964f, -0.12613308f, 0.02417515f, 0.31353751f, 0.40240914f, -0.16329826f, -0.08825757f, 
    -0.16505027f, -0.12450315f, 0.05636889f, 0.01709886f, 0.11874785f, 0.01141499f, 0.03754135f, 0.06959078f, 
    0.00832360f, 0.62856293f, -0.23393753f, -0.14330932f, -0.11653963f, -0.08624092f, -0.01373275f, -0.05850869f, 
    -0.04282997f, 0.07008776f, 0.02937673f, 0.01712980f, 0.24111734f, -0.26097360f, -0.32925609f, -0.04455012f, 
    0.16859189f, 0.11390229f, 0.08536932f, 0.18284184f, -0.00162332f, -0.06699622f, -0.03979144f, -0.09412179f, 
    -0.10093318f, -0.03231673f, -0.11655921f, -0.40361962f, -0.11062780f, -0.12229183f, 0.04037897f, -0.04571290f, 
    0.02736892f, -0.01832454f, -0.08660778f, -0.07182553f, -0.11033939f, -0.33766451f, 0.00064647f, -0.06382791f, 
    0.08748361f, 0.13814037f, -0.12547645f, 0.11193127f, 0.17097533f, -0.04307610f, -0.01093682f, 0.07003301f, 
    -0.09941432f, -0.24447706f, 0.08755787f, -0.18603142f, -0.09943981f, 0.00818685f, -0.02118199f, 0.12583497f, 
    0.00724486f, -0.06085940f, -0.00516043f, 0.05719915f, -0.35852766f, 0.07873551f, 0.21566503f, -0.56513864f, 
    -0.00993517f, -0.15307383f, -0.03034126f, -0.08328665f, 0.07671711f, -0.01499902f, 0.03566257f, 0.10031619f, 
    -0.13460763f, -0.07562923f, -0.13928555f, 0.01655264f, 0.00860128f, 0.08293632f, 0.00476887f, 0.07579633f, 
    0.06509193f, -0.00164247f, 0.05583215f, -0.14209114f, -0.02920850f, -0.19564307f, -0.07097470f, -0.19533086f, 
    -0.20980085f, 0.08382866f, -0.12895602f, -0.07227246f, 0.13502006f, 0.04863799f, 0.07221136f, -0.00912623f, 
    -0.29044235f, -0.07725643f, 0.21429804f, -0.22442840f, -0.21503203f, -0.05553338f, 0.07446846f, 0.02646708f, 
    0.15804841f, 0.04385272f, 0.03214327f, 0.02242782f, 0.06994874f, -0.02114862f, 0.10020610f, 0.00796591f, 
    0.22759062f, -0.14524156f, -0.11490333f, -0.12007266f, 0.00092699f, 0.05198052f, -0.08132534f, -0.10798992f, 
    -0.03388350f, -0.06120855f, 0.30403864f, 0.15796421f, 0.14598724f, 0.12704699f, -0.08965673f, 0.07481463f, 
    0.11361015f, 0.12198302f, 0.04879797f, 0.04347510f, -0.03702391f, -0.21889864f, -0.10391834f, 0.08403632f, 
    -0.06690504f, 0.16277535f, 0.17226069f, 0.00289334f, 0.31193125f, 0.14681008f, 0.15503615f, 0.04314969f, 
    -0.05421602f, -0.00368586f, -0.07985637f, 0.10288895f, 0.06185846f, 0.12683804f, -0.16714631f, -0.05471506f, 
    0.10563910f, -0.20872426f, -0.15544777f, 0.02539944f, 0.11179724f, -0.25418147f, 0.02033456f, 0.12481634f, 
    0.01842239f, 0.00521905f, 0.09959818f, -0.01660382f, 0.01304699f, -0.01928692f, -0.12956978f, -0.08438361f, 
    -0.28937852f, 0.44868603f, 0.07029609f, -0.84251112f, 0.01036396f, -0.21128115f, 0.16855441f, -0.07351286f, 
    -0.13803041f, 0.00076530f, -0.04570902f, -0.01675107f, -0.02178749f, 0.18489145f, 0.11254979f, -0.32242393f, 
    -0.01591556f, -0.06074621f, -0.18262982f, -0.24219291f, 0.06869675f, 0.02764340f, 0.09996709f, 0.12073388f, 
    -0.08987348f, -0.07286341f, -0.12530270f, 0.03879916f, 0.09368140f, 0.11612515f, 0.11183533f, 0.07086253f, 
    -0.01801813f, 0.04455797f, -0.02837691f, -0.02062799f, -0.03337627f, 0.34150490f, 0.02294361f, -0.29990193f, 
    -0.03147899f, -0.09814319f, 0.20893198f, 0.16916457f, -0.09447948f, 0.06213692f, 0.02007173f, 0.03110391f, 
    -0.37859848f, 0.14391193f, -0.26596296f, 0.17843328f, -0.20202196f, -0.00102789f, -0.23298439f, -0.06471880f, 
    0.12840322f, -0.07166938f, 0.01091328f, 0.03229171f, -0.35219473f, -0.03786137f, 0.10159821f, -0.16880892f, 
    0.20398676f, -0.19865188f, 0.14040139f, -0.16275987f, -0.07085463f, -0.04101510f, 0.03671465f, 0.06800739f, 
    -0.37636548f, -0.08797003f, -0.06819312f, 0.17834713f, -0.04777789f, 0.18796511f, -0.18762343f, -0.01062500f, 
    -0.20216535f, -0.15543991f, -0.04687356f, -0.03409958f, -0.00570878f, 0.18980341f, -0.29033294f, -0.02775813f, 
    0.10678186f, 0.02585899f, 0.10132802f, 0.11083355f, 0.02963725f, -0.13762057f, -0.08366514f, -0.04995687f, 
    0.12899272f, -0.20475611f, -0.20306990f, -0.40662506f, -0.00310890f, -0.00037603f, 0.02663712f, 0.08527846f, 
    -0.00194969f, -0.04910753f, -0.00621526f, -0.00274702f, -0.13034771f, 0.14760970f, -0.30301559f, -0.03399152f, 
    0.14889625f, -0.09740675f, 0.06332261f, -0.04824137f, 0.05475874f, -0.03489836f, 0.02486349f, 0.04939557f, 
    0.32838380f, 0.17282668f, 0.30539483f, 0.26929525f, 0.14341441f, -0.14465976f, -0.04213826f, -0.15658991f, 
    -0.22172035f, -0.00885452f, -0.13746029f, 0.04470893f, 0.16015373f, -0.12751937f, 0.28333908f, -0.03860864f, 
    0.04358830f, -0.04740808f, -0.06587745f, -0.04949356f, -0.05354855f, 0.07438622f, 0.00990546f, -0.13031578f, 
    -0.22970560f, -0.71883655f, -0.03251966f, 0.18363281f, 0.01950303f, 0.19687894f, 0.12816097f, -0.03402928f, 
    0.00282593f, -0.02108705f, -0.01480267f, -0.03623099f, -0.42455879f, -0.33731714f, -0.08012889f, -0.23786882f, 
    -0.03432096f, 0.03930061f, -0.08964465f, 0.01582938f, -0.07448317f, -0.03752999f, 0.02095276f, 0.10242324f, 
    0.18876052f, -0.30340892f, 0.11592907f, -0.27079690f, 0.01332390f, -0.21200232f, -0.07400524f, -0.01190651f, 
    -0.23068728f, 0.00121136f, -0.10476080f, -0.03132287f, -0.40525088f, 0.04068076f, -0.16434003f, 0.03350648f, 
    0.05400739f, -0.16494039f, 0.12605411f, 0.06150252f, -0.02917024f, -0.02946221f, -0.06919985f, -0.06319278f, 
    -0.42261472f, -0.03006749f, -0.11437501f, 0.04155649f, 0.02010849f, -0.11243607f, -0.00006573f, 0.23560008f, 
    0.03375981f, 0.08900283f, 0.06406928f, -0.05319500f, -0.07968517f, 0.07402191f, 0.21115392f, 0.39064881f, 
    0.04285183f, -0.07626158f, -0.04454195f, -0.03075837f, 0.11853748f, -0.01570548f, 0.09742100f, 0.16552889f, 
    0.05857289f, -0.09254239f, -0.01017453f, -0.34639657f, -0.05213797f, -0.01115505f, -0.12399521f, 0.16515705f, 
    0.05255426f, -0.02105975f, -0.00852611f, -0.00801389f, 0.31399095f, -0.58944952f, 0.18969594f, -0.05947622f, 
    -0.02873252f, -0.09699892f, -0.08084387f, -0.00458132f, -0.14164519f, 0.04810220f, -0.17147341f, -0.14044802f, 
    -0.06325810f, 0.02029136f, -0.05946146f, -0.00903738f, 0.04460998f, 0.11303420f, 0.09279189f, 0.00215511f, 
    0.12558748f, -0.05377474f, 0.05582049f, 0.36091590f, 0.05904654f, -0.00598188f, 0.06965274f, -0.50451601f, 
    0.10973375f, -0.01167515f, 0.06897139f, 0.13525188f, 0.04664162f, 0.06775360f, 0.03335359f, -0.08421797f, 
    0.20859575f, 0.46851036f, 0.32156885f, 0.04975213f, 0.07063068f, 0.16335042f, -0.07872871f, 0.09709711f, 
    -0.07011639f, 0.14144680f, 0.19157001f, -0.00965129f, 0.12185290f, -0.14988032f, 0.02117786f, 0.14907877f, 
    0.08404737f, -0.01415809f, -0.06682221f, -0.02110039f, 0.10762568f, -0.11398178f, -0.11916170f, 0.03544356f, 
    -0.13070373f, 0.42649290f, 0.33730319f, -0.03880170f, -0.17702550f, -0.02492288f, 0.12233188f, 0.02854764f, 
    0.00878419f, 0.02492079f, -0.29162383f, -0.07091488f, 0.09263532f, -0.01608256f, 0.02844911f, -0.03494905f, 
    -0.22515668f, -0.03151612f, 0.08220322f, -0.08694249f, -0.20052612f, -0.03172382f, -0.08766774f, -0.08564424f, 
    -0.14536341f, 0.10261726f, 0.20967513f, 0.38266650f, 0.06902903f, 0.02381677f, 0.08999800f, 0.05149402f, 
    -0.23581098f, -0.09740943f, -0.02950031f, -0.21744996f, -0.09016564f, -0.16443104f, 0.17542878f, -0.14845572f, 
    -0.10565482f, 0.04418223f, -0.08330711f, -0.06733692f, -0.12968941f, -0.00627560f, 0.01069412f, -0.28762886f, 
    0.04654760f, -0.04249590f, -0.16073228f, 0.46678513f, 0.01213710f, -0.04174479f, 0.01524846f, 0.03174049f, 
    -0.21810856f, -0.02707292f, -0.18679303f, -0.25108922f, 0.01112592f, -0.09704649f, 0.23650014f, 0.14097071f, 
    0.01080965f, -0.26849607f, 0.24768844f, -0.03888179f, 0.12988171f, 0.15909699f, -0.12223081f, -0.09008821f, 
    0.16328581f, 0.06659196f, -0.07502598f, -0.25481117f, 0.07865325f, -0.03867437f, -0.00659503f, 0.12352672f, 
    -0.03437009f, 0.08621313f, -0.16117808f, -0.06411222f, 0.20485920f, -0.01357334f, -0.02883224f, -0.22844408f, 
    -0.04000504f, 0.08352942f, 0.09281767f, 0.06280158f, 0.01321573f, -0.13089831f, -0.01957457f, -0.12251303f, 
    -0.17348832f, 0.07181112f, -0.09878848f, 0.12235655f, -0.06725778f, 0.09071466f, 0.08242703f, -0.07895277f, 
    0.03451660f, -0.06355901f, -0.03473317f, 0.07815392f, -0.10909083f, -0.12617573f, -0.14632772f, 0.24774353f, 
    -0.13297862f, -0.13255273f, -0.17067629f, 0.09369777f, 0.14786471f, 0.05122399f, -0.03212582f, 0.04196209f, 
    0.03205838f, 0.08242035f, 0.09173035f, -0.08655451f, -0.07032889f, -0.10354073f, 0.11341614f, -0.00155214f, 
    -0.10555638f, -0.08233489f, 0.02432108f, 0.04742572f, -0.27026284f, 0.19311877f, 0.16259520f, 0.06478347f, 
    0.17564991f, -0.04878661f, 0.02192389f, -0.04672282f, -0.16260785f, 0.14449562f, 0.10441819f, 0.02068870f, 
    -0.17049499f, 0.15349670f, 0.02905349f, -0.18853346f, 0.05031847f, -0.04968598f, -0.20061579f, 0.06797870f, 
    0.03423976f, 0.06210107f, -0.14693731f, -0.31945336f, -0.19813931f, 0.00507761f, -0.07015516f, 0.10446998f, 
    -0.14981915f, 0.15075026f, -0.10675862f, -0.12219724f, -0.05074260f, -0.01219899f, -0.03366004f, -0.11836587f, 
    -0.12580538f, 0.00492908f, 0.03682488f, -0.01857303f, 0.00008640f, 0.07553642f, 0.01048601f, 0.11252849f, 
    -0.00398741f, 0.10588202f, -0.00386743f, 0.03906325f, -0.05256227f, 0.10921010f, 0.11287278f, -0.05697055f, 
    -0.06088067f, -0.12717471f, -0.04658469f, -0.06035634f, 0.07906072f, 0.10713633f, -0.08092881f, -0.05409875f, 
    -0.06316301f, -0.24206892f, -0.03217057f, -0.00452245f, -0.14196827f, -0.16148785f, 0.06831990f, -0.04739902f, 
    -0.10524578f, -0.07125814f, 0.00628855f, -0.06782337f, -0.13664311f, 0.16952808f, -0.19302100f, 0.11307105f, 
    -0.04376022f, -0.11307365f, 0.08900106f, 0.00193212f, -0.04371985f, 0.07324772f, -0.06461922f, 0.14122906f, 
    -0.30388668f, 0.39601013f, 0.07370189f, -0.08812820f, 0.08141187f, -0.06805620f, -0.10138422f, 0.08959218f, 
    -0.17477421f, -0.31301969f, -0.38319597f, -0.36827901f, -0.11958017f, -0.06233416f, -0.06067863f, 0.12540406f, 
    0.10405664f, 0.16464467f, -0.06036510f, -0.06759980f, 0.12068214f, 0.08765274f, -0.03329281f, -0.05861424f, 
    -0.15057252f, 0.13570100f, -0.13053615f, -0.06484111f, 0.01334354f, 0.03025105f, -0.03175380f, -0.04379078f, 
    -0.19687630f, -0.03877274f, -0.36756513f, -0.15114719f, -0.15784483f, 0.00928618f, -0.11474900f, -0.13515700f, 
    -0.12847659f, -0.14989465f, -0.00976894f, 0.05102224f, -0.05689339f, 0.04350469f, -0.07015517f, -0.20427415f, 
    0.21030922f, -0.14396726f, 0.29577076f, 0.01124305f, -0.09933817f, -0.05294441f, -0.02861177f, -0.10271043f, 
    -0.01815157f, -0.06336960f, 0.00761390f, 0.04438872f, -0.31431958f, 0.05827783f, -0.17484492f, 0.00935533f, 
    0.11061292f, -0.06781735f, 0.04222310f, 0.23106354f, -0.12060393f, -0.21154219f, -0.12039363f, -0.25772485f, 
    -0.23532978f, 0.30421409f, -0.09856726f, 0.13946313f, -0.02650313f, 0.02691371f, -0.22374320f, 0.17400475f, 
    0.07679369f, 0.11023054f, 0.11219806f, 0.17015845f, -0.41350418f, -0.29633090f, -0.14648676f, -0.01305695f, 
    0.03475415f, -0.05894652f, 0.08175457f, 0.14759102f, -0.01147573f, 0.13556333f, 0.01343733f, 0.04881890f, 
    0.10798655f, -0.30476612f, 0.14767277f, 0.02397687f, -0.03340220f, -0.12192372f, 0.13861521f, -0.05446538f, 
    -0.12426049f, -0.13033786f, -0.07652558f, 0.03126432f, -0.04725717f, -0.26086307f, -0.04988455f, -0.04814664f, 
    -0.16527398f, 0.01185200f, 0.03569158f, -0.11175912f, -0.09015481f, 0.02804563f, -0.01894850f, -0.07864166f, 
    0.12105821f, -0.07082486f, 0.19596130f, 0.18001337f, 0.02298522f, 0.00866699f, 0.25199464f, 0.14233458f, 
    0.02030049f, -0.00561022f, 0.11186044f, 0.19115616f, -0.23571710f, -0.06443435f, 0.23537156f, -0.09170325f, 
    -0.09650339f, -0.14779575f, 0.08022840f, 0.12263403f, -0.16007398f, -0.00180401f, 0.01580001f, 0.01293806f, 
    -0.21897972f, 0.08634286f, 0.07555107f, 0.05329344f, -0.04464918f, -0.13669381f, 0.06979285f, -0.13015193f, 
    -0.08746409f, 0.13572395f, 0.19024068f, 0.02470762f, -0.28460968f, -0.24797657f, 0.24733521f, 0.01198647f, 
    -0.00490080f, 0.11400760f, -0.00395091f, -0.04274812f, 0.04783360f, -0.02799124f, -0.00638244f, -0.07092810f, 
    0.04903988f, -0.04945112f, 0.12542038f, -0.09283100f, -0.02673098f, -0.04050514f, 0.15912189f, 0.10405396f, 
    -0.03754712f, 0.05223427f, 0.04988594f, 0.17205673f, -0.08314562f, -0.14313671f, -0.18537217f, -0.04643461f, 
    0.08551265f, -0.14841455f, -0.03737957f, 0.09346030f, -0.11238573f, 0.05258920f, -0.05806429f, -0.28329033f, 
    -0.06763473f, -0.48787913f, -0.32013601f, -0.17818408f, 0.09097252f, -0.07654724f, -0.12755631f, -0.07804542f, 
    0.02245017f, 0.06266846f, -0.02477710f, 0.03531295f, -0.03164405f, 0.07016097f, 0.09214233f, 0.13369998f, 
    -0.08771928f, -0.01752337f, 0.04434288f, 0.04380310f, 0.05104933f, 0.07062818f, 0.21275872f, 0.12208135f, 
    -0.25117287f, -0.29776064f, -0.27009720f, -0.08820111f, -0.15375827f, -0.10179143f, -0.03533619f, -0.20920485f, 
    -0.08371723f, -0.14069362f, -0.03975756f, 0.07412676f, -0.12590124f, -0.20088917f, -0.14096236f, -0.17510772f, 
    -0.19358060f, -0.09467655f, 0.04694752f, -0.15592659f, -0.03379069f, -0.00006202f, -0.07996741f, -0.05759703f, 
    -0.16254698f, 0.19754162f, -0.22991879f, 0.10063282f, -0.08208422f, 0.25910005f, 0.25708416f, 0.01535816f, 
    -0.23622370f, 0.01308516f, 0.17038043f, 0.04996399f, -0.22928502f, 0.27237463f, -0.38312545f, 0.06137409f, 
    -0.08845077f, 0.15922803f, 0.11056111f, -0.03755394f, 0.03823068f, 0.00839818f, -0.02811465f, 0.04602214f, 
    0.10832357f, -0.29153025f, 0.22428797f, 0.28895241f, -0.19822344f, -0.04134203f, 0.00917298f, 0.09745967f, 
    -0.00890206f, -0.05157503f, 0.02529539f, 0.19281746f, 0.20670167f, 0.04782458f, 0.21254137f, -0.09562338f, 
    0.06096413f, -0.04098095f, 0.01066552f, 0.10734364f, -0.22774491f, 0.00376784f, -0.06403948f, -0.09605322f, 
    -0.09982904f, 0.06754123f, 0.06381498f, -0.01936336f, 0.00994379f, -0.20917740f, -0.07377479f, 0.10644218f, 
    -0.09789218f, 0.05027454f, -0.02523156f, -0.16638686f, -0.18625139f, -0.20035402f, 0.03889069f, 0.07753672f, 
    -0.00403813f, -0.01801099f, 0.10633314f, -0.03718732f, 0.00029516f, 0.06468111f, 0.07651723f, 0.10500001f, 
    0.67774773f, -0.22609340f, 0.23492619f, -0.09238593f, 0.01122432f, 0.03352714f, 0.10590425f, 0.05669331f, 
    -0.18082216f, 0.08835429f, 0.02844021f, -0.14909722f, -0.10852981f, 0.22904670f, -0.02035655f, -0.14170712f, 
    -0.14938764f, -0.01232333f, -0.15351088f, 0.05755972f, -0.00419027f, -0.04528117f, 0.01287161f, -0.01779281f, 
    0.05495958f, 0.32073599f, 0.06982479f, 0.18054119f, 0.02873708f, -0.01518679f, 0.12232582f, -0.02489714f, 
    0.13082691f, 0.07687245f, 0.07688401f, 0.12269397f, -0.20122519f, -0.28466874f, 0.05794209f, -0.09416750f, 
    -0.16328402f, -0.03513687f, 0.20740487f, -0.05181833f, -0.09444053f, 0.18373670f, 0.09864847f, -0.03781423f, 
    -0.33545411f, 0.20502089f, 0.07417021f, 0.09767468f, 0.05024990f, -0.16459189f, 0.15837014f, 0.09077986f, 
    -0.06520001f, 0.05727967f, 0.04410289f, 0.08186251f, -0.13313231f, 0.07617670f, 0.08876607f, 0.09681426f, 
    0.02157024f, -0.03278624f, -0.09492357f, 0.05845676f, -0.10944302f, -0.17872399f, 0.00810703f, -0.04258149f, 
    0.15839854f, 0.11253049f, 0.08560842f, -0.28044808f, -0.17815295f, -0.03009205f, -0.01175861f, 0.00218431f, 
    0.14735624f, 0.08841589f, 0.05326806f, -0.11856009f, -0.16538899f, 0.11000863f, -0.03785468f, 0.11381150f, 
    -0.10585716f, -0.13434783f, 0.00741261f, 0.01553088f, -0.03396670f, -0.03083461f, 0.03321636f, 0.06358682f, 
    -0.19043602f, -0.12135483f, -0.14939348f, 0.11845525f, -0.05880495f, -0.00199287f, 0.07465860f, 0.05116863f, 
    0.10073409f, -0.00446426f, -0.00456466f, -0.01303377f, -0.15229836f, -0.03815777f, 0.21085200f, -0.14263046f, 
    -0.15094541f, 0.09208007f, 0.10174578f, -0.15664624f, 0.11147684f, 0.00023798f, -0.20535430f, -0.09060868f, 
    0.08705005f, 0.17191705f, -0.25715441f, 0.25330299f, 0.04455187f, 0.07350246f, 0.00772236f, 0.01929041f, 
    -0.01090794f, 0.00682248f, -0.04439536f, 0.14916909f, 0.23723572f, -0.24650043f, 0.04032187f, -0.07132280f, 
    -0.12536906f, 0.06329747f, 0.08086732f, -0.09854735f, -0.11060360f, 0.05916674f, -0.15139298f, 0.13599278f, 
    -0.19524252f, -0.03554080f, -0.00986535f, 0.11413973f, -0.08354817f, 0.09217155f, -0.31701982f, 0.09850398f, 
    -0.00076583f, 0.13552026f, 0.10617117f, -0.04676357f, -0.15202892f, 0.22638510f, -0.04335155f, -0.05507391f, 
    -0.03479761f, 0.00874204f, -0.01165686f, 0.09729780f, -0.05750123f, -0.07611714f, -0.18358283f, -0.34600645f, 
    -0.08723872f, -0.25220209f, 0.17927718f, 0.09936772f, 0.05068979f, -0.01907982f, 0.03445165f, -0.03798783f, 
    -0.03503378f, -0.01049881f, -0.28861070f, -0.12784447f, -0.18621360f, 0.26337311f, -0.47745183f, 0.38259670f, 
    0.08319590f, 0.12561260f, 0.06148129f, 0.02657592f, 0.06066385f, 0.01588934f, 0.02843355f, 0.14035125f, 
    0.06484228f, -0.04851249f, 0.06832901f, -0.25096649f, -0.23537132f, -0.06617779f, -0.02747468f, -0.13448492f, 
    -0.00005310f, -0.22024715f, -0.25911093f, -0.30104172f, 0.18351249f, -0.16668478f, 0.22863223f, 0.08873749f, 
    -0.09750398f, -0.01496705f, -0.21945611f, 0.11875666f, 0.10685293f, -0.13049056f, 0.13592538f, 0.02801703f, 
    0.07382789f, -0.19880322f, 0.18609945f, -0.07865308f, 0.13666217f, -0.09683477f, 0.07976036f, 0.10057089f, 
    0.04724582f, 0.05974683f, 0.08691347f, 0.08125740f, -0.55485964f, 0.19132584f, -0.16408072f, 0.00507480f, 
    0.05057961f, 0.11503422f, 0.09106273f, -0.12973580f, 0.01815553f, 0.16720128f, 0.06742732f, -0.01060011f, 
    0.04947001f, -0.12829611f, 0.15472190f, -0.15617400f, 0.02085201f, 0.11231320f, 0.07114008f, 0.05031327f, 
    0.13638988f, 0.02816579f, 0.03497662f, 0.08974125f, 0.07886565f, 0.07150453f, 0.15673716f, -0.21298324f, 
    0.03049540f, -0.04484151f, 0.11889957f, 0.13302451f, 0.05016311f, 0.10103167f, 0.10338291f, 0.03897703f, 
    -0.40831348f, 0.41780064f, -0.05462917f, 0.08849201f, -0.19647734f, -0.23053013f, 0.26471189f, -0.12326828f, 
    -0.00561008f, 0.08564815f, 0.03208796f, 0.09366710f, 0.30689722f, 0.18800952f, 0.15805347f, 0.14008680f, 
    -0.12493644f, -0.07466881f, -0.01252983f, -0.00045541f, 0.02904855f, -0.08888457f, -0.01499621f, 0.15639944f, 
    -0.28968516f, -0.07401015f, 0.28814486f, 0.21919820f, -0.00332342f, -0.11457783f, 0.06366313f, 0.00131580f, 
    -0.09308168f, 0.00382044f, 0.05361350f, 0.15153815f, -0.14667773f, -0.20018978f, 0.14664514f, -0.25905123f, 
    0.04394183f, 0.16273797f, -0.02689026f, 0.09475575f, -0.10009090f, 0.13535650f, 0.00369653f, -0.13300866f, 
    -0.38184890f, -0.10134973f, -0.07485618f, -0.36460450f, -0.10100021f, -0.16171956f, 0.05364674f, -0.08167875f, 
    -0.08401314f, -0.07029014f, -0.07090803f, -0.02142649f, -0.37841830f, -0.29637688f, 0.24201663f, -0.13905674f, 
    0.09374584f, 0.08975951f, 0.08664630f, -0.01244873f, 0.03097242f, 0.11603685f, 0.20409413f, 0.03745465f, 
    -0.65791112f, 0.21248522f, -0.32486013f, 0.14060511f, 0.09698351f, 0.03203874f, 0.11130697f, -0.22248861f, 
    -0.01003843f, -0.04886916f, 0.16024056f, 0.11120279f, 0.09075965f, 0.23267747f, 0.12653761f, -0.07312177f, 
    -0.04139724f, 0.00388441f, 0.04300550f, -0.04744347f, -0.06791393f, 0.05953997f, -0.01732303f, -0.02442405f, 
    0.01409205f, -0.09033557f, 0.06932823f, -0.02933678f, -0.00054585f, 0.15565047f, 0.14643009f, -0.04754822f, 
    -0.19093771f, -0.04492543f, 0.03129778f, -0.25314263f, -0.53799558f, 0.22235571f, -0.49597663f, 0.22373900f, 
    0.12168758f, -0.01778326f, 0.09587348f, -0.04983280f, -0.03296268f, -0.09877362f, 0.12544598f, 0.02387909f, 
    0.02316986f, -0.05124883f, -0.21278431f, -0.27549148f, 0.00529485f, -0.02779725f, 0.04268179f, 0.01022591f, 
    0.02445781f, 0.12956451f, 0.05164471f, -0.00508579f, 0.19936343f, 0.15028340f, 0.19136959f, -0.10605458f, 
    0.03875381f, -0.08028904f, -0.09054714f, -0.01412043f, -0.12651592f, 0.06680472f, -0.01803025f, -0.01768720f, 
    0.09711590f, -0.49180093f, 0.29280987f, -0.09719002f, 0.14041664f, -0.16836728f, -0.20183459f, -0.07272717f, 
    -0.00303515f, 0.05689159f, 0.03996961f, -0.19474520f, -0.09372523f, 0.21426401f, -0.07835674f, 0.07165801f, 
    0.04496070f, -0.02070126f, 0.13316481f, -0.06425852f, 0.08406533f, -0.06439479f, 0.06795739f, -0.03524163f, 
    0.15870476f, 0.08911899f, 0.21343026f, -0.05421215f, -0.01825791f, -0.06516492f, -0.09488816f, -0.11235040f, 
    -0.14937913f, 0.03886151f, -0.00610732f, 0.00262354f, 0.11843297f, 0.00840998f, 0.13307646f, 0.19268481f, 
    -0.00860708f, -0.01583426f, 0.04927351f, -0.09260303f, 0.01765390f, -0.13476494f, 0.10135826f, -0.06214252f, 
    -0.28586957f, 0.18020116f, -0.16013218f, 0.16870117f, -0.04231050f, 0.00590280f, 0.09598066f, 0.23375368f, 
    -0.02805143f, 0.08788652f, 0.03991758f, 0.04350479f, -0.57371020f, -0.30105957f, 0.31802499f, -0.16669042f, 
    -0.22980501f, -0.13208240f, -0.17173877f, -0.16382779f, 0.02427219f, -0.08900701f, -0.01500018f, 0.09559906f, 
    0.13682611f, -0.15799181f, 0.06857348f, 0.00130766f, 0.07655693f, -0.00968177f, 0.14343320f, 0.21410096f, 
    -0.01428056f, 0.24210314f, 0.12064725f, -0.03467519f, -0.03568840f, 0.00354874f, -0.10894687f, 0.01129466f, 
    0.10165216f, 0.10124200f, 0.16501759f, -0.04163869f, 0.02135481f, -0.04875238f, 0.02102260f, 0.01131576f, 
    0.00613730f, 0.13138619f, 0.00897471f, -0.02118188f, 0.00682255f, 0.05326879f, 0.03995235f, -0.23134896f, 
    -0.22745982f, 0.13281769f, 0.00690783f, -0.09151162f, -0.09062910f, -0.34493539f, -0.11166009f, 0.09697624f, 
    0.09290191f, -0.00305323f, 0.05708296f, 0.14532100f, -0.06476492f, -0.02177936f, 0.03345459f, 0.07475722f, 
    -0.11592558f, 0.10709626f, -0.38509372f, -0.01338923f, -0.08261000f, -0.06753684f, -0.01940017f, 0.20055066f, 
    -0.06622418f, -0.15365015f, -0.12145743f, -0.11263195f, -0.02857447f, -0.71910369f, 0.08445503f, 0.06647696f, 
    0.02999287f, -0.12216935f, 0.14161962f, -0.00132658f, -0.09141244f, 0.01408580f, 0.18356989f, 0.08758546f, 
    -0.20927779f, -0.22380631f, 0.06769819f, -0.07495110f, -0.07160617f, -0.02827555f, 0.06488688f, -0.14661501f, 
    0.06111155f, -0.01870075f, -0.07002474f, -0.01602925f, 0.47229812f, 0.37232748f, 0.17664024f, -0.14399600f, 
    -0.04055846f, -0.00266145f, -0.08459120f, 0.08572559f, -0.02425879f, -0.00032017f, -0.00873901f, -0.08512966f, 
    -0.05971998f, 0.09993398f, -0.06318408f, 0.10883122f, 0.06369515f, 0.05640343f, -0.23521666f, -0.00190821f, 
    0.03676217f, 0.07034393f, -0.11799758f, -0.11808199f, -0.24588522f, 0.14736030f, -0.21720378f, -0.01462463f, 
    0.05106811f, -0.00480849f, 0.11233292f, 0.05397636f, -0.02471169f, 0.01781313f, -0.03888887f, 0.00960712f, 
    -0.08447625f, 0.00964109f, -0.04129223f, 0.11548741f, -0.05271702f, -0.15109694f, -0.14825146f, -0.25801474f, 
    -0.04921085f, 0.01156961f, -0.16160585f, -0.08060811f, 0.29248759f, -0.03749638f, -0.05152810f, -0.32906061f, 
    -0.03626068f, -0.12903494f, 0.17237565f, -0.14127395f, 0.06185406f, 0.23887587f, 0.00422940f, -0.25519925f, 
    -0.08790405f, 0.06484695f, 0.02153719f, -0.01902685f, 0.02501773f, -0.10207721f, 0.07737142f, -0.17605512f, 
    0.14400484f, 0.14051130f, 0.01705630f, -0.08698741f, -0.13060820f, 0.46610671f, -0.31033421f, -0.27416530f, 
    -0.08564902f, 0.10680638f, 0.12397359f, -0.01648670f, -0.02641724f, 0.03702564f, 0.07218640f, 0.08505198f, 
    -0.03051699f, -0.34635001f, -0.15249236f, 0.01181577f, -0.14409146f, -0.20912212f, 0.14271660f, -0.21138312f, 
    0.00084424f, 0.00463349f, -0.09354723f, -0.05813555f, -0.09332376f, 0.04089214f, -0.12180714f, -0.20315576f, 
    -0.06210782f, 0.20311511f, -0.24300587f, 0.13733307f, -0.05346812f, -0.11206546f, -0.21602273f, -0.18772776f, 
    -0.21027781f, 0.13562790f, -0.24591424f, -0.01144622f, -0.01656222f, 0.10847186f, 0.02049690f, 0.07644976f, 
    -0.06157861f, -0.10558338f, 0.15785648f, -0.08632316f, -0.07318828f, 0.03741246f, -0.13375208f, -0.04150165f, 
    -0.05137707f, -0.07795143f, 0.10232238f, 0.07992461f, 0.01063900f, -0.00375349f, 0.01429780f, 0.03683114f, 
    -0.14761953f, -0.10392141f, 0.11379375f, 0.26647225f, 0.20906106f, -0.10425973f, -0.03337805f, 0.01816433f, 
    0.03275794f, 0.02336893f, 0.13537556f, -0.05689214f, 0.08008850f, -0.25313735f, 0.05635311f, 0.30140015f, 
    0.06748955f, -0.02551098f, -0.08755349f, 0.03130600f, 0.05477050f, 0.05118410f, 0.08574413f, -0.04496118f, 
    0.09494180f, -0.43707564f, 0.60781014f, -0.27128041f, -0.04280429f, 0.02656308f, 0.09021304f, 0.20855236f, 
    -0.10813081f, -0.17974515f, -0.00967153f, -0.05153277f, -0.41785040f, 0.23448668f, -0.26457971f, 0.15210751f, 
    -0.01604124f, -0.07114781f, 0.02146045f, 0.00746999f, -0.03309087f, -0.05476017f, -0.11348080f, -0.04658419f, 
    0.24295673f, -0.02044072f, 0.30324665f, -0.00327199f, -0.08326062f, -0.03371213f, -0.15003063f, 0.10729078f, 
    -0.13204475f, 0.04066296f, 0.01325776f, -0.11209147f, 0.17311218f, -0.20560214f, 0.07954825f, -0.28363448f, 
    0.03369110f, -0.10636044f, -0.23161943f, -0.07496100f, -0.06954537f, -0.00711731f, -0.13178654f, -0.09019014f, 
    -0.04453563f, -0.20450392f, 0.37291554f, 0.01372365f, 0.09804205f, 0.15408082f, -0.09231816f, -0.02564927f, 
    0.06954244f, -0.15161522f, 0.13136570f, -0.08740506f, 0.40766019f, -0.09394722f, 0.32611042f, 0.17421995f, 
    0.05188138f, 0.08311052f, -0.20576270f, 0.19273348f, -0.24620846f, 0.01921996f, -0.00487058f, -0.03033263f, 
    -0.22944038f, -0.06466503f, 0.01163227f, 0.04017719f, 0.22803664f, 0.08193536f, 0.21645440f, -0.16213273f, 
    -0.05732602f, 0.13447896f, -0.06308470f, 0.07611237f, 0.37743279f, 0.22386438f, 0.15110196f, -0.07654239f, 
    0.01153801f, 0.12453355f, -0.15315500f, 0.03368271f, -0.11417256f, -0.03550128f, 0.00022514f, 0.01170058f, 
    -0.24636099f, -0.05467605f, 0.15911517f, -0.01394825f, -0.06665730f, -0.19420794f, 0.08030356f, -0.09926888f, 
    -0.02419140f, 0.04870145f, -0.01768048f, -0.00344856f, 0.13052115f, 0.09108427f, 0.11288230f, -0.07910741f, 
    0.09508619f, -0.02961401f, 0.10026677f, 0.08941279f, 0.04407927f, 0.05259356f, 0.08660958f, 0.11328454f, 
    -0.27196872f, -0.14386673f, -0.29203847f, -0.12260380f, 0.18302050f, -0.03544058f, -0.02123333f, 0.14109488f, 
    -0.20896204f, 0.03271572f, -0.02909117f, -0.04377403f, -0.24344981f, 0.03889332f, -0.24398685f, 0.15670820f, 
    0.00923115f, 0.06177059f, 0.01821142f, 0.08984235f, -0.12560394f, -0.08014762f, 0.09813413f, -0.01826577f, 
    -0.13324234f, -0.04008061f, 0.02949334f, 0.25631389f, 0.10898717f, -0.03818454f, 0.01560757f, -0.24194993f, 
    0.03089296f, 0.11619078f, -0.13021462f, 0.08494827f, -0.03152396f, -0.00556466f, 0.17372608f, -0.34197378f, 
    0.06092583f, 0.03481974f, 0.26644829f, -0.08714882f, 0.20235042f, 0.02266209f, 0.04552593f, 0.13164727f, 
    -0.57948369f, -0.10721656f, -0.03371677f, 0.22749469f, -0.04365645f, -0.05742768f, -0.03567951f, 0.16876705f, 
    -0.29994524f, -0.11572578f, -0.04166511f, -0.03053058f, 0.33588332f, -0.06310787f, 0.22282493f, -0.22480074f, 
    -0.05008266f, -0.10179461f, -0.14472523f, 0.01085804f, -0.00470954f, -0.03205047f, -0.06025322f, -0.09840603f, 
    0.02452654f, -0.21326318f, 0.10706141f, -0.03989566f, -0.05895410f, -0.06103928f, -0.28694960f, -0.06671552f, 
    0.02194957f, -0.02738526f, -0.05661429f, -0.10824019f, 0.01304673f, -0.22492477f, -0.08116844f, 0.07283133f, 
    0.10928593f, 0.01054713f, -0.09664458f, 0.00603097f, 0.07851202f, 0.12535858f, 0.15361272f, 0.10072137f, 
    -0.15012498f, 0.21968189f, -0.13198383f, 0.00730201f, 0.01358270f, 0.16316186f, -0.01809447f, -0.03661320f, 
    -0.01257357f, 0.06273771f, 0.10703541f, 0.10597291f, -0.52665186f, 0.39974585f, -0.35995972f, 0.36345232f, 
    0.03523768f, -0.13702424f, -0.01239158f, 0.06649659f, -0.04865331f, 0.12190058f, 0.17428070f, -0.01486911f, 
    0.12329473f, -0.03208651f, 0.02284949f, -0.15753457f, -0.00157413f, 0.02597587f, -0.02365767f, -0.05647196f, 
    0.06608403f, 0.12381528f, 0.06380256f, 0.09878989f, -0.08343327f, 0.02174982f, -0.11828793f, -0.01249593f, 
    -0.03113539f, 0.05571239f, -0.01843376f, 0.10511535f, -0.19578943f, 0.11062037f, -0.14345993f, 0.00030644f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11650275f, 0.11470829f, 0.08270183f, -0.07601942f, -0.11382563f, 0.05366247f, 0.01125435f, -0.14078330f, 
    0.06884507f, 0.00831017f, 0.03431246f, -0.03470334f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
