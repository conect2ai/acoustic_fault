#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.12097465f, -0.20018983f, -1.01671624f, -0.79877144f, -0.82289898f, -0.94844228f, -0.73344648f, -0.53032541f, 
    -0.85199016f, -0.81498379f, 0.42589718f, 0.37478310f, 0.47408435f, -0.17852606f, -0.00497818f, 0.29540461f, 
    0.18273343f, 0.01741281f, 0.18759611f, -0.05959590f, 0.00851045f, -0.15878440f, -0.16576321f, -0.17979661f, 
    -0.05244816f, -1.77183461f, -0.72436804f, -0.97353113f, -1.51141942f, -1.12201691f, 0.58686197f, 0.94277799f, 
    -0.80563051f, -0.72780448f, 0.67354387f, -0.27141318f, -0.40919852f, -0.55979323f, -0.97074115f, -0.38120136f, 
    -0.37452644f, 0.20047638f, -0.08386904f, -0.02509453f, -0.03165950f, -0.13104230f, -0.16662873f, -0.34075180f, 
    -0.05482132f, -0.06849568f, -0.29392344f, -0.43410951f, 1.10692012f, -0.03103587f, -0.40204692f, -0.83532923f, 
    -0.36801845f, -0.05744049f, 0.07356024f, 0.09467535f, 0.09752200f, -0.11617407f, -0.31987965f, -0.09017383f, 
    0.58902591f, -0.54592651f, -0.10821240f, 0.13090886f, -0.39413750f, -0.72244209f, -0.12434971f, -0.37169075f, 
    -0.43345419f, -0.92214310f, -0.86487997f, -0.62062728f, 0.81830573f, 0.75743437f, 0.28580514f, -0.81392747f, 
    -0.32402170f, -0.06615647f, 0.25308359f, 0.29179528f, -0.48366770f, -0.52985740f, -0.20782341f, -0.07874800f, 
    0.05983862f, 0.19612464f, 0.26135546f, 0.34184048f, -0.27646372f, -0.04980219f, 0.10056575f, -0.54633886f, 
    -0.26099077f, 0.20568956f, 0.40978187f, -0.06406815f, 0.33607769f, 0.50667441f, 0.43576989f, 0.07888094f, 
    0.04795603f, -0.79074121f, -0.55480468f, 0.07644042f, 0.25580826f, -0.13026179f, -0.53072864f, -0.73785633f, 
    1.21312380f, -0.63220942f, 0.10925455f, 0.24242115f, -0.13096640f, -0.01925679f, -0.02336502f, 0.18039967f, 
    -0.04316226f, 0.41953620f, -0.41972792f, -0.16486362f, -0.19200356f, -0.20349444f, -0.81328243f, -1.09589374f, 
    -0.44677624f, 0.28780624f, -0.09757756f, -0.51593560f, -0.68786925f, -0.62559390f, -0.62311107f, 0.27714089f, 
    -0.58529562f, -0.15154758f, 0.33915663f, 0.42827675f, -0.10969587f, -0.25741121f, 0.12562215f, -0.28946012f, 
    -0.59380448f, -0.28303877f, 0.68183547f, 0.66191971f, 0.55279791f, 0.43632835f, -1.76331854f, -0.74558097f, 
    -0.08933339f, -0.24724796f, -0.48107934f, 0.68190128f, 0.75402445f, 0.52423501f, 0.71209592f, 0.59437841f, 
    -0.02696621f, 0.03982605f, 0.40348643f, -0.08614933f, -0.10002467f, -0.04212772f, -0.09095049f, -0.05842941f, 
    -0.41981816f, -0.04249523f, 0.03928829f, 0.25582859f, 0.37453023f, -0.15813412f, -0.01161547f, -0.05266478f, 
    0.25432241f, 0.31259227f, 0.47712424f, 0.36600697f, 0.40065876f, 0.33347800f, 0.15624753f, 0.61764127f, 
    0.42702740f, 0.43788046f, 0.08146444f, 0.27473992f, 0.13669243f, -0.46448129f, 0.06266450f, -0.05473117f, 
    0.13977315f, -0.00810341f, -0.42407161f, -0.24371268f, 0.35482636f, 0.04702095f, 0.22410320f, -0.15823446f, 
    -1.59795475f, -0.38797870f, 0.50296324f, 0.38068756f, 0.03406301f, 0.44821823f, 0.64985758f, -0.30707338f, 
    0.27115548f, -0.28955299f, 0.12694685f, -0.05197740f, -0.39897305f, 0.38656446f, -0.52797830f, -0.00150816f, 
    -0.10600810f, -0.10636243f, -0.07763329f, -0.17213251f, -0.44304219f, -0.37533155f, -0.33226478f, -0.25486162f, 
    -0.52517647f, -0.53738230f, -0.48653817f, 0.66800028f, -0.08543483f, -0.11105524f, -1.39988577f, -1.31007934f, 
    0.02130218f, 0.13184850f, -0.28600198f, 0.18756489f, -0.32873231f, -0.20390208f, 0.38731658f, -0.14949787f, 
    -0.31496686f, -0.01667240f, -0.24620272f, -0.36632785f, -0.83113551f, -0.12191953f, -0.01035004f, 0.18475915f, 
    -0.16159862f, 0.33555415f, 0.54983389f, 0.40083987f, -1.17947590f, -0.90785068f, -0.65247762f, -1.00138676f, 
    -0.53845686f, 0.36492735f, 1.25935721f, -0.50783163f, -0.19818786f, 0.19784421f, 0.19237787f, 0.52865684f, 
    0.02260849f, -0.38006976f, -0.37739933f, -0.42041305f, -0.28732458f, -0.14026688f, -0.16611147f, 0.04768665f, 
    0.35180923f, -0.44773716f, 0.01296559f, 1.47740352f, -0.00627278f, -0.10524219f, -0.03449932f, -0.19487497f, 
    0.45593029f, 0.10321863f, 0.41987026f, -0.03346045f, -0.39129838f, -0.33627269f, 0.58692777f, -0.52625704f, 
    -0.87008554f, 0.11053585f, -0.49175301f, -0.02096110f, 0.05490610f, -0.68998903f, -0.02577135f, 0.05829212f, 
    0.03755404f, -0.04926804f, 0.23547764f, 0.16429295f, -0.83301544f, -0.41291305f, 0.75132149f, 1.52360559f, 
    0.33726618f, 0.31781515f, -0.28035122f, -0.72682148f, -0.40433902f, -0.09889147f, -0.43638790f, 0.12242079f, 
    -0.32170761f, 0.66838425f, -0.22425209f, -0.20806190f, -0.24504428f, -0.12105405f, 0.18672064f, 0.38970101f, 
    -0.06203450f, -0.12524015f, -0.19206889f, 0.26619738f, -0.26167336f, -1.42024636f, -0.78228742f, 0.33999479f, 
    0.28565121f, 0.79674751f, 0.15394711f, -0.60026628f, -0.67851114f, 0.14991398f, 0.94136590f, -0.08550759f, 
    0.22799428f, 0.51509321f, -0.06508151f, 0.02603228f, -0.33922398f, -0.31976172f, 0.40140468f, -0.33028921f, 
    0.45834330f, 0.28758746f, -0.15479441f, -0.03110344f, 0.05208384f, -0.33089879f, 1.52399230f, 0.72163248f, 
    -0.69616348f, -0.54578263f, -0.55162120f, -0.08897508f, 0.60314327f, 0.14178610f, 0.02071072f, 0.42181814f, 
    -0.22312516f, 0.38420245f, -0.17024140f, -0.53984940f, 0.04115718f, 0.05602277f, -0.12868965f, -0.16023895f, 
    0.11572620f, -0.02170556f, -0.35969976f, -0.34511265f, -0.28452206f, -0.52448547f, -0.54723364f, 1.48478878f, 
    -0.33629012f, -0.46658012f, 0.03559341f, -1.08359396f, 0.92524976f, -0.84409779f, -0.43510094f, 0.41123185f, 
    0.05617162f, 0.54609025f, 0.05867210f, 0.04183821f, 0.31930384f, -0.30014333f, -0.14653030f, 0.26068321f, 
    0.24305956f, -0.25036481f, -0.35830456f, 0.00048638f, 0.05335643f, -0.09245863f, 0.23875259f, -0.36313450f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17046148f, 0.01689289f, -0.02818564f, 0.47092140f, 0.29735065f, 0.10119195f, 0.36030039f, -0.12293878f, 
    0.04039799f, 0.72812295f, 0.50701988f, 0.57067072f, 0.59976077f, 0.40159294f, 0.32081777f, 0.53824288f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.67481828f, 0.39731932f, -0.27836978f, -0.26648736f, 0.22397956f, 0.07564810f, 0.09317878f, 0.07877024f, 
    0.07876810f, 0.05113808f, 0.10971317f, 0.06400261f, 0.51485240f, 0.40565807f, -0.06565462f, -0.28692403f, 
    0.20635496f, 0.45629352f, 0.15956160f, 0.25139368f, 0.07735456f, -0.00307496f, 0.01018872f, -0.09196174f, 
    -0.10766819f, 0.05086331f, 0.18166639f, -0.33965486f, -0.10562571f, -0.12368428f, -0.11357895f, 0.00138720f, 
    -0.11154250f, -0.00189392f, 0.17855501f, 0.30012295f, -0.50146729f, -0.55259830f, 0.16621654f, -0.15041322f, 
    -0.04262065f, -0.08659378f, -0.11314288f, 0.04083410f, -0.28275177f, -0.09556527f, -0.02399238f, -0.07778534f, 
    -0.58013177f, -0.19242832f, 0.42645845f, 0.15675347f, 0.09402322f, -0.09932937f, -0.50991410f, -0.13783765f, 
    0.03832420f, -0.01193245f, -0.07477269f, 0.07462440f, 0.29604790f, 0.31752256f, -0.16492794f, -0.46234396f, 
    0.06725997f, 0.25329769f, 0.09404596f, -0.25363752f, -0.03650755f, -0.00163766f, -0.05062862f, -0.00244273f, 
    -0.20421310f, -0.26653206f, 0.04038285f, 0.00192594f, 0.16145369f, 0.13864218f, 0.09656143f, 0.03515064f, 
    -0.21838003f, 0.04902466f, -0.24816388f, 0.00708219f, -0.09447654f, -0.14837626f, -0.07780556f, 0.04016467f, 
    0.13240318f, 0.05507391f, -0.00486202f, 0.11944542f, -0.08369663f, -0.22909902f, -0.21390314f, -0.19441225f, 
    0.24929544f, -0.14768074f, -0.19093069f, -0.05559502f, -0.07134776f, -0.06289741f, 0.08199231f, 0.08291392f, 
    0.13346583f, 0.23126225f, 0.23075616f, 0.21067891f, 0.11943306f, 0.28028199f, 0.43591565f, -0.49038279f, 
    0.04486234f, 0.12856971f, -0.15157048f, -0.10800895f, -0.05731625f, -0.10190818f, -0.07261119f, -0.41054034f, 
    0.39922100f, -0.27350312f, -0.14142853f, -0.13753106f, -0.11888373f, -0.09646787f, -0.34401810f, 0.04057299f, 
    -0.06133487f, -0.21936657f, -0.10559784f, -0.04207607f, -0.34512728f, -0.70363802f, -1.12600529f, 0.41213736f, 
    0.03547212f, 0.12315650f, -0.05004445f, 0.07884774f, -0.00793584f, -0.01537151f, 0.03491585f, -0.14779879f, 
    0.32904029f, -0.53552020f, -0.30013862f, -0.77930647f, 0.02544820f, -0.22087632f, -0.00425813f, -0.07088771f, 
    -0.07861553f, -0.02222472f, -0.11510079f, -0.05822688f, 0.58704370f, 0.41942433f, 0.26637873f, -0.49194959f, 
    -0.13866328f, 0.06089055f, -0.04120838f, 0.13061339f, -0.15551589f, -0.17798674f, -0.12915361f, -0.15757714f, 
    -0.79950726f, -0.51452518f, -0.08707377f, 0.21326026f, 0.02169028f, 0.05066327f, -0.03893908f, -0.00685076f, 
    -0.17191024f, -0.14050250f, -0.18260299f, -0.11741877f, -0.04147321f, -0.47943735f, -0.24187654f, -0.01333824f, 
    -0.07854435f, 0.15852949f, -0.13255925f, 0.09206432f, -0.25549325f, -0.00879809f, -0.20758367f, 0.13320895f, 
    -0.11222704f, 0.11732281f, 0.00780913f, -0.05477035f, -0.34747675f, -0.07509776f, -0.16744691f, -0.04917219f, 
    -0.06544594f, -0.06558758f, -0.03900169f, 0.09285573f, 0.82767135f, 0.22278021f, 0.18184660f, -0.17044249f, 
    -0.05289504f, 0.14325567f, -0.16851671f, -0.00676266f, 0.09206910f, 0.00145928f, -0.15734801f, 0.06112666f, 
    -0.25699329f, 0.21091914f, 0.34699574f, -0.75083423f, 0.04192919f, 0.10958139f, -0.02779065f, 0.15976539f, 
    -0.17121901f, -0.21334536f, -0.18820848f, -0.56880927f, -0.02488676f, -0.04163408f, 0.28124434f, -0.40531462f, 
    0.08289305f, -0.27804813f, 0.10850186f, -0.22901823f, 0.12893033f, 0.15049084f, -0.21331455f, -0.18574657f, 
    0.14570071f, -0.01971462f, -0.25223291f, 0.00655492f, -0.10741074f, -0.03823149f, -0.21626085f, 0.04524649f, 
    -0.08219079f, 0.08795775f, -0.02454847f, -0.01064508f, -0.17570093f, 0.26022327f, 0.35859528f, 0.02819695f, 
    -0.23750731f, -0.11846098f, 0.33137131f, 0.18354680f, -0.06177050f, 0.04033397f, 0.11967797f, -0.15606573f, 
    -0.15528120f, -0.00383374f, -0.29856816f, -0.17373616f, -0.12171026f, -0.04679101f, 0.05152325f, -0.00967644f, 
    -0.12523007f, 0.07684355f, -0.18457144f, -0.07261682f, 0.14249001f, 0.11783066f, 0.26087457f, 0.25187328f, 
    -0.13430418f, -0.11028121f, 0.05263110f, -0.01149200f, -0.01608969f, 0.17750004f, 0.04180282f, 0.13160169f, 
    0.29879883f, -0.32841772f, -0.26715076f, -0.11953901f, 0.03341742f, -0.05419432f, -0.00427095f, 0.08428158f, 
    -0.07389443f, -0.32042873f, -0.33828619f, -0.51370716f, -0.36014453f, 0.02734608f, -0.29979467f, -0.33468476f, 
    0.10597271f, -0.01114441f, 0.22582230f, 0.32161269f, 0.01426318f, 0.00672667f, 0.01257830f, 0.01437233f, 
    -0.57808900f, -0.10118800f, -0.29481986f, -0.11308559f, 0.11602934f, 0.24876253f, -0.11960759f, -0.13113764f, 
    0.12721384f, 0.06568176f, 0.00408697f, 0.21794936f, 1.19303739f, 0.29493189f, 0.08418566f, 0.21888906f, 
    -0.07077794f, -0.05360795f, 0.04253718f, 0.05225835f, -0.04033066f, 0.04366749f, -0.28385526f, 0.16410026f, 
    0.21300270f, 0.04054453f, -0.20720868f, -0.18599187f, -0.18790324f, -0.16121653f, 0.05137864f, 0.02276726f, 
    0.05115939f, 0.04134280f, 0.07357669f, -0.05452581f, -0.49582526f, 0.15963855f, -0.10710590f, 0.29241258f, 
    0.04981574f, -0.05218888f, 0.08856696f, 0.10152387f, -0.01768990f, -0.12928827f, -0.04262679f, 0.06791160f, 
    0.36378688f, -0.21868460f, 0.09284638f, -0.05989915f, 0.00375426f, 0.03816624f, -0.19763422f, -0.00384499f, 
    0.17496060f, -0.03741067f, -0.16055670f, -0.21115813f, 0.28328025f, -0.16922402f, 0.03571885f, -0.28755942f, 
    0.01806752f, -0.27141541f, -0.08603541f, 0.28567508f, 0.21069406f, 0.25767094f, 0.30232376f, -0.01250799f, 
    -0.47071129f, -0.49348453f, -0.47073546f, -0.42663404f, 0.00699825f, 0.06615084f, 0.02196314f, -0.51917624f, 
    0.07639621f, -0.02807999f, 0.06596664f, 0.02757913f, -0.21147725f, 0.40164047f, 0.86038578f, 0.49235818f, 
    -0.25271904f, -0.10970113f, -0.07036646f, 0.09895392f, 0.05403439f, 0.00254390f, -0.06195324f, -0.02392323f, 
    0.02323779f, 0.00968888f, 0.14353423f, 0.05501473f, 0.03014422f, 0.01818307f, -0.11058674f, -0.13811800f, 
    -0.01178245f, 0.20999631f, -0.11488983f, -0.04205189f, 0.00618261f, -0.04067457f, -0.20097952f, 0.04917014f, 
    0.09886684f, -0.05411381f, 0.09935913f, -0.09416168f, -0.10893271f, 0.07750610f, 0.07691047f, 0.02397353f, 
    -0.48486990f, 0.00102622f, -0.16017297f, -0.13095103f, 0.04169654f, 0.11946598f, 0.14170001f, 0.18041375f, 
    -0.06909657f, 0.03667309f, 0.09222219f, -0.02637559f, -0.77422827f, -0.55021197f, 0.06125015f, -0.21840253f, 
    -0.12273050f, -0.06518392f, -0.05550647f, -0.11368098f, -0.01112354f, -0.05248325f, 0.05456734f, -0.07596278f, 
    0.07247385f, 0.18789288f, 0.49462432f, 0.39519995f, -0.03991745f, 0.02270135f, 0.19010529f, -0.02404598f, 
    -0.04500430f, -0.19680245f, 0.08920145f, -0.07814342f, -0.42385948f, -0.31813785f, -0.24857260f, -0.06467514f, 
    0.00152268f, 0.01176410f, 0.06885903f, 0.13336049f, -0.06035607f, -0.32379526f, 0.39853448f, 0.03269942f, 
    0.18558259f, -0.08155961f, 0.03664900f, 0.04528786f, -0.03126268f, -0.00387181f, 0.05174159f, 0.00283072f, 
    -0.05509538f, 0.04966256f, 0.20204717f, 0.09135914f, -0.23790938f, -0.17903425f, -0.28176472f, -0.10981722f, 
    0.16290365f, 0.25720444f, -0.04762962f, -0.19598424f, -0.03723549f, -0.06951732f, -0.04093506f, 0.02642046f, 
    -0.87972349f, 0.47136715f, -0.56720549f, 0.57850546f, -0.20038188f, 0.07425911f, 0.13864632f, -0.38644513f, 
    -0.02154438f, -0.02513701f, -0.36421022f, 0.03625212f, -0.14000325f, 0.09157420f, -0.07057793f, 0.25573212f, 
    -0.03729197f, -0.04543148f, 0.00920532f, -0.02079755f, 0.08079034f, 0.06997282f, -0.18695286f, 0.06634502f, 
    -0.51344222f, 0.89887375f, -1.04945767f, -0.12478072f, 0.08163936f, -0.12663606f, 0.06476371f, 0.13963296f, 
    -0.05251994f, 0.06624953f, 0.20786977f, -0.07394296f, 0.29821134f, -0.19220188f, -0.16051367f, 0.83107781f, 
    0.22246942f, -0.16048542f, 0.01066591f, 0.06779037f, 0.01334833f, -0.05619012f, 0.13817069f, -0.15866987f, 
    -0.06454902f, 0.17359513f, 0.12979594f, -0.09221697f, 0.02087208f, -0.00867680f, -0.12935726f, -0.23708238f, 
    0.19542101f, 0.27144712f, -0.04569190f, 0.22632466f, -0.66440487f, 0.68728882f, -0.05409904f, -0.09005348f, 
    0.03770069f, 0.02582857f, -0.14851271f, -0.42120388f, -0.03762913f, -0.07864683f, 0.09412516f, 0.27289021f, 
    -0.12466842f, -0.33914781f, -0.16189328f, 0.28945228f, 0.07709167f, 0.17377169f, 0.01196078f, 0.05383097f, 
    0.05022388f, 0.05684057f, 0.03125710f, -0.05620843f, 0.17900382f, -0.25328875f, -0.00945488f, 0.41965964f, 
    0.14336911f, -0.09914529f, 0.08901037f, -0.29752508f, 0.01289278f, 0.07749628f, 0.11499242f, 0.03397811f, 
    0.10631258f, 0.03928884f, -0.02641691f, 0.36524788f, 0.00544159f, 0.13338633f, -0.22486185f, -0.02227999f, 
    -0.10126766f, 0.03151752f, -0.13313523f, 0.04019934f, 0.71739018f, 0.51212490f, 0.47620225f, -0.14755066f, 
    -0.35399863f, -0.35852206f, -0.33814356f, 0.00579727f, -0.28703469f, -0.37337017f, 0.17810744f, -0.11308495f, 
    0.36134428f, -0.11758520f, -0.18467723f, -0.20368792f, -0.06604298f, -0.04191420f, -0.18548463f, 0.07420393f, 
    0.21483444f, 0.30488753f, 0.09221257f, -0.25126538f, -0.00414451f, -0.08443965f, -0.07790314f, 0.37204412f, 
    0.03413262f, -0.00308038f, -0.16453947f, -0.07054237f, 0.10745559f, 0.02294487f, 0.10547110f, -0.09668988f, 
    0.67465794f, -0.29121369f, 0.12716089f, -0.16242802f, 0.46569675f, 0.27696216f, 0.11180525f, 0.23429367f, 
    -0.24731243f, 0.22166896f, -0.03268698f, -0.02019869f, -0.76327837f, -0.48644018f, 0.12104752f, -0.35378104f, 
    0.17475295f, 0.27085945f, 0.04378430f, -0.14961098f, -0.13903697f, -0.08226118f, -0.15489466f, -0.55142617f, 
    -0.06974535f, 0.68777108f, -0.15077505f, -0.19533329f, 0.06231287f, 0.15695009f, -0.02654063f, -0.05729054f, 
    -0.38748085f, -0.26783898f, 0.06700402f, -0.18239927f, 0.22800988f, 0.00355585f, 0.13950704f, -0.02578139f, 
    -0.20547523f, -0.00404626f, -0.12985197f, -0.01750256f, -0.01803156f, -0.00458479f, 0.05157640f, -0.23829226f, 
    0.19565123f, -0.06660363f, 0.07059667f, 0.43059790f, -0.08507063f, -0.00935238f, -0.12308569f, 0.24874170f, 
    0.02784123f, -0.02375142f, 0.00195342f, -0.08281275f, -0.84887266f, 0.36246753f, 0.43990439f, 0.06082992f, 
    0.06125185f, -0.10427014f, -0.04001122f, -0.08740016f, -0.11645267f, 0.25184172f, -0.21911959f, -0.06737894f, 
    -0.50329733f, 1.19362020f, -0.21430090f, 0.31652093f, -0.16997612f, -0.31556141f, -0.09457809f, 0.00654799f, 
    -0.35842159f, -0.04897050f, -0.01680204f, 0.24885368f, -0.88462001f, 0.13789405f, -0.68826246f, -1.32433641f, 
    0.21462117f, 0.17325141f, -0.16461821f, -0.33880511f, -0.07438559f, 0.24433681f, -0.33790901f, -0.05136756f, 
    -0.49960408f, 0.20974292f, -0.16430739f, 0.28376731f, -0.16190229f, 0.17924093f, -0.30327433f, 0.18378504f, 
    -0.01052091f, 0.28179869f, 0.09568689f, 0.06649386f, -1.11745071f, -0.37014467f, 0.29006857f, 0.08031239f, 
    -0.08687223f, 0.33555630f, 0.17978616f, -0.46927515f, -0.01240269f, -0.02920381f, -0.15439583f, 0.11922488f, 
    0.19923542f, 0.23721689f, 0.39951113f, 0.43143496f, -0.13046639f, -0.14799249f, 0.01322380f, 0.20230103f, 
    0.12955107f, 0.08742406f, 0.08494674f, 0.09593575f, -0.42522579f, -0.12803410f, 0.11797886f, 0.18577309f, 
    -0.01381257f, -0.15578550f, -0.11570703f, -0.13646960f, -0.01022284f, 0.04955399f, 0.02626699f, 0.07012361f, 
    0.00227385f, 0.31269801f, -0.09691060f, 0.14698888f, 0.09059704f, -0.14134195f, 0.11126004f, -0.22698154f, 
    0.16927588f, -0.05107675f, 0.31215957f, 0.46766341f, -0.12741417f, -0.34668976f, -0.52213234f, 0.19764683f, 
    0.07108799f, 0.03245920f, -0.02922952f, -0.02039732f, -0.08571371f, -0.09732280f, 0.00870516f, -0.18188784f, 
    0.02536357f, -0.09509762f, 0.44068065f, -0.21373197f, -0.19505678f, -0.11371172f, 0.15829115f, -0.05155980f, 
    0.27569398f, -0.20673683f, -0.16562226f, -0.06485739f, 0.27076223f, 0.05985197f, 0.29327145f, 0.28076339f, 
    -0.00222801f, 0.12634903f, -0.03656396f, 0.04356350f, 0.09166346f, -0.02468373f, -0.01018653f, 0.03306028f, 
    0.37800130f, 0.00387961f, -0.16570376f, -0.22597067f, -0.08225059f, -0.13253506f, 0.10419388f, 0.00677364f, 
    0.19822557f, -0.30951804f, -0.03829552f, -0.06818034f, 0.21120001f, 0.05483122f, -0.12055774f, -0.05652312f, 
    0.09471423f, 0.03082900f, 0.06448559f, 0.13938080f, 0.07273343f, -0.15010305f, -0.22724748f, -0.09023299f, 
    -0.12942912f, -0.40593168f, 0.15603736f, 0.05273114f, -0.10352133f, -0.07628649f, 0.04187207f, -0.08095699f, 
    0.04913968f, 0.48506430f, 0.08568889f, 0.23289466f, -0.09845562f, 0.10748041f, 0.13951147f, 0.24921006f, 
    -0.11536600f, 0.09738114f, -0.09712234f, -0.23410167f, -0.12674215f, -0.24114139f, -0.15085928f, 0.00724794f, 
    -0.10056385f, 0.09862833f, 0.45234877f, 0.00172185f, -0.18758212f, -0.06865240f, -0.20367831f, -0.15119815f, 
    -0.22890991f, -0.26173851f, 0.08369765f, -0.14269605f, -0.31035805f, 0.01663991f, -0.21851632f, -0.79908419f, 
    0.16700827f, 0.13063352f, 0.03516484f, 0.04596575f, -0.04928112f, -0.06043037f, 0.04946099f, -0.25428289f, 
    -0.08137158f, -1.03773296f, 0.70512080f, 0.15685327f, -0.04157334f, 0.26487079f, -0.27624050f, -0.01181954f, 
    -0.15176541f, 0.05644890f, -0.18420511f, 0.15842523f, -0.11289884f, 0.28648025f, -0.49305651f, 0.05497822f, 
    -0.09385140f, -0.20730522f, -0.01037265f, -0.14652264f, -0.07019933f, 0.01684238f, -0.13638027f, -0.01209917f, 
    0.04187294f, 0.09051958f, -0.22954452f, -0.17120540f, 0.19209521f, -0.01319449f, 0.12091874f, -0.05400036f, 
    -0.01113454f, -0.07217021f, 0.11268079f, 0.20368324f, 0.08455348f, 0.12439413f, -0.04515251f, 0.11942256f, 
    0.20494175f, 0.03269791f, -0.27689058f, -0.16686881f, 0.05923789f, -0.40597415f, -0.57481021f, -0.12701398f, 
    0.04169754f, 0.22998580f, 0.10913730f, -0.01689373f, 0.50580519f, 0.13727602f, -0.07900430f, -0.09397902f, 
    -0.14067855f, -0.07143795f, 0.06108218f, -0.01367823f, -0.38796535f, 0.23515669f, -0.11990731f, -0.44007507f, 
    0.01113461f, -0.17630237f, 0.05182733f, 0.08401643f, -0.07147540f, -0.12505786f, 0.01376062f, -0.02526025f, 
    0.10032819f, -0.25499701f, 0.01196014f, 0.19666593f, 0.15432552f, 0.04881501f, -0.08441244f, 0.01294491f, 
    0.06613971f, -0.03309183f, -0.26864174f, -0.56025511f, -0.12733433f, -0.31756222f, -0.38004777f, 0.44128260f, 
    0.14529468f, 0.25838482f, -0.29225054f, 0.00414656f, 0.21665709f, -0.12826297f, 0.11081634f, 0.08831670f, 
    -0.02743490f, 0.08600070f, -0.05410966f, 0.41354924f, 0.12186634f, -0.04458271f, 0.12001178f, 0.07146208f, 
    -0.01599910f, 0.11683007f, 0.27218410f, 0.05413254f, 0.00472416f, 0.14938389f, -0.06730820f, -0.31657547f, 
    0.20939073f, 0.12637484f, 0.23751880f, 0.01066316f, 0.21162961f, 0.07506990f, -0.10321863f, 0.13945687f, 
    -0.78625196f, -0.68863630f, -0.52526361f, -0.17449480f, 0.12424907f, -0.13001008f, -0.11633579f, -0.13238594f, 
    0.31505921f, -0.13908634f, 0.05889710f, 0.09430622f, -0.07625675f, -0.20906577f, -0.13504967f, 0.10174393f, 
    -0.05693906f, -0.18943024f, -0.10858822f, -0.05332341f, 0.01602601f, -0.12791945f, 0.24721868f, 0.15104504f, 
    -0.45237318f, -0.12508868f, -0.07370209f, -0.14615837f, 0.06473184f, 0.07129509f, -0.04448504f, -0.02568688f, 
    -0.05148194f, -0.31591192f, -0.28409201f, -0.00969003f, 0.19288014f, -0.16316476f, 0.44529778f, 0.21829042f, 
    -0.01106316f, 0.06511281f, 0.03384690f, -0.05349398f, 0.06768580f, 0.12513861f, -0.05953739f, 0.12264379f, 
    0.48714781f, 0.16830590f, 0.04710440f, 0.01604742f, -0.08710473f, 0.00701074f, 0.13350166f, 0.14643347f, 
    -0.02246123f, 0.15755942f, -0.11157168f, -0.13829081f, -0.33706817f, -0.49667096f, -0.35238087f, -0.08402772f, 
    0.10330002f, 0.06279067f, -0.14467376f, 0.02703952f, 0.19926776f, 0.01661292f, 0.26299053f, 0.05597699f, 
    0.02469568f, -0.55024040f, 0.48587525f, 0.38262418f, -0.15084188f, 0.06720228f, 0.06193111f, -0.12889242f, 
    -0.00809229f, -0.02645083f, -0.15494996f, -0.06674916f, 0.49875396f, -0.62036115f, 0.56636429f, -0.16855162f, 
    -0.20292115f, 0.00125569f, -0.23543732f, 0.14891733f, 0.10801676f, 0.03212607f, 0.20441315f, -0.00655717f, 
    0.34659624f, -0.13558123f, -0.36610326f, 0.05007608f, -0.02777511f, -0.04081044f, 0.13554278f, 0.14185296f, 
    0.13106288f, -0.53768045f, -0.28232434f, -0.48314485f, 0.26288491f, -0.03226642f, -0.33343425f, -0.35532251f, 
    -0.04487998f, 0.31602275f, 0.14213122f, -0.12378498f, 0.05598639f, 0.10033940f, 0.42140511f, -0.38713494f, 
    -0.91184467f, -0.65398395f, -0.67370653f, -0.19005254f, -0.43069771f, 0.12273467f, 0.15832521f, -0.47263652f, 
    0.13037868f, 0.01620571f, -0.03953192f, 0.01367032f, -1.70606005f, -0.79615462f, 0.34228784f, 0.34696236f, 
    -0.20283525f, -0.07295772f, 0.05586439f, -0.12751183f, -0.10718873f, 0.05699638f, 0.08282375f, -0.04704436f, 
    0.17863792f, -0.30014354f, -0.45727542f, -0.06877739f, -0.11954301f, 0.18925151f, 0.08668175f, 0.14622062f, 
    0.06922720f, -0.09341739f, 0.11475559f, 0.13546129f, -0.12846737f, -0.09926932f, 0.24608251f, -0.23477405f, 
    -0.19661796f, 0.39332092f, 0.05084457f, 0.18426684f, -0.13879326f, -0.14237139f, -0.07673478f, 0.10351258f, 
    0.21711642f, -0.03561171f, -0.47155413f, -0.05788023f, -0.35469702f, 0.32731530f, 0.44883496f, -0.07331420f, 
    -0.13134074f, -0.08797286f, -0.11149709f, 0.13268609f, -0.98945165f, -0.95241886f, -0.28269026f, -0.06430317f, 
    -0.18311879f, -0.73184294f, -0.57967669f, -0.31523836f, -0.11036231f, -0.06417913f, 0.04627472f, -0.09400948f, 
    -0.43365079f, 0.15542081f, 0.51370513f, 0.21570842f, -0.13959278f, -0.05612099f, -0.08328591f, 0.00534686f, 
    -0.03291089f, 0.25192970f, 0.19374552f, 0.29558775f, 0.01615212f, -0.35180113f, 0.01401623f, -0.27819076f, 
    -0.07252853f, -0.13219562f, -0.10798316f, 0.15755637f, -0.15561372f, 0.08904591f, -0.39256197f, -0.23361030f, 
    -0.33104295f, -0.03581101f, 0.48884714f, 0.10967747f, 0.03748835f, 0.05466028f, -0.00660910f, 0.00278845f, 
    0.10043633f, 0.08059452f, 0.14725909f, 0.12921132f, -0.27544886f, -0.38788119f, -1.44154692f, -1.13374090f, 
    -0.07877930f, -0.15404719f, 0.12542401f, -0.14791059f, -0.09160467f, 0.03667732f, 0.00438045f, -0.12976345f, 
    1.01048756f, 0.61012530f, -0.20674713f, -0.19728564f, 0.02060997f, -0.06037187f, -0.13625351f, 0.10902023f, 
    0.04239420f, -0.14021859f, 0.12635888f, 0.16906150f, -0.27045792f, 0.04240758f, 0.15969580f, -0.30083430f, 
    0.04438964f, -0.01269574f, -0.00554000f, -0.00244138f, -0.05665804f, -0.08327171f, 0.02910419f, -0.09306988f, 
    -0.40636110f, -0.52759510f, -0.29487282f, 0.57487011f, 0.13647847f, 0.21212597f, -0.03959158f, 0.11359289f, 
    -0.00776683f, -0.01686374f, -0.06601086f, 0.21694258f, 0.01842193f, -0.09702885f, 0.18661329f, 0.42442632f, 
    -0.21516772f, 0.21934155f, -0.05471146f, 0.21973015f, 0.26343349f, 0.15029034f, 0.16926523f, 0.23723876f, 
    0.39625868f, 0.15420911f, -0.26441523f, -0.01366370f, -0.11736500f, -0.07595477f, 0.18561299f, -0.00627246f, 
    -0.09660956f, 0.35883790f, 0.47698152f, 0.08193838f, 0.76832998f, 0.34731713f, -0.15760057f, -0.27385673f, 
    0.04978646f, -0.12382104f, 0.18796042f, 0.00685001f, 0.31304979f, 0.07306495f, -0.15580946f, -0.06135939f, 
    -0.53672618f, -0.35813084f, -0.42102090f, 0.39425704f, 0.35540244f, 0.09619585f, 0.09123506f, 0.06406762f, 
    0.02407359f, 0.02293226f, -0.08901668f, -0.08096221f, 0.12134743f, -0.99699450f, -0.16212779f, -0.90887821f, 
    0.01280975f, 0.01751875f, 0.10111424f, 0.38134620f, 0.00918281f, -0.02496578f, -0.07512806f, -0.05161605f, 
    0.22527662f, -0.50648737f, -0.17629622f, 0.52218163f, -0.18037373f, 0.02113059f, 0.06972058f, -0.00589741f, 
    0.38152546f, 0.07839748f, -0.01898874f, 0.17686063f, -0.00745420f, 0.60476828f, -0.36097842f, 0.19214429f, 
    -0.12189560f, 0.12876627f, -0.03885165f, -0.32986960f, -0.34213099f, -0.06191320f, -0.13161834f, -0.02539873f, 
    -0.11070337f, 0.16217805f, -0.51560032f, -0.01374700f, -0.02236514f, -0.07019465f, -0.01710356f, -0.42717314f, 
    0.09143702f, 0.11892495f, 0.00990285f, 0.06083550f, -0.83722931f, -0.41894290f, 0.43492696f, -0.00066325f, 
    -0.24531151f, 0.01202437f, -0.11368977f, 0.01298084f, 0.04249852f, 0.06116686f, 0.01268846f, -0.01489006f, 
    0.65344614f, -0.00616501f, -0.35591230f, -0.33983132f, 0.02770272f, 0.02520389f, -0.12721890f, -0.03036675f, 
    0.06618035f, -0.03179525f, 0.11125561f, 0.03506801f, 0.19844529f, 0.15205529f, 0.15156710f, -0.38020480f, 
    0.02644797f, 0.06565578f, 0.12287737f, -0.03594753f, 0.09821574f, -0.25694591f, -0.28165653f, -0.24439855f, 
    0.37311694f, 0.15161836f, -0.21670781f, -0.31320429f, -0.08576033f, -0.11898157f, -0.12321611f, 0.05562752f, 
    0.16694698f, 0.20833978f, 0.01612568f, -0.16883630f, -0.90873605f, -0.31748578f, 0.03829303f, 0.91712832f, 
    -0.10131991f, 0.15330268f, -0.39211857f, -0.23422511f, -0.13663860f, -0.16927660f, -0.23548774f, -0.02829020f, 
    -0.92066544f, 0.52769947f, -0.74743903f, 0.41187429f, 0.07430945f, -0.13071044f, 0.22544011f, 0.06707919f, 
    -0.20661080f, 0.14816780f, 0.16502823f, -0.04870906f, 0.09306780f, -0.00241213f, 0.24614516f, -0.33459720f, 
    0.01546219f, 0.06686686f, 0.15768047f, -0.05382643f, 0.06372032f, -0.03540707f, 0.08615977f, -0.26778182f, 
    0.14771476f, -0.27328372f, -0.00668863f, -0.66155702f, -0.15953162f, -0.03218864f, 0.03637194f, -0.04277260f, 
    -0.03293696f, 0.16716151f, 0.06422038f, -0.20033388f, 0.84699750f, -0.27795178f, -0.04275848f, -0.57186341f, 
    0.15832755f, 0.10424573f, -0.14159425f, 0.03126010f, -0.18123029f, -0.04597920f, 0.01710936f, -0.17988369f, 
    -0.11353046f, 0.29859382f, 0.14263037f, 0.25695935f, 0.06928069f, 0.02565377f, 0.03134642f, -0.03947304f, 
    -0.18047370f, -0.05698403f, 0.05453967f, 0.02325388f, -0.01537657f, -0.16201086f, 0.32914045f, -0.21856318f, 
    0.01483686f, -0.06670097f, -0.08178810f, -0.02158483f, -0.06960987f, -0.25374255f, 0.08660320f, 0.18765195f, 
    -0.23842250f, -0.39703622f, -0.27248010f, 0.05121741f, -0.31915125f, 0.12199411f, -0.16766223f, 0.17431448f, 
    -0.22305673f, -0.14900450f, -0.14383772f, -0.20744954f, 0.13702027f, -0.65769231f, -0.82907039f, 0.17482448f, 
    -0.05724484f, 0.18453379f, 0.07742743f, -0.20525391f, -0.04950919f, -0.14031835f, 0.06602547f, 0.00732075f, 
    0.06702156f, -0.02314537f, -0.16376203f, -0.15899451f, 0.21055791f, 0.03762186f, -0.12845451f, 0.03218116f, 
    -0.24687912f, 0.08857040f, -0.25846300f, -0.66874427f, 0.11124438f, 0.19755849f, 0.33626202f, 0.17795780f, 
    0.22863242f, -0.25790122f, -0.05239164f, 0.35661605f, 0.15912190f, -0.03047760f, 0.37565455f, 0.10172770f, 
    -0.13869007f, -0.03060577f, -0.11803694f, 0.40669703f, 0.29477766f, 0.20072883f, 0.08678818f, -0.22316638f, 
    -0.21825658f, 0.05242919f, -0.23589104f, -0.06804378f, -0.33945024f, -0.86538082f, -0.27567741f, -0.06745108f, 
    0.27850905f, 0.21472688f, -0.07226872f, -0.01682107f, 0.13695388f, 0.18867101f, -0.01087883f, 0.30314517f, 
    -0.32421055f, -0.35532859f, -0.46586844f, 0.13492998f, -0.16863821f, 0.23602280f, 0.15109292f, 0.11514169f, 
    0.36233994f, 0.28921816f, -0.09755249f, 0.09264949f, -0.04197841f, 0.24639772f, -0.31660217f, -0.27909017f, 
    -0.02260814f, -0.05518533f, -0.04712476f, -0.01463741f, -0.02625296f, 0.15520926f, 0.04487015f, 0.20848006f, 
    -0.15603060f, -0.03577273f, -0.17745976f, -0.21811832f, 0.04488949f, 0.05320321f, 0.08096936f, 0.09480461f, 
    -0.36392686f, -0.10442717f, -0.18805332f, -0.36735946f, 0.83639419f, 0.33919555f, -0.60075825f, 0.10730442f, 
    0.33591163f, -0.20693240f, -0.13971488f, 0.23134549f, 0.35816145f, 0.17109515f, 0.36825439f, 0.30975097f, 
    -0.56102103f, -0.45476899f, -0.22953406f, -0.03835725f, 0.44309813f, 0.41132286f, -0.10244643f, 0.15726405f, 
    -0.19022068f, 0.09646648f, 0.04623983f, 0.13605011f, -1.00223672f, 0.06828212f, 0.33582246f, 0.01446419f, 
    -0.21705194f, 0.01635311f, -0.19121803f, -0.04782487f, 0.16764870f, 0.06045777f, 0.15895079f, 0.33287200f, 
    0.87608975f, 0.26771620f, -0.00216272f, -0.55254030f, -0.25108930f, -0.13215323f, 0.08487381f, -0.10514838f, 
    0.06895419f, 0.01294407f, 0.09345036f, 0.06999832f, 0.53209984f, -0.17758572f, -0.64296526f, -0.41129780f, 
    0.03860181f, -0.22002649f, 0.14608714f, -0.16899833f, 0.06112037f, -0.13499331f, -0.00740555f, 0.20507136f, 
    -1.14894569f, -0.34906408f, 0.11221440f, -0.00619388f, -0.10159202f, -0.03406988f, -0.28697115f, -0.07465001f, 
    -0.37661996f, -0.00386510f, -0.22439525f, -0.24781859f, -0.54256320f, -0.04928609f, -0.07203165f, 0.02108949f, 
    0.22933249f, -0.16011705f, 0.14683799f, 0.18316092f, 0.02068639f, 0.05953168f, -0.09620258f, -0.11770232f, 
    -0.43769801f, 0.55695063f, 0.50789529f, -0.62419623f, -0.05603079f, -0.17208332f, 0.28216323f, 0.34964412f, 
    -0.11202253f, 0.10928577f, 0.13414705f, 0.01053337f, -0.20982482f, -0.22918145f, 0.13395445f, -0.53599674f, 
    -0.13346840f, 0.02954141f, 0.03318736f, 0.12822482f, 0.20999521f, -0.01165810f, 0.01544904f, 0.01987604f, 
    0.07094271f, 0.22007875f, 0.04533232f, 0.11324982f, -0.06499552f, 0.06648028f, 0.03253643f, -0.00175392f, 
    -0.05920418f, 0.19066478f, 0.16214728f, 0.14840184f, -0.60691488f, 0.31822544f, -0.72392833f, 0.01798602f, 
    0.12919419f, -0.36925560f, 0.24348262f, 0.19147351f, 0.22080548f, -0.25452429f, 0.17856532f, 0.16937679f, 
    -0.58434504f, 0.16281183f, -1.23021865f, -0.22057550f, 0.51094836f, -0.10844867f, 0.07778540f, 0.03756353f, 
    0.12636599f, -0.17821334f, -0.26127797f, 0.02249348f, 0.09847690f, -0.40970165f, 0.22194812f, -0.13391124f, 
    0.08455800f, -0.09354296f, -0.20288478f, 0.10422158f, -0.10116656f, -0.08736420f, -0.06552888f, -0.05790012f, 
    0.20538694f, 0.82006836f, 0.18787350f, 0.60807049f, -0.13701567f, -0.19168311f, -0.43941799f, -0.08559615f, 
    -0.05524336f, -0.07502185f, -0.12103692f, 0.10327998f, -0.11486314f, -0.20395093f, -0.01938471f, 0.46004868f, 
    0.21176507f, 0.13341852f, -0.12515736f, -0.17351015f, -0.02096966f, 0.26789063f, -0.00534943f, -0.05390061f, 
    -0.29816303f, 0.05798998f, -0.08761499f, 0.60696721f, 0.05057450f, 0.09140803f, -0.21837941f, 0.12270096f, 
    0.15424801f, 0.08142319f, 0.07403556f, 0.04581767f, -0.13056636f, 0.16968060f, -0.73311520f, 0.38375193f, 
    0.09073763f, -0.16488777f, -0.13820344f, 0.06471438f, 0.13169703f, 0.01768056f, 0.05574080f, -0.08419400f, 
    -0.49680245f, 0.18630524f, -0.13717531f, -0.55456150f, 0.09318082f, -0.53567415f, -0.00494745f, -0.13681096f, 
    0.04939349f, 0.06720641f, 0.18504603f, -0.08034898f, 0.02394141f, -0.49711862f, 0.00839335f, -0.08409067f, 
    -0.08294684f, 0.14284472f, 0.10409114f, 0.10565436f, -0.08799107f, -0.19187242f, -0.00198086f, -0.28409129f, 
    -0.04064296f, -1.10356736f, 0.18986484f, -0.13419099f, 0.23603179f, 0.27362028f, -0.16813657f, 0.11266460f, 
    -0.24918395f, -0.05913060f, 0.01626191f, 0.00746059f, -0.55781335f, -0.52308583f, 0.44754097f, 0.19126070f, 
    0.00239836f, 0.04920962f, -0.14027074f, -0.36596006f, -0.01199839f, -0.18834300f, -0.12488039f, 0.15721466f, 
    -0.11022892f, 0.13034469f, 0.29292721f, -0.69113493f, -0.03344546f, 0.03613055f, 0.22123818f, 0.08082123f, 
    0.20880593f, 0.04696440f, 0.18477374f, 0.39366695f, 0.42109305f, 0.03396183f, 0.41846052f, -0.16565433f, 
    -0.00706153f, 0.07545810f, -0.16748022f, 0.06936709f, -0.06530707f, -0.02332479f, -0.13259402f, -0.06373901f, 
    -0.17438075f, -0.49348703f, -0.10332382f, 0.21268053f, -0.03039994f, -0.05828845f, -0.19124164f, -0.21990354f, 
    -0.02511972f, -0.01944040f, -0.33102965f, -0.14614396f, -0.16029340f, -0.44375223f, 0.17697439f, 0.14155999f, 
    0.07550425f, -0.06368184f, -0.21568868f, 0.11577115f, -0.04573818f, 0.00441949f, -0.05656203f, -0.40907553f, 
    -0.25722641f, 0.09114525f, -0.28262913f, -0.22646700f, -0.05998155f, -0.18166667f, 0.25823748f, 0.05634738f, 
    -0.29794186f, -0.24264365f, -0.33432505f, -0.54613513f, 0.22480607f, -0.27957723f, 0.18020575f, -0.17777577f, 
    -0.27687168f, 0.42542121f, 0.16666906f, 0.01535792f, 0.08608477f, 0.14873154f, -0.12569067f, 0.01142569f, 
    -0.05918999f, -0.11957756f, 0.62330949f, -0.18555364f, -0.32050398f, -0.23746558f, -0.20483465f, 0.06155876f, 
    -0.04725206f, 0.01606596f, 0.13101101f, 0.20079307f, -0.30403510f, 0.40604421f, -0.85321945f, 0.51112652f, 
    0.18257901f, 0.01655834f, 0.06303798f, 0.09095668f, 0.05569971f, 0.25750917f, 0.07974505f, 0.41630074f, 
    0.59205961f, 0.14529684f, 0.37984717f, -0.39642787f, 0.02300312f, -0.21478528f, -0.06160884f, 0.10460602f, 
    -0.26493090f, -0.09453036f, 0.10202456f, -0.25192940f, -0.59610164f, 0.03768555f, -0.51816761f, -0.56311691f, 
    -0.14701499f, -0.03471782f, 0.02478465f, -0.35729814f, 0.02470313f, 0.23741364f, 0.00241499f, 0.27248111f, 
    0.35207039f, 0.81785136f, 0.54262894f, -0.51117253f, 0.17756046f, -0.07471943f, -0.24858309f, 0.17039989f, 
    -0.23593524f, -0.31631032f, -0.36460060f, -0.67249256f, -0.20924506f, 0.25595763f, -0.22651942f, -0.17742319f, 
    0.14259750f, 0.05536808f, 0.26291385f, 0.10836384f, -0.09418629f, 0.33739123f, -0.05655577f, 0.28221312f, 
    -0.18298976f, 0.21158378f, 0.20780988f, -0.06353306f, 0.12625995f, -0.22805965f, -0.00512451f, 0.00084748f, 
    0.16460973f, -0.06648065f, 0.13921760f, -0.08853184f, -0.39061296f, 0.07278616f, 0.14450119f, 0.06439044f, 
    -0.22733523f, -0.17389244f, -0.16783598f, 0.16013145f, 0.05090524f, 0.04979715f, 0.45045230f, 0.34716308f, 
    -0.91825581f, 0.65770632f, -0.27058730f, 0.28114015f, -0.07453965f, 0.37575465f, -0.01592062f, -0.17039829f, 
    0.20953865f, 0.14222121f, 0.04293390f, -0.14637926f, -1.08520579f, 0.38306713f, -0.10685914f, -0.01136088f, 
    0.12628269f, 0.03643875f, 0.10175632f, 0.08069056f, -0.23503579f, -0.10613764f, 0.23291223f, 0.20559785f, 
    -0.16490547f, 0.33777794f, 0.27673423f, -0.17709598f, -0.01371371f, -0.43534118f, -0.19837649f, -0.10971539f, 
    -0.07994901f, -0.35121316f, -0.36876491f, -0.40658271f, -0.42654127f, 0.12841478f, -0.77444553f, 0.68238908f, 
    0.04411808f, 0.25202599f, 0.14774965f, 0.21433279f, -0.33933744f, 0.02363877f, 0.18492539f, -0.06226595f, 
    -0.11719299f, -0.53711134f, 0.28645670f, -0.48597398f, -0.19907698f, -0.45367101f, -0.13554507f, -0.09676561f, 
    0.10193285f, 0.22763947f, -0.09786569f, -0.21608104f, -0.10177780f, 0.73161697f, -0.30968964f, 0.12290316f, 
    -0.29344147f, -0.18557806f, 0.22372358f, -0.10251725f, -0.07951969f, 0.31647757f, 0.13495825f, -0.09340334f, 
    -0.25949261f, -0.13746518f, -0.40132296f, -0.14415228f, 0.23092067f, -0.07543299f, -0.09701215f, 0.06613026f, 
    0.22930121f, 0.05803502f, 0.01537088f, 0.14873035f, 0.21755776f, -0.26395175f, 0.45654607f, -0.27464268f, 
    0.24032982f, 0.28647384f, -0.02092805f, 0.03159231f, -0.16595113f, 0.08272514f, -0.08711082f, 0.21439412f, 
    0.76531601f, -0.03810874f, 0.80160391f, -0.65206665f, -0.21415329f, 0.05027171f, -0.21943289f, 0.21119872f, 
    -0.27634737f, -0.22564568f, -0.18165512f, 0.00920429f, -0.34871432f, 0.03569718f, -0.15523972f, -0.12681788f, 
    -0.13733016f, -0.27758491f, -0.50336015f, 0.01147663f, -0.09998035f, -0.00615954f, -0.17366573f, -0.32067946f, 
    -0.89657480f, -0.39969411f, -0.15862675f, -0.11054985f, 0.03864800f, 0.04984657f, 0.11138357f, -0.00936541f, 
    -0.22819379f, -0.03903066f, 0.12129425f, -0.24971768f, -0.16773240f, 0.05854441f, -0.13143134f, 0.09950794f, 
    0.03674879f, 0.17402261f, 0.10798662f, 0.09875246f, 0.00093933f, 0.11801464f, 0.10156520f, -0.18579136f, 
    -0.34572685f, -0.18501726f, -0.04729327f, 0.09553676f, 0.11438026f, 0.18166925f, 0.24373826f, -0.19923297f, 
    0.05225560f, -0.10331707f, 0.36069435f, 0.31333056f, 0.28055894f, -0.60647094f, 0.27436095f, 0.29885820f, 
    0.00955384f, -0.49978045f, 0.16240242f, -0.25167435f, -0.00739691f, -0.02352104f, 0.08298234f, 0.11035444f, 
    -0.02699477f, -1.75919366f, 0.45806286f, -0.31432480f, -0.08141778f, 0.26292869f, 0.14313041f, 0.31080499f, 
    -0.04925788f, 0.11440552f, 0.23575021f, -0.00949785f, 0.25653678f, 0.36233804f, -0.20529148f, 0.49385512f, 
    -0.07244073f, 0.09794830f, -0.16400026f, 0.04960710f, -0.49365065f, 0.09529117f, -0.09632508f, -0.12860096f, 
    -0.16874231f, 0.37109736f, -0.02822444f, -0.05957121f, 0.33118120f, -0.03658935f, 0.08759943f, 0.02904073f, 
    0.03835545f, -0.14951392f, -0.06499082f, 0.04860604f, -0.60033321f, -0.30870309f, -0.60074526f, 0.45013994f, 
    0.13554657f, -0.15522191f, 0.26236907f, -0.25400910f, 0.05441303f, 0.01167201f, 0.18235241f, -0.25996712f, 
    0.11594095f, -0.10827200f, -0.00699088f, 0.20489776f, -0.08285730f, 0.14212233f, 0.07957967f, 0.16387320f, 
    -0.23990427f, 0.27842680f, 0.16124801f, 0.13433726f, -0.35407910f, -0.29097512f, 0.65687555f, 0.95546770f, 
    -0.14591803f, -0.14579195f, 0.48705977f, 0.13216551f, -0.10835176f, 0.12997384f, -0.00004281f, 0.05422521f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.30520767f, 0.18723403f, 0.23742057f, -0.10051824f, -0.34161833f, 0.20516567f, 0.05789571f, -0.29436764f, 
    0.08574013f, 0.04257483f, 0.01144429f, -0.06322120f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
