#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.57098269f, -0.50441003f, -0.41445079f, -0.18941499f, 0.12698814f, 0.49235094f, 0.36399928f, 0.16958486f, 
    0.27376133f, -0.37066334f, 0.32297492f, 0.67544776f, -0.87057847f, 0.37923720f, -0.38145909f, -0.11162231f, 
    -0.21328512f, -0.02315891f, -0.90112424f, 0.96055841f, 0.32991132f, -0.02863382f, 0.66046631f, 0.38014632f, 
    -0.18650630f, 0.06352528f, 0.12869026f, -0.01099472f, -0.81878614f, 0.70699894f, -0.36683908f, 0.15345787f, 
    0.57689548f, -0.21799020f, -0.54773545f, -0.28576326f, -0.46444693f, 0.28162405f, 0.00072763f, 0.74184561f, 
    0.33116680f, 0.40990683f, 0.54229909f, -0.29778257f, -0.07820167f, 0.03937316f, -0.55731171f, -0.42634025f, 
    -0.62546003f, -0.42673507f, -0.59006399f, 0.26366654f, 0.31966934f, 0.19475637f, -0.81869090f, 0.15150566f, 
    0.89939684f, 0.50981218f, 0.00317309f, -0.43269604f, 0.17779085f, 0.41764605f, -0.13917564f, -0.07011975f, 
    -0.73007661f, 0.34801415f, 0.43441591f, -0.28520253f, -0.50546241f, -0.14513147f, -0.48001802f, -0.35939708f, 
    0.39248350f, 0.61042064f, -0.89058954f, 0.00468949f, -0.45337647f, 0.26553518f, -0.20408778f, -0.12835073f, 
    0.03797625f, 1.19321525f, 0.73087013f, 0.57675993f, -0.64632124f, -0.44617730f, -0.41521108f, 0.08633128f, 
    -0.00933855f, 0.06903686f, -0.53156960f, -0.64014196f, 0.44887316f, -0.57715183f, -0.17945424f, -0.12967917f, 
    0.52954018f, 0.23123737f, -0.22731891f, 0.21834412f, 0.31271568f, 0.73326057f, 0.49607447f, 0.38281667f, 
    0.50327355f, -0.13578637f, -0.10344676f, -0.22252111f, -0.65308928f, -0.63308841f, -0.21550684f, 0.37160814f, 
    0.42998001f, 0.19634609f, -0.52010900f, 0.38567480f, 0.29653302f, -0.33746070f, -0.47940060f, -0.35830417f, 
    -0.34262347f, -0.71741641f, -0.40829584f, -0.20905615f, -0.11531015f, -0.15429166f, 0.64269018f, -0.78872478f, 
    -0.72280806f, -0.10828373f, -0.15987109f, 0.31906050f, 0.15482527f, 0.21481019f, 0.21576685f, -0.34312734f, 
    -0.90444720f, -0.56548256f, 0.18986011f, 0.92397135f, 0.38377503f, -0.18800735f, -0.11464277f, -0.23069718f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18116322f, 0.15248041f, 0.05093997f, -0.09073451f, 0.06253210f, 0.27605614f, 0.00398221f, -0.13454652f, 
    -0.16536364f, 0.26415700f, 0.29092509f, 0.31672531f, -0.01187465f, 0.32941702f, 0.17394654f, 0.14514619f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03360217f, 0.13152295f, 0.03427269f, -0.02912107f, 0.01216322f, -0.00250708f, 0.01441871f, 0.16442332f, 
    0.09280849f, -0.03301946f, -0.02997560f, -0.02928030f, 0.05250622f, -0.04027871f, -0.06402548f, 0.01876986f, 
    0.10948246f, 0.03206684f, -0.03589725f, 0.10136782f, 0.07179012f, -0.11655439f, -0.10513644f, -0.04279688f, 
    0.03452088f, -0.05261847f, 0.00005146f, 0.00770452f, 0.02014657f, 0.10092360f, -0.01360793f, 0.07714710f, 
    -0.00335581f, 0.03027102f, 0.03501474f, 0.10008813f, -0.01518393f, 0.07963862f, -0.07141314f, 0.12853576f, 
    -0.45880020f, -0.01386875f, -0.19684003f, 0.02858817f, 0.01924151f, 0.06238636f, 0.11982568f, -0.17027919f, 
    -0.06676722f, 0.07512298f, -0.01994772f, 0.04836724f, 0.09892754f, -0.03255066f, 0.09136532f, -0.03695600f, 
    -0.06679866f, 0.20701672f, -0.01383593f, 0.03314187f, -0.22245525f, 0.03872790f, -0.02534553f, -0.00408108f, 
    0.10068811f, -0.00481156f, -0.03417500f, -0.10206934f, -0.04788844f, 0.06465314f, 0.01305611f, -0.00056087f, 
    -0.06454428f, 0.02292249f, -0.10586695f, 0.03613838f, -0.11285118f, 0.01872641f, -0.16576892f, -0.07812355f, 
    0.01065321f, -0.01517707f, -0.09431682f, 0.07954497f, 0.12690818f, 0.05280257f, 0.01919037f, -0.07572894f, 
    -0.01693581f, 0.05327056f, 0.08716276f, 0.08329511f, -0.12313896f, -0.06959586f, 0.03274528f, 0.11143351f, 
    0.10215750f, 0.08710591f, -0.11354551f, 0.11646196f, -0.06872796f, 0.04218432f, 0.02448742f, -0.03210350f, 
    0.05824018f, 0.01032045f, -0.05657377f, -0.04636660f, 0.13973668f, 0.03071455f, 0.05246961f, 0.00224189f, 
    0.07579389f, 0.03842372f, -0.04336918f, 0.07577477f, 0.03016270f, -0.12131867f, -0.09727654f, 0.04652092f, 
    -0.11842711f, -0.03337251f, 0.02896708f, 0.12553203f, 0.07043672f, -0.01907441f, 0.05193789f, -0.11281005f, 
    0.02265159f, 0.03208204f, 0.06529659f, 0.00872985f, -0.05815888f, 0.08648185f, 0.03281654f, 0.00905503f, 
    0.03650933f, 0.11510491f, 0.03197150f, 0.04239802f, -0.14619894f, -0.01530283f, 0.06462902f, -0.07270810f, 
    -0.18807270f, -0.00963536f, -0.00382474f, 0.03939032f, -0.10702568f, 0.08863763f, 0.02923174f, 0.03916809f, 
    0.04177519f, -0.11558767f, -0.05484103f, -0.02448225f, 0.01122180f, -0.18607661f, 0.01291772f, -0.02068958f, 
    -0.29908150f, -0.00609689f, -0.00818434f, 0.00513347f, 0.04282135f, 0.02296508f, 0.04611438f, -0.06378686f, 
    -0.01753900f, -0.03660611f, -0.01086223f, -0.08061671f, 0.00330866f, 0.03601765f, -0.07007750f, 0.00651798f, 
    0.01589468f, -0.06234385f, 0.19288856f, 0.02438624f, 0.02338017f, 0.07655539f, 0.07077673f, -0.01042801f, 
    -0.11752705f, 0.22108349f, -0.01748041f, 0.04335114f, 0.03148655f, 0.07163955f, -0.01572414f, 0.02439079f, 
    0.04298607f, 0.26791543f, 0.07408968f, 0.08662090f, 0.00745072f, -0.01354638f, -0.13551851f, 0.02219905f, 
    -0.05386976f, 0.06414010f, 0.00306141f, -0.09258051f, -0.00722557f, 0.02484086f, -0.01991863f, -0.03227675f, 
    0.17264718f, 0.00469429f, 0.01244161f, 0.05472000f, 0.03655408f, -0.02306611f, 0.08447307f, 0.07476462f, 
    0.04205942f, 0.07518888f, -0.15044667f, 0.01472475f, 0.24021107f, 0.05058745f, -0.04002669f, 0.05153430f, 
    -0.02974617f, 0.10850740f, 0.22370687f, -0.11945776f, -0.02032754f, 0.08090968f, 0.02319747f, -0.01945281f, 
    0.02161831f, 0.03075893f, 0.08806004f, 0.00198057f, -0.01948229f, 0.15303643f, 0.03364171f, 0.00209241f, 
    0.10236837f, -0.04537642f, 0.00847752f, 0.09533817f, -0.05708682f, -0.05639831f, -0.01064182f, 0.09237538f, 
    -0.08003025f, -0.00798735f, -0.03632498f, -0.06380194f, 0.04102831f, -0.02705909f, -0.05951231f, 0.02948310f, 
    -0.06461821f, -0.00297065f, -0.07247747f, -0.05689622f, 0.01103869f, -0.02222407f, -0.03509223f, -0.19690299f, 
    0.05859165f, 0.02118772f, -0.08407814f, 0.05938799f, -0.08740395f, 0.06332517f, 0.03544494f, -0.06468821f, 
    0.07155581f, 0.10864969f, -0.11157879f, -0.04954661f, 0.02791460f, -0.16267788f, -0.14227144f, -0.12244003f, 
    -0.13499615f, -0.18001521f, 0.09665300f, -0.00292195f, 0.23606305f, 0.03452390f, -0.07375351f, 0.03564114f, 
    0.12708865f, -0.00617229f, 0.18511477f, -0.07214601f, -0.03041288f, 0.00240619f, 0.00218848f, 0.04752111f, 
    0.03478243f, -0.15444806f, 0.01199217f, -0.00525172f, 0.32353714f, 0.01680540f, -0.15046571f, -0.01483654f, 
    -0.00299863f, -0.01506417f, 0.01176841f, -0.04594755f, -0.02289189f, -0.10905636f, 0.09222618f, 0.01758242f, 
    -0.01613650f, -0.13426797f, -0.03877138f, -0.04530025f, -0.02194079f, -0.13996230f, -0.01177818f, 0.01329228f, 
    0.15513532f, -0.03088829f, -0.07867651f, 0.12677732f, -0.08061702f, -0.06096227f, -0.05406984f, -0.06534742f, 
    0.08677665f, 0.06183110f, 0.02204008f, -0.09056409f, -0.03945060f, -0.02847693f, 0.08665720f, 0.04185649f, 
    0.17503312f, 0.01013296f, 0.02991859f, 0.15188436f, -0.03741872f, -0.09634704f, -0.01407082f, -0.16695690f, 
    0.01969698f, 0.00170835f, 0.10205365f, -0.01029367f, -0.01043380f, -0.00046693f, 0.10823154f, 0.03651374f, 
    0.00060919f, -0.01226749f, -0.06324174f, -0.00826416f, -0.01998207f, 0.01704738f, 0.05090252f, 0.04982360f, 
    0.33753285f, -0.05343111f, -0.08749252f, -0.04846978f, 0.15361629f, -0.02598081f, 0.02179274f, -0.00112204f, 
    -0.10224563f, -0.08080978f, 0.01867391f, 0.00534504f, 0.01393796f, -0.02046666f, 0.03408565f, -0.01533329f, 
    -0.05283995f, 0.19052650f, 0.07556048f, -0.00279864f, 0.43476757f, 0.01171546f, -0.03320490f, 0.11446991f, 
    -0.08445950f, 0.01912907f, -0.02990479f, 0.04687020f, -0.04237014f, 0.04402799f, 0.00453143f, 0.10974456f, 
    -0.05376668f, 0.07652166f, -0.02020517f, 0.11113873f, 0.03972409f, 0.01498944f, 0.06445094f, 0.01575392f, 
    0.06506031f, 0.17852500f, 0.04186195f, -0.00170936f, 0.01723436f, 0.02928094f, 0.05787354f, 0.00248107f, 
    -0.07009480f, -0.05134074f, 0.15092923f, -0.07717126f, -0.07476164f, -0.00569168f, 0.02299307f, 0.02071399f, 
    0.21585108f, 0.04428472f, 0.06809172f, -0.00161174f, 0.02331818f, -0.09406537f, -0.02471779f, -0.01180123f, 
    -0.03005811f, -0.02478442f, -0.02047046f, -0.01386649f, 0.10368601f, 0.10727932f, -0.02417183f, -0.01594250f, 
    0.00191269f, -0.01123669f, 0.08207876f, 0.12663646f, 0.10708268f, -0.06254615f, 0.00062986f, 0.09503128f, 
    -0.26582456f, -0.01030613f, 0.03193758f, -0.00390649f, 0.11536197f, 0.07244024f, -0.00528021f, -0.08937313f, 
    -0.01230768f, 0.06876651f, 0.05242725f, -0.07176413f, 0.07608957f, -0.03928734f, -0.09523760f, -0.01454690f, 
    0.02947553f, 0.09814970f, 0.00095465f, 0.02108309f, -0.02217693f, 0.10583968f, -0.08671999f, -0.23098075f, 
    -0.22937629f, 0.09029186f, 0.01755198f, 0.00408813f, 0.03175871f, 0.24093729f, -0.07715843f, -0.02025243f, 
    0.06460995f, 0.03202319f, 0.03028519f, 0.05869031f, 0.04753303f, -0.00088630f, 0.09219525f, 0.00945616f, 
    -0.17276625f, -0.50087559f, 0.17813492f, -0.22044700f, 0.09730069f, -0.02300938f, -0.09821136f, 0.06816757f, 
    0.10542899f, -0.05068542f, -0.00211394f, -0.13696606f, -0.05491624f, 0.11001947f, 0.04586008f, 0.00385479f, 
    -0.03205478f, 0.07376095f, 0.11574875f, 0.03070748f, -0.14948051f, -0.11560291f, 0.21023187f, 0.06217168f, 
    -0.17435662f, 0.11908200f, 0.01823230f, 0.06322079f, 0.01985624f, 0.01513749f, -0.12217408f, -0.04299054f, 
    0.07170533f, 0.09721818f, -0.02026363f, 0.08426987f, -0.00061463f, -0.06057698f, -0.11430817f, -0.04102015f, 
    0.07628302f, -0.11408926f, -0.05531085f, 0.05648295f, -0.25599736f, 0.08589195f, -0.04859758f, -0.06065864f, 
    0.08194333f, -0.01133279f, 0.03144228f, 0.06075015f, 0.08357652f, -0.01698318f, -0.00768580f, 0.01376575f, 
    0.03881117f, 0.03645319f, -0.03845008f, -0.05279699f, 0.21979165f, 0.07885860f, 0.15974404f, 0.21931829f, 
    0.15639505f, 0.05876243f, 0.15366474f, -0.00647782f, -0.01594787f, 0.00719225f, 0.06596577f, 0.06782997f, 
    -0.00822691f, 0.03926292f, 0.02761440f, -0.03522107f, 0.03659667f, 0.09547015f, 0.12857944f, -0.02219804f, 
    0.24352142f, -0.02545777f, -0.09633467f, 0.09315076f, -0.15700969f, 0.07887075f, -0.04418152f, 0.03772499f, 
    -0.08920749f, 0.05587993f, -0.03885218f, 0.05720272f, -0.02945635f, -0.00128569f, -0.13392958f, 0.05643173f, 
    -0.01848114f, 0.04721618f, 0.05657989f, 0.02991343f, -0.09243547f, -0.15433806f, -0.04066233f, -0.09028781f, 
    -0.07396334f, 0.04124932f, 0.06177725f, 0.08272175f, 0.01032439f, 0.17552464f, 0.00557882f, -0.04468874f, 
    0.13591842f, 0.12713723f, -0.00582439f, -0.06049665f, 0.01514421f, -0.06972100f, -0.06419311f, -0.04134134f, 
    0.06442179f, -0.28430486f, 0.07850154f, 0.06013618f, 0.08615732f, -0.10254437f, 0.04209315f, 0.06418709f, 
    0.09166447f, 0.09194303f, 0.05530756f, -0.08690869f, 0.06620025f, 0.09819414f, 0.01887334f, 0.05351045f, 
    -0.05930829f, 0.01998765f, 0.03197334f, 0.01527789f, 0.33393106f, -0.00474083f, -0.20503502f, -0.10135980f, 
    -0.06263082f, -0.03693400f, -0.02055429f, -0.07866615f, 0.02367766f, 0.04757674f, 0.07460579f, 0.06486277f, 
    -0.01748313f, -0.03020835f, 0.04202050f, 0.00104777f, -0.02666614f, -0.02201488f, -0.12566720f, -0.00211094f, 
    -0.04184399f, 0.02250218f, -0.05352543f, -0.02078904f, -0.03844478f, 0.01813872f, -0.05129329f, -0.03526976f, 
    0.03927219f, 0.01278798f, -0.02139960f, 0.03303692f, -0.02288496f, -0.01144227f, -0.04186940f, -0.03188823f, 
    0.02326007f, -0.06000428f, -0.05857999f, -0.02158784f, 0.01473527f, 0.04133652f, -0.01263809f, 0.02914514f, 
    -0.02375608f, 0.04264592f, -0.02560207f, 0.03397750f, 0.01598807f, 0.01147722f, 0.02135665f, -0.02434234f, 
    -0.05697311f, -0.01735024f, 0.00023982f, 0.01108557f, -0.05057025f, -0.06096267f, 0.04673770f, -0.02127293f, 
    -0.02496414f, 0.02903088f, 0.01050984f, -0.02836663f, 0.02522639f, -0.02149442f, 0.01818916f, 0.01195369f, 
    -0.01502273f, 0.01286717f, 0.01816216f, 0.01644459f, 0.03156982f, 0.01617061f, -0.02480168f, 0.01749140f, 
    0.02721719f, 0.00484106f, 0.00016668f, 0.01473929f, -0.00747276f, -0.01401565f, -0.04725257f, -0.00083158f, 
    0.00259346f, -0.03738352f, 0.00130699f, 0.04531186f, -0.03056910f, 0.01749096f, -0.04767134f, -0.04580379f, 
    -0.06076563f, -0.00567452f, -0.02172025f, -0.00071737f, 0.04252013f, 0.04079164f, -0.03268082f, -0.01288703f, 
    -0.01597419f, -0.03404021f, -0.00747051f, 0.01883368f, -0.05111425f, -0.05588962f, -0.05031655f, -0.01676918f, 
    -0.02314801f, 0.00155554f, 0.01868519f, -0.06189278f, -0.04463720f, -0.04822595f, 0.04935540f, -0.05512644f, 
    0.02530826f, 0.02149467f, 0.04557198f, -0.04283099f, 0.03280611f, -0.03957856f, 0.02741551f, -0.03220654f, 
    -0.03434724f, 0.00025591f, -0.04231570f, 0.00794336f, -0.02151892f, 0.00986122f, -0.04168104f, -0.01126286f, 
    -0.04617219f, -0.02587619f, -0.04266495f, -0.01801250f, -0.04664579f, -0.00945463f, -0.06142893f, -0.05047428f, 
    -0.03071096f, 0.03022040f, 0.03203387f, -0.00826195f, 0.05058742f, -0.01378115f, -0.03444805f, 0.02146130f, 
    0.03016802f, -0.05896255f, 0.01926365f, -0.01811859f, -0.00278226f, 0.04389900f, 0.04899225f, -0.00251237f, 
    -0.02828640f, -0.05423366f, -0.03041865f, -0.04243993f, -0.05428379f, 0.00160604f, 0.00141386f, 0.01021530f, 
    -0.03321664f, -0.00983030f, -0.04839066f, 0.02052533f, 0.04653701f, -0.00988583f, -0.00262981f, -0.01560079f, 
    -0.00699468f, -0.01509304f, -0.00169345f, 0.04447618f, 0.04906303f, -0.04895474f, -0.03845621f, -0.01564117f, 
    -0.01912186f, -0.01498598f, -0.00888594f, -0.04726436f, -0.02862340f, 0.02611679f, 0.01151782f, -0.03662806f, 
    -0.00078598f, -0.02054968f, -0.03691169f, 0.05000255f, -0.04922614f, 0.04336353f, -0.04197290f, -0.03081655f, 
    -0.04499089f, -0.02080283f, -0.02038031f, -0.05000218f, -0.00612829f, -0.02189814f, 0.02220932f, -0.00606985f, 
    -0.02231421f, -0.04045918f, 0.00752098f, -0.04679015f, 0.01428431f, 0.01070538f, 0.01312380f, 0.02179791f, 
    -0.03496258f, 0.02436191f, 0.01039205f, -0.00719664f, -0.05301322f, -0.01837317f, 0.04601687f, -0.03499210f, 
    -0.01069044f, -0.05194325f, -0.02868295f, 0.00547990f, 0.01076662f, -0.03802407f, 0.00890996f, -0.00765813f, 
    -0.05015419f, -0.01399631f, 0.01021153f, 0.04363905f, 0.03708757f, 0.04389402f, -0.04787169f, 0.02831041f, 
    -0.04156513f, 0.02519065f, 0.02151573f, -0.04911992f, -0.04780187f, -0.03627665f, -0.03472058f, -0.04492045f, 
    -0.03912710f, -0.05295391f, 0.01004425f, -0.00800568f, -0.00618150f, 0.02849033f, 0.04845626f, -0.00682186f, 
    -0.00855408f, 0.03481863f, -0.03462331f, 0.04475439f, -0.05393077f, 0.02895938f, 0.04467173f, -0.00757826f, 
    -0.04214117f, 0.02834329f, -0.00320659f, 0.02564010f, 0.04302206f, 0.00830794f, -0.02565830f, 0.00789146f, 
    -0.02553970f, -0.05569229f, 0.01074780f, -0.03962064f, -0.01868663f, 0.02093985f, -0.04626948f, -0.05355420f, 
    -0.01658521f, -0.05371515f, -0.02319405f, 0.00361063f, 0.03558619f, -0.06021172f, 0.04048976f, 0.02564017f, 
    0.04283612f, -0.01354613f, 0.01092616f, 0.01315380f, -0.05478729f, -0.02259300f, -0.05554000f, -0.00138153f, 
    0.02160454f, -0.03412878f, 0.00346282f, 0.00118505f, -0.04535333f, -0.02675341f, -0.00021206f, 0.00996907f, 
    0.04600452f, 0.03285740f, -0.06124867f, 0.00017341f, -0.00762887f, 0.04027076f, 0.01822942f, 0.00721081f, 
    0.04227725f, -0.03760758f, -0.03716409f, 0.04776220f, -0.00465289f, 0.03457813f, 0.04951396f, 0.03256971f, 
    0.01007829f, -0.02075510f, -0.00594886f, -0.03411391f, -0.04151259f, -0.00218263f, 0.02937991f, -0.05781012f, 
    0.01473536f, 0.01955849f, -0.05659345f, -0.02835499f, -0.01713656f, -0.01766183f, 0.01088542f, 0.01386963f, 
    0.02215485f, -0.00436284f, -0.02968270f, -0.03585164f, -0.03029717f, -0.00001206f, 0.04867378f, 0.00372302f, 
    0.02912725f, 0.02416582f, -0.01331944f, -0.03185466f, 0.02267934f, 0.02450553f, 0.02416216f, -0.03414132f, 
    -0.03627955f, -0.01077181f, -0.00990297f, -0.04803498f, 0.01946809f, -0.04416046f, -0.02187989f, -0.00513267f, 
    0.01173487f, -0.01871642f, 0.00916213f, -0.00080417f, 0.02096591f, -0.04675921f, 0.01519960f, -0.04352979f, 
    -0.02999864f, 0.03791428f, 0.00061597f, 0.00016233f, -0.00405242f, 0.04704628f, -0.05492432f, -0.03785222f, 
    0.00306772f, -0.00754288f, -0.03952447f, 0.02240477f, -0.00069626f, -0.02641588f, -0.02831428f, -0.03516442f, 
    -0.00048091f, -0.00167875f, 0.04390428f, -0.03293247f, -0.02944663f, 0.01184987f, -0.01478248f, -0.00710109f, 
    -0.01190151f, 0.03502648f, 0.03881637f, 0.02838034f, 0.04377838f, 0.00639377f, 0.01587257f, 0.04058790f, 
    0.03250249f, -0.02342685f, -0.06441896f, -0.01410752f, 0.03979418f, -0.05952859f, -0.05415900f, 0.01425030f, 
    -0.05841317f, 0.04597525f, -0.00479699f, 0.02463347f, 0.00848487f, 0.04071749f, 0.01653532f, -0.00354988f, 
    0.00390963f, 0.03032469f, 0.04026438f, -0.03809088f, -0.03556936f, -0.02585997f, 0.01379158f, -0.00257035f, 
    -0.04326084f, 0.01940741f, -0.00366362f, 0.03793418f, 0.01720074f, -0.03287013f, -0.01019275f, 0.04133437f, 
    0.00349237f, -0.02154041f, -0.04197331f, 0.03326944f, 0.04536872f, -0.02697302f, 0.03078887f, 0.02938824f, 
    0.00801281f, -0.03522715f, -0.01588562f, -0.04252600f, -0.03779324f, -0.04110428f, 0.02464849f, -0.01277689f, 
    0.01869314f, -0.01312005f, 0.01552337f, -0.03637208f, 0.01267754f, 0.01625561f, 0.02302013f, -0.02127447f, 
    0.03945597f, -0.01617599f, -0.03513075f, -0.00118240f, 0.03135585f, -0.03116959f, 0.00744471f, -0.00816953f, 
    -0.04967238f, -0.00597861f, 0.02210471f, -0.04168545f, 0.00320733f, -0.01264652f, 0.00961011f, -0.05166381f, 
    0.02207363f, 0.02262344f, -0.00899573f, 0.01060640f, 0.04984715f, -0.02363026f, -0.04505996f, 0.01446764f, 
    -0.00961934f, -0.04148879f, -0.04159780f, -0.01455034f, 0.02360003f, -0.04719699f, -0.05658664f, 0.02298126f, 
    0.04528051f, -0.04830031f, -0.03060044f, -0.02048972f, 0.00063827f, 0.00909982f, 0.00634655f, -0.00524468f, 
    -0.05737884f, -0.03657278f, -0.03327962f, 0.04410607f, -0.06192039f, -0.00115347f, 0.00378273f, -0.05949749f, 
    -0.05227302f, 0.00508077f, -0.00675542f, -0.05084052f, 0.00497303f, -0.01501992f, -0.06323645f, -0.00099442f, 
    -0.04033580f, -0.00117638f, -0.00238026f, -0.01298548f, 0.04494311f, -0.00301832f, -0.01492691f, 0.02216146f, 
    -0.00660566f, 0.01087036f, 0.03141139f, 0.04709381f, 0.04172554f, -0.05922391f, -0.00287428f, 0.03719081f, 
    0.01692926f, 0.03374432f, 0.03659695f, 0.03205663f, 0.02271784f, -0.00643073f, -0.04927800f, -0.03255756f, 
    0.01271013f, 0.01967153f, -0.03058338f, -0.03865599f, -0.00176888f, 0.02714101f, -0.04636365f, 0.01900068f, 
    0.00867158f, 0.00606611f, -0.03384822f, 0.04744305f, -0.01990077f, -0.03178911f, -0.03310349f, -0.01851326f, 
    -0.00844238f, -0.00203125f, -0.04724789f, -0.00231266f, -0.04573397f, -0.06015102f, 0.03063549f, 0.00691429f, 
    -0.02465259f, 0.04435248f, -0.01019755f, 0.03703715f, 0.00726539f, 0.01757221f, 0.04009547f, -0.02043108f, 
    -0.05147417f, 0.00235927f, 0.02822057f, -0.00128227f, 0.04892378f, -0.04931364f, 0.00086569f, -0.01563841f, 
    0.03206486f, 0.03936412f, -0.05804216f, -0.03995401f, -0.02308113f, -0.02731293f, -0.00191040f, -0.04226124f, 
    -0.01042971f, -0.02768750f, -0.01273998f, -0.02839098f, 0.00061420f, -0.04429420f, -0.05911707f, -0.05904726f, 
    -0.02970132f, 0.03418764f, 0.01351642f, -0.03145194f, 0.02989295f, -0.03214243f, 0.02694914f, -0.03133112f, 
    -0.01799863f, 0.04574259f, -0.00693992f, 0.03400403f, 0.04536363f, 0.04852313f, 0.04397821f, -0.01277354f, 
    0.04689329f, -0.04332278f, -0.04428625f, -0.04997486f, -0.00086227f, 0.00005918f, -0.06231702f, 0.03391200f, 
    0.01734108f, 0.04128828f, -0.05639774f, 0.00534006f, 0.04899247f, -0.03894917f, 0.04410954f, 0.01094524f, 
    -0.00225745f, -0.01536080f, 0.03161466f, 0.00411202f, -0.01082761f, -0.01756983f, 0.00825965f, 0.00679335f, 
    -0.04464437f, -0.01590465f, -0.06046744f, -0.03093432f, 0.03127855f, 0.04586016f, 0.00565554f, -0.06344531f, 
    -0.04619640f, -0.04988154f, -0.02448894f, -0.03049197f, -0.05822434f, -0.02005633f, -0.04216086f, -0.05389750f, 
    -0.05007881f, -0.04613726f, 0.03720992f, -0.01428204f, -0.00147301f, 0.00439458f, -0.05748311f, 0.04081531f, 
    -0.05752798f, 0.01131865f, 0.00253549f, 0.03544499f, -0.05611674f, 0.02931839f, -0.05857029f, 0.00281284f, 
    0.02293034f, 0.00926481f, -0.05392549f, 0.04021630f, -0.05800852f, -0.00366737f, -0.00645022f, 0.00783162f, 
    0.00168612f, -0.03482201f, 0.03339482f, 0.03032787f, -0.00256629f, 0.02685424f, -0.02460367f, -0.01406476f, 
    0.01525870f, -0.04986480f, 0.01962815f, -0.01761976f, -0.03307225f, -0.02297748f, 0.02295268f, -0.04282518f, 
    0.03923926f, -0.06191454f, -0.03766953f, 0.00316522f, -0.03747208f, 0.03513093f, -0.04942076f, 0.00642752f, 
    -0.06543256f, 0.02199511f, 0.00880351f, -0.01506957f, -0.03401541f, -0.02475773f, 0.03157506f, 0.02157573f, 
    -0.02850788f, 0.03323511f, -0.00226444f, -0.01356668f, -0.03380251f, -0.00310841f, -0.04443568f, -0.00974524f, 
    -0.00263658f, -0.03336005f, -0.04571328f, -0.02345951f, 0.04170626f, -0.04003578f, 0.02280467f, -0.04393724f, 
    0.04446865f, 0.04164969f, 0.03072234f, -0.05621571f, 0.03286770f, 0.00284976f, 0.03255166f, -0.04942806f, 
    -0.01368793f, 0.02550523f, -0.01689663f, 0.01479408f, -0.00283937f, 0.03474063f, -0.01336833f, -0.04413396f, 
    0.03991201f, 0.02249828f, -0.04086947f, -0.04417128f, -0.01078835f, 0.02149317f, -0.01830542f, -0.05264872f, 
    -0.03971737f, -0.00313100f, -0.01259953f, 0.02133169f, -0.03884942f, -0.00477459f, -0.02273648f, 0.03675951f, 
    0.02454209f, -0.06278317f, -0.00528217f, -0.00060741f, -0.06670580f, 0.00376686f, -0.05455894f, -0.00712573f, 
    -0.04116533f, 0.00314091f, -0.03446503f, 0.00789455f, 0.00244480f, -0.02123926f, 0.02080066f, 0.01656798f, 
    0.01607353f, 0.00585546f, 0.00446206f, -0.01124996f, 0.00888396f, -0.04773672f, -0.06688821f, -0.01059534f, 
    0.01957329f, -0.01762822f, -0.01402699f, 0.04125584f, -0.05571531f, -0.00420939f, 0.02276021f, -0.02420723f, 
    -0.03980957f, 0.04111092f, -0.00715836f, -0.05566285f, -0.02745897f, -0.04221751f, 0.02754518f, -0.02978566f, 
    0.03395448f, -0.05791484f, 0.03622866f, 0.02407920f, -0.06235658f, -0.03073912f, 0.04091341f, 0.03434243f, 
    0.02900840f, -0.04617850f, -0.03665033f, 0.02774518f, -0.01806941f, -0.01992678f, -0.03646345f, -0.01941533f, 
    -0.00279748f, -0.00071823f, 0.03892253f, -0.01136602f, 0.04521698f, 0.03466738f, 0.03800438f, 0.04205680f, 
    -0.04959116f, 0.02320077f, -0.02304014f, 0.00165892f, -0.03586979f, -0.03308463f, -0.02245850f, -0.05755612f, 
    -0.02860210f, 0.01562641f, 0.04571849f, 0.03962276f, 0.02460609f, -0.04963696f, 0.01811093f, -0.00362615f, 
    0.03806560f, -0.01476550f, 0.00024194f, 0.03469105f, 0.01144835f, 0.00396333f, 0.01209763f, 0.02355395f, 
    0.00834966f, 0.03501014f, 0.01045706f, 0.00011221f, -0.04635343f, -0.06096884f, 0.03571507f, -0.03383634f, 
    -0.06112491f, 0.03733365f, -0.03603254f, 0.02420377f, 0.01747548f, -0.03286161f, -0.04157199f, 0.00664781f, 
    -0.04965292f, -0.00236257f, -0.05344753f, 0.04141301f, -0.01522967f, -0.02147433f, -0.00956874f, -0.05341946f, 
    -0.06393100f, -0.05648962f, -0.05025644f, 0.00078978f, -0.00202407f, 0.02354467f, -0.03901973f, 0.03384764f, 
    0.03050541f, 0.00015534f, 0.01949780f, -0.01929791f, 0.03800207f, -0.04496027f, 0.03635892f, -0.05694113f, 
    0.03631141f, -0.02973090f, 0.03843698f, -0.05395532f, 0.02126643f, -0.03035219f, -0.05736790f, -0.04045732f, 
    -0.06258575f, -0.02285233f, -0.06321093f, -0.02841329f, -0.00977390f, -0.04144639f, -0.00767009f, -0.01520719f, 
    -0.06420322f, 0.02886066f, 0.00240478f, 0.00139832f, -0.00975617f, 0.00998855f, 0.00921886f, 0.03484091f, 
    -0.05810077f, -0.05052296f, 0.02695471f, -0.02239658f, 0.03710779f, -0.01513662f, -0.03315205f, 0.00979899f, 
    0.01174626f, 0.01770382f, -0.00190933f, 0.02485202f, 0.03934939f, 0.01592356f, 0.01631431f, -0.05401773f, 
    0.01955051f, -0.03951138f, -0.05318132f, 0.03509064f, -0.04685531f, -0.00502350f, -0.03388644f, 0.01911339f, 
    0.02735238f, 0.04440132f, 0.01433181f, -0.00589770f, 0.03755869f, 0.03580961f, -0.05914346f, -0.02073882f, 
    -0.02357312f, 0.00487062f, -0.00097708f, 0.00871630f, -0.01623884f, 0.04575050f, -0.00336517f, 0.00441370f, 
    -0.02071538f, -0.01178336f, 0.03396976f, -0.00185902f, 0.03890087f, -0.06328946f, -0.05576960f, -0.05139452f, 
    -0.04839624f, 0.00302578f, 0.03616171f, -0.04506965f, 0.01840588f, -0.01072519f, 0.00392919f, -0.02102280f, 
    -0.01997771f, 0.01446566f, -0.03884721f, 0.02327507f, 0.00429922f, -0.05077914f, -0.05871211f, -0.06608874f, 
    0.01030857f, 0.02465072f, 0.03906953f, -0.02094991f, -0.01204386f, -0.01787206f, -0.03443203f, 0.00352530f, 
    -0.04034639f, -0.05908080f, -0.05632572f, -0.00051373f, -0.05109264f, 0.01020914f, -0.03785694f, -0.06099770f, 
    0.00521517f, -0.00886996f, -0.09342252f, -0.02934295f, 0.04134049f, 0.10406683f, 0.01852165f, -0.00596117f, 
    0.01967770f, -0.00997363f, -0.00384699f, -0.00453952f, -0.07291491f, 0.01188843f, 0.01284376f, -0.08945252f, 
    0.04569362f, -0.02620845f, 0.06126005f, -0.01031384f, 0.12618911f, -0.11349146f, 0.31820732f, -0.05813101f, 
    -0.04177583f, 0.00244916f, 0.00349558f, -0.02699422f, 0.07620291f, 0.04508814f, -0.05708258f, 0.02583605f, 
    -0.09957530f, -0.05669346f, 0.06065318f, -0.01189195f, 0.00597801f, 0.11444173f, 0.04036156f, 0.04112028f, 
    0.09415334f, -0.34502292f, 0.08013457f, 0.05479582f, 0.02264932f, 0.08312667f, -0.11791504f, 0.07077606f, 
    -0.02318790f, -0.02377895f, -0.06456649f, -0.01343303f, -0.13900842f, 0.00098289f, 0.01719997f, -0.00002777f, 
    -0.09652471f, 0.08514571f, -0.00307935f, -0.00634490f, 0.43578491f, -0.04279843f, 0.05257650f, 0.12158145f, 
    -0.01626004f, -0.01621371f, 0.03338257f, 0.02782321f, 0.00895948f, -0.08338439f, -0.00068236f, 0.01187627f, 
    0.03708324f, -0.07033556f, 0.00975536f, 0.00237584f, -0.05401443f, -0.09265212f, 0.15617710f, 0.07583168f, 
    0.04399135f, -0.20786135f, -0.06013105f, -0.04100838f, -0.17811179f, -0.10136057f, 0.06502246f, 0.07502291f, 
    -0.03056993f, 0.00084587f, 0.09282276f, -0.00513090f, 0.06301833f, -0.06207375f, 0.03355523f, -0.12799011f, 
    0.03667659f, 0.00745941f, 0.02864197f, -0.03510823f, 0.08363393f, -0.04532480f, -0.01279534f, 0.23611081f, 
    0.15542723f, 0.00930143f, -0.00333817f, 0.07498609f, -0.08212041f, 0.10220815f, -0.08694720f, -0.09084971f, 
    -0.03432906f, 0.04673841f, -0.01139322f, -0.04999100f, 0.10589169f, 0.06936109f, 0.02490926f, -0.01551928f, 
    -0.31471121f, 0.10108716f, -0.09930104f, 0.08880530f, 0.07504680f, 0.00556358f, -0.07847920f, 0.00112186f, 
    0.01079087f, 0.08635168f, 0.00618714f, 0.05636155f, 0.05001060f, -0.02456187f, -0.05774261f, 0.05830557f, 
    -0.04969412f, -0.01923370f, -0.09866077f, -0.06633010f, 0.22233541f, 0.34753656f, -0.02908015f, -0.01297533f, 
    0.06428343f, -0.01792705f, -0.07315960f, 0.11152966f, 0.10011768f, -0.00844296f, -0.13352044f, 0.03963848f, 
    -0.02353444f, 0.01587670f, 0.00027943f, 0.05978994f, -0.15892410f, 0.01747130f, -0.07893365f, 0.04277808f, 
    0.14708290f, 0.02920056f, 0.36625689f, -0.02554345f, 0.16512705f, -0.08470977f, -0.08336899f, -0.02036808f, 
    -0.03649084f, -0.01008711f, 0.03500043f, -0.04176772f, 0.06592894f, 0.06170828f, 0.07728598f, 0.06020391f, 
    0.03017352f, -0.13828036f, -0.10552204f, 0.08104674f, -0.13637985f, 0.06363402f, 0.36449736f, 0.10411219f, 
    -0.17965083f, -0.13956101f, 0.02560918f, 0.03066786f, 0.00411865f, 0.07208659f, -0.07955009f, -0.02869540f, 
    0.05140693f, 0.02777649f, -0.03489002f, 0.01182390f, -0.01151821f, -0.07576024f, 0.09616821f, -0.01135881f, 
    0.03731205f, 0.04231670f, 0.03075036f, 0.09613959f, -0.09072189f, -0.01229649f, 0.07165487f, 0.01073688f, 
    -0.02092665f, -0.02329990f, -0.09535711f, -0.02403257f, -0.05740770f, -0.05808338f, -0.03710841f, 0.01627445f, 
    -0.04083231f, 0.02448532f, -0.01361106f, 0.07681943f, -0.07882524f, -0.02889434f, -0.04446260f, 0.20099762f, 
    -0.02778722f, -0.00998009f, -0.00799666f, 0.02893000f, -0.02876428f, -0.03193359f, 0.07797173f, 0.04567773f, 
    0.04656357f, 0.07595651f, 0.05463871f, 0.04392868f, -0.00103073f, -0.10545685f, 0.04847127f, -0.01496830f, 
    0.03697265f, -0.02811011f, -0.00633686f, -0.05970708f, -0.08010560f, 0.00456512f, 0.04067473f, -0.03417453f, 
    -0.03110840f, -0.03714659f, -0.06868204f, 0.01895337f, 0.00339891f, 0.08356257f, 0.02128600f, 0.07406463f, 
    0.13538378f, -0.01623480f, 0.06119103f, -0.00922836f, 0.24009754f, 0.07435176f, 0.02988048f, 0.24270256f, 
    0.16443397f, 0.09867138f, 0.03075160f, 0.13944788f, 0.01413889f, 0.10848799f, -0.10886909f, -0.00872404f, 
    -0.09667447f, -0.09936901f, 0.01774659f, 0.01134006f, -0.10940570f, -0.03091673f, -0.02007172f, -0.03467859f, 
    0.10867722f, -0.16061939f, -0.02868334f, 0.02159592f, 0.18427634f, -0.00511936f, 0.09757189f, 0.04401782f, 
    -0.03089466f, -0.01681419f, -0.04231699f, -0.01711818f, 0.03998863f, -0.03295852f, 0.03084040f, -0.00021972f, 
    -0.04270034f, 0.06994779f, -0.06524849f, -0.07362515f, 0.05627830f, 0.02372251f, -0.03772164f, -0.10812213f, 
    -0.06480786f, 0.00957667f, 0.10662266f, -0.02672402f, -0.05674741f, -0.02062574f, 0.00983932f, 0.14843623f, 
    0.11316442f, 0.05812489f, -0.07151785f, 0.04923293f, 0.05755530f, 0.00500725f, 0.01974420f, 0.06900915f, 
    0.05108576f, 0.06635670f, -0.15799057f, 0.04180187f, 0.01409708f, 0.14277714f, 0.01596304f, 0.00474547f, 
    0.15484072f, 0.04964725f, 0.00469651f, 0.02022801f, -0.10390266f, -0.08209568f, -0.02371528f, 0.09185526f, 
    0.03153585f, 0.01470621f, 0.03743688f, -0.01578627f, 0.10735557f, -0.06020937f, -0.04887863f, -0.15088366f, 
    0.00262107f, -0.05291804f, 0.05856682f, -0.07164197f, 0.02760999f, -0.00709134f, -0.00000968f, -0.00301121f, 
    0.02988062f, 0.01912520f, -0.06888539f, 0.00938233f, -0.02370279f, 0.07124796f, 0.02607667f, -0.00008748f, 
    0.05464667f, -0.17279817f, 0.00812395f, -0.11012849f, 0.10473731f, -0.05045302f, 0.08378918f, 0.07818104f, 
    -0.07486690f, -0.07303262f, -0.00076904f, -0.00088615f, 0.10239700f, 0.08928619f, 0.03165660f, 0.00613965f, 
    -0.13205208f, -0.01885757f, 0.09545350f, -0.04401639f, 0.22563183f, 0.13340630f, -0.02920689f, 0.09661569f, 
    -0.22257620f, 0.03073760f, 0.05093153f, -0.00235345f, 0.01337815f, 0.03376843f, 0.00780154f, 0.09961431f, 
    0.03494333f, 0.04764579f, -0.06728853f, 0.15711375f, -0.03053039f, -0.02774545f, 0.12790297f, -0.00679049f, 
    -0.10228404f, -0.08802908f, -0.04027484f, -0.03862633f, -0.02771948f, -0.07059903f, 0.15309341f, -0.02383257f, 
    0.09971171f, -0.00721171f, 0.07713749f, 0.02852385f, -0.00312342f, -0.08053038f, 0.00491034f, -0.01068792f, 
    0.11673433f, -0.02288700f, -0.06706893f, -0.03680911f, -0.05981521f, -0.23960187f, -0.05708297f, 0.12255518f, 
    0.10455676f, -0.02577625f, -0.06931332f, 0.06443164f, 0.09233853f, 0.06182778f, -0.02911269f, -0.02621616f, 
    -0.03274111f, 0.05363568f, 0.07640853f, -0.02894489f, 0.03476480f, 0.05361994f, 0.11470514f, 0.01000379f, 
    -0.33677563f, -0.00110396f, 0.09093326f, -0.04780326f, 0.12850729f, 0.03483165f, -0.04684880f, -0.03883532f, 
    -0.08019935f, 0.09760564f, -0.11306579f, 0.05292568f, -0.05215446f, -0.05087924f, -0.08980696f, 0.01553847f, 
    -0.01624732f, 0.06519150f, -0.11161074f, 0.01033509f, 0.11935305f, 0.16590026f, -0.16318315f, -0.20038529f, 
    -0.09723652f, 0.07892785f, 0.03583179f, 0.01887060f, 0.03540542f, 0.08043780f, -0.12128726f, 0.00147212f, 
    0.03870899f, 0.05589774f, 0.12801266f, 0.10265466f, -0.01876534f, -0.05173445f, 0.13694127f, 0.19283047f, 
    0.05154282f, -0.27790856f, 0.18593945f, -0.17372413f, 0.20900166f, -0.12378421f, -0.07972444f, 0.02125552f, 
    -0.01307658f, -0.02219623f, 0.05456442f, -0.15155503f, -0.00308011f, 0.12594168f, 0.04304723f, -0.01581806f, 
    0.02125153f, -0.00339940f, -0.01596896f, -0.05137210f, 0.39249429f, 0.20743512f, 0.23519260f, 0.07720134f, 
    -0.02204944f, -0.02906450f, -0.05035238f, 0.05791517f, 0.00767227f, 0.06766705f, -0.09856586f, -0.05092159f, 
    -0.02810796f, 0.08841010f, 0.05463608f, 0.04747226f, 0.00235103f, -0.10898464f, -0.04875626f, 0.05555158f, 
    -0.10649571f, 0.06738231f, -0.13000435f, 0.09639297f, -0.14272647f, -0.02301236f, -0.02164290f, 0.01654354f, 
    0.08643544f, -0.01316806f, -0.02621653f, 0.00596152f, -0.02183139f, -0.02210122f, 0.02981336f, 0.04992199f, 
    -0.04695274f, 0.02689845f, 0.04575165f, -0.03923876f, 0.06850013f, 0.10180568f, 0.18854374f, 0.13447046f, 
    0.07376565f, 0.09361278f, 0.04747397f, 0.04516119f, -0.02704429f, 0.14095969f, -0.02097127f, 0.04892640f, 
    0.02437620f, 0.12607047f, -0.00565679f, 0.02151919f, 0.07618108f, -0.09750523f, -0.02372224f, -0.02436027f, 
    0.13040751f, 0.07015707f, -0.19470085f, 0.05170551f, -0.15107429f, 0.14718691f, -0.05915783f, 0.02076075f, 
    -0.00634450f, 0.08296695f, -0.00032308f, 0.03037341f, 0.04888063f, 0.16897140f, -0.13366345f, 0.06030023f, 
    0.07405923f, 0.02232343f, -0.00630472f, 0.10609297f, -0.07542064f, -0.05438006f, -0.02167717f, 0.04481582f, 
    0.18172428f, 0.02031341f, -0.05242343f, 0.06048900f, 0.06210857f, 0.16466360f, -0.14099458f, -0.02068993f, 
    -0.02682357f, 0.11701600f, 0.00704351f, 0.12633802f, 0.01659086f, -0.00006748f, 0.07143000f, -0.02053286f, 
    0.17985992f, -0.32766512f, -0.00769593f, 0.04430936f, 0.15775472f, -0.01679817f, 0.01755696f, 0.04246411f, 
    0.04714482f, 0.08196149f, -0.00917499f, -0.10827526f, 0.02519098f, 0.03958621f, -0.06821620f, 0.07514121f, 
    -0.02824814f, -0.02442316f, -0.08692591f, -0.06499410f, 0.13455187f, -0.07502487f, -0.18602300f, -0.12040890f, 
    -0.26199508f, 0.13506122f, 0.12610944f, -0.03158978f, -0.01438374f, 0.09012324f, 0.11689410f, 0.10058985f, 
    0.07219325f, -0.02178782f, -0.05057168f, 0.01517048f, -0.00393697f, 0.03413635f, -0.14308156f, 0.01180246f, 
    0.01640079f, 0.09833839f, -0.01809113f, -0.02633937f, -0.13899830f, 0.03855659f, 0.07653695f, 0.05543508f, 
    0.04028152f, 0.08614211f, -0.07793003f, -0.01971611f, 0.06547728f, 0.05020903f, -0.07222081f, 0.10462799f, 
    -0.02359558f, 0.02977389f, -0.02719072f, 0.05602170f, -0.13752437f, 0.35364732f, -0.18255037f, 0.10716698f, 
    0.05221710f, 0.06960212f, 0.10644632f, 0.05780743f, -0.05621989f, 0.01272906f, -0.02677275f, -0.04000468f, 
    0.01151902f, 0.05266833f, 0.02557632f, 0.00538972f, -0.00784563f, -0.02207414f, -0.03924695f, 0.02458827f, 
    -0.56661963f, 0.44039074f, -0.15449819f, -0.08807413f, 0.08574083f, -0.02589325f, 0.07320381f, -0.06651927f, 
    0.04110071f, 0.02961190f, 0.09666178f, -0.02088198f, 0.01332910f, 0.01914802f, -0.00948631f, -0.04451662f, 
    -0.08107331f, 0.06700160f, 0.04174801f, -0.06795354f, -0.40807608f, 0.11441903f, 0.03632595f, 0.08972818f, 
    -0.08477572f, 0.03804196f, -0.01758841f, 0.01961412f, -0.04184255f, -0.07518666f, 0.00013426f, 0.07181362f, 
    -0.11406609f, -0.04896685f, -0.04409749f, 0.01379678f, -0.05464900f, 0.04229171f, -0.04907883f, -0.10370360f, 
    -0.05372247f, 0.15602507f, 0.04165304f, -0.00891926f, 0.00316867f, -0.05352842f, 0.02017944f, -0.06967358f, 
    -0.04824841f, -0.03098123f, 0.01032753f, 0.02151186f, -0.09204492f, -0.06987756f, 0.09432497f, 0.02145405f, 
    0.01744551f, 0.03714323f, 0.02789920f, -0.01491746f, 0.00916440f, 0.04095666f, -0.01330232f, 0.00650812f, 
    0.03012133f, 0.13124664f, 0.02561701f, 0.06383211f, 0.05642033f, 0.05981279f, -0.11025335f, -0.04650599f, 
    0.04192542f, 0.07477639f, 0.08592068f, 0.10321952f, 0.03493627f, -0.00155704f, 0.04453372f, 0.02525847f, 
    -0.07257722f, -0.05881586f, 0.09741936f, 0.16981107f, -0.05734705f, -0.02981446f, 0.03468978f, -0.07817006f, 
    -0.03839801f, 0.00479619f, -0.00332369f, 0.08278976f, -0.08998483f, -0.02592560f, 0.04245654f, -0.11707974f, 
    0.02507601f, 0.07531719f, -0.00005476f, 0.09024673f, -0.18784064f, -0.09108716f, -0.03896613f, 0.06344815f, 
    -0.22094360f, 0.08985382f, 0.00832950f, 0.00499407f, -0.10938162f, -0.02726509f, 0.05718185f, -0.00010493f, 
    0.02271890f, -0.06430775f, 0.10311980f, 0.01073627f, 0.03014355f, -0.11912335f, 0.14863938f, 0.08977158f, 
    0.10286207f, -0.11540730f, -0.13737552f, -0.00025252f, 0.14007880f, -0.04154098f, -0.02433143f, -0.07611666f, 
    -0.00877871f, 0.06944201f, 0.04826853f, -0.00964883f, -0.04386929f, -0.00391583f, -0.06035721f, -0.00111811f, 
    -0.03746349f, -0.03551646f, 0.16551964f, -0.07834802f, 0.36215949f, 0.07699654f, -0.06704233f, 0.14334759f, 
    0.30542144f, 0.17231266f, -0.07879937f, -0.03951718f, 0.04821911f, 0.02384511f, 0.15068695f, 0.00615842f, 
    -0.00140971f, 0.21681958f, 0.05448867f, 0.05086190f, 0.03625892f, -0.02680197f, -0.01420072f, -0.03210267f, 
    -0.15564543f, 0.20349941f, 0.04581513f, 0.00198923f, -0.20302173f, 0.05018206f, -0.05970402f, 0.01280233f, 
    0.10683700f, -0.10586394f, -0.03567562f, 0.03133145f, 0.00962809f, 0.04594449f, 0.02389185f, 0.00954012f, 
    -0.01238868f, 0.08193911f, -0.06816093f, 0.03955485f, -0.02472087f, 0.07557033f, 0.10589224f, 0.11478524f, 
    -0.01220916f, -0.12912799f, 0.04133700f, -0.00911251f, 0.04656168f, 0.06318784f, -0.08871516f, -0.01330504f, 
    0.03421453f, -0.04339601f, 0.05414774f, 0.00172337f, 0.01449459f, 0.12577605f, -0.00386702f, 0.05650954f, 
    -0.09423693f, 0.17140676f, -0.14355960f, 0.00658796f, -0.27578819f, -0.15125203f, -0.00812062f, 0.06773832f, 
    0.07216712f, -0.00213633f, -0.08152379f, 0.01628421f, 0.02033282f, -0.00059464f, -0.05310559f, 0.08652920f, 
    -0.04539254f, -0.01133096f, -0.01032405f, 0.03434648f, 0.05730953f, 0.17377253f, -0.01655325f, -0.19065551f, 
    0.00794191f, 0.06682276f, -0.00975164f, -0.01003999f, -0.08256572f, 0.11785465f, -0.06366721f, -0.02341638f, 
    0.15337110f, -0.00870505f, -0.04432575f, -0.00679312f, 0.03473770f, -0.04758592f, -0.01950745f, -0.07254401f, 
    0.04546708f, -0.16324580f, 0.00810294f, -0.00536675f, 0.02815898f, 0.00305926f, -0.09765178f, 0.05527661f, 
    0.15302424f, 0.12328310f, 0.03219514f, 0.06360253f, 0.03140277f, 0.05980602f, -0.01015074f, 0.08266202f, 
    0.00824503f, -0.02236589f, -0.03218791f, 0.04404472f, 0.08082757f, -0.01214055f, -0.26850680f, -0.08127028f, 
    -0.16643840f, 0.03100247f, 0.05676146f, 0.05024612f, -0.01059248f, 0.01937249f, -0.04358339f, 0.05048767f, 
    0.02507721f, -0.06472706f, 0.11748853f, 0.07616073f, 0.08109478f, -0.07029258f, -0.01582711f, 0.00299789f, 
    0.05012944f, 0.05617598f, -0.01269374f, 0.04719813f, -0.11831475f, 0.10161287f, -0.00615775f, 0.02845237f, 
    0.09655543f, -0.01946050f, -0.00564438f, 0.04118071f, -0.00533281f, 0.03789143f, -0.05402381f, 0.09958020f, 
    0.02175480f, -0.01348234f, -0.06843356f, 0.11043869f, -0.08988463f, 0.00869437f, -0.09769106f, -0.01622369f, 
    0.12651658f, -0.01302862f, 0.09158356f, 0.01208669f, -0.00153368f, 0.04444748f, 0.06337845f, 0.04297663f, 
    0.00409712f, 0.02206376f, -0.03679478f, 0.06666094f, -0.03277619f, 0.02009897f, -0.15898696f, 0.06875362f, 
    -0.40433860f, 0.06327113f, -0.05262805f, -0.04835622f, 0.05477365f, -0.02529520f, 0.06062182f, -0.14192699f, 
    -0.11953906f, -0.09620246f, 0.02391735f, -0.05921378f, 0.01134269f, 0.02957330f, 0.06949668f, 0.01724618f, 
    -0.05420956f, 0.06010436f, 0.00399238f, 0.01279693f, -0.15067169f, -0.00615623f, 0.05523679f, 0.13192676f, 
    -0.03926945f, -0.11082283f, -0.06635272f, -0.07879473f, -0.06738700f, -0.03681707f, 0.09392019f, 0.06313173f, 
    -0.12130253f, -0.01187197f, -0.08484269f, -0.04518086f, -0.08153283f, 0.07804705f, -0.09471469f, -0.05446493f, 
    -0.13305411f, 0.08127845f, 0.01099343f, 0.00199715f, -0.03443439f, 0.05835022f, -0.04704483f, -0.03334932f, 
    0.00251470f, 0.00900608f, 0.00124817f, -0.02747543f, -0.10043400f, -0.01541397f, 0.00609495f, 0.05896712f, 
    0.15963797f, 0.12344659f, -0.01450268f, 0.03731326f, 0.03709801f, 0.07825400f, 0.04778935f, 0.04606824f, 
    -0.02895843f, 0.07767550f, -0.04753706f, 0.06813065f, 0.17192303f, 0.04083917f, -0.08999690f, 0.05233756f, 
    0.12271130f, 0.08053742f, 0.01014743f, 0.05661061f, 0.04305372f, -0.09888349f, -0.08026663f, 0.07568611f, 
    -0.33786917f, -0.06575459f, 0.06192308f, 0.09392846f, -0.01079308f, 0.03628231f, 0.02812204f, -0.12782612f, 
    0.03429900f, 0.06436075f, 0.07800052f, 0.10118335f, -0.09770226f, -0.00288991f, -0.01581678f, -0.10390688f, 
    0.09293060f, 0.05728895f, 0.08474583f, 0.05683987f, -0.04540995f, 0.15769054f, 0.07632070f, 0.10314154f, 
    -0.19287236f, 0.08973581f, 0.04545784f, 0.01894130f, -0.08409601f, 0.10251402f, 0.06470235f, 0.05290534f, 
    0.07134129f, -0.07797151f, 0.08467295f, 0.02967051f, -0.02294295f, -0.15966451f, 0.09684368f, -0.07064737f, 
    -0.18721439f, -0.18664505f, -0.04390325f, -0.15182911f, 0.21284825f, -0.00584858f, 0.04832837f, -0.08164148f, 
    0.07361235f, 0.03418531f, 0.03304335f, -0.01707765f, -0.12092880f, -0.03501178f, -0.02132681f, -0.03977606f, 
    0.00432980f, -0.04906348f, 0.15156132f, 0.01132556f, 0.14446838f, -0.12125345f, 0.00797374f, 0.04479269f, 
    0.02848137f, 0.05760667f, -0.11252503f, -0.05610228f, 0.05231776f, 0.02359949f, -0.00924341f, -0.05756989f, 
    0.05260049f, 0.21303606f, -0.00643492f, 0.03890197f, 0.04153203f, 0.01502782f, -0.09945476f, 0.00659346f, 
    -0.07535711f, 0.05446564f, 0.08698861f, -0.00775858f, -0.07425019f, 0.03994666f, -0.05310468f, -0.07564590f, 
    0.15327530f, -0.03516228f, -0.05790680f, 0.04351277f, -0.01185027f, 0.13488467f, 0.07750095f, 0.00020009f, 
    -0.00955861f, 0.00355205f, -0.18704076f, 0.00230495f, 0.17919850f, 0.05789614f, 0.06473305f, 0.08206102f, 
    0.01101232f, -0.04859487f, 0.01614931f, -0.08467377f, -0.09038622f, 0.03531533f, 0.02188471f, -0.00535020f, 
    0.02056812f, -0.07527266f, -0.03907186f, 0.00438156f, 0.07392715f, 0.20626405f, 0.09082262f, 0.03768760f, 
    0.04597709f, 0.04679214f, -0.03151308f, 0.15475859f, -0.17613253f, -0.01097523f, -0.01988138f, 0.17820051f, 
    -0.06009774f, -0.03119926f, -0.08828624f, -0.05510733f, -0.00491446f, -0.15035160f, -0.03437598f, 0.03657547f, 
    -0.04145278f, 0.01704845f, -0.01510800f, 0.06622893f, 0.08497183f, 0.19633409f, 0.13137871f, -0.11419186f, 
    -0.01496941f, 0.06759897f, 0.02002316f, 0.07929790f, -0.05427878f, 0.12314905f, -0.08320370f, -0.06372128f, 
    0.12550353f, 0.09872614f, -0.07742061f, -0.05048599f, 0.10485432f, -0.08322275f, -0.19312684f, -0.06104444f, 
    -0.00732067f, -0.16619323f, 0.14370827f, 0.06340876f, 0.06784366f, -0.07234762f, 0.02031814f, 0.06091347f, 
    0.05184836f, 0.12958899f, 0.13357200f, -0.02275708f, -0.06114325f, 0.11981776f, -0.00783560f, 0.05943533f, 
    -0.01456559f, -0.09419406f, -0.01162982f, 0.06034497f, 0.36325222f, 0.08664245f, -0.16245860f, 0.00056132f, 
    -0.14630926f, -0.03408206f, 0.04185006f, 0.01034646f, -0.01011940f, -0.04676660f, 0.01560877f, 0.07386769f, 
    -0.07839316f, -0.09353000f, -0.00589554f, 0.04387241f, -0.00500456f, -0.07398809f, 0.00333631f, -0.06444235f, 
    0.03536369f, 0.08497161f, 0.10169623f, 0.08245561f, 0.15042478f, 0.18640338f, 0.04767284f, 0.01370156f, 
    0.08487837f, -0.01325350f, 0.03328657f, 0.05078208f, 0.02023630f, 0.00566266f, -0.06165309f, 0.01147990f, 
    -0.06025169f, 0.05657565f, -0.11953098f, 0.01675924f, -0.35439575f, -0.00916025f, -0.04289454f, 0.09578064f, 
    0.10474222f, -0.11793867f, -0.09413718f, -0.06275799f, 0.01916050f, 0.15574221f, 0.14126655f, -0.01311863f, 
    0.14116953f, 0.11940128f, -0.00766174f, 0.01404635f, -0.02150074f, -0.10574870f, -0.09571800f, -0.00330474f, 
    -0.18806846f, 0.00416454f, 0.09334058f, 0.01045082f, 0.16556866f, 0.07111622f, 0.02152208f, -0.12652248f, 
    -0.03599009f, 0.07099944f, -0.04846508f, -0.04542530f, 0.00430332f, 0.00477418f, 0.06591743f, 0.10635730f, 
    0.05021162f, -0.06648090f, 0.01673346f, 0.09200554f, -0.28811333f, -0.03115815f, 0.12559833f, -0.08057196f, 
    0.01586653f, -0.03452218f, -0.00783148f, -0.01631867f, -0.01545542f, 0.03179563f, 0.07100099f, -0.03201511f, 
    -0.00357138f, -0.04700246f, -0.05901290f, 0.05394752f, -0.05287295f, 0.13415326f, -0.15622121f, 0.06122075f, 
    -0.17397693f, 0.20060736f, -0.13077731f, 0.12372674f, 0.07778300f, 0.20558971f, 0.00007131f, -0.00584538f, 
    0.00742468f, 0.01249210f, -0.15666617f, 0.12645727f, -0.02887945f, -0.01988122f, 0.00301459f, 0.02499650f, 
    0.06495392f, 0.02773954f, -0.00144561f, 0.04089892f, -0.28758284f, 0.05936835f, -0.03030352f, 0.10817939f, 
    -0.06543653f, 0.01578792f, 0.00890420f, 0.05831753f, 0.17687345f, -0.07766856f, -0.02395488f, 0.11374617f, 
    0.05658133f, 0.08468955f, 0.11202598f, 0.03595863f, -0.04711210f, -0.10280090f, -0.09341408f, 0.06508230f, 
    -0.17462726f, 0.21722141f, 0.03048743f, -0.10842269f, 0.01228013f, 0.09145264f, -0.01581208f, 0.05331441f, 
    0.00878648f, 0.01854054f, -0.05685120f, -0.02737875f, -0.02337469f, -0.01652897f, 0.13236149f, -0.04841965f, 
    0.06651092f, -0.16057907f, 0.02986365f, -0.04473330f, -0.03179948f, 0.15316616f, 0.14775114f, 0.17870592f, 
    -0.12590550f, 0.08376047f, -0.01086572f, -0.01611878f, -0.04491765f, -0.01493513f, 0.07775843f, 0.09191719f, 
    0.04040202f, 0.00450181f, -0.05129908f, -0.04814959f, -0.04936567f, -0.07349535f, 0.12983999f, -0.14083400f, 
    0.00366384f, 0.12913246f, -0.09075195f, -0.18765689f, 0.04977791f, -0.07273766f, 0.08231211f, -0.16889153f, 
    0.05738196f, -0.08304740f, 0.00186057f, 0.06091890f, 0.04153981f, -0.08998787f, 0.13920946f, -0.08302517f, 
    0.12199517f, -0.12804869f, 0.12988070f, 0.05483526f, 0.29071650f, -0.29889399f, -0.10135242f, 0.07664946f, 
    0.17156875f, -0.03989645f, -0.06863637f, -0.13388662f, -0.03218657f, -0.05667106f, 0.11170696f, 0.05635120f, 
    -0.00765766f, 0.06278012f, 0.15541846f, 0.01318862f, -0.01204590f, 0.05668253f, 0.00026434f, 0.00805997f, 
    -0.17634591f, -0.09567919f, 0.17454517f, -0.13500862f, 0.22141165f, 0.05960601f, -0.06798826f, 0.04037032f, 
    0.05817280f, 0.03511385f, -0.01266457f, 0.08881260f, -0.04691581f, 0.02457674f, -0.03313240f, 0.04167443f, 
    0.05170256f, -0.01409373f, -0.06152654f, 0.04256018f, 0.15701370f, 0.01020293f, 0.08425773f, -0.09556328f, 
    0.05441306f, 0.03295048f, -0.00740909f, -0.03921629f, -0.01853648f, -0.02836381f, 0.01672780f, -0.03345144f, 
    -0.02563714f, -0.06294975f, 0.00996178f, 0.02735628f, 0.04016420f, 0.08138771f, 0.08725579f, 0.07906085f, 
    -0.20110434f, 0.12860650f, 0.06116940f, 0.09938186f, -0.00292632f, 0.11152444f, 0.09693830f, 0.07077256f, 
    0.00502298f, 0.13374098f, -0.02152297f, -0.04229829f, 0.09891260f, -0.07071380f, 0.05337105f, 0.08994223f, 
    -0.17731188f, -0.00680846f, -0.03756468f, -0.00541502f, 0.09885736f, 0.11396562f, 0.23561190f, 0.21891384f, 
    0.05690895f, -0.00647218f, 0.06498241f, 0.09327022f, 0.05480806f, 0.01376498f, 0.05141639f, 0.06454055f, 
    0.08928234f, 0.00699140f, -0.00996053f, -0.06431958f, 0.06402263f, -0.02211843f, -0.12115591f, 0.08624829f, 
    -0.19296709f, 0.33965957f, -0.08977556f, 0.16640112f, -0.09435359f, 0.06892040f, -0.04163140f, 0.05564482f, 
    0.06595596f, 0.06309072f, 0.08732953f, 0.12612405f, -0.03071961f, 0.03124699f, -0.02117740f, -0.05420544f, 
    0.01750667f, -0.01045782f, -0.11288390f, -0.03893439f, -0.27629575f, 0.13966951f, -0.04038032f, 0.22405453f, 
    -0.05191374f, 0.13513370f, -0.04226424f, 0.05210177f, -0.04309551f, 0.12174845f, -0.05856591f, 0.03707805f, 
    -0.00102762f, -0.08427773f, 0.02060136f, -0.01051259f, 0.02157533f, -0.04264949f, 0.15391947f, -0.09935095f, 
    -0.18911597f, -0.03562112f, 0.10256959f, -0.13051347f, 0.05762615f, -0.02731357f, -0.07931258f, 0.09439425f, 
    -0.17466056f, -0.08452343f, -0.01317364f, 0.01030642f, 0.02940318f, 0.10470926f, -0.03862906f, -0.06369143f, 
    -0.04685219f, -0.09162477f, -0.00178875f, 0.10022331f, 0.38642243f, -0.38795662f, 0.14678466f, -0.02953558f, 
    -0.08546051f, 0.04562880f, -0.02508041f, -0.03459445f, 0.01854079f, -0.01745521f, 0.00941392f, 0.12004623f, 
    -0.01396140f, 0.17891949f, 0.15972179f, -0.04011228f, 0.16816466f, 0.03002731f, 0.17498070f, -0.00087976f, 
    0.31725734f, -0.24098356f, 0.16107950f, 0.39124736f, -0.11108471f, 0.17448276f, -0.07115808f, -0.06494578f, 
    -0.00716463f, 0.11332011f, 0.00440176f, 0.08932368f, 0.03453561f, 0.07295737f, -0.10829030f, 0.00246953f, 
    0.08296035f, -0.11260693f, 0.01163872f, 0.04804994f, 0.11081512f, 0.08258943f, -0.12837461f, -0.12497404f, 
    0.23983827f, 0.10414339f, -0.04390229f, -0.00987992f, 0.03615171f, 0.09872738f, -0.08914841f, -0.06776369f, 
    0.15982336f, 0.16327240f, 0.08173719f, 0.09716325f, 0.02848073f, 0.02770332f, 0.03131609f, -0.02739545f, 
    0.23874784f, -0.05151971f, -0.04558326f, -0.00024798f, 0.03534640f, -0.10923499f, -0.06319910f, 0.00835507f, 
    0.07433225f, 0.16276057f, 0.10111171f, -0.00544759f, 0.13768701f, 0.06794770f, 0.06504627f, -0.06060417f, 
    -0.08592471f, 0.03524445f, -0.16422807f, -0.05982970f, -0.19825505f, 0.26174909f, -0.10783090f, -0.43103430f, 
    0.01250857f, -0.06072067f, -0.13507488f, -0.02458281f, -0.04596999f, 0.01661090f, 0.02813417f, 0.02898262f, 
    -0.02290841f, -0.03376962f, -0.04151752f, -0.02043746f, -0.02907678f, 0.07655220f, 0.04446722f, 0.07586056f, 
    0.30622649f, -0.12976149f, 0.17462198f, 0.20001495f, 0.02182926f, 0.02867603f, 0.10276220f, -0.00857260f, 
    -0.02614162f, -0.08219497f, 0.02968413f, -0.06475927f, 0.03687868f, 0.12231074f, 0.09727828f, 0.06533100f, 
    0.04532455f, -0.00212790f, -0.05090508f, -0.14617625f, -0.11860012f, -0.07233290f, 0.08896845f, -0.12524411f, 
    0.37030721f, -0.07681124f, -0.08121916f, -0.02368709f, 0.15727872f, 0.11066653f, 0.02616835f, 0.06034866f, 
    0.04441341f, 0.09231482f, -0.04868759f, 0.04360586f, 0.04854122f, 0.12946451f, -0.03028920f, -0.05919252f, 
    -0.20695786f, 0.69180340f, 0.05774564f, 0.22987247f, -0.24064946f, 0.23084022f, 0.12441672f, -0.08384787f, 
    -0.04067713f, 0.08768111f, 0.05117664f, 0.10528809f, 0.15308061f, -0.01816422f, -0.04575495f, 0.16894467f, 
    0.02575205f, -0.01734164f, 0.02507518f, 0.08356114f, -0.10355484f, 0.24210669f, -0.08298068f, -0.05323120f, 
    0.00422770f, 0.08412493f, 0.16132890f, 0.00217985f, -0.09172589f, -0.08032858f, -0.04060831f, -0.07274812f, 
    -0.00058462f, -0.07123360f, 0.00699967f, 0.01679567f, 0.03123110f, 0.05131279f, -0.06851331f, -0.01641366f, 
    0.11343883f, -0.08372129f, 0.02455325f, -0.07612797f, 0.16207488f, 0.00251084f, 0.06845655f, 0.01836319f, 
    -0.10624973f, 0.02118441f, 0.10294714f, 0.02175841f, 0.19687174f, 0.06303783f, 0.11579857f, 0.04280467f, 
    0.04887470f, -0.00377963f, -0.01651476f, 0.12675679f, 0.23907284f, 0.10597773f, -0.06945822f, 0.01525185f, 
    -0.02199768f, 0.14825979f, 0.15107435f, -0.08940938f, -0.08073994f, -0.12258679f, 0.06822976f, 0.05106279f, 
    -0.03894100f, 0.03898868f, 0.07876603f, 0.00230704f, -0.01545242f, -0.05735917f, -0.10708363f, -0.09393965f, 
    -0.04656949f, -0.20420347f, 0.25756413f, -0.18778378f, 0.17804880f, 0.06482080f, 0.04224611f, 0.00716625f, 
    0.04475787f, -0.05665128f, 0.05419820f, 0.02267438f, -0.00341303f, -0.00328611f, 0.00087057f, 0.03447485f, 
    -0.01991850f, -0.07896230f, -0.07861201f, -0.09849175f, -0.24952696f, -0.09361946f, -0.06775047f, -0.15854484f, 
    0.09195845f, -0.01055082f, -0.10501524f, -0.05931852f, -0.00766208f, 0.01729045f, 0.14948106f, 0.10044033f, 
    0.01821619f, -0.01144289f, 0.09603894f, 0.11750534f, -0.05257967f, 0.09431457f, 0.09339648f, 0.12571140f, 
    -0.14690568f, 0.29002857f, 0.07540482f, -0.14158778f, 0.03069339f, 0.04073161f, -0.01005980f, 0.02426546f, 
    -0.09874529f, -0.05642086f, -0.01496142f, 0.08843874f, 0.00848986f, -0.05063843f, -0.06349944f, -0.08827002f, 
    0.05570104f, 0.00291971f, 0.15451460f, 0.17684874f, -0.10186215f, 0.06853102f, 0.19249678f, -0.18523142f, 
    0.16201596f, 0.07668796f, 0.00872538f, 0.02044624f, 0.08651853f, 0.00487065f, 0.08089940f, -0.14655426f, 
    0.05948440f, 0.02848818f, 0.00942856f, -0.03714354f, -0.00796162f, -0.05006487f, 0.01143914f, 0.00967649f, 
    0.01279411f, -0.03305876f, 0.02769527f, 0.03711194f, -0.05381115f, -0.00147288f, -0.00744437f, 0.04272870f, 
    0.01292042f, 0.02755735f, -0.03177358f, 0.00508695f, -0.03068882f, -0.00326709f, -0.02432197f, -0.04472429f, 
    -0.06065181f, -0.02023382f, 0.00200310f, -0.01257275f, -0.01675573f, -0.03024797f, 0.01206065f, -0.04884680f, 
    0.00716653f, -0.01475666f, -0.00556132f, -0.03005660f, -0.02922433f, 0.02650530f, 0.04905744f, -0.01365798f, 
    0.03747448f, -0.04520161f, 0.03872971f, -0.02234555f, 0.03884625f, -0.02351905f, -0.05418450f, -0.02369054f, 
    -0.03743477f, -0.04242374f, -0.01705361f, 0.01199376f, -0.01287779f, -0.01516006f, -0.03085032f, -0.06022708f, 
    -0.01472647f, -0.04025999f, -0.01330977f, -0.06102712f, -0.03090450f, -0.04374833f, -0.05098719f, -0.01410948f, 
    0.00338010f, -0.02090337f, 0.01255918f, 0.04864733f, 0.03942623f, 0.03711558f, -0.05351557f, -0.02769933f, 
    -0.03799897f, -0.00304419f, -0.04244474f, -0.02566486f, -0.05397275f, 0.00665051f, 0.03566878f, -0.00015858f, 
    0.00505236f, -0.02022023f, -0.00605248f, 0.01565005f, -0.05996799f, -0.05330052f, 0.00068003f, 0.04287438f, 
    -0.02424921f, -0.03038559f, -0.01972985f, -0.03179570f, 0.01647629f, -0.04343045f, -0.04030204f, 0.03300970f, 
    0.03123821f, 0.01226646f, -0.03751522f, 0.00787735f, 0.05087636f, -0.05885917f, -0.02237614f, -0.00046454f, 
    -0.03225612f, 0.01476306f, 0.00843296f, 0.04150181f, -0.03344624f, 0.01908109f, -0.02464030f, -0.04710441f, 
    -0.03883328f, 0.00634867f, -0.03118960f, -0.01575341f, 0.00554803f, -0.05108572f, 0.04533730f, 0.02494914f, 
    -0.00279774f, -0.00457802f, 0.03693188f, -0.05452054f, -0.02627355f, -0.01890446f, -0.01457498f, 0.03719171f, 
    0.00602200f, -0.05523418f, 0.00349908f, 0.01969943f, -0.05078273f, 0.00489837f, 0.00458626f, 0.00732814f, 
    0.00296540f, -0.01945096f, -0.06050413f, 0.04198796f, 0.01216678f, 0.03358207f, 0.00746504f, 0.01371517f, 
    0.01240325f, -0.04255040f, 0.04019947f, -0.05894408f, 0.04457814f, -0.00467924f, 0.03531742f, -0.04039318f, 
    -0.04370441f, -0.03011388f, -0.01603798f, -0.02413523f, -0.02074783f, -0.02068840f, -0.00990163f, 0.02393924f, 
    0.01591212f, -0.05271142f, -0.03845403f, -0.02840434f, -0.00437332f, -0.04752766f, -0.05993598f, 0.01663015f, 
    0.00372113f, 0.03109251f, 0.00378290f, -0.01200068f, -0.05738869f, -0.03537674f, 0.00049238f, -0.03683646f, 
    -0.00866547f, -0.03559713f, -0.01970640f, 0.00623108f, -0.05598908f, 0.01870220f, -0.00359203f, 0.04079250f, 
    0.04250797f, -0.05051478f, -0.03003389f, -0.04711579f, -0.02302998f, 0.04293225f, -0.01461490f, -0.04660122f, 
    0.01505941f, -0.01966399f, 0.02450949f, 0.04018869f, 0.04934987f, -0.01819139f, -0.02534148f, 0.02680164f, 
    0.00339017f, 0.00232194f, 0.05452981f, 0.01561546f, -0.01918800f, 0.00074907f, 0.00310857f, 0.02123610f, 
    0.04611854f, -0.00899333f, -0.05911430f, 0.02115950f, -0.01356348f, 0.00310621f, 0.03970387f, -0.00611752f, 
    -0.02583396f, 0.02524731f, -0.04215683f, -0.04651161f, -0.03139662f, -0.00359724f, -0.01734505f, -0.01405320f, 
    -0.06084396f, 0.03246791f, -0.04261367f, 0.03667694f, 0.02776518f, -0.02193681f, 0.00235661f, -0.04886583f, 
    -0.01285658f, 0.04780783f, -0.00534533f, -0.01130414f, 0.01577292f, -0.02252145f, -0.05138417f, 0.00504135f, 
    -0.02631024f, -0.05007386f, -0.01803708f, 0.04223862f, 0.01087189f, 0.03479975f, -0.00741374f, -0.05860769f, 
    -0.04818337f, -0.01836666f, -0.05677139f, -0.01572894f, -0.00882892f, 0.03533388f, 0.04402285f, -0.05754820f, 
    -0.05897086f, -0.02953094f, -0.00491218f, 0.00398233f, 0.03479585f, 0.03773575f, -0.01977108f, 0.04613797f, 
    0.03042089f, 0.03304685f, 0.03511359f, 0.02982991f, 0.01374387f, 0.00154979f, -0.00577235f, -0.03398155f, 
    -0.02624672f, -0.02718105f, -0.04634147f, -0.02381330f, -0.01119129f, -0.01800481f, 0.04875012f, 0.03743922f, 
    -0.00853068f, -0.04065734f, -0.05188380f, -0.05796563f, -0.04625525f, 0.02881425f, 0.04784290f, -0.04065685f, 
    -0.03319788f, 0.05339964f, 0.04816752f, -0.05528447f, -0.05962304f, 0.01785473f, 0.03919639f, -0.04493654f, 
    0.00337781f, 0.03082092f, 0.02727478f, 0.05524362f, -0.04706220f, 0.02323367f, 0.02478685f, -0.03843271f, 
    -0.04844816f, -0.04151275f, 0.02932444f, -0.03118624f, 0.01909631f, -0.04001661f, -0.04979294f, -0.05106366f, 
    -0.04954923f, -0.01305769f, -0.02854639f, 0.03907532f, -0.05693187f, -0.00616503f, -0.06108490f, -0.03105234f, 
    0.04700416f, -0.00941677f, 0.03751601f, 0.04541748f, -0.00469919f, -0.02320871f, -0.03586309f, -0.05338520f, 
    0.02433053f, -0.04514398f, 0.00413549f, 0.04282292f, 0.00638495f, -0.04576513f, -0.05533149f, -0.05504152f, 
    -0.01762982f, -0.02211099f, -0.04716487f, -0.03614522f, 0.03878564f, -0.04533412f, -0.00263214f, 0.02414303f, 
    0.00387608f, 0.03755553f, -0.00606183f, -0.03485361f, -0.01822951f, 0.02004840f, -0.02001941f, 0.05176810f, 
    -0.00266661f, -0.02637142f, 0.03525436f, -0.00875749f, 0.04383064f, 0.02045555f, 0.01096943f, -0.04405762f, 
    -0.00340051f, -0.04168367f, 0.02101336f, 0.01136050f, 0.00071392f, -0.00135042f, 0.01821311f, -0.00888569f, 
    -0.00935548f, 0.00468185f, 0.04802456f, 0.00029460f, 0.01524136f, -0.02904551f, 0.01990177f, -0.05809812f, 
    -0.05721663f, -0.05035154f, 0.00600352f, -0.03680156f, -0.01896452f, 0.00146604f, -0.05162067f, -0.02592566f, 
    -0.00834504f, -0.03586923f, -0.05149692f, -0.03439353f, -0.01178985f, 0.01919083f, -0.03639324f, -0.02861072f, 
    0.03363666f, -0.00977801f, 0.02177111f, -0.00571677f, 0.01478209f, -0.03156554f, 0.04045701f, 0.03412902f, 
    0.02278370f, -0.00098838f, -0.04133698f, -0.00696133f, -0.02817115f, 0.02650248f, 0.00716577f, 0.02491684f, 
    0.00780533f, 0.01972317f, -0.04518688f, 0.03792885f, 0.03054462f, 0.04023609f, -0.03706067f, 0.00577369f, 
    0.03170998f, 0.03032661f, -0.04597086f, -0.01139046f, 0.04169727f, -0.03712338f, -0.00639228f, -0.03570604f, 
    -0.04600260f, 0.02732971f, 0.00018319f, -0.04755944f, -0.04291264f, 0.01729175f, 0.00770250f, -0.01212774f, 
    -0.05731921f, -0.05052308f, -0.04864420f, -0.03998725f, -0.06129435f, -0.01507137f, 0.03521397f, 0.01662049f, 
    0.02292063f, 0.04984680f, -0.04836319f, 0.01727217f, 0.02914805f, 0.00985053f, -0.02520931f, -0.03185545f, 
    -0.00558098f, 0.00569139f, -0.02833036f, -0.03382435f, 0.03842986f, -0.00823601f, 0.02709680f, -0.01556376f, 
    -0.01044383f, 0.00597997f, -0.01534049f, 0.04669442f, 0.03362147f, 0.02439394f, -0.02401732f, 0.03677268f, 
    0.03975370f, -0.03210811f, -0.06188419f, 0.04707981f, 0.00795036f, -0.01485684f, -0.01627523f, 0.00515335f, 
    0.02258068f, 0.02408287f, 0.00383006f, -0.03712981f, -0.02787318f, 0.00023049f, 0.00014361f, 0.00260604f, 
    -0.02164977f, -0.04139121f, 0.01659961f, -0.03492687f, 0.05497403f, -0.04152901f, 0.03951110f, 0.00114963f, 
    0.05389732f, 0.01283427f, -0.05377794f, 0.00872551f, 0.01586633f, 0.04058388f, -0.00131441f, 0.01749764f, 
    0.02198331f, -0.03098799f, -0.02751895f, -0.02305507f, 0.00528703f, -0.03179655f, 0.02869690f, 0.04278674f, 
    0.00658785f, 0.03171221f, -0.00735799f, -0.02060367f, -0.02148998f, 0.05392605f, -0.00485665f, 0.02653884f, 
    0.00110466f, -0.01372970f, -0.03891043f, 0.03830226f, 0.04387128f, -0.01032438f, -0.03499671f, -0.02501626f, 
    0.04272679f, -0.05610348f, 0.02968941f, 0.00624937f, -0.01896328f, 0.01868957f, 0.00885834f, -0.06535633f, 
    -0.05511119f, -0.03654657f, -0.02328733f, 0.05030261f, -0.03229726f, -0.04249408f, -0.00871693f, 0.04550996f, 
    0.03047934f, 0.03974053f, 0.01847154f, 0.04367069f, 0.04025725f, -0.00301274f, -0.04119567f, -0.01858161f, 
    -0.01794303f, 0.00247676f, -0.03786521f, 0.01693402f, -0.02547809f, 0.04367173f, 0.05540024f, 0.00575733f, 
    -0.01143797f, -0.05004258f, -0.04640488f, -0.04951246f, -0.04504042f, -0.00875474f, 0.01101980f, -0.02144517f, 
    -0.01180622f, -0.04784280f, -0.00558594f, -0.01407928f, -0.04547128f, -0.05353782f, -0.04836689f, -0.04969038f, 
    0.02355144f, -0.02506020f, 0.01115973f, 0.00730763f, -0.02508762f, -0.00835761f, -0.04441268f, 0.00992744f, 
    -0.06340620f, -0.03960142f, -0.04414943f, -0.04317525f, -0.02835016f, -0.00433860f, -0.00688731f, 0.02623727f, 
    0.03211401f, -0.06133077f, 0.03203955f, 0.02241298f, -0.05298705f, -0.01892969f, 0.04433292f, -0.01362961f, 
    -0.03301602f, 0.00778925f, -0.01938168f, -0.03495415f, 0.03484778f, -0.02209601f, -0.00478420f, -0.01446648f, 
    -0.02923196f, -0.04237433f, -0.00498929f, -0.05781772f, -0.05228893f, -0.00187443f, 0.04137745f, 0.00838330f, 
    0.00022148f, 0.00004900f, -0.05947127f, -0.00007881f, -0.01440336f, -0.02822494f, -0.02594713f, -0.02661835f, 
    -0.04489284f, 0.03508350f, -0.04005010f, 0.03515786f, 0.03138002f, 0.00914824f, -0.03743869f, -0.03608458f, 
    0.01429514f, 0.03861190f, 0.00848933f, -0.02399477f, -0.05679404f, -0.01903703f, 0.00302032f, 0.02833820f, 
    0.04515995f, -0.02554118f, -0.01826123f, -0.00035590f, -0.02097328f, -0.02366382f, -0.00169410f, 0.03395568f, 
    0.02297694f, 0.02048884f, -0.00806546f, 0.03482073f, 0.02300677f, 0.02387680f, -0.04289138f, -0.00331460f, 
    0.22710957f, 0.06076251f, -0.02592387f, 0.17749751f, 0.04135404f, -0.02292171f, 0.00130166f, -0.08975805f, 
    -0.04512301f, 0.09931137f, -0.03124696f, 0.04904916f, 0.02573895f, -0.12445392f, 0.06573007f, -0.00387301f, 
    -0.05358618f, -0.02426445f, 0.11039152f, -0.00305622f, 0.24624106f, -0.23432280f, 0.02541680f, -0.17103848f, 
    0.23538916f, -0.09523360f, 0.02896929f, -0.01358689f, 0.10545730f, -0.07459696f, -0.06197465f, -0.04643662f, 
    0.04598970f, 0.06832315f, -0.16421317f, -0.00631107f, 0.03339205f, 0.03599939f, 0.08221500f, 0.05850491f, 
    0.08611397f, -0.38660744f, -0.08023330f, -0.13414703f, -0.20315655f, 0.03441373f, 0.03514137f, -0.03874451f, 
    -0.01486436f, -0.14686549f, -0.06998977f, -0.03780677f, 0.14297922f, 0.11333678f, 0.04955459f, 0.08448216f, 
    0.05324209f, -0.09600355f, -0.17834124f, 0.06288884f, 0.12609503f, -0.02230718f, -0.03425079f, -0.02200043f, 
    0.12667912f, -0.07645142f, 0.02240740f, 0.04006255f, 0.01535901f, 0.05006753f, 0.00083837f, 0.02983479f, 
    0.06398419f, 0.15901513f, -0.14976387f, 0.06968007f, -0.01832796f, -0.06311119f, 0.00367729f, -0.00907174f, 
    -0.06273911f, -0.27378994f, 0.08368884f, -0.00620866f, -0.06574121f, -0.05155978f, 0.14027351f, -0.10228180f, 
    0.06169342f, 0.03594172f, 0.02192119f, 0.11137766f, 0.05398845f, -0.02197264f, -0.04712157f, 0.06718463f, 
    -0.00467483f, -0.12612511f, -0.01192907f, -0.01478381f, 0.09932037f, 0.05504747f, -0.15031841f, 0.02898883f, 
    0.20722772f, 0.06519569f, -0.02680776f, 0.05510065f, 0.02972775f, 0.06834511f, -0.05008243f, 0.02145059f, 
    -0.02293067f, -0.13372713f, -0.00603599f, 0.04527085f, -0.05136739f, 0.03553755f, 0.10613380f, 0.00889564f, 
    0.01824871f, 0.02198461f, -0.14107159f, 0.02351673f, 0.15698411f, 0.03676637f, 0.15800576f, -0.10388994f, 
    -0.02934762f, 0.11945727f, -0.13682604f, -0.10295551f, -0.04874780f, -0.01266019f, -0.04302923f, 0.15185778f, 
    -0.01043652f, 0.05306990f, -0.01410988f, 0.08293343f, 0.20342751f, -0.02491064f, -0.17436171f, -0.10505186f, 
    0.27975345f, -0.03858905f, 0.05317991f, 0.06051349f, 0.01608645f, 0.07005455f, -0.17364202f, -0.03019629f, 
    0.03818897f, 0.09564393f, -0.08106881f, 0.23874369f, 0.10523157f, -0.07045013f, 0.08270660f, 0.00129924f, 
    -0.05753983f, 0.03538473f, 0.19936937f, -0.11320209f, 0.30947882f, 0.14170188f, 0.00469027f, 0.06807850f, 
    0.09841128f, -0.14634192f, 0.07174440f, -0.07898684f, 0.04665462f, 0.15614814f, 0.06949637f, 0.01354810f, 
    0.03893895f, 0.13381329f, -0.11476772f, 0.04552221f, 0.18411015f, 0.06259185f, -0.26196727f, -0.26761082f, 
    -0.19097251f, 0.03847343f, 0.05357206f, 0.02615276f, 0.04259270f, -0.05145659f, 0.00181012f, 0.12456141f, 
    -0.07769877f, 0.00890054f, -0.01503392f, -0.00533724f, -0.03382894f, -0.04532504f, -0.03379789f, -0.00614676f, 
    0.06564183f, 0.12498266f, -0.06221109f, 0.07517354f, 0.15673706f, -0.05976556f, 0.10437802f, -0.05367564f, 
    -0.00921367f, 0.14491372f, -0.02350518f, -0.07793010f, -0.03505822f, -0.03990020f, 0.11272448f, 0.01140845f, 
    -0.08441357f, -0.05844640f, 0.12690650f, -0.03155105f, -0.09175522f, -0.25642899f, -0.00965657f, -0.17457245f, 
    0.00656416f, 0.11662569f, 0.06528123f, 0.14168802f, -0.04946113f, -0.01929824f, 0.05974548f, 0.04807985f, 
    0.01928034f, 0.13356835f, -0.02850712f, 0.11815391f, -0.00924329f, -0.07307061f, -0.06656829f, -0.07157987f, 
    0.40340364f, 0.00509124f, 0.05080752f, 0.21080706f, 0.07186072f, 0.07598420f, -0.11705481f, -0.05511029f, 
    0.02771976f, 0.17943326f, -0.04811219f, 0.06768262f, -0.04267647f, 0.10762814f, -0.07317889f, -0.01976514f, 
    0.00712961f, 0.03335176f, -0.15537137f, -0.00021853f, 0.00875075f, 0.08982918f, 0.03923544f, 0.08578120f, 
    0.18113042f, -0.11995375f, -0.06155268f, 0.08569368f, 0.05916411f, 0.01282166f, -0.02743834f, -0.04636892f, 
    0.03309433f, 0.08926848f, -0.00465607f, 0.14092155f, -0.03297161f, -0.03250863f, 0.18799229f, 0.00826512f, 
    0.14721979f, -0.06341048f, -0.01048327f, 0.19113761f, 0.18698040f, 0.02174928f, 0.11606590f, -0.00942018f, 
    -0.05470336f, -0.03735271f, -0.00516804f, -0.01355032f, 0.02736507f, 0.07829707f, 0.05496990f, 0.05343655f, 
    -0.04043061f, -0.06481744f, -0.10080382f, -0.01795576f, 0.32335299f, -0.11006254f, 0.11043873f, 0.12205471f, 
    -0.02418997f, 0.07999077f, 0.07411045f, -0.16756228f, -0.01493795f, 0.23222145f, -0.01037646f, 0.05222251f, 
    0.07025127f, 0.03756481f, -0.06864137f, -0.05486174f, -0.06009058f, -0.02950079f, -0.11924158f, -0.00321688f, 
    -0.15705068f, 0.20173009f, -0.13221410f, -0.08882920f, -0.08712798f, 0.00387216f, 0.10406461f, -0.06277068f, 
    0.17268072f, 0.07033198f, 0.04379932f, -0.07674617f, -0.04095047f, -0.05383041f, -0.01700842f, 0.11927241f, 
    0.00463705f, -0.06691185f, 0.06113379f, -0.03271530f, -0.04112224f, 0.22807781f, -0.19312708f, -0.02012632f, 
    -0.02390589f, -0.02415892f, 0.05023382f, 0.06385011f, -0.05232000f, -0.13593216f, 0.06191282f, 0.10241554f, 
    0.02275979f, -0.03670625f, -0.07260390f, 0.02662410f, 0.02646532f, -0.00105439f, 0.07275297f, -0.00286104f, 
    0.06835286f, 0.40631771f, 0.05881164f, -0.08863244f, 0.29224107f, -0.07429609f, 0.19292651f, 0.16020817f, 
    0.08824620f, -0.04011422f, -0.06123245f, 0.00705405f, 0.24909142f, 0.05366119f, 0.09181453f, 0.04975738f, 
    -0.01634504f, -0.07042518f, 0.03428521f, -0.06579708f, -0.34383982f, 0.25666493f, -0.03604604f, 0.15818045f, 
    -0.21254054f, 0.06692669f, 0.05289723f, 0.06759883f, 0.00753097f, 0.10134499f, 0.07280812f, 0.07005457f, 
    0.04648848f, 0.01554717f, 0.06466205f, 0.07653822f, 0.06306414f, -0.02346529f, 0.07164864f, -0.01261889f, 
    0.22237059f, -0.08131009f, 0.11969009f, -0.06816830f, 0.13708149f, -0.00991558f, 0.13768117f, 0.08623450f, 
    0.04888183f, 0.11672126f, -0.01423815f, 0.07588596f, 0.00756284f, 0.09015539f, -0.05078857f, 0.07129289f, 
    0.05652827f, -0.13458315f, -0.11211124f, -0.01346367f, -0.15089434f, -0.18464531f, -0.06194366f, 0.05356318f, 
    -0.05594581f, 0.07458804f, -0.01848715f, 0.08414645f, 0.07770324f, 0.03092067f, 0.05923508f, 0.04847240f, 
    -0.08053619f, -0.05976750f, 0.10439681f, 0.06805430f, 0.05570479f, 0.08034946f, 0.11639168f, 0.06575796f, 
    0.06376245f, -0.08524357f, 0.20363896f, -0.02555833f, 0.03732312f, -0.09229995f, 0.02607308f, 0.06301542f, 
    -0.00563529f, 0.05577030f, -0.00060967f, 0.05126487f, -0.00388971f, 0.00002515f, -0.01118448f, 0.09205627f, 
    -0.07437582f, -0.04861959f, -0.02267381f, 0.09679130f, 0.06582511f, -0.15437917f, -0.04335108f, -0.21581376f, 
    -0.14717677f, -0.03593022f, -0.02386047f, 0.09421265f, 0.05300119f, -0.03085995f, -0.02732467f, -0.00540994f, 
    0.00782013f, 0.16373043f, 0.17053926f, 0.07675412f, 0.10557100f, 0.08659495f, 0.11643096f, 0.21671523f, 
    0.11904401f, -0.15772806f, -0.08215989f, -0.02448711f, -0.07536530f, -0.01181538f, -0.12229252f, 0.09958496f, 
    -0.02960974f, 0.03747776f, 0.03315122f, -0.03839367f, 0.07628963f, -0.02074901f, 0.07410435f, 0.03708695f, 
    0.10267206f, 0.05798402f, -0.06759005f, -0.09430113f, 0.45352495f, 0.45514688f, 0.06966524f, 0.01886693f, 
    0.16728440f, 0.04066163f, 0.05312612f, 0.06894644f, 0.05624814f, 0.08928718f, 0.11548830f, 0.02031032f, 
    -0.01034032f, 0.03618788f, 0.00425561f, -0.01637856f, 0.07576633f, 0.04123898f, 0.04964701f, 0.09087326f, 
    -0.13603644f, 0.05276490f, -0.16713557f, -0.00851975f, -0.18161643f, -0.06046225f, -0.06891194f, -0.01132651f, 
    0.04606985f, -0.00717870f, 0.03056639f, -0.01368626f, -0.02871135f, -0.05175818f, 0.05223472f, 0.05969869f, 
    0.01191163f, 0.03416036f, 0.13374089f, -0.01709611f, -0.04931825f, 0.10210714f, 0.15544605f, 0.16237794f, 
    0.01936786f, 0.01647175f, 0.05664651f, 0.07758044f, 0.07079198f, 0.17177270f, -0.02726707f, 0.06656405f, 
    0.10468396f, 0.08468062f, 0.16143554f, 0.08533183f, 0.11557385f, -0.11015266f, 0.01342444f, -0.00907575f, 
    -0.09410350f, 0.16812375f, -0.13819885f, -0.16425784f, -0.08025717f, 0.05298393f, -0.03091893f, -0.10788317f, 
    0.09335852f, 0.10083626f, 0.04840247f, -0.09669843f, -0.04948559f, 0.10386872f, -0.02036714f, 0.03082873f, 
    -0.03273134f, -0.01832874f, -0.03387119f, 0.04814917f, -0.13429132f, -0.24010006f, -0.12746669f, -0.05351365f, 
    -0.10660907f, -0.10408413f, -0.03366954f, 0.03708775f, 0.07420463f, 0.10295587f, -0.04533078f, 0.04969703f, 
    0.02307452f, 0.11415261f, 0.03955402f, 0.10510054f, 0.01756809f, 0.07691510f, 0.18042521f, 0.01438165f, 
    0.03017973f, -0.17421703f, -0.10137878f, 0.07361732f, -0.11209216f, 0.21490499f, -0.08311038f, 0.10937812f, 
    0.01720311f, 0.09542484f, -0.07220089f, 0.03065533f, -0.00580682f, 0.00073755f, 0.03462872f, 0.00441370f, 
    0.03530254f, 0.00997178f, 0.02972083f, -0.00499785f, -0.14497618f, 0.00016799f, -0.18047303f, -0.02637352f, 
    -0.24497931f, 0.18864287f, 0.00413856f, -0.02141977f, 0.01143537f, 0.13458049f, 0.04209163f, -0.06883327f, 
    0.07808140f, 0.13906141f, 0.02469034f, 0.12606287f, 0.01649300f, 0.02728892f, -0.07313383f, 0.06136518f, 
    -0.39268094f, -0.02013008f, -0.17892250f, -0.09215192f, 0.13382213f, 0.16707230f, 0.05514269f, 0.05093646f, 
    0.08673642f, -0.03094522f, -0.00863866f, 0.07089870f, -0.05880995f, 0.09138950f, -0.04701200f, 0.04817221f, 
    0.05383509f, -0.01005806f, -0.09606286f, 0.02010840f, -0.09384128f, -0.03912798f, 0.14029010f, -0.03769727f, 
    -0.08335902f, -0.07940513f, -0.13570687f, -0.02177662f, -0.01464043f, 0.07030788f, 0.03197469f, 0.03741306f, 
    0.08355829f, 0.02512004f, 0.09439150f, -0.02346144f, 0.00911274f, 0.01374441f, 0.02402629f, 0.01619376f, 
    -0.05227168f, -0.12733917f, 0.24403563f, 0.19648840f, 0.02350943f, 0.05224905f, 0.00099537f, 0.02769749f, 
    0.01365858f, 0.06359426f, 0.05649640f, 0.02581685f, -0.03210556f, -0.02776876f, -0.00928311f, -0.02014395f, 
    0.01885484f, 0.03529416f, 0.05335604f, -0.01975855f, -0.03795182f, 0.03741708f, -0.05457337f, -0.04084049f, 
    -0.00447312f, 0.06021706f, 0.10467554f, 0.00750869f, 0.03710032f, 0.04278790f, -0.00572749f, -0.06778435f, 
    -0.04614205f, -0.00219928f, -0.01051227f, 0.01862234f, 0.06130969f, 0.08905887f, -0.00325621f, 0.00440404f, 
    -0.09124945f, 0.00648102f, -0.08480632f, 0.03633745f, -0.06533273f, 0.11900173f, -0.03004890f, 0.18302307f, 
    0.06523479f, 0.12220267f, 0.00623978f, 0.02302651f, 0.01080785f, -0.02274621f, -0.06387409f, -0.02223643f, 
    -0.04128085f, 0.04311813f, -0.04779495f, -0.04092296f, -0.35257077f, -0.07307751f, -0.04597195f, 0.07621212f, 
    0.08789384f, -0.00887328f, -0.02762898f, 0.00588874f, 0.05998614f, -0.07282278f, 0.03485372f, -0.04407366f, 
    -0.01282124f, -0.00895418f, 0.04516396f, -0.09955460f, -0.03269535f, -0.03431344f, -0.00508935f, -0.03143100f, 
    -0.10117341f, 0.15625691f, 0.06841619f, -0.05671991f, -0.05829258f, 0.02327991f, -0.06237708f, -0.00170615f, 
    0.00313043f, 0.03116590f, 0.05066608f, 0.04442897f, 0.08527862f, 0.14536275f, 0.12396014f, -0.03897908f, 
    0.05594084f, 0.00966048f, -0.08044893f, -0.12504910f, 0.04917901f, 0.05524272f, -0.05125863f, 0.01654224f, 
    0.11047830f, -0.04883807f, -0.05735153f, -0.05366324f, 0.05124976f, -0.03093529f, 0.06071549f, 0.05395262f, 
    0.04932879f, -0.01531958f, -0.02495126f, -0.00349467f, 0.06454597f, 0.05087209f, 0.00095490f, 0.02278658f, 
    0.05195398f, 0.21661106f, 0.03018394f, 0.05517321f, -0.25469235f, -0.07523516f, 0.04327760f, -0.07047115f, 
    -0.05046794f, 0.10993855f, -0.05834806f, 0.04480835f, 0.00339582f, -0.00144948f, 0.05548357f, 0.04214407f, 
    0.04083886f, -0.06222990f, -0.01959996f, 0.00175820f, 0.12334672f, 0.11642555f, 0.27013475f, 0.17998528f, 
    0.10646913f, -0.06418083f, 0.07027924f, 0.05659005f, 0.00691394f, 0.05844048f, -0.07264938f, -0.07552178f, 
    0.03423328f, 0.01779230f, 0.14121833f, 0.01928284f, 0.01151098f, 0.08082996f, 0.02910461f, 0.07529174f, 
    -0.05036562f, -0.07352343f, -0.01468129f, -0.06883299f, 0.06748994f, -0.01043980f, -0.06165721f, 0.02151566f, 
    0.00094404f, 0.07139423f, 0.00888489f, 0.03661915f, -0.00143395f, -0.06706860f, 0.07143886f, 0.03478957f, 
    0.04752994f, 0.04057897f, -0.03444785f, 0.05815705f, 0.10989551f, 0.12514088f, 0.07425103f, 0.04791263f, 
    -0.09681696f, 0.05618525f, 0.04706230f, 0.04239545f, 0.05099385f, 0.00337935f, 0.06831072f, 0.03763127f, 
    0.01232652f, 0.05476429f, 0.05139721f, 0.08504122f, 0.05543410f, -0.01204397f, 0.08768083f, -0.03642257f, 
    -0.40555871f, 0.05525702f, -0.16493738f, -0.10842922f, 0.10803434f, 0.15843226f, 0.09482386f, 0.02652306f, 
    -0.00040305f, 0.09258824f, 0.00114633f, -0.00170260f, 0.11725721f, 0.04451770f, 0.07792542f, 0.10949391f, 
    0.03367041f, -0.01101133f, 0.13551798f, -0.03690807f, 0.02009626f, -0.13961460f, -0.09087431f, 0.12481995f, 
    0.13555863f, 0.01814526f, 0.00544302f, 0.03289549f, -0.00943861f, 0.04001087f, 0.06656738f, 0.03708608f, 
    0.03734133f, 0.00209355f, 0.12465798f, 0.03478506f, 0.06722333f, 0.06917188f, 0.08992812f, 0.05034813f, 
    -0.10467751f, 0.09497178f, -0.14955011f, -0.04534615f, -0.06293976f, 0.06561499f, -0.02567325f, -0.01055779f, 
    0.03340264f, 0.06316558f, 0.00307110f, 0.02793070f, -0.00561248f, -0.07620563f, -0.06906667f, 0.00020078f, 
    -0.03278175f, -0.00556113f, -0.03823779f, 0.03054309f, -0.52304035f, 0.00941460f, -0.12235242f, 0.01561272f, 
    0.06994556f, 0.10468960f, 0.05199563f, 0.08730036f, 0.01938925f, 0.00660233f, 0.04785674f, 0.03937089f, 
    0.05288164f, 0.00759698f, 0.03573312f, 0.09133276f, 0.08183337f, 0.00516701f, 0.13653901f, 0.03544592f, 
    0.00560758f, -0.15124962f, 0.06880301f, -0.04616403f, 0.03486601f, -0.08575998f, -0.01763829f, 0.04474404f, 
    -0.05810969f, 0.08844192f, 0.11060943f, -0.04942290f, 0.06281511f, 0.04283449f, -0.00186953f, -0.15493044f, 
    0.02898561f, 0.00397997f, 0.04436653f, -0.07818504f, 0.03225188f, 0.05946174f, 0.19650507f, 0.08631739f, 
    0.05805282f, 0.12918764f, 0.01831817f, 0.02439636f, -0.03718907f, 0.03628704f, -0.11067698f, 0.02720206f, 
    -0.04138106f, -0.05392355f, 0.03230774f, 0.06780513f, 0.05961081f, 0.08613867f, 0.07490592f, -0.00340661f, 
    0.00565398f, -0.09971561f, -0.03668069f, -0.02210813f, -0.20731276f, -0.00841953f, -0.11073089f, 0.05763125f, 
    0.02333053f, 0.02280921f, 0.03440226f, -0.03356429f, -0.02654229f, 0.00987554f, -0.07141910f, 0.00538176f, 
    0.03944514f, 0.02202610f, -0.06818641f, -0.03944414f, 0.21635731f, -0.30887774f, 0.15235962f, -0.07242918f, 
    0.14291245f, 0.09593810f, -0.01796161f, 0.02168493f, 0.03952969f, -0.06159180f, 0.02629061f, -0.04108661f, 
    0.09406804f, -0.01280302f, 0.16869046f, -0.01575981f, 0.03323741f, 0.02484987f, 0.02336380f, 0.04890726f, 
    -0.02996303f, -0.20794532f, -0.02798530f, 0.10301577f, -0.04165642f, -0.10683342f, 0.01832050f, -0.02225474f, 
    0.09503175f, -0.05268893f, -0.02898729f, -0.09689211f, 0.08609090f, -0.00481815f, 0.10677285f, -0.11063411f, 
    -0.14389256f, 0.00946820f, 0.03105586f, 0.00855723f, 0.09313905f, 0.24563678f, 0.03451076f, -0.00561023f, 
    0.10062372f, 0.07577034f, 0.11221895f, -0.04360733f, -0.03999358f, 0.09612390f, -0.02729969f, -0.05269344f, 
    -0.03392594f, -0.06278700f, -0.06054678f, -0.00302967f, -0.03025730f, 0.07990673f, 0.02243207f, 0.00874151f, 
    0.31305003f, 0.05069090f, -0.16488589f, 0.02391798f, -0.00595268f, 0.10609096f, -0.02380683f, 0.10236727f, 
    0.07249724f, -0.02283646f, 0.02159141f, 0.08451790f, -0.09061377f, -0.03823606f, -0.10222676f, 0.01675280f, 
    0.00302522f, 0.04397283f, -0.02204114f, -0.05769416f, 0.04958103f, 0.07076801f, -0.03519356f, 0.05423861f, 
    0.20979600f, -0.09018683f, -0.07156991f, 0.03441172f, 0.02706024f, -0.08219697f, 0.02971759f, 0.06318385f, 
    -0.07288488f, -0.03143213f, -0.04034167f, 0.03061560f, -0.05162841f, 0.06066246f, -0.14242236f, 0.01231431f, 
    0.14941759f, 0.19476883f, -0.08433498f, 0.21635690f, -0.06099037f, -0.08588047f, 0.05571781f, -0.03014568f, 
    0.04605221f, 0.03881351f, 0.10494455f, 0.06083702f, 0.01876785f, 0.06695774f, -0.09744312f, 0.02139795f, 
    -0.07863174f, -0.00152231f, -0.08624417f, 0.02135063f, -0.30376995f, -0.10179949f, -0.02299589f, 0.04478319f, 
    -0.08585599f, 0.00437687f, 0.04354019f, 0.00154924f, -0.00549287f, -0.04475734f, -0.03389600f, 0.05456103f, 
    0.08120044f, -0.11669259f, -0.10122264f, -0.00482243f, 0.02203916f, -0.09258717f, 0.07817733f, -0.02577593f, 
    0.12421773f, 0.09880184f, 0.13966264f, 0.06688175f, 0.07150997f, 0.06791545f, -0.00306685f, -0.02068351f, 
    -0.14276148f, -0.00855717f, 0.04488915f, 0.01335318f, 0.02045969f, -0.00805427f, -0.06092552f, 0.01752345f, 
    0.08708448f, 0.05402321f, 0.02026340f, 0.00026141f, -0.17673194f, -0.11465130f, -0.11651181f, -0.01378593f, 
    -0.05364985f, -0.10200993f, 0.00027312f, 0.04295181f, 0.10926851f, -0.02542788f, -0.00626188f, 0.01386925f, 
    0.03795386f, 0.06267431f, 0.08744048f, -0.02943447f, -0.08274233f, -0.08140002f, 0.01975662f, -0.02905724f, 
    0.06316504f, -0.08236464f, 0.14163856f, 0.04392371f, 0.11623847f, -0.07286941f, 0.00109466f, -0.00983810f, 
    -0.00725042f, -0.07415746f, 0.00636545f, -0.00561359f, 0.00482024f, 0.06371292f, 0.06793672f, 0.04777526f, 
    0.12658831f, 0.09697121f, -0.00708568f, -0.00453045f, 0.06755891f, 0.14532542f, 0.07172791f, -0.00940337f, 
    0.03070037f, 0.10025603f, 0.04131332f, -0.07320543f, 0.00158731f, 0.00081885f, 0.01579705f, 0.03902856f, 
    -0.14287221f, -0.10962181f, 0.01791831f, 0.03646936f, -0.08471211f, 0.07761746f, 0.08199706f, 0.01862769f, 
    0.02990924f, 0.16461878f, 0.05374015f, -0.02486155f, 0.02720012f, -0.00270136f, -0.00637919f, -0.06043310f, 
    -0.06736141f, -0.03722934f, 0.01764635f, 0.00875326f, 0.06148458f, -0.03997040f, -0.02105900f, -0.02189456f, 
    0.08310548f, 0.14771259f, 0.06507585f, -0.03914213f, -0.02393872f, -0.15394308f, 0.17740130f, 0.01077009f, 
    0.11451898f, -0.03329235f, -0.03139977f, 0.05451214f, 0.04723998f, -0.06011803f, -0.05885651f, -0.09804901f, 
    0.06201518f, 0.05533272f, -0.00728398f, -0.02277608f, 0.01363056f, 0.00214818f, -0.00652758f, 0.04789273f, 
    -0.23895723f, 0.16194698f, -0.15085150f, -0.02666805f, 0.12460976f, 0.12381338f, 0.00464033f, 0.15766697f, 
    0.06157014f, 0.14830394f, -0.02799356f, -0.04915018f, 0.05944210f, -0.05094238f, -0.00927684f, -0.00603516f, 
    0.06807174f, 0.06073100f, 0.03980898f, 0.09938732f, -0.06177467f, -0.07011723f, -0.01708808f, -0.05633690f, 
    0.13081101f, -0.04705813f, -0.01861230f, 0.11196083f, -0.01716819f, 0.03231468f, 0.05757123f, 0.07881733f, 
    0.00531336f, -0.01048153f, 0.08574057f, 0.08375063f, 0.09542274f, -0.02272882f, -0.06215500f, 0.06605475f, 
    -0.28168613f, -0.07930292f, -0.10456426f, 0.10484453f, 0.08308972f, 0.08065572f, 0.14202848f, -0.07138562f, 
    0.09041766f, 0.05080494f, -0.05967969f, 0.11748356f, 0.04602925f, -0.02873660f, 0.13015170f, -0.02678933f, 
    0.14489773f, 0.03718163f, -0.04923854f, 0.12947346f, -0.28035796f, -0.04788112f, -0.06156337f, -0.12645465f, 
    0.18079580f, 0.06120899f, 0.04437301f, -0.13389811f, -0.04711324f, -0.01091938f, -0.11712792f, -0.16181542f, 
    0.01647374f, 0.16323771f, -0.08626192f, 0.08452968f, -0.01335926f, 0.10475204f, -0.10109138f, -0.02106454f, 
    -0.03933572f, -0.04381867f, -0.19023181f, 0.11536609f, 0.12617870f, 0.13735235f, 0.07391645f, 0.02907060f, 
    0.04451333f, 0.14263065f, 0.01653014f, 0.05998367f, -0.02537888f, -0.07630938f, -0.04521821f, 0.14969419f, 
    0.05037025f, 0.03809000f, -0.03281812f, 0.05606014f, -0.31266662f, 0.11628360f, -0.15322019f, -0.08895345f, 
    0.04505055f, 0.09660937f, -0.03924261f, 0.09034534f, 0.02865149f, 0.00124125f, 0.01869229f, 0.03358634f, 
    -0.04752448f, 0.01214967f, -0.01020200f, 0.01132226f, 0.04594461f, -0.04653375f, 0.00217654f, 0.07437548f, 
    -0.04462234f, 0.17276643f, -0.08794209f, -0.04988213f, 0.03638107f, 0.00267399f, 0.09838239f, -0.07500957f, 
    -0.01474215f, 0.04240492f, 0.00935642f, -0.06628283f, -0.00081289f, 0.14089060f, 0.01144745f, 0.21734771f, 
    0.01012495f, -0.03872096f, -0.10398290f, -0.04289842f, -0.03363090f, -0.05500107f, -0.12181917f, -0.22830169f, 
    0.07398862f, -0.10982336f, 0.02375306f, 0.02632472f, 0.05688048f, 0.08515163f, -0.01056052f, 0.02529582f, 
    0.00443277f, 0.01612444f, -0.02396602f, -0.00618648f, 0.12612942f, 0.02072271f, 0.01483202f, -0.00898736f, 
    -0.47289294f, 0.07475886f, -0.07375489f, 0.09751596f, -0.14621484f, 0.06831876f, 0.06720649f, -0.08223729f, 
    -0.08498673f, -0.10125152f, 0.00537605f, 0.00722134f, 0.09701147f, -0.03874545f, 0.01037023f, -0.11646523f, 
    0.05425501f, -0.09551434f, 0.09417862f, 0.11103541f, -0.07368870f, 0.15729646f, 0.29394624f, 0.02706496f, 
    -0.21516709f, 0.11197888f, 0.10377844f, 0.00244868f, -0.02912210f, 0.04153632f, 0.15805058f, 0.03837305f, 
    0.10411524f, 0.18246683f, 0.20392902f, 0.06168275f, -0.02751804f, 0.08479346f, -0.08672056f, 0.06184055f, 
    -0.11032489f, 0.14821748f, -0.05003224f, -0.19322522f, 0.12642623f, 0.06395952f, 0.01327733f, 0.08299928f, 
    0.00313455f, 0.07395099f, -0.00986975f, 0.11159226f, -0.00822794f, 0.03764771f, 0.06990361f, 0.05360341f, 
    0.01817244f, 0.09959011f, -0.03629112f, 0.05965061f, 0.15127906f, 0.09065999f, -0.08430479f, -0.06563778f, 
    -0.01355495f, 0.19159116f, 0.20444660f, -0.14307041f, 0.04492138f, 0.06680859f, 0.07643089f, -0.03102445f, 
    -0.02069676f, 0.08757608f, 0.17518117f, 0.08179576f, 0.00853736f, 0.05894452f, 0.04158568f, 0.01103357f, 
    -0.14625750f, -0.04459014f, -0.17781292f, 0.03259706f, 0.12652662f, 0.02842657f, -0.01170851f, 0.06937106f, 
    0.02022866f, 0.13460855f, -0.12713665f, -0.06265075f, -0.05144041f, 0.12630075f, -0.06157804f, 0.13651349f, 
    0.01176903f, -0.07047061f, -0.04793299f, -0.00565908f, 0.07409960f, -0.04761779f, -0.15332831f, -0.14279923f, 
    0.11267331f, -0.08672641f, 0.01866146f, 0.05761023f, 0.05992011f, -0.05880743f, 0.14037478f, 0.04331150f, 
    0.05408559f, 0.08312667f, 0.06980255f, 0.04057512f, 0.03183351f, -0.02085838f, 0.07848100f, 0.11632852f, 
    -0.30168638f, 0.04660380f, -0.02080510f, -0.07141460f, 0.16549115f, 0.16657436f, -0.06316201f, 0.15149125f, 
    -0.01697946f, 0.03701444f, 0.07561772f, 0.04621076f, 0.02968157f, -0.04068995f, 0.03628454f, 0.05165932f, 
    0.07854793f, -0.10485061f, 0.01675668f, 0.02596690f, -0.05094171f, -0.19707753f, -0.24014214f, 0.10482910f, 
    0.08077711f, 0.14677876f, 0.00500065f, -0.10847003f, 0.04562357f, 0.08760730f, -0.03762117f, -0.07415965f, 
    -0.04824594f, -0.06004913f, -0.01133410f, 0.08092305f, -0.06339665f, -0.01069879f, 0.05478475f, 0.01025752f, 
    0.03364683f, -0.07361795f, -0.20096503f, -0.03889308f, -0.00823113f, 0.05566414f, -0.07201636f, -0.13579006f, 
    -0.05214012f, 0.04637661f, 0.02257080f, 0.02795673f, 0.06290766f, -0.07060612f, 0.02161305f, -0.07755399f, 
    0.05329245f, -0.01977254f, 0.08114537f, 0.08549010f, -0.03752682f, 0.05560810f, 0.31371155f, 0.06007800f, 
    0.11107827f, 0.01709129f, 0.08579068f, 0.02799579f, 0.07898998f, 0.06093193f, -0.01519012f, -0.01390888f, 
    0.10232062f, -0.01260723f, 0.06708649f, -0.03404335f, 0.11306299f, -0.03403823f, 0.13688597f, 0.04617958f, 
    0.30104133f, -0.21917161f, 0.09413995f, -0.09835603f, -0.10814647f, -0.05315238f, 0.00446493f, 0.04519698f, 
    0.08357056f, -0.11197039f, 0.01102547f, 0.00119689f, -0.02352964f, 0.09520397f, 0.00728811f, -0.03075182f, 
    0.04040493f, -0.17171727f, 0.02412685f, -0.00368462f, 0.52064282f, -0.06856864f, -0.05429316f, 0.07249597f, 
    0.02027876f, 0.04503375f, 0.10037826f, 0.02494761f, -0.04060438f, -0.04736220f, -0.05918511f, 0.02432684f, 
    0.06605510f, 0.09506011f, 0.04353465f, 0.08117209f, 0.11768745f, -0.09528989f, 0.16130604f, 0.06844217f, 
    -0.01426954f, -0.06697483f, -0.08113112f, -0.10596284f, -0.26042366f, -0.01857635f, 0.10418274f, -0.00448174f, 
    0.03364530f, -0.00435598f, 0.00570385f, -0.08220314f, 0.07134293f, -0.05506991f, -0.07056733f, -0.06955564f, 
    0.08618631f, -0.08639346f, 0.04557077f, 0.01711265f, 0.09319272f, 0.09974480f, -0.11227070f, 0.21390653f, 
    0.03241171f, -0.08128603f, -0.01914238f, 0.01667147f, -0.14931425f, 0.08713580f, 0.01173128f, -0.08126743f, 
    -0.02100588f, -0.09955453f, 0.07809540f, 0.03913274f, 0.10196794f, 0.10897501f, 0.03434684f, 0.09049476f, 
    -0.17628044f, 0.24615581f, 0.00371551f, -0.08938558f, 0.12682965f, 0.08756975f, -0.03018700f, 0.01501313f, 
    0.00931085f, 0.04554899f, -0.05508855f, 0.02655312f, 0.08457023f, -0.01713474f, -0.08546368f, -0.03645738f, 
    0.00686122f, -0.06960961f, 0.00731645f, -0.03661507f, 0.36201596f, 0.10115986f, -0.10652370f, -0.08218011f, 
    0.23841678f, 0.04818897f, 0.03841374f, 0.03165536f, 0.04944747f, 0.14508142f, -0.01050452f, -0.04287923f, 
    0.04766315f, 0.11342234f, 0.06443684f, 0.16323228f, 0.04241546f, 0.13227846f, -0.06004038f, 0.03242480f, 
    0.19135262f, -0.09401663f, 0.26074111f, 0.04536081f, 0.13443987f, -0.09493845f, 0.01281641f, 0.02662970f, 
    -0.00439589f, 0.02127783f, -0.00046339f, -0.00566618f, 0.07821824f, 0.17031877f, 0.07862443f, -0.00941292f, 
    0.05132932f, 0.04174000f, -0.11171980f, 0.13838208f, -0.14931199f, -0.13839230f, 0.16652288f, 0.11382260f, 
    -0.07271490f, -0.06399193f, 0.13438353f, 0.11724790f, -0.09996726f, 0.01345140f, -0.02481091f, 0.00171675f, 
    -0.05036357f, -0.12789163f, 0.03953367f, -0.05210349f, -0.01340668f, 0.00742133f, 0.08876434f, 0.03438855f, 
    0.09943203f, 0.04879953f, 0.10466878f, 0.10561135f, 0.03267879f, 0.01362315f, 0.04685291f, 0.04232528f, 
    -0.15792988f, 0.05200487f, 0.01981567f, 0.02329551f, 0.01464353f, -0.05015617f, 0.00590860f, -0.02300178f, 
    0.05953333f, 0.00342198f, 0.17411533f, -0.00483699f, -0.15691830f, -0.06280471f, -0.09776466f, 0.01993371f, 
    -0.06472035f, 0.08014717f, 0.07247562f, 0.06822313f, -0.01868556f, -0.07702076f, 0.00181645f, -0.03160001f, 
    -0.01310647f, 0.15820730f, -0.04320002f, 0.07361154f, 0.07228109f, -0.15578723f, 0.00227064f, -0.00320149f, 
    0.01347074f, 0.02439379f, -0.17447957f, -0.06493887f, -0.08108303f, 0.02056691f, -0.08069839f, -0.06818670f, 
    0.03647223f, 0.10942873f, -0.06172981f, 0.07993386f, -0.01524664f, 0.12328181f, 0.02830352f, 0.02374836f, 
    0.05583252f, 0.02586350f, 0.12716793f, -0.07896678f, 0.19140045f, 0.07670789f, -0.05078035f, 0.32348698f, 
    0.11863948f, 0.02976764f, 0.03728106f, 0.13171043f, 0.00891322f, 0.03669292f, -0.08840287f, 0.01066353f, 
    0.05287082f, 0.06733590f, 0.11315984f, 0.09906611f, -0.00793450f, 0.12523858f, 0.19389570f, 0.18065113f, 
    0.00700326f, 0.01786117f, -0.15066113f, 0.05389706f, -0.01680630f, -0.00448847f, 0.04317725f, -0.00743027f, 
    -0.08898046f, 0.00373603f, -0.08688331f, -0.00061139f, 0.05770012f, 0.03913454f, 0.07356118f, -0.01744398f, 
    0.04683955f, 0.05411445f, -0.07188290f, 0.09110506f, -0.02413193f, -0.06637119f, -0.18279453f, -0.04200955f, 
    -0.10538141f, 0.03787098f, 0.01576458f, -0.01600670f, 0.06196202f, 0.12175895f, -0.08261902f, 0.07466542f, 
    0.09857999f, 0.01492298f, -0.02636535f, 0.07452148f, 0.06351908f, -0.00104704f, 0.00985743f, 0.01620872f, 
    -0.17760608f, -0.04261756f, -0.07340007f, -0.01056166f, 0.06520931f, 0.05868917f, 0.01060384f, -0.07604314f, 
    0.02275055f, -0.06244336f, 0.09803426f, 0.16474961f, -0.00463878f, -0.05778991f, 0.03907284f, -0.03554855f, 
    -0.01121079f, -0.01186409f, 0.03837670f, 0.03684144f, 0.18421999f, -0.11882057f, 0.05118021f, 0.13392308f, 
    -0.08184002f, -0.12150902f, -0.03540500f, -0.04985995f, 0.06511553f, 0.13731019f, -0.08683348f, 0.08595893f, 
    0.06057154f, 0.11945747f, 0.00677879f, -0.02320754f, 0.06102517f, 0.01276115f, -0.06026627f, 0.05741368f, 
    -0.05739168f, -0.22083794f, 0.00937957f, 0.01578677f, -0.19428068f, 0.05546519f, -0.00704704f, 0.06777212f, 
    0.07364260f, 0.03898219f, 0.06825256f, 0.03830389f, -0.01068327f, 0.02789784f, -0.00234286f, -0.07106589f, 
    0.04754573f, -0.00806001f, -0.11659501f, 0.09410378f, -0.00150138f, 0.14968069f, -0.17970113f, -0.04013678f, 
    0.07861064f, -0.07906745f, 0.12430123f, 0.02481465f, 0.08633386f, 0.00524915f, -0.02753806f, -0.05626993f, 
    0.04010109f, 0.00016445f, -0.02742292f, 0.00274968f, -0.00165256f, -0.03902962f, 0.00358382f, 0.07818316f, 
    -0.11404148f, 0.02638947f, 0.09211300f, -0.05476654f, -0.12276004f, 0.12983420f, -0.02803463f, 0.09607951f, 
    0.05370073f, 0.09287675f, 0.02468529f, 0.08946875f, 0.02696284f, -0.07346848f, -0.08645170f, 0.02696088f, 
    -0.13907839f, 0.10377049f, -0.03767977f, 0.03884111f, 0.01619351f, -0.06083434f, -0.02241318f, 0.16208538f, 
    0.14310366f, -0.03508450f, -0.03755599f, -0.01421823f, 0.05206069f, -0.05698597f, 0.03425944f, -0.02486424f, 
    0.08693769f, 0.02552091f, 0.06627611f, -0.04440793f, -0.01612291f, 0.03120437f, -0.03655396f, -0.02925896f, 
    -0.01739565f, 0.24185766f, -0.03411762f, 0.03944211f, -0.03817606f, 0.01072460f, 0.10595924f, -0.00981260f, 
    -0.02636323f, -0.07519065f, 0.03918047f, 0.01586395f, 0.06915778f, 0.04450080f, 0.16584305f, -0.01558207f, 
    0.11615852f, -0.03942265f, 0.00555714f, -0.13659720f, 0.13439944f, 0.06799845f, -0.03291121f, 0.28314534f, 
    0.30683899f, -0.05130051f, 0.00834002f, -0.01078387f, 0.00660050f, 0.03385771f, 0.07313494f, 0.01458827f, 
    -0.03518085f, 0.03009086f, -0.12040991f, 0.02467702f, 0.10276680f, -0.05119210f, -0.12744805f, -0.02583957f, 
    -0.02650045f, 0.19319011f, 0.09117401f, 0.09668195f, -0.05736511f, 0.08571331f, 0.14904760f, 0.03336672f, 
    -0.12924865f, 0.04399621f, -0.08022995f, 0.06344341f, 0.07373319f, 0.05596672f, 0.04619827f, -0.00653561f, 
    0.09456896f, 0.07221365f, 0.01020303f, 0.07404597f, -0.15237227f, -0.04607229f, 0.03794363f, -0.04901742f, 
    0.01152375f, -0.12881161f, 0.00835840f, 0.02860565f, -0.00976727f, -0.02016162f, -0.10479288f, -0.07883753f, 
    -0.05323102f, -0.07653975f, 0.03645493f, -0.01707688f, -0.02258720f, 0.04689225f, 0.01998556f, 0.04598650f, 
    0.22131078f, 0.01655749f, -0.06313992f, -0.03098916f, 0.22375557f, -0.07641001f, 0.08812726f, 0.02783740f, 
    -0.03553769f, 0.03670519f, 0.03002371f, 0.11326052f, 0.02047055f, -0.04811764f, 0.01843830f, 0.14437586f, 
    0.01813398f, 0.02214576f, 0.11843907f, 0.04907344f, -0.11526292f, -0.05050956f, -0.07531065f, -0.21824171f, 
    -0.12871815f, 0.02690706f, 0.10616010f, 0.04171481f, 0.03057040f, -0.11381473f, 0.07975141f, -0.00734026f, 
    -0.02455772f, 0.07871298f, -0.01140453f, 0.01559794f, -0.08570594f, -0.03171118f, -0.00027072f, 0.09436163f, 
    -0.19731037f, 0.18147068f, -0.00535141f, -0.00901004f, 0.21950413f, 0.07104888f, 0.01752732f, -0.08145256f, 
    -0.00002060f, 0.10761533f, 0.03971184f, 0.02078992f, 0.06677034f, -0.07049678f, 0.04708487f, -0.07443737f, 
    0.04977493f, 0.06710407f, 0.10486782f, -0.03921147f, 0.22237641f, -0.00262278f, -0.06281480f, 0.35484073f, 
    0.16316511f, 0.04417022f, -0.00840044f, -0.08436430f, -0.01758582f, -0.05412463f, 0.06807368f, 0.11165244f, 
    0.02791786f, -0.07337864f, 0.06182570f, 0.08671305f, 0.02828052f, 0.06321020f, 0.04188750f, 0.05009456f, 
    -0.06564938f, 0.17099915f, -0.11002361f, 0.09333826f, 0.01915533f, 0.02205949f, -0.05541189f, -0.07650724f, 
    0.03210459f, -0.05669735f, -0.04695965f, 0.05702992f, -0.00154735f, -0.10708510f, 0.07067366f, 0.00470561f, 
    -0.00025061f, 0.04723658f, 0.00753104f, 0.05040415f, -0.29621527f, 0.19838376f, 0.11893555f, 0.11470449f, 
    0.15454419f, -0.00873980f, 0.04000556f, 0.02431072f, 0.08697390f, -0.00406717f, 0.05956493f, 0.00696474f, 
    0.03305485f, -0.01390136f, -0.07171258f, -0.08585650f, 0.00107330f, 0.01196214f, 0.10245592f, -0.12054006f, 
    0.17814741f, -0.14718325f, 0.13047169f, 0.08738687f, -0.15326366f, -0.09545037f, -0.06653546f, -0.00666391f, 
    -0.01481166f, 0.01888385f, -0.07469022f, -0.00767058f, 0.02313740f, 0.05175199f, -0.00313468f, 0.01556478f, 
    -0.03172697f, 0.03330337f, -0.02178978f, 0.03120431f, 0.29537740f, -0.02755058f, -0.08927919f, 0.11997459f, 
    0.02958728f, 0.13274826f, 0.07324939f, -0.09259197f, 0.09119584f, 0.03796308f, -0.10816952f, -0.02554208f, 
    0.02008017f, 0.09363338f, -0.02677418f, -0.01791060f, -0.00270948f, 0.02150123f, 0.04064111f, -0.01734394f, 
    -0.30555546f, -0.10228138f, -0.10985155f, -0.06993701f, -0.25637475f, -0.05841101f, 0.03816669f, -0.12948520f, 
    -0.06061805f, -0.05609945f, 0.05976681f, -0.01388166f, 0.04754918f, 0.13909967f, -0.08359671f, 0.03291995f, 
    0.00080096f, 0.04957398f, -0.07194667f, -0.03261086f, 0.13326363f, 0.13380867f, -0.08145340f, 0.10922935f, 
    0.13068350f, 0.00151869f, -0.07077967f, -0.04037923f, 0.00286643f, 0.01161580f, -0.06380557f, 0.10098590f, 
    0.03779094f, 0.08155245f, -0.05587725f, -0.03542488f, -0.09686868f, -0.06296311f, -0.05253983f, -0.12897876f, 
    -0.08145094f, 0.08992235f, 0.17003039f, -0.05787847f, -0.08658858f, 0.00838696f, -0.15598501f, -0.07260915f, 
    -0.03790107f, -0.01247343f, 0.07363499f, 0.01818364f, -0.04522857f, -0.06520529f, 0.07967966f, 0.03203722f, 
    -0.01853034f, 0.09146374f, -0.04499625f, 0.02534368f, 0.23627853f, 0.10811478f, 0.05335014f, -0.02408145f, 
    0.17501263f, -0.04615818f, -0.01981276f, -0.09766027f, -0.04191317f, 0.09558985f, -0.06943471f, 0.01658799f, 
    0.08643822f, 0.01264106f, 0.03196483f, 0.11471557f, 0.03837192f, 0.03973156f, 0.04716286f, -0.04178179f, 
    0.15199378f, -0.24413769f, -0.10111588f, 0.24310617f, 0.04198710f, 0.09351429f, 0.16860585f, -0.10546903f, 
    -0.03260333f, 0.06782477f, 0.03190725f, 0.00257644f, -0.04447317f, -0.06780481f, 0.07775734f, -0.02789557f, 
    0.05299414f, 0.13153721f, 0.09238713f, 0.11893052f, -0.06884327f, 0.03368892f, -0.03193931f, 0.23687772f, 
    0.17176144f, 0.05104760f, 0.11793204f, 0.01628872f, -0.03053549f, 0.07024603f, 0.03381214f, 0.04072176f, 
    0.02305154f, -0.10050703f, 0.05056721f, 0.08792365f, 0.09481757f, -0.17644653f, 0.08539066f, 0.01607833f, 
    0.09668142f, 0.19706288f, 0.02172790f, 0.02993562f, 0.16168493f, 0.07893271f, 0.09983700f, 0.01825744f, 
    0.05208308f, 0.08264387f, 0.01436063f, 0.05565048f, -0.04856803f, 0.14276908f, -0.11566496f, 0.06434482f, 
    0.01225431f, 0.04414931f, 0.05250482f, 0.02374619f, 0.04359021f, -0.06256182f, -0.30959326f, -0.11223653f, 
    0.16270055f, 0.05500845f, -0.04237010f, 0.02222885f, 0.02638632f, -0.01355211f, -0.03877345f, -0.01081772f, 
    0.01726071f, 0.11944669f, -0.02539662f, 0.05632568f, 0.00344481f, -0.00569475f, -0.13557483f, -0.01207111f, 
    0.12989205f, 0.13430540f, 0.07397976f, 0.14993936f, 0.15757783f, 0.03798729f, 0.06276742f, -0.04890275f, 
    0.06945110f, 0.09978233f, 0.00202751f, 0.02595704f, 0.10041642f, 0.09970828f, 0.06291230f, -0.00957199f, 
    0.06596839f, 0.03189720f, -0.03560453f, 0.00898634f, -0.01382397f, -0.19475079f, 0.00697116f, -0.11268702f, 
    -0.13028535f, -0.12591906f, 0.04906985f, 0.06663125f, -0.04742905f, 0.01698405f, 0.07036576f, 0.03684438f, 
    -0.02373229f, 0.02503133f, -0.12707010f, 0.02093576f, -0.11861630f, 0.05220536f, -0.05572382f, 0.00965500f, 
    0.30192223f, 0.03286566f, 0.09589198f, 0.04846492f, -0.06969874f, -0.08296178f, -0.02653820f, 0.05094922f, 
    -0.00572658f, -0.08140136f, -0.03388576f, 0.00388599f, 0.11240194f, -0.10034614f, 0.01033410f, -0.05916470f, 
    0.03454177f, 0.06356404f, 0.05928574f, 0.08879256f, -0.01662341f, 0.21077147f, 0.07883628f, -0.02926634f, 
    0.09400814f, 0.12881413f, -0.09836954f, -0.07768980f, -0.13595794f, 0.01418254f, 0.02334155f, -0.07515185f, 
    0.02827059f, -0.00052743f, -0.05439675f, -0.00092167f, 0.03551853f, 0.07631531f, -0.00817986f, -0.04350977f, 
    0.10700071f, -0.04558322f, 0.13627169f, 0.04855459f, 0.06250510f, -0.11201455f, 0.00258173f, -0.07540506f, 
    0.07793546f, 0.01948180f, 0.01901931f, 0.04367046f, -0.02644654f, 0.00966556f, 0.06772646f, 0.08598962f, 
    0.06874514f, 0.06193895f, 0.04209286f, 0.02808271f, 0.48914963f, 0.04445969f, 0.12527953f, -0.03372836f, 
    0.00418151f, -0.01021170f, 0.04370601f, 0.04268269f, 0.07532346f, -0.02985339f, 0.01011814f, 0.04683710f, 
    -0.05996270f, -0.08493150f, 0.03894150f, -0.07037097f, 0.05186110f, -0.00104273f, 0.03051130f, 0.09606708f, 
    -0.25740206f, 0.05996517f, -0.16922344f, -0.23473138f, 0.04691198f, 0.11842876f, 0.04854068f, 0.00370385f, 
    -0.07157048f, -0.02588397f, 0.09529191f, -0.04610783f, -0.04229312f, 0.05618886f, -0.01818446f, 0.03029266f, 
    -0.07164551f, -0.11320911f, 0.02591683f, -0.00133676f, -0.00535395f, 0.15996391f, 0.01362750f, 0.16018057f, 
    -0.17520526f, 0.08331431f, -0.07937080f, -0.02951395f, 0.03024966f, -0.06126937f, -0.04638987f, 0.06924789f, 
    0.05489371f, 0.00011858f, 0.02965308f, -0.07723976f, -0.04171854f, -0.02374497f, -0.02177879f, 0.00483184f, 
    -0.07213125f, 0.18194732f, 0.12934765f, 0.26658276f, -0.05059396f, 0.14066230f, -0.04066999f, 0.13892548f, 
    0.11256710f, 0.07463946f, -0.01548036f, -0.00111235f, -0.03202364f, -0.02075624f, -0.09656277f, 0.01191247f, 
    -0.03636501f, -0.10975391f, 0.12564054f, -0.05723707f, -0.19386351f, 0.11080689f, -0.08449566f, 0.08341647f, 
    -0.07481286f, 0.16794857f, -0.00821454f, 0.00027795f, 0.06321557f, -0.03393964f, -0.04619642f, -0.01996542f, 
    0.12531112f, -0.02882806f, 0.08087828f, 0.01124562f, 0.06259286f, -0.11439077f, 0.14322788f, 0.03210340f, 
    0.07196555f, -0.06597210f, -0.10763010f, -0.10954840f, -0.10306342f, 0.08925065f, -0.03077671f, 0.12350635f, 
    0.03636610f, 0.06245705f, 0.11007052f, 0.00893617f, 0.15123658f, -0.07520204f, -0.03645733f, -0.04577429f, 
    -0.07538120f, -0.03058516f, -0.13709643f, -0.00830541f, -0.12721802f, -0.00893013f, 0.01866222f, 0.09101474f, 
    0.08485162f, -0.07104203f, -0.13255593f, -0.08135651f, -0.04308648f, -0.00669812f, 0.01640102f, -0.00106018f, 
    -0.01357126f, 0.00007576f, 0.04420770f, -0.06085813f, -0.01217497f, 0.09588585f, 0.06366430f, -0.06981204f, 
    0.13341437f, 0.00951154f, 0.15311040f, 0.09389731f, -0.06521045f, 0.09498301f, 0.08264858f, 0.04177721f, 
    -0.01172599f, -0.01261878f, 0.01778950f, 0.04084524f, -0.05332256f, -0.01350049f, 0.04327653f, 0.06700803f, 
    -0.07634622f, -0.11072913f, -0.04113019f, -0.01720317f, 0.00683373f, 0.04065977f, 0.08273749f, 0.13609427f, 
    0.10932009f, -0.06278118f, -0.09987649f, -0.08007319f, -0.00873146f, -0.05751484f, 0.09035404f, 0.08693067f, 
    0.02971387f, 0.01487299f, 0.11536128f, 0.00631393f, -0.04657921f, 0.06292865f, -0.00129032f, 0.09134417f, 
    0.39724833f, 0.34414935f, -0.10239579f, 0.14963117f, -0.11604534f, -0.09679149f, 0.00180907f, -0.07702815f, 
    -0.11656793f, 0.14080605f, -0.03973776f, 0.00969013f, 0.05258977f, 0.01562202f, -0.04458435f, 0.13985960f, 
    0.00670093f, -0.00108616f, -0.04592710f, -0.06977620f, 0.34155560f, 0.30433887f, 0.13810596f, 0.26729617f, 
    0.27170825f, -0.03292060f, 0.02208049f, -0.03308456f, -0.04995583f, 0.07826370f, 0.01172743f, -0.15568140f, 
    0.00418144f, -0.06827191f, 0.05709023f, 0.04704738f, 0.00842981f, -0.05562191f, 0.03476463f, 0.03675424f, 
    -0.03043337f, 0.03219788f, -0.00320538f, -0.03579927f, -0.00570964f, 0.04492532f, -0.10932346f, -0.04619715f, 
    -0.02766803f, -0.02191861f, -0.04087528f, -0.01625707f, 0.03454849f, -0.02881423f, 0.04089439f, -0.03451928f, 
    0.06185464f, 0.03375018f, 0.07456184f, -0.03955995f, 0.04799091f, 0.12708938f, 0.03063161f, 0.14099188f, 
    -0.15137866f, -0.00206870f, -0.10024893f, 0.06761684f, 0.11367774f, 0.10646992f, 0.03363835f, 0.01883130f, 
    0.07937042f, 0.08943108f, 0.01706289f, 0.01316130f, 0.09915506f, -0.12335889f, -0.06631373f, 0.03135163f, 
    -0.31098229f, 0.07874291f, -0.19270921f, -0.30056041f, 0.04400202f, -0.00983173f, 0.15331441f, -0.01726685f, 
    -0.01233249f, -0.12494352f, 0.14047804f, 0.01726082f, 0.08739303f, 0.06733559f, 0.08977310f, 0.03705477f, 
    0.12330141f, -0.01283302f, 0.07042231f, -0.07621471f, 0.00703136f, -0.08094380f, -0.02563380f, 0.00438323f, 
    0.16373965f, 0.06907092f, -0.03881727f, -0.06018216f, -0.00980099f, 0.01873402f, 0.01358602f, 0.10164112f, 
    -0.04321394f, -0.09125553f, 0.03747016f, 0.02907706f, -0.00003985f, 0.10311633f, 0.16803072f, 0.04010710f, 
    0.13313776f, 0.06135785f, -0.18817323f, -0.17237481f, -0.05368925f, 0.03496358f, -0.04521955f, -0.00367241f, 
    -0.06776251f, 0.04628949f, -0.07487801f, 0.01936178f, -0.01115881f, -0.10115366f, -0.06857267f, -0.02391839f, 
    -0.01406140f, 0.01377921f, 0.00495968f, -0.04649825f, -0.42513728f, 0.09166452f, -0.17784421f, -0.25839582f, 
    -0.01338404f, 0.12741415f, 0.08341262f, 0.17320919f, 0.01679693f, -0.08957661f, 0.02207854f, 0.00134309f, 
    0.06250592f, 0.09798114f, 0.01457901f, 0.10101194f, 0.15191270f, 0.03885988f, -0.02353331f, -0.00247230f, 
    -0.02809771f, -0.04805630f, -0.02287841f, -0.05122234f, 0.00861519f, -0.02275952f, 0.03184118f, -0.00899014f, 
    -0.03219861f, 0.01490786f, 0.02022428f, 0.04033020f, 0.00130788f, -0.05143704f, 0.01749014f, -0.04308941f, 
    0.00401662f, -0.02598586f, 0.01108388f, -0.02521095f, -0.05226668f, -0.04364099f, 0.01174326f, 0.04873599f, 
    0.00350426f, -0.04859706f, -0.05100707f, 0.03084149f, -0.03520749f, 0.04285021f, 0.03208044f, 0.04061847f, 
    0.00967847f, -0.03024270f, -0.05839169f, 0.00370656f, 0.02459328f, -0.00077303f, 0.01623763f, 0.01205033f, 
    -0.05959175f, 0.03700002f, 0.02472239f, -0.01535357f, -0.01583942f, 0.03504026f, -0.00423461f, 0.00550069f, 
    0.01636980f, 0.02241189f, -0.01256275f, 0.03386972f, 0.00936551f, 0.05102661f, -0.02506029f, -0.00920282f, 
    0.00970836f, -0.06143351f, -0.03824242f, -0.03075876f, -0.04786293f, 0.02985126f, -0.06105421f, 0.01038849f, 
    -0.03803833f, -0.04688282f, 0.01204836f, -0.00966595f, 0.03301969f, 0.01954043f, -0.05158532f, -0.02835280f, 
    -0.01165743f, 0.05184795f, 0.01971149f, -0.05472209f, 0.00039883f, 0.00783196f, 0.03066140f, -0.00948160f, 
    -0.02730844f, 0.02763499f, 0.03455357f, 0.03079493f, 0.01867150f, 0.01380221f, 0.04794587f, 0.00750552f, 
    -0.02579997f, 0.01425934f, 0.02289245f, -0.00465577f, -0.02480146f, -0.06276339f, 0.03520137f, 0.01944533f, 
    -0.02944007f, 0.04270393f, 0.03053955f, -0.06642848f, 0.03210437f, -0.04519433f, -0.00802743f, 0.01838772f, 
    0.01479780f, -0.02065868f, -0.00133872f, 0.00142604f, -0.00285513f, -0.01202835f, -0.06227715f, -0.01158643f, 
    -0.04216656f, 0.00043345f, 0.03736957f, 0.02623196f, -0.00335636f, 0.03796942f, -0.05120119f, 0.01846785f, 
    -0.03881370f, 0.04943496f, -0.01754397f, 0.02713671f, 0.04342369f, 0.03573827f, 0.02018435f, -0.02509402f, 
    0.00083796f, -0.03345853f, -0.03147115f, -0.01292317f, -0.01757827f, -0.06549510f, 0.03709136f, 0.02338143f, 
    0.01013556f, 0.03910905f, -0.04414588f, 0.01791131f, 0.01530188f, 0.03822706f, 0.01929940f, -0.01773342f, 
    -0.05871301f, 0.04703758f, -0.00819543f, -0.05084636f, 0.04459325f, -0.02885995f, 0.03651733f, 0.00447649f, 
    -0.03400573f, -0.03243034f, 0.03682429f, -0.00255620f, 0.01398031f, -0.01739702f, 0.00376986f, 0.02055942f, 
    0.00757095f, -0.02105490f, -0.04399703f, -0.03702839f, 0.02483650f, 0.00466703f, -0.03858046f, 0.00393439f, 
    0.03322018f, 0.04540761f, -0.01344738f, 0.04862029f, 0.01211206f, -0.02826878f, 0.01749201f, -0.02113249f, 
    0.04565302f, 0.03921811f, 0.00319831f, 0.04878798f, -0.02885998f, 0.04373281f, -0.02204605f, -0.00465574f, 
    -0.01549110f, 0.01927583f, -0.01065502f, -0.00891141f, 0.03476055f, 0.02977638f, -0.01252394f, 0.04558094f, 
    0.01760216f, -0.04535931f, 0.02034274f, -0.03530232f, -0.05960861f, 0.00692378f, -0.06317195f, 0.01525159f, 
    -0.03548469f, 0.03282448f, 0.03003043f, -0.04558589f, -0.03304115f, 0.03634052f, -0.01871034f, -0.02903895f, 
    -0.00132655f, -0.04539910f, -0.05337490f, -0.01399557f, -0.00008648f, 0.04065364f, -0.04511197f, -0.04967904f, 
    0.00759838f, -0.03769302f, -0.03105544f, 0.01462529f, -0.00438798f, -0.04888206f, -0.04142203f, 0.03305000f, 
    0.03423392f, -0.04558111f, -0.01238667f, -0.04770258f, -0.02413787f, 0.02400852f, -0.03072435f, -0.04525300f, 
    -0.00591782f, 0.00421887f, 0.02077219f, -0.02753727f, -0.04958478f, 0.01014109f, -0.01987636f, -0.05473998f, 
    0.00339551f, 0.04327735f, 0.02556904f, -0.00756741f, 0.00852041f, -0.01146494f, 0.01254943f, 0.00276941f, 
    0.01942448f, 0.04604583f, 0.00871269f, -0.05040315f, -0.06617782f, -0.05128853f, 0.03983713f, 0.02836120f, 
    -0.01206844f, 0.03913106f, -0.02739829f, -0.02862156f, -0.05618210f, -0.02931006f, 0.00315937f, 0.01454972f, 
    0.02847915f, -0.05178886f, 0.03937003f, 0.04282023f, -0.03827108f, -0.02688725f, -0.05856735f, 0.02092776f, 
    0.02263897f, 0.03095296f, -0.04876084f, -0.04796663f, 0.04063550f, -0.04162038f, -0.01424835f, -0.04951203f, 
    -0.03386940f, 0.00348222f, 0.01908233f, -0.03538634f, -0.03749785f, 0.02177354f, -0.06394354f, 0.03116064f, 
    0.00913388f, -0.00906408f, 0.02990754f, -0.05001402f, -0.02851789f, 0.02887569f, -0.03797412f, -0.03726483f, 
    -0.03169751f, 0.02656070f, 0.04070545f, -0.03622741f, 0.03677839f, -0.02862827f, 0.04613585f, -0.00439186f, 
    -0.00745862f, -0.00691680f, 0.03442644f, -0.02871797f, 0.01926994f, -0.03484264f, -0.00068964f, 0.02258287f, 
    0.02520040f, 0.00252503f, 0.04425810f, -0.06263793f, 0.04669587f, -0.01097719f, -0.01870259f, -0.00126647f, 
    0.23268729f, 0.04004426f, 0.10898585f, 0.05133406f, -0.00670192f, -0.08085222f, -0.04260031f, 0.03756215f, 
    0.10791240f, 0.01260186f, 0.03364965f, -0.06137894f, -0.01361515f, 0.08451895f, -0.00071152f, 0.06931932f, 
    0.06506880f, 0.04046747f, 0.01696564f, 0.05943974f, 0.21266618f, -0.16635238f, -0.19345118f, 0.03084886f, 
    0.04812252f, -0.00049112f, 0.05384486f, -0.11273588f, -0.08564111f, 0.02318659f, 0.02578764f, 0.08985824f, 
    0.06722081f, 0.03980353f, -0.04575562f, 0.06240724f, -0.05161451f, -0.00359899f, 0.02133800f, 0.03049065f, 
    0.28031808f, 0.07159464f, -0.03606902f, 0.04002150f, 0.12902084f, -0.00229671f, 0.06587081f, -0.06064970f, 
    -0.13805383f, -0.05744740f, -0.03915248f, 0.04719641f, 0.11807122f, 0.06687970f, 0.05315694f, 0.09050723f, 
    -0.00411215f, 0.02539089f, -0.04900408f, 0.04191086f, 0.10551860f, 0.05389784f, -0.05905426f, -0.01698728f, 
    0.02922729f, -0.02174996f, -0.01316379f, -0.08007425f, 0.02033238f, 0.05306032f, 0.08758308f, 0.08915927f, 
    0.06716777f, 0.01854277f, 0.03295955f, -0.00701502f, -0.07233191f, 0.03848162f, 0.03123511f, 0.02595409f, 
    0.18637909f, 0.11430340f, 0.05952438f, 0.04242663f, 0.13717045f, 0.00731066f, -0.01241216f, -0.08864181f, 
    -0.03986990f, -0.00023878f, 0.06196186f, -0.00270640f, -0.10052061f, 0.06284289f, 0.03168460f, 0.07625916f, 
    0.06432156f, -0.03559268f, -0.06622302f, -0.03073918f, 0.05322306f, 0.00438451f, 0.04314611f, -0.16195405f, 
    -0.12193185f, 0.03103741f, -0.07569079f, -0.05103455f, 0.03039429f, -0.04857058f, -0.06199390f, 0.02801343f, 
    0.00812508f, 0.03906621f, -0.03462465f, 0.11468736f, 0.00966128f, -0.04603136f, -0.03326675f, 0.11479671f, 
    -0.02704819f, -0.16571645f, 0.07220478f, -0.00233741f, -0.02304329f, 0.04839486f, -0.02139328f, 0.01439944f, 
    0.06829124f, 0.03306780f, -0.01399194f, -0.00727169f, 0.03465271f, 0.04769574f, -0.06567665f, 0.00793037f, 
    -0.06343187f, 0.02778276f, 0.10552040f, 0.09772685f, -0.08726570f, -0.03216640f, 0.16204469f, -0.05117891f, 
    -0.15628104f, 0.11297438f, 0.01538004f, -0.01228106f, 0.07281358f, 0.02244292f, -0.01698814f, 0.07875893f, 
    0.05413093f, -0.02195078f, -0.03771274f, 0.04932706f, -0.04001221f, -0.03651060f, 0.07492154f, -0.09112067f, 
    -0.18201633f, -0.10238937f, -0.00556658f, -0.21988429f, 0.06663513f, 0.06347752f, -0.05336631f, -0.01460303f, 
    0.14858712f, -0.04609916f, 0.02839612f, -0.07191500f, 0.07956726f, 0.01011991f, -0.00683821f, -0.00118555f, 
    0.02342561f, 0.02552053f, 0.06614044f, -0.03020630f, 0.05170947f, -0.03105165f, -0.14831407f, -0.03812417f, 
    0.08496970f, 0.11199743f, -0.09498727f, -0.05480060f, -0.08097029f, -0.07500011f, 0.01851015f, 0.12020130f, 
    0.07380819f, 0.06836540f, 0.03806417f, 0.05644542f, 0.06014359f, 0.02340836f, -0.11131491f, -0.12233581f, 
    0.04292752f, -0.26201504f, -0.04578502f, 0.09056943f, -0.04331107f, 0.09518559f, 0.07246754f, -0.04604251f, 
    0.09701172f, -0.03724191f, -0.01696162f, 0.01298710f, 0.02280083f, 0.05621377f, -0.01725377f, 0.00192707f, 
    0.01297942f, 0.02805290f, -0.04682736f, 0.05243322f, 0.24241522f, 0.13059393f, 0.04386043f, 0.04374601f, 
    0.19123307f, 0.07003189f, 0.00843060f, -0.13743487f, -0.07777602f, 0.00807629f, 0.03927018f, -0.00030474f, 
    0.06927198f, -0.01895342f, -0.02183978f, -0.06538127f, -0.02666029f, 0.09488840f, -0.01924866f, -0.02545472f, 
    0.24794343f, -0.12013189f, 0.21765324f, 0.06133141f, -0.12907495f, 0.02253079f, -0.04151635f, 0.05516329f, 
    -0.03814634f, 0.04217159f, 0.03119845f, -0.08126446f, -0.10904764f, -0.04249699f, -0.10100550f, -0.02632914f, 
    0.03314974f, 0.01729195f, -0.03763010f, 0.07857997f, -0.20975760f, -0.10219935f, 0.21090946f, -0.15839225f, 
    -0.06790590f, 0.07405895f, 0.03283659f, -0.04846202f, 0.02909103f, 0.00510620f, 0.05842318f, -0.00346232f, 
    0.09293405f, 0.00087694f, -0.01701729f, -0.03043685f, 0.03748945f, -0.12744829f, -0.08619148f, -0.10350113f, 
    0.09369246f, -0.05527581f, 0.13626495f, -0.00010063f, -0.06103652f, -0.05857059f, 0.10238121f, -0.00456139f, 
    -0.01208036f, 0.01548029f, 0.02867478f, -0.05698906f, 0.01294670f, 0.12929550f, -0.01532043f, 0.04922531f, 
    -0.00997647f, 0.01276152f, 0.08536936f, 0.02658002f, 0.37339711f, 0.00894310f, 0.09474473f, 0.05453312f, 
    0.07276423f, -0.07401418f, 0.01357413f, -0.05234919f, 0.08105097f, 0.13700908f, 0.04766865f, 0.01479016f, 
    -0.01106994f, -0.03665129f, 0.01134648f, 0.05704361f, -0.04929309f, 0.02591302f, -0.01766159f, -0.01474920f, 
    -0.04985454f, 0.03990972f, 0.11832286f, 0.03988000f, 0.07116095f, 0.04748441f, 0.03823892f, 0.09689114f, 
    -0.01402112f, -0.05464014f, -0.00739398f, 0.03632987f, 0.01391746f, 0.06400537f, -0.03529561f, 0.05988454f, 
    0.09760254f, -0.00607121f, -0.03159509f, 0.04684893f, 0.06546148f, -0.16467427f, 0.06666071f, -0.19417994f, 
    0.15444183f, -0.05602402f, 0.01683387f, 0.03329263f, 0.04774769f, 0.10026174f, 0.11644874f, 0.02464767f, 
    0.02864413f, 0.11105031f, 0.11547539f, 0.05911520f, 0.00786442f, 0.05268436f, -0.02891737f, 0.05411324f, 
    -0.27738973f, -0.30685061f, -0.01705653f, 0.06647574f, 0.02459095f, 0.06247127f, 0.07517614f, -0.15695278f, 
    0.02284738f, -0.04282171f, -0.01697729f, 0.06071646f, 0.03203921f, 0.03617535f, 0.06046746f, 0.04358397f, 
    0.12727690f, 0.14065105f, -0.03495035f, 0.04750049f, -0.14044254f, -0.00017621f, 0.01144118f, -0.10251536f, 
    0.24760284f, 0.03652605f, -0.05416366f, -0.01415292f, -0.04804019f, 0.01711329f, -0.06699292f, -0.08329999f, 
    -0.00659719f, 0.10081445f, -0.04633530f, 0.01807814f, -0.07417779f, 0.16962305f, -0.14578772f, -0.06895712f, 
    -0.08821544f, -0.00021615f, -0.09262615f, 0.17295191f, 0.10956065f, 0.07055779f, -0.02876630f, -0.05422218f, 
    0.08294279f, 0.05547183f, 0.03999183f, 0.09157138f, -0.06077049f, -0.09765019f, -0.01461437f, 0.17231689f, 
    0.09345909f, 0.09978572f, -0.04542346f, 0.06783503f, -0.25857249f, 0.28858212f, -0.13257611f, -0.21028791f, 
    0.06849135f, 0.08595511f, -0.05395252f, -0.01099009f, 0.03115883f, 0.02745637f, 0.01307740f, -0.03905314f, 
    0.01397012f, 0.11915132f, 0.09975538f, -0.02291986f, -0.03105696f, -0.09585148f, -0.11772373f, 0.11063994f, 
    -0.02236032f, -0.03942543f, 0.00990109f, 0.00101930f, 0.10286678f, 0.05254422f, 0.05931437f, -0.04876040f, 
    -0.00160669f, -0.08090781f, 0.06691289f, -0.07658970f, 0.05313464f, 0.06063619f, 0.05474611f, 0.03944800f, 
    0.13601345f, 0.05199555f, 0.03978143f, -0.06990693f, -0.09599563f, -0.00979174f, -0.12608308f, -0.14062984f, 
    0.09015430f, -0.12883525f, -0.09068923f, 0.08784210f, 0.00281933f, 0.14845556f, -0.00657583f, -0.02059448f, 
    0.04321328f, -0.03527468f, -0.02215891f, 0.00267539f, 0.06723267f, -0.08592284f, 0.03295545f, -0.11989778f, 
    -0.44674158f, 0.06672000f, 0.00679435f, 0.02689691f, -0.12758695f, 0.12330336f, 0.06843022f, -0.07769901f, 
    0.01411175f, -0.07600363f, 0.05086890f, 0.02213678f, 0.03120694f, 0.01178454f, 0.01094006f, -0.10138794f, 
    0.08638412f, -0.02548883f, 0.15317211f, 0.05195891f, -0.03389883f, 0.05936668f, 0.05496575f, -0.09246760f, 
    -0.23468718f, 0.13845302f, 0.08584129f, 0.03981911f, -0.04526870f, 0.06986413f, 0.05902473f, 0.05042129f, 
    0.05217218f, 0.19040897f, 0.07026039f, 0.03412971f, -0.06237909f, 0.05558352f, -0.15508251f, -0.05964131f, 
    -0.06459998f, 0.08445013f, 0.07979895f, -0.09089746f, 0.11092566f, 0.03828856f, -0.07689650f, 0.05439999f, 
    -0.01763640f, 0.05641829f, 0.06372747f, 0.13388792f, 0.11435041f, 0.02711030f, 0.10878132f, 0.09968666f, 
    0.03618197f, -0.03513298f, -0.06134759f, 0.05065557f, 0.24362060f, -0.04041874f, 0.01245676f, -0.02382423f, 
    -0.01952612f, 0.17297548f, 0.23126960f, -0.14664683f, -0.08180965f, 0.03094042f, 0.02320324f, -0.00816265f, 
    -0.04462450f, -0.02458770f, 0.06153983f, 0.03281613f, 0.00686747f, 0.11901490f, 0.05899987f, -0.08859157f, 
    0.07701013f, -0.04242918f, -0.00781694f, 0.07900105f, -0.02336543f, -0.00857191f, -0.02200981f, 0.09256896f, 
    -0.07205337f, 0.00199920f, -0.01818869f, -0.01657555f, 0.07005488f, 0.03444717f, -0.03138942f, 0.06415645f, 
    -0.07239033f, 0.01356560f, -0.02821238f, -0.03391699f, -0.01787343f, 0.07981988f, -0.06875367f, -0.20828040f, 
    -0.00633890f, -0.10158031f, 0.02414052f, 0.05599803f, 0.00323830f, -0.02180524f, 0.09835158f, -0.02547937f, 
    0.10872058f, 0.10669718f, 0.03994333f, -0.03356764f, -0.03696706f, -0.06550498f, -0.07471430f, 0.02443722f, 
    -0.17627935f, 0.06784339f, 0.15315425f, 0.05040574f, 0.10497203f, 0.05421460f, -0.07685872f, 0.07945557f, 
    0.05471003f, -0.04386095f, 0.11930668f, 0.08323059f, -0.02247791f, 0.07410048f, 0.07760115f, -0.05273943f, 
    0.01949617f, -0.07261499f, 0.06543361f, 0.12893429f, 0.22541969f, -0.05992235f, -0.14725532f, 0.04769331f, 
    0.04831792f, -0.00947507f, 0.04948930f, -0.11425582f, -0.04718738f, -0.03666168f, 0.05061426f, -0.05452148f, 
    -0.04972134f, -0.12796555f, 0.07737242f, -0.01351303f, -0.09119579f, -0.06317684f, -0.00396836f, -0.08453618f, 
    0.01038092f, 0.00176407f, 0.00095521f, -0.02823617f, 0.00626748f, 0.03262718f, 0.03087186f, -0.01999538f, 
    0.03067610f, -0.05932159f, 0.03682584f, -0.04300759f, 0.01044376f, 0.02220789f, 0.03596453f, -0.05622427f, 
    0.01028557f, 0.03636663f, -0.02701541f, -0.00970326f, -0.04513022f, 0.01710624f, 0.01821241f, -0.00429769f, 
    -0.05169505f, -0.03668723f, 0.02264011f, -0.01589388f, -0.05060750f, -0.02717396f, -0.01496042f, 0.02811950f, 
    -0.05583615f, -0.05519937f, -0.06271598f, -0.03529441f, 0.02735363f, -0.01503770f, 0.02013084f, -0.04492039f, 
    0.03406871f, 0.00734928f, 0.02640261f, -0.04917503f, 0.03598026f, -0.02541153f, -0.05323485f, 0.01821589f, 
    -0.00874056f, -0.00696505f, -0.06057650f, 0.00660402f, 0.02748971f, 0.02207845f, -0.02149743f, -0.01172431f, 
    -0.05425027f, 0.05045209f, 0.03195130f, 0.04797146f, -0.00027525f, -0.06245813f, -0.03998579f, -0.05274487f, 
    0.04486732f, 0.02520072f, -0.02437455f, 0.02307411f, -0.00787816f, -0.03247581f, 0.04160189f, -0.05744495f, 
    -0.00222682f, 0.01531538f, -0.05309488f, -0.02691359f, -0.02413373f, 0.01256676f, -0.05945829f, 0.01342709f, 
    -0.02116111f, 0.01714095f, -0.02357305f, -0.05310958f, -0.03091566f, -0.01962558f, -0.00626761f, -0.05004868f, 
    -0.04492593f, 0.04820042f, 0.02819152f, -0.04296958f, 0.04475604f, -0.05424497f, -0.04014782f, -0.02346784f, 
    -0.02800341f, 0.00552860f, 0.05094333f, 0.04004728f, -0.00469206f, 0.04215757f, -0.00350975f, 0.00713160f, 
    -0.01894587f, 0.01098996f, 0.03238563f, -0.00679226f, 0.00643539f, -0.04622088f, -0.02893163f, -0.02544451f, 
    0.00757468f, -0.03039315f, 0.03706069f, -0.03889143f, 0.01511385f, -0.06212701f, -0.04524823f, 0.02217579f, 
    -0.02950637f, 0.02534082f, 0.03456556f, -0.01396307f, -0.04093439f, 0.01857527f, -0.02454203f, -0.00376519f, 
    -0.04275007f, 0.00359434f, 0.00407171f, 0.03826084f, -0.05553729f, -0.05154072f, -0.03459774f, 0.03088128f, 
    -0.06039214f, 0.03586959f, 0.02795433f, 0.00926949f, 0.01672518f, -0.00983993f, -0.06067583f, 0.00699605f, 
    -0.02008496f, 0.00234828f, -0.02503688f, 0.01042763f, -0.03805833f, -0.00080224f, -0.01337722f, 0.04236797f, 
    -0.01368859f, -0.03220210f, -0.01877865f, 0.00747137f, 0.04640989f, 0.00282058f, -0.00067217f, 0.01409180f, 
    0.04592497f, 0.01554528f, -0.04049426f, 0.00602098f, 0.04045325f, 0.03571951f, -0.01850435f, -0.03315455f, 
    0.02105758f, 0.01108606f, 0.00504883f, -0.04953969f, 0.01843787f, 0.02948315f, -0.04510014f, 0.02034501f, 
    0.03993986f, -0.04065393f, 0.03173249f, 0.04774209f, -0.00716633f, -0.03692750f, 0.04413404f, -0.04950319f, 
    -0.05350783f, 0.01266233f, 0.04124353f, -0.02552083f, 0.01031983f, 0.00488596f, -0.03117825f, 0.01439325f, 
    0.04664126f, -0.02562581f, 0.01221154f, 0.02359477f, 0.04554304f, 0.02470455f, -0.05665061f, -0.04228988f, 
    0.02838243f, -0.04865276f, -0.04939353f, 0.01322139f, 0.02716813f, -0.03735635f, -0.04843293f, -0.04050025f, 
    -0.00131009f, 0.01510566f, 0.00815581f, -0.03253501f, -0.01300981f, 0.03081718f, -0.04813418f, -0.00074961f, 
    -0.01099243f, 0.04054276f, -0.00434233f, 0.04839285f, -0.05090847f, -0.02755118f, 0.02653257f, -0.04234970f, 
    0.02443817f, -0.02780176f, 0.03409299f, 0.00250425f, -0.03563716f, -0.03893144f, 0.02010084f, -0.03640639f, 
    -0.00759966f, -0.00713810f, -0.00943995f, 0.04093155f, 0.04422137f, 0.00691755f, 0.01223419f, -0.05093016f, 
    0.00160961f, 0.05816727f, -0.04738768f, -0.02123150f, -0.04573357f, 0.03802221f, 0.00783193f, -0.04424754f, 
    -0.03924676f, 0.02419386f, -0.03544923f, 0.03840351f, 0.01860122f, 0.02126456f, 0.03177112f, -0.05053633f, 
    -0.04614567f, 0.04347724f, 0.04765347f, 0.01259844f, -0.02025773f, -0.06377579f, 0.03920355f, 0.01818179f, 
    -0.01488262f, -0.02665095f, 0.00334155f, 0.00397460f, -0.01264839f, 0.03234562f, 0.00239526f, 0.03470236f, 
    0.01667776f, 0.02379415f, 0.01284538f, 0.01344998f, 0.01744273f, -0.02091771f, -0.05004224f, 0.04859623f, 
    0.03601228f, -0.01728225f, -0.05157400f, -0.00854006f, -0.04543964f, -0.00477929f, 0.04309711f, -0.04688301f, 
    -0.02706769f, -0.00558609f, 0.03994995f, 0.03587080f, -0.06114890f, -0.00184158f, 0.02607091f, -0.02749844f, 
    -0.02658641f, -0.05069021f, 0.03419546f, -0.00250675f, 0.01322099f, -0.04172742f, 0.02619520f, -0.00414544f, 
    -0.00361050f, -0.03171927f, -0.03569201f, -0.03372874f, 0.00621529f, -0.01110337f, 0.04588853f, 0.00316404f, 
    0.04581981f, -0.05615030f, -0.04438622f, -0.03726127f, -0.06084479f, 0.02866796f, 0.00862504f, 0.01010720f, 
    -0.03368943f, -0.06884754f, -0.12385933f, 0.12934592f, 0.01008148f, 0.12303976f, -0.02431367f, -0.05888750f, 
    0.01457414f, -0.04799182f, -0.01976107f, 0.12899606f, -0.02221627f, 0.01779005f, 0.06083614f, -0.04494106f, 
    0.03906876f, -0.00371340f, 0.02158425f, 0.02400986f, 0.06857382f, -0.27472299f, 0.07792979f, -0.00307400f, 
    -0.14724459f, -0.06625199f, -0.03553763f, -0.01256363f, -0.03411176f, 0.09549161f, 0.00828976f, 0.01492455f, 
    0.02262703f, 0.05495797f, 0.01900057f, -0.10474604f, -0.03086852f, 0.00228350f, 0.01421106f, 0.00471759f, 
    0.43903744f, -0.29279971f, 0.34963039f, 0.19357182f, 0.12009202f, 0.07094201f, -0.07001694f, 0.08169593f, 
    -0.09515969f, -0.02888294f, -0.00409544f, -0.03099963f, -0.02662978f, 0.02751654f, -0.00505283f, -0.00595387f, 
    -0.00832820f, 0.03962826f, 0.07563213f, -0.01893872f, 0.44007534f, 0.04783560f, -0.02750432f, 0.13345228f, 
    -0.15641072f, 0.00478793f, 0.03074702f, 0.09440611f, 0.01398979f, 0.01327214f, 0.07418142f, 0.06595340f, 
    0.07976227f, -0.11074797f, 0.00032883f, 0.06197776f, 0.00109243f, 0.04163923f, 0.06702457f, 0.10298379f, 
    -0.03461345f, -0.00295739f, 0.10602996f, -0.05882290f, -0.09614172f, 0.00053456f, 0.05313701f, 0.09694968f, 
    -0.00544598f, -0.02161329f, 0.10010859f, 0.03744115f, 0.02710488f, -0.01213018f, 0.02808011f, -0.00891588f, 
    0.09998923f, 0.02554118f, 0.04449020f, -0.04941582f, -0.14423172f, -0.22722717f, 0.10193207f, 0.15411623f, 
    0.01519952f, -0.11264443f, -0.03830777f, 0.05900548f, -0.01882818f, -0.06090941f, -0.04394792f, 0.01174073f, 
    -0.02116228f, -0.04628439f, 0.00627060f, -0.01102982f, -0.04174804f, 0.00153244f, -0.04853386f, -0.01082013f, 
    -0.37473074f, 0.01957228f, 0.07762017f, -0.02790131f, 0.02569062f, 0.07348043f, -0.07287630f, 0.04256289f, 
    -0.00465787f, 0.08001693f, 0.01532513f, -0.06032048f, 0.09031624f, -0.01258528f, 0.05742194f, -0.03557377f, 
    -0.06829198f, -0.11271089f, -0.04392547f, -0.08017997f, 0.13141891f, 0.21960142f, 0.01715712f, -0.08140988f, 
    0.07212432f, 0.02898334f, 0.00326872f, 0.05418506f, 0.07710805f, 0.06214792f, -0.01538484f, -0.00485187f, 
    -0.01765654f, -0.02049140f, -0.03260211f, 0.07849111f, 0.00576708f, 0.10738112f, 0.04411370f, -0.01839862f, 
    0.15247983f, -0.00609391f, 0.34454697f, -0.22931133f, 0.13515812f, -0.10812616f, -0.01986476f, -0.05335915f, 
    0.10203008f, 0.00266907f, -0.01432687f, -0.08235309f, 0.05519889f, 0.05624650f, 0.00761782f, 0.03142934f, 
    0.02767554f, 0.03874914f, 0.01928224f, -0.00634928f, 0.18186803f, -0.05027647f, 0.09510818f, 0.01330613f, 
    -0.04023501f, -0.08349417f, -0.06673362f, -0.04108224f, 0.02157833f, 0.05852522f, -0.14273666f, -0.08146315f, 
    -0.01160229f, -0.05514377f, -0.03316564f, -0.08552124f, -0.01929139f, -0.04356919f, 0.11284300f, -0.04779938f, 
    -0.06912730f, -0.27008879f, -0.06864800f, 0.09489074f, -0.06452248f, -0.07375254f, -0.04404840f, 0.05227707f, 
    -0.00482231f, 0.01806246f, 0.07154262f, 0.03266244f, -0.07422259f, -0.05359433f, -0.02048686f, 0.03448927f, 
    -0.02529631f, -0.05606324f, 0.05360135f, 0.07524073f, 0.19440843f, 0.18137151f, 0.10763525f, 0.20551398f, 
    0.07734785f, 0.12539265f, -0.00511565f, 0.08996820f, -0.13341096f, -0.07467119f, 0.02120055f, 0.05119791f, 
    -0.04098942f, 0.10256748f, 0.01007191f, 0.00672653f, 0.03699068f, 0.01009745f, 0.11638153f, -0.01601942f, 
    -0.04749878f, 0.00566062f, 0.05044305f, 0.00472352f, -0.08059450f, 0.17086023f, 0.06670484f, -0.00874999f, 
    -0.04608013f, 0.11466748f, 0.09156752f, 0.09613612f, 0.04497992f, 0.06337457f, 0.01307918f, 0.07435614f, 
    -0.01512756f, -0.00178413f, 0.03033583f, -0.02844466f, -0.05347328f, -0.21642219f, 0.12856862f, 0.19747281f, 
    0.01224183f, 0.06740902f, 0.06649734f, -0.00890425f, 0.07480139f, 0.11475120f, -0.03196906f, -0.03105598f, 
    0.04295429f, -0.01525353f, 0.03416009f, -0.01418542f, 0.05347442f, 0.03267689f, -0.02620222f, -0.00135921f, 
    0.02764445f, -0.12715375f, -0.09157452f, 0.04014594f, -0.00824810f, -0.06628061f, 0.09347979f, -0.03605745f, 
    0.03881101f, 0.01487257f, -0.11232113f, 0.02634063f, 0.03646391f, -0.06457669f, -0.03288465f, -0.04145144f, 
    -0.00569076f, 0.03687386f, -0.02101068f, -0.02199155f, -0.23639226f, 0.18894765f, 0.09641761f, -0.07977609f, 
    -0.05214428f, 0.08499121f, 0.11112683f, -0.00472637f, 0.01452979f, 0.00651082f, 0.11312155f, 0.12249947f, 
    0.06421154f, -0.00820558f, -0.00379870f, 0.06364034f, 0.04202935f, 0.02370967f, 0.01584392f, 0.02719503f, 
    0.07527329f, -0.11792213f, 0.07717784f, 0.11388570f, 0.01373961f, 0.06847701f, -0.06497787f, -0.07096925f, 
    0.01558677f, -0.02315130f, 0.01502152f, 0.04502174f, 0.03493699f, 0.03149188f, -0.03668667f, 0.02468475f, 
    -0.07506260f, 0.01622343f, -0.00149020f, -0.01778415f, -0.08308079f, -0.00509626f, -0.03184909f, 0.07325365f, 
    -0.10748269f, 0.09414725f, -0.03904344f, -0.02920552f, -0.01861997f, -0.02486051f, 0.07960093f, -0.11929225f, 
    0.03315080f, 0.06253301f, -0.01755200f, -0.11170628f, -0.04436264f, -0.02399212f, -0.07547074f, -0.04740533f, 
    0.28033638f, 0.05295722f, 0.31444633f, 0.12886022f, 0.06342494f, 0.00165723f, -0.09685455f, 0.10268447f, 
    -0.09898403f, -0.04631331f, 0.08606777f, -0.07645074f, -0.04326354f, -0.02291903f, -0.07444153f, 0.02419233f, 
    -0.10091803f, -0.04299155f, 0.14162789f, -0.04734773f, 0.19010064f, 0.06001044f, 0.11957624f, 0.14873336f, 
    -0.17938417f, -0.00972277f, -0.03990533f, 0.17336279f, 0.00066261f, -0.01652402f, 0.15260391f, 0.08850461f, 
    -0.02700793f, -0.03965513f, 0.05503362f, 0.01865628f, -0.04611234f, -0.02169674f, 0.09352565f, 0.00281330f, 
    -0.22627272f, 0.22607577f, 0.06781266f, 0.06801566f, -0.10530654f, -0.08039222f, -0.04078900f, 0.07856910f, 
    -0.09111208f, -0.05269981f, 0.03304863f, -0.05371848f, 0.03414469f, -0.00093988f, 0.04045485f, 0.02014465f, 
    0.08482864f, -0.04348496f, 0.02721659f, -0.00402406f, -0.04571300f, -0.12563837f, 0.10050799f, 0.28333080f, 
    -0.08024702f, -0.10115230f, 0.05412204f, 0.08067278f, 0.03285366f, 0.08044898f, -0.05401079f, -0.05610894f, 
    0.05106494f, 0.06672319f, 0.01774270f, -0.02463477f, -0.03603739f, 0.02991328f, -0.02067692f, -0.00357665f, 
    -0.23985533f, -0.07750371f, 0.06472700f, 0.01546002f, -0.04690834f, 0.03286130f, -0.11220804f, 0.00815905f, 
    -0.02930858f, 0.05059367f, -0.02142626f, 0.06001375f, 0.02676732f, -0.07661211f, 0.01671949f, -0.10891453f, 
    -0.08563554f, -0.04200179f, 0.01369408f, -0.04017805f, -0.01030162f, 0.28388503f, 0.06621399f, 0.12384732f, 
    -0.05998512f, 0.12766089f, 0.02155933f, 0.00479628f, -0.00234511f, 0.01161097f, 0.00494190f, 0.09166611f, 
    0.09545225f, 0.00453412f, 0.08171860f, 0.04056773f, 0.02133607f, 0.03996373f, 0.09245124f, -0.00423127f, 
    0.43305761f, -0.02143734f, 0.18586923f, -0.19341946f, 0.13359301f, -0.22731444f, -0.01950214f, -0.04879565f, 
    0.20180212f, 0.13572977f, -0.02318273f, -0.02369934f, -0.02183624f, 0.09432253f, 0.02270992f, 0.06206636f, 
    0.01986783f, 0.07837749f, -0.01635838f, -0.02409766f, 0.35514450f, -0.09290577f, 0.00594182f, 0.19184080f, 
    0.33598566f, -0.18760005f, -0.04741397f, 0.03997539f, 0.06770466f, 0.01938239f, -0.13219123f, -0.09189352f, 
    -0.06286050f, -0.00434640f, -0.03689786f, -0.02322083f, 0.00162727f, -0.02963877f, 0.09654079f, 0.04150442f, 
    -0.13456167f, -0.16296649f, 0.06728395f, 0.08154663f, -0.08852913f, -0.01783593f, -0.06179641f, -0.01538356f, 
    -0.01802211f, -0.06005293f, -0.00302489f, -0.02503324f, -0.04217375f, 0.04107253f, -0.09551071f, -0.07323768f, 
    -0.02508123f, 0.01572347f, -0.05355396f, -0.06028946f, 0.19204237f, 0.11299719f, 0.19090670f, 0.17703207f, 
    0.07900991f, -0.10288577f, -0.12322930f, 0.08502086f, -0.02566997f, -0.13629012f, 0.06221645f, 0.04220449f, 
    0.05741400f, -0.01384623f, -0.11807957f, 0.01260264f, -0.02968013f, -0.04195462f, 0.00718679f, 0.00446842f, 
    -0.16922030f, -0.00140517f, 0.05516711f, -0.00713891f, -0.21714145f, 0.11179788f, 0.04079150f, -0.08519191f, 
    -0.01705096f, -0.00812916f, 0.03514438f, 0.04175581f, 0.10172170f, -0.02996064f, 0.10123030f, -0.01816482f, 
    -0.05617053f, 0.09800449f, 0.12767844f, -0.03619507f, -0.14617571f, -0.00896090f, 0.20729114f, 0.18526483f, 
    0.02200639f, 0.13207234f, 0.02234304f, 0.01964661f, 0.05275164f, 0.19145451f, -0.10317686f, -0.05206380f, 
    0.07452578f, -0.04707423f, 0.01621713f, -0.05465755f, 0.04028321f, 0.03722799f, -0.08016562f, 0.00264078f, 
    0.23662467f, 0.03186061f, 0.00842497f, 0.09340566f, -0.13847230f, -0.10440697f, 0.13289267f, -0.06320762f, 
    0.03523568f, 0.05129804f, -0.10806192f, 0.03644849f, -0.00624176f, 0.05553391f, 0.01189491f, -0.00439268f, 
    -0.09744716f, 0.05759206f, -0.09736621f, -0.03673385f, -0.18646368f, 0.14894234f, 0.06315944f, -0.14350596f, 
    -0.12414363f, 0.02756257f, 0.00920856f, 0.12966722f, 0.00968746f, -0.01857213f, 0.06246284f, 0.13820753f, 
    0.05222229f, 0.05309750f, 0.01319991f, 0.07780518f, 0.04658948f, 0.01122026f, 0.04200786f, -0.00552161f, 
    -0.12219775f, 0.10171866f, -0.12017354f, -0.04921100f, -0.09363014f, 0.04320209f, -0.10427637f, -0.01846260f, 
    0.14008088f, -0.12360816f, -0.04843241f, 0.03112270f, -0.02775951f, 0.04793061f, 0.01810375f, 0.00065289f, 
    0.07412241f, 0.02776741f, 0.01109464f, 0.06011255f, 0.06854650f, -0.12485754f, -0.00862940f, 0.06909174f, 
    0.08282448f, -0.11820783f, -0.00800241f, -0.12537615f, 0.08761968f, 0.19494818f, -0.00184419f, 0.07739624f, 
    -0.03835807f, 0.05559234f, -0.02672545f, 0.06167632f, -0.04353438f, 0.01204395f, -0.14803863f, 0.04522675f, 
    -0.26505485f, -0.21096590f, 0.02262842f, 0.08683500f, 0.22360903f, 0.07401225f, 0.06460927f, -0.05689100f, 
    -0.06567609f, 0.01997763f, 0.00369852f, -0.02024095f, 0.00570787f, 0.03417070f, 0.09225953f, -0.00286895f, 
    -0.00111254f, 0.13247661f, -0.01375994f, 0.00841849f, -0.13714120f, 0.09576652f, -0.06424233f, 0.07348746f, 
    -0.07092620f, -0.13393541f, 0.02361393f, -0.03075081f, -0.00399841f, -0.01557739f, 0.02933737f, 0.04612632f, 
    -0.06296510f, -0.02493477f, -0.06913726f, -0.01079257f, 0.00803382f, -0.05528571f, -0.09097966f, 0.04490900f, 
    0.01249546f, -0.04290909f, -0.02743549f, -0.03724879f, -0.07934155f, 0.07325756f, 0.03613756f, 0.07952772f, 
    -0.05673870f, 0.02769667f, 0.05498580f, 0.12090499f, -0.09986898f, -0.09716419f, 0.05623930f, 0.11577886f, 
    0.04077548f, 0.14486594f, -0.05705355f, -0.00409842f, 0.00339743f, -0.21021713f, 0.04361743f, 0.18161184f, 
    0.08135909f, 0.01627253f, -0.10018354f, -0.01932851f, 0.10830130f, -0.06501213f, -0.01759144f, 0.02159269f, 
    0.06806649f, 0.12149131f, -0.00389883f, 0.04231420f, 0.01539398f, -0.05109826f, 0.03787804f, -0.05532700f, 
    -0.50530142f, 0.02402838f, 0.18069163f, 0.14562820f, 0.01105370f, -0.06233399f, -0.02350245f, -0.09332132f, 
    -0.07876410f, 0.04173805f, 0.01223695f, 0.00735416f, 0.06579101f, -0.00207221f, 0.10306793f, -0.02876875f, 
    0.05958712f, 0.01937879f, -0.03784204f, 0.01516578f, 0.01748713f, 0.18921861f, 0.07134957f, 0.14942047f, 
    -0.12518215f, 0.13815552f, -0.07856557f, 0.01820413f, 0.01037716f, 0.07604901f, -0.06784607f, 0.09194776f, 
    -0.02142208f, 0.00249500f, -0.02984429f, 0.07341373f, -0.11916088f, -0.08952907f, 0.01534463f, -0.06197393f, 
    -0.21690625f, -0.06665634f, 0.18741678f, -0.13642024f, 0.21484981f, -0.04015001f, 0.07861824f, -0.02394213f, 
    -0.00297708f, -0.00372958f, -0.01670137f, -0.08390519f, -0.03673340f, -0.03503840f, 0.01744288f, 0.01465064f, 
    -0.00961226f, -0.08335858f, 0.13897359f, -0.00117506f, 0.23585093f, 0.05248170f, 0.20821401f, -0.00886270f, 
    -0.03594998f, 0.05477745f, -0.16481118f, -0.02834325f, 0.07231866f, 0.09062906f, -0.05281109f, -0.04959269f, 
    0.00375242f, 0.21721236f, 0.09348038f, 0.02595467f, 0.03806741f, 0.02331474f, -0.11726604f, 0.01753989f, 
    -0.05999989f, 0.05990614f, -0.08756360f, 0.00603492f, 0.00045181f, -0.00906606f, 0.00329522f, 0.02033087f, 
    0.11083797f, 0.00838081f, 0.01644618f, 0.02475270f, 0.04111482f, -0.03676169f, 0.05335710f, 0.02572540f, 
    -0.02271044f, 0.00943877f, -0.06610595f, 0.10501978f, 0.07792754f, 0.07197268f, 0.08879238f, 0.08526266f, 
    -0.02131355f, 0.12056405f, 0.09677150f, 0.03373874f, -0.05397203f, 0.00420973f, 0.03624097f, -0.06364606f, 
    -0.00576094f, 0.02091900f, -0.06526203f, 0.01845323f, 0.07812815f, 0.12845697f, 0.09198297f, 0.00800287f, 
    -0.04144855f, 0.13931571f, -0.11568545f, -0.01771119f, -0.11406437f, 0.01091100f, 0.09528248f, 0.08210560f, 
    -0.02099217f, -0.07089590f, -0.02802399f, -0.01906097f, 0.08354773f, -0.04980323f, -0.04776357f, 0.04680208f, 
    0.01836007f, 0.05974671f, 0.01753094f, 0.01208335f, 0.13988100f, -0.07100885f, -0.01897474f, 0.16081585f, 
    0.06265221f, 0.00797443f, -0.03191460f, 0.08861224f, -0.01379003f, 0.07238463f, -0.09887546f, -0.09769141f, 
    0.03965499f, 0.07029611f, 0.03099160f, 0.08064630f, 0.01411236f, -0.08521954f, -0.15394036f, -0.04483615f, 
    -0.08066949f, -0.27952379f, 0.04369362f, 0.10396808f, 0.11072071f, 0.00258015f, -0.04142524f, -0.02923490f, 
    -0.00266320f, 0.02743287f, 0.01258140f, 0.04099339f, -0.01702790f, 0.01095478f, 0.00602813f, -0.04112545f, 
    -0.02638849f, -0.05691997f, -0.06136267f, -0.04745886f, 0.11824922f, 0.14654756f, -0.16526438f, -0.07454738f, 
    -0.22225434f, 0.04254715f, 0.06581126f, 0.01474636f, 0.01688361f, -0.15582430f, 0.11653745f, 0.08616640f, 
    -0.03533569f, -0.06908919f, -0.06011466f, 0.00898910f, 0.09727012f, -0.05625408f, -0.04108816f, -0.03348874f, 
    -0.09283397f, 0.15862073f, -0.15441081f, -0.06573749f, 0.18773186f, 0.10148872f, 0.06080224f, 0.06187684f, 
    0.17621225f, 0.12066359f, 0.00652083f, -0.07563990f, -0.04134197f, -0.00293475f, -0.08391405f, 0.13586847f, 
    0.09674632f, 0.13551831f, 0.02653616f, 0.13875224f, 0.01366888f, 0.36985087f, -0.05974348f, -0.00640249f, 
    -0.07372491f, 0.02449905f, 0.06240152f, 0.07088082f, -0.03518889f, -0.04149373f, -0.00897948f, -0.02905483f, 
    -0.05758477f, -0.01503016f, 0.11431587f, 0.03581692f, 0.08588005f, -0.02908143f, -0.08168378f, 0.04306921f, 
    -0.02759129f, 0.30533960f, -0.25127944f, -0.09890998f, -0.23198663f, -0.02822739f, 0.12981869f, 0.16757971f, 
    0.01564728f, 0.03000391f, 0.00484644f, 0.01147241f, 0.03935404f, 0.01102969f, 0.02646554f, -0.03194748f, 
    0.04949269f, 0.05226063f, -0.15589690f, -0.01279272f, -0.22907010f, 0.14294976f, -0.19353272f, -0.05734812f, 
    0.20125823f, 0.09684189f, 0.06290671f, -0.13199317f, 0.04599160f, 0.02825092f, -0.11643505f, -0.00607465f, 
    0.02502319f, 0.14373408f, -0.01593986f, 0.08114457f, 0.03083280f, 0.03763702f, 0.03190764f, -0.10993516f, 
    -0.11690088f, 0.24146190f, -0.03315457f, 0.10869338f, 0.15004386f, 0.06765750f, -0.09551463f, 0.14639005f, 
    0.08826302f, 0.13805033f, 0.08183356f, -0.01690505f, -0.05132020f, -0.10889643f, -0.17686902f, 0.02434954f, 
    0.09655645f, 0.04120991f, -0.01779090f, 0.16653462f, -0.06800748f, -0.00778876f, -0.11285198f, 0.01802982f, 
    -0.02522943f, 0.11015854f, 0.00071144f, -0.08806179f, 0.03210092f, 0.06462044f, 0.05169299f, -0.02714978f, 
    0.10136697f, 0.01847456f, 0.06899197f, 0.03807883f, 0.06524599f, 0.06141768f, -0.02654759f, 0.03473037f, 
    0.39668217f, 0.12552939f, -0.14912784f, -0.23030497f, 0.05612179f, -0.05258602f, 0.16779840f, -0.10312573f, 
    0.00449695f, -0.00229819f, -0.05893421f, -0.03714625f, -0.05288641f, 0.09027705f, 0.02498554f, 0.03294285f, 
    0.04305697f, -0.00381038f, 0.02455308f, 0.01251746f, -0.00059831f, 0.00483051f, -0.21985447f, -0.06082906f, 
    -0.04388103f, -0.07298174f, 0.04525209f, -0.08186214f, -0.02158813f, 0.04122559f, 0.13135372f, 0.00649460f, 
    0.10916486f, 0.08838467f, 0.10702338f, -0.11710723f, 0.19578528f, -0.07013226f, -0.00585866f, 0.17272031f, 
    -0.23355351f, -0.35571724f, -0.33782113f, 0.24167889f, -0.33279338f, 0.01037696f, -0.10352820f, 0.17091900f, 
    -0.07046218f, 0.09396898f, -0.07536270f, -0.00908161f, -0.04023503f, 0.07940520f, -0.09709094f, 0.00277314f, 
    0.00766977f, 0.06511880f, 0.00577085f, 0.03404571f, -0.17726265f, 0.09160103f, 0.27381808f, 0.25477007f, 
    -0.01043144f, 0.02027190f, 0.08152519f, 0.24510503f, 0.02893990f, 0.00445516f, 0.05616961f, -0.10886032f, 
    0.09174912f, 0.06365609f, 0.12064722f, 0.11794987f, 0.02299717f, 0.02250162f, -0.12002750f, 0.09111025f, 
    0.26121226f, 0.18481435f, 0.01129683f, -0.13931675f, 0.00755102f, 0.14558612f, -0.06607296f, -0.00715453f, 
    0.07186502f, -0.02418694f, 0.06716883f, 0.11923362f, 0.04568405f, 0.07370382f, 0.06730617f, 0.14620231f, 
    0.02795188f, 0.12134690f, 0.07187892f, 0.05391891f, 0.12831290f, 0.19703159f, 0.05520839f, -0.01917615f, 
    -0.08638138f, 0.12191021f, 0.16874142f, -0.01977039f, 0.18574616f, 0.15378033f, -0.01393346f, 0.04387017f, 
    0.04202814f, 0.06015079f, 0.13962042f, -0.02851564f, 0.01591098f, 0.01224401f, 0.06920244f, 0.05574734f, 
    -0.10246220f, 0.00791223f, -0.32440546f, 0.00184752f, 0.30773336f, -0.13624713f, -0.13123275f, -0.13468736f, 
    0.06112810f, 0.11487217f, 0.02466210f, 0.03223125f, -0.08434541f, 0.10590860f, -0.05553032f, 0.09036668f, 
    0.01080651f, 0.01948887f, 0.23566580f, -0.03581456f, 0.06893525f, 0.00473905f, -0.31174201f, -0.02390923f, 
    0.04856754f, 0.04649439f, 0.08695965f, 0.00085025f, 0.09992661f, 0.04857182f, 0.16346899f, 0.05091241f, 
    0.21075158f, 0.15389720f, 0.09547740f, 0.01845959f, 0.03072455f, 0.03043472f, 0.14857866f, 0.13183211f, 
    -0.06954037f, -0.16969076f, 0.04745071f, -0.03388736f, 0.06421818f, 0.16141289f, -0.12506293f, 0.07610921f, 
    0.04390245f, 0.13298170f, 0.06415203f, -0.02940300f, 0.14380506f, -0.07062037f, 0.03128984f, 0.05232897f, 
    0.03924762f, 0.02364303f, 0.09853054f, -0.01407149f, 0.00865481f, -0.23329292f, -0.24451734f, 0.12014883f, 
    0.32535839f, -0.09281058f, -0.07304917f, -0.14016023f, 0.15350005f, 0.05821900f, 0.11054116f, -0.11518334f, 
    0.02486341f, 0.03792772f, 0.09460328f, 0.04118926f, -0.15054075f, 0.05930947f, 0.01384599f, 0.08439498f, 
    0.04117908f, -0.13234942f, 0.09518397f, 0.00762782f, 0.08979619f, -0.04493698f, 0.04749595f, 0.05870042f, 
    -0.04358524f, 0.02805134f, -0.00178625f, -0.05875767f, 0.01133026f, 0.06070009f, -0.04124055f, -0.00861779f, 
    0.00587387f, 0.05514552f, 0.05085600f, 0.08748905f, -0.21477821f, 0.27262381f, 0.06593248f, 0.02236548f, 
    -0.00341078f, 0.27155310f, 0.04793811f, 0.15136920f, -0.04167330f, -0.12724689f, -0.00157014f, -0.02876148f, 
    -0.05429900f, -0.01873107f, 0.08776078f, 0.05858331f, 0.10556594f, -0.10587096f, 0.03949464f, 0.04734026f, 
    0.19711548f, 0.23764047f, -0.16290572f, 0.02220248f, -0.09196957f, -0.09596664f, -0.04903166f, 0.05874861f, 
    -0.06088370f, 0.05026570f, -0.05819467f, 0.03273659f, -0.12065991f, -0.07378388f, -0.09888399f, -0.00274144f, 
    0.03633524f, -0.05454331f, 0.06222001f, 0.03180858f, 0.18197247f, -0.20628981f, 0.13156269f, -0.05167753f, 
    0.20889267f, 0.07849611f, 0.05035067f, -0.10143171f, 0.03252077f, -0.00076034f, -0.06702299f, -0.08380494f, 
    0.03183147f, 0.11112603f, 0.18525514f, -0.04039520f, -0.02249548f, -0.01016116f, 0.12246428f, -0.04113913f, 
    0.03805784f, 0.18451659f, -0.13533448f, 0.08513837f, 0.14703694f, -0.07013559f, -0.04451961f, -0.04083143f, 
    -0.04012901f, -0.00842640f, -0.02606202f, -0.13291743f, 0.05788472f, -0.03215706f, 0.09864905f, -0.10224778f, 
    0.02352433f, -0.08561543f, 0.00159065f, 0.13835590f, 0.08045192f, 0.24977496f, -0.06081250f, -0.15860367f, 
    -0.23076572f, 0.03882378f, 0.08450752f, -0.05110728f, -0.08559290f, 0.04628734f, -0.08631507f, -0.02889742f, 
    0.03782387f, -0.02944306f, 0.02772715f, 0.00203778f, 0.01194693f, 0.06450627f, -0.05413566f, 0.02255899f, 
    0.54080403f, 0.06221669f, -0.14682801f, -0.19520044f, 0.00797821f, 0.03650134f, -0.00988680f, -0.01232530f, 
    0.11564291f, -0.01332951f, 0.08020577f, 0.08823414f, -0.06296530f, 0.06030870f, -0.01195042f, 0.06460566f, 
    -0.02995237f, 0.00960965f, -0.04797520f, 0.04424507f, -0.07155343f, -0.03043164f, -0.01252695f, -0.05390196f, 
    -0.10618877f, -0.14396146f, -0.03035871f, -0.06225809f, -0.00058056f, 0.02914731f, -0.03058274f, 0.05196229f, 
    0.04968285f, 0.05175145f, 0.07647434f, -0.09843945f, -0.00545390f, 0.07332937f, -0.01976248f, 0.11623199f, 
    0.09885397f, -0.18741205f, -0.33441696f, 0.30840862f, -0.31482702f, -0.05973256f, -0.06375071f, -0.02271591f, 
    0.01857731f, -0.02522044f, 0.08717799f, 0.05189377f, -0.02661153f, -0.05220456f, -0.02604927f, -0.03642379f, 
    -0.07683708f, -0.08504085f, 0.04465854f, 0.03537829f, -0.43642181f, -0.16105752f, 0.12857929f, 0.18440937f, 
    0.01132374f, 0.00367725f, 0.18185492f, 0.08244123f, -0.07617721f, -0.03911355f, 0.05765467f, 0.03118668f, 
    0.08506599f, -0.07924652f, -0.02833296f, -0.02019263f, 0.10747804f, -0.02200364f, 0.00412041f, -0.01464907f, 
    0.03640626f, -0.04544146f, 0.20802881f, 0.00033648f, -0.11349472f, 0.10336933f, 0.06867915f, -0.01302807f, 
    -0.11824632f, 0.03638589f, -0.04062870f, -0.01154933f, 0.07394239f, -0.00593835f, -0.11998346f, 0.01588349f, 
    0.04295732f, -0.03601962f, 0.06510153f, -0.02109783f, 0.01737009f, 0.00008880f, -0.15252663f, 0.05154906f, 
    0.16261160f, -0.16182126f, -0.03944816f, -0.06546077f, 0.12778409f, -0.11125886f, 0.02702351f, 0.08430663f, 
    0.04384934f, -0.02570765f, 0.08374816f, -0.01436890f, 0.06020309f, -0.06946696f, -0.12952457f, -0.05628318f, 
    0.09286615f, -0.13625814f, 0.14669165f, -0.05148017f, 0.20228952f, -0.13908298f, -0.03414471f, -0.00925521f, 
    0.04787667f, -0.06482856f, -0.02258766f, 0.01129420f, -0.21998851f, 0.11850657f, 0.05827760f, 0.04648956f, 
    0.09159818f, -0.05890565f, 0.01517746f, -0.06938762f, -0.04635331f, 0.15494563f, 0.08529623f, -0.16829638f, 
    -0.16868860f, 0.04459103f, 0.04167351f, -0.07131832f, 0.08251733f, -0.00183714f, -0.02538322f, -0.00251372f, 
    0.03762763f, 0.03325742f, 0.07259557f, -0.00725654f, -0.02155341f, 0.06964806f, 0.07239489f, 0.16041827f, 
    0.06811892f, 0.12308111f, 0.03945510f, -0.21731596f, -0.11258059f, -0.08973865f, 0.04826020f, 0.00844404f, 
    -0.00690620f, -0.08811068f, 0.03492717f, 0.00036037f, 0.10720317f, 0.06966530f, -0.00468215f, -0.02843725f, 
    0.12542062f, 0.05548440f, 0.13367584f, 0.08987809f, 0.04119964f, -0.26260796f, 0.12474776f, -0.02348545f, 
    0.27794629f, -0.16520196f, -0.00366025f, 0.02333014f, 0.10557242f, 0.01772544f, -0.00991120f, -0.07169301f, 
    0.00373626f, 0.10942924f, 0.11141077f, 0.05263323f, -0.04251223f, -0.03800876f, 0.02585034f, 0.11431851f, 
    0.32365772f, 0.00819116f, 0.00987209f, 0.16182527f, 0.00163814f, -0.11579092f, -0.06514591f, -0.06192357f, 
    0.11513725f, 0.03665304f, 0.02051980f, 0.00029489f, 0.01806675f, -0.06813467f, 0.07736216f, 0.01928669f, 
    0.03193581f, 0.09036768f, 0.13511012f, 0.04721662f, 0.11843059f, -0.15107441f, -0.16659072f, -0.06733952f, 
    0.07525992f, -0.01930421f, 0.11507866f, -0.07724307f, 0.08805394f, -0.03081624f, 0.07338399f, 0.02607669f, 
    0.03821671f, 0.03015951f, -0.03699952f, 0.01241169f, 0.08661416f, -0.04486466f, 0.15672123f, 0.02182264f, 
    0.47369510f, -0.03546216f, -0.08575791f, -0.10493643f, 0.14934723f, 0.04545064f, 0.11123460f, -0.11734840f, 
    -0.04527815f, -0.08283260f, 0.02649686f, 0.02967494f, 0.11077173f, 0.04820282f, 0.09061113f, 0.11640401f, 
    0.07932404f, -0.05324530f, -0.10125162f, 0.05100813f, 0.23823611f, 0.05025077f, -0.21876253f, 0.07268652f, 
    0.00585166f, -0.10177027f, 0.00285223f, -0.02976223f, 0.03010217f, 0.06310020f, 0.00721082f, 0.13188067f, 
    0.13729230f, 0.05299994f, -0.03997113f, 0.02990522f, 0.03582908f, -0.00023642f, -0.00503011f, 0.03774101f, 
    0.11363295f, 0.11052884f, 0.13955733f, -0.14260489f, 0.06257282f, -0.01680455f, 0.05983322f, -0.04141030f, 
    0.04887049f, 0.07540317f, 0.01460279f, -0.01189222f, 0.02952087f, 0.04511866f, 0.06130977f, 0.05833784f, 
    0.07683871f, -0.00875197f, 0.03137377f, -0.01056569f, 0.15674730f, -0.05791152f, 0.01647298f, -0.11970361f, 
    -0.14074312f, 0.06787439f, 0.03277823f, -0.00532595f, -0.04465054f, -0.00992331f, -0.02006939f, 0.00699283f, 
    0.02132361f, -0.02739348f, -0.02084535f, 0.11282275f, 0.03335514f, 0.00811319f, 0.05795971f, 0.14768957f, 
    0.06552748f, 0.04325734f, 0.00354375f, -0.07893972f, 0.06807970f, 0.05507153f, 0.04949034f, -0.07343456f, 
    -0.00639164f, 0.08337040f, -0.09442738f, -0.01029199f, 0.10580741f, -0.00984529f, -0.07099606f, 0.06549446f, 
    -0.01039179f, 0.03839919f, 0.09159184f, 0.09166836f, 0.03888673f, -0.15815270f, -0.02109311f, -0.14559607f, 
    -0.09485985f, 0.11682782f, 0.01673708f, -0.06491137f, 0.09148590f, 0.04830194f, -0.06339589f, -0.01243954f, 
    0.03580226f, 0.00337668f, -0.04955093f, 0.12353717f, 0.05618309f, 0.00559132f, 0.09765633f, -0.09531120f, 
    -0.23164134f, -0.33624434f, 0.06820310f, -0.16923788f, 0.19773756f, 0.09704160f, -0.05577177f, 0.16747846f, 
    0.10766732f, -0.11540701f, 0.09540157f, 0.01751118f, 0.03452402f, 0.10084723f, 0.07840899f, -0.02610842f, 
    -0.00784227f, 0.12626630f, -0.03042761f, 0.07453713f, -0.11646630f, -0.11421075f, -0.08397045f, -0.18450229f, 
    -0.11231901f, 0.06742442f, 0.06369410f, 0.04952385f, -0.10981585f, -0.10075664f, -0.01739445f, 0.06012214f, 
    -0.03785611f, -0.02054048f, -0.02069003f, 0.02214941f, 0.04983890f, 0.05002599f, -0.01889832f, -0.05700481f, 
    0.12566535f, -0.19497257f, -0.09787411f, 0.04707477f, 0.00682566f, -0.00854690f, 0.10073587f, -0.03805537f, 
    -0.01453139f, 0.06811764f, 0.08274440f, -0.03315033f, 0.05460953f, 0.01110700f, 0.05091114f, 0.07804431f, 
    0.03822970f, -0.09352748f, 0.08366819f, 0.05495546f, 0.10441633f, 0.08232211f, 0.05863592f, -0.08382874f, 
    0.15182289f, 0.07914893f, 0.12248045f, -0.02280532f, -0.07680081f, -0.01640343f, 0.02267511f, 0.03181003f, 
    -0.03161817f, 0.05697584f, 0.02326474f, 0.03989153f, 0.06051948f, -0.02898398f, -0.05721987f, -0.03545995f, 
    0.37089968f, 0.00682735f, 0.13542235f, 0.17039098f, -0.06117843f, 0.08022118f, -0.05236721f, -0.02169338f, 
    0.06995417f, 0.11826450f, 0.09588759f, -0.03868759f, -0.05853998f, 0.00790048f, -0.05274638f, 0.00832398f, 
    -0.04204151f, -0.03909212f, -0.07733880f, 0.03815510f, -0.08250181f, -0.18878612f, 0.09694779f, 0.07713117f, 
    -0.16565870f, -0.02107773f, -0.03014298f, 0.02083936f, 0.06057449f, 0.01189108f, 0.06225925f, 0.05853337f, 
    0.00711427f, 0.03094254f, 0.01392463f, -0.01656896f, 0.05461191f, 0.00723149f, 0.03240018f, 0.00418102f, 
    0.16196434f, 0.02153752f, 0.05358462f, 0.14951414f, -0.10042540f, 0.00417829f, 0.03534732f, 0.07470635f, 
    -0.05735587f, 0.05855985f, 0.05631940f, -0.04515122f, 0.00527752f, 0.04460803f, 0.02824583f, 0.09385821f, 
    0.04226568f, 0.01101510f, 0.08264116f, 0.08588576f, 0.34569028f, 0.04492968f, 0.17414702f, 0.06148493f, 
    -0.05967127f, -0.03562502f, -0.06638708f, -0.02866911f, 0.05921213f, 0.23021680f, 0.02050074f, -0.05107309f, 
    -0.03972677f, 0.02047397f, -0.03201503f, -0.05178863f, -0.06203040f, 0.06743003f, -0.11267900f, -0.04544073f, 
    -0.03192066f, 0.00517229f, -0.02701732f, -0.00673461f, -0.02444637f, -0.03742551f, -0.02356182f, 0.01410854f, 
    0.02043725f, -0.04922516f, 0.02180802f, -0.04947772f, -0.02744651f, -0.04749340f, 0.01675334f, 0.02588286f, 
    0.01925797f, 0.01935515f, 0.03562867f, -0.02464492f, 0.00673381f, 0.04113145f, -0.02971089f, 0.01659507f, 
    -0.02207376f, 0.02912927f, 0.03719043f, -0.01554108f, 0.03501385f, 0.04045620f, 0.00477698f, 0.01672372f, 
    -0.00227410f, 0.01352162f, 0.00693359f, 0.01586973f, -0.02634436f, 0.03439588f, -0.03255729f, -0.02995708f, 
    -0.02258896f, -0.05304785f, -0.01422461f, 0.02475893f, 0.03857330f, 0.02052407f, 0.03833984f, -0.04161318f, 
    0.02374272f, -0.01630644f, -0.05593244f, -0.00091173f, 0.01663668f, -0.00430314f, 0.00330772f, -0.02499048f, 
    0.04013811f, 0.00947460f, -0.01215341f, -0.01137114f, -0.05941616f, -0.01490492f, 0.00687342f, -0.03430142f, 
    -0.01162804f, -0.05061332f, 0.04033880f, -0.04021184f, -0.05954624f, -0.02250375f, -0.03675280f, -0.06236982f, 
    0.01505134f, -0.03480635f, -0.01618939f, 0.01648995f, -0.05669408f, -0.00728707f, -0.03472149f, -0.00889405f, 
    0.00813167f, -0.05540361f, -0.04048134f, 0.04648850f, -0.02624763f, 0.00866890f, -0.05874165f, -0.05249865f, 
    -0.03977284f, 0.00554380f, -0.02003730f, 0.03401034f, 0.02617691f, -0.02367590f, 0.03015132f, 0.04122142f, 
    0.00392966f, 0.01134541f, 0.01703360f, -0.03619746f, 0.03178018f, 0.02534988f, -0.04740970f, -0.04277323f, 
    -0.03865757f, -0.06483843f, -0.00302980f, -0.02272169f, 0.00614167f, -0.01841470f, 0.03092902f, 0.01548201f, 
    -0.03680253f, -0.06054183f, -0.00538182f, 0.04093685f, -0.02494525f, -0.01886307f, -0.00293135f, -0.01992614f, 
    -0.03032277f, 0.04161203f, -0.05958154f, -0.04425124f, -0.06034829f, -0.04257873f, -0.01456935f, -0.02492379f, 
    0.00903591f, 0.01282995f, 0.00291577f, -0.02915096f, -0.04646472f, -0.04746397f, 0.02886086f, -0.02251135f, 
    -0.04009532f, -0.06283591f, -0.00619962f, 0.01084188f, -0.01863692f, 0.03567027f, 0.01321448f, -0.06021150f, 
    -0.03841352f, -0.04381209f, -0.06241953f, 0.03474557f, -0.01641679f, -0.05732429f, 0.04986566f, -0.00374732f, 
    0.02726695f, 0.00289721f, -0.06092298f, -0.00319459f, 0.04009900f, -0.06384489f, -0.01236393f, 0.02933432f, 
    -0.05071263f, 0.02222935f, -0.01755709f, -0.04654057f, -0.05221714f, 0.01396537f, 0.04301767f, -0.04257425f, 
    -0.01632027f, 0.02584027f, -0.01662134f, -0.04718220f, -0.01363201f, -0.01004296f, -0.03806110f, -0.05782246f, 
    0.01651349f, -0.01834509f, -0.00013878f, -0.00072999f, -0.04754461f, -0.03193141f, 0.02161256f, 0.01957720f, 
    0.01849700f, -0.05118461f, 0.00843841f, -0.03814735f, -0.01454848f, 0.00381281f, -0.05358279f, -0.00534934f, 
    0.03368521f, -0.05651310f, -0.02223397f, 0.02588628f, -0.00425932f, -0.00191470f, 0.01156886f, 0.00501113f, 
    -0.04824824f, -0.04591289f, -0.06268992f, 0.03526114f, -0.05560926f, 0.00198254f, -0.04630123f, -0.03576580f, 
    -0.02643761f, -0.05548155f, -0.04258353f, 0.02553315f, -0.02215127f, -0.02720312f, -0.04050026f, 0.00459077f, 
    0.00433784f, -0.00885311f, -0.04989656f, -0.03394736f, -0.00352514f, 0.00152734f, -0.06022959f, 0.01665406f, 
    -0.02144651f, -0.00096880f, -0.05389623f, 0.03007982f, -0.04104252f, 0.04519692f, -0.04389727f, -0.04064319f, 
    -0.05918992f, -0.05052626f, -0.04830359f, -0.04798868f, -0.03074202f, 0.03280449f, 0.04468510f, 0.04394104f, 
    0.03239107f, -0.05535273f, -0.00419458f, 0.00963121f, 0.01618064f, 0.00510379f, -0.04564925f, 0.03505098f, 
    0.00155541f, -0.03379437f, -0.00162700f, 0.01401017f, -0.00087133f, 0.01842429f, 0.01686635f, 0.04200383f, 
    -0.03444689f, -0.04333457f, -0.02643208f, -0.00156583f, 0.02465794f, 0.04361174f, -0.04282615f, -0.01334760f, 
    0.03023438f, 0.03566372f, -0.05162227f, -0.02632852f, -0.02314042f, 0.00234409f, -0.05081977f, -0.00422697f, 
    -0.03406731f, -0.01060648f, -0.02750690f, 0.03950641f, -0.04389856f, -0.04316701f, -0.00805115f, -0.00091242f, 
    -0.04483779f, -0.03284291f, -0.04890052f, -0.04610081f, 0.04357670f, -0.03125718f, -0.01053927f, 0.02225506f, 
    -0.03244177f, -0.00910146f, 0.00350574f, -0.00408820f, -0.00786235f, -0.05545995f, -0.00400255f, -0.03155262f, 
    -0.02120857f, -0.03578014f, -0.01730331f, 0.01200350f, 0.01393759f, 0.04539543f, 0.04391584f, -0.00581387f, 
    0.03819077f, -0.06098251f, -0.01907261f, -0.02451530f, -0.01113064f, -0.04537960f, 0.00884530f, -0.02000140f, 
    -0.03242634f, -0.04788696f, -0.04974283f, 0.04193635f, 0.02697604f, 0.04878391f, -0.01732595f, 0.02661980f, 
    -0.04215452f, 0.00714201f, -0.01392194f, -0.04517252f, 0.02039512f, -0.02338790f, 0.03305759f, -0.01980905f, 
    -0.03945146f, -0.01949410f, 0.01537931f, 0.01570722f, -0.06474932f, -0.05640459f, -0.06476511f, 0.03814979f, 
    -0.01779192f, -0.04901915f, 0.02041183f, -0.05218386f, 0.01237946f, -0.01592973f, -0.03170108f, 0.01864186f, 
    -0.04838056f, 0.02018081f, 0.04268633f, -0.01845565f, -0.02510181f, -0.02244484f, -0.03090235f, 0.01974323f, 
    -0.06158888f, -0.05299772f, -0.00866781f, -0.04667135f, -0.01232397f, 0.01000429f, -0.00609944f, 0.01183085f, 
    -0.02244387f, 0.02870605f, -0.00801522f, -0.04761562f, -0.04914919f, -0.02208417f, -0.03959507f, -0.03954427f, 
    -0.00255693f, 0.00967827f, -0.03172883f, -0.01186374f, -0.04046176f, 0.03782434f, -0.05440897f, -0.01470583f, 
    0.02576021f, -0.05374162f, 0.00138603f, -0.01228851f, -0.03505833f, -0.05355709f, 0.00451073f, -0.04599989f, 
    -0.00615031f, -0.03394504f, 0.03336254f, 0.03200352f, 0.01467990f, -0.01063388f, 0.00449436f, 0.00040137f, 
    0.02615959f, 0.00925009f, -0.05940399f, -0.02028968f, 0.02876389f, -0.00487732f, -0.06034956f, -0.01608577f, 
    -0.00970081f, -0.03026822f, 0.03655586f, -0.05457504f, 0.00137188f, -0.00098147f, -0.03259750f, -0.00449663f, 
    -0.03591365f, -0.05233733f, -0.05857718f, -0.04357716f, 0.00329937f, -0.03726985f, -0.03407975f, -0.02897405f, 
    -0.01983831f, -0.01655640f, -0.02776109f, -0.04778353f, -0.03071542f, 0.00728021f, 0.00439001f, -0.02251668f, 
    0.03433368f, 0.04148916f, -0.00618059f, -0.02421729f, 0.04760678f, -0.04818178f, 0.02173143f, -0.01388393f, 
    -0.05717148f, 0.03039876f, -0.04076293f, -0.00403360f, -0.03418483f, -0.03294072f, 0.03722993f, -0.04484732f, 
    -0.03892528f, -0.00738369f, 0.01018910f, -0.01097561f, -0.01472219f, -0.01576649f, 0.00282965f, 0.00514355f, 
    0.04062258f, 0.04274546f, -0.04410064f, 0.02424902f, -0.00177332f, -0.02774728f, -0.01003547f, -0.03537124f, 
    -0.04577141f, 0.02264038f, 0.01877018f, 0.00445081f, 0.01377731f, 0.04433532f, -0.03967258f, 0.03098634f, 
    -0.03939462f, 0.00827829f, -0.03729669f, 0.01164624f, -0.01315355f, -0.03627682f, 0.01198047f, -0.04167764f, 
    0.04093783f, -0.03479699f, 0.00216673f, -0.01032234f, -0.03136011f, 0.01317089f, -0.05463218f, -0.03875209f, 
    0.03548011f, -0.03041768f, -0.00332025f, -0.03314616f, -0.04304907f, -0.04131017f, 0.01509010f, 0.02652609f, 
    -0.06455620f, 0.02049457f, -0.00040858f, -0.05233638f, -0.02491981f, -0.05677817f, 0.03338318f, 0.03824918f, 
    -0.00775175f, 0.02794770f, -0.04304324f, 0.00877793f, -0.01441566f, 0.01965082f, 0.03802397f, -0.00923519f, 
    -0.03628984f, 0.03615019f, 0.00535011f, -0.01867095f, 0.00321240f, -0.03795058f, -0.01754400f, -0.05336124f, 
    0.04014153f, 0.00401267f, -0.03173470f, 0.01850062f, 0.01435091f, -0.01463917f, -0.03860436f, 0.01792503f, 
    -0.06045872f, -0.05226598f, 0.02339936f, 0.04004928f, -0.06307312f, -0.01699557f, -0.03745337f, 0.03133377f, 
    -0.01459706f, -0.02091322f, 0.03888414f, -0.02387450f, 0.03020102f, -0.05764657f, -0.03073789f, 0.03711168f, 
    -0.06025650f, 0.04009707f, -0.03607642f, -0.03061438f, 0.01284561f, -0.01970871f, -0.00534058f, -0.04424722f, 
    -0.04485390f, 0.01833363f, 0.03153237f, -0.00365023f, -0.04876224f, -0.01266620f, 0.03752387f, -0.02489030f, 
    0.01604318f, 0.04357531f, 0.03624814f, 0.02566185f, 0.02793727f, -0.06453058f, 0.01660142f, -0.05771753f, 
    -0.03555433f, -0.06014739f, 0.01563229f, 0.04500437f, -0.00072009f, -0.00651866f, -0.01143524f, -0.04760627f, 
    0.00066807f, 0.00679408f, 0.00110241f, -0.01253901f, -0.02992940f, 0.02531885f, 0.04296111f, -0.05082331f, 
    0.03163647f, -0.04265023f, -0.05266445f, -0.05160876f, -0.05447369f, 0.01758686f, -0.00670146f, -0.03995512f, 
    -0.03307885f, 0.00219625f, -0.03499418f, 0.02573018f, -0.04866403f, -0.05078213f, 0.00718561f, 0.00444055f, 
    0.02472795f, -0.01420133f, 0.04242962f, 0.04493150f, -0.03368234f, -0.06341112f, -0.01234082f, 0.01505874f, 
    0.00637163f, -0.01405912f, 0.00971224f, 0.02149561f, -0.06251816f, 0.01918196f, 0.03566015f, -0.02346047f, 
    0.00009699f, -0.02333742f, 0.03274108f, -0.02443538f, 0.00259019f, -0.02540025f, 0.01857855f, 0.03802458f, 
    0.01010248f, 0.03745911f, -0.01667213f, -0.05499658f, -0.02079967f, -0.03825184f, -0.05789828f, -0.05310848f, 
    0.04435709f, 0.00361963f, 0.04285370f, 0.02136934f, -0.04968565f, -0.02159873f, -0.00611538f, 0.01753126f, 
    0.03697520f, -0.06200183f, -0.04279383f, -0.04537299f, -0.05604500f, -0.03464169f, 0.05042287f, 0.02417821f, 
    0.03898323f, 0.11333452f, -0.11115129f, -0.04045213f, 0.01401669f, 0.12894380f, 0.06287927f, -0.04418417f, 
    0.16055043f, 0.06840269f, 0.06385089f, 0.06685585f, 0.05196749f, 0.02830504f, 0.02456661f, -0.03873751f, 
    0.13231021f, 0.00426474f, -0.02088527f, 0.06333213f, -0.41209307f, 0.36878037f, 0.06449425f, 0.06340516f, 
    0.01665691f, 0.04746117f, -0.01466337f, 0.03729241f, -0.03858506f, 0.06434381f, 0.02533226f, 0.03286047f, 
    0.04744736f, -0.13620442f, -0.04266828f, 0.02932177f, -0.00668919f, -0.05511126f, -0.03628414f, -0.01989981f, 
    0.07939977f, 0.23918068f, 0.06195201f, -0.13619499f, 0.23533551f, -0.02266650f, -0.05456362f, 0.07049090f, 
    0.02351664f, 0.03963234f, -0.04359840f, 0.02893206f, -0.06996511f, -0.05326147f, 0.07826188f, -0.03440695f, 
    0.02467286f, -0.00270522f, 0.07190866f, -0.02758116f, -0.00548535f, -0.16545147f, 0.16498718f, 0.02263430f, 
    -0.10007480f, -0.03133585f, 0.12991673f, -0.03637022f, -0.04769856f, -0.02684714f, 0.07942946f, 0.05185914f, 
    -0.07304423f, -0.09139329f, 0.03450673f, -0.01252304f, 0.04732079f, -0.00927179f, 0.07519290f, 0.10927112f, 
    0.02316018f, 0.19280039f, -0.11233287f, -0.00058371f, 0.05441354f, 0.07156084f, 0.02126564f, 0.04892110f, 
    0.04559864f, -0.03708453f, -0.04729607f, -0.00862583f, 0.07636164f, 0.04235521f, -0.00451636f, -0.03159454f, 
    0.13348338f, -0.08625247f, 0.11665894f, -0.00437627f, -0.11330541f, -0.02243121f, -0.03590525f, 0.23778929f, 
    -0.27221787f, 0.03323517f, 0.12921682f, 0.12506875f, 0.03138785f, -0.00227313f, 0.00759628f, 0.04707978f, 
    -0.05988219f, 0.01682694f, 0.03866051f, -0.05937581f, 0.01164511f, 0.04060233f, -0.00597956f, 0.13610956f, 
    -0.22381152f, 0.26920035f, 0.03138093f, -0.30878878f, -0.04123585f, -0.01102267f, -0.15703440f, -0.00521993f, 
    0.12315691f, 0.01068650f, -0.01304151f, 0.04678548f, -0.02830312f, -0.00666718f, -0.12009143f, -0.12618862f, 
    0.00956712f, -0.07774838f, -0.08190274f, -0.03507196f, 0.03855642f, 0.05188916f, 0.09432279f, 0.04911032f, 
    -0.23555006f, 0.11966848f, -0.03288012f, -0.03562466f, 0.06586343f, -0.00444429f, 0.09370734f, 0.04266841f, 
    -0.03970154f, 0.04828309f, 0.07996042f, -0.11228259f, -0.02730571f, 0.17459308f, -0.05383402f, 0.02315281f, 
    0.11913320f, -0.35684463f, -0.15935159f, -0.06374088f, -0.01509421f, -0.23778929f, -0.01197939f, -0.02455333f, 
    -0.03512737f, -0.06177290f, 0.05264134f, 0.00959775f, -0.03833129f, 0.01210835f, 0.12244934f, -0.13723239f, 
    -0.04743711f, -0.09092405f, 0.03695692f, -0.02616491f, -0.05186637f, -0.25969389f, 0.27689230f, 0.33600891f, 
    0.11906631f, -0.07084045f, -0.00735006f, -0.03162302f, 0.01103099f, 0.02875531f, 0.08705002f, 0.08883732f, 
    -0.02101307f, 0.00855245f, 0.04961304f, 0.02266189f, 0.06443611f, 0.00439782f, 0.09197772f, -0.01301272f, 
    -0.17804466f, -0.01514275f, 0.17964536f, -0.04780843f, -0.13839664f, 0.08362836f, -0.04592852f, -0.00083018f, 
    0.04188169f, -0.05640259f, 0.04279739f, 0.02154805f, -0.08829839f, -0.01227838f, -0.11178606f, -0.02347518f, 
    0.00725523f, 0.06177368f, 0.06609248f, -0.01774286f, -0.02210061f, 0.07915658f, 0.00638310f, 0.15433210f, 
    0.18487521f, -0.08942195f, -0.13059920f, 0.01438619f, 0.04968357f, -0.06010791f, -0.04163553f, -0.03864399f, 
    0.06158216f, -0.05176042f, 0.06839231f, 0.03581510f, 0.12923503f, -0.05029573f, 0.06106876f, 0.08561812f, 
    -0.20089424f, 0.13442799f, -0.09391584f, -0.00593480f, -0.06284173f, 0.00667405f, 0.04605953f, -0.04710825f, 
    0.07339239f, 0.07819512f, -0.00978769f, -0.02108462f, -0.00521133f, -0.04706470f, 0.05490463f, 0.12945926f, 
    0.01680421f, 0.09850570f, 0.03918596f, 0.06119343f, 0.10480195f, -0.03800952f, 0.12140378f, 0.08876095f, 
    -0.07550444f, 0.04335444f, 0.05419821f, 0.04129803f, 0.08506130f, 0.05241827f, 0.00912179f, 0.00987117f, 
    0.05420016f, -0.02131618f, 0.06810413f, 0.04535377f, -0.00953783f, -0.03664355f, 0.06146507f, 0.07025561f, 
    0.03577767f, 0.11895025f, -0.18167688f, 0.01102532f, -0.13178493f, 0.04699297f, -0.05427137f, 0.08237942f, 
    0.08786827f, -0.00579366f, -0.00060184f, -0.08611340f, 0.06441013f, 0.02348916f, 0.00520226f, 0.01441685f, 
    0.01317050f, 0.02712961f, -0.03089108f, 0.00459482f, -0.32020095f, -0.04589491f, -0.09711113f, 0.04861534f, 
    -0.02240307f, -0.05437505f, 0.00424332f, 0.06931039f, -0.03976025f, 0.10017094f, -0.06994447f, 0.02919818f, 
    0.05957934f, 0.04441147f, 0.07894427f, 0.11176583f, 0.12275007f, 0.01274015f, 0.05770446f, 0.00668416f, 
    0.03342688f, -0.04478153f, 0.04612252f, -0.01150187f, -0.01950720f, -0.07023696f, -0.00060336f, 0.01242151f, 
    -0.05135880f, 0.03954995f, 0.04904179f, -0.05003580f, 0.01388416f, -0.05268736f, -0.02222646f, -0.03727943f, 
    -0.00064118f, -0.02572566f, -0.04570827f, -0.02057557f, -0.00308783f, 0.02699048f, -0.06872416f, -0.02041304f, 
    -0.03559678f, -0.05271043f, -0.04711352f, -0.03931507f, -0.01502158f, -0.04901879f, -0.02276188f, 0.01937006f, 
    -0.02608936f, -0.03681091f, 0.02355643f, 0.04231904f, -0.01511778f, -0.05917066f, 0.01834415f, -0.03272038f, 
    0.08811061f, 0.05843135f, 0.02958220f, -0.00579273f, -0.00278073f, -0.05137904f, -0.04233775f, 0.04225315f, 
    0.01074304f, -0.00025213f, -0.03370710f, 0.01459733f, -0.00628323f, -0.02372025f, -0.05483089f, -0.04865313f, 
    -0.06482890f, 0.01374480f, 0.03362433f, -0.03117166f, -0.03340051f, 0.01937590f, 0.00299412f, -0.05880253f, 
    -0.01554285f, -0.00255380f, -0.02674728f, -0.02850362f, -0.05033713f, -0.05862003f, 0.01145320f, 0.03417514f, 
    0.00996378f, 0.01541783f, 0.05354875f, 0.00939420f, -0.05677104f, 0.04676571f, 0.01112949f, -0.00019384f, 
    0.06437740f, -0.04440580f, 0.03216054f, 0.04772757f, 0.00955621f, -0.04780364f, 0.00639203f, 0.02756058f, 
    0.02197387f, 0.04171281f, -0.04119319f, 0.04936533f, -0.06303388f, 0.04104672f, 0.02093280f, 0.01484367f, 
    0.02581595f, -0.02156441f, -0.00701585f, 0.02156163f, 0.02694054f, -0.06033029f, 0.03765839f, -0.06988039f, 
    -0.04453739f, 0.02436746f, -0.00461107f, -0.06527385f, 0.02542453f, 0.04455799f, 0.00860222f, 0.00673712f, 
    0.04429093f, -0.03069239f, 0.00657354f, -0.06274065f, -0.05389121f, -0.02799190f, 0.05310239f, -0.00685554f, 
    0.03487379f, -0.00979976f, -0.04098384f, -0.03588242f, 0.00073855f, -0.00475778f, 0.02146623f, -0.01050622f, 
    0.03819741f, -0.06525321f, 0.04899443f, 0.04997624f, 0.00965490f, -0.02236959f, -0.01613999f, -0.03607917f, 
    0.02154690f, -0.04229870f, -0.00667494f, 0.01341444f, 0.01258304f, -0.02549836f, 0.02740469f, -0.02052080f, 
    0.01813590f, -0.01055435f, -0.01395272f, -0.04070437f, 0.03174977f, -0.05605584f, 0.04359003f, -0.04120658f, 
    0.03737824f, -0.02865831f, -0.01399121f, -0.02201232f, -0.05431231f, 0.03965233f, 0.01833176f, 0.04756653f, 
    -0.00444731f, -0.00728309f, 0.00257803f, -0.02888997f, -0.02580730f, 0.06232877f, 0.01901088f, -0.02242174f, 
    0.01525423f, -0.00689360f, 0.05726290f, 0.03609832f, 0.02716547f, -0.00141412f, 0.02133523f, -0.04349426f, 
    -0.01892144f, 0.02979119f, -0.01211792f, 0.04929508f, 0.03796358f, -0.03157162f, -0.05821016f, -0.03504036f, 
    -0.02505821f, -0.01565456f, -0.01617154f, 0.02562440f, 0.01497128f, 0.01627314f, 0.01648840f, 0.01449294f, 
    0.00339846f, 0.00440079f, 0.02423062f, 0.01595723f, -0.02516226f, -0.02367165f, 0.01143636f, 0.01049838f, 
    0.03421143f, -0.05099578f, -0.00478465f, -0.00509644f, -0.06768277f, -0.00350144f, -0.04358670f, -0.03007993f, 
    0.04261849f, 0.04046168f, -0.03190294f, 0.03963732f, -0.01268148f, 0.03146674f, 0.03243555f, -0.00837221f, 
    -0.03989670f, -0.01552336f, -0.00910114f, 0.04050169f, -0.02270081f, -0.01707481f, -0.02921875f, -0.00169483f, 
    0.01255808f, 0.00025296f, -0.01372794f, -0.01369758f, 0.01925254f, 0.00752328f, 0.00571162f, 0.01177504f, 
    -0.06540902f, -0.05092267f, -0.05136240f, -0.00554106f, -0.00025151f, -0.03337746f, 0.04660570f, -0.03901850f, 
    -0.05847767f, 0.02531612f, -0.02395045f, -0.06595278f, -0.00612899f, -0.05554584f, -0.00918972f, 0.01236097f, 
    0.02546507f, 0.00302402f, 0.03460173f, 0.01555641f, 0.04562182f, 0.03385776f, 0.01283622f, -0.03405362f, 
    -0.02993163f, -0.03114072f, -0.03739957f, -0.00540691f, 0.01950575f, -0.04155106f, -0.01169854f, -0.04829543f, 
    0.01475125f, 0.01834153f, 0.04436647f, 0.01202359f, -0.06710134f, 0.01802980f, -0.04982662f, 0.02244951f, 
    -0.00725274f, 0.01343495f, 0.00619942f, -0.05495541f, -0.04522503f, 0.00779672f, 0.04498502f, 0.02395820f, 
    -0.00413420f, -0.03856282f, 0.02649063f, -0.06423490f, -0.06535693f, -0.07293456f, 0.00038337f, -0.05964686f, 
    0.00080831f, -0.03613238f, -0.05588344f, -0.01378077f, -0.00121773f, -0.00250607f, -0.04476905f, -0.06226313f, 
    0.03824777f, -0.05266656f, -0.02987859f, 0.03254473f, -0.00703003f, -0.01326475f, 0.03835250f, -0.03244283f, 
    0.03734626f, -0.00147024f, 0.05334907f, 0.05456462f, -0.00389156f, 0.05927817f, 0.02003989f, -0.04810495f, 
    -0.01897668f, 0.02439012f, 0.00350851f, 0.01807513f, -0.03194621f, -0.04922891f, -0.05587040f, 0.01647422f, 
    0.23990020f, -0.01094303f, 0.22187614f, 0.07296988f, 0.07330966f, -0.14263190f, 0.03517906f, 0.10919195f, 
    0.08137810f, 0.04505645f, -0.00524008f, -0.08351828f, 0.04365681f, 0.13326004f, -0.03879526f, 0.02621746f, 
    -0.03539046f, 0.08100598f, 0.01827932f, 0.07237819f, -0.01226070f, 0.02032976f, -0.13598575f, -0.17933308f, 
    -0.02939834f, 0.13635202f, 0.04345443f, 0.06909970f, -0.02720360f, -0.11420406f, 0.04383896f, -0.03311903f, 
    0.01251611f, -0.02858875f, 0.03117253f, 0.00543160f, -0.03704057f, -0.04967805f, -0.02981429f, -0.03431048f, 
    0.04801684f, 0.12916474f, -0.07235494f, 0.03672620f, 0.03148342f, -0.04895117f, 0.00646097f, 0.01921264f, 
    -0.13683918f, 0.00533264f, 0.03997403f, 0.06064769f, 0.04341516f, 0.06293920f, -0.03243971f, 0.10250482f, 
    0.04523254f, 0.14592150f, -0.00682964f, 0.01808254f, -0.04348582f, 0.01906702f, 0.05608867f, -0.05872367f, 
    0.07582403f, 0.10152020f, -0.06116756f, 0.00296631f, -0.02693507f, 0.07717005f, -0.00420176f, 0.07976283f, 
    0.00488570f, 0.13148129f, -0.06432579f, 0.04240550f, -0.01983382f, 0.13137747f, -0.05578284f, -0.08707116f, 
    -0.12584773f, 0.29916039f, 0.01372245f, 0.14796588f, 0.20212202f, 0.02600782f, -0.02555318f, -0.12996578f, 
    -0.06460973f, -0.04061941f, 0.07187758f, 0.01644487f, -0.03057597f, 0.03460336f, 0.07081237f, 0.03648402f, 
    0.13486813f, 0.04862496f, 0.00997875f, 0.07753568f, 0.00908629f, 0.14986621f, 0.04014582f, -0.08349398f, 
    -0.09242792f, -0.02575220f, -0.01675638f, -0.02795978f, 0.06310131f, 0.05944084f, -0.03480278f, 0.00000378f, 
    0.10928477f, 0.07698340f, 0.03666740f, 0.03249366f, 0.02578717f, 0.00267909f, -0.13507754f, 0.04615299f, 
    0.24129415f, -0.20469940f, -0.08222443f, -0.10129333f, -0.04055070f, 0.01796118f, -0.02268924f, 0.01891345f, 
    0.00727791f, -0.05145045f, 0.05231019f, -0.01448802f, -0.09464680f, 0.02534479f, 0.02177727f, -0.04456859f, 
    -0.03645605f, 0.09881458f, 0.11826476f, 0.15037693f, -0.18856081f, -0.02066065f, 0.00733906f, -0.10471828f, 
    -0.17159939f, 0.05503301f, 0.07923957f, -0.07505602f, -0.06923189f, 0.12691699f, -0.00145207f, -0.00426735f, 
    0.08871909f, -0.04671083f, 0.02277573f, -0.06256449f, 0.06842778f, 0.00165029f, 0.13227992f, -0.08994005f, 
    -0.10078020f, -0.26381841f, -0.19466071f, -0.06198103f, -0.19225182f, 0.07615724f, -0.05967119f, 0.06039585f, 
    0.11349940f, -0.00921710f, 0.05102859f, -0.02645644f, -0.07791167f, -0.04537566f, -0.01632044f, 0.02053825f, 
    -0.00128330f, 0.13588543f, 0.12838946f, -0.05263674f, -0.00951384f, -0.19699806f, -0.15785928f, -0.00398781f, 
    0.03058046f, 0.10351731f, 0.06477943f, 0.00903456f, 0.03043815f, -0.03992463f, -0.04315932f, -0.00729776f, 
    0.05503583f, 0.07769316f, 0.05604288f, 0.01443209f, 0.02464845f, 0.03901403f, -0.10322852f, -0.03495201f, 
    0.03090325f, -0.08655410f, 0.09232680f, 0.05622873f, -0.05253443f, 0.01826660f, 0.04684135f, 0.01581871f, 
    0.07521186f, -0.01996360f, 0.04703695f, -0.01229740f, -0.01249093f, 0.13094313f, -0.08251475f, 0.03547541f, 
    0.02210584f, 0.02158779f, -0.08595096f, -0.00300382f, 0.29313132f, 0.06424762f, 0.13403346f, 0.09243535f, 
    0.14946628f, 0.03269947f, -0.03703025f, -0.08839238f, 0.03244391f, 0.00156841f, 0.03342235f, 0.00905544f, 
    -0.00895402f, -0.10491248f, -0.03863032f, -0.06695832f, 0.03914582f, 0.10635809f, -0.01848853f, 0.01616071f, 
    0.19941963f, -0.18251503f, 0.16884249f, 0.19525592f, 0.01984903f, -0.02710088f, -0.07217323f, -0.01423590f, 
    -0.01505697f, -0.07442159f, -0.01064864f, 0.01328619f, -0.02413749f, 0.00417759f, -0.00856777f, -0.03317720f, 
    -0.07391981f, 0.00999518f, 0.01713912f, -0.04525654f, -0.23933055f, 0.07210816f, 0.07288068f, -0.30798969f, 
    -0.09056175f, 0.09280369f, 0.00345319f, -0.00332134f, 0.01388391f, 0.01547981f, 0.01859544f, 0.02582114f, 
    0.07921592f, 0.07502012f, -0.00869598f, -0.08649855f, 0.07734513f, 0.00283998f, -0.13704783f, -0.09514216f, 
    0.04296875f, 0.03168303f, 0.16280875f, -0.02121871f, -0.04286067f, -0.08065152f, 0.01635428f, 0.01243835f, 
    0.04095731f, 0.06759792f, 0.14722286f, -0.07147586f, 0.01479774f, 0.10384013f, -0.01732515f, 0.10451545f, 
    0.03757554f, -0.06352742f, 0.04086635f, 0.04317340f, 0.26968107f, -0.06422734f, 0.11083627f, 0.07312521f, 
    0.11068998f, -0.06644749f, -0.01407407f, -0.05913771f, -0.00298647f, 0.06577458f, 0.08760644f, 0.04114076f, 
    -0.03085258f, -0.02060921f, 0.07132950f, -0.02996011f, -0.09734378f, -0.00973970f, -0.00581379f, 0.05544986f, 
    -0.00526652f, -0.06211575f, -0.05955792f, 0.02635435f, 0.02956632f, 0.04179289f, 0.04680531f, -0.00491894f, 
    -0.02421951f, 0.01935622f, 0.00963447f, 0.03951014f, 0.05049291f, 0.00875878f, -0.00120020f, 0.00493545f, 
    -0.03834093f, -0.05341917f, 0.00166958f, -0.00973080f, 0.00501181f, 0.00898092f, -0.05053275f, 0.03816107f, 
    0.02098632f, -0.05926864f, -0.00375402f, -0.01138154f, -0.00169785f, 0.02879648f, -0.05689327f, -0.04071695f, 
    -0.01387841f, -0.05148801f, -0.04126675f, -0.04307488f, 0.01745129f, 0.01790836f, -0.01082109f, 0.02883429f, 
    0.00791361f, 0.03404144f, -0.04597497f, 0.02927079f, 0.01104927f, -0.02641240f, -0.04221030f, 0.04093094f, 
    -0.03624927f, 0.03091042f, -0.05159324f, 0.04925781f, -0.05753546f, -0.00437876f, 0.01868964f, -0.00653883f, 
    -0.00762019f, -0.04627354f, 0.03653279f, 0.03552620f, 0.00951271f, -0.01021055f, -0.03085245f, 0.03110794f, 
    0.04412452f, -0.02697912f, -0.00992914f, -0.05525953f, -0.02674288f, 0.00234581f, 0.02830983f, 0.03583421f, 
    0.03672180f, 0.03720625f, 0.02462732f, 0.00675938f, -0.02518693f, -0.04608917f, 0.04643302f, -0.02057564f, 
    -0.04076443f, 0.04035849f, 0.04722042f, 0.01922573f, 0.00148620f, -0.00658045f, 0.00594261f, 0.00572029f, 
    -0.00934395f, -0.02708600f, -0.02819952f, 0.04176565f, -0.01614351f, -0.02443878f, -0.00293648f, 0.04474264f, 
    0.03165533f, -0.02672137f, -0.02090198f, -0.04379858f, 0.03939709f, -0.04370761f, -0.03023738f, 0.02138533f, 
    -0.03526950f, 0.00191341f, -0.01622790f, -0.05509523f, 0.00420418f, -0.03774703f, -0.05714105f, -0.04907247f, 
    -0.04654275f, -0.03325218f, -0.00252290f, 0.02930969f, -0.01164605f, -0.02081802f, 0.03374263f, 0.04380991f, 
    -0.04378311f, -0.01247456f, -0.05338968f, 0.02672682f, 0.03077654f, 0.01513712f, -0.04975221f, -0.04833464f, 
    0.00956612f, -0.03294809f, -0.02013562f, 0.02797414f, -0.04388791f, -0.05612829f, -0.00340950f, 0.01589478f, 
    -0.00952795f, -0.05616608f, -0.03917014f, -0.03965742f, -0.04392672f, -0.02550902f, -0.00041461f, -0.05795566f, 
    -0.04162120f, 0.03354723f, 0.02359038f, 0.03431858f, 0.03432281f, -0.00048155f, 0.04925549f, -0.06023794f, 
    -0.00566288f, 0.03017167f, -0.04110301f, 0.00870495f, 0.05107411f, -0.00400752f, 0.01438307f, 0.02305562f, 
    0.03674992f, -0.03948090f, -0.02006510f, -0.02461311f, -0.00051824f, -0.05044035f, -0.05476050f, -0.02557041f, 
    -0.02640873f, 0.04405412f, 0.03756364f, 0.01505055f, -0.01531774f, -0.03510717f, -0.04596807f, 0.03122603f, 
    -0.01129663f, -0.01243492f, 0.02768408f, 0.03276476f, 0.02324251f, -0.02027223f, 0.00125715f, 0.02564030f, 
    0.00706904f, 0.04618622f, -0.06118618f, -0.04168957f, 0.03280552f, 0.03573514f, -0.00350724f, -0.02082368f, 
    0.04324058f, -0.04196058f, 0.01355084f, -0.02650401f, 0.04073913f, -0.00880166f, 0.00812503f, -0.02148526f, 
    0.02232740f, -0.01612944f, -0.00246568f, -0.01399069f, -0.04811696f, -0.02314648f, 0.03622208f, 0.03465817f, 
    -0.05120245f, -0.04323183f, -0.01084758f, -0.00807077f, 0.04043714f, 0.03185660f, 0.04693405f, -0.05599042f, 
    -0.00985490f, -0.03541835f, -0.04388759f, -0.03916886f, -0.02740657f, 0.01196066f, -0.00249441f, 0.02271888f, 
    -0.05444610f, 0.00508534f, -0.03633832f, -0.05667456f, -0.03727703f, 0.02735306f, -0.02325044f, -0.05302504f, 
    0.03876728f, -0.02007289f, -0.02616983f, -0.01702953f, -0.01864515f, 0.00539946f, -0.01988242f, -0.02086456f, 
    0.00851395f, -0.01682500f, -0.02993363f, -0.05788545f, -0.02573979f, -0.01629025f, -0.02195224f, 0.00082436f, 
    0.00144945f, -0.00608586f, 0.01734208f, -0.00061214f, -0.04992027f, -0.02603917f, 0.03394599f, -0.04107721f, 
    0.00153157f, 0.03088552f, -0.05333690f, 0.02506803f, 0.03598008f, -0.01172548f, -0.02934956f, 0.00341378f, 
    -0.01211872f, 0.02658714f, 0.01160288f, -0.02492179f, -0.04143327f, 0.04031765f, -0.01063505f, -0.01974571f, 
    -0.05473007f, 0.00978064f, -0.04335946f, 0.00213424f, 0.04165055f, 0.04879654f, 0.03670464f, -0.04156150f, 
    -0.00165710f, 0.00587775f, 0.01614296f, -0.03196796f, 0.01346957f, -0.00044623f, 0.00124708f, -0.01736636f, 
    -0.06206932f, -0.01646738f, 0.02914586f, -0.02435954f, 0.00417101f, -0.00053158f, 0.03038113f, 0.02407724f, 
    -0.03389089f, 0.01920507f, 0.02920797f, -0.05918017f, -0.04569092f, -0.01641192f, -0.02099456f, 0.00869695f, 
    -0.04550464f, 0.03817317f, 0.04378507f, 0.02584018f, -0.00069993f, -0.00208936f, -0.05601606f, -0.03360194f, 
    -0.03128701f, -0.01041395f, -0.02817944f, 0.00399224f, 0.02716754f, 0.04966307f, -0.05130671f, -0.05391976f, 
    0.01608911f, 0.03198955f, -0.00186358f, -0.04168667f, 0.01584602f, -0.05754065f, 0.01261297f, 0.01816547f, 
    0.01282804f, -0.00230023f, 0.02856749f, 0.01266894f, -0.00271564f, 0.02509498f, -0.00625408f, -0.06069563f, 
    -0.02491335f, 0.03406206f, 0.00867775f, 0.04666483f, -0.04465908f, -0.05959882f, -0.03951242f, 0.03364244f, 
    0.02083033f, -0.01738092f, 0.00908186f, -0.01022609f, 0.02858650f, -0.01464815f, -0.03801204f, -0.03708940f, 
    -0.03231795f, -0.05146508f, -0.04877956f, -0.04743106f, -0.05775692f, -0.01578053f, -0.04438870f, 0.03987273f, 
    -0.04859086f, -0.02169486f, -0.04272749f, -0.04349194f, -0.04234222f, -0.01594161f, -0.00486042f, -0.05249357f, 
    -0.05827588f, -0.02418130f, -0.05201913f, -0.05985438f, 0.02130071f, 0.02293281f, -0.03871389f, -0.02712690f, 
    -0.01969101f, -0.01328706f, -0.04050335f, -0.01582047f, -0.04699785f, 0.03228002f, 0.04534227f, -0.05350287f, 
    0.03911432f, -0.05398357f, -0.04702839f, -0.01911871f, -0.02252027f, 0.03694243f, 0.00608025f, -0.00426599f, 
    0.01633536f, 0.02101384f, -0.00810637f, -0.03278575f, -0.03212839f, 0.00224764f, 0.01505315f, -0.00039122f, 
    0.03559753f, 0.04382383f, 0.00058595f, -0.02587644f, -0.03869196f, -0.01565579f, -0.03139785f, -0.02355980f, 
    -0.01071643f, -0.02397515f, -0.02341205f, -0.01183619f, -0.05436219f, -0.01696572f, -0.02827207f, -0.01879195f, 
    0.01044658f, -0.01399055f, -0.02561431f, -0.03302819f, 0.04639962f, -0.02001674f, 0.04336588f, -0.01949197f, 
    -0.00170867f, -0.03007479f, -0.04435344f, 0.02902262f, 0.01689176f, -0.02385160f, -0.05979272f, -0.01210034f, 
    -0.04032453f, 0.01314601f, 0.04374466f, 0.02700719f, 0.01955844f, 0.01162945f, 0.03153996f, 0.00917393f, 
    0.04750575f, -0.03974235f, -0.04928462f, -0.01418741f, -0.01945376f, -0.02874119f, 0.04337244f, -0.03333372f, 
    0.01558516f, -0.00457272f, -0.04095323f, -0.03244699f, -0.05845127f, -0.00141160f, -0.04505577f, -0.05351855f, 
    0.02242447f, 0.01762125f, 0.00143996f, 0.04326150f, -0.04278697f, -0.00178700f, 0.04677843f, -0.02034122f, 
    -0.01415706f, -0.00324625f, -0.04581981f, -0.01949549f, 0.04304122f, -0.02166010f, 0.01842508f, 0.05114972f, 
    -0.05183052f, -0.04379974f, -0.04458401f, -0.02261932f, 0.01590857f, 0.04554823f, 0.01839016f, 0.04195544f, 
    0.04967565f, 0.02773122f, 0.05046737f, 0.03906182f, -0.01120378f, -0.01674738f, -0.02389777f, -0.05205911f, 
    -0.02388578f, -0.04582056f, -0.04998688f, -0.04470906f, 0.03258651f, -0.05864476f, -0.03478425f, -0.01546534f, 
    -0.04795041f, -0.02143162f, 0.00790031f, -0.00646465f, -0.00453107f, -0.05164586f, 0.01490248f, 0.00980922f, 
    0.01464078f, 0.00469968f, 0.02661228f, -0.04581252f, 0.04278071f, -0.03876299f, -0.02582158f, -0.03792077f, 
    0.00061399f, -0.03438301f, -0.05030544f, 0.01129874f, -0.01827622f, -0.04245471f, -0.01271496f, -0.02833866f, 
    0.02070041f, -0.00275559f, -0.05759248f, -0.03396802f, -0.00635377f, -0.02076396f, -0.01953638f, -0.04433165f, 
    -0.04182526f, -0.00015208f, -0.02370964f, 0.04103094f, 0.01488972f, -0.05968099f, -0.05076809f, -0.02950417f, 
    0.01039015f, -0.04741061f, 0.00646858f, 0.04848619f, -0.03291434f, 0.01739691f, 0.01747663f, -0.00430174f, 
    -0.00864565f, 0.00242955f, -0.03800446f, 0.01412936f, 0.04303077f, 0.02860553f, -0.05037536f, -0.00115892f, 
    -0.01983536f, -0.04740345f, -0.01240184f, 0.01935223f, 0.02934116f, 0.03093395f, 0.04123062f, 0.02453466f, 
    -0.04698186f, -0.03982680f, 0.00269985f, -0.00073377f, -0.04842696f, 0.01858249f, 0.03438356f, 0.03942174f, 
    -0.01840255f, -0.01694131f, 0.03006057f, -0.00731017f, 0.00403032f, 0.02841225f, -0.00292402f, -0.01153381f, 
    0.02488626f, -0.02038513f, 0.02413339f, -0.01627790f, 0.03502354f, -0.05245475f, 0.02522481f, 0.00124978f, 
    -0.06015215f, -0.02290997f, -0.01935195f, -0.05030838f, 0.02202315f, 0.01399923f, -0.00589760f, -0.03025089f, 
    -0.01993753f, 0.02793968f, -0.04635156f, -0.05017523f, -0.01021577f, 0.02482072f, -0.03876591f, 0.02149831f, 
    -0.02292206f, -0.02140320f, 0.02284124f, -0.00792793f, -0.06034510f, -0.02820458f, 0.02453065f, 0.04824675f, 
    0.00001345f, 0.01423020f, 0.03787287f, 0.04135175f, 0.04056867f, 0.02639513f, -0.02889366f, 0.04472698f, 
    0.01914920f, -0.03494226f, -0.02045517f, -0.00848047f, -0.05171150f, 0.04518169f, 0.04925193f, 0.03775799f, 
    -0.01146010f, -0.05487570f, -0.01552208f, -0.02748736f, -0.01653477f, -0.02886373f, -0.04689757f, -0.02932151f, 
    -0.01972996f, -0.02062871f, 0.01955932f, 0.01843008f, -0.01730602f, -0.05336302f, 0.01754922f, -0.02160197f, 
    0.24184665f, -0.00848365f, 0.10771990f, 0.08600624f, 0.01431030f, -0.07746845f, -0.05958138f, -0.01273635f, 
    -0.00118067f, 0.01804172f, -0.03211149f, 0.00026974f, 0.01592171f, -0.05404256f, 0.06281456f, -0.05699357f, 
    0.03050391f, -0.01623463f, 0.13519041f, -0.01843612f, 0.23366444f, -0.10118882f, 0.14023727f, 0.00771837f, 
    0.08403666f, 0.00315628f, 0.01712272f, -0.01022712f, 0.04347280f, -0.05776150f, -0.05066107f, -0.00176723f, 
    0.01736789f, 0.01647951f, -0.10587086f, 0.11329884f, 0.07221999f, 0.05906047f, 0.16611412f, 0.03256548f, 
    0.29553625f, -0.21183980f, -0.11172515f, -0.05259954f, 0.04170895f, -0.02812597f, -0.00370250f, -0.05262186f, 
    -0.02397963f, -0.04587274f, -0.05348139f, 0.10174066f, 0.09771376f, -0.01336906f, 0.04170810f, -0.03315040f, 
    0.11517057f, -0.06400555f, -0.13558328f, 0.02331972f, 0.28009942f, -0.19070479f, 0.01929657f, 0.07889818f, 
    0.10738751f, -0.02573761f, -0.08148110f, 0.01645596f, 0.07645623f, 0.00158015f, -0.07910456f, 0.04645673f, 
    0.08893749f, 0.12823267f, 0.05073252f, 0.06380900f, 0.05005972f, -0.10326304f, 0.10961559f, 0.03444131f, 
    0.29061240f, -0.31051877f, 0.00032786f, -0.06829030f, 0.00987170f, -0.16293620f, 0.12115531f, -0.10940581f, 
    0.09186637f, -0.02188633f, -0.00207148f, 0.04422122f, 0.07810581f, 0.03189119f, 0.05096782f, -0.05446703f, 
    -0.00638596f, -0.05149401f, 0.01752403f, -0.06803606f, 0.26809427f, 0.12850365f, -0.02633720f, -0.19983846f, 
    0.05905757f, 0.02122133f, 0.06732322f, -0.01235957f, -0.06458703f, -0.01986343f, 0.03134090f, 0.01869181f, 
    -0.10874490f, -0.05094007f, -0.09497333f, -0.00813276f, -0.03647952f, 0.10410702f, 0.17348914f, 0.06619515f, 
    0.14865951f, 0.00905665f, -0.10485714f, 0.05049389f, 0.05035751f, 0.05559480f, 0.03016730f, 0.04524877f, 
    0.00268223f, -0.03629303f, -0.04318693f, -0.07812826f, 0.10992546f, 0.05379067f, -0.06453947f, 0.01171715f, 
    -0.10124379f, 0.03638409f, -0.00976112f, 0.04990884f, 0.11152788f, -0.10989285f, 0.05996011f, -0.22569992f, 
    0.14504355f, -0.05453365f, -0.03090766f, 0.08578255f, 0.10575647f, -0.02093246f, -0.06068091f, -0.11692075f, 
    0.05779914f, 0.04016533f, -0.00718484f, 0.16856223f, -0.09725391f, 0.06354722f, 0.01438181f, -0.01347108f, 
    -0.05482132f, -0.00630411f, 0.06474099f, 0.13000529f, 0.13837902f, 0.08960384f, -0.02618176f, 0.06484083f, 
    0.04127989f, -0.10658908f, 0.13234262f, 0.06219649f, 0.08197752f, 0.08072306f, 0.12737654f, 0.02591529f, 
    -0.05088138f, -0.02402779f, -0.04431372f, 0.04697985f, -0.21478075f, 0.11515113f, -0.04869997f, -0.21901196f, 
    -0.30650592f, 0.05797619f, 0.08318666f, 0.00210673f, 0.01701307f, 0.00203688f, -0.00744098f, 0.11066709f, 
    -0.03676389f, -0.04401294f, -0.09243464f, 0.08940560f, 0.04592011f, 0.06690003f, 0.00076791f, -0.08033174f, 
    0.15733454f, 0.13577156f, 0.01742862f, 0.12160051f, 0.02121115f, -0.02321878f, 0.09976874f, -0.01147686f, 
    -0.07337803f, 0.04751540f, 0.00371320f, -0.00116759f, 0.03827085f, -0.04162861f, 0.01235439f, 0.04407587f, 
    -0.01974856f, -0.01044756f, 0.14572309f, -0.00297982f, -0.08208495f, -0.11273589f, -0.04346478f, -0.10066570f, 
    0.09393948f, 0.04069050f, 0.10271621f, -0.01594191f, -0.04355183f, -0.00627319f, 0.03142188f, 0.03959219f, 
    -0.06144846f, 0.09467350f, -0.00523154f, -0.03031328f, 0.05391634f, -0.07270254f, -0.08816589f, -0.10012981f, 
    0.43159249f, -0.10402276f, 0.18520461f, 0.05675991f, 0.00421661f, -0.04194424f, -0.12061657f, 0.03761333f, 
    0.02146279f, -0.03476518f, -0.03047012f, -0.04903834f, -0.08199921f, 0.07688058f, -0.04955193f, -0.05618690f, 
    0.08092311f, -0.13070501f, -0.07720877f, 0.01689898f, 0.05002930f, 0.07915145f, 0.07886452f, -0.05919008f, 
    0.03780587f, -0.11257298f, -0.00049180f, 0.03443627f, 0.05918836f, -0.02953842f, 0.01304642f, -0.02944440f, 
    -0.10204199f, 0.01343642f, 0.04083044f, 0.08081371f, -0.09538683f, 0.04240872f, 0.13396986f, -0.01710047f, 
    0.13780762f, -0.05949739f, 0.07178587f, -0.01508107f, 0.06806387f, 0.03170542f, 0.07601728f, 0.06324612f, 
    -0.07336230f, -0.12244975f, -0.02382089f, 0.02140391f, -0.02691877f, 0.03167685f, 0.04602123f, 0.04994192f, 
    0.04880056f, 0.06622998f, 0.01520591f, -0.01814875f, 0.43988407f, -0.04146785f, 0.22748962f, 0.05523644f, 
    0.01286054f, -0.10609201f, 0.01898449f, -0.12210280f, 0.08649392f, 0.02245083f, -0.00748878f, -0.02129390f, 
    -0.01287748f, 0.09019063f, -0.07166440f, -0.05324219f, -0.04059839f, -0.01795954f, -0.08226068f, 0.09441683f, 
    -0.11315513f, 0.04063925f, -0.16062747f, -0.05210193f, -0.11782689f, 0.09505939f, 0.03771339f, -0.02253923f, 
    0.00276869f, -0.04091823f, 0.07807416f, 0.10011371f, -0.00210248f, -0.05074938f, 0.02375142f, -0.03049518f, 
    0.04723887f, 0.01019004f, 0.03629627f, -0.00875992f, 0.14157470f, -0.12705944f, -0.01588562f, 0.16691798f, 
    -0.12103006f, -0.16005921f, 0.05191912f, -0.15294667f, 0.09233255f, 0.07436813f, -0.05773444f, 0.06305274f, 
    0.01750591f, 0.09420216f, 0.02879129f, -0.03019915f, -0.03050889f, 0.07196338f, -0.05131297f, -0.06511652f, 
    0.06549711f, -0.19245306f, 0.10523639f, 0.12669840f, 0.10529096f, 0.08322877f, -0.08434658f, -0.09725011f, 
    -0.02287721f, -0.03511364f, 0.01626020f, -0.05059926f, -0.04568934f, 0.06910298f, 0.13136682f, 0.01982613f, 
    0.00830185f, 0.11089032f, 0.01725862f, 0.04495165f, 0.06339478f, 0.13842134f, -0.21055014f, 0.07305468f, 
    -0.25661322f, -0.11647712f, 0.17217089f, -0.11262728f, 0.07331870f, -0.12317946f, -0.01456436f, 0.02610780f, 
    0.08327962f, -0.13532102f, -0.02602226f, -0.07307969f, 0.00186589f, -0.02056340f, 0.03204823f, 0.11674222f, 
    0.10203636f, -0.08336370f, 0.05748156f, -0.34885278f, -0.20208450f, 0.11260916f, 0.02394649f, 0.13626821f, 
    0.07828750f, 0.05160813f, -0.01659887f, 0.02748471f, -0.03835814f, 0.01424818f, -0.01131219f, 0.06541545f, 
    0.08600952f, 0.09187368f, -0.04350825f, -0.04936241f, 0.08966331f, -0.27536857f, 0.23476119f, 0.23522775f, 
    0.02334771f, -0.00360218f, -0.08384648f, -0.01498023f, -0.03361273f, 0.00311061f, 0.00524518f, 0.06208192f, 
    0.09033938f, 0.04615606f, -0.00831176f, -0.05076586f, 0.05705218f, -0.05564013f, -0.00918278f, -0.04368410f, 
    -0.61448842f, 0.11458018f, 0.10921439f, 0.14692864f, -0.08590269f, -0.05452418f, -0.04770112f, -0.01127743f, 
    -0.02765382f, 0.01935810f, -0.03754836f, 0.03876274f, 0.16409685f, 0.00763760f, 0.03167408f, 0.02553292f, 
    0.10594340f, 0.06010295f, 0.07270948f, -0.02967389f, 0.02215312f, 0.15557839f, 0.16593778f, 0.19949494f, 
    0.01993776f, 0.23268647f, -0.13286458f, 0.00871965f, 0.01889997f, 0.04704378f, 0.04268574f, 0.03813882f, 
    -0.04767793f, -0.00540575f, -0.08011963f, 0.06534898f, -0.15601100f, 0.07408858f, -0.06438567f, -0.08125138f, 
    -0.10805268f, 0.20050855f, 0.31612501f, -0.18993938f, 0.21635100f, 0.03748249f, 0.02969949f, -0.04155375f, 
    -0.20955393f, 0.05697648f, -0.10663386f, -0.09696273f, 0.05769752f, 0.06587766f, 0.07073817f, 0.02534013f, 
    0.14595053f, -0.08173643f, 0.02225510f, -0.01903725f, 0.02553867f, -0.04182908f, 0.15880243f, -0.04768515f, 
    0.04340274f, -0.08941311f, -0.13173929f, -0.08754380f, -0.09147758f, 0.02567531f, -0.10882317f, -0.09622335f, 
    0.03894107f, 0.05397426f, 0.10464907f, 0.01839651f, -0.01425691f, -0.00766364f, 0.06834385f, -0.04948563f, 
    0.06772600f, -0.15039562f, 0.04694580f, 0.00425483f, 0.06782953f, -0.04665363f, 0.05810910f, -0.00067242f, 
    0.03243809f, 0.05068855f, 0.00762766f, 0.09036357f, 0.03670302f, 0.05998021f, -0.04227473f, 0.01252749f, 
    0.00703659f, 0.00936626f, -0.03897888f, 0.06734952f, -0.13178790f, 0.02758322f, -0.01487063f, -0.10433371f, 
    -0.16039699f, 0.03053698f, 0.00099878f, -0.00928222f, -0.06120733f, -0.08686147f, 0.01591830f, -0.04094052f, 
    -0.04299749f, 0.05379178f, -0.00371707f, 0.04413483f, 0.04602047f, 0.02443139f, 0.07826950f, 0.08176167f, 
    -0.09842748f, 0.24673100f, -0.08679926f, -0.04252255f, -0.17064410f, 0.06821519f, 0.15430070f, 0.06979245f, 
    -0.01614237f, 0.05201148f, 0.08997627f, -0.08413343f, 0.08241218f, -0.09566022f, 0.03895610f, -0.01172328f, 
    0.07624813f, -0.01734399f, 0.06861561f, -0.02896295f, 0.23484296f, -0.21939227f, 0.17123105f, 0.45671847f, 
    0.09460253f, 0.10309925f, -0.02036619f, 0.00090494f, 0.00913517f, 0.07289343f, -0.07528351f, -0.00732872f, 
    0.02640390f, 0.02626389f, 0.04237840f, 0.03777130f, -0.02147119f, -0.04717534f, -0.10624239f, 0.00318575f, 
    -0.07026409f, -0.01472517f, -0.13667132f, 0.03324651f, -0.02780532f, 0.01456012f, -0.06179475f, 0.06813477f, 
    -0.01408573f, 0.00909421f, -0.04844240f, -0.08737752f, -0.01437259f, -0.08936379f, 0.04896015f, -0.02612892f, 
    0.02521157f, 0.07120845f, 0.03359614f, 0.02374329f, -0.21460775f, 0.32004157f, -0.03233830f, -0.14873850f, 
    -0.18990229f, 0.09892894f, 0.11142187f, 0.15982118f, -0.04122239f, -0.05187210f, 0.01414108f, -0.01359222f, 
    -0.01079115f, 0.02984867f, -0.06483297f, 0.01673487f, 0.08186474f, -0.04001503f, 0.02154198f, -0.02485405f, 
    -0.00367527f, 0.01614941f, 0.01160242f, -0.00269076f, -0.04449749f, 0.03864975f, -0.02669412f, -0.04594452f, 
    -0.02505613f, -0.06148589f, 0.00637590f, 0.00123644f, 0.02135662f, -0.04570298f, 0.02034656f, -0.04993287f, 
    -0.01474553f, 0.02845420f, -0.05770791f, 0.04881952f, -0.02149595f, 0.01477581f, -0.00130822f, 0.02710084f, 
    -0.03386971f, 0.02213794f, -0.03702177f, 0.01033997f, -0.02123977f, -0.01033985f, -0.01259941f, -0.03687659f, 
    0.02347540f, -0.01837985f, 0.01657918f, -0.05027949f, -0.00407982f, -0.05075234f, 0.00075522f, 0.02343370f, 
    0.05104060f, -0.05517736f, -0.05723124f, -0.01227673f, -0.06025976f, 0.03054567f, -0.04106067f, -0.02002155f, 
    0.01472460f, -0.04452613f, 0.02643098f, -0.02534536f, 0.01650977f, 0.03788258f, 0.04673878f, -0.03958898f, 
    -0.01839083f, 0.02524247f, -0.05220257f, 0.01967886f, 0.02139073f, -0.02335301f, -0.05567081f, -0.00822775f, 
    -0.00566238f, 0.04122056f, -0.03533461f, 0.04551835f, -0.03698657f, 0.04572903f, -0.04299248f, -0.00683387f, 
    0.04082533f, -0.01724975f, 0.01541955f, -0.02954732f, -0.03126010f, 0.03500667f, 0.03881969f, -0.00629036f, 
    0.03280023f, 0.03504837f, 0.04391702f, -0.05675637f, -0.01817862f, 0.02472691f, 0.03055678f, -0.03175538f, 
    0.03059238f, -0.02965769f, -0.00862446f, 0.00763845f, -0.04068102f, 0.00285730f, 0.02245096f, 0.00678449f, 
    -0.05559931f, -0.04832520f, -0.04634545f, -0.03362064f, -0.02542843f, 0.02033431f, -0.00628675f, -0.03206847f, 
    0.02457096f, 0.00621139f, 0.02257652f, 0.04787522f, -0.05948134f, 0.01833797f, -0.04185568f, -0.03419175f, 
    0.00657895f, -0.02239925f, -0.04964379f, 0.02962559f, -0.01076671f, -0.01230466f, -0.00768555f, 0.01141207f, 
    0.02828394f, 0.02739036f, 0.00967961f, 0.04710127f, 0.01694858f, 0.00444026f, 0.03693586f, -0.03097233f, 
    -0.02516697f, -0.03152509f, -0.05994121f, -0.00762079f, 0.02685420f, 0.02794449f, -0.02330266f, -0.04968368f, 
    -0.03117406f, -0.02569278f, -0.02469733f, 0.00163847f, -0.04420361f, -0.01277917f, -0.01117370f, -0.00675689f, 
    -0.00017037f, 0.01187314f, -0.04550793f, -0.04057035f, -0.01231529f, 0.02149645f, 0.01843593f, 0.01840157f, 
    -0.01299230f, 0.00707731f, 0.03182590f, -0.02149895f, -0.00048235f, -0.06724480f, -0.05640391f, 0.02826322f, 
    0.01604533f, 0.02126942f, 0.02979169f, -0.05384445f, 0.03407935f, 0.02558599f, -0.03131568f, 0.01778745f, 
    -0.02974216f, -0.00018338f, 0.03511095f, 0.00948545f, 0.01304978f, 0.03980495f, 0.00406031f, -0.01711614f, 
    -0.06250629f, -0.03179988f, -0.00058337f, 0.02237002f, 0.00333497f, -0.01620369f, 0.02745092f, -0.04867754f, 
    0.00873896f, -0.03899644f, 0.01157329f, -0.00259895f, -0.00241728f, -0.04631012f, 0.02340181f, -0.03129245f, 
    0.02279535f, -0.03294533f, -0.03834587f, 0.04543310f, 0.01579891f, -0.05060913f, -0.03747690f, 0.02125057f, 
    0.01959804f, 0.02829105f, 0.00088729f, 0.03497090f, 0.03211199f, -0.04019326f, -0.04273330f, -0.01087470f, 
    -0.03161739f, 0.02074792f, -0.00109258f, -0.05880388f, -0.02242852f, 0.03712501f, -0.04873738f, -0.02290021f, 
    -0.00182713f, -0.03337989f, -0.05906905f, -0.01028497f, -0.05921235f, -0.04691839f, -0.01405951f, 0.00581615f, 
    -0.00334505f, 0.02879506f, -0.00702713f, -0.02199131f, -0.02086770f, -0.04159873f, -0.02594159f, -0.03124567f, 
    0.00036817f, 0.01995261f, -0.00828341f, -0.01981233f, 0.04715949f, 0.00148337f, -0.04871712f, 0.02209963f, 
    -0.03846015f, 0.02000195f, -0.00454869f, 0.03078443f, 0.03956809f, 0.02410146f, -0.01723252f, 0.03612753f, 
    -0.00121787f, -0.07088917f, -0.03811057f, 0.04214910f, -0.07587612f, -0.05775535f, -0.02095863f, -0.04237618f, 
    -0.04676210f, 0.00821029f, 0.01473876f, -0.02934372f, 0.00691996f, -0.06006961f, 0.01737900f, 0.00301635f, 
    0.00140635f, -0.03530544f, -0.04746702f, -0.05090763f, -0.05048162f, -0.00729810f, -0.05391560f, -0.00937491f, 
    -0.03674852f, -0.05813762f, -0.01318187f, -0.00054111f, -0.02557051f, -0.03278539f, 0.01407380f, -0.05517691f, 
    0.03838202f, -0.03747201f, -0.03214835f, 0.02014424f, -0.00510450f, -0.01943543f, -0.05160385f, -0.04204610f, 
    -0.00842972f, -0.04190455f, -0.00464817f, 0.03717544f, -0.00038629f, -0.01863328f, 0.00822319f, -0.04210600f, 
    0.00276683f, -0.04943254f, -0.03828104f, 0.01531087f, 0.00867594f, -0.04364259f, -0.02783979f, 0.00623655f, 
    -0.01198759f, -0.05449324f, 0.01366737f, 0.02103269f, -0.02915534f, 0.02326302f, -0.05981570f, -0.03528991f, 
    0.02738256f, -0.02907680f, -0.03471819f, -0.02657617f, 0.03185994f, -0.03992111f, -0.02697989f, 0.02172251f, 
    -0.11314225f, -0.04900666f, -0.10915343f, -0.10221308f, -0.15762469f, 0.03860105f, 0.05229672f, -0.05116324f, 
    -0.05632443f, 0.01458777f, 0.02510141f, -0.00187093f, 0.07828453f, 0.01531806f, 0.01581938f, -0.08614648f, 
    0.09333087f, 0.02188977f, 0.08198416f, -0.03716505f, 0.05762756f, 0.18473974f, 0.23415047f, 0.17054087f, 
    0.21624132f, 0.03445536f, 0.03986808f, 0.05293792f, 0.04475072f, 0.10309728f, -0.10882296f, 0.07846755f, 
    -0.01522913f, -0.03506127f, -0.02347552f, 0.07280883f, 0.02039565f, 0.08482967f, 0.01826383f, 0.01422621f, 
    -0.38475522f, -0.12774892f, -0.12471632f, -0.18013953f, -0.12405763f, -0.02894015f, -0.00364650f, -0.10714943f, 
    0.12546602f, -0.01938943f, 0.07885051f, 0.02129591f, -0.02399611f, 0.00670893f, 0.11859755f, -0.06694633f, 
    -0.00197143f, 0.09045960f, -0.00575150f, 0.08256754f, 0.23891215f, -0.16215740f, 0.06487183f, 0.04043709f, 
    0.02591630f, 0.00607445f, 0.08289842f, -0.06477938f, -0.03321610f, -0.18367165f, -0.09692126f, -0.12255494f, 
    -0.06330460f, -0.00950994f, 0.08146597f, -0.06364635f, -0.00326351f, -0.02839820f, -0.04948360f, 0.05137693f, 
    0.03182509f, -0.27092692f, -0.11314935f, -0.11475723f, -0.16906184f, -0.06452380f, 0.09568050f, -0.05881445f, 
    0.12243318f, 0.07171152f, -0.06375279f, -0.00379465f, 0.00011832f, -0.07216219f, 0.03296615f, 0.07206115f, 
    -0.00466375f, 0.06079173f, 0.01322703f, -0.03219687f, 0.17504123f, 0.15953577f, 0.06953767f, 0.03473940f, 
    0.14038779f, 0.05193944f, 0.08339635f, 0.07065535f, -0.08119668f, 0.05859337f, -0.03160448f, -0.07694972f, 
    0.00038708f, -0.00333277f, -0.05526077f, 0.03537710f, 0.14243695f, 0.06395724f, -0.01476762f, 0.03484523f, 
    -0.07008773f, 0.13278000f, -0.10444359f, 0.23332961f, 0.03146653f, 0.06868907f, 0.01958050f, 0.05371558f, 
    0.08874365f, -0.03082482f, 0.06603540f, 0.04242849f, 0.03351228f, 0.04607976f, 0.04361710f, 0.03543552f, 
    0.00799000f, 0.07495116f, 0.05286502f, -0.03926539f, 0.17235108f, 0.08933315f, 0.04388732f, 0.09764893f, 
    0.16541764f, -0.05766264f, 0.05244724f, 0.08243948f, -0.01753558f, -0.05305507f, 0.00846521f, -0.03265097f, 
    -0.12408564f, -0.06565514f, 0.03198148f, 0.05200636f, 0.00215330f, -0.02432562f, -0.06863249f, 0.11593239f, 
    -0.08853311f, 0.20811270f, 0.14503236f, 0.29148373f, 0.34425986f, 0.02061057f, 0.13249625f, 0.02196946f, 
    -0.14202552f, 0.03024453f, 0.05856344f, 0.01739504f, -0.02524159f, -0.00798179f, 0.08864770f, -0.01130729f, 
    -0.00507539f, -0.12546583f, -0.04317115f, 0.13879237f, -0.28926528f, 0.12310274f, 0.11622139f, -0.04038440f, 
    -0.09962475f, 0.04087222f, 0.02191510f, 0.01512196f, 0.01984845f, 0.09114034f, 0.08603839f, 0.08531857f, 
    0.02009171f, 0.13468811f, -0.01314752f, 0.10669417f, -0.04867274f, -0.03103537f, -0.02318325f, 0.03158701f, 
    0.09010493f, 0.34417191f, 0.11783598f, 0.05481619f, -0.02021059f, 0.08163324f, 0.09463766f, 0.06842364f, 
    0.01347355f, 0.03219023f, -0.02448191f, 0.06711180f, 0.02203419f, -0.06387156f, 0.00652768f, -0.01942455f, 
    0.04545292f, 0.07719144f, 0.05314871f, 0.11518499f, -0.34405240f, -0.22659086f, -0.20064330f, -0.05120813f, 
    -0.16107124f, 0.00110569f, 0.01490640f, 0.06916617f, 0.05541625f, -0.01244555f, 0.03120713f, -0.02735347f, 
    -0.04007435f, 0.12934801f, 0.10494812f, 0.05784694f, 0.01179941f, -0.00638130f, 0.07052502f, 0.07443485f, 
    0.12947361f, 0.07520173f, -0.16490088f, -0.00498921f, -0.03237703f, -0.09642799f, 0.02278529f, 0.18204746f, 
    0.06410418f, -0.06790589f, -0.10544696f, -0.01515789f, 0.07592595f, -0.01633717f, 0.08331010f, 0.02015028f, 
    0.06389373f, 0.03595344f, -0.03396330f, 0.07085323f, 0.28541186f, 0.20190732f, 0.03526368f, 0.04440285f, 
    0.03486871f, -0.04365851f, 0.00868756f, 0.15392086f, -0.11063165f, -0.08180622f, -0.11769261f, -0.02657162f, 
    -0.03414764f, -0.11569642f, -0.07115503f, 0.06791251f, -0.03748903f, 0.00419273f, 0.08580412f, 0.04193614f, 
    -0.09299696f, -0.02583203f, 0.05635368f, 0.04334075f, 0.10936907f, -0.02283999f, 0.04692278f, 0.09459668f, 
    -0.05715106f, -0.10256785f, 0.10300189f, 0.04736391f, -0.04911742f, -0.02860872f, 0.06627779f, -0.03495942f, 
    0.09516074f, 0.00724406f, -0.04280699f, 0.03835830f, 0.20207569f, -0.01885794f, -0.08861216f, -0.05730756f, 
    -0.13291374f, -0.00995711f, 0.06264408f, 0.12519373f, 0.00624485f, -0.13582504f, -0.12838857f, 0.02636534f, 
    0.11052191f, -0.06476409f, 0.03128748f, -0.04136308f, 0.01338189f, -0.07801560f, -0.07006733f, 0.07214286f, 
    -0.00311677f, -0.00825642f, 0.03465215f, -0.03874348f, -0.16789439f, 0.05259933f, -0.00993383f, 0.05814894f, 
    0.14996031f, -0.04090440f, -0.06044460f, -0.04518922f, -0.01183822f, 0.07071185f, -0.11236957f, 0.06462295f, 
    0.08899171f, -0.01532612f, -0.08589149f, 0.04127358f, -0.14729059f, 0.21030143f, -0.09357751f, 0.11879960f, 
    0.06419186f, 0.09674006f, 0.03628917f, -0.09863807f, -0.04646224f, 0.08049631f, -0.01964316f, 0.07245357f, 
    -0.00140188f, -0.02094602f, 0.00307618f, 0.02571607f, -0.07775516f, 0.03040023f, -0.08948523f, 0.00606697f, 
    -0.45519406f, 0.17062235f, -0.01787009f, -0.03857335f, 0.15582854f, -0.01608177f, -0.03110331f, -0.15762411f, 
    -0.06137849f, 0.01301181f, 0.06504708f, 0.02072027f, -0.03724040f, -0.05469561f, 0.11204939f, -0.02702861f, 
    -0.02132669f, 0.11319648f, 0.05024537f, -0.02543937f, -0.14338322f, 0.04874076f, 0.13263805f, 0.12318775f, 
    -0.08562671f, -0.06718605f, -0.04660880f, -0.09129466f, -0.03358517f, -0.09683909f, 0.09320837f, 0.10907810f, 
    -0.17899103f, -0.01859903f, -0.08001188f, -0.04659842f, -0.00782305f, -0.00572840f, 0.00612886f, 0.02100044f, 
    -0.07192648f, 0.20241010f, 0.04705365f, -0.00121500f, -0.00218252f, -0.00786970f, -0.01258561f, -0.06606600f, 
    -0.11738916f, -0.03095467f, 0.05860421f, 0.03739262f, -0.15828760f, -0.00226478f, 0.09688122f, 0.00786960f, 
    0.04497163f, 0.10339022f, 0.04900105f, 0.04978001f, 0.12114216f, -0.10578147f, 0.16060975f, 0.10272472f, 
    -0.07257162f, 0.07632954f, 0.04059623f, 0.00018261f, 0.19793348f, 0.02527882f, -0.09290491f, -0.07359501f, 
    0.11180747f, 0.09504244f, 0.04825076f, 0.14035223f, 0.05796205f, -0.08259254f, -0.03815734f, 0.00028268f, 
    -0.31963021f, -0.04979746f, 0.02418396f, 0.16983411f, -0.04615486f, 0.00467469f, 0.03759165f, -0.04191342f, 
    -0.03171791f, 0.07177810f, 0.02628921f, 0.09874256f, -0.06722061f, 0.01593179f, 0.06178974f, -0.07916059f, 
    0.09774894f, -0.01953436f, 0.01002700f, 0.04486145f, -0.20947731f, 0.16602089f, 0.13263819f, 0.23563996f, 
    -0.23081048f, 0.16335939f, 0.04910947f, 0.06826462f, 0.01530886f, 0.09791581f, 0.02509318f, -0.03713827f, 
    -0.02229046f, -0.06604520f, 0.06922500f, -0.01489579f, -0.13082291f, -0.05862981f, 0.07922110f, -0.05249813f, 
    0.00900251f, -0.05219328f, 0.02572488f, -0.09264226f, 0.30901447f, -0.09030518f, 0.07674752f, -0.07126077f, 
    -0.05294146f, 0.01863380f, -0.05065521f, -0.04411659f, -0.12612483f, -0.08780441f, -0.01026505f, -0.02368396f, 
    -0.09935901f, -0.12944025f, 0.19882227f, -0.07586824f, 0.20664397f, -0.11055399f, 0.08349975f, 0.12398180f, 
    0.13251318f, 0.03946071f, -0.15506198f, -0.10206100f, 0.01407111f, 0.03394442f, 0.00906836f, -0.03992931f, 
    0.04655490f, 0.25475496f, 0.05989267f, 0.05515873f, 0.06398863f, -0.09208725f, -0.02101972f, -0.03107508f, 
    -0.15031773f, 0.07381642f, 0.04228001f, 0.06439325f, -0.18431613f, 0.10321517f, -0.00892633f, 0.00623632f, 
    0.18856102f, -0.04667540f, -0.01642980f, 0.00166463f, 0.04426335f, 0.01621710f, -0.04807449f, 0.02652652f, 
    -0.02417684f, 0.06959508f, -0.13978268f, 0.09634015f, 0.03390499f, 0.10833325f, 0.11091834f, 0.17152910f, 
    -0.01111631f, -0.07620703f, -0.05860963f, -0.02821382f, -0.09725903f, 0.02910803f, -0.09710810f, -0.00448835f, 
    0.02061925f, -0.05650845f, 0.00409861f, -0.06812200f, 0.06553317f, 0.14748016f, 0.07730850f, 0.02194262f, 
    -0.01874866f, 0.11649648f, -0.08970633f, -0.00527634f, -0.22942597f, -0.04812360f, 0.11553261f, 0.06553793f, 
    -0.03682717f, -0.10409457f, 0.00844315f, -0.00310910f, 0.01591711f, -0.09883793f, -0.00780610f, -0.04875025f, 
    -0.00917798f, 0.01245623f, 0.02779109f, 0.12382668f, 0.13315648f, 0.10009282f, 0.10672145f, -0.00780505f, 
    0.01259669f, 0.15260473f, 0.07799798f, 0.08883439f, -0.06984121f, 0.06303393f, 0.01328447f, -0.07431298f, 
    0.05968435f, -0.01614901f, -0.07674435f, 0.06291389f, 0.02190088f, -0.08916216f, -0.17084962f, -0.00755623f, 
    0.02394330f, -0.21090887f, 0.04050105f, -0.02811190f, 0.00960830f, -0.04772760f, 0.00455149f, 0.07261457f, 
    0.15271704f, 0.01839988f, 0.02477304f, -0.00585721f, 0.01635292f, 0.04753534f, 0.04391575f, 0.00641918f, 
    -0.05490349f, 0.00958857f, -0.00285627f, -0.01660831f, 0.25398418f, 0.15342683f, -0.18119882f, -0.09516472f, 
    -0.09347776f, -0.04830970f, 0.12566145f, 0.01678375f, 0.05720538f, -0.06041158f, 0.06416731f, 0.09515012f, 
    -0.07379398f, -0.03405459f, -0.05624922f, 0.04146525f, 0.08299456f, -0.03695127f, 0.00798968f, 0.00539386f, 
    0.17943209f, 0.29888815f, -0.08773966f, 0.06195412f, 0.03297035f, -0.08242270f, 0.06452882f, -0.08946324f, 
    0.14045867f, 0.05995677f, 0.01037138f, 0.03750051f, 0.03843201f, -0.09448548f, 0.08478718f, 0.00811221f, 
    -0.04662045f, -0.01678192f, 0.11984086f, -0.07254037f, -0.08834093f, 0.08839536f, -0.23682873f, 0.04059625f, 
    0.09132560f, -0.15095519f, 0.10046436f, 0.00969536f, 0.07998279f, -0.01287979f, 0.07608953f, 0.06062202f, 
    0.06142388f, -0.09471007f, -0.09501227f, 0.05263847f, 0.02792439f, -0.09402049f, 0.05157886f, 0.02819627f, 
    0.17020276f, 0.30683297f, -0.15250355f, -0.15308526f, 0.34369472f, -0.01031833f, 0.10788986f, 0.12422492f, 
    0.09177275f, -0.03679910f, -0.00704506f, -0.00791676f, 0.14498210f, -0.05755988f, 0.13836959f, -0.02875273f, 
    0.03537758f, -0.10563780f, -0.08116796f, 0.00948065f, -0.38558781f, 0.04795424f, -0.07141886f, 0.12880020f, 
    -0.13505302f, -0.03486760f, 0.01203146f, 0.07903986f, 0.16496536f, 0.11391602f, 0.08693339f, 0.00381784f, 
    0.02958305f, 0.00668768f, -0.06465806f, 0.01792472f, 0.12133091f, -0.06656918f, 0.01572642f, 0.06162791f, 
    0.27645138f, -0.09487933f, 0.16638191f, -0.16066162f, 0.16782512f, 0.03050820f, 0.12329984f, 0.01814087f, 
    0.04251407f, -0.03430671f, -0.08693645f, 0.02880865f, 0.04737075f, 0.09603273f, 0.00577526f, 0.00960934f, 
    -0.02843479f, -0.11278395f, -0.08560604f, -0.03535215f, 0.05536829f, -0.42103246f, 0.02045973f, 0.12427301f, 
    -0.15611178f, 0.06761266f, 0.06705083f, 0.11602616f, 0.09684011f, -0.05959988f, 0.01021430f, 0.12655146f, 
    -0.00240161f, -0.00887221f, -0.02806221f, 0.03685168f, -0.08028942f, 0.03151118f, 0.12291769f, -0.03474029f, 
    -0.02516415f, 0.09554010f, 0.10635196f, -0.17776844f, -0.05890239f, -0.09993745f, 0.03149743f, -0.00710401f, 
    -0.06858990f, 0.08313257f, -0.11064271f, -0.03436274f, -0.00582660f, -0.04283296f, -0.03730180f, 0.10268687f, 
    -0.06835183f, -0.00032099f, 0.04765927f, 0.09860504f, -0.02650749f, -0.25412714f, 0.16514944f, 0.02721597f, 
    -0.18257467f, 0.08975163f, 0.00856605f, 0.09133773f, 0.09863945f, -0.20830850f, -0.02362032f, -0.03759558f, 
    -0.05338208f, 0.10903393f, -0.01016629f, 0.13459477f, -0.06935914f, -0.00401847f, 0.08707813f, 0.07050937f, 
    0.25558403f, -0.19461393f, -0.03271345f, -0.16862959f, 0.12768739f, 0.08499052f, -0.08824775f, 0.12052136f, 
    -0.00922225f, -0.10803191f, 0.05028175f, -0.02556258f, 0.02145728f, -0.11120043f, 0.15147404f, -0.03043306f, 
    0.04625565f, 0.11992078f, -0.14260863f, -0.14009491f, 0.29875159f, 0.16614169f, -0.08267079f, -0.03008943f, 
    -0.00553785f, -0.00928022f, -0.10967827f, -0.12337381f, 0.05747085f, -0.00868718f, 0.19145909f, 0.14215508f, 
    -0.11700966f, -0.02782486f, -0.02481773f, 0.06107247f, 0.08083346f, 0.05754226f, 0.03109348f, 0.00539038f, 
    -0.08133021f, 0.05023424f, -0.16347863f, 0.09276847f, -0.06486692f, -0.10329656f, 0.02104579f, 0.02863220f, 
    0.06274256f, 0.01284201f, -0.03130665f, -0.06048219f, -0.03003052f, -0.08591639f, -0.05816813f, 0.00847532f, 
    -0.00746601f, 0.01800293f, 0.13329306f, -0.01789135f, -0.15991929f, 0.03100233f, 0.04053397f, -0.14792289f, 
    0.16230887f, -0.06117857f, -0.09455734f, 0.04218867f, 0.07958271f, 0.17010532f, -0.05674620f, 0.06336874f, 
    -0.01002322f, -0.03515553f, -0.02991308f, 0.06592059f, 0.03211482f, -0.10019764f, -0.09760100f, 0.06600509f, 
    0.01946503f, 0.26882645f, 0.08930910f, 0.05651965f, 0.03204216f, 0.05652247f, -0.06616450f, -0.07830764f, 
    0.05544396f, 0.10925233f, 0.05062314f, -0.06356899f, -0.12582247f, -0.00159727f, -0.02772390f, -0.05769830f, 
    -0.00831623f, 0.01274670f, -0.21991749f, 0.03923043f, -0.06627462f, -0.23547523f, 0.06904258f, 0.22068508f, 
    -0.08098304f, -0.01637344f, -0.01880070f, 0.05531140f, 0.13508441f, -0.08081577f, -0.05271519f, 0.04683039f, 
    -0.09510399f, 0.08597265f, -0.03250077f, 0.10110380f, 0.03855575f, -0.01158203f, 0.17198548f, -0.06861662f, 
    0.17032322f, 0.02270560f, -0.16090423f, 0.14158970f, -0.08947636f, 0.11374464f, 0.07063024f, 0.06810810f, 
    -0.05675574f, 0.00843538f, -0.07058764f, 0.00795739f, 0.01497045f, 0.03512035f, 0.03203643f, 0.00158690f, 
    -0.07124703f, 0.00649079f, -0.05925003f, -0.14838128f, -0.05499529f, 0.09273624f, 0.21096924f, 0.07768713f, 
    -0.09683777f, -0.00869603f, -0.02736739f, -0.05707338f, -0.03854443f, 0.13440545f, -0.03854563f, -0.04426694f, 
    0.03115940f, 0.11824001f, 0.00397600f, -0.02637192f, 0.08010615f, 0.03862524f, -0.13182583f, -0.08442153f, 
    0.35182104f, 0.08507541f, 0.02016805f, 0.06075240f, -0.10312498f, -0.08119527f, -0.02048694f, -0.07768543f, 
    0.07391283f, 0.00641104f, -0.04747335f, -0.05985902f, 0.02793494f, -0.01489945f, 0.07857104f, 0.11381240f, 
    0.04567158f, 0.13109204f, 0.03071044f, 0.10761326f, -0.26952007f, 0.35653335f, -0.18048593f, -0.00387719f, 
    0.06441382f, 0.10611808f, 0.12833045f, 0.05606230f, -0.02301878f, -0.10286137f, 0.08304600f, -0.08959188f, 
    0.05657457f, -0.05090084f, -0.07505945f, 0.11933405f, 0.01549974f, -0.05783786f, 0.03247083f, 0.06366238f, 
    0.29651529f, 0.43159959f, -0.20563008f, -0.31706199f, 0.12472287f, -0.09824855f, 0.09028664f, -0.00446420f, 
    0.01263878f, -0.11999410f, 0.01992653f, 0.05504072f, 0.12310247f, -0.00100130f, 0.01418300f, -0.01634561f, 
    0.05396958f, -0.14586855f, -0.01975419f, 0.01962630f, -0.05631709f, 0.08734707f, -0.08835059f, 0.06945352f, 
    -0.04925755f, 0.05965125f, 0.02612552f, -0.08409875f, -0.04549266f, 0.02361129f, 0.03980177f, 0.17872879f, 
    -0.02737337f, -0.01171570f, -0.05199277f, 0.00453484f, 0.17055638f, 0.00642787f, 0.02183894f, 0.00865015f, 
    0.14319785f, 0.32023540f, 0.12531568f, -0.11461268f, 0.14147747f, -0.02420654f, 0.06281324f, 0.03226814f, 
    0.05099895f, 0.03645805f, -0.00430579f, 0.03177332f, -0.05860241f, 0.10081361f, -0.06984479f, 0.04957831f, 
    0.20849156f, -0.08057710f, 0.07589266f, -0.01566444f, 0.21636653f, -0.00949435f, 0.12392637f, 0.03991513f, 
    -0.25465238f, 0.01142255f, 0.10090309f, 0.03636371f, 0.00936612f, 0.03476036f, 0.01557411f, 0.04874405f, 
    0.09357004f, 0.04236947f, 0.10711571f, 0.07594856f, 0.06237400f, 0.03235134f, 0.09099685f, 0.18337686f, 
    0.11610787f, 0.07125881f, 0.05178609f, -0.14474203f, -0.03181946f, -0.02690528f, 0.03107032f, -0.09957922f, 
    0.09479416f, 0.03526742f, -0.03551517f, 0.04801130f, 0.02879937f, -0.00923559f, -0.07666489f, -0.08007930f, 
    0.06149144f, 0.00612772f, 0.08117622f, 0.16007999f, -0.05166519f, -0.10579864f, -0.04152827f, -0.04543577f, 
    -0.26794523f, 0.09357658f, 0.00017933f, -0.03892287f, 0.00036671f, 0.09993902f, -0.01372846f, -0.09468895f, 
    0.05092485f, 0.15115136f, 0.11452561f, 0.05909929f, 0.04757043f, 0.06304015f, 0.11195424f, -0.01548318f, 
    0.10155223f, -0.53402853f, -0.19255900f, -0.12922277f, 0.02390487f, -0.05476125f, -0.12479118f, 0.19745286f, 
    -0.01210058f, -0.02397293f, 0.01694445f, 0.03557718f, 0.00143683f, 0.08568799f, 0.08741029f, -0.06691033f, 
    -0.00331214f, 0.09890616f, 0.00224771f, -0.11155041f, -0.01046926f, -0.14063390f, -0.09958079f, 0.02642310f, 
    0.22033188f, 0.08453526f, 0.02890660f, 0.08035693f, -0.09213461f, -0.01041726f, 0.07209364f, 0.07785448f, 
    0.01499651f, -0.03723967f, 0.04790777f, 0.02877835f, 0.09742367f, 0.09060184f, 0.03376762f, -0.05244484f, 
    0.02257247f, 0.01401237f, 0.04340313f, 0.11778594f, -0.21388094f, 0.03684894f, 0.03069112f, 0.00831784f, 
    0.08687534f, -0.04691019f, -0.01846527f, -0.02157793f, 0.03851712f, 0.06986984f, -0.01185971f, 0.04989427f, 
    0.04066705f, -0.10852790f, 0.09228588f, 0.01776434f, -0.12430323f, 0.04406609f, 0.02597011f, -0.08832183f, 
    0.16260326f, -0.11553530f, -0.02556268f, -0.03382150f, -0.00212449f, 0.00959034f, -0.03551050f, 0.12039305f, 
    0.09666412f, 0.01325028f, 0.02675288f, 0.10419084f, 0.14460050f, -0.01555583f, -0.02948695f, 0.06576241f, 
    0.22873706f, 0.14785889f, -0.17123432f, 0.03897449f, -0.14628275f, -0.13564427f, -0.06291410f, -0.07401510f, 
    0.13115644f, 0.01786768f, 0.03467617f, -0.05552965f, -0.10348304f, -0.02168418f, -0.03069013f, -0.05270959f, 
    -0.00957644f, -0.04485228f, 0.06224894f, 0.08747923f, 0.05332696f, -0.08663754f, 0.05232270f, 0.03984442f, 
    -0.21626221f, 0.01515048f, 0.08585383f, 0.05187235f, 0.09086937f, 0.07624181f, -0.03016557f, 0.02606896f, 
    0.12663946f, 0.07233592f, 0.06065630f, -0.00198684f, 0.09723634f, 0.00208116f, -0.02102245f, 0.05808565f, 
    0.21149108f, 0.07095700f, 0.01607916f, 0.09876459f, -0.18207219f, -0.00723993f, -0.07870521f, 0.09954154f, 
    0.04838240f, 0.06742940f, 0.05354234f, -0.12502873f, 0.03722182f, 0.02013699f, 0.10652372f, 0.05584431f, 
    0.03704723f, 0.12174711f, 0.06505378f, -0.00679957f, 0.09083833f, 0.01904791f, -0.09763325f, 0.04743310f, 
    -0.01079973f, -0.15532987f, -0.11888296f, -0.00972324f, 0.03448477f, 0.13776109f, -0.04593775f, 0.03157236f, 
    -0.04222187f, 0.03576595f, 0.16512972f, 0.02365621f, 0.06242837f, 0.08703424f, -0.02540046f, -0.01241393f, 
    -0.07397912f, 0.08126869f, 0.10296275f, -0.10865487f, -0.09138332f, 0.03007109f, 0.02425184f, 0.04125629f, 
    -0.06416114f, 0.02084272f, -0.01009432f, -0.04738116f, -0.00599867f, -0.04268302f, -0.07215852f, 0.01608602f, 
    -0.06236018f, 0.03483002f, 0.02053109f, -0.06931708f, 0.04694437f, 0.19134375f, -0.06623723f, 0.19422403f, 
    0.10633264f, 0.06969027f, -0.01244853f, -0.07445304f, 0.05371008f, 0.00884639f, -0.08884126f, -0.03256334f, 
    -0.01049136f, 0.12555714f, -0.10872271f, 0.03695271f, 0.03087118f, -0.03442624f, 0.01290259f, -0.03725011f, 
    -0.45734239f, 0.17497188f, -0.11877479f, -0.15215211f, -0.06873578f, -0.00703971f, 0.10284328f, -0.08036333f, 
    0.08856729f, 0.02836264f, -0.01182863f, -0.02557040f, 0.00508994f, 0.02226312f, -0.05946332f, -0.03919466f, 
    0.00066646f, -0.03111920f, -0.02760222f, 0.05838170f, -0.44840342f, 0.09095778f, 0.03668220f, 0.03637800f, 
    0.10598197f, 0.00117032f, 0.02457677f, -0.00098780f, 0.07376342f, 0.03384099f, 0.04125886f, -0.01794126f, 
    0.06522265f, 0.02321867f, 0.08591783f, -0.07030964f, -0.02788759f, -0.13251494f, -0.05881807f, -0.02778329f, 
    -0.02563376f, -0.10295936f, 0.10032339f, -0.04721824f, 0.00528868f, 0.01410926f, 0.00384942f, 0.03191496f, 
    0.00673334f, -0.01073581f, -0.06656103f, 0.10246282f, -0.03129778f, 0.01441745f, -0.05316624f, -0.01630496f, 
    -0.14196914f, 0.07664131f, -0.13854660f, 0.00500692f, 0.09221651f, 0.10216892f, -0.04501126f, -0.00248412f, 
    0.13033381f, 0.09958701f, -0.02368625f, -0.07130679f, -0.05011411f, -0.01461884f, 0.02549166f, 0.00413261f, 
    0.01836638f, 0.02297372f, 0.04725665f, 0.05362552f, -0.03491958f, 0.10346445f, 0.07304856f, -0.04097311f, 
    0.17320429f, -0.09464274f, 0.07479740f, 0.14781415f, 0.01939634f, 0.02054424f, 0.10949393f, -0.04328912f, 
    0.03992824f, 0.04871970f, -0.03988211f, 0.07588387f, -0.08070331f, 0.01801590f, 0.05845216f, 0.00293808f, 
    0.02956260f, 0.03453970f, 0.08754247f, 0.12083413f, -0.12783146f, -0.17205146f, 0.06802870f, 0.29191768f, 
    0.10366264f, 0.00009601f, 0.00402535f, 0.00865603f, -0.05226318f, -0.11450317f, 0.10690670f, 0.01433421f, 
    0.03353309f, -0.01750074f, 0.10227845f, 0.03944347f, -0.11342292f, -0.07544341f, 0.11273114f, 0.11181649f, 
    0.27083865f, 0.35342512f, -0.14220066f, 0.25936455f, 0.16603523f, 0.12543641f, 0.11463833f, -0.03835600f, 
    -0.01314457f, 0.13898094f, 0.00212292f, 0.05441559f, -0.03433847f, -0.05689825f, -0.05098519f, 0.06181991f, 
    0.02868746f, 0.04109195f, -0.10454942f, -0.03777446f, 0.36842480f, 0.18197636f, -0.20709555f, -0.02707527f, 
    0.25253901f, 0.02457730f, -0.10983487f, -0.03410794f, 0.00558412f, -0.07713274f, 0.12913287f, 0.10011882f, 
    -0.02580785f, 0.14212552f, -0.03777730f, 0.04523975f, 0.04506239f, 0.00110762f, -0.04747169f, 0.02323189f, 
    -0.14660393f, 0.26734304f, 0.01284444f, -0.00978566f, 0.19359119f, 0.02580829f, 0.06663077f, -0.07289064f, 
    0.05913774f, 0.00216148f, -0.08861113f, -0.03457634f, -0.03919781f, 0.12568611f, 0.06955871f, -0.04432321f, 
    0.00813530f, 0.03851616f, 0.02304137f, -0.03418544f, -0.20788710f, -0.19513865f, -0.07472961f, -0.07591683f, 
    -0.15967609f, -0.10255750f, -0.04224532f, 0.05520513f, 0.03177839f, 0.11538838f, -0.01902069f, -0.00625538f, 
    0.06389389f, -0.02091832f, 0.04514663f, -0.03876621f, 0.00902089f, -0.07721122f, -0.03775543f, 0.02372845f, 
    -0.05015341f, 0.13450980f, -0.00247538f, -0.02380938f, -0.01198764f, -0.15978302f, 0.06209014f, 0.00384024f, 
    0.09735377f, -0.09252664f, -0.06151345f, 0.02370374f, -0.02860109f, -0.04782160f, 0.06752318f, -0.02411579f, 
    0.02817903f, -0.01114444f, -0.08357839f, 0.07632139f, 0.01739635f, 0.18044484f, -0.03470782f, -0.00395026f, 
    0.13718148f, -0.00150307f, -0.12906216f, -0.08724236f, -0.11205430f, -0.05204576f, 0.05129810f, 0.04481997f, 
    -0.00891452f, -0.02600165f, -0.04207876f, 0.05664200f, 0.00029946f, 0.04909156f, 0.06579299f, -0.03336636f, 
    0.04912854f, 0.05063134f, 0.02929062f, -0.02653996f, -0.01427729f, 0.01069729f, -0.00101165f, -0.00828414f, 
    -0.00661867f, 0.04591601f, -0.01364598f, 0.05507698f, 0.01973910f, -0.08816802f, 0.06577364f, 0.03401506f, 
    0.03955960f, -0.01246866f, 0.00872825f, 0.01916944f, 0.03674773f, 0.05434497f, 0.04595750f, -0.00527285f, 
    -0.10266111f, -0.01166351f, 0.00990847f, 0.06774089f, -0.00049962f, -0.11137148f, 0.00071202f, -0.03837172f, 
    0.07020672f, 0.05781998f, -0.01555415f, -0.03574736f, 0.06940964f, -0.03505970f, -0.01740641f, -0.02784394f, 
    -0.02198505f, 0.04309286f, -0.00924715f, 0.01425335f, 0.02729296f, 0.03601992f, 0.02529065f, -0.02893303f, 
    -0.03768085f, 0.03389006f, -0.01862676f, -0.04614790f, -0.02027317f, -0.00272356f, -0.01697801f, 0.01722451f, 
    -0.05430677f, 0.01597214f, 0.01482404f, -0.04251662f, -0.05101610f, -0.02722576f, -0.01355651f, 0.03546056f, 
    -0.03210059f, 0.02983003f, -0.03377952f, -0.05279798f, 0.00205132f, 0.03159940f, -0.04255663f, 0.03056994f, 
    0.00132049f, 0.00983636f, 0.02791763f, -0.02769818f, 0.03333835f, 0.03209091f, 0.02329108f, -0.02289857f, 
    0.01434429f, -0.04506280f, -0.00693322f, -0.00510783f, 0.04731158f, -0.01351563f, -0.05326216f, -0.02098144f, 
    0.01846612f, -0.04400328f, -0.01653033f, -0.03121139f, -0.03637110f, 0.00310918f, -0.00340855f, 0.03753021f, 
    -0.03980816f, -0.02950132f, 0.01711273f, 0.01845243f, -0.05011609f, -0.02534266f, 0.03313100f, 0.01688450f, 
    0.03844304f, -0.04988811f, 0.00238418f, -0.00494032f, 0.03394576f, 0.02392366f, -0.03825718f, 0.00849875f, 
    0.04965118f, 0.02263890f, -0.00542877f, 0.03424491f, -0.00940630f, 0.00224335f, 0.04418006f, 0.02679796f, 
    -0.02290226f, 0.04190786f, 0.03999859f, 0.04386607f, 0.02425598f, -0.04720994f, -0.03496615f, -0.00782699f, 
    -0.03779717f, 0.04314671f, 0.04117734f, -0.02384733f, -0.02799370f, -0.01478952f, -0.06097386f, -0.04161084f, 
    0.00306120f, -0.00224966f, -0.03806248f, -0.03074734f, -0.00228074f, 0.02624070f, -0.02839165f, 0.04060783f, 
    0.02507580f, -0.02285356f, -0.01100225f, 0.03721233f, -0.00281355f, -0.01279515f, -0.02003726f, -0.02546911f, 
    0.00785588f, -0.04646843f, 0.02061949f, -0.01595140f, -0.02162276f, -0.00957346f, -0.02290077f, 0.04159532f, 
    -0.02259705f, 0.04193459f, 0.02297080f, -0.04475187f, 0.00297765f, 0.01524378f, -0.03387631f, -0.00251387f, 
    -0.02952149f, -0.04417768f, 0.00482175f, 0.02503791f, -0.01755368f, 0.02822274f, -0.02223853f, -0.05135328f, 
    -0.06306181f, -0.04652464f, -0.02504152f, -0.03912262f, 0.03594188f, -0.03320553f, 0.01956259f, 0.04636765f, 
    0.05074404f, 0.02612417f, 0.01253472f, -0.05692750f, 0.03116004f, 0.00778069f, -0.01610485f, -0.00687588f, 
    -0.04262194f, -0.00867238f, -0.06479862f, -0.05348367f, -0.01314946f, -0.00831616f, 0.00688739f, 0.04289119f, 
    0.03926989f, -0.02421002f, 0.00623605f, 0.02585101f, 0.00255202f, -0.01108512f, -0.06192901f, 0.04754427f, 
    -0.01002197f, 0.00216042f, -0.00448578f, 0.01636892f, 0.00489111f, -0.02960129f, 0.02642023f, -0.05203712f, 
    0.01311744f, -0.03262047f, -0.03409776f, 0.02406517f, 0.02066385f, -0.00153344f, 0.01772006f, -0.04174921f, 
    0.02918196f, 0.01353815f, -0.06509324f, -0.03966566f, -0.00181660f, -0.05662390f, -0.00238724f, -0.02045902f, 
    -0.00934459f, -0.03225831f, 0.03281922f, 0.02171328f, 0.03235001f, -0.05098341f, -0.02474224f, -0.05200069f, 
    0.03973555f, -0.02382519f, -0.03626244f, 0.00888698f, -0.02369030f, -0.02214467f, 0.03043721f, -0.04699670f, 
    -0.00836693f, 0.02754073f, -0.03306472f, 0.03179579f, -0.05808808f, -0.05374940f, -0.00959386f, -0.03736483f, 
    -0.01574338f, -0.06217142f, 0.01602414f, -0.03188897f, 0.04102987f, 0.02317156f, -0.06024019f, -0.05996102f, 
    0.01621063f, -0.04742231f, 0.04378625f, 0.03068780f, 0.01039274f, 0.01833650f, -0.03959910f, 0.03487298f, 
    -0.04591808f, -0.01194008f, -0.01326566f, 0.00358409f, 0.00655306f, 0.00347692f, 0.01825050f, 0.01806085f, 
    0.00030644f, 0.01435456f, -0.04264635f, -0.04912159f, -0.04261813f, -0.06191055f, -0.01224539f, 0.00384761f, 
    -0.02325889f, -0.06162239f, 0.04512718f, -0.00624033f, -0.00741086f, 0.03430620f, 0.03028483f, -0.03589160f, 
    -0.00093849f, -0.03803090f, 0.02601437f, 0.04320372f, -0.03059561f, 0.03903241f, -0.01870867f, -0.01060667f, 
    -0.04298376f, 0.04875556f, -0.05425157f, -0.03228455f, -0.03161931f, -0.02633061f, 0.03859810f, 0.01191213f, 
    -0.04353615f, -0.01597576f, -0.01930470f, -0.03537131f, 0.00221845f, 0.02368853f, -0.03222606f, -0.03552654f, 
    -0.04335513f, 0.04077165f, -0.02993237f, 0.01666918f, 0.00136830f, 0.02086961f, 0.03554659f, -0.03551783f, 
    -0.04336280f, -0.02037952f, -0.03249577f, 0.04605801f, -0.01095208f, -0.04192436f, -0.04177980f, -0.05972818f, 
    0.00837369f, 0.00935528f, -0.05546809f, 0.00612612f, -0.01715805f, -0.03534090f, 0.02423990f, 0.02423377f, 
    -0.00431934f, -0.00285950f, -0.06348100f, -0.00973983f, -0.05869282f, -0.04989737f, 0.03320643f, -0.04945845f, 
    0.02033676f, -0.00338336f, 0.04030598f, 0.00375148f, -0.03470881f, 0.00214925f, -0.00255922f, 0.00752202f, 
    0.19807266f, 0.10438885f, 0.13405706f, -0.06502944f, -0.02824323f, -0.03888134f, -0.03577306f, 0.02583455f, 
    -0.04691754f, 0.12259360f, -0.00338844f, 0.02316506f, 0.13197742f, -0.03843940f, -0.00054850f, -0.05721953f, 
    0.05373743f, 0.00870975f, 0.01127844f, -0.03939264f, -0.37558505f, 0.31280506f, 0.18408470f, -0.02296018f, 
    0.18038215f, 0.11844424f, 0.04132614f, 0.09606111f, -0.02111783f, 0.01828135f, 0.00385977f, -0.02984208f, 
    -0.02682496f, 0.04987365f, -0.05327462f, 0.13934284f, 0.01715677f, -0.06048724f, 0.01445390f, 0.09763763f, 
    -0.47514477f, -0.08038547f, -0.03061621f, -0.21086417f, -0.17667256f, -0.05547072f, -0.02533159f, -0.16050312f, 
    0.01331359f, 0.02510378f, 0.04569325f, 0.03423010f, -0.01689791f, 0.03920833f, 0.04231092f, 0.06287678f, 
    0.15205604f, -0.01533202f, -0.00597547f, 0.03277567f, -0.07823721f, -0.34500271f, 0.16691184f, -0.07309708f, 
    0.25082326f, 0.03629338f, -0.01822124f, -0.05701706f, -0.00217441f, 0.00082261f, -0.08685246f, -0.05830706f, 
    -0.10505746f, 0.02324740f, 0.05195041f, -0.06467447f, -0.02255188f, 0.01724283f, -0.03992575f, 0.07986642f, 
    -0.15990102f, 0.01456272f, -0.18091357f, -0.00204870f, -0.11630036f, 0.01952481f, -0.00098155f, -0.11994285f, 
    0.09500971f, 0.02293783f, -0.09425372f, 0.06592158f, 0.03074460f, -0.08562154f, 0.02545339f, -0.00406968f, 
    0.01034056f, 0.10727642f, 0.04882832f, 0.00676273f, 0.14721100f, 0.37716231f, -0.05321747f, 0.00084754f, 
    -0.01269819f, -0.01157363f, 0.07842095f, 0.03175365f, -0.08466900f, 0.02426295f, 0.04751295f, -0.03247839f, 
    0.03024231f, -0.04899253f, 0.00089218f, -0.02451151f, 0.04773081f, 0.07044029f, -0.02369816f, 0.06461032f, 
    0.02288364f, 0.13505189f, -0.19317438f, -0.08657701f, 0.01194837f, 0.05166800f, -0.07222543f, -0.06906080f, 
    0.11123865f, 0.03397757f, 0.02413841f, 0.15281475f, 0.01408018f, -0.01040930f, -0.11443212f, -0.02173651f, 
    0.03606976f, -0.05746675f, -0.04699608f, -0.01708062f, -0.09636946f, 0.06236074f, -0.14481312f, 0.11339064f, 
    0.02211097f, -0.09115256f, 0.03203153f, -0.00155504f, -0.09945828f, 0.07051376f, 0.01131731f, -0.07971851f, 
    -0.04678929f, 0.00541911f, 0.08289473f, 0.01991630f, 0.07681008f, 0.04794683f, -0.07431599f, -0.04257256f, 
    -0.03922364f, 0.05942207f, -0.21687056f, 0.22928119f, 0.11225332f, -0.08019169f, 0.12207087f, -0.08178572f, 
    0.03859573f, -0.01529627f, 0.06381431f, 0.04453977f, -0.02979489f, 0.05371217f, 0.01385322f, -0.10843319f, 
    0.02961947f, -0.09912626f, 0.06903347f, 0.03558050f, -0.28455782f, -0.34043697f, -0.01726148f, -0.01626888f, 
    -0.12695794f, 0.13487729f, 0.06300728f, 0.03439465f, 0.02492392f, -0.01369286f, 0.21167488f, 0.08454126f, 
    0.07806697f, 0.01425413f, 0.02389898f, 0.10988237f, 0.02814999f, 0.05976268f, 0.00807510f, -0.09217418f, 
    -0.08338036f, 0.25058895f, 0.26092982f, -0.01025222f, 0.06087215f, 0.03583239f, 0.01603840f, 0.00131273f, 
    0.00642830f, 0.06119860f, -0.03091847f, 0.05976973f, 0.05540103f, 0.08480297f, 0.02818014f, 0.02616108f, 
    -0.03128302f, -0.00942029f, 0.07606764f, 0.05007761f, -0.33807763f, -0.26793882f, -0.20009777f, -0.17167962f, 
    -0.10409285f, -0.01756987f, 0.00275702f, -0.02676572f, 0.08896196f, -0.00587768f, 0.00982645f, 0.04392351f, 
    0.03213144f, -0.01255351f, 0.03280341f, 0.00599555f, 0.04686235f, 0.03570662f, 0.04005695f, 0.04060442f, 
    0.11769249f, 0.10255131f, -0.07124512f, 0.02580076f, 0.01764220f, -0.16558997f, -0.06551096f, 0.03446018f, 
    0.05545621f, 0.03657825f, -0.10170193f, 0.00761785f, -0.02927060f, 0.04443790f, 0.08052648f, -0.03208062f, 
    -0.02594086f, 0.04415763f, 0.04055293f, -0.00781112f, 0.20316212f, 0.34645963f, 0.02997063f, -0.05407535f, 
    -0.00269366f, -0.04980746f, 0.07930704f, 0.10707849f, -0.01144539f, -0.04720311f, 0.02614367f, -0.07092751f, 
    0.01069316f, -0.00263183f, 0.04599987f, 0.04149942f, 0.00447963f, 0.04088386f, 0.09109239f, 0.12751448f, 
    0.05407871f, 0.27416489f, 0.04741255f, 0.02634180f, -0.02262283f, -0.02681136f, -0.05112486f, -0.01798486f, 
    -0.00412296f, -0.04310275f, 0.15481535f, 0.07245120f, 0.01683384f, 0.11304731f, 0.01527153f, 0.02048901f, 
    0.02932441f, 0.04142937f, -0.04012543f, 0.04595975f, 0.21182984f, -0.00414891f, -0.03658744f, 0.15334816f, 
    -0.00316545f, -0.11671829f, -0.11403625f, 0.03093925f, -0.00852396f, 0.04093832f, -0.06457885f, -0.00326532f, 
    0.08236274f, 0.00511782f, 0.07029811f, -0.02453364f, 0.02981531f, -0.05309913f, 0.07807747f, 0.03027249f, 
    -0.12914963f, 0.03441278f, 0.10930930f, -0.09945543f, -0.13083379f, -0.02008968f, 0.05978826f, 0.05692384f, 
    -0.21095695f, 0.02616305f, 0.07279669f, -0.03871300f, 0.05343146f, 0.00024583f, 0.05842786f, -0.02255108f, 
    -0.05989366f, -0.07579060f, 0.05133577f, -0.14078735f, 0.10635290f, 0.14588585f, 0.08736455f, 0.07291871f, 
    0.18686228f, 0.12797910f, -0.00188131f, 0.07937489f, 0.04759464f, -0.04449597f, -0.10910092f, 0.04472353f, 
    -0.04763039f, 0.04695794f, 0.01637026f, 0.04903208f, 0.03106649f, 0.04744405f, 0.05821462f, 0.04317186f, 
    -0.44321990f, 0.06899241f, 0.06685598f, 0.03244480f, -0.05910151f, -0.04725791f, 0.05240186f, 0.00306925f, 
    0.09261107f, 0.05017112f, -0.03084971f, -0.06028000f, -0.00261528f, 0.04712194f, -0.04186439f, -0.03485293f, 
    -0.03775650f, -0.04013274f, -0.05047208f, 0.05339288f, -0.28725490f, -0.12035158f, 0.19038445f, -0.04168342f, 
    0.10172381f, 0.04464747f, -0.08642285f, 0.07369140f, 0.05131869f, -0.08686440f, -0.05693207f, -0.07052618f, 
    0.00906072f, 0.04514975f, 0.09837571f, -0.01352501f, -0.02939510f, -0.07601465f, 0.03634873f, -0.03518178f, 
    0.13448931f, -0.41808367f, 0.02658199f, 0.11332179f, 0.00127413f, -0.09291454f, 0.00798837f, -0.06380375f, 
    0.00987811f, -0.08348484f, -0.08501360f, 0.08993259f, 0.06867791f, -0.04580560f, 0.12538326f, -0.01455455f, 
    -0.12504540f, -0.01724562f, 0.04585363f, 0.01475544f, 0.09254816f, 0.18229823f, -0.10633262f, -0.09208287f, 
    0.15907606f, 0.03148775f, -0.00984495f, -0.02252120f, -0.04040904f, 0.02996288f, -0.04892245f, 0.00311605f, 
    -0.01233378f, -0.02115297f, -0.04606121f, -0.04914214f, -0.02467197f, 0.09846696f, 0.10226538f, -0.03673852f, 
    0.21523517f, -0.04869286f, -0.04369408f, 0.28936267f, 0.05741280f, 0.08673754f, 0.02827910f, 0.09478839f, 
    -0.00483265f, -0.02036816f, 0.10520701f, 0.03435811f, -0.03297391f, 0.06524859f, -0.07305049f, 0.08684610f, 
    -0.02821082f, 0.06010639f, -0.03212405f, 0.08680234f, -0.05144061f, -0.15652388f, 0.07177466f, 0.01777748f, 
    0.11206445f, -0.07473551f, 0.04340668f, 0.16937746f, 0.01274453f, -0.08520920f, -0.07182144f, -0.04574666f, 
    -0.04575944f, -0.00626133f, 0.03839004f, 0.03610959f, -0.05139347f, 0.02133858f, 0.00757796f, 0.10987971f, 
    0.16418578f, 0.44668952f, -0.00879280f, 0.28703520f, 0.20287006f, 0.08968853f, 0.02568941f, -0.08575609f, 
    0.03012387f, -0.01195420f, 0.09235655f, 0.10702127f, -0.00283145f, -0.09917719f, -0.11326114f, -0.00790345f, 
    -0.04287433f, -0.05224569f, -0.06668461f, 0.02859759f, 0.19524539f, 0.27700451f, -0.10189131f, -0.12895201f, 
    -0.02941628f, 0.13323475f, 0.04996857f, -0.03559725f, 0.13195901f, 0.10942019f, 0.13155869f, 0.07008576f, 
    0.04697002f, 0.07247879f, -0.11325496f, 0.06253057f, 0.03487734f, -0.00491167f, 0.07301976f, 0.00386925f, 
    -0.14278424f, 0.37366521f, 0.03323730f, 0.08132394f, 0.06734956f, 0.05334465f, 0.05703136f, -0.00336493f, 
    -0.03407238f, 0.01719758f, -0.10942267f, -0.08300398f, -0.00588296f, -0.01996590f, 0.02460162f, -0.05019901f, 
    0.07888342f, 0.12671532f, 0.01101890f, 0.01386683f, -0.14812687f, -0.29231277f, -0.14114130f, 0.05243461f, 
    -0.06609646f, -0.04410916f, -0.01068279f, 0.05972021f, 0.14214283f, 0.16683833f, -0.06754684f, 0.02087639f, 
    0.02957073f, -0.01157020f, -0.01219834f, 0.06654685f, -0.04053037f, -0.11222042f, -0.02634648f, 0.01872130f, 
    0.12710296f, 0.01086744f, 0.14770584f, -0.03538272f, -0.09711963f, -0.15138108f, 0.01280855f, 0.03171530f, 
    -0.00475401f, -0.21418828f, -0.01771863f, 0.03574061f, 0.04510884f, 0.09337071f, 0.06467775f, 0.02788286f, 
    0.12103031f, 0.00249176f, -0.10321528f, 0.10432881f, -0.00627379f, 0.17370906f, -0.05435855f, -0.26197997f, 
    0.08408502f, -0.08488794f, -0.12289465f, 0.08034445f, -0.15674923f, -0.08311814f, -0.05646789f, 0.00327057f, 
    -0.12789369f, -0.02175580f, -0.01612877f, 0.12192669f, -0.12623325f, 0.00745575f, 0.16224819f, 0.00961020f, 
    0.07271538f, 0.08420596f, 0.07425264f, -0.01666211f, 0.09785063f, 0.06160400f, 0.01725038f, -0.00645261f, 
    -0.09761787f, -0.03374654f, -0.03661970f, 0.10697761f, -0.03598304f, -0.03868510f, -0.01397851f, 0.00247799f, 
    -0.01963447f, 0.04264950f, 0.09049848f, -0.00927123f, 0.19190747f, -0.11979255f, 0.04858571f, -0.07540010f, 
    -0.15573831f, 0.00115080f, 0.03982127f, 0.02399032f, 0.00244356f, -0.05358668f, -0.09056439f, 0.01618085f, 
    0.08642595f, 0.14857775f, -0.06011948f, 0.09120587f, 0.07415313f, -0.07386914f, -0.07332744f, 0.06690408f, 
    -0.20942213f, -0.31251645f, -0.05819468f, -0.06394789f, 0.04242561f, 0.09654518f, -0.12485396f, 0.06561771f, 
    -0.09131311f, -0.10486103f, 0.01500388f, 0.11664142f, -0.12089373f, -0.00737703f, -0.09190807f, 0.00058642f, 
    -0.00652144f, -0.06946476f, -0.01870594f, 0.07063662f, 0.15627722f, -0.13342045f, 0.26494214f, -0.00669919f, 
    -0.12147060f, 0.03883800f, -0.00047232f, -0.06245126f, 0.05796136f, -0.02534576f, -0.03429271f, 0.03639520f, 
    0.06944162f, 0.11421973f, 0.17002390f, -0.15205775f, -0.02895963f, 0.07511869f, 0.04286677f, -0.02390886f, 
    -0.16706897f, -0.32427472f, 0.26853004f, 0.25582370f, -0.37030086f, 0.12681079f, -0.15600011f, -0.09405730f, 
    0.08163796f, -0.04119187f, 0.08029819f, -0.01710523f, -0.03823612f, 0.06348802f, -0.09045993f, -0.03042759f, 
    0.06382263f, 0.08748281f, 0.08115984f, -0.06351795f, 0.23925240f, 0.06935710f, -0.03811286f, 0.04856154f, 
    0.07568071f, 0.01751763f, 0.00463645f, -0.01019202f, 0.03542601f, -0.04377102f, -0.03497011f, -0.02675130f, 
    0.06983649f, 0.07617468f, 0.05522960f, 0.05285044f, -0.01634144f, -0.01940633f, -0.01053421f, 0.00823879f, 
    -0.20737520f, -0.04560053f, -0.00603516f, 0.01561105f, -0.21425772f, 0.02368682f, -0.17059827f, 0.06731837f, 
    0.00484604f, -0.04628373f, -0.01230691f, -0.00945306f, 0.03484156f, -0.12372248f, -0.06674437f, 0.02445577f, 
    -0.08542378f, 0.10163684f, 0.01309745f, -0.01964455f, -0.05907302f, 0.15090233f, 0.01063222f, -0.05573882f, 
    0.16640078f, -0.12365608f, -0.08077227f, 0.01335958f, -0.00850749f, 0.15127276f, 0.04280107f, -0.08579420f, 
    0.07377456f, 0.04650471f, -0.00949054f, -0.05082215f, 0.01623472f, 0.01364755f, -0.02423659f, -0.03799588f, 
    0.02258173f, -0.06887479f, -0.01845635f, 0.18937446f, 0.04756486f, 0.16885780f, 0.06952174f, -0.10416529f, 
    -0.05046762f, -0.01515575f, 0.00427925f, -0.02429894f, 0.06027607f, 0.03363431f, 0.09621587f, -0.05681288f, 
    0.10229771f, -0.01585306f, -0.05494998f, -0.13461293f, 0.04953990f, 0.13718346f, -0.16499773f, 0.17322816f, 
    0.29974800f, -0.10320101f, -0.03985393f, 0.04931572f, -0.03476848f, 0.08113744f, 0.08170813f, 0.12125006f, 
    0.03998937f, -0.11902428f, 0.04967863f, -0.03664397f, 0.07036018f, -0.03416976f, 0.03086476f, -0.01422174f, 
    -0.07218762f, 0.37363183f, 0.11993295f, 0.12640108f, -0.12018245f, -0.01224639f, 0.15174571f, -0.14639242f, 
    0.04368639f, 0.12130316f, -0.08502253f, 0.00208956f, -0.02830874f, 0.15185389f, -0.12629043f, 0.03597460f, 
    -0.02680285f, -0.04158818f, -0.01006299f, 0.19783616f, -0.01280703f, 0.01477729f, -0.03840625f, 0.06322115f, 
    0.08511620f, -0.06972159f, 0.12350155f, 0.03886306f, 0.00129797f, -0.01067505f, -0.20492689f, -0.12877120f, 
    -0.00185586f, -0.01318944f, 0.06658388f, -0.08230017f, -0.07424646f, -0.02070629f, 0.00142449f, 0.00281192f, 
    0.13265020f, -0.03559295f, 0.05675226f, -0.01494174f, 0.20097680f, -0.02116114f, -0.08193276f, -0.03606183f, 
    -0.01896414f, 0.08883472f, -0.05302981f, 0.05611328f, 0.08490531f, -0.00691258f, 0.06476440f, 0.07202907f, 
    0.00326186f, 0.04902507f, -0.04050570f, 0.08110867f, 0.07677917f, 0.01130819f, 0.10698585f, 0.04977853f, 
    -0.24117650f, 0.04127906f, 0.07736133f, 0.00448954f, -0.14246024f, -0.11053573f, 0.03945961f, -0.04276383f, 
    -0.08705917f, 0.02623275f, -0.02709981f, -0.05933632f, -0.06654152f, 0.01119443f, 0.08928905f, 0.01133786f, 
    -0.10492797f, -0.05915010f, -0.07090539f, -0.05475818f, 0.08246145f, 0.04927771f, 0.06751553f, 0.01554648f, 
    -0.02226416f, 0.02337255f, -0.00417624f, 0.10765560f, 0.06945906f, 0.02628462f, -0.01016816f, 0.05915925f, 
    -0.04126506f, 0.02879997f, 0.17288178f, -0.02251899f, 0.05699026f, 0.10173485f, -0.06207595f, 0.04925959f, 
    0.16973326f, 0.01254399f, -0.04106515f, -0.02598951f, -0.12894177f, 0.07203016f, 0.08327596f, 0.02930103f, 
    0.09078509f, -0.03157130f, 0.08906285f, -0.05851518f, -0.03512445f, 0.16231704f, -0.00075038f, 0.04596033f, 
    -0.07638947f, 0.00233385f, 0.01717713f, -0.00395420f, 0.09300668f, -0.03563868f, -0.02375100f, -0.09689636f, 
    0.06890649f, 0.03876066f, -0.00861916f, 0.11776303f, 0.01615487f, -0.08980228f, -0.00583357f, 0.03050533f, 
    -0.04144700f, -0.02055255f, -0.02054229f, 0.10239040f, -0.10558635f, 0.08799890f, -0.08756870f, -0.13574313f, 
    0.06102523f, 0.13885629f, 0.00094578f, 0.04932815f, 0.10077281f, -0.11820053f, -0.01935766f, 0.01490302f, 
    0.00271028f, -0.09416566f, -0.03403293f, 0.01246675f, -0.02660400f, -0.03484507f, 0.20166673f, -0.00418380f, 
    0.01604997f, 0.01080805f, 0.16150339f, -0.03285956f, 0.06045359f, 0.04552446f, 0.04511146f, 0.06815287f, 
    0.03180570f, 0.00704637f, 0.07738654f, 0.05061440f, 0.01326490f, 0.10840428f, -0.01846221f, 0.02898938f, 
    -0.06643687f, 0.10380015f, -0.07181913f, -0.04322842f, -0.22370988f, 0.30548945f, -0.09122561f, 0.20132753f, 
    0.01935010f, 0.14570226f, 0.04841107f, 0.06595829f, -0.09858142f, -0.05744719f, 0.04785572f, -0.02621589f, 
    0.10500791f, 0.02617338f, 0.05660016f, -0.01464300f, -0.03409720f, -0.04567004f, -0.03058212f, -0.05040582f, 
    -0.20271376f, 0.43016681f, -0.14602457f, -0.18986075f, -0.14371629f, -0.01784956f, 0.02678533f, 0.02795127f, 
    0.02938963f, 0.01835627f, 0.01091852f, -0.06742758f, -0.06811969f, 0.04556056f, 0.01261731f, 0.00934099f, 
    -0.00926088f, -0.04602220f, 0.01348981f, -0.05139543f, -0.38369045f, 0.10421012f, 0.05273090f, -0.10009870f, 
    0.10801738f, -0.00834383f, 0.04015270f, 0.00298817f, 0.02609282f, 0.06683891f, -0.01955846f, -0.01425936f, 
    -0.01850573f, -0.04961553f, -0.03238127f, -0.04561683f, -0.02275375f, 0.08501703f, -0.04536996f, -0.06825346f, 
    -0.21450417f, 0.37622732f, 0.05431476f, 0.08195070f, 0.10180419f, 0.13426399f, -0.07319777f, 0.08504491f, 
    0.05551219f, -0.03524248f, -0.02824164f, 0.02662036f, -0.00285379f, 0.02941943f, -0.05264914f, 0.01097574f, 
    -0.04095947f, 0.06673978f, 0.00141181f, 0.07745430f, 0.07696410f, 0.15734914f, 0.11446887f, 0.05143672f, 
    -0.06774768f, 0.08941557f, -0.00243351f, -0.09806388f, 0.01283279f, 0.01240950f, 0.06023638f, 0.05576402f, 
    0.14563175f, -0.01178833f, 0.02167036f, 0.05234909f, -0.04591121f, -0.01755566f, -0.02037116f, -0.00145611f, 
    0.36549789f, 0.09178340f, -0.09841713f, -0.14136566f, -0.12125625f, -0.02541417f, 0.13267583f, -0.01301739f, 
    0.11784886f, -0.03763159f, 0.07396232f, -0.00421228f, -0.17726654f, 0.02608923f, 0.06603533f, 0.04683425f, 
    0.04823888f, 0.05157130f, 0.11259244f, 0.04294786f, -0.04247528f, -0.00690248f, 0.03174897f, 0.35144827f, 
    0.03154892f, 0.06021270f, 0.06681468f, -0.06374827f, -0.05182859f, -0.04833416f, 0.11293445f, 0.01494009f, 
    -0.01133636f, -0.06343613f, 0.00563399f, -0.14414203f, 0.08712911f, -0.05441181f, 0.01804015f, -0.01687226f, 
    0.24812631f, 0.12188639f, -0.39311734f, 0.15277028f, -0.21659432f, 0.02871621f, 0.01529289f, -0.00164264f, 
    0.10972306f, 0.08423334f, -0.00848724f, 0.03994907f, -0.04840204f, -0.12898178f, -0.05445525f, -0.06300721f, 
    0.05595573f, 0.03347817f, 0.02731883f, -0.02713923f, 0.05146210f, -0.22951560f, -0.21875304f, 0.16430269f, 
    0.37687644f, -0.05417920f, 0.04525854f, 0.05591350f, -0.04445110f, -0.07507849f, 0.14277770f, 0.00447673f, 
    -0.00160593f, -0.07286157f, 0.02526154f, -0.02549529f, 0.04918022f, 0.06636524f, 0.02230068f, 0.04187871f, 
    -0.04788681f, -0.04208693f, 0.10064068f, -0.01395052f, 0.18791711f, 0.01792580f, 0.05801914f, -0.01940342f, 
    0.03519538f, 0.02815077f, 0.02408179f, 0.03329615f, -0.09253749f, 0.09252354f, -0.03974323f, -0.00610497f, 
    0.07656740f, -0.00366899f, -0.08632112f, 0.03334196f, -0.08456640f, 0.02258308f, -0.06567995f, -0.21973363f, 
    -0.05747747f, -0.16351227f, -0.13773650f, -0.05239949f, 0.09723985f, 0.00573556f, -0.02152591f, 0.02781048f, 
    0.04655632f, -0.09565609f, -0.05621946f, 0.05807096f, -0.01726944f, 0.06136380f, -0.01664578f, 0.09446949f, 
    -0.19903447f, 0.03979701f, 0.03194071f, 0.02875808f, 0.17290933f, -0.04529584f, 0.08214179f, -0.06723084f, 
    0.08012222f, -0.00899506f, 0.01115550f, -0.02104229f, -0.00087389f, -0.01495004f, 0.07436363f, -0.03198804f, 
    -0.03111417f, 0.07264733f, 0.08296667f, 0.02948760f, 0.08043944f, 0.18085353f, 0.07099932f, 0.12901533f, 
    0.00808585f, 0.12514864f, 0.03812343f, -0.09176378f, 0.03706511f, -0.01817737f, 0.09351676f, 0.08480751f, 
    0.09349050f, -0.05972350f, 0.00602303f, -0.11051176f, 0.07676706f, 0.02335094f, -0.06878479f, 0.06609564f, 
    0.02227364f, 0.27028385f, -0.01858473f, -0.01960256f, -0.19998695f, 0.04152412f, 0.00145267f, 0.00858621f, 
    0.12879105f, 0.04456126f, 0.01602494f, 0.08187446f, 0.07598181f, 0.06824048f, 0.00742045f, 0.06918231f, 
    0.01030128f, -0.00166474f, 0.03220054f, 0.04302745f, -0.26681143f, -0.01508705f, 0.07114128f, 0.21185711f, 
    0.23772772f, -0.06965382f, -0.11332256f, 0.07445093f, 0.02792312f, 0.05890214f, -0.00251166f, -0.05051615f, 
    -0.01551870f, 0.03215453f, 0.00598724f, 0.02109110f, -0.02139794f, 0.05267752f, 0.17913410f, -0.07473117f, 
    -0.10524449f, -0.00046666f, 0.17069218f, -0.06045529f, 0.06270313f, 0.05042212f, 0.03007596f, -0.00047457f, 
    -0.05100195f, -0.05029764f, 0.00364416f, 0.02123073f, -0.03647991f, 0.02866462f, -0.05608835f, -0.01167897f, 
    -0.14546181f, 0.02463515f, 0.01225399f, -0.11285826f, -0.07391147f, 0.01054702f, -0.09283116f, 0.14869089f, 
    -0.07675843f, 0.01769149f, -0.01762817f, -0.11730201f, 0.01448312f, -0.05299481f, -0.03543375f, -0.03608466f, 
    0.08453484f, 0.06835253f, 0.06931092f, -0.07387307f, 0.04225035f, -0.10912137f, -0.03355585f, -0.06439419f, 
    -0.10716914f, 0.24649233f, 0.08338648f, 0.08242716f, -0.11063824f, 0.04514877f, 0.00055308f, -0.00327178f, 
    0.10172080f, -0.02205518f, 0.04717401f, -0.04505041f, -0.02926715f, 0.09715024f, -0.05911496f, 0.03599776f, 
    0.10613797f, -0.22718954f, 0.01037256f, 0.02158780f, -0.35164082f, 0.12836139f, 0.04838327f, -0.01283929f, 
    -0.00712200f, -0.01051895f, 0.04907584f, 0.02501967f, 0.04778476f, 0.00744724f, 0.02230326f, -0.06798806f, 
    -0.00713765f, -0.01788913f, -0.03686850f, 0.01480075f, -0.02518236f, -0.06187527f, -0.03186782f, -0.00663903f, 
    -0.10757519f, 0.25670448f, 0.09099219f, -0.01785555f, 0.07657176f, 0.07867695f, -0.10869242f, 0.09646641f, 
    0.00227850f, 0.00792536f, -0.08123466f, 0.02617431f, 0.08286877f, 0.09114861f, -0.09773953f, 0.04006244f, 
    -0.12197470f, 0.02302782f, -0.05646066f, 0.03837050f, -0.01946101f, 0.09349545f, 0.03913300f, 0.00877942f, 
    0.02913274f, -0.04163893f, -0.09485099f, -0.05051127f, -0.04111762f, -0.04891007f, -0.04857651f, 0.04896187f, 
    0.09356086f, 0.03721143f, 0.04638410f, 0.01650842f, -0.10866164f, 0.08586496f, -0.00035240f, -0.08230305f, 
    0.29033712f, 0.03111130f, 0.17102984f, -0.07039734f, -0.08611435f, 0.03204852f, 0.04812384f, 0.01426252f, 
    0.05298818f, -0.05294180f, -0.02655913f, 0.01764240f, -0.07920193f, 0.04607780f, 0.08863726f, -0.01332698f, 
    0.01938104f, -0.06634315f, 0.01629255f, 0.04152836f, -0.04165260f, -0.01929706f, 0.09203392f, 0.34953558f, 
    0.15923783f, 0.00642074f, -0.02067833f, -0.08781528f, -0.05158266f, -0.11667924f, 0.10771076f, 0.03643384f, 
    -0.00588805f, 0.01392161f, -0.04831307f, -0.00011961f, -0.03949900f, -0.05548938f, 0.05030975f, -0.13214190f, 
    0.22832529f, 0.36041841f, -0.10769922f, 0.07836311f, -0.08356529f, -0.00293877f, 0.05331690f, -0.04297729f, 
    0.05664562f, 0.06554061f, -0.07711013f, 0.18130636f, 0.05057241f, -0.10026849f, -0.04542141f, 0.00559323f, 
    0.07063607f, -0.01060900f, -0.01611924f, -0.01218318f, 0.32646793f, -0.03669537f, -0.29455462f, 0.06416245f, 
    0.37726018f, -0.05253037f, 0.00722688f, -0.00416719f, -0.00578464f, -0.03524524f, 0.07830176f, -0.07811294f, 
    -0.04389778f, -0.01249511f, -0.03084686f, -0.11278136f, 0.09930004f, 0.09626564f, -0.00645100f, 0.08785496f, 
    -0.12775025f, -0.00318834f, 0.11296178f, -0.09034716f, 0.26828119f, -0.05843597f, 0.03775952f, 0.01459123f, 
    -0.01559835f, 0.08592041f, -0.04490057f, -0.03044072f, -0.06212922f, 0.12602922f, 0.00944510f, 0.04105649f, 
    -0.02129671f, -0.03069974f, 0.04740518f, 0.01955077f, 0.03095579f, 0.00190520f, -0.03672602f, -0.21229662f, 
    -0.10209011f, -0.04520804f, -0.12252424f, -0.02317812f, 0.02094221f, -0.08160833f, -0.02585270f, 0.00085234f, 
    0.00167374f, -0.05644761f, 0.03207675f, 0.09559396f, 0.04536664f, -0.00190043f, 0.01984212f, 0.07627517f, 
    -0.25470921f, 0.10147466f, 0.13849251f, -0.03308229f, 0.14627612f, 0.06874166f, 0.11497851f, -0.04435957f, 
    0.04406702f, -0.03615408f, 0.02245396f, 0.02749984f, 0.02240480f, -0.08983411f, 0.05993551f, 0.01397699f, 
    -0.08194441f, 0.01918282f, 0.08084276f, -0.01319098f, -0.04033944f, 0.05394997f, 0.07606472f, 0.16433345f, 
    0.09059618f, -0.00036296f, -0.04706135f, -0.13996129f, -0.01358121f, -0.03888155f, 0.13590822f, 0.08218084f, 
    -0.05254177f, -0.01109264f, 0.06942561f, -0.00571053f, -0.03801322f, 0.07787564f, 0.02264058f, 0.00558712f, 
    0.06245375f, 0.42407480f, -0.11344394f, 0.05178362f, -0.12929481f, 0.00222790f, -0.04721769f, -0.01034297f, 
    0.05471001f, 0.03951529f, -0.04381153f, 0.07463483f, 0.02260080f, -0.01281579f, 0.03960065f, -0.08986019f, 
    -0.00575253f, 0.00772223f, 0.01449582f, 0.02591761f, -0.34038636f, 0.17329155f, 0.10458954f, 0.12388267f, 
    0.02642025f, 0.10461488f, -0.04350920f, 0.15263797f, 0.02934350f, -0.02817670f, -0.06663669f, -0.07386648f, 
    0.04668435f, 0.05335055f, 0.05324837f, -0.00482757f, 0.11546391f, 0.06006485f, 0.15288278f, -0.03643728f, 
    -0.17916353f, 0.17913580f, -0.03070328f, -0.04504290f, -0.01421323f, -0.04376258f, 0.06857154f, 0.01616004f, 
    0.04291638f, -0.01104100f, 0.05214130f, 0.00947745f, -0.00792261f, 0.02424551f, 0.05567574f, -0.02414470f, 
    0.05461123f, -0.02676512f, 0.06242688f, 0.03868932f, 0.29753962f, -0.21556237f, -0.06661126f, 0.06855293f, 
    -0.03039069f, -0.11541240f, 0.00342808f, -0.00505923f, 0.06039565f, 0.03406955f, 0.08620807f, 0.31107774f, 
    -0.02546415f, -0.07397196f, -0.00368764f, 0.01114623f, 0.00515094f, 0.06537638f, 0.08075490f, -0.11234780f, 
    0.34038472f, 0.09035663f, 0.06018029f, 0.25945848f, 0.49615511f, 0.06051635f, 0.05572259f, -0.00795681f, 
    -0.08325277f, 0.08759619f, -0.08540587f, 0.09764856f, 0.12773767f, -0.10510954f, 0.02013420f, -0.05321399f, 
    -0.02570538f, 0.08299877f, 0.04934601f, 0.07170009f, -0.21975295f, 0.17835209f, -0.17270768f, 0.08730086f, 
    -0.04109819f, 0.09687085f, 0.06550079f, -0.08176942f, 0.06017185f, 0.03690739f, -0.05480644f, 0.02274916f, 
    0.10729630f, -0.00519693f, 0.13507110f, 0.08294410f, 0.16870849f, 0.03119825f, -0.02708524f, 0.03150959f, 
    0.55062687f, -0.20772944f, 0.15600134f, -0.02575718f, 0.17179832f, 0.01161319f, 0.12455846f, 0.07692567f, 
    0.00661138f, 0.10150072f, 0.01136163f, 0.05090701f, 0.03954407f, 0.07402771f, 0.08314873f, 0.02112429f, 
    -0.00802058f, 0.06984670f, -0.07490896f, -0.08616413f, -0.15440390f, -0.21566196f, 0.01478085f, -0.20421594f, 
    -0.17076388f, 0.05330533f, -0.07012716f, 0.06889074f, -0.02105675f, -0.13511918f, 0.10262439f, 0.08095823f, 
    -0.08573918f, 0.00754339f, 0.01257046f, 0.05933472f, -0.03125433f, -0.02366316f, 0.03498884f, 0.02122147f, 
    -0.00172359f, -0.02873052f, 0.26920542f, 0.18304847f, -0.05115741f, -0.10770808f, -0.02807677f, 0.08937073f, 
    -0.01335889f, 0.00086351f, 0.07659090f, -0.03759092f, 0.14434794f, 0.09883843f, 0.04310487f, 0.03193893f, 
    -0.01362579f, 0.06352073f, -0.00273248f, 0.03795727f, -0.04554676f, -0.21847545f, 0.29270920f, -0.05333985f, 
    -0.09111128f, -0.03597254f, -0.15524115f, 0.08518622f, 0.12905608f, 0.01792040f, -0.05710946f, 0.09459108f, 
    -0.03266945f, 0.11199030f, -0.08370297f, 0.01905914f, -0.18186566f, 0.10297555f, -0.06613044f, 0.11973682f, 
    -0.12232845f, 0.12943293f, 0.05670838f, 0.03060823f, -0.12860492f, 0.23057203f, -0.01193455f, 0.03596442f, 
    -0.12786736f, -0.05300888f, -0.00213882f, -0.00036588f, 0.07052797f, -0.10867976f, 0.01224518f, 0.19193667f, 
    0.04753659f, -0.04797373f, -0.06484177f, -0.00943847f, -0.00497867f, 0.44670394f, 0.18931182f, -0.14037482f, 
    -0.07277811f, 0.01349678f, 0.00718270f, -0.03953855f, 0.05363181f, 0.01571689f, 0.04849071f, 0.02778149f, 
    0.07299305f, 0.02044729f, 0.00022512f, 0.01130881f, 0.00717833f, 0.07165534f, 0.05072956f, -0.04550310f, 
    0.04702098f, -0.12418544f, -0.14918517f, -0.03392926f, -0.13803256f, -0.06364764f, 0.08913344f, -0.00232233f, 
    0.03345270f, -0.04620089f, 0.11526497f, -0.02747333f, 0.01095381f, -0.04489160f, 0.07845062f, 0.06928896f, 
    0.06776970f, 0.04112761f, 0.01562450f, 0.12664846f, 0.11154764f, 0.14579429f, 0.10434489f, 0.15376864f, 
    0.11842358f, 0.13098894f, 0.09622753f, -0.01705443f, 0.03824640f, 0.05433032f, 0.05273829f, 0.04559485f, 
    -0.02448308f, -0.00600724f, 0.05528218f, 0.01193476f, 0.07593770f, 0.05624111f, -0.00404229f, 0.00936166f, 
    0.07631038f, 0.11347473f, 0.14279154f, -0.08979674f, -0.00212847f, -0.05662569f, 0.06876488f, 0.01755154f, 
    0.06580941f, -0.06771348f, 0.10360944f, -0.11074769f, 0.01223454f, -0.02503301f, -0.00880413f, 0.01781216f, 
    0.08487339f, -0.10755502f, -0.05154644f, 0.10103305f, -0.21063225f, -0.31844690f, -0.11535133f, -0.11035322f, 
    -0.14086141f, -0.05345142f, -0.11123721f, -0.09879423f, 0.03489372f, -0.05368171f, 0.05655154f, 0.06610202f, 
    -0.07657147f, 0.07196326f, -0.07922716f, 0.02498324f, -0.03781549f, -0.12754627f, 0.04201377f, -0.02788019f, 
    -0.04394920f, -0.06358633f, -0.05410728f, -0.06241614f, 0.01112493f, 0.12493971f, 0.01608784f, 0.05800277f, 
    -0.06670748f, -0.08132768f, 0.04078597f, -0.02356011f, 0.01547317f, -0.00221248f, -0.01658649f, -0.02516938f, 
    -0.01649277f, 0.04120012f, 0.20720699f, -0.01739982f, 0.05213373f, 0.21886590f, 0.17162718f, -0.10898480f, 
    -0.03634292f, 0.03554353f, 0.03977621f, -0.04524475f, 0.07622525f, -0.09539425f, 0.04613155f, -0.15996327f, 
    0.01813661f, 0.06041477f, -0.00164735f, -0.02868481f, 0.04719963f, 0.02088272f, -0.10222720f, 0.08374866f, 
    -0.15442540f, 0.06069597f, -0.14372344f, 0.01030514f, 0.15230916f, 0.11554001f, 0.00195911f, 0.12100318f, 
    0.06298351f, -0.03035819f, 0.05842542f, 0.03186794f, -0.00404229f, -0.02196109f, -0.04952044f, -0.00226889f, 
    0.00659127f, -0.02101792f, -0.01628058f, -0.01922255f, 0.06787522f, -0.18446963f, 0.14894585f, -0.08663780f, 
    -0.14782180f, -0.05200791f, -0.10301422f, 0.14326726f, -0.03809845f, -0.04198265f, 0.03482388f, -0.03544279f, 
    0.01990818f, -0.03751136f, 0.03432789f, -0.01990731f, 0.04175340f, 0.08164027f, -0.03512780f, 0.01616243f, 
    -0.05648066f, -0.27797607f, 0.10688886f, 0.13788214f, -0.11880778f, 0.08763400f, -0.02652859f, 0.20989603f, 
    0.05150396f, 0.10630408f, -0.02719823f, 0.08159638f, 0.04463760f, 0.00647096f, 0.01320194f, -0.09143095f, 
    -0.08590839f, 0.07295795f, 0.01617613f, -0.03469292f, 0.10184863f, 0.00937362f, 0.01236184f, -0.00904580f, 
    0.03350827f, 0.08299058f, 0.01350215f, 0.03576129f, -0.01076498f, 0.01892633f, 0.05356004f, -0.01781877f, 
    -0.00153247f, 0.10121382f, 0.02077366f, 0.05383943f, 0.03164832f, 0.10443508f, 0.08838882f, -0.03989893f, 
    -0.17320016f, -0.16890876f, -0.07734527f, 0.13672094f, -0.08358350f, -0.01879393f, -0.03276262f, 0.05854883f, 
    0.03976345f, 0.04407578f, 0.13534263f, 0.07361974f, 0.08660538f, -0.10137408f, -0.05690681f, -0.07070545f, 
    -0.06840355f, -0.01179851f, -0.03879670f, 0.05036229f, -0.27283111f, -0.12559384f, -0.10676617f, 0.03811754f, 
    0.20863111f, -0.00598665f, -0.02543813f, 0.04506824f, 0.00945674f, -0.01623271f, 0.01047238f, -0.07464784f, 
    -0.03331016f, 0.05998629f, -0.00704689f, 0.01018602f, -0.07017858f, -0.02398437f, 0.02602751f, -0.02859995f, 
    -0.01477108f, 0.11250023f, -0.08521631f, -0.04896465f, 0.03740742f, -0.02225211f, -0.00709811f, -0.02430035f, 
    -0.05123655f, 0.04198213f, 0.01362096f, -0.09102544f, -0.05200889f, 0.09920160f, -0.02770872f, 0.00636479f, 
    0.02609039f, 0.06330088f, -0.03681742f, -0.08943819f, 0.10262983f, 0.12433778f, -0.18808825f, -0.17564635f, 
    0.15328103f, -0.05542256f, 0.04054428f, 0.06608538f, 0.01356138f, 0.04092683f, 0.03764795f, 0.02905428f, 
    0.07575206f, -0.01952836f, -0.03223281f, 0.02150746f, 0.10225031f, 0.07989882f, -0.08729416f, 0.12370215f, 
    -0.08066881f, 0.03925584f, 0.09133602f, 0.13567345f, -0.24997665f, 0.00221257f, -0.04766630f, -0.06114640f, 
    -0.06417993f, 0.04847017f, 0.00084482f, -0.09592631f, 0.05319481f, 0.09766926f, -0.03354729f, 0.09052990f, 
    0.03226926f, 0.03155211f, 0.05538474f, 0.05429250f, 0.03344784f, 0.13101129f, 0.25955439f, 0.17413002f, 
    -0.25960088f, -0.10480653f, 0.04847627f, 0.12164696f, 0.11011732f, 0.06767527f, -0.03655326f, -0.07927861f, 
    0.05043482f, -0.01408946f, 0.01579863f, -0.02179199f, -0.03779498f, -0.04514915f, 0.05780940f, 0.13510475f, 
    0.04938425f, 0.07064424f, -0.08456686f, -0.07787611f, 0.06433909f, -0.04241310f, -0.08897026f, 0.02551720f, 
    -0.02591207f, 0.01811925f, -0.00169101f, 0.07393807f, -0.00192277f, -0.06752668f, 0.06300710f, 0.09046283f, 
    -0.00703176f, 0.11900669f, 0.02021082f, 0.07592274f, 0.15689452f, 0.12322164f, 0.02499511f, 0.13640809f, 
    -0.06193707f, 0.09086562f, 0.05633599f, 0.05330520f, 0.11817944f, 0.06564526f, -0.00499294f, 0.01195169f, 
    0.00441213f, 0.08383743f, 0.03365734f, 0.06635996f, -0.03699061f, -0.06692167f, 0.08537957f, 0.00541801f, 
    -0.21485840f, -0.07794395f, -0.01918133f, 0.04375249f, 0.22717297f, 0.12240319f, -0.01502957f, -0.07067979f, 
    -0.04315037f, 0.05914313f, 0.00238597f, 0.03681331f, 0.04438809f, 0.12341903f, -0.04333497f, 0.13559762f, 
    -0.00175740f, 0.03509574f, 0.09681895f, -0.04662968f, -0.03312568f, -0.08377859f, -0.26041767f, -0.06230770f, 
    0.14742009f, -0.07535481f, 0.05413867f, 0.08769239f, 0.08158969f, 0.07489258f, 0.04786267f, 0.01769327f, 
    0.06099806f, 0.07724669f, 0.10158803f, 0.13572265f, 0.01066645f, 0.09593616f, 0.12979791f, 0.01973412f, 
    -0.06969097f, -0.16513701f, -0.05209979f, -0.01033902f, 0.23276263f, 0.12170827f, -0.01461916f, -0.03513034f, 
    0.00362483f, 0.00621180f, -0.04307479f, 0.03266929f, -0.00920090f, -0.11488120f, -0.02005511f, 0.01784734f, 
    0.00766073f, -0.10305020f, -0.01200953f, -0.00665024f, -0.17975499f, -0.08993042f, -0.07270481f, -0.02491471f, 
    0.12090609f, 0.12985103f, 0.09912322f, -0.09455337f, -0.05371653f, 0.00511772f, 0.08700816f, 0.06689231f, 
    0.09273648f, 0.01043629f, 0.00805628f, 0.03899804f, -0.04942675f, 0.04767541f, -0.05708342f, 0.00408182f, 
    -0.01479802f, -0.01659474f, 0.01754608f, -0.00774505f, -0.05396429f, 0.02661120f, -0.00502317f, -0.01749831f, 
    0.02032224f, 0.02504280f, -0.00166224f, -0.04034429f, -0.02685999f, 0.04382889f, -0.05933430f, -0.00555837f, 
    -0.05801931f, 0.00922557f, 0.03152862f, -0.04050969f, -0.04400044f, 0.03358916f, -0.01177594f, -0.03741291f, 
    -0.04513304f, 0.00205470f, 0.00357120f, 0.00521302f, 0.04096899f, -0.04664289f, -0.03759041f, 0.01608278f, 
    -0.06134818f, 0.04816372f, -0.05659270f, 0.03013612f, 0.02707608f, -0.00006389f, 0.02058788f, 0.04005544f, 
    0.02219286f, -0.03948520f, -0.02234962f, -0.00419933f, 0.04010376f, 0.02083205f, -0.01425265f, -0.06010841f, 
    0.00632712f, 0.03045625f, -0.04611742f, -0.01094565f, 0.01455143f, 0.02753640f, -0.02644727f, -0.00862337f, 
    0.01037712f, 0.02887627f, -0.02439919f, -0.05217182f, 0.04248299f, -0.00629414f, 0.03063257f, -0.01453350f, 
    0.02234968f, 0.01285096f, 0.01609906f, 0.04622963f, -0.02382506f, 0.04004294f, -0.03928417f, -0.03629962f, 
    -0.03232868f, -0.03364943f, 0.05246491f, -0.02955067f, 0.02783121f, -0.04730496f, 0.00471424f, 0.00155934f, 
    -0.05008062f, -0.05693752f, -0.00295031f, 0.02559353f, 0.02466801f, -0.03502612f, -0.04676920f, 0.05047612f, 
    -0.06307616f, 0.01122187f, -0.00118193f, 0.02976257f, -0.00847584f, 0.02747861f, 0.04209133f, 0.03605700f, 
    -0.04374273f, -0.03615537f, 0.03230718f, 0.01160927f, 0.04282306f, -0.03791206f, -0.02550519f, -0.00084005f, 
    0.04754403f, -0.03757398f, 0.01996119f, -0.04731662f, 0.04162164f, -0.04708303f, 0.02518432f, -0.04738385f, 
    -0.04022345f, -0.05094488f, -0.03704992f, -0.01359556f, 0.02175923f, 0.03861335f, -0.04122339f, -0.00826834f, 
    -0.01254949f, 0.04117083f, -0.06083166f, -0.05915308f, -0.03692764f, -0.00030687f, -0.01295299f, -0.06639481f, 
    -0.00324092f, 0.01590144f, -0.03178013f, -0.01792989f, 0.03126925f, -0.03043209f, 0.00869225f, 0.02859256f, 
    0.04499856f, -0.04520273f, 0.01079104f, -0.05935043f, 0.03797460f, 0.04349194f, 0.03074936f, 0.00681514f, 
    0.00068558f, 0.04255159f, -0.05520699f, -0.00542680f, 0.02176630f, 0.03866166f, 0.03750852f, -0.03427612f, 
    0.02014578f, 0.01873146f, 0.03536272f, -0.02112784f, -0.04127670f, 0.01372048f, -0.05543048f, 0.00922715f, 
    -0.05216648f, -0.03925113f, -0.04420702f, -0.04467609f, -0.00288291f, -0.01003107f, -0.04021839f, 0.03410150f, 
    -0.04805236f, -0.04094809f, 0.03559623f, 0.03302009f, 0.04116907f, -0.04388030f, -0.06018735f, -0.01634725f, 
    -0.05336143f, 0.02566757f, -0.03042979f, -0.05020161f, 0.02470713f, -0.04584443f, 0.00727410f, -0.02338155f, 
    0.02254418f, -0.01293031f, -0.04623903f, -0.01032464f, -0.02065275f, 0.02015047f, 0.03045327f, -0.02770828f, 
    -0.06291685f, 0.00265554f, -0.03310478f, 0.01683821f, -0.00191709f, -0.03343656f, 0.02683224f, -0.04090961f, 
    -0.00787507f, -0.05353470f, 0.00432036f, -0.03370278f, -0.02905629f, -0.00857861f, -0.05173643f, 0.01782346f, 
    -0.02490661f, -0.02201676f, 0.00389508f, 0.03356893f, -0.02853728f, -0.03202773f, 0.02747533f, 0.02033994f, 
    -0.05406820f, 0.02052159f, 0.02210439f, -0.00604713f, -0.02082823f, 0.00545761f, -0.01059048f, -0.06631399f, 
    0.01133035f, -0.04849288f, 0.00115028f, -0.02199161f, 0.03600589f, 0.01764097f, 0.01389117f, 0.01651432f, 
    -0.02755334f, 0.03616813f, 0.02613840f, -0.02622762f, 0.02517550f, -0.03373250f, -0.05008459f, 0.04064045f, 
    -0.01600340f, 0.03942246f, 0.01970362f, 0.01558103f, -0.04033500f, 0.02574304f, 0.00466416f, 0.00188018f, 
    0.04788326f, 0.01029229f, 0.01614840f, -0.05511219f, 0.03320643f, -0.02071293f, -0.02909175f, -0.01395455f, 
    -0.00590798f, 0.02759865f, 0.02791038f, 0.02976738f, 0.00478329f, -0.00082353f, -0.06126927f, 0.04925393f, 
    0.02107272f, -0.00286049f, -0.01550160f, -0.03294754f, -0.03601028f, 0.00590265f, 0.01320809f, -0.03781965f, 
    0.03978286f, -0.03103388f, -0.00255985f, 0.00682745f, 0.04294218f, -0.00337306f, 0.00479221f, 0.04239955f, 
    -0.04964094f, 0.03651677f, 0.00951044f, -0.00958347f, 0.00635318f, -0.04939602f, -0.01988927f, -0.02970479f, 
    -0.06038411f, 0.03404291f, 0.03198111f, 0.02810154f, -0.01182157f, 0.01816612f, -0.01824953f, -0.06499898f, 
    -0.01052141f, 0.04540519f, -0.02296106f, 0.04451333f, -0.00894578f, -0.00871402f, -0.02440022f, 0.03294110f, 
    -0.01649020f, -0.01224003f, -0.04479697f, -0.06107194f, -0.01343206f, -0.02808463f, -0.05635284f, -0.03549648f, 
    0.02505188f, 0.04503144f, -0.05363083f, -0.00347357f, -0.03773839f, -0.00968276f, 0.00958965f, 0.02327016f, 
    -0.03047771f, -0.03177559f, 0.01832488f, -0.02421350f, -0.05301768f, 0.02865560f, 0.02108429f, -0.04771854f, 
    -0.04530833f, -0.02761362f, -0.01826154f, 0.03687926f, 0.01149830f, -0.04590390f, -0.06153476f, -0.05632704f, 
    -0.02827407f, -0.02834998f, -0.03757217f, -0.02797530f, -0.02648528f, 0.00702649f, -0.05450184f, 0.00756135f, 
    -0.02371241f, 0.01069987f, 0.02188562f, -0.02213824f, 0.02953936f, 0.04236931f, -0.00661442f, 0.00182061f, 
    0.01949706f, -0.01907155f, -0.03952086f, -0.00225918f, 0.01290840f, 0.05033430f, -0.02140189f, -0.01242630f, 
    -0.06077512f, -0.05430900f, 0.02188771f, -0.00774711f, 0.03435751f, 0.04688276f, 0.00085182f, 0.02313229f, 
    0.00951016f, -0.03194964f, -0.06230370f, -0.05563752f, 0.02236496f, 0.00622410f, 0.00255639f, 0.01788118f, 
    -0.03285535f, 0.00498339f, -0.04519637f, 0.02655900f, -0.01138922f, 0.04691103f, 0.02385886f, 0.01216511f, 
    -0.00845494f, 0.00140622f, 0.04248539f, 0.00278265f, -0.02808684f, 0.04432112f, -0.04942377f, 0.00992400f, 
    -0.05170350f, -0.04707046f, -0.04779353f, 0.01135476f, -0.03724259f, 0.01257982f, 0.04712040f, -0.05465088f, 
    0.01921812f, -0.05893089f, -0.00329666f, -0.04748935f, -0.04382721f, -0.01437017f, -0.05490481f, -0.03690815f, 
    0.03818420f, 0.01991220f, 0.02008206f, 0.04338537f, -0.04866780f, -0.03916674f, 0.01201059f, 0.00373796f, 
    0.05374045f, 0.00944401f, 0.03220797f, 0.03973811f, -0.03606171f, -0.01216102f, -0.01636185f, -0.02812652f, 
    -0.03781744f, -0.03047404f, 0.00989748f, -0.01776545f, 0.03889961f, -0.01742148f, -0.02335329f, -0.00121223f, 
    -0.03443833f, -0.02334534f, -0.01312166f, -0.01183786f, 0.01571222f, 0.03680236f, -0.00043051f, -0.00813594f, 
    -0.02002024f, 0.01817987f, -0.03213321f, -0.04591510f, 0.01015438f, -0.05071801f, -0.03747437f, 0.05067793f, 
    0.04290344f, 0.01676474f, -0.02334891f, -0.03452658f, 0.02692953f, -0.03769878f, 0.00341448f, 0.00759453f, 
    0.03856726f, -0.01174795f, -0.02629597f, -0.05538908f, -0.03453049f, 0.01172045f, -0.05979358f, 0.04129067f, 
    -0.05267708f, -0.04793067f, 0.03016926f, -0.00799971f, 0.03773827f, 0.00023527f, -0.01571729f, 0.02798577f, 
    0.01282848f, 0.03259470f, 0.02677318f, -0.01045188f, -0.02264881f, 0.02914088f, -0.06055677f, -0.04776597f, 
    -0.06059526f, -0.03935142f, -0.00719132f, -0.03767972f, -0.05830635f, 0.04083707f, 0.03007705f, -0.05371007f, 
    -0.02554403f, 0.04241319f, -0.02881671f, 0.04127355f, -0.04090268f, 0.01585727f, 0.03202693f, -0.05628982f, 
    -0.04605518f, 0.01486750f, 0.03012986f, -0.04681768f, -0.02044185f, -0.00941639f, -0.04016044f, -0.01789519f, 
    -0.05774884f, -0.01393223f, 0.01323356f, 0.01439943f, 0.00886328f, -0.04047823f, -0.00868264f, -0.01279114f, 
    0.01518043f, -0.05710541f, 0.05023335f, -0.02473080f, -0.02267588f, -0.05603655f, -0.00837190f, -0.00451282f, 
    0.03911762f, 0.03095187f, 0.02142133f, -0.01574914f, -0.04859272f, 0.00117879f, -0.02204636f, -0.02472432f, 
    0.00751536f, -0.03658994f, 0.00237965f, 0.03054919f, -0.03724862f, 0.02618149f, 0.00286936f, -0.06223302f, 
    0.03276288f, 0.04589080f, -0.03544989f, -0.02384028f, -0.06036562f, 0.03841269f, 0.01172979f, -0.00140852f, 
    0.02459220f, -0.02275500f, -0.05459819f, 0.03867509f, -0.01269980f, 0.02451409f, 0.03805400f, 0.04694927f, 
    -0.02308675f, -0.00565614f, -0.02744799f, -0.00520080f, -0.03609439f, 0.01832728f, -0.01760592f, -0.03674168f, 
    0.01550778f, -0.02158738f, -0.01596581f, 0.02797755f, 0.04494730f, 0.00738683f, -0.03892070f, 0.01754373f, 
    -0.03429933f, -0.05206615f, -0.02602389f, -0.06109761f, 0.00599250f, 0.00417927f, -0.00577426f, -0.03984008f, 
    -0.03757253f, -0.05095359f, -0.05052232f, -0.00774376f, 0.00840473f, -0.04054372f, -0.02604886f, -0.05136175f, 
    -0.01252739f, 0.04279385f, 0.01613373f, -0.06022518f, -0.01132284f, 0.00756832f, -0.00087294f, 0.03182186f, 
    -0.02815481f, 0.01038838f, 0.00669998f, -0.04998565f, -0.04131356f, -0.04337631f, 0.03044206f, -0.01806075f, 
    0.02592354f, -0.01668618f, -0.05848447f, 0.03832917f, -0.06305289f, 0.00327835f, 0.03390846f, 0.04236771f, 
    -0.02455714f, 0.00699130f, 0.03129060f, 0.03472806f, -0.05707840f, 0.03657402f, 0.00934478f, -0.00996810f, 
    -0.03826402f, -0.04993185f, 0.03678523f, 0.04244921f, -0.03598269f, 0.03081382f, -0.00256441f, -0.03971289f, 
    0.04712388f, -0.05673847f, 0.04298757f, 0.00044260f, 0.03223529f, 0.02408327f, 0.02460559f, 0.02439061f, 
    0.02849960f, 0.04674470f, -0.01892392f, -0.05113557f, 0.02846942f, 0.03970344f, -0.01157034f, 0.05515208f, 
    -0.01936414f, 0.03672733f, 0.02567855f, -0.00080148f, -0.00231921f, 0.04443082f, 0.03445539f, -0.01834524f, 
    -0.01537101f, 0.00106732f, -0.02565590f, 0.00611401f, 0.00907161f, 0.00494545f, 0.01927336f, -0.04705615f, 
    0.04002631f, 0.00201230f, -0.03685809f, 0.03002844f, -0.02776176f, 0.02543983f, -0.02050931f, -0.03362994f, 
    -0.05636833f, -0.06027604f, 0.01690873f, -0.05182699f, -0.01722044f, -0.05113273f, -0.00711547f, -0.06169973f, 
    0.04309558f, -0.00759548f, -0.04617829f, -0.04426087f, -0.02097048f, -0.02308097f, -0.04788112f, -0.04177495f, 
    0.03565836f, 0.01820220f, 0.02499152f, -0.01484140f, 0.02714365f, -0.02630190f, -0.03035449f, 0.01495723f, 
    -0.03145555f, -0.03368834f, -0.01389404f, -0.02280875f, 0.05931820f, 0.02857921f, -0.04813984f, -0.01267980f, 
    -0.03436225f, -0.04123517f, -0.04155033f, 0.00751598f, 0.03315726f, -0.04785158f, 0.00738603f, -0.05983016f, 
    -0.03532816f, -0.02654070f, -0.01280035f, -0.04298134f, -0.05069228f, -0.05540256f, -0.03033817f, 0.02107430f, 
    0.03987115f, 0.00784298f, 0.03479316f, -0.01779102f, -0.02218751f, 0.02186158f, 0.03229076f, -0.00487402f, 
    -0.03049647f, 0.02477258f, -0.00061578f, -0.04900622f, 0.03922734f, 0.03991381f, 0.00759460f, -0.00624254f, 
    0.02914024f, -0.04580479f, 0.04413937f, -0.00447048f, 0.04029595f, 0.02664365f, -0.05297389f, 0.03094393f, 
    0.05099367f, 0.02511224f, -0.02805528f, 0.03884595f, -0.00155481f, 0.01218958f, -0.04676256f, 0.04297697f, 
    0.04208979f, -0.02612563f, -0.05667245f, -0.04537069f, 0.02072458f, 0.00563126f, 0.01567590f, 0.01650423f, 
    0.00811884f, -0.01158726f, -0.03444128f, -0.03957022f, 0.02106892f, -0.03106459f, 0.03577570f, 0.04494499f, 
    -0.05538528f, -0.05699097f, 0.02073303f, 0.00445529f, -0.04417041f, 0.05143187f, -0.01335617f, 0.02003291f, 
    -0.01019805f, 0.03852541f, 0.02177302f, -0.03906012f, 0.00215531f, 0.04115080f, 0.02502306f, 0.05335249f, 
    -0.05339165f, 0.01598562f, 0.03419127f, -0.05903181f, -0.01839822f, 0.00074967f, -0.06651792f, -0.00305272f, 
    0.01838361f, 0.01001326f, 0.02136106f, -0.03316265f, 0.01996987f, -0.04911112f, -0.04334413f, 0.02132811f, 
    0.02382628f, 0.03131020f, 0.03895376f, -0.02628475f, 0.02151018f, -0.01382441f, -0.05510509f, -0.03699814f, 
    -0.02004750f, 0.04695228f, 0.01190343f, -0.06559584f, 0.02548435f, 0.05073491f, -0.04457037f, -0.01477616f, 
    0.01580776f, 0.01932751f, -0.01929770f, -0.04217262f, -0.04387800f, -0.01959464f, -0.00414834f, -0.01149633f, 
    0.03667380f, 0.02492191f, -0.00178632f, 0.02366990f, -0.03143903f, 0.00778298f, -0.00834889f, 0.03234775f, 
    0.02527115f, -0.03280465f, 0.01837016f, -0.03770028f, -0.00123863f, -0.02199204f, -0.00153916f, 0.02568507f, 
    -0.04078474f, 0.03769131f, 0.01710956f, 0.01467388f, -0.01139981f, -0.01650815f, 0.03984091f, 0.05013584f, 
    -0.01046626f, 0.05501151f, -0.03844675f, 0.02846514f, -0.01463731f, 0.00707074f, -0.02493270f, -0.04271222f, 
    -0.00064348f, 0.03678733f, -0.04301662f, -0.05498602f, -0.00114133f, 0.03735530f, -0.01502701f, 0.00013317f, 
    -0.01035746f, 0.00285085f, 0.04662526f, 0.00935055f, -0.06189131f, -0.01084305f, -0.05279760f, -0.04470250f, 
    0.02234320f, 0.04996170f, -0.00490108f, -0.05215367f, 0.01320490f, -0.01604107f, -0.04876502f, 0.02420573f, 
    0.00148165f, -0.01462513f, -0.03181598f, -0.04243636f, -0.02928425f, 0.01076742f, -0.03509184f, -0.04981732f, 
    -0.03923664f, -0.02396599f, -0.01935737f, 0.00685896f, -0.03288674f, 0.04261514f, 0.01735494f, -0.05093012f, 
    0.05000135f, 0.03770490f, -0.03902896f, -0.02677753f, 0.04741924f, -0.04498739f, 0.01673159f, -0.01874251f, 
    0.03114566f, -0.01851211f, 0.06331519f, -0.04287596f, 0.03915619f, 0.06555413f, -0.02121958f, 0.01225184f, 
    0.03959952f, 0.02072424f, -0.01073478f, -0.05317914f, -0.01027800f, -0.02874303f, -0.04669201f, 0.02588009f, 
    -0.05150415f, 0.05419327f, -0.00379942f, -0.04509279f, 0.01019241f, 0.04359560f, -0.05544775f, -0.02091069f, 
    0.05689295f, -0.03334266f, -0.05726681f, 0.04279243f, -0.03305878f, -0.05064994f, -0.01230476f, -0.00134166f, 
    -0.01949947f, -0.05150461f, 0.04599269f, -0.04655674f, -0.02561733f, -0.04232086f, -0.02550672f, 0.03231880f, 
    -0.01689220f, -0.02626488f, 0.01712026f, -0.03815341f, -0.02052411f, -0.03180346f, -0.01633910f, -0.04080443f, 
    -0.04657071f, 0.05949824f, -0.02647781f, 0.04749893f, -0.00021742f, 0.03156415f, -0.03023529f, 0.01991896f, 
    -0.02939055f, -0.05021906f, 0.02586793f, 0.00301335f, 0.00732869f, -0.03480735f, 0.01154418f, -0.02718744f, 
    -0.03791441f, -0.05158763f, 0.00485313f, 0.02748516f, -0.05315984f, -0.03097442f, -0.01660855f, 0.00207943f, 
    -0.02143842f, 0.00099063f, -0.03712874f, -0.00408304f, 0.01578976f, -0.02205405f, 0.01008704f, -0.00677680f, 
    0.03762551f, 0.01881274f, -0.02836816f, -0.04829403f, -0.03346882f, -0.00014393f, -0.05061850f, -0.04138058f, 
    0.00168308f, 0.05404430f, 0.01505131f, -0.05544608f, 0.03147059f, -0.04614349f, 0.00943623f, -0.00110085f, 
    -0.04871193f, 0.04549320f, 0.03789453f, 0.00377422f, 0.02447536f, -0.02413117f, 0.01246842f, -0.05062734f, 
    -0.01986614f, 0.03768924f, -0.01224386f, -0.04761153f, -0.01930275f, -0.01908691f, -0.05131740f, -0.05064306f, 
    0.01047403f, 0.02051166f, 0.04321301f, 0.02565811f, -0.02128132f, 0.05033019f, -0.03777608f, -0.02908319f, 
    0.04231632f, 0.04921602f, -0.04508827f, -0.00330236f, 0.02427267f, -0.04502816f, 0.03983347f, 0.02548681f, 
    -0.00064389f, 0.04615553f, -0.00957628f, 0.01176540f, -0.01269191f, -0.02156755f, -0.02729199f, 0.03334337f, 
    0.00717595f, 0.04966623f, 0.05122909f, -0.02013639f, -0.04770812f, -0.01754604f, -0.04218856f, -0.05280281f, 
    -0.01041944f, -0.00962291f, 0.02839278f, -0.00065914f, -0.02872209f, 0.01944293f, -0.03020349f, -0.01755741f, 
    0.01156465f, -0.05123072f, -0.03660853f, -0.04080017f, -0.02130895f, -0.01552574f, 0.03282720f, -0.02583614f, 
    -0.04955478f, -0.04736176f, -0.02837595f, 0.01751380f, -0.00216061f, -0.00419153f, 0.03119624f, -0.03755313f, 
    -0.05198465f, 0.04934575f, -0.00065940f, -0.05072273f, -0.00850033f, 0.01820978f, 0.03776739f, -0.04022705f, 
    0.03599948f, -0.03073945f, 0.01712626f, -0.04787094f, 0.03787715f, -0.03168995f, -0.04135283f, -0.04902184f, 
    -0.00001469f, 0.02457460f, -0.03540909f, -0.02138430f, 0.04050809f, 0.00713939f, 0.00005724f, 0.00648744f, 
    -0.01851838f, -0.02690371f, -0.00009799f, 0.00989284f, -0.02623050f, 0.04832040f, -0.01436189f, -0.03439131f, 
    -0.00383401f, -0.03776281f, -0.02517114f, -0.00850148f, 0.04772284f, 0.00535029f, 0.04733172f, -0.04851525f, 
    -0.03964252f, 0.02881347f, 0.03100363f, -0.02417595f, -0.00056132f, -0.04395497f, -0.02778341f, -0.03285515f, 
    0.02773253f, -0.04070874f, -0.01241783f, 0.01577538f, -0.03328818f, 0.02394463f, -0.04211423f, -0.04336302f, 
    0.00334120f, -0.02305475f, -0.01715815f, -0.04284960f, -0.00408457f, 0.00344244f, -0.01130163f, 0.02958162f, 
    -0.00203834f, 0.02013953f, -0.03602419f, -0.01550547f, -0.00269741f, -0.04793049f, -0.04125729f, -0.01017333f, 
    0.03922503f, -0.04720181f, -0.01350651f, -0.00613020f, 0.02410228f, -0.02872370f, -0.04945429f, -0.05538582f, 
    -0.02703508f, 0.00715515f, -0.02863132f, 0.02321200f, 0.00266903f, 0.01543889f, -0.04551081f, 0.00051902f, 
    -0.03784740f, -0.01975705f, -0.01411568f, 0.04996146f, -0.02757909f, 0.03605249f, 0.00718129f, 0.04296530f, 
    -0.03914988f, 0.04957210f, -0.03830082f, -0.04283906f, 0.04003674f, 0.03293920f, -0.04977938f, 0.05129637f, 
    0.02829844f, 0.00243547f, -0.01488443f, -0.02461666f, -0.00961736f, -0.04789143f, -0.01926194f, 0.04960705f, 
    0.01239238f, -0.05291976f, 0.03378349f, -0.05362357f, 0.00285568f, 0.00860149f, 0.05293941f, -0.00892619f, 
    -0.05192584f, 0.05454797f, 0.04996179f, 0.03037854f, -0.05546217f, 0.02707440f, 0.02488843f, -0.01656021f, 
    0.02318600f, -0.00077392f, -0.05119963f, -0.03124634f, -0.01646610f, 0.01732867f, -0.01190017f, 0.04440166f, 
    0.03783674f, -0.04514623f, 0.02175985f, 0.04253057f, -0.02651843f, -0.01653195f, 0.05463374f, 0.03110981f, 
    -0.04220503f, 0.03830957f, 0.05410624f, -0.02625198f, 0.01393732f, 0.01113362f, 0.02247648f, 0.03939945f, 
    0.01537043f, -0.02238668f, 0.00287125f, -0.04475669f, -0.05146491f, 0.00308825f, -0.00668321f, 0.01642778f, 
    -0.01494950f, 0.05300703f, -0.05038666f, -0.00598397f, -0.02414814f, 0.05360413f, 0.03759051f, -0.04273828f, 
    0.03796782f, -0.03457001f, 0.01792081f, -0.05332959f, 0.00346650f, 0.00406749f, 0.00479448f, -0.04825798f, 
    -0.01438175f, 0.04505287f, 0.05299521f, 0.03075086f, -0.03329459f, 0.04288838f, 0.03598090f, 0.02884498f, 
    -0.04863177f, -0.02805373f, -0.05385687f, -0.01164848f, -0.01759929f, 0.04102163f, -0.03479435f, -0.01037253f, 
    0.04555874f, 0.01297656f, 0.03709169f, -0.00989155f, 0.01355115f, -0.00833917f, -0.03921042f, 0.04773486f, 
    0.00710946f, -0.01879907f, -0.03851485f, -0.01016827f, -0.04559018f, 0.02743658f, 0.00189733f, 0.01503595f, 
    -0.05404264f, -0.03022800f, 0.04922691f, -0.03163614f, 0.03057465f, 0.05350423f, -0.04723223f, -0.03204967f, 
    0.05801118f, -0.11174566f, -0.02677429f, -0.08464354f, -0.00528835f, 0.03489886f, -0.01480380f, -0.01636416f, 
    -0.05994083f, 0.05218925f, 0.08385606f, 0.10284832f, 0.09072328f, 0.02587112f, -0.02990534f, -0.04780346f, 
    0.08862140f, 0.00029699f, 0.07351962f, -0.04968726f, -0.12353132f, 0.07081486f, 0.24820426f, 0.18560445f, 
    0.13252473f, 0.01823383f, 0.02485134f, 0.01280465f, 0.07155896f, 0.05349885f, 0.02807117f, 0.02077853f, 
    0.06857260f, 0.03445221f, 0.00322410f, 0.03049521f, 0.02578321f, -0.04614208f, 0.06690192f, 0.06207315f, 
    0.02613879f, -0.11467342f, 0.05256844f, -0.02478157f, -0.08619853f, 0.09300215f, -0.01914323f, -0.04698550f, 
    0.09005743f, -0.02432808f, 0.03132140f, 0.04725170f, -0.13603303f, -0.01777776f, -0.03596215f, -0.03290531f, 
    0.18886377f, -0.06536396f, 0.01815278f, 0.03943581f, 0.34083775f, -0.18632846f, 0.00734014f, -0.07146133f, 
    0.16915704f, -0.00376809f, 0.03938053f, -0.03819961f, 0.04128129f, -0.08000686f, 0.03446293f, -0.02057306f, 
    0.09113165f, -0.05196839f, 0.04756874f, -0.05401750f, 0.08154123f, 0.05423999f, 0.00928754f, 0.18388993f, 
    -0.10778438f, 0.09398590f, -0.04152832f, -0.07602174f, -0.12722008f, 0.11123369f, -0.02780365f, 0.00650559f, 
    0.02616182f, 0.06913415f, -0.10886874f, -0.01918344f, 0.13165590f, -0.05400859f, -0.03120514f, -0.04284771f, 
    -0.01864225f, 0.07668559f, 0.08662599f, 0.05136758f, 0.07000950f, 0.20397943f, 0.00766060f, 0.05557781f, 
    0.02367952f, 0.00191512f, 0.02764564f, -0.02821782f, -0.00178692f, -0.06099579f, -0.01944431f, -0.04655858f, 
    0.03576661f, -0.03243591f, 0.03746050f, -0.06069064f, -0.02907540f, 0.04521108f, 0.05677467f, -0.00058759f, 
    -0.07459360f, 0.20875211f, -0.03837778f, -0.08233003f, 0.02770537f, 0.09572359f, -0.04498786f, -0.02749035f, 
    0.05947810f, 0.00747056f, -0.03201844f, 0.06910581f, 0.01378578f, -0.05846511f, 0.09228689f, 0.02482102f, 
    0.11235994f, -0.09060894f, 0.04074517f, -0.05657107f, 0.14523937f, 0.04457515f, 0.05379471f, 0.28655499f, 
    0.24573870f, 0.01355422f, -0.05117580f, -0.04870628f, 0.05347066f, -0.01301488f, 0.06698854f, -0.00628329f, 
    -0.05011154f, -0.03043560f, -0.05186649f, 0.01683161f, -0.01827116f, 0.08141077f, -0.14936061f, -0.08289220f, 
    0.06952302f, 0.10605469f, 0.01796374f, 0.14052130f, 0.08345076f, 0.00887807f, 0.13967603f, 0.05741774f, 
    0.04399268f, 0.00791641f, 0.07052194f, 0.15872201f, -0.00059207f, 0.04491332f, 0.16188198f, 0.00111603f, 
    0.04367163f, -0.00665738f, -0.07299930f, 0.16945723f, -0.32146633f, -0.27020320f, 0.07149166f, -0.02353547f, 
    0.03064872f, -0.05793737f, 0.05654216f, -0.04542605f, -0.06322928f, -0.08804083f, 0.02151707f, 0.11875225f, 
    0.04030872f, -0.05811398f, 0.06096489f, -0.05868839f, 0.03106692f, -0.00198627f, 0.10690451f, 0.00129038f, 
    0.07815983f, -0.00485433f, 0.17523614f, -0.05653976f, 0.12467460f, 0.01183429f, 0.03876804f, 0.06088762f, 
    -0.02576536f, 0.09716479f, 0.03718313f, 0.07876193f, -0.01018700f, -0.07356437f, -0.05377901f, 0.06465956f, 
    -0.00038491f, -0.03594356f, 0.13125595f, 0.03769140f, -0.15331969f, -0.07739139f, -0.10190853f, -0.19634558f, 
    -0.04024525f, -0.01697917f, -0.02483498f, 0.00107118f, -0.06111823f, -0.17763494f, -0.03190304f, 0.00058193f, 
    -0.04871041f, 0.02627622f, 0.01070322f, -0.00283680f, 0.00503954f, 0.01542203f, 0.01044921f, 0.08890092f, 
    -0.02833962f, 0.01336895f, 0.05750893f, -0.04142061f, 0.14692992f, 0.02575363f, -0.00266836f, -0.02194598f, 
    0.04666587f, 0.00380942f, -0.00685829f, 0.01903748f, 0.06725091f, 0.01319421f, 0.14477377f, 0.00883732f, 
    0.04257039f, 0.03513025f, 0.04127332f, 0.01113494f, 0.20427611f, 0.06587657f, 0.10588559f, 0.30414259f, 
    0.01581034f, 0.05707692f, 0.10389858f, -0.02864408f, 0.02733365f, -0.00294935f, 0.04471655f, 0.04651602f, 
    -0.02051046f, -0.07885568f, 0.08527517f, 0.06309044f, -0.04455226f, 0.08587027f, 0.06291624f, 0.15391351f, 
    -0.01444340f, 0.33758730f, -0.05193387f, -0.03956174f, -0.12067925f, -0.01692592f, 0.03917968f, -0.00609230f, 
    -0.07255402f, -0.06752507f, -0.00709906f, 0.04397050f, -0.02211931f, 0.02803112f, 0.07396135f, -0.09966058f, 
    0.05092610f, 0.06414875f, -0.08297815f, 0.06144349f, -0.09289604f, 0.06641787f, 0.16440873f, 0.08756705f, 
    0.10251906f, -0.10053258f, -0.08971634f, 0.10239338f, 0.00734575f, 0.01200301f, -0.02174096f, 0.02827046f, 
    0.00763624f, -0.04779865f, -0.02015175f, 0.00862096f, 0.01966844f, 0.04854855f, 0.15785594f, 0.01483316f, 
    -0.10367507f, -0.22098893f, -0.16956262f, -0.13497525f, -0.03750346f, 0.02437980f, 0.02644633f, 0.19081396f, 
    0.02555158f, 0.06878056f, 0.01471872f, 0.09758884f, -0.04841173f, 0.07407039f, -0.11119150f, -0.02821608f, 
    -0.02203612f, -0.03270877f, -0.01782783f, 0.03631518f, 0.32826120f, 0.22175349f, -0.05525301f, 0.00099078f, 
    0.04908792f, 0.03734772f, 0.08768649f, 0.06505146f, -0.02930384f, 0.07295934f, -0.01050517f, -0.08049122f, 
    -0.13319249f, 0.00862293f, 0.02779820f, 0.06590369f, 0.01418755f, 0.05269643f, -0.05059544f, 0.03694435f, 
    -0.19802280f, 0.28455955f, -0.12211584f, 0.03580490f, -0.23503630f, -0.02235846f, -0.01099558f, 0.08725698f, 
    -0.06499264f, 0.20231229f, 0.07997634f, 0.09515619f, 0.05098038f, 0.00869862f, -0.03972616f, -0.06295077f, 
    -0.03131754f, 0.08996592f, 0.04159120f, 0.03439537f, 0.06261950f, -0.00859288f, 0.11179123f, -0.11874370f, 
    0.20284732f, 0.10773944f, -0.03523538f, -0.01419089f, -0.02147987f, 0.03957319f, 0.00778544f, -0.02318190f, 
    -0.02400590f, -0.00392142f, 0.04705942f, -0.02030081f, -0.06160495f, -0.00973520f, -0.07257773f, -0.05551763f, 
    0.13578284f, -0.11255807f, -0.12150460f, 0.13545448f, -0.17449650f, -0.05985729f, 0.00097059f, -0.07039621f, 
    0.02843008f, -0.03236615f, 0.06274629f, -0.04689437f, 0.00281716f, -0.11409830f, -0.02811380f, 0.04018676f, 
    -0.05619002f, 0.03475448f, -0.04942665f, 0.03366021f, 0.09567101f, -0.01764236f, -0.18937451f, -0.18682325f, 
    0.17484514f, 0.11636698f, 0.07322348f, 0.01219846f, 0.12882599f, 0.08566829f, 0.09444664f, -0.04514769f, 
    0.03087541f, -0.01449876f, -0.15735227f, -0.04358727f, -0.04326301f, -0.00081041f, -0.06539748f, 0.02867000f, 
    0.38744536f, -0.12882032f, -0.14275937f, 0.26742139f, -0.18233979f, -0.11466470f, 0.06417192f, 0.01534608f, 
    -0.00736643f, -0.03592957f, 0.03727782f, 0.07267676f, -0.00658210f, -0.10451142f, 0.00730080f, 0.04180297f, 
    -0.03986657f, 0.10314623f, 0.06361946f, -0.07085695f, -0.13480012f, -0.03937402f, -0.02629014f, 0.00181251f, 
    0.06959432f, 0.02683765f, 0.15685311f, 0.05602008f, -0.10531297f, -0.05221592f, -0.04841683f, -0.00492096f, 
    0.02189783f, -0.03445341f, 0.04198262f, -0.03770921f, 0.03470123f, -0.11195470f, -0.00841955f, 0.09254088f, 
    -0.22939400f, -0.09210166f, -0.11834153f, 0.23046987f, 0.13030437f, 0.08728441f, 0.04011870f, 0.14507727f, 
    -0.06903061f, 0.04868765f, -0.01391503f, -0.02666428f, -0.04725429f, -0.06718053f, -0.13229907f, -0.03725326f, 
    -0.18656297f, 0.02079561f, 0.04677565f, 0.03118249f, -0.08545937f, 0.24942042f, 0.24808386f, 0.12732160f, 
    -0.04958198f, 0.12152442f, 0.04888391f, 0.17149910f, 0.14238356f, 0.01276911f, -0.00321746f, 0.00663477f, 
    0.02479712f, 0.08988035f, -0.02015651f, 0.08655050f, 0.06604318f, -0.02313344f, -0.05814137f, 0.01075075f, 
    0.22177266f, 0.09174445f, -0.10843415f, -0.07785718f, -0.20357963f, 0.02559410f, -0.07663614f, 0.06789122f, 
    -0.02902985f, -0.01104776f, -0.02869090f, 0.01744057f, 0.08799105f, -0.04999143f, 0.05991999f, -0.05228939f, 
    -0.00103487f, 0.01369362f, -0.08667809f, 0.07314514f, 0.18167467f, 0.20569909f, -0.00034727f, 0.25470302f, 
    -0.29683959f, -0.04884436f, 0.02693905f, 0.02048142f, 0.03358639f, 0.09483334f, -0.06403826f, 0.04850756f, 
    -0.00822023f, -0.06744989f, 0.02949874f, -0.02236470f, 0.09331930f, 0.12940240f, -0.02438704f, -0.05284824f, 
    0.00830721f, -0.30173153f, -0.15962058f, -0.28159228f, 0.00804613f, -0.09660091f, 0.02018593f, 0.04478775f, 
    -0.05293712f, -0.15647201f, -0.10009028f, 0.00989309f, -0.04830235f, 0.05166309f, -0.00782142f, -0.03091437f, 
    0.09610541f, -0.04656991f, -0.03087236f, 0.01450270f, -0.04455852f, 0.03672014f, -0.34317040f, -0.34980503f, 
    0.14755115f, 0.08520155f, 0.05743794f, -0.02843361f, -0.08969265f, 0.07972649f, 0.02935704f, -0.00992984f, 
    -0.07075969f, -0.10543072f, -0.09241354f, 0.05432123f, -0.01869195f, -0.02485302f, 0.00216851f, -0.00961959f, 
    -0.19795673f, -0.34904042f, 0.21122120f, -0.24658091f, 0.20524190f, 0.00874252f, 0.04381121f, 0.03271785f, 
    0.01738565f, -0.03151640f, 0.12434570f, 0.03665902f, 0.04196222f, 0.08953160f, -0.18364450f, 0.01419122f, 
    0.02721194f, -0.04101130f, 0.11207845f, 0.08740608f, 0.32472381f, -0.42166886f, -0.11987422f, -0.41654682f, 
    0.14070490f, -0.08459440f, 0.04025567f, -0.05720014f, 0.01865241f, -0.13340540f, -0.03068684f, 0.11671607f, 
    0.05680480f, 0.06476116f, 0.00881388f, 0.01746561f, -0.05381560f, -0.16086413f, -0.13990098f, 0.09675512f, 
    -0.03761834f, -0.04892622f, -0.01689050f, 0.00285748f, -0.01161825f, 0.02503528f, -0.05125789f, -0.03430279f, 
    -0.03440516f, -0.00198476f, 0.00205196f, 0.05224235f, 0.03692346f, -0.04904696f, 0.04662821f, -0.03474845f, 
    0.01143044f, -0.02090004f, 0.02686640f, -0.04421201f, 0.01602751f, 0.03212842f, 0.00390408f, 0.03149651f, 
    -0.00337493f, 0.01795743f, 0.00189259f, 0.01440309f, -0.05226025f, 0.04135514f, -0.04924773f, -0.03508218f, 
    0.03637479f, -0.00447714f, -0.04523638f, -0.02739603f, -0.02003435f, -0.05069297f, -0.00952322f, 0.04069736f, 
    -0.04775000f, 0.04431084f, -0.00191613f, 0.03097659f, -0.01386994f, -0.05591745f, 0.03995827f, -0.02486653f, 
    -0.03491800f, -0.02758195f, -0.03524618f, -0.01797563f, -0.02139781f, -0.04993255f, 0.02103804f, 0.04167300f, 
    -0.05055200f, -0.01876960f, 0.02635617f, -0.02080996f, 0.04975569f, 0.00522972f, -0.05075275f, -0.02019506f, 
    0.00705734f, -0.01627152f, -0.00655753f, 0.01541868f, -0.04889170f, 0.02499890f, 0.00978906f, -0.00272422f, 
    -0.01622230f, -0.05951759f, 0.00299744f, -0.05378945f, 0.01906128f, -0.01389299f, 0.00458451f, -0.00716279f, 
    0.02575036f, 0.01180010f, -0.01757776f, -0.05340078f, -0.00164028f, 0.04110846f, -0.05459486f, 0.00141793f, 
    0.00142302f, -0.04154176f, -0.01365572f, -0.01569040f, -0.01511619f, -0.03447979f, -0.01773849f, -0.04004096f, 
    -0.02519254f, -0.01065012f, 0.04894450f, 0.02856520f, -0.04242444f, 0.00064680f, 0.03812912f, 0.02709796f, 
    -0.02952540f, -0.05037754f, -0.04413777f, 0.02293315f, -0.02536434f, -0.00660719f, 0.00014648f, -0.04864617f, 
    -0.02772223f, 0.00895708f, 0.04581918f, 0.01937862f, 0.02742903f, -0.02461371f, 0.00111798f, 0.01701909f, 
    -0.05287073f, -0.04906973f, -0.03481832f, 0.04330344f, -0.00530717f, -0.00392741f, -0.04664673f, -0.05606956f, 
    -0.04174899f, 0.03802622f, -0.02705152f, -0.04966256f, 0.00914113f, 0.02628592f, -0.03131116f, -0.02862383f, 
    0.00245337f, -0.05798383f, 0.00468762f, -0.05326760f, -0.03387055f, -0.03438741f, -0.00967990f, 0.01897749f, 
    -0.02302343f, -0.02699122f, -0.05730338f, -0.00428288f, 0.01687779f, 0.02406298f, -0.03988087f, 0.00063193f, 
    -0.01054047f, -0.00679338f, 0.02456142f, -0.02306226f, 0.03863263f, -0.04401640f, -0.05536123f, 0.04625938f, 
    -0.00106937f, -0.01791090f, 0.00432118f, 0.00839126f, 0.00473714f, 0.01230451f, -0.02437294f, -0.03991094f, 
    -0.01373582f, 0.00448103f, -0.02151062f, 0.04460516f, -0.05276043f, -0.03408684f, 0.00815540f, -0.04688822f, 
    -0.01221272f, -0.05302360f, 0.01427835f, -0.00266164f, -0.00611864f, 0.04527634f, 0.02028992f, 0.02633724f, 
    -0.01703594f, 0.02376829f, -0.01584034f, -0.05087498f, -0.04687288f, 0.00037824f, 0.02444057f, -0.01663694f, 
    -0.00563235f, -0.05286251f, 0.00921590f, 0.00687049f, -0.04325264f, -0.04296957f, -0.04503710f, -0.03299844f, 
    -0.00285867f, 0.04625852f, -0.04079462f, 0.02284887f, 0.04193770f, 0.03047171f, 0.00020604f, -0.00527266f, 
    -0.05750690f, 0.03314428f, 0.02289037f, 0.00842524f, 0.01471688f, -0.01064427f, 0.01413049f, -0.03787633f, 
    -0.02406807f, 0.02866102f, -0.00075569f, -0.04333473f, -0.05221879f, 0.03753552f, 0.05042996f, 0.04762364f, 
    -0.01939205f, 0.04883436f, 0.03758551f, -0.04487870f, -0.02489537f, 0.03548048f, 0.04244779f, -0.03001339f, 
    0.02057150f, -0.03058461f, -0.01649458f, -0.04650022f, -0.03948641f, -0.02939953f, 0.02894161f, -0.05512228f, 
    -0.03693713f, 0.04539295f, 0.00723686f, 0.04120255f, -0.01321066f, 0.04178688f, -0.01623103f, 0.00348071f, 
    -0.01151804f, 0.04372923f, -0.00308329f, -0.00563641f, -0.02239055f, -0.01375925f, 0.02617534f, 0.01299599f, 
    -0.05520191f, -0.02934972f, -0.03960368f, -0.03700613f, 0.01335006f, 0.00563179f, 0.03906002f, 0.00586898f, 
    0.02652376f, -0.03589528f, 0.00549284f, -0.04908822f, -0.03607905f, -0.00991627f, 0.00173287f, -0.02413472f, 
    0.04152815f, -0.05163058f, -0.04678726f, -0.01072504f, 0.03141862f, 0.01447295f, -0.01014404f, -0.04880432f, 
    0.01195832f, -0.00633695f, -0.04550461f, -0.04000938f, -0.05932657f, -0.05365624f, 0.01376234f, 0.02396682f, 
    -0.02250837f, 0.00741976f, -0.02827166f, 0.01420734f, -0.02758450f, -0.03832061f, 0.03139504f, 0.01063172f, 
    0.00972132f, -0.02815870f, 0.01330513f, 0.02655752f, -0.01704026f, -0.05819235f, -0.04960098f, 0.03069754f, 
    -0.02142296f, -0.00729828f, 0.04123311f, -0.00474873f, -0.03266962f, 0.00484198f, -0.01512206f, 0.01880926f, 
    -0.05151868f, -0.03422919f, -0.01253215f, -0.04292634f, 0.00742760f, -0.00118350f, -0.03059778f, -0.00845107f, 
    0.03837524f, -0.03060990f, 0.03718289f, -0.01320809f, 0.01960291f, -0.04190605f, -0.03179865f, -0.01133666f, 
    -0.05861533f, 0.02770306f, -0.03557672f, -0.05864177f, 0.04147369f, -0.02179690f, -0.05623109f, 0.03119705f, 
    0.03249132f, 0.02694482f, -0.00431176f, 0.00843442f, -0.03146835f, 0.02297911f, 0.00748220f, 0.00530260f, 
    0.02049020f, -0.03605661f, 0.02411345f, -0.05272600f, -0.03017224f, 0.04083068f, 0.01479136f, -0.05718512f, 
    -0.01466095f, -0.06011679f, -0.05482781f, -0.02312520f, 0.02227336f, -0.02829055f, -0.01680429f, -0.00549072f, 
    -0.06408569f, -0.04324622f, 0.00470782f, 0.01939242f, -0.03979155f, -0.02761474f, -0.00565917f, -0.05964702f, 
    0.02794909f, 0.02577833f, 0.01076835f, 0.03806819f, -0.03130282f, -0.00664073f, -0.03792723f, 0.00458382f, 
    -0.06292467f, 0.01284349f, -0.04953177f, 0.04246887f, 0.04501228f, -0.03531462f, -0.05386901f, 0.03866557f, 
    -0.01286684f, 0.02541514f, -0.03319746f, -0.05376063f, -0.02746205f, -0.03456160f, 0.03191997f, -0.04677607f, 
    -0.01453823f, 0.01579798f, -0.01942500f, -0.03712840f, 0.01886200f, 0.03806804f, -0.00446620f, 0.02065636f, 
    0.03715731f, -0.03289211f, -0.00324041f, -0.01396399f, -0.01616041f, -0.03311237f, 0.03030188f, 0.04482776f, 
    -0.02386604f, -0.01855138f, -0.05104612f, -0.06197656f, -0.01209742f, -0.05814185f, 0.00387517f, -0.00496355f, 
    0.02044789f, -0.03159706f, -0.00844472f, 0.00048092f, -0.00235214f, -0.00504781f, -0.01957137f, -0.06089512f, 
    0.03455821f, -0.04052885f, -0.00104194f, -0.03591026f, -0.01807325f, -0.04730269f, 0.03800028f, -0.02477329f, 
    -0.05486247f, 0.02937596f, -0.00517296f, 0.00767259f, 0.03127282f, -0.02201214f, -0.02512090f, -0.01666266f, 
    0.04128220f, -0.05402933f, -0.04524233f, -0.03545789f, 0.01510773f, 0.00880565f, 0.04186698f, -0.04977221f, 
    0.02814207f, 0.01508700f, 0.02606069f, 0.02056162f, 0.02613921f, 0.03817483f, 0.00261585f, -0.00046043f, 
    -0.00507785f, 0.04484643f, -0.06595260f, -0.05133320f, -0.04076000f, 0.00353011f, 0.02984572f, 0.02672498f, 
    -0.01895703f, -0.01382397f, 0.01596780f, 0.00592654f, 0.01399337f, 0.03677922f, -0.02001073f, 0.04589572f, 
    -0.04512160f, -0.05366963f, 0.02185230f, -0.05313654f, -0.00720342f, -0.05464420f, 0.00250674f, 0.01725675f, 
    0.03437465f, 0.01757700f, 0.03080236f, -0.01980329f, -0.06574301f, 0.00384674f, 0.04063061f, -0.04410701f, 
    -0.04415845f, 0.02015820f, -0.05162868f, -0.01865293f, 0.01145674f, -0.04277834f, 0.02993420f, 0.01253847f, 
    -0.00331243f, 0.01240980f, -0.06552874f, 0.01845900f, 0.02993144f, -0.05504116f, 0.03650708f, 0.01090245f, 
    -0.02296202f, 0.01037223f, 0.01879101f, -0.01863269f, 0.02096481f, 0.00741371f, 0.01607642f, -0.03285507f, 
    0.01505344f, 0.03230952f, -0.03317147f, 0.00872229f, -0.05544931f, 0.01618971f, 0.03298727f, -0.02635605f, 
    -0.06098924f, 0.00606808f, 0.00032330f, -0.02311737f, 0.02816106f, -0.01539558f, -0.02384516f, -0.04498482f, 
    -0.01691314f, 0.02341779f, 0.03333747f, -0.05716995f, 0.03751833f, 0.02066927f, -0.03453858f, -0.01429986f, 
    0.01437392f, -0.06216514f, 0.00060463f, 0.03026010f, 0.00742772f, -0.00847737f, 0.00968251f, -0.04655891f, 
    -0.05093981f, 0.04208971f, -0.03977842f, -0.01841348f, -0.05289994f, 0.00055211f, -0.03151397f, 0.02183411f, 
    0.03179207f, -0.00793574f, 0.03186803f, 0.00442676f, 0.00837095f, 0.01496923f, -0.02315834f, -0.06023448f, 
    -0.01005424f, -0.06749883f, -0.03454827f, 0.02249414f, 0.03818756f, -0.00867296f, -0.04920787f, 0.00526335f, 
    0.03985085f, 0.02393365f, -0.03995058f, 0.04163779f, -0.04657148f, -0.05189901f, 0.01100359f, 0.02547112f, 
    -0.02299810f, -0.05999636f, 0.02396309f, 0.02916158f, -0.01150825f, -0.03235434f, -0.06436742f, 0.03457839f, 
    -0.04675105f, 0.00226345f, 0.03461026f, -0.02206944f, -0.04856662f, 0.01205879f, -0.05456918f, 0.04083511f, 
    -0.06317811f, 0.03378772f, -0.01763219f, -0.04792861f, -0.04877436f, -0.03203868f, -0.00907174f, -0.03777247f, 
    -0.00092215f, -0.03696725f, 0.03896680f, -0.00988762f, 0.00408199f, -0.06032462f, -0.03746791f, -0.05261953f, 
    -0.06317261f, 0.02896398f, 0.00102988f, -0.00922516f, 0.04190334f, -0.03333610f, 0.02546147f, 0.04227741f, 
    -0.02951805f, -0.02084796f, 0.00828795f, -0.00851380f, -0.04469950f, -0.05913516f, -0.02760440f, -0.05183557f, 
    -0.06522638f, -0.01925554f, 0.04358589f, -0.06095977f, -0.06464090f, 0.03604374f, 0.03186242f, -0.00936136f, 
    0.04031075f, 0.01859339f, -0.02258934f, -0.00147182f, 0.00510248f, -0.03739886f, -0.05991604f, 0.01222539f, 
    -0.14465493f, 0.05805662f, -0.04863365f, -0.07828920f, 0.21678330f, 0.09913582f, -0.00692445f, -0.05515477f, 
    -0.01642998f, 0.04812998f, 0.06448050f, 0.01835321f, 0.05623336f, -0.12324060f, 0.00545330f, 0.01790293f, 
    0.03688350f, -0.10612011f, 0.07624345f, -0.03976435f, 0.17288528f, -0.18107143f, 0.15701455f, -0.05239060f, 
    -0.07251824f, -0.06199070f, 0.01256540f, 0.00660158f, -0.02394151f, -0.04177343f, 0.02025972f, 0.09011690f, 
    -0.01307732f, 0.04815601f, 0.05151282f, 0.04291267f, 0.04492633f, -0.01485554f, 0.07935920f, -0.00766088f, 
    0.24338049f, -0.21369450f, 0.02145527f, 0.09817997f, -0.17004803f, 0.06540275f, -0.01501296f, 0.10577721f, 
    0.02579183f, 0.00880698f, -0.07776006f, 0.05430062f, 0.02966649f, 0.02631093f, -0.04212273f, 0.05066315f, 
    0.06509761f, -0.17327239f, -0.17551464f, 0.06992994f, 0.22367027f, 0.03458657f, -0.16071945f, -0.13940606f, 
    0.07605364f, 0.05398663f, 0.04921042f, -0.05652317f, 0.10233493f, 0.05340139f, -0.07957593f, -0.06898664f, 
    0.13961495f, 0.02133643f, 0.10310004f, 0.02492883f, 0.02496303f, -0.16965595f, 0.04946338f, 0.03213098f, 
    0.02032211f, -0.13268892f, -0.07157800f, -0.01682024f, -0.03558467f, 0.09651738f, 0.06522190f, 0.03494058f, 
    0.10172968f, 0.14258318f, 0.06222896f, 0.04399306f, 0.11929652f, -0.08773986f, -0.08152770f, -0.00169945f, 
    0.01436922f, -0.06203836f, -0.12567557f, 0.00434989f, -0.07557325f, 0.03381839f, -0.16935147f, -0.04097528f, 
    0.05620951f, 0.07494557f, -0.00223043f, -0.01397736f, -0.08656842f, -0.05509506f, -0.00302951f, -0.00604594f, 
    0.00974910f, -0.07640421f, 0.07738392f, -0.06147869f, -0.00728373f, 0.01547605f, 0.04150242f, 0.05718783f, 
    0.15894912f, 0.15664241f, -0.05157064f, -0.17090984f, 0.02998173f, 0.03227702f, 0.01511674f, -0.02126362f, 
    -0.06432682f, -0.01917342f, -0.09550431f, -0.02065548f, -0.04186287f, 0.09488011f, 0.06237570f, 0.15613706f, 
    0.04908653f, -0.11413211f, -0.08087477f, -0.07793961f, 0.18622580f, 0.05660164f, -0.03276310f, -0.05865295f, 
    0.29296571f, -0.15611593f, -0.03805754f, 0.07041895f, 0.13015443f, 0.02329771f, 0.02982538f, 0.05122335f, 
    0.04019481f, 0.08827079f, 0.06395073f, 0.01340324f, -0.00903879f, 0.10790811f, -0.07912610f, 0.05041038f, 
    -0.01508523f, 0.28806975f, 0.05292897f, 0.17360711f, -0.16843252f, 0.02421868f, -0.05976378f, 0.07729942f, 
    -0.08478232f, -0.11718100f, -0.08495530f, 0.14750953f, 0.05440334f, 0.05201835f, 0.11682776f, 0.08292055f, 
    0.07453026f, -0.10912845f, -0.09476348f, -0.03197961f, -0.13544941f, 0.04065010f, 0.12714396f, 0.04912808f, 
    -0.12833905f, -0.12248806f, 0.11042204f, 0.07914274f, -0.06200320f, -0.09418271f, 0.01292176f, -0.05067031f, 
    -0.04723465f, -0.09959031f, 0.05962255f, -0.00334904f, -0.05511358f, -0.05835231f, 0.00241311f, 0.01977402f, 
    0.21923126f, 0.06155292f, -0.01100033f, -0.06992096f, 0.20213489f, 0.01690200f, 0.06573616f, 0.00765290f, 
    -0.12569967f, 0.04514186f, 0.00374650f, 0.07703468f, 0.02211080f, -0.08707771f, -0.00705815f, 0.00421237f, 
    0.06540440f, -0.00067224f, 0.16718219f, 0.13216987f, -0.06676450f, -0.00375307f, -0.12028041f, -0.14002018f, 
    -0.15263318f, 0.06880552f, 0.09042516f, 0.01766364f, 0.02621474f, -0.03026002f, 0.08534119f, -0.00171528f, 
    -0.05324351f, 0.06729843f, 0.01056935f, 0.06802144f, -0.00131687f, -0.14040622f, -0.08635365f, -0.06018227f, 
    -0.10060458f, -0.02720528f, -0.05662850f, -0.11843219f, 0.22627218f, 0.13668741f, 0.08746610f, -0.03692226f, 
    0.03453464f, 0.13103490f, 0.05455067f, 0.00278568f, -0.00879841f, 0.06688222f, 0.03786447f, -0.00686739f, 
    0.06119885f, -0.00113651f, 0.01341636f, -0.09232280f, 0.20326841f, -0.04596818f, -0.04277761f, 0.17647128f, 
    0.11771067f, -0.12146237f, -0.00129174f, -0.03955680f, 0.13367586f, -0.07832938f, -0.03271587f, 0.05128355f, 
    -0.00436518f, 0.03426713f, 0.12103643f, 0.00563750f, -0.08510308f, 0.09887001f, 0.19653766f, 0.09871053f, 
    -0.00526905f, 0.24799892f, -0.05861428f, -0.09853663f, 0.04430269f, 0.17641284f, -0.03579764f, 0.05051909f, 
    -0.08707519f, -0.08883326f, -0.07991410f, 0.08398211f, -0.01841374f, -0.06372458f, 0.01856101f, -0.04723953f, 
    0.04246761f, 0.09758622f, -0.04755416f, -0.01921659f, -0.24409138f, -0.03320967f, 0.05350745f, 0.06663938f, 
    0.19774309f, 0.05612928f, 0.05638384f, -0.01308134f, 0.07802029f, 0.04505788f, -0.03378737f, -0.11139075f, 
    0.07777060f, 0.06589909f, 0.01034226f, -0.02130738f, 0.03167130f, -0.06049313f, 0.02665413f, -0.02658092f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13168225f, 0.10996871f, 0.01367324f, 0.01059521f, -0.06881997f, -0.00172698f, 0.07275618f, 0.05528772f, 
    0.05694554f, 0.02233058f, 0.04955899f, -0.03704674f, -0.02332775f, 0.03990373f, 0.06416085f, 0.08656116f, 
    -0.00029966f, 0.09763373f, 0.06232020f, 0.05529891f, -0.02729571f, 0.04099650f, -0.01338027f, 0.01140727f, 
    0.15899341f, -0.02760668f, -0.05458244f, -0.03641599f, 0.07145447f, 0.12159666f, 0.01535979f, -0.00333767f, 
    0.03052497f, 0.04546495f, 0.02550265f, -0.01368819f, 0.03333312f, -0.04623102f, 0.04031188f, 0.01477184f, 
    0.00415341f, -0.04066603f, -0.00338720f, 0.09647964f, -0.03159334f, 0.06021146f, -0.02694796f, -0.04157156f, 
    0.07341594f, 0.02830751f, -0.02023392f, 0.01742111f, -0.07168221f, 0.00948746f, 0.01010896f, -0.03955776f, 
    -0.03420322f, -0.05008534f, 0.03263972f, 0.01224071f, 0.05916880f, 0.00166619f, 0.02120119f, -0.02540512f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00792199f, 0.19043250f, -0.05799555f, 0.03795780f, -0.06811903f, -0.03945948f, -0.07396159f, 0.02864805f, 
    0.00715925f, 0.27742505f, 0.02669540f, -0.05187346f, -0.09724633f, -0.12474464f, 0.14771450f, 0.03760044f, 
    -0.08699054f, -0.02670990f, 0.04479148f, 0.08412094f, -0.22953899f, -0.08078035f, 0.01394820f, 0.06955577f, 
    0.08612005f, 0.09037226f, -0.00792654f, 0.10566015f, -0.00692452f, 0.15663740f, 0.18508773f, 0.03580989f, 
    0.00036310f, 0.10865571f, 0.40552151f, 0.04083408f, 0.13214116f, -0.09656841f, 0.01398961f, -0.17348666f, 
    0.16021271f, -0.08666542f, -0.08856848f, 0.09194452f, 0.12156226f, 0.23667222f, -0.25206342f, 0.08935019f, 
    0.07671010f, -0.31113532f, -0.04994892f, 0.18691075f, -0.01048878f, -0.12140150f, -0.10698340f, 0.01516916f, 
    -0.02284593f, -0.06854356f, -0.03172565f, 0.21052575f, -0.31656280f, -0.03413635f, -0.00886386f, -0.09287869f, 
    0.01186382f, -0.06507862f, -0.06395631f, 0.06189493f, -0.01358378f, 0.01765970f, 0.13422349f, 0.22797236f, 
    0.16710326f, 0.14215748f, 0.15912662f, -0.04373457f, 0.05413941f, -0.02061100f, 0.25511089f, 0.21610327f, 
    -0.14397657f, 0.20672411f, -0.00397232f, 0.06384543f, -0.14003941f, 0.25396630f, 0.07660668f, -0.15497009f, 
    0.08865350f, -0.00039165f, 0.03366229f, -0.05525500f, 0.34603006f, 0.06084048f, -0.37236381f, -0.23119922f, 
    -0.06692342f, 0.10892606f, 0.10091262f, -0.03656230f, -0.21308325f, 0.01724610f, 0.02814664f, -0.24786927f, 
    0.25925553f, -0.05605363f, 0.04180131f, 0.04018629f, 0.06826929f, -0.14462106f, 0.25172675f, -0.10318696f, 
    -0.08887501f, 0.12124700f, 0.10994856f, -0.15030824f, 0.05413298f, 0.16414395f, 0.21195966f, 0.05096492f, 
    0.07091751f, 0.05624405f, -0.06470051f, -0.15738826f, -0.01682881f, 0.04180522f, 0.06422241f, 0.11672357f, 
    0.00572068f, 0.15672433f, 0.05638508f, 0.02201245f, 0.03256183f, 0.04817652f, 0.12795343f, 0.27090645f, 
    0.11158682f, -0.01759347f, -0.38416851f, 0.06223471f, 0.05682723f, 0.14584100f, 0.10669068f, -0.14601776f, 
    0.05871938f, 0.02317596f, 0.07350354f, -0.09534393f, 0.00696919f, -0.15065679f, -0.05602816f, 0.03145004f, 
    -0.15179394f, -0.11067536f, -0.27541217f, -0.20496193f, -0.07044575f, 0.22784381f, 0.23830658f, 0.15387577f, 
    -0.05190698f, -0.08958191f, 0.36426017f, -0.08304036f, -0.03476685f, 0.08404574f, -0.00408942f, 0.02849779f, 
    -0.12701857f, 0.00062901f, 0.19681621f, 0.12404403f, 0.23336418f, 0.26578328f, 0.03268829f, -0.01057275f, 
    0.29669213f, -0.05913765f, -0.47085518f, 0.18798314f, -0.15114434f, -0.13955188f, -0.03004873f, -0.11782152f, 
    -0.04967807f, 0.01754769f, -0.06317469f, -0.04229243f, -0.03041623f, 0.05045827f, -0.09653667f, -0.06598309f, 
    -0.06473450f, -0.03562121f, -0.01883022f, 0.11598332f, 0.04663552f, 0.11904967f, -0.05568490f, -0.21404593f, 
    -0.27407047f, -0.23523805f, 0.19508506f, 0.01264858f, 0.07885187f, 0.21238947f, 0.08518704f, 0.03807889f, 
    0.12825245f, 0.09981243f, 0.23687138f, -0.04830251f, 0.06010065f, -0.15003116f, 0.03422857f, -0.11410037f, 
    0.19267638f, -0.09090233f, -0.15098670f, -0.37066391f, -0.05153754f, 0.16495293f, 0.00000440f, 0.08845392f, 
    0.11351388f, 0.08737358f, -0.23690309f, 0.02236747f, -0.09716824f, 0.05847992f, -0.02550650f, 0.43797722f, 
    -0.13049084f, 0.03930829f, 0.22671688f, -0.37197205f, 0.00555929f, 0.05847963f, 0.07769015f, -0.00464842f, 
    0.28977367f, 0.13573188f, 0.00570543f, -0.29870322f, -0.24406447f, 0.08908925f, 0.00474338f, -0.12803617f, 
    -0.01169251f, -0.07898571f, 0.05214438f, 0.17963539f, 0.18992466f, 0.03577963f, -0.03096736f, 0.21542853f, 
    -0.25056720f, -0.07904191f, 0.02444356f, -0.06708673f, -0.12759997f, -0.05544024f, -0.01401733f, -0.31566000f, 
    -0.49850827f, -0.12613092f, 0.18923104f, -0.00570328f, -0.04565782f, 0.21890457f, 0.21539965f, -0.01410791f, 
    0.20534040f, 0.10477973f, 0.23447531f, 0.05912175f, -0.20298629f, 0.05053160f, 0.10814232f, 0.04482974f, 
    -0.06954452f, -0.10059039f, -0.02415362f, -0.19657806f, -0.19199190f, 0.00766267f, 0.28365168f, 0.27278683f, 
    -0.00548838f, 0.04615975f, 0.02287742f, -0.04853543f, -0.23489729f, -0.04029448f, -0.03809502f, 0.35820508f, 
    -0.06203816f, 0.11071049f, 0.03922774f, -0.38837162f, 0.16047737f, 0.17129928f, 0.03734307f, -0.05378207f, 
    0.02277191f, 0.01426576f, -0.13617514f, -0.11767749f, 0.10458687f, 0.11297271f, 0.06729868f, 0.10859163f, 
    0.00699501f, 0.06032150f, -0.06679465f, 0.05627709f, -0.32596043f, 0.03755555f, -0.10004121f, 0.29719266f, 
    -0.24009719f, -0.00942038f, -0.09436139f, -0.00273504f, -0.00951968f, 0.00470290f, 0.08556562f, -0.22136246f, 
    -0.06417125f, 0.10471651f, -0.19054902f, -0.04644870f, -0.10741093f, 0.17556205f, 0.11104943f, 0.01788587f, 
    -0.06838660f, -0.03773705f, 0.19505435f, 0.11762697f, -0.20909217f, -0.02027209f, 0.04987570f, -0.03505030f, 
    0.05574603f, -0.08361767f, 0.32138348f, 0.24539559f, 0.03576654f, 0.05735175f, -0.16648453f, 0.04205301f, 
    -0.06028318f, 0.09478867f, 0.32542101f, 0.08205430f, -0.15351342f, -0.03637995f, 0.03810161f, -0.05013812f, 
    0.12342497f, -0.07517382f, -0.15693107f, -0.04458132f, 0.29564032f, 0.13907720f, -0.19092053f, -0.00622650f, 
    -0.22645341f, -0.21683769f, -0.19353515f, -0.13249721f, -0.12794207f, 0.06783774f, 0.10954274f, 0.04700989f, 
    -0.01599984f, -0.00353369f, -0.10273677f, 0.13926831f, -0.68827397f, -0.02481119f, 0.08340524f, 0.17564788f, 
    -0.13089357f, -0.04008261f, 0.11792946f, -0.04987297f, 0.03786096f, -0.04997896f, 0.06135929f, -0.10250951f, 
    -0.06077303f, -0.04059513f, 0.07059115f, 0.06816617f, -0.10242458f, 0.08964972f, 0.09800999f, -0.10043316f, 
    -0.07007094f, -0.00138892f, -0.06839471f, -0.08935101f, -0.12277182f, 0.00829584f, -0.05395555f, -0.04506411f, 
    -0.04431022f, -0.08042439f, -0.03604285f, -0.03943742f, -0.03010797f, -0.03311788f, -0.06381800f, 0.10322137f, 
    -0.04572646f, 0.03567180f, -0.00629677f, -0.05717235f, -0.10334280f, 0.01971948f, 0.05022654f, -0.10489505f, 
    0.05500730f, -0.01686576f, -0.10883646f, -0.06568350f, 0.00369142f, 0.07361945f, -0.11192041f, 0.09828920f, 
    0.09655939f, 0.07774248f, 0.01623787f, -0.03141298f, 0.06370915f, -0.07525323f, 0.00148894f, 0.00929704f, 
    -0.07728839f, -0.08936871f, -0.02955551f, -0.00044512f, 0.06572498f, 0.10994872f, 0.08173931f, -0.11881313f, 
    -0.01018425f, -0.05032476f, -0.01178035f, -0.00351260f, -0.02831223f, 0.07404374f, -0.13410993f, -0.10967783f, 
    -0.07572388f, 0.02882950f, -0.06633248f, -0.02795550f, -0.11776371f, -0.06320307f, -0.00053305f, -0.06772739f, 
    -0.04384853f, -0.03435734f, -0.10122912f, 0.06830876f, -0.05027528f, -0.04767768f, -0.05500217f, -0.05886811f, 
    -0.01152187f, 0.12776682f, -0.00222131f, 0.07379858f, 0.00915479f, -0.03543996f, 0.00309277f, -0.11883265f, 
    -0.05317792f, 0.06728771f, 0.02582119f, 0.04410378f, 0.06350733f, -0.03602242f, -0.06036191f, -0.11955746f, 
    -0.08206856f, 0.07910690f, 0.01947143f, -0.09718058f, -0.03017607f, 0.00831423f, -0.12726575f, -0.00526710f, 
    -0.04245275f, -0.04043028f, 0.09755442f, -0.03767224f, -0.12922016f, -0.00024872f, -0.09771454f, -0.05540693f, 
    0.02240450f, -0.06440831f, 0.07355803f, -0.06106594f, 0.07875898f, -0.01775615f, -0.01861002f, 0.03126749f, 
    -0.17702572f, -0.06114032f, -0.03817949f, 0.03166349f, 0.04101232f, -0.01048144f, -0.08072478f, -0.09417075f, 
    -0.10054247f, 0.13148141f, 0.18200564f, -0.08920068f, 0.07019521f, -0.10105380f, 0.09200429f, 0.19827604f, 
    -0.10062753f, 0.14246018f, 0.05081922f, 0.07497317f, -0.24584372f, -0.08556610f, -0.00146313f, 0.12655687f, 
    0.15911578f, 0.04824787f, 0.22181179f, 0.09802113f, 0.11795817f, -0.10387247f, 0.02030485f, 0.13194315f, 
    -0.07902861f, 0.00754802f, 0.24415994f, 0.02466927f, -0.00341645f, 0.00567820f, -0.04295830f, -0.07190350f, 
    0.25593224f, -0.02508490f, -0.09315307f, -0.16398785f, -0.03416499f, -0.08426663f, -0.26731700f, -0.09261668f, 
    -0.06661972f, -0.10885726f, -0.03756168f, -0.09145903f, 0.01165543f, -0.02292794f, 0.07513749f, 0.05159842f, 
    -0.02243611f, -0.04494574f, -0.07453792f, 0.20040029f, -0.55629784f, 0.08515266f, 0.02897176f, 0.08240884f, 
    -0.10875107f, 0.05872827f, 0.07740318f, 0.03997685f, 0.04706994f, 0.20435581f, 0.19095849f, -0.26138216f, 
    -0.19838390f, -0.02951385f, 0.16505544f, 0.05400832f, 0.08124376f, -0.05123716f, 0.12092820f, 0.28351244f, 
    -0.16020091f, 0.03079849f, 0.06563131f, -0.01673461f, -0.23124568f, 0.25167480f, 0.04927367f, 0.15899612f, 
    -0.06506617f, 0.12716606f, 0.42718151f, 0.10373980f, 0.02072359f, 0.06339373f, -0.11169516f, 0.15331295f, 
    -0.04193722f, 0.09744141f, 0.16590890f, 0.07175497f, 0.03668206f, -0.07553761f, 0.08355514f, 0.08675421f, 
    0.19808181f, 0.07410482f, -0.06246069f, -0.10840847f, 0.00374992f, 0.08901179f, -0.22844084f, 0.10534990f, 
    -0.38332742f, -0.30742866f, 0.11154261f, -0.01225124f, 0.02540099f, 0.26815215f, 0.17341025f, 0.03957217f, 
    0.02360999f, -0.02921731f, -0.05867463f, -0.14036019f, -0.24392474f, -0.05437540f, 0.06881274f, 0.09600616f, 
    -0.33259463f, 0.04238851f, -0.02555539f, 0.01437010f, 0.06823051f, 0.12494165f, 0.13580316f, 0.04975712f, 
    0.00660983f, 0.14193523f, 0.00984935f, 0.06066461f, 0.00868618f, 0.21039684f, -0.05554912f, -0.06685214f, 
    -0.12131775f, -0.13910945f, 0.28295848f, 0.00706872f, 0.10828321f, -0.07505952f, 0.08117330f, 0.05985887f, 
    -0.11723083f, -0.03058777f, 0.25896293f, 0.39175472f, 0.05091256f, -0.04286249f, -0.16846351f, 0.18368354f, 
    -0.04408855f, 0.04790663f, 0.19790618f, -0.11175321f, -0.08889489f, -0.11640038f, -0.06984637f, 0.04984158f, 
    0.08068737f, -0.05672600f, -0.10653111f, -0.09808184f, 0.03238494f, 0.07844937f, -0.02484769f, -0.03225847f, 
    0.07471458f, -0.20208566f, 0.06464680f, -0.01956568f, 0.20021601f, -0.21285082f, -0.01185358f, 0.07418557f, 
    -0.12193249f, -0.05903257f, 0.06962648f, 0.13444109f, -0.62219715f, -0.08573607f, 0.02418463f, -0.08001710f, 
    0.12268423f, -0.01197661f, 0.04529881f, 0.04759930f, 0.08356301f, 0.17247234f, 0.21099035f, 0.18197645f, 
    -0.04856875f, -0.05205749f, -0.06809871f, 0.12448367f, -0.04584311f, 0.05645538f, 0.09122599f, 0.10447772f, 
    0.00250467f, 0.14378478f, 0.24107482f, 0.09866429f, -0.16624902f, 0.22224431f, 0.10006944f, -0.19427906f, 
    -0.01221666f, -0.03897611f, -0.09069511f, -0.18756619f, 0.08639412f, 0.12602091f, -0.08083660f, -0.13164626f, 
    0.07985669f, -0.01837370f, 0.20354013f, -0.05440087f, -0.17434546f, 0.03956275f, -0.03906822f, -0.02565118f, 
    -0.03092309f, -0.03885872f, 0.24456725f, 0.07986093f, -0.05135792f, 0.11264291f, -0.01920969f, 0.06417006f, 
    0.33364058f, 0.30516088f, -0.01325232f, -0.04035359f, -0.07166498f, -0.10728151f, 0.28882810f, -0.06790031f, 
    -0.00820679f, -0.03073056f, 0.05420566f, 0.02288278f, 0.27265269f, 0.05484068f, 0.02013018f, 0.08441417f, 
    0.02526657f, 0.10395157f, 0.05951470f, 0.01772195f, -0.00079029f, 0.17812119f, -0.11721464f, 0.24076208f, 
    0.23627302f, -0.00908190f, -0.10978533f, -0.02894858f, 0.03883232f, -0.16319023f, -0.13347462f, -0.14033456f, 
    0.07788441f, 0.00098228f, 0.01610098f, -0.19752489f, 0.10262290f, -0.11828569f, -0.11515699f, 0.21266681f, 
    -0.03381193f, 0.04932193f, -0.13613291f, -0.02597349f, -0.02678072f, 0.06490105f, 0.41907212f, -0.02116803f, 
    -0.12398529f, 0.06325691f, 0.02632423f, 0.08515953f, 0.26701862f, -0.11875556f, 0.07838977f, 0.12914212f, 
    -0.20915414f, -0.00626380f, 0.13258398f, 0.18290004f, 0.07697199f, 0.07944673f, -0.02618979f, -0.10766581f, 
    0.04439830f, 0.26398399f, -0.28892991f, -0.00727177f, -0.28288287f, 0.14555837f, -0.03478239f, -0.06688321f, 
    -0.02238943f, -0.09777445f, 0.11483395f, -0.07136765f, 0.21392834f, 0.04147348f, 0.10785540f, -0.02390596f, 
    -0.06170138f, -0.17698422f, 0.05290380f, -0.01281364f, 0.10571882f, 0.30194539f, 0.13247056f, -0.39004421f, 
    -0.01640593f, 0.12279134f, 0.02204913f, 0.11572339f, -0.11604185f, 0.30457589f, -0.32099289f, -0.07684325f, 
    0.03477206f, 0.05169467f, 0.12340304f, 0.17871274f, 0.16614093f, 0.01812967f, 0.09206255f, 0.07003593f, 
    -0.02642010f, -0.03654195f, 0.17189606f, 0.16769560f, 0.04935757f, -0.01097756f, -0.04726603f, 0.09518600f, 
    0.11818218f, -0.06679447f, -0.14300814f, -0.01069514f, -0.05468783f, -0.03048322f, -0.00830889f, 0.22852278f, 
    0.10783441f, -0.06607678f, -0.06646702f, -0.08758403f, -0.07777538f, -0.19879529f, 0.02043699f, 0.06294374f, 
    0.15999985f, -0.09664111f, 0.13470550f, 0.04319171f, -0.00353661f, -0.22377682f, 0.12215770f, 0.00394058f, 
    -0.05466953f, 0.00701042f, 0.07866564f, 0.18188424f, -0.56051499f, -0.06344903f, 0.01319501f, 0.18426466f, 
    0.13257822f, -0.13308762f, 0.09597272f, -0.05083780f, -0.11977898f, -0.13801165f, 0.17233697f, 0.19877809f, 
    -0.02158874f, -0.14687920f, 0.05498580f, -0.02415961f, -0.10306865f, -0.14417520f, 0.24991068f, 0.17325515f, 
    -0.20935476f, 0.11938434f, -0.15548521f, -0.00644260f, 0.07103454f, 0.19939524f, -0.04967098f, -0.06013320f, 
    -0.18789688f, -0.11648257f, -0.17669016f, -0.03178095f, -0.07806138f, 0.20953886f, -0.14332147f, 0.04847343f, 
    0.10584183f, 0.05945903f, 0.00041433f, 0.00710714f, 0.00267137f, 0.08113603f, 0.02805984f, -0.21080112f, 
    -0.00757107f, 0.07806723f, -0.07415650f, 0.14525799f, 0.08665432f, 0.00674844f, 0.31304133f, 0.01808549f, 
    -0.22358115f, -0.14515170f, -0.12050039f, 0.14730063f, 0.05789094f, -0.05634910f, 0.16627283f, -0.10819775f, 
    -0.00710827f, 0.03714222f, 0.00972681f, -0.11103428f, 0.54539615f, 0.10449518f, 0.01813699f, 0.10865590f, 
    0.08246472f, -0.02291697f, 0.08926210f, 0.10759853f, 0.08439063f, -0.14663120f, -0.11983275f, -0.36045575f, 
    -0.25298616f, -0.03624830f, 0.36461440f, 0.08441387f, -0.01390396f, 0.24989529f, 0.01686234f, -0.00963899f, 
    0.03386160f, 0.22769496f, -0.00422334f, 0.09908197f, 0.12468982f, -0.18173543f, 0.04138659f, 0.16697085f, 
    0.06237317f, 0.01536150f, -0.05363325f, -0.13585296f, -0.19625881f, 0.13858010f, 0.27456605f, 0.25522205f, 
    0.11002872f, -0.02357996f, -0.34202135f, -0.05659888f, 0.21924865f, 0.00709391f, 0.11554013f, 0.17255890f, 
    -0.32441142f, 0.01388586f, -0.20755838f, -0.23188718f, -0.00456612f, -0.11525172f, -0.19407187f, 0.01509666f, 
    -0.17332844f, 0.01660191f, 0.09365510f, 0.10362771f, 0.14475921f, 0.11308127f, 0.22845683f, 0.06925742f, 
    0.09650671f, -0.12858188f, -0.05536874f, 0.09641540f, -0.02072412f, 0.09716912f, -0.07436767f, 0.34867188f, 
    -0.27141389f, -0.01726971f, 0.02726470f, -0.00166731f, -0.09534935f, 0.01921214f, -0.05600043f, -0.13007838f, 
    0.02958972f, -0.04456232f, -0.00463079f, 0.02297658f, 0.01418642f, 0.21697831f, -0.08607406f, -0.11940167f, 
    0.19399932f, -0.18081732f, 0.02766810f, 0.09565166f, 0.31330326f, -0.16179228f, 0.09295157f, 0.03187110f, 
    -0.06122668f, 0.08864231f, -0.01564275f, 0.27411839f, -0.17712712f, -0.02048608f, 0.23709017f, 0.11741302f, 
    -0.05196536f, 0.04885979f, -0.09716826f, 0.08942782f, 0.22806922f, -0.05714293f, -0.04017253f, 0.22797376f, 
    -0.26559058f, -0.03970644f, -0.18225943f, -0.08610546f, -0.03537961f, 0.18904205f, 0.19735004f, 0.00220419f, 
    0.02553754f, -0.06143311f, 0.04466784f, 0.14756241f, 0.18911366f, -0.10441831f, -0.05690785f, -0.07427225f, 
    -0.05187827f, -0.12294789f, 0.10037526f, -0.00713197f, 0.05968219f, -0.00480677f, -0.04589347f, -0.16999748f, 
    -0.07078627f, -0.13693215f, 0.06165523f, 0.11065084f, 0.10716243f, -0.12679932f, -0.05515375f, -0.09344614f, 
    0.04379123f, -0.09975509f, -0.08406638f, 0.02872161f, 0.08119377f, 0.03717573f, -0.02400604f, -0.10255057f, 
    0.09686420f, -0.12294524f, 0.05189230f, 0.02007116f, -0.10945305f, 0.03374946f, 0.05891893f, -0.03831996f, 
    -0.02002823f, 0.03029967f, -0.11810800f, 0.08281289f, 0.07833055f, 0.08330512f, -0.12641197f, 0.03992069f, 
    -0.00717589f, -0.06010245f, 0.01741584f, 0.01194009f, 0.07186837f, -0.09542812f, 0.01005073f, -0.01148952f, 
    -0.03526475f, -0.05871012f, 0.03513495f, 0.02469675f, -0.03340656f, -0.10408049f, 0.05094641f, 0.01865592f, 
    -0.02205993f, 0.08668462f, -0.03813341f, -0.11708529f, -0.00509061f, -0.01753724f, -0.02030967f, 0.04367904f, 
    -0.02765120f, 0.08044375f, 0.11194015f, -0.01980834f, -0.01679962f, -0.09533142f, -0.01348126f, -0.13667792f, 
    -0.01241225f, 0.22882141f, 0.00030336f, 0.10033777f, -0.04944121f, 0.16144863f, 0.26664731f, -0.06553560f, 
    0.01826913f, -0.22280547f, -0.11750867f, 0.07887174f, -0.05719441f, 0.43889162f, 0.10925424f, -0.21640341f, 
    0.17473952f, 0.01891322f, -0.02603580f, -0.04263771f, 0.10962343f, -0.10965924f, -0.07344396f, 0.17895243f, 
    0.01749271f, -0.07152159f, 0.01715632f, 0.00274183f, 0.00087499f, 0.06504429f, -0.04493610f, 0.13722678f, 
    0.01581050f, 0.04311506f, -0.15696320f, 0.07715568f, 0.09416492f, -0.00733694f, -0.06172720f, 0.35051546f, 
    -0.24899575f, 0.12040829f, -0.07041725f, -0.07401732f, 0.00748808f, -0.03145437f, 0.03772810f, -0.03754024f, 
    0.01938530f, 0.14227520f, -0.21318166f, -0.02009714f, -0.32217053f, -0.09467240f, -0.00254801f, -0.03058830f, 
    0.11981335f, 0.02057292f, 0.05876543f, -0.14073901f, 0.35010546f, -0.05219926f, 0.07679112f, 0.03006779f, 
    0.03718332f, -0.28885663f, 0.01261842f, -0.04044309f, -0.07798501f, -0.20506965f, -0.15921707f, 0.12069147f, 
    -0.04571937f, 0.20178030f, 0.08908776f, -0.05809608f, -0.08149680f, 0.10045669f, -0.04822098f, 0.10369203f, 
    0.15244153f, 0.22251870f, 0.09172274f, 0.17097889f, 0.21206801f, 0.16203675f, 0.03240194f, -0.07224806f, 
    0.18268187f, -0.09959456f, -0.23343527f, -0.17188329f, -0.00240454f, 0.13084856f, -0.09001898f, 0.00018791f, 
    0.03154587f, -0.09800737f, -0.15066418f, 0.01695281f, -0.05022125f, -0.03033600f, 0.10392904f, -0.01485855f, 
    -0.12831645f, -0.10848751f, 0.17887717f, -0.08213132f, -0.12231560f, -0.11587096f, 0.29635394f, -0.10406885f, 
    0.33352965f, 0.29545909f, 0.30104321f, 0.25569382f, 0.36676592f, -0.08563116f, -0.00763965f, 0.08247900f, 
    0.10846114f, 0.09009891f, 0.10883588f, 0.23965997f, -0.14919294f, 0.01574834f, -0.05884634f, 0.09332594f, 
    -0.11952095f, -0.06500784f, -0.09736646f, 0.04424326f, -0.02587456f, -0.03723389f, -0.18178821f, -0.12658857f, 
    0.06034107f, 0.13017040f, 0.02904398f, 0.06928181f, -0.00905268f, -0.26379052f, -0.07952877f, 0.12541033f, 
    0.07356054f, 0.03745580f, 0.12055649f, 0.12441748f, 0.00779667f, 0.06950231f, -0.07634360f, -0.07952494f, 
    -0.01995443f, -0.01597461f, 0.15073256f, 0.18127196f, 0.10141442f, 0.04234109f, 0.07780300f, -0.09872539f, 
    0.08102962f, 0.10933904f, 0.28913695f, -0.12821911f, -0.11216274f, 0.02138855f, -0.01121466f, -0.07190033f, 
    0.36448294f, -0.03056552f, 0.08487498f, 0.18534139f, -0.21316522f, 0.07824001f, -0.06278851f, 0.08613290f, 
    0.15616322f, -0.20187956f, 0.27318195f, 0.27547219f, 0.06173862f, -0.13744900f, 0.00578399f, -0.05089321f, 
    -0.02829605f, 0.13785167f, 0.12241217f, 0.29129595f, -0.14929482f, -0.09102256f, 0.07398606f, 0.11199412f, 
    -0.13551810f, 0.09228998f, -0.05990006f, -0.02176026f, -0.08954363f, -0.07617638f, 0.06536801f, 0.22299144f, 
    0.05578006f, -0.08898392f, 0.08819861f, 0.08989834f, -0.08918794f, -0.22192299f, 0.09443463f, -0.09650813f, 
    0.22630201f, -0.00939565f, 0.11417691f, -0.27511281f, 0.12338560f, 0.20813730f, 0.09115652f, 0.14389658f, 
    -0.03233244f, 0.11026803f, 0.06635549f, 0.34626529f, -0.25377545f, -0.03658630f, 0.58183217f, -0.02391188f, 
    0.01010949f, -0.07367582f, 0.31978455f, -0.01248308f, 0.23034072f, 0.01537084f, -0.06501560f, -0.11550973f, 
    -0.30325666f, -0.11373018f, -0.03251705f, 0.10662506f, -0.02225512f, 0.19055808f, 0.01960560f, 0.09519204f, 
    0.13545229f, -0.05506038f, -0.14826687f, 0.11711383f, -0.03917561f, -0.04845308f, -0.07908237f, -0.07558029f, 
    -0.02435138f, -0.02518682f, -0.06318451f, 0.12772071f, 0.39541072f, -0.08384635f, -0.01943435f, -0.26854187f, 
    0.19258185f, 0.18116857f, 0.09974870f, -0.09639199f, -0.06675056f, 0.07548098f, 0.26984257f, 0.05345307f, 
    0.11676403f, 0.10210161f, -0.08748652f, -0.07052948f, -0.13789503f, 0.24701445f, -0.02749183f, -0.11073031f, 
    -0.09832197f, 0.03443824f, 0.07910197f, 0.00374567f, 0.18054530f, -0.13744915f, -0.06952419f, 0.12467984f, 
    -0.08796647f, 0.04969651f, 0.19413604f, 0.00595611f, 0.41829631f, -0.15852177f, -0.35956454f, 0.24338117f, 
    -0.05923220f, -0.04476021f, -0.11319525f, -0.02733813f, 0.02692815f, 0.09192707f, 0.07619204f, 0.13287240f, 
    0.25151592f, 0.05167775f, 0.03870972f, 0.20891951f, 0.23438852f, -0.01520383f, 0.12702027f, 0.12583411f, 
    -0.10632935f, 0.04463056f, -0.10162784f, -0.21520074f, -0.09045559f, 0.11620576f, -0.04045866f, -0.08233961f, 
    -0.02563284f, -0.09778614f, 0.05757968f, 0.02455935f, -0.12057959f, 0.04116930f, 0.10370497f, -0.15404828f, 
    0.01643649f, -0.01140269f, 0.03423049f, 0.10263216f, 0.03173839f, -0.18598737f, 0.03308053f, 0.14678144f, 
    0.01857676f, 0.06583761f, -0.00286316f, 0.06233747f, -0.11773106f, 0.28331494f, 0.27385232f, 0.00311413f, 
    -0.24108283f, -0.08617081f, -0.17014851f, 0.15700932f, 0.10986301f, 0.21232152f, -0.09996935f, 0.00168235f, 
    0.03526727f, -0.11451484f, -0.01144198f, 0.15359284f, 0.10757626f, -0.09935020f, -0.42809677f, 0.09949304f, 
    -0.08082944f, -0.07683198f, -0.24276192f, -0.08260668f, 0.10284910f, -0.06759006f, 0.06622368f, -0.08299265f, 
    0.09822406f, 0.02164898f, -0.12333003f, -0.00354965f, 0.28371143f, 0.11578634f, 0.20517196f, -0.08675941f, 
    -0.19868588f, 0.12842438f, 0.03006209f, 0.16095889f, 0.29494020f, 0.02370704f, -0.01661111f, -0.04157139f, 
    0.11998065f, 0.00548071f, 0.11986789f, -0.13310400f, -0.08433469f, 0.00311637f, -0.08632667f, -0.13045482f, 
    0.14372741f, 0.21041748f, -0.04046936f, 0.10678896f, -0.08353034f, -0.46184373f, -0.17756413f, -0.14106950f, 
    -0.14132226f, 0.03732847f, 0.23199533f, 0.06351403f, -0.07646357f, -0.16750875f, -0.04073421f, 0.06960014f, 
    0.04663920f, 0.07171533f, -0.11488257f, 0.17987531f, 0.09439886f, -0.15422153f, -0.01314044f, 0.17602299f, 
    0.12888993f, 0.08220606f, -0.18366672f, -0.22318217f, -0.20695601f, 0.22589390f, 0.30403793f, 0.24200121f, 
    -0.10827243f, -0.00115315f, -0.11804090f, 0.05708455f, 0.27987099f, -0.05792558f, -0.03145687f, -0.01997300f, 
    -0.20247507f, 0.06475136f, -0.47267637f, -0.22784950f, 0.09314883f, 0.21315292f, -0.13312215f, -0.06800693f, 
    -0.10478685f, -0.45215973f, -0.06373403f, 0.30958548f, 0.08523449f, 0.11042893f, 0.09631161f, 0.00822444f, 
    0.01286242f, 0.08571514f, -0.08586486f, -0.07776563f, -0.14688078f, 0.05929758f, 0.09183487f, 0.00133876f, 
    0.05351956f, -0.11004250f, 0.09545420f, -0.09676920f, 0.12492326f, -0.09177514f, -0.08568294f, -0.06061484f, 
    0.12167477f, -0.09533139f, 0.03483493f, 0.06207198f, -0.11794418f, -0.11753073f, -0.09940930f, -0.01300003f, 
    -0.09390263f, 0.03602337f, -0.05665246f, -0.02019355f, -0.10514499f, 0.00903086f, 0.09277348f, -0.10616791f, 
    -0.01905923f, -0.06278816f, 0.00060773f, -0.06855209f, -0.06378238f, 0.10225288f, 0.02271445f, 0.12640394f, 
    -0.08684878f, 0.02370530f, -0.07028550f, -0.05295544f, 0.06985817f, 0.03243767f, 0.05026709f, 0.10220589f, 
    0.10888791f, 0.10206243f, 0.01229296f, 0.09731871f, -0.03282377f, -0.10450680f, 0.07453112f, -0.08338016f, 
    0.08829574f, -0.07332183f, -0.05536305f, -0.07280309f, 0.08199635f, -0.03161577f, -0.03921327f, 0.11320068f, 
    -0.01729986f, -0.03969108f, 0.05188908f, 0.03080189f, -0.08501632f, 0.00327927f, 0.06946863f, -0.04925783f, 
    0.06616528f, -0.10610715f, 0.05456007f, 0.01786655f, 0.09110538f, -0.07457835f, 0.10019565f, 0.10395857f, 
    0.04811566f, -0.12995829f, -0.04187511f, 0.05625533f, 0.06771392f, -0.01453329f, -0.04446952f, -0.10115505f, 
    -0.08402026f, -0.04273538f, 0.10085338f, -0.10761575f, 0.08923074f, -0.06992044f, -0.02730468f, -0.00520791f, 
    -0.02279670f, 0.01875380f, -0.09821402f, 0.08592033f, -0.06818908f, 0.10225597f, -0.00336362f, 0.05744432f, 
    -0.00796647f, -0.11233997f, 0.09768822f, 0.01976574f, -0.02871484f, 0.10846221f, -0.11087926f, -0.09665886f, 
    -0.12607644f, -0.10257094f, -0.06682254f, 0.00238789f, 0.08152111f, -0.10660510f, -0.14277920f, 0.11292453f, 
    -0.03090885f, 0.00903423f, 0.07580876f, 0.10041577f, -0.02138956f, -0.12923092f, -0.05416999f, 0.10793349f, 
    0.03153637f, -0.02629773f, -0.01706350f, -0.09885488f, 0.02044846f, -0.09675615f, -0.02445315f, 0.09790257f, 
    -0.02502036f, 0.07129547f, -0.03064531f, 0.11268884f, 0.01612850f, 0.00538733f, -0.09403830f, -0.09002235f, 
    -0.13751934f, -0.09272577f, -0.12081780f, 0.05709888f, 0.02823296f, -0.12639840f, 0.10631980f, 0.05639070f, 
    -0.06255699f, 0.02670678f, -0.07270777f, -0.09058831f, -0.06840181f, -0.07236441f, 0.01596704f, 0.10865107f, 
    -0.09247946f, -0.05001548f, -0.04186959f, 0.04953792f, -0.13116916f, 0.07227850f, 0.00169304f, -0.10476673f, 
    0.00919342f, 0.08209664f, -0.11883822f, -0.10253809f, 0.00034414f, 0.09141624f, -0.05001070f, 0.08698308f, 
    -0.08167443f, -0.03581680f, -0.12065003f, -0.00729705f, 0.01370507f, -0.04697156f, -0.12318600f, 0.04672913f, 
    -0.00727908f, -0.00468000f, -0.03708535f, 0.07490144f, -0.08256996f, -0.05367001f, -0.10734747f, -0.10547838f, 
    -0.01426990f, 0.08890368f, 0.03477579f, -0.12274781f, -0.03689788f, 0.00475852f, 0.08520758f, -0.13463049f, 
    -0.22901340f, -0.09399395f, -0.09902030f, -0.01010850f, -0.08276895f, 0.04808017f, 0.08476825f, -0.11832105f, 
    -0.27279654f, -0.06023192f, 0.00898851f, -0.11960698f, -0.00432439f, 0.06500326f, 0.15489724f, 0.03060868f, 
    0.08897005f, 0.04637234f, 0.23930153f, -0.03390840f, -0.14077242f, -0.00110443f, 0.10781807f, -0.05824067f, 
    -0.16007505f, 0.03176613f, -0.15456818f, -0.24942540f, -0.23494445f, -0.01682166f, 0.25353742f, 0.17514953f, 
    -0.01754363f, -0.09176088f, 0.28114101f, 0.03014100f, -0.12375958f, -0.04624541f, 0.05279973f, 0.26883098f, 
    0.20119259f, 0.00801453f, 0.04322419f, -0.23757413f, 0.06122674f, 0.24443294f, 0.02438832f, 0.05054355f, 
    0.19779211f, -0.06306316f, -0.28340542f, 0.00492036f, -0.04458312f, 0.09841411f, -0.14425501f, 0.08270788f, 
    -0.12710138f, -0.07868413f, -0.03347021f, 0.09810209f, -0.29803649f, -0.08106026f, 0.09652787f, 0.33760378f, 
    0.29727495f, -0.00929361f, 0.01626229f, 0.05731557f, 0.10149860f, 0.09985992f, -0.32047155f, 0.04978598f, 
    0.20114036f, 0.08110613f, 0.01653655f, 0.06235256f, -0.06392881f, -0.14002097f, -0.21823449f, -0.03709039f, 
    0.16135113f, 0.09682199f, -0.12912357f, 0.18669027f, -0.00071110f, -0.31068885f, -0.05403005f, 0.01839565f, 
    0.05339513f, -0.06356912f, -0.19441232f, -0.25952587f, 0.18354294f, 0.06995915f, 0.13186945f, 0.13414322f, 
    0.03751184f, -0.02045293f, 0.08671147f, -0.08998610f, 0.02761285f, -0.04982915f, 0.05076037f, 0.09515594f, 
    0.20034203f, 0.09662102f, 0.20722045f, 0.23651278f, -0.23340361f, -0.12039854f, -0.06649002f, 0.02403964f, 
    0.18205921f, -0.11037873f, 0.10537033f, -0.03349867f, -0.05638991f, 0.18586449f, 0.06655416f, 0.07594812f, 
    0.11608668f, 0.11197314f, 0.01555543f, 0.16652437f, 0.08328094f, -0.05697232f, -0.13336769f, -0.05954074f, 
    0.15475644f, -0.04588692f, -0.08022106f, 0.08804546f, -0.05309391f, -0.06450734f, -0.03905023f, 0.01036498f, 
    0.17303512f, 0.19414210f, 0.15517808f, 0.04783668f, -0.09975577f, 0.27833608f, -0.05138969f, -0.14811516f, 
    -0.17414957f, 0.06012877f, 0.07889264f, 0.12328512f, 0.30508068f, -0.22110270f, -0.02815528f, 0.20822635f, 
    0.09509022f, -0.11262573f, -0.12785351f, -0.16466978f, 0.07158488f, -0.16197975f, -0.39615321f, 0.23799172f, 
    -0.10590570f, 0.10604502f, -0.24950069f, -0.02093273f, -0.04932928f, -0.03306468f, -0.00705090f, 0.21625520f, 
    0.24343070f, 0.13041057f, 0.22938876f, 0.09086519f, 0.17006864f, 0.12685801f, 0.25886673f, -0.04615024f, 
    0.10067068f, 0.06035487f, -0.08470602f, 0.11722278f, 0.07449140f, 0.08871009f, -0.28248298f, -0.10833309f, 
    -0.02255765f, 0.09163388f, -0.05516143f, 0.22875686f, -0.37641135f, 0.05165941f, -0.05440572f, -0.09072417f, 
    0.05004239f, -0.02605711f, 0.01828051f, 0.09138536f, 0.08854888f, -0.12301752f, 0.11950935f, -0.08375371f, 
    0.07203788f, -0.10566345f, 0.06182840f, 0.00873794f, -0.04070037f, 0.11245640f, -0.11651046f, 0.04154190f, 
    -0.04637814f, 0.08495600f, -0.00916953f, 0.00123844f, 0.05036150f, -0.05047539f, -0.01698579f, -0.11879706f, 
    0.07266417f, -0.02571412f, -0.03326800f, -0.11746763f, 0.01589284f, -0.07343096f, -0.08702247f, -0.00166747f, 
    0.10981461f, 0.08778644f, -0.01868265f, 0.10417289f, -0.01626727f, 0.04805386f, 0.02049698f, -0.07511175f, 
    0.07170325f, -0.04741441f, -0.10113578f, -0.10208727f, -0.11235136f, -0.08326591f, -0.05608122f, -0.07812136f, 
    0.04130742f, 0.06403257f, 0.07131626f, 0.05875552f, -0.07697409f, -0.10724344f, 0.04403891f, -0.11591558f, 
    -0.04012893f, -0.12074600f, -0.01162368f, -0.08400389f, 0.08047801f, -0.00634967f, 0.05590416f, -0.10062297f, 
    0.13283299f, -0.18689235f, -0.04895410f, -0.11038574f, 0.04980099f, -0.00860690f, -0.03904409f, 0.01690390f, 
    0.03607073f, 0.19282018f, -0.11282897f, 0.09884669f, -0.08660373f, 0.02830423f, -0.05543127f, -0.05220814f, 
    0.18686371f, 0.18681274f, -0.14374018f, 0.14310308f, -0.18087883f, -0.19280954f, 0.00827798f, -0.05377283f, 
    0.18704098f, 0.07204405f, -0.16161443f, -0.20942657f, 0.11706812f, -0.01711199f, 0.02112594f, -0.17256872f, 
    -0.06397357f, 0.03118898f, 0.22768290f, 0.01817704f, -0.06295266f, -0.09867112f, 0.06834932f, 0.16781193f, 
    -0.02742379f, -0.04105132f, 0.18295184f, 0.04572417f, 0.31519595f, 0.01865454f, 0.14606306f, 0.00815348f, 
    0.33041880f, 0.24664287f, -0.33734125f, 0.16853255f, -0.06448808f, 0.09856661f, 0.12174098f, 0.03130278f, 
    0.02370779f, 0.12610915f, -0.03863536f, 0.07239130f, 0.11849363f, 0.05315465f, 0.01720062f, -0.01187005f, 
    -0.02708013f, -0.09072900f, 0.05568099f, 0.03571847f, 0.06213561f, -0.10401146f, -0.01653104f, -0.12085342f, 
    -0.01826020f, 0.07406965f, -0.02076491f, -0.01117688f, 0.11411361f, -0.08935000f, -0.03111716f, 0.04162992f, 
    -0.13277155f, 0.11569626f, -0.08728404f, 0.09262312f, -0.02677078f, -0.09304576f, -0.05262841f, 0.08549965f, 
    -0.06765022f, -0.02712780f, -0.06729124f, -0.00396358f, -0.10420318f, -0.12176532f, -0.00694854f, 0.05981556f, 
    -0.04108152f, -0.08728181f, -0.12028357f, 0.11031988f, 0.08264720f, 0.03462942f, 0.01959503f, 0.05041664f, 
    0.00061861f, 0.01368925f, -0.03690998f, 0.11103813f, -0.09150536f, 0.10483598f, 0.11378154f, 0.02186552f, 
    -0.12709075f, -0.09765103f, -0.11758724f, -0.09827842f, -0.10749992f, -0.08473731f, 0.11319500f, 0.08154911f, 
    0.07569097f, -0.13068883f, 0.11117718f, -0.00332768f, 0.02755378f, 0.11906058f, 0.05006072f, 0.11437744f, 
    0.13866131f, 0.17133065f, 0.08634073f, -0.09303802f, -0.09774901f, 0.08641514f, 0.18728817f, 0.23014031f, 
    0.20783763f, 0.05430234f, -0.17304315f, -0.06512904f, -0.13081753f, 0.07354540f, -0.19200319f, 0.12518552f, 
    -0.12790076f, 0.13521948f, 0.13387883f, 0.01445845f, 0.18375574f, -0.14844094f, 0.04889762f, -0.10305659f, 
    0.11678704f, 0.04645847f, 0.00728029f, -0.02100622f, 0.33410549f, 0.16609085f, -0.15966265f, -0.04763633f, 
    -0.00468076f, 0.04745414f, 0.21449132f, -0.03958353f, -0.00918146f, -0.04514831f, 0.00243065f, -0.17659871f, 
    0.09582743f, 0.10974892f, 0.09622335f, 0.30791566f, -0.13878633f, 0.14068095f, -0.02526762f, 0.07911627f, 
    0.27044618f, -0.26658657f, 0.23101537f, 0.06488843f, -0.10795677f, -0.28811565f, -0.04101323f, -0.02066377f, 
    -0.11723354f, -0.06229523f, 0.00398219f, 0.23932646f, 0.11519599f, -0.12308362f, -0.07637672f, -0.12608656f, 
    -0.21302302f, -0.21112774f, -0.11311824f, -0.10731685f, -0.07553736f, 0.10512210f, -0.11532799f, 0.19134876f, 
    -0.23669636f, -0.30853885f, 0.06715187f, -0.02369188f, -0.07044560f, -0.16543974f, 0.10179071f, -0.09962692f, 
    -0.01640687f, -0.18213838f, 0.03549936f, 0.28132296f, 0.26163214f, 0.28816688f, 0.02400281f, 0.01529956f, 
    -0.27077836f, 0.03279017f, -0.13259022f, 0.01275200f, 0.06319557f, 0.13259438f, 0.00619604f, 0.00138390f, 
    0.09841575f, 0.04581886f, -0.11202157f, 0.09368908f, -0.27773836f, -0.08118963f, -0.09526405f, -0.08149926f, 
    0.35657287f, 0.11208365f, 0.15417230f, 0.12887473f, 0.12404001f, 0.12960663f, 0.36096424f, 0.12814412f, 
    -0.17479593f, 0.15267026f, 0.02009176f, 0.19992435f, 0.31055889f, 0.13417922f, -0.25244352f, 0.10823786f, 
    -0.07526651f, -0.06746828f, -0.10006459f, 0.08857910f, -0.04147518f, -0.04507669f, 0.05385215f, 0.11725352f, 
    0.25301409f, 0.09854485f, 0.10701698f, -0.09888008f, -0.12710084f, 0.04751108f, 0.20086014f, 0.43605018f, 
    0.29430893f, -0.06473467f, -0.07787960f, -0.04982027f, 0.05431459f, -0.11257784f, 0.31163132f, 0.03622429f, 
    -0.22160785f, 0.06719193f, 0.04751054f, -0.07423653f, 0.14922275f, 0.05997540f, -0.03683054f, 0.07063150f, 
    0.13114262f, -0.08739703f, -0.14097668f, 0.00570382f, 0.04135240f, 0.09708098f, -0.27618697f, 0.02138785f, 
    -0.09499116f, -0.08788703f, -0.01457367f, 0.04113933f, 0.06641481f, -0.10798351f, 0.01580969f, -0.01176510f, 
    0.07058805f, 0.04825189f, 0.00284264f, 0.20391087f, 0.15556842f, 0.23069333f, 0.07514732f, 0.02364007f, 
    -0.12762465f, 0.09478356f, -0.12647326f, 0.10940777f, 0.08521342f, 0.19039112f, -0.16647239f, -0.02983765f, 
    -0.03987772f, 0.01024473f, -0.03590274f, -0.18757576f, 0.15520826f, -0.05194154f, 0.06621191f, -0.20280126f, 
    0.04681415f, 0.21114253f, 0.11779897f, -0.11848222f, 0.12008695f, -0.25595102f, -0.17871548f, -0.12715833f, 
    0.07468615f, -0.06722309f, 0.12787160f, 0.03685227f, -0.08536705f, -0.19351794f, -0.03741351f, -0.16650619f, 
    -0.08627445f, 0.10224901f, -0.11047435f, -0.18576138f, -0.20292270f, -0.24198781f, -0.04676292f, 0.23832242f, 
    0.14981675f, 0.07313467f, -0.11069269f, -0.18998860f, -0.01878608f, 0.20074436f, 0.29508686f, 0.30308175f, 
    -0.07407567f, 0.03051326f, 0.21703386f, 0.11571813f, 0.30446503f, 0.01648647f, -0.11777347f, 0.11393166f, 
    -0.18162383f, -0.09825248f, -0.31717876f, 0.06923050f, -0.00487260f, 0.26798752f, -0.18555811f, 0.01009319f, 
    0.05347810f, -0.29281929f, -0.20472893f, 0.08415456f, -0.06586931f, 0.18452647f, -0.18952887f, 0.07944295f, 
    0.11307961f, -0.08412457f, -0.04869011f, 0.12193478f, 0.16111414f, -0.00816201f, -0.08524458f, -0.10548203f, 
    -0.01602461f, -0.06489120f, 0.11065309f, -0.02018135f, 0.03079339f, 0.13371111f, 0.02036738f, 0.03847452f, 
    -0.12470875f, -0.02676694f, 0.15596375f, -0.09471499f, -0.03462359f, -0.13838038f, -0.01840550f, 0.02577949f, 
    0.29250735f, -0.00517166f, 0.18594739f, 0.34006643f, 0.19888854f, 0.20173934f, -0.02166410f, -0.09656523f, 
    0.14419511f, -0.11432878f, -0.04897884f, -0.00856080f, -0.14457351f, 0.19274984f, 0.35159475f, -0.24115561f, 
    0.10507411f, 0.09251449f, -0.04992441f, 0.06354928f, 0.09992848f, -0.12779039f, -0.05914833f, -0.14696796f, 
    -0.09646957f, 0.04624038f, 0.02592609f, -0.08561920f, -0.21859320f, -0.07690427f, 0.10994621f, 0.02416078f, 
    0.26560956f, 0.04130595f, 0.35057470f, 0.27801648f, 0.12348968f, -0.12572384f, 0.22383268f, 0.13125308f, 
    -0.11041301f, 0.10439277f, 0.08585428f, 0.21236980f, 0.34984079f, -0.00250788f, 0.01098712f, 0.25655153f, 
    0.20311487f, -0.18898934f, 0.05490249f, -0.01689155f, -0.07943673f, -0.11647088f, 0.00149833f, 0.38434780f, 
    0.09172299f, 0.07879727f, 0.13407981f, -0.00798661f, -0.07429736f, 0.07040755f, 0.02297551f, 0.04157313f, 
    -0.02318384f, 0.10926208f, -0.09888948f, -0.06578389f, 0.09791084f, -0.02310545f, -0.01445240f, 0.08643916f, 
    0.22227879f, 0.00869807f, -0.15557925f, -0.16593334f, -0.03981613f, 0.17720737f, 0.10024645f, -0.14817925f, 
    0.11254577f, 0.06367464f, -0.13885345f, -0.01556928f, 0.05578042f, -0.00698253f, 0.04693455f, -0.11624028f, 
    -0.36511299f, 0.02417637f, 0.01044678f, 0.10459997f, -0.11465738f, 0.07228572f, 0.29085666f, -0.10177114f, 
    0.21144772f, 0.12183202f, 0.10593157f, 0.21597202f, 0.09836484f, 0.09177381f, 0.02942641f, -0.06031157f, 
    0.05608005f, 0.07715133f, -0.01136562f, -0.13448340f, 0.52318066f, 0.07242063f, -0.07926476f, -0.03619344f, 
    0.18196197f, 0.25412744f, -0.10053897f, -0.11585884f, -0.10388391f, 0.07742235f, 0.08834045f, 0.25484389f, 
    0.04838980f, -0.18816425f, -0.12846883f, -0.09481400f, -0.12467691f, 0.01427693f, 0.16045099f, -0.02162521f, 
    -0.02106353f, 0.12637517f, 0.25499985f, -0.20370620f, -0.07221232f, -0.02872288f, -0.11564112f, -0.10911180f, 
    -0.01750824f, -0.03492782f, -0.11035546f, 0.07317834f, 0.04534655f, 0.06819504f, 0.29281041f, 0.05951916f, 
    -0.05461255f, -0.07311943f, 0.19693436f, -0.01896486f, 0.02502324f, 0.05040277f, -0.02891477f, 0.17504886f, 
    -0.31862581f, -0.07706933f, 0.20021833f, 0.19917551f, -0.16273509f, 0.12995753f, -0.11290791f, -0.06572785f, 
    0.23959392f, 0.19744843f, 0.05879662f, -0.14892182f, -0.31953737f, -0.15682867f, 0.10701142f, 0.12028465f, 
    -0.07439123f, 0.06429861f, -0.04989107f, -0.02819609f, 0.43078396f, -0.00004162f, 0.03876306f, -0.23772185f, 
    0.37805304f, 0.24705973f, 0.05869445f, -0.01758377f, 0.02893043f, 0.13413179f, 0.27839798f, 0.12108050f, 
    0.26238096f, 0.11438842f, 0.16899027f, 0.08166345f, 0.02789096f, -0.03405947f, 0.15049432f, -0.08105855f, 
    -0.22945738f, 0.08578619f, 0.03291167f, -0.15666416f, -0.00569028f, -0.15131965f, 0.02130969f, 0.23073894f, 
    0.21356867f, -0.12543662f, 0.24680980f, 0.05551263f, 0.33967215f, 0.01051133f, -0.33156511f, 0.21521313f, 
    -0.07159662f, -0.11554512f, -0.10196520f, 0.05462851f, 0.04628850f, 0.08175209f, 0.00600072f, 0.02231462f, 
    0.18598011f, 0.11998241f, -0.02417951f, 0.20935498f, -0.09625806f, 0.08276686f, -0.14630090f, -0.10629166f, 
    -0.15597962f, -0.04095861f, 0.10677005f, -0.26136619f, -0.26100928f, 0.14222199f, 0.02732281f, -0.03857646f, 
    -0.09545241f, 0.05738097f, -0.04096320f, -0.17382246f, 0.07042491f, -0.02311038f, 0.04294877f, -0.19751053f, 
    0.01323258f, 0.07045885f, 0.08413604f, 0.02581252f, 0.01707653f, 0.02703111f, 0.00011053f, 0.04442185f, 
    0.03170449f, -0.11852451f, 0.09844933f, -0.08326480f, -0.10281212f, -0.03459656f, -0.12595095f, 0.04880486f, 
    -0.06610462f, -0.08315372f, -0.05768835f, -0.03205686f, 0.00408864f, -0.00841461f, 0.04233132f, -0.14101799f, 
    0.02672829f, 0.05020590f, 0.06706543f, -0.08386800f, -0.09682049f, -0.07648345f, -0.01939736f, 0.08076686f, 
    0.10843150f, -0.01481311f, -0.01658566f, -0.05485451f, 0.04972942f, 0.05602070f, -0.00080664f, 0.04947478f, 
    0.00071014f, -0.01851749f, 0.06029064f, -0.05981898f, 0.00202623f, -0.11269149f, 0.06424326f, -0.11474709f, 
    0.07385316f, -0.06194679f, 0.06191482f, -0.08927812f, -0.03372561f, -0.06403882f, 0.00788074f, -0.12614082f, 
    -0.03266299f, 0.10283124f, -0.12386200f, 0.07868695f, -0.10924824f, -0.10006443f, 0.01023914f, -0.15820025f, 
    0.41499543f, 0.22901596f, -0.03368273f, 0.03634999f, -0.11992576f, -0.02247248f, 0.16562544f, -0.03760484f, 
    0.23619376f, -0.08318921f, 0.12273397f, 0.11575767f, 0.03433417f, 0.20299722f, -0.11636025f, 0.10473613f, 
    -0.02160889f, 0.07757185f, -0.01226866f, 0.03597920f, 0.11746854f, -0.08373743f, -0.02768794f, 0.14781256f, 
    0.27128696f, 0.07902939f, 0.01999446f, -0.10999835f, 0.13580205f, 0.17043512f, 0.18892728f, 0.17254765f, 
    -0.08143923f, -0.05548649f, -0.12760511f, -0.09191343f, 0.13777803f, 0.05105467f, -0.05115548f, 0.06398648f, 
    -0.16161384f, -0.02663998f, 0.03798530f, -0.03828458f, -0.08976373f, -0.07200245f, -0.23945864f, -0.10332941f, 
    0.07745294f, -0.22569397f, 0.07287588f, -0.23465127f, -0.19721459f, 0.03931474f, 0.18553893f, -0.00209696f, 
    0.02780244f, -0.10773823f, 0.10145056f, -0.07586708f, 0.43996033f, 0.02781810f, -0.09928831f, 0.07746578f, 
    -0.08470204f, 0.06985670f, 0.07418613f, 0.12346073f, -0.10022928f, 0.33774996f, 0.16067585f, -0.33971953f, 
    -0.24739605f, -0.06112922f, 0.12069447f, -0.04469907f, 0.02311804f, -0.00425321f, -0.08524899f, 0.26106879f, 
    0.11099843f, 0.05552180f, 0.17264207f, 0.12810622f, -0.13632903f, 0.27428961f, -0.00097876f, -0.01567387f, 
    0.01778901f, 0.12868027f, 0.29542893f, 0.14919065f, 0.02376119f, -0.05953849f, -0.15941018f, 0.00236593f, 
    0.01866373f, -0.05600752f, 0.03858456f, 0.06774742f, -0.09944487f, 0.04443809f, 0.11140081f, 0.10166629f, 
    0.27669516f, 0.04263105f, 0.05430603f, -0.09268716f, 0.00770826f, -0.23458739f, -0.27761126f, 0.00118318f, 
    -0.12786746f, -0.12755509f, 0.28278342f, -0.15999842f, -0.10898399f, 0.13703713f, 0.22870417f, 0.00171964f, 
    0.02352685f, 0.06855854f, 0.04399139f, 0.10133432f, -0.03232934f, -0.00161001f, -0.06146952f, 0.27628630f, 
    -0.08422992f, 0.07327408f, -0.00423509f, -0.08427780f, -0.08592572f, 0.05881529f, 0.14311616f, 0.14842544f, 
    -0.27684405f, -0.15117790f, 0.18529119f, -0.10310800f, 0.04896983f, -0.13437785f, 0.34124577f, 0.22489056f, 
    -0.05688807f, 0.11762898f, -0.07990776f, -0.03892737f, -0.22074519f, 0.38931629f, 0.01544130f, -0.03090238f, 
    -0.04445284f, -0.07730771f, 0.20238337f, 0.10843132f, 0.13397810f, 0.15727389f, -0.17096323f, -0.09274997f, 
    -0.09484015f, -0.03487759f, 0.06257638f, 0.12027381f, -0.08795441f, -0.07913928f, 0.01083635f, 0.15343598f, 
    0.00747366f, 0.02791075f, -0.12199078f, 0.09189276f, 0.25081828f, -0.10097169f, 0.10466646f, 0.07757163f, 
    -0.38573104f, 0.19313502f, -0.10675145f, -0.10235737f, -0.10747485f, 0.31605169f, 0.27163413f, 0.06763011f, 
    -0.01734958f, -0.12190510f, -0.09969001f, -0.10817366f, 0.23515230f, 0.05327776f, -0.02473947f, 0.05181093f, 
    -0.09715556f, 0.05567021f, 0.08403341f, -0.03470445f, 0.09566567f, -0.05236034f, -0.07077384f, 0.09917571f, 
    0.04648224f, 0.00808073f, 0.03068463f, -0.01952720f, -0.09811424f, 0.00400960f, -0.02552098f, 0.01152313f, 
    -0.02497139f, 0.09312849f, 0.01729469f, -0.06901120f, -0.03579396f, -0.12224143f, -0.07562482f, -0.04236111f, 
    0.08060578f, 0.03631010f, -0.00802337f, -0.12830830f, 0.02138506f, -0.11403476f, 0.11048796f, -0.10525608f, 
    -0.04440732f, -0.07434327f, 0.11862585f, -0.06458683f, -0.07864963f, 0.12623084f, -0.07508187f, -0.10449312f, 
    -0.04204014f, 0.06585970f, -0.12539126f, -0.06661027f, -0.12773132f, -0.12766220f, -0.00908000f, 0.07456905f, 
    -0.11675814f, 0.07960187f, -0.04862318f, 0.06869105f, -0.09946962f, 0.02632454f, -0.06048141f, -0.07620534f, 
    -0.04268428f, 0.04614211f, -0.09449288f, 0.10217933f, 0.05828714f, 0.12074375f, -0.05592630f, 0.01099566f, 
    -0.07996584f, -0.10606901f, -0.04897967f, 0.01363817f, 0.11201169f, 0.10219624f, 0.07460956f, 0.13566841f, 
    0.00302386f, 0.25061196f, -0.11324348f, -0.04459015f, -0.09215939f, 0.12987071f, 0.16854520f, 0.23223232f, 
    -0.06487234f, 0.23022479f, 0.12475814f, 0.05438513f, -0.26992527f, 0.00309580f, -0.08189274f, -0.20880286f, 
    0.14455798f, 0.04120455f, -0.10977536f, -0.05050072f, -0.06443624f, 0.27608088f, 0.04494245f, -0.18345046f, 
    -0.02717530f, -0.11493616f, 0.20089285f, 0.08932221f, -0.06587363f, 0.08404312f, -0.00092648f, -0.19946150f, 
    -0.07860039f, 0.06987701f, -0.00756199f, -0.14145839f, 0.16253005f, -0.02148574f, 0.02863625f, 0.09103855f, 
    0.14261565f, -0.03947863f, -0.03571038f, 0.21526390f, 0.12274860f, -0.10355899f, 0.30033010f, 0.06850201f, 
    -0.07380021f, -0.03114497f, 0.01735303f, -0.02807806f, 0.16895196f, 0.06422053f, -0.02211461f, 0.12329325f, 
    -0.03548535f, 0.04202573f, 0.11581612f, 0.08773790f, 0.12032176f, -0.00739855f, 0.01653473f, -0.08967878f, 
    -0.16763195f, -0.35546952f, 0.20421404f, -0.10874537f, -0.02844477f, 0.26938841f, -0.10453652f, -0.17956977f, 
    0.27590674f, -0.17709452f, 0.12639140f, -0.02060820f, 0.28508997f, -0.07144560f, 0.08688896f, 0.02607846f, 
    0.01603474f, -0.05342641f, 0.11183362f, 0.04534252f, -0.23532085f, 0.04113745f, 0.15990461f, 0.16782573f, 
    -0.10320192f, 0.06412134f, -0.27431995f, 0.08553783f, -0.01728417f, 0.07739700f, 0.10766965f, 0.21510954f, 
    -0.14778912f, -0.09376463f, 0.13945609f, -0.15570939f, 0.04860665f, 0.11446454f, -0.04522166f, -0.03666243f, 
    -0.03913325f, 0.24952969f, 0.17404097f, -0.04441923f, -0.05157631f, 0.02167972f, 0.07367935f, 0.07581776f, 
    -0.06690409f, 0.03342211f, 0.03885072f, -0.03300824f, 0.22892787f, -0.01570791f, 0.07313193f, 0.04946452f, 
    0.05887673f, -0.13142416f, 0.01509646f, 0.10028134f, 0.10630243f, -0.09441527f, 0.05919070f, -0.03544531f, 
    -0.08829532f, 0.04314473f, 0.05930361f, -0.07920587f, -0.04240006f, -0.15638627f, -0.14334230f, -0.02976610f, 
    -0.10514250f, -0.02710279f, -0.04242492f, -0.01398546f, 0.05406079f, 0.02875868f, 0.07383856f, -0.15306002f, 
    0.03300777f, 0.11122858f, -0.05345428f, 0.05583689f, 0.04186157f, -0.13248256f, -0.00845842f, 0.01428128f, 
    0.01986729f, 0.06166432f, -0.12462688f, 0.06956708f, -0.03817755f, 0.05205719f, 0.10237429f, 0.02201838f, 
    0.04833500f, 0.11273143f, -0.03623246f, -0.16034080f, -0.00254262f, -0.06021876f, -0.10382438f, 0.01357356f, 
    -0.15209207f, -0.03101029f, 0.02330547f, 0.03562869f, -0.09346763f, -0.11673480f, 0.07306674f, 0.11289111f, 
    -0.11440478f, -0.08385845f, -0.09979962f, -0.05542171f, 0.07733475f, 0.08957078f, -0.08123263f, -0.07492788f, 
    -0.04106803f, -0.01035154f, 0.00605281f, 0.03068858f, 0.04855755f, -0.05490074f, 0.07527262f, 0.03435246f, 
    -0.09091161f, -0.13393636f, -0.00184447f, 0.11544557f, 0.11411894f, 0.02576817f, -0.11402668f, 0.07753663f, 
    -0.11275747f, -0.09809403f, -0.03337119f, 0.04862427f, -0.09848702f, -0.08440504f, 0.10400844f, 0.09380747f, 
    0.06882361f, -0.06981920f, 0.04246447f, -0.03448841f, 0.07466640f, -0.12320098f, -0.09480093f, -0.00797783f, 
    0.07042190f, -0.09298082f, -0.05755582f, -0.05507353f, 0.10229862f, -0.05139211f, 0.05717795f, -0.10243145f, 
    0.04599996f, 0.10136168f, -0.01850509f, 0.09627921f, -0.00752974f, -0.00724684f, 0.02811209f, 0.08224118f, 
    0.01785523f, -0.09666818f, -0.13286884f, 0.06256274f, 0.09954484f, -0.00522928f, -0.11953405f, 0.01658531f, 
    -0.06747271f, 0.05842255f, 0.08838974f, -0.04919508f, 0.00726157f, -0.06012228f, 0.03690566f, 0.10870911f, 
    0.02984693f, -0.10507281f, -0.10624522f, 0.08915574f, 0.12058042f, 0.01252440f, -0.08925865f, 0.09443930f, 
    0.10073086f, 0.06580899f, 0.26055709f, 0.00728219f, 0.10936987f, 0.03483061f, -0.01824204f, 0.10692848f, 
    0.21546718f, -0.10599967f, -0.09201455f, 0.02744935f, 0.14266054f, 0.28091905f, 0.03704734f, 0.05051559f, 
    0.04996826f, -0.03051093f, -0.13823082f, 0.01150833f, 0.13688464f, -0.13850307f, 0.07123516f, -0.22099194f, 
    0.08269941f, -0.09422354f, 0.13298133f, -0.04147049f, -0.13693990f, -0.11120341f, 0.07055071f, 0.13036194f, 
    0.04759194f, 0.06251467f, 0.05253468f, 0.21904561f, 0.05536124f, -0.17941502f, 0.34520453f, -0.04585139f, 
    0.20897965f, 0.47588265f, 0.20598568f, 0.06101348f, 0.27690464f, -0.00466569f, -0.01320277f, 0.05938226f, 
    -0.00179367f, -0.11977006f, -0.05308123f, 0.15996093f, 0.12511691f, 0.02004359f, -0.07343580f, -0.02298003f, 
    0.19776158f, -0.14991798f, -0.11951370f, 0.10292684f, 0.08741569f, -0.04439717f, -0.12003232f, 0.22694916f, 
    0.22767027f, 0.11805922f, 0.28444871f, 0.09997024f, 0.08397973f, -0.12547943f, 0.11133487f, -0.06214884f, 
    0.09374025f, 0.05289965f, -0.02930499f, -0.16262193f, 0.12186272f, 0.00408709f, -0.01361546f, 0.19709887f, 
    0.03325697f, -0.00863924f, -0.05402596f, -0.03532805f, -0.02705956f, -0.05422892f, 0.10175384f, 0.03685826f, 
    -0.00556920f, 0.03045379f, -0.08407911f, -0.09714705f, -0.00098337f, -0.02263332f, -0.05463187f, 0.10389797f, 
    -0.14899650f, -0.12953557f, -0.01449646f, 0.21673723f, -0.04408988f, -0.11182886f, 0.15320665f, 0.08752086f, 
    0.06968221f, 0.26828545f, -0.05261746f, -0.03275231f, 0.25599319f, 0.01590041f, -0.19161445f, 0.00843930f, 
    0.03345969f, 0.06845453f, -0.10968186f, 0.07940220f, -0.12692425f, 0.07588644f, 0.11361621f, -0.02139594f, 
    0.03010412f, -0.13246755f, 0.01418361f, 0.05954963f, 0.01530918f, 0.07651224f, 0.01584947f, -0.09016448f, 
    -0.00330573f, -0.08398147f, -0.00546484f, -0.10805705f, -0.10692151f, 0.05786540f, -0.08285248f, -0.10279383f, 
    -0.11991106f, -0.06230208f, 0.04003882f, -0.12202376f, -0.02875941f, 0.04718493f, 0.05257975f, 0.05707439f, 
    0.08957821f, 0.02800116f, -0.06225093f, -0.14120407f, 0.02184608f, 0.10129951f, 0.07168701f, 0.07599233f, 
    0.01848188f, 0.01839023f, -0.00041213f, -0.04842253f, 0.03383123f, 0.12557131f, 0.07746447f, 0.07124557f, 
    0.01021778f, -0.07487511f, 0.00512812f, 0.04113294f, -0.14808917f, -0.07997186f, 0.06986857f, -0.03857737f, 
    -0.06983010f, -0.02297724f, -0.06810156f, -0.14113526f, -0.03478519f, 0.07747880f, 0.05276372f, -0.02186832f, 
    0.03077573f, 0.11814190f, 0.09304363f, -0.12588575f, -0.07155296f, -0.07902215f, 0.04185710f, -0.07971629f, 
    -0.25102931f, -0.08270532f, -0.06385666f, 0.06884664f, -0.07565800f, -0.15499263f, -0.10929778f, 0.30490342f, 
    -0.06616091f, 0.12637734f, -0.21081297f, 0.07799894f, -0.10128574f, -0.02222253f, 0.06502971f, 0.00341903f, 
    -0.01803563f, -0.12127424f, 0.11221098f, 0.08047839f, 0.07396252f, 0.14112695f, -0.10697863f, -0.06535444f, 
    -0.14100434f, 0.07165027f, 0.03469557f, 0.06759661f, -0.31058589f, 0.09841131f, 0.05686555f, 0.11743980f, 
    0.11978100f, -0.08096209f, 0.25712326f, 0.06509956f, 0.00496515f, 0.05606775f, 0.10091995f, -0.18647836f, 
    -0.04685850f, -0.10002276f, -0.00506695f, 0.09906328f, 0.00044225f, 0.23624328f, 0.05944088f, 0.07346120f, 
    0.16757117f, 0.08735749f, -0.16038607f, 0.27238300f, 0.11284843f, -0.22282127f, -0.02936762f, 0.06009008f, 
    -0.07442877f, 0.11256665f, 0.03226185f, 0.13410507f, -0.13666341f, -0.09655368f, 0.00390783f, -0.01395365f, 
    0.03150705f, -0.12627663f, 0.06153408f, 0.01176609f, -0.01492701f, -0.12595488f, 0.10213898f, -0.00260380f, 
    -0.09292235f, 0.03790909f, 0.03015737f, -0.05126521f, 0.08112261f, -0.12880115f, 0.07425958f, 0.05003329f, 
    -0.04708445f, -0.12739782f, -0.11013803f, 0.00046178f, -0.06292515f, 0.00004972f, -0.07607203f, -0.05566546f, 
    -0.04794310f, -0.04966656f, -0.06475225f, -0.11374335f, -0.12451050f, -0.10778165f, 0.07345457f, 0.13116290f, 
    -0.04410580f, -0.09261527f, -0.09030604f, 0.02650825f, -0.09317959f, -0.00391503f, 0.08769469f, -0.03691790f, 
    -0.13407770f, -0.11568312f, 0.02916758f, -0.05547967f, -0.03642473f, 0.10037485f, 0.05710795f, 0.11192537f, 
    0.06741247f, 0.08117681f, 0.09073986f, 0.05080497f, -0.02077603f, -0.12984277f, -0.09776530f, -0.12255434f, 
    0.08970836f, 0.09852498f, -0.08764091f, -0.04392838f, 0.10316406f, -0.10818754f, -0.01505140f, -0.08358264f, 
    -0.08563397f, -0.02905105f, -0.00274760f, 0.07988520f, -0.13027149f, 0.09564830f, 0.05701552f, 0.04317608f, 
    0.03467063f, 0.02545342f, -0.10580826f, -0.07573044f, 0.01468377f, -0.11731213f, -0.08311244f, -0.01314583f, 
    0.09490880f, -0.15127333f, 0.06542396f, 0.08704040f, 0.02758297f, 0.01952559f, 0.10417581f, 0.10142189f, 
    -0.09518570f, -0.04731473f, -0.03339411f, 0.09103964f, -0.13800552f, 0.07946335f, -0.08755862f, -0.01694726f, 
    -0.01852413f, 0.04199279f, -0.08824482f, 0.04482248f, 0.03152587f, -0.03731433f, -0.11272506f, -0.10601279f, 
    -0.09177055f, 0.01002318f, -0.00377829f, -0.10031054f, 0.07657859f, 0.01172172f, 0.03509765f, 0.02507645f, 
    -0.08757751f, -0.02167810f, -0.06966601f, -0.02403570f, -0.07170483f, -0.07174230f, -0.13606486f, -0.05854182f, 
    -0.10539778f, 0.10527175f, 0.11082675f, -0.05266913f, -0.05566924f, -0.12362790f, 0.01898529f, 0.03815132f, 
    -0.23182645f, -0.06542395f, -0.05925190f, -0.02082173f, 0.00011564f, -0.23912650f, 0.03715756f, 0.22434723f, 
    -0.09537587f, 0.29816878f, -0.15638173f, 0.11717290f, -0.02560184f, -0.20147462f, 0.09121322f, 0.09439320f, 
    0.13353905f, -0.05720392f, -0.14014158f, -0.12043028f, -0.16227022f, 0.19650389f, 0.12530892f, 0.14463671f, 
    -0.17654726f, 0.03028399f, 0.09339140f, 0.26754516f, -0.22187574f, 0.07964887f, 0.14664753f, 0.12582871f, 
    0.03189634f, -0.07417375f, 0.34325460f, -0.08842684f, 0.20581923f, 0.09220625f, 0.09750931f, -0.23984715f, 
    -0.12883538f, -0.07335540f, -0.20062394f, 0.07118883f, 0.24690218f, 0.24083117f, 0.16024075f, -0.11395389f, 
    0.05578160f, -0.06188003f, -0.19210055f, 0.39634982f, 0.42884251f, 0.03651265f, -0.23264755f, -0.05639790f, 
    -0.07879928f, 0.10502701f, -0.10874382f, 0.12588400f, -0.41048750f, -0.05828403f, -0.12532313f, 0.03844584f, 
    -0.15214561f, 0.03062193f, -0.00780521f, -0.03653504f, -0.03728556f, -0.01430528f, -0.09698603f, -0.05925785f, 
    -0.00320838f, -0.00293821f, -0.10448427f, 0.06949453f, -0.06722520f, 0.02588307f, 0.05785777f, 0.05923547f, 
    0.05805795f, -0.13608924f, -0.11814529f, -0.15522476f, 0.07082897f, 0.03939006f, -0.03749675f, -0.03710205f, 
    -0.10269307f, 0.10519857f, -0.10129300f, 0.05937973f, -0.16046786f, -0.04550575f, -0.09880284f, -0.14404516f, 
    0.05791157f, -0.06413317f, 0.03954662f, -0.12731427f, -0.06047259f, -0.11731318f, -0.04374108f, -0.08316208f, 
    -0.10436722f, -0.11556263f, -0.07118732f, -0.13367796f, -0.03362434f, -0.02204260f, -0.12522070f, 0.08765491f, 
    0.03343197f, -0.00037089f, -0.13345063f, 0.03775969f, 0.03572332f, 0.03549783f, 0.01060066f, -0.03556316f, 
    0.08608066f, 0.09587735f, 0.06514689f, -0.07285607f, 0.06821462f, 0.08418459f, 0.02349680f, 0.03009421f, 
    0.01175359f, -0.04271564f, 0.07839084f, 0.00970034f, 0.01501339f, -0.01828728f, -0.13833687f, -0.13267367f, 
    -0.12313199f, -0.00399706f, -0.03392270f, 0.05682060f, -0.05142530f, 0.09655974f, 0.04318639f, -0.01917439f, 
    -0.05387255f, -0.03525846f, -0.00870842f, -0.10521875f, -0.07421440f, -0.11875769f, 0.09936342f, -0.04134406f, 
    -0.09161649f, 0.04694288f, -0.14340732f, 0.07788491f, -0.01641234f, 0.09420588f, 0.09105442f, -0.14934626f, 
    -0.05468135f, 0.06185584f, 0.00565930f, -0.12278653f, -0.02936194f, -0.07205259f, -0.12264256f, -0.02925458f, 
    -0.06829474f, 0.05890734f, 0.12732522f, 0.05098321f, 0.02271158f, -0.12289201f, 0.06445712f, 0.07983302f, 
    0.05148523f, 0.10925689f, 0.07396608f, 0.11241975f, -0.09383362f, -0.04451039f, 0.01681239f, -0.04640592f, 
    -0.05280834f, -0.08858594f, -0.08214450f, -0.06295185f, -0.08881874f, -0.04077467f, 0.10733445f, -0.09712677f, 
    0.02519661f, 0.18905507f, -0.00603443f, 0.07854341f, 0.06067133f, 0.09474447f, 0.30935889f, 0.06481804f, 
    0.03158847f, -0.13839528f, -0.11374523f, 0.03367334f, 0.09568518f, -0.19046921f, 0.26154730f, 0.28993705f, 
    -0.13383049f, -0.03729572f, 0.18245316f, 0.04229322f, -0.11298563f, 0.20306315f, 0.06338628f, 0.10610774f, 
    -0.07364845f, 0.11690334f, 0.18728429f, 0.24859391f, 0.19237214f, 0.14659661f, -0.05889864f, -0.11747139f, 
    -0.06825405f, -0.08646327f, 0.07928042f, -0.06621873f, -0.10307189f, -0.07875644f, -0.06293521f, -0.26161680f, 
    0.19791459f, -0.08372071f, -0.11789411f, 0.04345556f, -0.03035951f, 0.11732321f, -0.07390007f, -0.00680301f, 
    -0.40597406f, -0.20843503f, 0.01402172f, -0.15306102f, -0.19801013f, 0.17431410f, 0.25131181f, 0.09117185f, 
    -0.03238745f, 0.01020661f, 0.03801854f, -0.18342446f, 0.31530029f, -0.06423289f, 0.06657612f, 0.07649368f, 
    -0.18658105f, 0.11430103f, -0.05486224f, -0.01424422f, -0.10076159f, 0.17674449f, -0.03567880f, -0.20228861f, 
    -0.03833263f, 0.04505587f, 0.06003317f, 0.05721145f, -0.12286726f, -0.03982343f, -0.17843880f, 0.20594276f, 
    0.17387207f, 0.00444185f, 0.24692222f, 0.29411608f, 0.04745927f, -0.03775479f, -0.03275225f, -0.03890060f, 
    -0.05618644f, 0.05667128f, 0.14523806f, 0.10200033f, 0.00419444f, 0.05857166f, -0.08722393f, -0.07964700f, 
    -0.00880219f, -0.04740695f, -0.06089786f, 0.03659942f, -0.07805178f, 0.11269939f, 0.05050748f, -0.16034715f, 
    0.37308839f, 0.08600620f, 0.18883580f, 0.07827461f, -0.13079821f, 0.01435717f, -0.20920958f, 0.05727360f, 
    -0.06789843f, -0.18295459f, 0.24515906f, 0.11000745f, -0.03059809f, 0.00582957f, -0.00299936f, 0.12619939f, 
    0.00217583f, 0.01518587f, -0.11436115f, 0.24846257f, -0.28432047f, -0.07110769f, 0.10972607f, 0.28679228f, 
    0.30093625f, -0.01405931f, 0.01825041f, -0.03123781f, -0.06672774f, -0.18123126f, -0.01894462f, 0.25848845f, 
    0.26582927f, 0.06208048f, -0.03599907f, 0.06046619f, -0.02635144f, 0.05678396f, 0.05720146f, 0.01169022f, 
    -0.19254801f, 0.09683563f, -0.11671238f, 0.05621018f, 0.20262454f, -0.03275878f, -0.11251570f, 0.21063040f, 
    0.19806951f, -0.12498672f, -0.06869974f, 0.07034698f, 0.21543846f, 0.10296549f, -0.18430062f, 0.03819805f, 
    0.04409219f, 0.10056610f, 0.01131450f, 0.11913167f, 0.06360983f, -0.05924098f, 0.07898085f, -0.00590533f, 
    -0.00347393f, 0.04285988f, 0.01444651f, 0.28295046f, -0.03140745f, 0.01398536f, 0.09966528f, -0.00941695f, 
    -0.03524019f, -0.13885114f, -0.14583260f, 0.11715683f, 0.13677645f, -0.07837052f, -0.00167120f, -0.03196185f, 
    -0.03331098f, -0.09754923f, 0.11555816f, -0.23425558f, 0.18602139f, -0.08400115f, -0.07596417f, -0.25642878f, 
    0.06776738f, 0.11769684f, 0.03580517f, -0.01096502f, 0.00552024f, 0.03004676f, 0.05569057f, -0.22534622f, 
    -0.01144179f, -0.31720781f, -0.09583376f, 0.05277903f, -0.11619781f, 0.19594173f, -0.01153974f, -0.16498542f, 
    0.11988006f, -0.02040354f, 0.20035155f, 0.22750059f, 0.20440507f, -0.27505961f, -0.04119914f, 0.07755306f, 
    0.05888635f, -0.02643764f, 0.05578514f, -0.23081066f, -0.00344545f, 0.07408454f, -0.01703506f, 0.21679141f, 
    -0.02991635f, -0.02574589f, -0.08689912f, -0.09448527f, -0.11586377f, 0.11581828f, -0.06678288f, 0.25078776f, 
    0.22063164f, -0.01672482f, 0.29540962f, -0.16028170f, -0.01834461f, 0.06081429f, -0.02367560f, 0.06933013f, 
    0.09189768f, -0.08989275f, -0.07393993f, -0.10462788f, -0.35654327f, 0.06931541f, -0.04043073f, -0.07906318f, 
    0.10725160f, 0.09024306f, 0.07602638f, 0.21036407f, 0.00812332f, -0.00398837f, 0.02373146f, 0.05747816f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01528282f, 0.02600076f, -0.00594908f, 0.08961881f, 0.08966400f, -0.08348149f, -0.08491396f, -0.09962844f, 
    0.10371210f, -0.08090770f, -0.01700145f, 0.12855081f, 0.09706438f, -0.14408188f, -0.06272561f, 0.00831611f, 
    0.04322985f, 0.08783356f, -0.07411189f, 0.03875011f, -0.04223526f, 0.08558506f, -0.03222071f, -0.11765723f, 
    -0.02222893f, -0.03408520f, 0.03068032f, 0.03340033f, 0.03566875f, 0.03263186f, 0.04964102f, 0.08554550f, 
    -0.01924692f, -0.10316283f, 0.03373331f, 0.01402356f, 0.04253253f, 0.00834586f, 0.05044806f, 0.18372504f, 
    0.15431371f, -0.01491855f, -0.02417295f, 0.07366822f, 0.00640291f, 0.02684794f, 0.07161806f, 0.15859073f, 
    -0.00128462f, -0.07748109f, 0.00698640f, -0.04968149f, -0.03601636f, -0.01121682f, -0.08659998f, -0.01181295f, 
    0.03806772f, 0.07701201f, -0.06856635f, -0.14708266f, 0.07844184f, 0.10031290f, 0.01164481f, 0.14094897f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.00710400f, 0.10748977f, -0.04979895f, -0.28104162f, 0.01772339f, 0.34173286f, 0.06876922f, -0.09761161f, 
    0.18443422f, 0.22217672f, 0.25383958f, -0.10433980f, -0.00631895f, -0.14587606f, 0.00121044f, -0.52068371f, 
    -0.15577661f, 0.08397106f, -0.13470075f, -0.45071164f, -0.05522349f, -0.03156452f, 0.30954257f, 0.18884332f, 
    -0.55514371f, -0.04954029f, 0.07253656f, 0.03701353f, 0.10127801f, -0.28104654f, 0.07892855f, -0.09082432f, 
    -0.13092265f, -0.11603560f, -0.16729675f, 0.31483582f, 0.14857601f, -0.24996911f, -0.41904357f, -0.44136181f, 
    -0.15150057f, 0.15654556f, -0.00424802f, -0.30424604f, 0.11825198f, 0.24311680f, 0.08454625f, -0.21094379f, 
    -0.20121682f, 0.11244596f, 0.00913888f, -0.00544140f, -0.07397553f, 0.06968924f, -0.07483390f, -0.09432888f, 
    -0.06727920f, 0.15428934f, -0.04344656f, 0.00125225f, 0.21330284f, 0.00735043f, -0.08723132f, -0.03767032f, 
    -0.01291495f, -0.03322038f, 0.27035180f, -0.38092127f, -0.34443468f, -0.05351185f, -0.04096492f, 0.03903494f, 
    -0.30041495f, -0.11234237f, 0.14023332f, -0.01094987f, 0.15470760f, 0.17122300f, 0.28209457f, -0.24937046f, 
    0.16092640f, -0.01998091f, 0.28056583f, -0.22289792f, -0.29752165f, 0.11421461f, 0.18967526f, 0.13121210f, 
    -0.10400916f, 0.02734349f, -0.11870803f, -0.11404420f, -0.36087251f, -0.36474481f, -0.03553536f, 0.04480134f, 
    -0.01445389f, 0.10861953f, 0.15388516f, -0.32731453f, 0.19604823f, 0.01158513f, -0.23493285f, 0.15969910f, 
    0.14863612f, 0.17953461f, 0.07109579f, 0.13305996f, -0.32172582f, -0.00575965f, 0.08557475f, 0.06463905f, 
    -0.12240197f, -0.04283874f, 0.00669085f, -0.16250533f, -0.07845000f, -0.10438123f, -0.02877821f, -0.01709723f, 
    -0.01221273f, 0.02662170f, -0.14234951f, -0.03865954f, 0.16536242f, -0.30534425f, 0.26332459f, -0.19790739f, 
    -0.05285461f, -0.43004405f, 0.15330833f, 0.10558747f, 0.18129747f, -0.15170944f, 0.10767645f, -0.12263682f, 
    -0.22403191f, 0.03152358f, -0.22845955f, -0.26947731f, 0.11760571f, -0.56918585f, 0.21796456f, 0.23543134f, 
    0.24416839f, -0.02771243f, 0.22736797f, -0.31105387f, -0.40683618f, -0.00105301f, -0.19581811f, 0.17742231f, 
    0.27630791f, -0.05900297f, 0.05669750f, -0.00635314f, 0.14110357f, -0.21290743f, -0.05037026f, -0.00933356f, 
    -0.15209024f, 0.08760425f, -0.36261457f, 0.29688543f, 0.10877952f, 0.15948702f, -0.04692999f, -0.02427926f, 
    -0.15960722f, -0.12092000f, 0.07708123f, -0.01698846f, -0.26593140f, 0.10315684f, -0.10687111f, -0.20154105f, 
    0.24451374f, -0.07716431f, -0.09329320f, -0.45234460f, -0.18493846f, -0.03623220f, 0.01378790f, 0.03865889f, 
    0.04220938f, 0.06144311f, 0.05789763f, -0.03102194f, -0.08006708f, -0.20404367f, 0.02442079f, 0.25054297f, 
    0.06629509f, -0.23149703f, 0.21403626f, -0.03027369f, 0.00043737f, -0.13751799f, 0.08589863f, -0.12683834f, 
    -0.06872988f, -0.49544275f, 0.22567669f, 0.07080970f, 0.03821851f, -0.18882111f, -0.55320275f, -0.31197938f, 
    0.12373648f, 0.03887496f, -0.16360480f, 0.17607525f, 0.11247589f, 0.33431292f, -0.28084591f, -0.15450443f, 
    -0.44399682f, -0.01043240f, 0.12826008f, 0.10170659f, 0.16320910f, -0.16120444f, 0.02278395f, 0.09965730f, 
    -0.12239409f, -0.04250025f, 0.11762322f, 0.09732767f, 0.05690226f, -0.41562572f, 0.09795400f, 0.04426416f, 
    0.22140132f, -0.24141118f, 0.09855609f, -0.35589087f, -0.20418526f, -0.47703058f, -0.03079908f, -0.02015370f, 
    0.03622529f, -0.01730585f, 0.11060518f, 0.08157967f, 0.04703301f, 0.03084056f, 0.26526225f, 0.07763756f, 
    -0.02680539f, 0.26480266f, -0.01410498f, -0.14025471f, -0.51453882f, 0.01023912f, -0.15078999f, 0.00152885f, 
    0.16170359f, 0.00981865f, 0.14761624f, -0.12260849f, 0.16760948f, 0.18576743f, 0.09928809f, 0.02261144f, 
    0.18048902f, 0.08002985f, 0.05453739f, 0.05103020f, -0.15058939f, 0.26177472f, -0.03120479f, -0.05694879f, 
    -0.25604829f, -0.02420877f, -0.37136203f, -0.01905465f, 0.15674469f, -0.03635194f, -0.31829101f, -0.15767442f, 
    0.19036582f, 0.08490352f, 0.03580395f, 0.11502466f, 0.17624198f, -0.06953978f, -0.26367515f, -0.03992085f, 
    0.18088745f, 0.08317975f, -0.00684836f, 0.05262474f, -0.16212137f, 0.22256240f, 0.14742137f, -0.15213342f, 
    -0.17410329f, -0.31279606f, -0.02460094f, -0.18196049f, 0.07732251f, -0.01047040f, 0.09492697f, 0.24502794f, 
    -0.32052311f, 0.05206201f, 0.02965540f, -0.06624701f, -0.22285180f, -0.12721406f, 0.09220329f, -0.01513795f, 
    -0.05504841f, 0.22851802f, -0.12517168f, -0.06140324f, -0.04653832f, 0.17195617f, -0.23408718f, -0.20157318f, 
    -0.08235382f, 0.25124127f, -0.50166589f, -0.22498620f, -0.37689838f, -0.17287759f, 0.05737634f, 0.06016689f, 
    -0.07391486f, 0.10866145f, -0.01875177f, 0.06625418f, -0.28402606f, -0.26682860f, 0.13378665f, -0.05832964f, 
    -0.20640554f, 0.07544665f, -0.37671617f, 0.06797082f, 0.12523143f, -0.12513562f, -0.06866980f, 0.05104632f, 
    0.28880599f, -0.05819504f, -0.10401303f, 0.03811396f, -0.69999748f, 0.13151440f, -0.17959134f, 0.05308754f, 
    -0.30275843f, 0.08178449f, 0.19831510f, 0.12797944f, 0.10683247f, -0.18040882f, 0.19933398f, 0.07061913f, 
    -0.05740172f, 0.11698921f, 0.05343801f, 0.04652157f, 0.12897862f, 0.07591949f, 0.00139224f, 0.03983593f, 
    -0.15244260f, -0.11160874f, 0.09377756f, -0.00294687f, -0.07606489f, -0.04854106f, -0.14708434f, 0.05870860f, 
    -0.08805840f, -0.20187119f, 0.00540418f, -0.04120519f, 0.21476568f, 0.18485300f, 0.11666702f, -0.23669328f, 
    -0.25681296f, -0.01736160f, -0.09021708f, 0.30752674f, 0.19230381f, -0.23798178f, 0.03373853f, 0.04707190f, 
    -0.17891723f, -0.01349818f, -0.44380260f, 0.11485192f, 0.30299747f, -0.21578483f, -0.07199635f, 0.07482068f, 
    -0.08570078f, -0.07464589f, 0.29779929f, -0.14317349f, -0.26205900f, 0.19011664f, -0.18479541f, -0.44964722f, 
    -0.40858182f, -0.00855283f, 0.09977643f, -0.02852624f, 0.06197249f, -0.09187467f, -0.39813483f, -0.05648105f, 
    0.08919737f, 0.11349369f, -0.15107082f, -0.10959382f, -0.06090986f, -0.21529341f, 0.11395911f, 0.05571066f, 
    0.27842423f, 0.06240588f, -0.10541536f, 0.12586448f, 0.20072000f, 0.21552646f, 0.08687890f, -0.00064905f, 
    0.23358145f, 0.03532613f, 0.09149491f, 0.12953913f, -0.05222485f, 0.15090239f, -0.26188827f, 0.10687377f, 
    -0.05599428f, -0.34404445f, -0.01371300f, -0.08487678f, 0.05573391f, -0.10722058f, -0.30453438f, 0.09214212f, 
    -0.32575849f, -0.27381539f, -0.39702302f, 0.02742433f, 0.01738909f, -0.18303952f, 0.02184039f, -0.07056867f, 
    -0.15206383f, -0.20793545f, 0.16969644f, -0.20312180f, 0.00674776f, 0.32105991f, -0.01865265f, 0.19608618f, 
    0.25452951f, -0.05003281f, 0.16021821f, 0.09963183f, 0.10730283f, -0.10819612f, 0.09983564f, -0.09839545f, 
    0.08392618f, -0.12800156f, -0.07559979f, 0.04154596f, -0.10641981f, 0.08901844f, 0.21734191f, 0.05071212f, 
    -0.10972851f, 0.09920703f, -0.02994937f, 0.18689661f, -0.40553799f, 0.08608485f, 0.14353172f, -0.19644487f, 
    -0.39668006f, -0.07329325f, -0.10151780f, -0.14200726f, 0.15367159f, -0.43315962f, -0.00581675f, -0.29972404f, 
    0.26537168f, -0.09236488f, 0.06885627f, 0.17171772f, -0.00157179f, -0.01250851f, -0.07472528f, 0.04078734f, 
    -0.06940345f, -0.06939220f, -0.08160205f, -0.06392469f, -0.42796692f, 0.21371496f, -0.15187962f, 0.11241470f, 
    0.12041640f, -0.16862158f, -0.37710568f, -0.13545167f, -0.02067886f, -0.37312382f, 0.12760353f, -0.05793843f, 
    0.30365914f, 0.02390601f, -0.15810746f, -0.38799587f, 0.14317991f, -0.10606347f, -0.27656403f, 0.23306219f, 
    0.01160741f, 0.03167142f, -0.39134032f, -0.00752441f, 0.07735994f, 0.18347469f, -0.23522316f, -0.10993280f, 
    0.24510075f, -0.01149989f, -0.00943069f, -0.05192799f, -0.12249172f, 0.15349422f, 0.11182690f, 0.06931399f, 
    -0.04619972f, -0.03836907f, -0.16580217f, -0.44883129f, 0.09214709f, 0.29557306f, -0.14640205f, 0.24470086f, 
    -0.18243058f, 0.15891087f, -0.09937756f, 0.07747049f, -0.19073568f, -0.09220838f, -0.04015797f, -0.18952106f, 
    -0.25720528f, -0.03392473f, 0.02183708f, 0.07414600f, 0.38062605f, -0.01992480f, -0.20680757f, 0.02047648f, 
    0.07948678f, 0.25467193f, -0.04486424f, -0.15958591f, -0.31697616f, -0.10954928f, 0.16094281f, -0.40342280f, 
    0.06817806f, -0.08719178f, -0.10315393f, 0.21684569f, 0.27829811f, 0.29559836f, -0.01063853f, -0.13848126f, 
    0.30730903f, 0.18536456f, 0.27420375f, -0.02949650f, -0.40686899f, 0.25420690f, -0.48158818f, 0.16566685f, 
    -0.24133690f, 0.05647495f, 0.11537185f, -0.12130995f, -0.07223324f, -0.26867455f, 0.13408878f, -0.17204523f, 
    0.07448862f, 0.07143333f, 0.00875143f, 0.09349812f, 0.17238680f, -0.12861690f, 0.07637748f, -0.01390353f, 
    -0.22369605f, -0.10408543f, 0.04704558f, -0.42680794f, -0.11066817f, 0.05995793f, -0.13742590f, -0.41102192f, 
    -0.01876786f, 0.17892531f, 0.10578851f, 0.13140908f, 0.18822503f, -0.10786660f, 0.10796902f, -0.05108055f, 
    0.03947918f, 0.10084724f, 0.11083589f, -0.29980856f, -0.23648228f, 0.04494578f, -0.26904622f, 0.02880717f, 
    -0.01878504f, -0.27609396f, 0.07435334f, 0.01313202f, 0.00746999f, 0.17887148f, -0.19903700f, 0.30624270f, 
    0.05253170f, -0.04658984f, 0.26965535f, 0.17856830f, -0.29612708f, -0.26382199f, 0.09909579f, 0.03475774f, 
    -0.04758855f, -0.54399866f, -0.33000278f, 0.05991044f, 0.22843537f, -0.15522511f, -0.48613402f, -0.28383994f, 
    -0.29295328f, 0.07866213f, 0.01604001f, -0.02847935f, 0.07064542f, -0.18730879f, 0.15501401f, -0.37529737f, 
    0.06953695f, 0.02466351f, 0.09322589f, 0.07757333f, -0.07125533f, 0.66973507f, 0.21200651f, -0.12610425f, 
    0.30319926f, 0.00130513f, 0.28204703f, -0.02398629f, 0.09399230f, 0.31343713f, -0.07111264f, 0.00573119f, 
    0.07881225f, 0.12828806f, -0.03271339f, 0.10776833f, -0.10068620f, -0.41600713f, 0.05403199f, -0.10691043f, 
    -0.14412987f, 0.00264676f, -0.09762478f, -0.02345564f, -0.02907168f, 0.02395983f, -0.15747027f, -0.04803976f, 
    0.07690228f, -0.25211155f, 0.08843421f, 0.06287970f, -0.36063993f, 0.07689941f, 0.12331417f, 0.37388265f, 
    -0.29600745f, 0.23823452f, -0.10781204f, 0.21956874f, 0.15198085f, -0.22554775f, -0.09623492f, 0.02212145f, 
    -0.08695199f, -0.36246106f, -0.27141881f, 0.04951821f, -0.14373536f, -0.27049989f, 0.09246801f, 0.11834147f, 
    -0.24582501f, -0.07965317f, -0.01196296f, 0.30250618f, -0.32563403f, -0.35234883f, -0.01877067f, 0.38412580f, 
    -0.28841600f, -0.00285779f, -0.02315866f, -0.02997964f, 0.05638291f, -0.31055140f, 0.25290117f, -0.10388552f, 
    0.16847476f, -0.02903547f, -0.20098247f, 0.07037871f, 0.11174009f, -0.44609991f, -0.08168022f, 0.29736701f, 
    -0.17885828f, -0.07578087f, 0.03969979f, -0.17237532f, -0.22515041f, 0.06759606f, -0.05065136f, 0.06314939f, 
    -0.05224198f, 0.10342418f, 0.08668964f, 0.16146354f, 0.16222811f, -0.03840087f, -0.07111364f, -0.02950261f, 
    -0.05431682f, 0.01150240f, -0.00819548f, -0.03162815f, -0.43548352f, -0.25202560f, 0.03653982f, -0.08072679f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.04668919f, -0.04767677f, 0.01149013f, -0.02822190f, 0.08068095f, -0.05540844f, 0.00159381f, -0.04741827f, 
    -0.00356926f, -0.00866925f, 0.02226810f, 0.06848641f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
