#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.58866972f, 0.79577488f, -0.51680899f, 0.00070240f, 0.02612644f, -0.18856534f, 0.28681508f, -0.11839647f, 
    0.25579166f, 0.08979362f, -0.22122267f, 0.31501159f, 0.07368589f, -0.33116031f, -0.39961568f, 0.17248257f, 
    0.27879643f, 0.34500051f, 0.03481308f, 0.04793007f, 0.47800362f, -0.07522080f, 0.38453022f, -0.53075528f, 
    0.33710828f, -0.11856194f, 0.36183286f, -0.16873702f, -0.13860546f, -0.59045422f, 0.63586497f, 0.04487296f, 
    0.38014853f, -0.27489975f, -0.25154948f, -0.08249652f, 0.43190381f, -0.73495930f, -0.02833777f, -0.33261478f, 
    0.10777932f, -0.06521444f, -0.25174946f, -0.24630922f, -0.26398909f, -0.43111068f, -0.09200232f, -0.25433537f, 
    -0.17628685f, 0.12251489f, -0.53048724f, -0.12012817f, -0.17864564f, -0.03595773f, -0.46503288f, -0.12412595f, 
    -0.44142878f, -0.14427271f, 0.11776962f, 0.58645326f, 0.15346664f, 0.03447609f, -0.15338843f, -0.14180121f, 
    -0.63897365f, 0.79485250f, -0.23214416f, -0.23623823f, 0.17546576f, -0.15489766f, -0.09032208f, 0.21116824f, 
    0.21010971f, -0.21402475f, -0.58456916f, -0.21162887f, -0.09008322f, 0.11112833f, -0.09585375f, 0.14553748f, 
    0.01997153f, -0.01973393f, 0.00722048f, -0.43447962f, -0.36492145f, -0.30603862f, -0.54685736f, 0.26027614f, 
    0.19913250f, 0.36710247f, 0.40959984f, 0.03794313f, 0.40592754f, 0.40705711f, 0.46221751f, 0.32062697f, 
    -0.07958940f, 0.09133667f, -0.08780590f, -0.35025498f, -0.15944733f, 0.43983310f, 0.36137557f, 0.12198553f, 
    -0.07704476f, -0.11291249f, -0.46652445f, -0.06997837f, 0.43864670f, -0.08570608f, 0.12410192f, -0.41675252f, 
    -0.01005107f, 0.10479160f, -0.15472135f, 0.36575025f, 0.11640262f, 0.74855047f, -0.70585954f, -0.33477652f, 
    0.26082402f, 0.08302034f, 0.17307635f, 0.18092701f, 0.09840684f, 0.06206504f, -0.01142201f, -0.02637235f, 
    0.32124540f, -0.44676310f, -0.57788676f, -0.23300183f, 0.30197990f, -0.51094335f, -0.38520414f, 0.30179647f, 
    0.81268203f, -0.63631779f, -0.34328160f, 0.23834984f, -0.34361795f, -0.09080140f, 0.04624875f, 0.05072486f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07389306f, -0.08931217f, -0.22453824f, -0.14557739f, -0.10277217f, 0.00298381f, 0.10459537f, -0.12249538f, 
    0.26856256f, -0.15108143f, 0.13483545f, -0.06858032f, 0.12824373f, -0.12040782f, -0.32317165f, -0.08733117f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05898891f, 0.34410307f, 0.20147595f, 0.06009375f, -0.06209739f, 0.02045144f, -0.00488510f, 0.21881920f, 
    0.14060163f, 0.09654323f, 0.09427787f, -0.04308650f, 0.14251649f, 0.00518781f, -0.02441098f, 0.35060543f, 
    0.12727693f, 0.12005710f, -0.03702144f, 0.10917230f, -0.10633330f, 0.10224834f, 0.26060066f, -0.07544298f, 
    0.08627217f, 0.09403068f, 0.20418188f, -0.04586404f, 0.19493590f, -0.04979723f, 0.01061086f, -0.12402694f, 
    0.07202595f, -0.16066669f, -0.28205621f, -0.11251630f, 0.08065107f, -0.16825432f, -0.02470759f, 0.10607670f, 
    -0.04116888f, 0.04950812f, -0.16801082f, -0.07948484f, -0.29970792f, -0.19012302f, -0.10285354f, 0.08575274f, 
    -0.11154076f, -0.00174233f, -0.15542069f, 0.00602699f, -0.07889984f, 0.00648986f, 0.05085035f, 0.04779930f, 
    0.13337539f, 0.12908189f, -0.11793640f, -0.00171806f, -0.01686362f, 0.05611873f, -0.11533349f, -0.08435869f, 
    0.04814074f, 0.00870068f, 0.19781846f, -0.10381018f, 0.18709867f, -0.06032727f, 0.00080213f, 0.14371122f, 
    0.05740544f, 0.07614297f, 0.00265202f, 0.11547697f, 0.04019769f, 0.07093818f, 0.00670154f, -0.04330603f, 
    0.10436107f, 0.11966853f, -0.03626276f, -0.04600239f, -0.07096597f, 0.02796543f, -0.00518211f, 0.16572382f, 
    0.17724955f, -0.04927644f, -0.17776616f, -0.23645256f, -0.10581084f, 0.12119996f, -0.03093764f, 0.03561217f, 
    -0.07531463f, -0.03275955f, -0.07310423f, -0.10950653f, 0.04030434f, 0.01651894f, 0.07234178f, -0.11543273f, 
    0.04840859f, -0.20908561f, -0.13980088f, -0.29541892f, 0.02489544f, -0.08189085f, 0.11124121f, 0.12244398f, 
    0.18863903f, 0.15239339f, 0.07709128f, -0.00054016f, 0.06891264f, -0.09974562f, 0.01527798f, 0.15565021f, 
    0.15825866f, 0.06376636f, -0.15655509f, -0.09657232f, 0.03313585f, 0.19001296f, 0.04913089f, -0.01370562f, 
    0.05724750f, 0.23877954f, 0.05366908f, 0.04040904f, -0.06476971f, 0.05570827f, -0.07334243f, -0.04073027f, 
    0.40544295f, -0.24234000f, 0.07703968f, -0.02301272f, 0.06891907f, 0.02248150f, 0.23233932f, -0.11144742f, 
    -0.16650267f, 0.15389732f, 0.31137565f, -0.14548428f, 0.24564712f, -0.20973748f, -0.09876169f, 0.04188276f, 
    -0.03701083f, 0.07087277f, -0.18729407f, -0.10460801f, -0.04117624f, 0.29946026f, 0.09504985f, 0.12508439f, 
    -0.02232065f, 0.09433681f, 0.02024331f, 0.26512957f, 0.10271145f, -0.04147946f, 0.11410975f, -0.22278719f, 
    -0.12128262f, 0.09713522f, 0.05341715f, -0.07004867f, 0.08792747f, 0.07525273f, 0.13289350f, -0.01447361f, 
    -0.13644274f, 0.13648447f, -0.25526544f, -0.23849477f, 0.04195926f, -0.27155417f, -0.16808543f, -0.12622906f, 
    0.08483899f, 0.09695167f, -0.10293321f, 0.08350198f, -0.02878486f, 0.20445745f, 0.25467843f, 0.04743991f, 
    -0.11610124f, -0.04749411f, -0.12792119f, -0.08276925f, 0.04667632f, -0.11564049f, -0.32254139f, 0.19417323f, 
    -0.28461391f, -0.01683336f, -0.03050830f, -0.11820387f, 0.12279632f, -0.08821370f, 0.09637037f, -0.30664816f, 
    0.23160510f, 0.01091285f, -0.00320105f, 0.14014412f, 0.13789076f, 0.01023769f, 0.02667553f, -0.14458248f, 
    0.04713852f, -0.12609760f, -0.18914470f, -0.00350476f, -0.09313291f, -0.02382215f, 0.01212153f, -0.00089363f, 
    0.11025164f, 0.05163352f, -0.09651112f, -0.08147977f, 0.03709044f, -0.09009285f, 0.06318019f, -0.01419364f, 
    0.07387386f, 0.14580204f, 0.07067362f, 0.06267016f, 0.26630825f, -0.14667115f, -0.07950974f, 0.02612151f, 
    -0.03667596f, -0.06669455f, 0.09405697f, -0.11421116f, -0.19112994f, 0.11710525f, 0.04913638f, 0.26913330f, 
    -0.04386450f, -0.18953221f, -0.06916498f, 0.07082333f, 0.06206254f, -0.04313118f, 0.01852096f, 0.04207437f, 
    -0.11181955f, 0.19441403f, -0.02371485f, 0.10496872f, 0.01203807f, 0.23740028f, -0.12953791f, -0.07521521f, 
    -0.06712558f, -0.22783059f, 0.05818010f, -0.03932507f, 0.00490096f, -0.01519304f, -0.01100081f, -0.29830608f, 
    0.03621268f, -0.16014890f, 0.06935534f, 0.04680464f, -0.00015711f, 0.14397912f, 0.04742789f, 0.03086763f, 
    -0.05611305f, 0.11486898f, 0.14232570f, 0.07461343f, -0.04171465f, -0.11727323f, -0.05742779f, 0.01011557f, 
    -0.04426071f, -0.12034989f, -0.18170528f, 0.07999711f, -0.01503350f, 0.09327111f, 0.05754613f, 0.16424184f, 
    0.12165144f, 0.00164479f, 0.05979848f, -0.25159633f, -0.08236561f, -0.09551108f, 0.12658177f, -0.15677081f, 
    -0.06433398f, 0.08525520f, -0.02357195f, 0.19090596f, -0.28946623f, -0.19411413f, -0.08366241f, -0.08554894f, 
    -0.09017074f, 0.08719248f, -0.06002889f, 0.18332106f, 0.26463741f, 0.09910028f, -0.01570033f, 0.11279435f, 
    -0.04003320f, 0.17530358f, 0.23880981f, -0.19129708f, 0.02293838f, 0.21908100f, 0.19273826f, -0.16379584f, 
    -0.09272984f, 0.01933994f, 0.03973461f, 0.05345855f, -0.18694690f, 0.18782644f, 0.10673878f, 0.15489615f, 
    -0.07377838f, 0.00023701f, 0.05577567f, 0.25746009f, 0.01365495f, -0.15315269f, 0.00960989f, -0.16180760f, 
    0.14418191f, 0.08707534f, 0.12249248f, -0.02617107f, 0.08527827f, 0.13980985f, -0.03302744f, 0.01085769f, 
    0.07654908f, -0.20055276f, -0.11291450f, 0.13270083f, -0.09718381f, 0.09240621f, 0.14124285f, -0.19379000f, 
    0.17077082f, 0.15637545f, 0.01743208f, 0.12381951f, 0.03403952f, 0.11294350f, 0.17811157f, 0.06024957f, 
    0.01022356f, -0.09108447f, 0.18949914f, 0.26934180f, -0.00440528f, -0.07679241f, 0.01045067f, -0.00361711f, 
    -0.10778771f, -0.02694431f, -0.13669038f, -0.23869033f, -0.38199416f, 0.09056571f, -0.02540574f, 0.02049319f, 
    0.12839565f, -0.02380445f, 0.12590174f, 0.16337268f, 0.28272742f, 0.02330468f, 0.11887249f, -0.02785936f, 
    0.04772485f, 0.11300620f, 0.08734225f, 0.00079573f, 0.16447625f, 0.06191002f, -0.22567463f, -0.01261664f, 
    -0.01232952f, 0.05256194f, 0.07539856f, 0.00976897f, 0.10717309f, 0.22500312f, 0.02217391f, -0.45059779f, 
    -0.02663829f, 0.02874561f, -0.04397747f, 0.09988254f, 0.14098683f, 0.15177082f, -0.36679420f, 0.11360075f, 
    -0.04500940f, -0.09561735f, -0.24126850f, -0.02262431f, -0.03227881f, -0.05549372f, 0.11299627f, -0.54100144f, 
    -0.31889489f, -0.19844989f, -0.11856869f, -0.32197285f, -0.07497776f, -0.04362181f, -0.00354970f, -0.02111565f, 
    -0.29282886f, -0.18674317f, -0.10971177f, 0.05272907f, 0.33469450f, 0.08710270f, 0.19487287f, 0.11033907f, 
    -0.11054095f, -0.28295365f, 0.15133682f, -0.02930652f, -0.02570249f, -0.06995241f, -0.04050224f, 0.06983361f, 
    0.16559862f, -0.10305610f, 0.01231829f, -0.23821579f, 0.09025531f, -0.30862880f, -0.09463990f, -0.16283810f, 
    0.05784360f, -0.08710741f, -0.08578077f, -0.48925444f, -0.41891694f, 0.04879374f, -0.00640978f, 0.05917763f, 
    -0.08578704f, -0.17167525f, -0.09962577f, 0.12061584f, -0.06048655f, -0.11153930f, -0.29718721f, -0.14426681f, 
    0.21589239f, -0.04215005f, 0.05089287f, -0.06833515f, 0.08946928f, 0.18560548f, -0.33291960f, -0.41996399f, 
    0.03059785f, -0.01355937f, -0.14695312f, -0.02107646f, -0.04897240f, 0.10242101f, -0.35051847f, -0.32512984f, 
    -0.25664297f, 0.05756408f, 0.04739838f, 0.09107051f, 0.06464171f, -0.14470847f, 0.06475488f, -0.17351657f, 
    -0.30017295f, -0.37736350f, -0.04101162f, 0.03051664f, 0.03761278f, 0.10679481f, 0.01342776f, 0.00211369f, 
    -0.06181581f, -0.16845426f, -0.09300306f, 0.15237810f, 0.13782546f, 0.17974351f, 0.16663955f, -0.01068152f, 
    0.09080955f, -0.49643293f, -0.02748349f, -0.04923888f, 0.03652323f, -0.04818668f, -0.02943225f, 0.00560845f, 
    -0.25529015f, 0.05004929f, 0.22961864f, 0.37080917f, 0.15474512f, 0.10011519f, -0.03639914f, 0.04189109f, 
    -0.04886805f, 0.05590781f, 0.05647086f, -0.04130835f, -0.13237745f, -0.03862374f, -0.17825063f, -0.02316955f, 
    -0.14155452f, 0.20441908f, 0.07362360f, 0.23971397f, 0.15168482f, 0.10367772f, 0.00853984f, -0.15798567f, 
    -0.03105295f, 0.05811277f, 0.16985095f, 0.02656124f, 0.02108970f, 0.13825676f, -0.01091949f, -0.36656010f, 
    -0.03867232f, 0.15216550f, -0.04028400f, 0.03694505f, 0.01883996f, 0.01332204f, -0.18540937f, 0.06947371f, 
    0.18343009f, -0.22069412f, 0.00785705f, -0.18562731f, -0.01698747f, 0.03603596f, 0.13662364f, -0.00953054f, 
    0.22749671f, 0.08914781f, 0.00914664f, 0.21238603f, 0.08292352f, -0.04929322f, -0.04412878f, -0.00985865f, 
    -0.16217020f, 0.12779251f, -0.20535003f, -0.06730289f, -0.12044723f, 0.15652235f, -0.04976830f, 0.15963434f, 
    -0.16746010f, -0.01201269f, -0.01002148f, 0.03506612f, -0.04515743f, 0.00850562f, -0.04552348f, 0.08012515f, 
    0.12282850f, 0.06778911f, -0.05180455f, -0.14994980f, -0.01876657f, -0.06819037f, -0.14946853f, 0.06746303f, 
    0.01227359f, -0.06050768f, -0.11822323f, -0.01568354f, -0.29752806f, -0.20470269f, -0.29906711f, -0.01253300f, 
    0.04880339f, 0.03424735f, 0.08340926f, 0.03933041f, 0.19211304f, -0.12421896f, 0.13922589f, 0.09285481f, 
    -0.06631440f, 0.23764226f, 0.10466494f, -0.13552238f, 0.01910022f, 0.07672085f, 0.04461455f, 0.17916264f, 
    -0.12922053f, -0.06477776f, 0.09104722f, 0.03343935f, 0.03516689f, 0.09664904f, 0.13228567f, -0.05581464f, 
    0.03183020f, -0.18889742f, -0.05435495f, 0.10565779f, 0.05517332f, 0.03423122f, 0.02266229f, 0.09773285f, 
    0.03791567f, 0.09501759f, 0.00191207f, 0.11669453f, 0.15865733f, 0.09180210f, 0.26097652f, -0.07583791f, 
    0.19267061f, 0.19504200f, -0.18426369f, 0.07617051f, 0.07841331f, 0.08824234f, 0.04631470f, -0.05240519f, 
    -0.11849382f, 0.28572810f, 0.25116774f, 0.14347684f, -0.06631793f, -0.11362388f, -0.06152540f, 0.01647215f, 
    0.01289513f, 0.02471409f, 0.17251953f, 0.06164973f, -0.46000445f, 0.05781638f, -0.14947444f, -0.13981676f, 
    0.14580013f, -0.03777785f, 0.04122049f, -0.10631715f, -0.27825594f, -0.26264700f, -0.08231132f, -0.01792732f, 
    -0.03280113f, 0.07643507f, 0.10773873f, -0.11111922f, -0.46968746f, -0.12772109f, -0.12828617f, 0.00921782f, 
    0.07358542f, -0.02978434f, -0.08258259f, -0.02135404f, 0.11135896f, 0.05326461f, -0.24103196f, -0.65096003f, 
    0.00372814f, 0.05161348f, -0.05086882f, -0.01729446f, 0.01241114f, 0.06091020f, -0.02313127f, 0.14084135f, 
    -0.01060021f, -0.05577678f, 0.13982634f, 0.01333097f, -0.03285898f, -0.16516422f, -0.03344947f, 0.09558886f, 
    -0.31320143f, -0.94710785f, 0.24447209f, 0.06171671f, -0.06977915f, 0.08487816f, 0.10719725f, 0.03666879f, 
    -0.32218242f, -0.44588697f, -0.15092042f, 0.02307870f, 0.04350829f, 0.07400089f, 0.01655056f, -0.05253528f, 
    -0.08221160f, 0.12880759f, -0.25449181f, -0.18568847f, 0.02005155f, -0.02058036f, -0.08712250f, 0.10822835f, 
    -0.04702621f, -0.02789372f, 0.25557265f, -0.49523702f, 0.05130626f, -0.00498910f, -0.09457473f, 0.01395154f, 
    0.15065192f, 0.13040295f, 0.09498276f, -0.14911130f, -0.01303161f, 0.26892993f, 0.03748300f, -0.10329823f, 
    -0.01093822f, -0.02634601f, 0.08699068f, 0.00126871f, -0.00507427f, -0.14244188f, -0.16706255f, 0.01594752f, 
    0.04402538f, -0.03431730f, 0.17770487f, -0.12774076f, -0.01507872f, 0.06312753f, -0.25307181f, 0.08452894f, 
    0.01437691f, -0.04287108f, 0.06276912f, -0.09240035f, 0.01116683f, 0.15121701f, -0.48194423f, 0.23382173f, 
    0.29917553f, -0.08163099f, 0.10684890f, 0.04136696f, 0.11683311f, 0.10535287f, 0.00426526f, 0.36064062f, 
    -0.27624279f, -0.49607667f, -0.16188584f, -0.04890481f, 0.08806470f, 0.01025848f, -0.04758584f, 0.05651686f, 
    0.12062373f, 0.39444286f, 0.12311321f, -0.04412014f, 0.15433650f, -0.02409664f, 0.01725916f, 0.07728162f, 
    0.09417706f, -0.26588485f, -0.24303290f, -0.20442310f, -0.01378638f, -0.13225283f, -0.25248724f, 0.05739133f, 
    -0.00083227f, -0.03589330f, 0.04841266f, 0.00089113f, 0.01875491f, -0.05946979f, -0.05360936f, 0.19651705f, 
    0.13794746f, -0.04669027f, 0.13255772f, -0.01665856f, 0.24302395f, 0.06368244f, -0.06510697f, -0.13401055f, 
    -0.03453607f, 0.04978516f, -0.01563904f, 0.17110255f, 0.06716015f, 0.06752119f, -0.36193913f, 0.03308824f, 
    0.04758776f, 0.09020912f, -0.03729041f, 0.11516960f, 0.14806318f, 0.19088630f, 0.42120561f, -0.02349446f, 
    0.02578119f, 0.02076373f, 0.15534110f, -0.04026780f, -0.11827993f, -0.00556175f, -0.60093093f, -0.31379399f, 
    -0.45901254f, -0.04562689f, 0.03440718f, -0.06151375f, 0.00968091f, -0.04533875f, 0.02477132f, 0.04282854f, 
    -0.57138866f, -0.15844285f, 0.08415888f, -0.06863655f, 0.04121117f, 0.01704034f, -0.06142928f, 0.04890979f, 
    -0.05876039f, 0.04501788f, -0.01353123f, -0.05263218f, -0.02771720f, -0.06231019f, -0.01867114f, -0.07532701f, 
    -0.01775155f, -0.05594762f, 0.06188590f, -0.04812404f, -0.03540797f, 0.04425738f, -0.00822475f, 0.04607413f, 
    -0.07095264f, -0.08248474f, 0.03002344f, 0.07557105f, 0.01778770f, 0.01282190f, 0.07486416f, -0.02149697f, 
    0.07191102f, 0.03231476f, 0.00068385f, 0.01549980f, -0.08413919f, -0.02970041f, -0.02179852f, 0.04979219f, 
    -0.03942579f, 0.04765651f, -0.06543391f, 0.01531926f, -0.02495143f, -0.04239186f, -0.02699882f, -0.06530557f, 
    -0.06145156f, 0.00097844f, 0.04952372f, 0.03396640f, 0.07225287f, -0.02482764f, -0.08790527f, 0.05924848f, 
    -0.03384218f, -0.06908159f, -0.00986788f, -0.03805023f, -0.07640208f, -0.01157316f, 0.03857865f, 0.05406288f, 
    -0.01175657f, -0.02009257f, 0.00457398f, 0.04984163f, 0.03224667f, -0.04129224f, -0.07469015f, -0.04168411f, 
    0.02181801f, -0.01822438f, 0.07292766f, -0.02047238f, -0.07758899f, -0.03366535f, 0.04228485f, 0.04405756f, 
    -0.02303252f, 0.06222621f, -0.01382875f, -0.03553865f, -0.04613499f, -0.04608748f, 0.05668402f, -0.07545461f, 
    -0.05530819f, 0.05446197f, -0.07980018f, -0.03417471f, 0.04180406f, -0.06767944f, 0.02209887f, -0.04664982f, 
    0.00905676f, 0.01678150f, -0.07829530f, -0.07877734f, -0.03296306f, 0.02137798f, -0.01970326f, -0.07742471f, 
    -0.04385502f, 0.04568686f, -0.04620419f, -0.01521146f, -0.04828340f, 0.07249530f, -0.07325748f, -0.02421276f, 
    -0.05012412f, -0.02097755f, -0.05078421f, -0.00449577f, -0.08082710f, 0.02024116f, 0.02486251f, -0.06147135f, 
    0.03222203f, -0.04618128f, 0.03982315f, 0.02144236f, -0.03859553f, -0.00886522f, -0.02431911f, -0.05347637f, 
    -0.08937944f, -0.07204138f, 0.05489020f, 0.02523815f, -0.06164199f, -0.00198912f, -0.08074978f, 0.05022845f, 
    -0.02598319f, 0.04824876f, -0.02754034f, -0.04604637f, -0.04232594f, -0.00842866f, -0.04805085f, 0.06929560f, 
    0.05114329f, -0.04565733f, -0.00864143f, -0.03856207f, -0.05622084f, 0.03056754f, 0.02554544f, -0.04128608f, 
    -0.08059058f, -0.05342129f, 0.01355973f, 0.05270381f, -0.09268282f, 0.13724664f, -0.04528806f, -0.05239448f, 
    -0.05395359f, -0.06792331f, 0.01275164f, -0.19186334f, -0.01003311f, 0.14251272f, -0.13373792f, 0.16281907f, 
    -0.00346099f, 0.00714038f, 0.15376288f, -0.10236052f, -0.04839278f, 0.18611416f, 0.09566413f, 0.03397087f, 
    0.16443580f, 0.21917509f, 0.14431103f, -0.04901405f, -0.05472983f, 0.17385118f, 0.08167843f, 0.04836784f, 
    -0.09535733f, -0.26804453f, -0.12095685f, 0.12656443f, -0.28021172f, -0.05745316f, 0.10248508f, -0.03093615f, 
    0.17378376f, 0.10175443f, -0.32972535f, 0.20918769f, -0.11158577f, -0.09453893f, -0.14013091f, 0.08706832f, 
    0.05880917f, 0.05020953f, 0.02787672f, 0.06409941f, 0.06593414f, 0.09153429f, 0.02130864f, -0.01459393f, 
    0.06532344f, -0.05284837f, 0.00107879f, 0.19347998f, -0.11642478f, 0.15849803f, 0.14176078f, 0.08593828f, 
    0.03310264f, -0.36569005f, -0.06278008f, 0.23457575f, 0.04177212f, 0.16457178f, 0.14522776f, -0.16369243f, 
    -0.11906806f, -0.11366474f, 0.31146342f, -0.03446826f, 0.05538907f, 0.02902886f, 0.04243422f, 0.03959813f, 
    0.09129911f, -0.14460458f, 0.16135991f, -0.11848571f, -0.03311368f, 0.08085944f, -0.07515637f, 0.12359661f, 
    0.14918761f, -0.02066736f, 0.02633541f, 0.01188436f, -0.28867275f, 0.00469081f, 0.06363162f, 0.01384090f, 
    0.00002569f, -0.03317767f, -0.23237155f, 0.04949148f, 0.06178362f, -0.04611072f, -0.05904768f, 0.02798655f, 
    -0.05947270f, 0.14468627f, -0.05259633f, -0.15078057f, 0.40348727f, -0.14092524f, 0.08049726f, 0.17920591f, 
    0.25120533f, 0.16309972f, 0.08748064f, 0.16295697f, 0.03996527f, 0.00198850f, 0.09579176f, 0.03128407f, 
    0.01441899f, 0.13935690f, 0.09304070f, 0.04833156f, 0.10266075f, -0.06619943f, -0.41413304f, 0.01388778f, 
    -0.23773250f, -0.04863584f, 0.06332740f, -0.06314252f, -0.03652676f, -0.03137947f, -0.06154819f, 0.06231553f, 
    -0.37199476f, 0.03986548f, 0.02732955f, -0.07282891f, -0.02305475f, 0.14728205f, 0.02393209f, 0.01783476f, 
    0.00509192f, 0.34552011f, -0.14830333f, -0.00728977f, -0.00305338f, 0.00073057f, -0.11108354f, 0.09809575f, 
    0.11924244f, 0.14407188f, -0.06400612f, 0.08246689f, -0.02545607f, -0.11934347f, 0.04569686f, -0.07103062f, 
    -0.09340609f, -0.19554867f, 0.07745820f, -0.03295690f, -0.17477682f, -0.03238866f, -0.06357010f, 0.01734595f, 
    -0.03136158f, -0.04147903f, -0.18722887f, -0.07209069f, -0.22181369f, 0.00192247f, -0.13733843f, 0.07613418f, 
    0.15924135f, 0.03681132f, 0.31480938f, 0.21400130f, -0.10662390f, 0.14791127f, 0.10300343f, 0.02518165f, 
    0.02917748f, -0.02406609f, 0.10265665f, 0.16589944f, 0.04483311f, 0.11305701f, -0.08292225f, 0.02700443f, 
    -0.04135245f, -0.11286913f, 0.06306784f, 0.04906998f, 0.11999695f, 0.14063969f, -0.03895397f, -0.28683871f, 
    -0.03117266f, 0.01424651f, 0.05095242f, 0.06806302f, -0.05905252f, -0.01080805f, 0.03480120f, 0.25145036f, 
    -0.05094553f, -0.10567921f, -0.06883076f, 0.12293833f, -0.07829592f, 0.01944583f, 0.13359290f, 0.05636553f, 
    -0.03590013f, -0.02271412f, 0.01450895f, 0.12842605f, 0.13805656f, -0.07858028f, -0.07635336f, 0.11679019f, 
    -0.07379711f, -0.11000449f, -0.10573186f, -0.17505927f, 0.14618371f, 0.15236957f, -0.03836953f, -0.18725830f, 
    -0.00119390f, -0.27133551f, 0.07980074f, -0.08229206f, -0.12611265f, -0.01263632f, 0.10293163f, 0.19672783f, 
    -0.07372493f, 0.05534492f, -0.11504646f, 0.12070284f, -0.04763289f, -0.02860046f, -0.08658864f, 0.00505026f, 
    0.07917005f, 0.12382405f, 0.17721833f, -0.01571446f, -0.13724725f, 0.11880779f, -0.08263460f, -0.09632270f, 
    0.00617052f, -0.11355294f, 0.00424246f, -0.05806105f, -0.09885120f, -0.35513195f, 0.00320993f, 0.03684902f, 
    0.11474341f, 0.02094584f, 0.22849800f, 0.02174589f, 0.14736637f, -0.15076368f, 0.10681659f, 0.23482898f, 
    -0.01840623f, -0.04644709f, 0.04160233f, 0.05423650f, 0.06065618f, -0.07248469f, -0.02530730f, 0.13894735f, 
    0.31287518f, 0.18213814f, 0.08333052f, 0.25999123f, -0.11240956f, 0.13368373f, 0.12211794f, 0.05226875f, 
    0.05285852f, -0.02115045f, 0.05513232f, 0.03235738f, -0.01701676f, -0.04654045f, -0.08750420f, -0.00959962f, 
    -0.08287085f, -0.05436806f, 0.01961128f, -0.01299164f, -0.05469022f, 0.04806195f, -0.01760743f, -0.07587670f, 
    0.01132153f, -0.08902493f, 0.06789564f, 0.04312376f, -0.04125603f, -0.07832383f, -0.05512228f, 0.04426727f, 
    -0.00487610f, -0.06753072f, -0.00216318f, 0.00048481f, -0.01991826f, -0.07613879f, 0.02107986f, 0.06159424f, 
    -0.07854597f, -0.08039739f, -0.00521935f, 0.04966260f, -0.00123977f, -0.04332819f, 0.06475057f, -0.01777274f, 
    -0.08035034f, -0.02301810f, 0.04579326f, -0.01210136f, 0.02610661f, -0.03368196f, -0.00880098f, 0.07214152f, 
    -0.03458126f, 0.02833819f, -0.04123868f, -0.07936077f, -0.02567127f, -0.08470791f, 0.02955850f, -0.06768113f, 
    -0.00276155f, 0.05703293f, 0.05881609f, -0.07297162f, 0.03169758f, 0.02092493f, 0.02049722f, -0.05173089f, 
    -0.02660831f, -0.05609227f, -0.06021179f, 0.03554581f, -0.01644291f, -0.02388215f, -0.01406194f, 0.05612826f, 
    -0.01423196f, 0.05364503f, -0.08175571f, -0.00159609f, -0.06970658f, -0.04317851f, -0.06623228f, -0.05856526f, 
    -0.02756682f, -0.04257646f, 0.01203087f, -0.07762980f, 0.01843636f, 0.02108968f, 0.04765302f, 0.06362424f, 
    0.06027794f, 0.03681006f, -0.05359152f, 0.01650826f, -0.02269498f, -0.03530088f, 0.06015839f, -0.06450101f, 
    -0.07254300f, 0.06112394f, -0.06695122f, 0.03366901f, 0.00333436f, 0.01473836f, -0.01753987f, -0.03065225f, 
    0.01792899f, 0.04175907f, -0.03759251f, 0.03061936f, 0.03241232f, 0.02828885f, -0.02857484f, -0.03201757f, 
    -0.03857333f, -0.06306778f, -0.08762099f, -0.05000943f, -0.03999717f, 0.01673105f, 0.00432208f, 0.02486483f, 
    -0.02299143f, -0.06395116f, 0.02145614f, -0.05458247f, -0.08441737f, 0.06841281f, -0.04232147f, -0.01616657f, 
    -0.06601141f, -0.03307277f, -0.02766423f, -0.04594537f, -0.04748996f, -0.02752895f, -0.02256387f, 0.06673194f, 
    0.03981976f, -0.01023751f, -0.01667255f, 0.04589223f, -0.02421167f, -0.06167995f, -0.05368394f, -0.05035584f, 
    0.16677551f, 0.06018627f, -0.14370933f, 0.06952151f, -0.04299362f, 0.09919565f, -0.02028298f, 0.06996972f, 
    0.01162817f, -0.15826212f, 0.13030043f, -0.11650098f, -0.00298216f, 0.04714010f, 0.06506916f, 0.07060647f, 
    0.07211304f, 0.19369726f, -0.21421579f, 0.09299433f, 0.22651026f, -0.02144780f, 0.04221883f, 0.06392939f, 
    0.01898844f, 0.09512506f, 0.27492827f, -0.00956830f, 0.00161027f, 0.09223194f, -0.11287823f, -0.03177845f, 
    0.01732525f, -0.19830808f, 0.01439880f, -0.06734842f, 0.20526615f, 0.24680585f, -0.13578944f, 0.03756626f, 
    -0.02314579f, -0.00270249f, -0.09319553f, 0.02727208f, -0.10813393f, 0.28666088f, 0.18170670f, 0.07835799f, 
    0.03462606f, 0.07682535f, -0.09226100f, -0.03929204f, 0.04715009f, -0.12809613f, 0.06457502f, 0.14027862f, 
    -0.00027169f, -0.02070838f, -0.00202216f, -0.02481238f, 0.09230307f, 0.02800469f, -0.03347926f, 0.25035191f, 
    0.19638628f, -0.23284183f, 0.13422836f, 0.19520280f, -0.01648391f, -0.09194742f, -0.03284318f, 0.00951787f, 
    0.10809810f, -0.05653679f, -0.23410399f, 0.05928284f, 0.04878911f, 0.07683509f, -0.04369488f, -0.02133804f, 
    -0.04013204f, 0.12190530f, 0.15135930f, 0.13985197f, 0.02619977f, -0.04403522f, 0.00784169f, 0.03809246f, 
    0.01513198f, 0.15039375f, -0.28958270f, 0.07778531f, 0.16355506f, -0.02737009f, 0.02263826f, -0.15606526f, 
    -0.05306051f, 0.06421619f, -0.01413685f, -0.23910636f, -0.30663002f, -0.16898769f, 0.04006838f, -0.01477822f, 
    -0.01653970f, -0.02099298f, -0.11027393f, -0.09536537f, -0.11799720f, -0.19714685f, -0.07769983f, 0.10582290f, 
    -0.09956161f, -0.18275119f, 0.14515375f, 0.01627186f, 0.13601786f, -0.08845618f, -0.27449813f, 0.05342634f, 
    0.07077387f, -0.07472499f, -0.18135493f, 0.10935604f, -0.06859478f, -0.09409909f, 0.05106634f, 0.22186431f, 
    -0.34794730f, 0.05663512f, -0.08778317f, -0.00616293f, 0.02845971f, 0.11591760f, 0.00079631f, -0.61174613f, 
    -0.43008050f, -0.02794485f, -0.06299180f, 0.01843964f, 0.15638596f, -0.02248438f, 0.21020104f, -0.02104426f, 
    -0.09137687f, -0.27043784f, 0.11388312f, -0.15937901f, 0.23936778f, 0.19608745f, -0.01868655f, 0.02111993f, 
    0.01725658f, -0.17130305f, -0.05727126f, 0.04364128f, -0.18224652f, 0.01714559f, 0.02685711f, 0.05058545f, 
    -0.03278080f, 0.04217247f, 0.07460640f, 0.15229075f, 0.03381374f, -0.07427861f, -0.04772760f, -0.20302260f, 
    0.03645287f, -0.02625808f, -0.05391390f, -0.50158846f, -0.13851719f, -0.02619343f, -0.02622531f, -0.09891262f, 
    -0.17266242f, -0.00231020f, -0.01514520f, -0.01525696f, 0.25940892f, -0.30224431f, -0.12200265f, 0.13451132f, 
    -0.02257668f, 0.11998516f, -0.00505494f, -0.04233058f, 0.19784766f, -0.05738436f, 0.24154593f, 0.35609946f, 
    0.03865406f, -0.00603186f, -0.07234362f, -0.10929116f, 0.05321902f, -0.00838350f, -0.06704225f, 0.37210509f, 
    -0.13354464f, 0.00243606f, -0.15125820f, 0.02435889f, 0.01750158f, -0.02883838f, 0.02123487f, -0.50011587f, 
    0.01095211f, 0.20774446f, -0.03273381f, 0.09161900f, 0.12027548f, -0.06157821f, 0.01163662f, 0.04010532f, 
    -0.10818925f, 0.33099842f, 0.18799630f, 0.09470829f, 0.01200611f, 0.04297294f, 0.09044784f, -0.02681021f, 
    0.01301066f, -0.14535773f, 0.26939198f, 0.21605743f, -0.06264735f, -0.04378975f, -0.15805787f, 0.07339273f, 
    -0.02239521f, -0.08977040f, 0.11826349f, 0.02358074f, 0.16259034f, -0.14924410f, 0.09867714f, -0.19866450f, 
    0.15417123f, 0.08425518f, 0.06068378f, -0.42508188f, -0.04925013f, -0.07844371f, 0.16449185f, 0.22859214f, 
    -0.25170454f, 0.06019231f, -0.14763767f, 0.12537755f, -0.05238758f, -0.11488380f, 0.15849534f, -0.07618097f, 
    -0.03535178f, 0.04600286f, 0.10797894f, 0.18976624f, -0.02937072f, -0.25604132f, -0.42859685f, 0.04881378f, 
    0.08229392f, -0.13578163f, 0.22881244f, 0.08877941f, 0.05290562f, 0.09608302f, -0.11715236f, -0.24475159f, 
    0.34756282f, -0.14411885f, -0.00417548f, -0.15072110f, 0.06282774f, -0.05732346f, 0.07819039f, 0.30071801f, 
    0.12210459f, 0.12229379f, -0.02548346f, -0.02864254f, 0.00142787f, -0.08388796f, -0.03013027f, 0.05493627f, 
    -0.02582372f, 0.05039166f, -0.24467194f, -0.06690490f, 0.05850365f, 0.05533065f, -0.10748754f, 0.18665390f, 
    0.09382213f, 0.05602561f, -0.06426082f, -0.21889707f, 0.12335413f, -0.15160556f, -0.01679503f, -0.13646489f, 
    -0.03613681f, -0.06710649f, -0.10208520f, 0.02625582f, 0.12309449f, -0.08748607f, -0.13323760f, 0.03326519f, 
    0.01695362f, -0.03604452f, 0.07911108f, 0.05264963f, -0.06137378f, -0.05095054f, 0.08880661f, -0.07431763f, 
    -0.04751639f, -0.04444746f, 0.12720244f, 0.13525259f, 0.07530014f, 0.29454708f, -0.09266631f, 0.03595753f, 
    -0.01783528f, 0.12098709f, -0.19025415f, -0.03538680f, 0.11142110f, 0.24736361f, 0.17648378f, -0.00396875f, 
    0.13154371f, -0.02847607f, -0.14211887f, -0.08888704f, -0.16126947f, 0.08125522f, 0.11514635f, -0.11202313f, 
    0.13285308f, -0.04833111f, 0.16308174f, -0.00849027f, -0.22744128f, 0.01981462f, 0.08877757f, 0.29712251f, 
    -0.01323564f, -0.16578715f, 0.04353985f, -0.06558658f, -0.13534690f, 0.05178144f, -0.09804700f, -0.01264792f, 
    0.19979954f, 0.14394769f, -0.04516194f, -0.05300384f, -0.04179930f, -0.06222697f, -0.05177801f, 0.06438317f, 
    -0.05658993f, 0.22019003f, 0.32637626f, -0.11259820f, 0.05215032f, 0.00319133f, -0.13731395f, 0.05748002f, 
    -0.00999865f, -0.13305193f, -0.15445957f, -0.09073994f, -0.11329627f, 0.29145616f, -0.08731911f, -0.05760393f, 
    0.02511808f, -0.08355618f, 0.06550210f, 0.24795485f, -0.01471807f, -0.22396757f, -0.01596803f, 0.08055536f, 
    -0.01774758f, 0.14030014f, -0.03698331f, 0.05829843f, -0.41809699f, -0.11658286f, 0.01084031f, 0.22498973f, 
    -0.06325927f, 0.18664850f, 0.04599124f, 0.24369007f, 0.00428365f, -0.03870925f, 0.34885293f, -0.21838702f, 
    -0.07929044f, 0.05604881f, 0.07406479f, 0.21361555f, 0.07144517f, -0.02129294f, 0.13298610f, 0.16752456f, 
    0.08323082f, 0.08241816f, -0.04250415f, -0.13368766f, 0.10221248f, -0.05194500f, 0.12590799f, -0.02257732f, 
    0.20586838f, 0.01296582f, -0.17922074f, -0.13944392f, 0.10354871f, -0.03729742f, -0.01620504f, -0.07224907f, 
    0.02117356f, -0.03882094f, -0.08439933f, -0.08640938f, -0.07613858f, 0.03409534f, -0.00269309f, 0.01289496f, 
    0.03062106f, 0.01645803f, 0.04806319f, -0.04814105f, -0.01335375f, -0.10445243f, -0.06769950f, -0.03733643f, 
    -0.00305433f, -0.01034303f, -0.08524929f, 0.01421946f, -0.00452106f, 0.00811376f, -0.06906748f, 0.04371197f, 
    0.03592827f, -0.00810227f, 0.02337532f, -0.09483402f, -0.04255080f, 0.04246181f, 0.01997485f, 0.05471580f, 
    -0.03086262f, -0.06398243f, -0.00427477f, 0.03298018f, -0.06555217f, -0.02878432f, -0.06327987f, -0.01618507f, 
    -0.06049348f, 0.06590164f, 0.06958435f, 0.06285238f, -0.03692853f, 0.04819971f, -0.00715326f, -0.02838630f, 
    -0.01959153f, 0.01678135f, 0.05003110f, -0.04572562f, -0.08055126f, -0.07851950f, 0.05477707f, -0.00920542f, 
    -0.03024327f, -0.06033027f, -0.00584683f, 0.00837522f, -0.09509290f, -0.03741682f, -0.07020934f, -0.09031790f, 
    0.03408926f, -0.03435355f, 0.00556491f, -0.01878744f, 0.06551770f, 0.02734068f, 0.00346151f, 0.04427668f, 
    -0.07018191f, 0.05377098f, -0.09195549f, -0.07368962f, 0.02594619f, -0.04393446f, -0.04288669f, -0.06674156f, 
    0.07200185f, 0.06065279f, -0.06372119f, -0.08904724f, -0.10720494f, -0.09599856f, -0.08798375f, -0.05756091f, 
    -0.06329396f, -0.09110463f, -0.09141072f, 0.05460774f, -0.07348461f, -0.07614669f, -0.04876093f, -0.04433163f, 
    -0.04760712f, -0.03909105f, 0.00721065f, 0.03106408f, -0.02321475f, -0.09617617f, -0.08658894f, -0.05170006f, 
    -0.06062904f, -0.01091017f, -0.00493536f, 0.03540868f, -0.01412022f, 0.05169810f, -0.07701258f, 0.02495468f, 
    -0.02454343f, 0.02598869f, -0.04720189f, 0.00187495f, -0.06339557f, -0.04817083f, -0.00174787f, 0.02496442f, 
    0.05105164f, -0.00198246f, -0.09899914f, -0.03076675f, 0.00735528f, 0.04332244f, -0.07843149f, -0.02235067f, 
    -0.01218699f, -0.04389235f, 0.05528272f, 0.04756440f, -0.06609508f, 0.02469890f, 0.06176762f, 0.03609111f, 
    -0.02117211f, 0.03755386f, -0.07966246f, -0.00809512f, -0.03657430f, 0.01376510f, 0.05410423f, 0.02397906f, 
    -0.24924222f, -0.05604994f, -0.11749326f, -0.02929135f, 0.09324360f, 0.05500311f, 0.11281004f, -0.00797169f, 
    0.07947815f, 0.20655029f, 0.10795560f, 0.11569034f, 0.04845919f, 0.03211178f, 0.09761310f, -0.05988774f, 
    0.14524309f, -0.10244510f, 0.10057358f, -0.00586714f, 0.19553025f, 0.09858256f, 0.04000924f, 0.10665829f, 
    0.04463584f, -0.02823499f, -0.16389067f, 0.40681893f, 0.22970949f, -0.08678452f, -0.07297494f, -0.01819660f, 
    0.03268326f, 0.03136261f, 0.05911128f, 0.05966992f, -0.01366811f, -0.36986405f, -0.04456930f, 0.03264916f, 
    -0.16050884f, 0.14085886f, 0.09715319f, 0.06705204f, -0.07075176f, -0.08904426f, -0.26566681f, -0.33439493f, 
    0.09164433f, -0.07551228f, -0.10556979f, 0.07711268f, -0.01564215f, 0.17481543f, 0.26628232f, -0.10867658f, 
    0.02899372f, 0.17046317f, -0.14228103f, -0.00116063f, -0.12188127f, 0.12348360f, -0.07924867f, -0.56422216f, 
    -0.06799694f, -0.44698480f, 0.02375417f, 0.02606345f, -0.04309182f, 0.13775021f, -0.20225544f, 0.00964444f, 
    -0.13419434f, -0.11322389f, 0.05770202f, -0.08882853f, -0.04761335f, 0.03773460f, -0.05411046f, 0.03864139f, 
    0.02852555f, 0.20300074f, 0.27166978f, 0.04929163f, -0.05722684f, 0.10143527f, -0.28139728f, 0.02261452f, 
    -0.05871820f, -0.12374020f, 0.11557427f, 0.10177578f, 0.35909939f, -0.11686692f, -0.11153853f, -0.10869056f, 
    0.00254284f, 0.04609167f, -0.03296768f, -0.00486218f, 0.28184453f, 0.09692062f, -0.19147143f, 0.02450787f, 
    -0.14876775f, -0.10219164f, 0.07748270f, 0.27389306f, 0.01389080f, 0.12123583f, 0.11199151f, 0.16962452f, 
    0.05769653f, 0.14923081f, 0.09548759f, 0.08500345f, -0.04566089f, 0.12816459f, -0.21520552f, 0.36560526f, 
    0.09080184f, -0.00911845f, -0.00577415f, -0.01791352f, -0.01125481f, -0.04270668f, -0.14184892f, -0.19293664f, 
    -0.07265642f, 0.05851157f, -0.10011088f, -0.04218554f, -0.01211881f, 0.06183757f, 0.07610777f, 0.26319581f, 
    0.14298192f, -0.13114043f, -0.10094541f, 0.05083891f, 0.06483210f, 0.03519946f, 0.04824401f, -0.19990924f, 
    0.07272960f, 0.12843032f, -0.43915790f, 0.07457857f, -0.09141015f, -0.05666311f, 0.04675508f, -0.01449736f, 
    -0.01785600f, 0.16725771f, -0.01337253f, -0.11544740f, 0.16107807f, 0.04227201f, 0.00535964f, 0.03192746f, 
    0.05619101f, 0.01005570f, -0.08886227f, -0.10535979f, -0.04195543f, 0.07894054f, 0.15839615f, -0.00438120f, 
    0.15008388f, -0.16610244f, 0.03430032f, -0.07735427f, -0.13820663f, 0.05701338f, -0.30874977f, -0.03582583f, 
    -0.01029739f, -0.01287720f, -0.13261853f, 0.02311983f, -0.20449875f, 0.06353251f, -0.01642144f, 0.06709360f, 
    -0.11738975f, -0.02041882f, 0.00288050f, -0.08899658f, 0.04907803f, -0.11596581f, -0.03282652f, 0.03211538f, 
    -0.01846264f, 0.03327693f, -0.02606524f, -0.00493800f, -0.02809787f, 0.07870848f, -0.13604017f, -0.06573084f, 
    0.25965720f, 0.04690077f, -0.08432390f, -0.03036373f, 0.12689787f, 0.05978076f, 0.04554101f, -0.14025450f, 
    -0.31358060f, -0.50808436f, 0.08272394f, -0.09009780f, 0.11531065f, 0.03765478f, -0.00360309f, -0.08292031f, 
    -0.02657301f, 0.13713430f, 0.23785317f, -0.03401373f, -0.06004731f, 0.08055963f, -0.01864872f, 0.04211436f, 
    0.12071255f, 0.27793303f, 0.35346368f, 0.23680991f, -0.08818240f, -0.14244041f, -0.01741986f, 0.16026139f, 
    0.08958665f, -0.00605023f, 0.23177947f, 0.08593393f, 0.01279010f, -0.07123768f, -0.08519437f, -0.06974908f, 
    0.08636254f, 0.00433117f, 0.17326061f, -0.17423519f, -0.19771352f, -0.00870478f, -0.15222774f, 0.01315083f, 
    0.05926799f, 0.14380473f, -0.11582177f, -0.02109051f, -0.42992961f, -0.06567343f, -0.11417463f, 0.14294913f, 
    0.10164112f, -0.00319503f, 0.04370957f, -0.01736425f, -0.01460135f, 0.17763603f, 0.01161225f, 0.12064958f, 
    -0.14091103f, -0.02345894f, -0.03885507f, 0.15530050f, -0.07524211f, -0.05176825f, 0.19567351f, 0.04701037f, 
    -0.12796745f, -0.21278685f, -0.11052644f, 0.06817427f, 0.10742076f, 0.04389009f, 0.06585026f, -0.42855248f, 
    0.13967575f, -0.65091169f, 0.10858578f, -0.09516548f, 0.16028064f, -0.10055631f, -0.03007166f, 0.02478126f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02084561f, 0.06555633f, 0.16490354f, 0.16328683f, -0.06120717f, 0.26522553f, 0.07123937f, 0.10686046f, 
    -0.06400251f, 0.06137612f, 0.05338734f, 0.11432049f, -0.13205142f, -0.05998624f, 0.00229449f, 0.03570287f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07945266f, 0.12134744f, 0.20385997f, 0.44327545f, -0.31346768f, 0.20435309f, -0.01299124f, -0.13185586f, 
    -0.08033314f, -0.20425214f, 0.55918580f, -0.24623342f, -0.03954807f, -0.03189018f, -0.00562288f, 0.01421816f, 
    0.27645731f, -0.10308917f, -0.45179316f, 0.16377059f, -0.45544732f, 0.43426296f, -0.12480432f, 0.07599687f, 
    0.10227983f, 0.19669700f, -0.42458165f, -0.13987926f, 0.35996565f, -0.21036878f, -0.01097717f, -0.06762934f, 
    0.06002017f, -0.32261261f, -0.14561588f, 0.16050664f, 0.29643545f, -0.10604461f, -0.18081179f, -0.14986274f, 
    0.29613462f, 0.05407509f, -0.25210559f, -0.03650417f, 0.40469474f, -0.12399580f, 0.16995686f, 0.20832619f, 
    0.22754131f, 0.21474785f, -0.14954640f, 0.22949979f, 0.49117446f, -0.35004377f, -0.18936658f, 0.25596392f, 
    -0.17463535f, -0.19038390f, -0.16857170f, 0.01747186f, -0.04680684f, -0.08681449f, -0.07753394f, -0.31759518f, 
    -0.04845193f, 0.29676685f, 0.30561575f, -0.15772106f, 0.52119040f, 0.19069889f, -0.05297807f, 0.22334294f, 
    -0.21713060f, -0.03164506f, -0.07621216f, -0.25444666f, -0.06354961f, -0.17309749f, 0.23080403f, 0.23753974f, 
    0.14263846f, 0.28771919f, -0.33896852f, -0.30631298f, 0.07134418f, -0.15638721f, -0.19659007f, 0.09295629f, 
    0.05356069f, -0.09084629f, -0.02902462f, 0.35407254f, 0.14592575f, -0.02759064f, -0.11191341f, -0.31111509f, 
    0.02479066f, -0.46436226f, 0.25721797f, 0.06086968f, -0.30723360f, 0.40338549f, 0.21908815f, 0.17358287f, 
    0.19882573f, 0.11519966f, -0.05694788f, -0.25938058f, 0.14802837f, 0.10026216f, -0.40652871f, -0.02424031f, 
    0.32653514f, -0.29403344f, 0.08991622f, -0.26179150f, 0.08386172f, -0.13952194f, -0.18514627f, 0.21116127f, 
    -0.07486209f, -0.13859740f, -0.02190080f, 0.10202060f, -0.18707050f, 0.16151753f, -0.28548867f, 0.10958552f, 
    -0.29228991f, 0.00353648f, -0.24008319f, 0.13938046f, 0.36162531f, 0.00850241f, 0.02910204f, 0.22125940f, 
    -0.00425112f, 0.07703459f, -0.00432359f, 0.11155334f, 0.39325023f, -0.01579066f, 0.25449860f, -0.41931647f, 
    0.01079948f, -0.06732340f, -0.12496530f, 0.01948344f, -0.08852115f, 0.25071317f, -0.18049839f, 0.19304435f, 
    -0.04075540f, -0.13022177f, -0.16512439f, 0.09618893f, -0.00971643f, 0.14014104f, 0.09655412f, -0.41156629f, 
    -0.09583369f, 0.19099569f, 0.01410070f, -0.03262438f, 0.39232883f, -0.00631928f, 0.08878800f, -0.05394311f, 
    0.08441483f, -0.22510332f, -0.01606135f, 0.01890866f, 0.01678278f, -0.13635308f, 0.30534092f, 0.13763686f, 
    0.11362862f, 0.11559781f, -0.22812681f, -0.15203629f, -0.31927365f, -0.07682461f, 0.08248845f, -0.25333530f, 
    -0.01863959f, 0.00064114f, -0.31936255f, -0.00631860f, -0.20867060f, -0.09720349f, 0.38319004f, 0.63353181f, 
    0.24496002f, -0.18964939f, 0.09702659f, -0.01808742f, 0.19582853f, 0.50425297f, -0.09666906f, 0.11881801f, 
    -0.20306459f, -0.11675132f, -0.01806343f, 0.26070452f, 0.02219957f, 0.15633604f, -0.42976645f, -0.13574061f, 
    0.35309607f, 0.12858637f, -0.31293571f, -0.20772414f, -0.16375497f, -0.13485073f, 0.00704506f, -0.29958007f, 
    0.13028039f, 0.08033998f, 0.18430333f, 0.04130489f, 0.16581430f, -0.10645685f, 0.06486378f, 0.24261147f, 
    0.09417590f, -0.03531848f, 0.30270067f, -0.31881207f, -0.43015239f, 0.13780524f, 0.15650265f, -0.05288670f, 
    0.11261070f, 0.01785690f, 0.18685514f, -0.17227946f, -0.26792282f, -0.05715628f, 0.07206781f, -0.07393971f, 
    -0.30787364f, 0.29620191f, 0.23222077f, -0.50345784f, 0.06252859f, -0.26481301f, 0.00167000f, -0.19573820f, 
    0.23910944f, 0.21558991f, 0.31396940f, 0.32247579f, 0.07012742f, -0.01314298f, 0.00060070f, -0.15602013f, 
    0.14340636f, 0.22957845f, -0.27644795f, -0.12411779f, -0.79661077f, 0.33108911f, -0.00221675f, 0.17088801f, 
    -0.11118258f, 0.09802061f, -0.20243044f, -0.15186094f, -0.08656493f, 0.13296048f, 0.21308854f, -0.06037380f, 
    0.13066675f, 0.07781028f, -0.05147706f, 0.17565323f, -0.50568360f, -0.30685499f, 0.12489858f, 0.33768725f, 
    0.22464992f, 0.12775764f, 0.19121592f, -0.33129036f, -0.70766461f, -0.08173065f, 0.15296225f, -0.32430178f, 
    0.25852239f, 0.17569654f, 0.17806555f, -0.23706935f, -0.23449370f, 0.00459956f, -0.05673356f, -0.01363191f, 
    -0.30268186f, -0.24906528f, 0.04254283f, 0.36741823f, -0.13515572f, -0.02810002f, -0.14459428f, 0.13616736f, 
    -0.01243758f, -0.17826906f, 0.41530865f, -0.68058556f, 0.20810843f, 0.18509771f, -0.23640743f, 0.01676930f, 
    0.13459808f, -0.23241037f, -0.19605924f, 0.10054187f, -0.12842819f, -0.00012775f, -0.43123987f, -0.21505231f, 
    0.30371574f, -0.05571688f, 0.16164705f, 0.04163240f, 0.42276698f, -0.09648560f, 0.22821337f, -0.07312482f, 
    -0.03839263f, 0.13028800f, 0.40433136f, -0.18366097f, -0.07265753f, -0.02088359f, 0.01410660f, 0.33011821f, 
    -0.35178629f, 0.05689802f, -0.04313491f, -0.28397208f, 0.36251724f, -0.11487968f, 0.17252631f, -0.12946276f, 
    -0.00338212f, 0.09221014f, 0.42540741f, -0.05479449f, -0.00201760f, 0.23648588f, -0.07174219f, 0.10854754f, 
    -0.02650960f, -0.19564049f, 0.14021662f, -0.53492910f, 0.22633015f, -0.04330501f, 0.09949576f, -0.12729099f, 
    0.31586432f, -0.12009990f, -0.08707173f, 0.12927106f, 0.12273226f, -0.08055050f, -0.11561764f, 0.37911016f, 
    -0.15902588f, 0.01893714f, -0.07562737f, -0.11389367f, 0.08450053f, -0.08310764f, 0.08069739f, 0.03883438f, 
    -0.10644068f, -0.17181486f, 0.09923429f, -0.22344232f, -0.17416787f, -0.17653750f, -0.03433229f, 0.12506290f, 
    -0.10497528f, 0.35760716f, 0.09023403f, 0.15111279f, 0.16297078f, 0.02377515f, 0.18995278f, 0.14829722f, 
    0.09039525f, 0.14060023f, 0.05760239f, -0.15392059f, 0.15810080f, 0.03060672f, -0.06152854f, -0.15527365f, 
    -0.08056743f, -0.04455870f, 0.14002582f, -0.75968093f, 0.23574369f, 0.28780100f, -0.17165354f, 0.31857780f, 
    -0.26271147f, 0.08805490f, 0.15987384f, -0.16162741f, 0.18644840f, -0.14502688f, -0.41813487f, 0.15116437f, 
    -0.06717977f, -0.40103179f, 0.18868595f, 0.14105783f, 0.50731295f, -0.40468061f, 0.02387931f, 0.07987303f, 
    -0.06250405f, -0.20569271f, 0.09979603f, 0.07600893f, 0.42509171f, 0.14770466f, 0.07891888f, 0.43427515f, 
    0.01269038f, -0.30566117f, -0.09420343f, 0.18985227f, 0.28261280f, 0.11883155f, -0.18137643f, 0.01940201f, 
    0.23064241f, -0.23553932f, -0.00992301f, 0.01040971f, -0.23019271f, -0.20091841f, -0.01724737f, 0.36630818f, 
    -0.25162566f, -0.35574120f, 0.23090343f, -0.16407479f, -0.03671289f, 0.09564386f, -0.19757068f, 0.04148298f, 
    0.08953632f, 0.08040494f, -0.29957661f, 0.39027274f, 0.28198951f, 0.01958753f, 0.19315894f, 0.00054676f, 
    -0.35216677f, -0.09587836f, -0.07845718f, -0.31878629f, 0.06069194f, 0.29624948f, -0.15025248f, 0.26691306f, 
    0.26519001f, 0.20901096f, 0.05001968f, 0.51490384f, -0.14715691f, 0.21220563f, -0.04468369f, -0.18906347f, 
    -0.13455944f, -0.07208335f, -0.22391233f, -0.12442208f, -0.22723535f, -0.19084229f, 0.19310355f, -0.21654816f, 
    -0.26038992f, -0.24404898f, 0.00326207f, 0.09877309f, -0.20883635f, 0.19877687f, 0.10769374f, 0.20134304f, 
    0.03049064f, -0.37682098f, 0.26512745f, -0.37380344f, 0.15136303f, -0.06506836f, -0.23222548f, 0.05702246f, 
    0.05713134f, 0.00748971f, 0.08632307f, 0.10352033f, -0.22137919f, 0.21614428f, -0.06551113f, 0.30719444f, 
    0.03939584f, -0.22248469f, -0.18785578f, -0.39586869f, -0.12915260f, 0.44534355f, -0.09335538f, 0.24161188f, 
    0.22602881f, -0.01022852f, -0.29124552f, 0.25889650f, 0.01255197f, -0.09771823f, -0.01768752f, 0.12556581f, 
    -0.20883809f, 0.26368669f, 0.27417386f, 0.06512290f, 0.36065599f, -0.21809959f, 0.00244655f, 0.19620329f, 
    -0.04045504f, 0.11280550f, 0.16541927f, 0.18351516f, 0.01855887f, 0.07556640f, 0.14337327f, -0.39359817f, 
    0.25801969f, 0.39397162f, -0.04129283f, 0.09448203f, 0.13481499f, -0.09196603f, -0.02428401f, -0.16490801f, 
    -0.24046478f, -0.22412427f, 0.04742138f, 0.14130284f, 0.31022519f, -0.08493094f, -0.23751828f, -0.29609844f, 
    0.06995603f, -0.33752429f, 0.23931235f, -0.52317518f, -0.20936811f, 0.30277419f, 0.03517765f, -0.15147062f, 
    0.22134395f, 0.05803776f, -0.11662687f, 0.42254508f, -0.08470879f, 0.19236013f, -0.28129488f, -0.22414534f, 
    -0.12015045f, -0.44198343f, 0.25556225f, -0.65117061f, -0.19937423f, 0.26350814f, -0.14367339f, -0.30362433f, 
    0.27693650f, -0.03514889f, -0.03949556f, 0.21512792f, 0.26243994f, 0.06465519f, 0.13352001f, 0.39967838f, 
    0.23662257f, -0.23498929f, 0.25203964f, 0.03896428f, -0.25527382f, -0.35756260f, -0.15151046f, 0.17885374f, 
    0.05006263f, -0.03679717f, 0.55255598f, -0.07498463f, -0.39557385f, 0.19160883f, -0.09418010f, 0.30201542f, 
    0.06348405f, -0.20046619f, -0.49689561f, 0.17653984f, -0.64668220f, -0.19324194f, 0.13107750f, -0.14228733f, 
    -0.16088367f, 0.19897282f, -0.49479052f, 0.04002507f, -0.12212876f, -0.18215576f, 0.25923380f, -0.20430890f, 
    -0.25930366f, 0.23409989f, 0.28961614f, 0.20644000f, 0.11255986f, 0.26602435f, -0.03279192f, 0.31245923f, 
    -0.04296402f, -0.19942021f, -0.14085166f, -0.09061071f, -0.22417375f, -0.13341987f, -0.16042280f, -0.03562396f, 
    0.12105852f, -0.24865787f, 0.32748422f, 0.60606754f, -0.23345032f, -0.24536836f, 0.02582502f, 0.30857408f, 
    -0.17895535f, -0.21929199f, -0.06743133f, -0.13203201f, 0.12835665f, -0.12767521f, -0.04312000f, -0.23935936f, 
    0.07499112f, -0.30697834f, 0.38633502f, -0.82383746f, -0.08000655f, 0.26967055f, -0.01417503f, 0.17494322f, 
    -0.18230593f, -0.11289257f, 0.07252771f, -0.00123610f, -0.04060035f, -0.26018414f, -0.41159400f, 0.14427255f, 
    0.01132290f, 0.23479600f, -0.11017141f, 0.08126824f, -0.17725013f, 0.36333314f, 0.18148188f, 0.18845741f, 
    -0.11089240f, 0.12809323f, -0.09209627f, 0.25516793f, 0.00529405f, -0.20342238f, -0.26450208f, -0.31676793f, 
    0.15177351f, 0.07249200f, 0.17811626f, 0.13360655f, 0.24057955f, -0.31600711f, -0.04980835f, -0.09158321f, 
    0.22848676f, -0.01987466f, -0.21829808f, -0.22246784f, 0.33380616f, -0.13918024f, -0.13216558f, -0.41405025f, 
    0.14554782f, 0.00830761f, -0.32947722f, -0.04162146f, 0.02205121f, 0.45596465f, 0.09179893f, 0.18792111f, 
    -0.06230345f, 0.24589863f, 0.34738398f, -0.42439321f, -0.09583035f, -0.21521488f, 0.14841121f, 0.47392380f, 
    -0.02928869f, -0.00016312f, 0.25814396f, 0.32510695f, -0.07642344f, -0.89817357f, -0.22707227f, 0.11396713f, 
    0.03398445f, -0.22583660f, -0.17502938f, -0.19259474f, 0.39669013f, 0.19636169f, -0.07093126f, -0.35400975f, 
    0.26223177f, -0.10324063f, -0.05751693f, -0.27562284f, -0.05847223f, -0.35186711f, 0.12085527f, 0.06799307f, 
    0.19196181f, -0.05950043f, -0.19633414f, 0.10092133f, -0.16590326f, 0.11822468f, -0.32287109f, -0.40643069f, 
    -0.24009849f, -0.14124544f, 0.12248188f, 0.18573903f, -0.06201172f, -0.35349160f, -0.04649223f, 0.01046444f, 
    0.33151779f, 0.00568439f, -0.34787369f, -0.03671809f, 0.47408330f, 0.17932878f, 0.01592157f, 0.17221315f, 
    -0.03067482f, -0.05767942f, 0.04715884f, -0.05486865f, 0.16003656f, -0.16622405f, -0.09173197f, -0.18928885f, 
    -0.05041140f, -0.14568242f, 0.34911412f, -0.09033576f, 0.31684616f, -0.00979364f, 0.41262707f, 0.18122353f, 
    -0.24199767f, 0.24284473f, 0.20283076f, 0.17875752f, -0.01840727f, -0.29804572f, -0.13939999f, 0.01746541f, 
    0.04610381f, -0.00983080f, 0.20990631f, -0.09301848f, 0.39532739f, -0.19333832f, 0.21244490f, -0.14993945f, 
    0.02842554f, 0.07652188f, 0.29950672f, -0.03325263f, 0.00870114f, -0.11704542f, 0.05014885f, 0.40618289f, 
    0.01497846f, 0.02388129f, 0.02439406f, -0.00778827f, -0.38259310f, 0.00961116f, -0.52093732f, -0.04520025f, 
    0.11194026f, 0.10394632f, 0.04552807f, 0.14722836f, -0.12348162f, 0.23618442f, -0.14981550f, 0.26902899f, 
    -0.22440858f, -0.07690106f, -0.30868980f, 0.03924986f, 0.12111808f, -0.07074622f, -0.03638989f, -0.27304760f, 
    -0.23775901f, -0.10352510f, 0.28526026f, -0.39791450f, -0.47181857f, -0.43660414f, 0.15332249f, 0.22516723f, 
    0.24541378f, -0.05686337f, 0.07101047f, -0.13657613f, 0.23596263f, 0.09022552f, -0.25085184f, -0.03381986f, 
    0.07137198f, -0.26076788f, -0.33901131f, 0.29591420f, -0.39124349f, 0.24750575f, 0.16520724f, -0.03238353f, 
    0.28524888f, 0.16878110f, 0.16326861f, -0.15515237f, -0.23074369f, 0.17518130f, 0.00979991f, 0.34371769f, 
    0.16778739f, 0.08939349f, 0.17852566f, -0.03635258f, 0.14570758f, -0.40878087f, -0.24334797f, -0.26294333f, 
    0.28201273f, -0.07080668f, -0.05152255f, -0.16771851f, -0.03809555f, 0.11154348f, 0.25153735f, 0.19652006f, 
    -0.04990429f, -0.08572732f, -0.23111512f, 0.21701135f, -0.18119004f, 0.24143055f, 0.22576591f, -0.15379107f, 
    -0.22400789f, 0.24433762f, 0.06592148f, -0.23744488f, 0.21577688f, -0.22364548f, -0.22517103f, -0.20414850f, 
    -0.10153574f, -0.02001011f, -0.24407443f, -0.18964025f, 0.03269914f, -0.02694321f, 0.16938341f, -0.19546574f, 
    -0.12233296f, -0.14464772f, -0.02350202f, 0.06173423f, 0.09774137f, 0.23007154f, -0.00916305f, -0.18394542f, 
    -0.14226106f, 0.41283855f, -0.13204142f, 0.14105181f, 0.44978681f, 0.04323758f, 0.11437809f, -0.00057334f, 
    -0.13525313f, 0.13999929f, -0.25152802f, -0.23098019f, 0.52448225f, -0.23110303f, 0.23780911f, 0.16981094f, 
    0.24678986f, 0.09686977f, 0.32888252f, -0.24588944f, 0.12990214f, 0.04074801f, -0.16496497f, -0.17610912f, 
    -0.08434460f, -0.10962787f, 0.30139893f, -0.24908085f, 0.18881571f, -0.11608154f, 0.04560621f, -0.03057344f, 
    0.24892896f, -0.16929761f, 0.24775797f, -0.18500249f, -0.25433156f, 0.40681952f, -0.01584261f, 0.15182313f, 
    -0.00385180f, -0.12909546f, 0.31070039f, -0.29830769f, -0.14782478f, -0.04945950f, -0.25048363f, -0.20850322f, 
    0.37095580f, 0.06853876f, -0.03142226f, 0.26704791f, 0.22254317f, 0.04719363f, 0.12467376f, -0.34877077f, 
    0.21521531f, -0.15143050f, 0.24344684f, -0.23994212f, 0.25213176f, -0.22005190f, -0.25143048f, 0.20684364f, 
    0.01011328f, 0.17864290f, 0.19287832f, 0.28916448f, -0.58827579f, 0.12844448f, 0.03502459f, -0.04883584f, 
    -0.28127646f, 0.08472615f, 0.20059912f, 0.17144059f, -0.10360034f, 0.15159665f, 0.12775743f, -0.45114025f, 
    0.01032111f, 0.10942857f, 0.18636844f, -0.23468760f, -0.06778067f, -0.54756904f, 0.04633841f, -0.10955437f, 
    0.22270085f, 0.02374063f, 0.15518352f, 0.30454710f, 0.11374729f, 0.00625811f, 0.18269888f, 0.03710047f, 
    -0.28414196f, -0.34429297f, 0.12277337f, -0.26029003f, -0.20064521f, 0.48389253f, 0.05454804f, 0.01588294f, 
    0.38240489f, 0.14825025f, -0.18941504f, 0.17866157f, 0.20228307f, 0.16415149f, -0.34224528f, -0.21105906f, 
    -0.01579282f, 0.11124788f, 0.34518123f, 0.27072135f, 0.32497880f, -0.17654510f, -0.23704261f, -0.08263458f, 
    0.06046679f, -0.06725079f, 0.12303492f, -0.24888483f, -0.09621295f, 0.21172349f, 0.09605454f, 0.33682549f, 
    -0.19308448f, -0.26875082f, -0.04261175f, 0.03810500f, 0.15435895f, 0.31628653f, -0.11805850f, 0.01878984f, 
    0.25603020f, -0.01044375f, -0.36498964f, -0.00424423f, 0.30160549f, 0.05555106f, 0.09999319f, 0.01657210f, 
    -0.22718306f, 0.30077758f, 0.19421066f, 0.03080415f, -0.32641393f, -0.19945049f, -0.04789560f, 0.31545413f, 
    -0.09902380f, 0.01550478f, -0.26546022f, 0.48988083f, 0.04595730f, -0.17834568f, 0.09449141f, -0.36807001f, 
    -0.18993685f, -0.48107702f, -0.08423618f, -0.21153168f, 0.07583869f, -0.23401225f, 0.23094197f, 0.18615118f, 
    0.21986748f, 0.20244732f, -0.22510982f, 0.27848592f, 0.31093439f, 0.20358381f, 0.18452136f, 0.08060199f, 
    -0.04494478f, 0.23234838f, -0.01141294f, -0.21320380f, 0.05998148f, -0.10641744f, -0.08239999f, -0.01582763f, 
    -0.17105399f, 0.20288730f, 0.05412133f, -0.09052664f, -0.22304213f, -0.08721021f, -0.17459396f, -0.24985380f, 
    0.10507477f, -0.20881015f, 0.09770341f, -0.43196288f, 0.50452513f, 0.30586457f, 0.13436377f, 0.05232522f, 
    -0.26763028f, -0.18169254f, 0.20342426f, -0.09465861f, 0.02286938f, 0.00599951f, -0.45085263f, -0.01252004f, 
    0.35350785f, 0.30997941f, 0.29874682f, 0.29858419f, 0.06279242f, 0.07362624f, -0.25422272f, -0.23461169f, 
    -0.31054553f, 0.04613174f, 0.09031221f, 0.37180820f, -0.23613392f, -0.15376364f, -0.16446759f, -0.27042446f, 
    0.25461736f, 0.10419661f, -0.09571920f, 0.27091250f, 0.38156870f, -0.21996093f, 0.20598446f, 0.17231886f, 
    -0.29190555f, -0.22383386f, 0.06492876f, 0.01565691f, -0.05333647f, 0.20639847f, -0.22033291f, -0.08009417f, 
    -0.06119245f, -0.40718451f, -0.14000787f, -0.00035648f, 0.07878351f, 0.02954471f, 0.16589727f, 0.31927171f, 
    0.28845486f, 0.11515877f, -0.34045991f, 0.22156832f, 0.08766664f, -0.14407104f, -0.07602117f, -0.57024527f, 
    -0.17671868f, 0.12772773f, 0.05593140f, -0.28394914f, 0.41024241f, 0.05302398f, -0.03365639f, -0.40513822f, 
    0.19900258f, -0.13710919f, 0.36820233f, -0.07606066f, 0.09583870f, -0.08890731f, -0.17732663f, -0.21762235f, 
    0.01187552f, -0.14736296f, 0.05360970f, -0.03691126f, -0.15516174f, -0.05895494f, -0.08741826f, 0.01254704f, 
    -0.22600527f, -0.13760245f, -0.16863577f, -0.17773663f, 0.28405941f, -0.02902442f, 0.17485580f, -0.32279626f, 
    0.00781909f, -0.10051166f, 0.08540899f, -0.15127578f, -0.30530643f, -0.18472414f, -0.21203545f, -0.02034091f, 
    0.15018922f, -0.14455467f, -0.18129492f, -0.22432223f, -0.10976287f, 0.21605030f, -0.10962655f, 0.10117668f, 
    0.30171615f, -0.16161965f, -0.23227087f, 0.18298145f, 0.34852529f, -0.31819159f, -0.06501281f, 0.11647675f, 
    0.18696097f, -0.15861574f, 0.36031079f, 0.10804301f, -0.04506550f, 0.06708428f, -0.10882334f, -0.19084464f, 
    -0.04709493f, 0.04951439f, 0.32204792f, 0.56294137f, -0.21434017f, -0.18769088f, -0.23834324f, 0.30202976f, 
    -0.31688249f, -0.13277090f, 0.29244515f, -0.18239509f, 0.22328542f, -0.08177775f, -0.20543239f, -0.18248396f, 
    0.38621616f, -0.26828429f, -0.10967004f, 0.00056970f, -0.07672065f, -0.23559937f, -0.11961445f, -0.19123289f, 
    -0.10563286f, 0.14501745f, -0.21744260f, 0.30279681f, -0.11486338f, -0.06537789f, -0.10662707f, -0.22298014f, 
    -0.18221143f, 0.18659900f, 0.19453377f, -0.17380641f, -0.28700912f, 0.41918865f, 0.11766861f, -0.17819715f, 
    0.36387405f, 0.16092190f, -0.22072607f, 0.05890258f, -0.04622598f, -0.12007578f, -0.05843596f, 0.23791629f, 
    0.20458554f, 0.46881509f, -0.23817949f, -0.24218425f, 0.34904501f, -0.19082780f, 0.22031364f, 0.07238592f, 
    0.20354947f, 0.19635838f, -0.14770576f, -0.11825148f, 0.33419704f, 0.24283941f, -0.17040451f, 0.15340841f, 
    -0.18189839f, 0.12253610f, 0.34908816f, -1.12997425f, -0.36510131f, -0.08164439f, -0.20488010f, 0.05937802f, 
    -0.20113483f, -0.07070535f, 0.28959814f, -0.00070048f, 0.16172166f, -0.09330694f, -0.36431503f, 0.34232575f, 
    0.15718515f, -0.24153569f, -0.19417380f, 0.21747625f, -0.30870989f, -0.13440098f, 0.09183834f, 0.08234039f, 
    -0.22184215f, 0.25512969f, 0.19884235f, 0.38492358f, -0.21512580f, -0.08156384f, 0.17375532f, -0.02732530f, 
    -0.20073955f, -0.05323712f, -0.20558767f, 0.18450095f, 0.43163556f, 0.53957641f, -0.20548609f, -0.18132246f, 
    0.01481907f, -0.00370359f, 0.16738304f, -0.19054924f, 0.35918468f, -0.16327184f, -0.00974698f, -0.07603569f, 
    0.22014061f, 0.22851291f, -0.28457618f, -0.23402828f, -0.28311211f, -0.06337070f, -0.19366880f, 0.14755227f, 
    0.09756229f, -0.09746784f, 0.17067081f, -0.07203758f, 0.01650523f, -0.06065206f, 0.05242632f, -0.41952372f, 
    0.21150687f, 0.01559398f, -0.28665093f, 0.30882657f, -0.24365592f, -0.42440346f, -0.22432107f, 0.00681538f, 
    0.31515768f, -0.20299558f, 0.24597700f, -0.31802815f, 0.25688061f, -0.00876468f, -0.16690205f, -0.10411326f, 
    -0.21014327f, -0.09433600f, -0.32832563f, 0.05192123f, -0.11341204f, 0.34119889f, 0.01912174f, -0.16631909f, 
    -0.02274068f, 0.21275797f, -0.31142431f, 0.49833971f, -0.29877177f, -0.19685884f, 0.40791881f, -0.02327309f, 
    0.41370383f, 0.16087548f, -0.16681711f, -0.08463565f, -0.23717940f, -0.14689901f, -0.12797019f, 0.05525248f, 
    -0.39223087f, -0.05076420f, 0.40549490f, 0.25145847f, 0.16478288f, 0.05488171f, 0.02796717f, -0.29984361f, 
    0.16219997f, -0.34698859f, -0.02813517f, 0.42384019f, 0.14525123f, 0.05139469f, -0.22859757f, 0.29144818f, 
    -0.19937669f, 0.13079679f, -0.06519790f, -0.29097307f, 0.26697898f, -0.06258547f, -0.18298581f, -0.13210326f, 
    -0.06219876f, 0.10271668f, 0.34925213f, -0.17839721f, 0.37602252f, -0.18223990f, 0.15579590f, -0.12412123f, 
    -0.16089062f, -0.22011024f, -0.05698483f, 0.26821867f, 0.05985443f, -0.10371404f, 0.09055438f, 0.44475913f, 
    0.17475924f, -0.26102182f, 0.05920107f, -0.20014386f, 0.03176604f, -0.16675413f, 0.22240138f, 0.16821863f, 
    -0.12840083f, -0.21014446f, -0.12773763f, 0.43815827f, -0.25128716f, 0.02607382f, -0.09611148f, 0.12474392f, 
    0.00216669f, 0.00330700f, -0.18560085f, -0.22245589f, -0.23059647f, -0.01632199f, -0.00554747f, -0.17517017f, 
    0.14773555f, 0.10956165f, -0.10727552f, -0.27844620f, 0.14548372f, -0.18588388f, -0.04070032f, -0.25749809f, 
    -0.24593897f, -0.00454301f, 0.16387959f, 0.21060289f, -0.01666932f, -0.07663465f, 0.06310213f, 0.00600349f, 
    -0.12061310f, 0.07384017f, -0.33897132f, -0.12856299f, 0.21647683f, -0.01573536f, 0.17278475f, 0.27602661f, 
    0.20363577f, -0.02656552f, 0.35906097f, 0.25736436f, -0.29338738f, -0.39858299f, 0.14841239f, -0.01373040f, 
    0.05188301f, 0.14512421f, 0.33013916f, -0.27686521f, 0.20973945f, -0.00878652f, -0.19075003f, 0.03673810f, 
    -0.08303615f, -0.56070137f, -0.14605206f, 0.27531052f, -0.58205944f, -0.72973150f, 0.15743586f, 0.17171808f, 
    0.00913001f, 0.01980853f, 0.09976288f, 0.39543942f, 0.37511706f, -0.06595788f, -0.05887172f, 0.19201243f, 
    -0.10229582f, -0.00189111f, -0.04114450f, -0.06996823f, -0.04201647f, 0.00806905f, 0.22945413f, -0.04128569f, 
    -0.08047622f, 0.24581891f, 0.00131549f, 0.00253608f, 0.02240875f, 0.15720777f, -0.05279116f, -0.03602203f, 
    0.26654506f, -0.30101460f, -0.00663034f, 0.56025630f, 0.02470175f, -0.36148185f, -0.11694973f, 0.29603818f, 
    -0.29616588f, 0.12414337f, 0.19051166f, 0.29914552f, -0.17251341f, -0.21967661f, -0.08649296f, -0.22308981f, 
    0.28743231f, -0.50486785f, -0.12778160f, -0.06031568f, -0.23391359f, 0.38454080f, 0.07998037f, 0.26512995f, 
    0.08173443f, -0.18329552f, -0.06796742f, 0.01602960f, 0.13433506f, 0.03535302f, -0.38884029f, -0.30850413f, 
    0.32201618f, 0.27020514f, -0.29767627f, -0.48621637f, 0.14751317f, 0.03702320f, -0.13968341f, 0.07348667f, 
    0.10198412f, -0.07142355f, 0.09376010f, 0.22555302f, -0.12686001f, 0.02186166f, -0.35428685f, 0.01798398f, 
    0.36478639f, -0.13823180f, 0.27003512f, 0.08020385f, -0.38967046f, -0.09003289f, 0.02668199f, 0.15144895f, 
    -0.22353967f, -0.05163062f, -0.15170111f, -0.07969335f, 0.24765627f, 0.11139936f, -0.40750605f, -0.31280673f, 
    -0.16431728f, -0.04037899f, 0.09045949f, -0.00579685f, -0.22767980f, 0.00457609f, 0.08127859f, -0.17102696f, 
    0.16434813f, 0.10851154f, -0.04076103f, -0.07956114f, -0.03416130f, -0.09627855f, -0.13138001f, -0.12540367f, 
    -0.22968708f, -0.06198026f, -0.00357260f, 0.20417915f, 0.10814908f, -0.84403419f, -0.01310390f, -0.35925707f, 
    0.34333780f, 0.02767679f, 0.02771894f, 0.29043660f, 0.22627836f, -0.22516948f, 0.08658673f, 0.13608876f, 
    -0.17952377f, -0.18586586f, -0.02464283f, 0.08241909f, 0.07929223f, -0.00334525f, 0.21572135f, 0.02940661f, 
    0.26267391f, 0.04169905f, -0.11550029f, -0.14541323f, -0.21693371f, -0.16296031f, -0.11897244f, 0.11107317f, 
    -0.16769665f, 0.26116747f, 0.24354012f, 0.08128443f, -0.17732500f, -0.04398255f, -0.07962123f, 0.37318420f, 
    -0.13003764f, -0.14323582f, -0.04338891f, -0.04335327f, -0.13847326f, -0.07537013f, 0.29633856f, -0.36801741f, 
    -0.04802549f, 0.06414984f, -0.25673825f, 0.08607434f, 0.18222363f, 0.04569970f, 0.01795620f, -0.16933753f, 
    -0.04902463f, -0.09638533f, 0.00031480f, 0.13246658f, -0.04260109f, -0.15214510f, -0.10426086f, -0.22153457f, 
    0.18497095f, 0.20141548f, 0.11521871f, -0.24361379f, 0.18428500f, 0.28663173f, -0.05443157f, 0.20372182f, 
    -0.35208642f, 0.25224897f, 0.32711968f, -0.03410898f, -0.01308390f, 0.15555672f, -0.50097239f, -0.23006614f, 
    -0.23318857f, -0.64669025f, -0.12148166f, 0.03348219f, -0.30719796f, -0.47476467f, 0.08283567f, 0.19287708f, 
    0.15494058f, -0.14500660f, 0.07300752f, 0.32627890f, 0.08870827f, -0.25199535f, 0.32408354f, -0.02461375f, 
    0.14716659f, 0.15811437f, 0.03896647f, -0.00708908f, -0.16053629f, 0.31255546f, -0.01802967f, 0.38665619f, 
    -0.31846774f, 0.22574091f, -0.31317300f, 0.27811843f, 0.03032538f, 0.06610268f, -0.26593149f, -0.10212530f, 
    -0.26671284f, -0.12160612f, -0.06618732f, -0.58216578f, 0.12214881f, -0.41132215f, -0.07858327f, -0.31503242f, 
    0.15020515f, 0.14133126f, 0.26638886f, 0.40603855f, 0.26397845f, -0.26745895f, -0.01982912f, 0.04883574f, 
    -0.12155060f, 0.23304871f, 0.30579051f, -0.04129180f, 0.36133891f, -0.08601522f, 0.18267199f, -0.03330935f, 
    -0.14734310f, -0.23179168f, 0.26005316f, -0.10685270f, -0.20878729f, -0.14118610f, -0.09998411f, 0.36982056f, 
    0.17587751f, -0.33928201f, 0.18717042f, -0.51556969f, -0.02133336f, 0.21436493f, 0.00939292f, -0.19954696f, 
    0.09581650f, -0.00823198f, -0.20003513f, 0.25996312f, 0.00998080f, 0.04875295f, 0.03433233f, 0.21090426f, 
    -0.17202614f, -0.31997648f, 0.30137107f, 0.20669359f, -0.39592856f, -0.30895048f, -0.23066020f, 0.40562397f, 
    -0.02733819f, 0.11626053f, -0.04263097f, -0.05763911f, 0.14458910f, 0.16235974f, -0.11763684f, 0.46682835f, 
    0.13098381f, 0.19297679f, 0.27466655f, -0.37203792f, 0.34588021f, -0.27410415f, -0.24334022f, -0.18194160f, 
    0.10709615f, 0.16622816f, 0.09903017f, 0.24783106f, 0.24937722f, -0.24758421f, -0.04900407f, 0.34287909f, 
    -0.00177825f, 0.01696710f, 0.21333224f, -0.38747033f, -0.56379569f, -0.36439753f, 0.01227031f, 0.03922818f, 
    0.20222609f, 0.12490955f, 0.28413567f, 0.29132572f, -0.34715548f, 0.08124157f, 0.06005375f, 0.20165825f, 
    0.02546388f, -0.49961686f, -0.01410909f, 0.11211782f, -0.03709960f, -0.05853528f, -0.23642112f, 0.24913315f, 
    -0.00327788f, 0.05024058f, -0.23116143f, 0.43665528f, 0.10711160f, 0.08679848f, -0.14087063f, -0.18847251f, 
    -0.09004580f, 0.42541611f, 0.25614980f, -0.39475891f, 0.26964432f, 0.24193922f, 0.06692658f, -0.22211736f, 
    -0.04883877f, -0.02567986f, 0.29704297f, 0.30763853f, 0.15585463f, -0.09388772f, -0.32727998f, -0.03358600f, 
    0.22615720f, 0.14733994f, -0.23581672f, -0.18073499f, 0.06271117f, -0.29363218f, 0.24163836f, -0.22414640f, 
    0.07697393f, -0.16931583f, -0.06960099f, 0.31822824f, 0.27846134f, -0.09350306f, 0.35182875f, -0.07584586f, 
    -0.21862145f, -0.09130990f, 0.08655425f, -0.14087410f, -0.32110316f, 0.33057749f, 0.18885234f, 0.03235059f, 
    0.37633741f, 0.03182068f, -0.25499961f, 0.17245848f, 0.18049689f, 0.16667715f, -0.33864409f, -0.43238640f, 
    0.31061316f, 0.12607811f, 0.06802356f, -0.27220827f, 0.16456547f, 0.05182288f, 0.01148258f, 0.00491290f, 
    -0.19709189f, 0.22525488f, 0.37378052f, -0.07582264f, -0.42626181f, -0.19791380f, 0.06372105f, -0.42449468f, 
    -0.06022637f, 0.07576113f, -0.13228127f, -0.14373507f, 0.39794832f, -0.34152576f, -0.20003405f, 0.20954348f, 
    0.21382464f, -0.13096645f, -0.05233902f, -0.22539666f, 0.01058037f, 0.24891166f, 0.18233304f, 0.31860816f, 
    0.10473892f, -0.45502189f, 0.33026618f, -0.51547182f, 0.31990573f, -0.02341153f, -0.00610873f, 0.05186494f, 
    0.18242148f, 0.22345644f, -0.14628464f, 0.38526243f, -0.28570002f, 0.09941354f, -0.16910155f, 0.10306149f, 
    -0.31264991f, -0.09393683f, 0.38460660f, 0.40172258f, -0.07803494f, 0.05049097f, 0.02324159f, 0.30776393f, 
    -0.13552818f, -0.03417370f, -0.11975615f, -0.02833690f, 0.01554826f, 0.13043259f, -0.11368635f, 0.27450442f, 
    0.05476713f, 0.22104372f, 0.37507829f, -0.11615869f, 0.24224904f, -0.19297893f, -0.10146454f, 0.14309822f, 
    -0.12294404f, -0.16535965f, 0.24969701f, 0.12448749f, -0.00028162f, 0.08566841f, -0.18010120f, 0.12284473f, 
    0.17356338f, -0.23893891f, -0.30293182f, -0.08629086f, 0.44922131f, -0.32712278f, 0.22971156f, 0.06965540f, 
    -0.10836446f, 0.18978903f, -0.20376182f, 0.43878922f, -0.07862296f, 0.14687301f, 0.26519197f, 0.13956727f, 
    0.14139156f, -0.09921087f, 0.24383497f, 0.49505940f, 0.16852057f, -0.16863054f, -0.00764409f, 0.23859373f, 
    -0.08103751f, -0.04365759f, 0.23833646f, -0.39721245f, 0.08025997f, 0.01274949f, -0.44663918f, 0.13976668f, 
    -0.16762611f, -0.11855837f, -0.20246789f, -0.42200488f, 0.33065501f, -0.04518261f, 0.21803842f, -0.01089271f, 
    0.19878232f, 0.11258313f, -0.03167268f, 0.44886038f, -0.02754619f, -0.02153232f, 0.28545946f, 0.31907761f, 
    0.21794088f, -0.30846387f, 0.16682978f, 0.29230535f, -0.61254221f, -0.56263053f, 0.05203059f, 0.03528326f, 
    0.11212598f, -0.14741820f, 0.36306366f, -0.22098893f, 0.16710171f, 0.15771455f, 0.05267209f, -0.14117125f, 
    -0.26492351f, -0.07317890f, 0.32171598f, -0.73574907f, -0.09213896f, -0.48999330f, -0.00769523f, 0.17930546f, 
    0.29574329f, 0.20051149f, 0.14905302f, 0.04013520f, 0.18670453f, -0.15133514f, -0.40297738f, -0.10694952f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.38798285f, -0.54408652f, 0.21325798f, 0.29621226f, -0.36641729f, 0.16975082f, 0.19108228f, 0.56228888f, 
    -0.16014528f, 0.29202518f, -0.38554642f, -0.17521413f, 0.50670218f, -0.14616859f, 0.54860091f, -0.22094026f, 
    -0.13274154f, -0.31825972f, 0.40771729f, 0.37991065f, -0.21604988f, 0.14002778f, 0.07519891f, 0.18351977f, 
    -0.50566494f, 0.30988616f, 0.08626455f, 0.20847736f, -0.06285307f, 0.26462200f, -0.04918332f, 0.30990374f, 
    0.37828091f, -0.36972991f, 0.33630607f, 0.43539825f, 0.21280682f, 0.14883669f, 0.36247754f, 0.10653282f, 
    0.12143766f, -0.16574563f, 0.41697785f, -0.22601515f, -0.32973334f, -0.26368591f, -0.02802772f, 0.34609628f, 
    -0.16835517f, -0.48983979f, 0.30120528f, 0.22253558f, -0.17092040f, 0.39003250f, -0.09712298f, -0.14725216f, 
    -0.20482749f, 0.00842588f, 0.09699078f, 0.20940764f, 0.04726167f, 0.29832926f, 0.03991071f, 0.04277157f, 
    -0.23575535f, 0.39247271f, 0.00178010f, 0.31881729f, -0.06072208f, -0.34563360f, 0.00103470f, 0.22436622f, 
    0.11292964f, -0.15350892f, -0.02034036f, -0.27371737f, -0.24662317f, -0.10055739f, -0.15656227f, 0.20675394f, 
    -0.23778105f, 0.19028883f, 0.13652422f, -0.05923623f, -0.10235396f, 0.46585038f, -0.06697879f, 0.06429043f, 
    0.42535523f, 0.08910999f, 0.31763574f, -0.00883362f, 0.22570227f, 0.30457720f, 0.22481519f, 0.06609408f, 
    0.02790455f, 0.30600294f, -0.08443747f, 0.18517946f, -0.22793075f, -0.24722023f, 0.18290649f, -0.26783279f, 
    -0.06785035f, -0.21390225f, 0.37905768f, 0.19235916f, -0.06150791f, -0.21710056f, 0.41308451f, 0.04298954f, 
    0.03074322f, 0.24815007f, 0.45696193f, -0.17246276f, -0.13494658f, 0.29972824f, 0.28645557f, -0.17306992f, 
    -0.04481150f, 0.42647022f, -0.01389694f, 0.03323564f, 0.03342921f, 0.12041914f, -0.05164988f, -0.30337411f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06724822f, -0.00376222f, 0.06437654f, -0.09033167f, -0.00921329f, -0.02934552f, -0.07023090f, -0.01895310f, 
    -0.03557659f, -0.09351677f, 0.00567793f, -0.09855550f, 0.05004170f, -0.00101225f, 0.07718726f, -0.09272584f, 
    -0.08424196f, -0.06572974f, -0.03763760f, 0.06108656f, -0.09393480f, -0.02218184f, 0.04151710f, 0.03002912f, 
    -0.06261636f, 0.06017359f, -0.07629391f, 0.04275100f, -0.04662589f, -0.01348754f, -0.03916414f, 0.06883503f, 
    -0.07270109f, 0.05891844f, -0.11013463f, 0.02217758f, -0.07405443f, -0.10528832f, -0.03762769f, -0.06023951f, 
    -0.03533638f, -0.00226788f, 0.01191004f, -0.08869575f, 0.02478467f, -0.05022116f, 0.08527556f, 0.05714877f, 
    -0.10045169f, -0.00317004f, -0.04486439f, -0.08948395f, -0.06469472f, -0.04558020f, -0.09692007f, -0.00617316f, 
    -0.04702532f, 0.04025804f, -0.01262004f, -0.08067177f, -0.03201884f, -0.03992366f, -0.00460890f, -0.04739309f, 
    -0.04184431f, -0.04741283f, 0.00240322f, -0.01854820f, 0.00240843f, -0.02597704f, 0.02413916f, -0.03621095f, 
    -0.05847424f, -0.01376487f, -0.05907057f, -0.02942931f, 0.01455069f, 0.04641915f, 0.03939144f, -0.00373728f, 
    0.02815927f, -0.02946248f, -0.01043952f, 0.03948278f, -0.03072039f, -0.09107153f, -0.03270921f, -0.10006846f, 
    -0.02223457f, -0.08482710f, -0.05537659f, -0.01309552f, -0.09639888f, 0.03411167f, 0.00561135f, 0.01415437f, 
    0.03141157f, 0.00191014f, 0.05883334f, -0.06313074f, 0.08323802f, 0.03461146f, 0.01085779f, 0.00128559f, 
    0.00373539f, 0.06546750f, -0.01082487f, 0.05317934f, -0.05911088f, 0.02393316f, -0.08850013f, -0.02593473f, 
    -0.03710549f, -0.00803321f, 0.03196298f, -0.06021548f, -0.04754093f, 0.01326559f, -0.04583043f, 0.00886853f, 
    0.01085850f, -0.02709240f, -0.00607100f, 0.06355465f, -0.05462215f, 0.03151099f, -0.03603072f, -0.06197396f, 
    0.30013338f, -0.02310585f, -0.12739784f, -0.30695286f, 0.02164276f, -0.17313975f, -0.06353652f, 0.07902221f, 
    -0.20665607f, -0.08571386f, -0.07386145f, -0.07007577f, -0.06241843f, 0.19929008f, 0.30361378f, 0.34979799f, 
    0.06397367f, -0.22403049f, 0.16504775f, 0.00169332f, 0.05631995f, -0.11125317f, 0.12829173f, 0.04751440f, 
    -0.02505137f, 0.00648626f, -0.05353757f, -0.06633957f, -0.12960069f, -0.08358246f, -0.03963666f, 0.19329944f, 
    -0.09342019f, -0.14010744f, 0.02096393f, 0.14624742f, 0.23175810f, 0.20284545f, 0.18778080f, -0.02870054f, 
    -0.02667947f, -0.12567972f, 0.00594415f, -0.32547823f, 0.04921339f, -0.05659179f, 0.26073360f, 0.10560036f, 
    0.16527626f, 0.13431163f, -0.01146177f, 0.02942649f, 0.21523102f, 0.03319176f, 0.14786008f, 0.01134576f, 
    0.02672267f, -0.01530576f, 0.40753549f, 0.24144402f, 0.20404780f, 0.16656449f, 0.17071024f, -0.23461759f, 
    -0.11598424f, -0.15198947f, -0.02178188f, 0.07129077f, -0.03652181f, -0.43088940f, 0.19647749f, -0.24265729f, 
    -0.28942192f, -0.07371863f, -0.09197539f, 0.00154377f, -0.09209671f, -0.00579615f, 0.28405958f, 0.04767405f, 
    0.05824212f, 0.16769660f, -0.01690795f, -0.37499490f, 0.02959670f, 0.03402908f, -0.10929043f, 0.12886335f, 
    -0.13961963f, 0.10714722f, 0.02319033f, 0.01709500f, -0.12281550f, 0.13400427f, -0.01445465f, -0.06773173f, 
    -0.20242737f, -0.10556581f, -0.06682025f, 0.18877648f, -0.09763227f, 0.11285924f, 0.02978966f, -0.10325865f, 
    0.08577249f, -0.13986790f, 0.13692969f, -0.00613754f, 0.09170904f, -0.14232408f, 0.08976839f, 0.16915204f, 
    0.15449195f, 0.34344050f, -0.01036564f, 0.15865402f, 0.04963782f, -0.05734588f, 0.16202725f, -0.07366671f, 
    0.03947869f, 0.01401607f, 0.14994287f, -0.30892256f, 0.03802314f, 0.05730022f, 0.31947860f, 0.17875707f, 
    0.10234716f, -0.33845574f, 0.16619076f, 0.08073381f, -0.06284215f, -0.08540038f, 0.11649455f, 0.28474894f, 
    -0.19210811f, -0.06808901f, -0.31130669f, -0.50480872f, 0.20075899f, -0.02536844f, 0.05728516f, -0.27758074f, 
    -0.28388482f, -0.13422634f, -0.04243495f, -0.10031600f, 0.16825803f, -0.33699664f, -0.03495944f, 0.02177701f, 
    -0.29852036f, 0.07746994f, 0.02559954f, 0.04959252f, -0.00526136f, -0.11557278f, 0.07179506f, 0.14080088f, 
    0.15885742f, -0.17121603f, -0.02084312f, -0.02602952f, 0.04577891f, 0.20739627f, -0.36645848f, -0.06666324f, 
    0.03388809f, 0.08560592f, 0.01151695f, 0.12120543f, -0.16539790f, -0.18238929f, 0.02242414f, 0.01848538f, 
    -0.16088070f, -0.20155443f, 0.05544306f, 0.00689287f, -0.49807453f, 0.07926202f, -0.02631219f, -0.02303578f, 
    -0.06036102f, -0.42498255f, 0.02962994f, 0.20326924f, 0.23588127f, -0.34474537f, 0.06994054f, -0.10359927f, 
    -0.06749687f, 0.12947945f, -0.49718368f, 0.19646159f, 0.07156621f, 0.11057612f, -0.05913395f, 0.13021533f, 
    0.13424350f, -0.27503151f, 0.02650780f, 0.18544798f, 0.08878285f, 0.10036673f, -0.11526139f, -0.24212548f, 
    0.01987008f, -0.22030222f, -0.06745098f, -0.56537247f, -0.06052299f, 0.27080008f, -0.12561443f, 0.07989497f, 
    0.38001904f, 0.03305439f, 0.15588306f, -0.03697130f, -0.04059361f, 0.12187256f, 0.06654987f, 0.01798877f, 
    0.20177567f, 0.33498344f, 0.10820227f, -0.00779985f, -0.00722264f, -0.38867125f, -0.11360244f, -0.57839906f, 
    -0.06270879f, 0.12721388f, 0.12063836f, 0.01109155f, -0.28232554f, -0.02821095f, 0.12767988f, 0.04596175f, 
    0.01680709f, 0.00319471f, 0.09313899f, -0.17581326f, -0.20158327f, -0.20140916f, 0.15346810f, -0.00639076f, 
    0.02783035f, -0.00621355f, 0.05446651f, 0.17406434f, 0.18067038f, 0.04224866f, 0.01584165f, -0.23852377f, 
    0.28163251f, -0.22338535f, -0.16262613f, 0.06174180f, -0.12077107f, -0.17124633f, 0.07405395f, 0.11314443f, 
    -0.00435818f, 0.14998971f, -0.10832401f, 0.00277733f, 0.09181613f, -0.28606185f, 0.11224400f, 0.04782180f, 
    -0.03096453f, -0.14673018f, 0.23872364f, 0.01917358f, -0.07921030f, -0.03619172f, -0.04087880f, -0.05676333f, 
    0.00832087f, -0.03521232f, -0.02576161f, -0.02532392f, -0.02230745f, -0.02944161f, 0.03897134f, 0.04641229f, 
    -0.02310668f, 0.19939846f, -0.02941787f, 0.05296817f, -0.17037997f, 0.21804909f, 0.22814894f, 0.12341985f, 
    0.25460207f, 0.10379581f, 0.14588539f, -0.37656882f, -0.23109314f, -0.34139785f, -0.16416642f, -0.13054766f, 
    -0.23060995f, 0.07371596f, 0.19759119f, 0.10335599f, -0.33952639f, 0.03750405f, -0.03801297f, 0.06154897f, 
    0.00056482f, 0.04430898f, 0.00652373f, 0.03490885f, -0.10777324f, 0.18504514f, 0.09334234f, -0.47801694f, 
    -0.02217796f, 0.00566138f, 0.32250848f, -0.14146209f, 0.00183759f, -0.03224894f, 0.23832124f, 0.14191444f, 
    -0.11668494f, -0.38127539f, -0.05719388f, -0.12129687f, -0.06710256f, 0.28236693f, 0.12718153f, 0.00523792f, 
    -0.20252620f, 0.07183384f, 0.05037680f, -0.23305187f, -0.04140067f, -0.05708076f, 0.34701347f, 0.06466221f, 
    0.14929181f, 0.04087532f, 0.34446427f, 0.04876751f, 0.01545152f, 0.18777047f, 0.03102929f, 0.07245260f, 
    0.27629662f, -0.03881467f, -0.02440153f, 0.17142606f, -0.04152112f, -0.38924229f, 0.09378793f, 0.04887716f, 
    0.06230995f, 0.13035341f, -0.03166543f, 0.13520260f, -0.42631540f, 0.30921650f, -0.14362580f, 0.14197323f, 
    0.09775519f, 0.21643952f, 0.07146666f, 0.06246505f, -0.03663835f, -0.31069651f, 0.02370178f, -0.13863555f, 
    0.11451251f, 0.28512353f, 0.07000051f, -0.05407633f, 0.17702051f, -0.09232740f, -0.04681248f, -0.01853997f, 
    0.05172867f, -0.03109330f, -0.00594242f, -0.07982208f, -0.01321897f, -0.04383871f, 0.00857956f, 0.03870796f, 
    -0.03117423f, -0.11552618f, 0.04546556f, -0.06280972f, -0.06257720f, -0.05672831f, -0.02807630f, -0.03001041f, 
    -0.01002389f, 0.06390718f, 0.01494814f, -0.04403035f, -0.04552738f, -0.01047748f, 0.03252860f, 0.02175382f, 
    0.07105198f, -0.01484950f, -0.07382074f, -0.06514525f, -0.06406470f, -0.10921461f, -0.03010994f, 0.04424027f, 
    -0.03295810f, 0.04443344f, 0.03055834f, -0.02026324f, 0.02967036f, 0.06836300f, -0.04844945f, -0.02869694f, 
    -0.05214791f, 0.03573310f, 0.04417146f, -0.01106029f, 0.05704691f, -0.06196154f, -0.05769482f, -0.09532119f, 
    -0.04918331f, -0.06254251f, -0.02750015f, -0.02387365f, -0.07035757f, -0.10629766f, -0.08765732f, -0.03209349f, 
    -0.06994924f, 0.08190008f, -0.04387825f, 0.01394526f, -0.03009644f, -0.03883386f, -0.05705522f, -0.02545620f, 
    0.06830103f, -0.00657470f, -0.10768102f, 0.02804478f, 0.01027476f, -0.09202620f, -0.00972148f, -0.04608741f, 
    -0.00150771f, -0.06066685f, 0.03020242f, -0.04482726f, 0.04169865f, -0.08690673f, -0.08645596f, -0.05016868f, 
    0.03170738f, 0.01474816f, -0.09534846f, 0.07529999f, 0.02788707f, -0.07028133f, -0.01410516f, -0.08481913f, 
    -0.06810526f, 0.06274886f, -0.04542051f, -0.03234389f, -0.04288757f, 0.00800440f, 0.02648880f, 0.00576739f, 
    -0.04835784f, -0.06030519f, -0.09068898f, -0.06603950f, 0.08822289f, 0.08300544f, 0.04344953f, -0.06716938f, 
    -0.02837666f, 0.09252637f, 0.00344462f, -0.10534463f, -0.03846923f, 0.05286262f, 0.03504462f, 0.04953532f, 
    0.00423561f, 0.00027054f, -0.05383978f, -0.04162367f, 0.03569651f, -0.01643416f, -0.05180212f, -0.00914272f, 
    0.06915544f, 0.05524657f, 0.00874821f, -0.06516275f, -0.08520260f, 0.00909749f, 0.01575555f, -0.01777588f, 
    -0.35036567f, 0.02556854f, -0.03746547f, 0.29313853f, 0.04596595f, 0.21568719f, -0.27743021f, 0.01332252f, 
    0.20326923f, 0.01761141f, 0.11195238f, 0.05157078f, 0.02337427f, -0.04678187f, -0.27900133f, -0.01927930f, 
    0.08860562f, 0.16322479f, 0.13776353f, -0.05879929f, 0.02304169f, 0.17304860f, -0.05281127f, -0.03547665f, 
    0.03700203f, -0.01946389f, 0.15967271f, 0.07534914f, 0.16865048f, 0.25495413f, -0.06503414f, -0.00539308f, 
    -0.00686538f, 0.22581516f, 0.10056932f, -0.11313663f, -0.02125264f, -0.07085662f, -0.79676956f, 0.07618156f, 
    0.15160875f, -0.10509779f, 0.05201979f, -0.21798962f, -0.11449169f, -0.36978593f, -0.23031306f, -0.00999534f, 
    0.00137945f, 0.10178529f, 0.07583866f, 0.15545426f, -0.46493584f, -0.19822767f, -0.00796713f, -0.04055681f, 
    0.07580496f, 0.07002264f, 0.04404926f, -0.27598312f, -0.25892192f, 0.01507807f, -0.02485391f, -0.27330008f, 
    -0.05101391f, -0.04015522f, 0.36888182f, 0.08952539f, -0.05347211f, 0.03090305f, -0.11773057f, 0.15115073f, 
    0.15777248f, 0.04358945f, -0.04496238f, 0.00465834f, 0.03394355f, -0.12561028f, 0.13322453f, -0.16804667f, 
    0.11861243f, -0.06770369f, 0.14554174f, -0.33310875f, 0.04351394f, -0.22114006f, -0.14372635f, 0.13377483f, 
    -0.01727427f, 0.20959772f, 0.23530298f, 0.06591905f, 0.18305005f, -0.02941164f, 0.02503596f, 0.03928912f, 
    0.08196841f, -0.09834290f, 0.06469896f, -0.08027130f, -0.03061177f, -0.12124322f, 0.09148677f, 0.03708741f, 
    0.00896391f, 0.05742335f, -0.02645406f, 0.18825975f, -0.02786438f, 0.19728507f, 0.10114972f, 0.06558500f, 
    0.10922866f, -0.03137485f, 0.03237966f, 0.03577254f, 0.12115220f, -0.20540999f, -0.01820185f, 0.10138973f, 
    0.11519738f, 0.10595357f, 0.06103135f, 0.36810592f, -0.05184024f, 0.28781858f, -0.36997846f, -0.12538952f, 
    0.02142794f, -0.09934979f, -0.06887001f, 0.03091692f, 0.00104437f, 0.05096915f, -0.06592114f, -0.03841036f, 
    -0.09280030f, -0.01016644f, 0.04179606f, 0.04206895f, -0.06560034f, 0.01974508f, -0.06504693f, 0.02991996f, 
    0.02771702f, 0.07295756f, -0.10304541f, -0.05700140f, -0.11636323f, 0.07295575f, 0.08050133f, -0.03050187f, 
    -0.08447670f, 0.04943343f, 0.06445861f, 0.06180333f, 0.02270449f, -0.03594168f, 0.03341557f, 0.02280841f, 
    0.02451689f, -0.01845273f, 0.06888039f, -0.06480540f, -0.07104497f, 0.02798900f, -0.05459061f, -0.04805839f, 
    0.03134912f, 0.08506586f, -0.07167798f, -0.08668090f, 0.03152176f, 0.01400579f, 0.01103142f, 0.06965559f, 
    0.05370513f, -0.01776602f, -0.09171710f, 0.04274688f, 0.02952650f, -0.01090283f, -0.08164345f, 0.07320530f, 
    0.08130945f, 0.03331454f, 0.00651122f, 0.02214165f, 0.03421804f, -0.06198336f, -0.07331906f, -0.02914316f, 
    0.02137507f, -0.11811648f, -0.06089688f, -0.09413867f, -0.06798343f, 0.04359915f, 0.00554508f, -0.02947424f, 
    -0.10271393f, -0.09342106f, -0.05074760f, 0.00347170f, -0.04582212f, -0.04404196f, 0.02544464f, -0.11262339f, 
    -0.06119114f, 0.00079863f, -0.04314422f, -0.02344446f, -0.11309979f, -0.05358927f, -0.08609797f, -0.09722722f, 
    -0.08726227f, -0.03402641f, -0.04505203f, 0.02070617f, -0.04075433f, -0.06238849f, 0.06457478f, -0.04120712f, 
    -0.05388931f, -0.03465146f, -0.02630426f, -0.06565559f, -0.00769558f, 0.05185222f, -0.06558278f, -0.11478161f, 
    0.00948474f, -0.01964922f, -0.11967807f, 0.00797798f, -0.04204170f, -0.02405742f, 0.05536884f, 0.02527627f, 
    0.01249012f, 0.05655958f, -0.02799825f, 0.05843920f, 0.00110067f, 0.05171176f, 0.04522448f, -0.01386832f, 
    0.01193240f, -0.06620649f, 0.00152934f, -0.07787315f, 0.01644772f, 0.07889747f, 0.06107492f, -0.04884784f, 
    0.03806583f, -0.37046391f, 0.16483189f, -0.04731334f, -0.30553058f, 0.09317494f, -0.14421485f, -0.07217566f, 
    0.19963785f, -0.14949374f, 0.02463834f, -0.01390361f, -0.15733510f, 0.19695941f, -0.05509025f, 0.34270379f, 
    -0.28125244f, -0.14709917f, -0.21577838f, -0.05026631f, 0.00942086f, 0.42009705f, 0.20778051f, -0.01827825f, 
    -0.00924609f, -0.09072745f, 0.07364638f, -0.02412100f, 0.18480401f, 0.04537142f, -0.01753258f, 0.04264006f, 
    -0.23751742f, 0.10536791f, -0.08481700f, 0.02890583f, 0.09327179f, 0.09283981f, -0.33455577f, -0.25759786f, 
    0.11351155f, -0.22022654f, -0.29987976f, 0.26139703f, -0.05820396f, 0.45295861f, 0.19537260f, 0.10694120f, 
    0.31816560f, 0.20604159f, -0.26214743f, -0.29186836f, 0.35958934f, -0.06605516f, 0.14914197f, -0.03560291f, 
    0.00533891f, -0.04249931f, 0.09163989f, -0.12350735f, -0.00002414f, -0.08084951f, 0.19061443f, 0.22925539f, 
    0.07755366f, -0.06100950f, 0.06577720f, 0.11723706f, 0.06326395f, -0.04411909f, -0.18854113f, -0.07403296f, 
    0.19137461f, 0.43257114f, 0.12527265f, -0.04438149f, 0.13134801f, -0.05694250f, 0.06299128f, -0.18862295f, 
    -0.06953398f, -0.00289341f, -0.00751058f, 0.40338188f, -0.05639972f, 0.24185725f, -0.32203230f, 0.01601668f, 
    -0.11259485f, 0.10663492f, -0.36664686f, -0.01083889f, -0.18112640f, -0.00173649f, 0.31154084f, 0.06596041f, 
    -0.01344738f, -0.29205021f, 0.17804690f, -0.36758637f, -0.05041359f, 0.44538125f, 0.01178717f, -0.15839592f, 
    0.06012160f, -0.11356021f, 0.43210730f, -0.37474281f, 0.58294892f, -0.05886538f, 0.05643896f, -0.09334998f, 
    0.06890777f, 0.08359541f, 0.08420338f, 0.03115846f, 0.10764131f, 0.16824514f, -0.04552413f, 0.19170459f, 
    0.04761089f, -0.00289490f, -0.01799979f, -0.15215223f, 0.00874411f, 0.20537001f, 0.38952196f, 0.22255504f, 
    0.13402086f, -0.32528001f, 0.15448320f, -0.11255386f, -0.13730200f, 0.02678100f, 0.13443378f, 0.16898341f, 
    -0.37002313f, -0.05657474f, -0.07040911f, -0.08657621f, 0.06551963f, -0.02806079f, 0.07481502f, 0.11400923f, 
    -0.25918201f, -0.25464854f, 0.12512907f, -0.12461141f, 0.25016946f, 0.23168968f, 0.17528076f, 0.00823267f, 
    -0.13584644f, -0.16139545f, 0.13257936f, 0.15075190f, 0.01406612f, 0.10321776f, 0.03694054f, 0.26873127f, 
    0.05943348f, 0.01417375f, -0.04864653f, 0.00265017f, 0.14694019f, 0.39339224f, -0.48128670f, -0.08135429f, 
    -0.11767838f, -0.25324148f, -0.14899923f, -0.25690550f, -0.01117474f, -0.59568554f, 0.02945765f, 0.06702825f, 
    0.00376970f, -0.18319660f, 0.12186132f, -0.08581150f, -0.62890381f, 0.05808820f, 0.09372657f, -0.04643824f, 
    -0.04263109f, -0.26093701f, 0.14854805f, 0.11953533f, 0.17263488f, -0.23497473f, 0.12638603f, -0.20104881f, 
    0.16270591f, -0.03446430f, -0.27128774f, 0.04838367f, 0.03538789f, -0.10717236f, 0.09903471f, 0.12420329f, 
    -0.07900604f, 0.15619473f, 0.05346846f, 0.18890864f, 0.11283837f, -0.08280650f, 0.12240701f, -0.04889577f, 
    0.11801193f, -0.22394775f, -0.05904584f, -0.20279254f, -0.04021318f, 0.13499451f, -0.42005557f, 0.04075757f, 
    0.11843111f, 0.22007656f, 0.19518563f, -0.01215741f, -0.00999907f, 0.18597296f, -0.00822480f, -0.07495581f, 
    0.00368680f, 0.07948055f, 0.23790303f, -0.05217148f, -0.06500260f, 0.17906748f, -0.14203347f, -0.46892858f, 
    0.02985696f, 0.12558973f, 0.10456955f, -0.07452767f, 0.24273445f, -0.03639527f, 0.10368915f, 0.14480631f, 
    0.19039556f, 0.18026979f, 0.12039114f, 0.01552080f, -0.09341558f, -0.38250038f, 0.05755251f, 0.04955005f, 
    0.10609885f, 0.09373378f, 0.10552706f, 0.17621672f, 0.18833447f, 0.37306795f, -0.05109835f, -0.06363925f, 
    -0.39830795f, -0.20674506f, 0.03202778f, 0.09622090f, 0.04948406f, 0.26201352f, -0.29089555f, 0.26575947f, 
    -0.03433647f, 0.13761178f, 0.01463432f, 0.07104958f, 0.15343335f, 0.22348496f, 0.08843069f, -0.05807699f, 
    -0.07526856f, -0.30266446f, 0.29494712f, -0.06841514f, 0.07351763f, -0.11581509f, 0.04316361f, -0.08416321f, 
    -0.24232331f, -0.10005438f, -0.01034869f, 0.00272336f, -0.03267727f, 0.24078573f, -0.02158233f, 0.05289885f, 
    0.06979965f, -0.00210422f, 0.01479485f, 0.11408708f, 0.00044782f, 0.02305614f, -0.05730568f, -0.14807899f, 
    -0.12730744f, -0.13088271f, 0.08187477f, -0.29239604f, -0.18598305f, -0.42522597f, -0.06142690f, -0.08626688f, 
    -0.08785546f, -0.13818944f, 0.10198327f, 0.08469356f, -0.42285457f, -0.33112031f, -0.01105188f, -0.05694109f, 
    0.02948110f, 0.12921859f, 0.14931230f, -0.12299775f, -0.04723585f, -0.03435762f, 0.20195803f, -0.42317769f, 
    -0.21972756f, -0.07960656f, 0.31628847f, 0.12372488f, -0.06609201f, -0.03096732f, 0.02277909f, 0.05427272f, 
    0.05086859f, -0.10836308f, -0.05202010f, 0.04035205f, 0.00329093f, -0.28154072f, 0.15579835f, -0.04411813f, 
    0.01189051f, -0.11041658f, 0.13733314f, -0.46834382f, 0.02236563f, 0.01313299f, 0.09485890f, 0.26823071f, 
    -0.14545920f, 0.29727322f, 0.36587936f, 0.00701557f, 0.06205381f, -0.02376555f, 0.08648229f, -0.04534916f, 
    0.13473330f, -0.09879334f, 0.13687968f, 0.03363083f, -0.05802551f, -0.03333471f, 0.05538574f, -0.04121557f, 
    0.05224095f, -0.02214171f, 0.19052576f, 0.10088614f, 0.03313537f, -0.16448419f, 0.16170795f, -0.05283245f, 
    0.21228376f, 0.17309399f, 0.09217761f, -0.00307005f, 0.25278616f, -0.20408875f, 0.10100947f, -0.01539735f, 
    0.09714892f, -0.13848194f, 0.17764550f, 0.38003802f, -0.11276636f, 0.32681525f, -0.16073607f, -0.16163191f, 
    0.01552558f, 0.06759717f, 0.02784994f, -0.26304281f, 0.21665728f, -0.40310979f, -0.04612875f, 0.06971671f, 
    -0.29983661f, -0.15566112f, -0.01427244f, -0.28545368f, 0.04402107f, -0.13303731f, 0.04989728f, 0.23660776f, 
    -0.27623478f, -0.48480585f, 0.03402692f, 0.06106322f, 0.28417549f, 0.27540979f, 0.11168955f, 0.01488479f, 
    -0.06122293f, 0.01870828f, 0.20998321f, 0.11468031f, 0.14069512f, -0.06284664f, -0.04133269f, 0.17979890f, 
    -0.06113616f, 0.18812612f, -0.39157191f, 0.05423296f, 0.12306580f, 0.26277551f, -0.13267028f, -0.01137771f, 
    0.06842218f, 0.17117208f, -0.19937378f, -0.12114764f, -0.18548855f, 0.06405722f, 0.25976980f, -0.03121066f, 
    0.24314530f, 0.07716604f, 0.07282273f, -0.18335339f, -0.15923543f, -0.40759665f, 0.25639781f, -0.06489553f, 
    0.05923714f, -0.19612360f, 0.07081140f, 0.09176496f, -0.02062333f, -0.18988344f, 0.16002661f, -0.22194065f, 
    0.35082582f, -0.04811008f, -0.08309104f, 0.04184750f, -0.02453856f, 0.25199977f, -0.04214425f, -0.09431820f, 
    -0.14775291f, 0.23489314f, 0.27931377f, -0.00261559f, 0.14453571f, 0.14228246f, -0.23862880f, -0.05609376f, 
    -0.04850598f, 0.17731741f, -0.10305484f, 0.10882843f, -0.22021826f, -0.02310319f, -0.44213444f, -0.15115885f, 
    -0.18861063f, 0.25933209f, 0.07434484f, 0.02203268f, 0.03265433f, 0.16119298f, -0.04561949f, -0.06498181f, 
    0.00312500f, -0.13182698f, -0.00914877f, -0.11835718f, -0.00102679f, 0.14562686f, -0.07409306f, -0.04215116f, 
    0.03479515f, -0.14854540f, -0.07141554f, -0.07892611f, 0.13334730f, 0.41757330f, 0.07019153f, 0.26230237f, 
    0.21456121f, 0.11085083f, 0.10334168f, 0.06957901f, -0.18221085f, -0.43717828f, -0.09233739f, 0.11722545f, 
    0.10976360f, 0.19858311f, 0.26836112f, -0.03297457f, 0.19044009f, 0.15004535f, 0.12487767f, 0.27102128f, 
    0.31797215f, -0.08921848f, -0.06466015f, -0.00657249f, -0.02915850f, -0.15148075f, 0.07463074f, 0.01778051f, 
    0.02086893f, -0.08502187f, 0.05802390f, -0.00847819f, -0.03478933f, 0.10971862f, 0.16562748f, 0.05656959f, 
    0.01612552f, -0.04806629f, -0.01635154f, -0.15518372f, 0.16852647f, -0.00030395f, -0.05811398f, 0.05602779f, 
    0.08062205f, 0.01644521f, -0.04316689f, -0.00028979f, -0.20648298f, -0.34747162f, 0.08126599f, -0.04530333f, 
    0.03759849f, 0.09356383f, 0.14807415f, -0.19670834f, -0.13838145f, 0.15720427f, 0.10795359f, -0.00760203f, 
    0.22987238f, 0.08517576f, 0.00179053f, 0.06759167f, 0.01096218f, 0.12716092f, 0.14263444f, -0.09543155f, 
    0.16295448f, 0.09729113f, 0.05290245f, -0.11933888f, -0.14565030f, 0.03936421f, 0.16397290f, 0.07035980f, 
    0.02645932f, -0.01754669f, 0.13428959f, 0.07294646f, 0.16903274f, 0.09135495f, 0.10134969f, -0.43587911f, 
    0.10075591f, -0.09624694f, 0.03042899f, -0.18161261f, 0.09514561f, 0.14802012f, 0.18033439f, -0.03523974f, 
    -0.11239313f, 0.01600429f, 0.14512981f, -0.06572951f, 0.05744743f, 0.34734130f, 0.11187483f, 0.07998219f, 
    0.06887884f, -0.08282297f, -0.08324827f, 0.34690192f, 0.12115066f, 0.10290198f, -0.12427472f, 0.07427510f, 
    0.22046931f, 0.00797595f, -0.07737882f, -0.07620554f, -0.02759490f, 0.08939230f, -0.08288364f, -0.05156887f, 
    0.31213883f, -0.02161184f, -0.12859666f, 0.21753533f, -0.03460719f, 0.00719544f, -0.08227588f, -0.07978515f, 
    -0.02978864f, 0.27144819f, -0.25111228f, -0.14279456f, -0.11913542f, 0.24734703f, -0.02662069f, 0.04279235f, 
    0.13842151f, 0.11797743f, -0.05653112f, -0.00838167f, 0.03070025f, -0.57794940f, 0.16536619f, 0.00391950f, 
    -0.13507427f, 0.10501160f, 0.08955261f, -0.22625232f, 0.14355458f, -0.12498534f, 0.08364480f, -0.06014902f, 
    0.02087820f, -0.28422424f, -0.18681175f, 0.11474860f, -0.22349089f, 0.10800979f, 0.22858895f, 0.30537766f, 
    -0.49634516f, -0.01747667f, -0.49936262f, -0.28056499f, 0.20405993f, 0.14727664f, 0.16348621f, -0.07139356f, 
    -0.16143548f, -0.27332595f, 0.32208058f, 0.23763494f, -0.00720285f, -0.36382356f, 0.03480727f, -0.01630644f, 
    -0.31645894f, 0.28003088f, -0.11761741f, -0.11389383f, -0.12268159f, 0.02690888f, 0.08387066f, 0.22887796f, 
    0.03956869f, -0.08583088f, 0.44785938f, 0.32526916f, -0.01976191f, 0.09102849f, -0.02103926f, 0.01732462f, 
    0.06160115f, 0.46163791f, 0.10860732f, 0.06065982f, -0.27139765f, 0.11838061f, 0.35333443f, 0.04682938f, 
    -0.32471183f, -0.20271897f, 0.31419376f, 0.10066546f, 0.13411567f, -0.08181713f, -0.13353610f, -0.04334367f, 
    -0.08061650f, -0.35768774f, 0.05969420f, 0.24297713f, -0.00528068f, -0.03173050f, -0.02546160f, 0.18232904f, 
    -0.22246791f, -0.12341084f, 0.01540276f, -0.07697684f, -0.02898731f, 0.03523444f, 0.40845290f, 0.13516016f, 
    0.02106343f, -0.28938159f, -0.12235131f, -0.05770320f, 0.01850241f, 0.18634246f, 0.25800508f, 0.10656858f, 
    -0.00406717f, 0.19353104f, -0.09559391f, -0.57572848f, 0.08036434f, -0.01949983f, -0.46691605f, 0.35745218f, 
    0.09527922f, 0.12627079f, 0.29356590f, 0.07777180f, -0.11367972f, 0.06682652f, 0.03980463f, 0.04376448f, 
    0.14397898f, 0.25517428f, 0.01737656f, 0.64330447f, 0.03430850f, -0.23283687f, 0.06566988f, -0.36353967f, 
    0.10358239f, 0.22026412f, -0.22752441f, 0.27603829f, -0.37619486f, 0.00649127f, 0.09082157f, 0.05508676f, 
    0.14149635f, 0.05954339f, 0.19782726f, 0.14547059f, -0.18374397f, 0.18581218f, 0.29863888f, -0.40405440f, 
    0.13417719f, 0.09117271f, 0.22795297f, -0.06137468f, 0.18574680f, -0.38165206f, -0.01057685f, 0.00916356f, 
    -0.60791427f, 0.14742681f, 0.12934044f, 0.25853723f, -0.09701873f, 0.47870186f, -0.10199508f, 0.04981538f, 
    0.23969512f, -0.02651666f, -0.17634992f, -0.35030359f, 0.12289412f, 0.13678871f, -0.32547966f, -0.13466340f, 
    -0.17257795f, 0.25599319f, 0.13227701f, -0.03428600f, 0.10014994f, 0.09442374f, 0.06830340f, -0.09126551f, 
    -0.00550977f, 0.03564461f, 0.20440191f, 0.06542429f, 0.11024719f, 0.19027843f, 0.01090103f, -0.06195424f, 
    0.08973378f, 0.02694418f, 0.16831885f, -0.08094479f, -0.15646432f, 0.01915149f, -0.72833276f, -0.28198090f, 
    0.07291109f, -0.03270229f, 0.01932526f, -0.22252434f, -0.07040851f, -0.23571749f, -0.03259345f, -0.00084100f, 
    -0.00793193f, -0.06393185f, -0.01140776f, 0.03083040f, -0.46359587f, -0.21669614f, -0.25827250f, -0.08082974f, 
    -0.03227571f, -0.13297889f, -0.04818872f, -0.22860646f, -0.01840350f, -0.10449111f, 0.02629291f, 0.01022096f, 
    -0.34681633f, -0.01562921f, 0.20999008f, 0.04299954f, -0.04044963f, 0.22098787f, 0.11786503f, 0.29850653f, 
    0.29482615f, 0.20935711f, -0.17507693f, 0.00356170f, 0.19599321f, -0.16099985f, -0.27397451f, -0.60215062f, 
    0.03474469f, -0.05168233f, 0.05335446f, -0.24788947f, 0.07964644f, 0.05255859f, -0.30944437f, 0.32409447f, 
    0.19359995f, 0.07750711f, 0.30285409f, -0.07921474f, -0.22166674f, 0.04941684f, 0.32332620f, 0.00034118f, 
    0.39122146f, 0.09840523f, 0.21393797f, -0.09117895f, 0.08665097f, -0.06927762f, -0.08196302f, -0.05392294f, 
    -0.07435668f, 0.13186289f, 0.22908990f, 0.19212690f, 0.17659993f, -0.04849464f, -0.06640828f, 0.12355457f, 
    0.04112184f, -0.23171745f, 0.16744830f, -0.00976248f, 0.20894943f, -0.18448004f, 0.01728589f, -0.12620397f, 
    -0.05636178f, -0.16458780f, 0.02140076f, 0.52156258f, 0.06008979f, 0.20961602f, -0.17339967f, -0.17570674f, 
    -0.21656133f, -0.10079671f, 0.03123150f, 0.06412182f, 0.02631260f, 0.36346915f, -0.18770804f, 0.21060714f, 
    -0.23462807f, 0.01029212f, -0.09914739f, 0.00453803f, 0.09143570f, 0.11559045f, 0.15127589f, 0.31838521f, 
    -0.04300072f, -0.37238419f, 0.18604642f, -0.08680840f, -0.03503675f, 0.25526512f, 0.10323735f, -0.05245082f, 
    -0.04658952f, -0.05025237f, 0.01062464f, -0.14869910f, 0.04655809f, 0.15240979f, 0.04670262f, 0.16482700f, 
    0.06326859f, 0.09823017f, 0.11473060f, 0.09322700f, 0.05284008f, -0.03554523f, -0.14122432f, -0.00375720f, 
    0.02574040f, -0.16033533f, 0.07008557f, -0.14601871f, -0.17951412f, -0.09067843f, 0.17108263f, 0.06812914f, 
    0.21109873f, 0.02343480f, -0.04091751f, 0.03071287f, 0.14662483f, -0.25450981f, 0.06609614f, -0.05716296f, 
    -0.01577282f, 0.04333064f, 0.18544953f, -0.01716623f, -0.08628960f, 0.13442861f, 0.24136545f, -0.34243867f, 
    -0.18848579f, -0.08057699f, 0.27530780f, 0.06574099f, -0.03454244f, -0.18485212f, 0.04070806f, -0.14686072f, 
    0.02222429f, 0.12144653f, -0.03720837f, -0.21305235f, -0.04222723f, -0.26267126f, 0.12045047f, 0.07675553f, 
    0.17831358f, 0.08554323f, -0.04812633f, -0.43303171f, 0.07259977f, 0.00918388f, -0.44992518f, 0.18718565f, 
    -0.04118691f, 0.34146377f, 0.28634506f, -0.02464199f, -0.04945066f, 0.07852422f, 0.06296313f, -0.08598571f, 
    -0.14973983f, -0.01201477f, 0.05208658f, 0.11674199f, -0.00857758f, 0.40569586f, -0.04087615f, -0.07078035f, 
    0.09053970f, -0.00601391f, 0.02138139f, 0.15242107f, 0.51242775f, -0.16969556f, 0.12150711f, 0.02511992f, 
    0.29138878f, 0.18909685f, 0.04797180f, 0.07737613f, 0.26245734f, 0.05991066f, 0.05577781f, -0.07194410f, 
    -0.03148428f, -0.08502711f, 0.14984052f, 0.12636478f, -0.07199836f, 0.28280240f, -0.10082907f, -0.02626492f, 
    0.26832020f, -0.07661393f, -0.23373285f, -0.12245840f, -0.02572712f, -0.31627557f, -0.02484942f, -0.09969582f, 
    0.24135931f, -0.04342938f, 0.15978676f, -0.02448604f, -0.10893912f, -0.35071075f, 0.06790976f, 0.33637130f, 
    -0.15541495f, -0.27762884f, -0.08157776f, 0.01806532f, 0.05738578f, 0.19011089f, 0.03130304f, -0.01925536f, 
    0.17203695f, 0.01194521f, 0.10016403f, -0.05176875f, 0.13852318f, 0.00066059f, 0.04508350f, 0.15438850f, 
    -0.26727152f, 0.25847897f, -0.12510026f, -0.08336504f, 0.07578378f, 0.08520178f, 0.87888819f, 0.16889048f, 
    0.03989416f, 0.09458227f, -0.05440853f, 0.03180418f, -0.27322361f, 0.01972537f, 0.01864730f, 0.06325510f, 
    0.22126769f, 0.31789750f, 0.02844446f, -0.11389831f, 0.12721443f, -0.31891552f, -0.07276461f, -0.00454010f, 
    0.05221625f, 0.07888459f, 0.13117912f, -0.01066747f, 0.06353442f, 0.21426675f, 0.02116136f, -0.02392422f, 
    0.19637330f, -0.09956805f, 0.32877713f, -0.10538517f, 0.05355622f, 0.17317966f, 0.15230298f, -0.05018303f, 
    -0.63181984f, 0.18804811f, 0.18961459f, 0.02649249f, -0.01417660f, 0.25890103f, 0.01763534f, 0.03907209f, 
    -0.13754015f, 0.26686224f, -0.10919957f, 0.57981402f, -0.10555227f, -0.07201172f, 0.38826409f, -0.01258844f, 
    -0.13346131f, 0.11228480f, -0.16632837f, -0.01604334f, -0.01969839f, 0.08049427f, -0.16542159f, 0.06070134f, 
    -0.00430240f, -0.24281229f, -0.08443179f, -0.25840160f, 0.02535701f, 0.14399326f, -0.09765347f, 0.04979033f, 
    -0.01268891f, 0.14520372f, -0.16702135f, -0.15507725f, 0.07145010f, 0.26620296f, 0.05162559f, 0.02145841f, 
    0.03367892f, 0.19139376f, -0.00531909f, 0.24764930f, -0.20493074f, -0.47673398f, 0.09531219f, -0.02116136f, 
    0.16536185f, 0.13516231f, 0.21900901f, -0.33281758f, 0.09804537f, -0.03862806f, -0.11680645f, 0.21961164f, 
    0.14158893f, -0.35797757f, -0.17398538f, -0.25046748f, 0.10627878f, -0.28902134f, 0.00543076f, -0.00148859f, 
    -0.23918463f, -0.25588524f, -0.10178827f, -0.11230390f, -0.04679838f, -0.23317610f, 0.11354880f, 0.39548612f, 
    -0.03084884f, -0.38963956f, -0.00916527f, 0.12697236f, 0.16843219f, 0.20394213f, 0.06200226f, 0.09204403f, 
    0.01053173f, 0.05330689f, 0.16129977f, -0.18451650f, -0.04719327f, -0.02239459f, -0.06341936f, 0.03604792f, 
    -0.27319613f, 0.15340878f, -0.20845179f, 0.02154810f, 0.17056204f, 0.15765016f, -0.08647028f, 0.00639298f, 
    -0.13143112f, 0.19830960f, -0.15396014f, 0.10006066f, -0.08769087f, 0.27075204f, 0.12505499f, 0.06672575f, 
    0.13980573f, 0.23169872f, 0.02567477f, -0.25027135f, 0.40300813f, -0.46725118f, 0.08230045f, -0.04559471f, 
    0.04791721f, -0.26139393f, 0.04072794f, 0.07892162f, -0.04651444f, 0.09679092f, 0.17460471f, 0.04852671f, 
    0.30038121f, -0.23614712f, 0.08250476f, 0.01235803f, 0.05274959f, 0.17416526f, -0.06484864f, -0.06272944f, 
    -0.42815518f, 0.15221480f, 0.07085964f, -0.02937162f, -0.01284776f, 0.24038981f, -0.02593199f, 0.12551604f, 
    -0.13016932f, 0.29738590f, -0.01442283f, 0.37580314f, -0.29351920f, -0.17136873f, -0.13621147f, -0.01135718f, 
    -0.29551148f, 0.23015705f, -0.19887532f, 0.03816222f, -0.05536523f, 0.07164746f, 0.04618859f, -0.06959551f, 
    -0.19604512f, -0.17027719f, -0.03714786f, -0.19225912f, -0.07554393f, 0.29991058f, 0.09306773f, 0.26563090f, 
    -0.08231736f, -0.00471233f, -0.17042208f, -0.08359456f, 0.18591526f, 0.36742988f, -0.04451784f, 0.17390120f, 
    0.15649551f, 0.16658691f, -0.02287765f, 0.16709147f, -0.24186951f, -0.23123085f, -0.03243024f, -0.13153575f, 
    0.17874385f, 0.01391090f, 0.19192944f, -0.38828486f, -0.04153340f, 0.01102878f, 0.02071444f, 0.21909600f, 
    -0.11494622f, -0.24869029f, 0.21874413f, 0.01693282f, -0.00689746f, -0.08888357f, -0.02696573f, -0.00040252f, 
    0.02919074f, 0.00015824f, 0.02134953f, -0.04074229f, 0.04880785f, -0.29913035f, 0.02375042f, -0.10072438f, 
    -0.08895193f, -0.15217575f, 0.02618655f, 0.23304419f, -0.16146247f, -0.13748664f, 0.07077108f, 0.04915803f, 
    -0.09622946f, -0.10325335f, 0.16198680f, 0.08839591f, 0.26412788f, 0.39314601f, 0.04335160f, 0.10290557f, 
    0.03145287f, 0.06238626f, -0.20851587f, 0.21903895f, 0.26669961f, 0.02270522f, 0.29617125f, 0.12660570f, 
    -0.06090554f, 0.05299446f, 0.03989286f, 0.00883034f, -0.30944839f, -0.38697568f, -0.13974218f, 0.20129922f, 
    -0.09534473f, -0.07123487f, -0.02217799f, 0.06983858f, -0.15776576f, -0.04352710f, -0.03180034f, -0.05941812f, 
    -0.04030346f, -0.02745326f, -0.09180091f, -0.15567645f, -0.22138216f, -0.02807174f, 0.04217414f, 0.06959819f, 
    -0.03003245f, 0.19121258f, 0.20742469f, 0.17674963f, -0.05695658f, -0.02601920f, -0.11926211f, 0.00535897f, 
    0.11062986f, -0.11148226f, -0.14220466f, 0.06098837f, -0.14701425f, -0.06315721f, -0.18793170f, 0.12565185f, 
    -0.15742141f, -0.03981586f, 0.09110060f, -0.39154732f, -0.11246198f, -0.08836859f, 0.15963858f, -0.33766812f, 
    -0.05069460f, 0.12697098f, 0.20660755f, -0.07717996f, 0.08766682f, -0.11966960f, -0.03341888f, -0.00331851f, 
    0.04469644f, 0.01056577f, -0.17845668f, -0.23881236f, -0.05446482f, -0.23485692f, -0.00153156f, -0.06392333f, 
    0.01805116f, -0.19650154f, 0.35931808f, -0.06665208f, -0.05026545f, 0.03510037f, 0.20170517f, 0.09099232f, 
    0.05688620f, 0.18346210f, 0.09900461f, -0.08757395f, -0.03114798f, 0.16092099f, -0.14488223f, 0.03588108f, 
    0.12887664f, 0.15167817f, -0.04103802f, 0.23429194f, -0.01714253f, 0.18047966f, -0.24394441f, -0.03765418f, 
    0.53317678f, -0.23842967f, -0.08754498f, 0.01798876f, -0.11953533f, -0.47429788f, 0.30974159f, 0.09898017f, 
    -0.06833742f, 0.03204803f, -0.22875270f, -0.04933022f, -0.00292230f, -0.27969682f, 0.25763154f, 0.05749822f, 
    0.01125160f, -0.14890106f, -0.03719276f, 0.16963881f, 0.12713392f, 0.01348280f, 0.01282894f, -0.07253677f, 
    0.01063304f, 0.02322556f, -0.11531355f, 0.03996399f, -0.19239722f, -0.41875747f, 0.04916938f, 0.09521147f, 
    -0.20729782f, -0.06120192f, -0.09419796f, 0.03675007f, -0.09177674f, 0.28098011f, 0.47135997f, 0.19734381f, 
    0.35400993f, 0.29891211f, 0.01299327f, 0.25507700f, -0.13825531f, 0.22391729f, 0.21973990f, -0.01636958f, 
    -0.10729960f, 0.00205136f, 0.29688382f, 0.07630070f, 0.26541418f, 0.19563669f, -0.08537578f, 0.07791578f, 
    -0.00026110f, -0.00286880f, 0.17604022f, 0.28216797f, 0.07430961f, 0.08941230f, -0.15607496f, 0.09579058f, 
    0.06521786f, -0.10630060f, -0.10928428f, -0.06486475f, -0.01351451f, 0.16080515f, 0.07540241f, 0.04695138f, 
    -0.29777628f, 0.09940206f, -0.03507967f, -0.04816014f, -0.12236751f, 0.51006114f, 0.04144812f, -0.02335040f, 
    -0.18043950f, 0.22539331f, -0.01351199f, 0.29917750f, -0.13155289f, 0.19990817f, 0.28241506f, -0.11408681f, 
    0.18382750f, -0.11444109f, -0.20726644f, -0.02186549f, 0.02592807f, 0.22160435f, -0.13436003f, 0.00474114f, 
    0.12920466f, 0.15482105f, -0.04233147f, 0.20677480f, -0.05098416f, -0.19306037f, 0.17023383f, -0.05579875f, 
    0.01272863f, 0.04728815f, -0.19895947f, 0.00490390f, -0.24414405f, 0.16600819f, -0.01510054f, 0.17919499f, 
    0.02699037f, 0.03461344f, -0.07862777f, -0.08760512f, -0.46208066f, -0.17165962f, -0.01787558f, -0.13639584f, 
    -0.08286849f, 0.21512550f, 0.06570987f, -0.41516301f, 0.28875691f, -0.55206120f, 0.28908554f, 0.12777328f, 
    0.50376165f, -0.06788388f, 0.09763788f, -0.03738037f, -0.06059960f, -0.19966903f, 0.12671240f, -0.14276104f, 
    -0.07754609f, -0.02457821f, -0.05590409f, 0.12225921f, -0.17729497f, 0.08107957f, 0.18864468f, 0.07964624f, 
    0.08324835f, 0.00316317f, 0.06171876f, -0.18880260f, 0.11308075f, -0.09779921f, -0.14251491f, -0.07222501f, 
    -0.00510907f, 0.01219067f, 0.10413592f, 0.04681122f, -0.14987838f, -0.58846384f, 0.06841572f, -0.12272401f, 
    -0.14021651f, 0.00269044f, 0.02480777f, -0.09040294f, -0.10120818f, 0.21675633f, 0.05386722f, -0.11466780f, 
    0.39476517f, 0.01991305f, -0.12928881f, 0.06823754f, 0.14850190f, 0.54784536f, -0.07039663f, -0.06100408f, 
    0.22604534f, 0.04140377f, 0.15970980f, 0.02560868f, 0.59900630f, 0.15554130f, 0.16651693f, 0.01046893f, 
    -0.08568779f, -0.02959687f, 0.03067686f, 0.17260341f, 0.15947160f, 0.26646423f, 0.12554421f, -0.11554707f, 
    0.19031449f, -0.18198299f, -0.10134681f, -0.22815485f, 0.03258635f, -0.02001019f, 0.31456172f, -0.06861249f, 
    -0.34146211f, 0.06087959f, -0.22639365f, -0.17062883f, 0.08611225f, 0.52936715f, -0.00624481f, -0.07999261f, 
    -0.26083779f, 0.31086436f, 0.25496539f, 0.20004463f, -0.03615739f, 0.16406201f, 0.35168216f, 0.14163716f, 
    -0.06353596f, -0.08626001f, -0.05677684f, 0.07653851f, 0.11251102f, 0.25938857f, 0.23536110f, -0.08345983f, 
    0.16203555f, -0.16258191f, -0.13791353f, 0.30869672f, -0.03538989f, 0.28561547f, -0.05409450f, -0.01646602f, 
    0.01553205f, 0.04595936f, -0.03492830f, -0.10746775f, -0.00561794f, -0.00181235f, -0.10187181f, 0.34862638f, 
    -0.04074524f, 0.29066789f, -0.07479085f, 0.04512243f, 0.16206044f, -0.26513460f, 0.20871919f, -0.08936569f, 
    -0.23052840f, 0.06639226f, -0.01962849f, 0.03111974f, 0.18729968f, -0.27749035f, 0.64071280f, 0.18243933f, 
    0.32908928f, -0.31416392f, -0.00271351f, 0.12628849f, -0.03179180f, 0.01318629f, 0.27776304f, 0.22864382f, 
    0.05205077f, 0.11200273f, -0.07491533f, -0.44925380f, 0.24688075f, -0.21968468f, 0.25268757f, -0.28604957f, 
    -0.17886552f, -0.86436337f, 0.00440151f, 0.19302751f, -0.04191519f, -0.44392154f, 0.10392537f, -0.01834889f, 
    -0.03123476f, 0.10625651f, -0.06224149f, -0.13450545f, 0.08427764f, -0.05674039f, 0.03727703f, 0.12379966f, 
    0.14687376f, -0.05500529f, 0.24172857f, 0.35071841f, 0.06254304f, -0.06912708f, 0.22973749f, 0.19998957f, 
    0.25232431f, 0.09248841f, 0.28986064f, 0.05594319f, -0.44452977f, -0.08735199f, 0.21005009f, 0.20423150f, 
    -0.28068009f, -0.04123592f, -0.02445589f, 0.18532448f, 0.05553108f, 0.07681149f, -0.11281761f, 0.00163366f, 
    0.02622538f, 0.26386100f, 0.11407010f, 0.37106887f, 0.11110125f, 0.09622774f, -0.08910867f, 0.12164506f, 
    -0.19638930f, 0.24182050f, 0.00788666f, -0.02595842f, -0.02825099f, 0.06312153f, 0.18944184f, 0.08619634f, 
    -0.05486663f, -0.41007480f, -0.02317344f, 0.05197493f, -0.11678760f, 0.27820027f, 0.01315061f, 0.16569605f, 
    0.02372291f, 0.15081489f, -0.14706810f, 0.04856233f, -0.09737524f, 0.19628537f, -0.09916212f, -0.11563890f, 
    0.30504578f, -0.13618228f, 0.02725873f, 0.04009317f, 0.08007749f, 0.12214283f, -0.12349815f, 0.02162140f, 
    -0.08503033f, 0.41515437f, -0.06492147f, 0.44302547f, -0.01845915f, -0.41196486f, 0.05065305f, -0.15190616f, 
    -0.02210683f, 0.13701448f, -0.14045219f, 0.16428207f, -0.46213189f, -0.09006204f, 0.21399651f, -0.07810006f, 
    -0.01700616f, 0.00187860f, 0.15342657f, -0.05379093f, -0.14006625f, 0.55063570f, 0.02652628f, -0.09907155f, 
    0.16724741f, 0.26249793f, -0.04965203f, -0.22119163f, -0.06188948f, -0.25959936f, -0.10338041f, -0.13229357f, 
    -0.23187776f, -0.20003724f, 0.15538956f, 0.18273868f, -0.01820202f, -0.07518179f, 0.09901018f, 0.10695485f, 
    0.33314306f, 0.06075997f, 0.03226107f, -0.36523676f, 0.08562081f, -0.02593092f, -0.19305582f, -0.12826538f, 
    -0.12862173f, 0.21344860f, -0.07043251f, -0.09273054f, 0.10164902f, -0.23099154f, 0.02362814f, -0.00031310f, 
    0.02574172f, -0.02414712f, 0.15873285f, -0.02921674f, 0.10570762f, 0.12683198f, -0.00325878f, 0.08883914f, 
    0.05994981f, 0.17784736f, -0.32334933f, -0.15355493f, -0.11050453f, 0.11505360f, 0.15934885f, 0.04532052f, 
    0.29981413f, 0.03959016f, -0.06859986f, -0.03581341f, -0.15211718f, -0.12166825f, -0.17130962f, -0.01942040f, 
    -0.10422440f, 0.06091874f, 0.00415308f, -0.10424671f, -0.27039173f, -0.12303162f, -0.09007530f, 0.04319107f, 
    -0.05143039f, -0.19325192f, -0.09750607f, -0.09389847f, 0.00446411f, -0.14965738f, -0.01839058f, 0.19661544f, 
    -0.16184855f, 0.05026812f, -0.07008117f, 0.25755179f, 0.06446654f, 0.09289677f, -0.17997366f, 0.17258947f, 
    0.33337161f, -0.12584873f, -0.18252257f, -0.09753279f, 0.15073788f, -0.07263691f, -0.24885330f, -0.34228790f, 
    0.05445874f, -0.02592528f, 0.12122554f, -0.39847237f, -0.02412492f, 0.09750438f, -0.05014190f, 0.09203897f, 
    0.17080446f, -0.04951175f, 0.07071569f, -0.09253894f, -0.11721604f, -0.01075165f, 0.26531485f, 0.05618982f, 
    0.24724397f, 0.09539989f, -0.01621842f, -0.00638635f, -0.06099569f, -0.07301673f, 0.13726908f, 0.08026269f, 
    0.04295414f, -0.09496440f, 0.47893482f, -0.14588472f, 0.01167157f, -0.10836644f, -0.04944723f, 0.17098983f, 
    -0.06402370f, -0.02091690f, 0.06694011f, -0.14200376f, -0.09811614f, 0.06584478f, -0.05900485f, 0.08172627f, 
    0.08313009f, 0.15888637f, -0.03056685f, 0.18880177f, 0.13161531f, 0.15425153f, 0.22598514f, 0.06347695f, 
    -0.20635292f, -0.06666993f, 0.01232736f, 0.18369435f, -0.21521361f, 0.13497332f, -0.03401018f, -0.01557034f, 
    0.09746822f, -0.05318276f, -0.19527872f, -0.44148508f, 0.13206914f, 0.03033419f, -0.20426217f, -0.14754553f, 
    -0.19803503f, 0.23275836f, 0.06606788f, -0.18250185f, 0.02108932f, -0.27758825f, -0.19806111f, 0.05550253f, 
    -0.15223730f, -0.04165139f, 0.23063542f, 0.09228049f, 0.09070778f, -0.01496804f, -0.07603416f, -0.16547857f, 
    -0.09468544f, 0.08293892f, 0.06608793f, -0.24135403f, -0.26006055f, 0.12425492f, -0.44298854f, -0.00295335f, 
    0.43838575f, 0.10185830f, 0.11948111f, -0.24311572f, -0.42096853f, -0.28513584f, -0.13645107f, -0.03814992f, 
    -0.23535579f, -0.00105145f, 0.16317198f, -0.07879670f, -0.36256561f, -0.04815468f, -0.14635465f, 0.00885373f, 
    -0.08411761f, -0.21131700f, -0.05070028f, -0.07171421f, -0.07507820f, -0.07478310f, 0.03102248f, -0.25800726f, 
    -0.08163281f, -0.16597559f, 0.29217476f, 0.10318587f, 0.02827152f, 0.21810691f, 0.19520032f, 0.21570891f, 
    0.18946959f, -0.31154954f, -0.09495665f, -0.07283862f, 0.24299797f, 0.24951345f, -0.24970786f, -0.36661959f, 
    0.01752496f, 0.02979966f, 0.07981378f, -0.43602672f, -0.09175848f, 0.24726701f, -0.06550987f, 0.41479677f, 
    0.21359462f, -0.03137387f, 0.35573921f, -0.05118578f, -0.02098175f, 0.16911307f, 0.35813749f, -0.04049716f, 
    0.68730468f, 0.21194109f, -0.03368279f, 0.18532920f, 0.02172430f, -0.23266785f, 0.04712307f, -0.13575557f, 
    0.09465062f, 0.19482653f, 0.32499316f, 0.05492315f, -0.33798891f, 0.15317975f, -0.18688984f, 0.21835306f, 
    0.00657508f, -0.07878956f, 0.18541446f, -0.04776363f, 0.07968290f, -0.08814948f, 0.07918321f, -0.17207931f, 
    -0.17077859f, 0.11652946f, 0.11919544f, 0.26313248f, 0.17816690f, -0.13003418f, 0.28341544f, -0.24339518f, 
    0.11199416f, -0.22084977f, 0.00579132f, -0.06628368f, -0.16016544f, -0.08685859f, 0.13658902f, 0.12545450f, 
    -0.29975161f, -0.14155902f, -0.23271658f, 0.05888963f, 0.08348210f, 0.18915659f, 0.23804180f, 0.37792197f, 
    -0.10709886f, -0.10704369f, 0.26339188f, -0.00569575f, 0.07653580f, -0.07865544f, 0.13505641f, -0.08258763f, 
    -0.11967513f, 0.12346477f, -0.09054739f, -0.05395118f, -0.03608158f, -0.08794087f, -0.06886824f, 0.12868115f, 
    -0.03603234f, -0.14423889f, 0.00244355f, 0.11066553f, 0.12823397f, 0.33120230f, 0.00768729f, -0.05677506f, 
    0.06240707f, -0.13812223f, -0.11872675f, -0.11935303f, -0.03047468f, 0.21583149f, 0.20052087f, 0.03493093f, 
    0.18490349f, 0.06895784f, 0.19989012f, -0.00455605f, 0.34711227f, -0.13013417f, 0.15701805f, 0.08146410f, 
    0.03441083f, -0.03265695f, 0.30108780f, 0.17805958f, 0.07104630f, -0.03665071f, 0.19990948f, 0.00510154f, 
    0.01313864f, -0.20060726f, 0.04600887f, -0.01896771f, -0.05199640f, -0.50880414f, 0.10931484f, -0.20443101f, 
    -0.11189969f, -0.08333440f, -0.05664698f, -0.14877085f, 0.01399899f, 0.03849096f, 0.13615310f, 0.02874662f, 
    -0.03065116f, -0.01857740f, -0.00691980f, -0.26700485f, 0.05619792f, 0.00167186f, -0.47757983f, 0.19938087f, 
    -0.15763964f, 0.15810862f, 0.16420527f, -0.10087568f, -0.07859212f, 0.15648077f, 0.03287880f, 0.05133446f, 
    -0.10551597f, -0.00880425f, 0.01906666f, 0.17077814f, 0.01930418f, 0.36728308f, 0.08887149f, -0.14739829f, 
    0.01903140f, 0.02636703f, 0.03507605f, 0.08465949f, 0.31918690f, -0.21262714f, 0.08649763f, 0.26325062f, 
    0.22573465f, 0.39300099f, -0.04533388f, 0.05062290f, -0.01626205f, 0.15909114f, 0.08621005f, 0.02770544f, 
    0.01602977f, -0.00299147f, 0.20329183f, -0.14537379f, 0.08176205f, -0.00141131f, 0.36350346f, 0.18105786f, 
    0.29943606f, -0.11874532f, 0.16457881f, -0.02812594f, 0.03829306f, -0.15465140f, -0.06869610f, -0.09982637f, 
    -0.13916977f, -0.08005550f, -0.04752239f, 0.04192416f, -0.08322156f, 0.18975726f, -0.00217625f, 0.36006591f, 
    0.02629430f, -0.40292627f, 0.17160343f, -0.03855597f, 0.10738514f, 0.24747652f, 0.05305481f, -0.07392750f, 
    -0.02944505f, -0.08437757f, 0.14611496f, 0.13316141f, 0.02145454f, -0.24986915f, 0.05918845f, 0.04933200f, 
    -0.01871744f, -0.08934716f, 0.25184357f, -0.13257797f, 0.08837520f, 0.02659581f, -0.04167236f, -0.04855848f, 
    0.16644980f, -0.07656761f, 0.00899300f, 0.16177246f, 0.09292707f, 0.25333506f, 0.23502782f, 0.14008561f, 
    0.26726153f, 0.04411888f, -0.13845268f, -0.02034235f, -0.15739681f, -0.00467305f, 0.23531781f, 0.07017586f, 
    0.03978584f, 0.22512041f, 0.23833238f, -0.05537616f, 0.27872464f, 0.06195273f, 0.11473570f, -0.26853254f, 
    0.28759190f, 0.02835123f, -0.08605488f, 0.02379828f, -0.06175751f, 0.13736390f, 0.18296678f, 0.04087899f, 
    -0.32024795f, 0.16814013f, 0.18945551f, 0.06821557f, 0.02600725f, 0.17797330f, 0.01333813f, -0.05494870f, 
    0.03325045f, 0.07903253f, 0.09790476f, -0.41251287f, 0.06600391f, 0.03910585f, -0.07644385f, -0.01045763f, 
    0.08530173f, 0.23696922f, -0.07303061f, -0.05236400f, 0.06654494f, 0.13071872f, -0.01796545f, -0.02801833f, 
    0.09988569f, -0.37267515f, 0.07913654f, -0.15862827f, -0.03075255f, 0.31431204f, -0.20907998f, -0.12874778f, 
    0.06105364f, 0.04307863f, -0.13459440f, -0.04173209f, 0.27118266f, 0.24934086f, 0.03597349f, 0.20845348f, 
    0.21748148f, 0.08634979f, -0.03643978f, 0.14864233f, 0.21004121f, -0.28114635f, -0.03933758f, 0.04839606f, 
    0.02997153f, 0.03635374f, 0.04254299f, -0.07040779f, 0.15726493f, 0.11824165f, -0.15234995f, 0.13168630f, 
    0.19820470f, -0.29711190f, -0.18937270f, 0.13912612f, -0.15028156f, -0.01552167f, 0.10045999f, 0.25379124f, 
    -0.34568012f, -0.02716863f, -0.29343104f, -0.58469892f, 0.25334188f, 0.11640856f, 0.12619826f, -0.10013383f, 
    -0.28433812f, 0.32252517f, 0.22081062f, 0.14291574f, -0.01001277f, -0.04716907f, -0.07115674f, -0.01262558f, 
    -0.37752837f, 0.23628350f, -0.05860226f, 0.05089323f, -0.04037579f, 0.09453318f, -0.04866333f, 0.18090029f, 
    -0.05359520f, -0.07169738f, 0.15246548f, 0.28974387f, -0.13722032f, 0.19456519f, -0.01713607f, -0.00572738f, 
    0.06377820f, 0.26373643f, 0.15808673f, -0.18179674f, -0.10835613f, -0.44514608f, 0.04708534f, -0.16143930f, 
    -0.26960588f, -0.30191427f, 0.31781122f, -0.02384657f, -0.24191046f, 0.01387205f, -0.18397069f, 0.07102880f, 
    0.05234307f, -0.58838576f, 0.08421490f, 0.31897900f, 0.09292016f, -0.05687661f, -0.07631709f, 0.13891770f, 
    -0.10233389f, -0.12548040f, -0.24625425f, -0.04697789f, 0.07788507f, -0.07983904f, 0.26037186f, 0.28917378f, 
    -0.01063734f, -0.14982042f, -0.10812843f, 0.04801831f, 0.04204035f, 0.00962978f, 0.10789839f, -0.07690675f, 
    -0.07623920f, -0.04030488f, 0.10514357f, -0.65544164f, -0.08983417f, 0.02233155f, -0.34631878f, 0.26740506f, 
    0.13366999f, 0.02465173f, 0.37443477f, 0.02545442f, -0.23215988f, 0.09522958f, 0.18285774f, 0.07558853f, 
    0.34816068f, 0.19822672f, 0.20914602f, 0.36000264f, 0.00938603f, -0.07193147f, -0.00054190f, -0.28635553f, 
    -0.00680370f, 0.31039971f, -0.04099279f, 0.14586726f, -0.09329409f, 0.04371316f, 0.15853256f, -0.02677350f, 
    0.08320006f, -0.01179245f, 0.09740058f, 0.14565977f, -0.17959896f, 0.14446278f, 0.16663422f, -0.20144410f, 
    0.13285144f, -0.01134742f, 0.13784567f, 0.03469155f, 0.18656279f, 0.03348845f, -0.08705430f, -0.18075885f, 
    -0.06022292f, 0.05243440f, -0.06811793f, -0.08049538f, 0.00407299f, -0.01055549f, 0.06688152f, -0.01715176f, 
    -0.01422676f, -0.06163729f, 0.06005580f, 0.01628689f, -0.10862711f, -0.11748548f, -0.09606130f, -0.10350068f, 
    -0.06639002f, -0.01227318f, 0.02468515f, -0.04189212f, -0.08910815f, 0.02326949f, -0.09658393f, -0.00952301f, 
    -0.03455670f, -0.11241920f, -0.00215202f, -0.02896743f, -0.08845871f, 0.05092347f, 0.02330210f, 0.01509317f, 
    -0.08012322f, 0.03478181f, -0.03452185f, -0.06009635f, 0.06919529f, -0.04831774f, 0.01933747f, 0.05689318f, 
    -0.02699524f, -0.01737620f, -0.02158528f, -0.10334257f, -0.02758353f, 0.01301772f, -0.03731101f, 0.02182825f, 
    0.02165597f, 0.00648733f, 0.09034438f, -0.02762555f, 0.03740125f, -0.09199674f, -0.06380302f, -0.00024824f, 
    -0.05016730f, -0.09000974f, -0.01945581f, 0.00484074f, -0.03222949f, -0.10983263f, 0.00072226f, 0.00482599f, 
    0.05386421f, 0.02176005f, -0.02718453f, 0.07845851f, 0.07358239f, -0.02743223f, -0.05625219f, -0.10275503f, 
    0.02834069f, -0.06742710f, -0.03237519f, -0.06796738f, -0.06792573f, -0.08691181f, -0.04767279f, -0.07534274f, 
    -0.06859107f, -0.09732783f, -0.05713544f, -0.00731109f, 0.03698598f, -0.03423405f, 0.04047116f, -0.12414525f, 
    -0.01378105f, -0.04149821f, 0.05266124f, 0.07549075f, -0.03347092f, -0.03796812f, -0.06815472f, -0.06932696f, 
    -0.10210419f, -0.10596041f, 0.03198939f, 0.04479070f, 0.07764903f, 0.07914636f, 0.03316567f, 0.01102955f, 
    0.06807140f, -0.06033303f, -0.00973460f, -0.03530149f, -0.05390659f, 0.04044541f, -0.03671207f, -0.05095045f, 
    -0.03371793f, -0.03924528f, -0.08140008f, -0.04685191f, -0.04005386f, 0.02477442f, 0.07088020f, 0.07340954f, 
    -0.02315283f, -0.07468184f, -0.11468372f, -0.05590758f, 0.00001446f, 0.07040101f, 0.00402140f, -0.04056024f, 
    0.38092211f, -0.09475309f, -0.00289114f, 0.21064819f, -0.15578206f, 0.03640914f, 0.10693418f, 0.10235445f, 
    -0.03736761f, 0.03898546f, -0.09063992f, -0.06258345f, 0.15202016f, -0.04426409f, -0.17417622f, 0.09012320f, 
    -0.13932985f, -0.44170818f, 0.21019551f, 0.02316208f, 0.00138141f, -0.07335192f, -0.01638691f, -0.06358970f, 
    -0.19301327f, -0.02651157f, -0.02877848f, 0.12850855f, -0.12997182f, -0.25816143f, 0.06212116f, 0.05096932f, 
    -0.08110904f, 0.08948120f, 0.36681977f, 0.09947321f, -0.07028276f, -0.01113249f, 0.80180615f, 0.03960986f, 
    0.26214981f, 0.11130019f, 0.15503810f, -0.20085199f, -0.35202658f, -0.30312765f, 0.29559523f, -0.05093510f, 
    -0.14464273f, -0.07465411f, 0.16250585f, 0.04760204f, -0.47625217f, 0.15331791f, -0.11986072f, 0.03794513f, 
    0.06261729f, 0.07004946f, 0.07331678f, 0.06122981f, 0.25446972f, 0.18364283f, 0.11549013f, -0.34459758f, 
    0.01796606f, -0.08898249f, 0.01014107f, -0.13048157f, 0.05384504f, 0.12748593f, 0.53243959f, 0.28389850f, 
    -0.29652447f, -0.23177972f, -0.02205753f, -0.05497476f, 0.01753531f, 0.17600198f, 0.19736087f, -0.28137583f, 
    -0.00579555f, 0.07808174f, 0.11925227f, -0.08561390f, -0.11563169f, 0.02527518f, 0.22220212f, 0.12427925f, 
    0.18113568f, 0.01907795f, 0.13427877f, -0.05677526f, 0.01244971f, -0.02652042f, -0.04887324f, 0.04126272f, 
    0.42607933f, 0.10593095f, 0.17569977f, 0.27079657f, -0.07478489f, -0.20776469f, -0.04199566f, -0.07795621f, 
    0.05742997f, 0.25880507f, -0.42096779f, 0.11734765f, -0.35890007f, 0.17038205f, -0.02160497f, -0.08079799f, 
    -0.02773031f, -0.05638734f, 0.03233236f, 0.10304094f, 0.06791326f, -0.52898532f, 0.10335962f, -0.27647111f, 
    0.09550762f, 0.21061170f, 0.08891956f, 0.10072238f, 0.03002261f, -0.21401146f, -0.24651286f, -0.00225356f, 
    -0.02640903f, -0.08196047f, -0.01712427f, 0.03802484f, 0.01857305f, -0.04377536f, 0.00533987f, -0.02165463f, 
    -0.04656282f, -0.08300113f, -0.05202125f, -0.05233592f, -0.02778174f, 0.04131321f, -0.03233062f, -0.00634147f, 
    0.05534612f, 0.03012550f, 0.06161150f, -0.05745857f, -0.02743891f, 0.07083384f, 0.03964214f, -0.05184505f, 
    -0.09114630f, -0.01039658f, 0.01177876f, 0.00135470f, -0.05294591f, -0.00671898f, 0.07713514f, -0.08916531f, 
    -0.04667683f, -0.00653304f, 0.08606360f, 0.01261440f, -0.03106628f, -0.02239633f, -0.04603868f, -0.07019283f, 
    0.04565502f, -0.03772438f, 0.04202980f, 0.04566487f, 0.07208541f, -0.03870738f, 0.01815611f, -0.02197299f, 
    -0.08059468f, 0.01250208f, -0.03880923f, 0.05420890f, -0.06134117f, -0.06651411f, -0.07998780f, 0.06355134f, 
    0.08052725f, 0.02377127f, -0.07320169f, 0.00068281f, 0.00755095f, -0.07568170f, 0.02049378f, -0.06108416f, 
    -0.00164680f, -0.05597875f, -0.07815784f, -0.05985860f, -0.02095183f, 0.02167618f, 0.03756604f, 0.07636237f, 
    -0.07718818f, 0.08258861f, 0.05445018f, 0.08642995f, -0.01649896f, 0.00114345f, -0.06625938f, -0.02071679f, 
    0.00390587f, 0.04182131f, -0.04247072f, 0.06021741f, -0.06565367f, -0.03816099f, -0.01103771f, -0.03297092f, 
    -0.08069961f, -0.05629086f, 0.04941060f, 0.02149742f, 0.04526622f, 0.05971300f, 0.06788391f, 0.02551341f, 
    -0.08605908f, 0.02550826f, -0.02446648f, -0.02174941f, 0.00233927f, -0.08462410f, 0.02376757f, -0.06508762f, 
    0.01306490f, 0.07974820f, 0.00715095f, -0.03219846f, -0.03916415f, -0.05543813f, 0.04866128f, -0.06091534f, 
    -0.01953530f, 0.04959284f, -0.03902545f, -0.01311381f, 0.03022896f, -0.08461885f, -0.04357935f, 0.03830561f, 
    0.04170350f, 0.00936516f, 0.01591612f, 0.00975541f, -0.09264316f, 0.03442819f, 0.07570803f, 0.01834308f, 
    -0.12219206f, 0.19633837f, 0.17977354f, 0.03542378f, 0.04358775f, -0.27411491f, -0.04338158f, -0.10548635f, 
    0.17490819f, -0.05460982f, 0.13844600f, -0.05023657f, 0.12857728f, 0.09228867f, -0.27440855f, -0.26089451f, 
    -0.01520161f, 0.19273007f, -0.12379233f, 0.02610069f, 0.16906756f, -0.10419039f, 0.02049541f, -0.00293002f, 
    0.07570967f, 0.13748738f, 0.21972638f, -0.02210962f, 0.11707664f, -0.32111695f, -0.03309304f, -0.09696753f, 
    -0.16995746f, 0.24986674f, 0.39571950f, -0.29925230f, 0.13681376f, -0.02727789f, -0.14444348f, -0.14883199f, 
    0.39437601f, 0.16381970f, -0.13940981f, 0.27319211f, -0.02139547f, 0.50637591f, -0.10846311f, 0.20352717f, 
    0.02345615f, 0.51208127f, -0.13014241f, 0.01495047f, -0.27030581f, -0.06064038f, 0.27696019f, 0.01749640f, 
    0.03624208f, 0.27595887f, 0.12940913f, -0.18898235f, 0.21205011f, -0.01560565f, 0.05239922f, 0.04454890f, 
    0.04352758f, 0.01012124f, 0.12453510f, 0.00141255f, 0.05491693f, 0.31951061f, 0.17646235f, 0.32519087f, 
    -0.08148674f, 0.09556124f, 0.21094613f, -0.06649724f, 0.21703179f, 0.23167436f, -0.14043128f, -0.17236510f, 
    0.19470339f, 0.20412040f, 0.01921028f, -0.35575426f, 0.00813844f, -0.09548524f, -0.33637732f, 0.24886926f, 
    0.16117582f, 0.14184016f, -0.11784528f, 0.03257129f, 0.08040366f, 0.05285569f, 0.26593927f, 0.01848180f, 
    0.21361017f, 0.05832858f, -0.28900987f, 0.01003827f, -0.04630172f, 0.24528465f, 0.03777297f, 0.04277041f, 
    -0.05498817f, 0.04770231f, -0.18827963f, -0.02326021f, -0.01826923f, 0.10085493f, 0.01851631f, 0.11175793f, 
    0.00637650f, -0.27443087f, -0.08037855f, 0.05514808f, 0.06724963f, -0.10710143f, -0.08741418f, 0.15769576f, 
    0.01418512f, -0.06146489f, 0.12391241f, 0.19284885f, 0.06406571f, -0.01718107f, 0.04069531f, -0.03664352f, 
    0.18301280f, 0.02501917f, 0.20152754f, 0.09956028f, -0.07735603f, 0.21687108f, -0.03483845f, -0.07153683f, 
    -0.05767527f, 0.00323683f, 0.09444450f, 0.15235041f, 0.04871174f, 0.24434932f, 0.03992558f, 0.13921925f, 
    -0.03221729f, 0.03795377f, 0.02538461f, -0.09699584f, 0.00681819f, 0.02050506f, 0.03700077f, -0.05268234f, 
    -0.03303148f, 0.04006581f, -0.01655336f, -0.00960440f, -0.22149226f, -0.44589922f, -0.09849320f, -0.16952628f, 
    -0.17299666f, -0.00426928f, 0.58758175f, 0.01137909f, 0.09764193f, 0.09747086f, 0.41695270f, -0.21697597f, 
    0.14914297f, -0.04531725f, -0.06629679f, 0.46538794f, 0.00396578f, 0.66116869f, 0.28891778f, -0.02329939f, 
    0.26355198f, 0.09504895f, -0.15152407f, -0.06929070f, 0.26179343f, 0.03593519f, 0.23390783f, -0.00952384f, 
    0.07873765f, 0.14564000f, 0.08227110f, 0.09408765f, 0.29067439f, 0.06517454f, 0.14613236f, 0.01533637f, 
    0.14392278f, -0.02610644f, -0.09010909f, 0.03393837f, 0.01021085f, -0.01897821f, 0.26834941f, 0.10457094f, 
    -0.14339349f, 0.11883852f, 0.16988428f, -0.02253654f, 0.01165797f, 0.05460461f, 0.25061935f, 0.06436981f, 
    0.25179878f, 0.01217585f, 0.10202534f, 0.15496200f, 0.11160567f, 0.18108352f, -0.13133182f, 0.22298120f, 
    0.01539617f, -0.01443613f, -0.28128648f, 0.04634911f, 0.06170100f, 0.19098035f, 0.03940969f, -0.06545816f, 
    0.09713386f, 0.02333829f, 0.02304961f, 0.26481155f, 0.03342346f, 0.31349212f, -0.07640877f, 0.00648663f, 
    -0.05630707f, 0.03007087f, -0.18460111f, -0.05109512f, 0.06398975f, -0.17499581f, 0.00708770f, -0.10874463f, 
    0.02177070f, 0.02583737f, -0.13134073f, 0.09218392f, 0.28711656f, -0.03996412f, 0.03013001f, 0.08449353f, 
    -0.20553513f, -0.17016116f, -0.04934599f, -0.04125190f, -0.06161007f, -0.17630050f, 0.37017635f, -0.00505985f, 
    -0.18730128f, -0.48500854f, -0.13906176f, -0.34225580f, -0.06647582f, -0.37098178f, 0.26343912f, 0.16069312f, 
    -0.54180431f, -0.13972640f, -0.52016121f, -0.28021443f, 0.14034803f, -0.20030609f, 0.31424391f, 0.09348757f, 
    -0.22921996f, -0.29721302f, 0.17377727f, 0.46564859f, -0.02540155f, -0.14031844f, 0.31251052f, -0.05887926f, 
    -0.25389206f, 0.22263052f, -0.04092013f, -0.14997743f, 0.12510645f, 0.05289823f, 0.00157959f, 0.17471658f, 
    -0.02938670f, -0.11394801f, -0.22080567f, 0.31223661f, 0.25908741f, 0.09212903f, -0.03681160f, -0.14231516f, 
    -0.18414435f, 0.40886644f, -0.08635913f, 0.00834600f, -0.19764990f, 0.16201816f, 0.22426376f, 0.10958821f, 
    -0.29196411f, -0.15265602f, 0.17348205f, -0.15224990f, 0.44742259f, -0.11562734f, -0.01986218f, 0.07204190f, 
    0.02093163f, -0.48841301f, 0.12913352f, 0.25137997f, -0.15418525f, -0.04818409f, -0.01802547f, 0.34551224f, 
    -0.19409378f, 0.01555477f, -0.13720231f, 0.14372788f, 0.04183080f, -0.32598177f, -0.16120876f, -0.32453540f, 
    0.01565279f, -0.23467278f, -0.08213462f, -0.05938751f, -0.15983939f, -0.10982807f, -0.19254525f, 0.17879723f, 
    -0.15876675f, 0.27331209f, -0.27702820f, -0.51577014f, -0.20304051f, -0.11525676f, -0.17243855f, -0.05818713f, 
    -0.02446002f, 0.08519283f, -0.01491000f, -0.05973290f, -0.06115906f, 0.02212260f, -0.11737098f, -0.03663809f, 
    -0.32222122f, 0.01037100f, -0.15968418f, 0.13369438f, -0.02854588f, 0.03175617f, -0.02550328f, -0.41918078f, 
    -0.09199126f, -0.04519895f, 0.04800972f, -0.11433909f, 0.00469509f, 0.08379043f, 0.29316485f, 0.23412021f, 
    0.16940980f, 0.22978361f, -0.01515331f, 0.10203211f, -0.30136719f, 0.19941941f, 0.11026450f, -0.23257652f, 
    0.31728607f, 0.01770303f, 0.14890037f, -0.37882406f, -0.01691757f, -0.05198561f, 0.02655452f, 0.22301619f, 
    0.04929887f, -0.06273288f, -0.07064427f, 0.15468676f, -0.01887052f, 0.18540025f, -0.05346616f, -0.01371059f, 
    0.24353606f, 0.20873627f, -0.02407582f, -0.24273424f, -0.06485923f, -0.23448350f, -0.01930920f, -0.38428020f, 
    -0.06635375f, 0.05186433f, 0.07104838f, -0.36528856f, -0.36706144f, -0.53503966f, -0.17766476f, 0.08799442f, 
    -0.07413729f, -0.29603702f, 0.23243631f, 0.03972995f, 0.26193205f, 0.31995723f, 0.00924671f, -0.17649460f, 
    0.11623406f, 0.18950093f, -0.15432109f, -0.36593556f, -0.15311940f, -0.04832716f, 0.15760818f, 0.19798747f, 
    0.56190473f, -0.48213217f, 0.16320544f, -0.27507123f, -0.14888902f, -0.04432346f, -0.12541378f, 0.18231423f, 
    -0.08260948f, 0.03058397f, 0.10313202f, 0.15886466f, -0.25033072f, -0.07978120f, -0.48962006f, 0.07241102f, 
    0.08649989f, 0.01350245f, -0.16923159f, -0.16453008f, -0.36745718f, 0.18407108f, 0.00005404f, -0.22305064f, 
    -0.18830213f, 0.01850078f, 0.51698190f, 0.13306983f, -0.08774305f, -0.60681444f, -0.05515243f, 0.20187862f, 
    0.33879587f, -0.37650806f, 0.04166079f, 0.00285602f, 0.04360900f, 0.44396514f, -0.19843078f, -0.17236818f, 
    -0.23442045f, -0.26320425f, 0.21971759f, 0.57316297f, -0.00400433f, -0.01901018f, 0.14241379f, 0.09433281f, 
    0.40342492f, 0.01684358f, 0.20620511f, 0.08291648f, 0.09294305f, -0.01527388f, 0.25793424f, 0.07461263f, 
    0.45008877f, 0.13818447f, -0.18910427f, 0.23532306f, -0.03172748f, -0.57089484f, 0.21801244f, 0.14343035f, 
    -0.06944247f, -0.31242973f, 0.37386492f, 0.23516780f, -0.22279207f, 0.26989082f, -0.30185738f, 0.50907987f, 
    -0.14992717f, 0.02677441f, 0.08092286f, -0.61790740f, -0.18071000f, -0.05672030f, -0.12677491f, -0.05562349f, 
    -0.19846261f, 0.37816653f, 0.05824770f, 0.24374676f, 0.10671526f, 0.04872617f, -0.04814234f, -0.44157964f, 
    -0.07079615f, -0.01939361f, -0.06427038f, 0.05464885f, -0.07968251f, 0.02404911f, 0.04147620f, -0.07407022f, 
    0.01348165f, -0.05839528f, 0.07731703f, -0.01396365f, -0.03019016f, -0.06767815f, 0.06477144f, 0.01155992f, 
    -0.08317661f, 0.03099370f, -0.10018376f, 0.06298632f, 0.01153307f, -0.03059028f, 0.00839339f, 0.06578262f, 
    -0.07442867f, -0.09082922f, 0.04242135f, -0.08227510f, -0.09251584f, 0.05955688f, 0.06767642f, -0.03750594f, 
    0.01915939f, -0.09491945f, -0.00329935f, 0.00436182f, 0.02481160f, -0.02751302f, 0.06033358f, -0.08042729f, 
    0.00892550f, 0.04326570f, -0.08766023f, -0.03118650f, 0.01857355f, -0.03096163f, 0.06058609f, -0.08706805f, 
    -0.09729815f, -0.05709442f, -0.09200829f, 0.07467427f, 0.02740683f, 0.02955664f, 0.04041217f, -0.03754823f, 
    0.07481398f, -0.06963256f, 0.01667275f, -0.05148162f, -0.08369590f, -0.04316664f, 0.02087377f, -0.04979567f, 
    0.00088131f, 0.05618512f, -0.08064828f, 0.06976704f, 0.01315646f, -0.00388922f, 0.07189926f, -0.00646167f, 
    -0.03180839f, -0.03345079f, -0.06445733f, 0.00224536f, -0.08395499f, 0.06200662f, 0.04423536f, -0.00070269f, 
    -0.04147417f, -0.03783971f, 0.05307732f, 0.03493612f, -0.00886725f, -0.00867610f, 0.00547107f, 0.04035988f, 
    -0.05312246f, 0.05595236f, -0.04409654f, -0.01456824f, 0.04470677f, -0.07557646f, 0.01341488f, 0.06764470f, 
    0.06502458f, -0.06353014f, -0.00364190f, -0.05780423f, -0.05943996f, -0.04595700f, -0.02823004f, -0.06687156f, 
    0.02200489f, -0.05554238f, -0.02457275f, -0.01072832f, 0.08746538f, -0.04323277f, 0.02310150f, 0.03684754f, 
    -0.09409539f, -0.09401676f, 0.06245838f, -0.04107039f, 0.04664942f, -0.04076238f, -0.02979140f, 0.00243235f, 
    -0.04190838f, 0.00562394f, -0.08174323f, -0.00705004f, -0.03139050f, 0.03971889f, -0.07900624f, 0.04740836f, 
    -0.27133957f, -0.44676629f, 0.28758112f, -0.09380440f, -0.38542700f, 0.21245724f, 0.08545609f, 0.04219632f, 
    0.01305231f, 0.00843604f, -0.08720668f, 0.09920965f, 0.07575518f, 0.05090994f, 0.14068025f, -0.10009116f, 
    -0.11322571f, -0.13328537f, 0.00632539f, 0.27839997f, -0.27623963f, -0.15491253f, 0.15046109f, 0.00562632f, 
    -0.22843137f, 0.09177674f, 0.03716761f, 0.15023318f, 0.31874457f, 0.60282576f, 0.01437448f, 0.13904609f, 
    0.28044310f, -0.07918787f, 0.02269522f, 0.37301025f, 0.33782372f, -0.18337858f, -0.39746892f, -0.02919522f, 
    -0.19011693f, -0.14782543f, 0.13238150f, 0.03782785f, -0.08053505f, -0.09238945f, 0.09868671f, 0.21629168f, 
    -0.25127178f, -0.12771055f, 0.00512909f, -0.09179725f, 0.42079920f, 0.12177155f, -0.15207252f, 0.00542764f, 
    -0.00888967f, -0.27808523f, -0.14931901f, -0.09945019f, -0.20487735f, -0.14389296f, 0.14826930f, 0.30206034f, 
    -0.30681700f, 0.35067537f, 0.18497404f, 0.35079518f, -0.01922542f, -0.26697141f, -0.05832493f, -0.11983654f, 
    0.42041409f, -0.16329496f, -0.05548695f, 0.10120635f, -0.07118915f, -0.29088607f, 0.17348118f, 0.27058107f, 
    -0.08917090f, -0.07403059f, -0.02691557f, -0.44434434f, -0.26931435f, 0.03958483f, 0.27620232f, -0.18920904f, 
    -0.08335125f, 0.02039445f, 0.38078150f, 0.04115328f, -0.01507774f, 0.00659396f, 0.16518532f, -0.06185287f, 
    -0.01937316f, 0.23388542f, -0.00325432f, 0.05770860f, -0.02056812f, 0.20452790f, -0.04967044f, -0.14334154f, 
    -0.06522761f, -0.17720240f, 0.55500358f, 0.00065303f, 0.19312149f, -0.37300873f, 0.22280189f, 0.12657051f, 
    0.02991028f, 0.10541646f, 0.19435276f, -0.03759526f, 0.08472624f, 0.80441236f, -0.28575289f, -0.19381882f, 
    0.19469629f, 0.07074021f, -0.04400649f, 0.13695708f, -0.03777789f, 0.38935751f, -0.12729613f, 0.03572362f, 
    0.25643271f, 0.07737525f, 0.04115663f, 0.00066311f, 0.07438593f, 0.22689384f, 0.17772657f, -0.15302083f, 
    0.00424424f, 0.08207716f, 0.02740245f, -0.04225290f, 0.06974512f, -0.03054423f, -0.21655522f, -0.22222403f, 
    0.00227617f, -0.04443342f, 0.07136809f, -0.51087838f, 0.05135209f, 0.01110442f, -0.11867458f, -0.00934087f, 
    0.00726863f, -0.71468568f, 0.03809746f, 0.14721647f, 0.00865642f, -0.01777850f, 0.00824726f, -0.23951627f, 
    0.02706964f, -0.20177560f, 0.04740295f, -0.21554416f, -0.12645456f, -0.01299810f, -0.12088136f, 0.13212620f, 
    0.39492860f, -0.56713557f, 0.17668596f, -0.11255509f, 0.09467678f, -0.10024131f, -0.07351776f, 0.00035411f, 
    -0.19085163f, -0.09019981f, -0.06351499f, 0.11691874f, -0.07629299f, 0.27174798f, -0.20917782f, 0.01570793f, 
    -0.03414551f, 0.00338655f, -0.16076958f, -0.20580482f, 0.14043553f, 0.04759546f, -0.06776770f, 0.06130905f, 
    0.01282740f, 0.11844728f, -0.04119667f, -0.16402300f, 0.07380307f, -0.38344166f, 0.00333216f, 0.10736316f, 
    0.10765120f, 0.18571889f, -0.07069623f, 0.01675064f, -0.02924276f, 0.35922274f, -0.14884180f, 0.08563451f, 
    0.13812023f, -0.67182422f, -0.01552700f, 0.52634490f, 0.05844951f, 0.10955254f, 0.09685342f, -0.17729834f, 
    0.37785581f, -0.08957136f, -0.04241809f, -0.07517034f, 0.03790848f, 0.08054196f, 0.43805382f, 0.00140430f, 
    0.44387680f, 0.15767400f, 0.05084485f, 0.06859242f, -0.00239778f, -0.23530863f, 0.07916710f, -0.05993739f, 
    0.03367925f, -0.28376219f, 0.12042330f, 0.28315482f, -0.06975526f, 0.09491152f, -0.09840160f, 0.20721218f, 
    -0.06813070f, -0.06881324f, 0.15623716f, -0.58917755f, -0.12572689f, -0.10281561f, -0.11250338f, 0.08447137f, 
    -0.11930927f, 0.40917534f, -0.00584990f, -0.05886725f, 0.20985167f, 0.01691682f, 0.16891183f, -0.20187302f, 
    0.02403493f, 0.08281445f, -0.05043580f, 0.02234334f, -0.03836067f, 0.03171040f, -0.07650952f, 0.01281052f, 
    -0.07833707f, -0.05968782f, -0.08262255f, -0.02444950f, -0.10979933f, -0.02312124f, 0.02679761f, -0.10898585f, 
    0.00352368f, -0.08070013f, -0.02972564f, 0.04240026f, -0.06635449f, 0.00299073f, 0.03795774f, -0.00676814f, 
    -0.10290127f, -0.06395517f, -0.03398351f, -0.05978809f, -0.05215838f, 0.04954672f, 0.08026341f, 0.06606144f, 
    -0.03369002f, -0.00101149f, -0.02718401f, -0.08130685f, 0.00571212f, -0.00061112f, 0.04681332f, -0.04930069f, 
    -0.11215127f, 0.02156204f, 0.01313026f, 0.01747391f, 0.05560151f, -0.10221539f, 0.07346564f, 0.06774248f, 
    -0.08944955f, -0.06008949f, -0.07972442f, -0.04379730f, -0.05601246f, 0.06785773f, 0.02944661f, 0.08623025f, 
    0.08434922f, -0.02107542f, -0.10605488f, -0.09975903f, 0.05994964f, -0.05964668f, -0.06870966f, 0.02253285f, 
    0.02375448f, -0.06589659f, -0.08107246f, -0.01618853f, -0.03248845f, -0.07732597f, 0.04125297f, 0.00141613f, 
    -0.02874264f, -0.07251570f, 0.07199074f, -0.02229665f, -0.02785135f, -0.03851056f, 0.04612491f, -0.04129593f, 
    0.00648470f, -0.08024933f, -0.03245566f, -0.11713073f, -0.12144304f, -0.08867583f, 0.01762172f, -0.11784023f, 
    -0.06443576f, -0.02562590f, 0.00080152f, -0.00173795f, -0.09752648f, -0.01442247f, -0.03104014f, 0.04300928f, 
    0.02583797f, 0.05760335f, -0.05772055f, 0.00027079f, 0.06398703f, 0.05554270f, 0.06006456f, 0.00767450f, 
    -0.05861473f, -0.07780236f, 0.01792241f, -0.08788995f, 0.00543854f, 0.03862022f, 0.01222760f, -0.07424003f, 
    -0.05086327f, -0.06222191f, -0.01500863f, -0.04880508f, -0.03563957f, -0.02961314f, -0.04914957f, 0.08592552f, 
    0.05139520f, -0.02762510f, 0.03019903f, -0.05701135f, -0.08135988f, 0.02699088f, 0.02940639f, -0.00428423f, 
    -0.26553747f, -0.03811412f, -0.17187291f, 0.16397592f, 0.05073036f, 0.02800482f, 0.01729247f, 0.27298009f, 
    -0.09428888f, 0.08807058f, -0.12461901f, -0.32884532f, 0.15168305f, -0.03765171f, 0.02382801f, -0.32552311f, 
    0.00126093f, -0.24611419f, 0.23721923f, 0.43881571f, -0.03638416f, -0.23623294f, 0.11652499f, 0.07562735f, 
    -0.24908966f, 0.34939817f, 0.00104089f, -0.06902614f, -0.03240641f, -0.02926998f, -0.05932184f, 0.10195789f, 
    0.11093852f, -0.08238634f, 0.54193312f, 0.39414081f, -0.05497077f, -0.09272262f, 0.16093269f, -0.11366735f, 
    -0.18413073f, 0.43485552f, 0.11582442f, 0.02279400f, -0.20833673f, -0.14402670f, 0.22550231f, -0.25628102f, 
    -0.32651332f, -0.25434604f, 0.12053061f, -0.00755405f, -0.17497960f, -0.22776839f, -0.35785887f, 0.00555297f, 
    0.07946073f, 0.07058322f, 0.22787182f, 0.34558854f, 0.05064262f, -0.03361847f, -0.16911820f, 0.20256975f, 
    -0.38525376f, -0.10681468f, -0.04946864f, -0.00310678f, -0.02992764f, 0.24001794f, 0.35497501f, 0.24927863f, 
    -0.02210655f, -0.24627003f, -0.01015556f, -0.07282020f, -0.11809780f, -0.01815678f, -0.05808429f, 0.02139900f, 
    -0.05176888f, 0.13106702f, -0.09613111f, -0.38570884f, 0.14567809f, -0.15114623f, -0.29813015f, 0.32296771f, 
    0.07640255f, -0.04498851f, 0.21755058f, -0.02665553f, -0.08339184f, -0.01803388f, -0.06806266f, -0.07961937f, 
    -0.02677291f, 0.23532988f, 0.20908721f, 0.29007715f, 0.07611512f, -0.52287281f, 0.21059135f, -0.20952590f, 
    -0.01030975f, 0.39308390f, -0.37983572f, 0.18089229f, -0.40389571f, 0.05383475f, 0.20114191f, -0.16094732f, 
    0.01435229f, -0.04551309f, 0.03464014f, 0.11281339f, -0.22763397f, 0.17638654f, 0.34850258f, -0.28626251f, 
    0.11687896f, -0.03192909f, 0.15634798f, -0.07968569f, 0.06540032f, -0.29277429f, -0.45979711f, -0.04312004f, 
    -0.08609958f, 0.32145840f, -0.01717061f, 0.04772121f, 0.18741634f, 0.12647925f, -0.18730526f, -0.18197788f, 
    0.15940133f, 0.12375337f, 0.09204277f, -0.03826588f, -0.18860373f, 0.04817208f, -0.08351962f, -0.16920662f, 
    0.04109716f, -0.07771473f, 0.01500611f, -0.10965452f, 0.03491301f, -0.33347216f, -0.05979021f, -0.06745954f, 
    0.25434911f, -0.26030999f, -0.07337791f, -0.05576167f, 0.25896484f, 0.28212419f, -0.03694097f, -0.31559855f, 
    0.09856853f, 0.30524176f, -0.13107274f, -0.47209468f, -0.29030675f, -0.32168972f, -0.74999905f, 0.10218988f, 
    0.11168368f, -0.13876212f, -0.01500821f, 0.68170315f, -0.04998428f, 0.68113697f, 0.09204993f, 0.08115588f, 
    -0.16106348f, 0.19756138f, 0.02187778f, 0.16111585f, -0.22441250f, -0.01602872f, 0.10142415f, 0.06126036f, 
    0.04011481f, 0.00233704f, 0.02833482f, 0.10200800f, -0.04363564f, 0.16236375f, -0.02605036f, -0.52287000f, 
    0.06542831f, 0.00405336f, 0.28829688f, 0.08652471f, 0.03230802f, -0.15133992f, 0.15347029f, 0.07901478f, 
    0.31818318f, 0.08465886f, 0.12689222f, -0.10800303f, 0.15261772f, 0.13425356f, -0.02453831f, 0.01885741f, 
    -0.03110065f, -0.16986735f, -0.03657533f, 0.10737746f, 0.17337148f, -0.20820153f, 0.05878154f, 0.08369490f, 
    -0.14021853f, 0.00595805f, -0.05757996f, 0.07927943f, -0.06762036f, 0.01995176f, 0.11237933f, -0.05441561f, 
    0.09294167f, -0.09172817f, 0.12666520f, -0.00469290f, -0.01726982f, 0.01338310f, 0.07690948f, 0.21994630f, 
    0.06960464f, -0.21349443f, -0.11855797f, 0.15450640f, 0.05259314f, -0.26366833f, -0.27341029f, 0.05050775f, 
    -0.13058093f, -0.19392006f, 0.03941375f, -0.31822467f, 0.09928730f, -0.11743226f, 0.05810757f, 0.05137456f, 
    -0.16900976f, -0.08662274f, 0.04144697f, -0.00608763f, -0.08228048f, -0.10454498f, 0.16126145f, -0.34046733f, 
    0.25492433f, -0.31848830f, 0.17487401f, -0.03153656f, -0.32725966f, -0.28770602f, 0.22956233f, 0.01497145f, 
    -0.15968320f, -0.02455744f, -0.27728546f, -0.01626354f, -0.02526276f, 0.02678048f, 0.17544392f, -0.08220262f, 
    -0.12099650f, 0.14909679f, 0.04922599f, -0.17921108f, 0.03342205f, -0.21558188f, 0.00712112f, 0.04141560f, 
    -0.16872659f, -0.02559824f, 0.13525885f, 0.12370782f, 0.04649659f, -0.37057325f, 0.04266951f, 0.00269957f, 
    -0.05677816f, -0.23742557f, -0.17067070f, -0.12569994f, 0.08162196f, 0.20377827f, 0.43653277f, -0.25572520f, 
    0.18173712f, 0.08818161f, -0.06960320f, 0.10553548f, 0.01788409f, 0.13445103f, 0.04000817f, 0.09190763f, 
    -0.00458299f, -0.07376854f, 0.02810839f, -0.00951996f, 0.32341775f, 0.29744583f, 0.06989525f, 0.01320024f, 
    0.04680963f, -0.30149877f, 0.04254256f, 0.16341862f, 0.12539163f, 0.06328735f, 0.08208070f, 0.16345543f, 
    -0.11441096f, 0.07822194f, -0.32939586f, 0.14775595f, 0.02989706f, -0.27355170f, -0.11141881f, 0.06178889f, 
    0.12178536f, -0.25285417f, -0.18522511f, 0.12270923f, 0.08944066f, 0.21820900f, -0.15391201f, -0.05891318f, 
    -0.08265182f, 0.09461280f, 0.11380804f, -0.27213207f, -0.08039535f, 0.31820333f, -0.06111890f, -0.00120176f, 
    0.24011691f, -0.10624728f, 0.06986464f, 0.06311571f, 0.06374615f, 0.18964387f, 0.32974398f, 0.01846413f, 
    0.18188882f, 0.16361769f, -0.24899568f, 0.17996442f, 0.02115725f, 0.02451306f, 0.00577791f, -0.24116255f, 
    0.04459760f, -0.15309173f, 0.28750381f, -0.15578778f, -0.00731930f, -0.20133997f, 0.03230874f, 0.17089109f, 
    -0.01605523f, 0.04356311f, 0.09524067f, -0.03862431f, 0.02324094f, 0.03031083f, -0.01841168f, -0.04666369f, 
    -0.13320960f, 0.02230463f, -0.13712920f, -0.11344010f, 0.21061313f, -0.16306919f, 0.66396105f, 0.10354847f, 
    -0.00141656f, -0.26253989f, 0.00902923f, 0.05502982f, -0.14542347f, -0.07347563f, 0.06110017f, 0.05217055f, 
    -0.06108833f, -0.00699128f, -0.12755097f, -0.14678007f, 0.09219994f, -0.07181039f, -0.11814019f, -0.15996653f, 
    -0.00811388f, 0.23866567f, -0.00398999f, -0.08324451f, 0.01589643f, -0.28061536f, -0.05260611f, 0.03634667f, 
    -0.03403648f, 0.01693958f, 0.21362755f, 0.02754697f, 0.04295781f, -0.18535420f, -0.03808899f, 0.01221811f, 
    -0.03498968f, 0.12089583f, -0.02758314f, -0.24047847f, -0.06658693f, 0.13368930f, -0.75832498f, -0.02676463f, 
    0.43007040f, 0.17330898f, -0.08087080f, 0.06888054f, -0.10166093f, 0.14403023f, -0.04493560f, 0.15315254f, 
    -0.17288846f, 0.01798712f, 0.16418634f, 0.03431970f, 0.15352832f, 0.08961415f, -0.06219938f, -0.02526983f, 
    0.06024971f, -0.29294929f, -0.00546818f, -0.03456190f, 0.01314829f, 0.00189995f, 0.08986090f, -0.11861655f, 
    -0.02270558f, -0.01543925f, 0.07799696f, 0.12951097f, 0.06028556f, -0.04308607f, -0.07960643f, 0.04819902f, 
    0.17615925f, -0.06688114f, -0.18114510f, -0.13732652f, 0.09798858f, 0.35730085f, -0.22513026f, -0.25077918f, 
    0.04839546f, 0.10617566f, -0.05258412f, -0.28240052f, 0.09326544f, 0.15413222f, -0.12727118f, 0.07662275f, 
    0.20999515f, 0.01799991f, 0.15281992f, 0.05843532f, -0.12281586f, 0.08860791f, 0.17864546f, 0.02256216f, 
    0.28199747f, 0.02342640f, -0.20249799f, 0.26208374f, 0.02988105f, -0.17593208f, 0.08684177f, 0.00046553f, 
    -0.06654454f, 0.00321158f, 0.20368122f, -0.01354112f, -0.21443307f, -0.00254338f, -0.11556942f, 0.39424095f, 
    0.01974378f, 0.02091016f, 0.17323956f, -0.03342294f, -0.22705136f, -0.17756042f, 0.04101636f, 0.02740972f, 
    -0.09795348f, 0.09705497f, -0.00711127f, -0.07508409f, 0.18335502f, -0.22626989f, 0.29748169f, 0.18733063f, 
    0.01127057f, -0.37969890f, 0.07497739f, 0.01235384f, -0.20451701f, 0.07863951f, -0.00847335f, 0.29677296f, 
    -0.17530385f, 0.18998514f, -0.10246196f, 0.08281947f, 0.09233673f, 0.15347412f, 0.47902694f, -0.13490695f, 
    -0.09197726f, 0.19193326f, 0.07518531f, 0.01935179f, 0.01697566f, -0.13008229f, -0.05090706f, -0.04118647f, 
    -0.22858113f, -0.09807781f, 0.01991720f, 0.08840676f, -0.00981228f, 0.35901532f, 0.01800074f, 0.18038879f, 
    0.17074288f, -0.08567389f, 0.03371194f, 0.24331474f, -0.07397562f, 0.15064012f, 0.46691534f, -0.15684268f, 
    -0.22730421f, 0.00087401f, 0.06031125f, -0.15329996f, -0.22418936f, -0.51182365f, -0.02503497f, -0.14581250f, 
    0.00194544f, -0.16687010f, 0.12454634f, 0.06246886f, -0.36055571f, 0.04920328f, 0.18929964f, 0.00747197f, 
    0.05459077f, -0.35169402f, 0.02545664f, 0.06955008f, -0.01248478f, 0.11307323f, 0.14708391f, -0.07197735f, 
    -0.15492706f, 0.13644487f, -0.02320332f, 0.09186812f, 0.02419904f, -0.19761911f, 0.10975125f, -0.07978164f, 
    0.03054100f, -0.10851206f, -0.06906483f, 0.00284901f, 0.09563371f, -0.38623407f, 0.14893986f, 0.19707111f, 
    -0.02329922f, -0.15360817f, 0.15580563f, -0.25114229f, 0.02522391f, 0.04758043f, 0.14547233f, 0.06645849f, 
    -0.14629929f, -0.02833450f, 0.45560497f, -0.06264672f, -0.03281554f, 0.13260648f, -0.02914245f, -0.01657045f, 
    -0.04181261f, 0.08169922f, 0.13979031f, 0.07103181f, -0.04860280f, -0.18979453f, 0.01436535f, -0.11092424f, 
    -0.06660596f, 0.11587959f, 0.26673135f, -0.02111585f, -0.14038928f, -0.17341512f, 0.12174082f, -0.16737276f, 
    0.14250430f, 0.33783457f, 0.15053910f, -0.07285733f, 0.23403041f, 0.02406276f, 0.22153166f, 0.02828256f, 
    0.12523402f, -0.04682961f, 0.12588455f, 0.25223735f, -0.09004736f, 0.36383459f, -0.02198139f, -0.17334662f, 
    0.03647925f, -0.04677790f, -0.04428237f, -0.08648609f, -0.10559262f, -0.01827228f, -0.00872255f, -0.03602939f, 
    0.01407172f, 0.00039655f, -0.08286430f, -0.02907261f, -0.08681712f, -0.08723850f, -0.01630543f, 0.07756509f, 
    -0.10921673f, -0.01548583f, -0.09038932f, 0.07213817f, 0.01968941f, -0.00335627f, -0.01894705f, -0.05110881f, 
    -0.06135589f, 0.06320315f, -0.09526464f, 0.03771379f, -0.03288048f, -0.06300302f, -0.03898393f, -0.03775421f, 
    -0.04148772f, 0.06118074f, -0.05987288f, -0.06183960f, -0.07085994f, 0.04827074f, -0.01102769f, -0.00015650f, 
    -0.01740108f, -0.04600422f, -0.01464359f, 0.05680826f, -0.00526572f, -0.01049866f, -0.08532823f, -0.00233635f, 
    -0.04127049f, -0.01510705f, -0.08720309f, -0.08395182f, -0.01799499f, 0.03440684f, -0.05104920f, -0.03002943f, 
    -0.01071262f, -0.11711792f, -0.06221246f, -0.09372897f, -0.02524333f, 0.04489146f, -0.08829696f, -0.06034729f, 
    0.02747032f, -0.00285762f, -0.08590583f, 0.05480469f, -0.03805089f, 0.06814213f, 0.04440839f, 0.00169052f, 
    -0.11564171f, -0.01564950f, -0.00203359f, 0.08113500f, 0.00091519f, 0.03855852f, -0.08602107f, -0.11291254f, 
    -0.08464480f, 0.04318549f, -0.05298306f, -0.06377585f, 0.05572843f, -0.10135100f, -0.01320199f, 0.06637748f, 
    0.00147173f, -0.07537191f, -0.05153785f, 0.08396352f, 0.05146216f, -0.01584519f, -0.01708023f, -0.05415307f, 
    -0.10575633f, -0.04056437f, 0.07683470f, 0.04175105f, 0.07332885f, 0.02934368f, 0.05315061f, -0.05995240f, 
    -0.02260312f, -0.08796526f, 0.04096543f, -0.04247684f, 0.08598138f, -0.02483287f, 0.05693467f, -0.09036569f, 
    0.02426551f, -0.00980482f, 0.05072524f, 0.01089652f, -0.06376715f, -0.09717100f, -0.06141597f, -0.09921674f, 
    -0.06287689f, -0.01176920f, -0.02353697f, 0.03097897f, -0.09361866f, 0.00879918f, -0.01884536f, -0.07270543f, 
    -0.26229012f, -0.56251770f, -0.08535422f, 0.19755132f, 0.39545858f, 0.10382789f, 0.01839768f, 0.19041021f, 
    -0.30321813f, -0.05359163f, 0.19451559f, -0.61569238f, 0.11060694f, -0.26399022f, 0.01575006f, 0.12816627f, 
    -0.19822651f, -0.29514185f, 0.23965764f, 0.15536779f, 0.10862553f, 0.11003354f, 0.14913711f, -0.02183233f, 
    -0.07625978f, 0.18834905f, 0.06296881f, -0.08857436f, -0.09624948f, -0.17329256f, 0.06942141f, 0.17719232f, 
    -0.00373839f, 0.14473364f, 0.26344058f, 0.00919737f, -0.05273353f, 0.06241329f, 0.08805960f, 0.06676214f, 
    -0.30123657f, 0.20999593f, -0.01065447f, 0.04479262f, -0.71065462f, -0.03890261f, 0.32720050f, -0.20849086f, 
    0.08853296f, -0.12992807f, 0.13010167f, 0.00490749f, -0.29541492f, -0.42958245f, -0.00427201f, -0.07713069f, 
    0.03257443f, 0.20166859f, 0.13549608f, 0.11685082f, 0.02774488f, 0.05971197f, 0.02284114f, -0.17206210f, 
    0.17805520f, -0.08334415f, -0.03753736f, -0.01839334f, 0.07721151f, 0.45138812f, 0.37189129f, 0.20483753f, 
    -0.17934877f, 0.18933341f, 0.07739532f, -0.08277913f, 0.03878466f, -0.10717802f, 0.02012757f, -0.14414345f, 
    0.06738576f, 0.08848207f, -0.07778853f, 0.38761353f, -0.10509133f, -0.18380025f, -0.15417816f, 0.12787542f, 
    0.01293242f, 0.14274246f, 0.21324089f, -0.08969382f, -0.18504696f, -0.03244175f, -0.15672535f, 0.05270578f, 
    0.03149476f, -0.02701852f, 0.32570761f, -0.03615049f, 0.01344095f, -0.01451250f, -0.08610001f, -0.31170532f, 
    0.01829199f, 0.23581874f, -0.40579739f, 0.13417917f, -0.06956039f, 0.21568368f, 0.19847961f, -0.20644735f, 
    0.10889216f, -0.01799361f, 0.08794877f, 0.21895880f, -0.12908681f, -0.46768883f, 0.23846544f, -0.04477335f, 
    0.15407816f, -0.09565427f, 0.20686698f, 0.02611365f, 0.03382942f, 0.02833140f, -0.46262705f, 0.00967500f, 
    -0.25144705f, -0.19060709f, 0.24298184f, -0.07244982f, -0.34037986f, 0.25076467f, 0.13792562f, -0.03693902f, 
    0.19757031f, 0.09530972f, -0.15930858f, 0.00718238f, 0.12132694f, -0.16090985f, -0.07021564f, -0.09508646f, 
    -0.19242501f, 0.09671513f, -0.13327575f, 0.19534564f, -0.25237009f, 0.13664968f, 0.22202647f, 0.08980919f, 
    -0.02389249f, 0.14262836f, 0.17373741f, -0.02912931f, 0.26435235f, 0.48239747f, 0.08703949f, 0.00059982f, 
    0.14109780f, -0.00178296f, -0.13768950f, 0.15170147f, 0.30015281f, -0.15436944f, 0.26499656f, 0.02994612f, 
    -0.11163840f, 0.00504015f, 0.03172768f, 0.39390320f, -0.07882825f, 0.29656708f, 0.18221256f, 0.38587967f, 
    0.09642275f, 0.04736020f, -0.01102669f, -0.09945135f, 0.43734509f, 0.12660924f, -0.16588461f, -0.05144120f, 
    0.00793361f, -0.07488351f, -0.07621817f, -0.06017962f, -0.15309314f, -0.12633148f, 0.10385574f, 0.65474218f, 
    -0.22518273f, 0.34321931f, 0.12027672f, 0.27607840f, -0.04618280f, -0.10012618f, -0.38132671f, -0.13002692f, 
    0.43805462f, 0.28457090f, 0.08133124f, 0.02765919f, -0.04418252f, -0.17030068f, 0.00875400f, 0.08360631f, 
    -0.21141605f, -0.02037438f, -0.04898731f, 0.01514840f, -0.15504378f, 0.09680588f, 0.26264998f, -0.05925658f, 
    0.14704734f, -0.04464614f, -0.02650154f, -0.01129493f, 0.08723860f, -0.00996572f, 0.35685426f, -0.03080533f, 
    -0.00111993f, 0.20257232f, -0.07990704f, -0.00430707f, -0.06172401f, 0.36477003f, -0.05873624f, -0.02141731f, 
    0.02492479f, -0.11202847f, 0.50593442f, -0.14753036f, 0.45670703f, -0.32250527f, 0.14801294f, 0.17550637f, 
    0.05533294f, -0.12335280f, 0.24990052f, -0.00623017f, 0.00339258f, 0.72676414f, -0.22434315f, -0.12571509f, 
    0.09143285f, 0.11482668f, -0.11988769f, 0.19935088f, -0.14245471f, 0.31286871f, 0.08964937f, 0.16866553f, 
    -0.17127003f, -0.38648427f, 0.17541614f, -0.08183534f, -0.10763998f, 0.31610855f, -0.27967626f, -0.11346954f, 
    0.38196248f, -0.09449951f, 0.44393483f, -0.21234706f, -0.04429488f, 0.25694004f, -0.32318360f, 0.21611176f, 
    -0.39899188f, -0.56183422f, -0.01538977f, -0.02581483f, 0.07733385f, 0.36517808f, 0.11981153f, -0.01992452f, 
    0.01148479f, -0.02624264f, 0.09120458f, 0.07134785f, 0.01416891f, 0.18098965f, 0.08462830f, -0.02374338f, 
    -0.16856675f, 0.20979890f, 0.06921336f, -0.01031180f, 0.05154844f, -0.09834787f, -0.40753579f, -0.70265573f, 
    -0.47662246f, -0.06470270f, -0.10408740f, -0.12159441f, -0.08534201f, -0.23420314f, 0.16914350f, -0.06979022f, 
    0.19569822f, 0.01288655f, -0.18082094f, -0.25682822f, -0.39725703f, -0.44230142f, 0.04332366f, 0.02905312f, 
    -0.05985301f, 0.09565148f, 0.13757795f, -0.09828417f, 0.09571803f, -0.31294787f, 0.15739366f, 0.00768023f, 
    0.06290851f, 0.00401814f, -0.20851715f, 0.06369399f, 0.08941024f, 0.21026097f, 0.09826514f, 0.06703825f, 
    -0.06553228f, 0.36396983f, -0.03177759f, -0.03943017f, 0.20056406f, -0.32711932f, 0.05397825f, -0.54345292f, 
    0.20818821f, -0.05021761f, 0.12593947f, 0.37481922f, -0.08022044f, -0.04906040f, -0.66538841f, 0.04932204f, 
    -0.22047569f, 0.09853493f, 0.04585835f, 0.07126847f, -0.16682385f, -0.04671040f, -0.01789506f, 0.07864999f, 
    0.03372887f, -0.16026485f, 0.36677223f, -0.49383724f, 0.07217019f, 0.37852725f, -0.18267950f, -0.28098705f, 
    0.02442342f, -0.04408706f, 0.01806810f, -0.15034948f, 0.46591684f, 0.21252331f, 0.02425071f, -0.12547524f, 
    0.09840190f, -0.04087607f, 0.07013460f, 0.15869977f, 0.30838281f, -0.36833796f, 0.10828696f, 0.01460511f, 
    0.03408244f, -0.34662312f, 0.08246525f, 0.47380838f, -0.01623592f, 0.37875205f, -0.26161119f, -0.03669931f, 
    0.02135118f, 0.01344445f, -0.10810454f, -0.08128828f, -0.06956892f, 0.04497929f, -0.09574209f, -0.05366392f, 
    -0.03112553f, -0.03610291f, -0.01519451f, -0.08806834f, -0.08552649f, 0.02061530f, -0.01316989f, 0.02379663f, 
    -0.02145300f, -0.03532783f, -0.10295967f, -0.05324729f, 0.01239517f, -0.00626103f, 0.05296317f, -0.05716843f, 
    -0.01670747f, 0.03875242f, -0.09611232f, -0.08977095f, -0.07914092f, -0.02260470f, -0.06632025f, -0.09566228f, 
    0.06026926f, -0.08555020f, -0.03960922f, -0.00232215f, -0.09163089f, 0.04648713f, -0.06512938f, -0.00535994f, 
    -0.05472239f, -0.08720080f, -0.06098642f, -0.04828972f, 0.03345954f, -0.03821312f, -0.05334726f, -0.03342513f, 
    -0.07347468f, 0.02658476f, -0.04585023f, 0.02661662f, 0.02002140f, 0.05798887f, -0.06042939f, 0.04277687f, 
    -0.07600493f, -0.02932530f, -0.02501586f, -0.02298327f, -0.03691241f, -0.09910348f, 0.06170745f, 0.04436933f, 
    -0.02626967f, -0.06753355f, 0.04969505f, 0.05133793f, 0.01387800f, 0.02670223f, -0.03447751f, -0.05731074f, 
    -0.06089314f, 0.04545574f, 0.05085940f, 0.03006015f, -0.05491554f, -0.03568978f, 0.07398375f, -0.07832194f, 
    -0.06928793f, 0.01273730f, -0.08611269f, 0.07751347f, -0.01652639f, 0.03424097f, -0.06608192f, -0.06900278f, 
    0.01809324f, -0.02921720f, 0.01600653f, 0.03815811f, -0.03501222f, -0.02043943f, -0.08747385f, -0.08750903f, 
    0.01759217f, 0.05413258f, -0.03710475f, -0.09512487f, 0.02736141f, -0.09368153f, -0.02708329f, -0.01299239f, 
    0.08198419f, 0.06253739f, -0.06531060f, -0.05364399f, 0.00263461f, -0.08296838f, -0.10408943f, -0.11186245f, 
    0.02860924f, -0.08577562f, -0.02802630f, -0.10897109f, -0.09726726f, 0.03398760f, 0.04395107f, -0.08130471f, 
    0.04693658f, -0.01914001f, 0.06238127f, -0.03781821f, -0.07630665f, 0.06306323f, -0.09837645f, 0.00072163f, 
    -0.00209666f, -0.02602321f, 0.04227192f, 0.02271255f, -0.05088460f, -0.13400179f, -0.03794525f, 0.03676075f, 
    0.11214993f, -0.05780093f, 0.09423648f, -0.08267795f, -0.01605720f, -0.10196704f, -0.13331236f, -0.07756269f, 
    -0.06856896f, -0.04321684f, -0.07910621f, 0.03154718f, -0.04803880f, -0.09654832f, -0.00377807f, -0.03952056f, 
    -0.05207215f, 0.01408650f, -0.03802648f, -0.01796150f, 0.02165660f, -0.06571013f, 0.04979420f, -0.03838827f, 
    -0.01434452f, -0.04656030f, -0.06686143f, -0.03378734f, -0.09980959f, -0.01092026f, 0.02854455f, -0.02426495f, 
    -0.09617085f, -0.05480254f, -0.07153501f, -0.07045590f, 0.12633151f, 0.08087181f, -0.06386162f, -0.02722958f, 
    -0.06468280f, -0.05252879f, -0.08602875f, -0.03891665f, 0.06825145f, -0.00758367f, -0.04751559f, -0.08146736f, 
    0.05150640f, 0.02849710f, -0.05253840f, -0.08464951f, -0.02377532f, 0.01282545f, 0.04948888f, -0.00380544f, 
    -0.01854936f, 0.05395457f, -0.04694046f, -0.09168556f, 0.02127002f, -0.03832302f, -0.13972445f, -0.05123587f, 
    0.04930644f, 0.04748736f, 0.04204148f, 0.08704696f, -0.03967782f, -0.00990840f, 0.01858613f, -0.03491928f, 
    -0.09756104f, -0.03946895f, 0.04033492f, 0.08782552f, -0.00861517f, -0.03004798f, 0.03464373f, -0.12103961f, 
    0.03236865f, 0.00144627f, -0.13387406f, 0.04281482f, -0.00262015f, 0.04821931f, -0.04563795f, 0.04261361f, 
    -0.07676257f, -0.02147925f, -0.08961882f, -0.08080829f, 0.03868354f, 0.05643467f, 0.01766393f, 0.00470011f, 
    0.04076565f, -0.00251792f, -0.01495812f, -0.02693662f, 0.06023438f, -0.00486833f, 0.01825776f, 0.01184111f, 
    -0.05734842f, -0.08339177f, -0.01705730f, -0.08697958f, 0.03421539f, -0.07192609f, -0.08688757f, 0.03719395f, 
    -0.04265905f, 0.00396344f, -0.09115960f, 0.06850539f, -0.08027954f, 0.01074379f, -0.09700572f, 0.00925394f, 
    0.35017970f, -0.22447361f, -0.13519666f, 0.05731134f, -0.10225279f, -0.19819264f, 0.27521554f, 0.20540857f, 
    -0.11100241f, 0.05290077f, -0.23263097f, -0.68613625f, 0.15532510f, -0.24111378f, 0.36846179f, -0.24983647f, 
    -0.08532073f, -0.10546860f, 0.02997274f, 0.09214011f, -0.07238977f, -0.26518548f, 0.07032862f, 0.01269622f, 
    -0.04857185f, 0.19237468f, -0.11751331f, 0.01671241f, 0.01455860f, -0.00428348f, -0.00033154f, 0.08773416f, 
    0.11016710f, -0.07269532f, 0.13194327f, 0.25821793f, -0.08227154f, 0.12200246f, -0.26371926f, 0.25724441f, 
    0.32360351f, 0.25596446f, 0.22865224f, 0.14370941f, -0.11980193f, 0.22310004f, 0.14050020f, 0.00298861f, 
    -0.29679686f, -0.07003853f, 0.24957724f, 0.06846488f, 0.06152188f, 0.17349131f, -0.25138614f, -0.00969670f, 
    -0.02318869f, -0.02356229f, 0.13308683f, 0.36333409f, 0.08411887f, 0.17000674f, -0.07158796f, 0.18618710f, 
    -0.05770256f, 0.07331899f, -0.02509717f, -0.09623163f, -0.08238596f, 0.10027807f, 0.04035220f, 0.04577810f, 
    0.08029950f, -0.20896579f, -0.19433190f, -0.01268708f, -0.03159589f, 0.37353092f, -0.11102220f, 0.10339390f, 
    -0.04358768f, 0.07241040f, -0.03299993f, -0.14215149f, 0.02836004f, 0.13866790f, -0.04049803f, -0.01174372f, 
    0.31638706f, -0.10593601f, 0.07284038f, 0.03753477f, 0.04858682f, 0.14163622f, -0.08642597f, -0.05583213f, 
    0.03034544f, 0.34034449f, 0.03496344f, 0.50264347f, -0.05433806f, -0.17799918f, 0.01770456f, -0.08008146f, 
    0.01583392f, 0.10038936f, -0.21799392f, 0.22857802f, -0.20824444f, -0.12126096f, 0.09694909f, 0.04008836f, 
    -0.07229955f, -0.08894531f, 0.14675143f, 0.07068410f, -0.40021485f, 0.41020888f, 0.13429731f, -0.15848774f, 
    0.08075310f, 0.11268108f, 0.04734416f, -0.42699596f, 0.24033019f, -0.30090636f, 0.09985068f, -0.01031546f, 
    -0.10423346f, -0.00423663f, 0.05021130f, 0.00891543f, -0.09183164f, -0.03566505f, -0.01667449f, -0.03093586f, 
    -0.08209564f, -0.06976511f, -0.09713203f, 0.02801403f, -0.02035550f, -0.08661927f, -0.07667310f, -0.02139860f, 
    -0.06173593f, 0.06370898f, -0.04771390f, -0.05493911f, -0.04946353f, -0.11155225f, -0.07014098f, 0.00070755f, 
    -0.11628983f, 0.05235337f, -0.02228005f, -0.01563403f, -0.03362183f, -0.03226962f, -0.02168637f, -0.02949840f, 
    0.05632089f, 0.00343927f, -0.06227076f, 0.02292480f, -0.07508326f, 0.01525359f, -0.08464870f, -0.08285720f, 
    -0.08823445f, -0.01800455f, -0.03715591f, -0.01795815f, -0.03265507f, 0.07355735f, 0.04122592f, -0.01532543f, 
    0.05751793f, 0.04985762f, -0.05660829f, 0.02226307f, -0.10146423f, -0.05007520f, -0.09508191f, 0.04832473f, 
    -0.03588380f, -0.06119949f, -0.05600627f, -0.08992578f, 0.00426705f, -0.09948044f, -0.03922195f, 0.04593429f, 
    0.02871149f, -0.06437404f, -0.02861651f, 0.05285508f, 0.03800179f, 0.03174745f, 0.05068330f, -0.07996001f, 
    -0.01237472f, -0.05936045f, -0.02613445f, 0.03631681f, -0.08386514f, -0.06898428f, 0.03209656f, -0.00145386f, 
    0.01784308f, -0.00276833f, -0.11646347f, 0.07676674f, -0.11625884f, -0.08262070f, -0.07480633f, -0.06694810f, 
    -0.11402092f, -0.06885950f, 0.03250914f, -0.01699624f, -0.00751725f, -0.05822403f, -0.07464585f, 0.07885294f, 
    -0.03172815f, 0.03266879f, 0.04983279f, -0.01449289f, 0.07289100f, -0.01978254f, -0.01650019f, 0.06529161f, 
    -0.06485181f, -0.10721032f, -0.00917960f, 0.02331170f, -0.07794829f, -0.00674030f, -0.03878494f, -0.02412358f, 
    -0.00288122f, 0.05564523f, -0.08022736f, -0.01046493f, -0.11143769f, -0.09097561f, -0.00905391f, -0.08698026f, 
    -0.09727142f, -0.11068115f, 0.04552740f, -0.10072277f, -0.02966766f, -0.10425827f, 0.01198284f, -0.07945121f, 
    0.03227461f, 0.03288545f, 0.03273501f, -0.08885780f, 0.03956685f, -0.04127635f, 0.01866712f, -0.02576322f, 
    -0.10678066f, -0.07645518f, -0.06289938f, -0.06938630f, 0.02908029f, -0.11882780f, -0.10268636f, -0.00815135f, 
    0.06500749f, 0.06794024f, 0.03933733f, 0.04316695f, -0.03854330f, 0.01355884f, -0.01446264f, 0.00967630f, 
    -0.11200351f, -0.11216393f, -0.04294031f, -0.08970903f, -0.01465011f, -0.02752041f, -0.00984914f, -0.01399778f, 
    -0.08483691f, -0.08139644f, -0.09510060f, -0.04650174f, 0.03559626f, -0.09442404f, -0.01853616f, -0.09015152f, 
    0.00176668f, 0.00451397f, -0.03522616f, -0.02177055f, -0.00655862f, -0.05218256f, 0.06225241f, 0.02787345f, 
    -0.06172818f, 0.03474404f, -0.00066402f, 0.02057765f, -0.10615488f, -0.06290980f, -0.05982563f, -0.05034639f, 
    -0.02172286f, -0.11014451f, 0.03300961f, 0.01662299f, -0.08273711f, -0.05661200f, 0.02223302f, -0.09904133f, 
    -0.00659538f, 0.02216385f, 0.03912659f, -0.09117924f, 0.02546904f, -0.08478541f, 0.04319739f, -0.08688406f, 
    -0.01093670f, 0.03108798f, -0.06381455f, 0.03667471f, -0.09859533f, -0.11569010f, 0.07767839f, -0.12244561f, 
    -0.11509704f, -0.12047926f, -0.07386819f, 0.00203815f, 0.07042476f, -0.00404237f, -0.06263039f, 0.02178481f, 
    0.05442204f, -0.11900478f, 0.05032147f, 0.01909419f, 0.01386582f, -0.06421533f, -0.09940816f, 0.04869670f, 
    -0.09531871f, 0.02222669f, -0.01085956f, -0.02520463f, 0.02382134f, -0.11773266f, -0.05559424f, -0.05099770f, 
    0.03055632f, -0.07401650f, -0.08029480f, 0.03396177f, 0.03605968f, 0.00747621f, 0.00107715f, -0.11725094f, 
    -0.00427526f, -0.05474961f, 0.02534943f, -0.01154507f, -0.01607733f, -0.02732434f, -0.08767992f, 0.05520794f, 
    -0.12285949f, -0.04007694f, 0.02259814f, -0.11228779f, -0.04892986f, -0.01584390f, -0.06407047f, -0.00164788f, 
    -0.07243530f, -0.17190376f, 0.05134427f, 0.18398762f, -0.05282590f, 0.10885519f, 0.17234485f, 0.12978746f, 
    0.15672007f, 0.10645463f, -0.13341852f, -0.13301794f, 0.07090132f, -0.16760246f, 0.10166805f, -0.29185376f, 
    -0.03003273f, 0.11330242f, -0.15780982f, 0.22183688f, -0.08045705f, -0.42159256f, 0.00297731f, 0.00903069f, 
    -0.06013382f, 0.07971084f, 0.07946955f, -0.04383387f, 0.09233497f, 0.32591775f, 0.00129740f, 0.14181229f, 
    0.15892145f, -0.06793030f, -0.25071940f, 0.13329214f, 0.10270754f, -0.03732537f, 0.18287513f, -0.04818874f, 
    0.08880926f, 0.01777060f, -0.00532489f, -0.05712949f, -0.24835701f, -0.27328014f, -0.13173507f, 0.21512507f, 
    -0.22422439f, -0.06927097f, 0.15062605f, -0.07085304f, -0.13879120f, 0.14074248f, -0.00947695f, -0.07348730f, 
    0.03554834f, -0.14986432f, -0.12885478f, 0.11623351f, -0.19962138f, 0.10434663f, -0.04647217f, 0.15127259f, 
    -0.15351969f, 0.25037190f, 0.09366905f, 0.18842888f, -0.09217700f, 0.15023166f, -0.37645853f, 0.01957785f, 
    0.18698728f, -0.38772884f, 0.10788524f, -0.03664584f, 0.11600892f, 0.11147547f, -0.11421020f, -0.07957162f, 
    -0.20419711f, -0.11970618f, 0.05696838f, 0.15989700f, 0.03733643f, 0.19589497f, 0.30849621f, -0.09776122f, 
    0.19354469f, -0.00272395f, 0.15326932f, -0.01929209f, 0.04603979f, -0.03388336f, 0.04877799f, -0.03405114f, 
    -0.01219504f, 0.20446253f, -0.02950664f, 0.04791884f, 0.03387956f, -0.64417487f, 0.02890484f, 0.04578262f, 
    0.00096487f, -0.07486612f, 0.31045356f, -0.00496756f, -0.60916418f, -0.02833794f, 0.02620494f, 0.15714137f, 
    -0.07097024f, -0.11218309f, 0.19706656f, -0.14998642f, -0.28257030f, 0.19005640f, 0.03989173f, 0.08931381f, 
    0.01213868f, 0.12070873f, -0.03699490f, 0.16128094f, 0.16714641f, -0.06720509f, 0.06702159f, -0.29328102f, 
    -0.06165498f, -0.35210156f, 0.01776615f, 0.10458472f, -0.24405457f, 0.00075187f, 0.10799056f, 0.17540716f, 
    -0.12543580f, 0.03645191f, -0.13014895f, -0.48896262f, 0.06994956f, -0.17641053f, -0.06182045f, -0.14176579f, 
    -0.34326011f, 0.01887067f, -0.03987193f, -0.24684650f, 0.13159317f, -0.10971285f, 0.01095567f, -0.02763947f, 
    -0.16702959f, -0.09776287f, 0.28758693f, 0.00344904f, 0.04664865f, -0.02035575f, 0.06397242f, 0.02342425f, 
    -0.08108523f, 0.14708987f, -0.03333477f, -0.07384646f, -0.25164467f, 0.34086132f, -0.04076006f, -0.03332639f, 
    0.43209648f, -0.06468938f, -0.06494796f, -0.33108893f, -0.48550546f, -0.37773570f, -0.15445594f, 0.05975459f, 
    -0.24511676f, -0.05170178f, 0.20586309f, 0.02855914f, -0.65024060f, -0.03644594f, 0.13205533f, 0.03634027f, 
    0.06051726f, -0.39160767f, -0.00180718f, 0.02305114f, 0.02894963f, -0.02268927f, 0.21759425f, -0.20271704f, 
    0.05296446f, -0.09341556f, 0.03140082f, 0.10650208f, 0.00923902f, 0.21807669f, 0.22751988f, 0.19820824f, 
    0.22497787f, -0.17025007f, -0.06370386f, -0.03025195f, 0.25038508f, 0.22441976f, -0.10280174f, -0.29138389f, 
    -0.08728783f, -0.16666998f, 0.11586559f, -0.37607306f, -0.05298140f, 0.14964800f, -0.29189381f, 0.13295515f, 
    0.21609606f, 0.06774633f, 0.21839124f, 0.09433231f, -0.00902614f, 0.10977537f, 0.20160215f, -0.09049805f, 
    0.55799693f, 0.07160090f, 0.18616566f, 0.16374618f, 0.06055746f, -0.28234789f, 0.13303632f, -0.16438790f, 
    0.02905164f, 0.13172799f, 0.28942469f, -0.02029842f, -0.30194020f, 0.19219412f, 0.00695594f, 0.33773851f, 
    0.02823350f, 0.18137656f, 0.13329202f, -0.06421863f, -0.09299406f, -0.28706357f, -0.01944045f, -0.06068508f, 
    -0.00193047f, 0.23631100f, 0.14324290f, 0.18675542f, 0.33383542f, 0.06277546f, 0.39876559f, -0.29543114f, 
    -0.09348887f, -0.01829589f, 0.04541316f, -0.05814858f, -0.06056760f, -0.06827990f, -0.08312008f, -0.08663473f, 
    0.00637703f, -0.08735275f, -0.00654477f, -0.02079292f, 0.06747620f, -0.07232184f, -0.06666105f, -0.08617000f, 
    0.05746058f, -0.03681713f, 0.05782147f, 0.00309774f, 0.06431458f, 0.05730214f, 0.01626660f, -0.03155956f, 
    0.07466657f, 0.02654329f, 0.03571206f, 0.03121241f, -0.05642891f, 0.03777378f, -0.07285009f, 0.02320076f, 
    -0.01447525f, -0.07625145f, 0.04656149f, 0.03879021f, 0.02823645f, 0.01575170f, 0.08217980f, 0.05453720f, 
    -0.00539422f, 0.07052691f, 0.00257418f, -0.03657344f, -0.07314717f, 0.05422891f, -0.04468434f, -0.03056696f, 
    0.00887031f, 0.04882174f, 0.04703752f, 0.02724606f, 0.00143516f, -0.07194840f, 0.04113856f, 0.04133576f, 
    0.03205411f, -0.07647213f, -0.00755910f, 0.00142100f, -0.05313258f, 0.04017514f, -0.02823398f, -0.08688455f, 
    -0.10841966f, 0.07185185f, -0.06392346f, -0.04191562f, 0.02581142f, -0.01299982f, -0.05988435f, -0.03013840f, 
    -0.01291866f, -0.09595372f, 0.00260075f, 0.04479562f, -0.03526042f, 0.03750444f, -0.08192790f, 0.03317018f, 
    -0.08921538f, 0.06147770f, -0.00027038f, -0.00132745f, 0.00170158f, -0.04805037f, -0.01776582f, 0.01419646f, 
    -0.07378338f, 0.04960542f, -0.04812113f, 0.00418077f, 0.01793783f, 0.04537465f, -0.00994973f, 0.01724780f, 
    0.05174759f, -0.06460062f, 0.05217979f, 0.01942695f, 0.08053942f, 0.00070276f, 0.03349571f, -0.06440347f, 
    -0.04171893f, 0.01707209f, -0.00467840f, -0.09175920f, 0.02730687f, 0.04087904f, 0.06534208f, -0.04567454f, 
    -0.06471188f, -0.00184246f, -0.09293412f, -0.09068669f, -0.02958582f, 0.07860166f, -0.01156295f, -0.04468166f, 
    0.03274462f, -0.04002183f, -0.00934855f, -0.09843513f, -0.07313014f, 0.00542800f, -0.08503802f, -0.02793933f, 
    -0.15832888f, -0.21028547f, -0.07556602f, 0.35694456f, -0.01925620f, 0.20952760f, -0.09560756f, -0.02575598f, 
    0.17133631f, -0.01279271f, -0.08074385f, -0.31458968f, 0.02959627f, -0.19718574f, -0.08978303f, -0.25903618f, 
    -0.12690291f, 0.04083070f, 0.15748112f, -0.11050387f, 0.00473673f, -0.22292781f, -0.17841195f, -0.01847764f, 
    0.16035645f, 0.10389438f, 0.18061429f, -0.05830534f, 0.01124886f, -0.06164362f, 0.01965617f, -0.07863543f, 
    -0.04490902f, 0.26693124f, 0.26248103f, -0.19654754f, -0.28533947f, 0.01108288f, -0.20765546f, 0.11000612f, 
    0.42428803f, 0.13275227f, 0.17207426f, 0.02819602f, -0.58694142f, 0.10675200f, -0.09028945f, -0.03721016f, 
    -0.22446832f, 0.16392408f, 0.24407673f, 0.14460981f, -0.42260325f, -0.27384928f, -0.04815407f, -0.04551136f, 
    0.00381116f, -0.01533839f, 0.00074925f, -0.07920027f, -0.01810283f, 0.09016615f, 0.02404542f, -0.28054500f, 
    0.05989437f, -0.17601068f, 0.49123907f, 0.06423262f, -0.00265306f, 0.43893352f, 0.28426269f, 0.25856662f, 
    0.07767894f, -0.01109897f, 0.06758029f, -0.07825065f, 0.11608329f, 0.26344746f, -0.20636021f, -0.36030379f, 
    -0.02614954f, -0.07638375f, 0.06841238f, 0.00258066f, 0.05221820f, 0.07474066f, -0.21955697f, 0.29198256f, 
    0.12954700f, 0.04178113f, 0.17396607f, -0.03010349f, 0.05200983f, 0.11996938f, 0.22989680f, 0.02810236f, 
    0.41630539f, 0.07102619f, 0.11614008f, 0.41170606f, 0.02281155f, -0.33361486f, 0.01726024f, 0.04398020f, 
    -0.03507561f, 0.35272679f, 0.10538242f, 0.21223344f, -0.43723863f, 0.16804944f, -0.13851359f, 0.24924347f, 
    0.08614270f, -0.03956744f, 0.19538394f, 0.04508214f, -0.00262645f, -0.27139473f, 0.10960149f, 0.03110677f, 
    -0.10340769f, 0.13082410f, 0.06363495f, 0.01231097f, 0.13829236f, -0.36558101f, -0.03095828f, -0.22890726f, 
    -0.15112926f, -0.06666428f, 0.03287166f, -0.02046198f, 0.11136856f, -0.25772908f, 0.16869920f, -0.01208802f, 
    0.10577620f, -0.09357641f, 0.02466585f, -0.00109910f, -0.03984841f, 0.02605802f, 0.03178456f, -0.12354763f, 
    -0.04023397f, -0.11673827f, -0.04279981f, 0.25546363f, 0.00470337f, 0.11453023f, 0.17569450f, -0.02163326f, 
    0.10977040f, 0.13810293f, 0.28976020f, 0.04348494f, 0.21901871f, -0.05378205f, 0.02102299f, 0.05296392f, 
    -0.01289755f, 0.16059598f, -0.14105691f, -0.04665693f, 0.15310825f, -0.10060561f, -0.42711267f, -0.08725316f, 
    0.12397914f, 0.21518692f, -0.21745206f, 0.38824967f, -0.02816115f, 0.68613636f, 0.05079488f, 0.25667441f, 
    0.24446721f, 0.25225687f, 0.12109555f, 0.02752007f, 0.42760158f, -0.08521338f, 0.14801918f, 0.02781254f, 
    -0.01767580f, 0.07439324f, 0.18295543f, -0.07242659f, 0.00212531f, -0.11206727f, 0.04145830f, 0.04019823f, 
    0.16713412f, 0.10639291f, 0.07607664f, 0.21714309f, -0.01618071f, 0.15683618f, -0.26373059f, -0.07926153f, 
    0.10537154f, 0.21423839f, 0.17282273f, -0.05666596f, -0.01326353f, 0.14057548f, 0.00883235f, 0.02248447f, 
    -0.02787028f, 0.21712148f, -0.13610449f, 0.07670429f, -0.02239371f, -0.03478181f, -0.08005597f, -0.08103309f, 
    0.07572919f, 0.16562440f, -0.19678599f, 0.01588191f, 0.11715277f, 0.11204719f, 0.08154052f, -0.04408599f, 
    -0.23809099f, -0.12684162f, -0.08342627f, 0.11011892f, 0.01256050f, 0.04999776f, -0.01410274f, 0.00720418f, 
    0.00963137f, 0.01548115f, -0.04799355f, -0.19346391f, 0.08909390f, -0.03756141f, 0.07452445f, 0.24598408f, 
    0.10428587f, -0.10441133f, 0.01963621f, 0.09630341f, 0.07492971f, 0.15720069f, -0.06946154f, 0.14973438f, 
    0.11965302f, 0.04985945f, 0.13151647f, -0.16485955f, 0.02776163f, -0.02385832f, -0.01572377f, 0.09553379f, 
    -0.03966146f, 0.06455049f, 0.04373760f, -0.06339151f, -0.09878651f, 0.05457447f, 0.02561488f, 0.03036994f, 
    -0.12573588f, -0.03701315f, -0.11573954f, -0.06959994f, 0.05149507f, -0.05607584f, -0.05213532f, 0.00304943f, 
    -0.06012961f, 0.01136677f, 0.05868259f, 0.02956804f, -0.09461887f, 0.00811324f, -0.02024273f, 0.06292612f, 
    0.03742266f, -0.01674190f, 0.00838964f, 0.02635453f, 0.00373381f, -0.02510145f, -0.00684332f, -0.02576604f, 
    0.03403436f, 0.04318713f, -0.09930014f, -0.09049936f, 0.05141364f, -0.09323978f, 0.07008526f, 0.01988031f, 
    -0.06060732f, 0.07677794f, 0.01893204f, -0.00460537f, -0.01420191f, 0.03557422f, 0.02394646f, -0.01777862f, 
    -0.03097002f, -0.04441967f, -0.03087011f, 0.04576038f, -0.06902038f, 0.01622426f, -0.00364452f, -0.04479799f, 
    -0.07747240f, 0.02152434f, -0.05176087f, -0.08227805f, -0.06204046f, 0.00597476f, -0.08850548f, -0.02338124f, 
    -0.08526948f, -0.04168887f, 0.04140225f, -0.09615124f, 0.09027939f, -0.02717075f, -0.03658801f, -0.04135356f, 
    0.02057023f, 0.01979736f, -0.00305976f, -0.04193449f, -0.03770848f, -0.07027445f, 0.03324463f, 0.03577207f, 
    -0.08917733f, 0.01983213f, -0.06069856f, 0.05961708f, -0.09076846f, 0.05616350f, -0.01413007f, 0.05541392f, 
    -0.01956535f, -0.02308947f, 0.03713331f, -0.07110729f, -0.06401677f, 0.03086632f, 0.05286852f, 0.05630687f, 
    0.01314643f, -0.11702505f, -0.04565614f, -0.02748644f, -0.07169253f, -0.03586185f, -0.01220550f, -0.01196212f, 
    0.05749339f, 0.05122975f, -0.07282645f, -0.04647638f, -0.10104667f, -0.04746880f, -0.03151012f, -0.01319283f, 
    0.05417148f, 0.01710585f, -0.02023434f, 0.00209339f, -0.01544701f, -0.00048176f, -0.02454636f, -0.04983570f, 
    -0.10312562f, -0.02357210f, 0.01076633f, -0.03899592f, 0.03406136f, -0.08222183f, -0.05641683f, 0.06691659f, 
    0.07550596f, -0.07877053f, 0.11756642f, -0.07282972f, -0.04131640f, 0.23692973f, 0.16024856f, 0.14248110f, 
    -0.12159760f, 0.05430482f, -0.03828340f, -0.02082131f, -0.00123429f, 0.17399286f, 0.32979423f, -0.22338888f, 
    0.10484358f, 0.03609800f, -0.02016022f, 0.00816355f, -0.10314882f, -0.51057410f, -0.02903800f, -0.06217149f, 
    0.02163782f, 0.06701838f, -0.05030773f, 0.05690967f, 0.00499928f, 0.30059716f, -0.02473270f, -0.01469814f, 
    0.28267661f, -0.22570474f, -0.20656545f, 0.23208344f, 0.19180903f, -0.00300678f, 0.43691197f, 0.01920049f, 
    -0.19055179f, -0.15624051f, 0.24143811f, 0.11386363f, 0.05520752f, 0.06946348f, 0.21741161f, 0.14504755f, 
    -0.10868509f, -0.14937864f, -0.05173943f, 0.07092176f, 0.25907889f, 0.17409778f, -0.00354739f, 0.02768533f, 
    -0.07119013f, -0.07657872f, -0.02191087f, 0.08340830f, 0.11432641f, 0.00813771f, 0.00694135f, 0.15133351f, 
    -0.20704783f, 0.29140833f, -0.04402660f, 0.23746929f, -0.00309496f, -0.34380898f, -0.03086904f, -0.06050467f, 
    0.19130276f, -0.34929135f, 0.20115082f, 0.06897771f, -0.02394986f, -0.12896129f, -0.13742840f, 0.35381755f, 
    0.07631924f, -0.02635977f, 0.03231790f, 0.11964374f, 0.13687794f, 0.44952884f, -0.01781934f, 0.00804678f, 
    0.04994060f, -0.15673177f, -0.04073847f, -0.06447864f, -0.01844558f, 0.07709420f, -0.05837011f, -0.07278479f, 
    -0.34038654f, 0.29502007f, 0.13260166f, 0.10937455f, 0.02671356f, -0.25924313f, -0.06319542f, 0.02537468f, 
    0.02835442f, -0.11910161f, 0.43503979f, -0.05155262f, -0.18277402f, -0.42241976f, -0.01679398f, -0.13709494f, 
    0.01040835f, 0.19463754f, 0.00709567f, -0.19792095f, -0.04137273f, 0.57591707f, 0.16804224f, -0.06664348f, 
    0.05364264f, -0.14204492f, -0.19274789f, -0.14390661f, 0.01272186f, 0.12799810f, 0.23651868f, -0.04443593f, 
    -0.39402789f, -0.30741581f, 0.25085175f, -0.18089920f, -0.44262722f, 0.15354761f, 0.10818072f, 0.07092665f, 
    -0.06936321f, 0.14956476f, -0.12091452f, 0.15584525f, 0.14018065f, 0.03578541f, 0.09349750f, 0.00874471f, 
    -0.19890265f, -0.51163876f, 0.14187913f, 0.21239541f, -0.25404948f, -0.06507433f, 0.17194708f, -0.07390741f, 
    -0.43920743f, 0.02117573f, 0.04445674f, 0.08336746f, 0.26496828f, 0.54324818f, 0.02172833f, 0.15151697f, 
    0.24640635f, -0.14942798f, 0.07497291f, 0.41986081f, 0.27667582f, -0.15935230f, 0.13766585f, -0.04128141f, 
    -0.23936346f, -0.00632762f, 0.21873990f, 0.08229691f, -0.29518715f, -0.13988203f, -0.00096310f, 0.24101323f, 
    -0.17814186f, -0.20323907f, 0.06611133f, 0.07197029f, 0.26665691f, 0.08907781f, -0.09704052f, -0.07901730f, 
    -0.05207598f, -0.37597579f, -0.10723429f, 0.00034018f, 0.00198640f, -0.19888379f, 0.01140265f, 0.34843001f, 
    -0.30590418f, 0.38530993f, 0.17948806f, 0.27035320f, 0.01605502f, -0.17966059f, -0.11436395f, -0.09387130f, 
    0.46250194f, -0.02815249f, -0.14060730f, 0.08268609f, -0.07195465f, -0.37413749f, 0.00655292f, 0.33435026f, 
    -0.09473275f, 0.01285721f, 0.09697963f, -0.51046365f, -0.33886951f, 0.05944441f, 0.40453169f, -0.14823180f, 
    -0.00192163f, 0.09180508f, 0.32802525f, -0.06193689f, -0.02061662f, -0.09768334f, 0.20047608f, 0.05381796f, 
    0.02314712f, 0.22962382f, 0.03169839f, -0.05833406f, -0.07614111f, 0.15769757f, 0.09129301f, -0.48395553f, 
    0.06111128f, -0.14070384f, 0.44110039f, 0.10163207f, 0.25104490f, -0.31007752f, 0.21960671f, -0.00129888f, 
    0.08058081f, 0.21570016f, 0.31665099f, 0.01520803f, 0.01891231f, 0.83986473f, -0.09820500f, -0.22246605f, 
    0.21577317f, 0.04771607f, -0.01481870f, 0.23168993f, -0.16777164f, 0.28479716f, -0.24586171f, 0.13418137f, 
    0.25327039f, -0.01192790f, -0.07470436f, -0.08579353f, 0.04056443f, -0.34848449f, 0.12444092f, -0.06180676f, 
    0.02791252f, -0.01231965f, 0.09769467f, -0.00985299f, 0.10237636f, -0.06862118f, 0.09642996f, -0.14023142f, 
    0.06033646f, 0.06175042f, -0.01146759f, 0.10636234f, -0.02030470f, 0.10240907f, -0.06653050f, 0.03455398f, 
    0.03628846f, 0.23176596f, -0.02436221f, 0.11898824f, -0.04167226f, -0.22147159f, 0.05162627f, 0.01892750f, 
    0.06806605f, 0.05647155f, 0.08605610f, -0.17109345f, -0.10729272f, 0.05225214f, 0.08754772f, 0.07803480f, 
    0.20186782f, 0.13467745f, 0.03006576f, 0.09534038f, -0.03794753f, 0.08338505f, -0.08312487f, -0.17480056f, 
    -0.04143058f, 0.05430707f, 0.18439138f, -0.03382985f, -0.25182059f, 0.02734798f, 0.00096482f, -0.00813767f, 
    -0.07080306f, -0.09461047f, 0.07881083f, 0.18884495f, 0.04775101f, 0.03688587f, 0.02407878f, 0.02250945f, 
    0.17508215f, 0.04782825f, -0.10769728f, -0.13852379f, -0.01763223f, 0.32509607f, 0.32209975f, 0.07346335f, 
    -0.20226374f, 0.05810767f, 0.24536553f, 0.02217566f, 0.06645725f, 0.34276977f, -0.09316045f, 0.06883222f, 
    -0.07715152f, -0.04254745f, -0.05920516f, 0.36772692f, 0.10511019f, -0.09496179f, 0.21379754f, 0.04293436f, 
    0.14880097f, 0.03483094f, -0.04501982f, 0.08508700f, -0.13521694f, 0.04710849f, -0.16076024f, -0.09034660f, 
    0.19248562f, -0.00686643f, -0.07251326f, 0.29300877f, -0.05281030f, -0.01784186f, 0.12171516f, 0.12970695f, 
    0.05243855f, 0.27759653f, -0.25364280f, -0.08131289f, -0.11942804f, 0.22673404f, -0.14072736f, 0.01950875f, 
    0.00390133f, 0.04711347f, 0.01225083f, 0.11572608f, -0.09676863f, -0.29608253f, 0.18384838f, -0.03434519f, 
    0.02247216f, 0.01037931f, 0.11012729f, -0.17993633f, 0.16644111f, -0.09221229f, -0.10277147f, 0.09724070f, 
    0.25692341f, -0.10462241f, -0.15447399f, -0.08432255f, -0.06929941f, -0.08546127f, -0.17326851f, 0.23227292f, 
    0.03950392f, 0.12904102f, 0.02035398f, -0.06201902f, 0.01686472f, -0.14373371f, 0.33202678f, -0.03080963f, 
    0.05326545f, -0.02399461f, 0.20183301f, -0.00141011f, 0.01958292f, -0.12812074f, 0.01323833f, -0.04507125f, 
    0.03494921f, -0.00301975f, -0.11653990f, 0.08414423f, 0.07601240f, 0.27314129f, 0.09564890f, 0.01315453f, 
    0.14557396f, 0.07990461f, -0.02937034f, 0.25928220f, -0.01249893f, 0.14930217f, 0.39029428f, 0.19303416f, 
    0.04428248f, 0.09382294f, 0.29884911f, -0.31222743f, -0.17465870f, -0.49738705f, -0.03426304f, -0.01468399f, 
    -0.21245277f, -0.01629010f, 0.26270872f, 0.14179511f, -0.39436582f, 0.01301503f, -0.09016493f, 0.03079074f, 
    0.07702217f, -0.02061197f, 0.09283067f, 0.15872672f, 0.05015338f, 0.20201729f, 0.06788017f, -0.36366114f, 
    -0.05248498f, -0.01285995f, 0.13847728f, -0.01632277f, 0.07910773f, -0.17609811f, 0.17662877f, -0.13884468f, 
    0.04055963f, -0.28717998f, -0.13333298f, -0.09171702f, -0.00464066f, -0.06923945f, 0.06980455f, 0.26072702f, 
    -0.00424991f, 0.06740329f, -0.01869041f, -0.14821893f, 0.02399102f, -0.05771442f, 0.01270406f, -0.09997413f, 
    -0.04189617f, -0.00162591f, 0.51007062f, 0.04789308f, 0.10338476f, -0.02410969f, -0.13713270f, 0.04278037f, 
    0.06694219f, -0.03326331f, 0.04675048f, 0.15010412f, -0.06742533f, -0.13868412f, 0.05190912f, 0.18179134f, 
    0.02154835f, 0.00453677f, 0.17808186f, 0.20058647f, -0.28745207f, 0.12515585f, 0.07083822f, -0.02645740f, 
    0.03613263f, 0.32462722f, 0.07804479f, 0.00592466f, -0.15103985f, -0.10262479f, 0.08599373f, -0.13479164f, 
    0.13128650f, 0.23791510f, 0.20613922f, -0.12169820f, -0.00021905f, -0.02604108f, -0.27285773f, -0.10580917f, 
    -0.06496634f, -0.01092051f, 0.00259370f, 0.04851865f, -0.05680149f, 0.05300302f, -0.01606366f, -0.06148691f, 
    0.04565300f, -0.06200269f, 0.01651150f, 0.04771673f, -0.06428652f, -0.05411191f, -0.09275002f, -0.06953728f, 
    0.04939675f, -0.01736878f, -0.09340127f, 0.02086308f, -0.02678137f, 0.07625823f, 0.04343224f, -0.03436052f, 
    0.01693310f, 0.07468727f, -0.03062966f, 0.01289553f, -0.01878661f, 0.06955636f, 0.04402047f, -0.04013902f, 
    -0.04045587f, -0.07639422f, 0.02924940f, 0.02137702f, 0.02769817f, -0.05189444f, 0.01246406f, 0.00201510f, 
    -0.08406246f, 0.05059289f, 0.05525446f, -0.08628642f, -0.09767873f, 0.04445432f, 0.02058122f, 0.00081532f, 
    -0.09912354f, -0.02407072f, -0.08953393f, -0.10484668f, 0.02449776f, -0.06911342f, 0.01790401f, 0.00433663f, 
    -0.01558805f, 0.01777894f, -0.00305722f, 0.04061261f, -0.09972267f, -0.01276123f, -0.06842420f, -0.01246659f, 
    -0.02543702f, -0.01887525f, -0.05585401f, -0.09690272f, -0.07571481f, 0.02531314f, -0.08232336f, -0.02385621f, 
    0.03889760f, 0.07599441f, 0.04622195f, 0.03106992f, -0.00447319f, -0.05021152f, 0.01581440f, -0.06553804f, 
    -0.00329542f, 0.00348907f, -0.08998522f, 0.04833379f, -0.08831887f, -0.07410514f, 0.04420226f, -0.03902869f, 
    0.06097420f, 0.03758486f, -0.08546807f, 0.00934497f, -0.06810663f, -0.01212726f, -0.00180644f, -0.00044310f, 
    -0.07831618f, 0.03815249f, 0.05792128f, -0.09753376f, -0.03186788f, -0.06031697f, 0.03143882f, 0.03271831f, 
    -0.01786769f, 0.04410619f, -0.08986054f, -0.04080138f, 0.00951998f, 0.00722011f, 0.07332931f, -0.10987584f, 
    0.06174180f, 0.00674919f, -0.06114155f, 0.00079270f, -0.08578375f, 0.02512094f, -0.01199430f, 0.02311568f, 
    -0.07776389f, 0.07379799f, 0.00195789f, 0.07934710f, -0.01427025f, -0.04679623f, 0.02905720f, -0.08677987f, 
    0.01268463f, -0.02104714f, -0.03727239f, -0.03478654f, 0.02377065f, 0.01123509f, -0.03433628f, 0.05793897f, 
    -0.07394820f, -0.10805949f, -0.03813898f, 0.05508497f, -0.05815294f, -0.00299573f, 0.06276440f, 0.07011832f, 
    -0.00428843f, -0.10216051f, -0.10209591f, -0.01441249f, -0.03728103f, -0.01113676f, -0.05445645f, -0.00101461f, 
    0.04038163f, -0.04165934f, -0.07544576f, -0.04157323f, 0.01896823f, -0.06584443f, 0.03747471f, 0.06039689f, 
    -0.04901444f, 0.02825907f, -0.03278173f, 0.06346083f, 0.01219482f, 0.06984415f, 0.07327460f, 0.02788033f, 
    -0.08933356f, -0.04122211f, -0.03671303f, -0.00748706f, -0.02590054f, 0.05499324f, -0.01204754f, -0.07692398f, 
    -0.10225836f, -0.11495382f, 0.07568245f, -0.04858807f, 0.07850052f, -0.06746221f, 0.02756372f, 0.03809799f, 
    -0.01658317f, -0.02833552f, 0.02796970f, 0.03465853f, -0.12070207f, -0.01376851f, -0.06054620f, 0.07188779f, 
    -0.05677484f, -0.00423381f, -0.11072980f, 0.03747543f, -0.05519348f, 0.02282178f, 0.03147513f, -0.02844632f, 
    0.05241580f, -0.05214002f, -0.00933141f, 0.08591278f, -0.00080108f, -0.06926333f, 0.04562908f, -0.00696823f, 
    -0.09764308f, -0.08225378f, -0.07726090f, -0.09757525f, -0.09603158f, 0.03395631f, 0.01680470f, -0.09731559f, 
    -0.07610173f, -0.02386665f, -0.08108241f, -0.03280691f, -0.06208311f, -0.05691753f, -0.08986179f, -0.00841840f, 
    -0.04862073f, 0.03553754f, 0.01883006f, -0.00625071f, -0.04688990f, -0.01592903f, -0.06577468f, -0.09432171f, 
    0.07889951f, -0.01797866f, -0.07267405f, -0.07153991f, 0.08707150f, 0.06662039f, 0.02875256f, -0.00419021f, 
    0.00571818f, -0.06582836f, -0.07646275f, -0.07029045f, -0.03334420f, -0.03224920f, -0.06781940f, -0.08020304f, 
    0.02002358f, -0.04762322f, -0.04480139f, -0.11640950f, 0.04677537f, -0.10582086f, 0.04286984f, 0.02110396f, 
    0.08644956f, -0.12978266f, -0.00704281f, 0.08185208f, -0.17045222f, 0.04057867f, -0.00358032f, 0.12872618f, 
    0.08996468f, 0.09676322f, -0.09345277f, -0.00411774f, 0.05651835f, -0.12654281f, 0.24200402f, -0.11086202f, 
    0.02485914f, 0.20896246f, 0.13245165f, -0.12875228f, -0.05704617f, -0.23223060f, -0.04906717f, 0.00143941f, 
    -0.10580173f, -0.11750510f, 0.07685967f, 0.07264733f, 0.06427379f, 0.23849548f, 0.05161238f, -0.02879710f, 
    0.07790349f, 0.07904398f, -0.03125878f, 0.20189220f, 0.05974190f, 0.30486098f, 0.47998032f, 0.09712081f, 
    0.03256764f, 0.08778596f, 0.20522593f, -0.16609457f, -0.08871921f, -0.29315370f, -0.20565712f, -0.00947181f, 
    -0.14164519f, -0.09633831f, 0.19472410f, 0.12419736f, 0.01700295f, 0.18238087f, 0.01453536f, 0.07611854f, 
    0.00522184f, -0.16952795f, -0.02609132f, 0.00689726f, -0.15977302f, 0.06485528f, 0.20915499f, -0.05978301f, 
    -0.04494911f, 0.12617452f, 0.15613820f, 0.12475211f, 0.05805311f, -0.23900993f, -0.05868047f, -0.00855070f, 
    0.14386709f, -0.22267751f, -0.24470776f, 0.01413623f, 0.05136345f, -0.06751520f, -0.10660563f, 0.15715760f, 
    -0.11661478f, 0.01113463f, 0.17043090f, -0.21061531f, 0.12569892f, 0.34161970f, 0.15919521f, 0.08075249f, 
    -0.07005550f, 0.06952944f, 0.28525189f, -0.00612155f, -0.00187706f, 0.15437607f, 0.10911226f, -0.04617235f, 
    0.22769642f, 0.01271281f, -0.13149442f, 0.12673143f, 0.02376145f, -0.25719211f, 0.13777892f, -0.04032810f, 
    -0.03961371f, -0.09139528f, 0.40090367f, 0.21411236f, -0.18627301f, -0.08581708f, 0.12753005f, 0.14554396f, 
    -0.05563573f, 0.39233869f, 0.19451033f, -0.16371612f, -0.02971468f, 0.16055964f, 0.10837185f, -0.03275999f, 
    0.04721007f, 0.24179810f, -0.01965366f, 0.12177264f, -0.00507988f, 0.03825792f, 0.23229057f, -0.07746022f, 
    0.33049989f, 0.15732242f, -0.09854065f, 0.03545401f, -0.32360113f, 0.16754843f, 0.22411494f, -0.04002320f, 
    0.02265142f, 0.05566659f, -0.29996037f, -0.42264590f, 0.14282733f, 0.12194017f, 0.14015418f, -0.01114832f, 
    0.02653833f, 0.19445251f, 0.28408864f, -0.00902223f, -0.15976579f, -0.21805423f, -0.09220940f, -0.00273135f, 
    -0.01660748f, 0.12368443f, -0.15078565f, -0.03575227f, 0.11763384f, 0.10609486f, -0.07175801f, -0.10368798f, 
    0.03948003f, 0.11549708f, 0.41325748f, 0.26687574f, 0.07503498f, 0.08346983f, -0.06068620f, 0.02706029f, 
    0.09622011f, 0.11431052f, 0.29027706f, 0.06988554f, -0.06106192f, 0.25487950f, 0.01695733f, 0.00544179f, 
    -0.27490449f, 0.18842256f, 0.07989068f, 0.03794758f, 0.24254827f, 0.02109198f, -0.14576344f, 0.06235971f, 
    -0.01457129f, -0.22703730f, 0.05902213f, 0.28300533f, -0.02886542f, 0.27571779f, 0.03285772f, 0.28911623f, 
    -0.13676815f, -0.04583129f, 0.29754320f, -0.00601647f, -0.03950091f, -0.24344251f, 0.32289758f, 0.06368505f, 
    0.15665364f, -0.30350497f, -0.09416188f, -0.07042334f, -0.00090566f, 0.36873671f, 0.23639120f, 0.18335940f, 
    -0.17933333f, 0.22751711f, -0.04274875f, 0.02499641f, 0.03870245f, 0.08660456f, -0.20335251f, 0.31020048f, 
    0.05486147f, -0.08819796f, 0.03799731f, -0.01006487f, -0.12515305f, 0.06874045f, 0.16530104f, -0.08620853f, 
    0.17443465f, 0.23770224f, -0.15021484f, 0.36673388f, -0.00198704f, -0.05058591f, 0.08174830f, -0.07613015f, 
    0.06563275f, 0.13083379f, -0.11784318f, 0.12512112f, -0.22981559f, -0.11046357f, 0.08205480f, -0.01266601f, 
    -0.07633352f, 0.21003249f, 0.06914466f, 0.13585529f, 0.07666419f, 0.51269442f, 0.24620305f, -0.44061837f, 
    0.04803541f, 0.04216927f, 0.02086091f, -0.40907633f, -0.00295805f, -0.27102083f, 0.35691419f, -0.02238949f, 
    0.07296776f, -0.06570779f, 0.07249440f, -0.05476437f, -0.06314230f, -0.05757928f, -0.01333162f, 0.06311460f, 
    -0.01804909f, 0.03681301f, -0.00818318f, 0.00105295f, 0.02316041f, -0.08043732f, -0.06237638f, 0.02871709f, 
    -0.08139215f, -0.02496639f, 0.01226271f, -0.04497289f, 0.05718717f, 0.03365324f, 0.00067729f, -0.06050207f, 
    -0.08947267f, -0.02276614f, 0.03944327f, -0.08472283f, 0.02620889f, 0.00250817f, -0.04269493f, -0.08043641f, 
    -0.03085049f, -0.03672867f, -0.08187487f, -0.05429405f, 0.00869903f, -0.03886855f, -0.00382285f, -0.00214669f, 
    -0.09267876f, -0.07069581f, 0.01773329f, -0.06158180f, 0.00926643f, -0.09433810f, -0.06341673f, 0.04962769f, 
    -0.09081940f, 0.03939294f, -0.02426185f, 0.06551623f, -0.04222865f, 0.05698274f, 0.00924397f, 0.07647947f, 
    0.03684963f, 0.06520116f, 0.05191337f, -0.04698463f, -0.03707868f, -0.04434378f, -0.01810903f, -0.03486156f, 
    0.03309710f, 0.01615990f, 0.06564608f, -0.04041925f, 0.07474133f, -0.05090429f, -0.09493425f, -0.05456714f, 
    -0.02645073f, 0.00218792f, -0.05479415f, -0.03277522f, 0.01161877f, 0.04298907f, -0.04366530f, -0.03172484f, 
    0.04475486f, 0.00907223f, -0.02019357f, -0.06909102f, 0.06370467f, -0.00427701f, -0.06809141f, -0.00076203f, 
    -0.03690595f, 0.04868411f, -0.01683668f, -0.05870821f, 0.03076867f, 0.01104897f, -0.05658600f, -0.06512571f, 
    0.05659808f, -0.00767869f, -0.01600575f, -0.01984887f, 0.03190181f, -0.02385830f, -0.09574314f, -0.10765484f, 
    0.03709350f, 0.04683425f, 0.07309964f, -0.07768036f, 0.03187978f, -0.03375508f, 0.04484264f, -0.07119031f, 
    -0.05215507f, -0.09711841f, 0.06480051f, -0.10071730f, -0.08621415f, 0.04671313f, 0.02159060f, 0.04558090f, 
    -0.01044840f, -0.07926451f, -0.03649207f, -0.05533414f, 0.04043163f, 0.04541298f, 0.01028241f, 0.04053867f, 
    -0.15330033f, 0.17021663f, 0.28652951f, 0.12544146f, 0.06026394f, 0.18317583f, 0.14265049f, -0.22396673f, 
    0.20010890f, 0.05772690f, -0.05221405f, -0.18325818f, 0.08828068f, 0.02948101f, -0.05590788f, -0.09751248f, 
    0.02459256f, 0.16443327f, -0.31019720f, -0.53487581f, -0.13082448f, -0.17436717f, -0.05980952f, 0.00801437f, 
    0.27760321f, -0.68833321f, 0.14604196f, -0.01716247f, 0.31740892f, 0.00221091f, 0.00772366f, -0.30869099f, 
    0.06370876f, 0.12520608f, 0.43620017f, -0.02280921f, 0.33759907f, -0.35511914f, 0.09218122f, 0.17894962f, 
    0.06447639f, -0.79160386f, -0.01321836f, 0.47854292f, 0.07909954f, 0.40433496f, 0.27125692f, 0.44125128f, 
    -0.04273370f, 0.38870344f, -0.55559248f, 0.04682291f, -0.48317677f, -0.04827678f, 0.14931241f, -0.08162137f, 
    0.00426683f, 0.21479107f, -0.13008058f, 0.02671575f, 0.25735059f, -0.00473074f, 0.06736822f, 0.25494045f, 
    -0.02675716f, 0.20012732f, 0.18847668f, 0.22722313f, 0.07408305f, -0.31573164f, -0.38315782f, 0.11682352f, 
    0.17037442f, -0.05438938f, 0.30190384f, 0.09768784f, 0.03516769f, -0.01737430f, 0.21005316f, 0.08323630f, 
    0.51010692f, -0.62737149f, -0.18798317f, 0.38773993f, 0.07347537f, 0.31264973f, -0.50458390f, -0.09401125f, 
    0.13569339f, -0.39046097f, -0.51081598f, 0.03390716f, 0.04754465f, -0.05314897f, -0.03656778f, -0.08839787f, 
    -0.10975802f, 0.28921205f, -0.10473416f, 0.04036385f, -0.03316180f, 0.32240412f, 0.01624824f, 0.08068153f, 
    -0.03607706f, -0.22633550f, -0.14343551f, 0.06384210f, -0.29666758f, -0.01027635f, 0.11741790f, -0.08276819f, 
    -0.03267242f, -0.33191383f, 0.01761800f, -0.32015455f, 0.08084860f, 0.43321946f, -0.17031141f, 0.14773181f, 
    -0.23208459f, -0.05629748f, -0.20304197f, -0.08615249f, -0.16437772f, -0.07958293f, 0.03829232f, -0.31422547f, 
    -0.02150677f, 0.01340781f, 0.04926610f, -0.00517222f, 0.01988696f, 0.04827494f, 0.06800678f, -0.09750666f, 
    -0.03105856f, 0.04742426f, 0.04730914f, -0.09274518f, 0.06367031f, 0.05364419f, -0.05024188f, -0.05751629f, 
    -0.04050354f, 0.02861804f, -0.05008591f, -0.00643890f, -0.02306245f, 0.02042503f, 0.00987522f, 0.08478975f, 
    -0.09031133f, -0.02579352f, -0.09684233f, 0.00121956f, -0.06911603f, -0.10699133f, -0.03887517f, -0.06836491f, 
    -0.02099388f, 0.05361047f, -0.04445210f, 0.06273970f, -0.07594667f, -0.05386683f, -0.03279933f, 0.04378471f, 
    -0.06732696f, 0.02034060f, -0.03902351f, -0.02316905f, 0.01866380f, 0.01356990f, -0.06943362f, 0.04965766f, 
    -0.02135688f, -0.07488518f, 0.04483892f, -0.04475642f, 0.03116117f, 0.04272054f, -0.07514938f, 0.04758238f, 
    0.00866529f, -0.02349214f, 0.03919333f, -0.04345384f, -0.07477096f, -0.05351033f, -0.07264481f, 0.04233633f, 
    -0.04084666f, -0.10627590f, -0.05445270f, -0.09195824f, 0.08297145f, 0.06732225f, 0.02170440f, 0.04869584f, 
    0.00540673f, -0.04562938f, -0.02919389f, 0.01800913f, -0.06150155f, -0.07119846f, -0.04449042f, -0.12160480f, 
    0.07570598f, -0.07171141f, 0.01848106f, -0.03342640f, -0.05716476f, -0.09127568f, -0.10805278f, 0.00581075f, 
    0.06195545f, 0.04548072f, -0.10869601f, 0.07261519f, 0.06645496f, -0.03107140f, -0.05225511f, -0.07588681f, 
    -0.01189274f, 0.05790393f, 0.04191998f, 0.04097253f, 0.03197636f, 0.02602048f, -0.06049235f, -0.02080052f, 
    0.01692195f, -0.00714892f, 0.05519394f, 0.00909031f, 0.04116888f, -0.06791317f, -0.05219496f, 0.04088540f, 
    -0.04672903f, -0.07528742f, -0.08244400f, -0.05499807f, 0.04394083f, 0.04915334f, 0.00586013f, -0.06092852f, 
    0.07679745f, 0.03999127f, 0.05759345f, -0.09386490f, 0.02087224f, -0.05190705f, -0.05341145f, -0.01649143f, 
    0.18317443f, 0.02965963f, -0.12252223f, -0.01353588f, -0.07035532f, 0.13044006f, 0.14845283f, 0.19869693f, 
    -0.01312655f, 0.12151149f, -0.30682573f, -0.41856962f, 0.27542320f, -0.14091890f, 0.36369872f, -0.04984907f, 
    -0.06485902f, -0.19880417f, 0.27884209f, 0.16410172f, -0.08875573f, -0.30240619f, -0.10234809f, -0.02585794f, 
    -0.15455040f, 0.03083379f, -0.13922755f, -0.06483929f, 0.00255672f, 0.26030234f, -0.01878364f, 0.10859041f, 
    0.23634410f, -0.16607089f, 0.37461311f, 0.32408503f, 0.05943184f, 0.07096078f, -0.19161576f, 0.03178679f, 
    0.02635165f, 0.11939024f, 0.30515423f, 0.16703857f, -0.20234273f, -0.12470423f, -0.10054673f, -0.07522722f, 
    -0.23272334f, -0.03360813f, 0.25823855f, 0.15870723f, -0.07078871f, 0.06247946f, -0.32317603f, 0.00575152f, 
    0.06389436f, -0.14901762f, 0.01637562f, 0.27648163f, -0.06419823f, -0.05235006f, 0.05226164f, 0.15664952f, 
    -0.31612474f, 0.06430970f, 0.02738016f, -0.02881433f, -0.01720552f, -0.08251628f, 0.05422011f, 0.04945933f, 
    0.21899056f, -0.22210781f, -0.26409981f, -0.13579294f, 0.03125118f, 0.04857869f, 0.07577658f, 0.07597136f, 
    -0.05735424f, 0.17724319f, -0.11866881f, 0.17479731f, 0.04938211f, 0.10926335f, 0.08951262f, 0.20251156f, 
    0.24021198f, -0.11767363f, 0.19462064f, 0.02021579f, -0.13964893f, 0.02031656f, -0.10243456f, -0.00912279f, 
    -0.01250000f, 0.43724883f, -0.01328742f, 0.46951157f, -0.00506889f, -0.27127346f, 0.12101172f, -0.20390435f, 
    -0.07647684f, 0.12107927f, -0.15430449f, 0.27975690f, -0.20801726f, -0.04313655f, 0.19033964f, -0.14036453f, 
    0.05013110f, 0.04894008f, 0.19194973f, 0.01026518f, -0.09182877f, 0.59138894f, 0.09548976f, -0.27977434f, 
    0.10483270f, 0.04198715f, 0.02223084f, -0.28830191f, -0.00406905f, -0.12322878f, -0.01509526f, -0.12017253f, 
    -0.03712996f, 0.00251282f, 0.04237947f, -0.06951389f, 0.02210831f, -0.04916181f, -0.00526848f, 0.05668418f, 
    -0.08872914f, -0.07269808f, -0.07673706f, 0.02036045f, 0.01441365f, -0.03688837f, -0.01354528f, -0.09088815f, 
    -0.04221469f, 0.01349369f, -0.01919675f, 0.06677616f, -0.08839978f, 0.02687282f, -0.05475549f, 0.03999978f, 
    0.03354406f, 0.04889071f, 0.02123889f, 0.00040008f, 0.06767651f, 0.01849940f, -0.01090031f, 0.02171104f, 
    0.03818508f, -0.00034737f, 0.05564474f, -0.07356863f, -0.00371921f, -0.04263546f, -0.05854655f, -0.08131302f, 
    -0.07000329f, -0.07217182f, -0.08104639f, -0.07966664f, -0.06113520f, 0.08454797f, -0.01589091f, -0.04814665f, 
    0.03012179f, 0.02845098f, 0.01426900f, -0.07682705f, 0.00679773f, 0.01411290f, 0.05023529f, 0.08691753f, 
    -0.03081281f, -0.01701434f, -0.05687569f, 0.01473964f, 0.04238703f, 0.02284929f, 0.03449133f, 0.07387426f, 
    -0.04777794f, -0.05438506f, -0.06723382f, -0.08591532f, -0.02672324f, -0.01443558f, 0.04804233f, -0.01156471f, 
    0.07549503f, 0.03123839f, -0.02212151f, -0.00306042f, 0.06983057f, 0.00797143f, 0.00012293f, 0.00019037f, 
    0.00463907f, 0.07252311f, -0.04717477f, -0.06402878f, 0.01823594f, -0.02389725f, -0.01055496f, -0.08691172f, 
    -0.08525581f, -0.06468450f, 0.00308930f, -0.07857607f, 0.03362714f, -0.04042432f, 0.02128260f, 0.05623975f, 
    0.05459154f, 0.05209383f, 0.03467585f, 0.07620191f, -0.04233612f, 0.01553449f, -0.06523734f, -0.06869483f, 
    0.08672990f, -0.07200675f, 0.02477958f, 0.01825531f, 0.07823288f, -0.05600467f, -0.01147483f, 0.03743648f, 
    -0.02049293f, 0.04613797f, -0.00424590f, -0.02767688f, 0.01278042f, 0.07424675f, -0.01864894f, 0.06222293f, 
    -0.06185840f, -0.09010658f, 0.04996024f, 0.03607396f, 0.03340207f, -0.05704694f, 0.03958341f, 0.01259419f, 
    0.05267250f, 0.04144151f, -0.08168514f, 0.07039538f, -0.00094001f, -0.04337103f, 0.04290658f, -0.03585389f, 
    -0.05955340f, -0.07874533f, 0.02432488f, 0.03576253f, -0.08025677f, -0.04510779f, 0.07987844f, -0.01698828f, 
    0.05060470f, -0.04282011f, -0.01222898f, 0.02836464f, -0.05667552f, -0.05989300f, 0.02705409f, 0.00568201f, 
    -0.01090706f, 0.05390199f, 0.04405493f, -0.08694620f, 0.01793170f, -0.03097791f, -0.06647019f, -0.07843501f, 
    -0.05871021f, -0.03245364f, -0.02219268f, 0.06451651f, -0.07847038f, 0.05849661f, 0.01506861f, -0.00259438f, 
    -0.02336230f, -0.02562596f, 0.05664707f, 0.06741874f, -0.01201159f, 0.00502987f, 0.03489903f, 0.02035592f, 
    -0.08383621f, -0.09156577f, 0.01085075f, -0.04618452f, 0.05672268f, -0.07446206f, 0.01878640f, 0.01474469f, 
    -0.07690594f, 0.01882678f, -0.09508754f, 0.00761683f, -0.08913450f, -0.00306904f, -0.04596530f, 0.04573485f, 
    -0.06653315f, 0.07005154f, -0.06778988f, -0.03784116f, -0.04377868f, -0.03303802f, -0.05599349f, 0.07231242f, 
    -0.04456814f, 0.07567479f, 0.01506997f, 0.04970798f, -0.07872827f, 0.08171521f, 0.01938244f, 0.05376696f, 
    -0.00751406f, 0.02136648f, -0.01413454f, -0.01984382f, 0.05755305f, 0.07113381f, -0.02544912f, 0.05231501f, 
    -0.07378113f, 0.08177126f, 0.01784626f, -0.04208575f, -0.05051229f, 0.03737882f, -0.01184309f, -0.03755239f, 
    -0.06435154f, -0.00566534f, 0.06001494f, 0.05787078f, -0.01770974f, 0.03335155f, -0.08067624f, -0.05354753f, 
    -0.04424152f, 0.02256753f, -0.05464393f, -0.06653485f, -0.07167750f, -0.00540868f, -0.02824921f, -0.08738921f, 
    0.04483597f, -0.03288664f, -0.03862647f, -0.07756925f, 0.00088310f, -0.00061951f, 0.01529390f, 0.07784308f, 
    -0.03642464f, -0.01465538f, 0.08052150f, -0.07115703f, -0.03762105f, -0.08665127f, -0.06548382f, 0.00294638f, 
    0.01443473f, -0.26305866f, 0.11456601f, 0.23812538f, 0.00001363f, -0.01963339f, -0.17733283f, -0.01353703f, 
    -0.05666240f, 0.13593830f, -0.01309978f, 0.00003240f, -0.04088882f, 0.05657751f, 0.00618315f, -0.09083471f, 
    -0.06778966f, 0.09290945f, 0.12277780f, -0.16687812f, 0.04243299f, -0.28699726f, -0.00851337f, 0.06272116f, 
    -0.02217931f, -0.01269300f, 0.24871159f, 0.09481449f, 0.05712383f, -0.06292848f, 0.06099307f, -0.00660127f, 
    -0.04158396f, -0.02249315f, -0.35449830f, -0.22203033f, -0.17257382f, 0.24340224f, -0.34112448f, 0.04050587f, 
    0.13785745f, 0.05273849f, 0.07685604f, -0.27101675f, -0.22006173f, -0.45217380f, -0.09744776f, 0.11511722f, 
    -0.08026533f, -0.05536025f, 0.11892462f, 0.03618696f, -0.32071298f, 0.11183900f, 0.13195594f, -0.00030506f, 
    -0.05694787f, 0.00529383f, -0.07215835f, -0.21522321f, 0.04742691f, 0.00413079f, 0.13694133f, -0.25688279f, 
    0.08644108f, -0.04350325f, 0.01685388f, 0.00648068f, -0.02445561f, -0.09446668f, -0.07706045f, -0.02458272f, 
    0.02239909f, -0.41000298f, -0.16339210f, 0.03722752f, 0.19704393f, 0.11330240f, -0.29370382f, -0.01166478f, 
    0.07889491f, -0.00711258f, 0.06747814f, -0.69900995f, 0.07118560f, 0.22616217f, -0.10561506f, -0.01929909f, 
    -0.04809415f, 0.02595754f, 0.27528733f, -0.07046232f, 0.11010753f, 0.02574296f, 0.17204414f, -0.03077053f, 
    0.26573941f, -0.24282250f, 0.11157241f, -0.04418699f, 0.08768417f, -0.36062461f, -0.10585723f, -0.00667512f, 
    -0.03214351f, 0.02419543f, 0.28412053f, 0.11564235f, -0.41019881f, -0.01872282f, -0.09405155f, 0.18250477f, 
    0.07917228f, 0.24908248f, 0.10065021f, -0.12268806f, 0.20899053f, -0.41297561f, 0.03121038f, 0.12959826f, 
    -0.03703086f, 0.08060311f, 0.12112996f, 0.20295101f, 0.18534897f, 0.16672111f, 0.11174642f, -0.03617449f, 
    -0.27912393f, -0.13989873f, 0.30557266f, 0.14702834f, 0.03670776f, -0.12528020f, -0.00666306f, 0.03564086f, 
    0.05260587f, -0.09287796f, 0.18045492f, -0.01765033f, 0.01817499f, 0.02158189f, -0.04968352f, -0.19191089f, 
    -0.13077609f, -0.23196718f, -0.11866590f, 0.12111723f, 0.13401097f, 0.23521246f, 0.27295068f, 0.04370997f, 
    0.01350503f, 0.12863216f, 0.31967789f, 0.03391295f, 0.21251132f, 0.01102926f, 0.04355150f, 0.08453437f, 
    0.00402180f, 0.06243100f, -0.03751012f, -0.05324429f, 0.17994024f, -0.07818582f, 0.04921745f, -0.01993134f, 
    -0.12866268f, 0.03400826f, -0.12620749f, 0.43488109f, -0.03902064f, -0.03533052f, 0.19787152f, 0.30545115f, 
    0.11226404f, 0.10198550f, -0.11487564f, -0.12292969f, -0.43532982f, -0.01895164f, 0.25296685f, 0.06702565f, 
    -0.00308905f, 0.29496646f, 0.12343314f, -0.06035100f, 0.11991036f, -0.22344144f, 0.05876423f, -0.05440587f, 
    0.13602529f, 0.20013878f, -0.09825519f, 0.28081974f, -0.07678110f, 0.36638156f, -0.32298538f, -0.00608063f, 
    0.07700026f, 0.31412840f, 0.22380133f, 0.13518482f, 0.03707590f, -0.23600377f, -0.08597220f, 0.01573494f, 
    0.23185502f, -0.06675284f, -0.18571310f, 0.05587641f, -0.07152043f, 0.09744335f, -0.19439748f, -0.17981389f, 
    0.14975078f, 0.24799152f, -0.08373830f, 0.05445757f, 0.16134419f, 0.04816539f, -0.05343270f, 0.04695114f, 
    -0.19989380f, -0.01706017f, 0.00166286f, -0.08873740f, 0.04311419f, -0.01599598f, -0.09647466f, -0.02706583f, 
    0.07673371f, 0.12578064f, 0.13451956f, -0.17919414f, 0.07999269f, 0.12418464f, 0.21525247f, 0.06640947f, 
    0.16501452f, -0.24563757f, 0.10457757f, 0.03836476f, -0.05700114f, -0.12076499f, -0.18118352f, 0.21110193f, 
    0.18766567f, 0.05632265f, 0.01018104f, 0.18228529f, 0.06321572f, 0.20749670f, -0.25241295f, -0.02413749f, 
    -0.11132830f, -0.55791593f, 0.08041783f, 0.14860231f, 0.16101216f, 0.07988475f, 0.01283729f, 0.21149501f, 
    0.00580191f, -0.06848029f, -0.01621881f, 0.04892638f, 0.03637822f, -0.06366359f, 0.11143061f, 0.01620940f, 
    -0.14869539f, -0.47026202f, 0.02861062f, 0.11181575f, 0.08023715f, -0.11562482f, 0.08773997f, 0.07543435f, 
    -0.05491424f, 0.10841081f, 0.26051369f, -0.10544567f, -0.00927078f, -0.18646713f, -0.07399534f, 0.15637638f, 
    0.00848569f, 0.11141360f, 0.27893350f, -0.03909786f, 0.11963741f, -0.04270118f, -0.24333458f, -0.09147313f, 
    0.13066730f, -0.12132395f, 0.01517873f, 0.60875618f, -0.20539147f, 0.42637232f, 0.37453800f, 0.22576994f, 
    0.14431496f, 0.09960317f, 0.01173079f, 0.05280395f, -0.23648971f, -0.14815395f, 0.30820724f, -0.06801117f, 
    0.08701573f, 0.22296660f, 0.21237846f, -0.05067106f, 0.08895104f, 0.05162143f, 0.21539357f, -0.29107913f, 
    0.07659993f, 0.13677213f, 0.03096155f, 0.10294624f, 0.07454530f, 0.25542554f, -0.16707954f, -0.03502092f, 
    -0.06836616f, 0.21556996f, 0.15379521f, -0.06978112f, -0.01085789f, -0.13846099f, -0.20346439f, -0.02065303f, 
    0.21046080f, 0.01536023f, -0.05680038f, -0.17317158f, 0.06879564f, 0.21154571f, -0.33287388f, 0.10604180f, 
    0.28355283f, 0.31872538f, 0.18410206f, 0.01810092f, 0.09984778f, 0.11415978f, 0.16347316f, -0.06604251f, 
    -0.07682938f, -0.02737313f, -0.02717867f, 0.30055529f, 0.06768550f, -0.02311467f, -0.07952562f, -0.00515742f, 
    0.08906958f, 0.00625969f, 0.05918606f, -0.06678743f, 0.04396431f, -0.07218494f, 0.06151877f, 0.04532136f, 
    0.20917505f, 0.01312428f, 0.08611562f, 0.05870683f, 0.10942034f, -0.13869955f, -0.00793073f, 0.11461134f, 
    0.13854876f, 0.01948633f, 0.10756408f, 0.03537808f, 0.06307226f, 0.07780751f, 0.04285129f, -0.07801617f, 
    0.02291252f, -0.09380932f, 0.05431842f, 0.02691995f, -0.09539060f, -0.02351594f, 0.00874289f, 0.08645222f, 
    0.03444163f, 0.05547484f, 0.03930246f, -0.05985649f, -0.01286681f, -0.10356145f, -0.00679223f, 0.03809957f, 
    -0.05008218f, -0.08503248f, -0.02713398f, -0.05713647f, 0.05827617f, 0.02517991f, -0.00892954f, 0.02494870f, 
    0.01525731f, -0.06335714f, -0.05479504f, -0.02301654f, -0.00728458f, -0.04577278f, 0.04785822f, 0.06191885f, 
    0.03875929f, 0.00632217f, -0.01659105f, -0.04550430f, 0.04279067f, 0.07700431f, -0.07809192f, 0.03313964f, 
    -0.03596533f, 0.00483123f, -0.09274840f, -0.00909083f, -0.02669597f, -0.07383066f, 0.08724160f, 0.04659929f, 
    -0.04412300f, 0.02267664f, -0.08660595f, -0.02217291f, 0.08838209f, 0.02600642f, -0.05390696f, -0.01268657f, 
    0.06428200f, 0.05585767f, -0.02735662f, -0.05578819f, 0.01739696f, 0.01076914f, -0.05305960f, 0.07729056f, 
    0.06257904f, 0.00138628f, -0.08113181f, -0.09564422f, 0.05860014f, 0.04205791f, 0.00717716f, -0.01961399f, 
    -0.08428803f, -0.05228068f, -0.00399805f, -0.00083865f, -0.07329846f, 0.02299352f, -0.06196526f, 0.00796424f, 
    0.03946130f, -0.04832001f, -0.02384119f, -0.07784379f, -0.03541647f, -0.04289906f, -0.05397746f, 0.06785163f, 
    0.06806815f, -0.11078022f, -0.04856826f, 0.02889557f, -0.09782341f, -0.09916296f, -0.08943437f, 0.00073546f, 
    -0.00874266f, -0.02677076f, -0.01834207f, -0.01809228f, -0.02908195f, -0.07075036f, -0.01292666f, -0.02130095f, 
    -0.08080155f, -0.07172266f, -0.10239419f, 0.01400111f, -0.08582355f, -0.03213044f, 0.01940622f, 0.06740023f, 
    -0.04173863f, 0.04068271f, 0.01686794f, 0.00186165f, -0.02456725f, 0.03204290f, -0.01361430f, -0.07834995f, 
    0.06538739f, -0.01135303f, -0.07870099f, -0.10741898f, -0.02123560f, -0.07813686f, -0.04295341f, -0.08764096f, 
    0.04472199f, 0.06958754f, -0.05392315f, -0.09183127f, -0.02291298f, 0.06830494f, -0.07448926f, 0.03335414f, 
    0.06210693f, -0.00220789f, -0.06978194f, -0.05588802f, -0.00488184f, 0.06364013f, -0.04771097f, 0.00186822f, 
    0.02530993f, 0.08654634f, -0.09079643f, -0.00490674f, -0.06287305f, -0.06241959f, 0.04143839f, -0.06149912f, 
    0.03355953f, -0.00293158f, 0.07485421f, -0.06097889f, -0.01541758f, -0.01080424f, 0.03207295f, 0.01245728f, 
    0.02637276f, 0.00423553f, -0.09481060f, 0.04663871f, 0.02291785f, 0.05159219f, -0.05544249f, 0.01447390f, 
    -0.07642166f, 0.01075639f, -0.02532811f, 0.06968995f, -0.02029692f, 0.00923025f, -0.00949068f, -0.02930638f, 
    -0.06001402f, -0.03485241f, 0.01205019f, 0.05851022f, 0.00619304f, 0.02589552f, -0.03031510f, 0.05600891f, 
    -0.04952199f, -0.02345855f, -0.03426944f, 0.03172280f, -0.01668780f, -0.07699484f, 0.00702734f, 0.02574741f, 
    0.04448847f, -0.00778460f, 0.02738442f, 0.05330960f, 0.06404381f, 0.06909790f, -0.08986709f, -0.01226507f, 
    -0.00168481f, 0.02030940f, 0.00439628f, -0.06183133f, 0.03157698f, 0.06753648f, 0.08082880f, -0.08802181f, 
    0.05474581f, 0.02369740f, -0.04343720f, 0.04139480f, -0.08586559f, -0.08544237f, -0.05572372f, -0.03348242f, 
    -0.02232881f, -0.02529139f, 0.02698032f, 0.02785370f, -0.05825571f, -0.05072582f, 0.02451153f, 0.02335739f, 
    -0.05514332f, 0.04646241f, 0.06411120f, -0.05953820f, -0.03368760f, 0.07817550f, 0.04012047f, -0.03658931f, 
    0.03874377f, 0.02139286f, -0.01939825f, -0.04870962f, -0.06298818f, 0.02243638f, -0.03305010f, 0.07159809f, 
    -0.04195036f, -0.02845526f, -0.07471417f, -0.03293002f, 0.06532360f, 0.00835919f, 0.06564400f, -0.05345826f, 
    -0.08347549f, 0.01068308f, 0.06067224f, -0.03185039f, 0.03461469f, 0.00595383f, 0.03228392f, -0.03929152f, 
    -0.04581358f, -0.02109283f, -0.07951310f, -0.01079875f, -0.04089165f, 0.01234790f, 0.06601658f, -0.02032113f, 
    -0.02739668f, -0.00498180f, 0.05054061f, 0.02735828f, -0.02839457f, -0.06746237f, -0.08655185f, 0.04202571f, 
    0.02299554f, -0.05791238f, 0.03503780f, 0.06889059f, -0.07429466f, -0.00698067f, 0.00437464f, 0.01744618f, 
    0.05645246f, -0.03420051f, -0.06154172f, -0.09254117f, 0.02077497f, 0.05778723f, 0.01179519f, -0.07408243f, 
    -0.06910501f, -0.07778176f, -0.00372462f, -0.00153709f, 0.00461752f, -0.08948624f, 0.07717472f, -0.03117852f, 
    -0.04601293f, -0.01929217f, 0.00645463f, 0.08370920f, -0.05377001f, -0.05154024f, -0.03767228f, 0.02124305f, 
    0.05358572f, 0.06795256f, 0.04540146f, 0.03766715f, -0.02128062f, 0.05760307f, -0.05491755f, -0.01404604f, 
    -0.03105442f, -0.05062199f, -0.07138211f, 0.07521549f, 0.01924432f, -0.06302788f, -0.09334029f, 0.06703102f, 
    -0.00755031f, -0.02222474f, -0.05071682f, 0.05092430f, 0.00374609f, -0.05479863f, 0.05806987f, 0.01602316f, 
    0.00546696f, 0.02933187f, 0.00943588f, 0.06405000f, 0.01907713f, 0.01586894f, -0.03766632f, -0.03656521f, 
    -0.08872408f, 0.08123938f, 0.02237832f, 0.08674595f, 0.00622390f, 0.06454549f, -0.06728089f, 0.07221563f, 
    -0.07302733f, 0.08178774f, 0.01578685f, -0.06248672f, -0.09939548f, 0.05339479f, -0.00272682f, 0.02835882f, 
    -0.06367000f, 0.06183766f, -0.02118918f, 0.08147135f, -0.01389124f, 0.07548823f, -0.01249182f, 0.01181109f, 
    0.03972904f, 0.02518514f, 0.08156510f, -0.07601128f, 0.04434508f, -0.04139444f, -0.04199099f, 0.07015403f, 
    -0.00639913f, -0.08735219f, -0.07889352f, -0.04010064f, 0.00329765f, -0.08664817f, -0.09351362f, -0.05604558f, 
    0.07822613f, -0.04069852f, -0.05256445f, 0.00890129f, -0.10217272f, -0.05279549f, -0.02738610f, 0.03045598f, 
    -0.03705631f, 0.11974038f, 0.32146418f, 0.09289673f, 0.00862719f, 0.03362348f, 0.05125944f, 0.04721470f, 
    0.04732757f, 0.02629238f, 0.02137498f, -0.02249249f, 0.09437627f, 0.04623187f, -0.03974980f, 0.12804528f, 
    -0.01584776f, -0.26739523f, -0.10010218f, -0.01390206f, 0.09638418f, 0.18788756f, 0.17766929f, 0.02067903f, 
    -0.00013523f, -0.07069858f, 0.01808657f, 0.09333690f, 0.23031537f, 0.18354166f, -0.03774649f, 0.12752566f, 
    0.10566133f, -0.20458604f, 0.08102095f, 0.30740073f, 0.43800333f, -0.16729631f, 0.33224535f, -0.07149374f, 
    -0.29747608f, -0.18597144f, 0.00954368f, 0.00246853f, 0.12075397f, -0.08356978f, 0.27787861f, 0.12179289f, 
    0.07307917f, 0.02963667f, -0.21083525f, -0.01874006f, 0.19706279f, 0.04542818f, 0.06055233f, -0.02442461f, 
    -0.02959976f, 0.07663352f, 0.03184164f, 0.22644936f, 0.21721341f, 0.11244299f, -0.02429969f, 0.37337974f, 
    -0.08310655f, 0.23249994f, -0.19243939f, 0.12143974f, -0.05086838f, -0.21941443f, -0.09569915f, 0.09859171f, 
    0.06969775f, 0.13109592f, 0.02942316f, 0.09690317f, 0.05885432f, -0.38459575f, 0.20288454f, 0.16005942f, 
    -0.00563999f, -0.01451203f, 0.02425414f, 0.00437744f, -0.04635607f, -0.03702243f, -0.25345993f, -0.06066596f, 
    -0.04586974f, 0.02233750f, -0.01368095f, -0.04685297f, 0.17439552f, 0.01370469f, -0.01324193f, -0.05984968f, 
    -0.32068297f, -0.00317550f, 0.18335050f, -0.29549274f, -0.07862356f, 0.20272233f, -0.08229551f, -0.04684777f, 
    -0.02635612f, -0.16297194f, 0.21221103f, 0.01347403f, 0.30175641f, -0.09096915f, 0.37610856f, -0.19440791f, 
    0.08699692f, -0.00692038f, 0.06206079f, 0.07528013f, 0.20572722f, 0.32425812f, -0.17485200f, 0.02979344f, 
    0.22424385f, -0.06667469f, -0.13032778f, 0.15853231f, -0.10066757f, 0.30290478f, -0.13353142f, 0.10239340f, 
    0.31543830f, 0.32111734f, -0.00227418f, -0.01804291f, 0.08670924f, -0.30439422f, 0.45397064f, 0.09146616f, 
    0.01969579f, 0.05728171f, -0.34978810f, -0.76709849f, 0.27628571f, -0.22426717f, 0.15878208f, -0.11394414f, 
    -0.05792010f, -0.38045436f, -0.04413842f, 0.28259099f, 0.03668605f, -0.23653767f, 0.04315954f, -0.02493792f, 
    -0.03933463f, 0.27590114f, -0.02772573f, 0.04460334f, 0.12410769f, 0.02217476f, -0.07597473f, 0.18999965f, 
    0.17635627f, -0.11472577f, -0.02398839f, 0.26645774f, 0.19055460f, -0.17088535f, 0.07701124f, 0.16923331f, 
    -0.09688637f, 0.42599005f, 0.16397840f, 0.10278433f, -0.12665774f, 0.00818046f, 0.00935815f, -0.01475381f, 
    -0.21868943f, -0.07730365f, 0.10137474f, 0.14317568f, -0.05436713f, 0.14360414f, -0.50052452f, 0.05511485f, 
    0.08809794f, -0.05121313f, 0.08821138f, 0.37228647f, 0.13245976f, 0.01133330f, -0.09321316f, 0.54818439f, 
    -0.28960016f, 0.27055582f, -0.16370296f, -0.03221970f, -0.00234987f, 0.38515452f, 0.15807413f, 0.03975910f, 
    0.06979924f, -0.12474737f, 0.02520545f, 0.15981919f, -0.10399938f, 0.25587225f, -0.21792080f, 0.23059291f, 
    -0.06249947f, 0.07790613f, -0.17888397f, 0.23917356f, -0.00642409f, 0.07862452f, -0.05023270f, -0.15780546f, 
    0.35708046f, -0.03129561f, -0.05454724f, 0.00241961f, 0.04483218f, 0.03052489f, -0.18729088f, -0.06368008f, 
    -0.07313866f, 0.32055044f, -0.10376863f, 0.07654794f, 0.06731845f, -0.40775266f, 0.09097748f, -0.34789464f, 
    -0.00572903f, 0.17819470f, -0.29751745f, 0.26954699f, -0.34232533f, 0.23992807f, 0.19810218f, 0.05683311f, 
    -0.08220274f, -0.34507954f, 0.06060555f, 0.12052544f, -0.37160599f, 0.44977957f, 0.14658611f, -0.27568665f, 
    0.15512520f, 0.20379685f, -0.13770390f, -0.46272442f, 0.07577218f, -0.27007499f, -0.24223803f, 0.12861088f, 
    -0.06170135f, 0.06861923f, 0.22419250f, 0.18718450f, -0.13256490f, 0.25659940f, 0.04457236f, 0.12552302f, 
    0.08977455f, 0.16567810f, 0.00913291f, 0.05403377f, 0.11749940f, -0.12019479f, -0.10625319f, -0.09074699f, 
    0.00813653f, 0.12375779f, 0.01324133f, 0.07294778f, -0.14173779f, -0.06959926f, 0.05918035f, -0.03941053f, 
    0.02091024f, 0.03370455f, -0.06494709f, 0.08881361f, 0.22914967f, 0.55609238f, -0.07336202f, -0.00164107f, 
    0.11055325f, -0.11700642f, -0.11644325f, 0.22318041f, 0.01556887f, -0.02615800f, 0.08942831f, 0.01998244f, 
    -0.22614281f, -0.00382046f, 0.07495100f, -0.14017391f, 0.02867985f, -0.41379815f, -0.10980169f, 0.15550546f, 
    -0.06315784f, -0.08174822f, 0.02981630f, 0.18189697f, -0.23542619f, 0.09645592f, 0.01518839f, 0.07929778f, 
    0.02537507f, -0.09055290f, -0.13172637f, -0.04591937f, -0.00623365f, 0.03660976f, 0.05204971f, 0.24623881f, 
    -0.01943136f, 0.32614243f, 0.03616354f, 0.10461659f, 0.01040135f, -0.06334220f, -0.05629200f, -0.01933312f, 
    0.33699349f, -0.06904686f, -0.13140284f, 0.08741815f, -0.01720811f, -0.37385541f, -0.27796873f, 0.11143912f, 
    -0.15861771f, -0.04366209f, 0.14292727f, -0.13671927f, -0.01787803f, 0.21379226f, 0.05400705f, -0.10414810f, 
    -0.14437678f, -0.09812474f, 0.43017226f, -0.07335019f, 0.03939699f, 0.00792836f, 0.21847473f, 0.01240576f, 
    -0.11474981f, 0.21456651f, 0.12027604f, -0.17509593f, 0.02579088f, -0.03896619f, 0.07167436f, -0.01045034f, 
    -0.03496847f, -0.11330496f, 0.39515510f, 0.22457425f, 0.00963105f, -0.11081786f, 0.20188105f, -0.10816030f, 
    -0.15717924f, -0.13335034f, 0.24512625f, -0.01718653f, 0.02806374f, 0.34704408f, -0.09579330f, 0.01844219f, 
    0.11407134f, 0.06067144f, -0.20079592f, 0.22509849f, -0.06105686f, 0.10489321f, -0.05000395f, -0.11877285f, 
    0.14680484f, 0.34844127f, -0.09129406f, -0.11732196f, -0.41427985f, 0.23625596f, 0.18418117f, 0.03935498f, 
    0.03349396f, 0.13913375f, -0.39625600f, -0.62822205f, 0.26650840f, 0.08920504f, 0.11060326f, 0.07629958f, 
    0.11905853f, -0.31742996f, 0.22460264f, 0.04104415f, -0.16069409f, -0.17583121f, -0.01451831f, -0.02321926f, 
    -0.10472661f, 0.01852013f, -0.05559020f, -0.08202343f, 0.08706021f, 0.27044597f, 0.02062633f, -0.05720019f, 
    0.10979158f, -0.16658372f, 0.30929232f, 0.30849260f, 0.09478904f, -0.14053005f, -0.01223170f, 0.04328876f, 
    -0.09871461f, 0.22863987f, 0.31233102f, -0.05031952f, 0.02315466f, 0.02498771f, 0.06775453f, 0.03856616f, 
    -0.21561587f, 0.03654955f, 0.17424774f, 0.13252486f, 0.28179166f, -0.02295422f, -0.38345936f, 0.06217070f, 
    -0.07856770f, -0.31542790f, 0.01556814f, 0.18282135f, 0.01311972f, 0.13464014f, 0.04407005f, 0.32263625f, 
    -0.30881760f, 0.13651852f, 0.19945228f, -0.04482502f, 0.03590576f, -0.21431519f, 0.23640424f, -0.07997191f, 
    0.17139611f, -0.24320060f, -0.08822310f, -0.08176124f, -0.12503760f, 0.02448288f, 0.12383419f, 0.10330778f, 
    -0.02546034f, 0.16133934f, 0.01628954f, -0.02982709f, -0.09275919f, -0.01305212f, 0.01932180f, 0.23694812f, 
    0.09481934f, 0.00802744f, 0.12827092f, 0.09443185f, -0.08835370f, -0.00309272f, 0.12075529f, -0.01227709f, 
    -0.03581209f, 0.37749550f, -0.12342481f, 0.38873732f, 0.00850293f, 0.01007042f, 0.00688144f, -0.19239171f, 
    -0.04560087f, 0.02081122f, -0.15729760f, 0.28164074f, -0.03891905f, -0.14113416f, 0.19982833f, 0.01287630f, 
    0.04880868f, -0.05706492f, 0.24358529f, 0.03978557f, -0.02666999f, 0.73499185f, 0.01369617f, -0.52749145f, 
    0.12182880f, 0.07967960f, -0.08036198f, -0.34743184f, -0.01846555f, -0.13297665f, -0.06149537f, 0.13708678f, 
    0.31226397f, -0.15039961f, 0.00476909f, -0.08114839f, 0.01078986f, -0.42271173f, 0.08553727f, -0.10607097f, 
    -0.08677265f, 0.08539376f, -0.01109036f, 0.07464910f, -0.16911995f, 0.02880781f, 0.04172570f, -0.00886489f, 
    -0.00449721f, 0.06436480f, 0.12592292f, -0.10539500f, 0.05242047f, -0.07540475f, -0.09341805f, -0.08563152f, 
    -0.11535574f, -0.09330064f, 0.05564966f, -0.02355947f, -0.08918633f, -0.34096527f, -0.00773330f, -0.04657891f, 
    -0.02869506f, -0.04003958f, -0.09283304f, -0.15536617f, 0.04441447f, 0.31667659f, -0.16510203f, -0.04255207f, 
    0.55515254f, 0.13081834f, -0.10590508f, -0.04310441f, 0.09908522f, 0.39449149f, -0.07924569f, -0.00829409f, 
    0.09561467f, 0.11766656f, 0.12028806f, 0.04859716f, 0.50856835f, 0.00580776f, 0.10466149f, 0.07494479f, 
    0.04608426f, -0.09138191f, 0.02699292f, -0.03390366f, -0.09067585f, 0.15346016f, -0.00396662f, -0.00075000f, 
    0.08858833f, -0.07477041f, 0.15558319f, -0.11457957f, 0.03678710f, -0.12137925f, 0.08532366f, -0.13297705f, 
    -0.22242628f, -0.14296231f, -0.21948285f, -0.08363125f, -0.02673737f, 0.40470594f, -0.02665216f, 0.00687387f, 
    -0.14540531f, 0.26233640f, 0.15942977f, -0.40623638f, 0.00284221f, 0.07724841f, 0.16097647f, 0.12040199f, 
    0.09602265f, -0.07105726f, -0.06939784f, 0.04861073f, 0.04084723f, 0.15065771f, 0.16461165f, -0.08166312f, 
    0.34966409f, -0.07515330f, -0.31965190f, 0.09608889f, 0.00594940f, 0.11855052f, 0.04943014f, 0.06212175f, 
    0.01052475f, -0.17630343f, 0.07598279f, 0.01958413f, 0.02870703f, 0.06710628f, -0.09277109f, 0.24897434f, 
    -0.01930789f, 0.19288866f, -0.06690512f, -0.01256295f, -0.07707153f, 0.03231405f, 0.08472075f, -0.12352767f, 
    -0.05779417f, 0.21321853f, 0.02978142f, -0.09041580f, 0.05725792f, -0.25152913f, 0.63526452f, 0.11906175f, 
    -0.27008832f, -0.59580612f, -0.01431993f, -0.27362844f, 0.24760574f, -0.44485617f, 0.04214046f, 0.22205974f, 
    -0.47773868f, -0.04391114f, -0.02070941f, -0.00063015f, 0.02343806f, -0.02645758f, 0.06361745f, -0.00647678f, 
    -0.18170640f, -0.34385273f, 0.07105426f, 0.42490327f, 0.09548381f, 0.16168423f, 0.25001743f, -0.02939232f, 
    -0.34620914f, 0.16820362f, 0.33890861f, -0.00210856f, 0.09842934f, 0.03439578f, 0.04265507f, 0.34668642f, 
    -0.07096546f, -0.04383484f, -0.48397726f, 0.11861061f, 0.35443148f, 0.09458489f, 0.26592600f, -0.26618484f, 
    -0.10951575f, 0.03105841f, -0.28943586f, -0.03527649f, -0.11338869f, 0.00884535f, 0.05668415f, 0.18825139f, 
    0.32232612f, -0.15495628f, 0.01345333f, -0.10288954f, 0.30133879f, -0.27029768f, 0.22840773f, -0.01747969f, 
    0.06558917f, -0.24429417f, 0.15148066f, 0.02249828f, -0.16347083f, -0.25768390f, 0.07426552f, 0.01999570f, 
    0.10122651f, 0.05615642f, -0.10951050f, 0.19154376f, -0.06317217f, -0.15422833f, -0.40575692f, -0.21057345f, 
    -0.12109930f, 0.21174242f, 0.16253436f, 0.04763733f, 0.00193471f, -0.40374216f, -0.22200997f, 0.01707706f, 
    -0.14416060f, 0.13810559f, -0.10304061f, -0.29817674f, -0.21771166f, -0.11544607f, -0.17962526f, -0.16552961f, 
    0.07496855f, 0.33029476f, 0.09274118f, 0.05292209f, -0.06780829f, 0.12916519f, 0.07345813f, 0.02455643f, 
    -0.24515912f, -0.02519131f, -0.23232952f, 0.09305222f, -0.01694274f, 0.27007851f, -0.13011579f, -0.06365553f, 
    0.01959320f, -0.12519826f, 0.28724909f, -0.07529688f, 0.36941826f, -0.07939097f, 0.32311636f, 0.21574906f, 
    0.17887875f, 0.28129452f, -0.05868060f, -0.12477225f, -0.17850021f, -0.11245447f, -0.06646899f, 0.05902972f, 
    0.31218982f, 0.09787381f, 0.09495128f, 0.08911338f, -0.07325751f, 0.30577007f, 0.05182415f, 0.18592651f, 
    -0.21579026f, 0.23836970f, 0.15791304f, 0.02051318f, -0.39056304f, -0.09888304f, -0.24149740f, -0.17076506f, 
    0.07719188f, 0.00071060f, -0.11759067f, -0.15272616f, -0.13772801f, 0.25827709f, -0.34477955f, -0.19159044f, 
    -0.31780332f, 0.25089797f, 0.03511875f, -0.15159957f, -0.12059098f, -0.26335034f, -0.16730429f, -0.06324928f, 
    -0.08472516f, -0.18325078f, 0.09128816f, 0.00230479f, 0.10598855f, -0.06256896f, 0.00928619f, -0.11559875f, 
    -0.02889356f, 0.07082299f, -0.27135599f, -0.03072289f, -0.04216022f, 0.03958780f, -0.37956998f, -0.20643185f, 
    0.14319724f, -0.19360709f, -0.00984473f, -0.31596041f, -0.31592083f, 0.09432614f, 0.11984886f, 0.17845544f, 
    0.00350942f, 0.07023894f, 0.10547026f, 0.03913701f, -0.22281726f, 0.07162274f, 0.01358898f, 0.04772271f, 
    -0.07594104f, -0.20214798f, -0.14762469f, -0.27824479f, -0.01566739f, 0.06442683f, 0.00956197f, 0.12103578f, 
    -0.14376694f, 0.06636644f, 0.23493673f, 0.07413508f, 0.04700729f, -0.27196133f, 0.18035644f, 0.11356031f, 
    0.25857481f, -0.09927282f, 0.05939220f, -0.08138682f, 0.23628397f, -0.05389490f, 0.17126024f, -0.35555202f, 
    -0.24411032f, -0.12281518f, 0.28607270f, -0.27563363f, -0.06930947f, 0.04175687f, -0.20190628f, 0.28854349f, 
    -0.02575928f, -0.11401341f, 0.29879895f, -0.03986261f, 0.02458589f, -0.01461001f, 0.39204580f, 0.01446504f, 
    0.44380164f, 0.01606661f, -0.21995020f, -0.08735622f, -0.02232751f, 0.04529433f, -0.06714392f, -0.13042521f, 
    0.00497213f, -0.18908338f, 0.36521211f, -0.04308014f, -0.12648833f, -0.23996066f, 0.06137516f, 0.27756649f, 
    -0.12272737f, -0.04838361f, 0.14837787f, -0.24339537f, 0.14307734f, 0.05830593f, 0.08268139f, -0.02786182f, 
    -0.07021952f, 0.01099056f, -0.20316380f, 0.23916525f, -0.04621416f, 0.07132357f, 0.43470791f, -0.12714139f, 
    -0.00874309f, -0.02283963f, -0.11207342f, -0.07965174f, -0.06170534f, 0.04975022f, -0.14452522f, -0.06444662f, 
    -0.04628262f, -0.09843823f, -0.02508246f, 0.03106104f, -0.08010349f, 0.04663843f, -0.01114797f, 0.01545244f, 
    -0.01717093f, -0.04835699f, -0.05550557f, 0.00897931f, -0.05417367f, -0.01972691f, 0.02454690f, 0.01115179f, 
    0.01205985f, 0.03519850f, -0.08447083f, 0.04947127f, -0.06994596f, -0.15963826f, -0.08281329f, 0.00626867f, 
    -0.13007145f, -0.06697193f, 0.01575326f, -0.08579399f, -0.09834054f, -0.10643776f, -0.04961097f, -0.06784161f, 
    -0.13354197f, 0.02738204f, -0.08494975f, 0.02234803f, 0.02393685f, 0.07505776f, -0.04109729f, -0.10182154f, 
    0.07214890f, -0.04190841f, -0.03931108f, -0.02769119f, -0.04016635f, 0.04221753f, -0.08130248f, -0.04698028f, 
    0.06962743f, 0.07160483f, 0.00617284f, -0.00395707f, 0.07514851f, 0.00601567f, 0.02320315f, -0.10169199f, 
    0.09604283f, -0.11119682f, -0.15250677f, -0.07871982f, 0.01027513f, -0.08045748f, 0.01462673f, 0.04257023f, 
    -0.04554119f, 0.09603896f, 0.08782731f, 0.03511636f, -0.11429679f, -0.17886543f, -0.04195238f, -0.11781333f, 
    0.02312871f, 0.02726541f, -0.05405249f, -0.00485976f, 0.03676667f, -0.01675742f, -0.01477826f, 0.00211555f, 
    -0.10317530f, -0.04506995f, 0.05063863f, 0.05753684f, 0.04656448f, -0.05868202f, 0.02643644f, 0.05139015f, 
    -0.09662022f, -0.06833611f, 0.02790031f, 0.01842628f, 0.08045956f, -0.01008020f, 0.00534050f, -0.00271552f, 
    -0.08261511f, 0.04583060f, -0.10833997f, 0.03742092f, -0.13654073f, -0.09829286f, -0.06176335f, -0.07653109f, 
    -0.06674322f, -0.02008325f, 0.00198616f, -0.08794135f, 0.03062276f, -0.09070813f, -0.03211484f, -0.04625102f, 
    -0.12304769f, -0.11379492f, 0.02104927f, -0.08122149f, 0.02614084f, 0.04529493f, -0.02848893f, -0.11120217f, 
    -0.19717997f, -0.42711335f, 0.25165290f, 0.12127105f, 0.07844082f, -0.17001729f, 0.00525224f, 0.07357857f, 
    0.08237519f, -0.07999755f, 0.06741041f, -0.22978820f, -0.02909077f, 0.04967397f, -0.07625763f, -0.20498428f, 
    -0.21765979f, -0.16776623f, -0.17275096f, -0.00700651f, 0.13149582f, 0.02601797f, 0.17949240f, -0.02953911f, 
    0.13432978f, 0.17396647f, 0.21725231f, 0.15008518f, 0.01864835f, -0.09153496f, 0.05330745f, 0.12792338f, 
    -0.11301240f, 0.11620864f, -0.10384168f, -0.05229430f, 0.00651998f, 0.11117276f, -0.44153354f, 0.06674070f, 
    0.20700708f, 0.00454682f, -0.15447472f, 0.48895207f, -0.04237238f, 0.25290638f, -0.00021397f, 0.32166299f, 
    0.03943651f, 0.02015229f, 0.03096649f, -0.08892795f, -0.09230947f, -0.09354495f, 0.07896741f, -0.03149868f, 
    -0.04320399f, 0.05577528f, -0.02255266f, 0.05840323f, 0.11289947f, -0.21335505f, -0.00985046f, 0.05005337f, 
    0.30113903f, 0.08144645f, -0.21729673f, 0.18757641f, -0.01465054f, 0.12330783f, -0.20886874f, 0.15412857f, 
    0.04538577f, 0.29862109f, 0.02514729f, 0.02688630f, 0.13866422f, 0.01242201f, -0.25319561f, -0.26915026f, 
    0.24757393f, 0.00426442f, -0.14280456f, -0.32156479f, -0.16363658f, 0.09893432f, -0.48442942f, -0.13919395f, 
    0.16370009f, 0.06684342f, 0.03071069f, -0.07672414f, -0.05906053f, 0.08202223f, 0.23767972f, 0.01816877f, 
    0.18055031f, 0.01954677f, -0.02048395f, -0.05661060f, 0.08419982f, 0.50077415f, -0.04154692f, -0.08136787f, 
    0.01490008f, -0.05172243f, 0.19384934f, -0.01615379f, 0.57522589f, 0.01696595f, 0.02836705f, 0.05956222f, 
    0.11612589f, -0.17109388f, 0.08634079f, -0.01352502f, 0.01103835f, 0.03253234f, -0.19375956f, 0.08029167f, 
    0.09662141f, 0.05892106f, 0.13674302f, 0.08060407f, 0.04701519f, 0.17341852f, 0.10217991f, 0.14789772f, 
    -0.29696000f, 0.17846246f, -0.08177142f, -0.15394990f, -0.17749749f, 0.16258778f, 0.03210471f, -0.00256315f, 
    -0.01158518f, -0.03381660f, -0.05798520f, 0.08543234f, -0.00110403f, -0.15477063f, -0.12975816f, 0.18114324f, 
    0.04724566f, 0.18309920f, -0.01052614f, 0.02174736f, -0.22851428f, 0.05577859f, 0.18425773f, -0.01381485f, 
    -0.05102692f, -0.14252362f, 0.11944481f, -0.02082681f, 0.28759053f, 0.42130405f, -0.05313561f, 0.13575080f, 
    0.07679367f, 0.10310492f, -0.15402704f, 0.05467539f, 0.16836265f, -0.09309514f, -0.15880580f, 0.09901360f, 
    -0.07468989f, -0.08290383f, 0.09615669f, -0.12218110f, -0.07505974f, -0.09035052f, -0.08008128f, 0.25197232f, 
    -0.14199002f, 0.01772980f, 0.20779441f, -0.03988830f, 0.59377611f, -0.08975452f, -0.13942899f, -0.07009261f, 
    -0.07281830f, -0.18094236f, -0.19349977f, -0.24145316f, -0.19161092f, 0.05822871f, 0.02033712f, 0.25293633f, 
    -0.25304234f, 0.00258447f, 0.35128114f, 0.20186505f, 0.00908201f, -0.27824748f, -0.22489138f, -0.13930675f, 
    0.25809756f, 0.03088333f, -0.09424071f, -0.07542895f, 0.00374595f, -0.20555080f, -0.00804368f, 0.03684403f, 
    -0.23577127f, 0.03143515f, 0.15855189f, -0.11944781f, -0.09871510f, -0.16760248f, 0.21714139f, -0.03144810f, 
    -0.20593403f, 0.03686719f, 0.21703419f, 0.02753672f, -0.07469755f, -0.01412685f, 0.36064893f, 0.05655987f, 
    0.09085679f, 0.09567509f, -0.13547395f, -0.21435407f, 0.00131518f, 0.17415912f, -0.02933026f, -0.02762758f, 
    -0.10985893f, -0.37468091f, 0.42042986f, -0.00063519f, 0.30402106f, -0.01645784f, 0.04053636f, 0.29339442f, 
    0.02579544f, 0.10081664f, 0.15191749f, -0.01781467f, 0.06298694f, 0.29765791f, -0.22586378f, -0.01093311f, 
    0.13059346f, 0.10379077f, -0.12157342f, 0.19057113f, -0.12073088f, 0.23329601f, -0.10407054f, 0.27354649f, 
    0.04201876f, 0.01297290f, -0.01960823f, -0.00310293f, 0.03663098f, -0.09172744f, -0.08420751f, -0.01720007f, 
    0.02166680f, -0.00669338f, -0.07094036f, 0.06811237f, -0.05431323f, 0.01540340f, -0.03584838f, -0.04762701f, 
    -0.02724795f, -0.08389880f, 0.04792561f, -0.03251687f, -0.05471391f, 0.04148752f, -0.07024097f, 0.01855850f, 
    0.04486993f, 0.05735192f, -0.04687681f, -0.09579791f, -0.04278773f, 0.06547806f, -0.02270445f, -0.00373324f, 
    -0.04567279f, 0.01088930f, -0.00814929f, -0.06871283f, -0.02583029f, -0.03515647f, 0.05773198f, 0.06045540f, 
    -0.02524078f, -0.07923374f, -0.05742804f, 0.07876828f, -0.03982763f, 0.02750131f, 0.00190156f, -0.06880549f, 
    0.04437479f, 0.01017627f, 0.04804749f, -0.09693157f, -0.00816780f, -0.03453816f, 0.05419339f, -0.06882601f, 
    0.04694262f, 0.02381044f, -0.09127142f, 0.03012059f, -0.05432143f, 0.04012859f, -0.04703105f, 0.02218692f, 
    -0.08661469f, -0.08058088f, 0.03127201f, -0.07919841f, 0.00513049f, -0.05743977f, 0.03897178f, -0.10013810f, 
    -0.08372277f, -0.06442601f, -0.01629679f, 0.03552530f, -0.03576149f, -0.06632025f, 0.08169185f, -0.06573978f, 
    0.02284364f, -0.00396946f, -0.04417313f, 0.03699988f, 0.02395888f, -0.07066070f, 0.00597999f, -0.11469381f, 
    -0.05011670f, -0.00118854f, 0.06311989f, -0.05662276f, -0.07195901f, -0.09086499f, 0.01092699f, -0.03456760f, 
    0.05712136f, 0.04604143f, -0.01313882f, 0.03236011f, 0.08788180f, 0.03352131f, -0.07263810f, 0.05174429f, 
    -0.00032649f, -0.02293772f, -0.01968462f, -0.06411546f, -0.06453501f, 0.07054601f, -0.02512727f, -0.07213599f, 
    -0.00493022f, -0.05218105f, -0.06466524f, -0.09320077f, 0.03575020f, -0.05711893f, 0.06069176f, -0.11316431f, 
    -0.00389318f, 0.00988260f, -0.03059205f, 0.05001024f, 0.01521574f, 0.04229399f, 0.05846229f, 0.08344406f, 
    0.01194798f, -0.02245460f, -0.08820453f, -0.11196618f, -0.03084626f, -0.07659574f, -0.09101004f, -0.11668580f, 
    0.01366057f, -0.01957423f, 0.00678628f, -0.07390607f, -0.06245613f, 0.03500766f, 0.06363273f, 0.03448518f, 
    -0.09161721f, -0.01187679f, -0.05012084f, 0.02862427f, -0.07954037f, -0.07387716f, -0.12135003f, -0.00118437f, 
    -0.01075025f, 0.04187516f, 0.04052480f, -0.08970591f, 0.07900402f, -0.13404633f, 0.08575527f, 0.02045663f, 
    0.03279158f, 0.00597504f, 0.23463623f, -0.02694742f, 0.01006987f, -0.10747268f, 0.01204451f, 0.03647427f, 
    0.08430039f, -0.11555451f, -0.08260914f, 0.31395575f, 0.01843550f, 0.27973244f, 0.01702050f, -0.00071442f, 
    -0.00238144f, -0.07293411f, -0.01413172f, 0.02729351f, -0.00284538f, -0.02458501f, -0.04137279f, -0.04377776f, 
    -0.05574355f, -0.07386090f, -0.09333654f, 0.06031936f, 0.03431102f, -0.08238693f, 0.02660174f, -0.07051243f, 
    -0.01267849f, -0.03325646f, 0.02687570f, 0.00773932f, 0.00568519f, -0.08755129f, -0.04141478f, -0.10108955f, 
    -0.11904623f, -0.07747902f, -0.06367792f, 0.07072815f, -0.09761282f, 0.00348245f, 0.05574831f, -0.08710329f, 
    -0.06821229f, -0.05531305f, -0.09164806f, 0.03058456f, 0.02460615f, 0.03863382f, -0.01919604f, -0.10158418f, 
    0.01304351f, -0.07825108f, -0.09558472f, -0.08177659f, -0.10073601f, -0.06276149f, -0.08325472f, -0.07877766f, 
    0.06123049f, -0.01548463f, 0.00354382f, -0.09848113f, -0.00113232f, 0.30363357f, 0.00173583f, -0.01234651f, 
    -0.00859068f, 0.03067671f, -0.00721861f, -0.07396990f, 0.01706760f, -0.06075141f, -0.09395950f, -0.09002486f, 
    -0.09188975f, 0.02544956f, -0.00098523f, -0.06539858f, 0.02105837f, -0.01148203f, 0.05581417f, -0.10199828f, 
    -0.09106998f, 0.00563432f, -0.08399047f, -0.08455380f, -0.05622546f, -0.01538594f, 0.01307715f, -0.08800804f, 
    0.11454923f, -0.02852578f, 0.09954564f, 0.04446121f, 0.05546013f, 0.27455804f, -0.02951814f, 0.15194105f, 
    -0.14047056f, -0.00183373f, 0.09730549f, -0.07723292f, 0.05791648f, 0.03630514f, 0.02714031f, 0.04004465f, 
    -0.11685099f, -0.09419826f, 0.01437758f, -0.04021223f, 0.18723214f, 0.20028947f, 0.09076384f, 0.01611119f, 
    0.14111079f, 0.10048679f, -0.05342378f, 0.10611814f, -0.07126975f, 0.08573341f, 0.03309606f, 0.01395644f, 
    0.05151618f, -0.00391625f, 0.15121730f, 0.05542052f, 0.02673012f, -0.00096026f, -0.24168731f, 0.02390992f, 
    -0.23041150f, -0.00552022f, 0.06462024f, 0.14165542f, -0.00082775f, -0.23735744f, 0.26921573f, 0.05990489f, 
    -0.10888615f, -0.00273319f, 0.09273463f, -0.08342140f, -0.65430355f, 0.00800484f, 0.15270729f, -0.06147498f, 
    0.07452499f, 0.02680096f, 0.12484539f, 0.02415832f, 0.28423098f, -0.19264138f, 0.03251920f, -0.02634789f, 
    0.05362346f, 0.00631448f, -0.23798445f, 0.00042534f, 0.10595013f, 0.26175001f, 0.11504523f, 0.09152938f, 
    0.06390908f, 0.23560320f, 0.01987716f, -0.04969349f, 0.21431199f, -0.25348327f, 0.08392646f, 0.26815781f, 
    0.54599833f, -0.08186251f, -0.25255424f, 0.37616929f, 0.00313129f, 0.17867881f, -0.16138671f, -0.21716508f, 
    0.04219713f, 0.07890647f, 0.02443425f, 0.11229336f, -0.06033399f, -0.00032112f, -0.10143010f, 0.03775726f, 
    -0.10017142f, 0.08497842f, 0.36635882f, 0.01915568f, -0.04503423f, 0.09726272f, -0.11968478f, -0.08421180f, 
    0.04765171f, 0.25836438f, -0.15224759f, 0.05714952f, 0.03623491f, 0.16056223f, -0.05660063f, -0.19526218f, 
    0.10944747f, -0.01703436f, 0.02927253f, 0.05081387f, -0.07664956f, -0.24725598f, -0.11690326f, 0.09994694f, 
    0.13639487f, 0.04039816f, 0.15240243f, -0.21045718f, 0.08020801f, 0.09697545f, -0.33381659f, -0.07708581f, 
    -0.21177965f, 0.07176617f, -0.07706285f, 0.16579972f, 0.13564557f, 0.25745535f, -0.24917413f, -0.02007047f, 
    0.31082746f, 0.05186166f, 0.06465104f, -0.25957170f, 0.07469226f, -0.24867947f, -0.05562894f, 0.11609454f, 
    -0.04707685f, -0.26553759f, 0.08446820f, -0.01852105f, -0.05324411f, 0.26185042f, 0.01279053f, 0.00081912f, 
    0.04961013f, 0.00637894f, 0.10670578f, -0.11227550f, 0.20510840f, 0.35896674f, 0.06153836f, 0.00214747f, 
    -0.04337174f, 0.37429205f, 0.15387651f, -0.02431544f, -0.13254243f, -0.21157396f, -0.06324071f, 0.20995282f, 
    0.06026500f, 0.00150011f, 0.07034516f, -0.10984736f, -0.29961166f, -0.25314105f, -0.21161103f, 0.07558259f, 
    0.06619772f, 0.05745362f, 0.04924836f, 0.10510902f, -0.42171225f, -0.26120156f, -0.18904357f, -0.05750534f, 
    0.06150054f, 0.17370322f, 0.02574205f, -0.01705136f, -0.14697295f, 0.06768697f, 0.03391229f, -0.18142578f, 
    -0.06117819f, 0.11999737f, 0.44036469f, 0.07645991f, 0.06735098f, 0.24837536f, 0.19977073f, 0.13264132f, 
    0.20949523f, 0.03620483f, 0.16516881f, 0.05809682f, -0.00282366f, 0.05155599f, 0.06681967f, -0.11779974f, 
    -0.03212418f, 0.04424775f, -0.03663602f, 0.31849784f, 0.07177106f, -0.20750611f, -0.05837793f, 0.08321118f, 
    0.00056156f, 0.16961034f, 0.12368098f, 0.08348594f, -0.02261701f, 0.01487283f, -0.18455686f, -0.05125193f, 
    0.10376986f, -0.13795510f, -0.00532929f, 0.01038532f, -0.01681782f, -0.15739238f, -0.02093837f, 0.18784909f, 
    -0.04089515f, 0.05260330f, -0.11042405f, 0.22306469f, -0.00447620f, 0.21807957f, 0.00992384f, -0.00371072f, 
    0.16821988f, -0.06974868f, 0.04554126f, 0.20088907f, 0.11464299f, -0.27640334f, 0.06040953f, -0.07342476f, 
    0.10792828f, -0.00228268f, 0.09677868f, 0.05388151f, -0.14216989f, 0.08368379f, -0.46316576f, -0.18890332f, 
    0.09506486f, -0.00086738f, 0.13592598f, -0.03913620f, 0.03747494f, -0.24896646f, 0.19335119f, -0.12304206f, 
    0.08654728f, -0.10551179f, 0.07241195f, -0.09743416f, -0.05323505f, 0.06915648f, -0.03781632f, -0.07634749f, 
    -0.02602183f, -0.17441441f, -0.18454652f, 0.21654934f, 0.22182415f, 0.01510112f, 0.22779211f, 0.09345195f, 
    0.12719566f, 0.17185028f, 0.33674464f, 0.01451906f, 0.11462108f, -0.46628264f, 0.06098933f, 0.04390769f, 
    -0.18228109f, 0.13708979f, -0.11836775f, -0.05983376f, 0.16684169f, 0.02832249f, 0.12306536f, -0.11587842f, 
    0.18827084f, 0.34036836f, -0.09407426f, 0.41167271f, 0.09975516f, 0.51979810f, 0.09814341f, 0.11233611f, 
    0.16120276f, 0.17714909f, 0.09799863f, 0.05341282f, 0.01000109f, -0.03365365f, 0.06919229f, -0.06723511f, 
    -0.07078612f, 0.21806806f, 0.09239911f, 0.10249110f, 0.30610156f, 0.01815184f, 0.05753155f, 0.32381311f, 
    0.37646550f, 0.02096548f, -0.06643502f, 0.02660082f, -0.07374658f, 0.34122938f, -0.11171912f, 0.00899316f, 
    -0.22898518f, 0.33006480f, 0.17533575f, 0.04407777f, 0.11421830f, 0.29745063f, -0.06580773f, -0.04632700f, 
    0.04113638f, 0.07532450f, -0.03573704f, -0.04797401f, -0.09838968f, 0.05053275f, -0.05365236f, -0.14882676f, 
    0.17338005f, 0.06032367f, -0.21928391f, -0.00405770f, 0.10279754f, 0.10807960f, 0.04611968f, -0.00557127f, 
    0.09006678f, 0.04313301f, -0.19805586f, 0.03821968f, 0.06377795f, 0.13021238f, -0.12879913f, 0.01006212f, 
    -0.00181721f, -0.11621172f, -0.02610095f, -0.11921982f, -0.02497466f, 0.18937719f, -0.05080919f, 0.27450562f, 
    0.04382275f, -0.16762035f, 0.05445805f, -0.02897612f, 0.03928254f, -0.01853098f, -0.05679696f, 0.13250187f, 
    0.18163717f, 0.13192227f, 0.02517567f, -0.08004258f, 0.15624331f, -0.22710282f, 0.06688961f, 0.18081583f, 
    -0.23972626f, 0.16516875f, 0.13036478f, 0.09879306f, -0.19447428f, 0.35267305f, -0.06269767f, 0.00454630f, 
    -0.08513654f, -0.01298142f, -0.05755876f, 0.06698599f, -0.01697061f, 0.18427034f, -0.00825172f, 0.32984173f, 
    -0.01597520f, -0.28388637f, 0.27243948f, -0.07325561f, 0.00627592f, 0.17552134f, 0.06241981f, -0.00778970f, 
    -0.08924650f, -0.07571653f, 0.17475075f, -0.16518253f, 0.01080049f, -0.11925752f, 0.02104322f, -0.00611956f, 
    0.02326839f, -0.03265934f, 0.53666764f, 0.03907063f, 0.03802502f, 0.04134063f, -0.89542228f, -0.22842425f, 
    0.01502933f, -0.30726412f, -0.03435439f, 0.31935880f, -0.04707606f, 0.63851374f, 0.16217346f, 0.24731883f, 
    0.24428877f, 0.14178148f, -0.19834112f, -0.04379255f, 0.28421924f, -0.23121145f, 0.12138955f, -0.00719948f, 
    0.04836359f, 0.02463898f, 0.11302366f, -0.10871977f, 0.18329765f, 0.07743485f, 0.16462980f, -0.09044345f, 
    -0.03194212f, -0.07183371f, 0.23255521f, 0.16204819f, -0.03267759f, -0.16907172f, 0.16483720f, 0.06710933f, 
    0.06437418f, 0.31263575f, 0.01624923f, -0.06499417f, 0.07500606f, -0.07723448f, 0.12042360f, -0.14071286f, 
    0.25891772f, 0.03161030f, 0.01243561f, 0.00975017f, 0.01919192f, 0.15253033f, -0.67096281f, 0.39432934f, 
    0.04467451f, 0.07308543f, -0.11654079f, -0.02847230f, -0.16354328f, 0.07782122f, 0.28385830f, -0.01979930f, 
    0.08679004f, -0.22559518f, 0.10155872f, 0.00845555f, 0.00835810f, 0.55568230f, 0.03853619f, -0.06558586f, 
    0.00810673f, 0.08180508f, 0.07200000f, 0.15146796f, 0.34358829f, -0.23500469f, 0.19681042f, -0.05485648f, 
    0.09527478f, 0.04354384f, 0.08236583f, 0.17884520f, 0.32272559f, 0.10951088f, 0.03713436f, -0.18423134f, 
    0.01292029f, -0.34652612f, 0.10926680f, 0.19891599f, -0.19812569f, -0.08974959f, 0.33111158f, -0.02752723f, 
    0.07221289f, 0.03795179f, 0.14344390f, -0.31114337f, -0.07893674f, -0.15900068f, 0.38117191f, 0.11439203f, 
    -0.05755039f, 0.01300212f, -0.27602857f, 0.08855066f, -0.06190967f, -0.34137529f, 0.38377145f, -0.05129804f, 
    0.02018267f, -0.61635536f, -0.07627505f, 0.24550900f, -0.30752683f, -0.20133665f, 0.12550147f, -0.07702293f, 
    -0.36968011f, 0.04932920f, -0.00636306f, -0.01905469f, 0.22686768f, 0.31075206f, 0.00152603f, 0.20085484f, 
    0.18121785f, -0.36220923f, -0.42263845f, 0.16714346f, 0.32078633f, -0.13005051f, 0.37840214f, 0.03089054f, 
    0.00200908f, -0.22794886f, 0.08299695f, 0.06542462f, 0.02570998f, 0.35150063f, -0.28476232f, 0.36503685f, 
    -0.15853095f, -0.08302564f, 0.09787106f, -0.02307383f, 0.58946759f, 0.30337274f, -0.21982284f, 0.04358331f, 
    -0.07598224f, -0.24241459f, -0.10999147f, 0.12970543f, -0.15218875f, 0.11595829f, 0.03120976f, 0.28800866f, 
    -0.28388670f, 0.34087288f, 0.10182237f, 0.10697076f, -0.05365625f, -0.52400929f, -0.52742630f, -0.25899991f, 
    0.16087736f, -0.25967553f, 0.19564493f, 0.00611780f, -0.24800615f, -0.07402249f, -0.02213990f, 0.34790242f, 
    -0.17816669f, 0.00935683f, -0.04510717f, -0.13903035f, -0.17460756f, 0.01585974f, 0.16584736f, -0.30189380f, 
    0.19297875f, -0.10658693f, 0.02839216f, 0.00426045f, 0.18738440f, -0.05751001f, 0.15709378f, -0.02929925f, 
    -0.32702863f, 0.07760866f, -0.13766907f, -0.00187229f, 0.02597835f, -0.16351594f, 0.05173008f, -0.12667085f, 
    0.08265421f, -0.32330364f, 0.34071380f, 0.10987268f, -0.08860235f, -0.44200483f, 0.26923341f, 0.24494678f, 
    -0.14748992f, 0.15034211f, 0.18456331f, -0.23256347f, -0.42287233f, 0.46407875f, -0.11341666f, -0.05949117f, 
    0.03013940f, 0.27511305f, -0.15788570f, -0.22301051f, -0.06907545f, 0.02004308f, 0.03854788f, 0.17108211f, 
    0.00192394f, -0.24408454f, 0.33953071f, 0.08589799f, -0.08266512f, -0.10988707f, -0.06866623f, 0.01022516f, 
    0.06608712f, -0.05199989f, 0.00831022f, -0.11339968f, -0.02325095f, 0.01332511f, -0.02303146f, -0.19266441f, 
    -0.15789475f, -0.48865265f, -0.04000068f, 0.35209572f, -0.00858135f, -0.09330025f, 0.28649753f, 0.02409196f, 
    -0.09784506f, 0.25923464f, 0.28515396f, 0.01864597f, 0.15940306f, 0.13177823f, -0.06614418f, 0.13520665f, 
    0.04670754f, -0.13220982f, -0.15814631f, 0.02677227f, 0.31999013f, -0.01017341f, 0.09654602f, -0.01738466f, 
    -0.15918326f, -0.00217413f, -0.03943232f, 0.51623291f, -0.05684549f, 0.01490289f, 0.25908437f, 0.36793664f, 
    0.03993549f, -0.13395876f, -0.07769801f, 0.06227082f, -0.38074934f, 0.06594857f, 0.11176756f, 0.04499946f, 
    0.07025015f, 0.15888302f, 0.00950073f, 0.00966938f, 0.14861482f, -0.03064283f, 0.14205760f, 0.12908068f, 
    0.14374116f, 0.17724586f, -0.07085523f, 0.12037357f, 0.03823430f, 0.17941165f, -0.19759585f, -0.03542440f, 
    -0.06267852f, 0.25069937f, 0.19122294f, 0.14228556f, 0.06825764f, -0.20372194f, -0.23357235f, 0.08122317f, 
    0.08460639f, 0.02374290f, -0.05766753f, -0.49512950f, -0.11299726f, 0.14165112f, -0.10900462f, -0.31045261f, 
    0.15720810f, 0.13327621f, -0.07615501f, 0.04198999f, 0.13749513f, 0.12408472f, -0.08370628f, 0.06951779f, 
    -0.06188251f, -0.19423532f, 0.07119598f, -0.10950626f, -0.04895360f, -0.01619386f, -0.07882967f, -0.10934517f, 
    -0.08693019f, 0.00013297f, 0.13214688f, -0.03594928f, 0.06955738f, -0.08984168f, 0.20542742f, 0.04892406f, 
    0.17420161f, -0.04089141f, 0.12507515f, -0.01322305f, -0.04765737f, -0.07080159f, -0.08352701f, 0.15390435f, 
    0.10376948f, 0.21453953f, -0.03108012f, 0.11329237f, 0.06181115f, 0.31202537f, -0.23209266f, -0.04413512f, 
    -0.17292579f, -0.41842106f, 0.06630641f, 0.05406762f, 0.07023106f, 0.02058625f, 0.00987978f, 0.17533810f, 
    -0.15548886f, 0.06001170f, -0.03152275f, -0.00146206f, 0.15093796f, -0.01655597f, 0.16841921f, -0.14421670f, 
    -0.14870113f, -0.41128647f, 0.06548911f, 0.10828115f, 0.11090785f, -0.13678998f, 0.05328294f, -0.02490181f, 
    -0.09779821f, 0.16465582f, 0.16658688f, 0.02303136f, 0.04904452f, -0.19431752f, -0.06579064f, 0.14409663f, 
    0.00652176f, 0.19597331f, 0.12587231f, -0.09199383f, 0.02750157f, 0.08219696f, 0.03472303f, 0.04385397f, 
    0.06087793f, 0.09225696f, -0.01397314f, 0.00109147f, -0.29029426f, -0.29497999f, 0.13294551f, 0.20901944f, 
    -0.01621661f, 0.05851931f, 0.05218805f, -0.04096477f, -0.58897209f, -0.14802858f, 0.20437936f, 0.08721838f, 
    0.01684646f, 0.19893640f, 0.16120034f, -0.06222865f, 0.15348409f, -0.06247821f, 0.18322164f, -0.28301683f, 
    0.23782703f, -0.06409036f, -0.03435264f, 0.17761259f, 0.01944637f, 0.29725128f, 0.03447182f, 0.11378704f, 
    -0.14724602f, -0.02269509f, -0.00351092f, 0.09436319f, -0.07965013f, -0.08226015f, -0.24256751f, 0.07920533f, 
    0.22853635f, -0.04564438f, -0.12525783f, -0.30972829f, -0.04211504f, 0.15261348f, -0.22666347f, -0.07464308f, 
    0.19159287f, 0.33935288f, 0.31067866f, -0.11347008f, 0.08168977f, 0.14847521f, -0.15128198f, -0.02905504f, 
    0.04085692f, -0.03521912f, 0.02967863f, 0.13621648f, 0.02733587f, -0.44073427f, -0.00492057f, 0.07810090f, 
    -0.07201803f, 0.17226459f, -0.01889297f, -0.05714788f, -0.35845023f, 0.08413815f, 0.13231236f, 0.11113875f, 
    0.14097719f, 0.00201876f, 0.03629838f, 0.08937988f, -0.08548378f, -0.28093123f, 0.03847094f, 0.13004382f, 
    0.08227643f, 0.22349539f, 0.32667008f, 0.12872411f, 0.10351638f, 0.01881975f, -0.28301114f, -0.13563375f, 
    -0.24533609f, -0.03662450f, 0.04887562f, 0.23377469f, -0.09129177f, 0.26258829f, -0.16861179f, -0.02431231f, 
    0.37453479f, 0.11492603f, -0.03262556f, -0.02105615f, -0.01456562f, -0.15375245f, -0.14935990f, -0.15581156f, 
    -0.00295855f, 0.02541975f, -0.05481757f, -0.11704385f, -0.28263956f, -0.22109523f, -0.05886748f, -0.08588941f, 
    0.12496521f, -0.30096710f, 0.13984229f, 0.01887058f, 0.12092417f, 0.26278687f, -0.03562681f, -0.17632699f, 
    0.12041131f, 0.14802097f, 0.05983355f, -0.12391904f, -0.12538524f, -0.17319356f, 0.17831451f, 0.14087281f, 
    0.02033762f, -0.31165558f, 0.12332709f, 0.01632488f, -0.13733283f, -0.48513570f, -0.26934904f, 0.24966389f, 
    -0.19327837f, 0.04143489f, 0.05069805f, 0.00360194f, -0.39874756f, -0.15722677f, -0.06624054f, -0.06127263f, 
    -0.07181132f, 0.09309101f, -0.17702629f, -0.37942493f, -0.21291138f, 0.00146615f, 0.08112358f, -0.05724940f, 
    -0.12684914f, 0.09994011f, 0.49862337f, 0.16818725f, 0.01645196f, -0.19382091f, -0.14886607f, 0.17280771f, 
    0.22394212f, -0.22731636f, -0.14736542f, 0.02645309f, 0.11679344f, 0.02130557f, -0.40100402f, -0.11306269f, 
    0.10425132f, -0.26169595f, 0.12289715f, 0.22897828f, 0.00872780f, -0.06339471f, 0.05814932f, 0.05648694f, 
    0.00218421f, 0.06515385f, 0.36598492f, -0.08649318f, 0.04211850f, -0.14615481f, 0.00282282f, 0.04349181f, 
    0.11218066f, -0.01179897f, -0.07839608f, -0.20771454f, 0.07148042f, -0.07419500f, 0.03641144f, 0.02106210f, 
    0.01160023f, -0.16458325f, 0.25368974f, 0.08171698f, -0.25220001f, -0.05363931f, 0.01558739f, 0.16163866f, 
    -0.03905959f, -0.08519017f, 0.14469133f, -0.25130731f, 0.11910144f, 0.03630793f, -0.14948866f, 0.08825392f, 
    0.05955775f, 0.01529847f, -0.07937185f, 0.23490076f, -0.12655933f, 0.06638353f, -0.40530252f, -0.09143781f, 
    0.05925900f, -0.08212346f, 0.04094737f, 0.04693300f, -0.06217575f, 0.04992398f, 0.06987375f, -0.06501324f, 
    -0.02622262f, 0.00697521f, 0.05794597f, 0.02647610f, -0.09354983f, -0.00281363f, -0.08554650f, -0.04813534f, 
    -0.02250771f, 0.04811283f, -0.04770315f, -0.03364459f, 0.05869048f, 0.00916258f, 0.02559965f, 0.06907943f, 
    0.01567091f, -0.00264875f, 0.00842469f, -0.02706516f, 0.02930913f, -0.01524945f, 0.03483449f, -0.00490469f, 
    0.04794720f, -0.03457578f, -0.04660459f, 0.03526444f, -0.09640083f, 0.04299981f, -0.00574093f, -0.04472060f, 
    -0.08256289f, 0.01582380f, 0.05396814f, 0.04536868f, -0.09803690f, -0.06611690f, 0.02231576f, 0.00019353f, 
    0.03150567f, 0.00031946f, -0.05521584f, -0.04891047f, 0.06318200f, -0.08524180f, 0.03296482f, -0.00949921f, 
    -0.04201065f, 0.01641241f, -0.04148337f, -0.06766735f, 0.00289252f, -0.09148277f, -0.06105712f, 0.00227380f, 
    -0.06173814f, -0.02568582f, 0.01350857f, -0.09311454f, -0.07936850f, -0.02224408f, 0.02178573f, -0.10740683f, 
    -0.05075515f, -0.05716701f, -0.05757268f, -0.06230986f, -0.03649605f, 0.05419590f, 0.00411302f, -0.01508026f, 
    -0.11662828f, 0.05735046f, -0.09508996f, 0.06225500f, -0.01081597f, 0.01819830f, -0.06200567f, -0.02420744f, 
    -0.06828352f, 0.02371199f, -0.08677664f, 0.00806336f, -0.05587222f, -0.05761407f, -0.06452521f, -0.00966047f, 
    0.01506214f, -0.06487222f, -0.03484656f, -0.00795649f, 0.07423265f, -0.07249780f, -0.07520527f, -0.01675690f, 
    -0.05073213f, 0.01586411f, -0.10055479f, -0.05520606f, -0.01219537f, -0.05673403f, -0.09769123f, 0.07319093f, 
    0.07008642f, 0.00395430f, -0.08585214f, 0.07272645f, -0.09553366f, 0.05656509f, -0.03006574f, 0.05366558f, 
    0.07330354f, -0.01176756f, 0.02152694f, -0.03112870f, -0.08533309f, 0.01544143f, -0.04797647f, -0.03215163f, 
    -0.09071646f, -0.18986097f, -0.01621791f, -0.18473762f, 0.00240937f, 0.07399846f, -0.01519111f, 0.30667180f, 
    -0.35340786f, -0.01955877f, -0.05560081f, -0.03126742f, 0.24127135f, 0.16891752f, 0.23416778f, 0.35384440f, 
    0.01092826f, -0.18784983f, 0.48353243f, 0.07412477f, 0.17844550f, -0.11952447f, 0.11657596f, 0.04164748f, 
    -0.07218826f, 0.07452977f, 0.14973201f, -0.02967374f, -0.03923262f, -0.07891058f, 0.04289218f, 0.18496241f, 
    -0.02424276f, -0.02508034f, 0.37447855f, 0.26777530f, 0.22425102f, 0.25501496f, -0.37411493f, -0.22634527f, 
    0.02496422f, 0.05454240f, -0.07524227f, -0.19767141f, -0.04857997f, -0.07553099f, 0.27898246f, 0.02689826f, 
    0.09158497f, -0.08300772f, 0.23342426f, -0.01208370f, 0.08203124f, -0.26080608f, 0.20277578f, -0.06798102f, 
    -0.06186039f, 0.03824741f, 0.41654649f, 0.30955413f, 0.06838311f, -0.05703790f, 0.20553085f, -0.08477609f, 
    -0.10329419f, -0.10125539f, -0.04589743f, 0.17571419f, 0.02297437f, -0.33696899f, 0.14761004f, -0.11353994f, 
    -0.13376863f, -0.22520177f, -0.24388266f, -0.13804373f, -0.05923750f, -0.19661754f, 0.16249889f, 0.03356045f, 
    0.19106030f, 0.15966979f, 0.05287664f, -0.47006419f, 0.04567933f, -0.04905388f, -0.85084957f, 0.33173993f, 
    0.10864316f, 0.42566252f, 0.29810536f, -0.01298641f, -0.00328740f, 0.18479560f, 0.19126394f, 0.08876629f, 
    -0.07674081f, 0.14275196f, -0.08296087f, 0.32762522f, -0.03861634f, 0.06438836f, 0.01358922f, -0.11778462f, 
    -0.02204748f, -0.01245621f, -0.00574285f, 0.11111593f, -0.01374632f, -0.24832195f, 0.18234849f, 0.06094786f, 
    0.27124155f, 0.36749712f, 0.10402773f, 0.20097905f, 0.13699056f, 0.06615615f, 0.10074736f, -0.07283291f, 
    0.11505985f, -0.04920545f, 0.30256119f, 0.01853541f, 0.02186821f, 0.14619784f, 0.08652614f, 0.11970863f, 
    0.02460741f, 0.04493061f, -0.06255019f, 0.03268769f, 0.01683685f, 0.02499263f, -0.06838198f, -0.03111541f, 
    -0.10442199f, -0.06536227f, -0.10908664f, 0.05146331f, 0.06480695f, 0.01770707f, -0.03827056f, -0.11332017f, 
    -0.10451818f, 0.00857898f, -0.03846961f, -0.07041029f, 0.00204304f, -0.03370843f, 0.03896958f, -0.00600691f, 
    0.01448102f, -0.01749693f, -0.07844537f, -0.05410147f, -0.00468252f, 0.01124659f, -0.06186311f, -0.10135746f, 
    -0.01000594f, 0.00163966f, 0.02129624f, -0.05730902f, -0.07385205f, -0.05847102f, 0.04060104f, 0.01185581f, 
    -0.08763041f, 0.07555098f, 0.00017986f, 0.06564151f, -0.05486429f, 0.00851444f, 0.07425822f, -0.03022358f, 
    -0.01921519f, -0.07813753f, 0.00685020f, 0.03819624f, -0.06734553f, 0.03120308f, -0.06143286f, -0.06163155f, 
    0.05376299f, -0.13306341f, 0.04088592f, -0.07699963f, 0.01132018f, 0.01085638f, -0.02771218f, 0.03191318f, 
    -0.07946242f, -0.03647659f, -0.00082476f, -0.09986552f, 0.00460766f, 0.00602117f, -0.03674566f, -0.08842094f, 
    -0.03316785f, -0.06772996f, -0.01588511f, -0.04381130f, -0.07910444f, 0.03109274f, -0.07273075f, -0.04644394f, 
    -0.02794285f, 0.04839738f, -0.07631135f, 0.04635819f, -0.03169531f, -0.03627510f, 0.01653612f, 0.07401235f, 
    0.06019875f, 0.05007858f, -0.02484175f, -0.00931689f, -0.12933384f, -0.06953668f, -0.07452027f, 0.06942568f, 
    -0.11626454f, -0.05995515f, -0.05608232f, 0.01129292f, 0.01840097f, 0.01195744f, -0.06511924f, -0.06145709f, 
    0.03719199f, -0.00310185f, -0.06547626f, -0.08992021f, 0.03975138f, -0.05354765f, 0.03324611f, 0.05888705f, 
    -0.03418561f, 0.06765538f, 0.05218701f, -0.07598492f, 0.03311853f, 0.00247605f, -0.01550788f, -0.00174010f, 
    0.02466300f, 0.04923218f, 0.00323973f, 0.04398911f, -0.03726035f, -0.00260118f, -0.09099946f, -0.07259062f, 
    -0.25404093f, -0.37160221f, -0.13521539f, 0.00563512f, -0.34469849f, 0.33798003f, -0.01816255f, 0.09403660f, 
    -0.18855184f, -0.16675794f, -0.22133729f, -0.21640638f, 0.08525398f, 0.09739187f, -0.06620700f, 0.21506910f, 
    -0.31410348f, -0.37045932f, 0.23760016f, 0.06261113f, 0.04613373f, -0.02392093f, 0.11108389f, -0.00573857f, 
    -0.15539664f, 0.08744285f, 0.02750036f, -0.28214860f, -0.01171390f, -0.22408326f, 0.01472088f, -0.00271357f, 
    -0.21478792f, 0.12051925f, 0.67341393f, 0.11066879f, 0.09976781f, -0.15428507f, 0.01420340f, -0.30948049f, 
    -0.39383474f, 0.18561372f, 0.04634292f, 0.28951037f, -0.69977176f, 0.46319184f, 0.43944842f, -0.05238336f, 
    0.04429093f, 0.16251476f, 0.06062491f, -0.02204712f, 0.13816345f, -0.55327600f, 0.06350846f, 0.01094559f, 
    -0.00497318f, -0.06000157f, 0.18334129f, -0.02940802f, 0.07397604f, -0.02250206f, 0.19954970f, 0.00319574f, 
    -0.15224956f, -0.18835375f, 0.23890825f, -0.09884527f, 0.06323728f, 0.02456893f, 0.32624060f, 0.09259912f, 
    -0.07415637f, 0.18710975f, -0.02878048f, 0.09600358f, 0.05422911f, -0.25893813f, 0.13270487f, -0.15996580f, 
    0.28178436f, 0.20783384f, 0.00225967f, 0.33095673f, -0.07182786f, 0.00382404f, -0.08971135f, 0.26335749f, 
    -0.18286565f, 0.23601779f, 0.06631926f, 0.06724124f, -0.28714922f, 0.14527385f, 0.00264652f, -0.00335743f, 
    0.02706304f, -0.00592031f, 0.27470410f, 0.35184038f, -0.03871790f, 0.20765111f, 0.03503049f, -0.37372434f, 
    -0.01880296f, 0.22763272f, -0.31439519f, 0.04655246f, 0.00626850f, 0.01902956f, 0.12480237f, -0.23904996f, 
    0.08536796f, 0.13480543f, 0.08828036f, 0.26762372f, 0.29935789f, 0.11446041f, -0.00230639f, -0.50702274f, 
    0.12841187f, -0.32641149f, 0.22149065f, -0.06187020f, 0.00917012f, -0.16214688f, -0.07281002f, 0.17253639f, 
    0.22550078f, -0.13414603f, 0.19008252f, -0.09357310f, -0.05918405f, -0.30708140f, 0.24090715f, -0.03982576f, 
    0.06111870f, -0.06145894f, 0.05349603f, 0.06091229f, 0.04480986f, -0.08003417f, -0.06117228f, -0.09416830f, 
    -0.05669307f, -0.23537183f, -0.13787164f, 0.30217373f, 0.01596307f, 0.14622648f, 0.16742027f, 0.05493092f, 
    0.05598683f, 0.17207569f, 0.28272805f, -0.02438244f, 0.21441017f, -0.07933941f, -0.05225685f, 0.12730309f, 
    -0.07777832f, -0.02835787f, -0.05830099f, -0.04253697f, 0.29452139f, -0.03315327f, 0.60371554f, -0.06243212f, 
    -0.04906471f, 0.31540844f, -0.12686042f, 0.50014269f, -0.00523838f, 0.40480787f, 0.26187262f, 0.31672177f, 
    0.15294228f, 0.22627108f, -0.03624928f, -0.05532057f, 0.39801249f, 0.01049874f, 0.24574679f, -0.04756868f, 
    -0.03832166f, 0.26294506f, 0.06893207f, -0.02819157f, 0.16842833f, 0.01865070f, 0.10419458f, 0.08105951f, 
    0.17141727f, 0.14428791f, -0.08503758f, 0.20545925f, -0.03038399f, 0.02201552f, -0.00135536f, 0.02978865f, 
    -0.11059313f, 0.11827289f, 0.24316446f, 0.08867227f, 0.02493238f, 0.25214306f, -0.01603746f, 0.11933967f, 
    0.03295528f, 0.18335377f, -0.02929692f, 0.16266456f, -0.09116537f, -0.02458864f, -0.10051875f, -0.27114397f, 
    0.16801666f, 0.16542327f, -0.17563003f, 0.02115122f, 0.13946195f, 0.08392133f, -0.12057073f, -0.01534103f, 
    -0.20347548f, -0.16025153f, -0.24516845f, 0.00397995f, 0.06934524f, 0.06200440f, -0.14333780f, -0.09977130f, 
    -0.03351263f, -0.15411931f, 0.05587050f, -0.12275404f, 0.03228363f, 0.04896967f, 0.11207552f, 0.17941274f, 
    0.03211426f, -0.07674085f, 0.12658672f, 0.06595834f, 0.01995410f, 0.06152525f, -0.10572036f, -0.00888227f, 
    0.26717398f, 0.09686241f, -0.04008773f, -0.18831390f, 0.14766555f, -0.04114436f, -0.06274398f, 0.16367923f, 
    0.03161389f, 0.12190787f, 0.12466008f, -0.11941300f, 0.10342687f, 0.03139354f, 0.12213924f, 0.11811882f, 
    -0.04625484f, 0.13635360f, -0.06680521f, -0.07475638f, 0.14398247f, -0.08353420f, 0.03780998f, 0.07273467f, 
    0.03563306f, -0.12171380f, -0.01961128f, 0.24156044f, -0.11805470f, 0.04028903f, 0.29427150f, 0.01089804f, 
    0.05293678f, -0.08573690f, 0.01652656f, 0.15353158f, 0.12439168f, 0.61111635f, 0.07103749f, 0.19312225f, 
    0.24382235f, -0.15494202f, -0.32797202f, 0.35856622f, 0.36978006f, -0.12026434f, 0.16708463f, 0.04475026f, 
    -0.17545712f, -0.20892595f, 0.07842296f, -0.21454985f, 0.20606552f, -0.44292542f, -0.27974972f, 0.02206603f, 
    -0.08884522f, -0.14228432f, 0.13310112f, 0.11168505f, 0.17339924f, 0.06843466f, -0.16324008f, -0.03785306f, 
    -0.05733534f, -0.12336771f, -0.17216533f, 0.15716520f, -0.14435984f, 0.08500898f, -0.03966939f, 0.26856378f, 
    -0.11725773f, 0.15851331f, 0.03364468f, 0.10257994f, 0.03693853f, -0.21362269f, -0.12726101f, -0.21177506f, 
    0.27458668f, -0.04321144f, -0.22257730f, 0.08903532f, 0.03355086f, -0.26479363f, -0.03775306f, 0.20819879f, 
    -0.28119627f, -0.01620319f, 0.15424773f, 0.06103251f, -0.05539897f, -0.03496689f, 0.27692425f, -0.15831500f, 
    -0.21873230f, 0.15005895f, 0.27355319f, -0.01984649f, 0.15348366f, -0.10224346f, 0.10807773f, 0.06133312f, 
    -0.26041576f, 0.05761550f, 0.03430643f, -0.32382333f, 0.06450328f, 0.28240269f, -0.03684567f, -0.04588803f, 
    0.03557433f, -0.31222636f, 0.32910448f, 0.15465553f, 0.41890150f, -0.08381604f, 0.31021455f, 0.01057159f, 
    -0.11665064f, 0.09765342f, 0.03238592f, -0.16273196f, -0.14502494f, 0.39339846f, -0.20296876f, -0.05646193f, 
    0.27761322f, 0.25701898f, -0.09249729f, 0.05838712f, -0.11343960f, 0.25605875f, 0.10692681f, 0.12635960f, 
    0.02371900f, 0.02218843f, -0.07920419f, 0.06742399f, -0.10275320f, -0.02887728f, 0.00910704f, -0.05828624f, 
    -0.08895216f, -0.03248487f, -0.13548228f, -0.05059950f, -0.03442532f, -0.07197527f, 0.01866726f, 0.01376292f, 
    -0.03879810f, 0.06014733f, -0.02898914f, 0.00189813f, 0.05406291f, -0.00644805f, -0.08043809f, 0.00786285f, 
    0.00345569f, 0.00726974f, -0.08127028f, -0.11526262f, -0.07287879f, -0.00248966f, 0.02395492f, -0.11760373f, 
    -0.01950848f, 0.00315685f, 0.04563809f, -0.00474725f, -0.05010860f, -0.08196272f, 0.07447131f, 0.02945194f, 
    -0.04007611f, 0.01388684f, -0.08189176f, -0.07999400f, -0.03402214f, -0.06419851f, 0.07406412f, -0.01004528f, 
    0.00636103f, -0.07617034f, -0.02329560f, 0.00006546f, 0.05143865f, -0.02019875f, -0.05307149f, -0.08031245f, 
    -0.06153169f, -0.02809384f, 0.09155737f, 0.05941695f, 0.06044739f, 0.01355116f, -0.01758515f, -0.09486692f, 
    -0.09740593f, -0.09871601f, 0.01395745f, -0.10087255f, -0.07677759f, -0.00370452f, 0.02520701f, 0.00238586f, 
    -0.06793199f, -0.05330637f, -0.05221891f, 0.06616914f, -0.08182169f, 0.06541391f, -0.08636488f, -0.01776013f, 
    -0.05146464f, -0.04803443f, 0.06300032f, -0.03550044f, -0.01602226f, -0.00554135f, -0.09724803f, 0.07474488f, 
    0.01817713f, -0.03934761f, -0.02281930f, -0.08037195f, 0.02820460f, -0.00148494f, 0.01468642f, 0.07519607f, 
    0.02375068f, 0.03181172f, -0.07233924f, -0.10145713f, 0.08091495f, -0.01893263f, -0.01200482f, -0.09166810f, 
    0.04188108f, -0.06753463f, -0.12078686f, 0.00615236f, -0.06470208f, -0.08232806f, -0.05145211f, -0.02261255f, 
    -0.01159458f, -0.08021782f, 0.00192281f, 0.03370452f, -0.07001140f, -0.06121271f, -0.07115895f, -0.08876504f, 
    0.02955267f, 0.02030775f, 0.00210611f, -0.03206783f, 0.00116714f, -0.12120999f, -0.02658560f, -0.05181052f, 
    -0.19523472f, 0.05366715f, -0.17207423f, -0.04484328f, -0.13952038f, 0.39082500f, 0.02509987f, -0.07362060f, 
    0.16979507f, 0.19750616f, -0.13407797f, -0.52816451f, 0.09699397f, -0.20686410f, 0.09944858f, -0.04782193f, 
    -0.10039796f, 0.60333574f, 0.14838040f, 0.10427697f, -0.39481816f, -0.28775638f, -0.08805532f, 0.03937901f, 
    0.18340018f, -0.01081312f, -0.13068885f, -0.09853381f, 0.23562489f, 0.38963300f, -0.02366438f, -0.13827877f, 
    -0.03906718f, 0.34926248f, 0.17938685f, 0.01386085f, -0.03658102f, -0.25019825f, -0.65960157f, 0.23578225f, 
    0.21163975f, 0.07384500f, 0.18569863f, -0.33496812f, -0.24680959f, 0.43213984f, -0.24924657f, 0.16359441f, 
    -0.22293736f, 0.24811056f, 0.14247955f, 0.06559285f, 0.55172974f, -0.18481641f, -0.32966191f, -0.00017125f, 
    0.03599568f, -0.24752186f, -0.09620163f, 0.00880762f, -0.29758754f, 0.15015356f, 0.12282956f, 0.26461524f, 
    -0.39351627f, -0.05484072f, 0.56930739f, 0.02997322f, 0.07028273f, -0.27778924f, 0.15746826f, -0.20588142f, 
    0.37367278f, -0.35205382f, 0.18337730f, -0.08582053f, 0.00479089f, 0.25359491f, 0.05383009f, 0.02399054f, 
    -0.29470801f, 0.22497734f, -0.09596200f, 0.20677547f, 0.06240373f, -0.13420600f, -0.13693918f, 0.39644063f, 
    -0.03407423f, -0.16828333f, -0.03263302f, 0.00093702f, -0.02314929f, 0.07888752f, 0.33030829f, -0.08794585f, 
    0.17468582f, 0.13670190f, -0.04433709f, 0.28347105f, -0.05540401f, -0.15708955f, 0.09665928f, 0.29900321f, 
    0.06884003f, -0.03149039f, 0.17071407f, 0.26504812f, -0.21945998f, -0.26276365f, 0.03266472f, 0.21332629f, 
    -0.07480545f, 0.08590425f, 0.06541200f, -0.00192319f, -0.01390166f, 0.59851867f, 0.06461543f, -0.30937040f, 
    -0.08759559f, -0.01382220f, 0.01303813f, -0.22011955f, -0.26956138f, -0.25428846f, 0.29182014f, 0.03834533f, 
    0.07055771f, -0.02831326f, 0.10167611f, 0.15663993f, -0.05306607f, 0.05449178f, 0.10331217f, -0.13031974f, 
    0.16748364f, -0.05872722f, 0.02466694f, -0.35921207f, 0.04106249f, 0.11509538f, -0.26208547f, -0.07159407f, 
    -0.29007959f, -0.25175732f, -0.02054969f, -0.08533985f, 0.00973210f, -0.08166879f, -0.08062793f, -0.02464961f, 
    0.17875616f, 0.18263094f, 0.24935807f, -0.04697243f, -0.00600768f, -0.45769876f, 0.09226328f, -0.12847580f, 
    -0.14901784f, 0.17545490f, 0.47417435f, -0.22998346f, -0.12103687f, -0.04299782f, -0.15076199f, -0.06605334f, 
    0.26873103f, 0.13684265f, 0.00766684f, 0.43584949f, -0.31151062f, 0.41906792f, 0.16702902f, 0.23304814f, 
    0.01804393f, 0.24220552f, 0.02120753f, 0.05780047f, -0.13701136f, -0.08363471f, 0.04408557f, 0.03433328f, 
    0.06344149f, 0.16192667f, 0.03941334f, -0.11507737f, 0.24688910f, 0.03372546f, 0.13857688f, -0.10144051f, 
    0.05692996f, -0.04441267f, 0.09733094f, -0.03697681f, -0.07550995f, 0.27324921f, 0.39053446f, 0.26443326f, 
    -0.03146093f, 0.09508779f, 0.13892223f, 0.04007519f, 0.06192686f, 0.16885510f, -0.10298260f, -0.12925662f, 
    0.12629831f, 0.04145138f, 0.02532490f, 0.30684212f, 0.00234381f, 0.25145465f, -0.20297027f, 0.07159410f, 
    0.27551731f, 0.01497575f, -0.16174354f, -0.07288691f, -0.00608256f, 0.18733881f, 0.12769969f, -0.04595502f, 
    0.13075204f, 0.02765579f, 0.09351527f, 0.42666489f, 0.09744592f, -0.13516578f, 0.01963597f, -0.12868731f, 
    -0.04767499f, 0.14411427f, -0.07535316f, 0.02686106f, -0.29642856f, -0.00263388f, 0.00550091f, 0.08630192f, 
    0.08028159f, -0.25653517f, -0.01367857f, 0.08507999f, 0.15254456f, -0.13807876f, -0.04195886f, -0.05281875f, 
    -0.08146457f, 0.07645965f, 0.13258401f, 0.02564015f, 0.12043456f, -0.33406174f, 0.05004256f, -0.04690811f, 
    0.11329333f, -0.28012675f, 0.03452376f, 0.05111824f, -0.25936031f, 0.18596150f, 0.10821484f, -0.03779842f, 
    -0.11614504f, -0.13352270f, -0.18164347f, -0.31999999f, 0.04171523f, 0.00823557f, -0.14779004f, 0.16204485f, 
    -0.11795399f, 0.05723307f, 0.04984157f, -0.30026925f, 0.20254929f, 0.13429143f, -0.03816113f, 0.01820408f, 
    -0.08479140f, 0.05883842f, 0.35782164f, -0.05620459f, -0.02132628f, -0.21244052f, 0.06106749f, 0.08436029f, 
    -0.24439105f, 0.19756219f, -0.00903070f, -0.22503707f, -0.09569505f, 0.34863722f, -0.37441590f, -0.05381326f, 
    0.37116536f, -0.28220612f, 0.03893465f, -0.35577023f, -0.25410575f, 0.21097948f, -0.11238157f, 0.13044286f, 
    0.02346111f, 0.05064783f, 0.22651426f, -0.08855126f, -0.14737980f, -0.03735902f, 0.03223924f, 0.05279548f, 
    -0.02745442f, -0.37960589f, -0.05963315f, 0.00337381f, 0.20857842f, 0.04824081f, 0.18247250f, -0.11720186f, 
    0.15861107f, -0.17207271f, 0.07919373f, 0.07371350f, -0.02145663f, 0.07050549f, 0.36322874f, 0.15402541f, 
    0.13524465f, 0.27196234f, 0.02844066f, -0.16309920f, 0.31024936f, 0.35383382f, -0.04352425f, -0.27298340f, 
    -0.06316218f, -0.22796443f, 0.04284086f, -0.20077536f, 0.02151173f, 0.34028226f, -0.40851769f, 0.33545956f, 
    0.04455554f, 0.05737609f, 0.19917928f, 0.04237666f, -0.06374652f, 0.25309840f, 0.58369970f, -0.03945045f, 
    0.55910438f, 0.04903172f, 0.25528190f, 0.05719102f, -0.03129033f, 0.36088502f, 0.04972341f, -0.10937989f, 
    0.09374458f, 0.10199071f, 0.19965908f, -0.13252366f, 0.32228789f, 0.02289845f, -0.08328939f, 0.33638743f, 
    0.04089157f, 0.12822501f, 0.10941546f, 0.07705193f, 0.02264944f, -0.08492586f, 0.12694834f, -0.16442576f, 
    -0.12418946f, 0.11123475f, 0.23122299f, 0.01090527f, 0.25487787f, -0.08409488f, 0.71397716f, 0.04395628f, 
    0.08647685f, -0.11002114f, 0.13390285f, -0.08157995f, -0.11363304f, -0.30854580f, 0.21036936f, -0.04745876f, 
    0.04636797f, -0.05251960f, -0.07561851f, 0.04555556f, -0.03042321f, -0.17595889f, 0.07081883f, -0.09212577f, 
    -0.13101381f, -0.57106704f, -0.12078055f, 0.31164831f, -0.04498240f, -0.15355144f, 0.11357407f, 0.04021934f, 
    -0.06288249f, 0.13546118f, 0.26639238f, 0.08600103f, 0.25684008f, -0.03096589f, 0.00611953f, 0.16128471f, 
    -0.00037022f, -0.02020256f, -0.25629583f, 0.03790316f, 0.23176551f, 0.02544629f, 0.28717098f, 0.03007051f, 
    0.06005093f, 0.32830206f, -0.03520736f, 0.15930985f, -0.01335134f, 0.44899857f, 0.33065251f, 0.22512470f, 
    0.13168897f, 0.03137884f, -0.10812993f, -0.06618962f, 0.41555002f, 0.12305821f, 0.13901469f, 0.01844204f, 
    -0.01223205f, 0.11065191f, -0.03159444f, -0.12005619f, -0.02155169f, 0.02841916f, 0.09795639f, 0.11369786f, 
    0.10242927f, 0.21226586f, 0.06941769f, 0.12025597f, -0.00972739f, -0.06182110f, -0.25514412f, -0.11507703f, 
    -0.15427813f, -0.07273088f, -0.01321751f, 0.06799576f, -0.09688209f, 0.21569915f, -0.07665164f, 0.09988109f, 
    -0.16714260f, 0.35863844f, -0.09109300f, -0.32625476f, -0.19765402f, 0.08871029f, 0.05037491f, -0.25603747f, 
    0.13610679f, 0.12703127f, -0.05433514f, -0.00163626f, 0.14084771f, 0.12452402f, 0.06974734f, 0.03344060f, 
    -0.05485207f, -0.16926140f, -0.32725224f, -0.05527839f, 0.02538320f, 0.19976062f, -0.04049658f, -0.15389039f, 
    0.01501857f, -0.12336965f, 0.17833768f, -0.10023393f, 0.13800840f, 0.05105812f, 0.00619856f, 0.33973068f, 
    0.06577368f, 0.04669261f, -0.00899790f, 0.00906683f, -0.15811798f, -0.00402718f, -0.28187126f, -0.03097701f, 
    0.10995059f, 0.08464967f, 0.05323355f, -0.10471808f, -0.00235515f, 0.12014838f, 0.08685835f, 0.35365304f, 
    0.00922545f, -0.22593732f, 0.07554326f, -0.18158312f, -0.10493950f, 0.07572213f, -0.08361209f, -0.07701822f, 
    -0.14343493f, -0.18769225f, -0.06942906f, -0.15756720f, -0.14622316f, 0.10002158f, 0.03636995f, 0.35588419f, 
    -0.26064914f, -0.30722615f, 0.02094794f, -0.02752416f, 0.07025224f, 0.31472948f, 0.07957882f, -0.09269845f, 
    -0.08588519f, -0.09077702f, 0.18383880f, 0.05550857f, 0.11399137f, 0.03466277f, -0.06832468f, 0.19999748f, 
    -0.16123937f, 0.11521215f, -0.13501140f, 0.08546870f, 0.18489523f, 0.26042700f, -0.23192692f, -0.26348060f, 
    0.14105745f, -0.28465089f, -0.07606026f, -0.13187082f, -0.06536145f, 0.32534039f, 0.25350446f, 0.15242754f, 
    0.20578106f, 0.09182426f, -0.00398253f, -0.24946332f, 0.00630980f, -0.18121403f, 0.14825581f, 0.04296516f, 
    0.08233722f, -0.19904563f, 0.03577091f, -0.04840412f, 0.09961501f, -0.03636829f, 0.26311043f, -0.06527101f, 
    0.03913932f, -0.02903558f, 0.05413682f, 0.04179245f, -0.04720267f, -0.09403647f, 0.04757809f, -0.08265536f, 
    0.08020777f, 0.21632597f, 0.06268554f, -0.11226281f, 0.21594271f, -0.06028275f, 0.10721600f, -0.14409272f, 
    0.09847137f, 0.09087981f, 0.02040278f, -0.04441429f, -0.07118171f, 0.15334627f, -0.61255097f, 0.12588188f, 
    -0.19853435f, 0.19486348f, 0.07742927f, -0.04110584f, -0.15379654f, 0.18445669f, 0.37766251f, 0.04414185f, 
    0.30178404f, -0.15889874f, 0.22017367f, -0.11352665f, -0.00203934f, 0.54929107f, 0.00502846f, -0.10654802f, 
    -0.08473732f, -0.08427998f, 0.31598508f, -0.25398692f, 0.57452232f, 0.04489917f, 0.10921699f, 0.10249665f, 
    0.20080277f, 0.21027690f, 0.00055317f, 0.07396652f, 0.18223254f, -0.13310905f, -0.06825857f, 0.08740543f, 
    0.06246707f, 0.00593592f, 0.06598426f, 0.03554391f, -0.10862851f, 0.30900815f, 0.41508210f, 0.19430301f, 
    0.31060016f, -0.20564654f, 0.13983162f, 0.19708735f, -0.05065964f, -0.23900726f, 0.24656662f, 0.23664172f, 
    -0.10799900f, -0.02282291f, -0.16465667f, -0.05060332f, 0.11226840f, -0.15530095f, 0.20623878f, -0.27418596f, 
    0.05033169f, -0.06541368f, -0.05865377f, 0.08139562f, 0.02074122f, -0.29011139f, 0.03134932f, -0.04106702f, 
    -0.11260191f, -0.02015770f, 0.05607960f, 0.19331346f, -0.14783710f, -0.10984740f, -0.02097483f, 0.08715706f, 
    0.03297038f, -0.09919718f, 0.07887439f, 0.10576974f, -0.14134438f, 0.13727492f, 0.88414675f, 0.13124146f, 
    0.19546060f, 0.24404603f, 0.14559002f, 0.05058582f, -0.12516335f, -0.28261733f, 0.10548359f, 0.19387126f, 
    -0.36533999f, -0.19263189f, 0.26151264f, 0.09356986f, -0.28350121f, 0.31727332f, -0.01635827f, 0.05894662f, 
    -0.03605781f, 0.03334119f, -0.09021126f, 0.16064963f, 0.22414753f, 0.16766189f, 0.03769601f, 0.06551782f, 
    0.04617404f, 0.22222710f, -0.14543907f, -0.02386598f, 0.00217190f, 0.17399417f, 0.21153575f, 0.05343641f, 
    -0.13474680f, -0.33256602f, 0.03582780f, 0.07775362f, -0.00497749f, 0.23220804f, -0.04706208f, 0.13534385f, 
    -0.02198734f, -0.04502511f, 0.06725907f, 0.14129968f, -0.13257675f, 0.29883024f, 0.25094351f, -0.15629308f, 
    0.27801606f, -0.05401595f, 0.10101996f, -0.00868772f, 0.10351098f, 0.03375005f, -0.20525180f, -0.00193000f, 
    0.07764971f, 0.24389745f, -0.03881339f, 0.08374273f, -0.03400179f, -0.55183202f, 0.03771350f, -0.08288416f, 
    -0.04159607f, 0.15293162f, 0.06749288f, -0.01053063f, -0.61925042f, 0.11064930f, 0.00666834f, 0.16345055f, 
    -0.10176502f, -0.04448592f, 0.18359654f, -0.15121360f, -0.31419456f, 0.00991138f, 0.10720044f, -0.07456345f, 
    0.00126570f, 0.18138205f, -0.05088193f, -0.00478428f, 0.13772595f, -0.11481523f, -0.09091203f, -0.03912480f, 
    -0.04335621f, -0.36303324f, 0.05720793f, 0.04035775f, 0.25914845f, -0.20663938f, 0.13539931f, 0.04181604f, 
    -0.11395778f, -0.17172420f, 0.10544783f, -0.41937530f, 0.11774345f, -0.28713250f, 0.01208301f, 0.14449833f, 
    -0.24155910f, -0.59479082f, 0.02776607f, 0.16507898f, 0.20195994f, 0.15960717f, 0.15686265f, -0.01336464f, 
    -0.01155762f, 0.11872138f, 0.22204505f, 0.07807889f, -0.06507131f, -0.28769687f, 0.08692925f, 0.12609009f, 
    -0.10321525f, 0.15563300f, -0.03679230f, -0.06891744f, 0.05577354f, 0.16189210f, -0.21399160f, 0.10794669f, 
    0.03355732f, 0.24371079f, -0.22685504f, 0.39895090f, -0.18498540f, 0.24917261f, 0.28924942f, 0.11971127f, 
    0.03949282f, 0.00258988f, 0.20644017f, -0.13609327f, -0.19914493f, -0.24056497f, 0.16201730f, -0.07752151f, 
    -0.04358234f, 0.06240320f, 0.11665727f, 0.01138047f, 0.14683139f, -0.19879889f, 0.09026602f, -0.00379098f, 
    0.35034046f, -0.07194076f, -0.13915861f, 0.13400914f, 0.01448773f, 0.35412073f, 0.08490618f, -0.03728373f, 
    -0.19977735f, 0.24285384f, 0.23365998f, 0.10135422f, 0.16077246f, 0.12599722f, -0.12396661f, -0.02952409f, 
    0.18241625f, 0.10077202f, -0.25626522f, 0.23457772f, -0.17070977f, -0.01119613f, -0.17230186f, -0.13054892f, 
    0.02413688f, 0.23841280f, -0.07969720f, 0.05156664f, 0.07505437f, 0.06447317f, -0.15490909f, -0.05295273f, 
    -0.05937715f, -0.11557761f, 0.02773052f, 0.04563482f, 0.00560446f, 0.08801202f, -0.11301589f, -0.05735480f, 
    -0.08584536f, 0.02803543f, -0.12133292f, -0.13048334f, -0.00202556f, 0.28132552f, 0.08563221f, 0.14574280f, 
    0.20872711f, -0.00678634f, 0.05794356f, 0.04844334f, -0.16607563f, -0.27772656f, -0.03682354f, 0.19293867f, 
    0.08722331f, 0.07263342f, 0.26660284f, -0.14388198f, 0.17318954f, -0.02784575f, -0.00905876f, 0.23046760f, 
    -0.16227615f, -0.43470669f, 0.24181867f, 0.24244341f, -0.24344604f, 0.48968354f, 0.15791655f, 0.15982686f, 
    0.08955160f, 0.19558457f, -0.15753207f, -0.08878813f, 0.11626749f, 0.12280431f, 0.24517532f, -0.07350278f, 
    -0.14348164f, 0.57343012f, 0.06575841f, -0.30056426f, -0.00110592f, -0.47506946f, -0.14186662f, -0.10078322f, 
    -0.20733704f, 0.07039081f, -0.12258061f, -0.04122068f, -0.07346726f, 0.01226062f, -0.02267201f, -0.09462848f, 
    0.07818945f, -0.01424241f, 0.15852796f, 0.03741877f, -0.18108931f, 0.09239224f, 0.39754871f, -0.20728287f, 
    0.08800439f, -0.24144076f, 0.10665299f, 0.07545051f, -0.07074567f, 0.12512565f, -0.19748232f, 0.03300487f, 
    -0.11380392f, -0.10136902f, 0.10533616f, 0.00443501f, 0.53106648f, -0.05567363f, 0.03089512f, -0.04480593f, 
    -0.00263678f, -0.22386700f, 0.06717023f, 0.04884022f, 0.02784964f, 0.02472408f, 0.19655481f, 0.16845970f, 
    -0.49088293f, -0.00906058f, 0.08526621f, 0.16695203f, 0.09113050f, -0.20768818f, -0.08709549f, 0.11840643f, 
    0.42398229f, -0.36386669f, -0.02920191f, -0.04349946f, 0.21009731f, -0.16161439f, 0.00486255f, -0.30875328f, 
    0.08464319f, -0.21702239f, 0.12128817f, 0.07218365f, 0.20420013f, 0.38121265f, 0.17125213f, 0.38072616f, 
    0.15201052f, -0.18985982f, 0.16917063f, -0.04536644f, -0.16112782f, 0.06639865f, 0.31160629f, -0.05332451f, 
    0.25820142f, 0.26200190f, 0.23695526f, 0.16300470f, 0.02816205f, -0.12060335f, 0.09029848f, -0.09882357f, 
    0.05839780f, 0.08833446f, 0.51481271f, -0.09798861f, -0.09017904f, -0.53307003f, 0.06593540f, -0.14218417f, 
    -0.05510505f, 0.06950637f, 0.13894530f, -0.12200514f, 0.29388639f, 0.43836913f, 0.27898633f, 0.05424489f, 
    -0.06849974f, -0.25910875f, -0.04885994f, 0.36809501f, 0.02286068f, 0.22627605f, 0.57736975f, -0.25127047f, 
    -0.03572048f, -0.38414124f, -0.28404042f, -0.29841331f, -0.14433435f, -0.37445655f, 0.11777511f, 0.19993569f, 
    -0.53139478f, -0.07606973f, -0.44459993f, -0.21810846f, 0.13125248f, -0.19430915f, 0.23724522f, 0.13952444f, 
    -0.23186396f, -0.30104411f, 0.14506976f, 0.44463831f, 0.00741744f, 0.07958064f, 0.24952391f, -0.01393816f, 
    -0.23561341f, 0.23350148f, -0.01105928f, -0.05476740f, -0.09346876f, 0.00597650f, -0.08753673f, 0.17941807f, 
    0.02131224f, -0.10400586f, -0.30394745f, 0.36223334f, 0.07123023f, 0.22139907f, 0.04718065f, -0.11431537f, 
    0.00005364f, 0.34893808f, -0.02127975f, -0.27116153f, -0.16974318f, -0.11334004f, 0.23478277f, 0.07693127f, 
    -0.27346140f, -0.15048954f, 0.28684095f, -0.08414763f, 0.12879549f, -0.25004640f, -0.11533072f, 0.06731903f, 
    0.05113467f, -0.48760316f, 0.05635882f, 0.12759690f, -0.15195276f, -0.06869052f, -0.03060303f, 0.18687506f, 
    -0.14681987f, -0.13952458f, 0.08412194f, 0.01042794f, -0.01011168f, -0.28883839f, 0.14495815f, -0.13413861f, 
    -0.03123579f, -0.05286446f, 0.13037662f, -0.12541123f, -0.22800982f, -0.13401935f, -0.15389313f, 0.16422440f, 
    -0.12657401f, 0.21333617f, -0.09328239f, -0.46344504f, -0.28434944f, -0.21421415f, -0.33413216f, -0.04468708f, 
    -0.10860810f, 0.08606824f, 0.21423927f, 0.02183091f, -0.13280566f, 0.03775506f, -0.01567261f, -0.06240781f, 
    -0.26485515f, 0.01104530f, -0.14072311f, 0.22599232f, -0.04310825f, 0.03585987f, 0.03084214f, -0.22909445f, 
    -0.07588491f, -0.04413137f, -0.13358457f, -0.01531479f, -0.00644882f, 0.06124454f, 0.14734858f, 0.19586241f, 
    0.05046811f, 0.29622412f, 0.01659659f, 0.06944973f, -0.42380223f, 0.25264385f, 0.01621427f, -0.19986035f, 
    0.11584728f, 0.04522225f, 0.17411998f, -0.29516986f, -0.02272929f, 0.05400401f, -0.15144201f, 0.26826620f, 
    0.05294698f, 0.06348266f, -0.05366603f, -0.04642647f, -0.10058907f, 0.01303441f, -0.04420876f, -0.04822486f, 
    0.04300383f, 0.04306561f, -0.01155065f, -0.09645938f, -0.00235485f, -0.07638788f, -0.00784200f, -0.05534498f, 
    -0.09032494f, -0.10191583f, 0.05184259f, -0.08220199f, -0.11257388f, 0.01478920f, -0.04065825f, -0.08782674f, 
    0.02426305f, 0.01362779f, -0.05709702f, -0.04555186f, -0.07647762f, -0.01231572f, -0.00483731f, 0.02264807f, 
    -0.11982822f, -0.10717703f, 0.00713218f, -0.01056563f, -0.07122602f, -0.07856303f, -0.01848667f, 0.05663561f, 
    -0.02846615f, -0.07503452f, -0.11292044f, -0.05946857f, -0.05277883f, -0.03862408f, -0.02637104f, 0.03522254f, 
    -0.07579586f, 0.05240523f, -0.00555215f, -0.06810153f, -0.06810013f, -0.08685599f, -0.06490779f, -0.00465126f, 
    -0.06544914f, -0.08324607f, -0.04136527f, -0.04463880f, -0.04118765f, -0.01948252f, -0.04935158f, 0.03399687f, 
    -0.07948799f, -0.11143705f, -0.02700581f, -0.06812508f, -0.03652117f, 0.06900220f, -0.05109537f, 0.01175160f, 
    0.05103615f, 0.03223072f, 0.02958605f, -0.00620987f, -0.07112310f, -0.09906361f, 0.00537090f, -0.07393946f, 
    0.06598557f, 0.04352136f, 0.03664466f, 0.00637901f, -0.08420529f, -0.10315175f, -0.09252538f, -0.04149881f, 
    -0.00335426f, -0.11923765f, -0.02297213f, -0.03997243f, -0.09145731f, -0.04481266f, -0.05798499f, 0.05874005f, 
    0.01527567f, 0.01194627f, -0.07635593f, 0.05624130f, 0.02439638f, -0.07571509f, -0.04823424f, -0.03837415f, 
    -0.02669973f, -0.03271051f, 0.01974923f, -0.09578011f, 0.03291954f, -0.04802917f, 0.03888590f, -0.10707909f, 
    -0.11344347f, -0.11522335f, 0.02306214f, -0.05354681f, 0.03691514f, -0.02446970f, -0.01648017f, 0.01957878f, 
    0.03773787f, 0.02802961f, 0.04316972f, -0.03372230f, -0.02284230f, -0.07738122f, -0.06153716f, 0.00284323f, 
    -0.00303821f, -0.04599039f, -0.06680737f, -0.00450121f, 0.03147109f, 0.05641789f, -0.02904800f, -0.01706017f, 
    0.03317682f, -0.04367024f, -0.06865117f, 0.02418954f, -0.02062000f, -0.08303919f, -0.07722232f, -0.03473657f, 
    0.01764916f, 0.06737120f, -0.08278403f, -0.07224712f, -0.04295028f, 0.03983821f, 0.04816036f, 0.01185396f, 
    -0.02796611f, -0.06069407f, 0.00716778f, 0.03460016f, -0.00691751f, -0.00299001f, -0.08312898f, -0.02130611f, 
    -0.06774934f, 0.02535165f, -0.04315890f, -0.07864209f, 0.01327143f, 0.08370391f, -0.06594986f, -0.06301748f, 
    -0.03934909f, -0.00240988f, 0.06822272f, -0.02599536f, -0.02587485f, 0.06024546f, 0.08362124f, -0.07567361f, 
    0.06646857f, -0.08094262f, 0.03190492f, 0.05344525f, 0.07557402f, -0.02536126f, -0.06330110f, -0.02327132f, 
    -0.05478254f, -0.07375262f, -0.04917298f, -0.07785971f, -0.08245557f, 0.02403262f, 0.06778300f, 0.00969114f, 
    0.06449434f, 0.05026089f, -0.02467671f, -0.04559751f, 0.06097616f, 0.00757397f, -0.07997250f, -0.08854639f, 
    0.03071789f, 0.06026979f, 0.03303357f, -0.04687587f, 0.02652037f, 0.00540881f, -0.03589458f, -0.03419762f, 
    -0.01012637f, 0.00127120f, -0.00853323f, -0.04707953f, 0.02566117f, 0.00156301f, 0.00481308f, -0.06522696f, 
    -0.02418459f, -0.00422310f, 0.07168632f, -0.08024985f, -0.05943942f, 0.05574811f, 0.03871426f, -0.06549397f, 
    -0.03363264f, 0.02376064f, -0.06262273f, 0.03363150f, -0.02214814f, 0.00556899f, -0.08603425f, -0.03049482f, 
    -0.07609712f, -0.05328912f, -0.02865898f, -0.01158318f, -0.02638442f, 0.03605545f, 0.00893045f, -0.04218541f, 
    -0.06742571f, -0.06886702f, 0.00201999f, 0.05163443f, -0.06120760f, -0.03210832f, -0.08312871f, -0.03074045f, 
    0.06609454f, 0.03500592f, -0.06899344f, 0.07646607f, -0.06291939f, 0.02452317f, 0.07747868f, -0.06655008f, 
    0.20802490f, -0.20903111f, -0.07367475f, 0.13031662f, -0.13121486f, -0.13485757f, 0.16616353f, 0.29584748f, 
    -0.08653566f, 0.03114710f, -0.41596895f, -0.54812676f, 0.20362428f, -0.28287503f, 0.07338388f, -0.22305815f, 
    -0.05167518f, 0.35854313f, 0.09081582f, 0.08648133f, -0.00006584f, -0.24241854f, 0.01669535f, -0.05969093f, 
    -0.12799567f, 0.06055095f, 0.01140718f, -0.01417884f, -0.03181460f, 0.02905581f, -0.04290685f, -0.00245367f, 
    0.13093038f, -0.05480274f, -0.05088788f, 0.04830514f, -0.08616801f, 0.11142324f, -0.15547496f, 0.05724242f, 
    0.20207822f, 0.18034430f, 0.09914736f, 0.02365162f, 0.00454606f, 0.10708626f, -0.06274855f, -0.06155703f, 
    -0.20061032f, -0.08556345f, 0.23986201f, -0.05773119f, 0.07820469f, 0.19179270f, -0.23712280f, 0.02851684f, 
    -0.01678181f, -0.38664258f, 0.06413838f, 0.22926940f, 0.05007673f, -0.11160155f, -0.12596045f, 0.09156922f, 
    -0.13063356f, -0.00825475f, -0.17834067f, -0.01311520f, 0.00125565f, 0.07387859f, -0.03105097f, 0.13752764f, 
    0.10314617f, -0.17784627f, -0.27726907f, -0.10394160f, 0.05086300f, 0.25043324f, -0.22921592f, -0.10696993f, 
    -0.01387431f, 0.04886926f, 0.02585014f, -0.16050501f, -0.02543139f, 0.11863141f, 0.37322775f, 0.07135206f, 
    0.33770657f, -0.03666431f, 0.28785309f, 0.06045631f, -0.11387121f, 0.10700964f, -0.00361412f, 0.03332331f, 
    0.24054694f, 0.29786772f, -0.11613480f, 0.28536856f, -0.00462794f, -0.12510659f, 0.08776724f, -0.11904079f, 
    0.00018467f, 0.10231736f, 0.01315449f, 0.12915084f, -0.24710940f, -0.04272357f, -0.04011595f, 0.11943058f, 
    -0.11839493f, 0.03233912f, 0.12718177f, -0.11424035f, -0.47435990f, 0.34198275f, 0.07883658f, -0.06535979f, 
    0.08791910f, 0.09044541f, -0.05673712f, -0.16794035f, 0.25421569f, -0.22611009f, 0.27459505f, 0.08734481f, 
    0.03352173f, 0.03895810f, 0.02924389f, -0.07671039f, -0.09128208f, -0.06294815f, 0.04664316f, -0.02134953f, 
    -0.00603925f, -0.00443786f, 0.02205660f, -0.04844086f, -0.06254615f, -0.04171907f, 0.04515886f, -0.07586881f, 
    0.02835109f, 0.02256982f, 0.04335456f, 0.05726515f, -0.02757113f, -0.04472791f, -0.09028672f, -0.08682931f, 
    0.01857844f, -0.02912006f, -0.01705114f, -0.07985948f, 0.06881205f, 0.02665889f, -0.04226307f, 0.07139918f, 
    -0.04251207f, -0.05426034f, 0.03839227f, 0.04573638f, 0.08446876f, 0.00501011f, -0.01318450f, -0.03232282f, 
    0.00646672f, -0.08859405f, -0.05839373f, -0.02888726f, 0.00660272f, -0.01960281f, -0.00654988f, 0.04872793f, 
    -0.08071057f, -0.11898562f, 0.06239114f, -0.03196311f, 0.08395883f, 0.02670904f, -0.01371261f, -0.06801001f, 
    -0.03643543f, -0.09805416f, 0.00183825f, 0.06192894f, -0.13652866f, -0.06133431f, -0.11067608f, -0.02786493f, 
    -0.03097899f, -0.08086357f, 0.04719739f, 0.01322047f, -0.06042185f, 0.02251647f, 0.00437095f, -0.08782274f, 
    -0.08604047f, -0.09495051f, 0.06707013f, 0.00722588f, -0.12554708f, -0.04157834f, -0.01719290f, -0.11117907f, 
    0.01274542f, 0.06167689f, -0.09035995f, 0.00180304f, 0.01578294f, -0.06971782f, 0.03218142f, -0.09456639f, 
    0.03948328f, -0.02019839f, -0.02579407f, -0.02289119f, -0.12588426f, -0.02703843f, -0.09745885f, -0.07512999f, 
    0.07289574f, -0.00681426f, -0.05476407f, -0.04723210f, 0.06655846f, -0.01549819f, 0.02153900f, -0.05061481f, 
    0.01200631f, -0.08942978f, -0.02860755f, -0.06114271f, -0.03919913f, 0.03992108f, -0.02608190f, -0.10372315f, 
    0.01952264f, -0.01196132f, -0.00828972f, 0.03869203f, -0.08880513f, -0.08610670f, -0.00552372f, -0.00569593f, 
    0.04641999f, -0.06503140f, -0.13547340f, -0.05838399f, 0.02232953f, -0.08786406f, 0.03424791f, 0.01875102f, 
    -0.24163169f, -0.19168155f, -0.30525693f, -0.08702759f, 0.00400563f, 0.12373275f, -0.17323984f, 0.14198709f, 
    -0.00769401f, -0.01937352f, -0.11993484f, -0.12487540f, 0.11064650f, 0.02641866f, 0.08404810f, -0.00431530f, 
    0.09836933f, 0.12104224f, 0.32584304f, 0.07126956f, -0.04056239f, 0.02378661f, -0.01238802f, -0.06130321f, 
    -0.01059692f, 0.02790789f, 0.01561473f, -0.17831378f, 0.11115474f, 0.24953689f, -0.01439778f, -0.01516952f, 
    0.01965639f, 0.10439680f, -0.22374216f, 0.01362552f, -0.02840734f, 0.21486886f, -0.67568147f, 0.01063721f, 
    0.20247106f, -0.12575975f, 0.01447812f, -0.29212752f, -0.05310945f, -0.10390376f, -0.27524766f, 0.00435665f, 
    -0.17080553f, -0.08693298f, 0.24553242f, 0.03824875f, 0.37030414f, -0.30258456f, -0.11382765f, -0.01487420f, 
    0.05286715f, -0.23051822f, 0.04740705f, -0.12336116f, -0.29088742f, 0.06899282f, 0.15633725f, 0.01796976f, 
    -0.23213640f, -0.18486449f, 0.47314888f, 0.11929809f, -0.06693283f, -0.31153652f, -0.02710953f, -0.11401828f, 
    0.10961599f, -0.09583623f, -0.28838879f, -0.02391004f, -0.04230770f, 0.01344217f, 0.11520833f, -0.18713561f, 
    -0.22827049f, 0.22028135f, 0.09713246f, -0.30460191f, -0.06277683f, -0.10721934f, -0.01034924f, 0.33203512f, 
    -0.17733285f, 0.16872552f, 0.45428973f, 0.03603034f, -0.10349309f, 0.00275812f, 0.29959607f, 0.03208820f, 
    0.09221177f, -0.10672249f, -0.13640602f, 0.10477898f, -0.07663892f, 0.18014118f, 0.00388927f, 0.29046845f, 
    0.01123806f, -0.26895654f, 0.12224088f, 0.22287667f, 0.05437296f, 0.03819129f, 0.04463485f, 0.26548916f, 
    0.02734058f, 0.33359134f, 0.16050485f, -0.01679930f, -0.06747678f, 0.12707669f, 0.01794327f, 0.00150133f, 
    -0.01404291f, 0.06055673f, 0.05287120f, 0.12859406f, -0.05441759f, 0.07322563f, 0.19917262f, 0.16947716f, 
    0.08158705f, -0.05254574f, 0.14380111f, 0.02210629f, -0.52153987f, -0.21285377f, 0.12534122f, -0.38680026f, 
    0.19762871f, -0.04691727f, -0.09234875f, -0.21365857f, -0.11741339f, 0.07822362f, -0.52503961f, 0.02275283f, 
    -0.32867929f, -0.02335341f, -0.26741952f, -0.10691255f, -0.02915195f, 0.10888653f, -0.10994870f, 0.00019400f, 
    0.02905589f, -0.03042645f, 0.11541609f, -0.03457813f, 0.02496339f, -0.45588139f, -0.07525013f, -0.11698692f, 
    -0.40716341f, 0.13356344f, 0.14064965f, -0.34584835f, -0.10853913f, -0.04119724f, -0.59869021f, -0.13732563f, 
    0.32368329f, 0.05347788f, -0.21730067f, 0.31381348f, -0.43408772f, 0.65367132f, -0.10635784f, 0.28559113f, 
    0.19309200f, 0.28773528f, -0.30694044f, -0.15972412f, 0.44127297f, 0.06513862f, 0.16383876f, 0.06165402f, 
    0.07604052f, -0.00720389f, -0.06738838f, -0.15570821f, 0.04308869f, -0.05521264f, 0.09593069f, 0.00474189f, 
    -0.00314917f, 0.02436750f, 0.00308075f, 0.12041572f, 0.03560595f, 0.15937349f, -0.12325127f, 0.01869383f, 
    0.13329844f, 0.17799702f, 0.20898654f, -0.04031227f, 0.11240355f, 0.32216549f, 0.13592236f, -0.39871943f, 
    -0.11461980f, 0.11227950f, 0.01522801f, 0.14501190f, -0.12310170f, 0.31304166f, -0.18763480f, 0.13733733f, 
    0.22875667f, -0.02302660f, -0.55764574f, -0.00298336f, 0.08797261f, 0.09638045f, 0.38279188f, -0.06338167f, 
    0.28211880f, -0.11425236f, -0.19872759f, 0.08566242f, 0.03881223f, 0.28376105f, 0.02747133f, -0.14734404f, 
    0.05924628f, 0.02823111f, 0.25550902f, -0.31942600f, 0.15798482f, 0.02288496f, -0.24403469f, 0.10848332f, 
    0.01186813f, -0.14263618f, 0.09604196f, 0.11566172f, 0.09491149f, -0.13160704f, -0.23856607f, -0.12841073f, 
    -0.19280557f, 0.04220273f, -0.15658623f, -0.06786139f, 0.01182550f, -0.18325092f, 0.61473048f, 0.17590261f, 
    0.16724764f, -0.11566611f, 0.06819230f, 0.03119658f, -0.06149178f, 0.18105504f, 0.34953821f, 0.07974588f, 
    -0.06335962f, -0.00380714f, -0.16222399f, -0.03525005f, -0.04072208f, 0.01391443f, 0.31677565f, -0.15546729f, 
    -0.01642698f, 0.18292968f, -0.12547059f, 0.03004890f, -0.03703745f, -0.23137797f, -0.04319742f, 0.03194346f, 
    -0.02647253f, -0.01965827f, 0.03046013f, 0.17370594f, -0.14335980f, 0.07660357f, 0.08788013f, -0.04042992f, 
    0.15990403f, -0.18280828f, -0.22680721f, -0.01733547f, -0.06014484f, 0.13061328f, 0.44767252f, 0.09425365f, 
    0.05953562f, -0.08773897f, 0.17779264f, 0.06820949f, -0.03358230f, 0.12942097f, -0.12002637f, 0.18903422f, 
    -0.27671120f, -0.23251639f, 0.15618801f, -0.04335911f, 0.26079649f, 0.33445242f, -0.02338346f, -0.02943509f, 
    -0.07206295f, -0.12579960f, -0.04053726f, 0.10800530f, 0.12307712f, 0.10248452f, 0.08567800f, 0.30674273f, 
    -0.11167902f, 0.26392236f, -0.19003549f, 0.10855066f, 0.01728378f, -0.08440088f, -0.22113702f, -0.03123816f, 
    0.09054682f, -0.31297067f, 0.26950645f, 0.09017950f, 0.05798918f, 0.09170130f, -0.13499542f, 0.21004017f, 
    0.00101301f, -0.11657594f, 0.01770462f, 0.39036822f, 0.05430373f, 0.39970472f, 0.18092677f, -0.15184407f, 
    0.23993103f, -0.21439882f, -0.00813465f, 0.05864967f, 0.07915711f, 0.10403849f, -0.02400995f, -0.08332585f, 
    0.04355313f, 0.33431065f, 0.10668819f, -0.00223523f, 0.01718794f, -0.05282254f, -0.03295758f, -0.03725685f, 
    -0.06094310f, -0.16881061f, 0.38605082f, 0.01011694f, -0.21821702f, -0.19538264f, -0.00457103f, 0.11232822f, 
    -0.12270650f, 0.08636364f, 0.16327275f, -0.22290897f, -0.23024328f, 0.40438092f, 0.05073750f, 0.03034035f, 
    -0.07377207f, 0.15269478f, -0.11893341f, -0.10770834f, 0.16664678f, 0.01802748f, 0.30954951f, -0.00938668f, 
    -0.11345457f, -0.29896066f, -0.10114524f, 0.21969023f, -0.18593480f, 0.13646831f, 0.09956849f, 0.29866576f, 
    -0.20882140f, 0.05134435f, -0.20909353f, -0.67030787f, 0.18556392f, 0.01978660f, -0.00714120f, -0.25334632f, 
    -0.36549249f, -0.13228564f, 0.16683355f, -0.03869658f, 0.10472445f, 0.00385809f, 0.03436918f, 0.06788079f, 
    -0.27871397f, 0.17612749f, 0.02844404f, -0.01367418f, -0.10676185f, 0.07493982f, 0.07700548f, 0.11118630f, 
    0.05843978f, -0.02698419f, 0.33186132f, 0.08426842f, -0.10540362f, 0.14166093f, -0.31362510f, -0.26359880f, 
    0.01255828f, 0.18112901f, 0.13927816f, -0.20366262f, -0.50466907f, -0.33130988f, -0.06486641f, -0.17731449f, 
    -0.10730240f, -0.10854039f, 0.12080418f, 0.02354171f, -0.58564907f, -0.14255059f, -0.14555632f, -0.05967017f, 
    0.07872384f, -0.25840792f, 0.00540660f, 0.12629500f, 0.07962538f, -0.20366259f, -0.07128042f, -0.07804085f, 
    -0.16861741f, 0.03075652f, -0.16610582f, 0.02806644f, 0.08878205f, 0.06860007f, 0.23313677f, 0.21463124f, 
    0.08305686f, -0.13190807f, -0.07736379f, 0.05532241f, 0.14063935f, -0.09055111f, -0.11047655f, -0.32425371f, 
    0.02278564f, -0.04005709f, 0.10496770f, -0.50375617f, -0.20446149f, -0.04044234f, -0.11182576f, 0.17308685f, 
    0.13961592f, 0.02192326f, 0.42911166f, -0.04425070f, -0.09322288f, 0.08910177f, 0.20450254f, -0.08038668f, 
    0.36938655f, 0.21503501f, 0.18108793f, 0.28106952f, 0.01230046f, -0.16326830f, 0.11308735f, -0.32329568f, 
    0.04464063f, 0.31657836f, -0.04325401f, 0.16171438f, -0.23066321f, -0.03296552f, 0.08389627f, -0.14969954f, 
    -0.02161531f, -0.14249878f, 0.24189475f, 0.01725109f, -0.07251956f, -0.19480450f, 0.16011472f, -0.22007880f, 
    0.07556372f, 0.07468904f, 0.09093370f, 0.25623158f, 0.08659554f, 0.02963283f, -0.17105493f, -0.20898630f, 
    -0.04121875f, -0.06257629f, -0.01030763f, 0.00738303f, -0.08676948f, -0.02917057f, -0.01339549f, -0.07444670f, 
    -0.10564508f, 0.04734764f, -0.03154270f, -0.03907915f, -0.04517399f, -0.08308033f, -0.04755794f, -0.10104588f, 
    0.08644172f, -0.02019191f, -0.00456940f, -0.05837359f, -0.01311146f, -0.00471112f, 0.03285730f, -0.03805832f, 
    0.05907764f, -0.09312856f, -0.07059573f, -0.02327589f, 0.05678670f, -0.00387457f, -0.08784126f, 0.01270946f, 
    0.04514563f, -0.00932160f, 0.02217502f, 0.04374403f, 0.01972073f, -0.07075703f, -0.02243651f, 0.04582056f, 
    0.01944443f, -0.02687429f, -0.03536256f, -0.10907413f, -0.01779750f, 0.02640040f, -0.04920087f, -0.04268635f, 
    0.01140656f, 0.02513779f, -0.02557162f, -0.01269450f, -0.07183569f, -0.03303874f, -0.07181969f, -0.06183505f, 
    -0.05966352f, -0.07535783f, 0.02994681f, -0.09104593f, 0.05925799f, -0.08307759f, -0.03682406f, -0.09723167f, 
    0.02193495f, -0.04728615f, 0.05037443f, -0.01783134f, 0.03290728f, 0.02758802f, 0.02629561f, -0.09088401f, 
    -0.05523509f, 0.01217102f, -0.03372442f, 0.03753164f, -0.08456645f, 0.05065834f, 0.05919589f, -0.07318746f, 
    -0.03732843f, -0.03610904f, -0.10199112f, -0.00079856f, -0.04485185f, 0.00782727f, -0.06338042f, 0.03681616f, 
    0.01581817f, -0.05603186f, 0.00599832f, 0.01524915f, -0.09691660f, -0.06641465f, -0.06261721f, -0.01058986f, 
    -0.03531635f, -0.05786310f, -0.05830185f, 0.02296115f, -0.04398579f, -0.10869431f, -0.00369451f, -0.01766674f, 
    0.00379508f, 0.02134172f, -0.07054166f, -0.04518468f, 0.05999596f, 0.05297001f, -0.09949855f, -0.06751740f, 
    -0.03415225f, 0.05817884f, 0.03000848f, 0.02663159f, 0.00092138f, -0.00882223f, -0.05550023f, -0.07669012f, 
    -0.07337215f, -0.05858563f, -0.01839517f, -0.01904332f, -0.03931229f, -0.04852610f, -0.04609617f, 0.02177489f, 
    -0.18957521f, -0.16141750f, 0.00569989f, -0.10795546f, -0.03306732f, 0.15874527f, -0.00107283f, 0.04619324f, 
    -0.31888250f, -0.03631093f, 0.01444063f, -0.05887533f, 0.16712934f, 0.20968303f, 0.07641299f, 0.23319702f, 
    -0.05215253f, -0.29742205f, 0.15863548f, 0.21292813f, 0.06245316f, 0.34921077f, 0.14170171f, -0.03757375f, 
    -0.06780042f, 0.14350134f, 0.06382903f, -0.09545742f, -0.00104477f, 0.11587629f, -0.07370790f, 0.25078019f, 
    -0.00020693f, 0.15895221f, 0.07876955f, 0.25730765f, 0.26422927f, -0.03019370f, -0.42378876f, -0.07840578f, 
    -0.22444434f, -0.05886086f, 0.03023101f, -0.20260416f, -0.10186729f, -0.10561556f, 0.40668947f, 0.14765631f, 
    0.30231920f, 0.05684695f, -0.00484734f, -0.00711358f, -0.07726426f, -0.23735380f, 0.17902002f, 0.08238565f, 
    0.02508334f, -0.06362288f, 0.13193494f, 0.08718036f, 0.04564994f, -0.06896536f, 0.10224066f, 0.12123290f, 
    -0.00804375f, -0.10836240f, 0.07718448f, 0.07693696f, -0.06127403f, -0.05361409f, 0.10019901f, -0.07119822f, 
    -0.02360477f, 0.15154409f, 0.15481420f, -0.03815266f, 0.06849617f, -0.36998364f, 0.17687109f, -0.02305980f, 
    0.06689839f, -0.01482359f, -0.03628621f, 0.07912360f, -0.07094444f, 0.00796730f, -0.85213041f, 0.01185128f, 
    -0.24782228f, 0.21790700f, 0.12679523f, -0.03621083f, -0.06302503f, -0.00658222f, -0.02740020f, -0.02671816f, 
    -0.25132781f, -0.10816759f, 0.22895516f, -0.05604146f, 0.02265956f, 0.41643566f, 0.02134459f, -0.16083115f, 
    -0.05850762f, 0.03507762f, -0.05045053f, -0.07729967f, 0.38270345f, 0.08192682f, 0.28528550f, -0.06066466f, 
    0.21087623f, 0.15213691f, 0.10091464f, 0.20531847f, 0.13325304f, 0.10401968f, 0.11175932f, -0.04642914f, 
    0.27886873f, -0.14925836f, 0.11643792f, 0.11628491f, -0.16951224f, 0.27397817f, -0.14645113f, 0.01474066f, 
    0.21175303f, -0.12289109f, -0.22355787f, -0.04917913f, 0.01159920f, -0.33197626f, 0.00633311f, 0.05614493f, 
    0.07760940f, -0.03814451f, 0.01130546f, -0.15314549f, -0.02442532f, -0.10898669f, 0.17181951f, -0.01296206f, 
    0.02421290f, -0.04837455f, 0.05621241f, 0.13437103f, 0.00949985f, -0.06030088f, -0.05403947f, -0.03156942f, 
    0.11299471f, 0.15520129f, -0.04448114f, 0.03098043f, -0.04427351f, 0.04899670f, 0.03662763f, -0.07801200f, 
    -0.09734926f, 0.24079275f, -0.17214094f, -0.15962672f, -0.11840957f, 0.18552491f, -0.00109621f, 0.11819947f, 
    0.44595721f, 0.27692848f, 0.05144048f, 0.04423815f, 0.00594119f, 0.19462335f, -0.08101416f, -0.04865576f, 
    0.11705091f, 0.09989771f, 0.19904858f, -0.10581686f, 0.05004422f, -0.00395932f, 0.10785942f, -0.01761877f, 
    0.03359703f, -0.00998411f, 0.23676482f, 0.10910613f, -0.06926747f, 0.05283295f, 0.12357730f, -0.01043013f, 
    0.09228729f, -0.11421322f, 0.24096672f, -0.00632757f, 0.02289607f, 0.32007843f, 0.12489899f, 0.02607592f, 
    0.05467537f, 0.00347602f, 0.01087594f, -0.00685504f, -0.05004194f, 0.31770736f, -0.21069407f, 0.02236317f, 
    0.01424563f, 0.31463900f, -0.00855116f, 0.16416259f, -0.08238203f, 0.00127846f, -0.07579496f, 0.07076388f, 
    0.20016074f, 0.15847050f, -0.03916817f, -0.01236550f, -0.00554267f, 0.08930601f, -0.11572649f, -0.03409605f, 
    0.20440638f, -0.06682637f, -0.21396679f, 0.33010480f, -0.02780066f, -0.17005309f, 0.19110747f, 0.08824068f, 
    -0.07250191f, 0.04424229f, 0.06207560f, 0.05695469f, -0.18746205f, 0.33396554f, -0.12953109f, 0.21805316f, 
    0.16998276f, 0.19195518f, 0.03502816f, 0.10093447f, -0.27349386f, 0.01274226f, 0.00293511f, -0.02720801f, 
    0.04769699f, 0.14888853f, 0.31769449f, -0.33612540f, 0.15861169f, -0.26798543f, 0.00657062f, 0.19639623f, 
    0.16343944f, -0.34257582f, -0.12815250f, 0.21133971f, -0.10778653f, -0.05611444f, 0.12452347f, 0.22677165f, 
    -0.26352766f, 0.00032666f, -0.22397861f, -0.52219248f, 0.21960841f, 0.03453696f, -0.02351419f, -0.20671611f, 
    -0.16697150f, 0.29721418f, 0.13223937f, 0.17860560f, 0.16042143f, -0.30525929f, 0.04058766f, 0.07617638f, 
    -0.07845855f, 0.25985375f, 0.01806778f, 0.08293389f, -0.07822115f, -0.12315285f, -0.03790674f, -0.01024989f, 
    -0.00529157f, -0.14041105f, 0.13285211f, 0.06303219f, -0.06947267f, 0.09303624f, 0.09269974f, 0.13042091f, 
    0.07959633f, 0.22181307f, 0.05424388f, 0.09389893f, 0.00004654f, -0.07790504f, 0.21222261f, -0.24297237f, 
    -0.12297495f, -0.13579260f, 0.18681304f, 0.05051055f, -0.20736040f, 0.15717977f, -0.12477820f, 0.02354074f, 
    0.04823708f, -0.38780707f, 0.08713500f, 0.30207780f, 0.08659440f, -0.07208948f, -0.17673232f, 0.19731405f, 
    0.00257683f, -0.05995466f, -0.38148448f, -0.09607872f, -0.04382835f, 0.31476045f, 0.21747474f, 0.20489492f, 
    0.08510950f, -0.02799410f, -0.17416692f, -0.04777124f, 0.12012924f, 0.18830371f, -0.19287477f, -0.14654414f, 
    0.02070571f, -0.08863959f, 0.02227301f, -0.14459266f, 0.04276450f, 0.14210334f, -0.16182823f, 0.10494272f, 
    0.15939397f, -0.07512482f, 0.01049752f, -0.03318369f, -0.08641633f, -0.00155289f, -0.14726937f, -0.08095884f, 
    0.21828243f, 0.29214427f, 0.16929306f, 0.37741128f, 0.02987872f, -0.37831548f, 0.04170373f, -0.40902454f, 
    0.04093348f, 0.29569227f, -0.25207293f, 0.16223797f, -0.35462904f, -0.01177002f, 0.11394560f, 0.03768891f, 
    -0.08460083f, -0.13436058f, 0.10292415f, 0.08713398f, -0.31195498f, 0.07748959f, 0.17514555f, -0.22129437f, 
    0.14195460f, 0.14278485f, 0.05791366f, -0.09419595f, 0.17267539f, -0.26077509f, -0.18520208f, -0.09647898f, 
    0.13925724f, -0.04574644f, 0.17316499f, 0.21185823f, 0.10613985f, 0.03602691f, -0.07713405f, -0.20643710f, 
    0.16327426f, 0.03780663f, 0.04548613f, -0.19949730f, 0.06307126f, -0.08509035f, -0.16605315f, -0.10394470f, 
    0.05186149f, 0.00631426f, -0.00420589f, -0.48891070f, -0.24133582f, -0.28427738f, -0.05053468f, 0.00628876f, 
    0.22600508f, -0.65772617f, 0.18474071f, 0.03268782f, 0.32183161f, -0.05081327f, -0.05946884f, -0.25064605f, 
    0.00228905f, 0.18977132f, 0.00671883f, -0.26609582f, 0.17738411f, -0.10767493f, 0.01041057f, 0.24804431f, 
    0.44584155f, -0.47365782f, 0.17034468f, -0.29845989f, -0.22131360f, -0.20765243f, 0.02651293f, 0.39902043f, 
    0.15655668f, 0.26610577f, -0.37983644f, 0.19895816f, -0.52153295f, -0.04182930f, 0.03331953f, 0.02704878f, 
    -0.03963988f, 0.12563874f, -0.20370039f, -0.32285032f, -0.08482078f, -0.00891271f, 0.00521899f, -0.20102006f, 
    0.15297152f, 0.11960226f, 0.46536258f, 0.05005290f, -0.02771595f, -0.48495799f, -0.15408598f, 0.20450772f, 
    0.13514912f, -0.14163923f, 0.25167924f, 0.09734783f, -0.12044550f, 0.26295733f, -0.09562365f, 0.09272420f, 
    0.12657867f, -0.53570414f, -0.05168905f, -0.00865626f, 0.01278891f, -0.09052095f, -0.27069122f, -0.21604526f, 
    0.42614919f, 0.05285317f, 0.03914348f, -0.00421314f, 0.23114254f, -0.02894010f, 0.17244901f, -0.06664095f, 
    0.40641150f, 0.05346652f, -0.20656036f, -0.06780237f, 0.07606781f, -0.07958878f, 0.20737915f, 0.02297550f, 
    0.07500648f, -0.30216199f, 0.18067928f, 0.21287414f, -0.25036138f, 0.07133386f, -0.01736807f, 0.20273729f, 
    -0.02735626f, -0.11516543f, 0.16610722f, -0.37315869f, -0.05688614f, -0.17894603f, -0.31388789f, 0.08031268f, 
    -0.04840038f, 0.45115989f, -0.03588104f, -0.07258595f, -0.11045370f, -0.04276253f, -0.15214388f, -0.42521405f, 
    0.05195874f, -0.49095601f, 0.03733871f, -0.15411486f, 0.07559381f, -0.19641684f, -0.00830875f, 0.06980819f, 
    0.05193796f, -0.02036717f, 0.00189470f, 0.06967428f, -0.07722588f, -0.27728811f, 0.20281427f, 0.09481677f, 
    -0.06878080f, -0.55887544f, 0.04510094f, 0.28360367f, -0.10989643f, 0.05800910f, 0.09138650f, 0.09890431f, 
    -0.18021263f, 0.03331439f, 0.15037675f, -0.01573121f, 0.26724803f, 0.56884050f, 0.08976822f, 0.20522049f, 
    0.09415245f, 0.07626811f, -0.51005054f, 0.12348660f, 0.18407717f, 0.16189508f, 0.11439462f, 0.07080216f, 
    -0.02820768f, -0.00117617f, 0.07861615f, -0.42639267f, -0.27326983f, -0.37350675f, -0.13287061f, 0.14556439f, 
    -0.06174826f, -0.12047316f, 0.19314718f, -0.04761829f, 0.09548337f, -0.09229777f, 0.01871698f, -0.01278113f, 
    0.00656195f, 0.00279815f, -0.05716310f, -0.16260794f, -0.23709108f, 0.10750753f, 0.17159988f, -0.13730775f, 
    -0.05198224f, 0.23505390f, 0.29092687f, 0.28201616f, -0.01047488f, -0.25813690f, -0.04875740f, -0.10832877f, 
    0.11395410f, -0.13588853f, -0.26838306f, 0.15805383f, -0.16280125f, -0.08343790f, -0.12908758f, 0.15305811f, 
    -0.31680837f, 0.02897915f, 0.12725720f, -0.37572175f, -0.04653014f, -0.17626442f, 0.02929425f, -0.31031039f, 
    -0.00160325f, 0.30826464f, 0.28594416f, -0.05424638f, 0.15755941f, 0.05913804f, -0.10996987f, 0.04452452f, 
    -0.14802282f, -0.32828659f, -0.13949794f, -0.19615352f, 0.04075257f, -0.00242057f, -0.13661487f, 0.18078449f, 
    0.06156778f, -0.16873097f, 0.27530420f, 0.11015449f, 0.03714197f, 0.06845631f, 0.08781809f, 0.25075823f, 
    0.01803234f, 0.42958030f, 0.03974618f, -0.05934443f, -0.11010587f, 0.04098185f, -0.17416114f, 0.01596589f, 
    0.28481027f, 0.27219236f, 0.03723789f, 0.11777277f, -0.11686700f, 0.26469719f, -0.30012506f, 0.09900289f, 
    0.01534834f, 0.03613177f, 0.06135026f, -0.08790991f, -0.01296210f, 0.01301586f, 0.02276356f, 0.11673314f, 
    0.16327621f, 0.14796494f, -0.02128367f, -0.09759735f, 0.15576367f, -0.06123913f, -0.00781436f, -0.03767344f, 
    0.02052644f, -0.06887667f, 0.01110839f, 0.21084529f, -0.07201081f, -0.02071441f, 0.25394475f, -0.02889736f, 
    0.12532747f, -0.07505783f, -0.06106196f, 0.08095359f, 0.24896473f, 0.63949943f, -0.05666982f, 0.26088190f, 
    0.19713295f, 0.04792540f, -0.21695153f, 0.40034857f, 0.18274900f, -0.10198164f, 0.48585352f, 0.11017974f, 
    -0.13454929f, -0.02716884f, 0.18248852f, -0.10324009f, 0.03932774f, -0.40890002f, -0.05890813f, 0.14287233f, 
    -0.18785369f, 0.03861308f, 0.00548897f, -0.01510944f, 0.01017703f, 0.06656344f, -0.11549849f, 0.01523824f, 
    -0.04623748f, 0.02386186f, -0.14753099f, 0.19355834f, 0.02615865f, 0.13637942f, -0.12333272f, 0.36205518f, 
    -0.11669031f, 0.26822749f, 0.00633950f, 0.26625770f, 0.04265670f, -0.26389384f, -0.04273836f, -0.02006233f, 
    0.20965987f, -0.13850453f, -0.25204325f, 0.04118577f, -0.04864016f, -0.25719005f, -0.15529770f, 0.22043742f, 
    -0.08708823f, 0.06733704f, -0.04912045f, -0.11951921f, 0.03776600f, 0.14712958f, 0.08255878f, -0.16916832f, 
    0.00178552f, -0.07725097f, 0.24904808f, -0.11180486f, 0.07108448f, -0.10011645f, -0.04883057f, 0.02518690f, 
    -0.20442441f, 0.21315710f, 0.01629506f, -0.16301183f, -0.02984396f, 0.01154475f, 0.02127503f, 0.17956463f, 
    -0.00686144f, -0.19005764f, 0.26458067f, 0.15851761f, 0.03359132f, 0.00255576f, 0.19623515f, 0.02361850f, 
    0.06775919f, -0.08771130f, 0.16662398f, -0.06806255f, -0.16927341f, 0.70089012f, -0.15410015f, -0.01131429f, 
    0.19956927f, 0.17168413f, 0.02199836f, -0.07908101f, -0.12749361f, 0.03749390f, -0.30355352f, 0.11906945f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02926613f, 0.10029364f, 0.19634658f, 0.24980915f, -0.06372275f, -0.04455272f, -0.04167729f, -0.02381408f, 
    0.07808726f, 0.13022754f, -0.17083724f, 0.01996085f, 0.10527192f, -0.04553708f, 0.06552473f, -0.13256450f, 
    -0.08281220f, 0.23550110f, 0.20421259f, 0.00543200f, 0.22120047f, 0.05842046f, -0.00812357f, 0.17404446f, 
    0.24286731f, 0.15786107f, 0.00829027f, 0.09384418f, 0.04390367f, -0.24077529f, 0.08478069f, 0.09696263f, 
    0.17973475f, -0.00050511f, 0.18104033f, 0.10442654f, -0.04751055f, 0.11910604f, -0.22007641f, 0.03400087f, 
    0.13170785f, 0.36071625f, -0.10470531f, 0.02357181f, 0.14096691f, -0.03162619f, -0.10557499f, -0.11795988f, 
    0.27456507f, -0.11790795f, -0.03940545f, 0.19449703f, 0.12527426f, -0.08138835f, -0.01508663f, -0.06077202f, 
    -0.10646657f, 0.36751875f, 0.30802709f, -0.11300355f, 0.34607977f, 0.01228863f, -0.09966003f, 0.20000124f, 
    0.17959562f, -0.08454440f, 0.15195890f, -0.08299858f, 0.20386210f, -0.09111109f, 0.03167925f, 0.24923316f, 
    0.10037927f, 0.20148094f, -0.06709673f, -0.06110761f, -0.07700420f, 0.16711764f, 0.05437177f, 0.19954903f, 
    0.21307862f, 0.01510297f, 0.07795502f, -0.05482933f, -0.02430941f, 0.03975613f, -0.02661692f, 0.02214943f, 
    -0.07114966f, 0.01343343f, 0.07298408f, 0.01882509f, 0.12304430f, 0.26823294f, 0.18675587f, 0.25736102f, 
    0.14089842f, -0.04815540f, 0.15405107f, -0.07570869f, -0.04050913f, 0.04773968f, 0.17604202f, -0.08999552f, 
    -0.00073441f, 0.05415564f, -0.09544886f, 0.09255240f, 0.07256684f, 0.43508968f, -0.02548573f, 0.27704334f, 
    0.07760478f, -0.07888536f, 0.02476446f, 0.21952462f, -0.08362158f, -0.04733972f, -0.20144153f, 0.19724610f, 
    0.08192185f, -0.10780635f, 0.07750081f, -0.06437504f, 0.13224241f, 0.23240626f, 0.22443202f, 0.19731840f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.05072039f, 0.00800202f, -0.27525532f, -0.30701709f, -0.00083982f, -0.03666444f, -0.09184682f, 0.19468704f, 
    -0.00760804f, -0.20833121f, 0.10064294f, 0.11143611f, -0.29094592f, 0.03005044f, 0.03772626f, 0.22535639f, 
    0.18069126f, -0.28192851f, 0.09418914f, -0.02948156f, -0.07680138f, -0.06358182f, -0.17081831f, 0.01684131f, 
    0.15308328f, -0.25154471f, -0.06840523f, -0.10393106f, -0.06029563f, 0.09172478f, 0.15836686f, -0.14094181f, 
    0.26149023f, 0.05614135f, -0.51007056f, -0.06858145f, 0.04246329f, -0.20640822f, -0.06095260f, -0.32088658f, 
    -0.16834669f, -0.45488569f, 0.06886908f, 0.23757251f, 0.00967262f, 0.30509377f, -0.06253861f, 0.03849703f, 
    -0.11258810f, -0.03742496f, -0.07221745f, 0.12329245f, -0.04174676f, -0.05290600f, 0.03284919f, 0.13005131f, 
    -0.02659188f, -0.06446824f, -0.61943036f, 0.06330114f, -0.46742535f, -0.00683159f, -0.03147718f, -0.56740922f, 
    -0.23928772f, -0.03986553f, -0.17592829f, 0.05140031f, -0.36520106f, -0.02868777f, -0.01485467f, -0.31410259f, 
    0.13385774f, 0.08980698f, -0.07196487f, -0.03023370f, 0.05587271f, 0.01645532f, 0.04422351f, -0.40824878f, 
    -0.36933750f, -0.12362552f, 0.06821253f, -0.22095297f, -0.05721306f, 0.10120022f, -0.25562266f, 0.04775725f, 
    -0.19369349f, 0.13171095f, 0.18766300f, 0.10940914f, 0.09778218f, 0.38973925f, 0.04907059f, -0.01776859f, 
    -0.57952976f, -0.03332999f, -0.00793608f, -0.05585130f, 0.11632898f, 0.12974034f, -0.18316503f, -0.05858965f, 
    0.33344182f, 0.16860250f, 0.02678584f, 0.03255374f, 0.09466667f, -0.08304144f, 0.18595254f, -0.03401501f, 
    -0.08939847f, 0.06576177f, -0.02552700f, -0.34338725f, -0.06900023f, -0.20233728f, 0.29790571f, 0.02911705f, 
    -0.15745939f, -0.01231797f, 0.11230999f, 0.06722661f, -0.13120268f, -0.21003139f, -0.12238763f, -0.29040566f, 
    0.02507777f, 0.06812344f, -0.06782793f, 0.27487019f, -0.00829964f, -0.08908791f, -0.01975023f, -0.68332285f, 
    -0.11875001f, -0.09817388f, 0.13962995f, 0.18460116f, 0.21153840f, -0.31354871f, -0.07988675f, 0.32003757f, 
    0.24238239f, -0.10411977f, 0.29154444f, 0.00424301f, 0.17867005f, -0.11256039f, 0.05511283f, -0.00851079f, 
    0.06606601f, 0.05600533f, -0.05078882f, 0.23090176f, -0.03527152f, 0.02834929f, -0.01584332f, 0.13844989f, 
    0.29705253f, -0.02498574f, -0.69169033f, 0.15985547f, -0.05046817f, 0.16902551f, -0.07461834f, -0.12846328f, 
    0.04840800f, -0.11264309f, 0.07183027f, 0.18055671f, -0.58878958f, -0.73610228f, -0.08517360f, -0.06793647f, 
    0.14824158f, 0.01944221f, 0.03185650f, -0.06617623f, 0.06382828f, 0.05314465f, 0.20641983f, -0.04333691f, 
    -0.01048996f, -0.11135846f, -0.58569562f, 0.12316338f, 0.12854405f, -0.02161301f, 0.02130032f, -0.01385543f, 
    0.09506063f, -0.06259850f, 0.08405453f, 0.07415348f, 0.05523794f, -0.08463905f, -0.02482114f, 0.02990334f, 
    -0.08280369f, -0.04397780f, -0.05512784f, 0.07774412f, 0.04351999f, -0.30636775f, 0.10104899f, -0.19472131f, 
    0.05622355f, 0.08821515f, -0.03972447f, -0.39276201f, -0.09660822f, -0.14174114f, -0.23328172f, -0.01317413f, 
    0.00698550f, 0.07137751f, 0.17196006f, 0.03324520f, -0.17685682f, -0.32932970f, -0.09457665f, 0.07047507f, 
    0.08046792f, -0.11191078f, 0.04868161f, -0.02624615f, 0.04426081f, 0.01584335f, -0.25176504f, -0.02107156f, 
    -0.02013483f, 0.14714256f, -0.09684565f, -0.00239084f, -0.11471985f, 0.18090311f, 0.14714117f, -0.50026590f, 
    0.15321667f, 0.01523058f, 0.06444383f, -0.00303364f, -0.03636000f, -0.05188018f, -0.29521221f, -0.07325840f, 
    0.02061788f, -0.00480079f, -0.08718631f, 0.17658406f, 0.07435764f, 0.12478957f, 0.02573951f, -0.12479497f, 
    -0.01305562f, -0.00264435f, -0.04593653f, -0.15989006f, -0.03561863f, -0.32395631f, -0.04397628f, -0.88656515f, 
    -0.20211244f, -0.26195654f, -0.47985145f, -0.02248159f, 0.29049617f, -0.33736530f, -0.19812979f, -0.30677536f, 
    -0.30601570f, 0.00938815f, 0.14856775f, 0.22778228f, 0.23250055f, -0.15147486f, -0.36488104f, -0.00297530f, 
    -0.09446056f, 0.16958001f, -0.08176170f, -0.32721657f, -0.09321462f, -0.02711262f, 0.01594035f, 0.37113103f, 
    -0.44950947f, 0.02938167f, 0.15392822f, -0.12725449f, 0.06320653f, 0.38102800f, 0.19152704f, -0.00941218f, 
    -0.13462564f, 0.02019594f, 0.00952245f, -0.53881514f, 0.08980834f, -0.34898183f, 0.04319173f, 0.04266283f, 
    0.33145306f, 0.02691813f, -0.04827695f, 0.11179774f, -0.62149644f, -0.06821214f, -0.34575215f, -0.10973380f, 
    0.05766128f, 0.15876088f, 0.21099488f, 0.11792152f, 0.09672911f, -0.02096980f, -0.02568397f, -0.00707634f, 
    0.15071870f, 0.04876159f, -0.18526329f, 0.04998034f, 0.13739589f, -0.07289958f, 0.04960286f, -0.41456401f, 
    -0.24680327f, -0.25546011f, -0.11343379f, 0.07510995f, -0.07295854f, 0.01441842f, 0.26729378f, 0.12452988f, 
    0.16145338f, 0.03224126f, 0.04503083f, 0.06736352f, -0.04050412f, -0.20655848f, -0.16568154f, -0.07966771f, 
    0.02651165f, -0.17864284f, -0.30877194f, -0.01350017f, -0.69386214f, 0.22711089f, 0.03862012f, -0.14731020f, 
    -0.38045856f, 0.06339089f, -0.03450473f, 0.02052260f, -0.19407496f, 0.05011467f, 0.13811016f, -0.04489516f, 
    0.15165605f, -0.17458478f, -0.64437264f, 0.03190980f, -0.83078682f, 0.08747739f, -0.37298241f, -0.08171731f, 
    0.22070739f, 0.05603018f, -0.09499560f, 0.05224544f, 0.03492970f, -0.14623328f, -0.14455703f, 0.10437556f, 
    0.05652427f, -0.07874437f, 0.02495371f, -0.02103504f, 0.13467374f, -0.38406712f, 0.03382620f, 0.16084458f, 
    0.03189822f, 0.13654938f, -0.22076337f, -0.17553902f, -0.04779512f, -0.14838290f, 0.02555108f, 0.07232527f, 
    -0.01838041f, -0.08098445f, 0.00849556f, -0.05672243f, -0.01699215f, -0.24194902f, 0.06648282f, -0.07335594f, 
    0.08252474f, -0.09331539f, 0.15197840f, 0.23793440f, -0.07983595f, -0.00379199f, -0.16632092f, 0.12603448f, 
    0.08508480f, -0.20222351f, 0.04589944f, -0.42575690f, 0.07234289f, 0.01203121f, 0.12152403f, 0.09288646f, 
    -0.55096132f, -0.03418432f, 0.15842663f, -0.49126297f, -0.03309891f, -0.47522643f, -0.77120996f, 0.23363285f, 
    0.03014659f, -0.15009543f, -0.03556212f, -0.24409397f, 0.10537972f, -0.22366339f, -0.00205424f, -0.03157190f, 
    0.01278549f, -0.01138098f, -0.02008043f, -0.15394899f, -0.08103140f, 0.00433748f, -0.25550884f, 0.05725510f, 
    0.05870610f, 0.01772166f, 0.07033793f, -0.19197488f, -0.13568063f, -0.03870714f, 0.05470313f, -0.04196537f, 
    0.05760318f, -0.05505351f, -0.65081525f, 0.00795211f, -0.08647597f, 0.02780085f, 0.07606952f, -0.02261786f, 
    -0.05089002f, 0.04639033f, 0.04764959f, -0.03224662f, -0.01923728f, 0.04545742f, -0.16732106f, -0.09487963f, 
    0.08684143f, 0.37985954f, 0.10667275f, -0.17638011f, -0.20093980f, 0.05200268f, 0.13772824f, -0.00113604f, 
    -0.11025166f, -0.16451922f, -0.28553358f, 0.03480197f, 0.12892203f, 0.09665979f, 0.00801819f, -0.10146140f, 
    -0.05311586f, 0.01604593f, 0.11990755f, 0.01057457f, 0.03602526f, 0.06526300f, 0.06866571f, -0.02329393f, 
    0.11940755f, -0.04097394f, 0.01477028f, 0.08187575f, 0.12110702f, -0.06286380f, 0.05321677f, 0.09204739f, 
    0.09960694f, -0.05416573f, 0.02089306f, -0.04874995f, -0.00186290f, 0.13036555f, 0.28571761f, 0.00879482f, 
    -0.37757641f, 0.01508276f, 0.02315835f, 0.07152700f, -0.25573820f, -0.84093124f, 0.03268164f, -0.01843084f, 
    0.07101070f, 0.06033388f, -0.15867040f, -0.06822999f, -0.03060394f, 0.08947510f, 0.01261680f, 0.03206684f, 
    0.15887931f, 0.12139592f, 0.15678433f, -0.09103930f, -0.14692053f, 0.08990999f, 0.10028972f, 0.08410954f, 
    0.10983203f, 0.03218067f, -0.44188643f, -0.26348460f, -0.42540810f, 0.03678259f, -0.05597335f, 0.05058710f, 
    0.09571376f, 0.02443241f, -0.03272524f, -0.11747400f, -0.08068509f, 0.02860413f, -0.09111873f, 0.02297864f, 
    -0.20849860f, 0.03611132f, 0.03698489f, 0.18769398f, 0.04377237f, -0.20349826f, 0.04433298f, -0.17735520f, 
    -0.23896392f, -0.00649633f, 0.02541079f, -0.02195310f, 0.00222986f, 0.18322022f, -0.09534371f, 0.02009739f, 
    -0.46263149f, 0.03221944f, 0.01514735f, -0.34049284f, 0.01608161f, -0.03314669f, -0.20395578f, -0.01392343f, 
    0.05808635f, -0.40334225f, 0.07678276f, -0.04934488f, 0.07521123f, -0.07272236f, 0.02883989f, -0.12285126f, 
    -0.30474952f, 0.04904121f, 0.00989029f, 0.04405635f, -0.24154826f, 0.02899537f, 0.03998429f, -0.03007156f, 
    0.05412108f, -0.02686043f, -0.00118564f, 0.04612036f, -0.02836522f, 0.11933345f, -0.41275910f, 0.03335401f, 
    -0.15089488f, -0.05022337f, 0.15888801f, 0.07812326f, 0.04325304f, 0.07398637f, 0.08563434f, -0.00420003f, 
    -0.11615857f, 0.02784172f, 0.10085826f, 0.03035652f, 0.02509314f, -0.55830944f, 0.07031071f, 0.02355438f, 
    -0.19205144f, 0.04406770f, 0.10632095f, -0.04491445f, -0.02190841f, 0.03029485f, 0.17789531f, 0.05368079f, 
    -0.36851409f, -0.19408153f, 0.02194054f, 0.04445152f, 0.16866228f, -0.50407356f, 0.07111850f, -0.56598872f, 
    0.12421082f, -0.02357584f, 0.08133896f, -0.37274212f, 0.01593260f, 0.10743192f, -0.40477407f, -0.54065615f, 
    0.00431685f, 0.04432948f, 0.18335022f, 0.01501076f, -0.34817615f, 0.22418554f, 0.20747545f, 0.06748366f, 
    0.07710090f, -0.04288721f, 0.16422711f, -0.09139749f, 0.02274469f, 0.03461372f, -0.05457847f, -0.11482424f, 
    0.00950664f, 0.08399714f, -0.06504259f, -0.03166019f, 0.16212362f, 0.21360072f, 0.00490838f, -0.23868708f, 
    -0.16044441f, -0.00728144f, -0.13213569f, -0.35491440f, 0.08860651f, 0.15085602f, 0.10940437f, -0.03192180f, 
    0.02812112f, 0.13942078f, -0.09212148f, 0.01507521f, -0.00536746f, 0.11568088f, 0.01959712f, -0.01645064f, 
    -0.11279043f, -0.01639605f, -0.08155017f, -0.25822404f, -0.03148473f, 0.21843444f, 0.04324992f, -0.00729641f, 
    0.02785224f, -0.01547693f, -0.06038248f, 0.10605475f, -0.01684979f, -0.08811425f, 0.00767197f, -0.01989658f, 
    0.08405022f, 0.02336306f, -0.01316133f, -0.03664964f, 0.09698936f, 0.04769310f, 0.10149466f, 0.00363142f, 
    0.06585977f, 0.02092220f, -0.02741252f, -0.04227551f, -0.00793603f, -0.00348196f, -0.00434307f, -0.06275615f, 
    -0.09792130f, 0.00503180f, 0.32670134f, 0.01752996f, -0.00141429f, -0.01298266f, 0.03461908f, 0.03329294f, 
    0.16291782f, 0.15173745f, -0.08308400f, -0.07082493f, 0.07714318f, -0.06348323f, -0.02182219f, 0.04876574f, 
    -0.02937306f, -0.20292129f, -0.03973538f, -0.08294204f, -0.00494654f, 0.13455032f, -0.35154256f, -0.11441566f, 
    -0.00588589f, 0.10627005f, 0.09784914f, 0.02222399f, 0.00823304f, -0.71458268f, 0.09887157f, 0.17973554f, 
    0.11526187f, -0.06700613f, 0.06290051f, 0.07323140f, 0.06042976f, -0.00601749f, -0.16134080f, 0.02040559f, 
    -0.21266280f, 0.16049016f, -0.00860950f, -0.03168674f, -0.05033076f, -0.01734222f, 0.08053949f, 0.06427798f, 
    0.02850417f, 0.00796329f, -0.02718073f, -0.00695831f, -0.06599637f, -0.13675886f, -0.29737279f, -0.06890945f, 
    0.20705608f, 0.07680290f, -0.00777804f, 0.07156146f, 0.15967746f, 0.07823566f, -0.15498808f, -0.02308824f, 
    0.07507492f, -0.60130709f, -0.09271280f, -0.43849701f, 0.00383124f, -0.25422180f, -0.07776383f, -0.21845296f, 
    -0.66974664f, -0.43165016f, -0.50870109f, -0.11090317f, -0.75966787f, -0.10695258f, -0.56836587f, 0.19604838f, 
    -0.26088694f, 0.07662924f, -0.00281666f, -0.16869034f, 0.36804453f, 0.14487329f, -0.01664267f, -0.79495656f, 
    -0.36509883f, -0.41681972f, 0.07232068f, -0.00374286f, -0.00326202f, -0.00566759f, -0.00836644f, -0.37602171f, 
    -0.07048035f, 0.08350781f, 0.15170406f, 0.08079679f, -0.03184991f, -0.31275600f, -0.13837357f, 0.14227587f, 
    -0.10161430f, 0.01202589f, 0.00467478f, -0.02067743f, 0.18130201f, 0.02092743f, 0.01454426f, 0.01567431f, 
    0.31818986f, 0.00235489f, -0.03043726f, 0.12898524f, -0.72465897f, 0.03932581f, -0.14616887f, -0.11141130f, 
    0.00299058f, 0.21544862f, 0.28229424f, -0.12402400f, -0.05620870f, 0.01309693f, -0.08324543f, 0.08368944f, 
    0.20577183f, 0.07049766f, 0.25307664f, 0.01289071f, 0.34304076f, -0.05668958f, -0.08377106f, -0.15492044f, 
    0.03125563f, -1.08968759f, -0.09993451f, 0.05937098f, -0.03371363f, 0.12119296f, 0.50523931f, 0.17576194f, 
    0.45216930f, -0.17154841f, -0.36090037f, 0.19214015f, -0.03221128f, -0.27947292f, 0.05864996f, -0.06807239f, 
    -0.04931779f, 0.03539688f, -0.23320721f, -0.06240682f, -0.24388668f, 0.27950686f, -0.15178344f, -0.89878374f, 
    0.04775155f, 0.02376385f, -0.84491807f, -0.02359121f, -0.23512585f, 0.00142053f, 0.21577695f, -0.06389035f, 
    0.06192821f, -0.06026210f, -0.87617218f, -0.04358089f, -0.69783771f, 0.13606122f, -0.37462044f, 0.25414357f, 
    -0.84178525f, -0.08602706f, 0.06831049f, 0.13321078f, -0.03160233f, -0.41312772f, -0.61588156f, 0.23071131f, 
    -0.22563763f, 0.03488255f, -0.61487317f, -0.34068412f, -0.25747082f, -0.02711410f, -0.27158976f, 0.25476369f, 
    0.07226396f, -0.35989776f, -0.20729539f, -0.23526739f, -0.06870232f, 0.25432485f, -0.05537802f, 0.26309824f, 
    -0.51113969f, -0.33631572f, -0.47959343f, -0.01736198f, -0.56111449f, 0.27753872f, -0.39186716f, -0.23515171f, 
    -0.20771410f, -0.06095968f, -0.26142851f, 0.13160257f, -0.61616945f, -0.03192113f, 0.30576679f, -0.31754723f, 
    0.06041613f, -0.20729019f, -0.00691983f, 0.14281933f, 0.00223063f, 0.21486492f, 0.03710473f, -0.16806574f, 
    -0.11349387f, 0.03229247f, 0.06188325f, 0.04871332f, 0.08448046f, 0.05223282f, 0.10064807f, 0.27731222f, 
    0.08498580f, -0.42619166f, -0.01085832f, -0.15541942f, 0.09884880f, -0.05631417f, 0.04510273f, 0.07569219f, 
    -0.47824770f, -0.08821619f, -0.09810933f, -0.05743889f, 0.21766083f, 0.07811137f, 0.19918473f, 0.08802915f, 
    0.07268680f, -0.45030865f, -0.03274660f, 0.01669979f, -0.24916746f, 0.07411150f, -0.01109288f, -0.04417644f, 
    0.22965372f, -0.01173826f, 0.12576871f, -0.01008277f, -0.35742268f, 0.03392128f, 0.05305150f, 0.07845376f, 
    -0.00178251f, -0.11891975f, -0.01652987f, -0.06228466f, -0.00446622f, -0.17894128f, -0.05699048f, -0.04748965f, 
    -0.16985834f, 0.14480887f, -0.17048033f, 0.37848586f, -0.10126042f, 0.09055149f, 0.08019678f, 0.01704571f, 
    0.00644755f, -0.48136419f, -0.09033648f, 0.06085757f, 0.27661002f, 0.16987418f, -0.05120216f, -0.73068577f, 
    -0.02023617f, -0.06050352f, -0.80794889f, -0.00778865f, -0.47790170f, -0.00440911f, -0.23898521f, -0.04547630f, 
    0.13562833f, 0.25310740f, 0.30136395f, 0.10428757f, 0.32710937f, -0.23037535f, -0.50025010f, 0.01127638f, 
    -0.35601526f, 0.07564341f, 0.03100348f, -0.07417110f, -0.07194018f, 0.01892909f, 0.83722407f, -0.14983906f, 
    -0.31363145f, 0.01551294f, -0.63014364f, -0.15261084f, -0.01978408f, 0.08056554f, -0.15720655f, -0.32490006f, 
    -0.07627872f, -0.01329898f, 0.40187731f, 0.21907581f, 0.00996839f, -0.13176672f, -0.01226030f, -0.22798818f, 
    0.27989104f, -0.02639681f, -0.20241708f, 0.10779755f, 0.03970405f, -0.04788630f, -0.26184091f, -0.46782422f, 
    -0.53662497f, -0.34780353f, 0.37616187f, 0.22585608f, -0.13247813f, 0.16917765f, 0.28483987f, 0.11675966f, 
    -0.03298151f, 0.27412924f, 0.00305742f, -0.01581228f, 0.07217829f, -0.32880598f, -0.11884382f, -0.66706616f, 
    0.02816870f, -0.02040166f, -0.51449782f, 0.18978025f, -0.04143892f, -0.26592141f, -0.10715920f, 0.31751671f, 
    0.21169549f, 0.25411198f, -0.03849116f, -0.51362622f, -0.57714313f, -0.23164615f, 0.03875899f, -0.02302814f, 
    0.19412269f, 0.00412828f, 0.00066444f, 0.07301864f, 0.39998049f, 0.05413695f, 0.13042757f, -0.47554585f, 
    0.04634875f, -0.00394914f, -0.44142476f, 0.12196554f, 0.10165405f, 0.04373860f, 0.07409535f, 0.14393972f, 
    0.01914148f, -0.03259652f, -0.60964864f, 0.03496284f, -0.00660103f, -0.03326384f, -0.07062602f, 0.19274186f, 
    -0.46309048f, -0.18916720f, -0.06534807f, -0.01184186f, -0.05454835f, -0.21564944f, 0.01633360f, 0.08410735f, 
    -0.11711103f, 0.15447566f, -0.63838601f, 0.18826705f, 0.06770510f, -0.07616321f, -0.31886882f, 0.04792979f, 
    -0.01409649f, 0.01391390f, -0.46582055f, -0.09011231f, -0.36601618f, -0.05194411f, -0.37246045f, -0.07286793f, 
    -0.17546915f, -0.05116273f, -0.01428171f, -0.05123435f, -0.54767060f, -0.43482932f, 0.11812015f, 0.02874687f, 
    -0.17309949f, -0.01043431f, 0.32936710f, -0.35449779f, -0.14693688f, 0.20596841f, -0.04706930f, 0.22152498f, 
    -0.25234848f, -0.05035376f, -0.05282929f, 0.28738254f, -0.01217930f, -0.05394512f, -0.04201470f, 0.19013385f, 
    0.18225485f, -0.02881025f, -0.47489977f, 0.07088195f, 0.28510156f, -0.14455040f, -0.71418196f, -0.11745665f, 
    0.02765224f, -0.04884931f, 0.22301370f, -0.13255531f, 0.00803287f, 0.04227239f, -0.07466250f, -0.13607541f, 
    0.25275117f, 0.10329013f, -0.06328581f, -0.43797675f, -0.52165425f, -0.28606787f, -0.07312889f, -0.44600579f, 
    -0.43751237f, 0.27438083f, -0.12259986f, -0.45448893f, 0.02492940f, -0.03878623f, -0.51133621f, -0.08479376f, 
    0.00923636f, -0.42999527f, -0.03096838f, -0.20969909f, -0.03835519f, -0.68074077f, -0.26489717f, 0.02139527f, 
    -0.07066064f, -0.05382801f, 0.24917580f, 0.05665796f, -0.11780100f, -0.38188004f, -0.12310734f, 0.10393952f, 
    -0.04427161f, 0.12199584f, -0.00832847f, 0.09633046f, 0.15888546f, -0.16125546f, -0.04683019f, 0.04400956f, 
    -0.32736188f, 0.05640762f, -0.03309944f, 0.15141593f, -0.01321945f, -0.01951884f, -0.55669385f, -0.05963192f, 
    -0.07338855f, 0.22145337f, 0.22550337f, -0.31649098f, 0.06807824f, 0.04873631f, 0.06303465f, 0.12440252f, 
    -0.52864200f, 0.06810857f, 0.00097739f, 0.01429047f, -0.18226793f, -0.00322806f, 0.01079533f, 0.18240352f, 
    0.19946317f, 0.01895731f, -0.02950354f, -0.04863225f, 0.00453205f, 0.18982625f, -0.12487578f, 0.16529940f, 
    -0.34563994f, -0.33181560f, 0.22656393f, -0.53380877f, -0.09367829f, -0.05101214f, 0.11546261f, -0.02786613f, 
    0.05902209f, 0.09406433f, -0.09563960f, -0.13767910f, -0.16842523f, 0.19229056f, 0.21136500f, 0.05060613f, 
    0.12695605f, 0.03717340f, -0.03968138f, -0.05999980f, -0.68004912f, 0.11156923f, 0.20234728f, 0.00385157f, 
    -0.65866286f, -0.63433766f, -0.33107924f, 0.09423758f, -0.07326481f, 0.15856665f, 0.02407601f, -0.05070437f, 
    -0.15823737f, 0.04411200f, -0.06323734f, -0.21745378f, -0.06581119f, -0.22522663f, -0.73970002f, 0.09850998f, 
    -0.16498011f, 0.06764586f, 0.04138440f, -0.33405098f, -0.43053144f, -0.03524576f, 0.33046478f, 0.11243249f, 
    0.07268949f, 0.14658004f, -0.12444183f, 0.08517504f, 0.02058218f, 0.15291424f, -0.01709549f, -0.01096644f, 
    0.03622458f, 0.27671310f, -0.49661908f, 0.11484384f, 0.17613924f, 0.09504764f, 0.19719811f, -0.03635688f, 
    -0.19094305f, -0.22483720f, -0.19406380f, -0.22852674f, 0.03879848f, -0.43040740f, 0.08333030f, 0.16712029f, 
    0.01976817f, 0.14941195f, -0.05743057f, 0.11019053f, 0.04703212f, -0.32633698f, 0.20617403f, -0.50951910f, 
    -0.59161890f, -0.08666889f, -0.05993976f, -0.37591168f, 0.02518417f, 0.19086051f, -0.33665165f, -0.36501691f, 
    -0.37844563f, 0.23617028f, 0.07779320f, 0.09523933f, -0.38706404f, 0.11146002f, -0.07817232f, -0.05149223f, 
    -0.08051740f, -0.08080500f, -0.03141656f, -0.13671824f, 0.05837653f, -0.06450967f, 0.00571341f, -0.58931828f, 
    0.07325220f, -0.00645717f, -0.05418371f, -0.07816700f, 0.11440428f, 0.06626888f, 0.03947047f, 0.02515379f, 
    0.24469021f, 0.05885455f, 0.00521625f, 0.03768690f, 0.17888160f, -0.04166704f, 0.02488375f, -0.08232310f, 
    -0.34428343f, 0.01044084f, -0.06819825f, 0.04673865f, 0.03863741f, 0.05528153f, -0.17945425f, 0.00909408f, 
    0.15954591f, -0.31139109f, -0.42841813f, 0.02338438f, -0.04185287f, -0.55470425f, -0.24456574f, -0.10317313f, 
    0.04431614f, 0.10676344f, 0.16281269f, -0.75105131f, 0.26581645f, -0.26878121f, -0.36325565f, -0.01422283f, 
    -0.13881046f, 0.01062740f, 0.22188614f, 0.05255511f, 0.32568440f, -0.66343462f, -0.22345372f, 0.02070262f, 
    0.12752749f, -0.08005105f, -0.00432000f, -0.63314313f, 0.00117821f, -0.07018864f, -0.26780143f, 0.30157059f, 
    -0.09567113f, -0.08652154f, -0.04775373f, -0.15371715f, 0.04783355f, 0.04569250f, -0.35475847f, -0.21617238f, 
    0.17220329f, -0.01396185f, 0.14918558f, -0.08214055f, 0.00646556f, -0.43895024f, -0.36102626f, -0.26148355f, 
    -0.03859492f, -0.21686673f, -0.12060567f, 0.03015549f, -0.04277029f, 0.22626279f, 0.00452943f, -0.27714375f, 
    -0.29749855f, 0.26156396f, -0.24106273f, -0.19087785f, -0.14805402f, 0.40028262f, 0.03129255f, -0.18611921f, 
    -0.30282262f, 0.08877158f, -0.44093469f, -0.38978484f, -0.13855913f, 0.21364632f, 0.21201624f, -0.17941482f, 
    -0.42614272f, -0.15363161f, 0.02258164f, -0.40128967f, 0.04038436f, -0.21085028f, -0.68188035f, -0.08147863f, 
    0.35362971f, 0.01413819f, 0.09802109f, -0.01795632f, 0.06002438f, -0.07616458f, 0.25216991f, -0.23875888f, 
    0.16354063f, 0.01591608f, 0.00618374f, -0.67593294f, 0.11566962f, -0.52858484f, -0.04746153f, -0.03073084f, 
    -0.14640065f, -0.03095822f, -0.05590723f, 0.18649924f, 0.08746213f, 0.06766606f, 0.22201757f, -0.01941792f, 
    0.01831275f, -0.07106710f, -0.01435230f, -0.08197120f, 0.09597487f, -0.05291365f, -0.04438272f, 0.13107452f, 
    -0.02198656f, 0.03288503f, -0.20653971f, -0.09953135f, 0.11893158f, 0.02418837f, -0.05828117f, -0.00606601f, 
    -0.20232223f, -0.05891764f, 0.00207414f, -0.06764136f, 0.08070158f, -0.33815509f, -0.26973796f, 0.13424340f, 
    0.00212694f, -0.09311000f, 0.05546925f, 0.06073100f, -0.07741417f, -0.00779485f, 0.27699721f, -0.09537379f, 
    -0.00547824f, -0.66560000f, 0.35415179f, -0.31347492f, -0.14679654f, -0.04749546f, -0.30604962f, -0.05926995f, 
    0.30731490f, -0.03014381f, -0.10562665f, -0.01143664f, -0.85994762f, -0.29436642f, 0.14763066f, -0.02023371f, 
    0.39775231f, -0.18889561f, -0.11138482f, -0.15488255f, -0.17419060f, -0.12989384f, -0.28980967f, 0.14813124f, 
    -0.02754957f, -0.07482152f, 0.00689824f, 0.09667293f, -0.04165971f, 0.52589667f, -0.26371178f, -0.04312752f, 
    0.01721204f, -0.07005666f, -0.24132182f, 0.10760801f, -0.34460920f, -0.01520402f, 0.11699706f, 0.11666378f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.26383370f, 0.02340605f, 0.10037840f, 0.00971903f, 0.04146336f, 0.07677979f, -0.01686636f, -0.26087743f, 
    0.10326110f, 0.17445840f, 0.14475241f, -0.20108789f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
