#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.12013152f, 0.09450301f, -0.60584611f, -0.59380925f, -0.52717751f, 0.45738903f, 0.20888354f, 0.38680506f, 
    0.38077027f, 0.07979570f, -0.33185452f, -0.30640462f, -0.11866127f, -0.09573517f, -0.07866390f, -0.24686126f, 
    -0.07632651f, 0.04041678f, 0.29606873f, -0.22413085f, -0.11405038f, -0.15315114f, -0.25616843f, -0.24439335f, 
    0.35927826f, 0.60819632f, 0.75943094f, 0.75292242f, 0.57929701f, 0.23145783f, 0.18255387f, -0.07304535f, 
    -0.32571602f, -0.54788166f, -0.09374133f, 0.38064116f, 0.18749380f, -0.06036898f, 0.22053535f, -0.14551470f, 
    0.10278841f, -0.32234260f, -0.01726881f, 0.25159436f, -0.30291235f, 0.19340460f, 0.22615843f, 0.06599109f, 
    0.17520097f, 0.18598713f, 0.08899348f, 0.42422900f, 0.89007235f, -0.84172875f, -0.50967664f, 0.67199224f, 
    -0.52981538f, -0.51426470f, -0.00334676f, -0.17323978f, 0.30915880f, 0.55748308f, -0.01189355f, 0.13653283f, 
    -0.25592315f, -0.00740843f, 0.15122302f, -0.21285734f, -0.08396566f, -0.24897291f, 0.12417930f, -0.00490663f, 
    -0.10042511f, 0.11809179f, 0.27922788f, 0.66025913f, 0.61933982f, 0.32082120f, 0.61003309f, -0.14308099f, 
    0.45338374f, 0.27555269f, 0.23574941f, 0.17446306f, -0.02259695f, -0.41094509f, -0.04539487f, -0.27169067f, 
    -0.17720255f, 0.00642015f, -0.21533765f, 0.15570083f, -0.15051848f, -0.18526225f, -0.11704615f, -0.26629773f, 
    -0.13917422f, -0.39416727f, -0.15772466f, -0.19536917f, -0.58999348f, -0.46587735f, -0.06033698f, 0.09434339f, 
    -0.17706046f, -0.60176772f, -0.45678502f, -0.38713419f, -0.16267025f, -0.09160454f, -0.47255957f, 0.41018319f, 
    0.09573041f, 0.14030902f, -0.37664875f, 0.30978009f, -0.07541581f, 0.21579051f, -0.44646409f, -0.19444717f, 
    0.15531369f, 0.10876081f, 0.02261702f, 0.20137544f, -0.05136626f, -0.34275070f, -0.63290143f, -0.41656739f, 
    -0.20299561f, 0.47279438f, 0.24456303f, -0.14913428f, 0.40506744f, 0.47752011f, -0.59896284f, -0.20086168f, 
    -0.11702166f, -0.08333760f, -0.14721505f, -0.22046500f, 0.37315148f, 0.12297548f, 0.40307590f, -0.11880834f, 
    -0.16706695f, 0.02426343f, -0.21569550f, -0.16060019f, 0.24914479f, 0.02427357f, -0.05823111f, -0.40970349f, 
    0.37327251f, -0.30831710f, -0.64420217f, 0.38470265f, -0.41429922f, -0.38836458f, 0.00892162f, 0.32958999f, 
    0.46712381f, 0.30896130f, -0.21330591f, 0.09665192f, -0.23205638f, -0.16670930f, 0.15809122f, 0.07745687f, 
    -0.04369224f, 0.34625533f, 0.10272715f, 0.35367432f, 0.36105651f, 0.38619670f, -0.27678332f, -1.02781773f, 
    0.04806075f, -0.34277973f, -0.24811310f, -0.34508568f, 0.46892792f, 1.07731402f, -0.08040442f, 0.08915297f, 
    0.62579674f, -0.01113057f, -0.01845200f, 0.18238339f, -0.43527076f, 0.27233565f, 0.15755165f, 0.24737254f, 
    0.02343520f, 0.19184744f, -0.09807316f, 0.01855381f, -0.00265694f, 0.13565150f, 0.05440026f, 0.10607933f, 
    1.08574855f, 0.61767167f, -0.09108633f, 0.88552779f, 0.91760033f, 0.23274133f, 0.12750724f, -0.36629984f, 
    0.57147753f, -0.22622660f, 0.07642943f, 0.03481604f, -0.12569667f, 0.18338962f, -0.42229569f, -0.12188590f, 
    -0.26893044f, -0.00052992f, -0.04725219f, -0.25211564f, 0.17789616f, 0.05646471f, 0.21058391f, -0.01051605f, 
    0.10865392f, -0.73721373f, -0.63302994f, 0.48133287f, 0.39839637f, 0.33083662f, 0.87531710f, 0.56759834f, 
    -0.31332219f, 0.31352618f, -0.51130664f, 0.13082208f, 0.25357205f, 0.16911280f, 0.42443672f, 0.31665847f, 
    0.17910770f, -0.17443751f, 0.09527531f, -0.28423890f, 0.16146369f, -0.04360975f, 0.19527209f, -0.00768614f, 
    -0.07441870f, 0.11610396f, -0.17412260f, -0.21462263f, 0.22567375f, -0.48335379f, -0.01132007f, -0.52289253f, 
    -0.43284294f, 0.00665541f, -0.10567794f, -0.21200788f, -0.47598711f, -0.22297925f, -0.38476521f, -0.39374447f, 
    -0.49595380f, -0.03454064f, 0.00277435f, -0.13177899f, 0.03497752f, -0.44819352f, -0.18449038f, 0.15191460f, 
    0.08085248f, 0.33542639f, -0.42248827f, -0.45837590f, 0.18971302f, -0.07994994f, -0.56958735f, -0.48262736f, 
    0.46163642f, -0.22856472f, -0.30442020f, 0.08074275f, 0.27456638f, 0.49232593f, -0.46374634f, -0.24082932f, 
    -0.20666543f, -0.43906632f, 0.20698418f, -0.02707337f, 0.48715171f, -0.23283176f, 0.02203512f, -0.14379446f, 
    -0.20462175f, -0.12966157f, -0.04571883f, 0.03926950f, -0.46161443f, -0.66766649f, -0.28032675f, -0.12040547f, 
    -0.03610748f, 0.25167653f, 0.30204672f, 0.32750931f, -0.45576465f, -0.17117195f, -0.48137787f, 0.23358490f, 
    0.13688233f, 0.11589646f, 0.02701140f, -0.69490719f, -0.00460055f, -0.19455817f, -0.19333266f, -0.12559941f, 
    -0.08702368f, 0.11461259f, 0.28664705f, 0.25040033f, 0.07570837f, 0.53544128f, 0.57447493f, -0.51756978f, 
    -0.63782942f, -0.29470843f, -0.23968406f, -0.57650667f, 0.29000965f, -0.22066905f, -0.34713763f, 0.04939384f, 
    0.22127017f, 0.04705298f, 0.20421380f, 0.11726924f, 0.18653949f, -0.14296065f, -0.18430740f, 0.17137839f, 
    0.37874573f, 0.49583861f, -0.15835987f, -0.03598796f, -0.36605135f, -0.03185963f, -0.07448290f, -0.90886116f, 
    -0.02839148f, 0.65823662f, -0.25124475f, -0.67108780f, 0.00878410f, 0.37994027f, -0.27556875f, -0.06299841f, 
    0.21801811f, 0.24276175f, -0.30855855f, 0.18049759f, -0.01309230f, 0.13719796f, -0.19426262f, -0.29067588f, 
    -0.02630181f, -0.12729421f, 0.05471107f, 0.04064394f, 0.31139055f, 0.48852527f, -0.12319143f, -0.59192187f, 
    -0.78841674f, -0.47210392f, -0.22580062f, -0.12127646f, -0.86614841f, 0.05105874f, 0.07960803f, -0.27467149f, 
    0.08270154f, 0.44740713f, 0.23228946f, 0.21791896f, -0.12110469f, 0.24298333f, -0.19354391f, 0.19557938f, 
    0.29395795f, 0.03118709f, 0.03714524f, 0.21172094f, -0.14684018f, -0.20938140f, 0.09104053f, 0.14674312f, 
    0.70127136f, 0.34448761f, 0.31878963f, 0.42241320f, 0.24308968f, -0.92340744f, -0.97089845f, 0.11494146f, 
    -0.36682093f, 0.61007410f, 0.37880147f, 0.08910758f, -0.16137798f, 0.18474066f, -0.28741497f, 0.08752478f, 
    0.17595015f, -0.04513505f, 0.19446914f, 0.02517000f, 0.11028217f, 0.15163405f, -0.06628166f, -0.04762808f, 
    -0.05311742f, 0.86729950f, -0.04783928f, 0.46827635f, 0.38352999f, 0.49897769f, 0.50011146f, 0.21103694f, 
    -0.27540544f, 0.12756318f, 0.29659811f, -0.25831220f, 0.40793625f, 0.10421690f, 0.34327787f, -0.28479895f, 
    -0.12281743f, 0.28551418f, 0.11772675f, 0.00049176f, -0.14250234f, -0.08132101f, -0.00811766f, 0.07014117f, 
    0.04979279f, 0.15671802f, 0.31520936f, 0.20013632f, -0.66033763f, -0.47404709f, -0.60194325f, -0.14336628f, 
    0.08699855f, -0.25770524f, 0.18466155f, 0.45434254f, 0.19373773f, -0.10431828f, -0.56088871f, -0.03098475f, 
    0.18885490f, 0.00633188f, 0.01999327f, -0.10618704f, 0.04435715f, 0.46227023f, -0.19226114f, 0.39788258f, 
    -0.09407817f, 0.13898918f, -0.37397116f, -0.16904658f, -0.35875016f, -0.23703231f, -0.44443148f, 0.38235420f, 
    -0.20218417f, -0.83906108f, -0.40529123f, -0.42911735f, -0.65227664f, 0.02873790f, 0.14647385f, 0.33200070f, 
    0.24073549f, -0.23880023f, -0.07304100f, 0.03807124f, -0.41042995f, -0.03364184f, 0.58377647f, -0.17363326f, 
    0.28150484f, 0.01018542f, 0.27712137f, -0.23491549f, 0.44320914f, -0.45082572f, -0.71847755f, -0.41508865f, 
    0.12966423f, 0.09477707f, 0.69550472f, 0.56350183f, 0.73358762f, 0.38448817f, -0.02849894f, 0.09713210f, 
    -0.21235059f, -0.19565763f, 0.10896816f, 0.09164616f, -0.01447764f, -0.17363924f, 0.00230315f, -0.08435956f, 
    -0.06179390f, -0.19317155f, 0.22420153f, 0.00595526f, 0.10495372f, -0.87303686f, 0.69170123f, -0.33466306f, 
    -0.51116091f, -0.04363681f, 0.82272953f, -0.42457747f, -0.61355889f, 0.24478760f, -0.07417823f, 0.25168884f, 
    -0.30820483f, 0.10534690f, 0.36515450f, -0.11754319f, -0.31710106f, -0.04829803f, -0.09251165f, -0.32158345f, 
    -0.41785797f, -0.10523190f, 0.20129174f, -0.09259383f, -0.00265487f, -0.23550375f, 0.94064236f, -0.12168880f, 
    -0.22291046f, 0.69304460f, 0.77868348f, 0.48589298f, -0.35759735f, -0.44633177f, -0.54003263f, -0.11358105f, 
    -0.12380666f, 0.15671369f, 0.15895447f, -0.09721207f, -0.03266184f, 0.06287443f, -0.03789052f, 0.30942684f, 
    0.17665982f, 0.05325102f, -0.07204554f, 0.22678228f, -0.02970291f, -0.19053844f, 0.06900904f, 0.56994778f, 
    0.70394355f, 0.03038831f, 0.56486487f, 0.41314635f, -0.09746572f, 0.20497556f, 0.28478634f, 0.08841629f, 
    0.17692465f, -0.37181196f, -0.04020102f, 0.21930754f, -0.00420328f, 0.26771247f, 0.06893723f, 0.13710122f, 
    0.05227244f, -0.18852381f, 0.35434687f, 0.42415017f, 0.10293080f, 0.35919577f, 0.20377150f, 0.14206950f, 
    -0.12777765f, -0.62384909f, 0.43509039f, 0.22487465f, 0.65039092f, -0.67147249f, -0.15113188f, 0.34466171f, 
    -0.29075617f, -0.12121972f, 0.37264830f, 0.25816542f, -0.12463693f, 0.13197997f, -0.02046914f, -0.52634519f, 
    0.35955256f, 0.25779694f, -0.02234651f, -0.24968125f, -0.09847634f, 0.13470265f, -0.18895231f, -0.19418806f, 
    -0.12911114f, 0.82722080f, -0.00852026f, 0.27686760f, 0.79950982f, 0.59319091f, -0.09759071f, -0.15749945f, 
    0.30619892f, 0.40485194f, -0.07274028f, -0.47996181f, -0.37596521f, -0.38877699f, -0.09546100f, 0.28761062f, 
    0.16588576f, 0.16485699f, 0.22055806f, 0.30180332f, 0.29420117f, 0.21042123f, -0.21036720f, 0.02461195f, 
    -0.18033034f, 0.01842030f, -0.40400702f, -0.51250321f, -0.23219004f, -0.04197699f, -0.48853701f, 0.65112138f, 
    -0.09361548f, -0.33763438f, 0.18305200f, -0.06644882f, -0.12557684f, -0.56382161f, 0.23369125f, -0.20002511f, 
    -0.00492311f, -0.48039362f, -0.03375851f, -0.13758424f, -0.13958357f, 0.05675615f, -0.23306665f, 0.30064842f, 
    0.25220123f, 0.23228063f, -0.04266274f, -0.67728782f, 0.41496113f, 0.64393163f, 0.51649785f, 0.60449731f, 
    0.68269426f, -0.09572524f, 0.14582810f, 0.18068215f, 0.00854555f, -0.45618847f, -0.51707244f, -0.13769905f, 
    0.21918096f, -0.13129139f, -0.08334693f, -0.15493172f, -0.30233863f, 0.01461513f, -0.28494906f, -0.08832937f, 
    -0.14140587f, -0.14437494f, 0.10845322f, 0.02158356f, -0.61182392f, 0.86645931f, 0.80848616f, -0.08264973f, 
    -0.51403618f, -0.33447033f, 0.30619243f, 0.07182959f, 0.19635984f, -0.31760198f, 0.00534259f, 0.12083206f, 
    -0.11423670f, -0.25070792f, 0.33581454f, -0.00153720f, 0.13480853f, 0.25884891f, 0.23045385f, -0.02740105f, 
    0.03913865f, 0.01892650f, -0.06107044f, 0.04038767f, 0.09074734f, 0.56716979f, 0.32463777f, 0.19620547f, 
    -0.25659522f, 0.05592083f, -0.06787882f, -0.17721455f, -0.58314621f, 0.20392941f, -0.33680770f, 0.26901901f, 
    0.04729085f, 0.00754545f, 0.09244437f, 0.04752767f, 0.18591997f, 0.23456484f, -0.35428181f, 0.08897949f, 
    0.32271498f, -0.43070394f, 0.09903958f, 0.22327547f, -0.07217205f, 0.60402369f, -0.24683048f, -0.68631810f, 
    -0.60734808f, -0.42073646f, -0.34281722f, 0.32683438f, -0.47488895f, 0.41723531f, 0.55811918f, 0.40701416f, 
    -0.15500091f, -0.14334841f, 0.03196802f, 0.27842414f, -0.33080718f, 0.06816338f, 0.03785062f, -0.04725238f, 
    -0.09105508f, 0.02743821f, -0.09639829f, -0.04792060f, -0.11333436f, -0.04324849f, -0.19359219f, 0.63842601f, 
    -0.27905744f, 0.81654197f, 0.38236570f, -0.12783486f, 0.32702306f, -0.95912403f, 0.14866693f, 0.34610286f, 
    0.14983186f, 0.23621565f, -0.40844145f, -0.44652116f, -0.10988231f, -0.10471231f, -0.00708451f, -0.18439326f, 
    -0.13128276f, -0.22012167f, 0.00463682f, 0.44485247f, 0.05847666f, 0.06486633f, -0.04289846f, 0.07074689f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02851618f, 0.19091606f, 0.14206167f, 0.04293474f, 0.17317167f, 0.20986058f, 0.18107827f, 0.10479138f, 
    0.20215477f, 0.26935351f, -0.08216380f, 0.01821688f, 0.23931055f, 0.34289351f, 0.02509439f, 0.06668712f, 
    0.30023563f, 0.16260317f, 0.26396009f, 0.05876649f, 0.05026850f, 0.05437252f, 0.11877183f, 0.00430745f, 
    -0.06750776f, 0.14708540f, 0.05952046f, -0.05940969f, 0.03350450f, 0.08996096f, 0.03073421f, 0.15736172f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02907651f, 0.00628968f, -0.05357081f, -0.03555558f, -0.02232123f, -0.05018252f, -0.04995834f, -0.00668906f, 
    0.03995108f, 0.04803627f, -0.02430984f, 0.00287117f, 0.02632834f, 0.04446564f, -0.04026140f, 0.01489575f, 
    -0.03318144f, -0.02049724f, 0.00587911f, 0.02719725f, 0.04283993f, -0.00646522f, 0.02638282f, 0.03065351f, 
    -0.05234873f, 0.01335733f, 0.03811004f, -0.01200526f, -0.03775208f, 0.02165906f, -0.00292012f, 0.02140606f, 
    0.03102160f, -0.05123972f, 0.03969676f, -0.03403955f, -0.03080033f, 0.00717676f, -0.01435222f, -0.01657537f, 
    0.02820929f, -0.03997352f, -0.02552661f, 0.04338982f, -0.05401760f, 0.03009875f, 0.01453081f, -0.01738425f, 
    0.00316447f, 0.01758559f, -0.04996992f, -0.04381848f, -0.02645450f, 0.03447505f, 0.03073923f, 0.01538739f, 
    0.03129012f, 0.02330278f, 0.02495496f, 0.04588266f, -0.03928201f, 0.00620687f, -0.04700070f, -0.02901229f, 
    0.04631291f, 0.04247725f, -0.01691552f, 0.01499494f, -0.00919832f, -0.04921135f, 0.03307235f, -0.04640479f, 
    0.02623784f, -0.00639043f, 0.01533557f, 0.01722801f, 0.02907021f, -0.05165399f, -0.04836715f, 0.02177177f, 
    -0.02491287f, 0.02923301f, -0.01652412f, -0.01653947f, -0.04155232f, -0.01896143f, 0.01389809f, 0.04024882f, 
    0.00991795f, 0.01430605f, -0.00587678f, -0.03101491f, -0.03093575f, 0.00237440f, -0.04196589f, -0.02768435f, 
    0.00489682f, 0.01994788f, 0.01453916f, -0.02138536f, 0.02690594f, -0.04933818f, -0.03540320f, -0.02124600f, 
    0.04776547f, -0.01317513f, -0.01798482f, -0.02837603f, -0.00415960f, -0.04108382f, 0.02171445f, 0.01887028f, 
    -0.01704329f, -0.03740756f, 0.04446223f, 0.00535237f, -0.00838273f, -0.03598963f, -0.00410520f, 0.03707500f, 
    -0.01117480f, -0.02154160f, -0.03422423f, -0.04385159f, -0.04490207f, 0.04661062f, -0.02998017f, -0.04195905f, 
    0.04248479f, -0.01496779f, -0.00272128f, 0.00430742f, -0.03693558f, -0.00928418f, -0.00965536f, -0.03480234f, 
    -0.01513396f, -0.04970171f, 0.02285561f, 0.00904039f, 0.01516239f, -0.00290763f, -0.00797562f, 0.01416900f, 
    0.01312152f, -0.04356172f, -0.03095593f, -0.02654281f, -0.03053053f, -0.03471254f, -0.02901817f, -0.02728036f, 
    -0.00197822f, 0.00955379f, -0.00457780f, 0.02364609f, 0.02458787f, 0.02090517f, 0.00979978f, -0.00445809f, 
    -0.03991904f, 0.00481949f, 0.00167792f, -0.04355244f, -0.03616956f, -0.04610487f, 0.02614184f, -0.01376743f, 
    -0.03357768f, -0.04926929f, 0.04222201f, -0.00217101f, -0.04674065f, -0.04618777f, 0.04283379f, -0.04528644f, 
    -0.01726145f, -0.00827214f, -0.04609321f, 0.01728367f, -0.03065782f, -0.04296511f, -0.00759036f, -0.01122987f, 
    0.02151268f, -0.04949895f, -0.01347803f, -0.00796941f, -0.01777204f, -0.02558905f, 0.03182250f, -0.00322122f, 
    -0.03227594f, -0.00000057f, -0.00880303f, -0.02719947f, -0.03090038f, 0.02968165f, -0.01966574f, -0.05100196f, 
    -0.04562284f, -0.03766945f, -0.01691542f, 0.01915868f, 0.01240003f, 0.02022494f, 0.00095214f, -0.00705677f, 
    -0.01450848f, -0.01104533f, 0.03144034f, 0.00156228f, 0.00827446f, -0.01796970f, 0.00387848f, -0.02462338f, 
    0.00037217f, -0.01080351f, -0.03156817f, 0.02865984f, 0.02057766f, 0.01891087f, 0.04398243f, -0.00329830f, 
    0.03640359f, -0.03186482f, -0.00624622f, -0.00155031f, -0.01391028f, 0.04047399f, -0.04759385f, 0.00125500f, 
    0.04382285f, 0.04000695f, -0.01082820f, -0.04314069f, -0.03049898f, -0.00861535f, 0.03926573f, 0.00705656f, 
    -0.00298912f, 0.01101732f, -0.01569998f, -0.02078988f, -0.03132435f, -0.00433311f, 0.04542309f, 0.00937244f, 
    -0.04458917f, 0.00744248f, -0.03189620f, -0.00945773f, -0.00069665f, 0.00167323f, -0.00993652f, 0.01664150f, 
    -0.00327199f, -0.01324776f, 0.01402433f, -0.05088315f, -0.02812199f, -0.00677209f, 0.04582861f, 0.02722942f, 
    0.04136817f, -0.04016048f, -0.02712116f, -0.01653350f, 0.00840577f, 0.04553281f, -0.02019244f, -0.01901422f, 
    0.01340381f, 0.01705867f, 0.02001550f, -0.00597136f, 0.00944478f, 0.00241243f, -0.02386677f, -0.02421470f, 
    0.04533783f, 0.04680634f, -0.04272520f, 0.02549043f, -0.01715300f, -0.02040277f, -0.04145360f, 0.02190632f, 
    0.02298589f, -0.03673708f, -0.03259768f, -0.00316055f, -0.05226253f, 0.00088139f, -0.04348907f, -0.01699269f, 
    0.02460424f, -0.00798487f, -0.01280514f, -0.03537724f, 0.04304445f, 0.00909485f, -0.03735888f, -0.04806929f, 
    -0.05001191f, -0.02170441f, -0.04246543f, -0.00589793f, -0.01612578f, -0.05106461f, 0.04041462f, -0.05209073f, 
    0.00482229f, 0.00186761f, -0.00102022f, -0.03734660f, 0.01068144f, 0.01877638f, 0.01064710f, -0.02162729f, 
    -0.03578888f, 0.03221433f, -0.00399653f, 0.02231896f, 0.03359316f, -0.05118266f, 0.00824900f, -0.02727440f, 
    -0.01101665f, -0.01671604f, 0.04668020f, -0.01454374f, -0.03968899f, 0.03883452f, -0.04883058f, -0.04329833f, 
    0.02712606f, 0.02894166f, 0.01355084f, -0.04592145f, -0.02429982f, -0.03151494f, -0.04042478f, 0.02045854f, 
    0.04842488f, -0.02731063f, -0.00135960f, 0.00092769f, 0.02660352f, -0.02046000f, 0.02313061f, 0.00883270f, 
    0.02285073f, -0.01044378f, -0.02662709f, 0.03099276f, 0.03465617f, -0.00594455f, 0.03089730f, 0.02719863f, 
    -0.01265307f, 0.01546325f, -0.03745948f, 0.02717714f, 0.02435995f, 0.03533480f, -0.00824036f, 0.03214849f, 
    0.04548882f, -0.01351551f, -0.01354992f, -0.00533299f, 0.04445086f, 0.02650601f, -0.02986228f, 0.02913744f, 
    -0.01128029f, -0.04279536f, 0.03636190f, -0.02306063f, 0.03177686f, -0.02632728f, 0.02313085f, -0.03999272f, 
    0.11938636f, -0.18825300f, 0.14804320f, -0.38812745f, 0.14199556f, -0.05470767f, -0.10677858f, 0.06982466f, 
    0.00079623f, -0.03580259f, -0.08678127f, -0.01281167f, -0.01375772f, -0.07751185f, 0.08454068f, -0.01447931f, 
    -0.04324236f, 0.04137165f, 0.00494821f, 0.07125472f, -0.03536939f, 0.01892918f, 0.02032861f, -0.08463480f, 
    -0.11965485f, 0.06888221f, 0.20761201f, -0.21583670f, -0.03108132f, -0.01963447f, 0.03174154f, -0.00956818f, 
    -0.06604124f, 0.02303274f, 0.03789525f, 0.06119158f, 0.07174022f, -0.08018566f, -0.15041384f, 0.12931089f, 
    -0.02621924f, 0.00430518f, -0.00829644f, -0.07786293f, 0.02899392f, -0.02676244f, -0.02182610f, -0.01342768f, 
    -0.01269769f, 0.05225997f, -0.01517958f, 0.23224607f, 0.02059159f, 0.04024343f, -0.00917298f, 0.13124825f, 
    -0.07813825f, -0.12051708f, -0.06400798f, -0.00077821f, 0.32070068f, 0.18211542f, 0.00085777f, 0.10982441f, 
    0.15964201f, 0.01397510f, 0.04376959f, 0.03019919f, 0.01188225f, 0.02089973f, -0.02052741f, 0.01491179f, 
    0.03109356f, -0.05072647f, -0.12942503f, 0.04396768f, 0.09054297f, -0.15987048f, 0.02436171f, 0.01763789f, 
    0.13954918f, 0.06668572f, 0.05296659f, -0.00113456f, -0.04553083f, 0.05704395f, -0.10427955f, -0.23869503f, 
    0.11296996f, 0.04804012f, -0.05323934f, -0.09461796f, 0.18518166f, 0.00037468f, 0.04812958f, 0.01718789f, 
    -0.05388156f, 0.06156553f, 0.03478133f, 0.13797428f, -0.13641351f, 0.01093834f, -0.05722673f, -0.03509201f, 
    0.00297554f, -0.10710672f, -0.12835787f, 0.00618933f, -0.26715946f, 0.29857296f, -0.10221176f, 0.08492102f, 
    -0.04159420f, 0.08092858f, 0.02259178f, 0.07122229f, 0.07907470f, 0.08655235f, 0.03427508f, 0.14531952f, 
    0.10163946f, 0.13530178f, -0.00496755f, 0.18776245f, 0.12988463f, -0.11911157f, 0.03576080f, 0.12249013f, 
    0.00245386f, -0.05843292f, 0.01800073f, -0.12237340f, -0.06668656f, -0.11096776f, 0.10099352f, -0.18419676f, 
    0.01476327f, 0.07358640f, 0.04358665f, -0.01341534f, 0.06643853f, -0.15732299f, -0.07893364f, -0.07491022f, 
    -0.05453877f, 0.12708965f, -0.11622528f, 0.22442889f, 0.15230720f, 0.01187481f, 0.02235106f, 0.11053441f, 
    -0.02483823f, -0.04802198f, 0.09515236f, -0.13342497f, 0.16098560f, -0.02598874f, 0.35222575f, -0.14738257f, 
    -0.02063823f, 0.00922665f, -0.01937519f, 0.16387254f, -0.08482771f, 0.10421313f, -0.03807217f, 0.07558887f, 
    -0.25577036f, 0.08860771f, 0.01536186f, 0.31986576f, 0.03697876f, -0.05969723f, -0.08658896f, 0.08643790f, 
    0.00324786f, -0.04003694f, -0.06488841f, 0.18917198f, -0.14000604f, -0.13030837f, -0.05229319f, 0.17067762f, 
    0.05285281f, -0.00848911f, -0.07007387f, -0.02418048f, -0.03052465f, -0.01541776f, 0.07597639f, 0.10130379f, 
    0.04505073f, -0.17483337f, 0.05587019f, 0.17817982f, 0.00306686f, -0.05059876f, 0.07008764f, 0.05770703f, 
    0.11127041f, -0.00275645f, 0.07207399f, 0.07931789f, 0.19797127f, 0.04723657f, -0.11205582f, 0.06982382f, 
    0.10386080f, -0.02291557f, -0.01968205f, 0.06734565f, 0.04760457f, 0.02451697f, -0.00321798f, -0.08362925f, 
    0.16927862f, -0.09642030f, 0.02937127f, -0.28034350f, 0.00141751f, -0.08439310f, -0.01182122f, 0.02270711f, 
    0.06902886f, 0.12408820f, -0.01481654f, 0.07540084f, 0.17179942f, -0.15017794f, 0.14934286f, 0.09014820f, 
    0.00209120f, -0.02460726f, 0.09733928f, 0.01740095f, 0.06495813f, 0.06713863f, -0.06972577f, 0.17247221f, 
    0.29386818f, -0.00691605f, -0.07545860f, -0.18733032f, 0.11710980f, 0.06676577f, -0.00075539f, -0.02250070f, 
    -0.07441872f, 0.12454912f, -0.06358419f, 0.01998088f, -0.26089227f, -0.35020208f, 0.15501519f, -0.05233603f, 
    0.00185443f, -0.03754756f, 0.12910056f, -0.06034206f, 0.11902004f, -0.14032489f, -0.00252400f, -0.12336021f, 
    -0.01479574f, -0.01563834f, -0.10022866f, 0.10521755f, -0.08049075f, -0.01631752f, -0.00365782f, 0.05730419f, 
    -0.14533205f, 0.13667674f, 0.05877616f, -0.02879220f, 0.20844741f, -0.07992557f, -0.08613638f, 0.00521998f, 
    -0.05038069f, 0.02170975f, 0.04388130f, 0.08902133f, 0.08377767f, 0.00498539f, -0.02181991f, 0.10090780f, 
    -0.28049159f, 0.06435722f, -0.01011264f, -0.12485189f, -0.05236629f, -0.12546904f, -0.02783156f, -0.03857863f, 
    -0.09151246f, -0.02696598f, 0.15142566f, -0.11937456f, 0.13099572f, -0.10860556f, -0.15492767f, 0.35519621f, 
    -0.11686446f, -0.09021076f, -0.10990781f, -0.07943165f, 0.05325676f, 0.05061698f, 0.10220782f, -0.00093659f, 
    -0.15670486f, 0.07684862f, -0.01517246f, 0.19680749f, 0.14590140f, -0.00858774f, -0.04661154f, 0.07422489f, 
    0.02589998f, -0.00386326f, 0.07196733f, -0.14053258f, -0.31560010f, 0.12077504f, 0.02593165f, 0.07415085f, 
    0.01131083f, 0.06930047f, -0.00160852f, -0.09448002f, 0.07283151f, -0.17786938f, 0.03396405f, -0.04682751f, 
    -0.31577423f, 0.08770099f, 0.07930942f, -0.02436292f, -0.00731593f, -0.02560561f, -0.09273830f, 0.04844023f, 
    0.02631907f, 0.05843011f, 0.12542778f, 0.14098747f, 0.10254583f, 0.02516723f, 0.18460493f, -0.04913158f, 
    0.19112141f, 0.08337409f, 0.01052475f, 0.02222488f, -0.06961454f, 0.08679177f, 0.01023405f, 0.27466348f, 
    0.39498273f, -0.13334331f, -0.03566802f, -0.22113281f, 0.04699788f, 0.05386430f, 0.02676198f, 0.00321221f, 
    0.00438051f, -0.03989083f, 0.08331063f, -0.05477604f, 0.40920755f, -0.07451452f, 0.02124958f, 0.11236411f, 
    -0.03214455f, 0.01422784f, 0.04752398f, -0.04464076f, 0.01244799f, 0.07738779f, 0.05582630f, -0.05870863f, 
    -0.03912380f, -0.01907404f, 0.01383871f, 0.01655135f, 0.02458057f, 0.01370450f, 0.03003168f, -0.01622951f, 
    0.02134603f, -0.04719878f, -0.05116370f, -0.01838714f, -0.02141708f, -0.02953419f, -0.05796033f, -0.03793010f, 
    -0.05160349f, -0.04033190f, -0.05210564f, 0.04136066f, 0.01536745f, 0.00254677f, 0.04530840f, -0.05634618f, 
    0.01826430f, -0.02529373f, 0.02966855f, 0.00164376f, 0.02388801f, -0.00325525f, 0.03276720f, -0.04220342f, 
    -0.03820501f, -0.04147985f, 0.01572837f, 0.01487624f, -0.05778533f, -0.01577661f, 0.01686925f, -0.04730131f, 
    0.02676146f, -0.00064826f, 0.03715001f, 0.03819718f, -0.02555368f, 0.00079022f, 0.01141738f, -0.00791596f, 
    0.03557297f, -0.03683971f, -0.02380561f, -0.01151738f, -0.03897529f, -0.05781447f, -0.02583698f, 0.00114861f, 
    -0.01426415f, -0.03923654f, 0.03099476f, 0.00380626f, -0.03296385f, 0.03429263f, -0.02401976f, 0.01277528f, 
    -0.04280690f, -0.00241559f, 0.01843010f, -0.04019254f, 0.01305594f, 0.02097460f, -0.02885974f, 0.00744532f, 
    -0.03071687f, 0.00507044f, -0.03795055f, -0.04002455f, 0.02490064f, 0.02562799f, -0.02892300f, -0.02539192f, 
    -0.00226592f, -0.00797012f, 0.00269498f, -0.04235302f, 0.02848976f, 0.03220799f, -0.01940329f, 0.04603404f, 
    0.02753298f, -0.04563905f, 0.01709200f, -0.02693241f, 0.01957393f, 0.01146355f, 0.00126954f, -0.00011578f, 
    -0.04234549f, -0.04977757f, -0.03948995f, -0.03063522f, -0.02218952f, -0.01962710f, 0.01709874f, -0.01487309f, 
    -0.00663494f, -0.04370230f, 0.02286632f, -0.03664006f, 0.02131063f, -0.01193062f, 0.02263850f, 0.03167577f, 
    0.00499572f, 0.02452392f, -0.03302913f, -0.05183708f, 0.03156213f, 0.04076079f, -0.01697827f, -0.05289963f, 
    -0.01855725f, 0.00685393f, 0.01247637f, -0.03044061f, 0.03383474f, 0.01019661f, -0.01510767f, -0.04981310f, 
    -0.04886495f, -0.03909067f, -0.05115608f, 0.01411436f, 0.02429752f, -0.04017464f, -0.03899692f, -0.00065177f, 
    -0.03332070f, 0.01135038f, -0.05857291f, 0.00810228f, -0.02559704f, -0.02675532f, -0.00754860f, 0.02692242f, 
    -0.01262780f, -0.00143765f, -0.03624397f, -0.03522304f, 0.01976254f, -0.03924603f, 0.00108245f, -0.05193914f, 
    -0.03153775f, -0.03695443f, 0.03346317f, 0.02634653f, 0.03890079f, -0.03208792f, 0.01160885f, -0.00073520f, 
    0.01649255f, 0.00071413f, 0.00707849f, -0.03401650f, 0.03735064f, 0.03773513f, -0.00881158f, 0.00830452f, 
    -0.00559636f, -0.03305174f, -0.04231756f, 0.04201199f, 0.01577621f, -0.01615270f, -0.03680883f, -0.02624387f, 
    -0.04971591f, 0.03325423f, -0.01879841f, -0.03105045f, -0.01253267f, 0.03570570f, -0.02630385f, -0.01654098f, 
    0.00136833f, -0.02162239f, -0.02235902f, 0.01842270f, 0.02422157f, -0.00975358f, -0.00382139f, -0.04655270f, 
    0.00670321f, -0.04722463f, -0.02518715f, -0.00105491f, -0.01140712f, -0.04094708f, -0.03949339f, -0.04374510f, 
    0.02718564f, 0.00290959f, -0.01714695f, -0.05244865f, -0.05767299f, 0.03053685f, 0.01049885f, 0.00474253f, 
    0.00454209f, -0.05400679f, -0.03626961f, 0.02760499f, 0.00660215f, -0.02683388f, 0.00226526f, -0.00237911f, 
    -0.04791588f, 0.03702638f, -0.02250824f, -0.03073043f, -0.04551972f, -0.04541687f, 0.00781429f, -0.03828521f, 
    -0.03644602f, 0.00000006f, -0.02852435f, -0.05051282f, -0.00781525f, -0.05059551f, 0.00482954f, 0.02905114f, 
    -0.04381385f, -0.01539330f, 0.01478602f, -0.01040982f, -0.01589232f, -0.04403706f, 0.04242465f, 0.03529091f, 
    0.01686364f, 0.03733370f, -0.04118986f, 0.01738845f, 0.00040445f, -0.02930455f, -0.04437628f, 0.01328463f, 
    -0.00301705f, 0.03738307f, 0.02020935f, -0.03363979f, -0.01025485f, 0.02734495f, -0.01226883f, 0.03702675f, 
    0.02446333f, -0.02426040f, 0.03348529f, -0.04356468f, 0.03708530f, -0.02863028f, -0.04514211f, 0.03570184f, 
    -0.03584959f, 0.01364858f, -0.02035118f, -0.05030871f, 0.01973712f, 0.00681761f, -0.04764313f, -0.01896267f, 
    -0.01496262f, -0.05804094f, -0.05078487f, -0.02925323f, -0.04551471f, -0.02671520f, -0.05218457f, -0.02894208f, 
    0.04169572f, -0.02259835f, 0.00207516f, 0.03769748f, 0.01098696f, 0.00843006f, 0.03543546f, -0.03702698f, 
    -0.02006949f, 0.03943022f, 0.03137012f, 0.03068678f, 0.00413876f, -0.05503564f, -0.02371621f, -0.04752427f, 
    0.03536936f, 0.03242296f, 0.02248900f, 0.01041715f, -0.05411977f, -0.04201984f, -0.00072967f, -0.04181714f, 
    0.04181134f, 0.03519121f, 0.01344210f, 0.00462532f, -0.02899881f, -0.03334212f, 0.01204441f, -0.00890166f, 
    0.03417553f, -0.04274534f, -0.00517168f, -0.01939704f, -0.01822896f, -0.05235418f, -0.02559723f, 0.02374095f, 
    0.01221096f, 0.01373255f, 0.02385212f, 0.02918025f, -0.04809986f, 0.03133965f, -0.00517397f, 0.02770745f, 
    -0.02889553f, -0.01345245f, -0.01371191f, 0.00232894f, 0.00054686f, -0.01864312f, -0.02246708f, 0.03529089f, 
    -0.03351823f, -0.04407964f, -0.04500097f, 0.02621895f, -0.04897492f, 0.02754218f, 0.01740957f, 0.04682387f, 
    0.04063300f, 0.02678685f, -0.04232342f, 0.00788510f, -0.03988319f, 0.04359655f, 0.02537355f, 0.03969117f, 
    -0.03041773f, 0.03143955f, 0.01635814f, -0.03841246f, -0.01172629f, -0.05030892f, 0.04730478f, 0.02345679f, 
    -0.04613380f, 0.01457058f, 0.02749860f, -0.02457958f, -0.04107774f, -0.00090020f, 0.01173226f, 0.02468144f, 
    0.01509699f, 0.00942216f, 0.00616359f, -0.00642115f, 0.02212314f, -0.01459889f, 0.04123067f, -0.05770246f, 
    0.00801054f, -0.01686058f, 0.03564373f, 0.00975855f, -0.00514660f, 0.01023553f, -0.05404959f, 0.00481015f, 
    0.00703077f, -0.01130102f, -0.03413421f, -0.00709854f, -0.04815558f, -0.05641456f, 0.00199754f, -0.05673580f, 
    0.00165514f, 0.02320876f, -0.00951272f, -0.03825304f, -0.04940512f, 0.00917020f, -0.03951727f, 0.02065543f, 
    0.00401699f, -0.03277538f, 0.04299124f, -0.00887452f, 0.04142106f, 0.00610974f, -0.01740479f, 0.04199617f, 
    0.01024180f, -0.01039714f, 0.04237325f, 0.02153381f, -0.03484972f, -0.02605381f, 0.01502193f, -0.04917720f, 
    -0.01512573f, 0.00808046f, -0.02371979f, -0.02053107f, -0.03665480f, -0.04586839f, -0.02036919f, -0.04952339f, 
    -0.04091613f, -0.04907769f, 0.03696201f, -0.04313740f, 0.02285005f, -0.01508287f, 0.01601958f, 0.02335744f, 
    -0.04622051f, 0.02980910f, -0.00948343f, 0.03205172f, 0.00674417f, -0.00793723f, -0.02969188f, -0.01686064f, 
    0.03208564f, 0.02393935f, 0.00980504f, -0.00719646f, -0.00905212f, 0.00384992f, -0.04170628f, -0.01406597f, 
    0.02765586f, 0.02821409f, -0.01673068f, -0.04843448f, -0.03142652f, -0.02574647f, 0.03259876f, -0.03093599f, 
    -0.02539794f, -0.02806365f, -0.02868591f, 0.03723216f, 0.03926403f, 0.01342258f, -0.00654001f, 0.03510537f, 
    0.04109610f, 0.03772130f, -0.02589509f, 0.01740878f, 0.03093801f, -0.01494311f, 0.03710206f, 0.03513489f, 
    -0.02241527f, 0.01976394f, -0.01003900f, -0.02249851f, -0.00314857f, -0.03227428f, -0.02181347f, 0.02612898f, 
    0.01488302f, -0.00528690f, -0.00793132f, 0.02946049f, -0.01302736f, -0.02514225f, -0.05237025f, 0.01853088f, 
    -0.04347359f, -0.04436191f, 0.04105114f, -0.03755220f, -0.05066700f, -0.05403719f, -0.02437912f, 0.04102543f, 
    -0.03417615f, -0.03333715f, -0.04156544f, 0.02135920f, 0.01326893f, -0.05575890f, -0.03823037f, 0.02512464f, 
    -0.01491218f, -0.04626250f, -0.00312683f, 0.01889293f, 0.03551696f, -0.00451240f, -0.02003494f, -0.02319573f, 
    0.02821259f, -0.02778295f, -0.03454442f, 0.00724558f, -0.00273755f, 0.00445505f, -0.04210567f, -0.05305910f, 
    -0.04112871f, -0.05464076f, -0.01866388f, 0.02840276f, 0.02876885f, -0.00231099f, -0.05200020f, -0.00245334f, 
    -0.04153490f, 0.02358343f, -0.00042774f, 0.04380322f, 0.02039009f, -0.01419906f, -0.03864739f, 0.01187494f, 
    -0.00151494f, -0.02321454f, -0.02837036f, -0.03850285f, -0.04140075f, 0.03703310f, -0.00053447f, -0.02567961f, 
    0.00864132f, -0.01126520f, -0.02089645f, 0.02645164f, 0.00582415f, -0.02388961f, 0.00800519f, -0.03977435f, 
    0.01939713f, 0.00450708f, -0.01705969f, -0.04398771f, -0.01529359f, 0.01801600f, -0.03026702f, -0.04879567f, 
    0.00178313f, -0.03862473f, -0.02357213f, -0.05567772f, -0.02745331f, -0.03752851f, -0.02243835f, -0.02038497f, 
    -0.02795437f, -0.04871487f, 0.02944742f, -0.01990642f, -0.02547637f, -0.03156716f, 0.00415674f, 0.04387975f, 
    0.00013630f, 0.01791991f, -0.04449056f, 0.03554532f, -0.05467019f, 0.04451552f, -0.01942653f, 0.00661435f, 
    -0.02372153f, -0.04755910f, -0.01170953f, -0.01206341f, -0.02047673f, -0.01365137f, -0.00865342f, 0.02009094f, 
    -0.00519191f, 0.01004964f, 0.02863706f, 0.03421564f, 0.03346305f, 0.01856170f, -0.03789069f, -0.05041248f, 
    -0.02210047f, -0.00099461f, -0.00679711f, -0.00727595f, -0.05260866f, 0.03733956f, 0.03967562f, -0.02471062f, 
    -0.03728235f, 0.03089033f, -0.00605520f, 0.04163508f, 0.03259138f, 0.04003520f, 0.02889570f, 0.00930421f, 
    0.03156705f, -0.02902510f, 0.00629908f, 0.04469214f, -0.02635944f, -0.03836608f, 0.00496649f, 0.01623423f, 
    -0.02850700f, -0.01517177f, -0.03255866f, -0.04603998f, -0.03063348f, -0.03626993f, -0.03891325f, 0.02681495f, 
    -0.05136522f, 0.04167109f, 0.04004475f, -0.00861413f, 0.03318938f, -0.01342427f, -0.00152369f, -0.05374483f, 
    0.01036282f, 0.03117087f, 0.00206825f, -0.00580340f, 0.03777020f, -0.03511985f, -0.00718381f, 0.00000726f, 
    0.04081468f, 0.00579706f, -0.00407844f, -0.04088076f, -0.03794806f, 0.04462036f, 0.01203870f, -0.05131637f, 
    0.01660406f, 0.03956335f, 0.01328273f, -0.04634957f, 0.00867945f, -0.03232963f, 0.02429917f, 0.02064981f, 
    0.02963994f, 0.00692958f, 0.02428031f, 0.02429652f, -0.00998342f, 0.00271763f, 0.04214669f, -0.02456162f, 
    -0.01313550f, 0.03337507f, -0.01214237f, 0.01089497f, -0.01546527f, -0.01153743f, -0.03104980f, 0.03802301f, 
    0.02092178f, -0.01597883f, -0.01874999f, 0.04182468f, -0.05178221f, -0.02365033f, 0.01755569f, 0.00920680f, 
    -0.01856247f, -0.03500794f, -0.01379436f, -0.02309665f, -0.02032035f, 0.04431384f, 0.03650936f, 0.02435867f, 
    -0.03595809f, -0.02308462f, -0.03101064f, -0.03977711f, -0.03072440f, -0.03569322f, -0.02938146f, -0.05089355f, 
    -0.04468422f, -0.03961476f, -0.00422417f, 0.01549575f, -0.03942163f, -0.01489301f, 0.03537956f, -0.02376385f, 
    0.00341930f, 0.03103596f, -0.00090485f, 0.03296631f, -0.00873949f, 0.00091357f, 0.01048680f, 0.04751494f, 
    -0.00174889f, -0.00893627f, -0.01388534f, -0.00635395f, 0.03750222f, -0.03177857f, -0.02441079f, 0.02702085f, 
    0.02921477f, -0.01977979f, -0.01317005f, -0.04315267f, 0.03407930f, 0.04034854f, 0.03778377f, -0.03824595f, 
    -0.03425567f, -0.00099025f, -0.05702103f, 0.03298331f, -0.01557725f, -0.00493463f, -0.02483541f, 0.02897131f, 
    0.04289766f, 0.02089353f, 0.02462248f, 0.01228205f, -0.00464030f, 0.00230490f, 0.04142699f, -0.00155589f, 
    -0.02796147f, -0.05576231f, -0.02867009f, -0.03452960f, -0.02578693f, -0.03641056f, -0.01160351f, 0.01046553f, 
    -0.00901298f, -0.04775151f, -0.04113281f, -0.00057131f, 0.01003479f, 0.00327551f, -0.00407356f, -0.02616576f, 
    -0.05117841f, -0.08507174f, 0.04913538f, -0.12415273f, 0.01556400f, -0.01262895f, 0.05980821f, 0.01014101f, 
    0.00974300f, -0.02629281f, 0.03617863f, -0.15761720f, 0.15693435f, -0.11173087f, -0.07229720f, 0.05198678f, 
    -0.10277029f, -0.10384899f, 0.04428467f, -0.00816445f, 0.16923068f, 0.06233391f, 0.05564880f, -0.01650680f, 
    -0.05169024f, 0.00951785f, 0.08216269f, -0.12453866f, -0.05820500f, 0.06134365f, 0.06180844f, -0.05403274f, 
    0.07334245f, 0.06251501f, 0.00775058f, 0.02118433f, 0.01770980f, -0.29213724f, -0.21487702f, -0.09413475f, 
    0.02661364f, -0.04466406f, 0.05216745f, -0.00329357f, -0.01233931f, -0.02022402f, 0.05735694f, -0.04391116f, 
    -0.08558555f, 0.07215326f, 0.06420197f, -0.15504682f, -0.14317971f, -0.05500809f, -0.04270401f, 0.11741160f, 
    0.09758932f, -0.15031470f, 0.06815926f, 0.12598617f, -0.09585291f, 0.04522413f, 0.04962536f, -0.03300389f, 
    0.01477107f, 0.00461164f, 0.07031647f, 0.12815592f, -0.03131470f, -0.00779837f, 0.00929469f, 0.00268957f, 
    0.11865919f, -0.20363812f, 0.14775392f, -0.11885943f, 0.07606126f, 0.09505829f, -0.05511281f, -0.03783599f, 
    -0.05737781f, 0.07281671f, 0.11796577f, 0.05206953f, 0.32480851f, 0.22429207f, 0.12513779f, -0.08292238f, 
    -0.18770801f, -0.08335332f, -0.09503671f, 0.07601247f, 0.04911140f, 0.06519754f, -0.01032300f, 0.00783270f, 
    0.60033023f, -0.35032967f, -0.02067736f, 0.35821646f, -0.15089783f, -0.02388515f, 0.00404072f, 0.16404331f, 
    0.10452656f, 0.13039388f, 0.01902274f, -0.04701477f, -0.08881097f, 0.03682126f, -0.03615011f, -0.04854440f, 
    -0.05402970f, 0.06349814f, 0.04190933f, 0.02978745f, 0.00319052f, 0.01684439f, 0.03392097f, -0.03371597f, 
    -0.18976726f, 0.09253618f, 0.01404380f, -0.03201824f, -0.04058637f, -0.15784892f, -0.05409430f, -0.03636688f, 
    0.15844643f, -0.01554396f, -0.06348620f, -0.06127239f, 0.03781264f, -0.00361539f, 0.02828765f, -0.28391537f, 
    -0.08405114f, 0.02400493f, -0.00184290f, -0.00579657f, -0.05594147f, 0.02835711f, -0.03193677f, 0.14932193f, 
    0.03198372f, 0.18497282f, 0.01033735f, -0.09111501f, 0.01919393f, -0.05850739f, -0.05023570f, -0.03683173f, 
    0.03601683f, -0.02951986f, 0.05438676f, -0.08206623f, 0.06494342f, 0.09104002f, 0.07529043f, -0.35188538f, 
    0.01293539f, 0.08538682f, 0.05228905f, 0.06727608f, 0.07711010f, -0.04933086f, 0.02740727f, -0.03324745f, 
    -0.37736529f, 0.06193550f, 0.03306535f, 0.23602970f, 0.06816901f, 0.13597789f, 0.00637772f, -0.06292054f, 
    0.01324081f, 0.01977318f, -0.05420364f, 0.09633002f, 0.13034803f, 0.16552447f, 0.02921528f, -0.04886358f, 
    0.00716428f, 0.04036608f, -0.05777432f, -0.00138275f, 0.03443892f, -0.01644026f, 0.15621510f, 0.04997667f, 
    0.05578140f, -0.00832194f, 0.04610642f, 0.19895151f, 0.06697974f, -0.06139730f, -0.01287314f, 0.13308184f, 
    0.03722515f, 0.05425617f, 0.06417841f, 0.01728034f, 0.20084408f, -0.38006720f, -0.15491708f, 0.25853461f, 
    -0.12152718f, -0.07834978f, 0.00403283f, 0.09082164f, 0.03946809f, 0.08250789f, -0.03635901f, 0.03497588f, 
    0.27209786f, -0.10758736f, 0.10448679f, -0.21359730f, -0.09629767f, 0.03137014f, 0.06145768f, -0.01963781f, 
    0.03845239f, 0.03738666f, 0.03076255f, 0.17266977f, 0.09779858f, -0.05224629f, 0.17264622f, -0.21025632f, 
    0.07846222f, 0.01668004f, 0.15300465f, -0.02755113f, 0.11951945f, 0.04123833f, 0.07153694f, -0.17039374f, 
    0.12531680f, -0.00334651f, 0.07247628f, 0.00724641f, 0.01724715f, 0.06345906f, -0.02985026f, 0.02688804f, 
    -0.02728871f, 0.05655135f, 0.00682839f, -0.05203648f, 0.36020538f, -0.03082538f, -0.10992686f, -0.21367189f, 
    0.04092067f, -0.04746424f, -0.03400031f, -0.03308547f, 0.20510143f, -0.04103171f, 0.02790699f, 0.04965790f, 
    0.25812444f, -0.31847787f, 0.12548399f, 0.37909219f, -0.00310217f, -0.04219556f, -0.01224177f, 0.03369565f, 
    0.05112309f, -0.02881077f, 0.04263661f, 0.00673629f, 0.32165062f, -0.09396300f, -0.21346758f, 0.25052905f, 
    -0.10744433f, -0.12610857f, 0.02263065f, 0.08418579f, 0.01953362f, 0.07536262f, -0.04202759f, 0.03725268f, 
    -0.26346499f, 0.16738795f, -0.13453704f, 0.22124608f, -0.03828038f, -0.10411879f, -0.01045658f, 0.09815337f, 
    -0.12462915f, 0.01510141f, -0.01567191f, -0.07751732f, -0.05491715f, -0.13737765f, -0.12093661f, 0.38284191f, 
    0.02677542f, 0.01065993f, -0.05984543f, 0.18649510f, 0.11200055f, -0.05311560f, -0.06019175f, 0.04323900f, 
    -0.04471732f, -0.09720645f, 0.00132360f, -0.04795293f, 0.08526828f, -0.03374767f, 0.03592230f, 0.07183529f, 
    0.05312540f, 0.00416826f, -0.04965057f, 0.05845683f, -0.01207164f, 0.05735668f, -0.09864667f, 0.11625296f, 
    -0.03446850f, -0.05270915f, -0.04278513f, 0.04260069f, 0.02643172f, -0.02924049f, 0.01900771f, -0.03808362f, 
    -0.32877395f, 0.26060018f, -0.22528750f, -0.15582253f, -0.18500349f, 0.01851515f, -0.04652291f, 0.05315161f, 
    -0.07831173f, 0.00197010f, -0.01776377f, 0.02797722f, 0.16771901f, -0.17439143f, 0.04172802f, 0.04290995f, 
    0.02408482f, 0.02987266f, 0.00327694f, 0.19712166f, -0.04608254f, 0.10865770f, 0.14695676f, 0.07358103f, 
    0.24506223f, 0.00351708f, 0.00752798f, -0.07083526f, -0.00753688f, -0.03280106f, -0.01966648f, 0.02920667f, 
    -0.02482244f, 0.09337303f, 0.01058736f, -0.06526170f, -0.04790730f, -0.15911937f, 0.15851130f, 0.15027043f, 
    0.07948717f, -0.06855009f, 0.04776055f, 0.06463655f, -0.01468541f, 0.01778064f, 0.00897970f, -0.01457212f, 
    0.12994051f, 0.08889870f, -0.04413708f, 0.13299932f, -0.00387584f, 0.06472652f, 0.12338365f, 0.01672089f, 
    0.02224111f, 0.01547858f, 0.02492434f, 0.03846277f, 0.28085846f, 0.12058576f, -0.14071719f, -0.11641931f, 
    0.02234966f, -0.11886301f, -0.14063552f, -0.09215124f, -0.04235762f, 0.03817888f, 0.00443193f, -0.07024752f, 
    -0.12249060f, 0.10430358f, -0.04555389f, 0.12328096f, -0.01335748f, -0.01105879f, 0.12272341f, 0.00794289f, 
    0.05705722f, 0.04549288f, 0.05985743f, 0.02960307f, -0.00167580f, 0.09210793f, -0.08026698f, -0.20667753f, 
    -0.15234847f, 0.00547306f, -0.07855396f, -0.12175229f, 0.13701388f, 0.02273904f, 0.03827338f, 0.11625520f, 
    -0.03060078f, -0.06076046f, -0.10276847f, -0.12338279f, 0.01260713f, -0.02921724f, -0.02336892f, -0.10367726f, 
    -0.06446448f, 0.06892799f, -0.09181257f, -0.04224461f, 0.07213812f, 0.02558786f, 0.14545527f, 0.02855096f, 
    -0.01253641f, 0.02162046f, 0.05086274f, 0.13891965f, -0.04730485f, 0.08132403f, 0.01274371f, 0.00074618f, 
    0.01812952f, 0.04878388f, 0.11044259f, 0.00613358f, -0.02103085f, -0.01867105f, 0.05627018f, -0.10564306f, 
    -0.08851492f, 0.04755447f, 0.05741135f, -0.14093465f, 0.70946580f, -0.01620893f, 0.02947733f, -0.03530307f, 
    -0.04063980f, 0.01737398f, 0.01583660f, 0.14822644f, -0.13123520f, -0.09206573f, -0.10414377f, 0.03308909f, 
    -0.07399178f, 0.21473593f, -0.00428106f, -0.11504386f, 0.12493858f, -0.01323076f, -0.15051104f, -0.03492050f, 
    -0.00020686f, 0.02013542f, 0.12478817f, -0.05347070f, 0.31276631f, -0.37971395f, 0.02570576f, 0.14525521f, 
    0.07228351f, -0.00255747f, 0.04883314f, 0.03921094f, -0.07031970f, 0.07967287f, 0.01420675f, -0.19713071f, 
    -0.12652351f, -0.05520984f, 0.03898992f, -0.10558049f, -0.16894990f, -0.05474440f, -0.10053355f, -0.04961606f, 
    -0.04020607f, 0.05703150f, 0.16606778f, 0.12146661f, 0.21965323f, -0.07661673f, -0.01832153f, 0.02603657f, 
    -0.13541169f, 0.03554982f, 0.06504440f, 0.07641581f, 0.08361211f, 0.20470104f, -0.05570752f, -0.00621674f, 
    0.13384840f, -0.02042753f, 0.14696722f, 0.08278316f, 0.01066849f, -0.03576232f, -0.16472214f, -0.06475552f, 
    0.13632433f, 0.06534487f, -0.00110012f, 0.13946962f, -0.14836401f, 0.22088085f, 0.01356002f, 0.05128738f, 
    0.05741254f, 0.14216115f, 0.03449962f, 0.10411675f, -0.05157828f, -0.22941864f, 0.02445988f, -0.01033169f, 
    0.49680153f, 0.01802272f, -0.08299053f, 0.05834564f, 0.00182423f, -0.07465336f, -0.01432990f, -0.12356095f, 
    0.11896778f, 0.08217219f, 0.26444682f, -0.13112135f, 0.24262807f, 0.07483826f, 0.12494142f, -0.12271754f, 
    0.02055620f, 0.07489543f, -0.03187129f, -0.12136668f, -0.09373398f, 0.03848735f, -0.17544317f, -0.14480118f, 
    0.18661982f, 0.28413180f, -0.00389494f, -0.22612593f, 0.12025934f, -0.00087159f, 0.04191939f, -0.12134506f, 
    -0.06942864f, -0.08890206f, -0.08579533f, -0.11751345f, -0.03864606f, -0.02601331f, -0.01744321f, 0.02308754f, 
    -0.11260442f, -0.02496812f, -0.03854135f, -0.00854947f, -0.09644908f, 0.15826531f, -0.02253611f, -0.03240943f, 
    -0.16928910f, 0.08080937f, 0.06406648f, 0.11416555f, 0.11250096f, 0.09575698f, 0.00280009f, 0.05351399f, 
    0.04028505f, -0.05383213f, 0.17629606f, -0.02208267f, -0.13193117f, 0.03975556f, -0.16078489f, -0.13264690f, 
    0.10525810f, 0.13329034f, -0.03782143f, 0.06129199f, 0.06491677f, -0.13695540f, -0.10996716f, -0.12043353f, 
    -0.12315844f, 0.17225827f, -0.05751998f, -0.04794087f, 0.06591671f, -0.03883706f, 0.08555955f, 0.07035916f, 
    -0.09207517f, -0.03635246f, 0.17110546f, -0.01570536f, 0.19596718f, -0.10177445f, -0.03251452f, -0.00616641f, 
    0.02686278f, -0.01030486f, -0.11637346f, 0.00856086f, -0.03148613f, 0.14237918f, 0.16466556f, 0.05216245f, 
    0.02417203f, 0.08651242f, -0.01450488f, 0.04609406f, 0.10585185f, -0.04540076f, -0.07942870f, -0.00694054f, 
    -0.01652848f, 0.05102696f, -0.06619899f, -0.08019900f, -0.25387901f, 0.18677644f, -0.04097461f, -0.16279259f, 
    0.07100843f, -0.07462375f, -0.06739397f, -0.16428947f, -0.13934796f, -0.12306161f, -0.04840831f, -0.08113650f, 
    0.34168336f, -0.02865524f, -0.17894685f, 0.10408361f, -0.09611245f, 0.01938181f, 0.10593755f, 0.05814319f, 
    0.05650907f, 0.05216921f, -0.10820629f, 0.07040661f, 0.00552999f, 0.07577060f, 0.04977709f, -0.09156860f, 
    -0.07522767f, 0.09543474f, 0.01298885f, 0.04467021f, -0.02403490f, -0.11935663f, -0.03958058f, 0.00740639f, 
    0.32550874f, -0.06039359f, 0.16717967f, -0.13576399f, -0.05044329f, -0.09132989f, -0.06309241f, -0.01011718f, 
    0.02636804f, 0.08025791f, 0.00263769f, 0.13379243f, 0.02796395f, -0.23778032f, 0.10431227f, -0.18122448f, 
    0.06164583f, -0.22850430f, -0.19448701f, -0.02183329f, -0.00173516f, 0.03042795f, 0.06388250f, 0.13032521f, 
    0.49212217f, -0.01162336f, 0.12731992f, 0.22731504f, 0.04478017f, 0.05220689f, -0.04536072f, -0.03445888f, 
    -0.04678081f, -0.14426176f, -0.08847608f, -0.04151723f, -0.00240756f, -0.01284051f, -0.04995118f, -0.00983839f, 
    -0.09205115f, -0.20656195f, -0.10202526f, 0.11491689f, 0.20622171f, -0.03165866f, -0.04558838f, -0.21576934f, 
    0.18933946f, 0.07174712f, -0.06428201f, -0.08628159f, 0.00174273f, 0.03839459f, 0.09521715f, 0.08103823f, 
    -0.04039471f, -0.00327143f, -0.01867268f, 0.09707447f, 0.11234002f, -0.06213592f, -0.10645777f, -0.13375705f, 
    0.04562162f, 0.00593922f, -0.09778174f, 0.02325088f, -0.01769429f, -0.00576777f, 0.16306323f, 0.10772645f, 
    -0.05841102f, -0.06915333f, -0.20295568f, 0.11833657f, -0.06594056f, 0.01036009f, 0.06273969f, -0.02197849f, 
    0.00260509f, -0.05298002f, 0.05930583f, 0.13504724f, 0.22751525f, -0.03341269f, 0.11214293f, 0.08579458f, 
    -0.00872440f, -0.03613322f, 0.03626849f, 0.06791010f, 0.05209914f, -0.01901711f, 0.01673358f, 0.01125818f, 
    -0.06387774f, -0.23395328f, 0.11708996f, 0.15838365f, 0.02953296f, 0.11452170f, -0.03429142f, 0.00543557f, 
    0.01344510f, 0.06134184f, -0.11321729f, 0.02341240f, -0.09314558f, -0.12636684f, 0.12216301f, -0.16923597f, 
    0.01979457f, 0.11522555f, 0.00341081f, 0.07264140f, -0.06943052f, -0.01200662f, 0.15938571f, 0.04209318f, 
    0.11821499f, 0.14235683f, -0.20511098f, 0.04162947f, -0.03513880f, 0.08930137f, -0.05638679f, 0.08833364f, 
    0.14960589f, 0.06051153f, 0.14677857f, 0.12155548f, -0.02228262f, -0.12685794f, -0.08361860f, -0.03053613f, 
    -0.02753539f, -0.01052416f, -0.00690261f, -0.06162111f, 0.12372660f, 0.01726966f, 0.04593976f, 0.03118742f, 
    -0.14717536f, -0.19501129f, -0.06969050f, 0.05479822f, 0.07137587f, 0.06114836f, -0.07820936f, 0.04701073f, 
    0.05245161f, 0.00698303f, 0.00608642f, 0.01822249f, -0.38062552f, -0.04558005f, -0.02416418f, -0.09714787f, 
    -0.01885435f, 0.03951880f, -0.04803107f, 0.00228779f, -0.01808057f, -0.08449652f, 0.00646011f, -0.05301990f, 
    0.37039340f, -0.11583218f, -0.08052594f, -0.15644249f, 0.00983870f, -0.04215022f, 0.11476601f, 0.01479440f, 
    0.16622710f, -0.00923589f, -0.02519473f, 0.00849992f, -0.15605940f, 0.04785292f, 0.06316817f, 0.02680631f, 
    0.02208978f, -0.03933697f, -0.07506730f, 0.04960856f, 0.06621964f, 0.00555969f, 0.04658328f, 0.03496084f, 
    -0.00548229f, 0.11439384f, -0.07589917f, 0.00587446f, 0.01313678f, 0.09833491f, 0.07852908f, 0.08541647f, 
    0.00283477f, 0.01264188f, -0.01930792f, 0.03444669f, 0.24573596f, -0.14928931f, 0.03893309f, 0.08212529f, 
    -0.07943508f, 0.01892762f, -0.05294736f, -0.06015396f, 0.14568022f, 0.10605748f, 0.06267874f, 0.00640754f, 
    -0.11548417f, 0.14419141f, -0.06285833f, -0.07213119f, -0.09559079f, 0.04604354f, 0.04162423f, 0.07415227f, 
    0.06400020f, 0.02641162f, 0.21467680f, 0.08497541f, -0.02094114f, -0.07914701f, 0.06314047f, 0.23366451f, 
    -0.02050904f, -0.01244367f, 0.23805635f, -0.07578105f, -0.03459597f, 0.08052958f, -0.02152024f, -0.01967175f, 
    -0.21377708f, 0.07009241f, -0.06403809f, -0.01880813f, 0.09596881f, -0.00407326f, -0.04471089f, 0.00684288f, 
    0.05412135f, 0.00409215f, -0.04587633f, -0.07461867f, -0.17217302f, 0.11083181f, -0.31771708f, 0.00072663f, 
    -0.06018225f, -0.10438030f, 0.10933477f, 0.14031363f, 0.03253502f, -0.02090252f, 0.00438105f, 0.03031558f, 
    0.13142288f, 0.10400933f, 0.07535916f, 0.21006192f, 0.03486723f, 0.09900822f, -0.06276703f, 0.03950477f, 
    0.03467044f, -0.06337111f, 0.02642139f, 0.09393838f, 0.01208294f, -0.11958291f, 0.01930390f, 0.06322373f, 
    0.09514774f, -0.01952595f, 0.01250487f, 0.07382247f, 0.17839223f, 0.05354313f, -0.13123246f, 0.11246462f, 
    0.16194355f, -0.26463187f, 0.10779932f, 0.05482465f, 0.04889102f, 0.03378414f, 0.01096685f, 0.00502438f, 
    0.01175642f, 0.07717447f, 0.01350433f, 0.05242131f, 0.18173182f, -0.06177259f, 0.05259438f, 0.25216359f, 
    0.00330298f, 0.02869799f, -0.01320096f, -0.06814530f, -0.00310052f, 0.00670437f, 0.02045829f, 0.05060757f, 
    -0.11730829f, -0.02889366f, -0.05994692f, -0.00685402f, -0.00950664f, -0.01865681f, 0.10822836f, -0.06119440f, 
    -0.01644786f, -0.00076828f, 0.02996228f, 0.03525118f, 0.47093943f, -0.11133873f, -0.09505972f, 0.07502387f, 
    -0.17551112f, 0.17176187f, 0.13765778f, -0.00071731f, 0.00362254f, -0.04048950f, -0.09600058f, 0.07900264f, 
    0.26832908f, -0.26128459f, 0.24465048f, -0.03879033f, 0.16449475f, 0.03767198f, -0.03315016f, 0.03579845f, 
    0.04585671f, -0.05380401f, 0.08275983f, 0.10664195f, 0.03887129f, 0.07025800f, 0.09528711f, 0.04114254f, 
    0.04146098f, 0.01184670f, 0.06291281f, -0.02048341f, 0.04001410f, -0.07565948f, 0.01220018f, -0.09571048f, 
    0.07541376f, 0.26298320f, 0.00925711f, -0.02204105f, 0.06392659f, 0.09106051f, 0.06008993f, 0.01367263f, 
    0.00714388f, -0.04081130f, -0.04847160f, 0.04275809f, -0.10428759f, 0.05878027f, 0.01905275f, -0.28030357f, 
    0.17090845f, -0.01418478f, -0.03075795f, 0.09601005f, 0.08806571f, -0.07261558f, -0.06388669f, 0.12913282f, 
    0.07835960f, -0.21852304f, -0.08939948f, 0.05231338f, -0.02901175f, 0.07777263f, 0.00647212f, 0.11204021f, 
    0.01934064f, -0.15428531f, 0.04072434f, -0.01162550f, 0.02002611f, -0.09659418f, 0.08572126f, 0.02258608f, 
    -0.03306577f, 0.05241520f, 0.16116469f, 0.12863439f, -0.01789140f, 0.00631975f, 0.01606225f, 0.03373894f, 
    -0.13189328f, 0.21170463f, -0.05208223f, -0.02627743f, -0.14857338f, -0.03708602f, 0.09152400f, 0.12176756f, 
    0.00296830f, -0.00725659f, 0.01542914f, -0.07136730f, 0.10865001f, 0.22530460f, 0.06979630f, 0.17050008f, 
    -0.04716296f, 0.01276296f, 0.18167204f, -0.04012856f, -0.00736234f, -0.02876098f, -0.05039282f, -0.06349184f, 
    0.00897252f, -0.09085174f, -0.28179011f, -0.00246237f, 0.04742959f, -0.00444007f, -0.06047668f, -0.01227521f, 
    0.05020604f, 0.06845079f, -0.03555198f, 0.00274694f, -0.08664624f, -0.12908600f, -0.05411994f, 0.05515058f, 
    0.09364363f, -0.03308310f, 0.07428788f, 0.07951943f, 0.07000586f, 0.04007172f, 0.06883123f, 0.18409781f, 
    -0.00217482f, 0.00912905f, 0.02096305f, 0.03225904f, 0.02129798f, 0.01863842f, -0.04256367f, -0.03739160f, 
    -0.03610863f, -0.00697801f, -0.01850976f, 0.03463924f, 0.00801259f, 0.00526507f, 0.02260760f, -0.05329677f, 
    -0.00136506f, -0.04859458f, -0.04285988f, -0.03127124f, 0.02951764f, 0.03514886f, -0.00145915f, -0.00579437f, 
    -0.00861901f, -0.04504856f, 0.00668186f, -0.03653059f, 0.04161764f, 0.02685871f, -0.02243501f, -0.00837129f, 
    -0.00744354f, -0.03915816f, -0.04310733f, -0.03386110f, -0.01472771f, 0.04461693f, 0.03843455f, -0.00003239f, 
    0.00026236f, 0.00749289f, 0.02486280f, -0.02713554f, -0.03664175f, 0.02638646f, -0.03635914f, -0.05303071f, 
    0.01744769f, 0.01241283f, 0.00144118f, 0.03697127f, -0.00291350f, 0.02744011f, 0.00825221f, -0.04899365f, 
    0.00411920f, 0.00422623f, -0.01513253f, -0.03047695f, -0.04270260f, -0.03764241f, -0.02042535f, 0.02946474f, 
    0.00754486f, -0.02825675f, -0.04366392f, 0.03762493f, -0.05395237f, 0.00613424f, -0.02370806f, 0.03088974f, 
    -0.01423954f, -0.05036768f, 0.02586683f, 0.04009690f, -0.05285686f, 0.00691270f, -0.01287076f, -0.03943721f, 
    -0.03974707f, -0.01685798f, -0.01784039f, -0.02841549f, -0.03153481f, 0.00556034f, -0.03661809f, 0.02481468f, 
    0.03455857f, -0.04165412f, 0.03105109f, -0.03962115f, -0.04922005f, -0.04462955f, 0.00090496f, 0.04464408f, 
    -0.01438210f, -0.04093758f, -0.00037355f, -0.04082616f, -0.02497036f, 0.03111514f, 0.04013071f, -0.05138164f, 
    0.04269062f, 0.01886155f, -0.04169532f, 0.02667669f, 0.01229455f, -0.01297113f, -0.01430320f, -0.04094330f, 
    -0.03247710f, -0.01370430f, 0.03846274f, 0.03433015f, -0.01267305f, -0.02311148f, -0.04977037f, -0.04957607f, 
    -0.04073656f, 0.02909824f, -0.00457028f, -0.00322696f, -0.05230736f, -0.04479425f, -0.01371878f, -0.05214801f, 
    0.04107413f, 0.03243108f, -0.00605329f, -0.04416546f, 0.03065028f, 0.00374597f, -0.01567905f, -0.01059491f, 
    0.02748300f, 0.04444184f, -0.00807564f, -0.04209358f, -0.00848915f, -0.04102198f, 0.04361037f, 0.04204398f, 
    -0.01212162f, -0.02348032f, -0.04253570f, 0.02014789f, -0.00087961f, -0.04607743f, -0.03624994f, 0.00672800f, 
    -0.02970315f, -0.01809852f, 0.00944296f, 0.03041463f, -0.05446082f, -0.01952425f, 0.00101961f, -0.04060461f, 
    0.02886137f, -0.01383922f, 0.04055103f, 0.01763267f, 0.03223758f, -0.01481190f, -0.02347612f, -0.05272070f, 
    0.01066572f, -0.01760903f, -0.05307094f, -0.04437638f, -0.00425132f, -0.00063077f, -0.00584609f, -0.02238265f, 
    -0.04939834f, -0.02537028f, 0.04415065f, -0.01532351f, 0.04011371f, 0.02675130f, -0.02014394f, -0.01154775f, 
    -0.05429863f, 0.01896514f, -0.03418582f, 0.03590171f, 0.05130948f, 0.02667790f, 0.05545798f, -0.00841780f, 
    -0.04015094f, 0.03308051f, 0.00125614f, 0.02397392f, -0.03230098f, 0.04127673f, 0.03716021f, -0.03014544f, 
    0.02911795f, -0.00495422f, -0.03070614f, -0.01831693f, -0.00576991f, -0.00423591f, 0.02762417f, 0.03237046f, 
    -0.01814630f, 0.03335748f, -0.05446223f, -0.01426080f, -0.00098546f, -0.01890859f, -0.00940377f, -0.05381695f, 
    -0.03405108f, 0.04175987f, 0.02919122f, -0.05445301f, 0.01951532f, -0.01950771f, -0.04942621f, -0.05129783f, 
    -0.04229982f, -0.03642221f, 0.02342508f, 0.01614657f, 0.01215633f, -0.02785717f, 0.01347002f, 0.00192569f, 
    0.03134540f, -0.02890039f, -0.02552797f, -0.05506942f, -0.03390228f, -0.01406129f, -0.00778735f, -0.00076110f, 
    -0.03350886f, 0.02278155f, 0.04384293f, 0.00933784f, 0.03897205f, 0.04526136f, -0.04282400f, 0.01446311f, 
    -0.04209384f, 0.01488008f, 0.00736243f, -0.01632278f, 0.00414832f, -0.01741768f, 0.03210149f, 0.04012386f, 
    -0.03944409f, 0.03481282f, 0.01949427f, -0.00126569f, -0.01727269f, 0.03283986f, 0.05402542f, 0.00552807f, 
    0.03350039f, 0.01617722f, 0.01120481f, -0.02283394f, 0.01216950f, -0.02370431f, 0.00636784f, 0.01267592f, 
    -0.00369738f, 0.02911665f, 0.01866505f, -0.01241241f, -0.01848298f, -0.01182615f, 0.04002496f, -0.03912545f, 
    -0.03640215f, -0.01761884f, -0.00117895f, 0.01566544f, -0.02568740f, 0.02322835f, 0.04100788f, -0.01153036f, 
    0.01940236f, 0.02031604f, 0.00436800f, 0.01936040f, -0.04086834f, 0.04213488f, 0.00666018f, 0.01663201f, 
    0.00390653f, -0.01662465f, -0.03263701f, 0.02152155f, 0.03422559f, 0.02012379f, 0.01215921f, 0.01910723f, 
    -0.02393896f, -0.04089310f, 0.02571349f, 0.00664315f, 0.02272972f, -0.04059666f, 0.00728322f, -0.04384400f, 
    -0.04810303f, -0.03777893f, -0.01151977f, 0.03555627f, -0.00744108f, 0.00074881f, -0.00963429f, -0.00345329f, 
    0.02716688f, 0.01157046f, -0.02115926f, -0.00592676f, -0.01036015f, -0.01940258f, 0.03844819f, -0.02123319f, 
    0.00530287f, -0.02885520f, 0.03812536f, -0.00981187f, 0.00941203f, -0.03351459f, -0.01275825f, 0.02568350f, 
    -0.00218152f, 0.03327820f, 0.01316640f, 0.04387755f, -0.03566617f, 0.02958268f, -0.01392775f, 0.03722776f, 
    0.00933980f, -0.04241659f, 0.00611239f, -0.00211488f, -0.01441244f, -0.03147683f, -0.05333032f, -0.04367910f, 
    0.03225208f, -0.04529883f, 0.02541284f, -0.01022451f, 0.03371820f, 0.02048341f, -0.03076996f, -0.03367741f, 
    0.03848585f, -0.03712981f, -0.00909675f, -0.00762251f, -0.02614669f, 0.03547958f, -0.04860716f, 0.02514715f, 
    0.03012281f, -0.02671385f, -0.05631356f, 0.01262251f, -0.00419583f, -0.03546625f, -0.03688093f, 0.02708987f, 
    -0.00308734f, 0.02693812f, -0.00036689f, -0.04913678f, -0.05114487f, -0.04359735f, -0.05330819f, -0.03170506f, 
    0.30093530f, 0.13058414f, -0.13355109f, -0.17602524f, 0.05448124f, 0.11343984f, -0.13033395f, 0.07996869f, 
    -0.05612506f, -0.07446393f, -0.05336896f, -0.08598617f, -0.09036645f, 0.12520792f, 0.13847914f, 0.05085346f, 
    -0.01293828f, 0.09750187f, 0.00487502f, 0.00212914f, 0.03247784f, 0.05562975f, 0.09322608f, 0.10511584f, 
    -0.54080069f, 0.18352835f, 0.19277154f, -0.04405012f, 0.09970137f, -0.04270855f, -0.04726709f, -0.08493275f, 
    -0.00506397f, -0.04352232f, 0.04180047f, 0.10174906f, 0.11739086f, 0.13705994f, 0.05566403f, -0.01347967f, 
    0.13538720f, 0.01884452f, -0.21801491f, -0.16478914f, -0.15570523f, -0.12011836f, -0.02604717f, -0.19254103f, 
    0.05672028f, -0.03006581f, -0.13940021f, 0.12982619f, 0.08133011f, 0.01878862f, 0.08039081f, 0.04881813f, 
    -0.00471263f, -0.12136994f, 0.13097073f, 0.00077349f, 0.02401219f, 0.13505201f, -0.00803361f, -0.07870169f, 
    0.15494338f, 0.13723879f, 0.04158651f, 0.08751870f, 0.08772194f, -0.08984526f, 0.02596013f, 0.03734703f, 
    -0.21967652f, -0.02484664f, 0.03786269f, 0.11728259f, 0.05685728f, -0.20216505f, 0.12937312f, -0.03087711f, 
    0.09925381f, 0.10057586f, 0.07973523f, 0.07999026f, 0.23519672f, 0.18197115f, 0.01197189f, -0.03577670f, 
    0.07313299f, 0.00795202f, 0.00057475f, -0.02694595f, 0.16140462f, 0.00601627f, 0.02313326f, 0.09959587f, 
    -0.03661356f, -0.16590300f, 0.07364384f, 0.12378799f, 0.05420813f, -0.05870321f, 0.07158829f, -0.00806690f, 
    0.15976997f, -0.02877947f, -0.02409725f, 0.05247061f, -0.02005792f, 0.05324977f, -0.01042647f, 0.00440671f, 
    -0.13849056f, 0.07575868f, 0.07349882f, 0.06885739f, -0.00929207f, 0.06654682f, 0.00054130f, 0.02726667f, 
    -0.09584028f, 0.03309852f, 0.00393501f, 0.06631426f, 0.07928380f, -0.05134077f, 0.10574367f, 0.15699153f, 
    0.03276222f, -0.10794429f, -0.12889829f, -0.06271549f, -0.02296137f, -0.11918210f, -0.01514502f, 0.05119685f, 
    0.20362119f, 0.03652625f, 0.01757550f, -0.08566734f, 0.07571729f, -0.09407324f, -0.12968881f, -0.09126673f, 
    -0.05079605f, 0.08587576f, -0.10222929f, 0.03636920f, 0.05446236f, 0.04114178f, 0.12544799f, 0.07612573f, 
    -0.03861661f, -0.07524525f, 0.13308115f, -0.18942292f, -0.05089823f, -0.00449830f, 0.27621940f, -0.15850441f, 
    0.12630814f, -0.04172925f, -0.04775894f, 0.01559172f, -0.05717388f, 0.10870804f, -0.02524264f, 0.20487568f, 
    0.00450443f, -0.02308047f, -0.22430994f, 0.23089397f, 0.07050196f, 0.02655020f, -0.01211214f, 0.08523633f, 
    0.04798710f, -0.01535546f, -0.02948723f, 0.23045391f, 0.01492055f, -0.22850201f, -0.18621373f, -0.04058967f, 
    0.14436629f, 0.06982554f, 0.02379869f, 0.11925163f, -0.02177376f, 0.07893858f, 0.08323837f, 0.18379940f, 
    -0.05500309f, 0.03728376f, 0.11429232f, -0.05448426f, 0.08471379f, -0.06487972f, -0.02039636f, 0.12733828f, 
    0.01271793f, -0.02036202f, 0.06482948f, 0.20867808f, 0.21108815f, 0.01906237f, 0.14531861f, 0.09632017f, 
    0.13704887f, 0.04315422f, 0.01878629f, -0.01497868f, 0.05891249f, -0.04026902f, 0.16624257f, 0.05375000f, 
    0.04690643f, -0.16787633f, 0.01069543f, -0.09648009f, 0.16101116f, -0.15597124f, 0.10105003f, 0.02711858f, 
    0.00986848f, 0.13955449f, -0.12500726f, -0.02597801f, 0.12346909f, -0.00768695f, 0.01910945f, -0.11236476f, 
    0.04309768f, -0.01276541f, 0.09833749f, -0.17899853f, -0.00186076f, 0.12693205f, -0.01642067f, 0.16921997f, 
    0.26994574f, -0.11443356f, -0.02609491f, -0.16709366f, -0.01245860f, 0.06902519f, 0.03059529f, -0.08404251f, 
    0.02308138f, -0.06272754f, -0.16950423f, 0.07040478f, -0.38202456f, -0.21962006f, -0.01139611f, -0.09313212f, 
    0.05910095f, -0.10609686f, 0.12894200f, -0.00116095f, 0.08134776f, -0.04982191f, -0.05996147f, -0.14267917f, 
    0.02808964f, -0.23517582f, 0.12378380f, -0.01676950f, -0.03502260f, -0.07858667f, 0.03369856f, 0.10881505f, 
    -0.01008065f, 0.15207152f, 0.18095692f, 0.04144849f, 0.19462234f, 0.03140119f, 0.03145611f, -0.06026383f, 
    -0.06067428f, 0.06469656f, -0.04221404f, 0.03881765f, 0.19450194f, 0.14287819f, 0.00909179f, 0.11881407f, 
    0.05850384f, 0.07194846f, -0.02693132f, -0.16165167f, -0.01637224f, -0.13128768f, -0.06337446f, -0.00896833f, 
    -0.07792703f, -0.04808442f, 0.07863456f, -0.03606090f, 0.11851306f, -0.02412450f, -0.16340974f, 0.13828006f, 
    0.01196786f, -0.17384291f, -0.17522410f, 0.02742899f, 0.06423476f, 0.10213854f, 0.03867847f, 0.02037313f, 
    -0.15161587f, 0.05967768f, 0.01389000f, 0.06832197f, 0.07547846f, 0.04046537f, 0.11526694f, 0.00023613f, 
    -0.08636492f, 0.18969437f, -0.03941818f, -0.13130870f, -0.18981531f, 0.16381080f, 0.06786285f, 0.05682034f, 
    0.09305031f, 0.15833431f, 0.02369376f, -0.09851457f, -0.00401120f, -0.09419642f, -0.08868208f, -0.17278978f, 
    -0.29849714f, 0.08731989f, -0.17662270f, -0.09710260f, -0.07807165f, -0.03567962f, -0.02367759f, -0.10457892f, 
    0.05077890f, 0.07665805f, 0.11029578f, 0.05252269f, 0.00770821f, 0.10353283f, 0.09644488f, 0.02477177f, 
    0.10819805f, 0.03161179f, 0.04174827f, -0.02571001f, -0.04020311f, -0.00650233f, -0.04100648f, 0.28763616f, 
    0.09864030f, 0.00439605f, 0.03454755f, -0.04327147f, 0.03635288f, 0.08257552f, 0.03666336f, -0.04670587f, 
    -0.05267594f, -0.00377416f, -0.06660125f, 0.03099540f, -0.17167088f, -0.02498201f, -0.00133629f, 0.20326306f, 
    0.05169579f, -0.10642748f, -0.04948159f, 0.00883320f, 0.01213328f, 0.09095106f, -0.01384849f, 0.05147132f, 
    0.15853940f, 0.10861789f, 0.14189728f, -0.04197685f, 0.09793304f, 0.07161321f, -0.04118302f, 0.07565120f, 
    0.06826195f, 0.03394884f, -0.00048484f, 0.03090494f, 0.28218007f, 0.24688320f, -0.08112575f, -0.24484859f, 
    0.12615004f, 0.08798746f, -0.01276391f, -0.09056609f, 0.01147969f, -0.03540519f, 0.00535955f, 0.02897343f, 
    0.01215502f, 0.12050934f, 0.01529655f, -0.18945000f, -0.10301141f, -0.06625552f, 0.00760484f, -0.04446167f, 
    0.07295551f, 0.02239273f, 0.11763864f, 0.12618388f, 0.11062816f, 0.19335979f, 0.05767768f, -0.10821581f, 
    0.17578727f, -0.02141208f, -0.05045460f, -0.07631604f, 0.04070534f, 0.09281652f, -0.04566849f, 0.03790072f, 
    -0.17887855f, -0.11252552f, -0.03698430f, -0.12630907f, 0.03982149f, 0.07909953f, 0.09283652f, 0.01711676f, 
    -0.05360122f, -0.00172792f, 0.00919927f, -0.11685779f, 0.10911938f, 0.10842273f, 0.00695809f, 0.11054903f, 
    -0.04490683f, 0.07372539f, -0.01156104f, 0.10929792f, 0.00619123f, -0.03500687f, 0.00751396f, 0.06822083f, 
    0.19200955f, 0.06046559f, 0.07678135f, -0.04043729f, 0.02355733f, -0.08562779f, -0.09960802f, -0.01696265f, 
    -0.10793222f, 0.05755414f, -0.02892866f, -0.00010666f, 0.49593899f, -0.18889055f, 0.01005341f, 0.18178028f, 
    0.02672566f, 0.05834755f, 0.09841502f, 0.00870275f, -0.01724069f, 0.05058263f, 0.04337417f, 0.04077084f, 
    -0.28938076f, 0.33604249f, 0.08643895f, -0.07793009f, 0.02725392f, 0.03341976f, 0.02270354f, -0.05830728f, 
    -0.08019550f, 0.00421484f, -0.09800373f, 0.00460092f, 0.07485190f, -0.00094262f, 0.03301721f, 0.11652330f, 
    -0.03778433f, -0.04685533f, 0.06274216f, -0.03431822f, 0.05721939f, 0.06597534f, -0.00989805f, 0.05223491f, 
    0.02459314f, -0.20943671f, -0.00066648f, -0.04935129f, 0.04174170f, 0.01961730f, 0.03560485f, -0.02071746f, 
    -0.02242198f, 0.05716268f, 0.16270638f, 0.02591247f, 0.10234676f, -0.26537168f, -0.00012225f, -0.00953060f, 
    -0.03034909f, -0.01163882f, 0.02218457f, 0.02360994f, 0.03260953f, 0.12455675f, 0.05951494f, -0.15417524f, 
    -0.15819223f, -0.03729550f, 0.08027778f, 0.08260586f, 0.11530990f, -0.01060396f, -0.07436925f, -0.01611949f, 
    -0.00858850f, -0.01052344f, 0.05332790f, 0.04931822f, -0.09250186f, 0.24205667f, 0.13663548f, -0.04185092f, 
    0.12344986f, 0.06615993f, -0.06616622f, 0.02145091f, 0.00032322f, -0.12918252f, 0.04898645f, -0.00674021f, 
    -0.02850481f, 0.11486691f, -0.13745497f, -0.01213038f, 0.05640468f, 0.08832221f, 0.03258310f, 0.02636863f, 
    -0.04913662f, 0.12810843f, 0.16485460f, 0.03520708f, -0.13114472f, 0.01430595f, 0.13551550f, -0.03542637f, 
    0.05722931f, 0.16583137f, 0.03667716f, -0.08088361f, -0.00689438f, 0.02464997f, 0.06010398f, -0.15774696f, 
    -0.07440266f, 0.12872544f, 0.11650851f, -0.38341245f, 0.05332437f, -0.07263835f, 0.01875231f, 0.08735918f, 
    0.06859480f, 0.04539960f, 0.02560882f, 0.02603776f, 0.00388847f, 0.21810323f, -0.01789991f, -0.13604210f, 
    0.04874709f, 0.06770159f, 0.08134857f, 0.05615453f, -0.11517604f, 0.15223196f, 0.04462035f, -0.20794317f, 
    -0.03117735f, 0.16279738f, 0.18838680f, 0.08163934f, 0.12098760f, 0.01462546f, -0.01074812f, -0.11174365f, 
    0.03742602f, 0.00086426f, 0.07364908f, -0.07809196f, -0.21288037f, -0.01001097f, -0.12871706f, 0.03264162f, 
    0.01124538f, 0.04634258f, 0.06112637f, 0.12650737f, 0.01225223f, 0.08045025f, -0.02779341f, 0.09645297f, 
    -0.06295287f, 0.18520795f, -0.02943136f, 0.06090041f, 0.05299549f, 0.00580520f, 0.09933389f, 0.17896773f, 
    0.14648896f, 0.03036619f, 0.01915153f, -0.02283633f, -0.45573246f, -0.36714655f, 0.06673035f, 0.02833541f, 
    0.06751822f, 0.07593635f, 0.01269893f, -0.05119580f, 0.01302416f, 0.09684002f, 0.09550560f, 0.03978235f, 
    -0.37538156f, 0.20749995f, -0.26713201f, -0.23992805f, 0.03977782f, -0.09815212f, -0.02350415f, 0.05307251f, 
    0.00725186f, 0.10835285f, 0.00738799f, 0.00970547f, 0.11458330f, 0.04729940f, -0.07377376f, 0.01459728f, 
    0.15067023f, 0.18904053f, 0.10199331f, -0.04812959f, -0.04208586f, 0.03174838f, -0.03009690f, 0.02546770f, 
    0.07070062f, 0.01279613f, -0.24771298f, -0.20470218f, -0.03528110f, -0.13072860f, -0.06942263f, 0.02591125f, 
    0.15107863f, 0.01442520f, 0.04618520f, 0.07937720f, 0.03921118f, 0.12081776f, -0.06176188f, 0.06956193f, 
    0.06053878f, -0.05919152f, -0.08654789f, 0.09699596f, -0.04597836f, 0.04605324f, -0.09441152f, 0.02690207f, 
    0.00206212f, -0.07551766f, 0.21235134f, 0.02171746f, -0.01411952f, -0.05373225f, 0.02655252f, -0.15311754f, 
    -0.04187927f, 0.11839135f, 0.01223036f, 0.01525169f, -0.16156772f, -0.13291298f, 0.17372301f, -0.10612660f, 
    0.05146891f, 0.02397998f, -0.03440289f, -0.13556099f, -0.05078789f, -0.02676899f, 0.07028011f, 0.15538868f, 
    0.48606777f, -0.21500632f, 0.04670892f, 0.15206027f, -0.00159167f, 0.07601916f, 0.01584145f, -0.04177551f, 
    0.00389351f, -0.02087605f, 0.05138775f, -0.00378992f, 0.16026109f, 0.00319077f, 0.11280604f, -0.05666747f, 
    -0.00902306f, 0.06053915f, -0.15484811f, -0.02188224f, -0.03109884f, 0.02105286f, -0.05661222f, -0.02288815f, 
    0.19461578f, -0.00712261f, 0.19174515f, 0.04881627f, 0.08813705f, -0.03871213f, 0.04617414f, 0.08464129f, 
    0.04953917f, -0.00045755f, 0.01606432f, 0.05612732f, 0.29492414f, 0.10141748f, 0.07924718f, -0.21265146f, 
    0.04006589f, -0.05691752f, -0.04917178f, 0.05256326f, -0.03490888f, -0.14648429f, 0.00873913f, 0.03679510f, 
    0.00741187f, 0.03746652f, -0.03130938f, -0.01164822f, -0.05224363f, -0.02491495f, -0.05187431f, 0.04126687f, 
    -0.03644694f, 0.03305677f, -0.02594172f, -0.04724938f, -0.01515881f, 0.03679615f, -0.02877888f, 0.00115795f, 
    -0.00258268f, -0.03918097f, 0.02354374f, -0.01675121f, -0.02589571f, -0.00520413f, 0.01091866f, -0.01095318f, 
    0.00654284f, -0.01575686f, 0.01273983f, -0.05471439f, -0.00578341f, -0.02295078f, 0.00450289f, 0.02266843f, 
    0.01463717f, -0.03626023f, 0.03617919f, -0.00654306f, 0.00731497f, -0.02341359f, -0.01313193f, -0.03059491f, 
    -0.01018308f, -0.00725855f, -0.01609023f, 0.04347455f, -0.03384423f, -0.00458223f, 0.00670389f, 0.01053874f, 
    -0.00558653f, -0.01272221f, 0.02465605f, 0.01661143f, -0.02431166f, 0.04004231f, -0.02381933f, 0.03929763f, 
    -0.00884765f, -0.01424842f, -0.05074381f, 0.00012447f, 0.00967497f, 0.00830465f, -0.02776662f, -0.04442204f, 
    0.02289759f, -0.04786773f, -0.02677521f, -0.05613146f, 0.02187094f, -0.00109548f, -0.02266004f, 0.03017590f, 
    0.01480236f, -0.02856940f, 0.01540010f, 0.00919547f, -0.01928729f, -0.05156495f, -0.02709502f, -0.02969597f, 
    -0.02116979f, 0.01090415f, 0.01985391f, -0.04869141f, -0.03407638f, 0.01542451f, -0.00268001f, -0.02364851f, 
    -0.02608946f, -0.00820541f, -0.04542270f, 0.02113516f, -0.05497692f, 0.02841503f, -0.03136140f, -0.00312980f, 
    -0.02870884f, -0.05057875f, -0.02154415f, -0.01082928f, -0.01917965f, -0.01058883f, -0.05014683f, -0.03847420f, 
    0.00787074f, 0.02327628f, 0.01412953f, 0.00332673f, 0.03831617f, -0.01194612f, 0.00418364f, 0.03669277f, 
    -0.02678408f, 0.03445196f, 0.02341558f, 0.03631835f, 0.00775044f, -0.04779407f, -0.02204987f, 0.00901191f, 
    0.03347495f, 0.01436652f, 0.00877201f, 0.01138990f, -0.04172588f, -0.01254307f, -0.04396527f, 0.00029085f, 
    -0.03443922f, 0.00923952f, -0.00713103f, -0.02965338f, -0.00155158f, -0.00280308f, 0.01697889f, -0.02681170f, 
    0.03101064f, -0.05302128f, -0.01074657f, 0.03987154f, 0.01885519f, -0.03969904f, -0.01195605f, -0.01765590f, 
    -0.03471996f, -0.04370035f, -0.03654040f, 0.04275012f, -0.04941448f, -0.00193250f, -0.03217931f, -0.05271753f, 
    0.00586321f, -0.01117455f, 0.03583409f, 0.01023416f, -0.00579363f, 0.00408783f, 0.00167612f, 0.03694063f, 
    -0.02469517f, -0.00287893f, -0.04729258f, 0.00761868f, 0.00389128f, -0.00012960f, 0.03006666f, 0.00469526f, 
    0.01180467f, 0.02836294f, 0.01618377f, 0.03302621f, -0.03358327f, 0.01271948f, 0.00683844f, 0.02625983f, 
    0.03976493f, 0.04433294f, 0.01856322f, -0.04171112f, -0.02693301f, -0.04941275f, -0.02100458f, -0.02967597f, 
    0.02741423f, -0.03337992f, 0.00103534f, 0.03233173f, -0.00949574f, 0.00325019f, 0.00938175f, 0.01046680f, 
    0.03109699f, -0.04791700f, -0.05048424f, -0.05068168f, -0.03288034f, -0.04831313f, 0.03313072f, -0.04791362f, 
    0.01498391f, 0.02797097f, 0.00110650f, 0.04530837f, -0.00671264f, -0.05122450f, -0.00438283f, -0.01965795f, 
    -0.03947283f, -0.04640668f, 0.00179600f, -0.01874005f, 0.00631074f, -0.00510581f, 0.00709928f, -0.03627240f, 
    0.02929961f, 0.03805112f, -0.04868432f, 0.00582030f, 0.02499984f, 0.00685450f, -0.00626416f, -0.01865202f, 
    0.01328562f, -0.03904759f, 0.02234503f, -0.02532884f, 0.03099124f, -0.04174864f, -0.02416612f, -0.05443221f, 
    0.00450079f, -0.05613433f, -0.03473793f, -0.00339206f, -0.01498665f, 0.02776506f, -0.03550628f, -0.01448851f, 
    -0.00858479f, 0.02228704f, -0.00234681f, -0.01075656f, -0.02617619f, 0.02155903f, -0.04076345f, 0.01947161f, 
    -0.05095439f, -0.01896655f, 0.01007650f, 0.00841630f, -0.02767207f, 0.01124251f, 0.00676990f, -0.05536816f, 
    -0.04937438f, 0.04598948f, 0.02620351f, 0.01492051f, -0.05429158f, -0.00242519f, 0.02910364f, 0.02436903f, 
    0.04283040f, 0.02849660f, -0.04782549f, -0.03989824f, 0.02073166f, -0.00163597f, 0.03863549f, -0.00545403f, 
    -0.05589643f, -0.04754158f, -0.04179309f, 0.00487607f, -0.02447798f, -0.00884026f, -0.04114759f, -0.03024686f, 
    -0.02053525f, 0.01737732f, -0.05053129f, 0.02549914f, -0.02777702f, 0.00191299f, -0.04638964f, -0.00260645f, 
    -0.00542993f, -0.03691341f, 0.02067294f, 0.02695718f, -0.05178487f, 0.03884402f, -0.01113532f, -0.04002118f, 
    -0.01213738f, -0.01196736f, -0.04828984f, 0.02817487f, -0.01727811f, -0.00672616f, 0.00427778f, -0.02624718f, 
    -0.01630335f, -0.03100771f, 0.02338550f, -0.04899478f, 0.01672234f, 0.01998152f, 0.03253673f, -0.04165756f, 
    -0.00290747f, 0.03575731f, 0.01471166f, 0.03467968f, -0.04664358f, -0.03081724f, 0.04182952f, -0.02508115f, 
    0.00462506f, -0.00258518f, -0.02238984f, -0.00579734f, 0.01566333f, -0.03845387f, 0.03166185f, -0.00870105f, 
    0.03286381f, 0.00296702f, 0.02768677f, -0.04864221f, -0.01451672f, 0.00160033f, 0.03389181f, 0.03286501f, 
    -0.04659035f, 0.00186115f, -0.00051564f, -0.00533059f, -0.02432873f, 0.03300925f, -0.04000184f, -0.00813637f, 
    -0.00769124f, -0.04960653f, 0.00339728f, -0.02677425f, -0.02550023f, 0.03168816f, -0.03240636f, 0.03421753f, 
    -0.01680654f, 0.03697430f, -0.01355391f, -0.03128904f, -0.03663795f, -0.02432856f, -0.05027262f, -0.00761556f, 
    -0.00951886f, -0.03054858f, 0.04450186f, -0.01107800f, 0.00728781f, -0.00673780f, 0.00467323f, 0.01105362f, 
    0.04306423f, -0.03910164f, 0.00705665f, -0.05072606f, -0.04331428f, -0.04462139f, 0.01326224f, -0.05329204f, 
    0.01407981f, 0.02738196f, 0.02585184f, 0.02791050f, -0.04962014f, 0.04344777f, -0.05080935f, -0.03505966f, 
    0.06053811f, 0.08450303f, 0.18593548f, -0.21124648f, 0.08766259f, -0.06535551f, 0.13661160f, 0.06417308f, 
    -0.12881376f, 0.04310295f, 0.00012384f, 0.23903522f, -0.27812666f, 0.13329609f, 0.08417565f, -0.05527489f, 
    0.01034966f, -0.08765451f, -0.22536923f, -0.05430034f, -0.02473115f, -0.10510321f, -0.07774843f, -0.11841535f, 
    -0.02360607f, 0.23680806f, 0.17810303f, -0.38976318f, 0.09286790f, -0.07299042f, 0.11550499f, -0.14123529f, 
    -0.01113572f, 0.04697252f, 0.00787382f, 0.10237515f, -0.15029970f, 0.01437240f, -0.07929033f, 0.09288327f, 
    0.02808371f, -0.00091216f, 0.01086136f, -0.05208966f, -0.02398668f, 0.08335803f, 0.13169789f, 0.04521169f, 
    0.21846657f, -0.18333846f, 0.11698809f, 0.35930216f, 0.09793815f, 0.02877328f, -0.13329107f, -0.00175205f, 
    -0.02234737f, 0.20751669f, -0.08564845f, 0.01293896f, 0.00355478f, 0.03044410f, -0.00744359f, 0.23800790f, 
    0.09933373f, -0.10744233f, 0.18441541f, -0.00606532f, 0.03169959f, -0.03484092f, 0.12662885f, 0.02399573f, 
    0.13598108f, 0.00860504f, -0.01158437f, -0.16446878f, 0.11333577f, -0.08179595f, -0.09167751f, -0.03194150f, 
    0.03599208f, -0.02379727f, -0.12609442f, 0.12370557f, 0.17017846f, 0.09232777f, 0.21699110f, -0.23620342f, 
    0.10801245f, 0.13015282f, 0.01222683f, 0.01138039f, 0.08829782f, -0.09626210f, -0.06644046f, 0.14568107f, 
    -0.20209974f, 0.16980246f, -0.01947132f, -0.04557185f, -0.04726231f, 0.03796715f, -0.04727211f, -0.08249541f, 
    -0.07044142f, -0.16589166f, 0.03809356f, -0.03302979f, -0.33076429f, 0.30015695f, -0.05249429f, -0.23447159f, 
    0.09967476f, -0.09548491f, 0.00996443f, 0.04852618f, 0.15096547f, -0.04979553f, -0.04363188f, -0.01947444f, 
    0.32233268f, -0.19453302f, 0.09527896f, 0.38451031f, 0.03637147f, 0.05521927f, 0.02255341f, 0.06292346f, 
    -0.09939082f, 0.18805212f, 0.18454051f, 0.08617101f, 0.12720835f, 0.12507349f, 0.14462292f, -0.08714954f, 
    0.04506441f, 0.00365678f, 0.07389805f, 0.09804006f, 0.04984232f, -0.00364447f, 0.03211426f, -0.02480028f, 
    -0.22205822f, 0.05606598f, 0.04539636f, -0.02746927f, 0.10475852f, 0.03409315f, -0.02916434f, 0.15348059f, 
    -0.07723534f, 0.08891167f, 0.06578674f, 0.09981187f, 0.05889453f, 0.04382630f, 0.22450282f, 0.00704125f, 
    -0.03092977f, 0.01696833f, -0.00083586f, 0.00478394f, -0.02206801f, 0.01427621f, 0.03317250f, -0.05417989f, 
    -0.04847011f, -0.14110796f, 0.00090913f, 0.17614871f, -0.04361227f, -0.11592618f, -0.05807848f, 0.02304669f, 
    -0.02104864f, 0.06498256f, 0.08553826f, -0.03971036f, -0.17730148f, -0.29300350f, 0.05635478f, 0.12776542f, 
    -0.00258840f, -0.04753882f, -0.05736463f, -0.01271657f, 0.03256305f, 0.02714834f, -0.01746488f, -0.01375450f, 
    -0.01262533f, -0.38829654f, 0.06863321f, 0.22411053f, -0.00933706f, 0.03594906f, 0.01140073f, -0.21176763f, 
    -0.05377943f, -0.01886057f, 0.10576695f, -0.00112679f, -0.06246854f, 0.11651944f, -0.09738364f, -0.06362884f, 
    0.09222638f, -0.10261174f, 0.01536415f, 0.10023952f, -0.05382266f, 0.05733554f, -0.14846748f, -0.00751825f, 
    -0.13383697f, 0.08838910f, 0.10578217f, -0.02311319f, 0.01419769f, 0.11187500f, 0.05379866f, -0.02837083f, 
    0.07540505f, -0.05925039f, 0.15080820f, 0.02436463f, -0.07357744f, 0.04812247f, 0.09636399f, 0.19245729f, 
    0.02362964f, 0.02383796f, -0.16753720f, 0.07679910f, 0.06172528f, -0.06057470f, -0.01242188f, -0.01234587f, 
    0.00808747f, 0.31968141f, -0.25049061f, -0.05939605f, 0.01782394f, 0.15432684f, 0.09827381f, -0.00706320f, 
    -0.04445517f, 0.04964842f, -0.00023661f, -0.05497121f, 0.21464875f, -0.08550209f, 0.15133335f, 0.00199242f, 
    0.09389812f, 0.01194369f, 0.02746131f, 0.02278755f, 0.10359405f, -0.06265078f, 0.07335719f, 0.02635458f, 
    0.07969740f, 0.39010128f, -0.14507122f, 0.08977346f, -0.01391729f, 0.10521600f, 0.01315469f, 0.05953749f, 
    -0.04480799f, 0.01251950f, 0.03956874f, -0.02494337f, 0.02583566f, -0.21646820f, -0.14101888f, -0.10157295f, 
    -0.01490770f, -0.07053201f, -0.06190858f, -0.14960183f, -0.04110480f, -0.11543547f, -0.08131925f, -0.02697092f, 
    0.04161850f, -0.00735911f, -0.14635794f, -0.03499698f, 0.00752854f, 0.02224397f, -0.06874702f, -0.20214847f, 
    0.04646246f, 0.05950830f, -0.04899599f, -0.04877168f, 0.12897727f, -0.04985962f, -0.17337494f, 0.32856575f, 
    0.04939790f, -0.13941333f, -0.03452638f, -0.25351033f, 0.11383650f, 0.02894061f, 0.18661602f, -0.02332302f, 
    -0.05591847f, 0.07957796f, -0.00713125f, -0.16701199f, 0.11214099f, -0.01636348f, -0.09575622f, 0.08025451f, 
    -0.12412687f, 0.06031404f, 0.07523105f, 0.03397113f, -0.15501451f, 0.11497837f, 0.01962999f, 0.10816431f, 
    0.05448263f, -0.13012214f, -0.22406846f, -0.00174217f, -0.04362683f, -0.15332446f, 0.14886524f, 0.14235938f, 
    -0.09194612f, 0.03285630f, 0.19300380f, 0.11163723f, 0.06492592f, 0.00094512f, -0.05225906f, 0.07903963f, 
    -0.02231876f, 0.06051120f, 0.01986998f, -0.00506990f, -0.19160128f, 0.01491233f, 0.17661296f, -0.18746482f, 
    0.05369485f, -0.06125718f, -0.13610718f, 0.00635225f, 0.08910245f, -0.14762756f, -0.00869276f, -0.03616808f, 
    0.27324414f, -0.09450737f, -0.04337153f, 0.18219867f, 0.10122289f, 0.18263593f, 0.03083534f, 0.14275616f, 
    0.03631951f, 0.09347188f, 0.03187037f, 0.05100973f, 0.27508259f, -0.22828849f, -0.18110116f, 0.19513597f, 
    0.00912775f, 0.02811269f, -0.05150344f, -0.24860124f, 0.06445979f, 0.07398997f, 0.00880747f, 0.00077593f, 
    -0.03294729f, 0.01174173f, -0.02908022f, -0.03818630f, -0.03068061f, 0.03344322f, 0.01590746f, -0.03291387f, 
    -0.04084511f, 0.00089336f, -0.05828517f, 0.02411723f, -0.02933365f, -0.05614299f, 0.00112520f, -0.04828350f, 
    -0.01924103f, -0.03760865f, -0.03130041f, 0.00442344f, -0.03515087f, -0.02524771f, -0.01676589f, -0.00378286f, 
    -0.04160670f, -0.00872794f, -0.01325146f, -0.01314589f, 0.03590482f, 0.00643006f, -0.03505902f, -0.02703464f, 
    -0.01485085f, 0.00183994f, 0.00014975f, 0.03181949f, -0.03437696f, -0.02879249f, -0.02382912f, -0.00391877f, 
    0.01150308f, 0.00574813f, -0.03158609f, -0.02345338f, -0.05496294f, -0.03767072f, 0.04960702f, -0.01829594f, 
    -0.03335771f, -0.01105033f, 0.02381747f, -0.01413721f, 0.02391378f, 0.01909492f, 0.00867598f, 0.02583663f, 
    -0.00329947f, -0.01995219f, -0.01338125f, -0.05371339f, -0.01831003f, 0.02047298f, 0.03807346f, 0.04253563f, 
    -0.03716914f, -0.02954968f, -0.04619098f, -0.02309209f, -0.01720892f, -0.02328637f, 0.01807701f, 0.00232510f, 
    -0.01741177f, 0.02327756f, 0.01801885f, 0.02634013f, -0.03747027f, -0.04806894f, -0.03915291f, -0.05237788f, 
    0.05236385f, 0.03450237f, -0.00014148f, 0.01923519f, 0.00389426f, -0.02508568f, 0.02229531f, -0.01272981f, 
    0.04708866f, 0.00133266f, -0.03118801f, -0.02781114f, -0.05027820f, -0.03624165f, 0.03153301f, -0.04691706f, 
    0.03440431f, 0.01687519f, -0.04162182f, 0.02624274f, -0.04478420f, 0.04794405f, 0.01049355f, -0.03685980f, 
    0.01349171f, 0.03425787f, -0.03525134f, -0.00869802f, -0.00118084f, -0.01154677f, 0.03976911f, 0.01782068f, 
    -0.03935701f, 0.02230198f, -0.03286278f, 0.05264031f, -0.05515004f, 0.03695410f, 0.01764835f, -0.01120886f, 
    0.02676106f, -0.03353754f, -0.03866610f, 0.01754786f, -0.04065506f, -0.01402851f, -0.03265123f, -0.02085838f, 
    -0.02913968f, 0.03693435f, 0.02534818f, 0.03565165f, 0.03004166f, 0.00011971f, -0.00065958f, -0.05789925f, 
    -0.04413506f, -0.03464409f, 0.00061774f, 0.01047412f, 0.02859639f, -0.04226561f, 0.02486922f, 0.01816732f, 
    -0.05525192f, -0.02995338f, 0.04655740f, 0.02786559f, 0.01623249f, -0.01161561f, 0.00495187f, -0.00267495f, 
    0.02121200f, -0.02322527f, 0.04375994f, 0.01305946f, -0.02782850f, -0.04465791f, 0.03016810f, -0.01700887f, 
    -0.03678491f, -0.03376538f, 0.02479025f, -0.04251031f, 0.03156127f, -0.00952140f, -0.06137680f, -0.03808452f, 
    0.00277045f, -0.03229566f, -0.04848495f, 0.01668884f, 0.05498858f, 0.01177553f, 0.02237222f, -0.02562399f, 
    -0.04094204f, 0.00910089f, 0.03476891f, -0.03433772f, 0.04331460f, 0.00395891f, -0.04809756f, 0.00918493f, 
    -0.05673321f, -0.00695580f, -0.03206749f, -0.03513845f, 0.04114687f, 0.03634912f, 0.01877910f, -0.02209126f, 
    -0.00822155f, -0.04850001f, 0.03543090f, 0.02049884f, -0.04401877f, 0.02022648f, -0.00464094f, -0.00634473f, 
    -0.01889511f, -0.00941718f, -0.02091834f, -0.04774254f, -0.00138524f, -0.01284260f, 0.03762141f, 0.01828713f, 
    -0.01777538f, 0.04105600f, 0.04227463f, -0.04767345f, -0.03954667f, 0.03097637f, -0.02234912f, 0.04183309f, 
    0.03344741f, -0.00153719f, -0.03886985f, 0.03221360f, 0.01568640f, -0.02812619f, -0.00073911f, -0.03796095f, 
    -0.01101812f, -0.05262564f, 0.04204094f, -0.03679197f, -0.01389057f, 0.03764437f, -0.03217930f, 0.01586824f, 
    0.00710869f, 0.00386669f, 0.00540416f, -0.04473219f, -0.04913782f, -0.01085833f, 0.00190843f, -0.01399516f, 
    0.00809479f, 0.05068271f, 0.04798936f, 0.03684696f, 0.00060213f, -0.01167721f, 0.02069050f, 0.02715086f, 
    -0.02914703f, -0.01530452f, 0.00492806f, -0.05178401f, -0.00298341f, -0.02874406f, 0.02850265f, -0.04286992f, 
    0.00068066f, -0.04029702f, -0.00108881f, -0.01939104f, -0.01824397f, 0.01649648f, 0.00442317f, -0.02014066f, 
    0.00117895f, 0.00523343f, -0.01382903f, 0.03473597f, 0.01485278f, -0.05176679f, -0.04252512f, 0.00546464f, 
    -0.03743232f, -0.02109292f, -0.03139625f, -0.03362015f, -0.02936536f, -0.01826319f, 0.03055420f, -0.04003803f, 
    0.00460889f, 0.04711161f, -0.00388737f, 0.03857625f, 0.00902643f, -0.05668484f, -0.01544494f, -0.02825688f, 
    -0.01856934f, 0.00738239f, -0.02864805f, -0.01740961f, 0.01608434f, -0.03232579f, -0.03854481f, 0.02576857f, 
    0.02117887f, 0.04136548f, -0.04581351f, -0.04705842f, 0.03736558f, 0.03704679f, 0.00892865f, -0.04982730f, 
    -0.03229367f, 0.03781022f, -0.02174281f, 0.02099022f, -0.01062188f, -0.01276413f, -0.01832303f, 0.02165510f, 
    0.02354649f, 0.01565066f, 0.01912469f, 0.03080564f, -0.00458242f, -0.04135017f, 0.04094064f, -0.04524049f, 
    0.01166760f, -0.03839435f, -0.04193093f, 0.04124508f, 0.04361534f, -0.03209618f, 0.01747722f, 0.02251817f, 
    -0.02087668f, 0.00850212f, -0.02712834f, -0.02498812f, -0.02752874f, -0.03899389f, 0.04471480f, -0.00603500f, 
    -0.02881037f, -0.02000824f, 0.04654316f, 0.01271172f, -0.04332749f, 0.00549566f, -0.03619295f, 0.04770006f, 
    0.02481591f, -0.02272666f, 0.01247162f, -0.04832688f, 0.01534457f, -0.00851425f, 0.02988390f, 0.03615006f, 
    -0.02760836f, 0.03909603f, 0.04259877f, 0.02931547f, 0.01923792f, -0.03915891f, 0.03564885f, -0.03456414f, 
    -0.03314344f, -0.00854503f, 0.03160613f, 0.01951127f, -0.00967729f, 0.02828903f, 0.00109711f, -0.00870892f, 
    -0.02287843f, 0.03650990f, 0.00005317f, 0.02317019f, 0.01628267f, -0.03542125f, -0.05364588f, -0.04348341f, 
    -0.05422218f, 0.02085162f, 0.01193190f, -0.02616604f, 0.01205549f, -0.03803939f, -0.01440312f, 0.01558827f, 
    0.07700253f, 0.01309933f, 0.01282962f, 0.03581324f, -0.08235370f, 0.07340829f, -0.09919142f, 0.03715257f, 
    0.00491871f, -0.00081620f, 0.03140210f, -0.07146058f, 0.02477569f, -0.10069162f, 0.04321202f, 0.25194576f, 
    0.09101793f, 0.01023763f, 0.07107738f, -0.14471485f, 0.05363607f, 0.00564953f, 0.14786969f, 0.11699726f, 
    0.31463817f, -0.11492568f, -0.09589618f, 0.01023591f, 0.10440107f, -0.00018615f, -0.08000914f, 0.03798125f, 
    0.02505047f, -0.02573618f, -0.09813233f, -0.00839706f, 0.26987231f, -0.04108605f, 0.03212760f, -0.04895307f, 
    0.17845318f, -0.02590777f, -0.11724362f, -0.12174793f, -0.05335683f, -0.02403763f, -0.04378318f, -0.03544333f, 
    0.14866674f, 0.06535753f, 0.16339329f, 0.05636587f, 0.09581507f, 0.09787621f, 0.02519345f, -0.06730847f, 
    0.00338527f, -0.13024007f, 0.05266698f, 0.03541299f, 0.13098980f, 0.15927054f, 0.11851462f, -0.00605230f, 
    0.05487944f, -0.04566628f, -0.07047535f, 0.04400832f, 0.00564069f, 0.00411870f, 0.04372578f, -0.03047525f, 
    0.18097007f, 0.08067689f, 0.14458741f, 0.09807363f, -0.02045751f, -0.05755990f, 0.01534790f, 0.01459651f, 
    0.16556008f, 0.08005422f, -0.04124479f, 0.11999033f, -0.30892345f, 0.12036216f, 0.01330043f, 0.18649283f, 
    0.04179579f, -0.01132329f, 0.14691561f, -0.00282720f, -0.03914199f, 0.03713109f, 0.08036607f, -0.01558483f, 
    0.08831015f, -0.16718806f, -0.03700526f, 0.09832875f, 0.05968041f, -0.05540197f, -0.03982642f, -0.15708129f, 
    0.04898158f, -0.07341743f, 0.00217514f, 0.08464197f, 0.03182473f, 0.10641901f, 0.09605834f, -0.14145355f, 
    -0.08326323f, 0.06561975f, -0.09362263f, 0.03982834f, -0.12143542f, -0.05428092f, -0.06391925f, 0.13560748f, 
    0.11592007f, 0.03271947f, 0.08331268f, 0.07687869f, 0.09615302f, 0.04974851f, 0.05901067f, -0.01272380f, 
    -0.06475989f, -0.07109042f, -0.02435886f, -0.13006802f, -0.21854033f, 0.15278995f, 0.08646531f, 0.22307961f, 
    0.20117664f, -0.03909925f, 0.03724490f, 0.06075096f, -0.05040307f, -0.09162219f, -0.07736239f, 0.06441296f, 
    -0.05462949f, 0.05052159f, 0.04102386f, 0.14675099f, 0.02235908f, 0.00365666f, 0.20420152f, 0.04234209f, 
    -0.02953878f, -0.02569015f, -0.05112350f, -0.10790109f, 0.01820570f, 0.20420232f, -0.10950799f, 0.06800113f, 
    0.01687882f, -0.12813620f, -0.09398270f, -0.09371928f, -0.01143822f, 0.14838639f, -0.11634345f, -0.00261112f, 
    -0.06194060f, 0.02402204f, 0.09295521f, -0.17564511f, 0.18083774f, -0.02851633f, 0.03111332f, -0.06030580f, 
    -0.02599537f, 0.00574430f, -0.11819216f, 0.22085184f, 0.30759168f, 0.18528971f, 0.14162625f, -0.04504054f, 
    0.03881192f, 0.00643591f, -0.02564184f, -0.07636493f, 0.00950665f, 0.15286423f, 0.05737494f, 0.03923489f, 
    -0.08083288f, -0.07543152f, -0.24198084f, -0.02789625f, 0.10993865f, -0.04210103f, -0.03836747f, 0.00000250f, 
    0.12151945f, 0.01198437f, 0.01346013f, 0.09885405f, -0.06839360f, 0.00021310f, 0.04512157f, 0.03681823f, 
    0.14382733f, 0.03789538f, -0.06086561f, -0.15486972f, -0.01139635f, -0.15989210f, 0.05638116f, -0.04659819f, 
    0.17122735f, 0.21662457f, 0.02684558f, 0.03241372f, 0.03817737f, -0.18870929f, -0.08119360f, 0.06512620f, 
    0.00693648f, 0.02780887f, -0.22957298f, -0.03729257f, 0.11652419f, 0.09755769f, -0.10046651f, 0.29543105f, 
    0.01828810f, -0.14467676f, -0.02839134f, -0.03567515f, -0.08078440f, 0.21048960f, 0.01051739f, 0.18472959f, 
    0.18230455f, -0.05213336f, 0.03016409f, 0.07867054f, -0.01922296f, 0.04404142f, -0.01351571f, 0.06630252f, 
    0.00489847f, 0.01541590f, -0.13910204f, 0.09211951f, -0.31161839f, 0.14495975f, -0.01964977f, -0.01527102f, 
    0.13166921f, -0.00937702f, 0.00318752f, 0.08597071f, 0.04560398f, -0.01216071f, 0.05347721f, -0.08893266f, 
    -0.35208684f, 0.01690031f, 0.17543162f, 0.19274756f, 0.14365081f, -0.19256186f, -0.04555651f, -0.04892140f, 
    0.07538790f, 0.03817900f, 0.13191527f, 0.12334186f, 0.19204076f, -0.09132782f, 0.00432649f, 0.05219808f, 
    0.05454838f, -0.02848252f, -0.04428156f, 0.00870957f, 0.13064666f, 0.07862496f, -0.01140776f, 0.13943590f, 
    -0.26370046f, -0.12543696f, 0.05735433f, -0.14542691f, 0.14807570f, -0.12640168f, -0.21358369f, 0.01298079f, 
    -0.07028908f, -0.04843682f, 0.01021534f, -0.11142638f, 0.03038380f, -0.00492510f, 0.02244916f, -0.02447619f, 
    0.04768945f, -0.11984941f, -0.10591794f, -0.10051204f, -0.04056010f, 0.16324501f, 0.01300160f, 0.14719151f, 
    -0.25874990f, 0.19301027f, 0.01787340f, 0.21353629f, 0.07170628f, 0.07960967f, 0.11057300f, -0.04073993f, 
    0.03813609f, -0.00738439f, -0.04487413f, -0.13040134f, -0.09715562f, 0.14768432f, 0.00384841f, -0.06691969f, 
    0.06929528f, 0.14642784f, -0.08918782f, -0.12450942f, 0.06707527f, 0.10272612f, 0.05565727f, -0.07895974f, 
    -0.03552994f, -0.17467254f, -0.19875824f, -0.26378110f, 0.07413534f, 0.11430186f, -0.10455856f, 0.02043789f, 
    0.07688010f, -0.04408821f, 0.07927471f, 0.22768931f, 0.03799117f, -0.01937114f, -0.06314904f, 0.14570631f, 
    0.09720089f, 0.05822075f, -0.01181968f, -0.09047935f, -0.14749640f, 0.02658328f, 0.04120424f, 0.28552920f, 
    0.11583772f, 0.05084222f, 0.17998792f, 0.25598511f, 0.00648112f, 0.12523133f, -0.06517623f, 0.03862157f, 
    0.02177266f, -0.09153088f, 0.00035736f, -0.06613155f, -0.12855864f, 0.01793040f, -0.03429861f, 0.04867515f, 
    0.00240534f, -0.12695247f, -0.11667044f, -0.02217929f, 0.04648237f, 0.02255709f, -0.10546210f, -0.04713547f, 
    -0.00253258f, 0.00626946f, 0.00156185f, -0.01626834f, 0.00628987f, -0.04850636f, 0.02040880f, 0.03736435f, 
    0.04275327f, -0.02073764f, -0.01910810f, 0.03010165f, -0.04599414f, -0.01007600f, 0.00557909f, -0.02496907f, 
    -0.04526010f, -0.05401281f, -0.05232929f, 0.00364260f, 0.03402115f, 0.00720421f, -0.04799917f, -0.03972166f, 
    -0.04307999f, -0.05717634f, -0.00525133f, 0.00736212f, 0.02399628f, -0.00815471f, 0.03476096f, 0.03422990f, 
    0.01223945f, 0.02575983f, -0.04243427f, 0.03225418f, -0.04929499f, -0.05393459f, -0.04414194f, -0.00876145f, 
    0.04016709f, -0.03460997f, -0.04962482f, -0.00291681f, 0.03775258f, 0.01384144f, -0.00720184f, 0.01900392f, 
    -0.04002861f, -0.03556221f, -0.02172669f, 0.02655686f, 0.00747692f, -0.00281099f, -0.04992365f, -0.02560316f, 
    0.01351274f, 0.02841226f, -0.02467165f, -0.05738107f, -0.02282103f, 0.03262750f, 0.03948654f, 0.00829498f, 
    0.01372870f, -0.00010076f, 0.03321986f, -0.04802795f, -0.02979520f, -0.01835400f, -0.02524805f, 0.01673843f, 
    -0.03212234f, -0.03778737f, 0.01146789f, 0.01132227f, 0.03703958f, 0.04682164f, 0.02546902f, -0.01226990f, 
    -0.02331901f, -0.00836580f, 0.03983836f, -0.02513210f, -0.02405310f, -0.04553314f, -0.04327688f, -0.03267023f, 
    -0.02196854f, 0.00750663f, -0.00914402f, -0.02656536f, 0.00493355f, -0.04252545f, 0.00932646f, 0.04259328f, 
    -0.01838263f, -0.01808388f, -0.00741707f, -0.02640058f, -0.03872452f, -0.00975141f, -0.04071319f, -0.02898724f, 
    -0.02246002f, 0.02489913f, -0.02831023f, -0.03035559f, 0.03622103f, -0.03914264f, 0.00160580f, 0.02786465f, 
    -0.00618138f, -0.05162239f, -0.05396770f, -0.01887411f, -0.03148970f, -0.03229732f, 0.04346036f, 0.00711915f, 
    0.03763117f, -0.03565174f, 0.00032171f, 0.02714561f, -0.04688308f, 0.01591545f, -0.00292288f, -0.02565921f, 
    -0.00717901f, -0.00588909f, -0.01571802f, 0.02724620f, 0.01685739f, 0.03364148f, -0.02773424f, 0.00396011f, 
    0.02029684f, -0.05624663f, -0.02322532f, -0.05351704f, -0.05346394f, 0.02988084f, -0.00891030f, -0.02918716f, 
    -0.03445046f, 0.00368151f, 0.03172262f, -0.01175468f, -0.01107808f, 0.01053712f, 0.00446858f, 0.01991271f, 
    0.01078132f, -0.04393699f, -0.04919090f, -0.03415922f, -0.05719568f, 0.00068358f, 0.00106364f, -0.02888378f, 
    -0.02700686f, 0.03620582f, -0.03138268f, -0.03272917f, -0.04991413f, -0.02331085f, -0.04604145f, 0.03403405f, 
    -0.01669938f, -0.01349695f, 0.00248547f, -0.03066113f, 0.00978561f, 0.00615018f, -0.01329073f, 0.02852325f, 
    0.02871153f, -0.00051520f, 0.04090855f, -0.04814535f, -0.04332649f, 0.02019690f, 0.03191136f, -0.05618976f, 
    -0.02145720f, -0.02087871f, 0.00628189f, -0.04036848f, -0.01359909f, -0.05586058f, -0.00893853f, -0.01620904f, 
    0.00418294f, -0.04650313f, 0.02975204f, -0.05538667f, -0.02508709f, -0.01149226f, -0.04637055f, -0.01419861f, 
    -0.05736405f, 0.03897469f, 0.00258064f, -0.04119808f, -0.04193369f, -0.00977808f, -0.04097248f, 0.03678090f, 
    0.00270747f, 0.03880076f, 0.02993540f, -0.03937621f, 0.01118568f, -0.05773905f, -0.01463507f, -0.04873469f, 
    -0.03663124f, -0.00776508f, 0.02314465f, -0.04980900f, 0.01272498f, -0.05473576f, -0.00870170f, -0.05102820f, 
    -0.02978693f, -0.02171603f, -0.00922455f, 0.01262325f, -0.03704118f, 0.04273191f, 0.00642890f, -0.04926348f, 
    -0.03641176f, 0.04369638f, -0.03421830f, -0.03768502f, -0.02577090f, -0.02815541f, -0.00441169f, -0.01528751f, 
    0.02847293f, -0.02801908f, 0.03944911f, 0.01605150f, -0.05748967f, -0.00600082f, -0.01453987f, -0.02282963f, 
    -0.01344860f, 0.01296355f, 0.03140981f, 0.00601865f, -0.00480411f, 0.00749683f, -0.01645857f, -0.01384950f, 
    0.01864230f, 0.04094829f, 0.03992996f, -0.00033338f, -0.04838845f, -0.01187736f, 0.02871292f, -0.03534918f, 
    -0.00597715f, 0.03411895f, -0.02576833f, -0.03343122f, -0.04414399f, 0.00454959f, -0.03487018f, -0.04953786f, 
    -0.04800541f, -0.05019990f, 0.00363486f, -0.03244624f, -0.02449144f, -0.01928402f, -0.04263590f, 0.01671574f, 
    0.01149695f, -0.02180014f, -0.02812943f, -0.02298224f, -0.02398066f, -0.05016419f, -0.01254433f, 0.00366291f, 
    0.02490682f, -0.00372939f, -0.01707155f, 0.00821345f, 0.04602350f, 0.03609103f, -0.02465076f, 0.00273721f, 
    -0.02013742f, 0.00629332f, -0.01130128f, 0.01096307f, 0.03143269f, 0.04373757f, -0.03362229f, -0.04381004f, 
    -0.01780967f, -0.01279743f, -0.02996602f, -0.01518129f, 0.01491236f, -0.03629562f, -0.03272666f, 0.02230486f, 
    -0.05017471f, -0.01573466f, -0.05589462f, 0.02836208f, 0.00002930f, -0.05458084f, 0.00192758f, -0.02186595f, 
    0.02749333f, 0.01994633f, -0.00671704f, 0.03483254f, 0.01318233f, -0.04007325f, -0.03629891f, -0.03603703f, 
    0.03512828f, -0.04088077f, -0.04754671f, 0.03560148f, 0.03158767f, 0.02215206f, 0.02219635f, -0.02549833f, 
    0.02868188f, 0.03747793f, 0.03664535f, -0.04524258f, -0.02698677f, -0.00543837f, 0.04269078f, -0.00279514f, 
    -0.04708213f, -0.01639024f, 0.00122872f, -0.02956492f, 0.00747541f, -0.03672738f, 0.03470688f, -0.03844453f, 
    0.02264322f, 0.02056108f, -0.02897857f, -0.00275273f, 0.01970089f, -0.03578990f, -0.03899353f, 0.00593108f, 
    0.01537863f, -0.04741070f, 0.04159695f, 0.01048732f, -0.03965439f, 0.00301803f, -0.03244809f, 0.02672211f, 
    -0.00316362f, 0.03520192f, -0.02616568f, -0.00832899f, -0.04597155f, 0.00632761f, 0.00923522f, -0.02305077f, 
    0.00955101f, 0.00607070f, 0.01950790f, 0.00382996f, -0.00878335f, 0.02127993f, -0.05241454f, 0.00483901f, 
    0.15960661f, 0.05068936f, -0.08994744f, -0.15172681f, 0.09166093f, -0.07994102f, 0.04871489f, 0.04403570f, 
    0.05374360f, -0.01195467f, -0.09111179f, 0.12404314f, -0.15076101f, 0.14253187f, 0.20273627f, -0.06241975f, 
    -0.09754629f, 0.07609937f, 0.03334891f, 0.18873879f, -0.01743883f, 0.02169124f, -0.10940956f, 0.04516290f, 
    -0.30432549f, 0.11313909f, 0.11961208f, 0.05751028f, -0.01545111f, 0.02373069f, -0.04060912f, -0.00679193f, 
    -0.05779516f, 0.03797157f, 0.04102950f, 0.00548911f, 0.07215513f, 0.20607090f, 0.12729241f, 0.20455414f, 
    -0.06497496f, 0.06332368f, 0.01436289f, 0.11328724f, -0.00770524f, -0.03262772f, -0.02934285f, 0.10879714f, 
    0.00528851f, 0.00646944f, -0.00216282f, 0.21280721f, 0.12544581f, -0.00426202f, 0.03680787f, -0.02095441f, 
    -0.08604299f, 0.02411333f, 0.04748043f, -0.05742605f, 0.15288816f, -0.02142013f, -0.13930832f, -0.08873985f, 
    0.16480158f, 0.11919115f, -0.00279385f, -0.04015510f, 0.08991963f, 0.01609397f, -0.01921231f, 0.13276461f, 
    -0.35041055f, 0.16809009f, -0.14175685f, 0.15241489f, 0.02086284f, -0.05130354f, 0.01925861f, -0.00263255f, 
    0.13614212f, 0.01294510f, -0.08703250f, -0.13316582f, -0.09036443f, -0.07464876f, -0.10140657f, -0.15672724f, 
    0.22302666f, 0.11082289f, -0.01489722f, -0.07230160f, 0.19407763f, 0.06518429f, -0.00159474f, 0.04431995f, 
    -0.31972671f, 0.27244803f, 0.12317491f, -0.07916423f, -0.05338481f, -0.02836360f, -0.03353426f, 0.08404782f, 
    -0.03128826f, -0.02326563f, -0.10739432f, 0.01964377f, -0.11427924f, 0.00921358f, -0.08778411f, 0.05226528f, 
    0.05916676f, 0.07722779f, -0.03488646f, 0.02716584f, -0.01666681f, 0.02503264f, 0.03483516f, -0.06197784f, 
    0.13551022f, -0.06583342f, -0.08031738f, 0.11352986f, 0.01827310f, -0.06549648f, 0.06732886f, 0.07109296f, 
    -0.06982363f, 0.01203562f, -0.00813796f, 0.12450753f, 0.09278820f, -0.00878190f, -0.01134691f, 0.03940244f, 
    0.03678700f, 0.07213012f, 0.11540154f, 0.04542850f, 0.14732100f, 0.02707814f, 0.00192857f, -0.11028669f, 
    0.16781299f, -0.03901327f, -0.02931820f, 0.06018640f, -0.03585534f, 0.07182139f, -0.07905908f, 0.03889067f, 
    0.02657973f, -0.03514995f, 0.03924921f, 0.00670469f, 0.08069621f, -0.25684604f, 0.12522666f, 0.13817129f, 
    -0.01537772f, -0.03302049f, 0.09581925f, 0.05960108f, -0.03459360f, -0.00864961f, 0.04458522f, 0.09215754f, 
    0.21399304f, 0.00879935f, -0.15174739f, 0.26194227f, -0.08965964f, -0.01385686f, -0.03372535f, 0.03513736f, 
    0.02170626f, -0.09221444f, -0.05901865f, -0.04748745f, -0.04263134f, -0.25492391f, -0.05287041f, 0.20853093f, 
    0.03387294f, 0.04589009f, 0.07281032f, 0.13616788f, 0.07016207f, -0.06092563f, -0.07837252f, 0.06009219f, 
    0.06545475f, 0.02602700f, 0.17728457f, 0.04326560f, -0.09687506f, 0.07200357f, 0.01668187f, -0.01583881f, 
    -0.06293523f, -0.07431150f, -0.02032208f, 0.04927353f, 0.23627596f, 0.22047742f, 0.19527955f, -0.07170452f, 
    -0.02802834f, -0.03938343f, 0.05865844f, -0.01129112f, 0.01972474f, -0.01716970f, -0.00738084f, -0.02209529f, 
    -0.08940155f, -0.10937171f, -0.14946210f, 0.05708312f, 0.07060555f, -0.03516519f, 0.11691180f, 0.10218971f, 
    -0.03245835f, -0.01808525f, 0.06040648f, 0.00847864f, 0.01145197f, -0.05716546f, 0.13602018f, -0.02249985f, 
    0.00864394f, 0.05118073f, -0.03867465f, -0.11405089f, -0.02008233f, -0.00358294f, 0.01322042f, 0.03993529f, 
    0.19459781f, -0.24299717f, 0.02609226f, -0.18391353f, 0.11100385f, 0.14271706f, -0.10083923f, -0.05289993f, 
    0.05671884f, -0.06660350f, 0.11742530f, 0.02421165f, -0.17084858f, -0.00802679f, 0.21557823f, 0.08008550f, 
    -0.07179460f, -0.01578906f, 0.07118433f, -0.00880876f, -0.18707784f, 0.04950685f, 0.02870998f, -0.08552673f, 
    0.25575575f, 0.03530476f, -0.04897184f, -0.22987290f, -0.07683171f, 0.10539101f, 0.03455055f, 0.08813687f, 
    -0.11121708f, 0.04899745f, 0.00357165f, 0.01169777f, -0.12177950f, 0.17267586f, 0.17293169f, -0.06913859f, 
    -0.09694742f, 0.05113728f, 0.01099066f, 0.03777765f, -0.03309873f, -0.07270492f, 0.13785289f, 0.11508343f, 
    0.18564610f, -0.08636267f, 0.13816662f, -0.00538381f, -0.06972460f, -0.03031478f, 0.12489082f, 0.08678412f, 
    0.04597550f, 0.02153268f, 0.10297273f, 0.08240473f, 0.24570489f, 0.15477234f, 0.02994734f, -0.00276968f, 
    -0.14674200f, 0.04010949f, 0.06466088f, 0.00063896f, 0.05182137f, 0.00336936f, 0.03246188f, 0.01944550f, 
    -0.01395043f, 0.17069814f, -0.05577900f, 0.01948519f, -0.00921868f, 0.04050885f, 0.02623502f, 0.00749707f, 
    0.00760153f, 0.04019487f, 0.08104785f, 0.03174622f, 0.15918125f, 0.18851741f, -0.01465480f, 0.05710956f, 
    -0.00633378f, 0.00666605f, 0.12711698f, -0.00325452f, -0.05985839f, 0.07307034f, -0.04069835f, 0.02052769f, 
    -0.11266805f, -0.08419179f, 0.20972151f, 0.10804033f, 0.09091976f, -0.09540948f, 0.09425507f, -0.09015807f, 
    0.11540060f, 0.04018673f, -0.07515062f, -0.05747983f, -0.11816657f, 0.17514181f, 0.10315368f, -0.10620403f, 
    -0.01196821f, -0.05091754f, 0.06119742f, -0.01454297f, 0.00972399f, 0.05120834f, 0.00114246f, 0.09299653f, 
    -0.02283093f, -0.05192063f, -0.07615708f, -0.13421135f, 0.09326153f, 0.01182339f, 0.09420817f, 0.00612334f, 
    0.04567195f, 0.03146307f, 0.03127453f, 0.09182594f, 0.10935544f, 0.12752609f, 0.06675338f, 0.09491520f, 
    -0.12687232f, 0.01044661f, 0.10988774f, -0.06466013f, 0.06722294f, 0.01979948f, 0.06698761f, 0.07622224f, 
    0.09596542f, 0.02373202f, -0.22203632f, 0.08084201f, -0.12758276f, 0.07731274f, -0.01476600f, -0.09283441f, 
    -0.02797874f, -0.00477821f, -0.00275404f, -0.00191460f, 0.04879113f, -0.08924312f, 0.00878209f, 0.02734698f, 
    0.02202020f, -0.01883881f, 0.06398057f, -0.07982056f, 0.02344152f, -0.01079477f, 0.12040037f, 0.08732865f, 
    -0.16973133f, -0.21855357f, 0.01273399f, 0.24458651f, 0.20533639f, 0.01869348f, -0.00994614f, -0.03633432f, 
    0.00932238f, -0.01270862f, 0.02924624f, -0.04229278f, -0.01605591f, -0.07104927f, 0.08296891f, -0.36888415f, 
    0.16653869f, -0.04228586f, -0.07312987f, -0.09297145f, -0.06511755f, -0.10136587f, -0.10175674f, -0.10876372f, 
    0.25066751f, 0.10283072f, -0.01438063f, 0.09467287f, 0.00592386f, 0.17257766f, 0.03292698f, -0.02496249f, 
    -0.05433382f, 0.02642388f, 0.17919512f, 0.01766947f, 0.16056941f, 0.09878983f, 0.18673444f, 0.01917482f, 
    -0.03038652f, -0.00883887f, -0.01826174f, 0.01083965f, 0.01888801f, -0.06466080f, 0.12316309f, -0.07788789f, 
    -0.01922282f, 0.02193402f, 0.01805502f, 0.21874613f, 0.02477824f, -0.06529304f, 0.07429908f, 0.00885635f, 
    0.00006138f, 0.13366050f, 0.01305916f, 0.01595642f, -0.11586579f, 0.15143950f, 0.03685933f, 0.10381521f, 
    -0.00870077f, -0.08949545f, 0.11732651f, 0.06018345f, -0.05556945f, -0.08774559f, 0.10586403f, -0.03900646f, 
    -0.08527218f, -0.24142188f, -0.08271410f, -0.15890276f, 0.07048672f, 0.01567883f, 0.00663199f, -0.13733147f, 
    0.16833466f, -0.02415862f, 0.09922054f, 0.06401962f, -0.01603276f, 0.01775105f, 0.23272888f, 0.06669277f, 
    -0.07868385f, 0.01857503f, -0.00321536f, 0.02196663f, 0.02559658f, 0.04226888f, 0.00582636f, 0.10775097f, 
    -0.09340651f, 0.13540232f, 0.07033873f, 0.09921747f, 0.04950710f, 0.14253314f, 0.00955228f, 0.02219583f, 
    -0.05713015f, -0.12628195f, -0.12909833f, -0.14918144f, 0.06043399f, 0.01374105f, -0.09916947f, 0.32228732f, 
    0.09091961f, -0.01669316f, -0.12105610f, -0.17038840f, 0.00486662f, -0.03739787f, -0.08254702f, -0.01667609f, 
    -0.15614261f, 0.04795790f, -0.07439850f, 0.01873932f, -0.08743032f, -0.00303478f, 0.19414605f, 0.07100227f, 
    0.00293742f, -0.00451447f, 0.16394375f, -0.02296000f, -0.15912412f, 0.22182383f, 0.06091927f, 0.23975383f, 
    0.14182341f, -0.10644247f, -0.04781266f, -0.20662813f, 0.02039493f, 0.08064695f, -0.10923535f, 0.03673516f, 
    0.14678307f, 0.10771489f, 0.06557725f, -0.12957837f, 0.22214462f, 0.12292383f, 0.03724326f, 0.00458652f, 
    0.02183117f, 0.09098227f, -0.03130810f, 0.11127944f, -0.04808366f, 0.23474132f, -0.09492685f, -0.13215296f, 
    -0.04072792f, -0.07770255f, -0.00493594f, -0.01252728f, -0.09387624f, 0.19038835f, -0.06460796f, 0.05855633f, 
    -0.00368561f, 0.19963488f, -0.10509200f, -0.08927743f, 0.17449935f, 0.02550181f, -0.00174767f, 0.04530742f, 
    0.03263512f, -0.04874491f, 0.08891081f, 0.12235831f, -0.23492765f, -0.22859697f, 0.01554462f, 0.01514611f, 
    0.13304061f, 0.07585585f, 0.03795158f, 0.00044742f, 0.03153712f, 0.02180876f, 0.11498848f, 0.00854644f, 
    -0.00660984f, -0.02203237f, 0.06158639f, 0.09601966f, 0.19017403f, -0.14000280f, 0.00494570f, -0.10272522f, 
    0.09866697f, 0.12718102f, -0.07294131f, -0.04279607f, 0.29935554f, 0.08968657f, -0.08727625f, 0.30007321f, 
    0.01223856f, -0.03095799f, -0.00449109f, -0.01240660f, -0.00045461f, 0.04710943f, -0.08843950f, 0.17624189f, 
    -0.09427463f, -0.08071196f, -0.05412312f, -0.02764204f, -0.15947716f, -0.06421567f, 0.18315399f, -0.09314507f, 
    0.04076282f, -0.02745388f, -0.15174383f, -0.02952322f, -0.05289591f, -0.10741670f, -0.18243143f, 0.10493699f, 
    0.06623518f, 0.13331045f, 0.09724232f, 0.07854855f, 0.04575270f, -0.00324519f, 0.01699884f, -0.05364006f, 
    -0.21601570f, -0.19935891f, 0.18787408f, 0.05901087f, 0.13150224f, -0.09204744f, 0.08640211f, 0.00758288f, 
    0.07033765f, 0.09033775f, 0.17507569f, 0.11916947f, -0.05142606f, 0.02664668f, 0.02263504f, -0.19926006f, 
    0.14702858f, 0.12488159f, 0.05229905f, 0.04405089f, 0.20100354f, 0.07799503f, 0.02080056f, 0.09625994f, 
    0.04514685f, 0.10920555f, -0.11938105f, -0.19164626f, 0.10930753f, 0.06770938f, -0.17330222f, 0.00895964f, 
    -0.05235241f, -0.09311202f, -0.02027060f, -0.02114593f, -0.28928253f, -0.10856708f, 0.00712872f, -0.26703453f, 
    0.05879166f, -0.07659837f, -0.08611552f, 0.02181656f, 0.04920070f, 0.06016424f, -0.02788456f, 0.13477267f, 
    0.16249374f, -0.04686280f, -0.06451181f, 0.28427118f, -0.01316856f, 0.14744627f, 0.16202590f, -0.02253934f, 
    0.07530963f, 0.08491373f, -0.06062591f, -0.02903414f, -0.41795132f, -0.10120080f, 0.11797754f, -0.26161504f, 
    0.11748187f, -0.01170999f, -0.02151197f, -0.02951443f, 0.05672842f, 0.04697425f, -0.00930965f, -0.12600845f, 
    -0.09814814f, -0.03486591f, -0.03894857f, 0.01574955f, -0.01850900f, -0.03798600f, -0.18404683f, -0.00814633f, 
    0.02391994f, 0.10297431f, 0.12887621f, 0.12199095f, -0.01290532f, 0.09050692f, 0.07702976f, 0.24870853f, 
    0.12059077f, 0.04836066f, 0.08281230f, -0.03745427f, 0.06106162f, 0.05042178f, -0.11650590f, 0.14788836f, 
    0.12609455f, 0.01037558f, -0.00391768f, 0.13904659f, -0.05931481f, 0.09368440f, 0.04410430f, -0.04879954f, 
    -0.07175625f, -0.03746897f, -0.05631611f, -0.01690102f, -0.29395851f, -0.23118158f, -0.18551032f, -0.08186162f, 
    0.15295492f, -0.05229498f, -0.14009762f, 0.07676528f, 0.01026947f, 0.00809746f, -0.09411122f, 0.23985751f, 
    -0.13636559f, -0.11935422f, 0.03783302f, 0.10731444f, -0.01816510f, -0.04007562f, 0.04584411f, -0.01444787f, 
    0.03723517f, 0.08842555f, 0.11041451f, 0.16473089f, 0.05756781f, -0.04984431f, 0.20568231f, 0.08138494f, 
    -0.02141127f, -0.02679014f, -0.01045345f, -0.01702882f, 0.07761550f, -0.08877221f, -0.00893436f, -0.03018397f, 
    0.18253775f, -0.26318759f, 0.07449429f, 0.00464177f, 0.06652649f, 0.09910359f, -0.12575367f, 0.09712065f, 
    0.02643830f, 0.03260595f, -0.01627144f, -0.02785993f, -0.05328542f, -0.05791385f, 0.02199469f, -0.15883493f, 
    0.17558502f, 0.08500608f, 0.10577594f, 0.13223830f, -0.04573913f, 0.05485841f, 0.05487915f, 0.04110932f, 
    0.17986801f, 0.10612170f, -0.06089289f, 0.11881060f, -0.06663205f, 0.07481451f, -0.01728372f, 0.02326409f, 
    0.04139192f, 0.10190328f, 0.04030726f, 0.15437382f, 0.24559753f, -0.02244601f, -0.28262237f, 0.12979408f, 
    0.05153804f, -0.08915424f, -0.03536993f, 0.04079234f, 0.03653657f, -0.00735044f, 0.03538925f, 0.05992979f, 
    0.00260614f, -0.08120105f, 0.00381807f, -0.02016279f, 0.13585356f, 0.04967424f, -0.19719097f, 0.10637651f, 
    0.03453537f, 0.00176723f, -0.00241244f, -0.05350766f, -0.49441096f, -0.05196331f, 0.01884402f, 0.02498747f, 
    0.08922887f, 0.01604999f, 0.07301391f, 0.03920675f, -0.07592982f, 0.01149213f, 0.00818946f, -0.05512658f, 
    0.20859753f, 0.00839422f, -0.10283978f, -0.14023216f, -0.00745193f, -0.01232934f, 0.10803965f, -0.15102780f, 
    0.07421877f, -0.06315244f, -0.09504255f, 0.04494342f, -0.13894166f, 0.33453363f, 0.08669588f, -0.11629903f, 
    0.06523801f, -0.00112287f, -0.08163390f, -0.01985704f, -0.02471453f, -0.09679827f, -0.08106155f, 0.03846271f, 
    0.32264629f, 0.00683290f, 0.00170414f, 0.16342576f, 0.09767164f, 0.08461431f, 0.00301895f, 0.02607093f, 
    -0.07069209f, 0.03991335f, 0.03976281f, -0.04378692f, 0.04003218f, -0.04405699f, 0.18402930f, 0.20484354f, 
    0.00716512f, -0.05610854f, 0.06884880f, -0.01212679f, 0.10026273f, 0.03693398f, 0.06492510f, -0.06235103f, 
    -0.10815727f, 0.03759593f, -0.07879116f, 0.08426518f, 0.05156801f, -0.01769978f, 0.04833539f, 0.08371544f, 
    -0.07059136f, 0.00231232f, 0.09013812f, 0.04610416f, 0.01229027f, -0.03258163f, 0.07184447f, 0.26724231f, 
    -0.08142388f, -0.07213832f, 0.06138601f, -0.09686954f, -0.00993200f, 0.04367086f, 0.00444041f, -0.09253194f, 
    -0.28386056f, 0.08642323f, -0.02886083f, -0.03462662f, 0.06343666f, 0.11252228f, -0.08060724f, 0.05235587f, 
    -0.10715469f, 0.01717491f, -0.09345367f, -0.06751422f, 0.04851026f, 0.05966944f, -0.09311850f, 0.11090970f, 
    0.01384828f, -0.00722869f, 0.03836949f, -0.00371511f, 0.07165716f, 0.00138921f, 0.08451673f, -0.11332470f, 
    -0.08912835f, -0.06486994f, -0.00206408f, 0.05188662f, -0.12137147f, -0.01109245f, 0.04047946f, -0.09704814f, 
    0.07578560f, 0.05083521f, 0.00483524f, 0.05693291f, -0.04391556f, 0.09722392f, -0.00746265f, -0.11815999f, 
    0.09993080f, 0.12024277f, -0.00591805f, 0.06449196f, 0.00318039f, -0.02143686f, -0.17794451f, -0.07749576f, 
    0.21125682f, -0.17397301f, 0.22026581f, 0.07895162f, 0.02819999f, -0.06692085f, -0.10809555f, 0.00144280f, 
    0.03225991f, 0.00180580f, 0.01407245f, 0.06237936f, 0.21250540f, -0.01166677f, 0.00799614f, 0.40313339f, 
    0.03357791f, -0.00472611f, -0.03229672f, 0.01251580f, -0.01415225f, 0.04310730f, -0.02829575f, 0.11273985f, 
    -0.00551529f, -0.06284627f, -0.09656769f, 0.13715439f, 0.07874651f, -0.00240460f, 0.00603879f, 0.04706436f, 
    0.09532691f, 0.01185920f, 0.04847194f, -0.01000442f, 0.02315147f, -0.07829267f, 0.00361625f, 0.08661932f, 
    -0.09441986f, 0.26772544f, 0.07974207f, 0.02644787f, -0.01349594f, -0.18373662f, -0.06163264f, 0.05967018f, 
    -0.13435847f, 0.11363241f, 0.07617131f, -0.10184824f, 0.19694105f, -0.08285928f, -0.00508263f, -0.07381499f, 
    -0.04413859f, -0.08200288f, 0.04497872f, 0.09255444f, 0.16667381f, 0.03767091f, 0.12537348f, 0.13113357f, 
    0.03719118f, 0.04379733f, 0.11327692f, 0.00203397f, 0.02022157f, -0.13404770f, -0.02836278f, 0.01296829f, 
    -0.13732781f, 0.07359269f, 0.02033992f, -0.12180322f, 0.07474042f, -0.03555767f, -0.06946280f, -0.00161709f, 
    0.01090592f, 0.00941524f, 0.04735076f, -0.16420326f, 0.01349627f, 0.12375791f, -0.05742289f, -0.14584447f, 
    0.09956019f, -0.03614647f, 0.03624694f, -0.10067637f, 0.09499769f, -0.03712599f, -0.05917230f, 0.03395834f, 
    -0.25177941f, -0.16727781f, -0.14255066f, 0.16630331f, -0.04379470f, 0.07380012f, 0.02738255f, 0.00753857f, 
    -0.01590003f, -0.10790835f, 0.06243172f, 0.01288089f, -0.07032498f, 0.09674451f, -0.01642220f, -0.16988370f, 
    -0.03386620f, 0.20947103f, 0.11523490f, 0.14381817f, -0.06698291f, 0.08577240f, 0.06543528f, 0.12881215f, 
    0.05826550f, -0.08149010f, -0.08748938f, -0.11788478f, 0.03709829f, 0.06118418f, 0.05603516f, 0.03071145f, 
    -0.01233500f, -0.05469423f, 0.01175988f, 0.04648763f, 0.09579197f, 0.11968393f, 0.09495247f, 0.20724730f, 
    0.04945057f, -0.02296341f, 0.01491063f, -0.13654163f, -0.17402560f, -0.00315411f, -0.01412694f, 0.01287037f, 
    0.19645256f, -0.01763234f, -0.18924527f, 0.27048248f, 0.04866386f, 0.03909756f, -0.10076633f, 0.00668626f, 
    0.11665562f, -0.00901385f, -0.05413720f, -0.08169767f, 0.05925679f, 0.05551354f, 0.04221483f, -0.19236140f, 
    0.03366936f, 0.00551940f, 0.02433351f, 0.02544520f, 0.08186667f, -0.02260278f, 0.03424270f, 0.04014789f, 
    -0.23969281f, -0.15439965f, 0.01311330f, 0.18411943f, -0.01502015f, -0.00047799f, 0.02729868f, -0.03594268f, 
    0.03110162f, 0.08255818f, 0.03068973f, 0.13910311f, -0.04853689f, 0.07551932f, 0.10121283f, -0.03265306f, 
    0.04170873f, -0.09511192f, 0.00521542f, 0.06543887f, 0.08305050f, -0.05368109f, 0.00150979f, 0.04348468f, 
    0.38597599f, -0.04240849f, -0.08448174f, 0.08262528f, -0.00832780f, 0.00511992f, -0.07783139f, -0.06997094f, 
    -0.02173273f, 0.06136179f, 0.07481880f, 0.10168643f, -0.00157146f, 0.09289987f, 0.16515462f, -0.05896465f, 
    0.04293000f, 0.03984050f, 0.09706870f, 0.07354525f, 0.05147540f, 0.08042377f, 0.12565190f, 0.09863708f, 
    0.04526837f, -0.06072463f, 0.02647393f, 0.03665238f, 0.05523307f, 0.07694085f, 0.12234501f, 0.03752485f, 
    -0.02969306f, 0.14823870f, -0.02299831f, 0.06683163f, 0.09659373f, -0.09105504f, -0.19652852f, -0.03366606f, 
    -0.04413603f, -0.17021202f, 0.12727730f, 0.00130291f, 0.00541369f, -0.00378858f, 0.13018534f, 0.07561640f, 
    0.15579644f, 0.07492271f, -0.15696280f, -0.01230954f, 0.09199399f, 0.13296880f, -0.05960772f, 0.04985202f, 
    -0.08394761f, -0.01481169f, -0.08180717f, 0.08981280f, -0.46446714f, -0.28325680f, -0.11518960f, 0.25746429f, 
    -0.02977049f, 0.06075475f, 0.14202933f, -0.02854677f, -0.10414609f, 0.01259047f, 0.01013580f, 0.02225064f, 
    -0.08195069f, 0.24762021f, -0.04010708f, -0.15783024f, -0.09421603f, 0.01378071f, 0.05083478f, -0.00738723f, 
    0.00456059f, -0.02047667f, -0.00903758f, 0.07197469f, -0.34867769f, 0.14030755f, -0.01773258f, -0.12377229f, 
    0.19933912f, -0.00713566f, 0.01501406f, 0.00121330f, 0.06459449f, -0.04709511f, 0.08267077f, 0.10513439f, 
    0.20458281f, -0.15063399f, 0.12574516f, -0.04533641f, -0.08909037f, 0.04457076f, 0.06642496f, -0.02510812f, 
    -0.02927184f, 0.01245977f, 0.08134916f, 0.09503519f, 0.19802167f, -0.02288285f, -0.08687582f, 0.15683286f, 
    -0.05682402f, -0.01004392f, 0.01713484f, 0.02126711f, 0.01882676f, 0.14334860f, 0.18050252f, 0.11768093f, 
    -0.34828588f, -0.06539708f, -0.05573703f, -0.09603357f, 0.00885176f, -0.00549430f, 0.11359779f, 0.00317372f, 
    -0.09118130f, 0.04058884f, -0.00742542f, 0.09845808f, 0.13237336f, 0.00692320f, -0.05453093f, 0.32075310f, 
    -0.05789290f, 0.05657519f, 0.01886482f, -0.17350733f, -0.00270289f, -0.07912468f, 0.08311392f, -0.13116817f, 
    -0.22764190f, 0.13777667f, 0.07494985f, -0.26877528f, 0.16902553f, -0.07168354f, 0.20168510f, 0.00961436f, 
    -0.08619450f, 0.07255322f, -0.04620712f, -0.19670756f, -0.49971664f, 0.05406512f, -0.06793062f, -0.01140034f, 
    0.09077869f, 0.04483602f, 0.09227529f, 0.06298521f, 0.05901388f, 0.01186165f, -0.03836220f, -0.07478095f, 
    -0.07236291f, -0.11963733f, 0.10057840f, -0.02694165f, -0.04317331f, 0.06598353f, -0.00892355f, -0.12898883f, 
    0.11251038f, 0.09665558f, -0.01477832f, -0.10734145f, -0.03843575f, 0.20875110f, 0.00047516f, -0.11627837f, 
    0.05172764f, -0.05757678f, 0.00462862f, 0.06284276f, 0.02214343f, 0.01400962f, -0.04224245f, 0.00949600f, 
    0.10710661f, 0.19465686f, 0.08652368f, 0.27599648f, 0.05705313f, 0.07262761f, 0.01854271f, 0.02546776f, 
    0.01234793f, -0.05877146f, 0.13295086f, -0.08065132f, 0.03653776f, 0.03064432f, -0.10494071f, 0.25992781f, 
    -0.08016643f, -0.06596793f, -0.05155520f, 0.16826883f, -0.01325150f, -0.06204068f, -0.00458426f, 0.03928894f, 
    -0.44428772f, -0.01422739f, -0.01146374f, 0.08865770f, 0.09616195f, 0.04168817f, 0.05419131f, 0.06173567f, 
    0.04730162f, 0.00499399f, 0.15638269f, 0.11484022f, 0.08579998f, -0.17069662f, -0.03378411f, 0.17400689f, 
    -0.12699103f, 0.26091912f, -0.00442668f, 0.02967613f, -0.09139968f, 0.04707985f, 0.11430947f, 0.07252169f, 
    -0.08369757f, 0.27183369f, -0.09326862f, -0.07113955f, -0.07047158f, 0.00870421f, 0.07683749f, 0.02119428f, 
    0.06735806f, -0.09475999f, 0.03412227f, 0.06994266f, -0.04578809f, 0.07227372f, 0.19006689f, 0.12392391f, 
    0.12129533f, 0.05323058f, -0.01181409f, 0.03733546f, -0.02211924f, 0.04243927f, 0.02894065f, -0.14764278f, 
    -0.02248492f, -0.04470166f, -0.01202807f, -0.24023871f, 0.12700361f, 0.05670932f, 0.00439340f, -0.07426070f, 
    0.13625519f, 0.01755425f, -0.10540736f, -0.01936448f, 0.00231804f, 0.12757683f, 0.18210505f, -0.28968200f, 
    0.04316292f, -0.02278850f, 0.13621542f, 0.01024360f, 0.05221620f, 0.00805324f, 0.05202829f, 0.04088574f, 
    0.05353136f, -0.06343000f, -0.14386986f, 0.04804050f, -0.17123945f, 0.05206203f, 0.10226993f, -0.09406167f, 
    0.00751211f, -0.09000394f, 0.03253182f, 0.02438729f, 0.04388149f, -0.02828875f, 0.04908025f, -0.20401341f, 
    -0.06665047f, -0.01454990f, 0.04499594f, 0.20341155f, 0.01154307f, 0.01920221f, 0.04645798f, 0.08528032f, 
    0.28615537f, -0.18537268f, 0.31720677f, 0.11484842f, 0.05943542f, -0.06393328f, 0.03069516f, 0.06137792f, 
    0.08415101f, 0.00093245f, -0.11719295f, -0.00325003f, 0.00590166f, 0.15718116f, 0.09361000f, 0.15027241f, 
    -0.05460563f, 0.00345134f, 0.04154331f, -0.03031577f, 0.15475446f, -0.01877390f, -0.12923203f, -0.14595297f, 
    -0.22936492f, -0.20474495f, -0.00114196f, 0.15339459f, 0.06982145f, 0.00841781f, -0.04485254f, -0.02324558f, 
    0.05136671f, 0.01759671f, -0.01033329f, 0.03035725f, 0.15118392f, 0.08474056f, 0.17927849f, -0.20099704f, 
    0.00399505f, 0.03730929f, -0.02281256f, 0.05372722f, 0.00553619f, -0.04454267f, -0.06793222f, 0.08691821f, 
    -0.13142680f, -0.12545009f, 0.27730092f, 0.04756576f, 0.00927055f, -0.05624098f, -0.11689799f, 0.11298728f, 
    -0.02936464f, -0.01399724f, 0.03238000f, -0.08940792f, 0.12811550f, 0.06419230f, 0.11963832f, -0.05728994f, 
    0.11320891f, 0.07452113f, -0.01952361f, 0.03998832f, 0.04292049f, -0.05355721f, 0.01072325f, -0.01011394f, 
    0.24863671f, 0.00341852f, 0.00094452f, -0.33927882f, -0.04348904f, 0.09415483f, -0.06140497f, 0.09870692f, 
    0.09926172f, -0.04547669f, 0.00021210f, 0.06228413f, 0.07378395f, 0.00032099f, -0.01974512f, 0.01733840f, 
    0.25217369f, 0.01877310f, -0.03267659f, 0.04268297f, 0.11624118f, -0.01722563f, 0.07409775f, 0.07303907f, 
    -0.06708312f, -0.05134584f, 0.00078903f, -0.17045015f, -0.05530494f, 0.01448078f, 0.04098986f, 0.02635682f, 
    -0.04161549f, -0.07961327f, 0.00409869f, 0.07463225f, -0.03834930f, -0.09982318f, -0.19492744f, 0.17560686f, 
    -0.01876998f, -0.00901311f, -0.06173203f, 0.12807539f, 0.02619231f, 0.02240444f, -0.08112159f, 0.00100146f, 
    0.30771980f, -0.09695507f, 0.19401941f, -0.18921639f, 0.08010340f, -0.02883559f, -0.06771646f, 0.10161594f, 
    0.03451713f, -0.04900539f, 0.07604054f, 0.06314765f, -0.00994897f, -0.26958054f, -0.20262472f, 0.11374625f, 
    -0.11959691f, 0.08572584f, 0.03632499f, 0.03723026f, 0.06600959f, 0.07532325f, -0.03158012f, -0.00408028f, 
    0.25889537f, -0.11685468f, 0.07403450f, 0.19916233f, 0.07958954f, -0.01419331f, -0.03169505f, -0.04888281f, 
    -0.01874541f, 0.03140449f, -0.04565543f, 0.11155394f, 0.30101579f, 0.24461932f, -0.10731556f, -0.03991238f, 
    -0.01221870f, -0.07630546f, -0.03227726f, -0.00288604f, 0.00198374f, 0.01223731f, 0.00219222f, 0.06951973f, 
    0.17049457f, -0.09947190f, -0.01310848f, -0.10902295f, 0.07389013f, -0.02855201f, 0.04767940f, -0.01145059f, 
    0.03699478f, 0.03274468f, 0.13485150f, 0.05781712f, -0.12810324f, -0.13032115f, 0.21617404f, -0.15982160f, 
    0.12521054f, -0.01486756f, 0.12811340f, 0.10664976f, -0.02042046f, 0.05885806f, 0.00495910f, 0.05093790f, 
    -0.02478697f, -0.06400138f, -0.01845624f, 0.10026397f, 0.08861166f, -0.05631423f, -0.09504060f, -0.01822513f, 
    0.04080522f, -0.04294359f, -0.01377479f, 0.00216234f, 0.04839609f, -0.10057189f, 0.02743741f, -0.14474306f, 
    -0.01199005f, -0.00892670f, 0.00259077f, 0.07196615f, 0.00844280f, 0.07454083f, 0.05365058f, -0.01001268f, 
    -0.38445726f, -0.01384154f, -0.08694521f, 0.05507503f, 0.02767549f, 0.04783820f, -0.03059573f, 0.01811708f, 
    -0.15316088f, 0.02498421f, -0.04495547f, 0.15438326f, 0.20377176f, -0.04949880f, 0.06486809f, 0.04044690f, 
    0.02507327f, 0.13886979f, 0.01667793f, -0.05787759f, 0.03534475f, -0.05706440f, 0.15972711f, -0.06689118f, 
    -0.15498489f, -0.12209674f, 0.14685601f, -0.03526735f, -0.03867049f, -0.03204514f, 0.10976294f, -0.01942521f, 
    0.18578003f, 0.08896439f, -0.01709743f, 0.00659261f, 0.24123923f, 0.18311720f, 0.08630592f, -0.11318699f, 
    0.01500797f, 0.09767966f, -0.05688058f, -0.01611133f, -0.01491723f, -0.11068336f, -0.02095507f, -0.06828313f, 
    0.21651518f, -0.00530170f, 0.16739826f, -0.01134518f, -0.02544192f, -0.09960937f, 0.02103103f, 0.06548758f, 
    0.03547301f, -0.05069736f, -0.04546812f, 0.17767908f, -0.15560822f, -0.03389512f, 0.01102450f, -0.09222728f, 
    0.04556204f, -0.01852256f, 0.08940946f, -0.02311491f, 0.00780589f, 0.21542987f, 0.08565483f, -0.00785838f, 
    0.20034535f, -0.06263227f, 0.04506622f, 0.21837743f, 0.10907482f, -0.02101212f, -0.09812864f, 0.29116622f, 
    0.11623847f, 0.06110093f, 0.03880293f, 0.10550061f, -0.29946661f, -0.10930746f, 0.11625203f, -0.21364123f, 
    -0.00970268f, 0.04355870f, -0.07594018f, 0.03933861f, 0.12053175f, -0.05806186f, 0.03606759f, -0.04829478f, 
    -0.18739450f, 0.11628179f, -0.01931350f, -0.16047691f, 0.14793772f, -0.02814380f, -0.03877040f, -0.02412710f, 
    0.05591724f, -0.03963228f, 0.03349380f, -0.01121257f, 0.30690366f, -0.01449218f, -0.13238779f, 0.30044770f, 
    0.00181878f, 0.03217860f, 0.07541947f, -0.09019184f, -0.00841478f, -0.02483856f, -0.02534343f, 0.10329342f, 
    -0.04163062f, 0.02946265f, 0.04539644f, 0.06340068f, 0.00076553f, -0.17268525f, -0.11007572f, 0.16031988f, 
    0.01751342f, -0.00152167f, 0.12862475f, -0.08200087f, 0.09581634f, 0.07039426f, -0.06014176f, 0.07485200f, 
    0.09491147f, -0.00939071f, -0.05214996f, -0.00540084f, 0.03147540f, 0.04842208f, -0.07502369f, 0.01621484f, 
    -0.39272347f, 0.02477201f, 0.10888746f, -0.08159321f, 0.03961769f, -0.09969947f, -0.03833075f, -0.03322779f, 
    0.09772439f, 0.02504472f, 0.00781078f, -0.03482569f, 0.19706224f, 0.12049046f, -0.14079335f, 0.02127435f, 
    0.04469412f, 0.18075714f, 0.01303996f, 0.03414337f, -0.08159189f, 0.07203332f, 0.15452428f, 0.10276879f, 
    0.09775630f, -0.16129830f, -0.24567991f, -0.26801214f, -0.04502074f, 0.07678892f, -0.01223802f, 0.00858228f, 
    -0.05273879f, -0.07870346f, 0.00955453f, 0.08234192f, 0.12577882f, 0.09237134f, 0.05708554f, -0.02085572f, 
    0.11248025f, 0.03321885f, -0.12462202f, -0.10305876f, -0.19169174f, 0.08046810f, 0.18828116f, 0.05545138f, 
    0.03172235f, -0.07623246f, 0.13915464f, 0.00436786f, 0.01015566f, -0.07280497f, -0.02743361f, 0.12202501f, 
    0.04674222f, -0.05665237f, 0.04382585f, -0.01322212f, 0.08877515f, 0.24258214f, 0.20191692f, -0.07639694f, 
    0.10025284f, -0.03637093f, 0.08406680f, -0.03477940f, 0.04172436f, -0.02545161f, -0.00034842f, -0.09001060f, 
    -0.03845919f, -0.02649269f, -0.04118810f, -0.01228617f, 0.00560737f, -0.02110149f, 0.03239819f, 0.00938002f, 
    -0.05735565f, 0.01219933f, -0.05073437f, -0.02468167f, -0.04361537f, -0.01077755f, 0.01523148f, 0.05153127f, 
    -0.05182999f, 0.04083064f, 0.00605456f, -0.04592460f, 0.01285950f, 0.01761180f, 0.00662968f, -0.04374243f, 
    0.04645082f, 0.00893549f, -0.00348695f, 0.03956689f, -0.03339765f, -0.01721468f, 0.00806278f, 0.03927480f, 
    -0.01800973f, 0.04820514f, -0.01042251f, -0.02054328f, -0.02848984f, -0.01667480f, -0.04637221f, -0.02117950f, 
    0.03200545f, -0.00922081f, -0.02726919f, 0.03716246f, -0.00312083f, -0.04188797f, -0.01102507f, -0.03183952f, 
    -0.00364333f, -0.05140644f, 0.00510237f, -0.01593740f, 0.01627408f, -0.05497975f, 0.01053242f, 0.03113664f, 
    -0.00579287f, 0.02914904f, 0.03536600f, -0.05684651f, -0.03733429f, -0.01443059f, 0.04014556f, 0.02716579f, 
    -0.03119156f, -0.02172082f, 0.03456277f, 0.04088873f, -0.02390523f, -0.00776424f, 0.04436985f, 0.02202342f, 
    0.00191537f, 0.00760115f, -0.01255123f, 0.01420374f, 0.00532771f, 0.04433214f, -0.01949579f, -0.02024378f, 
    -0.04296560f, 0.00683067f, -0.03675782f, 0.02810119f, -0.02391444f, 0.03608901f, 0.00300819f, -0.01901128f, 
    -0.03808865f, 0.02088017f, -0.01319709f, 0.01899478f, 0.02481953f, -0.02020791f, 0.03257270f, -0.03386921f, 
    -0.00354908f, -0.00314600f, -0.00246342f, -0.04195752f, 0.03037333f, -0.01944599f, -0.01507130f, 0.02098609f, 
    -0.02022169f, -0.02568661f, -0.04138274f, -0.04991755f, 0.04699813f, 0.00097183f, -0.00826841f, -0.04227486f, 
    -0.04904563f, -0.00581748f, -0.02570869f, -0.05028048f, 0.03333415f, -0.06116239f, 0.04103161f, -0.00949153f, 
    0.00242642f, 0.01821039f, -0.00273225f, 0.01854030f, 0.00983646f, -0.04525734f, 0.03745987f, -0.02063760f, 
    0.03521340f, 0.02805770f, 0.01363883f, 0.01086362f, 0.01304857f, 0.03685576f, -0.04373788f, -0.02427044f, 
    -0.00317729f, -0.05017480f, -0.04730549f, -0.01914294f, -0.06019435f, 0.03201099f, -0.02290498f, 0.01439850f, 
    -0.00790047f, 0.01245878f, -0.01980860f, 0.00467448f, 0.04087727f, 0.03579956f, -0.03226446f, 0.02456371f, 
    0.00635324f, 0.03603068f, -0.01963537f, -0.02820029f, 0.01355080f, 0.02778711f, -0.03746621f, -0.02682942f, 
    0.01982553f, 0.00885180f, 0.03293119f, 0.00633234f, -0.04593413f, -0.00449177f, 0.02750075f, -0.00546942f, 
    -0.04657197f, -0.02130191f, 0.04378939f, -0.03409709f, -0.05262260f, 0.01208916f, 0.00507963f, 0.04801635f, 
    -0.01547015f, -0.01281512f, -0.01983684f, -0.00276762f, -0.03705809f, -0.03348117f, 0.01700669f, -0.05718466f, 
    -0.02842290f, -0.01461383f, 0.01019392f, 0.01657150f, 0.00492697f, 0.00077284f, -0.02701849f, -0.04965082f, 
    0.00918077f, -0.02631720f, -0.01007709f, 0.02526102f, 0.00856056f, -0.04154982f, -0.03251821f, -0.02804030f, 
    -0.00745309f, -0.03873890f, 0.01986522f, 0.02437462f, -0.04442793f, 0.02645901f, 0.05267296f, -0.00340720f, 
    -0.01965049f, -0.02526455f, -0.00286130f, -0.02064632f, 0.01933442f, -0.00203518f, 0.00407139f, 0.00355757f, 
    0.00601456f, -0.05985748f, -0.00821386f, 0.02423310f, 0.01363826f, 0.04032273f, -0.04998091f, -0.01825303f, 
    0.00395771f, -0.04937971f, -0.00087499f, -0.03827079f, 0.01920669f, 0.03552031f, 0.00483822f, 0.01908416f, 
    -0.03231104f, 0.02298617f, 0.00434702f, 0.02813363f, 0.00070738f, -0.00685383f, -0.03667583f, -0.03209023f, 
    -0.00287448f, 0.04306456f, -0.00082646f, -0.00653242f, -0.02777778f, -0.03452895f, -0.01673346f, 0.00025524f, 
    0.00220833f, -0.04300750f, -0.05689984f, 0.02501898f, -0.03573126f, -0.02413128f, -0.01062948f, 0.03598274f, 
    0.01058458f, -0.05354545f, -0.03015124f, -0.03068743f, 0.01939181f, 0.00827735f, 0.00509924f, 0.02900269f, 
    0.02613361f, -0.03859499f, -0.00729340f, 0.02476514f, -0.01435606f, 0.03290697f, 0.04234175f, 0.01760495f, 
    -0.02466624f, -0.00882715f, -0.03121849f, 0.01940097f, -0.01120953f, 0.03705229f, -0.04316865f, 0.03681786f, 
    0.00130909f, -0.05324720f, 0.04582753f, -0.05766151f, 0.00786934f, -0.01013435f, 0.04283350f, 0.00414132f, 
    0.05165901f, -0.04557819f, -0.04899316f, 0.03786538f, 0.00270117f, -0.06206594f, -0.03223936f, -0.01036824f, 
    -0.02591175f, -0.05357721f, -0.04639551f, -0.00053360f, -0.03386931f, -0.00336208f, 0.03873844f, -0.01757805f, 
    0.00029977f, 0.02034130f, -0.03833856f, -0.03958270f, 0.00788999f, -0.02218344f, 0.03851453f, 0.01513615f, 
    -0.03666409f, -0.06178091f, 0.00403250f, -0.03009013f, -0.00618515f, 0.03723638f, -0.02973031f, -0.00328520f, 
    0.02414432f, -0.03009057f, -0.04104795f, -0.01162014f, -0.00324180f, -0.03458348f, 0.01610944f, -0.02871163f, 
    0.02897047f, 0.00236248f, -0.04487077f, -0.06193613f, -0.03848458f, 0.03173936f, -0.03601226f, 0.02945196f, 
    0.00742799f, 0.02491454f, -0.00113749f, -0.05983179f, 0.00737615f, -0.04573397f, -0.01912314f, -0.01584669f, 
    0.01678383f, 0.00290411f, 0.02347976f, 0.03590492f, -0.05658807f, -0.03439201f, 0.00851955f, 0.01984988f, 
    0.00512186f, 0.03046030f, -0.05855436f, -0.03631032f, 0.04256817f, -0.01575613f, -0.01683135f, 0.00588799f, 
    0.03722895f, 0.01224064f, 0.02417010f, -0.01636818f, 0.03067247f, 0.00965853f, -0.02997346f, -0.04704044f, 
    -0.03227728f, 0.03139845f, -0.02961843f, 0.03857717f, -0.00764433f, -0.03302279f, -0.02909295f, 0.00331189f, 
    0.01564437f, -0.01568782f, 0.03555256f, -0.00651943f, 0.03212511f, 0.01589618f, -0.04354522f, -0.03493027f, 
    0.02016019f, 0.03276664f, 0.02268548f, 0.03209779f, -0.00934076f, 0.03535603f, -0.00665413f, -0.00074431f, 
    0.02317675f, -0.01753458f, 0.01959605f, -0.01700746f, -0.01879814f, -0.05036189f, -0.02984584f, 0.02637463f, 
    0.00802232f, 0.01642956f, -0.03084123f, 0.03741995f, 0.04305431f, -0.04168742f, -0.03960530f, -0.05123542f, 
    0.04725416f, 0.01370493f, -0.04645575f, -0.02654458f, 0.03131124f, 0.04340605f, 0.02156530f, -0.04810394f, 
    -0.04397619f, 0.01024868f, 0.03891226f, -0.01739624f, 0.05515246f, -0.04889290f, -0.03266677f, 0.01492328f, 
    -0.00057440f, 0.02711268f, 0.01374830f, -0.02232996f, -0.05246557f, -0.03611703f, 0.00167807f, 0.01503469f, 
    -0.03723769f, 0.02361810f, -0.00833446f, 0.01265537f, -0.05688586f, -0.03862262f, 0.01376279f, -0.03740330f, 
    0.00019923f, 0.00089263f, 0.00701297f, 0.01845116f, 0.01257000f, 0.00174866f, 0.01835956f, -0.04747152f, 
    0.04234737f, -0.01272767f, 0.03699441f, 0.02565709f, 0.00571466f, -0.03158583f, -0.02193658f, -0.04317235f, 
    0.02352020f, 0.04580292f, -0.02102136f, -0.03970556f, 0.04473686f, -0.04203884f, -0.03449639f, 0.00133587f, 
    -0.01131816f, -0.04256464f, 0.02779792f, 0.04394484f, -0.00227614f, -0.03096569f, 0.02004453f, -0.03331419f, 
    -0.01108181f, -0.03572277f, -0.02533461f, -0.00494925f, -0.03388731f, -0.00958013f, 0.01798488f, -0.00967955f, 
    -0.04810170f, -0.02875922f, -0.03882396f, -0.02285908f, 0.03932090f, -0.01543187f, -0.00650334f, -0.04475350f, 
    -0.04260435f, -0.01150071f, -0.02923386f, 0.02970932f, 0.04223769f, -0.03019168f, -0.01768449f, 0.01919927f, 
    -0.03521511f, 0.02974387f, -0.04390410f, -0.01018061f, -0.03932555f, -0.02104194f, -0.02810139f, -0.04943011f, 
    0.04139043f, 0.03182991f, -0.03069595f, -0.01582623f, -0.04478152f, -0.01236495f, -0.05091349f, 0.02961929f, 
    -0.01979499f, 0.00899108f, -0.03399874f, -0.02885026f, -0.00181904f, -0.00668036f, 0.02530398f, 0.02967814f, 
    0.03871802f, 0.04595429f, 0.03716531f, 0.00626173f, 0.04392623f, -0.02555640f, -0.02104740f, -0.00338665f, 
    0.00566960f, 0.00991619f, -0.02370611f, -0.00872307f, 0.02185321f, -0.01047508f, -0.02734461f, 0.02999275f, 
    0.02546109f, -0.00082761f, 0.01833924f, 0.03558229f, 0.00495633f, -0.00970191f, -0.05099418f, -0.01014345f, 
    -0.01722424f, 0.02216661f, -0.00281399f, -0.04757798f, -0.00425743f, -0.02040785f, 0.01996791f, 0.01993204f, 
    0.00933715f, -0.02854244f, -0.04612025f, 0.04621462f, -0.01516897f, 0.05521950f, 0.01320021f, 0.04628257f, 
    -0.02030021f, 0.02626836f, 0.01550729f, -0.00562212f, -0.04747686f, -0.05482448f, 0.04994280f, -0.00351660f, 
    -0.04533925f, 0.01312576f, 0.02218237f, 0.01816526f, 0.02203727f, -0.02752507f, 0.03981207f, 0.00639876f, 
    -0.04919189f, 0.00004660f, -0.00595604f, -0.01689522f, -0.02326914f, 0.03117487f, -0.01552018f, -0.02576034f, 
    -0.03243575f, -0.01657145f, -0.00553887f, 0.03805146f, -0.03187630f, 0.01254913f, 0.00613448f, -0.03831434f, 
    0.02452016f, -0.01113520f, 0.02040731f, 0.03074618f, 0.03590199f, -0.01612264f, -0.04630472f, 0.01215384f, 
    0.00035778f, 0.01549214f, -0.03624834f, -0.01142258f, 0.02304963f, -0.04175050f, -0.02753872f, 0.01948138f, 
    -0.00711238f, -0.05425407f, -0.05058687f, 0.04660755f, -0.02809888f, -0.03570811f, -0.02503887f, -0.01002182f, 
    0.02123912f, 0.02150780f, -0.02301109f, -0.03709362f, -0.01721363f, 0.04089695f, 0.03607228f, 0.02669168f, 
    0.03573614f, -0.04381108f, -0.03249622f, 0.02012652f, -0.04646915f, 0.00218184f, 0.03545065f, -0.03487730f, 
    -0.04842535f, -0.02359592f, 0.02945068f, -0.05396149f, 0.00936130f, -0.01596402f, -0.03364526f, 0.02931367f, 
    0.02955904f, -0.04636709f, 0.01643460f, 0.04352973f, -0.02159635f, -0.01715277f, 0.03566018f, -0.03987789f, 
    0.01554680f, 0.03971303f, -0.04603674f, -0.02563787f, -0.02519334f, 0.01920464f, -0.05202099f, 0.01708835f, 
    0.01806927f, 0.02724124f, 0.01098733f, 0.02419546f, 0.01010069f, -0.01441004f, -0.03986003f, -0.03423978f, 
    -0.00431213f, -0.04294218f, 0.03641749f, -0.01634061f, 0.02292329f, -0.00388782f, -0.03189166f, 0.01356659f, 
    -0.05480361f, -0.05167316f, -0.00575203f, -0.03531879f, -0.02590879f, 0.00213125f, -0.03597626f, -0.00057578f, 
    0.02640243f, 0.02705913f, -0.05487555f, 0.00260421f, 0.04923215f, 0.00499619f, -0.03843882f, -0.00870863f, 
    0.03182188f, -0.02262619f, -0.04376597f, 0.01923015f, -0.03828749f, -0.04975973f, -0.02600225f, -0.03135073f, 
    -0.02510365f, -0.02364169f, -0.00214707f, 0.01845268f, 0.02309378f, 0.05537689f, -0.00033004f, -0.01096591f, 
    -0.02269681f, -0.02751305f, 0.02497256f, -0.05068783f, -0.00923165f, -0.00164920f, -0.02382191f, -0.00938747f, 
    0.02428256f, -0.04293138f, -0.04103175f, -0.00530245f, -0.02178519f, -0.04121925f, -0.04704517f, -0.02643024f, 
    -0.01050983f, 0.03150186f, -0.01761715f, -0.00323444f, 0.01930390f, 0.03249068f, -0.03144515f, 0.00915347f, 
    -0.01409136f, 0.02012523f, 0.02173074f, -0.03471741f, -0.02705674f, -0.04998724f, -0.01799830f, 0.02625067f, 
    -0.01213744f, -0.02492839f, -0.02872828f, 0.04187322f, -0.00627820f, 0.00388972f, -0.03589953f, -0.02839624f, 
    0.02625966f, -0.05356467f, -0.02073944f, -0.00921086f, 0.02747104f, -0.02047442f, 0.00754109f, 0.04353327f, 
    0.03771065f, -0.02734232f, 0.00597684f, 0.01322006f, -0.00120876f, 0.02689805f, -0.03548414f, 0.02026433f, 
    0.04035526f, 0.03782818f, 0.02287762f, -0.02164080f, -0.04539971f, -0.04304266f, 0.03684445f, -0.02069548f, 
    0.02349003f, 0.03681035f, 0.01546591f, 0.01698353f, 0.03779825f, 0.03403213f, 0.02985734f, 0.01905834f, 
    -0.01522314f, 0.01688575f, -0.02991832f, 0.02307954f, 0.00277483f, 0.00836289f, -0.03409343f, 0.02725799f, 
    -0.01731594f, -0.02890339f, 0.00485438f, 0.03188966f, 0.02402993f, -0.01228299f, -0.01884969f, 0.03456545f, 
    0.02739486f, 0.01536701f, 0.03792315f, 0.03672638f, 0.02119142f, -0.03903904f, -0.03830972f, 0.02568194f, 
    0.01714939f, 0.03650730f, 0.02475504f, 0.00454850f, -0.01419381f, 0.04579036f, -0.00540148f, -0.00121398f, 
    -0.04630084f, 0.01079446f, 0.01236632f, -0.00788755f, 0.02869747f, 0.03237704f, 0.03869471f, 0.00825347f, 
    -0.05260772f, -0.03733039f, -0.02683563f, -0.00323372f, -0.02261984f, -0.00765971f, 0.01040745f, -0.02122650f, 
    0.00435717f, -0.00751374f, -0.05634120f, -0.05361400f, 0.01867743f, -0.02764436f, 0.03904356f, -0.02664089f, 
    0.02887383f, 0.00242205f, 0.01167157f, 0.03149983f, -0.03316954f, 0.01845323f, -0.01815970f, -0.03988626f, 
    0.02909202f, 0.02373778f, 0.01015157f, 0.01755094f, 0.02331592f, 0.02503436f, -0.04943223f, -0.03655735f, 
    -0.02815101f, -0.05490470f, -0.04983827f, -0.00415985f, -0.00016105f, 0.02404020f, -0.01269024f, 0.02944627f, 
    -0.05408912f, -0.02414660f, -0.05558520f, 0.01923508f, -0.04125128f, 0.04184701f, -0.05496822f, 0.01603005f, 
    -0.02097823f, -0.03618445f, -0.02878044f, -0.04078016f, -0.03112499f, -0.01931320f, 0.00195105f, -0.05045079f, 
    0.01044390f, -0.00666213f, 0.02000166f, 0.03611228f, 0.02573108f, -0.02277953f, -0.03523206f, -0.04001006f, 
    0.04154191f, -0.00893301f, 0.01990274f, -0.02284471f, 0.04077548f, -0.04470874f, -0.05750266f, -0.03127114f, 
    0.02702889f, -0.05483015f, -0.01492641f, -0.03070142f, 0.02158223f, 0.00384489f, -0.01225815f, 0.04009939f, 
    0.01692020f, -0.01892675f, 0.03381681f, 0.02569077f, 0.03328683f, -0.04463667f, -0.00603850f, -0.00122375f, 
    0.00407655f, 0.02586469f, 0.04338457f, 0.02165966f, -0.05028609f, -0.04689141f, 0.01269810f, -0.00300364f, 
    -0.03838722f, -0.01379136f, -0.02663071f, -0.01317792f, 0.02318185f, -0.01674553f, -0.03719037f, 0.03705278f, 
    -0.05875313f, -0.00040137f, -0.03088972f, -0.04165492f, -0.05046906f, -0.04244508f, -0.01723575f, 0.00696688f, 
    0.02031980f, -0.03140346f, -0.05239101f, -0.04682585f, 0.01005815f, -0.00390185f, -0.01412980f, 0.01652425f, 
    0.04177259f, 0.03666113f, 0.00929388f, 0.00302443f, -0.00776382f, 0.03892017f, -0.01187289f, 0.04281474f, 
    -0.02098540f, -0.03892545f, -0.02097454f, -0.01242053f, -0.02110059f, 0.01347181f, 0.00797796f, -0.04867798f, 
    -0.01024458f, 0.01808733f, -0.04410148f, 0.01537900f, -0.05419268f, 0.00020474f, -0.05337263f, 0.00052456f, 
    0.02508853f, -0.05524540f, 0.01077896f, -0.05656298f, -0.04248782f, -0.05626944f, 0.00176474f, 0.04091002f, 
    0.03868200f, -0.02388592f, 0.02023158f, -0.02140488f, -0.01463507f, 0.03437955f, 0.03726675f, 0.01339261f, 
    -0.00536959f, -0.01471177f, 0.00626979f, -0.04861470f, 0.00535642f, -0.05241827f, -0.02414748f, 0.01251870f, 
    -0.05368887f, -0.01247873f, -0.01649898f, -0.05214838f, -0.03187232f, -0.00176228f, -0.01538734f, -0.04977079f, 
    -0.04112917f, 0.00672395f, -0.03328151f, 0.00862066f, 0.02172516f, -0.04760136f, 0.04150661f, -0.00713785f, 
    -0.01723912f, -0.03113270f, -0.04111855f, 0.04119918f, -0.03913275f, 0.02544639f, -0.02428379f, 0.03775888f, 
    -0.04763036f, -0.05705884f, -0.00960563f, -0.00307217f, 0.01190410f, -0.00313623f, -0.03402719f, 0.03683979f, 
    -0.04825523f, -0.04313190f, 0.01376457f, -0.01771999f, -0.03643752f, 0.00333942f, -0.00036461f, 0.00230236f, 
    0.01909444f, -0.01805082f, 0.02322835f, 0.01128787f, 0.00869481f, -0.02297389f, -0.02065262f, -0.00864586f, 
    -0.05116840f, 0.03110512f, 0.00009108f, -0.01690029f, -0.04434881f, 0.02214799f, -0.00221978f, -0.00224866f, 
    0.00178368f, -0.04060819f, -0.04541117f, -0.04684364f, -0.00120978f, -0.03735874f, -0.00572279f, 0.02571716f, 
    0.03017342f, -0.05514636f, -0.02356832f, -0.01206571f, -0.03211062f, 0.03928026f, 0.00846142f, -0.00585526f, 
    -0.05371075f, -0.00656230f, -0.02994831f, -0.04103795f, 0.01547723f, 0.01558698f, -0.04879909f, -0.01874047f, 
    0.02090021f, -0.00865993f, -0.02981992f, 0.00325447f, -0.03461571f, 0.01960168f, -0.02563403f, -0.04394102f, 
    -0.02507003f, -0.01148290f, 0.00845134f, -0.05877197f, 0.01863185f, -0.02207156f, 0.00086212f, -0.04716868f, 
    0.01727559f, 0.00289521f, 0.01953149f, -0.02916027f, -0.04051127f, 0.01787089f, 0.03989373f, -0.05080381f, 
    0.02136737f, -0.03602050f, 0.01423933f, 0.02035038f, -0.04690789f, -0.01722867f, -0.04739518f, -0.02437366f, 
    -0.01085458f, -0.03054744f, -0.01556798f, 0.00665547f, 0.01272234f, -0.01918682f, -0.03812810f, -0.02314614f, 
    -0.04725420f, 0.03840565f, -0.01216496f, -0.03281669f, -0.04086686f, -0.02219913f, -0.00310939f, -0.05026065f, 
    -0.04820889f, -0.01483229f, -0.00821447f, 0.00066378f, 0.01088368f, 0.00251576f, 0.00930472f, 0.00125377f, 
    0.03120710f, 0.00966176f, -0.02153050f, 0.02610741f, -0.02956285f, -0.04188641f, 0.00134416f, -0.00604457f, 
    -0.03255856f, 0.03643063f, -0.01716597f, 0.00938346f, 0.02171164f, -0.03972869f, 0.01692457f, -0.03501074f, 
    -0.02405220f, 0.03879905f, -0.02788657f, -0.01493804f, 0.01378761f, -0.01369230f, -0.02771013f, 0.01110934f, 
    -0.04040019f, -0.01197991f, 0.01171512f, -0.00374561f, -0.00446075f, -0.05145153f, -0.01204702f, 0.00982070f, 
    -0.00079372f, 0.02167991f, 0.00203991f, 0.00263600f, 0.01508585f, -0.04347179f, -0.01883708f, -0.03671288f, 
    0.00083656f, -0.00102918f, -0.02016601f, -0.02386024f, -0.04735309f, -0.00286331f, 0.01201701f, -0.01245366f, 
    -0.03137934f, -0.02047393f, 0.02277281f, -0.02120454f, -0.00903944f, 0.01564070f, -0.00626987f, -0.00926822f, 
    0.01668393f, -0.02236163f, 0.00651067f, -0.00094512f, -0.03735914f, -0.01920244f, -0.01254504f, -0.03752936f, 
    0.02075474f, 0.00178803f, -0.00900536f, -0.05860954f, -0.01876661f, 0.01387367f, -0.05535833f, -0.01735028f, 
    0.04907890f, -0.01890770f, -0.03688551f, 0.02274767f, -0.05808038f, 0.00964219f, -0.00180857f, -0.01977213f, 
    -0.04096080f, 0.02171826f, -0.02008411f, -0.05155481f, -0.00438347f, 0.00747839f, -0.00727467f, -0.03118488f, 
    -0.03980054f, -0.03996593f, -0.01236991f, -0.03085655f, -0.05700645f, -0.04779052f, 0.03909190f, 0.03402942f, 
    -0.01728525f, -0.03666101f, 0.00781693f, -0.00947441f, -0.03728558f, -0.04818840f, -0.03354926f, -0.00799744f, 
    0.02835228f, -0.04519317f, -0.05504312f, -0.04348130f, -0.02428987f, 0.02143881f, -0.00371974f, 0.00355143f, 
    0.03367764f, -0.01185829f, -0.05628371f, 0.00669233f, -0.00351830f, 0.01214953f, -0.04869305f, -0.04636711f, 
    -0.02671344f, 0.01570782f, -0.05538005f, 0.04093605f, 0.03491729f, 0.00307631f, -0.01959351f, -0.01440844f, 
    -0.02592107f, 0.03890926f, 0.03742567f, -0.01703678f, -0.01448908f, -0.05917573f, -0.05645418f, -0.00909818f, 
    -0.02183747f, 0.03777039f, 0.00851758f, 0.03225500f, -0.03689212f, 0.00159358f, -0.04876542f, -0.00026767f, 
    0.02087008f, -0.01582737f, -0.02646980f, 0.04099417f, -0.01617188f, -0.04006197f, 0.00579840f, 0.04033187f, 
    -0.01844619f, 0.03427133f, 0.03537538f, -0.00633808f, 0.03270317f, 0.03637811f, -0.02440056f, 0.00931801f, 
    -0.01243424f, -0.04002246f, -0.02215044f, -0.02950738f, -0.05957158f, -0.04249559f, 0.00886680f, 0.03781720f, 
    -0.02752194f, -0.03363084f, -0.02913195f, -0.02540699f, 0.04193395f, 0.01086742f, 0.02810809f, 0.03571002f, 
    -0.01644776f, -0.05450590f, -0.02375156f, 0.04115611f, -0.00889516f, 0.03828854f, -0.04640502f, -0.03674973f, 
    0.00241924f, -0.02215975f, 0.02298825f, 0.03421899f, -0.05368336f, -0.01233200f, -0.05446658f, -0.05939888f, 
    -0.02948932f, -0.05448755f, 0.02165851f, -0.02005128f, -0.01441650f, 0.02536043f, 0.03006677f, 0.02465910f, 
    0.03395413f, -0.03091361f, -0.04720009f, -0.00115883f, 0.03774527f, 0.01714473f, -0.04678066f, -0.05764301f, 
    -0.02264543f, 0.02833077f, 0.02188110f, 0.00492937f, -0.05022791f, -0.04594028f, 0.01690024f, -0.01653803f, 
    -0.00216938f, -0.00979303f, 0.03233633f, -0.04509133f, -0.03647643f, -0.02310554f, -0.04030550f, 0.03195432f, 
    -0.01415950f, -0.04439319f, 0.03550912f, 0.01027027f, -0.02983845f, -0.00848683f, -0.03553941f, -0.05680218f, 
    0.00427322f, -0.01442571f, -0.00839132f, -0.05055512f, -0.05776512f, -0.04112095f, -0.05594191f, -0.04108219f, 
    -0.00556682f, 0.00809385f, -0.01814074f, -0.00037271f, -0.01235119f, 0.03682038f, -0.00669970f, 0.01055493f, 
    0.00233925f, 0.00051446f, 0.03194996f, -0.03948778f, 0.00235081f, -0.00109093f, -0.01807590f, -0.01004338f, 
    0.01567778f, -0.03429180f, 0.02794145f, -0.01647498f, 0.00530908f, 0.01366288f, -0.03708095f, 0.03111892f, 
    0.02080309f, -0.03481145f, -0.02863551f, 0.03164268f, -0.05119221f, -0.01664301f, -0.03686742f, -0.02238624f, 
    0.03093049f, -0.01234902f, 0.00691704f, 0.02415952f, 0.00671500f, -0.04013918f, 0.00151860f, -0.03221986f, 
    0.03979528f, -0.02993387f, -0.00435414f, -0.01330251f, -0.00720090f, 0.02421595f, 0.00534333f, 0.01154145f, 
    -0.00059262f, 0.01729351f, -0.05948196f, -0.00856977f, -0.04169166f, -0.05293815f, 0.01699357f, -0.01830361f, 
    -0.00327917f, 0.01389764f, 0.03868102f, -0.04394533f, 0.01632208f, -0.01149343f, -0.03497995f, -0.05440710f, 
    0.03851566f, -0.04675055f, 0.02547326f, -0.04419007f, 0.01008432f, -0.05054260f, 0.01039048f, -0.03334134f, 
    -0.00247422f, 0.02522306f, 0.03011342f, -0.01685338f, -0.02098431f, -0.03740666f, -0.03130697f, -0.03707231f, 
    0.00750518f, -0.00527298f, -0.05135673f, -0.05059007f, -0.04469880f, 0.02235648f, -0.05347112f, 0.00031567f, 
    -0.00855532f, -0.01242801f, -0.01532276f, 0.02675407f, -0.05033138f, 0.00172809f, 0.03380398f, -0.02943916f, 
    -0.02701900f, 0.04197352f, -0.02781303f, -0.04430398f, -0.03663342f, 0.01105006f, -0.03366486f, 0.02831253f, 
    -0.03748091f, -0.02147510f, -0.02764992f, -0.03103599f, 0.04153046f, -0.01248278f, -0.05357629f, 0.02964228f, 
    0.02126530f, -0.05611497f, 0.02562987f, -0.05022500f, -0.00377828f, -0.04586026f, 0.02358250f, -0.04068984f, 
    -0.01311088f, -0.03172976f, -0.01429620f, -0.00491481f, 0.04114176f, 0.00143533f, 0.03163611f, -0.05576605f, 
    0.00751430f, 0.03142635f, 0.01876112f, -0.04121226f, 0.00216129f, 0.02982409f, -0.05762846f, 0.02503507f, 
    -0.03094567f, -0.03514954f, -0.04600830f, -0.03622325f, 0.04644237f, -0.01247720f, -0.02106672f, 0.02362802f, 
    -0.05711736f, -0.01161600f, -0.00313314f, -0.04165680f, -0.01251235f, -0.02090176f, -0.04006061f, -0.04738896f, 
    -0.01190684f, -0.03938361f, -0.05704244f, -0.00447844f, 0.02753290f, -0.05134772f, -0.02215356f, -0.05378594f, 
    0.03061277f, 0.02706889f, 0.00552966f, -0.01119541f, 0.00150292f, 0.02497254f, -0.02185572f, -0.03710904f, 
    -0.01854245f, 0.02265950f, 0.01957780f, -0.05896707f, -0.00074657f, 0.01435529f, 0.03549617f, 0.00377540f, 
    -0.13742501f, 0.00748119f, 0.20608407f, 0.14466785f, -0.06284692f, -0.04626146f, 0.14100285f, 0.03099720f, 
    0.07246018f, 0.01344209f, -0.01742855f, 0.08709216f, -0.13314320f, 0.10493243f, 0.00743104f, -0.41109562f, 
    0.14175043f, 0.04133345f, -0.05794096f, -0.05031844f, 0.02222335f, 0.05407135f, -0.02736512f, 0.01878947f, 
    0.01135149f, 0.01050166f, 0.05945722f, -0.01222778f, 0.14108151f, -0.05818531f, 0.03975599f, 0.08622142f, 
    0.02140855f, 0.01471812f, 0.14454469f, -0.04950031f, -0.43467996f, 0.07877753f, 0.03082313f, -0.14433172f, 
    0.20041575f, 0.04264342f, 0.05883023f, -0.08366214f, 0.17677641f, -0.02485367f, -0.02567183f, 0.06259924f, 
    0.17995165f, 0.01111886f, -0.07301639f, -0.18855430f, -0.03494727f, 0.06347988f, 0.08838727f, -0.06522164f, 
    -0.03815660f, 0.02589566f, 0.00646876f, -0.06937175f, 0.10935947f, -0.11469526f, -0.11284228f, 0.14660631f, 
    -0.10039131f, -0.00502790f, -0.02462044f, 0.16683374f, -0.08459443f, 0.04379066f, -0.02046419f, 0.02367086f, 
    0.18634832f, 0.20619752f, 0.08966067f, -0.08805939f, 0.00829810f, 0.04300744f, -0.10500228f, -0.05581143f, 
    0.03480490f, 0.00878258f, 0.03865016f, -0.01497894f, 0.36674324f, -0.34819543f, -0.14053056f, 0.08150760f, 
    -0.00417479f, 0.08877329f, 0.08076557f, 0.11774171f, -0.07387354f, 0.05933690f, 0.05322609f, 0.01450032f, 
    -0.47107980f, 0.22017322f, 0.06895035f, -0.30913401f, 0.12045948f, 0.08508515f, 0.02927276f, 0.02480264f, 
    0.00574029f, 0.09735902f, 0.02550744f, 0.04007503f, 0.62189323f, 0.06921805f, -0.21011354f, 0.12381731f, 
    0.01344269f, -0.04711060f, 0.06781095f, 0.06705838f, 0.07531837f, -0.00532822f, -0.03709185f, -0.13802157f, 
    -0.05130331f, -0.20783840f, 0.00303731f, -0.10720401f, -0.00033387f, 0.06871144f, -0.04823308f, -0.09547582f, 
    0.03515868f, 0.12754735f, 0.14998420f, 0.20475335f, -0.13809881f, -0.12244513f, 0.08039191f, -0.02338777f, 
    -0.09761249f, -0.02185261f, 0.10099410f, 0.09544484f, -0.05878563f, 0.05717031f, 0.02862021f, -0.02663523f, 
    0.39342532f, -0.11443029f, 0.10910636f, 0.16457845f, -0.01488049f, -0.05973049f, -0.08929128f, -0.11438865f, 
    0.06500905f, 0.10620537f, -0.11304657f, 0.09948678f, -0.06806237f, -0.10117341f, 0.07107876f, 0.09644593f, 
    0.07842179f, 0.11026918f, 0.08394065f, 0.05066749f, 0.08409439f, -0.06495126f, 0.09485022f, -0.05433452f, 
    0.42323393f, 0.08031605f, -0.03430860f, -0.11067116f, -0.05163467f, 0.10858907f, 0.00848686f, -0.01768739f, 
    -0.02578777f, 0.10515022f, 0.14917733f, -0.03775499f, 0.21088630f, -0.07965498f, 0.08414878f, -0.11310383f, 
    0.04890795f, 0.13969415f, 0.12236967f, -0.09316943f, -0.05532260f, -0.00523070f, -0.01309864f, -0.19038787f, 
    -0.21816844f, 0.22528788f, 0.12253061f, -0.22175109f, 0.12869202f, 0.06705822f, 0.18264790f, -0.03700850f, 
    -0.01404411f, 0.10441027f, -0.00824315f, -0.05694246f, -0.22442880f, 0.13212343f, 0.08028001f, -0.21689707f, 
    -0.01534053f, 0.11857107f, -0.01537262f, -0.00103342f, -0.01772634f, 0.11639678f, 0.03885088f, -0.10476635f, 
    -0.29657719f, 0.06837395f, 0.11016948f, 0.15518945f, 0.08200501f, 0.12545754f, 0.06274670f, 0.05468650f, 
    0.05057825f, -0.11720830f, 0.06845281f, 0.06259327f, 0.02924113f, 0.09847543f, -0.17612037f, -0.24857785f, 
    0.01131057f, 0.04665531f, 0.00004316f, 0.07700016f, 0.15246624f, 0.09055338f, 0.02622971f, -0.06129311f, 
    -0.01154899f, -0.16124316f, 0.05692814f, 0.19344971f, 0.04917353f, -0.07246814f, -0.01284501f, 0.20879368f, 
    0.08499271f, -0.09298744f, 0.17507556f, -0.00977600f, -0.20753182f, 0.15139371f, -0.13549934f, 0.02181047f, 
    0.01500086f, 0.02034729f, -0.04431220f, 0.06978912f, -0.09120152f, 0.12362262f, 0.05245132f, 0.06199681f, 
    -0.18028463f, 0.23975864f, -0.12884127f, -0.34100702f, 0.21492656f, 0.06121627f, 0.03896628f, 0.07315350f, 
    0.04518890f, 0.06242189f, -0.10030500f, -0.07711910f, -0.39061242f, 0.10116387f, -0.08544425f, -0.06513065f, 
    0.13018018f, 0.05650920f, 0.02306258f, -0.05218830f, -0.02018345f, 0.00585446f, 0.11304193f, 0.03680120f, 
    0.40271965f, 0.16147266f, 0.04509794f, -0.01818134f, -0.07730196f, -0.00307648f, 0.09176454f, 0.17201094f, 
    0.13685347f, 0.18758211f, 0.05525839f, 0.01282533f, -0.23856696f, 0.13755965f, 0.05822647f, -0.19119100f, 
    0.05795978f, 0.03149947f, 0.07482452f, 0.10675161f, -0.07882877f, -0.02047442f, -0.11076108f, -0.09781133f, 
    0.13463275f, 0.08006310f, 0.10656031f, -0.02449501f, 0.01839267f, -0.03816080f, 0.02935207f, -0.20462289f, 
    0.17224185f, 0.15887122f, 0.03445043f, 0.13304113f, 0.10104884f, -0.03117402f, -0.15831760f, -0.23182383f, 
    0.16112499f, -0.03963583f, -0.16620418f, -0.03888523f, 0.03881926f, 0.08970883f, 0.00795740f, 0.17953053f, 
    0.21481350f, -0.11689727f, 0.03747023f, 0.06612412f, 0.15035143f, 0.06622484f, 0.04960378f, -0.01363834f, 
    -0.08442822f, -0.05672418f, -0.11159529f, 0.04019231f, -0.12556316f, 0.07574409f, 0.18750563f, -0.04779605f, 
    0.06552601f, -0.08112087f, -0.08433543f, 0.00476148f, 0.14429584f, 0.13529727f, 0.09665012f, -0.04696444f, 
    -0.07353207f, 0.18355747f, 0.09033804f, -0.03315056f, 0.00435723f, -0.09582156f, 0.12415522f, 0.11031954f, 
    0.08092100f, -0.03049716f, 0.04538851f, 0.07628527f, -0.06579599f, 0.24288666f, 0.04194314f, -0.40126121f, 
    0.08797694f, 0.06404646f, 0.12794735f, 0.01076018f, -0.06023429f, -0.19137082f, 0.14984351f, 0.04903720f, 
    0.03573571f, -0.00305185f, 0.05491206f, -0.05896169f, 0.08121039f, -0.12893264f, 0.04188908f, 0.08585306f, 
    -0.03555818f, -0.08683418f, 0.02797533f, -0.14199896f, -0.16191188f, 0.10766696f, 0.07315653f, 0.05199888f, 
    0.02029758f, 0.02953515f, 0.04874656f, -0.00427315f, -0.00236736f, 0.05156433f, 0.01697973f, -0.08848666f, 
    -0.04322382f, 0.19478042f, 0.07585062f, -0.45335355f, -0.04691765f, 0.06424163f, 0.03504599f, 0.00088505f, 
    0.06473760f, 0.02144241f, 0.16345817f, -0.02673337f, -0.02274351f, 0.02771652f, -0.12298170f, 0.11843150f, 
    0.04633174f, 0.00535432f, 0.07314521f, 0.07302491f, 0.00878001f, -0.07304263f, -0.07312297f, -0.00463585f, 
    -0.13858329f, -0.26356497f, 0.12960657f, -0.08968215f, -0.10163618f, -0.05049422f, -0.00084275f, 0.08488514f, 
    0.05497597f, -0.14269891f, -0.00012431f, 0.05316630f, -0.14189959f, -0.02161015f, -0.10603574f, 0.08894807f, 
    -0.02274568f, 0.09705985f, -0.00110296f, 0.09827115f, 0.03547835f, 0.05982841f, 0.00002413f, 0.07136328f, 
    0.06631150f, 0.02568337f, 0.20586035f, -0.20971607f, -0.01323096f, -0.12525210f, 0.00407348f, 0.06394099f, 
    -0.00149250f, 0.03660112f, 0.12864780f, -0.06047520f, 0.51718980f, 0.11701882f, 0.07222620f, -0.08441687f, 
    -0.03656021f, -0.05150821f, -0.10628292f, 0.03334830f, 0.15772176f, 0.11146614f, 0.04764349f, 0.00086001f, 
    0.28933981f, -0.10732318f, 0.13322477f, 0.48154306f, 0.01016027f, -0.07019643f, 0.03060913f, 0.12827660f, 
    -0.11347766f, 0.08826496f, -0.01105180f, -0.07591911f, 0.33000267f, 0.14670750f, -0.02810757f, -0.13329332f, 
    -0.13574795f, -0.05542621f, 0.06746658f, -0.06426813f, -0.00136233f, 0.04513146f, -0.04289540f, -0.01576982f, 
    -0.01621934f, -0.23034157f, -0.10217658f, -0.07372066f, 0.05010433f, -0.08525640f, -0.07125915f, 0.02820594f, 
    -0.08717851f, 0.01064187f, -0.10960259f, -0.04133840f, -0.21878490f, 0.12734559f, 0.20496710f, -0.25957489f, 
    0.03071018f, -0.03824178f, 0.20030321f, 0.15515429f, -0.06696875f, 0.00770201f, 0.08963661f, 0.04352382f, 
    0.18501078f, 0.16756222f, 0.01478648f, -0.09484282f, -0.00312384f, -0.05263105f, -0.14992860f, 0.02051372f, 
    -0.03537665f, -0.02943352f, -0.10105180f, -0.08471205f, -0.09890603f, -0.25795165f, 0.02936505f, -0.43983606f, 
    0.00394065f, 0.01744885f, 0.09164407f, 0.12045437f, 0.07714746f, -0.04561490f, 0.04039907f, 0.08317273f, 
    -0.08154619f, -0.09138498f, -0.11994439f, 0.19851582f, -0.07460105f, 0.07750823f, -0.02720681f, 0.01718151f, 
    -0.06502400f, 0.03731053f, 0.02804992f, 0.20935379f, 0.36557621f, -0.15179312f, 0.04138885f, -0.08677935f, 
    -0.05701189f, 0.02967202f, -0.05347272f, 0.04300724f, 0.06032941f, 0.06331915f, 0.06229153f, 0.09108276f, 
    -0.20998743f, -0.22962643f, 0.10296667f, 0.10134337f, 0.00314515f, -0.01755055f, 0.04423136f, -0.00879804f, 
    0.03868606f, 0.02527264f, 0.05029830f, -0.00693174f, 0.21982040f, 0.07681227f, 0.03043017f, 0.19225474f, 
    -0.00615428f, 0.01451453f, -0.10780562f, -0.03219771f, -0.06795683f, -0.02406452f, -0.05057655f, -0.11281493f, 
    0.09990259f, -0.14592294f, 0.07526955f, -0.22098354f, -0.14873421f, -0.09834132f, 0.02675884f, 0.09067640f, 
    0.00006398f, -0.03996244f, 0.03600973f, 0.15516610f, -0.19197859f, -0.14461076f, 0.04994817f, -0.22924255f, 
    0.10008869f, 0.01252955f, 0.16810556f, -0.04308309f, 0.05024572f, 0.08439570f, 0.04377709f, -0.08846738f, 
    0.30987528f, 0.01783497f, 0.16126162f, 0.17712201f, 0.01820350f, 0.05241830f, -0.11648152f, 0.05192564f, 
    -0.00759239f, 0.03849384f, 0.06957582f, 0.04860051f, -0.05056652f, 0.21351276f, 0.12810341f, -0.32660285f, 
    0.04661548f, -0.14249192f, -0.03736502f, -0.03243071f, 0.20226139f, -0.07655999f, 0.08200936f, -0.04915153f, 
    0.04660653f, -0.12189935f, 0.13660824f, 0.21076857f, 0.02296759f, -0.02131503f, -0.08203306f, 0.05455172f, 
    -0.06079997f, -0.03671978f, 0.04639128f, -0.10242626f, 0.28730315f, -0.05610989f, -0.08640456f, 0.23915996f, 
    -0.04628871f, -0.02474655f, 0.03876513f, -0.04446430f, 0.02319224f, 0.05127234f, -0.11108843f, 0.09028672f, 
    0.01469893f, -0.03501779f, -0.15307821f, 0.11331535f, -0.04420194f, -0.10760688f, -0.04428054f, 0.03385668f, 
    -0.09057610f, -0.01142189f, 0.04294427f, -0.13250192f, 0.10072564f, 0.00744331f, -0.19336984f, 0.45416147f, 
    -0.00950473f, 0.02240201f, 0.06181530f, 0.03803207f, 0.08086445f, -0.03922162f, -0.04455162f, -0.10454433f, 
    -0.31417423f, 0.14471941f, 0.13531145f, -0.07803259f, 0.03633712f, -0.04919377f, -0.06918598f, 0.01712356f, 
    -0.07714073f, 0.04858045f, -0.08241948f, 0.06751132f, 0.15876290f, 0.28914446f, -0.20586284f, 0.27526450f, 
    0.03492353f, 0.06981555f, -0.06520654f, 0.05171480f, -0.01354270f, 0.04753232f, -0.06347480f, 0.04082245f, 
    -0.35153461f, 0.17372870f, -0.22812288f, -0.27527636f, -0.07838570f, 0.12896273f, -0.02676656f, -0.09399029f, 
    -0.02878038f, -0.00262378f, -0.04061245f, -0.03384628f, -0.08287635f, -0.16187243f, -0.01678748f, -0.10852305f, 
    0.11232912f, 0.02536435f, -0.04631617f, 0.10944902f, -0.08923411f, 0.10311216f, 0.17135757f, -0.02007265f, 
    0.10047008f, 0.07476350f, 0.18355000f, 0.09156877f, -0.05614903f, -0.06996030f, -0.01141289f, 0.16609178f, 
    0.07232902f, 0.02702432f, -0.01936841f, -0.16376461f, -0.06122961f, 0.24000920f, 0.07413250f, 0.14786088f, 
    -0.04381466f, -0.00916295f, 0.07741293f, -0.04224759f, -0.08512376f, -0.00288283f, 0.03465654f, -0.15768936f, 
    0.01404906f, -0.01125673f, -0.00350376f, -0.03501897f, 0.03534143f, 0.00617221f, -0.02478505f, 0.02005004f, 
    -0.03389804f, -0.00464556f, -0.00457328f, -0.03847850f, -0.01071306f, -0.02026278f, -0.02407060f, -0.03844548f, 
    0.03835173f, -0.04859122f, 0.03665431f, 0.00438149f, 0.00344417f, -0.01283975f, 0.02217081f, 0.03151501f, 
    -0.03862930f, 0.02219437f, -0.02452119f, -0.03407774f, 0.04488324f, 0.01305629f, 0.03426329f, 0.00006457f, 
    -0.02251433f, -0.01421912f, -0.03419950f, -0.03045832f, -0.04946590f, -0.00702161f, -0.02665916f, 0.00231665f, 
    -0.00300101f, -0.05127728f, 0.03495201f, -0.05018421f, 0.01367105f, -0.04982479f, -0.05183707f, 0.04004833f, 
    0.02938367f, -0.02497927f, -0.00883410f, -0.00597917f, -0.03506315f, -0.01195731f, -0.02950245f, -0.02153382f, 
    -0.00665077f, 0.03430077f, -0.05390823f, -0.04427605f, -0.02524837f, -0.04828512f, 0.01511927f, -0.05693889f, 
    0.01860586f, -0.04360415f, 0.00016056f, -0.02424275f, -0.02936813f, -0.03923789f, 0.03724183f, -0.05373472f, 
    -0.04101406f, 0.00206861f, 0.02804700f, -0.02415988f, 0.03868302f, 0.01510627f, 0.01360879f, 0.01941290f, 
    -0.03756331f, -0.03661140f, -0.03004569f, -0.03716792f, -0.04367697f, 0.00224286f, 0.02875371f, -0.01899471f, 
    0.00635261f, -0.03221856f, -0.03448945f, 0.01530818f, 0.01500289f, -0.04493956f, 0.00388291f, -0.05251928f, 
    -0.01220414f, -0.04112183f, -0.05495755f, 0.02680077f, -0.03548950f, -0.02175453f, -0.05075946f, -0.00408606f, 
    0.04261541f, -0.00058773f, 0.03234824f, -0.02439538f, 0.01686080f, 0.03780494f, 0.01749917f, 0.02324176f, 
    0.01312875f, 0.00444757f, 0.03603699f, -0.03907912f, 0.00054694f, 0.00008132f, -0.05111192f, -0.04855280f, 
    0.00087004f, -0.03152133f, -0.03540320f, 0.03950752f, -0.00851688f, -0.00276169f, 0.00434679f, 0.01886121f, 
    -0.00638980f, 0.01136188f, -0.00710155f, 0.04334700f, -0.03828410f, -0.03359412f, 0.02498074f, -0.02024864f, 
    -0.01945981f, -0.04793007f, 0.04210938f, -0.04157360f, 0.00944847f, -0.00598860f, -0.04664595f, -0.03843851f, 
    0.03849518f, 0.04410584f, 0.01937640f, 0.00730305f, -0.05610312f, -0.03998527f, -0.02084326f, -0.04780716f, 
    -0.00172388f, -0.04233425f, 0.01805052f, -0.01104706f, -0.05556395f, -0.00038126f, 0.03292117f, -0.04365616f, 
    -0.03524858f, -0.01507047f, 0.04198838f, 0.04433073f, 0.00836205f, 0.02738284f, 0.04351027f, 0.03811963f, 
    0.03297560f, -0.04418327f, -0.05116273f, 0.03226849f, 0.04177045f, 0.00964378f, -0.00939648f, -0.04353521f, 
    -0.04976021f, -0.03782088f, -0.05484505f, -0.04987125f, 0.03638760f, -0.05237155f, -0.04138109f, -0.03487319f, 
    -0.04002100f, -0.03559711f, 0.00751342f, -0.05028407f, -0.05646760f, -0.04620137f, -0.02175611f, -0.00712392f, 
    0.02037628f, -0.00993616f, -0.00606320f, 0.02174320f, 0.01906895f, 0.04488936f, -0.04201186f, -0.02575859f, 
    -0.05358861f, 0.02845031f, -0.04862301f, 0.01698271f, -0.04297937f, -0.04989905f, 0.03160358f, -0.02276909f, 
    0.01887509f, -0.04314214f, 0.01002576f, -0.00651324f, 0.02600603f, -0.03854382f, -0.05596096f, -0.05420029f, 
    -0.01504488f, 0.04440251f, -0.01975438f, -0.01395186f, -0.04439072f, -0.01213792f, -0.03636219f, -0.02183657f, 
    -0.02761975f, -0.03157458f, 0.01265188f, 0.01736415f, -0.03557096f, -0.05373858f, 0.02063459f, 0.00260088f, 
    0.01501217f, 0.03915608f, -0.02133180f, -0.01006053f, -0.02257133f, -0.01214066f, 0.03863553f, -0.01025038f, 
    0.02137265f, -0.05318527f, 0.01983775f, -0.03227249f, 0.01295175f, 0.02020692f, -0.04939796f, 0.02003492f, 
    -0.05510356f, 0.01892063f, -0.04191516f, -0.00905794f, 0.01684535f, -0.02218291f, -0.00367964f, -0.04062256f, 
    -0.05153332f, -0.00511969f, -0.00317890f, 0.03583183f, -0.04552136f, 0.04296945f, -0.02681707f, -0.01712359f, 
    -0.01961245f, 0.03189481f, 0.01715607f, 0.00931736f, 0.03689256f, 0.00959366f, -0.05431683f, 0.02926722f, 
    -0.04860434f, 0.00070518f, -0.02493728f, 0.02104520f, 0.01109939f, 0.01408115f, 0.02221682f, -0.03115491f, 
    -0.00281141f, 0.02825513f, 0.03857183f, -0.05140541f, 0.03226814f, -0.03498374f, -0.02943024f, 0.03929792f, 
    -0.00639139f, 0.03293462f, 0.02368637f, 0.01169534f, 0.01431493f, 0.04438691f, 0.02751126f, -0.03219416f, 
    -0.04991317f, -0.02163613f, 0.00036161f, 0.02330658f, -0.00464140f, 0.01817412f, 0.00496814f, -0.01165451f, 
    -0.04495667f, 0.00170973f, 0.01706220f, -0.00885346f, 0.01911343f, 0.04141145f, -0.00884506f, 0.00090209f, 
    0.03307388f, -0.05552362f, -0.03424023f, 0.02711575f, -0.04615557f, -0.05570620f, -0.03156951f, -0.02334204f, 
    0.01117252f, -0.04702511f, 0.02831463f, 0.02745497f, -0.02570339f, -0.03040355f, -0.04603823f, 0.02516017f, 
    -0.01217818f, 0.04440497f, -0.03280766f, -0.04585523f, -0.04853044f, 0.02533433f, -0.02816297f, 0.02481470f, 
    0.03431492f, -0.00568323f, 0.01365762f, 0.01878543f, -0.04430134f, 0.03606738f, -0.05217104f, -0.00254493f, 
    0.02071330f, -0.05144319f, -0.00542525f, 0.04303398f, 0.02377024f, -0.02385001f, 0.04167457f, -0.04147647f, 
    0.02909616f, -0.02208128f, 0.03417759f, -0.02301656f, 0.03211957f, 0.04074680f, 0.01991777f, -0.03603788f, 
    -0.04640010f, 0.03558430f, 0.03847271f, -0.04840175f, -0.04241223f, 0.02552694f, -0.01165415f, -0.03055288f, 
    -0.02811881f, 0.01876600f, -0.02630354f, 0.00526543f, -0.01248250f, 0.01903537f, -0.03893793f, -0.02153403f, 
    0.02323365f, 0.03326218f, -0.01569761f, 0.02360994f, 0.00717232f, 0.03676830f, -0.00448428f, 0.02218742f, 
    0.01345068f, -0.02653233f, -0.04296064f, 0.00770075f, 0.02722804f, -0.00800745f, 0.01824696f, -0.03905503f, 
    -0.03578809f, -0.02640120f, 0.00228201f, -0.02344887f, 0.00963403f, -0.05263189f, -0.03617012f, -0.05057041f, 
    -0.00349430f, 0.00206110f, -0.03195950f, 0.02124212f, -0.03803565f, 0.01329566f, 0.04468069f, 0.02417378f, 
    -0.00157095f, 0.01596572f, -0.01709090f, 0.03627260f, 0.02691064f, 0.02057582f, -0.05081209f, -0.05160551f, 
    -0.00669705f, 0.00571621f, -0.03917784f, -0.00699753f, -0.03670087f, 0.00007634f, -0.03316822f, -0.01472965f, 
    -0.04515034f, -0.00155513f, -0.02354781f, -0.01302868f, 0.03009177f, -0.01198397f, -0.01940074f, -0.00670031f, 
    0.02176224f, 0.01686403f, -0.04291378f, 0.04440720f, -0.03474908f, 0.03139113f, -0.00631911f, 0.03518293f, 
    -0.00221467f, -0.03404161f, -0.04098298f, -0.00473274f, -0.03326702f, 0.02299475f, -0.00171292f, -0.00620474f, 
    0.01145328f, -0.01287022f, 0.04286986f, -0.02655982f, 0.03337985f, 0.02250322f, 0.02098916f, 0.01566112f, 
    -0.04480985f, -0.05287850f, 0.02228567f, -0.03075732f, -0.01800720f, -0.01156188f, 0.00178389f, -0.04844508f, 
    0.00246679f, -0.05536015f, -0.01666261f, 0.02867596f, -0.02894838f, 0.03094641f, 0.01954645f, -0.03152591f, 
    -0.00031727f, -0.05105258f, -0.02817619f, -0.04301677f, -0.03791568f, -0.02250136f, 0.03914224f, -0.03301343f, 
    -0.03170865f, 0.00099735f, 0.03236294f, 0.00556284f, -0.01068377f, -0.03085306f, 0.00333945f, 0.01868108f, 
    -0.02271387f, -0.05377838f, -0.04814858f, -0.05502513f, -0.03835621f, 0.00520835f, 0.03954683f, -0.03438121f, 
    -0.01684275f, -0.03487260f, -0.00939891f, -0.01464480f, -0.00337186f, -0.03850103f, -0.01684256f, -0.04720227f, 
    0.02680381f, 0.03001850f, 0.02781348f, 0.03158651f, -0.01631794f, -0.01822809f, -0.00650645f, 0.00578164f, 
    -0.00893404f, -0.02812021f, -0.05441631f, 0.00874241f, 0.03245345f, 0.02902305f, -0.02954219f, 0.01601196f, 
    -0.00864297f, -0.03264153f, -0.04318272f, 0.01918329f, -0.04230847f, -0.02182184f, 0.01370344f, -0.03441937f, 
    0.04466527f, 0.03529803f, -0.04588077f, -0.05019816f, -0.02198090f, -0.03008997f, 0.00084034f, -0.04162927f, 
    -0.05465259f, -0.01922715f, 0.03243255f, -0.02225436f, 0.00064150f, 0.02789583f, -0.00014785f, 0.01998408f, 
    0.03107127f, -0.04938979f, 0.02914897f, 0.01246152f, 0.04369841f, 0.02975837f, 0.03266231f, -0.01245657f, 
    -0.02327901f, -0.04612298f, -0.00694775f, -0.04800675f, 0.03779363f, -0.00348866f, -0.00244360f, 0.00915755f, 
    0.04577615f, 0.02856960f, -0.03057524f, -0.04066235f, 0.03656870f, -0.04332932f, -0.02032200f, 0.02747276f, 
    0.04170001f, 0.00934587f, 0.01951515f, 0.02509097f, -0.04545717f, -0.05468045f, -0.04385194f, 0.03255761f, 
    -0.01386763f, 0.00109574f, 0.02696819f, 0.02876422f, 0.02898283f, 0.02704578f, 0.02177695f, 0.02678128f, 
    -0.03988612f, 0.01242019f, 0.02519922f, -0.04243969f, 0.00151073f, -0.00108624f, -0.03441132f, 0.03733352f, 
    0.00810101f, 0.04154715f, -0.01554362f, -0.02547373f, -0.00340218f, 0.00477199f, -0.00933427f, 0.03051654f, 
    0.04135499f, -0.04026374f, -0.01720047f, 0.02699246f, -0.00803657f, -0.02621540f, -0.01027097f, -0.01228097f, 
    -0.04202898f, -0.03653179f, -0.05443897f, -0.04990252f, -0.04073684f, 0.04250712f, -0.01601835f, -0.00565010f, 
    -0.04049008f, 0.04394891f, -0.03222067f, 0.00682135f, 0.00535177f, -0.05669831f, -0.04269071f, -0.03064491f, 
    -0.04161066f, 0.02568400f, -0.01399617f, -0.02469074f, 0.04476636f, 0.03069695f, 0.00405559f, 0.01805177f, 
    0.02237416f, -0.00876226f, 0.03285975f, -0.01945929f, 0.03888230f, -0.03684906f, -0.00520019f, 0.00166084f, 
    0.04472798f, -0.04857526f, -0.02581005f, -0.02952853f, -0.01066068f, -0.02488717f, 0.00048394f, -0.02951973f, 
    -0.02574935f, 0.02144808f, 0.02885380f, -0.01100808f, -0.02401499f, -0.03019313f, 0.02292939f, 0.01658186f, 
    0.01069808f, 0.01092643f, -0.00899741f, 0.02872814f, 0.00891487f, -0.04237159f, -0.04505962f, 0.02230015f, 
    -0.03959934f, 0.00039702f, -0.01999669f, 0.04262463f, -0.01698250f, -0.00472854f, -0.03760773f, -0.00512718f, 
    0.01843171f, 0.04347867f, -0.01183242f, -0.00182890f, -0.01546615f, -0.04654218f, 0.02008850f, -0.04387035f, 
    -0.00583973f, -0.00218344f, -0.03360589f, -0.01828026f, -0.00489843f, -0.01541113f, -0.04961222f, -0.03219786f, 
    -0.03251640f, 0.02374506f, -0.05364756f, -0.05682300f, -0.02006520f, -0.04885019f, 0.01256438f, 0.00594649f, 
    -0.00444958f, -0.01106476f, -0.04588335f, -0.02910282f, -0.04778694f, -0.05585060f, -0.01192101f, -0.01465592f, 
    0.00301185f, -0.01037959f, -0.05549937f, -0.03739082f, -0.04703094f, -0.02901956f, -0.04661874f, -0.03880957f, 
    0.01986871f, 0.00082623f, 0.03272805f, 0.00029610f, 0.02944421f, 0.00003737f, -0.03911453f, 0.02016713f, 
    -0.03320448f, -0.04661872f, -0.00892759f, -0.02795847f, 0.02238056f, 0.01816496f, -0.03302420f, 0.01928692f, 
    0.02343100f, -0.00048652f, -0.00001965f, -0.00112353f, 0.02909531f, -0.02819753f, -0.00936398f, -0.04265279f, 
    -0.00169095f, -0.04385346f, -0.01977539f, -0.00436060f, -0.01953657f, 0.02777530f, 0.00374876f, 0.00529466f, 
    -0.05479079f, -0.03930569f, -0.02805959f, 0.03379065f, -0.04921585f, -0.00032605f, 0.03448489f, -0.04083960f, 
    0.01512143f, -0.03605031f, -0.00120575f, -0.01336375f, 0.03862915f, -0.00255722f, 0.03896848f, -0.01338027f, 
    0.03562815f, 0.01523518f, -0.02860625f, -0.04270792f, -0.02742046f, -0.01756939f, -0.02012789f, -0.04378540f, 
    0.15842097f, 0.02292787f, -0.13686606f, -0.11341503f, 0.08040187f, -0.06035550f, 0.20246632f, -0.04061476f, 
    0.07279781f, 0.06611785f, -0.00884984f, 0.12062335f, -0.41153407f, -0.17606333f, 0.10657035f, 0.02429751f, 
    -0.10221828f, -0.08108668f, -0.04639136f, 0.07414097f, -0.00402726f, -0.04431171f, -0.02660430f, 0.00391799f, 
    -0.23906037f, 0.10478292f, 0.09795585f, 0.01319911f, 0.01741046f, 0.07698224f, 0.08217273f, -0.03808820f, 
    -0.07568866f, 0.01757598f, -0.00143606f, -0.07206298f, -0.02085492f, -0.04970852f, -0.10244124f, 0.18243955f, 
    -0.28631085f, -0.00397602f, 0.05809999f, 0.01325930f, -0.01810337f, 0.02842855f, 0.06113731f, 0.08212461f, 
    0.19235635f, 0.02892577f, 0.21122198f, 0.21822187f, -0.01193090f, -0.03562305f, -0.09333594f, 0.02304789f, 
    0.04204927f, 0.01751836f, -0.00566441f, 0.01820831f, -0.02827171f, 0.06739087f, 0.07187079f, -0.05256718f, 
    0.11359129f, -0.02867340f, 0.04171443f, -0.01300523f, 0.06926448f, 0.01099479f, 0.11889772f, -0.02896364f, 
    -0.23289484f, 0.15510389f, -0.08722720f, 0.12131841f, -0.03779374f, 0.12605880f, 0.08542832f, 0.01944823f, 
    0.01400755f, 0.06338091f, 0.03088849f, -0.05182182f, -0.00838141f, 0.35835892f, 0.14387263f, -0.20867807f, 
    0.04223540f, -0.02801877f, -0.12532398f, -0.01823002f, 0.14547326f, -0.01990928f, 0.04868118f, -0.00418528f, 
    0.01516022f, -0.03085842f, -0.01844234f, 0.12081829f, -0.15987363f, -0.03255612f, -0.08790638f, 0.01534697f, 
    0.05273861f, 0.02173409f, -0.01649690f, -0.05194395f, -0.33117312f, 0.03986380f, -0.03026594f, -0.14529876f, 
    0.03035196f, 0.00369035f, -0.01351305f, 0.07257029f, 0.11178374f, -0.12782291f, 0.05422639f, -0.07331306f, 
    0.04734550f, 0.15466467f, 0.14364143f, 0.24428548f, -0.09018829f, 0.00729439f, 0.00184658f, -0.04466564f, 
    -0.00869496f, 0.05709306f, -0.11070019f, 0.00442123f, 0.05963385f, 0.37797967f, 0.06412048f, 0.15439044f, 
    -0.00748655f, 0.00123375f, 0.09070676f, 0.03341295f, 0.03319498f, -0.08226867f, 0.12343593f, 0.09587187f, 
    0.17780702f, 0.17622761f, 0.07955725f, -0.03326073f, 0.00119341f, 0.00179915f, 0.05413101f, 0.04910146f, 
    -0.06201466f, 0.07217480f, 0.00205841f, 0.03021917f, 0.09532420f, -0.11756502f, -0.02427408f, 0.03940207f, 
    -0.08952505f, 0.00020549f, 0.10783490f, 0.09800649f, -0.06894997f, -0.00739319f, 0.02632762f, -0.05870637f, 
    0.19096383f, -0.04720902f, 0.12324156f, 0.31334007f, -0.08379780f, 0.05347042f, -0.03324817f, -0.00151893f, 
    0.04214485f, -0.07658044f, -0.01482412f, -0.09067615f, -0.02234333f, 0.03289141f, 0.06908681f, 0.15880314f, 
    0.00588843f, 0.00726154f, 0.06383494f, 0.13209504f, -0.01693071f, 0.04177023f, -0.02186533f, 0.07880049f, 
    0.07542189f, -0.18367293f, 0.07540425f, 0.43590084f, -0.07444797f, -0.03851883f, 0.04661853f, -0.03189800f, 
    -0.12101397f, -0.10916600f, -0.03271292f, -0.06297249f, -0.03327276f, -0.19534533f, -0.08076189f, 0.09919488f, 
    -0.06515887f, -0.16211869f, -0.05754670f, 0.05606112f, -0.06233037f, 0.09948317f, -0.00417544f, 0.12092277f, 
    -0.01449779f, -0.09114037f, -0.06846144f, -0.04648682f, -0.07112142f, 0.05375877f, 0.12407974f, 0.01103921f, 
    -0.01120166f, 0.00252347f, 0.06974259f, 0.00435476f, 0.13066602f, 0.02226059f, 0.24234730f, 0.10474242f, 
    0.09221728f, 0.07028743f, -0.00497425f, -0.04869134f, -0.00381612f, -0.11619677f, 0.01886003f, -0.10040384f, 
    0.01660346f, 0.00973682f, -0.00746507f, -0.21205932f, -0.03993891f, 0.17487757f, -0.07800543f, -0.16704990f, 
    -0.03056686f, 0.03032809f, 0.02800041f, 0.00857236f, 0.44831261f, 0.36227244f, -0.04005519f, 0.11977616f, 
    0.00619005f, -0.02412185f, 0.18266496f, -0.05275145f, -0.08535077f, 0.03411436f, -0.05928191f, -0.00884477f, 
    0.40163645f, -0.14591478f, 0.16244018f, 0.25435454f, -0.20499100f, 0.06421153f, -0.01565723f, 0.06504643f, 
    -0.09999925f, -0.00569745f, -0.06660023f, 0.02727488f, -0.09386598f, -0.06194988f, -0.09303699f, -0.05047842f, 
    -0.17928015f, -0.12995903f, -0.10403469f, 0.00838844f, -0.01155043f, 0.09569057f, 0.00815598f, 0.02004755f, 
    -0.07473504f, -0.03111671f, 0.07844932f, 0.06875620f, -0.00583870f, 0.05239080f, 0.11339367f, -0.06817120f, 
    -0.14487618f, 0.04885218f, -0.00214490f, -0.07514264f, 0.16237299f, -0.14118159f, 0.01025981f, 0.19224755f, 
    -0.09544542f, -0.01744249f, -0.00155568f, -0.09111179f, 0.07130738f, 0.00714186f, 0.01381141f, 0.00323188f, 
    0.09808937f, 0.18596502f, -0.12803939f, 0.13490981f, 0.15440309f, 0.04614331f, -0.03532671f, 0.06202743f, 
    -0.07052999f, -0.01308056f, 0.02368034f, 0.08569597f, 0.19063638f, 0.26351884f, -0.12269416f, 0.10563716f, 
    -0.05838437f, -0.15268163f, -0.07503121f, 0.01857249f, 0.01690024f, -0.05267189f, -0.18380749f, 0.01885752f, 
    -0.42753056f, 0.14862400f, 0.04468311f, 0.01251360f, 0.10565602f, -0.02565433f, 0.06232873f, -0.05646132f, 
    0.02081149f, 0.09403133f, -0.03679430f, -0.05989745f, -0.11693866f, -0.04134201f, 0.07792126f, -0.03919058f, 
    0.03859519f, -0.00435127f, 0.12056730f, 0.07304987f, 0.11228370f, -0.05682616f, 0.03031464f, 0.02900049f, 
    0.06510245f, 0.05918249f, -0.10297257f, 0.06089159f, 0.01014533f, 0.06308866f, 0.10142945f, 0.00802237f, 
    0.02388977f, 0.03867104f, 0.00630330f, 0.01979649f, -0.12137910f, -0.11460886f, -0.06802043f, 0.25779703f, 
    -0.01784270f, 0.05204321f, -0.02289798f, -0.11621913f, -0.00346421f, 0.05524662f, -0.00935122f, 0.06418614f, 
    -0.13300903f, 0.00782812f, 0.16262600f, 0.19598921f, 0.02441585f, -0.05944311f, 0.00779983f, 0.06047325f, 
    -0.03707587f, 0.05540535f, 0.11600839f, -0.00051023f, -0.39681983f, 0.03618709f, 0.18046658f, 0.13483968f, 
    0.10584724f, -0.01373004f, 0.01071138f, -0.03007940f, -0.00983787f, -0.03432021f, 0.02212614f, -0.04424645f, 
    0.26712954f, 0.04658195f, -0.05448367f, -0.27264047f, 0.00920330f, 0.07220829f, -0.04571287f, -0.02569098f, 
    -0.01387955f, -0.03552436f, -0.01473849f, 0.05523346f, 0.14677902f, 0.10051365f, 0.02235050f, 0.09821374f, 
    0.12527582f, 0.01523101f, 0.05668138f, 0.13877539f, -0.01354229f, 0.07211735f, -0.00994454f, 0.05999822f, 
    0.06060931f, -0.12121769f, 0.20296167f, 0.13449453f, 0.01831977f, -0.05062633f, -0.05914095f, -0.03521217f, 
    0.02782000f, 0.03967297f, -0.00568517f, 0.12345211f, -0.01440132f, 0.06898701f, -0.16071449f, 0.16452934f, 
    0.05030155f, -0.09418682f, 0.00424678f, -0.07781103f, 0.01097113f, -0.00867407f, 0.07267517f, 0.02271413f, 
    0.15506902f, 0.23003973f, 0.13906375f, -0.08428279f, -0.02996603f, -0.01235502f, 0.03655497f, 0.03142628f, 
    -0.00223562f, -0.00266614f, -0.10889510f, 0.13614173f, -0.11797330f, 0.05257312f, 0.13484296f, 0.22615026f, 
    0.09009565f, 0.04319810f, 0.05481592f, -0.06419481f, 0.08751787f, 0.01845130f, 0.03164658f, 0.05421047f, 
    0.05624390f, 0.12186606f, -0.03303209f, 0.20778291f, -0.00675496f, 0.00603133f, 0.06145063f, -0.06482252f, 
    -0.10330644f, -0.06072430f, -0.07130819f, -0.01266420f, -0.14634675f, 0.35885000f, -0.01514883f, -0.38009173f, 
    0.06216699f, 0.00868337f, 0.03557349f, -0.05567662f, 0.01626120f, -0.06476808f, -0.02384369f, 0.08833726f, 
    0.35239455f, -0.20533501f, 0.12018444f, 0.21289703f, 0.09499495f, -0.00285152f, 0.09269910f, -0.08304059f, 
    -0.12845312f, 0.13387835f, -0.02819699f, -0.02866106f, -0.18300849f, 0.24888736f, 0.12834503f, 0.05033012f, 
    0.17941862f, 0.01481797f, 0.01894138f, 0.15367179f, -0.06738212f, -0.01915648f, 0.16330956f, 0.02689108f, 
    -0.07765540f, -0.04179985f, 0.05613717f, -0.02919069f, 0.11829755f, -0.10305683f, 0.04583310f, 0.04639075f, 
    -0.08238776f, -0.04191497f, -0.12751435f, -0.04336347f, -0.01002056f, 0.00114189f, -0.03806978f, 0.05011167f, 
    -0.14754859f, -0.06824488f, -0.12531574f, -0.05851763f, -0.06301867f, -0.02171451f, -0.00754999f, -0.10965227f, 
    -0.08591659f, -0.09392007f, 0.08607370f, -0.08402822f, 0.04427505f, 0.00718023f, 0.01722161f, 0.04974033f, 
    -0.17853089f, 0.07077378f, -0.11565913f, 0.02904070f, 0.19134299f, -0.14057922f, 0.22876781f, 0.06193721f, 
    0.08688374f, 0.01486436f, -0.02854961f, -0.00449934f, 0.06047425f, 0.00770888f, 0.02547948f, 0.05305046f, 
    -0.28102553f, -0.36133221f, -0.01750101f, 0.06330882f, -0.14789554f, -0.07618195f, -0.02413782f, -0.14203474f, 
    -0.01445608f, 0.01056036f, -0.00668012f, -0.09018032f, -0.00978004f, 0.20277072f, 0.02868160f, -0.03178211f, 
    0.11628159f, 0.01707749f, -0.04838598f, 0.00671699f, -0.11552365f, -0.09784565f, -0.08954979f, -0.04277929f, 
    0.03559153f, 0.22998296f, 0.08215219f, 0.03399086f, -0.07981994f, -0.03894403f, -0.01368678f, 0.09200124f, 
    0.02696855f, -0.09072760f, 0.00382925f, -0.05306026f, -0.09353492f, 0.00911713f, 0.06010482f, 0.15740022f, 
    -0.01188460f, -0.03103950f, -0.07475567f, -0.02774738f, -0.03176241f, 0.04824631f, -0.02955682f, -0.04659123f, 
    -0.07087336f, 0.15880884f, 0.06223552f, 0.22445758f, -0.03596769f, 0.06903970f, -0.04635541f, 0.08651134f, 
    0.05492612f, 0.09677463f, 0.02664226f, 0.10988455f, -0.12482782f, 0.23224157f, 0.15102948f, -0.02977562f, 
    0.04373435f, 0.04362386f, 0.08560917f, -0.03873845f, 0.00226814f, -0.05057221f, 0.00999278f, 0.01374981f, 
    -0.24642695f, 0.29400468f, 0.00950551f, 0.07369877f, -0.08021839f, -0.05482960f, -0.02017386f, -0.07704320f, 
    -0.01258021f, -0.05432217f, -0.00658757f, -0.01080568f, 0.35397747f, -0.13214433f, 0.08639560f, 0.21459116f, 
    0.03779193f, 0.00201227f, -0.01552470f, -0.08347569f, 0.02499004f, 0.02200415f, 0.03028467f, -0.05218687f, 
    -0.12373525f, -0.22242607f, 0.07982165f, -0.04621096f, 0.06158109f, -0.07845338f, -0.09850060f, -0.09690625f, 
    0.01356032f, -0.04011061f, 0.03037856f, -0.11981874f, 0.19673295f, 0.08699507f, -0.06362569f, 0.13817814f, 
    0.08847231f, -0.08487529f, 0.10013223f, -0.06626940f, 0.02062604f, 0.10470917f, 0.10833368f, 0.06648834f, 
    -0.29999343f, 0.25118244f, 0.03183900f, 0.05917267f, 0.05655009f, -0.00120757f, 0.02245797f, 0.04633407f, 
    -0.07974498f, -0.02647042f, 0.00246159f, -0.00378160f, 0.17516366f, 0.28476709f, -0.07092674f, 0.02749428f, 
    -0.01994399f, 0.11769050f, 0.00421658f, 0.09538739f, -0.00991729f, 0.11199586f, 0.11596590f, 0.06405280f, 
    0.13111341f, -0.10395268f, -0.03630924f, -0.28154656f, 0.09300089f, 0.02440481f, 0.05156817f, -0.02668049f, 
    0.03443082f, 0.10413682f, -0.05873390f, -0.00236512f, -0.10716707f, 0.00760858f, -0.06171643f, -0.00924260f, 
    -0.05684074f, 0.06083634f, -0.02129529f, -0.00137409f, -0.20011286f, -0.06392602f, 0.07278055f, 0.04363790f, 
    -0.03008359f, 0.06324153f, 0.24514399f, 0.40757284f, 0.01967598f, 0.08593362f, -0.12766892f, 0.16152336f, 
    0.05003477f, -0.05779531f, 0.02113832f, -0.04571793f, 0.06148850f, 0.18844692f, 0.11790238f, 0.04305368f, 
    -0.02606124f, 0.04962194f, 0.02916917f, -0.12511265f, 0.00705031f, -0.01927688f, -0.08022057f, -0.16297987f, 
    -0.03465587f, -0.02094679f, -0.05509821f, 0.00320765f, -0.04731664f, -0.00713590f, 0.02464637f, -0.03615516f, 
    -0.04655431f, -0.01222119f, -0.02761594f, 0.01951522f, 0.04412139f, 0.03207570f, -0.04132670f, 0.00985477f, 
    -0.01945092f, 0.01996615f, 0.02338262f, 0.02890742f, 0.01570437f, -0.01561254f, 0.03227927f, 0.01523331f, 
    -0.01743452f, -0.04497370f, 0.01495035f, -0.00819653f, 0.03454501f, 0.00006629f, 0.00492202f, 0.00906312f, 
    -0.03392472f, 0.01352040f, -0.00860929f, 0.03150088f, -0.03545146f, -0.00521726f, -0.01958196f, -0.01411853f, 
    0.01263770f, 0.02154542f, 0.02938547f, 0.00978751f, -0.04168991f, -0.02141209f, 0.01466765f, 0.03170983f, 
    -0.03670417f, -0.04626176f, 0.02431232f, -0.00172538f, -0.04199414f, 0.00067564f, 0.01337272f, -0.01319708f, 
    0.03748631f, -0.04946059f, -0.02421405f, 0.00959448f, -0.05783943f, 0.03090178f, 0.00852962f, 0.02483985f, 
    -0.01658137f, 0.03712013f, 0.01988449f, 0.01817144f, 0.03361393f, 0.00645695f, -0.00654278f, -0.05052802f, 
    -0.01804581f, 0.04005917f, 0.04038647f, 0.00359290f, -0.05397885f, 0.03057058f, 0.02140833f, -0.01319653f, 
    -0.04100838f, -0.02187336f, -0.04174598f, -0.04679088f, 0.04236049f, -0.00851372f, 0.00804947f, 0.00825162f, 
    0.03849474f, -0.00663893f, 0.02678853f, -0.00485300f, -0.03548403f, 0.00013236f, 0.03692018f, -0.04216087f, 
    0.01603096f, 0.02493645f, 0.00894538f, 0.03553472f, -0.02760449f, -0.04475224f, 0.02266124f, -0.03742185f, 
    -0.00373725f, -0.05955276f, 0.00892744f, 0.03613591f, -0.04908721f, -0.03273388f, 0.03889962f, 0.02343539f, 
    -0.04028518f, -0.01597910f, -0.05282804f, -0.00528423f, 0.03123587f, -0.05195584f, -0.03987107f, -0.02077175f, 
    0.03165073f, 0.03245660f, 0.03380539f, -0.01771490f, 0.03919756f, 0.02960708f, -0.00273551f, 0.00935551f, 
    0.03392424f, -0.00552934f, -0.04444241f, 0.03469393f, 0.02876337f, -0.02288744f, 0.04213510f, 0.01741683f, 
    -0.00399468f, -0.00664267f, -0.05173159f, -0.00398919f, -0.04169766f, 0.04267538f, -0.04045260f, -0.05614451f, 
    -0.04147264f, -0.05069466f, -0.01360002f, -0.02852331f, -0.02445120f, 0.04027978f, 0.01291352f, -0.04081478f, 
    0.00336394f, 0.03035324f, 0.00270856f, -0.01483939f, -0.00568256f, -0.04356146f, -0.02754875f, -0.01282099f, 
    -0.04223778f, 0.00206640f, 0.01475648f, -0.05593209f, 0.00038412f, -0.02363784f, -0.03310945f, -0.03943643f, 
    0.02808732f, -0.01575968f, 0.01130669f, -0.01072123f, -0.04856175f, 0.01214716f, -0.00353367f, -0.02931505f, 
    -0.00131786f, 0.02173001f, -0.03348586f, -0.04629178f, -0.02230025f, -0.04293513f, 0.03510529f, -0.00256067f, 
    -0.04309213f, 0.02318630f, -0.01494345f, -0.01663968f, -0.05457050f, -0.01978890f, -0.01897683f, 0.00452452f, 
    -0.03750794f, 0.02051770f, -0.02026016f, -0.04486243f, -0.05595237f, -0.01434033f, 0.01529365f, -0.03655477f, 
    0.02706608f, -0.04298666f, -0.05095078f, 0.02574606f, -0.04614976f, 0.01991903f, 0.00344332f, 0.03066184f, 
    0.01307929f, -0.02071188f, -0.01416832f, -0.04573814f, -0.01168154f, -0.04564124f, 0.03054179f, 0.04366898f, 
    0.00218255f, 0.04112784f, 0.01049954f, -0.05242190f, -0.05423890f, -0.00053238f, -0.00166470f, -0.05759408f, 
    -0.01943410f, -0.04396301f, 0.03681488f, -0.05215453f, 0.00144956f, -0.00412987f, -0.02276126f, -0.04402854f, 
    0.02682658f, 0.02219681f, -0.05037336f, 0.03149394f, 0.01340583f, -0.02232370f, -0.05126801f, -0.04937925f, 
    -0.04551468f, 0.01138788f, -0.02656538f, -0.03923644f, 0.00115003f, -0.02549669f, 0.00325469f, -0.04760413f, 
    0.01274175f, 0.01313555f, -0.00962292f, -0.03721695f, 0.03860195f, 0.02694347f, -0.03554141f, -0.00208688f, 
    0.03245661f, 0.00435290f, 0.02698731f, 0.03871147f, -0.05596502f, -0.00779849f, -0.05086305f, 0.01119148f, 
    -0.01263141f, -0.01465596f, -0.04348263f, -0.00010211f, -0.03199145f, -0.02422253f, -0.05070692f, -0.04842242f, 
    0.01345229f, 0.02883422f, 0.03822469f, -0.02249953f, -0.02776130f, 0.00916386f, 0.02359317f, -0.03558110f, 
    -0.04501775f, -0.02449080f, -0.02999764f, 0.02628712f, 0.00001725f, -0.03073870f, 0.04372226f, -0.04197311f, 
    -0.02040305f, -0.03398287f, -0.00981296f, -0.04201548f, 0.01391547f, 0.03257895f, 0.02465000f, 0.00553924f, 
    -0.00675671f, -0.04346444f, -0.01902483f, 0.01991626f, -0.05694967f, -0.05146077f, 0.03665350f, 0.02309749f, 
    -0.02214139f, -0.03356044f, -0.01169877f, -0.03196140f, 0.02611409f, -0.00685069f, -0.00913199f, 0.02639182f, 
    -0.04271335f, -0.00515906f, -0.03306431f, -0.05077039f, -0.01826337f, -0.04706033f, 0.03093234f, 0.02219424f, 
    -0.00748608f, -0.01912242f, -0.03147759f, 0.01570158f, -0.00149815f, 0.04401449f, -0.04360301f, -0.04245029f, 
    0.00908421f, -0.04391276f, 0.02248534f, 0.03795569f, -0.03316949f, -0.04725049f, -0.02513075f, 0.02084570f, 
    -0.02372816f, -0.02444954f, 0.00942671f, -0.04171716f, -0.00839598f, -0.03684568f, 0.02695601f, -0.01489538f, 
    -0.04783206f, -0.03969534f, -0.02765165f, 0.01391292f, 0.03515321f, 0.02822721f, -0.00761152f, 0.00682543f, 
    0.01454378f, 0.04150360f, -0.04457418f, 0.02113839f, 0.02695300f, -0.01353603f, -0.01807530f, -0.01670976f, 
    0.00260571f, 0.04162750f, -0.04887505f, -0.04731350f, -0.05633608f, 0.00436108f, 0.02823243f, 0.03215488f, 
    0.02662971f, -0.00354291f, 0.03242429f, 0.02348859f, -0.01900443f, 0.02439449f, -0.04869571f, 0.04833742f, 
    0.02866112f, 0.03548049f, -0.03118312f, 0.01886631f, -0.03918434f, 0.04396507f, -0.02043606f, -0.01923113f, 
    -0.04870908f, -0.05271085f, 0.01458783f, -0.01550920f, 0.04260606f, 0.02705647f, -0.01466124f, 0.03758414f, 
    0.04269934f, -0.00581704f, 0.02704152f, 0.01528602f, -0.02407507f, -0.01229735f, 0.02250833f, 0.03553149f, 
    -0.04593107f, -0.01316427f, 0.03216731f, 0.01635279f, 0.02573645f, 0.00695572f, 0.02841387f, -0.05032993f, 
    0.01045754f, 0.01487190f, -0.01039985f, -0.04418642f, -0.04928705f, -0.00883910f, -0.02525660f, -0.03697742f, 
    -0.03520585f, -0.02193004f, 0.04501816f, 0.03688602f, 0.02778540f, -0.04591883f, -0.05453400f, -0.03512803f, 
    -0.04184986f, 0.01656271f, 0.01562682f, -0.03100623f, 0.01180311f, 0.01982796f, -0.04663101f, -0.04049185f, 
    -0.04952804f, 0.02581916f, -0.02276895f, 0.01957242f, -0.02526507f, 0.02997691f, -0.03224541f, 0.01303589f, 
    -0.01457840f, -0.02356474f, -0.04875179f, 0.00137018f, -0.02189169f, -0.01968344f, 0.04029457f, -0.02875411f, 
    0.00704958f, 0.00310470f, -0.02169939f, -0.04480753f, 0.02934935f, -0.02709512f, -0.05092595f, -0.00162556f, 
    0.01881045f, 0.02621184f, 0.03572744f, -0.02369015f, 0.02280931f, -0.00244018f, -0.03828820f, 0.01833677f, 
    -0.04790905f, -0.01017957f, -0.03780156f, 0.01010131f, 0.01580968f, 0.03963623f, 0.01809911f, -0.00677707f, 
    -0.01922799f, 0.04182819f, -0.02806423f, -0.00091948f, 0.02133628f, -0.01663305f, -0.02123697f, -0.03059276f, 
    -0.03694050f, 0.00415936f, -0.05301247f, -0.03700757f, -0.00763247f, -0.03228720f, 0.02021182f, -0.03865318f, 
    -0.00038741f, -0.03413502f, 0.03324140f, -0.04280493f, -0.03322461f, 0.02232004f, 0.02756946f, -0.04767220f, 
    -0.04000610f, -0.02887065f, -0.05505199f, 0.03579764f, 0.03557267f, 0.00202303f, -0.04326246f, 0.02461872f, 
    -0.00924329f, 0.02948838f, -0.02352635f, -0.00207308f, 0.01065453f, 0.04077088f, -0.03715903f, 0.02610700f, 
    -0.00200740f, -0.02013406f, -0.00349841f, -0.02924256f, -0.01654724f, 0.01809421f, -0.02218506f, 0.03334079f, 
    -0.02617810f, -0.05550039f, 0.01349351f, -0.04314261f, -0.03958254f, 0.02053958f, -0.03160815f, -0.03486546f, 
    -0.03734693f, 0.03150972f, 0.03715498f, -0.03575094f, 0.02503001f, 0.02550506f, -0.00723566f, -0.01540148f, 
    0.01368368f, 0.02671815f, -0.04122045f, -0.03442935f, -0.03771359f, -0.02401053f, -0.02401221f, 0.01654678f, 
    -0.04116254f, 0.03014081f, -0.05079091f, -0.04414546f, -0.05616614f, -0.04366484f, -0.05304919f, -0.01108910f, 
    0.02987703f, 0.00368404f, -0.01978913f, -0.00337846f, 0.00169475f, -0.00902248f, 0.03052912f, 0.00988504f, 
    0.01971065f, -0.05466153f, 0.00855214f, -0.00762481f, -0.03294555f, -0.01846199f, 0.02448405f, -0.03262091f, 
    0.03095916f, 0.02077527f, -0.01076355f, -0.04986794f, -0.01400709f, -0.02203586f, -0.02317818f, -0.02164185f, 
    -0.03207682f, -0.03466087f, 0.04350442f, 0.01213640f, -0.02734317f, -0.00587329f, -0.02024326f, -0.03971457f, 
    -0.01214400f, -0.05087207f, 0.03297376f, -0.04313340f, -0.04367340f, -0.05315974f, -0.01758682f, 0.00188839f, 
    0.01293571f, -0.01413302f, -0.02612534f, -0.02035298f, -0.04527358f, 0.03543572f, -0.04387626f, -0.02665294f, 
    0.03222561f, 0.01519275f, -0.00734892f, -0.03039737f, -0.02185012f, 0.00633175f, 0.00080765f, 0.01754933f, 
    -0.04022635f, 0.02952587f, 0.02580339f, -0.05397382f, 0.01570865f, 0.02029137f, -0.01246217f, -0.03599882f, 
    0.03712990f, 0.04247174f, 0.01556864f, 0.01756031f, -0.00448414f, -0.01055920f, 0.00943350f, -0.01570313f, 
    0.03793735f, -0.05576942f, -0.01635705f, 0.00964132f, -0.03022643f, -0.05086760f, -0.02775044f, -0.04810459f, 
    -0.00731342f, -0.01728350f, -0.00179245f, 0.02525441f, -0.03347995f, -0.05181593f, 0.02979676f, 0.02513041f, 
    0.03359868f, -0.04497788f, 0.04392016f, -0.03500983f, 0.03270085f, -0.05399237f, -0.05611246f, 0.01729601f, 
    0.01516707f, -0.03154403f, 0.00307836f, -0.04851095f, -0.01223043f, 0.04523477f, -0.03905190f, 0.02228633f, 
    0.04505146f, -0.00290521f, 0.02971058f, -0.04838297f, 0.01688509f, -0.00779939f, -0.03706277f, -0.03839703f, 
    0.00439780f, -0.01737216f, 0.02952981f, 0.03335259f, -0.02476097f, -0.04644990f, 0.02890529f, -0.05374315f, 
    -0.04130025f, -0.04581386f, 0.03720021f, -0.00775855f, 0.00874604f, 0.03668334f, -0.01863930f, 0.01506820f, 
    0.00552701f, -0.01777321f, -0.04560116f, -0.04854105f, -0.03721931f, 0.02291181f, -0.01522923f, 0.00348032f, 
    -0.05274230f, 0.04050056f, 0.02217199f, 0.03227621f, 0.02012268f, -0.02022884f, -0.02837884f, 0.02308706f, 
    -0.01358529f, -0.05176594f, -0.00847456f, -0.04950683f, 0.04495672f, 0.04212294f, -0.05532885f, -0.05172087f, 
    -0.00907087f, 0.03017228f, -0.05173806f, 0.02045671f, 0.04163406f, 0.00587454f, 0.01856779f, -0.04628349f, 
    0.01112618f, -0.04221858f, -0.01624149f, 0.03797545f, 0.00802316f, 0.02586114f, -0.00081510f, 0.04044335f, 
    0.03033417f, 0.00999451f, 0.00964413f, -0.03849224f, -0.01074085f, 0.00004440f, -0.02822681f, -0.02432811f, 
    -0.01788755f, -0.01034828f, -0.03890759f, -0.03535496f, -0.02143047f, -0.02607182f, -0.01414963f, -0.04024289f, 
    0.03698988f, 0.02040732f, 0.02947034f, -0.02932996f, 0.03134744f, -0.02079271f, -0.01941755f, 0.01645574f, 
    0.04414163f, -0.04906470f, 0.01435618f, -0.01365573f, -0.01944070f, -0.01620829f, 0.02235910f, -0.04190147f, 
    0.03072289f, -0.05231207f, -0.00003737f, -0.05157590f, 0.01107901f, -0.05086982f, -0.03444884f, -0.02330111f, 
    -0.04045508f, 0.02281116f, -0.01758874f, 0.04460192f, -0.05356452f, 0.01129585f, -0.04245235f, -0.01451524f, 
    -0.17617700f, -0.00950825f, 0.04571011f, 0.22158523f, -0.06963073f, -0.04528171f, 0.29935363f, -0.12870771f, 
    0.00721611f, 0.07618388f, -0.01025286f, 0.09113926f, -0.48314580f, -0.10178842f, 0.06528781f, -0.19075836f, 
    0.05678374f, -0.12948935f, 0.00249096f, 0.00727881f, 0.07507495f, -0.02636815f, 0.01230799f, -0.00779539f, 
    0.05668703f, -0.20850633f, 0.02992783f, 0.06377982f, 0.09001920f, 0.07418760f, -0.05712735f, 0.07439677f, 
    -0.13611412f, 0.03815883f, 0.07331269f, -0.12166972f, -0.31765717f, 0.03049992f, 0.04527009f, -0.21528210f, 
    0.05527720f, 0.06538014f, 0.02789961f, 0.08749142f, 0.07994042f, -0.07137761f, 0.04728013f, 0.05966071f, 
    0.34248558f, 0.04516331f, 0.14689229f, 0.08876942f, 0.06874231f, 0.06907524f, -0.04731172f, -0.08873028f, 
    -0.01284932f, 0.16869815f, 0.00569318f, 0.05735998f, 0.02443543f, -0.04501241f, -0.08052085f, 0.06132102f, 
    -0.00461705f, -0.07505161f, 0.06125931f, -0.02343732f, 0.02749115f, -0.04619654f, 0.11572053f, 0.06507127f, 
    0.10450704f, 0.15861014f, 0.05892885f, 0.07970542f, -0.01369511f, 0.13855831f, -0.07758393f, 0.00126992f, 
    -0.03594270f, 0.01729554f, -0.00923334f, 0.00414616f, -0.14888242f, 0.08805636f, 0.09636410f, 0.09245172f, 
    0.04069282f, 0.07898849f, 0.13841659f, -0.05231570f, -0.06399152f, 0.07029305f, 0.08001816f, 0.07186753f, 
    -0.27077413f, 0.11154901f, -0.06007220f, -0.21519603f, -0.01119025f, 0.05114199f, 0.06635162f, 0.01761576f, 
    0.02538106f, 0.01265246f, 0.07712807f, -0.02277737f, 0.03392083f, 0.17514232f, 0.00511703f, -0.15732478f, 
    0.05963691f, -0.02180624f, 0.04731598f, 0.04288285f, 0.13879284f, -0.10782489f, -0.02547145f, -0.02336063f, 
    0.15147425f, -0.11664217f, 0.21833783f, 0.23789959f, -0.07027528f, 0.09079455f, 0.02616919f, -0.11610169f, 
    -0.09900349f, 0.14290108f, 0.02875054f, 0.11638224f, 0.02932138f, 0.24843928f, 0.02045754f, 0.28028432f, 
    -0.04226262f, -0.11153168f, 0.02749285f, 0.07299582f, -0.06583536f, 0.09049917f, 0.12084935f, 0.11135156f, 
    0.10875650f, -0.01791799f, 0.04013153f, -0.09362862f, -0.03011845f, 0.01579941f, -0.00004203f, 0.00333412f, 
    -0.01816818f, 0.09326496f, -0.00719626f, 0.07672232f, -0.01113315f, -0.15544124f, -0.07226941f, 0.29057851f, 
    -0.00600991f, 0.02107497f, 0.08239412f, -0.09554043f, 0.04414264f, -0.09196664f, 0.04552169f, -0.13696600f, 
    0.30920652f, -0.05922253f, 0.15684284f, -0.04701421f, -0.03567313f, 0.15279454f, 0.05216688f, -0.00300673f, 
    -0.08265207f, 0.00958450f, -0.03525278f, -0.10331160f, 0.06220208f, 0.00610704f, -0.02996956f, -0.04729828f, 
    -0.03775684f, -0.02674175f, 0.07459449f, 0.10590357f, -0.07699645f, 0.08301695f, -0.08657602f, -0.06657228f, 
    -0.20008342f, -0.04172030f, 0.07497043f, 0.13086988f, -0.05968174f, 0.03163538f, 0.02122966f, -0.10618690f, 
    -0.02786476f, 0.08470067f, 0.02252864f, -0.08085967f, -0.38818473f, -0.05444572f, -0.02282182f, -0.18586981f, 
    0.05363738f, 0.00268937f, 0.06421589f, 0.06081342f, -0.06033363f, 0.14287534f, 0.01865760f, 0.09432077f, 
    -0.12801309f, 0.12604333f, 0.09823211f, 0.27358961f, -0.09741157f, 0.10126538f, 0.06523813f, -0.01034366f, 
    0.03429852f, -0.00044010f, 0.16616172f, -0.01921620f, 0.22886248f, 0.11017373f, -0.03676097f, 0.14822359f, 
    0.02286411f, 0.06335774f, -0.06608885f, 0.07091814f, 0.10068347f, -0.07136160f, -0.00413980f, -0.12074698f, 
    -0.29990885f, 0.01341975f, 0.01181166f, 0.07549767f, -0.02023210f, 0.10132575f, 0.04530729f, -0.05331529f, 
    0.03748224f, -0.02868531f, 0.13078332f, -0.02250784f, 0.31177920f, 0.28522477f, -0.11224801f, 0.22376567f, 
    -0.03671627f, 0.10647082f, 0.08008450f, 0.09494798f, -0.10090980f, 0.01534448f, -0.00063837f, 0.09689004f, 
    -0.06617227f, 0.21215460f, 0.01362744f, -0.10000353f, 0.05234340f, -0.00186071f, 0.12395843f, 0.04868554f, 
    -0.00054148f, -0.03996976f, -0.01280641f, 0.07964344f, -0.32798752f, -0.09102086f, 0.09973627f, -0.07585548f, 
    0.05964901f, -0.03190527f, 0.00646662f, 0.08874366f, 0.05035114f, 0.05640247f, 0.14461078f, 0.01813635f, 
    0.15921946f, 0.11489338f, 0.01400509f, -0.11391614f, 0.05107879f, 0.15568765f, 0.05764055f, -0.05350345f, 
    0.06237590f, 0.08658859f, -0.10510481f, -0.01353388f, -0.23394969f, 0.01785788f, 0.07718208f, -0.18897401f, 
    0.08360875f, 0.01420735f, 0.17536084f, 0.03434608f, 0.06124597f, 0.05308845f, 0.00360605f, 0.00532946f, 
    0.21325530f, 0.06544287f, -0.12456209f, 0.09907507f, -0.01178968f, 0.03638451f, 0.07684814f, -0.06876619f, 
    0.05417972f, 0.00292076f, 0.02108444f, 0.20728303f, 0.09573130f, 0.08462304f, -0.12886909f, -0.23893073f, 
    0.02360007f, -0.14719190f, -0.04084126f, 0.13604018f, -0.02041461f, 0.09637568f, -0.05294442f, 0.06701020f, 
    -0.06207149f, 0.02504707f, 0.15777025f, -0.05986923f, 0.06001922f, 0.02273270f, 0.03568048f, 0.10932022f, 
    -0.02516066f, 0.04746313f, -0.08545725f, -0.06287655f, -0.26178572f, 0.10222659f, 0.14680326f, 0.05796105f, 
    -0.12246063f, -0.03031865f, 0.11067024f, 0.04639291f, 0.27729353f, 0.04118799f, 0.00721655f, -0.11353935f, 
    -0.03258395f, 0.07441692f, -0.06622075f, 0.29747677f, 0.02532850f, -0.01598801f, 0.00842709f, 0.05214641f, 
    0.07280483f, 0.05108222f, -0.05968350f, -0.04551995f, -0.26480541f, 0.01940874f, -0.00303359f, -0.15599225f, 
    0.08396590f, 0.13960101f, 0.04497423f, -0.01314353f, -0.02750176f, -0.02851942f, -0.05919240f, 0.08653035f, 
    0.00153715f, 0.00279319f, 0.02398148f, -0.03513809f, 0.01858291f, -0.00518195f, 0.03236856f, -0.00406733f, 
    -0.04267285f, 0.00782487f, 0.02544125f, -0.03686169f, 0.01149340f, 0.03723212f, 0.03871180f, 0.02520243f, 
    -0.01608145f, -0.05372804f, -0.00410877f, 0.03003757f, -0.00662364f, -0.02417350f, 0.01128995f, 0.02356355f, 
    -0.04689294f, 0.00905629f, -0.02766753f, 0.00368858f, 0.00552345f, -0.02056061f, -0.01211598f, -0.05470239f, 
    -0.01147917f, -0.01363908f, 0.00841149f, -0.01383602f, -0.00936195f, 0.02879668f, -0.00503540f, 0.03642890f, 
    0.02846817f, -0.00006642f, 0.01136765f, -0.04463263f, 0.02652139f, -0.03597915f, -0.01138635f, 0.02202370f, 
    0.03034441f, -0.03659509f, 0.03983980f, -0.03392313f, 0.03016330f, 0.00835074f, 0.03145381f, 0.03490808f, 
    0.03051248f, -0.05081159f, -0.05248659f, 0.04157404f, 0.03140181f, 0.02467960f, -0.01088619f, -0.02290928f, 
    -0.01492479f, -0.03081110f, -0.05506462f, 0.03067377f, 0.02435422f, 0.02660197f, -0.01796038f, -0.04262273f, 
    -0.03007156f, -0.02147082f, -0.02286957f, -0.00373541f, -0.02228276f, -0.03061894f, 0.00602702f, -0.04086022f, 
    -0.05146049f, -0.03970177f, 0.01833966f, 0.03760517f, 0.01152571f, 0.01294537f, -0.03155310f, -0.03997694f, 
    -0.01364590f, -0.01855345f, 0.02423688f, 0.02581236f, 0.03391096f, -0.05421791f, -0.04719463f, -0.03296142f, 
    -0.01842543f, 0.00065273f, -0.03374669f, -0.00654944f, 0.01396663f, 0.02020308f, -0.03587287f, -0.03958912f, 
    0.03629113f, -0.03378811f, -0.00956185f, -0.05600029f, 0.03711574f, -0.02767036f, -0.02851127f, -0.00586350f, 
    -0.05683694f, 0.04146707f, -0.00115230f, 0.03112860f, 0.01508231f, 0.03851946f, -0.04419806f, -0.04366482f, 
    0.04313678f, 0.00091728f, -0.05336582f, 0.00964743f, -0.02080612f, -0.01337462f, -0.04413537f, -0.02134485f, 
    -0.04684425f, 0.03721379f, 0.00923142f, -0.05190219f, 0.01365771f, -0.05339489f, -0.05303823f, 0.04152547f, 
    0.03843465f, -0.01960626f, -0.03184899f, -0.02789806f, -0.05130757f, 0.00249087f, -0.02065392f, -0.04599081f, 
    0.01566732f, 0.01731014f, -0.00393981f, 0.00218325f, -0.05565756f, 0.01825281f, 0.00168569f, -0.05177788f, 
    -0.02612058f, -0.03340973f, -0.00286612f, -0.03306530f, -0.01199595f, 0.03604118f, 0.01941594f, 0.02600015f, 
    -0.04337849f, -0.03708532f, 0.03397198f, -0.01864249f, -0.00602117f, -0.03998373f, 0.01192044f, -0.02231940f, 
    -0.04858584f, -0.03569791f, -0.01219595f, -0.01233580f, -0.01452818f, -0.00724251f, -0.01840409f, -0.02456385f, 
    -0.05583789f, 0.01763982f, 0.02720097f, -0.02655371f, 0.00641078f, -0.03492761f, -0.02631916f, -0.01669425f, 
    -0.04112161f, -0.00176775f, 0.01603548f, 0.01079303f, -0.04504751f, -0.03186420f, -0.03960358f, -0.04716219f, 
    -0.00306502f, -0.00174304f, 0.00902606f, -0.02550953f, -0.02482823f, 0.02997270f, 0.04145600f, 0.02534301f, 
    -0.01428131f, -0.02203123f, -0.04810484f, -0.05065103f, 0.01432519f, -0.02794551f, -0.02031412f, -0.00467735f, 
    -0.00082749f, -0.02520954f, -0.01589250f, -0.04690634f, 0.03189419f, 0.01758858f, 0.00328683f, 0.00544421f, 
    0.03907203f, -0.00364990f, -0.03534196f, -0.01334569f, -0.01262682f, -0.01918023f, -0.05499531f, 0.04038472f, 
    0.00354770f, -0.04635057f, -0.04346771f, 0.00004048f, 0.00175409f, 0.01789678f, 0.03120767f, -0.00492063f, 
    0.02604904f, 0.00616433f, 0.00482397f, 0.03856815f, 0.01300939f, 0.01933057f, 0.00016490f, 0.04063647f, 
    0.02600178f, -0.04096602f, -0.01963364f, 0.03390081f, -0.01619141f, -0.03116488f, -0.04548967f, -0.01530470f, 
    -0.03982851f, -0.02525003f, -0.01829690f, 0.03708775f, 0.00686244f, -0.03647815f, 0.02538919f, 0.00480923f, 
    -0.02593991f, 0.00489196f, 0.04302700f, 0.03484627f, -0.04400092f, -0.00812341f, -0.02981083f, -0.00569861f, 
    -0.05537954f, -0.03959298f, 0.00230919f, -0.03380609f, -0.03592354f, 0.02218238f, 0.02432082f, 0.02700246f, 
    -0.04029392f, -0.03886928f, -0.00287994f, 0.03124498f, -0.04062688f, -0.03155160f, -0.01442477f, 0.02820668f, 
    -0.04527009f, -0.00109292f, -0.01640069f, -0.04617270f, -0.05348867f, -0.01845625f, -0.00952382f, -0.02247984f, 
    -0.01194104f, -0.04511334f, -0.05225916f, -0.00071439f, -0.01000077f, -0.04490079f, 0.03690402f, 0.02539236f, 
    -0.01158113f, 0.00947621f, -0.02297311f, 0.00681015f, -0.00073983f, -0.03287667f, -0.04532335f, 0.02839443f, 
    0.03268771f, 0.00389279f, -0.01006374f, 0.03147808f, -0.04790560f, 0.02852358f, -0.00086541f, -0.02855003f, 
    0.00205071f, -0.03688041f, 0.00105502f, 0.00713997f, -0.04191343f, 0.01018524f, -0.04232534f, 0.03292509f, 
    -0.02217705f, 0.01367317f, -0.00627855f, 0.00271443f, -0.04180456f, -0.05598570f, 0.01675400f, -0.02384173f, 
    0.00501663f, 0.03469874f, 0.00127137f, -0.02095779f, 0.01870918f, -0.03430672f, 0.04465173f, 0.00223023f, 
    -0.00179889f, 0.01363342f, -0.02845219f, -0.02870417f, -0.01278312f, -0.02405921f, 0.01493953f, -0.02887097f, 
    0.01733036f, -0.00753567f, 0.01203723f, -0.04387671f, -0.03093670f, -0.01470791f, -0.01265425f, -0.02186320f, 
    -0.00338192f, 0.00741897f, 0.01756626f, -0.02729131f, -0.04994998f, -0.04660858f, -0.02824668f, -0.01730553f, 
    0.01080965f, 0.00963292f, 0.01441136f, 0.03329151f, -0.03562261f, 0.02687873f, -0.00051968f, -0.02039989f, 
    -0.02689487f, 0.03072333f, -0.04718990f, -0.04562311f, -0.05147580f, -0.03909353f, -0.02730718f, -0.03059167f, 
    -0.01778991f, -0.00256256f, 0.04233321f, -0.03401100f, -0.01506795f, -0.04646296f, -0.00990311f, 0.00588669f, 
    -0.05201123f, -0.03572207f, 0.04671274f, -0.03118537f, 0.00997685f, 0.01425672f, 0.02418529f, -0.06059426f, 
    -0.04882722f, 0.00365708f, -0.01977550f, 0.02834601f, 0.00501714f, -0.01640156f, 0.00538360f, -0.00551500f, 
    -0.03982009f, -0.04418892f, 0.01278076f, -0.03700210f, 0.01671887f, -0.02013802f, 0.03340799f, -0.00312147f, 
    0.01914803f, -0.00684272f, -0.00903345f, -0.02428379f, 0.03394821f, -0.01423001f, -0.03371118f, -0.01465529f, 
    -0.04043086f, 0.01057661f, -0.05365222f, 0.03786122f, -0.04528254f, 0.02730323f, -0.05398642f, -0.04083589f, 
    -0.00240093f, -0.04397674f, -0.05042986f, -0.04565484f, 0.03140243f, 0.02167751f, 0.03866587f, -0.00070679f, 
    0.01604936f, -0.05713777f, 0.02773125f, 0.01559901f, 0.02101833f, -0.01099005f, -0.00446435f, -0.00265545f, 
    -0.02475861f, 0.00318674f, 0.02955503f, 0.01034764f, 0.00177270f, 0.01255419f, -0.05130788f, 0.03373776f, 
    -0.05321630f, -0.03393050f, -0.03935618f, 0.01440136f, -0.04278264f, 0.01470524f, 0.00380587f, 0.00638906f, 
    -0.01012315f, 0.01975999f, -0.01950824f, -0.03625712f, -0.02947057f, 0.02528995f, 0.04073526f, 0.02346786f, 
    -0.03349860f, -0.01932299f, 0.01074017f, 0.03569873f, -0.02161220f, -0.01452775f, -0.01271780f, -0.00955427f, 
    -0.00804305f, 0.02776805f, -0.03975151f, -0.05099471f, -0.03972072f, -0.02826089f, 0.04063482f, -0.02988292f, 
    -0.03825906f, -0.04069572f, 0.01929428f, -0.03720629f, -0.04548600f, -0.01883610f, 0.01375518f, -0.01786175f, 
    0.01007372f, -0.01478392f, 0.04782571f, -0.00314683f, -0.02054427f, -0.05184068f, 0.01689147f, 0.01311591f, 
    -0.05399883f, -0.03205841f, 0.01797054f, -0.03712207f, 0.00510090f, -0.04384623f, 0.02832603f, 0.01828338f, 
    -0.00307741f, -0.02669084f, -0.00185545f, -0.04564464f, 0.03188105f, -0.00417062f, -0.01650491f, -0.01960061f, 
    -0.04672704f, -0.04159866f, -0.00654958f, 0.04499336f, -0.01783983f, -0.00497403f, 0.03340647f, -0.00366490f, 
    -0.02035637f, 0.03691768f, 0.00516855f, -0.02461965f, 0.00504783f, -0.05678386f, 0.03713227f, 0.00203509f, 
    -0.03176350f, -0.02327360f, 0.02807859f, -0.03364781f, -0.00995548f, -0.01861613f, -0.05382025f, -0.04143296f, 
    -0.05233405f, 0.03097379f, 0.02571184f, -0.05381606f, -0.04675374f, 0.04286665f, -0.05192859f, 0.00344828f, 
    0.00051279f, -0.00017092f, -0.01561667f, -0.04639634f, 0.02566280f, -0.00845576f, -0.04075887f, -0.00525079f, 
    0.03885655f, -0.00401165f, 0.03846765f, -0.01599634f, -0.04751866f, -0.05411902f, 0.03207596f, -0.04481753f, 
    0.02212873f, 0.03303475f, 0.00492175f, -0.02352248f, 0.01831843f, -0.05597072f, -0.01847290f, -0.02764677f, 
    -0.03666092f, 0.00457280f, -0.04237974f, 0.04214006f, -0.01035184f, -0.02044163f, -0.03843489f, -0.04200646f, 
    -0.03860194f, 0.00636557f, 0.03454139f, -0.03022714f, 0.04065773f, -0.02849540f, 0.00746105f, -0.05513774f, 
    -0.01547928f, 0.04541942f, -0.03336243f, -0.05438483f, 0.03426836f, -0.01785550f, -0.04014718f, 0.00469416f, 
    0.01740262f, 0.03656340f, -0.01137934f, -0.02004782f, 0.04976659f, -0.01514177f, 0.03954976f, 0.04147908f, 
    -0.00789632f, 0.04365906f, 0.00036162f, -0.02839937f, -0.04573332f, -0.02878963f, -0.05733620f, -0.04350092f, 
    0.03752859f, -0.05695649f, -0.01238134f, 0.02342052f, -0.02226317f, -0.03585785f, 0.03951484f, -0.04452147f, 
    -0.01697318f, 0.02249015f, -0.00933310f, -0.02496656f, 0.01445123f, -0.02902913f, -0.03257203f, -0.01167991f, 
    -0.00094058f, -0.02862354f, -0.04551582f, 0.03610558f, 0.00925251f, -0.04197777f, -0.02264671f, 0.01074165f, 
    0.03674106f, 0.02041203f, -0.00766673f, 0.01807922f, -0.05372599f, -0.01138462f, -0.01605209f, -0.02195712f, 
    -0.01384744f, 0.04613501f, -0.00952529f, 0.05121920f, 0.03913451f, 0.02822779f, -0.01759541f, -0.02745359f, 
    0.02929447f, -0.00382062f, -0.02688936f, 0.02527764f, -0.04201579f, -0.01598175f, 0.04058090f, 0.02810980f, 
    -0.02937289f, 0.00709619f, -0.00725473f, 0.03960786f, -0.04394066f, 0.01927074f, 0.00481746f, -0.02017808f, 
    0.00466082f, 0.01332276f, -0.04793982f, 0.02558729f, 0.02375473f, 0.04015389f, 0.01860631f, 0.03654097f, 
    0.01186314f, -0.00265015f, -0.03640169f, 0.02968134f, -0.00384077f, -0.02771582f, -0.04684861f, -0.04521603f, 
    0.02929330f, -0.03335889f, 0.02763943f, -0.05217063f, 0.04639455f, -0.05238152f, 0.02614073f, -0.00204327f, 
    -0.03649480f, -0.00539226f, -0.00670883f, -0.05647881f, 0.03098690f, 0.02523364f, 0.01256224f, -0.05394930f, 
    -0.00293911f, 0.01685881f, -0.00906088f, 0.00513644f, -0.02932607f, 0.03675496f, 0.03193314f, -0.05034499f, 
    -0.01051912f, -0.02378709f, -0.01769915f, 0.02800270f, 0.00230993f, -0.03675461f, 0.01301229f, -0.05514661f, 
    0.03575961f, -0.00894399f, -0.02904687f, 0.01518774f, -0.01201417f, 0.02942800f, 0.00823561f, -0.06012969f, 
    -0.01367778f, 0.00732317f, -0.02170366f, 0.02261688f, 0.01858466f, 0.00131513f, 0.03910275f, 0.04154037f, 
    0.01657127f, 0.03357904f, -0.04245191f, 0.01151263f, -0.01677402f, -0.03477878f, -0.02720600f, -0.01150660f, 
    0.02840361f, -0.01230212f, 0.03988158f, 0.04385989f, -0.00346813f, -0.03632149f, 0.02276796f, -0.04914265f, 
    -0.04419719f, -0.03805413f, -0.01253998f, -0.04522228f, 0.03424811f, 0.00645204f, 0.02386180f, -0.03569772f, 
    0.02846215f, -0.05166620f, -0.01867808f, 0.04933394f, 0.00981096f, -0.05708472f, -0.03771668f, -0.01117435f, 
    0.01939254f, -0.03185023f, 0.03029785f, -0.04956655f, 0.02579113f, 0.05161094f, -0.02330100f, 0.02539988f, 
    0.16110805f, 0.10285281f, -0.11929103f, -0.07448678f, -0.08196560f, 0.05323932f, -0.01195420f, 0.03825239f, 
    0.00910899f, -0.08515656f, -0.00321438f, -0.23387773f, 0.19630913f, 0.14513299f, -0.00728220f, -0.02773938f, 
    -0.05715649f, 0.04551472f, 0.02057810f, -0.01193277f, 0.05909937f, 0.12733115f, 0.09211981f, 0.15336724f, 
    -0.36124510f, 0.10349643f, -0.11197402f, 0.09974611f, 0.04792595f, 0.05139085f, -0.01213115f, -0.06985156f, 
    0.04995194f, -0.05924019f, 0.03334433f, -0.01729571f, 0.11311820f, 0.08883210f, 0.03056992f, -0.07927523f, 
    0.06144449f, -0.00160652f, -0.10140269f, -0.15420114f, -0.00532709f, -0.10819022f, -0.06159179f, 0.00774766f, 
    -0.03085280f, 0.01504280f, -0.11646916f, -0.22542019f, -0.03514522f, 0.09370180f, 0.06794091f, -0.01046544f, 
    0.01407265f, -0.18158884f, 0.12907229f, -0.06911795f, -0.15276730f, 0.03706964f, 0.10550725f, -0.16649087f, 
    0.00371179f, 0.17318121f, -0.00507104f, 0.13066320f, 0.02076003f, 0.05458501f, -0.01947353f, 0.05854687f, 
    -0.19559653f, 0.00177111f, 0.16323948f, 0.12126669f, -0.03630001f, -0.07592827f, 0.04940755f, -0.04262855f, 
    0.03220692f, 0.11402506f, 0.06901106f, -0.03094617f, 0.36662829f, 0.00253770f, -0.20034495f, 0.02277392f, 
    -0.09244755f, -0.04741003f, 0.02944083f, 0.10964841f, 0.00717606f, 0.07262300f, -0.02225626f, -0.01540305f, 
    0.18083638f, -0.15272589f, 0.12168740f, 0.20208415f, 0.05940619f, -0.05497832f, 0.02676075f, 0.02429632f, 
    0.13771507f, 0.11118618f, -0.00338880f, 0.14451425f, 0.36031020f, -0.14638300f, -0.00319614f, 0.09064996f, 
    -0.13756813f, 0.11186828f, 0.02713849f, 0.09619904f, -0.11524232f, 0.09009904f, 0.06229889f, -0.03952880f, 
    -0.34769556f, -0.06886835f, 0.04274298f, -0.14687695f, -0.08746150f, -0.03857127f, 0.04011853f, 0.00391400f, 
    0.08108221f, -0.11137658f, -0.08568938f, 0.02372704f, -0.12251050f, -0.12587687f, -0.02502043f, -0.00740105f, 
    0.08506433f, -0.00440986f, 0.12840551f, -0.07004909f, -0.05148091f, 0.04971091f, -0.06247575f, 0.04081987f, 
    0.11621229f, 0.05228661f, 0.00704283f, 0.00626337f, -0.09780425f, 0.05920236f, -0.02783029f, -0.13573389f, 
    0.14216353f, -0.01943532f, -0.02893643f, -0.13011442f, 0.03654196f, -0.05578513f, -0.00157175f, -0.24625291f, 
    0.07146896f, 0.07956469f, 0.05583735f, 0.04044647f, 0.00753206f, -0.01321281f, 0.01572591f, 0.15687580f, 
    0.14557345f, -0.02132703f, -0.16668151f, 0.10237997f, -0.00165616f, 0.00412784f, 0.07095171f, -0.03949986f, 
    -0.07701796f, 0.05713796f, 0.04046439f, 0.22867756f, 0.21530013f, 0.00333216f, -0.00980015f, -0.06792457f, 
    0.09058618f, 0.16709901f, 0.01832080f, 0.00966291f, -0.06010488f, -0.02866749f, 0.12590235f, 0.07730640f, 
    -0.06527936f, 0.24222574f, 0.14597484f, -0.17387976f, 0.12609226f, 0.04444140f, 0.03630925f, 0.09566773f, 
    0.03478483f, -0.04632029f, -0.04359830f, 0.08848619f, 0.23828916f, -0.08928346f, 0.20802267f, 0.03567803f, 
    -0.04745066f, 0.03152592f, -0.02918960f, -0.10145154f, 0.05789224f, -0.04478371f, 0.11739829f, -0.02041361f, 
    0.03111510f, -0.11984187f, -0.06183630f, 0.09560762f, 0.11916392f, -0.18128544f, 0.05273873f, 0.02902268f, 
    -0.04787783f, 0.05598051f, -0.07496824f, 0.08149085f, -0.04278917f, 0.04299876f, -0.08875777f, -0.38563654f, 
    0.00458789f, 0.00792643f, 0.21529874f, -0.15833129f, 0.08317842f, 0.12610190f, 0.07190724f, 0.03036239f, 
    0.21721797f, -0.25104070f, 0.18251671f, -0.03341780f, 0.02503154f, 0.00794830f, -0.04215849f, 0.02319045f, 
    0.05703253f, -0.04782693f, 0.00376867f, 0.02983223f, -0.35778168f, -0.04023886f, -0.07392267f, -0.08318922f, 
    0.06560171f, -0.12425209f, -0.05348528f, 0.04050077f, -0.07993259f, 0.17543665f, 0.01103009f, -0.09393670f, 
    0.11252048f, -0.33303055f, 0.15399750f, -0.17118184f, -0.00116363f, -0.08634725f, -0.06738222f, 0.04693116f, 
    0.11735982f, 0.11931738f, 0.10841329f, -0.02303143f, 0.08808067f, 0.14521199f, 0.05758988f, 0.07153212f, 
    -0.14874080f, -0.05537073f, -0.00596712f, 0.04327554f, 0.04650838f, 0.08308154f, 0.04951632f, 0.09393504f, 
    0.15003498f, 0.04165240f, 0.02038138f, 0.03993515f, 0.04789499f, -0.12508395f, -0.07683197f, 0.21257587f, 
    -0.07703118f, 0.01808140f, 0.07432505f, -0.05847447f, -0.02002778f, 0.04416225f, 0.06366884f, 0.06245960f, 
    -0.02906101f, 0.05104572f, -0.06788912f, 0.14453779f, -0.07890441f, 0.06118213f, -0.10780244f, 0.03760256f, 
    -0.03703700f, 0.00529847f, 0.11060145f, -0.06740037f, -0.03740719f, -0.03594364f, 0.12915057f, -0.10227492f, 
    0.09445118f, 0.14974333f, -0.02388553f, 0.04193600f, 0.17227849f, 0.16597551f, -0.00385665f, -0.02423812f, 
    0.13251872f, 0.04209252f, -0.00634225f, -0.05391567f, 0.00935054f, 0.14895897f, -0.03265595f, -0.07491586f, 
    -0.17556998f, -0.06008733f, -0.23980284f, -0.05651797f, -0.07529710f, -0.00528893f, -0.02895334f, -0.22654124f, 
    0.03176074f, -0.05172160f, -0.00735633f, 0.03271171f, -0.01311498f, -0.02287974f, 0.07617643f, 0.03827877f, 
    0.08257211f, 0.01710925f, -0.04270244f, -0.06034647f, 0.05388683f, 0.14312944f, -0.02705583f, 0.12039902f, 
    -0.13061282f, 0.04510470f, 0.12268464f, -0.11204807f, -0.01972311f, -0.08348545f, 0.09646090f, -0.00082667f, 
    -0.01977658f, -0.04174361f, 0.00075145f, -0.04947850f, -0.30647472f, 0.16359724f, 0.17588650f, 0.05316238f, 
    0.11392528f, -0.10875754f, 0.01376238f, 0.03673161f, -0.02496519f, -0.09002005f, 0.07215052f, 0.11396446f, 
    -0.06533118f, 0.04855322f, -0.14478233f, 0.06663321f, 0.15463601f, -0.01210195f, 0.17104809f, 0.04475718f, 
    0.08149145f, -0.02062294f, 0.09926680f, 0.11820956f, 0.05009247f, 0.15414189f, 0.04483266f, 0.09777060f, 
    0.01108651f, -0.01683526f, -0.01009730f, 0.09944927f, -0.02032559f, 0.03307708f, 0.01302201f, 0.02416334f, 
    -0.00673538f, 0.16276185f, 0.09791381f, -0.01370828f, -0.01216093f, 0.09167802f, 0.04323982f, -0.10223895f, 
    -0.00663580f, 0.07274514f, 0.01684852f, 0.11037643f, 0.12326135f, 0.20524636f, -0.00384303f, 0.15643124f, 
    -0.13090451f, 0.08564991f, 0.04025856f, 0.21688487f, -0.00048769f, 0.11725099f, 0.16639994f, 0.14333647f, 
    -0.25054142f, -0.13788624f, -0.02856089f, 0.06394888f, 0.01953645f, -0.11245625f, -0.06413737f, 0.03556438f, 
    0.07345638f, 0.17494082f, -0.00169134f, 0.09945869f, -0.40268055f, -0.16246143f, -0.16665401f, -0.04955530f, 
    0.04297593f, -0.00972787f, 0.11209609f, -0.10098517f, 0.10092068f, 0.05135846f, 0.00178495f, 0.11854297f, 
    -0.27652869f, -0.07532468f, -0.07615358f, -0.17528173f, -0.05155969f, 0.18520433f, 0.01264187f, 0.03521589f, 
    -0.09061720f, -0.08864420f, -0.11752611f, 0.02456929f, -0.02496810f, -0.14641309f, 0.06258205f, -0.04523895f, 
    -0.00726688f, 0.10320964f, -0.03313173f, -0.01584592f, 0.06349185f, -0.02748442f, -0.01781153f, 0.03293791f, 
    0.23719339f, 0.18643273f, 0.07384457f, 0.07186621f, 0.00441021f, 0.01653310f, -0.00994136f, 0.09682903f, 
    0.02319956f, 0.06658201f, 0.08403944f, -0.03180582f, -0.15445240f, -0.18510351f, -0.03227978f, -0.08519380f, 
    0.18728240f, 0.03228177f, 0.03068602f, 0.07887122f, 0.00616430f, 0.04998387f, 0.05836932f, -0.06225868f, 
    -0.08472542f, -0.08546223f, -0.12664035f, -0.05534687f, -0.12000211f, 0.02467834f, -0.06263448f, -0.01603909f, 
    -0.02785097f, 0.07547579f, 0.05984134f, 0.10077026f, 0.15907550f, -0.02797578f, 0.00753868f, -0.12262771f, 
    -0.07040470f, 0.02900656f, 0.05379064f, 0.11150941f, 0.08061224f, 0.14843048f, 0.18715042f, 0.06121826f, 
    -0.17137285f, 0.01969118f, -0.05658560f, -0.29274827f, -0.06874530f, -0.03029441f, -0.10536043f, 0.01447651f, 
    0.02469794f, 0.03189688f, -0.05454987f, 0.21871161f, -0.07775117f, -0.03561950f, -0.14229864f, 0.03774868f, 
    -0.04628954f, 0.05953274f, 0.16712455f, -0.09300499f, 0.03144369f, -0.14608943f, 0.09134922f, -0.02012669f, 
    -0.10715514f, -0.11320119f, -0.08598343f, 0.00084048f, -0.00571690f, -0.06714970f, 0.04482389f, 0.03734797f, 
    -0.00174383f, -0.01244608f, 0.11546165f, -0.19088066f, -0.27364886f, -0.28187194f, -0.07905065f, 0.02023056f, 
    0.07037244f, -0.05829259f, 0.09971218f, 0.22518826f, 0.10715234f, -0.11826041f, -0.14863671f, -0.05007552f, 
    -0.04217529f, -0.03781828f, 0.18194485f, 0.27077043f, -0.18705377f, 0.11521517f, -0.08401714f, -0.02969231f, 
    -0.03957782f, 0.00853985f, -0.00054145f, -0.02727726f, 0.19502553f, 0.08265430f, 0.11254001f, 0.06344941f, 
    -0.04777240f, -0.03702636f, 0.03365241f, 0.04340066f, 0.08746372f, 0.06229858f, -0.01403710f, 0.18955962f, 
    -0.08632126f, -0.18285803f, -0.00945919f, 0.14055800f, -0.02651242f, 0.12647527f, 0.14577803f, 0.03619275f, 
    -0.12858443f, -0.07547726f, 0.17900418f, -0.03227097f, -0.27866483f, -0.09615460f, 0.13105136f, -0.09093104f, 
    0.06853449f, 0.06198895f, 0.00745229f, -0.07971432f, -0.02149087f, -0.17373687f, 0.04629416f, -0.13115011f, 
    -0.17159253f, 0.15093443f, -0.01728470f, -0.03167937f, 0.08288778f, 0.04729631f, 0.04956192f, 0.05121060f, 
    0.03390854f, -0.00073573f, 0.18912768f, 0.12974948f, 0.43163025f, 0.00153759f, 0.09854560f, -0.02782931f, 
    -0.08875572f, 0.00020139f, 0.07542288f, -0.03801912f, -0.00644268f, 0.09951558f, -0.09486765f, 0.16895650f, 
    0.40193015f, 0.08685365f, 0.06662904f, -0.01573463f, -0.10951506f, 0.09976603f, -0.02120298f, -0.01914624f, 
    -0.01449059f, -0.02438476f, -0.00642019f, -0.02849271f, 0.13878770f, 0.07351334f, 0.14319259f, 0.14403963f, 
    -0.02827374f, 0.00295807f, -0.01050098f, -0.12594855f, -0.12001140f, -0.00161236f, 0.03880639f, -0.07981656f, 
    0.23681626f, -0.14521319f, 0.14761056f, 0.12476874f, -0.02967189f, 0.07021532f, 0.19546695f, -0.03119828f, 
    0.15549205f, 0.06182270f, -0.06504642f, 0.21575348f, 0.24504815f, 0.14173499f, 0.12748036f, 0.15740046f, 
    0.06458835f, 0.12283763f, 0.10407598f, 0.00513951f, 0.09386190f, -0.01351871f, 0.08965082f, -0.00723093f, 
    0.07088708f, -0.08185976f, -0.09179543f, -0.26311791f, -0.03577509f, 0.00698005f, -0.00102880f, 0.09917332f, 
    -0.13415460f, -0.08840407f, 0.00905746f, 0.17124368f, 0.41842160f, 0.00871567f, 0.02544267f, 0.28850436f, 
    -0.09700164f, -0.02620553f, 0.10755651f, 0.12383629f, 0.01011770f, 0.03829689f, 0.03421420f, 0.17398819f, 
    0.18125281f, 0.25984773f, 0.13925573f, 0.08373817f, -0.03370037f, -0.01379401f, 0.20063807f, -0.05008465f, 
    0.08577170f, 0.06908607f, -0.04549618f, -0.15243588f, -0.06943324f, 0.15702717f, -0.08864126f, -0.09622609f, 
    -0.08856341f, -0.00076289f, 0.08032835f, 0.02251156f, 0.05883685f, -0.17853779f, 0.00963337f, -0.24248415f, 
    -0.27461305f, -0.13467783f, -0.15541039f, 0.03182587f, 0.05577505f, 0.01399984f, -0.00583763f, 0.08730838f, 
    0.03470616f, 0.08111812f, 0.03645770f, 0.05355917f, -0.08132065f, 0.08572956f, 0.03356508f, 0.25049618f, 
    -0.01949687f, 0.07071812f, 0.01998267f, -0.04388946f, 0.08285825f, -0.02472843f, 0.14284034f, 0.05936126f, 
    -0.14373423f, -0.17472954f, 0.20336092f, 0.04827171f, -0.00528965f, -0.07811262f, 0.15625176f, 0.01848224f, 
    -0.00048368f, 0.05596577f, 0.09098256f, -0.04728778f, 0.04238062f, -0.20426905f, -0.16221114f, -0.15580466f, 
    -0.07673444f, -0.12047136f, -0.06076024f, 0.04175771f, 0.12551986f, 0.02339971f, -0.01027089f, -0.12468293f, 
    0.09093523f, -0.18529403f, 0.04169433f, -0.03044921f, -0.08015012f, -0.00403834f, 0.08359517f, 0.06227283f, 
    0.02551955f, 0.07962611f, 0.04378787f, -0.12877031f, -0.19542022f, -0.36822939f, -0.33060542f, -0.12905945f, 
    -0.00187914f, 0.04657846f, 0.14778143f, -0.00401178f, 0.20177290f, -0.01419680f, 0.10083015f, 0.04809105f, 
    0.19590275f, 0.14392805f, 0.14515500f, -0.05354368f, -0.04608206f, 0.03087352f, 0.01413676f, 0.00484960f, 
    0.03620415f, -0.03240137f, -0.07823103f, 0.02314588f, 0.29138923f, 0.10987929f, 0.06563177f, 0.07291196f, 
    -0.00864418f, -0.05381225f, -0.00795175f, 0.13698742f, -0.03019469f, 0.08522811f, 0.03047091f, 0.00587933f, 
    0.22252248f, 0.00459341f, 0.12348337f, 0.09298794f, 0.04834280f, 0.15242970f, -0.15670164f, -0.02278867f, 
    -0.00066250f, 0.07061131f, 0.06058627f, -0.06831933f, 0.29392681f, 0.11218531f, 0.13487455f, -0.07857799f, 
    -0.01245978f, -0.00274407f, -0.05316040f, 0.09264193f, -0.04972456f, 0.12875724f, -0.02557217f, -0.07763887f, 
    0.14222243f, -0.15828815f, -0.12336682f, -0.07422364f, -0.21311617f, -0.02899533f, 0.02154564f, 0.06899491f, 
    -0.00495502f, 0.09649789f, 0.04346607f, -0.01914685f, 0.08173156f, 0.11994836f, -0.07598624f, 0.04196672f, 
    0.09917219f, -0.03699168f, 0.09480960f, 0.03727417f, -0.02093654f, -0.05179521f, -0.06466506f, -0.06874722f, 
    -0.05113532f, 0.12945682f, 0.16459633f, 0.16120750f, -0.06348486f, -0.05969400f, -0.14370959f, -0.08479088f, 
    0.05791407f, 0.21984208f, 0.04502058f, 0.03910594f, -0.09300414f, 0.10619426f, 0.13134502f, -0.09975459f, 
    -0.20094554f, 0.03870414f, 0.06760654f, 0.06325468f, -0.05896990f, 0.08911856f, -0.00051863f, 0.01982789f, 
    0.23921660f, 0.08858184f, 0.10943545f, 0.15195334f, 0.06114443f, -0.04653342f, -0.13623342f, -0.02801391f, 
    0.06815556f, 0.00284226f, 0.00552202f, 0.00424163f, 0.12588894f, -0.00484486f, 0.08307578f, -0.04016315f, 
    -0.05863623f, 0.04610213f, 0.08792192f, 0.16729730f, 0.08714516f, -0.03484442f, -0.00194199f, -0.09336749f, 
    -0.02371505f, 0.14950967f, 0.16914789f, 0.23869422f, -0.05580691f, 0.13308249f, -0.07171184f, -0.04585153f, 
    -0.06892323f, 0.03036624f, 0.08252645f, -0.01883607f, 0.24881107f, 0.22716126f, 0.24048166f, 0.02895536f, 
    -0.05518937f, 0.11332341f, 0.00127405f, -0.14796887f, -0.08022486f, -0.04662519f, 0.03004625f, -0.07531871f, 
    0.05646583f, 0.00425909f, -0.02930591f, 0.10865010f, 0.14057402f, -0.10352853f, 0.15082836f, 0.00697594f, 
    -0.01296124f, 0.12697737f, -0.01263267f, -0.02491304f, -0.07793377f, -0.18546179f, -0.31618366f, -0.00971891f, 
    -0.12526603f, 0.01123583f, -0.10746064f, 0.07299250f, -0.06887159f, 0.06287380f, -0.06215717f, 0.01206958f, 
    0.19632427f, 0.03279156f, 0.11159521f, -0.14954688f, -0.20098622f, 0.13842012f, 0.01004096f, -0.05160162f, 
    0.11695434f, 0.04844851f, 0.10078133f, 0.10173025f, 0.24472579f, 0.08596739f, 0.04123119f, 0.01971607f, 
    0.09648816f, 0.00269652f, 0.02990089f, 0.05421250f, 0.17920232f, -0.02250495f, -0.03032546f, -0.16090938f, 
    -0.01303517f, -0.07660696f, 0.12324163f, 0.10925083f, 0.05159714f, -0.02876794f, -0.11998038f, 0.12903275f, 
    -0.04780761f, 0.16035594f, 0.17648886f, -0.05924045f, 0.21246414f, 0.21619402f, -0.17859200f, 0.04978080f, 
    0.05915993f, -0.00461386f, -0.03070474f, -0.06037305f, 0.05397425f, -0.00564606f, 0.08979055f, 0.04196380f, 
    0.06822746f, -0.04265884f, -0.08196694f, 0.21166743f, 0.12958023f, -0.03287303f, -0.06795356f, -0.01597603f, 
    0.00860375f, 0.02056301f, -0.05145109f, -0.05626184f, -0.07497734f, -0.03436193f, -0.22522981f, 0.06808430f, 
    -0.11150418f, -0.11662194f, 0.05778003f, 0.10940132f, -0.07608613f, -0.02635802f, -0.03768316f, 0.00977075f, 
    -0.21309981f, 0.22759430f, -0.08542617f, 0.13775080f, -0.00469091f, 0.04194022f, 0.02934815f, 0.12389026f, 
    -0.05367175f, 0.13413970f, 0.09297246f, -0.09032472f, -0.11437777f, -0.15011469f, -0.18020935f, 0.16441068f, 
    0.00014742f, 0.11918662f, 0.02531232f, 0.07073253f, 0.04432728f, -0.09824167f, -0.02447887f, 0.01916905f, 
    0.08040266f, -0.03827237f, 0.00820999f, 0.25278571f, 0.08534954f, -0.08880715f, -0.08694319f, -0.00003192f, 
    0.16101998f, -0.08651038f, 0.09301222f, 0.10011280f, -0.01353732f, -0.00871401f, -0.24862452f, -0.19343576f, 
    -0.01635316f, -0.12377848f, -0.04202751f, 0.00056579f, 0.03989716f, 0.04779887f, 0.11199001f, 0.09536520f, 
    -0.16025656f, 0.00303882f, -0.04264234f, -0.01797563f, -0.05699142f, 0.13000430f, 0.05837755f, 0.11596938f, 
    -0.13294370f, -0.02506832f, 0.01138913f, -0.01440167f, 0.07589242f, -0.15691018f, 0.05198178f, 0.12235473f, 
    0.03538151f, -0.03404466f, -0.01079278f, 0.14797193f, -0.02864276f, 0.06516568f, 0.12897404f, -0.00006509f, 
    0.39961925f, 0.22622891f, -0.00214595f, -0.03287397f, 0.00141305f, -0.07496892f, -0.00000778f, 0.09336868f, 
    0.04540648f, 0.07275124f, 0.02969986f, -0.07251392f, 0.12609570f, -0.07224932f, 0.07838920f, -0.18687750f, 
    0.06488221f, -0.03954237f, 0.13252653f, -0.00779879f, -0.06265642f, -0.05841855f, 0.03151003f, 0.02683604f, 
    -0.02923872f, -0.00911341f, 0.04705694f, -0.04268900f, -0.02317171f, 0.02866662f, -0.05323400f, -0.02984347f, 
    -0.01554278f, -0.05339980f, -0.04715171f, 0.00266595f, 0.03107128f, 0.03077023f, -0.01030152f, 0.04190833f, 
    0.01293993f, -0.01323005f, 0.00317779f, -0.02392619f, 0.03836105f, 0.01460167f, 0.03838557f, 0.03321183f, 
    0.03027160f, -0.05356584f, -0.04222519f, 0.00762668f, 0.00182140f, 0.02953135f, -0.00946392f, 0.00435937f, 
    0.04840378f, -0.06035941f, 0.01023713f, -0.01798859f, 0.00761312f, -0.03669784f, 0.01388672f, 0.01831574f, 
    0.00799464f, 0.00045343f, 0.02266147f, 0.03089670f, 0.00461497f, 0.03993498f, -0.06101109f, 0.01514347f, 
    0.01079649f, 0.04106275f, -0.04312322f, -0.02770411f, 0.04229636f, -0.02723600f, 0.02911187f, -0.04423724f, 
    -0.05712353f, -0.04270583f, 0.00176579f, -0.03036905f, 0.04025896f, -0.06027946f, -0.05691627f, 0.03374775f, 
    0.03361372f, 0.00601665f, -0.02454999f, -0.03270964f, 0.01142674f, 0.03157111f, -0.02378009f, -0.01678932f, 
    -0.04654654f, -0.04269648f, 0.00392205f, -0.02039167f, -0.03800254f, -0.04432969f, -0.01392644f, -0.00793974f, 
    0.00549913f, 0.03251877f, -0.03144220f, -0.04653895f, -0.05851535f, 0.03424763f, -0.00111173f, 0.00988246f, 
    0.04740153f, 0.00840270f, -0.05023409f, -0.01729771f, 0.04860539f, 0.01133371f, 0.00776190f, 0.02064989f, 
    -0.01714719f, 0.03008664f, -0.03881823f, 0.02631658f, 0.04671315f, -0.05165262f, -0.00141427f, -0.01330632f, 
    0.02874950f, -0.03678304f, -0.00717862f, -0.03284173f, -0.05838369f, -0.01630096f, 0.00295418f, 0.04038688f, 
    -0.01492860f, -0.01086084f, -0.04786422f, -0.03078402f, -0.02542109f, 0.04747370f, -0.00652660f, -0.02578463f, 
    -0.00632754f, 0.01969783f, 0.00470429f, 0.01399045f, 0.01900772f, 0.03062252f, 0.04318961f, -0.00785795f, 
    0.01241552f, -0.00018382f, -0.05130329f, 0.01059676f, 0.01995981f, -0.02043470f, -0.02534486f, -0.01411897f, 
    0.01390332f, 0.00593474f, 0.03556021f, 0.02627081f, 0.01779398f, -0.01279475f, -0.02056408f, 0.02425172f, 
    0.04494496f, 0.02828635f, 0.03781048f, -0.04395812f, -0.01779725f, -0.03469437f, -0.02757193f, 0.03208927f, 
    -0.03689376f, -0.00343909f, -0.05621957f, 0.05125841f, 0.02702454f, -0.01776201f, -0.02549883f, -0.04172889f, 
    -0.00883642f, -0.01911631f, 0.04170660f, 0.04207915f, -0.01653891f, 0.01231984f, -0.01187219f, -0.00713886f, 
    0.01746086f, 0.01659295f, -0.05746120f, 0.00862550f, -0.04465967f, 0.01647921f, 0.00063075f, 0.00990653f, 
    0.00054816f, 0.00795532f, -0.01884727f, 0.01247191f, 0.01707145f, 0.04009246f, -0.04174644f, 0.03509298f, 
    -0.04570039f, 0.01283192f, -0.04826037f, -0.00835606f, -0.03324540f, -0.05785635f, 0.00894045f, -0.00746785f, 
    -0.01554895f, 0.00739309f, -0.01967228f, -0.04355613f, -0.04837605f, -0.00978819f, 0.01620622f, -0.02796084f, 
    0.01401968f, 0.03549520f, 0.01120332f, 0.03729806f, -0.05665182f, 0.00616330f, 0.03798894f, -0.05267612f, 
    -0.03990173f, 0.01833158f, 0.00745690f, -0.03679503f, -0.01064253f, -0.03943104f, 0.01408107f, 0.02533088f, 
    -0.00465199f, 0.01522071f, -0.00412032f, 0.02862939f, -0.03406495f, 0.00616545f, -0.00677699f, 0.00333325f, 
    -0.01293430f, -0.02882205f, -0.03706540f, 0.02075453f, 0.03356772f, -0.03255419f, 0.04210579f, -0.00173001f, 
    -0.05450261f, -0.01411763f, 0.03051494f, -0.02283738f, 0.02146762f, -0.01340076f, -0.03409726f, -0.01197626f, 
    -0.04699466f, 0.03122363f, 0.02774901f, -0.01925836f, -0.00566642f, -0.04146343f, -0.01937446f, 0.00976997f, 
    0.02287404f, 0.01529709f, 0.00538075f, 0.02412807f, -0.01913823f, 0.04752991f, 0.00442384f, -0.01915525f, 
    0.04205329f, 0.03284844f, -0.03064867f, 0.01912712f, -0.00217500f, 0.00609622f, -0.03110015f, -0.00442357f, 
    -0.03449541f, 0.01715971f, -0.04039264f, -0.04976697f, -0.00232731f, -0.05187508f, 0.01028213f, -0.05882721f, 
    -0.04928132f, -0.03237451f, -0.00444461f, -0.03664345f, 0.02896542f, 0.02830465f, -0.03299488f, -0.03369610f, 
    0.01397419f, -0.04280102f, 0.03621412f, 0.04687826f, -0.03614142f, -0.01350891f, 0.01014057f, 0.00604509f, 
    -0.04950885f, 0.03675126f, -0.02370633f, 0.03461790f, 0.02517014f, -0.03405994f, 0.02640828f, 0.01662048f, 
    0.00537348f, -0.04322813f, -0.05586531f, -0.02186885f, 0.02517515f, -0.05499904f, -0.05876985f, -0.01165423f, 
    0.04165290f, -0.05366350f, -0.03174049f, 0.01697143f, -0.04114958f, -0.00423497f, 0.01803675f, -0.02040205f, 
    -0.01502532f, -0.00653535f, -0.02055759f, -0.01028584f, 0.02926226f, -0.00752922f, -0.00907031f, -0.04037531f, 
    0.01245579f, -0.03806075f, 0.03464155f, 0.04091484f, 0.02122545f, 0.02114729f, 0.04758430f, 0.00326634f, 
    -0.04853233f, 0.02225982f, 0.02569183f, 0.00602983f, -0.03046270f, -0.03843060f, 0.01692275f, -0.01144742f, 
    0.00601308f, -0.00417742f, -0.04872495f, -0.01101030f, 0.04045745f, -0.01941147f, -0.00989935f, -0.01347055f, 
    -0.04041676f, -0.02421068f, 0.02047712f, -0.00523683f, -0.00001159f, 0.01259686f, 0.00615923f, -0.05175511f, 
    0.01231569f, 0.01089615f, -0.03825320f, 0.01454221f, 0.03155083f, -0.02886710f, -0.02537236f, -0.00690065f, 
    0.00117493f, 0.01147965f, 0.02676970f, -0.02144032f, 0.01022082f, 0.00515442f, -0.01549358f, 0.04525925f, 
    -0.00028577f, -0.04958554f, -0.03268619f, 0.01668456f, -0.00466168f, 0.02024681f, 0.02809506f, -0.04549735f, 
    -0.01119613f, 0.00319664f, -0.00787853f, 0.04115456f, -0.01661862f, -0.03891342f, 0.00314083f, 0.03023763f, 
    -0.17070895f, 0.13146903f, -0.02726832f, 0.29624650f, 0.02599424f, 0.01129675f, 0.18837880f, 0.03961431f, 
    -0.02092184f, 0.00000551f, 0.14255138f, -0.00020278f, 0.24833889f, 0.06892888f, -0.20697965f, 0.05709796f, 
    0.06481020f, -0.06469199f, 0.05690315f, -0.08060525f, 0.06208969f, 0.00728800f, 0.05646423f, -0.05850216f, 
    0.33253813f, -0.07357107f, -0.16369836f, -0.02741303f, -0.03291628f, 0.07251198f, 0.09347437f, 0.10100693f, 
    0.17685778f, 0.00715237f, -0.03305140f, -0.06425875f, 0.08339496f, -0.04449354f, -0.03687397f, -0.04069817f, 
    -0.00352581f, 0.06030223f, 0.09821286f, 0.08810350f, 0.10970312f, 0.03682536f, 0.03708747f, 0.11990225f, 
    -0.15224135f, -0.01815706f, 0.08172762f, -0.32449749f, -0.09154709f, -0.03645109f, -0.07932109f, -0.01106106f, 
    0.10836280f, 0.05806468f, -0.11981399f, 0.02416528f, -0.30508053f, -0.04271490f, 0.04858307f, 0.02991799f, 
    -0.08138558f, -0.03680076f, -0.03940392f, 0.03741065f, -0.00733530f, -0.01021156f, -0.00698016f, 0.04174070f, 
    0.18337277f, -0.02457652f, 0.20848547f, -0.15267920f, -0.10551618f, 0.19955258f, -0.04739309f, 0.02991724f, 
    -0.15575390f, -0.11333995f, 0.00992172f, -0.03808943f, 0.27391061f, -0.06211799f, 0.15547903f, 0.19810289f, 
    -0.10149399f, 0.01836221f, -0.00129851f, 0.11474899f, -0.08141048f, 0.04137505f, 0.00923270f, -0.09141100f, 
    0.39565521f, 0.02831227f, 0.01710304f, 0.07992198f, 0.08678368f, 0.02859569f, 0.05001007f, 0.01744693f, 
    -0.08823222f, 0.13631712f, 0.03874797f, -0.10774618f, 0.31869054f, -0.16339162f, 0.04589963f, -0.09412631f, 
    0.01111762f, -0.04612710f, 0.04807423f, -0.03020074f, -0.02264736f, 0.06781923f, -0.06263397f, -0.10890012f, 
    -0.13755830f, -0.14253047f, -0.02160827f, -0.22315829f, -0.05179107f, 0.00730364f, -0.12533337f, -0.15505020f, 
    0.05517645f, 0.17616332f, 0.10723078f, 0.07675049f, -0.01492058f, 0.13266779f, 0.07081211f, -0.08676475f, 
    -0.01702858f, 0.02473611f, 0.04633042f, 0.06439790f, -0.08629654f, 0.13965993f, 0.13263352f, 0.02449220f, 
    0.09112418f, -0.01297440f, 0.15740417f, -0.08380983f, 0.03963350f, -0.09108207f, -0.12272649f, -0.13359243f, 
    0.10041752f, 0.10512561f, -0.16161215f, 0.14223051f, -0.09931771f, 0.09342089f, -0.27447429f, -0.11686197f, 
    0.04313530f, 0.07905405f, 0.02661957f, 0.07108370f, 0.07801545f, -0.08773939f, 0.03667756f, -0.02024713f, 
    0.00832136f, -0.11509518f, 0.00013718f, -0.05965807f, -0.04979963f, 0.06511065f, -0.01497999f, -0.04867983f, 
    -0.00042565f, 0.00339691f, 0.13607015f, -0.14975536f, 0.29787999f, 0.14952797f, 0.18293472f, -0.02440195f, 
    -0.05469314f, 0.02633191f, 0.04640653f, 0.03950083f, 0.06690392f, -0.05579545f, 0.01231306f, -0.04616394f, 
    0.02270727f, 0.10083825f, -0.03347325f, -0.04841061f, -0.06867377f, -0.00369070f, -0.07138441f, 0.01819572f, 
    -0.00705428f, 0.02654833f, -0.01645446f, -0.09699543f, 0.00429843f, -0.05105487f, -0.05802955f, 0.00922771f, 
    -0.08877884f, 0.04421740f, -0.03463531f, -0.00888152f, -0.05733304f, 0.07454320f, -0.03716125f, 0.04444689f, 
    0.02726459f, 0.19144239f, 0.00049114f, 0.10330225f, -0.11816636f, 0.17678152f, 0.03354678f, 0.08848465f, 
    -0.02846438f, -0.10497396f, 0.07786452f, -0.02304848f, -0.27919537f, 0.01662759f, -0.05487797f, -0.15329571f, 
    0.06285138f, 0.03802696f, 0.04630942f, 0.06025730f, 0.00293176f, -0.06865143f, 0.07163201f, -0.23843797f, 
    -0.15513882f, 0.18019986f, 0.08573931f, 0.20997664f, 0.03119608f, -0.06618486f, -0.03361341f, 0.13864613f, 
    0.02551592f, 0.07874506f, 0.14962794f, -0.02961695f, 0.28632388f, 0.33663738f, -0.05233505f, -0.13035667f, 
    0.03302430f, -0.03035871f, -0.12597595f, -0.04430479f, -0.00242212f, 0.08814470f, -0.04305435f, 0.11873703f, 
    0.03505767f, 0.07398831f, 0.10528093f, 0.07272802f, 0.07726176f, 0.00892903f, -0.13812852f, -0.10822748f, 
    0.07218663f, -0.08038174f, -0.06885292f, -0.05245418f, 0.02420362f, 0.07972329f, -0.05556342f, 0.16508782f, 
    0.09058025f, -0.09704417f, 0.01527640f, -0.03109264f, -0.17444897f, 0.01722189f, -0.07120658f, -0.08894984f, 
    0.10735852f, -0.12314624f, -0.03264734f, 0.29593462f, -0.00910335f, 0.00233257f, 0.01499166f, -0.00873912f, 
    0.09349936f, 0.05664438f, -0.12468929f, -0.00930732f, -0.01898034f, 0.15823029f, 0.12150449f, 0.01272411f, 
    0.06269643f, 0.13793859f, 0.06935915f, 0.11596780f, -0.02784415f, -0.13184172f, -0.01534079f, -0.02740654f, 
    -0.02079799f, -0.11269209f, 0.12549165f, -0.20169866f, -0.06441386f, -0.05630124f, -0.06893381f, -0.00029415f, 
    0.01102345f, -0.04162860f, 0.04097499f, 0.20441158f, 0.32845250f, -0.08145463f, -0.05930602f, 0.07503488f, 
    -0.02453244f, -0.06163765f, -0.00220165f, 0.04129595f, -0.03098904f, 0.12701696f, 0.15236412f, 0.12715401f, 
    0.35416317f, 0.08638261f, -0.14218758f, 0.00702397f, 0.00633850f, 0.09348323f, 0.07982101f, 0.01924893f, 
    -0.09248888f, -0.11063091f, -0.01053465f, -0.09440132f, 0.10179357f, -0.07399128f, -0.18475345f, -0.03823181f, 
    -0.08860958f, 0.01375460f, -0.09759145f, -0.00250443f, 0.03108091f, -0.02872805f, 0.09028756f, -0.19081861f, 
    -0.08322804f, 0.24852040f, 0.14047927f, 0.18401308f, -0.00259728f, -0.02219197f, -0.03895498f, 0.08788145f, 
    -0.01065542f, 0.05801872f, 0.03683737f, -0.01039348f, -0.06650383f, 0.13417235f, 0.04656941f, -0.14700292f, 
    0.05638060f, 0.05573247f, -0.03273347f, 0.05443467f, 0.01352270f, -0.10824934f, 0.10367202f, 0.01779144f, 
    0.18915224f, 0.07846443f, 0.03816040f, -0.18439583f, 0.06776563f, 0.07307725f, -0.17778012f, -0.00721455f, 
    0.06855610f, -0.04312098f, -0.09256326f, 0.00466567f, 0.22377509f, 0.14432292f, -0.09169258f, 0.00921209f, 
    0.00377217f, 0.16152231f, -0.01185258f, 0.02703943f, 0.00813198f, 0.05488490f, 0.09006597f, 0.07389166f, 
    -0.11407151f, 0.27003688f, 0.11137924f, 0.03979715f, 0.07185003f, -0.06820210f, 0.05987542f, -0.06392228f, 
    0.00798115f, 0.05323226f, 0.03916124f, 0.23908627f, 0.09890822f, -0.01673778f, 0.11055949f, 0.05655795f, 
    -0.00984287f, -0.09609017f, -0.15663244f, -0.17985578f, -0.07186799f, 0.04791032f, 0.00893825f, -0.03676553f, 
    -0.11839557f, -0.04749304f, -0.14821459f, -0.01488385f, 0.07085389f, -0.03382435f, 0.11733039f, 0.07980853f, 
    -0.02197397f, -0.02936891f, 0.08104694f, 0.00525659f, -0.14121564f, -0.01640324f, 0.15303820f, -0.02314285f, 
    -0.05152037f, 0.06458998f, 0.05506233f, 0.05192588f, 0.08821587f, 0.09253239f, 0.07264468f, 0.00887879f, 
    0.01151492f, -0.08493013f, -0.02104228f, -0.04564054f, 0.06605517f, -0.09646305f, 0.19298644f, 0.00582012f, 
    -0.00351184f, 0.00095942f, 0.03051993f, 0.15928794f, 0.13037460f, -0.10305677f, -0.10207885f, 0.03562711f, 
    -0.07000220f, -0.02913279f, -0.02529493f, -0.00167976f, 0.08843175f, -0.05634987f, 0.00716267f, 0.09637742f, 
    -0.06238742f, 0.00392478f, 0.09891988f, 0.03945636f, 0.14547981f, 0.02956152f, -0.00588831f, -0.01298888f, 
    0.06805415f, -0.00391004f, 0.10575181f, 0.00493435f, -0.09396404f, -0.21655723f, -0.00656797f, 0.19337411f, 
    -0.01791575f, -0.00447223f, 0.04650728f, 0.04475816f, 0.04538961f, 0.17280832f, 0.13430676f, 0.12134523f, 
    -0.13907737f, 0.14004804f, -0.00485678f, -0.09832151f, -0.04673503f, 0.01677951f, 0.10847391f, 0.07876351f, 
    0.16858420f, -0.11062329f, 0.03234934f, 0.07947504f, 0.15873589f, -0.22565706f, -0.09147175f, -0.16156270f, 
    0.08022041f, -0.02372858f, -0.01746759f, -0.14334315f, 0.11800890f, -0.01191945f, -0.07617230f, -0.01447934f, 
    -0.15640016f, 0.03788951f, -0.09512262f, -0.06975072f, 0.05449531f, 0.12317146f, 0.10631425f, 0.02983357f, 
    0.04867637f, -0.07038045f, 0.13210423f, -0.02095710f, 0.01492126f, 0.14240690f, 0.19890362f, -0.13408990f, 
    0.14872004f, 0.12344532f, -0.04507063f, 0.00679425f, 0.02912241f, 0.09334961f, -0.03650992f, 0.17661564f, 
    -0.10981540f, 0.00147108f, -0.01212112f, 0.02022869f, 0.09584165f, -0.07570940f, 0.05919668f, 0.09422016f, 
    0.15873598f, -0.03147428f, 0.09049907f, 0.13320942f, -0.39849186f, -0.07778756f, -0.17155319f, -0.10291503f, 
    0.04971047f, -0.06775778f, -0.03904714f, -0.01042017f, 0.04412092f, 0.04771980f, 0.02118680f, 0.07635805f, 
    0.09868690f, 0.05394925f, 0.17171744f, -0.11569665f, 0.14058295f, 0.07426882f, 0.03564683f, 0.12968715f, 
    0.05904127f, 0.02809476f, 0.07314217f, 0.14490832f, 0.12677708f, -0.02582061f, 0.10776726f, 0.12203570f, 
    0.06761497f, -0.03383499f, 0.12487175f, 0.02293168f, 0.08178179f, 0.12944144f, 0.15873119f, 0.07557168f, 
    -0.12177739f, -0.04705590f, 0.02878688f, -0.08164770f, 0.12324359f, -0.02191852f, 0.06127542f, 0.02194965f, 
    0.10398927f, 0.10852456f, -0.07612436f, 0.04320892f, -0.04180758f, -0.02080664f, -0.06376463f, -0.17490320f, 
    -0.02839413f, 0.07377331f, 0.11750740f, 0.02404883f, 0.04695234f, 0.06742944f, -0.06136072f, 0.16907167f, 
    0.02116122f, 0.10938491f, -0.10654382f, -0.13710074f, 0.04685771f, -0.00208304f, 0.15085721f, -0.09109161f, 
    0.02632440f, -0.07798772f, -0.09499055f, 0.02503384f, -0.12639256f, -0.30492249f, 0.04907010f, -0.08715992f, 
    -0.00517658f, -0.06318185f, 0.04491887f, 0.06080605f, 0.10650606f, -0.01590860f, 0.07669313f, -0.02458511f, 
    0.06862060f, -0.15185501f, -0.11728588f, -0.00406838f, -0.03751086f, 0.10492878f, 0.12853634f, 0.17665216f, 
    0.07876550f, 0.11183731f, 0.19707203f, 0.08221599f, 0.04222141f, -0.06686393f, 0.00553875f, -0.08853406f, 
    0.05133664f, 0.09670098f, 0.04043782f, 0.02686694f, 0.10168859f, 0.02207018f, 0.01141895f, 0.04230668f, 
    0.09243786f, 0.11695695f, -0.04601237f, -0.08900784f, -0.03653695f, -0.01448315f, 0.03835225f, -0.02034904f, 
    0.09327403f, -0.00750322f, 0.04269820f, 0.16717751f, -0.08488030f, -0.16374697f, 0.08756761f, 0.11081057f, 
    0.01493310f, -0.05964614f, -0.10823435f, 0.06901087f, -0.04146685f, 0.05897975f, 0.09381986f, -0.00720630f, 
    0.14312881f, -0.14645785f, 0.07860278f, -0.14824028f, 0.00508454f, 0.06803728f, 0.02088993f, 0.02032277f, 
    0.07587887f, 0.07489198f, 0.03981725f, -0.11278810f, -0.29367900f, -0.26724601f, 0.27227971f, 0.10455132f, 
    0.07827231f, -0.03354209f, 0.05293582f, -0.09452058f, 0.11622268f, -0.16088310f, -0.10602176f, -0.03041522f, 
    -0.01439282f, 0.11185758f, 0.16156521f, 0.25905326f, -0.08047184f, -0.11633143f, -0.03344457f, 0.00029657f, 
    0.09008657f, 0.08204999f, 0.17428033f, 0.01864844f, 0.09772386f, 0.08904933f, 0.07765574f, -0.07502530f, 
    0.07129326f, 0.15250015f, 0.06293447f, 0.07552677f, 0.12842117f, 0.00342506f, -0.17032106f, 0.14177851f, 
    -0.04957557f, -0.16645655f, 0.00915887f, -0.28118935f, 0.02208220f, -0.01507639f, 0.00202408f, -0.07063916f, 
    -0.08226389f, -0.04723753f, -0.00053596f, 0.10663753f, 0.16802153f, -0.17880507f, 0.00113834f, 0.19452059f, 
    0.03965265f, -0.01699807f, 0.01158136f, 0.09655034f, 0.05137827f, 0.03865521f, -0.01809453f, 0.01470878f, 
    -0.01475546f, 0.03164954f, -0.02144094f, 0.02486936f, -0.04788281f, 0.02444195f, -0.04359494f, -0.05164850f, 
    -0.02511771f, 0.00328055f, 0.03443841f, -0.02178981f, -0.02474027f, -0.01191157f, -0.03072969f, -0.04707015f, 
    0.03048057f, 0.02644355f, 0.02736611f, 0.00549874f, -0.03129448f, -0.04535078f, 0.00431775f, -0.04853897f, 
    0.00102766f, -0.01871718f, 0.04247869f, -0.02029936f, 0.00889998f, -0.04795036f, 0.00818823f, -0.00118917f, 
    -0.01131104f, 0.02061518f, 0.03690436f, 0.01260713f, -0.00163694f, -0.04978572f, -0.03996844f, -0.02363731f, 
    0.03339849f, 0.02792770f, -0.03654087f, -0.02987327f, -0.04406925f, 0.02378554f, -0.04895324f, -0.01676792f, 
    0.03781908f, -0.03051410f, -0.00282489f, -0.01629840f, -0.03601516f, -0.01769169f, -0.01045954f, 0.02539623f, 
    0.00805108f, -0.01500785f, 0.02408518f, -0.02628465f, -0.04660611f, -0.05165374f, -0.05193341f, -0.01750833f, 
    0.03670049f, -0.04849421f, 0.02180784f, -0.04452113f, 0.03848337f, -0.00535679f, 0.01284130f, -0.05336329f, 
    -0.00229931f, 0.00953133f, -0.04219743f, -0.04209270f, -0.03294291f, -0.03226466f, -0.00042447f, -0.01547367f, 
    0.00542184f, 0.00509354f, 0.03228103f, -0.04705064f, -0.02918033f, -0.04850469f, -0.04897976f, -0.00920257f, 
    0.03681707f, 0.02163712f, 0.01565415f, -0.02707500f, -0.05578738f, 0.03055960f, -0.01307538f, -0.01701214f, 
    -0.02090120f, -0.04591668f, -0.03116184f, -0.03349837f, 0.02687339f, -0.04753952f, -0.05082665f, 0.00727226f, 
    -0.04101342f, 0.03806919f, -0.01204291f, 0.01976774f, -0.00897626f, -0.05137401f, -0.03100137f, -0.04397029f, 
    -0.04478613f, -0.00853962f, -0.01517685f, 0.01920944f, -0.04073854f, -0.02613687f, -0.04568604f, 0.03591419f, 
    0.02539703f, -0.02542319f, -0.04983160f, -0.01562674f, 0.02745326f, 0.03964874f, 0.04492397f, 0.04288938f, 
    0.02221292f, 0.01207775f, -0.02504349f, 0.00688287f, 0.02716707f, 0.01892426f, -0.01480420f, 0.02739789f, 
    -0.00327916f, 0.03623397f, -0.03429197f, 0.01639653f, 0.03948658f, -0.02379507f, 0.03518615f, 0.02388594f, 
    0.00941605f, -0.00712302f, 0.01786077f, -0.01489418f, 0.03354796f, 0.02991961f, -0.02957855f, -0.05520739f, 
    0.02813783f, 0.00647799f, -0.01882136f, -0.01995480f, 0.00529632f, -0.05677078f, 0.01258438f, 0.03940781f, 
    0.00377620f, -0.00439683f, -0.05221225f, -0.00779589f, -0.02754622f, -0.02375757f, -0.04943549f, -0.04283600f, 
    -0.02886653f, -0.01770379f, -0.03083081f, -0.05463408f, -0.04048413f, -0.00521953f, 0.03437954f, 0.03479654f, 
    -0.00675922f, 0.03749332f, 0.01316853f, -0.04759372f, 0.00471228f, 0.01859615f, 0.03471740f, -0.00986538f, 
    -0.02437386f, 0.04154153f, 0.04047109f, -0.02269099f, 0.01141477f, 0.01825549f, -0.00535001f, 0.00740669f, 
    0.03992154f, 0.00353514f, -0.01184736f, -0.04026635f, -0.03921724f, 0.02232906f, 0.01363139f, 0.00292302f, 
    -0.03196613f, 0.01626089f, -0.03306997f, -0.03287727f, -0.02340591f, 0.00131490f, 0.02776699f, -0.04242339f, 
    0.03402867f, -0.05202175f, 0.00874046f, 0.03555381f, -0.04058636f, 0.04148327f, -0.04892458f, -0.02838357f, 
    0.03884901f, -0.03470628f, -0.04632295f, 0.03528234f, -0.00442444f, 0.03738557f, 0.03619691f, -0.04907323f, 
    0.03370400f, -0.00107759f, 0.03827319f, -0.01782670f, 0.01298338f, -0.01148593f, 0.00914050f, -0.03414245f, 
    -0.03885790f, -0.02572589f, -0.02342119f, 0.00593532f, 0.01293893f, -0.04008535f, 0.03056706f, -0.03082530f, 
    0.03347436f, 0.00383951f, -0.00949869f, 0.02272956f, -0.01655814f, 0.04512211f, -0.02885710f, -0.01862722f, 
    0.03848345f, 0.01835351f, -0.04853904f, -0.05519600f, -0.00097817f, -0.03458841f, -0.01815103f, -0.03709022f, 
    0.00477411f, -0.05083152f, 0.01807549f, -0.00323886f, 0.03808590f, -0.01549733f, -0.02851454f, 0.00050886f, 
    -0.04952689f, -0.03479131f, -0.00308445f, 0.00555284f, -0.00974934f, -0.03635396f, -0.05177232f, -0.01897025f, 
    0.00056591f, -0.02564087f, -0.02621146f, -0.05665861f, -0.00254090f, -0.03919176f, -0.00990562f, 0.00191963f, 
    -0.05303798f, 0.01166119f, -0.01586645f, 0.03203260f, 0.03076895f, -0.00677501f, -0.01372013f, 0.00662079f, 
    -0.04318482f, 0.03139012f, -0.04127828f, -0.04851397f, -0.00308367f, 0.04342832f, 0.03666175f, 0.00227508f, 
    -0.01202939f, -0.01948055f, -0.02723774f, 0.01121929f, 0.02867566f, -0.04163665f, -0.04270658f, 0.01451318f, 
    -0.04773783f, -0.05303594f, -0.01026838f, -0.00326292f, 0.05080502f, 0.00986589f, -0.01693625f, -0.03995606f, 
    -0.00743603f, 0.02026996f, -0.03260463f, 0.02005400f, 0.03705826f, -0.02352417f, 0.02378122f, 0.03860032f, 
    -0.01972054f, -0.04636151f, 0.00438707f, -0.02449268f, -0.01729291f, -0.00921954f, 0.02650036f, 0.02193231f, 
    -0.00312562f, 0.00176652f, -0.04071506f, -0.04073302f, -0.05380576f, 0.01486085f, 0.01705391f, 0.02786599f, 
    -0.05546170f, 0.01343071f, -0.00294735f, -0.01148119f, -0.05183589f, 0.03248468f, 0.04449518f, 0.03445086f, 
    0.00461798f, 0.02451416f, -0.01167129f, -0.00800782f, 0.01220305f, -0.05541547f, -0.01597288f, 0.03555002f, 
    -0.00016365f, 0.04240729f, -0.00954993f, 0.03631545f, -0.05203911f, -0.01127035f, -0.05161487f, -0.00758068f, 
    -0.01439858f, -0.04344582f, 0.03002188f, -0.01579910f, 0.01134798f, 0.03073401f, -0.05578123f, -0.01148103f, 
    0.02721475f, 0.00583524f, 0.04272718f, -0.04452515f, 0.01218223f, 0.04084007f, -0.05250613f, -0.05675029f, 
    -0.02052664f, -0.01565088f, 0.01413050f, 0.00021869f, -0.00183175f, -0.04361608f, -0.00511042f, -0.04157179f, 
    -0.03318617f, 0.01335361f, 0.00618942f, -0.05434578f, -0.03524460f, 0.02073460f, 0.04030234f, -0.05447206f, 
    -0.00450775f, -0.02044629f, -0.00901120f, -0.03438711f, -0.03068251f, -0.02365681f, -0.03279583f, 0.02267522f, 
    -0.02017512f, 0.01376737f, 0.00381327f, 0.03145720f, 0.03085280f, 0.00721358f, -0.03763965f, 0.01600968f, 
    -0.01773224f, -0.05606115f, 0.01177676f, -0.02234795f, 0.00987918f, 0.02780180f, -0.01486380f, -0.00896038f, 
    -0.02392907f, 0.01985523f, 0.02717323f, -0.00709234f, -0.00938047f, -0.00154335f, 0.00467276f, 0.01568201f, 
    -0.02041788f, -0.05221094f, 0.00736617f, -0.03392487f, 0.02493788f, 0.03567583f, 0.02524394f, -0.01844076f, 
    -0.02439003f, -0.00209462f, -0.02577872f, 0.05027160f, 0.02853039f, -0.03750564f, -0.02487091f, 0.03148906f, 
    0.03105005f, -0.00757931f, -0.04544502f, 0.01028307f, 0.03245440f, -0.03960644f, -0.01653846f, 0.00730913f, 
    0.03235780f, 0.02361540f, -0.04090839f, -0.05447027f, -0.02440959f, -0.04501471f, -0.03973626f, 0.00011806f, 
    0.03544136f, 0.02893060f, 0.00432617f, -0.03063343f, 0.01357949f, 0.02649446f, 0.03671323f, 0.01722422f, 
    -0.05296456f, -0.01453379f, -0.03146262f, 0.02132925f, -0.01302925f, 0.02714141f, -0.00483036f, -0.03087512f, 
    -0.03296388f, -0.00492381f, -0.03428083f, -0.00041833f, 0.01813388f, 0.00397922f, -0.01804500f, 0.02310215f, 
    -0.05056343f, -0.05536812f, 0.01998263f, 0.03329444f, 0.02584873f, 0.00622065f, 0.04398393f, 0.03798996f, 
    -0.01422550f, 0.02111169f, 0.02213969f, 0.01199345f, -0.04665038f, 0.02934025f, 0.00033032f, -0.04235117f, 
    -0.04062584f, 0.01876011f, 0.01533097f, -0.05549647f, 0.00525104f, 0.03197988f, -0.01605391f, -0.04781796f, 
    -0.04172489f, -0.00787035f, -0.05599555f, -0.00837779f, -0.02452982f, 0.03346504f, 0.02452366f, 0.02970297f, 
    -0.01649887f, 0.04086417f, 0.02326449f, -0.00791309f, -0.01265160f, -0.04317647f, -0.02106396f, -0.00691217f, 
    -0.05014884f, -0.01459482f, -0.00960483f, -0.00136545f, 0.02501567f, -0.04660426f, -0.00672224f, 0.02393686f, 
    -0.03440454f, -0.01411181f, 0.03200646f, -0.00984690f, -0.00692907f, -0.03172265f, -0.03743799f, -0.00720023f, 
    -0.03275708f, -0.05599715f, -0.04145192f, 0.04309253f, -0.01943165f, 0.01446109f, 0.02432404f, -0.04366017f, 
    0.03199574f, -0.00116995f, -0.01126066f, -0.05071872f, -0.00235564f, 0.03014522f, 0.00066391f, -0.04179142f, 
    -0.03992965f, -0.01249701f, -0.03715014f, -0.02702211f, 0.02331417f, -0.03183964f, 0.03835077f, 0.03039572f, 
    0.01574992f, 0.02495658f, -0.04300860f, -0.02205155f, -0.03205670f, -0.00982514f, -0.00836882f, 0.04069079f, 
    -0.04488742f, 0.01311280f, -0.00019327f, -0.03254573f, -0.00731003f, -0.02429099f, 0.02846016f, -0.03908072f, 
    -0.05653277f, -0.00250694f, -0.00267983f, -0.01275078f, 0.00811964f, 0.02236279f, -0.03603559f, 0.00525868f, 
    -0.01253770f, -0.03323314f, -0.03509339f, -0.01742263f, -0.04839658f, 0.01735046f, 0.00189502f, -0.03921789f, 
    0.01747763f, 0.03046777f, 0.01037310f, -0.01570393f, 0.00373631f, -0.00721911f, 0.01617725f, 0.00027262f, 
    0.02538724f, -0.01288092f, -0.00371271f, -0.04268866f, 0.01498871f, -0.03287616f, -0.00729457f, -0.04735885f, 
    -0.00000373f, -0.03293033f, -0.01260219f, 0.02789036f, 0.01084629f, 0.02483546f, -0.01514303f, -0.04390224f, 
    -0.05463031f, 0.03527338f, -0.03338530f, 0.00417104f, 0.00125022f, 0.01662936f, -0.00879094f, 0.02521806f, 
    0.02287504f, -0.02015995f, -0.00675643f, -0.01031009f, -0.02748517f, 0.01532845f, 0.00722341f, -0.01870444f, 
    -0.02178741f, -0.00372238f, 0.02065845f, -0.05124197f, -0.05275146f, 0.04140039f, -0.00346116f, -0.01395235f, 
    0.01353904f, -0.05195779f, -0.00879681f, 0.04373664f, 0.02091310f, -0.03494532f, -0.00336685f, -0.04525295f, 
    0.03304993f, -0.03640071f, 0.02610791f, -0.01268606f, 0.00655119f, 0.00896817f, -0.04568081f, -0.03917795f, 
    0.04173015f, -0.00798657f, -0.04407446f, 0.01934612f, 0.01836692f, -0.05312837f, -0.02523071f, 0.03906038f, 
    -0.02958472f, 0.00969675f, -0.03404098f, -0.04138962f, -0.02893708f, 0.03786935f, 0.02513069f, -0.04141728f, 
    0.00311959f, 0.00061791f, -0.00916573f, -0.04614827f, -0.05569770f, -0.04830218f, -0.00839357f, -0.00318994f, 
    -0.01147803f, -0.05274979f, 0.02614287f, -0.03125547f, -0.05681096f, 0.04280977f, -0.00684871f, 0.01151979f, 
    0.00898384f, -0.03253335f, 0.00662711f, -0.01123641f, -0.00604530f, -0.00397355f, 0.02870658f, 0.00344089f, 
    -0.02669900f, 0.01899243f, 0.03683049f, 0.03464804f, -0.04210389f, -0.00824959f, -0.02839604f, -0.01666378f, 
    -0.00927863f, -0.02585244f, 0.00346253f, 0.00016622f, -0.02149025f, -0.03074247f, -0.00977218f, -0.03766236f, 
    0.03412005f, -0.04663387f, 0.00959594f, 0.01023808f, -0.05038761f, -0.00638464f, -0.02005473f, -0.00371411f, 
    0.03528555f, -0.03224196f, -0.03271352f, 0.01180306f, -0.02610748f, 0.04870463f, 0.02591417f, 0.00730647f, 
    -0.03299410f, -0.03049580f, -0.02034395f, -0.01377938f, 0.02519988f, 0.03302738f, 0.00257168f, 0.04284887f, 
    -0.01396150f, -0.00984905f, 0.03874558f, -0.00758065f, -0.03460935f, -0.04124487f, -0.04597485f, -0.05494721f, 
    -0.04490660f, -0.05540646f, -0.05356751f, -0.03890537f, 0.02110479f, 0.01939947f, 0.03894582f, 0.04085469f, 
    0.00651585f, -0.04548281f, -0.02458651f, 0.01641509f, -0.05499361f, 0.04480573f, -0.05301777f, 0.02381547f, 
    0.01890509f, 0.02084721f, -0.05479761f, -0.03964962f, 0.04492819f, -0.01911912f, -0.04884698f, 0.00071234f, 
    -0.02261315f, -0.05070907f, 0.04061296f, 0.00375348f, -0.00312660f, -0.02846197f, -0.05628584f, 0.01496932f, 
    0.00159627f, -0.02991941f, 0.03691535f, -0.00172019f, 0.00841162f, -0.04775418f, -0.03581629f, -0.04365129f, 
    -0.00341015f, -0.01399855f, 0.02188044f, 0.04430877f, 0.01963794f, 0.03539441f, -0.02696246f, -0.00127970f, 
    -0.04189681f, 0.02004739f, 0.00359069f, -0.04815248f, -0.03896202f, -0.00143848f, 0.01585787f, 0.03689124f, 
    -0.02878116f, -0.01532823f, 0.00035690f, -0.02177931f, 0.00294579f, -0.04559137f, 0.00183098f, 0.02970130f, 
    -0.00447895f, -0.02761426f, -0.04692592f, 0.00854156f, -0.01102166f, -0.02307835f, -0.05453276f, -0.04397128f, 
    -0.02068419f, -0.02767490f, 0.01594893f, -0.02590127f, -0.05510595f, 0.02087189f, -0.02225442f, 0.02870215f, 
    -0.00177906f, -0.04686037f, 0.02225329f, -0.05226912f, -0.03305864f, -0.00471846f, 0.02251407f, -0.01960071f, 
    0.02209090f, -0.04965771f, -0.00355940f, -0.04397218f, -0.05672166f, 0.00518370f, -0.00859962f, 0.03264137f, 
    -0.00914672f, 0.00339101f, 0.04160023f, -0.05353782f, -0.03099575f, -0.03441739f, 0.03386488f, -0.03310619f, 
    -0.04390236f, 0.02902056f, -0.04515024f, 0.02705953f, 0.04101854f, 0.04368595f, -0.01257347f, -0.05278390f, 
    -0.02990193f, -0.02458453f, -0.03973506f, 0.02878782f, 0.01654528f, 0.03646163f, 0.03766762f, -0.02859129f, 
    0.02142245f, -0.04075499f, -0.04921546f, -0.04147007f, -0.05443886f, -0.01676066f, 0.01905351f, -0.04318773f, 
    -0.02641623f, -0.05145758f, 0.00182102f, 0.03161443f, -0.04259152f, -0.00758443f, 0.04061819f, -0.05157016f, 
    0.02958520f, -0.03142638f, 0.00225797f, -0.04162075f, -0.04119564f, -0.04068918f, -0.01171621f, 0.00882346f, 
    0.03923015f, 0.02171423f, 0.02562853f, -0.05694860f, 0.02762204f, -0.00387041f, 0.00052263f, -0.05649316f, 
    -0.02139220f, 0.02144296f, -0.02825716f, 0.03905628f, -0.02787530f, 0.02504565f, -0.02287200f, 0.03076175f, 
    0.03639437f, -0.02809400f, 0.03672688f, 0.03314022f, -0.04165000f, -0.01855463f, -0.00126122f, 0.02115642f, 
    -0.01393572f, 0.00894895f, -0.03073447f, -0.00221934f, -0.00608159f, -0.04974011f, 0.01290903f, -0.03810300f, 
    -0.02662645f, -0.02585456f, 0.03454560f, -0.02222377f, -0.04740802f, -0.02562599f, -0.01947004f, -0.01916450f, 
    -0.02823416f, -0.03627481f, 0.02877378f, 0.00024968f, -0.00933742f, -0.00689451f, -0.03559460f, 0.04301419f, 
    -0.03661932f, -0.05248442f, -0.04018764f, 0.03904449f, -0.04896470f, 0.03928658f, 0.02192625f, -0.05510596f, 
    -0.02036326f, -0.03170878f, -0.00961766f, 0.00460618f, 0.02825173f, 0.04452761f, 0.03922007f, 0.00179112f, 
    -0.03225306f, 0.04391578f, 0.02706580f, 0.00008952f, -0.04065201f, -0.04108396f, 0.02740048f, -0.00763669f, 
    -0.01575941f, -0.05332774f, 0.02822814f, 0.02535018f, -0.03965127f, 0.03675925f, -0.03137214f, 0.03182861f, 
    0.03691595f, 0.04009003f, -0.04732967f, -0.01917594f, -0.02540664f, -0.05676709f, 0.00777835f, 0.01233897f, 
    -0.00379239f, -0.04090868f, 0.02882893f, -0.01132856f, -0.05093949f, 0.02852927f, -0.02253578f, 0.01585202f, 
    0.00154142f, 0.00093735f, -0.04355804f, -0.04124581f, -0.05565447f, 0.02716158f, -0.05347628f, 0.04465007f, 
    -0.05559458f, -0.01172042f, 0.01118588f, 0.04074341f, -0.00627223f, -0.01409787f, -0.03529161f, -0.01237338f, 
    0.02589530f, -0.02613882f, -0.01049644f, -0.02296121f, 0.03604172f, 0.01036715f, 0.03332458f, -0.05621282f, 
    -0.04259004f, 0.01263958f, 0.02779955f, -0.03094696f, 0.03711167f, -0.04001692f, 0.01960273f, -0.02965626f, 
    -0.05318027f, -0.02848248f, 0.01923450f, 0.00578400f, 0.03204709f, -0.02069314f, 0.03091077f, 0.00027470f, 
    0.04070431f, 0.00970602f, -0.01967001f, -0.03488136f, -0.02696296f, 0.03249301f, -0.01660049f, -0.04216002f, 
    0.04269437f, -0.04794684f, 0.00760418f, 0.00595725f, 0.03101092f, 0.01833745f, -0.02011012f, 0.00024869f, 
    -0.01464868f, 0.01733365f, -0.01449745f, 0.03689480f, 0.04110162f, -0.04206530f, -0.02545138f, -0.04802762f, 
    -0.01661541f, 0.03888011f, -0.01033242f, 0.04256354f, -0.01633238f, -0.00900910f, 0.00751012f, -0.04968078f, 
    -0.01089720f, -0.04863262f, 0.00519699f, -0.03951729f, -0.00831825f, 0.02118395f, -0.05613084f, 0.02004737f, 
    0.03386159f, -0.03079033f, -0.02205142f, -0.00274732f, 0.02131639f, 0.02782173f, -0.02324398f, -0.05206460f, 
    -0.05223575f, 0.01098166f, 0.02747510f, -0.01353325f, -0.00393246f, -0.04740864f, -0.02330592f, 0.03507382f, 
    0.01461549f, -0.03260169f, -0.02143611f, 0.00824118f, -0.03634388f, -0.02394441f, 0.03925595f, -0.02670618f, 
    -0.01097512f, -0.00709305f, 0.01751537f, 0.00619310f, 0.04462287f, -0.01472590f, -0.02308256f, 0.01737835f, 
    -0.03622737f, 0.01353469f, 0.04129679f, -0.01803696f, -0.04082029f, -0.01312374f, -0.05379099f, -0.03884887f, 
    -0.01606357f, -0.01164083f, -0.04332451f, -0.01096892f, -0.00376052f, 0.04489322f, -0.01964223f, -0.03229110f, 
    -0.04840520f, -0.01665190f, 0.00087409f, -0.04920590f, 0.01541216f, 0.04151045f, 0.01416660f, -0.01955304f, 
    -0.00018786f, -0.01446650f, 0.01955946f, -0.00675583f, -0.02460936f, -0.01116656f, 0.03021188f, -0.00776788f, 
    -0.05574030f, -0.03657982f, -0.02746321f, 0.01984545f, -0.01697728f, -0.00408091f, -0.01741557f, -0.04151094f, 
    -0.05008324f, 0.03510263f, 0.02456611f, 0.03629706f, 0.01228767f, -0.03943742f, -0.03960804f, -0.01237684f, 
    -0.04864032f, -0.02246713f, -0.02129385f, 0.02655247f, -0.04191695f, -0.03107351f, -0.00889362f, 0.03116644f, 
    -0.02705814f, 0.02211058f, -0.03610713f, -0.00294488f, -0.05475290f, 0.02154006f, -0.05280224f, 0.03650339f, 
    -0.04453310f, 0.01356336f, -0.04873984f, -0.02967146f, 0.03196603f, -0.01102646f, -0.04062122f, -0.01044025f, 
    -0.03170171f, 0.03330557f, -0.00228887f, 0.00230808f, -0.02787479f, -0.04171678f, -0.02338311f, -0.04052164f, 
    -0.02868207f, -0.01404004f, -0.04413351f, -0.03959239f, -0.01723640f, -0.04746573f, 0.01815513f, 0.01953632f, 
    -0.04144057f, -0.04479426f, 0.02494973f, 0.00171455f, -0.04542780f, -0.01177253f, -0.02666392f, -0.04682092f, 
    -0.00403259f, -0.00403518f, -0.00661583f, -0.02300994f, -0.02995794f, 0.03136898f, -0.01868993f, -0.03122194f, 
    -0.05239657f, 0.01278282f, -0.00516713f, -0.04494287f, -0.02496140f, -0.03653115f, 0.02366950f, -0.01431282f, 
    -0.00362432f, 0.02130121f, -0.02980884f, -0.02035168f, 0.00609214f, 0.02290946f, -0.00426814f, -0.05060171f, 
    0.00860862f, -0.03303497f, -0.00666390f, -0.01062035f, -0.03036929f, -0.04099486f, 0.03610302f, -0.05128689f, 
    -0.01397267f, 0.02566468f, -0.00584246f, -0.00974150f, -0.00425730f, 0.00715434f, -0.05343813f, 0.01725223f, 
    -0.00261517f, -0.05509155f, -0.04491182f, -0.00507053f, -0.02992954f, -0.03161037f, 0.03220951f, -0.01276647f, 
    0.01335140f, 0.00404795f, 0.01339777f, 0.00756956f, -0.01344105f, -0.03917328f, -0.04589954f, -0.02881348f, 
    0.00802655f, 0.00905371f, -0.03926375f, 0.03711632f, -0.04151371f, -0.02223947f, 0.01591156f, -0.05161334f, 
    0.03876193f, 0.03689986f, -0.01263530f, -0.00127931f, 0.03076244f, -0.02038832f, 0.02731919f, 0.03130748f, 
    -0.00739070f, -0.00565608f, 0.02489023f, 0.02084204f, -0.04525851f, -0.03452509f, -0.03189753f, -0.04097107f, 
    0.04494682f, -0.04042492f, -0.03721730f, -0.04851974f, 0.03900024f, -0.00893203f, -0.00146859f, -0.05136605f, 
    -0.02134506f, -0.01546575f, 0.00528608f, 0.00267819f, -0.03629589f, -0.05631299f, -0.02855580f, -0.03973531f, 
    -0.01389335f, 0.01668303f, -0.03064499f, 0.00961346f, -0.01111330f, -0.01551117f, -0.04208208f, 0.02502635f, 
    -0.02451064f, 0.03602004f, 0.03193420f, -0.03096793f, -0.04676800f, 0.02799450f, 0.01393032f, -0.00409452f, 
    -0.03519972f, 0.00215840f, -0.03062500f, 0.01774039f, 0.00120826f, 0.00637663f, -0.03355076f, -0.04227233f, 
    -0.00391050f, 0.02659068f, 0.03979239f, -0.02610089f, 0.02521837f, -0.03332026f, 0.03736193f, -0.03177057f, 
    -0.01918328f, 0.03287952f, 0.01170973f, -0.02066006f, -0.03717320f, 0.02084222f, -0.02846661f, -0.05318115f, 
    0.00009668f, 0.04114979f, -0.04682501f, -0.05360005f, 0.02999390f, 0.04412655f, 0.04161692f, -0.05228652f, 
    -0.02412523f, 0.03313009f, -0.03166347f, -0.05230204f, -0.01257745f, 0.02611657f, 0.03669524f, -0.03234028f, 
    0.01613914f, -0.00136417f, 0.00169071f, 0.02752775f, -0.04776138f, -0.03879714f, 0.03421938f, -0.04685897f, 
    -0.04420638f, 0.01178675f, 0.01321816f, 0.02940164f, -0.03235015f, 0.01414033f, -0.05005011f, -0.02886693f, 
    -0.00807058f, 0.03474788f, -0.05164361f, -0.02189864f, 0.03634715f, 0.00108314f, -0.04635612f, 0.02074420f, 
    -0.05057540f, 0.02212617f, -0.01784504f, 0.02947328f, 0.01867991f, 0.01890092f, 0.02612058f, 0.01142097f, 
    0.03555962f, -0.05307445f, 0.02478758f, 0.02134456f, -0.04581384f, -0.02213581f, 0.01434518f, 0.03028167f, 
    0.02907477f, 0.02584284f, -0.00782365f, -0.00605517f, -0.03506489f, -0.01190650f, 0.04529941f, 0.03683544f, 
    0.01934320f, -0.00073276f, 0.02603255f, -0.02800412f, 0.00092868f, -0.03601338f, 0.00480228f, 0.00742781f, 
    0.04070163f, -0.03181182f, -0.05549778f, -0.04431662f, 0.04036742f, -0.03063472f, 0.03506013f, -0.02581789f, 
    -0.02184920f, 0.02547831f, 0.01029759f, 0.01802095f, -0.02189882f, -0.04310853f, -0.02667933f, -0.03437096f, 
    -0.03426154f, 0.03333208f, 0.03882779f, -0.05015290f, 0.01233105f, -0.01111233f, -0.02006446f, 0.02036407f, 
    -0.00555522f, -0.05008212f, -0.02857389f, -0.03280710f, -0.03850334f, 0.04476959f, -0.03220569f, -0.02897831f, 
    -0.01876869f, 0.00743223f, 0.01994190f, 0.01018810f, 0.01235218f, -0.05668372f, -0.01582482f, -0.01343222f, 
    -0.03414585f, -0.04148616f, -0.05010432f, -0.04469648f, 0.04044115f, -0.04865511f, 0.00288385f, 0.01692200f, 
    -0.01924455f, -0.03510408f, 0.00632183f, 0.04470781f, -0.00797939f, 0.01361962f, -0.02143010f, -0.02582452f, 
    0.02811971f, -0.04446214f, -0.00633813f, -0.00663517f, -0.02433348f, 0.03904257f, 0.02008049f, -0.00022207f, 
    0.01427844f, -0.00966977f, -0.03332217f, 0.00199813f, -0.00433652f, 0.02888259f, 0.03454952f, -0.04309422f, 
    -0.01041195f, 0.00609505f, 0.01195905f, -0.02231980f, 0.01925204f, 0.02244175f, -0.01396677f, -0.00300811f, 
    0.00752974f, 0.03350252f, 0.00647138f, 0.02159332f, 0.02731999f, -0.02889966f, 0.04479377f, -0.00400259f, 
    -0.05158101f, -0.03350633f, 0.02507467f, 0.04383866f, -0.00349312f, -0.00051805f, 0.02718268f, -0.01507400f, 
    -0.03440469f, -0.04925369f, -0.01740924f, 0.02811410f, 0.03505984f, 0.01540499f, -0.02539942f, 0.00229927f, 
    -0.00662079f, -0.04266712f, 0.00759295f, -0.03629302f, -0.03379059f, 0.00772984f, -0.04916678f, -0.04689418f, 
    0.04281143f, -0.04848083f, -0.01126482f, 0.02768109f, -0.00186234f, -0.02447542f, -0.05139329f, -0.00473472f, 
    -0.03353298f, -0.01114911f, -0.01820521f, -0.02165142f, -0.05381046f, -0.01979487f, -0.00785287f, -0.05015683f, 
    -0.03695975f, 0.03744564f, 0.01128572f, -0.03206108f, 0.00926173f, 0.00919013f, 0.02018634f, -0.03702846f, 
    -0.04001676f, 0.00087705f, -0.03364313f, 0.01115124f, -0.00342180f, -0.00562867f, 0.03217005f, 0.00113515f, 
    -0.02559222f, -0.00828148f, -0.00894818f, 0.02231135f, -0.00070240f, -0.02988343f, -0.05327353f, -0.02816086f, 
    -0.03583608f, 0.02198880f, -0.02211078f, -0.02568372f, -0.02767528f, -0.00832549f, -0.03441401f, 0.03962449f, 
    0.03188350f, 0.03598060f, -0.00094184f, -0.03691416f, 0.02991920f, -0.05711735f, 0.03196581f, -0.01593338f, 
    0.03373777f, 0.04155654f, -0.01436100f, 0.01734268f, -0.03726114f, 0.00734900f, -0.03500922f, 0.01179044f, 
    0.02346071f, -0.03313875f, 0.02043417f, 0.00927118f, 0.02230775f, -0.04516580f, -0.02984970f, -0.02212848f, 
    -0.03151783f, 0.03374267f, -0.04001271f, -0.03708389f, -0.03658804f, -0.02644840f, -0.03006188f, 0.04059721f, 
    -0.00300819f, -0.01221021f, 0.01265903f, 0.01643694f, 0.01807581f, -0.04271683f, 0.03139007f, -0.05150831f, 
    0.02688928f, -0.02727292f, 0.04223855f, -0.02741235f, 0.02731834f, -0.02006967f, 0.01979530f, -0.02104650f, 
    -0.01846924f, 0.00804973f, -0.03563980f, 0.00355785f, -0.04142131f, 0.02361824f, 0.03961320f, -0.00190479f, 
    -0.04491457f, 0.01688421f, -0.04663239f, 0.02356521f, 0.00423167f, 0.03198661f, -0.04197340f, 0.00862092f, 
    -0.05145865f, -0.01442738f, -0.00332611f, -0.04826518f, -0.01691320f, -0.04511614f, -0.05018684f, 0.02836092f, 
    -0.05232799f, 0.03153781f, 0.04039190f, -0.02242422f, -0.04197726f, -0.00772911f, -0.04809110f, -0.01018605f, 
    0.03269655f, 0.02978325f, -0.04142813f, -0.02197200f, -0.01223067f, 0.00270681f, -0.01748611f, 0.02342180f, 
    -0.02173588f, -0.01149317f, 0.00310024f, -0.04893044f, -0.04164814f, -0.05512048f, 0.03926645f, -0.04210166f, 
    -0.03708078f, 0.01163195f, 0.03348989f, -0.02459454f, 0.03800870f, -0.01056918f, -0.04796685f, 0.01548577f, 
    -0.00745911f, -0.05755455f, -0.00525237f, -0.00551221f, 0.02454111f, 0.03772090f, -0.02878147f, 0.03793342f, 
    -0.00152742f, -0.01097328f, 0.03072674f, -0.00135484f, -0.03738440f, 0.03237770f, -0.05613935f, -0.01670997f, 
    0.02559079f, -0.01536547f, -0.01779186f, -0.04536330f, -0.03728389f, -0.04768848f, 0.02246585f, -0.04052123f, 
    0.01124244f, -0.01181455f, 0.00284671f, -0.02001075f, -0.00532485f, 0.01114623f, 0.01617154f, 0.01712593f, 
    0.03594422f, 0.00187824f, -0.00086056f, -0.04472098f, -0.00689812f, 0.00944911f, -0.01471398f, 0.01709467f, 
    -0.05173445f, -0.00797370f, -0.04537872f, 0.03693598f, 0.02615625f, -0.01519540f, 0.00804102f, 0.00308065f, 
    0.03919720f, 0.02736609f, 0.01429940f, -0.00748979f, 0.01695031f, -0.06160350f, 0.01186386f, 0.01703756f, 
    -0.05887311f, 0.03812975f, 0.01716749f, -0.02242571f, -0.03946782f, -0.05551874f, 0.01459730f, 0.00320222f, 
    0.01255944f, -0.02102921f, 0.03192490f, 0.04000287f, 0.00122857f, -0.05017003f, -0.01638267f, -0.00599500f, 
    -0.01375917f, -0.02002147f, -0.05515697f, -0.05753908f, 0.02480094f, -0.00695022f, -0.04426172f, 0.03332666f, 
    -0.04557443f, 0.00734760f, -0.04188266f, 0.00919571f, -0.00425883f, -0.02495704f, 0.00593944f, -0.01517382f, 
    0.01720993f, 0.02412765f, -0.05691863f, -0.00645272f, 0.00068460f, -0.02330077f, -0.02880596f, 0.02558838f, 
    -0.02206659f, -0.03473791f, -0.01090911f, -0.02310150f, 0.02822862f, 0.02136044f, -0.02464742f, -0.06015589f, 
    -0.01966265f, -0.06150799f, -0.02434334f, -0.02623671f, -0.04302965f, 0.00514533f, -0.00331690f, -0.02742474f, 
    -0.00819044f, 0.01974571f, 0.00377064f, -0.01130050f, 0.00728047f, 0.00675875f, -0.04057693f, -0.03042082f, 
    -0.04985759f, 0.02230873f, 0.00074363f, -0.05682171f, 0.02255723f, 0.00566918f, 0.03079801f, -0.05996148f, 
    0.00006701f, 0.01652124f, 0.01085682f, 0.01896543f, -0.05194784f, 0.02176548f, -0.03592791f, -0.01636170f, 
    0.02560467f, 0.00514408f, 0.02330733f, -0.05582686f, -0.05270223f, 0.01369047f, 0.03178935f, 0.03898328f, 
    0.00680170f, -0.04574309f, -0.01858731f, 0.01114114f, -0.04070366f, -0.02267954f, -0.03764152f, 0.02626090f, 
    0.02696348f, -0.01014736f, 0.03454092f, 0.01281584f, -0.00557500f, -0.01783277f, -0.03387133f, -0.05383905f, 
    0.01471280f, 0.03858032f, 0.02256240f, 0.00532963f, 0.01339267f, 0.01376019f, 0.02022794f, -0.01807826f, 
    0.02774979f, 0.00592568f, 0.03848656f, -0.02531885f, -0.04556314f, -0.04804033f, -0.02090138f, 0.02652446f, 
    -0.03398266f, 0.02253893f, 0.00628216f, -0.04683213f, 0.02634852f, 0.03470519f, 0.01699026f, 0.03231132f, 
    -0.02411560f, -0.04455622f, -0.05208824f, -0.05197101f, -0.01971138f, -0.02793862f, 0.03453892f, 0.01633627f, 
    -0.02862161f, 0.03528245f, -0.04781952f, -0.00701790f, -0.05063315f, -0.03572765f, -0.00553728f, 0.00892624f, 
    0.02523945f, -0.05918055f, 0.03434364f, 0.02797825f, -0.03995405f, -0.00853946f, -0.02261388f, 0.01470273f, 
    0.02507778f, -0.04491208f, -0.03983703f, 0.01982795f, -0.02082601f, 0.03323023f, 0.03161012f, -0.05662040f, 
    -0.04137392f, 0.01596697f, -0.01349218f, -0.04823987f, -0.04029321f, -0.05983465f, 0.04085588f, -0.03151870f, 
    -0.00090185f, -0.03190249f, -0.00778106f, -0.00891050f, 0.01873914f, 0.02284651f, -0.04466885f, 0.00970506f, 
    -0.00473520f, 0.00668497f, -0.03745792f, -0.05788152f, 0.02808632f, 0.02842318f, -0.01624353f, 0.00231192f, 
    -0.01415321f, -0.05486044f, -0.01745499f, 0.00791681f, 0.00586846f, 0.02608390f, -0.05139647f, 0.02685086f, 
    0.00170970f, 0.03134276f, -0.03722044f, 0.03692617f, -0.01290232f, -0.01526898f, -0.05077423f, 0.01614027f, 
    0.14931798f, 0.16647185f, 0.04728188f, -0.02491320f, 0.08814444f, 0.14618954f, -0.03787786f, 0.03576018f, 
    -0.06705171f, 0.01185224f, -0.01122715f, 0.17686252f, 0.19787589f, -0.01629190f, -0.16245492f, -0.01252016f, 
    0.03876075f, 0.03142183f, -0.00149116f, -0.11625163f, -0.12822565f, -0.03756777f, 0.01538158f, -0.01626199f, 
    0.13113827f, -0.00323500f, 0.07753941f, 0.16215326f, 0.15501189f, -0.02286826f, 0.17530246f, 0.07025196f, 
    0.01609767f, 0.04160311f, -0.06082376f, 0.00369892f, -0.01237591f, -0.10699248f, -0.02509338f, -0.03371399f, 
    -0.08782434f, 0.01749914f, -0.03984790f, -0.08976540f, -0.06331739f, 0.13726203f, -0.05630822f, -0.00421380f, 
    -0.05670172f, 0.10674195f, -0.11264057f, 0.17039730f, 0.12787935f, 0.08499274f, -0.02074530f, 0.02052509f, 
    0.00728740f, 0.13915007f, -0.08124393f, -0.02893648f, 0.05846168f, 0.10615771f, 0.28549105f, 0.25842533f, 
    -0.08705350f, -0.00252829f, 0.00182969f, -0.06816065f, -0.00080075f, 0.06476153f, 0.01709646f, -0.02645814f, 
    0.07557403f, -0.05914119f, 0.06443044f, -0.02930539f, -0.00356067f, -0.03476879f, 0.00999908f, -0.05347823f, 
    -0.04811433f, 0.01805907f, 0.03709977f, 0.00295361f, 0.25661948f, 0.02102164f, 0.16315408f, -0.09523948f, 
    0.03695671f, -0.01276006f, -0.04678451f, 0.07751171f, -0.03299003f, -0.07359149f, -0.03471057f, 0.00574976f, 
    -0.26266125f, 0.17813563f, -0.14960136f, -0.29234010f, 0.20230459f, 0.03976562f, 0.00032397f, -0.06404968f, 
    -0.05437499f, -0.06855945f, 0.09391218f, -0.08600665f, 0.07524621f, -0.16220683f, 0.20769368f, 0.23477907f, 
    -0.06135312f, -0.03888782f, -0.02524459f, -0.02859294f, 0.07066835f, 0.11012584f, 0.00413990f, 0.04613085f, 
    -0.05831471f, 0.09978599f, -0.13827574f, 0.02155684f, 0.13863117f, 0.17996883f, -0.06385671f, -0.01826779f, 
    -0.01671850f, 0.01160156f, 0.12341770f, 0.02395292f, 0.02622660f, -0.09531154f, -0.01279616f, 0.04752050f, 
    0.02005346f, 0.04166323f, -0.05110353f, -0.07448900f, 0.13659321f, -0.08266424f, -0.04976371f, -0.07463490f, 
    0.00371016f, -0.02542975f, 0.06315033f, 0.16456223f, -0.00828578f, 0.04793858f, 0.03241765f, 0.09780284f, 
    0.01471130f, 0.08101358f, 0.09224062f, 0.07799063f, -0.16019279f, 0.32411095f, 0.04424395f, 0.11859000f, 
    0.13580869f, 0.03623452f, -0.01023149f, 0.06683174f, 0.05951881f, 0.08607160f, -0.07872019f, 0.08937019f, 
    0.39606532f, -0.02938089f, 0.10666227f, -0.13896231f, 0.04631720f, 0.01857685f, -0.08525199f, 0.06257362f, 
    0.22154832f, 0.00327899f, 0.16438672f, -0.05160674f, -0.08291885f, -0.02708401f, -0.06037023f, -0.05689273f, 
    -0.05483577f, -0.10505736f, -0.02248565f, -0.19164957f, -0.00868181f, 0.04030659f, -0.12451272f, -0.09640624f, 
    0.22872661f, 0.23967150f, -0.15973784f, -0.11819272f, 0.20843884f, 0.04867324f, 0.06389867f, 0.03013720f, 
    -0.07198809f, -0.00728350f, 0.14554079f, 0.04199639f, -0.32130611f, 0.00296940f, -0.07989580f, -0.01738384f, 
    0.09325362f, 0.09323956f, 0.11555351f, -0.02611157f, -0.01626318f, 0.16899478f, -0.00385749f, 0.07289073f, 
    -0.17878830f, 0.08558345f, 0.04155058f, -0.08732624f, 0.17784286f, 0.10528644f, -0.10509558f, -0.05023622f, 
    0.13037789f, -0.01422741f, 0.05379773f, -0.11417295f, 0.03140040f, 0.01767650f, -0.13169853f, 0.30793354f, 
    0.11330040f, 0.05672346f, -0.12272206f, 0.09903932f, -0.00684267f, -0.04962814f, -0.05587468f, 0.12252276f, 
    -0.10689896f, 0.34990022f, -0.12364046f, -0.05608708f, -0.08911434f, -0.13928145f, 0.15819453f, 0.00198645f, 
    0.00265684f, 0.01808362f, -0.06229323f, -0.11042749f, 0.01727028f, -0.07980910f, 0.08428454f, 0.15981928f, 
    0.06870715f, 0.06595332f, -0.03153207f, 0.03507440f, 0.09609095f, -0.02170480f, 0.05834085f, 0.06872951f, 
    -0.31972715f, 0.19196846f, -0.06278924f, 0.00105907f, 0.18248901f, 0.09229194f, 0.02750022f, -0.00732652f, 
    -0.00995065f, 0.06190436f, 0.01036284f, -0.00282107f, -0.23916347f, -0.04076525f, -0.13353550f, -0.26624787f, 
    0.22946455f, 0.11213017f, 0.03045245f, 0.00130696f, 0.02595019f, -0.14586142f, 0.01160855f, -0.06746760f, 
    0.15425970f, 0.07939786f, -0.00464623f, -0.04463354f, -0.09987996f, 0.12200765f, 0.10367738f, -0.14383925f, 
    0.07019908f, -0.01107089f, -0.05315433f, 0.18080519f, -0.21206793f, -0.01484291f, -0.04593299f, -0.13871168f, 
    0.08110578f, -0.00185662f, -0.04575470f, -0.14692776f, 0.05303403f, -0.11380412f, 0.06032328f, 0.06964015f, 
    0.24071962f, -0.09912305f, 0.01290041f, 0.08948782f, 0.04465833f, 0.07944863f, -0.07873514f, 0.05185274f, 
    -0.02352256f, -0.04031344f, 0.03932676f, -0.09458393f, -0.40104586f, -0.38625968f, 0.24043125f, -0.05162705f, 
    0.12463909f, -0.01650222f, -0.02176337f, -0.13922827f, 0.13366161f, -0.09229009f, 0.06098137f, 0.08891198f, 
    0.30118439f, 0.06845976f, 0.08059942f, 0.32343376f, 0.05404099f, 0.04236814f, -0.05668884f, 0.14243008f, 
    -0.07153224f, 0.02623568f, 0.15245819f, -0.05684608f, 0.08889718f, 0.01273194f, -0.13584498f, -0.04646210f, 
    -0.00562557f, 0.07588980f, 0.05645175f, 0.04913279f, 0.03363752f, -0.11325671f, -0.07834981f, 0.04574984f, 
    0.14440431f, 0.12149639f, -0.11309750f, 0.00794384f, 0.07181192f, 0.07673042f, 0.00630148f, -0.07408776f, 
    -0.00467770f, -0.01395273f, -0.04743008f, 0.09833936f, 0.26831818f, -0.21477744f, -0.32543916f, -0.02996612f, 
    -0.00564356f, 0.13312705f, -0.04520421f, 0.01806047f, 0.00833281f, 0.05522357f, 0.01657427f, 0.06164689f, 
    0.10074370f, -0.02818329f, -0.21286832f, 0.01572818f, -0.06267148f, -0.00815271f, -0.03261090f, -0.05698216f, 
    -0.04140401f, -0.04289011f, 0.07747032f, -0.07507187f, 0.01096172f, -0.13828467f, 0.11846754f, 0.28470543f, 
    -0.11905662f, 0.00410502f, 0.14422829f, 0.01883533f, -0.04214736f, 0.01643294f, 0.00387293f, 0.06507597f, 
    -0.07491202f, -0.14779474f, -0.08382981f, 0.26807439f, 0.03684292f, 0.08209015f, -0.00808695f, 0.09036447f, 
    0.03758753f, -0.05634420f, -0.13193613f, -0.06734870f, 0.10036956f, 0.00990548f, 0.09974416f, 0.10443172f, 
    -0.07711188f, 0.07502061f, 0.06102165f, 0.05318313f, -0.05731476f, -0.06894775f, 0.01558935f, -0.01764496f, 
    0.12347185f, 0.17561765f, 0.01741843f, 0.10186812f, -0.07495668f, 0.01401472f, -0.08351840f, 0.04198426f, 
    0.11285786f, -0.07075050f, 0.11778327f, 0.12672348f, -0.04605996f, 0.05835538f, 0.00928212f, -0.08989665f, 
    0.05174538f, 0.05091576f, 0.01166469f, -0.08185080f, 0.09585553f, 0.02810199f, -0.00251624f, -0.00485263f, 
    -0.30558282f, -0.06350718f, 0.00753416f, 0.18501131f, 0.01459908f, 0.00533030f, 0.10815300f, -0.00174712f, 
    0.07555653f, 0.03288615f, -0.00961257f, -0.06239039f, -0.31086597f, 0.29016784f, -0.05692122f, -0.13164996f, 
    0.03162664f, -0.03053424f, 0.00624066f, 0.01579775f, 0.11312902f, 0.01617563f, 0.02560218f, -0.03493315f, 
    0.36972964f, -0.25232154f, -0.01822296f, 0.12504534f, -0.03756992f, -0.03806851f, -0.00750745f, -0.05357612f, 
    0.09164231f, 0.02107754f, 0.00297415f, 0.04115077f, -0.06902861f, -0.11975960f, 0.11259689f, -0.06778839f, 
    -0.05648472f, 0.06906662f, -0.11580921f, -0.01720257f, -0.10836621f, -0.01400454f, -0.02492361f, -0.00859443f, 
    -0.04025213f, 0.20382077f, 0.01514228f, 0.04913046f, 0.02810211f, 0.04071259f, 0.12274947f, 0.01834992f, 
    0.01876877f, 0.02673782f, -0.16295436f, -0.02566890f, -0.03396047f, 0.27764896f, 0.02333821f, 0.17575304f, 
    0.06674869f, 0.01485010f, 0.04390959f, -0.03760572f, 0.00866115f, -0.06582472f, -0.05597267f, 0.03394381f, 
    0.14533594f, 0.11805069f, 0.01829405f, 0.02497509f, -0.06601731f, 0.01832058f, 0.07802203f, 0.04224282f, 
    -0.03582452f, -0.02082949f, 0.04625682f, -0.01919880f, 0.06086512f, -0.10771230f, -0.06749503f, 0.02089267f, 
    -0.05106018f, -0.02695748f, 0.09823060f, -0.01794057f, -0.00041825f, 0.15497215f, -0.02788344f, 0.08289570f, 
    0.00081480f, -0.02474996f, 0.08954669f, 0.05845770f, 0.03267535f, -0.00081460f, 0.01777774f, -0.03956271f, 
    0.05357972f, -0.00977612f, -0.11283241f, 0.09058050f, 0.35659111f, 0.06864685f, -0.04952575f, 0.09890641f, 
    -0.02978648f, -0.06954926f, -0.03261943f, 0.17210734f, 0.07544696f, -0.03058148f, 0.00747183f, 0.12193629f, 
    0.16879970f, 0.00818222f, -0.12145521f, 0.25778794f, -0.03507295f, 0.07414717f, -0.00190424f, 0.02562827f, 
    0.00220302f, -0.10000584f, 0.01000617f, 0.04721673f, 0.16443260f, -0.14230049f, 0.12103544f, 0.09831376f, 
    -0.02219614f, -0.02625675f, 0.01936451f, -0.11134188f, 0.04304350f, -0.12311874f, -0.01585679f, 0.09113359f, 
    0.12746751f, -0.22084679f, -0.10864271f, 0.00480845f, 0.03928023f, -0.02058436f, -0.04702495f, 0.04353317f, 
    -0.05403334f, 0.13080047f, -0.05305995f, 0.08360872f, 0.19046925f, 0.02891227f, 0.10309926f, 0.09036388f, 
    0.01353498f, 0.00001125f, -0.02115237f, -0.16960794f, -0.06665821f, 0.09172481f, 0.04172417f, 0.04116694f, 
    0.23098600f, -0.20565544f, -0.01796887f, -0.07473410f, -0.06129983f, -0.01287749f, -0.05943581f, -0.11169063f, 
    -0.01627143f, -0.00598288f, -0.04764680f, 0.05084459f, 0.28680283f, 0.30039328f, -0.01531754f, 0.01292118f, 
    0.03014231f, -0.06058042f, -0.01051531f, 0.00017504f, -0.03448251f, 0.06785222f, -0.02696064f, -0.09181887f, 
    0.26225612f, -0.25376531f, 0.34872901f, 0.16889398f, 0.06510828f, -0.00228809f, -0.04825282f, -0.04394827f, 
    0.05040630f, -0.04096257f, 0.09032349f, 0.04848704f, 0.10774540f, 0.10084242f, 0.13187249f, 0.02750949f, 
    -0.13952206f, -0.06289934f, -0.07889491f, 0.01895720f, 0.05564315f, -0.01519248f, -0.05167017f, 0.01274386f, 
    -0.06072238f, 0.03605055f, 0.18453373f, 0.16057676f, 0.02168664f, 0.05993646f, -0.04096201f, -0.03327519f, 
    -0.13356958f, -0.13061841f, -0.07491560f, 0.03045938f, 0.05691921f, -0.03249336f, 0.03897083f, -0.07927372f, 
    0.05887051f, 0.06633854f, -0.05319633f, -0.02987466f, 0.03412357f, 0.04496945f, -0.02627216f, 0.01767548f, 
    -0.05069583f, 0.02904528f, -0.11036013f, 0.04018816f, 0.00287108f, 0.09491304f, 0.00012953f, 0.10987878f, 
    -0.05221184f, -0.03355250f, -0.00407693f, -0.00818549f, 0.16492394f, 0.20198379f, -0.07932387f, 0.09791217f, 
    -0.00799353f, 0.08181822f, 0.15191442f, 0.04945615f, 0.01439261f, 0.13305722f, -0.01210132f, -0.11819130f, 
    -0.25029719f, 0.10243125f, -0.13654248f, -0.23822969f, 0.05965602f, 0.06923804f, 0.03860342f, -0.01207755f, 
    0.07875172f, 0.02599332f, 0.04733975f, 0.05547583f, 0.01275777f, 0.01619777f, -0.12417945f, 0.12001591f, 
    -0.01358604f, 0.01571121f, 0.03422432f, -0.04277801f, -0.07035919f, 0.03360278f, 0.00569570f, 0.08135055f, 
    -0.07402408f, 0.04367767f, -0.07189209f, 0.09796865f, 0.00992096f, 0.02484562f, 0.02575845f, 0.00140710f, 
    0.03565779f, -0.00291473f, -0.01173964f, -0.07232401f, -0.24366231f, 0.00960445f, -0.07824723f, 0.24950777f, 
    0.03630232f, 0.04006702f, -0.02394830f, -0.02034536f, 0.08788483f, 0.07201994f, -0.01601699f, 0.04056798f, 
    0.20174530f, 0.05311049f, 0.06288365f, -0.14824367f, 0.19980653f, -0.09207749f, -0.08036082f, 0.20815191f, 
    0.01514105f, 0.05687459f, -0.01836130f, 0.08876567f, 0.46247366f, 0.14436656f, 0.08133639f, -0.08921238f, 
    -0.10244616f, 0.16006078f, 0.07959041f, -0.02338834f, -0.12080679f, 0.00812142f, -0.08482192f, -0.03899226f, 
    -0.26381168f, -0.00435048f, 0.14133069f, -0.06688168f, -0.15861952f, -0.02750313f, -0.01744284f, 0.03214285f, 
    0.06501437f, 0.03060826f, 0.02619960f, 0.01789511f, 0.12884256f, 0.16319968f, 0.00823821f, 0.12786242f, 
    -0.07071996f, 0.08190068f, 0.08705121f, 0.06572807f, 0.02692192f, 0.03012954f, 0.01456890f, 0.04190271f, 
    -0.18354520f, -0.05789600f, -0.13920753f, 0.16064321f, 0.08521064f, -0.02678898f, 0.02690573f, 0.10484760f, 
    -0.09159010f, -0.08381253f, -0.04992862f, -0.18114057f, 0.19420703f, 0.14296138f, -0.19444172f, 0.14881097f, 
    0.03586111f, 0.16066487f, -0.08086570f, 0.04857674f, 0.08857370f, -0.04828282f, -0.05923087f, 0.02310578f, 
    -0.20286685f, -0.03660240f, -0.04170238f, 0.05180097f, 0.12049746f, -0.07145483f, -0.10397699f, -0.00581098f, 
    0.10728430f, -0.03754601f, -0.02569339f, -0.14327240f, 0.26416814f, -0.20744291f, -0.08737846f, -0.22896212f, 
    0.19527611f, 0.12205206f, 0.00973092f, 0.08886330f, 0.03383770f, 0.06715779f, -0.03875480f, -0.04322055f, 
    -0.16923077f, 0.31965876f, 0.08883719f, -0.13213804f, -0.00311569f, 0.01640578f, 0.06656881f, -0.00093266f, 
    -0.10157198f, -0.04772560f, -0.12950771f, 0.07509274f, 0.08007570f, 0.03834049f, -0.00366646f, 0.20481017f, 
    -0.05265638f, 0.04339777f, 0.03493587f, -0.10230869f, -0.00241517f, 0.10138395f, -0.11464084f, -0.01210447f, 
    0.10257507f, -0.06152350f, -0.17893927f, 0.03622550f, 0.03274802f, -0.00098106f, -0.08685119f, 0.14578946f, 
    -0.01188019f, -0.01523849f, 0.15077476f, 0.00740781f, 0.08982525f, -0.23778164f, 0.15310597f, 0.04452466f, 
    0.03232027f, 0.04165850f, 0.07190586f, 0.05022246f, 0.20502517f, -0.01558429f, -0.00449166f, -0.23609330f, 
    0.06354094f, 0.00773668f, -0.04172957f, 0.24524820f, 0.09657979f, -0.01072985f, -0.04192407f, -0.00318050f, 
    -0.00748039f, -0.03920326f, 0.08472069f, -0.02703123f, -0.01599656f, -0.01136445f, 0.21030559f, 0.05823816f, 
    0.04721389f, -0.07659501f, 0.10493678f, 0.09435841f, -0.06730036f, -0.01649921f, -0.06752133f, 0.04662087f, 
    0.07887015f, 0.06426438f, -0.27166209f, 0.18253914f, -0.08908071f, 0.07521014f, -0.07256710f, 0.04142986f, 
    0.02717827f, 0.01052122f, 0.04355934f, 0.00543981f, 0.10718767f, -0.18051273f, 0.02510895f, 0.25160640f, 
    0.07211223f, 0.05726221f, 0.01209119f, -0.02894430f, 0.04367979f, -0.07603928f, 0.05815655f, -0.05567933f, 
    0.21405919f, 0.26002014f, 0.09069753f, -0.22280937f, -0.16587856f, -0.04220374f, 0.09772649f, 0.03596844f, 
    -0.01110248f, -0.10133585f, -0.15955743f, 0.01235397f, 0.38473189f, 0.33942702f, 0.04528312f, -0.06608043f, 
    0.00857985f, 0.11101903f, 0.06603350f, 0.03685444f, 0.05549278f, -0.03864464f, -0.01077680f, -0.10881645f, 
    0.07725462f, -0.11287989f, 0.00824577f, -0.04795057f, 0.17184681f, 0.01239591f, 0.00848307f, 0.06209283f, 
    -0.13267547f, -0.01294217f, 0.04681275f, -0.05219923f, -0.13927294f, -0.19421238f, 0.03684485f, 0.12524796f, 
    0.00573628f, -0.03239954f, 0.01334053f, -0.03486156f, -0.09590430f, -0.02076005f, -0.06441827f, 0.04129131f, 
    0.33095780f, -0.09465665f, 0.06923001f, -0.13527295f, 0.21642701f, -0.03853729f, -0.08275321f, 0.13942440f, 
    0.10976933f, 0.05603063f, 0.03807226f, -0.05376663f, -0.50779098f, -0.31270480f, 0.19942027f, 0.05284410f, 
    -0.05067760f, 0.10597672f, 0.09270309f, -0.04005479f, -0.02484315f, -0.02958242f, -0.03420230f, -0.06935577f, 
    -0.06805816f, 0.04401251f, -0.05536434f, -0.31209952f, 0.08773178f, 0.01942301f, -0.02914242f, -0.09160292f, 
    -0.15232109f, 0.10586183f, -0.07384799f, -0.08867541f, 0.09436195f, 0.27860123f, -0.00441199f, -0.06353659f, 
    0.01753459f, 0.13188776f, 0.01058260f, -0.09342726f, -0.09831840f, -0.13608006f, 0.01358981f, 0.07833091f, 
    0.01873937f, -0.05385063f, -0.09096479f, 0.00157061f, -0.18206276f, -0.07950640f, 0.06320479f, 0.07842556f, 
    -0.02104278f, 0.03443372f, 0.17030986f, 0.07340012f, 0.32561460f, 0.24288151f, -0.08072216f, -0.04699869f, 
    -0.09081066f, 0.06361015f, -0.09227294f, -0.08706050f, 0.04224972f, -0.10407557f, -0.02305658f, 0.02995483f, 
    -0.10559249f, -0.05378512f, 0.17990001f, 0.07841567f, 0.05006580f, 0.01491945f, -0.01184507f, 0.03729608f, 
    -0.01794702f, -0.03904333f, -0.00381771f, -0.03128083f, -0.06706771f, 0.01487528f, 0.12512334f, 0.04364453f, 
    -0.04863422f, 0.21787196f, 0.10716575f, -0.12638532f, -0.12547626f, -0.00385823f, 0.10409500f, 0.22589861f, 
    0.30121064f, -0.22492217f, 0.04884354f, 0.17498769f, 0.03880973f, 0.06775230f, 0.07315646f, -0.07073309f, 
    0.03081946f, -0.06617975f, 0.06684261f, -0.02848323f, 0.19159120f, 0.12584263f, 0.02883724f, 0.04003707f, 
    0.09764785f, -0.12544170f, -0.05916211f, -0.09875042f, -0.20323738f, -0.10001424f, 0.01317806f, 0.06575649f, 
    0.28274775f, 0.03237016f, -0.08721326f, -0.11974325f, 0.21336235f, 0.04546330f, 0.02069095f, 0.01143969f, 
    0.09661455f, -0.01680594f, 0.09785724f, -0.04722305f, 0.44752723f, 0.16673648f, -0.03172276f, -0.07485485f, 
    -0.07538700f, -0.02476044f, 0.04257209f, -0.01668929f, 0.04745420f, -0.07862872f, 0.09118634f, 0.09195783f, 
    0.04523712f, 0.00244337f, 0.01513699f, 0.00686500f, -0.03576509f, -0.00075091f, -0.05546270f, 0.02657198f, 
    -0.04421284f, -0.03673205f, 0.02196876f, -0.01118857f, -0.02891964f, -0.02498355f, 0.03224748f, 0.01647781f, 
    -0.02174385f, -0.03186394f, 0.01377920f, -0.02844737f, -0.01807423f, -0.04664968f, 0.01899790f, -0.04857796f, 
    -0.00813163f, -0.01097760f, 0.00693093f, -0.05040666f, -0.01733799f, -0.04992197f, -0.04327076f, 0.00517566f, 
    0.04447062f, 0.01999758f, 0.02219692f, -0.04574346f, -0.05081769f, 0.01914411f, -0.04199811f, -0.00402600f, 
    -0.03753253f, -0.04759165f, -0.02598710f, -0.01157149f, -0.00597396f, 0.00632422f, 0.04299839f, -0.04996315f, 
    0.00100834f, 0.00960119f, -0.03318138f, -0.02346762f, 0.03894218f, 0.00228500f, -0.03647868f, 0.02082809f, 
    -0.04388755f, 0.01259064f, -0.02672328f, 0.04060602f, -0.04560723f, 0.03942600f, 0.03825719f, -0.04429767f, 
    0.02559834f, 0.02494209f, 0.03374564f, 0.04557321f, 0.02334750f, 0.02436026f, 0.00409485f, 0.03612668f, 
    -0.05349581f, 0.00778371f, -0.03324906f, 0.01713933f, -0.02017542f, -0.04745132f, 0.04177723f, -0.03221641f, 
    -0.03045728f, -0.01467203f, 0.04376194f, -0.05547016f, 0.03011911f, -0.02751957f, -0.01634648f, -0.05166480f, 
    -0.00819354f, -0.02656252f, 0.02415764f, 0.04154281f, 0.01690752f, -0.03752049f, -0.02562988f, -0.02734188f, 
    -0.03513654f, 0.04361057f, -0.04511714f, -0.00225324f, 0.02098420f, 0.00990229f, 0.02122488f, -0.03735568f, 
    0.01185602f, -0.00812750f, -0.02681486f, 0.00325946f, -0.03219954f, -0.03652851f, 0.01256681f, -0.01262487f, 
    0.01092783f, 0.01781268f, -0.05493443f, -0.02672217f, -0.05466830f, -0.03375191f, -0.03043037f, -0.02403456f, 
    0.03445819f, 0.04408279f, 0.01301594f, 0.01854394f, 0.04057004f, -0.04103523f, -0.00827142f, 0.01574524f, 
    -0.02058616f, 0.00155522f, -0.00671604f, -0.04270964f, 0.03823502f, -0.01559124f, -0.00164460f, -0.03279788f, 
    0.00662212f, 0.01188321f, -0.05347272f, -0.05452925f, -0.04580592f, 0.02004001f, -0.00003526f, -0.03196206f, 
    -0.01578510f, -0.03533773f, -0.04706156f, -0.03642766f, -0.04737481f, 0.00614152f, 0.01970316f, -0.02016446f, 
    -0.03591051f, -0.04061239f, -0.05162551f, 0.01194538f, 0.01972174f, 0.03162854f, 0.02245668f, 0.01436856f, 
    -0.03026565f, -0.02603816f, -0.04683038f, -0.02237331f, 0.01270389f, -0.03693143f, 0.04267998f, -0.02715867f, 
    -0.01461928f, 0.00529489f, -0.03923353f, 0.02144960f, -0.01739442f, -0.04729160f, -0.03220464f, -0.04430854f, 
    0.03805661f, -0.05299001f, -0.02144532f, 0.03551669f, -0.04386309f, 0.02705263f, -0.03878195f, 0.03065564f, 
    0.03761157f, -0.03779828f, -0.01728974f, -0.01862132f, 0.02038283f, -0.03888099f, 0.00740218f, -0.05469998f, 
    0.03103751f, 0.01951706f, -0.02985278f, -0.04677548f, -0.03542974f, -0.01331315f, -0.01599165f, 0.03426889f, 
    -0.00697086f, 0.00839631f, 0.04497520f, -0.02411314f, -0.00744436f, 0.02764077f, -0.03735886f, 0.02129582f, 
    -0.01598889f, 0.01925403f, -0.03731731f, -0.00705504f, 0.00308635f, -0.01987618f, 0.00055305f, -0.01771481f, 
    -0.04188070f, -0.04355840f, 0.00589273f, 0.03240552f, -0.03824022f, -0.04608716f, -0.03594837f, 0.01304814f, 
    0.00952923f, 0.01163372f, -0.04407300f, -0.00523175f, 0.01315749f, -0.05024345f, 0.02413929f, -0.01271078f, 
    0.02589752f, -0.03260012f, -0.03008271f, -0.01301782f, -0.02315256f, 0.01214838f, 0.00520089f, 0.02001271f, 
    0.03418300f, 0.01683874f, -0.02071194f, -0.05199076f, -0.03177354f, -0.05297778f, -0.04240743f, 0.02721087f, 
    -0.04148838f, 0.00870891f, -0.01762491f, 0.03791216f, -0.00463627f, 0.03280459f, -0.00904997f, -0.03617853f, 
    -0.02257089f, -0.00980628f, 0.03427181f, -0.03143702f, -0.02681523f, 0.01175371f, -0.00344372f, -0.04157473f, 
    -0.01449315f, -0.04758157f, -0.01101126f, 0.02590237f, 0.02267898f, 0.03984004f, 0.01950026f, 0.00458312f, 
    -0.04925336f, 0.01278332f, 0.00021975f, -0.00445581f, -0.02480606f, -0.02839177f, -0.00098457f, -0.01160819f, 
    -0.02613810f, -0.02605176f, -0.03873005f, 0.00475110f, -0.02583702f, -0.04893229f, 0.01591481f, -0.00113881f, 
    -0.01355343f, 0.04025359f, 0.01068301f, -0.03846868f, -0.00730627f, -0.04212759f, -0.02217636f, 0.02995422f, 
    0.01815924f, -0.03358393f, -0.03467283f, 0.00372858f, 0.00379754f, -0.03267223f, -0.01654658f, -0.03398599f, 
    -0.02124859f, 0.02152194f, -0.00420742f, 0.03571353f, -0.03132990f, 0.01086326f, -0.01779303f, 0.01444049f, 
    -0.04667365f, -0.02376837f, -0.00293011f, -0.03949992f, -0.03406492f, 0.01618816f, 0.00976643f, 0.02209189f, 
    -0.03383714f, -0.05385963f, -0.02715439f, 0.01238791f, -0.05594746f, 0.01529854f, -0.00131624f, 0.01720837f, 
    0.02416106f, 0.03644424f, -0.05410239f, -0.02823471f, -0.02456763f, 0.01325842f, -0.04516071f, 0.01472581f, 
    -0.00344184f, -0.01962730f, 0.01788969f, -0.00620251f, -0.04299944f, 0.00944851f, -0.00423170f, -0.02986021f, 
    0.03472223f, -0.04852530f, -0.02269538f, 0.00609523f, -0.04621328f, 0.02437173f, -0.01155815f, -0.05122105f, 
    0.03058786f, 0.00334755f, 0.00042586f, 0.02996186f, 0.01954127f, 0.02612649f, -0.04523275f, -0.02712049f, 
    0.03096073f, 0.04463657f, -0.02272260f, -0.01278345f, -0.00022248f, -0.03743973f, -0.02284247f, 0.04360924f, 
    0.04284709f, 0.02390575f, -0.05491311f, -0.00657447f, 0.00855996f, -0.04590637f, 0.00160589f, -0.04512330f, 
    0.02040393f, -0.04406507f, 0.03977523f, 0.01652717f, 0.02920237f, -0.02966410f, 0.00048999f, 0.00748779f, 
    -0.17509708f, -0.09832462f, 0.10507127f, -0.00512225f, 0.00839943f, 0.01345343f, -0.00002837f, 0.02567695f, 
    0.02506178f, 0.02912952f, 0.10021093f, 0.03736402f, 0.16626285f, -0.10655130f, -0.09982794f, 0.15093350f, 
    0.04007106f, 0.03986630f, -0.01374978f, 0.04507467f, 0.00941048f, -0.00298248f, -0.00448125f, -0.03954221f, 
    0.60687125f, -0.01980191f, -0.12410406f, 0.10848479f, -0.05836682f, -0.09203798f, 0.00410939f, -0.00551165f, 
    0.02756243f, 0.09532690f, 0.01067691f, 0.14725588f, 0.20578437f, -0.00668557f, 0.06942581f, 0.18432517f, 
    -0.04303992f, -0.06054835f, 0.13665694f, 0.06202878f, 0.01919103f, 0.16024810f, 0.04392258f, 0.09668818f, 
    -0.18803117f, 0.12260689f, 0.11738823f, -0.03838264f, 0.06129409f, -0.05695773f, 0.09959481f, 0.02667248f, 
    -0.07158349f, 0.08248167f, -0.13295215f, 0.04601794f, 0.14999141f, 0.07184800f, 0.19843940f, -0.03976236f, 
    -0.07469026f, -0.17203820f, 0.04079505f, -0.03957536f, -0.01573220f, 0.05894183f, 0.04117579f, 0.02673230f, 
    0.30228314f, 0.03464190f, -0.14943029f, -0.04373025f, 0.02643164f, 0.08715063f, 0.01458753f, -0.00522299f, 
    -0.07010466f, -0.00058854f, -0.01628736f, 0.02954632f, -0.35513917f, -0.10425739f, -0.09204249f, 0.02358125f, 
    -0.02313399f, 0.06905814f, 0.00143218f, -0.00233059f, -0.06874815f, -0.05336725f, -0.00864939f, -0.03717500f, 
    -0.15978293f, 0.18787782f, 0.02709910f, -0.07496537f, 0.05608408f, 0.11406937f, -0.07381499f, -0.09124848f, 
    -0.08912703f, -0.07931325f, 0.05300241f, 0.02900453f, -0.18959281f, 0.06358164f, 0.06841802f, 0.11896580f, 
    0.10120273f, -0.03515138f, -0.01887759f, -0.02702985f, -0.04102049f, 0.03216599f, 0.13358460f, 0.04512916f, 
    0.17781985f, 0.13805957f, 0.01319185f, -0.10929424f, -0.01658885f, -0.00140250f, 0.02609171f, 0.05286342f, 
    0.06883423f, -0.00975356f, 0.04404778f, 0.10005727f, 0.06402063f, 0.03865964f, -0.08384128f, -0.07348296f, 
    -0.06352113f, 0.05681029f, -0.08284924f, 0.04194411f, 0.05145596f, 0.04573167f, 0.03033066f, 0.09212032f, 
    -0.11041719f, -0.02089061f, 0.00994732f, -0.02612044f, 0.07040064f, 0.08061516f, 0.08872056f, 0.01683752f, 
    0.02371371f, 0.08513811f, 0.00632450f, 0.18809435f, 0.25834513f, 0.20093848f, -0.12148844f, 0.28917038f, 
    -0.01157065f, 0.10499749f, -0.06001419f, -0.05530877f, 0.15029643f, 0.01559016f, 0.04736685f, -0.04055428f, 
    -0.21696119f, 0.17524926f, 0.21678279f, -0.17386658f, 0.15436092f, -0.12026547f, 0.06201616f, 0.08952001f, 
    0.01791202f, 0.08674428f, -0.01793725f, -0.08068381f, -0.41486499f, 0.24503560f, 0.10410912f, 0.02369504f, 
    -0.08405679f, -0.05116959f, -0.06184670f, -0.08456320f, 0.07149334f, -0.04150494f, -0.05725629f, -0.05805361f, 
    0.17453963f, -0.14749992f, -0.16518073f, -0.00417025f, 0.07057773f, 0.07998314f, -0.07292254f, -0.00391892f, 
    0.08264803f, 0.12511808f, 0.11462240f, -0.02893976f, -0.03754417f, 0.07504016f, -0.06492668f, -0.06303743f, 
    -0.04538299f, -0.02157127f, -0.04219514f, -0.06843739f, 0.04368663f, -0.05002756f, -0.01302390f, 0.06918099f, 
    0.07221582f, 0.31641695f, -0.07195830f, -0.02484532f, -0.00962519f, 0.16429812f, -0.13094960f, 0.07584323f, 
    0.11633877f, -0.05672898f, -0.01314308f, 0.00962535f, -0.10939778f, 0.00531131f, -0.01598580f, 0.15979581f, 
    -0.09345489f, -0.14461322f, -0.10158792f, 0.22966327f, -0.07852852f, 0.01511285f, 0.00221862f, 0.06217121f, 
    -0.22245178f, 0.13991757f, -0.06779760f, -0.04250478f, 0.02395547f, 0.02209980f, -0.03176985f, -0.02758502f, 
    0.07002567f, 0.17297392f, 0.06659482f, -0.00365695f, 0.09100327f, -0.07036977f, 0.17116126f, 0.09250152f, 
    -0.05151208f, 0.08800392f, -0.08705999f, 0.09672126f, -0.00680444f, -0.00482349f, 0.11629732f, 0.04427366f, 
    -0.09700409f, 0.35079068f, -0.14591418f, 0.09956449f, 0.01080638f, 0.10321123f, 0.01403850f, 0.01597272f, 
    -0.01748915f, -0.09341946f, 0.02960632f, 0.00847073f, -0.07431570f, 0.03904835f, 0.09784890f, 0.00063896f, 
    0.10764682f, 0.04569767f, -0.01349705f, 0.00090479f, -0.08930722f, -0.10316972f, -0.08701560f, -0.14128779f, 
    -0.22355570f, -0.03387055f, 0.08155806f, -0.03196605f, 0.08435998f, 0.03375687f, 0.06869512f, -0.00292614f, 
    0.16655242f, 0.03644910f, -0.06948944f, 0.04468963f, -0.02546815f, -0.06207074f, 0.16543490f, -0.03132480f, 
    -0.03561901f, 0.01120289f, 0.06152946f, -0.15593278f, -0.02705094f, -0.03096295f, 0.06732592f, 0.09398342f, 
    0.16863517f, 0.02242520f, -0.04116754f, -0.05684068f, -0.11791382f, -0.02632041f, -0.00727772f, 0.03095682f, 
    0.07363604f, -0.07930978f, 0.12310198f, 0.01467594f, -0.00107721f, -0.21245912f, 0.16056839f, -0.00073420f, 
    -0.08987118f, -0.10502164f, 0.00217538f, 0.04147097f, -0.03091135f, -0.06502986f, 0.14085065f, 0.14307633f, 
    0.33577612f, -0.11659401f, 0.38063323f, 0.23880476f, 0.18766165f, 0.00585978f, -0.12705740f, 0.05837139f, 
    0.13935477f, -0.01590431f, 0.01894027f, 0.01549609f, 0.06953759f, -0.08792803f, -0.03789401f, 0.09115146f, 
    -0.05119913f, -0.04757696f, -0.00644709f, 0.01212719f, 0.01268229f, 0.03559447f, -0.05725198f, -0.02240293f, 
    -0.01417004f, -0.07008510f, 0.07653002f, -0.15163358f, -0.02722334f, -0.01458852f, -0.03861665f, -0.05048713f, 
    0.00824155f, 0.03665216f, 0.05302612f, 0.03204921f, 0.43389595f, -0.06576343f, -0.03739022f, -0.10253919f, 
    -0.11184376f, 0.07260188f, 0.05214489f, 0.04272270f, -0.02235309f, 0.09057344f, -0.02267301f, -0.09093462f, 
    -0.06930984f, 0.07048804f, 0.01688124f, -0.03528547f, -0.04146853f, 0.00000428f, -0.00223380f, 0.11166255f, 
    0.01012250f, 0.00645584f, -0.02375672f, -0.06550448f, -0.08644767f, 0.01935004f, 0.01831320f, 0.13252367f, 
    0.10164507f, 0.04356379f, 0.00966862f, 0.11293026f, -0.01616456f, 0.13973761f, 0.04194957f, 0.05099304f, 
    0.10700455f, 0.08912568f, -0.09610384f, 0.02511646f, 0.04212627f, 0.01249584f, 0.06980172f, 0.06262495f, 
    0.03764869f, -0.02698566f, -0.03222802f, 0.02595716f, 0.05727030f, 0.01739295f, 0.00907892f, 0.15707210f, 
    0.11958261f, 0.00437020f, 0.00356685f, 0.03055220f, 0.06358102f, -0.07322475f, 0.06294113f, 0.08167589f, 
    0.02605965f, 0.04554582f, 0.05206782f, -0.19907032f, -0.04883392f, -0.05183963f, -0.00255409f, -0.01726206f, 
    0.07074012f, -0.09583377f, 0.05503942f, 0.07140008f, -0.25053421f, -0.14374603f, 0.05973238f, -0.06986409f, 
    -0.04990768f, -0.00354264f, -0.00283702f, 0.03326635f, 0.00288285f, 0.15930825f, -0.08683860f, 0.07336900f, 
    -0.00715239f, 0.02395851f, 0.11408562f, -0.04447350f, -0.04891919f, -0.06634320f, 0.08685900f, 0.10234661f, 
    0.10168438f, -0.02380015f, 0.05442510f, 0.06836244f, 0.06826701f, -0.05967342f, -0.22211239f, 0.09866152f, 
    -0.14551967f, -0.02061255f, -0.06414769f, 0.02974058f, 0.03890296f, -0.05008912f, -0.05725039f, 0.05414804f, 
    0.14380039f, -0.20723252f, 0.14604296f, 0.11405527f, 0.15120263f, -0.01125475f, -0.01489684f, 0.09460201f, 
    0.01068720f, 0.10888587f, 0.03927036f, 0.05552401f, 0.50369358f, -0.08708034f, -0.11238991f, 0.02246701f, 
    0.01050940f, 0.01485889f, 0.03825284f, 0.08287588f, -0.05722230f, 0.01227844f, -0.02182893f, -0.11341556f, 
    -0.15773833f, -0.03390731f, -0.01630656f, -0.18203761f, 0.05149378f, -0.01711239f, 0.08662926f, 0.05598089f, 
    0.06412220f, 0.08624326f, -0.05436881f, 0.17866008f, -0.20244601f, 0.10970638f, 0.09463213f, -0.10282868f, 
    0.07509235f, 0.04940041f, 0.09248225f, 0.06945179f, -0.03746039f, 0.06046123f, -0.01214218f, 0.09005054f, 
    0.34205216f, -0.00631585f, 0.09979132f, -0.02043272f, -0.05330000f, 0.01987411f, -0.08420447f, -0.01436744f, 
    0.04368822f, 0.06384061f, -0.05882205f, 0.08824848f, 0.05080147f, -0.19732405f, -0.12665002f, -0.12657124f, 
    0.05795311f, 0.12530106f, 0.07615366f, 0.08892924f, 0.08271622f, 0.05025961f, 0.06257100f, 0.08688533f, 
    0.10384005f, -0.11492445f, 0.02370529f, -0.00396537f, -0.06774508f, -0.07071331f, 0.04594897f, -0.03869665f, 
    0.00566036f, -0.01372561f, -0.05601093f, 0.16697873f, 0.30622265f, -0.02659041f, 0.03336623f, -0.11494554f, 
    0.05169379f, 0.10985851f, 0.06133079f, 0.01005273f, -0.00402340f, -0.05898317f, 0.12051606f, 0.08502523f, 
    -0.11360821f, 0.02622537f, 0.07360843f, 0.08797578f, 0.12378049f, 0.14012344f, 0.12127115f, 0.03139204f, 
    0.02276493f, -0.01590532f, -0.05215178f, 0.03332458f, 0.17938599f, 0.01915456f, 0.13251999f, 0.04175735f, 
    -0.08395093f, 0.01049549f, -0.06906709f, -0.03427136f, 0.10523958f, -0.19018966f, 0.10088512f, 0.04850334f, 
    -0.08492667f, -0.02686027f, -0.11696064f, 0.03129978f, -0.00472810f, 0.02358160f, 0.05016328f, 0.21751417f, 
    0.04319797f, -0.01678337f, -0.07469024f, 0.16065377f, -0.11146603f, 0.18783234f, 0.04587400f, -0.39121416f, 
    0.00218045f, 0.02312029f, 0.03278514f, -0.06726637f, 0.12505023f, 0.15023021f, 0.07148091f, -0.12198620f, 
    0.22325100f, -0.10963310f, 0.06759553f, 0.08684780f, 0.00761289f, -0.06313011f, -0.10065524f, 0.08530993f, 
    -0.02819831f, -0.00020368f, 0.06342085f, 0.09658422f, 0.03917723f, 0.30327100f, 0.03103837f, -0.18571427f, 
    0.07728550f, -0.10163864f, -0.12471806f, 0.08946572f, -0.06929165f, 0.14785260f, 0.03630089f, -0.03521513f, 
    0.14289241f, -0.10912777f, 0.10684173f, -0.05440321f, 0.00625268f, 0.09447906f, -0.08576049f, -0.03634448f, 
    0.11380915f, 0.04567546f, 0.03648595f, -0.04691447f, -0.05684419f, 0.04487070f, 0.00392629f, 0.12323752f, 
    -0.07827996f, -0.13435753f, 0.00876502f, -0.03439821f, 0.02308886f, 0.05695731f, 0.01498965f, 0.10947932f, 
    0.23431882f, -0.02420029f, 0.23972355f, 0.24064486f, -0.03595767f, -0.05179115f, 0.00160029f, 0.12329143f, 
    0.06977830f, 0.06415606f, 0.06981072f, 0.04919339f, -0.00610566f, 0.02555810f, 0.15474121f, 0.01027674f, 
    0.04969203f, 0.01073560f, 0.02385689f, 0.02273582f, -0.06057939f, 0.08850444f, -0.01822318f, -0.04505464f, 
    -0.04470893f, 0.15420374f, 0.14485158f, -0.20974755f, 0.00135425f, -0.06895437f, -0.05392813f, 0.02750795f, 
    0.17672209f, 0.13055445f, -0.00593745f, -0.00030258f, 0.38456413f, 0.03265493f, -0.22752711f, 0.07835688f, 
    0.11329289f, 0.07250633f, -0.03430281f, -0.02789792f, -0.02475012f, 0.12043948f, 0.04924409f, 0.03889148f, 
    -0.07507301f, 0.05469168f, -0.13812536f, -0.16228752f, 0.06013648f, 0.04385988f, 0.07596636f, -0.08152390f, 
    0.02499603f, -0.08609735f, -0.08609017f, 0.09449387f, -0.09773704f, -0.00564008f, -0.05155300f, -0.06574782f, 
    0.12302859f, 0.02182467f, -0.02896249f, 0.01542031f, -0.01527773f, 0.15116814f, 0.11967186f, -0.00867897f, 
    -0.29817021f, -0.03879999f, 0.17800251f, -0.14528665f, -0.10516113f, -0.02138099f, 0.09182949f, 0.10710876f, 
    0.01747249f, -0.02217724f, 0.03328564f, 0.04271962f, -0.32007304f, 0.20584051f, 0.10584445f, 0.11945403f, 
    0.03348628f, 0.02375740f, 0.08475332f, 0.03003728f, 0.02920577f, -0.00174763f, 0.11650769f, -0.01612085f, 
    0.21558459f, 0.11273677f, -0.23665693f, 0.17494734f, 0.10256898f, 0.14241166f, 0.02131352f, -0.05071709f, 
    0.01920265f, -0.03515838f, 0.13025515f, -0.03752943f, 0.25383827f, 0.18595092f, -0.10353721f, 0.21722676f, 
    0.00874124f, -0.01386354f, 0.08107126f, -0.05662714f, 0.01745804f, -0.06063213f, 0.01589139f, 0.04443299f, 
    0.07197622f, 0.04312709f, -0.18478516f, 0.02209296f, -0.03435420f, 0.05653765f, -0.03383280f, -0.13407466f, 
    0.07676652f, -0.03915753f, -0.03818761f, 0.03162581f, 0.44171315f, 0.09861734f, 0.15137468f, -0.10023576f, 
    -0.00011531f, 0.00224738f, -0.03531631f, 0.06282414f, -0.14410537f, 0.06030964f, -0.05565673f, 0.02275389f, 
    -0.10788604f, -0.05970155f, 0.01234868f, 0.10780801f, 0.01059853f, 0.01434682f, -0.01338007f, 0.08328979f, 
    0.09626724f, 0.05077386f, 0.02534364f, 0.06989425f, -0.13812803f, 0.18701942f, 0.10628819f, -0.12309574f, 
    0.05861063f, 0.09118669f, 0.07944430f, -0.12510483f, -0.01705731f, -0.15164205f, 0.11287322f, -0.04229433f, 
    -0.10439479f, 0.00165373f, 0.06614351f, 0.08102050f, -0.02935788f, 0.01172512f, 0.01788731f, -0.06514124f, 
    -0.09762152f, 0.03160921f, -0.01648943f, 0.07889312f, 0.04232842f, 0.18104289f, 0.27599192f, 0.21565795f, 
    0.00048592f, 0.01945677f, 0.10201931f, -0.02078816f, -0.01678856f, 0.01600530f, 0.01669988f, 0.02182953f, 
    0.31457338f, 0.07598858f, 0.04569617f, 0.11992586f, 0.04408227f, 0.02057491f, 0.00849808f, -0.03135136f, 
    0.04488014f, -0.01591340f, 0.06478813f, -0.10198098f, -0.41126934f, -0.21887799f, 0.35225531f, -0.15439709f, 
    -0.03785722f, 0.07469766f, 0.02870386f, -0.04206410f, 0.04478198f, 0.10251418f, 0.03120895f, 0.14025849f, 
    -0.05592298f, -0.11396160f, -0.04122061f, -0.04116240f, -0.00066813f, 0.11967519f, 0.06927194f, 0.05146952f, 
    -0.02455689f, -0.03946703f, -0.09113451f, -0.11100397f, 0.25930142f, -0.02989971f, -0.12415955f, 0.20252252f, 
    0.14815396f, -0.04905669f, -0.09223259f, -0.05960296f, 0.02090825f, 0.07550270f, 0.10069913f, -0.07161989f, 
    -0.49090710f, 0.03673916f, 0.03980546f, -0.11803472f, 0.03232026f, 0.01561376f, 0.02248936f, -0.06274434f, 
    -0.01404075f, -0.03813694f, 0.02812820f, 0.00996421f, -0.03624931f, 0.38883597f, -0.17920233f, 0.08148768f, 
    0.03105296f, -0.11614057f, -0.01352172f, -0.18574437f, 0.01891791f, -0.02179170f, 0.00089418f, 0.03695255f, 
    -0.08340743f, 0.00514188f, -0.03837056f, -0.06834548f, 0.06548057f, -0.07259177f, 0.06369425f, 0.03597313f, 
    0.02126961f, -0.00477990f, 0.03430212f, -0.03436035f, -0.11026143f, 0.08914731f, -0.00012125f, 0.07526919f, 
    0.05545031f, -0.06091779f, -0.08342582f, 0.12571694f, 0.08817630f, 0.03252919f, -0.01474841f, 0.09734713f, 
    0.07924149f, -0.03625696f, -0.17070705f, -0.18471569f, -0.13858970f, -0.04631676f, -0.19077404f, 0.09743542f, 
    0.00439287f, 0.02430180f, 0.01156713f, -0.02483920f, 0.11028346f, -0.09074947f, 0.00808793f, 0.15367118f, 
    0.07075033f, -0.02097586f, 0.09115709f, 0.06632591f, -0.01592481f, 0.09934343f, -0.04153031f, -0.00235202f, 
    0.15895990f, 0.12512140f, 0.00147455f, 0.16465661f, 0.07932071f, -0.04334057f, -0.00873766f, -0.07163260f, 
    -0.09018084f, 0.08071659f, 0.00248704f, -0.13554089f, -0.27045676f, -0.06380089f, 0.00990114f, 0.25191823f, 
    -0.00942080f, -0.00962032f, 0.02167094f, 0.02110670f, -0.14398524f, -0.03370313f, -0.03444095f, 0.11931001f, 
    -0.23697019f, 0.27842399f, -0.00938447f, 0.00191129f, -0.05482238f, 0.00509426f, 0.21521145f, -0.06475893f, 
    -0.00519019f, 0.08225358f, -0.11166920f, 0.02945315f, 0.00161121f, -0.12011027f, 0.10332093f, 0.10537539f, 
    0.03212853f, 0.05262223f, 0.07748542f, -0.08397091f, 0.01455516f, 0.09395541f, 0.03695121f, 0.06480283f, 
    -0.14314723f, -0.07635907f, 0.10400268f, 0.13245358f, -0.02687840f, -0.10608547f, 0.02633749f, -0.04023847f, 
    0.06952269f, -0.03822083f, -0.00178620f, 0.13080312f, 0.38770834f, 0.09289088f, 0.13224451f, 0.04734098f, 
    0.08101030f, 0.02965395f, 0.02552116f, 0.01709806f, 0.04390047f, 0.08875952f, -0.02531575f, -0.04130909f, 
    -0.19284458f, -0.16514492f, -0.23256004f, -0.07338086f, 0.09455398f, 0.05143533f, -0.05909069f, -0.19291510f, 
    0.00145187f, -0.15273094f, -0.14963908f, 0.10455270f, 0.22641714f, 0.06072520f, 0.01293837f, -0.02051362f, 
    0.15486380f, -0.03474017f, -0.03869943f, 0.02003421f, 0.05958283f, 0.02870296f, 0.00121894f, 0.15751803f, 
    0.01545477f, -0.11507609f, 0.10407048f, 0.06637118f, 0.00700663f, 0.14526913f, 0.07225865f, 0.02093705f, 
    -0.16319816f, 0.01524765f, -0.10161713f, -0.02532464f, -0.00187053f, -0.01236042f, 0.34581998f, 0.08658975f, 
    0.05459240f, 0.06648181f, 0.10092711f, 0.02283788f, 0.01078833f, -0.07465831f, 0.00829120f, -0.05252115f, 
    0.45083138f, -0.00285663f, -0.08322349f, 0.05684096f, -0.07602616f, 0.06604563f, -0.05112094f, -0.09390932f, 
    0.11152397f, 0.08207455f, 0.03421159f, -0.08868804f, 0.11965797f, -0.02231572f, -0.23509496f, 0.12779456f, 
    -0.20967327f, 0.04126161f, -0.00239070f, -0.03017147f, -0.07254128f, -0.12167371f, -0.13310544f, -0.04194256f, 
    0.08303882f, 0.05278306f, 0.06628080f, 0.29243910f, 0.08599532f, 0.06557582f, -0.07111107f, -0.10907234f, 
    -0.11891386f, 0.05162333f, 0.02432447f, 0.00068027f, -0.06530853f, -0.11942512f, -0.09349048f, 0.06436236f, 
    0.00220518f, -0.04043233f, -0.14693017f, 0.10735284f, 0.06941541f, -0.00257085f, -0.12764952f, 0.09893797f, 
    0.00612493f, -0.00986276f, -0.02389839f, 0.00962230f, -0.03031636f, -0.05339845f, -0.02191263f, 0.00492654f, 
    -0.00578786f, -0.03670904f, -0.00734071f, 0.04295836f, -0.03679344f, -0.01758917f, 0.03757589f, -0.04660542f, 
    0.04293500f, -0.04523845f, -0.02056238f, -0.03786825f, 0.02623880f, -0.02405014f, -0.02174004f, -0.05072702f, 
    -0.00827954f, 0.03713269f, -0.02776801f, 0.03788093f, -0.04126133f, -0.05236736f, -0.00525839f, -0.04950678f, 
    0.02225094f, 0.00012175f, 0.01828522f, 0.03157307f, 0.02641344f, 0.04045162f, -0.02778148f, -0.03644695f, 
    -0.04922235f, -0.02295090f, -0.00638605f, -0.01116138f, -0.00105579f, -0.04126386f, 0.00251705f, -0.02143211f, 
    -0.03766843f, 0.01657369f, -0.01510650f, 0.01131782f, -0.03498243f, -0.01917857f, 0.01788729f, -0.01209688f, 
    -0.03211746f, -0.02900755f, 0.01975043f, 0.01377255f, -0.03459857f, -0.02750593f, -0.02247522f, -0.04511578f, 
    -0.03850261f, -0.05271299f, 0.00993339f, -0.02467857f, 0.02600822f, 0.04074578f, -0.00736082f, -0.05481812f, 
    -0.03646367f, 0.00894120f, 0.04416301f, 0.03117583f, 0.02133930f, -0.00532236f, 0.04374372f, 0.00485532f, 
    0.03727192f, -0.02341212f, 0.03480760f, 0.02596807f, -0.02509732f, -0.04627777f, -0.02349167f, -0.05092871f, 
    -0.03145692f, -0.01807670f, -0.02547146f, 0.02681852f, -0.00559696f, 0.01990361f, 0.01490361f, 0.02618291f, 
    -0.01725760f, 0.04004557f, 0.00573524f, 0.03107460f, 0.01027597f, -0.00327900f, -0.04213086f, 0.04212810f, 
    0.00073986f, -0.04194425f, -0.05097454f, 0.03873300f, 0.01425349f, -0.00445955f, -0.00659070f, -0.04847027f, 
    -0.01859236f, -0.02888809f, -0.02443168f, 0.03632139f, -0.01293545f, -0.04711125f, 0.03105285f, -0.01550388f, 
    -0.03526422f, -0.04537786f, 0.02946668f, -0.02840740f, -0.02804824f, -0.02927467f, 0.01576511f, -0.00011605f, 
    0.03903366f, -0.01315533f, 0.03435049f, -0.03752662f, -0.03459518f, 0.04250773f, -0.01783820f, 0.03956040f, 
    0.03264033f, -0.05050743f, -0.02935027f, -0.00060866f, -0.04435205f, 0.00883563f, 0.01215918f, -0.03119157f, 
    0.04600076f, -0.05579086f, 0.02121345f, -0.00120498f, 0.01604839f, 0.01723729f, -0.03142803f, 0.02702915f, 
    0.00931386f, -0.02954197f, -0.00147958f, 0.02746246f, -0.05051559f, -0.04238109f, -0.01060255f, 0.00999486f, 
    -0.00145216f, 0.03007714f, 0.01521189f, 0.02273146f, 0.01767343f, -0.01142221f, 0.02170907f, 0.02285828f, 
    0.00317833f, 0.02600876f, 0.03485880f, -0.01449802f, 0.01744583f, -0.05024754f, -0.04636531f, 0.02958513f, 
    0.00330906f, 0.04110754f, -0.03244997f, -0.03085221f, -0.05441071f, -0.01776311f, -0.03591084f, 0.03265810f, 
    0.01618822f, -0.03198399f, 0.01932695f, -0.00728575f, -0.04787652f, -0.04932175f, -0.05349535f, 0.03471871f, 
    -0.03800783f, -0.05166274f, -0.00203290f, 0.00301081f, -0.03993188f, -0.04859769f, 0.04437490f, -0.05313684f, 
    -0.02124357f, -0.02008954f, 0.02166405f, 0.02748186f, 0.02188631f, -0.03680226f, -0.04522126f, 0.04292834f, 
    -0.01481762f, 0.04061028f, -0.02939636f, -0.03109112f, -0.02602607f, -0.05470837f, 0.01220441f, -0.03748501f, 
    -0.04050468f, 0.03409582f, -0.03794256f, 0.00989575f, 0.03574254f, -0.00296019f, -0.03184564f, -0.00174945f, 
    -0.00853947f, 0.03951814f, 0.01099586f, -0.03836071f, 0.02972358f, 0.02006160f, -0.01066593f, 0.03702087f, 
    0.00842514f, -0.05106134f, -0.01006860f, 0.02458236f, -0.03162401f, -0.04821547f, 0.01840024f, 0.03088094f, 
    -0.04150288f, -0.04111637f, -0.03128404f, -0.01395690f, -0.00789500f, 0.02620489f, 0.00567594f, -0.03788530f, 
    -0.02529343f, -0.05663797f, -0.00508112f, -0.00529648f, -0.01472642f, -0.01791141f, -0.02608493f, 0.04492468f, 
    -0.01902278f, -0.02991039f, 0.03388356f, 0.00175287f, -0.05200674f, 0.00433158f, -0.02744151f, 0.02854682f, 
    0.02294711f, -0.01731619f, 0.02134743f, -0.05275779f, -0.05428999f, -0.00006655f, 0.04277685f, 0.03791617f, 
    -0.01688110f, 0.01740483f, 0.04184131f, -0.04869510f, 0.00945749f, 0.00903937f, -0.04171301f, 0.00848641f, 
    -0.04346163f, -0.01242831f, 0.03415852f, 0.02138898f, -0.02113484f, -0.03976181f, -0.01449653f, -0.00553387f, 
    -0.04711988f, 0.00300314f, 0.04439759f, -0.02997755f, 0.00138702f, -0.02594823f, 0.01129100f, -0.01023333f, 
    -0.01470600f, 0.01728187f, -0.03990721f, -0.00475697f, 0.01254403f, 0.04028550f, 0.04074497f, 0.02049940f, 
    -0.02628992f, 0.02256221f, -0.04338710f, 0.02013849f, -0.01911430f, -0.04785781f, -0.05014392f, -0.04113710f, 
    0.04970001f, -0.01220259f, 0.00645549f, -0.00948403f, 0.01367642f, 0.01320878f, -0.03721370f, 0.00669207f, 
    -0.01730166f, -0.00329866f, -0.02083583f, 0.03810755f, -0.02682722f, -0.00116556f, 0.00710051f, 0.01027115f, 
    -0.04086383f, -0.01666178f, 0.02716115f, 0.00070189f, -0.04744119f, -0.03670964f, -0.00643687f, -0.00999766f, 
    0.00933042f, 0.01452847f, 0.01538415f, -0.03062725f, -0.04464148f, -0.04355807f, -0.00068631f, -0.01049801f, 
    0.02222242f, -0.01591387f, 0.00199522f, 0.00708520f, 0.02658101f, -0.02278975f, -0.04575107f, -0.00929752f, 
    0.00965542f, -0.05007374f, -0.04897038f, -0.00993183f, 0.01316819f, -0.00557436f, -0.04138724f, -0.03919614f, 
    0.03550194f, -0.03043350f, -0.00503671f, -0.03167485f, -0.00328340f, -0.03748469f, -0.01352395f, 0.02722120f, 
    0.00438819f, -0.01892662f, 0.01893788f, 0.03703227f, 0.04284734f, -0.03698870f, -0.04789504f, -0.03065054f, 
    0.01204601f, -0.01293839f, -0.02462666f, 0.00974349f, -0.00069941f, -0.01027639f, -0.04433642f, -0.02336144f, 
    0.02939392f, -0.17153910f, -0.07104000f, -0.09579127f, -0.07115035f, 0.04929442f, -0.13693668f, -0.00045468f, 
    0.11776582f, -0.02247440f, 0.01716354f, 0.04176669f, 0.05366857f, -0.04214073f, 0.15950285f, 0.13392122f, 
    0.03083526f, 0.03449076f, 0.00622522f, 0.00848285f, 0.02016595f, -0.02281097f, 0.04818469f, 0.14084473f, 
    0.23339517f, -0.08570869f, -0.12200812f, 0.19166933f, 0.05506662f, -0.02148031f, -0.12604484f, 0.03555289f, 
    -0.00043333f, 0.03443022f, -0.01654445f, 0.03779891f, 0.17605299f, 0.02830183f, 0.21840847f, 0.10992815f, 
    0.09522633f, -0.03985423f, -0.06624565f, -0.09112037f, 0.01957224f, -0.05680129f, 0.00307564f, 0.04468375f, 
    0.09135599f, 0.27818644f, -0.00824499f, 0.02690043f, 0.08070086f, 0.02160187f, 0.16680233f, -0.03499369f, 
    -0.00064559f, -0.03423657f, 0.05607941f, 0.03327657f, 0.22672173f, -0.04285784f, 0.13295071f, -0.14070657f, 
    0.00995569f, -0.06436007f, 0.01409832f, 0.01071125f, 0.07861105f, 0.06550423f, 0.03621905f, -0.03279658f, 
    0.02788547f, 0.04588250f, -0.16236685f, 0.16422150f, 0.09701296f, -0.11968897f, 0.12054835f, 0.01725313f, 
    0.16901577f, 0.10736921f, -0.05954771f, 0.06773922f, -0.55096656f, -0.15522702f, -0.31484449f, 0.02476355f, 
    0.01422716f, -0.01235662f, 0.10997040f, -0.07621555f, 0.01467492f, -0.04954305f, 0.02656442f, 0.08203699f, 
    -0.19224116f, 0.00887346f, 0.04522262f, -0.05964408f, -0.00975064f, 0.04152507f, 0.01917968f, -0.06204447f, 
    0.07974680f, -0.03246751f, -0.02332563f, 0.22545595f, -0.18311653f, 0.10605825f, -0.02606069f, 0.04189880f, 
    0.04382454f, 0.07924250f, -0.04704012f, 0.01919015f, -0.02176595f, 0.07012383f, 0.13361482f, 0.03411795f, 
    0.00410822f, 0.23140089f, 0.14547595f, -0.04554468f, -0.02492215f, 0.00121646f, 0.17309044f, 0.13905057f, 
    0.05771826f, -0.12109852f, -0.10246750f, 0.10443220f, 0.08527466f, 0.01470960f, -0.04601297f, 0.15459745f, 
    0.05957352f, 0.04996246f, -0.07253295f, -0.01739814f, 0.00203834f, -0.03184402f, -0.04365275f, 0.14057495f, 
    -0.08512743f, -0.02094460f, -0.11234684f, 0.05156056f, -0.05800037f, 0.11556617f, 0.17151922f, 0.00489795f, 
    0.01101270f, 0.04921887f, 0.07173020f, 0.01843650f, 0.25789082f, -0.03345382f, 0.03134148f, 0.29572737f, 
    0.08696360f, 0.00253930f, -0.04893044f, -0.00307027f, 0.02111837f, 0.11957292f, 0.08078645f, 0.06637449f, 
    -0.17315023f, 0.23534752f, 0.09521347f, -0.09168584f, 0.16114731f, -0.14551170f, 0.08392894f, 0.00906158f, 
    0.00048345f, -0.00452280f, -0.16459079f, 0.14125505f, -0.44470850f, 0.20806514f, -0.05316650f, 0.01208470f, 
    0.04768122f, 0.02611656f, 0.03142332f, 0.00904952f, 0.00931069f, -0.02795193f, -0.03516614f, 0.04169714f, 
    0.16480240f, -0.03604385f, 0.00930997f, 0.05346700f, 0.10294829f, 0.08160773f, -0.00906759f, 0.02122770f, 
    0.08206474f, 0.09285521f, 0.06117935f, 0.04786365f, 0.06871819f, 0.09433978f, 0.13314076f, -0.06876174f, 
    0.06211466f, 0.01409193f, -0.01941572f, -0.10862008f, 0.13301526f, -0.11894139f, 0.12291692f, 0.03316793f, 
    0.10176770f, 0.07918184f, -0.21338344f, 0.14840533f, 0.12888731f, -0.09728104f, -0.07966104f, 0.02559278f, 
    0.02647052f, 0.04211185f, -0.12002499f, 0.05766467f, 0.33538473f, 0.07591398f, -0.01718300f, 0.12091734f, 
    -0.07774474f, -0.09870551f, 0.04384492f, 0.08488205f, -0.07511764f, 0.13501126f, 0.01622870f, 0.16662523f, 
    0.01134743f, -0.23095560f, -0.01672998f, -0.09267195f, 0.09178089f, 0.06834564f, 0.00922297f, -0.00749186f, 
    0.05336285f, 0.04501619f, -0.00897900f, 0.07625114f, -0.15155119f, -0.13501146f, -0.01024887f, 0.11012240f, 
    -0.12151183f, 0.09326597f, -0.01760804f, 0.17312190f, -0.08580092f, 0.08863935f, 0.11838243f, -0.05868106f, 
    0.05891860f, 0.07726189f, 0.00387011f, 0.00237267f, -0.03738763f, -0.01026704f, 0.03663708f, -0.00799646f, 
    0.07868934f, 0.01370729f, 0.12674816f, 0.06302270f, -0.08589369f, 0.07013585f, 0.15179692f, -0.02295492f, 
    -0.03788566f, 0.02413730f, -0.08981147f, 0.08508854f, 0.11286583f, -0.02356356f, 0.02452706f, 0.04262676f, 
    -0.06144844f, -0.00408361f, 0.14080440f, -0.13748236f, 0.13628285f, -0.05623741f, -0.03590420f, 0.11609437f, 
    -0.01249866f, 0.00348339f, 0.05356674f, -0.02799342f, -0.02422883f, -0.01700947f, 0.18980269f, -0.19311754f, 
    -0.06664591f, -0.02231215f, 0.05279536f, -0.02241034f, -0.03262898f, 0.05636860f, 0.00006947f, 0.07430955f, 
    0.06329744f, 0.05731396f, -0.10639343f, 0.08944775f, -0.03467730f, 0.03374461f, 0.11652815f, 0.03869021f, 
    0.17262404f, -0.01187068f, 0.03430057f, -0.11392464f, -0.09898098f, -0.04518670f, 0.05170022f, -0.08745922f, 
    0.01239814f, -0.00249600f, 0.08290917f, 0.01525856f, -0.06444398f, -0.00755344f, 0.02419460f, 0.00337266f, 
    -0.08284168f, -0.19627284f, 0.24613810f, 0.08433080f, 0.15662697f, -0.08309640f, -0.08190602f, 0.02132255f, 
    0.14754887f, -0.02366033f, -0.01879029f, 0.14768083f, -0.00642728f, 0.04910369f, 0.10081834f, 0.11643575f, 
    0.03505161f, -0.06960896f, 0.07017232f, -0.11040285f, 0.08253571f, 0.10034449f, -0.11314367f, 0.16106212f, 
    -0.18779936f, -0.15160270f, -0.05725783f, -0.21983595f, -0.01264714f, 0.00805778f, 0.01539453f, -0.09764498f, 
    0.00430003f, -0.04687533f, 0.09311766f, 0.01521806f, 0.01611636f, 0.02254426f, 0.14666419f, 0.00999822f, 
    0.02708065f, -0.04691849f, 0.00691656f, -0.00341542f, -0.01046324f, 0.06444570f, 0.00976850f, 0.07417887f, 
    0.00555226f, -0.05099850f, 0.03466055f, 0.00296340f, -0.03699653f, -0.01013013f, 0.01394586f, -0.02472029f, 
    0.00363005f, 0.03252593f, 0.00748911f, -0.00384884f, 0.04454129f, 0.01558663f, -0.01268200f, -0.00331512f, 
    0.03537180f, -0.04683078f, -0.03669257f, 0.01818423f, -0.02498742f, 0.04605526f, -0.03003198f, -0.03844050f, 
    0.00026212f, 0.04729509f, -0.03512182f, 0.02006499f, 0.01893300f, 0.00119218f, 0.03230287f, 0.02820708f, 
    0.03808570f, -0.00333677f, -0.03014653f, 0.04620869f, 0.00932495f, -0.03309914f, 0.03783843f, 0.04536365f, 
    -0.00652524f, 0.02158793f, -0.00653908f, -0.04261832f, -0.01595024f, -0.02464633f, -0.02198011f, -0.04807342f, 
    -0.05297766f, 0.02745123f, 0.03998550f, -0.05280318f, -0.01959727f, -0.05492410f, -0.01372255f, 0.04263097f, 
    0.00094470f, -0.01516147f, -0.04697356f, 0.02854824f, 0.03783559f, 0.01797502f, -0.00655524f, 0.00313889f, 
    -0.00358002f, 0.02243523f, 0.03820870f, 0.00534652f, -0.03179333f, -0.04007606f, -0.00249660f, 0.00905955f, 
    -0.03326287f, 0.04868113f, 0.00919397f, 0.02724090f, 0.03934182f, -0.03194945f, -0.04673643f, 0.00474710f, 
    -0.03421933f, 0.04501730f, -0.01090050f, -0.03654506f, -0.02634792f, 0.00197238f, -0.04460822f, -0.03200472f, 
    0.02866447f, 0.00308141f, -0.01178460f, -0.00220178f, -0.03893276f, 0.04143798f, 0.00362493f, 0.02236428f, 
    0.01020779f, -0.02814316f, -0.02826041f, -0.04141923f, 0.03886884f, 0.04749425f, -0.00249655f, -0.00965411f, 
    0.04410969f, -0.03612094f, 0.02825111f, -0.05510720f, -0.02384587f, -0.01764787f, -0.01474954f, -0.00227265f, 
    0.04749645f, -0.00989515f, -0.05093205f, -0.01519831f, 0.02213407f, -0.04655050f, 0.03307077f, -0.02913687f, 
    0.01834846f, 0.02994625f, 0.03227375f, -0.01202748f, -0.04642182f, -0.00672923f, -0.05211921f, -0.03333936f, 
    -0.02875587f, 0.04267309f, -0.01570802f, 0.01673469f, -0.04679282f, -0.00894407f, 0.03919619f, 0.04385104f, 
    0.01537602f, 0.01456976f, -0.04092542f, 0.00236735f, 0.04202682f, -0.03635112f, 0.01422942f, 0.00979898f, 
    -0.02633542f, 0.03656514f, -0.02652868f, -0.03469525f, 0.00815874f, -0.00887962f, -0.02047880f, 0.00181923f, 
    0.04801043f, -0.02989033f, -0.03354561f, 0.01172223f, 0.00752179f, 0.02262449f, -0.03023613f, -0.04135563f, 
    -0.05147177f, -0.04518925f, -0.02538162f, 0.02655845f, 0.01007215f, 0.00144078f, -0.03784130f, -0.04290890f, 
    0.03988939f, 0.00992948f, 0.01926114f, 0.02716818f, 0.01650206f, 0.01852067f, 0.01054611f, 0.04329676f, 
    0.02475296f, -0.04030370f, 0.02335585f, -0.02652451f, -0.02569292f, -0.05584785f, 0.03353861f, -0.02713603f, 
    0.03547609f, -0.02367427f, -0.01069149f, 0.01239746f, 0.01860735f, 0.02170222f, -0.01360564f, 0.02856136f, 
    0.03172456f, 0.01854929f, 0.03986181f, -0.00117743f, 0.00483085f, -0.04559829f, 0.00032672f, -0.01922239f, 
    -0.04068947f, -0.02433061f, -0.01787215f, 0.00536916f, -0.02979309f, -0.01755081f, -0.02921952f, -0.00730588f, 
    -0.03633889f, 0.00034574f, 0.00635751f, -0.01099399f, -0.04130758f, 0.03361238f, 0.01915983f, 0.00148463f, 
    -0.02328270f, 0.00666650f, 0.04029857f, -0.04156042f, 0.03427133f, -0.04411547f, -0.03208799f, -0.03349476f, 
    0.02391011f, 0.00370563f, 0.01152577f, -0.00600250f, 0.00072408f, -0.02898638f, -0.04514499f, -0.03515503f, 
    0.04147003f, -0.03595288f, -0.03675533f, -0.01020945f, 0.02804680f, -0.00336246f, 0.02780801f, -0.00534752f, 
    0.00911389f, -0.02792692f, 0.01837754f, -0.01764816f, -0.02118614f, -0.00561611f, -0.00482226f, 0.00477498f, 
    -0.00778266f, 0.03555179f, 0.02344385f, 0.02876527f, -0.05639679f, -0.02984800f, -0.03241006f, 0.00498019f, 
    -0.04897180f, 0.01165632f, -0.04008070f, -0.01794634f, -0.03130192f, -0.01241565f, 0.03562817f, 0.04311537f, 
    -0.05310877f, -0.00580302f, -0.01975239f, -0.02380354f, 0.01843735f, -0.00410051f, -0.04320179f, -0.02173364f, 
    0.00997085f, 0.04492030f, -0.00523666f, 0.04132889f, 0.01280581f, -0.05076635f, -0.03507628f, 0.04723124f, 
    -0.04565134f, -0.05294982f, -0.00499011f, -0.04593287f, -0.00450131f, 0.03776743f, -0.03043773f, -0.02912623f, 
    -0.03356341f, -0.03752324f, -0.00880262f, 0.03790215f, -0.01057639f, 0.01309828f, 0.04061613f, 0.02542678f, 
    -0.04954548f, -0.02914756f, -0.02343007f, 0.02139893f, 0.03630232f, 0.02410251f, -0.05218973f, -0.01238594f, 
    0.03185085f, -0.05912490f, 0.00196647f, 0.04073646f, -0.00682946f, 0.00900739f, 0.04486568f, -0.03982662f, 
    -0.05317191f, -0.02856461f, -0.03636152f, 0.03512074f, -0.04333755f, -0.02020900f, 0.04105311f, 0.02250244f, 
    -0.00601496f, -0.03164934f, 0.00642249f, 0.02753475f, -0.03348296f, -0.03246853f, 0.04047288f, 0.02773882f, 
    -0.01747723f, -0.04655714f, 0.03579471f, -0.02571880f, 0.02209853f, 0.00178751f, 0.01526466f, 0.02901096f, 
    0.00595973f, -0.04558400f, -0.00866015f, -0.05378267f, 0.04665628f, 0.01693614f, -0.00893204f, -0.00183451f, 
    0.02853171f, 0.00950500f, 0.03982702f, 0.00865182f, -0.01703249f, -0.02691656f, 0.03854591f, 0.04685052f, 
    0.00033039f, 0.02029007f, -0.02366476f, 0.00268304f, -0.04491307f, 0.02374013f, -0.02674728f, -0.04497468f, 
    -0.05303659f, -0.01404311f, -0.03983817f, -0.05438242f, 0.02836645f, -0.02340375f, -0.04755337f, 0.02560376f, 
    0.03426960f, -0.00864277f, -0.00040797f, 0.03801086f, 0.01550332f, 0.03690398f, 0.01660659f, -0.04944702f, 
    -0.05261301f, -0.00810367f, 0.01995752f, -0.03499655f, 0.00066035f, -0.01858187f, 0.01995943f, 0.05056058f, 
    -0.27790448f, -0.12085325f, 0.13303551f, 0.05453736f, -0.02131130f, -0.00216233f, 0.11532123f, 0.10669613f, 
    -0.09367736f, 0.05997254f, 0.06943720f, 0.13348250f, 0.21696413f, -0.10924293f, 0.02021867f, 0.12265600f, 
    0.09372473f, -0.00472893f, -0.01662465f, -0.10017962f, 0.01617690f, -0.00901977f, 0.03818288f, -0.09982506f, 
    0.36197689f, -0.19483589f, 0.15926810f, -0.15567295f, 0.04942252f, 0.13802236f, 0.09040162f, 0.06549092f, 
    0.10166223f, 0.03597104f, -0.07645616f, 0.04974210f, -0.18721488f, -0.26956192f, -0.20499897f, -0.05088065f, 
    0.02931762f, 0.06347317f, 0.05428375f, 0.08172069f, 0.08499356f, 0.04451382f, 0.12929785f, 0.08408539f, 
    -0.05609560f, 0.03008979f, 0.04337860f, -0.04021097f, -0.08353183f, -0.05740205f, -0.12218285f, 0.06176483f, 
    0.04023513f, 0.08805105f, -0.09208447f, 0.08914287f, -0.09887163f, -0.11801465f, -0.13194945f, 0.23695189f, 
    -0.10180033f, -0.13074124f, -0.02334074f, -0.03526055f, -0.02957994f, -0.05475354f, -0.05563247f, 0.01103121f, 
    0.17910618f, -0.26336706f, 0.11184406f, -0.26020622f, 0.06599126f, 0.07240403f, -0.10974557f, 0.16586342f, 
    -0.12437166f, -0.10972485f, 0.00073257f, -0.03113152f, -0.18314631f, -0.04084971f, 0.07648263f, -0.09749221f, 
    -0.01995212f, 0.06492185f, -0.01204677f, 0.09248631f, -0.02047141f, -0.15865450f, -0.09111373f, -0.18069424f, 
    0.55246341f, -0.13846062f, -0.15287718f, 0.00557587f, -0.01910568f, -0.04409501f, -0.02722933f, -0.07353277f, 
    0.01209947f, 0.06214727f, 0.01648745f, -0.03244817f, 0.17159289f, 0.28650630f, -0.07218648f, -0.02335797f, 
    0.10698473f, -0.01658958f, -0.02478957f, -0.02299927f, 0.01609107f, -0.04198737f, -0.11112537f, 0.01387051f, 
    0.16380708f, 0.08968227f, -0.03952158f, 0.08695503f, -0.00346050f, -0.00318322f, -0.05138351f, 0.01501299f, 
    0.03058134f, 0.16182992f, 0.10098600f, 0.06073637f, -0.16151328f, 0.02523951f, 0.23624696f, -0.17870206f, 
    -0.04781526f, 0.01689219f, 0.01338784f, 0.12431370f, -0.03300945f, 0.00543367f, -0.01473058f, 0.09462477f, 
    0.02626864f, 0.07007699f, -0.01167620f, 0.02550264f, -0.00739225f, -0.11666053f, -0.02384122f, 0.15719964f, 
    -0.08785020f, 0.04898417f, -0.02267994f, 0.06739344f, -0.01869739f, 0.06239949f, 0.03506558f, 0.01583776f, 
    -0.12702559f, 0.02794907f, 0.06504984f, -0.01764831f, -0.01076100f, 0.04325579f, -0.03729386f, -0.05929039f, 
    -0.33798796f, -0.03290546f, 0.09167492f, 0.03650522f, 0.00569149f, 0.06819527f, -0.12417715f, 0.02179141f, 
    -0.09178584f, -0.02408908f, 0.03960997f, -0.02438380f, 0.03697560f, 0.01582902f, -0.07292602f, -0.01289837f, 
    -0.01120632f, -0.14393602f, 0.05356959f, -0.01531391f, 0.03037417f, -0.07468067f, -0.03090557f, -0.08985685f, 
    0.07723065f, -0.16700576f, -0.08454731f, 0.24016282f, 0.02565618f, 0.01739824f, 0.06768163f, 0.01931307f, 
    0.05488605f, 0.10116515f, 0.06241586f, 0.00804406f, 0.05508925f, -0.03169746f, -0.28714746f, -0.00579366f, 
    0.06827781f, 0.00594282f, -0.02137026f, 0.12353953f, -0.02836705f, -0.01159108f, -0.18242487f, 0.01509104f, 
    0.17121069f, -0.11623432f, 0.18897749f, -0.15340175f, -0.16985804f, 0.12888685f, -0.08045635f, 0.04362786f, 
    -0.00810820f, -0.04541036f, 0.01687213f, 0.07755357f, -0.01733334f, -0.00811456f, 0.06230159f, 0.23345813f, 
    0.03848533f, -0.01809813f, -0.05761446f, 0.11292125f, -0.06499299f, 0.05268247f, 0.04030631f, -0.01793448f, 
    -0.03041178f, 0.15252171f, -0.04615505f, 0.19059826f, 0.02180936f, 0.04293653f, -0.04341726f, 0.18460248f, 
    -0.02753455f, 0.09123190f, 0.04159287f, 0.02928608f, 0.31317279f, 0.10224109f, -0.06613257f, -0.10865819f, 
    -0.11233016f, 0.17276125f, 0.03934294f, -0.09566037f, 0.22895175f, -0.10796867f, -0.04810306f, 0.10283144f, 
    -0.00927958f, 0.06133833f, 0.13826053f, 0.17760625f, 0.15177947f, -0.00862567f, -0.02170081f, -0.04225280f, 
    0.04414058f, -0.14520688f, -0.03154613f, 0.07183042f, 0.32539254f, -0.05902259f, -0.13660097f, 0.18543026f, 
    0.07035840f, -0.05646754f, 0.02488048f, -0.01848970f, 0.00292486f, -0.14148338f, -0.02142701f, -0.00644242f, 
    -0.22731778f, 0.22637692f, -0.00588613f, 0.16133973f, 0.10176381f, -0.03707285f, -0.02512662f, -0.01196608f, 
    0.08431470f, 0.02783605f, -0.03616214f, -0.04946839f, -0.03372981f, -0.00092088f, -0.21203367f, 0.07407329f, 
    0.14348392f, -0.02139860f, -0.00970111f, -0.03056396f, 0.14093001f, -0.03856616f, 0.14009222f, -0.01089559f, 
    -0.10133852f, -0.14800654f, -0.05053817f, -0.00289455f, -0.03373842f, -0.07516462f, -0.02667814f, 0.14844443f, 
    -0.06447125f, -0.20144750f, 0.04058255f, 0.03659491f, 0.05190773f, -0.04516061f, -0.10257880f, 0.02107172f, 
    -0.03231860f, 0.03955629f, -0.10292119f, 0.09682631f, 0.09953280f, 0.07645518f, 0.13126372f, 0.20018613f, 
    0.00288110f, 0.24263185f, -0.18238923f, -0.21152323f, -0.04586165f, 0.14365913f, 0.02845376f, 0.18762183f, 
    -0.11081976f, -0.05027656f, 0.09424605f, 0.01906941f, 0.23562570f, -0.07616668f, 0.03779587f, 0.08768374f, 
    0.02242798f, 0.01199899f, 0.03105838f, -0.02941153f, -0.17972906f, -0.04668628f, 0.13031143f, -0.09925019f, 
    0.08428606f, -0.00495978f, -0.15130654f, 0.15022294f, -0.03561731f, 0.00208241f, -0.11416699f, 0.12290006f, 
    0.00279540f, 0.06346468f, 0.00156276f, -0.04185401f, 0.15947464f, -0.02223166f, -0.05480648f, -0.12993729f, 
    0.00127455f, 0.00226236f, 0.01026582f, -0.03774652f, 0.00797145f, 0.11754046f, 0.09414681f, -0.05504021f, 
    -0.01806408f, -0.12586066f, -0.03886835f, 0.07431431f, -0.02588000f, -0.06520840f, 0.28667486f, -0.00701642f, 
    -0.02703007f, 0.08279286f, 0.07637811f, 0.14487335f, 0.12560235f, -0.01321774f, -0.04798610f, -0.08192547f, 
    0.02899790f, -0.20195730f, -0.09471627f, -0.10185163f, 0.08481098f, -0.01865419f, 0.03631682f, -0.05179099f, 
    -0.05893718f, -0.01943202f, 0.00815945f, 0.03336897f, -0.06588316f, 0.04370521f, 0.07984409f, -0.15817334f, 
    0.04118263f, 0.09223878f, 0.01258112f, 0.00150772f, -0.17069098f, -0.11897002f, -0.18212605f, -0.25601050f, 
    0.01549429f, 0.02409187f, -0.00013426f, -0.01199116f, 0.10481180f, 0.03336521f, 0.17136538f, 0.09082548f, 
    0.10016447f, 0.03625926f, 0.13058065f, 0.00803082f, -0.07727744f, -0.00229325f, -0.08816223f, 0.00189326f, 
    -0.02388567f, 0.17979302f, 0.01293615f, 0.06956180f, 0.05940031f, -0.00930460f, 0.03446522f, -0.06193390f, 
    0.00679746f, -0.07372018f, 0.18293338f, 0.15748884f, -0.08760640f, 0.01323447f, 0.14267269f, -0.04845435f, 
    0.13470906f, 0.00263837f, 0.00120482f, 0.01410751f, 0.03366026f, 0.11457766f, -0.04261451f, -0.05357670f, 
    -0.17689459f, 0.07854002f, 0.01950798f, 0.02086788f, 0.20974600f, 0.02065775f, 0.10187901f, -0.05410178f, 
    0.02557061f, 0.06796535f, 0.10529137f, 0.12708168f, -0.06784749f, -0.03307562f, -0.11998148f, 0.05980237f, 
    0.16942255f, -0.07057500f, -0.00436533f, -0.07070609f, -0.08044592f, -0.03972407f, -0.07217923f, 0.06367372f, 
    0.05181818f, 0.12877847f, 0.00096533f, -0.01515067f, -0.25876376f, 0.08728734f, -0.03740965f, -0.18549272f, 
    0.13574289f, -0.00378280f, 0.10079087f, 0.05046557f, 0.09663534f, 0.02933034f, 0.04163058f, -0.15939987f, 
    -0.00608414f, -0.01793987f, 0.21571872f, 0.09848847f, -0.14678143f, -0.02903664f, -0.18939368f, -0.02793912f, 
    -0.00989261f, 0.08810069f, 0.08979747f, 0.08118681f, 0.24489504f, 0.09719425f, 0.09559520f, 0.09202077f, 
    -0.13200244f, 0.05342271f, 0.06171404f, 0.09859070f, 0.00131016f, 0.22214311f, 0.00774095f, 0.10773900f, 
    -0.14108460f, 0.06897806f, -0.00853229f, -0.14972238f, 0.04527504f, -0.01956941f, -0.09383286f, -0.06817818f, 
    0.06917185f, 0.08255225f, -0.02024128f, 0.18239222f, -0.00484380f, 0.17585772f, 0.00386860f, 0.11504720f, 
    -0.06769729f, 0.06327882f, 0.05049388f, -0.10389377f, 0.04406521f, -0.23889172f, 0.10598250f, -0.08597911f, 
    -0.01824528f, 0.15445030f, 0.02382808f, 0.21239050f, 0.02097287f, -0.00288440f, 0.00409128f, -0.05536070f, 
    -0.17978533f, 0.03592416f, 0.15688327f, -0.15594895f, -0.15053549f, 0.30215448f, 0.06515970f, -0.06844568f, 
    0.03362774f, -0.05085704f, -0.04178634f, 0.05696853f, -0.10220769f, -0.04694119f, -0.03626253f, -0.16706225f, 
    0.16455546f, -0.03199818f, -0.05003764f, 0.09901290f, -0.00935388f, -0.01303726f, 0.02277918f, -0.03014339f, 
    -0.05055457f, 0.07474127f, -0.00263337f, -0.06114802f, -0.00709607f, -0.18572633f, -0.21118772f, -0.10600471f, 
    -0.04901317f, -0.13726376f, -0.01158202f, 0.07793529f, -0.05627619f, 0.13830933f, -0.06857288f, 0.05799498f, 
    0.06935342f, -0.04901266f, 0.20010388f, 0.07733952f, -0.07625659f, 0.06238132f, -0.01605163f, -0.04635220f, 
    -0.01241809f, 0.01211863f, 0.18127088f, 0.01484907f, 0.13853107f, 0.00747348f, 0.04914575f, 0.10618709f, 
    0.05722799f, -0.02051203f, 0.00657328f, 0.11654071f, 0.08506589f, -0.10368434f, -0.00677249f, -0.12627809f, 
    -0.32284087f, 0.00467403f, -0.07301272f, -0.12824206f, 0.13401970f, 0.07407736f, 0.14561358f, 0.12701637f, 
    -0.12362202f, 0.04168978f, 0.18470863f, -0.02505642f, 0.58205700f, -0.02171643f, -0.15369721f, -0.00629728f, 
    0.01349100f, 0.13157260f, -0.01671671f, 0.01469765f, 0.02151422f, 0.11314802f, 0.12416130f, 0.11603361f, 
    0.19458662f, -0.06023230f, 0.07988210f, 0.22708006f, 0.06608137f, -0.05020939f, 0.06813016f, 0.02055580f, 
    0.02820135f, 0.03961678f, -0.03453784f, 0.01123814f, 0.03830253f, 0.05295498f, -0.12259267f, 0.00947960f, 
    -0.01828936f, -0.20001680f, -0.06348898f, -0.07717267f, -0.00897337f, 0.04605576f, -0.01726969f, -0.15871452f, 
    -0.08843473f, 0.12727332f, -0.31342852f, 0.04666569f, 0.09170830f, -0.00505241f, -0.04107166f, -0.06532304f, 
    0.03454053f, 0.07002832f, -0.14110813f, -0.05908618f, 0.05664679f, -0.12584980f, -0.14466172f, 0.00588167f, 
    0.08492856f, 0.03728573f, 0.06523396f, -0.01701532f, 0.03520855f, -0.12752526f, 0.03047135f, 0.09344587f, 
    0.19012210f, -0.16774869f, -0.05297222f, -0.05478425f, -0.05460230f, -0.02741477f, 0.02290924f, -0.01189657f, 
    -0.02840270f, 0.02409699f, -0.04476199f, 0.22289091f, 0.15093631f, -0.08019488f, -0.07985566f, -0.20836940f, 
    -0.08862783f, -0.20598258f, -0.20563932f, 0.14787211f, -0.05028639f, 0.01440085f, 0.07341306f, 0.20831822f, 
    0.17785534f, 0.12150755f, 0.08867285f, 0.08821467f, -0.02036457f, 0.09601930f, 0.04030085f, -0.06238986f, 
    0.03866617f, -0.05595673f, -0.08164002f, -0.08729003f, 0.06374510f, -0.07881393f, 0.12097294f, 0.17097922f, 
    -0.08567267f, -0.25845689f, -0.03951174f, 0.00655833f, 0.21573541f, 0.00017600f, -0.05363292f, -0.23784773f, 
    0.21503194f, 0.00158148f, -0.18914908f, 0.04658574f, 0.09447764f, 0.02487479f, 0.05981360f, 0.03633569f, 
    -0.05779766f, 0.08895025f, 0.00069175f, 0.02667058f, 0.13755962f, -0.21671137f, -0.07384689f, -0.10078648f, 
    0.06131345f, 0.02644997f, -0.03176970f, -0.07692241f, -0.00892078f, -0.01433220f, 0.05897951f, 0.09750734f, 
    -0.04869229f, -0.02317937f, -0.00416509f, -0.02906494f, 0.03788222f, -0.02361817f, -0.01558344f, 0.03221813f, 
    -0.02651144f, 0.00823820f, -0.02955492f, -0.04580980f, -0.02773411f, 0.04321435f, 0.02192131f, -0.02921508f, 
    0.02194944f, -0.00389797f, -0.04725939f, 0.04018818f, -0.02322610f, -0.04488479f, -0.02011998f, -0.02216517f, 
    -0.02397359f, -0.03899781f, -0.02780916f, -0.04701321f, 0.04148636f, -0.00583708f, 0.04070123f, -0.05813213f, 
    -0.03621593f, 0.04710678f, -0.02120116f, 0.00027616f, -0.00428820f, -0.01087801f, 0.01445560f, -0.04279293f, 
    0.00955408f, -0.05271258f, 0.01507852f, -0.04963994f, -0.00287353f, -0.02987749f, -0.05039133f, -0.04178713f, 
    0.03871446f, 0.00970339f, -0.01860824f, 0.03796081f, 0.03923685f, -0.05123398f, -0.00265384f, -0.01888574f, 
    -0.03916578f, -0.03715755f, -0.00266198f, 0.02162432f, 0.03876184f, 0.04231712f, 0.00044859f, 0.03995930f, 
    -0.03980537f, -0.05039656f, -0.02782562f, -0.03308314f, -0.04006416f, -0.04805346f, -0.02518261f, -0.04340441f, 
    -0.00840556f, 0.00128282f, 0.02118504f, -0.03988262f, -0.01454865f, -0.01130363f, -0.05731087f, 0.04069506f, 
    -0.02619147f, -0.02535803f, 0.02424067f, 0.00599528f, -0.04248969f, 0.01951266f, -0.04305698f, -0.02601138f, 
    0.03603649f, 0.03068860f, 0.03156335f, -0.02102857f, 0.01529826f, -0.00059378f, -0.05184842f, -0.02811848f, 
    -0.00495846f, -0.01365105f, -0.04344406f, 0.03089069f, 0.01031476f, -0.01097297f, -0.01761999f, 0.01756336f, 
    0.00089355f, -0.02034621f, -0.03800242f, 0.03579713f, 0.01160635f, 0.01113004f, -0.00031408f, -0.05532610f, 
    0.02228008f, -0.04251970f, -0.05097261f, -0.05283215f, 0.03649981f, 0.01727955f, -0.01455941f, -0.02730617f, 
    0.00583474f, 0.00630863f, -0.01114995f, 0.02416505f, 0.02220736f, -0.01159120f, -0.01025508f, -0.02811562f, 
    -0.00627610f, -0.00458987f, 0.02587605f, 0.03683961f, 0.03089655f, 0.00823099f, -0.01873239f, -0.01812592f, 
    0.03895295f, -0.00561741f, -0.00523415f, 0.02051804f, -0.00180206f, -0.02756693f, -0.05572160f, -0.02966247f, 
    0.00185942f, 0.02598810f, 0.01635248f, 0.00904609f, -0.02352667f, 0.04062137f, 0.00122082f, -0.02565788f, 
    0.04031037f, -0.05806485f, -0.04562309f, -0.04259084f, 0.03678623f, -0.02739465f, -0.02876730f, 0.02406901f, 
    -0.05662752f, -0.00805641f, -0.02339718f, -0.05001472f, 0.00989985f, -0.03195355f, -0.00717128f, -0.03532904f, 
    0.03119073f, 0.01043804f, 0.01452996f, -0.02267451f, -0.02920944f, 0.00074095f, -0.01210319f, -0.00459235f, 
    0.00191959f, 0.04041411f, -0.04322849f, 0.00563130f, 0.04009673f, -0.05411564f, 0.03890104f, 0.00343981f, 
    -0.01978023f, 0.03874729f, 0.02519647f, -0.00696755f, -0.01623920f, -0.01783710f, 0.00385710f, 0.02642212f, 
    -0.05658533f, -0.03535590f, 0.03368132f, -0.05770154f, 0.02196729f, -0.02519783f, -0.03256914f, -0.02606229f, 
    -0.02142476f, -0.05238705f, 0.01652788f, 0.02407861f, 0.01027843f, -0.01938928f, -0.05665806f, -0.03184597f, 
    -0.01301702f, -0.02342171f, -0.04475799f, 0.03579014f, -0.02150198f, 0.01252114f, 0.00609453f, -0.00024292f, 
    -0.01421926f, -0.00877926f, 0.00886876f, 0.00235149f, -0.04449269f, 0.01501118f, -0.02894888f, -0.03997106f, 
    0.01998031f, -0.03341642f, -0.03368659f, -0.04187592f, -0.04729231f, 0.04215920f, -0.02533710f, 0.04825260f, 
    -0.00498452f, -0.04263401f, 0.00309039f, -0.03617447f, 0.03761364f, 0.00495088f, -0.03930040f, -0.01395294f, 
    -0.04826625f, 0.01125322f, 0.03901061f, -0.01334977f, 0.02360298f, -0.04189619f, -0.01168458f, -0.01498230f, 
    -0.00983387f, 0.03422346f, 0.01297546f, -0.00509250f, 0.02519691f, -0.01508333f, -0.01761942f, 0.00268702f, 
    0.03468098f, 0.04249990f, 0.03684894f, 0.01060296f, -0.05181434f, -0.01240465f, 0.01179735f, 0.00462876f, 
    -0.05256223f, -0.02495154f, 0.04621451f, 0.00192213f, 0.03744289f, -0.02566736f, -0.00443352f, 0.00693966f, 
    -0.05760935f, 0.01919244f, -0.00084983f, 0.02898007f, 0.03468601f, -0.02400049f, 0.03431658f, 0.02600123f, 
    0.02436311f, 0.01907382f, 0.03474299f, 0.03720745f, 0.00635968f, -0.05322896f, -0.03905466f, -0.01630962f, 
    -0.03726094f, -0.05214998f, -0.00328740f, -0.02679167f, -0.00255220f, 0.02626162f, -0.02170714f, 0.02835319f, 
    -0.04166567f, -0.00131458f, 0.02393414f, -0.03786588f, -0.05432319f, -0.01539213f, 0.00103136f, -0.04875468f, 
    0.01537911f, -0.03245646f, -0.05900306f, -0.04403786f, -0.03296657f, -0.00037112f, 0.00847298f, -0.03292695f, 
    -0.01402562f, 0.01391913f, 0.03409548f, 0.04103337f, -0.03014039f, 0.03887443f, -0.04190086f, 0.01607695f, 
    -0.02483160f, -0.04282431f, 0.01413924f, -0.01428875f, 0.03645398f, 0.03652020f, -0.02439846f, 0.00184109f, 
    -0.01708936f, 0.03444793f, -0.03298532f, 0.00999050f, 0.00800563f, 0.00435236f, 0.03800660f, -0.01055205f, 
    -0.02403978f, 0.03947328f, 0.00170191f, 0.02092659f, 0.00225895f, -0.04538636f, 0.01929755f, -0.04293883f, 
    0.04119264f, 0.00361346f, 0.03406136f, -0.05092599f, 0.03529106f, -0.01800184f, 0.03422048f, 0.02184038f, 
    0.01639310f, 0.03963114f, -0.05765143f, -0.05177353f, -0.00603518f, 0.02095098f, 0.01162730f, -0.02328118f, 
    -0.05475596f, -0.00291182f, -0.02773790f, 0.01562583f, 0.03259472f, 0.00319182f, -0.02989346f, 0.01632158f, 
    -0.01446951f, -0.00030641f, -0.04239001f, -0.01870758f, 0.01654886f, 0.00721472f, -0.02598992f, -0.02043324f, 
    0.01182966f, -0.05549046f, -0.00571946f, 0.04041472f, -0.04033182f, -0.00865011f, 0.03739373f, 0.04401089f, 
    0.19439690f, 0.04813773f, -0.22883363f, -0.04839849f, 0.14269499f, 0.07752698f, 0.00531406f, -0.05749669f, 
    0.02153993f, -0.01547184f, 0.08025223f, 0.02279723f, 0.28489667f, -0.02878763f, 0.00217746f, 0.26032797f, 
    -0.16333678f, 0.00313407f, 0.13632135f, 0.05225800f, -0.03352728f, -0.00618749f, -0.01619045f, 0.06314892f, 
    -0.14486626f, -0.01699092f, -0.14033429f, 0.33638287f, -0.10587851f, 0.02963261f, 0.01933233f, 0.00007580f, 
    0.01266230f, -0.02497098f, -0.13314480f, -0.06026678f, 0.36099112f, 0.10279977f, 0.09823015f, 0.16649342f, 
    -0.25513053f, 0.07001414f, 0.09074036f, 0.04294452f, -0.11161487f, 0.03606163f, 0.05526511f, 0.02420513f, 
    -0.13757412f, 0.03740766f, -0.00928648f, 0.08693966f, -0.03488327f, -0.08420584f, -0.00106370f, 0.07161026f, 
    0.02637239f, -0.04292719f, -0.02022391f, 0.03317076f, -0.03657031f, 0.06301031f, 0.15204926f, -0.23883115f, 
    0.04878245f, 0.04655996f, 0.01889955f, -0.07801878f, 0.00830820f, -0.01836767f, -0.04537481f, 0.00608915f, 
    -0.31350192f, -0.04562702f, -0.09211911f, 0.10454005f, -0.04477308f, 0.04878555f, 0.05365852f, -0.00396350f, 
    -0.03320548f, -0.00349936f, -0.02075548f, -0.09791768f, -0.13515694f, 0.17583592f, -0.01154304f, -0.08543934f, 
    0.03978844f, 0.01891155f, -0.10010483f, -0.00106848f, 0.06224271f, 0.04299771f, 0.02091613f, 0.03251579f, 
    0.27074692f, -0.02587740f, 0.01882077f, 0.03226430f, -0.00167592f, -0.00421824f, 0.03566805f, 0.07805854f, 
    0.01921890f, 0.02516480f, 0.04531683f, -0.05400619f, -0.21108425f, -0.25500113f, 0.20715328f, 0.05866703f, 
    -0.01063010f, 0.19699915f, -0.01837337f, -0.11635946f, -0.10220253f, 0.06856588f, 0.08231087f, 0.01985909f, 
    -0.16268104f, 0.08180282f, -0.11338075f, -0.02579861f, -0.00709323f, -0.07810429f, 0.02978681f, 0.03696807f, 
    0.02160287f, -0.03389486f, -0.11755285f, 0.03712893f, 0.25575325f, 0.14516103f, -0.12642927f, 0.15717947f, 
    -0.00355542f, 0.02173725f, -0.08385231f, -0.10043841f, 0.12710357f, 0.02025673f, 0.02947229f, 0.04545710f, 
    0.00496492f, 0.08781751f, 0.06023255f, -0.05842025f, -0.05981202f, 0.04130293f, 0.03725103f, -0.04876551f, 
    0.04049774f, -0.04636781f, 0.02038031f, 0.07214347f, 0.11143848f, 0.09152669f, -0.19087510f, 0.07180823f, 
    0.03429230f, -0.04326694f, 0.05603462f, -0.03450594f, -0.02937110f, 0.01969534f, 0.02082369f, 0.12552585f, 
    0.06580026f, 0.00893322f, -0.03918675f, 0.10412434f, -0.02515517f, -0.05574093f, -0.02222087f, 0.00544228f, 
    0.09861790f, -0.05308220f, -0.00882492f, -0.03532502f, 0.08279240f, 0.10752652f, -0.00594544f, 0.19055769f, 
    -0.09613258f, -0.14224759f, 0.03256406f, 0.05848017f, 0.08537808f, -0.02712453f, -0.04569433f, 0.15602593f, 
    0.27043048f, 0.17390965f, -0.13201897f, 0.07372072f, -0.13182306f, 0.01442495f, -0.14809063f, 0.05889442f, 
    -0.03610127f, -0.02778088f, -0.03703414f, -0.00180517f, 0.27879992f, -0.10382842f, 0.04799434f, 0.13438383f, 
    -0.10743840f, -0.10331212f, 0.02313775f, -0.09947482f, 0.05239993f, -0.07095563f, -0.00106087f, 0.09309530f, 
    0.06834668f, -0.08948790f, -0.19561255f, 0.02453233f, 0.05693879f, 0.00205261f, -0.03845655f, 0.06554307f, 
    -0.14218287f, 0.03493040f, -0.02993116f, -0.00614339f, -0.12330946f, -0.08964131f, 0.17792529f, 0.09880029f, 
    -0.03019756f, -0.00312972f, -0.02067480f, -0.05905594f, -0.07369790f, -0.05767633f, 0.01735689f, 0.02597076f, 
    0.08679803f, 0.01195378f, 0.03340225f, -0.16198663f, 0.00769011f, 0.01105577f, -0.01252617f, -0.12381248f, 
    0.02738616f, 0.05757340f, 0.00314041f, -0.02621827f, 0.22211403f, 0.05492896f, 0.07776678f, 0.11702958f, 
    0.01750227f, -0.03729291f, 0.02793428f, -0.02871265f, -0.05855261f, 0.10937501f, 0.00236535f, 0.00788966f, 
    0.30720037f, -0.20226511f, 0.20407498f, 0.09434228f, -0.03248268f, 0.06800621f, -0.09603633f, -0.02815067f, 
    0.01784638f, 0.00526263f, -0.02288795f, 0.03383548f, 0.00875841f, 0.12850748f, 0.11697151f, -0.06040709f, 
    -0.03468922f, -0.04364141f, -0.10259403f, -0.00151651f, -0.03842953f, -0.02908308f, -0.00856461f, -0.03994491f, 
    -0.03938905f, -0.17877427f, 0.12620124f, 0.18223087f, -0.05142167f, 0.11165591f, 0.09540863f, 0.02327322f, 
    -0.05415577f, -0.08378904f, -0.03762161f, 0.07491603f, 0.27625784f, 0.09560286f, 0.10755402f, -0.11218112f, 
    -0.05918063f, 0.15403792f, -0.03182377f, -0.00825343f, -0.01005650f, -0.11717506f, 0.02702452f, 0.00010755f, 
    0.10152069f, -0.00990999f, -0.04144617f, 0.03959385f, -0.04295903f, 0.11061620f, -0.03897422f, 0.13388535f, 
    -0.09930649f, -0.09206788f, -0.02297360f, 0.01836744f, 0.18629336f, -0.05659972f, 0.16059406f, 0.24970859f, 
    -0.09384706f, 0.11163183f, 0.20444998f, 0.05211653f, -0.00152949f, 0.02649625f, -0.00030651f, -0.02680150f, 
    0.16889496f, 0.04771657f, 0.03007675f, 0.09929685f, 0.01573152f, -0.00760098f, 0.03974540f, -0.08569533f, 
    0.08941992f, -0.07860100f, 0.04189474f, -0.08016831f, 0.12021498f, -0.02775952f, -0.20950177f, 0.05490028f, 
    -0.12966327f, -0.07978944f, 0.08954912f, -0.03515439f, 0.04914346f, -0.09847768f, -0.10750823f, -0.07193319f, 
    -0.06023151f, -0.01536912f, -0.15797338f, -0.09606768f, -0.01759819f, 0.07678252f, -0.01028648f, -0.09328301f, 
    -0.04632769f, 0.03623361f, 0.01635100f, 0.00584881f, -0.06868810f, -0.04933108f, -0.11106203f, 0.20397201f, 
    -0.11889754f, 0.02726818f, 0.02041975f, 0.06015632f, 0.08075111f, 0.06306769f, 0.01932128f, 0.11233814f, 
    0.13987990f, 0.08202179f, -0.02858743f, -0.01166034f, -0.17259407f, 0.15627509f, 0.01822646f, -0.03975571f, 
    -0.00571229f, -0.05221558f, 0.04318366f, -0.04244610f, 0.03032847f, -0.14301790f, -0.27612188f, 0.06268898f, 
    0.10529264f, 0.01804028f, 0.02438258f, -0.07649694f, -0.02192872f, 0.01696499f, 0.09894851f, 0.08616889f, 
    0.19411094f, -0.11064360f, -0.12181776f, 0.23958065f, 0.20323263f, -0.04904647f, 0.09288042f, 0.16053651f, 
    0.07568614f, -0.02108363f, -0.14740153f, -0.02428603f, -0.01882054f, -0.20167696f, -0.07357351f, -0.11070678f, 
    0.00288383f, 0.00462987f, -0.08959542f, -0.10895647f, 0.03554693f, -0.10139950f, -0.03863063f, -0.01234015f, 
    0.09288820f, 0.22852652f, 0.05940799f, -0.10915159f, 0.01604797f, 0.00680226f, -0.04034748f, -0.07414519f, 
    0.05725454f, -0.01209529f, 0.01789511f, -0.02880055f, 0.08839845f, 0.02979046f, 0.33376026f, -0.00509473f, 
    -0.13762328f, -0.05669443f, -0.06322230f, 0.04254937f, -0.01992387f, 0.14869116f, 0.03149792f, -0.08894931f, 
    0.11085668f, 0.04399565f, 0.19979391f, 0.03524221f, -0.07637005f, -0.05690794f, 0.14934404f, -0.03518912f, 
    0.08583069f, 0.10588136f, 0.01320476f, 0.09242160f, 0.03825701f, 0.24350105f, 0.00197241f, 0.05136395f, 
    -0.14444177f, -0.05152426f, 0.02423355f, 0.09857307f, -0.08731069f, -0.12580721f, 0.00208919f, -0.00106969f, 
    -0.02644074f, -0.24045795f, -0.19292624f, -0.02080756f, 0.14646727f, 0.01797600f, -0.04322851f, -0.11843146f, 
    0.14666235f, -0.02016924f, 0.12211274f, 0.11227384f, 0.33853152f, -0.19351335f, 0.13510701f, 0.11314249f, 
    -0.03136357f, 0.06975540f, -0.08324014f, 0.00962258f, -0.05828131f, 0.10834783f, 0.00574209f, 0.01187446f, 
    -0.26397869f, 0.24072130f, 0.12347905f, -0.04807742f, 0.10642402f, 0.00925724f, -0.06472567f, 0.05409751f, 
    0.07654113f, 0.00065746f, -0.06570605f, -0.02042132f, -0.17278907f, 0.24415573f, -0.03977722f, 0.00681954f, 
    0.09851364f, 0.04853403f, -0.03314379f, -0.02442382f, -0.04018329f, 0.01270522f, -0.13935654f, 0.03110160f, 
    0.27693737f, 0.11588556f, 0.10780795f, 0.02607955f, -0.10614969f, 0.03958111f, 0.10423585f, 0.05907815f, 
    0.11609511f, 0.02516072f, 0.03901421f, 0.07386936f, 0.03356987f, 0.15140378f, -0.13929008f, 0.00532504f, 
    0.13406889f, 0.09136417f, -0.07831664f, 0.00608519f, 0.05807682f, 0.06451976f, 0.01004155f, 0.08149935f, 
    0.33905050f, -0.01591024f, 0.26950380f, -0.15810782f, 0.08526189f, -0.11683598f, -0.04895919f, -0.03410668f, 
    0.20692837f, 0.01217694f, 0.04968547f, 0.13392292f, 0.22136678f, 0.20278457f, 0.10289086f, -0.08356258f, 
    -0.08884225f, -0.03627467f, -0.04222920f, -0.11218955f, -0.11991797f, 0.07679494f, -0.03913140f, 0.04920859f, 
    0.10767777f, 0.15539265f, -0.22698043f, 0.04163944f, 0.34182510f, 0.11576528f, -0.00357223f, 0.03954289f, 
    -0.04026237f, -0.08410203f, 0.08000997f, 0.11160196f, -0.26144922f, -0.23900726f, -0.12308279f, 0.14172414f, 
    0.02199590f, 0.04567009f, -0.00796920f, -0.16075619f, 0.13630483f, -0.07768620f, 0.08300408f, 0.13832785f, 
    -0.08525822f, 0.16712739f, -0.08353188f, -0.02469701f, -0.00443610f, 0.06396168f, -0.05858948f, -0.07417980f, 
    0.12168610f, 0.09248214f, -0.12856543f, 0.02240002f, 0.17499208f, 0.19715373f, -0.00346091f, 0.01980153f, 
    -0.01123162f, -0.04069967f, -0.01814600f, 0.07266148f, -0.00873748f, 0.01253874f, 0.02466357f, 0.01483333f, 
    0.15283357f, 0.03850801f, -0.00761237f, 0.00333862f, -0.21218924f, -0.09706131f, 0.07306893f, -0.15936957f, 
    -0.05042781f, -0.01727406f, 0.01878570f, -0.01613191f, 0.21605062f, 0.30864966f, -0.10668417f, -0.08710761f, 
    0.15595159f, -0.04576601f, -0.08955781f, 0.09142270f, 0.00818555f, 0.06657472f, -0.03243772f, -0.08101887f, 
    -0.12174686f, -0.09904481f, 0.04659761f, 0.26945350f, 0.09802010f, -0.02300054f, 0.10294946f, -0.07216267f, 
    0.17251287f, 0.02092594f, 0.07365083f, 0.05486650f, -0.25189763f, -0.08130744f, -0.15316808f, -0.15678492f, 
    -0.00279652f, -0.01583371f, -0.01250245f, 0.05342581f, 0.12328530f, 0.07844120f, -0.03096976f, 0.01263260f, 
    0.01916759f, -0.03068655f, 0.16699298f, 0.15243606f, 0.01754716f, 0.08652715f, -0.11045124f, 0.14048080f, 
    -0.10395198f, -0.02069006f, -0.08893301f, -0.04162547f, -0.29257512f, -0.22491130f, 0.05701954f, -0.16716969f, 
    0.01902924f, -0.01058858f, 0.00768962f, 0.02400993f, -0.09930351f, -0.04708115f, 0.00126885f, 0.02333335f, 
    0.17585963f, 0.12706873f, 0.07307536f, -0.00328137f, 0.06742395f, 0.02301730f, -0.04664203f, 0.07984714f, 
    0.12218887f, 0.07592361f, -0.05334285f, 0.04397010f, -0.18107331f, -0.34562138f, -0.06282347f, 0.00629355f, 
    0.09362479f, -0.04359439f, -0.02683395f, -0.07130689f, 0.09209452f, 0.02817709f, 0.03080521f, -0.20820057f, 
    -0.10257117f, 0.01023528f, -0.05716227f, -0.06313165f, 0.07635432f, -0.06510129f, -0.14378624f, 0.05026624f, 
    0.00225722f, -0.09814186f, 0.09195998f, 0.11360704f, -0.02675169f, -0.17930092f, -0.01893445f, -0.12210733f, 
    0.08722785f, 0.08467331f, -0.00223070f, -0.01355338f, 0.11171439f, 0.11112697f, 0.06739207f, 0.09767324f, 
    0.02283902f, 0.17756027f, 0.04265774f, -0.00438215f, -0.16842210f, 0.06856634f, 0.04152442f, -0.10291285f, 
    -0.10749093f, -0.05512518f, 0.00565079f, 0.01128041f, -0.18243237f, -0.17502344f, -0.18714161f, 0.06949526f, 
    0.01651519f, -0.04123372f, -0.08438481f, -0.00761965f, 0.06652277f, 0.13766408f, 0.02954153f, 0.01650576f, 
    0.03755464f, -0.03922278f, -0.02671883f, 0.03272817f, -0.05356632f, 0.02808978f, -0.03768844f, 0.04109563f, 
    -0.00469164f, -0.01109002f, 0.02931503f, 0.01476930f, -0.01635769f, 0.00721323f, -0.04085245f, -0.01461380f, 
    -0.03723017f, 0.03487319f, -0.03465476f, -0.02916148f, -0.02431080f, 0.02411423f, 0.00261969f, 0.02821058f, 
    -0.01470536f, -0.01834146f, -0.03894377f, -0.01119850f, -0.05180904f, -0.01052601f, -0.01567927f, 0.03486507f, 
    0.04274161f, -0.03589645f, -0.00344406f, 0.01769689f, 0.00806814f, -0.03832358f, 0.02768527f, -0.01258786f, 
    -0.02863088f, 0.03599519f, -0.02286250f, -0.02346550f, -0.01836495f, 0.02607692f, 0.01164928f, 0.03026274f, 
    -0.05135337f, -0.03758022f, -0.01324776f, 0.00245922f, -0.01629296f, -0.00704503f, 0.01852180f, -0.02776458f, 
    0.00041445f, 0.03101536f, 0.04005059f, 0.04136400f, 0.00699387f, 0.01000103f, 0.03471595f, -0.02578139f, 
    -0.03135307f, 0.04218911f, -0.01445837f, 0.03361957f, -0.01710090f, -0.04461421f, -0.03566863f, -0.00032793f, 
    -0.02531197f, -0.03867594f, -0.05267281f, -0.01678382f, 0.03636264f, 0.02637771f, 0.02543548f, 0.02327881f, 
    -0.03721557f, 0.02532887f, -0.00985642f, 0.02293686f, -0.05348997f, 0.01377322f, 0.03929694f, -0.04779722f, 
    -0.04506075f, 0.02688063f, 0.01774138f, -0.00183835f, 0.02385864f, -0.05505296f, 0.01442299f, 0.04123690f, 
    0.02127296f, -0.03938312f, -0.01684866f, 0.04353355f, -0.00415348f, 0.04562132f, -0.01751932f, -0.00693739f, 
    -0.01933323f, -0.00432550f, 0.02961749f, -0.03027351f, 0.03143834f, -0.04424861f, 0.04516477f, 0.01709657f, 
    -0.01981278f, -0.05913783f, -0.01925598f, -0.04111950f, -0.04629938f, -0.02151780f, -0.00360365f, -0.01796889f, 
    -0.04262304f, 0.03618881f, -0.04659225f, 0.00073279f, 0.00788824f, 0.02105245f, -0.04412664f, -0.01546635f, 
    -0.01256817f, 0.04704889f, 0.00954688f, -0.03731191f, -0.05289510f, 0.01910590f, 0.00424006f, -0.01734908f, 
    -0.03169603f, -0.02504660f, -0.00394695f, -0.04184053f, -0.03715312f, -0.00612009f, -0.01854635f, 0.02489051f, 
    0.02196340f, -0.05291547f, 0.02851049f, -0.04365376f, -0.05443108f, 0.02142054f, -0.05562992f, 0.03485368f, 
    -0.00120079f, -0.00148368f, -0.04276550f, -0.02583002f, -0.03185525f, 0.01011829f, 0.01849741f, -0.00735312f, 
    -0.03356936f, -0.05731472f, -0.00426714f, -0.00431662f, 0.04066854f, -0.03678957f, 0.01611886f, -0.01091498f, 
    -0.00449267f, 0.02152865f, 0.00133856f, -0.04223471f, -0.05294956f, 0.00446463f, -0.05318272f, 0.01715612f, 
    0.04328601f, -0.05771567f, -0.01893168f, 0.02426462f, -0.00883956f, -0.04934600f, -0.05690442f, -0.00503078f, 
    -0.04527849f, -0.00229771f, -0.02146303f, -0.00956458f, -0.04186016f, 0.01876364f, 0.03731142f, -0.05670768f, 
    -0.05846770f, -0.03836186f, -0.01432324f, -0.02759195f, 0.04259253f, -0.01979539f, -0.01847926f, -0.01717708f, 
    0.04087080f, 0.04900731f, -0.02605766f, -0.05250331f, 0.00899573f, -0.04362864f, -0.05075334f, -0.02076429f, 
    0.02208778f, -0.00872619f, -0.01209483f, -0.00739853f, -0.04633651f, 0.00883439f, 0.04072335f, 0.02738831f, 
    0.02642930f, -0.02771922f, -0.03681654f, -0.00802531f, 0.02192059f, -0.01590449f, 0.02111585f, -0.00112464f, 
    -0.02125164f, -0.04208059f, 0.02929787f, -0.00397132f, -0.00252469f, -0.00397211f, -0.03452061f, -0.01958547f, 
    -0.02566372f, 0.03115965f, -0.02843871f, -0.03010808f, -0.01710780f, 0.01726900f, -0.05257151f, 0.00406949f, 
    0.02404463f, 0.02814456f, 0.02185640f, 0.01189294f, 0.03266568f, 0.04340256f, 0.01158341f, -0.01600944f, 
    -0.04123738f, 0.04643999f, -0.04086472f, -0.03287525f, -0.00299999f, -0.01444201f, 0.02032895f, -0.01010660f, 
    -0.03609549f, -0.05890029f, 0.02812700f, -0.03764354f, 0.02041291f, -0.00197366f, 0.01249037f, 0.00094186f, 
    0.03021551f, -0.05255383f, -0.02879306f, 0.01668265f, 0.00368728f, -0.03293593f, 0.01428582f, -0.04975938f, 
    0.01006607f, -0.01262912f, 0.02492413f, 0.00581644f, 0.01596479f, 0.02457893f, 0.00793042f, -0.00322197f, 
    -0.00937995f, -0.02861906f, 0.02967284f, -0.00175015f, -0.03656865f, 0.00470371f, -0.05235647f, 0.03070371f, 
    -0.01011915f, 0.04662953f, 0.03668804f, -0.01083438f, 0.03304737f, 0.00614550f, -0.02224455f, -0.00392181f, 
    -0.02037249f, -0.02288881f, -0.04885598f, 0.00305877f, 0.00951227f, 0.02449971f, 0.02214423f, -0.02566160f, 
    -0.02054380f, 0.01257077f, -0.04044607f, -0.05412415f, 0.00648237f, 0.01795696f, 0.00002277f, 0.03803134f, 
    0.02865164f, -0.05569872f, 0.03712691f, -0.01119440f, -0.01058946f, -0.02565910f, -0.03856838f, 0.02260870f, 
    0.02098303f, 0.00800640f, -0.03098776f, 0.02302337f, 0.00738108f, -0.01962974f, -0.04675777f, -0.03039085f, 
    0.03081871f, -0.00955520f, 0.00273736f, -0.03823581f, 0.00494131f, -0.00542646f, 0.05797658f, -0.03797535f, 
    -0.00573652f, -0.00946360f, 0.01472259f, 0.01796334f, -0.03908083f, -0.05267729f, -0.04563738f, -0.04822880f, 
    -0.04328611f, 0.02731877f, 0.04184026f, -0.05330124f, 0.01949960f, -0.00955789f, -0.00900521f, 0.02265641f, 
    0.00854242f, 0.01819980f, 0.01085907f, 0.00059103f, 0.02380959f, -0.00973608f, -0.01388246f, 0.03033103f, 
    0.01192837f, -0.02693590f, -0.04470083f, 0.02838869f, -0.04075871f, 0.05040091f, 0.02540524f, 0.00050165f, 
    0.00393558f, 0.00484499f, 0.00644037f, 0.00149674f, 0.02175230f, -0.05662316f, -0.02292168f, -0.04049041f, 
    -0.03520218f, -0.00194434f, 0.01363809f, -0.05800980f, -0.03124567f, -0.01891918f, 0.03610306f, -0.04539131f, 
    -0.01230858f, -0.00256669f, 0.02102565f, 0.00518263f, -0.04005177f, 0.03334310f, -0.00276216f, 0.03237827f, 
    -0.02575815f, 0.03964626f, -0.04838977f, -0.01166801f, -0.05019859f, 0.01049827f, -0.05754222f, 0.01622245f, 
    -0.04851261f, 0.03701948f, -0.04925179f, 0.03860323f, -0.05426412f, -0.01030417f, -0.03560255f, -0.04587010f, 
    -0.02345942f, -0.03800347f, -0.03764945f, -0.01413593f, 0.02101759f, -0.00426575f, 0.01419279f, -0.04381419f, 
    0.02883168f, 0.00488762f, 0.02490579f, -0.05625561f, -0.04221901f, 0.04549396f, -0.03447945f, -0.02551985f, 
    -0.05452306f, -0.03610619f, -0.00736306f, -0.03660940f, 0.02059492f, -0.00360100f, -0.03743597f, 0.00827971f, 
    0.00022589f, -0.03718158f, -0.04945293f, 0.00256706f, 0.01494649f, -0.05401957f, 0.02156444f, -0.05637402f, 
    0.00982445f, 0.01485860f, -0.01017803f, 0.01209084f, 0.00728936f, -0.04105147f, -0.01428959f, 0.03179917f, 
    -0.05066697f, 0.01666824f, -0.01178026f, 0.03568422f, -0.03108638f, -0.00085598f, 0.01971438f, -0.02896284f, 
    0.01796186f, 0.01904553f, 0.04029035f, 0.02016971f, -0.02185974f, 0.00189959f, 0.00054494f, 0.01439133f, 
    0.03166442f, -0.00569114f, 0.01770042f, -0.00031285f, 0.00581671f, 0.00390007f, -0.01070180f, 0.01986988f, 
    -0.02198839f, -0.02399452f, 0.00703856f, -0.05298593f, 0.02084876f, -0.05419271f, -0.04814427f, -0.02106142f, 
    0.03685752f, 0.00889399f, -0.00078055f, -0.02333656f, 0.01004257f, 0.03093464f, -0.01369295f, -0.02159896f, 
    -0.05203357f, 0.01642451f, -0.04613516f, -0.05577559f, -0.03804295f, -0.05031383f, 0.00534358f, 0.01687394f, 
    0.02597582f, -0.04752724f, 0.00977733f, -0.02794509f, -0.01310162f, -0.01640172f, 0.02063750f, 0.01775521f, 
    -0.04231219f, -0.01847962f, -0.00232045f, 0.02739118f, -0.02012567f, -0.05520968f, -0.03049454f, -0.00099448f, 
    -0.02819623f, 0.02236316f, 0.03516794f, 0.02918033f, -0.03302997f, 0.02746012f, 0.02734726f, 0.01807326f, 
    -0.05923337f, -0.00489878f, -0.04540762f, -0.00531386f, 0.00411260f, -0.01961181f, 0.02031556f, 0.03641484f, 
    0.04079190f, 0.03845075f, 0.01663759f, 0.03421012f, -0.03524666f, -0.00591144f, -0.01982302f, -0.05355380f, 
    -0.01128654f, -0.04724573f, 0.02187539f, -0.03056621f, -0.05654388f, -0.03737529f, -0.01401211f, 0.02928456f, 
    -0.04880213f, 0.02188626f, -0.03756242f, -0.00566282f, 0.00251716f, 0.02731814f, -0.03000729f, 0.00889078f, 
    -0.00285478f, 0.03908552f, -0.01340184f, 0.02886474f, -0.05680317f, -0.03536089f, 0.01896097f, -0.01247901f, 
    0.00130460f, -0.05357049f, -0.04274536f, 0.00535435f, -0.04150864f, 0.02489929f, -0.01124385f, -0.00057154f, 
    0.01980004f, 0.00444150f, -0.02717793f, 0.00674037f, 0.02200130f, 0.03327670f, -0.01326064f, -0.03310410f, 
    -0.00421382f, -0.02973553f, 0.02304266f, -0.02687925f, -0.05198526f, -0.01240084f, -0.03576851f, 0.01335148f, 
    -0.00275041f, -0.03759689f, 0.01823255f, 0.00438687f, -0.03777910f, -0.01202323f, 0.00725148f, -0.05458876f, 
    -0.01409766f, 0.02965995f, -0.01800861f, -0.00833887f, 0.01618534f, -0.04367698f, -0.05753575f, -0.00379639f, 
    -0.05921421f, 0.02160879f, 0.04101843f, -0.00891151f, -0.01046846f, 0.02939603f, -0.00809411f, -0.00399053f, 
    -0.01427500f, 0.03839881f, -0.03962348f, 0.03707309f, 0.01600524f, 0.00283307f, 0.00296360f, 0.03127899f, 
    0.02008125f, -0.03393514f, 0.03424896f, -0.02036236f, -0.05349125f, 0.02152828f, -0.03132472f, -0.01723879f, 
    -0.00059658f, -0.02623786f, -0.02219969f, -0.05241333f, -0.00140704f, -0.05299656f, -0.03728590f, 0.00048873f, 
    -0.02480449f, -0.00642736f, 0.03797865f, 0.00658075f, -0.05927211f, 0.00371921f, -0.04225848f, -0.02566446f, 
    0.02335266f, -0.00174178f, -0.04423580f, 0.03091163f, -0.00553639f, 0.00657287f, 0.03378938f, -0.05237477f, 
    0.00282449f, -0.03354499f, 0.01956516f, -0.01230212f, -0.04767462f, -0.00957365f, -0.03372031f, -0.04638142f, 
    -0.05004856f, -0.04422056f, 0.03762739f, 0.00792901f, 0.03149744f, -0.02132103f, 0.02608552f, 0.01097548f, 
    -0.03272002f, 0.03009055f, 0.00968396f, -0.00504594f, 0.03528620f, 0.03890340f, -0.05099884f, 0.03663855f, 
    -0.04433848f, 0.00476997f, -0.04309716f, 0.02335540f, 0.01344848f, 0.00157166f, 0.02181786f, -0.04610545f, 
    0.03717712f, 0.04156221f, 0.02180800f, -0.04224081f, -0.02928843f, 0.01521794f, -0.03162492f, 0.01383021f, 
    0.01464456f, 0.00647147f, -0.05732303f, -0.03804938f, -0.03740690f, 0.02139080f, 0.01712443f, 0.02702391f, 
    -0.04969775f, 0.03302805f, 0.00196863f, -0.03051670f, 0.02813867f, 0.01283491f, -0.00095132f, -0.02645081f, 
    -0.00902222f, 0.03779352f, 0.03914905f, -0.00199919f, -0.04094134f, -0.00248058f, 0.01896627f, 0.02811295f, 
    0.02403630f, 0.03822501f, 0.02138574f, 0.01709728f, 0.00782646f, 0.03304036f, 0.01198833f, 0.03517250f, 
    0.01222174f, 0.02896603f, 0.00705391f, -0.02153012f, 0.01655536f, -0.02635278f, -0.05925944f, -0.05912844f, 
    -0.02458538f, -0.05977416f, -0.03815924f, 0.01189442f, -0.03348596f, 0.01387569f, 0.03888017f, -0.01980365f, 
    -0.04638935f, 0.01938067f, -0.02021177f, 0.03997851f, -0.03485683f, -0.01258780f, 0.03822869f, -0.04211654f, 
    -0.04898806f, -0.02731210f, -0.00015248f, -0.05031592f, 0.01155897f, -0.00234653f, 0.01234093f, 0.03476060f, 
    0.03191657f, -0.02469756f, 0.03296548f, 0.01581044f, 0.02232067f, 0.03100316f, 0.02542306f, 0.03669712f, 
    -0.05275896f, -0.00806513f, 0.03049783f, -0.04288271f, -0.01832894f, -0.04859912f, -0.02672959f, 0.00567897f, 
    0.00456658f, -0.01188931f, -0.01196556f, -0.03854742f, -0.00298373f, -0.02867694f, -0.03737877f, -0.01623578f, 
    -0.00752721f, 0.01963622f, -0.05547915f, 0.04059123f, -0.02200368f, 0.00016768f, -0.02376665f, -0.04097132f, 
    0.01126701f, -0.03230829f, 0.03817936f, -0.04715444f, -0.03996478f, -0.02963301f, -0.05335015f, 0.00662279f, 
    -0.05058205f, -0.05818251f, 0.00572404f, -0.03644505f, -0.05039899f, -0.05057820f, -0.05542689f, 0.04124067f, 
    0.04131424f, -0.05068016f, -0.01465724f, -0.03838668f, -0.01292191f, -0.05191580f, -0.04440319f, -0.03977671f, 
    0.01369378f, -0.02401327f, -0.03376951f, 0.01928989f, -0.02593424f, -0.02394538f, 0.02826463f, -0.00535535f, 
    0.00885182f, 0.00340551f, -0.04060319f, 0.04217999f, -0.00434401f, -0.04913202f, 0.01864610f, -0.02918876f, 
    -0.01855299f, -0.03577128f, 0.00055094f, 0.01333256f, 0.03445174f, 0.03162656f, -0.04307078f, -0.02126971f, 
    -0.00969368f, 0.03562840f, 0.02845554f, -0.04975363f, 0.01226401f, -0.04696116f, 0.00599728f, -0.05209940f, 
    -0.01012559f, -0.03746737f, -0.02167214f, 0.03639891f, 0.02811530f, -0.04306525f, -0.01708686f, 0.01340956f, 
    -0.01916711f, -0.00864658f, 0.03410154f, -0.03915279f, -0.01930974f, -0.03371589f, 0.01252509f, 0.03488332f, 
    -0.04882757f, -0.01293503f, 0.01597932f, 0.00240608f, -0.01200922f, -0.02775478f, 0.02230960f, -0.01500612f, 
    -0.01419650f, -0.04941863f, -0.05169906f, -0.00275596f, -0.00331690f, -0.05928903f, -0.03539305f, -0.03782320f, 
    -0.00426171f, -0.01561722f, 0.00025124f, -0.01631032f, -0.02491292f, 0.02926121f, -0.01734420f, -0.03227357f, 
    0.03084275f, -0.04669028f, 0.02187464f, -0.01094510f, 0.05171590f, 0.00723542f, 0.01533519f, -0.00125920f, 
    0.01041959f, -0.00469268f, 0.00132629f, -0.04260304f, -0.05060044f, 0.00915985f, 0.00695501f, 0.04010260f, 
    0.02962928f, -0.03790577f, -0.04049776f, -0.03617204f, -0.05411575f, -0.00153495f, 0.03682425f, -0.02366924f, 
    -0.04507249f, -0.02318657f, 0.03359378f, -0.02986736f, -0.01244486f, -0.04229223f, -0.05073543f, -0.03685268f, 
    -0.04189356f, -0.00141840f, -0.05672112f, -0.01599395f, -0.02216781f, -0.00883848f, 0.03305558f, 0.03282443f, 
    -0.05097523f, 0.04149055f, -0.05401882f, 0.00974879f, 0.00899649f, -0.03736128f, 0.00391955f, 0.03867444f, 
    0.02663447f, 0.02775699f, 0.03976512f, -0.03147696f, 0.01225380f, -0.02091150f, -0.00975784f, -0.02811632f, 
    0.00835244f, -0.03334200f, 0.00567208f, 0.02851105f, -0.04581597f, -0.03998773f, 0.03267091f, -0.02060697f, 
    0.01160145f, 0.02414322f, -0.00163088f, -0.00790792f, -0.04739892f, -0.01893701f, -0.05444380f, -0.01550517f, 
    -0.00535583f, 0.01519241f, 0.00319509f, 0.00171038f, -0.05877506f, -0.01189276f, -0.00424530f, 0.02230445f, 
    0.01384498f, -0.04839501f, -0.04163590f, 0.03158383f, -0.03525400f, -0.01424498f, -0.00244151f, 0.02199083f, 
    -0.01440155f, -0.03865999f, -0.03626184f, 0.03942351f, 0.00662428f, 0.02562166f, -0.02527974f, 0.02295703f, 
    0.03789607f, 0.00709144f, 0.02004242f, 0.03239221f, -0.05607527f, -0.04900068f, 0.00523620f, -0.01436669f, 
    0.04320646f, -0.02915899f, -0.02638712f, 0.01371913f, 0.00262670f, 0.00811771f, 0.01625573f, -0.00323435f, 
    -0.03081389f, -0.04672796f, 0.01327740f, 0.02671949f, -0.01911471f, 0.02651647f, 0.01058653f, 0.04019800f, 
    -0.02881452f, 0.03788744f, 0.00595358f, -0.01979982f, 0.04022222f, -0.03824089f, -0.00076975f, 0.00396286f, 
    0.04152391f, 0.00696510f, 0.02870185f, -0.05361017f, 0.01648519f, -0.02907144f, 0.03393001f, 0.01804866f, 
    0.03512697f, 0.03757857f, -0.01636647f, -0.05481555f, 0.01699312f, 0.00137702f, 0.03284601f, -0.02154586f, 
    0.01382992f, 0.01180075f, 0.04419958f, 0.01252350f, 0.03604773f, 0.04064879f, 0.02714890f, -0.01274025f, 
    0.01374679f, 0.01794074f, -0.01881982f, -0.04886889f, -0.04646827f, -0.05423097f, -0.02176866f, -0.04473939f, 
    0.00397227f, -0.03219307f, -0.00824263f, 0.02837692f, -0.03286321f, 0.02901542f, -0.01929560f, -0.02120254f, 
    -0.05732029f, -0.00526885f, -0.00725221f, 0.04406464f, 0.02534672f, -0.02007923f, 0.01679127f, -0.02500268f, 
    -0.04583177f, 0.03258044f, 0.03429667f, 0.04051051f, 0.05583910f, 0.04018489f, -0.04778152f, 0.03831709f, 
    -0.00335252f, 0.02003932f, -0.00098695f, 0.01486291f, 0.02470177f, -0.05352976f, -0.02269646f, -0.04804525f, 
    0.03123905f, 0.01624267f, 0.01098809f, 0.00046612f, 0.02876829f, -0.02769902f, -0.00671442f, -0.02965973f, 
    -0.05640597f, -0.01652871f, -0.00252533f, 0.04261533f, -0.02508680f, 0.02210371f, -0.02023872f, -0.02497844f, 
    -0.02810762f, -0.01054838f, -0.01620924f, 0.01223827f, 0.04702704f, -0.04583015f, -0.04397095f, -0.02452367f, 
    -0.03571425f, -0.04102878f, -0.04187786f, 0.03817711f, -0.05602069f, -0.01720499f, -0.05180731f, -0.02577327f, 
    -0.02057669f, 0.03662952f, -0.01148182f, 0.03870729f, -0.02024868f, 0.01323298f, -0.00370962f, 0.03339610f, 
    -0.02593276f, 0.02928826f, -0.04127039f, -0.01591054f, 0.04037050f, -0.02170008f, -0.03078403f, -0.04920555f, 
    -0.02649550f, -0.02383863f, -0.04441576f, 0.03040850f, 0.04552868f, 0.04444475f, 0.00102633f, 0.03776608f, 
    -0.05387930f, -0.05234072f, -0.03420975f, -0.02976390f, -0.05602811f, -0.04559124f, -0.03124208f, -0.05509894f, 
    -0.00545321f, 0.03031418f, -0.00136755f, 0.03581665f, -0.04230338f, -0.00409531f, 0.02795800f, 0.02004444f, 
    0.02952591f, -0.00225313f, -0.04184460f, -0.00947903f, -0.04478139f, -0.04307849f, 0.02943783f, -0.02311566f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01685595f, 0.00174155f, -0.04993431f, 0.00063097f, 0.03522919f, -0.00625231f, 0.07953480f, -0.04734884f, 
    0.06093675f, 0.04983208f, -0.01807378f, -0.00622676f, -0.05999495f, 0.07722232f, -0.00024975f, 0.00822473f, 
    0.05609456f, 0.09462129f, -0.00962054f, 0.08399624f, 0.04188626f, 0.00085063f, 0.04032521f, -0.03321185f, 
    0.04219644f, -0.00143113f, -0.05177257f, 0.02712622f, 0.02472741f, -0.05139560f, -0.03386393f, -0.04767697f, 
    0.06492367f, -0.03866287f, 0.03409686f, 0.06331071f, -0.06105576f, -0.00288883f, -0.04660144f, -0.09762891f, 
    0.03041110f, 0.01907333f, -0.01875151f, 0.03222886f, -0.00786755f, -0.02440063f, -0.04770418f, 0.03424650f, 
    -0.01420838f, -0.01730835f, -0.01084814f, 0.06434317f, -0.12774038f, -0.05443818f, 0.08603848f, -0.05320083f, 
    0.05737756f, -0.01777839f, -0.05082924f, -0.06047328f, 0.03447486f, -0.00935518f, -0.01510675f, 0.03074037f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02980898f, 0.28745472f, 0.10658363f, 0.05393765f, 0.27604046f, 0.31440866f, -0.04522865f, 0.09708942f, 
    0.20763244f, 0.03976685f, -0.06433210f, 0.32446927f, 0.09124488f, -0.51573300f, -0.12639551f, 0.08282853f, 
    -0.30266407f, -0.40130225f, -0.23966719f, -0.21192922f, 0.07026936f, 0.00400608f, -0.07293871f, -0.12978321f, 
    -0.38319269f, 0.22195481f, 0.05505930f, 0.01539177f, 0.25326270f, -0.23071389f, 0.05268790f, -0.02917348f, 
    -0.16030544f, 0.09487561f, -0.02158043f, 0.01772952f, 0.16582412f, 0.08646158f, -0.06420232f, -0.07841836f, 
    0.19181456f, 0.08272760f, -0.04798855f, 0.03184169f, -0.01812106f, 0.06382867f, 0.04866760f, -0.10086022f, 
    0.04331682f, -0.02292296f, -0.14055142f, -0.17746469f, 0.15386564f, -0.00994316f, -0.28003526f, 0.07493092f, 
    -0.09780633f, 0.27409568f, -0.12322287f, 0.16577677f, -0.38525084f, 0.09608093f, 0.08320945f, 0.06444789f, 
    0.10454756f, 0.24235420f, -0.03364204f, -0.11960783f, 0.15521413f, -0.61093223f, -0.03490306f, 0.02081773f, 
    0.19385764f, -0.12649508f, 0.08393393f, -0.52551913f, 0.04377883f, 0.12582427f, 0.11145020f, 0.15461057f, 
    -0.32069451f, -0.00566317f, -0.24943583f, 0.18580970f, -0.06496176f, -0.03641081f, 0.02376743f, 0.00102054f, 
    -0.12894808f, 0.35566741f, 0.06417627f, 0.01675456f, 0.00097241f, 0.00737508f, -0.06382616f, 0.05361012f, 
    -0.27945533f, 0.05744357f, -0.09717753f, 0.26783112f, -0.04976432f, 0.10096870f, -0.00330156f, -0.06791388f, 
    -0.07099956f, -0.12078613f, 0.07593045f, 0.10152871f, -0.03112659f, 0.01392898f, -0.48416761f, 0.25129473f, 
    0.18423584f, -0.01000865f, -0.16446947f, 0.18566950f, -0.18283254f, -0.02372827f, 0.06245117f, 0.01669571f, 
    0.04535795f, -0.35168269f, 0.09598046f, 0.12812975f, -0.09978035f, -0.05744877f, -0.08364571f, 0.07416683f, 
    -0.09964988f, -0.57051414f, -0.01378764f, -0.03861396f, 0.00366722f, 0.38479409f, 0.09741396f, 0.07327042f, 
    0.05659000f, 0.03528908f, 0.02742225f, -0.16291666f, 0.09574072f, -0.06819066f, -0.00673037f, -0.18525207f, 
    -0.05320155f, -0.03270620f, -0.37045458f, 0.06788126f, 0.10370405f, 0.08490004f, -0.06297509f, -0.00233359f, 
    0.28131580f, 0.25555596f, -0.09944988f, -0.06101215f, -0.23026510f, -0.01836750f, 0.10095898f, -0.01683807f, 
    0.06584201f, -0.09988662f, 0.11516609f, 0.16646869f, 0.09309765f, -0.07347032f, -0.02673206f, 0.37086812f, 
    -0.11639530f, 0.06442428f, -0.05607205f, 0.06355428f, 0.10237174f, -0.03411516f, 0.18315378f, 0.09654785f, 
    0.00325017f, 0.07053097f, -0.65599281f, 0.16220661f, 0.06429893f, -0.04451109f, -0.64007264f, -0.03141775f, 
    0.19928621f, -0.10266423f, -0.10387680f, -0.04753382f, 0.04925258f, 0.03435250f, 0.04195683f, 0.09048883f, 
    -0.00764086f, 0.04839704f, 0.05548116f, -0.06568331f, 0.07895325f, -0.22985603f, 0.13762684f, 0.02852314f, 
    -0.41883016f, -0.75682098f, -0.04668843f, 0.11869986f, 0.12141410f, 0.01372166f, 0.05895903f, -0.14272369f, 
    -0.07856216f, -0.02745459f, -0.12181648f, -0.21814705f, -0.04835134f, -0.03302091f, 0.07919318f, 0.05498257f, 
    -0.18111104f, -0.18414231f, 0.01828288f, -0.07726406f, 0.21375754f, -0.08254034f, -0.03588670f, 0.08125722f, 
    0.12674689f, -0.09583625f, -0.10186336f, -0.42697760f, -0.04953590f, 0.23239805f, 0.06005860f, 0.03166630f, 
    -0.09596571f, -0.05058161f, -0.09291530f, -0.00553307f, 0.00852149f, -0.00151131f, 0.22593926f, 0.29150590f, 
    -0.54997462f, 0.04683349f, 0.21892813f, 0.06886130f, -0.40950003f, -0.06132621f, 0.06694104f, -0.08914841f, 
    0.38196263f, 0.05572458f, -0.09676164f, 0.12557632f, 0.29870000f, 0.06814934f, -0.10953152f, -0.06582330f, 
    -0.11129801f, -0.08103461f, -0.04462317f, -0.01985535f, 0.02061509f, -0.53910184f, 0.12731095f, -0.06160353f, 
    -0.21339266f, -0.10869587f, -0.00443606f, 0.20006137f, 0.03304072f, 0.02482782f, -0.08277994f, -0.06580011f, 
    -0.15742229f, 0.23065181f, 0.33413184f, 0.08264170f, 0.06739563f, 0.07343963f, 0.09472942f, -0.07787717f, 
    -0.12422533f, 0.14298205f, 0.09894308f, 0.07072108f, 0.10208272f, 0.40061897f, -0.13066109f, -0.10772340f, 
    0.26127517f, 0.11762179f, 0.02944126f, -0.23688118f, 0.13860878f, 0.00578271f, 0.02350361f, 0.04903747f, 
    -0.17328058f, 0.03728083f, 0.06019415f, -0.02196746f, 0.09089203f, 0.05490828f, -0.37794954f, -0.00609899f, 
    -0.28620782f, 0.03815505f, 0.05815412f, -0.10799619f, 0.10742111f, 0.03090656f, 0.01525498f, 0.01196920f, 
    0.27446514f, 0.25743476f, 0.04957555f, -0.13613915f, -0.50615454f, 0.03929517f, 0.11094149f, -0.12553237f, 
    0.08335148f, 0.15523233f, 0.10408209f, 0.01182707f, -0.34287402f, -0.48026076f, 0.19860923f, -0.05408177f, 
    0.29710567f, -0.01622242f, 0.05858332f, -0.02685083f, 0.04520548f, 0.12445974f, -0.02239922f, 0.15209781f, 
    0.21380740f, 0.10428726f, 0.09005509f, -0.12324350f, -0.10856329f, 0.02442908f, 0.03736506f, 0.08751793f, 
    -0.35651377f, -0.51249349f, -0.01326025f, 0.08664197f, -0.04528557f, -0.14322606f, 0.05988673f, 0.04055303f, 
    -0.14262055f, -0.00579069f, 0.05432934f, -0.03107047f, 0.00058336f, -0.59838969f, 0.01949265f, -0.46003234f, 
    0.19233181f, 0.10855346f, -0.01643049f, 0.04076801f, 0.09907582f, -0.00623192f, 0.20543946f, 0.16938011f, 
    0.13178611f, 0.07203745f, 0.06456047f, -0.18254574f, 0.22507286f, -0.01943452f, 0.26319051f, 0.02144673f, 
    -0.18315659f, -0.38339460f, 0.05789241f, 0.20574248f, -0.07037540f, -0.12566504f, 0.07675668f, 0.09340701f, 
    -0.07213614f, -0.50788140f, 0.08942743f, 0.01615714f, -0.35796547f, 0.43707103f, 0.03868936f, -0.12940979f, 
    -0.28920069f, 0.01085512f, -0.06324995f, -0.41562778f, 0.06894442f, -0.49233377f, 0.00416888f, 0.22033283f, 
    -0.26053879f, -0.24177635f, 0.18869245f, -0.14736992f, -0.03856324f, -0.05044411f, -0.11500203f, -0.05040785f, 
    0.35865730f, -0.52220088f, 0.03060808f, -0.01591842f, -0.08626270f, -0.38481644f, 0.06875682f, -0.01225771f, 
    0.14976454f, -0.05096866f, -0.07802111f, 0.16587266f, 0.22191510f, -0.20603292f, -0.05175812f, 0.17537187f, 
    0.05180344f, -0.00511200f, -0.06898137f, 0.06440674f, 0.09369605f, 0.05284965f, -0.03797036f, -0.07673515f, 
    -0.00191000f, 0.11724350f, 0.15293248f, 0.17921738f, -0.12968773f, 0.02466947f, 0.15908575f, 0.05044177f, 
    -0.41297379f, 0.06910659f, -0.00937761f, 0.20919384f, -0.00578960f, -0.06852134f, 0.07864337f, -0.00177933f, 
    -0.09946489f, -0.15958220f, 0.04550523f, -0.01858288f, -0.47453406f, 0.30753425f, -0.39406961f, 0.02615201f, 
    -0.16576481f, 0.09159994f, -0.02497587f, 0.07314064f, 0.04076181f, 0.30063030f, 0.01418056f, 0.03933693f, 
    0.15361328f, -0.00899290f, -0.03312013f, -0.37254003f, -0.05803153f, 0.11141964f, 0.08097560f, -0.09640585f, 
    0.08623818f, -0.04895829f, -0.00332590f, -0.02533801f, 0.13249731f, 0.29305559f, -0.07043914f, -0.10017864f, 
    0.23511185f, 0.05061486f, 0.07349138f, -0.03628400f, -0.42323461f, 0.08509771f, -0.02169425f, 0.00473402f, 
    -0.47297204f, 0.06222592f, 0.00891891f, -0.09396648f, -0.02920366f, 0.03006817f, 0.24154760f, 0.01973960f, 
    0.03127850f, -0.10708833f, 0.06094860f, -0.33347338f, 0.25473624f, -0.08548710f, -0.07750351f, 0.03622622f, 
    -0.39266095f, 0.07889443f, 0.08959619f, 0.10689003f, 0.13654231f, -0.08199494f, -0.01846819f, 0.01931907f, 
    0.11812983f, -0.16637652f, 0.07211564f, -0.05879547f, 0.04934815f, -0.06190628f, -0.36316451f, 0.08165892f, 
    0.02944550f, 0.17554070f, 0.01689978f, -0.12738715f, 0.10099373f, 0.32698241f, -0.10818601f, -0.41162324f, 
    -0.14645933f, -0.49464318f, -0.03481686f, 0.14084758f, 0.11802019f, -0.05114920f, 0.05346010f, 0.02899328f, 
    -0.16812149f, 0.21146519f, -0.01693477f, -0.00875313f, -0.44083339f, 0.26022226f, 0.03333645f, -0.10574406f, 
    -0.33429557f, 0.01747750f, 0.12969387f, 0.17227037f, -0.08644803f, -0.32862803f, 0.02219308f, 0.24654990f, 
    0.20486718f, 0.06250487f, -0.00537937f, -0.04434495f, -0.08687975f, -0.08839596f, -0.03112205f, -0.11834750f, 
    -0.46341056f, -0.00698658f, 0.25160149f, 0.22943379f, 0.29632437f, -0.07671889f, 0.05706816f, 0.01391191f, 
    -0.12045452f, -0.43478718f, -0.10829341f, -0.05653904f, 0.24439305f, -0.03992932f, -0.03698704f, 0.02171763f, 
    -0.07206658f, 0.28193986f, -0.05001163f, 0.00553245f, -0.34739554f, 0.04132527f, -0.16644652f, 0.02547050f, 
    -0.14001372f, 0.37811062f, 0.00439681f, 0.32187915f, -0.01128668f, -0.14037132f, -0.01676993f, 0.05723599f, 
    -0.34077066f, 0.03521735f, 0.11022527f, 0.17159677f, -0.08003655f, 0.02005043f, -0.01379565f, 0.08892162f, 
    0.40729201f, 0.05366212f, -0.02644881f, 0.06050089f, -0.31913751f, 0.11849213f, 0.09901258f, -0.03614385f, 
    0.01094629f, -0.05059493f, -0.09233596f, -0.22165519f, -0.09891196f, 0.05290114f, 0.07696038f, -0.10719418f, 
    0.06053165f, 0.07164532f, 0.01221558f, -0.10431731f, -0.00844472f, 0.11223973f, 0.23967247f, -0.63642764f, 
    0.25256526f, -0.00119998f, 0.17652033f, -0.11562248f, -0.36539525f, 0.09271795f, -0.02952982f, 0.11416814f, 
    0.11679004f, -0.13457894f, 0.00559650f, -0.50841677f, -0.36278871f, 0.09041296f, -0.01525228f, -0.05247334f, 
    -0.12070277f, 0.11132099f, 0.10652483f, -0.04407353f, 0.08987109f, -0.11989994f, 0.01194836f, -0.06585147f, 
    0.38597688f, -0.06214963f, -0.09072464f, -0.17217629f, -0.10853378f, 0.11419830f, 0.06782158f, -0.11166154f, 
    0.33438247f, -0.11116866f, -0.10937918f, -0.10147629f, -0.01582774f, -0.13359663f, -0.08611134f, -0.01640895f, 
    0.35987687f, 0.03133500f, -0.07570797f, 0.03177223f, 0.02727963f, -0.33488411f, 0.06180719f, -0.09551394f, 
    0.22527595f, -0.08314014f, -0.08604196f, 0.31879675f, -0.55939102f, 0.18666402f, -0.08640961f, -0.40910012f, 
    0.12519208f, 0.03000091f, 0.04967490f, 0.03536395f, -0.01392259f, 0.05012471f, -0.00997930f, -0.03712495f, 
    -0.51093978f, -0.08209310f, -0.29348472f, 0.02958239f, -0.47126421f, -0.08041571f, 0.14512034f, -0.01203437f, 
    -0.24158432f, 0.06001348f, -0.02175094f, -0.47648859f, 0.23925564f, -0.01427279f, -0.03999577f, -0.07370704f, 
    -0.10495421f, -0.07125792f, 0.11192774f, -0.05671826f, 0.16931196f, 0.29982170f, 0.19931346f, 0.01893745f, 
    -0.29386303f, 0.19939165f, -0.09064965f, -0.50245196f, 0.07385742f, 0.00852489f, 0.07885878f, -0.41443083f, 
    0.14278790f, 0.15775299f, 0.11402842f, -0.00477166f, -0.06449394f, -0.08489221f, -0.08417156f, -0.04921772f, 
    -0.08452009f, -0.44269231f, -0.01215069f, 0.01809956f, -0.40199593f, -0.45381558f, -0.03269152f, -0.04465037f, 
    -0.12064326f, 0.11221006f, -0.11617295f, -0.03472477f, -0.20683572f, 0.23102523f, -0.01642889f, 0.17352384f, 
    0.02477960f, 0.09159142f, 0.04815388f, -0.10433839f, -0.02142461f, -0.06455422f, 0.23165256f, -0.13058557f, 
    0.02388220f, -0.02317355f, 0.22596118f, -0.30833375f, 0.22890979f, -0.11818769f, 0.03282594f, -0.04336858f, 
    0.30988902f, 0.31381875f, -0.10575355f, 0.08662761f, 0.01710319f, -0.04749395f, -0.05559207f, 0.03569746f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09856936f, 0.12975569f, -0.14409889f, 0.03531549f, 0.08434638f, 0.05123786f, 0.11669513f, 0.01313927f, 
    0.05748443f, 0.11730774f, -0.01210593f, -0.11160842f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
