#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.92564869f, 1.58961964f, -0.23568960f, -0.37099591f, 0.07961664f, -0.26455986f, 1.35996747f, -0.31476885f, 
    0.08001705f, 0.28028211f, -0.27315146f, 0.18721741f, 0.24555881f, -0.33181307f, 0.11849089f, 0.12771721f, 
    -0.10088906f, -0.22579229f, -0.12084354f, -0.46018612f, 0.34175280f, 0.33790168f, 0.16317947f, 0.22530276f, 
    0.13416100f, -0.83395445f, -1.79650605f, 0.01161423f, 0.67499202f, 0.29035017f, 0.95155919f, -0.29347557f, 
    0.46008775f, 0.68451655f, -0.22369628f, -0.11658377f, 0.02075034f, -0.07921693f, 1.05940902f, 0.23180112f, 
    0.20105307f, 0.24186110f, -0.02708747f, 0.25226390f, 0.22858165f, -0.04345898f, 0.01657682f, -0.02503879f, 
    -0.19510844f, -0.15190157f, -0.52601665f, -1.63415253f, -0.53919595f, 0.31958103f, -0.18290761f, -0.69884580f, 
    1.49596095f, 1.25671923f, -1.32348859f, -0.03755445f, 0.42112154f, 0.21026562f, -0.02234031f, -0.29863858f, 
    -0.18429343f, -0.53158027f, -0.32956433f, -0.30016848f, -0.28766549f, -0.26836190f, 0.03201683f, -0.11414516f, 
    0.13250081f, -0.12873383f, 0.18528432f, -0.62278277f, 0.55237019f, -0.30649367f, -0.26666427f, 1.19231343f, 
    -0.36206189f, 0.73110968f, 1.16861284f, 0.44512689f, 0.54517007f, -0.64095742f, -0.04579367f, -0.40266016f, 
    0.01963718f, 0.33883724f, 0.53279549f, -0.05708387f, 0.09757339f, 0.14342009f, 0.10831323f, 0.36954910f, 
    0.07471150f, -0.06099328f, 0.00732936f, 0.44864678f, 1.35835862f, 1.12257028f, 1.38227141f, -0.81952882f, 
    -1.69650090f, -0.30485329f, -0.04468828f, -0.14311217f, -0.78533876f, 0.47429121f, 0.53101647f, 0.51424676f, 
    -0.36129197f, 0.13843356f, 0.19373980f, -0.05027043f, -0.11389685f, 0.15643932f, 0.26742768f, -0.05140958f, 
    -0.06156903f, 0.01646647f, 0.06804136f, -0.12178797f, 0.30052778f, -0.61450809f, 0.27890712f, 0.68057394f, 
    0.67418653f, 0.39074311f, -1.51629567f, 0.06760184f, -1.23998129f, -1.19823194f, -0.31330070f, 0.61513615f, 
    0.30703455f, -0.07208078f, 0.19996275f, -0.14407411f, 0.08584389f, -0.11791895f, -0.13771690f, 0.00750578f, 
    -0.17031772f, 0.22466791f, -0.11663693f, -0.12672281f, 0.29938239f, 0.27122724f, -1.10400867f, 0.28804100f, 
    -0.03208823f, -1.15410686f, -0.37772208f, -1.07533300f, -0.09294993f, 0.12938294f, -0.25317407f, -0.64269203f, 
    0.19740120f, -0.06087874f, -0.02296527f, 0.01109872f, 0.00813121f, 0.86112273f, 0.15425001f, 0.01632303f, 
    -0.26534995f, -0.15476559f, -0.38567054f, 0.03545971f, 0.36532351f, -0.22839670f, 0.20849282f, -0.83229852f, 
    0.23555920f, -0.39277804f, -1.14578998f, -0.61440611f, -0.26198861f, -0.89938754f, -0.55882972f, -1.10151291f, 
    -0.27934030f, -0.36156017f, 0.03519588f, 0.56444812f, 0.69279087f, 0.16934852f, -0.36272696f, 0.00178383f, 
    0.26457050f, 0.49611282f, 0.70543426f, -0.11753953f, 0.17575303f, -0.17438553f, -0.07010549f, 0.12662771f, 
    0.07313552f, 0.02548134f, -0.35035908f, -0.22055592f, -0.77668422f, 0.11582725f, -0.17744169f, -0.68501312f, 
    0.08176120f, -0.79923123f, 0.83931655f, -0.13319343f, -0.93867791f, -0.44692504f, -0.11610787f, 0.57665777f, 
    0.45780876f, -1.11487973f, -0.02292860f, 0.35233453f, 0.36747247f, -0.23514451f, -0.22780368f, 0.02798179f, 
    -0.34859654f, 1.54583108f, 0.47773746f, -0.57512891f, 1.16374862f, 0.68145519f, 0.47007713f, 0.74636120f, 
    0.75607544f, 0.72548199f, 0.32833493f, -0.48645210f, 0.00671063f, 0.09347576f, -0.51777619f, -0.15388824f, 
    0.17600071f, -0.25861406f, -0.03997511f, -0.33702874f, 0.11709873f, 0.06976727f, -0.13479154f, 0.40083373f, 
    -0.11090901f, -0.10546038f, -1.05240023f, -0.39414084f, -0.88579822f, -0.96873498f, -0.87611300f, 0.96686071f, 
    0.71960247f, -0.32686785f, 0.93817061f, 0.87533396f, 0.32210660f, -0.23408404f, 0.26856247f, -0.19902508f, 
    -0.59068614f, -0.22832133f, 0.04602680f, 0.08351949f, 0.25370985f, -0.33872551f, -0.39356577f, -0.44023994f, 
    -0.46734536f, -0.05082775f, 0.15295376f, 1.25006175f, 1.06739247f, 1.11743963f, 1.13417125f, 0.89475286f, 
    1.17320871f, -0.71480972f, -0.57995749f, -0.71495467f, -0.28795126f, 0.44809616f, 0.25813362f, -0.24225393f, 
    0.09427211f, -0.58151394f, -0.09604769f, -0.26285517f, 0.12951970f, -0.14473328f, -0.18677865f, -0.03693441f, 
    0.25125584f, 0.14703237f, -0.13384205f, 0.31992227f, 1.05522382f, 1.18985403f, 0.75012958f, -0.28488168f, 
    1.08917391f, 0.67941272f, 0.11560780f, 0.36983293f, 0.50158459f, 0.62628508f, -0.71041089f, 0.25694436f, 
    0.16032250f, -0.15498249f, 0.05028778f, -0.42389601f, 0.17293084f, -0.35600579f, -0.28532353f, -0.43478867f, 
    -0.07319837f, -0.16830067f, -0.00202185f, 0.19519587f, 0.14590845f, 0.59644771f, 0.97665143f, 1.23610389f, 
    0.86466724f, 0.81594753f, -0.43047178f, 0.07080163f, 0.23277925f, -0.74301243f, -0.05438825f, -0.29510814f, 
    -0.44855630f, -0.62698281f, 0.46757174f, 0.47537649f, -0.11101153f, 0.37938550f, 0.19830480f, 0.50108796f, 
    0.27067319f, 0.08260842f, -0.23567261f, -0.17210105f, 0.24405141f, 0.27709842f, 1.29088759f, -0.77187204f, 
    -1.37398386f, -1.32219541f, -0.19076332f, 1.20897806f, -0.19583319f, 0.47041586f, 0.29083347f, -0.13234928f, 
    -0.59875154f, 0.01794678f, -0.62722665f, -0.00076306f, -0.07458013f, -0.03677588f, -0.11492417f, -0.06242076f, 
    0.22167240f, 0.39986670f, 0.11051909f, -0.13145956f, -0.15281098f, 0.00695379f, -0.07118376f, 1.43035126f, 
    0.74566931f, -1.00999558f, 0.40801269f, -0.35226473f, -0.64844817f, -0.15118259f, 0.66451961f, 0.39976159f, 
    -0.40660250f, 0.01502652f, -0.19898848f, 0.25812811f, -0.18063696f, -0.76752990f, 0.01083557f, -0.26848331f, 
    -0.37398353f, -0.04137444f, -0.16292872f, -0.10901109f, -0.23760003f, -0.56163996f, -0.32224241f, -0.40254974f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.05498710f, 0.42413586f, 0.33852607f, 0.27478626f, 0.18562393f, 0.47049579f, 0.30787942f, 0.65248019f, 
    0.46140671f, 0.08544074f, 0.05866015f, 0.38834417f, 0.12531823f, 0.10171352f, 0.27493703f, 0.12267056f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.80545902f, 0.02836204f, 0.43344650f, -0.17531846f, 0.08212729f, -0.04774155f, -0.00524531f, 0.06886011f, 
    0.06296374f, -0.04548069f, -0.06382049f, -0.04090193f, -0.12774834f, -0.18191060f, -0.08464830f, 0.33872747f, 
    0.17135973f, 0.10006427f, 0.01974032f, -0.00771069f, 0.08848451f, -0.05918082f, 0.13010070f, -0.03488497f, 
    -1.05648541f, 0.27743542f, 0.12401749f, -0.14380546f, -0.04701577f, 0.11633082f, -0.25646907f, 0.05057740f, 
    0.10096053f, 0.03627607f, 0.10570083f, 0.03989223f, -0.38457105f, 0.23930429f, 0.03417756f, -0.40184972f, 
    0.03725192f, 0.12841214f, -0.02534888f, -0.02006554f, 0.08418922f, 0.21368830f, -0.16100225f, 0.14698178f, 
    -0.70684457f, 0.30747035f, 0.17697430f, -0.29295126f, -0.06100839f, 0.03056334f, -0.12489717f, -0.01069587f, 
    -0.04433924f, -0.09464922f, 0.03751086f, -0.03587411f, 0.02088609f, -0.16621818f, -0.02617719f, 0.47404051f, 
    -0.19617407f, -0.06677178f, 0.04200963f, -0.07148553f, 0.03462243f, -0.18914296f, -0.05210009f, -0.09230065f, 
    -0.28069669f, -0.16784605f, 0.12723550f, -0.38876155f, -0.11871571f, -0.14609125f, -0.18394475f, 0.21339089f, 
    0.06638172f, 0.19046332f, 0.02659953f, -0.16426694f, -0.73734099f, -0.08142516f, -0.00063485f, -0.32726237f, 
    -0.02448690f, 0.13335370f, 0.30595073f, -0.00469507f, -0.00321311f, -0.11671704f, -0.08486290f, -0.07062609f, 
    -0.06443976f, -0.03252140f, -0.00664256f, 0.12214290f, -0.35766846f, -0.06706711f, 0.02542556f, 0.01526834f, 
    -0.16107367f, -0.09074977f, 0.23069344f, -0.20362712f, -0.07131969f, 0.14445414f, -0.16119997f, 0.34113273f, 
    -0.31112617f, 0.13059887f, -0.20683873f, 0.00533994f, -0.14306985f, 0.24734423f, -0.02510105f, -0.17664844f, 
    0.64956200f, 0.16739330f, -0.17929690f, -0.45091358f, 0.22877060f, 0.12926994f, -0.03315700f, 0.14861289f, 
    0.17708375f, 0.10515761f, -0.13908271f, 0.03372486f, 0.24772556f, -0.31895819f, 0.05470135f, 0.17457542f, 
    -0.44338748f, -0.08548332f, -0.03052580f, 0.08260524f, -0.03307884f, 0.18490924f, -0.21586438f, -0.06701314f, 
    0.21299174f, -0.10189584f, 0.06271747f, -0.06304653f, -0.07137446f, 0.01904764f, 0.16792630f, 0.14821085f, 
    0.02450706f, -0.04676014f, 0.02187742f, -0.00619466f, -0.01504612f, 0.28257585f, -0.22697262f, 0.14737718f, 
    -0.55828643f, 0.10274097f, 0.02028672f, 0.09575269f, 0.00140197f, -0.21658041f, -0.00587590f, -0.04804981f, 
    0.33042377f, -0.29806089f, 0.04140741f, -0.70635551f, 0.03445504f, -0.08873188f, 0.17090414f, -0.24542755f, 
    -0.20870167f, -0.05697547f, 0.11043721f, 0.20713003f, -0.05010379f, 0.18192858f, 0.16214840f, -0.22912140f, 
    -0.19162728f, 0.14949213f, -0.26812014f, 0.08616129f, 0.00267013f, -0.12278921f, 0.13974924f, 0.05839921f, 
    -0.58314580f, 0.03097370f, -0.50966913f, -0.58409554f, 0.08033772f, 0.01343394f, -0.02596317f, -0.00270867f, 
    0.08772685f, -0.23478998f, 0.01335465f, 0.02062716f, 0.31810778f, 0.40735286f, -0.27865279f, 0.10569170f, 
    -0.18483345f, 0.15609300f, -0.03092450f, 0.03108084f, -0.10454965f, 0.08982205f, -0.05726079f, 0.13774544f, 
    0.30439562f, -0.18082620f, -0.21940377f, 0.25028983f, -0.33533260f, -0.05016447f, -0.01510166f, 0.00500980f, 
    -0.12993546f, -0.24443881f, -0.04093738f, -0.12955271f, 0.07262606f, -0.11713477f, -0.06991592f, -0.07253149f, 
    0.17625217f, -0.08477242f, -0.24189553f, 0.13437787f, 0.36030129f, 0.23283717f, -0.19811356f, -0.03264253f, 
    0.08197787f, 0.18581557f, -0.39341137f, -0.26555717f, -0.00756276f, -0.05681500f, -0.01779057f, -0.15446828f, 
    -0.06898770f, 0.04032867f, 0.10533740f, 0.02551617f, -0.30638772f, -0.25512132f, -0.43049017f, -0.28236195f, 
    -0.03433837f, 0.00990350f, 0.04702482f, -0.02780262f, 0.08523395f, 0.08276360f, 0.07882523f, -0.12064623f, 
    -0.05992656f, 0.27513289f, -0.09833838f, -0.23015127f, -0.02706347f, 0.17079295f, -0.06295582f, 0.17384091f, 
    0.09479362f, 0.01743415f, -0.10817934f, 0.00158140f, -0.01137679f, -0.01849562f, 0.04100680f, -0.21277024f, 
    -0.02467207f, 0.02667077f, 0.17480552f, -0.09851167f, -0.11937563f, 0.37280676f, 0.23790701f, 0.15957928f, 
    -0.15851055f, -0.15480252f, -0.45676243f, -0.12051535f, -0.09739760f, 0.13196687f, 0.06056758f, -0.00915129f, 
    -0.14943054f, 0.06845248f, -0.52062708f, 0.05279082f, 0.49806142f, -0.10616058f, 0.34330153f, 0.29795247f, 
    -0.06551689f, -0.09131832f, -0.01794773f, 0.05000033f, 0.21654715f, 0.02644273f, -0.13883922f, 0.07811926f, 
    -0.32182854f, -0.27388242f, 0.08495323f, -0.22045423f, 0.11674383f, -0.05580432f, -0.06579459f, 0.14885278f, 
    0.01156814f, -0.06006551f, -0.01747547f, 0.13246621f, 0.23826559f, -0.07253850f, 0.25354627f, 0.25044054f, 
    -0.23525700f, -0.07151856f, 0.02290093f, -0.08396767f, -0.17040333f, -0.10769755f, 0.18523045f, 0.02582311f, 
    0.43810865f, 0.30105177f, 0.08809365f, 0.09921197f, -0.10376094f, -0.19318029f, 0.27230513f, 0.06079173f, 
    -0.07252097f, -0.10019661f, 0.00133515f, 0.02400863f, 0.39334807f, 0.25898257f, -0.16999167f, 0.39736673f, 
    -0.05109929f, 0.08511844f, 0.04812773f, 0.00405431f, -0.02898476f, 0.14215703f, -0.14058442f, 0.12713344f, 
    0.44879910f, -0.74592751f, 0.46001831f, -0.64619249f, 0.19233324f, 0.00255510f, 0.01837736f, 0.06588776f, 
    -0.03792948f, 0.18553452f, -0.03013154f, -0.17243458f, 0.32603669f, -0.71278739f, 0.11621398f, -0.14774320f, 
    -0.02673663f, -0.20394969f, -0.17009103f, 0.07559333f, -0.04333094f, -0.13880093f, -0.23006597f, -0.00099703f, 
    0.52580357f, -0.13482073f, -0.28374618f, -0.39645016f, 0.10470755f, 0.09369095f, -0.05897285f, -0.08432052f, 
    0.06454837f, 0.05574708f, 0.06637375f, -0.05453833f, 0.03889295f, 0.11667369f, 0.02606948f, 0.03524791f, 
    -0.28839180f, 0.04449730f, -0.23363897f, -0.09387340f, -0.01021286f, -0.19359913f, -0.06258689f, -0.13848670f, 
    1.11675179f, 0.02414490f, 0.24725358f, 0.23892674f, -0.05741620f, -0.01393299f, -0.09173758f, -0.00720097f, 
    0.18366407f, 0.02374746f, -0.04031508f, -0.16528451f, 0.11224511f, -0.21982779f, -0.29037493f, 0.12030344f, 
    -0.23995362f, 0.20510393f, 0.10635661f, -0.16429248f, -0.12313656f, -0.05230564f, 0.02560935f, 0.23180062f, 
    -0.41304860f, -0.06581829f, 0.08561486f, -0.44601175f, -0.02191947f, 0.19417918f, 0.14409886f, -0.02846657f, 
    -0.16071065f, -0.05256803f, 0.03822137f, -0.14100248f, 0.71555489f, 0.02299595f, -0.66622967f, -0.17145228f, 
    0.01394016f, 0.13369885f, -0.24449761f, -0.01050871f, -0.28396481f, -0.12432094f, 0.01823399f, -0.33435273f, 
    -0.14867380f, -0.14886396f, -0.61690569f, -0.11581287f, 0.09633040f, 0.09953633f, -0.12410675f, -0.02716092f, 
    -0.04278070f, 0.05281832f, -0.19334868f, -0.01327288f, -0.97454613f, 0.19235688f, -0.21092467f, -0.50887859f, 
    -0.05978934f, 0.02951957f, -0.12850930f, 0.01404214f, -0.16127644f, 0.10953061f, -0.15922178f, 0.10049248f, 
    -0.08777589f, -0.46860835f, 0.09616313f, -0.10366179f, 0.02011767f, -0.04776260f, -0.12434436f, 0.02956393f, 
    0.07728289f, -0.16214442f, 0.14966652f, -0.11552352f, 0.30153447f, -0.15869759f, -0.08796579f, -0.12683752f, 
    0.15351526f, 0.13026205f, 0.18361218f, 0.28126439f, -0.11496791f, 0.01021684f, 0.03738280f, -0.04020443f, 
    0.51179254f, 0.22497335f, 0.35665214f, 0.36121875f, -0.11001462f, -0.21271132f, 0.07589304f, 0.02513156f, 
    -0.08322646f, 0.09022065f, 0.08273135f, -0.19620681f, 0.03486670f, -0.01162241f, -0.17954941f, 0.08588361f, 
    0.14285272f, 0.10673436f, 0.05122872f, -0.11854808f, -0.09248903f, 0.02563104f, -0.14964734f, -0.03531923f, 
    0.07360633f, -0.14270926f, -0.03496915f, -0.14278461f, 0.30233070f, 0.05776890f, 0.29749095f, -0.02471584f, 
    -0.03520451f, 0.07598756f, 0.01416307f, 0.23737280f, -0.27391234f, 0.12240111f, -0.44571507f, 0.10759171f, 
    0.17474806f, 0.05552055f, 0.01751364f, -0.00031414f, -0.12839200f, -0.02584648f, -0.14401601f, 0.13284341f, 
    -0.89390039f, 0.26560172f, 0.12720227f, 0.42724848f, 0.16568689f, -0.03247215f, 0.05411823f, -0.10596041f, 
    -0.21420486f, -0.19471607f, 0.03736674f, 0.01707107f, -0.02005758f, 0.11456235f, -0.41091704f, -0.08631290f, 
    0.14692178f, -0.13027209f, 0.16219786f, 0.26220548f, -0.24312599f, -0.07245817f, 0.08581931f, -0.24879244f, 
    -0.13471553f, 0.82560819f, 0.16482563f, -0.07562017f, -0.09647714f, 0.04384159f, -0.14548030f, 0.27160585f, 
    -0.04378955f, 0.00351283f, -0.12406406f, 0.03501540f, 0.22712605f, 0.02052089f, -0.16797195f, 0.02208405f, 
    0.02112419f, 0.11230274f, -0.04723021f, -0.05327927f, 0.11450446f, -0.15729050f, 0.22686242f, 0.04061127f, 
    0.12872095f, 0.04517080f, 0.40305007f, 0.08442152f, 0.14092930f, 0.16602471f, -0.08996286f, -0.01164766f, 
    -0.05183252f, 0.18839864f, -0.05964217f, 0.10893952f, -0.49102280f, 0.30016437f, -0.06414564f, 0.16306904f, 
    -0.13843431f, -0.27558425f, 0.02695192f, -0.19096820f, -0.17397659f, -0.12763207f, -0.30506337f, -0.01673204f, 
    -0.51211292f, -0.05213696f, -0.23218313f, 0.10161871f, -0.09036213f, -0.16086906f, 0.01760524f, 0.04576176f, 
    -0.07761338f, -0.12439860f, 0.03746533f, -0.15708092f, -0.40685928f, 0.52410603f, 0.23881428f, 0.20243217f, 
    0.24809913f, 0.08946652f, 0.08680794f, -0.05227687f, -0.19817609f, 0.04349307f, -0.23073293f, -0.27131957f, 
    -0.21753924f, 0.19506907f, -0.00180889f, -0.02540974f, -0.19941838f, -0.19907242f, 0.00342343f, 0.03799670f, 
    0.21479726f, -0.05749929f, -0.17086934f, -0.13149211f, 0.43458924f, 0.10887691f, 0.14372316f, -0.03579194f, 
    -0.17960170f, 0.08154962f, -0.09564655f, 0.17937529f, 0.08867638f, -0.15474990f, -0.04192261f, 0.31646013f, 
    0.20342194f, -0.22462519f, 0.00977251f, -0.03844876f, 0.00277860f, -0.05300869f, 0.06281028f, 0.14145367f, 
    0.06768913f, 0.17928255f, 0.10947704f, -0.11973158f, -0.31886268f, -0.12433586f, -0.29338652f, -0.26030383f, 
    -0.06657454f, -0.04581429f, -0.01241968f, -0.13572282f, 0.03921258f, -0.05349496f, -0.01607339f, -0.00542924f, 
    -0.08015408f, 0.17604376f, -0.12142746f, -0.47440124f, -0.11385537f, -0.08125029f, 0.02031686f, 0.00774743f, 
    -0.08743352f, -0.25618798f, -0.04035107f, 0.05431407f, 0.22556043f, -0.79723001f, -0.35283419f, 0.57548827f, 
    0.02893646f, -0.05339333f, -0.06934772f, -0.05267191f, 0.07218933f, -0.13304248f, -0.05275163f, -0.03097444f, 
    -0.40390614f, -1.01833582f, -0.54315889f, -0.34842211f, -0.14001985f, -0.13740312f, 0.03144957f, -0.03348848f, 
    -0.15799533f, 0.16459121f, 0.05415125f, 0.15819468f, -1.03831744f, -0.86976600f, 0.17190146f, 0.04668750f, 
    -0.13109547f, 0.11358983f, 0.20242931f, -0.05660682f, 0.01027934f, -0.27698171f, 0.27217957f, 0.03862637f, 
    -0.29263908f, -0.11442767f, 0.00385289f, 0.17570224f, -0.16672818f, 0.22524409f, 0.08674245f, 0.07230727f, 
    -0.08983651f, 0.04164615f, 0.02612142f, -0.02860878f, 0.57365608f, -0.31037733f, 0.12198352f, 0.11141638f, 
    0.09594115f, 0.09877945f, 0.24351633f, 0.28245589f, 0.18434381f, 0.10294537f, -0.15471227f, 0.06831996f, 
    -0.05568739f, 0.30885217f, -0.02460850f, -0.14342408f, -0.04339914f, -0.08081512f, 0.19591384f, -0.05782503f, 
    -0.05150908f, -0.12493341f, -0.25152057f, -0.05461175f, -0.48172781f, 0.26088434f, -0.12407564f, -0.24588902f, 
    -0.05541299f, 0.09138464f, 0.12567772f, -0.02288504f, 0.23192814f, -0.09032873f, -0.14639753f, -0.07309134f, 
    -1.21056163f, 0.14010438f, -0.14380582f, -0.17932777f, 0.06671444f, -0.03119952f, 0.02105503f, 0.00586801f, 
    -0.06982291f, 0.10384413f, -0.07248593f, 0.24513972f, 0.24456014f, -0.27465481f, -0.29120177f, 0.27282831f, 
    -0.43863946f, -0.24622306f, 0.18142922f, -0.16972609f, -0.13524742f, -0.17688480f, 0.06065955f, -0.07679493f, 
    -0.46974859f, -0.66392159f, 0.28990200f, -0.55107009f, -0.17657217f, 0.12431031f, -0.02489344f, -0.05396453f, 
    0.01445479f, -0.04994740f, -0.12999792f, -0.17247525f, -0.68683356f, -0.27084258f, 0.50778586f, 0.03927603f, 
    0.04512544f, 0.01958158f, -0.28130406f, -0.08490700f, 0.09835500f, 0.11791023f, -0.16428539f, 0.01847345f, 
    0.48907509f, 0.20890316f, 0.21425663f, 0.04856779f, -0.09741797f, -0.07390208f, 0.30565581f, 0.06695746f, 
    -0.04797724f, -0.11392273f, 0.09722314f, 0.04681067f, 0.23027478f, -0.09134910f, 0.17094052f, 0.12565087f, 
    -0.05502193f, -0.00169680f, 0.19278319f, 0.23777844f, 0.08672460f, -0.24047287f, 0.00162353f, 0.04830451f, 
    0.11907650f, 0.46182793f, 0.26140660f, -0.06472223f, -0.06006632f, -0.22911461f, -0.08497221f, 0.04649429f, 
    -0.18551734f, -0.11689796f, 0.18373342f, 0.13120209f, 0.42113572f, -0.17675930f, -0.08881959f, 0.16752768f, 
    0.03481460f, 0.00125342f, 0.03518302f, 0.06690729f, 0.03950846f, 0.01726109f, -0.11132319f, 0.02435441f, 
    -0.18915780f, -0.06504683f, 0.15069731f, 0.46400765f, 0.12479877f, -0.06349257f, 0.10569604f, 0.11859627f, 
    0.11297353f, 0.10321143f, 0.17480342f, -0.00518828f, -0.26129040f, 0.30824885f, 0.13508421f, -0.02221908f, 
    -0.13513237f, 0.05129469f, -0.15098304f, 0.11721371f, 0.07803763f, -0.24896069f, 0.06725414f, 0.05591851f, 
    0.00041935f, -0.29736149f, -0.22332373f, 0.01831586f, -0.16346279f, -0.01891984f, 0.01399760f, 0.13991150f, 
    -0.12347879f, 0.17260118f, -0.08113844f, -0.12365176f, 0.02945746f, 0.32650793f, 0.19664054f, 0.06876319f, 
    -0.01192984f, -0.16021322f, 0.06167644f, 0.15168792f, -0.01731844f, 0.14475438f, 0.16039358f, -0.31990203f, 
    -0.57382262f, 0.02116773f, -0.17051922f, 0.45898682f, -0.01811227f, -0.04283395f, 0.03251385f, -0.31049633f, 
    0.13068952f, -0.10206695f, 0.16543591f, 0.04433259f, 0.23561205f, -0.17183693f, 0.01082070f, -0.00745519f, 
    -0.15727752f, 0.04610538f, 0.20063201f, -0.24434343f, -0.05819785f, 0.03364481f, 0.03630340f, -0.16164722f, 
    -0.83025640f, -0.39772630f, 0.11402275f, 0.21468994f, -0.25898847f, 0.06162597f, 0.00518333f, 0.04632273f, 
    0.22481741f, 0.11870788f, 0.17197883f, -0.03538486f, -1.32566476f, -0.12276206f, -0.10711298f, -0.11899371f, 
    0.19865510f, -0.03275471f, 0.03952089f, -0.19766849f, 0.10402235f, 0.17937021f, 0.09165078f, 0.21791847f, 
    -0.84769028f, 0.02117089f, -0.21139498f, -0.21245901f, 0.04896999f, -0.08013204f, 0.09334105f, 0.07467104f, 
    -0.07541764f, 0.06450429f, -0.12698512f, -0.15293352f, 0.28218779f, 0.24921118f, 0.35096014f, -0.17557950f, 
    0.03138243f, 0.29433656f, -0.13148297f, -0.07429057f, -0.06655297f, -0.02848649f, 0.14100476f, 0.01313554f, 
    0.02755097f, 0.14582114f, -0.19807337f, 0.04724647f, -0.11388361f, 0.04381340f, 0.17223635f, 0.20155160f, 
    0.04731972f, -0.04563271f, 0.13602622f, 0.00414802f, 0.29734334f, 0.05949626f, 0.27604344f, 0.06749742f, 
    -0.14526516f, -0.16521429f, -0.00625346f, 0.17497814f, -0.10702419f, -0.10059267f, 0.22206196f, 0.34482673f, 
    -0.27872223f, -0.34125218f, 0.12508778f, 0.40855947f, 0.10167364f, 0.17121580f, 0.03399070f, -0.13178986f, 
    0.02416093f, 0.21105179f, -0.20296010f, 0.29409698f, -0.31176081f, -0.34114799f, -0.05772821f, 0.38655746f, 
    0.18679605f, -0.08777946f, -0.11923975f, -0.06655903f, -0.03447747f, 0.10862520f, 0.22782122f, 0.10706155f, 
    -0.20967391f, 0.04700512f, 0.08226186f, 0.16259968f, 0.09882367f, -0.11721791f, -0.14390400f, -0.13319720f, 
    0.05203718f, 0.29771641f, -0.38228589f, 0.13248877f, 0.19102812f, 0.16998000f, 0.19918300f, -0.43083841f, 
    -0.05282067f, -0.18862793f, -0.03923634f, -0.22200727f, 0.09333859f, -0.04112586f, -0.19047254f, 0.20590891f, 
    -0.14307137f, -0.31877980f, -0.44859201f, -0.15213574f, 0.08020356f, 0.26265940f, -0.06332370f, -0.33873510f, 
    -0.05252599f, -0.35019928f, -0.00070823f, -0.18796842f, -0.20890988f, -0.06156657f, 0.07050712f, 0.33355004f, 
    -0.09594449f, 0.12023510f, 0.24943438f, 0.06669901f, -0.07845622f, -0.02663639f, -0.02198632f, 0.21289141f, 
    0.15537806f, -0.08656208f, 0.44211397f, 0.09409051f, 0.19999808f, 0.01820273f, -0.05383924f, -0.20817688f, 
    0.01733364f, -0.18875901f, -0.00628809f, -0.15888979f, 0.05167358f, -0.19290818f, 0.18342167f, -0.16431908f, 
    -0.25355852f, 0.13338180f, -0.18959413f, -0.14432552f, 0.10710172f, 0.18436027f, 0.13546169f, 0.18742655f, 
    0.29966465f, -0.02254640f, -0.21162304f, -0.14335670f, -0.02900904f, 0.02238631f, -0.32021040f, -0.08122370f, 
    0.19765639f, 0.22751768f, -0.08241139f, -0.01192626f, 0.25358191f, 0.34374711f, 0.03395453f, 0.28013092f, 
    -0.30522361f, -0.04183986f, -0.09764862f, -0.38247165f, -0.24041644f, -0.11378738f, -0.08911493f, -0.33099955f, 
    0.01120223f, -0.13285798f, 0.04414445f, 0.29743111f, 0.15954532f, 0.06299514f, 0.02990105f, -0.01226304f, 
    -0.21867126f, 0.10860682f, -0.12686265f, 0.01850623f, -0.14240071f, -0.78210562f, 0.07917080f, -0.36930519f, 
    -0.10415313f, 0.04540069f, 0.09417022f, 0.01749768f, -0.17188533f, -0.01347611f, -0.25382623f, -0.19345026f, 
    0.62104344f, -0.46340084f, -0.10623346f, 0.00109276f, 0.08298050f, 0.04466031f, 0.07319441f, -0.04198797f, 
    0.14263764f, -0.05919360f, 0.32074603f, 0.13652731f, -0.50506437f, -0.27495745f, 0.24600945f, -0.07225146f, 
    0.09819923f, -0.03878222f, 0.14263257f, 0.04913044f, -0.09635914f, -0.26868516f, -0.08987889f, 0.07139115f, 
    -0.30835345f, 0.22397785f, -0.06915356f, 0.62494093f, 0.09666792f, 0.01694748f, -0.05638283f, -0.03497167f, 
    0.02771184f, -0.02959254f, -0.33012691f, -0.20940869f, 0.25140947f, 0.02208079f, -0.03201246f, -0.09520376f, 
    0.14261222f, 0.03620695f, 0.09510972f, 0.05089101f, 0.05036131f, 0.14796400f, 0.00860608f, -0.11067430f, 
    0.04690174f, -0.24028552f, -0.53696716f, -0.21388049f, -0.14414510f, -0.05082511f, 0.06809200f, -0.05752257f, 
    -0.01043742f, 0.02872785f, 0.07742307f, -0.24776463f, 0.15586737f, -0.15814656f, 0.03165243f, 0.14655319f, 
    -0.12549749f, -0.00940470f, -0.06536905f, -0.09852340f, -0.09146352f, -0.30411386f, -0.12078297f, -0.05343598f, 
    0.13954929f, 0.08924200f, -0.56535566f, 0.19130169f, 0.06791244f, -0.00206755f, -0.03296881f, -0.03144317f, 
    -0.11962653f, 0.10915837f, 0.41008911f, 0.10231167f, -0.62572712f, 0.16509449f, 0.29785290f, -0.25674659f, 
    -0.18150763f, 0.08972294f, 0.07678333f, 0.12228739f, -0.11241192f, -0.16403024f, 0.27289528f, 0.12823988f, 
    -0.07286979f, -0.16343327f, -0.36023882f, -0.14380203f, -0.29527953f, 0.11893695f, -0.31349605f, -0.29327589f, 
    -0.03018336f, 0.37792292f, -0.06278314f, 0.16585036f, 0.19245866f, 0.21157359f, 0.03777862f, -0.59466636f, 
    -0.10355611f, 0.10583418f, 0.07409277f, 0.14857462f, 0.07943548f, 0.13069512f, 0.03098956f, -0.04191636f, 
    -0.68395841f, 0.31444082f, 0.17925695f, 0.18655312f, -0.23130274f, -0.00792710f, 0.00355184f, 0.05609823f, 
    -0.11748569f, 0.21283257f, 0.05218020f, 0.12221602f, 0.24845368f, 0.20393440f, 0.30884251f, -0.62332225f, 
    0.11214151f, -0.09156495f, 0.13742103f, 0.05383644f, -0.00609250f, 0.04647693f, -0.35850590f, -0.14969349f, 
    -0.39411500f, -0.00888579f, -0.47941008f, -0.07339276f, 0.06015031f, -0.17094056f, 0.39044562f, 0.28345105f, 
    -0.01983433f, -0.15382555f, 0.00559104f, 0.14535899f, -0.30471426f, 0.15384112f, 0.18349987f, 0.16956314f, 
    0.23862110f, 0.11746097f, 0.04569080f, 0.21366426f, 0.05579992f, 0.21064146f, 0.19163445f, 0.13748360f, 
    0.01261849f, -0.13444549f, 0.24986310f, 0.24647738f, 0.20993909f, -0.14418904f, -0.07231387f, 0.08084790f, 
    -0.05174205f, -0.01406086f, -0.03548377f, 0.06886361f, 0.02405801f, -0.05013773f, 0.04227087f, -0.07444996f, 
    -0.04674661f, 0.03637447f, -0.02744119f, -0.17668560f, -0.07599597f, -0.04501627f, -0.06564640f, -0.18872459f, 
    0.59859216f, -0.20325328f, 0.44694614f, -0.01118950f, -0.06095741f, 0.09185925f, 0.08224278f, -0.01330347f, 
    0.03078140f, 0.06361642f, -0.23432235f, 0.00763643f, 0.05893375f, -0.36894292f, 0.02015548f, 0.00465681f, 
    -0.11499920f, -0.03885642f, -0.20959333f, -0.14660007f, -0.11704884f, -0.10759199f, 0.09848836f, 0.06438135f, 
    -0.19496568f, -0.33456564f, -0.27192149f, -0.09852585f, 0.08556408f, -0.05304052f, -0.03828948f, 0.10656700f, 
    -0.02164848f, -0.12679410f, -0.06643286f, -0.10941056f, 0.20593326f, -0.68540162f, 0.23515141f, 0.08972166f, 
    -0.12006022f, -0.30799612f, -0.06869211f, -0.14209200f, 0.03712883f, 0.07710944f, -0.15089568f, -0.26600516f, 
    0.31061640f, 0.12520228f, 0.30177265f, 0.46859607f, 0.24244279f, 0.08652616f, -0.03905429f, -0.07926661f, 
    -0.26722717f, -0.20541778f, -0.07482176f, -0.16092172f, 0.25540870f, 0.21630600f, 0.05804809f, 0.34895471f, 
    0.07847048f, -0.22347237f, -0.02537683f, -0.12389138f, -0.01514123f, -0.11954864f, -0.36142066f, -0.26200297f, 
    -0.20590942f, 0.19016297f, -0.07839102f, 0.27487528f, 0.03285734f, -0.00523156f, -0.04070229f, 0.02436445f, 
    0.12185871f, -0.31517133f, -0.03059249f, -0.20539398f, -0.55758494f, 0.34793764f, 0.02405195f, -0.12530434f, 
    -0.09227663f, -0.00839161f, -0.23984320f, -0.17050655f, 0.03831564f, -0.07686034f, -0.04518469f, -0.21357363f, 
    -0.32865065f, 0.46633741f, 0.07229166f, 0.35219526f, 0.33238491f, 0.04929893f, 0.29359421f, 0.13205175f, 
    0.12297959f, -0.01294038f, 0.15195382f, -0.05849936f, -0.75472778f, 0.27638537f, -0.05501955f, -0.30752909f, 
    -0.02620693f, -0.14365189f, 0.03207508f, -0.21892773f, -0.17184198f, 0.21499351f, -0.08653068f, 0.09392928f, 
    0.01356387f, 0.27820152f, -0.06482140f, -0.16717748f, 0.14920808f, 0.00893495f, -0.03372158f, -0.13130863f, 
    -0.25781381f, -0.05741536f, 0.06981102f, -0.28470698f, 0.10753735f, -0.48897490f, -0.07422654f, 0.08356310f, 
    -0.22386003f, 0.08078026f, 0.11828047f, -0.23923594f, -0.02625576f, 0.08218692f, 0.04665830f, -0.15715802f, 
    0.22047709f, 0.36859792f, -0.08231085f, 0.32190222f, -0.02296065f, 0.24470821f, -0.11541338f, -0.06148663f, 
    0.03342827f, 0.10850721f, -0.00594864f, -0.09674708f, -0.02264286f, 0.36954826f, -0.26310915f, -0.11104772f, 
    -0.19947435f, 0.13610046f, -0.02750789f, -0.00205320f, -0.10891064f, 0.08829264f, 0.04799841f, -0.22049901f, 
    -0.05018912f, 0.29220808f, -0.22395669f, 0.29715306f, -0.00308957f, 0.12123233f, -0.10784834f, -0.08927955f, 
    0.16434112f, -0.00225968f, -0.02842158f, -0.11766747f, -0.42200467f, -0.19591241f, 0.48497686f, 0.07827791f, 
    -0.21658142f, -0.07607023f, -0.01451503f, 0.07126831f, -0.17411754f, 0.07947930f, 0.12215885f, 0.05202318f, 
    -0.12599874f, -0.09420809f, -0.07756246f, -0.19596279f, 0.02255231f, 0.02842745f, 0.16765897f, -0.04560992f, 
    0.09490933f, -0.21285200f, -0.14010872f, 0.01945472f, 0.32407877f, 0.14367029f, 0.11023090f, 0.19565122f, 
    0.08479495f, 0.00038291f, -0.22778745f, -0.09157251f, 0.05815928f, 0.12950146f, -0.12963818f, -0.13276508f, 
    0.71240944f, 0.13340706f, -0.80032200f, -0.12175467f, 0.12058851f, 0.03335934f, -0.02841601f, -0.22558735f, 
    0.00965873f, 0.02153873f, 0.12837134f, 0.33541980f, -0.34102890f, -0.31175652f, -0.80372632f, -0.30698064f, 
    -0.18285590f, -0.02124807f, 0.04724824f, -0.19260108f, 0.10117465f, 0.07302801f, 0.04159176f, 0.30191085f, 
    -0.08148237f, -0.22318700f, 0.14285815f, -0.48502085f, 0.04974681f, -0.02185836f, 0.03092942f, -0.02432681f, 
    -0.03353043f, 0.07828753f, -0.13138905f, 0.25465056f, -0.16721161f, -0.06438611f, -0.01664331f, -0.67052978f, 
    -0.04349030f, -0.16126272f, 0.00101253f, 0.08962746f, 0.12062712f, 0.16574675f, 0.22597481f, -0.18105452f, 
    0.12901585f, -0.00051838f, -0.19918323f, -0.45031455f, 0.07548480f, -0.34308913f, -0.16729306f, 0.09706610f, 
    -0.25340381f, 0.20918503f, -0.39143759f, 0.20817225f, 0.56557059f, -0.09207844f, 0.08281939f, 0.17995401f, 
    0.20246674f, -0.13377871f, -0.00256003f, -0.10283338f, -0.01409675f, 0.08564041f, -0.04281165f, -0.03360586f, 
    -0.21410887f, 0.04905410f, 0.33887976f, 0.15096453f, -0.23783498f, 0.11819921f, -0.16982868f, -0.06600221f, 
    -0.08946863f, -0.34372377f, 0.04918008f, -0.13826911f, -0.22323030f, 0.09253767f, 0.14952345f, 0.30391842f, 
    0.23452555f, 0.15623885f, -0.08419073f, -0.04532462f, 0.14589533f, -0.08193025f, -0.17004813f, -0.09695514f, 
    0.41695908f, -0.07998195f, -0.15499550f, 0.09339861f, 0.04673733f, 0.02040520f, -0.26576203f, -0.11106743f, 
    -0.19676754f, 0.12054340f, -0.03483547f, -0.08351463f, 0.01409298f, -0.37760928f, 0.01093595f, 0.44092977f, 
    0.19550274f, -0.07063405f, -0.17155492f, -0.00182835f, 0.03456516f, 0.17510539f, 0.30174425f, 0.16660608f, 
    -0.34736413f, 0.54637724f, 0.03114058f, -0.07687699f, -0.41375816f, -0.03330543f, -0.26871106f, 0.00023861f, 
    0.00073090f, -0.05000193f, -0.07586078f, -0.24981247f, -0.28622496f, -0.06947944f, -0.40220308f, -0.15841937f, 
    0.04565145f, -0.30308551f, -0.31200352f, -0.06330775f, 0.06752189f, -0.04444216f, 0.14522937f, 0.06521836f, 
    0.64469337f, -1.09949422f, 0.13187952f, 0.10873947f, -0.01394665f, -0.12529874f, 0.14168675f, -0.05644206f, 
    -0.09696803f, -0.09821121f, 0.10520504f, 0.07740545f, 0.96043396f, -0.02189931f, -0.32412061f, 0.14918813f, 
    0.17942525f, -0.03177724f, 0.03359622f, -0.00737779f, 0.02583937f, -0.07817059f, 0.14024124f, -0.04241541f, 
    -0.16049229f, -0.06783196f, -0.18006340f, 0.23594140f, 0.09787467f, -0.00077430f, -0.08572421f, -0.00649941f, 
    -0.00235011f, 0.30930239f, -0.01432045f, -0.13011974f, 0.22568728f, -0.32989323f, -0.09726481f, 0.12423529f, 
    0.20318191f, -0.25750828f, -0.02322914f, -0.06504317f, -0.11577969f, -0.14685950f, 0.04289437f, -0.19149201f, 
    0.49237797f, -0.12850727f, 0.41771299f, 0.11618228f, 0.00809421f, -0.07642137f, -0.05744521f, 0.01598433f, 
    -0.01667394f, 0.22158764f, 0.12659480f, -0.01196020f, -0.15319487f, 0.07952458f, -0.10451118f, -0.48954329f, 
    -0.06498435f, -0.07838672f, 0.06563041f, -0.03925367f, 0.13385472f, 0.02571245f, 0.02863982f, -0.19501528f, 
    -0.07688119f, -0.55488259f, -0.40689018f, 0.25394091f, 0.17747308f, 0.16557395f, -0.21230344f, 0.18155792f, 
    -0.11329329f, -0.07221936f, 0.21591081f, -0.10150844f, -0.23130369f, -0.20836921f, 0.06241824f, -0.41435510f, 
    0.19242451f, -0.18771517f, -0.08145357f, -0.02515444f, 0.10053325f, -0.15440631f, -0.47603393f, -0.05746286f, 
    -0.15860474f, 0.08420788f, -0.07100715f, -0.02642864f, 0.02795811f, 0.25456935f, 0.10245564f, 0.08516475f, 
    0.18918458f, -0.17599864f, 0.09148156f, -0.18301307f, -0.68657559f, 0.30468091f, -0.27939174f, -0.15572774f, 
    0.04352747f, 0.15825921f, 0.19240944f, -0.10392535f, 0.02076032f, -0.06440832f, 0.22473656f, 0.09706625f, 
    -0.61682683f, -0.47962785f, 0.07304265f, -0.08102174f, 0.13762870f, 0.01321715f, 0.10712928f, 0.20402679f, 
    0.13593332f, 0.07382359f, 0.10247952f, 0.14778352f, -0.33607444f, 0.46568674f, -0.39285818f, -0.89980209f, 
    0.24535054f, -0.09623568f, -0.12034518f, 0.08249218f, -0.20605806f, -0.00558540f, 0.07756880f, -0.11202819f, 
    -0.05901608f, 0.33475050f, -0.00978613f, -0.08885864f, 0.14198472f, 0.20004077f, -0.17825095f, -0.15231529f, 
    0.11211626f, 0.02224736f, 0.02251362f, 0.24022548f, -0.05816049f, -0.26471233f, -0.12578575f, -0.27751732f, 
    0.16115984f, -0.03166048f, -0.10084441f, -0.00075224f, -0.10369064f, -0.29073563f, -0.07889801f, -0.11367302f, 
    0.19798063f, 0.64699543f, 0.24532279f, 0.45449397f, 0.02595453f, 0.12015937f, -0.08389103f, 0.36765638f, 
    -0.04733365f, -0.03734282f, 0.01400734f, 0.03437560f, -0.28012788f, -0.07854654f, 0.13073985f, 0.02483826f, 
    -0.04970979f, -0.09749305f, 0.11504091f, 0.25811732f, -0.01700198f, 0.06240934f, -0.09052575f, 0.15141821f, 
    -0.41353866f, -0.02422508f, -0.31251934f, 0.18627402f, -0.16375872f, -0.05505185f, -0.08666212f, -0.14369752f, 
    0.05847253f, 0.18992995f, 0.13218434f, -0.01377150f, 0.14315857f, 0.05071595f, 0.05534944f, 0.09757926f, 
    -0.08451681f, -0.18864647f, 0.10384038f, 0.24850126f, -0.04687297f, 0.10261490f, 0.10354811f, 0.02163201f, 
    0.39505899f, 0.09753536f, -0.17683896f, -0.03978803f, -0.14680193f, 0.05330092f, -0.04632778f, -0.02071455f, 
    0.02968885f, -0.24637721f, -0.19153608f, -0.08046982f, 0.35365129f, 0.03440630f, -0.07285623f, 0.03038237f, 
    0.04023223f, 0.06202245f, 0.09177103f, 0.15501015f, 0.07856710f, 0.41234377f, 0.20907007f, 0.15303373f, 
    -0.90665090f, -0.11959077f, 0.17906161f, 0.33402312f, 0.31937897f, 0.00255350f, 0.00796889f, -0.03382943f, 
    0.00679066f, 0.13838471f, -0.05830099f, 0.22153926f, 0.33236620f, 0.30853188f, 0.02105331f, 0.02318583f, 
    0.10067856f, 0.33454308f, 0.18171643f, 0.13200334f, 0.04282237f, -0.00332972f, 0.20523018f, 0.31515044f, 
    0.07523694f, 0.02919152f, 0.26184884f, -0.42123574f, 0.20786226f, 0.09822114f, 0.04241279f, -0.26575091f, 
    -0.16251278f, -0.10377390f, 0.12279414f, 0.32610694f, 0.39647606f, 0.13474447f, -0.26727194f, 0.01094425f, 
    0.13534683f, 0.24901102f, 0.15051048f, 0.08770137f, -0.11124021f, 0.36529660f, 0.19163848f, -0.21209551f, 
    0.01407317f, -0.08337740f, 0.34082007f, 0.02509687f, 0.12485188f, 0.05369192f, -0.02055224f, -0.06750987f, 
    0.13873169f, -0.14396571f, -0.15676092f, 0.37358734f, -0.51586258f, -0.48169720f, -0.49148864f, -0.23338826f, 
    0.02849950f, -0.03909702f, 0.06671312f, -0.16755624f, -0.06971736f, -0.16174887f, -0.04064539f, -0.00478254f, 
    0.29234192f, 0.19283757f, 0.03706065f, 0.11441638f, -0.24612072f, -0.22359169f, -0.01336319f, -0.04814156f, 
    0.15680349f, -0.12349076f, -0.00723571f, -0.15285230f, -0.71017236f, -0.34556168f, -0.22377646f, -0.57183665f, 
    0.16542548f, 0.03410919f, -0.02609657f, -0.08769226f, 0.01676447f, 0.05946205f, 0.07137299f, 0.05282450f, 
    -0.85738546f, -0.15078121f, -0.07030296f, -0.01123374f, 0.05788188f, 0.04191455f, -0.13802749f, -0.15288045f, 
    0.02386259f, -0.20936027f, 0.04087840f, 0.13344158f, -1.39491236f, 0.07097688f, -0.39114356f, -0.33912793f, 
    0.06524428f, -0.04885121f, -0.28725478f, -0.04495546f, -0.04207310f, 0.12816148f, 0.01294300f, 0.03295940f, 
    -0.02389113f, -0.31846842f, 0.12491897f, 0.03096531f, -0.13815887f, -0.01540950f, -0.00684613f, -0.02853082f, 
    0.08191784f, 0.00886494f, -0.12680833f, -0.17362435f, -1.13459170f, -0.62122613f, -0.06041791f, -0.31799904f, 
    0.19085954f, -0.01587853f, -0.28290921f, -0.21155454f, -0.01020628f, -0.45207071f, -0.10098527f, 0.07874350f, 
    -0.47229266f, 0.06928945f, -0.06921735f, -0.01078176f, -0.04429044f, 0.08768539f, -0.21322702f, 0.12271153f, 
    -0.24012868f, 0.15462407f, 0.21849619f, -0.00097019f, 0.19068803f, 0.05774898f, 0.26819861f, -0.15217753f, 
    0.21824719f, 0.03015351f, -0.23953941f, 0.24109973f, -0.13704082f, -0.23770873f, 0.00429356f, 0.07515649f, 
    -0.65618384f, 0.02533637f, 0.00708788f, 0.25979283f, 0.00814272f, 0.05270271f, 0.22593561f, -0.21290448f, 
    -0.01586932f, 0.00113758f, 0.26699814f, -0.07088543f, -0.74659777f, 0.37098089f, -0.18011305f, -0.21180066f, 
    -0.12259826f, 0.00555728f, -0.04816255f, 0.17873769f, -0.10891474f, -0.13987666f, 0.07280737f, -0.30527112f, 
    0.98798692f, -0.08397364f, 0.14207710f, 0.20015416f, -0.00227659f, -0.32993728f, -0.08142239f, 0.12770033f, 
    0.29331458f, 0.10484821f, 0.12665594f, 0.10525817f, 0.30942342f, 0.02903324f, -0.47268680f, 0.18527971f, 
    0.05003355f, -0.08765317f, 0.13413206f, 0.16489787f, -0.12056641f, -0.09523243f, 0.10513742f, 0.05160571f, 
    -0.16578537f, 0.19986810f, -0.03227447f, 0.16875254f, -0.19743568f, -0.25312355f, -0.08663025f, -0.02402239f, 
    -0.07860544f, -0.26850915f, 0.09533588f, -0.12914060f, 0.16733219f, -0.01462896f, -0.25343755f, 0.31768078f, 
    -0.21020497f, 0.09555450f, -0.22763398f, -0.00705539f, 0.18997210f, -0.16891642f, -0.17474920f, -0.11796282f, 
    0.29141983f, -0.53004986f, 0.21278599f, -0.33030394f, -0.05233235f, -0.04067316f, -0.12320146f, -0.01163717f, 
    0.01990518f, -0.14803323f, -0.20231570f, -0.20601405f, -0.90301245f, -0.42357150f, -0.01479847f, -0.40736157f, 
    0.25970504f, 0.08070427f, 0.02328492f, 0.19366245f, -0.04366702f, 0.03318080f, -0.03635244f, -0.05088652f, 
    0.30615488f, -0.35511974f, -0.04442381f, 0.03257478f, -0.21005282f, -0.19106084f, 0.01798275f, 0.08510364f, 
    0.08063902f, -0.11522292f, -0.30213669f, -0.06482511f, 0.73573905f, -0.41180587f, -0.28072521f, -0.05332671f, 
    0.10628728f, -0.22272886f, -0.09185313f, -0.15807192f, 0.02594637f, 0.20480286f, 0.01709427f, 0.02446718f, 
    0.16360557f, -0.00364026f, -0.28513315f, -0.14459695f, -0.06753738f, -0.00372295f, -0.05566204f, 0.21892379f, 
    0.35163295f, -0.04661769f, 0.15123661f, -0.01861936f, 0.19899210f, -0.15693912f, -0.06050613f, -0.33943903f, 
    0.10030606f, -0.14166543f, -0.00636085f, 0.08578619f, 0.10770430f, -0.17574872f, -0.15489686f, -0.05604937f, 
    -0.09957757f, -0.33115071f, -0.24500747f, 0.15823139f, 0.00809316f, -0.14479490f, -0.13356327f, -0.22908480f, 
    -0.11951575f, 0.04370610f, -0.19349171f, -0.09746584f, -0.25313541f, 0.42985874f, -0.16834371f, 0.12836461f, 
    0.26200330f, 0.07421160f, 0.20115440f, -0.18681358f, 0.29029068f, 0.24450433f, 0.14541321f, 0.09670168f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22632805f, 0.00928353f, -0.05233008f, 0.07860171f, 0.05542899f, 0.07719699f, 0.08033469f, -0.14795601f, 
    -0.11963518f, 0.00715030f, 0.15043147f, 0.03998528f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
