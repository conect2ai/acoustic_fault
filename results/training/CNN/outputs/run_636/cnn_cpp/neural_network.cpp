#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.71012497f, 0.89518005f, 0.63377202f, -0.61024308f, -0.57927454f, 0.56184888f, -0.31261605f, -0.55917484f, 
    0.10932709f, -0.47780180f, 0.32048371f, -0.24688976f, 0.27750492f, 0.17719667f, 0.19720070f, -0.23297340f, 
    -0.42110696f, -0.20554709f, -0.22640696f, -0.01979041f, 0.03652981f, 0.10482500f, -0.10147063f, 0.15073675f, 
    -0.18340778f, 0.96228480f, 0.58003688f, 0.19035274f, -0.38173023f, 0.47638422f, 0.20442083f, -0.52274990f, 
    0.35603625f, 0.34459436f, 0.52529025f, -0.18546608f, 0.21245119f, -0.17649311f, -0.35736418f, -0.20942545f, 
    -0.00836672f, 0.14277196f, -0.17644012f, -0.01762528f, -0.13196363f, -0.05921640f, -0.02094366f, 0.16911818f, 
    0.11309259f, -0.11253619f, -1.09018099f, -0.14903887f, -0.75159556f, 0.44438082f, 0.36264467f, 0.42205369f, 
    0.93083358f, -0.05201756f, -0.24910589f, -0.23915918f, 0.04486705f, -0.18342677f, 0.33621061f, -0.42330569f, 
    0.29090333f, -0.45060223f, 0.04982968f, 0.19760622f, 0.17873892f, -0.14642830f, 0.12851541f, -0.21045466f, 
    -0.19189897f, -0.19720648f, -0.29992628f, 0.96186733f, 0.57856691f, 0.42406082f, 1.02867472f, 0.76566243f, 
    0.28216276f, -0.11122767f, -0.31229004f, 0.11225344f, -0.24784483f, -0.09602901f, 0.28566977f, -0.11884637f, 
    0.08028468f, -0.18836243f, 0.34232435f, 0.19833045f, 0.26067460f, -0.05524997f, -0.04611153f, -0.00897738f, 
    0.29239398f, 0.14965859f, 0.10777906f, 0.34899247f, -0.06232685f, 0.47147876f, 0.66061974f, 0.35808018f, 
    0.37491468f, 0.38420001f, 0.45241240f, 0.06256527f, 0.29976174f, 0.20514460f, 0.04792903f, 0.04623116f, 
    -0.03812999f, -0.46837804f, -0.39906287f, -0.25314966f, -0.01352139f, -0.09673774f, -0.31537145f, 0.13819329f, 
    0.11913043f, 0.34372735f, -0.35779276f, 0.49917623f, -0.18759920f, -0.27838594f, -0.80155522f, -0.73663861f, 
    -0.25794330f, 0.42423660f, -0.24298915f, 0.71174252f, 0.40616271f, -0.09408994f, -0.06155618f, -0.02360491f, 
    0.07838778f, -0.06548009f, -0.23105000f, -0.35345429f, -0.11232997f, 0.32561183f, 0.42010364f, 0.28327867f, 
    0.04515998f, -0.03790906f, 0.01488036f, -0.25098279f, 0.03103069f, -0.24035203f, -0.46294802f, 0.19268140f, 
    -0.69913059f, 0.11563415f, -0.77879757f, 0.79653150f, 0.78310305f, -0.10172880f, 0.05212441f, 0.06516908f, 
    -0.36260098f, -0.21449684f, -0.10906386f, 0.09017024f, -0.22364773f, -0.04217953f, -0.23085833f, 0.11410018f, 
    -0.26883730f, -0.00341257f, 0.20742820f, 0.00469518f, 0.10164994f, -0.11269326f, 0.21791995f, 0.62473905f, 
    -0.09332788f, 0.15071094f, 0.38732925f, -0.40788561f, 0.46318036f, 0.59024894f, 0.76162893f, 0.22374074f, 
    0.40874410f, 0.09317186f, -0.34686652f, -0.37843540f, -0.23758146f, -0.42826602f, 0.13930605f, 0.30108985f, 
    -0.33267525f, 0.24683310f, -0.26105815f, -0.16501062f, -0.34051174f, -0.20491199f, -0.16260555f, -0.21518210f, 
    -0.21734585f, -1.08068764f, 0.09015942f, 1.01999390f, 0.19250883f, -0.28800878f, 0.65736330f, 0.70259744f, 
    -0.08723615f, 0.29752541f, 0.18282242f, 0.16484991f, -0.06042205f, -0.36379549f, -0.23892045f, -0.43256751f, 
    0.02427378f, -0.45097184f, 0.08250427f, -0.12483969f, -0.08489807f, 0.27723315f, 0.25091457f, 0.09693991f, 
    -0.07197092f, 0.11074231f, 0.87374413f, -0.58295739f, -0.59713358f, 0.54305267f, 0.24482864f, -0.74010199f, 
    -0.50173742f, -0.37917158f, -0.34149697f, 0.50181764f, -0.21054360f, -0.17257325f, -0.14676337f, -0.20817469f, 
    -0.12439506f, -0.16696614f, -0.05769286f, -0.37075806f, -0.25536427f, -0.08966059f, -0.11788385f, 0.22734162f, 
    0.13608938f, 0.06210907f, 0.74026358f, 0.40972885f, 0.49857593f, 0.71202409f, -0.04471232f, -0.45579889f, 
    0.15819824f, -0.54714394f, 0.15415879f, 0.33054972f, -0.39225152f, 0.10391700f, -0.03049836f, 0.14794901f, 
    -0.19709194f, -0.44444445f, -0.23747511f, -0.02310145f, 0.07565603f, 0.13725486f, 0.03289028f, 0.02687378f, 
    -0.34667981f, -0.28953350f, -0.05446747f, 0.89950562f, 0.59700620f, 0.43416256f, 1.03625965f, 0.34570447f, 
    0.45952299f, 0.14222327f, -0.56850541f, -0.18089721f, -0.23435098f, 0.18151021f, -0.04310992f, -0.21359201f, 
    -0.13555096f, -0.22606358f, -0.01335059f, -0.02815777f, 0.23933549f, -0.11184736f, 0.00305891f, -0.15420996f, 
    0.19589660f, -0.02571749f, 0.14650555f, 0.45520800f, -0.14692190f, -0.56171870f, -0.43546045f, -0.43622580f, 
    -0.65421182f, 0.08650777f, -0.50976002f, -0.27537400f, -0.23180731f, 0.06809582f, 0.47725931f, 0.16637164f, 
    -0.25095183f, 0.15385431f, -0.29852155f, -0.09694282f, 0.27730542f, -0.10470629f, -0.22207715f, 0.63781786f, 
    -0.18839233f, 0.00736849f, 0.19447221f, 0.32495630f, -0.03426141f, 0.00986774f, 0.70475268f, -0.50448692f, 
    -0.43255538f, -0.35824874f, 0.77050692f, -0.36071396f, -0.36679214f, 0.24018398f, 0.33518878f, 0.42060709f, 
    -0.08889090f, -0.38210949f, -0.12998329f, 0.25557670f, 0.04168272f, -0.29766971f, 0.02969667f, -0.18046826f, 
    0.23355488f, 0.05602773f, 0.03382482f, -0.24648198f, 0.20607719f, -0.09128121f, 0.22571975f, 1.02236795f, 
    -0.60124946f, -0.25909653f, 0.39338446f, 0.20664215f, -0.65539658f, -0.52999675f, -0.31728926f, 0.11264630f, 
    0.02489822f, 0.03212075f, 0.31340137f, 0.50935894f, -0.29378241f, 0.13369365f, -0.08048237f, 0.03390569f, 
    -0.02800232f, 0.33694547f, -0.24412324f, 0.32602584f, -0.08120158f, -0.30806908f, -0.19269896f, 0.74403107f, 
    0.05570893f, -0.73186070f, 0.35685977f, -0.17664570f, 0.09393189f, 0.65316707f, -0.06045772f, 0.28091562f, 
    0.48346871f, 0.14107193f, 0.22491895f, -0.05563768f, -0.39022589f, 0.23819901f, -0.11501767f, -0.42595425f, 
    0.22757922f, -0.24944064f, 0.22825094f, 0.29645833f, -0.14512068f, 0.35696176f, 0.02030943f, -0.00226942f, 
    0.80587107f, 0.79668826f, 0.62835544f, 0.46012178f, 0.38395149f, -0.14104813f, 0.18147513f, 0.12182470f, 
    -0.37676269f, 0.12494155f, -0.07605343f, -0.09468808f, -0.13450502f, 0.19393243f, 0.21896727f, 0.01663961f, 
    0.22740513f, 0.25013110f, 0.15167858f, -0.02336224f, 0.21429588f, -0.28943372f, -0.34542114f, 0.37761685f, 
    0.25713018f, 0.05970919f, -0.32750103f, -0.13467476f, 0.00665551f, 0.64490479f, 0.20199931f, -0.65017277f, 
    -0.65720809f, -0.31095949f, 0.06800667f, 0.28923923f, 0.41750652f, 0.09994565f, -0.00160247f, 0.19181532f, 
    0.23367277f, 0.39416969f, 0.28295639f, 0.40796724f, 0.35013539f, -0.32576549f, 0.29667640f, -0.05889207f, 
    -0.13148250f, -0.18729356f, -0.33094907f, -0.91311902f, -0.07040981f, 0.84464741f, 0.23569670f, 0.12677002f, 
    0.93796325f, -0.45654178f, 0.70242703f, 0.40789780f, -0.04879934f, 0.21510509f, -0.35600385f, 0.34518927f, 
    0.01564882f, 0.04138889f, 0.27609113f, 0.06077046f, -0.06149355f, 0.04810224f, 0.07497419f, 0.35503405f, 
    0.16879213f, -0.25302908f, -0.00007665f, 0.40356836f, 0.02608707f, 0.62224746f, 0.17179370f, 0.41469705f, 
    -0.28250211f, 0.21103048f, 0.20158932f, 0.20246993f, 0.43143204f, 0.05645337f, 0.20402393f, 0.33932477f, 
    0.19742234f, 0.25420743f, -0.37373257f, -0.41738409f, 0.03112734f, 0.01129269f, 0.22356440f, 0.18012217f, 
    -0.71532476f, 0.09886416f, 0.43718007f, -0.21851711f, -0.09416991f, -0.36583072f, -0.41982660f, -0.65160936f, 
    -0.31317529f, 0.06854359f, -0.27643108f, -0.26454088f, -0.52667856f, -0.55330348f, -0.22288546f, 0.07474346f, 
    0.21275082f, 0.36832163f, -0.13230421f, 0.23469007f, 0.32662103f, -0.20717835f, -0.03954860f, 0.32754239f, 
    -0.06877139f, -0.13674554f, -0.10579576f, 0.44674602f, -0.40932894f, 1.05621016f, 0.56727338f, -0.38763133f, 
    -0.53621423f, -0.34454513f, -0.18781888f, 0.54078752f, -0.55621690f, 0.06002579f, 0.39722008f, 0.22793008f, 
    -0.11894970f, -0.33283582f, -0.16677676f, 0.07228983f, 0.16604048f, 0.05014572f, -0.29814425f, -0.04170917f, 
    0.06617854f, -0.31418228f, -0.00533923f, -0.07099281f, -0.06709179f, -0.23097906f, -0.69368833f, -0.45554307f, 
    -0.31315422f, -0.31194270f, -0.36228454f, 0.45313939f, 0.86840874f, 0.22153667f, 0.02086236f, 0.51612151f, 
    -0.16503827f, -0.00238560f, 0.03066197f, -0.43531209f, 0.14255989f, -0.01921473f, 0.15094396f, 0.08120105f, 
    0.11641378f, -0.29220504f, -0.09370057f, -0.21483210f, 0.08465116f, -0.05874136f, 0.13216092f, 0.58769053f, 
    -0.17232895f, -0.38178700f, 1.00744402f, 0.73300612f, 0.33977702f, 0.33133659f, 0.40900889f, 0.05878271f, 
    -0.27265123f, -0.57141352f, -0.24047467f, -0.16317056f, 0.18605484f, -0.17210020f, -0.48685429f, -0.09637850f, 
    0.28387249f, 0.34754097f, 0.06890624f, 0.03047575f, -0.31683937f, -0.42617041f, 0.02313348f, -0.32107192f, 
    -0.63458222f, -0.18206914f, -0.30628306f, -0.38913429f, -0.22490555f, 0.41878349f, 0.86004114f, -0.22121976f, 
    0.59776121f, 0.60899204f, -0.08775069f, -0.07969332f, 0.19842228f, 0.31058475f, 0.17185512f, -0.44126970f, 
    -0.01206202f, 0.08358784f, 0.05626941f, -0.29713103f, 0.10795940f, -0.22372904f, -0.00476621f, 0.14548035f, 
    0.15324804f, 0.14102182f, -0.09277705f, 0.73259747f, -0.62638205f, -0.28473786f, 0.47817457f, -0.76824456f, 
    0.28591880f, 0.45516342f, 0.48047802f, 0.19849476f, -0.17829731f, -0.42823905f, 0.19942510f, 0.14736633f, 
    0.08769975f, 0.32333082f, -0.08459816f, -0.13679281f, 0.02823994f, -0.14551629f, 0.31433073f, 0.50620031f, 
    0.17357185f, 0.36546245f, 1.00923800f, 0.05410928f, -0.75764465f, -0.66991764f, -0.01350761f, 0.18957092f, 
    0.47318771f, 0.46614897f, 0.27868879f, -0.35283813f, -0.22394313f, -0.26456174f, -0.26083922f, 0.09384689f, 
    0.07436629f, 0.11004849f, -0.05494773f, -0.00055338f, -0.31327102f, -0.00847716f, 0.19138700f, 0.44777682f, 
    -0.30769449f, 0.45235011f, -0.40955579f, -0.63835514f, -0.78177518f, -0.85377657f, -0.33940214f, 0.05962771f, 
    0.03734066f, 0.02418812f, 0.37647989f, 0.28117070f, 0.34978804f, 0.34087321f, -0.24772580f, 0.11040555f, 
    -0.05624454f, 0.22985545f, -0.03112969f, 0.36076996f, 0.00841557f, -0.06915308f, -0.12365409f, 0.05913443f, 
    -0.19192463f, -0.14120105f, 0.17031202f, -0.04625869f, -0.40505266f, 0.05890029f, 0.32534236f, -0.22048178f, 
    0.00636651f, -0.67996091f, 0.13360448f, -0.12791851f, -0.62379062f, 0.17055331f, -0.25496289f, 0.18117428f, 
    -0.54144078f, 0.01954583f, -0.22846766f, -0.01379131f, -0.51929551f, 0.18069252f, -0.37807578f, -0.33496854f, 
    -0.15159546f, -0.08022159f, 0.26411584f, 0.39392889f, -0.28205821f, 0.09231789f, -0.47140601f, 0.33826157f, 
    0.42299801f, -0.50145423f, -0.82771230f, -0.51620871f, -0.00397298f, -0.24225722f, 0.09098114f, -0.14210257f, 
    0.03552205f, -0.55692965f, -0.41791791f, -0.12420132f, -0.47413334f, -0.45321840f, 0.32246161f, -0.21003766f, 
    -0.01887888f, 0.26357961f, -0.23570523f, -0.18122458f, -0.20442289f, -0.08301044f, 0.92648387f, 0.21473415f, 
    0.71668279f, -0.20985259f, 0.10409015f, -0.14387666f, -0.74438715f, 0.18997374f, 0.19508918f, 0.19571970f, 
    0.40264165f, 0.33157521f, -0.17463255f, -0.10851980f, 0.20569849f, -0.18429922f, 0.07317689f, -0.09900480f, 
    0.00897206f, -0.05105337f, 0.11189343f, 0.23072012f, -0.02669911f, -0.00076434f, 0.10280676f, 0.19679372f, 
    0.33062646f, 0.28847224f, -0.65186584f, -0.48892927f, -0.43507665f, -0.30524194f, 0.02057199f, -0.26332256f, 
    -0.29823956f, -0.14142731f, 0.08551760f, -0.34370729f, -0.26273951f, -0.28437483f, -0.04051761f, 0.08884321f, 
    0.24772380f, -0.21234798f, -0.50650841f, 0.39020458f, 0.01210758f, 0.09072927f, 0.08787570f, -0.01374823f, 
    0.22825721f, -0.59214652f, -0.62049454f, -0.51436847f, 0.72492826f, 0.52270806f, 0.57430911f, -0.35758778f, 
    0.02006265f, -0.05290267f, 0.09147272f, -0.31160551f, -0.03245607f, 0.05626349f, 0.20653366f, -0.19162636f, 
    -0.42235091f, -0.03664420f, -0.42488703f, -0.16991211f, 0.16267940f, 0.10619988f, 0.11147781f, 0.05882224f, 
    -0.13143094f, -1.00681293f, 0.07239699f, -0.52844036f, 0.17737298f, 0.28991479f, 0.31489486f, 0.86593825f, 
    0.58648694f, 0.31201026f, -0.08445036f, 0.07434664f, -0.27096051f, 0.07212188f, -0.06512307f, 0.45226559f, 
    0.30038846f, -0.05190485f, -0.28160599f, -0.27978921f, -0.20378499f, 0.22107923f, 0.03505532f, 0.06517219f, 
    0.46196502f, 0.40494937f, 0.48119411f, 0.44659460f, 0.44057214f, -0.56958520f, -0.73585922f, 0.53742605f, 
    -0.15861598f, -0.20407766f, -0.43190366f, -0.06071446f, 0.27604464f, 0.56523317f, -0.18485217f, 0.37696701f, 
    0.27631953f, 0.06276292f, -0.26522788f, 0.24950993f, -0.14080517f, 0.54477572f, -0.06360434f, 0.17025879f, 
    0.05832214f, -0.21973687f, 0.35498971f, 0.51211452f, -0.01729903f, -0.62699348f, 0.65713519f, 0.63296419f, 
    -0.28123245f, -0.73542118f, -0.08527358f, 0.00177363f, 0.31366426f, -0.53590894f, -0.23336321f, -0.06500871f, 
    -0.21682261f, 0.33700469f, -0.03014813f, 0.02753963f, -0.44347474f, 0.18052150f, 0.03384523f, 0.38348809f, 
    0.15704241f, 0.26368099f, -0.31400636f, -0.07625995f, 0.98231953f, 0.67329955f, -0.22058046f, -0.14464815f, 
    -0.46187901f, -0.08599214f, 0.27341154f, -0.40665695f, 0.29217321f, 0.35708839f, 0.09734824f, -0.03708707f, 
    -0.03425108f, 0.11122679f, -0.14599840f, -0.12290081f, 0.10321296f, 0.19536164f, 0.00148195f, -0.33079791f, 
    -0.10272681f, 0.19879894f, 0.21902518f, 0.01792190f, 0.41080755f, -0.24809973f, 0.16551279f, 0.76176739f, 
    -0.20010157f, -1.02510238f, 0.06191929f, -0.59292781f, -0.33814654f, -0.58354717f, 0.34984785f, 0.36821139f, 
    0.39617828f, 0.35960293f, 0.04608521f, 0.06901939f, 0.42404249f, -0.02442085f, 0.30204597f, 0.16677161f, 
    -0.27702358f, 0.16242574f, 0.02698180f, 0.01828530f, 0.17026010f, -0.11776398f, -0.69190729f, -0.59869957f, 
    -0.38324723f, 0.38922042f, -0.03823248f, -0.17469186f, 0.40754259f, 0.14719568f, -0.28421375f, -0.35421860f, 
    0.14540532f, 0.49655101f, -0.21046782f, 0.26230472f, -0.10178043f, 0.11167387f, 0.13854718f, -0.51502895f, 
    -0.45074597f, -0.29697531f, -0.04216309f, -0.11741305f, 0.22437000f, 0.17502566f, -0.12737344f, 1.04107845f, 
    0.36033857f, 0.15364361f, -0.69708037f, -0.75062835f, -0.09214222f, -0.46991816f, 0.07269846f, -0.34724918f, 
    -0.00320238f, 0.16509978f, 0.32014897f, 0.37769169f, 0.09168073f, -0.32826167f, 0.10330798f, -0.02756458f, 
    0.13940561f, 0.07671358f, 0.43627682f, -0.00525438f, 0.23116578f, 0.07503881f, -0.00085445f, 0.28723577f, 
    -0.02399182f, -0.95780218f, -0.15846032f, 0.34720021f, 0.35910410f, -0.73648387f, 0.82528895f, -0.24121913f, 
    -0.60471672f, 0.02954149f, 0.26918811f, 0.24860929f, 0.20934203f, -0.32315290f, -0.10363294f, -0.32372692f, 
    0.16239813f, 0.36856577f, -0.07004570f, -0.54897946f, -0.00973355f, -0.21394461f, -0.06209326f, -0.16759951f, 
    0.05540592f, -0.30147621f, -0.10295682f, -0.39846393f, -0.18018787f, -0.15341660f, -0.38101491f, -0.65230864f, 
    -0.24490178f, 0.44330797f, -0.11936171f, -0.28511596f, -0.05009433f, -0.42943761f, 0.03973009f, -0.52158612f, 
    -0.02725809f, 0.36439821f, 0.08571512f, -0.39362898f, -0.36824107f, 0.28468353f, -0.08169212f, 0.29017237f, 
    0.39255759f, 0.12926069f, -1.18921721f, 0.42651710f, -0.13478211f, -0.62629777f, 0.14173768f, 0.21344182f, 
    -0.16908827f, -0.05669878f, 0.44021171f, 0.62920904f, -0.01314189f, 0.25347498f, 0.12243039f, -0.27790052f, 
    -0.15153340f, 0.27808213f, 0.21124446f, -0.01120113f, -0.00852743f, -0.20851931f, -0.26543623f, -0.14154662f, 
    0.00051922f, -0.14380749f, -0.27542368f, -0.52292174f, 0.62300885f, 0.44922557f, 0.12969476f, -0.25977492f, 
    -0.92627656f, -0.46188137f, -0.55353320f, -0.82922977f, -0.25936082f, 0.18074939f, 0.02677369f, 0.38355696f, 
    -0.09336569f, -0.26732424f, -0.21262562f, -0.52813274f, 0.10962727f, 0.24046394f, -0.23033145f, 0.20680727f, 
    0.18672986f, -0.12048566f, 0.24875417f, -0.16820495f, -0.25034165f, -0.44540492f, -0.02710944f, 0.79334080f, 
    -0.21519190f, 0.44973058f, -0.01179512f, 0.12032811f, -0.22503589f, -0.68295532f, -0.28452483f, -0.51387769f, 
    -0.40790349f, -0.03672284f, 0.09526865f, 0.25674745f, 0.32522035f, -0.13275328f, -0.00766535f, 0.24067365f, 
    0.29875925f, -0.14742957f, -0.11977590f, -0.02708510f, -0.46257824f, -0.51753622f, -0.47456169f, -0.58034480f, 
    0.36612710f, -0.18946667f, 0.63538527f, 0.39608318f, -0.02016041f, 0.86000115f, 0.20724829f, 0.22084613f, 
    0.17739709f, -0.19892061f, 0.16091770f, 0.32952452f, 0.14648655f, -0.09119806f, 0.03043112f, 0.06192921f, 
    0.28949162f, -0.21020325f, -0.30603638f, -0.28833830f, 0.25124937f, -0.26230675f, -0.74264491f, -0.33667916f, 
    -0.23216115f, -0.32626328f, -0.60049200f, 0.26028171f, 0.32547516f, -0.32405871f, -0.11739214f, 0.55685830f, 
    0.09670297f, -0.23334971f, -0.19524209f, -0.13885012f, -0.16450609f, -0.24660881f, -0.06689106f, -0.17609550f, 
    0.27153671f, 0.22497915f, 0.18097915f, 0.01909844f, 0.14953031f, -0.02753240f, -0.32536927f, -0.10650925f, 
    -0.05247545f, 0.24753003f, 0.37383935f, 0.22843297f, -1.04285884f, 0.37893534f, -0.23131205f, -0.63567644f, 
    -0.08201410f, 0.60860366f, -0.25933489f, -0.00509146f, 0.21704414f, 0.13915250f, 0.40061387f, 0.27710676f, 
    0.15634324f, 0.31078300f, -0.42685691f, 0.02670792f, -0.21166505f, -0.09085274f, 0.00820045f, 0.16803947f, 
    -0.29708913f, -0.64415026f, -0.35521254f, -0.30200997f, -0.66054326f, 0.23760822f, -0.11676102f, 0.33035547f, 
    0.28726992f, 0.13255683f, -0.15941995f, -0.37283584f, -0.06249198f, 0.21337813f, 0.05072444f, 0.16090360f, 
    0.01493242f, 0.02815047f, -0.03220804f, 0.21067908f, -0.28631654f, -0.26848906f, 0.20356883f, -0.38189465f, 
    0.40898004f, -0.22461848f, -0.39821810f, -0.29918903f, 0.27982610f, -0.55342036f, -0.11244159f, 0.37148565f, 
    -0.34737623f, -0.14733839f, 0.01917393f, -0.13486809f, 0.15344010f, -0.08210344f, 0.61782038f, -0.16635677f, 
    -0.29345974f, -0.15923020f, -0.28583884f, 0.40667006f, -0.34026903f, -0.20873512f, 0.07813554f, 0.13489801f, 
    -0.42519832f, 0.42562920f, -0.39700842f, -0.37310034f, -0.54611003f, -0.72598654f, -0.33484384f, -0.11647381f, 
    -0.41230056f, 0.08227552f, -0.08085749f, 0.23102356f, -0.33223033f, -0.06344835f, -0.00237730f, -0.13896722f, 
    -0.19858882f, 0.53473181f, 0.07862820f, 0.15304588f, 0.29192555f, 0.47283033f, -0.15253933f, 0.08993724f, 
    -0.13363992f, 0.03947293f, 0.11065333f, 0.64414728f, 0.58440638f, 0.48999321f, 0.64627630f, 0.18599848f, 
    0.49952349f, -0.07974808f, -0.16584352f, 0.11337809f, 0.16529144f, 0.31116739f, -0.15889359f, 0.00662259f, 
    0.15544766f, -0.31712872f, -0.07780191f, -0.39333877f, -0.04897655f, 0.00956898f, -0.39184546f, 0.24002033f, 
    -0.23642357f, 0.25019437f, 0.08703431f, 0.35719195f, -0.02603884f, -0.17945306f, -0.52590269f, -0.56420505f, 
    -0.58918506f, 0.08152279f, 0.35503197f, 0.12741266f, -0.59152412f, -0.17404898f, -0.34541258f, -0.04470327f, 
    -0.36436728f, -0.15495797f, 0.16225317f, 0.23556563f, 0.29775882f, 0.47048414f, 0.42178720f, -0.35750404f, 
    0.03896574f, -0.44064027f, -0.31234932f, -0.20223643f, -0.13172525f, 0.44360256f, 0.45506245f, 0.71415132f, 
    0.52101755f, 0.74341208f, -0.39992198f, -0.73327440f, -0.52700967f, 0.29568192f, -0.49346995f, 0.00655089f, 
    -0.06738424f, 0.25694746f, 0.26256856f, 0.10723814f, 0.09623216f, 0.37976104f, -0.07199642f, 0.11914188f, 
    0.28380349f, 0.41539192f, 0.17351609f, 0.08286983f, -0.16590570f, -0.23451906f, 0.91844356f, 0.50601608f, 
    0.63571072f, 0.25480026f, -0.19641526f, 0.19974603f, 0.06707016f, 0.07785066f, 0.12249608f, 0.11491201f, 
    -0.43951803f, 0.04343008f, -0.12322899f, 0.28089920f, -0.15991126f, 0.26735944f, 0.06328115f, -0.10019138f, 
    -0.15965089f, 0.09342463f, 0.00297129f, -0.41939366f, 0.19012372f, -0.04059009f, -0.18068035f, -0.82687992f, 
    -0.35159016f, 0.07473063f, 0.12848510f, 0.40650117f, -0.90345353f, -0.33673990f, -0.18207213f, -0.19610375f, 
    0.25626007f, 0.33059952f, 0.13565132f, 0.32120550f, 0.27468559f, -0.21895653f, -0.00471989f, 0.16448061f, 
    0.12739480f, 0.16822743f, 0.42641249f, 0.22348073f, -0.13286524f, 0.04419882f, -0.15272844f, -0.24691857f, 
    -0.34222153f, -0.10032514f, 0.32786795f, -0.29101890f, -0.46389520f, -0.14746325f, -0.57380396f, 0.35176569f, 
    0.46082050f, -0.23232765f, -0.46274346f, 0.28570262f, 0.40444982f, -0.22695144f, -0.16234833f, 0.28485954f, 
    0.23036487f, -0.22717842f, -0.03860365f, 0.30585998f, 0.07312370f, -0.39569205f, 0.00292899f, -0.18867177f, 
    0.11119722f, -0.74113035f, -0.66313738f, -0.36044949f, 0.11404268f, -0.02743240f, 0.31835705f, 0.03045457f, 
    0.47049326f, 0.06621101f, -0.67374986f, 0.42588267f, -0.41530892f, 0.20752037f, 0.09342337f, -0.03333352f, 
    -0.00654365f, 0.39094579f, -0.34241641f, -0.22220053f, 0.26930094f, -0.09313842f, -0.21238668f, 0.08570182f, 
    -0.43918940f, 0.09991587f, -0.06409256f, 0.49939230f, 0.87158960f, 0.67421126f, 0.21994589f, -0.55022001f, 
    -0.43948877f, -0.75809276f, -0.61682326f, -0.00577478f, 0.33068445f, 0.44804880f, -0.18156132f, -0.02871677f, 
    -0.02162692f, 0.09915368f, -0.40986899f, 0.07656659f, -0.23467609f, 0.14923148f, -0.00223192f, 0.26422530f, 
    0.23036233f, 0.18964376f, -0.05877121f, 0.35713178f, -0.70455861f, 0.18044300f, 0.51242089f, 0.34291193f, 
    -0.98246604f, 0.48207438f, 0.28618184f, -0.12906331f, -0.43518886f, 0.38825023f, 0.27426425f, -0.11699284f, 
    0.09617890f, 0.07485043f, -0.48018354f, 0.12400283f, -0.25527933f, -0.09151702f, -0.14825016f, -0.02475767f, 
    0.26761478f, 0.13824797f, 0.32550991f, 0.09048310f, -0.19744220f, -0.05208313f, -1.04614258f, -0.67500323f, 
    0.50976586f, -0.40900457f, 0.24035920f, 0.71076447f, -0.01583839f, 0.20733939f, -0.31571832f, -0.22507350f, 
    -0.11963940f, -0.20919165f, -0.17392094f, -0.15760665f, -0.07131182f, -0.09648960f, -0.01940248f, 0.10366231f, 
    -0.03835775f, 0.20398061f, -0.01343065f, 0.18773043f, 0.26949680f, -0.02968537f, -0.15688679f, -0.57017893f, 
    0.23705232f, -0.18184221f, -0.51027179f, -0.89069110f, -0.18716174f, 0.14689326f, -0.21372268f, 0.21359074f, 
    0.36323446f, 0.38563138f, 0.33380988f, -0.18965004f, 0.02988772f, -0.11740468f, 0.20512044f, 0.28534549f, 
    0.01586959f, -0.21397142f, 0.38901272f, -0.04449442f, 0.06769911f, 0.51479536f, -0.07845856f, -1.03356028f, 
    0.71447897f, -0.24123029f, -0.66863072f, 0.52739036f, -0.19026276f, 0.53288066f, -0.43314797f, 0.37762368f, 
    0.13838147f, -0.25841194f, -0.32881999f, -0.00941471f, -0.26329476f, 0.06916562f, -0.06782590f, 0.06050720f, 
    -0.14887722f, 0.00134906f, -0.07361010f, 0.09760082f, -0.11418425f, -0.15431522f, 0.12516482f, -0.03032606f, 
    0.48397589f, 0.54023200f, 0.31107700f, 0.76206291f, 0.20192374f, 0.65352499f, 0.73103809f, -0.64222342f, 
    0.14097615f, -0.14760387f, -0.41128182f, -0.00890635f, 0.00647645f, -0.27006319f, 0.04036681f, -0.16028371f, 
    -0.01816348f, 0.09037158f, -0.38110319f, 0.02241638f, -0.11256801f, 0.11249743f, -0.16507465f, -0.09187154f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04995118f, 0.19432078f, 0.06495290f, 0.29656214f, 0.14951137f, 0.18663386f, -0.03388571f, -0.06831916f, 
    0.08901614f, -0.00402220f, -0.03383461f, 0.29137591f, 0.22575846f, 0.10584604f, 0.05380088f, -0.03168369f, 
    0.00279170f, 0.25971320f, 0.08943966f, 0.05184751f, 0.22573233f, 0.23685828f, 0.02037091f, 0.15006739f, 
    -0.23459925f, 0.04401043f, 0.03434711f, 0.22071089f, 0.10466548f, 0.15497449f, 0.20346290f, 0.03165820f, 
    0.19637734f, 0.12687519f, 0.10228851f, 0.25223869f, 0.13967258f, 0.05985992f, 0.05996071f, 0.27415076f, 
    0.11959002f, 0.10638759f, 0.17116056f, 0.05783458f, -0.04717820f, 0.11007734f, 0.06994933f, 0.13174731f, 
    -0.13346851f, 0.28664505f, -0.11514069f, 0.21136026f, 0.06238960f, 0.01480697f, 0.35082480f, 0.29069397f, 
    0.13268319f, 0.13391927f, 0.21844709f, 0.21398653f, 0.28315014f, 0.03834097f, 0.14745551f, 0.09886396f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.30911732f, 0.12508297f, 0.01216139f, -0.18546079f, 0.08384780f, -0.09916753f, 0.02001070f, 0.01689911f, 
    0.22301373f, 0.04749750f, 0.17169197f, 0.14886798f, 0.05929222f, 0.24264932f, -0.11433513f, -0.04731882f, 
    -0.06775615f, 0.08205084f, 0.01927515f, 0.11027924f, -0.00574310f, 0.10465235f, 0.07146369f, 0.06769112f, 
    0.27238280f, -0.11467406f, -0.09013240f, 0.11668079f, -0.06701508f, -0.02278227f, 0.00628555f, -0.01667823f, 
    0.10724672f, 0.07806463f, -0.07122098f, 0.13269939f, 0.01537616f, 0.12171914f, -0.02037473f, 0.15913735f, 
    0.00462575f, -0.01113397f, -0.07360063f, 0.07630368f, -0.02021478f, -0.12088003f, -0.05248807f, -0.18495968f, 
    0.06300295f, -0.10597405f, -0.01821312f, 0.02957823f, -0.00243907f, -0.06408237f, 0.04021007f, 0.00618688f, 
    -0.07643633f, -0.05295584f, -0.09915700f, 0.00165610f, -0.43572953f, 0.06112591f, -0.00866221f, 0.02086959f, 
    -0.13874303f, 0.12756735f, 0.17208450f, 0.11430853f, -0.01159045f, 0.03857374f, -0.10820785f, 0.08196133f, 
    0.22726291f, -0.05729925f, 0.25123799f, -0.12293507f, 0.08967598f, 0.08765315f, -0.03924698f, -0.01868835f, 
    -0.04219552f, -0.07868038f, -0.00338586f, 0.14547524f, 0.01615248f, -0.11390901f, -0.07813618f, 0.20823349f, 
    -0.00696491f, 0.11660521f, 0.14415985f, 0.08948423f, 0.11076842f, 0.05113199f, 0.14942563f, 0.03469900f, 
    0.03249829f, 0.06445407f, 0.13444066f, 0.09176261f, 0.01464627f, 0.03077991f, -0.00226551f, 0.03714710f, 
    0.02965733f, -0.01473658f, 0.03904239f, 0.00006915f, 0.27369189f, 0.26033679f, 0.12384340f, -0.15803273f, 
    -0.02200760f, 0.02742338f, -0.06882817f, -0.06273896f, 0.06264113f, 0.07361229f, 0.14070760f, 0.01027045f, 
    -0.06852802f, 0.13507852f, -0.16378270f, 0.14610426f, 0.06526908f, 0.08498348f, 0.08192618f, -0.01474775f, 
    -0.01437117f, 0.11001862f, 0.04387354f, 0.15904674f, -0.02314627f, 0.08135886f, -0.08188538f, 0.22474273f, 
    0.08165278f, -0.02020286f, -0.01923191f, 0.09238581f, 0.01319425f, -0.04299526f, -0.03222951f, -0.05929808f, 
    -0.01887315f, -0.06034687f, -0.13794972f, -0.24150647f, -0.12450343f, 0.11344377f, 0.01489069f, 0.04478117f, 
    -0.08472147f, -0.07828523f, -0.01541709f, -0.07122310f, 0.12175265f, 0.35477403f, 0.17135714f, -0.06237186f, 
    -0.11402441f, 0.04414661f, 0.14364517f, -0.00151231f, -0.08312842f, -0.01989418f, 0.09027176f, -0.02060327f, 
    0.25035924f, 0.24636802f, 0.01438480f, -0.21429433f, 0.00570278f, 0.15466085f, -0.18121803f, 0.20925392f, 
    0.09575956f, 0.05215785f, -0.06876801f, -0.04508308f, -0.18482657f, 0.37842754f, -0.05741493f, 0.13267605f, 
    0.00169373f, 0.03755759f, 0.01872027f, -0.04514859f, 0.03415507f, 0.09077780f, 0.23199524f, -0.01290712f, 
    -0.00644392f, 0.01048594f, 0.02825816f, 0.12914927f, 0.03328316f, -0.14366558f, 0.02802300f, 0.08648517f, 
    -0.10776517f, -0.09287154f, 0.02740753f, -0.17230561f, 0.01340527f, 0.14887838f, 0.07345209f, 0.03339061f, 
    -0.07665969f, 0.16486873f, 0.04808287f, -0.00495550f, 0.05131100f, -0.02391953f, -0.13576926f, -0.09500320f, 
    -0.20128372f, -0.00389806f, 0.17631121f, 0.15885824f, -0.08376869f, 0.01966747f, -0.00410756f, -0.10967299f, 
    0.01555559f, 0.02428899f, -0.07895339f, 0.05706844f, -0.07966167f, -0.21240444f, -0.12754858f, 0.11910997f, 
    0.02589943f, 0.08696328f, -0.03732409f, 0.05398125f, 0.05598437f, -0.05159808f, 0.01971679f, 0.02494543f, 
    -0.15738216f, 0.03367788f, -0.00343116f, -0.04014175f, 0.06308766f, -0.04855582f, -0.04568180f, 0.06036449f, 
    -0.04810629f, -0.06323847f, -0.06227167f, -0.05222781f, -0.12272786f, 0.35602361f, 0.06524872f, 0.10622950f, 
    -0.00243196f, 0.10462689f, -0.03937466f, 0.13833536f, 0.02361470f, 0.01638841f, 0.14603430f, 0.00104249f, 
    0.08830563f, -0.18860811f, 0.12034184f, -0.07437182f, 0.00959121f, 0.05065214f, 0.03192579f, 0.05135354f, 
    0.01497927f, 0.04001104f, -0.07987087f, 0.06882823f, -0.07112161f, -0.10282134f, -0.17243397f, 0.15736760f, 
    0.02777898f, 0.00426653f, 0.19506875f, 0.09173703f, -0.03409275f, -0.02606237f, 0.10845318f, 0.17625809f, 
    0.12463909f, -0.09343486f, 0.22711971f, -0.00442752f, 0.00572997f, -0.03741965f, -0.16887131f, -0.03759163f, 
    0.02816884f, 0.06807688f, 0.00617142f, 0.29461804f, 0.28225678f, -0.13304646f, 0.01430390f, -0.25331700f, 
    -0.03008926f, 0.13178457f, -0.05358943f, -0.06796174f, -0.06136510f, -0.00230807f, -0.02489139f, 0.04398176f, 
    -0.11674441f, 0.33810687f, -0.00977356f, 0.09491526f, 0.07876101f, 0.07081770f, 0.04486707f, 0.11673070f, 
    -0.04952973f, -0.02306897f, -0.05666589f, 0.02516278f, -0.05595429f, -0.07362986f, 0.01628920f, -0.04181745f, 
    -0.09743749f, -0.07280760f, -0.01194169f, 0.04102258f, -0.01393288f, 0.03206531f, 0.03430436f, -0.01414513f, 
    -0.26021644f, -0.12588349f, -0.00122471f, 0.00125459f, 0.00577195f, 0.00770498f, -0.11061762f, -0.06194560f, 
    0.10388853f, 0.09775002f, 0.12605171f, 0.23087633f, 0.02415075f, -0.10621242f, 0.05653644f, -0.07537112f, 
    -0.03312670f, 0.01466464f, 0.05543342f, -0.04272393f, 0.09961867f, 0.16050754f, 0.05731502f, 0.09751987f, 
    0.34890628f, -0.04402772f, -0.09488913f, 0.02669516f, -0.04697321f, 0.06220837f, 0.10290041f, -0.02355847f, 
    -0.01089126f, 0.01850918f, -0.05150945f, -0.04881283f, -0.08649736f, -0.06167905f, -0.02615380f, -0.00922085f, 
    0.00479225f, 0.00621437f, -0.00287309f, -0.04678423f, -0.10044169f, 0.10631061f, -0.05139783f, 0.06430911f, 
    -0.25001124f, 0.14404312f, 0.10072111f, 0.16204162f, 0.05441437f, 0.05474316f, -0.08621836f, -0.07319016f, 
    0.00674776f, -0.00660444f, 0.07229188f, 0.06259722f, 0.16564794f, 0.07205092f, -0.08640510f, 0.13327348f, 
    -0.00178801f, -0.09248593f, -0.00868158f, 0.03812780f, -0.14762430f, 0.05959512f, -0.03252414f, -0.06505141f, 
    0.15147711f, 0.08502329f, 0.08909506f, -0.09969664f, 0.09762885f, -0.03090733f, 0.02783990f, 0.06114207f, 
    0.03743466f, -0.10938548f, 0.00644411f, -0.04876097f, 0.13465495f, 0.08415455f, 0.03106978f, 0.08984222f, 
    -0.01982733f, 0.11370423f, 0.04594556f, -0.11242429f, -0.11386623f, -0.05251596f, 0.09485155f, -0.01036054f, 
    0.10420737f, 0.02139491f, 0.08226353f, 0.18862039f, 0.14151439f, 0.04516803f, -0.05682440f, 0.00716893f, 
    0.09421321f, 0.10225930f, -0.06071445f, -0.01341702f, -0.02406857f, 0.09539183f, 0.00132861f, -0.14236154f, 
    0.08775438f, 0.06719897f, 0.00302387f, -0.03659173f, -0.07661959f, 0.04564690f, -0.06030238f, -0.04626946f, 
    -0.08055504f, 0.06925762f, 0.06630884f, 0.13569267f, -0.00800477f, 0.01687261f, -0.05674236f, 0.03282487f, 
    0.05471376f, 0.11531804f, 0.21934134f, -0.00448899f, 0.16786568f, 0.03659286f, -0.09628152f, -0.08941949f, 
    -0.02069581f, 0.14489520f, -0.05017408f, 0.01155195f, -0.05948215f, -0.00882175f, -0.14641336f, -0.02458316f, 
    -0.20950368f, -0.01912068f, -0.05009116f, 0.05176197f, -0.04676402f, -0.01620639f, 0.03229668f, 0.01459287f, 
    0.06595607f, 0.26235741f, -0.14098120f, 0.20003715f, -0.09087233f, -0.01175709f, 0.01137121f, -0.06629828f, 
    -0.11076457f, -0.12089107f, -0.09008022f, 0.08901541f, -0.12426288f, 0.16367084f, 0.00398907f, 0.13612595f, 
    0.21170504f, 0.00764413f, 0.00289206f, -0.03281737f, -0.01616702f, 0.00149500f, -0.02796660f, 0.13380721f, 
    -0.00392337f, 0.04218308f, -0.04276351f, 0.03399536f, -0.14621103f, 0.04131097f, 0.05479453f, -0.24452662f, 
    0.06740313f, 0.10899675f, -0.04600526f, 0.00330366f, 0.00438891f, 0.05612084f, -0.03944234f, 0.04086852f, 
    0.17512554f, -0.06453688f, -0.10965417f, -0.05866773f, 0.14357895f, 0.07616578f, 0.07565938f, -0.00182016f, 
    0.00051480f, -0.07422914f, 0.13780242f, 0.02840744f, -0.01885726f, -0.12997906f, -0.05370206f, 0.01187073f, 
    -0.05571424f, 0.09774090f, -0.00843863f, 0.03840024f, 0.05783102f, -0.06791063f, 0.15050219f, -0.11986260f, 
    0.01232811f, -0.07642985f, 0.06995066f, -0.41130170f, -0.09507759f, 0.09773590f, -0.09691387f, 0.01321424f, 
    0.05348073f, -0.09022258f, 0.09730486f, 0.02525069f, -0.20645548f, 0.02372849f, -0.00913069f, 0.09728672f, 
    -0.01822618f, -0.08733039f, 0.06298420f, -0.11423495f, 0.14757386f, 0.02589652f, 0.04338465f, -0.11309705f, 
    0.03978033f, -0.15769336f, 0.04093623f, -0.25664288f, -0.00154602f, -0.01483221f, 0.04644457f, 0.10661495f, 
    -0.06051713f, -0.02758473f, -0.03365831f, -0.10875923f, 0.01590786f, -0.01842333f, 0.22416881f, -0.06437995f, 
    0.03282901f, -0.04478547f, 0.04947220f, -0.04837971f, 0.00432232f, 0.09564114f, -0.00883527f, 0.07539654f, 
    -0.21160206f, -0.16236965f, -0.17125010f, -0.20427150f, -0.11394909f, -0.06287336f, 0.03033312f, 0.21626739f, 
    0.02220278f, -0.13440822f, -0.04902834f, 0.19466597f, 0.02475383f, 0.08242623f, -0.02198398f, 0.15410231f, 
    0.08997138f, -0.01773653f, -0.06311967f, -0.02553390f, -0.06754485f, 0.11781179f, 0.04407576f, -0.04796368f, 
    -0.28783536f, -0.12661359f, 0.06833848f, -0.15196945f, -0.05565495f, -0.04358327f, 0.08187488f, -0.08510431f, 
    0.04224147f, 0.11291853f, 0.07985496f, 0.16737135f, 0.09132383f, 0.01454929f, 0.01824099f, 0.04093256f, 
    0.01196404f, 0.17792635f, 0.03757459f, -0.01592318f, 0.08108415f, -0.02257469f, -0.10820336f, -0.26067480f, 
    0.01564458f, -0.00572688f, -0.07827763f, 0.12855750f, 0.00251108f, 0.01875616f, -0.02867438f, 0.14554109f, 
    0.06919249f, 0.07201052f, -0.01770444f, 0.03317310f, -0.29759142f, 0.05980757f, 0.20672166f, 0.08680177f, 
    -0.04590289f, -0.01244792f, 0.03056342f, -0.03287265f, 0.01611999f, -0.10717478f, -0.16866452f, -0.14477858f, 
    -0.05243461f, -0.04579285f, 0.07795935f, 0.06703061f, 0.10199106f, 0.02630136f, 0.05395311f, 0.08418643f, 
    0.05613794f, 0.05488420f, -0.00877304f, 0.04597506f, 0.05357055f, -0.14533222f, -0.06097537f, 0.06899126f, 
    -0.11498507f, -0.06068960f, -0.00826053f, 0.02523986f, -0.02163661f, -0.07323416f, 0.15417401f, -0.08993905f, 
    -0.29649347f, -0.01933246f, -0.00146063f, 0.03196588f, 0.03863549f, 0.02821046f, -0.01424163f, -0.04760752f, 
    0.03171569f, -0.06222976f, -0.00445463f, -0.17186424f, -0.01082888f, 0.03414709f, -0.03727552f, 0.00544895f, 
    -0.05689664f, -0.06657074f, 0.06030000f, -0.09636539f, 0.06186528f, -0.03325503f, 0.02201206f, 0.10636231f, 
    -0.34796670f, 0.09373394f, -0.02063385f, 0.01207448f, -0.15568690f, -0.06118630f, 0.07861348f, 0.02361830f, 
    -0.08803636f, 0.11595266f, -0.04630347f, 0.06717428f, 0.04454874f, -0.17069042f, 0.00756324f, 0.04395811f, 
    -0.04579381f, 0.02782813f, 0.04035101f, -0.03914584f, 0.08879597f, -0.12609333f, -0.16407195f, -0.13158239f, 
    0.48379335f, 0.02531087f, 0.13965783f, -0.33016512f, 0.06536528f, 0.06236847f, 0.06694081f, 0.02839767f, 
    -0.05800582f, 0.08172219f, -0.02152513f, 0.09797920f, -0.03471709f, -0.14966130f, 0.04697047f, 0.04914371f, 
    0.03507320f, 0.04133290f, 0.04504511f, 0.00201722f, 0.04209305f, -0.01797059f, 0.12229435f, -0.03769441f, 
    -0.24788095f, -0.03406717f, 0.20680267f, 0.16293885f, -0.01718013f, 0.00530142f, 0.13579497f, 0.10464539f, 
    -0.06124358f, -0.00814479f, -0.01536090f, -0.10457561f, 0.25176653f, -0.12940495f, 0.22952427f, -0.00989451f, 
    0.03352785f, -0.04905139f, -0.04946488f, -0.01400501f, -0.02247631f, -0.14571555f, -0.13774176f, 0.04806376f, 
    -0.39467537f, 0.33438918f, -0.02415700f, -0.27038464f, 0.12814429f, 0.10449975f, -0.12454213f, -0.05699559f, 
    0.10129939f, -0.05297721f, 0.10578151f, -0.20092079f, 0.24885854f, -0.06841519f, 0.16135074f, 0.32710057f, 
    -0.01304578f, 0.01510368f, 0.07877212f, -0.04299679f, 0.01337002f, -0.01120324f, -0.00839711f, 0.31282365f, 
    0.01843273f, 0.08934240f, 0.25262415f, 0.24398127f, -0.06087577f, -0.10443846f, -0.01726964f, 0.05626054f, 
    0.06325080f, 0.16148539f, -0.07515497f, -0.08053393f, -0.13469502f, 0.10838043f, -0.13494882f, -0.17228010f, 
    0.17142850f, -0.07580919f, -0.05556772f, 0.03649823f, 0.12860271f, 0.04510360f, 0.02477511f, 0.13500102f, 
    0.01944595f, 0.13856976f, -0.10121991f, -0.20757377f, 0.03229307f, 0.07256525f, 0.16159520f, 0.05794522f, 
    0.09881201f, 0.04573357f, -0.11972994f, -0.14997721f, 0.40899092f, 0.35638848f, 0.00722742f, 0.12324159f, 
    0.00924519f, -0.00184739f, -0.18285041f, -0.05708573f, -0.09791404f, 0.10230303f, -0.10965879f, 0.03582327f, 
    -0.29603666f, 0.17756572f, -0.07988556f, 0.02776684f, -0.04263270f, 0.02705698f, 0.09778234f, 0.09590498f, 
    0.04579694f, -0.05540599f, 0.01334515f, -0.04209138f, 0.03541267f, 0.01092844f, 0.36973956f, 0.19432105f, 
    -0.05899411f, -0.01370900f, 0.09455223f, 0.00728530f, 0.01908676f, -0.12552044f, -0.11827252f, 0.03334788f, 
    0.22762869f, -0.06635685f, 0.03709374f, 0.22022977f, 0.09208267f, -0.14093579f, 0.09384054f, 0.05113390f, 
    -0.07177688f, 0.02834534f, 0.05585063f, -0.10936251f, 0.19365254f, -0.12415899f, 0.11055303f, 0.36716399f, 
    -0.08003603f, 0.11626409f, 0.03273403f, -0.01073804f, -0.11943720f, -0.06233787f, -0.00281966f, 0.07074700f, 
    -0.30611357f, -0.21251835f, -0.06442299f, 0.09741946f, 0.06500926f, -0.04338454f, 0.21488070f, 0.11953347f, 
    0.03504008f, 0.05559105f, 0.04717313f, 0.20167063f, 0.19251241f, 0.02428265f, -0.12160323f, -0.07289737f, 
    0.09263711f, -0.01220763f, -0.07063589f, -0.06229538f, -0.01868897f, 0.05726672f, -0.12778889f, -0.03550777f, 
    0.25569937f, 0.00008787f, 0.24211088f, 0.03764423f, -0.19209141f, -0.12350564f, 0.13311011f, -0.11309649f, 
    0.05611120f, -0.07323698f, 0.09313954f, 0.09233343f, 0.47504169f, -0.17139430f, 0.05144718f, -0.06684192f, 
    -0.11611599f, -0.15553142f, -0.01674223f, 0.00852551f, -0.02102878f, 0.08338921f, -0.13696496f, 0.08529516f, 
    0.26409462f, 0.05718210f, 0.25506994f, 0.19562681f, -0.05136633f, 0.13764159f, 0.00371811f, 0.03336849f, 
    -0.05785387f, 0.00505472f, 0.16101609f, 0.16788226f, 0.07694549f, -0.10686948f, 0.05071568f, 0.02433188f, 
    -0.04344821f, 0.12514254f, -0.09741166f, 0.01007309f, 0.03543613f, 0.16516128f, 0.20913239f, 0.32307678f, 
    -0.21991274f, 0.20257255f, -0.11327594f, 0.15792166f, 0.13254635f, 0.10366010f, 0.04976254f, 0.01589969f, 
    0.10590084f, 0.00766779f, 0.12857714f, 0.05096365f, 0.22513650f, 0.17759769f, 0.16003527f, 0.01721631f, 
    -0.10521137f, 0.04293625f, 0.17928497f, 0.07902941f, -0.04673488f, -0.02139695f, -0.00707403f, -0.08718873f, 
    -0.13858616f, -0.23801826f, 0.14680678f, -0.02155950f, 0.08462355f, -0.18990579f, 0.06689259f, 0.09702874f, 
    0.05578922f, 0.24666779f, 0.02652017f, 0.10745388f, 0.23660919f, -0.13119496f, -0.10228490f, -0.20431106f, 
    0.01352702f, 0.00015009f, -0.08742528f, -0.05045551f, -0.19168307f, 0.08727255f, -0.11497610f, 0.09437954f, 
    -0.10544378f, 0.04423660f, -0.16593632f, -0.30200914f, 0.17868558f, 0.07633237f, -0.02391179f, -0.04579034f, 
    0.09055646f, -0.04113238f, 0.07384067f, 0.10388459f, 0.03908500f, 0.30745807f, 0.20100090f, 0.04938094f, 
    0.04568783f, -0.03000144f, -0.11785493f, -0.03307169f, 0.05542686f, 0.04001592f, 0.23424943f, -0.10737467f, 
    -0.21466526f, 0.01603316f, -0.12711926f, -0.30228406f, 0.10014524f, 0.07966262f, 0.11222005f, 0.02354220f, 
    0.09082810f, -0.14042215f, 0.11469002f, -0.14309734f, -0.10226976f, -0.07474797f, -0.12050435f, 0.01832756f, 
    0.07895460f, -0.06092031f, 0.21048051f, -0.03251375f, 0.19906238f, -0.10090601f, -0.01601395f, -0.00974858f, 
    0.31036863f, -0.16702899f, 0.05450181f, -0.26790416f, 0.01180964f, -0.07463257f, -0.00065323f, -0.04817781f, 
    0.21039174f, 0.14671709f, -0.21065120f, -0.06140432f, -0.15629895f, -0.02050568f, -0.22302116f, -0.17892003f, 
    0.22385816f, 0.08507757f, 0.00287419f, 0.00259726f, 0.07447015f, 0.04577691f, -0.14036261f, 0.08577143f, 
    -0.12678806f, 0.07308486f, -0.01259279f, 0.00810399f, 0.00558588f, -0.02362065f, -0.00434848f, 0.00516691f, 
    -0.01621437f, -0.01720794f, -0.09476434f, -0.10989417f, -0.03950214f, 0.05704077f, -0.18231034f, 0.24942572f, 
    -0.02845224f, 0.07786670f, -0.08377696f, 0.20851418f, -0.09088212f, -0.01806696f, -0.07193426f, -0.26568145f, 
    0.24210353f, 0.03949722f, 0.13729191f, 0.15202215f, -0.02936148f, -0.08009031f, -0.00857014f, 0.01845288f, 
    -0.02371965f, -0.10904509f, -0.01285282f, 0.09656568f, -0.14241873f, 0.06389903f, -0.08453900f, 0.17017238f, 
    0.15343334f, 0.07971533f, 0.00432743f, 0.21272269f, 0.13112682f, -0.07855362f, -0.03097519f, 0.00092338f, 
    0.00868404f, 0.02255882f, -0.12124968f, -0.22338185f, 0.02054959f, 0.05117140f, -0.00258326f, 0.08603813f, 
    0.10290619f, 0.11394719f, -0.06213865f, -0.06251394f, -0.23602089f, 0.48065853f, -0.04267522f, -0.15891901f, 
    0.01260580f, 0.22104572f, 0.16426571f, -0.04484257f, 0.19663423f, 0.00476279f, -0.05902439f, -0.02178615f, 
    -0.13566189f, 0.18940838f, 0.03208705f, -0.01494199f, -0.07430715f, 0.04562271f, 0.10401817f, 0.06666993f, 
    -0.15338206f, 0.18276492f, 0.07169461f, 0.11197691f, 0.23119541f, -0.07930692f, 0.03843015f, -0.09980109f, 
    -0.03393459f, -0.09046435f, -0.00270090f, 0.04889353f, 0.01371397f, -0.01042236f, -0.02381848f, -0.07499299f, 
    0.27781078f, -0.01691823f, -0.13743706f, -0.11639640f, -0.07994061f, 0.02494338f, -0.04997226f, 0.03052532f, 
    -0.11934666f, -0.17904557f, 0.10499591f, 0.05310849f, -0.26267970f, 0.05324736f, -0.12108308f, 0.05609355f, 
    0.05085141f, -0.10556557f, 0.07960431f, 0.07441456f, 0.08404742f, -0.05920675f, 0.17443156f, 0.06731770f, 
    -0.46915957f, 0.01882327f, -0.10551318f, -0.08219043f, 0.06163260f, 0.07487669f, -0.03606989f, -0.01826416f, 
    -0.00112826f, -0.01985332f, -0.13325831f, 0.19900012f, 0.20973501f, 0.07789005f, 0.05559105f, -0.01639968f, 
    -0.06370306f, -0.05818048f, 0.06878131f, 0.09465633f, 0.01411768f, -0.05436947f, 0.09016833f, 0.09463616f, 
    -0.27452734f, 0.01162295f, -0.05172854f, 0.08460125f, 0.01770611f, 0.08718947f, -0.01643213f, 0.10279237f, 
    0.15189788f, -0.09340042f, 0.15589204f, 0.03883208f, -0.07431342f, -0.07257996f, -0.08240113f, 0.13336268f, 
    0.18668433f, 0.02629217f, 0.04639905f, 0.04238404f, 0.21047717f, -0.20501494f, -0.04117928f, -0.05092490f, 
    -0.04036380f, -0.18266055f, 0.03898761f, -0.07152582f, 0.11539767f, 0.05113169f, -0.08103578f, -0.24116097f, 
    0.15043825f, -0.10375618f, -0.00325483f, 0.05017767f, -0.20321761f, 0.15665232f, 0.01445558f, 0.32436037f, 
    -0.07147670f, -0.06212272f, 0.09590408f, 0.11491496f, -0.03962891f, 0.07722061f, 0.07610076f, -0.01980870f, 
    -0.20652679f, 0.05781803f, -0.09125645f, 0.07832896f, 0.03290844f, -0.08843018f, -0.00141821f, 0.04929753f, 
    0.09186459f, 0.23015334f, -0.00496096f, -0.08710850f, -0.09001835f, 0.07119824f, -0.11606596f, -0.20329724f, 
    0.14731446f, 0.05506368f, 0.00463431f, -0.27139738f, 0.09762268f, 0.07006408f, 0.04597479f, -0.00744435f, 
    -0.04526021f, -0.08123423f, -0.12971064f, -0.08344179f, 0.18711975f, -0.00914741f, 0.14016034f, 0.09175917f, 
    0.05611938f, -0.04740794f, 0.02375101f, -0.04378940f, -0.12431399f, 0.04184215f, -0.01070957f, 0.07799993f, 
    0.02203819f, -0.03973098f, -0.03758397f, 0.03422877f, 0.05848494f, -0.09406244f, 0.05172140f, 0.18718196f, 
    -0.16871195f, -0.02716873f, -0.13108027f, -0.08720092f, 0.12486099f, 0.06801705f, -0.03358162f, -0.06272935f, 
    0.05802753f, 0.14995570f, 0.07462151f, 0.15323880f, -0.26111680f, -0.09938735f, -0.20377372f, 0.17818728f, 
    -0.05087404f, 0.14344673f, -0.03133199f, 0.07250887f, -0.09700689f, -0.15749496f, 0.19023782f, 0.05560171f, 
    -0.05762927f, -0.00345660f, 0.11169237f, -0.30199897f, 0.09285419f, 0.06477199f, 0.06094817f, 0.03048374f, 
    0.04506834f, 0.13065252f, 0.15775900f, 0.01043690f, 0.08996325f, -0.05663958f, 0.09766170f, 0.27731565f, 
    -0.09876478f, 0.07527430f, 0.12871474f, 0.07474963f, 0.07679897f, -0.18780319f, 0.00566187f, -0.00736477f, 
    -0.05265095f, -0.00137997f, -0.05447245f, -0.14622986f, 0.03620317f, 0.03718709f, -0.10732171f, 0.17328854f, 
    0.19678861f, 0.13601083f, 0.11009729f, 0.04845353f, 0.31038702f, -0.02749793f, 0.06803072f, 0.11126976f, 
    0.11300636f, -0.10678753f, 0.10968966f, -0.01007304f, -0.02148428f, 0.12213324f, 0.07066392f, 0.31710500f, 
    0.29838875f, 0.19013074f, 0.05022947f, 0.23638293f, -0.03836731f, -0.15367889f, -0.04120175f, 0.06138439f, 
    -0.06572676f, -0.06470829f, -0.03193852f, 0.08408970f, -0.09770359f, -0.01158870f, -0.18168600f, 0.02887754f, 
    0.04793374f, -0.00291930f, 0.04174838f, 0.01291362f, 0.04814299f, 0.12536193f, 0.10402989f, 0.18293396f, 
    -0.10314023f, -0.13283205f, 0.09560445f, -0.04808118f, 0.13929966f, -0.07477342f, 0.01448868f, -0.17781912f, 
    -0.03898851f, -0.04705787f, 0.06683166f, 0.15979613f, -0.35934585f, 0.00197997f, -0.18986066f, -0.01936423f, 
    0.15931785f, 0.20966420f, 0.09366881f, -0.16588105f, -0.10617676f, 0.02852270f, -0.04761866f, 0.10630843f, 
    -0.02970109f, 0.02310642f, -0.00592233f, 0.27300936f, -0.07805438f, -0.00315535f, -0.03926641f, 0.03932086f, 
    -0.00488834f, -0.01424780f, -0.06267459f, 0.15181044f, -0.15827781f, -0.00289673f, 0.22139978f, 0.14522892f, 
    -0.05577470f, 0.02966070f, -0.07292288f, 0.08189016f, -0.00311110f, -0.07822905f, -0.00742673f, 0.02112549f, 
    -0.07893801f, 0.04119437f, 0.07529654f, -0.45672587f, 0.13031781f, 0.11627175f, 0.10675988f, -0.07335994f, 
    -0.04122708f, -0.04873336f, -0.03351940f, -0.14054745f, 0.06064669f, 0.00073828f, 0.07477348f, 0.22175293f, 
    -0.16054855f, 0.07402385f, 0.00627335f, 0.05314727f, 0.03098766f, -0.21995768f, 0.23773617f, 0.22920506f, 
    -0.15939561f, 0.08824422f, -0.05546355f, 0.21038389f, 0.03793078f, -0.01638183f, -0.06761292f, -0.01279908f, 
    0.16035929f, -0.09075935f, 0.01592163f, -0.10216209f, -0.08065562f, 0.32165325f, 0.43829301f, 0.19115764f, 
    -0.05253844f, 0.00764311f, -0.02171532f, 0.04683666f, 0.04723142f, 0.03592361f, -0.02959212f, 0.06856199f, 
    0.13138530f, -0.03301682f, -0.00602404f, -0.01024201f, -0.02231909f, 0.11096338f, 0.00965403f, -0.07976425f, 
    0.15673321f, -0.04470939f, 0.02517015f, 0.07880367f, -0.15600520f, 0.04732220f, -0.07161286f, 0.11589211f, 
    -0.01373729f, 0.08786390f, 0.03108176f, 0.05116635f, 0.12483629f, 0.11404222f, 0.14016150f, 0.02101758f, 
    0.18965575f, -0.08672647f, 0.07036658f, 0.15784049f, 0.05318004f, 0.08867809f, 0.28624907f, 0.02365835f, 
    0.04357081f, 0.00937517f, -0.01758272f, 0.21285181f, 0.10756737f, 0.17191727f, -0.11909139f, -0.36588788f, 
    -0.09159494f, -0.04256276f, 0.03682060f, 0.06576106f, 0.07387183f, -0.01994548f, -0.07986908f, -0.09692125f, 
    -0.04602695f, -0.00810349f, -0.19771397f, -0.23499118f, -0.07180892f, 0.09672216f, 0.07929061f, 0.12884328f, 
    -0.03491915f, -0.01534363f, 0.12737124f, 0.13044849f, -0.16163819f, -0.05032948f, -0.19646980f, 0.18208794f, 
    0.08509828f, 0.08957897f, 0.08553110f, 0.04759859f, -0.03159073f, 0.00034001f, 0.04117321f, -0.13880379f, 
    -0.23382427f, -0.23802207f, 0.00746586f, 0.07345653f, 0.08045918f, 0.22991544f, -0.00854366f, -0.08178335f, 
    -0.04947358f, 0.09155378f, 0.06032696f, 0.08767972f, -0.41992530f, -0.24432550f, 0.00435985f, -0.06324077f, 
    0.07714874f, 0.06279014f, 0.17265169f, 0.11436550f, 0.09545282f, -0.01317187f, 0.15660486f, -0.03669988f, 
    -0.38563153f, 0.25333720f, -0.16255753f, -0.02661998f, 0.16340806f, 0.07874379f, -0.06954174f, 0.05344785f, 
    0.00567901f, 0.03175291f, 0.07672095f, 0.04733688f, 0.37663072f, -0.16033889f, -0.07531583f, 0.22303349f, 
    -0.11201970f, 0.01689245f, 0.05136862f, -0.04763842f, 0.00294724f, 0.11779288f, 0.05389939f, -0.02924608f, 
    -0.12382092f, 0.22901085f, 0.16439477f, -0.20497881f, -0.08552001f, 0.22006528f, 0.04909615f, -0.00751063f, 
    0.09253357f, 0.01534068f, -0.05341137f, 0.25248614f, 0.14263716f, 0.11793059f, -0.03091444f, -0.30122048f, 
    0.02446594f, -0.05311210f, 0.08113847f, 0.04221151f, 0.09472564f, 0.10503647f, 0.05784564f, -0.04116558f, 
    0.20088586f, -0.15242465f, -0.07917627f, -0.08270927f, -0.02081493f, 0.07799869f, -0.05292139f, 0.01091127f, 
    0.01096763f, 0.00671359f, 0.03278227f, -0.09737656f, 0.07875188f, -0.27268448f, 0.31547773f, 0.13884592f, 
    -0.10124338f, 0.12054311f, 0.06351052f, 0.05175947f, 0.05770119f, 0.01536231f, 0.12165326f, -0.06430660f, 
    0.24207501f, -0.12915501f, -0.03597583f, 0.16730532f, -0.04716904f, 0.13833757f, 0.08627893f, 0.04565112f, 
    0.07894588f, 0.01513789f, -0.07741297f, 0.14533645f, -0.35762161f, -0.04026560f, 0.12844580f, 0.02914861f, 
    0.17215306f, 0.19109634f, -0.02166041f, 0.03683970f, 0.03166625f, -0.07252092f, -0.00722447f, -0.05037327f, 
    -0.01027736f, 0.05966058f, 0.02083145f, -0.18106085f, -0.07269249f, -0.04629888f, 0.01498144f, 0.02837980f, 
    0.07087930f, -0.01991609f, -0.08198494f, -0.21738121f, 0.24156889f, 0.09263283f, 0.01362242f, 0.12637714f, 
    0.25074658f, 0.04799496f, 0.12027164f, 0.01483511f, 0.06604013f, -0.01866291f, -0.08395969f, -0.15973184f, 
    -0.23934485f, 0.21173441f, -0.00177215f, -0.11897664f, 0.00239631f, 0.04194100f, 0.12227990f, -0.05077763f, 
    -0.08101702f, 0.08682963f, -0.10154141f, 0.06946798f, -0.17545317f, -0.12153827f, -0.02551504f, -0.10529581f, 
    0.08854861f, -0.08582806f, 0.01680103f, 0.11466219f, 0.10868780f, 0.05747893f, 0.01922496f, 0.22575273f, 
    0.20612921f, -0.02753373f, -0.03635595f, 0.25158447f, -0.01830071f, 0.14717652f, -0.06491903f, 0.00368792f, 
    0.00984857f, -0.08725348f, 0.02764954f, 0.01679800f, -0.06581262f, -0.12723397f, 0.35094425f, 0.19065885f, 
    -0.00549114f, 0.04005597f, 0.14213091f, 0.10488927f, 0.13424037f, 0.07922532f, 0.16365379f, -0.03512790f, 
    -0.37884477f, -0.21087502f, -0.05500211f, 0.00373086f, -0.02917379f, 0.03777115f, -0.06713640f, 0.04537324f, 
    0.01067196f, 0.07866929f, -0.05225781f, -0.02989896f, -0.10490044f, -0.10633558f, -0.20928985f, -0.00673994f, 
    0.16191883f, 0.01814100f, 0.10879083f, 0.01114885f, -0.04044401f, 0.06056511f, -0.02534983f, 0.20796341f, 
    -0.13338678f, -0.22873175f, -0.07070413f, -0.04368146f, -0.04386006f, -0.08530147f, -0.01201817f, 0.02729108f, 
    0.00641337f, 0.04007770f, -0.16115946f, 0.17111227f, 0.24370478f, -0.24159409f, 0.09072606f, -0.13515088f, 
    0.04800445f, 0.08826880f, -0.12283363f, 0.07407017f, -0.01288965f, 0.00923236f, -0.02665036f, 0.04684971f, 
    -0.16743268f, -0.05052110f, 0.09544615f, 0.28929389f, 0.21478716f, 0.07238406f, 0.00557635f, -0.00149137f, 
    -0.07555322f, -0.13165934f, 0.25698593f, 0.11190762f, 0.11703373f, -0.11370824f, -0.20616838f, -0.03024599f, 
    0.02127218f, -0.01085541f, 0.08206306f, 0.10294025f, 0.02111179f, -0.03404821f, 0.15897146f, -0.10164198f, 
    0.07074679f, 0.03830179f, 0.05388764f, -0.04673788f, 0.03602616f, 0.00262451f, -0.03027691f, 0.17719619f, 
    -0.00348818f, 0.04745780f, -0.01410399f, 0.12880656f, -0.15977664f, 0.04503164f, 0.18334845f, -0.06250978f, 
    0.05494858f, 0.12669237f, 0.10974436f, 0.04619245f, 0.06992566f, 0.01617790f, 0.15099265f, 0.24538237f, 
    0.14188410f, -0.10206510f, 0.09636945f, -0.01801251f, -0.06349507f, 0.03901734f, 0.03912229f, 0.00910970f, 
    0.17266835f, 0.06568159f, -0.08385666f, 0.00365653f, 0.09034371f, -0.02677438f, 0.14403558f, 0.03524079f, 
    -0.17259978f, 0.07843318f, 0.01376953f, -0.09070513f, 0.03368750f, 0.11523277f, 0.02035163f, 0.04466196f, 
    0.12283166f, -0.23246145f, -0.08473685f, 0.06645382f, 0.04832809f, 0.06012801f, 0.04018956f, 0.06869381f, 
    0.00188032f, -0.12865593f, 0.24645381f, 0.14317413f, -0.03425561f, -0.19928835f, -0.13310863f, 0.06596120f, 
    0.16572697f, -0.04593062f, -0.02569277f, 0.10380021f, -0.18670869f, -0.02989724f, 0.08380912f, 0.02360407f, 
    -0.05130092f, -0.15965474f, 0.23453210f, 0.19379833f, 0.08729686f, 0.05517988f, -0.02635646f, 0.04857064f, 
    0.07398625f, -0.04200988f, 0.01953682f, -0.09434256f, 0.09518909f, 0.07360263f, -0.05427875f, 0.18301356f, 
    0.13917744f, 0.18629688f, 0.16903903f, -0.02687877f, 0.09545700f, 0.00011622f, 0.15331900f, 0.19591886f, 
    -0.20353290f, -0.06222573f, 0.33003971f, 0.11601101f, -0.01799091f, -0.04213800f, 0.09868664f, 0.07364520f, 
    0.05516714f, 0.09113448f, -0.13504881f, -0.02347788f, -0.09154759f, -0.25190979f, 0.09795175f, 0.06805019f, 
    -0.10274221f, 0.22479665f, -0.08912513f, -0.03717728f, 0.00650621f, -0.02062517f, -0.25353396f, 0.01096916f, 
    -0.02658734f, 0.26798856f, -0.14719975f, 0.14218682f, 0.05534263f, -0.08608996f, 0.03864896f, 0.13481435f, 
    0.04980890f, 0.13044110f, 0.29235390f, -0.11401728f, -0.02028899f, -0.20154156f, 0.13396113f, 0.17137443f, 
    -0.00708082f, 0.14689305f, 0.15396416f, -0.06297767f, -0.03655653f, -0.01847476f, -0.10897784f, -0.05974082f, 
    -0.46597102f, 0.20163134f, -0.09675796f, 0.07164654f, 0.23386551f, -0.00718023f, -0.00241367f, -0.00236050f, 
    0.00826720f, 0.14210854f, -0.00042061f, 0.04754299f, 0.30254936f, 0.03064058f, -0.07471522f, -0.00075128f, 
    -0.12527029f, 0.03584105f, 0.02083977f, -0.02636501f, 0.02335417f, 0.15166830f, 0.05841371f, 0.13595486f, 
    0.13672239f, -0.00031514f, -0.08007523f, -0.10527378f, -0.04652783f, 0.14631897f, 0.02872342f, 0.22411156f, 
    -0.01193056f, 0.22721875f, 0.02885406f, -0.04220214f, -0.00691627f, 0.17309783f, 0.24313621f, -0.00540450f, 
    0.03038488f, 0.19732705f, -0.07199187f, -0.01290269f, 0.06829007f, -0.06313070f, -0.08921402f, 0.09588157f, 
    0.08496479f, -0.06952906f, -0.10519832f, -0.16589640f, 0.13462929f, 0.17875005f, -0.03247565f, -0.10706740f, 
    -0.07692347f, -0.20808829f, 0.03749695f, 0.18084207f, -0.12839985f, -0.06302954f, -0.15975149f, -0.05549109f, 
    0.03784892f, 0.10333622f, 0.08413231f, 0.23511145f, 0.00543231f, -0.07946206f, -0.01638237f, 0.07366048f, 
    -0.10090134f, -0.19157052f, -0.15932296f, -0.14589088f, -0.13578923f, 0.10369632f, -0.12154244f, 0.02317886f, 
    -0.05886016f, 0.05645439f, 0.06306478f, 0.06286330f, -0.26858202f, 0.12962002f, 0.05916220f, 0.06277036f, 
    0.06126339f, 0.16331564f, -0.01932237f, 0.05382386f, 0.03046860f, 0.03664315f, 0.00806235f, -0.20975807f, 
    0.04449534f, -0.13202938f, -0.13443391f, 0.01340982f, -0.04870333f, -0.10310395f, 0.02176099f, -0.03587031f, 
    0.10004533f, -0.10240796f, 0.04615207f, 0.02698994f, -0.07950135f, 0.14317420f, 0.00159124f, 0.03839873f, 
    0.08340717f, 0.01812850f, 0.09096931f, -0.04631523f, 0.17682213f, 0.21224277f, -0.05531523f, 0.06516440f, 
    0.11308996f, -0.24726197f, -0.33798924f, 0.09627651f, -0.19463322f, -0.02346824f, -0.01831937f, -0.03566690f, 
    -0.03452333f, -0.09600166f, -0.09333599f, 0.08767688f, 0.06307716f, -0.00573672f, -0.07754033f, -0.25126714f, 
    -0.10190207f, -0.12968822f, -0.00850501f, 0.08098268f, 0.07190603f, 0.11939368f, -0.00109669f, 0.08117598f, 
    -0.09189103f, -0.10687973f, 0.11110505f, 0.15032102f, -0.05617472f, -0.03200628f, 0.06398644f, -0.01117775f, 
    0.04357537f, -0.02597221f, -0.01260642f, 0.11263476f, 0.07054537f, 0.23728445f, 0.03680743f, -0.04500700f, 
    -0.18556678f, 0.09412412f, 0.05033309f, 0.03057532f, 0.03588029f, -0.16389132f, -0.02145472f, -0.03381784f, 
    -0.10882515f, -0.00910664f, 0.14004922f, -0.09829768f, 0.01456891f, 0.09797494f, 0.04457421f, 0.06790773f, 
    0.06054095f, 0.15562075f, 0.09742338f, 0.01704110f, 0.03315103f, 0.21428320f, -0.04446514f, 0.12178436f, 
    -0.00287233f, 0.04765006f, 0.10642872f, 0.07611659f, 0.11860465f, -0.04127795f, -0.04868368f, -0.01391763f, 
    0.11416867f, 0.10103372f, -0.00620414f, -0.02407330f, -0.17155193f, 0.14613503f, 0.04191200f, 0.06307917f, 
    -0.02469096f, -0.01575467f, -0.02189031f, -0.00726885f, 0.18746975f, -0.08227612f, -0.10397716f, 0.06302803f, 
    -0.04514303f, -0.10546491f, -0.00449605f, 0.11664217f, 0.17400876f, -0.01029329f, 0.18274522f, -0.05725204f, 
    0.10599668f, 0.31315655f, 0.24139446f, -0.03215049f, 0.00635949f, 0.03383117f, -0.04792357f, 0.07920859f, 
    0.00526266f, -0.08133031f, 0.04012638f, -0.03045565f, -0.31416523f, 0.21561742f, -0.01294164f, 0.02936875f, 
    0.02295351f, -0.05072803f, 0.13032435f, -0.01711936f, -0.03380424f, -0.02671653f, 0.09967478f, -0.02422284f, 
    -0.16214912f, -0.12202700f, -0.25368485f, 0.19876161f, -0.06445955f, -0.08641497f, 0.03239154f, 0.10558590f, 
    0.02029476f, 0.03107055f, 0.20057048f, 0.12376830f, -0.09668276f, -0.07716547f, -0.05358155f, 0.10048179f, 
    0.06466520f, 0.13295920f, 0.11797671f, 0.02202143f, -0.00216445f, 0.00337873f, -0.15722737f, -0.10499327f, 
    0.07304508f, -0.25299945f, 0.09730478f, -0.15124391f, -0.09174367f, 0.13424592f, 0.07476276f, 0.05166428f, 
    -0.10852579f, 0.21065946f, 0.04096656f, 0.19056325f, -0.23200752f, -0.07860810f, -0.28209367f, -0.31824610f, 
    -0.02957613f, 0.01064427f, 0.07511244f, 0.07710786f, 0.00476106f, 0.05490683f, 0.01127954f, 0.05527959f, 
    -0.03372154f, -0.02599629f, 0.01050183f, -0.03594217f, -0.02097396f, -0.03778212f, -0.03215302f, 0.03131483f, 
    0.00594488f, 0.02326849f, -0.01828543f, 0.01616245f, 0.01530054f, -0.03717539f, 0.02050545f, 0.00589629f, 
    -0.00411290f, 0.03121008f, 0.00420337f, -0.00050547f, 0.00074832f, -0.03382068f, 0.00784513f, -0.01574322f, 
    -0.01446109f, -0.03639218f, 0.00442502f, -0.03395981f, 0.01275988f, 0.00968698f, -0.00524351f, 0.03228878f, 
    0.01837553f, -0.03742876f, 0.02725417f, -0.03936302f, -0.01555842f, 0.02027756f, 0.01116507f, -0.00173089f, 
    -0.02309886f, 0.01802505f, -0.03076760f, -0.02096760f, 0.02253863f, -0.01664774f, -0.03443841f, 0.00197746f, 
    0.00283508f, 0.00869735f, -0.01036850f, -0.03287334f, 0.01943962f, 0.00168005f, -0.02650412f, 0.03098008f, 
    -0.00420461f, 0.00379255f, -0.03578717f, 0.02116360f, -0.03839111f, -0.02174010f, 0.00196051f, -0.02731303f, 
    0.02726047f, -0.00833565f, -0.01284058f, -0.00812372f, -0.01108642f, 0.01449778f, -0.01499037f, 0.01574833f, 
    -0.00561329f, -0.02145388f, -0.00280511f, 0.01280335f, -0.01485536f, 0.01181407f, -0.01821402f, 0.00668487f, 
    -0.03654556f, -0.03858934f, -0.03785063f, 0.02307237f, -0.02908171f, -0.03455846f, -0.02284416f, 0.00660151f, 
    -0.03613929f, -0.01706817f, -0.02952030f, -0.00909165f, -0.00964159f, 0.00615933f, -0.02259721f, -0.02546707f, 
    -0.03581664f, -0.00346424f, 0.03256266f, -0.01596788f, -0.02093430f, -0.03685713f, -0.00693965f, 0.00260362f, 
    0.01298515f, -0.00442903f, 0.01498183f, -0.02066986f, 0.00326849f, 0.00649176f, -0.02519959f, -0.02082346f, 
    -0.01110922f, -0.02574625f, -0.01234189f, -0.01789046f, 0.00247711f, 0.01391258f, -0.00741690f, 0.00360685f, 
    0.01807003f, 0.03277957f, 0.00711006f, 0.01286124f, -0.02365210f, -0.00417619f, -0.01816403f, -0.00824512f, 
    -0.02014831f, -0.02819420f, -0.01732410f, 0.02152562f, -0.03775008f, 0.01703095f, -0.03262171f, -0.03664502f, 
    -0.03695572f, -0.01587064f, -0.01210146f, -0.02033021f, 0.02928575f, -0.00076746f, -0.02067431f, 0.00985321f, 
    0.02253085f, 0.00463185f, -0.01165499f, -0.03676886f, -0.03107979f, 0.00990593f, -0.00437394f, -0.03213717f, 
    -0.02965942f, 0.02963098f, -0.01178874f, 0.00042023f, 0.00949338f, -0.01675354f, 0.00607078f, -0.00119547f, 
    0.03174014f, -0.01777416f, -0.00560011f, 0.02308089f, 0.02304419f, -0.01640635f, 0.01473371f, 0.00807972f, 
    0.00842319f, -0.02972771f, 0.00834438f, 0.03209606f, -0.02542640f, -0.01716362f, -0.02626040f, 0.00474795f, 
    -0.00170142f, 0.01382209f, 0.01618055f, -0.03395704f, 0.00349030f, 0.00289245f, -0.01657465f, 0.02895041f, 
    0.00064812f, 0.00755766f, 0.01210382f, -0.03148434f, -0.03375947f, 0.00958031f, -0.01030681f, -0.00020168f, 
    -0.02431757f, -0.03740790f, 0.02803725f, 0.00774051f, -0.02712042f, 0.02076731f, -0.00283731f, -0.01959031f, 
    -0.01264525f, -0.00365044f, -0.00551196f, -0.00242615f, 0.01433926f, 0.01268465f, -0.03803846f, 0.00234942f, 
    0.01117720f, 0.03252204f, 0.02666565f, -0.01700275f, 0.02332944f, 0.01599411f, -0.01117501f, 0.01445737f, 
    -0.02494940f, -0.01183314f, -0.00351318f, 0.02279293f, -0.00407546f, 0.02132943f, -0.02063279f, -0.01225433f, 
    -0.01635148f, 0.02615845f, 0.02610667f, 0.01830584f, 0.03134613f, -0.00307826f, -0.01317975f, -0.00441435f, 
    -0.01495512f, -0.01081330f, -0.01971052f, -0.01438503f, -0.03457423f, -0.01579730f, -0.01847489f, -0.02781805f, 
    0.01563809f, 0.02871432f, -0.03847810f, 0.02184106f, -0.00155910f, -0.01504275f, -0.03705722f, 0.02998518f, 
    0.01935976f, 0.00068669f, -0.00283058f, 0.03385936f, -0.03644219f, -0.01350036f, -0.00038577f, 0.03280847f, 
    0.01293611f, -0.02987344f, -0.02713577f, -0.02655823f, -0.00833648f, 0.00368642f, -0.02729542f, -0.01384043f, 
    -0.02641908f, 0.01308047f, 0.01789833f, 0.03530598f, 0.00815462f, -0.01265621f, 0.00998385f, -0.00576852f, 
    -0.00706746f, 0.00491783f, 0.03111292f, -0.02294885f, -0.03104754f, 0.00164832f, 0.01864608f, 0.03083652f, 
    0.02751946f, -0.01772567f, -0.02802042f, 0.01042272f, -0.02239857f, 0.01011513f, 0.01190339f, -0.02949129f, 
    0.00080277f, 0.03023334f, 0.00928850f, 0.02951140f, -0.03778517f, 0.01455199f, -0.00449098f, 0.03043200f, 
    -0.01489576f, -0.03906083f, -0.03710164f, 0.02903869f, 0.00398315f, 0.03276152f, 0.02903841f, -0.01913997f, 
    -0.02285744f, 0.02716447f, 0.03060520f, 0.01141311f, 0.02434944f, 0.01067112f, 0.03039504f, 0.02857535f, 
    0.01169674f, 0.00015221f, -0.00890436f, 0.00773542f, -0.01028733f, -0.00218727f, 0.00413688f, 0.01030939f, 
    0.00751232f, 0.02443204f, -0.02803997f, -0.00198464f, 0.01243318f, 0.02136453f, 0.03090399f, -0.01954466f, 
    -0.01191389f, -0.03166888f, -0.02368926f, -0.01349266f, -0.02879988f, -0.03566175f, -0.02101720f, -0.02280786f, 
    0.02587338f, -0.00391597f, 0.03069011f, 0.00838802f, -0.02194103f, -0.03002498f, 0.02417949f, 0.03153059f, 
    -0.00614455f, 0.02312962f, -0.00152483f, -0.03533878f, 0.00751726f, -0.00240040f, -0.02951144f, -0.00237655f, 
    0.02336480f, 0.03035083f, -0.01926547f, 0.02417959f, 0.01173740f, -0.03607606f, 0.00158066f, 0.02336580f, 
    0.01697603f, 0.01387533f, 0.02653347f, 0.02913799f, -0.02166431f, 0.02841264f, -0.01814076f, 0.00723155f, 
    0.02557392f, -0.03378363f, -0.03324905f, -0.02690337f, -0.02010052f, 0.00245393f, -0.00946556f, -0.02633361f, 
    0.01329380f, -0.02224897f, 0.00376600f, 0.01865952f, -0.00592299f, -0.03810939f, 0.01167629f, 0.01956197f, 
    0.01971357f, -0.02400912f, -0.01379348f, 0.02575804f, 0.00084127f, -0.02254700f, 0.01753685f, -0.02177971f, 
    -0.00231774f, -0.02572900f, 0.01698440f, 0.02239510f, -0.02746594f, 0.01641316f, -0.02157761f, -0.02498264f, 
    -0.00555903f, -0.02538957f, 0.00827592f, 0.03021198f, 0.02421029f, -0.02462990f, 0.00937836f, 0.03300057f, 
    -0.01540983f, 0.02050967f, 0.02606749f, -0.00847750f, 0.01345507f, 0.00293785f, -0.00582879f, -0.01041077f, 
    0.02905072f, -0.01609928f, -0.00436163f, 0.00796407f, -0.01066723f, -0.00952034f, -0.00311426f, 0.00974086f, 
    -0.03697646f, -0.02101096f, 0.00021546f, 0.03355217f, 0.02763199f, 0.00049841f, -0.02832077f, 0.01973477f, 
    -0.01309090f, -0.02942699f, -0.02777664f, -0.02316520f, 0.01421193f, 0.00273790f, -0.02232615f, 0.01622518f, 
    0.01667421f, -0.02709473f, 0.01472345f, -0.02783342f, 0.02139611f, -0.03167079f, -0.00417146f, -0.00788773f, 
    0.01615715f, -0.02148885f, -0.01061416f, -0.03479147f, -0.02058261f, -0.04051039f, -0.00696297f, -0.01898984f, 
    -0.01824782f, 0.02249319f, -0.02424083f, -0.01642730f, -0.02908080f, 0.00513921f, -0.02792890f, 0.00489646f, 
    0.01696198f, -0.00950357f, -0.02992978f, 0.02888722f, -0.02395355f, 0.00995475f, 0.00289910f, 0.03295434f, 
    -0.01418937f, 0.01922078f, -0.01626053f, -0.03437757f, -0.02712192f, -0.02237048f, -0.02264154f, -0.03448479f, 
    0.02885138f, -0.00996523f, 0.01754921f, 0.03435015f, 0.02304736f, -0.03905974f, -0.01633295f, -0.00663966f, 
    -0.02091884f, -0.03693658f, -0.00267520f, -0.02085197f, 0.01810592f, -0.03779180f, 0.01073033f, 0.02465606f, 
    0.02595608f, -0.01724812f, 0.02379487f, -0.00688434f, -0.03147219f, -0.03353308f, 0.02119914f, 0.00394211f, 
    0.00692851f, -0.01925401f, 0.00306229f, -0.03665817f, -0.03011470f, 0.00896452f, -0.02844595f, 0.02616824f, 
    -0.00489541f, -0.00898434f, -0.03505014f, -0.03548616f, 0.02109080f, 0.01935529f, 0.01285865f, -0.01019889f, 
    0.03234336f, 0.01920100f, 0.00867817f, 0.01862363f, -0.00109040f, 0.00955360f, 0.00857639f, -0.02495463f, 
    -0.02995585f, 0.02378453f, 0.01755217f, 0.01754905f, -0.01161122f, 0.01418319f, -0.03460022f, -0.03070554f, 
    0.00007725f, -0.02963920f, -0.01168571f, -0.01826833f, 0.00355242f, -0.00146450f, 0.02517871f, 0.01449736f, 
    0.02206384f, -0.02432038f, -0.00079260f, -0.03350424f, -0.01980725f, 0.01377318f, 0.02344227f, 0.00239239f, 
    -0.03404236f, -0.02962377f, -0.01259807f, -0.02690254f, 0.02470158f, -0.01773676f, 0.02006657f, -0.03756263f, 
    -0.02143713f, 0.01045659f, -0.01420240f, 0.02830570f, -0.00861859f, 0.01598402f, -0.02876857f, -0.00283630f, 
    0.02455340f, 0.00266695f, -0.02486698f, 0.01620096f, -0.00077469f, -0.03647890f, -0.01832940f, -0.01640135f, 
    0.00225083f, -0.03422485f, 0.00865444f, 0.00529636f, 0.01836679f, -0.01093421f, -0.02780842f, -0.04106802f, 
    0.02231413f, -0.02504238f, -0.03104332f, 0.01568964f, -0.01475456f, 0.00570431f, 0.01204973f, -0.03745464f, 
    -0.02456563f, 0.03192957f, -0.00192318f, 0.03041606f, 0.01897904f, 0.00530808f, 0.00530549f, -0.02647579f, 
    -0.02548705f, -0.03328198f, -0.00642568f, -0.02168703f, -0.02420733f, 0.01109357f, -0.00542508f, -0.00997604f, 
    -0.01523233f, -0.00154338f, -0.00206151f, 0.01434970f, -0.03957706f, -0.01376296f, -0.03615712f, 0.00818449f, 
    0.01988656f, -0.02315235f, -0.00149969f, -0.00037157f, -0.00057066f, -0.01829585f, -0.00841451f, 0.01958750f, 
    -0.03453998f, -0.01950984f, 0.00400358f, -0.01583019f, -0.03713333f, 0.01638154f, 0.01334403f, -0.03135220f, 
    -0.02722726f, -0.03513078f, 0.01013973f, -0.01684305f, -0.00308888f, -0.00852628f, 0.02007493f, -0.01490868f, 
    -0.01514070f, -0.01684018f, 0.00298158f, -0.01186548f, -0.00335830f, -0.01677947f, 0.01269838f, 0.02867522f, 
    -0.00175477f, -0.01129675f, 0.02887115f, -0.01293535f, -0.03209627f, -0.02604526f, -0.01929618f, -0.03763930f, 
    -0.03829742f, -0.00691624f, -0.03109380f, 0.01282766f, -0.02381081f, 0.00450738f, -0.01770876f, 0.02200441f, 
    0.00862099f, -0.01412080f, -0.01127807f, 0.01844914f, -0.00895905f, -0.03419000f, -0.00489927f, -0.03761665f, 
    0.00983611f, -0.01251760f, 0.01312803f, -0.02056234f, 0.03229328f, -0.00165436f, 0.02001024f, -0.00395737f, 
    -0.02610650f, -0.01951220f, -0.01186692f, 0.00447966f, 0.00461111f, 0.01590983f, -0.03659394f, -0.00820421f, 
    0.03034233f, 0.01145583f, 0.01419270f, 0.01070701f, -0.01220858f, 0.01992656f, 0.02659454f, -0.02869283f, 
    0.00576713f, -0.03426661f, -0.01350632f, 0.00296294f, -0.03198174f, 0.03240101f, -0.03102771f, -0.00575555f, 
    -0.01408203f, 0.01202825f, 0.03163831f, 0.00654805f, -0.02409109f, 0.01488312f, 0.01163885f, -0.03270067f, 
    0.00956783f, 0.00236459f, -0.01169346f, -0.00255948f, -0.00393292f, -0.02944487f, -0.01417289f, 0.02205630f, 
    -0.02423861f, -0.02266855f, 0.02123368f, -0.03303033f, 0.00750780f, 0.00311662f, 0.00334029f, 0.03133124f, 
    -0.03727612f, 0.01139103f, 0.01613438f, -0.01657774f, -0.01117597f, 0.01305608f, -0.01916723f, 0.00417385f, 
    0.01525564f, -0.00278052f, 0.01478067f, -0.00167144f, 0.02139507f, -0.03215228f, -0.03786631f, 0.01481378f, 
    0.00537493f, -0.00170885f, -0.00112666f, -0.03368983f, 0.01902600f, 0.01693161f, -0.03938923f, -0.01943325f, 
    -0.01609122f, -0.01841164f, 0.03203392f, 0.02233427f, 0.00276770f, -0.02616340f, 0.01344135f, -0.00180816f, 
    -0.01522734f, 0.01369097f, -0.03814811f, 0.02885853f, 0.00798525f, 0.00174979f, -0.03576547f, -0.03815820f, 
    0.02799301f, -0.00654340f, -0.01203500f, -0.01341175f, 0.02630475f, 0.00379564f, 0.00691544f, -0.02454671f, 
    0.00015115f, -0.03549068f, -0.02584039f, -0.01145200f, 0.02152281f, 0.00907015f, 0.01348036f, -0.01155573f, 
    -0.03089722f, -0.03452824f, -0.01669677f, 0.02627125f, 0.00080343f, -0.02746343f, -0.02871580f, 0.00746731f, 
    -0.01079468f, -0.00577512f, 0.00783578f, -0.01348627f, 0.00837954f, -0.02434810f, -0.03467459f, 0.01624238f, 
    0.02162082f, -0.00518065f, 0.00228271f, 0.00602460f, -0.02375802f, 0.00271778f, 0.00706361f, -0.00721512f, 
    -0.00493565f, -0.00913545f, -0.02521219f, 0.00248014f, -0.03972412f, 0.00336968f, 0.00667859f, -0.03848156f, 
    0.00032248f, 0.02261727f, -0.03454373f, -0.03327074f, -0.01656684f, -0.01994298f, -0.03731612f, 0.02083989f, 
    -0.03935504f, 0.01986868f, -0.00600412f, 0.01193378f, -0.03969447f, 0.00543494f, -0.01895556f, 0.01302689f, 
    0.02434737f, -0.02876279f, 0.01990538f, 0.01660671f, -0.03103257f, -0.00926603f, 0.00969919f, -0.00571208f, 
    0.01858929f, -0.01827022f, 0.01339379f, -0.03169130f, -0.04282428f, -0.01873079f, 0.01724183f, 0.00244962f, 
    -0.03998197f, 0.00626513f, -0.03319211f, -0.01154155f, -0.00295441f, 0.02687174f, 0.01962427f, -0.02629794f, 
    0.02202471f, -0.00870775f, 0.01433582f, -0.03449692f, -0.01353485f, -0.01980440f, -0.00042101f, 0.00414850f, 
    0.02633522f, -0.01927442f, -0.03126196f, 0.02018536f, -0.03557065f, 0.01772798f, 0.00330591f, -0.02056109f, 
    0.00606742f, -0.01206578f, 0.01335969f, 0.03263799f, 0.01312553f, -0.02155149f, -0.00502063f, 0.01080910f, 
    -0.02667685f, 0.01524884f, -0.03129649f, 0.02675901f, 0.01205336f, -0.02693362f, -0.03182477f, 0.02727403f, 
    -0.00131664f, 0.01740686f, -0.02243266f, -0.03331264f, -0.04388788f, 0.00609788f, 0.01746553f, -0.00774511f, 
    -0.02073849f, -0.02824296f, -0.03142523f, 0.00478728f, -0.03943188f, -0.02664845f, -0.02045957f, 0.02427658f, 
    -0.01084102f, -0.00715362f, 0.01785505f, 0.00546668f, -0.02661732f, 0.00489749f, -0.01289293f, -0.01202331f, 
    -0.03617978f, -0.02650230f, 0.01504873f, -0.03084304f, -0.01112058f, 0.00515052f, -0.02409595f, 0.00050154f, 
    -0.03861849f, -0.03562610f, -0.00566276f, -0.04232652f, -0.03483897f, -0.02662213f, -0.01988538f, 0.02697879f, 
    0.01408993f, 0.01362894f, -0.01652249f, -0.03839019f, 0.01004788f, 0.01016254f, -0.03067107f, -0.03933388f, 
    0.01465356f, 0.00412685f, 0.01754285f, -0.02321158f, -0.03440099f, -0.04078120f, 0.00482848f, -0.00199787f, 
    0.01842514f, 0.01412757f, 0.00507355f, -0.01583103f, -0.01610789f, -0.02519829f, -0.03220770f, 0.00688825f, 
    -0.02414528f, -0.04059762f, 0.00639483f, -0.00707676f, 0.01116313f, -0.01085519f, 0.00277229f, 0.01952701f, 
    -0.03160117f, -0.04116875f, 0.02588634f, 0.00573835f, -0.01563011f, -0.03506044f, 0.02161690f, 0.00000404f, 
    -0.02242382f, -0.02752798f, -0.00432647f, -0.02509610f, -0.01409404f, -0.03550335f, 0.02438762f, 0.01271134f, 
    -0.01351335f, -0.01484533f, 0.02204931f, -0.01677966f, 0.01142213f, -0.03934254f, 0.00546045f, 0.01109107f, 
    -0.03238064f, 0.01989802f, 0.01767369f, -0.03504909f, -0.03148323f, 0.01514526f, 0.01922965f, -0.00575783f, 
    -0.03614999f, -0.03092917f, -0.02737432f, -0.01868154f, -0.00449086f, 0.02319791f, 0.00660698f, 0.01524513f, 
    -0.00468905f, -0.01742127f, 0.02925099f, -0.03391169f, -0.01553513f, -0.02578044f, 0.00598570f, 0.02446737f, 
    -0.00571406f, -0.03798592f, -0.00681325f, -0.01381033f, 0.00933943f, 0.01575124f, -0.03002558f, 0.02478072f, 
    -0.00505086f, 0.01890848f, 0.00565439f, -0.01161469f, -0.01553814f, -0.04179623f, -0.00029276f, 0.00077819f, 
    -0.00061437f, -0.02825416f, 0.01947737f, -0.03916560f, -0.04416795f, 0.02805075f, -0.04147678f, -0.01318443f, 
    0.02270580f, -0.00565318f, 0.00822773f, 0.01118045f, -0.01700174f, 0.01427224f, -0.03108720f, 0.01914980f, 
    0.02376403f, -0.03132859f, -0.00212932f, 0.02196562f, -0.01834982f, -0.01397963f, -0.01759682f, -0.02759842f, 
    0.00113014f, 0.01908953f, -0.03068362f, -0.01457330f, -0.01717247f, 0.00600044f, -0.03520560f, 0.01110704f, 
    -0.00665597f, -0.00205994f, 0.00149163f, -0.03970243f, 0.00886591f, 0.00684325f, -0.04085279f, -0.04151278f, 
    -0.00183878f, -0.03371085f, -0.00701654f, -0.00648773f, -0.03060169f, 0.00032947f, -0.04235551f, 0.00600866f, 
    -0.02132943f, -0.02168258f, -0.01031828f, 0.02563575f, -0.01594904f, -0.03576648f, -0.00516359f, -0.01730664f, 
    0.00488038f, 0.00342561f, -0.00824938f, -0.02626781f, -0.03387263f, -0.00876739f, 0.01462766f, -0.03120152f, 
    -0.01026718f, -0.01250236f, 0.01004691f, 0.00659539f, 0.00199587f, 0.01647036f, -0.03043012f, 0.00431879f, 
    0.01558748f, 0.00334193f, -0.04155897f, 0.02510816f, 0.02124476f, -0.03747060f, 0.00502482f, -0.04146919f, 
    0.02748919f, 0.01548405f, -0.04151564f, -0.00101745f, -0.00146362f, -0.03823743f, -0.03971425f, -0.00029513f, 
    -0.01863643f, 0.01766895f, -0.00744911f, -0.00770228f, -0.00629920f, -0.01479810f, -0.00199010f, -0.00847260f, 
    -0.00419203f, -0.02256253f, 0.00100840f, -0.02662008f, 0.00252553f, -0.03382144f, -0.03673895f, -0.00420524f, 
    0.00939474f, -0.01123497f, -0.01090633f, 0.01221665f, 0.02303127f, 0.01604716f, -0.02263038f, 0.00086552f, 
    -0.00096147f, -0.01723849f, 0.00997527f, 0.01733136f, -0.03703112f, 0.00398053f, 0.01953015f, -0.03393731f, 
    -0.00721873f, -0.00251267f, -0.02052951f, -0.04065236f, -0.00368122f, 0.02244541f, -0.01671758f, 0.02515737f, 
    -0.02092435f, 0.02594364f, -0.02770715f, 0.01887385f, 0.02270264f, -0.00166408f, 0.01649321f, -0.00468117f, 
    -0.03223455f, -0.02837001f, -0.02525757f, 0.02524940f, 0.01682229f, -0.04170160f, -0.00571652f, -0.02264708f, 
    -0.03839268f, 0.02369716f, 0.02157859f, -0.00514535f, 0.02570656f, 0.00010451f, -0.04138612f, 0.02252693f, 
    -0.00387448f, -0.01597086f, -0.00832684f, 0.01037528f, -0.02586180f, -0.00168579f, 0.00643735f, -0.02068867f, 
    0.00491588f, -0.02557538f, -0.01092519f, -0.00836658f, -0.01233509f, 0.02042423f, -0.01867284f, -0.01582403f, 
    0.01164129f, 0.01746300f, 0.01754152f, -0.04333803f, -0.01935601f, -0.03786849f, -0.03003807f, -0.01379825f, 
    0.00719027f, -0.03478450f, -0.00073598f, 0.00002757f, -0.02142617f, -0.02729312f, -0.00128584f, 0.00766685f, 
    0.01852842f, 0.00406250f, 0.01674780f, 0.01242338f, -0.03722554f, 0.00973392f, -0.02582254f, -0.02719721f, 
    0.02679837f, 0.01292385f, -0.03383786f, 0.02340638f, 0.01628734f, -0.02911858f, -0.00485953f, -0.03892443f, 
    0.02446865f, 0.01572257f, 0.00603020f, 0.02311261f, -0.01870085f, 0.02268448f, 0.02215847f, 0.02679501f, 
    -0.01847642f, -0.00208532f, -0.01274133f, 0.00970889f, -0.03039062f, 0.00219890f, -0.02613829f, -0.03864244f, 
    -0.01796368f, 0.02166258f, -0.03510846f, 0.01529667f, -0.02922293f, 0.01846764f, -0.03898700f, -0.03100893f, 
    0.00547474f, 0.01358815f, -0.00804347f, -0.01330429f, -0.01494881f, -0.01639680f, -0.00467096f, 0.00380280f, 
    -0.00329113f, -0.00526070f, -0.03729825f, -0.03233951f, 0.00046087f, 0.02187265f, -0.02979537f, 0.02073326f, 
    0.02416668f, 0.01029299f, 0.00857385f, 0.02828196f, -0.00665662f, -0.01422252f, 0.01011912f, 0.00514130f, 
    0.00904788f, -0.03459856f, -0.00417511f, -0.04154235f, -0.00353818f, 0.00858729f, 0.00793564f, 0.02155041f, 
    -0.02712361f, -0.01971357f, -0.02412868f, -0.00732352f, 0.02630912f, -0.00137258f, 0.01363850f, -0.01119237f, 
    -0.04143324f, 0.01336541f, 0.00430988f, -0.03543866f, 0.01172761f, -0.01790671f, -0.01664031f, -0.01187756f, 
    0.02342549f, -0.00634783f, 0.00776690f, -0.00859424f, 0.01580953f, 0.02544439f, -0.00092280f, -0.01153094f, 
    0.02196649f, -0.02558661f, 0.00963949f, -0.00369418f, -0.03767789f, -0.00999737f, -0.01496381f, 0.01713592f, 
    -0.01553470f, 0.01651293f, 0.00009488f, 0.00068734f, -0.02503921f, -0.04306072f, 0.02568994f, 0.01785532f, 
    -0.00505854f, -0.00296121f, -0.02110229f, -0.02038666f, -0.01022258f, -0.01028019f, 0.01226499f, 0.01096327f, 
    0.00651408f, -0.00688822f, -0.02138522f, -0.00994020f, 0.00352462f, -0.02069506f, -0.04121605f, 0.02532138f, 
    0.01867484f, 0.01769325f, 0.02367423f, 0.00809455f, 0.02781429f, -0.02844012f, -0.03728539f, -0.00186645f, 
    -0.03723814f, 0.00991549f, -0.03805271f, -0.03074726f, -0.00042099f, -0.02819859f, -0.00565030f, -0.02194266f, 
    0.02358757f, -0.02041411f, -0.00413982f, 0.01904623f, -0.00806261f, -0.02314797f, -0.04191089f, -0.01668995f, 
    -0.03701813f, -0.04197015f, -0.01661421f, 0.02068556f, -0.02309261f, -0.02570307f, -0.03638506f, 0.01071963f, 
    -0.00988026f, 0.02230649f, -0.01793699f, 0.02000206f, -0.01844601f, 0.01431750f, -0.00807672f, -0.03685569f, 
    -0.02949502f, 0.00748562f, 0.01781910f, -0.00996681f, 0.01823047f, -0.03516283f, 0.01168495f, -0.01702529f, 
    0.01543353f, 0.02270973f, -0.02560593f, 0.00917874f, -0.02231063f, -0.02413776f, 0.00686458f, -0.03649820f, 
    -0.00798928f, 0.01419857f, 0.01169096f, -0.01324823f, 0.01314020f, -0.04075782f, 0.00992444f, 0.00937183f, 
    0.00511592f, -0.00287384f, -0.00161531f, -0.00549928f, -0.00320743f, 0.02214340f, -0.02135347f, 0.00215463f, 
    0.00683847f, -0.03047229f, -0.03625029f, 0.01847256f, 0.02073077f, -0.04336260f, 0.02635092f, -0.04241116f, 
    -0.01164043f, 0.01893540f, -0.02003126f, -0.00850663f, -0.00781730f, 0.02303129f, -0.00787213f, 0.02332737f, 
    -0.00379181f, -0.01949867f, 0.00159924f, 0.00803203f, 0.02679905f, -0.02790006f, -0.00092691f, -0.04288523f, 
    0.02829129f, -0.02244278f, 0.02066539f, -0.00720738f, -0.02384390f, 0.00790133f, -0.00929346f, -0.02184099f, 
    -0.00577038f, -0.01307457f, -0.01630735f, -0.02179978f, 0.01735218f, 0.02061933f, -0.03142203f, 0.01258811f, 
    -0.00854147f, 0.01454490f, -0.01612910f, 0.02388608f, 0.01744354f, -0.00956088f, -0.01972255f, -0.01323265f, 
    -0.01543010f, -0.01323524f, -0.00657926f, -0.01420508f, -0.04210037f, -0.03911884f, -0.02419744f, -0.03307015f, 
    0.02639049f, -0.04059032f, -0.02521759f, -0.02023278f, -0.01535133f, 0.01276464f, -0.00274626f, -0.00846472f, 
    0.01883552f, -0.03207390f, -0.02197742f, 0.00915236f, -0.01633207f, 0.00286350f, -0.02162552f, -0.03748807f, 
    -0.00004722f, 0.01500127f, -0.00836329f, -0.01711944f, 0.01246216f, 0.02070715f, 0.00476348f, -0.02786428f, 
    -0.01354121f, 0.02867107f, 0.00507925f, 0.01678078f, -0.01054920f, -0.03531413f, -0.00182798f, -0.00560382f, 
    0.02740738f, 0.02027439f, -0.02264584f, 0.02492607f, -0.00802266f, -0.01724814f, 0.01960934f, -0.04093991f, 
    -0.02744359f, 0.02026998f, -0.03898735f, -0.02437069f, -0.00488739f, 0.01148178f, 0.02057448f, -0.02173960f, 
    0.00830323f, -0.03494343f, 0.00253519f, -0.03254408f, 0.01272196f, 0.00614418f, -0.03830962f, -0.02442944f, 
    -0.03594559f, -0.02219022f, 0.00569127f, -0.01143268f, -0.03271965f, 0.01755421f, -0.00917684f, 0.01822811f, 
    0.00910062f, 0.00274127f, -0.04124552f, -0.03139630f, -0.00167529f, -0.03519293f, -0.04162365f, -0.01202238f, 
    -0.04201273f, -0.00862057f, 0.02922479f, -0.01343418f, -0.03965757f, -0.03625961f, 0.01273134f, 0.00093982f, 
    0.00591945f, -0.00200808f, -0.00720457f, 0.02907237f, -0.03992724f, 0.01086747f, 0.01837623f, 0.02713290f, 
    -0.03164511f, -0.01755248f, -0.01306636f, 0.02683098f, 0.00529091f, -0.03972429f, 0.00943463f, -0.03607698f, 
    0.02201387f, 0.01880787f, -0.03631353f, -0.03556167f, -0.03492321f, 0.00294246f, -0.01697327f, -0.02652354f, 
    0.00658070f, 0.01981890f, -0.00533682f, -0.00300625f, -0.02437808f, -0.03449403f, -0.01064104f, -0.03572851f, 
    -0.00283175f, -0.02773652f, -0.02015197f, 0.00437996f, 0.02596874f, 0.02561950f, -0.02927413f, 0.00915306f, 
    0.02712261f, -0.00764249f, -0.00627454f, 0.00235107f, -0.00978934f, 0.02185499f, -0.01978389f, -0.02482812f, 
    0.01181618f, 0.01620484f, -0.00162494f, -0.03734729f, 0.02935462f, -0.00566911f, -0.04070547f, 0.02861186f, 
    -0.03880754f, -0.02080856f, 0.01196602f, 0.02139401f, 0.01584662f, 0.00458692f, -0.00921718f, -0.00370415f, 
    0.02969055f, 0.00035048f, -0.02561600f, -0.02167953f, -0.03467947f, -0.00745002f, 0.02557917f, -0.03029320f, 
    -0.03903409f, -0.00361964f, 0.01595565f, -0.02413425f, -0.00704134f, 0.00522760f, -0.03987116f, 0.01624488f, 
    0.03073010f, -0.02719375f, -0.01479282f, 0.01440666f, -0.01956649f, 0.00000817f, -0.02247875f, -0.01650164f, 
    -0.00159073f, -0.04046174f, -0.02273553f, -0.04076664f, 0.01122897f, -0.02869518f, -0.02423234f, -0.02208339f, 
    -0.00930085f, -0.02921178f, 0.02549988f, 0.00288218f, 0.00855224f, 0.00948352f, 0.01045598f, -0.00567467f, 
    -0.01317179f, 0.02253211f, 0.02382847f, -0.02969343f, 0.01070432f, -0.01309199f, -0.01121727f, -0.00602554f, 
    -0.01624314f, -0.01958647f, 0.02013399f, -0.00337582f, -0.01149793f, -0.02075120f, 0.02457063f, -0.01049495f, 
    0.00700502f, 0.01524231f, -0.00161524f, -0.02756814f, -0.01919760f, 0.01476235f, -0.04141919f, -0.02053667f, 
    0.01147104f, 0.02445062f, -0.02675873f, -0.01555106f, -0.03178773f, -0.03431587f, -0.01918547f, -0.03362028f, 
    0.01050922f, 0.01658996f, -0.02206039f, 0.02924314f, 0.02594867f, 0.01040684f, 0.01927634f, -0.01607160f, 
    -0.02456499f, 0.02238146f, -0.02203617f, -0.03855615f, -0.02246439f, 0.01304732f, -0.02925682f, -0.03126739f, 
    0.00576186f, -0.04107530f, 0.02105948f, -0.04116542f, -0.03308103f, -0.01412119f, -0.01287508f, -0.02779062f, 
    0.01591017f, -0.02556926f, -0.00943471f, 0.00888280f, -0.04024203f, 0.01599989f, 0.00725678f, 0.02108372f, 
    0.02466334f, 0.01863920f, 0.01136755f, -0.02548807f, 0.01244382f, 0.02199357f, -0.01778690f, 0.02899252f, 
    -0.03734943f, -0.02133879f, 0.01046722f, -0.00801674f, 0.01199693f, -0.04022105f, 0.00620340f, -0.01424596f, 
    0.02530486f, -0.03757029f, -0.01377437f, 0.02243799f, 0.00904765f, -0.02521688f, -0.02898586f, 0.01874249f, 
    -0.00427431f, -0.03816724f, -0.00609951f, -0.03180059f, -0.02721719f, -0.00346314f, -0.01421453f, -0.02582452f, 
    -0.03701632f, -0.03861264f, -0.01385492f, -0.04127635f, 0.02013933f, -0.03661693f, -0.02510654f, 0.02974857f, 
    0.04084534f, -0.01612833f, 0.02864306f, -0.03399403f, -0.02446962f, -0.00515599f, -0.02176725f, -0.03978460f, 
    0.00684665f, -0.01236852f, -0.02820467f, 0.01437571f, -0.02983483f, -0.03096760f, 0.02668721f, -0.02794503f, 
    0.02145885f, -0.02059599f, 0.00731263f, -0.03478095f, -0.03299321f, -0.02307541f, -0.01886007f, -0.02444784f, 
    0.02150629f, -0.01972642f, -0.01417958f, -0.01269205f, 0.02697868f, -0.03752196f, -0.03969306f, -0.02619035f, 
    -0.02222847f, -0.00055622f, -0.01421985f, -0.03780657f, 0.01979476f, -0.02353837f, 0.01123585f, -0.03504208f, 
    -0.00358579f, 0.02051625f, -0.02694974f, -0.01041425f, 0.02688748f, 0.02243029f, 0.01254070f, -0.02685522f, 
    -0.01400248f, -0.00234653f, -0.01840472f, -0.01134237f, -0.02361154f, -0.00428842f, -0.00256827f, -0.02911173f, 
    -0.01342341f, -0.02307047f, 0.02733002f, 0.00924022f, -0.03468969f, 0.01841174f, 0.02612766f, -0.04045887f, 
    -0.00374716f, 0.01476809f, 0.01618307f, -0.02418396f, -0.00580526f, 0.00591801f, 0.00619296f, 0.00183586f, 
    -0.02131541f, -0.02784733f, 0.00731874f, -0.00196858f, 0.01712288f, -0.03262440f, 0.00076441f, -0.01577838f, 
    0.00974322f, 0.01442812f, -0.02932090f, -0.00841671f, -0.03037147f, -0.00796113f, 0.00695676f, -0.01730780f, 
    -0.00379820f, -0.02751626f, 0.00109420f, -0.00818847f, -0.00816387f, -0.00702398f, 0.00459226f, -0.00007200f, 
    0.02456952f, -0.00751123f, -0.01902766f, 0.01405311f, -0.02515126f, 0.02059660f, -0.01120214f, 0.00371382f, 
    0.01797256f, -0.01969796f, 0.01770568f, -0.01711245f, -0.02306691f, 0.02655441f, -0.03071387f, -0.01958956f, 
    -0.03489499f, -0.00227796f, 0.00050578f, -0.00833224f, -0.00517391f, 0.01506810f, 0.02290265f, 0.02379074f, 
    0.02843018f, -0.03668007f, 0.01263531f, 0.01672631f, -0.00923147f, -0.02462216f, 0.00274120f, -0.02770746f, 
    -0.00168342f, -0.02525762f, 0.02131457f, -0.01296594f, 0.00635484f, 0.02902213f, -0.02052254f, -0.03141582f, 
    -0.00503276f, -0.01809423f, -0.03392550f, -0.03311428f, 0.01019534f, -0.01223488f, 0.02328457f, -0.03886038f, 
    0.00172887f, -0.03378026f, 0.01482410f, 0.00528664f, -0.01376695f, 0.00693421f, -0.03939974f, 0.01701469f, 
    -0.00196682f, -0.00917651f, 0.00478400f, -0.00691005f, -0.03800112f, 0.02241119f, -0.03241156f, -0.02654022f, 
    0.01032764f, -0.01745141f, -0.03360151f, 0.01015857f, 0.01206158f, 0.01805825f, 0.01611085f, -0.03589192f, 
    -0.03559875f, 0.02535487f, -0.02258737f, -0.02705855f, -0.01190833f, 0.01946562f, 0.00938072f, 0.02605569f, 
    0.00586797f, -0.01692570f, -0.02104770f, 0.02921774f, -0.00190520f, 0.01448695f, 0.00780249f, -0.00752102f, 
    -0.00561090f, -0.02153124f, -0.03150288f, -0.03901521f, -0.03315582f, 0.02493835f, 0.01758907f, 0.02437462f, 
    -0.02337291f, -0.01802472f, 0.00489869f, -0.00695183f, 0.00323780f, -0.03978259f, 0.00507511f, -0.02116057f, 
    0.01007455f, -0.00476905f, 0.02329655f, -0.04012818f, -0.02097372f, -0.01960096f, -0.00535129f, -0.03836427f, 
    -0.01159880f, -0.02772198f, -0.02037418f, 0.02076877f, -0.02450238f, 0.01069134f, -0.03127497f, -0.01536178f, 
    0.00666663f, -0.02548775f, -0.04140839f, 0.00785044f, -0.03430415f, -0.03066636f, 0.01745806f, -0.02033577f, 
    0.00746402f, -0.01614360f, -0.03712123f, 0.02841925f, -0.01765824f, 0.02884793f, -0.04131095f, 0.02163661f, 
    0.01070787f, 0.01471657f, 0.00463958f, -0.01631904f, 0.01574751f, -0.01981139f, -0.01171501f, 0.00916107f, 
    -0.04131379f, -0.00909149f, -0.02217351f, -0.00469363f, 0.00510112f, -0.00382133f, -0.04012469f, -0.00569467f, 
    -0.02982858f, 0.02106573f, -0.00606591f, -0.02414604f, -0.04145485f, 0.02478355f, -0.02902340f, -0.02057463f, 
    -0.00518553f, -0.02429014f, -0.02793490f, 0.02257440f, 0.01394509f, 0.03007694f, -0.03103219f, -0.01656313f, 
    0.01065283f, 0.01864754f, 0.01388800f, -0.04178561f, 0.01475982f, -0.01893475f, -0.01679580f, -0.01788919f, 
    0.00892576f, -0.01692628f, -0.00325927f, 0.01603228f, 0.00947253f, 0.00587647f, -0.03600366f, 0.02688910f, 
    0.00372526f, -0.03129059f, 0.00025035f, -0.00456472f, -0.02261467f, -0.02386000f, -0.00860491f, -0.03710435f, 
    0.01834837f, 0.02963619f, -0.02236477f, -0.03427235f, -0.00681248f, -0.01465275f, -0.03813903f, 0.01106123f, 
    0.02023714f, -0.03271132f, -0.00000033f, 0.02769971f, -0.01515987f, 0.00936579f, 0.00857337f, -0.01462550f, 
    0.00751526f, -0.03981622f, -0.03387500f, -0.02830544f, 0.02792245f, -0.01381069f, -0.01519764f, 0.02319411f, 
    0.02466594f, 0.00600283f, -0.02279188f, -0.00016546f, -0.03354536f, -0.01394426f, -0.01805292f, -0.00225564f, 
    0.00439669f, -0.01911484f, -0.03405604f, -0.03296567f, -0.03011274f, -0.00780468f, 0.01732688f, 0.00526327f, 
    -0.02064747f, -0.01372078f, 0.00773042f, 0.01299453f, 0.01939816f, 0.00302068f, -0.00471827f, -0.01101579f, 
    0.01059195f, -0.03540778f, 0.02102664f, 0.02236842f, -0.03464827f, 0.00595343f, -0.01808146f, -0.02405297f, 
    0.01054345f, -0.04097891f, 0.02773672f, -0.00728520f, 0.02024276f, -0.03869017f, 0.01738442f, 0.02814976f, 
    -0.00224103f, -0.03271476f, 0.02536041f, -0.01283794f, -0.02822543f, 0.02542249f, -0.02059176f, 0.00896035f, 
    0.02595286f, -0.02553730f, -0.03823164f, -0.03929438f, -0.01669802f, 0.01049795f, 0.00359437f, 0.01761137f, 
    0.01783974f, -0.00154993f, 0.00438041f, -0.03132195f, -0.02979006f, 0.01689177f, 0.00338599f, -0.01695923f, 
    0.02350151f, -0.01799566f, 0.01321327f, -0.00285767f, 0.02537628f, 0.01711541f, -0.01103940f, 0.02262419f, 
    0.02343048f, -0.01976711f, -0.03734909f, -0.01636310f, 0.00382000f, -0.00849640f, -0.02442153f, 0.02221338f, 
    -0.03049096f, 0.02353104f, -0.03664695f, -0.00574283f, -0.01884759f, 0.00399879f, -0.03548321f, 0.02825347f, 
    0.01169077f, 0.01751024f, 0.02794543f, -0.01394168f, -0.00721148f, 0.01266981f, -0.02805725f, -0.00216570f, 
    -0.01548236f, 0.01137536f, 0.01062641f, 0.01718768f, -0.00916878f, -0.02556491f, 0.02992510f, 0.01334771f, 
    -0.03691952f, -0.04098522f, -0.01753468f, 0.02778460f, 0.02950863f, -0.00866679f, -0.01153340f, -0.01788913f, 
    -0.03960502f, 0.02304546f, 0.00793336f, -0.02578261f, 0.01737794f, -0.02921742f, -0.03345976f, 0.01576965f, 
    -0.01625391f, -0.02013422f, -0.01824107f, 0.02369957f, 0.00571722f, -0.00550673f, 0.01318291f, 0.01420484f, 
    0.00533327f, -0.02726050f, -0.01692456f, -0.03707053f, 0.01465772f, 0.00597473f, -0.03835315f, -0.00034925f, 
    0.01407127f, 0.02957149f, -0.01880265f, -0.01125100f, -0.03565598f, 0.02947438f, 0.02527285f, 0.01155784f, 
    0.02785170f, -0.01310975f, -0.01916133f, -0.01893569f, 0.00647507f, -0.01678927f, -0.00856011f, -0.02707965f, 
    0.02301557f, 0.00021424f, -0.01018345f, 0.00428640f, -0.00092701f, 0.02839484f, 0.01740151f, 0.02885480f, 
    -0.02908718f, -0.04031318f, -0.02488805f, -0.01966446f, -0.02852584f, -0.02029100f, 0.02352932f, -0.02803157f, 
    0.02004708f, -0.03242473f, -0.02373436f, -0.04051824f, 0.01332740f, -0.01521632f, 0.00588787f, -0.00584968f, 
    0.02961578f, 0.01132324f, -0.00019226f, -0.03837584f, -0.01395220f, -0.03565550f, -0.03819052f, -0.02065897f, 
    -0.01999029f, -0.03381398f, -0.00527189f, 0.02217951f, 0.01152801f, -0.00637121f, 0.02284201f, 0.02355290f, 
    -0.02400582f, 0.01943745f, -0.01078118f, 0.01434140f, 0.00564939f, 0.02185901f, 0.01481812f, -0.03990337f, 
    0.02547340f, 0.02825572f, 0.01353468f, -0.03357847f, -0.02879711f, 0.01696192f, -0.03226199f, -0.01550988f, 
    -0.03008458f, -0.04122201f, -0.00312189f, 0.00899842f, 0.00007067f, -0.02093814f, -0.00019302f, -0.01919450f, 
    -0.00174441f, 0.00439543f, -0.01886302f, -0.04077716f, 0.00800022f, -0.00357034f, -0.01466361f, -0.03134035f, 
    -0.00862520f, -0.02069855f, 0.02810807f, -0.03914273f, 0.00678916f, -0.02202749f, 0.00089172f, -0.03874152f, 
    -0.02479722f, 0.00453251f, 0.02669817f, 0.00823349f, -0.02327415f, -0.01073388f, -0.03811086f, 0.02137263f, 
    -0.17771459f, 0.12719217f, 0.16472460f, 0.09234039f, 0.00341344f, -0.09299566f, 0.04618435f, -0.02428735f, 
    0.10285122f, 0.04930393f, 0.11355822f, -0.03910071f, 0.00308519f, 0.02516929f, -0.05147856f, -0.12851654f, 
    -0.12095274f, 0.00020243f, -0.00738449f, 0.03453415f, -0.00777892f, -0.00032875f, -0.00660618f, -0.04293740f, 
    0.33333415f, 0.08878071f, 0.05933554f, 0.05603790f, 0.01944136f, -0.04518830f, 0.03472582f, 0.01892194f, 
    -0.01480249f, -0.00485440f, -0.01367546f, 0.01474672f, -0.16480424f, -0.06882938f, -0.25529668f, -0.08093441f, 
    -0.03529923f, -0.10464421f, -0.08697068f, 0.06509134f, -0.06389743f, -0.04477881f, 0.01351483f, 0.00499340f, 
    -0.32746866f, -0.04178672f, -0.04296749f, -0.13545026f, -0.08373522f, -0.01283079f, -0.03532086f, -0.07114144f, 
    -0.07959335f, -0.02486003f, -0.19059005f, 0.10149705f, 0.00549386f, 0.06672546f, 0.11307659f, -0.01644023f, 
    -0.05009605f, 0.09201531f, 0.12127483f, 0.03019602f, -0.06484326f, 0.07136267f, -0.00858374f, -0.03278643f, 
    0.11085144f, 0.32977635f, 0.12937149f, -0.03186087f, 0.02833975f, 0.11184885f, 0.06612683f, 0.02951690f, 
    0.00542309f, 0.03100201f, -0.11557332f, 0.05118581f, -0.00433130f, -0.07478454f, -0.12536727f, -0.03024425f, 
    -0.05609931f, 0.02375432f, 0.05488613f, -0.14545549f, 0.07235806f, 0.05850222f, 0.03089915f, -0.07512073f, 
    -0.13607979f, 0.29378444f, -0.13561475f, 0.03104426f, 0.04448118f, 0.06095959f, -0.07618925f, 0.07422760f, 
    -0.00154439f, 0.08813503f, -0.01997790f, 0.05502967f, 0.23590790f, 0.13802691f, 0.39288259f, -0.15213178f, 
    -0.06401771f, 0.02463217f, -0.03347059f, 0.07327217f, 0.13360952f, -0.01760657f, -0.01914668f, -0.09974528f, 
    -0.06802918f, -0.15695812f, -0.14893173f, 0.04021154f, -0.03538657f, -0.06503516f, 0.01768056f, -0.05365647f, 
    0.00387587f, 0.06740770f, -0.12614718f, 0.08018968f, -0.23865785f, -0.03957677f, -0.18848221f, 0.11694998f, 
    -0.11696389f, -0.05417307f, -0.09890371f, 0.10421709f, -0.02959429f, -0.00802803f, -0.14417610f, 0.00623981f, 
    0.10351307f, -0.07238060f, -0.12259198f, 0.00925559f, 0.02838391f, -0.05429899f, -0.00276001f, 0.06365284f, 
    0.04287796f, -0.01664412f, 0.01135398f, -0.06695072f, 0.04366577f, 0.07704236f, 0.18235014f, -0.16711226f, 
    -0.08553700f, 0.09355342f, 0.14086801f, -0.01785322f, -0.01675428f, 0.05307142f, -0.03326837f, -0.02856680f, 
    0.22760162f, 0.07697517f, 0.25110653f, -0.29248127f, 0.01544600f, -0.00199517f, -0.03994879f, 0.20327817f, 
    0.07928985f, 0.02894751f, -0.05113061f, -0.00141818f, -0.34601021f, 0.13525155f, -0.07852318f, 0.02222122f, 
    -0.01370623f, 0.06076764f, 0.04096351f, -0.01873049f, 0.20265269f, 0.17657070f, 0.14622688f, -0.00833917f, 
    -0.24388999f, -0.18217418f, -0.18417700f, -0.09712484f, -0.11210660f, -0.03906927f, 0.01567669f, -0.07888268f, 
    -0.12720090f, -0.04642818f, 0.03357220f, -0.02368752f, 0.14205307f, 0.15079555f, -0.04058792f, -0.08663449f, 
    -0.00574476f, 0.09712999f, 0.02971943f, -0.03630339f, 0.03326935f, 0.22288193f, 0.07178818f, 0.00693903f, 
    -0.38579130f, 0.17171906f, -0.08871980f, 0.15359543f, -0.00718852f, -0.02064628f, 0.07138363f, 0.09737698f, 
    -0.01298072f, 0.13547795f, -0.02070914f, 0.11547252f, -0.08605324f, -0.21391711f, -0.22154906f, -0.03168889f, 
    0.02179622f, 0.18644008f, 0.07735957f, 0.00289804f, 0.18516749f, -0.04139094f, -0.02303044f, -0.01047169f, 
    0.05324122f, -0.12253791f, 0.05861886f, 0.14678259f, 0.06941018f, 0.02571240f, -0.12741296f, -0.02002134f, 
    -0.05458870f, -0.01912337f, -0.05604891f, -0.09400373f, -0.28848541f, 0.16645774f, 0.10348644f, -0.08569244f, 
    -0.10119180f, 0.00610892f, -0.01209529f, 0.00709542f, 0.04528757f, -0.01116898f, 0.01294168f, 0.00071835f, 
    0.27695072f, 0.28835326f, 0.12545770f, -0.23033674f, 0.16426031f, 0.14352094f, -0.01417149f, 0.01196041f, 
    0.03644427f, 0.01082043f, 0.00899612f, 0.02004368f, -0.14079335f, -0.07177224f, -0.07596006f, 0.12288173f, 
    -0.06709094f, 0.04702096f, -0.02925839f, -0.02280557f, 0.04761296f, 0.04052968f, 0.13832003f, -0.02056492f, 
    -0.05880149f, 0.16085461f, 0.01536035f, -0.22954895f, 0.10375090f, -0.09052534f, -0.06713303f, 0.02187762f, 
    0.10082537f, 0.05113506f, -0.04739465f, 0.25830200f, 0.04370150f, -0.20916699f, 0.01326376f, -0.23263583f, 
    0.14227569f, 0.00936177f, 0.02414760f, 0.02324381f, 0.06891282f, 0.15509652f, 0.00173629f, 0.21091647f, 
    -0.01939317f, 0.08073380f, 0.10612790f, -0.02681184f, 0.05380876f, 0.10613010f, 0.00419007f, 0.03603268f, 
    -0.07632256f, -0.00954570f, 0.03895395f, -0.03205974f, 0.23970802f, 0.07358693f, -0.11629817f, -0.13470168f, 
    0.01270065f, 0.01959539f, 0.00940189f, 0.05047687f, -0.04654758f, 0.00797330f, 0.02438718f, -0.00356773f, 
    -0.06136072f, -0.04905925f, 0.17444493f, 0.18771894f, 0.08746610f, 0.00663230f, -0.19306026f, -0.00853623f, 
    0.06547901f, 0.01018282f, 0.11868670f, 0.12172975f, 0.20761082f, 0.10034055f, 0.08502141f, 0.34260073f, 
    -0.10006132f, -0.04771321f, -0.05155038f, -0.11572441f, -0.05140787f, 0.03095759f, 0.05577099f, 0.07797671f, 
    0.28773820f, -0.14375754f, -0.14209263f, -0.07709521f, -0.04858244f, 0.00535765f, 0.10298283f, -0.02086164f, 
    -0.10494357f, 0.01112977f, 0.04211095f, -0.05744936f, 0.00776066f, 0.17061482f, 0.10068979f, 0.13779290f, 
    0.08906595f, 0.03785872f, -0.14150003f, -0.09418103f, -0.03909109f, 0.15466258f, 0.04685981f, 0.00593568f, 
    -0.08577917f, 0.31447509f, 0.19388044f, 0.25858587f, 0.03783599f, 0.08016202f, 0.06192145f, 0.01274670f, 
    0.05630577f, 0.04875465f, 0.02394248f, -0.02702121f, 0.25862885f, 0.21106964f, 0.05051338f, -0.02934773f, 
    0.01253961f, 0.07072698f, -0.06490381f, 0.13917105f, -0.00588634f, 0.15326753f, 0.05373669f, 0.02277132f, 
    -0.10097414f, 0.10906019f, 0.22241333f, 0.03790005f, 0.02637344f, -0.03755298f, 0.04744404f, 0.14905319f, 
    0.06056859f, 0.07743932f, 0.03316657f, 0.15155602f, 0.12421396f, -0.06364292f, 0.07898097f, 0.16219065f, 
    0.01798016f, 0.11490661f, -0.04371918f, -0.12653580f, -0.08870672f, -0.02404570f, 0.03674420f, 0.06827314f, 
    -0.22997779f, -0.08170228f, 0.03479661f, -0.06435675f, 0.07042788f, -0.04759985f, -0.06716017f, 0.04775700f, 
    0.08822476f, 0.13167095f, 0.00386194f, 0.09223828f, -0.23934123f, 0.22229357f, 0.06125840f, 0.22476105f, 
    0.11626770f, 0.07073525f, 0.06407695f, -0.03092616f, -0.09985583f, 0.05574254f, 0.02106147f, -0.03967651f, 
    -0.08078686f, 0.14087823f, 0.11846817f, 0.36062789f, 0.02856558f, 0.09140769f, -0.05975606f, 0.12334437f, 
    0.02811714f, -0.00377284f, 0.05580826f, 0.01599608f, 0.04570602f, -0.05905262f, 0.13739090f, -0.04892841f, 
    0.06323288f, 0.03300532f, -0.05099215f, -0.00014086f, 0.03469642f, -0.00313720f, -0.09036291f, 0.12248319f, 
    -0.27595392f, -0.03209409f, 0.11070229f, 0.13961679f, -0.07547668f, -0.12189078f, 0.05125597f, 0.03221186f, 
    -0.08047225f, 0.17667682f, -0.14983235f, 0.00940800f, 0.06033813f, 0.14209844f, 0.08122807f, 0.21218632f, 
    0.10280953f, 0.02526488f, 0.00669295f, 0.11539268f, 0.00482257f, 0.04526364f, 0.08714654f, 0.01323545f, 
    0.10749504f, 0.03860646f, -0.09849341f, -0.16198434f, -0.01316300f, -0.03547247f, -0.04593932f, -0.06396434f, 
    0.02436713f, -0.11015622f, -0.06996535f, -0.16189840f, 0.01736457f, 0.37068358f, 0.07498834f, 0.10473607f, 
    0.07532322f, 0.06445573f, -0.11420168f, 0.02649499f, -0.05378396f, 0.04561377f, 0.02635885f, 0.02733417f, 
    0.28364536f, 0.05689932f, 0.03869360f, 0.44186890f, 0.09350826f, 0.07232729f, 0.07441160f, 0.00080349f, 
    0.03247370f, 0.02343919f, 0.00779746f, 0.00312626f, -0.00213775f, 0.14241457f, -0.24309228f, -0.14631948f, 
    0.13661583f, 0.01994448f, 0.05445733f, -0.02109399f, 0.15363926f, -0.04386528f, 0.05740814f, -0.01570684f, 
    0.15118021f, 0.22012968f, -0.03400541f, -0.15788174f, 0.11284063f, -0.01420864f, -0.05720834f, -0.06739894f, 
    0.07722976f, -0.07327481f, 0.02290131f, 0.07320945f, -0.23805702f, -0.01015688f, 0.08131056f, 0.13800047f, 
    -0.05756844f, -0.00985625f, -0.04186366f, 0.01434908f, 0.04542805f, -0.00805365f, 0.08777855f, -0.04280153f, 
    0.46952385f, 0.10433777f, -0.05633829f, -0.26046103f, 0.04205694f, 0.01912200f, 0.09059116f, 0.06247331f, 
    0.03646898f, -0.00082718f, -0.12693016f, -0.07494969f, 0.04279767f, 0.02469427f, 0.10243687f, 0.14628515f, 
    -0.01290848f, 0.06283878f, 0.05910018f, 0.04676786f, -0.06396420f, 0.05660666f, -0.14096768f, 0.09974793f, 
    0.17906867f, -0.04115255f, 0.00855416f, -0.22167084f, -0.01016846f, 0.07999986f, 0.02832830f, 0.06535269f, 
    -0.04560087f, 0.04326125f, -0.01477872f, 0.09430454f, -0.17163171f, -0.10674254f, -0.16494459f, -0.02045254f, 
    -0.01855208f, 0.02117743f, -0.02152265f, -0.05618065f, -0.01390585f, -0.01408879f, -0.07739657f, -0.06205948f, 
    0.01149001f, 0.03088020f, 0.15201722f, -0.12021042f, -0.00540683f, 0.04575158f, 0.00452980f, -0.06879497f, 
    0.07041850f, -0.05246300f, 0.04250007f, 0.08062344f, 0.03022720f, 0.02465189f, -0.19946441f, -0.17638533f, 
    0.00187888f, 0.05377654f, 0.04108341f, 0.05128553f, 0.04566875f, -0.00800872f, -0.09482431f, -0.10548082f, 
    -0.16190521f, -0.17730005f, -0.15021540f, 0.02573837f, -0.02876105f, -0.15531407f, -0.10899999f, -0.03302622f, 
    0.10969378f, 0.01263324f, -0.00855000f, 0.03484950f, -0.05284173f, 0.09592662f, 0.11838705f, 0.03063627f, 
    0.00051829f, 0.00913549f, -0.03386877f, 0.09027476f, 0.11308386f, -0.09163182f, -0.01639187f, -0.01610520f, 
    0.19717360f, 0.11809211f, 0.03151238f, 0.06100175f, 0.07580969f, 0.00163268f, 0.01844556f, 0.13344827f, 
    0.05272210f, -0.01124593f, 0.04924421f, 0.08324683f, 0.32554683f, -0.03360754f, -0.06724461f, 0.11360443f, 
    -0.05673101f, 0.01434401f, -0.04601319f, 0.12971656f, -0.00962263f, -0.08467972f, 0.06891528f, -0.14924361f, 
    -0.17662403f, 0.13502544f, -0.05716544f, 0.08991930f, 0.02149591f, -0.05176900f, -0.00390350f, -0.00161679f, 
    0.00890432f, -0.03629211f, 0.04674181f, -0.01667634f, -0.19551547f, -0.05454477f, -0.02451919f, 0.26497903f, 
    -0.17192338f, -0.02209319f, -0.04932823f, -0.14501098f, -0.01169476f, -0.10011715f, -0.00291841f, 0.04686077f, 
    0.02550005f, 0.05758613f, 0.12214094f, -0.03161011f, -0.06494417f, -0.02526126f, 0.09473543f, 0.08236607f, 
    -0.12374628f, 0.20198657f, -0.04150056f, -0.04519730f, 0.29653218f, -0.09617209f, 0.01810349f, 0.09093837f, 
    -0.02801085f, 0.00040990f, 0.01859488f, -0.06766808f, 0.02456005f, 0.01345312f, 0.02783012f, -0.16054080f, 
    0.44979453f, 0.23678933f, 0.06729869f, -0.01017431f, 0.07789192f, 0.04807704f, 0.03196153f, 0.01985685f, 
    -0.11145822f, 0.12768137f, -0.10626297f, -0.00683678f, -0.20847677f, -0.25185493f, 0.05941171f, -0.12841810f, 
    -0.14357932f, 0.04395489f, -0.03859923f, -0.07222458f, -0.00311132f, -0.07594986f, 0.03920163f, -0.04921896f, 
    -0.03470211f, 0.02752773f, -0.03850806f, -0.03035378f, 0.02221697f, 0.03999117f, 0.01274393f, 0.00453751f, 
    -0.02492482f, 0.03172667f, 0.00782605f, -0.00123551f, -0.00859332f, 0.02845751f, -0.00494817f, 0.02566492f, 
    -0.00700327f, 0.00594471f, 0.00605872f, -0.01299469f, 0.00864027f, 0.02678405f, 0.02598634f, -0.00614407f, 
    -0.02779368f, -0.00407283f, -0.01535526f, -0.02419041f, 0.02121908f, -0.01684672f, -0.01833176f, -0.00324494f, 
    -0.03556577f, 0.02572878f, 0.00823043f, 0.01900202f, 0.01393510f, 0.00109780f, 0.01195365f, 0.01995961f, 
    -0.00446962f, -0.01293668f, -0.00089857f, 0.00954917f, -0.00911442f, -0.02193167f, -0.02745555f, -0.02468732f, 
    0.02895353f, 0.03913960f, -0.02304596f, -0.04104346f, -0.04032413f, 0.02126716f, -0.04048859f, -0.03680449f, 
    0.01294380f, 0.02974404f, 0.01966524f, 0.00801075f, -0.01208663f, -0.00944231f, 0.02353223f, -0.01380266f, 
    -0.02383419f, -0.00820431f, 0.00534364f, 0.02627084f, -0.02817257f, -0.01225828f, -0.00968952f, -0.03171996f, 
    -0.02171784f, 0.02149606f, 0.02458142f, -0.00926583f, -0.02236108f, -0.01087073f, -0.01361115f, -0.01914265f, 
    -0.03777405f, 0.01639810f, -0.00938433f, -0.00098275f, -0.00231313f, -0.00036875f, -0.01665271f, 0.00183459f, 
    0.00691887f, 0.03585700f, 0.01567481f, 0.00588560f, 0.03196828f, 0.01750013f, -0.02695458f, 0.02428083f, 
    0.01863287f, 0.00318157f, -0.04062792f, 0.00933466f, -0.02877457f, 0.01071810f, 0.01356476f, 0.01982729f, 
    0.00248786f, -0.00387915f, 0.02560351f, 0.00091039f, -0.00659736f, 0.02575285f, 0.00370953f, -0.02791468f, 
    -0.00451889f, -0.01024863f, -0.02911655f, -0.02874851f, -0.00757826f, -0.00851811f, 0.00096285f, 0.01530825f, 
    0.02737662f, -0.02846399f, -0.01365883f, 0.02075300f, -0.02916048f, 0.01746299f, 0.00144025f, 0.01398775f, 
    -0.00503135f, 0.01253220f, -0.02212045f, -0.03939141f, -0.03712449f, -0.02595977f, 0.00789655f, -0.00340902f, 
    -0.02246500f, 0.01616683f, -0.03500816f, 0.01497700f, 0.00519348f, -0.03932341f, -0.00542425f, 0.00015188f, 
    -0.03030095f, -0.02321040f, -0.02950875f, -0.01495678f, -0.00154228f, -0.02754468f, 0.01019579f, -0.01984315f, 
    0.00441669f, 0.00709612f, -0.02900369f, -0.02851545f, -0.01100166f, 0.01642102f, -0.01099635f, -0.03258999f, 
    0.01426635f, -0.01128162f, 0.01275898f, -0.01724924f, -0.00438828f, -0.00849023f, -0.03659449f, -0.02033234f, 
    0.01772677f, -0.01350443f, 0.02358642f, -0.00818371f, -0.01301524f, 0.02868398f, -0.02236956f, 0.00190854f, 
    -0.00285724f, -0.00621309f, 0.00440672f, -0.03464664f, -0.01773261f, 0.01931067f, 0.02686871f, 0.00717498f, 
    -0.01835890f, 0.00653920f, -0.01460258f, -0.00938091f, 0.01241956f, -0.01785487f, -0.00756024f, -0.01757428f, 
    -0.00744786f, -0.02349664f, 0.01799213f, -0.01158128f, 0.02378837f, -0.01085558f, -0.01475000f, 0.02624300f, 
    -0.02722755f, -0.02588610f, -0.04269919f, -0.02478252f, 0.01121472f, 0.02223234f, -0.00307343f, -0.00694770f, 
    0.01542571f, -0.02304330f, 0.01867414f, -0.00333924f, 0.00505867f, -0.01975807f, 0.03259306f, 0.01820187f, 
    -0.01668512f, 0.02108669f, -0.02044592f, -0.03887385f, 0.01452021f, 0.00976509f, -0.00688769f, -0.00456752f, 
    -0.01771332f, -0.02217730f, -0.01935966f, -0.01884023f, 0.01606278f, -0.01874368f, -0.02585148f, -0.01201825f, 
    0.01621306f, -0.03221111f, 0.01420444f, 0.03070889f, -0.01984585f, 0.01078270f, 0.01009239f, -0.03052978f, 
    0.02795819f, 0.02693058f, 0.02535294f, 0.00329327f, -0.00651224f, -0.02232527f, -0.02207292f, 0.01920238f, 
    -0.02186524f, 0.02775276f, -0.03218098f, 0.02650389f, -0.01081902f, -0.02649943f, -0.03616266f, -0.01573585f, 
    0.01207206f, -0.02916589f, -0.03778131f, -0.00627731f, -0.03368907f, 0.02793382f, 0.01918549f, 0.01304722f, 
    -0.02970499f, 0.00136182f, -0.03595513f, 0.02409209f, 0.01429151f, 0.03196288f, -0.04254024f, -0.00231618f, 
    -0.03080019f, 0.02543458f, 0.01865934f, 0.02637102f, 0.01190559f, 0.02811076f, -0.02894638f, 0.01772985f, 
    0.01411922f, 0.00314538f, -0.00981132f, 0.00810068f, -0.02560689f, -0.01659644f, -0.03763326f, -0.00080763f, 
    0.00652105f, -0.03784356f, 0.02838924f, 0.00804723f, -0.01259266f, -0.02115240f, 0.02013155f, -0.02922569f, 
    -0.03441639f, -0.00348104f, -0.01555131f, -0.03781686f, -0.01423126f, -0.03967250f, -0.01430087f, -0.01307674f, 
    0.01020054f, -0.03092176f, -0.02526123f, 0.01952513f, -0.00261281f, -0.03202640f, 0.02893009f, 0.01677900f, 
    -0.00809760f, -0.03303485f, 0.01151873f, -0.01659221f, -0.01289291f, 0.02695002f, -0.02019825f, -0.02847748f, 
    0.02378422f, 0.02229814f, -0.03775714f, -0.00656410f, 0.00696949f, -0.02108698f, 0.01192854f, 0.00932458f, 
    0.00028217f, -0.03376976f, -0.00702521f, -0.00412226f, -0.02389808f, 0.02361369f, -0.00999169f, 0.02400490f, 
    0.01651499f, -0.00746212f, -0.00693988f, 0.02146322f, 0.01712030f, -0.02798158f, -0.01634897f, -0.02294868f, 
    0.00898573f, -0.00468437f, -0.01201611f, -0.02188965f, -0.03897160f, -0.01276060f, 0.00300232f, -0.00325327f, 
    0.01736309f, 0.02274092f, -0.02293547f, 0.03512308f, 0.02992829f, -0.00756686f, -0.00154062f, -0.00416586f, 
    -0.01473925f, 0.00251552f, -0.02508079f, -0.03128130f, -0.02953321f, -0.02201872f, -0.03218602f, 0.01687687f, 
    0.00486679f, 0.00284568f, 0.02003332f, -0.02263159f, 0.01431684f, -0.00889064f, -0.02698157f, 0.01690355f, 
    0.02966952f, -0.02771947f, -0.02122495f, -0.03901147f, -0.00476487f, -0.00689652f, -0.02248541f, -0.03678163f, 
    -0.02399745f, -0.02018339f, 0.00441095f, -0.00796100f, 0.01252833f, -0.02037548f, -0.03505254f, 0.01860740f, 
    -0.02652081f, 0.01527777f, 0.01969911f, -0.01597543f, -0.00635450f, 0.01266433f, -0.02320110f, 0.01245927f, 
    0.02916788f, 0.01532181f, -0.04018957f, -0.04269487f, 0.01338701f, 0.03106035f, -0.02149082f, -0.00807937f, 
    0.00050122f, -0.04333802f, 0.01124991f, 0.01657868f, 0.01801900f, -0.00309896f, 0.01798262f, -0.01829802f, 
    -0.02847069f, -0.00316229f, 0.01124380f, -0.02390890f, 0.00702257f, -0.00058716f, 0.02518836f, -0.00047498f, 
    -0.04037281f, 0.01766864f, -0.02064855f, 0.02217607f, -0.01813751f, -0.02859847f, 0.00197964f, -0.02338243f, 
    0.03112128f, -0.02229927f, -0.01680130f, -0.01749479f, -0.00840838f, 0.02034092f, -0.03236198f, -0.00646984f, 
    0.00878798f, -0.01763762f, 0.01140010f, -0.01757302f, -0.02220671f, -0.03540120f, -0.02239067f, -0.01819066f, 
    -0.03724226f, 0.03622090f, -0.02624748f, 0.02049550f, 0.01588199f, -0.01550243f, 0.00065045f, -0.01644857f, 
    0.01791799f, -0.02407571f, 0.01421527f, -0.03033640f, 0.02630731f, -0.02674906f, -0.00921168f, 0.00254101f, 
    0.01583242f, -0.01291083f, 0.03132371f, 0.02221842f, -0.04216552f, 0.00600656f, -0.03161268f, 0.00645209f, 
    0.01359041f, 0.01567484f, 0.00186342f, 0.00962190f, 0.02435733f, 0.01611054f, 0.04177714f, -0.00627033f, 
    0.00698017f, -0.00360044f, 0.03577657f, 0.01914493f, 0.00021269f, -0.00250512f, -0.02599392f, 0.00665933f, 
    -0.01789919f, 0.00815722f, -0.01684052f, 0.02087585f, -0.01084334f, 0.02503726f, -0.02411848f, 0.01873160f, 
    0.02301488f, 0.02971644f, 0.02266857f, -0.04068148f, 0.00031119f, 0.02204938f, 0.01651153f, 0.01770491f, 
    0.01287026f, 0.02006548f, 0.02738625f, -0.00326311f, 0.03700683f, 0.01266312f, 0.00895429f, -0.03789456f, 
    0.00105679f, -0.04108246f, 0.00509695f, 0.00201009f, -0.00907626f, -0.02570061f, 0.01948076f, 0.00498118f, 
    -0.04075190f, -0.03326187f, -0.02542140f, 0.01584780f, -0.01341542f, -0.01109711f, -0.01874904f, -0.01520600f, 
    -0.02318328f, -0.03184981f, -0.04076515f, -0.01956212f, -0.01662825f, -0.03753454f, 0.01733105f, 0.02276255f, 
    -0.02335871f, -0.01778332f, 0.00821556f, 0.01143970f, 0.00192474f, -0.02186499f, -0.01883755f, -0.00520413f, 
    -0.02468843f, -0.03146539f, 0.00147330f, 0.00069804f, 0.02289506f, -0.00257724f, -0.00905046f, -0.03435246f, 
    0.02781300f, 0.00652315f, -0.03455582f, 0.01049398f, 0.00860736f, -0.01159011f, -0.00765461f, -0.02020711f, 
    -0.04139168f, -0.00252039f, -0.01440457f, -0.00061817f, -0.00939066f, 0.03135829f, -0.03874736f, 0.02314512f, 
    0.02558069f, 0.02819743f, -0.00566602f, 0.02057421f, -0.01724766f, -0.02891039f, -0.00087935f, -0.02190569f, 
    -0.02269851f, -0.02519787f, -0.02251149f, 0.00368763f, -0.00847862f, -0.04079310f, -0.01524206f, -0.01389362f, 
    -0.02638458f, -0.01763428f, 0.00798336f, -0.01266233f, -0.00753627f, 0.01775459f, 0.00039725f, -0.04138883f, 
    -0.01140208f, -0.04030046f, 0.00326732f, -0.01948344f, 0.01201425f, 0.02678729f, -0.00193484f, -0.04081372f, 
    -0.02770075f, 0.02643415f, 0.02568037f, -0.00462065f, 0.01137901f, -0.01338607f, 0.01361262f, -0.03434241f, 
    -0.00227976f, -0.00193879f, 0.01133175f, -0.02516053f, -0.03237367f, -0.03517900f, 0.02410197f, -0.00621525f, 
    0.02135417f, -0.02506370f, 0.00940675f, -0.01270390f, -0.03939771f, 0.03217846f, 0.01717165f, -0.03307864f, 
    0.02476212f, 0.00239587f, -0.01564034f, 0.02334281f, 0.00613413f, -0.02218751f, 0.00564929f, -0.00171643f, 
    -0.01232910f, -0.03569810f, -0.02539161f, -0.01500732f, 0.03581393f, 0.03627800f, -0.04154443f, -0.04001665f, 
    0.03762135f, -0.03920632f, -0.03061100f, 0.01449113f, 0.02478439f, -0.02768908f, -0.01127665f, 0.02499562f, 
    -0.00797675f, -0.03153688f, 0.00620196f, -0.02054057f, 0.01596224f, 0.03775795f, -0.03889472f, 0.00374450f, 
    0.00257087f, -0.00868304f, -0.03788077f, 0.00507168f, 0.02486579f, 0.02239638f, -0.02056999f, -0.00783746f, 
    0.00388638f, -0.03429026f, -0.03138423f, 0.01390775f, 0.01192509f, -0.03324613f, -0.02177338f, -0.03116787f, 
    -0.02532882f, -0.03279606f, -0.02048738f, 0.01996082f, 0.01510007f, -0.03335805f, -0.00241517f, 0.02509854f, 
    -0.00892929f, 0.00517650f, -0.02374646f, 0.02261586f, 0.01468184f, 0.01301328f, -0.03161187f, 0.03103987f, 
    -0.02911426f, 0.03014501f, 0.03416525f, 0.00811400f, -0.04230379f, -0.01731660f, -0.02968346f, -0.02369463f, 
    0.02353690f, 0.01395765f, -0.00806869f, -0.02314517f, -0.04146858f, -0.02849822f, 0.01660039f, -0.03889155f, 
    -0.03316982f, -0.03006008f, -0.00372868f, -0.03282053f, 0.00857652f, 0.00305307f, 0.00934852f, -0.00778888f, 
    -0.00541343f, -0.00271219f, -0.03767212f, 0.01485451f, 0.02628392f, 0.03038235f, 0.00954395f, -0.01534041f, 
    0.02697663f, 0.01112085f, -0.04106732f, 0.01267422f, 0.02159630f, -0.01277689f, 0.03353264f, -0.02643741f, 
    -0.02218972f, -0.03703393f, -0.03649526f, -0.03134640f, -0.01618040f, -0.00534249f, -0.00639772f, 0.01724190f, 
    0.03748586f, 0.02970445f, 0.01963199f, -0.01766615f, -0.04208923f, 0.01736844f, -0.01836411f, -0.01339630f, 
    0.00778448f, 0.02206493f, -0.00141978f, 0.00037360f, 0.00393346f, -0.03759506f, -0.02919687f, 0.03215827f, 
    0.01670907f, 0.02824859f, -0.03835287f, 0.00282046f, -0.00221326f, -0.00876338f, 0.01219190f, -0.01042295f, 
    0.01939784f, 0.02698334f, -0.00509767f, 0.01809112f, 0.01238631f, -0.03445711f, -0.02684982f, -0.01549396f, 
    -0.03267525f, -0.00453279f, -0.01690194f, -0.02979367f, -0.01923396f, -0.00108247f, 0.02306214f, -0.00130212f, 
    -0.01384031f, -0.00654710f, 0.01355354f, 0.01982358f, -0.03956608f, 0.01341785f, 0.00789707f, -0.03116240f, 
    -0.03684076f, 0.01597361f, 0.02362918f, -0.03981301f, -0.00991971f, 0.01190823f, -0.00259694f, 0.01636847f, 
    -0.04228098f, -0.03242101f, 0.00734374f, 0.01763463f, -0.03514703f, -0.03598082f, 0.01881397f, 0.01684328f, 
    -0.00477803f, -0.03182882f, 0.01480094f, -0.03339249f, -0.01180915f, 0.02348994f, -0.01494468f, -0.01001072f, 
    -0.02423772f, -0.00741769f, -0.01762533f, -0.04197082f, 0.00558862f, -0.02018654f, -0.02623978f, -0.02930103f, 
    0.02489185f, 0.02393208f, -0.00717759f, -0.02032665f, 0.00208886f, -0.00855949f, 0.02164279f, 0.00679746f, 
    -0.00260723f, -0.01229995f, 0.02307203f, -0.01681093f, 0.00803781f, -0.04424302f, -0.00181991f, -0.03193158f, 
    -0.02692623f, -0.03684778f, 0.02485213f, 0.01036341f, -0.00036109f, 0.00450443f, -0.00609810f, -0.01705348f, 
    -0.03724631f, 0.01354057f, -0.02460427f, -0.00691710f, 0.00808220f, -0.03977284f, -0.00711067f, -0.00179589f, 
    -0.02208042f, 0.01585460f, -0.03219196f, -0.01387861f, -0.02031290f, -0.04326078f, -0.01562481f, 0.00299176f, 
    -0.00896636f, 0.01317960f, -0.01739265f, 0.01952513f, 0.01250538f, -0.00648892f, -0.03440436f, -0.03362200f, 
    0.01445984f, 0.01421915f, 0.01985851f, -0.02071991f, -0.00004634f, -0.02286044f, 0.02102524f, 0.00109273f, 
    -0.00292579f, -0.03152144f, 0.02484998f, 0.03051672f, 0.02023938f, 0.02554492f, 0.01034606f, -0.01363592f, 
    -0.03858319f, -0.03035629f, -0.00828058f, -0.00699232f, 0.00103161f, 0.02316777f, -0.02188422f, -0.01513768f, 
    -0.02135102f, -0.03238989f, -0.01167772f, -0.02561167f, -0.00493417f, -0.02610594f, 0.01396228f, 0.01091187f, 
    0.00362156f, 0.01749503f, -0.00830944f, 0.02578807f, -0.02322761f, -0.04191140f, -0.00511676f, 0.01696246f, 
    0.02628883f, 0.00531851f, 0.01563807f, -0.01078358f, -0.00658588f, -0.01684250f, -0.00782589f, -0.00470446f, 
    -0.01666367f, -0.03586648f, -0.01460462f, -0.02476273f, -0.01944888f, 0.02730811f, -0.03185729f, 0.02210156f, 
    0.01542637f, -0.04244531f, -0.03932972f, -0.00304296f, -0.02653657f, -0.01570026f, 0.02460935f, 0.01636204f, 
    -0.01407044f, -0.02355561f, 0.00282897f, -0.01611543f, -0.02551158f, -0.04385720f, 0.00491171f, -0.01049219f, 
    -0.01179850f, -0.00990765f, -0.03466346f, 0.01487485f, -0.02617224f, -0.01345996f, -0.02080907f, 0.01906189f, 
    0.01612196f, -0.00763081f, 0.00469197f, 0.01872319f, 0.00089326f, -0.04003106f, -0.01519763f, 0.01197451f, 
    -0.04048927f, 0.00890864f, -0.02147194f, -0.02838328f, 0.00381836f, 0.02391721f, -0.01785695f, -0.00034207f, 
    0.02609720f, -0.00126346f, 0.01894680f, 0.01877867f, -0.03665455f, 0.01380832f, -0.00213205f, -0.01805484f, 
    -0.00324850f, 0.02623265f, 0.01691913f, -0.03085792f, 0.00552794f, -0.02774721f, -0.04094967f, 0.02185836f, 
    -0.00164276f, -0.00678033f, 0.00395965f, -0.00110333f, -0.02735679f, -0.01540893f, -0.03826741f, 0.01568053f, 
    -0.01614934f, 0.01781143f, -0.03018843f, -0.03079000f, 0.01689851f, 0.00273982f, -0.03962968f, -0.04106055f, 
    -0.00886689f, 0.01875560f, -0.01528288f, -0.01651936f, 0.02587584f, -0.02336569f, -0.03926025f, 0.00447480f, 
    -0.04397015f, 0.01814918f, -0.01338041f, -0.01966298f, -0.04056019f, -0.00118224f, -0.01697712f, -0.02259915f, 
    -0.04271168f, -0.02085442f, 0.00642823f, 0.02189900f, -0.02404800f, 0.01920264f, -0.04023115f, 0.02799754f, 
    0.01347299f, 0.00284461f, 0.01923519f, -0.02230183f, 0.01066721f, 0.01270419f, -0.00878751f, 0.00052543f, 
    -0.04273700f, 0.01490890f, 0.00793002f, -0.03101656f, -0.03260831f, -0.01498945f, -0.03528274f, -0.01251058f, 
    0.02549264f, -0.03411606f, 0.00300509f, -0.02664678f, -0.00157790f, 0.02187868f, -0.01648946f, -0.03941687f, 
    0.02516856f, 0.02165486f, -0.02879363f, 0.01240101f, -0.03078523f, 0.01456236f, 0.02125118f, 0.02476968f, 
    -0.01478430f, -0.01020213f, -0.03626339f, -0.01455954f, 0.00076967f, -0.03980851f, -0.01499244f, -0.03960957f, 
    -0.01199941f, 0.01360271f, -0.00384213f, -0.03394669f, -0.02959456f, 0.01477261f, 0.01916299f, -0.00134451f, 
    -0.02470821f, -0.00596287f, 0.01672142f, -0.02403382f, -0.01011737f, 0.00652499f, -0.02141796f, -0.02139603f, 
    -0.00661179f, -0.02587676f, -0.03693708f, -0.01650969f, 0.00663416f, -0.00366676f, -0.03870161f, 0.00411516f, 
    0.02172517f, 0.02125903f, 0.02396726f, -0.02296362f, -0.01925883f, -0.00387526f, -0.00151010f, 0.01166036f, 
    -0.03819123f, 0.02676641f, 0.01372712f, -0.00229057f, -0.04093749f, 0.02078342f, 0.02576628f, 0.01461055f, 
    -0.03179867f, 0.00121374f, 0.02731048f, -0.01413872f, -0.02107451f, -0.03957223f, -0.00834669f, -0.03968602f, 
    0.00488986f, 0.01717350f, -0.01669714f, 0.00396292f, 0.01253789f, 0.01394150f, -0.00510431f, 0.01202807f, 
    0.01469328f, -0.01604346f, 0.01565289f, -0.02720455f, 0.01108600f, 0.00677726f, -0.00484456f, 0.00676232f, 
    -0.01546887f, -0.03754991f, 0.01087646f, 0.01830636f, -0.02308877f, -0.03016259f, 0.02938837f, 0.02342301f, 
    0.03290756f, 0.02047130f, -0.02436599f, 0.02391032f, -0.00384769f, -0.01058852f, 0.01580795f, -0.02864804f, 
    0.01490598f, 0.00048314f, 0.00331265f, -0.00059379f, -0.01087615f, 0.02132829f, -0.02176949f, 0.01414900f, 
    -0.01390159f, 0.01646292f, -0.03546752f, 0.00718704f, 0.02603380f, -0.00365597f, -0.00253217f, -0.01405146f, 
    -0.01563326f, 0.02110336f, -0.02224351f, 0.01450083f, 0.00597306f, 0.01472923f, -0.02427851f, -0.04078999f, 
    0.02332187f, -0.00242951f, 0.00586392f, -0.02148179f, -0.02242413f, -0.03619086f, 0.02455485f, 0.02173533f, 
    -0.02854515f, 0.00432044f, 0.00123564f, 0.00592729f, 0.01983875f, 0.00426570f, 0.02673515f, -0.01453064f, 
    -0.03065490f, 0.00391411f, -0.00613051f, -0.03879059f, 0.00660047f, 0.00125194f, -0.02292870f, -0.03351838f, 
    -0.03580971f, 0.00303045f, -0.01601896f, 0.00145185f, 0.00099253f, -0.00439533f, 0.00268555f, -0.00176206f, 
    -0.02821963f, 0.01846560f, 0.01555240f, -0.03562029f, 0.02241811f, -0.02225157f, -0.04147372f, 0.00183928f, 
    -0.04060493f, 0.02092105f, 0.00607374f, -0.02062396f, -0.01221781f, 0.00925379f, -0.00487707f, 0.00219985f, 
    -0.03752792f, 0.01728715f, 0.02673335f, -0.02228010f, -0.02475692f, -0.04131255f, 0.01437099f, -0.02489214f, 
    -0.00172539f, -0.02045248f, 0.02438181f, 0.00512523f, -0.01070016f, 0.01371790f, -0.03102996f, -0.03446839f, 
    -0.00272317f, -0.03641963f, 0.01276221f, 0.02651760f, -0.04085685f, -0.02085861f, 0.01833752f, -0.02864150f, 
    0.02090158f, -0.03079239f, 0.00973986f, 0.00312592f, -0.02564912f, -0.00239125f, -0.03181684f, -0.00181117f, 
    -0.02002576f, -0.02877191f, -0.03421900f, 0.01954307f, -0.01324257f, -0.02868631f, 0.00858290f, -0.00056033f, 
    -0.01440511f, 0.02229000f, -0.02350568f, -0.00392937f, 0.01756145f, -0.00446708f, -0.04423075f, 0.02776771f, 
    -0.02253532f, -0.02341263f, -0.04034619f, -0.00013237f, 0.02341304f, 0.01414520f, -0.03940059f, 0.01637824f, 
    -0.03165362f, -0.01961688f, -0.04395679f, -0.03057989f, 0.00140417f, -0.02700299f, 0.03164262f, 0.00086014f, 
    -0.01666608f, 0.00827053f, -0.04087689f, -0.01804519f, 0.00026324f, -0.01175533f, 0.00572871f, -0.01617797f, 
    -0.00423035f, -0.02198771f, -0.00851269f, 0.00431107f, -0.01342220f, -0.01640146f, -0.02392021f, -0.02523769f, 
    -0.02035817f, 0.01735038f, 0.02621333f, -0.01899889f, -0.00430792f, 0.02073224f, -0.00854115f, -0.03078346f, 
    0.01717352f, -0.02443597f, 0.02000062f, -0.01558092f, -0.01360477f, -0.03887498f, -0.01789553f, -0.01657135f, 
    -0.03674330f, -0.00325562f, 0.00371259f, -0.00874052f, -0.00369743f, 0.01064140f, -0.02395814f, -0.01522352f, 
    -0.03389991f, 0.00608995f, 0.00566860f, 0.01571021f, 0.01237131f, -0.01411587f, 0.01645633f, 0.01470752f, 
    0.02188189f, 0.00792671f, 0.02663657f, -0.03467745f, -0.02501530f, 0.00523113f, -0.03401237f, -0.00114996f, 
    -0.02294410f, -0.01020163f, 0.01582732f, 0.02048186f, -0.02903083f, -0.02942409f, 0.00609287f, 0.02287208f, 
    -0.02728448f, -0.01699371f, 0.00425592f, -0.02939115f, -0.01973800f, -0.02077997f, 0.02151932f, 0.01921624f, 
    -0.01070375f, 0.01391040f, 0.01001382f, -0.00700137f, -0.02229868f, -0.04242008f, 0.01531045f, -0.02878355f, 
    0.00980985f, -0.02586048f, -0.00756785f, -0.02561320f, -0.00598428f, -0.00351825f, -0.04117408f, -0.00979100f, 
    0.01345929f, -0.02019581f, -0.04430473f, -0.01668592f, -0.03904554f, -0.03730785f, 0.02097003f, -0.03158112f, 
    -0.02598749f, 0.00956818f, -0.02383612f, -0.03707830f, -0.00287385f, -0.02051149f, -0.01066583f, -0.03675107f, 
    0.01559596f, 0.03525166f, 0.02917944f, -0.00529702f, 0.00445714f, 0.00275218f, -0.02512023f, 0.02197850f, 
    -0.04039452f, -0.01780538f, -0.02101823f, -0.01524018f, -0.02047072f, 0.02549980f, -0.03268527f, -0.02196337f, 
    -0.00957777f, -0.02316219f, -0.01991411f, 0.00344936f, -0.01431184f, 0.00828025f, 0.01528366f, 0.01646003f, 
    -0.04367403f, -0.00292911f, -0.01608395f, -0.03452072f, -0.01543967f, 0.00522420f, -0.02538594f, -0.02315318f, 
    -0.02393043f, 0.00506653f, 0.00553520f, -0.02391237f, -0.00231754f, 0.00436346f, -0.01179514f, -0.00265088f, 
    -0.00314369f, -0.02641300f, 0.01496727f, 0.00864775f, 0.01637506f, -0.03282819f, 0.01231796f, -0.03841712f, 
    -0.03310504f, -0.02796430f, -0.02099917f, -0.01733552f, -0.01430359f, 0.00221539f, -0.03931137f, 0.01837101f, 
    0.02278997f, 0.02449969f, -0.04020355f, -0.03030556f, -0.02120652f, -0.04085237f, -0.03526536f, -0.03012177f, 
    -0.04211991f, -0.02100434f, -0.01619745f, 0.02511721f, 0.01683719f, 0.01514008f, -0.02024211f, -0.03855632f, 
    -0.00632769f, -0.01902860f, 0.00159563f, 0.00295853f, -0.03427808f, 0.01968471f, -0.03537453f, -0.00973508f, 
    -0.03686432f, -0.00969669f, 0.02363336f, -0.00099469f, 0.01660335f, 0.01557559f, -0.00131710f, 0.00009667f, 
    -0.03866532f, 0.00057255f, -0.00905580f, 0.00479949f, -0.02156048f, -0.03837055f, 0.02565615f, -0.04016167f, 
    0.00163743f, 0.00569742f, 0.00792968f, 0.01178088f, -0.00229220f, -0.04359342f, 0.02126202f, -0.03073090f, 
    0.00539036f, -0.00517602f, -0.03138470f, -0.01374363f, -0.01087815f, -0.02810295f, 0.00312386f, -0.02345481f, 
    0.02592735f, 0.00006495f, 0.02117568f, 0.02135480f, 0.01820597f, -0.03261328f, -0.01830606f, -0.03046885f, 
    -0.00748520f, 0.01007127f, 0.02058353f, -0.03818441f, -0.03582391f, 0.02302890f, 0.02078345f, 0.02061536f, 
    0.01955979f, -0.01430869f, 0.02788510f, 0.02735366f, 0.02276512f, -0.02410883f, -0.02655377f, 0.02057829f, 
    0.00811170f, 0.00562061f, -0.01339086f, 0.02385310f, 0.02679532f, -0.01400028f, -0.04371082f, 0.02343361f, 
    0.01709589f, -0.03314206f, 0.00469514f, -0.00259764f, 0.01862616f, -0.01380506f, -0.00784423f, -0.00196101f, 
    -0.04186437f, 0.00761515f, 0.01258751f, 0.02716940f, -0.03617761f, 0.02173356f, -0.00215334f, 0.00074158f, 
    0.02177612f, -0.01827686f, -0.01317638f, -0.00629712f, -0.01619327f, -0.01453148f, -0.00057007f, -0.01296792f, 
    -0.02814013f, -0.00924508f, 0.00859957f, -0.04130501f, 0.01365750f, -0.00840457f, 0.00216323f, -0.03692924f, 
    -0.04135429f, 0.00244194f, 0.02952462f, -0.01065441f, 0.01555078f, 0.01179800f, -0.00237202f, 0.00070266f, 
    -0.00444609f, 0.01947750f, 0.00605213f, 0.00195039f, 0.02370410f, 0.01958852f, -0.01460972f, -0.01182224f, 
    0.02285501f, -0.00557130f, 0.02440354f, -0.02593150f, 0.02138535f, 0.00458062f, -0.02851748f, 0.02556295f, 
    -0.02756345f, 0.02827634f, 0.00620037f, -0.02179373f, -0.01114235f, 0.01502683f, -0.01192677f, -0.00891445f, 
    0.00321392f, -0.04033971f, 0.01045334f, -0.00735037f, -0.01527944f, -0.00142678f, -0.03881669f, 0.02098900f, 
    -0.02032222f, -0.02838903f, 0.00752245f, -0.03106312f, -0.02943609f, -0.00546630f, -0.04123582f, 0.00519717f, 
    -0.03036093f, 0.01362299f, -0.00259747f, 0.00681688f, -0.03720159f, 0.01406448f, 0.00715150f, -0.02877154f, 
    0.02303908f, 0.02635941f, -0.03009915f, -0.01455440f, 0.03212148f, -0.02996571f, 0.01266497f, 0.00105177f, 
    0.01393467f, -0.03782398f, -0.01093212f, -0.01317441f, -0.04422551f, -0.02049587f, -0.01135741f, 0.01275096f, 
    0.01945194f, 0.00308696f, -0.02639498f, 0.00601330f, 0.01303817f, -0.03291442f, 0.03156900f, -0.03143254f, 
    0.01157313f, 0.01102230f, 0.00354781f, -0.03405785f, 0.03233079f, -0.02495959f, -0.03990787f, -0.01501817f, 
    -0.00306906f, -0.04221313f, 0.00057098f, -0.01871459f, 0.02094419f, 0.02488925f, -0.03275229f, 0.02988223f, 
    -0.00655164f, -0.00283859f, -0.01847172f, 0.01826271f, -0.01165337f, 0.02582761f, 0.02244534f, 0.00198224f, 
    0.00160409f, 0.01023394f, -0.01760028f, -0.00348147f, 0.02182900f, 0.03008499f, -0.03657381f, 0.02007369f, 
    0.00803093f, -0.01921421f, 0.02513476f, 0.01114410f, -0.03597527f, -0.02085062f, 0.01327851f, -0.02382397f, 
    -0.02226655f, 0.00863620f, -0.01301854f, -0.02656612f, 0.03237117f, 0.02927772f, -0.00539691f, -0.01969795f, 
    -0.01619570f, 0.00546490f, 0.00864258f, -0.02159787f, -0.00104700f, 0.00047332f, 0.01995761f, 0.01276613f, 
    -0.02009928f, -0.03711066f, -0.02953320f, 0.01769798f, 0.01900478f, 0.02881265f, 0.02129380f, 0.00490243f, 
    -0.03888982f, 0.01254922f, 0.02977484f, -0.00617509f, -0.00112711f, 0.02335825f, -0.00864043f, 0.00786580f, 
    0.01472756f, 0.00821398f, 0.02928361f, -0.04062088f, 0.02780049f, -0.01743360f, 0.01156484f, 0.01436063f, 
    0.02350483f, -0.03459980f, -0.00775588f, -0.02261373f, -0.00559125f, -0.02003105f, 0.02434169f, 0.00353478f, 
    -0.03313309f, -0.00420086f, -0.02794310f, 0.00182296f, 0.00136225f, 0.01265610f, 0.02461515f, 0.01659849f, 
    -0.00271472f, -0.01955388f, 0.02485993f, -0.00421118f, 0.01073197f, -0.00558291f, 0.01408293f, 0.01276811f, 
    -0.00406466f, 0.01120826f, -0.02169286f, 0.01747595f, 0.01778542f, 0.02610869f, 0.03265730f, -0.02346267f, 
    0.00672713f, -0.01915516f, 0.03210465f, -0.02797526f, -0.01961709f, -0.03412297f, -0.03360214f, -0.02756199f, 
    -0.03326434f, -0.01484444f, -0.00924780f, -0.00900777f, -0.00978290f, -0.03281919f, 0.01489615f, -0.03015262f, 
    -0.03713971f, 0.01635047f, -0.02924158f, 0.00105121f, 0.03701434f, -0.03419341f, -0.02254445f, -0.02948565f, 
    0.02747987f, -0.02820303f, -0.03101060f, 0.02301829f, -0.02175895f, -0.00980384f, 0.00554199f, 0.02577460f, 
    -0.01564070f, 0.02748490f, 0.03100098f, -0.00412797f, 0.02777625f, 0.00156704f, -0.03401645f, -0.03117160f, 
    -0.00059780f, -0.02243816f, 0.02517308f, -0.03585165f, -0.03577943f, -0.00105242f, 0.00083134f, -0.02313542f, 
    -0.03355009f, -0.00563579f, -0.02784306f, -0.02864542f, 0.01022218f, -0.01544743f, 0.01790106f, -0.00187244f, 
    0.02878287f, -0.01052409f, -0.01397880f, 0.02835721f, -0.01753513f, 0.01212955f, -0.00871896f, -0.02887588f, 
    0.00800385f, -0.02472446f, -0.02058735f, -0.01788068f, 0.00841505f, -0.02769722f, 0.00190780f, 0.01661243f, 
    0.03869681f, -0.03307749f, 0.01197019f, -0.00773376f, 0.01623581f, -0.00797693f, -0.02649291f, 0.00532659f, 
    0.00576347f, -0.01032177f, -0.01055388f, -0.01682880f, -0.00489755f, -0.02428351f, -0.00364403f, 0.01393813f, 
    -0.00837310f, 0.01133341f, -0.03194909f, 0.01354330f, -0.01425420f, -0.03983910f, -0.00029759f, 0.02596493f, 
    -0.01326571f, -0.01460671f, -0.03790355f, -0.01027852f, 0.00873263f, 0.02832445f, -0.01869155f, -0.02099529f, 
    -0.02981709f, -0.02136234f, 0.00021810f, -0.00317887f, -0.02262208f, 0.01884526f, -0.00487063f, 0.02278318f, 
    0.02144800f, 0.00461962f, -0.02741019f, 0.02500590f, -0.01050378f, 0.00217694f, -0.00358503f, -0.03942877f, 
    -0.04035257f, -0.01949602f, 0.00956535f, -0.03017235f, 0.02453925f, -0.01317901f, -0.03415437f, -0.03627612f, 
    -0.01638832f, 0.02983638f, 0.02120179f, 0.03093838f, 0.00545249f, -0.00566790f, 0.02647326f, 0.01353038f, 
    0.00234465f, -0.03613504f, 0.01507821f, 0.02904436f, 0.01761169f, 0.01489694f, 0.02921324f, -0.03055077f, 
    -0.00315264f, -0.01787307f, -0.00753027f, 0.00930195f, -0.02205467f, 0.02938672f, -0.01885141f, 0.01972236f, 
    0.01295964f, -0.00394914f, 0.03077900f, 0.02844232f, 0.02702057f, -0.00724237f, 0.00067148f, 0.01816492f, 
    0.00368742f, 0.00826081f, 0.02123612f, -0.03501540f, 0.00046095f, -0.03343461f, 0.01265244f, -0.03334460f, 
    -0.03061196f, -0.01209060f, 0.01612754f, 0.02021059f, 0.00505740f, -0.00383445f, -0.02753741f, 0.02576576f, 
    -0.00745136f, -0.00975245f, -0.01460143f, 0.02942005f, 0.02057006f, 0.01235801f, 0.01400624f, 0.01836949f, 
    0.02458558f, -0.03866937f, 0.03654722f, -0.04010230f, -0.02479478f, 0.00874663f, -0.04103030f, 0.01601139f, 
    0.03249568f, 0.00208775f, -0.00523434f, 0.02200995f, -0.01321459f, 0.01532922f, 0.01402132f, -0.02645475f, 
    -0.00147672f, -0.01310634f, -0.01085563f, -0.02479817f, -0.02788635f, -0.01034257f, -0.03589043f, 0.01295686f, 
    0.00776261f, -0.02277236f, 0.01837400f, 0.01307450f, 0.01281409f, -0.01161800f, -0.02958491f, 0.02683988f, 
    -0.03445873f, 0.02519165f, 0.00317906f, -0.01712280f, -0.03999081f, -0.01794191f, 0.00127246f, 0.01984827f, 
    -0.02240999f, -0.03275215f, 0.01404807f, -0.02858809f, -0.03508237f, 0.01341167f, -0.02327242f, -0.01128522f, 
    0.01333477f, 0.02031267f, 0.00025467f, 0.00698092f, 0.01900290f, 0.01319058f, 0.04228598f, -0.01320687f, 
    -0.03653803f, 0.00396297f, 0.00296840f, -0.01875035f, -0.02994987f, -0.00626203f, 0.00626230f, 0.01382615f, 
    0.02266053f, 0.02818971f, 0.01363166f, -0.03449502f, 0.02051685f, 0.02617402f, 0.02607602f, 0.00856913f, 
    0.01780627f, -0.00666264f, -0.02871180f, -0.01289364f, 0.03128695f, 0.00651933f, -0.04117396f, 0.00501420f, 
    0.02490028f, 0.00067786f, 0.01770698f, 0.01381376f, 0.01975723f, -0.01475487f, 0.01448540f, -0.01510976f, 
    -0.01823023f, -0.00746409f, 0.00343120f, -0.00609431f, -0.03060900f, 0.00719103f, -0.01946135f, 0.02224472f, 
    -0.04051680f, 0.01539256f, -0.00559895f, 0.00394093f, 0.01859514f, 0.03790445f, 0.02272583f, -0.00404966f, 
    -0.00469296f, -0.01338451f, -0.02542197f, -0.03235819f, 0.02740319f, 0.00621673f, 0.01532847f, 0.02278301f, 
    -0.00908628f, -0.02128086f, 0.02780078f, -0.03283718f, -0.01045976f, -0.01534696f, 0.00009262f, 0.00112155f, 
    0.01503805f, -0.02816639f, -0.00674945f, 0.00370982f, 0.03056866f, -0.00556750f, 0.00104815f, 0.01156795f, 
    0.03133572f, 0.02713680f, -0.00869984f, 0.02752434f, -0.03337587f, 0.00425749f, 0.02108431f, 0.02763949f, 
    -0.00406771f, 0.02085379f, -0.00458343f, -0.03049383f, -0.03932180f, 0.00536391f, 0.00149647f, 0.02476422f, 
    0.00163434f, -0.01885107f, -0.01507318f, -0.01356127f, -0.01828834f, -0.02976624f, 0.00468794f, 0.00923981f, 
    -0.01297959f, -0.01228188f, 0.00046489f, -0.03969523f, 0.01412161f, -0.02978783f, -0.02940461f, 0.02722707f, 
    0.01978979f, 0.02594033f, -0.00439718f, -0.03870851f, -0.02563347f, 0.01443890f, 0.00844069f, -0.03473669f, 
    -0.01420916f, -0.02028338f, 0.03676071f, -0.01995768f, -0.01524040f, -0.00280656f, -0.03074721f, -0.03626683f, 
    -0.02367404f, 0.02303589f, -0.03431196f, -0.02697846f, 0.01937181f, 0.02381483f, -0.00927830f, -0.01902276f, 
    -0.02387024f, -0.03010676f, 0.00044115f, -0.02451579f, 0.02803173f, 0.02081318f, -0.00585330f, -0.03526952f, 
    0.02675202f, 0.02575047f, -0.00720978f, -0.03211294f, 0.02356292f, 0.00774092f, -0.03667062f, 0.01075976f, 
    -0.02367008f, 0.00876609f, 0.02805139f, 0.00950727f, -0.02262042f, 0.02469066f, -0.03582400f, -0.03714764f, 
    0.01646231f, -0.01082291f, 0.00186228f, -0.03385182f, 0.00420012f, 0.00565742f, 0.03338003f, -0.00129165f, 
    -0.00240450f, -0.02489298f, -0.02804442f, -0.03296300f, -0.00594477f, 0.01675797f, 0.01934118f, -0.01798350f, 
    0.03117600f, -0.03664003f, -0.01392715f, 0.01457264f, -0.03898101f, 0.02913439f, 0.00880746f, -0.03257099f, 
    0.03370728f, 0.03144602f, 0.01431733f, 0.01942184f, 0.00158966f, 0.01735335f, 0.00057842f, -0.02456335f, 
    -0.01867482f, -0.03919848f, -0.00383490f, 0.02840447f, 0.00243036f, 0.03101698f, 0.00714284f, -0.03376570f, 
    -0.02045963f, -0.00446754f, -0.01483790f, 0.02032857f, 0.02564362f, -0.01558627f, 0.01371829f, 0.02394519f, 
    -0.00962187f, -0.02088502f, -0.02958312f, 0.02070920f, 0.00761090f, -0.02328632f, -0.01767140f, -0.01011122f, 
    0.00484595f, 0.01020003f, 0.01030481f, -0.00399828f, -0.00500245f, 0.03117291f, -0.01042604f, -0.01373655f, 
    -0.03083071f, -0.02994919f, -0.01200646f, 0.02072866f, 0.03319474f, 0.00690362f, -0.00736562f, -0.01553977f, 
    -0.02135575f, -0.02535003f, 0.02925286f, -0.00549549f, -0.01328567f, -0.02905393f, 0.00846277f, 0.03004231f, 
    0.01321824f, -0.02260967f, -0.02241964f, -0.00624524f, -0.01640105f, 0.02849249f, -0.00608922f, -0.00963144f, 
    -0.02506671f, -0.00626356f, 0.01128255f, -0.02746955f, -0.02575826f, 0.01762622f, 0.00826398f, -0.02400929f, 
    -0.00425015f, 0.03136813f, 0.01282228f, -0.00091290f, -0.02631304f, -0.03918670f, -0.02918763f, -0.03840356f, 
    -0.00867206f, -0.01785942f, 0.00160641f, 0.02601088f, 0.01577176f, 0.02477900f, 0.01661965f, -0.02343462f, 
    -0.03885414f, 0.00925353f, -0.03323475f, -0.02424265f, -0.00287599f, -0.02105462f, -0.03919295f, -0.03351437f, 
    -0.02367595f, -0.01348848f, -0.01987983f, 0.03161472f, 0.01607849f, -0.03291022f, -0.01296155f, 0.02432723f, 
    -0.01356037f, -0.03115962f, -0.03166547f, -0.03265325f, -0.00889084f, 0.02818712f, -0.01398017f, -0.04353176f, 
    0.03425827f, -0.01858602f, -0.02314854f, -0.04089599f, 0.01560844f, 0.00620142f, -0.03722354f, 0.01166620f, 
    -0.02922629f, 0.02979868f, 0.03304817f, -0.03227021f, 0.00873862f, 0.00582997f, 0.02520698f, 0.01349024f, 
    -0.04381135f, -0.02831711f, 0.02717449f, -0.02559344f, 0.01954089f, -0.01855126f, -0.00570681f, -0.02368924f, 
    -0.02840257f, 0.02926401f, 0.03424726f, -0.01829270f, 0.03149427f, 0.00603620f, -0.00276345f, 0.02522273f, 
    0.32679617f, -0.01409146f, -0.04591017f, 0.17745459f, 0.11609603f, -0.01888164f, -0.10188883f, 0.12104511f, 
    0.05221843f, 0.03837583f, -0.03675194f, -0.02483501f, -0.31909505f, 0.14236695f, -0.25503668f, 0.11858795f, 
    0.08041526f, 0.06778453f, -0.00808423f, -0.07378165f, -0.00154048f, 0.06875321f, -0.08131509f, 0.05456926f, 
    0.01046381f, -0.06473950f, 0.09754036f, 0.19908939f, -0.14809352f, -0.04383988f, 0.12408849f, 0.07166271f, 
    -0.06147644f, 0.02357403f, -0.05318996f, 0.09610257f, -0.35345131f, 0.00776075f, -0.07122246f, -0.36771691f, 
    0.08751100f, 0.08256075f, 0.02774283f, -0.07228498f, -0.06316623f, -0.01122653f, 0.04982171f, -0.06067165f, 
    -0.00876071f, -0.18780008f, -0.16078542f, -0.24917255f, 0.17808306f, -0.02406743f, -0.07344026f, 0.06720673f, 
    0.02701625f, -0.00553272f, 0.11376952f, 0.05134752f, 0.14133465f, -0.06612813f, 0.07206967f, 0.07630481f, 
    -0.00476709f, -0.04596151f, -0.00109292f, -0.02153592f, -0.03533993f, 0.11341794f, -0.03926122f, 0.04220671f, 
    -0.08965404f, 0.04284793f, 0.13531248f, 0.25460902f, -0.14090297f, 0.07290906f, 0.08149645f, 0.01432120f, 
    -0.10642375f, -0.07881907f, 0.09958043f, 0.00434014f, -0.11413164f, -0.01249730f, 0.02239770f, -0.22067748f, 
    -0.06411252f, -0.03571907f, 0.02234359f, -0.05270605f, 0.03571543f, 0.02004173f, -0.09309491f, 0.07770333f, 
    0.43955851f, -0.29096341f, 0.11588273f, -0.23888144f, 0.12893113f, -0.05457442f, 0.05683942f, 0.01063721f, 
    0.05756276f, 0.05583639f, 0.02103732f, 0.03171484f, -0.01043460f, 0.09033570f, -0.24431883f, 0.38738620f, 
    0.15645713f, 0.06079333f, -0.12041908f, 0.05055078f, -0.04073431f, 0.05947359f, -0.01460073f, 0.01761267f, 
    -0.18109277f, 0.02013808f, -0.09422425f, -0.31654167f, 0.03506785f, 0.05602624f, 0.09284677f, 0.01748845f, 
    -0.13198096f, -0.11578847f, 0.03700215f, -0.00244049f, -0.30549550f, -0.00638148f, -0.06385062f, -0.31843871f, 
    0.18274970f, 0.01587536f, -0.03990044f, -0.05607926f, 0.04822683f, 0.08226103f, 0.06847180f, 0.03734165f, 
    0.27431422f, 0.24824300f, 0.05101598f, 0.12901162f, -0.02508134f, -0.02850593f, -0.12162168f, -0.01565924f, 
    0.14095990f, 0.06089080f, -0.07897130f, -0.01283419f, -0.15665334f, 0.22639230f, 0.01567508f, 0.18641201f, 
    0.08932814f, 0.05514312f, 0.03136596f, 0.21797341f, 0.07982612f, 0.01918220f, 0.08495774f, -0.10824456f, 
    -0.02366783f, 0.16204633f, -0.06584001f, 0.46360004f, 0.06740080f, 0.11429138f, -0.03327852f, 0.11863589f, 
    -0.00314363f, -0.03329878f, 0.02825267f, 0.07192922f, -0.30419514f, 0.20186858f, -0.00948087f, -0.04500698f, 
    0.01168894f, 0.10933826f, -0.04450977f, 0.07301440f, 0.08703464f, -0.05596375f, 0.02108623f, -0.08943669f, 
    -0.32332537f, -0.11704715f, -0.06209325f, -0.24115209f, 0.02913862f, 0.03212328f, -0.00784406f, -0.08462607f, 
    -0.08317879f, -0.07146449f, 0.04766333f, 0.01767627f, -0.05610650f, 0.15152851f, -0.14017278f, -0.00136371f, 
    0.04628485f, -0.00157750f, -0.09932662f, 0.04475235f, -0.01757411f, -0.02609364f, -0.11231661f, -0.09693036f, 
    -0.02930792f, 0.04138292f, 0.14302319f, -0.22557853f, -0.00413062f, -0.02190303f, 0.05881921f, 0.01245343f, 
    0.01512188f, -0.03503906f, 0.06900201f, -0.06463436f, -0.18107346f, 0.07685610f, 0.10993254f, -0.10633756f, 
    0.03370658f, -0.04121472f, 0.03702279f, 0.01941432f, -0.03061211f, -0.02059966f, -0.04831965f, 0.03900875f, 
    0.22329557f, 0.00588734f, -0.10421125f, 0.20166646f, 0.02191205f, 0.02849201f, -0.09430038f, 0.10630738f, 
    0.01814790f, -0.01491555f, -0.01365113f, 0.01206813f, -0.21284796f, 0.02142491f, -0.06564829f, 0.39552504f, 
    0.08433084f, 0.15684010f, -0.02275600f, 0.06914696f, 0.09313969f, -0.03368610f, 0.03376765f, -0.00406956f, 
    -0.01985677f, -0.06622684f, -0.05153951f, 0.18481670f, -0.01784587f, -0.00449918f, 0.07631967f, -0.00149581f, 
    -0.13154663f, 0.02161346f, 0.05391268f, -0.07293570f, -0.06655560f, -0.01982418f, 0.25230506f, -0.31773901f, 
    0.06792472f, -0.03363829f, 0.22025184f, -0.11359002f, -0.12325329f, -0.01603274f, 0.02511344f, -0.07642562f, 
    -0.23334941f, 0.07207073f, 0.02572819f, 0.00861579f, -0.14968815f, 0.00322721f, 0.05227965f, -0.15887029f, 
    -0.03692997f, 0.01097164f, 0.04032929f, 0.01945706f, -0.11955382f, 0.10670709f, 0.00271562f, 0.04829914f, 
    0.00682900f, 0.09188269f, 0.02711588f, 0.08874632f, 0.00240692f, 0.06937858f, -0.04590774f, -0.06168836f, 
    -0.11344454f, 0.22065848f, 0.07307862f, 0.33067045f, 0.06852968f, 0.13010427f, 0.04554405f, 0.13725832f, 
    0.02856658f, -0.03740162f, 0.10510562f, -0.04828259f, -0.08634391f, -0.06968377f, 0.08253890f, -0.05187473f, 
    -0.15491292f, -0.02873828f, 0.10410315f, -0.18440993f, -0.07939154f, 0.03712418f, 0.08791213f, -0.05256561f, 
    0.33417696f, 0.12346209f, 0.10965459f, 0.16852862f, 0.07957797f, -0.02575568f, 0.14907613f, 0.05942309f, 
    0.01500289f, 0.05963635f, -0.05352353f, 0.09008437f, 0.33769125f, 0.27179676f, 0.21168639f, -0.15631014f, 
    0.18092424f, 0.07257764f, 0.00881651f, 0.06354835f, 0.05435758f, 0.18341883f, 0.06513599f, 0.01778723f, 
    -0.08649044f, 0.05861886f, -0.16012667f, 0.03459059f, 0.08804609f, 0.09594069f, 0.06012836f, -0.00353291f, 
    -0.09107726f, 0.09542254f, -0.00223755f, -0.05019960f, 0.13245186f, -0.14270015f, -0.01003686f, 0.26981577f, 
    0.09355888f, 0.04513389f, -0.06483893f, -0.05131428f, -0.03491873f, 0.04548937f, -0.00432090f, 0.00777360f, 
    0.16224323f, 0.14323440f, -0.08110727f, 0.28074163f, -0.03412147f, 0.03355389f, 0.00959605f, 0.04472087f, 
    -0.00311148f, 0.05039565f, 0.09985959f, 0.15043163f, -0.11337246f, -0.23428223f, 0.09782851f, 0.07096731f, 
    -0.00030479f, -0.11486968f, 0.16110030f, -0.01091329f, -0.10577320f, -0.01315834f, 0.06140610f, 0.00882876f, 
    0.18453546f, -0.03358227f, -0.21074191f, 0.39806181f, -0.04058584f, -0.05505428f, 0.03253072f, 0.03051848f, 
    0.08902024f, -0.02706494f, -0.02961607f, -0.14903860f, -0.12148102f, 0.17047119f, -0.09300155f, -0.12420416f, 
    0.03262450f, -0.00971607f, 0.12115814f, -0.00042796f, 0.19334689f, -0.01791033f, 0.07496270f, -0.06177594f, 
    -0.27589318f, 0.10562039f, 0.02194041f, 0.09010247f, 0.08345174f, 0.19687223f, 0.01242598f, -0.00184660f, 
    0.09939026f, 0.08493301f, -0.02661023f, 0.01375088f, 0.32357037f, -0.03176579f, 0.01319507f, 0.24265675f, 
    0.02169649f, -0.03942263f, -0.06497308f, 0.02875816f, 0.00515624f, -0.02980497f, -0.05153758f, -0.01055272f, 
    0.38900873f, -0.05944249f, 0.32592633f, 0.00961954f, -0.04804840f, -0.07547452f, 0.20761517f, 0.03830185f, 
    -0.00504845f, 0.09781238f, 0.04578349f, 0.04886242f, -0.01982177f, 0.00084574f, -0.19623351f, 0.32528844f, 
    0.00806797f, 0.01336963f, -0.08279964f, 0.06384318f, 0.10496408f, 0.06008234f, -0.09403919f, -0.01661739f, 
    0.10535195f, 0.23248765f, 0.17410652f, -0.09041652f, 0.05706067f, 0.16080110f, 0.07453566f, -0.04481756f, 
    0.00078015f, 0.14550248f, 0.04946000f, -0.02149429f, 0.12321085f, 0.14268897f, 0.09048745f, 0.07460473f, 
    -0.04383156f, 0.04797955f, -0.03581183f, -0.08287589f, -0.15317881f, 0.13829646f, 0.06260085f, 0.03995047f, 
    -0.29393861f, 0.01061300f, 0.07076434f, 0.19248827f, 0.15034696f, -0.02631291f, 0.05385619f, 0.06468251f, 
    -0.07108059f, 0.03262723f, 0.02286139f, 0.09310100f, 0.37504837f, -0.08950475f, 0.00168718f, 0.13020387f, 
    0.06254449f, -0.08106241f, -0.02991040f, 0.03738531f, 0.02977378f, -0.11698315f, -0.12524112f, 0.03794409f, 
    0.25043145f, -0.04072224f, 0.25673285f, -0.01794812f, -0.03105817f, -0.09328126f, 0.10611846f, -0.02210722f, 
    -0.06721183f, -0.01106898f, 0.03988598f, -0.01256479f, -0.18691713f, -0.02664931f, 0.15173273f, -0.10527544f, 
    -0.17288174f, -0.00717622f, 0.13376483f, -0.00057469f, 0.09489110f, 0.04609149f, 0.04894082f, -0.04984705f, 
    -0.08748935f, 0.19005167f, -0.01974547f, 0.18742178f, -0.04436951f, -0.01306639f, 0.06880441f, -0.01409553f, 
    0.02525839f, -0.05389633f, 0.01590991f, 0.09639928f, -0.01909746f, 0.11075567f, 0.22741666f, -0.14657192f, 
    0.00354435f, -0.00159301f, 0.06073312f, -0.01701597f, -0.02522450f, -0.01457914f, -0.06245146f, -0.02020330f, 
    0.21196331f, -0.04713507f, -0.01455687f, 0.09774202f, -0.07128859f, 0.06421019f, 0.02968290f, -0.02424925f, 
    -0.04951576f, 0.02404733f, 0.06085203f, 0.01085504f, 0.22554341f, -0.00184632f, 0.29564017f, 0.06737068f, 
    0.04205757f, 0.01873856f, 0.09269492f, -0.08771605f, 0.11700193f, 0.07345357f, 0.23318858f, 0.09002932f, 
    0.05321224f, 0.18731195f, -0.08699167f, 0.21293886f, -0.05426066f, -0.01007313f, -0.14358185f, 0.03296129f, 
    0.01954793f, -0.05138330f, -0.02289474f, -0.08244555f, -0.23350112f, 0.03657965f, -0.09255387f, -0.29256994f, 
    0.05274136f, 0.00646936f, -0.02011686f, -0.03895230f, 0.07332836f, 0.04960107f, 0.06250390f, 0.11308376f, 
    0.16883677f, -0.07091406f, -0.15680391f, 0.14978462f, -0.00579050f, 0.03807978f, 0.02391440f, -0.01385372f, 
    -0.11661937f, -0.01463682f, 0.00940969f, -0.07199523f, -0.15676992f, 0.04284270f, -0.11017533f, -0.29323947f, 
    0.03244184f, 0.08972862f, -0.01097609f, 0.02515515f, -0.03855425f, -0.01572625f, 0.07425347f, -0.03800654f, 
    -0.25543031f, -0.06510241f, 0.07779945f, -0.09383532f, -0.01398106f, 0.17043489f, 0.04838277f, -0.03654172f, 
    0.03542473f, -0.00927718f, 0.04645855f, 0.05712101f, 0.04586674f, 0.19367997f, 0.05095220f, -0.12564957f, 
    0.05478498f, 0.01712557f, 0.02748970f, -0.10045607f, -0.04331087f, 0.08426801f, -0.04406201f, 0.04089578f, 
    0.12239968f, 0.08306906f, -0.01657862f, 0.13243750f, -0.00702019f, 0.01640820f, -0.04497131f, 0.07010571f, 
    0.09238794f, 0.08855759f, 0.02861628f, 0.03216949f, 0.16606684f, 0.01386737f, 0.07356020f, 0.14295837f, 
    -0.03451833f, -0.11116000f, 0.08748443f, -0.02894261f, 0.04304617f, 0.04825109f, 0.03266983f, 0.11306030f, 
    0.13788617f, -0.06806181f, -0.17775519f, -0.23611106f, 0.14527886f, -0.00290461f, 0.01690833f, 0.07622167f, 
    -0.07638630f, 0.12040576f, 0.00144196f, 0.01651123f, 0.04714076f, 0.04053461f, 0.11179084f, -0.25090820f, 
    0.11311004f, 0.07101002f, 0.16388899f, 0.15596773f, -0.06636809f, 0.07173302f, 0.04408205f, 0.00672272f, 
    0.07112353f, -0.15365258f, 0.11892988f, 0.43993729f, 0.05229571f, -0.06457944f, 0.05152944f, 0.04376358f, 
    0.05690035f, 0.09548859f, 0.01144979f, 0.06018383f, 0.14086673f, 0.26388827f, -0.00129991f, -0.04567508f, 
    -0.05180284f, -0.04114974f, -0.05162780f, -0.14601508f, 0.01409024f, 0.00338171f, -0.03073441f, -0.00667100f, 
    0.34329391f, 0.06591985f, -0.18149602f, 0.19472767f, 0.01466469f, -0.02716024f, 0.01078255f, 0.10767954f, 
    0.02837026f, 0.04257563f, 0.11774328f, 0.11060778f, -0.03715405f, -0.28913209f, -0.05955129f, -0.04848587f, 
    0.09768268f, 0.02023550f, -0.01476981f, -0.00678405f, 0.08943499f, -0.07515860f, -0.03238653f, 0.07741412f, 
    -0.01025486f, -0.01800909f, 0.00692719f, -0.02399516f, 0.00167220f, -0.04023907f, -0.01371046f, -0.04160354f, 
    0.01527017f, 0.00346802f, 0.00248368f, 0.01706840f, -0.02935451f, -0.01078725f, -0.03957002f, 0.01035828f, 
    -0.03243920f, 0.01186175f, -0.00524805f, -0.00545353f, -0.04256880f, 0.01891962f, 0.01828600f, -0.04125084f, 
    0.00167727f, 0.00473213f, -0.03653321f, -0.03225386f, 0.01725793f, -0.04099378f, -0.02218742f, -0.03741996f, 
    -0.04235884f, -0.01579083f, -0.00825374f, -0.02457357f, 0.00692451f, -0.00933543f, 0.00168411f, 0.00985507f, 
    -0.01507864f, -0.04173995f, -0.00674109f, 0.02361638f, -0.00601400f, -0.03935095f, -0.00786699f, -0.00728092f, 
    -0.00631473f, -0.03157726f, -0.02766092f, -0.00337355f, -0.01758993f, -0.00306280f, -0.01828259f, -0.02770862f, 
    -0.04021354f, -0.04005039f, -0.01455237f, -0.03078972f, -0.03346864f, -0.01272087f, -0.02041676f, -0.03133756f, 
    0.01168051f, -0.02638168f, 0.01687418f, -0.00745023f, 0.01035095f, -0.00291970f, -0.04318036f, 0.01277774f, 
    -0.02382921f, -0.00309458f, 0.01686932f, -0.04035151f, -0.02699801f, 0.00573952f, -0.01509987f, -0.02639841f, 
    0.01495344f, 0.00553387f, -0.03426470f, 0.01703785f, -0.01136796f, -0.00760826f, -0.04042757f, -0.03336629f, 
    -0.03467784f, -0.02671394f, 0.00756491f, -0.00921976f, 0.01568370f, -0.02352824f, -0.02024306f, 0.01307105f, 
    0.02803580f, 0.00055726f, 0.02146452f, 0.01607879f, -0.02815754f, -0.02002174f, -0.03587146f, -0.01723756f, 
    -0.02074166f, 0.02148545f, -0.02532565f, -0.00900115f, -0.01330762f, 0.00061281f, 0.02828722f, 0.00889258f, 
    -0.03553861f, -0.02639535f, -0.01232835f, 0.01005906f, -0.04094406f, -0.02169714f, -0.02365556f, -0.01257929f, 
    0.02192447f, 0.02650550f, 0.01609079f, 0.00214390f, 0.00208651f, -0.04294607f, -0.02760384f, 0.00798053f, 
    -0.02628838f, 0.02789142f, 0.01227038f, 0.00534870f, 0.02331064f, -0.01472656f, -0.03190016f, 0.02211215f, 
    0.00541098f, -0.01974162f, 0.02832141f, -0.00196473f, 0.00419250f, 0.00197328f, -0.01032803f, -0.01226025f, 
    -0.03092339f, -0.03132839f, 0.00336536f, -0.00904688f, 0.02007497f, 0.01644003f, -0.00572445f, -0.03310047f, 
    0.00635827f, 0.00320004f, 0.02634000f, -0.04147145f, 0.02359444f, -0.01531929f, 0.01897410f, -0.02997495f, 
    0.01719878f, 0.00699190f, 0.02698083f, 0.00846130f, -0.03538704f, -0.04251758f, 0.00489458f, -0.02540234f, 
    0.02249705f, -0.01296646f, -0.00809002f, -0.02931574f, -0.01882173f, 0.01145426f, -0.02222442f, -0.00500583f, 
    -0.00910875f, 0.02343484f, -0.00602630f, 0.02293948f, -0.00853832f, -0.03842916f, 0.01021525f, 0.01357906f, 
    -0.00591465f, 0.02082266f, 0.01836959f, 0.00211697f, -0.02591563f, -0.02355121f, 0.00530200f, -0.00586531f, 
    -0.01659008f, 0.01543695f, -0.00531752f, -0.03488393f, 0.00884155f, -0.02591777f, 0.00657335f, -0.02276910f, 
    0.00762316f, 0.01976558f, 0.00049264f, 0.00361923f, -0.01420695f, -0.02932267f, 0.02460397f, -0.03010905f, 
    -0.00647974f, 0.01355017f, 0.00636495f, -0.01127861f, -0.01123325f, 0.02435005f, -0.02173524f, -0.00486626f, 
    -0.02295332f, 0.02313796f, -0.02994826f, 0.00337269f, -0.00676036f, 0.00608238f, -0.03026098f, -0.02298566f, 
    0.02054047f, 0.00918746f, 0.02164418f, 0.01279717f, 0.01271983f, -0.01235489f, 0.00240379f, -0.00409049f, 
    -0.04298405f, -0.00751401f, -0.03651960f, 0.01942140f, 0.02771238f, 0.02326952f, -0.01515994f, -0.00357154f, 
    0.01669325f, -0.00881588f, -0.03725858f, -0.02434503f, 0.01676332f, 0.02762956f, -0.01129246f, -0.02704132f, 
    0.00085735f, -0.03654515f, 0.02410219f, -0.00808312f, 0.00921065f, 0.00664241f, 0.01836579f, 0.01203675f, 
    -0.00470295f, -0.01540497f, -0.03695663f, -0.02100549f, 0.01981737f, 0.01963363f, -0.01631316f, -0.00889253f, 
    -0.02961770f, -0.02242411f, -0.01149787f, 0.00407348f, -0.02801577f, 0.00488506f, -0.01441877f, 0.01331418f, 
    -0.03156934f, 0.00497938f, 0.00342819f, -0.03270443f, -0.02072482f, 0.00953110f, 0.00860633f, -0.01733603f, 
    -0.03929295f, 0.02776914f, 0.00896692f, -0.00188558f, -0.00471826f, 0.02829108f, -0.04154936f, -0.02576665f, 
    0.01060746f, 0.00193333f, 0.00405244f, -0.02827061f, -0.01547772f, 0.02345974f, -0.01178219f, -0.03847048f, 
    -0.00666641f, -0.01304704f, 0.00045210f, -0.00834742f, 0.00030079f, -0.02029446f, -0.00990273f, 0.01659882f, 
    0.02183638f, 0.00717949f, -0.01643951f, -0.01712349f, -0.00161865f, -0.01446856f, -0.02439909f, -0.01863115f, 
    -0.01517896f, -0.03363787f, 0.02310453f, 0.01388363f, 0.01446793f, -0.01418242f, -0.00404371f, 0.00925558f, 
    -0.02121152f, 0.02799312f, -0.03031048f, -0.02107115f, -0.03283359f, -0.00051463f, 0.01386053f, -0.04086507f, 
    -0.00650328f, -0.03969840f, -0.02844188f, 0.02544439f, -0.00854003f, -0.01500735f, -0.02840965f, -0.00788174f, 
    -0.02420674f, 0.03407731f, 0.01627601f, -0.00397777f, -0.02728529f, -0.01403912f, -0.02939967f, -0.03002173f, 
    -0.02142422f, -0.02873029f, -0.01666608f, -0.00253567f, -0.02393468f, -0.02478275f, -0.01739032f, -0.02021756f, 
    0.01526501f, 0.01446437f, -0.01696238f, 0.00358731f, -0.00724625f, -0.04093319f, -0.04011681f, -0.02131378f, 
    -0.03430596f, 0.00479435f, -0.03820360f, -0.00003024f, 0.00492861f, -0.03264385f, 0.00149274f, 0.00848149f, 
    0.01954911f, -0.02478301f, 0.02713136f, 0.01091641f, -0.03704708f, 0.01671913f, -0.00879302f, 0.03476868f, 
    -0.03916488f, 0.01674002f, 0.00950803f, -0.01384714f, 0.01696306f, -0.00570251f, -0.00817102f, -0.00124934f, 
    -0.03986413f, -0.02118662f, 0.02087846f, -0.03946147f, 0.02919639f, -0.01304630f, 0.03103909f, -0.01037279f, 
    -0.01013559f, 0.00516434f, -0.03560472f, -0.01873923f, -0.03459604f, -0.02267825f, -0.00819305f, -0.02383632f, 
    -0.02771381f, -0.02707626f, -0.03203402f, 0.01378986f, -0.02927845f, 0.01559759f, 0.02345683f, -0.02526588f, 
    0.00139272f, -0.03983284f, 0.01196373f, -0.00110588f, 0.00448795f, -0.03790889f, -0.03637112f, 0.00532873f, 
    -0.03025549f, -0.02447067f, 0.00704026f, 0.01110352f, -0.03956714f, -0.01585423f, 0.00637997f, 0.01403392f, 
    -0.03862609f, 0.01067676f, -0.03056297f, -0.03946257f, -0.02022983f, -0.00516879f, -0.02853090f, -0.03174161f, 
    0.02819220f, 0.00985263f, -0.04294311f, 0.00551647f, -0.01656821f, -0.01877038f, -0.03178637f, 0.00764294f, 
    0.02763937f, 0.00247096f, -0.00141109f, 0.01329468f, -0.00806955f, -0.00479051f, -0.02224070f, 0.01381562f, 
    0.02057775f, 0.02611160f, -0.03189413f, -0.02103665f, 0.02075480f, 0.00734282f, -0.03909981f, -0.03405416f, 
    0.01164682f, 0.02157248f, 0.01441901f, -0.03896241f, -0.04230785f, -0.03425091f, -0.01449178f, 0.01883688f, 
    -0.03027653f, -0.00669906f, -0.01559119f, 0.01894614f, 0.00489807f, 0.02769899f, -0.03862978f, 0.02120181f, 
    -0.01023470f, -0.04156652f, -0.04211133f, 0.00093807f, -0.01110706f, 0.01420200f, -0.02271851f, -0.01694337f, 
    0.02049793f, -0.02133607f, -0.00876914f, -0.00097502f, -0.01901200f, -0.01029269f, 0.02611499f, -0.02773022f, 
    -0.03018866f, -0.02361321f, -0.01719374f, 0.01830039f, -0.03002170f, 0.01692361f, -0.04214312f, 0.01047130f, 
    0.01981285f, -0.01086537f, -0.02232726f, -0.02782243f, -0.03549008f, -0.02242882f, 0.01831831f, 0.01952439f, 
    0.02419071f, -0.00695592f, -0.03711866f, 0.02343398f, 0.01746576f, -0.03214636f, 0.02726468f, -0.00078034f, 
    -0.04069216f, -0.02091727f, -0.03716645f, 0.01322029f, 0.01713326f, -0.01427576f, 0.00189453f, 0.01302582f, 
    0.02439694f, -0.03536234f, 0.00195125f, 0.01678790f, -0.02780512f, -0.01477902f, -0.03943581f, -0.00977597f, 
    0.02635578f, -0.02095730f, -0.01368710f, -0.03177950f, -0.01993843f, 0.00167436f, 0.00266045f, 0.02827197f, 
    -0.00531469f, -0.00201714f, 0.02287843f, -0.00335745f, -0.00784899f, 0.00085268f, -0.02287227f, -0.03834594f, 
    -0.03173881f, -0.02573049f, 0.01041350f, 0.02639934f, 0.00582569f, 0.00907122f, -0.01812373f, -0.01100443f, 
    0.00476846f, 0.02746892f, -0.02353253f, -0.03734458f, -0.01515340f, -0.02841912f, 0.02433603f, -0.01691501f, 
    -0.00975433f, -0.02282387f, -0.01522523f, 0.02548383f, 0.00773314f, -0.02198242f, 0.02493509f, -0.03973234f, 
    -0.00694566f, -0.03434717f, -0.01571148f, 0.00130473f, 0.01658488f, 0.02340727f, -0.01313151f, 0.02502915f, 
    0.01772323f, -0.03714986f, -0.03568308f, -0.03670047f, 0.00765300f, 0.02677273f, 0.01594373f, -0.01408156f, 
    -0.00313394f, 0.00972306f, -0.03539051f, 0.00266749f, -0.03507725f, -0.01149634f, -0.02150929f, 0.00042711f, 
    -0.01494979f, -0.03345539f, 0.01806111f, -0.00193330f, -0.00783058f, -0.02111568f, 0.01523691f, -0.02401035f, 
    0.01986066f, -0.01806909f, 0.01734225f, 0.01031349f, 0.02974900f, -0.02284643f, 0.01504908f, -0.02674289f, 
    -0.03265321f, -0.01230716f, 0.02619287f, 0.02047451f, -0.03021887f, -0.03823989f, 0.02315856f, -0.03115239f, 
    -0.02460903f, -0.04044235f, -0.01916891f, 0.01265099f, -0.03622692f, 0.00721631f, -0.01031915f, -0.03856248f, 
    -0.03145353f, -0.04292103f, -0.01692115f, -0.00624527f, 0.01727341f, -0.04346852f, -0.02489828f, -0.02729610f, 
    -0.03731438f, 0.02156049f, -0.00166824f, 0.00870879f, 0.00223222f, 0.00009747f, 0.01307575f, -0.03388286f, 
    -0.01100257f, -0.01487423f, 0.02273108f, -0.01056968f, -0.01348390f, 0.01977968f, -0.03296850f, -0.01073478f, 
    0.00109423f, -0.02170044f, -0.02748607f, 0.00143972f, -0.01479175f, 0.00257031f, -0.01155365f, 0.00991903f, 
    -0.01751615f, 0.02349667f, -0.00673136f, -0.02858182f, 0.00303221f, -0.01882890f, 0.01221276f, -0.02154526f, 
    0.00829979f, 0.01997448f, 0.02315186f, -0.03896579f, -0.00798607f, -0.03270791f, 0.00833001f, -0.04308188f, 
    -0.00475949f, -0.01229437f, 0.02423112f, 0.01944457f, 0.00443627f, 0.01457488f, -0.00262516f, -0.03079716f, 
    0.02773504f, 0.01770237f, 0.01216192f, 0.01281612f, 0.00824908f, 0.01527520f, -0.01620007f, 0.01200399f, 
    -0.03390000f, -0.00179636f, -0.00748163f, -0.02983786f, -0.00718669f, -0.01455515f, -0.01244266f, -0.03651619f, 
    -0.01359201f, 0.03600310f, -0.03505117f, 0.01110972f, 0.02736192f, -0.01935869f, -0.01195624f, -0.04147874f, 
    0.01736768f, 0.01562049f, 0.00186011f, -0.02071737f, -0.03905693f, -0.01587474f, -0.01711130f, 0.01360175f, 
    -0.02831194f, -0.01962870f, -0.00159527f, 0.02158666f, -0.04268305f, -0.04011743f, -0.03818492f, 0.01730487f, 
    -0.03053095f, 0.01638203f, 0.00689622f, -0.03410203f, 0.02110131f, -0.03538143f, -0.03588431f, -0.02446757f, 
    0.01787866f, -0.01451505f, -0.00276131f, -0.02184012f, -0.02812092f, 0.02056688f, 0.02039751f, -0.02551265f, 
    -0.01686449f, -0.01091624f, -0.03893377f, -0.00085105f, 0.00130174f, -0.00001581f, 0.01813294f, -0.04124189f, 
    -0.03807728f, 0.00302053f, -0.01597382f, -0.02072756f, -0.03148827f, -0.03919265f, -0.00325949f, 0.01275724f, 
    -0.03732463f, -0.01042576f, -0.03187038f, 0.02165993f, 0.01658193f, 0.02217181f, -0.00061255f, 0.00973284f, 
    -0.03782777f, -0.02209283f, 0.02675193f, -0.01813577f, 0.00447225f, 0.01373887f, 0.02366906f, 0.02544368f, 
    0.29425675f, 0.11763813f, -0.21260309f, 0.33134648f, -0.04860060f, 0.16921934f, 0.00907886f, -0.01660819f, 
    -0.04639479f, 0.09339833f, -0.03808868f, 0.06027357f, -0.13763395f, -0.14368321f, 0.02399046f, -0.14277948f, 
    0.02804727f, 0.06142896f, 0.02240310f, 0.07289394f, 0.02467522f, 0.02453109f, 0.02998029f, -0.02620911f, 
    -0.22535563f, 0.09839397f, 0.25515744f, -0.16230184f, -0.03868226f, 0.03339516f, 0.10330728f, -0.03199508f, 
    0.08470779f, 0.10270351f, 0.00677871f, 0.04360142f, 0.14456786f, -0.23594198f, -0.06511684f, 0.21776658f, 
    -0.11655584f, -0.00199868f, 0.04349680f, 0.06402257f, 0.07123502f, 0.07424603f, -0.04258308f, 0.01418981f, 
    -0.14746314f, -0.11158947f, -0.08459713f, -0.00414293f, -0.08444002f, -0.14039567f, 0.06120273f, 0.02405686f, 
    -0.02139062f, 0.12347102f, -0.16783822f, 0.02373341f, -0.11729743f, 0.22849891f, 0.13905029f, -0.10992295f, 
    -0.02369451f, 0.04058526f, 0.14720915f, -0.01602665f, -0.02472295f, 0.08662800f, 0.03225572f, 0.09201878f, 
    0.55798930f, 0.27939305f, -0.12239423f, 0.03352941f, -0.07019316f, 0.08641564f, -0.00668118f, 0.11448543f, 
    -0.09143829f, 0.02472353f, 0.14497457f, 0.07455914f, -0.38418296f, -0.13992016f, 0.10521581f, -0.13015440f, 
    -0.07182918f, 0.03754652f, 0.05948564f, 0.12674354f, -0.18356064f, 0.17605974f, -0.02314234f, -0.04159120f, 
    0.03591466f, 0.14063251f, -0.05610070f, -0.10194828f, 0.04846682f, 0.09529179f, 0.04913533f, -0.01269155f, 
    0.03632591f, 0.06311078f, 0.02864463f, -0.06074552f, 0.23800686f, 0.02149997f, 0.01339578f, 0.25681350f, 
    0.00044810f, -0.01463838f, 0.07604403f, -0.04314421f, 0.01473020f, 0.04815634f, 0.04872330f, 0.00782663f, 
    0.24002385f, 0.05886349f, -0.14598796f, 0.07472537f, -0.05463287f, 0.06173686f, -0.05747928f, 0.01511265f, 
    0.01901828f, 0.03040375f, -0.05033401f, 0.03468969f, 0.28455958f, -0.18111925f, -0.11932132f, 0.16016081f, 
    -0.12446500f, 0.00848304f, -0.01903836f, 0.07274046f, 0.10362551f, 0.05463581f, -0.03444882f, 0.03894066f, 
    -0.07629431f, -0.04556293f, -0.11170197f, -0.02777310f, -0.10586416f, 0.12665100f, 0.02307858f, -0.13325810f, 
    -0.07959631f, 0.04698399f, -0.02096599f, -0.17377692f, 0.43054023f, -0.01164932f, -0.16890304f, 0.16637619f, 
    0.08189767f, 0.06218796f, -0.01957227f, -0.10875887f, -0.07328692f, 0.07899733f, 0.03948005f, -0.00955136f, 
    0.36455944f, 0.22794667f, 0.01002790f, 0.16690977f, 0.01834369f, 0.03041537f, 0.00717165f, -0.01295077f, 
    0.06658963f, 0.10561764f, 0.04820992f, -0.02801319f, 0.01768095f, -0.18624580f, -0.08029465f, -0.01115171f, 
    0.04765132f, -0.00274953f, -0.19023269f, -0.00622144f, 0.06463593f, 0.00941474f, -0.00885286f, -0.20639658f, 
    0.04380628f, -0.03943399f, -0.13987005f, -0.15394598f, -0.04454053f, -0.07356025f, 0.09866337f, 0.07691221f, 
    0.02148329f, -0.05998052f, -0.09830678f, 0.01358782f, 0.03216144f, -0.30919474f, 0.03602005f, 0.19769578f, 
    0.01480192f, 0.00827195f, 0.02084299f, -0.15772912f, -0.07308806f, -0.02380966f, -0.07679947f, -0.06061743f, 
    0.05223031f, 0.14661859f, 0.16080271f, -0.11388111f, -0.04758513f, 0.07031918f, 0.15281726f, 0.07773229f, 
    -0.09499761f, -0.04842250f, 0.05855499f, 0.05339679f, -0.01319335f, 0.06425135f, -0.18011533f, -0.08405327f, 
    -0.08019093f, -0.10764136f, 0.08208551f, 0.10614157f, -0.03876033f, 0.04891425f, 0.06015995f, -0.02994706f, 
    0.02379814f, -0.05550940f, 0.08832894f, -0.10290579f, -0.04728787f, 0.11546495f, -0.06442464f, -0.02700681f, 
    0.05851026f, -0.10200597f, -0.00399547f, -0.05687801f, -0.19959645f, -0.16067360f, 0.04645966f, -0.20051551f, 
    -0.03439780f, 0.08390093f, 0.10085458f, 0.16881487f, 0.03479085f, 0.08607263f, 0.02006100f, -0.06729373f, 
    0.28759617f, 0.28117624f, 0.23443294f, 0.06228209f, -0.00584423f, -0.04222292f, -0.02364207f, 0.10058303f, 
    0.02012799f, -0.01620810f, -0.01541615f, 0.01997971f, 0.05146094f, -0.17436619f, 0.34788999f, -0.12769547f, 
    -0.09526859f, 0.14562839f, 0.04669965f, -0.07484173f, 0.16733816f, -0.01055338f, -0.06993800f, 0.08930448f, 
    0.40915522f, 0.27053419f, 0.01929740f, 0.02002592f, -0.04387411f, 0.06960555f, -0.01381214f, -0.04252987f, 
    -0.05446091f, -0.00336316f, -0.02851295f, 0.10796532f, -0.08233760f, 0.00521001f, -0.03644098f, 0.11408415f, 
    -0.03713841f, 0.13137193f, -0.07233781f, -0.02496145f, -0.03824465f, 0.11502130f, -0.07367647f, -0.09503917f, 
    -0.06263153f, -0.14950506f, -0.04106867f, -0.18360054f, 0.01358219f, -0.00081246f, 0.19517477f, -0.13339958f, 
    -0.16641551f, -0.03061989f, 0.02698814f, -0.04325657f, 0.00801105f, 0.14529566f, 0.04148071f, 0.03530448f, 
    -0.01981002f, -0.01807361f, -0.03446160f, -0.01026213f, 0.01605823f, 0.06385478f, 0.01678154f, 0.01322861f, 
    0.06472597f, 0.18306455f, -0.00800821f, 0.07343441f, 0.08078191f, 0.00734551f, -0.03702072f, 0.04353361f, 
    -0.12310325f, 0.10702224f, 0.10016856f, -0.02051207f, 0.21892257f, 0.00915180f, 0.02334780f, 0.09840493f, 
    -0.02733441f, 0.03799185f, -0.10324112f, -0.06045248f, 0.00943882f, 0.05050060f, -0.00771264f, 0.04639931f, 
    -0.19123015f, -0.01633297f, -0.18577355f, 0.03463082f, -0.01227876f, 0.00933380f, 0.00492062f, 0.04376779f, 
    0.06950475f, -0.02066084f, 0.11292859f, 0.05828093f, -0.19625008f, 0.16991155f, -0.05469585f, 0.04418952f, 
    -0.02263292f, -0.04569911f, -0.08324331f, -0.10843670f, -0.00450482f, -0.01934402f, -0.07616381f, 0.00314382f, 
    -0.01668522f, -0.14998749f, 0.22035523f, -0.05669326f, -0.16414043f, 0.09956922f, 0.15560618f, 0.00112372f, 
    0.07555831f, -0.02230192f, 0.06155229f, 0.06033790f, -0.04634831f, 0.15145147f, 0.25418261f, -0.08993271f, 
    0.01767619f, -0.10589749f, 0.05816048f, 0.05728527f, 0.00111794f, 0.04462655f, 0.04300237f, -0.07825123f, 
    -0.27504644f, -0.06958235f, -0.01167202f, 0.09454363f, -0.02915067f, 0.02830156f, -0.01142895f, 0.09063473f, 
    -0.00391960f, -0.12732685f, -0.08162140f, -0.03031125f, 0.27814636f, -0.07767656f, 0.06196994f, 0.07814665f, 
    0.03643069f, 0.16781339f, -0.02715682f, 0.01555191f, 0.02568150f, -0.03792626f, 0.14379190f, 0.05778010f, 
    -0.08247376f, -0.09236528f, -0.08419652f, -0.00428272f, 0.06439511f, 0.05272094f, 0.02927434f, 0.01544405f, 
    -0.00666739f, 0.10706422f, -0.01665899f, -0.06105136f, -0.03390833f, -0.11440152f, -0.00093278f, 0.23757096f, 
    -0.06600376f, 0.08335701f, -0.04533570f, -0.02165990f, 0.05739685f, -0.03864238f, -0.16176024f, -0.07469949f, 
    0.21184087f, 0.12994024f, 0.19222245f, -0.33156443f, 0.02017166f, 0.04825255f, 0.04046939f, -0.12343056f, 
    -0.03138498f, 0.07032883f, 0.16984916f, -0.04976823f, -0.22945569f, -0.05495884f, -0.07885092f, 0.00288758f, 
    0.08658389f, -0.03170265f, 0.03749201f, 0.15781868f, -0.01855768f, -0.02907755f, -0.05083766f, 0.03186793f, 
    0.22926965f, 0.06258575f, 0.31262478f, -0.04257027f, 0.07055845f, 0.04693158f, 0.09683646f, -0.03804161f, 
    -0.10524186f, 0.06924707f, -0.11204864f, 0.11056618f, 0.07475536f, 0.20839939f, 0.01461545f, 0.12273961f, 
    0.14634511f, 0.05639537f, -0.08866523f, 0.01360700f, 0.09989275f, 0.16788565f, -0.07231689f, -0.13818504f, 
    0.28293645f, 0.30731663f, 0.03873526f, -0.08559161f, -0.08855297f, 0.02737258f, -0.02989654f, -0.00176514f, 
    -0.01036635f, 0.16846418f, -0.09245327f, 0.00689620f, 0.07188457f, 0.15491493f, 0.06867123f, 0.38429663f, 
    -0.04624525f, 0.01335983f, -0.08032738f, -0.08004741f, 0.08369880f, 0.01792389f, -0.10169049f, -0.03222595f, 
    -0.10167598f, -0.19060580f, 0.29964510f, 0.10529937f, -0.07361381f, 0.11050010f, -0.01088579f, 0.02473853f, 
    0.05725195f, -0.09948162f, 0.23235972f, -0.02335155f, 0.31582117f, 0.10452556f, 0.04698120f, -0.10897765f, 
    -0.06943420f, -0.04502387f, -0.02543425f, 0.01573243f, -0.02803112f, -0.08471789f, -0.03315140f, -0.11377115f, 
    0.43224484f, 0.19996244f, 0.11089420f, 0.03924517f, 0.00035683f, 0.08184862f, 0.03125633f, 0.08080264f, 
    0.01248203f, -0.02962942f, 0.10532602f, -0.04429667f, 0.17019442f, 0.16188172f, 0.14873537f, 0.14847316f, 
    0.09806782f, 0.02720741f, 0.06740666f, -0.05212002f, -0.20736961f, -0.04068891f, -0.18110853f, -0.06818131f, 
    0.10683075f, 0.02871561f, -0.20964983f, 0.24261788f, -0.13528553f, 0.13483140f, -0.03732479f, -0.03523914f, 
    -0.02297093f, 0.03187971f, 0.00285667f, -0.01884625f, 0.20048246f, 0.14455624f, 0.02340643f, 0.02069902f, 
    -0.02190850f, 0.13788542f, -0.01792353f, -0.05633606f, 0.03904331f, 0.04400229f, -0.06011786f, 0.00418077f, 
    0.12495713f, 0.19112790f, -0.00865471f, 0.13780388f, -0.15931922f, -0.02475971f, -0.00544653f, -0.13160163f, 
    0.05175888f, 0.02381792f, -0.02016139f, -0.01814202f, 0.15588519f, -0.22066641f, -0.20896697f, -0.00348724f, 
    -0.04291227f, -0.07175145f, -0.04923864f, 0.02922294f, -0.03116242f, 0.06578024f, 0.01416485f, 0.06290526f, 
    0.15355204f, -0.04975144f, 0.05178868f, -0.07533032f, -0.00061788f, -0.05523795f, 0.01668237f, 0.00153614f, 
    0.05277723f, 0.10502678f, 0.02951344f, 0.12521762f, 0.11458876f, 0.16809151f, -0.04374315f, 0.22730581f, 
    -0.00436635f, 0.08133420f, 0.02490666f, -0.08249348f, 0.10185663f, -0.08437227f, 0.00665723f, 0.07616267f, 
    -0.02949672f, -0.10276440f, -0.23129046f, -0.11244926f, -0.06394668f, -0.10579236f, 0.05534716f, 0.06196454f, 
    -0.07175165f, 0.13153888f, 0.00193829f, -0.03003943f, 0.07871240f, 0.17866215f, -0.20551492f, 0.15506905f, 
    -0.05289707f, 0.00135002f, 0.01538391f, -0.05616983f, -0.02742408f, -0.06630647f, -0.04897723f, -0.07826617f, 
    0.02576170f, 0.31913096f, -0.07815935f, 0.25409040f, -0.02580029f, 0.08793577f, -0.01553658f, 0.00717668f, 
    -0.06239406f, 0.02601912f, -0.09726089f, -0.07527420f, -0.09581836f, -0.20684341f, 0.05211014f, -0.16760369f, 
    -0.11693196f, 0.05902635f, -0.01867907f, -0.02961788f, 0.15975869f, 0.01530811f, 0.02751086f, 0.02359270f, 
    0.35343853f, 0.01719400f, -0.19832012f, 0.47533107f, -0.07424214f, -0.04244428f, -0.03888698f, -0.00426478f, 
    0.04854113f, -0.04473916f, -0.01912140f, -0.01148837f, 0.31201339f, 0.14352368f, -0.05162294f, 0.00147518f, 
    -0.04901785f, -0.08537839f, 0.05522670f, -0.16977733f, -0.00123920f, -0.03657543f, -0.00168022f, -0.05949681f, 
    -0.10483915f, 0.31542739f, -0.04654451f, 0.13031675f, 0.09684419f, -0.04950466f, 0.12184124f, -0.12776256f, 
    0.00815534f, 0.03574535f, 0.00936266f, 0.06283233f, 0.18663113f, 0.07715805f, -0.10109968f, -0.00450935f, 
    0.10687668f, -0.00754212f, 0.06850228f, -0.09094597f, 0.11950432f, -0.04314426f, 0.00117582f, 0.00503347f, 
    -0.31904480f, -0.10715704f, 0.26086318f, 0.05771471f, 0.05324681f, 0.08679655f, 0.02282164f, 0.06323767f, 
    0.01351739f, -0.00159106f, -0.04966640f, -0.09929220f, -0.33605456f, -0.18915972f, 0.17344968f, 0.01223695f, 
    -0.01990996f, -0.09374335f, 0.01601076f, -0.02485249f, 0.06713814f, -0.10538323f, 0.04762735f, -0.05456458f, 
    0.01285848f, 0.02235534f, -0.02132760f, 0.00305575f, -0.03890079f, 0.00502465f, 0.00785775f, -0.01779814f, 
    -0.03045703f, -0.02229672f, 0.00337146f, -0.00772172f, 0.02425378f, -0.01328336f, -0.03060207f, -0.03311120f, 
    -0.03000918f, -0.02095920f, 0.00573128f, -0.00232875f, -0.04800680f, 0.00713128f, 0.00665905f, -0.02219422f, 
    0.02124914f, -0.00133414f, -0.01990785f, 0.00716179f, 0.01492646f, 0.02101335f, 0.01056546f, -0.03183236f, 
    -0.03047839f, 0.00266813f, -0.01659775f, 0.00805757f, -0.02546138f, -0.03100672f, -0.01808519f, 0.00085868f, 
    -0.01773637f, 0.02834161f, -0.02874965f, 0.00723399f, -0.03266063f, 0.01377598f, 0.00553572f, 0.00236264f, 
    0.00196084f, -0.00943843f, 0.03610424f, 0.03005927f, 0.01744885f, -0.02022679f, -0.00592510f, 0.00036595f, 
    -0.03564218f, 0.02931697f, -0.01910732f, -0.02707780f, -0.01480101f, 0.01492911f, -0.04284269f, 0.01521556f, 
    0.00544171f, 0.01874573f, 0.01288934f, 0.02899875f, -0.03402483f, -0.01136706f, 0.00288771f, -0.01373021f, 
    0.00442982f, -0.01389294f, -0.02379666f, -0.00507827f, -0.03535295f, -0.04130576f, -0.01186300f, 0.02048899f, 
    0.01128225f, -0.00966190f, -0.02866680f, -0.01923762f, -0.00523270f, 0.01996139f, 0.00901917f, -0.00344631f, 
    0.01011921f, 0.01130038f, -0.01518568f, 0.00351377f, 0.02610719f, -0.01398264f, 0.02883803f, -0.00988433f, 
    -0.03000064f, -0.03176559f, 0.03245225f, 0.03490890f, 0.00776283f, 0.01516770f, 0.00571626f, -0.03154348f, 
    0.02017215f, -0.01208076f, 0.02521185f, -0.03695799f, -0.00058693f, 0.02270783f, 0.01454188f, -0.03253401f, 
    0.00728258f, 0.01328398f, -0.00667141f, -0.02653049f, -0.03355723f, -0.04171852f, -0.01744391f, 0.03575275f, 
    -0.00631179f, -0.03205398f, -0.00733888f, 0.02829605f, 0.01844119f, -0.01611057f, 0.01448318f, -0.04687441f, 
    0.01307447f, 0.01423756f, 0.01681449f, -0.00512350f, -0.02063592f, 0.01132413f, 0.02472964f, -0.00035193f, 
    -0.01803038f, 0.02187183f, 0.00987220f, 0.01530916f, -0.01133978f, 0.02089766f, -0.04367546f, -0.00687152f, 
    -0.01986867f, -0.04409925f, -0.01619574f, 0.01414058f, -0.03400468f, -0.00825580f, 0.02458025f, 0.00936533f, 
    -0.03591914f, -0.01894527f, 0.01812811f, -0.03029048f, 0.02735443f, 0.02620255f, -0.03693860f, -0.00804474f, 
    -0.01987425f, -0.01517372f, 0.02642497f, 0.02427011f, -0.00568270f, 0.01674392f, -0.01416884f, 0.01847061f, 
    0.00992011f, -0.03763687f, 0.01374759f, -0.03389389f, -0.03114475f, -0.00461291f, -0.00271495f, -0.01460219f, 
    0.00733799f, -0.04195897f, -0.04026652f, 0.02254443f, 0.02948874f, 0.01920122f, -0.03533076f, 0.01114120f, 
    -0.00539188f, 0.01227525f, 0.00928323f, -0.01761457f, -0.00682003f, 0.01145201f, -0.02264135f, -0.01779794f, 
    -0.00894674f, -0.00795990f, 0.02196662f, -0.01792809f, -0.00204893f, 0.00331883f, 0.00694169f, -0.01746338f, 
    -0.03552797f, 0.02047158f, 0.00155550f, -0.02373481f, 0.01556326f, 0.00106905f, 0.01551990f, -0.00790488f, 
    -0.01798633f, 0.00087737f, -0.02738230f, -0.02853206f, -0.02828364f, -0.04209570f, -0.02068091f, 0.00633436f, 
    -0.04369734f, 0.01416466f, -0.02457869f, 0.02026233f, 0.01292422f, 0.03419197f, -0.01898844f, 0.00917677f, 
    -0.02296846f, 0.00569047f, 0.00645322f, 0.02421945f, -0.01769456f, -0.01848057f, -0.01752052f, -0.04659576f, 
    -0.00360507f, 0.01041664f, -0.02030194f, -0.00808893f, 0.00701219f, -0.01414802f, -0.00980759f, -0.03252815f, 
    -0.02131150f, -0.02563132f, -0.00738988f, -0.00815299f, -0.01236076f, -0.00499055f, 0.01349923f, -0.03717534f, 
    -0.00051742f, 0.00219974f, -0.04024606f, -0.01873762f, 0.03030046f, 0.01817434f, -0.02737472f, -0.01191860f, 
    -0.02893315f, -0.04211016f, 0.00257347f, 0.01664109f, -0.01820260f, 0.00657210f, -0.02023001f, -0.01477100f, 
    0.02590653f, -0.03535026f, -0.01071517f, 0.02167663f, -0.03560666f, -0.00614718f, -0.03088892f, 0.00689378f, 
    0.01866691f, -0.00500271f, 0.01391655f, -0.02291010f, -0.00460651f, -0.00354235f, -0.01099370f, -0.01787871f, 
    -0.00716709f, 0.01670062f, -0.03849672f, -0.03379720f, 0.01316180f, -0.01563934f, -0.01001092f, -0.02483814f, 
    0.00472642f, -0.00784284f, 0.02228830f, -0.01645724f, 0.01727359f, 0.00656082f, -0.00163132f, 0.00354776f, 
    0.03298666f, 0.01248199f, -0.04015548f, 0.02247901f, -0.02400217f, -0.00061404f, -0.02890815f, -0.00153076f, 
    0.01892146f, -0.02331028f, 0.03124526f, -0.03251213f, -0.01169091f, -0.01941117f, -0.02785666f, -0.00311350f, 
    0.00083643f, 0.02625536f, -0.00377229f, -0.01566634f, 0.00314090f, -0.02318571f, -0.01269700f, 0.01564637f, 
    0.02166115f, 0.01574973f, 0.00811979f, -0.00869784f, -0.01248523f, -0.00195236f, -0.03609689f, -0.00767896f, 
    -0.03488480f, 0.01585458f, -0.01267680f, -0.02016343f, 0.02745839f, -0.01695856f, 0.00059764f, -0.01761962f, 
    -0.03832146f, -0.01618665f, -0.02030936f, 0.01195671f, -0.01136700f, 0.01683989f, -0.01768539f, 0.02068274f, 
    0.01911482f, -0.01865384f, 0.01211842f, 0.03291240f, -0.03993151f, 0.03006093f, -0.04331358f, -0.00438421f, 
    0.02844746f, -0.00789283f, -0.03499890f, 0.00798393f, 0.00519203f, -0.00050025f, -0.03519917f, 0.01715187f, 
    -0.02146115f, 0.02219694f, -0.00089343f, -0.04154174f, 0.00898875f, 0.00226263f, -0.04150940f, 0.00785977f, 
    0.01606810f, 0.00067162f, -0.01033299f, -0.04251294f, -0.00481952f, -0.00921242f, 0.00338355f, -0.04069365f, 
    -0.04599824f, -0.01342971f, -0.00885017f, -0.01196226f, -0.02043795f, -0.04543030f, -0.02253542f, -0.00557979f, 
    0.00743820f, 0.01365914f, 0.01683618f, -0.02541975f, -0.03171245f, -0.03509038f, 0.00987491f, -0.01907340f, 
    -0.03189046f, 0.02169290f, 0.01644175f, -0.00178993f, -0.00691906f, 0.01116543f, 0.01618706f, 0.00790159f, 
    0.01303775f, -0.02673798f, -0.01038427f, -0.03582624f, 0.01621508f, 0.01173140f, 0.02490230f, -0.02086950f, 
    -0.03913881f, -0.03740778f, -0.00020787f, -0.03551697f, -0.03651045f, -0.00325746f, -0.00046349f, 0.02512011f, 
    -0.03775274f, 0.01704953f, -0.01907454f, -0.04254305f, 0.02202180f, -0.02105562f, 0.02944226f, -0.00520736f, 
    -0.03683455f, 0.03440806f, 0.02714025f, -0.02409948f, 0.00574980f, -0.02885889f, -0.01030522f, 0.01700846f, 
    0.03451734f, -0.03088588f, -0.01945632f, 0.03203439f, -0.02298528f, 0.01772115f, -0.03127605f, -0.03139077f, 
    -0.00046347f, -0.02442103f, -0.01148567f, -0.01423666f, 0.01517481f, 0.00150717f, -0.01273705f, -0.03364266f, 
    -0.01940008f, -0.03147466f, -0.00265551f, 0.02210408f, -0.00683049f, -0.03148905f, -0.04183998f, -0.02237275f, 
    0.00658348f, -0.00077137f, 0.01756019f, 0.03041452f, -0.01515073f, 0.02002045f, -0.02426840f, 0.02606329f, 
    0.00116075f, 0.01862198f, 0.02926956f, 0.01798641f, -0.00206265f, -0.00893497f, 0.00768083f, -0.03274942f, 
    -0.01319097f, 0.02997262f, 0.00253056f, -0.01184924f, 0.00806672f, -0.03119781f, 0.02997151f, 0.02140641f, 
    -0.00398737f, 0.01573471f, 0.01709942f, -0.00814540f, -0.01939406f, -0.02639070f, 0.00386951f, 0.02189304f, 
    0.02687998f, 0.00149167f, -0.01323559f, -0.01092172f, 0.01799610f, 0.02073177f, 0.01167715f, -0.00024594f, 
    0.01205186f, 0.02006239f, -0.04278292f, -0.01009702f, 0.01337214f, 0.01391714f, -0.01662637f, 0.02409468f, 
    -0.01229814f, -0.01379781f, 0.02187986f, 0.02121654f, -0.00225921f, 0.02444569f, -0.03622095f, -0.02449364f, 
    -0.03548164f, -0.02599290f, -0.03767638f, 0.03085406f, -0.02121922f, 0.00872448f, -0.04808791f, 0.01155999f, 
    -0.01795229f, 0.02070368f, -0.01648140f, 0.00121059f, -0.02241208f, 0.02939293f, -0.01770741f, 0.00066838f, 
    -0.01374027f, -0.03759015f, -0.00360185f, -0.02041921f, 0.00120414f, 0.02450694f, 0.00918958f, -0.02107683f, 
    -0.02656095f, -0.01090815f, 0.01272895f, 0.00371635f, 0.02669148f, -0.00804869f, -0.00960081f, -0.02386050f, 
    0.02523740f, -0.01995949f, 0.00647295f, 0.02139175f, 0.01101112f, -0.00299220f, -0.02421859f, -0.01737008f, 
    -0.04180744f, -0.04164733f, -0.00544798f, 0.01376120f, 0.00473484f, -0.02812555f, -0.01085009f, 0.01572937f, 
    -0.00394136f, -0.02152899f, -0.04295732f, 0.01657389f, -0.01222260f, 0.00428251f, 0.00010021f, -0.04052885f, 
    0.02030763f, -0.02229009f, 0.00972445f, -0.03600220f, -0.02933535f, 0.00907067f, -0.01265910f, -0.01638209f, 
    0.00717247f, 0.02388217f, -0.00529597f, 0.00581556f, -0.00799345f, -0.02255075f, -0.03479493f, -0.01356972f, 
    0.00944304f, 0.03659938f, 0.02148782f, -0.03419697f, 0.01850219f, 0.00734539f, -0.03665802f, -0.01303586f, 
    -0.01606907f, 0.02420512f, 0.01225102f, 0.00641917f, 0.02615799f, 0.01028281f, -0.04196985f, -0.02459223f, 
    -0.00176277f, -0.00005350f, 0.01409491f, 0.00171717f, -0.02902202f, 0.01607156f, -0.02706859f, -0.00102192f, 
    -0.03736379f, -0.04634253f, -0.03090144f, -0.00821775f, -0.02992702f, 0.03235190f, -0.02972816f, -0.02619387f, 
    0.01718731f, 0.01325325f, -0.01084494f, -0.02925656f, 0.01312884f, 0.00006061f, 0.00119484f, -0.03433625f, 
    -0.03783859f, 0.00509564f, -0.00630044f, -0.00073966f, 0.02103785f, 0.00449743f, -0.02863043f, 0.02364019f, 
    0.02267767f, -0.02277749f, 0.00252844f, 0.00651991f, -0.02790250f, 0.01810011f, -0.01673782f, 0.03266154f, 
    0.00293349f, 0.02382187f, 0.02544034f, 0.01417851f, -0.03365641f, -0.01302522f, -0.01581313f, -0.02426603f, 
    0.03316741f, 0.01783670f, -0.03364129f, 0.02845146f, -0.02225154f, -0.02246812f, -0.03507449f, -0.03787293f, 
    -0.03447524f, -0.01889181f, -0.03985626f, -0.02012919f, 0.01432018f, -0.03695565f, 0.00763719f, 0.02268271f, 
    -0.02298002f, 0.02863690f, -0.02226510f, -0.01433500f, 0.02759088f, -0.04110134f, -0.00448447f, -0.04802722f, 
    -0.03208373f, -0.01414518f, -0.02893111f, -0.02178831f, 0.03382738f, -0.00688334f, -0.04438138f, -0.02351625f, 
    -0.04059940f, -0.03054294f, -0.03537751f, -0.01237285f, 0.01288275f, -0.04123959f, -0.00738095f, -0.02645504f, 
    0.01495685f, 0.02002609f, -0.03230596f, 0.03250559f, -0.03524436f, -0.02495000f, -0.00623244f, -0.03905305f, 
    0.02692682f, -0.01799217f, 0.00595463f, -0.03046825f, 0.02057295f, -0.03653122f, -0.03681700f, 0.02220105f, 
    -0.03695733f, 0.01802616f, -0.00822188f, 0.00245714f, -0.03412916f, -0.01371111f, 0.02557893f, -0.00361946f, 
    -0.01622445f, -0.04526190f, -0.02724004f, 0.02195365f, 0.00608171f, 0.02204040f, 0.02252650f, 0.01793466f, 
    0.01639808f, -0.02715243f, 0.00434525f, -0.03906330f, 0.01724462f, -0.00212159f, -0.03210507f, 0.01726065f, 
    -0.04461040f, 0.01487246f, 0.01615830f, -0.00723354f, -0.01586714f, -0.01634028f, -0.01430397f, -0.02727891f, 
    0.00457505f, -0.02598009f, -0.01406791f, 0.01494585f, -0.01475600f, -0.03069113f, -0.04478526f, -0.01590096f, 
    0.00063876f, 0.01846762f, -0.02374258f, 0.01883474f, -0.03514499f, 0.02266965f, -0.04440201f, -0.02999757f, 
    0.01972827f, -0.01550307f, 0.01974723f, 0.02451019f, 0.01104815f, -0.02531269f, -0.02163180f, 0.01067594f, 
    0.00563319f, -0.04008454f, -0.02544606f, -0.03455528f, 0.01071434f, 0.02479750f, -0.02155592f, -0.03711448f, 
    -0.01409751f, -0.02399285f, 0.01357523f, 0.01703158f, 0.01048536f, 0.02869282f, -0.02759538f, -0.03355154f, 
    0.00707525f, -0.00215115f, 0.02599725f, -0.02174127f, 0.00557817f, -0.00022332f, 0.01474549f, 0.00645190f, 
    0.02946940f, -0.02848020f, -0.00284885f, -0.02693444f, 0.01169929f, -0.03885118f, 0.01546975f, -0.03468143f, 
    -0.00612174f, -0.02907427f, 0.01167766f, -0.00388276f, -0.02756179f, -0.03479737f, 0.02693460f, 0.01057959f, 
    0.01658376f, 0.01663760f, 0.00336260f, 0.01337553f, -0.00837910f, -0.01245540f, -0.01164548f, -0.03683796f, 
    0.00842547f, -0.01074314f, 0.02806003f, -0.00833372f, -0.01155729f, -0.03393318f, -0.01297238f, 0.01611990f, 
    -0.00827700f, 0.00693674f, 0.01553847f, 0.02327140f, -0.02794110f, 0.02168620f, 0.02901762f, 0.01955141f, 
    -0.03744255f, 0.00422379f, 0.02726812f, 0.01496988f, -0.03968155f, 0.02498750f, 0.00302833f, -0.04027813f, 
    -0.02653782f, -0.00639752f, -0.01481312f, 0.00566574f, 0.02452631f, 0.00805304f, 0.02831917f, -0.02148211f, 
    -0.03742569f, 0.00867261f, -0.02829752f, -0.00255853f, 0.02067300f, 0.01378016f, 0.00313346f, 0.01241850f, 
    -0.00008129f, -0.02788715f, -0.03349400f, -0.00984224f, 0.00387099f, 0.02133407f, -0.03507473f, 0.01739882f, 
    -0.02086888f, 0.00262292f, -0.03958515f, -0.01365875f, -0.01288504f, 0.02543479f, -0.00088217f, 0.02065914f, 
    -0.03041184f, -0.02449241f, 0.01585745f, 0.01415551f, 0.01027813f, -0.02578469f, -0.02068773f, 0.00938033f, 
    -0.00455437f, 0.01888617f, 0.02165746f, -0.01368915f, -0.01180702f, -0.01600766f, 0.00656607f, 0.02256520f, 
    0.00436970f, 0.01588112f, -0.02042128f, -0.03194853f, -0.03533482f, 0.01450225f, -0.00205687f, -0.03923739f, 
    -0.02943886f, -0.02407007f, 0.02878218f, -0.03328225f, -0.03419742f, -0.02065733f, 0.02482210f, -0.04075595f, 
    -0.01564905f, -0.01940933f, 0.00073752f, -0.03954029f, 0.01833048f, -0.03443258f, -0.03958200f, -0.02250183f, 
    0.01735943f, -0.01258601f, -0.02533120f, -0.04204509f, 0.01483970f, -0.04094002f, -0.01117673f, 0.02372166f, 
    0.02446555f, -0.01880244f, -0.03386394f, -0.01076209f, -0.01916296f, -0.02825214f, -0.02218633f, -0.03099864f, 
    0.01139538f, 0.01886024f, -0.00372764f, -0.03060337f, 0.01858494f, -0.00050168f, -0.01130495f, -0.02168627f, 
    -0.00282021f, -0.02187590f, -0.00487143f, -0.03065834f, 0.02642311f, -0.02370700f, -0.03034601f, -0.00976303f, 
    -0.04003093f, -0.00244629f, -0.04152617f, 0.00139373f, -0.02804728f, 0.00331794f, -0.03203877f, 0.01461154f, 
    0.01544428f, -0.02855726f, -0.03576751f, -0.00155582f, -0.01341999f, -0.01487453f, -0.00654634f, 0.02258975f, 
    0.01419248f, -0.01719403f, -0.02083649f, 0.02583478f, -0.02565841f, -0.02051940f, -0.01926619f, -0.00308289f, 
    0.00731799f, 0.01339671f, -0.00113287f, -0.03932445f, -0.03123877f, 0.01124362f, 0.00862303f, -0.00694915f, 
    -0.00819167f, -0.00174107f, -0.02613999f, -0.02574116f, 0.01108764f, -0.02978649f, -0.02123618f, 0.01435775f, 
    -0.00652541f, 0.02586776f, -0.02541130f, -0.00010523f, 0.00157695f, 0.01104573f, -0.00497221f, 0.02039251f, 
    0.02997138f, -0.00510127f, 0.01266273f, 0.01590134f, 0.01879350f, -0.01933468f, -0.03199542f, -0.01223723f, 
    -0.03897684f, -0.03672669f, 0.02922812f, -0.00613245f, 0.01126831f, -0.00267231f, 0.01704245f, -0.02827533f, 
    -0.01103973f, -0.03493852f, 0.01632947f, -0.03696177f, -0.02062218f, -0.01334597f, 0.02922648f, -0.01280660f, 
    0.01718447f, 0.02091396f, -0.04205618f, -0.02736904f, 0.00835497f, -0.02581321f, -0.01483292f, -0.03022601f, 
    -0.00430388f, -0.00087965f, 0.02784914f, -0.01579766f, -0.03323289f, -0.04102365f, -0.01608832f, -0.01692919f, 
    -0.03760180f, -0.00725952f, 0.02453928f, 0.01362096f, 0.01918349f, -0.00546274f, -0.01040387f, -0.03865746f, 
    0.00627939f, -0.00318037f, 0.02635031f, -0.03421755f, -0.03233888f, 0.02041606f, 0.01663066f, -0.00716682f, 
    -0.02047940f, 0.01191592f, 0.00978192f, -0.01435968f, 0.02011702f, -0.02016494f, -0.00378154f, 0.02589084f, 
    -0.02133750f, 0.02858289f, 0.01911807f, -0.02985456f, 0.01460768f, -0.01885117f, 0.02822722f, 0.01577436f, 
    -0.01812362f, -0.02629888f, 0.00052772f, 0.01531425f, -0.00206379f, -0.03851807f, -0.00508264f, 0.00556003f, 
    0.00207550f, -0.01668782f, 0.00794971f, -0.01962175f, -0.02600151f, 0.01777556f, 0.00128483f, -0.02792968f, 
    -0.00679988f, 0.00172248f, 0.00689728f, -0.01919394f, -0.04177526f, -0.02773151f, 0.02760212f, -0.01842662f, 
    0.01684487f, -0.02705909f, -0.02748244f, -0.01342184f, 0.00938309f, -0.00476548f, -0.02302293f, 0.02102636f, 
    0.02256400f, -0.03572755f, -0.02425834f, -0.02409552f, -0.02320816f, -0.00060836f, -0.03315995f, -0.01421168f, 
    0.02442974f, -0.03673042f, 0.01495098f, -0.02812915f, 0.01417280f, -0.00398856f, -0.01156198f, -0.01684316f, 
    0.00818028f, 0.00189479f, 0.00615352f, -0.02841242f, -0.02581179f, 0.01069495f, -0.03701489f, 0.02315956f, 
    0.03004814f, -0.00073785f, -0.02628121f, 0.02420353f, 0.01250961f, -0.01715748f, -0.00733363f, 0.02283683f, 
    -0.01880102f, 0.01303662f, -0.03826717f, -0.02980882f, 0.00012963f, -0.03052936f, -0.00526779f, -0.02996214f, 
    0.02830051f, -0.03922530f, 0.01428917f, -0.01653401f, 0.00618487f, 0.02554390f, 0.02890992f, 0.02327483f, 
    -0.02581866f, -0.01968439f, -0.02543382f, -0.03365337f, -0.02330189f, 0.00633585f, 0.03032979f, -0.00534548f, 
    -0.03659776f, -0.02455745f, 0.00737261f, 0.01020836f, -0.02710495f, -0.02870480f, 0.00342966f, -0.03954283f, 
    -0.00539536f, -0.03120636f, 0.01399466f, 0.01914041f, 0.01474670f, 0.01406034f, -0.04085696f, 0.01751963f, 
    -0.03178288f, -0.03063453f, -0.01832646f, -0.03776514f, 0.01477693f, -0.01795446f, 0.01837515f, -0.03092612f, 
    -0.02250473f, 0.00215214f, 0.00341741f, -0.02293081f, -0.00665249f, -0.01826942f, 0.01979998f, -0.02361194f, 
    0.03538426f, -0.03304875f, -0.02324102f, -0.02698132f, 0.02689808f, 0.00143445f, -0.00099068f, 0.02761774f, 
    0.01851250f, -0.00582452f, 0.01689114f, -0.03761106f, -0.00484654f, -0.00859796f, -0.02653097f, -0.02994875f, 
    -0.01133823f, -0.00253255f, -0.03055675f, -0.01345375f, -0.01358536f, 0.00699433f, 0.01118239f, -0.00817127f, 
    -0.03954581f, -0.00620055f, -0.04045077f, -0.00095957f, -0.01360423f, 0.01460275f, 0.01920801f, -0.04133309f, 
    0.01941081f, 0.02462896f, 0.01017984f, -0.04184122f, 0.02063580f, 0.02694819f, 0.03020129f, 0.00793989f, 
    -0.02324759f, 0.02415268f, -0.02166990f, 0.02138728f, 0.01446877f, 0.00299202f, 0.02987318f, 0.00053863f, 
    -0.02576406f, 0.00544747f, 0.01297231f, -0.03796631f, -0.03355158f, 0.01179481f, -0.02681279f, 0.02509073f, 
    0.02900429f, 0.02951635f, 0.02050337f, -0.01315028f, -0.03861738f, -0.01859565f, 0.00463503f, 0.01732025f, 
    -0.01282083f, 0.00112614f, -0.02663068f, -0.03934239f, -0.03797803f, -0.01060512f, 0.01874628f, -0.00238207f, 
    -0.02063594f, 0.01618179f, 0.00984258f, 0.00466905f, -0.02926677f, -0.02732654f, 0.00715363f, -0.04027270f, 
    0.02749223f, 0.02196296f, -0.01870159f, 0.01755908f, -0.01530651f, -0.02471618f, -0.01448629f, -0.01248710f, 
    -0.00211313f, 0.01513808f, 0.00433650f, 0.01503128f, 0.00932386f, -0.02788606f, 0.01809457f, -0.03250522f, 
    0.01896469f, -0.00007751f, -0.00198778f, -0.03792163f, 0.02318986f, 0.00358401f, -0.00529539f, -0.01718514f, 
    0.00333746f, -0.02126418f, -0.01023141f, -0.03251494f, -0.00071974f, 0.00580061f, -0.02496983f, 0.02399199f, 
    0.00873342f, 0.00677808f, -0.00961338f, -0.01627871f, -0.03248674f, -0.01441429f, -0.00256444f, 0.01278950f, 
    0.00610147f, -0.01836049f, 0.00553841f, 0.00770256f, 0.00455769f, 0.00880178f, 0.03948541f, -0.03901434f, 
    -0.03550101f, -0.03153648f, -0.02727670f, 0.00603090f, -0.02838313f, -0.03555804f, -0.00598189f, -0.01418269f, 
    0.01782996f, 0.00332282f, -0.02672201f, 0.00353516f, -0.01169129f, 0.01709557f, -0.03366560f, -0.02974547f, 
    -0.01774382f, 0.00442777f, -0.02783916f, 0.00292764f, -0.00099002f, 0.02187817f, 0.02253455f, -0.00965795f, 
    0.01739066f, -0.02880438f, 0.01995810f, 0.02798094f, -0.00449915f, -0.03312999f, -0.00873175f, -0.03007545f, 
    -0.04137388f, -0.02813818f, -0.03319510f, 0.01915692f, 0.01025374f, -0.03502299f, -0.00459051f, -0.02634795f, 
    -0.03308164f, 0.01445504f, 0.02086757f, 0.01259546f, -0.03855317f, 0.02365999f, 0.01251955f, -0.01675946f, 
    -0.01363458f, 0.01609248f, -0.03673034f, 0.00220461f, 0.00538720f, -0.02337728f, -0.02604144f, -0.02092819f, 
    0.00832704f, -0.01898935f, 0.02784707f, -0.02775574f, -0.02032841f, -0.03785008f, -0.02641672f, -0.03650062f, 
    -0.00735032f, -0.01019342f, 0.02523834f, 0.02163564f, 0.02367304f, -0.02816421f, -0.02010628f, 0.01116103f, 
    -0.02094039f, -0.03142982f, -0.04131832f, 0.00579260f, -0.02268691f, -0.02411193f, -0.01374677f, 0.02323852f, 
    0.02911456f, 0.01498863f, 0.00746979f, -0.03040813f, -0.03663397f, -0.02447801f, 0.00498696f, 0.01228627f, 
    -0.00548347f, -0.03592377f, -0.00060677f, 0.02257556f, -0.03810511f, -0.01504702f, -0.00500858f, -0.02257378f, 
    0.01267991f, -0.02491755f, -0.04138255f, 0.00244510f, 0.01985840f, 0.02018036f, 0.01791058f, -0.00750894f, 
    -0.04064745f, -0.00046944f, 0.02012839f, 0.02619030f, 0.00475353f, -0.00290251f, -0.02556787f, 0.00241540f, 
    -0.02409525f, -0.03480095f, 0.01126868f, 0.01407327f, -0.03671437f, -0.02914580f, 0.00700621f, 0.02996811f, 
    0.01367921f, -0.03465269f, 0.00433025f, -0.00896495f, 0.02032286f, -0.03726499f, 0.00890062f, -0.01277709f, 
    -0.02276821f, 0.01211405f, 0.02361660f, 0.01030908f, -0.01323078f, -0.04179581f, -0.01910917f, 0.00028615f, 
    0.01899820f, -0.03208394f, 0.00842469f, -0.02133499f, -0.02177497f, 0.02054027f, -0.01759683f, 0.00017673f, 
    -0.04127243f, -0.01345408f, 0.00745565f, 0.01926339f, -0.03090392f, 0.01441344f, -0.00264987f, -0.01628317f, 
    -0.02627154f, -0.01514924f, 0.01579453f, 0.00875519f, -0.03244248f, 0.02575127f, -0.00230991f, -0.03994385f, 
    -0.00669860f, 0.01194328f, 0.02921396f, 0.00848040f, -0.02671735f, 0.01912220f, 0.02364998f, -0.00984734f, 
    -0.02999749f, 0.00757750f, 0.01471115f, 0.01864718f, -0.01799188f, 0.01181476f, 0.00785450f, -0.00108905f, 
    -0.02728305f, 0.01658115f, -0.01250638f, 0.01128915f, -0.03898280f, 0.02155965f, -0.02094420f, -0.00514578f, 
    -0.00347184f, -0.00131432f, -0.01121921f, -0.01955531f, -0.01400291f, 0.00102505f, -0.01431352f, 0.02643389f, 
    -0.00993469f, 0.01685578f, 0.00311376f, -0.02145487f, -0.00603375f, -0.03493562f, 0.00867815f, 0.00036479f, 
    -0.01599017f, -0.01714589f, -0.01311103f, -0.01689797f, 0.00487693f, -0.01268557f, -0.02904510f, 0.00564461f, 
    -0.00201141f, -0.03195732f, 0.01266410f, -0.00792417f, -0.03358595f, 0.02125774f, -0.00366156f, -0.02264468f, 
    -0.01981427f, -0.02362402f, 0.00955011f, -0.01944397f, 0.02990933f, -0.01475102f, 0.00675933f, -0.03593128f, 
    -0.03599772f, -0.04022467f, 0.02453208f, 0.01221229f, -0.02510735f, -0.00866151f, 0.01572806f, 0.02710387f, 
    -0.02621432f, -0.03071827f, -0.01968034f, 0.02557578f, -0.03101852f, -0.02399174f, -0.01878465f, 0.01189356f, 
    -0.03215361f, -0.03492980f, -0.01409640f, -0.01745035f, -0.01948442f, -0.01169482f, -0.02860615f, 0.00693337f, 
    0.01732046f, -0.01788216f, -0.00150599f, 0.00149639f, -0.03540746f, -0.00372404f, -0.01358509f, 0.00572128f, 
    -0.03535463f, 0.01710848f, 0.00632939f, -0.00369302f, -0.01228670f, 0.00435413f, -0.00369698f, -0.01187455f, 
    -0.01433577f, 0.03221260f, -0.02237121f, 0.03136873f, 0.00724079f, -0.02222910f, -0.00014551f, -0.00901588f, 
    0.00306180f, -0.02408959f, -0.01117225f, 0.01677567f, 0.03192785f, -0.03252409f, -0.00948746f, 0.01534011f, 
    0.02576265f, 0.00694982f, 0.00684081f, -0.01496696f, -0.01054739f, -0.02210537f, 0.00297594f, -0.03189427f, 
    0.02125680f, -0.01791312f, -0.02917134f, 0.02811156f, 0.00170430f, 0.03025462f, -0.00789830f, 0.02485987f, 
    0.02307845f, -0.00975435f, -0.01299094f, -0.02760311f, -0.01618305f, -0.02684727f, 0.03405592f, -0.02545242f, 
    -0.01213100f, -0.01576870f, -0.01248244f, -0.01392039f, -0.01386688f, -0.00080673f, -0.01308700f, 0.03089603f, 
    0.01260190f, 0.00033876f, 0.01658460f, 0.02793476f, 0.03555210f, -0.01839782f, 0.00580300f, -0.02200514f, 
    0.02092758f, 0.02326258f, -0.01276791f, -0.00615514f, 0.00872507f, 0.02531429f, -0.02829841f, 0.00087879f, 
    -0.01619978f, 0.03582028f, 0.02983368f, 0.00884241f, -0.01817348f, -0.03573900f, -0.02422350f, -0.00712410f, 
    0.00799244f, -0.02525000f, -0.01704986f, -0.00052610f, 0.03594304f, 0.01187725f, 0.02273355f, -0.02415339f, 
    -0.01258323f, 0.02381224f, 0.01342437f, 0.02857074f, -0.00829830f, -0.01561605f, 0.01766478f, -0.00185701f, 
    0.00663511f, -0.02615479f, -0.01967569f, 0.00271496f, -0.02682799f, -0.02843154f, -0.00168235f, 0.01364390f, 
    -0.03286419f, -0.02254911f, -0.03086834f, 0.02907710f, -0.03442499f, -0.03438287f, -0.03029772f, -0.02991072f, 
    -0.01281414f, 0.01974264f, -0.01804478f, -0.03000004f, 0.02975671f, 0.00262921f, 0.02729435f, -0.03081461f, 
    -0.01242341f, -0.02161957f, 0.01769758f, 0.00906657f, 0.00471404f, 0.01418269f, 0.03107816f, 0.02241574f, 
    -0.01626905f, -0.00865620f, 0.01768679f, 0.03212797f, 0.00261216f, -0.01828199f, -0.02945575f, -0.01133048f, 
    -0.00308085f, 0.01990849f, 0.01836543f, -0.03041968f, -0.03039838f, -0.01703042f, 0.00596117f, -0.00737067f, 
    -0.01824735f, 0.03285641f, -0.03184698f, 0.02896035f, 0.00282102f, 0.00044602f, -0.01317749f, 0.02253134f, 
    0.01956539f, -0.02938122f, -0.02305893f, -0.00332307f, 0.01080694f, -0.02108333f, 0.01662059f, -0.00133171f, 
    -0.02414125f, -0.01656806f, 0.02273212f, -0.02213126f, 0.01859977f, -0.03061997f, -0.00872357f, -0.00113027f, 
    -0.00758027f, -0.01234140f, 0.02389667f, 0.01320743f, 0.00710515f, -0.02295464f, -0.00175414f, 0.02628820f, 
    -0.01900089f, 0.01912244f, -0.02137498f, -0.00118787f, 0.01408115f, 0.00751320f, -0.00213870f, -0.00508076f, 
    0.02999640f, 0.01370878f, -0.01737710f, -0.01171415f, -0.01089479f, 0.00032264f, -0.02147312f, 0.02476499f, 
    -0.00863884f, -0.02554893f, -0.01271274f, -0.03456973f, -0.00343320f, 0.03581665f, 0.02270151f, 0.00272808f, 
    0.00418440f, -0.02363728f, 0.02929499f, -0.03030401f, 0.00068791f, -0.03448201f, 0.00741809f, 0.02431227f, 
    -0.03580055f, 0.00712904f, -0.01416190f, -0.00286020f, 0.00545909f, -0.03347937f, 0.01318985f, 0.01083538f, 
    0.02004373f, -0.01589939f, -0.01288960f, -0.03539330f, -0.02210725f, -0.01747450f, -0.03522607f, 0.00949549f, 
    0.00584262f, -0.01243701f, -0.03578442f, 0.02069292f, 0.02721605f, 0.02448990f, 0.00079277f, -0.03400925f, 
    0.01771947f, 0.01134847f, -0.00337775f, -0.00053150f, -0.02137995f, 0.00189259f, 0.00534608f, -0.03094031f, 
    0.02069683f, -0.01153130f, -0.02352283f, 0.01799177f, -0.03478215f, 0.01458462f, 0.00000431f, -0.01039318f, 
    0.02335523f, 0.00368297f, 0.01461601f, 0.00391147f, -0.01039582f, -0.00571546f, -0.00532479f, 0.01259469f, 
    -0.02257482f, -0.03375444f, -0.02187013f, -0.01098960f, 0.02180745f, -0.01902889f, 0.03566818f, -0.01290805f, 
    0.01351659f, -0.02544030f, -0.01913253f, 0.00144332f, -0.03554458f, -0.00470018f, -0.00899642f, 0.01435454f, 
    0.00326513f, 0.00638349f, 0.03285663f, 0.01450429f, -0.00199901f, -0.01046907f, 0.00676558f, -0.02881320f, 
    0.02568452f, 0.03516440f, -0.03158592f, 0.00930385f, -0.02154009f, -0.01257752f, -0.00623094f, -0.03225759f, 
    0.02316090f, -0.01367972f, -0.01492128f, -0.02280541f, 0.00220652f, -0.00762962f, -0.01161724f, 0.02495852f, 
    -0.02748035f, -0.03128006f, 0.00915881f, 0.00512750f, 0.00384393f, 0.00348038f, -0.03538682f, 0.01352041f, 
    -0.01591693f, -0.01867243f, 0.00241818f, 0.02313242f, -0.01749560f, 0.02426119f, -0.01939013f, -0.02082035f, 
    -0.00144995f, -0.03543292f, -0.02892434f, 0.00117355f, -0.02773235f, -0.01723867f, 0.02174445f, 0.01988717f, 
    0.03081240f, -0.02550925f, -0.02147063f, 0.01599381f, 0.01807806f, -0.02170005f, -0.01578817f, -0.01255965f, 
    -0.03091728f, 0.00984571f, -0.01975399f, 0.01377374f, -0.02934999f, -0.01709553f, 0.01666873f, 0.01754117f, 
    0.01392535f, -0.03396280f, -0.02008963f, -0.00212239f, 0.01273747f, -0.02782658f, -0.03395576f, -0.01734418f, 
    -0.03042541f, -0.02992113f, 0.01511314f, -0.00478998f, -0.02970210f, 0.02494704f, -0.01529388f, -0.00700720f, 
    0.02415664f, -0.01223267f, 0.00851825f, -0.01149244f, 0.02392126f, 0.01633966f, 0.02274601f, 0.00842238f, 
    -0.00252827f, -0.02918019f, -0.03141664f, -0.02390778f, -0.02228722f, -0.01541957f, -0.02376300f, -0.01773845f, 
    0.02177965f, -0.02735987f, 0.02680200f, -0.00036648f, 0.01906408f, 0.02360790f, -0.00941315f, -0.01006129f, 
    0.02586914f, -0.01235757f, -0.02821807f, 0.01231796f, 0.00411423f, 0.03404799f, 0.02386768f, -0.01461195f, 
    0.03085432f, -0.02845911f, 0.00986628f, 0.00127807f, 0.02359758f, 0.03034557f, -0.02230410f, 0.00059950f, 
    -0.01028174f, -0.03116128f, 0.01259706f, -0.00011914f, 0.01600119f, -0.00320692f, 0.03025743f, -0.00614882f, 
    -0.03565399f, 0.02277458f, -0.02992419f, -0.01574362f, -0.03511258f, -0.01126639f, 0.02396304f, 0.01703898f, 
    0.00810960f, -0.02538182f, 0.03436489f, 0.01210030f, 0.02267263f, 0.03573958f, -0.00615273f, -0.03177001f, 
    0.00889354f, -0.01268189f, -0.02411776f, -0.02955646f, 0.03123673f, -0.02528191f, 0.02318705f, -0.00469177f, 
    0.00174906f, 0.01907438f, -0.03431226f, 0.02406910f, 0.03290202f, 0.00786380f, -0.02732508f, 0.02464241f, 
    0.00976307f, -0.01194017f, -0.00556802f, 0.02922572f, 0.00116850f, -0.01211968f, 0.01566228f, 0.03553441f, 
    -0.01473399f, 0.02150579f, 0.02387845f, -0.01150515f, -0.01390798f, 0.00784409f, -0.02254871f, -0.00334846f, 
    -0.02821344f, 0.01962705f, -0.02835606f, 0.00835111f, -0.02409177f, 0.02846701f, -0.00967367f, 0.01860812f, 
    -0.03461184f, 0.00663857f, 0.03057134f, -0.02693307f, -0.01389207f, -0.00314022f, 0.02848352f, -0.01276739f, 
    0.03170115f, -0.02138258f, 0.02888857f, -0.00896841f, 0.02007589f, 0.02827264f, 0.01102137f, -0.02859422f, 
    0.03014492f, -0.00948158f, 0.02132568f, 0.03372818f, 0.02949335f, 0.00187328f, -0.00272078f, -0.03091329f, 
    -0.02073135f, 0.00493875f, -0.02126020f, 0.01900543f, 0.02250699f, 0.03053860f, -0.00343915f, 0.02526602f, 
    -0.01064556f, 0.03377514f, -0.00967356f, -0.01260651f, -0.03458465f, -0.00642287f, -0.01950357f, -0.01761164f, 
    0.00427524f, 0.01860805f, 0.03144351f, 0.01130737f, 0.01778509f, -0.01987394f, -0.02293577f, 0.00563448f, 
    0.03150555f, 0.02126358f, 0.03048925f, -0.02182071f, 0.00123552f, 0.02449720f, -0.01254328f, 0.01233197f, 
    0.03183024f, -0.01059996f, 0.01382400f, 0.01978208f, 0.02726766f, 0.02377433f, 0.01960295f, -0.02273569f, 
    0.03447357f, 0.02034392f, -0.03406503f, 0.00520801f, -0.01839927f, 0.00941176f, 0.02428134f, -0.01928030f, 
    0.02208769f, 0.00897260f, 0.02951571f, -0.03349740f, 0.03402920f, -0.02449770f, -0.01811912f, 0.00716639f, 
    -0.02541284f, -0.02392013f, -0.01426881f, 0.00678870f, 0.01378476f, -0.01378630f, 0.01486401f, -0.00169196f, 
    0.01959693f, -0.02934167f, 0.02920244f, 0.01364168f, -0.01252953f, -0.02277645f, -0.02646726f, -0.01274127f, 
    -0.00638418f, 0.02737151f, -0.02773676f, 0.02633638f, -0.01115934f, 0.01450571f, 0.01579693f, 0.01614190f, 
    -0.01517901f, -0.02803467f, -0.03351955f, 0.00815063f, -0.03487774f, -0.00458715f, -0.02836175f, 0.01371557f, 
    0.01143855f, -0.01223550f, 0.00737798f, -0.02107383f, -0.00721096f, 0.02258343f, 0.01991666f, 0.00005708f, 
    0.00473703f, -0.02055305f, -0.01980458f, -0.03219613f, -0.00251089f, 0.00790964f, -0.00590683f, 0.01540762f, 
    -0.02268902f, -0.01716781f, 0.02923191f, -0.02107313f, 0.01228708f, -0.02836785f, 0.01447691f, -0.00423164f, 
    0.00828135f, -0.02792079f, -0.02788267f, -0.02560095f, -0.01978683f, 0.01466050f, 0.03211663f, -0.03264480f, 
    -0.00602188f, -0.02050107f, 0.03521433f, -0.01742858f, 0.02796837f, -0.00854311f, -0.01406641f, -0.00262676f, 
    -0.02350428f, -0.01725468f, 0.00529442f, 0.03585982f, -0.01151665f, -0.00426437f, -0.01559996f, 0.02706329f, 
    0.01463386f, 0.00655763f, -0.01794570f, 0.00213065f, -0.00862517f, 0.01068002f, -0.03557787f, 0.01648401f, 
    -0.02184969f, 0.03000018f, -0.00605613f, 0.01311413f, 0.02493409f, 0.02603171f, 0.03474214f, -0.01466919f, 
    -0.03526169f, -0.01861541f, -0.00425694f, -0.03008969f, -0.01282502f, 0.01452350f, 0.00342864f, -0.03482237f, 
    -0.00532395f, 0.01969545f, 0.01684886f, 0.03279819f, -0.00519796f, -0.03304710f, -0.00142539f, -0.01955232f, 
    -0.00852469f, -0.00032129f, -0.00733941f, 0.02392839f, -0.02697335f, -0.01638214f, 0.01545401f, 0.02329282f, 
    0.03237315f, 0.01027050f, 0.00573529f, -0.03429184f, -0.01143628f, -0.03598923f, -0.02532997f, 0.02334495f, 
    -0.02411578f, -0.00156919f, -0.03467965f, 0.02391315f, -0.02375979f, -0.03182324f, -0.03044309f, -0.02818405f, 
    0.03400804f, -0.01844095f, 0.02667704f, 0.03150523f, 0.00952900f, 0.00418558f, 0.00218161f, -0.01333979f, 
    0.01231019f, 0.02066205f, 0.02277628f, -0.03003014f, 0.01428334f, 0.02558740f, -0.01604120f, -0.02662030f, 
    -0.02068343f, -0.02226116f, -0.01598430f, 0.00820635f, 0.01368565f, -0.00170597f, -0.00695715f, -0.02465594f, 
    -0.03422390f, 0.00710330f, -0.02445134f, -0.02306733f, 0.02765180f, 0.02166292f, -0.02592481f, -0.03143742f, 
    0.03601415f, 0.00110828f, 0.02477711f, 0.03422922f, 0.00708745f, -0.00911101f, 0.02669469f, -0.00942323f, 
    -0.01928533f, 0.01718206f, 0.02373491f, 0.01640007f, 0.03548907f, 0.02183693f, -0.01722481f, -0.01035630f, 
    -0.03307443f, 0.01162981f, 0.00345590f, -0.03203826f, 0.00535850f, -0.00995807f, 0.03400114f, -0.02865829f, 
    0.01975766f, -0.01267857f, -0.02706422f, -0.01251258f, 0.01118753f, 0.00383557f, -0.02197089f, -0.02130278f, 
    0.03498600f, 0.02077107f, -0.03159242f, -0.01416499f, 0.01948509f, 0.01480148f, 0.03189918f, -0.02755160f, 
    0.33224028f, -0.16003434f, 0.09017635f, 0.18831332f, -0.01619295f, -0.05144620f, -0.05534607f, 0.06711432f, 
    -0.04678948f, -0.04513758f, -0.00512795f, -0.03416802f, 0.08274964f, -0.11298474f, -0.03525610f, 0.07081616f, 
    0.02648474f, -0.04020500f, -0.07192141f, 0.00207163f, 0.04152943f, 0.05599136f, -0.05240356f, 0.01485891f, 
    -0.37014160f, 0.12251765f, -0.04565001f, -0.18394221f, 0.00794016f, 0.10942139f, 0.19561391f, -0.01580325f, 
    0.07949806f, 0.07518163f, 0.02107034f, -0.01823450f, 0.31585750f, 0.14530274f, 0.26805541f, 0.11811557f, 
    -0.16094753f, 0.05476200f, 0.00521371f, 0.04560412f, 0.06283025f, 0.05901632f, -0.07922704f, 0.02791200f, 
    0.15517691f, 0.19780244f, 0.06294937f, 0.14172174f, -0.01627841f, -0.01879189f, 0.02726801f, 0.16436167f, 
    0.01229015f, 0.05177980f, 0.16311118f, -0.04198017f, -0.20706461f, 0.02853813f, -0.01644538f, -0.03445192f, 
    0.17884451f, -0.00827052f, 0.10713685f, 0.01870322f, 0.12450290f, 0.05393890f, 0.02486822f, 0.02732749f, 
    -0.31565753f, -0.23551318f, -0.13753189f, 0.00500272f, 0.11440869f, 0.05221651f, 0.08672995f, -0.03972061f, 
    -0.03693756f, 0.10348056f, -0.01067368f, 0.03892832f, -0.10522699f, -0.00584524f, 0.12561803f, 0.09327097f, 
    -0.04364836f, 0.05347039f, -0.07321946f, 0.10126841f, 0.05851190f, 0.05008316f, 0.04221508f, 0.12138478f, 
    -0.24820594f, 0.01284581f, 0.07579529f, -0.12760568f, 0.11074310f, 0.05397094f, 0.04490035f, 0.05458996f, 
    -0.06259469f, 0.03823074f, 0.02980106f, -0.05061443f, 0.04520388f, 0.09103947f, -0.13801435f, 0.29945189f, 
    0.00334372f, -0.01287226f, -0.07257348f, -0.04353271f, -0.16011627f, 0.04924541f, 0.01846494f, 0.08779635f, 
    0.29943165f, 0.25236118f, 0.04578965f, 0.06524729f, 0.02099501f, -0.01175727f, 0.05535858f, 0.06812433f, 
    0.02170273f, -0.10084859f, 0.19330120f, 0.04024177f, 0.28418449f, 0.24621029f, 0.14016235f, 0.07061467f, 
    -0.08905499f, 0.01704250f, 0.03683826f, -0.02346528f, 0.01126230f, -0.02913885f, 0.08880229f, 0.01002443f, 
    0.13445634f, 0.12851687f, -0.15251197f, 0.21149498f, -0.00697698f, 0.13869464f, 0.04553383f, 0.04506788f, 
    -0.03783282f, -0.00929855f, -0.09012049f, 0.05410540f, 0.00194803f, 0.09226260f, -0.22668831f, 0.15738389f, 
    0.04272963f, 0.02294696f, -0.21885449f, -0.02760178f, -0.05001958f, -0.08040434f, 0.08776920f, -0.08369631f, 
    0.24180394f, 0.12329332f, -0.11727913f, 0.38935572f, -0.16846718f, -0.08735588f, -0.01185812f, 0.02536607f, 
    -0.06136146f, -0.04781775f, -0.01359642f, 0.10694902f, 0.19203062f, 0.05608236f, 0.00210049f, 0.08407007f, 
    -0.08619975f, 0.10204104f, -0.10229501f, -0.11253616f, -0.29317331f, -0.00408673f, -0.20075577f, -0.05310116f, 
    0.34129602f, 0.19591634f, 0.19107614f, 0.03664646f, -0.10985440f, -0.05654996f, 0.00721975f, 0.10684665f, 
    0.13733076f, 0.05795191f, 0.01939801f, -0.08784477f, -0.01626559f, -0.01820577f, -0.01227095f, 0.17870452f, 
    0.03191292f, -0.00516060f, -0.04441645f, 0.08439042f, 0.08736075f, -0.06606360f, -0.11163405f, -0.03372851f, 
    -0.17098926f, 0.27878845f, 0.09305768f, -0.12892848f, 0.02441779f, 0.13951892f, 0.02465719f, -0.02649960f, 
    -0.05282254f, 0.00447203f, 0.00871422f, -0.14564103f, 0.04433474f, 0.06366532f, 0.06155526f, 0.05779524f, 
    0.03757986f, -0.13653798f, -0.02475668f, 0.07761288f, -0.14203855f, -0.01181642f, -0.02353916f, 0.10439609f, 
    0.07147466f, 0.07854329f, 0.12144301f, 0.13821125f, -0.07844655f, -0.02938636f, 0.13214351f, 0.07925759f, 
    0.09831604f, 0.06879736f, 0.04248375f, 0.02446008f, 0.12090772f, 0.07273299f, -0.16767782f, 0.14005935f, 
    0.07244113f, 0.01702589f, -0.07961938f, 0.03504560f, -0.02461463f, 0.11613282f, 0.00947458f, 0.06067507f, 
    -0.42843533f, -0.16765480f, -0.10771908f, 0.09668950f, 0.14309372f, 0.04777737f, 0.03920811f, -0.10438179f, 
    -0.06661501f, 0.07514893f, 0.01104100f, 0.14490514f, 0.29906428f, 0.16183783f, 0.04583189f, -0.04778734f, 
    0.03031371f, 0.00413069f, 0.15279482f, -0.07749259f, -0.04227370f, 0.04380980f, 0.03612359f, 0.00908993f, 
    -0.36924520f, 0.03470929f, 0.03265493f, -0.02025414f, 0.06648473f, 0.09362908f, 0.01837251f, -0.03433097f, 
    0.04925974f, -0.08092076f, -0.01487438f, -0.05253487f, 0.07049676f, -0.00025130f, -0.15974016f, -0.03675978f, 
    0.00011057f, -0.04394882f, -0.08403506f, -0.00128847f, 0.05845312f, -0.10223623f, -0.03758451f, -0.12566534f, 
    0.37828240f, -0.11203057f, 0.04443372f, -0.14105830f, 0.08498336f, 0.16938160f, -0.01665292f, -0.08062033f, 
    0.01252385f, 0.14185865f, -0.04676068f, 0.02773773f, -0.23643315f, 0.05388185f, -0.09343112f, -0.03329066f, 
    0.18999660f, 0.02372049f, 0.03207520f, 0.04414471f, 0.05345934f, -0.04786582f, 0.04118726f, 0.02136575f, 
    -0.14397429f, 0.11843677f, 0.11949813f, 0.00357928f, -0.05627162f, -0.10238056f, 0.01607119f, 0.01058955f, 
    -0.16063721f, 0.12000230f, -0.14858003f, 0.00911758f, 0.01457016f, -0.01361798f, 0.02497172f, -0.10583188f, 
    0.01907152f, 0.04910597f, 0.03078546f, 0.12359506f, 0.04850589f, -0.08319260f, -0.01091962f, -0.02683987f, 
    0.04909752f, -0.17994632f, -0.00459518f, 0.01956587f, -0.08102750f, -0.04425423f, -0.08483870f, -0.01407326f, 
    0.07074665f, -0.01362604f, -0.05696937f, -0.00007586f, 0.25481829f, -0.02028763f, -0.09358905f, 0.11390626f, 
    0.00741746f, -0.08537689f, 0.09294292f, 0.08103714f, 0.09583918f, -0.03310583f, 0.05007863f, -0.08147004f, 
    0.03723896f, -0.06151007f, -0.16081680f, -0.18923420f, 0.06095960f, 0.00499095f, -0.07268538f, 0.00410140f, 
    -0.14009406f, 0.05216844f, 0.15816742f, 0.06396163f, -0.32687780f, -0.12014798f, -0.12291510f, -0.06056157f, 
    0.10548311f, 0.06298418f, 0.11153696f, -0.01707756f, -0.09575950f, -0.16276155f, 0.05163199f, -0.00356303f, 
    0.18515049f, -0.07716396f, -0.12658815f, 0.11214028f, 0.02369504f, 0.09022751f, -0.06704174f, -0.08336277f, 
    -0.12754184f, -0.05211446f, 0.01312418f, -0.12516148f, 0.22675279f, 0.16664772f, 0.14251566f, -0.01464635f, 
    -0.03855202f, 0.00865484f, -0.00541819f, 0.06433517f, -0.01573370f, 0.02466163f, -0.04068285f, -0.05144096f, 
    0.11895089f, 0.10005593f, -0.13787025f, 0.00178009f, -0.06293230f, -0.03054317f, 0.00357839f, 0.04908269f, 
    -0.03578883f, 0.00634102f, -0.02007980f, -0.10049291f, 0.29460394f, -0.25038925f, -0.00035964f, 0.13522729f, 
    0.00782858f, -0.05404736f, -0.01018338f, -0.04822043f, 0.11357757f, -0.02594166f, -0.13273278f, -0.01398339f, 
    -0.20229548f, 0.14956452f, -0.01275882f, -0.19293000f, 0.16249892f, -0.04323986f, 0.05918165f, 0.06626475f, 
    -0.07926746f, 0.10709529f, 0.08669204f, 0.18146981f, 0.37624583f, -0.08033079f, -0.16976722f, 0.16891302f, 
    -0.09647253f, 0.05895348f, -0.05198299f, -0.01315205f, -0.04783813f, 0.06169038f, 0.03869659f, -0.16898720f, 
    -0.46871018f, 0.07459623f, 0.12167938f, -0.11164977f, 0.06060400f, -0.02571772f, 0.00861619f, -0.03750895f, 
    0.11251418f, -0.04192382f, 0.06328773f, 0.07629836f, 0.22078167f, 0.22640747f, -0.03907765f, -0.05301009f, 
    -0.02799333f, -0.02404381f, 0.03991896f, -0.00679546f, -0.02261606f, -0.02957913f, -0.05852825f, -0.00225639f, 
    -0.12817697f, -0.02270760f, 0.12012520f, 0.04346113f, 0.11841426f, 0.01727006f, 0.02694246f, 0.00154902f, 
    0.06748743f, 0.14564534f, 0.07684505f, 0.11412964f, -0.14720573f, -0.41571516f, 0.10838121f, 0.13942368f, 
    0.01076830f, -0.11277729f, 0.05900232f, -0.05058287f, 0.04530875f, -0.04132252f, 0.00016571f, -0.01943057f, 
    -0.07500192f, 0.03130470f, 0.06202216f, -0.15781714f, 0.02994072f, 0.06291059f, 0.11441620f, 0.07661348f, 
    0.02084630f, 0.07956468f, 0.05328289f, 0.07037243f, -0.20196997f, -0.07000537f, 0.04951447f, -0.03193402f, 
    0.08044238f, 0.12126441f, -0.04216012f, -0.03424706f, 0.02783798f, -0.04252257f, 0.10553424f, -0.03694241f, 
    -0.12268831f, 0.12298335f, -0.02458310f, 0.17719506f, -0.01741518f, 0.08697602f, 0.11730131f, 0.16742410f, 
    -0.01649257f, 0.01059476f, -0.02001682f, -0.00034382f, -0.27061802f, -0.08449659f, 0.19906339f, -0.04518094f, 
    0.01713065f, -0.05714701f, 0.04787872f, -0.05762921f, 0.12247033f, 0.09609017f, -0.00587972f, -0.08456232f, 
    -0.20197809f, -0.02176781f, 0.06308687f, 0.17269257f, -0.01231113f, 0.07123202f, 0.00433135f, -0.12446781f, 
    0.06724242f, 0.00778633f, 0.06601866f, 0.08980003f, -0.02636940f, 0.08478805f, 0.04133117f, -0.02883634f, 
    0.09193067f, 0.06354211f, -0.01259079f, -0.07950249f, -0.01687148f, -0.00810968f, 0.11506543f, 0.07403446f, 
    0.15873559f, 0.16881542f, 0.09758190f, 0.25374460f, 0.00208140f, 0.04228214f, 0.12395254f, 0.08768179f, 
    0.05384718f, -0.01553921f, 0.00581313f, -0.03945367f, 0.10494579f, 0.17125933f, 0.15481274f, 0.01601983f, 
    -0.08193052f, -0.04445923f, 0.03454645f, 0.03276829f, -0.00133486f, -0.03393991f, 0.09274434f, 0.12345928f, 
    0.04995486f, 0.01735221f, 0.10148022f, 0.13328013f, 0.06829592f, -0.03818174f, 0.07762372f, 0.10464323f, 
    0.08344343f, 0.12516235f, 0.00962597f, 0.02639120f, 0.08340953f, -0.01802776f, 0.22081849f, 0.17125693f, 
    -0.10402505f, -0.02300451f, 0.00592760f, -0.06048485f, -0.01583445f, -0.05445633f, -0.06209889f, 0.07763948f, 
    0.33701414f, 0.22610264f, 0.14854507f, 0.00324066f, -0.11921270f, -0.03361159f, 0.06756423f, 0.11682760f, 
    0.03936507f, 0.02787897f, 0.08628453f, 0.05671513f, -0.14859772f, 0.05049646f, 0.00978733f, 0.08761206f, 
    0.03651240f, -0.01518675f, 0.11844076f, -0.04380695f, -0.06377257f, 0.09814468f, -0.05354556f, -0.09222309f, 
    0.11104326f, -0.18415780f, 0.02339210f, 0.01429877f, -0.01172744f, 0.03361772f, -0.00088357f, -0.05081036f, 
    0.01599465f, 0.01638125f, 0.01747478f, -0.00766223f, -0.26179087f, 0.06080310f, -0.10023572f, -0.02564302f, 
    0.09242038f, -0.00892319f, 0.03030729f, -0.04628305f, -0.01014398f, -0.03118383f, 0.09312356f, 0.11160059f, 
    -0.10992160f, -0.28466538f, 0.13345514f, -0.01939012f, -0.09434737f, 0.00572589f, -0.06645331f, -0.02226429f, 
    0.09887972f, -0.01775284f, -0.12260836f, -0.06875225f, -0.09215352f, -0.12569478f, 0.11731968f, -0.02535068f, 
    0.06052567f, 0.00015066f, 0.02747141f, 0.07608504f, -0.05066011f, -0.03010105f, -0.02227830f, 0.05444498f, 
    -0.05958412f, -0.00339680f, 0.10584493f, -0.05484660f, 0.13991684f, 0.01155824f, 0.04584099f, -0.01639416f, 
    -0.02983815f, -0.13550919f, 0.03137089f, -0.03434535f, 0.00761223f, 0.03439978f, 0.00351726f, 0.24018002f, 
    -0.13601524f, 0.00794549f, -0.02430750f, 0.07149564f, 0.10985319f, -0.12093379f, -0.15790555f, 0.10260868f, 
    -0.05121746f, -0.10112265f, -0.05798218f, 0.07458816f, 0.03879847f, 0.11036047f, -0.07300965f, 0.02816449f, 
    0.03797204f, -0.02639724f, 0.03818237f, 0.14999409f, 0.12552516f, 0.16918312f, 0.07342604f, 0.20062748f, 
    -0.11796962f, -0.06459910f, 0.13916595f, 0.14723560f, 0.01389198f, 0.11149821f, 0.09813667f, 0.03103427f, 
    -0.02604205f, 0.01694064f, 0.00006719f, -0.01535174f, 0.00238251f, 0.02718960f, -0.03391722f, -0.01142149f, 
    0.00456765f, -0.02890485f, 0.02505749f, 0.00625968f, -0.02674896f, -0.02884071f, -0.00245571f, 0.00099609f, 
    -0.01807924f, -0.00606746f, -0.00915782f, -0.00742924f, 0.01629385f, -0.01399077f, -0.00558543f, -0.01874030f, 
    0.02097046f, -0.00575449f, 0.01214277f, 0.00280839f, 0.00439341f, -0.00056507f, -0.03769447f, 0.02081955f, 
    -0.02398865f, -0.00239495f, 0.00363160f, 0.01619083f, 0.00947422f, 0.01386499f, 0.02907474f, 0.02343651f, 
    0.01843213f, -0.01049312f, 0.00437806f, 0.03634208f, -0.01625737f, 0.02944866f, 0.03757679f, 0.00093996f, 
    -0.03385502f, -0.02518535f, 0.00719755f, 0.00389980f, -0.01887407f, -0.04176465f, 0.03788935f, -0.00349220f, 
    0.00260070f, -0.00811762f, -0.01058436f, -0.02655913f, 0.00349246f, -0.01956023f, 0.00135257f, -0.01147876f, 
    0.00666111f, -0.01620907f, -0.00236432f, -0.00375926f, -0.03465289f, -0.01546270f, 0.01845111f, 0.00707402f, 
    0.00276998f, -0.00620938f, -0.03165209f, 0.02795014f, 0.02567316f, -0.01900199f, -0.00561799f, -0.01067927f, 
    -0.00080335f, -0.01182539f, -0.03123836f, -0.02508540f, 0.02602657f, -0.00824616f, 0.01768581f, 0.02178883f, 
    0.00914726f, -0.02507755f, 0.02555347f, 0.00978119f, 0.00905269f, -0.01287224f, -0.03768809f, -0.03717351f, 
    0.02013024f, -0.00009320f, -0.01863285f, -0.00639238f, 0.01744575f, -0.03772149f, 0.00778137f, 0.00761390f, 
    -0.00581715f, -0.02243729f, 0.01409583f, 0.02201934f, -0.00899551f, 0.02743454f, -0.01868021f, 0.02697014f, 
    0.00933065f, 0.01509707f, -0.02745188f, -0.02647000f, -0.01358577f, 0.02003824f, 0.02897322f, -0.02323227f, 
    -0.00133775f, 0.00956422f, 0.03001966f, -0.02840446f, 0.01415658f, -0.00612231f, -0.01710732f, -0.01964646f, 
    -0.02373599f, -0.01665804f, -0.01589270f, -0.01400957f, -0.00162776f, 0.02699842f, 0.01242790f, -0.03979450f, 
    0.02004323f, -0.02661624f, -0.03775381f, 0.02323857f, -0.01564343f, -0.03116189f, -0.01845604f, -0.02268090f, 
    -0.00280698f, -0.01158496f, -0.03081017f, -0.00742785f, -0.00394194f, -0.01702907f, -0.00504987f, -0.02804162f, 
    0.00989623f, -0.02944798f, -0.00291330f, -0.02802071f, 0.03247720f, -0.01969515f, -0.03188124f, 0.00630236f, 
    -0.01857289f, -0.03459342f, -0.00051162f, -0.02021456f, -0.00094335f, -0.02441638f, -0.03615033f, 0.00779432f, 
    -0.01577361f, -0.03126232f, 0.02033679f, 0.02000186f, 0.02439330f, -0.02594468f, 0.03304435f, -0.03624351f, 
    0.02193429f, -0.00554397f, -0.00207260f, 0.00033593f, -0.03110806f, 0.02332622f, 0.02566850f, 0.01152227f, 
    0.01074580f, 0.00507105f, 0.03230629f, 0.00280222f, 0.00310458f, -0.03509377f, -0.03089920f, -0.01314076f, 
    0.00899430f, -0.02828187f, 0.00415416f, -0.00296218f, -0.02751608f, -0.03161461f, -0.02023608f, 0.01779800f, 
    -0.00331677f, -0.00919110f, -0.01375006f, 0.00832831f, -0.02607152f, -0.02038031f, -0.01765165f, -0.02096247f, 
    -0.03901673f, -0.01284884f, 0.01557426f, -0.01813030f, -0.03548925f, -0.02437190f, -0.00671828f, -0.03021829f, 
    0.00207705f, -0.00360385f, -0.01947119f, 0.01085306f, -0.02253098f, 0.02733251f, -0.00516292f, 0.02124523f, 
    0.02239309f, 0.03838132f, 0.00403357f, -0.01684753f, -0.02425562f, 0.02162262f, -0.00729771f, -0.01861729f, 
    -0.02972023f, -0.01103184f, 0.03440577f, -0.00410644f, -0.00503797f, -0.03577398f, 0.00444790f, -0.00459515f, 
    -0.03893874f, 0.02263594f, 0.00517313f, 0.02881769f, -0.01345841f, -0.02507327f, -0.02150833f, -0.01827289f, 
    -0.02515183f, -0.02317483f, 0.01586247f, 0.00398475f, -0.03489624f, -0.03337361f, -0.03913146f, 0.02961792f, 
    -0.03451289f, 0.02169711f, 0.01183766f, 0.01680533f, 0.02450089f, -0.02939412f, 0.01967714f, -0.01927506f, 
    0.02819603f, 0.02479546f, -0.00288660f, 0.01756845f, -0.01043476f, -0.03936033f, 0.00105867f, -0.02792871f, 
    -0.02475432f, 0.01708397f, -0.02436107f, -0.03928285f, -0.02558161f, -0.03412447f, -0.02935242f, 0.02258240f, 
    -0.01241845f, -0.00279273f, 0.03002966f, -0.00180452f, 0.00361447f, 0.04147960f, 0.02520221f, 0.02407316f, 
    -0.01890262f, -0.01399865f, 0.00587218f, 0.01402087f, -0.03903389f, 0.02960108f, -0.00279960f, 0.00871205f, 
    -0.02080940f, -0.00553178f, 0.02837216f, -0.02244997f, -0.01081270f, -0.03302267f, -0.01616039f, -0.00229118f, 
    0.01349714f, 0.01246266f, -0.01965128f, -0.02925320f, -0.00361007f, -0.04122546f, -0.00748515f, -0.03739803f, 
    0.00866586f, 0.00317825f, 0.02903251f, 0.00290945f, -0.03225106f, 0.00148237f, -0.00392759f, 0.01719074f, 
    -0.04031694f, -0.03503095f, 0.00353467f, -0.01116105f, -0.03547304f, 0.02619343f, 0.00929366f, -0.00332944f, 
    -0.00184399f, 0.00328842f, -0.02721769f, -0.01344633f, -0.02492883f, 0.02317858f, -0.01780232f, -0.00071519f, 
    -0.04112189f, -0.01022474f, 0.02363776f, 0.02748470f, -0.01833792f, 0.01306744f, -0.03760874f, 0.00390735f, 
    -0.04088240f, 0.02716656f, 0.00126419f, -0.02928243f, -0.02544683f, -0.03299928f, -0.00105850f, -0.02015206f, 
    0.00191362f, -0.01882582f, 0.02498401f, -0.00477817f, -0.01397469f, -0.04183589f, -0.03330334f, -0.02735747f, 
    0.00264254f, 0.03389515f, -0.01806849f, 0.02445698f, -0.01151825f, 0.01364534f, 0.00433885f, -0.00204820f, 
    -0.03620983f, 0.01458472f, -0.00060799f, -0.01600318f, -0.01148890f, 0.01035743f, -0.01001908f, 0.02795642f, 
    0.00694306f, -0.00726690f, 0.02299869f, -0.00353557f, -0.00143073f, 0.03227428f, -0.02978240f, 0.02044676f, 
    -0.01536997f, -0.01249345f, -0.01470782f, 0.01378184f, 0.01271953f, 0.02852420f, 0.02794503f, 0.02717601f, 
    0.01012284f, 0.00781191f, 0.01803631f, -0.00915042f, -0.04185288f, 0.01914015f, -0.04063235f, -0.03170263f, 
    0.01087949f, -0.01986063f, -0.03708256f, -0.01847301f, -0.01017641f, -0.02865965f, -0.00332955f, -0.01410367f, 
    -0.01676620f, -0.02991086f, -0.01643539f, -0.02195763f, -0.03633968f, 0.01661493f, 0.00353541f, 0.02173063f, 
    0.00561604f, -0.03656686f, 0.02552261f, -0.03384351f, 0.00148024f, -0.03863450f, -0.03055399f, 0.02922112f, 
    0.02905994f, -0.03399091f, -0.02316432f, -0.03610516f, 0.02692121f, 0.02796372f, -0.01141047f, 0.03493314f, 
    0.01868471f, -0.01189671f, 0.03078726f, -0.00700128f, 0.02187611f, 0.00962246f, -0.01641268f, -0.02610756f, 
    -0.00955826f, 0.02300724f, 0.01816575f, 0.03834971f, -0.01521867f, -0.01843621f, 0.02109669f, 0.00171083f, 
    -0.03388304f, -0.02387112f, -0.00503079f, 0.02595305f, -0.01101772f, -0.02289727f, -0.00697344f, -0.03337268f, 
    -0.02554752f, -0.02958090f, -0.03302241f, 0.00517366f, -0.03532608f, 0.03090262f, 0.00351892f, 0.01725899f, 
    -0.01251629f, 0.02399665f, -0.02538902f, -0.02792982f, 0.01523136f, 0.02084942f, 0.01762233f, -0.04153252f, 
    -0.03318241f, 0.00841838f, -0.00859361f, -0.01910578f, 0.02523567f, -0.01224465f, 0.00951588f, -0.00463214f, 
    -0.04170103f, -0.04156940f, -0.04174409f, 0.00924631f, -0.02784650f, -0.03864084f, 0.00974152f, 0.02009810f, 
    0.02082628f, 0.02242676f, -0.02809899f, -0.03879955f, -0.03606798f, -0.03131706f, 0.00125890f, -0.02019884f, 
    -0.00203219f, 0.01624989f, 0.02604907f, 0.00939499f, 0.00064592f, 0.00988014f, -0.00293483f, -0.01941998f, 
    -0.01460374f, 0.01737861f, -0.01230930f, -0.01989587f, 0.01426177f, -0.02949069f, -0.04164046f, 0.00890401f, 
    -0.02000212f, 0.00260072f, 0.03299320f, 0.01108534f, 0.01460164f, -0.03681795f, 0.02440293f, -0.01301855f, 
    -0.02473995f, -0.01649166f, 0.00781491f, 0.02787974f, -0.01935779f, -0.02863931f, -0.02605580f, 0.00276854f, 
    -0.01173831f, 0.02098693f, -0.01479736f, -0.00391975f, -0.03720963f, 0.01956653f, -0.03228878f, -0.03811678f, 
    -0.02409767f, -0.02026081f, 0.02096510f, -0.01751410f, -0.00810656f, 0.02639519f, -0.00599640f, -0.00978116f, 
    0.00639033f, 0.02039946f, 0.01735084f, 0.02917577f, -0.00653760f, 0.02318388f, 0.01660083f, 0.00987156f, 
    -0.03210396f, -0.04179132f, 0.01931706f, 0.01616235f, -0.02965285f, 0.00665670f, -0.02393366f, -0.03388260f, 
    -0.00170585f, 0.02034088f, -0.03353014f, 0.01115953f, 0.02708723f, -0.02120818f, -0.02370264f, -0.00619195f, 
    -0.00054587f, -0.02068852f, -0.03045260f, -0.01113519f, 0.00796742f, -0.02568729f, -0.00618488f, -0.04007825f, 
    0.00525644f, -0.03357292f, -0.03501697f, -0.04184255f, -0.01841065f, -0.01709420f, 0.01472576f, -0.01421473f, 
    -0.00076942f, -0.02552384f, 0.02312707f, -0.03845948f, 0.02373484f, 0.01460191f, 0.00394400f, -0.00398420f, 
    0.03341836f, 0.01405392f, -0.00307609f, -0.00443143f, 0.02180928f, 0.02137029f, 0.00226325f, -0.03421731f, 
    -0.00496466f, -0.01209145f, -0.00297162f, 0.02713061f, 0.00345435f, 0.01716920f, -0.02513037f, 0.00359394f, 
    -0.03555349f, 0.02757163f, 0.02715177f, -0.02488753f, 0.02834405f, 0.02692861f, -0.01354419f, -0.03953028f, 
    -0.01722892f, -0.02868707f, 0.02014976f, -0.03970659f, 0.02155731f, -0.01570525f, -0.01954996f, -0.01977186f, 
    -0.03182538f, -0.01431241f, 0.01707966f, -0.00184143f, -0.02872795f, -0.01961058f, 0.02637358f, -0.03575710f, 
    -0.02273978f, 0.01755601f, -0.00110736f, -0.02111354f, -0.03760702f, 0.00401818f, -0.02959973f, -0.02102979f, 
    -0.02728016f, 0.01317127f, -0.00259146f, -0.00175307f, 0.01368555f, -0.00495607f, -0.01443208f, 0.02226664f, 
    0.02393333f, -0.02921748f, -0.03935498f, 0.00668289f, -0.00653514f, 0.03193327f, 0.02272662f, -0.03392654f, 
    -0.03724948f, -0.03086084f, -0.01592581f, 0.03242062f, 0.01195141f, -0.01969776f, -0.01131231f, 0.02137700f, 
    0.00561535f, 0.01962494f, -0.03456044f, -0.02300426f, -0.01882734f, 0.01791560f, -0.00369818f, -0.01546498f, 
    -0.01072908f, 0.00683639f, 0.02204562f, 0.01473774f, -0.01937216f, -0.03858114f, 0.02160701f, -0.00660757f, 
    -0.02688557f, 0.01464599f, 0.02544308f, -0.02672166f, -0.00663436f, 0.02984655f, 0.02597101f, -0.02218291f, 
    -0.03627022f, 0.02200528f, -0.03301441f, 0.00055963f, 0.01150922f, -0.01880939f, -0.03253326f, 0.01092498f, 
    -0.01036590f, 0.03681508f, -0.00183362f, -0.03743085f, 0.02860010f, 0.01073711f, -0.01345184f, 0.02169210f, 
    0.01132922f, -0.00013165f, -0.00615003f, -0.00950146f, 0.02865083f, -0.03734856f, 0.01155698f, -0.01523538f, 
    -0.03028540f, -0.03095344f, -0.02614141f, -0.01157327f, 0.00193548f, -0.01062394f, 0.01042773f, -0.01482874f, 
    -0.04015136f, 0.00999051f, -0.03788110f, -0.00072676f, -0.01370623f, -0.03909113f, 0.00434073f, -0.00794558f, 
    0.02365944f, 0.00527356f, -0.02319631f, 0.01473068f, 0.02018294f, -0.00122101f, -0.01085600f, 0.02592853f, 
    -0.00744357f, -0.01867516f, -0.02695643f, 0.03547245f, 0.01443185f, -0.03630642f, 0.01387845f, -0.03695104f, 
    -0.00619469f, 0.01628022f, 0.00120994f, 0.02664084f, -0.00633976f, 0.02983012f, -0.02468820f, -0.02261021f, 
    -0.02960693f, 0.01876868f, 0.02180940f, -0.01756062f, 0.02352654f, 0.00488088f, 0.01876511f, -0.01569035f, 
    0.01899367f, -0.03615448f, -0.01917698f, -0.01017311f, -0.01695178f, -0.00476174f, -0.00860033f, -0.00633346f, 
    -0.03625221f, 0.00676854f, -0.01656571f, -0.00961489f, 0.00755907f, 0.02489994f, -0.01218840f, -0.00047589f, 
    0.01584771f, 0.00441587f, 0.02740832f, -0.04121441f, -0.00117944f, -0.00229470f, -0.03668805f, -0.03982088f, 
    -0.01072154f, -0.00500874f, 0.02754834f, -0.02942793f, -0.01124688f, -0.01693613f, -0.02948711f, 0.01942088f, 
    -0.00073841f, -0.00699404f, 0.00995128f, 0.03209766f, -0.01627579f, 0.01341147f, -0.02969618f, 0.00507040f, 
    -0.03429880f, -0.00389687f, 0.01848093f, 0.00826320f, -0.00727220f, -0.03264400f, 0.01643860f, 0.02060246f, 
    -0.03567964f, -0.01055535f, 0.02359457f, 0.00695843f, 0.01966127f, 0.01402242f, 0.02878621f, 0.00864832f, 
    0.00838204f, -0.01990252f, 0.01955032f, 0.01368942f, -0.00733016f, 0.01718534f, -0.02574712f, -0.02356437f, 
    -0.00846662f, 0.02506034f, -0.00107624f, -0.01076046f, -0.00089711f, -0.00719955f, -0.02042591f, -0.01856823f, 
    -0.03167338f, -0.00852214f, 0.02706317f, 0.00331086f, -0.03304300f, -0.00590829f, 0.03019738f, 0.02894715f, 
    -0.03593726f, 0.02948072f, -0.02879020f, -0.01793966f, 0.01686215f, 0.02258321f, -0.02638669f, 0.00316830f, 
    -0.03102334f, 0.01319431f, -0.03855735f, 0.01437027f, -0.03430772f, -0.02315117f, 0.01199809f, 0.03021004f, 
    -0.00778090f, -0.01474613f, -0.03795917f, -0.00732619f, -0.03644404f, -0.02441840f, 0.01730539f, -0.04191749f, 
    -0.02184313f, -0.01935159f, -0.01881708f, 0.00482277f, -0.00911042f, 0.03008722f, 0.01063269f, -0.00703236f, 
    -0.02584987f, 0.01352094f, -0.01236002f, -0.03200463f, 0.00679501f, -0.00411388f, -0.02540719f, -0.00979934f, 
    0.00111780f, 0.00113569f, 0.01946389f, -0.02572326f, -0.03042752f, 0.01056106f, -0.00812113f, 0.02546657f, 
    0.02665304f, -0.00038373f, -0.02906219f, -0.00423604f, 0.03285222f, -0.01562474f, -0.02410237f, 0.00544124f, 
    -0.03695422f, 0.02755667f, 0.02437718f, -0.02031374f, -0.00773987f, 0.02891296f, 0.00689684f, -0.03606362f, 
    -0.03775907f, -0.03555287f, -0.01487735f, 0.02948431f, 0.02832664f, -0.03672995f, 0.00374944f, -0.03845241f, 
    0.00925550f, -0.02117484f, -0.03655620f, -0.03664074f, 0.00903891f, 0.02283325f, 0.00789150f, -0.02721540f, 
    -0.03153958f, -0.00228058f, 0.00854213f, -0.03762201f, -0.00989769f, -0.00591290f, -0.02208089f, 0.01692864f, 
    -0.01176394f, 0.02051311f, 0.01316676f, 0.00479644f, 0.03044457f, 0.02652048f, 0.03218102f, 0.02331161f, 
    -0.01552093f, 0.00538882f, 0.01181964f, -0.02665930f, 0.02411352f, -0.03180534f, -0.03919599f, 0.01605004f, 
    -0.01116392f, -0.00903273f, -0.00727079f, -0.01119570f, 0.00653136f, 0.00730574f, 0.01828477f, 0.01301789f, 
    -0.00959304f, 0.02820704f, 0.02384963f, 0.01393937f, 0.01430760f, -0.01081800f, -0.02012107f, -0.03816026f, 
    -0.00212313f, 0.01846987f, -0.01217481f, -0.00923019f, -0.00585422f, -0.03984783f, -0.01012994f, -0.01656034f, 
    0.00363162f, 0.00583080f, -0.01632572f, -0.01216868f, -0.01598972f, -0.02958536f, 0.00398840f, 0.00422532f, 
    0.01853950f, 0.02155708f, 0.00750215f, -0.00807277f, -0.01588373f, -0.02429622f, 0.02043130f, -0.03114825f, 
    -0.03384292f, -0.03100754f, 0.01285778f, -0.03316668f, -0.03568515f, -0.03744212f, -0.03876926f, -0.02517053f, 
    -0.03286415f, -0.02303566f, 0.02197852f, -0.02293257f, -0.02195544f, -0.01391518f, 0.00818032f, 0.00765981f, 
    -0.00711523f, 0.00068632f, -0.03703545f, 0.02169567f, 0.01101107f, -0.03475967f, -0.03468680f, -0.02686268f, 
    0.03158663f, 0.02145116f, 0.01842436f, 0.00913487f, 0.02539336f, -0.02070772f, 0.02782984f, 0.01593088f, 
    0.01847940f, -0.00000241f, -0.03411153f, 0.00754332f, 0.00163548f, -0.01668837f, -0.01604595f, -0.01037189f, 
    0.02053295f, -0.00413446f, -0.00767825f, 0.00040382f, 0.01553571f, 0.01402085f, 0.01437838f, 0.02328330f, 
    -0.02654452f, -0.01048905f, -0.02851292f, -0.02918051f, -0.02805180f, -0.02993729f, 0.02544624f, -0.01339706f, 
    -0.00177990f, -0.02628310f, -0.00607697f, -0.01518903f, -0.02039559f, -0.01985151f, -0.00736195f, -0.02173473f, 
    0.00889853f, -0.02108063f, 0.01819201f, -0.03498223f, -0.01341312f, -0.00172982f, -0.02394782f, -0.03601290f, 
    -0.01553741f, 0.00901025f, 0.02923274f, 0.01103766f, 0.02120961f, 0.02779316f, 0.01535823f, -0.01996081f, 
    -0.00583152f, 0.02262332f, 0.02753753f, -0.00336235f, -0.00989280f, -0.02348055f, -0.01415852f, -0.01003148f, 
    0.02114457f, -0.00784046f, 0.00610115f, -0.01613566f, -0.03509771f, -0.04088851f, -0.02307506f, 0.02558122f, 
    0.01429548f, -0.01153896f, -0.03252129f, 0.03516185f, 0.02643169f, -0.02706938f, -0.03651769f, -0.00562018f, 
    -0.03481635f, -0.03100353f, -0.01052664f, -0.01401493f, -0.03341968f, -0.00718355f, 0.01989598f, 0.01164215f, 
    -0.03013060f, -0.02943935f, -0.02240262f, 0.01830249f, 0.02256222f, 0.02814449f, 0.02772327f, -0.00035027f, 
    0.00710510f, 0.01007718f, 0.02904161f, 0.00847445f, -0.03618504f, 0.00003521f, -0.03447098f, -0.01314506f, 
    -0.03878823f, -0.03102350f, 0.00143337f, -0.00988125f, -0.00403666f, 0.01271015f, 0.00644930f, -0.02620295f, 
    -0.00100866f, -0.00799421f, 0.02884945f, -0.02571227f, 0.02558837f, 0.02084253f, 0.01294225f, -0.00958102f, 
    0.02416984f, 0.01680787f, 0.00534286f, 0.01188014f, 0.00936454f, -0.00715107f, 0.00885192f, -0.02881489f, 
    0.01758135f, 0.00902546f, 0.01528486f, -0.02966456f, 0.01811057f, -0.00575940f, -0.01528189f, 0.00256321f, 
    -0.02691392f, -0.03157476f, -0.03373665f, 0.02586265f, 0.01562487f, -0.00284539f, 0.00826072f, -0.02694733f, 
    -0.03505325f, -0.00000529f, 0.00312422f, -0.00580105f, 0.02088321f, -0.01637784f, -0.01050936f, 0.00047374f, 
    0.01930088f, 0.01666624f, 0.02129186f, -0.03116195f, -0.02066879f, -0.01884144f, 0.01024226f, -0.03745247f, 
    0.01865284f, 0.01813813f, -0.00015191f, -0.00190389f, -0.01320935f, -0.00726156f, -0.02563356f, -0.03863203f, 
    -0.02123537f, 0.00368416f, 0.01696519f, -0.01998387f, 0.00164055f, -0.03468530f, -0.03809856f, -0.00488770f, 
    -0.01249740f, 0.02352457f, 0.02041701f, 0.01210498f, 0.01276389f, 0.00616310f, 0.02311522f, 0.00516638f, 
    0.03171344f, 0.00989738f, -0.02801457f, 0.02762914f, -0.01431966f, 0.00813479f, -0.01275275f, 0.02980085f, 
    -0.03314284f, 0.00935902f, -0.02516675f, -0.01825952f, 0.00745387f, -0.02955514f, -0.01863277f, -0.03967189f, 
    0.02127877f, -0.00902249f, 0.01381015f, -0.01793320f, 0.01862407f, 0.00327493f, 0.00041244f, 0.01558392f, 
    0.02547818f, 0.00504215f, 0.02850281f, -0.03780704f, 0.03203181f, 0.00819488f, -0.00151397f, 0.01749023f, 
    -0.00577703f, 0.00129626f, -0.00828992f, -0.01297529f, 0.01333399f, -0.03832120f, -0.02357925f, 0.01027685f, 
    0.02098701f, -0.02084732f, -0.01943497f, 0.02191572f, 0.00601151f, -0.03911885f, -0.01254387f, 0.03000650f, 
    -0.03650988f, -0.03237045f, -0.00522576f, 0.00087512f, -0.02727610f, -0.01830251f, -0.03846797f, -0.00042290f, 
    0.01692313f, 0.00401793f, 0.03146783f, 0.01580531f, -0.03214273f, -0.03622948f, 0.00301747f, -0.01467080f, 
    -0.02077138f, 0.02275570f, -0.02642100f, 0.00383254f, -0.03099408f, -0.01521297f, 0.00058965f, 0.02712307f, 
    -0.03829997f, 0.02889782f, 0.01730884f, 0.01477633f, 0.00517951f, 0.01163837f, 0.01063427f, 0.01377502f, 
    0.00119641f, -0.00620204f, -0.03985936f, 0.00393154f, -0.03959413f, -0.01872840f, 0.01578598f, -0.02133591f, 
    -0.03129430f, -0.01375858f, -0.02235742f, 0.01864818f, -0.00663166f, -0.03499437f, 0.03522706f, -0.01912744f, 
    -0.00437686f, -0.00286092f, -0.00768055f, -0.00845786f, 0.02189766f, 0.02923508f, -0.00154445f, -0.00050254f, 
    0.02620734f, -0.02740072f, 0.00547035f, 0.01049480f, 0.03169548f, -0.01731729f, -0.01974030f, 0.00849347f, 
    -0.01937552f, 0.02005312f, -0.00746614f, 0.01672409f, -0.02072220f, -0.03079454f, 0.00141263f, -0.01542680f, 
    0.02088160f, -0.01064089f, 0.00447477f, -0.02139750f, -0.04105876f, 0.01427509f, -0.02820671f, -0.02239020f, 
    -0.00826258f, 0.00127837f, -0.03373332f, 0.00872966f, 0.01924790f, -0.01665842f, -0.02447999f, -0.00242977f, 
    -0.02506145f, -0.01960547f, -0.02916707f, 0.03129699f, 0.01840660f, -0.03367350f, 0.01420139f, -0.01280711f, 
    -0.00094678f, -0.02021363f, -0.00506085f, -0.01348615f, 0.02513834f, -0.00644047f, 0.01857102f, 0.00848473f, 
    -0.00519291f, -0.00515297f, -0.02387487f, 0.00101097f, -0.02616330f, -0.03837219f, 0.01127148f, -0.01671426f, 
    -0.03721271f, -0.02399696f, -0.03011075f, 0.01410609f, 0.00101217f, -0.03065437f, 0.00890619f, -0.00713107f, 
    -0.03940766f, 0.02919147f, -0.03010288f, 0.02273094f, -0.02711910f, 0.02658540f, -0.02827903f, 0.00516463f, 
    -0.01971948f, -0.02159693f, 0.04471245f, 0.02316495f, -0.03459224f, 0.03950725f, -0.01487094f, -0.03388641f, 
    -0.03375218f, 0.03207983f, 0.00810461f, 0.02286988f, -0.03989729f, -0.04011406f, -0.03738328f, -0.02868775f, 
    -0.02198154f, -0.01091769f, 0.01966678f, 0.00924891f, -0.02243336f, -0.01092270f, -0.03970345f, -0.02576965f, 
    -0.02223697f, 0.00537878f, -0.02223373f, -0.00431671f, -0.01465587f, -0.00827980f, 0.01884970f, -0.02694885f, 
    -0.03582465f, 0.03109824f, -0.01988315f, 0.00527332f, 0.00032270f, -0.03064333f, 0.00544701f, 0.00767630f, 
    -0.02862000f, 0.01339403f, 0.01804178f, 0.02828831f, 0.01741524f, 0.02471216f, -0.00429402f, -0.03121506f, 
    -0.01264452f, 0.01540115f, -0.00915536f, 0.00270582f, -0.02402226f, 0.01232186f, -0.03292220f, 0.01041455f, 
    -0.01456101f, 0.01372062f, -0.01548589f, -0.03896559f, -0.03613237f, -0.00706067f, 0.00471945f, -0.01235913f, 
    -0.00192598f, -0.01610440f, 0.02326418f, 0.02200550f, -0.00751747f, 0.01478165f, 0.00867543f, 0.03148635f, 
    0.02483704f, -0.03440291f, 0.00035466f, 0.02811725f, 0.02906237f, -0.00884567f, 0.01850346f, 0.01027597f, 
    -0.02021001f, -0.02633671f, -0.00536925f, -0.03129969f, -0.03227675f, 0.00949240f, -0.01003833f, -0.00815596f, 
    0.00212079f, -0.03381805f, 0.02440466f, -0.04192978f, -0.00643515f, -0.03646290f, 0.00729662f, -0.02901238f, 
    0.01076397f, -0.02032008f, 0.02250693f, 0.03088548f, 0.00615034f, -0.01251001f, -0.02210451f, 0.02174204f, 
    -0.02397848f, 0.00121511f, -0.03843648f, -0.02658262f, 0.01447584f, 0.01363929f, -0.00064635f, -0.01814181f, 
    -0.00267239f, 0.00187822f, 0.01818113f, 0.01021649f, 0.01310586f, -0.02544158f, -0.03772468f, -0.00534256f, 
    -0.02029264f, 0.01865274f, -0.00255535f, 0.02115001f, 0.00631432f, -0.03866510f, 0.02435597f, 0.02508383f, 
    0.00539119f, 0.02078983f, 0.02673245f, 0.00886488f, 0.01756867f, -0.02902419f, -0.02802859f, 0.00754661f, 
    -0.03575330f, -0.02927468f, 0.01746106f, -0.03173519f, 0.01963586f, 0.00004533f, 0.01076870f, -0.00823461f, 
    0.02637316f, -0.03550217f, 0.00743616f, -0.01333829f, -0.02748306f, -0.02375452f, 0.02103901f, -0.00302437f, 
    -0.01457465f, -0.02814458f, 0.02293498f, 0.00548933f, 0.00831196f, -0.02961019f, 0.03185408f, -0.00867314f, 
    0.02992186f, 0.03166619f, 0.02480522f, -0.00485032f, -0.03644669f, -0.01125762f, -0.02724671f, -0.01248940f, 
    0.05376613f, 0.09031184f, -0.20223427f, -0.17759064f, 0.04062779f, -0.01802953f, -0.02777467f, 0.09139668f, 
    0.08524708f, 0.07173034f, -0.12215590f, -0.00681057f, -0.11714683f, -0.33673531f, -0.22062726f, 0.06112736f, 
    0.14771546f, -0.03420907f, -0.11115384f, -0.14689134f, 0.08560430f, -0.05713771f, -0.12015797f, 0.11464467f, 
    -0.00471120f, 0.01174916f, -0.05666947f, -0.07133348f, -0.07847801f, -0.03295388f, 0.02234648f, -0.10534444f, 
    -0.10735954f, 0.12559752f, 0.07657008f, -0.19175625f, 0.07869078f, -0.44093725f, -0.04144842f, 0.33443373f, 
    0.09524652f, 0.00283548f, 0.04482147f, 0.00785265f, 0.03801632f, 0.04292159f, 0.04236692f, 0.29086861f, 
    -0.01039637f, -0.11376768f, -0.15238754f, -0.07432563f, 0.15413745f, 0.01027802f, -0.10821249f, 0.11742031f, 
    0.14094575f, 0.04635377f, -0.04400231f, -0.06894490f, -0.14637274f, 0.12196982f, 0.07069706f, 0.13142923f, 
    -0.05525276f, -0.14827178f, 0.03005974f, -0.11746870f, 0.01576245f, -0.06355120f, 0.07564005f, -0.01313384f, 
    -0.19146547f, -0.12238453f, -0.17523168f, -0.11232980f, -0.05536314f, -0.05587321f, 0.09792463f, 0.04157560f, 
    0.01408661f, -0.06308311f, 0.03868745f, -0.14591603f, -0.03482771f, 0.05050855f, 0.02658522f, -0.09941167f, 
    -0.05307632f, -0.08719396f, -0.19421749f, -0.12571171f, -0.19829148f, 0.02671282f, -0.03385488f, 0.03411654f, 
    -0.31135079f, 0.15372549f, -0.03614227f, 0.05228303f, -0.02978023f, -0.10557395f, 0.11123212f, 0.12273023f, 
    0.05255467f, 0.01033446f, -0.04756690f, 0.06261408f, 0.24614581f, 0.23578350f, -0.06291862f, 0.13823807f, 
    0.13306096f, 0.18495479f, 0.03740939f, 0.05004853f, 0.11793367f, 0.12904248f, -0.10989423f, 0.02800563f, 
    0.08884308f, -0.20168170f, -0.04349953f, 0.17832528f, 0.15185998f, -0.05898713f, -0.08131092f, 0.04442028f, 
    0.21662164f, -0.04064875f, 0.13696909f, -0.14029764f, 0.20721047f, -0.28200251f, 0.05000164f, 0.06203986f, 
    0.05985392f, 0.12892517f, 0.05309308f, -0.06359751f, 0.07029679f, 0.01125576f, 0.09699888f, 0.15155160f, 
    0.20731167f, 0.03682828f, 0.05273241f, -0.00978232f, 0.06933826f, -0.12735540f, -0.05125802f, 0.04661228f, 
    0.09362290f, 0.13636279f, 0.10595106f, 0.23523174f, 0.01076603f, 0.07132516f, -0.05323499f, -0.01036101f, 
    0.13084273f, 0.01999343f, -0.09684263f, 0.14999829f, 0.06453235f, 0.08715741f, -0.19740839f, 0.15254721f, 
    0.23231554f, -0.10505270f, -0.29032317f, 0.23755385f, 0.05572330f, -0.09533408f, -0.00374038f, -0.04747262f, 
    0.06939414f, -0.05535916f, 0.19455381f, 0.03369150f, 0.34719691f, -0.23935972f, -0.25595590f, 0.01804793f, 
    0.15956500f, -0.00189217f, -0.07542259f, -0.02828969f, 0.08928171f, 0.05540054f, -0.12239887f, 0.02753282f, 
    -0.13830145f, -0.27607355f, -0.24170484f, 0.21877247f, 0.01210220f, 0.16095783f, -0.08224655f, -0.01867283f, 
    0.02641150f, -0.02048466f, 0.21909252f, 0.15298516f, 0.11184486f, 0.02125752f, -0.03383844f, 0.15969093f, 
    0.00694492f, -0.02781998f, -0.06761695f, 0.03604744f, 0.01216272f, 0.01363691f, 0.15152861f, 0.18452704f, 
    0.25685027f, 0.15148693f, -0.08367958f, 0.01707920f, 0.00040197f, -0.13784049f, 0.08501066f, 0.04556601f, 
    0.08999466f, 0.00728485f, 0.15539624f, 0.13359948f, -0.03036001f, 0.00384651f, -0.02608219f, 0.01254046f, 
    0.09104548f, 0.03175704f, 0.12840110f, 0.08049493f, -0.08847758f, 0.20419028f, 0.02284225f, -0.09048786f, 
    0.18234846f, 0.04930792f, -0.00801759f, -0.04324999f, -0.04916704f, -0.14840361f, 0.19206692f, 0.04438267f, 
    -0.04596663f, 0.02395718f, -0.05751825f, -0.00486875f, 0.15375856f, -0.10996018f, -0.10516599f, -0.04031064f, 
    0.02581843f, -0.08336367f, 0.02295377f, -0.23367839f, -0.05543848f, 0.01991027f, -0.07976233f, 0.15124391f, 
    -0.15141821f, 0.04886428f, 0.00567753f, 0.11752041f, -0.16039763f, -0.09525762f, 0.03618652f, 0.03503245f, 
    -0.11868359f, -0.03223548f, 0.02464342f, -0.15104134f, -0.01719765f, -0.06713782f, 0.12983701f, 0.04817304f, 
    -0.02916332f, -0.14239576f, -0.09125128f, 0.07900774f, -0.00355570f, -0.03126686f, 0.18335512f, -0.09230656f, 
    -0.10515220f, 0.03681346f, -0.12616105f, 0.12877755f, -0.14211859f, -0.00849886f, 0.04857143f, 0.02771501f, 
    0.09705856f, -0.10640497f, 0.06218006f, -0.22367570f, -0.05324755f, -0.11134808f, 0.09716051f, -0.03876544f, 
    0.04045450f, -0.07816039f, 0.09559349f, 0.08638991f, 0.03525501f, 0.03407821f, -0.00731272f, 0.10092041f, 
    0.04834123f, -0.20067273f, 0.21851993f, -0.16823365f, -0.09535250f, 0.03959370f, 0.08002649f, 0.04447193f, 
    0.03353531f, 0.08638864f, -0.01362974f, -0.04437326f, 0.17756219f, 0.08868743f, 0.10069653f, 0.09576342f, 
    -0.14501162f, -0.11805049f, 0.00015781f, -0.08305420f, -0.00546882f, 0.09078106f, -0.02079291f, -0.01715111f, 
    0.02883910f, 0.32781819f, 0.16650318f, -0.01606870f, -0.05193596f, 0.00968486f, 0.13972203f, 0.03223304f, 
    0.08917991f, 0.01473581f, -0.06041597f, -0.05900538f, -0.14171121f, 0.14910036f, 0.02919875f, 0.05256424f, 
    0.07923632f, 0.06252597f, -0.24910699f, 0.19399917f, 0.01015345f, -0.00248114f, 0.06116035f, -0.17353205f, 
    0.01128749f, -0.16848147f, -0.13591428f, 0.07234274f, 0.16813900f, 0.07846549f, -0.02922712f, 0.09942356f, 
    0.09933280f, 0.07193299f, 0.04009663f, 0.06902985f, 0.06388793f, 0.27468237f, 0.16038212f, -0.14357008f, 
    0.03322474f, 0.08294594f, 0.02000696f, 0.03271994f, 0.12275302f, 0.01182950f, 0.04360569f, 0.02331169f, 
    0.38238767f, -0.08992992f, -0.03763465f, 0.09191763f, -0.09959954f, -0.01416706f, 0.15660493f, 0.01509427f, 
    0.07191099f, 0.01468937f, 0.00002179f, 0.00404627f, -0.08350519f, 0.13932773f, -0.00235456f, 0.03370744f, 
    -0.08906318f, 0.04141628f, 0.07037967f, 0.02829668f, 0.02668681f, 0.10787328f, 0.03296905f, 0.05868015f, 
    0.13365500f, -0.11247480f, -0.13450715f, -0.05011781f, 0.08161955f, -0.01817771f, -0.12565875f, -0.00566538f, 
    0.03224587f, 0.19132823f, 0.07403354f, 0.14285925f, 0.19217823f, 0.01120103f, -0.16937612f, 0.16052248f, 
    0.10727523f, -0.18454391f, 0.06700783f, 0.10665029f, 0.29012716f, 0.05659277f, -0.01194728f, 0.06019827f, 
    0.05462674f, -0.21338183f, -0.15240540f, -0.13467403f, -0.02533496f, -0.01363769f, 0.01009717f, -0.04945766f, 
    0.08704630f, -0.09780727f, 0.09545267f, 0.11686567f, 0.27967003f, -0.14946106f, -0.04460282f, -0.00535618f, 
    -0.08919985f, -0.03848219f, 0.07562805f, -0.00248573f, 0.11841654f, -0.13165301f, 0.13600686f, 0.20139512f, 
    -0.15568665f, 0.15687677f, 0.10579573f, -0.16837904f, -0.04671595f, -0.13336366f, 0.00748845f, -0.09376799f, 
    -0.04826243f, -0.02548187f, -0.19523942f, 0.14506507f, 0.07998466f, -0.00425649f, -0.00940793f, -0.06109881f, 
    0.06799318f, 0.04066936f, -0.05231163f, 0.15226211f, 0.18389319f, 0.23018870f, 0.11840632f, 0.15439731f, 
    -0.37633008f, 0.26062346f, -0.05235055f, 0.00154509f, 0.00807095f, 0.11387774f, -0.05239385f, -0.00990486f, 
    -0.08013923f, -0.17709227f, 0.17450427f, -0.06684994f, 0.35545325f, 0.02966146f, 0.13373485f, -0.03996938f, 
    0.00130436f, 0.08821148f, 0.06512574f, -0.02624413f, 0.11839842f, -0.04777211f, 0.01082372f, 0.08442586f, 
    -0.13430044f, 0.33511922f, 0.07756229f, 0.09129895f, -0.02893145f, -0.07530232f, -0.02779668f, -0.10406085f, 
    0.08230310f, -0.01008945f, -0.03270875f, 0.04079330f, 0.12129737f, 0.24271438f, 0.04059233f, 0.12320323f, 
    -0.04754165f, 0.06979247f, 0.11989139f, 0.00557842f, 0.04756777f, -0.00068076f, 0.14061244f, -0.07413303f, 
    -0.03512606f, -0.25298846f, 0.00851661f, -0.13882761f, -0.07860115f, -0.27379945f, 0.04650848f, 0.03520885f, 
    -0.07329963f, 0.13299109f, -0.08215919f, 0.10656021f, 0.18296784f, 0.04746106f, 0.10545310f, 0.02463285f, 
    0.06893440f, -0.08284077f, 0.02476805f, 0.06984504f, -0.02141295f, 0.05311312f, -0.08523037f, 0.18368945f, 
    -0.09687474f, -0.05876962f, 0.12192996f, 0.13347162f, -0.07726675f, -0.11679699f, 0.03380641f, 0.06597721f, 
    -0.01320940f, -0.06899613f, -0.12661482f, -0.09746160f, -0.45075154f, 0.17845036f, -0.01777064f, 0.10617513f, 
    0.16505134f, 0.08574061f, 0.02593210f, 0.01390435f, -0.11739819f, -0.04747454f, -0.00029737f, 0.27587780f, 
    -0.11526396f, -0.18296975f, 0.24401256f, -0.01279386f, -0.10567470f, 0.00212305f, -0.06345788f, -0.12898555f, 
    -0.04808053f, 0.14567235f, 0.09416662f, -0.05477946f, 0.23130573f, -0.03854970f, -0.09474265f, -0.00468310f, 
    0.07114068f, -0.00208913f, 0.00810288f, 0.08561735f, 0.08568689f, -0.12489185f, 0.13132060f, 0.03222108f, 
    0.05019725f, 0.28543681f, -0.00154036f, -0.05224518f, -0.06520336f, 0.00653485f, 0.00432668f, -0.16717736f, 
    0.11497553f, -0.00742999f, -0.00788894f, -0.12001959f, 0.09505159f, -0.26066902f, -0.14915815f, 0.02545329f, 
    0.01490797f, 0.08486550f, 0.04745109f, -0.00842038f, 0.19338496f, -0.00572133f, 0.05231174f, -0.01769168f, 
    -0.06025353f, -0.09016143f, 0.04866316f, -0.10120481f, -0.00953561f, 0.11548231f, -0.01777502f, -0.03257668f, 
    -0.07517449f, 0.05902764f, 0.01754555f, -0.03463811f, -0.03127091f, -0.30138487f, -0.05548697f, 0.32379323f, 
    0.24059601f, -0.10386625f, -0.03306444f, 0.13185669f, 0.07532483f, 0.12170727f, 0.08366396f, 0.06714886f, 
    0.04223321f, -0.20434730f, -0.09826696f, -0.05218679f, 0.06634332f, -0.00839432f, -0.07045676f, -0.09903555f, 
    -0.02801341f, -0.02156343f, 0.03520731f, 0.10406338f, -0.03210102f, 0.31016538f, 0.03473877f, 0.04864476f, 
    -0.05701096f, 0.00228427f, 0.10864310f, 0.04837864f, -0.02265661f, 0.13627037f, 0.12535408f, 0.14931343f, 
    -0.10206693f, 0.01629519f, 0.05951378f, -0.19012377f, -0.09874103f, 0.03056140f, 0.01543012f, -0.12213996f, 
    -0.13820571f, -0.06552482f, 0.03381490f, 0.07890340f, -0.02971469f, 0.10109353f, 0.22573555f, -0.23462833f, 
    -0.00389026f, -0.11521489f, 0.17470510f, -0.01617605f, -0.06849843f, 0.12219380f, -0.05754863f, 0.12269536f, 
    0.14054330f, -0.06627071f, 0.03120578f, 0.25085855f, 0.13022210f, -0.01519335f, 0.16020969f, 0.09889895f, 
    0.09538070f, 0.11731417f, 0.00684795f, 0.16390623f, -0.49553034f, 0.08767853f, 0.03902948f, -0.02319287f, 
    0.15043865f, 0.08765445f, -0.00465298f, 0.11707199f, -0.00295639f, 0.05061030f, -0.11887922f, -0.04903671f, 
    0.09190603f, 0.03267793f, 0.00687842f, 0.00023897f, 0.02405321f, 0.01518597f, 0.04688883f, -0.10017724f, 
    0.11168762f, -0.07201690f, 0.01378907f, -0.04961706f, 0.25656828f, 0.19498900f, -0.03724556f, -0.07493681f, 
    0.04341645f, 0.00650058f, -0.04078630f, 0.09763204f, 0.14318398f, -0.00962081f, 0.18205568f, 0.10242932f, 
    -0.32082689f, -0.08645975f, 0.15643834f, -0.02196720f, 0.01722054f, -0.07614830f, -0.21034402f, 0.07087297f, 
    0.12687479f, -0.05892650f, -0.03384256f, -0.07988386f, -0.21824053f, 0.01053929f, -0.13686913f, 0.07959486f, 
    0.04244505f, -0.04514533f, -0.12675203f, 0.02564297f, 0.04706550f, 0.00771547f, -0.00824109f, -0.00498660f, 
    -0.07904771f, -0.21718320f, -0.04254268f, 0.15545669f, -0.14205441f, 0.08698958f, -0.02559714f, 0.06794326f, 
    0.20481656f, -0.04519825f, 0.07720086f, 0.00502042f, 0.32601744f, 0.55763280f, 0.13657494f, 0.08109188f, 
    0.14435597f, -0.01364183f, 0.00903147f, 0.11528774f, 0.01069978f, -0.02878487f, 0.16619495f, -0.01216548f, 
    0.23265411f, -0.22145587f, 0.08281203f, 0.14744098f, 0.06684364f, 0.05808538f, -0.18956345f, 0.05169603f, 
    0.02309375f, -0.08933880f, 0.10496535f, 0.01037796f, 0.02699197f, 0.21835601f, -0.03894758f, -0.19057341f, 
    0.23595291f, 0.04704722f, 0.00274166f, -0.10897440f, -0.00272149f, 0.08821021f, 0.17064326f, 0.00129948f, 
    0.22508562f, -0.12531017f, 0.04841625f, 0.05422727f, 0.09724614f, 0.01914692f, -0.03016449f, -0.08571258f, 
    0.10352048f, 0.00572208f, -0.00583477f, -0.05084158f, 0.17396104f, 0.00621986f, -0.11449667f, 0.06354523f, 
    0.10269086f, 0.01262362f, -0.07212968f, 0.03165392f, 0.04800181f, -0.12946655f, 0.06764213f, -0.02618046f, 
    0.22475240f, -0.06637769f, 0.21263684f, -0.02650258f, -0.02058174f, 0.07519233f, -0.09455645f, -0.00210725f, 
    0.07230778f, -0.06061587f, -0.04480707f, -0.01770565f, 0.31764886f, 0.18060069f, -0.10430545f, -0.04019757f, 
    0.06482745f, -0.11279662f, 0.02002874f, 0.00149540f, 0.07891629f, 0.01995354f, 0.03452725f, 0.04741953f, 
    0.16988705f, -0.21563143f, -0.01702615f, -0.00004849f, 0.06812892f, -0.08325379f, 0.04336996f, -0.09165204f, 
    0.12326495f, 0.04489299f, 0.02337634f, 0.06156387f, -0.17387454f, -0.08596423f, -0.06122367f, 0.11574154f, 
    0.09533025f, -0.02201635f, 0.05221624f, 0.05187299f, 0.13312057f, -0.05393347f, 0.06001228f, 0.06495807f, 
    0.20461363f, 0.05514925f, -0.00574020f, -0.19492848f, 0.10111627f, -0.04521634f, -0.04056374f, -0.02574719f, 
    0.03110234f, 0.03294696f, -0.05388308f, -0.01094278f, 0.10469322f, -0.05333981f, -0.05134355f, -0.15241706f, 
    0.25362888f, -0.00441376f, 0.00399272f, -0.12981100f, -0.06380560f, 0.07661991f, -0.02421818f, 0.02537270f, 
    -0.13882338f, -0.00726161f, 0.11892699f, -0.03791538f, 0.02202634f, -0.08999091f, -0.06216131f, -0.07702492f, 
    -0.00116366f, -0.01519797f, 0.02215596f, 0.04996352f, -0.00937285f, -0.11949024f, 0.09252810f, 0.10896885f, 
    0.00048264f, -0.01590560f, 0.04516380f, 0.08441295f, 0.15269054f, 0.16754080f, -0.05109021f, 0.09392083f, 
    -0.21817611f, 0.04733122f, 0.08405715f, -0.04391324f, 0.14509608f, 0.00362791f, 0.07690676f, -0.12646145f, 
    0.12000128f, 0.00162372f, 0.02705839f, 0.01315152f, -0.04562019f, 0.29643881f, 0.11691397f, 0.02572822f, 
    0.19655141f, -0.06458036f, 0.16523592f, 0.22349723f, 0.18034895f, 0.08058365f, 0.07563181f, 0.09240691f, 
    0.42367050f, 0.24818935f, -0.06822495f, 0.01402767f, 0.21179114f, 0.06103249f, -0.03462634f, -0.10907610f, 
    -0.05167622f, 0.01059093f, 0.01288863f, 0.18203594f, -0.04299541f, 0.06438394f, -0.02628412f, -0.10258752f, 
    -0.01527212f, 0.01511001f, 0.02033694f, 0.08468556f, -0.02121395f, 0.10376485f, 0.07328834f, 0.07134899f, 
    0.22153115f, -0.28493422f, 0.10696001f, -0.06931995f, 0.14848109f, -0.15183096f, 0.10002205f, 0.01502519f, 
    0.08676508f, -0.07936586f, -0.04335818f, 0.01255092f, 0.24939145f, 0.17320403f, 0.14043936f, 0.04943252f, 
    0.04813318f, 0.07805567f, 0.01851466f, -0.07604162f, 0.09831572f, 0.03920984f, 0.03422460f, -0.04420881f, 
    -0.16391943f, 0.02503897f, -0.18526196f, -0.07232281f, 0.00058690f, 0.05957217f, -0.15431589f, -0.01522628f, 
    0.06199895f, 0.04633309f, -0.02871821f, 0.08111130f, 0.44254288f, 0.27009284f, 0.02028973f, 0.15589394f, 
    0.11838402f, -0.02998135f, -0.02835064f, -0.05437281f, 0.05010417f, 0.03812484f, 0.04854979f, 0.03880090f, 
    0.23811650f, -0.05867312f, -0.07972927f, 0.04496232f, 0.04225302f, 0.13885069f, 0.08068422f, 0.02643268f, 
    0.00064738f, 0.00237269f, 0.05469925f, -0.02492959f, -0.34358063f, 0.03311734f, 0.21121494f, -0.00705836f, 
    0.10996533f, 0.03545791f, -0.07047746f, -0.00673904f, -0.01970471f, 0.02512204f, -0.08212749f, 0.04013150f, 
    0.20015180f, -0.34247190f, 0.04506785f, 0.05160590f, 0.05253507f, 0.14380747f, 0.02522176f, 0.20689555f, 
    -0.08280488f, 0.11655649f, 0.09305497f, -0.04263305f, 0.03017328f, 0.09713710f, 0.08693775f, 0.15860932f, 
    -0.09755451f, 0.06541022f, 0.17175488f, 0.14355992f, 0.01040728f, -0.04057935f, 0.08784713f, -0.00622425f, 
    -0.27032694f, 0.50230968f, -0.10372932f, 0.16022445f, 0.16079929f, -0.11691494f, 0.08533598f, 0.09762481f, 
    0.20574336f, -0.07935116f, 0.06895761f, 0.15978344f, -0.11693811f, -0.03269543f, 0.15859269f, 0.02843523f, 
    -0.01598350f, 0.10729919f, 0.06689350f, -0.02121959f, 0.03177466f, 0.10541342f, -0.04922158f, 0.03368810f, 
    0.21756917f, -0.14019324f, -0.28582069f, -0.05668835f, 0.01613839f, -0.00985192f, 0.13258331f, 0.09214894f, 
    0.02109577f, -0.05040858f, 0.10850380f, -0.05134606f, -0.02851593f, 0.01414759f, -0.13174525f, -0.15549229f, 
    0.04482394f, -0.08469828f, 0.14439994f, 0.03047331f, 0.12017339f, 0.04514375f, -0.02849670f, -0.04615036f, 
    0.29529923f, 0.53258801f, 0.16380382f, -0.04455043f, 0.11276525f, -0.00195640f, 0.07539261f, 0.14803544f, 
    0.01740234f, -0.03736975f, 0.09357401f, 0.03914543f, 0.07592465f, 0.04783272f, -0.00667839f, -0.07085288f, 
    -0.01953814f, -0.04071954f, 0.00698073f, -0.01648259f, -0.03654206f, -0.07705570f, 0.04628491f, -0.01468317f, 
    -0.02459901f, 0.07110410f, 0.15432641f, 0.15084760f, 0.09949993f, -0.00118142f, -0.02237128f, 0.04793356f, 
    0.12905300f, 0.14847101f, -0.01097450f, 0.00244747f, -0.02668394f, -0.07252733f, 0.22942889f, 0.07307192f, 
    0.05718141f, 0.10456404f, -0.03829929f, 0.05306590f, 0.11401600f, 0.09359185f, -0.00060950f, 0.06787704f, 
    0.22716214f, 0.02499205f, -0.04444160f, 0.10658649f, -0.02073401f, 0.01978261f, 0.12236491f, -0.06426869f, 
    0.10606325f, 0.03917423f, 0.00587235f, 0.10254152f, -0.52259558f, 0.25797352f, -0.07764246f, -0.17535132f, 
    0.07712645f, -0.18614532f, 0.02354511f, 0.04026725f, 0.07633119f, -0.02948442f, 0.00900581f, -0.01047555f, 
    0.44652340f, 0.34785646f, 0.13271894f, 0.08821641f, 0.14030008f, 0.08556684f, 0.01655802f, 0.03649427f, 
    -0.06530911f, 0.06882454f, 0.15618476f, 0.10336018f, 0.10600536f, 0.19106117f, -0.03761449f, -0.09930898f, 
    -0.01416166f, -0.01475152f, 0.11595887f, 0.04219478f, 0.17272732f, 0.08432991f, 0.11472721f, 0.04378154f, 
    -0.04622332f, -0.06544473f, -0.00858869f, -0.01597515f, 0.03805863f, 0.05949756f, 0.01903509f, -0.09536459f, 
    0.12055320f, -0.01995558f, -0.00355548f, -0.03503574f, 0.04550610f, 0.46217993f, 0.06057701f, 0.07763724f, 
    0.09453860f, -0.13899483f, -0.04178065f, -0.04747494f, 0.08002245f, -0.01279579f, 0.14809227f, 0.04352798f, 
    0.41719952f, 0.03238408f, -0.37787104f, 0.00293476f, 0.08366127f, 0.01882743f, 0.16398679f, -0.02456393f, 
    0.07473903f, -0.07441010f, 0.21668237f, 0.02569315f, -0.34829035f, -0.16395111f, -0.06254318f, -0.11464043f, 
    0.05838226f, 0.00905635f, 0.05573580f, -0.09467126f, -0.02860735f, 0.01697289f, 0.06322999f, -0.01250862f, 
    -0.14219423f, -0.37954918f, -0.06577490f, -0.02623505f, 0.04806464f, 0.20161532f, 0.08141542f, 0.04239153f, 
    0.05663963f, -0.05425441f, -0.01463908f, -0.04170400f, 0.42826429f, -0.02153438f, -0.24854733f, -0.12443189f, 
    -0.03845864f, -0.06022083f, 0.08309793f, 0.01043543f, 0.09352197f, 0.06304851f, 0.06356591f, -0.00543652f, 
    -0.04361377f, -0.00002037f, 0.17796379f, -0.10825357f, -0.12485622f, -0.08702901f, -0.13559340f, -0.02528436f, 
    0.08191809f, 0.04371522f, -0.16156055f, -0.13874722f, 0.06531969f, -0.06747205f, 0.12729093f, 0.02541474f, 
    -0.00642079f, 0.00259440f, 0.10131864f, 0.08642214f, -0.09083128f, 0.19282511f, -0.06679526f, -0.04542977f, 
    -0.09816530f, -0.21621840f, 0.00942319f, 0.00568496f, 0.05342173f, 0.09990084f, -0.05601128f, -0.07151290f, 
    0.01950333f, 0.04114168f, -0.03850166f, -0.03379162f, 0.54640925f, 0.12952732f, -0.25675789f, -0.19833693f, 
    0.02046608f, 0.01237899f, -0.03021296f, 0.05561015f, -0.04282676f, -0.02333883f, 0.06719750f, 0.24525984f, 
    -0.03291700f, 0.11383580f, 0.01466817f, -0.03103079f, 0.12511732f, -0.09355649f, -0.02386563f, 0.11233587f, 
    0.07064742f, -0.02240107f, 0.05893151f, -0.06243742f, -0.16744365f, -0.17635956f, -0.00149470f, 0.06739805f, 
    0.02911428f, -0.06832965f, 0.00992337f, 0.01606610f, 0.01232906f, 0.02134134f, 0.01371049f, -0.05017126f, 
    -0.14719038f, 0.04057898f, -0.10415133f, -0.03239439f, 0.07370079f, -0.00731912f, -0.10886279f, -0.11923196f, 
    -0.02201561f, -0.01546050f, -0.10247172f, -0.08140469f, 0.26037169f, 0.08519142f, 0.13948904f, 0.01343689f, 
    0.17033178f, 0.01314620f, -0.03171638f, -0.03080584f, -0.06258045f, -0.00229959f, -0.02079316f, -0.07205699f, 
    0.03256469f, 0.11191460f, -0.29314810f, 0.17811935f, 0.02128319f, 0.04870689f, 0.01112682f, -0.08819622f, 
    -0.01117384f, -0.11274204f, -0.00413796f, -0.09442222f, 0.22291839f, 0.13851975f, -0.04854550f, -0.17300743f, 
    0.04253215f, -0.02004858f, 0.00419229f, 0.11608955f, 0.04745782f, 0.05566324f, 0.15433542f, -0.02618444f, 
    0.26404423f, 0.16767755f, 0.08408394f, 0.02432949f, 0.12636682f, 0.15382843f, -0.03579738f, -0.08056881f, 
    0.06428063f, -0.02656618f, 0.07855612f, -0.03842152f, 0.08726759f, -0.18502924f, -0.04268810f, -0.22766377f, 
    0.07954495f, 0.06791310f, -0.02517458f, 0.08090052f, 0.05006525f, -0.02644483f, 0.06785695f, 0.18784072f, 
    -0.20741069f, 0.19582470f, 0.10310983f, 0.01025331f, 0.03754662f, 0.02962937f, -0.01502168f, 0.03256015f, 
    0.13283423f, 0.05581986f, 0.02816370f, -0.08013661f, -0.01474911f, -0.07751989f, 0.30217540f, 0.04317418f, 
    0.05985643f, 0.01619469f, -0.01963813f, 0.01421468f, -0.06836662f, 0.07291723f, 0.00863960f, 0.05968000f, 
    0.61326689f, 0.04311457f, -0.23501091f, -0.19616272f, 0.04439688f, 0.03356451f, 0.04094303f, -0.00301838f, 
    -0.04334585f, 0.09888711f, 0.09798946f, 0.17277895f, 0.28110042f, 0.12947796f, -0.13425300f, -0.15535541f, 
    0.20289083f, -0.00802188f, -0.04896354f, 0.15175982f, 0.10211074f, 0.10355335f, 0.08160963f, -0.00978313f, 
    -0.03226593f, 0.14427263f, -0.01830231f, -0.01220393f, 0.01438156f, 0.00328420f, -0.06408256f, -0.02721661f, 
    0.07827414f, 0.06387331f, 0.06625207f, 0.05698120f, -0.34365186f, 0.08785393f, -0.00333089f, -0.27569219f, 
    0.07035641f, -0.02415971f, -0.05034915f, 0.01675647f, -0.08407966f, 0.13436155f, 0.03842767f, 0.04371507f, 
    -0.09552436f, 0.02111693f, -0.18601994f, 0.07143021f, -0.11548959f, -0.04708130f, 0.18940009f, 0.04476876f, 
    0.10157618f, 0.00781033f, 0.12733886f, -0.01234840f, 0.23140827f, -0.04297734f, 0.07105814f, -0.10206374f, 
    0.15878429f, 0.07817791f, 0.01472703f, -0.08443342f, 0.02089402f, 0.09351347f, 0.01898261f, 0.05480277f, 
    0.00714347f, -0.02323253f, -0.01098836f, 0.01920418f, 0.02941042f, 0.01041329f, -0.04010804f, 0.00315337f, 
    0.00635537f, -0.00122245f, -0.03917804f, -0.00125663f, 0.01494054f, -0.00402717f, -0.00837817f, -0.01846511f, 
    -0.03222979f, -0.03534129f, -0.00885010f, -0.00452484f, -0.00448172f, -0.00812420f, -0.03862918f, 0.02447239f, 
    -0.02585782f, -0.01967549f, -0.01289966f, -0.02974458f, -0.02004207f, -0.01046428f, 0.03040520f, -0.01905310f, 
    0.03720973f, 0.02388879f, -0.00879979f, -0.00200027f, 0.02181227f, -0.00102185f, -0.02848265f, -0.02657681f, 
    -0.02118921f, 0.02182737f, 0.01621706f, -0.01989838f, -0.01768921f, 0.00946639f, 0.02552998f, 0.00355473f, 
    -0.03683385f, -0.02396214f, -0.00011529f, -0.01380573f, 0.00750576f, -0.00556235f, -0.01738924f, -0.01150214f, 
    -0.00489425f, 0.00929827f, -0.00076094f, -0.03798275f, -0.00170876f, 0.03519028f, 0.00729384f, 0.00136155f, 
    0.01692600f, 0.00071078f, 0.01809666f, 0.03036792f, -0.00753011f, 0.02066802f, 0.00663118f, 0.01041816f, 
    0.01826231f, -0.01061046f, -0.00698026f, 0.01099240f, 0.02329844f, 0.00178464f, -0.01715141f, -0.03220493f, 
    -0.02593980f, -0.02668270f, 0.00849737f, 0.02562688f, -0.00382452f, 0.02573807f, -0.03165171f, -0.01158213f, 
    0.00223994f, 0.01252400f, -0.01043346f, 0.01679906f, 0.00167550f, -0.02858685f, 0.01035748f, -0.00324779f, 
    -0.00009348f, -0.02835920f, 0.00454811f, 0.02007440f, -0.02117626f, 0.02898435f, -0.00031722f, -0.01135683f, 
    0.02845798f, -0.03102558f, 0.01389370f, -0.02608106f, 0.00394021f, 0.01520339f, -0.02843017f, 0.01617583f, 
    0.00725533f, -0.04575867f, -0.01945159f, -0.01115306f, 0.02937277f, -0.00878947f, 0.03165047f, 0.02717129f, 
    -0.02590822f, 0.02088968f, 0.03133614f, 0.00687707f, 0.01246032f, 0.00816784f, -0.02463539f, 0.01082101f, 
    -0.00017596f, -0.01229485f, 0.03157993f, -0.01815339f, -0.00678495f, -0.01805821f, 0.00891132f, 0.02252267f, 
    0.02191858f, 0.00146011f, 0.02625976f, -0.02583290f, 0.00366042f, -0.02848776f, -0.00532742f, 0.01420225f, 
    0.01341272f, -0.00898172f, 0.02799789f, 0.00308441f, -0.00723888f, 0.02755547f, 0.01751504f, -0.01829578f, 
    -0.01647312f, -0.02710559f, 0.00174236f, 0.02342147f, -0.01712402f, 0.00907139f, -0.01128741f, 0.01939633f, 
    -0.02108548f, 0.00021654f, 0.01378585f, 0.03384929f, -0.02226963f, -0.03170950f, 0.02939535f, -0.01582919f, 
    0.02276171f, -0.02619227f, 0.02849600f, 0.01203972f, -0.01018783f, 0.02375825f, 0.01021126f, -0.01749172f, 
    0.01914247f, -0.03934732f, 0.02732850f, -0.00075200f, 0.00824827f, -0.02079573f, -0.03244662f, -0.02014489f, 
    0.01853262f, -0.00762400f, 0.02558204f, -0.02030752f, 0.03851658f, -0.00908854f, 0.03883832f, -0.01163615f, 
    0.00804768f, 0.00520230f, -0.00082715f, -0.00024882f, -0.03646880f, 0.02303176f, -0.03928352f, -0.01525011f, 
    -0.00909350f, 0.00664609f, 0.02673530f, -0.03452856f, -0.00827269f, -0.00509106f, -0.02853182f, 0.01036883f, 
    -0.01623676f, -0.03959409f, 0.00313068f, 0.00785490f, -0.00544263f, 0.02885071f, -0.00992824f, 0.01909244f, 
    0.00522866f, 0.01372467f, -0.00552708f, -0.02310144f, -0.03054143f, 0.02137707f, -0.00482227f, 0.00974461f, 
    0.01499367f, -0.00471477f, 0.03063897f, -0.00027439f, -0.01582589f, -0.00109007f, -0.00862202f, -0.03474239f, 
    0.00798168f, -0.04072555f, 0.01993374f, 0.02566092f, -0.03058959f, -0.01099942f, -0.01048012f, -0.02753384f, 
    0.00766284f, 0.00314057f, -0.00051612f, -0.03518901f, 0.00134857f, 0.01930185f, -0.00155205f, -0.00208939f, 
    0.01370038f, -0.01139979f, -0.02441373f, 0.02523383f, 0.00270495f, -0.04608952f, -0.00108636f, -0.01535309f, 
    0.03331313f, 0.01982085f, 0.02742506f, 0.00951472f, 0.03086016f, -0.03027661f, -0.01846064f, 0.02330749f, 
    -0.01974806f, -0.00048147f, -0.03739340f, -0.03457712f, 0.02732912f, 0.02368809f, -0.02646253f, -0.00385317f, 
    -0.02135003f, 0.00076593f, 0.00978762f, -0.01886373f, -0.00934303f, -0.00540288f, -0.01562037f, -0.00556789f, 
    0.02258146f, 0.01459056f, 0.01376953f, 0.03015842f, 0.02967268f, -0.00050314f, -0.02448715f, 0.01472328f, 
    0.03498342f, -0.00553012f, -0.00725845f, 0.00964858f, -0.01432629f, -0.00618861f, -0.02352172f, -0.00612003f, 
    -0.01014886f, -0.00057482f, 0.02458403f, 0.00597557f, 0.02312790f, 0.01939532f, 0.01182107f, -0.02352306f, 
    0.02111796f, 0.00990301f, -0.00845374f, -0.03320460f, -0.02576114f, -0.03576828f, 0.00373287f, -0.03609558f, 
    0.01792603f, 0.03441008f, 0.02404652f, 0.00676517f, -0.03099226f, -0.00959356f, 0.01546602f, 0.01444147f, 
    -0.01471240f, 0.02351057f, 0.01823112f, 0.01661960f, 0.01868822f, -0.00634543f, -0.02530710f, -0.00130222f, 
    0.00821492f, 0.01522335f, 0.02663141f, 0.03704428f, 0.02243375f, -0.02137186f, -0.03616390f, -0.01790351f, 
    0.03122959f, 0.00980842f, -0.02843789f, 0.01669955f, 0.03557521f, -0.01561522f, -0.01016205f, -0.01487173f, 
    -0.01179653f, 0.00302023f, 0.02148254f, 0.00848265f, -0.01022679f, 0.00025111f, -0.03241636f, 0.02615951f, 
    -0.01024240f, -0.03074181f, -0.02901723f, -0.01546219f, -0.01855143f, -0.02212122f, -0.03003347f, -0.00585933f, 
    -0.02648965f, 0.02732800f, -0.01114285f, 0.00020741f, -0.01086923f, 0.00824770f, -0.00195117f, -0.04679829f, 
    -0.03918073f, 0.01751063f, 0.00988509f, 0.02572269f, 0.01335558f, 0.02876245f, -0.00189085f, -0.02382173f, 
    -0.00622344f, -0.00308596f, -0.01863771f, -0.03213832f, -0.02879063f, -0.01446736f, 0.02328832f, 0.01886326f, 
    0.02683648f, -0.00877510f, 0.02740547f, 0.01909379f, 0.02835874f, 0.01701274f, 0.02090074f, 0.02763595f, 
    0.01700804f, 0.03221986f, -0.02172222f, -0.03605867f, 0.02067295f, -0.01610951f, 0.01474019f, -0.00494043f, 
    -0.03656132f, -0.00793952f, -0.03462748f, -0.01160489f, 0.00275968f, 0.01011807f, 0.02030024f, 0.01460118f, 
    0.01214371f, -0.01285697f, 0.00583331f, -0.00981567f, -0.00872016f, -0.00292241f, -0.00022635f, -0.01205496f, 
    -0.00210945f, -0.02271461f, 0.02500492f, 0.02662887f, 0.01799068f, 0.02391977f, 0.00111700f, -0.02865663f, 
    0.00072899f, -0.01949734f, 0.02809309f, -0.01392522f, 0.02282591f, -0.01925661f, -0.02519352f, -0.00693075f, 
    0.01680090f, 0.01690799f, -0.02047653f, -0.04411678f, -0.02450705f, 0.02415701f, -0.03356614f, 0.01971476f, 
    -0.03315934f, 0.02996782f, -0.00053242f, 0.02099203f, -0.00778043f, -0.03869581f, -0.01128029f, -0.00273838f, 
    -0.02688240f, 0.00805597f, -0.00030343f, -0.02985699f, 0.02488449f, 0.00155610f, 0.01382811f, -0.02255937f, 
    -0.02338814f, 0.03777274f, -0.03889650f, 0.02183367f, -0.03471736f, 0.02977721f, -0.00140197f, 0.00837006f, 
    0.00135851f, -0.02401293f, -0.00838821f, -0.03781395f, -0.00045347f, 0.01540212f, 0.01065280f, -0.01557127f, 
    -0.03018069f, 0.01998849f, -0.02242262f, 0.01615011f, -0.01790267f, -0.03851508f, 0.01548380f, -0.01869664f, 
    -0.01471127f, -0.00294174f, -0.02067764f, -0.00114026f, 0.01374228f, 0.01150657f, 0.02392921f, 0.00036788f, 
    0.03111590f, -0.03101976f, 0.01725574f, -0.03233521f, 0.00223861f, -0.00257647f, -0.04279487f, -0.03087212f, 
    0.01937514f, -0.01238523f, 0.01880505f, -0.02337965f, 0.01011163f, -0.02267910f, 0.00794844f, 0.02121580f, 
    -0.00164760f, -0.00430062f, 0.02869760f, -0.03377964f, -0.02234563f, -0.00659760f, -0.02839553f, -0.03118668f, 
    -0.01576854f, 0.01994802f, 0.00774963f, -0.01597284f, -0.02112573f, 0.02116296f, -0.02081531f, 0.02067583f, 
    0.02929322f, -0.01205359f, 0.00222200f, 0.03069853f, -0.02391495f, 0.00552506f, -0.02676976f, 0.02317293f, 
    0.00462691f, -0.01289883f, -0.01603325f, 0.01043178f, 0.01425957f, -0.02929872f, -0.02507438f, 0.01074828f, 
    0.00795748f, 0.00647392f, 0.02414690f, -0.03655545f, -0.00071789f, 0.02661834f, -0.01446769f, 0.00246558f, 
    0.01233691f, 0.00715665f, -0.03317253f, 0.02584380f, 0.02151722f, -0.00644868f, -0.01059382f, -0.03163443f, 
    -0.00142146f, 0.01736345f, -0.04127830f, -0.02294813f, 0.00075634f, -0.02801961f, -0.02309829f, -0.00644434f, 
    0.01371134f, 0.01455319f, 0.01247497f, 0.01834272f, -0.00066334f, -0.02556738f, -0.03161150f, 0.00681948f, 
    -0.00313260f, -0.02616064f, 0.00300026f, 0.01177305f, 0.00604371f, -0.03142438f, 0.00785058f, -0.02207962f, 
    -0.03512418f, -0.03571866f, -0.04507948f, 0.03274786f, 0.02305941f, -0.02969309f, 0.00025448f, -0.02091991f, 
    0.01427007f, 0.02235453f, -0.04150504f, -0.03752412f, 0.02603930f, -0.00081858f, 0.03071697f, 0.00821088f, 
    -0.02557185f, -0.03274810f, 0.01161433f, -0.02946121f, -0.02727498f, 0.02026662f, 0.00798816f, -0.01724234f, 
    -0.03761520f, -0.00305679f, 0.01039208f, -0.01717077f, -0.01584426f, -0.02110282f, -0.02770627f, 0.01292434f, 
    -0.00808814f, 0.00329760f, -0.00721814f, 0.02882877f, -0.03006372f, 0.02134771f, 0.01417502f, -0.04421148f, 
    0.02489328f, 0.00611265f, -0.03827271f, -0.03026229f, 0.02446205f, 0.01629553f, -0.04152559f, -0.00110800f, 
    -0.01051842f, 0.01788447f, -0.01666084f, -0.03454137f, -0.03317249f, -0.00741429f, -0.00486425f, 0.03331139f, 
    -0.01108456f, -0.00156681f, -0.01512157f, -0.02739062f, 0.00509704f, 0.00771413f, -0.00147266f, 0.00695032f, 
    0.00097772f, -0.04146497f, 0.01337176f, 0.01052724f, -0.01279968f, -0.01463536f, 0.01380301f, -0.03343874f, 
    -0.02707397f, 0.03816213f, -0.00015218f, 0.02813948f, 0.00751856f, 0.01341205f, 0.03008756f, -0.04100178f, 
    -0.01245064f, -0.01073270f, 0.00755680f, 0.00836235f, -0.03320479f, 0.01045210f, -0.00467729f, 0.03122345f, 
    0.00684771f, 0.00846394f, -0.04094081f, 0.01713591f, -0.04141172f, -0.03873145f, -0.02308317f, 0.01070081f, 
    -0.03937959f, 0.02705511f, 0.00322745f, 0.03060706f, 0.01652025f, 0.02818579f, -0.01085506f, 0.00918356f, 
    -0.03650243f, 0.00136450f, 0.02723897f, 0.00577535f, -0.01995936f, 0.03595268f, -0.04146072f, -0.03843705f, 
    -0.02935682f, 0.03036165f, 0.01936123f, -0.00753887f, 0.01252734f, -0.03261792f, -0.01978816f, -0.01058906f, 
    -0.02380887f, 0.00859817f, -0.01475121f, 0.03267198f, 0.02580225f, 0.01523679f, 0.01166631f, 0.01927825f, 
    -0.02463485f, -0.02335866f, -0.02193815f, -0.03379738f, -0.01443058f, 0.00095101f, 0.00594390f, -0.03343748f, 
    -0.02981684f, -0.03909961f, 0.02423687f, -0.03580714f, -0.03730252f, 0.00218546f, 0.01795533f, -0.02661311f, 
    0.02896174f, -0.00961296f, 0.02853647f, 0.00234830f, -0.01785283f, 0.01281920f, -0.02852451f, 0.02219010f, 
    -0.02131155f, -0.00499787f, 0.02560157f, 0.01288091f, -0.01451080f, 0.01316381f, -0.03788576f, -0.01663644f, 
    -0.04169236f, 0.02610000f, 0.00785144f, 0.02059939f, 0.02159915f, -0.01697311f, 0.01374780f, -0.04032455f, 
    -0.00735520f, -0.02027407f, 0.03473217f, 0.02810658f, -0.01330202f, -0.02378656f, 0.01608992f, -0.01839493f, 
    -0.03139115f, -0.03419172f, -0.01321488f, -0.01819655f, -0.01838012f, 0.02878674f, -0.01698125f, 0.00410178f, 
    0.01991027f, 0.02516194f, 0.02587921f, 0.02675674f, -0.03747925f, 0.02967186f, 0.03300193f, -0.01023423f, 
    -0.03275076f, 0.00575715f, -0.01320971f, 0.00859373f, 0.01496645f, -0.00786004f, -0.02122471f, 0.00804801f, 
    0.02211925f, 0.00298426f, 0.01685771f, -0.00739843f, 0.02119451f, -0.02327711f, -0.01315331f, -0.02802145f, 
    -0.03508979f, -0.01950045f, 0.02870635f, -0.00933971f, 0.00224599f, -0.02496906f, 0.02654683f, 0.01286413f, 
    -0.01889822f, 0.00427162f, -0.00848009f, 0.03483653f, -0.01478389f, 0.00468553f, -0.01026635f, 0.01253193f, 
    -0.04123494f, 0.02733166f, -0.03836303f, 0.00555463f, 0.02009301f, 0.00884768f, -0.03390455f, -0.01976585f, 
    0.01518470f, 0.02293493f, 0.00209549f, 0.00924108f, 0.02012892f, -0.02217417f, 0.02526695f, -0.02558590f, 
    -0.00037050f, 0.00559053f, 0.00176661f, -0.02195914f, 0.02821392f, 0.02599196f, 0.02388568f, 0.00318873f, 
    -0.01368375f, -0.00584397f, -0.02277558f, -0.00062469f, -0.03639396f, -0.02739434f, -0.01431931f, 0.02243991f, 
    0.00325643f, 0.01873608f, 0.00256989f, -0.02258362f, 0.00694760f, -0.02440963f, -0.03952467f, 0.00662125f, 
    -0.00446950f, 0.00284872f, 0.02161756f, -0.01151650f, 0.01888834f, -0.01260979f, 0.00302652f, -0.02090786f, 
    -0.03300070f, -0.02309457f, 0.02151652f, 0.01547265f, 0.00538018f, 0.00914489f, -0.00761092f, 0.02060016f, 
    -0.02910918f, 0.01757192f, 0.01869084f, -0.00071037f, 0.01003556f, -0.02297455f, -0.00186664f, -0.02858628f, 
    0.02340092f, 0.01447239f, -0.03596639f, 0.00005788f, 0.03720570f, -0.01881733f, 0.02642995f, 0.01407402f, 
    -0.02039145f, 0.00129235f, 0.01832232f, 0.02595928f, 0.00545896f, -0.00470792f, 0.00142989f, -0.03411342f, 
    -0.02323946f, 0.02143079f, -0.00852824f, -0.04089023f, -0.02441929f, -0.01201748f, -0.02904337f, 0.00825880f, 
    -0.02527963f, 0.00473202f, 0.01193982f, 0.03467474f, -0.02023092f, 0.00077012f, 0.02188239f, -0.02941718f, 
    0.01820713f, 0.00519236f, 0.02851013f, -0.04179583f, 0.00457189f, -0.00755170f, 0.02402418f, -0.03094881f, 
    -0.02282575f, -0.04012470f, 0.01289312f, -0.02235142f, 0.00757620f, -0.01401095f, -0.03978297f, -0.04033972f, 
    -0.02752916f, -0.00692683f, -0.03482812f, 0.00835677f, 0.02293342f, -0.02909851f, -0.04097288f, 0.02047656f, 
    0.02823423f, -0.01358978f, -0.03548935f, 0.02664156f, 0.00748347f, 0.00962413f, 0.03203802f, -0.01028336f, 
    0.02899961f, 0.00734887f, -0.01739175f, 0.00996790f, -0.00621004f, 0.01791527f, -0.03058487f, -0.02668047f, 
    -0.01684343f, -0.00839412f, 0.02348304f, -0.00986603f, 0.00541640f, 0.00563060f, 0.00634753f, 0.01303763f, 
    0.01240253f, -0.03964350f, 0.00245905f, 0.02351600f, -0.02831893f, -0.02918426f, -0.00225415f, 0.02478813f, 
    -0.00378648f, 0.01003703f, -0.02979138f, 0.01358509f, -0.02401803f, -0.00236905f, 0.02985991f, -0.01594365f, 
    -0.01917627f, -0.01370665f, -0.02711409f, -0.01705675f, -0.00422738f, 0.00361521f, 0.00865911f, -0.00896877f, 
    -0.03168055f, -0.01164281f, 0.00058876f, -0.02629120f, -0.03584754f, -0.02802163f, 0.02129846f, -0.01917031f, 
    -0.00103845f, 0.01511910f, 0.00499668f, 0.00023522f, -0.01066334f, -0.02924234f, -0.02645805f, -0.00690365f, 
    -0.03311159f, 0.02886148f, 0.02500097f, -0.03919046f, 0.02261993f, 0.00169127f, 0.02603764f, 0.02976813f, 
    -0.03542291f, 0.01055638f, -0.03466086f, 0.02576952f, -0.03506720f, -0.01488881f, 0.03204587f, -0.02910901f, 
    -0.00627836f, -0.00517272f, 0.01266159f, -0.01178140f, -0.00485962f, 0.01048602f, -0.03624666f, 0.02734841f, 
    0.02578443f, -0.00088080f, 0.03203090f, 0.00306596f, -0.02363444f, -0.03592465f, 0.02882509f, 0.01368731f, 
    0.02777059f, 0.01835657f, 0.02748469f, -0.01038822f, 0.00865855f, -0.00569055f, -0.01099858f, 0.00125306f, 
    -0.01842118f, 0.01069215f, 0.00937820f, -0.03511904f, 0.00222547f, 0.00804728f, 0.00590931f, -0.00140465f, 
    -0.03689938f, -0.02762300f, 0.01593670f, 0.01695706f, -0.02896461f, 0.01464232f, -0.02417734f, -0.03785066f, 
    -0.03086513f, -0.03095248f, 0.01042779f, 0.00551348f, 0.00547714f, 0.02881070f, -0.00221761f, 0.00208587f, 
    -0.00993363f, 0.02810712f, 0.00629606f, 0.01050682f, 0.01623935f, -0.01249670f, -0.01281958f, -0.00786711f, 
    0.00332654f, -0.03841823f, 0.00186020f, 0.01125022f, 0.00943752f, -0.03557663f, -0.03042054f, 0.01840445f, 
    -0.02250265f, -0.04403851f, 0.00609476f, 0.01101842f, 0.02587186f, -0.03200969f, 0.00601275f, -0.01668267f, 
    -0.00716333f, -0.01208635f, -0.00302075f, -0.03036292f, -0.00038737f, -0.03633598f, 0.00690788f, -0.01032340f, 
    -0.01450167f, -0.00059854f, 0.01997447f, 0.01986670f, -0.00262563f, -0.02480769f, -0.02490124f, -0.01265632f, 
    -0.01970182f, -0.02930412f, 0.00509355f, -0.02392293f, -0.01391094f, -0.00277633f, 0.00276296f, 0.00982701f, 
    -0.03398953f, -0.01680151f, 0.02645493f, -0.03982634f, -0.02428804f, 0.01610476f, 0.02457193f, 0.00649924f, 
    -0.01708486f, -0.01737947f, 0.02965429f, -0.02682715f, -0.01871666f, 0.02057762f, -0.00912855f, -0.02902148f, 
    0.03391223f, 0.00105311f, -0.01204422f, 0.00259124f, -0.01251565f, 0.02596742f, -0.00507374f, -0.03584795f, 
    0.01959472f, -0.02098810f, -0.03341428f, 0.01695068f, -0.02020350f, -0.00228807f, 0.00683404f, 0.03284734f, 
    -0.00968625f, -0.03525506f, -0.03959198f, 0.02166468f, -0.02893982f, -0.00179991f, -0.01499109f, -0.00881471f, 
    -0.03033003f, -0.00437212f, -0.02123467f, -0.02320014f, 0.03220248f, -0.00978751f, -0.01464115f, 0.01895878f, 
    -0.00675777f, -0.01514261f, 0.01377003f, 0.01241405f, -0.01485920f, 0.00035514f, -0.00272910f, -0.02520867f, 
    0.01846385f, 0.01896007f, 0.02227786f, -0.01366277f, -0.04120352f, -0.01117649f, 0.00570420f, -0.03565574f, 
    -0.02461820f, -0.01560536f, -0.01247049f, -0.00404441f, 0.01625487f, 0.02310410f, -0.01645976f, 0.00960031f, 
    0.02935433f, -0.01963552f, -0.03970710f, -0.03005092f, 0.02801398f, 0.00705593f, 0.02545994f, -0.01896398f, 
    0.02410780f, -0.00130738f, 0.00780367f, -0.00223865f, 0.02165156f, -0.00057057f, 0.02151874f, -0.04192238f, 
    -0.02839047f, -0.02362236f, 0.00497620f, -0.03083633f, 0.00778186f, -0.01227969f, 0.03366729f, 0.02765881f, 
    0.01077107f, -0.02163376f, -0.02224054f, -0.01972446f, 0.02776461f, -0.03382294f, -0.02006921f, 0.01829330f, 
    -0.01434030f, 0.01464257f, 0.02609322f, -0.00593095f, -0.02368096f, -0.01732613f, -0.03258175f, 0.01515095f, 
    0.01448638f, 0.02591699f, -0.01060445f, 0.01839846f, -0.01347487f, -0.01770223f, 0.02170253f, 0.03634785f, 
    -0.00914748f, 0.02303901f, -0.03062568f, -0.00984100f, -0.00118120f, -0.03154375f, 0.00060049f, -0.01876388f, 
    -0.03565582f, -0.00018875f, -0.00678456f, -0.01875387f, -0.02927600f, -0.01833289f, -0.00598237f, -0.03937931f, 
    -0.01922173f, -0.01882569f, -0.03449736f, -0.02009694f, 0.01453468f, -0.02743713f, -0.01676682f, 0.00853614f, 
    -0.00257761f, 0.01085512f, 0.02196618f, -0.02525226f, -0.03994148f, -0.01752964f, -0.00234708f, -0.01779833f, 
    0.02132472f, 0.01321695f, 0.02292082f, 0.02119158f, 0.01907061f, -0.00242785f, -0.00689805f, -0.00055048f, 
    0.00746675f, 0.01528962f, -0.02808452f, -0.01130756f, 0.00827526f, -0.00096135f, 0.01494617f, -0.02522633f, 
    0.02361492f, -0.00019445f, 0.02378520f, -0.01172008f, -0.00196416f, -0.02174288f, -0.03988573f, 0.01182248f, 
    -0.03114965f, -0.01379048f, -0.01921335f, 0.02810078f, -0.00770406f, 0.01012181f, 0.02374957f, 0.02934636f, 
    0.01083110f, 0.01453711f, -0.00536669f, -0.02640212f, 0.02443538f, 0.02424813f, 0.00558989f, -0.02928865f, 
    -0.03214448f, -0.02396491f, 0.01870084f, -0.00003884f, -0.03935531f, -0.03329136f, -0.02003046f, -0.01988211f, 
    -0.02907545f, -0.03449127f, -0.01491069f, -0.03800576f, -0.01974293f, -0.03386847f, 0.01370455f, -0.02053331f, 
    -0.01727801f, 0.01660664f, -0.01455919f, 0.02260640f, -0.00495335f, -0.04166839f, 0.00861597f, -0.00111620f, 
    0.02572184f, -0.03382339f, 0.01804555f, -0.03033697f, 0.00924298f, -0.01301484f, -0.01934605f, 0.00939269f, 
    -0.00723222f, 0.02966780f, 0.01307432f, -0.02460254f, 0.02282572f, 0.00936470f, -0.03117755f, 0.01020544f, 
    -0.04068350f, -0.01951985f, 0.02311710f, 0.00557839f, 0.00902005f, 0.01639543f, -0.02858241f, 0.02816572f, 
    0.01208526f, 0.01311392f, -0.02164260f, 0.00833203f, 0.02812174f, 0.00947400f, -0.00006373f, -0.04316681f, 
    0.02465141f, 0.01599883f, -0.03150316f, -0.00026292f, 0.02807660f, 0.01838206f, -0.03139169f, 0.00937873f, 
    -0.02007739f, 0.00288818f, -0.02675233f, 0.00231070f, -0.01903226f, -0.00412554f, -0.01024154f, 0.02211070f, 
    -0.03066293f, -0.02846794f, -0.01125492f, 0.01342457f, -0.01355317f, 0.00174520f, 0.00963413f, 0.02585307f, 
    0.02771729f, -0.00187449f, 0.03745578f, 0.00722198f, -0.03913108f, 0.00457549f, -0.01660500f, 0.00878014f, 
    -0.01442117f, 0.02538006f, 0.02784021f, -0.02609033f, 0.01204831f, -0.02942557f, -0.01206376f, 0.00201080f, 
    -0.02342543f, 0.02526176f, -0.03885566f, -0.01315147f, 0.02558543f, -0.02553611f, -0.00727186f, 0.00649780f, 
    0.00808612f, -0.00417085f, -0.01182592f, 0.00497783f, -0.01484058f, 0.00245347f, -0.02767883f, -0.01189130f, 
    -0.02240752f, 0.02348626f, -0.03763791f, 0.01740160f, 0.00775433f, -0.03318598f, 0.02515865f, -0.00981478f, 
    -0.01963032f, -0.01201979f, -0.00182985f, -0.00325484f, 0.01059967f, -0.03827737f, 0.02555614f, -0.04325623f, 
    0.02664810f, -0.01462088f, -0.02917125f, 0.00475794f, -0.02274107f, -0.03837324f, -0.03101118f, -0.00185233f, 
    0.01000602f, -0.03461738f, 0.02633678f, -0.04260113f, 0.01089517f, -0.03184028f, 0.01187284f, -0.03105294f, 
    -0.03763058f, 0.00095502f, -0.01796599f, -0.00614824f, -0.02346667f, -0.01307552f, -0.00032229f, 0.01864205f, 
    -0.01608386f, -0.03496275f, -0.01901300f, -0.02563857f, 0.02666517f, -0.00873079f, -0.01253844f, -0.00713253f, 
    -0.00899132f, 0.02659785f, 0.02632992f, -0.01252381f, 0.02685498f, 0.02233728f, -0.01435573f, -0.03492688f, 
    -0.01540924f, -0.03224650f, -0.02263209f, -0.01209147f, 0.02169833f, -0.02063954f, -0.03501620f, -0.00167102f, 
    -0.00105706f, -0.02450203f, -0.03674394f, -0.03885623f, 0.01991563f, 0.01926684f, 0.00864292f, -0.00881134f, 
    -0.00141107f, 0.00666484f, 0.00765753f, -0.03180976f, -0.03143170f, 0.02093276f, 0.00768676f, -0.02718003f, 
    -0.00348781f, -0.03057683f, -0.03712217f, 0.02224469f, -0.03611407f, 0.00579187f, -0.03128922f, -0.04093565f, 
    0.00354756f, 0.02225700f, 0.01098937f, 0.01645745f, 0.01729672f, 0.00853735f, -0.01470409f, 0.02396647f, 
    -0.02294506f, 0.01478979f, -0.00522433f, -0.01794104f, 0.01349939f, 0.02624572f, 0.02510470f, 0.03232830f, 
    0.00246380f, -0.03138089f, -0.02437611f, 0.01326402f, -0.00870397f, -0.01454741f, -0.02890704f, 0.01214105f, 
    -0.00490870f, 0.03298163f, -0.00530263f, -0.02965897f, -0.03486694f, 0.01211484f, 0.02995813f, 0.02949788f, 
    0.02184597f, 0.00801731f, -0.01498794f, -0.01674039f, -0.01775393f, -0.02450240f, 0.02553601f, -0.01780011f, 
    -0.00011527f, 0.02480773f, 0.01698632f, 0.00428414f, -0.02270799f, -0.01249038f, -0.02971512f, -0.01771922f, 
    0.15988207f, 0.18000793f, 0.02738716f, -0.12814702f, 0.09198283f, 0.10694862f, -0.01567301f, -0.09679513f, 
    0.07593977f, 0.03904491f, -0.00333765f, -0.03119548f, 0.11390253f, -0.19055472f, -0.13107440f, -0.12236485f, 
    0.02272426f, 0.04784476f, -0.07703712f, -0.10631692f, 0.00653078f, 0.04067056f, -0.06069627f, 0.01573490f, 
    -0.36770743f, 0.03646460f, 0.16071385f, -0.37336186f, -0.10001113f, -0.00795663f, 0.24378629f, -0.15091780f, 
    0.09736832f, -0.01774211f, 0.03286389f, -0.09644937f, -0.00983121f, 0.16116145f, -0.00136619f, 0.04116726f, 
    0.09039512f, -0.00572939f, 0.04112104f, 0.00345561f, -0.04244172f, 0.00607844f, -0.00633132f, 0.13425209f, 
    -0.09765971f, 0.08924767f, 0.01135233f, -0.13611646f, 0.11186562f, -0.07267597f, -0.07250421f, 0.07720809f, 
    0.11044939f, -0.01335143f, -0.15442604f, -0.06628933f, -0.27912697f, 0.05675923f, 0.17056158f, 0.18710265f, 
    0.04455336f, 0.08392330f, -0.09160529f, -0.14059396f, 0.00921786f, 0.05394115f, 0.04701001f, -0.08674520f, 
    -0.08717947f, 0.21000928f, 0.21711268f, 0.05998950f, 0.20604816f, 0.02380709f, 0.05493899f, 0.09199844f, 
    0.00668786f, 0.00007546f, 0.08908641f, -0.09023615f, -0.10317220f, 0.29905793f, 0.04078253f, -0.13210036f, 
    -0.06962474f, 0.06652439f, 0.00750637f, 0.06158422f, 0.03390561f, 0.04828489f, 0.04927453f, 0.08706354f, 
    -0.29309678f, 0.29859477f, -0.12436269f, -0.26060352f, 0.07060631f, 0.06057573f, -0.04145706f, 0.20340727f, 
    -0.12970932f, 0.06393789f, 0.06097025f, -0.15118752f, -0.18403512f, 0.17896327f, 0.11864192f, 0.30171880f, 
    -0.03454382f, 0.00661303f, -0.14110674f, 0.00222187f, -0.00806694f, -0.07296377f, 0.04505856f, -0.03894404f, 
    -0.25841641f, -0.02797807f, -0.00751685f, 0.16492420f, 0.10128764f, 0.09258906f, 0.08569497f, -0.00650843f, 
    0.02967149f, 0.07916554f, 0.03089603f, 0.08058405f, -0.10782463f, 0.29097989f, 0.12887110f, 0.01617952f, 
    0.03190422f, -0.01105288f, -0.00111227f, -0.01918522f, -0.00229001f, 0.04374405f, -0.06427173f, 0.06362341f, 
    -0.12139569f, -0.09035195f, 0.11033498f, 0.20410161f, 0.04043353f, 0.07233125f, 0.04098350f, 0.06568769f, 
    0.01117658f, 0.08770494f, -0.13387404f, -0.02678732f, 0.04158086f, 0.24164885f, 0.14376745f, 0.07487058f, 
    0.11241434f, -0.04249147f, 0.05496177f, -0.05685341f, -0.05688349f, -0.10434576f, 0.09838294f, -0.02019709f, 
    -0.12025478f, 0.08894631f, 0.02795605f, 0.29591274f, -0.11262765f, -0.09723028f, 0.01522909f, -0.00145047f, 
    -0.11049496f, -0.13263538f, 0.04902713f, 0.12062372f, -0.28740448f, 0.20453189f, 0.07392281f, -0.10129000f, 
    0.03785237f, 0.08321137f, -0.09532837f, -0.12771222f, -0.00843637f, 0.01832604f, -0.06600740f, -0.20465946f, 
    -0.15970311f, -0.10277896f, 0.09270984f, -0.14605856f, 0.05252314f, 0.15808408f, 0.08582736f, 0.01398967f, 
    -0.06150778f, -0.00518307f, 0.17114057f, -0.08220384f, -0.28382042f, -0.10792948f, -0.18382123f, 0.08474537f, 
    0.03886512f, 0.04093948f, 0.01789284f, 0.07576654f, 0.06745820f, 0.06352494f, -0.09511247f, 0.08788158f, 
    -0.62803757f, 0.29994521f, 0.32270429f, -0.07879309f, 0.05625556f, 0.03068091f, -0.07864912f, -0.03394017f, 
    0.10837404f, 0.07027493f, -0.08592100f, 0.01822060f, -0.04587523f, -0.04420310f, -0.21102682f, -0.11729532f, 
    0.06965826f, 0.20685743f, 0.24073480f, 0.04991361f, -0.09602494f, -0.05005479f, -0.08893100f, -0.12731728f, 
    -0.14392366f, -0.00213523f, 0.07755838f, 0.30449465f, 0.11089767f, -0.11131150f, -0.05497215f, 0.14468239f, 
    -0.03246877f, -0.06761163f, -0.01686589f, -0.00196657f, -0.35760260f, -0.04590584f, 0.14008757f, -0.00732640f, 
    0.00962084f, -0.04189510f, 0.00271298f, -0.01124564f, 0.06598909f, 0.04691853f, 0.05045296f, 0.00860235f, 
    -0.21504514f, 0.16009569f, 0.29096654f, 0.22567332f, 0.16334395f, -0.01743877f, 0.09504396f, -0.05216169f, 
    -0.00327755f, 0.02019054f, 0.00356041f, -0.02370179f, 0.10690177f, 0.43724266f, -0.01007267f, -0.19768970f, 
    0.11600047f, -0.11403493f, 0.09231476f, -0.10151651f, -0.21402802f, -0.02470658f, 0.18963027f, -0.03460150f, 
    -0.15875994f, 0.19585222f, 0.18029234f, 0.00908834f, 0.04118369f, -0.03629879f, 0.12111132f, -0.12053556f, 
    0.13407421f, -0.02213460f, -0.00740177f, -0.00778327f, 0.51846123f, -0.12236978f, 0.00003552f, -0.06779069f, 
    0.18543926f, -0.02063862f, -0.12672544f, -0.03241725f, 0.04314110f, 0.02512728f, -0.08973461f, 0.17984027f, 
    -0.01955680f, 0.23323895f, 0.10463414f, -0.01320929f, -0.04011334f, 0.14271826f, 0.06184099f, 0.04812672f, 
    0.00385637f, 0.05337527f, 0.08741862f, -0.09738141f, -0.30490911f, -0.11126008f, -0.05913433f, 0.25313726f, 
    0.11254746f, -0.03623302f, 0.02570486f, 0.05070837f, -0.02684790f, -0.09613360f, 0.01267038f, -0.01533162f, 
    0.15295322f, -0.12448245f, 0.24004047f, 0.17375110f, -0.03061976f, -0.01304461f, 0.04647497f, 0.07505509f, 
    0.06760057f, 0.02919789f, -0.05091896f, -0.02279767f, 0.25671792f, -0.13763389f, 0.16423795f, 0.11700086f, 
    -0.11555201f, 0.08463278f, -0.03710857f, 0.09301976f, 0.08355291f, 0.09449662f, 0.16208419f, -0.09417699f, 
    0.03278592f, -0.25008014f, -0.11603040f, -0.19348770f, -0.03592985f, -0.01648135f, 0.03942253f, -0.12778388f, 
    0.00271379f, -0.03811528f, -0.10357872f, 0.01645318f, 0.15490049f, -0.19226150f, 0.11431198f, 0.14122945f, 
    0.07888253f, 0.04381575f, -0.00370674f, 0.03717216f, -0.04117191f, -0.03370309f, 0.04708894f, 0.05636529f, 
    -0.47836974f, 0.18784922f, -0.05019496f, 0.10563672f, -0.03737807f, 0.07476130f, 0.06101782f, 0.07801089f, 
    0.05571498f, -0.10252715f, 0.11693635f, 0.09004271f, -0.06237374f, 0.03805135f, -0.02009802f, 0.01643529f, 
    0.08201171f, 0.04576851f, 0.13015473f, 0.10316750f, 0.06682656f, -0.10994665f, 0.04361484f, 0.05887690f, 
    -0.11012394f, 0.06408051f, 0.21840429f, -0.12633327f, -0.01468643f, -0.03783240f, -0.15308483f, 0.00588832f, 
    -0.06962080f, 0.00394115f, 0.06343214f, 0.04750009f, 0.14699470f, -0.09506746f, 0.02217109f, 0.15135466f, 
    0.04689573f, 0.00990013f, 0.05270745f, -0.10346442f, 0.13383219f, 0.05235597f, 0.07665481f, 0.00422588f, 
    -0.28775570f, -0.07267042f, 0.14363535f, -0.17561980f, -0.02706018f, 0.10075080f, 0.05860592f, -0.01764787f, 
    0.11041511f, -0.03571049f, -0.01989343f, 0.08000668f, 0.30053318f, -0.13878928f, 0.00027961f, -0.15593247f, 
    0.07788668f, -0.03186667f, -0.05223163f, -0.00131839f, 0.05303954f, -0.16896321f, -0.09223841f, -0.07870140f, 
    -0.12931107f, -0.10300547f, 0.19242617f, -0.19438320f, 0.06079515f, -0.03377988f, -0.00524753f, 0.12646741f, 
    -0.02769238f, 0.17661828f, -0.00500882f, 0.09395318f, -0.10042205f, 0.03739563f, 0.14837246f, 0.03091761f, 
    -0.10011677f, 0.06278992f, 0.03344162f, -0.04043216f, 0.00823039f, -0.02774859f, -0.04211918f, -0.04442058f, 
    -0.39601487f, -0.02823641f, 0.26617339f, -0.09758183f, 0.07347336f, -0.08522809f, 0.03096046f, -0.09413120f, 
    0.01157010f, 0.09046236f, -0.08357837f, 0.01629837f, 0.20193650f, 0.03641541f, 0.08108232f, 0.40796709f, 
    0.10837122f, 0.17656425f, 0.03127715f, 0.10816187f, -0.08516043f, 0.20896927f, -0.02804926f, 0.17867254f, 
    0.53972554f, 0.02745715f, 0.06673063f, 0.20847791f, 0.08642656f, 0.07715539f, -0.02463154f, -0.00792456f, 
    0.01921577f, -0.05622909f, 0.09325846f, 0.01820370f, -0.07814560f, -0.12568298f, 0.18458602f, 0.22037750f, 
    0.05131254f, -0.07372455f, -0.04336728f, -0.04073299f, 0.09046992f, -0.09182022f, -0.20303594f, 0.01243711f, 
    0.06885445f, 0.14949366f, 0.00340257f, -0.22762954f, 0.04085256f, 0.03979663f, 0.09939051f, 0.03520657f, 
    0.04583488f, -0.08402151f, 0.07548977f, 0.04056772f, -0.34757736f, 0.23555492f, 0.05903053f, 0.06091385f, 
    -0.09348673f, 0.02157589f, 0.01389768f, -0.02951751f, 0.14130972f, -0.18057188f, 0.08261488f, -0.04167824f, 
    0.00544397f, 0.01407978f, 0.13137095f, 0.31357393f, 0.21740802f, 0.12427696f, 0.08999852f, 0.13023227f, 
    -0.03189836f, -0.09053400f, 0.09900539f, -0.04073374f, -0.06511320f, -0.29183647f, 0.16502164f, 0.02374942f, 
    0.02118457f, -0.11707415f, -0.04614035f, -0.01509453f, 0.09165142f, 0.01456467f, 0.15393829f, -0.02481046f, 
    0.03823162f, -0.11646682f, 0.06551075f, 0.28596270f, 0.08861508f, 0.08520852f, -0.04287856f, -0.00865148f, 
    -0.04104166f, -0.06964730f, -0.08658107f, 0.06684029f, 0.00775764f, -0.04522349f, 0.11462460f, 0.03130595f, 
    0.06983654f, 0.18784410f, -0.08278589f, -0.08229830f, -0.08212023f, -0.04671140f, 0.06432223f, -0.05260137f, 
    0.11337315f, -0.13186684f, 0.08386418f, 0.37849423f, 0.14382701f, 0.03606084f, -0.07496472f, 0.09776343f, 
    -0.01415702f, -0.06372137f, -0.00881166f, 0.03704282f, -0.13035613f, 0.13430557f, -0.07719430f, -0.13151720f, 
    0.05551836f, 0.06070828f, -0.02467618f, -0.04133816f, 0.02863600f, -0.09915235f, 0.02066420f, -0.12729198f, 
    -0.16106276f, -0.05932274f, 0.23713015f, -0.03466433f, 0.03069616f, -0.13937847f, 0.11194571f, 0.19523419f, 
    0.00323398f, 0.02715373f, 0.08842595f, 0.08576719f, -0.12018486f, -0.10764580f, -0.01389641f, 0.01706982f, 
    0.08377358f, 0.10374919f, -0.02475637f, -0.09639877f, 0.09091444f, -0.00165653f, -0.04850329f, 0.08379472f, 
    -0.04330456f, -0.04638999f, 0.05125546f, -0.07996032f, 0.03374373f, 0.12132232f, 0.05563146f, 0.02872128f, 
    0.03429696f, 0.07696062f, 0.05821813f, 0.02380913f, -0.10348244f, -0.13995399f, -0.04382177f, 0.13801956f, 
    -0.10451227f, 0.02136507f, -0.02344929f, -0.11753751f, 0.09500615f, 0.12394927f, 0.00661741f, 0.06770259f, 
    0.52517724f, -0.13848615f, -0.05847583f, 0.08302385f, 0.06018655f, 0.10639865f, -0.11622815f, -0.11942214f, 
    -0.03364623f, -0.06683641f, 0.03202083f, 0.08989999f, -0.14034124f, 0.05260798f, -0.16173960f, 0.02313393f, 
    0.05395044f, 0.00960694f, -0.08720102f, 0.02237284f, 0.02052666f, -0.02995560f, 0.05001024f, 0.07401752f, 
    -0.38163790f, -0.09496177f, 0.10928433f, 0.20088194f, -0.13490838f, -0.09276714f, -0.17084935f, -0.00728426f, 
    0.05866145f, 0.04822040f, -0.10760617f, 0.07312220f, -0.18941587f, 0.04101288f, -0.03960573f, -0.23078366f, 
    -0.05618057f, -0.12131104f, 0.04450060f, -0.10045832f, -0.14157130f, -0.16264687f, -0.04070132f, 0.06615420f, 
    0.03355702f, -0.11629589f, -0.11384045f, 0.35847789f, -0.03684753f, 0.00793801f, 0.01938187f, 0.13575481f, 
    -0.14901192f, 0.09463943f, -0.07051821f, 0.01833445f, 0.12139590f, 0.08719795f, -0.14322524f, 0.10835807f, 
    -0.12721778f, 0.01979077f, 0.05175625f, -0.11679499f, 0.09053922f, -0.06744273f, 0.06548768f, 0.14025541f, 
    0.18829301f, 0.03235048f, 0.17950979f, -0.07681678f, 0.11784335f, -0.08973386f, -0.19083585f, -0.01234954f, 
    0.04144017f, 0.00214984f, -0.05229169f, 0.01422411f, 0.09927516f, 0.10257105f, 0.10159448f, 0.09576674f, 
    -0.02934176f, -0.08202767f, -0.07120471f, -0.04678797f, 0.00438238f, -0.08814669f, 0.02165513f, -0.01229519f, 
    0.00156628f, -0.02950137f, 0.02175526f, -0.01444551f, -0.02245202f, -0.02685846f, 0.01082929f, -0.03318958f, 
    0.02049472f, 0.02978192f, -0.00568311f, -0.00407093f, 0.01800212f, -0.01996570f, -0.00785286f, -0.00953110f, 
    -0.00566430f, 0.00448284f, -0.02631685f, 0.01676262f, -0.01221502f, -0.02658824f, -0.03509214f, 0.00756258f, 
    -0.03601734f, -0.03468754f, 0.00538974f, 0.00130177f, -0.00500099f, -0.00856189f, -0.00322685f, -0.03893381f, 
    0.01429453f, -0.01719835f, -0.02598230f, 0.02588213f, 0.01539518f, -0.00335525f, -0.02266764f, -0.01979743f, 
    0.01633490f, -0.03389961f, 0.00259290f, -0.03115633f, -0.02953661f, 0.02613340f, -0.02478629f, -0.02550490f, 
    -0.02498337f, -0.00670933f, -0.00603933f, -0.01197741f, 0.02233579f, -0.02755485f, 0.00263875f, 0.00197699f, 
    0.01428831f, -0.02753560f, 0.01527263f, -0.02525460f, -0.02777157f, 0.00934706f, -0.03832465f, -0.00548386f, 
    -0.01377340f, -0.00154819f, -0.00184623f, 0.02565242f, -0.02439014f, 0.01313717f, -0.04179432f, -0.00898504f, 
    -0.03727511f, -0.00930583f, -0.00575112f, 0.01721707f, -0.04073215f, 0.02958281f, 0.00915416f, -0.02550443f, 
    -0.04161060f, 0.01479295f, 0.00746182f, 0.00061630f, -0.03247061f, -0.01073359f, -0.03558178f, -0.04059922f, 
    0.01211908f, -0.00401258f, 0.02697100f, -0.03912060f, -0.03101315f, 0.02471097f, -0.00278716f, -0.02858204f, 
    -0.03329441f, -0.03261251f, 0.02493645f, -0.01705611f, 0.00173680f, 0.02160895f, 0.01584273f, 0.00787544f, 
    0.00859756f, -0.01032811f, -0.03569232f, 0.00001338f, 0.01697362f, 0.02497962f, 0.02295638f, -0.00789886f, 
    0.02204029f, -0.03549568f, -0.01317494f, 0.01531796f, -0.02678929f, 0.01190698f, -0.00567193f, -0.03724660f, 
    -0.03941362f, -0.01961725f, -0.02588808f, -0.03063974f, -0.02267754f, -0.01664812f, 0.00621463f, -0.01012700f, 
    -0.02739491f, -0.00436214f, -0.00975805f, -0.03563199f, -0.00856344f, -0.03638429f, -0.00713482f, -0.02003414f, 
    -0.03606204f, 0.01470482f, -0.00031142f, 0.00035532f, -0.01612874f, 0.01791136f, 0.01802134f, -0.02610242f, 
    -0.03933776f, -0.02126031f, 0.00846147f, 0.02577363f, -0.02191240f, -0.01109391f, 0.02239432f, -0.00277765f, 
    0.01909326f, 0.01166505f, -0.01345178f, 0.02221173f, -0.02043003f, -0.00561089f, 0.02661657f, -0.01684410f, 
    -0.02344154f, -0.02147359f, -0.00682844f, 0.02431285f, -0.02297938f, -0.00173374f, 0.00953361f, -0.01302602f, 
    0.01392852f, 0.03448198f, 0.00204519f, -0.00827865f, -0.01245419f, 0.03000242f, 0.01790441f, -0.00484801f, 
    0.02968605f, 0.00513012f, 0.02800107f, -0.01929421f, 0.02585060f, 0.01250123f, 0.03195665f, 0.00584310f, 
    -0.03401028f, 0.01891511f, 0.02992437f, 0.00810662f, -0.02617973f, -0.03316427f, -0.02440013f, -0.00103955f, 
    0.01571020f, -0.03489410f, -0.01227599f, 0.00821340f, -0.00640293f, -0.00434054f, 0.02369784f, -0.01224096f, 
    0.02717098f, -0.00729080f, -0.01335276f, -0.00609681f, -0.03828914f, -0.01922359f, -0.03286917f, -0.00822553f, 
    -0.01166429f, -0.03451111f, 0.00695132f, -0.03865872f, -0.01921995f, -0.02774587f, -0.01301212f, 0.01862048f, 
    0.01201177f, -0.02723176f, 0.01960775f, -0.00810402f, 0.02741323f, -0.00367159f, 0.02280753f, -0.00478158f, 
    -0.02162745f, 0.00746190f, 0.02114813f, 0.01714734f, -0.00462756f, 0.00583644f, -0.00466506f, -0.00401114f, 
    -0.00153414f, -0.02866340f, 0.01566954f, -0.01686417f, -0.02828641f, 0.01431892f, -0.02032489f, 0.02336814f, 
    -0.02880642f, -0.03486541f, -0.02058582f, -0.01203433f, -0.03016933f, 0.01034784f, 0.01630015f, 0.02567070f, 
    -0.00749917f, 0.01262181f, 0.00047361f, 0.01757443f, -0.02328698f, -0.03736673f, 0.00790600f, -0.02292483f, 
    -0.01136127f, 0.02625574f, 0.02033397f, 0.00233851f, 0.00661743f, -0.02791076f, 0.02286163f, 0.00253939f, 
    -0.00866493f, 0.02227004f, -0.00960123f, 0.02790731f, 0.02135333f, -0.01799903f, 0.02553748f, 0.02893608f, 
    -0.02135178f, 0.00124450f, -0.00831787f, 0.01076142f, -0.03715964f, -0.01795097f, -0.02736851f, -0.00420517f, 
    0.01772956f, -0.03538737f, 0.00320973f, 0.02040478f, -0.03223684f, -0.01594275f, -0.03755983f, 0.01522096f, 
    -0.01562448f, -0.01097485f, 0.01343289f, 0.01175278f, -0.01323516f, 0.02350049f, -0.02341217f, 0.00093550f, 
    0.01043185f, 0.01234799f, 0.00521684f, 0.00793793f, -0.02568447f, 0.02988478f, 0.02516973f, -0.01286978f, 
    0.00448235f, -0.03345456f, 0.00581698f, -0.00900135f, -0.01041012f, 0.02136822f, -0.01226434f, 0.01865464f, 
    0.01624021f, 0.01801345f, 0.01896207f, -0.02438477f, -0.00681564f, 0.00263809f, -0.00369328f, -0.03015910f, 
    -0.03540658f, 0.00246364f, -0.03954763f, 0.00700135f, -0.02526134f, -0.02937158f, 0.02885867f, -0.01407916f, 
    -0.00664387f, 0.02311959f, -0.01139535f, 0.01367951f, -0.03821273f, -0.04143043f, 0.01807380f, -0.01289258f, 
    0.02802353f, 0.01114654f, -0.03855747f, -0.01508203f, -0.03547351f, -0.03976690f, -0.00706405f, -0.01578237f, 
    -0.01461822f, -0.01072057f, 0.01720358f, -0.00010100f, -0.00207925f, 0.00409895f, -0.00950311f, 0.01707151f, 
    0.01578571f, 0.02655690f, -0.00313727f, -0.02359830f, -0.00187974f, -0.00339890f, 0.03607348f, -0.00332669f, 
    -0.00004942f, -0.02695071f, 0.02400064f, 0.01423204f, 0.01607824f, -0.02362522f, 0.02321055f, 0.01914247f, 
    0.01847562f, -0.02251108f, 0.01137505f, 0.00211515f, 0.00530138f, 0.02050205f, -0.03989964f, 0.02481577f, 
    -0.00820498f, 0.02702946f, -0.00603751f, -0.03478100f, 0.02442217f, -0.01564971f, -0.00542614f, -0.03597618f, 
    -0.03291972f, -0.03957815f, -0.00049454f, -0.01765436f, -0.00366277f, 0.00442034f, -0.02030777f, -0.03176708f, 
    -0.01735399f, -0.00594028f, -0.02952320f, -0.03488508f, -0.03540783f, -0.00478054f, -0.02618865f, -0.04193325f, 
    -0.00426051f, -0.01877469f, -0.02732733f, -0.03382580f, 0.00354151f, -0.00464330f, -0.01816707f, 0.00495129f, 
    0.01902491f, -0.01002968f, -0.02932381f, 0.01413983f, -0.02204539f, -0.03811550f, -0.03930956f, -0.01331780f, 
    0.02028174f, 0.02036306f, -0.01075562f, 0.00904538f, 0.02897999f, 0.02561401f, -0.03210755f, -0.01558584f, 
    -0.00879198f, -0.00130995f, 0.00354436f, 0.00364533f, 0.02742109f, -0.02713777f, -0.04006804f, -0.02735564f, 
    -0.02837308f, -0.01500362f, 0.00947159f, -0.00972997f, 0.00353787f, 0.00320031f, 0.01619738f, 0.00301686f, 
    -0.02508988f, 0.00743521f, -0.00959404f, 0.01434985f, -0.03271419f, 0.02352117f, -0.02615683f, -0.01086301f, 
    0.00934398f, -0.00012020f, -0.03769373f, -0.02282115f, -0.03635385f, -0.02537066f, -0.00763541f, -0.04168576f, 
    -0.01434519f, -0.02614556f, 0.01997296f, -0.02276875f, 0.01138932f, -0.02173737f, 0.02354663f, -0.00464459f, 
    -0.00050832f, -0.03201829f, -0.00298556f, -0.04089548f, -0.03898462f, -0.01221816f, 0.00374052f, 0.00257185f, 
    -0.02498501f, -0.00672627f, -0.04179554f, 0.00448261f, -0.02391197f, -0.01657514f, 0.00857703f, -0.00007903f, 
    -0.00845699f, -0.03963881f, -0.04149291f, 0.02960379f, 0.01771376f, -0.01665832f, 0.00957195f, -0.04172254f, 
    -0.01162152f, -0.02182115f, 0.01884521f, -0.03884277f, 0.00732809f, -0.01127592f, -0.00521484f, -0.00239497f, 
    -0.03471216f, -0.03100385f, 0.00947746f, -0.03996997f, -0.03303219f, 0.01294713f, 0.00936222f, -0.00698832f, 
    0.01665141f, -0.02739197f, 0.02833600f, -0.03266329f, 0.01443527f, -0.03655806f, 0.01152311f, -0.03144171f, 
    -0.00717288f, -0.01277932f, 0.02046261f, 0.02742581f, -0.02039271f, -0.02679711f, 0.02432246f, -0.03618293f, 
    -0.00847784f, -0.02864700f, 0.00924969f, 0.02608192f, 0.00706928f, -0.03680208f, -0.02662101f, 0.02320853f, 
    -0.02107632f, 0.02484491f, 0.01708001f, -0.01058468f, -0.00257494f, 0.02342379f, -0.03745047f, -0.00662794f, 
    -0.00107043f, -0.04058687f, -0.02665227f, -0.03108231f, 0.00585765f, -0.01718752f, -0.00468143f, 0.02023754f, 
    -0.00133775f, 0.01153719f, 0.00672343f, -0.00565357f, -0.01442917f, -0.01916567f, 0.00288852f, -0.02865184f, 
    0.00976419f, -0.01307207f, 0.02184534f, -0.01727101f, -0.04064735f, -0.00739485f, 0.00534987f, 0.00820493f, 
    0.01843461f, -0.04192797f, -0.01144823f, -0.03225052f, -0.00252032f, -0.01194287f, -0.01814989f, -0.03211951f, 
    -0.00646625f, -0.00446281f, 0.02143607f, -0.02719779f, 0.01274085f, -0.02125345f, -0.01764862f, 0.00707919f, 
    -0.01974693f, -0.00012726f, 0.02145657f, 0.02551037f, -0.03651221f, -0.02205055f, -0.01285893f, 0.00134311f, 
    0.00972826f, -0.03653470f, -0.00418985f, 0.01854516f, -0.00725267f, -0.00411064f, 0.00538938f, 0.02449832f, 
    -0.03803332f, -0.00860276f, -0.02654534f, 0.00994219f, -0.00843623f, 0.01304455f, -0.00193747f, -0.03928370f, 
    -0.02912508f, -0.03877215f, 0.01430820f, 0.01173810f, -0.02114655f, -0.00175374f, -0.03269631f, -0.02276034f, 
    0.02199828f, 0.00949277f, -0.00890288f, -0.02432290f, -0.03437176f, -0.02910955f, 0.01178137f, -0.00090358f, 
    -0.00585678f, -0.03463235f, -0.02574304f, -0.02834913f, 0.01299304f, -0.03222523f, -0.02810023f, -0.03092312f, 
    -0.02865484f, 0.02114871f, -0.02600011f, -0.00765500f, 0.00158608f, -0.01298966f, 0.02236647f, -0.01185533f, 
    0.02824331f, 0.03489814f, -0.02028215f, 0.01793564f, -0.01112902f, -0.03023714f, 0.00328735f, 0.02737674f, 
    -0.02836991f, -0.00838202f, 0.02769210f, 0.00685861f, 0.01494217f, -0.02813327f, -0.00533535f, -0.00326226f, 
    -0.01401574f, -0.01362900f, -0.00776140f, 0.00107524f, 0.02620286f, -0.03904864f, -0.01154836f, -0.03116026f, 
    -0.00312707f, 0.02034513f, -0.03699917f, -0.03522946f, -0.02675308f, -0.03003299f, -0.02585992f, -0.00773421f, 
    -0.01187529f, -0.00213437f, -0.01392356f, -0.01483406f, -0.02142587f, -0.03514501f, 0.01516795f, -0.02396699f, 
    0.01372174f, 0.01079217f, -0.00822581f, -0.04143581f, 0.02757776f, -0.00035523f, 0.01137148f, -0.03495627f, 
    0.01485033f, 0.00193178f, -0.01793235f, -0.03023437f, -0.02438613f, -0.02587703f, 0.00520360f, 0.00715914f, 
    0.02622500f, -0.01975728f, -0.03162192f, -0.01339472f, 0.01609351f, -0.04184718f, -0.01838123f, 0.02328161f, 
    -0.02215392f, 0.01909642f, 0.02066215f, -0.00344748f, -0.02056022f, 0.01862967f, -0.04101899f, 0.01230943f, 
    -0.03696533f, -0.00533239f, 0.00559836f, -0.00705356f, 0.01844304f, -0.00433629f, -0.01969381f, -0.02044512f, 
    -0.02971783f, 0.01549071f, -0.04060540f, -0.03798497f, 0.02649237f, 0.01803642f, 0.00807789f, -0.00001468f, 
    0.00097998f, -0.02081423f, -0.03349516f, -0.03329583f, 0.02740752f, -0.00687949f, -0.03905694f, 0.00116409f, 
    0.02857362f, 0.01775735f, 0.02512905f, 0.02388701f, 0.01835329f, 0.02831657f, -0.02699525f, 0.02637151f, 
    0.00293220f, -0.00204155f, -0.03784206f, -0.03308607f, 0.00580568f, -0.02198068f, -0.00409150f, -0.00937316f, 
    -0.01201002f, -0.01871373f, -0.03454227f, -0.03163692f, -0.00440835f, 0.00132719f, -0.03193097f, 0.01956873f, 
    0.00568217f, 0.00761599f, 0.00814183f, 0.00094116f, 0.02949610f, -0.01744059f, -0.00382180f, 0.01911559f, 
    -0.03848735f, 0.01348557f, 0.00654485f, -0.01753117f, -0.03174973f, -0.01753616f, -0.02367627f, 0.02352587f, 
    -0.02764728f, 0.02899179f, -0.05751059f, -0.27913988f, 0.02335610f, 0.02396378f, 0.01596693f, -0.17342606f, 
    0.09202042f, -0.09127773f, -0.01308321f, 0.09519204f, 0.48775676f, 0.03781838f, 0.07115135f, -0.09007278f, 
    0.02567344f, -0.09262934f, 0.05679012f, 0.08142371f, -0.01705817f, -0.06352780f, 0.11405019f, -0.03554639f, 
    0.32250899f, -0.09287629f, -0.05159430f, -0.13986216f, 0.15779492f, 0.05236782f, -0.00205029f, -0.00443228f, 
    -0.16673833f, 0.07342620f, 0.09987465f, -0.02458467f, 0.28457284f, 0.00757912f, -0.00804811f, 0.32025638f, 
    0.02761549f, -0.05172121f, -0.02244497f, 0.04048965f, -0.06406426f, -0.07427682f, -0.00543814f, -0.10284993f, 
    0.10436957f, 0.12969598f, 0.01586726f, 0.05030920f, -0.07420225f, 0.22182773f, 0.07018654f, -0.11864959f, 
    0.02596360f, -0.08362842f, -0.02745253f, -0.06601319f, 0.22109151f, -0.01671537f, 0.20095162f, 0.21705993f, 
    0.00904741f, 0.06119866f, 0.10801360f, -0.05211580f, 0.05005031f, -0.02551521f, 0.07456803f, -0.09267274f, 
    -0.42060727f, -0.27364570f, 0.03346929f, 0.04103252f, 0.23539044f, -0.11892889f, 0.02732343f, 0.01841849f, 
    0.09607106f, 0.10706293f, -0.04638015f, 0.07582820f, 0.02895134f, -0.07229423f, 0.16027270f, 0.17691447f, 
    -0.06005926f, 0.01062270f, 0.07841931f, 0.04581723f, 0.10401912f, -0.02000298f, 0.09983145f, -0.13883047f, 
    -0.30414823f, 0.23945598f, -0.04062400f, 0.34312713f, -0.00002879f, 0.11489364f, -0.08037250f, -0.00230840f, 
    -0.10544815f, 0.02651421f, 0.03907914f, 0.08357598f, -0.03008894f, -0.09474966f, -0.14009067f, -0.29433963f, 
    0.08240090f, -0.01045077f, -0.00193838f, 0.03209725f, -0.07744010f, 0.00801748f, 0.17148666f, -0.11661636f, 
    0.23008132f, 0.00278212f, -0.07062016f, 0.10688488f, -0.09133585f, 0.09417337f, 0.06093127f, 0.00171044f, 
    0.20817111f, -0.04030128f, -0.02883042f, -0.00160081f, 0.21680515f, 0.10010885f, 0.06284086f, 0.10779834f, 
    -0.03553450f, -0.00674141f, 0.03745581f, -0.00184708f, -0.07766350f, 0.01688740f, 0.03051507f, -0.10833682f, 
    0.07065579f, -0.06736873f, 0.15180679f, -0.01582540f, 0.07702150f, 0.05173565f, -0.07033777f, 0.02339096f, 
    -0.00645554f, 0.02550950f, 0.16096579f, -0.01636667f, -0.13654114f, -0.09386646f, 0.28591990f, -0.22291450f, 
    -0.11866298f, -0.10879289f, 0.02619378f, -0.03075137f, 0.01369634f, -0.10855144f, -0.02480954f, 0.07323706f, 
    -0.01210605f, -0.14739460f, -0.00371162f, -0.29391485f, 0.05101901f, -0.09441692f, 0.01702862f, -0.04772467f, 
    -0.06376687f, -0.00127123f, -0.01499798f, -0.04989056f, 0.29277802f, -0.10511442f, 0.07669808f, -0.02145141f, 
    0.05507969f, 0.07235687f, 0.06756832f, -0.07371543f, -0.16422233f, -0.04928480f, 0.01364075f, 0.13815856f, 
    0.20686886f, 0.02351204f, -0.12348543f, 0.15731202f, 0.00802384f, -0.05557618f, 0.06596971f, 0.02130161f, 
    0.07544806f, -0.00429463f, -0.13428353f, -0.06893125f, -0.07677867f, -0.09981228f, 0.17560303f, 0.14092548f, 
    0.08299208f, -0.05707472f, 0.05261390f, 0.01332518f, 0.04599154f, -0.10557249f, 0.07397813f, -0.03534110f, 
    0.28498062f, -0.15325837f, -0.11012483f, 0.04955580f, -0.03084044f, 0.02114456f, -0.03320617f, -0.06907993f, 
    -0.02588625f, 0.04634839f, -0.11520332f, 0.09992123f, 0.02934198f, -0.06300817f, -0.12687366f, -0.00108904f, 
    0.05683961f, 0.08010725f, -0.02777313f, -0.06187388f, 0.02314208f, -0.08303531f, 0.03953297f, -0.03157699f, 
    -0.00794518f, 0.13801296f, 0.05548489f, -0.04150335f, -0.01189266f, 0.15693952f, 0.11203888f, -0.02509564f, 
    -0.01488684f, -0.04921072f, -0.07314505f, 0.00548519f, 0.40978396f, 0.08703158f, 0.16569155f, -0.17866255f, 
    -0.15937112f, -0.17245583f, 0.07923794f, -0.02114307f, -0.01432332f, 0.03542265f, 0.00213303f, -0.00231767f, 
    0.08575320f, 0.14070687f, 0.21863534f, 0.14089055f, 0.04448379f, -0.03781804f, 0.07506904f, 0.10866357f, 
    -0.02188991f, 0.08118266f, -0.03837781f, -0.07689934f, -0.02172009f, 0.00556241f, -0.22355969f, 0.28684059f, 
    0.15227903f, 0.12095139f, -0.01210025f, 0.02597780f, -0.04128224f, -0.01792620f, -0.05026080f, 0.04952589f, 
    0.18965653f, 0.09957593f, 0.09621448f, 0.19795844f, 0.09619766f, -0.00934640f, -0.00733887f, 0.26054379f, 
    0.09881639f, 0.02783187f, 0.00484893f, 0.07384595f, 0.19422485f, 0.03465658f, 0.18162292f, -0.18892165f, 
    0.07640050f, -0.02581265f, -0.15889646f, 0.05658655f, -0.07400683f, -0.04882730f, 0.10677577f, 0.00511814f, 
    0.12336327f, -0.14765860f, 0.04517038f, -0.01614074f, 0.03371727f, -0.02254152f, 0.02696307f, 0.07170540f, 
    -0.11985508f, -0.00552822f, 0.04382342f, 0.15592168f, 0.44956705f, 0.25319526f, 0.09579014f, 0.29280034f, 
    0.03205492f, -0.01780689f, 0.04395848f, 0.13799791f, 0.09710935f, -0.07544920f, 0.10921865f, 0.03916429f, 
    -0.06771049f, -0.11475950f, 0.04293929f, -0.06065651f, -0.00960638f, 0.04589659f, -0.16721937f, -0.00222785f, 
    0.04549145f, -0.03964924f, 0.05428536f, -0.01766934f, -0.16942888f, -0.17966215f, -0.14150926f, -0.01052904f, 
    -0.03325609f, 0.02245679f, 0.04124403f, -0.10809462f, 0.03590536f, -0.08500268f, 0.06163624f, 0.14475337f, 
    0.02611044f, -0.06130018f, 0.00659810f, -0.19001083f, 0.00699217f, -0.03249760f, 0.02081687f, -0.01097692f, 
    0.05357632f, -0.07388741f, -0.00010544f, -0.07004754f, 0.22246771f, 0.16373619f, 0.10750283f, -0.28613618f, 
    -0.02424018f, -0.05855490f, 0.12974565f, 0.02536384f, 0.04478324f, 0.05884309f, 0.07444136f, 0.05434708f, 
    -0.00618063f, -0.10633517f, 0.07856496f, 0.00335399f, 0.01722976f, 0.05184760f, -0.04115092f, 0.00754197f, 
    -0.03867186f, -0.07741940f, -0.01331564f, -0.01242293f, 0.13556193f, 0.06970217f, -0.19178145f, 0.04564320f, 
    0.10282909f, -0.01786945f, -0.22734888f, 0.02556851f, -0.02471358f, -0.03400646f, 0.04871667f, 0.07055328f, 
    0.07443985f, -0.14113654f, 0.11963639f, -0.34776893f, 0.07032867f, 0.00987651f, -0.05164322f, -0.01401349f, 
    -0.01685547f, -0.04543671f, 0.00130832f, 0.00033907f, -0.08398267f, 0.00410726f, 0.13520496f, 0.16320142f, 
    0.04843150f, 0.10024095f, -0.07770362f, -0.10326510f, -0.13171108f, -0.04068336f, 0.01636005f, 0.05161349f, 
    0.35644922f, 0.02893063f, 0.13024995f, -0.18710591f, -0.08821408f, -0.19497032f, 0.05516041f, 0.00305521f, 
    -0.07036319f, 0.03584851f, 0.02307379f, 0.00719955f, 0.10805421f, -0.11370690f, 0.12267387f, -0.24843355f, 
    -0.03152812f, 0.05257069f, 0.03264277f, -0.01054364f, 0.07549429f, 0.07975492f, -0.05768572f, 0.04616764f, 
    -0.00822089f, 0.02599937f, -0.17986739f, 0.18110210f, 0.00979953f, -0.01147991f, -0.14871234f, 0.03890672f, 
    -0.08409058f, -0.07613734f, 0.05192756f, -0.03302706f, 0.17836560f, 0.03268887f, 0.14115496f, -0.28528982f, 
    -0.01341133f, -0.00513936f, 0.10549136f, -0.00536642f, -0.12183168f, 0.09259622f, 0.06853464f, 0.03448037f, 
    0.04169106f, -0.11588839f, 0.02309984f, 0.09500475f, -0.02791740f, -0.14104407f, -0.08764357f, -0.01036035f, 
    -0.06014293f, -0.06117314f, -0.01484507f, -0.04981403f, 0.02992868f, 0.00380654f, -0.07649416f, -0.01977618f, 
    -0.05196830f, -0.02234947f, 0.02785787f, 0.11658061f, 0.03002909f, -0.00883937f, 0.01341519f, 0.03381554f, 
    0.16139638f, 0.08187563f, 0.01303620f, -0.12566632f, -0.04547741f, 0.04101467f, 0.04991472f, 0.23723559f, 
    0.01695012f, -0.02263635f, 0.02475451f, -0.17434651f, -0.05638587f, -0.23405904f, -0.15352605f, -0.23795876f, 
    0.09865648f, 0.11320835f, 0.05415994f, -0.07210454f, -0.05641089f, 0.09381142f, 0.09022858f, -0.06605429f, 
    0.00788442f, 0.09330804f, -0.11922543f, 0.04388797f, 0.03195859f, 0.20095368f, 0.02776960f, -0.03015879f, 
    0.03679379f, 0.05479530f, -0.13458799f, 0.05559252f, 0.22960520f, 0.21259525f, -0.02056838f, 0.21911451f, 
    0.16013546f, 0.01199790f, 0.00572785f, 0.17231219f, -0.20406967f, 0.00142938f, 0.05649145f, 0.03544163f, 
    -0.03286223f, 0.03148288f, 0.27219674f, 0.07932610f, -0.00695546f, 0.04794578f, -0.05605060f, 0.03970039f, 
    -0.03017370f, 0.12015174f, -0.09986851f, 0.00777357f, -0.02343604f, -0.20073766f, -0.12871948f, 0.15308343f, 
    0.04268578f, -0.02149956f, -0.07502846f, -0.01227528f, 0.04403531f, 0.09943724f, 0.06075034f, -0.06760389f, 
    -0.07645680f, 0.14829363f, 0.21584277f, 0.15685588f, 0.04786886f, -0.07443864f, 0.14321651f, 0.16535865f, 
    0.05433102f, -0.04685614f, 0.09138382f, -0.19636647f, 0.06390808f, 0.06961881f, -0.22580303f, -0.16384640f, 
    0.01999748f, -0.09302659f, 0.02382238f, 0.08493663f, 0.03587332f, -0.00503384f, -0.20488013f, -0.04115589f, 
    0.14182538f, -0.09450958f, 0.10897516f, 0.22548920f, 0.22755960f, 0.05855272f, 0.12368195f, 0.07832261f, 
    -0.06572094f, 0.07223213f, -0.00602671f, 0.09619024f, 0.23246023f, 0.14534801f, 0.05191249f, -0.00332483f, 
    0.00956442f, 0.00361425f, -0.00764522f, -0.05918160f, -0.17483285f, 0.07054708f, -0.04302145f, -0.08593881f, 
    -0.00261929f, 0.23605621f, 0.28238228f, 0.13578932f, 0.06385961f, 0.05141773f, 0.16498965f, -0.01166279f, 
    -0.09755480f, 0.03901519f, -0.08347832f, 0.01868306f, -0.05714293f, -0.11216082f, -0.09695528f, 0.42654127f, 
    -0.10063789f, 0.06868245f, -0.03791021f, 0.01369783f, -0.04966625f, -0.05592829f, -0.09315109f, -0.15225123f, 
    0.38359201f, -0.01047872f, 0.04921595f, -0.15787798f, -0.01930900f, 0.01550424f, 0.03024703f, 0.02363565f, 
    0.04010609f, 0.03051853f, 0.01287887f, 0.01731691f, -0.03915812f, -0.22988887f, 0.09228180f, 0.19361550f, 
    0.02290181f, 0.03050208f, -0.10821807f, 0.08113474f, -0.00137700f, -0.10763159f, 0.00287526f, -0.06621751f, 
    0.01840354f, 0.13998002f, -0.03926962f, -0.09161079f, -0.11567353f, 0.06432326f, 0.01627402f, 0.06266744f, 
    0.01533066f, -0.02292688f, 0.01455674f, -0.12663844f, 0.16914791f, 0.28901985f, 0.13584560f, 0.15099348f, 
    0.02289120f, -0.03656484f, -0.05443030f, 0.21906933f, -0.01948877f, -0.02708360f, 0.04072115f, -0.08415914f, 
    -0.09370863f, -0.14022756f, 0.10550465f, 0.16048019f, -0.02934127f, 0.02401499f, 0.02777956f, -0.11324930f, 
    -0.01248751f, -0.03558169f, 0.11754529f, -0.06770205f, -0.07230316f, -0.08044684f, -0.11516324f, 0.21265809f, 
    -0.05642331f, -0.07981750f, -0.06772027f, -0.08095452f, -0.03212140f, 0.06548338f, -0.04907529f, -0.01819310f, 
    0.32647955f, -0.04855533f, -0.00736585f, 0.10481942f, -0.08810253f, -0.00422045f, -0.12315772f, 0.09029331f, 
    -0.05177173f, -0.01284027f, 0.03671081f, 0.04694331f, -0.15132880f, -0.18643224f, -0.10418849f, -0.09239367f, 
    0.14400589f, -0.02904015f, -0.01358293f, 0.13180381f, 0.00823767f, 0.27056283f, -0.10429633f, -0.10861326f, 
    -0.08199894f, 0.07286557f, 0.17586119f, -0.17404953f, 0.01607850f, 0.05043138f, 0.00534958f, 0.10186991f, 
    0.03954366f, 0.10798684f, -0.10044074f, 0.00788788f, 0.30452025f, 0.09355941f, -0.28171158f, 0.22809608f, 
    0.08300015f, 0.12754427f, 0.02918765f, -0.01449626f, -0.09784862f, 0.09809265f, 0.04092475f, -0.00080490f, 
    -0.02150177f, 0.01171124f, -0.01338992f, -0.00273792f, 0.02900420f, 0.02377072f, -0.02943167f, 0.01461074f, 
    0.01084099f, 0.01807947f, -0.03032336f, -0.03665048f, 0.02640900f, 0.02595947f, -0.01583338f, -0.03298620f, 
    0.01704871f, -0.02581927f, 0.03387780f, 0.00382787f, -0.03148949f, -0.02648961f, 0.00477163f, 0.01709746f, 
    -0.03143132f, -0.01148360f, -0.02760553f, 0.02625399f, 0.01840032f, -0.04113286f, -0.02126652f, 0.01852582f, 
    -0.03813925f, -0.02352492f, -0.02049110f, 0.02883141f, 0.03307891f, 0.01200712f, 0.01197397f, 0.01002494f, 
    0.01197893f, -0.02518198f, 0.02877730f, 0.02186923f, 0.00513043f, -0.01661947f, 0.00883770f, 0.02014745f, 
    -0.02122332f, -0.03422655f, 0.01996672f, 0.01267950f, -0.01674224f, 0.03431657f, -0.03926225f, 0.00024473f, 
    -0.02563956f, 0.00170497f, 0.01205240f, -0.01272143f, 0.00656035f, -0.00892391f, -0.00928221f, -0.03895781f, 
    -0.00243922f, 0.00184443f, 0.01629582f, -0.03815255f, 0.01157552f, 0.02034528f, -0.01089370f, -0.02182440f, 
    -0.03997245f, 0.00784120f, 0.03037115f, 0.00664849f, 0.00372384f, 0.00499863f, -0.00766706f, 0.00874127f, 
    0.01667370f, -0.02839755f, 0.02971495f, -0.01569094f, -0.02609682f, 0.01446675f, -0.03053793f, 0.02191569f, 
    -0.00558991f, 0.01163493f, 0.01689197f, -0.00462395f, -0.01245812f, -0.03012601f, -0.02033043f, 0.00591605f, 
    0.01651729f, -0.03479655f, -0.03821830f, 0.01621996f, -0.01013676f, 0.00935290f, 0.01934548f, 0.02616711f, 
    -0.02502069f, -0.02078859f, 0.01668739f, -0.03580251f, 0.02826765f, 0.01323584f, -0.01015934f, -0.03549281f, 
    0.01954632f, -0.03882170f, -0.00802701f, -0.02175924f, 0.01357744f, 0.01742279f, 0.00014573f, 0.02084140f, 
    0.02498138f, 0.00707857f, 0.02988360f, -0.01931414f, 0.01425470f, 0.01398176f, -0.01679557f, -0.02537353f, 
    -0.00826717f, 0.01389192f, 0.02049321f, 0.00785036f, -0.00988983f, 0.01377008f, -0.02287965f, -0.01416549f, 
    -0.01637297f, -0.00431301f, -0.01073014f, -0.03080604f, 0.00944006f, 0.00955403f, 0.00188949f, -0.00167556f, 
    -0.00738095f, -0.03445763f, -0.00792071f, -0.03075745f, 0.01335479f, -0.00001402f, -0.03645957f, 0.03423544f, 
    -0.02915198f, 0.02045728f, 0.02275163f, 0.02829268f, -0.01612834f, -0.03730224f, -0.03424630f, 0.01067327f, 
    0.02068215f, -0.03865581f, -0.00061726f, -0.01083468f, -0.01136168f, -0.00631786f, 0.02181212f, 0.00763916f, 
    -0.01076675f, -0.02068597f, -0.03753648f, -0.02078601f, 0.01994318f, 0.01072709f, 0.01259311f, -0.01520719f, 
    0.01465180f, -0.00345737f, -0.00085150f, -0.01209122f, 0.00328419f, -0.01473277f, -0.02048800f, 0.01389211f, 
    -0.00429484f, 0.02791961f, -0.02970592f, -0.02608058f, 0.00624989f, 0.01266426f, 0.02573824f, -0.02372023f, 
    0.01483365f, -0.00724497f, 0.02632305f, -0.00557651f, -0.03827274f, 0.01323261f, -0.00211799f, -0.02699004f, 
    -0.01742624f, 0.00248932f, -0.03285626f, -0.03190371f, -0.03696959f, -0.01665316f, -0.00815822f, 0.00549751f, 
    -0.01972911f, 0.02357112f, -0.03293032f, -0.00943714f, 0.00866821f, 0.01332542f, 0.02649871f, 0.01636577f, 
    0.00103375f, -0.02233670f, 0.02688414f, -0.02903699f, 0.01001292f, 0.00023231f, -0.00643145f, -0.03703071f, 
    -0.03783770f, 0.01409565f, 0.00461933f, 0.03007896f, -0.03146004f, 0.03645881f, -0.03668972f, -0.02140934f, 
    0.02999959f, -0.02121291f, 0.01832261f, 0.01055782f, -0.00798734f, -0.03573707f, -0.00271093f, 0.01882965f, 
    -0.00560165f, 0.00637175f, -0.02544204f, -0.03555897f, -0.02907727f, -0.03544310f, 0.00999901f, -0.02685720f, 
    -0.01509955f, 0.01493097f, 0.02857677f, 0.01601027f, -0.00667632f, 0.01751916f, -0.02272416f, -0.03076077f, 
    -0.00884239f, 0.01249719f, 0.02548530f, -0.02750631f, 0.01175938f, 0.00784441f, 0.03142571f, -0.01658994f, 
    -0.01995358f, -0.01329919f, 0.01649746f, -0.00417967f, -0.02480560f, 0.01541423f, -0.01482071f, 0.03199470f, 
    -0.01317609f, -0.03635055f, -0.02882450f, 0.02443145f, 0.03373886f, 0.02805193f, -0.01240586f, 0.02019997f, 
    0.01574682f, 0.01020805f, -0.03816440f, -0.01334142f, 0.00982323f, 0.00643740f, -0.00937057f, -0.02785315f, 
    -0.01950257f, 0.01717524f, -0.03391227f, -0.02368297f, -0.00408105f, -0.01110259f, -0.00852843f, -0.03535810f, 
    -0.00170992f, 0.01207319f, 0.02875980f, -0.01351226f, -0.00369084f, 0.00270810f, -0.02716462f, 0.02810155f, 
    -0.02897154f, -0.02473557f, -0.03437937f, -0.01241795f, -0.00111701f, -0.02599432f, 0.00009911f, -0.00354480f, 
    0.01001890f, -0.01435171f, 0.02356305f, -0.02974163f, 0.02288594f, 0.00588616f, -0.03212456f, -0.03845368f, 
    0.02310503f, -0.04178933f, 0.02653532f, 0.02265416f, -0.01230862f, 0.02730379f, 0.00052430f, -0.01948896f, 
    -0.02497837f, 0.02217010f, 0.00328672f, 0.01308177f, -0.00267677f, -0.01241622f, -0.01448181f, -0.03680347f, 
    -0.02130539f, -0.01262463f, -0.03283610f, -0.02790942f, 0.02088414f, 0.03282075f, -0.01513345f, 0.00552958f, 
    -0.03920936f, 0.00731652f, 0.01523274f, -0.01980568f, 0.00324899f, 0.00982329f, -0.03401900f, -0.03072117f, 
    -0.01264361f, -0.03227455f, -0.02529325f, 0.02371531f, 0.02471374f, -0.00135082f, 0.00257232f, -0.00546767f, 
    0.02879656f, 0.00217658f, -0.01454297f, -0.00019962f, 0.01889314f, 0.00500381f, 0.03089198f, 0.00678872f, 
    -0.02382715f, 0.00850902f, 0.02534037f, -0.02553049f, -0.03558885f, -0.01957935f, 0.00056080f, 0.01539802f, 
    -0.02009341f, 0.00205458f, -0.01835595f, 0.01204390f, -0.00081668f, -0.01558344f, -0.04014190f, 0.01766266f, 
    -0.00659050f, 0.02020949f, 0.02715493f, 0.02606753f, 0.00374209f, 0.02490323f, -0.02984533f, -0.02340339f, 
    -0.00732219f, -0.02989438f, 0.00182270f, 0.01618519f, -0.01239263f, 0.00688313f, -0.03554095f, -0.03175465f, 
    0.01785588f, -0.02495264f, 0.01942402f, -0.03751610f, 0.02189245f, 0.01789344f, 0.00147438f, 0.02044398f, 
    0.01036721f, 0.02804383f, 0.00894544f, -0.02877422f, -0.04117640f, -0.02031074f, 0.01967536f, -0.01535640f, 
    0.00364986f, 0.00569628f, -0.02510404f, -0.01862238f, -0.00333784f, 0.00011674f, -0.01788894f, -0.01027347f, 
    0.03204349f, -0.00952817f, -0.02490095f, 0.02623858f, 0.00787090f, 0.02627196f, 0.01825081f, -0.03081380f, 
    0.01254284f, -0.03092065f, -0.01272266f, -0.01517890f, -0.00955257f, -0.01368900f, 0.02084416f, -0.01015037f, 
    0.02824222f, 0.01032682f, 0.02388138f, 0.00296964f, -0.00797872f, 0.01539491f, -0.01245851f, -0.03441110f, 
    0.00531578f, -0.02893393f, 0.01646462f, 0.02570609f, -0.02688341f, 0.00135930f, 0.00211873f, 0.02100511f, 
    0.01139128f, 0.01910702f, -0.01698982f, 0.00080633f, -0.01280412f, -0.04000257f, -0.00944850f, -0.00363364f, 
    -0.02050620f, -0.03274978f, -0.01814668f, 0.00814676f, -0.02887474f, 0.00802980f, -0.01604193f, 0.03357422f, 
    0.00486143f, 0.02388147f, 0.02148159f, -0.00700907f, 0.00757905f, -0.01730737f, -0.03733606f, 0.02763099f, 
    -0.01561569f, -0.01300070f, -0.02937396f, -0.01156082f, -0.00205298f, -0.03436921f, 0.02180358f, -0.02034184f, 
    0.00601133f, 0.01405589f, 0.00570771f, 0.00276360f, 0.01274807f, 0.01017930f, 0.02747485f, -0.02885442f, 
    0.03579526f, -0.02735912f, -0.02418045f, -0.01937720f, -0.02201372f, 0.00578752f, 0.00578902f, -0.02938612f, 
    0.02721458f, 0.01369235f, 0.01758316f, 0.00316889f, 0.01537983f, 0.01251765f, -0.00627985f, -0.01851658f, 
    -0.00326237f, 0.01766152f, -0.01812839f, 0.00842865f, 0.00072467f, 0.02488446f, -0.03716042f, 0.00689006f, 
    -0.00908414f, -0.02235128f, -0.02621202f, -0.02395388f, 0.02824376f, 0.01141841f, -0.00294205f, -0.03566125f, 
    -0.00408046f, 0.01677081f, 0.02147179f, -0.00369040f, -0.03470579f, 0.02050014f, -0.01918419f, -0.02486551f, 
    -0.02357112f, 0.02590242f, 0.01532658f, -0.02036936f, 0.01005139f, -0.01044326f, -0.01761125f, -0.00204692f, 
    -0.00907502f, 0.01698572f, -0.02594280f, 0.01037368f, 0.03193517f, -0.01376828f, -0.00751687f, 0.03042466f, 
    0.01306890f, -0.00226721f, -0.03745943f, -0.02241492f, -0.01222648f, 0.01232202f, -0.02826795f, 0.01465993f, 
    0.01450141f, -0.02852509f, 0.00401245f, -0.01297899f, 0.01170809f, -0.02794297f, -0.02379453f, 0.02345770f, 
    -0.04140334f, -0.00840398f, 0.00970800f, 0.00548937f, 0.02476375f, 0.00750234f, 0.01508828f, -0.03587433f, 
    -0.00188036f, 0.01724588f, -0.03448365f, -0.01191203f, 0.01040460f, -0.00837865f, 0.00048110f, -0.01244249f, 
    -0.00019547f, 0.00371396f, -0.03274473f, -0.01426322f, 0.02781958f, 0.00047106f, -0.03511161f, -0.03646480f, 
    -0.03057925f, 0.00088188f, 0.01719243f, -0.01227059f, -0.01864163f, -0.02848635f, -0.04041718f, 0.00482762f, 
    -0.02408142f, 0.00145194f, -0.02874947f, -0.00183299f, 0.02834368f, 0.00833634f, -0.02107691f, 0.02947519f, 
    -0.01705044f, 0.02875772f, -0.00751342f, 0.01625807f, -0.00406082f, 0.02201394f, 0.01356755f, 0.01324060f, 
    0.00787768f, -0.01100690f, 0.02602949f, 0.00505549f, 0.00721314f, 0.00469407f, 0.02107322f, -0.01153781f, 
    -0.00523904f, 0.01477995f, -0.02002212f, -0.01405408f, 0.02677699f, 0.01311189f, -0.03558249f, -0.03603694f, 
    -0.00416262f, -0.02054594f, -0.00249472f, 0.02107922f, -0.02686725f, -0.00857241f, 0.02626890f, -0.01938394f, 
    -0.02266258f, -0.03115587f, -0.02976724f, 0.01765694f, -0.00685417f, -0.01459146f, -0.02699560f, 0.00810216f, 
    -0.01961377f, 0.01599198f, -0.01753352f, -0.03754917f, 0.01068246f, 0.02098383f, -0.01192789f, -0.00899610f, 
    -0.02549218f, -0.00202535f, -0.02047528f, -0.02401909f, -0.02555173f, 0.00307371f, -0.00385102f, 0.02194536f, 
    0.00530557f, -0.00733117f, -0.04044465f, 0.01066189f, 0.01283182f, -0.01948944f, -0.02552793f, 0.02023684f, 
    -0.03878503f, -0.03227426f, 0.00314979f, -0.00413943f, -0.02036557f, -0.01761356f, 0.01335025f, 0.00399611f, 
    -0.01442231f, -0.03213526f, -0.00200687f, -0.00422976f, 0.00021429f, -0.01895271f, 0.02830342f, 0.00308020f, 
    -0.03878675f, 0.02515987f, -0.02384051f, 0.00939482f, 0.00679057f, 0.01485782f, -0.01199899f, -0.03922163f, 
    0.01371791f, -0.01688041f, -0.03533251f, 0.02763315f, -0.03080728f, 0.01225071f, -0.03137871f, 0.02457659f, 
    0.01922756f, 0.01593585f, -0.02130285f, 0.01059911f, -0.00400235f, 0.01540185f, -0.03406225f, -0.02703959f, 
    -0.00574864f, -0.01934739f, 0.00550798f, 0.02135942f, 0.02508410f, -0.00347219f, -0.01053296f, -0.03865359f, 
    0.00538605f, -0.03916355f, -0.03393116f, 0.02839678f, 0.01563753f, -0.03025408f, -0.03763334f, 0.00527400f, 
    -0.01797188f, 0.01594535f, -0.03359743f, -0.02589789f, -0.03687184f, 0.01346335f, 0.01603164f, -0.03107511f, 
    0.01872219f, -0.02321092f, -0.00265277f, 0.01706028f, -0.03411728f, -0.02663574f, 0.02680930f, 0.01803762f, 
    0.02173371f, 0.01537680f, -0.03977268f, -0.00171493f, -0.01391285f, -0.00740005f, -0.00709761f, -0.03478360f, 
    0.02777628f, 0.01567900f, 0.01231864f, 0.02288293f, 0.01348009f, 0.02602377f, 0.01633568f, -0.04000691f, 
    -0.03853548f, -0.02987898f, 0.03147618f, -0.04207273f, -0.03201138f, -0.03641769f, 0.00697136f, 0.02535187f, 
    -0.15193743f, 0.02950233f, 0.05244352f, -0.14333275f, 0.13158230f, 0.02431943f, 0.07560631f, 0.01799145f, 
    -0.23286961f, 0.10327180f, 0.01831972f, -0.01264725f, -0.36148921f, -0.19116004f, 0.32219493f, 0.06996514f, 
    -0.02068577f, 0.04934351f, 0.17208882f, -0.02813525f, 0.06365991f, 0.06644689f, 0.04886707f, 0.09208301f, 
    0.05045387f, 0.13334113f, -0.16770838f, 0.15038133f, 0.05526545f, 0.01757613f, 0.01314004f, 0.19301490f, 
    0.09519750f, 0.00705708f, -0.10230445f, 0.10849298f, -0.17512615f, 0.14937149f, 0.22893760f, -0.09151987f, 
    -0.07476744f, 0.02614436f, 0.01971947f, 0.05256634f, 0.12036704f, 0.09972014f, 0.05715645f, -0.02727992f, 
    0.15193382f, 0.25828812f, 0.12815562f, 0.08934555f, 0.07038104f, 0.14476377f, 0.03821699f, -0.03340225f, 
    -0.03934734f, -0.01288322f, 0.24978335f, 0.20474368f, 0.39261770f, -0.11637539f, 0.00938705f, -0.02421303f, 
    0.05220221f, 0.03271154f, -0.04739002f, 0.17917193f, 0.06666961f, 0.02053784f, 0.01132731f, 0.01585579f, 
    0.05601960f, 0.06861222f, -0.03062729f, 0.08147041f, -0.01760689f, -0.15608628f, -0.05027375f, 0.01920981f, 
    0.09098841f, 0.12329528f, 0.06959339f, 0.08289132f, 0.06953182f, -0.04858971f, 0.11599924f, 0.12032236f, 
    0.15263668f, 0.10710403f, 0.10503157f, -0.01397888f, 0.06021127f, -0.14284280f, -0.01263720f, 0.08452926f, 
    0.56721687f, -0.25095543f, 0.10777064f, 0.22437054f, -0.06844025f, 0.07936113f, -0.01700881f, 0.00569826f, 
    0.04412248f, -0.06409703f, 0.05794744f, 0.15706675f, -0.26678303f, -0.18826723f, -0.08365174f, -0.35198742f, 
    0.02142126f, 0.05299719f, 0.14439966f, 0.06448721f, -0.05851322f, 0.04962086f, 0.02139184f, 0.08200949f, 
    -0.26022565f, 0.04765287f, 0.30170277f, 0.02255207f, -0.07800465f, 0.04888599f, -0.07202537f, -0.03670434f, 
    -0.07378723f, 0.03012181f, -0.00774098f, -0.03179334f, -0.20884550f, 0.21138677f, 0.22907974f, -0.09190693f, 
    0.02793832f, 0.06926296f, 0.02919522f, 0.08336528f, 0.10339431f, 0.01586444f, 0.09669694f, 0.05002281f, 
    0.06602695f, 0.15511231f, 0.17187738f, -0.04494020f, 0.07076499f, 0.07865227f, 0.12926465f, -0.04386200f, 
    0.06921976f, -0.00298470f, 0.03411717f, 0.07959533f, -0.19635119f, -0.14719647f, -0.13933104f, 0.03581278f, 
    0.03564046f, 0.08578051f, 0.06668390f, -0.01164993f, 0.03956582f, -0.07939891f, 0.06341653f, 0.12114564f, 
    -0.36577141f, -0.23818658f, 0.00858289f, -0.16059658f, 0.05750778f, 0.10748477f, 0.10620905f, -0.03686692f, 
    -0.04969367f, 0.15750729f, -0.03008839f, -0.03236449f, 0.12497006f, -0.20477192f, 0.12584217f, 0.03047227f, 
    -0.09585962f, 0.03469633f, 0.11200375f, 0.00697238f, -0.03296105f, 0.00424297f, 0.03988441f, 0.16950697f, 
    -0.16318570f, 0.23716700f, 0.22482771f, 0.04473770f, 0.05384251f, -0.00712040f, 0.02456826f, 0.01929686f, 
    0.18682368f, 0.17216161f, -0.06023631f, 0.06955452f, 0.02920972f, 0.08190078f, 0.07691941f, -0.15099923f, 
    0.01087517f, -0.04668991f, 0.10456467f, 0.03766725f, 0.05768800f, -0.02194310f, 0.10951898f, 0.00307559f, 
    0.39991656f, -0.24911924f, -0.17451438f, 0.15123692f, 0.08442794f, 0.11310121f, -0.13248952f, 0.07492746f, 
    0.04444706f, 0.05924625f, 0.06734601f, -0.02791444f, 0.07047671f, 0.03952909f, 0.25836176f, 0.12472272f, 
    -0.01454166f, -0.07149734f, -0.13043064f, -0.03465891f, 0.02753152f, 0.09832598f, 0.08345021f, 0.16222136f, 
    0.07276657f, 0.09352371f, 0.02137164f, -0.07879127f, 0.03167101f, 0.16955842f, 0.20464531f, -0.08396202f, 
    0.07985489f, 0.12528114f, 0.12935680f, 0.05282938f, -0.13540551f, -0.17941050f, -0.01192046f, -0.06039278f, 
    0.03515920f, 0.11250948f, 0.15499249f, 0.01249984f, 0.09768660f, -0.12108508f, -0.01039888f, -0.06406211f, 
    0.14880796f, 0.04403812f, -0.03191789f, 0.02551552f, -0.03081813f, -0.05360878f, -0.00781216f, 0.01634015f, 
    0.09644822f, 0.05127281f, 0.01705629f, 0.14495857f, 0.35104302f, -0.05383048f, -0.18538807f, 0.13234326f, 
    -0.10380958f, 0.10233568f, -0.09333996f, 0.18458371f, 0.17255874f, 0.05828366f, -0.16980661f, -0.02082364f, 
    0.21959941f, 0.01587748f, -0.07589290f, 0.09077749f, 0.08930371f, -0.02521125f, 0.04200183f, 0.06116891f, 
    -0.04835162f, 0.14827521f, -0.00174154f, -0.06520709f, -0.19306171f, 0.35176644f, 0.07475849f, 0.26919398f, 
    0.00221048f, -0.01775732f, 0.07471660f, -0.12336320f, 0.02831144f, 0.13175741f, 0.11230539f, 0.02438560f, 
    0.13448003f, -0.22717981f, 0.02678593f, 0.06552735f, -0.07398200f, -0.08614684f, -0.07394414f, -0.00750335f, 
    0.05003944f, 0.03259139f, 0.11985681f, 0.07812175f, 0.07979140f, -0.00447613f, 0.05542330f, 0.01113714f, 
    0.08407240f, 0.10108244f, 0.04018388f, 0.15758309f, 0.06252712f, -0.05697645f, -0.00516870f, 0.12708420f, 
    -0.00176711f, 0.00855940f, -0.03453005f, -0.08501779f, -0.02038229f, 0.12465484f, 0.02863621f, -0.03258916f, 
    0.06546041f, -0.01530899f, -0.09089123f, 0.00638773f, -0.10614343f, -0.08319359f, 0.08290724f, 0.00951838f, 
    0.12522899f, 0.02696793f, 0.17283621f, -0.07490288f, -0.04372248f, -0.09994856f, -0.08508615f, 0.10956579f, 
    -0.48306972f, 0.00238977f, 0.25835750f, 0.10419667f, 0.03178373f, 0.11457366f, -0.04819242f, -0.03793253f, 
    0.07588279f, 0.15040503f, 0.11170033f, 0.07010813f, -0.16611066f, -0.14897653f, 0.07314284f, -0.08709811f, 
    -0.01026747f, 0.11895678f, 0.13032278f, 0.11529584f, -0.00005874f, 0.04704456f, 0.04349258f, 0.03127585f, 
    0.08973749f, -0.05583657f, -0.07559810f, -0.23352957f, 0.10575429f, -0.06320974f, -0.00392754f, 0.01271432f, 
    -0.00857836f, 0.02020437f, -0.10884999f, -0.00260539f, 0.32335764f, -0.15609917f, -0.13955304f, 0.07376318f, 
    -0.05275194f, 0.00813266f, -0.02750298f, -0.04199796f, 0.10053919f, 0.06016632f, 0.07285505f, 0.06585114f, 
    -0.18447235f, 0.07174288f, -0.05095028f, -0.02605696f, 0.08637627f, 0.12023336f, 0.05402969f, -0.00231604f, 
    0.04657285f, 0.02126482f, 0.02923945f, 0.00848786f, 0.04964809f, -0.21349911f, 0.14471808f, 0.00768069f, 
    -0.01440165f, 0.13077617f, 0.03025093f, 0.14765194f, -0.06928838f, 0.10568856f, -0.08011425f, 0.07370765f, 
    -0.31513929f, -0.03383984f, 0.08409187f, 0.12522221f, 0.04972173f, -0.01412227f, 0.05106362f, -0.02825308f, 
    0.01882700f, -0.03523730f, -0.00207307f, -0.02323084f, -0.20308010f, 0.10555768f, 0.04084779f, 0.03765124f, 
    0.03686301f, 0.01567773f, 0.00238229f, -0.03402260f, -0.04945184f, 0.20930797f, 0.08536385f, 0.04433268f, 
    0.30476955f, -0.13752230f, -0.17053106f, 0.11597279f, 0.02394034f, 0.03086187f, 0.13955337f, 0.07739580f, 
    0.01669826f, -0.12464368f, -0.06335492f, -0.04520055f, -0.22632073f, -0.19961187f, 0.11935371f, -0.01359252f, 
    0.07256086f, 0.07608370f, 0.07467516f, -0.01623262f, -0.02668533f, 0.02244739f, 0.08318447f, 0.01465636f, 
    0.53232628f, -0.18024105f, 0.04612099f, -0.00720196f, -0.01227254f, 0.08780156f, -0.11110793f, 0.19441380f, 
    0.06903218f, -0.06437345f, 0.04366501f, 0.02598493f, -0.11232003f, -0.04287422f, 0.06471872f, -0.07250839f, 
    -0.01056151f, 0.04820335f, 0.04033728f, 0.02634549f, 0.14749713f, -0.02069879f, 0.03756241f, -0.02797443f, 
    -0.10849425f, 0.05949178f, -0.01303064f, 0.09845677f, 0.01237474f, -0.05879055f, 0.10146228f, 0.08511408f, 
    -0.04513312f, 0.06013467f, 0.14460498f, 0.08206746f, -0.22585781f, -0.04638330f, 0.14552461f, -0.19828841f, 
    0.09419868f, 0.15642011f, 0.04282610f, 0.07707004f, 0.02592497f, 0.06507900f, 0.13550062f, 0.15969712f, 
    -0.05313939f, 0.11448646f, -0.15355922f, 0.19998217f, 0.10198727f, 0.07889970f, -0.01329378f, 0.16680138f, 
    0.01057848f, 0.04819850f, 0.00254277f, 0.14857297f, 0.13426590f, 0.01768849f, 0.06037164f, 0.17559457f, 
    0.03660600f, 0.09906271f, -0.02035177f, 0.12060402f, 0.05351666f, 0.04666894f, -0.00535244f, 0.19191870f, 
    0.07041030f, 0.05446792f, 0.00243073f, 0.09846578f, -0.06627665f, -0.07246984f, 0.11770166f, -0.03643408f, 
    0.06079376f, 0.19151998f, 0.05778539f, 0.13012697f, 0.28304175f, -0.05334492f, 0.04348294f, 0.00169437f, 
    -0.04557645f, 0.15070178f, 0.08169377f, 0.21403828f, 0.09256636f, 0.12073787f, 0.03805169f, 0.03538817f, 
    -0.01102305f, 0.15158109f, 0.00540616f, 0.09035079f, 0.01813211f, 0.05284688f, 0.07323385f, -0.03197294f, 
    0.05339988f, 0.04062395f, -0.04310271f, 0.11288954f, 0.04687539f, 0.07865332f, -0.01484885f, -0.05165226f, 
    -0.02996256f, -0.00908136f, 0.07215235f, 0.10935135f, 0.07345986f, 0.09946558f, -0.01479898f, -0.00971699f, 
    0.01408019f, -0.09422211f, 0.23297934f, 0.07746357f, 0.13445665f, 0.08289835f, 0.13192829f, 0.07199037f, 
    -0.05871999f, 0.08789425f, 0.17527111f, 0.05502128f, -0.29469904f, 0.19305724f, 0.28676659f, 0.08478337f, 
    -0.00133374f, 0.06751589f, 0.05168993f, 0.12054092f, 0.09485815f, 0.06911788f, 0.07100854f, 0.09597448f, 
    0.09405803f, 0.07227799f, 0.10694785f, 0.09655297f, 0.05966206f, 0.08035344f, -0.07040960f, 0.07428732f, 
    0.07373289f, -0.02222406f, -0.08658028f, -0.06795029f, -0.31155932f, 0.13486722f, 0.18461248f, -0.03453666f, 
    0.05272523f, -0.04974454f, -0.05036736f, -0.01261470f, -0.01393925f, 0.05203864f, 0.04760875f, 0.12323970f, 
    -0.28578767f, 0.22658437f, 0.16096091f, 0.05506879f, 0.02799358f, 0.07464982f, 0.13964641f, 0.00379007f, 
    -0.00702059f, -0.01989198f, 0.02881687f, 0.02049701f, 0.34964973f, 0.02930713f, 0.05062053f, -0.02157506f, 
    0.13832478f, -0.03436119f, 0.02710236f, 0.08437102f, 0.03113960f, 0.12222634f, 0.12836908f, -0.01422693f, 
    0.05226064f, -0.13769524f, -0.03213871f, -0.05947249f, 0.07781897f, -0.05074148f, 0.11081359f, 0.07702146f, 
    0.01723666f, 0.09962482f, 0.10678547f, 0.00325049f, 0.12141158f, 0.24476355f, -0.05521906f, 0.07355516f, 
    0.06729542f, 0.09288393f, 0.01723210f, 0.07328248f, 0.09736597f, 0.01883568f, -0.10723452f, 0.07399596f, 
    -0.27956402f, 0.18019404f, 0.30753133f, -0.21450986f, 0.07412340f, 0.10191260f, 0.05546632f, 0.03160671f, 
    0.06558216f, 0.09662209f, 0.06267700f, 0.05295097f, 0.37806296f, -0.03170239f, 0.05066023f, 0.20440429f, 
    0.06138537f, 0.16125526f, 0.07738539f, 0.04868243f, 0.10039828f, 0.16396493f, 0.12984024f, 0.07481898f, 
    0.22335751f, -0.10847072f, 0.11270236f, -0.06095512f, 0.07134013f, 0.17921244f, -0.01389203f, 0.04144585f, 
    0.10579699f, -0.04383769f, 0.06233041f, 0.05432436f, 0.01574712f, -0.02199250f, 0.14336477f, 0.03938463f, 
    0.13973896f, 0.10209864f, -0.00142405f, 0.13072975f, -0.00384308f, 0.13905519f, 0.08225218f, 0.03419276f, 
    -0.03817044f, 0.05890701f, 0.02321411f, 0.16094157f, 0.09130136f, 0.07479329f, 0.08611866f, -0.04838496f, 
    -0.07029867f, 0.01323016f, 0.07631632f, 0.11467683f, 0.32966778f, 0.26354507f, -0.15488039f, -0.00901837f, 
    0.04555422f, 0.06706060f, -0.04588402f, 0.11955240f, -0.08938170f, 0.09070937f, 0.00601988f, 0.04507064f, 
    0.00427655f, 0.01779928f, 0.01218973f, -0.01507388f, 0.00984752f, -0.01271588f, -0.03303891f, -0.03317487f, 
    -0.03767693f, -0.03353063f, -0.04254036f, -0.03662132f, -0.01240318f, -0.02627830f, -0.01292305f, 0.00725997f, 
    -0.01374094f, -0.00109346f, 0.01369816f, 0.02312999f, -0.04374773f, -0.00210807f, -0.01207846f, -0.00063981f, 
    0.01713126f, -0.00849355f, 0.02413911f, -0.03294561f, 0.02073231f, -0.04096689f, 0.02585541f, 0.00371652f, 
    -0.00161938f, 0.01455496f, -0.03836218f, 0.00808077f, 0.02189085f, 0.01186422f, -0.03635257f, -0.01904401f, 
    -0.03545285f, -0.04313736f, 0.00055246f, -0.01549448f, 0.02436624f, -0.00925017f, -0.03337203f, 0.01452679f, 
    -0.03579111f, -0.02621162f, 0.01298140f, 0.00575248f, -0.00495388f, -0.01967372f, -0.04234070f, -0.00338627f, 
    0.02584044f, -0.02572117f, 0.00144566f, -0.04213192f, 0.00133342f, 0.01098392f, 0.01655435f, -0.03859173f, 
    -0.01046032f, -0.02837224f, -0.03464908f, -0.00757246f, -0.01195088f, -0.03765092f, -0.01165884f, -0.03502566f, 
    -0.04007462f, -0.02199344f, 0.01676245f, -0.01417410f, -0.02241252f, 0.02164204f, 0.00141390f, -0.01625381f, 
    -0.00401331f, 0.02590870f, 0.00650987f, -0.00234206f, -0.01431299f, -0.02438285f, 0.02743530f, 0.03141063f, 
    -0.02343177f, -0.02213190f, -0.02367373f, -0.00926313f, 0.01644303f, 0.01960518f, 0.00625527f, 0.00879897f, 
    0.01226010f, 0.01837063f, 0.01828068f, 0.00212202f, -0.03328668f, -0.00133038f, -0.01598455f, 0.01394594f, 
    -0.00771765f, -0.03607146f, -0.00265347f, -0.01108587f, -0.01548123f, -0.01197351f, -0.03334495f, -0.01401287f, 
    0.01457573f, -0.00448108f, -0.00517611f, 0.01932412f, -0.02576061f, 0.01489112f, -0.01383413f, -0.00510856f, 
    -0.01254185f, 0.00728295f, -0.01980530f, 0.01069427f, 0.00216294f, -0.03132370f, -0.03299767f, 0.01423579f, 
    -0.04086208f, -0.02687912f, -0.02092402f, -0.01280134f, -0.00618230f, 0.00938404f, -0.02798384f, -0.04014590f, 
    -0.00056957f, -0.03815895f, 0.00348805f, -0.04378456f, -0.02335384f, 0.00892641f, -0.00531362f, -0.00300811f, 
    0.02525095f, -0.00328295f, 0.01063001f, -0.04144632f, 0.01124087f, 0.01558123f, -0.02968826f, -0.01921616f, 
    -0.00152295f, 0.00909995f, 0.00240641f, -0.03970246f, -0.00621257f, -0.03114844f, 0.03164242f, -0.03445639f, 
    -0.03340232f, -0.00330470f, -0.00447367f, -0.02798637f, -0.01854865f, -0.01501516f, 0.01778719f, -0.02170843f, 
    -0.02765830f, 0.01642263f, 0.01259955f, -0.02904204f, -0.03894044f, -0.03143823f, 0.00557119f, -0.02063986f, 
    -0.04104150f, 0.01776585f, -0.00821345f, 0.01054422f, 0.02640928f, 0.01698541f, 0.00496869f, -0.03699375f, 
    -0.03492321f, 0.01665627f, 0.01354598f, 0.00077049f, 0.01806361f, -0.00458824f, -0.02060879f, -0.01380670f, 
    0.02689353f, -0.00245640f, -0.02807059f, -0.04186935f, -0.01493856f, -0.03791651f, -0.00999786f, 0.00776688f, 
    0.02334185f, -0.03574001f, 0.03211019f, -0.00627365f, -0.04417231f, 0.00346451f, 0.02277909f, -0.04404170f, 
    -0.03195769f, -0.01551294f, -0.02408103f, 0.01965808f, -0.03620426f, -0.02805902f, -0.02450265f, 0.00262979f, 
    -0.00408349f, 0.02551225f, -0.02710775f, 0.01911708f, 0.01908992f, -0.03305693f, -0.00936740f, 0.01618817f, 
    -0.02405909f, -0.03013850f, 0.00646057f, -0.01203561f, 0.01567571f, -0.00117324f, -0.00230152f, -0.03811608f, 
    -0.01300475f, 0.01554719f, -0.04299677f, -0.02476412f, -0.00352457f, 0.00751456f, -0.03366443f, -0.00330879f, 
    0.02373685f, -0.01860231f, -0.03519920f, -0.01064028f, -0.03207377f, -0.03362712f, -0.04273510f, 0.01225239f, 
    -0.00140926f, 0.01787010f, 0.01987699f, 0.01319028f, -0.03127437f, -0.02185231f, -0.01159417f, 0.01858152f, 
    0.00698437f, 0.01916680f, 0.01676026f, 0.01591050f, -0.00852569f, -0.02441078f, -0.00484527f, -0.01250454f, 
    -0.04107757f, 0.02701126f, -0.00885126f, -0.01792407f, 0.00526152f, -0.01772254f, 0.00449392f, -0.02703270f, 
    -0.02096573f, 0.03129707f, -0.01314783f, -0.00117151f, -0.01786871f, 0.01806130f, 0.00401449f, 0.02590936f, 
    -0.02031070f, -0.03135441f, 0.00782663f, -0.02743824f, -0.02799869f, 0.01004731f, -0.04103973f, -0.04293039f, 
    -0.00694032f, -0.04091805f, 0.02505936f, -0.00638874f, 0.02520679f, 0.01774511f, -0.02640289f, -0.02351250f, 
    -0.00191418f, -0.00250639f, -0.00381376f, -0.03410903f, -0.01947844f, 0.00455511f, -0.02169656f, -0.01309689f, 
    0.01141387f, -0.02590715f, -0.01254191f, -0.03325018f, 0.02838331f, -0.00122025f, 0.01923416f, -0.01133810f, 
    0.00523634f, -0.01663205f, -0.02500379f, -0.04152915f, 0.00813818f, -0.00982448f, -0.02854392f, 0.02189754f, 
    0.01100016f, -0.03145093f, -0.02419723f, 0.01579837f, -0.00824504f, -0.04239994f, 0.00923186f, -0.01924146f, 
    0.01171589f, -0.01599977f, -0.00303414f, 0.01914787f, -0.00728296f, -0.03025114f, 0.01660400f, -0.00257430f, 
    -0.03019020f, 0.00275724f, -0.02463640f, -0.03984997f, 0.02600055f, -0.01383198f, 0.01410697f, -0.02641255f, 
    -0.02229788f, 0.01888511f, -0.00811925f, 0.02248352f, -0.03796723f, 0.01658725f, 0.01185141f, 0.00573567f, 
    0.00981028f, -0.00020723f, 0.00017492f, -0.01348979f, -0.00240582f, 0.02325747f, 0.01116821f, -0.00614673f, 
    0.02203146f, -0.00467637f, -0.00556336f, 0.02644419f, -0.03953321f, 0.00756452f, -0.02226006f, 0.01995442f, 
    0.01543780f, -0.02604636f, -0.01614269f, -0.01465647f, 0.01842272f, -0.04097060f, -0.01033805f, -0.02062343f, 
    -0.01223076f, -0.02997612f, -0.02800513f, -0.01119214f, -0.01484197f, -0.01955126f, 0.01244470f, -0.00875379f, 
    -0.00121709f, 0.00974848f, 0.00857022f, 0.02634358f, 0.00155676f, -0.01742479f, -0.02572836f, 0.02251611f, 
    -0.01137003f, 0.01569312f, -0.02628188f, -0.03442058f, -0.01650561f, -0.03723729f, 0.00044415f, -0.02633397f, 
    0.01618754f, 0.02354532f, 0.01770275f, -0.00477723f, -0.02803402f, 0.02411229f, -0.00760577f, -0.00948248f, 
    -0.02284428f, 0.00030473f, -0.00232601f, 0.02707933f, 0.01661492f, 0.01164172f, -0.03315612f, -0.02425573f, 
    -0.02778022f, -0.03306453f, 0.00669101f, 0.00121874f, 0.02752705f, -0.02901822f, -0.01962959f, 0.01055858f, 
    -0.03848107f, -0.01499919f, 0.02512106f, 0.01314971f, -0.03200562f, -0.02452692f, 0.01370048f, -0.02932502f, 
    -0.01276508f, -0.00929910f, 0.00170461f, -0.00757846f, 0.00384033f, 0.01388573f, -0.00015680f, 0.02383026f, 
    -0.00941147f, -0.01097407f, -0.03289079f, 0.00121025f, 0.00529468f, -0.02329140f, 0.01158023f, -0.02563304f, 
    -0.03477509f, 0.01991355f, -0.02009239f, 0.00850516f, 0.02503115f, -0.00999588f, 0.02147961f, 0.01246740f, 
    0.00837860f, -0.01471571f, -0.02845195f, -0.03528847f, -0.03249621f, 0.01583354f, 0.02515532f, 0.01851012f, 
    -0.02578124f, -0.02199842f, -0.01765064f, 0.03287178f, -0.03772603f, -0.02583059f, -0.00094891f, 0.02351223f, 
    -0.03091921f, -0.01859607f, -0.02718126f, 0.01771980f, -0.03765994f, -0.03309327f, 0.01582436f, 0.00280263f, 
    0.00614180f, 0.00946845f, 0.00027206f, 0.00094613f, -0.00759068f, 0.02785830f, -0.04317192f, 0.00956079f, 
    0.00705325f, -0.02730291f, -0.00562253f, -0.00769739f, -0.01110893f, -0.00460552f, 0.00420799f, -0.02752061f, 
    -0.00034282f, -0.00538639f, -0.01661829f, 0.01551212f, 0.02683510f, -0.03530713f, -0.00326606f, -0.03983916f, 
    0.01577896f, -0.03954144f, 0.00424127f, -0.02152890f, 0.00125992f, -0.02942620f, -0.01536171f, -0.01981726f, 
    -0.03852955f, -0.02520579f, 0.01958177f, -0.03144722f, -0.03320819f, 0.00561542f, -0.00710087f, -0.03169243f, 
    -0.00758641f, -0.01973729f, -0.03926041f, -0.01465757f, -0.00432243f, -0.03678448f, -0.04337638f, -0.01015211f, 
    -0.02141920f, 0.02104564f, 0.02886053f, 0.02032451f, 0.02469471f, -0.02715307f, 0.00964568f, 0.01483654f, 
    -0.01465530f, 0.00101259f, -0.01920293f, 0.00528083f, -0.01053286f, -0.02930920f, -0.01448967f, 0.01961389f, 
    -0.01523413f, -0.01905634f, -0.02157193f, 0.00740030f, -0.03461651f, -0.01461282f, 0.00557606f, -0.00461249f, 
    -0.04237655f, 0.02667293f, -0.01520848f, -0.01266233f, -0.01295301f, 0.02253479f, -0.02618212f, 0.02395830f, 
    0.01872478f, -0.00073713f, -0.01468644f, -0.03633061f, 0.01342760f, 0.01536856f, -0.00870080f, -0.02093803f, 
    0.02236839f, 0.02688247f, -0.01184509f, -0.04152617f, -0.00089661f, 0.02078305f, 0.02060549f, -0.00409474f, 
    0.00165167f, -0.03152135f, 0.02150291f, -0.00556827f, -0.02962316f, 0.01676629f, 0.01882017f, -0.02451009f, 
    0.00989578f, -0.02181484f, -0.04056049f, -0.03720962f, -0.00201339f, -0.00831000f, 0.01888801f, 0.01007825f, 
    -0.00502417f, -0.03030076f, 0.01724984f, -0.03369326f, 0.01881895f, -0.03165687f, -0.03855351f, -0.02310692f, 
    -0.01946989f, -0.04089023f, -0.01174857f, 0.00490629f, -0.01611634f, 0.01162885f, -0.02473902f, -0.02302470f, 
    -0.02648311f, -0.00786521f, -0.00099905f, 0.00450815f, -0.00025381f, -0.00937669f, -0.04371294f, 0.02480425f, 
    -0.04049299f, 0.02132082f, -0.02677593f, -0.03432313f, -0.03778204f, -0.02376259f, -0.02055364f, 0.00470752f, 
    0.02767042f, 0.02005942f, -0.03865647f, 0.02344539f, 0.01028696f, 0.01363757f, -0.02830683f, 0.01347720f, 
    0.01718976f, 0.00276256f, 0.02255190f, 0.01765621f, 0.03670311f, 0.00502859f, -0.00066441f, -0.02558079f, 
    -0.00358348f, 0.01856255f, -0.01302400f, -0.00990745f, -0.02431630f, -0.00873580f, -0.00633593f, 0.01311290f, 
    -0.00452717f, -0.03241672f, 0.01699964f, 0.00667212f, -0.00273516f, 0.02257662f, -0.03589352f, 0.00864867f, 
    0.01957196f, -0.02243436f, -0.03461377f, 0.00900934f, 0.01773535f, -0.01684424f, 0.01498582f, -0.01688636f, 
    0.02307120f, 0.00136422f, -0.02045808f, 0.01470248f, 0.00481182f, 0.01463604f, -0.04177542f, -0.00862680f, 
    0.01972226f, -0.03489625f, -0.03246790f, -0.00727074f, -0.03531403f, -0.01327307f, -0.00466627f, -0.03257746f, 
    -0.04176760f, -0.03519926f, -0.03187961f, -0.03497964f, 0.00672226f, -0.04007890f, 0.00002060f, 0.02319129f, 
    -0.02810548f, -0.02574787f, 0.02345213f, -0.03443549f, -0.01722382f, -0.00092183f, 0.01172160f, 0.01513227f, 
    -0.03735712f, 0.00397389f, 0.01276001f, -0.04184731f, -0.02180002f, 0.02590133f, 0.01948027f, 0.00184464f, 
    -0.01673451f, 0.00178302f, 0.02148255f, 0.01531333f, -0.03930493f, 0.02248701f, 0.00221474f, 0.02619249f, 
    -0.02519245f, -0.03002288f, -0.03067537f, -0.01816852f, -0.02542335f, 0.01662185f, -0.01860491f, 0.03046999f, 
    0.02114229f, -0.00235985f, -0.04250645f, 0.00084844f, -0.01928078f, 0.01723347f, -0.03156928f, -0.04270883f, 
    -0.00618143f, 0.00058648f, 0.01376588f, 0.02976081f, 0.02302166f, 0.01185417f, 0.01012482f, -0.00086571f, 
    -0.01304380f, 0.00092313f, -0.03489267f, -0.00015637f, -0.02895870f, 0.02499454f, -0.01647662f, -0.02533196f, 
    0.00626797f, 0.02218767f, 0.00716288f, -0.03527974f, 0.01937548f, -0.00597997f, -0.01199580f, 0.00610523f, 
    -0.03429964f, 0.00221770f, -0.03527684f, 0.01853761f, -0.03847004f, -0.04240292f, -0.00147328f, -0.03463614f, 
    0.02290978f, 0.00036576f, -0.01300894f, -0.02985352f, -0.01465117f, -0.00165216f, 0.02937753f, -0.01650322f, 
    -0.00019680f, 0.02630456f, -0.02700992f, -0.01757984f, 0.02035026f, -0.01738348f, -0.00739918f, -0.00424950f, 
    0.00254706f, 0.01186286f, -0.03784667f, 0.01633811f, -0.03800629f, 0.01394579f, -0.00912082f, -0.03387947f, 
    0.01087371f, -0.00663652f, -0.00885490f, 0.01165741f, -0.00751816f, 0.02623968f, -0.03016139f, 0.02668183f, 
    -0.02264988f, -0.02065690f, 0.00505043f, 0.02657397f, -0.00020011f, -0.03145466f, -0.01735325f, -0.04121830f, 
    0.00380518f, -0.03213731f, 0.01335504f, -0.02224120f, -0.00226867f, -0.01429929f, -0.00371092f, 0.00739842f, 
    0.01934496f, 0.02949193f, 0.01063862f, 0.01165423f, -0.04192972f, -0.03096864f, -0.04130848f, -0.04324618f, 
    -0.00440808f, -0.03700274f, -0.01129205f, -0.03730560f, 0.00164668f, -0.01567073f, 0.01900453f, 0.02923517f, 
    -0.01913383f, -0.00846107f, -0.02831688f, 0.01588162f, -0.00316228f, 0.02851505f, -0.01013567f, 0.02322276f, 
    -0.00026507f, 0.00911454f, 0.01770901f, 0.00299205f, -0.03650806f, -0.00864727f, -0.00124648f, -0.02351614f, 
    -0.01074924f, -0.04105551f, -0.00360357f, -0.02878945f, -0.00622999f, 0.02302936f, -0.03169692f, -0.04366947f, 
    0.02401795f, 0.00012427f, -0.02251565f, -0.00709881f, -0.02317150f, -0.01471447f, 0.02354376f, 0.02734841f, 
    -0.02916968f, -0.04289154f, 0.00818087f, 0.01891226f, -0.03707216f, -0.02502558f, 0.00694571f, -0.00825292f, 
    -0.03616784f, -0.03541704f, -0.02630317f, -0.03905795f, -0.03621808f, 0.01721481f, 0.00359152f, 0.01957583f, 
    -0.00189746f, 0.02698381f, -0.01396663f, -0.03614807f, 0.02690256f, -0.02781587f, 0.01321965f, -0.04288219f, 
    0.00508832f, -0.01068672f, -0.00413435f, -0.00754887f, -0.02968753f, -0.00256591f, -0.01793491f, 0.02619888f, 
    -0.02740329f, -0.02835942f, -0.03821638f, 0.00084204f, 0.02625664f, 0.02608356f, -0.00568795f, 0.00166464f, 
    0.02414421f, -0.02118002f, -0.03759165f, 0.01426669f, 0.01902064f, -0.03267394f, -0.03743359f, 0.01241637f, 
    -0.02250956f, -0.01308242f, -0.02976319f, -0.03135208f, 0.00240818f, -0.00198807f, -0.01572569f, 0.00052231f, 
    -0.01399736f, 0.02766019f, 0.00051806f, -0.00181726f, 0.01958448f, -0.02373834f, -0.01027346f, -0.03909979f, 
    -0.01546059f, 0.01800061f, 0.01522592f, 0.02061854f, -0.00216762f, 0.00312086f, 0.02188344f, -0.00651330f, 
    0.02336024f, 0.01692290f, 0.00623176f, 0.01166670f, -0.01335287f, -0.00627660f, 0.00105395f, 0.00986907f, 
    -0.01552494f, 0.01865140f, 0.01371291f, 0.01318476f, -0.02602980f, -0.02514343f, 0.00774673f, -0.00659067f, 
    -0.00393297f, 0.02494864f, 0.00190865f, 0.02247375f, 0.01685203f, 0.02124784f, -0.02928955f, -0.00014609f, 
    0.00635260f, -0.01213830f, 0.00226897f, -0.01209759f, -0.00253708f, -0.00411357f, -0.03210620f, 0.00872009f, 
    0.02486481f, -0.01714533f, -0.01894918f, 0.02151051f, -0.02524278f, 0.01156296f, -0.00511683f, 0.00939254f, 
    0.01635854f, -0.02406269f, -0.02664135f, -0.00689825f, 0.00176605f, -0.03880389f, 0.02526067f, -0.04236800f, 
    -0.00987922f, 0.01423356f, -0.02215333f, 0.00391725f, -0.02633460f, -0.03676946f, -0.02135359f, -0.03484837f, 
    -0.02944801f, -0.02192588f, 0.01619043f, 0.02102901f, 0.01776849f, -0.03070539f, 0.00667253f, -0.00686995f, 
    -0.03648733f, 0.01809768f, 0.01835402f, -0.00875027f, 0.00856700f, -0.03803165f, -0.00120427f, 0.00090107f, 
    -0.02751794f, -0.01897223f, -0.03388232f, -0.01589809f, -0.03119471f, -0.00248058f, -0.01645860f, 0.01838857f, 
    -0.03402704f, -0.02318798f, -0.00475254f, 0.01012435f, -0.01422095f, -0.00342147f, -0.03127834f, -0.02919439f, 
    -0.03285944f, -0.02969787f, -0.00393685f, 0.02547112f, -0.01089995f, -0.03682160f, 0.00604802f, 0.01404702f, 
    -0.03817188f, -0.04281412f, -0.01597833f, 0.00232619f, -0.03616713f, 0.01310439f, 0.02349532f, -0.03000938f, 
    0.00767247f, 0.00466749f, 0.01875921f, 0.00554496f, -0.02831114f, -0.03513821f, 0.01376715f, -0.02561620f, 
    -0.04224638f, 0.02810852f, -0.02251576f, 0.00342524f, 0.01623917f, -0.03256426f, -0.00742791f, -0.02239410f, 
    -0.00563246f, 0.02444130f, 0.01771035f, -0.01676683f, 0.02425303f, -0.01985945f, -0.00689039f, -0.04021795f, 
    0.03909086f, -0.00263469f, 0.01590461f, -0.03582577f, 0.02268766f, -0.02545554f, 0.00937624f, 0.02757377f, 
    0.01386440f, 0.02836235f, 0.02920318f, -0.03588392f, 0.00055750f, 0.02333497f, -0.00273146f, -0.02711730f, 
    -0.01798400f, -0.02214508f, 0.01909415f, -0.03946566f, -0.01909822f, 0.00415312f, 0.01415911f, -0.00979652f, 
    -0.00127569f, -0.01921742f, 0.00081902f, -0.00113634f, -0.04162619f, -0.01742499f, -0.03879605f, 0.00241302f, 
    0.02200484f, -0.00706519f, 0.00665898f, -0.04234566f, -0.00936171f, -0.04051600f, 0.02867606f, -0.01496237f, 
    0.01309810f, 0.00225019f, -0.03703218f, 0.02574836f, 0.02337579f, 0.00074635f, 0.00135825f, -0.01104796f, 
    0.02293802f, -0.00166688f, 0.01297224f, 0.00805546f, -0.03668964f, -0.00837108f, -0.01224402f, -0.00386168f, 
    -0.03633084f, 0.02041420f, 0.01874961f, -0.02735987f, -0.00663219f, -0.02681649f, 0.00695755f, 0.01191274f, 
    -0.02549430f, -0.00764325f, -0.00444753f, 0.01162298f, 0.00985352f, -0.00407197f, -0.02305903f, 0.02156762f, 
    -0.03844524f, 0.01456454f, 0.02857816f, 0.01550464f, 0.01995637f, -0.02066536f, 0.00739105f, -0.03540962f, 
    0.02797791f, 0.01298892f, 0.02469003f, 0.00829446f, -0.01704441f, -0.01551729f, -0.03411770f, -0.00383296f, 
    -0.01089575f, -0.00453133f, 0.01299321f, -0.01108341f, -0.02063830f, 0.01679559f, -0.02756794f, 0.02724799f, 
    -0.00733589f, -0.02029763f, -0.04156493f, -0.03346422f, -0.02491919f, -0.02350077f, -0.02560813f, 0.01906339f, 
    0.02874651f, -0.03965984f, -0.03998884f, 0.02059598f, 0.01171874f, -0.01808817f, -0.01133169f, 0.02959732f, 
    0.00400566f, 0.01423755f, 0.01052926f, 0.01695678f, 0.00710145f, -0.03188119f, 0.01768332f, -0.03327715f, 
    -0.02663204f, -0.02834715f, -0.03839128f, -0.01057111f, -0.00336481f, -0.03134872f, 0.00721729f, -0.00223019f, 
    -0.04010632f, 0.02643682f, 0.02372958f, 0.02290327f, -0.00112953f, -0.02543644f, -0.01455507f, 0.01355954f, 
    -0.00490455f, -0.04161905f, -0.02568456f, 0.00359435f, -0.00671725f, -0.03455646f, 0.01896366f, -0.01394739f, 
    0.01806944f, 0.02876850f, -0.00528747f, -0.03202656f, -0.01906356f, -0.03652428f, -0.03203745f, -0.02326027f, 
    -0.00660742f, -0.00710008f, 0.01431368f, -0.01930263f, 0.01116779f, -0.01796521f, -0.01036712f, -0.03717218f, 
    0.01809740f, -0.03703662f, -0.03553968f, 0.01547404f, 0.02760165f, -0.00822685f, 0.02456079f, 0.01409555f, 
    0.01196795f, -0.03495512f, -0.00123443f, -0.03811501f, -0.00552313f, 0.00122174f, -0.03124047f, -0.01733861f, 
    -0.02973607f, 0.02684391f, -0.03308285f, -0.00747284f, -0.01696650f, 0.01811376f, 0.02075456f, 0.01567297f, 
    -0.00607791f, 0.01866503f, -0.00139922f, 0.01618607f, -0.01361102f, -0.03575601f, 0.01301190f, -0.01276335f, 
    0.00679877f, 0.00705390f, 0.00356625f, 0.01247482f, -0.03963870f, -0.02338016f, -0.00948890f, -0.04165710f, 
    -0.02761195f, 0.01014270f, -0.03063205f, -0.03088189f, -0.00159721f, -0.01502636f, -0.02344650f, -0.00266708f, 
    -0.02546080f, 0.00797282f, -0.00246047f, -0.00144546f, -0.03333730f, -0.03796000f, 0.01434750f, -0.02668952f, 
    -0.03318635f, 0.01504787f, -0.02329274f, -0.03205912f, -0.00705191f, -0.03931755f, 0.00380685f, -0.03013253f, 
    0.00060603f, -0.00699405f, -0.01658793f, -0.01783730f, -0.02708904f, -0.01957743f, -0.01958452f, -0.01940511f, 
    0.01650149f, -0.00042932f, 0.01839715f, -0.03658266f, -0.01887168f, 0.00681292f, 0.02418835f, 0.01913925f, 
    0.01714067f, 0.02614398f, 0.01024438f, -0.03235426f, -0.04220301f, -0.02589712f, -0.03895358f, -0.04020651f, 
    0.02254826f, 0.02241114f, -0.04249682f, 0.02312294f, 0.01239172f, 0.00085512f, -0.00234292f, -0.02405782f, 
    -0.02852985f, -0.00537327f, -0.00037805f, 0.00034365f, 0.02236856f, 0.01228144f, 0.00113130f, 0.02321733f, 
    -0.00108861f, -0.03594379f, -0.03538410f, -0.03214706f, 0.00542609f, -0.03869154f, -0.02352730f, -0.03880057f, 
    -0.00396496f, -0.02634108f, -0.01659015f, 0.01528731f, -0.03143828f, -0.02098392f, -0.02836919f, 0.00668369f, 
    -0.03130376f, -0.02724286f, -0.03536594f, -0.03787551f, 0.00652893f, -0.00062653f, -0.04160147f, -0.04309262f, 
    -0.00275107f, 0.02283055f, 0.01674485f, -0.02330684f, 0.02740171f, -0.01302365f, 0.02435945f, -0.02090461f, 
    -0.03108325f, -0.04031645f, 0.00773943f, 0.01352495f, -0.03712447f, -0.00123123f, 0.00189791f, 0.02545592f, 
    0.02358224f, 0.00229154f, -0.02800224f, -0.04265661f, -0.02476825f, -0.03323020f, -0.04102435f, 0.01759398f, 
    -0.04244553f, -0.02931401f, -0.00073158f, 0.01637790f, 0.02079150f, 0.02386696f, 0.01903367f, -0.00202513f, 
    -0.03703462f, 0.02825383f, 0.00817634f, 0.01060196f, -0.02723400f, -0.02394811f, -0.02905139f, 0.02694680f, 
    0.02273516f, 0.01594976f, -0.02850252f, -0.03860924f, -0.00904216f, -0.02202950f, 0.00925193f, -0.03362608f, 
    0.02633433f, -0.03016462f, -0.00375170f, 0.01049987f, -0.01699103f, 0.02260394f, 0.00944618f, 0.02399301f, 
    -0.00722778f, 0.01666614f, 0.00591733f, 0.01587209f, 0.00937180f, 0.00158584f, 0.01106232f, -0.03504985f, 
    0.01457320f, -0.01376148f, -0.02157544f, -0.00926204f, -0.01532113f, 0.00239797f, 0.00876270f, 0.01366347f, 
    -0.01696656f, 0.00898591f, 0.00729216f, -0.01935840f, -0.02097454f, -0.03874269f, 0.00947716f, -0.00797382f, 
    -0.02229381f, 0.00302520f, 0.00831720f, 0.02102242f, 0.01080503f, 0.00042900f, 0.00739451f, -0.00234807f, 
    -0.02816242f, 0.00285395f, -0.03752014f, -0.01573303f, 0.02532820f, 0.02161310f, -0.01764591f, 0.00219012f, 
    -0.02856796f, -0.03207762f, -0.04149516f, 0.00343598f, -0.00501384f, -0.00316074f, -0.01945402f, 0.00812521f, 
    -0.03035802f, -0.02783116f, -0.01198678f, -0.02952961f, -0.03568453f, -0.00577247f, -0.01823629f, 0.02299825f, 
    -0.02424168f, -0.02374024f, -0.00818824f, -0.01717874f, -0.00601307f, 0.02195903f, 0.02150169f, 0.02634588f, 
    0.02775273f, -0.02919229f, 0.01444681f, 0.00218726f, 0.01875887f, 0.02566865f, -0.00206392f, -0.01221440f, 
    -0.02370891f, -0.02168917f, 0.02538774f, -0.03332409f, 0.00502399f, -0.02849101f, -0.03038080f, -0.01360424f, 
    -0.00320871f, -0.00673273f, -0.02897754f, -0.01407640f, -0.00950881f, 0.00411647f, -0.02566694f, -0.01446008f, 
    -0.01360913f, -0.03040266f, -0.01662583f, -0.00202076f, 0.01525061f, -0.00782881f, -0.01494644f, -0.02284683f, 
    0.00290812f, -0.03467570f, 0.00046064f, 0.00917223f, 0.02622434f, -0.03295841f, 0.02132163f, -0.03293234f, 
    -0.02971408f, -0.00528784f, 0.01183736f, -0.01933116f, 0.00998733f, -0.03437711f, -0.04165548f, -0.02590434f, 
    0.00346563f, -0.01853831f, 0.01664183f, -0.00298064f, 0.00373976f, 0.02456890f, 0.00087092f, 0.01710600f, 
    0.02029754f, 0.00421904f, 0.02493433f, 0.01113285f, -0.03719658f, -0.01658229f, 0.00381626f, 0.01626046f, 
    0.01483355f, -0.00396214f, -0.02259303f, -0.01842220f, 0.01937097f, 0.00022321f, 0.02116261f, -0.01275071f, 
    -0.03546900f, 0.02000495f, -0.03546026f, -0.00348687f, 0.00789236f, -0.00478887f, -0.02790327f, -0.00169012f, 
    -0.02866889f, 0.01647765f, -0.03325934f, -0.03088112f, -0.00692994f, -0.00763297f, 0.01773613f, 0.02463952f, 
    -0.01547608f, -0.01636362f, 0.01574343f, 0.02017424f, 0.01271200f, 0.02318244f, -0.04093401f, 0.01907246f, 
    -0.03495033f, 0.00301304f, 0.00670734f, 0.01984700f, 0.02741227f, 0.01983395f, -0.02363475f, 0.00705978f, 
    -0.03948784f, 0.02272469f, 0.00390625f, 0.00030011f, -0.03377292f, 0.00830613f, 0.01131196f, 0.00370374f, 
    -0.02000418f, -0.00023999f, -0.00262672f, 0.00262889f, -0.02326997f, -0.01946361f, -0.01799799f, -0.02287458f, 
    -0.00236344f, 0.01671228f, 0.02638972f, -0.00154823f, 0.00603504f, -0.02685553f, -0.03155769f, -0.00312204f, 
    0.00654192f, 0.02152000f, -0.03122660f, 0.00504232f, -0.03548455f, 0.00156591f, 0.02955423f, -0.03093210f, 
    0.02069058f, -0.02047639f, -0.04573999f, 0.00371324f, 0.01095756f, -0.00415535f, 0.02949297f, -0.01270110f, 
    0.00290304f, -0.01073111f, -0.04032710f, 0.00216354f, -0.00605470f, 0.02294662f, -0.03902002f, -0.02349836f, 
    -0.02618122f, 0.01585060f, 0.01538515f, -0.00630014f, 0.01785888f, -0.03616505f, 0.02638860f, 0.01806389f, 
    -0.02522235f, 0.02902285f, -0.03341794f, 0.03250261f, 0.00069640f, -0.01397698f, -0.02415288f, 0.00483103f, 
    -0.00605292f, -0.01059877f, 0.00925767f, -0.03022589f, 0.02643200f, -0.01397111f, -0.01111603f, -0.00240982f, 
    -0.02168421f, -0.02726042f, 0.03431799f, 0.01891706f, 0.01838248f, -0.03402326f, 0.02308812f, -0.02179666f, 
    0.02269510f, -0.03551921f, -0.00990874f, 0.02059792f, 0.01480330f, -0.00197701f, 0.02828325f, 0.02545262f, 
    0.00556523f, -0.02045218f, -0.00651208f, -0.00085245f, 0.01400332f, -0.03033094f, -0.02239259f, -0.02956267f, 
    -0.04185757f, 0.02885267f, -0.02649306f, -0.01883657f, 0.01913635f, 0.01348474f, -0.02454193f, -0.03924916f, 
    0.00707152f, -0.00435237f, 0.01044763f, 0.01196786f, 0.01344595f, -0.00662550f, -0.02551950f, -0.03642095f, 
    -0.00700948f, 0.02720269f, 0.02103626f, 0.00076934f, -0.01678960f, 0.02187945f, 0.01835332f, -0.00607221f, 
    0.01044044f, 0.00691201f, -0.01342170f, -0.04176552f, -0.01101200f, 0.01053583f, 0.00541504f, 0.00845428f, 
    -0.01620729f, 0.01506121f, -0.02740238f, 0.02148257f, 0.00453227f, 0.02269088f, 0.01931842f, -0.02440861f, 
    0.00457131f, 0.00241407f, -0.02846351f, 0.02347939f, 0.01669110f, -0.01020279f, 0.02244845f, -0.03681185f, 
    -0.03054755f, -0.02781796f, -0.01357098f, -0.00967591f, 0.02271624f, -0.02729798f, -0.03526665f, -0.00651987f, 
    0.01536860f, -0.04433749f, -0.01206363f, -0.02173945f, -0.00075228f, 0.04311289f, -0.02466805f, -0.02736254f, 
    0.02043587f, 0.00691377f, -0.00093257f, 0.01418168f, 0.02810809f, -0.01617747f, -0.00179483f, 0.01908156f, 
    -0.00731584f, -0.00992262f, -0.03154514f, -0.02037510f, 0.00054984f, -0.00677331f, -0.00231190f, 0.02627945f, 
    -0.02216919f, -0.04029811f, -0.00917605f, -0.00126260f, -0.04269788f, 0.00751527f, 0.01533438f, -0.00802400f, 
    -0.01093803f, -0.04036506f, -0.01119700f, 0.01112007f, -0.00530995f, -0.01975222f, 0.00713136f, 0.01683397f, 
    0.01314417f, 0.02417493f, 0.03258209f, 0.00875408f, -0.00803288f, 0.02483881f, -0.02161037f, 0.00014755f, 
    0.01846347f, -0.01799398f, 0.01572388f, 0.02817858f, -0.00755105f, -0.02113758f, -0.00367053f, 0.01186731f, 
    0.00525948f, 0.03372936f, 0.02041373f, 0.02231983f, 0.01531667f, 0.01133037f, -0.00136546f, -0.02546685f, 
    0.02746669f, 0.01417968f, 0.00988513f, 0.02900441f, -0.03385121f, 0.01022088f, -0.03801019f, -0.02547495f, 
    0.00784636f, -0.02244804f, -0.00510610f, -0.03797618f, -0.00156324f, -0.03827545f, -0.01180723f, -0.03945902f, 
    0.01962676f, 0.02883954f, 0.01024734f, 0.00462076f, 0.02478281f, -0.03037263f, -0.03393793f, 0.02386828f, 
    0.02331211f, -0.01704733f, -0.00423080f, 0.00598811f, 0.01926197f, -0.03295401f, -0.02024660f, -0.01925493f, 
    0.00642319f, -0.04496099f, 0.02598818f, 0.01944625f, -0.00545113f, -0.02461688f, 0.02655687f, 0.00223050f, 
    0.02475997f, -0.01773721f, -0.01253082f, 0.00759268f, -0.01227695f, -0.01931237f, -0.02224689f, -0.03790677f, 
    -0.03289002f, -0.03304603f, -0.00406944f, -0.00361707f, -0.03094613f, -0.01882985f, -0.01828276f, 0.01891109f, 
    -0.00149593f, 0.00766680f, -0.00721524f, -0.01157361f, 0.00514844f, 0.02392713f, -0.00965669f, -0.03228383f, 
    -0.01700216f, -0.02955019f, -0.00704972f, 0.01003170f, -0.00540254f, 0.01195137f, 0.02235457f, -0.03730967f, 
    -0.00407920f, -0.02125412f, -0.00719508f, 0.01070323f, -0.00856836f, 0.01935865f, -0.00649302f, -0.03667607f, 
    -0.00298271f, 0.00864161f, 0.00483029f, 0.02164013f, 0.00501486f, -0.02987145f, 0.01607211f, 0.01585864f, 
    -0.01043067f, -0.01689968f, 0.01754629f, -0.00270760f, 0.02343440f, 0.00257244f, -0.02591257f, -0.02002796f, 
    0.01397933f, 0.01408123f, -0.01140383f, -0.01712403f, 0.02885945f, -0.02269636f, 0.04077708f, 0.00872121f, 
    -0.02777485f, -0.01625276f, -0.02714810f, -0.03206339f, 0.01074602f, 0.00922143f, 0.01512738f, -0.00311361f, 
    -0.02739256f, -0.02554329f, 0.02352216f, 0.01207673f, 0.01630077f, 0.02435637f, 0.02626128f, -0.02893117f, 
    0.02187695f, -0.02585641f, 0.01541115f, -0.00730629f, 0.01119976f, 0.00964387f, 0.00562631f, -0.00744588f, 
    0.03043490f, -0.01893919f, -0.02215321f, -0.00246800f, -0.04360066f, 0.00396458f, -0.02084631f, -0.03760757f, 
    0.02391406f, 0.00271132f, -0.02520524f, -0.01635034f, -0.01787726f, -0.03455543f, 0.01799192f, -0.01948184f, 
    -0.04164337f, 0.00215120f, -0.00628254f, 0.01932128f, -0.02749740f, -0.03271450f, 0.02380855f, -0.01691770f, 
    -0.01165814f, -0.02957083f, 0.01288513f, -0.03734602f, -0.02862141f, -0.00895997f, -0.00809789f, -0.01965446f, 
    0.00621966f, -0.00329633f, 0.00319895f, -0.01160155f, -0.00152821f, -0.01177707f, 0.03116438f, -0.04381808f, 
    -0.02125485f, -0.02805695f, -0.01853114f, -0.00354490f, -0.03896285f, 0.00611514f, 0.02112167f, 0.02144879f, 
    -0.01086874f, -0.00920752f, 0.02469933f, 0.02440070f, -0.04450721f, -0.00974780f, 0.00917456f, -0.04117306f, 
    -0.01979327f, -0.02485687f, -0.00655351f, 0.03412165f, -0.00992631f, -0.00755861f, -0.01857305f, -0.00589171f, 
    0.00526788f, 0.02955626f, -0.00276859f, 0.01323568f, -0.01112280f, 0.00924687f, 0.00552148f, 0.01152611f, 
    -0.01627798f, 0.02555560f, -0.00468339f, 0.01628756f, -0.01882651f, -0.02063476f, -0.02717868f, -0.02835417f, 
    0.00930100f, -0.01874468f, 0.01083728f, -0.02574024f, -0.02860062f, -0.03875058f, 0.00344130f, 0.01385602f, 
    -0.02424551f, -0.02995848f, -0.00008694f, 0.03459443f, 0.01692654f, -0.03948978f, -0.02735575f, 0.01721954f, 
    0.02548197f, 0.00618290f, 0.01700630f, -0.02781408f, -0.01726403f, 0.02700372f, -0.01099016f, 0.02869352f, 
    0.00083893f, 0.02284944f, 0.03337172f, -0.01501048f, 0.02315157f, 0.02471198f, 0.00323901f, 0.01477053f, 
    -0.03285573f, 0.02976206f, 0.02514358f, -0.00022620f, -0.00615406f, -0.03478466f, -0.00173318f, -0.03249279f, 
    -0.00943028f, -0.00041747f, 0.01757788f, -0.00090854f, -0.01787963f, 0.00090376f, -0.02555218f, 0.01898981f, 
    -0.03392203f, 0.01142907f, 0.02177556f, 0.02127589f, -0.00731034f, -0.00884571f, -0.02757009f, 0.01078221f, 
    -0.03231591f, 0.02257986f, 0.01853124f, -0.01579646f, 0.03662153f, -0.03201013f, 0.01061530f, -0.02028515f, 
    -0.03320400f, -0.02450771f, 0.02232044f, 0.02465901f, -0.02977476f, 0.01310910f, 0.01788090f, 0.02649603f, 
    0.00933309f, -0.01415024f, -0.02295320f, -0.01726629f, -0.01213132f, 0.00028272f, 0.01486304f, -0.01783529f, 
    0.02282198f, -0.01364428f, 0.03041984f, 0.01547093f, 0.01151839f, -0.02493319f, -0.03261789f, -0.02329619f, 
    -0.02397048f, -0.03315759f, -0.01949917f, 0.00976573f, 0.02264814f, 0.00417385f, -0.00690765f, 0.01084447f, 
    -0.03144829f, -0.01758814f, 0.00432858f, 0.02943967f, -0.04061040f, 0.01016245f, 0.01125407f, 0.02785243f, 
    0.00207905f, -0.01158462f, -0.02015455f, 0.02889300f, -0.00898671f, -0.02772681f, 0.01503759f, -0.02200095f, 
    0.01109413f, -0.02420206f, 0.00352448f, 0.00791515f, -0.01886261f, 0.02649794f, 0.02707850f, -0.00145443f, 
    -0.03302421f, 0.02811839f, 0.00051174f, 0.00267697f, -0.02900924f, 0.02219349f, -0.03784859f, 0.02114240f, 
    0.01413911f, 0.00766517f, -0.03517736f, 0.00851307f, 0.00487634f, -0.03323798f, -0.02297287f, 0.01699615f, 
    -0.02427409f, 0.00697137f, 0.01898557f, -0.03579279f, 0.01356683f, -0.01541349f, 0.00591511f, -0.02193621f, 
    -0.01223713f, 0.00412603f, 0.02042690f, -0.03052427f, -0.02237127f, 0.02893412f, -0.00767950f, 0.01968988f, 
    -0.00958553f, 0.01710140f, -0.03693071f, -0.03187002f, 0.01956817f, 0.01729336f, 0.00548408f, -0.01491469f, 
    -0.03599167f, 0.02438232f, -0.04087557f, -0.02648610f, 0.00837671f, -0.01503977f, -0.04007068f, -0.02428349f, 
    -0.02519426f, -0.01671926f, -0.02570603f, -0.00879536f, -0.03883341f, -0.03601537f, -0.03946720f, -0.00081288f, 
    -0.03357141f, 0.01937710f, 0.03312418f, 0.02127186f, -0.00576331f, -0.02478795f, -0.03690495f, -0.01076068f, 
    0.02238115f, 0.02710033f, 0.02365808f, 0.01299936f, -0.02345335f, -0.00735171f, 0.01085323f, 0.02594022f, 
    -0.00525153f, 0.01503672f, 0.03015400f, -0.00060635f, -0.01854269f, 0.02583401f, -0.02496850f, -0.00522192f, 
    0.00200215f, 0.02515782f, 0.02260311f, -0.04255148f, 0.04214881f, -0.00654004f, 0.03378037f, -0.02601944f, 
    -0.01301316f, 0.00088521f, 0.01291312f, -0.00291742f, 0.02249233f, -0.00514561f, 0.01865822f, -0.03818287f, 
    -0.00178371f, -0.01844246f, -0.00407485f, 0.01440663f, 0.01942078f, 0.01191222f, 0.01866816f, -0.01414646f, 
    0.01967831f, -0.03395028f, 0.00271720f, 0.02948198f, -0.04298317f, -0.01045478f, 0.01769527f, 0.00513946f, 
    -0.01734690f, -0.00279387f, 0.01792577f, -0.00479247f, -0.01839297f, -0.02768054f, -0.00994930f, -0.00623481f, 
    -0.03646068f, -0.03636622f, -0.03153545f, 0.02518150f, 0.02449730f, 0.00329115f, -0.00866547f, -0.02456551f, 
    -0.00331005f, 0.00025603f, 0.00347640f, 0.00607640f, 0.01064323f, 0.00861606f, -0.01925709f, 0.01658792f, 
    0.00169382f, -0.01057403f, -0.04341415f, -0.00533266f, 0.00320572f, -0.03112759f, -0.00373270f, 0.02874262f, 
    -0.03105576f, -0.00694456f, -0.00560725f, -0.04317586f, -0.02367234f, -0.02585316f, 0.02764193f, 0.00193198f, 
    0.02870168f, -0.02890994f, 0.01415239f, 0.00698786f, 0.02604116f, 0.03631583f, 0.02375887f, -0.00369611f, 
    -0.03656959f, 0.00517618f, 0.00156308f, 0.00229726f, -0.03658061f, -0.03251523f, -0.00985346f, 0.01072585f, 
    -0.04255987f, -0.00966504f, -0.00779085f, -0.01619537f, -0.00555974f, 0.03269552f, -0.02900591f, -0.01846868f, 
    -0.02095086f, -0.02598495f, 0.02044483f, -0.00310801f, -0.00250861f, 0.00222758f, -0.01537616f, -0.01865303f, 
    -0.02072481f, -0.03368012f, -0.04125547f, 0.03338603f, -0.02865133f, -0.01014763f, -0.03948484f, 0.01253502f, 
    -0.00543493f, 0.02536406f, -0.02419082f, -0.00696860f, 0.02545142f, 0.00498039f, 0.02014961f, 0.00843427f, 
    -0.04036781f, 0.02973632f, 0.01120406f, -0.03179913f, -0.04112874f, 0.01586290f, 0.01645783f, 0.01878332f, 
    0.00349470f, 0.01016373f, -0.02625053f, 0.02309506f, 0.00940026f, -0.00082435f, 0.00928963f, -0.00734335f, 
    -0.04000741f, 0.00211598f, 0.00313158f, 0.00567582f, 0.02981731f, -0.00263133f, 0.00317324f, -0.03000094f, 
    0.02445439f, -0.02112097f, -0.01415705f, 0.02200017f, -0.02003246f, -0.03805980f, -0.03647461f, 0.01082041f, 
    0.01777076f, -0.00404326f, -0.02186687f, -0.02190193f, 0.00803571f, -0.00850417f, -0.04212115f, -0.02209507f, 
    0.01132603f, 0.01761147f, -0.01325074f, -0.01495057f, 0.01841293f, 0.01928804f, 0.00986050f, -0.01038107f, 
    0.01542643f, -0.00279405f, 0.01908102f, -0.01790575f, -0.02830739f, -0.01611382f, 0.01630023f, 0.02257862f, 
    -0.01619316f, -0.03550321f, -0.03961006f, 0.02619432f, -0.02934310f, -0.02246443f, -0.00876283f, 0.00289269f, 
    -0.00660081f, -0.04052686f, -0.03861482f, 0.02911011f, -0.00326872f, 0.00073730f, 0.00893460f, -0.01114578f, 
    -0.01785762f, 0.02473251f, -0.01051261f, -0.01322368f, -0.03177314f, 0.01679927f, 0.02693224f, 0.01845516f, 
    -0.00925817f, 0.00968067f, 0.02083930f, 0.01126991f, 0.01024593f, -0.01325171f, 0.02871032f, 0.02372290f, 
    -0.03402479f, -0.03581571f, 0.00785398f, -0.01129935f, -0.04032516f, -0.02585448f, -0.02691473f, 0.02174079f, 
    0.02491499f, 0.01084223f, -0.01716694f, -0.03277833f, 0.00334218f, -0.00450187f, -0.00711214f, -0.01627437f, 
    -0.01506589f, -0.00722687f, 0.00438473f, -0.03938933f, -0.01228921f, -0.01477059f, 0.01231583f, 0.01346680f, 
    -0.00617645f, 0.00843831f, -0.00134280f, -0.03906135f, 0.01884377f, -0.00671329f, 0.00185409f, 0.02099256f, 
    0.00222529f, 0.00546202f, 0.01575977f, 0.00983458f, -0.01972031f, -0.00497748f, -0.02598244f, 0.00692051f, 
    -0.02500940f, -0.03489481f, -0.01405669f, -0.03857686f, 0.02458996f, 0.01710909f, 0.00273973f, -0.01603920f, 
    0.02178064f, 0.02511823f, -0.01277798f, -0.01552582f, 0.02212733f, -0.00409894f, 0.02476434f, 0.02711998f, 
    -0.01048176f, -0.03687938f, 0.02324083f, 0.01881858f, -0.00971350f, -0.02510680f, -0.00870381f, 0.00645850f, 
    -0.02413873f, -0.00169056f, -0.02386647f, -0.03364066f, 0.02604028f, -0.01599506f, 0.00922180f, -0.02371149f, 
    -0.00648910f, -0.03311564f, -0.00563115f, -0.02938660f, -0.01527722f, -0.01431727f, -0.01336290f, -0.03085229f, 
    -0.02628970f, 0.03653166f, -0.02598224f, -0.00633632f, 0.00565731f, -0.01984636f, 0.01656101f, -0.03509060f, 
    0.02897393f, -0.03387304f, 0.00688119f, 0.01755903f, -0.02576818f, -0.01790662f, 0.03014129f, 0.01768327f, 
    0.00434415f, 0.01500260f, -0.01064098f, -0.02860614f, -0.01463118f, 0.00333195f, -0.02819071f, -0.01090923f, 
    -0.03403886f, -0.01762637f, -0.00679299f, -0.02365959f, -0.01086423f, -0.00498034f, 0.00115002f, -0.00804047f, 
    -0.01997799f, -0.04164487f, 0.01540002f, -0.02285714f, -0.04261975f, -0.00168570f, -0.03238553f, -0.02638297f, 
    0.01471960f, 0.02635138f, 0.01173959f, -0.02867598f, -0.02230578f, -0.03158423f, -0.01533253f, -0.02944929f, 
    0.01585751f, 0.00400261f, -0.03685948f, -0.02523977f, -0.01708687f, -0.00398570f, -0.00533017f, -0.01527928f, 
    0.02917551f, 0.02413739f, -0.01073002f, 0.00965654f, -0.03451075f, -0.00310195f, -0.00483891f, -0.03103290f, 
    0.01155728f, -0.00987096f, -0.01450632f, 0.01366515f, -0.02983244f, 0.01302282f, 0.00476298f, 0.01516356f, 
    -0.03285472f, -0.03145190f, 0.03065050f, -0.03438697f, 0.01924622f, 0.02392888f, -0.01495608f, -0.03660068f, 
    -0.00040430f, -0.01114574f, 0.01146841f, -0.02595825f, -0.03721531f, -0.00896149f, 0.01093164f, -0.00803441f, 
    -0.03597059f, -0.00357376f, 0.00012000f, -0.02085983f, -0.01452013f, -0.02923109f, -0.02928281f, -0.00446060f, 
    -0.01671118f, -0.02215607f, 0.02864094f, 0.02691195f, -0.02951512f, -0.03457466f, 0.01849953f, 0.01461238f, 
    -0.04262425f, -0.00200563f, 0.01194399f, -0.00782715f, -0.00077758f, -0.01051812f, -0.03659434f, 0.02154827f, 
    0.01637195f, -0.01549496f, 0.01044540f, 0.01358951f, 0.02956439f, -0.02379237f, 0.01858442f, -0.02499248f, 
    -0.00645993f, 0.01251036f, -0.01324861f, -0.02383612f, -0.02757899f, -0.02654686f, -0.01710732f, -0.00798761f, 
    -0.01818494f, 0.02698977f, -0.01882077f, -0.03293502f, -0.01379226f, 0.01369060f, -0.01601593f, -0.02342369f, 
    0.01503285f, -0.02437978f, -0.02883805f, -0.03731255f, -0.03588839f, 0.02098802f, -0.00913033f, -0.01730070f, 
    0.02314531f, -0.02575655f, 0.00243393f, 0.02452346f, 0.00491828f, -0.04319309f, -0.03854262f, 0.00725450f, 
    -0.02911734f, -0.03392847f, 0.00196133f, -0.01153832f, -0.03650166f, 0.00694344f, -0.01094070f, -0.01772912f, 
    -0.03706526f, 0.00068280f, -0.03050365f, -0.01904208f, 0.02032384f, -0.02920678f, -0.02626773f, -0.03758322f, 
    0.00407471f, -0.03034894f, -0.03727944f, 0.01278141f, -0.01317012f, -0.03394904f, 0.01106629f, 0.00067595f, 
    -0.00870620f, 0.01371505f, -0.02821755f, 0.00238595f, -0.01809173f, 0.00891882f, -0.02528932f, 0.02834822f, 
    0.02605387f, -0.02503574f, -0.00842636f, -0.03696307f, 0.01131146f, -0.01514869f, -0.03378551f, -0.03800304f, 
    0.02593330f, -0.02438143f, -0.03171352f, 0.00808633f, -0.02561787f, -0.02776413f, 0.01748965f, 0.02499580f, 
    -0.01211941f, 0.02314109f, -0.00231433f, 0.01954711f, 0.00839323f, 0.01332536f, -0.04207831f, 0.01543345f, 
    -0.02333113f, -0.04263953f, -0.01192327f, -0.00164900f, -0.00963384f, 0.01607285f, 0.01518664f, -0.02734711f, 
    0.00825021f, -0.02436542f, -0.03508134f, -0.03353613f, -0.02956364f, 0.01276790f, -0.01511826f, -0.03019742f, 
    0.02712315f, -0.02733849f, -0.02917553f, -0.03651450f, -0.00302940f, 0.00935140f, -0.02807264f, 0.02325587f, 
    0.01483626f, 0.01418953f, -0.02725321f, 0.03027779f, -0.00828294f, 0.02363037f, -0.01354517f, -0.02332433f, 
    -0.01154051f, -0.02213580f, 0.02352922f, 0.02488118f, 0.00886738f, -0.00174328f, 0.01639783f, -0.03602075f, 
    -0.01739232f, 0.02161568f, 0.03132909f, -0.01639767f, -0.01895520f, 0.01488598f, -0.01514181f, -0.00904089f, 
    -0.02424015f, -0.00732820f, 0.00431172f, -0.01542295f, -0.01910880f, -0.00659489f, -0.01992068f, -0.04125446f, 
    -0.02457468f, 0.00787894f, -0.02032262f, -0.01619412f, 0.02055597f, -0.03851941f, -0.02021720f, -0.02799366f, 
    0.02433747f, -0.02689996f, 0.01604297f, -0.00070248f, -0.01369043f, -0.01398420f, 0.01944855f, -0.00787606f, 
    -0.01823260f, -0.01851474f, 0.02627593f, 0.00176130f, 0.01275570f, -0.03002451f, -0.04079720f, -0.02618086f, 
    -0.02198958f, -0.00558835f, 0.00221205f, -0.03168688f, 0.02539147f, -0.01073712f, -0.01101940f, -0.02157612f, 
    -0.03685815f, -0.02519646f, -0.00005080f, -0.01164257f, -0.02311181f, -0.02704296f, -0.01838285f, -0.00837649f, 
    -0.00850551f, 0.00743744f, 0.02779792f, -0.00135084f, 0.01451997f, 0.00011999f, 0.00142306f, 0.02147025f, 
    0.00685553f, 0.01453238f, 0.02485506f, 0.00086958f, 0.01230187f, -0.01928347f, -0.00100618f, -0.02185613f, 
    -0.00136802f, -0.02705357f, -0.01538098f, -0.01508763f, -0.00650277f, 0.01275773f, -0.01364844f, -0.00158703f, 
    0.01578044f, 0.01974183f, -0.00334682f, -0.00339009f, -0.03646271f, -0.02497842f, -0.01281395f, -0.02826102f, 
    0.00278185f, 0.01003186f, -0.00477096f, 0.02255321f, 0.00052131f, -0.03334752f, 0.00151909f, -0.01301161f, 
    -0.01963375f, 0.02364383f, 0.02235441f, 0.00651017f, -0.01940467f, -0.03511188f, 0.01771569f, -0.01515924f, 
    -0.00565066f, 0.01387895f, 0.01372330f, -0.03479861f, -0.03578670f, -0.03500010f, -0.00014720f, -0.02737913f, 
    -0.00730729f, 0.02806082f, -0.00673547f, 0.02624627f, -0.03422360f, -0.04154225f, 0.02106271f, -0.01975175f, 
    0.01725350f, 0.01387970f, 0.02252459f, 0.02684794f, -0.03279838f, 0.02934608f, 0.00777140f, 0.01224541f, 
    0.02366457f, 0.01651224f, -0.01602789f, 0.00566662f, 0.01267410f, -0.01529320f, -0.02171481f, 0.02865426f, 
    0.01935099f, -0.03813295f, 0.01820997f, -0.01792176f, -0.03440715f, 0.00831542f, 0.02918180f, 0.01093656f, 
    0.02842207f, 0.01842267f, -0.01348454f, -0.03588132f, -0.00997287f, 0.00374563f, 0.01997548f, 0.02841056f, 
    0.00682549f, 0.02502260f, -0.02272168f, -0.00466582f, -0.00074122f, 0.01327264f, 0.00035274f, 0.01266258f, 
    0.02389409f, 0.00945965f, -0.03638651f, -0.01374264f, -0.01385715f, 0.00729239f, -0.04118025f, 0.02193501f, 
    -0.03681130f, 0.02558021f, -0.00929693f, -0.02466053f, -0.04027088f, -0.02649664f, 0.01895102f, 0.01219966f, 
    -0.02606979f, 0.00810161f, -0.02571532f, -0.01122967f, 0.02392297f, 0.01168147f, -0.00297404f, -0.00581903f, 
    -0.01305203f, 0.02768189f, 0.00332323f, 0.01195593f, 0.00123690f, -0.03125146f, -0.03338669f, -0.00452899f, 
    0.02030056f, 0.02928668f, -0.02184288f, 0.00497336f, -0.01449921f, -0.03299361f, 0.00840937f, 0.01333177f, 
    -0.00501389f, 0.01838367f, 0.02778716f, 0.02505300f, -0.03919049f, 0.01805698f, 0.00574497f, -0.00674081f, 
    -0.03059539f, -0.01411842f, -0.02328715f, 0.01192303f, 0.01387440f, -0.02835120f, 0.02553930f, -0.02751506f, 
    -0.02075005f, 0.00465307f, -0.00776096f, -0.01055809f, 0.02259751f, -0.01367689f, 0.02731954f, -0.03438087f, 
    -0.01386961f, 0.02134787f, 0.02210009f, -0.01123169f, -0.03770475f, -0.02646573f, -0.02786158f, 0.00451040f, 
    -0.00537281f, 0.02797965f, 0.01667363f, 0.00776608f, -0.02848065f, 0.01485539f, -0.02596596f, -0.02848906f, 
    0.02830947f, -0.02386287f, -0.00857198f, -0.02315204f, -0.02593739f, -0.03158571f, -0.02210007f, -0.03782878f, 
    0.00409861f, 0.00296370f, 0.02392797f, -0.02912797f, -0.01205130f, -0.02767901f, -0.02532756f, 0.02810265f, 
    0.00224941f, 0.02290197f, -0.00883393f, -0.04174964f, -0.02936346f, 0.00340183f, -0.00286132f, -0.04222601f, 
    -0.03848299f, -0.02351174f, -0.01027446f, 0.01680266f, 0.02943918f, 0.01782986f, -0.03415785f, -0.01875263f, 
    0.00576229f, -0.00337664f, 0.00835102f, -0.02709699f, 0.02481184f, -0.00938920f, -0.00675835f, -0.02519167f, 
    -0.01813323f, -0.02837330f, -0.02896766f, -0.01227808f, 0.01535320f, -0.01364849f, -0.01413039f, -0.03775088f, 
    -0.00400813f, -0.03529109f, -0.00020640f, 0.01480115f, -0.02825776f, -0.01793551f, 0.01760673f, 0.00183656f, 
    -0.01935767f, 0.00022557f, -0.03866623f, 0.00956446f, -0.01128082f, -0.00343791f, 0.01685888f, -0.02580629f, 
    0.03283706f, 0.01294888f, -0.01088789f, -0.02515650f, 0.02544321f, 0.01377946f, -0.00930090f, -0.03520339f, 
    -0.00139160f, 0.02573685f, -0.01860925f, -0.03499813f, 0.00106459f, -0.02968821f, 0.01549047f, 0.00215537f, 
    0.00417160f, 0.00989203f, 0.02824851f, 0.00570712f, -0.03609458f, -0.02535602f, -0.03144347f, -0.03289456f, 
    0.00267063f, 0.01865296f, -0.02653613f, 0.02413660f, -0.02199039f, -0.03514287f, -0.03240945f, -0.02196491f, 
    0.01634161f, -0.03846192f, -0.03624414f, -0.03562209f, -0.03661976f, 0.00042686f, 0.02798585f, 0.02507833f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00512936f, 0.01088665f, 0.10570415f, 0.00777075f, 0.01903082f, -0.02273097f, -0.03544869f, -0.00521720f, 
    -0.02802004f, -0.02807687f, 0.06178534f, -0.01685963f, -0.04362198f, -0.02797741f, -0.02579132f, 0.01823973f, 
    0.00509323f, -0.00435148f, -0.02331680f, 0.11086138f, 0.04906505f, 0.00301312f, 0.02745898f, -0.03840838f, 
    -0.02230710f, -0.05067137f, 0.02360726f, 0.06420941f, -0.01335867f, 0.00103140f, -0.02557053f, -0.03395948f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.32305849f, 0.23145708f, -0.05018601f, 0.12346870f, -0.02888231f, -0.08749156f, 0.45446667f, -0.13211791f, 
    -0.17915724f, -0.09221625f, -0.70630294f, -0.00431301f, 0.31680045f, 0.14749905f, 0.12159770f, -0.04720103f, 
    -0.11185665f, 0.14120534f, -0.08327793f, -0.40512198f, -0.08613025f, 0.16150795f, -0.13584517f, -0.03015840f, 
    -0.04903501f, 0.10668217f, 0.11807521f, -0.06011377f, -0.01179851f, 0.12903017f, -0.17118713f, -0.10616834f, 
    -0.25391859f, 0.27199489f, -0.17027414f, -0.14787836f, -0.11870375f, -0.01165274f, -0.16702947f, -0.01776931f, 
    0.02706107f, 0.12361391f, -0.35730061f, 0.03809877f, -0.26398912f, 0.02884342f, 0.01300772f, 0.09876952f, 
    0.14875181f, -0.14646831f, -0.04379967f, -0.01556555f, -0.00510565f, -0.11497368f, 0.00710016f, -0.65730751f, 
    0.14078067f, 0.38277519f, 0.15768686f, 0.18770385f, -0.16089861f, -0.08927067f, -0.01900520f, 0.09088324f, 
    -0.08475094f, -0.29545981f, -0.11756455f, -0.17118543f, 0.09472910f, -0.02864339f, -0.46006581f, -0.14375238f, 
    0.14245865f, -0.15890391f, -0.16229142f, 0.11046263f, 0.38807487f, -0.10696887f, -0.14699590f, -0.01197780f, 
    -0.60920507f, -0.15722813f, 0.08484750f, -0.28200436f, 0.25156724f, 0.13650453f, 0.03068932f, -0.05550030f, 
    0.00207109f, 0.36720383f, 0.00114507f, 0.15586276f, 0.13063255f, 0.02147030f, 0.17427927f, 0.02577576f, 
    0.32718006f, 0.08523608f, 0.04476873f, 0.12816747f, -0.00000646f, 0.07669314f, 0.34452024f, 0.09031850f, 
    0.14552236f, -0.01554125f, 0.18036115f, 0.02297861f, 0.29840675f, -0.02414637f, -0.02056027f, 0.14115374f, 
    -0.04136946f, -0.15034726f, 0.12167051f, 0.24231713f, -0.55634725f, -0.12004138f, 0.11904288f, 0.08391247f, 
    -0.11675779f, -0.23727284f, 0.10987034f, -0.25901183f, 0.05076239f, 0.10032596f, 0.03080248f, 0.14533295f, 
    0.00188871f, -0.05374695f, 0.16357711f, 0.11945180f, -0.14694113f, -0.07224880f, -0.22907707f, -0.03156919f, 
    -0.12774538f, -0.05329023f, -0.11422269f, 0.07521949f, -0.05155978f, 0.11304878f, 0.11818584f, 0.04249241f, 
    0.36845478f, -0.14181061f, 0.10734928f, -0.04547391f, -0.41136849f, 0.01476477f, 0.14553148f, 0.51152796f, 
    -0.10005159f, 0.12886143f, -0.16283329f, 0.02900227f, -0.16635367f, -0.15295190f, 0.11938602f, 0.09305836f, 
    -0.36740595f, 0.51340032f, -0.13833918f, 0.16077806f, 0.16589400f, -0.06026481f, -0.17659236f, 0.05263092f, 
    -0.12553300f, -0.08780783f, -0.01770000f, 0.08516566f, -0.02159642f, -0.05652914f, -0.06166478f, 0.05091491f, 
    0.15851490f, -0.06599974f, 0.04992433f, -0.05797192f, 0.08075552f, -0.02170287f, -0.00983100f, 0.21158998f, 
    0.10182776f, -0.50106579f, 0.08737760f, -0.08107456f, -0.04765712f, 0.02445928f, 0.16835342f, -0.12197625f, 
    0.15714604f, -0.12683043f, 0.05817119f, -0.01345353f, 0.12750438f, -0.01393377f, -0.30587381f, 0.09686176f, 
    0.13050115f, 0.11832470f, 0.24578220f, -0.10959649f, 0.04118619f, -0.16521512f, 0.15413286f, -0.17610024f, 
    0.17737027f, -0.09422405f, 0.10817009f, -0.62475216f, 0.08840975f, 0.14450651f, 0.16375078f, -0.53861934f, 
    0.15283448f, -0.51899338f, 0.15406194f, 0.23433851f, -0.01697810f, 0.06806990f, 0.05394071f, -0.09978633f, 
    -0.45250213f, -0.28226948f, -0.42185688f, 0.10192242f, -0.09650613f, -0.02733266f, 0.17962712f, -0.13198300f, 
    -0.16671579f, 0.08057387f, 0.37737128f, -0.09690424f, 0.25660267f, -0.08309975f, -0.09671967f, -0.00607833f, 
    0.14217784f, -0.13186805f, 0.08611676f, -0.30816278f, -0.15404667f, 0.03976185f, 0.14529449f, 0.41285431f, 
    -0.06751004f, 0.01380256f, -0.06225409f, -0.04786571f, -0.08752568f, -0.14552644f, 0.07546523f, -0.04619787f, 
    0.32763848f, 0.13903531f, -0.77608907f, 0.00366007f, 0.14677866f, 0.05754569f, -0.29953799f, 0.02463280f, 
    -0.09770045f, -0.03753756f, -0.06090207f, -0.02722570f, -0.39432880f, 0.13189439f, 0.09228440f, 0.02740797f, 
    0.01635279f, 0.11930153f, 0.08586853f, 0.38876823f, 0.27343112f, -0.11035466f, 0.05290458f, 0.05850913f, 
    -0.03517211f, -0.02089731f, -0.12152948f, -0.16195171f, 0.04567497f, 0.15396763f, -0.07797460f, -0.05816225f, 
    0.35877389f, -0.20298462f, 0.17827438f, -0.12773591f, -0.09777855f, 0.13788424f, 0.34151027f, -0.00599831f, 
    0.05100466f, 0.14637381f, 0.08272777f, -0.17491175f, -0.69354486f, -0.16028136f, 0.11776882f, -0.10481725f, 
    -0.19394530f, 0.10119667f, 0.15057011f, -0.55857587f, 0.16584073f, -0.01018907f, 0.06871773f, 0.16699113f, 
    -0.00687661f, 0.18157955f, 0.13207591f, -0.06696532f, -0.07324705f, 0.10038149f, -0.10513559f, -0.15670121f, 
    -0.53199905f, -0.29570767f, 0.08639068f, -0.07715259f, -0.11341447f, 0.05239713f, 0.22664417f, 0.12241757f, 
    0.04946451f, 0.02976108f, 0.19454627f, 0.00435228f, 0.04327426f, -0.08630398f, 0.08605180f, 0.15003885f, 
    -0.58420414f, 0.12415014f, -0.11577094f, 0.31793451f, -0.17244901f, 0.06438058f, -0.17442285f, -0.16310358f, 
    -0.09678480f, -0.38254938f, -0.00670215f, 0.29884231f, -0.05753578f, 0.15349624f, -0.10849967f, -0.06837312f, 
    -0.15568540f, -0.22917901f, 0.26394004f, 0.03872795f, -0.07380827f, 0.00521676f, -0.15217167f, 0.03983002f, 
    -0.04575339f, 0.11675313f, 0.09591584f, -0.03805996f, 0.27993456f, -0.12716530f, -0.10540154f, -0.10838262f, 
    0.09277979f, 0.06738283f, 0.08184353f, 0.21321310f, 0.25998664f, -0.09750678f, 0.10779168f, -0.24354133f, 
    0.02595298f, 0.15573591f, -0.00008082f, -0.45293200f, -0.09973253f, -0.08049311f, -0.04349401f, 0.08477232f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07478841f, 0.05487791f, -0.14299166f, 0.13495010f, 0.12520571f, -0.02164617f, 0.20608163f, -0.07237409f, 
    -0.09512373f, 0.03901071f, -0.05692400f, 0.11209745f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
