#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.06398702f, 1.00042069f, 0.47989443f, -0.00316497f, -0.32141843f, -0.15415740f, -0.84400231f, -0.02388306f, 
    -0.20389405f, 0.75256169f, -0.00960793f, 0.13744463f, 0.03996774f, 0.21446614f, -0.13257666f, -0.23056072f, 
    -0.30055922f, 0.12743156f, -0.15771043f, -0.15069409f, -0.21828742f, 0.15039222f, -0.09234130f, -0.19635667f, 
    0.02283282f, -0.19632743f, -0.56735414f, 0.04319090f, -0.17176248f, -0.16547924f, -0.99452549f, -0.53402638f, 
    -0.16460112f, -0.54513490f, -0.42361444f, -0.36686596f, 0.57330501f, 0.06111721f, 0.43347469f, -0.69556540f, 
    0.16171183f, 0.01373811f, 0.00070229f, -0.11299849f, -0.33605695f, 0.03393343f, -0.16597174f, -0.02226669f, 
    -0.04233401f, -0.17384729f, 1.08780432f, -0.68903965f, -0.56560254f, -0.32030091f, 0.19163674f, 0.70529157f, 
    -0.47115755f, 0.18136203f, 0.54803526f, 0.26885915f, -0.37895176f, 0.13629481f, 0.03662701f, -0.06438694f, 
    -0.02522040f, -0.13049735f, -0.01902777f, 0.17680952f, 0.23869066f, -0.18520907f, -0.07491290f, -0.09663654f, 
    0.10901289f, 0.17817545f, -0.15113388f, 0.83815479f, -0.27630126f, 0.08894928f, 0.83403665f, 0.59884995f, 
    0.35357741f, -0.46336645f, -0.17537715f, -0.28049037f, -0.20106959f, -0.02362508f, 0.17467645f, -0.12942074f, 
    0.25836071f, -0.01105545f, 0.52329034f, 0.18579833f, 0.52857184f, 0.53778368f, 0.28346437f, 0.08083123f, 
    -0.11089475f, -0.10472791f, -0.05548089f, 0.23026718f, 1.03867018f, 0.58909881f, -1.18128049f, -0.72560304f, 
    -0.45478916f, -0.02798838f, -0.54504532f, -0.19870079f, 0.11808437f, -0.28650388f, -0.51318288f, 0.06396383f, 
    0.11256956f, 0.21430525f, 0.02284954f, -0.23652299f, 0.06233744f, -0.27979025f, -0.03376483f, 0.05159071f, 
    0.24724494f, 0.16459554f, -0.12140577f, -0.06578311f, 0.01530315f, -0.25386000f, -1.08115745f, -0.42848489f, 
    -0.07565545f, -0.53987944f, -0.59735602f, -0.41388240f, 0.05027207f, 0.12465800f, 0.27254280f, 0.10693078f, 
    0.06304634f, -0.15437980f, 0.03453603f, 0.08461764f, -0.28133225f, -0.19342969f, 0.22148488f, -0.04850161f, 
    -0.01351613f, 0.22483899f, 0.38593632f, -0.04800928f, -0.02731105f, 0.54532468f, 1.10294259f, 0.44572797f, 
    0.82906449f, 0.75579339f, 0.65377182f, 0.81832230f, 0.08687607f, -0.31215113f, 0.23395436f, -0.29872417f, 
    -0.11545672f, -0.09732351f, -0.05533936f, -0.18495472f, 0.09375675f, -0.02769821f, 0.12376849f, -0.06871533f, 
    -0.22003764f, 0.09878035f, -0.12540217f, 0.07713598f, 0.17575300f, 0.10770684f, 0.02608209f, 1.28216898f, 
    -0.06378944f, 0.94264108f, -0.26229620f, -0.03223327f, 0.38396481f, 0.01220717f, 0.49332151f, 0.48469633f, 
    0.21324837f, -0.15213422f, 0.15486890f, -0.05997600f, 0.32070339f, 0.20867802f, 0.42806423f, 0.20632483f, 
    -0.16092125f, 0.07234686f, 0.17924665f, -0.25124443f, 0.13277204f, 0.20412494f, 0.10708140f, -0.15249079f, 
    -0.63815498f, -0.16160040f, -0.98452365f, -0.80770105f, -0.30117404f, 0.71998990f, 0.37659404f, 0.14870131f, 
    0.32824308f, 0.74799687f, -0.50374937f, -0.21986592f, -0.22245760f, -0.29278451f, -0.37366998f, 0.10672891f, 
    0.04397547f, 0.25292644f, 0.02509486f, -0.02205076f, 0.05885442f, -0.21307352f, -0.23531397f, -0.00804991f, 
    0.27347171f, -0.57388097f, -0.74177837f, -0.76139450f, -0.04158871f, -0.50457144f, 0.01117649f, 0.29800633f, 
    -0.64977741f, 0.37611210f, 0.64992499f, 0.48253614f, 0.28189886f, 0.00633072f, 0.10469213f, 0.00851882f, 
    -0.13817832f, 0.46551579f, 0.40715706f, 0.13551837f, 0.24035481f, 0.00136469f, 0.19878983f, 0.09581225f, 
    0.13089308f, -0.03882575f, 0.28522506f, -0.28653774f, -0.30151355f, 0.47859395f, 0.41713589f, 0.21328595f, 
    -1.01044142f, 0.59017414f, 0.31891155f, 0.13950348f, -0.18869673f, -0.54404384f, -0.27419218f, -0.25223455f, 
    0.23779099f, -0.04850838f, -0.33689407f, -0.40963486f, -0.28077960f, -0.13967904f, 0.27417782f, 0.21209311f, 
    0.36017147f, 0.36035427f, -0.05438364f, -0.31768209f, -1.51947725f, -0.58412820f, 0.04016258f, 0.57757407f, 
    -0.34089762f, 0.86824942f, 0.19737014f, -0.42338672f, 0.10359113f, 0.22652441f, 0.27532601f, -0.11916035f, 
    -0.10498549f, 0.01073934f, -0.25984770f, -0.25460932f, -0.13945229f, -0.24974932f, -0.33117178f, 0.07811219f, 
    0.04065927f, 0.21058701f, 0.09893013f, -0.12930062f, 0.52812201f, 0.66257471f, 0.70635378f, 0.79064411f, 
    0.39213672f, -0.74623001f, -0.17532219f, -0.12863056f, -0.04884715f, 0.10057775f, 0.59678262f, 0.44370559f, 
    -0.27455306f, 0.12720481f, -0.37869549f, -0.01710266f, 0.14025840f, 0.03830844f, 0.04712332f, -0.09484449f, 
    0.35858169f, 0.34487793f, 0.03744306f, 0.16853267f, 0.04709588f, -0.82267344f, -0.53936642f, 0.37491459f, 
    1.17276502f, 0.57900059f, 0.48402268f, 0.25684822f, -0.39815977f, 0.62842149f, -0.33565089f, 0.07992083f, 
    -0.26684675f, -0.10830704f, 0.19478364f, 0.00377299f, -0.22304352f, 0.17644350f, 0.09798349f, -0.10459051f, 
    -0.05861012f, -0.23005824f, -0.17820396f, -0.57173407f, 0.03304134f, -0.19693342f, 0.40955254f, 0.12645276f, 
    -0.93910664f, 0.59250009f, 0.70163256f, 0.62189537f, -0.29916275f, -1.31009281f, -0.13189925f, -0.02681081f, 
    -0.00154200f, 0.28779927f, -0.34042847f, 0.07617345f, 0.06783738f, 0.10981356f, -0.15908846f, -0.21061778f, 
    -0.28033161f, -0.01865128f, 0.20764299f, 0.16981201f, 0.10909474f, 0.13824525f, 0.11103176f, -0.17877954f, 
    -0.84311366f, 0.25649709f, 0.00199044f, 0.38906524f, 0.68056434f, 0.70805097f, 0.56134391f, 0.48214856f, 
    0.19523795f, 0.17084351f, -0.06160473f, -0.13718353f, 0.11341283f, -0.37802932f, 0.26873359f, -0.02110491f, 
    -0.51693302f, 0.25751826f, 0.12659994f, -0.22707637f, -0.27875111f, 0.13670897f, -0.08513886f, 0.14379440f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17150955f, 0.17712276f, -0.11389445f, 0.06799689f, 0.10237433f, 0.28412315f, 0.43217275f, 0.07771934f, 
    -0.19064750f, 0.13100252f, 0.06682501f, 0.21451765f, 0.24850227f, 0.16468431f, 0.44961819f, -0.03737806f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.48204282f, -0.01945871f, 0.12502769f, -0.06433240f, -0.07722806f, -0.36650941f, -0.05640807f, 0.06943870f, 
    0.17736989f, 0.05710228f, 0.12097644f, 0.18115820f, -0.21290222f, -0.10858212f, -0.02327214f, -0.24037476f, 
    0.05233962f, -0.12218138f, 0.03989095f, 0.13052607f, 0.04028071f, -0.06207541f, 0.10037002f, -0.17571586f, 
    0.28106761f, -0.45134345f, 0.15865913f, -0.16584401f, 0.24352287f, -0.01569038f, -0.00492157f, -0.12040710f, 
    -0.16162223f, -0.08780960f, 0.03207077f, 0.03008795f, 0.15697651f, -0.14116015f, 0.22498338f, 0.30485585f, 
    -0.08620002f, 0.13662595f, -0.27684414f, 0.16601051f, 0.05521785f, 0.08927169f, -0.04075873f, 0.05309010f, 
    0.15536270f, -0.12237897f, -0.13175403f, -0.12738042f, -0.05580976f, -0.10180131f, 0.03148163f, 0.04320376f, 
    0.02805115f, 0.01283287f, 0.15362728f, -0.06343202f, -0.20102599f, 0.15197676f, -0.06063127f, -0.09716648f, 
    0.18067975f, -0.03505428f, -0.01767699f, 0.15111066f, 0.01094135f, -0.00848448f, 0.01347610f, 0.01919262f, 
    0.44766203f, -0.13412498f, 0.30854356f, 0.30645046f, -0.19593558f, -0.10268084f, 0.02039753f, 0.04359761f, 
    -0.02680657f, 0.10850200f, 0.03434420f, -0.07332167f, 0.10599822f, -0.12433702f, -0.10877582f, 0.00582635f, 
    0.11137319f, -0.24698935f, -0.14583878f, -0.10028217f, 0.00855658f, 0.01807968f, 0.06819803f, -0.06839212f, 
    0.19062251f, 0.00758881f, -0.21985921f, -0.12346970f, 0.00531362f, -0.07965411f, -0.02798559f, -0.08463015f, 
    0.16314337f, 0.06730325f, -0.06095626f, -0.19120573f, 0.46954402f, 0.36163563f, -0.26514748f, 0.22927064f, 
    0.20299847f, -0.06762195f, 0.07951614f, -0.05244672f, 0.13885678f, 0.17298539f, 0.04603001f, 0.10113063f, 
    -0.15331887f, -0.25910401f, 0.31964737f, 0.21363394f, -0.00167339f, -0.01567245f, -0.00775667f, 0.07193070f, 
    0.12222318f, -0.03411307f, -0.18900575f, 0.06019773f, 0.14583951f, 0.13242123f, -0.02339895f, -0.20636143f, 
    -0.05966467f, 0.04582410f, 0.20820896f, 0.00286669f, -0.02729482f, -0.24346867f, 0.04969435f, 0.02085244f, 
    0.52014208f, 0.11971164f, -0.06541582f, 0.13974898f, -0.08877742f, 0.05092592f, -0.04804681f, 0.22816816f, 
    0.17169924f, 0.08694973f, -0.01474651f, 0.01943625f, 0.08459307f, 0.13168496f, -0.06809008f, -0.06362218f, 
    0.12157518f, -0.01828619f, -0.04721642f, 0.11968049f, -0.17193921f, 0.02250332f, -0.04694143f, -0.06829921f, 
    0.26430094f, -0.49460688f, 0.01129349f, -0.10303595f, 0.15725639f, -0.04716353f, 0.03690838f, -0.10387123f, 
    0.04650611f, 0.07939058f, -0.03898877f, -0.02987356f, -0.19977722f, -0.00216229f, 0.08194109f, 0.02978402f, 
    -0.08981425f, 0.29635975f, -0.15086798f, 0.23163730f, 0.03303304f, 0.22199956f, -0.25095394f, 0.19678645f, 
    -0.15341938f, -0.27049878f, 0.23579969f, 0.15358068f, 0.06523255f, 0.01914757f, 0.11536445f, -0.06307696f, 
    0.17416294f, -0.15401539f, 0.00183279f, -0.01826798f, 0.09779469f, -0.03893345f, 0.06094672f, 0.13773184f, 
    0.09929364f, -0.06520832f, 0.08883224f, 0.06617954f, -0.01139349f, -0.04905003f, 0.07692467f, 0.28576642f, 
    -0.37257966f, -0.15529120f, -0.03209811f, 0.04606363f, 0.20945005f, -0.20835230f, -0.00395618f, 0.01882674f, 
    0.13156432f, -0.04479302f, 0.12851875f, 0.05670672f, -0.08464678f, -0.11019135f, 0.16138434f, 0.13808291f, 
    0.07044923f, 0.02054961f, 0.02268457f, -0.01471435f, 0.24308097f, 0.06403863f, 0.19072793f, 0.25193825f, 
    -0.24272734f, -0.29972953f, 0.14869727f, -0.05542349f, -0.02853695f, -0.02028908f, 0.01480096f, -0.00552909f, 
    0.06796464f, -0.01431073f, -0.00325061f, -0.14940283f, -0.41568369f, -0.23994556f, -0.04739387f, 0.13116708f, 
    0.22269468f, 0.16149931f, -0.02069029f, 0.21242528f, 0.04377219f, 0.15544654f, 0.12591356f, 0.11105087f, 
    0.30143744f, 0.02469543f, 0.05188378f, 0.15753478f, 0.09899831f, 0.05205462f, 0.05140718f, -0.01149354f, 
    0.09571944f, 0.10713205f, 0.06974848f, 0.13362810f, 0.00715801f, -0.04139375f, 0.23928542f, -0.01260646f, 
    0.17802331f, -0.00614038f, 0.08557634f, -0.14401685f, 0.15116519f, 0.19287051f, -0.03130514f, 0.31329581f, 
    -0.00371180f, -0.10940296f, 0.00508238f, 0.04273368f, -0.03531725f, 0.06024803f, -0.11717848f, -0.07531398f, 
    0.11558390f, -0.12886897f, -0.03317213f, -0.17839898f, -0.14024341f, -0.18606322f, 0.12458226f, 0.16082458f, 
    0.02858054f, 0.13368106f, 0.11730531f, 0.05059072f, -0.03464499f, 0.01020851f, 0.03656371f, 0.12716122f, 
    -0.03290986f, -0.35384375f, 0.05754751f, 0.09414019f, 0.07690604f, -0.05023284f, 0.05080653f, 0.07627501f, 
    0.24069868f, 0.04809807f, -0.23243344f, -0.16405249f, -0.69817442f, 0.22380635f, 0.01702923f, -0.19539998f, 
    0.16107616f, -0.07853666f, 0.06484029f, 0.19518822f, 0.00114839f, -0.16791984f, -0.04782402f, -0.08012405f, 
    -0.20694602f, -0.17119791f, 0.12842150f, 0.13002177f, -0.12097329f, -0.10194668f, -0.07280729f, 0.15677193f, 
    0.10440300f, 0.01467364f, 0.00690683f, 0.15629813f, -0.08514442f, 0.15425079f, 0.03843453f, 0.10204428f, 
    -0.08909535f, -0.08984928f, -0.10022630f, 0.00794566f, 0.09303503f, -0.03878995f, 0.02946707f, 0.04693531f, 
    0.27754420f, -0.12724148f, 0.37241083f, -0.00211906f, 0.08327983f, 0.10602499f, 0.07043374f, 0.00803863f, 
    0.12957712f, 0.12023524f, 0.12826258f, 0.17280386f, -0.21773690f, 0.25305325f, 0.04372819f, -0.01767534f, 
    -0.14609772f, -0.16744950f, 0.04869099f, 0.11365300f, -0.10505749f, -0.08729778f, -0.14538638f, -0.03613369f, 
    0.03251112f, 0.05818939f, -0.06633818f, -0.01955396f, 0.06260402f, 0.03453539f, 0.06004350f, -0.01296745f, 
    -0.07117441f, -0.01927318f, 0.00186824f, -0.05928015f, 0.02053754f, -0.01050237f, 0.03060243f, 0.06246896f, 
    0.02390106f, -0.04762392f, -0.06359268f, 0.05627083f, -0.04692930f, 0.05579000f, 0.01430198f, -0.00530582f, 
    -0.07965255f, -0.06453368f, 0.01256751f, 0.03268799f, -0.02325926f, -0.05662018f, 0.01155503f, -0.04041907f, 
    -0.00383030f, -0.07859950f, 0.03817397f, 0.04577422f, -0.05683606f, -0.04803484f, -0.04895693f, -0.00039900f, 
    0.04231112f, 0.00937869f, -0.01957385f, 0.03910204f, 0.05559883f, 0.03847157f, 0.02252751f, -0.01621399f, 
    -0.03392971f, 0.03961743f, 0.01540139f, -0.04513774f, -0.00288829f, -0.06891856f, 0.05705805f, -0.02979366f, 
    -0.00275381f, -0.00320156f, 0.03939647f, 0.04075683f, -0.06934972f, -0.02342300f, -0.06031657f, 0.02892721f, 
    0.03149312f, -0.01385824f, -0.03354603f, 0.01477154f, -0.00523945f, -0.06408268f, 0.02679298f, 0.03585963f, 
    -0.07204341f, -0.00074866f, -0.07378728f, -0.07520830f, -0.06370667f, 0.04205855f, -0.05469379f, -0.03241824f, 
    -0.06499156f, -0.07733119f, -0.04558899f, -0.01424212f, -0.07839261f, 0.05608571f, -0.01075631f, -0.06757450f, 
    -0.04030272f, -0.07030210f, 0.04255408f, -0.04521731f, 0.02812990f, -0.06950128f, -0.05939490f, -0.07303101f, 
    -0.07281079f, -0.00717495f, 0.06062331f, 0.02497131f, -0.05116081f, -0.03576427f, -0.00103641f, 0.03884242f, 
    0.04304735f, -0.06076636f, 0.00017927f, 0.00315759f, -0.03065317f, 0.05145751f, -0.00965320f, 0.00061802f, 
    -0.04911688f, -0.06787332f, 0.01702521f, 0.01403731f, -0.01949179f, -0.00813879f, 0.02779973f, -0.05783959f, 
    -0.05995374f, 0.02290807f, 0.01841279f, 0.03228007f, -0.01776722f, 0.04849065f, -0.06225347f, 0.00728508f, 
    -0.06461138f, -0.00278252f, 0.04791940f, -0.03309926f, 0.00777336f, -0.05238714f, -0.00171959f, 0.01160349f, 
    0.00237179f, -0.02397714f, -0.00178058f, 0.02346169f, -0.06359567f, -0.07737550f, 0.02887546f, 0.02625631f, 
    0.00566525f, -0.07950733f, 0.03964752f, -0.05194687f, 0.01289535f, -0.04445757f, -0.05423609f, -0.02099412f, 
    -0.02129317f, 0.01247267f, 0.03940489f, 0.06025689f, -0.07495503f, -0.07378210f, -0.06540815f, 0.03048340f, 
    0.04116399f, 0.06383474f, 0.02762673f, -0.02289441f, -0.07381028f, -0.01571830f, -0.05843115f, 0.02216597f, 
    -0.00733222f, 0.04737791f, -0.02898232f, 0.04555016f, 0.04582725f, -0.02933392f, -0.07760602f, -0.05600742f, 
    -0.04866097f, 0.01185029f, 0.01632308f, 0.02636152f, -0.00589434f, -0.07329438f, -0.00971549f, -0.06661402f, 
    0.00129422f, -0.03445578f, -0.05679224f, -0.05953050f, -0.04315719f, 0.02765268f, -0.02593582f, 0.04293200f, 
    -0.09441689f, 0.05296765f, 0.03510552f, -0.07774094f, 0.02921771f, 0.00975746f, -0.01930665f, 0.06251132f, 
    -0.02975152f, 0.02029596f, 0.01803592f, 0.02373744f, -0.00238327f, 0.06236773f, 0.02369756f, -0.02707898f, 
    -0.09762923f, 0.01564722f, 0.00915598f, -0.05698057f, 0.06358718f, -0.03892239f, -0.03665921f, 0.04257059f, 
    -0.06162652f, -0.02512780f, 0.01114963f, -0.04438584f, 0.01907971f, 0.03170398f, 0.03839100f, -0.02766744f, 
    0.04193456f, -0.00915138f, 0.04077130f, -0.02280265f, -0.04724772f, -0.01911549f, 0.03637970f, -0.02609822f, 
    -0.01061744f, -0.00461367f, -0.03715513f, -0.05207665f, -0.04505174f, -0.03684182f, -0.00288667f, -0.06466985f, 
    0.00522295f, -0.01603659f, -0.06961073f, -0.00922626f, -0.00108483f, 0.01781767f, 0.02449785f, -0.07482845f, 
    0.05096105f, -0.05912076f, 0.02923950f, -0.02597771f, -0.01432556f, -0.06120354f, 0.00517645f, -0.09406110f, 
    -0.06612369f, 0.01525262f, 0.03013107f, 0.02118986f, 0.02398517f, 0.04889238f, 0.05600204f, -0.04750452f, 
    -0.03798586f, -0.05556237f, -0.07447422f, -0.04292236f, -0.05672116f, -0.03883351f, 0.06710912f, 0.01166190f, 
    -0.09572829f, -0.05236084f, 0.05430542f, -0.04522490f, -0.03576661f, 0.05259269f, 0.05436936f, 0.01852195f, 
    0.03651819f, -0.03006576f, 0.02294707f, 0.04120190f, 0.04600929f, -0.05039646f, -0.05170655f, -0.06132479f, 
    -0.00672335f, 0.01679275f, -0.07981674f, 0.05013735f, -0.05594845f, -0.03839567f, -0.08204658f, -0.00740622f, 
    -0.05403961f, -0.05095599f, 0.01229455f, -0.07472559f, 0.01122615f, 0.00239582f, 0.03390112f, -0.02554140f, 
    -0.07375753f, 0.00232691f, -0.00826748f, -0.09932163f, 0.04734131f, 0.07337030f, 0.01232823f, 0.05959238f, 
    -0.02552972f, 0.05846522f, 0.00251648f, 0.02445780f, -0.02035068f, -0.07254765f, -0.01725115f, -0.07777324f, 
    -0.00013612f, -0.00497514f, -0.08397410f, -0.04897321f, -0.04105599f, -0.03003323f, 0.01832826f, -0.02282148f, 
    -0.03742179f, -0.03444144f, -0.06421792f, -0.04546130f, -0.07784238f, -0.04687654f, 0.05246696f, 0.01991667f, 
    -0.02522970f, -0.06812485f, 0.04603613f, 0.01435719f, 0.06591537f, -0.01240916f, -0.01658074f, 0.03633848f, 
    -0.02774725f, -0.04879843f, 0.03121354f, -0.08072502f, 0.03206138f, 0.00075173f, 0.00892894f, -0.02645642f, 
    0.05755527f, 0.03074053f, 0.05001719f, -0.11472316f, -0.02378568f, 0.02096567f, 0.06793702f, -0.02722204f, 
    -0.07647906f, -0.00498386f, -0.04302171f, -0.06375823f, 0.00110080f, -0.08134560f, -0.02496601f, 0.00269240f, 
    -0.04911389f, 0.01342625f, -0.08809378f, 0.01893084f, 0.02416138f, -0.01142003f, -0.05075998f, 0.04604753f, 
    -0.00171134f, 0.03385066f, -0.03208702f, 0.00989254f, -0.02361002f, 0.00114482f, 0.10064740f, 0.01465317f, 
    0.08128230f, 0.12731150f, -0.10427470f, 0.01746751f, 0.01591830f, -0.00758534f, -0.02021440f, 0.00848972f, 
    -0.04171454f, -0.20832445f, 0.14476782f, -0.09638838f, 0.14573979f, -0.23013555f, -0.07459743f, 0.26231095f, 
    0.00121488f, -0.28185582f, 0.03596157f, 0.00556849f, -0.04511527f, -0.19342998f, 0.25319007f, 0.15939043f, 
    0.21501590f, -0.42404088f, 0.09987355f, -0.24912682f, 0.08107058f, -0.09954754f, -0.04660052f, -0.11921144f, 
    0.06663824f, -0.02701248f, 0.14306934f, -0.00293558f, 0.00500393f, -0.09371231f, 0.10837516f, 0.23279208f, 
    -0.16385481f, 0.10522716f, -0.12073238f, 0.04444076f, 0.23271523f, 0.09196397f, 0.26953107f, 0.32783473f, 
    0.08230373f, -0.16124371f, -0.07270148f, -0.19255480f, 0.02484246f, -0.04676463f, -0.03487587f, 0.11590858f, 
    0.09033075f, -0.05131655f, 0.00903314f, -0.10958306f, -0.37601551f, -0.33751830f, -0.10185622f, 0.18358065f, 
    0.27211365f, 0.23089598f, -0.19135465f, 0.27282482f, 0.06052090f, 0.02734653f, -0.04572555f, 0.10285186f, 
    0.20522743f, -0.05827206f, 0.16579224f, 0.52169377f, -0.07148211f, 0.10402310f, 0.02466810f, -0.21625422f, 
    -0.03227673f, 0.09845673f, -0.14189056f, 0.10575292f, 0.11420895f, 0.14835408f, 0.15272242f, 0.12703642f, 
    -0.10429166f, -0.08235283f, 0.15471229f, -0.21558076f, 0.02486661f, 0.15397707f, -0.04563263f, 0.21995232f, 
    0.22644654f, 0.24768311f, -0.21756820f, -0.25019541f, 0.06399590f, 0.27843344f, -0.05436872f, -0.14307882f, 
    0.19990382f, -0.09769829f, -0.05082406f, -0.19904065f, -0.27189246f, 0.21583480f, -0.09391405f, 0.17268105f, 
    -0.00869825f, -0.04172189f, 0.10707366f, 0.07142175f, 0.04716935f, -0.08420996f, 0.20690529f, 0.16735250f, 
    -0.03100350f, -0.09255212f, 0.03549256f, 0.06805910f, 0.04772179f, -0.02570472f, 0.00485099f, 0.13778427f, 
    0.04742225f, 0.04895505f, -0.27151942f, -0.14673752f, -0.35753605f, 0.01153078f, 0.11537648f, -0.34392500f, 
    0.06476053f, 0.01842454f, 0.14050499f, 0.02432792f, 0.00377607f, -0.09455163f, 0.00652375f, 0.10075720f, 
    0.08329083f, -0.02433048f, 0.05047375f, 0.14035344f, 0.01855699f, -0.09365996f, -0.02165287f, 0.12201197f, 
    0.04926406f, -0.01133765f, -0.02496306f, 0.21190079f, -0.25178733f, 0.06404308f, 0.23582755f, -0.16666941f, 
    -0.02196441f, -0.02940249f, -0.00343263f, -0.21358177f, -0.07684901f, -0.01451480f, 0.23023021f, -0.09463554f, 
    0.23879728f, -0.34229079f, 0.05026195f, -0.03669662f, -0.12012586f, -0.10386258f, -0.01516458f, 0.04984606f, 
    0.16547287f, 0.09050640f, -0.07084382f, 0.04240540f, -0.27948630f, 0.21936390f, 0.15281413f, -0.10802533f, 
    -0.16593134f, 0.12284240f, -0.00240904f, -0.06101935f, -0.04470424f, -0.06945457f, -0.15508838f, 0.14823592f, 
    -0.00484941f, 0.29352868f, -0.18144210f, 0.13938238f, -0.03430802f, -0.15747759f, -0.13046560f, 0.25100213f, 
    -0.04029552f, 0.17462936f, 0.11469131f, -0.03572256f, 0.23547587f, 0.26478073f, 0.07151946f, 0.28785217f, 
    -0.09046184f, -0.06120174f, 0.02934003f, -0.01686492f, 0.11451094f, 0.05639210f, 0.23315881f, -0.03567078f, 
    -0.10868556f, -0.03818362f, -0.16734095f, -0.10841848f, 0.02025316f, 0.09548727f, 0.17584704f, 0.21430732f, 
    -0.10665230f, 0.10298824f, -0.09715744f, 0.06444766f, 0.29287198f, 0.05131942f, 0.06700547f, -0.09285986f, 
    -0.12099436f, -0.00086131f, 0.06941400f, 0.08515867f, 0.13729705f, -0.09191166f, 0.01789246f, 0.08934551f, 
    0.13346709f, 0.32729101f, -0.29904491f, 0.76454014f, 0.15387030f, 0.15919703f, 0.02929422f, -0.01455266f, 
    0.15139420f, -0.02883939f, -0.00117527f, 0.08459490f, 0.05888775f, 0.07346494f, 0.04053320f, 0.10420972f, 
    0.16317959f, 0.01685762f, 0.12686007f, -0.15161787f, 0.16058525f, 0.03413088f, 0.02624357f, -0.08289626f, 
    -0.14418514f, -0.04305045f, -0.13490634f, 0.10819759f, -0.24043797f, 0.00361949f, -0.02284718f, 0.05103188f, 
    0.00344715f, 0.10448837f, 0.07906716f, -0.07784110f, -0.49235797f, 0.10670312f, 0.00154715f, 0.37755495f, 
    -0.17331123f, 0.14602584f, 0.18007416f, 0.12625457f, 0.01386608f, 0.16721259f, -0.06374772f, 0.09087760f, 
    0.23053584f, 0.23371182f, -0.33584946f, -0.01718782f, 0.12678227f, 0.27288309f, 0.15273879f, -0.22949004f, 
    -0.12411452f, -0.07977051f, -0.08003081f, 0.09527789f, -0.09505730f, 0.33006990f, -0.00861624f, -0.10797512f, 
    -0.08259072f, 0.13363105f, 0.19905780f, -0.02565057f, -0.01667847f, -0.07932860f, -0.00957683f, -0.13136578f, 
    0.30468094f, -0.09016208f, 0.01935264f, -0.15972045f, 0.00769409f, 0.07336148f, 0.09287402f, 0.16676703f, 
    -0.22319707f, -0.07912502f, 0.03606561f, -0.05014118f, -0.24661681f, 0.15480652f, 0.01518277f, -0.24098891f, 
    0.11521029f, 0.04894871f, 0.13391282f, -0.06958574f, 0.14141236f, 0.15148805f, 0.07623062f, 0.16664581f, 
    0.07815684f, 0.19137041f, -0.19558592f, -0.30912265f, -0.14563134f, 0.06233218f, 0.07979373f, 0.04146544f, 
    -0.18482020f, 0.00863548f, 0.10684519f, 0.27119175f, 0.06437261f, -0.15757987f, 0.54286188f, -0.26836899f, 
    -0.03486108f, -0.04424168f, 0.26237899f, -0.10314575f, 0.06797355f, 0.10686838f, -0.08072325f, 0.15452884f, 
    0.30534646f, 0.22774731f, 0.22339997f, 0.24729428f, -0.16331986f, -0.06902102f, -0.11294125f, 0.08398221f, 
    0.21942566f, 0.00606476f, 0.14203694f, -0.01593800f, -0.62278891f, -0.19143908f, -0.10530191f, -0.13140872f, 
    -0.07477465f, 0.06722085f, 0.09765597f, 0.00974201f, 0.18376343f, -0.02866340f, 0.02696086f, -0.12529811f, 
    0.05611838f, -0.03149267f, 0.07620765f, 0.09292912f, -0.11918042f, 0.00224330f, 0.07552899f, 0.10253875f, 
    0.25851139f, 0.18518187f, -0.09944846f, 0.09669363f, -0.15910040f, 0.49965692f, -0.02269883f, -0.20285049f, 
    0.12760603f, -0.00395958f, -0.02209146f, 0.05911531f, 0.18916829f, 0.06371523f, -0.17310698f, -0.14855157f, 
    -0.29132053f, 0.11502514f, -0.03949394f, 0.06115876f, 0.05215577f, 0.12472471f, 0.18821786f, 0.18845810f, 
    0.02763767f, 0.04002639f, -0.12168869f, 0.13908017f, 0.11358409f, -0.19754323f, 0.16941699f, 0.09124961f, 
    0.08873402f, -0.03000237f, -0.02057146f, 0.10686360f, 0.00424489f, -0.02035125f, -0.12936881f, -0.21757756f, 
    -0.29722935f, -0.18833624f, 0.08753435f, -0.04121398f, 0.02080997f, -0.04222108f, 0.20015642f, -0.08736853f, 
    -0.07868975f, 0.02154189f, 0.06606103f, 0.11380188f, 0.19552433f, 0.00227031f, -0.09585931f, -0.21660191f, 
    -0.02075040f, -0.18971729f, 0.13072079f, -0.28438911f, 0.09376999f, 0.03419136f, 0.00238475f, 0.13940197f, 
    -0.24054502f, -0.31924829f, -0.16476688f, -0.25400639f, -0.06642902f, 0.09331563f, -0.00784582f, 0.06680927f, 
    0.09549114f, 0.08118583f, 0.12372120f, 0.03642694f, -0.35664859f, -0.28433493f, -0.13865700f, -0.08096203f, 
    0.07498324f, 0.02030827f, 0.11161133f, 0.18254679f, -0.16289426f, -0.02482259f, 0.05514108f, -0.08670274f, 
    0.07907923f, -0.13147666f, -0.15292549f, -0.08176210f, -0.09045123f, -0.22342606f, 0.15296084f, 0.04229958f, 
    -0.10253272f, 0.05447322f, -0.08171273f, -0.00460088f, 0.43164584f, -0.14278746f, -0.02813480f, -0.23049746f, 
    -0.06044007f, -0.13932747f, -0.03167502f, -0.05083833f, 0.03266727f, 0.03370586f, -0.06468699f, 0.04556721f, 
    -0.01793625f, -0.07577645f, 0.09890144f, 0.16021876f, -0.00707095f, -0.01899365f, 0.04578410f, -0.14363779f, 
    0.03761263f, 0.14085256f, 0.24851669f, 0.10946390f, 0.51947385f, 0.14271420f, 0.01011464f, 0.15494144f, 
    0.03721713f, -0.11143911f, 0.04663559f, 0.04629546f, -0.00724213f, 0.05575199f, 0.16363057f, -0.00880574f, 
    0.10504064f, 0.29225376f, -0.15673228f, 0.00730446f, -0.03006418f, 0.20743935f, 0.08375320f, -0.00542451f, 
    0.02814351f, 0.02499826f, 0.18811275f, -0.04922833f, 0.52007771f, -0.09527259f, -0.19596699f, 0.26119840f, 
    0.05367907f, -0.03256340f, 0.09680627f, 0.19493444f, -0.03288515f, -0.08067541f, -0.10141899f, 0.19512598f, 
    0.42741808f, -0.24033135f, 0.04602303f, 0.18025874f, 0.28946760f, 0.09610415f, 0.07647064f, 0.05056668f, 
    0.02273068f, -0.01233293f, 0.10081571f, -0.07319383f, 0.10399647f, -0.15471768f, -0.12987246f, -0.00506809f, 
    0.18598469f, 0.09958093f, 0.15301692f, 0.27623174f, 0.03853647f, 0.14842665f, 0.12286843f, -0.07697686f, 
    -0.66567391f, -0.18521874f, 0.19062865f, -0.04973588f, 0.07077434f, 0.08312104f, -0.03874180f, -0.07970554f, 
    -0.08368854f, -0.21792336f, -0.05461732f, -0.06640850f, 0.71374154f, -0.01751360f, 0.15168171f, 0.17965405f, 
    0.19319770f, 0.20399810f, -0.01524032f, -0.07892365f, -0.17376560f, -0.03861333f, -0.07621821f, -0.01147977f, 
    -0.06932672f, -0.01500664f, -0.06401149f, 0.16451313f, -0.06001646f, -0.09506878f, -0.16201727f, -0.27614847f, 
    0.02524438f, -0.17379841f, 0.02910039f, 0.01426589f, -0.15342543f, 0.08928511f, -0.07900196f, -0.16401364f, 
    -0.05729853f, -0.21011101f, 0.07288016f, 0.00267227f, -0.01446760f, 0.03489907f, 0.13295916f, -0.16807239f, 
    0.04108721f, 0.00053518f, 0.12330285f, 0.08886849f, -0.10190258f, -0.02061542f, -0.07586370f, 0.00308895f, 
    -0.11206881f, 0.08137371f, 0.14298071f, -0.13317566f, 0.30181864f, 0.00527413f, 0.02184788f, 0.13941325f, 
    0.22851969f, 0.04672853f, 0.11193132f, 0.14529653f, -0.01157539f, 0.15755866f, 0.26177892f, 0.00719691f, 
    -0.40113351f, 0.04497081f, 0.01510380f, -0.33027637f, 0.09841637f, 0.09054967f, 0.13995768f, 0.06309143f, 
    0.00989501f, 0.04838781f, -0.03892750f, 0.07314937f, -0.14429186f, -0.10488766f, 0.28210217f, -0.08658182f, 
    -0.10272804f, -0.13641162f, 0.03116183f, -0.12514532f, -0.06434295f, -0.05889655f, 0.06232252f, 0.05601565f, 
    0.22155440f, 0.18306588f, 0.25237903f, 0.23577802f, 0.27182719f, 0.19086419f, 0.11524818f, 0.15969817f, 
    0.10357384f, -0.00674787f, 0.12184793f, -0.04986664f, -0.12889308f, 0.23855287f, 0.14633165f, 0.20370938f, 
    0.35891336f, 0.10824449f, -0.03828561f, 0.03798344f, 0.06108971f, 0.05011213f, 0.18541226f, 0.05115500f, 
    0.12261261f, -0.21606615f, -0.02318057f, -0.07361368f, -0.04924155f, -0.00660261f, 0.05114765f, 0.04224075f, 
    0.15782505f, 0.02582117f, -0.13020246f, 0.05142759f, -0.14351362f, -0.04354963f, -0.11816633f, -0.05338552f, 
    -0.11940880f, 0.11637121f, -0.02710399f, 0.10212838f, -0.07690613f, -0.10603014f, -0.00610194f, 0.00896866f, 
    -0.40532753f, -0.24771643f, 0.19238284f, -0.22887179f, -0.04820919f, -0.16243979f, -0.02737978f, 0.05984939f, 
    -0.05320379f, 0.12835868f, -0.04054279f, 0.09318225f, -0.38849193f, 0.23844469f, -0.02978195f, -0.27636471f, 
    -0.00419143f, -0.04207746f, 0.00455720f, 0.23727384f, 0.06657211f, -0.01828237f, 0.10628884f, -0.09109800f, 
    -0.04689243f, 0.20200849f, 0.02464571f, -0.13478245f, -0.04226839f, 0.00665162f, 0.03111683f, 0.08076317f, 
    0.03400611f, -0.17633796f, 0.13404410f, 0.07021058f, 0.26480398f, 0.14287093f, -0.04181039f, -0.11008836f, 
    -0.04324044f, -0.11621521f, -0.01653031f, 0.00583401f, 0.05740151f, 0.02533791f, -0.14528218f, 0.02234853f, 
    0.03739353f, 0.09012007f, 0.02871391f, -0.27868149f, -0.04390617f, 0.04145300f, 0.18613592f, 0.10442878f, 
    0.04215940f, 0.04437416f, 0.08745240f, 0.11861538f, 0.14141074f, 0.20481420f, 0.18609217f, 0.24849860f, 
    -0.04742720f, 0.19773430f, 0.03027795f, 0.07101385f, 0.07067139f, 0.21881278f, 0.05342556f, -0.11885902f, 
    -0.15197603f, 0.10894170f, -0.18248063f, 0.03831951f, 0.10127436f, -0.05747806f, 0.01828711f, 0.14741515f, 
    -0.14079675f, -0.00313455f, -0.15293756f, -0.07870881f, -0.01728144f, 0.02322220f, 0.24926296f, -0.03303264f, 
    0.12676302f, -0.03526819f, 0.09695568f, 0.07633725f, -0.02680892f, -0.17432268f, -0.16790514f, -0.20329060f, 
    0.32882187f, 0.16999574f, -0.34854555f, 0.42012000f, 0.09786616f, 0.08976261f, 0.28533825f, -0.10291734f, 
    -0.08885981f, 0.08913317f, 0.14857462f, -0.03570052f, 0.31374019f, 0.20026849f, -0.02094597f, 0.30618632f, 
    -0.15904875f, -0.13244644f, 0.04246755f, -0.13878627f, 0.04275344f, -0.09421272f, 0.13419718f, 0.02016021f, 
    0.17258365f, 0.24063018f, -0.16509782f, -0.17318428f, 0.02056652f, -0.00917329f, 0.02838625f, 0.16363120f, 
    -0.02264378f, -0.02313968f, 0.10644421f, 0.01218606f, -0.49386197f, 0.19362302f, 0.02274647f, -0.18469112f, 
    -0.03541573f, 0.12898664f, 0.00298470f, 0.16203316f, 0.08679830f, -0.18273771f, -0.01909537f, -0.14627787f, 
    0.31848219f, -0.02248875f, -0.03048851f, 0.62759691f, 0.08864394f, -0.04959147f, 0.19619487f, -0.00493237f, 
    -0.16638193f, -0.04174722f, 0.08049295f, 0.09907074f, 0.15976803f, 0.20233180f, 0.33195728f, 0.05291532f, 
    -0.04857903f, 0.06971294f, -0.02889293f, 0.09065820f, -0.13565297f, -0.12888482f, -0.11739388f, -0.27120441f, 
    0.29613033f, -0.09542890f, -0.26095951f, 0.01871673f, 0.01679901f, 0.02834771f, -0.09000289f, 0.05772743f, 
    0.00156812f, -0.07751969f, 0.12901153f, 0.00311907f, -0.09956357f, -0.04644284f, 0.09154897f, -0.00804381f, 
    0.07230399f, -0.03596386f, 0.09239724f, -0.03599139f, 0.02946661f, 0.12226058f, 0.14597367f, 0.10772429f, 
    0.11531713f, 0.01522508f, -0.19181339f, -0.16989894f, -0.04076849f, 0.07256954f, 0.13352607f, -0.13271490f, 
    -0.11758363f, -0.05766273f, 0.02679743f, -0.08128144f, 0.16583420f, -0.16027267f, -0.01446185f, -0.24867052f, 
    0.10615944f, 0.15012018f, 0.19694686f, -0.08840391f, 0.08151001f, 0.03219871f, -0.06221517f, 0.19640087f, 
    0.18382828f, -0.06805483f, 0.35118249f, 0.08976370f, 0.04571438f, -0.11070871f, -0.13826677f, -0.06857686f, 
    -0.03330306f, -0.14405854f, -0.01121553f, 0.01661423f, -0.40066975f, 0.03380007f, -0.15562007f, -0.01573402f, 
    -0.02077547f, -0.05863973f, -0.02693927f, 0.25935945f, 0.12667239f, 0.00201939f, 0.00398112f, -0.14629754f, 
    0.15536889f, 0.01725041f, 0.10212049f, 0.05992474f, 0.00883778f, 0.06642569f, 0.14507246f, -0.11148278f, 
    -0.03586316f, 0.00491028f, -0.07852387f, -0.03060490f, 0.03166316f, 0.39102957f, -0.03113327f, -0.00599418f, 
    0.02044572f, -0.14079411f, 0.06829273f, 0.06986021f, -0.01193129f, -0.03983270f, -0.09456208f, -0.00818070f, 
    0.08973350f, -0.07208364f, 0.14643162f, 0.11988655f, 0.02995177f, 0.14784031f, 0.08118813f, 0.14597182f, 
    0.11792997f, 0.03111684f, 0.10586036f, 0.21083368f, 0.17866580f, -0.12498241f, -0.13194084f, 0.05399517f, 
    0.09206706f, -0.09077986f, -0.07886226f, 0.05522852f, -0.01629892f, 0.12809022f, 0.09246918f, 0.03723956f, 
    -0.40121561f, -0.20144428f, 0.54650193f, -0.44047737f, 0.04503080f, -0.07900479f, 0.13991697f, 0.00768608f, 
    -0.09014121f, -0.16817409f, -0.09198295f, 0.15826017f, 0.05380711f, -0.17425297f, -0.16792969f, -0.03475803f, 
    0.08691896f, 0.03830969f, 0.02485493f, -0.08985176f, 0.09033284f, 0.02965911f, 0.03541293f, 0.22108947f, 
    -0.30864820f, -0.31336734f, -0.05935211f, -0.07364164f, -0.04793401f, -0.00482947f, 0.08138552f, -0.01520582f, 
    0.05006803f, -0.02481595f, 0.08723091f, -0.02667609f, 0.20825045f, -0.26198283f, -0.15429333f, 0.01361772f, 
    0.15040770f, -0.08177078f, 0.21589397f, 0.03328546f, -0.22149909f, -0.04148360f, 0.07981291f, 0.08136827f, 
    0.09230338f, -0.11919185f, 0.07112029f, -0.38739246f, 0.00076967f, 0.00398714f, 0.02842103f, 0.15559834f, 
    0.12439049f, -0.03946061f, -0.13835804f, 0.02098098f, 0.07446194f, -0.40558070f, -0.19798869f, -0.33145508f, 
    0.15496096f, -0.15560824f, 0.05768946f, 0.05818368f, 0.13961716f, 0.00960817f, 0.02192523f, 0.13237010f, 
    -0.17565055f, 0.23357129f, 0.05404374f, 0.13251886f, -0.02865382f, -0.21841207f, 0.05979900f, -0.11487701f, 
    0.00546141f, 0.15634343f, 0.13473137f, 0.16113836f, 0.71323520f, -0.16549963f, -0.10699605f, 0.28336126f, 
    0.02689157f, 0.01822441f, -0.04270671f, 0.09900128f, -0.01837185f, 0.02771186f, 0.03292785f, -0.09780662f, 
    -0.07277303f, 0.18272975f, 0.04831625f, 0.18378270f, -0.09023683f, 0.02868728f, -0.06611945f, -0.03807326f, 
    -0.07390743f, 0.00048644f, 0.10484654f, 0.13159683f, 0.33742827f, 0.08233931f, -0.24154820f, 0.27120736f, 
    0.13662945f, -0.03082038f, -0.07981564f, 0.11355461f, -0.02553944f, -0.01694956f, 0.10439546f, 0.00189388f, 
    0.12329452f, -0.13483864f, -0.07340041f, -0.10790948f, 0.27627948f, 0.02406632f, 0.20272414f, 0.03281788f, 
    0.01907451f, 0.07597049f, 0.15039690f, -0.08529433f, 0.48143700f, -0.00654890f, -0.11095442f, -0.06720597f, 
    0.18410738f, 0.13045205f, 0.14196281f, -0.06239762f, -0.00184603f, 0.08317976f, 0.03519456f, -0.01572605f, 
    0.00624912f, -0.07065006f, -0.05377859f, 0.00996340f, -0.02375678f, -0.01330960f, 0.01465986f, 0.01386864f, 
    0.01056616f, 0.02298482f, -0.02759510f, 0.03934743f, -0.05865647f, -0.02100705f, -0.00969701f, -0.06758354f, 
    -0.03140428f, -0.01195800f, -0.04254171f, 0.00850990f, 0.05996903f, 0.00855571f, -0.01244319f, -0.04347503f, 
    -0.07180194f, 0.00561722f, -0.01961759f, -0.03721301f, -0.04186546f, -0.00049510f, -0.05459886f, -0.06041479f, 
    0.05668178f, 0.00994401f, 0.03034648f, -0.05039049f, 0.05317919f, -0.02011537f, -0.01116003f, -0.02257879f, 
    0.04843425f, -0.07240426f, -0.05344553f, 0.00095196f, -0.01655764f, -0.01014278f, -0.01035216f, -0.04246512f, 
    -0.07779249f, -0.00814206f, -0.01112813f, 0.06869785f, 0.04891984f, 0.01059783f, 0.02210248f, 0.03881938f, 
    -0.02217273f, -0.00358303f, 0.06364902f, -0.05660430f, 0.01662854f, 0.00267360f, -0.07317376f, 0.05858286f, 
    0.03400751f, -0.05381024f, 0.06768291f, 0.04834173f, 0.02032119f, -0.02826789f, -0.00894138f, 0.00585633f, 
    -0.01911461f, 0.04134743f, -0.01258665f, 0.00984850f, 0.00115041f, -0.01141130f, -0.05642160f, -0.01278950f, 
    -0.04755516f, -0.03075127f, -0.00374728f, -0.05495139f, -0.04294187f, -0.06236196f, -0.02410949f, 0.01827241f, 
    -0.05951221f, 0.06124089f, -0.00502875f, 0.02705761f, 0.00402927f, 0.06562596f, 0.04971061f, -0.05906496f, 
    -0.03206325f, 0.01130565f, -0.07282870f, -0.04419723f, -0.04282742f, -0.07235964f, 0.03081342f, 0.02473150f, 
    0.02750299f, 0.02648026f, 0.05528446f, -0.03509090f, 0.03807160f, -0.07287843f, 0.00791687f, -0.02373335f, 
    -0.07574517f, 0.03596370f, 0.03338834f, 0.00469591f, 0.00886234f, -0.05624672f, 0.01825527f, -0.06680831f, 
    -0.05144104f, 0.04499553f, -0.01680462f, 0.02786689f, -0.05368795f, 0.03172467f, 0.04524747f, -0.00890151f, 
    0.03129520f, -0.07381911f, -0.07271220f, -0.02540834f, -0.03850413f, 0.04521459f, -0.04805267f, -0.06699405f, 
    0.01406043f, 0.02143574f, -0.07061775f, 0.00902544f, -0.00890855f, -0.02591241f, -0.06376622f, 0.05720609f, 
    0.04640231f, -0.03822698f, 0.05041049f, 0.04849507f, -0.02475031f, -0.05005158f, 0.02886784f, 0.02158490f, 
    -0.02531418f, 0.05132328f, 0.03746286f, -0.06745601f, -0.02710880f, -0.07051269f, -0.01809007f, 0.03930476f, 
    -0.02039639f, -0.00711697f, -0.01434941f, -0.02125774f, -0.05421599f, 0.02525522f, -0.01102409f, -0.01229370f, 
    -0.01186536f, 0.02900671f, -0.02532298f, -0.04067706f, -0.05284795f, 0.02978421f, 0.03936834f, 0.03968704f, 
    -0.02980141f, -0.07420577f, 0.06480411f, -0.03149341f, -0.07336602f, -0.07613019f, 0.03115877f, -0.03586525f, 
    0.02415701f, -0.05342671f, -0.00476758f, -0.00183915f, -0.01591672f, 0.06150239f, -0.00463151f, 0.01685400f, 
    -0.17723097f, -0.62964809f, -0.19300352f, 0.05554586f, 0.04561245f, 0.17548028f, -0.00534127f, -0.08594836f, 
    -0.01216840f, -0.08097168f, 0.14588146f, 0.09851097f, -0.00208976f, 0.05060882f, 0.26524282f, 0.25571513f, 
    0.17102258f, 0.08546396f, -0.05093094f, -0.03260238f, 0.03909707f, 0.05388556f, 0.03797363f, 0.31134084f, 
    -0.28521594f, 0.08552498f, 0.03546753f, 0.06700467f, -0.04790591f, -0.10021982f, -0.01406166f, -0.17965847f, 
    0.02397560f, -0.11600977f, 0.08245376f, 0.03972218f, -0.13797386f, -0.13292947f, 0.31246117f, 0.51570612f, 
    0.11860619f, 0.04567699f, 0.12890494f, -0.15698767f, 0.23227912f, -0.03748429f, 0.12355992f, 0.14671376f, 
    0.21855450f, -0.49126896f, -0.06961326f, -0.14476329f, 0.03277398f, 0.03850660f, 0.07724795f, 0.10975754f, 
    -0.04596171f, 0.21842584f, -0.00975162f, -0.06344549f, 0.10438699f, -0.05733050f, 0.16371708f, 0.06522138f, 
    0.01973464f, -0.00582980f, -0.15685031f, 0.33231658f, -0.01743199f, 0.06424291f, 0.07796002f, 0.01640559f, 
    0.29012069f, 0.01208914f, 0.14719462f, 0.26616427f, 0.11287183f, -0.02033037f, -0.06324165f, -0.07052001f, 
    -0.01179641f, -0.02403218f, -0.01284484f, 0.08541582f, -0.31757957f, -0.00209184f, 0.04694640f, -0.31647232f, 
    -0.04427591f, -0.03731215f, -0.13984114f, -0.05868987f, 0.17574333f, 0.03927612f, 0.03693863f, 0.17376803f, 
    -0.40552017f, 0.00700967f, 0.15704061f, 0.24111314f, -0.04091636f, -0.21347646f, 0.08459523f, 0.03143325f, 
    -0.04126320f, -0.05815504f, 0.12932159f, -0.17581974f, 0.09932327f, 0.04512820f, 0.13723159f, 0.22585543f, 
    -0.18030177f, 0.13802934f, -0.07736932f, 0.16873524f, 0.08655926f, -0.02005603f, 0.07228077f, 0.13961597f, 
    0.29184234f, -0.20523629f, -0.21283782f, 0.21165709f, 0.16679414f, 0.16212821f, -0.02031637f, 0.00932857f, 
    0.22336708f, 0.17392205f, -0.19304796f, -0.11541436f, -0.51552671f, 0.22636484f, 0.01531759f, -0.08831652f, 
    0.15284415f, 0.07961287f, 0.11366349f, 0.08155867f, 0.03850096f, 0.05747457f, -0.07903013f, 0.04189100f, 
    -0.36125273f, -0.44800141f, 0.07582733f, 0.37575057f, -0.04212981f, 0.13369468f, 0.06223197f, 0.07569472f, 
    -0.00888569f, 0.11512800f, -0.06063626f, -0.11349840f, -0.22712153f, 0.15517470f, -0.07280038f, -0.08109886f, 
    0.05163928f, 0.05843878f, 0.09070636f, 0.01754870f, -0.01039675f, 0.10907575f, 0.16037041f, -0.03346949f, 
    0.45472878f, 0.00077612f, 0.12746774f, 0.08896341f, -0.10983121f, 0.05184251f, -0.11428314f, -0.11461510f, 
    -0.03791235f, 0.05098435f, -0.09885036f, 0.02455539f, -0.16096531f, 0.33972549f, -0.13394041f, 0.05739056f, 
    -0.16580862f, -0.30211976f, -0.16669315f, -0.10289243f, -0.06266633f, -0.10652031f, 0.06415667f, -0.05327920f, 
    0.03820676f, -0.08883632f, -0.09313210f, 0.36007661f, -0.18780367f, 0.12231317f, 0.15365493f, 0.06111074f, 
    -0.11411154f, -0.14605378f, 0.06252433f, -0.11348992f, 0.10579447f, 0.33172178f, 0.24434316f, 0.39440244f, 
    0.01575428f, -0.11689505f, -0.06974164f, -0.04188601f, -0.02084057f, -0.11618688f, 0.11121397f, 0.26300603f, 
    0.19173653f, -0.13015817f, 0.10898563f, -0.17153122f, 0.03959562f, 0.02946693f, -0.03701206f, -0.24823405f, 
    0.10856562f, 0.03636795f, 0.01397913f, 0.20128079f, 0.41387099f, 0.01894789f, -0.07391094f, 0.09675311f, 
    -0.15611315f, 0.08882101f, -0.01760858f, -0.02470205f, 0.03005170f, -0.08395150f, 0.04120978f, 0.16275066f, 
    0.25529304f, -0.42405161f, 0.19629723f, -0.08858385f, -0.02407886f, -0.04365298f, 0.06048197f, 0.11892734f, 
    -0.10919107f, -0.02637861f, -0.01810561f, 0.07788377f, 0.13014445f, -0.13794762f, -0.08186526f, -0.04531174f, 
    0.09048232f, 0.10700668f, -0.03499455f, 0.06626545f, -0.14534394f, -0.02530129f, 0.03314445f, 0.07238121f, 
    -0.14105159f, -0.19497424f, 0.19140580f, 0.29157582f, -0.20814529f, 0.03336806f, 0.03104004f, 0.07065473f, 
    -0.00257881f, -0.07146414f, -0.00564862f, -0.02876417f, 0.23192750f, -0.05331435f, -0.00525298f, 0.11816864f, 
    -0.03752544f, -0.18425858f, -0.00387766f, -0.02265024f, 0.10507936f, -0.00322049f, -0.03514213f, -0.01705375f, 
    -0.25919726f, 0.01487367f, -0.11839522f, -0.56410217f, 0.03147474f, 0.10517220f, 0.24075568f, 0.01339979f, 
    0.05915269f, 0.03397525f, 0.00308941f, 0.04302486f, -0.30211592f, -0.11883736f, -0.44015789f, -0.10581212f, 
    0.12405802f, 0.03188437f, 0.01424161f, 0.04149531f, 0.16799870f, -0.08096506f, 0.09166560f, 0.18129604f, 
    0.03778715f, 0.10446156f, 0.08522760f, 0.11031727f, -0.00470200f, 0.01539758f, 0.15381248f, -0.12686445f, 
    -0.07208028f, 0.15173268f, -0.02632308f, -0.05662541f, 0.24650046f, 0.00273965f, 0.09243822f, -0.04079178f, 
    0.00429517f, 0.08933672f, -0.01305920f, 0.04764014f, -0.03452503f, 0.01874192f, -0.01376885f, -0.06481145f, 
    -0.31553397f, -0.14747703f, 0.18855925f, 0.37246767f, -0.12005562f, 0.04555888f, -0.07550601f, 0.01114677f, 
    -0.17637475f, -0.03011931f, -0.16310345f, -0.07314372f, 0.03066959f, 0.37278661f, 0.00601309f, 0.05012869f, 
    0.05341923f, 0.20941824f, 0.09754289f, -0.02025094f, -0.16177036f, -0.03257332f, 0.17618850f, -0.10769293f, 
    0.12016723f, 0.04083390f, -0.17648186f, -0.01942755f, 0.00021150f, -0.01126819f, 0.02849483f, -0.01589930f, 
    -0.08399561f, -0.02894296f, 0.01053507f, -0.02507847f, 0.13251910f, 0.11902725f, -0.22479232f, -0.04612209f, 
    0.13704942f, 0.02377100f, -0.03430692f, -0.20418331f, 0.03773606f, 0.12597513f, -0.00749783f, 0.08485544f, 
    0.14409010f, -0.00249310f, 0.16148546f, -0.18764956f, 0.06799080f, 0.09068806f, -0.00235652f, -0.15550081f, 
    -0.10479285f, -0.06357156f, 0.03910850f, 0.02133138f, 0.09545302f, -0.03078707f, -0.14661844f, 0.32798672f, 
    -0.13676484f, 0.02388361f, 0.05409892f, 0.15784088f, 0.09400180f, 0.18590553f, 0.02845127f, 0.10921762f, 
    0.10001940f, 0.47417349f, -0.24008612f, 0.18267961f, -0.06365024f, 0.04980450f, 0.15763022f, 0.18092671f, 
    -0.13053310f, 0.22640769f, 0.03926505f, 0.07174813f, 0.06773417f, 0.32376006f, -0.18157876f, -0.05938890f, 
    0.32653219f, -0.10183261f, 0.15212595f, -0.24110620f, -0.00343058f, -0.03611355f, 0.04478319f, -0.06702586f, 
    -0.17786862f, 0.57825464f, 0.24879642f, 0.32089886f, 0.04105132f, 0.09891686f, -0.00292445f, -0.04074215f, 
    -0.02422877f, 0.01657372f, 0.01815846f, 0.15287641f, 0.21019262f, -0.17143300f, -0.03048753f, 0.18018903f, 
    -0.03618818f, 0.01926260f, 0.02909010f, -0.09478021f, -0.05625779f, 0.08149567f, -0.04939573f, 0.02642592f, 
    0.25003189f, 0.19603011f, -0.19546479f, -0.19132951f, 0.33200604f, -0.05942149f, -0.12458732f, -0.17681587f, 
    -0.08923686f, -0.02118711f, -0.08228622f, 0.13754795f, 0.57326692f, -0.00054058f, 0.04125963f, -0.00655283f, 
    -0.06056260f, 0.28173873f, 0.07487493f, 0.00213806f, 0.08426731f, -0.04562249f, -0.03863349f, 0.21628213f, 
    0.25083154f, -0.11362135f, 0.18764676f, -0.10836102f, 0.24653734f, 0.19002561f, 0.14851202f, 0.13778540f, 
    -0.15863627f, -0.17806818f, 0.07856571f, 0.19254781f, -0.08967445f, -0.20987806f, 0.21822904f, -0.26553595f, 
    0.02070158f, 0.13182136f, 0.03060445f, -0.05531333f, -0.07021768f, -0.13067733f, -0.17587422f, -0.21056569f, 
    0.54004043f, 0.07860874f, -0.16638486f, -0.01053023f, -0.00550717f, 0.00866886f, -0.07659515f, 0.14268486f, 
    -0.15869185f, 0.03942417f, 0.27974221f, 0.00550754f, -0.73090851f, 0.10005639f, -0.04351373f, 0.11293668f, 
    0.06364303f, -0.07559488f, -0.01562553f, -0.07863604f, -0.01015946f, 0.22026061f, 0.02270718f, 0.02703134f, 
    -0.03706539f, -0.00608972f, 0.04017770f, -0.32715687f, 0.00372826f, -0.09654168f, -0.00166537f, -0.11338729f, 
    -0.00322401f, -0.02184607f, -0.14175865f, -0.01224841f, -0.37658730f, -0.14997178f, 0.31916490f, 0.08138982f, 
    -0.03787469f, -0.29341927f, 0.18611330f, -0.03708260f, 0.11771219f, 0.02457463f, -0.03695756f, 0.13156329f, 
    -0.46243036f, 0.68008083f, 0.30338410f, 0.18929863f, 0.11134091f, 0.03655561f, 0.01071686f, -0.07062965f, 
    -0.04363215f, 0.04587773f, 0.08597499f, 0.05810618f, -0.19064237f, 0.10869036f, -0.24164265f, -0.34361398f, 
    0.20791289f, -0.05870189f, 0.09168824f, -0.07413215f, 0.12102331f, -0.16209477f, 0.23236540f, -0.16032481f, 
    0.03548696f, -0.05630681f, -0.07237116f, -0.07060795f, 0.01163322f, 0.05914029f, -0.04063195f, 0.01851112f, 
    0.02678516f, -0.03908261f, 0.06230183f, -0.00348765f, -0.03539327f, 0.04192614f, 0.04233056f, -0.01596317f, 
    -0.01459356f, -0.07861636f, 0.04481867f, 0.00734861f, 0.02017363f, 0.03134122f, -0.06460261f, -0.02806602f, 
    -0.03908566f, -0.07865382f, 0.05666008f, 0.01477395f, -0.04728528f, -0.07660346f, 0.04737647f, -0.01613229f, 
    0.02260103f, -0.05474821f, -0.07544094f, -0.00718450f, -0.00024211f, -0.02713048f, -0.07669189f, 0.00518478f, 
    0.02780074f, -0.03645497f, -0.07902780f, -0.02632865f, -0.07701962f, -0.08118421f, -0.05974158f, -0.05391538f, 
    -0.07131335f, -0.04817013f, -0.07521024f, -0.00467107f, 0.02041916f, -0.00555431f, 0.03675177f, 0.01031113f, 
    -0.04689749f, 0.02077592f, 0.05784824f, 0.03554504f, 0.02433669f, -0.05144532f, 0.03578174f, 0.01218752f, 
    0.03267671f, 0.04221218f, -0.06436603f, -0.00379487f, 0.03763812f, -0.04199111f, -0.01845475f, -0.06596885f, 
    -0.04148557f, 0.05427086f, -0.07586624f, -0.02611380f, -0.03922986f, -0.01557277f, -0.04881252f, 0.05963422f, 
    -0.01490069f, -0.03882640f, 0.01779006f, 0.05369308f, -0.06731007f, 0.04418970f, -0.00311366f, -0.03557746f, 
    -0.00507133f, 0.02071738f, 0.03469791f, -0.06363302f, -0.07196264f, -0.03341081f, 0.03777352f, 0.01478984f, 
    0.04760553f, -0.07524259f, -0.03372569f, -0.06023797f, -0.05660012f, -0.00199290f, 0.04557651f, -0.06159452f, 
    -0.04849123f, 0.05715070f, 0.01581824f, 0.01813456f, -0.04087340f, 0.03740963f, 0.01313497f, 0.02849729f, 
    -0.00319101f, -0.06983634f, -0.00706291f, -0.05851621f, 0.03416397f, -0.02555543f, 0.03522323f, 0.00993885f, 
    -0.02725921f, 0.05680952f, 0.04951949f, -0.01414799f, -0.00773055f, -0.00148584f, -0.02483893f, -0.07329939f, 
    -0.04854330f, -0.04997481f, -0.03071009f, 0.03446994f, 0.00168255f, -0.03179483f, -0.02056100f, 0.05453769f, 
    -0.03988655f, 0.04277619f, 0.00395627f, -0.06827986f, -0.04657611f, -0.02622009f, 0.01913029f, -0.04144901f, 
    -0.02434188f, -0.00576168f, 0.03474115f, -0.01748319f, -0.07002685f, -0.00991613f, -0.07311936f, 0.04790331f, 
    0.05030457f, -0.08134915f, 0.05768169f, -0.00803061f, -0.03925761f, 0.05437789f, 0.03380091f, 0.03808777f, 
    -0.02483496f, -0.04110971f, -0.07261297f, 0.01809750f, 0.01569058f, -0.05065703f, -0.02758888f, -0.07165550f, 
    -0.02979738f, -0.02276886f, 0.03451515f, 0.03887790f, -0.04969640f, -0.01619951f, -0.01979616f, -0.05848157f, 
    -0.03052354f, -0.02711956f, 0.00702218f, -0.08069316f, 0.06194527f, 0.00044643f, -0.02704311f, -0.06817722f, 
    -0.01877835f, 0.03387446f, -0.06870515f, -0.00123698f, -0.03452552f, -0.06625046f, -0.02803391f, -0.05254234f, 
    -0.36660439f, 0.20985326f, 0.22541337f, 0.40071720f, 0.18506491f, 0.16958104f, -0.01894584f, 0.00681294f, 
    0.13757440f, 0.00835141f, -0.07375208f, 0.06079294f, 0.14710338f, -0.15602033f, -0.15353870f, -0.40571332f, 
    0.18982479f, 0.27438575f, -0.01104414f, 0.00623380f, -0.06479079f, -0.08458479f, -0.02636663f, 0.09884585f, 
    -0.31101105f, 0.14109956f, 0.05875161f, -0.03060647f, -0.03709633f, 0.23838542f, 0.17456691f, 0.04916695f, 
    0.22627333f, 0.11410575f, 0.04075854f, 0.06571009f, 0.04849485f, 0.10686646f, -0.17124885f, -0.45221972f, 
    -0.04115022f, -0.05460569f, 0.11359777f, -0.00800035f, -0.10315154f, 0.15921369f, -0.13806397f, -0.25943837f, 
    -0.26659900f, -0.02873488f, 0.13472830f, 0.05229282f, 0.04336981f, 0.13022451f, -0.14469084f, 0.12061657f, 
    0.09849914f, -0.03029756f, 0.01195826f, 0.04043751f, -0.05303377f, 0.00872023f, 0.19509551f, -0.21686792f, 
    0.03920971f, -0.06963269f, 0.18375637f, 0.00783084f, -0.00200321f, 0.05018849f, 0.06995798f, 0.00156642f, 
    -0.43598959f, 0.31053868f, 0.07038704f, -0.29020670f, 0.12226538f, 0.09301673f, -0.01319393f, 0.09057348f, 
    0.04196230f, 0.01247569f, 0.19163321f, 0.08621143f, -0.03832898f, 0.02036014f, 0.12641680f, 0.23686457f, 
    0.13255261f, 0.16020581f, -0.10994598f, -0.07209926f, 0.04048893f, 0.01776030f, -0.03678253f, 0.04066752f, 
    -0.38320774f, -0.15458900f, 0.03231062f, -0.08477155f, -0.19110678f, -0.12309314f, -0.14778966f, 0.15687944f, 
    0.01562053f, 0.18461178f, 0.08156096f, 0.13372965f, -0.10512723f, -0.18630619f, 0.08080650f, -0.02017405f, 
    0.10985724f, 0.09008683f, -0.01252932f, -0.13986973f, 0.16635187f, 0.20239046f, -0.01360452f, 0.10212827f, 
    -0.41652817f, 0.10576347f, 0.10422715f, -0.14091189f, -0.10975801f, 0.06026550f, 0.13798715f, -0.05870029f, 
    -0.00559339f, 0.11183108f, 0.06225336f, 0.21179868f, 0.74840689f, -0.11389858f, 0.05216773f, 0.12773098f, 
    -0.06029939f, -0.00864131f, -0.19964777f, 0.04271126f, 0.05356912f, -0.13822812f, 0.03716927f, 0.00142295f, 
    -0.05373485f, 0.20961431f, 0.11630496f, -0.17579597f, 0.27645031f, 0.09073696f, -0.03191020f, -0.09719268f, 
    0.09908178f, -0.02588419f, 0.20993009f, -0.03477728f, 0.44114518f, -0.01507682f, -0.21951514f, 0.15309121f, 
    0.02002511f, 0.02554426f, -0.10221395f, 0.21530588f, 0.05588511f, 0.06940093f, 0.10413176f, 0.07574981f, 
    -0.24705154f, 0.17773974f, -0.33930832f, -0.06082988f, 0.17315879f, 0.16582541f, 0.06156332f, 0.06426816f, 
    0.09792087f, -0.06319729f, 0.02637996f, 0.11525561f, 0.72803539f, -0.35123321f, 0.12979876f, 0.19531043f, 
    -0.03109454f, -0.00153699f, 0.12728140f, 0.25350735f, -0.06786815f, -0.03900576f, 0.14816791f, 0.09850901f, 
    0.41898063f, -0.22142224f, -0.50697052f, -0.05340660f, 0.17905210f, 0.02061670f, -0.13355815f, 0.05005367f, 
    0.26896337f, -0.04708310f, 0.10108671f, 0.07675730f, -0.05720120f, 0.24910507f, 0.26931787f, -0.05323699f, 
    0.06062969f, -0.00401705f, -0.11627733f, 0.12295590f, 0.01075194f, -0.08796886f, -0.04316939f, 0.20920612f, 
    0.18338966f, 0.14014243f, -0.00018238f, 0.03317852f, -0.08300416f, 0.02794915f, 0.16392541f, -0.13107443f, 
    -0.06361336f, -0.05579749f, 0.04781169f, -0.11740647f, -0.11279411f, -0.25386792f, 0.11630421f, 0.21872132f, 
    0.08258794f, 0.11496107f, 0.02749977f, -0.23375750f, -0.12086333f, -0.14105979f, 0.09714453f, -0.11256819f, 
    0.40471601f, 0.28371269f, -0.08770158f, 0.32235923f, -0.01125748f, 0.11548600f, -0.13448828f, 0.14802477f, 
    0.05433365f, 0.22311600f, -0.13757838f, 0.02978850f, 0.30143788f, 0.44432163f, 0.44544032f, -0.01350510f, 
    -0.14070658f, -0.03048158f, -0.13613501f, -0.00208909f, 0.00353925f, -0.09946160f, -0.05628233f, 0.01071493f, 
    0.19022916f, -0.38285330f, -0.06361428f, -0.03849877f, 0.18601920f, 0.01199170f, -0.05917656f, -0.08678317f, 
    0.00091307f, -0.06123146f, 0.16870625f, -0.07428043f, 0.14642043f, -0.09875490f, -0.15236878f, -0.09821479f, 
    0.05064264f, -0.10856346f, -0.13905270f, -0.01138328f, 0.21918282f, -0.08825344f, -0.02319040f, -0.01012149f, 
    -0.26782379f, 0.30128378f, 0.21413696f, 0.08898639f, -0.24158114f, 0.00034450f, 0.19256714f, 0.13307022f, 
    -0.05668373f, -0.24578729f, -0.05483298f, -0.12965478f, 0.45712626f, 0.43696943f, 0.29568353f, 0.19016781f, 
    -0.11470506f, -0.13461797f, -0.09263371f, -0.02121692f, 0.10116220f, -0.16844514f, -0.01747657f, 0.03738198f, 
    -0.18122794f, 0.14030735f, -0.03331957f, -0.11233981f, -0.07493940f, 0.08963478f, 0.03269568f, 0.00552248f, 
    0.12449402f, 0.07202449f, 0.01043895f, 0.14675485f, 0.05072666f, 0.19995570f, 0.05980404f, 0.23929782f, 
    0.08655631f, 0.10508216f, 0.21721897f, -0.04982396f, 0.07220802f, 0.05264205f, -0.04157417f, -0.06666838f, 
    -0.10424629f, -0.46074280f, -0.20282499f, -0.03828902f, 0.25800925f, 0.10281671f, -0.08578665f, -0.00291124f, 
    -0.16911776f, -0.04045049f, -0.13754845f, -0.02670024f, -0.22903734f, -0.02656732f, 0.06602148f, -0.24204096f, 
    0.05305012f, -0.09169287f, 0.05000290f, -0.05876046f, -0.11505993f, 0.08964781f, 0.11428082f, -0.01738691f, 
    0.21425608f, 0.20922513f, -0.50467193f, 0.22322328f, 0.06193981f, 0.11603207f, 0.00961461f, -0.10340009f, 
    0.06202748f, -0.05105505f, 0.04051223f, 0.00860391f, -0.06896553f, -0.08668697f, 0.01307150f, 0.06114246f, 
    0.10690486f, -0.07118417f, -0.09042976f, -0.07429683f, -0.08157770f, -0.04517776f, 0.08300692f, 0.03132856f, 
    0.03430059f, 0.08636039f, -0.11751524f, -0.21884036f, 0.25580528f, 0.14940076f, -0.02406937f, -0.20714939f, 
    -0.08559931f, -0.18996708f, 0.03535317f, -0.04645135f, 0.16144696f, -0.24287789f, -0.09868058f, -0.06946181f, 
    0.01309952f, -0.00457553f, -0.07903396f, -0.04808220f, -0.05844143f, -0.06820740f, 0.05742672f, 0.09646524f, 
    0.14074060f, 0.26632786f, 0.09492785f, 0.16085483f, -0.24548225f, 0.00100567f, -0.04528709f, -0.02969254f, 
    0.19806491f, 0.15471001f, 0.07490040f, -0.06156969f, -0.30990934f, 0.06672101f, -0.22189078f, -0.01746745f, 
    0.05366269f, -0.00369571f, 0.16127741f, -0.19413371f, -0.16242626f, 0.17909460f, 0.22730224f, 0.28456816f, 
    -0.08957116f, 0.28767756f, 0.32529986f, -0.31959012f, 0.02928527f, -0.11378185f, -0.17465059f, 0.17777282f, 
    0.11161350f, 0.02936175f, -0.06903622f, -0.01734564f, 0.11640210f, 0.02434167f, 0.16794929f, 0.23672543f, 
    -0.01366465f, 0.20345661f, -0.06943584f, 0.17103644f, -0.04826947f, 0.04320026f, -0.13140166f, -0.01542846f, 
    -0.13287891f, -0.01251588f, 0.00262936f, 0.09000330f, 0.25916415f, -0.03179350f, -0.12728749f, -0.18865643f, 
    0.00692075f, -0.02817922f, -0.14129038f, 0.02308893f, 0.49385601f, 0.12066917f, 0.04573401f, 0.09649201f, 
    -0.03792987f, 0.07339787f, 0.07742720f, -0.17980418f, 0.00479639f, 0.06827638f, 0.03460231f, 0.03119318f, 
    -0.18771458f, 0.23809755f, 0.42714339f, -0.02751735f, 0.10132122f, 0.22898124f, -0.10760634f, 0.02956063f, 
    0.06194568f, -0.03549526f, 0.05928518f, -0.03428842f, -0.22829883f, 0.00494759f, 0.19280225f, 0.04205254f, 
    0.14576906f, -0.00393495f, 0.01336468f, 0.09840697f, -0.03697120f, -0.00671287f, 0.05180342f, 0.07030670f, 
    -0.12429386f, 0.29563192f, -0.13098389f, -0.08608765f, -0.01361276f, 0.02113123f, 0.08964992f, 0.03479240f, 
    0.14371774f, 0.07859670f, -0.03410826f, 0.06946953f, -0.00398381f, -0.31236944f, 0.06840892f, 0.18919869f, 
    0.00550698f, 0.09606141f, -0.12898105f, 0.09699407f, -0.00853850f, 0.01663184f, -0.10279428f, -0.12317541f, 
    -0.24118832f, -0.12450973f, 0.09175074f, -0.05213149f, 0.23592715f, -0.11816587f, -0.07577822f, -0.09032387f, 
    0.05538995f, -0.03780073f, -0.06672668f, 0.08380157f, -0.51735854f, 0.06310099f, 0.19986153f, -0.00492577f, 
    -0.04890301f, -0.12498567f, -0.14003719f, -0.03462701f, 0.05911655f, 0.08384148f, 0.05277039f, -0.16463837f, 
    -0.50269836f, 0.29415134f, -0.13592902f, -0.12094306f, -0.13004738f, -0.05780894f, 0.01774690f, 0.08971842f, 
    0.01020665f, 0.25965044f, 0.06265777f, 0.18527506f, 0.35405585f, 0.13662201f, 0.29592061f, -0.11455114f, 
    0.05066559f, 0.04122888f, -0.04423969f, -0.26979050f, 0.00714540f, 0.11050557f, 0.05121440f, 0.15738429f, 
    -0.04102910f, -0.34535968f, 0.08538308f, -0.33035445f, 0.06757747f, 0.03133420f, 0.01510748f, -0.04376675f, 
    0.15310340f, 0.16825847f, 0.02975452f, 0.03966101f, -0.11717011f, -0.00038862f, -0.01073394f, -0.46991754f, 
    0.03142133f, 0.05464735f, 0.09966764f, 0.00800605f, 0.12278612f, 0.09922319f, -0.08954807f, -0.28374338f, 
    -0.14254473f, 0.29116562f, -0.08209568f, 0.30167606f, 0.02416148f, 0.07448871f, 0.14724305f, 0.11433990f, 
    -0.15154208f, -0.04426527f, -0.13401841f, -0.03153744f, -0.20167372f, -0.23724677f, 0.16120154f, 0.42155311f, 
    0.24478015f, -0.02304110f, 0.06794219f, 0.05254202f, 0.01339875f, 0.09384847f, 0.08815972f, -0.02550780f, 
    -0.34418443f, 0.08676820f, 0.05668290f, -0.25381765f, 0.01938297f, 0.10657375f, 0.15680866f, -0.03434119f, 
    -0.03428676f, 0.12613291f, 0.02814701f, 0.03104280f, 0.33252999f, 0.14701903f, 0.12914728f, -0.05931023f, 
    -0.07538953f, 0.03644977f, 0.00465448f, 0.00982676f, 0.10508753f, 0.09746721f, -0.12823892f, 0.14830124f, 
    0.16579525f, -0.21766776f, -0.05681191f, -0.04173862f, 0.18600108f, -0.00549746f, -0.13106826f, -0.09827698f, 
    0.03257818f, -0.06051154f, -0.04712773f, 0.02597698f, -0.17943025f, -0.25049388f, -0.13998559f, -0.17945063f, 
    0.17993303f, -0.04351892f, -0.01670263f, 0.09410022f, -0.02959158f, -0.06184410f, 0.18561375f, -0.09335883f, 
    0.36341766f, 0.25971308f, 0.18115924f, 0.25742507f, -0.01932843f, -0.18884319f, 0.07973069f, 0.11143002f, 
    -0.01066315f, -0.00377405f, 0.01347949f, -0.06112862f, 0.49337289f, 0.16170350f, 0.28423649f, -0.06624048f, 
    -0.12444737f, -0.07977334f, -0.00503334f, 0.09382503f, -0.05345714f, 0.11361681f, 0.03198481f, 0.01246403f, 
    0.22088982f, -0.09058060f, 0.10291178f, 0.31699851f, 0.11184392f, 0.01967450f, -0.14160763f, -0.04156055f, 
    -0.00584972f, 0.06310971f, 0.10702046f, 0.09330417f, 0.04448162f, 0.17649895f, 0.03491453f, 0.25326350f, 
    0.08170766f, -0.04118547f, 0.11151126f, -0.08088251f, 0.00561884f, 0.01875577f, 0.10698592f, 0.07002492f, 
    -0.06969143f, 0.11614468f, -0.17280436f, 0.06403518f, 0.02947946f, -0.00653173f, -0.05625062f, -0.04481602f, 
    -0.03120242f, 0.03206087f, 0.10604563f, -0.01666391f, -0.02089479f, -0.08875024f, -0.11504741f, 0.35591599f, 
    0.10410439f, -0.16982687f, -0.02766126f, 0.03295857f, 0.08825765f, -0.09674510f, -0.15481716f, 0.07504425f, 
    0.28783977f, -0.21915247f, 0.09775431f, 0.23170884f, 0.19540101f, -0.03980638f, 0.10232800f, 0.02617361f, 
    -0.02747168f, 0.03230596f, 0.10459149f, 0.03500054f, 0.03675174f, 0.21856311f, 0.17779595f, 0.00155879f, 
    0.07584818f, 0.05220653f, 0.03031662f, 0.19082604f, -0.02988531f, 0.04461815f, 0.02209198f, -0.19203982f, 
    0.14429361f, -0.28816611f, 0.07270841f, 0.17974395f, 0.17935015f, -0.02959734f, -0.10902151f, 0.00704713f, 
    0.27800152f, 0.09607086f, -0.01834640f, 0.19767441f, -0.03968452f, 0.09582759f, 0.02181535f, -0.12243872f, 
    0.18037865f, 0.14245911f, 0.12026149f, -0.11908915f, 0.09396818f, 0.14265583f, 0.03961256f, -0.10862773f, 
    -0.39244547f, 0.26483423f, -0.19126613f, 0.07162958f, -0.09743699f, -0.28401962f, 0.20020358f, 0.08098890f, 
    -0.01133497f, -0.03054880f, 0.02493602f, -0.06430900f, -0.06358279f, 0.12110145f, 0.21512462f, 0.10002698f, 
    0.09798113f, 0.02753503f, 0.19467296f, -0.16090131f, -0.09739334f, -0.11700798f, -0.06427104f, -0.32222393f, 
    0.13713738f, 0.24121882f, -0.18750159f, 0.42369065f, 0.00958564f, 0.18833265f, -0.02892990f, -0.05273002f, 
    0.05230840f, 0.16844448f, -0.02416654f, -0.04132488f, -0.03897721f, 0.32297632f, 0.12533613f, -0.32285413f, 
    -0.14348271f, -0.22057278f, -0.02419209f, 0.00949482f, 0.02068457f, 0.13636561f, 0.01986629f, -0.15143266f, 
    0.07383343f, -0.02157041f, -0.03965220f, -0.27275804f, 0.16413723f, 0.02225485f, -0.02225471f, 0.03178069f, 
    0.04705397f, 0.04509788f, 0.22198191f, 0.21011665f, -0.17046744f, -0.14744158f, 0.16015865f, -0.13979106f, 
    0.02581188f, 0.17446119f, -0.22835834f, 0.15963824f, 0.18036138f, -0.01534393f, 0.03753908f, -0.04175292f, 
    -0.44308043f, -0.37817961f, -0.08756239f, 0.33163169f, -0.28454831f, -0.10071696f, -0.03766405f, 0.00116958f, 
    -0.03984551f, 0.07411539f, 0.10202069f, -0.03920306f, 0.34871900f, 0.05190221f, 0.11525544f, 0.03446270f, 
    -0.08647002f, 0.12637796f, -0.18665913f, 0.00755491f, 0.06115093f, -0.04745723f, -0.18428506f, -0.05006653f, 
    0.07017118f, -0.14468667f, -0.06814901f, -0.04783516f, 0.04886197f, 0.00432052f, -0.02860886f, 0.13668285f, 
    0.03993944f, 0.03891677f, 0.10452729f, 0.15878050f, -0.47871748f, 0.34004268f, -0.16192627f, -0.02855723f, 
    0.22254796f, -0.08161036f, 0.23974450f, 0.02710355f, 0.00618890f, 0.07735001f, 0.07911237f, 0.16100542f, 
    -0.00967949f, -0.14936066f, -0.04182817f, -0.15041541f, 0.14439313f, 0.12149718f, 0.07045588f, 0.12566848f, 
    0.10115613f, 0.13180643f, -0.01699116f, -0.16883191f, 0.02585586f, 0.10959899f, -0.02587781f, -0.10991984f, 
    -0.16158696f, -0.01237486f, 0.09996285f, 0.17775150f, 0.05769932f, 0.07480730f, -0.12066299f, 0.10626055f, 
    0.34453025f, 0.32214358f, 0.04871480f, 0.27189496f, -0.03272513f, 0.07630277f, -0.07280596f, 0.08159860f, 
    0.07498082f, -0.16163707f, 0.00990072f, 0.11068221f, -0.24679902f, -0.09524402f, 0.07250643f, 0.15920006f, 
    0.12387972f, -0.11848742f, 0.02054347f, 0.23742037f, -0.06379478f, -0.21993764f, 0.04643701f, -0.19870535f, 
    -0.22761723f, -0.11104691f, 0.03626779f, 0.24974339f, -0.10671128f, 0.03673292f, -0.08325021f, 0.07445910f, 
    -0.08317979f, 0.19859056f, -0.00231252f, 0.12843351f, -0.22564772f, -0.05223789f, 0.28664792f, -0.11050750f, 
    0.07552305f, 0.08290437f, -0.04377143f, -0.10737550f, -0.04321492f, 0.00581676f, -0.10086042f, 0.19752093f, 
    0.03856643f, 0.19077131f, 0.09540505f, -0.11821087f, -0.03777326f, 0.29459110f, 0.15673369f, -0.16150725f, 
    -0.02929258f, 0.00722202f, -0.06968923f, 0.15580487f, 0.27957141f, 0.20620346f, 0.05194330f, 0.04747678f, 
    -0.05852886f, 0.06412052f, 0.15459222f, 0.08752799f, 0.07167072f, -0.03824122f, -0.21103299f, -0.11000728f, 
    0.10586620f, -0.33130842f, -0.19620837f, -0.15969169f, 0.00969455f, 0.08240484f, 0.03157132f, 0.12354878f, 
    -0.16826116f, -0.07490182f, 0.08779994f, 0.03768736f, 0.04376992f, -0.18439400f, 0.18287332f, -0.18583928f, 
    -0.02578403f, 0.00856432f, 0.12963314f, 0.08770591f, -0.04721033f, -0.12902753f, -0.03947693f, 0.05390840f, 
    0.09943610f, 0.43990886f, 0.23126657f, 0.34781787f, -0.14782469f, -0.11291441f, -0.08343425f, 0.05859007f, 
    -0.05818922f, -0.04218396f, 0.13729540f, 0.08166768f, 0.08347452f, 0.06676270f, -0.10075082f, 0.00592941f, 
    -0.01185757f, 0.11797870f, -0.32676640f, 0.09780364f, 0.08335761f, 0.11653548f, -0.02910646f, -0.03622954f, 
    -0.42160508f, -0.08000826f, 0.12679869f, -0.17778043f, 0.08584827f, -0.24716276f, 0.13570662f, 0.06312368f, 
    -0.00245686f, 0.12740923f, 0.11660115f, 0.26869830f, -0.17061660f, -0.09783998f, -0.19601813f, -0.06302074f, 
    -0.00161668f, 0.21585739f, -0.15379387f, 0.10324475f, 0.03035627f, 0.19408751f, -0.17547725f, 0.09557365f, 
    0.08970432f, 0.04082973f, 0.15104593f, 0.26289016f, -0.12454455f, 0.15197548f, 0.13244909f, -0.22292402f, 
    -0.09693678f, 0.10426150f, 0.10048626f, 0.03319696f, 0.26964530f, 0.01999720f, 0.17099443f, 0.03529868f, 
    -0.02910010f, 0.05736347f, -0.10306308f, 0.00740540f, 0.19169047f, 0.01314112f, -0.04248279f, 0.14731649f, 
    -0.13046379f, -0.08851621f, 0.29513296f, 0.40704733f, 0.05082922f, 0.09612491f, -0.04748431f, -0.12844062f, 
    -0.02857276f, 0.02289319f, 0.00127858f, -0.16639206f, 0.34271669f, -0.05873883f, -0.24581553f, 0.22910644f, 
    -0.03159270f, 0.22283372f, -0.01975496f, 0.18345259f, 0.05239472f, 0.18678264f, 0.01647844f, -0.10880096f, 
    -0.14513937f, 0.15335532f, -0.15297678f, -0.07300761f, -0.06811286f, 0.09716541f, -0.17860754f, -0.01710672f, 
    -0.02249179f, -0.15946992f, -0.08442748f, -0.15347764f, 0.42507350f, -0.07347577f, -0.07040888f, 0.24280477f, 
    -0.07328793f, -0.01162168f, 0.06033271f, 0.02211645f, -0.06407353f, 0.05200867f, 0.22363541f, 0.03570887f, 
    0.47824231f, 0.29605949f, 0.17497906f, 0.10615582f, -0.00276930f, -0.14706099f, -0.03614123f, 0.08476435f, 
    0.00163789f, -0.10673402f, 0.01454962f, -0.13701707f, -0.09987547f, -0.25456190f, -0.18091722f, 0.07700427f, 
    0.06509928f, -0.11061993f, 0.11948021f, 0.08031176f, -0.07452127f, -0.05948531f, 0.20766136f, 0.16176380f, 
    0.30172381f, -0.28901547f, 0.04527296f, -0.20390484f, 0.07222625f, -0.25757179f, -0.12145233f, -0.12136621f, 
    0.04256082f, -0.03112396f, 0.28096661f, 0.02301085f, 0.16130497f, 0.09117459f, -0.07604375f, -0.00865767f, 
    -0.02935669f, -0.02786862f, -0.03199771f, 0.00036342f, 0.11613066f, 0.02814603f, 0.13597950f, 0.17498718f, 
    0.17736810f, -0.00954172f, 0.02225871f, 0.02396330f, 0.01446147f, 0.05161836f, -0.12550475f, -0.00993287f, 
    0.09015916f, -0.02969379f, 0.03593358f, -0.03370885f, -0.50101292f, -0.04773065f, -0.15185499f, 0.03075012f, 
    0.26057890f, 0.10529169f, -0.01881882f, 0.26910171f, 0.02737299f, 0.04144568f, -0.02026261f, -0.05577580f, 
    0.34179932f, 0.08211400f, 0.21396624f, 0.31620955f, 0.01027773f, -0.00217652f, 0.15593906f, 0.05641104f, 
    0.02021324f, 0.07368880f, -0.03046510f, -0.11353814f, 0.73000127f, 0.02407102f, 0.06333527f, 0.18711250f, 
    0.01628329f, -0.01895718f, -0.11715783f, -0.15390188f, 0.06519709f, 0.09806944f, -0.02706868f, 0.08586679f, 
    -0.01246856f, -0.16710442f, -0.02143312f, -0.30123246f, 0.02046480f, 0.14835744f, -0.15879080f, -0.07618251f, 
    0.23624265f, 0.00097699f, 0.00864924f, -0.01115064f, -0.21780333f, -0.11118996f, -0.30280992f, 0.13632661f, 
    0.19017830f, 0.14598426f, 0.11821759f, -0.10308484f, 0.13206470f, 0.06562354f, 0.01198553f, 0.08568393f, 
    -0.05634535f, -0.19270806f, 0.14960295f, -0.05396293f, -0.00637376f, -0.12167378f, 0.15071507f, 0.24000527f, 
    0.12895030f, 0.01830335f, -0.17512363f, -0.07592102f, -0.70069242f, 0.19060986f, -0.24528548f, -0.15664844f, 
    0.04466449f, 0.10856821f, 0.16273032f, 0.06160261f, 0.00375972f, -0.05943055f, 0.03101189f, 0.02119673f, 
    0.17745954f, -0.04257579f, 0.17925993f, 0.10447643f, -0.07619631f, -0.07975163f, -0.02472811f, 0.21149540f, 
    0.13473071f, -0.00221864f, -0.13990818f, 0.10827506f, -0.21282679f, 0.18554719f, 0.16401951f, -0.19031565f, 
    -0.10776717f, -0.03156761f, 0.12712474f, 0.01613935f, 0.03929216f, 0.08175954f, 0.13091351f, -0.02244057f, 
    -0.19284131f, -0.01051749f, 0.01622755f, -0.19324577f, -0.10209204f, 0.05983854f, 0.11854248f, 0.08395603f, 
    0.08436575f, 0.08049629f, -0.07249938f, 0.13565819f, -0.28342339f, -0.07756619f, 0.14579962f, 0.01230183f, 
    0.00784101f, 0.14482524f, 0.08475419f, -0.09345787f, -0.04618200f, -0.04077259f, -0.12358736f, 0.07115588f, 
    -0.03852407f, 0.37680352f, 0.02541409f, 0.26864430f, 0.02201894f, 0.26762658f, -0.02197990f, 0.00176766f, 
    -0.02893025f, 0.03227712f, 0.07115582f, -0.11170722f, 0.07320277f, -0.23288956f, -0.50485659f, 0.01062241f, 
    0.12980486f, 0.11433220f, -0.01221351f, -0.01650822f, 0.01296320f, -0.01651584f, 0.14893028f, 0.26299980f, 
    -0.42668545f, 0.14741038f, -0.13551079f, -0.19168867f, -0.03901039f, 0.03593630f, 0.10339447f, 0.09905499f, 
    0.08916289f, 0.10922203f, 0.05601131f, 0.09369101f, -0.07965536f, 0.20277213f, 0.14565283f, -0.37376305f, 
    0.05805061f, -0.11408480f, 0.08509010f, -0.06472696f, -0.06614549f, -0.03562776f, -0.14520477f, -0.00649463f, 
    -0.03976233f, 0.12827480f, -0.30861515f, 0.34761891f, 0.07508636f, 0.05162046f, -0.01559547f, -0.00305859f, 
    0.13222119f, 0.01860884f, -0.04951844f, -0.05510580f, -0.33007857f, -0.19851848f, -0.01871860f, 0.16699825f, 
    0.01333986f, 0.13677441f, 0.07237268f, -0.03755988f, 0.04177458f, -0.05257715f, 0.09959085f, -0.01445675f, 
    0.22179399f, 0.44218227f, 0.15330443f, 0.08163389f, 0.31111377f, 0.18372364f, -0.01456378f, -0.04132262f, 
    0.04936245f, 0.08499047f, 0.13556689f, 0.09040417f, -0.28132471f, 0.52539712f, 0.23650120f, 0.25012496f, 
    0.08352976f, 0.39057165f, 0.04414797f, -0.10321204f, 0.12342514f, -0.03712010f, -0.16656812f, 0.14936958f, 
    -0.21461987f, -0.25149080f, -0.14000186f, 0.30666038f, -0.07540651f, 0.14142896f, -0.14380075f, 0.04569984f, 
    -0.05294679f, -0.06630304f, -0.04374991f, 0.17004235f, -0.43744341f, -0.33086431f, 0.21179006f, 0.10851108f, 
    0.02999631f, 0.10603661f, -0.01354777f, -0.07993104f, -0.16054368f, -0.09165724f, -0.05211744f, -0.06914681f, 
    -0.28180692f, 0.02078177f, -0.11671326f, -0.38181758f, -0.07576048f, -0.13006268f, 0.04829765f, 0.12045056f, 
    0.08099633f, 0.07946615f, 0.00703920f, -0.00396459f, -0.04884025f, -0.22794330f, 0.02164526f, -0.30897674f, 
    0.12962475f, 0.01248565f, -0.04658215f, -0.04501711f, 0.14000303f, 0.04494519f, 0.05467235f, 0.13033879f, 
    0.16148514f, 0.14910872f, 0.17894156f, -0.05196276f, 0.18418632f, 0.04226024f, 0.03383669f, -0.10001248f, 
    0.09092844f, -0.04044899f, -0.01964496f, 0.18810506f, 0.36285463f, -0.24236998f, 0.25186202f, -0.06960885f, 
    -0.20497578f, 0.01516879f, -0.04889964f, -0.11046562f, 0.06985240f, 0.20829727f, 0.18989235f, 0.05382869f, 
    -0.23838368f, 0.15186095f, 0.06245337f, -0.16871575f, -0.03443807f, 0.08237232f, -0.08691888f, 0.09725618f, 
    0.15835921f, 0.03964300f, -0.00179093f, 0.13841878f, 0.06958272f, -0.19368571f, -0.00360896f, 0.09428191f, 
    -0.10056624f, -0.03949907f, 0.15573889f, 0.13783911f, -0.05027824f, -0.23050411f, 0.15243897f, 0.17298914f, 
    -0.50810283f, -0.32836249f, 0.17722113f, 0.03048917f, 0.00836398f, 0.03861273f, 0.12942059f, -0.16759083f, 
    0.10628867f, -0.08128606f, -0.01872162f, 0.11219059f, 0.46409932f, 0.04952247f, 0.17303643f, 0.23813207f, 
    0.01147409f, 0.07438466f, 0.05234249f, 0.11959155f, 0.00803710f, -0.05958367f, 0.03464980f, 0.06298532f, 
    -0.13010755f, 0.09008840f, -0.26656765f, 0.10444324f, -0.00346549f, -0.17194007f, 0.04836880f, 0.06943520f, 
    0.04771693f, 0.08360812f, 0.12778595f, -0.07566895f, -0.09392928f, 0.14360921f, -0.18989110f, -0.17287712f, 
    0.13032389f, -0.08608343f, 0.11946685f, 0.05048332f, 0.14823647f, 0.20842068f, 0.14805664f, 0.04562684f, 
    -0.00252290f, 0.05668933f, 0.36285311f, 0.41179568f, -0.04772311f, 0.10948141f, -0.01714916f, 0.05612465f, 
    -0.10752796f, 0.11741231f, -0.06870872f, 0.03897819f, 0.23314472f, 0.14339945f, -0.15052317f, -0.07324958f, 
    0.00518457f, 0.04621777f, 0.12981755f, 0.10591993f, -0.06697188f, 0.29808480f, 0.06699938f, -0.06573088f, 
    -0.34659380f, 0.10519406f, -0.11033550f, -0.56196761f, -0.04702372f, -0.03366289f, 0.04481243f, -0.00785582f, 
    0.07441970f, -0.04553182f, -0.05975292f, 0.17929743f, -0.15025458f, -0.28489596f, 0.22109422f, -0.09393408f, 
    -0.05843451f, 0.06607637f, 0.24978526f, -0.07741795f, 0.00541873f, 0.02156992f, 0.07469909f, 0.25022885f, 
    0.06543455f, -0.05531273f, -0.01291586f, 0.03911044f, 0.12640595f, 0.04138790f, 0.00711278f, 0.00417132f, 
    -0.05503066f, -0.10836570f, -0.01419110f, -0.00373380f, -0.13788806f, 0.21921225f, 0.04639275f, 0.01805090f, 
    0.09999713f, 0.06714226f, 0.04918038f, -0.01068603f, -0.02961213f, 0.11799523f, 0.13551509f, -0.17808728f, 
    0.31418121f, -0.18104389f, -0.26033482f, -0.10192107f, 0.09140373f, 0.14192317f, 0.04381863f, 0.12216945f, 
    -0.14236774f, 0.09986185f, 0.09381490f, 0.02676786f, -0.45214784f, 0.13284303f, -0.08782800f, 0.11730358f, 
    0.12126907f, -0.15701045f, -0.03906353f, 0.21625336f, -0.10117744f, 0.01330259f, 0.02360373f, -0.04094659f, 
    -0.31595761f, -0.11289767f, 0.05397955f, -0.41857922f, -0.01513988f, -0.11239751f, 0.01950248f, -0.10135861f, 
    0.00320023f, 0.11839195f, 0.08688933f, -0.05453365f, -0.44295639f, 0.44509238f, -0.00628833f, -0.11786727f, 
    -0.02276599f, -0.00252288f, -0.05821053f, 0.04886112f, 0.19817583f, -0.07021230f, -0.03538673f, 0.13397878f, 
    0.09616401f, 0.40661168f, 0.25860006f, 0.23054913f, -0.00587630f, 0.06919990f, 0.06452312f, 0.11736219f, 
    0.06074556f, 0.01803837f, 0.15607536f, 0.31802288f, -0.02447641f, 0.29725179f, -0.13100012f, -0.35764667f, 
    0.20791416f, -0.14358404f, 0.02985755f, 0.10355467f, 0.05212670f, 0.04097428f, 0.01446620f, -0.14581063f, 
    0.02877331f, -0.05013052f, 0.02071544f, -0.04469862f, 0.02342233f, -0.02604985f, 0.02319743f, 0.02403040f, 
    0.03399854f, 0.02767405f, 0.03916601f, -0.03689285f, -0.03892629f, -0.06696770f, -0.05736899f, -0.02800675f, 
    -0.03703824f, -0.04192177f, -0.06286523f, -0.03520380f, 0.06034787f, -0.07579172f, -0.00337390f, 0.00465387f, 
    0.01323886f, -0.05712450f, 0.04488073f, -0.07299286f, -0.06893823f, 0.03592281f, -0.06922462f, 0.02250793f, 
    0.05572611f, -0.02485634f, 0.03706732f, -0.06208997f, 0.00308885f, -0.03867913f, 0.03831739f, -0.06134379f, 
    -0.01002892f, 0.02453761f, 0.03207102f, -0.06705470f, -0.05185077f, -0.00676838f, 0.04984931f, -0.04462796f, 
    -0.01857403f, -0.01011122f, -0.03199461f, -0.05842698f, 0.03959760f, 0.01697843f, 0.03537678f, -0.05913023f, 
    0.05750966f, -0.05006425f, -0.04329399f, 0.03902114f, -0.06041404f, 0.04461856f, -0.07902520f, 0.05528196f, 
    -0.06703345f, -0.04344622f, -0.07322092f, -0.00605183f, 0.03700118f, -0.04175898f, -0.05916751f, -0.01954437f, 
    -0.04020774f, 0.05628460f, -0.04414200f, 0.02773509f, 0.00284695f, 0.04748570f, -0.03859719f, 0.01819704f, 
    0.01821753f, 0.05519874f, 0.00716993f, -0.07318687f, -0.06891561f, 0.04668756f, -0.01906515f, -0.06147131f, 
    -0.02980749f, -0.03376980f, -0.04060833f, 0.01196948f, 0.02599008f, -0.04454513f, 0.04470240f, -0.01234666f, 
    0.05190860f, -0.04287156f, 0.02211128f, 0.01073159f, 0.06275443f, 0.05559659f, 0.01459512f, -0.02267790f, 
    -0.06013305f, 0.01552144f, -0.07790349f, 0.04742749f, -0.05877315f, 0.05988670f, 0.03987676f, -0.03664726f, 
    -0.04977836f, 0.05197478f, 0.04456589f, -0.06998385f, -0.05130387f, -0.04156004f, -0.03697973f, 0.02644808f, 
    0.00505739f, 0.04803674f, -0.00110795f, 0.06115717f, 0.00739386f, -0.06083475f, -0.06100907f, -0.05555026f, 
    -0.00712824f, -0.04801426f, -0.01946246f, -0.06384984f, 0.04548718f, -0.03734480f, 0.00932252f, -0.00075878f, 
    0.04633596f, -0.03734785f, -0.02988592f, -0.06476078f, -0.06154071f, 0.02597914f, 0.03824550f, -0.00065732f, 
    0.05969008f, -0.07806518f, -0.07587446f, -0.07576464f, 0.03437961f, -0.06511839f, -0.00993823f, -0.02600450f, 
    0.00569174f, -0.07184827f, -0.04055627f, 0.02124402f, -0.06900974f, -0.01084647f, -0.00057010f, 0.01199148f, 
    0.02328964f, -0.02014504f, -0.07656708f, 0.03649229f, -0.06226496f, -0.01939323f, 0.03453822f, -0.05310878f, 
    -0.00243124f, -0.06399086f, 0.00961148f, 0.00370215f, 0.02941846f, -0.06949380f, 0.00968114f, 0.01927619f, 
    -0.06364681f, -0.02025048f, -0.06958971f, 0.01250282f, -0.04813344f, -0.00769636f, -0.02032135f, -0.01689741f, 
    -0.04430164f, 0.05291690f, 0.03047575f, -0.01022934f, -0.08013558f, -0.03722338f, -0.01136300f, -0.04707811f, 
    -0.19451234f, 0.14741227f, -0.25318271f, 0.38671052f, 0.10053893f, 0.16873424f, -0.03420182f, -0.05156072f, 
    0.06577894f, -0.06202431f, 0.02293152f, -0.02214917f, 0.36108705f, 0.28200006f, 0.02776610f, 0.27609006f, 
    -0.00973201f, -0.01169032f, -0.01439403f, -0.02675605f, -0.13619648f, -0.22222760f, 0.15247303f, 0.17092730f, 
    -0.06434345f, -0.34374774f, 0.02892161f, -0.19637148f, 0.12278820f, 0.07756807f, -0.04836447f, -0.12679583f, 
    0.17597802f, -0.08769012f, 0.22295059f, -0.00957769f, 0.08345190f, -0.05719015f, 0.11959913f, -0.14758170f, 
    -0.13083245f, -0.02305426f, -0.16576022f, -0.03752229f, -0.10521409f, 0.06636412f, 0.09971724f, 0.11971051f, 
    0.29616660f, -0.02466280f, -0.02336376f, 0.46843445f, 0.06006716f, 0.04994961f, -0.12250011f, 0.10307713f, 
    0.00208396f, 0.17488773f, -0.00510390f, 0.00916307f, 0.20311274f, 0.13133390f, 0.01942503f, 0.02800238f, 
    0.06615687f, -0.07531478f, -0.03083520f, -0.13810152f, -0.00486673f, 0.04850115f, 0.31876102f, -0.08226313f, 
    -0.42798334f, -0.14413717f, 0.08826160f, -0.16616735f, -0.12749931f, -0.00518285f, 0.05661685f, -0.12762575f, 
    0.18197510f, 0.11433094f, 0.07486141f, 0.09414388f, -0.53184336f, 0.03044784f, 0.21449520f, 0.34559685f, 
    0.03720209f, 0.06541730f, 0.13172439f, -0.18335377f, 0.03361711f, 0.07310929f, -0.05300685f, 0.00598884f, 
    -0.14845932f, 0.22351989f, -0.23198552f, -0.18049750f, -0.10284563f, 0.13900054f, 0.05560754f, -0.04473866f, 
    -0.07488203f, 0.02077691f, 0.01926612f, -0.16790077f, -0.05080483f, 0.40704474f, -0.05541053f, -0.12921882f, 
    0.11341119f, -0.04570162f, 0.14023432f, 0.04347828f, 0.11410861f, 0.07299317f, 0.00627110f, -0.06489780f, 
    -0.34072170f, 0.10542776f, -0.13387342f, -0.24134575f, -0.01382737f, 0.00573827f, 0.05945395f, 0.00641977f, 
    0.03800181f, 0.04238657f, -0.06045077f, 0.09034631f, 0.89130503f, -0.10099645f, 0.07338719f, -0.09957886f, 
    0.08284224f, 0.03846939f, 0.00237267f, -0.02776253f, 0.01756683f, -0.12230780f, -0.04246713f, -0.06493834f, 
    0.08020097f, 0.03268025f, -0.12239918f, -0.11011655f, 0.21085283f, 0.19324444f, 0.00878674f, 0.03015580f, 
    -0.08677597f, 0.06577853f, 0.12255940f, 0.28683481f, 0.15656225f, 0.23001447f, 0.21579555f, -0.28862423f, 
    0.14380431f, 0.08444050f, -0.14812200f, 0.03777457f, -0.07853834f, 0.12329979f, 0.24637178f, -0.00962882f, 
    0.30439106f, -0.04362582f, -0.16322224f, 0.00577901f, -0.06086252f, -0.06899324f, 0.12926280f, 0.11551919f, 
    0.03016302f, 0.04343076f, -0.10672788f, 0.07747994f, 0.23325014f, -0.19102183f, -0.08922470f, -0.15002969f, 
    -0.14376551f, -0.11211028f, 0.01475806f, 0.06073345f, 0.08489195f, 0.01650307f, -0.02045782f, 0.28005454f, 
    -0.37355629f, -0.03271599f, 0.24008426f, -0.25818968f, -0.03938740f, 0.08057012f, 0.18825457f, -0.14618304f, 
    -0.05227854f, -0.02884107f, 0.02541033f, -0.17553024f, 0.05880231f, -0.15319963f, 0.01929847f, 0.07710794f, 
    0.03176035f, -0.07044395f, -0.05220667f, -0.04896427f, -0.13813995f, -0.10079034f, -0.04326699f, 0.06423144f, 
    0.20523731f, -0.13396110f, 0.11742568f, 0.04802831f, 0.06118168f, 0.18482773f, -0.02778837f, -0.12299725f, 
    -0.13308989f, 0.06018352f, -0.03388374f, -0.03520629f, 0.00076948f, -0.01879401f, 0.08722854f, 0.14701656f, 
    -0.03937072f, -0.02816171f, -0.19876255f, 0.15832226f, 0.19430409f, 0.06116485f, 0.08180428f, 0.28374216f, 
    -0.12431171f, -0.39134517f, 0.07811922f, -0.54026955f, -0.02857695f, -0.05349156f, 0.17594624f, -0.04840403f, 
    -0.18518546f, -0.06831845f, 0.09274527f, 0.02710434f, 0.00163292f, -0.35374492f, 0.02295984f, 0.38852590f, 
    0.16532722f, 0.14057687f, 0.04408194f, 0.10855389f, -0.00888259f, -0.05554250f, 0.06795742f, 0.21622469f, 
    0.15847771f, 0.25528663f, 0.07997856f, 0.23582786f, -0.02013830f, 0.11166085f, -0.05805200f, -0.00484432f, 
    -0.04079565f, -0.00824226f, -0.12344946f, 0.01806378f, 0.03779255f, 0.17760637f, -0.01308873f, 0.00442064f, 
    0.01388021f, -0.16312991f, 0.13002206f, -0.09056385f, -0.00210137f, 0.05571832f, 0.01313386f, -0.03776720f, 
    0.55078930f, 0.32231447f, 0.11553168f, -0.01170447f, 0.12338890f, -0.23181838f, 0.01812451f, -0.00635549f, 
    0.09336230f, 0.09728186f, -0.04109592f, 0.02631881f, -0.02033502f, 0.11264937f, 0.19085370f, 0.22786804f, 
    0.02840225f, -0.08937422f, 0.11715110f, 0.13095069f, -0.15824129f, 0.17056505f, 0.15550438f, 0.14263678f, 
    0.01505673f, -0.11249103f, 0.11252334f, 0.27708986f, -0.04210075f, 0.11557468f, 0.09585490f, -0.10859969f, 
    0.04621074f, 0.13054204f, -0.09953232f, -0.14367212f, 0.31342062f, -0.05420516f, 0.14696001f, -0.00737667f, 
    -0.23121984f, -0.09595987f, -0.14277886f, 0.03090666f, -0.05736297f, -0.08416814f, -0.03808144f, -0.08113068f, 
    -0.05941789f, 0.13051477f, 0.13083732f, 0.27022430f, -0.14393951f, -0.06276052f, -0.14962097f, -0.15787739f, 
    0.02768970f, 0.07290608f, 0.11062853f, 0.08373898f, 0.05693275f, -0.08247995f, -0.27600896f, 0.29846320f, 
    0.18706594f, 0.06068746f, -0.20251074f, -0.07993300f, -0.01028480f, -0.05754486f, -0.00686413f, 0.00869211f, 
    -0.06625242f, -0.39926463f, 0.16960831f, -0.23177826f, 0.04714272f, -0.13799663f, 0.07953469f, -0.04658940f, 
    -0.06712501f, 0.13633592f, 0.10217967f, -0.03728100f, 0.39403218f, 0.40516564f, 0.10128319f, 0.00282493f, 
    -0.23055826f, 0.12380588f, 0.02078998f, 0.09252937f, 0.05876536f, 0.16096176f, -0.14869580f, 0.02061894f, 
    0.47785783f, -0.22024952f, -0.03556132f, -0.04183663f, -0.03078551f, -0.25940022f, -0.12858972f, 0.09168468f, 
    -0.09253310f, 0.12002404f, 0.02417085f, 0.06976400f, -0.34410942f, 0.20162207f, 0.11880504f, -0.06379507f, 
    -0.06698214f, -0.15523706f, -0.03888093f, 0.04394275f, 0.07763323f, 0.08866085f, -0.00701389f, -0.11379468f, 
    0.33404741f, 0.06677337f, 0.17304529f, 0.09769512f, -0.03996800f, 0.10148099f, 0.07735244f, 0.09369646f, 
    -0.05253275f, 0.13765760f, 0.08580027f, 0.12048741f, 0.14610074f, -0.11987169f, 0.05823202f, 0.57879645f, 
    -0.11128196f, 0.06535831f, -0.07249289f, 0.01670332f, 0.10333306f, 0.01981062f, 0.25385690f, 0.24778910f, 
    -0.02254235f, 0.11434018f, 0.28811044f, -0.28472072f, -0.02403695f, -0.01271544f, -0.12534474f, 0.14851274f, 
    0.00752076f, 0.00002299f, 0.02236732f, 0.13420494f, 0.17810722f, -0.09226279f, -0.00049439f, -0.20429087f, 
    0.01733745f, 0.06277871f, -0.07777973f, -0.04434529f, -0.01437620f, 0.04952376f, -0.14217038f, 0.09505615f, 
    0.18360686f, -0.29667667f, 0.02716546f, 0.34703785f, -0.28393963f, -0.10307540f, -0.16719423f, 0.00106100f, 
    -0.10268004f, -0.01199996f, -0.06590261f, -0.08959503f, 0.42016348f, -0.32120675f, -0.27527291f, -0.20314412f, 
    -0.09586982f, -0.23654069f, -0.08093942f, 0.12909670f, -0.15046942f, 0.04088405f, 0.03933192f, -0.04821775f, 
    0.11201898f, 0.07330237f, 0.02167182f, -0.50311989f, 0.01026821f, 0.05853499f, 0.21103591f, -0.01462794f, 
    0.05109636f, -0.00019636f, -0.10655386f, -0.20215772f, 0.33463115f, -0.11850961f, -0.25858113f, -0.19307506f, 
    0.01475779f, -0.03499926f, 0.02506533f, 0.09018485f, 0.13654771f, -0.03411505f, -0.02814977f, 0.19214253f, 
    0.26073661f, 0.07973689f, 0.15255179f, 0.27509126f, 0.13859099f, 0.01387846f, 0.03582997f, -0.05888651f, 
    -0.08679848f, -0.10532301f, 0.14671111f, 0.06204211f, -0.25555846f, 0.21402298f, -0.18271194f, 0.18504177f, 
    -0.02985692f, 0.02226151f, -0.01966266f, -0.09756199f, -0.03557398f, 0.18093832f, 0.04690787f, -0.04854900f, 
    0.04966323f, -0.09653746f, -0.02225957f, 0.25423667f, -0.10334289f, -0.15764028f, -0.03611723f, 0.01461265f, 
    0.04934294f, 0.02114511f, -0.01575777f, -0.00348839f, -0.16635872f, 0.15336713f, 0.13465345f, 0.32485825f, 
    0.16329068f, -0.04849616f, 0.03266968f, -0.05597311f, -0.05125093f, 0.06715076f, -0.04508706f, -0.06755120f, 
    0.18161304f, -0.06553280f, 0.10969100f, 0.04410925f, 0.06187740f, 0.02306892f, 0.03469397f, -0.09860431f, 
    0.06426682f, 0.08281745f, 0.07188226f, -0.17501256f, -0.16094011f, 0.16539682f, 0.04144599f, -0.02681834f, 
    0.09801634f, 0.08753566f, 0.00492129f, -0.12852599f, -0.07064370f, 0.16985692f, 0.01977963f, -0.09709466f, 
    0.15904124f, -0.22622608f, 0.27042362f, 0.03905848f, -0.27390489f, -0.12750062f, 0.18897109f, 0.06675460f, 
    0.02251603f, 0.06197512f, -0.01409460f, 0.07427099f, -0.27026451f, -0.05486453f, 0.41208577f, 0.40386096f, 
    -0.10871027f, 0.02319320f, -0.03200777f, -0.12882607f, 0.02081420f, 0.26967832f, -0.04432477f, 0.06189413f, 
    0.42374167f, 0.08465086f, 0.00054886f, -0.01186522f, 0.03672834f, 0.08071718f, -0.06457045f, -0.00928797f, 
    -0.21315923f, 0.08382963f, -0.03378701f, 0.09893928f, 0.48735189f, 0.33131775f, -0.11396292f, 0.03647774f, 
    0.08156887f, 0.06603365f, 0.08823648f, 0.15169267f, 0.07991822f, -0.17399037f, -0.20402773f, -0.07726728f, 
    0.18979552f, -0.27889946f, 0.18743783f, -0.12638471f, -0.05061739f, 0.03556302f, 0.14738554f, 0.08657376f, 
    -0.28503412f, -0.01575051f, -0.00421901f, 0.22293617f, -0.03327524f, -0.13626887f, -0.27815220f, -0.10407494f, 
    -0.05119303f, -0.01806230f, 0.19140574f, 0.07609357f, -0.11003699f, -0.11109567f, -0.06515282f, 0.00139734f, 
    0.24703422f, 0.23784481f, 0.07718061f, 0.15640830f, -0.14298199f, -0.09299574f, -0.02089518f, 0.22183245f, 
    -0.23376203f, -0.23748489f, -0.04430129f, -0.06486180f, 0.45798531f, -0.24786983f, -0.12249073f, -0.15662022f, 
    -0.02807566f, -0.03975140f, -0.04085439f, 0.25813636f, 0.10941181f, 0.01028674f, 0.13564850f, -0.12870230f, 
    0.12565273f, -0.18266791f, 0.13772988f, -0.14532712f, 0.23799199f, -0.15626711f, 0.18107535f, 0.01465845f, 
    0.09502580f, 0.14534622f, 0.17151587f, 0.22387405f, -0.20192638f, -0.17605953f, -0.32205987f, 0.00974291f, 
    0.12536275f, 0.17491254f, -0.01573815f, 0.07371478f, -0.01568004f, 0.04261583f, 0.02202491f, -0.04237764f, 
    0.55546403f, -0.04547504f, 0.19557136f, 0.23982920f, 0.01923960f, 0.18079534f, 0.03740510f, -0.20057416f, 
    -0.02043792f, -0.02385572f, 0.16920899f, -0.12281418f, -0.45197815f, 0.19194698f, -0.13836892f, 0.17315339f, 
    -0.06917042f, 0.03108621f, 0.02712960f, 0.00077795f, -0.07464699f, 0.16814746f, 0.06240709f, 0.05006780f, 
    -0.10550790f, -0.10961977f, 0.29727671f, 0.18602522f, -0.33414370f, -0.05632639f, -0.03725708f, -0.00820216f, 
    -0.03057655f, 0.04699219f, -0.16175815f, -0.20787153f, -0.22264233f, 0.23769963f, -0.35256946f, 0.14775294f, 
    -0.03223449f, 0.13812698f, 0.27777293f, 0.06651073f, 0.17767575f, -0.09638691f, 0.04512248f, 0.03743192f, 
    -0.27662513f, 0.31730238f, 0.25654307f, 0.05158985f, -0.12082510f, 0.05760592f, -0.04386025f, -0.06956504f, 
    -0.19671676f, -0.03823717f, 0.06910195f, -0.19553947f, 0.03683122f, 0.23028684f, -0.26415092f, 0.00574969f, 
    0.28248212f, -0.00632299f, -0.01469166f, -0.05689174f, 0.06825452f, 0.12561417f, 0.02555267f, -0.11505264f, 
    -0.02758355f, 0.04814329f, -0.00765339f, -0.03714764f, 0.05223924f, -0.04074536f, 0.02004856f, -0.06027692f, 
    -0.04513689f, 0.00367662f, -0.05804853f, 0.02917456f, -0.07892448f, 0.00342536f, -0.06118628f, -0.00875934f, 
    -0.05294918f, -0.07338462f, 0.03998632f, 0.02331774f, -0.06093920f, 0.01763136f, 0.04133344f, -0.00739043f, 
    0.04570065f, -0.02672877f, 0.04626562f, -0.06356242f, -0.04250205f, 0.00148494f, -0.07252607f, -0.06125218f, 
    -0.03583229f, -0.05039109f, -0.06588861f, 0.02973074f, -0.02297470f, -0.00574377f, -0.04161451f, 0.01750665f, 
    0.05713619f, -0.05091224f, 0.04720283f, 0.05669503f, 0.02423210f, -0.01966586f, 0.03204444f, 0.03836599f, 
    0.01263404f, 0.03043934f, -0.01120290f, -0.05488591f, 0.05395340f, -0.04985846f, -0.00100877f, -0.01286871f, 
    -0.03319339f, 0.03747067f, -0.06694200f, -0.03799427f, -0.00266919f, 0.02985895f, -0.00754283f, -0.01182295f, 
    -0.04525623f, 0.04350214f, 0.03514395f, -0.03156305f, 0.06214561f, 0.05727234f, 0.04092482f, -0.03138095f, 
    -0.03697718f, 0.01670926f, -0.00531002f, -0.04742617f, 0.03910149f, -0.07894768f, -0.07541092f, -0.07616406f, 
    -0.00127873f, -0.05608774f, 0.06152038f, 0.04367465f, 0.00855240f, 0.00332265f, -0.00559780f, -0.06218875f, 
    0.01173586f, -0.04298677f, -0.00985847f, 0.05439594f, -0.03366949f, -0.06625727f, -0.05700062f, -0.04430919f, 
    0.01940660f, -0.04488793f, 0.04341419f, 0.04850368f, 0.05437930f, 0.01748041f, 0.04751769f, -0.06555288f, 
    -0.01189118f, -0.00984201f, 0.04436840f, 0.00861111f, 0.03330471f, -0.07281010f, -0.01462558f, -0.07083297f, 
    -0.05472789f, 0.06496538f, -0.04756953f, -0.05997740f, 0.01381257f, 0.01510743f, -0.07411711f, -0.06931245f, 
    0.01561393f, -0.08632765f, 0.00575350f, -0.00345626f, -0.06285763f, 0.02295616f, 0.04566159f, -0.02375888f, 
    -0.02638365f, -0.05314140f, -0.06528138f, 0.06375253f, -0.02397425f, -0.05115289f, -0.02420566f, 0.00480775f, 
    -0.06718163f, -0.01470815f, -0.00626570f, 0.04087647f, 0.06294744f, 0.04352617f, -0.07503390f, 0.04488122f, 
    -0.06262560f, 0.05611245f, 0.01562974f, 0.04373936f, 0.02098373f, -0.00637291f, -0.00653659f, -0.07246719f, 
    0.02680612f, -0.04146583f, 0.04501903f, 0.03447345f, -0.04794810f, -0.01658372f, 0.02784686f, 0.03257676f, 
    -0.04413342f, -0.03731556f, 0.01085638f, -0.00527119f, 0.00394223f, 0.05115288f, 0.03207374f, -0.02400874f, 
    -0.04263291f, -0.01712979f, -0.06571174f, -0.04387645f, 0.06072923f, -0.04956269f, -0.00667171f, 0.00224967f, 
    -0.06310540f, -0.00309782f, -0.08058147f, -0.05741079f, -0.04798521f, -0.05189237f, 0.02973050f, 0.02126382f, 
    0.01057602f, -0.05145886f, -0.00215148f, -0.03113206f, -0.02989459f, 0.01142920f, 0.00168960f, 0.00703239f, 
    0.47535577f, 0.16858101f, 0.31823915f, -0.23818778f, -0.13830574f, 0.01111605f, 0.25647816f, -0.05284207f, 
    0.04449858f, -0.08516740f, 0.08485695f, 0.09173212f, -0.37782007f, -0.06264678f, -0.06333242f, 0.21134262f, 
    -0.12442683f, 0.01537575f, -0.09855547f, 0.00992302f, 0.01484093f, 0.18367837f, -0.12561999f, -0.01990310f, 
    0.27303603f, -0.16052949f, 0.13849282f, 0.07721821f, 0.09005088f, -0.22251628f, -0.10283552f, 0.10366886f, 
    0.03479962f, 0.02751672f, 0.11225846f, -0.04174705f, 0.19476888f, 0.21399358f, -0.02488206f, 0.07616621f, 
    0.05389161f, -0.06288372f, -0.12007315f, 0.05854639f, -0.09892333f, 0.04589406f, -0.03447516f, 0.02224700f, 
    0.10224845f, 0.00104780f, 0.30760619f, -0.26707128f, 0.03854589f, -0.17423762f, 0.04914514f, -0.06180507f, 
    -0.03641425f, 0.03768466f, 0.06000477f, -0.03593227f, -0.38591334f, 0.08963760f, -0.52613598f, 0.14484915f, 
    -0.00902974f, -0.03133199f, 0.01611594f, 0.04333242f, -0.16592658f, -0.07578152f, -0.03680246f, -0.00153423f, 
    0.29899371f, 0.08850460f, 0.15706037f, -0.00850306f, 0.01538065f, 0.11156705f, 0.13812350f, -0.00629068f, 
    0.03898671f, -0.03559464f, 0.14061785f, -0.00032075f, 0.58675385f, 0.02667315f, 0.08246385f, -0.14204173f, 
    0.21924269f, 0.02823889f, 0.06635106f, 0.13148175f, 0.07030489f, -0.25716689f, 0.12188108f, -0.07604157f, 
    -0.18138967f, -0.62731856f, 0.04516620f, -0.19061127f, 0.12659352f, -0.02588316f, 0.09113105f, 0.21056771f, 
    0.08185638f, -0.09619948f, -0.01562572f, -0.17922148f, -0.32851034f, -0.39100543f, -0.41704100f, 0.01755056f, 
    0.45883510f, -0.06513419f, 0.12046048f, 0.17158590f, -0.00297005f, 0.03916756f, -0.01213522f, -0.04214123f, 
    -0.01871422f, 0.21412717f, -0.00110153f, 0.08171619f, 0.11525153f, -0.15415256f, -0.12694487f, 0.02821216f, 
    0.25331786f, 0.09652746f, 0.19027875f, 0.26481155f, -0.00617640f, -0.30963308f, -0.23678303f, -0.08244956f, 
    0.02210293f, 0.07273189f, -0.00765010f, 0.17040141f, -0.00552260f, 0.02332185f, 0.02671214f, -0.03113677f, 
    0.30543706f, 0.04830924f, 0.26851773f, 0.20913558f, -0.10754162f, 0.00043695f, 0.02785821f, -0.02795434f, 
    0.07126588f, -0.00439207f, 0.01185291f, -0.02859041f, -0.01949369f, 0.43343008f, -0.29011601f, -0.04692420f, 
    0.20588966f, 0.23990093f, -0.06545385f, 0.05149594f, -0.03352216f, 0.08244249f, 0.20213205f, -0.04567724f, 
    -0.44691345f, 0.04771264f, 0.14564058f, -0.08208247f, 0.00633454f, -0.05994613f, 0.17026033f, -0.09317474f, 
    -0.03220112f, 0.15235430f, -0.06251051f, 0.06628937f, 0.15994924f, 0.14898990f, -0.02453247f, -0.17915750f, 
    0.21792424f, 0.09472420f, -0.09399997f, 0.05058377f, 0.01527892f, 0.10614534f, -0.09668493f, 0.14337426f, 
    0.57563639f, 0.56913179f, 0.01334478f, -0.24175279f, 0.04545950f, 0.04346501f, 0.02665403f, 0.02451630f, 
    -0.15157932f, -0.05727566f, 0.00335022f, -0.13893026f, -0.16858613f, -0.10213160f, -0.51591873f, -0.20131543f, 
    -0.12265993f, -0.10129293f, -0.01079654f, 0.07850487f, -0.07614560f, -0.14383721f, 0.00026354f, -0.05824297f, 
    0.23896480f, 0.05417770f, 0.13914727f, 0.07756718f, -0.07537544f, -0.13911140f, -0.06570488f, 0.07517482f, 
    0.10899610f, -0.00761393f, 0.10409710f, 0.00655313f, -0.19198501f, -0.08816243f, -0.15176345f, -0.03755622f, 
    0.01500621f, -0.12156369f, -0.07147223f, -0.14260007f, -0.08583438f, 0.15457943f, 0.11072436f, 0.23297752f, 
    -0.14539255f, 0.45062733f, -0.00893440f, -0.23220283f, 0.22895193f, -0.11370327f, -0.05756524f, 0.07223386f, 
    0.20120202f, 0.02353899f, 0.01510881f, -0.01908151f, -0.30887029f, 0.05319069f, 0.02095044f, 0.22508426f, 
    -0.02183244f, 0.07938164f, -0.10327398f, -0.03311370f, 0.13501382f, 0.02580467f, 0.00827106f, 0.01459257f, 
    0.20021582f, -0.03779213f, 0.04883748f, 0.21377023f, 0.18041992f, 0.09194684f, 0.07443273f, -0.11182307f, 
    0.00979178f, 0.05038907f, -0.02312159f, -0.11754663f, 0.41958952f, 0.28726017f, -0.00744046f, 0.10955824f, 
    0.06407455f, -0.02229178f, 0.09639705f, -0.11481504f, -0.03848862f, -0.08220105f, -0.01439046f, 0.07184859f, 
    0.19643229f, 0.10885128f, 0.13994086f, 0.01459200f, 0.03677025f, 0.23394436f, -0.15595926f, -0.06526013f, 
    0.02476820f, -0.13116688f, -0.01634826f, -0.06519050f, 0.08061323f, -0.25014967f, 0.13381290f, 0.02577816f, 
    0.05650485f, -0.12188379f, 0.04553236f, 0.07915349f, 0.02790820f, -0.24001445f, 0.05615563f, 0.09254938f, 
    -0.31586683f, 0.34654865f, -0.00132509f, -0.08123689f, -0.00114878f, -0.16456939f, 0.00675804f, 0.11733915f, 
    0.17842267f, -0.04832146f, -0.02694132f, 0.14939223f, 0.23394296f, -0.27215213f, 0.01907250f, -0.05345168f, 
    0.05395244f, 0.12366016f, 0.04119367f, -0.00622858f, 0.08883726f, -0.02315433f, 0.05063619f, -0.08390288f, 
    0.42692417f, 0.16533700f, 0.06863470f, -0.06949526f, 0.22092874f, -0.02574823f, 0.10101245f, 0.15615985f, 
    0.02995965f, -0.10551577f, -0.04569200f, 0.28485242f, 0.01875603f, -0.16818972f, 0.24737625f, -0.06587037f, 
    -0.06966405f, -0.13124990f, -0.11853144f, -0.19735210f, -0.14872113f, 0.08466035f, 0.17238511f, 0.01770628f, 
    -0.37219879f, -0.06168592f, -0.19265138f, -0.23876181f, 0.15703331f, -0.02989150f, 0.08142993f, 0.05671244f, 
    0.09728678f, 0.18693838f, -0.04539350f, 0.16417176f, 0.08053368f, -0.11504776f, 0.18326660f, 0.01707374f, 
    -0.00351163f, 0.12420098f, 0.08514851f, -0.09307986f, -0.08262032f, -0.00973616f, -0.05586394f, 0.20392559f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04674700f, 0.12024198f, 0.06206161f, -0.07482709f, -0.01074578f, -0.07687915f, 0.08336570f, 0.05501278f, 
    -0.06812689f, 0.06875476f, 0.03580497f, 0.10784447f, -0.03214838f, 0.05305160f, -0.07142827f, 0.07703865f, 
    0.10921802f, -0.03459487f, -0.05907348f, 0.15839911f, 0.03351087f, -0.01391419f, 0.04115453f, 0.19886464f, 
    0.01229945f, 0.21339874f, -0.04476691f, -0.12836248f, -0.12382844f, -0.08365181f, 0.02401525f, -0.02993320f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.21631138f, -0.04741400f, -0.11261459f, -0.01824630f, 0.19197977f, 0.12542054f, 0.03394789f, -0.87141573f, 
    -0.13740189f, 0.17679062f, -0.06518263f, -0.25810263f, 0.09941499f, 0.29528886f, 0.15774126f, -0.42157295f, 
    -0.67942828f, -0.28865141f, 0.18760152f, -0.49295372f, 0.06702244f, 0.17074288f, -0.49219203f, -0.11599062f, 
    0.06459663f, -0.78730536f, 0.29186893f, 0.64003891f, 0.50340593f, -0.10043997f, -0.01218091f, -0.10721791f, 
    0.43433535f, -0.07680108f, -0.01180489f, -0.13757464f, 0.19635381f, -0.60367078f, -0.12241492f, -0.05284754f, 
    -0.37390307f, 0.22226639f, 0.06709892f, 0.00657955f, 0.33613548f, -0.88290286f, -0.01590452f, 0.03499386f, 
    0.38881913f, 0.01263004f, -0.21898465f, -0.34358338f, 0.20564952f, 0.22791070f, -0.14151819f, -0.51080924f, 
    -0.12434229f, 0.10462631f, 0.19939665f, 0.16806380f, 0.14292538f, 0.03293633f, 0.49943674f, 0.09700309f, 
    -0.14695913f, -0.15495659f, 0.03205816f, 0.07383806f, -0.33411714f, -0.19486430f, 0.32869223f, -0.36150929f, 
    0.41959628f, 0.37161615f, -0.00350326f, -0.22859724f, -0.57428092f, -0.27908814f, 0.01540141f, 0.22493955f, 
    -0.40314230f, -0.12857196f, 0.35479844f, -0.40458822f, -0.00448255f, -0.58455491f, 0.31447950f, -0.63483739f, 
    -0.05786584f, -0.18060441f, 0.54110104f, -0.58102113f, -0.45579022f, 0.15398858f, -0.24175334f, 0.34152842f, 
    -0.49648318f, -0.25556764f, -0.08440945f, 0.12533201f, -0.22479883f, 0.15693888f, 0.18998063f, -0.32726231f, 
    -0.04992703f, 0.25733477f, -0.12524922f, 0.46641821f, 0.52638149f, -0.07789862f, 0.05865056f, -0.20911267f, 
    0.39486647f, -0.04341147f, -0.02579277f, 0.13398814f, 0.20640589f, -0.55304599f, -0.55603683f, 0.04443965f, 
    -0.11465278f, 0.21451987f, -0.41612861f, 0.38621557f, 0.03965512f, -0.13071989f, -0.82328326f, -0.36085743f, 
    -0.08841661f, 0.21302272f, 0.15200384f, -0.02474367f, -0.12695584f, -0.14830002f, -0.15772517f, 0.37714270f, 
    0.25194597f, -0.46925011f, 0.09659961f, 0.57677764f, -0.17935352f, 0.07345308f, -0.07376465f, -0.11803732f, 
    -0.26063278f, -0.35018548f, -0.04602345f, 0.41525173f, 0.17734665f, 0.07483181f, 0.08756746f, 0.23693967f, 
    0.00847278f, -0.43906054f, 0.00564156f, -0.33812207f, 0.32017350f, -0.11210713f, -0.06391558f, -0.43940219f, 
    -0.08344516f, 0.19456975f, 0.07923649f, -0.01186700f, 0.62069303f, 0.24821040f, -0.36202574f, 0.22758846f, 
    -0.07387529f, -0.09642358f, 0.06456590f, -0.04541503f, 0.16511135f, 0.03883535f, 0.12880760f, -0.26086923f, 
    -0.53634137f, 0.11154336f, -0.51460886f, -0.29835951f, -0.30762604f, 0.38723391f, 0.21862188f, 0.04901630f, 
    0.03198932f, 0.12280814f, -0.00134747f, -0.25085610f, -0.06958608f, -0.00803828f, 0.04409693f, 0.22472815f, 
    -0.12658724f, -0.30815071f, -0.06529962f, -0.08994228f, -0.22025281f, 0.44247246f, 0.09361280f, -0.72758085f, 
    0.04156407f, -0.02610738f, 0.06594171f, -0.78092647f, 0.08222788f, -0.25902027f, -0.07258538f, 0.47227737f, 
    -0.24571668f, -0.54199296f, -0.53072464f, 0.07192462f, 0.40042490f, 0.06485106f, 0.35245374f, -0.18112935f, 
    -0.13268776f, 0.36147627f, -0.35712489f, -0.71936578f, -0.01053457f, 0.07162657f, -0.18001990f, -0.08633309f, 
    -0.28355652f, -0.99052149f, -0.15385707f, -0.17992139f, 0.08119155f, 0.26783544f, -0.50224441f, 0.39699209f, 
    0.35136232f, -0.80939502f, -0.06348828f, -0.03453563f, -0.40907639f, 0.34897998f, 0.14023571f, -0.29175809f, 
    0.19426678f, 0.39231130f, 0.09021457f, -0.23719080f, -0.21087664f, -0.35790041f, -0.18781036f, 0.24819650f, 
    -0.17442194f, 0.26682004f, 0.10195094f, -0.20122509f, -0.14704646f, 0.01785905f, -0.07608923f, 0.04683430f, 
    0.02026447f, 0.05122548f, 0.05058874f, 0.02668000f, 0.29938796f, -0.16827127f, -0.28977844f, -0.31966135f, 
    -0.49619204f, -0.23907821f, 0.13187361f, 0.13903734f, -0.42044005f, 0.02269718f, -0.01234681f, 0.11000907f, 
    0.30776736f, 0.43363312f, 0.17236625f, 0.17396910f, 0.08256090f, 0.25416920f, 0.19961543f, -0.49150988f, 
    0.05914388f, -0.43813169f, -0.14076841f, 0.20231397f, -0.68238705f, -0.11592299f, -0.64104009f, 0.37047186f, 
    -0.75494671f, -0.21454372f, -0.04322338f, -0.10344075f, -1.03686512f, -0.35717762f, -0.07181510f, 0.25959656f, 
    -0.18739080f, 0.26671126f, -0.06908581f, -0.57322675f, -0.10618701f, 0.52201831f, 0.13182354f, 0.29050741f, 
    -0.40955541f, 0.45279506f, -0.13688621f, 0.06639328f, -0.02809537f, 0.05864416f, 0.08552909f, 0.30360702f, 
    0.12314417f, -0.40655574f, -0.32741016f, 0.00826210f, 0.31027704f, 0.07048349f, 0.39661890f, 0.17372949f, 
    -0.00101938f, 0.19220099f, -0.13010626f, 0.01923056f, 0.03743722f, -0.09853932f, 0.28322703f, 0.54716951f, 
    -0.25728694f, 0.35058197f, -0.08113042f, -0.10464504f, -0.28363964f, -0.58720434f, 0.15433000f, 0.38867396f, 
    -0.15195270f, -0.08942632f, 0.29247990f, 0.08007076f, -0.47387579f, -0.30106142f, -0.43156391f, 0.51574641f, 
    0.15056938f, 0.39674959f, 0.16520727f, -0.29321674f, -0.76667529f, 0.15494663f, -1.14389813f, -0.33366725f, 
    0.42967719f, -0.18138573f, 0.05360319f, -0.01201217f, -0.24599032f, 0.33679891f, 0.20252803f, -0.83452916f, 
    0.33659422f, -0.16678479f, 0.08103468f, -0.24794355f, -0.63470620f, 0.01380034f, -0.00682532f, -0.33712593f, 
    0.20493290f, -0.49742019f, 0.16021258f, 0.48500159f, -0.56941307f, 0.13845737f, -0.06215751f, -0.12772983f, 
    0.11489006f, -0.10683039f, -0.82395965f, 0.17863587f, -0.22109622f, 0.15178269f, 0.02928195f, 0.21194139f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.15621801f, -0.19784971f, 0.15535145f, -0.10625197f, -0.07148739f, -0.07676622f, 0.17680041f, 0.05534135f, 
    -0.04377632f, -0.02881001f, 0.03746881f, 0.10208769f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
