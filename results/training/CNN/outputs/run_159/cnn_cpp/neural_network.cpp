#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.25476578f, 0.53526247f, 0.40607676f, -0.57111603f, 0.03031992f, 0.17440991f, 0.27445906f, -0.01370904f, 
    0.39279172f, -0.63800931f, 0.58496332f, -0.58221978f, 0.21129343f, -0.40261987f, -0.38085476f, -0.10317014f, 
    0.45411894f, -0.01537580f, 0.44109359f, 0.41619381f, -0.32158855f, -0.07791632f, -0.02023016f, 0.30252233f, 
    0.30778897f, 0.38414198f, 0.26372167f, -0.47051874f, 0.61894757f, 0.04252766f, 0.13210875f, 0.53903347f, 
    0.30309549f, -0.30945960f, -0.28699070f, 0.16703747f, -0.37120596f, -0.30111632f, -0.45234179f, 0.45697814f, 
    -0.40013045f, 0.15012451f, -0.49551505f, -0.19176443f, -0.22649127f, -0.64493138f, 0.44683066f, -0.08996273f, 
    -0.31180260f, -0.17325272f, -0.53938276f, 0.08573037f, 0.10463453f, -0.29761413f, 0.08389306f, 0.74877644f, 
    -0.55558223f, 0.71252763f, -0.19146869f, -0.60674250f, 0.04765389f, 0.05434809f, 0.25835609f, -0.55676723f, 
    0.30661643f, 0.04240479f, 0.56772810f, -0.01385087f, -0.50678587f, 0.19642055f, -0.25475451f, -0.57521904f, 
    0.08882573f, -0.75457841f, 0.47035670f, 0.65385330f, -0.05518593f, 0.35633290f, -0.06131667f, 0.00330265f, 
    0.01231506f, -0.46332800f, -0.39162371f, 0.46241021f, 0.03021130f, 0.15288378f, 0.53970808f, 0.13296895f, 
    -0.39443961f, 0.46873021f, 0.71608460f, -0.32220253f, 0.30943432f, 0.55070978f, 0.11627679f, 0.15603004f, 
    -0.07821142f, -0.16074285f, -0.40979233f, -0.05728128f, -0.46850562f, 0.01690239f, -0.45550349f, 0.58303916f, 
    -0.65068138f, 0.04268618f, 0.26534870f, -0.44211903f, -0.55688429f, -0.28270882f, -0.30721825f, 0.20501763f, 
    0.49714220f, 0.43638769f, 0.15714388f, -0.07498544f, -0.28133765f, -0.11630014f, 0.24275742f, 0.39882123f, 
    0.51679558f, 0.42768848f, 0.25025049f, -0.13362069f, -0.38912991f, -0.26296663f, 0.22214621f, -0.44725865f, 
    -0.42914191f, -0.42248684f, -0.39116618f, -0.19466823f, -0.57715917f, -0.05635051f, 0.37057868f, -0.00509323f, 
    -0.51125562f, -0.43273386f, 0.34886074f, 0.48913735f, 0.48246247f, -0.36370760f, 0.17929184f, -0.40231973f, 
    -0.47612667f, -0.37846121f, -0.03198759f, 0.36137718f, -0.53525686f, 0.43853870f, 0.33016944f, -0.36423656f, 
    -0.09522046f, 0.26294631f, 0.30265644f, 0.36625025f, 0.30847028f, -0.64783746f, -0.48780376f, -0.33697283f, 
    0.02957498f, -0.16047096f, 0.61278611f, 0.56944114f, 0.61998653f, 0.38565084f, 0.40212664f, 0.16100244f, 
    -0.11973736f, 0.27453503f, 0.16847025f, 0.34198064f, 0.67799205f, 0.33413368f, -0.56402820f, -0.34743524f, 
    -0.67412370f, 0.39443773f, 0.07806261f, -0.04887748f, 0.28464127f, -0.46313733f, 0.00954749f, -0.73591876f, 
    -0.67161167f, -0.11104680f, 0.30759716f, 0.15181328f, 0.31519696f, -0.32686928f, -0.31968513f, -0.23158833f, 
    0.10398244f, 0.62758267f, 0.02111986f, -0.11497431f, -0.30706000f, -0.29793102f, -0.86195958f, -0.70001930f, 
    -0.31057614f, 0.01400234f, -0.30207148f, -0.25662535f, 0.25350016f, -0.02186577f, -0.09846796f, -0.49350759f, 
    -0.35310528f, -0.17607829f, 0.59943908f, 0.49088997f, -0.34294760f, 0.24455255f, 0.22268674f, 0.16390318f, 
    0.29516190f, 0.42104787f, 0.52125853f, -0.30163035f, 0.23711666f, -0.20836246f, -0.31371078f, -0.24596588f, 
    -0.29939267f, -0.74439859f, 0.20466389f, -0.00875795f, 0.44358686f, 0.47199303f, 0.13910158f, 0.03076136f, 
    0.14180616f, 0.17057876f, 0.68913233f, -0.13407809f, 0.64317364f, -0.11286804f, 0.00007740f, 0.49495599f, 
    -0.03366425f, 0.25445637f, 0.49424109f, -0.03655929f, -0.32105225f, -0.68369222f, 0.06954648f, 0.35464936f, 
    0.14221536f, -0.42050067f, -0.35682580f, 0.33736199f, 0.04537516f, -0.59702808f, -0.49755710f, -0.10610993f, 
    -0.74826300f, -0.34963009f, 0.03147485f, 0.25770855f, 0.27000460f, -0.24789764f, 0.42614427f, 0.11982057f, 
    0.44287813f, 0.51690573f, 0.08056296f, 0.46189401f, 0.38323319f, -0.24138093f, -0.23746477f, -0.41178551f, 
    -0.34760013f, -0.56896633f, 0.17028098f, 0.30480242f, 0.50946450f, 0.17711821f, 0.37021413f, 0.48939243f, 
    0.40279967f, 0.31225842f, 0.08023049f, -0.40476784f, 0.43613535f, -0.02168659f, -0.23821393f, -0.35991845f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12893383f, -0.18327124f, 0.25241721f, -0.16500524f, 0.02337328f, 0.07435118f, -0.11060522f, -0.29290563f, 
    -0.26109031f, 0.00825120f, 0.00524237f, -0.01239677f, -0.14726050f, 0.22721419f, -0.08336681f, -0.25820565f, 
    0.01839200f, -0.20058550f, 0.08094222f, -0.03154869f, 0.17427316f, -0.03427436f, 0.18406205f, -0.29346684f, 
    0.31422433f, 0.03253923f, -0.06955475f, -0.01689388f, 0.28996757f, 0.16847542f, 0.19474439f, 0.06086665f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.09005777f, -0.17469309f, 0.10577109f, -0.04115523f, 0.02612345f, 0.04009417f, -0.02323873f, -0.14003740f, 
    -0.10820804f, 0.09496063f, 0.12752999f, 0.30635914f, -0.12894244f, -0.15242764f, -0.02548763f, 0.02183977f, 
    0.00646149f, 0.11995763f, -0.01685483f, -0.16890217f, 0.13966621f, 0.02065841f, 0.09800394f, -0.01824626f, 
    -0.01558364f, -0.06230336f, -0.18520100f, -0.13398087f, -0.05424898f, 0.11629134f, -0.01096950f, -0.01726167f, 
    0.15999788f, 0.04693982f, 0.00776678f, -0.14480592f, -0.01814845f, 0.00229843f, 0.17653151f, -0.08976261f, 
    0.08474065f, -0.01914985f, 0.00467264f, -0.02718193f, 0.12309103f, 0.13208838f, 0.23579064f, 0.00922391f, 
    -0.07580864f, -0.08191661f, -0.09791653f, 0.05147643f, 0.01531173f, 0.11080269f, 0.17173705f, -0.05956749f, 
    0.17869577f, -0.05021872f, -0.02706558f, 0.03961981f, -0.18847096f, 0.04722449f, -0.06437141f, 0.01330575f, 
    0.12291346f, -0.13556427f, -0.09939985f, -0.07375149f, 0.14735357f, -0.00860155f, 0.04695342f, -0.01229444f, 
    -0.01391393f, -0.01503634f, -0.25282544f, -0.05937614f, 0.00463299f, 0.01444641f, 0.03058186f, -0.20451073f, 
    -0.09475796f, 0.09021240f, -0.04726540f, -0.14364670f, -0.01167648f, -0.13183473f, -0.02861114f, 0.00387703f, 
    -0.10653482f, -0.09125472f, -0.04616849f, 0.00163868f, -0.20258017f, -0.04184912f, -0.01887561f, 0.07142317f, 
    0.09379159f, 0.01451058f, -0.10977711f, -0.05120842f, 0.07509480f, 0.12666696f, 0.05414073f, -0.16220480f, 
    0.01033259f, -0.02931347f, -0.04866775f, 0.01948211f, 0.04367794f, 0.01085407f, 0.16584207f, -0.06887535f, 
    0.03383643f, -0.06569779f, -0.03066300f, 0.12302944f, 0.10852822f, -0.02482824f, -0.06794910f, -0.10691667f, 
    0.02253955f, -0.08187774f, 0.10620011f, 0.12352735f, 0.00121410f, -0.18048094f, 0.16588071f, -0.07217609f, 
    0.15581511f, -0.03759123f, 0.05354368f, -0.16112049f, 0.13958324f, 0.04284912f, 0.03784718f, -0.12301727f, 
    -0.03496154f, 0.16474229f, -0.01761284f, 0.05058187f, -0.10494042f, 0.02459626f, -0.01098086f, 0.03401346f, 
    -0.07329306f, -0.03870926f, -0.06527233f, 0.04907562f, 0.12619612f, -0.07427380f, 0.03191392f, -0.07460042f, 
    0.00363092f, 0.07904509f, -0.09463209f, 0.06127425f, 0.10013831f, -0.11882948f, 0.07795072f, 0.05876552f, 
    0.05082621f, 0.11029872f, -0.09496642f, -0.15159179f, 0.03938556f, 0.05745179f, 0.06981239f, 0.21347627f, 
    -0.03578716f, 0.00516947f, -0.10775260f, 0.05853056f, -0.06755508f, 0.09185093f, 0.07944901f, -0.01707898f, 
    -0.08221285f, 0.06017245f, 0.06883173f, 0.10527170f, -0.01328016f, -0.14547144f, -0.01008593f, -0.08251105f, 
    0.03288274f, -0.09103173f, 0.07129931f, 0.09031097f, -0.02900056f, -0.20948006f, -0.06428221f, 0.16226716f, 
    -0.09198498f, -0.04402933f, 0.07875602f, 0.07647261f, 0.10060146f, 0.16585727f, -0.10554730f, -0.07586438f, 
    0.10213570f, -0.09313278f, 0.02041384f, 0.01181120f, -0.05214137f, 0.00196110f, 0.03076255f, -0.11801616f, 
    -0.00214484f, 0.17987463f, 0.04160717f, 0.10367043f, -0.02700797f, -0.02362305f, -0.01553458f, 0.10536770f, 
    0.18526083f, -0.00430172f, 0.01618750f, 0.02822800f, -0.02210805f, 0.07056419f, 0.03776096f, -0.03332696f, 
    0.05642087f, 0.01871738f, 0.02368105f, 0.05410933f, -0.04607492f, 0.08533805f, -0.11812913f, -0.06910471f, 
    0.03075289f, 0.06671826f, 0.04282553f, 0.07152866f, -0.12564988f, -0.07344650f, 0.14478093f, 0.08879553f, 
    -0.02930936f, 0.00157740f, -0.01583024f, 0.05519928f, -0.10600730f, 0.21602631f, 0.02746794f, 0.05027777f, 
    0.02899717f, 0.09996008f, 0.01253429f, -0.10392874f, 0.14947423f, -0.06961249f, 0.07553534f, 0.00196529f, 
    -0.13928975f, 0.03293172f, 0.03967664f, 0.02200447f, -0.07897396f, -0.09117467f, 0.14027731f, 0.10809588f, 
    0.04988724f, -0.06928576f, 0.01464211f, 0.04355375f, -0.02743820f, -0.05235968f, -0.05966221f, -0.08771756f, 
    0.05657102f, -0.06978137f, 0.05251248f, 0.02726751f, -0.15412627f, -0.10134569f, 0.00504067f, -0.02652403f, 
    -0.09783406f, -0.17649361f, -0.01097900f, 0.12279566f, 0.12155990f, 0.06898607f, -0.13021131f, -0.06264086f, 
    -0.03008288f, -0.00347293f, -0.05769529f, -0.05896172f, 0.00187104f, -0.05208033f, -0.00199454f, -0.00272086f, 
    -0.01147199f, 0.00041061f, -0.00564214f, -0.00675923f, 0.00595199f, 0.03587713f, -0.06667320f, -0.01173975f, 
    0.02570635f, 0.02396603f, 0.03175493f, -0.04272825f, 0.00488200f, 0.04389798f, -0.06202774f, -0.03597759f, 
    -0.05751751f, -0.00852339f, 0.03197816f, -0.02136876f, -0.05074538f, 0.03121741f, -0.02520836f, -0.06690757f, 
    -0.06054823f, -0.03994229f, 0.02301407f, -0.02471348f, 0.00072012f, 0.03990940f, 0.00023204f, 0.01568356f, 
    -0.01419807f, 0.02497566f, 0.01131933f, 0.01639808f, 0.03460789f, -0.03554606f, -0.04862216f, 0.00034583f, 
    0.02850352f, -0.05716635f, 0.02255434f, 0.02114078f, 0.01412905f, -0.05180767f, -0.05100433f, 0.05119004f, 
    -0.00675031f, 0.03363928f, 0.00988824f, -0.04035505f, -0.00649266f, 0.00285415f, 0.03259520f, -0.00422890f, 
    0.03837444f, -0.01230857f, -0.00148988f, -0.05551620f, -0.06585190f, 0.01389608f, -0.02924794f, -0.03680322f, 
    -0.05998345f, 0.02819928f, 0.03935862f, -0.06669566f, -0.00387650f, -0.06584565f, 0.04924145f, -0.01965720f, 
    -0.01711631f, -0.01561297f, -0.01684192f, -0.00820043f, -0.05968819f, 0.04629806f, -0.06878239f, -0.03879806f, 
    -0.00134653f, -0.05430200f, -0.01378983f, 0.02084213f, -0.01713081f, 0.01979432f, 0.04895520f, 0.02176157f, 
    -0.00347382f, 0.00518181f, 0.02711806f, -0.01232655f, 0.02740023f, -0.01157136f, -0.03573238f, -0.05240086f, 
    0.01231976f, 0.03991655f, 0.01957029f, 0.00061265f, -0.05709026f, -0.02116629f, -0.03156710f, 0.02524182f, 
    0.02732828f, 0.03721223f, -0.06460437f, 0.01956098f, -0.00466551f, 0.02712389f, 0.02516409f, 0.00715602f, 
    0.02812102f, -0.03982805f, 0.01867605f, -0.00314277f, 0.01078843f, -0.00776831f, 0.04300227f, 0.00256043f, 
    -0.03030536f, 0.03253644f, -0.06426493f, -0.01804360f, -0.02071595f, -0.00359355f, 0.02545385f, -0.02459817f, 
    0.03571058f, -0.00206561f, 0.01847304f, -0.03121043f, -0.03945101f, 0.00927120f, -0.01688163f, 0.01639684f, 
    0.02059012f, 0.00463322f, 0.01345219f, -0.06119228f, 0.02007421f, -0.03490038f, 0.02682334f, 0.05129721f, 
    -0.06495592f, 0.03349393f, -0.00667351f, 0.03090574f, -0.00065770f, -0.00200398f, -0.06684838f, -0.00826115f, 
    0.00020788f, -0.01093912f, -0.00723045f, -0.04868723f, 0.00262298f, -0.05309463f, -0.03811082f, -0.03764100f, 
    -0.02165470f, 0.02615201f, -0.04735982f, -0.04234191f, 0.02513336f, -0.00545485f, 0.04500373f, -0.05457368f, 
    0.03830647f, -0.00989077f, -0.06133854f, 0.03831083f, 0.02090759f, 0.00385406f, -0.03169074f, 0.04237325f, 
    -0.02824862f, 0.04555318f, 0.04424537f, -0.05425866f, -0.02084351f, 0.04206942f, 0.02512126f, 0.04689365f, 
    0.03879949f, 0.00026307f, 0.02156282f, -0.04410421f, 0.02700161f, 0.04329902f, -0.03857708f, 0.01227870f, 
    0.00294825f, 0.03411367f, 0.03248804f, 0.02307769f, -0.02025337f, -0.06532393f, -0.00913383f, -0.04375544f, 
    -0.05462946f, -0.00611405f, -0.03232321f, -0.05839250f, 0.00818595f, -0.03833104f, -0.01749288f, -0.02841754f, 
    -0.04469726f, -0.05926218f, -0.03468486f, -0.01948934f, -0.04449854f, -0.02057381f, -0.06254844f, -0.01271534f, 
    -0.06892873f, 0.01328057f, -0.05567817f, -0.02224524f, -0.00564602f, -0.06266829f, -0.03725054f, -0.00556286f, 
    -0.00058552f, -0.06358446f, 0.01200734f, 0.04976752f, -0.01751931f, -0.03642754f, -0.03709439f, -0.01063291f, 
    -0.01149260f, 0.03559884f, 0.02446102f, 0.05026349f, -0.04312126f, 0.01358915f, 0.04950069f, 0.04196774f, 
    -0.01437184f, 0.03965441f, 0.00427617f, 0.01124766f, -0.03148895f, 0.04120631f, 0.01354744f, -0.00527618f, 
    0.00545138f, 0.01382208f, -0.01123451f, -0.01223032f, -0.01708419f, -0.00002822f, -0.00501801f, -0.05345967f, 
    0.03800639f, 0.02444657f, -0.01634227f, -0.01854677f, -0.03498507f, 0.04209677f, 0.00627189f, 0.03579009f, 
    -0.05993926f, -0.03126353f, -0.02363543f, -0.05024045f, -0.05717003f, 0.00723363f, 0.03822545f, 0.03871978f, 
    -0.02168694f, 0.04159546f, -0.03293506f, -0.04645060f, 0.00408699f, -0.04382736f, -0.05363869f, -0.06468482f, 
    -0.17169866f, -0.09289682f, -0.16408400f, -0.01579391f, 0.03954436f, 0.01687814f, 0.12109882f, 0.18678716f, 
    -0.03804415f, 0.09195197f, -0.17687491f, -0.03073088f, -0.04072700f, -0.01776113f, -0.00137775f, -0.04502895f, 
    0.02813835f, -0.04670296f, -0.26877612f, -0.12103499f, 0.00567634f, 0.01217075f, 0.06726983f, 0.18627959f, 
    0.09609082f, 0.03982529f, -0.04911640f, -0.21843058f, 0.00063657f, -0.17255951f, 0.00703831f, 0.02502240f, 
    -0.00413660f, -0.05481272f, 0.06303874f, 0.06324849f, 0.08136112f, -0.05695493f, 0.04483055f, -0.08361541f, 
    -0.04138669f, -0.03887128f, -0.04792800f, 0.10611362f, -0.06366169f, -0.03234809f, 0.04770473f, 0.00694677f, 
    -0.06352909f, -0.00512246f, 0.06400441f, -0.02140375f, 0.01157653f, -0.06016913f, -0.13627632f, -0.22057571f, 
    -0.00550431f, 0.06104337f, 0.01056323f, 0.08103938f, 0.00058440f, 0.02482166f, 0.06995748f, -0.38068500f, 
    -0.11731220f, -0.22054571f, 0.08490975f, -0.06431349f, -0.03328243f, 0.04279759f, -0.01116939f, 0.00718616f, 
    -0.08791072f, 0.09933136f, 0.07298648f, -0.00597087f, -0.00549300f, -0.09926294f, -0.00004004f, 0.02158361f, 
    0.11086909f, -0.00339998f, 0.04815262f, -0.02086078f, -0.03227027f, 0.01363929f, 0.06665274f, -0.00814860f, 
    0.06635778f, -0.03109225f, -0.34804523f, -0.17000246f, -0.16024429f, 0.00311190f, 0.07359484f, 0.14825980f, 
    0.03408365f, -0.03289022f, -0.03353546f, -0.07737645f, -0.10283896f, 0.02949542f, 0.08620301f, 0.03447691f, 
    -0.00443873f, 0.12937079f, 0.14382152f, -0.04773192f, 0.21189275f, 0.09190723f, 0.00917527f, 0.00282588f, 
    -0.11796474f, -0.02934011f, -0.02771859f, -0.04046755f, -0.01399286f, -0.10108761f, 0.02048197f, -0.14372012f, 
    0.04778304f, 0.11078192f, 0.03223857f, -0.08219300f, 0.01843280f, -0.02072882f, -0.04568167f, -0.18925931f, 
    0.22576408f, 0.00818534f, 0.03627757f, 0.18298714f, 0.06980464f, 0.01414501f, 0.06703567f, 0.21947892f, 
    0.05717071f, -0.04840137f, 0.01520060f, 0.05240942f, -0.11862266f, -0.00661936f, 0.05329702f, 0.07568080f, 
    -0.05887888f, -0.05064479f, -0.01510239f, 0.09405556f, -0.08452659f, 0.03541826f, -0.09753548f, 0.23063669f, 
    -0.02365972f, -0.22729729f, -0.08566944f, -0.05055367f, 0.10112207f, 0.09248458f, 0.05438994f, -0.10976383f, 
    -0.09812278f, 0.08094580f, -0.35490471f, -0.31828898f, -0.30880603f, 0.06460267f, 0.08794735f, -0.00802469f, 
    0.00029144f, -0.09092740f, -0.04597465f, 0.14497317f, 0.09285379f, 0.15364262f, 0.09765138f, -0.05717617f, 
    0.11323319f, -0.02886080f, -0.04733627f, 0.05519779f, 0.26197377f, 0.11128955f, 0.09827461f, 0.00307990f, 
    0.02466298f, -0.02151223f, 0.01640164f, -0.04173595f, 0.03869833f, 0.11808655f, 0.09812611f, -0.12457613f, 
    -0.10807112f, -0.09575143f, 0.00412458f, 0.00069394f, 0.06114289f, 0.02565978f, -0.10672160f, -0.12779085f, 
    -0.05876015f, 0.01619342f, -0.01605169f, 0.05376939f, -0.12797627f, -0.01946030f, -0.06285904f, 0.00058186f, 
    0.00467015f, -0.16984890f, -0.09070360f, -0.00654106f, 0.15929177f, 0.04602319f, 0.02884199f, 0.08717531f, 
    0.01268538f, 0.02105333f, -0.21287340f, 0.05700612f, 0.13465169f, -0.02055052f, -0.08727967f, 0.02345992f, 
    -0.06884240f, 0.07027678f, 0.05396350f, -0.09651200f, -0.13075198f, 0.02872103f, 0.00051871f, 0.13977787f, 
    0.05789880f, 0.07736352f, -0.28430358f, -0.22765404f, 0.02983001f, 0.06000381f, -0.01850120f, 0.02273217f, 
    0.03883132f, -0.00229935f, 0.00428211f, 0.04653565f, 0.04205818f, 0.22238152f, 0.02159712f, -0.00270898f, 
    0.12984020f, 0.05129597f, 0.16398352f, -0.12937614f, 0.14186260f, -0.01697018f, 0.12122964f, 0.03295146f, 
    -0.09418640f, 0.13214000f, -0.07559334f, 0.02698868f, 0.04716479f, -0.06973030f, 0.02619741f, 0.07362551f, 
    -0.01897591f, 0.14434348f, 0.02618902f, 0.17257950f, 0.11386783f, 0.08010426f, 0.10500624f, -0.06632251f, 
    -0.00347217f, 0.09632578f, 0.02386051f, 0.04035695f, 0.05791821f, -0.00437093f, 0.04994748f, -0.20524798f, 
    -0.21055086f, 0.00435787f, 0.20017216f, 0.05063938f, 0.05777220f, -0.02098217f, 0.03835302f, -0.14483498f, 
    0.09911319f, 0.22253753f, 0.02876184f, 0.27083021f, -0.11099725f, -0.08058503f, -0.16006505f, -0.00984830f, 
    -0.12628572f, -0.43738198f, -0.21512856f, -0.08231657f, 0.08593542f, 0.11385403f, 0.00523428f, 0.03746498f, 
    0.06865491f, -0.18828839f, 0.16012393f, 0.16980641f, -0.07559178f, 0.11450581f, -0.10325037f, -0.13392910f, 
    -0.12175928f, -0.03831414f, -0.06402230f, -0.19668254f, 0.00251404f, 0.01977378f, 0.05902627f, 0.07360604f, 
    -0.08940370f, 0.00551149f, 0.07295395f, 0.17238972f, -0.06413849f, -0.07740759f, 0.17018367f, -0.07919848f, 
    -0.07030618f, 0.05452342f, -0.05871621f, 0.01662305f, 0.07399579f, -0.36924368f, 0.02805664f, -0.20578450f, 
    0.02254256f, 0.10609785f, -0.09105362f, -0.04845045f, 0.10069629f, -0.04310391f, 0.22092679f, 0.26746094f, 
    -0.29515409f, 0.12931660f, -0.15662141f, 0.05316439f, -0.00224164f, -0.02044584f, 0.12694331f, -0.21068262f, 
    -0.23981641f, -0.24665958f, -0.00569286f, -0.05658320f, 0.00025230f, 0.11786164f, 0.00469435f, 0.03801377f, 
    0.02639342f, -0.00630435f, 0.09724439f, -0.04253413f, 0.05008481f, -0.05745943f, -0.19329664f, 0.05691391f, 
    0.13473521f, 0.23961653f, 0.17426923f, 0.17173272f, -0.02141144f, -0.04014252f, -0.00384949f, 0.14015076f, 
    0.00432168f, 0.01262468f, 0.32716325f, -0.04003437f, 0.09328298f, -0.02441907f, 0.06968685f, -0.01086927f, 
    0.11694508f, 0.07823441f, 0.09752391f, -0.01468530f, 0.00469423f, -0.38919941f, -0.03967423f, -0.00341672f, 
    0.03247444f, 0.13571873f, 0.04748353f, 0.09348867f, -0.24636456f, -0.17554981f, 0.20306821f, -0.01930559f, 
    0.13639294f, -0.01643289f, -0.03269363f, -0.01024568f, -0.05372138f, 0.07267101f, 0.02556796f, -0.19406421f, 
    0.07390388f, 0.01078373f, -0.04603277f, 0.06588506f, 0.05901428f, 0.14227328f, 0.04515297f, 0.07424999f, 
    0.05610310f, 0.13622659f, -0.10635241f, 0.10434675f, 0.13521142f, -0.09753094f, 0.10377800f, 0.06496993f, 
    -0.05057657f, 0.17594650f, 0.05134106f, 0.06263907f, 0.00125117f, -0.05917723f, 0.11492097f, -0.03252276f, 
    -0.01971362f, 0.03774053f, -0.05001685f, 0.00443280f, 0.02957636f, -0.00976512f, -0.10326637f, 0.14534859f, 
    -0.00200705f, 0.16998619f, -0.13348368f, -0.50535065f, -0.16354415f, -0.03636929f, 0.02262664f, 0.10530709f, 
    -0.10625917f, -0.04919018f, 0.03130376f, 0.07562875f, -0.04662796f, 0.16329326f, -0.05274338f, -0.07752309f, 
    -0.03096581f, -0.04389354f, 0.09954701f, 0.13387531f, 0.02068830f, -0.47380355f, 0.12659204f, 0.03525869f, 
    -0.06013246f, -0.05572135f, 0.04668682f, -0.07467152f, 0.01719197f, 0.04880859f, -0.04224545f, 0.10848920f, 
    -0.01772596f, -0.04043028f, -0.02360173f, -0.07159856f, -0.08977091f, -0.17955400f, -0.02473482f, 0.12176791f, 
    0.03001487f, -0.00059194f, -0.05218529f, -0.01168032f, 0.05785546f, 0.00715744f, -0.23255709f, -0.06485718f, 
    0.41548666f, 0.08630054f, 0.02920109f, -0.14610481f, 0.06858969f, 0.16525093f, 0.03419523f, -0.10381816f, 
    -0.25042951f, 0.14435650f, -0.12756239f, -0.15357052f, 0.08245901f, 0.04457542f, -0.00584519f, 0.08002848f, 
    -0.21393387f, 0.10763843f, -0.27023208f, 0.08135447f, -0.02368254f, -0.09388112f, -0.01468358f, 0.06215744f, 
    0.13464007f, -0.24725869f, -0.06863797f, 0.11487239f, 0.03145406f, -0.10703514f, 0.05088956f, 0.08118162f, 
    -0.08487098f, 0.10521998f, 0.06457017f, -0.05197105f, 0.03299902f, 0.08050032f, -0.01207356f, 0.01804568f, 
    0.12337662f, -0.06965787f, 0.10186322f, 0.09281329f, 0.05291582f, 0.19251588f, 0.04786470f, -0.00305092f, 
    0.03033281f, -0.02500072f, -0.05937122f, 0.15905644f, 0.08798613f, 0.13739842f, 0.16978234f, 0.03433484f, 
    -0.03960474f, -0.03601914f, 0.00245520f, -0.08735239f, -0.04605781f, 0.13634270f, 0.01768748f, -0.13792364f, 
    0.01407316f, -0.05720856f, 0.02778803f, -0.05045399f, 0.00603501f, -0.03009978f, -0.03543881f, 0.01593664f, 
    0.12828146f, -0.09771496f, -0.01456352f, 0.04039564f, -0.10663543f, -0.02200121f, -0.07318138f, -0.01254609f, 
    0.05489228f, -0.00097649f, 0.07934169f, 0.05245130f, -0.04419005f, -0.11305248f, 0.05464474f, -0.09579315f, 
    0.16858004f, 0.11275735f, -0.06716289f, 0.02677122f, -0.09179701f, 0.11160848f, -0.13160922f, 0.04453883f, 
    -0.01794807f, -0.06633985f, -0.06019693f, 0.20360357f, -0.09851161f, 0.07407232f, -0.03062336f, -0.01780905f, 
    -0.07050214f, 0.00985663f, 0.18348365f, 0.06251264f, 0.08008260f, -0.01697925f, -0.04340718f, 0.03048979f, 
    -0.03945610f, 0.05621744f, 0.08744859f, 0.08042613f, -0.06940152f, -0.05657846f, -0.04476799f, -0.04911892f, 
    -0.10458746f, -0.08782756f, 0.06184478f, -0.02024936f, -0.33309636f, 0.26613191f, 0.01050433f, -0.10933782f, 
    -0.03115733f, -0.04848217f, 0.11083394f, 0.00030154f, 0.00429273f, -0.05924276f, -0.20945953f, 0.10612105f, 
    -0.05620744f, -0.00209132f, -0.02930248f, 0.02882413f, -0.08446940f, 0.01421096f, 0.13502614f, -0.10190255f, 
    0.16804776f, -0.04317642f, -0.04512354f, 0.01948367f, 0.06187707f, 0.06124265f, 0.00959175f, -0.16379324f, 
    -0.08295400f, 0.09939968f, -0.04350319f, 0.05941467f, -0.00426583f, 0.16119170f, -0.02660107f, 0.09726365f, 
    -0.05192209f, 0.11530426f, -0.03709529f, -0.16804272f, -0.00867164f, 0.21398430f, -0.11910109f, 0.05523598f, 
    0.00140024f, -0.17951073f, -0.25439885f, 0.00651562f, 0.15972461f, 0.00961126f, 0.07253483f, 0.07034872f, 
    0.07170664f, 0.08384462f, 0.06845613f, 0.05057264f, 0.02844597f, -0.18631281f, 0.03583601f, 0.03534880f, 
    0.02757850f, 0.10334031f, 0.06976732f, 0.05578425f, -0.15315346f, -0.15999958f, 0.01512052f, 0.11078893f, 
    0.08949948f, -0.17102368f, -0.09914857f, -0.00730873f, -0.03440721f, 0.03487003f, -0.21000212f, -0.00298489f, 
    -0.09699192f, 0.03874098f, -0.01607948f, -0.03624716f, -0.02727201f, 0.07611512f, 0.06928806f, -0.06939015f, 
    -0.02164685f, 0.05293868f, 0.02542361f, 0.06847000f, 0.12668808f, -0.03460591f, -0.29684949f, -0.14053683f, 
    -0.11105125f, 0.12017313f, 0.02267794f, -0.04577253f, -0.02996460f, 0.02908760f, 0.01648699f, 0.02468559f, 
    0.02573768f, -0.22846279f, 0.04456325f, 0.08980625f, -0.02284276f, -0.06924862f, -0.10640634f, -0.07502721f, 
    -0.25864384f, -0.04005954f, -0.08675051f, -0.07793894f, 0.06509592f, 0.06317564f, 0.17939746f, -0.10103427f, 
    -0.03665309f, 0.08240529f, -0.06631501f, 0.04362516f, 0.01727240f, 0.12262112f, 0.03883427f, -0.02610555f, 
    0.07298712f, 0.04548668f, 0.14743333f, 0.12595798f, 0.12655213f, -0.02431304f, 0.04171127f, 0.02853537f, 
    -0.04420702f, 0.10424403f, -0.11867438f, 0.13462256f, 0.07513119f, -0.01649722f, 0.04492075f, -0.05053413f, 
    0.16372621f, 0.02881279f, -0.08520555f, 0.05633352f, -0.05864695f, 0.04065661f, 0.00217521f, -0.10387778f, 
    0.13534388f, 0.03220254f, 0.04030478f, 0.12195141f, 0.07688700f, 0.07672152f, -0.02991588f, -0.28618520f, 
    0.02073735f, -0.03333261f, 0.02357068f, 0.04212619f, 0.05496565f, -0.23112752f, -0.17548543f, -0.08947717f, 
    -0.04206939f, -0.07283194f, 0.09922362f, -0.11250084f, 0.13243218f, 0.12944810f, -0.04681783f, -0.26803362f, 
    -0.17004655f, -0.16451961f, -0.02524271f, 0.01461210f, -0.00386486f, -0.01880641f, 0.05144278f, -0.10075492f, 
    0.07507610f, -0.04205693f, 0.06845210f, 0.10549414f, 0.06310210f, 0.03343786f, 0.15254951f, 0.07126416f, 
    -0.02975462f, -0.34790167f, -0.07316037f, 0.03991321f, -0.01252557f, 0.06281123f, -0.03963883f, -0.05747537f, 
    -0.03361238f, -0.05797436f, 0.07529623f, 0.05542499f, -0.03492405f, 0.10391707f, 0.07856097f, -0.07648263f, 
    -0.08827454f, -0.03068469f, -0.04341505f, -0.25483471f, 0.08131345f, -0.08709627f, 0.12460703f, 0.01494662f, 
    -0.03517265f, 0.05418764f, 0.01725858f, -0.08193818f, -0.19044651f, -0.08285948f, -0.05795610f, -0.07897228f, 
    -0.01252095f, -0.13503653f, 0.04257689f, -0.09298527f, 0.11002328f, -0.01798804f, -0.12976116f, -0.04880461f, 
    -0.08217817f, 0.04773545f, -0.01432865f, -0.12183019f, 0.04928986f, 0.00299937f, -0.04820328f, 0.09286283f, 
    -0.10356719f, -0.05469118f, 0.12913148f, -0.00720121f, -0.02407620f, 0.01331137f, 0.03645149f, 0.15125684f, 
    0.06488513f, 0.04660878f, -0.02461370f, -0.06539002f, 0.05615736f, 0.08228125f, 0.05521957f, 0.10745861f, 
    0.04039977f, 0.00866694f, 0.01709415f, 0.09750576f, -0.02781618f, 0.05700630f, -0.01474671f, 0.08096367f, 
    0.12517300f, -0.35501650f, -0.31377429f, -0.36516494f, -0.03391446f, 0.09814537f, -0.11463330f, 0.14213495f, 
    -0.02284561f, -0.09170627f, 0.15855783f, 0.06216329f, -0.02642828f, 0.03654993f, -0.04121843f, 0.08672924f, 
    0.05920459f, 0.00684065f, 0.01993059f, 0.17803662f, -0.00699834f, -0.05046144f, 0.01404565f, -0.19596891f, 
    -0.01354983f, 0.14690605f, 0.07215051f, 0.10512690f, -0.10819389f, 0.10628160f, 0.08859433f, -0.04622707f, 
    0.02166095f, 0.03905641f, 0.09816762f, -0.03938819f, -0.04635062f, -0.15813988f, -0.24414816f, -0.18016732f, 
    0.00979293f, 0.13333876f, -0.13812298f, 0.02121498f, 0.00279456f, -0.08467040f, -0.22635938f, 0.02720300f, 
    -0.49003375f, -0.01312991f, -0.00514808f, 0.05290716f, 0.05945444f, 0.01920340f, 0.15735728f, -0.38582256f, 
    -0.21520831f, -0.05412522f, -0.00246074f, -0.08278776f, 0.06801356f, -0.05032735f, -0.04397604f, -0.01803784f, 
    0.16049945f, 0.08387790f, 0.00291323f, 0.00708042f, 0.08810619f, -0.02281941f, -0.16319910f, 0.08802696f, 
    -0.06122296f, 0.23339304f, 0.00948081f, 0.17232011f, -0.15749721f, -0.01608597f, 0.04648286f, -0.05383965f, 
    -0.01219255f, 0.07422325f, 0.05212151f, -0.02638822f, 0.02378919f, 0.07712249f, -0.05257778f, -0.08571211f, 
    0.02448588f, 0.10864471f, 0.03100487f, -0.27152878f, -0.11892146f, -0.06981800f, 0.01614677f, 0.11003862f, 
    0.07912720f, 0.00332665f, -0.08100200f, 0.03420727f, -0.06737830f, -0.04665624f, 0.02021804f, -0.06063173f, 
    0.05364467f, -0.15957582f, 0.03881002f, 0.02510505f, -0.02149489f, 0.08897579f, -0.01041308f, 0.05534339f, 
    -0.02105541f, -0.00300323f, 0.07884272f, 0.15190904f, 0.05394187f, 0.04014723f, -0.21098709f, -0.03717768f, 
    -0.11006858f, 0.06821158f, -0.12621854f, 0.00940540f, 0.05640833f, -0.01822099f, 0.06289624f, -0.10757248f, 
    -0.02217931f, -0.03726118f, 0.03225002f, 0.01659968f, -0.03130038f, -0.07194921f, 0.09962412f, -0.14054453f, 
    0.01333646f, 0.07566398f, -0.03066796f, 0.03348552f, -0.01766023f, -0.11765406f, 0.11660057f, 0.03403330f, 
    -0.04099677f, -0.14660509f, -0.05941686f, 0.08386485f, -0.03879764f, -0.01832833f, -0.21364513f, 0.05945335f, 
    0.05397869f, 0.08063406f, 0.20942837f, 0.11695111f, 0.00181783f, 0.07010363f, -0.01082712f, -0.20711365f, 
    0.01019555f, 0.05084739f, -0.07289106f, -0.13773176f, -0.10551646f, 0.15208513f, 0.00892566f, 0.14687520f, 
    0.00066196f, 0.06796157f, -0.05253364f, 0.11288903f, -0.11258397f, -0.06536870f, -0.02553365f, -0.00345794f, 
    -0.03580894f, 0.12428030f, 0.00552966f, 0.13880984f, 0.02205079f, -0.03187840f, 0.01995976f, -0.05823596f, 
    -0.07689784f, -0.01045627f, 0.01464091f, 0.04175007f, -0.10836104f, -0.11067580f, -0.14526433f, 0.08944225f, 
    0.30206212f, 0.03352016f, -0.12995642f, -0.07766722f, 0.05541515f, 0.05663983f, 0.08400928f, -0.18532419f, 
    -0.15881008f, 0.11415024f, -0.06336635f, -0.09916776f, 0.10536747f, -0.07305565f, 0.05012784f, 0.05577230f, 
    0.01096270f, -0.19629975f, 0.05594782f, -0.00131618f, 0.09110663f, 0.03923533f, 0.04859573f, 0.03574401f, 
    0.01373781f, -0.17479201f, -0.01870545f, 0.02353591f, -0.01321892f, 0.01377316f, 0.05847028f, -0.03600768f, 
    0.02674538f, 0.08776999f, 0.04512425f, -0.04851142f, -0.01139675f, 0.07655111f, -0.04484857f, 0.03328571f, 
    -0.07533232f, 0.08068513f, 0.02955357f, 0.01255716f, 0.04403426f, -0.06618259f, -0.12634473f, -0.03743779f, 
    0.10561735f, 0.06286468f, 0.08442339f, -0.09695133f, 0.00525559f, 0.13269213f, 0.08865088f, -0.11877645f, 
    -0.04698333f, -0.06098377f, -0.01800085f, 0.05641260f, -0.00735535f, 0.07087632f, 0.01222446f, -0.08090541f, 
    0.03800227f, -0.06319984f, 0.01358409f, -0.01758926f, 0.02223260f, 0.00940416f, 0.04059959f, -0.05148468f, 
    0.03461687f, 0.01341583f, 0.00735618f, 0.02085144f, -0.04130577f, -0.04038300f, 0.11090545f, 0.03494834f, 
    0.02714990f, 0.15430592f, -0.08999849f, 0.05768780f, -0.10614174f, 0.09615355f, 0.03319401f, -0.03172411f, 
    -0.00084695f, -0.02496930f, 0.04660816f, 0.01359086f, 0.04139258f, -0.02409867f, -0.02387689f, 0.05048834f, 
    0.01277393f, -0.04765479f, 0.02300738f, -0.02356645f, 0.02479245f, 0.02650623f, 0.00960337f, 0.02812261f, 
    0.04306250f, 0.01162997f, -0.02985071f, -0.03648271f, -0.02455193f, -0.06510667f, -0.02521629f, -0.01816170f, 
    -0.06179940f, 0.02686922f, 0.01630996f, 0.03010950f, -0.01227409f, -0.03796963f, 0.03523574f, -0.02211956f, 
    -0.03768955f, -0.04638459f, -0.02662605f, -0.00791426f, -0.01613090f, -0.01272051f, -0.02044290f, 0.03722140f, 
    0.02006665f, -0.02167889f, -0.01530096f, 0.03829568f, 0.02592221f, 0.00252565f, 0.00405180f, 0.01686851f, 
    -0.03408535f, 0.02534109f, -0.01664240f, 0.02653072f, -0.02278323f, -0.06031168f, -0.02983659f, -0.04231252f, 
    0.04384313f, -0.04861381f, 0.02042577f, 0.02936698f, 0.00744328f, 0.01640586f, 0.00870422f, -0.02217035f, 
    0.02681004f, -0.01499133f, 0.02307677f, -0.01699906f, 0.05070115f, -0.04892981f, -0.06047377f, -0.05853900f, 
    -0.00999410f, -0.00786225f, -0.00561455f, -0.03219151f, -0.01289664f, -0.03358078f, 0.05302783f, -0.01709576f, 
    -0.03428765f, -0.05867778f, -0.02647269f, -0.05065114f, 0.04269573f, 0.00837245f, 0.00275126f, 0.04514458f, 
    -0.02152003f, -0.03981382f, -0.05535604f, -0.01329743f, -0.01247192f, -0.00282753f, 0.02127867f, 0.04516508f, 
    -0.03655216f, -0.06139914f, -0.00670334f, -0.05809493f, 0.04514105f, -0.00255812f, 0.03980041f, -0.00408334f, 
    0.00403470f, 0.01599521f, 0.04348022f, -0.04488065f, 0.01471865f, 0.00083948f, 0.00103441f, 0.01039170f, 
    0.01948096f, 0.05651495f, -0.01768690f, -0.05334347f, -0.06295093f, 0.03180830f, -0.04983352f, 0.04736235f, 
    -0.04458554f, 0.02333088f, -0.04594302f, -0.06099962f, -0.04607258f, -0.01184899f, -0.03459148f, -0.01456166f, 
    0.00479919f, 0.02401339f, -0.04332012f, 0.03661676f, 0.00589113f, 0.04389516f, 0.02106617f, 0.01669764f, 
    0.04280216f, 0.01456357f, 0.03494503f, -0.05825620f, -0.03759775f, -0.04639354f, -0.06216702f, 0.00831092f, 
    0.02625307f, -0.06086872f, 0.00624958f, 0.01738699f, -0.00036202f, -0.01346618f, -0.02377253f, -0.00141134f, 
    -0.06076374f, -0.04372059f, -0.00628221f, 0.01120630f, 0.03042537f, -0.03183841f, 0.01778472f, 0.04277760f, 
    -0.01948895f, 0.04652825f, 0.01927023f, 0.03228120f, 0.00503337f, 0.03831642f, 0.00920397f, -0.06181829f, 
    -0.02843124f, 0.04412534f, -0.03270844f, 0.04507625f, 0.04387335f, -0.03375612f, -0.06552964f, -0.06401520f, 
    0.00903230f, -0.05997309f, -0.01883581f, 0.01395611f, 0.01032746f, 0.02036238f, -0.05900326f, 0.04659360f, 
    0.04265533f, -0.05381844f, -0.06603640f, -0.03410740f, -0.02310252f, 0.01608970f, 0.01996457f, 0.02791055f, 
    -0.03737450f, -0.00986520f, -0.00026892f, -0.02069019f, 0.01501286f, -0.01013698f, -0.03631002f, -0.05164794f, 
    -0.00080690f, 0.03938202f, 0.01015289f, 0.04463344f, -0.00165967f, 0.02804633f, -0.04443658f, 0.04711751f, 
    -0.04227555f, 0.01956261f, -0.01130960f, -0.04005557f, 0.01404892f, -0.03659926f, -0.04545305f, -0.01867179f, 
    -0.01415635f, -0.01604923f, -0.05672091f, 0.03294901f, 0.03969917f, -0.00168976f, -0.01548034f, -0.01116637f, 
    -0.01649524f, -0.04734477f, 0.01559204f, 0.02582805f, 0.04507671f, -0.01293396f, 0.04411947f, -0.03151710f, 
    -0.04885769f, -0.01564007f, 0.03554212f, -0.05279982f, -0.05604252f, -0.05765703f, 0.03518365f, -0.00231180f, 
    0.01849022f, 0.01661630f, -0.04260984f, -0.00830474f, 0.02510903f, 0.04567319f, -0.02681110f, -0.02259137f, 
    -0.05611336f, 0.03198329f, -0.01709043f, -0.04553750f, 0.00971336f, -0.04947412f, -0.06643759f, 0.04732631f, 
    -0.03014367f, 0.03868139f, -0.06210672f, -0.06539513f, -0.06313398f, 0.03270841f, 0.04955192f, -0.01781355f, 
    -0.04085197f, 0.00804243f, -0.05862405f, -0.03243017f, 0.00720534f, -0.02341917f, 0.03028010f, 0.03968388f, 
    -0.06430234f, -0.02131419f, -0.00124837f, -0.02295096f, -0.05833868f, -0.00639082f, 0.02797151f, -0.04343250f, 
    0.02090501f, 0.04458201f, -0.05854771f, -0.01809856f, -0.01840881f, 0.01522916f, -0.01851665f, -0.02317333f, 
    0.01235110f, 0.04868665f, -0.03707663f, 0.04663789f, -0.04146649f, -0.00224915f, 0.04593519f, -0.02713868f, 
    -0.05347879f, -0.02627844f, -0.06098162f, 0.04289685f, -0.05009797f, 0.02122047f, -0.03866041f, -0.03068875f, 
    -0.02464295f, 0.04083391f, -0.04807859f, -0.03896469f, 0.02568744f, 0.01352220f, 0.04736010f, 0.05481916f, 
    -0.01910205f, -0.03005721f, -0.01914974f, 0.00419238f, -0.00016851f, -0.01203372f, 0.03263473f, -0.04112559f, 
    0.02647009f, 0.00923627f, 0.00367060f, 0.00593079f, -0.02071145f, -0.03652040f, -0.00076816f, 0.00698943f, 
    0.04844254f, -0.05878498f, 0.00308911f, -0.00361781f, 0.03667124f, -0.03701834f, -0.00056156f, 0.00591092f, 
    0.04905877f, -0.04882627f, -0.05983102f, -0.05134079f, 0.02614722f, -0.04705384f, 0.02894069f, 0.00859016f, 
    -0.00977369f, -0.02935996f, -0.03811051f, 0.04081643f, 0.03041348f, 0.02731751f, -0.06123576f, 0.02708204f, 
    0.03670229f, 0.02017624f, -0.04788885f, 0.04389631f, -0.01183861f, 0.00566259f, -0.00490239f, 0.02627147f, 
    -0.01924581f, -0.05182986f, 0.03325576f, -0.00537348f, -0.02979545f, -0.05503628f, -0.05400612f, 0.01608349f, 
    -0.03707918f, 0.04583510f, -0.03856057f, -0.04883185f, -0.01376991f, 0.00636123f, -0.01183298f, -0.01052995f, 
    -0.00511341f, -0.03622786f, -0.01035937f, 0.03565012f, -0.04058303f, -0.00155779f, -0.04149712f, -0.05760612f, 
    0.04182677f, -0.04915667f, -0.01152775f, -0.00715661f, -0.03892322f, -0.04217730f, -0.04733298f, 0.00297768f, 
    -0.03861326f, -0.04305462f, -0.03098499f, 0.03413009f, 0.00633561f, -0.05111716f, -0.02828077f, 0.00168293f, 
    -0.01607275f, 0.00870555f, -0.01434464f, -0.00090308f, 0.01952279f, 0.05087496f, 0.01429116f, -0.03446834f, 
    0.04221400f, 0.03919362f, -0.02568741f, 0.01862191f, -0.05502052f, 0.00946425f, 0.05019722f, -0.01366452f, 
    0.00313919f, -0.01139074f, -0.05061862f, -0.00475305f, -0.03270771f, 0.02011170f, 0.03088421f, -0.02735169f, 
    0.03584417f, -0.03630083f, 0.04363837f, -0.06197233f, -0.01106468f, 0.03298236f, -0.03441961f, -0.04221875f, 
    -0.03149056f, -0.01700141f, -0.00229801f, -0.05035860f, 0.01193949f, -0.00701319f, -0.05950661f, 0.00015664f, 
    0.02761755f, -0.03366448f, 0.04593657f, -0.02720696f, 0.04239077f, 0.04481300f, -0.02778240f, 0.04956171f, 
    0.00413740f, 0.00955211f, -0.00369597f, -0.03357957f, -0.03361925f, -0.02737035f, -0.03435815f, -0.05710575f, 
    0.04912730f, -0.04646033f, 0.01747446f, -0.00890306f, -0.02251741f, -0.04569086f, 0.02486993f, 0.00694430f, 
    -0.03402787f, 0.03900917f, -0.04527080f, 0.02126117f, -0.02281864f, -0.01299114f, 0.02956825f, -0.02121250f, 
    0.02901312f, -0.06085676f, 0.05200650f, -0.02614222f, -0.03739101f, 0.01021819f, -0.01861441f, 0.01265556f, 
    -0.02703624f, -0.03479443f, -0.01008016f, 0.04220771f, -0.05228187f, -0.01651910f, -0.03433501f, -0.01046694f, 
    0.05271998f, 0.05161723f, -0.04003706f, -0.03034926f, -0.01315755f, -0.04078059f, 0.03367105f, 0.00531971f, 
    0.02831465f, -0.01859996f, 0.01194393f, -0.05198275f, -0.01889305f, -0.06688964f, 0.04751349f, -0.00168321f, 
    0.00244360f, -0.03379492f, 0.04155624f, 0.00479978f, 0.03296749f, 0.01207235f, -0.03635367f, -0.03554329f, 
    0.01152855f, -0.02283903f, 0.04406975f, 0.01129123f, -0.04503835f, 0.03870121f, 0.00688260f, 0.01309430f, 
    -0.06311170f, -0.03910508f, -0.04151398f, 0.01454496f, -0.04154869f, -0.01421055f, -0.01538477f, -0.04041429f, 
    0.02735197f, 0.03211812f, -0.01652273f, -0.03457680f, -0.01348959f, 0.03841399f, 0.04123932f, 0.01968149f, 
    0.01993711f, -0.03775368f, 0.02957814f, 0.04922162f, -0.04585042f, 0.03384294f, -0.03784857f, -0.05536583f, 
    -0.05858106f, 0.01576158f, -0.06019971f, -0.02982800f, -0.00701579f, 0.01822573f, -0.05101940f, -0.04262130f, 
    -0.01521650f, 0.01287203f, 0.03658224f, 0.01092086f, 0.04499044f, -0.02468033f, 0.00712151f, -0.05302417f, 
    0.03556333f, 0.00556780f, 0.00109619f, -0.00466224f, 0.03222037f, 0.05033645f, 0.00130515f, -0.04344790f, 
    -0.00367996f, -0.05195122f, -0.01999098f, -0.05014242f, -0.02612132f, -0.04014270f, -0.02017273f, -0.06071889f, 
    0.03807577f, 0.19384983f, 0.21372098f, -0.00596938f, 0.03368193f, 0.09197497f, 0.15780483f, -0.08683130f, 
    0.05328932f, -0.12102613f, -0.02971312f, 0.08720542f, -0.08988810f, -0.07108080f, 0.10137513f, -0.13169526f, 
    0.03972839f, 0.00370428f, 0.11059397f, 0.10700638f, 0.01571213f, -0.01290583f, 0.08988474f, 0.04688355f, 
    0.02366761f, 0.05928355f, 0.05547700f, 0.08341266f, -0.00775884f, -0.00707370f, -0.17239144f, 0.10205366f, 
    -0.06738072f, -0.02634400f, -0.19873269f, 0.10208797f, -0.15884350f, -0.04763601f, -0.03792873f, -0.00833691f, 
    0.00032318f, -0.05734938f, -0.07820182f, 0.04651837f, 0.10914774f, -0.01465376f, 0.07042380f, -0.02936132f, 
    -0.04847836f, 0.10361983f, -0.10700051f, 0.16602968f, -0.03357685f, 0.01179434f, -0.16203621f, -0.16446652f, 
    0.19985354f, 0.08670583f, -0.05597278f, -0.05474640f, 0.09434017f, -0.09526824f, 0.04669401f, -0.02686406f, 
    -0.14937618f, -0.19677764f, 0.04494378f, -0.08765293f, -0.10257571f, 0.00571815f, -0.06334161f, 0.07546034f, 
    0.05199316f, -0.16874045f, -0.17616645f, -0.08262761f, -0.08315803f, -0.03048726f, 0.00805795f, -0.15900575f, 
    -0.03405174f, -0.12206902f, -0.19688101f, -0.23324472f, -0.00481968f, 0.02649485f, -0.07541637f, -0.08323839f, 
    0.08451889f, -0.07779103f, 0.03864989f, 0.15510856f, 0.09477055f, 0.03982851f, 0.07800148f, 0.06385813f, 
    -0.00830796f, -0.01180930f, 0.02813879f, -0.02197189f, 0.08437066f, -0.36520773f, 0.05697661f, 0.10899831f, 
    -0.00444751f, -0.03495567f, 0.05730310f, -0.12589669f, -0.30141279f, -0.19355051f, -0.18281163f, 0.07966272f, 
    0.12239078f, 0.04514991f, -0.02495601f, -0.03811374f, 0.08239438f, 0.17764468f, 0.01538044f, 0.01788157f, 
    0.05061740f, 0.04025503f, 0.02358006f, 0.01275736f, -0.07942984f, 0.05752045f, -0.14070331f, -0.11047642f, 
    -0.24561347f, -0.01857563f, -0.07207899f, -0.00456425f, -0.12244863f, 0.13067517f, 0.06510358f, -0.13904703f, 
    -0.01824929f, 0.07828763f, 0.12316698f, -0.02208921f, 0.01928030f, -0.04975745f, -0.03852355f, 0.01446183f, 
    -0.10470362f, -0.16483307f, -0.16586009f, 0.07432916f, 0.04520113f, 0.08985796f, -0.08626062f, -0.06058847f, 
    -0.05003668f, 0.02337288f, -0.01053059f, -0.00361206f, 0.06460561f, 0.02907079f, 0.08776738f, 0.08147867f, 
    -0.02807100f, 0.08601608f, 0.00206709f, 0.14117160f, 0.28339571f, 0.14851993f, 0.17812197f, 0.03692536f, 
    0.05557308f, 0.08065540f, 0.04501187f, 0.02212264f, 0.07393988f, 0.18570285f, 0.04073252f, 0.09179551f, 
    -0.04583188f, 0.06679496f, -0.00397917f, 0.08398104f, -0.05563039f, -0.06436442f, -0.13286708f, 0.08470684f, 
    -0.05250268f, 0.00172632f, 0.03570086f, 0.00713237f, 0.11014418f, -0.15826923f, -0.21126409f, -0.12322956f, 
    0.05354854f, 0.10097287f, -0.05422316f, 0.02292532f, 0.07403455f, 0.05244104f, -0.01004019f, 0.00215639f, 
    -0.18677485f, 0.13638252f, 0.01485109f, -0.06271232f, 0.07778462f, 0.17464840f, -0.06617461f, -0.24453937f, 
    -0.17794330f, -0.34438145f, 0.05565119f, -0.05810577f, -0.08062436f, 0.14479275f, -0.03266973f, -0.25166932f, 
    -0.01084400f, 0.25424740f, 0.19118628f, 0.11718574f, -0.00974001f, 0.01436616f, 0.02910765f, 0.06342278f, 
    0.05407487f, -0.04208890f, -0.19576569f, -0.16943300f, 0.01999155f, 0.09710830f, 0.05892923f, 0.04486636f, 
    -0.04380159f, -0.02213106f, 0.03094308f, 0.09768324f, 0.08051006f, -0.05359493f, 0.00065534f, -0.04061854f, 
    0.02087889f, -0.05302989f, 0.15365230f, -0.04868288f, -0.12392713f, 0.18413785f, -0.07424850f, -0.03777521f, 
    -0.04291756f, -0.02333559f, -0.05428150f, 0.01699129f, 0.05967698f, 0.05316538f, -0.24996334f, 0.09902552f, 
    0.04150032f, 0.03689201f, -0.08890296f, 0.02477803f, -0.01295866f, -0.16396081f, -0.10687095f, 0.04058791f, 
    0.03543669f, 0.02998697f, -0.03117920f, 0.03059680f, 0.08678563f, -0.08543962f, -0.02831540f, 0.08689651f, 
    -0.06300440f, 0.15193091f, 0.06958541f, 0.06531362f, 0.07302795f, -0.06697601f, 0.03544330f, -0.09135439f, 
    0.13071911f, 0.15936519f, 0.14283536f, 0.12384892f, -0.06601085f, 0.04852484f, -0.04840095f, 0.06706640f, 
    0.15478927f, 0.03100968f, -0.03963194f, -0.04268274f, -0.03145950f, 0.04196551f, -0.11730401f, 0.13386284f, 
    0.07397380f, -0.22252047f, -0.22958368f, -0.11342565f, 0.19360885f, 0.11126208f, -0.03026684f, -0.02289378f, 
    -0.07349201f, 0.01005832f, 0.14946418f, 0.06116563f, 0.03474821f, 0.03622412f, -0.05596403f, 0.02812232f, 
    -0.04604716f, 0.09165661f, 0.11889242f, 0.30950537f, 0.06425601f, -0.09437239f, 0.00688207f, -0.15600096f, 
    -0.23904429f, -0.03506842f, -0.05719293f, 0.11524470f, -0.03405209f, 0.13265067f, -0.01843876f, 0.07126644f, 
    -0.07561827f, -0.05023539f, 0.02370705f, -0.01237913f, -0.09005660f, -0.10565718f, -0.16581205f, 0.08554541f, 
    -0.04229216f, 0.10248988f, 0.12741075f, -0.00245772f, -0.09592289f, 0.02870552f, -0.17569646f, 0.12144317f, 
    -0.04412590f, 0.09635349f, 0.09797534f, 0.08220214f, -0.13736704f, 0.01684109f, -0.04307397f, -0.22495307f, 
    -0.08488344f, 0.10811882f, 0.01046773f, -0.00623817f, 0.02636874f, 0.00891630f, 0.04240140f, 0.01519983f, 
    0.50916839f, 0.03776656f, 0.10188299f, 0.12381050f, -0.05245318f, 0.06405871f, 0.09617427f, -0.02049713f, 
    -0.02162982f, 0.12280153f, 0.13274652f, 0.09816557f, -0.04562198f, 0.10812825f, -0.09839355f, 0.07350663f, 
    0.03722643f, -0.03139545f, 0.17552400f, -0.17488819f, 0.03091878f, 0.05567965f, -0.30326200f, 0.08266339f, 
    0.11396686f, -0.02021278f, 0.16031767f, -0.19151151f, -0.08017571f, -0.02587199f, -0.01427117f, 0.12515040f, 
    0.01646671f, 0.04937395f, -0.00388176f, -0.07034009f, 0.06989429f, -0.08818060f, -0.11951841f, 0.05092682f, 
    -0.04945899f, -0.09257806f, 0.04077191f, -0.09475680f, -0.02437421f, -0.01212050f, 0.11501332f, 0.03454816f, 
    0.07110369f, -0.09888956f, -0.10742360f, 0.02426652f, 0.01284766f, 0.00616981f, -0.22447619f, 0.10591868f, 
    -0.07405967f, -0.03357130f, 0.07718910f, 0.06531543f, -0.19242866f, -0.04377174f, -0.03886301f, 0.13661274f, 
    -0.13554764f, -0.17330717f, -0.02008933f, -0.12710537f, -0.08828611f, 0.06732059f, -0.01079127f, 0.07570214f, 
    0.00086591f, 0.07427450f, -0.13773537f, 0.06696603f, -0.06407398f, 0.04239980f, 0.15144116f, 0.02241427f, 
    -0.03695921f, -0.19240624f, 0.05553618f, 0.03128717f, 0.07382262f, -0.05736827f, -0.20173424f, 0.06667530f, 
    0.07706650f, 0.07944003f, 0.07823020f, 0.02565758f, 0.13361488f, 0.15169795f, -0.08933046f, -0.16190304f, 
    -0.02092777f, 0.05621327f, -0.03262311f, 0.18377304f, -0.03740482f, 0.05312845f, 0.00150268f, -0.07089549f, 
    0.07808024f, 0.08760643f, 0.01494403f, 0.06732371f, -0.11791641f, -0.04459941f, -0.02686866f, 0.12806058f, 
    0.13702419f, 0.02672014f, -0.04874752f, 0.00878390f, 0.10863433f, 0.20045109f, -0.13727011f, -0.17501453f, 
    0.12275332f, -0.00221488f, -0.10865664f, 0.07195804f, -0.08595818f, -0.08061122f, -0.04197187f, -0.06925152f, 
    0.01866457f, -0.08456779f, 0.00800628f, -0.00424412f, -0.02311755f, 0.08114238f, -0.07006815f, -0.18692540f, 
    -0.05219347f, -0.10484197f, 0.09431718f, 0.01722649f, -0.06539978f, 0.05280719f, 0.12447833f, -0.08753940f, 
    0.02126779f, -0.12168894f, 0.01381265f, 0.02705495f, -0.05485135f, 0.03267571f, -0.08378809f, 0.09670918f, 
    0.07715914f, -0.04156448f, 0.08630036f, -0.05897874f, 0.09565878f, 0.10695583f, -0.03778948f, -0.01987246f, 
    -0.04102255f, 0.06502567f, 0.07780180f, -0.11394452f, -0.02205115f, 0.00987080f, 0.04746487f, 0.02025403f, 
    -0.07119270f, 0.00076168f, -0.16256125f, -0.00914351f, -0.07800927f, -0.15689515f, 0.12565804f, 0.04909634f, 
    0.07746473f, 0.04736246f, -0.04524186f, 0.01232232f, -0.15108578f, 0.05544274f, -0.05296033f, 0.04497273f, 
    0.02660346f, 0.00541478f, 0.01594453f, 0.00442802f, -0.20133412f, -0.07459194f, -0.03057950f, -0.18325238f, 
    -0.01464291f, 0.00462396f, 0.07069078f, -0.05834913f, 0.11529116f, 0.11159291f, -0.07729659f, -0.04523880f, 
    -0.01951288f, -0.02143671f, -0.02076440f, -0.00664793f, -0.11515818f, -0.02945999f, 0.06887417f, 0.09425254f, 
    0.12636857f, 0.06398874f, -0.03283649f, -0.17857394f, -0.02651882f, 0.03384700f, 0.08563969f, 0.11867867f, 
    -0.01026409f, -0.04914984f, -0.21819855f, 0.08044719f, -0.13314117f, 0.14182830f, -0.15333542f, -0.06961597f, 
    0.02815910f, 0.06355529f, -0.17673069f, -0.27744177f, 0.07681746f, -0.00215764f, 0.01182860f, 0.00950316f, 
    -0.08056787f, 0.12870190f, -0.01283172f, 0.04152792f, -0.02071752f, 0.07546797f, -0.07758673f, 0.02764506f, 
    0.02863911f, 0.06102132f, 0.14703657f, -0.04806283f, 0.21663348f, -0.01363002f, 0.05600670f, 0.12630016f, 
    0.10057989f, -0.03863110f, 0.04055718f, -0.01636820f, 0.15081576f, -0.16095290f, -0.14579631f, 0.05515739f, 
    0.15559106f, -0.01224644f, 0.04379740f, 0.23767705f, 0.01363708f, -0.01953592f, -0.02381427f, -0.26629555f, 
    0.04777265f, 0.04981298f, 0.09918818f, -0.00667063f, -0.09366108f, -0.04357674f, -0.16014779f, -0.61863965f, 
    -0.08348040f, -0.01753743f, -0.02857609f, -0.00481868f, -0.14430553f, -0.11488561f, -0.07385956f, -0.29950631f, 
    -0.27283204f, -0.04331279f, -0.12894706f, 0.14764106f, -0.07326768f, 0.05370069f, 0.11835478f, -0.20398881f, 
    -0.02166287f, -0.12791795f, 0.21474956f, 0.02247793f, 0.19325364f, 0.00057973f, -0.01271603f, -0.11759951f, 
    -0.09811668f, -0.23793264f, 0.29752654f, -0.16859710f, 0.07858998f, -0.07443681f, 0.00899267f, 0.02181190f, 
    -0.11064117f, 0.01235651f, -0.09898084f, -0.15114093f, 0.11811174f, -0.03003458f, 0.07243406f, 0.00064562f, 
    0.00929149f, 0.06774171f, -0.08529650f, -0.03515872f, -0.27064115f, -0.10019267f, -0.02532092f, 0.09918669f, 
    0.10336927f, 0.05136348f, 0.02212597f, -0.14694117f, 0.26758397f, 0.22873291f, -0.32808092f, -0.00622805f, 
    -0.06590120f, 0.07014924f, -0.00344200f, -0.01570370f, -0.01111075f, -0.04963622f, 0.11825034f, 0.16821258f, 
    -0.06367516f, 0.17874056f, -0.01624778f, -0.02799416f, 0.12108447f, -0.11360106f, -0.18309495f, -0.12567672f, 
    0.03582396f, 0.12315087f, -0.09592563f, 0.06467085f, 0.04082708f, -0.00237176f, 0.08611289f, 0.19415721f, 
    -0.12815779f, -0.23983876f, -0.07422400f, 0.04711249f, -0.01434452f, 0.00695254f, 0.16607633f, 0.00008199f, 
    -0.03464091f, 0.26803985f, -0.11925980f, 0.18432401f, 0.14193520f, -0.12300314f, -0.01153609f, 0.11449137f, 
    -0.06836602f, -0.04215638f, 0.05562727f, 0.05113205f, 0.09253692f, -0.12829837f, 0.07439982f, 0.02954605f, 
    -0.06466423f, 0.07021543f, -0.02454405f, 0.08723950f, 0.07238501f, 0.03697724f, 0.06286474f, 0.00212871f, 
    -0.05509662f, -0.04214268f, 0.13732454f, 0.12514615f, 0.10206859f, 0.01352226f, 0.04647036f, -0.04330381f, 
    0.09379155f, -0.08117168f, 0.05868240f, 0.00814124f, -0.21105023f, -0.03963530f, 0.21281120f, 0.08315806f, 
    0.07757279f, 0.06278944f, 0.06813218f, 0.04180561f, 0.01955516f, 0.31529582f, 0.04863241f, -0.24812827f, 
    0.06692864f, 0.04721751f, 0.01301315f, 0.11355399f, 0.05224868f, -0.13223255f, 0.01218402f, 0.09500238f, 
    -0.11069338f, 0.01788818f, -0.00783233f, -0.01629485f, 0.02488306f, -0.00165518f, 0.07692123f, -0.10138901f, 
    -0.10948142f, -0.11389824f, 0.01550006f, -0.06410103f, -0.01190533f, 0.01163340f, -0.08927805f, 0.02112831f, 
    0.02454277f, 0.10900566f, -0.08276762f, -0.06049635f, 0.07951640f, 0.05264177f, -0.03424355f, 0.06657410f, 
    -0.17509231f, -0.20243029f, 0.14161533f, 0.04079298f, -0.01339851f, -0.09201752f, 0.07031344f, 0.18985781f, 
    -0.08503013f, -0.07944730f, -0.36199665f, 0.04602479f, -0.16994219f, 0.07135149f, -0.03127821f, -0.04742689f, 
    0.08085893f, -0.00231563f, 0.08704542f, 0.07590637f, -0.18535168f, -0.22643374f, -0.00369114f, 0.05981022f, 
    -0.10855104f, 0.04559966f, 0.08836310f, 0.09318795f, -0.21438849f, 0.03337328f, 0.16669609f, -0.05645202f, 
    0.01166612f, 0.09810931f, -0.00408888f, -0.03987543f, 0.03466679f, -0.10157261f, -0.08525591f, 0.10325267f, 
    -0.11759449f, -0.02090780f, -0.02975142f, 0.04443355f, 0.09414137f, 0.00941811f, 0.23345685f, -0.07330555f, 
    -0.12309263f, 0.00288517f, 0.00120115f, 0.04041649f, 0.05286921f, -0.03688405f, -0.05855238f, -0.13169655f, 
    0.08619312f, -0.03835265f, 0.13765807f, -0.03388326f, 0.15240510f, -0.14038099f, 0.01320790f, -0.12514959f, 
    -0.06648904f, -0.09307018f, -0.03821724f, -0.19298582f, -0.03859444f, -0.03350990f, -0.05516173f, 0.00815023f, 
    0.03427133f, -0.16305894f, -0.24891342f, -0.01967362f, 0.08498070f, -0.12953342f, 0.08717823f, -0.06329783f, 
    -0.04947026f, 0.07476602f, -0.33785334f, 0.12886305f, -0.09336106f, -0.01269264f, 0.00418421f, -0.03312853f, 
    -0.00631396f, -0.11236325f, -0.02278605f, 0.45762739f, -0.19335924f, -0.10791308f, -0.00095951f, -0.08913283f, 
    0.05625354f, -0.02155356f, 0.13368824f, -0.07285719f, 0.16817056f, 0.01467144f, 0.16690578f, 0.02386645f, 
    -0.00483435f, 0.09127444f, 0.13591567f, 0.01533352f, -0.06069221f, -0.11851933f, 0.00675102f, 0.07563023f, 
    -0.09820618f, 0.06091829f, -0.03410659f, 0.05217365f, -0.08454537f, -0.00068313f, -0.26974541f, 0.10156354f, 
    -0.00206706f, -0.13205938f, 0.02469931f, -0.08266391f, -0.09078253f, -0.05819460f, 0.03536534f, -0.10735632f, 
    0.17429708f, -0.02044486f, -0.16488808f, -0.00400111f, -0.02951424f, 0.14905062f, -0.19823043f, -0.06324913f, 
    0.47924608f, -0.23049824f, -0.15386854f, -0.08134976f, -0.03550118f, 0.00522951f, 0.02025882f, -0.08148065f, 
    -0.07873397f, -0.05880877f, 0.04179272f, -0.08574554f, 0.19609307f, -0.13856043f, -0.03796888f, 0.09271425f, 
    0.13063042f, 0.06229519f, 0.22186378f, 0.14606832f, -0.10055068f, -0.07166070f, 0.01432799f, 0.05679186f, 
    0.01778884f, 0.01528635f, 0.06575888f, -0.21947107f, 0.11210262f, 0.16634499f, 0.09182454f, -0.08400387f, 
    0.17508794f, -0.06705611f, 0.03263598f, -0.01033545f, -0.08053493f, -0.05249385f, 0.01022869f, 0.19271058f, 
    0.20633532f, 0.06961123f, -0.00614603f, -0.10565147f, -0.01570150f, 0.12651435f, 0.11914641f, -0.03186319f, 
    -0.08348135f, -0.02744520f, -0.08736271f, 0.11535671f, -0.04864724f, 0.01552353f, 0.08958197f, -0.03683795f, 
    0.11893513f, 0.02677631f, -0.13474475f, 0.03258605f, -0.00764237f, 0.00285166f, -0.12775078f, -0.02107007f, 
    0.02366727f, 0.09800532f, 0.05348818f, 0.11146051f, -0.00197756f, 0.01616669f, 0.01706483f, 0.02385889f, 
    0.03774205f, 0.07731580f, -0.02774382f, 0.06520801f, 0.08413178f, 0.14116243f, 0.06827010f, -0.00393871f, 
    -0.06141612f, 0.12640037f, 0.20769338f, 0.03361929f, -0.33476636f, 0.01119287f, -0.21197653f, 0.08555645f, 
    -0.03907890f, 0.12239427f, -0.27588618f, 0.00259167f, -0.01067136f, 0.02341841f, 0.06145684f, 0.10685496f, 
    0.10631386f, 0.05065443f, -0.00256878f, -0.29037577f, 0.22746061f, 0.23815319f, -0.24309173f, -0.22807062f, 
    -0.28406915f, -0.05399356f, -0.00763356f, -0.12656458f, 0.27798650f, 0.07222518f, 0.04701788f, -0.17254879f, 
    -0.07759824f, -0.09810943f, -0.05552553f, 0.07828812f, -0.03916465f, -0.00796601f, 0.17491522f, 0.07332667f, 
    0.14207576f, 0.05561307f, -0.01662017f, -0.04683826f, 0.08727594f, 0.03245758f, -0.04231644f, 0.13406855f, 
    0.14561440f, 0.29257438f, -0.02177010f, 0.00512989f, 0.11241198f, 0.00908932f, -0.08096191f, -0.32571858f, 
    -0.16778016f, 0.04129348f, 0.16955887f, 0.00743204f, 0.04287702f, 0.11718918f, 0.15451540f, 0.03136078f, 
    -0.07675926f, 0.02559106f, 0.19606149f, 0.04200061f, -0.05752041f, -0.12339345f, 0.03071731f, 0.05391440f, 
    -0.05879604f, 0.03943451f, -0.22360829f, -0.05562349f, 0.06624101f, 0.08750817f, 0.04564475f, -0.08128718f, 
    0.13780263f, 0.08467718f, 0.18789682f, -0.11139943f, -0.14163989f, -0.14087045f, 0.05885570f, -0.05834915f, 
    0.11852784f, -0.05713818f, -0.11353163f, 0.00014900f, -0.17569822f, 0.07771450f, 0.11368422f, 0.02521247f, 
    0.17592500f, -0.02937421f, -0.11122215f, 0.10432088f, 0.02717801f, 0.01072095f, -0.02436624f, 0.04609204f, 
    0.08948183f, -0.04338473f, 0.01323828f, -0.06241828f, -0.05795782f, -0.13423902f, -0.07540929f, -0.12843962f, 
    -0.18112823f, 0.14024763f, 0.06813743f, 0.16359417f, -0.04155020f, -0.00073323f, -0.08048631f, -0.10680712f, 
    0.00407924f, 0.09811275f, 0.06170741f, 0.04473437f, 0.01036965f, -0.16233201f, -0.00620364f, 0.01744508f, 
    -0.00977689f, 0.22723272f, -0.08325577f, -0.04852515f, 0.03119300f, -0.00654770f, 0.00278228f, -0.07000936f, 
    -0.16061507f, -0.03223252f, 0.02974120f, 0.06226787f, -0.17783973f, 0.17696314f, 0.17987858f, 0.05933814f, 
    0.14920698f, 0.15734129f, -0.19658512f, 0.02375834f, -0.02403935f, -0.09892787f, -0.12328246f, 0.12814851f, 
    -0.00910502f, -0.06423336f, -0.07579768f, -0.00004441f, 0.17066430f, 0.09882691f, 0.02500753f, 0.05390593f, 
    0.14450034f, -0.09648704f, 0.04705056f, -0.35357389f, -0.04926443f, -0.06670210f, 0.11091949f, 0.06860610f, 
    0.07468463f, -0.18193080f, 0.00243125f, -0.02168264f, 0.15298927f, -0.15820871f, 0.04241790f, 0.10624787f, 
    0.08918078f, 0.14257123f, -0.02839126f, 0.13056034f, -0.09435017f, -0.07946096f, -0.15335767f, 0.11104304f, 
    -0.11881268f, -0.16557992f, -0.03786410f, 0.06087390f, -0.04331593f, -0.19075161f, -0.04257613f, -0.26660794f, 
    0.02766006f, -0.11060272f, 0.09097613f, -0.00151411f, 0.05988504f, -0.08908853f, -0.00684858f, -0.12096038f, 
    -0.19394147f, 0.05028705f, 0.09278422f, -0.10917936f, -0.06000239f, -0.08155498f, 0.11780521f, -0.05294556f, 
    -0.29188091f, -0.12980731f, -0.00449063f, 0.25687912f, -0.06998339f, 0.04830654f, 0.02001730f, -0.08705754f, 
    -0.09518249f, -0.14406924f, 0.22326629f, -0.10065161f, 0.02040672f, 0.00586100f, 0.08042710f, -0.10693479f, 
    0.04310041f, -0.04490724f, -0.25113428f, -0.15523440f, -0.02041088f, 0.15895304f, 0.05861566f, 0.03375761f, 
    -0.00948999f, 0.02669596f, -0.03666441f, -0.10090588f, 0.02948709f, 0.01827108f, -0.12136382f, -0.00078016f, 
    -0.03214828f, 0.03552907f, 0.04515440f, -0.14785495f, 0.11694031f, 0.01876936f, 0.13098837f, 0.10820571f, 
    0.03663562f, -0.21938944f, -0.04619270f, -0.06959231f, 0.11050904f, -0.03045092f, 0.00019737f, 0.02859099f, 
    0.23136693f, 0.10212041f, -0.02090432f, -0.06816157f, -0.10930796f, 0.04521848f, 0.10269769f, -0.04228549f, 
    -0.05906946f, -0.05338147f, -0.12069102f, 0.04823710f, 0.04503120f, -0.00876518f, -0.10806224f, -0.04438194f, 
    0.01895549f, 0.13146608f, 0.14325513f, 0.01001616f, -0.26476842f, -0.05658996f, 0.04091341f, 0.07609425f, 
    0.06508218f, -0.06253954f, 0.04156723f, 0.02905066f, 0.09118006f, 0.04117684f, -0.03906570f, 0.14383578f, 
    -0.13236062f, -0.06089337f, -0.05260418f, 0.12002377f, -0.03593767f, -0.01625338f, -0.01990253f, 0.00435032f, 
    -0.05493387f, 0.00371691f, 0.05501017f, 0.07291419f, 0.07092668f, 0.14796697f, 0.04985945f, 0.16646396f, 
    0.07062150f, 0.06216501f, 0.15193717f, 0.12737641f, -0.10446646f, -0.03077175f, 0.05894772f, -0.04996328f, 
    0.15859361f, 0.05774663f, -0.02936154f, -0.00051241f, 0.01033806f, -0.08111735f, -0.04805399f, -0.13629422f, 
    -0.23947556f, 0.05171336f, 0.04996753f, 0.02161925f, 0.03423703f, 0.04422010f, 0.06402593f, 0.10890827f, 
    0.15641211f, 0.03884119f, -0.03861155f, -0.11952633f, 0.01891063f, -0.00566595f, 0.05229149f, 0.08988799f, 
    0.02879028f, -0.17619473f, 0.08827014f, 0.01952525f, -0.00403563f, -0.04395511f, -0.04964179f, 0.07653431f, 
    0.15374455f, -0.06983504f, -0.19777299f, 0.01244381f, 0.05670065f, 0.13264659f, -0.03368969f, -0.09211645f, 
    0.01664643f, 0.06934154f, -0.08357082f, 0.04936304f, -0.02140466f, 0.01413938f, -0.03280821f, 0.04519009f, 
    0.01478199f, -0.03235773f, -0.01737528f, 0.01340527f, 0.00525139f, 0.05796688f, 0.02926706f, 0.06198880f, 
    -0.06344838f, 0.08823158f, -0.15383805f, 0.03376410f, 0.16642040f, 0.03337221f, -0.14020315f, 0.03476076f, 
    0.12840226f, 0.05694375f, 0.15304203f, 0.09883464f, -0.07315848f, 0.03489769f, -0.12734514f, 0.08106861f, 
    -0.03836824f, -0.15460870f, 0.10607340f, -0.07137990f, 0.18055812f, -0.07353827f, -0.02700812f, -0.03947650f, 
    -0.04714206f, 0.19358803f, -0.00262805f, 0.00409556f, -0.06209615f, 0.08318297f, -0.01857982f, 0.06079824f, 
    0.23922433f, 0.13347816f, -0.06222940f, 0.10834052f, 0.00443492f, 0.16276072f, -0.19128452f, 0.14385606f, 
    -0.03815749f, 0.08493336f, -0.11223442f, -0.03924786f, 0.10593713f, -0.04172996f, 0.01620149f, 0.01410419f, 
    0.02636053f, -0.10242590f, 0.07529423f, 0.13720120f, -0.06382199f, -0.05275927f, -0.03683436f, -0.02214489f, 
    0.05551720f, -0.00452586f, 0.02255165f, -0.02976909f, -0.01623687f, -0.03717214f, -0.05548983f, -0.05609867f, 
    -0.03611178f, -0.02116863f, -0.04440812f, -0.04199207f, 0.01810553f, 0.03954007f, 0.02008721f, 0.02013577f, 
    0.02670837f, 0.02090338f, 0.03971712f, 0.03740362f, 0.05196752f, -0.05451608f, 0.05138792f, 0.03328485f, 
    0.00279261f, 0.01734812f, -0.04313608f, -0.02358021f, -0.03775002f, 0.02446770f, -0.01331989f, -0.03775832f, 
    -0.06132263f, -0.04919661f, -0.00028798f, -0.04237654f, 0.03608171f, 0.05010151f, -0.03973976f, -0.02023238f, 
    -0.01543625f, -0.03051502f, -0.00555068f, 0.01275185f, 0.02798820f, -0.00566262f, 0.04782863f, -0.01373477f, 
    -0.01228193f, 0.02612379f, -0.04626742f, -0.05955805f, -0.00058881f, -0.06217365f, 0.00617918f, -0.01514556f, 
    0.01596183f, -0.02971869f, 0.05291037f, -0.04289451f, 0.00934527f, 0.01030555f, 0.03514707f, 0.01174786f, 
    0.02938341f, 0.04028599f, -0.05316128f, -0.02259752f, 0.03565939f, 0.00203003f, 0.03436871f, -0.03335282f, 
    -0.02541772f, 0.02815082f, -0.04220129f, 0.00443910f, 0.01013710f, 0.00335898f, -0.01048090f, -0.00579672f, 
    -0.03566871f, -0.04119450f, -0.02344016f, -0.03349016f, -0.04188612f, -0.04536613f, -0.02919501f, 0.02361759f, 
    -0.00646145f, -0.04947088f, -0.00013541f, 0.03109106f, -0.03505520f, -0.03899275f, 0.02315033f, -0.03492309f, 
    -0.04011111f, 0.04141646f, -0.04749442f, -0.04496158f, 0.01994097f, -0.01606592f, 0.01692903f, 0.02245967f, 
    0.05000882f, -0.03377150f, -0.00896262f, 0.03117659f, -0.04861403f, -0.00225449f, 0.03800543f, 0.03833478f, 
    -0.00198396f, 0.01343236f, 0.05234480f, -0.02137561f, 0.00996677f, 0.00962204f, -0.01399328f, -0.01274850f, 
    0.00042173f, -0.04583915f, -0.05794971f, -0.03586959f, 0.01011184f, -0.03527879f, 0.02295713f, 0.03850324f, 
    -0.02565009f, -0.01727047f, -0.05866075f, 0.05268341f, -0.05519862f, 0.05335970f, 0.00961155f, 0.01911227f, 
    -0.01827035f, -0.02534080f, 0.00155865f, 0.02022392f, 0.01255218f, -0.05723557f, -0.03988132f, 0.01029229f, 
    0.02694465f, -0.01575352f, 0.04209576f, 0.00993767f, -0.02475323f, 0.01809474f, -0.02923328f, -0.01233425f, 
    -0.06340326f, 0.03369246f, -0.03098483f, -0.05109814f, -0.02643481f, -0.00152429f, 0.01205255f, 0.02733560f, 
    0.02374811f, -0.02721673f, 0.04910566f, -0.05908732f, 0.02969978f, 0.05536999f, -0.04887737f, -0.04896537f, 
    -0.00031782f, -0.00142847f, 0.00419373f, -0.02664825f, -0.05979413f, -0.01903852f, 0.03063506f, -0.02776066f, 
    0.00869714f, 0.04121771f, -0.03596188f, 0.00110569f, -0.01630495f, 0.04830849f, -0.04354109f, -0.06008585f, 
    -0.01998816f, -0.02831794f, 0.04637250f, 0.00038776f, -0.00348072f, 0.04789795f, -0.02056474f, 0.00012046f, 
    0.00504601f, 0.00881353f, 0.03625867f, 0.00968176f, -0.02944308f, 0.00037901f, -0.04110648f, 0.01462592f, 
    0.03703362f, -0.04149292f, -0.05097358f, -0.02270340f, -0.05675040f, -0.00651263f, -0.03271922f, 0.00304132f, 
    0.01227635f, 0.00746957f, -0.05178890f, -0.03276417f, 0.01443506f, -0.01025444f, -0.02580530f, -0.01747929f, 
    -0.04626402f, -0.05670829f, -0.05555912f, -0.06214971f, 0.00004241f, 0.05025309f, -0.01398287f, 0.01188294f, 
    -0.03018265f, 0.01847529f, -0.01992925f, 0.01478044f, -0.02164159f, 0.01760757f, 0.05558893f, -0.04087776f, 
    0.00347400f, 0.05154826f, -0.03068106f, 0.05403616f, -0.01123998f, 0.02851791f, 0.01085660f, 0.02135996f, 
    0.05045351f, 0.03917129f, -0.04124045f, -0.02605390f, -0.05293840f, -0.01681528f, -0.05474820f, -0.05574801f, 
    0.01710390f, -0.02726153f, -0.02785092f, 0.03221598f, 0.00404755f, -0.02427143f, -0.06139164f, 0.02121412f, 
    0.00516120f, 0.01405639f, 0.00741502f, -0.06240987f, -0.03596418f, 0.03007742f, -0.02400892f, 0.04288505f, 
    0.00541213f, -0.02624313f, -0.05520574f, -0.03347665f, 0.00290146f, -0.02795792f, -0.03028183f, 0.02925039f, 
    -0.04001199f, 0.03945632f, -0.04768193f, 0.00111640f, 0.04984092f, 0.00832799f, -0.02630124f, 0.04180282f, 
    -0.00774473f, -0.00513440f, -0.02743717f, 0.04086130f, 0.03244815f, -0.01679274f, 0.03885568f, 0.00299085f, 
    -0.22638816f, -0.09274604f, 0.09730221f, -0.01286430f, 0.11201141f, 0.00812468f, 0.05166995f, -0.06717201f, 
    -0.16251037f, 0.31148714f, -0.00758261f, -0.05186050f, -0.11468016f, 0.00043172f, -0.20268439f, 0.07924395f, 
    -0.01148125f, 0.06135573f, 0.04952052f, -0.03632933f, -0.05202152f, -0.08275831f, 0.05025661f, -0.06429931f, 
    -0.05229933f, 0.07710104f, 0.05786662f, -0.03026985f, 0.10680803f, -0.10593795f, 0.11940444f, -0.02786249f, 
    -0.06838889f, 0.04535684f, 0.05306990f, -0.08517141f, 0.06677188f, 0.00490244f, 0.04453324f, 0.05694249f, 
    0.07191899f, 0.11165825f, 0.10061891f, -0.05477859f, 0.06536596f, 0.23845163f, 0.17542149f, -0.05111558f, 
    0.08715491f, 0.01300716f, -0.12142461f, -0.11233082f, 0.07715321f, -0.02708251f, 0.19881628f, 0.05641049f, 
    -0.13942184f, -0.15821350f, -0.12574892f, 0.05647608f, -0.02978493f, -0.02623695f, -0.00857183f, 0.30835369f, 
    0.17365946f, -0.00444023f, -0.04437156f, 0.04789746f, 0.01299865f, -0.09725951f, -0.01074219f, 0.04135930f, 
    0.18805893f, -0.02557156f, -0.12919156f, 0.04722351f, -0.09392011f, -0.10084821f, -0.07315215f, 0.10544105f, 
    -0.10017589f, 0.16820958f, -0.12706718f, -0.10188238f, 0.00363078f, -0.03807328f, -0.00462510f, 0.03239991f, 
    0.01655673f, -0.11962711f, -0.34737393f, 0.14645849f, 0.02967690f, 0.15107231f, 0.04246347f, -0.04370593f, 
    -0.07416578f, 0.07181518f, 0.00642243f, -0.15409173f, 0.21762504f, 0.16950080f, 0.03109604f, -0.05876933f, 
    -0.11217524f, -0.09439249f, -0.10337446f, 0.08268800f, 0.08654310f, -0.03093528f, -0.08888379f, 0.02972703f, 
    0.06553230f, 0.02686879f, 0.08936324f, -0.02377556f, 0.08367375f, 0.07662079f, 0.07298871f, -0.00041069f, 
    0.05601251f, -0.02049721f, 0.06412354f, 0.01058584f, 0.15630832f, -0.00496934f, 0.19999999f, -0.19348358f, 
    -0.02168855f, 0.03645017f, -0.03652479f, -0.07564995f, 0.07484403f, -0.02520769f, 0.04553622f, -0.01589159f, 
    0.10776448f, -0.11763895f, 0.06335882f, -0.00433622f, 0.05256441f, 0.01367077f, -0.05278297f, 0.04360121f, 
    0.20336553f, -0.05512503f, 0.09509660f, -0.01729650f, 0.05466652f, 0.02052060f, 0.00112217f, -0.11198211f, 
    -0.01971867f, 0.06253882f, -0.06640772f, 0.01039368f, 0.12652811f, -0.09380666f, -0.01191704f, 0.00433226f, 
    -0.03584034f, 0.01570270f, -0.39529234f, 0.02883972f, 0.09469002f, 0.00090059f, 0.04612512f, 0.06631168f, 
    0.06258865f, 0.08013884f, -0.10180799f, -0.02188667f, -0.01025982f, 0.01274384f, 0.15791300f, 0.06166132f, 
    -0.06501922f, -0.09521099f, 0.01174545f, 0.04395129f, 0.12823075f, -0.12405118f, 0.03963785f, -0.11664998f, 
    0.06873286f, -0.10892411f, 0.10901929f, 0.05310603f, 0.08693674f, -0.01880780f, -0.01717156f, -0.07333697f, 
    0.06301621f, -0.06915350f, 0.04953599f, 0.03515259f, 0.11149916f, 0.10786222f, -0.08987802f, -0.14225645f, 
    0.02731494f, -0.01069852f, 0.07846026f, -0.04119489f, 0.03474341f, 0.10214425f, -0.07512692f, -0.08570399f, 
    0.06306277f, -0.09328534f, 0.00402340f, 0.01931267f, -0.09767865f, 0.07988799f, 0.02174627f, -0.12084161f, 
    -0.16442922f, 0.02143253f, 0.12901509f, 0.03851147f, 0.08583315f, 0.08811044f, -0.01557376f, -0.08486924f, 
    -0.00116485f, -0.00714630f, 0.05601652f, -0.05859172f, 0.02072774f, 0.08738228f, -0.05179216f, 0.02006237f, 
    0.01569084f, 0.10415524f, 0.02450409f, -0.15764040f, 0.03176764f, -0.04641284f, 0.04646495f, 0.02845839f, 
    0.07894013f, 0.03462673f, 0.00707137f, -0.02503486f, -0.02316947f, -0.08704774f, -0.06744836f, -0.03971994f, 
    0.17819428f, 0.07759779f, 0.10368402f, -0.13970801f, 0.19777581f, 0.01922549f, 0.03313133f, 0.05354621f, 
    -0.03877661f, -0.09658056f, 0.05330388f, -0.00292896f, 0.01619378f, -0.01127760f, 0.05425109f, -0.14337732f, 
    -0.04774827f, -0.00439375f, -0.02006388f, -0.16319412f, -0.03898769f, -0.00530713f, -0.10571079f, 0.05165312f, 
    0.07313979f, 0.04953320f, -0.08540975f, -0.02305671f, -0.06337628f, 0.03380847f, 0.03537282f, -0.25180286f, 
    -0.15675423f, -0.05423665f, -0.01806903f, 0.18491927f, -0.00861296f, 0.11024679f, -0.08403850f, -0.04664247f, 
    -0.35305241f, -0.08923981f, -0.12955855f, -0.10637573f, -0.09420106f, -0.03712137f, -0.07697178f, 0.04238019f, 
    0.03004786f, 0.12287278f, -0.08164678f, 0.06412274f, 0.03424522f, 0.14689365f, -0.10118915f, 0.08777478f, 
    0.02424004f, -0.17394590f, -0.10772700f, 0.03431994f, 0.02100269f, -0.03457180f, -0.10994198f, -0.12727542f, 
    -0.02519502f, -0.02415566f, -0.01690475f, -0.15664631f, -0.13187931f, -0.00360400f, 0.09092183f, -0.01371296f, 
    -0.05690172f, -0.02537541f, 0.09270835f, -0.01956765f, 0.28970283f, 0.13752419f, 0.02747158f, 0.00128741f, 
    0.07418557f, -0.06381384f, 0.01007178f, -0.01505204f, -0.04989231f, 0.19144088f, -0.12209196f, 0.02678833f, 
    0.08139484f, 0.05771239f, -0.01848032f, 0.04405516f, -0.15667224f, -0.04109810f, 0.03429570f, 0.21448405f, 
    -0.16292807f, -0.03928591f, -0.12059128f, -0.01565301f, 0.02526447f, 0.11184488f, -0.11793018f, 0.11977602f, 
    0.25944546f, -0.02632498f, 0.08359203f, -0.06440160f, 0.07677316f, -0.12158702f, 0.06196985f, 0.15139239f, 
    0.07674184f, -0.13184856f, -0.11149962f, -0.02547031f, 0.11449704f, 0.01660525f, 0.05003142f, 0.07520964f, 
    0.01533488f, 0.15840387f, -0.19482183f, -0.01734152f, 0.03438600f, -0.11409408f, -0.03833190f, -0.07111579f, 
    -0.02383600f, -0.02697728f, 0.00365414f, -0.04695880f, -0.08095441f, 0.05883921f, 0.09889946f, -0.02708242f, 
    0.08520551f, 0.02829483f, 0.17485461f, -0.04621121f, 0.19398880f, 0.23812252f, 0.03585308f, -0.01932776f, 
    0.01413897f, -0.01887113f, -0.06549377f, -0.05486088f, 0.20770201f, 0.06681302f, 0.19815589f, 0.14606200f, 
    -0.05167652f, -0.00062308f, 0.11774264f, -0.04215868f, 0.11960341f, 0.02887126f, 0.02583418f, -0.11170740f, 
    0.00697631f, 0.02235817f, -0.02857336f, 0.06569241f, -0.06159320f, 0.04476526f, 0.04454502f, 0.04422072f, 
    0.09322121f, -0.03165338f, -0.02004960f, 0.07819186f, 0.03200872f, 0.02039039f, -0.10207574f, 0.12991893f, 
    0.09514429f, -0.13138884f, 0.12720849f, 0.09576712f, -0.09391531f, 0.05301774f, -0.04006454f, 0.20115502f, 
    0.09382742f, 0.04897663f, 0.20876721f, 0.00331213f, 0.10690308f, 0.12989931f, 0.01056693f, 0.02495235f, 
    0.04214084f, 0.10054506f, 0.04197592f, -0.06644969f, -0.10468639f, -0.08706822f, 0.06046731f, 0.00828614f, 
    -0.02176581f, -0.10721011f, -0.06075343f, 0.02234861f, -0.06303177f, 0.07327222f, -0.01632819f, 0.03059293f, 
    0.13896281f, 0.08615155f, -0.01439966f, -0.32007492f, -0.27701110f, -0.06052451f, -0.03667928f, -0.06067256f, 
    0.12954760f, -0.04277546f, 0.11435020f, -0.03084478f, 0.15113683f, 0.02354227f, -0.00645975f, -0.21227670f, 
    -0.05120143f, -0.00911360f, -0.07077120f, 0.00329950f, -0.11525635f, 0.22620201f, 0.09008592f, 0.11474842f, 
    0.07281494f, 0.10056273f, -0.01009066f, 0.03235637f, -0.12680700f, -0.10264969f, 0.01877280f, 0.07599803f, 
    0.20538110f, 0.12126642f, -0.01069162f, -0.03764175f, -0.04007697f, 0.04291297f, 0.03886763f, -0.00783429f, 
    0.23476656f, -0.01061268f, -0.03427217f, -0.09206081f, 0.02183530f, 0.05310165f, 0.10259508f, -0.06733397f, 
    -0.30183569f, 0.02675834f, 0.04442944f, -0.04280134f, 0.00973839f, 0.03132134f, -0.06999277f, 0.00546290f, 
    0.04806266f, -0.06353947f, 0.06840381f, 0.03910568f, -0.01982327f, 0.04773713f, -0.04096422f, -0.02278231f, 
    0.03191667f, -0.01608228f, -0.00685164f, 0.04270538f, 0.18598726f, 0.07653750f, -0.15152435f, -0.15317024f, 
    -0.06923028f, -0.05614618f, 0.01950193f, 0.01430817f, 0.01258368f, -0.05256541f, 0.05142286f, -0.03418550f, 
    0.09855161f, -0.00133898f, 0.03091509f, -0.00419827f, 0.12444095f, 0.13432930f, -0.00723938f, -0.08581202f, 
    -0.02632370f, -0.03224775f, -0.08931925f, -0.01613395f, -0.09745292f, -0.12608224f, 0.03691554f, -0.05089848f, 
    -0.02415632f, 0.01203072f, -0.12221865f, 0.01643726f, 0.01004893f, 0.08001620f, -0.06327107f, 0.02106763f, 
    0.12182084f, -0.02671282f, -0.01992388f, -0.11710420f, 0.08663002f, 0.00016571f, -0.08328405f, 0.02378272f, 
    -0.03292345f, -0.07466918f, 0.00352838f, 0.02481102f, 0.07268569f, 0.03679461f, -0.03649877f, 0.22462702f, 
    0.02167063f, 0.03691688f, 0.04080277f, -0.03715371f, 0.00067498f, -0.05695660f, 0.01336911f, 0.04160148f, 
    -0.00330333f, -0.00113009f, -0.00082339f, -0.04566441f, 0.02841034f, 0.05110633f, 0.01847821f, 0.02244418f, 
    0.04655914f, -0.01324520f, -0.00342348f, 0.03061835f, -0.02347615f, -0.03022034f, -0.03938756f, -0.01690339f, 
    0.04025573f, -0.00271164f, 0.01923152f, -0.05911256f, 0.00389031f, -0.00222732f, -0.05279463f, 0.04995591f, 
    0.04195203f, 0.04330229f, -0.04038278f, 0.00970708f, -0.01465789f, -0.04914020f, 0.02896514f, 0.05026083f, 
    -0.06361428f, -0.00437014f, -0.00211609f, 0.02948209f, -0.06141900f, 0.03359305f, 0.00221845f, 0.04455095f, 
    -0.04127842f, 0.03590100f, -0.00317786f, 0.00425003f, 0.02990937f, -0.02629867f, 0.04441725f, -0.04160275f, 
    -0.01611040f, -0.05641698f, 0.03519958f, -0.03620000f, -0.05349806f, -0.04548647f, -0.00887334f, -0.01427222f, 
    -0.05510941f, -0.03272080f, 0.02489947f, 0.01582090f, -0.01273991f, 0.01492490f, 0.01470127f, 0.04939929f, 
    -0.06446010f, 0.04640214f, 0.01449197f, -0.01537591f, -0.00854607f, -0.00338301f, 0.01249551f, -0.06374075f, 
    -0.04414336f, -0.01393497f, 0.00023099f, -0.05361852f, 0.01222091f, 0.00181689f, 0.01537855f, 0.05142651f, 
    -0.01558654f, -0.04970505f, 0.01414281f, 0.02533935f, -0.01628142f, -0.03108022f, -0.03585078f, 0.00586965f, 
    0.01865552f, -0.03679398f, 0.03381947f, 0.02341212f, 0.02705772f, 0.02556605f, -0.04149658f, -0.03343704f, 
    -0.03158543f, -0.02180859f, -0.01111335f, -0.06099660f, -0.05764370f, -0.01175651f, 0.00774511f, -0.05751209f, 
    0.01362143f, -0.00252272f, 0.02764957f, -0.05536471f, 0.01505407f, 0.03732232f, 0.04080047f, -0.06211814f, 
    -0.03049917f, 0.02866052f, -0.01749654f, -0.05856000f, -0.03102794f, -0.06190879f, 0.00092120f, 0.04508469f, 
    0.02482429f, -0.01682786f, 0.03625506f, -0.05132831f, -0.00672397f, -0.04488774f, -0.00773775f, 0.03109920f, 
    0.02323504f, -0.04958222f, 0.00754278f, -0.04628862f, -0.05978264f, -0.06604091f, 0.01254045f, 0.03633206f, 
    0.02521917f, -0.02827555f, -0.06120041f, 0.02284948f, -0.02657279f, -0.01687871f, 0.03597892f, 0.03964683f, 
    -0.03775567f, -0.00131741f, -0.03188363f, 0.04320335f, -0.00031735f, -0.05156134f, 0.00963572f, -0.05247204f, 
    0.02236147f, -0.02769377f, -0.02174332f, 0.02542173f, -0.03097769f, 0.04621068f, -0.06206181f, -0.05821584f, 
    0.00310136f, 0.04844271f, -0.04784120f, -0.02763395f, -0.00037952f, 0.01382547f, -0.00977238f, -0.05178360f, 
    -0.06163225f, 0.04450041f, -0.03729725f, -0.03560739f, -0.00871124f, -0.03353925f, -0.01021852f, -0.05367870f, 
    -0.02503386f, 0.00899806f, 0.00832485f, -0.03815905f, -0.01642135f, -0.05943151f, -0.05345218f, 0.01294142f, 
    -0.01043840f, 0.02373855f, 0.02271098f, -0.04266459f, -0.03922945f, 0.03225323f, -0.03817745f, 0.05474550f, 
    0.03492558f, 0.01185683f, 0.03156554f, -0.03445430f, 0.03232018f, -0.03173795f, -0.02315406f, -0.03264652f, 
    -0.00028825f, 0.04598842f, 0.01152135f, -0.02859495f, 0.04555614f, 0.02601230f, 0.05107655f, 0.00554089f, 
    -0.00944859f, -0.01610884f, -0.00506910f, 0.04691218f, -0.00862361f, -0.03093806f, -0.00990662f, 0.02377046f, 
    0.02878092f, -0.03184294f, 0.02998992f, 0.03642268f, 0.03345940f, 0.01096945f, 0.03030524f, 0.00192936f, 
    0.01266869f, -0.00473256f, 0.02633811f, 0.01254455f, -0.03456257f, -0.06054880f, 0.04863505f, 0.02138978f, 
    0.02274819f, -0.01850031f, -0.03388980f, 0.02948205f, -0.02010228f, 0.00910743f, 0.02733253f, -0.02607481f, 
    0.04761631f, 0.00204802f, -0.05356135f, 0.04021978f, -0.05327605f, -0.05727034f, 0.02068176f, -0.05539069f, 
    -0.01324331f, 0.05203531f, 0.00653048f, -0.06201763f, -0.00450890f, -0.03521683f, -0.02241359f, -0.03361708f, 
    -0.02996727f, 0.02910908f, -0.01421318f, -0.05498892f, -0.05618317f, -0.05619209f, -0.02986506f, -0.02924376f, 
    -0.03595160f, 0.03443698f, -0.05641756f, 0.01987550f, -0.05474563f, 0.01748465f, 0.02895144f, -0.06300515f, 
    -0.01464004f, -0.03582442f, 0.02031425f, -0.00928909f, -0.05169152f, 0.03643009f, 0.00160969f, 0.00978046f, 
    -0.10549413f, 0.05269556f, 0.01363830f, 0.04799603f, 0.00516481f, -0.01284209f, 0.03642371f, -0.04707713f, 
    -0.24840379f, 0.02973288f, 0.02946243f, 0.09328138f, -0.09331169f, 0.08260253f, 0.03660025f, 0.04295313f, 
    0.07236470f, 0.02786273f, -0.11896162f, -0.00268915f, 0.03960202f, 0.02136923f, 0.17489636f, -0.07408679f, 
    0.09268468f, -0.00928310f, -0.15091394f, 0.09304218f, -0.03096787f, -0.04024754f, 0.06107949f, 0.02560404f, 
    0.18830378f, -0.06365608f, 0.22770734f, -0.27464876f, 0.04959531f, -0.18523493f, 0.00372748f, -0.00908625f, 
    -0.04052167f, 0.10545731f, 0.12105677f, -0.13783185f, 0.18907771f, 0.10236997f, 0.24435903f, 0.16547389f, 
    0.05693898f, 0.07873920f, -0.01632796f, 0.10722677f, 0.03377293f, 0.16464426f, 0.14553213f, -0.08045416f, 
    0.02266010f, 0.07177908f, 0.06680719f, -0.09766997f, -0.02494509f, 0.14333683f, 0.02322811f, 0.10716248f, 
    0.03199601f, -0.02549262f, -0.02346472f, -0.13657388f, 0.12190782f, 0.01887296f, 0.11865376f, -0.00309323f, 
    -0.22169697f, -0.12238713f, -0.33925599f, 0.13628805f, 0.12216806f, 0.03899993f, -0.12796958f, -0.17344141f, 
    -0.26939023f, 0.00119481f, 0.07141256f, -0.09226456f, 0.08082495f, 0.03369050f, 0.02252724f, 0.17835423f, 
    -0.02809298f, -0.14625159f, -0.08575899f, 0.07879157f, -0.10860464f, 0.15933883f, 0.00567597f, 0.21675003f, 
    0.17130359f, 0.04905574f, -0.07042951f, -0.07373708f, 0.11962961f, -0.01596478f, 0.05765999f, -0.00189899f, 
    0.03395557f, -0.06386584f, 0.06704599f, 0.21128808f, -0.14882492f, -0.11113808f, 0.04159150f, 0.07036036f, 
    0.12412848f, 0.04677223f, -0.02767558f, -0.05598560f, -0.16214247f, 0.14045551f, -0.01710631f, 0.01516225f, 
    0.17333639f, 0.00788809f, 0.22159597f, 0.07255798f, 0.12148634f, -0.03060065f, 0.01108823f, 0.05940475f, 
    0.02014402f, -0.02225908f, -0.02223013f, 0.09215823f, 0.27973819f, 0.07723241f, 0.07917744f, -0.04874954f, 
    -0.11988303f, 0.10616610f, 0.06638724f, -0.11238614f, 0.09101619f, -0.02046273f, -0.13788483f, -0.09448144f, 
    0.07359296f, -0.10063431f, -0.12217885f, 0.09211223f, 0.11830314f, 0.01106185f, -0.06465537f, 0.10289109f, 
    0.04341639f, 0.04377545f, 0.25476232f, 0.08471086f, -0.02924950f, 0.05777855f, -0.08945588f, 0.18833591f, 
    0.07184076f, 0.14668594f, 0.07416717f, -0.04599984f, 0.00607661f, 0.13519745f, 0.07140622f, 0.17960496f, 
    0.05881674f, 0.17005135f, -0.04538368f, 0.33035225f, 0.24234875f, 0.07584593f, -0.00801455f, -0.13285796f, 
    -0.16268085f, 0.10906573f, 0.14674565f, 0.12652093f, -0.13517953f, -0.09523221f, 0.02094686f, 0.10549879f, 
    0.05912998f, -0.11100235f, 0.11302083f, 0.18598257f, 0.01728800f, -0.24135676f, -0.08169087f, 0.09536598f, 
    0.01665761f, -0.08487169f, 0.05188664f, -0.06398176f, 0.03878515f, -0.02006567f, 0.11929629f, 0.06897043f, 
    -0.02754827f, 0.11664882f, 0.05795574f, -0.01574428f, 0.16174325f, -0.02126651f, 0.15591545f, 0.07112703f, 
    -0.10824634f, 0.07381090f, 0.08589058f, 0.01983958f, 0.02877824f, -0.20819095f, 0.11774912f, -0.04966328f, 
    0.33974239f, 0.28281996f, 0.14848547f, 0.10254761f, 0.03224085f, 0.03945950f, 0.14231278f, 0.13648270f, 
    0.05640902f, 0.31374121f, 0.02646170f, -0.07032327f, 0.06108133f, 0.06049639f, 0.16017525f, -0.08796152f, 
    0.00649083f, -0.09832241f, 0.00763846f, -0.09564218f, -0.18672030f, 0.02167762f, 0.02883950f, 0.01131948f, 
    0.17831875f, 0.09007547f, -0.23521188f, 0.07668062f, -0.02684145f, 0.16375761f, 0.09882281f, 0.06441361f, 
    0.15328863f, 0.14844888f, -0.08459555f, 0.01821254f, 0.02982315f, -0.04788318f, 0.06282818f, 0.24798791f, 
    0.05492112f, -0.00341414f, 0.08241544f, -0.00559600f, 0.09701833f, 0.11157685f, 0.00592484f, 0.00326765f, 
    0.13612176f, 0.17677167f, 0.14640917f, -0.11891755f, -0.05209620f, 0.02566574f, -0.07059067f, 0.02870768f, 
    -0.02426723f, 0.07388929f, 0.16248430f, 0.00028430f, -0.06213500f, -0.03540595f, -0.22562508f, -0.01404306f, 
    0.10462025f, 0.14292744f, 0.03269612f, 0.11832743f, 0.09293515f, 0.21453020f, 0.03931679f, -0.00218841f, 
    0.04257779f, -0.06467167f, 0.04950723f, 0.03568759f, -0.03567706f, -0.05198023f, -0.06540514f, -0.01669459f, 
    0.03734122f, 0.02521397f, -0.01590003f, -0.02714510f, -0.00845920f, -0.02874758f, -0.03330012f, -0.00394940f, 
    -0.00798206f, -0.00192226f, -0.06185947f, -0.03063038f, -0.03518855f, -0.02198956f, -0.06120038f, -0.05246280f, 
    -0.05853651f, -0.02622472f, -0.02098755f, -0.01531722f, 0.00752352f, -0.03736319f, -0.01613934f, -0.00463462f, 
    0.03246975f, -0.01808226f, 0.04475468f, -0.03672916f, -0.00419587f, 0.04816405f, 0.00156805f, 0.02615241f, 
    -0.05041560f, -0.06600211f, -0.00889706f, 0.00347126f, -0.03482196f, 0.00558309f, 0.01028316f, 0.00152310f, 
    -0.01842417f, -0.01422051f, 0.05433459f, 0.05798061f, -0.00465572f, -0.03020024f, 0.04164962f, 0.02190126f, 
    -0.06681039f, -0.05568290f, -0.01693582f, -0.04186882f, 0.03451821f, 0.04150861f, -0.03391076f, 0.02135307f, 
    -0.04040242f, 0.03988199f, -0.06265365f, -0.00144223f, -0.00600515f, 0.02136051f, 0.02095199f, 0.04326011f, 
    -0.01393679f, 0.02753204f, 0.02380588f, -0.01899549f, -0.00713700f, 0.00444976f, 0.01016577f, 0.00668026f, 
    0.04258601f, 0.03969220f, -0.03670896f, -0.05719832f, -0.06747825f, -0.00073694f, 0.01252847f, -0.04131638f, 
    0.01158482f, -0.02467972f, -0.05241548f, 0.01140566f, -0.03942565f, -0.01550042f, 0.04971702f, 0.04209388f, 
    -0.02004750f, 0.03497342f, -0.05429932f, -0.03651877f, 0.01488330f, 0.00762194f, -0.04341913f, 0.01249965f, 
    -0.05136325f, 0.03982051f, 0.03741779f, 0.00904867f, 0.01359152f, -0.02532181f, 0.01664341f, 0.01623729f, 
    -0.00932727f, -0.04669661f, 0.04449167f, -0.03013868f, -0.00242946f, -0.04589226f, -0.00536748f, -0.00179508f, 
    0.04673542f, 0.03355615f, 0.01056619f, -0.03514113f, -0.05167216f, -0.02217723f, 0.04893636f, -0.03227794f, 
    0.00669405f, -0.01952291f, -0.03164295f, -0.00466915f, -0.03450492f, 0.03628480f, -0.05471756f, -0.04052041f, 
    -0.01599513f, -0.04853690f, -0.03078744f, 0.01286038f, -0.03205224f, 0.04984616f, 0.04493444f, -0.02198824f, 
    -0.05288299f, -0.04157541f, -0.02147647f, 0.04264911f, -0.06291521f, -0.06406584f, 0.00012450f, -0.04563757f, 
    -0.00927888f, 0.02514792f, -0.03698923f, 0.04937101f, 0.01783539f, -0.02017328f, 0.01756436f, -0.06212473f, 
    -0.06409624f, 0.00437025f, 0.00066711f, 0.03396288f, 0.01526954f, -0.00221262f, -0.00644636f, 0.01751100f, 
    0.00577953f, -0.00483347f, -0.03101358f, -0.04647866f, 0.00739535f, 0.01035934f, -0.02094051f, 0.01032076f, 
    0.06018689f, 0.03835996f, -0.03055459f, 0.05091685f, 0.03429119f, 0.05321985f, -0.03538100f, -0.05237976f, 
    -0.03683760f, -0.01067624f, -0.01447755f, 0.04541650f, 0.04816845f, -0.05860847f, 0.00716843f, -0.01924916f, 
    0.04594744f, -0.05706612f, 0.05025073f, 0.01085309f, -0.03655985f, 0.00580528f, -0.04857293f, -0.00980207f, 
    0.03971955f, -0.06351843f, 0.04466999f, -0.00126510f, 0.03774866f, 0.02206819f, -0.00062451f, -0.02337894f, 
    -0.04671391f, -0.02874644f, -0.05559432f, -0.06296089f, -0.02206395f, -0.04971521f, 0.01618188f, 0.04571905f, 
    -0.01842007f, -0.02464010f, -0.01642123f, -0.04567922f, 0.04858332f, -0.03360981f, -0.03285006f, -0.05093416f, 
    -0.06766533f, -0.04964375f, -0.03839051f, -0.05288593f, 0.04422080f, 0.03175890f, -0.04552586f, -0.02039633f, 
    0.03852699f, -0.03887720f, -0.00779163f, 0.04220999f, -0.04635103f, 0.01976117f, -0.03409628f, -0.03470710f, 
    -0.05884942f, -0.03363815f, -0.00231398f, -0.03373869f, -0.03867082f, 0.02606666f, -0.03433058f, 0.00789429f, 
    -0.04239950f, -0.05059705f, 0.00976287f, -0.04000740f, 0.00103414f, 0.04882709f, -0.03180768f, 0.01694287f, 
    -0.04781375f, 0.00853930f, 0.02859926f, 0.04791939f, 0.04923492f, -0.03078808f, 0.02740764f, -0.01024651f, 
    -0.04927630f, 0.00292029f, -0.03700993f, 0.04331293f, 0.04308893f, 0.04484060f, -0.04143725f, 0.00006063f, 
    0.00373611f, 0.03276003f, -0.04735380f, -0.03778533f, -0.01193787f, -0.02998051f, -0.00681897f, -0.03165374f, 
    -0.00828802f, 0.02844619f, 0.04319097f, -0.00635458f, -0.05958611f, -0.06335808f, 0.00484517f, 0.03151971f, 
    0.16143008f, -0.03361419f, -0.10364237f, 0.01915911f, 0.04508182f, -0.02494902f, -0.03192408f, 0.05421259f, 
    0.00412649f, -0.12796077f, -0.10410271f, -0.11632242f, -0.11035844f, -0.06105867f, 0.02258936f, -0.00888120f, 
    0.02667502f, -0.11265175f, 0.05359044f, 0.19072157f, -0.04408472f, -0.01884563f, -0.03065212f, 0.04048397f, 
    0.06794231f, -0.07629040f, -0.06103679f, 0.12521936f, 0.13321668f, 0.01288166f, 0.02734220f, -0.04233042f, 
    0.14124590f, -0.11852896f, 0.07998987f, 0.01975444f, -0.12811525f, -0.04309436f, 0.08770749f, -0.01752176f, 
    -0.01219782f, -0.17862210f, -0.01912060f, -0.02528292f, -0.08102916f, 0.06594153f, -0.18758407f, -0.26222104f, 
    0.00998539f, -0.07193965f, 0.08844144f, -0.00762599f, -0.06093302f, -0.02278672f, 0.08860642f, -0.13118684f, 
    -0.05342960f, 0.02061765f, 0.07978242f, -0.05122016f, -0.23914392f, 0.02266591f, 0.02620318f, 0.09137173f, 
    -0.13139574f, 0.03679449f, 0.06086234f, 0.01459743f, -0.05970067f, -0.16032134f, -0.03347275f, -0.06298080f, 
    -0.13181338f, 0.13241322f, 0.30256802f, -0.13467379f, -0.00596977f, -0.07060998f, 0.08584131f, 0.07985549f, 
    0.07037957f, -0.04371547f, 0.09232789f, 0.23994401f, -0.06647119f, -0.09099292f, -0.02603284f, -0.12913966f, 
    -0.00549371f, 0.06413373f, -0.25929749f, 0.24778149f, 0.11346962f, -0.00639909f, -0.07404282f, 0.11158098f, 
    0.02865789f, 0.03641725f, -0.04255831f, 0.14150812f, 0.07564943f, -0.23405713f, -0.00075099f, 0.08848263f, 
    0.11580012f, 0.02160725f, -0.10373390f, -0.11898688f, -0.00546167f, 0.02195396f, -0.00518730f, -0.02643256f, 
    0.03219199f, -0.07522789f, -0.09999313f, -0.01212761f, 0.03400365f, 0.14746191f, 0.04690869f, -0.01662221f, 
    -0.03063175f, -0.10551792f, 0.09892660f, 0.02865656f, 0.02258341f, 0.06587868f, 0.09005324f, -0.07970913f, 
    -0.12665981f, 0.04781242f, 0.03699341f, 0.09914247f, 0.02989690f, 0.00596276f, 0.03285354f, 0.03311890f, 
    -0.01448259f, 0.12710798f, 0.03328333f, -0.07873028f, 0.02090736f, -0.04990879f, 0.07107061f, -0.01105720f, 
    -0.21208683f, 0.08341771f, 0.19992465f, 0.00203366f, -0.01784720f, -0.19044304f, -0.04707811f, 0.04472723f, 
    0.07055354f, -0.18802300f, 0.08002277f, -0.08446519f, 0.03230322f, 0.18044978f, -0.06957094f, -0.09032988f, 
    -0.11057822f, 0.15476087f, -0.13461667f, -0.02056886f, 0.03063194f, 0.07873470f, 0.01599214f, -0.00336733f, 
    -0.11093097f, -0.00456659f, 0.02831761f, 0.07472908f, -0.13317797f, -0.14712594f, 0.03747854f, 0.09992053f, 
    0.09345311f, -0.09187914f, -0.16300786f, -0.01984205f, 0.21846522f, -0.03570929f, -0.03620745f, 0.02603946f, 
    0.04110966f, 0.03788774f, 0.04558008f, -0.04206727f, -0.00275161f, 0.08715435f, -0.02330384f, -0.14132272f, 
    -0.04428447f, 0.06628141f, 0.00430355f, -0.02611860f, -0.15011780f, -0.03899161f, -0.05284315f, -0.10002180f, 
    0.22307704f, 0.03692517f, 0.01737428f, -0.20264250f, -0.07573596f, 0.01130336f, 0.04712165f, 0.18800150f, 
    -0.13373691f, 0.07979319f, -0.20633709f, -0.12889689f, 0.02114546f, 0.09887177f, 0.07302085f, -0.03040059f, 
    -0.05021378f, 0.10657189f, -0.10794560f, 0.05395892f, -0.00228923f, 0.02388654f, -0.04203418f, -0.00398231f, 
    -0.02359937f, 0.16291291f, 0.11997662f, 0.04017170f, -0.06464566f, -0.10545772f, -0.03440631f, 0.12342570f, 
    0.03463859f, -0.00835193f, -0.15179956f, 0.11329091f, 0.12521438f, 0.08620161f, -0.07552841f, -0.02776356f, 
    -0.07273598f, -0.03726328f, 0.20179678f, 0.01221213f, 0.08594640f, -0.10166581f, 0.03083341f, -0.03566036f, 
    -0.01815368f, -0.03183492f, 0.03068370f, 0.03755535f, -0.07020602f, 0.08742107f, -0.02197433f, -0.08417552f, 
    -0.02930704f, 0.06747417f, 0.03287570f, -0.03045118f, -0.15818611f, 0.16599788f, 0.04962848f, -0.07121773f, 
    -0.10972854f, -0.05390217f, -0.00411025f, 0.09096705f, 0.11871263f, 0.08280044f, 0.41006184f, 0.12481928f, 
    0.12514164f, -0.01979350f, -0.09823099f, -0.05630890f, -0.08776543f, 0.06566004f, -0.01116389f, -0.04147844f, 
    0.19450575f, 0.01237857f, 0.21327811f, -0.00575689f, 0.00347184f, -0.07857016f, 0.03445613f, 0.08167479f, 
    0.11802889f, 0.05240521f, 0.18439610f, 0.11779287f, -0.06533837f, 0.03674019f, 0.09836634f, -0.13430299f, 
    0.08462602f, -0.10048018f, 0.00951884f, -0.12542905f, 0.11661860f, 0.06902657f, 0.06966121f, -0.02397753f, 
    -0.16131228f, 0.08548123f, -0.02672289f, 0.04474455f, 0.04296511f, -0.04596535f, -0.06683827f, 0.05091725f, 
    0.04956121f, 0.03721675f, 0.12861969f, -0.17654386f, -0.07008637f, -0.09938113f, -0.11817009f, 0.07814890f, 
    -0.03119270f, 0.00082794f, 0.02737737f, 0.12808973f, 0.10197689f, 0.11382482f, -0.07126444f, -0.10694243f, 
    0.05143985f, -0.05871579f, 0.05480197f, -0.08073455f, -0.20086922f, 0.00188273f, -0.00763164f, -0.14865187f, 
    -0.05238392f, 0.06749771f, 0.03146075f, -0.14915861f, -0.04994557f, 0.02617668f, -0.04796468f, -0.26601222f, 
    -0.03004028f, 0.17100625f, -0.00560616f, 0.03560813f, 0.02768684f, -0.12415928f, -0.00697781f, -0.03773668f, 
    -0.24592051f, -0.18756500f, -0.05806098f, 0.10317051f, -0.04371242f, -0.00742123f, 0.03012831f, 0.10181979f, 
    -0.15807289f, 0.00790122f, 0.07807930f, -0.08737644f, -0.08985649f, 0.15373889f, 0.01113231f, 0.01361737f, 
    -0.05074155f, -0.14251675f, 0.05716044f, -0.04725034f, 0.03712602f, -0.01334299f, 0.05144501f, 0.04569736f, 
    0.05155797f, -0.05754675f, -0.01277048f, -0.04841141f, -0.02104046f, 0.03009963f, 0.04091671f, -0.14532515f, 
    -0.05611616f, 0.04253592f, -0.04333529f, 0.05251462f, 0.07188758f, -0.12985757f, -0.05565219f, 0.10741837f, 
    0.11266244f, -0.01362878f, -0.11219409f, 0.03900243f, -0.11677215f, 0.02111930f, -0.09080893f, -0.00999593f, 
    -0.02952702f, 0.03784155f, -0.07096428f, 0.14892031f, -0.02420818f, 0.11630540f, -0.15376249f, -0.12829828f, 
    -0.06260749f, 0.15768360f, -0.09315939f, 0.00172665f, 0.04744879f, -0.03913105f, -0.01932717f, 0.03733993f, 
    -0.14918126f, -0.02183389f, -0.04732037f, 0.06649836f, -0.15240811f, -0.18632104f, -0.10645553f, 0.22651392f, 
    -0.04975463f, 0.00674983f, 0.09693170f, -0.04614888f, -0.05295314f, -0.06606825f, -0.01072784f, -0.06595498f, 
    -0.15740786f, 0.22684133f, 0.01506662f, -0.03000468f, -0.09431224f, -0.10657810f, -0.04243447f, -0.06048046f, 
    -0.02073451f, 0.16251379f, 0.19433430f, 0.01433284f, -0.07290552f, -0.00824889f, -0.02361832f, -0.04722236f, 
    0.06548248f, 0.06289246f, 0.24112250f, 0.14783372f, 0.14555715f, 0.00519293f, -0.08979326f, -0.09609500f, 
    -0.03463987f, 0.05840537f, 0.01031714f, 0.37220091f, 0.23422636f, 0.14959534f, 0.05258673f, -0.07441330f, 
    0.13961768f, -0.07723401f, 0.00223670f, 0.07937023f, -0.11435162f, 0.13402994f, -0.04544901f, 0.10735399f, 
    -0.07999596f, 0.03307828f, 0.04230478f, -0.08187199f, 0.00746747f, 0.01623377f, -0.11331243f, -0.12450053f, 
    0.02762376f, 0.11946463f, -0.07319011f, -0.09940080f, -0.03949539f, -0.02786455f, 0.04694699f, 0.23799369f, 
    -0.01193280f, 0.05102193f, -0.02490576f, -0.06528595f, -0.03136398f, 0.01717744f, -0.10616266f, -0.15801805f, 
    -0.15958112f, -0.10604855f, -0.02337475f, 0.01185650f, 0.14373358f, -0.03318113f, -0.14916311f, 0.00906167f, 
    0.15359297f, 0.13834624f, 0.00833221f, 0.01393568f, -0.16110620f, -0.06415389f, -0.00418126f, -0.03811134f, 
    0.17670959f, -0.25017238f, -0.04592799f, 0.02516798f, 0.07798111f, 0.03493383f, 0.04838980f, 0.06153696f, 
    -0.03120790f, -0.05319760f, -0.12801845f, -0.09542577f, 0.22096150f, -0.01006428f, -0.06282616f, -0.07323782f, 
    0.06285167f, 0.08648270f, 0.05358665f, 0.03527018f, 0.03079669f, -0.01739725f, 0.08389938f, -0.00921337f, 
    -0.01309528f, 0.06656111f, -0.13080916f, -0.04056193f, 0.00048675f, 0.19418508f, -0.15038718f, -0.02425095f, 
    0.01242665f, 0.06371875f, -0.02772429f, 0.02354476f, -0.18699452f, 0.03718508f, -0.23062962f, -0.00741113f, 
    -0.00920351f, 0.04039457f, -0.00045967f, 0.03631369f, 0.09260613f, 0.09375009f, -0.02747120f, -0.02613457f, 
    0.03763448f, 0.04351710f, 0.09586556f, -0.03976854f, -0.05482161f, 0.03115348f, -0.08190483f, 0.18136995f, 
    0.19000854f, 0.08268722f, -0.19099042f, 0.01170386f, 0.01224699f, -0.03865217f, -0.00594758f, 0.08573036f, 
    0.14637424f, 0.12056193f, -0.01597772f, 0.01491244f, -0.05378900f, -0.01051626f, 0.12773593f, -0.06335701f, 
    0.01939186f, -0.11565166f, -0.06345112f, 0.11240640f, 0.04575793f, 0.00350822f, 0.02982738f, -0.03189611f, 
    0.10019390f, -0.06725048f, 0.13233350f, 0.16371635f, 0.04309138f, -0.14657204f, -0.05288552f, -0.06974815f, 
    0.01151345f, 0.00348555f, 0.03909323f, 0.03921685f, 0.04068796f, -0.00198583f, 0.08189457f, -0.16849630f, 
    -0.15080346f, 0.01292809f, -0.07286716f, 0.05405019f, -0.09845454f, 0.16053768f, 0.06474716f, -0.09216273f, 
    -0.08216617f, 0.01988008f, 0.13628681f, 0.07208195f, -0.02816765f, -0.10351662f, -0.11544764f, 0.03619560f, 
    0.15074316f, 0.00708961f, 0.05967417f, 0.02493593f, 0.12693109f, -0.12502342f, -0.05409699f, 0.07372121f, 
    -0.12636122f, 0.12493777f, 0.03507882f, -0.07225709f, -0.02219311f, 0.05304581f, 0.02319958f, -0.11574889f, 
    -0.22406226f, 0.20372885f, -0.05898666f, 0.00966296f, -0.23649469f, -0.02093343f, -0.09303884f, 0.03986005f, 
    0.06683393f, 0.01399728f, 0.11763989f, 0.09239437f, -0.21194623f, 0.11677434f, -0.01036810f, 0.10486699f, 
    0.10513632f, -0.00118648f, -0.12382064f, 0.09564032f, 0.05086385f, -0.00754217f, 0.02317380f, 0.05514677f, 
    0.08278859f, -0.03453138f, 0.10209453f, 0.00681818f, 0.02908285f, -0.03272801f, -0.14007922f, -0.04669921f, 
    0.07964238f, -0.06024024f, 0.08214458f, 0.03605680f, 0.14431606f, -0.13087747f, 0.13218595f, 0.17318447f, 
    -0.03515062f, 0.00526995f, -0.03493546f, 0.07180286f, -0.12720039f, -0.23768941f, -0.01076975f, -0.13364612f, 
    -0.05492395f, -0.04321647f, 0.03138655f, 0.03131935f, 0.02569163f, 0.08451983f, -0.00807800f, 0.09417336f, 
    -0.01431074f, -0.05087584f, -0.06012318f, 0.11399987f, -0.07825236f, 0.04120680f, -0.09142750f, 0.16818705f, 
    -0.37192479f, 0.02824097f, -0.05166200f, 0.05910872f, -0.09350099f, -0.03322212f, -0.05721685f, 0.05432159f, 
    -0.09212594f, -0.05018106f, 0.01043263f, -0.03260221f, -0.01279120f, 0.01575928f, 0.05692562f, -0.11061138f, 
    -0.06777915f, -0.00133850f, 0.05014633f, -0.05455166f, -0.00846812f, 0.03675519f, 0.12480012f, 0.01852183f, 
    0.07615863f, 0.12732534f, -0.01896898f, -0.15986244f, 0.03237709f, 0.05375930f, 0.11070549f, -0.01139290f, 
    0.10769752f, -0.01539916f, 0.24113669f, 0.21153827f, 0.09807988f, 0.05256639f, -0.10716114f, -0.11285114f, 
    -0.11512502f, -0.06704340f, -0.01355174f, 0.19469927f, 0.07455380f, -0.11712325f, -0.03798560f, -0.06353971f, 
    0.14095372f, 0.07619692f, 0.06318877f, -0.02029204f, -0.06814355f, -0.02038527f, -0.09130147f, 0.11617398f, 
    -0.10585795f, 0.11068137f, 0.01992105f, 0.03455251f, 0.01204067f, 0.02791210f, -0.16981179f, -0.10808431f, 
    0.01288247f, 0.02809109f, -0.10110830f, 0.13688944f, -0.00261151f, -0.04165094f, 0.04193845f, 0.01858822f, 
    0.05390734f, -0.00975914f, -0.01510331f, 0.01305323f, 0.02867509f, 0.01417027f, 0.06769503f, -0.08276274f, 
    -0.22548707f, 0.02716029f, 0.10029283f, -0.03574630f, 0.00016857f, 0.06897959f, -0.10236166f, 0.08747698f, 
    0.17160442f, 0.01381497f, 0.02068030f, -0.08674818f, -0.01502975f, 0.11627331f, -0.00023191f, -0.00147587f, 
    0.04372910f, -0.22309639f, -0.11009846f, 0.10264706f, 0.10647602f, -0.08902497f, 0.02192393f, -0.00229644f, 
    -0.04324482f, 0.02540590f, 0.20122771f, -0.02105187f, 0.20451322f, -0.09032539f, -0.07326699f, -0.12927847f, 
    0.10627741f, -0.07599413f, -0.09656835f, -0.14884010f, 0.14323220f, -0.16658197f, 0.04175866f, -0.00899229f, 
    0.07709938f, 0.09511930f, 0.03923545f, -0.01763000f, 0.00051241f, 0.03233695f, -0.14724982f, 0.04396571f, 
    -0.04759423f, 0.04595625f, 0.01449730f, -0.00674531f, -0.06275866f, -0.14760491f, -0.07336055f, -0.03968398f, 
    0.02258233f, -0.12991138f, -0.04060746f, 0.03811368f, 0.04473379f, 0.00480938f, -0.11058135f, -0.03745136f, 
    0.09567327f, 0.06802752f, 0.07634415f, 0.04199250f, -0.07556124f, -0.04391099f, -0.04679379f, 0.15536651f, 
    0.19426656f, 0.13274965f, -0.00922991f, 0.02707553f, 0.11794648f, -0.00681673f, 0.08259682f, 0.07293725f, 
    0.02149187f, -0.02154407f, -0.01829516f, 0.04374000f, -0.00824097f, 0.02169871f, 0.00196969f, 0.03546290f, 
    -0.03575573f, 0.00414528f, -0.03953970f, -0.04612022f, -0.04784611f, 0.00478242f, 0.03049211f, 0.01650927f, 
    0.00434209f, -0.03244629f, -0.03376045f, -0.00533305f, 0.01038196f, 0.04195289f, 0.02768888f, 0.04046035f, 
    -0.07189053f, -0.03418734f, 0.05523156f, -0.01809227f, 0.00728212f, -0.03136792f, -0.04514231f, -0.03264135f, 
    0.03440382f, -0.04920803f, 0.03084113f, 0.04429700f, -0.05456223f, -0.04426914f, -0.02749050f, -0.02756302f, 
    0.04025938f, 0.02424313f, -0.00427915f, -0.05458253f, -0.02567745f, 0.00264613f, 0.01598470f, -0.04958035f, 
    -0.01570375f, -0.06050445f, -0.04743450f, -0.00327807f, 0.03802003f, -0.00611157f, 0.02243073f, -0.07827009f, 
    -0.04178242f, -0.02880491f, -0.00955462f, -0.02173170f, -0.03687628f, -0.08838785f, 0.01689305f, -0.03208677f, 
    0.03466685f, 0.01707354f, -0.05339417f, -0.03208512f, 0.02393152f, 0.01852747f, 0.03044908f, -0.03609528f, 
    -0.06440676f, -0.06814799f, -0.01318086f, -0.00360049f, -0.01813775f, 0.01870511f, -0.04376463f, 0.04540031f, 
    -0.05952300f, -0.01577826f, -0.02732480f, -0.01287901f, 0.02318659f, 0.00938285f, -0.02633248f, -0.02376817f, 
    -0.06922889f, 0.02701470f, 0.02232995f, 0.04306721f, -0.05396262f, 0.04033751f, -0.05595806f, -0.00565623f, 
    0.02746023f, -0.04625558f, 0.05084949f, -0.07801574f, 0.03309512f, -0.04284277f, -0.06243384f, 0.02318765f, 
    -0.05038882f, -0.00912750f, 0.00432701f, -0.02515722f, -0.01836720f, 0.01350491f, -0.07047270f, -0.00831019f, 
    -0.03632531f, -0.06446529f, 0.02537232f, -0.05971045f, 0.00745927f, -0.05571795f, 0.04510773f, 0.01564172f, 
    -0.00798802f, -0.03894416f, -0.01849467f, -0.04510660f, -0.02327860f, -0.03381969f, -0.04399144f, -0.04091277f, 
    -0.05543463f, 0.06926617f, -0.02851373f, -0.07739282f, -0.00323671f, 0.04221233f, 0.02244469f, -0.06533470f, 
    0.03986488f, 0.00389364f, 0.03578540f, 0.04159177f, 0.02564410f, 0.00341382f, -0.02490887f, -0.04401080f, 
    -0.04066923f, -0.00967980f, -0.05985433f, 0.04934790f, 0.02824957f, -0.03575879f, -0.03690023f, -0.02448136f, 
    -0.08204486f, 0.04401224f, -0.01744463f, 0.00984196f, 0.00902111f, -0.00650737f, 0.04101371f, 0.01174876f, 
    -0.03651937f, 0.02638912f, -0.02431241f, -0.01540717f, -0.00990819f, -0.08052932f, 0.04694409f, -0.03783347f, 
    0.02258696f, -0.01185335f, -0.02751959f, 0.03497723f, 0.01447854f, 0.01710288f, 0.04128522f, -0.06491669f, 
    -0.02184180f, -0.00656487f, -0.00748636f, -0.02143446f, 0.04305156f, -0.03080891f, -0.02734465f, -0.03442347f, 
    -0.04475002f, -0.02017600f, 0.02143484f, 0.02762857f, 0.00565309f, 0.02838036f, -0.06035735f, -0.02734960f, 
    0.05538587f, -0.00804835f, 0.02348017f, -0.04758286f, -0.04933939f, 0.00558428f, 0.04050809f, -0.01019805f, 
    0.03094089f, -0.03762666f, 0.00700041f, 0.01400207f, 0.01415055f, -0.02675772f, 0.00570747f, -0.06490075f, 
    -0.03367427f, 0.03179792f, 0.01316431f, -0.02146371f, -0.03785982f, 0.02930633f, -0.03110185f, 0.01917675f, 
    -0.00190570f, 0.02210787f, -0.02719564f, -0.01559646f, -0.04958189f, -0.05955737f, 0.04466737f, -0.01910329f, 
    -0.00622199f, -0.05998899f, -0.06911323f, -0.06922495f, -0.05621897f, -0.02955666f, 0.03089546f, -0.02919133f, 
    0.04394325f, -0.06698970f, -0.00061683f, -0.06046868f, -0.06409580f, -0.04848644f, 0.00171403f, -0.02898422f, 
    0.05187145f, 0.02738565f, -0.01079320f, -0.03953616f, 0.03359694f, -0.04680138f, 0.04475468f, 0.04968289f, 
    -0.05380859f, 0.04617867f, -0.04863090f, -0.00029999f, -0.01635297f, -0.02794786f, 0.03617259f, 0.02660754f, 
    0.01721392f, -0.02117746f, -0.02014385f, -0.05799688f, -0.04516582f, -0.05494108f, -0.03560835f, -0.07292380f, 
    0.01646456f, 0.00252383f, -0.02637291f, -0.03904785f, -0.05390377f, 0.01536474f, -0.03747807f, -0.03814726f, 
    -0.04738596f, 0.02373175f, 0.02225160f, 0.02485462f, -0.01579437f, -0.00808655f, -0.00341830f, -0.06446033f, 
    0.02573748f, -0.05270820f, 0.01406139f, 0.01006776f, -0.02980743f, -0.05373019f, -0.00154728f, 0.00665707f, 
    -0.24047512f, 0.12171635f, -0.19229195f, -0.09683132f, -0.13972548f, 0.09044533f, -0.18098521f, -0.14942972f, 
    -0.00320864f, 0.17713609f, -0.04213797f, -0.06096750f, -0.04926507f, 0.19262326f, -0.00004634f, 0.10049529f, 
    0.00172323f, 0.03314169f, -0.26059133f, -0.01372505f, -0.03738108f, -0.08795565f, 0.06432424f, 0.09298223f, 
    0.04384023f, -0.09322382f, 0.04660634f, 0.18963216f, 0.04576279f, 0.04965661f, 0.04556222f, 0.01711204f, 
    -0.03565942f, 0.03216885f, -0.11887415f, 0.03549747f, 0.23306060f, 0.17366557f, 0.21805023f, 0.07226693f, 
    -0.10198527f, -0.06530388f, 0.01482606f, -0.04168949f, -0.04300608f, -0.00038862f, -0.05573156f, 0.01209108f, 
    0.03670160f, 0.03309418f, -0.16381729f, -0.05488812f, 0.04783397f, 0.01683525f, 0.08018696f, -0.15832551f, 
    0.00457782f, -0.27960646f, -0.00499165f, -0.04006444f, 0.08034725f, 0.00629418f, -0.06926980f, 0.25439915f, 
    0.06055872f, 0.00958074f, -0.00216667f, 0.09601824f, -0.09565093f, -0.03360983f, 0.08235500f, 0.06275060f, 
    -0.33909944f, 0.04272690f, -0.01881295f, 0.11502329f, 0.02470885f, -0.09231457f, 0.09493568f, -0.00363654f, 
    0.05471034f, -0.13735674f, 0.01554710f, -0.03820290f, 0.04812470f, -0.15294331f, 0.12295979f, 0.13589704f, 
    -0.11540718f, 0.00443035f, -0.10666880f, -0.05422327f, 0.00553008f, 0.05422280f, 0.04687007f, -0.18807249f, 
    -0.04711523f, 0.00417021f, 0.22514662f, 0.05002894f, 0.12881900f, -0.07902247f, 0.05137553f, -0.11684986f, 
    -0.02051817f, -0.10860565f, -0.06205614f, -0.05900644f, 0.29235116f, 0.21501540f, 0.10560565f, 0.04022755f, 
    -0.00841905f, 0.12838112f, 0.07401669f, 0.03334900f, 0.05117349f, 0.00462860f, 0.02448766f, 0.07611132f, 
    0.07123987f, 0.11798402f, -0.19622560f, -0.06790572f, 0.05574941f, 0.11932444f, -0.03796775f, 0.06530454f, 
    -0.10284685f, 0.08786467f, -0.07272319f, -0.02511816f, -0.23673467f, 0.04034361f, 0.08044221f, 0.01395043f, 
    0.37268490f, 0.03045799f, -0.01641850f, -0.06271496f, 0.04057018f, 0.16741775f, 0.11532009f, 0.08198813f, 
    0.07281553f, 0.04414350f, 0.18987548f, 0.02058398f, 0.09058012f, -0.07124017f, 0.02751482f, 0.02966576f, 
    -0.11518434f, -0.07072358f, -0.17975722f, -0.02375576f, -0.08658380f, 0.09924170f, 0.07659756f, -0.01688789f, 
    -0.00818422f, 0.08774173f, 0.05462815f, 0.13166082f, -0.01549817f, -0.01172264f, -0.03796357f, -0.00860668f, 
    0.00783850f, 0.03566597f, 0.10728290f, -0.33436823f, -0.01871499f, -0.13983639f, -0.16624388f, -0.00272375f, 
    -0.03680576f, -0.21045578f, 0.08170222f, -0.12400753f, -0.27838674f, -0.36705101f, -0.03634024f, 0.09753745f, 
    -0.04378977f, -0.05697047f, -0.02958626f, -0.08423696f, -0.08144554f, 0.15472898f, 0.28137594f, 0.11455316f, 
    0.07258034f, -0.08522569f, 0.01677315f, 0.10861121f, -0.06051464f, 0.04400500f, 0.18997742f, 0.13223679f, 
    0.05271849f, -0.04759556f, 0.04250794f, -0.08342531f, 0.03929105f, 0.01264014f, 0.02961524f, 0.27148959f, 
    0.31284767f, 0.12275162f, -0.06136231f, 0.01067094f, -0.00213775f, 0.10725501f, 0.00706762f, 0.07420377f, 
    -0.21572353f, 0.05552985f, -0.12328281f, -0.11833492f, 0.05832998f, 0.05105898f, -0.00144792f, 0.01602184f, 
    -0.01800692f, 0.27750647f, 0.04662451f, 0.12253539f, -0.01094382f, 0.13660309f, 0.00927409f, 0.03020777f, 
    -0.12932211f, 0.11229891f, 0.09064844f, 0.05594279f, 0.04853409f, 0.00118546f, -0.18635984f, -0.08067502f, 
    -0.04212430f, -0.11569565f, 0.09525356f, 0.07551736f, 0.23233961f, -0.13154142f, -0.06167408f, -0.01570696f, 
    -0.11729717f, -0.01587306f, -0.02863590f, 0.06994557f, -0.16571446f, -0.04992503f, -0.07599963f, -0.02359316f, 
    0.03296612f, -0.02054847f, -0.07316116f, 0.06851821f, -0.04673213f, 0.09328338f, 0.10045546f, 0.03042190f, 
    -0.05808476f, 0.02202693f, 0.00476456f, -0.03320630f, 0.04232501f, 0.09079336f, 0.08421491f, 0.09425972f, 
    -0.13038117f, 0.06356656f, 0.07902589f, 0.12141535f, 0.10786048f, -0.10060383f, -0.01538926f, -0.00222442f, 
    -0.04580455f, -0.01840057f, 0.01729831f, 0.05499688f, -0.01579638f, -0.00827864f, 0.10328060f, 0.11194050f, 
    -0.01039832f, 0.01525386f, -0.03039667f, -0.03514789f, 0.01849486f, 0.00926401f, 0.01436310f, -0.00820762f, 
    0.04714490f, -0.05100221f, -0.03678177f, -0.01605206f, 0.00853589f, 0.00865697f, -0.00600722f, 0.02070640f, 
    -0.04956088f, 0.04237463f, 0.02369419f, -0.02227861f, -0.05649160f, 0.03801154f, 0.00650321f, -0.03472704f, 
    0.02271031f, -0.00834599f, 0.03666524f, -0.04066862f, -0.02530092f, -0.03200680f, -0.02664146f, -0.04800355f, 
    0.04842065f, 0.01244452f, -0.03885960f, 0.01290150f, 0.00824422f, -0.04177843f, -0.02474048f, -0.03984275f, 
    -0.06040956f, 0.00371010f, -0.05371645f, -0.05867239f, 0.04026485f, 0.03458503f, 0.01706958f, 0.03682056f, 
    -0.02501978f, -0.00501501f, -0.03337421f, -0.05047579f, 0.01795744f, 0.02967025f, 0.00820572f, -0.04729715f, 
    0.03893865f, 0.03783917f, 0.01588601f, -0.01198858f, -0.01488675f, 0.01868121f, -0.02040491f, 0.04352811f, 
    -0.05942456f, 0.04668500f, 0.04967100f, -0.03504784f, -0.01732496f, 0.01759999f, -0.00226760f, -0.00080482f, 
    0.01279369f, -0.00345628f, -0.02770227f, -0.01070608f, 0.02527127f, -0.06392697f, -0.03100787f, -0.03218551f, 
    -0.01965152f, 0.01234226f, -0.05462005f, 0.02534447f, 0.02825017f, -0.06732581f, 0.02634768f, 0.05420415f, 
    -0.02646665f, 0.02078536f, 0.00559793f, -0.05278038f, -0.05172420f, 0.00519186f, -0.01757229f, -0.01922715f, 
    -0.03628035f, -0.01979094f, -0.03706513f, -0.06098155f, -0.02614687f, -0.02573309f, -0.02095979f, -0.03230891f, 
    -0.03609716f, 0.04903947f, -0.01187715f, 0.00555439f, 0.00310773f, -0.04090732f, 0.01281956f, 0.01343748f, 
    0.00388499f, 0.04194816f, -0.01787846f, -0.01655122f, 0.03420330f, 0.02323534f, 0.02825232f, -0.02073374f, 
    -0.03858005f, 0.04606980f, 0.01353867f, -0.00736184f, 0.00078207f, 0.00259592f, -0.02727441f, -0.03674105f, 
    -0.03259337f, -0.02049101f, 0.06170824f, 0.00400075f, -0.02509107f, -0.01467151f, -0.02121701f, 0.03283991f, 
    -0.00521951f, 0.03934006f, 0.01232155f, 0.03767323f, -0.03884029f, 0.03995746f, 0.00478228f, -0.04982106f, 
    0.03503117f, -0.05027683f, 0.01842655f, -0.02656037f, 0.00714930f, -0.02598482f, 0.02915322f, 0.00338685f, 
    -0.02337823f, 0.02035183f, -0.05436721f, -0.01274601f, -0.04363736f, 0.01365081f, -0.04855805f, -0.03850006f, 
    -0.06167611f, -0.06253906f, -0.06057104f, 0.01808893f, 0.00327678f, -0.04690919f, -0.05980041f, -0.03313880f, 
    0.02816909f, -0.03671696f, 0.02297258f, -0.00653492f, 0.01326256f, -0.00777694f, 0.02842192f, 0.01294831f, 
    0.00746518f, -0.02763604f, 0.03193356f, 0.00882132f, 0.03356510f, -0.03918009f, -0.03062713f, 0.00450063f, 
    -0.01480283f, -0.01557974f, 0.01553887f, -0.06268241f, 0.03393997f, -0.02998201f, -0.03917108f, -0.02751507f, 
    0.03797787f, 0.03440595f, -0.04271105f, -0.02292897f, -0.06331501f, -0.03848631f, 0.03124190f, -0.03080819f, 
    -0.01013722f, -0.01473495f, -0.02735351f, 0.01726433f, 0.01782212f, 0.01143296f, -0.06466842f, -0.03034380f, 
    -0.01866973f, -0.06018274f, 0.00630041f, -0.01757352f, 0.00353503f, -0.04553511f, -0.03947264f, -0.02703849f, 
    -0.02583917f, -0.03664537f, -0.06564746f, -0.00078405f, 0.01574329f, -0.03260173f, -0.01355725f, 0.04222749f, 
    -0.05452110f, -0.05258339f, 0.00984423f, -0.01486890f, -0.06598273f, 0.04191311f, -0.05499400f, 0.04161492f, 
    -0.04521548f, -0.01101240f, 0.03411506f, 0.00629363f, 0.03093111f, 0.03414202f, -0.00791531f, -0.01099810f, 
    -0.05373935f, -0.01987709f, 0.03321065f, 0.00183848f, 0.02797816f, 0.01558206f, -0.01990987f, 0.02065119f, 
    -0.04208100f, 0.00921667f, -0.06023325f, 0.02475117f, -0.02047141f, -0.06175776f, -0.03799298f, 0.00437006f, 
    -0.00648086f, -0.01490138f, 0.00587207f, -0.05470346f, -0.04966359f, 0.01096160f, -0.01804903f, 0.03599840f, 
    -0.05921397f, 0.03512273f, -0.04410943f, -0.05896731f, -0.04111455f, 0.03887063f, -0.03217474f, -0.02785954f, 
    0.01359845f, -0.02418585f, 0.02730165f, 0.03259281f, 0.04209874f, 0.02625479f, -0.00844344f, -0.03125729f, 
    0.01784858f, -0.06531207f, -0.04689650f, 0.01496197f, 0.01363026f, -0.03731854f, -0.02299280f, -0.05922065f, 
    0.04282078f, -0.06073683f, -0.05804441f, -0.02072769f, -0.00652217f, -0.02704766f, -0.05244900f, -0.06347016f, 
    -0.03540251f, -0.05704055f, 0.01611175f, 0.04435727f, -0.03636985f, -0.04746537f, -0.02816407f, 0.03795816f, 
    0.03914218f, -0.01847740f, 0.01764596f, 0.04917559f, -0.05528663f, 0.01423003f, 0.04828957f, -0.03207387f, 
    0.02089924f, -0.03279535f, 0.01466523f, 0.03884852f, -0.06853545f, -0.05533946f, 0.01139053f, 0.03945954f, 
    -0.01000989f, 0.03725534f, -0.04062916f, -0.01311002f, -0.03441185f, 0.03201244f, 0.03380429f, -0.01766818f, 
    0.03261327f, -0.05060025f, -0.04959989f, -0.04094499f, -0.05883111f, -0.05376948f, 0.00870748f, -0.02640551f, 
    -0.04977492f, -0.04428137f, 0.02889466f, -0.06170164f, -0.02386035f, -0.02049066f, 0.02545232f, -0.02915083f, 
    -0.06174408f, -0.00298559f, -0.02943465f, 0.03943865f, 0.01108289f, 0.03913379f, -0.05034234f, -0.04284315f, 
    -0.03682946f, -0.01326961f, -0.04032192f, 0.04976020f, 0.02218678f, 0.03565346f, -0.03107077f, -0.03356579f, 
    0.00602140f, 0.01853956f, 0.03366664f, 0.01496660f, -0.00146816f, -0.06431717f, -0.02224713f, -0.05043206f, 
    0.02952620f, -0.06680032f, -0.02165397f, -0.02159689f, 0.02160445f, 0.04266958f, -0.00753321f, 0.03356689f, 
    -0.01600736f, -0.04660421f, -0.05539770f, -0.04026368f, 0.00444809f, 0.03797936f, 0.03271255f, -0.05826712f, 
    -0.03705424f, -0.06491068f, 0.04418834f, -0.03463260f, -0.06660207f, 0.00560312f, 0.02984293f, -0.03263112f, 
    -0.05050503f, -0.05380501f, -0.00869547f, -0.02349691f, -0.03291125f, -0.01762352f, 0.00588124f, -0.03069163f, 
    0.00929764f, -0.04382928f, 0.03810101f, 0.02185555f, 0.03863808f, 0.00001254f, -0.05681029f, 0.01433399f, 
    0.03112767f, 0.02834486f, -0.04742088f, 0.02331778f, -0.02919088f, 0.03197974f, -0.03680647f, 0.01462884f, 
    -0.04874430f, -0.00979312f, 0.00400378f, -0.00998544f, 0.01900859f, 0.03513143f, -0.01072829f, -0.04170670f, 
    -0.01577064f, 0.00260665f, -0.06768495f, -0.05256483f, -0.00756375f, 0.02969234f, 0.02253786f, 0.03943869f, 
    -0.03312208f, 0.02273329f, 0.00070856f, -0.03689044f, -0.00978214f, 0.00672294f, -0.05876611f, -0.02965911f, 
    0.00323701f, -0.05262563f, 0.04464515f, 0.00793432f, 0.01572223f, -0.03752835f, -0.01437825f, 0.01931815f, 
    -0.02861560f, -0.04177379f, 0.00860679f, -0.06384021f, -0.05529156f, 0.02167328f, -0.01901301f, -0.03180352f, 
    -0.04254875f, 0.00928178f, 0.01836550f, -0.06198089f, 0.04182782f, -0.01677801f, -0.01825419f, -0.02831170f, 
    -0.05501297f, 0.00937221f, -0.06273772f, -0.05702758f, -0.05655904f, 0.03066367f, -0.02446105f, 0.03521498f, 
    -0.01599823f, -0.03313878f, 0.00771589f, 0.03290192f, 0.00629565f, -0.02440239f, -0.02085978f, 0.03646097f, 
    -0.03467893f, -0.06248541f, -0.04986717f, 0.01446128f, 0.02131619f, 0.00650009f, -0.04699462f, 0.03416492f, 
    0.01901914f, 0.04545322f, -0.03721733f, -0.01238927f, 0.04458600f, -0.01245217f, -0.02586651f, -0.05228437f, 
    -0.01267386f, 0.00287016f, 0.04202474f, -0.00861790f, 0.01696062f, 0.01135400f, -0.04102414f, -0.02774106f, 
    0.04564652f, 0.03166273f, -0.05602457f, -0.05903921f, 0.03308999f, 0.04126476f, 0.00020875f, 0.01972829f, 
    -0.02573251f, -0.03212001f, -0.06273638f, -0.04616902f, 0.00774962f, -0.00654431f, 0.00916896f, 0.03637516f, 
    -0.01514439f, 0.00449884f, 0.01955415f, 0.05122569f, -0.00230323f, -0.03731355f, 0.02826379f, -0.04495759f, 
    -0.03335878f, 0.01373715f, 0.01098896f, 0.04209058f, 0.00551879f, 0.00759006f, -0.03967094f, 0.03579349f, 
    -0.00590949f, -0.01818777f, -0.05673616f, 0.04153154f, 0.00989824f, 0.04705317f, -0.05410758f, 0.01545869f, 
    -0.00190326f, 0.01182768f, 0.00109715f, 0.00778690f, 0.01198816f, -0.05979392f, 0.03373797f, -0.00548532f, 
    0.03221528f, -0.02866960f, 0.01651691f, -0.00157025f, -0.03512292f, -0.03390482f, 0.00923657f, 0.04946669f, 
    0.00823691f, 0.04960197f, -0.02193612f, 0.04472268f, -0.05005024f, 0.02635942f, 0.00293048f, 0.01100444f, 
    -0.03592681f, -0.03546244f, 0.03249626f, 0.02647559f, 0.01620001f, -0.05298118f, 0.02409391f, -0.06876422f, 
    0.02922482f, 0.00805885f, 0.00321893f, 0.11890098f, -0.07099419f, 0.03298638f, 0.04245836f, -0.06629974f, 
    -0.00374512f, 0.28843236f, -0.05948155f, -0.05099891f, -0.05659498f, -0.08758631f, -0.13493778f, -0.12063322f, 
    -0.01462265f, 0.09339175f, 0.04549320f, -0.22688617f, 0.01783903f, 0.00341479f, 0.04503157f, -0.00397998f, 
    0.03122525f, 0.10221265f, -0.01683913f, -0.21418324f, -0.19819194f, -0.14867574f, -0.06037921f, -0.10532237f, 
    -0.12600014f, -0.05477577f, -0.11317725f, -0.04598629f, -0.20381337f, 0.03377613f, -0.26590362f, -0.02141447f, 
    0.09675757f, 0.07310796f, 0.12229328f, 0.06911103f, -0.01394015f, 0.26107311f, -0.02168102f, -0.08477280f, 
    0.01960709f, 0.11019348f, 0.02351330f, -0.02889927f, -0.06608436f, -0.05894914f, 0.31904572f, -0.34727469f, 
    0.00767107f, -0.02695237f, -0.04901573f, -0.04283745f, -0.05747624f, 0.08133003f, 0.02811011f, 0.10856184f, 
    -0.01915029f, -0.06808641f, 0.02943033f, -0.15177521f, -0.11081245f, -0.07873329f, -0.01564421f, 0.05855648f, 
    0.02532601f, 0.09680004f, -0.11749977f, 0.15717404f, -0.06057374f, 0.04789437f, -0.02274841f, 0.02874322f, 
    -0.04876089f, 0.17321211f, 0.12211707f, 0.03381872f, -0.02274233f, -0.00692280f, -0.06585027f, 0.09010089f, 
    -0.00265784f, 0.01376950f, -0.11415150f, -0.05778343f, 0.00782931f, 0.10845380f, 0.16025819f, -0.11052565f, 
    0.08163321f, -0.02098422f, 0.03571927f, 0.04110153f, 0.03996922f, 0.01023319f, -0.00873744f, 0.01704407f, 
    0.13562784f, 0.06430659f, 0.03957004f, 0.11700029f, 0.04041417f, 0.03317225f, 0.00040353f, -0.20854156f, 
    -0.08298480f, -0.05161597f, 0.08367503f, 0.05031399f, -0.07128628f, -0.22547954f, -0.13299797f, -0.05682360f, 
    0.08034591f, -0.04457067f, -0.10639124f, -0.03036763f, 0.05248977f, 0.05211205f, 0.08534085f, -0.09925164f, 
    -0.11881639f, 0.02570893f, 0.03534087f, 0.12912373f, 0.19239551f, -0.08108047f, 0.12817515f, 0.14942816f, 
    -0.08450161f, 0.01271552f, -0.17715971f, -0.07845153f, 0.06044976f, -0.12337161f, 0.11382629f, -0.06037026f, 
    -0.21137771f, 0.15950102f, -0.13285123f, 0.11749682f, 0.10678130f, 0.06620461f, 0.06004497f, 0.01804024f, 
    0.03556550f, 0.15810749f, -0.09731087f, -0.06942090f, 0.09008403f, 0.09258643f, 0.04360435f, 0.04130216f, 
    -0.07761180f, -0.01115066f, -0.25206944f, -0.16059844f, -0.06772577f, 0.03527892f, -0.04432381f, -0.07452243f, 
    -0.05559067f, 0.02030457f, 0.00579231f, 0.33606496f, 0.09389937f, 0.10116109f, 0.25043899f, 0.14518820f, 
    0.10190079f, -0.03426830f, -0.00744203f, 0.16122608f, 0.27676964f, 0.31385624f, -0.04082145f, 0.04499856f, 
    -0.04924064f, 0.10034391f, 0.01910473f, 0.00814946f, -0.11259671f, -0.02765021f, -0.02398535f, 0.01840649f, 
    -0.16617474f, -0.00664166f, 0.09373191f, 0.05467987f, 0.01130805f, 0.03156550f, -0.23870870f, 0.18909723f, 
    -0.11346680f, 0.01995170f, 0.08486850f, 0.06181006f, -0.07443918f, 0.07804307f, -0.07198614f, -0.09797081f, 
    0.07688435f, -0.08646517f, -0.31989574f, -0.06220111f, 0.04876801f, -0.13817187f, 0.00627463f, -0.03731311f, 
    0.11101942f, -0.10807683f, -0.03188439f, 0.10974199f, 0.14635362f, 0.00644806f, -0.15921794f, 0.03871463f, 
    0.07777742f, 0.11090646f, 0.07262220f, -0.00305262f, -0.21189195f, -0.16415852f, 0.08021501f, -0.02511866f, 
    -0.00651595f, 0.02090452f, -0.33906552f, -0.17648229f, 0.21731471f, 0.08126356f, -0.01755787f, -0.04362807f, 
    0.24672464f, 0.19321649f, 0.05197022f, 0.18942186f, 0.03092222f, -0.16646582f, 0.01214030f, -0.05958213f, 
    0.06815737f, 0.12415274f, 0.14260441f, -0.01348642f, 0.31728664f, 0.15624940f, -0.14989841f, -0.04315959f, 
    -0.02501290f, 0.08322234f, -0.04574525f, 0.03658732f, 0.00828052f, 0.01823467f, -0.07236604f, -0.06456561f, 
    0.05465113f, 0.02511146f, -0.05894018f, 0.00442347f, 0.15130377f, -0.01498562f, 0.03327727f, 0.14564660f, 
    0.01713618f, -0.17172401f, 0.01418524f, -0.02673813f, -0.00302558f, 0.01753817f, 0.01752672f, 0.03046346f, 
    -0.24147964f, 0.11604707f, 0.27857855f, 0.11433085f, 0.03736816f, -0.10122183f, -0.02363271f, -0.00533862f, 
    -0.07270513f, 0.22711717f, -0.26799259f, 0.02155708f, 0.16424115f, 0.09946028f, -0.03676780f, 0.03504611f, 
    -0.12261205f, 0.01161021f, -0.22664766f, -0.14390472f, 0.04114244f, -0.07098539f, 0.11520854f, 0.04576522f, 
    0.02882467f, -0.11820565f, 0.01667919f, 0.03252190f, 0.02498485f, -0.11753458f, -0.04112083f, 0.13684259f, 
    -0.05705301f, -0.03557771f, -0.06752840f, 0.28222677f, 0.19577661f, 0.03979269f, -0.00537479f, -0.01219340f, 
    0.10925809f, 0.00493484f, 0.12857252f, -0.02464000f, -0.11543845f, 0.02533048f, 0.12997505f, 0.07573180f, 
    0.05689009f, 0.03189710f, -0.02607355f, -0.03117550f, 0.01467306f, 0.20208305f, -0.24516298f, -0.09529447f, 
    -0.04165825f, 0.05950548f, -0.00507540f, 0.00196291f, -0.02415641f, 0.02116071f, 0.13144533f, -0.05705159f, 
    -0.01284671f, -0.05980674f, 0.00821767f, -0.01613133f, -0.08536921f, 0.05023227f, -0.14048892f, 0.11056259f, 
    -0.24669239f, 0.07999673f, -0.06455193f, 0.04855918f, 0.08489855f, 0.09583142f, 0.17071991f, -0.03761144f, 
    -0.06711958f, 0.21510732f, -0.03937615f, -0.06146299f, -0.03374119f, -0.11399000f, 0.19284013f, -0.12986228f, 
    0.01944800f, -0.14594415f, 0.01983674f, -0.02457174f, -0.03596746f, -0.05412739f, 0.03544897f, 0.05421733f, 
    -0.06134343f, -0.00472015f, -0.16475381f, 0.12176157f, 0.04317478f, 0.12342940f, 0.04618524f, 0.12371679f, 
    -0.02731483f, -0.02708960f, 0.14124399f, -0.00587317f, -0.15602513f, -0.20557983f, 0.18354668f, 0.15400083f, 
    0.00965450f, -0.07555147f, -0.21827531f, -0.01199147f, 0.11136770f, 0.21292210f, 0.04279108f, -0.03372171f, 
    0.05507289f, -0.05312160f, 0.05783947f, -0.05014454f, -0.01043948f, 0.13468337f, 0.10563858f, 0.04825046f, 
    -0.00560165f, -0.06431990f, 0.07365967f, 0.03318845f, 0.04380056f, 0.13170007f, -0.05642864f, -0.28525636f, 
    0.05142865f, -0.04664296f, 0.08335695f, -0.10991459f, 0.00940254f, 0.13754629f, -0.06270796f, 0.15638964f, 
    0.18368328f, 0.06053851f, 0.10771233f, -0.07463235f, 0.05154119f, 0.04156985f, 0.02022862f, 0.03726275f, 
    -0.23788883f, 0.01046667f, -0.17980866f, 0.06462058f, 0.14625081f, 0.02917974f, 0.01667313f, -0.01054129f, 
    -0.02131354f, -0.10031396f, -0.13317885f, 0.04697791f, -0.07170241f, 0.14911927f, -0.07686467f, 0.06947391f, 
    0.15286484f, -0.02349242f, -0.11163010f, -0.16323341f, -0.09710386f, -0.05846709f, 0.04071024f, 0.18401304f, 
    -0.11411420f, -0.05273784f, 0.01328874f, 0.05227261f, 0.09223714f, 0.03670740f, -0.03594764f, 0.02287602f, 
    0.00975168f, 0.06695116f, -0.07732692f, -0.21673569f, 0.25969532f, 0.03693954f, -0.05192327f, 0.00027496f, 
    0.07744343f, -0.09788876f, 0.01622244f, -0.00371802f, 0.04823837f, 0.02853289f, 0.12876688f, -0.03271800f, 
    -0.11535229f, -0.14122090f, -0.13044702f, -0.00491537f, -0.02059799f, 0.10435244f, -0.09906249f, -0.43613324f, 
    0.01246194f, -0.11917327f, -0.17748046f, 0.07609137f, 0.00809650f, 0.03131380f, 0.05591178f, 0.40121594f, 
    -0.01369082f, 0.07805572f, 0.01593908f, -0.13271059f, -0.04755509f, 0.04573475f, 0.04435372f, -0.07993154f, 
    -0.06737638f, 0.09085393f, -0.17357631f, 0.06581675f, 0.03970860f, 0.07939638f, 0.03494988f, 0.07665796f, 
    -0.02036598f, 0.49562067f, 0.18077306f, 0.16287027f, -0.06049401f, -0.21684225f, -0.11709408f, 0.06607512f, 
    -0.05588058f, -0.08548795f, -0.21891339f, 0.06037560f, -0.16353421f, 0.12974727f, 0.07499658f, 0.16848661f, 
    -0.17252851f, 0.08573748f, 0.04841312f, 0.04314359f, 0.09289781f, -0.13614064f, -0.16573747f, -0.10093191f, 
    -0.03641596f, 0.09512873f, 0.01729240f, -0.10254257f, -0.12251808f, -0.26467150f, -0.08052965f, -0.08818951f, 
    -0.04912087f, -0.11809753f, 0.02903600f, 0.02552578f, -0.04293209f, 0.34210294f, -0.02618334f, 0.23173432f, 
    -0.06088163f, -0.09482282f, 0.01144139f, -0.04505876f, 0.06623495f, 0.04735228f, 0.34859541f, 0.04675240f, 
    0.02558688f, -0.08913771f, 0.03219746f, 0.08369206f, -0.03083535f, -0.05439680f, -0.03473983f, -0.00870563f, 
    -0.01174523f, -0.24809618f, 0.03486397f, -0.06762992f, 0.17253226f, 0.01385606f, -0.07506893f, 0.07159456f, 
    -0.05942830f, 0.00717738f, -0.07231218f, -0.22567129f, -0.03255975f, 0.09842074f, 0.03219850f, 0.10086984f, 
    -0.13592093f, -0.11435258f, -0.08043004f, -0.01029433f, 0.19062254f, -0.04963764f, -0.09601970f, -0.04151512f, 
    -0.09540249f, 0.13068235f, -0.39268354f, 0.00585097f, -0.05061654f, -0.00890910f, 0.01474732f, 0.01678211f, 
    -0.07114355f, -0.07213809f, -0.05696878f, 0.14960273f, 0.07734300f, 0.08642232f, -0.06165314f, -0.17370035f, 
    0.06757370f, 0.14173231f, 0.01235391f, -0.00086881f, -0.01636723f, 0.00673957f, 0.05055100f, 0.01410614f, 
    -0.00078385f, -0.02157087f, -0.06071052f, 0.04258578f, -0.00399959f, -0.13813344f, 0.00296663f, -0.07508944f, 
    0.10370707f, -0.10867495f, 0.03343812f, 0.03901795f, 0.05486777f, -0.04055672f, -0.05034249f, -0.06756599f, 
    0.00981102f, -0.03617279f, -0.14367703f, -0.04069356f, 0.01565681f, 0.01265190f, 0.10361905f, -0.15103260f, 
    -0.01193734f, 0.17467453f, 0.02454869f, -0.04522797f, -0.03926376f, -0.01292473f, 0.14256284f, 0.00824787f, 
    0.29969305f, 0.00868796f, 0.01045258f, 0.13760336f, 0.11442886f, 0.07428028f, 0.02408583f, -0.03348462f, 
    -0.01984304f, -0.02733822f, -0.15951499f, 0.10468013f, 0.03709419f, 0.04749091f, 0.18586603f, 0.13441162f, 
    0.14382693f, -0.07811259f, 0.14493339f, -0.01065076f, 0.05881138f, -0.04613490f, -0.05868509f, 0.13290712f, 
    0.06544840f, -0.01417638f, 0.11202022f, -0.19771229f, -0.02358315f, 0.02498261f, 0.13077880f, 0.02463444f, 
    -0.15164281f, -0.12606563f, 0.01811934f, 0.05840805f, 0.08263584f, 0.17869039f, -0.23598801f, 0.01766381f, 
    0.07927920f, 0.21368517f, -0.02597234f, -0.11050010f, 0.10937451f, -0.05352409f, 0.06680907f, 0.28017944f, 
    -0.19447167f, -0.01767134f, 0.08789521f, 0.18351662f, -0.01544958f, 0.00376466f, -0.09953460f, -0.03202984f, 
    -0.03505289f, 0.02103953f, 0.09938815f, -0.12414207f, -0.01549053f, -0.06548581f, 0.06223638f, 0.15075445f, 
    0.05295916f, -0.40004018f, -0.08351224f, 0.08089826f, 0.12141096f, -0.06610122f, -0.14133821f, 0.06048178f, 
    -0.08425237f, -0.12961149f, -0.15256192f, 0.05074904f, 0.07129424f, 0.05896678f, -0.13981655f, 0.01767522f, 
    -0.09480248f, -0.04457111f, 0.03938330f, 0.09442948f, -0.11299694f, 0.03347135f, -0.15495922f, -0.04819922f, 
    0.00973399f, 0.07996438f, -0.15823084f, 0.03951443f, 0.23823558f, 0.10745212f, 0.11080463f, 0.27706537f, 
    0.11164255f, -0.08364265f, 0.02200608f, 0.07615907f, 0.16338214f, 0.15700014f, -0.30753374f, -0.19079582f, 
    -0.09277993f, -0.10817410f, 0.05763503f, 0.16588411f, -0.16763733f, -0.18195906f, 0.10512979f, 0.07011839f, 
    0.02773229f, -0.03063036f, 0.03532808f, 0.18190937f, 0.03721631f, 0.16151533f, 0.23752204f, -0.12404849f, 
    0.07188208f, -0.06600456f, 0.01143552f, -0.01687527f, -0.10084778f, 0.04059358f, -0.26152015f, -0.10149186f, 
    0.00586165f, 0.10313419f, -0.05524162f, -0.10543693f, -0.02531668f, -0.01181535f, 0.05227248f, 0.12559924f, 
    0.08564717f, -0.02812699f, 0.09949441f, -0.05727307f, 0.09875707f, 0.06645607f, 0.08559466f, -0.04426525f, 
    -0.08140448f, -0.04788512f, 0.25666252f, -0.07885633f, 0.02011644f, 0.03308686f, 0.07321006f, -0.03377039f, 
    0.04231865f, 0.21574236f, 0.10828771f, 0.19420211f, 0.11482473f, 0.02247951f, -0.00952566f, -0.00917462f, 
    -0.07691983f, 0.09608839f, -0.02046311f, -0.08704314f, 0.00335231f, -0.16173118f, -0.00097849f, -0.01486821f, 
    0.05130155f, -0.09724227f, -0.15753222f, 0.01527861f, 0.14551091f, -0.23439963f, -0.00238185f, 0.01605982f, 
    0.09176094f, 0.15105897f, 0.04307250f, 0.09326364f, -0.31157193f, -0.10641668f, 0.01874658f, 0.05011202f, 
    0.00577239f, -0.16936195f, 0.06432810f, 0.04369703f, 0.07809152f, -0.11102138f, 0.01450974f, -0.00918166f, 
    0.04851045f, 0.04842076f, 0.05050994f, 0.03348363f, -0.06609743f, 0.02686259f, -0.28736234f, -0.10453019f, 
    -0.18266168f, 0.06258786f, 0.03584537f, 0.06265990f, 0.07760659f, 0.00787195f, -0.08419847f, -0.00218566f, 
    0.06745838f, 0.15420768f, -0.12372647f, 0.04625167f, -0.04307269f, 0.15426174f, -0.03713517f, 0.10317422f, 
    0.05972355f, -0.16634032f, -0.13376462f, 0.00057473f, -0.04767451f, -0.03868060f, 0.02884991f, -0.00772049f, 
    0.13485755f, -0.06901586f, -0.00815277f, -0.09407288f, -0.03355398f, 0.19732626f, 0.13423759f, 0.01592294f, 
    -0.17222497f, 0.05957324f, 0.07993373f, -0.08063263f, -0.01982326f, -0.03549604f, 0.00287914f, -0.04245438f, 
    0.11310446f, 0.08990198f, 0.12693073f, 0.00586976f, 0.00754232f, -0.01723054f, -0.01227070f, -0.04120168f, 
    -0.31894448f, -0.08944397f, 0.11931854f, 0.02518118f, 0.14613639f, 0.12207398f, -0.07134377f, -0.06300268f, 
    -0.03464908f, -0.14131588f, 0.08280564f, 0.01971925f, 0.05024704f, -0.09998080f, -0.05846982f, -0.14393392f, 
    0.02022252f, 0.05586885f, 0.17755044f, 0.07859418f, -0.11850379f, -0.16222383f, -0.13471249f, -0.15769394f, 
    -0.08952320f, 0.05461865f, 0.07474456f, -0.00780263f, 0.04015162f, 0.01553826f, 0.13638321f, -0.05320743f, 
    -0.11724332f, -0.10834394f, 0.11168163f, -0.09431335f, 0.02971961f, 0.10669790f, -0.14068925f, -0.09757020f, 
    -0.08482166f, -0.03645088f, 0.14074080f, 0.17257640f, -0.12435786f, -0.03397856f, 0.06741688f, -0.01101571f, 
    0.01119924f, -0.00103973f, 0.09434426f, 0.06078390f, 0.01194205f, 0.07400995f, -0.06077336f, 0.00686111f, 
    -0.00102707f, -0.11122629f, 0.03750335f, -0.02537462f, 0.12966424f, 0.05861461f, -0.01308642f, -0.09004479f, 
    -0.04539756f, 0.00520310f, -0.03018481f, 0.05212029f, -0.00532966f, -0.08340303f, 0.03551850f, -0.07655957f, 
    0.06856117f, 0.00300554f, 0.03780645f, 0.07313601f, 0.09567033f, -0.10665142f, 0.13197677f, -0.00224105f, 
    0.03939950f, -0.19578972f, 0.12102317f, -0.11378985f, -0.01471683f, 0.10411815f, 0.01722590f, 0.02200641f, 
    -0.02353061f, -0.06800777f, -0.03236231f, 0.10520674f, 0.04601841f, -0.13318913f, -0.04258515f, -0.09728543f, 
    -0.15638846f, -0.02566750f, 0.06557991f, -0.00985821f, -0.16234267f, -0.00630492f, -0.05248517f, 0.13455333f, 
    0.11171982f, -0.06407811f, 0.01278595f, -0.05098693f, -0.18208386f, 0.04182936f, 0.01577521f, -0.03598211f, 
    0.00044144f, 0.05057387f, 0.04319623f, 0.00731352f, -0.11902669f, 0.06504668f, 0.19694456f, -0.01654297f, 
    -0.10210318f, -0.29296938f, -0.07276544f, 0.04205438f, -0.02426371f, 0.08034152f, 0.03843041f, -0.14851351f, 
    -0.14654411f, -0.09799337f, 0.13007636f, 0.07483693f, 0.00140856f, 0.04599940f, 0.03135781f, -0.16174962f, 
    -0.19310448f, 0.06506879f, 0.13956791f, -0.07408948f, -0.20335594f, 0.00649157f, 0.05646676f, 0.02834368f, 
    0.21506648f, -0.05020753f, -0.12353138f, 0.15864368f, -0.07559832f, 0.04207100f, -0.06568119f, 0.09387758f, 
    -0.01371172f, 0.16560419f, 0.05701819f, -0.01185732f, -0.02714009f, 0.18170078f, -0.08636590f, -0.05668559f, 
    0.05989870f, 0.06949347f, -0.06205985f, 0.16053325f, -0.06152900f, -0.09445574f, 0.02965162f, 0.19251108f, 
    0.16924258f, 0.02469683f, 0.03274030f, 0.04200789f, 0.00133511f, 0.01103101f, -0.02177815f, -0.03551875f, 
    -0.04768831f, 0.05956637f, -0.21192861f, -0.05842594f, 0.00119233f, 0.00935437f, -0.03897650f, -0.03092773f, 
    -0.00101029f, -0.12554598f, 0.05195671f, -0.02252893f, -0.01734420f, 0.16696480f, -0.14921652f, -0.07539818f, 
    -0.09029000f, -0.09980372f, 0.01062964f, -0.03375494f, -0.09932914f, 0.07681569f, -0.05605971f, -0.00286705f, 
    0.00669519f, -0.02770146f, -0.07974939f, 0.01375545f, 0.05900744f, 0.13988003f, -0.11243951f, -0.29592046f, 
    -0.04193588f, 0.02987784f, 0.22049761f, 0.05603680f, 0.07498694f, -0.10041918f, -0.00798875f, 0.02885938f, 
    -0.13127704f, 0.01683811f, -0.12428223f, 0.04134898f, 0.07799424f, 0.19411904f, -0.06680387f, 0.06835498f, 
    0.06932250f, 0.24311534f, 0.06738509f, 0.07222916f, 0.00424528f, 0.02967364f, -0.05067666f, 0.02225442f, 
    -0.03255075f, -0.08991597f, -0.13099881f, 0.11177930f, 0.03817060f, 0.06267960f, 0.04521594f, 0.11940345f, 
    0.16297273f, -0.00132886f, -0.09433626f, -0.00041563f, -0.03290507f, 0.11399689f, 0.01932717f, 0.06899344f, 
    -0.05969629f, 0.02061417f, 0.07576613f, -0.05888005f, -0.02172529f, -0.06375851f, 0.00643028f, -0.08362222f, 
    -0.17705478f, -0.20762581f, -0.05854868f, -0.04295214f, 0.04228999f, 0.04753514f, 0.00257884f, 0.05917157f, 
    -0.22131376f, 0.26601899f, -0.09709026f, 0.18602878f, -0.01258306f, -0.04682028f, -0.19601281f, 0.02182092f, 
    0.03344374f, -0.01418403f, -0.10601550f, 0.00604344f, 0.06906117f, 0.05164041f, -0.00847240f, -0.00634444f, 
    0.11843702f, 0.13773687f, -0.02614073f, -0.15334211f, -0.00029736f, -0.21232854f, 0.04662941f, 0.02012439f, 
    0.09681194f, -0.13051206f, 0.00026646f, 0.04295051f, 0.23136525f, 0.11594306f, 0.12903580f, 0.00228936f, 
    -0.02170178f, 0.07573006f, -0.07718681f, -0.02744516f, 0.10997481f, 0.23292108f, 0.01584850f, 0.02858422f, 
    0.06803407f, -0.02313644f, 0.04361121f, -0.12891154f, 0.02330231f, -0.01913014f, 0.18739034f, -0.12124774f, 
    -0.16149859f, -0.06318389f, 0.04707793f, -0.04584713f, 0.08410361f, -0.04737066f, -0.07749043f, 0.20621301f, 
    -0.06780117f, -0.01853098f, -0.05465072f, 0.05821070f, -0.08763949f, -0.11659519f, -0.00681183f, 0.06960210f, 
    -0.07002173f, -0.07012873f, -0.05907404f, -0.08476516f, -0.12915270f, 0.00574917f, 0.05974212f, -0.07768916f, 
    0.09116464f, -0.03343863f, 0.03085595f, 0.03953385f, -0.03697773f, 0.03709607f, -0.03102770f, -0.05701402f, 
    -0.01257077f, -0.13002616f, -0.22912009f, -0.15538231f, -0.17172053f, 0.05634720f, 0.08620856f, 0.04311468f, 
    -0.02458490f, 0.02990652f, 0.02141230f, 0.13184099f, 0.24401130f, -0.06313099f, -0.02197674f, 0.02303054f, 
    -0.02057205f, -0.14534970f, 0.06948340f, -0.18982109f, 0.07854962f, 0.07499994f, 0.04599023f, 0.03986176f, 
    0.03980835f, 0.08015057f, -0.04567899f, 0.14826548f, 0.14502832f, -0.03266427f, -0.19703771f, -0.10117196f, 
    -0.00030338f, 0.07010513f, 0.07854934f, -0.08328677f, -0.01346965f, 0.04086675f, -0.00415804f, 0.12007789f, 
    -0.11073902f, 0.11689843f, -0.04981271f, -0.01623639f, 0.11725871f, -0.02884514f, 0.00588754f, 0.00110133f, 
    0.01391184f, 0.00443481f, 0.13837187f, 0.03792202f, 0.01082004f, -0.11554299f, -0.00215257f, 0.08811021f, 
    0.14461845f, -0.03527243f, 0.02829879f, 0.04879043f, 0.11680806f, 0.03282762f, 0.00539922f, -0.04027168f, 
    -0.02978729f, 0.00877564f, -0.27658883f, -0.04286901f, 0.02276190f, -0.01467366f, -0.03464459f, -0.07513670f, 
    -0.07097438f, -0.08890232f, -0.16243406f, -0.24617337f, -0.03706424f, 0.01902891f, 0.05735164f, 0.00634992f, 
    0.04321390f, 0.05718075f, 0.01280153f, 0.00252931f, -0.21799551f, -0.05618379f, 0.00749649f, 0.02340021f, 
    0.09989862f, 0.03158242f, -0.03890103f, -0.16672611f, 0.10819420f, -0.06575640f, -0.06576817f, -0.03931172f, 
    0.01780985f, -0.01328939f, 0.03522552f, -0.02425519f, 0.04555125f, -0.01306479f, 0.07113212f, 0.03152690f, 
    0.01772300f, 0.09323496f, 0.07844256f, -0.03589155f, 0.22873323f, 0.05817468f, -0.01085771f, 0.18565065f, 
    0.04870844f, -0.16616556f, 0.10273981f, -0.03468236f, -0.02996577f, -0.04155999f, 0.08422065f, 0.08822551f, 
    0.05238932f, -0.07729328f, -0.04240630f, 0.04529861f, -0.09748729f, 0.06956813f, 0.05853599f, -0.01023090f, 
    0.13289498f, -0.16450055f, 0.02849608f, 0.10959959f, -0.00957581f, 0.13334057f, -0.03890875f, -0.05800955f, 
    0.04265412f, 0.17325543f, 0.02428046f, 0.04457197f, 0.01707898f, -0.02746227f, -0.04524465f, -0.02077380f, 
    -0.01246919f, 0.12092251f, -0.24197569f, 0.04764305f, -0.06010450f, 0.03621279f, 0.07489678f, -0.01215851f, 
    0.09168138f, 0.19821909f, 0.06559300f, -0.04710102f, 0.11435201f, -0.00248974f, -0.07409164f, -0.11027516f, 
    0.09202942f, 0.08208422f, 0.06612219f, -0.00634912f, 0.15100826f, 0.02029381f, -0.07925168f, 0.00322267f, 
    -0.02337462f, -0.10245386f, 0.08239898f, -0.05347386f, 0.04025142f, 0.11011781f, -0.03037411f, 0.01363137f, 
    0.00050641f, -0.04586802f, 0.11873949f, -0.11327489f, 0.13118763f, 0.00005052f, -0.06402133f, 0.00360139f, 
    0.08289014f, -0.00692395f, 0.07908121f, -0.17877506f, 0.04276512f, 0.05044389f, 0.02711385f, -0.00962184f, 
    -0.31327304f, -0.20224105f, 0.06103897f, -0.06159507f, 0.02813224f, -0.01795888f, 0.01609498f, 0.05564252f, 
    -0.05004190f, -0.02461988f, -0.07231124f, -0.08318292f, -0.11561836f, -0.13311128f, -0.05962662f, 0.05459260f, 
    -0.14788848f, -0.13770121f, -0.06016220f, -0.49713290f, -0.03975550f, 0.05654136f, 0.15636532f, 0.14529669f, 
    -0.08405703f, 0.06398209f, 0.02122832f, 0.16748714f, -0.09622187f, 0.02919070f, -0.00361193f, -0.22423247f, 
    0.01849087f, -0.07919034f, -0.21382281f, 0.07866771f, 0.00268784f, -0.01954048f, 0.17075129f, 0.16095027f, 
    0.01993017f, -0.11025605f, -0.02699131f, -0.02301842f, 0.09496833f, -0.11345258f, -0.01340852f, 0.05887999f, 
    -0.01091558f, 0.05784209f, 0.07407474f, -0.09236649f, 0.10059272f, -0.26772296f, -0.25200698f, -0.20547710f, 
    0.01757640f, 0.07764669f, -0.10376062f, -0.02516123f, -0.06104483f, 0.05378563f, -0.02506923f, -0.00950565f, 
    -0.43138164f, -0.14878696f, -0.07414450f, -0.02270892f, -0.03171823f, 0.04571181f, 0.03445183f, -0.07575125f, 
    -0.26440921f, -0.13908406f, -0.09076465f, 0.00394538f, -0.05249508f, 0.01421079f, -0.00819555f, 0.11459802f, 
    0.11029234f, -0.15461519f, 0.00590521f, -0.05681267f, 0.21788259f, 0.02198789f, -0.08862039f, -0.13203600f, 
    0.01729600f, 0.20686096f, 0.04841768f, 0.12332938f, -0.05279616f, -0.00629819f, -0.07991349f, -0.06368052f, 
    -0.03692978f, -0.11162367f, 0.08401590f, -0.06319176f, 0.04826240f, -0.13752605f, -0.06747212f, -0.03868240f, 
    0.01005719f, -0.03665019f, -0.00936177f, -0.06737734f, -0.18193378f, 0.08336111f, 0.04446356f, 0.06721731f, 
    0.07609750f, 0.07515744f, -0.00266172f, 0.03071650f, 0.07004447f, 0.11661410f, -0.00009791f, 0.01603280f, 
    -0.03032276f, 0.13862453f, 0.06943100f, 0.08584265f, 0.05438506f, 0.03823908f, 0.15061535f, 0.17980145f, 
    -0.00080681f, 0.03686316f, 0.02027954f, 0.10576369f, 0.07942237f, -0.04374280f, 0.04344090f, 0.15515681f, 
    -0.04729736f, -0.08231353f, 0.03121165f, -0.10113535f, -0.01851636f, 0.08207504f, 0.06970517f, -0.02124152f, 
    -0.15307370f, -0.04589643f, -0.07082296f, -0.09203890f, 0.04897006f, -0.06637655f, 0.17498964f, 0.12840384f, 
    0.32497379f, 0.05955326f, 0.00947462f, 0.08299020f, 0.04820379f, 0.02413579f, 0.02227943f, -0.10246617f, 
    -0.01079851f, 0.11608629f, 0.15168020f, -0.06432901f, -0.11657322f, -0.05665943f, -0.06176644f, 0.00132852f, 
    0.13615604f, 0.04381574f, 0.34344834f, 0.12948799f, 0.11632752f, -0.20713316f, 0.04967486f, -0.02525583f, 
    0.07837049f, 0.15476021f, -0.10183650f, -0.25130591f, -0.04788825f, -0.07449811f, -0.00769734f, 0.03177506f, 
    -0.00273042f, 0.14822015f, 0.07347339f, 0.01925918f, -0.40269151f, -0.06688127f, 0.06254325f, 0.07070475f, 
    0.02674797f, -0.05843939f, 0.01434404f, 0.13563541f, 0.05464758f, -0.06757295f, -0.04083232f, -0.03940722f, 
    0.07254880f, -0.06028345f, 0.05853437f, -0.03534855f, -0.06813919f, 0.06372479f, 0.25703898f, 0.15063222f, 
    0.25236133f, 0.12737305f, -0.12482525f, 0.04793235f, 0.03681773f, -0.05589990f, 0.09396001f, 0.16990520f, 
    -0.01361119f, 0.00546117f, 0.10465108f, 0.01274464f, -0.10304040f, -0.00485438f, -0.10213468f, 0.04441005f, 
    0.19316690f, -0.00498276f, 0.11860215f, -0.09108196f, 0.11286318f, -0.01565457f, 0.06242577f, 0.04095158f, 
    -0.04323598f, 0.06459071f, 0.18228720f, -0.03159235f, -0.02172373f, -0.01736678f, -0.05012148f, 0.02967715f, 
    -0.02874080f, 0.04127453f, 0.03092710f, -0.07412191f, 0.00018882f, -0.08750632f, 0.04566331f, -0.02551117f, 
    0.11052238f, -0.01234221f, -0.12789726f, 0.01386597f, -0.10369705f, -0.10556261f, -0.09847172f, -0.18821195f, 
    0.00245551f, -0.08189479f, -0.08776993f, 0.00351673f, -0.03666470f, 0.14473127f, 0.13838571f, 0.15815052f, 
    0.03399532f, -0.01308146f, 0.13136445f, -0.03933932f, -0.02408585f, 0.14001700f, 0.03203240f, -0.05460003f, 
    0.01903896f, 0.08419585f, -0.03862298f, 0.06126427f, -0.05003149f, -0.06407707f, 0.04320819f, 0.08375225f, 
    0.07380880f, 0.06444400f, 0.07264115f, -0.02344485f, -0.14878976f, -0.01244430f, -0.22267795f, 0.23505555f, 
    0.04180853f, 0.20106243f, -0.05291808f, 0.09612918f, 0.08591507f, 0.04199262f, -0.10547636f, -0.04725678f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01068330f, -0.05631456f, 0.10677190f, 0.03846505f, 0.12380344f, 0.09132366f, -0.06186398f, 0.00232071f, 
    0.05153935f, 0.08669768f, 0.07443374f, 0.02488170f, -0.00103510f, 0.03492503f, 0.06571649f, -0.06093505f, 
    0.00091022f, 0.11273624f, -0.05328736f, 0.03313858f, 0.01802931f, 0.00717589f, 0.01849786f, -0.00450675f, 
    0.02225783f, 0.04127356f, 0.16283417f, 0.00493480f, 0.05369782f, 0.10155778f, 0.09347270f, 0.04350527f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04610141f, -0.02600197f, 0.08792401f, -0.17747213f, -0.21141540f, -0.02108686f, -0.00548630f, -0.11442141f, 
    -0.00447356f, 0.25507736f, 0.19462782f, 0.08085676f, 0.16803996f, 0.14836121f, 0.13744459f, 0.25232434f, 
    -0.06811167f, 0.08399551f, -0.11523522f, -0.26545531f, -0.33793992f, -0.33486450f, -0.03487480f, 0.06020236f, 
    -0.15945382f, -0.15317743f, -0.00882055f, 0.03149168f, 0.27143136f, -0.06820760f, 0.15504768f, -0.19042031f, 
    -0.36290297f, 0.06454070f, 0.02165975f, -0.08854444f, 0.10115072f, 0.09302026f, -0.10495742f, -0.07271675f, 
    0.28556144f, -0.02652376f, 0.14386196f, 0.32667229f, -0.27594009f, 0.13720743f, -0.02031611f, -0.01429484f, 
    -0.17931364f, 0.22078861f, 0.05914078f, -0.15048142f, 0.03986552f, 0.15661660f, 0.05279047f, 0.23333037f, 
    -0.14887442f, -0.03838321f, -0.06649389f, 0.15033774f, 0.11018211f, 0.16021371f, -0.19563656f, 0.08401647f, 
    -0.08671901f, 0.08185691f, 0.28356618f, -0.23866409f, 0.23132339f, -0.06668402f, -0.03599592f, 0.13318819f, 
    -0.09287138f, 0.12480844f, 0.16028064f, -0.17438756f, 0.08638060f, -0.16904581f, 0.20457077f, 0.19430462f, 
    -0.13150209f, 0.02571945f, 0.16161525f, 0.00942959f, -0.03785602f, 0.04523760f, -0.06304435f, -0.12049929f, 
    0.11991166f, -0.08927435f, 0.11943800f, -0.12646291f, 0.02215854f, 0.14166602f, -0.01117469f, -0.26984721f, 
    0.02596566f, 0.09447256f, 0.13550226f, -0.14364362f, 0.04107343f, 0.09333248f, -0.14234544f, -0.02593688f, 
    0.14696544f, -0.17077540f, -0.03994901f, -0.03408474f, -0.03090738f, 0.06304713f, -0.03818346f, -0.00607014f, 
    0.05836544f, -0.14477415f, 0.11687055f, -0.17278838f, -0.03601690f, -0.11897813f, -0.01101400f, -0.09612316f, 
    0.17537327f, -0.05791774f, 0.10883966f, -0.12713963f, -0.11825775f, 0.12974980f, -0.02987895f, -0.04833535f, 
    -0.10363825f, -0.07573436f, -0.03150425f, 0.09071482f, 0.06945002f, 0.54570174f, 0.13796119f, 0.09385367f, 
    -0.29854411f, -0.03815044f, 0.22263259f, 0.12897678f, 0.05643522f, 0.03004064f, 0.18002558f, 0.29576662f, 
    0.16077587f, -0.17669378f, 0.13766697f, 0.20811753f, -0.18673725f, 0.03249514f, 0.09289479f, 0.25002998f, 
    -0.15862635f, 0.16432890f, 0.21768500f, 0.17302506f, -0.22231652f, 0.22014840f, 0.19313928f, 0.38499907f, 
    0.03092484f, 0.01380577f, 0.10358795f, 0.35629368f, 0.07001118f, -0.00849164f, -0.03274741f, -0.13086440f, 
    0.02579889f, 0.15108119f, 0.20267735f, 0.21603136f, 0.17422539f, 0.01385047f, -0.12569074f, 0.01759345f, 
    -0.14935425f, -0.02289608f, -0.02447931f, -0.26738045f, 0.32302481f, 0.06061231f, -0.03831919f, -0.32051152f, 
    -0.01814204f, -0.09091938f, 0.18724477f, -0.28921592f, 0.10702601f, 0.19241777f, 0.16350530f, 0.19394809f, 
    0.07841080f, -0.11816231f, 0.35647038f, -0.07035704f, 0.16003263f, -0.33333743f, -0.17130803f, 0.12911941f, 
    0.01201131f, -0.12073353f, 0.07478855f, -0.33732396f, 0.33053973f, -0.09019719f, 0.13402051f, -0.18250284f, 
    0.02891072f, 0.25930649f, -0.04508109f, 0.02182590f, 0.12858038f, 0.16829430f, 0.04857150f, -0.19647090f, 
    0.10850577f, 0.08222538f, 0.19826226f, -0.12487892f, -0.21700771f, -0.08073147f, 0.17346744f, -0.29012275f, 
    -0.21524556f, -0.00624768f, 0.08347654f, -0.17216952f, -0.15798314f, 0.01731019f, 0.01580938f, 0.07759842f, 
    0.02893542f, 0.10911668f, -0.13375400f, 0.34956011f, 0.23238470f, -0.06730302f, 0.14072235f, 0.08578520f, 
    -0.05752853f, 0.08234115f, 0.07289682f, -0.24807410f, -0.04752873f, -0.29960209f, -0.07047796f, 0.35174444f, 
    -0.16622704f, 0.11426340f, -0.17613849f, -0.12474710f, 0.09777672f, -0.00993157f, -0.19610481f, 0.04875859f, 
    -0.03426648f, -0.03634338f, 0.12281405f, 0.06374663f, 0.15588477f, -0.13845447f, 0.13540334f, 0.08875281f, 
    0.00821744f, -0.11316043f, -0.03782816f, 0.12154008f, -0.13689561f, -0.10308075f, -0.03802007f, 0.01847869f, 
    0.15710706f, -0.16475844f, -0.15436964f, -0.01681386f, -0.19391067f, 0.03062361f, 0.16397583f, -0.09055153f, 
    -0.17813210f, -0.02702705f, 0.07090896f, -0.05934454f, 0.06802924f, -0.02420291f, -0.16287524f, -0.11405945f, 
    0.16161495f, -0.06567471f, 0.13836761f, -0.15669070f, -0.36778644f, 0.19857928f, -0.15603434f, 0.03022283f, 
    0.28885895f, 0.00987768f, -0.12853326f, -0.13155092f, 0.24239671f, 0.06160291f, -0.10666156f, -0.09269089f, 
    -0.11307453f, -0.13112561f, -0.13003075f, -0.12190324f, 0.15433767f, 0.02899369f, 0.13632444f, -0.05834047f, 
    -0.05546775f, 0.12176806f, 0.04940519f, 0.00114967f, 0.11439881f, -0.00248359f, 0.16501056f, -0.20158480f, 
    -0.18042503f, 0.14432241f, 0.13901863f, 0.06050149f, 0.22444580f, 0.25524676f, 0.02310194f, -0.02500305f, 
    -0.26121864f, 0.33295935f, 0.36756387f, 0.05135969f, -0.36101019f, -0.04933214f, -0.37865341f, 0.01719225f, 
    -0.06024090f, 0.02613468f, -0.02693950f, -0.17017166f, 0.03154415f, 0.26131743f, -0.05234481f, 0.11051060f, 
    0.09570065f, -0.16890268f, 0.09389611f, 0.24318607f, 0.16280122f, 0.02081841f, -0.25554410f, 0.34746224f, 
    -0.07232155f, 0.06478190f, -0.39788163f, 0.25191912f, 0.30291265f, -0.44173878f, -0.10094779f, 0.06639539f, 
    0.43526983f, -0.02675299f, -0.21994478f, 0.00307927f, -0.24322464f, -0.16900527f, 0.22622949f, -0.18970430f, 
    -0.12520312f, 0.26737171f, 0.08085576f, -0.20994501f, 0.18252513f, 0.22991499f, -0.12409584f, -0.02568115f, 
    0.11690763f, 0.03016981f, 0.13194166f, -0.14875996f, 0.26330358f, -0.32661197f, -0.09580170f, 0.23629971f, 
    -0.20044900f, -0.06787004f, 0.06003221f, -0.16343513f, 0.24964938f, 0.37861195f, 0.03484714f, 0.14753574f, 
    -0.20338830f, 0.15007734f, 0.39390272f, -0.06121603f, -0.01364166f, 0.04399366f, 0.06869727f, 0.07998343f, 
    -0.06174279f, 0.01466037f, -0.18089770f, 0.01525108f, 0.08487420f, 0.19180441f, -0.01629713f, 0.20469004f, 
    -0.05948373f, 0.08569463f, 0.16691099f, -0.15673628f, 0.09643112f, 0.25615117f, 0.12447279f, 0.33635056f, 
    -0.14136939f, 0.09663142f, -0.15927963f, 0.42742950f, 0.20017235f, 0.14639419f, -0.02312979f, -0.10956100f, 
    0.12250330f, 0.28650588f, -0.39074844f, 0.36033678f, -0.28543845f, 0.01420502f, -0.21259472f, -0.05251399f, 
    -0.08066675f, -0.05348669f, -0.11385702f, -0.21810491f, -0.02396191f, 0.21002103f, 0.04539435f, 0.10749750f, 
    -0.09853667f, -0.12991059f, 0.20862226f, -0.00495901f, 0.32386741f, -0.02910227f, -0.22936888f, 0.22250962f, 
    -0.13834625f, 0.10956550f, -0.06376649f, -0.01042448f, -0.06977344f, 0.00378879f, 0.11979388f, 0.03560679f, 
    -0.13113591f, -0.18536273f, 0.06324842f, -0.01271799f, -0.05846348f, -0.08447935f, -0.07919606f, -0.04280863f, 
    0.07685128f, 0.10672344f, -0.04280775f, 0.02998062f, -0.20737658f, -0.10556698f, 0.14574993f, -0.19661242f, 
    0.03429683f, 0.06347155f, 0.04320082f, -0.21341515f, -0.08992106f, -0.04054870f, -0.14142108f, -0.08884394f, 
    0.11128966f, 0.05218421f, 0.14591900f, -0.02015776f, -0.21030609f, -0.14393945f, 0.10568197f, -0.04915454f, 
    -0.06897854f, -0.20576391f, -0.09487662f, -0.04052217f, -0.02920791f, -0.01727418f, -0.19499575f, 0.02624675f, 
    0.07149140f, -0.11879057f, 0.08621784f, -0.08399288f, 0.05579640f, -0.00730130f, -0.05872111f, -0.02968197f, 
    0.00934164f, -0.15292600f, -0.13263246f, 0.11809232f, 0.09286351f, 0.02353271f, -0.20696974f, 0.08729288f, 
    0.09797472f, -0.04102290f, 0.22669880f, -0.21434806f, -0.11536343f, -0.05413534f, -0.04688499f, -0.00691187f, 
    0.00404720f, 0.04346585f, -0.06282918f, 0.01504795f, -0.12898567f, -0.08627909f, 0.04979101f, 0.07034817f, 
    0.01074106f, 0.19677049f, 0.13539965f, -0.22104831f, -0.02523745f, 0.01851968f, 0.02272090f, 0.21702196f, 
    0.17365080f, -0.15036871f, -0.19918469f, -0.27250856f, -0.20244375f, -0.34312907f, 0.09048516f, -0.15577716f, 
    0.19259381f, 0.10113781f, -0.24674389f, 0.36273080f, -0.04945161f, 0.41092578f, 0.13597049f, -0.04834876f, 
    0.11503691f, 0.13835591f, -0.28809515f, -0.20402151f, 0.19004963f, -0.13378997f, -0.00202399f, 0.34798855f, 
    0.04999342f, -0.18486322f, 0.03323551f, 0.08922569f, -0.08083300f, 0.04837742f, 0.11932756f, 0.12766400f, 
    0.08408891f, 0.10463566f, 0.20858996f, 0.01431721f, -0.19311222f, 0.19833528f, 0.21702333f, 0.02764951f, 
    -0.10454614f, 0.06334656f, -0.15698893f, -0.21040426f, -0.21227945f, 0.46830761f, 0.00814597f, -0.03492446f, 
    -0.18911010f, 0.04362996f, 0.50827819f, -0.08849557f, 0.32288712f, -0.12164583f, -0.21276325f, 0.18777114f, 
    0.12465555f, 0.18173864f, 0.14444858f, 0.03770001f, 0.14923367f, -0.14163209f, -0.06000094f, 0.27548856f, 
    0.00664856f, -0.03010383f, -0.13612205f, -0.14587110f, -0.08592156f, 0.27432826f, 0.09269851f, 0.25554585f, 
    0.03496338f, -0.01142658f, 0.03103900f, -0.11040045f, -0.17450435f, -0.17581417f, 0.02990947f, -0.16897742f, 
    -0.12457502f, 0.03945520f, -0.13797589f, 0.14488128f, -0.14751212f, 0.10245161f, -0.19251615f, 0.01079244f, 
    0.14965732f, -0.03096638f, -0.01216314f, -0.11526068f, -0.06108030f, 0.08970506f, 0.00931993f, -0.04327395f, 
    0.11431711f, -0.15419881f, 0.10774212f, -0.17477006f, -0.18694323f, -0.10994216f, -0.16406193f, -0.08732347f, 
    0.09100472f, -0.10187502f, 0.08377413f, 0.01561947f, 0.19563426f, 0.00983089f, 0.11077759f, -0.00916321f, 
    0.11744051f, 0.41144502f, 0.07647362f, 0.27746311f, 0.05752576f, -0.06228124f, 0.15752581f, 0.27658552f, 
    0.06541629f, -0.01833874f, 0.16214308f, -0.37206185f, -0.11670256f, -0.08435936f, 0.11902591f, 0.10462563f, 
    0.07957896f, -0.04765877f, -0.15053436f, -0.13769560f, 0.32187456f, -0.11510167f, 0.05175316f, -0.03147760f, 
    -0.04767147f, -0.16930896f, -0.22934344f, -0.43685222f, 0.32105294f, -0.21134278f, 0.14108704f, -0.08332010f, 
    0.32784593f, -0.15823814f, 0.28469816f, 0.18792500f, 0.10281362f, -0.02126756f, 0.22550164f, 0.31186885f, 
    -0.09672619f, 0.05382968f, 0.11054859f, -0.16525851f, 0.26403925f, 0.15613052f, -0.09187448f, 0.27047116f, 
    0.10859612f, -0.15038472f, -0.25359145f, -0.03357248f, 0.09345116f, 0.17062563f, 0.11909215f, 0.06015332f, 
    0.09967769f, -0.12428726f, -0.02530536f, 0.36141148f, 0.02016123f, 0.03899944f, -0.15306515f, 0.16173337f, 
    -0.05704843f, 0.25528756f, -0.23961568f, 0.11946735f, -0.28457981f, -0.16067292f, -0.09786752f, 0.07332521f, 
    -0.07044762f, 0.11442322f, -0.15504666f, -0.04495116f, -0.17520042f, -0.02318396f, 0.12046772f, -0.34694213f, 
    -0.09472502f, -0.00238988f, -0.01555091f, 0.16847821f, 0.12332605f, 0.01547384f, -0.26756969f, -0.13297968f, 
    0.07167091f, 0.08352652f, 0.04795970f, 0.10470449f, -0.09597586f, 0.12764750f, 0.12555444f, 0.11902235f, 
    0.01948904f, -0.10448974f, -0.15320867f, -0.01974526f, -0.02431077f, -0.06606421f, -0.14580688f, 0.05145955f, 
    -0.13941242f, -0.16685237f, 0.02753905f, -0.13166414f, -0.06828237f, 0.06841581f, -0.10997061f, -0.07655846f, 
    -0.13683727f, 0.09691696f, 0.05294572f, 0.02614398f, -0.05555937f, 0.11340018f, -0.17964603f, -0.03623622f, 
    -0.06568237f, -0.16107564f, -0.12583672f, 0.02843291f, 0.13012612f, 0.07424641f, 0.09850081f, -0.07266846f, 
    -0.08577417f, -0.11616033f, -0.19006440f, -0.09979097f, -0.04730704f, -0.10180113f, -0.06709018f, 0.01056939f, 
    0.12104655f, -0.12727307f, 0.09048387f, 0.08556259f, 0.03682666f, -0.16571301f, 0.05066827f, -0.08782993f, 
    -0.05768277f, 0.16942826f, -0.09787787f, 0.12399518f, -0.10053397f, 0.12139814f, -0.11707609f, 0.07553194f, 
    -0.04808431f, 0.09342471f, 0.00096768f, 0.16726986f, -0.05915948f, -0.08734860f, -0.10367267f, -0.14898926f, 
    0.10122623f, -0.11189874f, 0.12250837f, 0.03281061f, -0.08926893f, -0.02101615f, 0.16261730f, 0.02950935f, 
    -0.06927389f, -0.16392578f, -0.14098993f, 0.13833424f, 0.15915513f, -0.14761297f, -0.06084260f, -0.16070496f, 
    0.13688745f, -0.10655252f, -0.07268691f, -0.14165680f, 0.04692494f, 0.00781877f, -0.09443931f, -0.05412121f, 
    -0.23652531f, 0.09162983f, 0.41971716f, -0.32240450f, 0.44463736f, 0.09124127f, 0.06731839f, -0.00033029f, 
    -0.17438281f, 0.33586702f, 0.32205179f, -0.04566073f, -0.02722244f, 0.07192443f, 0.00182284f, 0.17222878f, 
    -0.05846964f, -0.18307289f, -0.06449084f, 0.17908540f, -0.02987191f, 0.31863782f, -0.10615809f, 0.17684366f, 
    -0.13474274f, -0.02808417f, 0.22801402f, 0.09442829f, 0.24104044f, 0.31698295f, -0.19316705f, -0.19286309f, 
    -0.20823349f, 0.04890783f, 0.37114123f, 0.05272413f, 0.01659503f, -0.06420526f, 0.07175945f, 0.01406377f, 
    -0.24269609f, 0.04629768f, -0.24869837f, -0.03044903f, 0.00672121f, -0.06279838f, -0.03103131f, -0.16742761f, 
    0.07025414f, 0.08089619f, -0.10383824f, 0.27746391f, -0.04041449f, 0.13152565f, 0.09928755f, -0.11708803f, 
    0.00006781f, -0.05296452f, 0.31223500f, 0.38079998f, 0.09861118f, -0.06339828f, 0.00759026f, -0.19356279f, 
    -0.28504810f, 0.10169879f, -0.13686375f, 0.13367097f, -0.15502481f, 0.13311204f, -0.16855220f, 0.07202619f, 
    0.01544663f, -0.26734957f, 0.24647312f, -0.09961008f, -0.08572549f, 0.00187760f, 0.08003773f, -0.45689833f, 
    -0.12108149f, 0.29016808f, -0.18004762f, 0.31957912f, -0.06732365f, 0.12557958f, 0.01423879f, 0.06876714f, 
    0.12697655f, 0.04719252f, -0.06156076f, 0.32032010f, -0.18101557f, 0.01268461f, 0.10460470f, 0.23966573f, 
    -0.00988044f, 0.03851907f, 0.06591128f, -0.02169422f, 0.09961861f, -0.17043202f, 0.03333636f, -0.07073624f, 
    0.06888117f, -0.01965697f, -0.06894380f, -0.13189490f, 0.06727385f, -0.14979506f, 0.12921301f, -0.03437068f, 
    -0.17438024f, -0.11970580f, -0.16465306f, -0.14139162f, -0.00651409f, -0.09435531f, 0.09771954f, -0.18012676f, 
    -0.09966056f, -0.11158508f, -0.08417267f, 0.01567659f, -0.04453086f, 0.13790862f, 0.03006095f, 0.06674757f, 
    0.09880601f, 0.00936949f, -0.05698355f, 0.23991179f, -0.20504551f, -0.20881449f, -0.02610018f, 0.02494365f, 
    -0.55450922f, -0.07649764f, -0.13429745f, -0.07863405f, 0.12728885f, 0.11240207f, 0.00470388f, 0.39587024f, 
    -0.10529020f, -0.05256291f, -0.12232935f, 0.07037525f, -0.39365891f, -0.15946351f, 0.01384375f, 0.12919734f, 
    -0.03050714f, -0.16319507f, 0.16171938f, -0.00670342f, 0.07958824f, 0.18006773f, 0.15538318f, -0.08063439f, 
    0.06285192f, -0.06347951f, -0.46512321f, 0.20643771f, 0.17792581f, -0.30212125f, 0.09177377f, 0.14225131f, 
    0.49550527f, 0.04989595f, -0.19320445f, 0.08910258f, -0.16957562f, 0.12339944f, 0.21255894f, 0.09479955f, 
    -0.06421575f, 0.21342611f, 0.04155524f, -0.00962457f, 0.08653093f, 0.09793487f, 0.01399151f, -0.10950764f, 
    0.10537232f, 0.15133780f, 0.26465786f, -0.34145430f, -0.06627907f, -0.03751604f, -0.07819302f, 0.08074183f, 
    -0.35227421f, 0.04410496f, -0.23062664f, -0.43621576f, 0.15944104f, 0.22341982f, -0.16691290f, 0.07721677f, 
    0.08332556f, -0.11642045f, 0.43258777f, 0.01514557f, 0.19913462f, 0.15138066f, 0.08323159f, 0.13284637f, 
    -0.12127857f, 0.04900611f, -0.06903708f, -0.09642940f, -0.10152986f, 0.16973494f, 0.09849630f, 0.09044650f, 
    0.04264648f, 0.16419791f, 0.03814803f, -0.24230640f, 0.16032915f, 0.30174214f, 0.14862856f, -0.10133543f, 
    0.28590843f, 0.11997151f, -0.10631976f, 0.06394763f, 0.01790814f, -0.27759060f, -0.10230932f, -0.01483449f, 
    0.18492894f, -0.24271414f, -0.04542823f, 0.13104591f, -0.06354440f, -0.00716815f, 0.17878617f, -0.11840609f, 
    0.17088646f, 0.26362330f, 0.16193107f, -0.01354663f, 0.13145727f, -0.10951189f, 0.08517347f, -0.25272107f, 
    -0.07837064f, 0.10652222f, -0.02346115f, -0.08180340f, 0.07011959f, -0.24155001f, -0.13601281f, -0.16533063f, 
    0.05305865f, -0.06044449f, -0.30009547f, -0.05714347f, 0.08243955f, 0.14592928f, -0.14387584f, -0.00752170f, 
    0.34507003f, 0.07000250f, -0.25400057f, -0.51916784f, 0.14004952f, -0.14489484f, 0.24202305f, 0.13179801f, 
    0.12997478f, -0.01069222f, 0.05190025f, 0.16119701f, -0.01019945f, 0.31669381f, 0.02135185f, -0.10800602f, 
    0.07786759f, -0.10269084f, 0.01185021f, 0.10767287f, -0.12279845f, -0.01490518f, -0.29783416f, -0.23392344f, 
    0.35538995f, -0.01631443f, -0.37412447f, 0.10004051f, -0.31474337f, 0.19859594f, -0.05680880f, -0.16136859f, 
    -0.30329734f, -0.01588695f, 0.39181197f, -0.27083409f, 0.27663505f, -0.14504598f, -0.05987671f, -0.30519083f, 
    0.08577966f, 0.03207000f, -0.15220430f, 0.29695156f, 0.13481475f, -0.11954444f, 0.12615564f, 0.06489753f, 
    0.08717296f, 0.14196393f, -0.03155614f, 0.35192195f, 0.18321006f, -0.11282679f, 0.12037185f, 0.25482729f, 
    0.30310312f, 0.16901006f, -0.07727780f, -0.32759553f, 0.04005526f, -0.05681683f, -0.13237059f, -0.14284965f, 
    -0.06307748f, 0.27480155f, 0.10078711f, 0.03829116f, -0.03269710f, 0.13818954f, 0.30037293f, 0.20926473f, 
    0.13460320f, 0.08229379f, 0.01390717f, -0.16981420f, -0.30374345f, -0.06448627f, -0.05734060f, 0.24245210f, 
    0.02753761f, 0.13756329f, -0.19699261f, 0.20363131f, 0.33702269f, -0.25636721f, 0.12088805f, 0.26792100f, 
    -0.00774943f, 0.10982303f, -0.17651045f, -0.13971740f, 0.06088972f, 0.06632315f, 0.04578075f, 0.02543225f, 
    -0.00269745f, -0.14934334f, 0.09406034f, -0.00244157f, -0.12469172f, 0.06461348f, -0.06058580f, 0.00693576f, 
    0.12541829f, -0.15704086f, -0.06516259f, -0.13864639f, 0.03545756f, -0.03918115f, 0.15863140f, 0.13692924f, 
    -0.14960477f, 0.13925831f, -0.08334479f, -0.03798052f, -0.16532341f, 0.13099499f, -0.16825533f, 0.16226232f, 
    -0.07011860f, -0.07779960f, 0.56173009f, -0.17075063f, -0.02210779f, -0.13712461f, 0.03169331f, -0.11234329f, 
    0.02137364f, -0.01935001f, -0.16541459f, 0.24103568f, -0.22655044f, -0.01962585f, 0.45413768f, -0.11361764f, 
    0.11752269f, 0.15236109f, -0.14271411f, -0.02997364f, -0.24152340f, -0.14920969f, -0.05153657f, -0.01055520f, 
    -0.02823533f, -0.14751536f, -0.07488347f, 0.27655399f, -0.13836403f, -0.03280414f, 0.15291792f, -0.05083356f, 
    0.24704194f, 0.02465107f, 0.21175602f, 0.32756692f, -0.15285146f, 0.19187808f, 0.13729741f, 0.07579928f, 
    0.22513093f, -0.17651983f, 0.06261228f, -0.24390750f, 0.12922485f, 0.04730531f, 0.06462762f, 0.03753050f, 
    -0.12253970f, -0.05524066f, -0.12531903f, 0.17667243f, 0.28490219f, 0.14287777f, 0.19669895f, -0.22416975f, 
    0.01848002f, 0.17434399f, 0.31337166f, -0.03023848f, -0.21907090f, 0.29609811f, 0.11360314f, 0.10040641f, 
    -0.21936539f, -0.09579098f, 0.05848738f, 0.15371746f, 0.26020738f, 0.44749373f, -0.07743616f, 0.12258193f, 
    -0.29900315f, 0.22547010f, 0.12950295f, -0.00478297f, 0.01017930f, 0.13317649f, -0.11842564f, 0.25036952f, 
    0.05092292f, -0.10424112f, -0.11417105f, -0.03483576f, -0.16093366f, 0.33599409f, 0.12910004f, 0.09025943f, 
    -0.05537215f, -0.00350891f, 0.15321767f, 0.24526057f, 0.14066169f, 0.15136912f, -0.00102789f, 0.02617054f, 
    -0.03364605f, -0.02908309f, 0.45863006f, 0.35593054f, -0.15270247f, -0.11758432f, 0.13462745f, -0.07563011f, 
    -0.20420934f, -0.04749595f, -0.01144065f, 0.13530037f, -0.03045527f, 0.13554852f, -0.17906477f, -0.21493338f, 
    -0.12988356f, 0.11098620f, -0.01644570f, 0.28052646f, 0.02664220f, 0.04026388f, -0.09518984f, -0.21144378f, 
    0.13573661f, -0.10060950f, 0.24622884f, 0.34377083f, -0.19902453f, -0.12741965f, 0.15372925f, -0.09754050f, 
    0.12520367f, 0.00073239f, -0.01189675f, -0.17097716f, 0.03708405f, -0.39155680f, 0.10962769f, 0.14961989f, 
    -0.31563112f, -0.12950146f, -0.19840159f, 0.39018747f, -0.15396410f, 0.09709636f, 0.13544437f, -0.00079351f, 
    0.12951648f, -0.06413159f, 0.00665558f, 0.06783583f, 0.19266938f, -0.31772518f, 0.02045461f, -0.09640671f, 
    0.12777704f, -0.02600209f, 0.11018075f, 0.11640596f, -0.40595526f, -0.08684121f, -0.14073759f, 0.07294068f, 
    0.16104537f, 0.08363328f, -0.02655517f, 0.01575827f, -0.26342896f, 0.32966539f, -0.13939232f, 0.07373741f, 
    -0.35363400f, 0.25446811f, 0.40484780f, -0.01187963f, 0.04727430f, 0.09336567f, -0.32970658f, -0.27559036f, 
    -0.10031446f, 0.13166405f, 0.03365276f, 0.23224211f, 0.18535829f, 0.11034358f, -0.13576931f, 0.04206784f, 
    0.11077454f, 0.17395693f, -0.19193067f, 0.24186867f, -0.12458663f, -0.09142720f, 0.02838833f, 0.45184243f, 
    0.05314469f, -0.06652305f, -0.11714630f, 0.25016233f, -0.30283555f, 0.22760408f, -0.08411618f, 0.07241157f, 
    -0.09294079f, -0.22722115f, 0.08949782f, -0.02664193f, 0.28708941f, 0.09852277f, 0.20168744f, 0.07254170f, 
    -0.11791257f, -0.00436350f, 0.01201300f, 0.06400710f, 0.12657368f, -0.04819886f, 0.05846365f, -0.02349044f, 
    0.08741154f, 0.10254730f, 0.23387471f, 0.19731642f, -0.39853317f, 0.05189587f, 0.15828361f, 0.30596790f, 
    -0.25426710f, 0.05038523f, -0.28761005f, 0.14008005f, 0.25663850f, 0.02199738f, -0.14540073f, 0.09116929f, 
    0.11890998f, 0.15252315f, 0.08727628f, 0.30404159f, -0.23000166f, -0.14179787f, -0.20160158f, 0.17916127f, 
    0.08153481f, -0.01704559f, -0.08185891f, 0.05868912f, 0.23267591f, 0.16335861f, -0.01240503f, 0.10249310f, 
    0.14431857f, -0.04106003f, -0.01600350f, -0.16065341f, 0.27745450f, 0.03447850f, -0.15387259f, 0.27170166f, 
    0.27649578f, -0.05999435f, -0.02088286f, 0.15013069f, -0.09773351f, -0.02805131f, -0.04379686f, 0.15998860f, 
    -0.12712124f, -0.00670953f, -0.14056267f, 0.14543152f, -0.01852720f, -0.04569349f, -0.01983627f, 0.25164792f, 
    -0.12492027f, 0.08016714f, 0.07177358f, -0.37466016f, -0.36257133f, -0.33791831f, -0.03589544f, 0.08115162f, 
    0.00778779f, -0.12474394f, 0.16847889f, -0.00460420f, 0.36706167f, -0.13046087f, 0.15696190f, 0.09100115f, 
    0.14701371f, 0.16097268f, 0.09043086f, 0.01885269f, -0.27221152f, 0.19725135f, -0.12460439f, 0.10185116f, 
    -0.01581108f, -0.13212594f, -0.32402307f, 0.16437100f, -0.29650322f, 0.04609147f, 0.40835398f, 0.11210065f, 
    0.17661475f, 0.14909376f, 0.12426624f, -0.30469686f, -0.51005393f, -0.16803887f, 0.16208753f, 0.04056159f, 
    -0.14389002f, 0.09657829f, 0.05033601f, 0.26903769f, 0.09414652f, -0.17278327f, 0.11470568f, 0.14829542f, 
    -0.18845987f, -0.04767383f, 0.11787280f, 0.05211788f, 0.10440454f, -0.06247447f, -0.05263165f, 0.11555149f, 
    0.00758390f, -0.05417657f, -0.07581685f, -0.05610882f, 0.04671641f, -0.00824493f, 0.07441927f, 0.00875226f, 
    -0.16224334f, -0.16294976f, -0.12811530f, -0.14983033f, 0.00601279f, -0.05932567f, -0.14348340f, -0.16289769f, 
    -0.13158609f, 0.15506954f, -0.14981796f, -0.15929300f, -0.07198203f, 0.13262211f, 0.03489418f, 0.10424057f, 
    -0.04658514f, -0.15021142f, 0.23652105f, 0.34006411f, -0.00114984f, 0.27512237f, -0.03900054f, -0.16820434f, 
    -0.11865145f, 0.13366325f, 0.16999054f, 0.05950554f, -0.11912254f, -0.03903846f, -0.28978041f, -0.07499697f, 
    -0.11085422f, 0.07053943f, -0.12930030f, -0.01097684f, 0.24174204f, 0.25520390f, -0.01878840f, -0.12238643f, 
    0.01099371f, -0.00374874f, 0.13007621f, -0.29939961f, -0.23407075f, 0.29492712f, 0.05695157f, 0.05267397f, 
    0.15732713f, -0.06806909f, -0.05495775f, -0.13664158f, 0.01744625f, -0.30559048f, 0.07422724f, 0.01040580f, 
    -0.06311345f, -0.30686578f, -0.02528666f, -0.20525120f, 0.13510638f, -0.04942216f, 0.39495823f, -0.11799259f, 
    0.01883916f, 0.22631003f, -0.06186500f, 0.04657200f, -0.07697521f, -0.06802697f, 0.10966213f, -0.18789069f, 
    -0.03879480f, -0.11320839f, 0.23458131f, 0.22007778f, 0.02490558f, -0.14321938f, 0.22630003f, -0.15268326f, 
    0.11748090f, 0.12642327f, 0.36550885f, 0.16024932f, -0.08057604f, -0.22079627f, 0.07735224f, 0.07903946f, 
    0.01229533f, -0.20319647f, -0.10733167f, 0.01496641f, 0.20643157f, -0.14479962f, 0.09239510f, 0.07085104f, 
    -0.03040830f, 0.08049985f, 0.10230677f, 0.05320732f, -0.05685109f, -0.17903091f, -0.09300652f, 0.19758306f, 
    0.01010110f, 0.11188274f, 0.22109322f, 0.32566348f, -0.07960284f, -0.15772028f, 0.02290640f, -0.25956684f, 
    -0.19741116f, 0.04949011f, 0.10112233f, -0.18061568f, 0.41246775f, -0.24243756f, 0.00230113f, -0.18124224f, 
    0.34193495f, -0.05567282f, -0.02927141f, -0.18827939f, 0.06203582f, -0.02165799f, 0.11802175f, 0.14367932f, 
    0.00195169f, 0.16548322f, -0.01569043f, -0.32666537f, -0.01269908f, 0.26784757f, -0.01086172f, -0.04405606f, 
    0.03344730f, -0.14127862f, 0.12036785f, -0.12315355f, 0.12570094f, 0.01651441f, 0.07028639f, -0.48045254f, 
    0.25909939f, -0.13778959f, 0.15978296f, 0.12498855f, -0.24114224f, -0.06310783f, -0.12457511f, 0.08374614f, 
    0.09511731f, -0.17759904f, 0.24745797f, 0.25954986f, 0.24838506f, -0.01868081f, 0.27592573f, 0.24321061f, 
    0.14832747f, -0.06137498f, 0.11893695f, 0.26062319f, 0.05848705f, -0.26121545f, -0.09181985f, 0.09462320f, 
    0.10392553f, -0.08174238f, -0.19731639f, 0.13388199f, -0.26117653f, 0.33751369f, 0.12916401f, -0.27563992f, 
    -0.11477476f, 0.03204185f, 0.42958587f, -0.14788800f, -0.17469682f, 0.08333156f, -0.02718491f, -0.14326966f, 
    -0.27011636f, 0.19857775f, 0.30482736f, -0.07909133f, 0.19810498f, -0.16351958f, 0.03852930f, 0.15054402f, 
    0.00504656f, -0.12391707f, -0.09532953f, 0.08506171f, -0.06239447f, 0.10692876f, 0.15836045f, 0.03512488f, 
    -0.17487435f, -0.03747818f, 0.01291944f, 0.09166709f, -0.08210420f, 0.27539608f, 0.13886906f, 0.17195532f, 
    -0.02109412f, 0.01375675f, -0.12768333f, 0.31127930f, 0.41435289f, 0.33412766f, 0.04705474f, 0.04546387f, 
    0.21087842f, 0.12758727f, -0.45728356f, -0.29590154f, 0.04857477f, 0.12242685f, -0.29760617f, -0.07242836f, 
    -0.12601456f, 0.16444431f, 0.11239474f, 0.11346457f, -0.25099698f, 0.10899114f, 0.07658071f, -0.07741338f, 
    -0.06971104f, 0.14832824f, -0.00663184f, -0.21758534f, 0.05716459f, 0.30777073f, -0.40723464f, -0.15294544f, 
    0.13577384f, -0.04820884f, -0.22206573f, -0.13832971f, -0.00293714f, -0.18594544f, 0.15737461f, 0.03504854f, 
    0.08876353f, -0.30088419f, -0.15329424f, -0.31232870f, 0.10989156f, -0.15210804f, 0.26404762f, 0.04771923f, 
    0.03184201f, 0.06815227f, 0.06377132f, -0.25556076f, 0.06092426f, 0.23058860f, 0.01633769f, -0.24269587f, 
    -0.10259407f, -0.06563805f, 0.30187026f, -0.10875878f, -0.06092810f, -0.15693745f, 0.05193004f, 0.20458898f, 
    0.10394912f, -0.08969771f, -0.06948470f, 0.39413515f, -0.22442913f, 0.15699969f, 0.09328244f, -0.02945486f, 
    -0.01024413f, 0.24977241f, -0.27894270f, 0.37540787f, -0.24606723f, -0.13347790f, -0.15703388f, -0.12517019f, 
    -0.08756960f, 0.23816696f, 0.15265946f, -0.10493192f, -0.29692364f, 0.12654611f, 0.09035153f, -0.10332714f, 
    0.10215841f, -0.07319997f, -0.21138933f, 0.14709052f, 0.20551741f, -0.42272684f, -0.07931788f, 0.33410808f, 
    -0.16569391f, -0.09616109f, 0.33073214f, 0.10600872f, -0.24485371f, 0.55339432f, -0.15774444f, 0.04837027f, 
    -0.34973544f, 0.21681885f, 0.08848273f, -0.14834683f, 0.04718021f, 0.01924400f, -0.11542878f, 0.05535649f, 
    -0.04797477f, 0.12555185f, -0.10320749f, 0.10673469f, 0.08689056f, 0.07007544f, -0.15320137f, -0.11657604f, 
    0.17169742f, 0.08932582f, -0.02630246f, -0.19153099f, -0.29578182f, 0.21580124f, 0.28880182f, 0.32388631f, 
    0.03150063f, 0.07638159f, 0.13114209f, -0.16443641f, 0.06712101f, -0.01703520f, -0.09140083f, -0.10845956f, 
    -0.12876153f, 0.01082588f, -0.01200700f, 0.10995103f, 0.01606211f, 0.10620074f, -0.10891779f, -0.01743140f, 
    -0.09397133f, -0.09190845f, 0.09008362f, -0.09594273f, -0.04727487f, 0.05867253f, -0.10447666f, -0.10675249f, 
    0.11725222f, -0.12181901f, -0.10538089f, -0.12202075f, 0.00049421f, 0.16188414f, 0.04470437f, -0.18692647f, 
    0.26860133f, -0.15200657f, 0.10491318f, 0.33852360f, -0.43902433f, 0.14437194f, -0.13155822f, 0.01241292f, 
    -0.08542626f, -0.03306973f, -0.22378428f, 0.06739985f, -0.08989745f, 0.10526939f, 0.27193764f, 0.05462201f, 
    -0.05036990f, 0.14228427f, 0.06950487f, -0.31349638f, -0.36381584f, -0.12664606f, 0.11416595f, -0.14868200f, 
    0.17240104f, -0.08801112f, -0.02622999f, 0.01315513f, 0.11956507f, -0.09269346f, 0.10711208f, 0.28661183f, 
    0.20125306f, -0.05134249f, -0.17597672f, 0.07985631f, -0.11180274f, -0.08301176f, 0.05452308f, -0.01254821f, 
    -0.18972757f, -0.45072895f, -0.14628386f, 0.11050116f, -0.07062148f, -0.07011110f, 0.32716405f, 0.37976646f, 
    -0.12196339f, -0.13291772f, 0.02947850f, 0.09446406f, -0.46887591f, -0.08664986f, -0.17554393f, 0.04565966f, 
    0.16967961f, 0.01104069f, 0.27185148f, -0.12830386f, -0.08192760f, -0.11292335f, 0.30689237f, -0.02816364f, 
    -0.25761902f, -0.07574145f, -0.07687934f, 0.33441389f, -0.09424444f, 0.04526992f, 0.06190681f, -0.15327606f, 
    0.15874416f, 0.01652912f, -0.31974643f, 0.29678380f, -0.31731090f, -0.07116921f, -0.17712334f, -0.11350705f, 
    -0.02631204f, -0.04164964f, 0.17642151f, 0.30470696f, -0.05810857f, 0.14828104f, 0.05774197f, 0.21947853f, 
    0.05027113f, 0.11204885f, 0.15383010f, 0.17912705f, 0.18436641f, -0.03804547f, -0.10077961f, -0.00569035f, 
    0.26606211f, -0.05579453f, -0.23169434f, -0.25242057f, -0.08628206f, -0.13769859f, 0.14267807f, 0.02080356f, 
    -0.14767109f, -0.13030802f, -0.09846256f, 0.30502471f, -0.12746304f, 0.17311221f, 0.19934437f, 0.06054351f, 
    0.14599144f, 0.19768201f, -0.12265315f, -0.41999131f, -0.35227948f, -0.26706848f, 0.03753554f, 0.28650963f, 
    0.09799223f, -0.10965557f, -0.03403195f, 0.08861700f, 0.34659621f, -0.23927639f, 0.17135036f, 0.32534897f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08330466f, 0.17504463f, 0.03097102f, 0.02231545f, 0.06326602f, 0.23461443f, 0.06866935f, -0.17097551f, 
    0.11137043f, 0.11108717f, 0.13977879f, 0.09844625f, 0.23054212f, -0.14514153f, 0.07990347f, -0.10026975f, 
    -0.06976770f, -0.19283509f, -0.08541653f, 0.00523444f, -0.09937699f, -0.01640312f, -0.00988692f, 0.00140992f, 
    -0.14479405f, -0.02322277f, 0.15123123f, -0.10854205f, 0.11568102f, -0.00705247f, 0.18812150f, 0.15569124f, 
    0.19307387f, 0.29854533f, -0.00108570f, 0.11426050f, -0.00560742f, -0.04381198f, 0.13667297f, -0.06149253f, 
    -0.01316845f, 0.11929700f, 0.02381145f, 0.09026884f, -0.02827582f, -0.01543611f, 0.03724191f, 0.04028426f, 
    -0.15334123f, 0.13433881f, 0.16333222f, 0.19337961f, 0.21275854f, 0.21122368f, -0.10253002f, 0.28535286f, 
    0.15929957f, -0.03886414f, 0.13313074f, -0.01926081f, 0.23700234f, -0.04698195f, 0.03583425f, 0.07414493f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03667905f, -0.09055959f, -0.07169749f, -0.04201952f, -0.08734389f, -0.06301491f, 0.01404076f, 0.07410890f, 
    0.03133351f, 0.05161669f, -0.08086020f, -0.05825622f, -0.00312124f, 0.00503347f, 0.06004384f, -0.01612286f, 
    -0.03045669f, 0.04991733f, 0.03945793f, -0.06986348f, 0.09889196f, 0.06103129f, 0.03567901f, 0.03386898f, 
    -0.02914770f, -0.04533091f, -0.00888400f, 0.12252039f, -0.05270173f, 0.04216233f, -0.00174728f, -0.07526584f, 
    -0.12334056f, -0.03743339f, -0.00313099f, -0.08374962f, -0.14674912f, -0.09357125f, -0.17222068f, -0.08618681f, 
    -0.11013370f, -0.08713158f, 0.02607918f, 0.04454153f, -0.12237997f, -0.00880887f, -0.06131604f, -0.03104134f, 
    0.08557673f, -0.05941442f, -0.16143645f, 0.06414289f, -0.09579739f, 0.10761983f, -0.02955623f, 0.12104684f, 
    -0.00052094f, 0.03750571f, 0.07590839f, -0.02802317f, -0.08318084f, -0.16884075f, -0.07741603f, -0.07405315f, 
    0.02254159f, -0.07718549f, -0.07881244f, 0.02444182f, 0.01823414f, -0.14191473f, -0.07949460f, -0.13028687f, 
    0.03677074f, 0.01558675f, 0.00115148f, 0.04459789f, 0.00620472f, -0.08706687f, -0.06251125f, 0.11108647f, 
    0.07132547f, 0.04292510f, 0.04677173f, -0.07175085f, 0.06319102f, -0.09310652f, 0.09610075f, 0.00703078f, 
    0.12474887f, -0.03974763f, 0.04284038f, -0.04632277f, -0.00227638f, -0.07521684f, -0.06573405f, -0.03123025f, 
    -0.11741750f, 0.06928111f, 0.08788136f, 0.02178945f, 0.07787257f, -0.09046891f, -0.13735783f, -0.05349918f, 
    0.05646858f, 0.05594402f, 0.06486987f, -0.04718832f, 0.08130626f, -0.10560694f, 0.04052524f, -0.06263130f, 
    0.07646994f, -0.01806452f, 0.02141036f, -0.13825256f, -0.08968445f, -0.07114872f, 0.09362134f, -0.11916061f, 
    0.04590751f, 0.01979401f, -0.13969594f, 0.10111092f, -0.02996864f, 0.02346331f, -0.06505180f, 0.04272826f, 
    -0.34714955f, 0.07946146f, -0.17922670f, -0.11724183f, 0.17928055f, -0.05530585f, 0.05827434f, -0.48208913f, 
    0.09977980f, -0.23259322f, 0.07013455f, 0.25847551f, 0.14770679f, -0.05398738f, -0.00333994f, -0.01159096f, 
    0.11791755f, -0.01814527f, 0.07424957f, -0.01044098f, -0.29289627f, 0.14770328f, -0.42411077f, -0.08844672f, 
    0.11883026f, 0.04940590f, -0.10675798f, 0.03743219f, 0.37608644f, -0.01265016f, -0.22868045f, 0.21995181f, 
    -0.01426550f, 0.00123368f, -0.24126285f, 0.25886011f, -0.09999522f, -0.10596247f, -0.22204682f, -0.02189487f, 
    0.03154840f, 0.09227132f, 0.15980406f, 0.30581519f, 0.23058575f, 0.10524486f, -0.33195597f, -0.15364432f, 
    0.10527600f, 0.07646187f, 0.06802521f, -0.00795078f, -0.20093606f, 0.03104183f, -0.19608596f, -0.37753463f, 
    0.19048445f, 0.20723422f, 0.07456531f, 0.04700854f, -0.15239628f, -0.52880239f, 0.17470810f, 0.10218143f, 
    0.25912198f, 0.27003801f, 0.03022158f, -0.05246679f, -0.16409560f, 0.13686535f, -0.14950716f, 0.51627755f, 
    -0.10278518f, -0.35646299f, 0.24733539f, 0.26424521f, -0.02008103f, 0.36386707f, 0.04653393f, -0.06348317f, 
    0.05946053f, -0.23205432f, 0.14388907f, 0.05307129f, 0.44479185f, 0.23798683f, 0.19262920f, -0.07486661f, 
    -0.08345351f, -0.07844283f, -0.06059691f, -0.03348526f, -0.09318697f, -0.11141592f, -0.21712631f, 0.13215166f, 
    0.12597655f, 0.16347404f, 0.05090682f, -0.08912996f, 0.33500162f, -0.02140842f, 0.15528044f, -0.42139256f, 
    0.03205527f, -0.19563685f, -0.00147435f, 0.10763205f, -0.28471452f, 0.29570946f, 0.15372488f, 0.10458556f, 
    0.07349472f, -0.05124610f, -0.27757531f, -0.13627112f, 0.17301445f, 0.06750777f, -0.11996953f, 0.33172914f, 
    -0.32508177f, 0.46176654f, -0.29690686f, 0.03852177f, 0.07799798f, -0.08519322f, 0.25216538f, 0.29403391f, 
    0.09071331f, 0.06408312f, -0.19650519f, -0.01256002f, 0.27370137f, 0.01290320f, -0.14957684f, 0.08371693f, 
    0.07275765f, 0.08914512f, 0.20416467f, -0.07885173f, 0.06838844f, -0.04545664f, -0.13757221f, 0.01515292f, 
    0.14382917f, 0.11264211f, 0.41092229f, -0.04105941f, 0.01788739f, -0.05798461f, 0.26260793f, 0.03260284f, 
    0.01428508f, 0.08278716f, -0.10592019f, 0.03751761f, 0.14969778f, 0.10927948f, -0.18978073f, -0.24737877f, 
    -0.04754268f, -0.09094325f, -0.10224170f, 0.54540855f, 0.24410136f, -0.06215746f, -0.05698522f, -0.02444974f, 
    0.11037167f, 0.09006518f, 0.57011169f, 0.44770089f, 0.23431093f, 0.02063829f, 0.13195840f, 0.26858762f, 
    -0.03174336f, 0.03927715f, -0.01239758f, 0.00835677f, -0.36924997f, 0.06598221f, 0.23951183f, -0.28228286f, 
    -0.08721713f, 0.10769483f, 0.33073568f, -0.03347915f, 0.28184602f, -0.07637496f, 0.02136843f, 0.20196420f, 
    0.30619922f, 0.00150837f, 0.15228932f, -0.10466163f, 0.09482466f, -0.08321552f, -0.05763993f, 0.31000417f, 
    -0.00941050f, 0.09079856f, -0.19259459f, -0.19242547f, 0.01251263f, -0.11913794f, 0.13411321f, 0.16937715f, 
    0.14015183f, 0.20909972f, 0.16135584f, 0.10391416f, 0.14384335f, 0.28198162f, -0.26419184f, -0.11670232f, 
    -0.00950593f, 0.10125464f, -0.02657752f, -0.20701431f, -0.10192493f, 0.11035616f, 0.20980982f, 0.08381425f, 
    0.26653108f, 0.02013218f, -0.30215457f, -0.23337545f, 0.08198030f, 0.11129085f, 0.04568355f, -0.17500231f, 
    -0.00739630f, -0.13031171f, 0.41777173f, -0.36687419f, 0.08735670f, -0.01567061f, 0.27113241f, 0.15185222f, 
    -0.03853488f, -0.29895195f, 0.03333607f, 0.24809511f, -0.04866439f, 0.40046072f, -0.03741025f, -0.35078418f, 
    -0.12192982f, -0.14263135f, -0.29523352f, 0.08718289f, -0.11917513f, 0.32792175f, -0.01458996f, 0.26111981f, 
    -0.13668454f, 0.20432714f, -0.10729379f, 0.03688528f, -0.02300840f, -0.01006361f, -0.03507873f, 0.01388355f, 
    -0.06389067f, -0.25927827f, 0.09372388f, 0.33578691f, 0.13229387f, 0.32311401f, -0.00811429f, 0.11892574f, 
    0.08445174f, -0.28968474f, 0.08221822f, -0.05667264f, 0.09270716f, 0.02355875f, 0.09868549f, 0.12578818f, 
    -0.00882513f, 0.04828334f, -0.19771032f, 0.18180084f, 0.17954534f, -0.09602841f, -0.23296463f, 0.10563622f, 
    -0.15638758f, 0.11837134f, -0.35953650f, 0.00359389f, -0.11060826f, -0.08108228f, -0.02111948f, -0.20589361f, 
    0.00993929f, 0.17235580f, -0.23423879f, 0.14827666f, 0.17000318f, 0.22858021f, -0.13580483f, 0.09580433f, 
    0.05121603f, 0.10782854f, -0.10550711f, 0.01451735f, 0.02028760f, -0.03543529f, -0.26799208f, -0.09586718f, 
    0.05120154f, 0.29159850f, 0.04339321f, -0.07908007f, -0.10798349f, -0.53242236f, 0.41202208f, 0.19516915f, 
    0.33470821f, -0.11612500f, 0.14197795f, 0.07924181f, 0.09730629f, 0.17907709f, 0.04906891f, 0.13127182f, 
    -0.12748687f, 0.21636951f, 0.01011001f, -0.23729312f, 0.02133839f, -0.07235130f, 0.00804584f, -0.01998606f, 
    -0.07535194f, 0.30407578f, 0.05970934f, 0.03156256f, 0.31213006f, -0.02640973f, 0.12109345f, 0.11670159f, 
    -0.03581659f, 0.02060905f, 0.06612381f, 0.12859583f, -0.23930371f, -0.03345290f, 0.54451621f, -0.04508206f, 
    -0.04949433f, -0.20485102f, -0.06406743f, -0.14693637f, 0.13059592f, -0.02551353f, -0.01646923f, 0.22246180f, 
    0.17768413f, 0.07521251f, 0.06175586f, -0.00983397f, 0.03973725f, -0.19848059f, 0.31394777f, -0.07519589f, 
    0.13797948f, -0.01148982f, 0.10720659f, 0.13096842f, 0.05607594f, -0.03752723f, 0.39460459f, -0.03008942f, 
    0.17064030f, -0.06038021f, 0.13992921f, 0.01547167f, 0.08767729f, 0.40927324f, -0.34369683f, 0.13079192f, 
    -0.08233004f, 0.13306452f, 0.06213093f, -0.04540658f, -0.10681581f, 0.22007629f, 0.10940541f, -0.07707482f, 
    -0.09935671f, -0.23165223f, 0.07911694f, 0.38238084f, 0.12452473f, 0.24856433f, 0.10041564f, -0.04837032f, 
    -0.04142725f, 0.11754407f, -0.01844373f, 0.03304479f, 0.12906815f, 0.16115703f, -0.27640665f, 0.01839301f, 
    0.06404563f, 0.13285649f, 0.19334659f, -0.15130085f, -0.00280984f, 0.01973219f, 0.30389124f, 0.18895045f, 
    0.31079620f, 0.00666024f, -0.15312873f, -0.28323880f, -0.13771103f, 0.03115572f, -0.31456441f, 0.01788308f, 
    0.02725976f, -0.27891740f, -0.47990215f, -0.03938726f, -0.02922277f, 0.28906372f, -0.12915920f, -0.47903755f, 
    -0.11317605f, 0.26446772f, -0.01588565f, -0.27759379f, 0.24674018f, -0.21666127f, -0.13394099f, 0.17403720f, 
    0.05388398f, -0.10594751f, 0.17512430f, 0.01412903f, -0.46764648f, -0.13517691f, 0.10631598f, -0.08402106f, 
    0.37763515f, -0.01303815f, -0.10229077f, -0.08274098f, 0.28219214f, 0.13832632f, 0.04874338f, 0.09307547f, 
    0.02694312f, 0.11120014f, 0.07906993f, -0.29256245f, 0.08892825f, -0.02734135f, 0.01448406f, 0.02289164f, 
    0.25403598f, 0.00623784f, 0.44488570f, 0.16250020f, 0.23754223f, -0.01710703f, 0.00452630f, 0.10282685f, 
    0.11983423f, -0.01983250f, 0.06143074f, -0.26243412f, -0.13814081f, -0.08640871f, 0.55903965f, -0.09607965f, 
    0.29028332f, -0.07199386f, -0.13111064f, 0.17196375f, 0.15665710f, 0.10819502f, 0.05871664f, 0.11164261f, 
    0.13761185f, -0.20009968f, 0.46933669f, 0.24883342f, 0.06602051f, 0.05289502f, 0.34695774f, 0.06462139f, 
    -0.03148009f, 0.10102534f, 0.09173173f, -0.11200021f, -0.12033049f, 0.16123143f, 0.34557977f, -0.23514141f, 
    0.01834152f, -0.10319885f, 0.48831370f, -0.12535554f, 0.16511892f, -0.00534301f, -0.37602213f, 0.17123199f, 
    -0.01438841f, -0.00955619f, 0.08153647f, 0.10951756f, -0.00699538f, 0.04792761f, 0.04534481f, -0.04931121f, 
    0.09225999f, 0.10906273f, 0.00793046f, -0.12082719f, -0.02844989f, -0.09398113f, -0.00935911f, -0.05303916f, 
    -0.11773939f, -0.02211015f, -0.01814670f, -0.07417327f, -0.08306153f, -0.05208468f, 0.05528730f, 0.11393137f, 
    0.05203377f, -0.10920374f, -0.02042483f, 0.10113493f, -0.11445600f, 0.10437924f, 0.06892384f, 0.06541088f, 
    0.02490068f, -0.00693515f, 0.06927951f, 0.04839095f, -0.12271940f, -0.12207302f, 0.07271429f, -0.13927774f, 
    -0.05641287f, 0.03608908f, -0.02696844f, -0.11967572f, -0.08905677f, 0.02192368f, -0.12088865f, -0.05105888f, 
    -0.02450304f, -0.14431402f, -0.12629749f, 0.04998594f, 0.07731286f, -0.14811964f, -0.07944478f, -0.00002812f, 
    -0.00876789f, -0.11319233f, 0.03496572f, -0.03984345f, -0.12257833f, -0.06323971f, -0.00423456f, -0.05989700f, 
    0.01994399f, 0.06045238f, 0.06166290f, -0.07326126f, 0.05851551f, 0.10859831f, -0.07856955f, -0.07957182f, 
    0.04598568f, 0.11142401f, -0.00985439f, 0.04594663f, -0.13013019f, -0.08857091f, 0.03880410f, -0.00437762f, 
    0.06039841f, -0.05558812f, 0.05064648f, -0.07929206f, -0.10845913f, -0.03232354f, -0.09760959f, -0.09103630f, 
    0.07558325f, -0.12138586f, 0.02022482f, -0.10049741f, 0.01649869f, -0.12127637f, 0.04069763f, 0.08225248f, 
    -0.14230831f, -0.05484053f, 0.07169114f, 0.08917148f, -0.08605181f, -0.03424141f, -0.07285374f, -0.11962452f, 
    -0.09512765f, -0.07323559f, 0.08388480f, -0.08968529f, 0.09521428f, -0.11746339f, 0.07281471f, -0.04512160f, 
    -0.06047751f, -0.05429984f, -0.11263964f, -0.06054333f, 0.01385574f, -0.01357148f, 0.08075847f, -0.07727768f, 
    0.08078375f, 0.10383938f, 0.00982660f, -0.09724601f, 0.02433518f, -0.00580141f, -0.10392446f, 0.06177552f, 
    0.29793024f, 0.00298550f, 0.11360215f, -0.00579922f, 0.20564142f, 0.09209897f, 0.00888263f, 0.29653385f, 
    0.00656952f, 0.22130011f, -0.18672375f, -0.20745870f, -0.06860398f, -0.04545803f, -0.14495517f, -0.12710892f, 
    -0.20517851f, 0.18110225f, 0.05437699f, -0.04471368f, 0.11796609f, 0.01819931f, -0.02351812f, 0.08682139f, 
    -0.01222999f, 0.15068214f, 0.13711594f, -0.02886063f, -0.15798122f, 0.02604691f, 0.45088238f, -0.17414823f, 
    0.05142959f, -0.17021447f, -0.07203115f, -0.49567851f, 0.18001230f, -0.07630319f, 0.10226276f, 0.17745167f, 
    0.10231987f, 0.08949132f, -0.06828316f, -0.40273932f, 0.09937691f, -0.04775936f, 0.13476501f, 0.18875204f, 
    -0.02480642f, -0.09947190f, 0.04448436f, 0.21001907f, 0.14040495f, 0.37034962f, 0.19102126f, -0.10801460f, 
    -0.19000144f, -0.15299265f, -0.03575243f, 0.05517346f, 0.09657039f, 0.36229581f, 0.05036210f, 0.14085679f, 
    0.07932425f, 0.06904104f, -0.11145255f, 0.12394296f, 0.01757523f, -0.05302298f, 0.01355080f, -0.08672445f, 
    -0.05479781f, 0.10535008f, -0.02064912f, 0.08286404f, 0.08895980f, -0.03563063f, 0.03664756f, 0.10837186f, 
    -0.04382087f, 0.03722695f, -0.12154090f, 0.03874764f, 0.01943626f, -0.07835158f, -0.11573969f, 0.07511598f, 
    0.06758809f, -0.05368127f, 0.00677385f, -0.09988831f, -0.05881386f, 0.00286527f, 0.08675398f, -0.08021706f, 
    -0.10541111f, -0.07433403f, 0.01681802f, -0.09015419f, 0.01521647f, -0.10253377f, 0.04407887f, 0.01643580f, 
    -0.07316204f, 0.00338505f, 0.06923408f, -0.06902958f, -0.00370269f, 0.01433854f, -0.05304869f, -0.09076581f, 
    0.07859951f, -0.06835530f, 0.04433300f, -0.09957468f, -0.00844053f, -0.08650222f, -0.05213802f, -0.05120863f, 
    0.07925607f, -0.11845464f, -0.08909117f, 0.01972471f, -0.05757761f, 0.01116365f, 0.10492670f, -0.10606715f, 
    0.11275072f, 0.03302769f, 0.05176017f, -0.10710385f, 0.18362574f, -0.07971103f, -0.12333012f, 0.18627667f, 
    0.09231570f, 0.10872720f, -0.09224379f, -0.14799328f, -0.08715456f, 0.07572366f, -0.08565126f, 0.10410883f, 
    0.13437745f, 0.04224579f, -0.07307840f, -0.04510368f, 0.11592571f, 0.10871808f, 0.22264028f, 0.12240110f, 
    -0.00696668f, -0.05023674f, 0.03265164f, -0.00107644f, 0.15478532f, 0.11544251f, -0.30213934f, -0.15488331f, 
    -0.11489704f, 0.07280368f, 0.26355010f, 0.16551638f, 0.30441165f, 0.12942290f, 0.45901340f, -0.26330009f, 
    -0.05914102f, -0.00714118f, 0.32443479f, 0.14946170f, 0.06779313f, -0.07692043f, 0.17391218f, 0.34123939f, 
    -0.10889088f, -0.29759407f, 0.12645549f, 0.09450597f, -0.12903701f, 0.19487317f, -0.06279755f, 0.01043599f, 
    -0.17243174f, 0.15036502f, -0.25491798f, 0.03788773f, 0.24646357f, 0.41936660f, 0.15295999f, 0.30346623f, 
    -0.04032384f, -0.09723166f, 0.30593231f, -0.07963096f, 0.07735962f, 0.13328493f, 0.42070740f, -0.46171024f, 
    0.09777004f, 0.20120427f, -0.26128757f, -0.00160025f, 0.14567685f, -0.34887493f, 0.11047713f, -0.14517954f, 
    0.00460118f, 0.16757680f, 0.03882009f, -0.05297336f, -0.07488997f, 0.06339921f, -0.25669861f, 0.07905305f, 
    -0.03826906f, -0.10512520f, 0.11811121f, 0.10630685f, 0.01497543f, 0.00058063f, 0.08741995f, 0.14709491f, 
    0.10891170f, 0.27257526f, 0.26978326f, -0.01604228f, -0.10006107f, -0.05833841f, 0.20499308f, 0.39499536f, 
    -0.08852694f, 0.20263678f, -0.01531806f, -0.19038886f, 0.22991039f, -0.17363682f, 0.08370601f, 0.14465843f, 
    0.11109143f, 0.00590215f, 0.31187487f, 0.15459409f, 0.16793959f, 0.28634152f, 0.17563319f, -0.16158085f, 
    0.37558806f, -0.40952680f, 0.02264442f, 0.01021500f, 0.11887516f, 0.07291023f, -0.26528442f, -0.14952885f, 
    0.17272933f, 0.25199157f, -0.05183643f, 0.04552101f, 0.08143692f, -0.14829582f, -0.21034747f, 0.37006357f, 
    0.09479730f, -0.11013287f, 0.31311655f, 0.24856669f, 0.04354854f, 0.33013204f, 0.04450770f, -0.01781580f, 
    0.01860529f, 0.00296027f, -0.02242092f, 0.07623769f, 0.14151801f, 0.11097371f, -0.08299042f, 0.00220416f, 
    -0.09432946f, -0.07083464f, 0.01170680f, 0.18463096f, 0.03654353f, 0.04860120f, -0.06904782f, 0.06110996f, 
    0.16525470f, -0.19326855f, 0.02191873f, -0.13463792f, 0.21159273f, -0.02791253f, 0.07502098f, -0.42083192f, 
    0.26156434f, 0.02694600f, 0.00458203f, 0.01658092f, -0.09529921f, 0.15651505f, 0.16744630f, -0.03837709f, 
    0.03483157f, -0.00887114f, -0.15819792f, -0.04360316f, -0.03196328f, -0.02261728f, -0.27520901f, 0.40883046f, 
    -0.09110357f, 0.11463130f, -0.27675048f, 0.06060655f, -0.13451606f, 0.17530487f, 0.44059312f, 0.10196612f, 
    -0.09982242f, 0.10632241f, -0.16961317f, 0.09631057f, 0.03951217f, 0.22733399f, 0.23195717f, -0.01909001f, 
    -0.06342689f, -0.13660432f, -0.10311306f, 0.28610897f, -0.02605084f, -0.11955956f, -0.14698742f, -0.01425199f, 
    0.07239369f, 0.07845905f, 0.22948304f, -0.12090620f, -0.17567453f, -0.06909655f, 0.15624046f, 0.06477217f, 
    -0.02669600f, -0.06247776f, -0.20743667f, -0.14873539f, 0.06797097f, -0.10976878f, -0.15378277f, 0.35058349f, 
    0.03146734f, 0.35944366f, -0.11953111f, -0.07595676f, -0.18915467f, -0.10758131f, -0.32122341f, 0.32528126f, 
    -0.09174345f, -0.03164119f, -0.17538707f, 0.18086737f, 0.21675810f, -0.02890915f, -0.07796675f, -0.11359283f, 
    -0.08698506f, 0.24517453f, 0.14052191f, -0.00969726f, 0.03991735f, 0.00865513f, -0.16186464f, 0.25448731f, 
    0.08392052f, 0.00665108f, 0.24036810f, 0.02194765f, 0.13668768f, -0.53201431f, -0.21953124f, -0.24285004f, 
    0.06243451f, 0.00836013f, -0.14017949f, 0.00296755f, -0.07872573f, -0.13147902f, -0.10481641f, -0.05487990f, 
    -0.09462124f, 0.05619589f, -0.06362399f, 0.31082410f, 0.01758651f, 0.16518795f, 0.12510863f, -0.03950869f, 
    0.16887967f, -0.11076766f, -0.24109794f, -0.00936108f, 0.02323998f, -0.16358860f, 0.23743071f, 0.05655139f, 
    0.00727937f, -0.11634947f, -0.48494962f, 0.12792423f, 0.18099040f, -0.07653682f, -0.26247874f, 0.20643455f, 
    -0.25955316f, 0.24616671f, 0.03759211f, 0.33724970f, 0.26990968f, 0.09007767f, 0.16958582f, -0.02382061f, 
    -0.18665755f, 0.05125881f, -0.21745497f, -0.01711552f, 0.19270639f, -0.10760722f, 0.36805603f, 0.41793230f, 
    -0.09721097f, -0.13740173f, 0.32688764f, 0.23283508f, -0.15971178f, -0.28692895f, 0.00785568f, -0.19514480f, 
    0.36296001f, 0.45885947f, -0.02129218f, -0.07319029f, 0.44912082f, 0.03620141f, 0.06782863f, 0.33456492f, 
    -0.07641728f, 0.10218146f, 0.13044950f, -0.12459067f, 0.09864680f, 0.10628226f, -0.10466622f, 0.06858989f, 
    -0.08884760f, -0.16359732f, 0.38147026f, -0.21491140f, 0.16886172f, 0.24265349f, -0.01123229f, 0.00558461f, 
    -0.13487923f, -0.08551844f, -0.15056440f, 0.12014908f, -0.01227515f, -0.22491211f, 0.47453550f, -0.06324579f, 
    -0.02952030f, 0.13802011f, 0.16561526f, 0.24732192f, 0.10531782f, -0.02424431f, 0.07366696f, -0.19746628f, 
    -0.08548640f, -0.12564442f, -0.20010687f, -0.25449124f, -0.16096260f, -0.06207839f, 0.27177596f, -0.08535712f, 
    0.24619588f, 0.27033505f, -0.03213844f, 0.07665782f, -0.04670254f, 0.07826347f, 0.17446870f, 0.10847192f, 
    0.06461094f, 0.33710542f, -0.20325790f, 0.09345184f, -0.22520572f, -0.06581219f, 0.34275946f, -0.05624463f, 
    -0.43637270f, 0.21986461f, 0.21629719f, -0.13522072f, 0.14383985f, -0.24175222f, 0.38648471f, -0.14140037f, 
    -0.05825690f, 0.03847250f, -0.23017280f, -0.11383268f, 0.04592887f, 0.04412185f, -0.13727534f, 0.13195783f, 
    -0.02299089f, -0.13881737f, 0.24013263f, 0.08415011f, 0.08528954f, 0.36306420f, -0.00267118f, -0.10180549f, 
    0.05126220f, 0.14433256f, 0.18532605f, 0.08969641f, 0.07482425f, -0.12169257f, 0.41817707f, 0.02799127f, 
    0.02861524f, -0.03063802f, 0.04583142f, -0.13644588f, 0.01776551f, -0.00219369f, 0.43051556f, 0.09638640f, 
    0.08289221f, -0.18218948f, -0.19926755f, 0.02199577f, 0.03357367f, 0.03429550f, -0.28209466f, -0.00081301f, 
    0.17710204f, -0.12495861f, -0.01564756f, 0.10740100f, -0.01301896f, 0.15009652f, 0.18258864f, 0.04362700f, 
    -0.01227699f, 0.11933582f, -0.29401624f, -0.24034649f, -0.14016983f, -0.27480900f, -0.07062746f, 0.31581959f, 
    -0.12766188f, 0.18952395f, 0.16148846f, 0.03491393f, 0.17450680f, 0.09021812f, 0.24360032f, 0.13739802f, 
    -0.11316281f, 0.03514758f, -0.08028701f, 0.02564545f, -0.05044929f, -0.05335933f, 0.39735249f, -0.18891397f, 
    0.01738286f, 0.27468640f, -0.13305032f, 0.19269733f, 0.08209606f, -0.06276494f, 0.10837361f, -0.04569764f, 
    -0.06808743f, -0.22317158f, -0.08354018f, 0.01883800f, -0.16164485f, -0.09318543f, -0.04644528f, -0.11069893f, 
    -0.07122738f, -0.03113345f, -0.21750386f, 0.32104424f, 0.31460416f, -0.05264583f, -0.20121481f, 0.00234229f, 
    -0.14448200f, 0.37644821f, 0.16013534f, 0.28337437f, -0.10925388f, -0.11566482f, 0.14279430f, 0.22587876f, 
    -0.25112340f, 0.34529173f, -0.29955789f, 0.12542556f, 0.18346289f, -0.10894644f, -0.04955233f, 0.11334351f, 
    0.10656305f, 0.13548695f, 0.40645799f, 0.10970027f, 0.18854572f, -0.01545034f, 0.01688477f, -0.23829848f, 
    0.34930220f, -0.07826187f, 0.01922863f, 0.08960729f, 0.26649249f, -0.28744888f, 0.09694747f, 0.03774557f, 
    -0.02393385f, -0.07758717f, -0.03334260f, 0.07460326f, 0.04595593f, -0.09830722f, 0.04573707f, 0.02883817f, 
    -0.00763716f, 0.00864165f, -0.04735832f, 0.09197237f, -0.07213738f, -0.03933984f, -0.00286865f, 0.07787712f, 
    0.02944857f, 0.03052492f, 0.10089688f, -0.01039141f, -0.14515361f, 0.07282964f, -0.02496512f, 0.06090663f, 
    -0.01766749f, -0.03692517f, -0.09050521f, 0.06910426f, -0.03040359f, -0.11077718f, 0.07995637f, -0.03216119f, 
    -0.13308126f, -0.12842025f, -0.07344536f, -0.12173992f, -0.13741457f, -0.07026246f, -0.10843322f, 0.03738755f, 
    -0.12366221f, -0.09284107f, -0.07657327f, -0.14160793f, 0.09142794f, -0.00760127f, 0.08528800f, 0.07070459f, 
    -0.01526606f, -0.02616527f, -0.00627723f, -0.13217421f, -0.02443448f, -0.12907574f, 0.10748513f, 0.07801913f, 
    -0.04812363f, 0.01445396f, 0.05442427f, 0.08775701f, -0.07806594f, -0.10774468f, -0.01271441f, -0.13598251f, 
    0.11401311f, 0.07563402f, 0.15424424f, -0.00831228f, 0.00472208f, 0.17472409f, 0.05177408f, 0.14378501f, 
    -0.00515805f, 0.16412386f, 0.12888536f, 0.20895599f, -0.10414343f, 0.24714899f, 0.05549489f, -0.02079364f, 
    -0.10929403f, -0.00380752f, -0.36310157f, -0.02546726f, 0.03954395f, -0.15041389f, 0.31214643f, 0.06475066f, 
    -0.09380806f, 0.03388080f, 0.01923214f, 0.29447076f, 0.03973127f, 0.05970919f, 0.19018511f, 0.19739881f, 
    -0.11677676f, 0.05513731f, -0.14338689f, -0.37886989f, -0.22324097f, -0.05666837f, 0.13591422f, -0.04045517f, 
    0.09259926f, 0.40700093f, -0.60551375f, -0.02666843f, -0.12370700f, 0.20138764f, -0.01497992f, 0.03840649f, 
    -0.10990983f, 0.25326735f, -0.05223820f, 0.20170674f, 0.23997816f, -0.08587446f, 0.09726869f, 0.32629412f, 
    -0.08455895f, 0.09024558f, -0.16353269f, 0.03660894f, -0.02645512f, -0.24652551f, 0.36139232f, -0.05701422f, 
    -0.14929025f, 0.11473414f, 0.33937815f, -0.03564680f, 0.03586877f, 0.22776495f, 0.39117765f, -0.32579216f, 
    -0.08638461f, -0.15593708f, -0.02983301f, 0.35213393f, -0.00752446f, -0.10193983f, -0.01620711f, -0.08230557f, 
    -0.17416374f, -0.00797138f, -0.09661924f, 0.10283872f, -0.15488727f, 0.20288950f, -0.36233357f, -0.06862222f, 
    0.14396408f, -0.05750031f, -0.10557770f, 0.05170852f, 0.23422977f, -0.00739781f, 0.06895087f, 0.42141843f, 
    0.18107940f, 0.37138531f, 0.07391667f, -0.23496023f, -0.11940004f, -0.01340678f, 0.02316778f, 0.49813566f, 
    -0.00858640f, 0.00073673f, -0.31450370f, -0.21155727f, 0.08303791f, 0.11562257f, -0.06661832f, -0.23632798f, 
    0.09006290f, 0.30562931f, 0.34280464f, -0.04949990f, 0.34401011f, 0.00958950f, -0.09972572f, 0.04408207f, 
    0.36352941f, -0.20729615f, 0.16660197f, 0.02616964f, -0.02027339f, -0.13205412f, -0.06915817f, -0.14807451f, 
    -0.06950086f, -0.00273022f, -0.00710250f, 0.11488730f, -0.05986334f, -0.09849777f, -0.14471236f, -0.09139441f, 
    -0.06023438f, 0.06359470f, 0.04188798f, -0.07882792f, -0.01718535f, 0.06549932f, -0.08424850f, -0.10454746f, 
    0.04519874f, 0.09140016f, 0.02207770f, 0.01505980f, 0.04487331f, -0.11904339f, -0.06432089f, -0.04106244f, 
    -0.10958114f, 0.10030405f, -0.05788670f, -0.04466511f, -0.05080630f, 0.01000915f, -0.12164871f, 0.09283308f, 
    0.01831405f, 0.01648526f, -0.11001876f, -0.07913201f, -0.00355564f, 0.02002324f, -0.05418944f, -0.01167091f, 
    -0.04319631f, 0.00424643f, -0.10169689f, 0.02141260f, -0.11369155f, -0.03308215f, -0.09706430f, 0.04075746f, 
    -0.05682829f, -0.05689444f, 0.04309186f, -0.09753518f, -0.08783730f, -0.09608647f, -0.03852385f, -0.05165387f, 
    0.05515654f, -0.02745621f, -0.13878949f, 0.10007696f, -0.07545137f, 0.06671087f, -0.14611682f, -0.13847403f, 
    0.25811228f, -0.02204187f, 0.13574804f, 0.06481136f, 0.19126181f, -0.19925997f, -0.24670123f, 0.02033846f, 
    0.09987447f, -0.15472990f, 0.34709233f, -0.08493267f, 0.17521107f, -0.07914558f, 0.06510314f, -0.05637806f, 
    0.16228873f, -0.01682273f, 0.27848110f, -0.10477754f, 0.17250447f, 0.13997106f, -0.17821145f, -0.08879494f, 
    -0.09339862f, -0.07998998f, 0.25734860f, -0.05573368f, 0.12945201f, -0.00464746f, 0.43821090f, -0.10505958f, 
    0.30159768f, -0.27205807f, 0.16801527f, 0.15578787f, 0.29474941f, -0.06519619f, -0.10173276f, -0.49513727f, 
    0.37685412f, -0.34788996f, 0.20935725f, 0.15859315f, -0.16569373f, 0.12916453f, 0.00426748f, 0.01937507f, 
    0.02513895f, -0.09773010f, -0.16642085f, -0.15315929f, 0.10583924f, -0.15663956f, 0.22845526f, 0.00977561f, 
    -0.11884262f, -0.10816337f, 0.13783520f, 0.05211518f, -0.04028828f, 0.18033296f, -0.07985297f, 0.19240963f, 
    0.06421591f, -0.07832664f, 0.06725258f, -0.02100110f, 0.28549877f, 0.25552747f, -0.12935406f, 0.01876733f, 
    0.07237951f, -0.06060335f, -0.04852808f, -0.07267402f, 0.14159761f, 0.19111961f, -0.09933774f, -0.02566188f, 
    -0.12246587f, 0.44602314f, 0.17242368f, 0.13663138f, 0.13916150f, -0.09420481f, 0.04720201f, 0.02935096f, 
    0.08541274f, -0.05723244f, -0.17173329f, -0.00548165f, 0.06427190f, 0.02327645f, 0.27051777f, 0.19291160f, 
    0.23256782f, -0.15981238f, 0.13991265f, -0.02351617f, -0.15983708f, 0.09952980f, -0.52976042f, 0.15128021f, 
    0.17319277f, -0.14516447f, 0.11516106f, 0.16160522f, 0.18861210f, 0.02037731f, 0.05946575f, -0.31594443f, 
    0.07445146f, 0.30647892f, -0.32641160f, -0.34740376f, -0.06994227f, -0.21476698f, -0.13100615f, 0.22200072f, 
    -0.30133349f, 0.04324439f, 0.47595376f, -0.00229661f, 0.01006269f, -0.03708781f, 0.03280509f, -0.22349764f, 
    0.08365599f, 0.10943566f, 0.43041211f, -0.00579116f, 0.14144649f, 0.12044504f, 0.18556781f, -0.00135636f, 
    -0.04721978f, 0.11393441f, 0.05036487f, -0.11208672f, 0.19528066f, 0.12585585f, 0.14381789f, 0.04912516f, 
    -0.15861852f, 0.11730672f, 0.12782359f, 0.03828561f, 0.07796502f, 0.16576362f, -0.28003943f, 0.00698946f, 
    0.01705159f, 0.00695708f, 0.48870113f, 0.11789104f, -0.13165216f, -0.07537926f, 0.51517558f, -0.06657474f, 
    0.20585036f, -0.23026398f, 0.05419154f, -0.41922557f, -0.13494496f, 0.11254734f, 0.05437539f, 0.00295947f, 
    0.21720010f, -0.07423156f, 0.16221379f, -0.27703479f, -0.03386805f, 0.11601596f, -0.11454188f, -0.07195705f, 
    0.03365006f, 0.10044314f, 0.10531531f, 0.11277915f, 0.34481978f, 0.13251537f, 0.33304682f, 0.30482119f, 
    -0.02513764f, -0.37013179f, 0.20704411f, -0.02285388f, -0.25102904f, 0.47290680f, -0.04485568f, -0.02678308f, 
    -0.09247372f, -0.16360109f, 0.08732916f, 0.02343050f, 0.03241569f, 0.04076315f, -0.15893798f, 0.02354635f, 
    0.11219157f, -0.06147363f, -0.11499261f, -0.00861322f, -0.04023213f, -0.03944056f, 0.12448868f, 0.01616887f, 
    0.12281373f, 0.03108112f, -0.10945367f, 0.11437054f, 0.04026534f, 0.05556661f, -0.03012133f, 0.06325347f, 
    0.04872486f, 0.11760366f, -0.07740801f, -0.02083562f, -0.17350264f, 0.05612479f, 0.00168656f, -0.14901209f, 
    -0.16203643f, 0.05840520f, 0.06542804f, 0.01352789f, -0.05381412f, 0.09998447f, 0.07187998f, 0.00673202f, 
    0.00416200f, -0.08239551f, 0.03672579f, -0.10903158f, -0.04460876f, 0.02880921f, -0.02723696f, 0.05145619f, 
    0.07499175f, -0.02351018f, -0.15718961f, 0.04143902f, -0.11430098f, -0.09319656f, 0.05689961f, 0.06216099f, 
    -0.00620390f, -0.07113580f, -0.08526587f, -0.04887737f, -0.07914998f, -0.10492560f, -0.04053067f, -0.00492109f, 
    0.10740153f, 0.04561692f, -0.37948138f, 0.08738136f, 0.10763401f, 0.02073272f, -0.17136572f, 0.24147016f, 
    0.07708292f, 0.13570695f, -0.09529364f, 0.10832409f, 0.01696054f, 0.32533106f, 0.04924649f, -0.09326721f, 
    0.24025793f, 0.39921278f, -0.12862012f, -0.07174332f, 0.30255297f, 0.05278030f, 0.26584899f, -0.11108126f, 
    0.05672510f, 0.08525047f, -0.47081503f, -0.30093086f, -0.10095102f, -0.01157249f, -0.08190989f, 0.27928847f, 
    -0.27089703f, 0.04307444f, 0.32194483f, -0.42055556f, -0.05791857f, 0.01719281f, 0.23101701f, 0.05802918f, 
    -0.06970235f, -0.04180377f, 0.25636518f, -0.05838184f, 0.06320379f, 0.17480987f, 0.01911061f, 0.18026462f, 
    -0.05171892f, -0.00840920f, -0.21404751f, 0.16196629f, -0.08496296f, 0.25533178f, -0.28344905f, 0.51542807f, 
    -0.36073518f, 0.37884352f, -0.01155665f, 0.11918725f, 0.30918211f, 0.23329592f, 0.32928261f, 0.07398813f, 
    0.10747047f, -0.13967867f, 0.03952764f, 0.11460361f, -0.08384613f, -0.00846796f, -0.03206833f, -0.03335067f, 
    -0.05307318f, 0.02026731f, -0.05423455f, -0.06900097f, -0.00893980f, 0.00711072f, -0.01229908f, -0.00673644f, 
    0.05060311f, -0.10533098f, 0.04696567f, 0.00215243f, -0.11260708f, 0.07814486f, -0.08691576f, -0.11254840f, 
    -0.10150793f, 0.08845372f, -0.11599463f, -0.15832111f, 0.04624503f, -0.09986800f, -0.10376500f, 0.04899883f, 
    -0.06941983f, -0.15318689f, -0.08134647f, -0.00291496f, -0.04782470f, 0.08650288f, -0.11610137f, -0.02887696f, 
    0.08673346f, -0.10177521f, 0.05290936f, 0.00693414f, -0.12890837f, -0.07757872f, -0.02004038f, -0.05854730f, 
    -0.00972015f, -0.14072092f, -0.06540565f, 0.01247542f, -0.06490090f, -0.07012679f, -0.12130588f, -0.10234103f, 
    -0.10336469f, -0.08570477f, 0.05827941f, 0.04589467f, 0.10188269f, 0.03109006f, -0.02709765f, 0.01615383f, 
    -0.15877546f, -0.02102667f, -0.05507796f, 0.06259368f, 0.03483047f, -0.05752255f, -0.07063881f, 0.02294316f, 
    0.07364447f, 0.11565009f, -0.03781304f, 0.09506464f, 0.01369181f, -0.11159492f, -0.04288499f, 0.09188318f, 
    0.07021521f, -0.16018321f, 0.05925174f, -0.09744270f, -0.08069286f, -0.10004854f, 0.00226781f, -0.01560728f, 
    -0.07190169f, 0.04558210f, -0.06051401f, 0.00493515f, -0.10654377f, 0.07541272f, -0.05628370f, 0.00637289f, 
    0.05115863f, 0.01526121f, 0.00638870f, -0.00136972f, -0.04150212f, 0.11027248f, -0.07490221f, -0.13952471f, 
    -0.04382711f, 0.05905394f, 0.04911778f, -0.07000927f, 0.03188230f, 0.08520284f, -0.00793479f, -0.08359267f, 
    0.01600493f, -0.10330170f, -0.04213827f, 0.08387968f, -0.12016064f, 0.05302984f, 0.02214268f, 0.04221799f, 
    0.01820403f, -0.15162306f, 0.05230983f, 0.06179751f, -0.04209990f, 0.04817989f, -0.14134952f, -0.02633341f, 
    -0.09593336f, -0.08814169f, -0.19843256f, -0.12165645f, -0.06413384f, 0.09168708f, 0.09007595f, 0.22876054f, 
    0.13140227f, 0.02322126f, 0.02000690f, 0.14946480f, 0.07082472f, 0.36999077f, -0.02361889f, 0.01806529f, 
    -0.14224014f, 0.38592151f, 0.04846266f, 0.04763175f, 0.10377553f, -0.23885158f, 0.31799406f, 0.00799859f, 
    -0.00444112f, 0.03710062f, 0.00740116f, 0.10301704f, 0.00524670f, -0.05340230f, 0.26952356f, 0.19771214f, 
    -0.25813678f, -0.03024955f, -0.01290486f, -0.13986343f, -0.31465900f, -0.05366102f, -0.19726199f, 0.16259712f, 
    0.09211782f, 0.11940842f, -0.21557416f, -0.17009577f, -0.11128519f, -0.00362883f, 0.15054931f, -0.04339581f, 
    0.04760571f, 0.14657488f, -0.24153343f, -0.10294980f, -0.04323259f, -0.07643539f, -0.27510756f, 0.64031041f, 
    -0.12519912f, 0.26580083f, 0.09494389f, -0.01004780f, 0.09331478f, -0.14354856f, 0.11605290f, -0.24954835f, 
    -0.24990280f, 0.20157215f, 0.11512575f, -0.08729449f, -0.21753447f, -0.22285168f, 0.12934774f, -0.06331643f, 
    0.02424612f, -0.25217113f, 0.18204775f, 0.30629873f, -0.03858728f, 0.06673057f, 0.05903591f, 0.05642643f, 
    -0.10322365f, -0.25238153f, 0.10440728f, 0.12124468f, -0.14476719f, 0.21205410f, -0.13023470f, -0.06802377f, 
    0.01347042f, 0.07642136f, 0.02076818f, 0.09897973f, 0.31089211f, 0.06585593f, -0.33265841f, 0.07412640f, 
    0.09192416f, 0.19596979f, 0.01178383f, 0.01336016f, 0.14499727f, 0.01234680f, 0.02575451f, -0.00457257f, 
    0.12666112f, -0.00110375f, 0.01545018f, 0.00450659f, -0.10377583f, -0.06847700f, -0.44825229f, -0.10559248f, 
    -0.04354764f, -0.10650938f, 0.27984288f, 0.20033242f, 0.34726426f, -0.18661872f, -0.28634989f, 0.15682940f, 
    0.25611347f, -0.04402277f, -0.22469838f, -0.03269181f, -0.37089610f, -0.23477480f, 0.02386009f, 0.03890160f, 
    0.06133483f, 0.25264698f, 0.20196933f, -0.10779938f, -0.11436705f, -0.00002037f, 0.32546440f, 0.17912623f, 
    -0.04264732f, -0.23028162f, 0.20897673f, -0.12032127f, 0.20299107f, -0.35529247f, -0.05386237f, 0.01868904f, 
    0.30722311f, -0.48297995f, 0.32657257f, 0.00711485f, 0.11231039f, 0.15864407f, -0.12017215f, 0.10958519f, 
    -0.13058549f, 0.06284209f, -0.00039981f, -0.13922815f, 0.27217653f, 0.04079720f, -0.02665779f, 0.07036968f, 
    0.39135760f, 0.29864761f, -0.08775955f, -0.32430410f, -0.15743180f, -0.05834299f, 0.22517069f, -0.16495983f, 
    -0.03306032f, 0.15052736f, -0.41461891f, 0.01438830f, -0.02596666f, -0.10208742f, -0.10373633f, -0.07187770f, 
    0.10891818f, 0.29345566f, -0.03617913f, -0.09038556f, 0.26964322f, 0.05452356f, 0.13426636f, 0.04752094f, 
    -0.08081472f, -0.00494460f, 0.36642927f, 0.00216853f, -0.07534086f, -0.50785059f, -0.32609716f, -0.00419978f, 
    0.09873464f, 0.05250283f, -0.03324059f, -0.01331343f, -0.13786303f, 0.03368089f, -0.09412969f, -0.08466119f, 
    0.02014151f, 0.08753952f, -0.13152854f, -0.06695025f, -0.11514722f, -0.02891351f, 0.09307909f, 0.00026651f, 
    0.08327167f, 0.09613115f, -0.11267436f, -0.11923419f, 0.01904291f, -0.02485264f, -0.01972321f, -0.04312016f, 
    0.11346699f, 0.05867064f, 0.01154740f, 0.02062253f, 0.03748303f, -0.04102415f, 0.01537097f, 0.02503681f, 
    -0.11906190f, -0.04255675f, 0.09068291f, 0.00750794f, -0.10374737f, 0.11297138f, 0.01232394f, 0.08723751f, 
    0.02196496f, 0.04723402f, 0.09543957f, -0.13619630f, 0.00160277f, -0.09552167f, 0.09650261f, -0.00877254f, 
    0.10837704f, 0.09126811f, -0.05934585f, -0.12494133f, 0.08363961f, -0.11894139f, 0.11991239f, -0.03791191f, 
    -0.06883024f, -0.10612032f, -0.07815872f, -0.00166966f, -0.12227291f, -0.14026222f, -0.12234979f, 0.02883942f, 
    -0.05511941f, -0.22917998f, -0.03392300f, -0.07895644f, 0.12367082f, -0.14123149f, 0.19563688f, -0.12267776f, 
    0.11393106f, -0.05215643f, -0.27523088f, -0.06868275f, -0.02651782f, -0.24121085f, -0.04302611f, 0.12868063f, 
    0.28567585f, 0.48017818f, 0.06620923f, -0.03569156f, -0.08379999f, -0.08927145f, -0.10249833f, -0.07420993f, 
    0.04084936f, 0.08928634f, -0.35819075f, -0.02735016f, 0.10018843f, -0.00302911f, 0.61143470f, 0.04369597f, 
    -0.20911296f, -0.09382900f, -0.33105400f, 0.37893531f, 0.15378188f, -0.05163650f, 0.05281127f, 0.12048616f, 
    0.14040948f, 0.06724790f, 0.29935792f, 0.10901002f, 0.25853282f, -0.25574231f, 0.22479936f, 0.12970263f, 
    -0.01233469f, -0.21180156f, 0.17543975f, 0.11068749f, -0.12271081f, 0.06548797f, 0.12186084f, -0.10810293f, 
    0.45495871f, -0.13891505f, 0.05218169f, 0.02419811f, 0.12865271f, 0.53528124f, -0.20600986f, 0.17514555f, 
    -0.12042736f, 0.06527343f, -0.08832391f, -0.00704357f, -0.06542093f, -0.10105427f, -0.11039474f, 0.04396760f, 
    -0.11484663f, 0.01486419f, -0.08446118f, -0.01962303f, 0.00028653f, -0.00234130f, -0.06207351f, -0.10193463f, 
    -0.03703806f, -0.04586828f, -0.09416132f, -0.09801967f, -0.00405601f, 0.03422916f, -0.00794919f, -0.09629141f, 
    0.11505494f, -0.02831005f, 0.03114566f, -0.04209782f, -0.12185659f, 0.07528439f, -0.12619120f, -0.04710303f, 
    -0.13797922f, -0.01243198f, -0.02474068f, 0.02547741f, 0.00039443f, 0.00267534f, -0.10309313f, 0.02929598f, 
    -0.00911197f, -0.10545520f, 0.02317827f, 0.00705682f, 0.02662606f, 0.00209828f, -0.04521281f, -0.03825965f, 
    -0.05331689f, 0.08758640f, -0.09780853f, 0.00810361f, 0.03839034f, 0.02527417f, 0.09652849f, -0.12571327f, 
    0.03158601f, -0.03861189f, -0.04259737f, -0.01834336f, -0.00748645f, -0.04320076f, -0.00450641f, 0.01900058f, 
    0.10614328f, 0.06602399f, 0.22716397f, -0.05314162f, 0.13782944f, -0.02016902f, -0.08920851f, 0.30207232f, 
    0.09726520f, 0.24423727f, -0.13361385f, -0.15426905f, -0.06734257f, 0.00036597f, 0.08655374f, 0.02351167f, 
    -0.00210049f, 0.25828627f, -0.04298222f, -0.10522222f, 0.26114067f, 0.19449611f, -0.49608076f, 0.00897641f, 
    0.07177906f, 0.07100421f, 0.01609596f, 0.08578385f, -0.16515359f, -0.11727826f, 0.33117536f, -0.01942071f, 
    0.17136815f, -0.25188190f, -0.06515579f, -0.20651765f, -0.01949857f, 0.07905066f, 0.09996596f, 0.02058640f, 
    -0.00832877f, -0.07892136f, 0.19387840f, -0.28656623f, 0.06045335f, -0.00591396f, 0.19651307f, -0.01181311f, 
    -0.05211512f, -0.15347685f, -0.04803635f, 0.26833123f, 0.02356970f, 0.37100983f, 0.25033081f, -0.20877117f, 
    -0.25584996f, -0.17746264f, -0.04152180f, -0.04203162f, 0.02949990f, 0.33325005f, 0.13293709f, 0.01409423f, 
    0.03292084f, -0.05676881f, 0.07949391f, 0.06644656f, -0.16521589f, 0.05808674f, 0.14470930f, 0.07382821f, 
    0.12251915f, -0.15936208f, -0.00858256f, 0.40179682f, 0.07218339f, 0.32725811f, -0.00547864f, -0.02307208f, 
    -0.35946539f, -0.05849913f, -0.29893857f, 0.00786346f, 0.17081420f, 0.05807269f, 0.17154947f, 0.07766251f, 
    -0.05292103f, -0.12633051f, 0.06748272f, 0.01581725f, -0.23919910f, -0.04215499f, 0.09071125f, 0.32386923f, 
    -0.00316189f, 0.22013523f, 0.03230068f, -0.32411340f, 0.13211472f, 0.10244428f, -0.09827237f, -0.18148366f, 
    0.09225368f, -0.19350655f, -0.31792602f, -0.27383563f, -0.15488958f, 0.22178090f, 0.14648367f, 0.15134919f, 
    0.07818892f, -0.08330664f, 0.19216664f, 0.06731971f, 0.34743652f, -0.31518880f, -0.14562255f, 0.23005138f, 
    0.46811756f, 0.11172350f, -0.37307703f, -0.12966779f, 0.02456900f, 0.34458807f, 0.02362088f, 0.24255116f, 
    -0.04229290f, -0.02924758f, -0.09436792f, -0.02635236f, -0.10487372f, 0.04648722f, 0.03988995f, 0.07652945f, 
    -0.05126928f, 0.01400894f, 0.12023145f, 0.09115731f, -0.11096041f, -0.06743181f, 0.05552505f, 0.08836402f, 
    0.12128624f, 0.03212123f, -0.13772596f, -0.04499790f, -0.13814777f, 0.08202171f, 0.07978426f, 0.06236504f, 
    0.10818739f, 0.10056251f, -0.06843626f, -0.10631325f, 0.00687215f, -0.02000515f, -0.04524143f, -0.08831783f, 
    0.06602098f, -0.05160999f, -0.06417477f, -0.08165976f, -0.10442343f, -0.00524502f, 0.08928136f, -0.08969965f, 
    -0.11948796f, -0.10897889f, 0.04822139f, -0.09499602f, 0.09152568f, -0.14435607f, -0.11438149f, -0.07674048f, 
    -0.12349334f, -0.03465110f, -0.11446428f, -0.09813160f, -0.11475126f, 0.08705714f, 0.04704435f, -0.07131577f, 
    -0.10738728f, -0.03313880f, 0.06810525f, 0.10107094f, -0.04943945f, 0.11763293f, -0.07223587f, -0.12378290f, 
    -0.02860798f, -0.00842963f, -0.02329221f, 0.01575129f, -0.12462329f, 0.23289500f, 0.02193301f, -0.11071967f, 
    -0.01359032f, 0.02710572f, 0.04569376f, 0.32614625f, -0.09670833f, 0.25985307f, 0.15374023f, 0.13106143f, 
    0.17403331f, -0.14665262f, -0.22000010f, -0.12882596f, -0.06271011f, -0.04135342f, 0.22756726f, -0.08794403f, 
    0.03772140f, 0.05415640f, -0.05178735f, 0.17020145f, 0.15349706f, 0.09153804f, -0.09120969f, 0.17691582f, 
    -0.28552514f, 0.34060606f, -0.12833944f, 0.08719275f, -0.14187802f, -0.01129394f, 0.14747253f, 0.21574375f, 
    -0.01825107f, 0.28327817f, -0.46267205f, 0.05495940f, 0.09944908f, 0.04297853f, 0.03590459f, 0.26172766f, 
    -0.08505980f, 0.03404117f, 0.13654248f, 0.00287494f, -0.05763175f, -0.14751559f, -0.04216017f, -0.30730167f, 
    0.22474627f, 0.28769305f, -0.14879125f, 0.09974014f, 0.35728091f, -0.25013456f, 0.34157190f, -0.12974818f, 
    0.30280966f, 0.07788669f, 0.16875552f, -0.11044815f, -0.34127676f, 0.15123257f, 0.33789855f, 0.21676005f, 
    -0.00436798f, -0.11411555f, 0.01415411f, 0.19050245f, 0.04870460f, -0.08827274f, -0.01841996f, 0.04996461f, 
    0.02372860f, -0.15739720f, -0.07031777f, 0.09128700f, -0.06298430f, 0.15836903f, 0.05631941f, 0.02507681f, 
    0.03847993f, -0.08458456f, -0.05740482f, -0.03803871f, 0.06035758f, 0.12700066f, -0.32341942f, 0.25571281f, 
    0.05133799f, 0.46060833f, 0.07835528f, 0.16476916f, 0.23180811f, 0.04160668f, 0.11447917f, -0.14600280f, 
    -0.26648286f, 0.12673357f, -0.36932388f, 0.02326056f, 0.00089829f, 0.02664524f, 0.18574563f, 0.12594157f, 
    0.04391895f, -0.07748284f, 0.30448750f, 0.19566058f, 0.31701651f, 0.04238101f, -0.05320175f, 0.25038424f, 
    0.43221077f, -0.11464041f, -0.21227515f, -0.04184875f, -0.04020036f, -0.37885624f, -0.15934083f, 0.26260805f, 
    0.30520692f, 0.09848914f, 0.24820472f, 0.11468536f, 0.18545447f, -0.22458510f, 0.02681525f, 0.28557459f, 
    -0.05487056f, 0.12533022f, -0.11588946f, -0.06799789f, 0.06669150f, -0.22004184f, -0.11688481f, 0.04809387f, 
    -0.07773800f, -0.04813158f, -0.01595490f, 0.09241993f, 0.08374632f, 0.04088014f, -0.03391176f, -0.10069204f, 
    -0.01006842f, -0.16469045f, 0.29301965f, 0.27921972f, -0.04722882f, -0.09692051f, 0.31459340f, -0.18242571f, 
    0.12889753f, -0.02689037f, 0.23234342f, 0.03426205f, 0.24064644f, 0.09379017f, 0.41110280f, -0.01923653f, 
    0.14597645f, -0.06737512f, 0.14062719f, -0.07777427f, -0.12539920f, -0.19247203f, 0.28308421f, 0.39353648f, 
    0.05424444f, -0.22922315f, 0.29296854f, 0.28578645f, 0.14421950f, 0.09140763f, -0.02842081f, 0.15382206f, 
    0.17060146f, -0.19244674f, -0.14494957f, -0.03335596f, 0.03485097f, 0.59975791f, -0.09144528f, 0.27573702f, 
    0.06577551f, -0.02645298f, 0.08894087f, -0.02874887f, 0.03556279f, -0.00733108f, 0.15355359f, -0.17973936f, 
    0.11477817f, 0.24153894f, 0.19289784f, -0.10822780f, -0.09623799f, 0.02883864f, 0.02233754f, -0.11521985f, 
    -0.10261437f, 0.12656377f, -0.05522867f, -0.10307149f, -0.27780271f, -0.25046477f, 0.39273876f, -0.08584524f, 
    0.10212956f, 0.10504147f, -0.09480338f, 0.25372070f, 0.07814312f, 0.04775062f, -0.03983335f, -0.17413159f, 
    -0.28607431f, 0.08760204f, 0.04351010f, 0.15610693f, -0.20653561f, 0.10683750f, 0.07872611f, 0.10771667f, 
    0.21676955f, 0.44765973f, -0.20337257f, 0.18636169f, 0.24222024f, -0.21743840f, 0.08408637f, -0.10104080f, 
    -0.11564453f, 0.26296067f, 0.21307285f, 0.30193856f, 0.05767356f, -0.08081745f, 0.07887788f, 0.30290762f, 
    -0.02369612f, 0.10764461f, 0.31268749f, 0.14858070f, 0.12879002f, -0.37863874f, 0.07861236f, -0.15665038f, 
    -0.04242362f, 0.25359127f, -0.14380212f, -0.08770360f, -0.12952843f, 0.19203851f, -0.12749150f, -0.05557099f, 
    -0.01571986f, -0.14405073f, 0.02601822f, 0.35214213f, 0.18092866f, 0.15488148f, 0.10992067f, -0.12266961f, 
    0.02053825f, -0.30611017f, 0.03818970f, -0.01725101f, 0.14870965f, 0.26248237f, -0.14936584f, 0.07957628f, 
    0.08501450f, 0.02094569f, -0.07848474f, -0.40366232f, -0.00094531f, 0.06540778f, -0.33866790f, 0.35677654f, 
    0.21214285f, 0.18728566f, -0.09784196f, -0.19100301f, 0.14361651f, -0.04898284f, -0.02708453f, -0.00861020f, 
    -0.21319430f, -0.20966309f, -0.22094469f, 0.02053422f, -0.03569672f, 0.21855794f, -0.06696200f, -0.06078785f, 
    -0.09294195f, 0.22111626f, -0.20016408f, -0.25447968f, 0.06303913f, 0.07643866f, 0.07686772f, -0.17654915f, 
    -0.03449808f, 0.27958113f, 0.00965734f, 0.06163412f, 0.27693895f, -0.30100444f, -0.04529499f, 0.16377276f, 
    -0.28227150f, -0.02000982f, -0.11470076f, 0.10274175f, 0.32844970f, 0.14974375f, -0.29143348f, -0.29747704f, 
    -0.09522696f, 0.05607765f, 0.19386232f, -0.03529618f, 0.09285795f, 0.18851669f, 0.09729518f, 0.03155760f, 
    -0.52967000f, 0.40332073f, 0.23771681f, 0.02879323f, -0.10712179f, 0.06956172f, -0.01830858f, -0.10671106f, 
    0.16748232f, -0.08334037f, 0.04743160f, -0.14684071f, 0.08481045f, 0.08591639f, 0.26492679f, 0.06500506f, 
    0.04668678f, -0.37890989f, 0.19900870f, 0.21527213f, -0.00535780f, 0.01900144f, -0.49991834f, 0.11961659f, 
    0.25264144f, -0.00263589f, 0.07025577f, 0.21837988f, 0.00299459f, 0.26491603f, -0.10262472f, -0.36938068f, 
    0.10247096f, 0.22420077f, -0.45735344f, -0.33778623f, -0.34402132f, -0.02414520f, 0.18230052f, -0.03173973f, 
    -0.18509385f, 0.10905992f, 0.26026794f, 0.04612436f, -0.06797808f, 0.11572047f, 0.10188498f, -0.15370053f, 
    -0.03813106f, -0.11020912f, 0.09354398f, -0.12008348f, 0.45031253f, 0.08296063f, 0.04750709f, -0.27133411f, 
    0.09083626f, 0.19738407f, 0.21454258f, -0.14779764f, 0.14634855f, -0.05593405f, 0.02173438f, -0.04860638f, 
    0.14770159f, 0.37891194f, 0.25862423f, 0.13393036f, -0.21032298f, -0.01782405f, -0.09933366f, 0.09181735f, 
    -0.03811039f, 0.13379636f, 0.26407352f, 0.05225186f, 0.02480676f, -0.12842007f, 0.43738881f, -0.22032954f, 
    0.16910191f, -0.28144258f, -0.07646442f, 0.16823943f, 0.05953711f, -0.12024334f, 0.01315579f, 0.26696283f, 
    0.31527457f, 0.19541490f, 0.25662392f, 0.28280365f, 0.29847056f, 0.04900350f, 0.00104031f, -0.05276731f, 
    -0.04042964f, 0.13109887f, 0.00577936f, 0.11409993f, -0.17597795f, 0.10862587f, 0.63062930f, -0.28701851f, 
    -0.17354409f, -0.12205585f, 0.60293710f, -0.09036854f, 0.01030672f, 0.22557139f, -0.14057703f, -0.13511504f, 
    0.05129635f, -0.09049701f, -0.01595259f, 0.01904958f, -0.01507220f, 0.17280780f, 0.44889590f, -0.24737051f, 
    0.04214167f, 0.22163540f, -0.27195498f, 0.00162283f, -0.02032372f, -0.19430484f, 0.04660494f, -0.01334919f, 
    0.16794726f, 0.17292850f, 0.09470945f, -0.03267770f, -0.25621986f, -0.04398498f, -0.11880352f, -0.07161173f, 
    0.06142915f, 0.02388160f, -0.33818343f, 0.11669751f, 0.17969923f, 0.09929591f, -0.01091563f, 0.19010097f, 
    0.04889848f, 0.33772874f, 0.13983063f, 0.19938953f, -0.27561310f, -0.06205522f, 0.18514521f, 0.35483846f, 
    -0.13102674f, 0.22896110f, -0.15446745f, 0.09098680f, 0.22825962f, -0.22326134f, -0.11059788f, 0.05877381f, 
    0.03857943f, 0.18355030f, 0.38848332f, 0.26540282f, 0.03411650f, -0.03297497f, -0.01761749f, -0.29842329f, 
    0.34171915f, -0.13000041f, 0.29996872f, -0.07395750f, 0.15980113f, -0.32112753f, -0.08544530f, -0.01484223f, 
    0.19929311f, 0.08922376f, 0.00759671f, 0.09893578f, 0.00645464f, 0.19230078f, -0.16464806f, -0.00298698f, 
    0.05390848f, -0.15388735f, 0.07921305f, 0.37393209f, 0.10398520f, 0.21318211f, -0.00280200f, 0.10226165f, 
    -0.19147988f, 0.12610266f, 0.04393494f, -0.03349778f, 0.33521265f, 0.23375207f, -0.11281749f, -0.05306781f, 
    0.13002238f, 0.00408770f, 0.09974671f, -0.19717880f, -0.16383903f, 0.00173681f, 0.14565104f, 0.20855838f, 
    0.24675152f, 0.03544049f, 0.11646839f, -0.06481721f, 0.09039412f, -0.04983478f, -0.17003857f, -0.04434670f, 
    0.01813273f, -0.32129702f, 0.01970390f, -0.10807812f, -0.07917118f, 0.27498233f, 0.01797705f, 0.03431763f, 
    -0.04367572f, 0.08960973f, -0.03799516f, -0.24562329f, 0.14934184f, -0.08353455f, -0.17226262f, 0.35502470f, 
    0.10730510f, -0.05505623f, -0.15460649f, -0.02244599f, 0.05003651f, 0.45629600f, 0.11205149f, 0.03454109f, 
    0.04708228f, 0.09200142f, -0.12366018f, -0.08655441f, 0.08428301f, 0.04813528f, -0.12634586f, 0.01430407f, 
    -0.02540636f, -0.07435259f, -0.11770342f, 0.00933077f, -0.09984145f, -0.13810459f, -0.00723234f, 0.11420122f, 
    0.06966764f, -0.02484148f, 0.03407053f, 0.04991531f, -0.07916379f, -0.04668955f, -0.12057701f, 0.08208783f, 
    -0.07304905f, 0.08022998f, -0.03664507f, -0.01556905f, 0.02396088f, -0.09777425f, 0.12571305f, -0.06425888f, 
    -0.12259421f, -0.08049358f, -0.00740157f, -0.07698523f, 0.11684905f, 0.00064607f, 0.06586578f, -0.06821131f, 
    0.07271403f, -0.11054116f, -0.04834253f, 0.06417381f, -0.04525431f, -0.06928013f, -0.04534561f, -0.04259338f, 
    0.01278231f, -0.08883696f, -0.07830130f, -0.01618573f, -0.04238811f, -0.02679488f, -0.06949995f, -0.01435285f, 
    0.01580828f, -0.02487519f, -0.10198891f, 0.10458092f, 0.04271642f, -0.09184355f, 0.05560830f, 0.00621262f, 
    -0.01791142f, -0.02788010f, -0.17275186f, 0.03658307f, -0.14823338f, 0.07058195f, 0.00784340f, 0.16936146f, 
    -0.05632886f, -0.10603006f, 0.13758323f, 0.01263975f, -0.04137238f, -0.02434945f, -0.13573678f, 0.11773601f, 
    0.23301204f, -0.26772347f, 0.18605769f, -0.02036773f, 0.10769746f, -0.00411014f, 0.54887402f, -0.04677295f, 
    -0.02809074f, -0.07986420f, -0.15735498f, -0.02888680f, 0.17729174f, 0.06780513f, -0.30980936f, -0.24114890f, 
    -0.11110496f, 0.19661579f, -0.03518336f, 0.26984993f, 0.16081461f, -0.05634926f, 0.11390609f, -0.28052306f, 
    0.02362075f, 0.19153564f, 0.04170578f, 0.35405436f, -0.12100323f, -0.02702666f, 0.24196945f, 0.25821948f, 
    0.04682611f, -0.06686231f, -0.02036026f, 0.12480782f, -0.16529527f, 0.16260576f, 0.02207958f, -0.18739073f, 
    -0.20626830f, 0.47810704f, 0.15842912f, -0.00370765f, 0.35430720f, -0.25613472f, -0.07448496f, 0.27617317f, 
    -0.12366872f, 0.14072713f, 0.16432798f, -0.01512507f, 0.30591577f, -0.13543512f, 0.07893372f, -0.25814870f, 
    -0.11353064f, -0.16780670f, 0.28419474f, -0.25062236f, 0.10415178f, -0.01542243f, 0.03859700f, 0.01723171f, 
    0.02433689f, -0.00846776f, -0.21073410f, -0.02419727f, -0.16895868f, -0.11256185f, 0.12251348f, -0.07207090f, 
    -0.01535988f, -0.02053855f, 0.17002423f, 0.36372474f, 0.13619146f, -0.08540535f, 0.33872920f, -0.19854493f, 
    -0.19076166f, -0.24888636f, -0.17344102f, -0.11601843f, 0.19140479f, 0.03358913f, 0.25088853f, -0.09820460f, 
    0.24579094f, 0.14654185f, 0.42143923f, 0.03970885f, 0.13561775f, 0.00140175f, 0.06913297f, 0.21837592f, 
    0.01783524f, -0.13080646f, 0.01209439f, 0.24599397f, -0.09017301f, -0.08564173f, 0.35828960f, -0.37911621f, 
    -0.25640342f, 0.14419858f, -0.02898542f, -0.07011548f, 0.01341169f, 0.46276134f, 0.28737924f, 0.16655397f, 
    -0.12854999f, -0.00863585f, 0.06261207f, -0.05913274f, -0.10410096f, -0.11026759f, 0.08841278f, -0.05145738f, 
    0.07906671f, 0.01116153f, -0.09193451f, -0.11258201f, -0.04731208f, -0.01055617f, -0.11077617f, 0.03442250f, 
    -0.02767064f, 0.08072522f, 0.07284193f, -0.08371846f, -0.09808595f, 0.01213681f, 0.06838687f, -0.08565859f, 
    0.06850104f, 0.04869427f, 0.07013056f, -0.09363035f, 0.01240648f, 0.01108633f, -0.09982511f, -0.03578372f, 
    0.00900385f, -0.06828646f, 0.01622283f, 0.00982754f, -0.10089882f, 0.10628840f, -0.02816120f, -0.11906894f, 
    0.11330736f, -0.02454624f, -0.02328560f, 0.10320305f, 0.05591061f, -0.10091416f, -0.05772313f, -0.05894963f, 
    -0.02571447f, -0.07435624f, 0.07882430f, -0.09557146f, -0.04963976f, 0.03002547f, -0.01091026f, -0.08201843f, 
    0.11945648f, -0.08746170f, -0.11890689f, 0.02920026f, -0.01246532f, 0.06461377f, -0.13006634f, -0.00268171f, 
    0.06083141f, 0.00018883f, -0.03533493f, -0.00035873f, 0.13546081f, -0.00229419f, -0.20238730f, 0.22890857f, 
    0.02894719f, -0.06056462f, -0.45679736f, 0.01379746f, -0.02316824f, -0.24216305f, 0.11410202f, 0.08244231f, 
    -0.03489967f, 0.41753745f, 0.14712694f, -0.09748843f, 0.00784876f, 0.17293979f, 0.04473187f, -0.02127958f, 
    0.07435051f, -0.04860384f, -0.30835888f, -0.23262411f, 0.02460121f, -0.02850157f, -0.00626096f, 0.11463714f, 
    0.15947947f, 0.13914602f, -0.19089991f, 0.01467580f, 0.13371609f, 0.11076660f, 0.22360654f, 0.13647218f, 
    -0.29253662f, -0.13565238f, 0.36132202f, -0.21518694f, 0.23040853f, 0.05718838f, 0.20873043f, 0.29278600f, 
    0.06106358f, -0.18464343f, 0.03264127f, 0.22263399f, 0.04241669f, 0.19612527f, -0.25400800f, -0.15107699f, 
    -0.09911779f, -0.08118960f, -0.14969073f, 0.13500419f, 0.15226291f, 0.49756119f, 0.01276982f, -0.00072889f, 
    -0.00336181f, 0.14027768f, 0.09892801f, -0.00280103f, 0.16003937f, -0.14840622f, 0.15100165f, -0.06139760f, 
    0.01702131f, -0.22509216f, 0.26890075f, 0.16810714f, 0.12504452f, -0.21011589f, -0.03636345f, -0.04299933f, 
    -0.10934769f, -0.46758568f, 0.34667626f, -0.07560841f, -0.17262639f, 0.27908796f, -0.38502514f, -0.01430518f, 
    -0.11863979f, 0.14025646f, 0.31415775f, -0.04813979f, 0.32849413f, 0.08216713f, 0.09766401f, -0.12226316f, 
    0.42725995f, -0.01360552f, -0.05953185f, 0.19415615f, 0.17436840f, -0.05993397f, 0.11225676f, -0.16265532f, 
    0.08151325f, -0.08356261f, 0.11135331f, 0.22038288f, 0.04226347f, 0.05844191f, -0.17194308f, -0.08120162f, 
    0.00249392f, -0.11261474f, 0.09102181f, -0.07247205f, 0.14182261f, -0.31318945f, 0.07461657f, -0.05970993f, 
    0.28669354f, -0.08213175f, 0.10740252f, -0.04111309f, -0.32299542f, -0.36177981f, -0.00773167f, 0.04873663f, 
    0.04959230f, 0.20334788f, -0.09440979f, 0.01182440f, 0.29447305f, 0.13314633f, -0.17808947f, 0.05052085f, 
    0.01333936f, -0.08700134f, 0.28332880f, -0.13226196f, -0.03995031f, 0.06225410f, -0.10541049f, -0.00552299f, 
    0.39339870f, -0.19298445f, 0.11182222f, 0.02828929f, -0.05742397f, 0.02432958f, 0.12085645f, -0.10318660f, 
    -0.06846029f, 0.07112624f, -0.08562396f, 0.05991192f, 0.18353182f, 0.10488684f, -0.22669615f, -0.11475551f, 
    -0.14578255f, -0.03285508f, 0.02081532f, -0.05610939f, -0.08071233f, 0.03309063f, 0.16606808f, -0.04588364f, 
    0.09585114f, 0.04101015f, -0.00228524f, 0.28169096f, 0.05334776f, 0.23374327f, -0.02706186f, 0.18066341f, 
    -0.00654602f, 0.25839368f, -0.21114624f, -0.11786773f, -0.17102909f, 0.03427533f, 0.26054528f, -0.26780811f, 
    -0.19797660f, 0.18799442f, 0.34643906f, 0.04996566f, 0.11681648f, -0.41109261f, 0.27548754f, 0.13488723f, 
    0.20247664f, 0.15822731f, -0.21402211f, 0.00117664f, -0.01341213f, 0.16074820f, 0.10019062f, 0.39973229f, 
    0.01302563f, -0.09580155f, 0.18734111f, 0.10371061f, 0.12955652f, -0.07116432f, -0.12794700f, 0.05617233f, 
    0.23818778f, -0.18375763f, 0.38807860f, -0.05845340f, 0.33111337f, 0.21983646f, 0.13255274f, 0.02689501f, 
    0.05557301f, 0.08780088f, -0.18504192f, -0.26684663f, 0.06858756f, -0.10838699f, -0.23436446f, -0.07305215f, 
    0.10229264f, 0.16994995f, -0.03172826f, 0.23163655f, 0.27909127f, 0.06283552f, -0.01623323f, -0.29522225f, 
    -0.26084462f, -0.18354937f, 0.11291377f, 0.26239511f, -0.00916369f, -0.01648493f, 0.16411114f, 0.01719557f, 
    0.09828765f, -0.06746005f, 0.01744718f, 0.05885582f, -0.01330508f, -0.07204352f, -0.09038070f, -0.13855644f, 
    0.18642490f, 0.38487700f, -0.10498320f, 0.07192440f, 0.20093930f, -0.01314353f, -0.31463182f, 0.37130764f, 
    -0.25522092f, 0.00563429f, -0.20648196f, 0.07148646f, 0.23339725f, -0.20278189f, -0.17627670f, -0.07141823f, 
    -0.04034731f, 0.12615560f, 0.04383453f, -0.08872183f, 0.06898753f, 0.13995267f, -0.09647021f, -0.04559270f, 
    -0.54183334f, 0.57206064f, 0.11639378f, 0.04196320f, -0.27070445f, -0.01948217f, -0.17849979f, -0.11752302f, 
    0.14624850f, 0.08129486f, 0.10517631f, 0.04342597f, 0.19321990f, 0.03440991f, -0.16458383f, 0.09662207f, 
    -0.03849420f, -0.34650069f, 0.50077975f, 0.11552238f, -0.27556911f, 0.07877766f, 0.04896830f, 0.30008638f, 
    0.24287921f, 0.08628024f, -0.11685578f, 0.17667493f, 0.24778403f, 0.02430484f, -0.38895127f, 0.12094919f, 
    0.01401716f, 0.08793175f, -0.28092253f, 0.08768274f, -0.04336725f, -0.14111407f, -0.04137225f, 0.55111665f, 
    -0.14710829f, 0.07578780f, 0.15604851f, 0.04512035f, -0.20002075f, 0.04973249f, 0.34027126f, -0.30412662f, 
    0.15457831f, -0.03229938f, 0.02656301f, -0.08379127f, -0.04812851f, 0.18104738f, -0.13570809f, 0.38233313f, 
    -0.09011206f, -0.10118999f, 0.13934040f, 0.33417469f, -0.04315353f, 0.36208096f, 0.03301558f, 0.00356294f, 
    -0.22120802f, 0.02556793f, -0.30259350f, -0.07736786f, 0.42953712f, -0.00790647f, 0.41866553f, -0.06343369f, 
    0.01798981f, 0.05426906f, -0.04891776f, -0.06117282f, -0.23674345f, 0.03898482f, 0.10919507f, 0.38812357f, 
    0.00381713f, 0.09168121f, 0.30143252f, -0.18406397f, 0.28916293f, 0.06399763f, 0.03646608f, -0.31311244f, 
    -0.02965013f, -0.11917087f, -0.14621131f, -0.25725347f, -0.00647828f, 0.15747318f, 0.47182733f, 0.10703454f, 
    -0.01967872f, -0.15127374f, 0.02546690f, -0.08701707f, 0.21239316f, -0.23400234f, -0.26914957f, 0.32089403f, 
    0.28601027f, 0.32656291f, -0.20352823f, -0.12506394f, 0.30144337f, 0.53220254f, -0.05624695f, 0.35641724f, 
    0.19230379f, -0.06609957f, -0.04938171f, 0.05717519f, 0.17823973f, -0.13944145f, 0.04571883f, 0.09847432f, 
    0.03929640f, 0.11413518f, -0.25786257f, -0.03232161f, -0.04824983f, -0.25389808f, 0.00969872f, -0.12088020f, 
    0.15770316f, 0.32380423f, 0.16429317f, 0.04431466f, -0.10603669f, -0.10320780f, -0.25542110f, 0.08816974f, 
    -0.14584401f, -0.01093426f, -0.69783390f, -0.24485578f, 0.21286105f, -0.02011966f, 0.10364650f, 0.13143757f, 
    -0.10832541f, 0.21097001f, -0.20632777f, 0.00532147f, 0.06443276f, -0.09769186f, 0.14784053f, 0.15053882f, 
    -0.36240542f, 0.09069311f, 0.69695860f, 0.00765197f, 0.13058071f, -0.31833202f, 0.18333010f, 0.34175318f, 
    0.07970133f, -0.17080015f, 0.27944356f, -0.00192922f, -0.02046857f, 0.26757270f, -0.17066896f, 0.04188985f, 
    0.14279851f, 0.12241040f, 0.24406172f, 0.04656732f, 0.30414245f, 0.42833745f, -0.14578821f, 0.16475897f, 
    0.00824878f, -0.08380964f, -0.06448581f, 0.05124016f, 0.07877258f, -0.14890844f, 0.00527398f, 0.19697016f, 
    0.08558288f, -0.10444192f, -0.00069901f, 0.07306501f, -0.08052678f, -0.03179276f, -0.05319797f, 0.11354994f, 
    0.52094340f, 0.07054135f, 0.06990434f, -0.06505061f, -0.08660184f, 0.11292568f, 0.06667887f, 0.00574073f, 
    -0.08779320f, 0.03227548f, -0.08452015f, -0.16586240f, -0.10880802f, 0.06124137f, 0.11447141f, -0.11204135f, 
    -0.06561334f, 0.12968431f, 0.11875188f, 0.02866475f, 0.06902295f, 0.03796554f, 0.05133350f, 0.02928022f, 
    -0.04075243f, -0.02694470f, 0.07154947f, -0.05311008f, -0.15490380f, -0.09033930f, 0.03156875f, 0.03841013f, 
    -0.03709476f, 0.10665607f, 0.03122640f, -0.06867006f, -0.12442460f, 0.08780839f, 0.08540155f, -0.03100916f, 
    0.06672779f, -0.04735057f, -0.10729185f, -0.08771586f, -0.05661426f, -0.01721721f, -0.00678953f, 0.05094716f, 
    0.03860286f, -0.11495558f, 0.11480910f, -0.08665636f, -0.13153890f, -0.02882130f, -0.11067821f, -0.00992385f, 
    -0.09637502f, -0.00835873f, 0.08634090f, 0.10031564f, -0.02117640f, -0.13941024f, -0.11300248f, -0.01135626f, 
    -0.01845054f, -0.11676881f, -0.00802515f, -0.03720002f, 0.03628409f, -0.13884148f, 0.12296413f, 0.05054334f, 
    -0.04253179f, -0.01426975f, 0.01932613f, -0.09230127f, -0.10813594f, -0.02043027f, -0.11558218f, -0.12143277f, 
    -0.12624630f, -0.12214088f, -0.02720930f, 0.08980487f, 0.05969688f, -0.08360989f, 0.00724963f, -0.06264012f, 
    0.08307358f, 0.00467006f, 0.00449811f, 0.08351938f, -0.13758869f, -0.11646634f, -0.00910668f, -0.12513098f, 
    0.06911752f, -0.05184880f, -0.12483248f, -0.13685869f, -0.04277505f, -0.08413208f, -0.10903989f, 0.07315063f, 
    -0.09871599f, -0.02506908f, 0.03580317f, -0.02206670f, -0.08606591f, 0.03354484f, 0.00439512f, 0.07142343f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00113674f, -0.09892433f, -0.12346844f, 0.00115296f, -0.12516895f, -0.18937971f, 0.10784358f, -0.16346581f, 
    -0.06987402f, -0.07262056f, 0.06378757f, -0.02546313f, -0.04412869f, -0.00194427f, -0.00737649f, 0.24467218f, 
    -0.06586348f, 0.00816046f, 0.01635956f, 0.10275932f, -0.00934981f, 0.22800006f, 0.08543759f, -0.04293907f, 
    0.31141296f, -0.07726026f, 0.01892397f, -0.03541811f, 0.05594794f, -0.15421365f, 0.09490058f, -0.09511381f, 
    -0.10942419f, 0.12288211f, 0.08270009f, 0.45427209f, -0.02931956f, -0.15998605f, -0.08012235f, -0.12491193f, 
    0.06274754f, -0.14814766f, -0.03232638f, 0.10348821f, 0.12879668f, 0.09067638f, 0.13492949f, -0.02606384f, 
    0.04462742f, 0.21084258f, 0.05029554f, -0.08871067f, -0.11430549f, -0.06554207f, 0.06788116f, -0.01320556f, 
    0.14990659f, 0.16540499f, 0.10643525f, 0.03412034f, 0.01590279f, 0.16046488f, 0.03484399f, -0.02154147f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.01156342f, -0.10682513f, -0.19407484f, 0.19700253f, 0.17884731f, -0.35152736f, -0.06220987f, 0.05410623f, 
    -0.34835702f, 0.26293424f, -0.09032724f, 0.08771232f, -0.19201051f, 0.05539736f, 0.22603869f, -0.14614788f, 
    0.09912535f, -0.67718899f, 0.25370485f, 0.15334308f, 0.04815781f, -0.20531029f, 0.08760174f, -0.08650941f, 
    -0.67449385f, 0.00201862f, 0.42474812f, -0.46727461f, -0.03209919f, 0.09132482f, -0.14721833f, 0.05705073f, 
    0.01201869f, -0.42721164f, -0.27464476f, -0.04433836f, 0.09166744f, -0.35848108f, 0.04395744f, -0.14885268f, 
    0.07868432f, 0.04011534f, -0.04009435f, 0.11240625f, 0.25030041f, -0.25266114f, -0.03576210f, -0.13466401f, 
    0.01656925f, -0.35559750f, 0.02925308f, 0.00529006f, 0.32085696f, 0.08912437f, 0.10422102f, -0.38727739f, 
    0.11547831f, 0.08844116f, 0.23155160f, -0.30328470f, 0.22610939f, -0.28621027f, -0.07314929f, -0.04228399f, 
    0.06470697f, 0.00905796f, 0.21779391f, 0.07951993f, 0.08011952f, 0.03016182f, 0.02638904f, 0.02546271f, 
    0.19949846f, 0.23257113f, 0.01016376f, -0.06558082f, -0.07041661f, -0.03836218f, -0.29124334f, -0.25458285f, 
    0.03849420f, 0.06592119f, -0.45938268f, 0.08625297f, 0.20030589f, -0.16811372f, -0.07248529f, -0.16075942f, 
    -0.00810038f, -0.08553822f, 0.30067647f, 0.25796866f, 0.02397365f, -0.02557947f, -0.37363359f, -0.07966276f, 
    -0.00802277f, -0.30346861f, -0.06352516f, 0.11775884f, -0.13085432f, -0.15240145f, -0.02230467f, -0.03473191f, 
    -0.39629573f, -0.15085389f, 0.01882244f, -0.19079272f, -0.27857977f, -0.29982942f, 0.19998740f, 0.30962268f, 
    0.13413160f, -0.32205778f, 0.14094314f, 0.00318112f, 0.04310650f, -0.19633658f, 0.10613486f, -0.04257029f, 
    0.21982576f, 0.20186453f, 0.04305778f, -0.10723109f, -0.24923675f, -0.01543042f, 0.05251196f, 0.08051980f, 
    -0.06779066f, 0.06819372f, 0.30566996f, -0.03582691f, 0.16045162f, -0.59479713f, 0.23004355f, -0.49766630f, 
    -0.34448943f, -0.56864363f, -0.04205387f, 0.00457364f, -0.38641056f, 0.11799166f, 0.11619292f, -0.25026202f, 
    0.18183745f, -0.23530114f, 0.23224647f, 0.29223025f, -0.06828825f, 0.15807347f, 0.01839486f, 0.20525835f, 
    -0.26002625f, -0.01307504f, -0.00133428f, -0.39720222f, -0.29448703f, 0.05683561f, -0.31567818f, 0.03140292f, 
    -0.00755211f, -0.29992199f, 0.29910731f, -0.02131027f, 0.05625337f, -0.10381643f, -0.05348607f, -0.36953738f, 
    -0.40261060f, -0.08024546f, 0.21658745f, -0.03898479f, -0.00721587f, 0.31472585f, -0.26753256f, -0.13237506f, 
    0.03590099f, 0.03990739f, -0.45934451f, -0.08512522f, 0.22218257f, 0.48472142f, 0.01333365f, -0.37043518f, 
    0.23147723f, 0.18836057f, -0.14611781f, 0.19435056f, -0.49247065f, -0.20240907f, 0.06167522f, 0.03437941f, 
    -0.16032220f, -0.00511948f, -0.47914627f, -0.38870111f, -0.14192292f, 0.03424771f, -0.58338976f, 0.21733260f, 
    0.11213988f, 0.03562722f, 0.11852671f, 0.09665221f, 0.06511499f, -0.06223524f, 0.00102097f, 0.23677018f, 
    -0.30211130f, -0.14154829f, 0.23533712f, -0.33625266f, -0.15576226f, 0.11210300f, 0.04356483f, -0.09901403f, 
    0.17182980f, 0.09470913f, -0.36554953f, 0.00116258f, 0.13923290f, 0.01753089f, -0.28147787f, 0.07974186f, 
    0.08308340f, 0.04886117f, -0.01591802f, -0.48674709f, -0.05058373f, 0.31753150f, 0.07694285f, 0.12544000f, 
    0.31969637f, -0.11592180f, 0.04051193f, 0.06324758f, 0.23740017f, -0.04097388f, -0.41950169f, -0.03365144f, 
    0.02632770f, 0.09475356f, 0.05474633f, -0.02663369f, -0.26353878f, 0.05451091f, -0.05588929f, 0.21300182f, 
    -0.22649975f, -0.65233278f, -0.25003922f, -0.03527994f, 0.12351627f, 0.11714046f, -0.13347125f, -0.07540905f, 
    -0.05556785f, -0.03844191f, 0.07046027f, 0.10753530f, 0.00418874f, 0.04534043f, -0.05909928f, -0.18902777f, 
    -0.54469192f, 0.00738710f, 0.04228418f, -0.10549794f, -0.11195728f, 0.03487539f, 0.18057989f, 0.04270703f, 
    -0.17756478f, 0.05951153f, 0.32303974f, -0.17990993f, -0.19573404f, 0.15813479f, 0.05650141f, -0.16022907f, 
    0.01489960f, 0.08970213f, -0.26753324f, -0.08593066f, -0.31883046f, -0.12302695f, 0.26559597f, -0.08641958f, 
    0.05792021f, -0.22144687f, -0.09112528f, 0.06826493f, -0.04185421f, -0.35593718f, 0.10238975f, 0.03453119f, 
    -0.07821279f, 0.05882591f, 0.11378991f, 0.10615534f, 0.02985987f, -0.21733916f, 0.16889428f, 0.19938740f, 
    -0.21683891f, 0.09099203f, 0.01595744f, 0.07576597f, 0.17377442f, -0.35493833f, 0.06728645f, 0.30097610f, 
    -0.04171285f, 0.09213100f, 0.10773480f, 0.35438433f, 0.02872243f, 0.24081568f, 0.04091461f, -0.14745651f, 
    -0.00877772f, -0.12478904f, -0.22438985f, 0.21884744f, -0.38585192f, 0.54391599f, -0.05484172f, -0.02844064f, 
    0.18476813f, -0.03669092f, 0.02673159f, 0.00335013f, 0.07862159f, -0.00915244f, -0.08283322f, -0.12604162f, 
    0.24611400f, 0.01106899f, -0.57558149f, -0.26102102f, 0.02630219f, -0.29588252f, -0.05156900f, 0.05166673f, 
    0.02310164f, -0.07936604f, 0.29593268f, 0.00178100f, 0.28474525f, 0.05104259f, -0.20802866f, -0.02021180f, 
    0.01975257f, 0.36334720f, 0.16706580f, 0.24719734f, 0.03754729f, -0.23225504f, 0.08408711f, 0.30361572f, 
    0.17716779f, -0.02442046f, -0.29111153f, 0.13645418f, 0.16033889f, -0.03512731f, -0.00791135f, -0.18523526f, 
    -0.27198672f, -0.40334281f, 0.19815017f, 0.07716217f, -0.19938388f, -0.27620196f, 0.04267781f, 0.07657330f, 
    0.21444723f, -0.18422860f, 0.01006596f, 0.21739404f, 0.10595863f, -0.42266858f, 0.05303684f, -0.04093027f, 
    -0.18030484f, -0.06942021f, 0.17835703f, 0.14159763f, -0.65598834f, -0.73543632f, 0.15164709f, -0.40550694f, 
    0.23744771f, -0.43150386f, 0.10325998f, -0.03646627f, -0.48379770f, -0.07300416f, -0.22101499f, 0.10606381f, 
    0.00055968f, 0.09378394f, 0.11093712f, -0.37848780f, -0.25539261f, 0.08005577f, -0.10090452f, 0.14349325f, 
    0.41899431f, 0.03747862f, -0.30419278f, -0.43256226f, 0.02205414f, 0.06695150f, -0.06360051f, -0.10981642f, 
    0.03236305f, -0.25839752f, 0.26735792f, 0.06490698f, 0.00034416f, -0.25260139f, 0.09359549f, -0.24063896f, 
    0.36551818f, -0.07290838f, 0.19423267f, 0.18669412f, -0.10876264f, -0.49269408f, 0.24727583f, -0.41150883f, 
    -0.48418036f, 0.07120098f, 0.19899710f, 0.00613409f, -0.23708101f, -0.39775270f, -0.03497975f, -0.31925744f, 
    0.16596149f, -0.16209096f, 0.00010422f, -0.52014911f, 0.10968269f, -0.57473963f, -0.10252958f, 0.09651184f, 
    -0.15454406f, -0.11042016f, 0.11000437f, 0.00805077f, 0.08227895f, 0.28621903f, -0.12817109f, 0.09832994f, 
    0.06503724f, 0.05107552f, 0.04516323f, -0.07912418f, 0.00413262f, -0.01123729f, 0.17048092f, -0.02355211f, 
    0.00711597f, -0.33268541f, -0.00420274f, -0.18990402f, 0.14696701f, -0.58717638f, 0.04190027f, -0.43993106f, 
    -0.38188937f, -0.05069989f, 0.23345844f, -0.01798410f, 0.10170283f, -0.07811923f, 0.45487440f, -0.07799616f, 
    -0.10994878f, 0.04918509f, 0.07454762f, -0.56970805f, -0.04276525f, 0.32474014f, -0.06082423f, 0.22307938f, 
    -0.10398676f, 0.06698047f, -0.49887508f, -0.19765623f, 0.13458145f, -0.46000248f, -0.18015757f, 0.06544924f, 
    0.13777189f, -0.35527408f, 0.04941968f, 0.10954291f, 0.04024077f, 0.24786754f, -0.03115716f, 0.22862315f, 
    -0.17148180f, -0.21914344f, 0.03773353f, 0.01104831f, 0.13288739f, 0.23306499f, 0.04380063f, -0.03172233f, 
    -0.02998542f, 0.05786414f, 0.19519271f, -0.27876341f, -0.01756396f, -0.19279325f, 0.08516693f, -0.08078046f, 
    0.10490645f, -0.07783873f, 0.08254038f, -0.01093554f, -0.23576428f, -0.01468045f, -0.50507361f, -0.19529253f, 
    -0.03756709f, 0.14360297f, -0.40774533f, 0.21853572f, 0.11519638f, -0.16314770f, -0.12155238f, 0.14247622f, 
    0.02133840f, -0.08062818f, -0.16091207f, 0.43589732f, 0.01533472f, 0.05541778f, 0.20988719f, 0.05486609f, 
    -0.11208828f, 0.36772022f, -0.59366697f, -0.15036742f, 0.08425736f, -0.26567742f, 0.11111721f, 0.05572877f, 
    -0.44377154f, 0.09889846f, 0.06072284f, -0.25521445f, -0.48170084f, 0.14161323f, -0.10862334f, 0.34358695f, 
    0.23770453f, 0.05741242f, 0.02875527f, -0.00812826f, -0.42113820f, -0.14814910f, -0.03969225f, -0.14177026f, 
    -0.12793298f, 0.19009353f, -0.46885332f, 0.32599935f, -0.48406449f, -0.34558421f, -0.03672692f, -0.07983662f, 
    -0.01241683f, -0.07589357f, -0.29636964f, 0.26540917f, -0.18772185f, 0.06620295f, 0.06722957f, 0.07690503f, 
    -0.16244249f, -0.10889702f, 0.01348539f, 0.11252380f, 0.05129587f, -0.09941792f, -0.08868528f, -0.28714916f, 
    0.06597989f, 0.06492271f, 0.14423044f, 0.24554686f, 0.18250437f, -0.10434647f, -0.12862471f, 0.26009506f, 
    -0.15767492f, -0.00700346f, -0.48243341f, 0.05547692f, -0.21136767f, -0.00569254f, 0.39033279f, -0.06431678f, 
    -0.01190328f, 0.50658756f, -0.22093216f, -0.10491356f, 0.04864579f, -0.66990244f, -0.00327331f, 0.28542343f, 
    0.19020091f, -0.01900290f, 0.22446498f, 0.03758139f, -0.17490689f, 0.09402316f, 0.09714669f, -0.15555784f, 
    -0.35055920f, -0.28300065f, 0.06999769f, -0.10552759f, 0.16696668f, -0.23950437f, -0.03645182f, 0.00218436f, 
    -0.43138286f, 0.06335460f, 0.01677191f, -0.37134048f, 0.25240344f, -0.42650536f, -0.04720721f, 0.03760568f, 
    -0.16462199f, -0.03581074f, -0.35490960f, -0.46295941f, -0.18743756f, -0.19700418f, -0.36625537f, 0.14337312f, 
    -0.40371579f, 0.08007488f, -0.02146912f, 0.00512910f, 0.15596811f, 0.01604565f, -0.10854251f, 0.30565220f, 
    -0.46059680f, -0.02251848f, -0.51231539f, 0.32039478f, -0.51918846f, 0.09847776f, 0.06397857f, 0.11303997f, 
    0.17266864f, -0.04073070f, -0.26044181f, -0.31760272f, 0.37543580f, -0.04910073f, -0.05287689f, 0.02649722f, 
    0.04360534f, -0.12201664f, -0.26014146f, 0.29609856f, -0.05771926f, -0.08584357f, -0.03068818f, 0.20499429f, 
    -0.44729716f, -0.04370782f, -0.04650258f, -0.00922044f, 0.14920795f, 0.21480823f, -0.46996978f, -0.40467200f, 
    0.30061743f, 0.16846663f, -0.37426916f, 0.06480440f, -0.14354666f, 0.20270798f, 0.08215227f, -0.08096630f, 
    -0.04377052f, -0.01693073f, -0.38774252f, 0.02559707f, -0.60529411f, -0.13162348f, 0.00875253f, 0.07136275f, 
    -0.08532890f, 0.02877701f, 0.17256236f, -0.31643277f, 0.18741901f, -0.34446090f, -0.10528474f, 0.05088548f, 
    -0.10414178f, 0.19944637f, 0.09048412f, 0.09706119f, -0.26784405f, 0.05565584f, -0.20621981f, 0.14660755f, 
    -0.64522684f, 0.32570571f, 0.19525321f, -0.28614992f, -0.26097161f, 0.19483376f, 0.05547469f, -0.17229010f, 
    0.11317338f, -0.04099540f, -0.11693460f, 0.10321607f, -0.23144214f, 0.03267392f, -0.48493427f, -0.14536579f, 
    0.10844777f, -0.15754648f, 0.00814413f, 0.16121490f, -0.12554298f, 0.08729055f, -0.07989059f, -0.25234658f, 
    -0.17970349f, -0.06985129f, -0.00130324f, 0.19131160f, -0.06301724f, 0.24728198f, -0.19900568f, -0.25849116f, 
    0.15958798f, 0.36001998f, -0.28013182f, 0.06051537f, 0.26391703f, -0.24925384f, -0.09514859f, -0.09771521f, 
    0.12510607f, -0.11286283f, 0.15274541f, -0.28640229f, -0.32177356f, 0.09454183f, 0.07923811f, -0.08932221f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.12372626f, -0.15629907f, -0.10731555f, -0.14041938f, 0.07726382f, 0.14173803f, 0.05595261f, -0.13373558f, 
    -0.11571401f, 0.00516517f, 0.23934077f, 0.09185525f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
