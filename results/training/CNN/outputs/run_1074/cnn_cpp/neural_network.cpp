#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.12710679f, -0.22026160f, 0.05090762f, -0.16091737f, 0.40060559f, -0.06917424f, -0.05438403f, 0.01119309f, 
    -0.26918292f, -0.35443762f, -0.00908870f, 0.42609376f, -0.18062375f, -0.13145255f, -0.18076906f, -0.33903831f, 
    -0.10633070f, -0.10572145f, -0.25972286f, -0.19339873f, -0.06469759f, 0.39772886f, -0.18005228f, -0.17359293f, 
    -0.08285140f, 0.23141794f, -0.32605591f, -0.20752421f, -0.80575377f, -0.33888721f, -0.11623127f, -0.32064503f, 
    0.39570647f, 0.35446480f, 0.23689228f, -0.37555280f, 0.05797977f, 0.48852015f, -0.05661747f, -0.17787783f, 
    0.13484493f, -0.06985199f, -0.10639063f, 0.10029541f, -0.03177057f, 0.13157190f, 0.02349148f, -0.16313276f, 
    -0.21954764f, -0.50616676f, 0.21915486f, 0.23846558f, 0.15410762f, 0.00117388f, -0.12547743f, 0.24861652f, 
    0.01461608f, -0.06436589f, 0.00464866f, 0.07301778f, 0.09510446f, 0.15552112f, 0.05100851f, 0.01315101f, 
    0.01742009f, -0.04536689f, 0.06103024f, 0.19849728f, 0.11318259f, -0.34245855f, 0.05199569f, 0.24719721f, 
    -0.06362265f, 0.02036827f, 0.01231964f, 0.20509569f, 0.19088827f, 0.05358361f, -0.53681505f, -0.03674031f, 
    -0.29820824f, -0.06049461f, 0.34320632f, -0.04980470f, 0.05289103f, 0.20735009f, 0.04279063f, 0.10345864f, 
    0.17369635f, 0.12550670f, -0.18704851f, 0.17541035f, -0.24552499f, 0.16886279f, -0.12372962f, 0.08512802f, 
    0.12061699f, -0.17267950f, 0.10540694f, -0.13460547f, 0.09476875f, 0.27895385f, 0.05406418f, 0.20141318f, 
    -0.23339805f, -0.48195505f, -0.09470622f, -0.03498139f, 0.21001506f, 0.27693930f, -0.21335192f, -0.24282476f, 
    0.48953938f, -0.40400535f, 0.08812203f, -0.01738478f, 0.23974608f, 0.35156614f, -0.32235914f, -0.41292444f, 
    0.31650886f, -0.12188751f, -0.49704257f, 0.09789114f, -0.02476765f, 0.63972676f, 0.36195073f, 0.32343864f, 
    -0.51650095f, -0.63025838f, -0.00387764f, -0.07434739f, 0.07256518f, -0.26141834f, -0.61884630f, 0.24395581f, 
    -0.25947127f, 0.20747550f, 0.15451883f, -0.00247841f, -0.06476434f, -0.05492030f, 0.26632696f, -0.18184054f, 
    0.07489345f, 0.00221616f, 0.04387930f, 0.22396806f, 0.33071440f, -0.03360205f, -0.50914586f, -0.48485306f, 
    -0.25305790f, 0.00692267f, -0.41967416f, 0.04675979f, 0.13076513f, 0.32641727f, 0.18161328f, 0.23910406f, 
    0.34691542f, 0.34966105f, -0.07776635f, 0.04071043f, -0.04653799f, -0.27102047f, -0.23758653f, -0.16219436f, 
    0.13649382f, 0.04224622f, -0.05023588f, 0.14355774f, -0.09798638f, 0.11374854f, 0.15973459f, -0.00459670f, 
    0.13093291f, -0.00503415f, 0.12060650f, 0.28000692f, 0.10881510f, 0.07285160f, -0.18871440f, -0.24522865f, 
    -0.20286658f, -0.30317026f, 0.26816434f, 0.07133696f, -0.18507808f, -0.06038877f, -0.07832726f, 0.12759985f, 
    0.15252286f, 0.09299611f, -0.05601435f, 0.14129795f, 0.03296649f, -0.35005638f, 0.36497036f, 0.17474817f, 
    0.12583807f, -0.30439758f, 0.33671317f, 0.89464265f, -0.62806439f, -0.25348517f, -0.47547832f, -0.04915177f, 
    -0.07096697f, 0.04592001f, 0.52283198f, -0.53856683f, -0.25354245f, 0.15554233f, 0.41236380f, -0.07349859f, 
    0.39788401f, 0.04290600f, -0.14171861f, -0.12408663f, -0.21083105f, -0.01097373f, -0.08383604f, 0.17954609f, 
    -0.12212589f, 0.19193618f, -0.32097223f, -0.14586221f, 0.25330311f, -0.28843057f, 0.07289336f, -0.26331067f, 
    -0.43889338f, -0.37031209f, -0.36983386f, -0.17478020f, -0.09344656f, 0.34449232f, -0.26437768f, 0.35625324f, 
    -0.28514290f, -0.07952213f, 0.23542602f, -0.17224938f, 0.03006304f, 0.09516117f, -0.20019816f, 0.04554731f, 
    0.19353548f, 0.11481003f, 0.07524626f, 0.44642359f, 0.29726860f, -0.05548794f, 0.28502807f, -0.72474420f, 
    -0.66123044f, 0.06640269f, 0.37016124f, 0.12170971f, 0.10721645f, -0.01822651f, 0.23207632f, 0.06066823f, 
    -0.29986432f, 0.11373543f, 0.21344517f, 0.10969486f, -0.14297764f, -0.25865486f, -0.04648108f, -0.00900975f, 
    -0.06026069f, 0.10223008f, -0.08118211f, 0.58880448f, -0.28394747f, 0.11603695f, 0.20211799f, -0.09647033f, 
    -0.31198570f, 0.02625631f, 0.04377480f, 0.06393345f, 0.38028148f, -0.09136848f, 0.40598258f, -0.21942942f, 
    -0.08919615f, 0.35332939f, -0.15950164f, 0.07383369f, -0.02726869f, -0.05275156f, -0.24763627f, -0.24967141f, 
    0.10508779f, 0.09057770f, -0.09291062f, 0.14542395f, -0.58908302f, -0.53008038f, -0.16148905f, 0.32972744f, 
    0.53107381f, 0.20057060f, 0.62504458f, -0.14218366f, -0.84470659f, -0.57724696f, -0.31168202f, 0.18742490f, 
    -0.31850401f, -0.16899616f, -0.24575731f, -0.04890391f, -0.14195882f, 0.27246645f, 0.22777794f, -0.04290197f, 
    0.10496978f, 0.02986065f, -0.15324515f, -0.25249693f, -0.22221345f, 0.23890094f, -0.19849546f, 0.02333273f, 
    0.39462504f, 0.01275214f, 0.01771526f, -0.11218910f, -0.18710434f, 0.04314332f, 0.36239159f, -0.23930289f, 
    0.34105235f, -0.26007134f, -0.19925639f, -0.04461926f, 0.08250379f, -0.08187940f, -0.26697332f, 0.15818492f, 
    -0.04578188f, -0.38051745f, -0.06302860f, -0.09183570f, -0.16688220f, -0.45616543f, -0.70600468f, 0.47718909f, 
    0.26227736f, -0.54003668f, 0.09886586f, 0.22104143f, -0.11956128f, 0.36405993f, 0.11358218f, -0.25813359f, 
    -0.50759929f, -0.16747542f, 0.00376082f, -0.14548600f, 0.20479280f, -0.03058088f, -0.22219214f, -0.03342357f, 
    0.20280752f, 0.26491597f, -0.13049632f, 0.46644989f, -0.02595005f, -0.25252852f, -0.44966730f, -0.82078391f, 
    -0.44452235f, 0.34151074f, -0.36751255f, -0.06867646f, 0.66431576f, 0.03371905f, -0.33444902f, -0.13505311f, 
    0.54753548f, -0.19722994f, 0.21598478f, -0.03239618f, 0.40936673f, -0.16414289f, -0.07687486f, -0.26587090f, 
    -0.19084294f, 0.27993101f, -0.02030981f, 0.01667074f, 0.17383565f, 0.30697027f, -0.04060518f, -0.00984015f, 
    -0.50544429f, -0.20380883f, -0.33244374f, -0.29588482f, -0.23947337f, -0.18597113f, -0.06313539f, 0.22510415f, 
    -0.21557783f, 0.43370181f, -0.27855688f, -0.14464720f, -0.28732967f, -0.29953757f, -0.18163179f, 0.21584457f, 
    -0.00137182f, -0.21292998f, -0.00401110f, 0.10082219f, -0.07776019f, -0.11106881f, -0.14736679f, -0.18978314f, 
    0.02139339f, 0.29378933f, -0.24959262f, -0.29913762f, -0.38085049f, -0.37345973f, -0.01150613f, 0.17544185f, 
    -0.13726461f, -0.09013734f, -0.38531774f, 0.48389107f, 0.53864908f, 0.40012908f, 0.01218259f, -0.05950780f, 
    0.13054539f, 0.01621599f, -0.00889462f, -0.12873751f, -0.35723701f, 0.11495025f, -0.22451000f, -0.13751280f, 
    0.04267567f, 0.05562200f, -0.10463355f, -0.32827455f, -0.50021672f, -0.34694916f, -0.34013629f, 0.14528480f, 
    0.10942287f, -0.20854078f, -0.00123989f, 0.40795594f, -0.08102946f, -0.11064956f, -0.32112435f, -0.06563980f, 
    -0.31409386f, 0.17530240f, 0.07521255f, 0.00752125f, 0.05968885f, -0.38814870f, -0.21479939f, -0.32341266f, 
    -0.29587334f, -0.30111492f, -0.12014221f, 0.76126033f, -0.65003610f, -0.64467353f, -0.41782433f, -0.55003893f, 
    0.36587924f, 0.33793870f, 0.54702061f, -0.22646078f, -0.06213677f, -0.15606372f, 0.36497566f, 0.29192206f, 
    -0.12219890f, -0.24595743f, -0.00428760f, 0.19858974f, 0.02816737f, -0.30943456f, 0.29735807f, -0.04697433f, 
    0.09324905f, 0.04160871f, 0.05966183f, -0.09364395f, 0.30631894f, 0.42895383f, -0.11387898f, -0.19266832f, 
    -0.55253428f, -0.12200209f, 0.21087101f, -0.01214019f, -0.01120513f, 0.10005280f, 0.27623284f, -0.01052409f, 
    -0.21000992f, 0.07034078f, 0.03110325f, 0.02205103f, -0.19672073f, -0.09830131f, -0.23111284f, 0.19498552f, 
    -0.06869555f, -0.14231229f, 0.12301046f, -0.04898503f, 0.27102679f, -0.60147470f, -0.49791962f, -0.18256184f, 
    0.59370047f, -0.03598996f, 0.07427788f, 0.27251962f, -0.17897412f, -0.12924185f, -0.17932689f, 0.06450034f, 
    0.08464302f, 0.01068838f, 0.25767368f, -0.26397416f, -0.06403445f, -0.00210647f, -0.12685430f, -0.03128958f, 
    -0.01298038f, -0.27161348f, -0.18350160f, -0.17869155f, -0.23348701f, -0.30636293f, -0.74482977f, -0.41717800f, 
    -0.08685335f, -0.12405687f, -0.24309927f, 0.71833378f, -0.11755116f, -0.51870191f, -0.17466156f, 0.17667535f, 
    -0.18694966f, -0.20968027f, -0.22603594f, -0.42470077f, -0.26374319f, 0.13127519f, 0.12935075f, 0.15030330f, 
    0.16673148f, -0.13954788f, 0.05911310f, 0.06889546f, 0.12583168f, 0.08476364f, 0.07586124f, -0.25936815f, 
    0.28334814f, 0.38517001f, -0.22839805f, -0.23504327f, -0.00382896f, -0.14372998f, -0.00509415f, 0.12684114f, 
    -0.16016908f, -0.23483256f, -0.22421972f, 0.56645352f, -0.44978410f, -0.13541874f, -0.01562278f, 0.18619342f, 
    -0.05517675f, 0.17980699f, -0.14864999f, -0.13536127f, -0.20254986f, -0.17745864f, 0.18862599f, 0.27547058f, 
    -0.77544791f, -0.11671552f, 0.57705098f, -0.78404176f, -0.21300574f, 0.38881058f, 0.02204658f, -0.23423322f, 
    0.01493156f, 0.43660259f, 0.01530450f, -0.31763163f, -0.09381998f, -0.20625710f, -0.18605505f, 0.16932765f, 
    0.08420205f, 0.00376015f, 0.18180409f, 0.08286464f, 0.05119132f, 0.14672001f, 0.11784679f, -0.19045337f, 
    -0.35186952f, -0.20615709f, -0.52107501f, -0.47605017f, -0.22280635f, 0.32600358f, 0.15805413f, 0.33762664f, 
    0.24551766f, 0.23475873f, 0.26531720f, 0.13362801f, -0.04199753f, 0.27634239f, -0.03996228f, 0.08073143f, 
    -0.08881748f, 0.06767750f, -0.12386154f, -0.12132774f, -0.41162437f, 0.34834504f, 0.06995161f, -0.31126949f, 
    -0.01643401f, 0.50458145f, -0.28962186f, 0.09089718f, -0.37052470f, -0.65945023f, 0.08630019f, 0.07279515f, 
    -0.37498462f, -0.23752822f, -0.16833881f, -0.20402448f, -0.15257680f, 0.36743233f, 0.22213653f, 0.01371520f, 
    0.09324750f, 0.14359434f, 0.08811522f, -0.08095358f, -0.36558333f, -0.07247699f, 0.13260567f, -0.30606881f, 
    -0.13861330f, 0.17987710f, -0.22274470f, -0.61134750f, -0.49169996f, -0.26277527f, -0.15599903f, -0.14348063f, 
    0.05993749f, 0.15894239f, 0.40408278f, 0.38514137f, 0.50938946f, 0.07600002f, -0.04053039f, -0.19882134f, 
    -0.19072349f, -0.02408246f, 0.10177703f, 0.06338681f, -0.09759790f, -0.02142337f, 0.09520318f, 0.17816752f, 
    -0.27923363f, 0.09751511f, 0.17491125f, -0.03306483f, -0.34377339f, -0.56041902f, 0.15334097f, 0.38791260f, 
    0.27755672f, 0.10828584f, 0.10515137f, -0.02183926f, -0.05166432f, -0.02559389f, -0.28562865f, 0.12967375f, 
    0.04079498f, -0.23465614f, -0.22535789f, -0.06201367f, 0.19564994f, -0.10723431f, 0.19034061f, -0.39753255f, 
    0.22209530f, 0.12114211f, 0.04129134f, 0.03768872f, 0.09271589f, -0.23149590f, -0.07874079f, -0.20232934f, 
    -0.12935920f, -0.56221998f, -0.32077923f, -0.41561490f, -0.38252002f, -0.33584428f, -0.07072039f, -0.26987818f, 
    -0.20458038f, -0.05318031f, -0.62687951f, -0.23910962f, 0.07339042f, 0.15491062f, -0.00484511f, -0.01280617f, 
    -0.05743100f, -0.09737974f, 0.01831991f, -0.24885398f, -0.14783573f, 0.15212058f, 0.31993312f, 0.02884840f, 
    -0.27571434f, 0.30725119f, 0.06024233f, 0.00318825f, -0.26289824f, -0.29826644f, 0.36778253f, 0.26287681f, 
    0.44103736f, -0.13479258f, -0.12825556f, 0.05148807f, -0.38052282f, -0.07974814f, 0.27481574f, -0.12460208f, 
    0.10620703f, -0.14541909f, 0.06093969f, -0.00636081f, -0.39785954f, -0.07239363f, 0.28766745f, -0.16557899f, 
    -0.27414724f, -0.50837511f, -0.33221111f, -0.15085512f, 0.41267827f, -0.18976846f, -0.24109256f, -0.61568081f, 
    -0.44410795f, -0.20564753f, -0.08133854f, -0.16525118f, -0.13077815f, -0.30581596f, -0.31642663f, -0.37676683f, 
    -0.32724366f, -0.22595993f, -0.37190568f, -0.05901081f, 0.45441091f, -0.22828157f, 0.05469397f, -0.09036568f, 
    -0.18399964f, -0.12204159f, -0.21678840f, 0.08339666f, 0.39905083f, -0.26085833f, -0.45678052f, -0.64636642f, 
    -0.68510354f, -0.58888006f, 0.37214682f, 0.13115737f, 0.11613529f, -0.34073210f, 0.05503952f, 0.12961496f, 
    0.27717161f, -0.07578493f, 0.15257351f, 0.29212654f, -0.09383300f, 0.04416284f, -0.13564952f, -0.16277851f, 
    -0.19306448f, -0.82257324f, 0.23041445f, 0.30293036f, -0.65287727f, -0.76694220f, 0.46121535f, -0.08120475f, 
    0.14594211f, 0.32213074f, 0.18350245f, 0.08971529f, -0.34210765f, 0.20262818f, -0.39456889f, -0.09495880f, 
    -0.05734758f, -0.06083648f, -0.28550372f, 0.15617071f, 0.18297032f, -0.15356046f, 0.05844886f, 0.12930851f, 
    -0.20172188f, 0.02219497f, -0.34096685f, 0.20825483f, -0.61030054f, -0.08840661f, 0.23280910f, -0.28729877f, 
    0.01680350f, 0.12222373f, -0.37290904f, -0.34672701f, 0.43079948f, -0.29382765f, -0.01264370f, -0.13273893f, 
    -0.15043871f, -0.10365811f, -0.06852015f, 0.01821999f, -0.05217785f, -0.07898314f, -0.04395986f, -0.00375716f, 
    0.27851805f, 0.25026658f, 0.53690749f, -0.51627940f, -0.48542994f, -0.52933472f, 0.10541488f, 0.39824006f, 
    0.09716424f, -0.05181673f, 0.52377033f, -0.44083887f, -0.12305523f, -0.32332957f, -0.31705180f, -0.23319545f, 
    0.46324611f, -0.10988568f, -0.02348302f, -0.20326275f, -0.12553222f, -0.33343044f, -0.47066143f, 0.11335418f, 
    -0.15459496f, 0.09506545f, 0.24932171f, -0.11756875f, -0.36630848f, -0.07891983f, 0.26832584f, -0.04085595f, 
    0.32206437f, 0.19030704f, 0.23046012f, 0.11434923f, 0.16398489f, 0.18121007f, 0.00469115f, -0.02939735f, 
    0.11680487f, 0.16697548f, -0.28940904f, 0.00791952f, -0.11517565f, 0.01331211f, -0.33707827f, -0.08674403f, 
    0.24914278f, -0.03878549f, -0.08281784f, -0.14138205f, -0.30259535f, -0.35363474f, -0.03564636f, 0.61650223f, 
    -0.03873108f, -0.14095694f, -0.64235628f, 0.09038284f, 0.18349637f, 0.27423415f, -0.28335688f, 0.12303154f, 
    0.11358564f, 0.03954430f, 0.43758401f, -0.49822754f, 0.40519458f, -0.35869560f, 0.32924601f, -0.45115131f, 
    -0.15346292f, 0.03107291f, -0.15232629f, -0.04489202f, -0.02274463f, 0.11279200f, -0.05057525f, 0.04534822f, 
    -0.12556742f, -0.33272138f, -0.07857562f, -0.14295618f, -0.11018991f, -0.39809126f, -0.23871876f, -0.24080211f, 
    0.08037983f, 0.22565737f, 0.21504694f, 0.35395339f, 0.36464027f, 0.30758864f, 0.05550266f, -0.19733126f, 
    -0.25206167f, -0.16315557f, -0.15057005f, 0.12666029f, 0.26441452f, 0.13453116f, 0.11909869f, -0.10811465f, 
    -0.60855305f, 0.48820880f, 0.20371605f, 0.47448519f, 0.13492748f, -0.49436089f, -0.20825616f, -0.17239302f, 
    0.22689947f, -0.13734369f, -0.11582081f, -0.14161053f, -0.00714891f, 0.30296066f, -0.31112161f, 0.10770050f, 
    0.13839477f, 0.03600258f, 0.15860267f, -0.14627028f, 0.22448997f, -0.14748792f, -0.01287138f, -0.01146978f, 
    0.28463775f, 0.97443527f, 0.19997132f, -0.60640073f, -0.30402792f, -0.35115317f, 0.03544166f, 0.02190164f, 
    -0.00837994f, -0.03512547f, -0.36011454f, -0.21198657f, 0.08729802f, -0.18371768f, 0.11201170f, 0.21925949f, 
    -0.21451521f, 0.19550817f, 0.01214326f, -0.20327824f, -0.11785331f, -0.09131784f, -0.23797770f, -0.38940486f, 
    -0.38358375f, -0.05281190f, 0.33910006f, 0.35588098f, 0.36504570f, 0.21959049f, 0.01164530f, 0.06130037f, 
    0.23036437f, 0.03692088f, 0.03345771f, -0.04166735f, -0.09372748f, -0.09729520f, 0.08403102f, -0.08955231f, 
    0.03245996f, 0.26030925f, 0.00704318f, -0.17844880f, -0.29267472f, -0.15789734f, -0.17816025f, -0.28720269f, 
    -0.14862783f, -0.13174194f, 0.55264491f, 0.05048005f, 0.25984836f, -0.32202077f, -0.53198099f, -0.30836627f, 
    -0.12475173f, 0.15631169f, 0.29819179f, 0.31314918f, 0.26838851f, 0.03570154f, -0.14373408f, -0.18883407f, 
    0.03282757f, 0.39827800f, -0.14353287f, -0.48719868f, 0.09378459f, 0.00059892f, -0.22208850f, -0.10849281f, 
    0.12337526f, 0.21681841f, 0.27452716f, 0.56273651f, 0.03145006f, -0.44836167f, -0.52365881f, 0.11571325f, 
    0.50497270f, -0.30681530f, 0.32960084f, -0.31859663f, -0.11021885f, 0.24608164f, -0.27844217f, 0.12438614f, 
    -0.44592744f, 0.42172167f, -0.23811556f, -0.00180830f, -0.05714233f, -0.08949925f, 0.15589707f, -0.04771403f, 
    -0.25573868f, 0.31642672f, 0.06231333f, 0.09232000f, -0.21536276f, -0.23471895f, 0.14522952f, 0.12054622f, 
    -0.01625519f, 0.11000656f, 0.15966821f, 0.18316108f, -0.01821543f, -0.07014991f, 0.03019870f, 0.17596537f, 
    0.09679000f, -0.00650771f, 0.03774508f, 0.22772963f, 0.06423265f, 0.28884345f, 0.07087533f, 0.27926478f, 
    -0.09507940f, 0.28517592f, -0.08284302f, -0.19006851f, -0.18423414f, -0.39157417f, -0.48081204f, -0.30940065f, 
    -0.32984951f, -0.32365766f, 0.39959764f, -0.30855542f, 0.05116777f, 0.50812668f, 0.19155404f, 0.17208342f, 
    -0.29997733f, -0.08721968f, 0.44675213f, 0.19342859f, -0.18688144f, 0.29192039f, 0.19166242f, 0.11127703f, 
    -0.31813949f, -0.27709413f, 0.29192308f, 0.08330218f, 0.10394480f, -0.35264421f, -0.67699987f, -0.69221568f, 
    -0.40276045f, 0.05369218f, -0.43067741f, 0.62271523f, 0.40687859f, 0.02814879f, -0.10998911f, 0.34487012f, 
    0.17502552f, -0.10702230f, 0.10307218f, 0.05159050f, 0.02509778f, -0.16891018f, 0.04230653f, 0.02813976f, 
    -0.27314943f, 0.13432567f, 0.00896501f, -0.09037486f, 0.13568060f, 0.13640235f, -0.14085071f, -0.05550272f, 
    0.43076593f, 0.41970754f, -0.60174447f, -0.45764488f, -0.33699515f, -0.06685594f, 0.21241051f, 0.08236485f, 
    0.32987133f, 0.18715246f, 0.04629003f, 0.05421221f, -0.36122498f, -0.16386063f, -0.12221188f, 0.17431536f, 
    0.21999918f, 0.08679302f, 0.24701977f, -0.03042405f, -0.10289604f, -0.36355075f, -0.24701038f, -0.11853910f, 
    -0.20715117f, -0.15042883f, -0.52694672f, 0.28318086f, 0.49726188f, 0.26169485f, -0.30786282f, -0.10010743f, 
    0.13430291f, -0.13707209f, 0.73303324f, -0.46637347f, 0.08386520f, 0.14392059f, -0.18043973f, -0.04786971f, 
    0.03725892f, 0.07898410f, -0.04806114f, -0.26339880f, -0.21449663f, -0.11822943f, 0.46969917f, -0.08958984f, 
    0.03838145f, -0.00275933f, 0.13864736f, -0.10645539f, 0.10042683f, 0.31659254f, -0.10076869f, 0.17931978f, 
    0.12166110f, 0.05188056f, 0.34676987f, 0.00825510f, 0.51632458f, -0.27484363f, -0.41487816f, 0.08479743f, 
    -0.12978171f, 0.23644450f, -0.30049399f, -0.12327079f, -0.10917656f, 0.08324321f, 0.11118223f, 0.08754093f, 
    -0.22940598f, -0.03996169f, -0.69805872f, 0.41270089f, 0.06795603f, 0.32369697f, 0.14940222f, -0.32816270f, 
    -0.53527623f, 0.02810783f, 0.42694589f, 0.34123129f, 0.29553884f, -0.42806634f, -0.28409049f, -0.28079024f, 
    0.46893454f, 0.01794006f, 0.26869205f, -0.11036219f, -0.05990278f, 0.19910617f, 0.17534895f, -0.16575249f, 
    -0.01069379f, -0.15387930f, -0.28580281f, 0.45329747f, -0.24774159f, 0.06139928f, 0.26631069f, -0.06856427f, 
    -0.16918276f, -0.01081528f, -0.19404216f, -0.02678945f, 0.13459630f, 0.11943046f, -0.00062819f, 0.11140422f, 
    -0.10524140f, 0.07589915f, -0.38061714f, 0.08881612f, -0.20278960f, 0.05546308f, -0.05828374f, 0.26666364f, 
    -0.05119963f, 0.16593301f, 0.21229863f, -0.00592899f, 0.15616357f, 0.38596588f, 0.22078054f, -0.56865323f, 
    -0.50921768f, 0.27941838f, 0.20524342f, -0.25247622f, -0.00924053f, 0.11682600f, 0.10242311f, 0.06186905f, 
    -0.40676516f, 0.23488733f, -0.05973858f, -0.32248023f, 0.14410290f, -0.21840723f, -0.06724894f, -0.33642346f, 
    0.29405630f, 0.09239861f, -0.02209626f, 0.36772448f, 0.33549097f, -0.55198628f, -0.16971204f, -0.35248405f, 
    0.30521536f, 0.24516408f, -0.23878491f, -0.31664535f, 0.32180905f, 0.63461077f, 0.36530182f, -0.37494278f, 
    -0.05238393f, -0.25103721f, 0.48987055f, -0.20312054f, -0.16788505f, -0.21326841f, 0.09096131f, 0.09046446f, 
    -0.00430240f, 0.12107940f, 0.31472495f, -0.21806292f, -0.23309596f, 0.09665900f, 0.41978011f, 0.39034471f, 
    -0.13874187f, 0.22159889f, -0.08635734f, -0.45217535f, -0.57311326f, 0.24882835f, 0.06378061f, -0.37071624f, 
    -0.09021240f, 0.16471219f, 0.14517330f, 0.21975842f, 0.21367815f, -0.23047139f, 0.30339631f, 0.00597236f, 
    -0.63857603f, 0.11922918f, 0.08715516f, 0.09399434f, 0.11466085f, -0.19124773f, 0.10651980f, 0.09896094f, 
    -0.31116125f, 0.46433005f, -0.16846550f, 0.13581982f, 0.14374731f, 0.49400979f, -0.26291192f, 0.26224479f, 
    0.25267991f, 0.29191235f, -0.25701880f, 0.16147779f, 0.04135644f, -0.07526588f, 0.19768159f, 0.06204199f, 
    -0.04307408f, -0.33161566f, 0.05761500f, -0.23680706f, 0.30121797f, 0.19151793f, -0.08549108f, -0.20696588f, 
    -0.35863358f, -0.70096910f, -0.53882062f, 0.14480191f, 0.69831896f, 0.15862155f, -0.17908977f, -0.28753075f, 
    0.26053679f, -0.07002188f, -0.29033619f, -0.09084003f, -0.07827327f, -0.09743420f, -0.10228866f, -0.06532095f, 
    0.05724066f, -0.07362661f, 0.53814322f, 0.30277830f, -0.13233286f, -0.43996355f, -0.20930842f, -0.07175748f, 
    -0.28292173f, 0.03352467f, 0.30372867f, 0.38509357f, 0.30326819f, 0.37273160f, -0.14748918f, -0.21462633f, 
    0.25472242f, 0.28588653f, -0.00036257f, -0.07720168f, -0.08972032f, -0.05297314f, 0.02513179f, -0.02723907f, 
    0.22653849f, 0.05351267f, 0.02650994f, -0.16032687f, 0.00191633f, -0.10484711f, -0.26157025f, 0.05095504f, 
    0.18942831f, -0.01580769f, 0.58684039f, -0.16845511f, 0.40742427f, 0.58457482f, -0.60551214f, 0.20042863f, 
    -0.27097371f, -0.29255256f, -0.17237443f, -0.19038950f, 0.62262535f, -0.62185878f, -0.22128144f, 0.15692702f, 
    -0.10728692f, -0.00148450f, 0.25854757f, 0.10052740f, -0.15014410f, -0.06307131f, 0.04084236f, -0.18590233f, 
    0.23742577f, 0.10314989f, -0.04644984f, 0.70335376f, 0.15232803f, -0.17611499f, -0.44950482f, 0.16508606f, 
    0.28809294f, 0.01609758f, -0.63409352f, -0.49383208f, -0.51316434f, -0.01032625f, 0.15971880f, 0.15022014f, 
    -0.04865361f, -0.20003414f, -0.06278469f, 0.29855132f, -0.06050455f, -0.34457412f, -0.12492853f, -0.48251086f, 
    -0.31979382f, -0.27535433f, 0.25825107f, -0.30902538f, 0.06500085f, 0.17197210f, 0.09979849f, 0.09308165f, 
    0.15784605f, -0.16043872f, 0.25564787f, 0.26332635f, 0.16800159f, -0.22766227f, 0.06795746f, 0.27759179f, 
    -0.00008068f, 0.19633256f, -0.31560707f, -0.16543239f, 0.09117053f, -0.01982247f, -0.09657577f, -0.15290779f, 
    -0.10605785f, 0.20718820f, 0.14273623f, 0.01027804f, -0.05620857f, -1.30919051f, -0.11595523f, 0.17202823f, 
    0.69391572f, 0.41270939f, 0.36228853f, 0.03243432f, -0.29225302f, -0.21114133f, 0.02794910f, 0.15183762f, 
    -0.15847215f, -0.28911996f, 0.70792198f, -0.33009693f, -0.48684901f, 0.08552150f, 0.14028063f, 0.01696642f, 
    0.23981304f, 0.09985797f, -0.23441491f, -0.17708595f, 0.22022085f, 0.01077640f, 0.53994131f, 0.78308725f, 
    -0.03632712f, -0.65656400f, -0.21713564f, -0.20488012f, 0.17039542f, 0.29726475f, -0.38686636f, -0.05537490f, 
    0.04662598f, -0.10319083f, 0.43974814f, 0.13606122f, -0.21320648f, -0.09209186f, -0.01541974f, -0.43106520f, 
    0.37571451f, 0.00399249f, 0.08166379f, 0.35871458f, -0.18346106f, 0.25620845f, -0.16957170f, 0.39539424f, 
    0.07344262f, 0.02287541f, 0.26577419f, 0.33941117f, 0.16232124f, 0.33529496f, 0.13928856f, -0.29398790f, 
    -0.40532497f, -0.13911390f, 0.07244842f, -0.02709500f, -0.39737365f, -0.04624601f, 0.10668984f, 0.10918956f, 
    -0.04667656f, -0.05812328f, 0.26671934f, 0.31973141f, -0.02635367f, -0.05415919f, -0.41492587f, -0.45766410f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17804852f, -0.01445297f, -0.35845554f, -0.53913862f, 0.38188913f, -0.02323563f, 0.00319285f, 0.05915648f, 
    -0.02242063f, -0.05101613f, 0.17403150f, 0.19170724f, -0.29198134f, -0.05859290f, 0.09103087f, 0.05901414f, 
    -0.18020098f, 0.10956824f, -0.03346248f, 0.21250677f, 0.19004938f, -0.02996993f, -0.05073298f, -0.04169093f, 
    0.04043510f, -0.12778348f, -0.28510678f, -0.16516607f, 0.03353265f, -0.31935227f, 0.03887399f, -0.23163120f, 
    -0.12619716f, -0.03216621f, 0.11370033f, -0.11880866f, 0.10332948f, 0.03177772f, -0.06555024f, 0.23604107f, 
    0.02740814f, -0.16581899f, 0.07971288f, 0.26094890f, -0.41775125f, 0.04590006f, 0.21574150f, 0.11054584f, 
    -0.04198290f, 0.08078773f, 0.04028407f, -0.04711968f, -0.17300846f, 0.20445369f, -0.06851318f, -0.28086638f, 
    -0.24297264f, -0.27826968f, 0.03294300f, -0.06989032f, 0.02578968f, -0.06390993f, -0.01662181f, 0.13030526f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04009241f, 0.02294336f, -0.03926601f, -0.04087730f, -0.01887069f, -0.02895359f, -0.02852206f, 0.01599665f, 
    -0.01551185f, 0.03909004f, -0.02806280f, -0.03695251f, 0.00233941f, -0.02044125f, -0.02284483f, -0.01295961f, 
    -0.03656357f, 0.02948968f, -0.01496976f, -0.00123470f, -0.03020663f, 0.00906462f, 0.00851263f, -0.00700590f, 
    -0.01970934f, -0.01957348f, 0.03300197f, -0.02805765f, 0.02794586f, 0.02794597f, -0.03291697f, -0.03199952f, 
    -0.02916519f, -0.00962537f, -0.03231341f, -0.00992507f, 0.03852318f, -0.00981109f, -0.02774467f, 0.02665550f, 
    0.01166198f, -0.02069819f, -0.00472500f, -0.03001107f, -0.02083371f, -0.01899611f, 0.00996674f, -0.03182936f, 
    -0.01915752f, 0.02994300f, 0.00500070f, -0.01947163f, 0.02432570f, 0.00552940f, -0.01990720f, -0.03000954f, 
    -0.02025108f, -0.00204108f, -0.01078635f, 0.02386615f, -0.00100407f, -0.00083445f, 0.00687040f, -0.03767362f, 
    -0.00830168f, -0.03525520f, 0.00293319f, -0.03080707f, -0.02626075f, -0.03817993f, -0.03430970f, 0.01751096f, 
    -0.03747365f, 0.01530357f, -0.01448839f, -0.00934372f, 0.01260032f, -0.03193739f, 0.02878219f, -0.00749038f, 
    0.00061079f, -0.01156624f, 0.00642968f, -0.00069750f, 0.00720314f, -0.02267195f, -0.01196709f, -0.02723224f, 
    -0.03267018f, 0.01303026f, -0.00497706f, -0.02854531f, -0.00774695f, -0.00828188f, -0.00683763f, -0.04189358f, 
    -0.02678417f, 0.00423306f, -0.01846309f, -0.00518438f, -0.00405820f, -0.01979421f, 0.02882886f, 0.02847258f, 
    0.01626690f, 0.02257714f, 0.01570902f, -0.03714283f, -0.03370874f, 0.02128862f, 0.02585743f, -0.01317293f, 
    -0.01953479f, 0.00215641f, 0.00771515f, 0.00170723f, 0.01929352f, -0.01146656f, 0.04110347f, -0.03771514f, 
    0.02126313f, -0.00985011f, -0.01094930f, -0.01346284f, 0.03175454f, -0.04191627f, 0.00443975f, 0.02050152f, 
    0.02748815f, -0.03804604f, 0.02967837f, -0.01662137f, -0.02391806f, 0.01608250f, 0.03138353f, -0.02607822f, 
    0.01449548f, -0.03935422f, -0.03103860f, -0.00546239f, 0.00184260f, 0.00646715f, -0.01936735f, -0.04193461f, 
    -0.02537660f, 0.00873653f, -0.02677882f, 0.02634476f, -0.01751365f, -0.00113976f, -0.00948861f, -0.00589991f, 
    -0.00647305f, 0.01339437f, -0.00040325f, -0.02885628f, 0.02567116f, -0.01065936f, -0.02055532f, -0.02769818f, 
    0.00047275f, 0.01784735f, 0.02992097f, -0.00225172f, -0.02683417f, -0.00373655f, 0.02020116f, 0.02193907f, 
    0.00450868f, -0.03220157f, 0.00865636f, -0.04131381f, -0.00785547f, -0.02708026f, 0.00844549f, -0.02344339f, 
    -0.00641205f, -0.02912229f, -0.02751489f, -0.01610291f, 0.01450592f, -0.03611459f, -0.01736691f, -0.02934298f, 
    -0.02443067f, 0.00368831f, -0.00142849f, -0.03528966f, -0.03551386f, -0.00484644f, -0.00734056f, -0.02044611f, 
    0.01472548f, -0.00930217f, -0.00975856f, 0.02025303f, -0.02155828f, 0.02553191f, -0.02833701f, 0.02262229f, 
    -0.01061689f, 0.02565325f, -0.01867967f, 0.00500852f, 0.02074723f, -0.01041719f, -0.00495337f, 0.01547634f, 
    -0.00766280f, -0.00550108f, -0.01730527f, -0.03882972f, -0.00167914f, 0.01584162f, -0.02927796f, -0.02710103f, 
    0.02518922f, 0.02167901f, -0.04203874f, -0.03364849f, 0.00403910f, -0.03185763f, 0.01805222f, 0.00134983f, 
    -0.01154124f, -0.03168862f, 0.02921557f, 0.01300451f, -0.03838248f, -0.00959732f, -0.01340544f, 0.02225146f, 
    -0.03706947f, -0.00969329f, -0.02215110f, 0.01906450f, 0.01498549f, -0.03437611f, -0.00604432f, 0.02224680f, 
    0.01557985f, 0.00704909f, -0.01793957f, 0.02771374f, 0.01548291f, 0.02917529f, -0.02524237f, -0.01738139f, 
    -0.00610700f, -0.03836732f, 0.01726534f, -0.00355569f, -0.02199742f, -0.03038054f, -0.00206512f, 0.00316090f, 
    -0.02713919f, -0.03465875f, 0.01592146f, -0.01218284f, -0.04137792f, -0.04033578f, 0.03002194f, 0.02115950f, 
    -0.00418197f, 0.02510775f, -0.03067163f, 0.01761674f, 0.01051141f, 0.02849014f, -0.03787239f, -0.00722472f, 
    0.00863685f, -0.03375545f, 0.00946879f, -0.03919613f, -0.00618320f, -0.03109270f, -0.03701265f, -0.02618019f, 
    0.00979447f, -0.00642361f, -0.01935119f, -0.02952152f, 0.02986410f, -0.02261121f, -0.03892431f, 0.00313306f, 
    -0.01088153f, -0.01713921f, -0.00131191f, -0.00549868f, -0.03688274f, 0.02881919f, -0.02874786f, -0.02173093f, 
    -0.00814722f, -0.01736863f, -0.01393145f, -0.01542061f, 0.02990416f, -0.02184989f, 0.03218437f, -0.00874339f, 
    -0.00002946f, -0.02135269f, 0.02005006f, -0.03525846f, -0.02860060f, -0.03657069f, -0.03244090f, 0.01927151f, 
    0.00321352f, -0.01791072f, 0.02235875f, 0.01242253f, -0.01658937f, -0.02436065f, -0.02143544f, -0.01099990f, 
    0.02709322f, 0.02304013f, -0.03456746f, -0.00924308f, -0.01534109f, 0.01338604f, -0.00641009f, 0.02387675f, 
    0.01238951f, -0.03523529f, -0.02097386f, 0.01561313f, -0.00776128f, -0.00335515f, 0.01415338f, -0.03597252f, 
    0.02137991f, 0.01659708f, -0.01489967f, -0.02454494f, 0.01017476f, 0.01040531f, -0.03722499f, 0.01136887f, 
    -0.00445493f, 0.00666488f, -0.03011663f, -0.03009519f, -0.00540374f, -0.00434486f, -0.02674034f, 0.00043676f, 
    -0.01592106f, -0.04162188f, 0.02531439f, 0.02549948f, -0.01691239f, 0.02703241f, -0.02086863f, 0.02072074f, 
    -0.00092106f, 0.01012279f, 0.02512924f, -0.02061160f, 0.03626798f, -0.02813517f, 0.00690200f, -0.02443689f, 
    -0.00956742f, -0.00918309f, -0.04072658f, 0.02271309f, 0.02139225f, 0.00489589f, -0.02973095f, 0.00476411f, 
    -0.03965462f, -0.02020958f, -0.02683302f, 0.00821994f, -0.03565736f, -0.01997802f, 0.01079714f, -0.03738594f, 
    -0.02357550f, -0.03809632f, -0.02782586f, -0.02946792f, -0.01474975f, -0.04150349f, -0.00732301f, -0.00080647f, 
    -0.02893070f, -0.01274587f, 0.01393194f, -0.01768586f, -0.03761516f, 0.00410314f, -0.01447878f, 0.02729541f, 
    0.00664620f, -0.03346206f, -0.01320934f, -0.02431371f, 0.02828605f, -0.03598840f, 0.02230418f, -0.02813303f, 
    -0.00652721f, 0.01549280f, -0.03651721f, -0.02333531f, 0.01540160f, 0.02164875f, -0.01938735f, -0.03200378f, 
    -0.02584629f, -0.02744116f, -0.01462917f, -0.03910486f, -0.03023519f, 0.02608251f, -0.03485776f, 0.02733132f, 
    -0.00873743f, -0.01699995f, -0.03944270f, 0.01619804f, 0.02171283f, 0.01768048f, -0.01260997f, 0.00361107f, 
    0.02953401f, -0.00796627f, -0.00115311f, 0.02976255f, 0.00588239f, 0.01158987f, 0.02193917f, -0.01218187f, 
    -0.00035428f, -0.00324093f, -0.02158505f, -0.01536399f, -0.00613489f, 0.00072459f, -0.02126878f, 0.02627365f, 
    0.00733345f, 0.00465241f, -0.04157819f, 0.01064218f, 0.02346191f, -0.00356104f, 0.00768170f, -0.03829940f, 
    0.02103579f, 0.02317984f, -0.00658742f, -0.02436844f, 0.02502954f, 0.01818685f, 0.01277502f, 0.02980453f, 
    -0.02575409f, 0.02479511f, -0.03307467f, -0.01955640f, -0.01666564f, -0.00071413f, 0.00455510f, -0.03298578f, 
    0.02524822f, -0.00859171f, 0.01674441f, 0.01132429f, -0.03910439f, -0.03432640f, -0.01835936f, -0.01692501f, 
    0.02624305f, -0.00140254f, -0.00149800f, -0.03976803f, 0.00261854f, 0.00999073f, -0.02264749f, -0.02705160f, 
    -0.00280596f, -0.01662576f, -0.04036235f, 0.02271165f, -0.01955500f, 0.03082447f, 0.03466839f, 0.03169704f, 
    0.00006084f, -0.02970882f, 0.00505288f, 0.01992990f, -0.03534725f, 0.00689006f, 0.02571933f, 0.02278992f, 
    0.00875249f, 0.02680989f, 0.02809189f, -0.03649718f, -0.02952878f, -0.02323239f, -0.01871905f, 0.00816291f, 
    -0.03204713f, -0.00154342f, 0.02550843f, -0.03365291f, -0.00522311f, -0.02641088f, 0.00678984f, 0.02651442f, 
    -0.03264180f, -0.00481355f, 0.00974257f, 0.01449822f, -0.01709211f, 0.02878367f, -0.01909763f, 0.01750805f, 
    0.01808313f, -0.04154409f, -0.00830597f, 0.02625634f, -0.00073547f, -0.04071509f, -0.00614637f, 0.00654790f, 
    -0.02489448f, -0.02108956f, 0.01064681f, 0.01956452f, -0.01884094f, 0.02045520f, 0.02312491f, -0.01659616f, 
    -0.00079158f, -0.01814851f, 0.00221632f, 0.00742819f, -0.03186473f, 0.01953849f, 0.02133656f, -0.03051569f, 
    0.01306030f, -0.01525107f, 0.01117844f, -0.00964639f, 0.01668780f, -0.00132485f, 0.02623322f, 0.02701243f, 
    -0.02705473f, -0.00667984f, -0.03260347f, -0.04084244f, -0.01061689f, -0.00190777f, -0.01984086f, -0.04198122f, 
    -0.00857524f, -0.00143790f, -0.01639089f, -0.02341970f, -0.01139136f, -0.01062009f, -0.01264425f, -0.00587296f, 
    0.00730803f, 0.03693369f, 0.00091112f, -0.00367802f, 0.02869314f, -0.02166103f, -0.03158906f, 0.02198421f, 
    0.01839986f, -0.03547475f, 0.02414848f, -0.02074205f, 0.01418195f, 0.01903284f, 0.00190050f, -0.00182783f, 
    -0.01913725f, -0.02151186f, -0.03080348f, 0.00431440f, -0.00712377f, -0.03486676f, 0.00453992f, 0.00871539f, 
    -0.01256473f, -0.01803351f, 0.00768167f, -0.02693234f, -0.02969762f, 0.01013226f, -0.00555520f, 0.02818921f, 
    -0.00457130f, 0.00254644f, -0.01937317f, -0.03521439f, -0.02303780f, -0.00920905f, 0.00378463f, 0.02358170f, 
    0.02476864f, 0.01285291f, -0.03596250f, -0.00112650f, 0.01065856f, 0.01300908f, 0.00930326f, 0.02475324f, 
    0.02166805f, 0.01965845f, 0.00564800f, -0.01584454f, 0.00114363f, -0.02579877f, -0.03005920f, -0.00583010f, 
    0.02629198f, -0.03027944f, -0.01263710f, 0.01006274f, 0.01611057f, -0.00955448f, -0.03063297f, -0.01714315f, 
    -0.00495823f, 0.01064304f, 0.01247712f, 0.00323675f, -0.02737161f, 0.00011345f, 0.00626601f, -0.00222142f, 
    0.02258605f, -0.02321096f, 0.00799870f, 0.03007830f, 0.00084890f, -0.03568182f, 0.01776193f, -0.04051230f, 
    -0.02421163f, 0.02571304f, -0.01040018f, -0.02954805f, 0.01713079f, -0.00605580f, 0.02415892f, -0.03388070f, 
    0.01197048f, -0.01430752f, 0.01758547f, -0.01898292f, 0.00951044f, 0.01151458f, 0.01833394f, 0.02106549f, 
    -0.00554930f, 0.02474771f, -0.00746769f, -0.00521892f, -0.01758325f, 0.00986108f, -0.04102511f, 0.02746871f, 
    0.01570522f, 0.02945377f, 0.02762954f, -0.02964227f, 0.00728967f, 0.02293183f, -0.02296725f, -0.01091488f, 
    -0.01988290f, -0.03437518f, 0.01410405f, 0.00987371f, -0.01140234f, 0.00916198f, 0.01585134f, -0.02044688f, 
    -0.01874899f, -0.04093236f, 0.00378434f, -0.00531796f, 0.00824727f, -0.01129791f, 0.02856926f, -0.02919820f, 
    -0.01250084f, 0.00069178f, -0.04096335f, -0.03385564f, -0.02460056f, -0.00215997f, 0.00214319f, -0.02600029f, 
    0.00697584f, 0.02686716f, -0.00726300f, 0.01229855f, 0.02241225f, 0.00794857f, -0.01104634f, 0.01959200f, 
    0.00350338f, -0.02509416f, 0.03689430f, -0.01611924f, -0.01872855f, 0.00211692f, 0.02725416f, 0.01537537f, 
    0.02625334f, -0.00440879f, 0.01713268f, 0.00387832f, -0.01708336f, 0.00894403f, 0.01831863f, -0.02426488f, 
    0.01152254f, 0.02570765f, -0.02449732f, -0.02582003f, 0.00688150f, 0.00259439f, -0.00088560f, 0.01678098f, 
    0.01545583f, 0.03845504f, -0.01340586f, 0.00634274f, 0.02206031f, 0.04123048f, -0.03606692f, 0.02571677f, 
    0.00848873f, -0.01916599f, 0.01622484f, 0.01380416f, 0.00382189f, -0.02497367f, 0.03514859f, -0.00686977f, 
    0.01154192f, -0.02259494f, 0.01383140f, 0.01410397f, -0.01344575f, -0.01586879f, -0.02199209f, -0.01759486f, 
    -0.06661946f, 0.03787758f, -0.16976985f, 0.06736180f, -0.18999690f, -0.07597514f, -0.00894940f, 0.06426481f, 
    -0.00587037f, 0.01965676f, -0.16819760f, 0.00324173f, -0.11361711f, 0.11475160f, 0.06503468f, 0.35999945f, 
    -0.07950622f, 0.10536997f, -0.00910613f, -0.10662874f, 0.09880182f, 0.06428628f, -0.09309904f, 0.23173343f, 
    -0.16693310f, -0.14382236f, -0.05565902f, -0.09028255f, 0.10862539f, 0.05034073f, 0.00268558f, -0.08074749f, 
    -0.01501596f, 0.09409364f, 0.10568822f, -0.06308942f, -0.17653941f, -0.17745042f, 0.00109972f, -0.01506214f, 
    -0.02615055f, 0.11608106f, 0.02656677f, -0.04316297f, 0.18501805f, 0.05275940f, -0.08883975f, 0.04862834f, 
    -0.26501116f, -0.00289978f, 0.10163527f, 0.00207400f, -0.04531500f, 0.08177844f, -0.16101976f, -0.02142773f, 
    0.04055509f, -0.05960140f, 0.05395942f, 0.00668190f, 0.06763253f, -0.05878813f, 0.23204385f, -0.07945280f, 
    -0.12706943f, 0.15624227f, 0.06495110f, -0.02292008f, 0.08785819f, 0.04365246f, 0.05162208f, 0.05493848f, 
    0.05501778f, 0.20011021f, -0.21081223f, -0.16269657f, 0.04294181f, 0.06525771f, 0.01317589f, 0.01734840f, 
    -0.15425825f, 0.04829892f, 0.05168640f, 0.01771448f, -0.03237469f, 0.02541507f, -0.04887519f, -0.01435984f, 
    0.11706673f, -0.11759032f, -0.08435016f, 0.10088784f, 0.08552771f, -0.00900533f, 0.10538430f, 0.01739830f, 
    -0.58932191f, 0.20936742f, 0.13538860f, -0.46242049f, -0.07371883f, 0.07706590f, 0.09272213f, 0.02663185f, 
    0.01976139f, 0.01722378f, -0.13340674f, 0.10051820f, 0.00537597f, 0.11100309f, 0.06628915f, 0.02161483f, 
    -0.08183178f, 0.06927648f, 0.05363423f, -0.07654550f, 0.08550151f, -0.05109004f, 0.03088092f, -0.04333024f, 
    -0.49351108f, -0.04173101f, 0.29437312f, 0.01262912f, 0.07097017f, 0.00447864f, -0.04934664f, -0.16581504f, 
    0.07646256f, -0.02600718f, 0.09611317f, 0.08014461f, -0.37403855f, -0.15963113f, 0.00384738f, -0.14778729f, 
    -0.05867409f, 0.10162778f, -0.06922119f, -0.06997532f, -0.15352271f, 0.18767564f, -0.06670444f, -0.02872839f, 
    0.20257162f, -0.10336037f, 0.10405716f, -0.00415174f, 0.02175266f, -0.03698005f, 0.00895504f, 0.14785498f, 
    0.13606617f, -0.02277930f, -0.06867001f, 0.07424515f, -0.22479844f, 0.15392295f, -0.03879852f, -0.08412547f, 
    -0.09002426f, -0.04455578f, -0.01781349f, -0.08617306f, -0.15926287f, -0.09503345f, 0.09496602f, -0.10554695f, 
    0.13036871f, 0.09818478f, -0.03424767f, 0.16018645f, -0.06671131f, -0.10512324f, -0.07103450f, 0.11952637f, 
    -0.21218766f, -0.00599579f, -0.00549668f, -0.04020404f, 0.47829205f, 0.28359154f, 0.17497073f, 0.13843568f, 
    -0.00129236f, 0.10175276f, 0.10511238f, 0.22033523f, -0.08812930f, -0.15382554f, 0.05298362f, 0.14515930f, 
    0.16163763f, 0.18642917f, 0.10784240f, 0.14765920f, 0.20700997f, 0.25080755f, -0.01380473f, -0.11543799f, 
    0.04228888f, 0.00741799f, -0.06408966f, -0.03488744f, 0.05766922f, -0.02611515f, -0.08896821f, 0.02838636f, 
    -0.02707733f, 0.07007033f, 0.08520887f, 0.06265125f, 0.01949487f, 0.06119281f, 0.18337655f, 0.05943552f, 
    0.19335708f, 0.17296827f, 0.09867369f, 0.23833895f, 0.10125583f, 0.02351781f, -0.10317507f, 0.01106681f, 
    0.11959939f, 0.15462430f, 0.07723153f, 0.08953030f, 0.35539883f, 0.07152638f, -0.01630186f, 0.10049041f, 
    0.01990833f, 0.03701427f, 0.07234207f, -0.02443135f, 0.02231357f, 0.10079347f, -0.02824418f, 0.02300045f, 
    -0.14864340f, -0.19349653f, 0.29624969f, -0.19421895f, -0.02240169f, 0.00130102f, 0.00205771f, -0.03058428f, 
    -0.02594039f, 0.01888332f, -0.07513259f, -0.01015024f, 0.05594752f, 0.03624330f, -0.06823860f, -0.01304487f, 
    -0.01654335f, 0.01617800f, -0.03242413f, -0.01764538f, -0.09882078f, 0.15158343f, 0.07909261f, 0.05214273f, 
    0.40803453f, 0.28003493f, 0.22940892f, 0.17930467f, 0.09005713f, 0.06946488f, 0.16310209f, 0.22525835f, 
    -0.02096920f, -0.00270429f, -0.02322982f, -0.02190303f, 0.01204468f, 0.06431929f, -0.08517952f, 0.05608513f, 
    0.05216052f, 0.10058392f, -0.01381865f, -0.12476769f, 0.04773827f, 0.01466807f, 0.01171016f, -0.11384872f, 
    0.41395512f, 0.14357245f, 0.13085480f, 0.10349911f, -0.03470491f, 0.11064491f, -0.03170583f, 0.09355653f, 
    -0.06075945f, -0.04596508f, -0.02137159f, -0.04907558f, 0.03686415f, 0.22838630f, -0.14731893f, 0.13079429f, 
    -0.02000134f, 0.14616676f, 0.04669502f, 0.10819612f, -0.00405606f, -0.00620533f, -0.01930115f, -0.07301261f, 
    0.10504641f, -0.17596023f, 0.04200272f, 0.39050075f, 0.01333944f, 0.20036939f, -0.07747551f, 0.12917772f, 
    -0.03609844f, 0.10496563f, 0.04197415f, -0.04114992f, 0.42962891f, 0.21906756f, 0.05229035f, 0.09252170f, 
    0.05533604f, 0.02122032f, 0.01475328f, 0.01474317f, -0.05567638f, 0.01641835f, 0.01311811f, 0.19299220f, 
    -0.07953104f, 0.27767354f, 0.03890489f, 0.04559332f, -0.11582189f, 0.03897086f, 0.21388198f, 0.05495472f, 
    0.05433753f, 0.02400568f, -0.11586809f, 0.05057655f, 0.03424155f, 0.07902788f, -0.02733398f, 0.09327280f, 
    0.05784280f, 0.17017624f, -0.07440840f, 0.01264615f, 0.03008585f, -0.00325960f, -0.05746000f, 0.03699637f, 
    -0.65664274f, 0.06683622f, 0.10396097f, -0.12656859f, -0.08321391f, -0.00472490f, -0.10899720f, -0.03698080f, 
    0.07762408f, -0.03905065f, 0.05109217f, 0.01163197f, 0.16084641f, 0.06870236f, 0.11456793f, 0.46483874f, 
    0.00415630f, 0.08379199f, -0.04506904f, 0.14189352f, -0.01026884f, -0.14878948f, -0.06734933f, 0.05058780f, 
    0.06076259f, 0.06806438f, -0.29701558f, 0.05537663f, -0.12459829f, -0.03811108f, 0.08723032f, 0.21387970f, 
    -0.07977126f, 0.03389266f, 0.01592598f, 0.06618918f, 0.42157537f, 0.32073069f, 0.13335578f, 0.00486555f, 
    0.02540576f, 0.19635510f, 0.02683305f, -0.01413333f, 0.00162476f, 0.01910089f, -0.01232992f, -0.04112966f, 
    0.00508310f, 0.12162770f, 0.12930246f, 0.09689233f, 0.11880777f, 0.01388170f, 0.20019852f, -0.11227427f, 
    -0.04854664f, 0.00485475f, 0.03049798f, 0.05736381f, 0.23200457f, 0.03690102f, 0.39829952f, 0.22462773f, 
    0.05443983f, 0.04544291f, 0.18226585f, -0.09221316f, -0.00720000f, -0.13390832f, 0.10368338f, -0.03996775f, 
    -0.00165828f, -0.13002665f, -0.19441678f, -0.11808538f, -0.01203385f, -0.07161157f, -0.01616811f, 0.03441976f, 
    -0.11019228f, 0.03145630f, -0.10365689f, 0.04198974f, -0.09726670f, 0.21191132f, -0.12473468f, -0.14337845f, 
    -0.02141932f, 0.19374326f, 0.05771495f, 0.17495342f, -0.08265125f, -0.10501736f, 0.02284677f, -0.03067178f, 
    0.17237958f, 0.01434008f, 0.06778569f, 0.17016068f, 0.07938369f, 0.07874031f, 0.03064721f, 0.10068975f, 
    0.00769138f, 0.18515171f, 0.00266500f, 0.01349207f, -0.17951483f, 0.07451899f, -0.32133278f, -0.00240549f, 
    0.03574957f, -0.04570035f, -0.15813038f, 0.05326322f, 0.09220347f, -0.04027217f, -0.05537768f, 0.03140682f, 
    -0.07403963f, -0.08850049f, 0.21763773f, -0.07252482f, 0.02802727f, -0.00644811f, -0.07526386f, -0.13466989f, 
    0.07845873f, 0.17518242f, 0.02693692f, -0.07543936f, -0.22785385f, -0.08739498f, -0.07701673f, -0.12403788f, 
    0.00050189f, -0.02622423f, -0.08563963f, -0.02727330f, 0.01082585f, -0.05462719f, -0.19766122f, 0.08283585f, 
    -0.03352581f, -0.12755741f, 0.19849783f, -0.24742800f, -0.13070376f, 0.16198868f, 0.11896863f, -0.17804079f, 
    0.02973447f, -0.00164233f, -0.07741588f, 0.19376564f, 0.12747829f, -0.06405425f, -0.22301030f, 0.35566950f, 
    -0.04151016f, -0.03518175f, 0.18184210f, -0.23386878f, -0.00059229f, -0.00906712f, 0.05062246f, -0.07054854f, 
    -0.00450031f, 0.03676025f, 0.07505241f, -0.00999468f, -0.05647214f, -0.00718971f, 0.07561035f, -0.11133963f, 
    -0.06794461f, 0.07552326f, 0.05096780f, 0.01201252f, 0.05169531f, 0.16070944f, 0.09381311f, 0.09089691f, 
    0.03057113f, 0.10745320f, 0.04594637f, 0.09744309f, -0.04112979f, 0.08051974f, -0.01783917f, 0.00205401f, 
    0.33590496f, 0.11571024f, 0.28497264f, 0.00195278f, 0.02682513f, 0.02165172f, 0.06986200f, -0.06507528f, 
    -0.02989272f, 0.01234366f, 0.07017155f, 0.00970963f, 0.05782925f, 0.07281601f, 0.16146968f, -0.07997606f, 
    0.11128578f, 0.12253288f, 0.01963793f, -0.09536117f, 0.20829354f, -0.07300774f, 0.13833874f, 0.01133027f, 
    -0.19965544f, 0.36255282f, 0.04150043f, 0.07763802f, -0.04929687f, -0.01825403f, 0.26708883f, 0.08635036f, 
    0.01344238f, 0.18829362f, 0.04232328f, -0.08042978f, -0.03861035f, -0.34736881f, -0.04305857f, -0.13177927f, 
    0.00393988f, -0.01618967f, 0.00648604f, 0.00261161f, 0.03895186f, 0.03611480f, -0.16639152f, -0.09970956f, 
    -0.25365159f, 0.01031584f, 0.02370758f, -0.04228310f, 0.16243736f, 0.06574910f, 0.10280334f, -0.07803475f, 
    -0.04753921f, 0.00538850f, -0.07395411f, 0.15741016f, -0.33046252f, 0.09446989f, -0.03027247f, 0.04144749f, 
    -0.12513997f, -0.05788077f, -0.08053024f, -0.00256202f, -0.04407796f, 0.03808336f, 0.08905581f, 0.12928168f, 
    0.19341092f, -0.30004242f, 0.12214590f, 0.01145418f, 0.10526539f, 0.13538097f, -0.04438221f, 0.10211729f, 
    -0.06594113f, -0.09026649f, 0.24032702f, 0.02401702f, -0.18770632f, 0.13684207f, -0.13055880f, 0.06957227f, 
    -0.06275155f, 0.04933263f, -0.01145863f, 0.07799799f, 0.01426182f, -0.03512483f, -0.16370995f, 0.00075389f, 
    -0.33972815f, 0.04116067f, 0.02235817f, -0.06529102f, -0.03794568f, 0.04169815f, 0.14764997f, -0.08102810f, 
    0.07640812f, 0.12042951f, -0.02172783f, 0.09590966f, 0.03607266f, -0.09560741f, 0.02357239f, -0.17919470f, 
    -0.14527138f, -0.03884046f, 0.05966807f, 0.00717328f, -0.14032499f, 0.16956359f, 0.23405851f, 0.01329069f, 
    0.01818145f, 0.18550451f, -0.05481583f, 0.22337615f, 0.07104163f, 0.11037081f, 0.02849944f, 0.05786578f, 
    0.08182605f, -0.09467693f, 0.00386495f, 0.03086009f, -0.38401556f, -0.26389083f, -0.08870114f, 0.02187461f, 
    -0.07695619f, -0.00109500f, 0.00159146f, -0.08373760f, 0.08021892f, 0.09041056f, -0.04208651f, 0.02468754f, 
    -0.53201145f, 0.20103051f, -0.19887881f, -0.30581737f, -0.11006082f, -0.08764365f, 0.11772218f, 0.02164046f, 
    0.01067554f, 0.09361544f, -0.00860205f, 0.12023982f, 0.09804914f, -0.08577523f, -0.12423684f, 0.19793823f, 
    0.00340349f, -0.13626130f, -0.01053083f, 0.08010533f, -0.14213084f, 0.00234474f, -0.20230129f, 0.09474209f, 
    -0.13428953f, -0.15147702f, -0.14167543f, -0.11622110f, -0.06515896f, -0.05932990f, -0.00003850f, -0.03882247f, 
    0.05220691f, 0.06172532f, -0.03606877f, 0.01316288f, -0.17082787f, 0.20849010f, -0.30249593f, -0.15635180f, 
    0.05226861f, 0.00029386f, -0.06440797f, -0.03318270f, -0.03862607f, -0.12891482f, -0.06718203f, -0.01265020f, 
    -0.18354706f, -0.41221148f, -0.08147250f, 0.33029598f, 0.00069713f, 0.02828626f, -0.03233328f, 0.17384996f, 
    0.04115527f, -0.13881890f, 0.00257787f, 0.22734161f, 0.11541471f, 0.01032716f, -0.00862961f, -0.22789825f, 
    -0.04771150f, -0.24999557f, -0.12143899f, -0.02550318f, 0.00715659f, 0.04785499f, -0.02136546f, 0.01133678f, 
    -0.01531642f, 0.02066153f, -0.02372432f, 0.00812201f, -0.01962714f, -0.02477031f, -0.02716121f, -0.00600312f, 
    0.00699830f, 0.01661887f, 0.00185644f, 0.01537773f, -0.00540736f, -0.00460648f, 0.02882038f, 0.01125094f, 
    -0.02191182f, 0.00592309f, -0.04226824f, -0.03869127f, -0.02602497f, 0.01148535f, -0.02952543f, -0.01538588f, 
    -0.01486817f, 0.01296567f, 0.03302342f, -0.01978085f, 0.02659182f, 0.01086647f, 0.00344989f, 0.02745392f, 
    0.02745824f, -0.04295648f, -0.03075677f, 0.00277303f, -0.02464225f, -0.00645975f, 0.01411391f, 0.03473232f, 
    0.03028524f, -0.00731084f, 0.01383634f, 0.02155095f, 0.02007858f, 0.01514362f, 0.00533002f, -0.04142443f, 
    -0.02347166f, 0.01626118f, 0.01817361f, 0.00456879f, -0.02449381f, 0.02711415f, 0.00827526f, -0.02356458f, 
    -0.00872536f, -0.00476331f, -0.02832473f, 0.01495162f, -0.00947815f, 0.02448452f, -0.01853683f, -0.03100722f, 
    -0.01268758f, 0.00444591f, -0.02156573f, -0.04019111f, -0.00017139f, -0.03963839f, -0.01284639f, 0.01396898f, 
    0.00493512f, -0.01213881f, 0.00368654f, -0.00729715f, 0.02006594f, -0.00553975f, -0.00607075f, 0.01313256f, 
    0.02212245f, -0.03273930f, 0.01793519f, 0.02077600f, 0.00332217f, -0.02370361f, -0.03197950f, -0.02931019f, 
    -0.02708903f, -0.01241105f, -0.03462984f, 0.00231656f, 0.01216412f, -0.00227270f, 0.01915334f, 0.01825769f, 
    -0.01640803f, 0.01161014f, 0.02111087f, -0.00694902f, -0.00849211f, -0.00525055f, -0.02678896f, 0.00844995f, 
    0.01289134f, 0.02337289f, -0.02546346f, 0.01895346f, -0.03278710f, 0.03033767f, 0.02132113f, 0.00725085f, 
    -0.03569309f, -0.03899273f, 0.01995955f, 0.01689923f, -0.03553918f, -0.01604691f, -0.02252558f, -0.03818037f, 
    -0.02664426f, 0.01260862f, -0.02807401f, -0.00639676f, 0.01940328f, -0.02603785f, 0.01195306f, -0.01387621f, 
    0.00789852f, 0.02841463f, -0.00481867f, -0.00581698f, 0.00359705f, -0.01136721f, -0.00975854f, -0.01349003f, 
    -0.00077471f, 0.01416548f, 0.02728226f, -0.00829004f, 0.01114100f, 0.01302826f, -0.02845056f, 0.00532630f, 
    -0.03624922f, 0.03800677f, -0.00464717f, 0.02029730f, 0.02321655f, 0.02728949f, 0.00093881f, 0.02377096f, 
    -0.00650864f, 0.01363234f, 0.01772191f, 0.00790718f, -0.01453388f, 0.01469606f, 0.01795410f, -0.02436631f, 
    -0.03200769f, -0.00122074f, 0.01837994f, 0.00181511f, -0.01856341f, 0.02226478f, 0.02121385f, 0.00416130f, 
    -0.00857205f, -0.00690470f, -0.02499007f, 0.00802287f, -0.00981616f, -0.02764704f, -0.02856656f, 0.01033724f, 
    0.01253048f, 0.01428117f, 0.01049663f, -0.03690490f, -0.02824434f, 0.03329773f, 0.00061055f, -0.00345772f, 
    -0.02449864f, -0.02832554f, 0.01502723f, -0.03903852f, 0.00135542f, 0.00724448f, 0.02320334f, -0.03548548f, 
    0.03210983f, -0.00457087f, -0.02060937f, 0.00450376f, 0.03251091f, 0.02934887f, 0.00670771f, -0.00171757f, 
    -0.01384601f, -0.03475849f, -0.01262219f, 0.02642537f, 0.03926777f, 0.01833698f, -0.00626653f, -0.01452517f, 
    -0.01264916f, -0.00122765f, -0.01422415f, 0.00394651f, -0.02327054f, 0.02530802f, -0.03893425f, -0.03074584f, 
    -0.01486020f, 0.00084662f, 0.02913377f, -0.00129996f, -0.02466880f, -0.03597885f, -0.00584903f, -0.01625073f, 
    0.03073216f, -0.02664721f, -0.01439289f, 0.01148264f, 0.01115026f, -0.02017527f, 0.02996771f, 0.02109511f, 
    0.02176867f, 0.01155505f, -0.00329229f, 0.02104993f, 0.01538353f, 0.02156243f, -0.02280103f, 0.02370998f, 
    0.02380534f, -0.00331757f, 0.02339615f, -0.01979686f, -0.01855093f, 0.00576056f, -0.03882112f, -0.03218998f, 
    0.00578680f, -0.02603048f, -0.02126990f, 0.02781291f, 0.00198295f, 0.02100241f, 0.03212358f, 0.02876116f, 
    0.01406623f, -0.00769332f, -0.00666856f, 0.02772432f, -0.01511198f, -0.01492806f, 0.01123453f, -0.00314449f, 
    -0.04018331f, 0.01549116f, 0.02419516f, 0.00178126f, -0.00782516f, 0.02883605f, -0.03780729f, -0.00461033f, 
    0.01320374f, 0.01413748f, -0.00525712f, -0.03355256f, -0.00957352f, -0.00994647f, -0.02045484f, -0.02633247f, 
    -0.01613858f, 0.02046945f, -0.00653672f, -0.03437556f, 0.02875351f, -0.04032473f, -0.03837084f, -0.03232241f, 
    -0.03220001f, -0.03440291f, -0.01389394f, -0.03230865f, -0.03931059f, -0.02148042f, 0.01629412f, -0.01265927f, 
    -0.02495951f, 0.00892368f, -0.00179249f, 0.01597167f, 0.02599970f, -0.03311350f, -0.00760208f, 0.00603414f, 
    -0.03648035f, 0.02335308f, 0.01563383f, -0.01077596f, -0.02295921f, 0.00927656f, -0.02872962f, -0.00080881f, 
    0.02943628f, -0.00253014f, -0.01608868f, 0.02123714f, -0.02858450f, 0.01887934f, 0.00258814f, -0.00273531f, 
    0.01153638f, -0.03494885f, -0.00362491f, 0.01397815f, -0.01403175f, -0.01360215f, -0.00989178f, 0.01404854f, 
    0.00463327f, -0.00829602f, 0.01563911f, 0.00336300f, 0.00629903f, -0.02654610f, -0.01732822f, 0.03367033f, 
    -0.01994453f, 0.02512178f, 0.02454185f, -0.04160565f, 0.01867859f, -0.01385099f, 0.02026230f, -0.00672597f, 
    0.00220007f, -0.01164391f, -0.02579678f, 0.02114090f, 0.02888465f, -0.01912985f, -0.00550171f, -0.02149311f, 
    0.01174451f, 0.01841136f, -0.01442869f, -0.02545247f, 0.00573408f, 0.00750591f, 0.00335536f, -0.01966142f, 
    0.00872342f, 0.02297063f, -0.03092355f, -0.01217776f, -0.03201890f, -0.01377090f, -0.03007671f, -0.03889904f, 
    -0.02859788f, 0.02520804f, 0.02726706f, -0.00671536f, -0.01060324f, 0.02126802f, 0.01242127f, -0.00106808f, 
    -0.02241101f, -0.01049022f, 0.01005220f, -0.02953262f, -0.02981982f, -0.04097574f, 0.00285932f, -0.00167915f, 
    -0.00635207f, 0.00623265f, 0.00913284f, -0.02521865f, -0.00806844f, -0.02292150f, -0.00124395f, 0.00600197f, 
    -0.00110425f, -0.02088647f, 0.01954651f, -0.00703542f, -0.02814595f, 0.02198414f, 0.00428557f, 0.02507313f, 
    -0.03466821f, 0.01794833f, 0.00037799f, 0.01099675f, -0.03958492f, -0.00154776f, -0.02325365f, 0.02345599f, 
    0.00494713f, -0.01741555f, 0.01685145f, 0.01541594f, -0.02677802f, 0.01514836f, 0.02101425f, 0.02382983f, 
    -0.01177888f, -0.02616921f, -0.00343693f, 0.01548397f, -0.01580632f, 0.02867260f, 0.01934953f, -0.00135790f, 
    -0.00000362f, -0.01188984f, 0.02457509f, 0.01489210f, -0.00232121f, -0.00053706f, -0.00244009f, -0.00698514f, 
    0.02564824f, -0.01978036f, -0.03005722f, -0.01324337f, 0.02577329f, 0.02554587f, 0.02047309f, 0.03042906f, 
    -0.03243906f, -0.00005237f, 0.02379010f, -0.04455669f, 0.01872653f, -0.03276274f, -0.01804408f, -0.02603165f, 
    0.01012479f, -0.04004825f, -0.00998657f, 0.02235594f, -0.04169393f, 0.00555120f, -0.04140208f, 0.03080384f, 
    -0.02278690f, 0.01944151f, -0.03573637f, -0.02845603f, 0.02644601f, -0.03271263f, 0.02805477f, -0.01031750f, 
    -0.04449824f, 0.00636190f, -0.02647895f, -0.03836865f, -0.03825445f, -0.01880191f, 0.01929051f, -0.03318012f, 
    0.01716338f, 0.00325844f, 0.02495205f, 0.02858733f, 0.00590165f, -0.00368425f, -0.00415145f, 0.02740955f, 
    0.00188225f, -0.01511989f, 0.03164947f, -0.01802293f, 0.00445157f, -0.00539283f, -0.00643462f, -0.01886796f, 
    -0.03872819f, -0.01380832f, -0.04123082f, -0.02077057f, 0.02134567f, -0.01467837f, -0.01025816f, -0.01101857f, 
    0.02251610f, -0.00981103f, -0.02471983f, 0.01225302f, 0.00703677f, -0.03050233f, 0.00578897f, 0.03292360f, 
    -0.02375990f, 0.01333460f, -0.03892699f, 0.01586136f, -0.00797946f, -0.00940789f, -0.00668213f, -0.01498636f, 
    -0.03039102f, 0.02041507f, -0.03373786f, 0.02486326f, -0.01004852f, 0.00289573f, 0.03096009f, -0.01908634f, 
    0.03062235f, -0.02650124f, -0.03340748f, 0.02643875f, -0.01644811f, -0.01164305f, -0.02358889f, -0.02755687f, 
    -0.00043840f, 0.00872778f, -0.01702756f, -0.01622418f, -0.03949011f, -0.00777170f, -0.00277357f, 0.02452202f, 
    -0.01244710f, -0.03026834f, 0.02381022f, -0.02097745f, -0.03706408f, 0.00103491f, -0.01068336f, 0.03325117f, 
    -0.00668273f, -0.03972071f, -0.03372405f, -0.00135322f, -0.02337465f, -0.02420917f, 0.01624727f, 0.00712303f, 
    0.03082063f, -0.03288976f, 0.02051899f, -0.01441383f, -0.01169086f, 0.02675425f, 0.01129467f, -0.00251086f, 
    0.00690263f, -0.02634095f, -0.02393611f, -0.01155085f, -0.03572290f, 0.00237618f, -0.00325220f, -0.03566891f, 
    -0.00199364f, -0.00553890f, 0.00673358f, -0.03687128f, -0.01999811f, 0.02480777f, -0.04526875f, -0.01645434f, 
    0.02742758f, -0.03246615f, 0.02321621f, -0.00266138f, -0.00922406f, -0.00169669f, -0.00558283f, -0.00316652f, 
    -0.03318963f, -0.04061225f, 0.02162048f, 0.01575252f, -0.02702801f, 0.00287273f, 0.01354066f, 0.03449207f, 
    0.01139222f, -0.02126013f, 0.01314592f, 0.02203615f, -0.02554302f, -0.00835765f, -0.04191791f, 0.01591002f, 
    -0.01092767f, 0.00334208f, -0.02691841f, 0.02437388f, -0.00568089f, -0.01468505f, 0.01771122f, -0.00733139f, 
    -0.04461908f, 0.01020139f, -0.02694669f, 0.00127580f, 0.01831128f, 0.03266672f, 0.01372703f, 0.02644567f, 
    0.01485521f, -0.03277067f, 0.00093344f, -0.00036922f, 0.01741263f, 0.00224769f, -0.00742877f, -0.02396738f, 
    0.02550185f, -0.02273407f, -0.01822056f, -0.01870699f, 0.00027792f, 0.01090162f, 0.00307023f, 0.02567695f, 
    -0.03371862f, 0.02376560f, -0.01953930f, -0.00678069f, 0.00914316f, 0.01103338f, 0.01046261f, 0.01425560f, 
    -0.02981356f, -0.00416078f, -0.00677148f, 0.01458339f, -0.02168059f, -0.01352247f, -0.00194600f, 0.01323305f, 
    0.01135376f, -0.02477598f, 0.00074001f, -0.00098428f, -0.03924882f, 0.02892032f, -0.03853313f, 0.02195605f, 
    -0.00741788f, 0.00104618f, 0.00200413f, 0.02495028f, 0.01915924f, -0.00279811f, -0.03440969f, 0.00992208f, 
    -0.01257020f, -0.01666991f, 0.01844960f, 0.01160902f, -0.01503582f, -0.03766885f, -0.02072460f, 0.01287864f, 
    0.01114633f, 0.02965434f, -0.02422873f, -0.01565976f, -0.03441955f, -0.01301105f, 0.00663619f, 0.01730091f, 
    0.03147530f, -0.02684538f, 0.00839552f, -0.02692643f, 0.00822961f, 0.01759910f, 0.00599005f, 0.00277617f, 
    0.00291078f, -0.03615336f, -0.02954357f, -0.02480131f, 0.02842357f, 0.01836086f, 0.00636797f, -0.00931361f, 
    0.03009169f, 0.03348520f, 0.01612693f, 0.00049182f, 0.00460958f, 0.02830327f, 0.00961291f, 0.00425670f, 
    0.02317462f, -0.03727841f, 0.02426371f, -0.03110338f, 0.01576508f, -0.01939309f, 0.01405665f, -0.03738613f, 
    0.03238655f, 0.02144219f, 0.01476203f, 0.02075651f, -0.00400491f, -0.01940257f, 0.00033448f, 0.01686664f, 
    0.03406869f, 0.02428599f, 0.01164138f, -0.01611240f, 0.03012387f, 0.01537619f, 0.02220817f, -0.02920815f, 
    -0.01752455f, -0.01173798f, -0.01282991f, -0.02176715f, 0.02637911f, 0.00558551f, -0.02091312f, 0.00520307f, 
    0.02766499f, 0.01123230f, -0.04268986f, -0.01782076f, -0.02837400f, -0.02263315f, -0.02431333f, 0.00482274f, 
    0.03253674f, -0.02653925f, 0.02809471f, -0.01831113f, -0.01519874f, 0.02831541f, -0.01999644f, 0.02379188f, 
    0.03263222f, -0.03013073f, -0.00507037f, -0.02687007f, 0.02785487f, -0.02891470f, -0.01047156f, 0.02609543f, 
    0.01662444f, 0.02538402f, -0.02313077f, -0.00652197f, -0.01404336f, -0.01794017f, -0.02647088f, -0.02592311f, 
    -0.03032336f, 0.01024252f, 0.24721850f, 0.13418202f, 0.17006993f, 0.00224105f, 0.04340832f, -0.02161811f, 
    0.07221345f, -0.11644996f, -0.09817341f, 0.12394739f, -0.03084439f, 0.30045602f, -0.02876366f, 0.14287430f, 
    -0.07548109f, -0.16667862f, 0.26895109f, -0.10447939f, 0.06675241f, 0.11293704f, -0.02862692f, 0.07932152f, 
    -0.02233739f, -0.03575472f, -0.04692132f, -0.09166753f, 0.02274120f, 0.09433699f, -0.12011543f, -0.13582647f, 
    0.10479486f, 0.00107775f, -0.05169504f, -0.11494553f, -0.12901223f, 0.04049518f, -0.11656999f, -0.06141731f, 
    -0.03918791f, -0.15371615f, -0.06432450f, -0.10471147f, 0.14581034f, 0.01753223f, -0.03351116f, -0.14615567f, 
    0.12447701f, 0.14208846f, -0.15738848f, 0.03572109f, 0.01720637f, -0.08502203f, 0.02219955f, -0.22487247f, 
    0.05246719f, 0.18113337f, -0.11575801f, 0.13501167f, -0.25343335f, 0.17516574f, 0.04030218f, 0.08121299f, 
    0.03433556f, -0.02013131f, 0.14647785f, 0.03051453f, -0.08315174f, -0.04981576f, 0.02514427f, -0.10802486f, 
    0.19091351f, 0.25151503f, 0.14293946f, 0.15036832f, -0.05622960f, -0.18192019f, -0.10396904f, -0.06146185f, 
    0.04947423f, 0.05334545f, 0.08342646f, 0.00937751f, -0.06838526f, -0.19258130f, 0.08560016f, -0.10455131f, 
    0.06028584f, -0.09631215f, 0.12391839f, -0.06376922f, -0.19515106f, 0.00914570f, -0.22886197f, -0.17626639f, 
    0.29307061f, -0.03328151f, -0.33808702f, 0.20253001f, -0.11234345f, 0.03128754f, 0.03342962f, -0.04022673f, 
    -0.05401864f, 0.08682632f, -0.02639258f, -0.03786501f, -0.33137757f, -0.19567101f, 0.04016811f, 0.14613311f, 
    -0.08780434f, 0.02471538f, 0.13538571f, 0.10573191f, -0.12201615f, -0.01367705f, -0.08175677f, -0.17207634f, 
    0.00201862f, -0.19696212f, -0.43092206f, 0.17433204f, -0.00988130f, 0.09860951f, 0.14905649f, -0.08679587f, 
    0.03434056f, 0.01366081f, 0.02534367f, -0.11063868f, 0.13019365f, -0.11573564f, -0.01497393f, -0.05102023f, 
    -0.12821843f, -0.03422924f, -0.13872163f, -0.13074018f, -0.02676285f, 0.16327336f, 0.07076042f, -0.00741870f, 
    -0.38087350f, -0.10802756f, 0.06764311f, 0.12949778f, 0.02821790f, 0.07568967f, -0.18062332f, 0.16802448f, 
    0.13304035f, 0.05972926f, 0.01736752f, -0.00896280f, -0.01927490f, -0.09493191f, -0.08755159f, -0.01547051f, 
    -0.08832026f, 0.09729275f, -0.10553484f, -0.01218679f, 0.20810613f, 0.09441994f, 0.10938563f, 0.15531856f, 
    0.27591005f, -0.14956911f, 0.03789106f, 0.15998612f, 0.02743342f, -0.02348526f, -0.01714649f, -0.05860365f, 
    0.11082873f, -0.04308096f, 0.20654070f, 0.16708435f, 0.12006068f, 0.19349283f, 0.11861994f, 0.20332359f, 
    -0.08547995f, -0.10775806f, -0.20745133f, -0.08250182f, -0.01384979f, -0.17477001f, 0.01950740f, 0.09351169f, 
    -0.18172005f, -0.21732603f, -0.00698803f, 0.10954117f, -0.04966195f, -0.02587832f, 0.03896699f, 0.09106340f, 
    0.04155265f, 0.04726707f, 0.06256759f, 0.10076527f, -0.18424141f, 0.14969347f, 0.22246693f, 0.15689693f, 
    0.06248055f, -0.01167047f, 0.05395726f, -0.03171787f, 0.06885891f, 0.16255097f, 0.10973823f, -0.03879940f, 
    -0.10351490f, -0.16584124f, 0.11365613f, 0.23890805f, 0.03297770f, -0.03833697f, 0.07492889f, -0.00293246f, 
    0.02079650f, 0.08800997f, 0.04952420f, 0.20051053f, -0.33242974f, 0.31671616f, 0.46230862f, 0.06639954f, 
    -0.00807104f, -0.08704968f, 0.10691866f, -0.04138917f, -0.01435551f, 0.04595409f, -0.00827332f, 0.05090012f, 
    0.03123837f, 0.25779033f, -0.07409351f, -0.16266638f, -0.01242814f, 0.01791662f, -0.04150573f, -0.09882418f, 
    0.08390640f, 0.04473385f, 0.13881035f, -0.16699296f, -0.10918786f, 0.16417606f, 0.16684553f, 0.14115396f, 
    0.00615390f, 0.02022936f, -0.15901344f, 0.09658478f, 0.05224105f, 0.13868327f, 0.05916535f, 0.12073582f, 
    -0.29844382f, -0.36485270f, -0.06491197f, 0.14846264f, -0.03618275f, 0.08141466f, -0.00130279f, 0.04031143f, 
    -0.04624756f, -0.06329240f, -0.08408654f, -0.04891547f, -0.04958094f, -0.09980381f, -0.01371671f, 0.07221096f, 
    0.05021157f, -0.11409404f, -0.14082769f, -0.17959324f, -0.11676940f, -0.03842725f, -0.03129315f, -0.36952117f, 
    0.21622518f, -0.14967114f, 0.11249645f, 0.20668881f, 0.00272950f, -0.02257350f, -0.01319262f, -0.01501673f, 
    -0.00490696f, -0.09772971f, 0.01100945f, 0.22216243f, 0.46159625f, 0.25869074f, 0.37556225f, 0.19690357f, 
    0.08088131f, -0.13861507f, -0.12882610f, -0.02717536f, -0.01532411f, 0.12659161f, -0.01583716f, 0.07695853f, 
    -0.26076630f, -0.25829148f, 0.02380691f, 0.06368317f, -0.01804371f, -0.04746668f, 0.14618842f, 0.02111350f, 
    0.06211560f, 0.17724814f, -0.06796589f, 0.14859168f, 0.08102926f, 0.12037641f, 0.21412377f, 0.31698710f, 
    -0.03538141f, -0.18976723f, -0.02369284f, 0.01941611f, -0.07216919f, 0.09103198f, 0.09944822f, 0.12086015f, 
    -0.18288985f, -0.00744618f, -0.09493403f, 0.13540244f, 0.15601608f, 0.16120984f, -0.10653694f, 0.06620198f, 
    -0.08970053f, -0.10696102f, -0.01873479f, 0.03220791f, -0.28658411f, -0.36273667f, -0.11834779f, 0.14883608f, 
    -0.09131558f, 0.00077514f, 0.10334023f, 0.12618276f, -0.03342671f, 0.02711174f, -0.10985099f, 0.03437601f, 
    0.14230332f, -0.11819869f, -0.17667256f, -0.08752473f, -0.04875650f, 0.01975038f, -0.05270521f, -0.03508867f, 
    -0.02541364f, 0.12339375f, -0.16514330f, -0.08263235f, -0.29996562f, -0.26821372f, 0.18625769f, 0.14290065f, 
    0.02781001f, 0.03155766f, 0.05382124f, 0.11207804f, 0.04805807f, 0.05296132f, 0.03899767f, 0.04024298f, 
    -0.29090840f, -0.33253935f, 0.00268929f, 0.17078982f, 0.01889206f, 0.05112453f, -0.02373492f, 0.11205918f, 
    0.11112200f, -0.03867116f, 0.00991637f, 0.02312047f, 0.20998046f, 0.09557133f, 0.05648100f, 0.28667003f, 
    0.03369352f, -0.06421839f, -0.04109786f, -0.00967933f, 0.02269555f, 0.02232282f, 0.18760206f, 0.17368603f, 
    -0.09732199f, -0.18913512f, -0.03739248f, 0.03767002f, -0.01324413f, 0.09741829f, 0.05081135f, 0.02477317f, 
    -0.14113693f, -0.05376199f, 0.00136350f, -0.26446250f, -0.09811100f, -0.07235369f, -0.10433365f, 0.21207131f, 
    -0.01038075f, -0.00704835f, -0.00792593f, 0.10642198f, 0.00179557f, 0.01754607f, 0.13501711f, 0.01503781f, 
    0.18322760f, 0.19300863f, 0.12129673f, 0.03648198f, 0.00299497f, -0.01179988f, -0.04577252f, -0.07644758f, 
    0.12681307f, 0.00142433f, -0.03729508f, 0.10194756f, -0.05849071f, 0.09348220f, -0.32277134f, 0.03214416f, 
    0.12729484f, -0.01588897f, 0.06005597f, -0.10738105f, 0.12283877f, 0.08131246f, 0.15914550f, -0.00528391f, 
    -0.02315286f, -0.07843124f, 0.03216224f, -0.02269591f, -0.05211183f, 0.04538326f, 0.01662246f, 0.02653560f, 
    -0.00327771f, -0.04203196f, -0.13257854f, -0.12036770f, -0.07958300f, -0.16647699f, -0.10841022f, 0.28291488f, 
    0.03430546f, 0.04231684f, 0.03715157f, 0.10273364f, -0.04951987f, -0.01080258f, -0.04088303f, 0.04299898f, 
    0.23839062f, 0.23276091f, 0.11469451f, -0.04344446f, 0.01399647f, -0.04274858f, 0.00784296f, -0.06836381f, 
    0.10467058f, 0.16440560f, 0.16417311f, 0.24907832f, -0.12640856f, 0.06817611f, -0.12947644f, -0.07839680f, 
    -0.05787364f, -0.09027644f, -0.06197208f, -0.06461736f, 0.17727970f, 0.20180683f, 0.14941183f, 0.18632202f, 
    -0.07883520f, 0.25423747f, -0.13899854f, -0.02429040f, -0.05854532f, 0.07206589f, -0.13240494f, -0.11773349f, 
    -0.04240599f, 0.21290533f, 0.18731372f, -0.18149669f, -0.07592244f, 0.02534092f, 0.38893282f, 0.03531275f, 
    0.10414548f, 0.06660821f, 0.02313604f, -0.19649495f, -0.01166681f, 0.17351538f, 0.12972525f, 0.08708707f, 
    0.06243423f, -0.00572356f, 0.00301317f, -0.05958624f, 0.10630096f, 0.09769438f, -0.04766872f, 0.07034395f, 
    0.03630513f, -0.05249994f, -0.00473664f, 0.07896998f, 0.04658790f, -0.00328511f, 0.17303638f, 0.27484658f, 
    -0.03056815f, -0.14643392f, 0.10121786f, 0.02265206f, 0.07906657f, -0.04717421f, 0.11984526f, 0.14400278f, 
    -0.00394600f, 0.12062852f, 0.45848152f, 0.24959819f, 0.02395277f, -0.07657868f, -0.01224396f, 0.11877389f, 
    -0.04378060f, 0.04650599f, 0.04442456f, 0.09560791f, 0.32891446f, 0.31996694f, -0.12061697f, -0.11265727f, 
    0.02287191f, 0.05240482f, 0.10629827f, -0.13248387f, 0.17025438f, 0.17045856f, 0.02156722f, 0.23290153f, 
    0.09146468f, -0.22962238f, 0.26511642f, 0.16067319f, 0.08389940f, -0.04716683f, -0.08701707f, -0.08539070f, 
    -0.07793760f, 0.06446318f, 0.04330199f, -0.02917959f, 0.17352107f, 0.11223803f, 0.04458661f, -0.09627595f, 
    -0.01508825f, 0.03964348f, 0.00880812f, 0.00653648f, 0.07181471f, 0.01153636f, -0.10743389f, 0.12907358f, 
    0.49772614f, -0.20632562f, -0.30761296f, -0.07941063f, 0.01058561f, 0.01096133f, 0.02746372f, -0.18019646f, 
    0.04683630f, 0.04159544f, 0.00319029f, 0.26578370f, 0.05353356f, -0.08256190f, 0.05750463f, -0.01452076f, 
    0.09282680f, 0.07420867f, -0.03909145f, -0.09783413f, -0.17812617f, -0.19711147f, -0.23153755f, -0.18508530f, 
    0.03120180f, 0.18076134f, 0.07946939f, 0.06360207f, 0.00286381f, -0.10887139f, 0.11839021f, -0.20437023f, 
    -0.10653508f, 0.18162513f, -0.16654901f, -0.06633709f, 0.31684154f, 0.03993871f, -0.17425929f, 0.19760789f, 
    0.00208419f, -0.02443990f, 0.01060006f, 0.02235658f, 0.06210062f, -0.08536658f, -0.01939686f, 0.13664155f, 
    -0.04460711f, 0.04020341f, 0.00127943f, 0.18465149f, 0.14937508f, -0.01549295f, 0.02106394f, -0.05193195f, 
    -0.05508655f, -0.21991317f, -0.09623850f, -0.05755336f, -0.06311451f, -0.04354292f, 0.01464447f, -0.13125232f, 
    0.06422684f, 0.09822685f, -0.07944564f, 0.04556833f, 0.12210536f, -0.07041571f, 0.01643881f, -0.13723430f, 
    -0.17102125f, -0.12726180f, -0.13372344f, -0.01834652f, -0.07899446f, -0.04634682f, -0.07573143f, 0.25411198f, 
    0.08877605f, 0.10472609f, 0.05268309f, 0.16181336f, -0.24221598f, -0.00415314f, -0.23240624f, -0.08182376f, 
    -0.09882282f, -0.00408064f, 0.04246381f, 0.02613473f, 0.00698675f, 0.11199918f, -0.01258733f, -0.03136614f, 
    0.03055054f, 0.06394295f, -0.04400698f, 0.08421788f, -0.09319532f, -0.00937268f, 0.13496819f, -0.02145446f, 
    -0.03731883f, -0.05908051f, -0.09064368f, -0.12785244f, -0.18369018f, -0.11696043f, 0.38608754f, 0.14224340f, 
    0.11830977f, 0.12062271f, 0.11942356f, 0.01761170f, 0.11700233f, 0.06598109f, 0.13338323f, 0.06981997f, 
    -0.01949766f, -0.00566776f, -0.02033526f, -0.00734029f, 0.03928830f, 0.03911724f, 0.05610409f, -0.00625058f, 
    0.03267085f, -0.06003356f, -0.00896711f, -0.08494520f, -0.54625130f, 0.09180302f, -0.24301529f, 0.04235399f, 
    0.06027074f, 0.12776226f, -0.00899648f, -0.11068303f, -0.17965692f, 0.15930618f, 0.02303893f, -0.13370214f, 
    -0.02857247f, 0.23597518f, 0.08903839f, -0.09716265f, 0.07445751f, -0.01655907f, 0.03621532f, 0.01874242f, 
    0.15442444f, 0.05048339f, -0.05588077f, -0.26278472f, -0.05516772f, 0.22095411f, 0.20776708f, -0.04723496f, 
    0.06841848f, 0.02911119f, 0.02042381f, 0.17734453f, 0.23768845f, 0.01876442f, 0.02448974f, 0.20215912f, 
    0.02879388f, 0.13080235f, -0.03075414f, 0.16249350f, 0.01782399f, 0.02134425f, -0.01557086f, 0.01550017f, 
    -0.03152711f, -0.14358532f, -0.00906785f, -0.13142782f, -0.12413061f, -0.34543377f, 0.29170272f, -0.14791644f, 
    -0.04244942f, 0.10403584f, 0.12432222f, 0.01582726f, 0.01867357f, -0.03425030f, 0.08842512f, -0.00215713f, 
    -0.16112423f, -0.05264844f, -0.02091104f, -0.04414387f, -0.12400374f, -0.07653344f, -0.11585112f, 0.02939834f, 
    0.15565480f, -0.05561887f, 0.04050316f, 0.07858586f, -0.17290772f, 0.03923036f, -0.04337293f, 0.04313404f, 
    -0.01498008f, -0.12956728f, -0.13655038f, -0.04635759f, 0.02484255f, 0.01733971f, -0.05009447f, 0.05706732f, 
    0.05773060f, 0.06693453f, -0.04258893f, 0.05470381f, 0.03018019f, -0.08792761f, -0.17148060f, 0.07179692f, 
    0.03630478f, -0.09858482f, 0.02924945f, -0.03923337f, -0.03317532f, 0.33933923f, -0.31872785f, 0.34990326f, 
    0.09922170f, 0.18682672f, 0.12621765f, 0.20068890f, 0.10705440f, 0.03632858f, -0.13180682f, -0.15550525f, 
    0.17026648f, -0.10742147f, -0.12986195f, -0.01460855f, 0.07891055f, 0.01469445f, 0.01123078f, -0.05556752f, 
    0.00784390f, -0.01005570f, -0.08705786f, -0.04220546f, -0.05946474f, 0.00621238f, -0.02401038f, -0.21964549f, 
    -0.07538021f, -0.06080709f, -0.08129903f, 0.08316699f, -0.00983634f, 0.07576979f, -0.00942482f, -0.04205662f, 
    0.44734240f, -0.33727822f, 0.43058658f, -0.09525344f, 0.18377128f, 0.07679535f, -0.09418087f, 0.17972653f, 
    0.01307754f, -0.07009175f, 0.09204870f, 0.14404856f, 0.56806839f, 0.27983165f, 0.03561629f, -0.17068772f, 
    -0.02444282f, 0.14001536f, 0.10904579f, 0.20722856f, -0.10421665f, 0.05680715f, -0.10400476f, -0.06140304f, 
    -0.27582029f, -0.04954743f, 0.18343611f, 0.09836633f, 0.12959944f, -0.08279546f, -0.10310251f, -0.12371574f, 
    0.05877836f, 0.02492282f, 0.01156756f, -0.02379163f, -0.15180613f, -0.23993130f, 0.16550030f, -0.08696787f, 
    -0.04537886f, -0.03107126f, -0.18950371f, -0.14527726f, 0.08770330f, -0.09936027f, 0.01085205f, -0.02116181f, 
    0.36991706f, 0.57741886f, 0.01821035f, -0.21953586f, 0.05976429f, 0.02584322f, 0.11196622f, 0.30595273f, 
    -0.01776989f, -0.03448670f, 0.09458105f, 0.07375034f, -0.02196967f, -0.17436041f, 0.24342571f, 0.00522668f, 
    -0.02314152f, -0.02712066f, 0.05336433f, -0.07652581f, -0.01762701f, -0.01222228f, 0.07297617f, 0.11095621f, 
    -0.08796999f, 0.19430500f, -0.11729471f, 0.07482657f, -0.00036262f, 0.11440738f, -0.04889943f, 0.17306563f, 
    0.11057417f, -0.04497203f, -0.04362997f, 0.25348809f, 0.12415689f, -0.12586151f, -0.07485873f, -0.36354405f, 
    0.08664954f, 0.24313423f, -0.14132854f, -0.04534865f, 0.21124049f, 0.03947498f, -0.13807464f, 0.06058384f, 
    0.27157170f, 0.20304096f, 0.04708062f, -0.03293239f, 0.18424465f, -0.05100362f, -0.01749310f, 0.12617955f, 
    -0.03306316f, -0.06483926f, 0.06033879f, 0.13933964f, 0.00782354f, 0.03784337f, 0.07646056f, 0.20490851f, 
    0.09355137f, 0.02084916f, 0.01229189f, 0.16205084f, -0.00133688f, 0.05733348f, 0.01873432f, -0.07335369f, 
    0.14572147f, -0.04122460f, -0.00260553f, -0.16986263f, 0.06374692f, 0.08942123f, 0.08345121f, 0.20213491f, 
    0.06264684f, -0.12828375f, 0.12525401f, -0.00782690f, -0.24093591f, -0.28085148f, -0.09660125f, -0.02806262f, 
    0.07577125f, 0.00981310f, 0.03326600f, 0.18823096f, 0.16774963f, 0.09154832f, -0.03992874f, -0.01617251f, 
    -0.20898375f, 0.00831910f, -0.16754557f, 0.00599290f, -0.09464788f, -0.04135863f, -0.15598229f, 0.03321216f, 
    -0.01179931f, -0.03477182f, -0.04316543f, 0.02356236f, 0.35709181f, -0.00343509f, -0.18902895f, 0.09225198f, 
    0.06490687f, -0.10307442f, -0.01232349f, -0.02032445f, 0.02123386f, 0.05091712f, 0.02178605f, 0.06327035f, 
    0.19034711f, 0.24888606f, 0.19659230f, -0.17800261f, -0.06697789f, 0.09948206f, -0.19438539f, 0.11269151f, 
    0.07624329f, 0.03090439f, 0.10598637f, 0.11642192f, -0.05891741f, 0.36316502f, -0.12244095f, 0.22177821f, 
    0.00511745f, -0.01210852f, 0.00126263f, 0.17587736f, -0.02062162f, -0.02643413f, 0.01578779f, -0.00977195f, 
    -0.11238474f, -0.03295485f, -0.11111591f, -0.20304470f, -0.09587801f, 0.30586007f, 0.02032927f, 0.05495372f, 
    0.06320008f, 0.10591359f, -0.00680812f, 0.09433151f, 0.15981095f, -0.02468862f, -0.12394579f, 0.07390422f, 
    0.14584562f, 0.02082286f, -0.08690650f, -0.19921453f, -0.05927869f, 0.05185321f, 0.03260076f, 0.01991020f, 
    0.30776489f, 0.44716173f, 0.07098464f, -0.14415517f, 0.07555396f, 0.08823164f, 0.05694648f, 0.16671130f, 
    -0.04747533f, -0.07181065f, -0.00293997f, -0.02396104f, 0.24014884f, -0.09739899f, -0.04069349f, -0.15455651f, 
    0.19590932f, 0.06740321f, 0.01589045f, 0.04155591f, 0.09910977f, -0.00831503f, 0.13408738f, 0.10846525f, 
    0.27599478f, -0.07645760f, 0.10065433f, -0.07102479f, 0.00606807f, 0.06000754f, -0.02446086f, 0.07549916f, 
    -0.04764108f, 0.06217136f, 0.07071881f, 0.03336001f, 0.41722667f, 0.49014834f, 0.30547816f, 0.09624317f, 
    0.17479125f, -0.08386903f, 0.03881566f, 0.24671802f, -0.08525726f, -0.10497673f, 0.10444513f, 0.02583779f, 
    -0.02361608f, -0.22343530f, 0.19951959f, -0.05745586f, -0.08641793f, -0.03533152f, 0.04368332f, -0.10989042f, 
    -0.11821347f, 0.05869959f, 0.09250214f, -0.01329643f, 0.37596604f, 0.51011831f, 0.05248922f, -0.08585258f, 
    0.10357753f, 0.10507915f, 0.09652858f, 0.23842815f, -0.11292630f, -0.09283166f, 0.12284439f, 0.07232495f, 
    0.51168269f, 0.36722326f, 0.36932388f, -0.16886398f, 0.29286602f, 0.15809514f, 0.04321405f, 0.20906091f, 
    0.06978997f, -0.02103480f, -0.05569361f, -0.02762396f, -0.04584343f, -0.18160814f, -0.32629281f, -0.40938202f, 
    -0.09611165f, 0.10372431f, 0.07779308f, 0.30675787f, 0.04552693f, 0.04183247f, -0.01745419f, 0.08821909f, 
    0.20356844f, 0.36627305f, -0.01926384f, 0.12992541f, 0.03776265f, 0.01774124f, 0.04556080f, 0.03150284f, 
    0.01166643f, 0.06187186f, 0.07302355f, 0.09147227f, 0.38902497f, 0.28839466f, -0.08464384f, 0.11373819f, 
    0.16284539f, 0.05448533f, -0.03361329f, -0.01840376f, 0.02909169f, -0.06149675f, -0.01644956f, 0.05885374f, 
    0.05825371f, 0.08982450f, 0.05938260f, 0.17264333f, -0.05164019f, 0.09449713f, -0.06116442f, -0.08415633f, 
    -0.00541209f, 0.07426647f, 0.10617033f, 0.00805405f, -0.07508316f, 0.28966537f, 0.06562426f, 0.44685447f, 
    0.06911104f, -0.02731229f, 0.12697616f, 0.13660926f, -0.05497825f, 0.06187342f, -0.11471828f, -0.08737163f, 
    0.07268006f, 0.22032565f, 0.08617911f, -0.02722128f, 0.05766357f, 0.11419904f, 0.11854172f, 0.18786246f, 
    0.04338509f, -0.00311390f, -0.13911860f, -0.16066150f, 0.30062911f, -0.17950141f, 0.26656356f, -0.47715876f, 
    -0.16679946f, -0.03802786f, -0.03742182f, -0.16498722f, 0.11138415f, 0.06759363f, -0.09514432f, -0.08338563f, 
    -0.45870259f, 0.18709631f, -0.21813856f, 0.15104778f, -0.05706025f, -0.06923558f, -0.03670697f, -0.00797254f, 
    0.09789352f, -0.05349798f, 0.03262014f, 0.05101717f, 0.03848500f, -0.03138255f, 0.04465276f, 0.09873933f, 
    -0.06100175f, 0.04017478f, 0.04883858f, -0.03008564f, -0.05723181f, 0.02435201f, -0.00724289f, 0.02894630f, 
    -0.36504868f, -0.15634868f, 0.14709927f, -0.05199400f, -0.08650120f, -0.00197973f, -0.13082249f, -0.04616563f, 
    0.03937561f, -0.09117703f, 0.06335324f, 0.22667918f, -0.06858472f, -0.00443273f, -0.31746057f, -0.53446269f, 
    0.11163204f, -0.04793715f, 0.10424370f, 0.02102242f, 0.12326351f, -0.14106020f, -0.10397446f, -0.00567134f, 
    0.00909549f, 0.04746024f, -0.04552964f, 0.06678866f, 0.02409880f, -0.05065131f, 0.02275477f, -0.00843515f, 
    0.15417935f, 0.06046554f, -0.01704481f, 0.05898109f, 0.56639922f, -0.36246976f, 0.04925372f, -0.11219054f, 
    0.02075096f, 0.08558904f, -0.06082805f, 0.03695545f, 0.18339856f, -0.15929535f, -0.00477115f, 0.07871480f, 
    0.32352349f, -0.11614335f, -0.46554467f, -0.05231534f, 0.13629860f, 0.00963174f, -0.09221277f, 0.01053590f, 
    0.09086532f, 0.08952340f, -0.05898966f, 0.04719147f, -0.38563263f, -0.00457942f, -0.00562063f, 0.00612768f, 
    0.03149719f, 0.01747777f, 0.02780929f, 0.03430295f, -0.11101237f, -0.05740142f, 0.03098530f, 0.18267420f, 
    0.51134282f, -0.14058642f, 0.24938899f, -0.27085564f, 0.02499492f, 0.17926103f, -0.04222928f, -0.19916792f, 
    0.09896462f, -0.13979919f, 0.17328453f, -0.04028306f, 0.04711486f, -0.06308065f, 0.04175140f, 0.01644359f, 
    -0.04484570f, 0.03758151f, -0.06915093f, -0.16663305f, -0.03582886f, -0.04642703f, 0.00890313f, -0.08775000f, 
    -0.00554530f, -0.07908612f, 0.38114962f, -0.11736761f, 0.00805048f, -0.03365818f, -0.02108699f, -0.11508325f, 
    0.19142547f, -0.03593220f, 0.02173351f, 0.07434180f, -0.06112321f, -0.11050273f, 0.13434567f, -0.07387481f, 
    0.05936244f, 0.01972610f, -0.02132897f, -0.11189237f, 0.00437625f, -0.05942793f, -0.06006546f, -0.00613586f, 
    -0.13411883f, 0.06956284f, -0.18347502f, 0.18419385f, -0.04698069f, 0.09585356f, -0.14207938f, 0.00392842f, 
    0.05150286f, 0.02441204f, -0.07266588f, 0.09020770f, 0.29003450f, -0.14006500f, 0.15734316f, -0.13999599f, 
    0.06161693f, 0.02295526f, -0.01481017f, -0.09564331f, -0.03290705f, -0.05734716f, 0.00672793f, -0.17043574f, 
    0.01208006f, 0.21817628f, 0.02572467f, 0.04926115f, 0.02638793f, 0.05126735f, 0.04063387f, 0.12451261f, 
    0.05555703f, 0.10167174f, -0.03136741f, -0.13958371f, -0.06717131f, -0.00102665f, -0.18124782f, -0.09192169f, 
    0.06377506f, 0.06517849f, -0.05269156f, -0.22976802f, 0.08806095f, 0.04742474f, -0.09417395f, -0.00867980f, 
    0.26875600f, 0.02999263f, 0.35676974f, -0.20600188f, 0.14597790f, -0.00233055f, 0.12564458f, 0.04477711f, 
    -0.06039447f, 0.03254450f, -0.05360939f, 0.11370903f, -0.14223015f, -0.09161881f, -0.03957540f, -0.01653354f, 
    0.04289844f, -0.10637737f, 0.01643989f, -0.13423780f, -0.02240434f, -0.04410218f, 0.10517760f, 0.01388412f, 
    0.11357783f, -0.26004288f, -0.05792904f, -0.03851913f, -0.02701211f, 0.24781093f, -0.09425364f, 0.05261136f, 
    0.01255571f, -0.09871311f, 0.06121981f, -0.02537048f, 0.24423137f, 0.22338064f, 0.12000189f, 0.04680068f, 
    -0.05661224f, 0.05381705f, -0.01255863f, 0.13554005f, -0.05058188f, 0.05643929f, 0.04228543f, -0.04020881f, 
    -0.07745476f, -0.09417581f, -0.19851005f, 0.06603830f, 0.03796385f, -0.02249777f, -0.05076002f, -0.07976889f, 
    0.08932012f, 0.05906840f, 0.03628214f, 0.05393310f, 0.25657460f, 0.09195945f, 0.06855380f, -0.11601816f, 
    -0.14062682f, 0.06230492f, -0.01162838f, 0.06106016f, 0.00459684f, 0.00029365f, -0.01102762f, -0.12828472f, 
    -0.51447487f, 0.26005861f, -0.14178924f, 0.17098343f, 0.05305944f, -0.14981551f, -0.04482545f, -0.11711483f, 
    0.06648047f, -0.02856231f, -0.00423906f, -0.00067579f, -0.07180667f, -0.00521120f, -0.07425195f, -0.01279127f, 
    -0.03824316f, 0.09398504f, 0.01809844f, 0.22309878f, -0.00203809f, -0.01829896f, -0.04571211f, -0.10268528f, 
    0.02101294f, 0.06448358f, -0.18642402f, -0.00499380f, -0.14372602f, -0.03566189f, -0.19564296f, 0.01070468f, 
    0.01036053f, 0.00656345f, -0.16524874f, -0.09112802f, -0.12360101f, 0.05626127f, 0.07861698f, -0.05480712f, 
    -0.00646174f, 0.03901856f, -0.09280602f, -0.00580537f, -0.16604532f, 0.00694948f, 0.20321554f, 0.05829347f, 
    0.02545449f, -0.02062432f, 0.04794848f, 0.00489829f, -0.00296477f, 0.04841626f, 0.02207340f, 0.05821920f, 
    0.03192673f, -0.10296084f, 0.06631055f, 0.05041414f, -0.04125533f, 0.06102632f, -0.01608690f, 0.05787484f, 
    0.04830477f, 0.03659610f, -0.01926458f, 0.04118858f, -0.04054110f, -0.06294893f, -0.13829346f, 0.06052032f, 
    0.00943014f, 0.11272115f, 0.02783377f, -0.17156640f, -0.05191714f, -0.00805061f, -0.10107403f, 0.13505827f, 
    0.15294006f, -0.10920846f, -0.07192077f, 0.15728876f, 0.26640186f, 0.11385154f, -0.10819796f, 0.01148420f, 
    -0.00711755f, 0.01993107f, 0.17189957f, 0.07499657f, -0.04617731f, 0.03984374f, 0.05519319f, 0.00094061f, 
    0.05126084f, -0.01767905f, -0.06093385f, -0.02921404f, 0.00123326f, -0.04407910f, 0.07547682f, -0.04173757f, 
    -0.17515586f, -0.10630953f, 0.01457887f, 0.03288429f, -0.01110661f, 0.03038954f, 0.08510141f, 0.06606826f, 
    -0.12268539f, 0.02326025f, -0.14113803f, 0.08523683f, 0.02258979f, -0.00006422f, -0.01388590f, -0.00823652f, 
    0.07833728f, -0.04221845f, 0.15342470f, -0.41294929f, 0.05410314f, 0.08801208f, -0.03075022f, -0.00301177f, 
    0.16019562f, 0.15008011f, 0.05846161f, 0.09465776f, 0.22756085f, -0.01215655f, -0.17648831f, -0.24615769f, 
    -0.05095274f, 0.02526760f, 0.01674160f, 0.10853975f, -0.08848767f, -0.03098169f, -0.10558525f, -0.10978592f, 
    -0.20521568f, -0.01654495f, 0.07674614f, -0.09734400f, 0.10720985f, -0.17330976f, -0.09926727f, -0.00380795f, 
    0.03016197f, -0.04856428f, 0.03944815f, 0.10483861f, -0.06162584f, -0.13790274f, 0.15589504f, -0.09322890f, 
    -0.05896553f, 0.06381618f, 0.00986342f, -0.05602634f, -0.00834013f, 0.02564751f, -0.06017743f, -0.18647729f, 
    0.37060764f, 0.00404614f, -0.06524361f, -0.11073402f, 0.14284950f, 0.02147657f, 0.09553210f, 0.15321095f, 
    0.01938412f, -0.18415149f, -0.01336398f, -0.03377409f, -0.15370961f, -0.10822012f, -0.00552959f, -0.16379385f, 
    0.04052041f, -0.00164178f, -0.02706523f, -0.03654669f, -0.00558808f, 0.15023643f, 0.25240168f, 0.01276275f, 
    -0.14830451f, 0.05703769f, -0.15580453f, 0.01610717f, -0.00182210f, 0.10190827f, 0.06069469f, -0.00027982f, 
    -0.16484059f, -0.08280091f, 0.09610217f, 0.27864227f, 0.33979627f, -0.16483803f, -0.06765485f, -0.15528774f, 
    -0.07312780f, 0.00152372f, 0.01524985f, 0.05400587f, -0.04241445f, -0.09797747f, -0.02218934f, 0.06711258f, 
    0.13839877f, 0.15280467f, -0.10815056f, -0.05148084f, 0.16763134f, 0.14820057f, 0.09286942f, 0.01675655f, 
    -0.11626494f, -0.07370844f, -0.10008515f, 0.03305363f, -0.08282203f, -0.13538291f, -0.04364773f, -0.04027734f, 
    0.00765751f, 0.06735579f, 0.07655575f, 0.05915472f, 0.04821687f, 0.13443194f, 0.13051479f, 0.14684735f, 
    0.15040357f, 0.04747229f, -0.05841577f, 0.02639246f, 0.03560476f, -0.03084724f, 0.02563624f, 0.04182448f, 
    0.04355959f, 0.18239728f, 0.19391918f, 0.16703877f, 0.06340600f, 0.12095930f, -0.01799192f, -0.06505301f, 
    0.04814967f, 0.02368127f, 0.00197578f, -0.00505522f, -0.06098235f, -0.05988149f, 0.16674228f, 0.08003549f, 
    0.03658562f, -0.11961688f, 0.10183832f, 0.00055059f, -0.08078007f, 0.07107282f, 0.02225417f, -0.05368524f, 
    -0.07726127f, 0.06336996f, -0.12823386f, -0.17855729f, 0.16855940f, -0.20084803f, -0.14960127f, 0.00452968f, 
    -0.01073018f, -0.05396756f, -0.04932147f, -0.04569844f, 0.12960258f, 0.05974506f, 0.10416266f, 0.12597753f, 
    0.36255270f, 0.18449759f, -0.18527837f, -0.20770307f, -0.05109899f, 0.02420473f, -0.14196391f, 0.17580310f, 
    0.05475175f, -0.03946032f, -0.12843134f, -0.06247490f, 0.02948957f, 0.16187793f, -0.22623937f, -0.19821182f, 
    -0.11749571f, 0.08394352f, 0.06823561f, -0.00164916f, 0.00760943f, 0.05011725f, -0.14182211f, -0.02511961f, 
    0.12372098f, -0.03695860f, -0.11635756f, -0.07034314f, -0.13103229f, 0.35207960f, -0.02899705f, -0.01133854f, 
    0.08742064f, -0.01446572f, -0.05025754f, 0.03921378f, 0.28210184f, 0.18967751f, -0.07497779f, 0.04995417f, 
    0.00608262f, 0.06812546f, 0.02906925f, 0.04495054f, -0.18571557f, -0.06597941f, -0.14825447f, -0.27208501f, 
    0.12358718f, 0.00666484f, -0.24199148f, -0.03855313f, 0.02425076f, 0.19925548f, -0.03869146f, 0.13571973f, 
    -0.11916540f, -0.10710245f, -0.01208085f, -0.01698653f, 0.30437258f, 0.17421517f, 0.09821948f, -0.03451752f, 
    0.05252820f, 0.07340968f, 0.03382440f, -0.22569969f, -0.17064835f, -0.02148598f, 0.15217806f, 0.07485200f, 
    0.19736329f, 0.02580288f, 0.06626181f, -0.14944369f, -0.05836575f, -0.00854634f, 0.04230780f, 0.10791104f, 
    -0.01173310f, -0.11190516f, -0.03487702f, -0.02606551f, 0.14007629f, 0.25854397f, -0.03378696f, -0.13695253f, 
    0.21457818f, 0.13986997f, 0.04338868f, 0.15870102f, -0.06665296f, -0.07256832f, -0.17753021f, -0.10381638f, 
    -0.06895163f, -0.04046401f, 0.02073233f, -0.12523210f, -0.05386834f, 0.04956716f, -0.05555995f, 0.00277254f, 
    0.00879638f, -0.04874488f, 0.10063384f, 0.09242361f, 0.20819046f, 0.09372849f, -0.11168216f, -0.06267266f, 
    0.07938174f, 0.03403511f, -0.03104164f, 0.16365728f, -0.23252907f, -0.29257420f, -0.11662490f, 0.00185279f, 
    0.28555262f, 0.06492057f, -0.37209705f, -0.19952622f, 0.05076754f, 0.09118224f, 0.09069248f, 0.15424600f, 
    -0.04533683f, -0.06241082f, -0.07960920f, -0.02041369f, -0.10152391f, 0.06829292f, -0.10643627f, -0.26909313f, 
    -0.03379142f, -0.06040837f, 0.01553137f, 0.12810953f, 0.05103574f, 0.06363961f, -0.11379642f, -0.01076813f, 
    0.04387872f, 0.14595266f, -0.00430037f, -0.26735979f, 0.06370796f, -0.08190010f, 0.02077202f, -0.06813335f, 
    -0.07985954f, -0.01286465f, -0.09669606f, -0.03004007f, 0.26055545f, -0.08555350f, 0.06159630f, 0.01088323f, 
    0.07257357f, 0.01186859f, -0.08595462f, -0.28084385f, -0.17094259f, -0.14267193f, 0.05380210f, -0.06117770f, 
    0.09887721f, 0.04811077f, -0.04458813f, 0.04590897f, 0.04143709f, 0.02148248f, 0.00953748f, 0.05731864f, 
    -0.00639758f, 0.09533427f, -0.02837281f, 0.03547493f, -0.27253821f, 0.04855277f, 0.04054578f, -0.03915077f, 
    -0.11352321f, 0.12202556f, 0.19361649f, 0.11287237f, -0.08582991f, -0.10550834f, -0.10524809f, -0.06533353f, 
    0.12989387f, 0.02629117f, -0.00883633f, -0.00890671f, -0.00292493f, 0.04212471f, -0.04804070f, -0.02851638f, 
    -0.03363620f, 0.05065085f, 0.01662854f, -0.04810027f, 0.06024915f, 0.00945404f, -0.00414957f, -0.15623178f, 
    -0.21628055f, -0.07906726f, -0.07381956f, -0.00663412f, -0.00475499f, 0.01837627f, 0.09513032f, -0.03336320f, 
    -0.30166826f, -0.02416814f, -0.07114405f, 0.08597317f, -0.04905480f, -0.02899911f, -0.08841716f, -0.07828854f, 
    0.05140572f, 0.01672698f, 0.18838212f, 0.15865608f, -0.06150081f, -0.02124882f, 0.05905249f, 0.09081628f, 
    0.00740615f, 0.01592011f, 0.00952440f, 0.05813872f, 0.19162494f, 0.21761440f, 0.08297579f, 0.30387107f, 
    -0.05568159f, -0.04917210f, 0.07898699f, -0.04832619f, -0.08217039f, 0.11899804f, 0.14505135f, -0.12433486f, 
    -0.04144004f, -0.07197241f, -0.09188174f, -0.18184976f, 0.15385607f, -0.09639824f, -0.26705238f, -0.15684581f, 
    0.05299102f, -0.11904136f, 0.25458372f, -0.18091504f, 0.03686406f, 0.18579905f, -0.08370260f, -0.01919205f, 
    0.08635432f, 0.12143287f, 0.06129339f, 0.10586024f, 0.02818731f, 0.02170057f, 0.00074954f, -0.03535007f, 
    -0.08576105f, -0.18482868f, 0.02869206f, 0.06605662f, 0.22307009f, 0.07390508f, 0.10311387f, 0.00581563f, 
    0.03831736f, 0.09007075f, -0.09947750f, -0.07024579f, -0.14767298f, 0.05464509f, 0.10038650f, -0.08260451f, 
    0.37474734f, 0.00764090f, -0.16503048f, 0.01396434f, 0.01825505f, -0.05660011f, -0.01830928f, -0.10510317f, 
    -0.10165361f, -0.13000318f, 0.00192294f, 0.08602022f, -0.10928313f, 0.08545600f, 0.10429561f, 0.03261405f, 
    0.02767497f, 0.23101516f, -0.02119979f, -0.03273536f, 0.07985495f, 0.09885837f, 0.15675040f, 0.09420928f, 
    0.16256440f, 0.05158950f, 0.21714416f, -0.13059758f, 0.12863833f, 0.16024679f, 0.07422021f, -0.04455945f, 
    0.01913303f, 0.04169111f, 0.09405877f, -0.18313600f, 0.06593662f, -0.04392767f, 0.00546838f, -0.07976494f, 
    0.05871138f, 0.13802733f, -0.02195546f, 0.07843672f, 0.04040121f, 0.07765369f, -0.19551919f, -0.23190583f, 
    -0.14288072f, 0.17564332f, 0.17027430f, 0.08012221f, -0.03924686f, 0.08140592f, 0.10767928f, -0.04053046f, 
    -0.01738459f, 0.14877929f, -0.13372922f, -0.03717398f, 0.06176962f, 0.00847373f, 0.14019926f, 0.04299352f, 
    -0.07077291f, -0.02605668f, -0.00686848f, 0.01586075f, 0.02127847f, -0.05093060f, -0.05438679f, -0.00128134f, 
    0.19183585f, -0.00708246f, 0.06500737f, 0.08814157f, -0.08910921f, 0.06594569f, 0.08212287f, -0.00351343f, 
    -0.07275938f, -0.09217785f, -0.07701823f, -0.21404982f, 0.26715586f, 0.16644765f, 0.11736026f, -0.15269269f, 
    0.09300401f, 0.04386264f, 0.00885734f, -0.02451206f, -0.12880172f, 0.05163608f, -0.01625638f, -0.07581402f, 
    -0.00228788f, 0.19645569f, 0.03995383f, -0.10116744f, -0.04188933f, 0.10811788f, 0.07322624f, 0.14689435f, 
    0.15249418f, 0.03330554f, 0.00641024f, -0.04495991f, 0.01812573f, 0.08606676f, -0.02192620f, 0.07965843f, 
    -0.02530676f, 0.05383960f, 0.05840760f, 0.02131786f, -0.12133259f, -0.11448424f, -0.07780986f, -0.30815274f, 
    0.18507895f, -0.02376737f, 0.05372862f, -0.01701706f, 0.08819324f, 0.12391033f, -0.03225701f, 0.05144171f, 
    -0.00088165f, -0.24585085f, 0.00369449f, 0.16572165f, -0.08338285f, -0.01489486f, 0.01488113f, 0.07010625f, 
    -0.00275215f, 0.00998067f, 0.04852172f, 0.03186336f, 0.12889215f, 0.05930166f, 0.04364470f, 0.07349148f, 
    0.08933746f, -0.04064133f, -0.09098110f, -0.09516127f, -0.12323487f, 0.00187306f, 0.04308799f, -0.06700127f, 
    0.03126273f, 0.00970849f, 0.05715068f, 0.07056424f, 0.13762741f, -0.25667703f, -0.19956768f, 0.12123605f, 
    -0.06009343f, -0.23242807f, -0.14381044f, 0.12083707f, -0.19248325f, 0.07172379f, -0.07367337f, 0.15670457f, 
    -0.02944348f, -0.05799369f, -0.00822199f, 0.07695539f, 0.05361093f, 0.03507718f, 0.07241298f, 0.02524257f, 
    0.06784392f, 0.02686676f, -0.02621124f, 0.03248968f, 0.23015997f, 0.01763908f, -0.05689232f, 0.09051714f, 
    -0.17781113f, 0.16506936f, -0.01379064f, -0.06237564f, -0.11033909f, -0.14584698f, 0.04769300f, -0.05132749f, 
    -0.17881036f, 0.03962568f, 0.00596292f, 0.15817536f, 0.08101945f, -0.12741001f, 0.06283364f, -0.03104142f, 
    0.03716248f, 0.13011852f, 0.01624591f, 0.10928713f, 0.02978252f, -0.01175987f, -0.01956433f, 0.01650190f, 
    0.00400296f, -0.03079588f, 0.00610064f, 0.17327194f, 0.15929873f, 0.13652048f, 0.13157903f, 0.13143814f, 
    0.10449746f, 0.03576023f, -0.09511953f, -0.02323248f, -0.11957405f, -0.00788199f, 0.08887355f, 0.16819064f, 
    -0.05769743f, 0.02691038f, -0.07630870f, 0.01272042f, 0.05129477f, -0.12139643f, -0.09339827f, 0.22914246f, 
    0.10847281f, -0.01404130f, -0.07434208f, 0.05959036f, 0.01210387f, -0.02666005f, -0.10321851f, 0.08503635f, 
    -0.19827875f, -0.14093126f, -0.18233469f, -0.05883169f, -0.04012628f, -0.13625075f, -0.03070844f, -0.17629018f, 
    -0.00288322f, 0.11459018f, -0.01468745f, 0.15266545f, -0.17669773f, -0.20257393f, -0.08497489f, -0.03261488f, 
    -0.15618782f, -0.02761398f, -0.06941769f, -0.11905261f, 0.05858254f, 0.03082868f, -0.04684183f, 0.01615729f, 
    -0.14157495f, 0.01696353f, 0.25914115f, 0.27354270f, 0.01901626f, 0.09689637f, 0.02282020f, 0.09959716f, 
    -0.02379506f, -0.06245916f, 0.17228828f, 0.05954922f, 0.04506286f, -0.29279169f, -0.03983041f, -0.05350069f, 
    0.02258141f, 0.17618617f, -0.09392732f, 0.11705013f, 0.03190837f, -0.05163814f, 0.01763116f, 0.12363657f, 
    -0.02445348f, 0.06624484f, -0.13467023f, -0.16863690f, 0.02877146f, 0.14131439f, -0.01017910f, 0.01723715f, 
    0.04326024f, 0.05054248f, 0.03144549f, 0.05369878f, -0.11394506f, -0.02438933f, -0.15069236f, -0.02767573f, 
    0.13917454f, 0.01763461f, 0.01872783f, 0.06114245f, 0.14405754f, 0.02472517f, 0.11412880f, 0.01044290f, 
    -0.52146840f, 0.14419590f, 0.14151110f, -0.42766356f, 0.15211041f, 0.12127393f, 0.16616365f, 0.11018198f, 
    -0.05220459f, 0.01910850f, 0.07805540f, -0.03535757f, 0.11509754f, 0.08808261f, -0.02362924f, -0.08647421f, 
    0.15216063f, 0.11613636f, -0.02441374f, -0.03431412f, 0.12767819f, 0.03965140f, 0.14374708f, 0.10912877f, 
    -0.28450444f, 0.14262669f, 0.16497497f, 0.00319320f, 0.05830093f, 0.04615196f, 0.07603285f, -0.03370870f, 
    -0.01258144f, 0.05868024f, -0.03149064f, 0.06342320f, -0.10173527f, 0.12939650f, 0.05594124f, -0.10060039f, 
    -0.05618348f, 0.03530276f, 0.02094010f, -0.10843529f, -0.07249863f, 0.02091468f, 0.05556404f, 0.05978573f, 
    0.37664241f, -0.08481690f, -0.00074905f, -0.15484256f, 0.02293641f, -0.08463880f, 0.10076123f, -0.00387205f, 
    0.00773055f, 0.01026992f, -0.02200451f, -0.02122032f, -0.10519271f, 0.15250461f, 0.10191903f, -0.14121747f, 
    -0.02227381f, -0.03509248f, 0.00259655f, -0.11831072f, -0.17338242f, -0.15518062f, -0.04670547f, -0.24733540f, 
    -0.03056862f, 0.10951932f, 0.02948043f, 0.02555223f, -0.03730327f, -0.06311219f, 0.01232780f, 0.09788128f, 
    -0.12304582f, 0.17453150f, -0.19932120f, -0.18324970f, 0.20792334f, 0.08723625f, 0.20202385f, 0.05798340f, 
    -0.01691650f, 0.05883228f, 0.11494769f, 0.18050484f, -0.04892147f, 0.12248410f, 0.09584191f, 0.07536889f, 
    0.14120662f, 0.18325324f, 0.08405339f, 0.08712315f, 0.07697281f, 0.14104912f, -0.06775808f, -0.14432959f, 
    -0.04321175f, -0.06058300f, -0.12809056f, -0.02069293f, 0.12585925f, -0.04984981f, -0.14902002f, -0.05398686f, 
    -0.08468074f, 0.00049266f, -0.10334637f, 0.07340424f, 0.05902377f, 0.00421965f, -0.08561186f, 0.03389570f, 
    0.16991606f, 0.15690446f, 0.00448428f, 0.05654263f, 0.07351914f, 0.04818427f, -0.03465354f, 0.01743023f, 
    -0.02618765f, -0.08040860f, -0.11723641f, -0.24518399f, 0.48415226f, -0.08433690f, -0.11159416f, 0.07286906f, 
    0.17315732f, 0.08499442f, -0.04915765f, 0.01093302f, 0.05755904f, 0.04139566f, 0.00220469f, 0.00393580f, 
    -0.07640460f, -0.04195050f, 0.22905622f, -0.02906376f, -0.03424556f, -0.02175737f, 0.04001199f, 0.04404711f, 
    0.08079119f, -0.00490711f, -0.08704806f, 0.14566018f, 0.03968987f, 0.04871434f, 0.00797836f, -0.21243289f, 
    -0.07260050f, 0.01162039f, -0.03229266f, -0.02269033f, -0.07536756f, -0.03535448f, -0.05093373f, -0.18116856f, 
    0.24892299f, 0.24537763f, 0.11619142f, 0.03290435f, 0.11386862f, 0.02443360f, 0.07085532f, 0.06220423f, 
    -0.04684405f, -0.00582273f, -0.01855639f, 0.08296636f, 0.02473383f, 0.05702247f, -0.01208156f, 0.11904588f, 
    0.02591250f, 0.00243801f, 0.08102633f, -0.07444884f, 0.09769411f, -0.06764051f, 0.12108193f, 0.08231025f, 
    0.16657397f, 0.08113053f, 0.02288555f, -0.01350683f, 0.13515390f, 0.01748216f, 0.04505613f, 0.14638984f, 
    -0.06786647f, 0.02368010f, -0.07537663f, -0.06451374f, -0.16818532f, 0.09557422f, -0.13469496f, 0.02559667f, 
    -0.19748382f, 0.05744093f, 0.07032488f, -0.06168773f, 0.11442613f, -0.04768345f, 0.10767535f, 0.03735217f, 
    0.21094204f, 0.08933746f, -0.07547733f, 0.17526075f, 0.09985415f, 0.14465775f, -0.17532352f, -0.02677665f, 
    -0.13131718f, -0.04908208f, 0.05577092f, -0.13161556f, 0.19443038f, 0.04081754f, -0.06899451f, -0.08492449f, 
    0.03522460f, 0.13707606f, 0.00624579f, 0.02678977f, 0.07428543f, -0.06494544f, -0.06964620f, -0.01578210f, 
    0.01222852f, 0.12729754f, 0.08169752f, -0.01689793f, -0.08413199f, -0.06410437f, 0.13837637f, -0.02666083f, 
    0.07894724f, 0.18680039f, -0.02160857f, 0.08443083f, 0.10020252f, 0.16006458f, -0.00772945f, -0.06106357f, 
    0.10359086f, 0.14227261f, -0.08884758f, -0.15314502f, -0.03513673f, -0.08714595f, -0.02668333f, 0.05753833f, 
    -0.35448232f, 0.24620177f, -0.00843784f, 0.01089424f, -0.05996713f, -0.06030315f, -0.03847970f, -0.10856104f, 
    0.04391576f, -0.03142581f, 0.07228339f, -0.02573031f, 0.17562246f, 0.09137110f, -0.12891944f, 0.07284092f, 
    0.09876509f, 0.12183834f, 0.08484922f, 0.02377562f, 0.02641253f, -0.02488182f, -0.08649227f, 0.08260104f, 
    0.02077315f, 0.12641418f, -0.14699346f, -0.08987851f, 0.08090936f, 0.00566647f, 0.04472971f, 0.05020026f, 
    -0.09688960f, 0.01284920f, 0.02768757f, 0.07830147f, 0.11120686f, 0.15477158f, 0.18526250f, 0.03345902f, 
    -0.00672339f, 0.23679039f, 0.01422548f, 0.01939195f, -0.08250695f, 0.01333751f, -0.11827374f, -0.11889108f, 
    0.06288252f, -0.02951824f, 0.00795157f, 0.08307412f, 0.08616992f, 0.10208549f, 0.22318381f, -0.09703445f, 
    0.08953062f, 0.08564137f, 0.07230963f, 0.21698564f, 0.07019976f, 0.10129583f, 0.24032690f, -0.04557998f, 
    0.07016025f, 0.06564967f, 0.14954738f, 0.01093558f, 0.14891005f, 0.02954374f, -0.08606507f, -0.05265545f, 
    0.06696219f, -0.04895692f, -0.01316701f, -0.07491752f, -0.11349323f, -0.12804870f, -0.07785402f, -0.05450847f, 
    -0.06127829f, 0.05160232f, 0.03512386f, 0.08668752f, 0.21215899f, 0.18297391f, -0.04111762f, -0.11365268f, 
    0.04091125f, 0.19415852f, 0.04033946f, 0.21122845f, -0.07313766f, -0.01977545f, -0.01114834f, 0.08764665f, 
    0.02570829f, -0.03428725f, -0.05817409f, -0.03653572f, 0.14281125f, 0.00637031f, 0.01001326f, 0.03611835f, 
    -0.03691294f, 0.10745227f, 0.09149407f, 0.04316660f, 0.00462206f, 0.11990533f, -0.10753013f, -0.09447291f, 
    0.11102714f, 0.08079429f, 0.03792984f, 0.11632679f, 0.09040841f, 0.01725775f, 0.01869833f, 0.00533492f, 
    -0.18103933f, -0.14437489f, 0.02240180f, 0.02455830f, 0.03646243f, 0.02173560f, 0.09284484f, -0.01380987f, 
    0.05529165f, 0.02847357f, -0.07964770f, -0.10814421f, -0.04291230f, -0.03534749f, 0.02449420f, -0.00421958f, 
    -0.05449079f, -0.12164570f, -0.06910597f, -0.08421370f, -0.07069387f, -0.19501086f, -0.20961499f, -0.09008507f, 
    0.04535083f, -0.01255652f, 0.05893690f, -0.10968155f, -0.00211370f, 0.01546928f, 0.03753052f, 0.03991894f, 
    0.20172280f, -0.01282652f, -0.03901994f, 0.14384708f, 0.14156981f, 0.08303857f, -0.17750217f, 0.42099780f, 
    0.00232725f, 0.08162152f, 0.05014604f, 0.12375502f, 0.10646996f, -0.01072390f, 0.00472140f, 0.01236727f, 
    -0.12318040f, -0.23264933f, -0.08332140f, -0.18477392f, -0.08429461f, -0.07087900f, 0.03192329f, -0.04207512f, 
    -0.04875457f, 0.10303614f, 0.03926446f, -0.08206244f, -0.11363059f, 0.17959885f, -0.14997821f, -0.14254114f, 
    0.10982840f, 0.16891503f, 0.15392962f, 0.10370232f, -0.07072157f, 0.03732752f, -0.02796010f, -0.08171739f, 
    0.27328619f, 0.07713216f, 0.08403477f, -0.10400228f, 0.01416997f, 0.07127088f, 0.04121800f, -0.00806900f, 
    0.09316542f, 0.07395121f, 0.05487116f, -0.01381700f, -0.11506309f, -0.07607322f, 0.02755072f, 0.01452529f, 
    0.11123520f, 0.00031239f, -0.01287794f, 0.13823950f, 0.08964462f, -0.14285047f, 0.14168836f, -0.09155976f, 
    -0.03824272f, 0.36367512f, -0.14809528f, 0.03221459f, -0.12082671f, 0.00983805f, 0.23430011f, 0.05335731f, 
    0.08563689f, 0.24811232f, -0.05895098f, 0.12028591f, -0.00805444f, -0.15114331f, 0.09972370f, -0.05524320f, 
    -0.05695938f, -0.16243693f, 0.03581927f, -0.05561871f, -0.00873431f, -0.04771134f, 0.03938076f, 0.00204460f, 
    -0.41757652f, 0.01491044f, -0.01810382f, -0.03785640f, 0.04030536f, 0.18579350f, 0.10950822f, 0.10942213f, 
    -0.04700911f, 0.07858683f, 0.06620475f, 0.00154383f, -0.23563449f, 0.03171080f, -0.05103765f, 0.01738244f, 
    -0.12643452f, 0.07434304f, -0.07244448f, 0.00324251f, 0.01147287f, 0.05384757f, 0.10965433f, 0.13550046f, 
    0.03864948f, -0.26633674f, 0.03114604f, -0.03347966f, -0.01207703f, -0.00976796f, -0.14925908f, 0.03997469f, 
    0.12871616f, -0.03363393f, 0.33102372f, 0.09606636f, -0.29359263f, 0.26188818f, 0.05340029f, -0.01475588f, 
    -0.13891213f, 0.03047550f, 0.10534118f, 0.02662929f, -0.06372368f, 0.08291254f, -0.01175041f, 0.07081180f, 
    -0.39726147f, 0.02923708f, -0.05353296f, -0.08755860f, -0.02476393f, 0.13657027f, 0.14142448f, -0.05890455f, 
    -0.03761304f, 0.11795981f, 0.00367339f, 0.10645422f, 0.13041461f, -0.13591199f, 0.01983736f, -0.14558831f, 
    -0.17878987f, -0.16054283f, -0.05833503f, -0.12042741f, -0.08286740f, 0.21172866f, 0.08190382f, 0.22798114f, 
    0.01685030f, 0.15461221f, -0.10213634f, -0.01255494f, 0.14769833f, 0.06645838f, 0.10442813f, -0.15125161f, 
    0.04785005f, -0.03269945f, -0.01854161f, -0.17468587f, -0.21981500f, -0.08173686f, 0.09037104f, -0.00617858f, 
    -0.11435235f, -0.06140205f, -0.13702331f, -0.16932584f, -0.01196052f, -0.10631616f, -0.02200763f, -0.01655021f, 
    -0.32772887f, 0.08221129f, -0.24838077f, -0.23682873f, 0.17419612f, 0.04458794f, -0.01134517f, 0.15032776f, 
    0.01374569f, 0.06718970f, 0.00910372f, 0.02976842f, 0.12055340f, 0.08027992f, -0.34209743f, -0.04182365f, 
    0.07603744f, -0.03824084f, 0.00988442f, 0.13394912f, 0.00420464f, -0.08165725f, -0.14561854f, 0.01084194f, 
    -0.11513039f, -0.04481189f, -0.01366489f, -0.07061388f, -0.17257369f, -0.19708350f, -0.10700820f, -0.19615468f, 
    0.00764244f, 0.10913657f, -0.06450000f, 0.11980119f, 0.24521767f, 0.09168484f, -0.10765661f, -0.28576905f, 
    -0.07682392f, -0.02005898f, -0.00698631f, 0.01226248f, 0.11754680f, -0.14210175f, 0.01317814f, 0.01951289f, 
    -0.05316513f, -0.20417494f, -0.22421093f, 0.33236933f, -0.05262947f, -0.03559870f, 0.05037197f, 0.06306224f, 
    -0.00793012f, -0.01792945f, -0.04609486f, 0.33191913f, 0.07195737f, -0.14583902f, 0.02423572f, -0.08015662f, 
    -0.04822784f, -0.20201719f, -0.12600273f, -0.17430945f, -0.05960028f, -0.11307544f, -0.05382370f, -0.15963244f, 
    -0.00444502f, 0.02298527f, -0.00980288f, -0.00850435f, 0.00338603f, -0.01497166f, 0.00947839f, -0.03390503f, 
    -0.01735749f, -0.00134288f, -0.03529028f, -0.01117952f, -0.03988529f, 0.01127026f, -0.01406725f, -0.04039623f, 
    -0.03329269f, -0.02765397f, -0.01034338f, -0.01247928f, -0.03870228f, 0.01147998f, 0.00339795f, -0.02781499f, 
    0.03028886f, -0.01703832f, 0.00705749f, -0.01792304f, -0.03491729f, -0.01915881f, -0.00082861f, -0.02519213f, 
    0.00273944f, 0.01712525f, 0.00603261f, 0.02564092f, -0.02776835f, -0.02565445f, -0.03509612f, -0.01786669f, 
    -0.00310053f, -0.01462730f, 0.01586990f, -0.00806894f, -0.01378056f, 0.02770603f, -0.01880956f, 0.01288503f, 
    -0.03011472f, -0.00379061f, -0.02593856f, -0.00702774f, -0.02895305f, -0.00619088f, -0.03394920f, -0.02961856f, 
    0.02031966f, -0.02240645f, -0.02948631f, -0.04019537f, 0.00295756f, -0.03302390f, 0.02202810f, 0.01225153f, 
    -0.02252604f, 0.00552023f, 0.00955724f, -0.00347178f, -0.00288105f, -0.00923072f, -0.03280434f, -0.03330931f, 
    -0.02550701f, 0.01192034f, -0.03255009f, -0.00816435f, 0.00686383f, 0.02159284f, 0.00417277f, -0.01203673f, 
    -0.03227883f, -0.03398050f, 0.01832318f, -0.02352448f, -0.02228609f, -0.01265032f, 0.00477840f, 0.03007577f, 
    -0.00125107f, 0.01502137f, 0.01169951f, -0.01029045f, -0.03566102f, -0.04039035f, -0.04062106f, -0.03717010f, 
    0.01963440f, 0.00286881f, 0.01858001f, 0.00726236f, 0.00324986f, 0.02634989f, -0.01443897f, 0.00760660f, 
    0.01791125f, -0.01711946f, 0.00887647f, -0.02260123f, -0.03865187f, -0.03851077f, -0.02699042f, -0.00565239f, 
    0.01327127f, -0.02012435f, 0.01881567f, 0.02431564f, -0.02802389f, -0.03453981f, -0.03415169f, -0.02855085f, 
    0.02576371f, 0.00047552f, -0.02660740f, 0.02642378f, -0.02058996f, 0.02867478f, -0.04085008f, -0.00385361f, 
    0.01074564f, -0.01430297f, -0.03169398f, -0.03698704f, 0.02334904f, -0.01291614f, -0.03227098f, -0.02936333f, 
    0.00468464f, 0.00126300f, -0.01082687f, -0.01420082f, 0.02466319f, -0.02878613f, 0.02003806f, 0.00267248f, 
    -0.02746818f, 0.00178884f, 0.02156915f, -0.01471941f, 0.01852795f, 0.01164018f, 0.02079433f, -0.00077754f, 
    -0.04054835f, 0.01733821f, 0.01406732f, 0.01113782f, -0.00760934f, -0.00562967f, 0.02234466f, -0.03364905f, 
    -0.03889788f, 0.01134052f, 0.00696688f, 0.00819219f, -0.02144755f, 0.01185087f, 0.00279991f, 0.00597479f, 
    -0.02131760f, -0.00356651f, 0.02111662f, 0.00165420f, 0.02130906f, -0.02954179f, -0.00349348f, 0.02579630f, 
    -0.04062594f, 0.02699165f, 0.02833350f, 0.01266433f, -0.01205029f, 0.03578104f, -0.03977862f, 0.01133320f, 
    -0.02533096f, 0.01292862f, -0.00707611f, 0.02281127f, -0.02137485f, 0.03090068f, -0.02363492f, 0.01946741f, 
    -0.02704662f, -0.02832199f, -0.01839141f, -0.00090379f, 0.00983106f, -0.02297226f, 0.00339270f, -0.00709060f, 
    -0.01409907f, -0.00518528f, -0.01458951f, 0.01030953f, 0.01977613f, 0.02180243f, -0.01694981f, 0.02517688f, 
    0.00630215f, 0.02728122f, -0.01318891f, -0.01212967f, 0.00923272f, 0.00731698f, 0.02718342f, 0.02255542f, 
    0.01143243f, -0.03895941f, -0.00652589f, -0.01005341f, -0.03068199f, -0.01272463f, 0.01864926f, 0.00795187f, 
    -0.04004258f, 0.01930434f, -0.01039560f, 0.03024294f, 0.01496196f, 0.00573166f, 0.01721376f, 0.00288505f, 
    -0.03924651f, -0.00389176f, 0.00807526f, -0.03494078f, 0.00315040f, -0.00467202f, 0.01249060f, 0.00763577f, 
    -0.01391986f, -0.03729352f, -0.01370709f, -0.01532677f, 0.01709824f, -0.00804661f, -0.04000800f, 0.01211389f, 
    -0.02837318f, 0.02368507f, -0.03707119f, -0.01650120f, -0.01728004f, 0.01470013f, 0.01135138f, 0.01203942f, 
    0.02267693f, 0.00179059f, -0.03637529f, 0.01212103f, 0.02311685f, -0.03653026f, -0.03833105f, -0.02129427f, 
    0.01231685f, -0.02364342f, -0.03157718f, 0.02539388f, 0.00196827f, 0.00984423f, 0.01711747f, -0.01082859f, 
    -0.01178268f, 0.02680658f, -0.01529374f, -0.03378681f, 0.01585608f, -0.02634429f, 0.02143273f, 0.02452337f, 
    0.00183378f, 0.01446780f, -0.00176571f, 0.02857926f, 0.02870594f, -0.02918725f, -0.04023297f, -0.00588678f, 
    -0.02788197f, 0.00609596f, -0.03499389f, -0.02946873f, -0.01278843f, -0.03595486f, -0.02921150f, 0.01544323f, 
    -0.03156392f, -0.00186891f, -0.01238092f, 0.00145756f, 0.02528618f, 0.00910725f, -0.02544654f, -0.01921914f, 
    -0.01359838f, 0.01233447f, 0.02769470f, 0.00626849f, 0.00615477f, -0.02709791f, 0.02980518f, 0.00814174f, 
    -0.01481694f, 0.02403004f, -0.01829741f, -0.01065427f, -0.00730386f, -0.01788430f, 0.01404516f, 0.02587350f, 
    0.01991771f, 0.00440153f, -0.02388657f, -0.02503685f, -0.03156241f, -0.03996977f, 0.00293876f, -0.00123083f, 
    -0.03670166f, 0.03018890f, 0.02356587f, -0.03750448f, -0.02281320f, 0.01018772f, -0.01886080f, -0.01920822f, 
    -0.03234023f, 0.02642391f, -0.03186869f, 0.01317113f, 0.02341758f, -0.01188930f, -0.00705797f, -0.00550497f, 
    -0.01239590f, -0.03735372f, -0.02500664f, 0.02936098f, 0.02248260f, -0.00219343f, -0.00044368f, -0.03550405f, 
    0.00150827f, -0.03494063f, -0.04002024f, 0.01406880f, -0.02376367f, 0.00452560f, 0.00364666f, -0.00074126f, 
    0.02442421f, 0.00773252f, 0.01281651f, -0.00220756f, 0.00756907f, 0.00318125f, 0.00811023f, -0.01451463f, 
    0.00722525f, -0.01006550f, -0.01084892f, 0.02050317f, -0.00002478f, -0.01214092f, -0.02304333f, -0.01773621f, 
    -0.02217790f, -0.03234547f, -0.03373117f, -0.03355176f, -0.01585153f, -0.02619602f, -0.02984029f, -0.00297576f, 
    -0.01733830f, 0.01358415f, -0.00661442f, -0.02005330f, 0.00696365f, -0.02829615f, 0.00186355f, 0.00847917f, 
    0.00999662f, -0.02688195f, -0.02715001f, 0.02471776f, 0.02488004f, 0.02514014f, -0.03204464f, 0.01091256f, 
    -0.00004941f, -0.02591472f, -0.01726210f, -0.01485996f, -0.03144574f, 0.00853477f, -0.02768057f, 0.01689967f, 
    0.01536713f, -0.00292809f, -0.02369418f, -0.02020363f, -0.02629069f, -0.04113274f, 0.01699763f, 0.00077783f, 
    0.01286384f, 0.01234756f, -0.00663547f, 0.02615839f, -0.00489873f, -0.01868748f, -0.00898507f, 0.00482335f, 
    -0.03841567f, -0.00304105f, -0.00322475f, -0.00392174f, 0.02847436f, 0.00031911f, 0.01743220f, 0.00548499f, 
    -0.01150712f, -0.01473230f, 0.01673983f, -0.02666781f, -0.01053760f, 0.02240543f, 0.01324032f, 0.00020531f, 
    -0.03694948f, -0.03485562f, 0.01300036f, -0.03572035f, -0.03140255f, -0.01152902f, 0.00173050f, -0.00156011f, 
    -0.01577877f, 0.02458416f, -0.00437078f, 0.00108020f, -0.01232074f, 0.02495359f, 0.01148217f, 0.01303036f, 
    -0.00967211f, -0.03116479f, 0.02411647f, -0.00105757f, -0.01761060f, -0.01649382f, -0.03976693f, 0.02073567f, 
    0.00109479f, 0.02332543f, -0.04104428f, -0.00127041f, -0.00989417f, 0.02539769f, -0.01226377f, -0.01139918f, 
    0.02413045f, -0.03010784f, 0.02515318f, -0.02092224f, 0.02296118f, 0.00912764f, -0.03910699f, 0.01426290f, 
    0.01390898f, 0.00853203f, -0.01746332f, 0.01604422f, -0.04061474f, -0.02654818f, 0.02495927f, -0.00644719f, 
    0.00281339f, -0.01720685f, 0.02270127f, 0.00090030f, -0.02596329f, -0.04160914f, -0.02086720f, 0.00797286f, 
    0.00293806f, 0.00678859f, -0.01824180f, 0.01075317f, 0.00967276f, -0.02056498f, 0.02683146f, 0.01607223f, 
    -0.02730560f, 0.02638350f, 0.00273294f, 0.00902259f, 0.02115818f, -0.00468738f, -0.02646978f, 0.01150688f, 
    0.02516158f, -0.02432017f, 0.01929985f, 0.00723717f, -0.03960787f, 0.00255741f, -0.00723711f, -0.01667879f, 
    0.00543723f, 0.01939649f, 0.00568410f, 0.02009243f, -0.03901059f, -0.01729142f, -0.00670224f, -0.03308956f, 
    -0.03699923f, 0.02539225f, -0.00618753f, 0.01697800f, -0.01362271f, 0.00348279f, -0.01956348f, -0.03331966f, 
    -0.03053991f, 0.00044742f, 0.01512995f, 0.01403492f, -0.04019107f, -0.02605123f, -0.02347986f, -0.01532470f, 
    -0.04030783f, -0.02511422f, 0.02501873f, -0.01645647f, -0.01727472f, -0.01711125f, -0.01957561f, 0.00511816f, 
    -0.03055908f, 0.01595819f, -0.02065321f, 0.00570694f, 0.02657164f, -0.02065538f, -0.01947093f, -0.02669312f, 
    -0.01561441f, -0.03359805f, 0.02802615f, -0.03233454f, -0.03742880f, 0.02723921f, -0.02925444f, -0.02527522f, 
    -0.01005699f, 0.02258831f, -0.02115467f, 0.03526498f, 0.00787291f, -0.01076466f, -0.01540851f, -0.01844229f, 
    -0.02478765f, 0.00532071f, 0.00170871f, 0.02235093f, 0.01385277f, -0.02852949f, -0.03349948f, 0.02560212f, 
    -0.01680548f, -0.01603339f, 0.02784771f, -0.01789884f, -0.01553595f, -0.03382039f, -0.01064849f, -0.01095859f, 
    0.00576105f, -0.04082369f, 0.00186266f, -0.03527161f, 0.01101910f, 0.02021243f, -0.03513194f, -0.00113461f, 
    -0.03459453f, -0.00804336f, -0.02687271f, -0.00606702f, -0.02701438f, -0.03674624f, -0.00034821f, 0.00343594f, 
    -0.01645944f, -0.00325450f, 0.01939833f, -0.03325927f, -0.03613990f, -0.02218097f, 0.01697286f, -0.02992705f, 
    -0.00584645f, 0.02366597f, -0.02343510f, -0.02877776f, -0.03989879f, -0.01916202f, 0.00778148f, 0.02447203f, 
    -0.00718579f, -0.02725900f, -0.02052990f, 0.01967077f, -0.01713212f, 0.02987412f, -0.02593255f, -0.01086955f, 
    0.00225936f, -0.00793497f, 0.02838145f, -0.00690368f, -0.00256431f, 0.01728026f, -0.02420363f, -0.01012174f, 
    0.01731821f, -0.02799465f, 0.01303406f, 0.00774377f, 0.01251699f, 0.03031177f, 0.02874042f, 0.02396520f, 
    0.00019806f, -0.01023191f, -0.03801358f, 0.00967744f, -0.04106109f, -0.00577757f, 0.00867884f, -0.02691301f, 
    -0.02995800f, 0.00082996f, 0.03014479f, -0.00436086f, 0.02825468f, 0.02232406f, -0.04012000f, -0.01496529f, 
    0.02287917f, -0.02081993f, 0.00424446f, 0.01126103f, -0.02633258f, 0.02368136f, -0.03615842f, 0.00492496f, 
    -0.00720147f, -0.00306118f, -0.01085251f, -0.02644782f, 0.01824373f, 0.00766281f, -0.00983148f, -0.00861289f, 
    0.00431355f, -0.03202116f, 0.02575088f, 0.02406930f, -0.03921892f, -0.02563234f, -0.02574275f, -0.03289641f, 
    0.02097875f, -0.00545330f, 0.01620193f, 0.01656268f, -0.01913388f, -0.03617121f, 0.02758830f, 0.01353764f, 
    -0.01832136f, 0.02601068f, -0.03359975f, 0.01600019f, 0.01993327f, 0.02102740f, -0.00618071f, 0.02871959f, 
    -0.02099431f, -0.00752798f, -0.03764827f, -0.01658741f, 0.02911840f, 0.00916741f, -0.02337689f, -0.01575586f, 
    0.01229873f, 0.01393870f, -0.03880730f, -0.02604813f, -0.02505043f, -0.03986406f, -0.02630672f, -0.01991124f, 
    0.01748886f, -0.01348388f, 0.02532705f, -0.02666232f, 0.01266909f, 0.00669095f, 0.00285285f, 0.00139633f, 
    -0.03014695f, 0.01907642f, 0.01504307f, 0.01430403f, 0.00684582f, -0.03724318f, 0.02867352f, -0.02044513f, 
    0.02895830f, -0.00730040f, -0.01746462f, 0.00458860f, -0.00797112f, -0.02460716f, 0.00839281f, -0.00976610f, 
    -0.03485221f, 0.02499525f, 0.01643756f, 0.02429730f, 0.01250876f, -0.01990149f, 0.02234230f, 0.01425770f, 
    -0.02298179f, 0.02598133f, 0.00958161f, -0.02595784f, 0.00422114f, -0.00433440f, 0.01466439f, 0.00534282f, 
    -0.03306317f, 0.00420505f, -0.01071437f, -0.01387401f, 0.01623584f, -0.02563945f, -0.00355321f, -0.02838952f, 
    -0.04129458f, -0.02228559f, 0.00860932f, -0.04035379f, -0.03593006f, 0.00273964f, -0.02718558f, -0.03878191f, 
    0.00651810f, -0.01529585f, -0.00379698f, -0.02835494f, 0.01727559f, 0.02788907f, 0.00998996f, 0.02725942f, 
    0.01821963f, -0.00886016f, 0.00550665f, -0.01682820f, -0.00275695f, -0.01574539f, 0.02047736f, -0.03424407f, 
    -0.03020098f, -0.02557111f, -0.03638101f, 0.01869628f, 0.01340419f, -0.00408669f, 0.01165690f, -0.02774435f, 
    0.01462222f, -0.00363616f, -0.01814975f, -0.00480748f, -0.03324501f, 0.02136384f, -0.02654533f, -0.04178366f, 
    -0.04229917f, 0.00521714f, -0.02873216f, 0.02751579f, -0.02490604f, 0.01748949f, 0.01168101f, -0.03013662f, 
    0.00633004f, -0.01663389f, -0.01168007f, 0.00040333f, 0.01829284f, 0.00908806f, 0.00214402f, -0.00428050f, 
    0.00478912f, 0.00140591f, 0.00287326f, 0.01834338f, -0.01261786f, -0.00452997f, 0.01143008f, 0.01433348f, 
    -0.01721459f, 0.01173590f, 0.02899580f, -0.01904446f, -0.03573370f, 0.00345910f, 0.01353679f, -0.00369616f, 
    0.01539531f, -0.00205041f, -0.02796512f, -0.03898749f, 0.00809074f, 0.02005592f, -0.00527498f, 0.01303157f, 
    0.02639948f, 0.00742528f, -0.03032413f, 0.01015701f, 0.02371725f, 0.02448072f, -0.00417803f, -0.03760603f, 
    0.01886365f, 0.00183141f, 0.01867159f, 0.02952480f, -0.04095618f, 0.00877813f, 0.00396198f, -0.02907519f, 
    0.01401719f, -0.00068365f, 0.00519593f, -0.00457913f, 0.00687864f, -0.04025972f, -0.02610086f, -0.00252955f, 
    0.01703655f, 0.02566806f, 0.00792976f, -0.01240042f, 0.02489714f, -0.03569595f, -0.00893753f, -0.02078899f, 
    -0.00772015f, 0.00045805f, 0.00759434f, -0.01461469f, -0.00559928f, -0.03205608f, -0.03416911f, -0.01725880f, 
    -0.01655257f, -0.01834314f, 0.02148289f, -0.03760383f, 0.02123894f, 0.02705446f, -0.00430839f, -0.04012776f, 
    0.02369211f, -0.00222083f, -0.03018534f, -0.03170229f, 0.00042037f, 0.02413779f, -0.00763535f, 0.01673598f, 
    -0.02426541f, -0.02155263f, -0.02862673f, 0.00618788f, -0.02935331f, -0.00552038f, 0.02494294f, -0.01530980f, 
    0.00725877f, -0.01729508f, -0.00282191f, -0.00900939f, -0.00439373f, -0.01344493f, -0.03829878f, -0.02199206f, 
    -0.03779437f, 0.02761738f, -0.01629763f, -0.03672967f, 0.01177107f, -0.00821550f, -0.01754857f, 0.02881750f, 
    0.00488351f, -0.00220643f, 0.02497622f, -0.03527842f, 0.00465645f, -0.03602885f, -0.02519434f, 0.00238646f, 
    -0.02896262f, -0.00845332f, 0.02641351f, 0.00109636f, -0.03553109f, -0.00112700f, -0.00398282f, -0.04306968f, 
    0.02477970f, -0.03302193f, -0.01623260f, -0.04179360f, -0.00311065f, -0.03725722f, 0.01206788f, -0.03636138f, 
    -0.01856745f, -0.01884312f, -0.03502756f, 0.00211073f, -0.02267311f, 0.01298826f, -0.01607407f, -0.00765326f, 
    -0.00526272f, -0.01443788f, -0.03586610f, 0.00353639f, 0.00514930f, -0.00543055f, -0.01480563f, 0.00067169f, 
    0.02116150f, 0.02218001f, -0.00516542f, -0.03362687f, -0.03953666f, -0.02068052f, 0.01206930f, -0.02074535f, 
    -0.03635315f, 0.01318628f, -0.03103142f, 0.02625930f, -0.01891793f, -0.03761327f, -0.00070828f, -0.00392919f, 
    -0.02594925f, 0.00219840f, 0.01636518f, 0.00019293f, -0.01183961f, -0.01537275f, -0.01104335f, 0.00620671f, 
    -0.01411905f, -0.00536961f, -0.03049967f, -0.03656032f, -0.03659823f, 0.02481589f, 0.02107647f, 0.01915496f, 
    -0.01769744f, 0.00316910f, 0.00132687f, -0.02073899f, -0.02091156f, -0.01494937f, -0.03506635f, -0.01922794f, 
    -0.00253034f, 0.01190584f, -0.03453850f, 0.01537011f, 0.00660442f, -0.02739772f, -0.02262797f, -0.02840782f, 
    -0.00995265f, 0.00575247f, -0.02423897f, -0.02146361f, 0.01068332f, 0.02495268f, -0.00985903f, -0.03366501f, 
    -0.01018246f, -0.00316580f, 0.00409747f, 0.02568965f, -0.02173654f, 0.01497263f, -0.00075285f, -0.00524282f, 
    0.01715449f, -0.02392872f, -0.00438322f, 0.00657790f, -0.00081005f, -0.01705633f, -0.01931942f, 0.01210108f, 
    -0.00728865f, -0.02580800f, -0.00338833f, -0.02201930f, -0.00189583f, 0.01843806f, -0.01202210f, -0.03477684f, 
    -0.02662796f, -0.03892154f, -0.02157032f, 0.00615095f, -0.02367651f, 0.02841526f, 0.01594762f, -0.01981912f, 
    -0.00218163f, -0.03248769f, -0.02604944f, 0.00831814f, -0.03403636f, -0.00606375f, -0.02120624f, 0.01384393f, 
    0.01760850f, 0.00983792f, -0.00049295f, -0.01708968f, -0.02253071f, -0.00186243f, 0.00048424f, -0.03141180f, 
    0.02478447f, 0.00772884f, -0.03034991f, -0.01767937f, -0.00307875f, 0.01192795f, -0.03905887f, -0.00603089f, 
    0.02299223f, -0.03030269f, 0.00285407f, -0.00130309f, -0.02696414f, 0.02349765f, 0.02723734f, -0.00524891f, 
    -0.00526887f, 0.02778700f, -0.00470772f, -0.00016206f, -0.00991082f, -0.01103990f, 0.01150443f, 0.01561834f, 
    -0.00847622f, 0.00849748f, 0.02076932f, 0.01087661f, 0.01219076f, 0.02209994f, -0.01491417f, -0.02140251f, 
    0.02215591f, 0.02266694f, -0.02045261f, -0.00085831f, 0.00739992f, 0.02212851f, -0.01544861f, 0.01223544f, 
    0.00654033f, 0.00069208f, -0.00916011f, -0.00990720f, -0.02326606f, -0.00929053f, -0.02520210f, 0.01999594f, 
    -0.01256377f, 0.01324967f, -0.00592844f, -0.01680007f, -0.03207375f, -0.00091348f, -0.03697262f, -0.02206910f, 
    0.01984251f, -0.02428546f, -0.01984131f, -0.03801927f, 0.00357466f, 0.02562149f, -0.01747194f, -0.02857617f, 
    -0.00100873f, -0.03692772f, 0.01457480f, -0.03357077f, -0.00482868f, -0.00945326f, -0.00643229f, -0.02089222f, 
    0.00435857f, 0.00205183f, -0.01045592f, 0.01807529f, 0.00050981f, -0.02953877f, -0.00056829f, 0.01441459f, 
    -0.03447322f, 0.00415119f, -0.00266233f, 0.02522715f, -0.01410983f, 0.00736990f, -0.04103066f, -0.00823554f, 
    0.01047587f, 0.02611437f, 0.00883940f, 0.00248302f, -0.00257574f, -0.00509313f, -0.02671255f, -0.01896109f, 
    -0.02927177f, 0.02986477f, -0.00874482f, 0.00121964f, 0.01295451f, 0.01177508f, -0.03259804f, 0.02901867f, 
    -0.02079240f, 0.02205021f, -0.01796854f, 0.01352736f, -0.03140890f, 0.01217099f, -0.01485141f, -0.00894432f, 
    0.01279447f, -0.03511809f, -0.00532896f, -0.03101430f, 0.03094650f, 0.03099862f, -0.02678969f, -0.00232630f, 
    -0.02867200f, 0.02729029f, -0.02267735f, -0.00414971f, -0.00929339f, 0.00433476f, -0.04016022f, 0.02796623f, 
    -0.02914437f, -0.01219354f, -0.00326324f, -0.02356901f, 0.01893121f, 0.02804653f, -0.02897008f, -0.03696734f, 
    0.02554598f, 0.00841121f, -0.01445821f, -0.00111122f, -0.01895246f, -0.00301656f, -0.01905529f, -0.01395528f, 
    0.00083007f, -0.00675515f, -0.03876809f, 0.00289189f, -0.02331453f, -0.02471946f, -0.03380679f, 0.01463806f, 
    0.00190362f, 0.01232827f, -0.02683694f, 0.02655599f, -0.00731623f, -0.01591638f, 0.01624382f, -0.02870287f, 
    0.00639954f, -0.03033237f, -0.02840562f, 0.01098999f, -0.01756220f, 0.01626046f, 0.02597990f, 0.01863875f, 
    -0.02165638f, -0.02969254f, -0.03681859f, -0.01020885f, 0.01812373f, 0.00268105f, 0.02151469f, -0.02114668f, 
    -0.01535130f, 0.00538976f, 0.02038692f, -0.00511865f, -0.00388066f, -0.01864166f, -0.02341778f, 0.02502633f, 
    0.00629507f, 0.01374508f, 0.00521689f, 0.02580649f, -0.00718938f, 0.00793806f, -0.02176271f, -0.01616297f, 
    -0.01403514f, 0.01530663f, 0.00470499f, -0.00727213f, 0.02814220f, -0.03409405f, 0.01487434f, -0.00535683f, 
    -0.02494009f, -0.01467753f, 0.02316595f, -0.00046701f, 0.01430711f, -0.04270966f, -0.01630995f, -0.02423713f, 
    0.00548583f, -0.03636187f, -0.02948643f, 0.00646090f, -0.04165298f, -0.00656684f, 0.00486430f, -0.01126921f, 
    0.01645511f, -0.01300438f, 0.01066541f, -0.00026748f, -0.00581908f, 0.02690124f, 0.01530339f, 0.00048545f, 
    0.02117852f, -0.01267206f, -0.01194324f, 0.01863457f, -0.02460444f, 0.00179120f, -0.04086566f, 0.01939086f, 
    -0.00748036f, 0.00272034f, 0.02890607f, -0.03836182f, -0.01682865f, 0.01920449f, 0.01780784f, 0.00671650f, 
    0.00942839f, 0.02342930f, -0.01268814f, -0.03385635f, 0.02880199f, -0.00541367f, -0.02615144f, 0.01788121f, 
    -0.02043786f, -0.00693233f, 0.00192306f, 0.00521055f, -0.02433055f, 0.01570167f, 0.02608984f, -0.02318300f, 
    -0.00009058f, -0.00091645f, -0.02774117f, 0.01910660f, 0.00053167f, -0.00903063f, 0.02063108f, 0.02385002f, 
    0.00953410f, 0.00727969f, 0.00782352f, 0.00208137f, -0.00857146f, -0.01841197f, 0.01445691f, 0.01738561f, 
    0.00597104f, 0.01818244f, -0.01726285f, -0.01859116f, -0.00717312f, 0.02855650f, -0.00113494f, 0.02830303f, 
    -0.04198287f, -0.03886741f, -0.00096045f, 0.00320003f, -0.02414669f, 0.01196267f, -0.01015422f, 0.00237498f, 
    -0.01211008f, -0.01107431f, -0.01473436f, -0.00700488f, -0.03677750f, 0.00490493f, 0.00793130f, 0.02747100f, 
    -0.00534019f, -0.00245653f, -0.02527739f, 0.02543689f, -0.00640901f, -0.03461455f, -0.01042213f, -0.01279245f, 
    0.00842001f, 0.02001499f, 0.02501117f, 0.01965917f, -0.01075548f, -0.02355728f, 0.02715780f, -0.01513561f, 
    -0.01756005f, 0.01561818f, -0.00171515f, 0.01753266f, 0.01417362f, -0.03293896f, 0.02120717f, 0.02487146f, 
    -0.02452939f, -0.01652081f, -0.00186978f, -0.02946115f, 0.00808808f, 0.01210987f, -0.03162324f, 0.00163370f, 
    0.00043302f, -0.04082510f, 0.00711361f, -0.04081517f, -0.01635149f, 0.00547159f, 0.00073193f, -0.03696067f, 
    -0.01866906f, -0.03428596f, 0.01373392f, 0.00449555f, -0.01141625f, -0.01227935f, -0.02446895f, -0.01134553f, 
    0.01248622f, -0.03115599f, 0.01632144f, 0.01567592f, -0.02217229f, -0.00646707f, 0.02789809f, -0.04111053f, 
    0.00788876f, -0.01820454f, -0.03170783f, -0.00882532f, -0.03084248f, 0.00323498f, -0.02936324f, -0.00064657f, 
    0.02115168f, 0.01430333f, -0.03242892f, 0.02664444f, -0.03671604f, 0.00764330f, -0.03577229f, 0.00784836f, 
    -0.02572235f, -0.03172331f, -0.00012390f, -0.01795791f, -0.00462007f, -0.03727820f, -0.03001664f, 0.02505401f, 
    -0.04187188f, 0.01356172f, 0.00952842f, 0.02165586f, 0.02969168f, -0.01558716f, 0.01622196f, -0.02009713f, 
    -0.00897079f, 0.00285259f, -0.00974841f, 0.02807339f, -0.02833843f, -0.02809926f, 0.01721377f, -0.01767092f, 
    -0.03186236f, 0.01464609f, 0.01570054f, 0.02001790f, 0.02339182f, -0.01765697f, -0.02872657f, -0.02873687f, 
    0.00146286f, 0.00278496f, 0.01232141f, -0.03909138f, -0.00952500f, -0.03104185f, -0.04166985f, 0.02922243f, 
    -0.04156072f, -0.04054739f, 0.00533423f, 0.00219015f, -0.00737742f, -0.02838085f, -0.00567485f, 0.02771080f, 
    -0.01877201f, 0.00449854f, -0.04013788f, -0.01311030f, -0.03438101f, -0.03373864f, -0.00395807f, -0.03488056f, 
    -0.00429150f, -0.03017491f, 0.01548160f, -0.00224981f, 0.01432296f, 0.02674999f, -0.04163327f, -0.00008730f, 
    0.02742211f, 0.01123683f, 0.00434421f, 0.00743315f, 0.02156383f, 0.02424332f, 0.01205447f, 0.02379095f, 
    -0.03302550f, -0.00662611f, -0.00346706f, 0.01367232f, 0.01019655f, -0.02157656f, -0.02528562f, 0.01624201f, 
    -0.03784761f, 0.01819511f, -0.02048829f, 0.02244223f, 0.00978773f, -0.01122310f, -0.03721178f, -0.01932626f, 
    -0.01401726f, 0.01737355f, -0.00956840f, -0.01788844f, 0.02021736f, -0.02586535f, 0.00923831f, -0.02735638f, 
    0.06030256f, -0.14073129f, 0.15276334f, 0.13308330f, -0.00120198f, -0.00665425f, 0.13535985f, 0.05415056f, 
    0.03185668f, 0.00650288f, 0.04278388f, 0.00693383f, -0.04673546f, -0.09921389f, 0.10531189f, -0.08609118f, 
    0.10879362f, -0.29937258f, 0.00543301f, 0.24068442f, -0.00509804f, -0.03770983f, -0.09595591f, -0.12512821f, 
    -0.14018300f, -0.04272545f, -0.16336963f, 0.04163088f, -0.02320554f, -0.05141049f, 0.00562497f, -0.13065587f, 
    0.19755591f, 0.10663439f, -0.00046675f, 0.05398702f, -0.21864074f, -0.10022292f, 0.05627722f, -0.02327281f, 
    -0.04938206f, 0.01339483f, 0.04515812f, -0.04373724f, -0.01214817f, 0.05648082f, 0.00161419f, -0.06197246f, 
    -0.05551934f, 0.09631663f, 0.22126144f, 0.26507530f, 0.12898290f, 0.04323675f, -0.11304396f, -0.05795091f, 
    0.10000510f, -0.14680246f, 0.20275231f, 0.04141387f, -0.07291909f, 0.19698113f, -0.02565007f, 0.18205900f, 
    -0.17650077f, 0.19383053f, 0.05402438f, 0.20545265f, -0.13853866f, -0.00891948f, -0.02164062f, 0.00452275f, 
    0.15722951f, 0.08948866f, -0.00365842f, -0.13725486f, -0.09131544f, 0.12745374f, -0.09505652f, -0.03576792f, 
    0.05789697f, 0.05268042f, 0.09065061f, 0.10594342f, -0.00627551f, -0.23439543f, -0.09069874f, -0.09111049f, 
    0.10864647f, 0.07618583f, 0.08169340f, 0.08828197f, 0.07142814f, 0.04502860f, 0.13239992f, 0.00664481f, 
    -0.04706938f, 0.05813281f, -0.14214985f, 0.09093704f, 0.14360380f, 0.15583415f, 0.14792944f, 0.12807806f, 
    -0.22725666f, -0.09376207f, 0.01645427f, -0.04069130f, -0.01762208f, 0.16510914f, 0.13478963f, -0.02606761f, 
    0.08348451f, 0.07908120f, 0.03308778f, 0.10982715f, 0.02179903f, 0.16317938f, 0.15825626f, 0.13262644f, 
    -0.18834478f, 0.29845476f, -0.15971878f, 0.24319372f, 0.16565803f, 0.18641356f, 0.11168505f, -0.08726883f, 
    0.08622105f, 0.05811385f, -0.01682859f, -0.00609153f, 0.02440771f, 0.12621956f, 0.09269859f, -0.07028726f, 
    0.04214068f, 0.02019538f, 0.00634462f, -0.03650837f, 0.03154211f, -0.09866546f, 0.10246265f, 0.06517269f, 
    -0.24185604f, -0.16768287f, 0.28136417f, -0.05454488f, -0.04962919f, 0.04355134f, -0.10277784f, 0.12483529f, 
    0.03141638f, 0.02864431f, -0.05576042f, -0.19287579f, 0.12660974f, -0.03193945f, 0.16885409f, -0.02465853f, 
    0.01452258f, 0.13340707f, 0.02716517f, -0.02345690f, -0.07195316f, -0.17898014f, -0.14598982f, -0.06782495f, 
    -0.11035179f, 0.01572456f, 0.06088804f, 0.12453032f, 0.03890153f, -0.07361744f, -0.03006400f, 0.02713396f, 
    0.02386077f, 0.10117112f, -0.15931417f, -0.15167311f, -0.09108094f, 0.28333715f, 0.02417708f, -0.06215531f, 
    -0.02000292f, -0.17659251f, 0.11259524f, -0.03906844f, -0.03043566f, 0.06215366f, 0.01535305f, 0.06212508f, 
    -0.15478720f, 0.02521168f, 0.18608926f, 0.01601865f, -0.03502579f, -0.01106836f, -0.14464697f, -0.02869845f, 
    0.02359422f, -0.05190048f, -0.10046443f, -0.05758746f, 0.08713649f, 0.00573312f, 0.24536507f, 0.13314891f, 
    0.02823694f, 0.02726005f, -0.05675723f, 0.11041411f, -0.00734961f, -0.09322055f, -0.13569340f, -0.06479195f, 
    0.03468608f, 0.02873580f, 0.05050210f, -0.14477508f, -0.02483639f, -0.06460731f, -0.14272973f, 0.06631746f, 
    -0.07998879f, -0.24897103f, -0.26100722f, -0.23378986f, 0.20514859f, -0.38299710f, 0.18626423f, -0.08308119f, 
    0.12099858f, -0.06113296f, -0.08477014f, 0.09580017f, 0.04115326f, 0.01639558f, 0.10053982f, -0.12370500f, 
    0.01947263f, 0.13749912f, -0.05335934f, -0.13900739f, -0.05659011f, -0.09987443f, 0.11270221f, 0.00504922f, 
    0.12745109f, 0.00687840f, 0.01025053f, 0.27315763f, 0.05570893f, -0.03701013f, 0.06941457f, -0.02145468f, 
    0.05447157f, 0.07025369f, -0.13529697f, 0.02741038f, -0.08403390f, -0.06322461f, -0.03569969f, -0.21643846f, 
    -0.24526550f, -0.14535157f, 0.13596605f, 0.23382902f, 0.02020022f, 0.00886305f, 0.13192475f, 0.03442032f, 
    -0.03253077f, -0.13582158f, 0.06727626f, 0.09391682f, -0.01832826f, -0.16566323f, 0.17760091f, 0.40284604f, 
    0.05650670f, -0.08400850f, 0.09359983f, -0.13713212f, 0.07218885f, -0.03925655f, 0.23353980f, 0.07010771f, 
    -0.27464497f, -0.00984822f, -0.10688568f, -0.05495398f, 0.05157920f, -0.29828358f, 0.18099146f, 0.05088352f, 
    -0.16841774f, -0.00049042f, -0.05094491f, 0.06610528f, 0.09248605f, -0.14330401f, 0.14616063f, -0.02892253f, 
    -0.20192209f, -0.04345629f, -0.17608742f, -0.03862073f, 0.12391523f, -0.14095312f, 0.18454777f, 0.10374064f, 
    -0.07711634f, 0.09498117f, 0.26372036f, 0.00946056f, -0.07575229f, -0.13747941f, 0.03222150f, 0.04341205f, 
    -0.16435482f, -0.07280704f, 0.09858708f, -0.10307030f, -0.09963052f, -0.04402808f, -0.08759039f, -0.08894067f, 
    -0.10725812f, -0.13684416f, -0.16777122f, 0.08024430f, 0.03672215f, -0.16040067f, -0.03874285f, -0.06108929f, 
    -0.13371134f, -0.15780677f, 0.16002522f, 0.20614912f, -0.02720807f, 0.17430702f, 0.02524995f, 0.00278548f, 
    -0.02203608f, 0.08839562f, 0.12669563f, 0.09293419f, -0.07175987f, -0.06454349f, 0.06875096f, 0.20159417f, 
    0.03020314f, 0.04332308f, -0.03446298f, -0.08860993f, 0.16252784f, -0.00060833f, 0.05770703f, 0.11566468f, 
    0.02004938f, 0.07540984f, -0.05838629f, 0.09670170f, -0.10993683f, 0.09611910f, -0.06450655f, -0.07820066f, 
    0.07499962f, -0.03964867f, -0.05705681f, 0.04599147f, -0.06910992f, -0.02060247f, 0.11213948f, 0.08630935f, 
    -0.03125662f, 0.07330189f, 0.10218595f, 0.04500371f, 0.11578639f, 0.13621271f, 0.05448750f, 0.05270551f, 
    -0.17588305f, -0.03076916f, 0.25035152f, -0.06986720f, 0.03335531f, 0.08792646f, -0.06495189f, 0.00010237f, 
    -0.08148797f, -0.02140800f, 0.00858578f, 0.02897763f, -0.06803947f, -0.04228202f, 0.05895501f, -0.06470969f, 
    0.01997103f, 0.04085229f, 0.13859627f, 0.03153882f, -0.11605322f, -0.09033531f, -0.06197526f, 0.04886935f, 
    0.00511821f, -0.03092219f, 0.13729917f, 0.33920869f, 0.00739131f, 0.07195766f, 0.04540118f, 0.06776491f, 
    0.05851176f, -0.02659285f, 0.03107031f, 0.30081743f, -0.20183781f, 0.24193363f, 0.09100121f, 0.13794164f, 
    0.05886109f, 0.00815914f, -0.01418486f, 0.07451803f, 0.08950954f, 0.06555776f, -0.13450783f, -0.02675455f, 
    -0.01783938f, 0.11653242f, 0.08965947f, 0.15369412f, -0.02006230f, -0.19651338f, -0.01732585f, -0.18306018f, 
    0.03378746f, -0.12396307f, 0.04262029f, 0.04037760f, -0.01998605f, 0.22571765f, -0.09064969f, 0.28935355f, 
    0.13954087f, -0.00406071f, 0.02660348f, -0.05498385f, 0.04206412f, 0.02321889f, 0.03438795f, 0.17105490f, 
    -0.09707531f, 0.26920202f, 0.10111014f, 0.03434639f, 0.10985452f, -0.02278658f, 0.14101677f, 0.16565023f, 
    -0.11957337f, -0.10056423f, -0.01531093f, -0.02830738f, 0.12973256f, -0.13096957f, -0.01232651f, -0.05977571f, 
    0.04310234f, 0.14072028f, 0.10964684f, 0.06659813f, -0.05058989f, 0.05577246f, 0.03913029f, 0.03764061f, 
    -0.01788432f, 0.28808019f, -0.10592905f, 0.00074387f, 0.09992675f, -0.04870263f, 0.16351554f, -0.01050866f, 
    0.01069643f, -0.12306286f, -0.17023800f, -0.12686424f, -0.06265936f, 0.01379320f, 0.11560379f, 0.11707338f, 
    -0.00599097f, -0.07996961f, -0.06648807f, -0.10830916f, 0.08517625f, -0.08791441f, 0.00307098f, -0.13226980f, 
    -0.06470776f, 0.02513885f, -0.04375742f, -0.23837997f, 0.04374139f, -0.11103429f, -0.03561557f, 0.04366028f, 
    0.15149446f, 0.10117173f, -0.00127530f, 0.11995942f, 0.08769535f, 0.15444013f, 0.13286455f, 0.28462034f, 
    -0.08955128f, 0.16013633f, -0.06461314f, 0.19487704f, -0.06717391f, 0.05007854f, -0.00338489f, 0.12120114f, 
    -0.07579540f, -0.18928722f, -0.14419246f, -0.16367950f, 0.14984195f, -0.02788263f, -0.05164429f, -0.00743630f, 
    -0.04550636f, 0.15045385f, 0.15093593f, 0.00049719f, -0.06297387f, 0.14959647f, -0.28621945f, -0.03666178f, 
    0.03406676f, -0.22094764f, 0.14524329f, 0.19235776f, -0.03750588f, 0.00503192f, 0.01533365f, -0.10629408f, 
    0.20891652f, 0.13918659f, -0.06198464f, 0.03727696f, -0.05781558f, -0.02968796f, -0.15474378f, 0.13286699f, 
    0.02447443f, 0.08590582f, 0.07488216f, -0.01795868f, -0.22337639f, -0.02012632f, -0.06920073f, -0.20138445f, 
    0.09760467f, -0.13717268f, 0.09474471f, 0.12609209f, -0.02097058f, -0.10903937f, -0.02901912f, 0.04715071f, 
    -0.01643668f, 0.13444175f, -0.08863561f, 0.42803133f, -0.16495451f, -0.02632022f, 0.18061218f, 0.03613639f, 
    0.03962018f, 0.01240293f, -0.02312232f, 0.26697934f, -0.08384040f, 0.02573412f, 0.22212188f, -0.02415555f, 
    -0.01981397f, -0.13824208f, -0.01984337f, -0.11172824f, 0.10086072f, -0.05999773f, 0.11773796f, 0.03216283f, 
    -0.25628433f, -0.02773358f, -0.18019328f, 0.07643323f, -0.12577625f, -0.01414935f, 0.00179130f, 0.17548878f, 
    0.00326901f, 0.12343466f, 0.04374382f, 0.12080134f, -0.00907939f, 0.08429689f, 0.00543542f, -0.03336478f, 
    0.02764282f, 0.08530691f, -0.13236764f, 0.05914739f, 0.06455867f, 0.05857263f, 0.17255697f, -0.00491402f, 
    0.10037170f, 0.08745062f, 0.12191963f, -0.16173068f, -0.19632757f, -0.11764015f, -0.08143121f, -0.05095142f, 
    0.15218741f, 0.16000751f, 0.09953887f, 0.07185289f, -0.16869932f, 0.20375517f, -0.01311387f, 0.09431570f, 
    -0.17099705f, -0.06523640f, 0.02495676f, -0.00229473f, 0.13414304f, 0.03284464f, 0.06546312f, 0.09607983f, 
    -0.26147485f, 0.17978008f, -0.09552873f, 0.11868363f, 0.07064851f, 0.06284838f, 0.08839674f, -0.04776446f, 
    -0.16081291f, 0.09166965f, 0.09073972f, 0.10333060f, 0.03924720f, -0.00910549f, -0.01753356f, -0.02584085f, 
    -0.03924097f, -0.14071840f, 0.00879373f, -0.13096392f, -0.12608750f, 0.18307801f, -0.11591000f, 0.19421029f, 
    -0.19072430f, -0.02019951f, 0.08799728f, -0.11210966f, -0.00317920f, 0.02975698f, -0.17583208f, -0.05724303f, 
    -0.14142834f, 0.01978080f, -0.17272510f, -0.20130596f, -0.11135300f, -0.05312749f, 0.05075425f, 0.01698831f, 
    -0.11025409f, 0.04652711f, -0.03871267f, -0.08700539f, 0.02929518f, -0.16285230f, -0.06749059f, -0.07283477f, 
    0.15877496f, 0.11886401f, -0.46873641f, 0.12349053f, 0.15713078f, 0.10274339f, -0.00419212f, 0.23152739f, 
    -0.09314742f, -0.03608566f, -0.08498006f, -0.12131377f, 0.09451298f, 0.16610160f, 0.15910041f, -0.14238165f, 
    0.06600983f, 0.10664708f, 0.05838628f, 0.19736032f, -0.04313603f, -0.15514065f, -0.02184791f, -0.14699793f, 
    -0.09233008f, 0.01548322f, 0.07421323f, 0.01587407f, -0.04913637f, -0.03543381f, -0.06866269f, -0.15548790f, 
    0.09399515f, 0.12793936f, 0.07385398f, 0.05644546f, -0.09793409f, -0.17940265f, 0.07297674f, 0.11498743f, 
    0.03597859f, 0.01520771f, 0.04089807f, -0.12191817f, 0.08208780f, -0.06134542f, -0.00807232f, -0.16010000f, 
    -0.04907532f, 0.04007470f, -0.09326667f, 0.01642122f, -0.05493463f, 0.03422350f, 0.07698458f, 0.06929722f, 
    -0.05587231f, -0.00901074f, -0.08762158f, 0.11729806f, 0.02139154f, -0.11854149f, 0.10579838f, -0.18125382f, 
    -0.06608807f, -0.01809367f, -0.16296369f, 0.04815077f, -0.03074765f, -0.16089356f, -0.03886371f, -0.06460397f, 
    0.11735876f, -0.04557586f, -0.09881721f, 0.05087197f, 0.14561830f, -0.03806392f, -0.00285463f, -0.07232407f, 
    0.05842905f, -0.05185998f, 0.00727549f, 0.09489372f, 0.01708859f, 0.28715584f, -0.00745604f, 0.17458050f, 
    0.05180232f, 0.10111035f, 0.15982369f, -0.01836964f, 0.07658057f, 0.06792627f, 0.09405366f, 0.12043527f, 
    -0.09817276f, -0.20179483f, -0.10407756f, -0.16513468f, -0.06160779f, -0.01991735f, -0.07918148f, 0.01212518f, 
    0.09129443f, -0.14415707f, -0.04806963f, -0.00383730f, -0.08745355f, 0.05186436f, -0.10743085f, 0.00830670f, 
    0.00437380f, -0.19951461f, -0.17131539f, -0.02434540f, 0.06700681f, 0.04624566f, 0.04082580f, -0.00549564f, 
    0.14156461f, 0.00894223f, -0.13912128f, -0.08471079f, -0.04415929f, -0.01729874f, 0.06788837f, -0.02403404f, 
    0.09158115f, 0.12746710f, -0.07434127f, 0.01822998f, -0.09090953f, 0.30993730f, -0.14534108f, -0.14611307f, 
    -0.00305575f, 0.09000106f, 0.09032769f, -0.06800175f, -0.02992987f, -0.06125724f, 0.00881789f, -0.17437686f, 
    0.04425676f, 0.26316619f, 0.15703663f, 0.03218544f, -0.10340710f, -0.04780958f, -0.03569465f, -0.05859792f, 
    -0.02222320f, 0.00969742f, -0.04867005f, -0.01513264f, -0.17230122f, -0.10922802f, -0.00300019f, 0.07103391f, 
    0.17138010f, -0.03835081f, 0.08415014f, 0.11558633f, -0.07521531f, -0.02815394f, -0.10696986f, -0.14918818f, 
    -0.19019900f, -0.07710747f, -0.34939346f, -0.30241671f, 0.16592003f, 0.04218599f, 0.01185076f, -0.14065018f, 
    0.01363134f, 0.04356235f, -0.04561985f, -0.04476273f, 0.09624095f, -0.11079297f, 0.13496745f, -0.15023990f, 
    0.03296088f, -0.02253957f, 0.09140801f, 0.00672724f, -0.03472944f, -0.05667057f, -0.12861975f, -0.11698804f, 
    -0.41872898f, -0.27634025f, -0.25886151f, 0.03825429f, 0.07818538f, 0.04654212f, 0.06295984f, -0.02206863f, 
    -0.01472044f, -0.08541319f, 0.00806417f, -0.09164004f, 0.09581847f, -0.19433711f, -0.00160255f, -0.17648835f, 
    -0.04296771f, 0.08545568f, -0.06144150f, -0.11658742f, 0.06231292f, 0.04396448f, -0.00889236f, 0.00990078f, 
    -0.02029808f, -0.15640008f, 0.11470349f, -0.06442675f, 0.07936833f, 0.02414713f, -0.01608901f, -0.03472413f, 
    0.16371116f, 0.09061144f, -0.02064844f, 0.09681416f, 0.11464679f, -0.23197143f, 0.00447131f, -0.10368071f, 
    -0.05020576f, -0.00128057f, -0.08437443f, -0.12243249f, 0.04141185f, 0.01323023f, 0.15007424f, 0.15583096f, 
    -0.18215661f, 0.03459226f, -0.04906209f, 0.12795001f, 0.02739790f, 0.02014970f, 0.03126232f, -0.04447472f, 
    0.03087562f, 0.08416075f, 0.06365919f, 0.14265123f, 0.14615569f, -0.07720040f, 0.29431176f, 0.14310345f, 
    -0.04450814f, 0.03407300f, -0.07223015f, 0.00263930f, 0.17360693f, -0.20840169f, 0.02554098f, -0.09265717f, 
    -0.04615466f, 0.02333640f, -0.03498533f, 0.10739749f, 0.05874439f, 0.05284529f, 0.06076612f, 0.05761063f, 
    -0.00424209f, -0.00556604f, 0.01137649f, 0.03402050f, 0.12740844f, 0.16200940f, 0.17054734f, -0.19021252f, 
    -0.06831481f, -0.18717687f, -0.00690737f, -0.03562748f, 0.09307749f, 0.06902637f, 0.02576896f, 0.04598115f, 
    0.00574049f, -0.01095700f, 0.16762272f, 0.14244595f, 0.04247309f, 0.02657940f, 0.07233270f, 0.05355643f, 
    0.10871390f, 0.12898101f, 0.07945219f, 0.22152306f, 0.13664825f, 0.50667506f, 0.28375351f, 0.02731559f, 
    -0.01508022f, 0.01288062f, 0.06031859f, -0.00621349f, 0.06158082f, -0.14993453f, -0.00205449f, 0.11816431f, 
    0.04339903f, 0.12807590f, -0.07187530f, -0.11540101f, -0.00386460f, 0.00749675f, -0.10798677f, 0.03727682f, 
    0.02178619f, 0.03309003f, -0.00074971f, -0.04594816f, 0.13029216f, -0.17544702f, 0.20796879f, -0.03516354f, 
    -0.02895343f, -0.13056080f, -0.01850862f, 0.03554298f, 0.22516200f, 0.22191946f, 0.09170973f, 0.19361484f, 
    -0.05696255f, -0.10880747f, 0.11924706f, 0.06486461f, -0.02825413f, -0.03408681f, -0.04932231f, 0.13316107f, 
    0.02959131f, 0.03143521f, -0.03078693f, -0.08620269f, -0.07594825f, 0.24969615f, -0.24874331f, -0.06941971f, 
    0.07292006f, -0.00894433f, 0.03891782f, 0.01014661f, -0.10890337f, -0.05456875f, -0.09035353f, -0.18074566f, 
    -0.10907487f, -0.11643273f, 0.05093273f, 0.18208486f, 0.01498244f, 0.10344533f, -0.00171705f, 0.12153354f, 
    0.05897716f, 0.01529182f, 0.01925119f, 0.05820904f, 0.24284314f, 0.10016048f, 0.18888800f, 0.09324450f, 
    -0.15275395f, -0.02851648f, -0.07657173f, 0.02883183f, 0.05858958f, 0.04682600f, -0.21110658f, -0.06488679f, 
    0.08750001f, 0.02650412f, -0.06700864f, 0.17305700f, 0.02758330f, 0.17653334f, -0.11413273f, -0.02900040f, 
    0.05128112f, -0.00277325f, 0.01741743f, 0.02830150f, 0.04338307f, 0.24734919f, 0.15191641f, 0.37262359f, 
    -0.09670697f, -0.03479668f, 0.02511685f, -0.02150892f, 0.00477973f, 0.06252725f, -0.02484702f, 0.05294661f, 
    0.08486088f, -0.07400225f, 0.07499199f, 0.03506905f, 0.14287828f, 0.04475067f, -0.01659587f, 0.03481186f, 
    0.01840393f, -0.03900227f, -0.02398029f, -0.06994968f, -0.06421896f, 0.15780485f, -0.01928109f, 0.04426290f, 
    0.04977974f, 0.03831926f, -0.00723777f, 0.06976765f, -0.03495133f, 0.00843485f, 0.00488439f, 0.06343133f, 
    0.13685997f, -0.18153849f, -0.00991691f, -0.06445630f, 0.06881025f, -0.01748021f, -0.06074827f, 0.12107500f, 
    0.02944194f, 0.07096948f, -0.04385978f, 0.06891125f, -0.00066708f, 0.00984008f, 0.20707156f, -0.06276223f, 
    0.11054896f, -0.04637690f, -0.07394746f, 0.00715034f, -0.00891075f, -0.06268959f, 0.01653288f, 0.04602210f, 
    -0.00150107f, -0.08966727f, -0.03753438f, 0.05674962f, 0.06315172f, 0.09747791f, -0.01935317f, 0.09083425f, 
    0.13728046f, -0.04417047f, 0.06337166f, 0.06486515f, -0.15612392f, 0.28155106f, -0.06553838f, 0.18451811f, 
    0.00671183f, 0.01463963f, -0.04161363f, 0.14828253f, 0.09460049f, 0.01662373f, 0.00733213f, 0.09181152f, 
    -0.17044787f, 0.03351916f, 0.09215108f, -0.22582431f, 0.13237241f, -0.01737045f, 0.08887272f, -0.01855480f, 
    -0.08129808f, -0.05528578f, -0.14172035f, -0.16525668f, 0.14570782f, -0.20322780f, 0.13268447f, -0.01009140f, 
    0.03425400f, -0.05267035f, 0.08069775f, 0.00350938f, 0.07978858f, 0.05048423f, 0.11004093f, -0.04493964f, 
    0.21386270f, 0.04685822f, 0.08002350f, 0.11956512f, 0.01545051f, -0.11577938f, -0.07121387f, 0.00428427f, 
    0.12918223f, 0.11084671f, 0.08282828f, 0.08468740f, -0.18691790f, -0.04944564f, -0.28445634f, 0.07516568f, 
    0.14431149f, 0.14608333f, 0.05280287f, 0.05549551f, -0.01132375f, -0.04834890f, 0.14867650f, -0.07976324f, 
    0.15523127f, 0.01104403f, -0.12773424f, -0.02852644f, -0.03064751f, 0.04761048f, -0.03507481f, -0.05145447f, 
    0.09823956f, -0.13775533f, 0.01425641f, -0.02850606f, 0.07766657f, -0.15480925f, 0.02906156f, 0.12335757f, 
    0.09722699f, 0.13542713f, -0.02981027f, -0.04310973f, -0.02451108f, -0.04380248f, -0.04989080f, 0.00911729f, 
    0.00208694f, 0.10522027f, -0.25179973f, 0.04644535f, 0.06344479f, -0.04329158f, 0.11489111f, -0.07633597f, 
    0.07123416f, 0.03863787f, 0.11400015f, 0.13232639f, -0.08604305f, -0.10503036f, -0.16847132f, -0.03412624f, 
    -0.00724196f, -0.01040407f, -0.07184591f, -0.02617306f, 0.10065643f, 0.02111267f, -0.03048530f, 0.20951906f, 
    -0.07979331f, 0.05328340f, -0.08528370f, 0.04391388f, -0.05930146f, -0.04388652f, -0.02205090f, 0.06850164f, 
    -0.03454626f, -0.04205286f, -0.05059307f, -0.08389724f, 0.14856260f, 0.04237605f, 0.15179157f, -0.08294254f, 
    0.08207894f, 0.06457157f, 0.01706285f, -0.05275257f, 0.01006650f, 0.05977215f, 0.09306426f, 0.06652033f, 
    0.01572857f, -0.08132219f, -0.02071027f, 0.03181997f, 0.04074254f, -0.07203020f, -0.03616639f, 0.04287431f, 
    0.05704027f, -0.08301736f, 0.06422715f, 0.08694810f, 0.03733847f, 0.27511835f, 0.22116782f, 0.11699545f, 
    0.04674990f, 0.08276556f, 0.09865690f, -0.03478977f, 0.09829400f, -0.08144774f, 0.08817550f, 0.04704584f, 
    0.16395976f, 0.16899036f, 0.40809590f, 0.16656597f, -0.10296601f, -0.15391104f, 0.06487483f, 0.02319221f, 
    0.11130168f, -0.01971583f, -0.09710936f, 0.09569793f, 0.08900402f, 0.12495562f, -0.13709660f, 0.13883059f, 
    0.13403316f, 0.17837813f, 0.06667866f, 0.02822527f, 0.24047416f, 0.19128193f, 0.09671770f, 0.11003718f, 
    0.09403388f, -0.08293135f, 0.55206549f, -0.24034151f, 0.10545943f, -0.17483033f, 0.01179243f, 0.02041297f, 
    0.09713450f, 0.08891924f, 0.06879380f, -0.30925596f, 0.13793397f, -0.13601029f, -0.10073456f, -0.07645591f, 
    0.04025646f, -0.04753909f, 0.00623800f, 0.06434172f, 0.02433434f, -0.03724121f, -0.06343573f, 0.11883023f, 
    -0.01449197f, -0.14702530f, -0.22521500f, 0.17668012f, 0.17676611f, 0.00693979f, -0.03549498f, -0.11416940f, 
    0.00099521f, 0.01950493f, 0.00586701f, 0.12603861f, -0.14532050f, -0.29326904f, -0.04006762f, -0.05558788f, 
    0.10479140f, 0.10249525f, 0.02089768f, -0.02495090f, -0.12113202f, -0.18245648f, -0.17077817f, -0.19783360f, 
    -0.01996411f, -0.05268640f, -0.11809235f, 0.01050434f, 0.08860113f, -0.01277719f, -0.08205506f, -0.00638745f, 
    -0.15004256f, -0.06159442f, -0.05750496f, -0.24528317f, -0.02147238f, 0.06913321f, -0.03066824f, 0.08679621f, 
    -0.05888539f, 0.09487899f, -0.04782627f, -0.05894832f, 0.01623172f, -0.01269846f, -0.01232226f, 0.06912165f, 
    -0.21829776f, 0.05572491f, -0.11551126f, 0.02021399f, -0.13403095f, -0.04978298f, -0.01862728f, -0.03317855f, 
    -0.03705919f, -0.09498206f, 0.04590109f, -0.17453273f, 0.10684513f, -0.20809488f, -0.01037898f, -0.05437205f, 
    -0.00268114f, -0.11870445f, -0.03451116f, 0.03610792f, 0.12985277f, -0.08594348f, 0.16421306f, 0.01620272f, 
    -0.04677980f, -0.24760255f, 0.08080003f, 0.01873690f, 0.01366165f, 0.15286894f, -0.02207367f, 0.14739993f, 
    0.23510519f, 0.14127198f, 0.08020083f, 0.11440407f, -0.47166643f, -0.14013177f, -0.19840004f, 0.06801324f, 
    -0.04445246f, 0.01658312f, -0.01833846f, -0.05436280f, -0.11639401f, -0.02705133f, -0.04451666f, 0.00727133f, 
    -0.22164944f, 0.02283026f, -0.31339082f, -0.32555848f, 0.16077207f, 0.01622351f, 0.03271817f, 0.01554111f, 
    0.05484053f, -0.04411970f, -0.10350643f, 0.00187423f, 0.05769125f, -0.06315029f, -0.07248089f, -0.04862011f, 
    0.07438012f, 0.03437465f, -0.11588790f, -0.07670823f, 0.00888102f, -0.00825960f, 0.02993543f, 0.05325192f, 
    -0.17514785f, -0.22212738f, -0.16567983f, 0.07264701f, 0.06571766f, -0.09889988f, 0.00799693f, -0.05263355f, 
    0.01216594f, -0.11302412f, -0.06375527f, -0.03046632f, 0.20663220f, -0.43343616f, 0.17474912f, 0.12400037f, 
    0.07657844f, -0.08226949f, -0.08959100f, 0.10046341f, -0.06658562f, 0.07743739f, -0.04934318f, 0.09233002f, 
    -0.10137588f, 0.00208840f, -0.26102233f, -0.03859933f, 0.07434850f, -0.07171302f, 0.02830529f, 0.00894075f, 
    0.05072159f, -0.08931854f, -0.09481066f, -0.04551972f, 0.01948646f, -0.20427686f, 0.01682957f, -0.04647953f, 
    0.00681981f, -0.10328369f, -0.04028222f, 0.07539873f, 0.15640654f, -0.00546773f, 0.11126053f, 0.22775280f, 
    0.07752564f, 0.06558956f, 0.17541596f, 0.14631319f, 0.15030129f, 0.05026902f, 0.02553887f, -0.10219320f, 
    -0.05711507f, -0.20796604f, 0.04238636f, -0.02036501f, 0.00525686f, -0.06212640f, 0.15989338f, -0.18415476f, 
    0.12098122f, 0.03622625f, 0.11389951f, 0.05247404f, 0.06967393f, 0.02058135f, 0.19210184f, 0.00093625f, 
    0.00912128f, -0.07180090f, -0.04863012f, -0.04708422f, -0.05409965f, 0.07989344f, -0.05070190f, 0.05426091f, 
    0.15683971f, -0.12655589f, 0.02725644f, 0.03704093f, -0.02846389f, 0.16845296f, 0.00924288f, 0.08992381f, 
    0.02136287f, -0.23742720f, -0.13751620f, -0.06590743f, -0.00349118f, 0.09766249f, 0.00548199f, 0.01563580f, 
    0.09160147f, 0.04599424f, -0.20310402f, -0.13010213f, -0.03028480f, -0.16861631f, -0.10305853f, 0.05162295f, 
    0.07786835f, 0.11176930f, -0.05245424f, -0.00829753f, 0.01155886f, 0.29201651f, -0.24965447f, 0.08046396f, 
    0.02020586f, 0.12932850f, 0.08568911f, -0.03301370f, -0.09362230f, 0.05366946f, -0.09101129f, -0.23189962f, 
    0.05019348f, -0.05501626f, 0.12577990f, 0.10422067f, -0.05105622f, -0.04662500f, -0.05835719f, -0.01894105f, 
    0.02183565f, 0.00660752f, -0.04682063f, -0.07278384f, -0.11550177f, -0.19943213f, -0.00090913f, -0.12689731f, 
    0.01170954f, 0.11232162f, 0.01894042f, 0.10541386f, -0.13943470f, -0.04634760f, -0.16813725f, -0.19106016f, 
    0.48895025f, -0.38185692f, 0.05096445f, 0.17648581f, 0.11716159f, 0.04313361f, -0.15180930f, -0.00740254f, 
    0.01381818f, 0.01213373f, 0.08100322f, 0.05530591f, 0.36408347f, 0.03397297f, 0.05159491f, -0.12952694f, 
    -0.00255904f, 0.01846609f, 0.09117633f, 0.13797772f, -0.11653260f, 0.04629302f, -0.13463637f, -0.12941971f, 
    -0.22204241f, -0.15944731f, -0.08878539f, 0.10366417f, 0.07307097f, 0.01461525f, -0.08727492f, 0.00953846f, 
    -0.08047359f, -0.09631722f, -0.01094789f, -0.13168421f, -0.02921893f, -0.30333385f, 0.05764610f, 0.04596559f, 
    -0.01408396f, -0.12752037f, -0.11899089f, -0.00934821f, 0.19202757f, -0.04203293f, 0.02987882f, -0.03432042f, 
    -0.06901129f, 0.35168326f, 0.03876179f, -0.05847671f, 0.08319837f, 0.10207811f, 0.06858091f, 0.13967225f, 
    -0.00540024f, 0.03953874f, 0.00678217f, 0.03647986f, -0.00445811f, -0.37246642f, 0.08249366f, 0.18814540f, 
    0.00815800f, -0.00878938f, 0.03316870f, -0.00131924f, 0.09922139f, 0.04415508f, 0.05724977f, 0.18951440f, 
    -0.08969690f, -0.03284732f, 0.04360307f, -0.00598748f, 0.07486987f, 0.16486421f, 0.02554047f, -0.03669730f, 
    0.20297915f, -0.04650384f, 0.01628229f, 0.29355988f, -0.18672322f, -0.13872437f, -0.06069347f, -0.14062342f, 
    0.01506707f, 0.04518563f, -0.14482000f, -0.09632904f, 0.25898978f, -0.10667188f, -0.07552979f, -0.05385126f, 
    0.00706041f, 0.07659248f, 0.02356966f, -0.04272338f, 0.12410533f, -0.10622085f, 0.06361074f, 0.12545650f, 
    -0.02385801f, 0.00379826f, 0.18413232f, 0.10047717f, 0.10414334f, 0.20509072f, 0.17468809f, 0.05498445f, 
    0.09363025f, -0.07799638f, -0.04362986f, -0.03868645f, -0.05552307f, -0.01553217f, 0.02242704f, 0.03829692f, 
    -0.00771996f, -0.01978203f, 0.04172511f, -0.13481967f, 0.06063018f, 0.08914498f, 0.15428877f, 0.14886782f, 
    -0.02364626f, -0.01986782f, 0.13515024f, 0.20924781f, -0.34638563f, 0.12691100f, 0.06070072f, -0.07178642f, 
    -0.00243088f, -0.03224273f, 0.06863748f, 0.13618989f, -0.01948722f, -0.04446928f, -0.03310297f, -0.03296493f, 
    -0.05881625f, -0.01472597f, -0.33715066f, 0.03046883f, -0.13528715f, 0.01451264f, -0.12944512f, -0.01771846f, 
    -0.02787271f, 0.00241914f, -0.06487778f, -0.03203751f, 0.02713835f, -0.12782514f, 0.00477973f, 0.06857876f, 
    0.09976710f, -0.06213026f, -0.09025638f, 0.03960947f, 0.05593533f, 0.13092837f, 0.08722618f, 0.14665785f, 
    -0.12921104f, -0.04395211f, 0.02356822f, -0.07310899f, -0.10176545f, 0.00819887f, -0.11204585f, -0.00845833f, 
    0.01668249f, 0.04379575f, 0.02196213f, -0.04657359f, -0.03689225f, 0.08700174f, -0.13471021f, 0.03532923f, 
    0.02779682f, -0.01922665f, -0.10356198f, 0.14268260f, -0.12214447f, 0.02188267f, -0.05361959f, -0.09326924f, 
    -0.30049860f, -0.04800226f, -0.07644212f, -0.13168955f, -0.03641013f, 0.13079852f, 0.07733279f, 0.02239380f, 
    0.11768126f, 0.02138829f, 0.02274630f, 0.10037944f, 0.11178901f, -0.10350199f, 0.02686607f, 0.09659261f, 
    0.09248873f, -0.12775356f, -0.17954685f, -0.04575086f, -0.06362668f, 0.08941346f, 0.02243753f, 0.00690821f, 
    0.20409183f, 0.32551521f, 0.00600111f, -0.07641116f, 0.08628113f, 0.05450645f, -0.03288943f, 0.08351222f, 
    0.06522965f, -0.07737891f, 0.00573012f, 0.11867729f, -0.20197824f, 0.02150080f, 0.14010915f, 0.04507690f, 
    0.15190384f, -0.04858621f, 0.04667969f, 0.01147276f, -0.03192643f, 0.10572252f, 0.07237265f, -0.01108645f, 
    0.12138786f, -0.15043730f, 0.00505268f, -0.00140969f, 0.05648851f, 0.00438581f, -0.09692477f, -0.02510528f, 
    -0.02217967f, -0.12291398f, 0.05358720f, -0.15166856f, 0.21147670f, 0.28346542f, 0.16948906f, 0.02073915f, 
    0.06152416f, -0.14619419f, 0.06955729f, 0.21181120f, -0.08009468f, 0.09452320f, 0.18329310f, 0.01401208f, 
    0.17850894f, -0.36001131f, 0.13616219f, 0.01401042f, -0.05231446f, 0.00151257f, 0.04927741f, 0.10641458f, 
    -0.08304255f, 0.04132666f, 0.03203818f, 0.03287418f, 0.10527971f, 0.27452487f, 0.09716835f, -0.24772476f, 
    0.11159395f, 0.04582110f, 0.04278843f, 0.08844935f, -0.04671322f, -0.01511988f, 0.11608338f, 0.03242263f, 
    0.25297651f, 0.16031595f, 0.34203559f, -0.05230687f, 0.23728928f, 0.13153946f, -0.02091229f, 0.12065943f, 
    0.17178874f, 0.00132085f, -0.00802235f, -0.01386456f, -0.20578633f, -0.10190894f, -0.16544899f, -0.16259985f, 
    0.08129628f, -0.05450909f, 0.05971708f, 0.20640700f, 0.12771350f, -0.03875698f, 0.00427551f, 0.17779431f, 
    0.07292254f, 0.20283356f, 0.01373232f, -0.08039518f, -0.00695016f, 0.08201109f, 0.00179029f, 0.06273697f, 
    -0.02409645f, -0.15237147f, -0.08372494f, -0.17436242f, 0.14402094f, 0.09588879f, -0.06454331f, -0.00692824f, 
    0.08906915f, -0.04881092f, -0.09767643f, 0.03640964f, -0.00648894f, -0.00415768f, 0.12417977f, 0.03337666f, 
    -0.00315891f, 0.06017163f, 0.05098648f, 0.23708217f, 0.12125847f, 0.02820547f, -0.06673530f, -0.04375291f, 
    0.13671210f, 0.08946604f, 0.13782375f, 0.08189476f, -0.17825538f, 0.08407433f, 0.06283600f, 0.42584726f, 
    0.08389612f, -0.11025911f, 0.09093249f, -0.07269789f, -0.00175004f, -0.05035805f, -0.04997178f, -0.00142480f, 
    0.09110006f, 0.24457961f, -0.00988385f, -0.08781779f, -0.05230703f, 0.07518855f, 0.09692090f, -0.09109972f, 
    0.06291042f, -0.12997650f, -0.12678733f, -0.08203483f, 0.19363597f, -0.18776524f, 0.35731655f, -0.11180849f, 
    -0.11335485f, -0.03742644f, 0.11425731f, -0.16571440f, 0.02653179f, 0.04697595f, -0.10638545f, -0.18161124f, 
    -0.14333218f, 0.08051239f, -0.33600852f, 0.11165644f, -0.00354617f, -0.06628524f, -0.00732335f, -0.00971551f, 
    0.15425104f, 0.00633693f, 0.05538398f, 0.09580591f, 0.00825208f, -0.12402267f, 0.01335648f, 0.19700670f, 
    0.09978397f, 0.09176003f, -0.03110337f, -0.01144702f, 0.02408862f, 0.09316694f, 0.03436982f, 0.06492555f, 
    -0.23824091f, -0.22815861f, -0.08698338f, 0.02367377f, -0.04170922f, -0.05461976f, -0.07363041f, 0.05378022f, 
    -0.07314258f, -0.02798222f, -0.04966461f, -0.03378967f, 0.00806340f, -0.01072932f, -0.06269993f, -0.56056994f, 
    0.01000043f, 0.03597571f, -0.03119663f, -0.06979569f, 0.00585112f, -0.06923392f, -0.00230626f, 0.04915740f, 
    0.06954793f, 0.06256085f, -0.12657115f, 0.12274075f, 0.15970650f, -0.01712371f, 0.07341731f, 0.13859941f, 
    0.10878736f, 0.04727771f, -0.02245808f, 0.08424610f, 0.24605547f, -0.10755498f, 0.14587165f, 0.02198073f, 
    -0.00482582f, 0.05456998f, 0.01071791f, -0.04877019f, 0.21398300f, -0.15027367f, 0.04571414f, 0.09161653f, 
    -0.14156984f, -0.01743765f, -0.09647261f, 0.06246566f, 0.03816244f, -0.03701437f, -0.07073831f, 0.09107225f, 
    -0.02710764f, 0.01848086f, -0.07065818f, 0.08756492f, -0.12510796f, 0.03194656f, -0.17323148f, -0.05433736f, 
    0.05162221f, 0.03799808f, 0.07405993f, -0.01550677f, -0.07518163f, 0.22535585f, 0.02601444f, 0.21459974f, 
    0.34026143f, -0.30631396f, 0.43557802f, -0.20187496f, 0.12846999f, 0.03448893f, -0.12140291f, -0.14359200f, 
    0.02809103f, -0.21616615f, 0.11789772f, -0.10838231f, 0.01061059f, 0.03219981f, -0.04341819f, 0.10280830f, 
    0.00827439f, 0.01939344f, -0.14704457f, -0.04199208f, 0.00858726f, 0.00747685f, 0.08078284f, 0.05694421f, 
    0.04471572f, -0.08059800f, 0.12871790f, 0.15413718f, -0.05628919f, -0.10370997f, -0.10352925f, -0.02987876f, 
    0.14964244f, 0.07958433f, -0.05442304f, 0.03471914f, 0.04410944f, -0.32342225f, -0.01135654f, -0.08203655f, 
    0.10605530f, 0.13556008f, 0.11934116f, -0.07884520f, -0.02687901f, -0.15804428f, -0.26551244f, -0.24636367f, 
    -0.07333717f, 0.09377667f, -0.31396520f, -0.00070669f, -0.11392690f, 0.08824638f, 0.00084571f, -0.18330781f, 
    -0.03585686f, -0.05247311f, -0.29908717f, -0.07795402f, 0.25814044f, -0.23424147f, 0.08408360f, 0.02548924f, 
    0.12544055f, -0.02546973f, -0.09045693f, -0.03019396f, 0.03668415f, 0.00366079f, 0.11806019f, -0.11614674f, 
    0.29341877f, 0.07519871f, 0.03688649f, 0.17452557f, 0.01243958f, 0.00214604f, -0.05135356f, 0.04808820f, 
    -0.02829135f, 0.00179126f, 0.01201542f, -0.25527084f, -0.12714651f, -0.10617384f, -0.19244421f, 0.23639636f, 
    0.21535201f, -0.01042092f, -0.01179189f, -0.08252311f, 0.15186535f, -0.10018152f, 0.00624271f, 0.04387181f, 
    0.00311632f, -0.22001536f, 0.27078786f, -0.19969702f, 0.06961142f, 0.06109439f, 0.06430702f, 0.14194226f, 
    0.00248553f, 0.25540486f, 0.05985186f, 0.15228140f, -0.28924769f, -0.08431187f, -0.08894642f, 0.11911520f, 
    0.09959072f, 0.02925942f, 0.06486893f, 0.06914973f, -0.09038496f, -0.03864676f, -0.01878533f, -0.05505588f, 
    0.21095486f, -0.36805910f, -0.09555741f, 0.06783272f, 0.05377604f, 0.20890927f, 0.01110709f, -0.04656860f, 
    -0.02938938f, -0.07077507f, -0.03705727f, -0.04553735f, 0.11415970f, 0.06511037f, 0.17336333f, -0.08920479f, 
    -0.01832338f, 0.20277837f, -0.09014673f, -0.04518158f, 0.02380573f, -0.01510943f, 0.12373447f, -0.03751167f, 
    -0.03166590f, -0.20103505f, -0.17287177f, 0.18699528f, 0.23407558f, 0.03429432f, 0.04446346f, 0.01286000f, 
    -0.03445997f, -0.04771251f, 0.08544853f, -0.03287362f, 0.03088084f, -0.30809397f, 0.34953395f, 0.32867005f, 
    0.02140425f, 0.09113527f, -0.01745223f, 0.11666869f, 0.00950509f, 0.00394917f, -0.06116851f, -0.09781211f, 
    -0.22587395f, 0.23416953f, -0.07348710f, -0.22104925f, 0.07567887f, -0.05198867f, 0.05234371f, -0.17257947f, 
    0.09987642f, 0.05277637f, -0.01427755f, -0.19957784f, -0.17419483f, -0.07784674f, -0.06930412f, 0.10425713f, 
    -0.06844392f, 0.19509581f, 0.05683780f, 0.17751096f, 0.12080751f, 0.03975794f, 0.01374542f, 0.08431005f, 
    0.20053513f, 0.07014882f, -0.01355672f, -0.09234705f, 0.04766039f, -0.05089320f, 0.03681368f, 0.15596794f, 
    0.04462332f, 0.06188852f, 0.09557693f, 0.14881177f, 0.02911156f, -0.08612091f, -0.27793404f, -0.05356167f, 
    0.01361741f, 0.21754308f, 0.00384632f, 0.22327161f, 0.00768293f, 0.02025948f, -0.03268777f, -0.18708958f, 
    0.05547776f, 0.07431886f, 0.12405836f, 0.03098152f, -0.03379961f, -0.04935828f, -0.01714113f, 0.04987378f, 
    0.00920693f, 0.00685814f, -0.00922244f, 0.02371626f, 0.01983116f, 0.00449274f, -0.05400823f, -0.07560482f, 
    -0.05723267f, -0.07988281f, -0.00566050f, -0.00046387f, -0.01145294f, 0.00322624f, 0.11796597f, 0.00906012f, 
    0.24231307f, 0.02310560f, 0.13087302f, 0.23884572f, 0.13897932f, 0.17596744f, 0.14485002f, 0.04525863f, 
    -0.01673620f, 0.19354163f, 0.22302817f, 0.04169429f, -0.11554008f, 0.15327665f, -0.08428384f, -0.23260926f, 
    0.13507892f, -0.04234619f, -0.08704076f, -0.05772684f, 0.03265125f, -0.06320477f, 0.00863619f, 0.11466290f, 
    -0.27009696f, -0.03640443f, -0.07986330f, -0.07415685f, -0.04574535f, 0.03665424f, 0.00361753f, 0.00515356f, 
    0.17021696f, 0.07565986f, -0.02019097f, 0.02462594f, 0.03011242f, 0.10811727f, 0.02147413f, -0.00704477f, 
    0.09083435f, 0.02329927f, -0.00554030f, -0.04243943f, 0.03028025f, 0.03348191f, 0.05846739f, 0.06718937f, 
    -0.08265569f, 0.08571355f, -0.12376022f, 0.11024999f, -0.00567996f, 0.03780365f, 0.16605127f, 0.03473298f, 
    0.04405039f, -0.11396653f, 0.09943967f, -0.09255430f, -0.04547908f, -0.14469352f, 0.15342985f, -0.09267794f, 
    0.08496265f, 0.06146072f, -0.06973721f, -0.07348220f, 0.02549116f, 0.06158638f, 0.11990046f, 0.12003214f, 
    0.20479412f, 0.06070091f, 0.03955691f, 0.08909696f, 0.04585012f, 0.06262684f, 0.03353890f, 0.09599818f, 
    -0.05298855f, 0.10002259f, -0.03379212f, 0.04872235f, 0.42594978f, 0.31403410f, 0.01548745f, 0.17724855f, 
    0.09383316f, 0.06746169f, 0.07423176f, 0.05308060f, 0.27157909f, -0.05228895f, 0.06376745f, 0.17554384f, 
    -0.04628306f, 0.02574569f, 0.03196989f, -0.17776179f, -0.20800501f, -0.10158466f, 0.10842874f, -0.05999961f, 
    -0.04305455f, 0.13258401f, 0.03507435f, -0.06333553f, 0.20667847f, 0.01687498f, 0.03156863f, 0.04047510f, 
    0.00084077f, 0.02824863f, -0.03905923f, 0.04036500f, -0.02700594f, -0.04871538f, 0.01779738f, -0.13177030f, 
    -0.31234208f, 0.26175731f, 0.04240260f, -0.01940163f, 0.08028705f, -0.04305102f, 0.13056417f, -0.00339116f, 
    0.13682495f, 0.05640090f, 0.01353171f, -0.18338373f, -0.38248712f, -0.49021724f, 0.19494934f, 0.01893254f, 
    -0.02190395f, 0.04320839f, -0.01416059f, 0.10214255f, 0.10575354f, 0.26329303f, 0.02538317f, -0.09247777f, 
    0.00103193f, 0.03757383f, 0.05745674f, 0.11873395f, -0.11155771f, -0.05115855f, 0.06519470f, 0.07040846f, 
    -0.01379483f, -0.05364691f, -0.05509428f, -0.03047141f, -0.09032897f, -0.01818648f, -0.00257018f, -0.26168385f, 
    -0.08257801f, -0.03005844f, 0.00241997f, 0.10597309f, 0.16418767f, 0.01607529f, -0.14612526f, -0.05839815f, 
    -0.03097044f, -0.00040662f, 0.12845537f, -0.16202563f, -0.04516526f, 0.07933667f, 0.00949945f, 0.01909573f, 
    -0.06344791f, -0.21425731f, -0.04731769f, -0.10741048f, 0.13520043f, 0.01886605f, -0.07541328f, -0.06601194f, 
    -0.05443425f, 0.06518748f, 0.10708332f, 0.07061068f, 0.08090290f, 0.00992773f, -0.02963307f, -0.07356451f, 
    0.31160519f, 0.28159025f, 0.01450909f, 0.05937318f, 0.04653983f, -0.03053035f, 0.04515693f, 0.07290401f, 
    0.20375468f, -0.04196853f, 0.09340821f, 0.23531187f, -0.06639466f, -0.11833213f, 0.04549005f, -0.22259469f, 
    -0.14200306f, -0.02758209f, 0.08026107f, 0.10665591f, 0.08118232f, -0.13486297f, -0.08922290f, -0.14790739f, 
    -0.40137169f, -0.18859565f, 0.20366819f, 0.01541334f, 0.06194811f, 0.00812221f, 0.01155105f, 0.12337145f, 
    -0.01279682f, 0.02352648f, 0.05347654f, 0.03829421f, 0.07083517f, 0.05544296f, -0.00913095f, 0.11616723f, 
    0.06274251f, -0.01466407f, -0.04058939f, -0.07920031f, -0.05888104f, -0.04655843f, 0.10753001f, 0.17069499f, 
    -0.30814433f, 0.00572327f, -0.04212532f, 0.01640939f, 0.24071735f, -0.02197682f, 0.04319641f, 0.21558695f, 
    -0.05406712f, -0.05686657f, 0.08456591f, -0.10638478f, -0.32353178f, -0.27923778f, 0.18324913f, -0.12557009f, 
    -0.07485730f, -0.01387314f, 0.04376201f, -0.04355926f, 0.28617027f, 0.03708405f, 0.08288438f, 0.11214067f, 
    -0.22953151f, 0.11956000f, 0.01208285f, -0.12884827f, -0.00623234f, -0.01826380f, 0.05274874f, -0.05205173f, 
    -0.04223473f, -0.07196239f, -0.03068178f, -0.03457522f, -0.31600526f, -0.12941983f, -0.13805908f, -0.00652807f, 
    -0.18513982f, -0.02062633f, -0.08654402f, 0.07882644f, 0.18816164f, -0.11708121f, -0.09705445f, -0.04082215f, 
    -0.02340058f, -0.13190226f, -0.08574113f, 0.06416088f, 0.09042078f, 0.04352831f, -0.13719907f, -0.06646959f, 
    0.00955156f, 0.11410329f, 0.10844843f, 0.06494714f, -0.02741059f, 0.03207555f, 0.09132702f, 0.02843398f, 
    0.05449478f, -0.00335196f, -0.05173326f, -0.13750079f, -0.07427192f, -0.00473855f, 0.05421283f, 0.04969043f, 
    0.34241042f, 0.29734603f, 0.22112733f, 0.05199704f, 0.05133894f, -0.02006191f, 0.00440840f, 0.01721373f, 
    0.09418786f, 0.01838943f, -0.00433529f, 0.11693026f, -0.07480460f, 0.03044278f, 0.10301234f, -0.24443053f, 
    -0.12603864f, -0.12661913f, 0.17869695f, -0.05229165f, 0.07990380f, 0.10332694f, -0.01979592f, -0.03143623f, 
    -0.44247258f, -0.19862044f, 0.09952705f, -0.12210489f, 0.01457471f, -0.00726676f, 0.11431946f, -0.18326476f, 
    -0.00877619f, -0.04378490f, -0.01984081f, 0.05878485f, -0.31518057f, 0.18524830f, 0.03909840f, 0.15307954f, 
    -0.04499938f, -0.00244440f, 0.06562373f, -0.01129608f, 0.03647420f, 0.00123153f, -0.06360235f, 0.03136014f, 
    -0.21560387f, -0.16901036f, -0.05709470f, -0.10963869f, -0.01242447f, 0.01486806f, -0.09038843f, -0.04908826f, 
    0.06257626f, 0.06357130f, 0.04343884f, 0.10170497f, -0.13744684f, -0.08832395f, 0.00484203f, -0.15490463f, 
    -0.11802260f, -0.03100006f, 0.06566546f, 0.22583722f, 0.20808701f, 0.15453380f, -0.14663363f, 0.11516654f, 
    0.16251205f, 0.02607573f, 0.08516285f, 0.04896084f, -0.03926173f, -0.01146623f, 0.00577784f, 0.00463496f, 
    0.10696276f, 0.01912184f, 0.21470647f, 0.02374492f, 0.09929405f, -0.23881957f, -0.11429423f, 0.09484551f, 
    0.19052364f, 0.03348050f, -0.09538319f, 0.01910686f, 0.02986744f, 0.09282106f, 0.17602761f, 0.14714748f, 
    -0.26269412f, -0.20807049f, -0.07748612f, -0.04204546f, 0.06504910f, -0.03403185f, -0.09518238f, -0.17808075f, 
    -0.11969790f, -0.04286117f, 0.05508029f, 0.02427454f, 0.20419113f, 0.00183795f, 0.05100980f, 0.10527001f, 
    0.18547590f, 0.14027995f, -0.00430868f, 0.15826949f, -0.00359479f, 0.09042816f, 0.05161345f, 0.11010753f, 
    0.09823216f, -0.06060164f, -0.09055267f, -0.10119268f, 0.01150419f, 0.05320416f, 0.17991458f, 0.20223147f, 
    -0.06890608f, 0.02396439f, -0.11455792f, -0.13642035f, 0.21098043f, 0.07443412f, 0.05070916f, 0.04521650f, 
    -0.02653327f, 0.02333654f, -0.02548576f, -0.01974663f, -0.00590655f, -0.05233689f, -0.00472479f, -0.07601681f, 
    0.25531736f, 0.34682259f, 0.06497916f, 0.21994238f, 0.18306963f, 0.02088117f, -0.00979413f, 0.01397012f, 
    0.27922016f, 0.14645876f, -0.05700593f, 0.08832804f, 0.03399787f, 0.10855695f, 0.26558545f, 0.05008999f, 
    0.03685012f, 0.08991849f, -0.05332230f, 0.43111709f, 0.16265997f, 0.10590678f, 0.11886710f, 0.00132986f, 
    -0.01363715f, -0.07957383f, -0.10475131f, -0.04758949f, 0.03679319f, 0.04738419f, 0.07458425f, 0.10970135f, 
    0.04011676f, -0.00323345f, -0.01628679f, -0.11959057f, -0.38946459f, 0.02439734f, -0.04274215f, -0.14587289f, 
    0.02708741f, 0.09378437f, 0.08673116f, 0.10269958f, 0.04603586f, -0.09244575f, 0.00155703f, -0.08248739f, 
    -0.24991110f, -0.09527401f, 0.01798631f, -0.09821671f, -0.08521364f, 0.03431855f, 0.02127940f, 0.04289293f, 
    0.22387104f, 0.12710118f, 0.06341629f, -0.14592603f, 0.00331057f, -0.10100008f, -0.11595803f, 0.03442325f, 
    0.09763292f, 0.03307005f, 0.07182737f, 0.22065419f, -0.06801846f, -0.01621432f, -0.09866366f, -0.10376816f, 
    -0.02587304f, 0.04966720f, -0.01652842f, -0.18381968f, -0.01835453f, -0.22612086f, 0.06524400f, 0.21250954f, 
    0.12710957f, 0.08146795f, 0.13705572f, 0.07468414f, 0.25534156f, 0.19434099f, 0.04337125f, 0.24340625f, 
    -0.00866740f, -0.02475759f, -0.03824930f, 0.03320926f, 0.07849218f, 0.00182692f, 0.08059501f, 0.17905676f, 
    -0.02412545f, -0.07062313f, 0.04562922f, 0.14460665f, 0.09166460f, 0.09721548f, -0.01729995f, 0.12484019f, 
    0.04430241f, 0.00529383f, 0.07976513f, -0.06713603f, 0.16561700f, 0.05894344f, -0.04489692f, -0.03878541f, 
    0.00702066f, -0.01745169f, -0.07510475f, 0.01129942f, 0.06521954f, 0.03877430f, 0.07951079f, 0.03314011f, 
    -0.10334451f, 0.00337963f, 0.06348208f, -0.20719348f, 0.03197002f, -0.12099671f, -0.07306781f, 0.02077030f, 
    0.11695259f, -0.03087557f, 0.14944606f, 0.09878350f, -0.27049726f, 0.04840586f, -0.04613678f, 0.07785024f, 
    0.04462427f, 0.02757646f, 0.04263010f, 0.00914440f, 0.03216134f, 0.04311164f, 0.15175584f, 0.25183922f, 
    -0.02261490f, 0.00742562f, -0.18181783f, 0.05689058f, 0.10387856f, -0.05850783f, 0.02385426f, -0.13971445f, 
    -0.02726453f, -0.04270767f, 0.00127698f, 0.14587481f, 0.09336817f, -0.02904110f, 0.04912318f, -0.01884208f, 
    0.00676608f, 0.01190165f, -0.05893278f, 0.02018473f, 0.16879354f, -0.05016734f, 0.05692253f, 0.22493163f, 
    -0.14900038f, -0.10496323f, -0.06384535f, -0.05196502f, -0.06192517f, -0.09849153f, 0.13196126f, 0.06835295f, 
    0.08469472f, -0.00874912f, 0.01839317f, -0.23258713f, 0.21807347f, 0.24397725f, 0.13957585f, 0.06312945f, 
    -0.02416066f, -0.04755611f, -0.06055112f, -0.03713243f, -0.08469072f, -0.07146545f, -0.02645311f, -0.04675945f, 
    0.09516546f, 0.30887294f, -0.00000327f, -0.22951983f, 0.12360701f, 0.06060449f, -0.03367848f, -0.15924776f, 
    0.03427591f, -0.00718011f, 0.10069973f, -0.06448893f, -0.20306739f, 0.04720921f, 0.10682515f, -0.28846487f, 
    -0.03688699f, 0.10579752f, 0.12452868f, -0.02479162f, 0.14037617f, -0.03268858f, 0.06115849f, -0.05222193f, 
    0.21583052f, 0.24287075f, 0.10960132f, 0.06796479f, -0.01638629f, -0.04223619f, 0.00125624f, -0.03517944f, 
    0.08061551f, 0.04061920f, 0.04225289f, 0.07074978f, 0.11528645f, -0.03610788f, -0.01265290f, -0.15662365f, 
    0.08928221f, -0.25220403f, 0.18171416f, 0.18664208f, 0.26924795f, 0.11727381f, 0.08829032f, 0.05993945f, 
    0.46676788f, 0.15855247f, 0.13681601f, -0.14027436f, -0.00901428f, -0.02928235f, 0.10469671f, 0.08701735f, 
    -0.04901337f, 0.00306175f, 0.14241049f, 0.10267539f, 0.12185901f, 0.03412907f, -0.07614338f, 0.11530650f, 
    -0.02469794f, -0.02864764f, 0.09077382f, -0.01502184f, -0.04212167f, -0.01622764f, 0.09247891f, -0.01637531f, 
    0.13737513f, 0.14906675f, 0.03714870f, 0.06243918f, 0.05803650f, -0.09111234f, 0.02598798f, 0.08164326f, 
    -0.09452970f, -0.07838435f, -0.02724581f, 0.07026403f, 0.11984850f, -0.11511432f, -0.03332426f, -0.23817137f, 
    -0.07638178f, 0.14805256f, -0.08250973f, -0.01350167f, -0.06678596f, -0.09331773f, -0.00846911f, 0.07288865f, 
    0.09034773f, -0.05001382f, -0.03437965f, 0.06108024f, -0.04101482f, -0.01789685f, -0.01184591f, -0.01658034f, 
    0.00854840f, -0.05853009f, -0.02798584f, 0.02899807f, -0.06074087f, -0.02296138f, -0.01368674f, 0.02829390f, 
    -0.01606856f, 0.00224975f, -0.07654668f, 0.01525089f, 0.14512718f, 0.10995938f, 0.00489628f, -0.12159745f, 
    0.12499791f, 0.16778307f, 0.11856853f, -0.02690988f, -0.01336969f, 0.00022580f, 0.24788694f, 0.02993999f, 
    0.19736427f, 0.13162866f, -0.05006960f, 0.23209809f, 0.63383418f, 0.05569108f, 0.00843175f, -0.07826874f, 
    -0.01387629f, 0.05870442f, 0.03171598f, -0.01949467f, -0.12796108f, -0.09174844f, -0.02128486f, -0.10277755f, 
    -0.18493803f, 0.08524661f, 0.09096747f, -0.00654144f, -0.03363234f, -0.06122142f, 0.00264126f, -0.08034737f, 
    -0.04347296f, 0.11810871f, -0.03890904f, 0.01835603f, 0.02451269f, 0.03159371f, -0.05109868f, 0.06615295f, 
    0.02724104f, -0.10238271f, 0.01658466f, -0.12053252f, -0.06569199f, -0.06094681f, -0.00600429f, 0.03969801f, 
    -0.00471815f, -0.09693092f, 0.00239080f, -0.22405550f, 0.01620100f, 0.41363460f, 0.03735200f, -0.16997996f, 
    -0.07288577f, 0.18675512f, 0.03150359f, -0.07923332f, 0.04268649f, -0.20859805f, -0.05211849f, -0.02977519f, 
    0.09170479f, 0.06233056f, -0.02816959f, 0.05174778f, -0.06691170f, -0.05533612f, -0.06130400f, -0.01813071f, 
    -0.07958190f, 0.03144770f, 0.09446946f, 0.03366467f, -0.04773690f, -0.01467715f, -0.00410234f, -0.04384990f, 
    0.00324138f, 0.04079756f, -0.14757539f, 0.08611817f, 0.16339067f, 0.13105087f, 0.19628340f, -0.09809229f, 
    -0.10133816f, 0.01331697f, 0.04336137f, -0.08161250f, 0.01513522f, 0.06403051f, -0.10685398f, 0.01531981f, 
    -0.23922296f, -0.35667658f, -0.23367517f, -0.27109507f, -0.00145098f, -0.02090492f, 0.05364569f, 0.15327556f, 
    0.10565663f, 0.04540189f, 0.17988998f, -0.08795429f, 0.04546614f, 0.09678104f, 0.12673685f, -0.02022322f, 
    -0.03405925f, 0.11523145f, -0.06283420f, 0.02980202f, 0.01358243f, 0.02322086f, 0.27592701f, -0.01660280f, 
    -0.29456469f, 0.00176315f, -0.04621012f, -0.05398044f, -0.08860994f, 0.04792687f, -0.04862902f, -0.09294169f, 
    0.05612747f, -0.05608521f, 0.13089213f, -0.13515387f, 0.07030267f, -0.33236778f, -0.04656281f, -0.21173555f, 
    -0.06673336f, -0.04962197f, -0.03109652f, 0.07861557f, -0.01127932f, 0.05574089f, -0.05090843f, 0.05545823f, 
    -0.27792835f, -0.46499622f, -0.39770386f, 0.23657128f, 0.03612088f, 0.03977548f, 0.05997997f, -0.01580183f, 
    -0.09503318f, -0.02634514f, -0.10066454f, 0.05256220f, 0.07481817f, -0.33314517f, -0.07170015f, -0.07186347f, 
    0.09882949f, 0.05952639f, 0.01777213f, 0.07671484f, 0.19159356f, 0.17111318f, 0.09127522f, 0.03387191f, 
    -0.19823390f, -0.40003651f, -0.07325707f, 0.20424874f, 0.07875014f, 0.06520571f, 0.04943886f, 0.10764603f, 
    -0.00495641f, -0.00434161f, -0.06112894f, -0.04590148f, 0.48281455f, -0.07346845f, -0.28462809f, -0.13060577f, 
    0.27426931f, -0.17281370f, -0.00181289f, -0.07394607f, 0.07475492f, 0.04300736f, -0.01465494f, 0.02495050f, 
    0.30405438f, 0.05565761f, 0.01423005f, 0.07449687f, -0.08974034f, -0.01951063f, 0.04410839f, 0.00133103f, 
    0.09130877f, -0.04180405f, -0.02018342f, -0.06169355f, 0.12062898f, 0.06766445f, 0.07002597f, -0.11636981f, 
    -0.05333579f, -0.02930319f, 0.06493108f, 0.01880826f, -0.00898517f, -0.23505466f, -0.25322762f, -0.19196258f, 
    -0.38262448f, -0.60770392f, -0.17930549f, -0.39220238f, 0.08786280f, -0.12957738f, -0.11386424f, 0.13047758f, 
    -0.10788329f, -0.10918435f, -0.09870522f, 0.06296325f, 0.27915615f, 0.11780281f, -0.21117125f, -0.26151538f, 
    -0.03327071f, -0.05550344f, 0.11622074f, -0.19829831f, -0.01219586f, 0.01976476f, -0.14298269f, -0.03407182f, 
    -0.02819865f, -0.29019701f, -0.01309661f, -0.12876934f, 0.00619083f, 0.02443445f, -0.13357970f, -0.10866476f, 
    -0.11221261f, -0.09563200f, -0.04063460f, 0.04098256f, 0.07841197f, 0.04568347f, 0.28641489f, -0.05141339f, 
    -0.05119447f, -0.04234134f, 0.03809495f, -0.01336307f, -0.02593124f, -0.07778575f, 0.03356177f, -0.06797686f, 
    -0.33856705f, -0.19316854f, -0.18047903f, -0.20434423f, 0.25347430f, 0.12872653f, 0.01631314f, 0.10718702f, 
    -0.02338284f, -0.07615061f, 0.01131227f, 0.04227058f, -0.05346607f, -0.20533955f, -0.08213805f, 0.08979599f, 
    -0.13667911f, -0.06784257f, 0.04653651f, 0.10634612f, -0.06349218f, -0.13195461f, -0.07308509f, 0.02539371f, 
    -0.08302069f, -0.13183972f, 0.03950652f, 0.11157851f, 0.06740008f, 0.27513698f, -0.05910378f, -0.07925983f, 
    -0.09698050f, -0.00575049f, -0.03693894f, 0.05231505f, -0.34437260f, -0.48192587f, -0.24115311f, 0.06159309f, 
    0.23061553f, 0.13140965f, 0.01178293f, -0.03601144f, -0.10003861f, -0.02615498f, -0.02993757f, 0.09490810f, 
    0.16712818f, 0.26942679f, 0.11477988f, -0.04385197f, 0.00000325f, 0.02572282f, -0.02272702f, -0.04832780f, 
    0.12379040f, 0.03007171f, -0.09107948f, 0.05693952f, -0.41701400f, -0.29420564f, -0.18392268f, 0.04309948f, 
    0.23556170f, -0.06538211f, 0.18355542f, 0.26671317f, -0.13842070f, -0.03911233f, -0.01194449f, 0.13400507f, 
    0.01250247f, 0.01452019f, -0.08260603f, 0.19274476f, 0.14626236f, 0.12130943f, 0.10844454f, -0.06968243f, 
    -0.05640186f, -0.00957184f, 0.00445864f, 0.01280747f, -0.50156087f, -0.08850424f, -0.05479656f, 0.11774023f, 
    -0.06555711f, -0.11298712f, 0.01459201f, 0.02350615f, 0.01436446f, 0.13278644f, -0.03572693f, -0.08720651f, 
    -0.32354566f, -0.30638245f, -0.09576847f, 0.04730098f, 0.10441110f, 0.04765516f, 0.13906805f, -0.11308006f, 
    -0.17053477f, -0.05050685f, -0.03679535f, 0.04408180f, -0.20369324f, -0.51881915f, -0.66221297f, -0.23214576f, 
    0.01869304f, 0.14010136f, 0.13332318f, 0.08207174f, -0.03735717f, 0.09768885f, 0.03083798f, 0.02558248f, 
    0.25012642f, 0.14727978f, 0.17709805f, 0.05905205f, -0.07383852f, 0.03778320f, -0.03096496f, 0.04021142f, 
    0.05416723f, 0.02281353f, 0.02538977f, -0.06559256f, -0.49687183f, -0.03931934f, 0.05348497f, -0.21949932f, 
    -0.14037217f, 0.11447778f, 0.03553969f, -0.10122178f, -0.05261659f, 0.27349693f, 0.07730822f, -0.06966612f, 
    0.08453818f, -0.16292268f, -0.14612316f, 0.05242714f, 0.27483556f, 0.14096783f, 0.11772950f, 0.03355346f, 
    0.10563491f, -0.10484766f, -0.01000052f, -0.10027759f, -0.08376648f, 0.03038429f, 0.05878252f, -0.03383993f, 
    -0.14765497f, 0.04991399f, -0.00579992f, 0.19479318f, -0.03395391f, -0.04295289f, -0.02701902f, 0.13039835f, 
    0.04115904f, -0.07494966f, -0.12924077f, 0.06086434f, -0.11694662f, -0.01680820f, 0.20448621f, 0.10339942f, 
    -0.00606069f, -0.07875383f, 0.06576809f, -0.01157479f, 0.06301038f, 0.02146473f, 0.12972115f, 0.11091162f, 
    -0.08189181f, -0.02548301f, -0.01197844f, -0.01826552f, 0.28273439f, 0.27636692f, 0.01735531f, 0.31160960f, 
    0.20600069f, 0.13642463f, -0.01144621f, 0.11050244f, 0.04676249f, -0.01909237f, 0.02936792f, 0.05914933f, 
    0.14531387f, 0.11481690f, 0.00665529f, -0.31957367f, 0.34705502f, 0.27333260f, -0.27480319f, 0.28403226f, 
    0.06537144f, -0.06102071f, -0.03557839f, 0.12183650f, 0.23384526f, 0.31420678f, -0.09553404f, 0.02253710f, 
    0.00249448f, -0.01518375f, 0.01150550f, 0.03072874f, 0.03610542f, -0.05666719f, 0.03002655f, -0.01391182f, 
    -0.12959255f, -0.19707598f, -0.17819367f, -0.08599111f, -0.25669086f, 0.13879883f, -0.06846616f, -0.56364733f, 
    -0.10201204f, 0.14171317f, -0.06410687f, -0.03643397f, -0.01338792f, -0.12049834f, 0.18826862f, -0.19263197f, 
    0.24016462f, -0.10650285f, -0.10170323f, -0.51578999f, -0.06986734f, -0.04875245f, -0.06174811f, -0.00494042f, 
    -0.06915324f, 0.12090470f, 0.00890368f, -0.02069340f, -0.00015383f, -0.20396341f, -0.03757880f, 0.07759394f, 
    0.08417340f, 0.14225908f, -0.08063744f, 0.09622344f, 0.15986738f, 0.11498525f, -0.13450031f, -0.02515083f, 
    -0.05155126f, -0.08364666f, 0.10517100f, -0.11491644f, -0.02179587f, 0.08883754f, 0.01875781f, -0.02418859f, 
    -0.06500743f, 0.29699218f, 0.07706419f, -0.01697062f, 0.13895866f, 0.07312019f, 0.11397906f, 0.10030781f, 
    -0.01911160f, -0.01835067f, -0.04304448f, 0.01593225f, 0.07754046f, 0.01862014f, -0.05844544f, 0.11468798f, 
    -0.00189764f, -0.01179100f, 0.16035090f, 0.06119003f, -0.22163455f, 0.18914439f, 0.14119843f, 0.12076721f, 
    -0.10202406f, 0.06769484f, -0.05834775f, 0.10445139f, 0.14887451f, 0.13265897f, -0.00327100f, 0.05870486f, 
    -0.02693652f, 0.00472221f, -0.02305285f, -0.04409632f, -0.05234972f, -0.10695966f, -0.06119590f, -0.02508396f, 
    0.25186530f, 0.06798702f, 0.05429763f, 0.08589471f, -0.00050611f, -0.09909017f, 0.04184161f, -0.07740929f, 
    0.10715545f, -0.15136760f, -0.05736175f, -0.25765836f, -0.26020256f, 0.48362118f, 0.21211682f, -0.21749572f, 
    -0.20116846f, 0.07151332f, 0.06433727f, 0.02638172f, -0.19414288f, 0.06614999f, 0.06553042f, 0.13722137f, 
    -0.03947482f, 0.17641564f, 0.07147588f, -0.08285289f, 0.00804202f, 0.08021446f, 0.13872521f, 0.10735733f, 
    -0.14925188f, -0.14707401f, -0.15619901f, 0.04243037f, 0.11789570f, -0.03120353f, 0.08161344f, 0.00111070f, 
    -0.03377744f, -0.00892985f, -0.06102892f, 0.03306772f, -0.08798032f, -0.02269533f, 0.00847619f, 0.00160990f, 
    -0.17100099f, 0.04671427f, -0.10614296f, -0.18127935f, -0.28244960f, 0.10632633f, -0.28816956f, 0.00560265f, 
    0.25174692f, -0.01695029f, -0.21783300f, -0.08564217f, 0.03331409f, 0.08634105f, 0.16227467f, 0.09458961f, 
    -0.08546054f, -0.05151900f, -0.02922097f, -0.05607030f, -0.00369272f, 0.01583055f, 0.00669731f, 0.04522299f, 
    0.52030373f, 0.11007109f, -0.10260175f, -0.21795569f, 0.06871516f, 0.04704271f, 0.00314765f, -0.11803798f, 
    -0.02653605f, -0.00328705f, -0.11082239f, 0.00627610f, 0.36543578f, -0.04922742f, 0.04131540f, 0.09896894f, 
    0.00894973f, -0.04622867f, 0.04825449f, 0.25572434f, 0.05690793f, 0.05302499f, -0.14432137f, 0.15513945f, 
    0.05626256f, 0.02989784f, 0.12635313f, 0.14050767f, -0.00831390f, -0.10703359f, -0.04804795f, -0.02204822f, 
    0.01404466f, -0.02712710f, -0.04183801f, 0.09969442f, 0.02210333f, 0.11346178f, 0.04557623f, -0.05898802f, 
    -0.06845230f, 0.13966697f, 0.07900994f, 0.13038047f, 0.00663675f, -0.10840845f, 0.03409188f, 0.01333722f, 
    0.36927927f, 0.22273797f, -0.10281970f, 0.06119439f, 0.07357461f, -0.12668367f, 0.01486105f, 0.01462920f, 
    0.00404501f, -0.02704277f, 0.07207687f, -0.04414073f, 0.22229581f, -0.02320030f, 0.06316524f, 0.17865781f, 
    -0.00038365f, -0.01840959f, 0.00873167f, 0.06085605f, 0.25773239f, -0.07907875f, 0.16813852f, 0.15203807f, 
    -0.02688158f, 0.01051207f, 0.34993935f, -0.06104793f, 0.09748106f, 0.12387428f, 0.07942233f, -0.12169489f, 
    -0.08800572f, -0.07406036f, 0.15242951f, 0.17486431f, 0.20081322f, 0.03414918f, -0.14163274f, -0.14191639f, 
    0.08996962f, -0.01451971f, 0.09796575f, 0.12150287f, 0.07781726f, 0.03116480f, -0.08242850f, 0.06642042f, 
    0.08036512f, -0.05224295f, -0.01754283f, -0.04021118f, -0.03344655f, -0.04228700f, 0.01069989f, -0.06080495f, 
    -0.17519611f, -0.03210017f, -0.04929669f, -0.09775927f, 0.28054139f, -0.06296083f, -0.14268054f, -0.20884724f, 
    -0.10134128f, -0.04938265f, -0.06996219f, -0.05744978f, -0.14031169f, 0.03346879f, 0.09132545f, -0.02793922f, 
    0.15976073f, 0.04184957f, 0.03107416f, -0.07913204f, -0.12470044f, -0.09552705f, 0.16450277f, 0.12179507f, 
    -0.03929035f, 0.22301814f, 0.00272023f, 0.07681489f, 0.14959966f, -0.32925785f, 0.28266010f, 0.17286733f, 
    0.22824302f, -0.13271669f, -0.05019062f, 0.04659070f, -0.06871036f, -0.05152228f, -0.10396969f, 0.03673156f, 
    0.00953921f, 0.01275971f, 0.34160528f, 0.32195497f, -0.11461724f, -0.13249587f, 0.00884779f, 0.05284962f, 
    0.09672046f, 0.06316967f, 0.00472428f, -0.15666027f, -0.10634257f, -0.01054659f, 0.01856562f, 0.08826798f, 
    -0.01605136f, 0.08872262f, -0.04651159f, -0.14857583f, -0.27470222f, -0.13326028f, -0.17135027f, -0.15459450f, 
    0.27323940f, 0.04375035f, 0.06527878f, 0.52504748f, 0.07488909f, -0.07772992f, 0.06885789f, 0.02267015f, 
    0.10695402f, 0.13149916f, 0.05658050f, 0.04291200f, -0.22290604f, -0.02895889f, -0.19627963f, 0.29444352f, 
    0.00604841f, 0.03339561f, 0.02070398f, 0.02443306f, -0.07357824f, -0.15694143f, -0.13189135f, -0.07731880f, 
    0.51502615f, 0.00431541f, -0.12677678f, -0.26757872f, -0.19483027f, 0.17114891f, 0.04440263f, 0.21731554f, 
    -0.18247662f, -0.04918712f, -0.02918435f, -0.12763096f, 0.08517209f, 0.18787901f, -0.19191292f, 0.16504961f, 
    -0.06427997f, -0.12573524f, 0.14781868f, 0.22022919f, -0.04691780f, 0.01741756f, 0.09917411f, 0.10834350f, 
    0.14691247f, 0.06305975f, -0.13325596f, 0.50772607f, 0.12873539f, 0.06405544f, 0.06020487f, -0.21867999f, 
    -0.20938495f, -0.07667488f, 0.04997014f, 0.06959685f, -0.06480215f, 0.13943709f, -0.31338236f, 0.11804102f, 
    -0.10615800f, -0.08397989f, -0.01908060f, 0.02346295f, 0.15534917f, 0.11373834f, 0.01909988f, 0.33849618f, 
    0.54918200f, -0.25116050f, 0.22493699f, -0.05261717f, 0.02251751f, 0.17796394f, 0.18366173f, -0.00438416f, 
    0.16080503f, 0.02327459f, 0.08043650f, 0.20811047f, -0.01545603f, 0.34458071f, -0.06119192f, 0.14452116f, 
    0.11231078f, -0.16910703f, 0.05383452f, -0.15365896f, -0.03251315f, 0.16002025f, 0.02296045f, 0.00745877f, 
    -0.05762159f, -0.09028006f, 0.00455997f, -0.12722386f, -0.05499510f, -0.03718594f, 0.11198703f, 0.21692288f, 
    0.00902210f, 0.07183481f, 0.15011731f, 0.12915520f, 0.16715184f, 0.12799191f, -0.11858808f, 0.26173902f, 
    0.06601615f, -0.03223374f, -0.03118084f, -0.10675284f, 0.04864385f, 0.00539127f, 0.00674715f, -0.09501349f, 
    -0.10423891f, 0.01955613f, -0.23449571f, 0.02556854f, 0.02648132f, 0.07883056f, 0.20231697f, 0.05515875f, 
    0.04913444f, 0.18241832f, 0.09911893f, 0.17013854f, -0.40425137f, 0.13733481f, -0.04087172f, 0.28212467f, 
    -0.07750029f, 0.00587982f, 0.02220896f, 0.06745065f, -0.12352964f, -0.02563917f, -0.11681204f, -0.03684686f, 
    0.15348819f, 0.02882692f, 0.04859811f, 0.35455045f, -0.01305167f, -0.00431322f, 0.03272429f, -0.03739531f, 
    -0.08385675f, -0.00465976f, 0.07623238f, -0.10280303f, -0.37089071f, 0.14747162f, -0.04347586f, -0.08184943f, 
    -0.09829245f, 0.02836966f, -0.03488436f, -0.11740607f, 0.14158279f, 0.07918753f, 0.01138053f, 0.13290474f, 
    -0.01696586f, -0.11084065f, -0.34109172f, 0.00546279f, 0.02232580f, -0.12047496f, 0.00741055f, -0.27434632f, 
    -0.18210892f, 0.05059618f, -0.07056112f, -0.14849798f, 0.13261648f, -0.16265415f, 0.42940980f, -0.10891445f, 
    -0.06549523f, -0.09172849f, -0.17054015f, 0.17005591f, -0.11461888f, 0.00375683f, -0.13927686f, 0.01372958f, 
    0.14833760f, 0.05975050f, 0.07560474f, 0.09628758f, 0.21302563f, -0.01396303f, 0.11195734f, -0.10612024f, 
    -0.03025300f, 0.07572265f, 0.07719170f, 0.04999430f, -0.08721714f, 0.18411070f, 0.06548144f, -0.00092688f, 
    0.11023922f, -0.13929304f, 0.05221942f, 0.08843891f, 0.07353123f, 0.12358129f, 0.07913998f, 0.06288850f, 
    0.05525724f, -0.07257649f, -0.11695433f, -0.07592662f, 0.07071012f, -0.07208876f, 0.13931748f, 0.02130811f, 
    0.12950422f, 0.00848284f, -0.13899888f, 0.08724483f, -0.06995080f, -0.01598639f, 0.06414957f, -0.12545498f, 
    0.12908939f, 0.08280005f, 0.19973268f, 0.22880228f, 0.03593032f, 0.17616378f, 0.08411250f, -0.07068069f, 
    -0.02320019f, 0.05264699f, -0.08735723f, -0.05394090f, 0.03684866f, -0.07876719f, -0.14559498f, -0.19222912f, 
    -0.17493215f, -0.13381016f, -0.02770158f, -0.11714210f, 0.06588665f, -0.30703810f, -0.13148570f, -0.16092004f, 
    -0.07248885f, 0.01617219f, 0.14849582f, 0.07766973f, -0.11380171f, -0.01913345f, -0.07185950f, -0.10479528f, 
    0.09849244f, -0.00647037f, -0.21959060f, 0.02439537f, -0.03921146f, -0.08962604f, 0.08449017f, 0.03151784f, 
    -0.03208065f, -0.01612663f, -0.04404957f, -0.11082785f, 0.00713241f, -0.28672537f, -0.29622605f, -0.00479713f, 
    0.03882831f, 0.03229762f, -0.02145182f, -0.19253850f, -0.00158663f, -0.01606780f, 0.05630903f, -0.00821504f, 
    0.05115681f, -0.07063396f, -0.05176035f, 0.35393450f, 0.02679202f, -0.03188179f, -0.02172616f, -0.14198326f, 
    0.03349111f, -0.05755776f, 0.04491031f, -0.05125602f, 0.22997589f, -0.27977180f, 0.33254468f, 0.34669825f, 
    0.18778291f, -0.15902005f, 0.07806587f, 0.07557990f, 0.14713602f, 0.01564185f, 0.09391611f, 0.03049689f, 
    0.16211258f, -0.15207551f, -0.07640691f, 0.08156511f, -0.11079355f, 0.02628092f, -0.14889115f, 0.13797462f, 
    0.01801066f, -0.11825012f, -0.09544867f, -0.32108039f, -0.01637151f, 0.06405215f, -0.19098043f, -0.26422939f, 
    -0.13307312f, -0.03248832f, -0.11499975f, 0.08145057f, -0.12187828f, 0.02906611f, 0.08053546f, 0.16347682f, 
    -0.03493543f, 0.04633077f, -0.00267276f, -0.18729216f, 0.03907880f, 0.00066941f, -0.00100531f, -0.05234238f, 
    0.16546330f, 0.10611974f, -0.00060491f, 0.05113086f, 0.36999053f, -0.03552407f, 0.52083176f, -0.26191410f, 
    -0.00580648f, 0.01928270f, 0.07653795f, -0.07853884f, 0.08177137f, 0.05501662f, 0.06818104f, 0.04306126f, 
    0.11721434f, 0.01521433f, -0.10643809f, -0.14231053f, -0.09334726f, -0.01500552f, 0.09402353f, -0.04652168f, 
    0.01463259f, -0.11383811f, -0.16402406f, -0.03962156f, -0.23769020f, 0.36951047f, 0.10206459f, 0.35558385f, 
    0.14924523f, 0.02541896f, 0.19654515f, -0.02081700f, -0.02099020f, -0.03168226f, -0.08722295f, -0.05309829f, 
    0.24588977f, -0.35860032f, 0.12942190f, -0.02973948f, -0.04818167f, 0.09240259f, -0.01038802f, 0.06282868f, 
    0.07069953f, 0.12654810f, 0.16938609f, 0.19167392f, -0.12681726f, -0.06454559f, -0.07343649f, -0.20310640f, 
    -0.10928840f, -0.11499579f, -0.06765655f, -0.01286079f, 0.03705485f, 0.16719639f, 0.21508555f, 0.08870342f, 
    0.18186545f, -0.01752220f, -0.20229682f, 0.31356350f, 0.09907240f, -0.04593724f, -0.01650131f, 0.21261817f, 
    -0.12800969f, 0.09179320f, 0.17024677f, -0.06988978f, -0.08340663f, 0.18758301f, 0.23022017f, 0.23381792f, 
    0.04503010f, 0.02991538f, -0.19216540f, 0.04227693f, 0.06909316f, -0.03214654f, 0.09354667f, 0.10950141f, 
    -0.16254842f, -0.00626424f, -0.03373246f, -0.04989917f, 0.01762824f, 0.11506535f, 0.01543478f, -0.01887455f, 
    -0.10685726f, -0.03333562f, -0.12605476f, -0.02337316f, -0.02404376f, 0.01657498f, 0.00156221f, 0.13047662f, 
    0.00840066f, 0.00940628f, -0.02373138f, -0.09057780f, 0.00641537f, 0.06775609f, -0.12181401f, 0.06276457f, 
    -0.36651397f, 0.13649526f, 0.09084478f, 0.09035417f, 0.08916013f, 0.01885271f, 0.05083229f, 0.00551955f, 
    -0.04601683f, 0.02222640f, -0.08298367f, 0.00406729f, 0.29131430f, -0.14472508f, 0.00192677f, 0.03961186f, 
    0.02912250f, -0.05709150f, 0.11239181f, 0.07531939f, -0.00083740f, 0.17442088f, 0.06073599f, 0.02314927f, 
    -0.08511528f, -0.09601282f, -0.11633693f, 0.25562361f, 0.08887016f, 0.13713129f, -0.30033413f, -0.00609810f, 
    0.02166229f, 0.05270906f, -0.00721856f, 0.18722615f, 0.06486337f, 0.17885563f, -0.07785291f, 0.03066432f, 
    -0.14241591f, -0.05988321f, -0.01786816f, 0.00073114f, -0.10083685f, -0.04053089f, 0.12411827f, 0.08307357f, 
    0.38670051f, 0.08451774f, -0.08373112f, -0.08206548f, -0.02516532f, 0.06946985f, 0.11762291f, 0.05413324f, 
    -0.01789015f, -0.10110743f, 0.08905805f, -0.06025164f, 0.03475301f, 0.03622913f, -0.04041722f, -0.02251710f, 
    0.06701422f, 0.19064510f, 0.14253122f, -0.04505282f, -0.13319726f, -0.00005234f, -0.12902801f, -0.07112614f, 
    -0.10342845f, 0.01505274f, -0.04022369f, 0.18463032f, 0.11005275f, -0.01372381f, 0.13811898f, -0.22352177f, 
    -0.23017402f, 0.02016301f, -0.17816928f, 0.09735250f, 0.16565390f, -0.00117893f, 0.09275526f, -0.12710328f, 
    0.04020203f, -0.01719015f, 0.01408573f, 0.05150550f, 0.10157523f, 0.10695213f, 0.09891938f, -0.03612326f, 
    0.51672906f, -0.19623131f, 0.30641514f, -0.09834822f, 0.06658348f, 0.08618616f, -0.05717289f, 0.19063945f, 
    -0.05296143f, -0.22410490f, 0.07945877f, 0.01198574f, -0.18797161f, -0.03552296f, 0.03894266f, 0.03582926f, 
    0.13754536f, 0.07261933f, 0.09615806f, 0.05365766f, 0.08433301f, -0.10798319f, -0.11278156f, -0.02676317f, 
    0.07647615f, 0.15170468f, -0.11515031f, 0.05654452f, -0.00602550f, 0.09642509f, 0.17550689f, 0.03980657f, 
    -0.08623453f, 0.12401682f, 0.13127123f, 0.19534521f, 0.20793219f, 0.01352606f, -0.10557154f, -0.19977805f, 
    -0.00817203f, -0.04736691f, -0.13846579f, 0.07589879f, -0.10633146f, 0.00723718f, -0.06548260f, -0.07717542f, 
    0.06287613f, -0.17152692f, 0.37929162f, 0.36033496f, 0.03996018f, -0.00804332f, 0.06928574f, -0.07315800f, 
    -0.00146308f, 0.05992297f, -0.04106826f, 0.05512755f, -0.25718802f, -0.03439121f, 0.02912885f, 0.23792897f, 
    0.05483618f, 0.10390443f, 0.06412032f, -0.00014387f, 0.09304202f, 0.07300250f, 0.17538302f, 0.13252661f, 
    0.11482078f, 0.09855670f, 0.09215206f, -0.16250677f, 0.00944840f, 0.08934917f, -0.01628609f, 0.01510277f, 
    -0.13437374f, -0.04004093f, -0.01664791f, -0.12095829f, -0.23536296f, 0.24186492f, 0.17477491f, 0.01590773f, 
    0.18996751f, 0.11330251f, 0.06168589f, -0.05714457f, -0.05992040f, 0.18607527f, 0.01941011f, -0.01627793f, 
    0.28686184f, -0.04327842f, 0.39783430f, -0.04323398f, -0.11350088f, 0.12812217f, -0.11875392f, -0.14121562f, 
    -0.10744131f, 0.14186123f, 0.05235760f, -0.17625943f, -0.22043756f, 0.02207799f, 0.03792066f, 0.15769479f, 
    -0.04406645f, 0.16180538f, 0.18987443f, -0.15998897f, -0.00351409f, 0.11218477f, 0.05499213f, 0.10238382f, 
    0.07387138f, -0.10321503f, -0.00010637f, 0.03314107f, -0.01077047f, 0.03257669f, 0.04183670f, -0.12405833f, 
    0.00123641f, -0.13393824f, 0.03863456f, -0.01289291f, -0.05361151f, -0.05193006f, 0.23714320f, -0.18453360f, 
    0.12659574f, -0.00258014f, 0.00401068f, 0.12913562f, 0.05994241f, 0.01109605f, 0.08539224f, -0.11620305f, 
    -0.05154150f, 0.00785829f, -0.07393964f, 0.00423877f, 0.02885358f, 0.06625476f, 0.01916949f, 0.04604531f, 
    0.10498660f, -0.09608594f, 0.05683361f, 0.03459420f, -0.03076324f, 0.12810710f, 0.10113840f, 0.04101996f, 
    0.06261994f, -0.05462101f, -0.04841259f, -0.04092794f, -0.07101532f, 0.03067957f, 0.10522312f, -0.10786396f, 
    -0.11899562f, 0.07624859f, 0.05731806f, 0.06063122f, 0.05557922f, -0.09221531f, -0.10003337f, 0.03777312f, 
    0.08610602f, -0.06680577f, 0.08055138f, 0.04391621f, 0.09568295f, 0.31942466f, -0.14034337f, 0.04293769f, 
    -0.12731683f, 0.11785404f, 0.03272485f, 0.06601898f, -0.02824493f, 0.02514129f, -0.00165600f, -0.21515611f, 
    -0.06083914f, 0.00505019f, 0.15522490f, 0.05866084f, 0.09968235f, 0.09383547f, 0.03473039f, -0.03568654f, 
    -0.06468200f, 0.01023307f, -0.05552686f, 0.02648199f, -0.00120029f, -0.14258596f, -0.03408895f, 0.04005224f, 
    0.13120341f, 0.13571592f, 0.01675737f, 0.10885026f, 0.03101378f, -0.00282118f, -0.07654907f, -0.11237772f, 
    0.01324106f, 0.08213878f, -0.04394099f, -0.10512774f, 0.14907482f, -0.08145551f, -0.06032716f, 0.03226339f, 
    0.04977347f, -0.01978852f, -0.06804235f, 0.10955731f, 0.36832446f, 0.11273428f, 0.09499096f, -0.13099176f, 
    0.11426294f, -0.05954790f, 0.05123323f, 0.10274945f, 0.00938139f, -0.01489211f, -0.10919333f, -0.06175333f, 
    -0.28135806f, 0.15110625f, -0.08728033f, 0.22864054f, 0.14512129f, 0.09160385f, -0.01080783f, -0.10652018f, 
    0.01464924f, -0.06346475f, 0.06575085f, 0.01499022f, -0.12252965f, -0.17592117f, 0.20041247f, 0.02833683f, 
    0.09939626f, -0.02431509f, 0.03598458f, 0.00841849f, 0.07904239f, -0.13851011f, 0.04114496f, -0.06847917f, 
    -0.00716708f, -0.06179098f, 0.22648869f, -0.04764448f, 0.00684346f, 0.06154016f, 0.00864333f, 0.01000388f, 
    -0.02934351f, 0.02729836f, -0.10570899f, -0.02928367f, 0.10459337f, -0.36449268f, 0.08826338f, 0.06360400f, 
    0.04616805f, -0.04927880f, 0.01643198f, -0.03684431f, -0.00284760f, 0.01111852f, 0.11247297f, 0.15159866f, 
    -0.36265334f, 0.01050272f, -0.05159835f, -0.00705038f, -0.01337428f, -0.02275827f, 0.05356537f, 0.09315772f, 
    0.09313784f, -0.02314622f, -0.05193968f, 0.18138522f, -0.33946136f, 0.07821694f, -0.00967227f, -0.11701758f, 
    0.07802758f, -0.00199246f, 0.09677807f, -0.12868661f, 0.23409806f, -0.01466410f, -0.02652111f, -0.10379240f, 
    -0.03661411f, 0.17410035f, 0.06120066f, -0.11047307f, 0.09578215f, 0.02249997f, 0.04433017f, 0.05626332f, 
    -0.08028902f, -0.02094769f, 0.04411472f, 0.05868607f, 0.38426876f, 0.28738669f, 0.15939820f, -0.02778931f, 
    -0.07865162f, -0.07336356f, -0.10839473f, -0.08095194f, 0.02782202f, -0.03853191f, 0.00207630f, -0.05913322f, 
    0.03248086f, 0.10445276f, 0.07882521f, -0.16612899f, -0.02932293f, 0.06694632f, 0.03309714f, 0.12748618f, 
    -0.11759026f, -0.11850166f, 0.08834118f, 0.14779812f, 0.10499314f, 0.00912191f, 0.08226508f, -0.13349970f, 
    0.13951710f, 0.00262625f, -0.13336629f, 0.04814126f, 0.00167208f, -0.00830370f, 0.12176589f, -0.01875047f, 
    -0.15621287f, -0.14943162f, -0.07654960f, 0.07574070f, 0.00366474f, 0.00067994f, -0.10939735f, 0.02234002f, 
    -0.09442336f, -0.02148370f, -0.03287706f, 0.12422168f, 0.11936610f, -0.34852770f, 0.02341341f, 0.02465384f, 
    0.07333536f, -0.02529310f, -0.01744802f, -0.02607515f, 0.18246423f, 0.17356820f, 0.14402923f, 0.24250104f, 
    0.04670317f, 0.10302864f, -0.04509570f, -0.02242201f, -0.11137675f, 0.00663355f, 0.07788774f, -0.07091805f, 
    0.06948724f, -0.02901571f, 0.03485957f, 0.00588751f, -0.11668964f, 0.08580535f, -0.06512392f, 0.07255720f, 
    0.03566721f, -0.06290168f, 0.05403986f, 0.00441108f, -0.08725578f, -0.14481185f, -0.05509863f, -0.14571996f, 
    -0.43753922f, 0.01826842f, -0.15677044f, -0.11152207f, -0.09947816f, 0.04723724f, 0.19957615f, 0.06789792f, 
    0.01276646f, -0.01748017f, 0.00443264f, 0.07594454f, -0.11533381f, -0.26979145f, 0.04228649f, 0.18775450f, 
    -0.04206647f, 0.05716242f, -0.06389055f, -0.07001193f, -0.06353389f, -0.07747304f, 0.07157828f, -0.01605539f, 
    0.16635810f, 0.31419450f, 0.01281006f, 0.00994345f, -0.04977543f, 0.08553478f, -0.18674485f, 0.02276908f, 
    -0.05731470f, -0.08639122f, 0.08960558f, -0.05770689f, -0.32140559f, 0.12071085f, 0.02249392f, 0.08744153f, 
    0.11540339f, 0.09304696f, 0.10139684f, -0.04931898f, -0.00885860f, 0.05407180f, 0.00287116f, 0.04185781f, 
    0.09326237f, -0.23580043f, 0.08380996f, -0.00223781f, 0.01375605f, 0.05615401f, 0.06995718f, -0.07757106f, 
    0.07254326f, -0.10243929f, 0.00932803f, -0.17142212f, 0.13750105f, 0.31203780f, 0.10778411f, -0.01139137f, 
    0.07412074f, -0.06067382f, 0.05311877f, 0.10772528f, -0.03589081f, -0.04933816f, 0.21571507f, 0.07648456f, 
    0.07524875f, -0.34664339f, 0.02611841f, 0.26490086f, 0.05211765f, 0.07560841f, -0.01295611f, 0.05098514f, 
    -0.01091784f, -0.01692008f, 0.02721227f, 0.09868506f, 0.12148425f, 0.14763658f, 0.08889683f, -0.04045760f, 
    0.01389279f, 0.12616770f, -0.05603444f, 0.03351120f, -0.05279541f, -0.05847576f, 0.14648154f, 0.07632289f, 
    0.35945410f, 0.28423399f, 0.27809963f, -0.07540102f, 0.01395625f, 0.04363514f, -0.10651507f, 0.11737650f, 
    0.06404849f, -0.06066831f, 0.00245055f, -0.09132896f, -0.40136886f, 0.04871577f, -0.22756273f, -0.25862756f, 
    0.03630036f, 0.07099090f, 0.14766924f, 0.18877102f, 0.03805790f, -0.12954430f, -0.05174217f, 0.07788968f, 
    0.09336586f, 0.15762433f, 0.18058422f, -0.07137941f, 0.03932158f, 0.05395891f, -0.01380888f, 0.00667245f, 
    -0.00365379f, -0.05455610f, -0.08532427f, -0.01520482f, 0.10193450f, 0.03292806f, 0.14454660f, 0.01704325f, 
    0.04371729f, -0.06792836f, -0.04805727f, -0.11443206f, -0.00153353f, -0.04735159f, 0.02075227f, 0.02979544f, 
    -0.13850836f, -0.09694100f, 0.06685157f, 0.37925792f, 0.06854521f, 0.01396586f, 0.03589075f, -0.04101871f, 
    0.07293354f, -0.02749604f, 0.05647646f, -0.01245846f, -0.19972934f, 0.09439491f, 0.07462023f, 0.42972630f, 
    0.12603155f, 0.03099905f, 0.02232185f, 0.02884547f, -0.03891921f, -0.11018905f, -0.07838149f, 0.01121804f, 
    0.31502640f, 0.40332496f, 0.00463221f, 0.03654608f, -0.05165134f, 0.07906629f, 0.10241771f, 0.03242384f, 
    0.09813827f, -0.11982735f, -0.06496287f, -0.07834085f, 0.27365503f, -0.12874295f, 0.15295933f, -0.14003664f, 
    0.07589991f, -0.01008524f, 0.12326801f, -0.09353812f, 0.04075276f, -0.00916484f, -0.06859907f, -0.09477101f, 
    -0.24397551f, 0.16540648f, -0.35396436f, 0.01156095f, 0.15046132f, -0.07564206f, 0.08390097f, -0.07798532f, 
    0.02153436f, -0.07060802f, 0.04119913f, 0.03886268f, -0.11499324f, -0.14349990f, -0.04928040f, 0.17468429f, 
    0.10601474f, 0.06392512f, 0.01797788f, -0.00179921f, 0.10767505f, 0.01482658f, -0.11199532f, 0.04967021f, 
    -0.25654039f, -0.33027682f, 0.11362945f, 0.01396090f, -0.00128313f, -0.12233099f, -0.04263828f, 0.02594017f, 
    -0.00485909f, -0.04829127f, -0.11603671f, 0.02701483f, 0.17103215f, -0.16096126f, -0.02065681f, -0.36905131f, 
    -0.05229279f, -0.00346955f, -0.07684650f, 0.01671867f, -0.15442714f, -0.10964473f, -0.04199665f, 0.02915021f, 
    0.00061919f, -0.04856033f, -0.02447722f, 0.07045641f, 0.14564134f, -0.00629275f, 0.04185599f, 0.03391676f, 
    0.08549323f, 0.10741585f, 0.01837270f, 0.10947108f, 0.11473842f, 0.12143026f, -0.01836857f, 0.06931352f, 
    0.15028296f, 0.03646486f, 0.07536941f, -0.11140644f, 0.20267484f, -0.06645725f, 0.02170435f, 0.02025845f, 
    -0.02259047f, 0.05513254f, -0.11249463f, 0.07081818f, 0.08353025f, 0.01592822f, 0.06530924f, -0.10483249f, 
    0.08338099f, 0.04843090f, -0.06851937f, 0.06474815f, -0.23785107f, 0.07450501f, -0.07423659f, -0.11501238f, 
    0.14274944f, -0.07195202f, -0.04649736f, -0.02034521f, -0.02308593f, 0.11479281f, 0.14557952f, 0.05597017f, 
    0.13298950f, -0.07049490f, 0.29599515f, 0.08885109f, 0.12689415f, 0.03300442f, 0.00024431f, -0.05059360f, 
    0.03924681f, -0.18884221f, -0.05605409f, -0.04614401f, -0.24113297f, -0.01951899f, -0.05964454f, 0.13266392f, 
    0.10063396f, -0.01357672f, 0.05422278f, -0.05366636f, -0.01229492f, -0.02003386f, -0.00665086f, -0.05592570f, 
    -0.37464786f, 0.17321634f, -0.01099052f, 0.19432816f, 0.10957440f, -0.12631293f, -0.04182187f, 0.09018762f, 
    0.07132542f, -0.00392321f, 0.05867331f, 0.23182608f, -0.05307550f, -0.19313751f, 0.07384223f, -0.03828714f, 
    0.17289488f, 0.09815159f, 0.03103654f, -0.02626150f, 0.00914135f, -0.15270464f, -0.14152516f, -0.12730426f, 
    -0.10867831f, -0.08637523f, -0.18982096f, -0.00745059f, -0.03345796f, -0.04357119f, -0.07651354f, -0.05875523f, 
    -0.17789312f, -0.04631890f, -0.12699264f, -0.20329630f, -0.22900790f, -0.12650655f, 0.17010838f, 0.15853000f, 
    0.00622347f, 0.07296304f, -0.07096750f, -0.07558875f, 0.18674108f, -0.00579691f, 0.10983596f, -0.02063156f, 
    0.20556115f, 0.28090897f, -0.01427696f, 0.09691326f, -0.18296281f, 0.00206873f, 0.04481533f, -0.03267963f, 
    -0.02283934f, 0.04075219f, 0.07549334f, -0.10004048f, -0.04713854f, -0.10962131f, -0.02419520f, 0.21832614f, 
    0.07523516f, -0.02398955f, 0.07790218f, -0.03060748f, -0.10286940f, -0.08818559f, -0.04683544f, 0.08482861f, 
    -0.02376554f, -0.27198866f, 0.33657461f, -0.11585372f, 0.10122430f, 0.14130987f, 0.02748852f, 0.03565025f, 
    -0.01086576f, 0.06669023f, -0.01583962f, 0.13750853f, -0.31697515f, -0.11065352f, -0.12567386f, 0.15157709f, 
    0.17015071f, 0.11356913f, 0.01398451f, 0.02367405f, 0.03121453f, -0.06117458f, 0.04233298f, 0.04746614f, 
    0.13038094f, -0.04759496f, -0.30397788f, 0.02195523f, 0.11614585f, 0.13795683f, -0.03989481f, 0.29360205f, 
    -0.02241965f, 0.00874513f, 0.03202371f, -0.05034171f, 0.22814663f, 0.13181382f, -0.04992879f, -0.15848926f, 
    -0.07153053f, 0.10200593f, -0.14878072f, 0.00125056f, -0.05688740f, -0.02372536f, 0.21261984f, -0.01345064f, 
    -0.13424298f, -0.24366860f, -0.11805310f, 0.15173890f, 0.15967198f, 0.11111449f, 0.02929530f, 0.00538389f, 
    0.02809711f, -0.02301834f, 0.05955060f, 0.00653064f, 0.07654726f, -0.71033919f, 0.35181645f, 0.42455286f, 
    0.02084658f, 0.05021900f, -0.03701498f, 0.16164127f, 0.14791618f, 0.01329040f, -0.19061393f, 0.04536650f, 
    -0.34337261f, -0.12563223f, -0.05433797f, -0.10637153f, -0.01329128f, 0.03746910f, -0.07905494f, -0.01362778f, 
    0.04441049f, -0.00221231f, -0.10464699f, -0.05073540f, -0.05647641f, -0.34988591f, -0.01775845f, -0.15624347f, 
    0.00626997f, 0.10268189f, -0.03703019f, 0.13706507f, 0.08336073f, 0.05811829f, 0.08277481f, 0.12159678f, 
    -0.00924956f, 0.00570566f, -0.02619462f, 0.01535486f, -0.03465903f, 0.01713286f, 0.02566161f, 0.00112482f, 
    0.01654066f, -0.01492657f, 0.00695751f, -0.04084728f, -0.02809023f, 0.01864735f, 0.02473683f, 0.00654549f, 
    -0.00213660f, 0.02324555f, -0.00168535f, 0.02483660f, -0.01713314f, 0.02946790f, 0.02042541f, -0.00086921f, 
    -0.03226597f, 0.01662493f, 0.01941287f, 0.02391236f, 0.02762487f, -0.03725013f, 0.00698345f, 0.01538779f, 
    0.00690814f, -0.01867800f, 0.02914200f, -0.00641526f, -0.01387118f, 0.00043105f, 0.01609776f, 0.02541786f, 
    -0.00797976f, -0.01904171f, 0.01093950f, 0.00534050f, -0.02494172f, -0.01000453f, -0.02422310f, -0.01100390f, 
    -0.02566939f, 0.00748726f, -0.01183345f, -0.01694403f, -0.01071056f, -0.01832493f, 0.02779498f, 0.01513164f, 
    -0.01578829f, -0.01062635f, -0.00597144f, -0.00061396f, 0.00811988f, 0.03057861f, 0.02804996f, -0.00370488f, 
    -0.03907195f, -0.03061322f, -0.03732644f, -0.00296027f, 0.00739293f, 0.00673691f, 0.02765936f, 0.00792670f, 
    -0.00205337f, -0.03651515f, 0.01262444f, -0.03607410f, 0.01726682f, -0.03139624f, -0.04019017f, -0.00042306f, 
    0.00254850f, -0.02120894f, -0.02572353f, -0.02664403f, 0.00950781f, 0.00731910f, -0.03960834f, -0.03384433f, 
    -0.02325060f, -0.03740372f, -0.01741808f, -0.00392794f, 0.02804032f, 0.00368992f, -0.01121449f, 0.02623834f, 
    -0.02179903f, -0.00761501f, -0.01887423f, 0.01424547f, 0.02307040f, -0.00306021f, 0.02533774f, -0.00300381f, 
    -0.03484773f, 0.01105404f, -0.01438963f, 0.00099400f, 0.02027010f, 0.00414276f, -0.03194665f, -0.01022783f, 
    0.02580556f, 0.02974189f, 0.02808464f, -0.00862570f, 0.02647893f, -0.02836580f, -0.00363550f, 0.00797488f, 
    -0.01821643f, -0.00815969f, -0.02272155f, -0.00663937f, 0.00179168f, 0.00766155f, -0.04184876f, -0.03367705f, 
    0.00944483f, -0.02349833f, 0.02511238f, -0.02399767f, 0.02889955f, 0.02083789f, -0.00829924f, -0.00896249f, 
    0.01039170f, -0.02037160f, -0.04047451f, 0.01340421f, -0.03057631f, -0.03926308f, -0.00186030f, 0.02302127f, 
    0.02433295f, -0.00615783f, -0.00399403f, -0.03735954f, -0.02512569f, 0.02181582f, -0.02102964f, 0.00110914f, 
    -0.01816945f, -0.00271361f, -0.02100223f, -0.02156936f, -0.00182398f, 0.01650253f, -0.01114507f, 0.00906545f, 
    -0.01021295f, 0.02621884f, 0.01210328f, -0.02503765f, -0.02738429f, -0.01578630f, -0.01997383f, 0.00046138f, 
    0.01251786f, 0.00807455f, -0.01800074f, 0.02918201f, 0.00819091f, -0.03068634f, 0.02244059f, -0.02037313f, 
    -0.03012867f, 0.02494472f, -0.00810057f, -0.02902161f, 0.00975878f, -0.01633292f, 0.02180097f, -0.01223710f, 
    -0.02728000f, 0.01174256f, 0.01544423f, 0.01632821f, 0.00725413f, 0.01735446f, 0.01523987f, -0.02440598f, 
    0.00265740f, -0.00562744f, -0.02733599f, -0.02380972f, -0.03560868f, -0.00882048f, -0.02312194f, -0.01537868f, 
    0.01844707f, 0.02718571f, 0.00946393f, -0.03266904f, -0.01259400f, -0.02209570f, -0.02060039f, -0.02938189f, 
    -0.00779060f, -0.03569664f, -0.01644048f, 0.02156029f, 0.00466460f, -0.02889390f, 0.01962312f, -0.03164714f, 
    0.01198895f, 0.00876642f, 0.00083669f, -0.01919264f, -0.02640819f, 0.02615155f, -0.00383272f, -0.01924070f, 
    0.01036773f, -0.01862272f, 0.01305036f, -0.02596257f, -0.03363719f, -0.01037084f, 0.03031157f, -0.02688728f, 
    -0.03753144f, -0.00246849f, 0.03120929f, -0.00565015f, -0.00082590f, 0.00162329f, 0.01563524f, 0.00187677f, 
    0.02332748f, -0.03881660f, -0.01131797f, 0.01500384f, 0.00910865f, -0.02929904f, 0.02186197f, -0.01410752f, 
    0.02755635f, -0.01470720f, -0.03955385f, 0.02073912f, -0.03636125f, 0.02942806f, -0.01732079f, 0.00424904f, 
    0.03041585f, -0.01152554f, 0.00550082f, 0.00222841f, -0.00767606f, 0.01723902f, 0.00128260f, 0.01497077f, 
    0.02398618f, 0.00628857f, 0.02760800f, 0.03137638f, 0.00979371f, 0.00327194f, -0.03332901f, -0.03735109f, 
    0.03116093f, -0.03180943f, 0.00424239f, 0.02394626f, -0.02007120f, -0.01693746f, -0.00229730f, 0.01946965f, 
    -0.00300008f, 0.01060927f, -0.00933420f, -0.03983581f, -0.02628591f, -0.03189139f, -0.01033014f, -0.03380756f, 
    0.01374443f, -0.00910122f, -0.03068964f, 0.01664377f, -0.02958180f, 0.01943940f, 0.01626248f, 0.00523024f, 
    0.02198070f, -0.03091722f, -0.03161094f, -0.00528614f, 0.01139779f, 0.01122943f, 0.01687341f, -0.01235043f, 
    -0.02336665f, 0.02553000f, -0.03059735f, -0.00006483f, 0.02114531f, -0.02928655f, -0.02237161f, 0.01773387f, 
    0.03326293f, -0.01082219f, 0.02828203f, -0.01473423f, -0.00559107f, 0.01357504f, -0.01206965f, 0.01244832f, 
    -0.03833351f, -0.02152930f, 0.02518986f, 0.01521417f, -0.03876421f, -0.00280847f, -0.00910808f, -0.01935400f, 
    0.00160255f, 0.00934255f, -0.01776255f, -0.00631200f, 0.02798448f, -0.02612969f, 0.00133391f, -0.01006399f, 
    -0.02452691f, -0.02850303f, 0.00618896f, 0.00747017f, -0.02336982f, -0.03289564f, 0.02004428f, 0.01808673f, 
    -0.01987948f, -0.00450909f, -0.02992172f, -0.02687201f, -0.01705467f, 0.03287987f, 0.02509895f, 0.00329635f, 
    -0.01989994f, 0.00075961f, -0.03089546f, 0.03082153f, -0.01974830f, -0.01496764f, -0.00611274f, 0.01933994f, 
    0.01074543f, 0.02931993f, -0.01012460f, -0.02378793f, -0.00209043f, -0.01690525f, -0.03335828f, -0.01704233f, 
    -0.03777539f, 0.01034846f, 0.00336255f, -0.02186773f, -0.02301257f, -0.03333019f, -0.01842409f, 0.03859838f, 
    -0.00833387f, 0.01205459f, -0.00272822f, -0.01013581f, -0.00047131f, 0.01918956f, 0.01497688f, 0.01308672f, 
    0.01142998f, 0.02099316f, -0.00284350f, -0.01163655f, 0.01922349f, -0.02733737f, -0.00775742f, -0.01272088f, 
    -0.02370765f, -0.01861032f, 0.02144471f, -0.00554911f, -0.00020688f, -0.01298330f, 0.01246303f, -0.03930825f, 
    -0.02758485f, 0.02138561f, 0.02270504f, -0.00706208f, -0.02054543f, -0.03578765f, 0.02294729f, 0.02099037f, 
    -0.00637584f, 0.00072711f, 0.01570319f, -0.01624124f, 0.01776288f, 0.01223708f, -0.01681370f, 0.00814306f, 
    0.00708380f, -0.03957839f, -0.02236004f, 0.00412674f, 0.01295834f, 0.00040844f, -0.02173937f, -0.02676113f, 
    -0.03960621f, -0.01357247f, 0.01968427f, 0.00542774f, 0.00122898f, -0.01199330f, -0.03522087f, 0.00833294f, 
    0.01296570f, -0.01019819f, -0.00418186f, 0.02858233f, 0.01277124f, -0.02699619f, -0.03660489f, 0.00907433f, 
    0.03061691f, -0.00681071f, 0.01794539f, 0.00491644f, -0.03097528f, -0.04108855f, 0.00672485f, -0.02593881f, 
    -0.00542511f, -0.03363084f, 0.02257590f, 0.00510941f, -0.02200387f, 0.02135741f, -0.03003304f, 0.01061715f, 
    -0.01721369f, -0.00327057f, -0.02600441f, -0.02371779f, -0.03865266f, -0.04043194f, -0.01149101f, -0.03163841f, 
    0.00130079f, 0.01491213f, -0.01098852f, -0.00583467f, 0.00837541f, -0.00268154f, -0.00840825f, -0.03416292f, 
    -0.02269905f, -0.00564392f, 0.00362497f, -0.01414933f, -0.00417398f, 0.02107575f, -0.03937910f, 0.00116281f, 
    -0.02801670f, -0.02648941f, 0.01886924f, -0.01423818f, -0.03157768f, -0.00699200f, 0.02907740f, -0.03492577f, 
    -0.02380611f, 0.00424270f, 0.01161315f, -0.00591990f, 0.01517073f, -0.01711026f, -0.01534084f, 0.01724346f, 
    -0.01377884f, -0.03994635f, 0.02001549f, -0.02296291f, 0.02580091f, 0.00944376f, -0.01880070f, 0.01288861f, 
    0.00216530f, 0.01274750f, 0.00101867f, -0.02839780f, 0.01127645f, -0.02671602f, -0.03090137f, 0.01822792f, 
    -0.00998160f, 0.01889685f, -0.01062306f, -0.02164126f, -0.01030202f, 0.01673838f, -0.04105821f, -0.03198963f, 
    -0.00321723f, -0.02191119f, -0.03388521f, -0.01672691f, -0.00600078f, 0.00364697f, 0.00101748f, 0.00578693f, 
    0.03152838f, 0.00167455f, -0.02491217f, 0.02277939f, 0.02051071f, -0.04099247f, -0.03070526f, -0.00981582f, 
    -0.01953072f, 0.02575345f, -0.01583537f, -0.02211403f, -0.01110934f, 0.00444306f, -0.01728235f, -0.01513173f, 
    0.01170636f, -0.02802375f, 0.02431362f, -0.01592518f, -0.03070817f, 0.00311081f, -0.02376924f, -0.03416866f, 
    0.00133244f, -0.00105333f, 0.02717807f, 0.01456213f, 0.02732643f, -0.02920166f, -0.00131990f, 0.02048681f, 
    0.02978783f, -0.03947746f, -0.00603483f, -0.03512133f, 0.00188123f, -0.02459531f, -0.03030460f, -0.01920936f, 
    -0.02249631f, -0.04056571f, 0.00845359f, -0.04066391f, -0.01622078f, -0.00724277f, -0.03292793f, 0.02620725f, 
    0.02186660f, 0.01386585f, 0.02109440f, 0.00288908f, -0.01734741f, 0.03065381f, -0.01864047f, 0.01496289f, 
    -0.00374673f, -0.02835918f, -0.00974084f, -0.01971143f, 0.00179978f, 0.00025058f, -0.03240926f, 0.00528020f, 
    -0.02076656f, -0.00197107f, 0.00650767f, 0.00754201f, 0.00490382f, -0.02885112f, 0.01384380f, 0.02256935f, 
    0.02236088f, -0.01107412f, 0.02665739f, -0.02565836f, -0.00418187f, 0.00664576f, 0.01484068f, 0.01489166f, 
    0.01787701f, -0.01164484f, -0.01079750f, 0.01450579f, -0.00206188f, -0.03959238f, -0.03039803f, -0.02484557f, 
    0.02331052f, -0.01768580f, -0.00786451f, -0.00590041f, 0.01186513f, -0.03347846f, 0.02483906f, -0.03844186f, 
    0.01711405f, -0.00235632f, 0.02656181f, 0.01843376f, 0.02747442f, -0.02639199f, 0.02607086f, -0.01268384f, 
    0.03019145f, -0.02644911f, 0.01028032f, -0.03731455f, 0.00033434f, -0.03342237f, 0.00649466f, 0.02721399f, 
    0.02373053f, -0.02797443f, -0.04040569f, 0.00517792f, 0.02688008f, 0.03137064f, -0.01785879f, -0.00385707f, 
    0.02741328f, 0.00202685f, 0.01000345f, -0.03880531f, 0.02000715f, -0.03878665f, 0.02855014f, 0.02382369f, 
    -0.00935530f, -0.00954940f, -0.00643237f, 0.02896956f, -0.02861951f, -0.02706889f, 0.00185907f, -0.01153201f, 
    -0.00337485f, 0.02652489f, 0.01072498f, -0.02732896f, -0.01742988f, -0.03578983f, 0.00193614f, 0.02295605f, 
    0.00790937f, 0.00997982f, 0.01106555f, 0.00538955f, -0.01253808f, -0.01541671f, -0.00648931f, 0.01685543f, 
    -0.02052667f, -0.01493085f, -0.00012926f, -0.03225875f, -0.00499179f, -0.03606973f, -0.02722946f, -0.03433619f, 
    -0.02871555f, -0.01071267f, 0.02573244f, -0.01271876f, 0.02621650f, -0.02312175f, -0.03624397f, 0.00506905f, 
    -0.03095355f, -0.02200573f, 0.00573573f, -0.00157567f, -0.00357980f, -0.02731430f, -0.00122702f, -0.00758119f, 
    0.00027521f, -0.03062224f, 0.01927523f, 0.01546323f, -0.00645528f, 0.02831563f, -0.01910777f, 0.02522757f, 
    0.02066329f, -0.01532219f, -0.01354256f, -0.02721233f, -0.01457690f, -0.03455228f, -0.01873452f, -0.03223816f, 
    -0.03238489f, -0.03928006f, -0.02231379f, 0.02949872f, -0.02770140f, -0.02683452f, 0.00732710f, -0.01904375f, 
    0.00275445f, 0.01385456f, -0.03505107f, -0.02444698f, 0.01200080f, -0.03658424f, 0.01860929f, 0.02905499f, 
    0.02821737f, -0.02042261f, 0.00327080f, -0.00005624f, -0.03454424f, -0.03339852f, 0.02124691f, -0.02109485f, 
    0.02118938f, 0.00788269f, -0.02040525f, 0.02368822f, -0.00586638f, 0.01507813f, -0.00149622f, 0.01738475f, 
    -0.00508380f, -0.00794642f, -0.02180005f, -0.02619041f, -0.02255587f, 0.01579785f, -0.02921247f, -0.03684844f, 
    0.00566195f, -0.01720397f, -0.00804746f, -0.00359586f, -0.01016486f, -0.03383330f, -0.00400785f, -0.01556511f, 
    -0.02456293f, -0.02125681f, -0.03008001f, 0.00663334f, 0.01250989f, -0.02288855f, -0.02703916f, 0.01150345f, 
    0.02282328f, -0.03999379f, -0.01593352f, -0.02425813f, 0.02231257f, 0.00466243f, -0.01460196f, -0.03707444f, 
    -0.01364628f, -0.02202454f, 0.00997708f, -0.00297719f, -0.03039304f, -0.02000878f, -0.02141129f, 0.00237715f, 
    -0.03147983f, 0.02272778f, -0.01350167f, 0.00555787f, -0.03632620f, -0.03887341f, -0.01390723f, -0.03120399f, 
    -0.01266384f, 0.00768521f, -0.02949060f, -0.00817534f, -0.03653403f, 0.01972213f, -0.02080808f, -0.02402930f, 
    0.00234783f, -0.03635193f, -0.03769729f, 0.00387504f, -0.00217901f, -0.01390175f, 0.00575013f, -0.01954934f, 
    0.01826654f, -0.03848500f, -0.01290182f, 0.00700662f, -0.04115390f, -0.03973843f, -0.01131274f, -0.02462171f, 
    -0.02623560f, -0.00538722f, -0.03613044f, 0.00067485f, 0.01686484f, -0.01613426f, -0.01254045f, -0.03540901f, 
    -0.03611549f, -0.01449718f, 0.01545630f, -0.00184837f, -0.00997974f, -0.02519727f, 0.00461076f, -0.00803405f, 
    -0.01924862f, 0.01093626f, -0.02772165f, 0.02508325f, -0.01701003f, -0.03563495f, 0.02749005f, 0.00218561f, 
    0.02729331f, 0.02889870f, -0.02328018f, -0.02552425f, -0.01315072f, -0.00293391f, -0.03630408f, -0.03766090f, 
    -0.00176019f, -0.00120253f, 0.00865637f, -0.00443718f, 0.00638534f, -0.00774307f, -0.00465038f, -0.00259448f, 
    -0.03301623f, 0.00412142f, 0.02940942f, -0.03239113f, 0.02423159f, -0.02526837f, -0.02444410f, -0.00711158f, 
    -0.00515339f, 0.00934333f, 0.02320803f, 0.01789074f, 0.02039332f, -0.02613181f, 0.02043030f, -0.00496465f, 
    -0.00567443f, -0.01425795f, 0.01209581f, 0.01124386f, 0.00763792f, -0.01793236f, -0.02855508f, -0.00522058f, 
    0.00732647f, -0.00486214f, 0.02543464f, -0.02567885f, 0.00881548f, -0.01480239f, -0.03931126f, -0.04159982f, 
    -0.01449870f, 0.00455457f, -0.00389670f, -0.02619069f, 0.01478368f, -0.01987731f, 0.01763034f, -0.01546587f, 
    -0.03395171f, 0.01511723f, -0.01171885f, 0.01094932f, 0.00962803f, -0.02461147f, -0.02225758f, 0.02265584f, 
    0.01605746f, 0.00757709f, 0.02719977f, 0.00472796f, 0.00816222f, -0.02828396f, -0.02440035f, 0.01430983f, 
    -0.00953841f, 0.02107739f, 0.00445427f, -0.03600939f, -0.03703780f, -0.02626768f, -0.01640338f, -0.03430091f, 
    -0.01353180f, -0.01370931f, -0.02371285f, 0.00210537f, -0.01900545f, -0.03761011f, -0.00708902f, -0.03426530f, 
    -0.04155451f, 0.01739149f, -0.03210505f, -0.04003668f, -0.00976250f, 0.02780828f, 0.02411708f, -0.03020238f, 
    0.01082100f, 0.00745719f, 0.00239714f, -0.01937295f, 0.01189203f, 0.00877632f, -0.03784076f, -0.02448552f, 
    -0.00772031f, 0.01024003f, -0.02557394f, 0.00544671f, 0.00665025f, -0.01049275f, -0.01211273f, -0.01574237f, 
    0.00956747f, -0.04014985f, 0.00434026f, -0.03571840f, -0.00638436f, -0.00496433f, 0.01590468f, 0.02504725f, 
    -0.03581986f, 0.02211989f, -0.00496646f, 0.00751815f, 0.00072434f, 0.02896886f, 0.02773628f, -0.01609193f, 
    -0.03586092f, 0.01001091f, -0.03779057f, 0.02091462f, -0.00277535f, -0.01933122f, -0.03232204f, 0.02925957f, 
    0.00532292f, -0.04044609f, 0.01378965f, -0.02735496f, -0.01245872f, 0.01522655f, -0.00607550f, -0.01650866f, 
    0.00598733f, -0.00570894f, 0.01987528f, -0.01884081f, -0.03641468f, 0.02532985f, 0.01344948f, 0.02687027f, 
    -0.00930036f, -0.00197392f, -0.01120040f, -0.03405489f, 0.00095648f, 0.00974872f, -0.01381652f, -0.00009927f, 
    0.01346393f, -0.03923442f, 0.00531862f, -0.02416189f, -0.03909383f, -0.01648122f, -0.03535854f, 0.01008381f, 
    0.00454574f, 0.00075189f, -0.02663082f, 0.00461516f, 0.00100251f, 0.00366816f, -0.03282886f, 0.01762737f, 
    -0.01220713f, 0.00173219f, 0.00869829f, 0.00385170f, -0.01902928f, 0.02572063f, 0.02805110f, 0.01362277f, 
    -0.01148837f, 0.02384069f, 0.00396111f, -0.04143878f, 0.00363216f, -0.00698072f, 0.01602007f, 0.00961133f, 
    0.00287187f, 0.01985504f, 0.01743738f, -0.01392417f, -0.01996677f, 0.02662609f, 0.00853409f, -0.02150287f, 
    -0.00512346f, 0.02434158f, -0.01287027f, 0.02896909f, 0.00354345f, -0.00778539f, -0.00110001f, 0.01480111f, 
    -0.03696965f, 0.01001566f, -0.00299402f, -0.03969441f, -0.00493830f, 0.00090658f, 0.02545952f, 0.00848151f, 
    -0.00342763f, -0.02615173f, -0.02209738f, -0.02589853f, 0.02769959f, -0.01689403f, -0.02312066f, -0.03085705f, 
    0.00202394f, 0.00667896f, 0.00061927f, -0.01469243f, 0.00739561f, -0.02878931f, 0.02229192f, -0.03628182f, 
    0.01516344f, 0.02364025f, 0.01168759f, 0.02768312f, 0.00584935f, -0.00833128f, -0.02664927f, -0.03501502f, 
    -0.00845560f, -0.00834125f, -0.02807581f, -0.04170666f, -0.02668328f, 0.02922239f, -0.02420278f, 0.01634401f, 
    0.00553280f, -0.01959567f, -0.00731695f, -0.01631372f, 0.00227019f, -0.01171430f, -0.02456529f, -0.00518578f, 
    -0.00601311f, -0.00841052f, -0.02940026f, -0.00702678f, 0.00536951f, -0.02281206f, -0.02909073f, -0.03473275f, 
    -0.01615632f, -0.01705364f, -0.02485486f, -0.02392884f, -0.03104212f, 0.02475440f, 0.01672246f, -0.03098938f, 
    0.01614691f, -0.03086940f, -0.00133161f, -0.01406400f, -0.02303673f, -0.03679134f, 0.02753399f, 0.01256213f, 
    -0.04087841f, -0.04107764f, -0.02301249f, -0.00744392f, -0.02976154f, -0.02230303f, -0.01862152f, 0.01766690f, 
    -0.02322597f, 0.02283930f, 0.01943354f, 0.01388949f, 0.01581463f, 0.02240768f, -0.02912884f, 0.00294386f, 
    -0.01198530f, -0.01171936f, 0.00957387f, -0.02687917f, 0.01922058f, 0.02880780f, -0.03106814f, -0.01339896f, 
    0.02042652f, 0.01708782f, -0.02332553f, -0.01276919f, -0.00269785f, -0.03331743f, 0.00585285f, -0.01352206f, 
    -0.01783915f, 0.00286682f, 0.00378721f, -0.03750895f, 0.01729468f, 0.02377751f, -0.04066853f, 0.00997199f, 
    -0.00632404f, -0.01440898f, -0.00610871f, 0.02906748f, -0.03410982f, -0.03316772f, 0.01771977f, 0.02929386f, 
    -0.03468561f, -0.01085228f, -0.03067022f, 0.01743093f, 0.00219973f, -0.02948727f, 0.02312860f, 0.01202169f, 
    -0.03787395f, -0.03246702f, -0.04058170f, 0.01121654f, -0.03167680f, -0.03190072f, -0.01649661f, -0.02554509f, 
    -0.01168429f, 0.01341091f, -0.00454273f, 0.00990024f, 0.02623905f, 0.00498978f, -0.00240610f, -0.00996117f, 
    -0.03667547f, 0.02260290f, -0.02060401f, -0.00591747f, 0.00175566f, -0.00452991f, 0.01201536f, 0.02630363f, 
    -0.01794228f, 0.01845742f, -0.03131028f, 0.01833828f, -0.00629334f, -0.04190415f, 0.00493548f, -0.01433037f, 
    0.02559559f, -0.00967635f, 0.00811000f, -0.01560551f, -0.03497315f, -0.02645552f, -0.02741702f, 0.02297575f, 
    -0.03003796f, 0.01124338f, -0.00467497f, -0.00642999f, -0.01632196f, -0.01632799f, -0.01471836f, 0.01766325f, 
    0.01712724f, 0.02401996f, -0.00106879f, 0.02806680f, 0.01942474f, -0.01894678f, -0.02426940f, -0.03138142f, 
    -0.01525335f, 0.00363811f, 0.00894522f, -0.03086640f, 0.00374103f, -0.02902460f, 0.02476147f, 0.00838787f, 
    0.01554399f, 0.01214092f, 0.01531589f, -0.02300185f, -0.01760612f, -0.01980627f, 0.02812289f, 0.02822579f, 
    -0.01197951f, 0.00565949f, -0.00081578f, -0.00996951f, -0.02863151f, -0.00634694f, 0.01166578f, 0.02331074f, 
    0.00720140f, 0.01169077f, 0.01746387f, 0.00550703f, 0.00721322f, 0.01107714f, -0.03725540f, 0.02680482f, 
    -0.00956476f, -0.03808015f, 0.02075452f, -0.01519880f, -0.00283846f, 0.02567404f, -0.02833285f, -0.00452113f, 
    -0.02874591f, -0.00131300f, 0.01472688f, -0.01677979f, -0.02000631f, -0.03643523f, -0.00669413f, 0.00427830f, 
    -0.01498815f, 0.02048141f, 0.02025373f, -0.00311485f, 0.02683481f, -0.01493807f, -0.02351650f, 0.02490489f, 
    0.01014881f, 0.01633127f, 0.02575488f, 0.02726159f, 0.02297793f, -0.01828381f, 0.00991995f, 0.02727152f, 
    -0.01371371f, -0.02075191f, 0.01550759f, 0.00512913f, 0.00664049f, -0.03823296f, -0.02180571f, -0.00945959f, 
    0.00134878f, -0.00110025f, -0.01100904f, 0.00790973f, -0.00532140f, -0.00280832f, 0.02494203f, -0.00731511f, 
    -0.01747402f, 0.00154952f, -0.02469324f, -0.02389321f, -0.00734244f, 0.02229079f, 0.01721586f, 0.01724008f, 
    -0.01969085f, 0.00832308f, -0.01775553f, -0.03864236f, 0.00912502f, -0.01155408f, -0.00466826f, -0.00432987f, 
    -0.02847502f, -0.03843055f, -0.03653552f, 0.02251589f, -0.01624016f, -0.00459501f, -0.04031519f, 0.01526084f, 
    0.01648276f, -0.03944251f, -0.03830687f, -0.00723336f, 0.00098787f, 0.00587109f, 0.00731348f, -0.02541100f, 
    -0.02202531f, -0.01193060f, 0.01520354f, 0.01292239f, -0.02829359f, -0.00189495f, 0.02981983f, 0.00504195f, 
    0.01602826f, 0.00186214f, -0.01397022f, 0.02324876f, 0.02918538f, -0.03183643f, -0.01818644f, -0.02168350f, 
    -0.00738425f, 0.02714362f, -0.01134279f, 0.01795672f, 0.01702004f, -0.01658013f, -0.02215439f, -0.00732221f, 
    -0.00924009f, -0.04060904f, -0.00249573f, -0.02884831f, -0.00282805f, -0.00764026f, -0.02211207f, -0.03802796f, 
    -0.02231077f, 0.00055700f, 0.00042497f, -0.01016940f, 0.02630616f, 0.02516282f, 0.00221747f, -0.01607031f, 
    0.02179588f, -0.03259909f, -0.02199891f, -0.02486076f, 0.00115135f, -0.04149370f, -0.00826188f, -0.00174106f, 
    0.00051059f, 0.00647355f, -0.02518922f, -0.00528146f, 0.02691944f, -0.03982322f, -0.01986221f, -0.03823393f, 
    0.00093572f, -0.03464221f, -0.02307487f, 0.01380833f, 0.01907642f, -0.01076327f, -0.02012033f, 0.02728164f, 
    0.00654856f, 0.00245948f, -0.00824710f, -0.00105148f, -0.00050652f, 0.01043609f, -0.03529291f, 0.01632950f, 
    -0.01065459f, -0.00326547f, 0.02195306f, 0.00105611f, 0.01995747f, 0.00199881f, -0.04192814f, 0.02751690f, 
    -0.03110241f, -0.00164429f, 0.00552170f, -0.03689228f, -0.03931075f, 0.00042622f, -0.03463109f, -0.01297128f, 
    -0.02342478f, 0.01926376f, -0.01345827f, -0.01942364f, 0.01003175f, 0.00627954f, 0.00626023f, -0.03225157f, 
    -0.03982610f, 0.00323952f, 0.02143604f, -0.03763425f, -0.02418395f, 0.02289159f, -0.02422776f, 0.02579165f, 
    -0.00130752f, -0.03044152f, -0.03462269f, 0.00919887f, 0.00502269f, 0.02162903f, 0.01520608f, 0.02755477f, 
    -0.03619573f, -0.03482688f, 0.02006873f, -0.03790408f, 0.02784778f, 0.01797889f, 0.02036980f, 0.01170202f, 
    0.02195460f, -0.01980296f, 0.02801584f, 0.02315886f, -0.03256410f, -0.02736809f, -0.02957464f, -0.00856514f, 
    -0.04013842f, 0.02358696f, 0.02900719f, -0.01874361f, -0.03595122f, -0.02450887f, -0.01010590f, 0.01683507f, 
    -0.04137216f, 0.00229624f, 0.01835377f, 0.00523289f, -0.04165114f, -0.02363030f, -0.00808023f, 0.00582722f, 
    0.00065511f, -0.04031502f, -0.01394152f, -0.00721595f, -0.01666234f, 0.00195191f, -0.02407916f, 0.02952695f, 
    0.00594752f, -0.01413540f, -0.01140773f, -0.03855302f, -0.04164149f, -0.00587446f, 0.02674842f, 0.02306138f, 
    0.00257005f, -0.00456535f, -0.02752748f, 0.02113285f, 0.02351054f, -0.03522777f, -0.01052222f, 0.02388053f, 
    0.02450864f, -0.01001009f, -0.04077323f, -0.02510238f, 0.02712066f, 0.01404605f, -0.00245184f, 0.02334806f, 
    0.01992411f, -0.00962043f, -0.02563879f, -0.00839733f, 0.02716149f, -0.00743250f, -0.03386557f, 0.00648394f, 
    0.02489406f, 0.02940081f, -0.01469651f, -0.01113083f, -0.00964227f, -0.04321217f, -0.01603503f, 0.01840554f, 
    0.01444787f, -0.00368363f, -0.01234643f, -0.00823676f, -0.01125032f, -0.00365413f, 0.02536952f, 0.00564309f, 
    0.02379832f, 0.00423917f, 0.02358289f, -0.00711734f, -0.02005884f, -0.00025270f, -0.00882375f, 0.01603109f, 
    0.00515090f, 0.00773182f, -0.00374364f, -0.00397705f, -0.03363663f, -0.00012055f, -0.03131672f, 0.02032120f, 
    0.02015948f, -0.03387999f, -0.02741404f, -0.03344743f, -0.03134200f, -0.00271559f, 0.01145529f, -0.00984117f, 
    -0.03031374f, -0.01821334f, -0.00723447f, -0.00493863f, -0.01883257f, -0.02648796f, 0.01598677f, -0.01038076f, 
    0.01108340f, 0.00252128f, -0.03748781f, -0.01660644f, 0.01347761f, 0.01234871f, -0.02663409f, -0.02328316f, 
    0.00821501f, 0.02095647f, -0.03617986f, -0.03573864f, -0.02529581f, -0.01696317f, -0.03154352f, -0.02039417f, 
    0.00612866f, 0.00208075f, 0.02954675f, -0.02594837f, 0.01849301f, 0.02560001f, -0.03969676f, 0.02843989f, 
    0.01920489f, 0.01107100f, -0.01026836f, -0.00324434f, 0.02999067f, 0.01086814f, -0.02582302f, 0.02159371f, 
    0.01952414f, 0.03528513f, -0.02786309f, -0.03164803f, -0.01009985f, -0.01031473f, 0.02839851f, -0.02641598f, 
    0.03876811f, -0.01638466f, 0.03775392f, -0.01119582f, -0.02582865f, 0.01253135f, -0.03505605f, -0.01134918f, 
    -0.01354710f, 0.03124952f, 0.00821137f, -0.00527984f, 0.01572772f, 0.00507036f, 0.03071795f, 0.00646745f, 
    -0.00337830f, -0.00327481f, 0.02754083f, -0.00438521f, -0.02720379f, 0.01727384f, -0.01350034f, -0.01076197f, 
    -0.01552700f, -0.02159483f, 0.03033118f, -0.03264413f, -0.00831293f, -0.02349146f, 0.01530435f, 0.02078822f, 
    -0.00430674f, -0.01675619f, -0.00808061f, 0.01195888f, 0.01513686f, 0.00921527f, 0.03812718f, 0.01794217f, 
    0.00620664f, -0.01923592f, -0.00360499f, -0.02206577f, 0.02726608f, 0.01728375f, 0.01820897f, 0.02760930f, 
    -0.00341765f, -0.01782896f, -0.01390374f, -0.03409643f, -0.01022905f, -0.02002967f, -0.03588226f, 0.02869441f, 
    -0.02264419f, 0.03896329f, 0.02496552f, -0.03913627f, -0.01876519f, 0.00437882f, -0.02262652f, -0.00970474f, 
    -0.00564703f, 0.02092692f, -0.02236596f, 0.01629030f, -0.02435683f, 0.00649097f, -0.00942495f, -0.01591305f, 
    -0.01298261f, -0.03776294f, -0.00453373f, 0.02343220f, 0.00168810f, -0.03745954f, -0.00540664f, -0.03287230f, 
    -0.01966822f, -0.01102169f, -0.02406254f, 0.00110339f, -0.04053433f, 0.02987336f, 0.03483740f, 0.00153180f, 
    0.02813538f, 0.02391673f, -0.00352594f, -0.02884735f, 0.01739949f, -0.00505801f, -0.00723378f, 0.01174322f, 
    0.01547478f, -0.01111518f, 0.00906486f, -0.00113497f, 0.02044947f, -0.01883356f, -0.01622205f, 0.00014513f, 
    -0.00290704f, 0.00852138f, -0.00820320f, 0.00000488f, 0.01383463f, 0.01141803f, -0.01341898f, -0.02416367f, 
    -0.03246283f, 0.01794829f, -0.01764613f, -0.04070820f, -0.03097696f, -0.00258978f, 0.01077819f, -0.02278229f, 
    0.00921438f, -0.03922066f, 0.03333338f, -0.00140588f, -0.03309010f, -0.03720025f, -0.02191573f, -0.03098819f, 
    -0.01297312f, 0.01906534f, 0.00091788f, -0.03025081f, -0.00724864f, -0.00486652f, 0.00068088f, -0.02557188f, 
    -0.02055729f, -0.02737692f, -0.00855624f, -0.03499774f, -0.01795407f, 0.00313542f, 0.03302880f, 0.00869133f, 
    -0.00127702f, -0.02535204f, -0.01033812f, 0.01561271f, -0.02036503f, -0.03299178f, -0.02059669f, -0.03813744f, 
    -0.00908586f, 0.02702473f, 0.01168135f, -0.03182588f, -0.02330617f, -0.03207504f, -0.00863960f, -0.03817945f, 
    0.01547325f, 0.02001972f, -0.02204644f, -0.04128366f, -0.00772303f, -0.02108994f, -0.00689760f, 0.00786505f, 
    -0.04269825f, 0.01812851f, -0.01112485f, 0.02268595f, -0.03076602f, -0.01362458f, -0.02916359f, -0.02884906f, 
    -0.02208453f, 0.00750446f, 0.02402717f, 0.00870950f, -0.00373889f, -0.02346169f, 0.01663432f, -0.00793792f, 
    -0.00417224f, -0.00031819f, -0.00284379f, 0.00786904f, 0.00271373f, -0.00745310f, 0.02774947f, 0.02957440f, 
    -0.00807875f, -0.00603035f, -0.02410215f, -0.00910081f, -0.02319779f, 0.00361470f, -0.02913494f, -0.03068607f, 
    -0.02518340f, 0.00528358f, -0.02349042f, -0.03310019f, 0.01211044f, 0.01444433f, 0.02104576f, -0.01551053f, 
    -0.00065912f, -0.02827510f, 0.01815295f, -0.00895139f, 0.02612105f, 0.02938183f, -0.03145165f, -0.03536220f, 
    -0.00417832f, -0.02519041f, 0.00943064f, 0.02258604f, 0.00845684f, -0.00731778f, 0.03724298f, -0.01865085f, 
    -0.03599722f, 0.00288574f, 0.01670531f, 0.00822571f, -0.01363878f, 0.00784003f, -0.01479189f, 0.02067424f, 
    0.00266937f, 0.01981007f, -0.01111889f, 0.02288605f, -0.01688789f, -0.03008999f, 0.02515791f, -0.03194813f, 
    -0.01400206f, -0.01206454f, 0.01050071f, 0.02611599f, -0.01499988f, -0.02564748f, 0.02742308f, 0.03665648f, 
    0.01557702f, 0.02058689f, 0.01120872f, 0.02109619f, -0.04387486f, 0.00062529f, 0.02462139f, -0.01381206f, 
    -0.03600786f, -0.00352275f, 0.00425653f, 0.00414471f, 0.02290205f, 0.02636944f, 0.01973734f, -0.02720984f, 
    -0.02975151f, -0.02716771f, -0.02986729f, 0.02259260f, 0.02439671f, -0.01995566f, 0.00918415f, 0.02483676f, 
    -0.00492294f, -0.03976788f, -0.03800075f, 0.02639382f, -0.03407077f, -0.03480572f, -0.03100353f, -0.02463447f, 
    -0.02175722f, -0.00089899f, 0.01315622f, -0.02847677f, 0.01101895f, 0.02403821f, 0.01863387f, 0.00246144f, 
    -0.00328972f, 0.02224857f, -0.00738282f, -0.03532572f, 0.02758140f, -0.02347014f, -0.00386937f, 0.00406026f, 
    0.00583556f, -0.03042093f, -0.02267020f, -0.03512682f, 0.00332877f, -0.00659910f, -0.01279944f, -0.02859368f, 
    -0.01270593f, 0.01964583f, -0.02116801f, -0.03601533f, -0.04026812f, 0.02702818f, -0.03765158f, 0.03096930f, 
    -0.00175555f, -0.03047748f, 0.02586110f, -0.03006442f, -0.01986112f, -0.02227703f, -0.01403823f, 0.01340133f, 
    0.02306599f, 0.02354553f, -0.02688894f, -0.01173292f, -0.00665427f, 0.00907666f, 0.02492854f, 0.02206525f, 
    -0.01672336f, 0.00785604f, -0.02886372f, 0.01308463f, 0.03114386f, -0.01235792f, -0.02000655f, 0.00545565f, 
    0.02152849f, 0.01144112f, -0.01032009f, -0.00718868f, 0.02088835f, -0.02568267f, 0.02905009f, 0.00861884f, 
    0.00422715f, -0.01911455f, -0.00054094f, 0.02054535f, -0.03743103f, -0.00492694f, 0.00692407f, 0.00735814f, 
    -0.01612773f, -0.00890258f, -0.03406798f, -0.00380101f, 0.01195798f, -0.00113401f, -0.03271271f, 0.00636150f, 
    0.00113010f, -0.01090214f, 0.00803451f, -0.01639806f, 0.00581433f, -0.01449176f, -0.02123249f, -0.04103582f, 
    0.01264519f, 0.02614408f, 0.01413397f, 0.01414004f, 0.03184117f, -0.02430849f, 0.02257277f, 0.00997813f, 
    -0.02852734f, -0.03703339f, 0.00980761f, -0.00796724f, -0.00604181f, -0.00308375f, -0.00002670f, 0.02673153f, 
    -0.01828726f, -0.03210469f, 0.00897067f, -0.00670388f, -0.02398258f, -0.01163425f, -0.01872589f, 0.00471876f, 
    -0.02951526f, 0.02513964f, 0.01186234f, -0.03412192f, -0.01728206f, -0.01118735f, -0.01350932f, -0.03290763f, 
    0.00717799f, -0.03983420f, -0.03157988f, 0.00738014f, 0.01196986f, -0.02350596f, -0.04159267f, 0.00608428f, 
    0.02926678f, -0.02263669f, -0.02380650f, 0.01834184f, -0.02865734f, 0.01299599f, -0.01036683f, -0.00811878f, 
    -0.01608590f, -0.01877340f, 0.00478648f, 0.00041349f, 0.01922081f, 0.01364634f, -0.01892887f, 0.01198567f, 
    -0.02339270f, -0.02086702f, -0.00275316f, 0.00848716f, 0.02714973f, 0.02504604f, -0.00076857f, 0.02531605f, 
    -0.00047414f, -0.03477075f, -0.00213771f, -0.00868395f, 0.01840969f, -0.01847871f, -0.02956648f, 0.01109377f, 
    -0.04049163f, -0.02270239f, 0.00875319f, -0.03346910f, -0.01147916f, -0.00439138f, 0.00836760f, 0.03522496f, 
    -0.01642288f, -0.03766603f, 0.02227219f, -0.01135043f, -0.01099168f, 0.02616838f, -0.01179266f, 0.00317081f, 
    -0.00303477f, -0.01166341f, -0.01010871f, -0.00646053f, -0.01045102f, 0.02154509f, -0.02325327f, 0.00490858f, 
    -0.02876836f, -0.02046474f, 0.02180164f, 0.01402161f, -0.00038451f, 0.00832209f, -0.01990885f, 0.00138996f, 
    0.02624462f, -0.00661824f, -0.03676077f, -0.01748328f, 0.00327332f, -0.01354100f, -0.01789897f, -0.03028352f, 
    0.03017386f, -0.03028939f, -0.01145691f, -0.02774478f, -0.03401736f, -0.00020762f, -0.03087110f, -0.01874984f, 
    -0.02519271f, -0.01403168f, -0.03802345f, -0.00346566f, 0.01399513f, -0.03478489f, 0.02130200f, -0.00847186f, 
    0.02945785f, -0.02893311f, 0.00201298f, 0.03049834f, 0.01453116f, -0.03406543f, -0.03512416f, -0.02951695f, 
    -0.01505390f, 0.00381810f, 0.02753297f, 0.02395585f, -0.02572363f, 0.02662301f, 0.01165624f, 0.02331340f, 
    -0.01207856f, -0.02993311f, -0.02826534f, -0.02233339f, -0.01895423f, 0.01904417f, 0.00320149f, 0.02340946f, 
    0.01302388f, -0.02565749f, -0.02330345f, 0.00012838f, 0.01253281f, 0.02665440f, -0.02693333f, -0.00347251f, 
    0.02397767f, -0.01535001f, -0.01188039f, -0.00505046f, 0.00609779f, 0.00044461f, -0.00776285f, -0.00665962f, 
    0.00336480f, 0.00359210f, 0.00993209f, -0.03609053f, -0.01594787f, -0.02148221f, -0.00361467f, -0.02857774f, 
    -0.03680998f, -0.00138380f, 0.00323511f, 0.02650805f, 0.00215599f, -0.03675820f, -0.02009399f, 0.01498200f, 
    -0.03342061f, 0.03110839f, 0.02129504f, -0.01529027f, 0.02344140f, -0.00682556f, 0.01468959f, -0.00268932f, 
    -0.02288196f, -0.02088112f, -0.01693353f, 0.01524076f, -0.03015624f, -0.00858813f, 0.00720697f, -0.03061034f, 
    -0.02069763f, 0.02913322f, 0.02465038f, -0.01644119f, 0.00715816f, -0.00065160f, -0.01404930f, -0.03556043f, 
    0.01828419f, -0.03232698f, 0.02252368f, 0.01727351f, 0.03595478f, -0.02841775f, -0.02875060f, 0.00270049f, 
    0.00836808f, -0.00210293f, -0.01950329f, -0.00316473f, -0.03172546f, 0.00784017f, -0.01554463f, -0.02287107f, 
    0.01030053f, -0.01276611f, -0.03596497f, 0.02504177f, 0.00143008f, -0.00894223f, -0.00674041f, -0.00811656f, 
    -0.01502915f, 0.02162172f, 0.01973864f, -0.03955250f, -0.04143310f, 0.01426392f, 0.01905222f, -0.00134837f, 
    0.00813227f, 0.03002545f, -0.01888791f, 0.01748804f, -0.02799223f, 0.00684043f, 0.00008104f, -0.01396926f, 
    -0.01360083f, -0.00100753f, -0.02242763f, 0.00505618f, 0.03000812f, 0.01059353f, -0.02748746f, -0.00687035f, 
    -0.03233046f, -0.02732425f, -0.02580017f, 0.02988842f, -0.00632478f, -0.00357947f, 0.01845463f, -0.02026100f, 
    -0.03094740f, -0.02277347f, -0.02569834f, -0.01772858f, -0.01072819f, -0.04203419f, 0.00512960f, 0.02844655f, 
    0.01345623f, -0.01992027f, -0.02504429f, -0.04051316f, 0.00340744f, -0.02703422f, -0.01609465f, -0.02987414f, 
    0.02417694f, -0.00499165f, 0.01331375f, -0.00604504f, 0.01292151f, 0.00426004f, 0.02116023f, 0.02740877f, 
    -0.03975522f, -0.03049154f, -0.00706167f, -0.03777175f, -0.03767747f, 0.01024195f, 0.02507559f, -0.00380000f, 
    0.00442730f, -0.00356185f, -0.01524861f, 0.03197662f, -0.00242063f, 0.00640229f, 0.00469414f, 0.02576776f, 
    -0.01446658f, -0.03524412f, -0.01513737f, -0.02159711f, -0.00666115f, -0.00959296f, 0.00412763f, -0.02847482f, 
    0.02668948f, 0.00181854f, -0.03567250f, 0.00119389f, -0.03968338f, -0.03531973f, 0.01136194f, -0.03531280f, 
    -0.03231029f, -0.03611009f, -0.00704553f, -0.01193270f, -0.00044276f, -0.01587352f, 0.02071583f, 0.01296457f, 
    0.00661122f, 0.01136515f, -0.00956841f, -0.02967546f, -0.00995791f, -0.02945871f, -0.04355713f, -0.00033407f, 
    0.03162979f, -0.02801315f, 0.00918791f, 0.01748168f, -0.03641454f, -0.00958353f, -0.02889096f, 0.00197241f, 
    -0.03327604f, 0.03339291f, -0.01332030f, -0.02308081f, 0.02810188f, -0.00227225f, 0.01513992f, -0.00580849f, 
    -0.02891460f, -0.00607379f, -0.00563659f, 0.01603063f, 0.02546258f, -0.01444187f, 0.03451306f, 0.00245248f, 
    -0.03461897f, 0.02253720f, -0.02592493f, -0.02633959f, 0.01212202f, -0.00744999f, -0.01774384f, -0.02002106f, 
    0.03155359f, -0.01148413f, 0.00254245f, -0.04159195f, -0.00451376f, -0.02300735f, 0.02388245f, -0.00445392f, 
    -0.00776592f, 0.00760740f, 0.01373765f, 0.00314310f, -0.01070090f, -0.03417921f, 0.01462043f, 0.00748765f, 
    -0.02419950f, -0.02887931f, 0.01683153f, -0.03025071f, -0.01742654f, -0.00391685f, -0.01978338f, -0.03258121f, 
    -0.02957533f, -0.04277209f, 0.02169233f, 0.01806033f, 0.02713664f, 0.01460842f, 0.02205621f, -0.02765553f, 
    -0.00472466f, -0.01733768f, 0.01577199f, 0.00634569f, 0.03437912f, -0.02869906f, -0.01733934f, -0.03133072f, 
    0.01312704f, 0.01663988f, 0.03251075f, 0.01304306f, -0.02524161f, -0.00523427f, 0.00523260f, 0.02711158f, 
    0.01922778f, -0.00810967f, 0.00514151f, -0.04148202f, -0.03679227f, -0.02180295f, 0.00652030f, -0.00926298f, 
    -0.00880281f, 0.01907362f, 0.01162377f, -0.02865454f, -0.00348145f, 0.01117895f, -0.02496487f, 0.03687795f, 
    -0.02331488f, 0.02701848f, 0.02253601f, 0.02647652f, -0.01069243f, -0.03433603f, -0.04241944f, 0.01988719f, 
    -0.00822078f, -0.03305738f, -0.00288503f, -0.01580288f, -0.02644666f, 0.00731452f, -0.01978102f, -0.01791970f, 
    -0.00642958f, -0.02305622f, -0.02948500f, 0.01640929f, 0.01906855f, 0.00901440f, -0.01855513f, -0.01430393f, 
    -0.00382555f, 0.01257647f, 0.02362442f, 0.01970865f, 0.02013463f, -0.00062540f, 0.02157850f, -0.00692725f, 
    -0.00307002f, 0.01667962f, -0.02258590f, 0.01440929f, -0.04089428f, -0.01878604f, -0.03112108f, 0.03541673f, 
    0.01202925f, -0.02333552f, -0.03323113f, -0.04278668f, 0.01715329f, 0.01656336f, -0.02983871f, 0.00273427f, 
    0.00827860f, -0.00157932f, 0.01231436f, 0.00310660f, -0.02998665f, -0.01397788f, -0.02376204f, -0.02085483f, 
    -0.01360548f, 0.02285681f, -0.00886044f, -0.00870612f, -0.03971185f, 0.02396544f, -0.03474736f, 0.01511592f, 
    0.02867796f, -0.02871400f, -0.00743044f, -0.04394207f, -0.04415471f, 0.01962285f, -0.00442231f, -0.00748596f, 
    0.00727747f, -0.01705742f, -0.02515953f, 0.02241617f, 0.01476695f, -0.00792175f, -0.00689500f, -0.00177251f, 
    -0.01345758f, 0.01468073f, -0.01839089f, -0.03416402f, 0.00458490f, 0.00252998f, -0.02825151f, -0.00184654f, 
    0.01530254f, -0.00356419f, 0.00695009f, 0.00914486f, 0.00086258f, -0.00089595f, -0.04405490f, 0.02661705f, 
    -0.03429862f, -0.03951081f, -0.00492206f, -0.02676630f, 0.02392755f, -0.04285945f, -0.03314288f, -0.03487932f, 
    -0.01644524f, -0.03277450f, 0.00905510f, -0.00679630f, -0.00245522f, -0.01368858f, 0.00751206f, -0.04361508f, 
    -0.00449320f, -0.02818175f, -0.01303481f, -0.01769519f, -0.02008365f, 0.00212232f, 0.01836077f, -0.03063953f, 
    -0.02264858f, -0.00469692f, 0.01657298f, 0.03503605f, 0.00237077f, -0.00681377f, -0.03706056f, -0.03755027f, 
    0.01957453f, 0.00377343f, 0.01591450f, -0.02811177f, 0.02267450f, -0.00966794f, -0.01056409f, -0.02928030f, 
    0.01129412f, -0.03244661f, 0.02636111f, -0.03072027f, -0.02033213f, 0.01373546f, -0.03126276f, -0.03562774f, 
    0.00441095f, 0.00062381f, 0.01133266f, 0.01363730f, 0.01258264f, 0.00411301f, -0.04526237f, 0.00855764f, 
    0.01333083f, -0.01153868f, 0.00884018f, 0.03564087f, -0.02661876f, -0.02240141f, -0.03197439f, 0.02207372f, 
    -0.00652371f, 0.02739622f, 0.00018076f, 0.03184131f, -0.04379749f, -0.03434457f, -0.03135505f, 0.01672584f, 
    -0.02055722f, -0.03361102f, 0.00496533f, -0.01134225f, -0.03805950f, -0.00495737f, 0.01618759f, -0.02129078f, 
    -0.03072105f, 0.01429242f, -0.01754964f, -0.01993565f, -0.01363929f, -0.01042214f, -0.02596673f, 0.00612392f, 
    0.00128410f, -0.00821829f, -0.01763822f, -0.01174882f, -0.01593686f, 0.03417137f, -0.01910775f, 0.01008707f, 
    -0.02892377f, 0.01649265f, -0.02497670f, -0.02304275f, 0.02117596f, 0.02862928f, -0.00032945f, -0.04196573f, 
    0.00588785f, 0.03460262f, -0.02217023f, -0.00053669f, -0.00520889f, 0.01937388f, 0.00903520f, -0.00742451f, 
    -0.01460528f, -0.00780589f, -0.01190371f, 0.00904234f, 0.00644123f, 0.01573634f, -0.01022390f, -0.04343167f, 
    -0.04090501f, 0.03009366f, -0.03755095f, 0.00970157f, -0.00569035f, -0.01240263f, 0.02894111f, -0.01645816f, 
    0.00303244f, 0.02369343f, 0.01193941f, -0.00298946f, -0.04235596f, 0.02188930f, -0.02683213f, -0.02931806f, 
    -0.00078822f, 0.00964202f, 0.01020645f, -0.00017158f, 0.00830211f, -0.04080584f, -0.00468727f, -0.02282469f, 
    -0.00548922f, -0.00430748f, -0.00801612f, 0.00336771f, -0.01866271f, -0.02798849f, -0.03209604f, -0.02657266f, 
    -0.02097391f, -0.00883050f, 0.02300253f, 0.01354914f, 0.00961242f, 0.01967652f, -0.00674732f, -0.03702050f, 
    0.00755953f, -0.02743201f, 0.01645342f, -0.00598778f, -0.02944090f, 0.00942342f, 0.00863924f, -0.03279760f, 
    0.03085066f, -0.02341603f, -0.00070266f, -0.02945749f, -0.01008058f, -0.04426954f, 0.00312417f, -0.00689670f, 
    0.02606981f, 0.02823585f, 0.02508535f, 0.03017535f, -0.01309648f, 0.01024588f, -0.03685609f, 0.02027373f, 
    0.00297197f, 0.01930118f, 0.01372915f, 0.02199075f, -0.01245444f, 0.00884356f, -0.02962862f, 0.00093696f, 
    -0.02069084f, -0.00240254f, 0.02142314f, 0.01673245f, 0.00327813f, 0.01331290f, -0.01340258f, 0.02164549f, 
    -0.00081394f, 0.01088235f, -0.04132605f, -0.00264830f, 0.01180501f, -0.03198583f, -0.04287934f, -0.01725520f, 
    -0.01640208f, -0.03803569f, 0.02443915f, -0.02526158f, 0.00011800f, -0.01465707f, -0.02407905f, 0.01710158f, 
    0.00129908f, -0.01190767f, -0.04102713f, 0.03349977f, 0.02632947f, 0.01591387f, 0.00343321f, 0.01328429f, 
    -0.03511667f, -0.00596969f, 0.02430704f, -0.03656290f, -0.03372922f, -0.02190131f, 0.02841030f, -0.03242400f, 
    -0.01286757f, 0.02706333f, -0.01891314f, -0.03378769f, 0.01393392f, -0.00501216f, -0.03984722f, 0.02405844f, 
    0.02753052f, 0.02339176f, -0.00165025f, -0.01592349f, -0.03086293f, -0.01210489f, -0.02157383f, -0.00665042f, 
    -0.01716237f, 0.00577122f, 0.00040660f, 0.01698896f, -0.00410799f, 0.00158816f, -0.03537894f, 0.01485849f, 
    -0.01056715f, -0.01175724f, -0.03740878f, -0.00340186f, -0.00907321f, -0.00082737f, 0.02318398f, 0.00880148f, 
    -0.03469256f, -0.03986461f, 0.02783447f, 0.02616131f, 0.01819435f, 0.00081214f, 0.02269631f, -0.00663103f, 
    0.02301172f, 0.02788979f, -0.00172067f, 0.01735452f, -0.01264293f, -0.01543070f, -0.00933489f, 0.02643564f, 
    -0.00041290f, 0.02097275f, -0.02452439f, -0.03218359f, -0.03375479f, -0.01870476f, -0.01220452f, -0.02685211f, 
    0.03681706f, -0.01450643f, 0.01699107f, -0.01363613f, -0.01868347f, 0.00420291f, -0.02676838f, 0.00844985f, 
    0.03633028f, 0.02326543f, 0.02524013f, -0.03937756f, 0.01215788f, -0.03755299f, 0.01145085f, -0.02915180f, 
    0.01489329f, -0.02998899f, -0.03116129f, 0.00373074f, 0.01111006f, -0.02073514f, 0.01235353f, -0.00209116f, 
    0.00300102f, 0.01445124f, -0.01681419f, 0.02426923f, -0.03604991f, 0.00907427f, -0.00719309f, 0.00155632f, 
    -0.03308819f, -0.02190454f, 0.02609086f, 0.01052114f, -0.02973530f, -0.02301327f, 0.00353946f, 0.00636014f, 
    0.02185508f, 0.02818937f, -0.00940881f, -0.01763444f, 0.02794522f, -0.02878308f, -0.00409858f, -0.02196619f, 
    0.00252118f, -0.04275360f, -0.00699741f, 0.01906171f, 0.01997659f, -0.00782803f, -0.01491816f, -0.00969477f, 
    0.01288643f, 0.02444170f, 0.02572340f, -0.01172579f, -0.00548500f, 0.01655973f, 0.02120087f, 0.02463399f, 
    -0.03127167f, 0.01326962f, -0.03712376f, -0.02338623f, -0.00225249f, -0.01565872f, 0.01132792f, -0.01096858f, 
    -0.01442023f, 0.00196434f, 0.00900023f, -0.00269446f, 0.02181178f, -0.01179307f, 0.03361826f, -0.01115551f, 
    0.01703728f, 0.01238833f, -0.04290397f, 0.00668479f, 0.01454371f, -0.01267172f, 0.00256843f, 0.01919631f, 
    0.00891201f, 0.00802373f, -0.02688498f, -0.01681970f, -0.01844089f, -0.00023141f, -0.04167353f, -0.04358003f, 
    -0.03179498f, -0.02616877f, 0.00731111f, -0.03509827f, -0.01300737f, -0.03964394f, 0.02670670f, -0.00674145f, 
    -0.01958432f, 0.02982301f, 0.01845842f, -0.02215574f, -0.02105908f, -0.03095752f, 0.03000915f, 0.00257150f, 
    0.01427547f, 0.00161541f, 0.03321088f, -0.02845721f, 0.00033437f, 0.01997165f, -0.01483176f, 0.03094811f, 
    0.00506098f, 0.00420314f, 0.00719677f, 0.01177583f, -0.02293378f, -0.00075409f, -0.01998631f, -0.02104987f, 
    -0.02993223f, 0.01315626f, 0.03652834f, -0.02533902f, -0.01761247f, -0.04176312f, 0.03081863f, -0.00880531f, 
    -0.03746686f, -0.03993554f, -0.00219372f, -0.03763887f, 0.00724936f, 0.01164936f, -0.03605405f, 0.01883425f, 
    -0.01219387f, 0.00361035f, -0.00625431f, -0.02518127f, -0.02919930f, 0.01878705f, -0.03889985f, -0.02218791f, 
    0.00270891f, -0.00133362f, 0.02178822f, 0.01634113f, -0.02226679f, 0.01563981f, -0.03061289f, 0.02123614f, 
    -0.04494512f, -0.01135876f, -0.02895003f, -0.02370741f, 0.01006187f, -0.00295621f, -0.02178390f, -0.00800764f, 
    0.02841851f, -0.03003730f, -0.03402733f, 0.02018821f, -0.04282523f, 0.02417487f, -0.00566594f, -0.02358228f, 
    -0.00715131f, 0.00216573f, -0.03679233f, -0.02189665f, -0.00985077f, 0.01572902f, -0.00353221f, 0.00599264f, 
    -0.02388295f, -0.04202925f, -0.01530845f, -0.00797573f, -0.01660773f, -0.03127514f, -0.01498523f, -0.00481732f, 
    -0.00723677f, 0.01490627f, 0.03719990f, -0.01738587f, -0.02544888f, -0.02579608f, -0.00647626f, 0.01471727f, 
    0.02890354f, 0.00171222f, -0.00477702f, 0.01298365f, 0.00100954f, 0.03651636f, 0.02586043f, -0.01772962f, 
    -0.03992110f, 0.02751427f, 0.00744782f, 0.01698207f, 0.02502409f, 0.00024301f, -0.00367848f, -0.00286201f, 
    0.02015147f, -0.02763942f, 0.02078131f, 0.00101644f, 0.01187273f, -0.02985698f, -0.00447955f, 0.03221639f, 
    -0.02041608f, -0.03658343f, -0.01845714f, 0.01284464f, 0.01989434f, -0.00957251f, -0.04058041f, 0.02240839f, 
    0.02599674f, -0.04340031f, 0.02587603f, -0.00469078f, -0.01162463f, 0.00093662f, 0.02678972f, 0.01260031f, 
    0.02609570f, -0.03681317f, -0.01059203f, -0.02548255f, -0.01856145f, -0.01785587f, -0.04419377f, -0.00363981f, 
    -0.01479985f, 0.00866887f, 0.02280799f, 0.01390116f, 0.02093327f, -0.01709262f, 0.00634069f, -0.03283253f, 
    -0.04158081f, -0.02638839f, -0.00107734f, -0.01670447f, 0.02817543f, -0.03123653f, -0.03245455f, 0.02626121f, 
    0.12910637f, 0.05826433f, -0.16649209f, -0.17388561f, -0.05765577f, 0.06878694f, -0.03886138f, 0.14644340f, 
    -0.00415398f, 0.08016951f, 0.01819322f, 0.09009222f, 0.13601413f, 0.17632160f, -0.15299478f, -0.05189042f, 
    0.04869881f, 0.11927898f, -0.08820504f, 0.14763950f, -0.07038614f, 0.06637468f, 0.22668286f, -0.08302193f, 
    -0.01566037f, -0.03327249f, -0.04481861f, -0.14339432f, -0.05234918f, -0.13729770f, -0.09250920f, -0.05790085f, 
    0.00697352f, 0.15409181f, 0.02541791f, -0.03405851f, -0.09102577f, -0.17805679f, -0.08993195f, -0.16118224f, 
    -0.14558509f, -0.12823893f, -0.13594642f, -0.13126235f, 0.06785933f, 0.03336987f, 0.10250379f, 0.06384635f, 
    0.26689047f, 0.05800335f, 0.24326459f, 0.14643329f, 0.25225750f, 0.12654895f, 0.06558797f, 0.00944397f, 
    0.06636591f, 0.14249040f, 0.26269370f, -0.00572948f, 0.16451615f, -0.00028789f, 0.05109797f, -0.50267774f, 
    0.05123549f, -0.07815994f, 0.03924189f, -0.10696962f, 0.01178542f, -0.01862300f, -0.02241037f, 0.09336850f, 
    -0.23545122f, -0.09368569f, -0.19687083f, 0.05368624f, 0.06019709f, 0.05186281f, -0.05254712f, 0.00207271f, 
    0.07173949f, 0.01087293f, 0.08905979f, 0.13224883f, 0.02279660f, -0.02149424f, -0.13961509f, -0.14991058f, 
    0.01630357f, 0.03073122f, 0.02361905f, -0.08959342f, 0.05259513f, 0.07729234f, 0.05322285f, 0.09212863f, 
    -0.28332055f, 0.27076009f, -0.25380918f, 0.16385449f, -0.10870939f, -0.03637096f, 0.20844486f, -0.03136937f, 
    0.27712563f, -0.13992572f, 0.08867161f, 0.01778789f, -0.11375237f, -0.18202475f, -0.01653683f, -0.15032141f, 
    -0.01311391f, -0.09076013f, -0.07493195f, -0.16316767f, 0.04073589f, 0.02028422f, 0.05824522f, 0.03267037f, 
    0.30640218f, 0.11934721f, 0.13979988f, -0.03919088f, 0.24744295f, -0.19460317f, -0.05568967f, 0.12483138f, 
    -0.04298801f, 0.02930681f, 0.00025672f, -0.01781499f, 0.39662495f, 0.37986168f, -0.10280146f, 0.37931576f, 
    0.11356428f, 0.05541138f, -0.07085879f, 0.03722442f, 0.14379133f, 0.03115904f, -0.00918671f, 0.04983477f, 
    -0.14630693f, -0.04573278f, -0.02877639f, -0.19553281f, -0.10229620f, -0.07080372f, 0.09905933f, -0.06392203f, 
    0.03078581f, 0.09882097f, 0.03086217f, -0.03885312f, 0.31586024f, 0.05151665f, -0.04990879f, 0.15761834f, 
    -0.03727717f, -0.03028550f, -0.08451912f, 0.02372756f, -0.01449828f, -0.01908855f, -0.04926176f, -0.24798203f, 
    -0.30066535f, 0.26289716f, 0.07070868f, -0.01233438f, 0.15259461f, -0.01987733f, 0.11893088f, 0.02765721f, 
    0.05871675f, 0.10095708f, 0.12116861f, -0.12506260f, -0.30344179f, -0.46533248f, 0.20388253f, 0.15437794f, 
    0.03530625f, 0.13309863f, 0.01596515f, 0.15147749f, 0.06589900f, 0.07952312f, 0.12037154f, 0.05606569f, 
    -0.03224472f, 0.03363214f, -0.02055506f, 0.00075965f, -0.04246905f, -0.06131178f, -0.02721996f, -0.14042443f, 
    -0.02640588f, -0.05351040f, -0.03070110f, -0.03235099f, -0.20481716f, -0.05208831f, 0.01899814f, -0.36289835f, 
    -0.00887525f, 0.03792205f, 0.06287214f, 0.11561896f, 0.06552897f, 0.04294302f, 0.02033777f, 0.03317253f, 
    -0.02165070f, 0.09182794f, 0.19619805f, -0.10915343f, -0.08386383f, 0.01218935f, -0.06295591f, -0.04244410f, 
    0.02780308f, -0.07787615f, 0.00173209f, -0.03042543f, 0.32810581f, 0.21071899f, 0.05010298f, -0.20577954f, 
    -0.03553854f, 0.20929916f, 0.11500332f, 0.08846781f, 0.06451528f, 0.07417419f, 0.15032580f, -0.07978966f, 
    0.37397844f, 0.14611827f, -0.00853202f, -0.07562436f, 0.08253907f, 0.03414991f, 0.04337264f, 0.02022777f, 
    0.16282998f, 0.09322778f, 0.06227529f, 0.29598421f, -0.10867119f, -0.06856263f, 0.07701350f, 0.05966775f, 
    -0.03676600f, -0.05269067f, 0.01583489f, -0.06422328f, -0.06082925f, -0.15412521f, 0.05444522f, -0.10011063f, 
    -0.10827528f, 0.04298791f, 0.18084928f, -0.01629942f, 0.08584049f, -0.03613811f, 0.03070501f, 0.11593270f, 
    -0.00680714f, -0.04993546f, -0.01214697f, -0.01821187f, 0.17388578f, -0.00923158f, -0.05548960f, -0.08213720f, 
    0.17893142f, -0.03042050f, -0.10650299f, -0.10462900f, -0.02793536f, 0.03104418f, 0.06344882f, 0.20772479f, 
    -0.06145470f, 0.12294246f, 0.06416564f, 0.04079401f, 0.14577617f, 0.02716519f, -0.00298871f, 0.19576532f, 
    -0.00159111f, -0.05030462f, 0.10101699f, -0.05736606f, -0.38376412f, -0.34032226f, 0.05751299f, -0.13823895f, 
    -0.10192570f, -0.09833446f, -0.10943432f, -0.05192526f, 0.11975463f, 0.10174587f, 0.13722019f, 0.12011179f, 
    -0.26704344f, 0.00893236f, -0.04381179f, -0.07637371f, 0.07913153f, -0.01956632f, -0.01124632f, -0.03571012f, 
    -0.11024148f, -0.04616867f, 0.05663981f, -0.07356580f, -0.20002083f, 0.03619665f, -0.04393578f, 0.03300332f, 
    -0.17192642f, 0.00997572f, -0.09527388f, -0.03266735f, 0.06386638f, -0.09542312f, 0.03786458f, 0.04775283f, 
    -0.10258888f, 0.04494892f, -0.04075012f, 0.07867377f, 0.06919093f, 0.07175492f, 0.05236125f, 0.03906496f, 
    0.07466972f, -0.00508997f, 0.01973460f, 0.02475291f, -0.10567576f, -0.00228044f, -0.00328055f, -0.07293710f, 
    -0.02584229f, -0.06460134f, -0.12007881f, -0.27089509f, -0.03661487f, 0.01229922f, -0.02181237f, -0.10584798f, 
    0.14877263f, 0.35546541f, 0.17610486f, 0.15779112f, 0.02229367f, -0.03776263f, -0.12560743f, -0.10311604f, 
    0.03635540f, -0.05530892f, -0.01027856f, 0.05364279f, -0.17840458f, -0.05025309f, 0.01490684f, -0.26099578f, 
    -0.18069048f, -0.13455227f, 0.08081689f, -0.08289154f, 0.03798297f, 0.11496185f, -0.08178038f, -0.08443206f, 
    -0.34304136f, -0.19313587f, -0.13399021f, -0.24474761f, -0.16136305f, -0.10228114f, 0.06956922f, -0.18969011f, 
    -0.12283842f, -0.08010539f, -0.09580682f, -0.04867180f, -0.21349522f, 0.26500785f, -0.00631262f, 0.01495632f, 
    0.04614280f, 0.01507502f, 0.02931889f, -0.13058469f, 0.03661285f, 0.13132834f, -0.01743555f, 0.05261820f, 
    -0.08174583f, 0.00371875f, 0.09246021f, -0.14042939f, 0.02563534f, 0.08621328f, -0.03109561f, -0.00989948f, 
    -0.08144800f, -0.02416371f, -0.07691982f, 0.05778938f, -0.29477927f, -0.22982457f, 0.08693958f, -0.12498974f, 
    -0.00298200f, -0.04840232f, 0.03645950f, 0.07814451f, 0.00528736f, -0.00693646f, -0.04094213f, 0.03187314f, 
    0.01045329f, -0.04949350f, -0.04179291f, 0.00550465f, -0.07386573f, -0.07031690f, -0.07161844f, -0.02876057f, 
    0.01326376f, 0.01904732f, 0.16451466f, 0.02733918f, -0.04312285f, -0.27915272f, -0.00448164f, 0.00395982f, 
    0.28048965f, 0.01922169f, -0.01409382f, 0.07661105f, 0.24399668f, 0.01476770f, 0.19671181f, 0.06086956f, 
    -0.22326301f, -0.17239007f, -0.05781504f, -0.07561874f, 0.10794175f, -0.03897011f, -0.10821554f, -0.10605124f, 
    -0.02122992f, -0.09151597f, -0.00845195f, 0.02348531f, 0.22389852f, 0.04398759f, -0.06607854f, 0.18057613f, 
    0.15707763f, 0.09715503f, -0.02747272f, 0.23915604f, -0.03139173f, 0.04570534f, 0.07135373f, 0.06159231f, 
    0.12548640f, -0.10862768f, 0.06387281f, -0.24151614f, 0.03474028f, 0.10884776f, 0.04771886f, 0.06254508f, 
    -0.01240401f, 0.05999625f, -0.07931487f, -0.16225861f, 0.08762320f, 0.02819959f, -0.06683822f, -0.05895163f, 
    -0.07267503f, -0.04315386f, -0.10902818f, -0.10359454f, -0.02007160f, -0.06838161f, 0.01542988f, -0.10635625f, 
    0.43072444f, 0.22763915f, 0.06956079f, 0.10722473f, 0.19151261f, -0.03753722f, 0.01473843f, -0.08155049f, 
    0.32975835f, 0.23846050f, -0.03196957f, 0.15627140f, 0.18328729f, -0.04724319f, 0.17804262f, -0.08977809f, 
    -0.03022273f, 0.12555401f, 0.06268673f, 0.24439904f, 0.19118835f, 0.22847423f, 0.10996255f, 0.10496510f, 
    -0.13601331f, -0.10934415f, -0.24826549f, -0.17126450f, 0.00939260f, -0.00894477f, 0.03031939f, -0.00431651f, 
    0.12908101f, 0.03504969f, 0.06998668f, -0.09243782f, -0.24376738f, 0.17748515f, 0.05609402f, 0.00409489f, 
    0.05563620f, 0.05091370f, 0.05423481f, 0.16055091f, -0.01716326f, 0.00448297f, 0.13619837f, -0.05244352f, 
    -0.24119641f, -0.02727501f, 0.11060487f, 0.02132884f, -0.05537462f, 0.05523895f, -0.04498092f, 0.03329340f, 
    0.10483877f, 0.04958283f, 0.22454418f, -0.01201723f, 0.01184595f, 0.03388303f, -0.03168224f, -0.11577102f, 
    0.07427821f, 0.11354849f, 0.02448621f, 0.13533917f, 0.02010737f, 0.10116213f, 0.02626969f, -0.14499885f, 
    -0.20713863f, 0.15916495f, -0.07249165f, -0.09397954f, 0.08672370f, -0.14791885f, 0.16732191f, 0.12846661f, 
    0.16553633f, 0.07861847f, 0.17702293f, 0.04818397f, 0.08236749f, 0.09511211f, -0.02552970f, 0.27524343f, 
    -0.07736597f, -0.01549254f, -0.16673489f, 0.04159671f, 0.08082236f, 0.05622946f, 0.02356005f, 0.11073358f, 
    -0.13448277f, 0.10997276f, -0.06621902f, 0.15560144f, 0.13654569f, -0.04987274f, 0.10335615f, 0.17482154f, 
    0.13548969f, 0.13092922f, 0.03366675f, -0.16723898f, 0.21244733f, -0.06716964f, -0.17676683f, -0.05444933f, 
    -0.04359971f, -0.15138429f, -0.11684514f, 0.02645532f, 0.11112414f, 0.00434498f, 0.00502361f, -0.02181284f, 
    -0.05307955f, -0.10940322f, 0.10805159f, -0.42044494f, 0.03245543f, -0.05952616f, -0.11793526f, 0.07941156f, 
    0.18237627f, 0.01087560f, -0.00131451f, 0.12687619f, -0.19912116f, -0.09086587f, -0.00843067f, 0.34628364f, 
    0.08187492f, -0.13283801f, -0.01113338f, 0.04906110f, 0.06982183f, 0.16741443f, 0.21398552f, 0.24093761f, 
    0.09485931f, 0.08165842f, -0.19990134f, -0.05446891f, 0.18542990f, 0.00943880f, 0.00555033f, -0.09451318f, 
    0.07665621f, 0.05317015f, -0.06884532f, 0.15704931f, -0.16405295f, -0.12269980f, -0.13889721f, 0.01331938f, 
    -0.06334879f, -0.12020268f, -0.14702064f, -0.01255864f, 0.19009000f, 0.01371919f, 0.26585993f, 0.06115684f, 
    -0.09004845f, -0.09508934f, -0.05000333f, 0.15636502f, 0.05060318f, -0.06441808f, 0.12359531f, 0.04158290f, 
    0.11443477f, -0.08195761f, 0.11212279f, 0.00368828f, 0.15226552f, 0.05885113f, -0.09450325f, -0.01859637f, 
    -0.11039731f, -0.19723001f, -0.14666820f, -0.12334076f, -0.09675879f, -0.17693165f, -0.12999357f, -0.12567791f, 
    -0.02348087f, 0.34738827f, -0.03320375f, -0.17252558f, 0.00645010f, -0.18395279f, 0.15999955f, -0.13079962f, 
    0.11384676f, -0.10614527f, 0.12905195f, 0.03318025f, -0.04724948f, -0.08741929f, 0.03103491f, -0.34725490f, 
    -0.09044403f, 0.05542732f, 0.13382868f, -0.02088529f, 0.06823921f, -0.02867890f, 0.04053380f, 0.08134247f, 
    0.13090387f, 0.07122078f, 0.01747837f, -0.05571814f, -0.05919540f, -0.06205194f, -0.12524062f, -0.03036055f, 
    0.01743358f, -0.04672615f, 0.06612603f, -0.00013761f, -0.04022628f, -0.21725549f, -0.19791496f, -0.03166235f, 
    0.20548031f, -0.09656718f, 0.09317105f, 0.10443576f, 0.35309228f, -0.14365947f, 0.17200415f, 0.05927498f, 
    0.68859172f, -0.12936559f, 0.20778912f, -0.38768119f, -0.02970258f, -0.06652822f, 0.00971757f, 0.07387144f, 
    -0.05961740f, 0.03693021f, 0.11905771f, 0.19059332f, 0.13792183f, 0.12294155f, -0.12434303f, 0.00057602f, 
    -0.06010404f, 0.00111639f, 0.00055373f, 0.02548567f, -0.07610989f, -0.00473246f, 0.06678053f, -0.20024705f, 
    0.02816995f, 0.01756603f, -0.03916653f, 0.00275491f, 0.02825237f, -0.00229626f, -0.02265079f, -0.03740586f, 
    -0.03979201f, 0.01073462f, 0.00317557f, 0.00447482f, -0.03506738f, 0.02648448f, 0.01582084f, -0.02201441f, 
    0.02525672f, -0.03179011f, -0.02201478f, 0.01573692f, -0.01574551f, -0.00773938f, 0.01783461f, -0.02489450f, 
    0.01801739f, 0.02991951f, -0.03622576f, -0.02072772f, 0.00381565f, -0.02357107f, 0.00410054f, -0.01969768f, 
    0.00508676f, 0.02162989f, -0.03460715f, -0.02565681f, 0.01767435f, -0.02432984f, 0.01830689f, 0.01738752f, 
    -0.02816023f, -0.01646034f, 0.02271659f, 0.00613046f, 0.02842252f, -0.02252924f, -0.01579127f, -0.00685107f, 
    0.01983226f, -0.01793681f, -0.00249183f, -0.03908611f, 0.01321134f, 0.02415981f, -0.02025364f, 0.02371382f, 
    0.00720177f, -0.01292501f, 0.02558663f, -0.01010498f, -0.01419448f, -0.00713507f, -0.00773775f, -0.03957214f, 
    0.02733168f, 0.01750422f, -0.03198631f, 0.02541686f, 0.00178198f, 0.01401349f, 0.00921352f, 0.02866238f, 
    -0.00194933f, -0.02607328f, -0.03035251f, -0.03763516f, -0.04059872f, 0.02793517f, -0.02412041f, 0.02886025f, 
    0.00895664f, -0.01563943f, 0.00858058f, 0.01047409f, -0.01292562f, -0.04026698f, 0.02211925f, 0.01061390f, 
    -0.00533740f, 0.00790311f, -0.02505209f, -0.01134515f, -0.02182399f, 0.02477953f, -0.01786154f, 0.02240804f, 
    -0.02967246f, -0.02987650f, 0.01900900f, -0.00381044f, 0.01480077f, -0.00738991f, -0.00096456f, 0.01833504f, 
    -0.02463772f, 0.00576200f, -0.00039910f, 0.00319154f, -0.02130551f, 0.00654763f, 0.02341884f, -0.01428647f, 
    0.01728070f, -0.00376659f, 0.01881803f, 0.00221571f, 0.02131643f, -0.02096521f, 0.01924822f, 0.02514103f, 
    -0.01153882f, -0.02045715f, -0.01839230f, -0.02662318f, 0.01557179f, 0.02742965f, 0.00689364f, 0.02823525f, 
    0.00161652f, -0.01475662f, 0.02147979f, 0.00293735f, -0.01935510f, 0.00852340f, 0.00117190f, -0.02210322f, 
    0.02369909f, 0.01267665f, 0.02608937f, -0.03754498f, -0.01905174f, -0.03471244f, -0.00936846f, -0.00120796f, 
    0.01375113f, -0.01445134f, -0.03686347f, -0.02038913f, 0.01353434f, -0.02405018f, 0.00925271f, 0.02594136f, 
    0.02732037f, 0.00926094f, 0.02346354f, -0.01577446f, 0.02270027f, 0.01426573f, 0.01172684f, -0.01828148f, 
    -0.03855767f, -0.02012835f, -0.00649428f, 0.00839160f, -0.02630789f, 0.00687577f, 0.01379193f, -0.00911714f, 
    0.02784255f, -0.03283100f, -0.01933638f, -0.03386991f, 0.01810913f, -0.04113946f, -0.03271902f, -0.03300263f, 
    -0.04038680f, -0.01064632f, -0.02886288f, 0.00290757f, 0.01010119f, 0.01304160f, -0.03693787f, 0.02250513f, 
    0.00565846f, 0.02169424f, -0.01172727f, -0.00402175f, -0.00373812f, -0.01429559f, -0.01458651f, 0.02286534f, 
    -0.01502793f, 0.02554806f, -0.00506345f, -0.03066978f, 0.02067502f, 0.01745002f, -0.03440063f, -0.00098825f, 
    -0.03458176f, -0.01460295f, -0.04189745f, 0.00851500f, 0.02167536f, -0.02792233f, 0.01628754f, 0.01725162f, 
    -0.00745805f, -0.03710754f, -0.00075189f, -0.01624849f, 0.00900687f, -0.00628330f, -0.03215504f, 0.02292790f, 
    0.00970655f, -0.03525578f, 0.01651646f, -0.01944050f, -0.02649874f, -0.01097140f, -0.01339588f, 0.02505242f, 
    -0.01050551f, 0.01409832f, -0.04088880f, -0.02586352f, 0.01552613f, -0.03545102f, -0.01245213f, -0.03082376f, 
    0.01885822f, -0.03014665f, 0.01333108f, -0.02012543f, -0.02423420f, -0.01836831f, -0.00789022f, 0.02536116f, 
    0.01252965f, -0.02159416f, -0.04012581f, -0.01637231f, -0.03225985f, 0.02760800f, 0.00662518f, -0.03319693f, 
    -0.02802343f, -0.00396095f, -0.02286472f, -0.01020068f, 0.00434215f, 0.00240187f, -0.03059927f, -0.03937906f, 
    0.00408192f, -0.01078022f, -0.00298360f, 0.02543647f, -0.02807653f, 0.01311461f, 0.01237838f, 0.02256809f, 
    0.01046398f, 0.01913746f, 0.02400727f, -0.03658639f, 0.01073486f, 0.01997996f, 0.02180538f, 0.00897463f, 
    0.01744780f, -0.02472495f, 0.00216559f, 0.00493368f, 0.01092003f, 0.00774408f, -0.00755072f, -0.04058737f, 
    0.01832569f, -0.04098153f, -0.02206171f, 0.00997014f, -0.00839188f, 0.01894279f, -0.01069443f, -0.02322513f, 
    -0.03750151f, 0.01554422f, 0.01386288f, 0.01536656f, -0.00069362f, -0.01285797f, -0.01764821f, -0.00329985f, 
    0.00701407f, -0.01819462f, -0.03658863f, 0.02964053f, 0.02694577f, -0.00041623f, -0.01325071f, -0.00661653f, 
    0.00687407f, -0.02866666f, 0.02288674f, -0.03231353f, -0.02873331f, -0.03105580f, 0.01510311f, -0.02658770f, 
    -0.02605334f, -0.02643293f, -0.02985824f, -0.03794440f, 0.02402118f, 0.00629975f, -0.03933727f, 0.00041219f, 
    -0.02872128f, 0.01646086f, -0.03407785f, 0.01956152f, -0.00659022f, 0.00354575f, -0.02307126f, -0.03997083f, 
    0.02691912f, -0.01938327f, 0.02853247f, -0.03396559f, -0.03613089f, -0.00064162f, -0.02355693f, -0.00746583f, 
    0.00171679f, -0.01693819f, 0.00118130f, -0.02251792f, -0.04154266f, -0.03707207f, -0.00984396f, -0.02328777f, 
    0.00711035f, -0.01433292f, -0.01034837f, 0.02553811f, 0.02277756f, -0.04184500f, 0.00018251f, -0.00838166f, 
    -0.03077955f, -0.00385988f, 0.02412749f, 0.02457401f, -0.02801235f, 0.01183781f, -0.00933738f, -0.01890400f, 
    0.02620460f, -0.00836538f, -0.00615826f, -0.00102370f, -0.03054970f, -0.00229873f, -0.00134589f, 0.02339354f, 
    0.02602490f, 0.02289666f, -0.03043684f, -0.01589136f, 0.00244409f, -0.02255011f, 0.01940382f, 0.02541765f, 
    0.02726333f, 0.00035055f, -0.04020870f, -0.03775994f, 0.00361688f, -0.01418284f, 0.01032334f, 0.00724233f, 
    -0.00888058f, 0.02280490f, 0.00762141f, -0.01790037f, 0.01373751f, -0.01546552f, 0.00839958f, -0.01433984f, 
    0.00923267f, -0.01007972f, -0.03886926f, -0.02791637f, -0.03140628f, -0.01686773f, -0.02284177f, 0.00100289f, 
    -0.01388396f, 0.01669461f, -0.03134449f, 0.00250166f, -0.00004478f, -0.00673016f, -0.00111873f, -0.01599604f, 
    0.02191676f, -0.03002672f, -0.04184322f, 0.02007221f, -0.00479786f, -0.03307554f, -0.00457429f, 0.02738130f, 
    -0.03044776f, -0.01491761f, 0.00992776f, 0.02389117f, 0.01434813f, -0.02168122f, -0.03905104f, 0.01686723f, 
    0.02323726f, -0.03144660f, 0.01538600f, -0.00332875f, -0.02692139f, -0.03192111f, 0.01859947f, -0.03730552f, 
    -0.01200672f, -0.02841207f, -0.02788513f, -0.01588912f, 0.00224037f, 0.00448900f, -0.02889910f, 0.01861772f, 
    0.01361019f, 0.02693275f, -0.01153180f, 0.00395348f, -0.02428709f, 0.01687779f, -0.03457290f, 0.01003591f, 
    -0.01205760f, -0.00958572f, -0.01023131f, -0.00369754f, -0.01866435f, -0.03448723f, -0.03978366f, -0.00767603f, 
    -0.03805920f, -0.03624546f, -0.02909406f, -0.04041743f, 0.02438826f, -0.01080355f, -0.02580090f, -0.02479543f, 
    -0.03394143f, -0.03325713f, -0.01340823f, -0.03488725f, 0.00032761f, -0.02448008f, -0.03596293f, -0.01055071f, 
    0.02090550f, -0.01297082f, -0.03740182f, 0.01625220f, 0.00423064f, -0.00189651f, -0.02299511f, 0.02352937f, 
    -0.02923100f, -0.02010432f, -0.03339988f, -0.02538834f, -0.02998669f, 0.00247389f, -0.00795295f, 0.02370664f, 
    0.02156310f, -0.00812670f, 0.01442753f, -0.04054143f, -0.01250224f, 0.00974194f, 0.00951402f, 0.00107708f, 
    0.02997759f, -0.03868794f, -0.01963001f, -0.03731380f, 0.02805132f, -0.02544487f, -0.03318946f, -0.01301733f, 
    0.01955247f, -0.02989773f, -0.03542472f, 0.00103331f, 0.01133466f, -0.01964741f, -0.00411976f, -0.04032509f, 
    -0.03097647f, -0.03281658f, -0.02123825f, -0.02066095f, -0.01904882f, -0.00219465f, -0.03437029f, -0.00732348f, 
    0.01324459f, -0.04128513f, -0.00817764f, -0.00423235f, 0.00747413f, 0.00929710f, -0.04127632f, -0.03454417f, 
    -0.01329132f, -0.04170065f, -0.01108536f, -0.03483310f, 0.00994293f, -0.01400193f, 0.02496919f, -0.03995619f, 
    0.02959589f, -0.00487774f, -0.01430252f, -0.04131381f, -0.00861227f, -0.02627003f, 0.01719991f, -0.01358903f, 
    0.01377338f, -0.03707796f, 0.00193303f, 0.01771676f, -0.00482249f, -0.01433498f, -0.01743264f, -0.00838306f, 
    -0.02574597f, -0.00446399f, 0.01357612f, 0.01554678f, -0.03367006f, -0.02763039f, -0.02202947f, 0.02021638f, 
    0.01737166f, 0.00689037f, -0.02192217f, 0.02824333f, -0.02642340f, -0.02570302f, -0.01004512f, 0.01709981f, 
    0.01134375f, -0.03279193f, 0.00995348f, -0.00726891f, -0.01411028f, 0.01623077f, 0.02789516f, 0.01175585f, 
    -0.03628086f, 0.02281531f, -0.01416517f, -0.01263412f, -0.00045261f, -0.00600472f, -0.03620754f, -0.01540701f, 
    -0.00370192f, -0.03298017f, -0.01527398f, 0.01223385f, 0.01818967f, 0.01869599f, -0.02841938f, 0.02769550f, 
    0.02917262f, -0.00429499f, 0.01879647f, -0.01516258f, 0.00921649f, -0.01905612f, 0.02127682f, -0.03968567f, 
    -0.03698775f, -0.00134308f, -0.03954967f, -0.01725369f, -0.01685192f, 0.01439295f, -0.03295752f, -0.00482378f, 
    -0.00601930f, 0.01535595f, -0.02460134f, -0.02458436f, 0.02551610f, -0.02307637f, -0.04027763f, -0.00933352f, 
    -0.03044858f, -0.01175117f, -0.00731136f, -0.00368144f, 0.00854945f, 0.00682480f, -0.02804160f, -0.00873130f, 
    -0.01443793f, -0.01328122f, -0.02715282f, 0.02889144f, -0.02486861f, -0.02881498f, 0.02438130f, -0.03679130f, 
    0.00342946f, -0.00181127f, 0.01370456f, -0.00887695f, 0.01618689f, 0.01612132f, -0.03278655f, 0.00051102f, 
    0.01594851f, -0.02433870f, 0.00590883f, -0.02562084f, -0.03368390f, -0.03437909f, 0.02717068f, -0.02927176f, 
    0.00186412f, -0.03875633f, -0.03343057f, -0.00656084f, -0.03480990f, 0.02703845f, -0.02974232f, 0.01307413f, 
    -0.03696082f, 0.00557235f, 0.03003825f, 0.00118667f, 0.00785859f, 0.02213197f, 0.00186778f, 0.00013082f, 
    -0.03924707f, 0.02815933f, 0.01117825f, -0.00703097f, 0.02113007f, -0.00808370f, 0.01330672f, -0.01472943f, 
    -0.01306890f, 0.02399344f, -0.01467013f, 0.01461999f, -0.00398347f, -0.02910951f, -0.03401444f, 0.00836604f, 
    0.02713561f, -0.01987556f, -0.00565430f, 0.00407517f, -0.00689619f, 0.02937135f, -0.02681407f, 0.01307139f, 
    0.02646661f, -0.02228714f, -0.00477956f, 0.01996342f, 0.00369617f, -0.01809577f, -0.03564854f, -0.03165630f, 
    -0.02137701f, 0.00255410f, 0.00429857f, 0.00220652f, 0.02088092f, -0.01644423f, 0.00500848f, -0.00006078f, 
    0.01975014f, -0.02975577f, -0.01769673f, 0.02614600f, -0.03318797f, -0.03251432f, 0.02280644f, -0.00903651f, 
    -0.01916174f, -0.01675076f, 0.00097465f, -0.03174534f, -0.04041880f, 0.02695443f, -0.00598114f, -0.03430152f, 
    0.02211712f, -0.03674669f, 0.00993926f, 0.01241622f, -0.01730208f, -0.03306762f, 0.01182498f, 0.00123768f, 
    -0.01445500f, -0.01432569f, -0.00602758f, -0.00861171f, -0.00008866f, 0.02800313f, 0.00741145f, -0.03558865f, 
    -0.02013705f, -0.01110900f, 0.00594638f, 0.01969338f, 0.01638396f, -0.03783977f, -0.03086987f, -0.00620637f, 
    -0.02141204f, -0.02982612f, -0.00284913f, 0.00952309f, -0.04143014f, 0.00424917f, -0.02406650f, -0.01259054f, 
    -0.00948144f, -0.04019362f, -0.03643423f, -0.02810558f, 0.02876513f, -0.00814710f, 0.02975862f, 0.00796006f, 
    -0.03219168f, -0.03144043f, -0.01284804f, 0.00015140f, -0.00407534f, -0.03824524f, 0.02287327f, 0.01407555f, 
    0.02006471f, 0.00673348f, -0.00785418f, -0.02262083f, -0.02794074f, 0.02898163f, 0.01768504f, -0.01559877f, 
    -0.04136795f, -0.03356272f, 0.01028916f, -0.00546758f, -0.02189548f, 0.00975047f, -0.00201588f, 0.01490707f, 
    0.02832901f, -0.01215016f, -0.02405162f, 0.02996314f, -0.00763698f, 0.00283220f, -0.03777917f, 0.01227377f, 
    -0.00481483f, 0.01034256f, -0.02057185f, -0.02171351f, 0.01501004f, -0.00898426f, 0.01034125f, 0.01785093f, 
    -0.00772500f, 0.02658961f, 0.01531992f, -0.02834117f, -0.00902977f, -0.02685867f, 0.01348892f, 0.00847715f, 
    -0.03058507f, 0.00866284f, -0.02822269f, 0.02929338f, -0.02337899f, -0.01138257f, 0.01095938f, 0.00845207f, 
    -0.01819186f, -0.03285078f, 0.00650336f, -0.01273286f, -0.02238706f, -0.00935303f, 0.01651470f, -0.02695317f, 
    0.00266513f, -0.04147000f, -0.03248202f, 0.00531119f, -0.04081751f, -0.04115699f, -0.02770764f, -0.03941305f, 
    -0.00613634f, -0.01437045f, 0.01281656f, 0.00974050f, 0.00391162f, -0.00569914f, -0.02700019f, 0.02094661f, 
    -0.01449876f, -0.02961688f, 0.01220479f, -0.00390585f, -0.03704090f, 0.01401072f, 0.01658781f, -0.02113913f, 
    0.02174905f, -0.01600544f, -0.02283914f, -0.03729449f, -0.03169530f, -0.02701128f, -0.02127577f, 0.02484705f, 
    -0.00475454f, -0.00693858f, -0.03288298f, 0.01725940f, -0.02534061f, -0.03420018f, -0.01117417f, -0.02402006f, 
    -0.02117200f, -0.00108620f, 0.01799974f, 0.01568920f, -0.01186533f, 0.02613068f, -0.03968691f, 0.00551924f, 
    0.01985265f, -0.03763819f, 0.00189016f, -0.01442704f, -0.01616330f, 0.00045258f, -0.01828144f, 0.01224452f, 
    -0.00890788f, -0.00412155f, 0.00419748f, 0.01435045f, 0.02100101f, 0.00177058f, -0.03750145f, -0.00116830f, 
    0.01754230f, -0.01744035f, -0.02334546f, 0.01292155f, -0.02158266f, 0.00530938f, 0.00894589f, 0.02409826f, 
    0.01914395f, -0.00548652f, 0.01089859f, 0.02687957f, 0.00786000f, -0.00008004f, 0.02072625f, -0.03990303f, 
    -0.03423764f, -0.01722567f, -0.03299132f, 0.02442183f, -0.01170209f, -0.03781839f, 0.02043781f, -0.01095574f, 
    -0.01428214f, 0.00668843f, -0.03480679f, 0.01731419f, 0.02188742f, 0.02606429f, -0.03988009f, -0.00207282f, 
    -0.02038139f, 0.01370818f, -0.03183872f, 0.00229943f, -0.01518842f, -0.03841196f, 0.00388830f, 0.02661290f, 
    0.01184092f, -0.01929891f, 0.01380629f, 0.02956807f, -0.00485203f, -0.02018013f, 0.01894049f, 0.00985663f, 
    0.01575110f, -0.03944177f, -0.01162515f, -0.01438529f, -0.03401935f, -0.00840316f, -0.00544642f, -0.01648985f, 
    -0.00895663f, 0.01043820f, -0.01814461f, -0.02813778f, -0.03112517f, -0.00433395f, -0.01674664f, -0.01507421f, 
    0.00074130f, 0.02322956f, -0.02559734f, 0.00695111f, 0.01473916f, -0.00935157f, -0.03690782f, -0.02530422f, 
    -0.03548072f, -0.03369395f, -0.00672756f, -0.02021913f, -0.00462446f, 0.02406744f, -0.01143552f, -0.02817843f, 
    -0.02371337f, 0.00724691f, 0.00911624f, 0.01117778f, -0.00113750f, -0.04177611f, 0.02695075f, -0.01747476f, 
    -0.04074497f, -0.01607176f, -0.01002534f, -0.00215664f, 0.02799498f, -0.01308217f, 0.00912650f, -0.02931670f, 
    0.01482100f, -0.01321159f, 0.02391518f, -0.01339579f, 0.01691139f, -0.00725088f, 0.02076058f, -0.00112337f, 
    0.02878791f, 0.01244143f, -0.01309719f, -0.03686109f, -0.00912988f, -0.00691403f, 0.00722320f, -0.03724832f, 
    0.02209912f, -0.01789704f, 0.02652282f, -0.04102438f, 0.01774653f, -0.03391385f, 0.02956979f, -0.01373450f, 
    0.01957738f, -0.01949672f, -0.01369188f, 0.02433160f, -0.01548992f, -0.00645723f, 0.00751961f, -0.02477356f, 
    -0.03965800f, 0.00701505f, -0.00897767f, -0.02655923f, -0.00011795f, -0.03966445f, 0.00121405f, -0.03226272f, 
    -0.01600865f, -0.03957839f, -0.03366011f, 0.03122544f, -0.02191385f, 0.01364730f, -0.00302193f, -0.02686517f, 
    -0.01571016f, 0.03000670f, -0.00667749f, -0.02598884f, 0.00097650f, -0.03812133f, -0.01731900f, -0.00349533f, 
    0.01286176f, 0.00266207f, -0.03761336f, -0.03453085f, -0.02226574f, -0.04128148f, 0.01709849f, -0.03709741f, 
    0.00883099f, -0.03114379f, 0.02961458f, -0.01144771f, -0.01752230f, 0.02819601f, 0.02285297f, -0.01424707f, 
    -0.02142850f, 0.00367707f, 0.01196525f, -0.03418732f, 0.01337442f, -0.03797552f, -0.02749097f, 0.02658253f, 
    -0.02208512f, 0.00400360f, 0.01591536f, 0.00740758f, 0.00093847f, -0.00152813f, 0.01503738f, -0.00666228f, 
    -0.02698732f, 0.01654942f, 0.01131073f, -0.01232016f, -0.02824608f, -0.01671313f, -0.01777335f, 0.01162156f, 
    -0.00885771f, -0.00429536f, -0.00105868f, 0.01714957f, 0.00742764f, 0.01343422f, 0.02993081f, 0.01707258f, 
    0.02947587f, -0.03422724f, -0.04075348f, 0.00211563f, -0.02533995f, -0.03797063f, 0.02805109f, -0.03014478f, 
    -0.02156257f, -0.00918602f, 0.00337542f, 0.00417407f, -0.02483749f, 0.02392496f, -0.01673483f, 0.02759090f, 
    -0.00933025f, 0.02401229f, 0.00297040f, -0.02101551f, -0.02503957f, -0.03012959f, -0.03484993f, -0.04116759f, 
    -0.00103115f, -0.00238387f, -0.00622715f, -0.00109280f, -0.00183244f, -0.02856929f, 0.01912106f, 0.02467411f, 
    -0.04072242f, -0.00698514f, -0.00311478f, -0.03119023f, -0.02991938f, 0.00249926f, -0.02213986f, 0.02737552f, 
    0.00684290f, -0.02203246f, -0.03846568f, 0.02413841f, 0.01138812f, -0.01716492f, 0.01815150f, -0.02294883f, 
    -0.00393398f, 0.00827640f, 0.02155133f, 0.00716992f, -0.02266005f, 0.02811413f, -0.00214598f, 0.02159837f, 
    0.01476111f, -0.01737757f, -0.02041193f, 0.00936785f, -0.00859397f, -0.02942747f, 0.01028307f, -0.01883865f, 
    -0.01448779f, -0.02695556f, -0.01752142f, -0.00319465f, -0.02218167f, 0.01376787f, -0.03407250f, -0.03089318f, 
    -0.03886238f, -0.04028761f, -0.02447324f, -0.01303922f, -0.04162273f, 0.01359596f, 0.02131121f, -0.00336594f, 
    -0.03479113f, -0.03388685f, -0.04165226f, 0.03171638f, -0.03208251f, -0.00487722f, 0.01596763f, -0.01694511f, 
    -0.03741794f, 0.01421365f, -0.00500267f, -0.00189907f, 0.01475966f, 0.00298211f, 0.00811752f, 0.02447547f, 
    -0.03355744f, 0.02781481f, -0.00353372f, -0.03558893f, 0.01846496f, -0.00484808f, 0.01281965f, -0.03866530f, 
    -0.00850462f, -0.03357565f, -0.01937816f, -0.01782235f, -0.02709117f, 0.00344610f, -0.03327058f, -0.02794628f, 
    0.02036584f, 0.01088285f, -0.04025676f, 0.00838702f, -0.02864776f, -0.00213994f, 0.00111000f, 0.00691136f, 
    0.01425472f, -0.04155000f, 0.02465728f, -0.04029326f, 0.00607785f, -0.00065569f, 0.02241827f, 0.00621824f, 
    0.00180470f, -0.00472848f, -0.02098498f, -0.00469072f, 0.02922194f, -0.02510749f, -0.00281799f, -0.02031796f, 
    0.02018863f, 0.01011675f, 0.02011523f, -0.01940390f, -0.01959942f, 0.00124164f, -0.03379860f, -0.04083932f, 
    0.02177640f, 0.01752056f, -0.00036738f, -0.01301085f, -0.01033953f, 0.00230776f, -0.00723559f, 0.02989464f, 
    -0.02740384f, -0.03891988f, 0.01513192f, 0.02423237f, -0.00886825f, -0.02328007f, 0.02062868f, -0.00105105f, 
    0.01787791f, 0.02700644f, -0.02653122f, -0.04005295f, 0.00828144f, -0.02043561f, -0.00439047f, -0.02769939f, 
    -0.02070208f, -0.01775443f, -0.02361421f, 0.01690437f, 0.03584418f, -0.01705739f, 0.00942285f, -0.00687649f, 
    -0.01071744f, -0.01904014f, -0.00019791f, -0.02393590f, 0.02010927f, 0.00211692f, -0.02351672f, -0.02046493f, 
    -0.01652721f, 0.01033933f, -0.02096379f, -0.01414853f, 0.02600989f, -0.03745213f, 0.02567911f, -0.00437578f, 
    -0.01332467f, 0.00061416f, 0.01922285f, 0.01117063f, 0.00111620f, -0.00741947f, -0.04197663f, -0.03743253f, 
    -0.01620029f, 0.01287778f, 0.00982100f, 0.02416769f, 0.01988369f, -0.03565801f, -0.01077941f, -0.02942803f, 
    -0.01921969f, -0.03017181f, 0.02480698f, -0.03155869f, 0.03541581f, -0.03860079f, -0.01713321f, -0.02004856f, 
    -0.03996530f, -0.00973745f, -0.02464822f, -0.00179966f, -0.02455392f, 0.01699163f, -0.04116675f, 0.02786331f, 
    0.00141869f, 0.01534047f, -0.02768710f, -0.00586282f, 0.00617307f, 0.02320340f, 0.01391274f, -0.00232219f, 
    0.02445987f, -0.00613885f, 0.01686146f, -0.00438123f, 0.00406417f, -0.04180921f, 0.02572407f, -0.00851576f, 
    -0.04168474f, 0.01905428f, -0.01549814f, -0.00742108f, 0.00566543f, -0.03195448f, -0.02897595f, 0.00101152f, 
    -0.01987566f, -0.02516143f, 0.02997277f, -0.01502895f, -0.03638566f, 0.01323418f, 0.01075369f, -0.01163751f, 
    0.01152545f, -0.00803301f, -0.02037423f, 0.00732866f, 0.01746103f, 0.02057615f, -0.00966797f, 0.02307789f, 
    -0.00279700f, 0.02706612f, -0.02463816f, 0.01306926f, 0.03103709f, -0.02599302f, -0.03191009f, 0.01915123f, 
    0.00676038f, 0.02950269f, 0.00143372f, 0.00582071f, -0.01784427f, 0.00367638f, -0.04112694f, -0.02202054f, 
    0.02597570f, -0.03117948f, 0.01062872f, 0.02853277f, -0.02317940f, 0.00211902f, -0.00642411f, -0.01356674f, 
    0.01243667f, -0.02337390f, -0.00810655f, 0.02927901f, 0.03529499f, -0.02482793f, 0.00842749f, -0.02831223f, 
    -0.03403178f, -0.01294464f, 0.01085064f, 0.01952082f, -0.03608502f, 0.00839519f, 0.01989482f, -0.02419832f, 
    0.02987585f, -0.00735607f, -0.00118047f, -0.01526738f, -0.01064630f, 0.00525370f, -0.00216309f, 0.01456083f, 
    -0.02659246f, 0.02062003f, 0.01059470f, 0.00294172f, -0.02369626f, -0.00855745f, -0.02195228f, -0.03483367f, 
    -0.02823273f, 0.00828603f, 0.00810557f, -0.01883226f, -0.02183613f, 0.02165364f, -0.03412442f, -0.01001733f, 
    -0.01526376f, -0.03773526f, 0.01719069f, 0.00974455f, -0.02948217f, -0.02131821f, -0.02514035f, 0.00704288f, 
    -0.03662147f, 0.01635441f, 0.01990656f, -0.02162482f, 0.00574018f, -0.02109381f, 0.02205304f, -0.01094184f, 
    -0.02934419f, 0.02322676f, 0.00918647f, 0.02127557f, 0.01545950f, -0.02817604f, -0.03326109f, -0.01597632f, 
    0.00502643f, -0.00891769f, -0.00515553f, -0.00165072f, -0.03786473f, -0.00836708f, -0.01311418f, 0.00263454f, 
    -0.00784392f, -0.00928325f, 0.01998671f, -0.00007086f, -0.02187733f, 0.01798073f, -0.00426763f, 0.02692420f, 
    -0.00938839f, -0.01337011f, 0.01656645f, -0.01549089f, 0.02169388f, -0.01204267f, -0.02114341f, -0.03878210f, 
    -0.00315710f, -0.03316494f, 0.02161425f, -0.04117730f, -0.01746523f, 0.01732325f, 0.02247359f, -0.00554742f, 
    -0.04024832f, 0.03088265f, -0.02008826f, 0.01438287f, 0.02277285f, -0.00673626f, -0.03367401f, -0.03619161f, 
    0.01532652f, -0.03768893f, 0.01482136f, -0.03755376f, 0.00630898f, -0.00044406f, 0.00335681f, 0.02181638f, 
    0.02129343f, -0.03168439f, -0.03882699f, -0.02350413f, -0.01502236f, -0.03986320f, -0.01460898f, -0.02808870f, 
    0.01908944f, 0.02601261f, -0.01959038f, -0.00851790f, -0.00544652f, 0.02159328f, 0.00917799f, 0.03270327f, 
    -0.04080925f, -0.01760684f, -0.01711539f, -0.02819837f, -0.00456372f, -0.02126505f, -0.04206313f, -0.02533123f, 
    0.01768403f, 0.02283440f, -0.00214031f, -0.01870650f, 0.00996882f, 0.01166533f, -0.01033696f, -0.03252366f, 
    -0.03430429f, 0.01241150f, 0.01952269f, -0.01308085f, 0.02821070f, -0.04023839f, -0.01931088f, -0.04131164f, 
    -0.01580061f, -0.02288150f, 0.00559573f, -0.04173520f, 0.00582898f, -0.01797145f, 0.00790193f, -0.01666513f, 
    0.04257766f, -0.13839972f, 0.15732419f, 0.08685137f, 0.01484998f, -0.00556329f, 0.12644619f, 0.00178456f, 
    -0.04357677f, -0.04981278f, 0.08550455f, -0.00245833f, 0.16903737f, 0.08547545f, 0.03404760f, -0.01302385f, 
    0.22306049f, -0.14441286f, -0.16641022f, 0.16462785f, 0.25563288f, 0.13776472f, -0.08623409f, 0.00003108f, 
    0.00795120f, -0.05291156f, -0.10051724f, 0.03161996f, -0.01060747f, 0.01189001f, 0.03610038f, -0.02616428f, 
    0.01279637f, -0.00052147f, 0.05722032f, -0.04085715f, 0.06036802f, -0.03800582f, 0.03181189f, 0.01274086f, 
    -0.03534182f, 0.02810494f, -0.06239172f, -0.06890459f, -0.02859320f, 0.06132798f, 0.06720607f, 0.03950385f, 
    0.02291686f, -0.02147872f, 0.12284417f, 0.02196651f, -0.04890990f, -0.02066235f, 0.09219277f, -0.00265870f, 
    0.00980384f, 0.07048793f, 0.14125019f, 0.05851771f, 0.26434973f, 0.00172834f, 0.08057643f, -0.06871372f, 
    -0.21183318f, 0.15372282f, -0.04683163f, 0.07507951f, -0.01744805f, 0.05782595f, -0.08359148f, 0.00649344f, 
    -0.04793218f, 0.20142847f, 0.13964224f, -0.04495548f, 0.04944047f, 0.14849089f, -0.11330101f, -0.03717751f, 
    0.01718565f, 0.04454501f, -0.02417363f, 0.00643112f, -0.08007590f, -0.12953705f, -0.17267303f, 0.03431902f, 
    0.11902444f, 0.01833347f, 0.13133405f, 0.09261540f, 0.03040398f, -0.06910620f, -0.02109714f, -0.04250751f, 
    -0.18711476f, 0.10369366f, -0.14892714f, 0.26092446f, 0.06485729f, -0.06390139f, 0.04624312f, 0.08166555f, 
    -0.11472293f, -0.07222838f, -0.03794359f, 0.02717279f, 0.09641915f, 0.18523172f, 0.12884387f, 0.05952175f, 
    0.06335711f, -0.05389447f, -0.02082750f, -0.05279189f, -0.00191216f, 0.03274778f, 0.02765023f, -0.01055166f, 
    -0.08399283f, 0.01168451f, -0.06095295f, 0.08417296f, -0.08526383f, 0.18825991f, 0.00925347f, 0.21263407f, 
    -0.01834166f, 0.03755969f, 0.05505666f, -0.05559031f, -0.12138703f, -0.09883809f, -0.01942090f, 0.18133768f, 
    0.00264035f, -0.03956965f, 0.06190482f, 0.04619518f, -0.17578727f, 0.01084399f, 0.02423509f, 0.00062622f, 
    -0.31665149f, -0.35164991f, 0.29751289f, 0.24428678f, 0.03183877f, 0.04209305f, -0.06401715f, -0.18642145f, 
    -0.04010260f, 0.06913011f, -0.10194252f, 0.02815089f, 0.12049119f, -0.03737859f, -0.00224197f, 0.15891443f, 
    -0.02601546f, 0.06046144f, 0.04521992f, -0.02073080f, 0.00865960f, -0.13375354f, -0.00051636f, 0.11127377f, 
    -0.10640870f, -0.12574296f, 0.05414776f, 0.06668308f, -0.03702499f, -0.03253770f, 0.00263503f, -0.03303273f, 
    0.06609400f, 0.07136429f, -0.13645576f, 0.03045576f, -0.19644950f, 0.45106813f, 0.10742609f, 0.06259410f, 
    0.19856964f, -0.18830979f, 0.24417523f, -0.04493411f, 0.18380633f, 0.00765818f, 0.12090760f, -0.00145097f, 
    -0.24451721f, 0.06323277f, 0.22177491f, -0.00588213f, 0.00632197f, 0.10584597f, -0.04638080f, -0.00649260f, 
    0.01225689f, 0.03066157f, 0.04295612f, -0.07531436f, 0.33295134f, 0.24811092f, 0.07535995f, -0.03478242f, 
    0.02337019f, -0.00512780f, -0.10439734f, -0.15536249f, -0.00013452f, -0.03142382f, -0.04619263f, 0.05698677f, 
    -0.06208033f, 0.20180523f, 0.06927689f, -0.11988459f, -0.05627056f, -0.00453810f, -0.09883831f, 0.02406647f, 
    0.04519174f, 0.09184545f, -0.03119431f, 0.11586335f, 0.29222998f, 0.13950494f, 0.04025527f, -0.09335978f, 
    0.13044372f, -0.10583279f, -0.21366531f, 0.03356469f, 0.09860785f, -0.01262427f, -0.03361621f, -0.01484756f, 
    0.02427180f, -0.16270782f, 0.01646925f, 0.03646926f, 0.01754662f, 0.01160599f, -0.00864894f, -0.05595595f, 
    0.01134835f, -0.10404572f, -0.06119893f, 0.15705734f, 0.03507973f, 0.05278686f, 0.15641943f, -0.07126163f, 
    0.07746631f, 0.00648707f, 0.01541733f, 0.00050939f, 0.00312119f, 0.12292712f, 0.05746958f, 0.15071303f, 
    -0.14141189f, 0.01325278f, 0.13097221f, 0.16585840f, -0.04075979f, -0.11443378f, 0.23287511f, -0.17419443f, 
    -0.03815582f, -0.02962315f, 0.08938781f, -0.01987706f, -0.02465046f, -0.17844877f, 0.24159475f, 0.05101082f, 
    0.02807286f, 0.00231730f, -0.04238906f, 0.13629292f, -0.08164528f, -0.02398451f, 0.00467087f, 0.01302566f, 
    -0.20148726f, 0.08853904f, 0.03942903f, 0.02318042f, 0.07703274f, -0.32514706f, 0.25949895f, 0.02704275f, 
    -0.03400806f, 0.05053836f, 0.05341006f, 0.03689577f, -0.20444094f, 0.00907650f, -0.02243126f, 0.00874455f, 
    -0.04686188f, 0.00734760f, -0.06331394f, 0.04027493f, -0.02090267f, -0.15788479f, 0.07856266f, 0.02708562f, 
    0.12524533f, 0.07790814f, 0.14104035f, 0.13736840f, -0.12573324f, -0.06439561f, -0.11896557f, -0.03127649f, 
    0.07155436f, 0.10081863f, 0.06460335f, -0.02970888f, -0.22614045f, 0.11269495f, 0.05624592f, 0.06786725f, 
    0.01145671f, 0.02342338f, 0.01435264f, 0.17000349f, 0.08624548f, 0.08672605f, -0.09233730f, 0.01420783f, 
    -0.20713666f, -0.04483829f, 0.04866202f, 0.20202854f, -0.00191834f, 0.01008206f, 0.07115488f, 0.00136565f, 
    -0.04004201f, 0.04918453f, -0.07744112f, -0.04015243f, -0.02566179f, 0.01886475f, 0.12310792f, 0.07615814f, 
    -0.00074403f, 0.10721864f, -0.01033439f, -0.01869709f, 0.00399891f, 0.02750911f, 0.14687788f, 0.03132557f, 
    -0.14644775f, -0.11025430f, -0.02278636f, 0.14296076f, 0.04458989f, 0.03187034f, -0.01855366f, -0.02012899f, 
    0.07924613f, -0.00506884f, -0.05378061f, 0.04286536f, -0.07335676f, 0.07372457f, 0.15966833f, 0.15573087f, 
    0.05288473f, 0.12206865f, 0.02053555f, -0.14329322f, 0.07504176f, -0.01232078f, 0.03139170f, -0.05352344f, 
    0.06375453f, 0.17910433f, 0.20701315f, 0.06720097f, -0.00118945f, -0.03758903f, -0.13331953f, 0.00369361f, 
    -0.03891854f, -0.01090236f, 0.14048518f, 0.03788593f, -0.09275789f, 0.03513172f, 0.15314528f, 0.01397145f, 
    0.14707360f, 0.09434307f, 0.05861580f, 0.00941855f, 0.09668863f, 0.00867636f, 0.01291880f, 0.01486399f, 
    0.02918493f, 0.05999575f, 0.25202659f, 0.18557751f, -0.05770953f, 0.07983864f, -0.01530812f, 0.11182323f, 
    -0.00255216f, -0.05939852f, -0.00491962f, -0.02164449f, -0.08764833f, 0.08955901f, 0.30546173f, 0.05145137f, 
    -0.08085613f, -0.06434287f, 0.07933889f, 0.01036689f, -0.01184693f, 0.07111909f, 0.09711827f, -0.01241208f, 
    -0.06355070f, -0.10531412f, -0.10338799f, 0.19807903f, 0.08862007f, -0.02116001f, -0.02549333f, 0.02828505f, 
    -0.04348440f, -0.06090490f, 0.06524253f, -0.00134458f, -0.03629486f, 0.08941233f, 0.18026128f, 0.14374395f, 
    0.11825294f, 0.02256644f, -0.13490392f, -0.05770690f, -0.07018747f, -0.09168095f, 0.02648627f, 0.13702004f, 
    0.17218746f, 0.28718260f, 0.06746019f, 0.13335446f, -0.02303836f, 0.04411093f, 0.13395779f, -0.01943411f, 
    0.07885645f, -0.02117283f, 0.00284375f, 0.00523577f, -0.19249111f, -0.04305042f, 0.02373142f, 0.26121259f, 
    0.14740723f, 0.12677991f, 0.28473067f, 0.01791932f, -0.02806916f, 0.06347334f, -0.00537634f, -0.03248017f, 
    0.29611811f, 0.09264551f, -0.13912170f, -0.02569184f, 0.01757876f, -0.01740970f, 0.10150232f, -0.07845581f, 
    0.12506118f, 0.12036814f, -0.04862978f, -0.03347013f, -0.02038076f, -0.10315457f, -0.03375378f, 0.06957531f, 
    0.06478420f, -0.00683156f, -0.02710432f, 0.00587427f, 0.02506277f, -0.01768572f, -0.09983079f, 0.02225064f, 
    0.14894997f, -0.34235728f, -0.07521542f, -0.04355022f, 0.01332023f, -0.09495851f, 0.01749615f, 0.07736994f, 
    -0.11002863f, -0.04721528f, -0.13801613f, 0.03920697f, 0.10569838f, 0.24787278f, 0.20380403f, 0.13877915f, 
    -0.17504311f, 0.22527510f, -0.09229326f, -0.00126940f, -0.02896081f, -0.05151059f, 0.07702537f, -0.01957526f, 
    -0.03890780f, -0.09235001f, -0.06453816f, -0.02099722f, 0.04091858f, -0.14569212f, 0.00671374f, -0.06367566f, 
    -0.13838109f, 0.06030834f, 0.11794811f, 0.08977299f, -0.14171034f, 0.15346846f, 0.04037045f, 0.13861281f, 
    -0.01526821f, -0.02148034f, 0.01065257f, -0.06657590f, 0.20880787f, 0.09115553f, 0.08156269f, -0.03751649f, 
    -0.06258737f, 0.23424226f, 0.16371982f, 0.05723512f, 0.09216430f, 0.02167061f, 0.02150077f, -0.09405256f, 
    0.04596712f, 0.16319861f, 0.06158900f, -0.01315501f, 0.09704814f, 0.01767468f, -0.02819496f, -0.03876463f, 
    0.11189863f, -0.30030060f, -0.07151489f, -0.02936882f, 0.06778516f, 0.10449278f, 0.14468773f, 0.07486831f, 
    -0.30073357f, 0.11922612f, 0.10812731f, 0.44407970f, -0.07535212f, -0.06300151f, 0.02818385f, 0.05077923f, 
    -0.07848157f, -0.06207854f, -0.00900455f, 0.02232445f, -0.11943929f, -0.14121145f, -0.14612751f, 0.12222888f, 
    0.01933701f, -0.10933135f, 0.05333761f, 0.02650195f, -0.08984046f, -0.14815733f, 0.14143711f, 0.09266543f, 
    -0.17923954f, -0.08938432f, -0.12335006f, 0.32162604f, 0.00167538f, -0.12037367f, -0.04899660f, 0.24305122f, 
    -0.11344207f, -0.07608040f, 0.26930985f, 0.03752849f, -0.13572621f, -0.02427419f, -0.08628604f, 0.07419627f, 
    -0.04322596f, 0.08035705f, 0.07053768f, 0.12538177f, -0.03738789f, 0.01293698f, -0.03570820f, -0.09718461f, 
    0.15076801f, -0.10565551f, 0.01351080f, -0.07690785f, -0.06469019f, -0.02088356f, 0.06082999f, -0.02935949f, 
    -0.06971005f, -0.06972925f, -0.01413550f, -0.10224790f, -0.39593431f, 0.06923335f, 0.07798702f, 0.22425799f, 
    -0.16260041f, 0.01161770f, -0.02168416f, -0.00699002f, 0.11695268f, 0.04996422f, 0.04901236f, 0.03077631f, 
    0.17812909f, 0.00116364f, 0.04979628f, 0.08442633f, -0.11418611f, 0.03092312f, 0.12966229f, 0.14898412f, 
    -0.12517269f, 0.05785066f, 0.04611977f, 0.01232287f, -0.02116702f, -0.18539038f, 0.00915393f, 0.12651445f, 
    0.03589339f, -0.05899335f, 0.06748786f, 0.01739518f, -0.21812882f, 0.02424143f, 0.02438716f, 0.11156728f, 
    -0.24045545f, -0.00641913f, 0.25121352f, 0.06803289f, -0.14680158f, 0.09756253f, -0.07561450f, -0.08728854f, 
    -0.06659082f, 0.18763222f, 0.07083322f, -0.00030784f, -0.15930989f, -0.18336077f, -0.02407605f, 0.11516304f, 
    -0.00341677f, 0.11054979f, -0.03651356f, 0.03049079f, -0.04179556f, -0.04663445f, -0.04912512f, -0.03195597f, 
    0.03090945f, -0.01924702f, -0.21996386f, -0.04183027f, 0.24294902f, 0.05080329f, 0.02871922f, 0.25727391f, 
    -0.02688492f, 0.03449765f, -0.07567740f, 0.00839936f, 0.18651234f, 0.29696369f, -0.02525845f, -0.16807790f, 
    0.05740295f, 0.00652683f, -0.20079297f, -0.12399972f, -0.01810954f, 0.05758744f, -0.03745486f, -0.12135722f, 
    -0.04623966f, -0.17752174f, -0.04355112f, 0.03795276f, 0.03437470f, 0.00590813f, -0.04120928f, 0.00400831f, 
    -0.05474832f, -0.06012877f, 0.03622532f, -0.04925480f, -0.32822308f, -0.40171319f, 0.31586292f, 0.25434771f, 
    0.17382534f, -0.08997389f, 0.01840784f, 0.19350992f, 0.02715778f, 0.15216859f, -0.25848487f, -0.00691601f, 
    0.31024867f, -0.42931464f, -0.01750438f, -0.03965887f, -0.10096621f, 0.10723608f, -0.13796568f, -0.01687053f, 
    -0.00199302f, -0.15529732f, -0.09885689f, 0.01368757f, 0.14598013f, -0.14347197f, -0.15459928f, -0.05873602f, 
    0.03201132f, -0.04009951f, -0.01629853f, -0.00241813f, 0.12130159f, -0.10462635f, 0.07827175f, 0.10073408f, 
    -0.00049443f, -0.03307795f, 0.02191293f, 0.02072058f, -0.01281991f, 0.01068794f, -0.00789641f, 0.01631012f, 
    -0.03502800f, -0.02533247f, 0.01874819f, 0.00841518f, -0.02771753f, 0.00361598f, -0.03056892f, -0.01305005f, 
    0.01718102f, -0.02095324f, 0.02522672f, 0.02201749f, -0.00038015f, -0.03329058f, -0.03487226f, 0.01422253f, 
    0.01990566f, 0.00735825f, -0.01149848f, -0.03074462f, 0.01879582f, 0.00837063f, 0.02110468f, 0.00393136f, 
    -0.02326420f, 0.00158721f, -0.00848896f, 0.01480831f, -0.02956319f, 0.02108446f, 0.01782401f, -0.04206626f, 
    -0.02046566f, -0.00786212f, -0.00371317f, -0.03242268f, 0.01331580f, -0.01853130f, -0.02676471f, 0.01999308f, 
    0.00321987f, -0.02510334f, -0.00189095f, -0.02067859f, 0.02271441f, -0.00067622f, 0.00930539f, -0.01468040f, 
    -0.01813253f, -0.00893439f, -0.01634625f, -0.00951245f, 0.00408712f, -0.00249017f, 0.02471887f, -0.02743954f, 
    -0.03260788f, -0.02772134f, -0.02279101f, 0.02799755f, -0.02016972f, 0.01774674f, -0.03767781f, 0.02396609f, 
    -0.03169262f, 0.02166127f, -0.00028309f, 0.00403053f, 0.02862607f, -0.02155400f, -0.01617858f, -0.03132990f, 
    0.01724464f, -0.02652599f, 0.00589293f, -0.03899650f, -0.01966875f, -0.03144370f, 0.02868730f, 0.01212115f, 
    0.01669807f, 0.01797041f, -0.03907291f, -0.00009054f, -0.02702534f, 0.00405387f, 0.01816504f, -0.00274102f, 
    -0.03119594f, -0.03467383f, 0.01613867f, 0.03776175f, 0.02240534f, -0.01186457f, 0.02364484f, -0.00975475f, 
    -0.02700369f, 0.00027732f, 0.01496466f, -0.03043316f, -0.00946278f, -0.03129031f, -0.02689584f, 0.01334338f, 
    0.01215746f, 0.01054916f, 0.02566729f, -0.00912947f, 0.01350877f, -0.03620709f, -0.00077949f, -0.03295827f, 
    0.00778656f, 0.00050930f, 0.01478780f, -0.03298938f, -0.01444486f, -0.03336997f, -0.00460942f, -0.02576638f, 
    0.00983170f, -0.01414795f, 0.01626947f, -0.01750353f, -0.01376434f, -0.03784916f, 0.02328937f, 0.02503746f, 
    0.00448778f, 0.00523867f, -0.01024299f, -0.00077240f, -0.04145408f, -0.03720843f, -0.00959717f, 0.01452929f, 
    0.00936662f, -0.01950614f, 0.02768214f, 0.03962279f, -0.01939158f, 0.01952437f, -0.01617732f, -0.00899478f, 
    0.02740955f, -0.01877746f, -0.02773821f, 0.02400079f, -0.04398781f, 0.02796393f, 0.01966631f, -0.00481392f, 
    -0.00873534f, 0.03438104f, -0.03606761f, -0.00237160f, 0.02550096f, -0.03604513f, -0.02468441f, 0.02322187f, 
    0.01478038f, 0.02075680f, 0.00814907f, 0.00304553f, 0.00876076f, 0.03197276f, -0.02998780f, -0.01879178f, 
    0.01448399f, 0.00102460f, 0.01966419f, -0.03140181f, -0.04135910f, -0.02757512f, 0.00210501f, 0.03703699f, 
    0.00590508f, -0.03308785f, -0.01291666f, -0.01895408f, 0.01351012f, 0.01127194f, 0.01021169f, -0.02899869f, 
    0.01186299f, 0.03345562f, -0.01994947f, -0.00368057f, 0.00753538f, 0.00636880f, 0.00606233f, -0.04237503f, 
    -0.03257112f, 0.00125141f, -0.02861788f, -0.00781018f, 0.01563224f, 0.00008054f, -0.02693439f, -0.02094463f, 
    0.03288264f, -0.01980655f, -0.02686833f, -0.01077280f, -0.01662054f, -0.00733087f, 0.00269075f, 0.00886550f, 
    0.02920749f, 0.00606343f, 0.01684977f, -0.01150396f, 0.01544856f, -0.01499136f, -0.04292982f, -0.00276116f, 
    -0.00203706f, 0.00827365f, -0.01377946f, -0.00178644f, -0.00825072f, 0.00735192f, -0.00058337f, 0.02973246f, 
    0.02090111f, -0.02682855f, -0.00911173f, -0.01219962f, 0.02221589f, -0.01618318f, -0.01101643f, 0.01073671f, 
    0.01436126f, -0.02093460f, 0.01212910f, 0.00727886f, 0.01347462f, 0.00455551f, 0.00064715f, 0.02587730f, 
    -0.01011768f, 0.01308615f, 0.00014174f, 0.02648471f, -0.00832441f, 0.02869181f, -0.00818865f, 0.02817457f, 
    -0.00511022f, -0.02003261f, 0.02304825f, -0.03911176f, 0.00685415f, -0.03521966f, -0.02657043f, -0.00490130f, 
    0.01808403f, -0.02137582f, 0.03280736f, -0.02599318f, 0.01457092f, 0.01437761f, -0.01204514f, 0.01852486f, 
    -0.00202966f, 0.00261436f, -0.03422061f, -0.01960916f, 0.00851658f, -0.02695571f, 0.00814652f, 0.00124849f, 
    -0.02648931f, -0.00752642f, 0.02073701f, 0.01977658f, -0.01852761f, -0.01446535f, 0.00766770f, -0.02153785f, 
    0.00711622f, 0.03038445f, 0.02580035f, -0.03817127f, -0.00849580f, -0.02589648f, 0.02488500f, 0.00930340f, 
    0.01863307f, -0.02266051f, -0.03259807f, -0.01869916f, 0.01210333f, 0.00410663f, -0.01864272f, 0.02272926f, 
    0.00814510f, -0.01408272f, -0.03340552f, -0.01842991f, -0.02851558f, -0.01953573f, -0.01879991f, 0.02624535f, 
    0.02789721f, 0.00699979f, -0.01815613f, 0.00505421f, 0.01599749f, -0.04967345f, -0.02363886f, 0.02492026f, 
    0.01129689f, -0.03073611f, 0.00586931f, 0.01633070f, -0.00386715f, 0.01118174f, -0.02799452f, 0.02087365f, 
    -0.01373286f, -0.03211439f, -0.00241613f, 0.01183892f, 0.01119078f, 0.02500091f, -0.04338615f, 0.02319866f, 
    0.02221479f, -0.04234732f, 0.00831468f, 0.02889246f, 0.02292904f, -0.01773155f, 0.02705581f, 0.01758108f, 
    -0.03816602f, -0.02650207f, -0.03623452f, -0.03184836f, -0.02146878f, 0.01307794f, -0.02798215f, -0.03058394f, 
    -0.02953395f, -0.00637399f, -0.00562005f, 0.00711696f, -0.01997599f, -0.03701847f, -0.03882789f, 0.02934335f, 
    -0.02218742f, 0.00984418f, 0.02471643f, 0.00177633f, -0.02281911f, 0.00517107f, -0.03944086f, 0.00896392f, 
    -0.00662980f, 0.01826779f, 0.01027842f, -0.03215840f, 0.00136456f, 0.02954816f, -0.02974616f, -0.01348122f, 
    0.00056630f, -0.03304129f, 0.01504080f, -0.02887226f, -0.00574603f, -0.04212758f, -0.01671422f, -0.00251285f, 
    -0.03846936f, 0.00994180f, 0.00359641f, 0.00006168f, 0.01297343f, -0.01491261f, -0.03216454f, -0.00773740f, 
    -0.00394615f, 0.00857640f, 0.02084056f, 0.01073548f, -0.00733932f, -0.01801876f, 0.00634390f, 0.02796480f, 
    -0.02633388f, -0.03163561f, 0.01149719f, 0.02326484f, 0.01392905f, 0.02633870f, 0.00088860f, -0.00349568f, 
    0.02173795f, -0.01718007f, 0.01735751f, 0.02960729f, 0.01674981f, -0.03336731f, 0.02159013f, 0.02808193f, 
    -0.01523272f, 0.00392780f, -0.02330410f, -0.01095425f, -0.02497619f, -0.01400171f, 0.01106216f, -0.00498969f, 
    0.02445684f, -0.01799895f, 0.00504710f, 0.00529049f, 0.02609793f, 0.01880740f, 0.02691634f, 0.01297665f, 
    -0.01305797f, -0.02000589f, -0.03217357f, -0.02116675f, -0.01952473f, -0.03197230f, -0.01769941f, 0.01364100f, 
    -0.02965051f, -0.04367147f, -0.01275680f, -0.01073165f, 0.00263356f, 0.00276779f, 0.00726516f, 0.01067602f, 
    -0.03324813f, -0.01654368f, -0.01206615f, -0.01654452f, -0.02099622f, -0.02731421f, -0.01574407f, -0.00034428f, 
    0.00065482f, 0.01407175f, -0.01350777f, -0.03984619f, -0.00772325f, 0.00691392f, -0.03252098f, -0.03119455f, 
    -0.03658638f, 0.01640009f, -0.00404531f, 0.00229387f, -0.01797405f, -0.02696097f, -0.03681434f, 0.00884623f, 
    0.02369897f, 0.00239403f, -0.00445884f, 0.02031080f, 0.00302086f, 0.02973242f, 0.01871061f, 0.00399304f, 
    -0.01817818f, 0.01958246f, 0.02712128f, 0.01582534f, 0.00210454f, -0.04139123f, 0.01567368f, -0.03982568f, 
    0.01539087f, 0.01143562f, 0.03059814f, -0.02126189f, 0.01787788f, 0.00716926f, -0.02996544f, 0.00456949f, 
    0.00225371f, -0.00393065f, -0.00351148f, -0.02727246f, -0.04720553f, 0.02455494f, 0.01045277f, 0.02358622f, 
    0.02542459f, -0.00795609f, 0.01153620f, -0.00137899f, 0.00193693f, -0.04227818f, -0.02864615f, 0.01427657f, 
    0.02776980f, 0.00310745f, -0.03412380f, -0.03231371f, -0.03326543f, 0.00346752f, -0.02921184f, 0.02369930f, 
    0.02243836f, 0.02035470f, -0.03603321f, -0.00107326f, 0.02056325f, 0.02447457f, 0.02325445f, 0.02101750f, 
    0.02302278f, 0.02573832f, -0.03303534f, -0.03780715f, 0.01462916f, -0.01514395f, -0.02687560f, -0.02095873f, 
    -0.01468371f, -0.01728030f, 0.01142012f, -0.00206777f, -0.00217208f, 0.02565653f, -0.03385151f, -0.02119180f, 
    0.01599388f, -0.00820813f, 0.03608582f, -0.01555906f, 0.03145473f, -0.01435724f, 0.02602239f, 0.00434530f, 
    -0.00367938f, 0.00319573f, -0.00760915f, 0.01831370f, -0.03898887f, -0.00057428f, 0.02833716f, -0.02725869f, 
    0.02080365f, -0.01220670f, 0.01477454f, 0.00591554f, -0.03459949f, 0.02719995f, -0.00295260f, -0.02876027f, 
    -0.03491874f, 0.02794947f, -0.02464266f, 0.02620305f, -0.00046219f, -0.01223955f, 0.00857458f, -0.01353670f, 
    -0.02981650f, -0.02869409f, 0.03082692f, -0.02576418f, -0.01150874f, -0.02790554f, 0.01020140f, -0.02725502f, 
    -0.02780967f, 0.02627976f, 0.01706816f, -0.01117919f, 0.02471016f, 0.02249071f, -0.01365137f, 0.01590518f, 
    -0.01708766f, -0.00818349f, -0.00073419f, -0.01213587f, -0.03852245f, 0.01687122f, -0.00111365f, -0.02853487f, 
    0.02881094f, -0.03294084f, -0.01161597f, -0.00500696f, -0.01829327f, 0.00455119f, -0.01516890f, -0.00815532f, 
    0.03025672f, -0.02259464f, -0.02709267f, 0.01919099f, 0.03068299f, -0.00847790f, -0.00869603f, -0.02804730f, 
    0.01038169f, -0.01386701f, -0.03808213f, -0.02035929f, 0.00792192f, 0.02043614f, 0.01258208f, 0.01923601f, 
    0.03146263f, -0.01489650f, -0.03641929f, 0.00815114f, -0.03906201f, -0.01492949f, -0.01279530f, -0.00833068f, 
    -0.02704999f, 0.01060431f, -0.00872352f, 0.00805134f, 0.01425536f, -0.02175447f, -0.01506335f, -0.01146316f, 
    -0.01432577f, 0.01328633f, -0.03112630f, 0.01659719f, -0.01276738f, -0.03013433f, -0.01854219f, 0.02520753f, 
    -0.03628687f, 0.03502405f, 0.00667074f, 0.02535742f, 0.00283546f, 0.02331965f, -0.01108235f, -0.00839023f, 
    -0.01776803f, 0.02721412f, 0.00554049f, -0.00931037f, 0.02646083f, -0.00861345f, 0.00245622f, 0.02101556f, 
    -0.03476339f, -0.03647178f, -0.03960363f, -0.00727489f, 0.00546527f, 0.00335505f, 0.02867123f, -0.00529513f, 
    -0.03880900f, 0.03456435f, -0.00987926f, -0.02647563f, -0.01776707f, 0.00569431f, -0.02814464f, 0.01280400f, 
    0.01693141f, -0.02084640f, 0.02370109f, 0.02239613f, -0.02721350f, 0.00356485f, 0.01464700f, 0.03293591f, 
    0.02875116f, -0.00075357f, 0.02228696f, 0.01854868f, 0.02299726f, 0.02389771f, -0.01567930f, 0.00846960f, 
    0.02411947f, -0.02899816f, -0.02768341f, 0.01449133f, -0.02537513f, -0.04350639f, 0.00217031f, -0.03354302f, 
    0.03080752f, -0.01524689f, -0.00689791f, -0.02681099f, -0.01910225f, -0.02186722f, -0.00301942f, -0.03300733f, 
    0.01335595f, -0.01566922f, 0.01648467f, -0.00450122f, 0.02920602f, -0.00976275f, -0.01125270f, 0.01270946f, 
    0.01490796f, -0.02873912f, 0.01124005f, 0.00671328f, 0.00671878f, -0.00016367f, -0.02565705f, -0.02951245f, 
    -0.00765880f, 0.02406552f, 0.02052440f, -0.00449668f, 0.01856834f, -0.02723487f, 0.01591210f, -0.00556155f, 
    -0.00548312f, -0.01954419f, -0.02695361f, -0.03977865f, 0.01475095f, -0.00267431f, -0.03612847f, -0.03526871f, 
    0.02751392f, 0.00345412f, 0.00792041f, -0.02176703f, 0.00043056f, 0.00748720f, 0.02948233f, 0.01942687f, 
    -0.01247771f, 0.02289524f, 0.02802118f, 0.02417221f, 0.03722509f, -0.03016367f, -0.01505247f, -0.03427883f, 
    -0.02955737f, -0.00182993f, 0.01903690f, -0.03105361f, -0.00330353f, -0.01362034f, 0.02141621f, -0.02650528f, 
    0.07946830f, 0.18119344f, 0.10369744f, 0.01531277f, -0.02688298f, 0.00714442f, -0.00783799f, 0.01358138f, 
    0.00802021f, 0.04422912f, 0.05626522f, -0.08111523f, 0.09542885f, -0.20852587f, -0.11067116f, 0.07968009f, 
    0.05054007f, 0.10027180f, 0.12053238f, 0.19932793f, -0.02973644f, 0.01450712f, 0.01075582f, -0.04814087f, 
    -0.31811413f, -0.06335726f, 0.04064572f, -0.12928130f, -0.16196910f, -0.26570162f, -0.20974828f, -0.04480441f, 
    -0.01583808f, -0.03931711f, -0.06121520f, -0.00581600f, -0.11655366f, -0.05147609f, -0.11794362f, -0.05593704f, 
    -0.20451716f, -0.21038365f, -0.01474295f, 0.07405850f, -0.19048889f, -0.03246885f, 0.01277073f, -0.03211074f, 
    0.18713765f, -0.12188574f, 0.02121658f, 0.14888588f, 0.09230284f, 0.08940796f, -0.11429087f, 0.16183530f, 
    -0.03949609f, 0.05092834f, 0.12785204f, -0.03529485f, -0.22707303f, 0.01771053f, -0.13750561f, 0.19084635f, 
    0.16370572f, 0.20362529f, -0.02390259f, 0.01990174f, 0.08251633f, -0.03269914f, 0.06289788f, 0.00227493f, 
    -0.06393023f, -0.20289223f, -0.11822183f, 0.03720672f, -0.06516439f, 0.06227512f, -0.06717795f, 0.05333241f, 
    0.09077748f, -0.00907887f, 0.15059584f, 0.01975796f, -0.12239390f, 0.01136193f, -0.00113878f, -0.25704333f, 
    -0.15318154f, 0.00565064f, -0.06612687f, -0.02963722f, 0.01486568f, 0.08501894f, 0.19016822f, 0.16920213f, 
    0.25110611f, -0.24830779f, 0.30059111f, 0.03172807f, 0.12857047f, 0.17102063f, 0.00476446f, 0.15837808f, 
    -0.04013439f, 0.01213315f, 0.13152334f, 0.06970797f, 0.04767368f, 0.03819354f, 0.01452043f, 0.03617160f, 
    0.09732161f, 0.22084381f, 0.00569246f, -0.02119970f, -0.07138621f, 0.08346783f, 0.11765074f, 0.07001219f, 
    -0.02671235f, -0.02369949f, 0.13012449f, -0.05377894f, 0.05329950f, -0.10250659f, -0.02251404f, -0.04558093f, 
    -0.03047858f, -0.02463896f, -0.05726922f, 0.04133273f, 0.11342978f, 0.12960215f, 0.03727693f, 0.02666447f, 
    -0.00744367f, -0.07022405f, -0.04810970f, 0.05378269f, 0.15416336f, -0.05308133f, 0.11661056f, 0.10743447f, 
    0.12963852f, 0.44942901f, -0.19527628f, -0.19936214f, 0.02068995f, -0.05730119f, 0.14045808f, 0.05176135f, 
    -0.08245477f, -0.02124384f, 0.01903906f, -0.04130300f, 0.00151274f, -0.01210795f, 0.15538415f, -0.03758627f, 
    0.01843605f, -0.12025173f, 0.01569470f, 0.01514997f, 0.03365780f, -0.05510401f, -0.15776993f, -0.11956618f, 
    0.13619849f, 0.25906008f, 0.01392395f, -0.01541648f, 0.07383466f, 0.02022796f, -0.01322146f, 0.19124685f, 
    0.03602658f, 0.06986895f, -0.06426274f, -0.14397226f, -0.01207981f, -0.44183198f, 0.15735281f, -0.18257408f, 
    0.01903996f, 0.14084664f, -0.16348746f, 0.17857975f, 0.05609200f, 0.19410031f, -0.00420077f, 0.00917351f, 
    0.17334127f, 0.04190098f, 0.00817500f, 0.02018532f, 0.05931069f, -0.10470665f, 0.04088615f, 0.08021814f, 
    -0.07030082f, -0.06158968f, -0.04040005f, 0.01433576f, -0.20710836f, -0.08704025f, -0.12254895f, 0.08549479f, 
    0.13028362f, 0.05955351f, -0.04679444f, 0.07720521f, -0.06451737f, -0.13270445f, -0.04731203f, -0.02651288f, 
    -0.00977273f, -0.05990550f, -0.04046460f, -0.12219808f, -0.07613346f, -0.00879902f, 0.04801029f, 0.04720714f, 
    -0.05301654f, -0.27711424f, -0.10122591f, -0.29598883f, -0.25105000f, -0.17492253f, -0.15680715f, 0.23078530f, 
    -0.04455917f, 0.12774567f, 0.03911565f, 0.11785048f, 0.03878540f, 0.04869114f, 0.03145088f, -0.00676141f, 
    -0.10284549f, 0.23346484f, -0.14301533f, 0.09681763f, -0.04709266f, -0.03257592f, -0.08520149f, 0.05098254f, 
    0.08537561f, 0.07744122f, 0.04800809f, 0.12462306f, 0.08968186f, 0.14404735f, -0.10471862f, -0.12741263f, 
    0.03375853f, 0.05067140f, -0.01541330f, 0.02514342f, -0.12161528f, -0.19109577f, -0.05045698f, -0.23433667f, 
    -0.09700432f, 0.03271274f, 0.15943809f, -0.09983872f, 0.14598204f, 0.07702684f, -0.04754793f, 0.05061400f, 
    0.02935329f, -0.01711901f, 0.07350487f, 0.13867326f, 0.13795783f, 0.18654405f, -0.02412051f, 0.27320847f, 
    -0.02937618f, 0.11926999f, -0.12033892f, -0.04872010f, -0.04373317f, 0.01451495f, 0.24420625f, 0.26664612f, 
    0.07215586f, -0.04661136f, 0.14017560f, -0.07332118f, 0.12898640f, 0.06746303f, 0.04432696f, 0.16259645f, 
    0.00798171f, 0.07965302f, -0.01246442f, -0.07841156f, -0.14884309f, -0.24852368f, -0.16687052f, -0.14261737f, 
    -0.01583255f, -0.04402418f, -0.01585134f, -0.14472499f, 0.09087974f, 0.09648923f, 0.16290635f, 0.19041604f, 
    0.00276970f, 0.06239747f, -0.04530582f, -0.14776750f, 0.09483441f, -0.04435610f, 0.09301732f, 0.01066162f, 
    -0.11389472f, -0.17490223f, -0.06811459f, -0.01182797f, 0.04605619f, -0.17419931f, -0.11131269f, -0.12361115f, 
    0.06780855f, 0.05149516f, -0.06812496f, 0.14434679f, 0.16037098f, -0.06871210f, -0.01554871f, -0.00157799f, 
    0.16397434f, 0.09624424f, -0.00969798f, -0.05691068f, -0.06424730f, -0.06282190f, -0.10069324f, -0.07301734f, 
    0.03069973f, 0.03613210f, 0.18688743f, 0.14473785f, 0.10939074f, -0.00363545f, 0.11628347f, 0.05681971f, 
    0.07286996f, -0.04982031f, 0.01879914f, 0.02172337f, -0.07032552f, -0.02142860f, 0.01654886f, -0.03941432f, 
    0.06986062f, -0.07288226f, 0.24750189f, -0.29287499f, -0.02058770f, -0.09387146f, 0.02684555f, -0.09704866f, 
    -0.02462132f, -0.01805453f, 0.15931883f, 0.03462836f, 0.04265984f, 0.19486523f, 0.00038990f, -0.22480440f, 
    -0.00078400f, -0.00434179f, 0.15431894f, -0.01011304f, -0.02752482f, 0.04731006f, -0.02539157f, -0.09750085f, 
    -0.09085747f, -0.01185061f, 0.12237184f, -0.05360506f, 0.26074675f, 0.08288366f, 0.06965217f, -0.02176922f, 
    0.05064027f, 0.00731263f, -0.07715043f, 0.05393431f, 0.12023845f, -0.10605432f, -0.00568353f, 0.07854617f, 
    0.08767471f, 0.00668559f, -0.02317224f, 0.07017650f, -0.03690854f, 0.02069795f, -0.01601481f, 0.04141952f, 
    0.11423919f, 0.12554772f, -0.09360006f, 0.16173643f, -0.01939700f, 0.07560555f, 0.14702190f, -0.07791229f, 
    0.15189448f, 0.05804032f, 0.18212028f, 0.19204836f, 0.07217777f, 0.21678327f, -0.20184933f, -0.11094201f, 
    0.06593376f, 0.02183707f, -0.05127055f, 0.05419909f, -0.01488794f, -0.06796011f, -0.26269695f, 0.07024311f, 
    0.15134090f, 0.15868668f, 0.07214369f, -0.15267205f, -0.06287268f, -0.01086133f, -0.11757246f, -0.03495592f, 
    0.05628650f, 0.04751720f, 0.12438782f, -0.01913531f, 0.37106350f, 0.11373527f, -0.07781889f, 0.17119160f, 
    0.02617818f, -0.03364691f, -0.03897779f, 0.12260631f, 0.04601459f, 0.07411253f, -0.05201519f, 0.07203177f, 
    -0.23289600f, -0.20551573f, 0.05259309f, -0.02765199f, 0.04333316f, -0.01300461f, 0.04145880f, -0.03409192f, 
    -0.15741473f, -0.00789091f, -0.05306068f, 0.06704532f, 0.23947467f, -0.02351969f, 0.29837108f, -0.17165299f, 
    0.01652407f, -0.01429315f, 0.03524904f, 0.02283571f, 0.06530331f, 0.12145891f, 0.01128862f, 0.03878714f, 
    -0.27900523f, -0.03968196f, 0.04564795f, 0.05676040f, -0.10541769f, 0.10498828f, -0.19372962f, 0.14961573f, 
    -0.00549610f, -0.02016785f, -0.10414838f, -0.26564080f, 0.07976008f, 0.06774229f, 0.02348257f, 0.00197655f, 
    -0.06325463f, -0.05130135f, -0.02405639f, -0.05733586f, -0.17209527f, -0.12717751f, -0.00348342f, -0.13922168f, 
    -0.09717689f, 0.22462438f, -0.04485832f, 0.12112089f, 0.00715322f, -0.03553628f, -0.13509852f, -0.00757485f, 
    0.14976265f, 0.00710666f, -0.03851239f, 0.31293970f, -0.33854413f, 0.11924188f, -0.05543955f, -0.00585377f, 
    0.11175768f, -0.01382879f, 0.06944217f, 0.05459852f, 0.14043802f, -0.04169251f, 0.04017462f, 0.05572681f, 
    -0.09178775f, -0.09468651f, -0.18015730f, -0.16690089f, -0.11733199f, -0.10523141f, -0.02248672f, 0.10097736f, 
    0.01199933f, 0.06529742f, -0.12041894f, -0.14345318f, 0.08394308f, -0.20963864f, -0.08611553f, -0.07358450f, 
    0.07447910f, 0.11386181f, 0.06906616f, 0.15875511f, 0.01418206f, -0.05693525f, -0.07878969f, -0.01702478f, 
    -0.07653275f, -0.21632397f, -0.20305371f, -0.08141627f, 0.04282920f, 0.06760669f, -0.09776291f, 0.13376568f, 
    0.12847473f, 0.04578243f, 0.02027042f, -0.03412276f, -0.11297874f, -0.08216367f, -0.05930417f, 0.16088322f, 
    -0.04091657f, 0.04158004f, -0.02095434f, 0.20691232f, -0.17145656f, -0.09067345f, -0.06429704f, -0.02200357f, 
    0.30165088f, 0.00242460f, -0.15818791f, -0.38060975f, -0.09255290f, 0.17831092f, 0.05244107f, -0.12485266f, 
    0.05526447f, -0.06566865f, 0.08467078f, 0.18948576f, 0.24782561f, 0.00215785f, 0.09056038f, -0.09346476f, 
    -0.10059019f, -0.18869770f, -0.06689806f, -0.09360866f, 0.05004549f, 0.00465417f, 0.14788789f, 0.09488170f, 
    0.14460546f, -0.13608193f, 0.25958142f, -0.28292319f, -0.01739420f, -0.05731073f, 0.05506275f, 0.16321555f, 
    0.12779316f, 0.18088327f, -0.06353831f, -0.17659472f, -0.06412117f, -0.03335945f, 0.00421529f, -0.04380097f, 
    -0.10384594f, 0.06189210f, -0.01452633f, -0.07335051f, 0.11858929f, 0.09782890f, 0.14367202f, 0.09710489f, 
    -0.26929295f, 0.08771825f, -0.04792387f, 0.04165682f, -0.18270695f, -0.03549578f, -0.30334237f, -0.00179665f, 
    0.26327124f, 0.06017792f, 0.05039323f, 0.31215206f, 0.35605747f, -0.20021445f, 0.06251723f, -0.18365094f, 
    0.15997052f, -0.05666155f, 0.02113688f, 0.10639574f, -0.09629773f, 0.05333977f, 0.12226032f, -0.09306256f, 
    -0.11289866f, -0.17879902f, 0.04473005f, 0.19094349f, 0.21442701f, 0.08477573f, 0.03472101f, -0.02845868f, 
    0.02259063f, 0.08993619f, -0.09640291f, 0.02871944f, -0.14760758f, 0.01714563f, -0.20317705f, -0.31495726f, 
    -0.06141022f, -0.13909324f, -0.11679979f, -0.20496731f, 0.15610795f, 0.01067625f, -0.11250757f, 0.24264929f, 
    0.14353523f, 0.18484992f, -0.06182950f, -0.08823086f, 0.12831509f, -0.17219743f, 0.16063142f, 0.05885947f, 
    -0.14178164f, 0.05956708f, -0.02984036f, -0.07013964f, 0.01820051f, 0.00478171f, 0.08417338f, -0.11910459f, 
    -0.10279310f, -0.22363581f, -0.14661704f, -0.18173052f, -0.11877380f, -0.17025727f, -0.05355180f, -0.00376522f, 
    -0.15267396f, -0.13471414f, 0.03341776f, 0.03832162f, 0.02387145f, 0.27401140f, -0.13711748f, -0.08758133f, 
    0.03868093f, -0.06256861f, 0.08333775f, 0.00945260f, -0.21157959f, 0.06045181f, 0.13993961f, -0.00347746f, 
    -0.05282705f, 0.06602573f, 0.12996496f, -0.12000004f, 0.03085898f, -0.15401590f, 0.03725740f, -0.10051232f, 
    0.01211052f, 0.10440627f, -0.02405594f, -0.05573315f, -0.16784370f, -0.18523969f, -0.12832385f, -0.10660366f, 
    -0.04997342f, 0.04695395f, 0.01894009f, 0.02071467f, 0.36269909f, 0.56676191f, -0.24517965f, -0.34505743f, 
    -0.00203350f, 0.03617522f, -0.00709232f, 0.01036725f, 0.07290319f, -0.03255229f, 0.26132327f, 0.03555188f, 
    -0.36158428f, 0.30181083f, -0.08863506f, 0.12242556f, -0.04232550f, -0.10590024f, 0.01125352f, -0.08892327f, 
    -0.06659184f, 0.14977288f, 0.16698137f, -0.12093440f, -0.19519523f, 0.08884341f, -0.01412464f, 0.04632704f, 
    -0.02377112f, -0.01969723f, -0.03807172f, -0.10183420f, -0.21447094f, -0.00470878f, -0.13199583f, -0.22393507f, 
    0.00026690f, -0.00895613f, -0.03457719f, -0.02929978f, -0.02259761f, -0.01696143f, -0.01720529f, 0.00244973f, 
    -0.03302604f, -0.01291130f, -0.03990767f, -0.01534146f, -0.01833823f, -0.02430695f, -0.00196877f, -0.01270201f, 
    -0.00598893f, -0.02790604f, -0.01883040f, 0.00403959f, -0.04163121f, -0.00204769f, -0.02235154f, -0.01705048f, 
    -0.03633188f, 0.01133347f, -0.02023198f, -0.00424407f, -0.02461554f, -0.03352315f, 0.01008448f, 0.02430622f, 
    -0.03957374f, -0.03334787f, -0.03960053f, -0.02735056f, -0.03606546f, -0.03300053f, -0.04130128f, 0.02543201f, 
    0.01541138f, 0.01790757f, -0.00437654f, -0.01387423f, -0.00136814f, 0.01377455f, 0.00492402f, -0.02530129f, 
    -0.03461621f, -0.02496760f, 0.01064171f, 0.01786289f, 0.01148633f, 0.01382754f, -0.00381431f, 0.00414000f, 
    -0.00051706f, -0.02879064f, -0.03397014f, -0.01760904f, 0.00985853f, -0.00948817f, -0.03253573f, -0.03532792f, 
    -0.02926623f, -0.02971544f, 0.02306272f, 0.00465870f, -0.02824539f, -0.00840440f, 0.02069884f, 0.01599379f, 
    -0.03790792f, 0.01634950f, 0.02686882f, 0.01215977f, -0.02744709f, 0.01880116f, 0.02791989f, -0.01028065f, 
    0.01947229f, 0.02013609f, -0.04124821f, -0.03653669f, -0.00932577f, 0.04176265f, 0.02351966f, 0.02578859f, 
    0.01663441f, -0.01826232f, 0.01732828f, 0.02258151f, 0.01310872f, -0.00956646f, -0.01659071f, 0.01663430f, 
    -0.02857777f, -0.02283053f, 0.00425625f, 0.02744712f, -0.03964862f, -0.00059606f, -0.00304342f, 0.00210981f, 
    0.02647199f, 0.02401027f, 0.02514128f, -0.03937658f, 0.02510486f, -0.03026394f, 0.02089299f, -0.02862584f, 
    -0.00236594f, -0.00603595f, 0.02534608f, -0.04002615f, -0.00478134f, 0.01070324f, 0.02074605f, -0.03871600f, 
    0.01606507f, 0.01219125f, 0.02162108f, 0.01238365f, 0.01453843f, 0.00165801f, -0.00173901f, -0.01689701f, 
    -0.01350743f, 0.02524085f, 0.01553442f, 0.01544360f, 0.01615204f, -0.01487940f, 0.00772604f, 0.03759602f, 
    0.02850412f, -0.02984284f, -0.02404056f, -0.01351211f, -0.01109170f, -0.00064402f, -0.02355829f, -0.03238355f, 
    -0.01926539f, 0.01727901f, -0.01694037f, -0.00819156f, -0.03747302f, -0.03018007f, 0.00137445f, 0.00106625f, 
    0.01325955f, 0.02179517f, 0.01665320f, -0.03596321f, 0.02895226f, -0.02971635f, -0.02624265f, -0.01304736f, 
    -0.03219511f, -0.03512533f, 0.03617984f, 0.02293446f, -0.02365019f, -0.01008854f, -0.00573556f, -0.00092864f, 
    -0.04134067f, 0.03000218f, 0.02756313f, 0.01563016f, -0.03696696f, -0.01343915f, 0.00583939f, -0.04127227f, 
    -0.04203791f, 0.00076248f, -0.00601388f, -0.02639530f, 0.01102148f, -0.02594618f, 0.01241493f, -0.04151147f, 
    -0.03509252f, -0.00369311f, -0.01734501f, 0.01187136f, 0.00527805f, -0.01578206f, -0.00449708f, -0.04048871f, 
    -0.01509830f, 0.00289881f, -0.00474399f, -0.03453788f, -0.01858372f, -0.00529681f, -0.02293103f, -0.01423740f, 
    0.02367915f, -0.02249595f, -0.02941606f, 0.03659507f, -0.04174878f, 0.02810288f, 0.02576851f, 0.01767107f, 
    -0.04017683f, 0.01192389f, 0.00623946f, 0.00993632f, 0.00919721f, -0.00007149f, 0.02278636f, 0.00451661f, 
    -0.02550118f, 0.00150782f, -0.02246800f, 0.02664869f, 0.00664119f, 0.01923831f, -0.01021547f, -0.03753554f, 
    0.02754038f, 0.00496657f, 0.01266354f, -0.02944073f, -0.02180064f, -0.01070664f, -0.03294943f, -0.01831754f, 
    -0.03093247f, -0.00945198f, 0.00195777f, -0.00488409f, 0.01096076f, -0.03513218f, 0.01824551f, 0.02332395f, 
    -0.00630425f, 0.02105778f, 0.01165727f, -0.02421506f, -0.03694200f, 0.00156058f, -0.02887470f, 0.01994733f, 
    -0.02290551f, -0.00041714f, 0.02439400f, -0.04008062f, 0.00627989f, 0.00986704f, -0.03860436f, -0.04155825f, 
    0.01439037f, -0.02236760f, -0.04188055f, 0.00959380f, 0.01804440f, 0.02388657f, -0.00173839f, -0.02938334f, 
    -0.00139564f, -0.03821330f, -0.02943524f, -0.00242168f, 0.02964484f, -0.03537185f, -0.03428318f, -0.01071679f, 
    -0.03524942f, 0.02488809f, 0.01531637f, -0.02791130f, 0.00398985f, -0.03629813f, 0.00083799f, 0.00848672f, 
    -0.00985871f, -0.03963182f, -0.01996962f, -0.02061278f, -0.01863653f, -0.03109750f, 0.01257494f, 0.01929358f, 
    0.01057169f, 0.01850693f, -0.04171676f, -0.00522705f, -0.03680281f, 0.01520256f, 0.01912719f, -0.00618426f, 
    0.01891398f, 0.01951247f, -0.01246406f, -0.03773165f, -0.02652871f, -0.00725941f, 0.02513212f, -0.02287993f, 
    -0.00141581f, 0.00245171f, -0.02428878f, -0.00569186f, -0.03382314f, 0.01082287f, 0.01215003f, 0.00055149f, 
    0.00030064f, -0.04099793f, 0.00432686f, 0.02787089f, 0.02142637f, 0.00717491f, -0.02019898f, -0.03069079f, 
    -0.03214582f, 0.00810252f, -0.01882050f, 0.01702005f, 0.00940851f, -0.02908205f, 0.01695876f, 0.01258443f, 
    -0.02333306f, 0.01693350f, 0.02319787f, -0.03781272f, 0.02677505f, 0.02283657f, -0.00575412f, 0.00768634f, 
    -0.04024357f, -0.00872395f, 0.00597730f, 0.02775252f, -0.00570739f, -0.02259331f, 0.02520655f, -0.03264153f, 
    -0.00669786f, -0.02285367f, 0.01091744f, -0.02095299f, -0.02339353f, 0.02609847f, -0.01789323f, 0.01279722f, 
    0.02218867f, 0.00265957f, -0.01627740f, -0.02098655f, -0.03204829f, 0.02535742f, 0.02528661f, -0.02612233f, 
    0.02262814f, 0.00398999f, -0.02120040f, 0.01677552f, -0.01639462f, -0.01845591f, -0.01581398f, -0.02239985f, 
    -0.02249533f, 0.00551055f, -0.01872474f, -0.01152562f, 0.00421515f, 0.02326658f, 0.01731485f, 0.00403976f, 
    -0.01750462f, 0.02904564f, -0.00596108f, -0.00231502f, 0.00391451f, 0.01375498f, 0.02541735f, -0.01510371f, 
    -0.02141806f, -0.01329974f, -0.04145056f, -0.00240878f, 0.00583030f, 0.01828746f, -0.03642373f, -0.03649768f, 
    0.01407119f, 0.03011996f, 0.02422715f, -0.01767770f, -0.03527923f, 0.02627393f, 0.02226245f, 0.01938212f, 
    -0.03654943f, -0.02339732f, -0.03783510f, 0.00013932f, -0.01868920f, -0.02382633f, -0.03790800f, 0.01029672f, 
    -0.03364034f, 0.02386788f, -0.01986190f, -0.03997083f, -0.04086976f, 0.01881657f, 0.02577928f, 0.00868845f, 
    -0.02919112f, 0.00477084f, 0.00137849f, 0.00382924f, -0.00724079f, 0.02352663f, 0.02930791f, 0.02308047f, 
    -0.00111690f, -0.02882134f, 0.02488328f, -0.00956310f, -0.01909004f, 0.01972442f, 0.02462710f, -0.03298058f, 
    -0.01879272f, 0.03035268f, -0.02737860f, -0.03932147f, 0.01020791f, 0.00307939f, 0.01627108f, 0.01370005f, 
    0.02656127f, -0.01600000f, -0.02260332f, -0.00485415f, 0.00078854f, -0.01304455f, -0.00393927f, 0.01968249f, 
    0.02313411f, -0.00506604f, 0.02912020f, -0.02697130f, -0.01179120f, 0.02277376f, 0.01199716f, -0.03164744f, 
    -0.01601913f, -0.02210211f, -0.00403989f, 0.00694197f, 0.01509607f, -0.02250305f, 0.00338404f, -0.02517208f, 
    -0.01053491f, 0.01403079f, -0.00985175f, 0.02523643f, 0.01741608f, -0.02837585f, 0.02437877f, -0.02102084f, 
    -0.02730676f, 0.02435135f, -0.03089180f, 0.02400300f, -0.02452913f, 0.02103433f, 0.00646132f, -0.02747596f, 
    0.01709119f, -0.03207821f, -0.02560063f, 0.02430464f, -0.02764974f, 0.01963202f, -0.02313985f, -0.01398203f, 
    0.00313462f, 0.01394842f, 0.02487957f, -0.01628429f, -0.00014235f, -0.01591453f, -0.00881924f, 0.04084006f, 
    -0.00941214f, -0.01546025f, -0.02918459f, -0.03867196f, 0.01417572f, -0.00993150f, 0.00184132f, 0.01801278f, 
    0.01454062f, -0.03998123f, 0.01737060f, 0.02322135f, -0.04173726f, -0.02224210f, 0.01896411f, 0.01289191f, 
    -0.01356092f, 0.00420250f, 0.03005906f, 0.01354842f, -0.00552908f, 0.02284691f, -0.04191851f, 0.00072952f, 
    0.02617344f, -0.02890579f, -0.01639289f, -0.02184520f, 0.01012048f, -0.02247001f, -0.04013886f, -0.02127012f, 
    0.02725633f, -0.01615105f, -0.01507659f, 0.02764392f, -0.02821459f, -0.02528556f, -0.01387497f, -0.03494402f, 
    0.02391906f, -0.00081498f, -0.01279940f, -0.01743519f, -0.00001188f, -0.02401112f, 0.01783477f, -0.00581639f, 
    -0.02291377f, -0.01361404f, -0.00067564f, -0.01355090f, -0.03627794f, -0.00672794f, -0.01035080f, -0.03504474f, 
    -0.04046705f, -0.03104741f, -0.02526283f, 0.02490682f, -0.02921568f, -0.01113193f, -0.01641870f, -0.00030693f, 
    -0.03622152f, 0.00471162f, -0.02204071f, -0.02296789f, 0.00903977f, -0.01784433f, 0.01809394f, -0.00812473f, 
    -0.01347457f, -0.02392154f, -0.01722677f, -0.01497469f, -0.02130189f, 0.00885979f, 0.02759427f, -0.02452740f, 
    -0.00651126f, 0.02422396f, 0.01432535f, -0.00103819f, 0.01051168f, -0.02711565f, -0.03977848f, -0.04147655f, 
    -0.02715061f, -0.02155517f, -0.01474561f, 0.00039425f, 0.02184292f, 0.01693205f, -0.02872343f, -0.01713176f, 
    -0.03766450f, -0.03224611f, 0.02985660f, -0.00141584f, 0.00353778f, -0.03393671f, -0.00785507f, 0.01611799f, 
    -0.00594301f, 0.02033573f, -0.03453577f, -0.00367843f, -0.04116866f, -0.02328774f, -0.01322401f, 0.00548607f, 
    -0.03357295f, 0.02259592f, -0.00639578f, 0.02419107f, -0.00104898f, -0.01699236f, 0.02892296f, -0.00410725f, 
    -0.01414018f, 0.00182276f, -0.02573914f, -0.02567991f, 0.01924132f, -0.01509245f, 0.01391609f, 0.02942040f, 
    -0.00515325f, -0.04124926f, -0.02955631f, -0.01153341f, 0.02103740f, -0.03384511f, 0.02665970f, -0.01761637f, 
    0.02978304f, 0.02417126f, -0.00838933f, 0.03073055f, -0.00051171f, -0.00477535f, -0.01933382f, -0.01522079f, 
    -0.03346124f, 0.00148152f, -0.02416326f, -0.00896526f, -0.00627543f, -0.00090038f, -0.00733108f, 0.03739087f, 
    0.00336405f, -0.03124852f, -0.03449951f, -0.00398560f, 0.01099858f, -0.03882103f, -0.02200469f, -0.00315721f, 
    -0.01862988f, -0.03231648f, -0.03105663f, -0.00983079f, 0.02811909f, 0.00035698f, -0.03446891f, 0.02863657f, 
    0.01920474f, 0.02684741f, -0.01684863f, -0.01572707f, -0.02097234f, -0.03135656f, -0.03195718f, -0.03528462f, 
    0.00021851f, 0.02349044f, -0.04104855f, -0.03502509f, -0.01567192f, -0.01407569f, -0.03537064f, -0.02666733f, 
    0.02302921f, -0.04140302f, 0.00616856f, 0.01960586f, -0.00750074f, 0.02070575f, -0.00620247f, -0.01268025f, 
    0.02280118f, -0.03447435f, -0.02184995f, 0.01553053f, 0.02666395f, 0.01463580f, 0.02384438f, -0.00086409f, 
    -0.00966638f, -0.00044941f, 0.00315307f, 0.01643975f, -0.00657482f, -0.02481427f, -0.01926116f, -0.00405896f, 
    0.01769589f, 0.01362826f, -0.01036949f, 0.01438999f, -0.00981892f, 0.00959557f, 0.02143391f, 0.02766216f, 
    -0.04186974f, -0.00552063f, 0.00301158f, -0.01328565f, 0.01574411f, 0.01900025f, 0.01369947f, 0.01342980f, 
    0.00190420f, -0.02705208f, 0.00786529f, -0.02563906f, 0.01988740f, -0.02340387f, -0.02677760f, -0.03801409f, 
    -0.00138142f, 0.01078411f, 0.02213325f, 0.02591994f, 0.02600977f, 0.00987258f, 0.02846551f, -0.03705432f, 
    -0.04094459f, 0.02062027f, 0.02840520f, 0.00190845f, -0.00548693f, -0.01668114f, -0.02418568f, 0.01551523f, 
    0.00811824f, 0.00185406f, -0.01765474f, -0.03595687f, 0.01892223f, 0.03917575f, -0.00244836f, -0.00230467f, 
    -0.02817556f, 0.02790490f, -0.04079051f, -0.02425790f, -0.00234966f, -0.00439249f, 0.03130238f, 0.02042039f, 
    -0.02076947f, 0.00382718f, 0.00172202f, -0.02326531f, -0.04041609f, 0.00310560f, -0.02807249f, -0.02038530f, 
    0.00126688f, -0.01660907f, 0.02739478f, 0.02039108f, -0.00909342f, -0.01503787f, 0.02016712f, -0.03238363f, 
    0.00161428f, -0.03879404f, -0.01029593f, -0.04113882f, 0.02783572f, 0.01581233f, -0.01854706f, 0.02195815f, 
    0.02489001f, -0.00615585f, -0.03668196f, 0.00150003f, -0.02138954f, -0.02369539f, 0.00929607f, -0.03098695f, 
    0.00930207f, 0.00852864f, -0.04075815f, -0.01103181f, 0.01029443f, 0.02081674f, -0.03123396f, -0.03338989f, 
    0.00869386f, 0.03023573f, 0.02343794f, 0.00815427f, -0.02831807f, 0.00354026f, 0.00936785f, -0.01104332f, 
    -0.01459111f, -0.00405858f, 0.01228452f, 0.00875713f, -0.03018194f, -0.00472976f, -0.03869391f, 0.01743370f, 
    0.01288149f, -0.00005417f, -0.02974470f, -0.01254185f, -0.00975441f, 0.02073603f, -0.00628494f, -0.03891584f, 
    0.02827993f, -0.02711659f, -0.00968200f, -0.00937803f, 0.00678065f, -0.00281237f, -0.00793045f, 0.01088417f, 
    -0.03971262f, -0.02149651f, -0.03811203f, -0.00631061f, -0.00370949f, -0.01627275f, 0.00732606f, -0.00620146f, 
    -0.01615534f, -0.00358741f, 0.01158219f, 0.02974701f, -0.01808914f, 0.02712473f, -0.00725985f, -0.02327324f, 
    -0.02971472f, -0.02933243f, -0.00046865f, -0.01610663f, 0.00228206f, 0.01720937f, -0.03851939f, -0.00081025f, 
    -0.03388597f, 0.00265279f, -0.01491967f, -0.02798349f, 0.02998274f, -0.02184597f, 0.02715838f, -0.00099476f, 
    -0.03210826f, 0.02870275f, -0.02968531f, -0.01954840f, -0.00653458f, 0.00328777f, 0.01358412f, 0.02216982f, 
    0.01723278f, 0.02925455f, 0.02917742f, 0.01071796f, 0.01368789f, 0.00227156f, -0.01234776f, 0.01100504f, 
    0.01515080f, -0.01679620f, 0.02557947f, 0.01242762f, 0.02112206f, 0.00595745f, 0.00940168f, -0.02397283f, 
    -0.03086107f, -0.01738963f, -0.01294758f, 0.02955414f, -0.03936105f, -0.02359581f, -0.01971266f, 0.01751408f, 
    0.00787010f, -0.03279969f, -0.00560274f, 0.02969647f, 0.02953617f, 0.00092618f, 0.02069365f, -0.02701600f, 
    0.02426493f, -0.03207672f, -0.00974620f, -0.00785781f, 0.01873186f, 0.01161121f, 0.01012110f, -0.02011950f, 
    0.01740533f, 0.02085280f, -0.03634538f, -0.03863297f, 0.01633850f, -0.01975491f, -0.00802172f, 0.00033285f, 
    0.00217676f, 0.01310793f, -0.00675982f, 0.02469837f, 0.01455967f, -0.01400610f, -0.00617412f, 0.01021838f, 
    -0.00355571f, 0.02125026f, 0.00067883f, -0.00885460f, -0.01535099f, -0.02666403f, 0.01141763f, 0.02204942f, 
    0.02826290f, 0.02001113f, -0.02249423f, 0.02513812f, -0.00122446f, 0.00007849f, -0.02211332f, -0.01555425f, 
    0.02531309f, -0.01676284f, -0.03812845f, -0.02514496f, -0.01675955f, -0.00580467f, 0.00027834f, -0.03637333f, 
    -0.01884650f, -0.02293967f, -0.03881150f, -0.00415578f, -0.01031585f, -0.03972844f, 0.00385647f, -0.01991003f, 
    0.02951907f, 0.01238138f, 0.01476076f, -0.02870041f, 0.01051147f, 0.00774499f, -0.00350280f, 0.02053241f, 
    -0.01696707f, -0.00982961f, -0.00091205f, -0.02155026f, -0.02826712f, 0.02267259f, 0.00716011f, -0.00609145f, 
    0.01421025f, 0.02922013f, -0.01934906f, -0.00007672f, 0.02008454f, 0.01134506f, 0.02383202f, -0.04039392f, 
    0.01277019f, -0.02120525f, -0.03612711f, -0.01445357f, -0.02011390f, -0.00801878f, -0.01240937f, -0.00960216f, 
    -0.02619752f, 0.00648217f, -0.03234885f, -0.00288021f, -0.02895433f, 0.00060070f, 0.00457841f, -0.03739244f, 
    -0.02974958f, 0.03223269f, 0.03030480f, 0.00876850f, 0.02858941f, 0.02548737f, 0.01039426f, -0.00995193f, 
    -0.02911376f, -0.00927338f, 0.01275546f, 0.02400005f, 0.02243571f, 0.02306510f, 0.01107915f, -0.01062415f, 
    0.00127152f, -0.03330818f, -0.03782305f, -0.01758007f, -0.02334550f, 0.01964103f, -0.03967551f, 0.01862877f, 
    0.02199757f, -0.02926103f, -0.01734978f, -0.03121956f, -0.01317102f, -0.02115919f, 0.00503569f, -0.01250489f, 
    -0.02637101f, 0.02804684f, -0.00303917f, -0.01086206f, -0.01582912f, -0.02322800f, 0.00088032f, 0.01979406f, 
    0.02038783f, -0.02513658f, -0.03491036f, -0.03001649f, 0.01765699f, -0.03158382f, -0.02519338f, 0.01030730f, 
    -0.03688423f, 0.00384004f, -0.03194687f, -0.03707198f, -0.03053593f, -0.00928181f, -0.00428540f, -0.00189358f, 
    -0.01952833f, 0.00748932f, -0.01693820f, -0.04008270f, -0.03788113f, 0.02801716f, -0.01760513f, 0.02959107f, 
    0.01539719f, -0.00709257f, -0.01289452f, 0.00715180f, -0.03791769f, -0.03406305f, 0.02805994f, 0.02425322f, 
    -0.03912008f, -0.01470052f, -0.01328832f, -0.03278554f, 0.01660448f, 0.00695975f, -0.04112916f, 0.03287104f, 
    -0.01688028f, -0.01942785f, 0.02141727f, -0.01455963f, 0.01486069f, -0.00569646f, -0.03571258f, -0.03622335f, 
    -0.00284471f, 0.02793088f, -0.00082512f, 0.02500466f, -0.01744242f, 0.02950518f, 0.03040701f, -0.02764812f, 
    -0.02720145f, -0.01133181f, -0.01589181f, -0.01532088f, -0.02685701f, 0.01283899f, -0.03905187f, 0.02179234f, 
    -0.01868017f, 0.03579169f, 0.01485937f, -0.03036550f, -0.04068418f, 0.02891387f, -0.00657895f, -0.00720849f, 
    0.00616554f, -0.01962689f, -0.02155200f, -0.00096048f, 0.01960909f, 0.02922772f, -0.00972902f, 0.02805767f, 
    0.01326285f, -0.04062140f, 0.00286201f, 0.01367319f, 0.02917133f, 0.01336794f, -0.03456429f, -0.00181628f, 
    -0.01010726f, -0.02682339f, 0.02696804f, -0.02350349f, -0.00889407f, -0.02917922f, -0.02597701f, -0.04115435f, 
    -0.02195073f, -0.04018724f, -0.01305036f, -0.01331579f, 0.02039738f, -0.03536671f, 0.02090544f, -0.02521477f, 
    -0.02267157f, -0.02419171f, -0.02436751f, 0.00660905f, 0.00336352f, -0.00925882f, -0.03207137f, 0.00242333f, 
    -0.02925722f, -0.01118566f, 0.00185236f, 0.01139081f, -0.00711884f, -0.02341278f, -0.00673539f, 0.00968709f, 
    0.02758114f, -0.04110638f, -0.03575378f, -0.01251773f, -0.02496955f, -0.01559503f, -0.01194840f, -0.00028335f, 
    -0.03739707f, -0.02495609f, -0.03631128f, -0.01988532f, -0.04096232f, 0.01761833f, -0.01826836f, -0.01684786f, 
    -0.02156909f, 0.00433322f, -0.00077897f, 0.00767517f, -0.01554582f, -0.01181638f, 0.02177960f, -0.03239845f, 
    -0.00811855f, 0.02371446f, -0.03193820f, -0.01738885f, -0.00257049f, 0.00160753f, -0.03231335f, -0.03664901f, 
    0.02504968f, 0.02065966f, -0.02384954f, 0.01132102f, -0.04198691f, -0.03876669f, -0.01514127f, -0.03079530f, 
    -0.01059622f, 0.00082569f, 0.00434607f, -0.01769941f, -0.03852808f, 0.01545093f, 0.00475448f, -0.00521067f, 
    -0.00051326f, -0.02968076f, 0.02084505f, -0.00696704f, -0.03402825f, -0.03459563f, -0.02012413f, -0.00832964f, 
    0.01810362f, 0.00279550f, -0.01440166f, -0.01943748f, -0.01857310f, -0.00046290f, 0.02285611f, 0.02162500f, 
    -0.01853127f, -0.02456127f, 0.01016335f, -0.04118849f, 0.00846184f, 0.00733139f, -0.01061663f, -0.01251197f, 
    -0.03606784f, -0.00141011f, -0.02210849f, -0.01287148f, -0.01929937f, -0.01396324f, 0.02577873f, 0.01709229f, 
    -0.00418163f, 0.01429432f, 0.00684947f, 0.02559187f, -0.00624022f, 0.00417681f, -0.04090376f, -0.00838419f, 
    0.02668215f, -0.00771534f, 0.02224106f, 0.02492480f, 0.00870635f, -0.00644556f, -0.04120272f, 0.01103335f, 
    -0.01092807f, -0.03221158f, 0.01251849f, -0.01515571f, -0.02375810f, 0.01696395f, -0.03539636f, -0.02074728f, 
    0.01274707f, -0.02037771f, 0.01807306f, 0.02993079f, -0.01532086f, -0.02559827f, 0.02466498f, -0.01065783f, 
    0.03023631f, -0.03530417f, 0.02662113f, -0.03111525f, -0.00411099f, -0.00222804f, -0.00428702f, -0.00797236f, 
    -0.03723157f, -0.03774516f, -0.02556160f, 0.02791228f, -0.00224368f, -0.01837783f, 0.01587043f, -0.02150044f, 
    0.03043653f, -0.03627323f, 0.02151020f, -0.03918846f, -0.02779388f, -0.03568303f, 0.02563428f, 0.02217845f, 
    -0.00394308f, 0.02349377f, -0.01801046f, 0.00822431f, -0.03173909f, -0.01576478f, -0.01175254f, -0.00690219f, 
    -0.00931271f, 0.02650099f, 0.00403579f, -0.02707276f, 0.00403809f, -0.02671848f, -0.01931294f, -0.02472529f, 
    -0.02802193f, -0.03597889f, -0.01631927f, 0.01719723f, 0.00238262f, 0.01978920f, -0.03859440f, -0.03328146f, 
    -0.04117601f, -0.03423319f, -0.02438672f, -0.02116496f, -0.00037173f, -0.02327913f, 0.00751471f, -0.01802258f, 
    -0.00063244f, 0.01757253f, -0.03345025f, -0.00570117f, 0.02180120f, 0.00770035f, -0.00020399f, 0.00574564f, 
    -0.02954311f, -0.00304093f, 0.02133609f, 0.01030376f, 0.02301110f, -0.03787697f, -0.03357223f, 0.00525528f, 
    0.00496207f, 0.03059942f, 0.02999428f, -0.00566845f, -0.00030604f, 0.02926283f, 0.02044081f, -0.00770983f, 
    0.02469076f, 0.01609351f, -0.02918940f, -0.03527397f, -0.00149595f, 0.01374469f, -0.02918736f, -0.02418134f, 
    -0.00075861f, -0.00337765f, -0.01101545f, 0.00170266f, -0.01607982f, -0.00282563f, -0.03643371f, -0.01328181f, 
    -0.02970803f, -0.01439239f, 0.00445105f, 0.00555173f, 0.03484383f, -0.02936300f, -0.00621225f, 0.02317189f, 
    0.01321909f, -0.02611907f, -0.00214310f, -0.00112001f, -0.01083539f, -0.00637010f, -0.03042945f, -0.01042234f, 
    0.00721298f, 0.01483081f, 0.00619893f, 0.02330150f, -0.02506327f, -0.01613539f, -0.03435729f, 0.00026560f, 
    0.00166008f, -0.01762390f, 0.02590539f, 0.01143937f, 0.00809526f, 0.00565356f, 0.01753899f, 0.02475055f, 
    0.02214447f, 0.02559991f, -0.03916162f, -0.00559327f, -0.02128134f, -0.01818314f, -0.00489106f, -0.00626273f, 
    -0.03807893f, -0.02897946f, 0.01889487f, -0.03007646f, 0.00230189f, 0.01623942f, 0.02132804f, -0.01187644f, 
    -0.02528226f, -0.01612645f, -0.00566956f, -0.03768545f, 0.01765072f, -0.03361951f, -0.03674484f, -0.00548023f, 
    0.01768428f, -0.01946622f, -0.02880405f, 0.02402176f, 0.01217081f, -0.03198428f, -0.03741392f, -0.03726055f, 
    -0.00528542f, 0.02943592f, 0.01435526f, 0.00463407f, 0.00330358f, 0.02692830f, 0.01449874f, -0.00877308f, 
    0.00063077f, 0.02039049f, -0.01377159f, -0.00748349f, 0.01358985f, -0.01315349f, -0.00905704f, -0.03854980f, 
    0.02951244f, -0.00893402f, -0.01388988f, -0.00952186f, -0.01044946f, 0.02180175f, 0.01328845f, 0.00704466f, 
    0.01359573f, -0.00828924f, -0.00169889f, 0.02511392f, -0.02712921f, -0.02568823f, 0.01996053f, -0.02574681f, 
    -0.02877662f, -0.01130191f, 0.01839066f, 0.01501034f, 0.00298696f, -0.03331549f, -0.01714325f, -0.00104559f, 
    -0.00239985f, -0.02458829f, -0.01886613f, -0.02725608f, -0.00834840f, 0.00483869f, -0.00878554f, 0.01825175f, 
    0.01558040f, -0.00565917f, -0.00205717f, -0.00504255f, 0.00833408f, 0.00060651f, -0.00494202f, -0.00434739f, 
    -0.01649449f, 0.02708342f, -0.01356797f, -0.01843259f, 0.01294976f, 0.01870312f, -0.02681134f, -0.00381129f, 
    0.02939665f, 0.01502210f, 0.00347667f, -0.00330989f, -0.00189391f, -0.03278597f, -0.03959049f, 0.00230138f, 
    -0.04111857f, -0.01157083f, -0.01643083f, -0.04109312f, -0.03810131f, 0.01532979f, -0.00637342f, -0.01633944f, 
    0.02053407f, -0.01522695f, -0.01119657f, -0.01373894f, -0.00614257f, -0.01180807f, 0.00723648f, 0.01273864f, 
    -0.01118307f, -0.00830657f, -0.02389229f, 0.02112749f, 0.01333325f, -0.01555923f, -0.02835323f, -0.02932003f, 
    0.01381393f, 0.02855488f, -0.02927152f, 0.01459458f, -0.01819237f, 0.02346068f, 0.00314576f, -0.00992824f, 
    0.01787492f, 0.09036666f, 0.40926537f, 0.07824475f, 0.14280482f, 0.05432903f, 0.04529137f, -0.00292087f, 
    -0.00055243f, -0.07589566f, 0.06595207f, 0.13642092f, 0.12572746f, -0.07042444f, -0.06470361f, -0.03868528f, 
    0.03987251f, 0.01217572f, 0.16808283f, 0.07020458f, 0.04763130f, 0.11775211f, -0.03170395f, -0.05646353f, 
    -0.06704307f, -0.07225380f, -0.02587033f, -0.05671930f, -0.10883721f, -0.01261356f, -0.03870812f, 0.01979264f, 
    0.01822054f, 0.08882940f, -0.03361548f, 0.03237673f, 0.06253394f, -0.02278377f, -0.07247883f, -0.09122637f, 
    -0.01952747f, -0.05097816f, -0.02941566f, -0.06068626f, -0.03954808f, 0.00202884f, 0.07939388f, 0.03285499f, 
    0.32901594f, -0.04523138f, -0.12179243f, -0.04668282f, -0.05920405f, -0.08032052f, -0.00871719f, -0.06048972f, 
    0.03947045f, 0.19148853f, 0.01190289f, 0.05417436f, -0.07445932f, -0.04912488f, 0.11389604f, 0.32253394f, 
    0.15559076f, -0.08468112f, -0.00088415f, 0.09110127f, -0.01800265f, -0.06138805f, -0.03624373f, 0.01824886f, 
    0.00313920f, -0.12238587f, 0.14416966f, 0.26232269f, -0.03276449f, -0.08302622f, 0.05944792f, 0.06631450f, 
    0.12500034f, 0.02672920f, 0.16511127f, -0.04175868f, -0.05048486f, -0.06817633f, 0.03038320f, -0.16036382f, 
    -0.05821187f, 0.10905438f, 0.07023040f, -0.05317606f, -0.09079685f, -0.02309813f, -0.10079692f, 0.04054752f, 
    0.62434000f, -0.04242673f, 0.01549968f, 0.73058617f, 0.04097847f, -0.00069978f, 0.03228153f, 0.08365255f, 
    0.06997693f, 0.00109856f, 0.11150151f, -0.06583250f, -0.13758299f, 0.06849975f, 0.11520078f, 0.41397354f, 
    -0.05268546f, 0.03480908f, 0.03606467f, 0.04644012f, -0.04408132f, 0.01878902f, -0.01695951f, -0.05331423f, 
    0.44265950f, -0.11352614f, -0.13011515f, -0.14950939f, -0.19402319f, 0.04685994f, 0.04435340f, 0.07909619f, 
    -0.01545028f, 0.06307430f, -0.09193981f, -0.09543432f, 0.12468838f, 0.03869028f, -0.22063534f, 0.19588053f, 
    0.00150567f, -0.12156575f, 0.03484937f, 0.08989353f, 0.09664211f, 0.03995007f, 0.08651368f, 0.11173923f, 
    -0.29545587f, 0.20113592f, -0.00087798f, 0.29176679f, 0.13180342f, 0.07155424f, 0.03870400f, -0.03816575f, 
    -0.09749603f, -0.03922981f, -0.01170307f, 0.08361050f, 0.06800987f, -0.02275202f, -0.22796828f, 0.03347110f, 
    -0.01067253f, -0.01299386f, -0.07707637f, 0.05914029f, 0.29272160f, 0.05668083f, -0.04443463f, 0.11860037f, 
    0.34397304f, -0.07744539f, 0.19147289f, 0.04834106f, 0.12603799f, 0.08181474f, 0.08530023f, 0.00397461f, 
    0.14772512f, 0.01647327f, 0.12845629f, 0.08757500f, -0.28945377f, 0.06622881f, -0.07833655f, 0.03708594f, 
    0.06483022f, -0.07385943f, 0.01599015f, -0.02459755f, 0.07599948f, 0.24040566f, -0.00148616f, 0.04430190f, 
    -0.09009160f, -0.19826744f, 0.02581527f, 0.05893086f, -0.02890490f, -0.16011475f, 0.05947511f, 0.10597854f, 
    0.02534970f, 0.01914606f, 0.11239987f, 0.12257726f, -0.24387817f, 0.07919883f, 0.16060388f, 0.30896679f, 
    0.14185826f, 0.08183201f, 0.06308933f, -0.00951771f, -0.02904860f, 0.00224006f, 0.06315576f, -0.07120392f, 
    -0.19952066f, -0.19903192f, -0.01186757f, 0.07076547f, 0.04439181f, -0.00921473f, 0.17019780f, 0.11936706f, 
    -0.03561668f, 0.00581981f, 0.13837785f, 0.05721657f, -0.50944817f, -0.02744479f, 0.17913665f, 0.20263267f, 
    -0.05925564f, 0.05144965f, 0.12443922f, 0.01703912f, -0.18699400f, 0.01674036f, -0.07814469f, 0.05066838f, 
    0.04364305f, 0.15213671f, -0.19226277f, 0.20277242f, 0.04233531f, 0.01740288f, 0.04793684f, -0.02393396f, 
    0.02191754f, 0.09917644f, 0.15764296f, 0.04246851f, -0.36760798f, 0.10602736f, -0.03018156f, 0.02924521f, 
    0.07294966f, 0.03390553f, -0.06752943f, -0.01325703f, -0.07668348f, 0.00355951f, -0.06272150f, 0.04254894f, 
    -0.20165451f, -0.14488852f, 0.11411131f, 0.09398749f, 0.05427992f, 0.01968976f, 0.01244787f, -0.10850153f, 
    -0.02377303f, -0.00471594f, -0.00136592f, -0.09423531f, 0.17230105f, -0.13406862f, 0.32300112f, 0.17341830f, 
    0.02073546f, -0.03501489f, -0.15931697f, 0.00025419f, -0.00809224f, 0.02723937f, 0.00393573f, 0.08576345f, 
    0.05546476f, -0.00752291f, 0.13592094f, 0.05544300f, 0.19251870f, -0.08726926f, 0.10944410f, -0.04491518f, 
    -0.02089552f, -0.01904308f, 0.02295751f, 0.04828149f, 0.02674596f, -0.06914942f, 0.01038613f, -0.01790863f, 
    0.13468249f, -0.12550209f, -0.01071408f, 0.02023780f, 0.10936382f, 0.10651081f, 0.13173750f, 0.25012246f, 
    -0.08192760f, 0.02074393f, 0.12030605f, -0.04540734f, 0.04954942f, -0.15674606f, 0.19738467f, -0.00956158f, 
    0.07511929f, 0.04201436f, -0.05115777f, 0.14268610f, -0.21889473f, -0.29031456f, 0.01594064f, -0.00303416f, 
    0.13820060f, 0.02710515f, 0.11235530f, 0.15723141f, -0.00439918f, 0.04213719f, 0.06512493f, 0.01504008f, 
    -0.08385645f, 0.02201835f, 0.00523096f, 0.01187158f, 0.10976164f, 0.09232079f, -0.13682345f, -0.03762608f, 
    -0.04480766f, -0.02972446f, 0.02911711f, 0.02029013f, 0.00453999f, -0.29005948f, 0.08788407f, 0.21788639f, 
    -0.09870896f, -0.15233266f, 0.09372142f, 0.01926978f, 0.03425188f, 0.06138043f, -0.01197572f, -0.07024623f, 
    0.20684911f, -0.13880770f, -0.07660437f, -0.00175072f, -0.06909270f, -0.07387964f, 0.07249887f, 0.03186982f, 
    -0.02477586f, 0.06697416f, -0.06396152f, 0.00088733f, -0.20089425f, -0.05191920f, 0.08728050f, 0.05358986f, 
    0.01114723f, -0.04084958f, 0.06853916f, -0.06777402f, 0.10929817f, 0.11881799f, 0.13153712f, 0.05872127f, 
    -0.11695231f, -0.04326928f, 0.37114042f, 0.26314482f, 0.02698550f, -0.01601093f, 0.01187707f, -0.04426043f, 
    0.08353828f, -0.01338693f, -0.05558540f, -0.01748049f, 0.16117921f, -0.24279575f, 0.12637123f, 0.26537916f, 
    0.15238129f, 0.00038461f, 0.06424253f, -0.04622499f, -0.01787512f, -0.02826670f, 0.20324945f, 0.12816910f, 
    0.11676313f, 0.06266081f, -0.00557747f, 0.24506992f, -0.10274266f, 0.04744572f, -0.06527825f, 0.17092773f, 
    0.05476122f, -0.10651852f, -0.06317423f, -0.08657393f, -0.08820803f, 0.09406720f, -0.23087658f, 0.00898550f, 
    0.11211552f, -0.02590952f, -0.13596305f, 0.17377821f, 0.05576058f, 0.10509209f, 0.02334786f, 0.16854726f, 
    -0.10249887f, 0.04371244f, 0.01511303f, -0.15385863f, 0.08859979f, 0.00389105f, -0.04058366f, -0.10160901f, 
    0.12643588f, 0.00275169f, 0.06331913f, 0.04257946f, 0.24071926f, 0.02181444f, 0.24146113f, 0.13628449f, 
    0.19045714f, -0.19026642f, 0.05906714f, -0.21104150f, 0.18445668f, 0.17606619f, 0.11798319f, -0.01024582f, 
    -0.05873990f, 0.08261695f, 0.05897958f, -0.02761518f, -0.04866010f, -0.04555108f, 0.09612807f, 0.06518329f, 
    0.04168111f, -0.09250365f, -0.06995471f, -0.00950242f, -0.04547872f, -0.01487110f, 0.13306211f, 0.18656170f, 
    0.06228108f, 0.09563421f, 0.09615615f, -0.03298101f, 0.07289516f, 0.10207003f, -0.04972665f, -0.02644620f, 
    0.31015947f, 0.04514056f, 0.11088375f, -0.04213648f, -0.09462447f, 0.01953422f, -0.05815783f, 0.05988590f, 
    0.18024814f, 0.10285150f, 0.08147452f, 0.11484399f, 0.01229700f, -0.00840998f, -0.03631381f, -0.18943650f, 
    -0.01658550f, -0.05197014f, -0.01370533f, -0.05960903f, 0.04049684f, 0.08811253f, 0.21578269f, -0.06700876f, 
    -0.03715682f, -0.03948931f, -0.20391917f, 0.18826248f, 0.07525603f, -0.00278431f, -0.13007784f, 0.04699972f, 
    -0.01437904f, 0.19389670f, 0.21170075f, 0.02261113f, -0.27010763f, 0.11460849f, 0.42681870f, -0.04090104f, 
    0.01689098f, 0.05808232f, -0.07825579f, 0.05309016f, 0.07262936f, -0.00951555f, 0.06186400f, 0.19398212f, 
    -0.12283827f, -0.03790931f, -0.11570261f, -0.08347446f, 0.05523041f, 0.09352564f, -0.03080329f, 0.12472177f, 
    0.12191144f, 0.07789020f, -0.02672444f, -0.03343927f, 0.04045280f, -0.18902718f, 0.04382864f, 0.19855897f, 
    -0.00587883f, -0.08081217f, 0.10731521f, 0.11495536f, 0.10068221f, -0.02095276f, -0.00005487f, 0.10424083f, 
    -0.46929607f, -0.08183036f, -0.01404914f, 0.10842966f, 0.11532722f, 0.01474950f, 0.00770347f, 0.15771727f, 
    -0.00353133f, 0.07335139f, 0.00155204f, 0.05149837f, 0.21411440f, -0.04121960f, -0.05953429f, 0.03210662f, 
    0.01058903f, -0.00854660f, 0.14354634f, 0.03506185f, -0.07764661f, 0.12352894f, -0.06410576f, 0.05271937f, 
    0.03882614f, -0.27472681f, -0.08846714f, 0.07464550f, 0.00690945f, 0.12373583f, -0.15782778f, -0.00021215f, 
    0.06212196f, -0.03397877f, 0.09434855f, 0.18711105f, 0.09803839f, 0.17471622f, -0.10283697f, 0.02978704f, 
    -0.08585236f, -0.08725093f, -0.06058614f, -0.01413114f, 0.01817041f, 0.02277592f, 0.11076886f, 0.10868181f, 
    0.51304281f, -0.10049007f, -0.11210838f, -0.16405016f, -0.10260648f, -0.05969744f, 0.09793413f, 0.01012405f, 
    0.14283934f, 0.09280626f, 0.17029484f, -0.13465600f, 0.08261362f, -0.10312329f, -0.04242551f, -0.06883411f, 
    0.06837434f, 0.01116363f, 0.04351089f, -0.02271188f, 0.00761318f, 0.01500977f, -0.07093575f, -0.05379373f, 
    -0.19121578f, 0.17121324f, -0.06502089f, 0.07319039f, 0.00967820f, -0.04220694f, 0.07795548f, -0.12352353f, 
    0.07775394f, 0.16013484f, -0.21364009f, 0.25866362f, 0.44440734f, -0.24041194f, -0.06088784f, -0.09389253f, 
    0.17443062f, 0.04688809f, -0.02138527f, 0.02042983f, 0.08306042f, 0.20630248f, 0.14649506f, -0.01129007f, 
    0.48298451f, -0.26343331f, 0.17714171f, 0.12349511f, 0.16601200f, 0.02596926f, -0.06411037f, 0.07218724f, 
    -0.06699414f, -0.05032453f, 0.06966826f, -0.03911625f, -0.19563496f, -0.00815127f, -0.07357455f, -0.06123655f, 
    0.10443661f, 0.08065090f, 0.01415169f, 0.04461695f, 0.21431127f, 0.04635369f, -0.05697542f, -0.00454621f, 
    -0.09039336f, -0.02158045f, -0.02135333f, -0.09104735f, 0.06818090f, -0.00705660f, 0.10301267f, 0.12847462f, 
    -0.15279649f, 0.12883921f, 0.09467558f, 0.04428553f, 0.07309329f, -0.09065700f, -0.13205440f, -0.24200319f, 
    -0.02962611f, -0.03748506f, -0.08265641f, 0.03404337f, -0.01657453f, -0.01037877f, 0.00402974f, -0.07141806f, 
    0.10731617f, -0.15014540f, 0.33576107f, 0.47308019f, -0.09942798f, 0.05051442f, 0.13434999f, 0.00873609f, 
    0.07914044f, -0.04455254f, 0.03041446f, -0.14703329f, -0.19741166f, 0.11360616f, 0.40038499f, 0.16754392f, 
    -0.07393422f, 0.18750896f, 0.21187390f, -0.02613528f, 0.19811037f, 0.05894979f, 0.24097109f, 0.00218764f, 
    0.05614811f, 0.03140987f, 0.02110638f, -0.14375523f, -0.01711222f, 0.01174667f, -0.05412843f, 0.00151900f, 
    -0.05239436f, -0.00244451f, 0.09644859f, -0.06034692f, -0.27143654f, 0.18756184f, -0.02418347f, -0.02801453f, 
    0.20648454f, 0.22334433f, 0.03922424f, -0.08818810f, -0.05767477f, 0.26497149f, -0.00877031f, -0.03929865f, 
    0.20552342f, 0.17306979f, 0.21735340f, -0.04744955f, -0.11463667f, 0.11980851f, -0.04967114f, -0.13613835f, 
    0.00277267f, 0.19519275f, 0.12165239f, -0.22038738f, -0.17088172f, 0.17874441f, 0.05581261f, 0.05226270f, 
    -0.05362914f, 0.12570974f, 0.10416857f, -0.02779870f, -0.07016716f, 0.07947357f, 0.01502162f, -0.02732478f, 
    -0.18387046f, -0.12344612f, -0.11900598f, 0.08419894f, 0.06782153f, 0.01375829f, 0.05732002f, -0.10203442f, 
    0.10276304f, 0.03291400f, 0.04993548f, -0.13178244f, -0.14610685f, 0.09189671f, 0.36359382f, -0.35770959f, 
    -0.10555998f, -0.14896172f, 0.11606590f, 0.15332353f, -0.06130304f, -0.05561284f, 0.02997481f, 0.04228213f, 
    0.05570935f, 0.04354572f, -0.00691159f, -0.11635375f, 0.04900253f, 0.04551218f, 0.10104281f, -0.05927002f, 
    0.15675768f, 0.12423309f, -0.00155325f, 0.11727798f, -0.04915503f, 0.14812456f, -0.07627247f, -0.08979174f, 
    0.05972089f, -0.02441251f, 0.02752496f, -0.00310684f, -0.02406088f, 0.01251829f, 0.20619817f, 0.17892714f, 
    -0.08057833f, 0.23224349f, -0.22133991f, 0.02990266f, -0.08188289f, -0.00212119f, -0.07581133f, -0.04532474f, 
    -0.04961504f, -0.26108685f, -0.14618470f, 0.01610258f, -0.03568175f, 0.46098697f, -0.44634131f, 0.21486129f, 
    0.05221878f, -0.14434893f, 0.06770847f, 0.30693597f, 0.06084170f, -0.00822367f, -0.04164556f, 0.03167808f, 
    0.36986214f, 0.04435837f, 0.25944602f, 0.08219970f, -0.01386193f, -0.11574820f, 0.04247440f, -0.08721436f, 
    -0.07923286f, -0.17070577f, 0.13602281f, 0.21106416f, -0.00432559f, -0.12296151f, 0.06866170f, -0.02515441f, 
    0.13692535f, 0.20121479f, 0.08544236f, -0.00342250f, 0.11420972f, -0.02476717f, -0.01062316f, 0.06056087f, 
    0.53830659f, -0.29338008f, -0.08508369f, -0.24616526f, 0.18785860f, 0.10420960f, 0.10001165f, 0.13539192f, 
    -0.07791518f, -0.07435911f, 0.07649596f, 0.08996253f, 0.37832418f, 0.04725708f, 0.17643639f, -0.14752281f, 
    -0.00842521f, -0.04924600f, -0.04457469f, 0.11515103f, 0.00456766f, -0.08700874f, -0.02054390f, 0.03609676f, 
    -0.00094304f, 0.15221716f, -0.53394514f, -0.02057954f, 0.13348733f, -0.01863245f, 0.09804983f, -0.08747810f, 
    0.01507885f, -0.02281874f, -0.05076155f, -0.02034511f, 0.18190479f, -0.07854930f, 0.10689917f, -0.23158327f, 
    0.08588094f, 0.04012588f, 0.01946285f, -0.02984501f, 0.08142807f, -0.17301194f, 0.19666976f, -0.03773918f, 
    0.13314959f, -0.06514187f, 0.17159849f, -0.03304888f, 0.09857975f, 0.13692136f, -0.10828091f, 0.03216164f, 
    -0.06138035f, -0.08174487f, 0.20358570f, 0.03964886f, 0.11316795f, -0.06908077f, 0.23748490f, -0.13244405f, 
    -0.00240643f, -0.04372239f, -0.04198585f, -0.03339514f, 0.03588158f, 0.10904118f, 0.02190541f, 0.00733109f, 
    -0.24083842f, -0.02318720f, -0.09299469f, 0.03042883f, -0.02284538f, 0.02109257f, 0.06544825f, -0.04899797f, 
    0.04022936f, -0.02302912f, 0.07575740f, 0.25592297f, 0.34991425f, 0.00385821f, -0.13490729f, -0.26698056f, 
    -0.26613122f, 0.01809599f, -0.10391026f, -0.10749130f, -0.11043032f, 0.23954858f, -0.03561024f, 0.07803049f, 
    -0.01339468f, 0.01460328f, -0.09924840f, -0.08250730f, 0.00406014f, 0.09117585f, -0.00914662f, 0.10417788f, 
    0.05106969f, -0.02953969f, -0.05084312f, -0.04268886f, 0.01976453f, 0.11017243f, 0.37236744f, 0.05036097f, 
    -0.05019534f, -0.08898973f, -0.02561023f, 0.07405719f, -0.10720691f, -0.01873375f, 0.12379407f, 0.01002911f, 
    0.16966993f, -0.07592762f, 0.00276074f, -0.00166015f, 0.06629389f, 0.03015720f, 0.17010574f, 0.15221095f, 
    0.03311616f, 0.07724430f, -0.08533118f, -0.19532610f, -0.31785911f, 0.00413767f, 0.23357528f, -0.29939950f, 
    0.08006272f, 0.09901655f, -0.01210223f, 0.08676071f, -0.01299709f, 0.10552044f, 0.17762887f, 0.08111575f, 
    0.10260585f, 0.08614947f, -0.07960807f, -0.02533991f, 0.01623466f, -0.02691517f, 0.07966463f, 0.09243137f, 
    -0.04441699f, -0.04309918f, 0.20869149f, -0.05415777f, 0.24159424f, -0.02049931f, 0.09643079f, 0.10448207f, 
    -0.05496695f, -0.00930757f, -0.19160929f, 0.00034847f, 0.19006255f, -0.03162943f, -0.01568075f, -0.16756830f, 
    0.13726479f, -0.09772512f, -0.24913490f, -0.12770596f, -0.18099476f, 0.05524230f, -0.17727074f, 0.05460778f, 
    0.06883959f, -0.05321804f, -0.03285415f, -0.07426519f, -0.22490446f, 0.18402001f, -0.19128162f, 0.12310541f, 
    -0.08879278f, 0.00170106f, 0.16018830f, 0.08546986f, 0.00972065f, -0.06586634f, -0.08486950f, 0.07448860f, 
    -0.24148273f, -0.18947895f, -0.20093822f, -0.11482351f, -0.24794169f, 0.09040181f, -0.01652785f, -0.00589374f, 
    0.05520897f, 0.01443283f, -0.08669611f, 0.01709894f, 0.40345925f, 0.01603843f, 0.23520787f, 0.01950019f, 
    -0.01805427f, -0.07347157f, -0.00024484f, -0.06016526f, 0.00993318f, 0.08758828f, -0.03878967f, 0.04787291f, 
    0.02991668f, 0.21586308f, 0.11445791f, -0.30762714f, -0.10521120f, 0.00145857f, 0.04570002f, 0.05526133f, 
    0.04984633f, -0.06286699f, 0.04549845f, 0.04792857f, 0.22915255f, -0.02571963f, 0.10842667f, 0.05089781f, 
    0.07079212f, -0.00754398f, -0.15540308f, -0.00609979f, 0.15938911f, 0.04935612f, 0.20576027f, -0.25395390f, 
    0.33446008f, -0.32235476f, 0.13749239f, -0.03718606f, 0.06720140f, 0.05987840f, -0.02436702f, 0.05564474f, 
    -0.00879064f, -0.09207863f, -0.03856715f, -0.01153634f, 0.08369830f, 0.23485900f, 0.02205851f, -0.07529414f, 
    -0.00932592f, 0.00822236f, 0.12158079f, 0.03558717f, 0.00138754f, -0.00679320f, 0.00543810f, 0.14405012f, 
    0.33421728f, -0.03064860f, 0.00223895f, -0.10685659f, 0.00056574f, 0.02328873f, 0.03599019f, -0.16616648f, 
    -0.12474382f, 0.06229674f, 0.03271250f, -0.03977004f, 0.16762146f, -0.00775986f, -0.07754982f, -0.17744461f, 
    0.02631207f, -0.00832755f, -0.02131527f, 0.14644779f, -0.01510971f, 0.07023133f, 0.15521269f, 0.12009572f, 
    0.29135776f, -0.19832741f, 0.14535655f, -0.11000089f, -0.03349480f, 0.17612492f, 0.09944894f, -0.02317525f, 
    0.05262477f, -0.02320908f, -0.00405989f, -0.10015221f, -0.48814049f, -0.19779591f, -0.12774082f, -0.20678145f, 
    -0.10910551f, 0.07243013f, 0.06607512f, 0.06958126f, 0.04100174f, 0.00970685f, -0.02042956f, 0.05423285f, 
    -0.08851890f, -0.16923347f, -0.08148552f, 0.05352644f, -0.00237689f, -0.24593075f, 0.11678454f, 0.25825775f, 
    -0.05099729f, -0.03324177f, -0.08868635f, 0.12553565f, 0.06972187f, 0.13537650f, -0.33461958f, 0.10964110f, 
    0.14038853f, 0.23816672f, -0.04576419f, 0.09689386f, -0.05895128f, 0.22075062f, -0.11508542f, -0.08783935f, 
    0.07818896f, 0.26705146f, 0.19962178f, -0.04920191f, -0.08424526f, 0.01841811f, -0.06461118f, -0.09220409f, 
    0.10132886f, 0.08959326f, -0.02306367f, 0.01149547f, -0.41746825f, 0.30409732f, -0.19651787f, 0.28905585f, 
    -0.06919402f, 0.01114287f, 0.08779018f, 0.12285013f, 0.00698299f, -0.01009702f, -0.15494679f, 0.07396042f, 
    0.06029797f, 0.48824313f, 0.09605472f, -0.12833692f, -0.09860662f, -0.17201592f, -0.06967945f, 0.05136207f, 
    -0.06281045f, 0.00973673f, 0.06762902f, -0.08664896f, 0.35523584f, -0.48641530f, -0.00081500f, -0.21928355f, 
    -0.05060576f, 0.01479712f, 0.25999948f, 0.04303420f, -0.04471434f, -0.01049120f, 0.07983497f, 0.01593728f, 
    -0.18159975f, 0.25818679f, -0.27164450f, 0.10092836f, -0.02359781f, -0.07040808f, 0.30441481f, -0.01825588f, 
    -0.11022188f, -0.24340641f, -0.00712490f, 0.23706524f, 0.09165176f, 0.10975925f, -0.00937255f, 0.03883085f, 
    -0.03253943f, 0.04547872f, 0.07070227f, -0.07473624f, -0.13686040f, -0.06282142f, 0.07461630f, 0.01505568f, 
    -0.21665998f, 0.00604743f, -0.00019059f, -0.05172878f, 0.08120926f, 0.00089446f, 0.09322491f, 0.08524351f, 
    0.03497962f, -0.04026639f, 0.22293957f, -0.15704712f, 0.27617073f, -0.03050027f, -0.02254467f, -0.07879430f, 
    0.14225495f, -0.14060305f, 0.08813315f, 0.21785487f, -0.12404679f, 0.00152960f, -0.03696978f, 0.16777699f, 
    0.04190806f, 0.04120084f, 0.01614423f, -0.04320220f, 0.06353095f, 0.06657595f, -0.10076478f, -0.07642920f, 
    0.18138206f, 0.00323199f, 0.07332293f, 0.04055983f, 0.33221632f, 0.00325929f, -0.15743908f, -0.25914299f, 
    0.07841989f, -0.22931448f, -0.00478512f, 0.18437594f, 0.08239357f, 0.14383565f, 0.00223807f, 0.05791632f, 
    0.46507508f, 0.19259714f, -0.22106257f, 0.04032882f, -0.11767250f, -0.03318680f, -0.15130426f, 0.00754040f, 
    -0.06284849f, 0.09033675f, 0.03862351f, 0.28138182f, -0.24806935f, 0.02169786f, -0.03961952f, -0.03512780f, 
    -0.01480133f, 0.08260836f, 0.24205858f, 0.10574755f, 0.12453891f, -0.03047493f, -0.08262424f, 0.02638074f, 
    0.34808597f, -0.05089173f, 0.16943465f, 0.10410253f, 0.22860007f, -0.02784372f, -0.04145849f, -0.06729248f, 
    0.07725482f, 0.07642595f, -0.16414548f, 0.08053230f, -0.06227997f, 0.08427420f, 0.32857731f, -0.21697623f, 
    0.01797857f, 0.06519101f, 0.00048372f, -0.11099058f, -0.02721510f, -0.05162519f, 0.11898483f, -0.11574195f, 
    0.10356063f, -0.01841427f, -0.00594000f, -0.03333235f, -0.09883790f, 0.28667852f, -0.09471340f, -0.04571436f, 
    -0.01973606f, 0.01535283f, 0.12404678f, -0.00753837f, 0.09497780f, -0.17104314f, 0.04290257f, -0.07810909f, 
    0.23016249f, 0.07720755f, 0.02254352f, -0.04161000f, 0.08746503f, 0.05717211f, 0.03239353f, -0.05546282f, 
    -0.00137190f, 0.18112615f, -0.06539193f, 0.04235413f, -0.20394014f, 0.11737977f, 0.13306946f, -0.07241345f, 
    0.03531843f, 0.15039238f, -0.08229414f, -0.12751323f, 0.47703537f, 0.27247223f, 0.06281701f, -0.07680097f, 
    0.04944739f, -0.04322679f, 0.02663960f, -0.13021378f, -0.01701699f, 0.12473387f, -0.05639131f, 0.00670646f, 
    0.05701028f, 0.41700986f, -0.21616544f, 0.00632745f, 0.01601722f, -0.06157269f, -0.01452367f, 0.10159112f, 
    0.11268573f, -0.03660996f, 0.12878214f, -0.17001994f, 0.08936673f, 0.17243160f, -0.02468033f, -0.15230288f, 
    0.00114173f, 0.09155262f, -0.00451452f, -0.05712669f, 0.09360648f, 0.11083381f, -0.14974201f, 0.01652485f, 
    0.20443881f, -0.17574404f, 0.13596612f, -0.18536960f, 0.09365609f, 0.03069978f, -0.09674592f, -0.05957938f, 
    -0.04637406f, -0.07154286f, -0.06674944f, 0.08141577f, 0.07684045f, 0.10261656f, -0.17068276f, -0.16630027f, 
    0.11149646f, 0.06541824f, 0.02537679f, -0.00469766f, 0.01082019f, -0.07184442f, -0.01130523f, 0.01078369f, 
    0.41786358f, -0.17554970f, -0.19315058f, -0.06804167f, 0.02348766f, 0.21970701f, -0.03772703f, 0.20685928f, 
    0.02626228f, -0.01208196f, -0.10872173f, -0.05137818f, 0.27482376f, 0.01289407f, 0.05327575f, -0.03620388f, 
    0.14406466f, 0.07225217f, -0.00798708f, 0.28123280f, 0.02084270f, 0.06658804f, 0.09229570f, -0.03997025f, 
    -0.07612403f, 0.09469609f, -0.04344838f, -0.08173767f, 0.09476521f, 0.10912917f, 0.08020183f, -0.04636059f, 
    0.15288824f, -0.01231683f, -0.03200469f, -0.01941591f, 0.28048733f, -0.22828445f, 0.05418608f, 0.11373325f, 
    -0.11874317f, 0.15758546f, -0.10310681f, -0.13047262f, -0.15932293f, 0.06613148f, 0.01428369f, 0.09426776f, 
    -0.24343222f, 0.41706008f, -0.27107790f, 0.02379453f, 0.07070453f, -0.05636955f, 0.29789308f, 0.05320621f, 
    0.12837245f, 0.18723351f, -0.11850192f, 0.13151266f, -0.08824584f, -0.11633964f, 0.27437285f, -0.03944984f, 
    0.03430693f, 0.05210656f, 0.05023553f, -0.04940053f, 0.05068779f, -0.09571180f, 0.04277208f, 0.04751736f, 
    0.00117199f, 0.00920144f, 0.01313227f, -0.01930901f, -0.00074279f, 0.01139808f, -0.03393590f, -0.00733506f, 
    0.00345333f, 0.01867213f, -0.02700773f, -0.03373718f, 0.02158775f, -0.04005286f, -0.02343040f, -0.01303015f, 
    0.01978478f, 0.00044707f, -0.01474967f, -0.00410707f, 0.00411834f, 0.00005142f, -0.01748803f, 0.01845362f, 
    0.02275431f, -0.02124160f, -0.01412071f, -0.04029936f, -0.04363493f, -0.02580392f, -0.01763474f, -0.04312588f, 
    0.01754867f, -0.01529037f, -0.02631995f, -0.02262994f, 0.01307048f, 0.00614961f, 0.00592831f, -0.03665427f, 
    0.00551313f, -0.04264052f, -0.00737571f, -0.01833989f, 0.01408445f, 0.02442927f, 0.00761590f, 0.01798010f, 
    0.00986188f, -0.01322605f, -0.02230622f, 0.02412864f, 0.00224234f, 0.03135119f, 0.02187999f, -0.03469374f, 
    -0.00407319f, -0.02780718f, -0.03200257f, -0.00200863f, 0.01399865f, -0.02067965f, -0.02318708f, 0.02969685f, 
    0.00533243f, -0.00634744f, -0.00257267f, -0.00590095f, -0.01097397f, -0.01508195f, 0.01471943f, -0.02231977f, 
    -0.01652830f, 0.01638811f, -0.01117083f, -0.03922604f, 0.02159538f, -0.02958620f, 0.00213400f, -0.02979907f, 
    -0.01239828f, 0.01656562f, 0.02222936f, 0.00978866f, 0.02779458f, -0.00097804f, -0.02597912f, -0.02796018f, 
    0.02530300f, -0.03042890f, -0.02059621f, 0.00091837f, 0.00725618f, -0.02383124f, -0.00813706f, -0.00557715f, 
    -0.00467935f, 0.00653836f, 0.01249155f, 0.00875846f, -0.01688635f, 0.01095095f, -0.03830567f, 0.03171130f, 
    0.01903345f, 0.03131241f, -0.00840688f, 0.03008649f, -0.03689750f, -0.02022298f, 0.00225060f, 0.02089782f, 
    -0.02385193f, 0.01077853f, 0.01197153f, 0.02725059f, 0.01836927f, 0.00730726f, 0.00397793f, 0.01745700f, 
    -0.00095086f, -0.03894192f, -0.00471157f, 0.01266951f, 0.02225609f, -0.01838796f, -0.01873477f, -0.02300273f, 
    -0.01060311f, 0.03022415f, -0.02303982f, 0.01063766f, -0.01260468f, 0.01933760f, -0.01572417f, -0.00131896f, 
    -0.03224824f, -0.02710908f, -0.01996357f, -0.02543222f, -0.01797186f, 0.03484924f, 0.00760580f, -0.00538251f, 
    0.04241706f, -0.00618947f, -0.01392971f, 0.02051624f, -0.02410674f, 0.01216247f, -0.01604707f, 0.02171875f, 
    0.00089588f, -0.02274198f, -0.01994887f, -0.00840531f, 0.01472688f, -0.01296623f, 0.02933090f, -0.00134712f, 
    -0.00858211f, -0.03611100f, -0.00445409f, 0.00904765f, -0.01356683f, 0.01403362f, -0.02049249f, 0.00275465f, 
    0.01085309f, 0.01286224f, -0.00139788f, 0.00977709f, -0.04518478f, -0.00208705f, -0.02807625f, 0.00401305f, 
    -0.04121339f, 0.02550865f, 0.00229764f, -0.04469560f, -0.01821488f, -0.02154860f, 0.00073892f, -0.03743027f, 
    -0.02802898f, -0.03109317f, -0.03117990f, -0.00727043f, 0.01418295f, -0.03514341f, -0.02434321f, -0.00406272f, 
    -0.00007338f, 0.00800954f, 0.01215046f, -0.02992999f, -0.02706610f, 0.03482103f, -0.02475938f, -0.01783841f, 
    -0.03203793f, 0.00308307f, -0.01873243f, 0.02444907f, 0.01869405f, 0.00587251f, -0.03233126f, -0.03141771f, 
    -0.03822647f, 0.02147448f, 0.00341846f, 0.01492246f, -0.00079693f, -0.01191600f, 0.03075369f, 0.01466395f, 
    -0.00871411f, -0.00656269f, -0.02912729f, 0.03107871f, -0.02613357f, -0.03304711f, -0.01942282f, -0.04205901f, 
    -0.01308399f, -0.02511805f, 0.01446151f, -0.02237688f, 0.01287511f, -0.02292155f, -0.00723949f, 0.03769516f, 
    -0.03386944f, -0.01248022f, -0.04330976f, 0.03322952f, 0.01505524f, -0.01656192f, -0.02528149f, -0.00520458f, 
    -0.03925975f, -0.03815459f, -0.03833105f, -0.02053577f, 0.02005605f, -0.03479454f, -0.02143660f, 0.01795750f, 
    -0.01615688f, 0.03265158f, -0.00217376f, 0.01330784f, -0.01598591f, 0.00756460f, -0.00863014f, -0.01713543f, 
    -0.04144901f, -0.02267131f, 0.02010104f, -0.02288566f, 0.03483748f, -0.01419906f, 0.01912247f, 0.00756330f, 
    0.01358102f, 0.00481767f, -0.01060815f, -0.00203474f, 0.00012382f, 0.02567351f, -0.01965182f, -0.01020657f, 
    -0.04388340f, 0.02300548f, -0.01679895f, 0.03307206f, 0.01564594f, 0.02123456f, 0.01376834f, 0.01441678f, 
    -0.00917608f, -0.03088677f, -0.03718008f, 0.00851508f, 0.01921584f, -0.03529995f, -0.00564629f, -0.02471298f, 
    0.00509237f, 0.01331430f, 0.00554377f, 0.01916271f, 0.01582326f, 0.02107909f, 0.03287385f, -0.02862875f, 
    0.03287114f, 0.01047026f, -0.01525520f, 0.01485506f, -0.01930279f, -0.02808288f, -0.03133648f, -0.00301508f, 
    -0.03103183f, -0.01593690f, -0.02817104f, -0.03275003f, -0.02527868f, 0.03618671f, 0.01345353f, 0.01317450f, 
    -0.01216851f, 0.02001943f, -0.00191729f, 0.01698466f, 0.01069734f, 0.02783465f, -0.02488731f, -0.00299161f, 
    -0.00466936f, -0.00842354f, -0.01549677f, -0.02911066f, 0.03390274f, 0.00525278f, 0.00833887f, 0.00385419f, 
    -0.00431837f, 0.02860405f, -0.03434194f, -0.01479541f, 0.01477063f, -0.03099349f, 0.02826914f, 0.00500500f, 
    0.00171137f, 0.02823882f, -0.03027461f, 0.00911146f, 0.00022017f, 0.02037793f, 0.00959774f, -0.02753385f, 
    -0.02390189f, 0.00434820f, 0.02333526f, -0.01480346f, 0.02005855f, 0.01790117f, -0.00930658f, -0.01303967f, 
    -0.01092060f, 0.03365730f, -0.01179011f, 0.01532330f, -0.01210637f, -0.02184792f, -0.00167719f, 0.01942869f, 
    -0.01804671f, 0.02651594f, -0.01511054f, -0.03351608f, 0.00339992f, 0.02668023f, -0.03825046f, -0.00042159f, 
    -0.01101805f, -0.00581571f, -0.00687585f, -0.00510640f, 0.03515644f, 0.03170916f, -0.02591647f, 0.01010817f, 
    -0.01125870f, 0.00104272f, -0.00383379f, 0.03002343f, -0.00413638f, 0.02660776f, -0.04290958f, 0.03020856f, 
    0.02416077f, 0.02239549f, 0.00230221f, -0.01786214f, 0.00707726f, -0.03313912f, -0.02911307f, -0.02010028f, 
    -0.02999100f, -0.00451230f, 0.02510720f, -0.02690551f, 0.00619421f, -0.02634753f, -0.00243882f, -0.03180833f, 
    -0.01161139f, 0.02151099f, -0.04047926f, -0.02270325f, 0.02921547f, -0.02228067f, -0.03497439f, -0.03531037f, 
    0.01949952f, -0.02176474f, -0.02795204f, -0.02751031f, 0.00539417f, -0.02133177f, -0.00677417f, -0.02647245f, 
    -0.03969445f, 0.00613801f, -0.01792675f, 0.00259282f, 0.00722100f, -0.01375184f, 0.01211190f, 0.02143466f, 
    -0.01227714f, 0.01814057f, 0.01596932f, -0.00318726f, 0.00822379f, 0.03174452f, -0.02563532f, -0.01363602f, 
    -0.03132696f, 0.01100133f, -0.00413406f, -0.01396995f, -0.03228590f, -0.03500449f, -0.04879544f, 0.02539330f, 
    -0.01676882f, 0.02861910f, -0.02321029f, -0.03555732f, -0.02388092f, -0.00629788f, 0.02051450f, -0.01823385f, 
    -0.00502761f, 0.01430902f, -0.01796203f, -0.01089580f, -0.02443608f, 0.01732033f, 0.00885625f, -0.02003407f, 
    -0.04199700f, 0.01314082f, -0.03510724f, -0.01249630f, -0.03493601f, -0.01858934f, -0.02197880f, -0.02841023f, 
    -0.01504819f, -0.03158153f, 0.00779843f, -0.02202726f, -0.00287369f, -0.03469329f, -0.00056899f, -0.01578442f, 
    -0.01953511f, 0.01645901f, 0.02416424f, 0.00290839f, -0.03209095f, -0.00315677f, -0.01668683f, 0.03086034f, 
    0.00760400f, 0.00902095f, 0.02645364f, 0.01811736f, -0.04229255f, -0.02285823f, -0.03466868f, 0.01210246f, 
    0.01104613f, -0.03209760f, -0.00148649f, 0.00716503f, -0.00769932f, -0.01391507f, -0.00486412f, -0.00840091f, 
    0.01740122f, 0.01689708f, -0.03136872f, -0.00168035f, 0.00252085f, 0.02480340f, -0.04139655f, 0.02515483f, 
    -0.02175639f, 0.01456796f, -0.03167100f, -0.00800555f, 0.02820279f, 0.02064526f, 0.02420327f, -0.03539461f, 
    0.00708169f, -0.00438291f, 0.02025322f, 0.00074000f, 0.01639040f, 0.01834567f, 0.00904736f, 0.02160539f, 
    -0.02866920f, 0.00695875f, -0.00776422f, -0.01193488f, 0.02350715f, 0.02582264f, 0.01712134f, 0.03241762f, 
    -0.01157615f, -0.00424605f, 0.01429648f, -0.00977472f, 0.02887138f, -0.02268585f, 0.00244214f, -0.02751544f, 
    -0.02557791f, 0.00233087f, 0.01884864f, 0.02051726f, 0.03398911f, -0.01541633f, 0.00161439f, -0.01489269f, 
    0.02812036f, 0.01594364f, -0.01569378f, 0.00322648f, 0.00479392f, 0.00762570f, 0.00399802f, 0.03344115f, 
    0.02277975f, 0.01331388f, 0.00944884f, 0.00520564f, -0.02897392f, 0.02120860f, -0.00900241f, 0.00269181f, 
    -0.00321641f, -0.02552292f, -0.02879189f, 0.02635799f, -0.03514766f, -0.00871680f, 0.01457901f, -0.02125196f, 
    -0.02864727f, -0.02485955f, 0.02611560f, -0.01533553f, 0.00397703f, 0.02895460f, -0.01371526f, 0.00537299f, 
    0.00606440f, -0.01177823f, 0.00278893f, -0.04200653f, -0.02377523f, 0.00987960f, -0.03361097f, -0.00484584f, 
    0.01068612f, -0.03529826f, -0.00787737f, -0.01446016f, 0.01730471f, -0.01028410f, 0.02007597f, 0.01520031f, 
    0.02614560f, -0.00327993f, 0.02415067f, 0.00835805f, 0.00910639f, 0.00482506f, -0.01006114f, 0.01877339f, 
    0.00046838f, 0.01031024f, -0.00025997f, -0.04450851f, 0.01096326f, -0.00078998f, -0.01968971f, -0.01995958f, 
    -0.00216608f, 0.00735132f, 0.02217922f, 0.01394329f, -0.00016949f, -0.03006256f, -0.03505153f, -0.01618942f, 
    -0.00344832f, 0.01063146f, 0.01269455f, -0.02253058f, 0.00975411f, -0.02512218f, -0.00218396f, 0.02790521f, 
    -0.02372831f, 0.01093658f, -0.02742007f, -0.01271079f, -0.00919218f, 0.01455407f, -0.03469568f, 0.01468187f, 
    0.02493360f, 0.00389081f, -0.01673196f, 0.03453880f, 0.00435473f, -0.03371673f, -0.00625652f, -0.02794839f, 
    0.02304255f, -0.03121617f, -0.02922744f, 0.01828052f, -0.03702977f, -0.03915041f, -0.02385234f, 0.00256466f, 
    -0.04186689f, 0.02023453f, -0.01632126f, -0.01709300f, -0.02231366f, 0.00311159f, 0.00051599f, 0.02070552f, 
    -0.00728560f, 0.01883441f, -0.01699894f, 0.00176054f, 0.00127978f, 0.00907518f, -0.00499859f, -0.00175551f, 
    0.01711914f, 0.02222804f, -0.00852253f, -0.02473809f, -0.02788811f, -0.00735833f, 0.03495175f, -0.01293867f, 
    0.01407756f, -0.00438004f, 0.00822615f, 0.02632613f, -0.03069220f, -0.02267105f, -0.01941972f, 0.01061802f, 
    -0.02077090f, 0.03153580f, -0.03078838f, -0.00434159f, 0.01253646f, -0.00897110f, -0.03384658f, -0.03571423f, 
    0.00460995f, -0.01076579f, -0.00382666f, -0.04327729f, 0.02551510f, 0.00162627f, -0.00907234f, -0.00576626f, 
    -0.00866613f, -0.01739040f, -0.01344707f, 0.00365215f, -0.02826900f, 0.00901232f, 0.00987945f, -0.03002848f, 
    -0.00626750f, 0.03407923f, 0.00608267f, -0.02511376f, 0.02692408f, -0.00739143f, -0.00427190f, -0.02417145f, 
    0.01781215f, 0.01651742f, -0.02394232f, -0.01897543f, -0.03484382f, -0.01004126f, -0.03489255f, -0.01044644f, 
    -0.01703244f, -0.00308389f, 0.00668107f, 0.02497348f, 0.00157781f, 0.00473127f, -0.00506221f, 0.01754569f, 
    -0.02333020f, 0.02415224f, 0.01325164f, -0.01160490f, -0.04287736f, 0.00420813f, 0.00862380f, -0.01753423f, 
    0.01645959f, -0.01426537f, 0.02375708f, -0.00991420f, 0.01235587f, -0.00739475f, -0.03093545f, -0.00825463f, 
    -0.01902792f, -0.03091778f, -0.02595030f, 0.01774348f, -0.01747815f, -0.04043195f, 0.01493026f, -0.03997293f, 
    -0.02598043f, 0.00352653f, 0.00179819f, 0.03292686f, 0.02844919f, 0.01771339f, -0.03324442f, 0.00432668f, 
    -0.04189318f, -0.03861066f, -0.02025343f, 0.02300213f, -0.02418389f, -0.04230012f, 0.00693448f, -0.01064241f, 
    -0.00292991f, 0.13137093f, -0.02151506f, -0.00280424f, -0.11243949f, 0.11727843f, -0.08755333f, 0.17976396f, 
    0.02695470f, 0.13607642f, -0.09619532f, 0.09821358f, -0.05809613f, -0.21890411f, -0.02102256f, 0.17221487f, 
    -0.01752110f, 0.07676474f, -0.06507446f, -0.12040775f, -0.06393317f, 0.06769821f, 0.06834047f, 0.13075709f, 
    -0.12991630f, 0.10925835f, 0.04109466f, 0.03729795f, -0.02130344f, -0.01560638f, 0.02691023f, -0.01365423f, 
    -0.03968267f, 0.20331289f, 0.11850798f, 0.07136352f, -0.07522117f, -0.10929869f, 0.03116406f, -0.02236049f, 
    -0.03537115f, 0.08811380f, 0.00870070f, -0.03430887f, 0.11436204f, 0.05231917f, 0.06997274f, 0.08750281f, 
    -0.13753350f, 0.06440248f, 0.27158982f, 0.05228609f, 0.03223892f, 0.00545275f, -0.13320357f, 0.05214331f, 
    -0.06988792f, -0.02728414f, 0.19743754f, 0.04018265f, -0.08404881f, -0.44439340f, 0.26246500f, -0.03857495f, 
    0.08718286f, -0.19899902f, 0.02289009f, 0.10287488f, 0.00496039f, -0.02534739f, -0.03434301f, 0.07873643f, 
    -0.03312006f, -0.17176679f, -0.28873226f, -0.01626990f, 0.03406777f, 0.06069245f, 0.12783456f, 0.05604062f, 
    0.03661482f, 0.00168845f, -0.03875314f, -0.14900132f, 0.02939467f, 0.18766630f, 0.01649250f, 0.01766743f, 
    -0.03485463f, 0.03951010f, -0.05129955f, 0.02284790f, 0.03532373f, 0.04444889f, -0.00735139f, -0.05430247f, 
    -0.22018290f, 0.37520996f, 0.31616417f, 0.12872948f, -0.09573769f, -0.16989991f, 0.06127115f, 0.02091612f, 
    0.13089579f, 0.00448357f, -0.03023977f, 0.03231259f, -0.08315310f, 0.00461960f, -0.24595623f, 0.15522645f, 
    -0.09442366f, -0.00688034f, 0.07688685f, 0.02585057f, 0.05308193f, 0.02375651f, 0.04039820f, 0.02715418f, 
    0.24891874f, 0.11813733f, 0.53471541f, -0.00634709f, 0.13842812f, -0.05213213f, -0.05382335f, -0.01604792f, 
    -0.02204785f, -0.02190091f, 0.06885274f, -0.02420326f, -0.10132185f, 0.28174818f, -0.07720765f, 0.16651873f, 
    0.01632061f, 0.05874493f, -0.03224212f, 0.00614067f, -0.16151896f, 0.20513423f, 0.00495361f, 0.12397813f, 
    0.31556565f, 0.15987110f, -0.19821458f, 0.01019259f, 0.01292463f, 0.10197417f, 0.13610139f, 0.18032354f, 
    0.06297513f, 0.01406972f, 0.07766265f, 0.14811078f, -0.15617944f, 0.27869204f, -0.23188442f, 0.09844127f, 
    -0.01150099f, -0.05655859f, -0.02476390f, -0.07024724f, 0.03668865f, 0.09284310f, -0.03248594f, -0.01278513f, 
    0.34702501f, 0.00859256f, 0.11636370f, -0.10658789f, 0.05395936f, -0.01613241f, -0.02899159f, 0.21831582f, 
    -0.08928123f, 0.09896512f, 0.09430409f, -0.05207478f, 0.06476795f, 0.14901781f, -0.28017148f, 0.09736024f, 
    0.07306611f, 0.07797693f, 0.11036453f, 0.05388996f, -0.09325475f, -0.09154367f, -0.11605567f, -0.02308786f, 
    0.25787205f, 0.08964922f, 0.05832068f, -0.04130842f, 0.11113562f, 0.07216008f, -0.04826476f, -0.11941709f, 
    0.07636242f, 0.02699807f, 0.02761358f, 0.07992271f, -0.33824551f, -0.29752880f, -0.14556068f, 0.16649885f, 
    -0.06838414f, 0.04807972f, 0.16588986f, 0.14552806f, 0.01684795f, -0.00476753f, 0.02634457f, 0.06690858f, 
    0.01278789f, 0.10641094f, -0.11452389f, 0.15729353f, 0.15785688f, 0.01512549f, -0.07352819f, -0.10985628f, 
    0.08351877f, 0.07818983f, 0.06596272f, 0.03988502f, -0.00800116f, -0.39402524f, -0.14012437f, 0.20790175f, 
    -0.10774729f, 0.12347402f, 0.23729365f, 0.08268845f, -0.02800240f, 0.09562331f, -0.04863515f, -0.08489515f, 
    -0.15540524f, -0.02248408f, 0.22492872f, -0.02163681f, 0.05891161f, 0.03878516f, 0.05667045f, -0.02220138f, 
    -0.13417123f, 0.07387856f, 0.03277840f, 0.02683779f, -0.14684653f, 0.05811652f, -0.24615631f, 0.21185322f, 
    0.03174664f, 0.00174476f, 0.07756177f, -0.09297018f, -0.18294314f, -0.06396601f, 0.03125869f, 0.03007264f, 
    0.32721254f, 0.35698023f, -0.02591550f, 0.05845149f, 0.13771877f, 0.01745313f, 0.13954410f, -0.00931433f, 
    -0.07249779f, -0.01744168f, -0.10707835f, 0.00435983f, 0.16272701f, -0.13720079f, 0.25684148f, 0.10171831f, 
    0.07253418f, 0.02162649f, 0.00435562f, -0.00589238f, 0.06063292f, 0.13673584f, -0.00884959f, -0.08620004f, 
    0.37576947f, 0.17173754f, -0.07179891f, -0.06656967f, 0.04168348f, 0.04147192f, -0.02603627f, -0.09303920f, 
    -0.08632921f, 0.06125072f, 0.00893445f, -0.03321336f, -0.26467255f, 0.04027488f, -0.29847065f, 0.12086175f, 
    0.03997317f, 0.07597551f, 0.01809358f, -0.12233344f, 0.04678619f, -0.00956833f, 0.03419013f, -0.04532011f, 
    0.05719347f, -0.08553712f, 0.04362485f, 0.00467323f, 0.01898667f, 0.02141997f, 0.09351355f, 0.03477130f, 
    0.00300255f, 0.06177515f, -0.05124088f, -0.00418263f, 0.12917402f, -0.09944303f, -0.07064586f, -0.27021402f, 
    0.09974699f, 0.14717153f, 0.06218307f, -0.18131746f, -0.05746029f, -0.07689587f, 0.08355919f, 0.11041672f, 
    -0.13535793f, 0.27607334f, -0.06487630f, 0.03569220f, 0.04202695f, -0.02123530f, 0.10651989f, -0.04746655f, 
    -0.06230940f, -0.04265358f, -0.05228981f, 0.05822198f, 0.10109220f, -0.02215299f, -0.08008193f, -0.03250142f, 
    -0.07424372f, -0.00591273f, -0.07527014f, -0.01604357f, 0.06038454f, 0.06513811f, -0.00796881f, -0.02353678f, 
    -0.31540900f, 0.18529962f, 0.02516936f, 0.25965527f, -0.08995046f, -0.02102124f, -0.02320901f, -0.06490080f, 
    -0.07741391f, 0.00995412f, 0.03947667f, -0.09836619f, 0.07199119f, -0.10374373f, -0.24139121f, 0.24588823f, 
    -0.10867793f, 0.06360260f, 0.04773614f, 0.17142361f, 0.05872352f, 0.09838954f, -0.04388112f, 0.15684511f, 
    0.08700729f, 0.08418395f, -0.25804406f, 0.03090791f, -0.16852161f, -0.03923250f, -0.00043512f, 0.14014874f, 
    -0.05931323f, 0.08309127f, -0.10107131f, -0.00576901f, 0.38726187f, -0.08858239f, 0.03455647f, -0.11331555f, 
    0.10811418f, 0.07997864f, 0.01234482f, -0.06298072f, -0.00237515f, 0.10423368f, 0.04613752f, -0.07376260f, 
    0.15326229f, 0.02190791f, -0.05409775f, 0.04976189f, -0.01514368f, 0.10211188f, -0.04421372f, 0.04737792f, 
    -0.01889083f, 0.03953945f, 0.03462996f, -0.01835283f, -0.05040039f, -0.04030583f, 0.11442158f, 0.04895288f, 
    0.13671301f, 0.06543784f, 0.08356550f, -0.03603055f, 0.08234261f, -0.20331886f, 0.05440855f, 0.13475788f, 
    -0.17478530f, -0.08634808f, -0.07626110f, -0.11268181f, -0.06925889f, 0.03417528f, -0.02559831f, -0.08286070f, 
    0.03336949f, 0.00354495f, -0.08758945f, 0.14537939f, 0.41154262f, -0.09952128f, 0.29335746f, -0.24821199f, 
    0.02834915f, 0.09234270f, 0.16965251f, 0.15346438f, 0.19675060f, 0.03634319f, 0.05407482f, 0.03381317f, 
    -0.08507746f, -0.15817244f, 0.09206170f, -0.04603082f, 0.01676731f, 0.05043861f, -0.08638271f, 0.09623755f, 
    -0.08562142f, 0.05199244f, -0.09313119f, -0.04715657f, 0.00388160f, 0.46426255f, -0.21357237f, -0.14896417f, 
    0.13604592f, -0.03083530f, -0.15517211f, 0.01616432f, 0.00205166f, 0.06327124f, -0.03027309f, -0.09498090f, 
    -0.12553440f, -0.22014311f, 0.42195085f, -0.12787093f, 0.03307439f, 0.01195858f, -0.21574657f, 0.11306378f, 
    0.00817472f, 0.13372406f, 0.05483274f, 0.01230271f, -0.13539933f, -0.00668001f, -0.08633108f, -0.14600991f, 
    -0.10104876f, -0.02064183f, -0.00075808f, -0.06096523f, -0.02498604f, 0.02498032f, 0.05722404f, 0.03157422f, 
    -0.05677337f, 0.04538146f, 0.15935549f, 0.00403853f, -0.02344172f, 0.08401038f, 0.00764651f, -0.10109557f, 
    0.02366240f, 0.08696839f, 0.11026677f, 0.23718777f, -0.19765329f, -0.18433155f, -0.12097372f, 0.06762996f, 
    -0.08515131f, -0.04685397f, 0.15526608f, 0.05962787f, 0.01820292f, 0.08739647f, -0.04563349f, -0.06497044f, 
    -0.09223796f, 0.03885197f, -0.04976436f, -0.11046721f, -0.01047368f, 0.11744305f, 0.16640246f, 0.07438423f, 
    0.08045656f, 0.07984956f, -0.02243537f, -0.06179354f, 0.10962766f, -0.11510041f, -0.04840198f, 0.12115541f, 
    0.04807828f, 0.02730892f, 0.09876936f, 0.06714000f, -0.18874376f, 0.01749257f, -0.04284053f, 0.02654296f, 
    -0.05138874f, -0.19012921f, -0.18778634f, 0.02542380f, 0.05501821f, 0.06928761f, 0.12062129f, 0.06954092f, 
    0.04669631f, -0.10339513f, 0.02563373f, -0.07910296f, -0.08325788f, -0.06913908f, 0.07514552f, -0.17807272f, 
    -0.11519080f, 0.13931446f, -0.00946720f, 0.02009482f, -0.07505750f, -0.18659461f, 0.02217338f, -0.04361235f, 
    -0.07616509f, 0.17483293f, -0.44522229f, 0.14606316f, -0.05167316f, 0.02231990f, 0.08320619f, 0.04698320f, 
    0.00585457f, 0.18327186f, 0.06917974f, 0.19599111f, -0.05606645f, 0.04825425f, 0.02578128f, 0.18202834f, 
    -0.06552733f, 0.11142926f, -0.06795134f, -0.12452598f, 0.00161567f, 0.13061950f, -0.01196890f, 0.13997616f, 
    0.00112708f, 0.17448643f, 0.01214628f, -0.30647248f, 0.04828079f, 0.03844674f, 0.12740166f, -0.03265103f, 
    0.10309820f, 0.01533161f, -0.04179657f, -0.09602774f, -0.01164740f, 0.22542384f, -0.04738609f, -0.02564738f, 
    -0.02906054f, -0.10832344f, -0.01949506f, 0.01928758f, -0.11555616f, 0.08981270f, 0.08295521f, 0.07768869f, 
    -0.23721582f, -0.11697923f, -0.01116366f, 0.03496161f, 0.14441018f, 0.10967044f, -0.01403769f, 0.04684616f, 
    -0.05864023f, -0.00198030f, 0.03014002f, 0.17140907f, -0.00248447f, -0.10172255f, -0.06560857f, -0.09641329f, 
    0.21627390f, -0.00037126f, 0.02730616f, -0.04271387f, 0.07042956f, -0.03882810f, -0.00779600f, -0.02585873f, 
    0.12434550f, -0.05975465f, 0.23189309f, -0.16495420f, 0.18103370f, -0.00111156f, -0.12918954f, -0.01294406f, 
    0.00092364f, 0.06100704f, -0.09771734f, 0.11090432f, -0.19830751f, 0.07899310f, -0.01254280f, -0.06183502f, 
    -0.03618142f, 0.01689558f, 0.04495890f, -0.03006435f, 0.10631065f, 0.26826742f, 0.18775460f, 0.11024937f, 
    0.18998952f, 0.22367141f, -0.32978532f, 0.04004840f, 0.22502242f, 0.03082969f, 0.14426926f, -0.15312047f, 
    0.10411230f, -0.04986679f, 0.00486183f, -0.03937475f, 0.22011057f, 0.05598029f, 0.07611293f, -0.04245925f, 
    -0.03260864f, -0.06734277f, -0.01799285f, -0.03849054f, 0.02818759f, 0.07286362f, 0.02445434f, -0.02449427f, 
    -0.42906639f, 0.16000721f, 0.30171239f, 0.25695068f, -0.17278910f, -0.27753687f, 0.15889908f, 0.08693562f, 
    -0.06029462f, 0.00428656f, 0.08872668f, 0.01133915f, -0.02131580f, -0.04113514f, -0.07227728f, 0.39062670f, 
    0.02283880f, -0.00970021f, 0.26428592f, 0.16618879f, 0.05110574f, 0.09428550f, -0.00035849f, 0.23617372f, 
    0.07256699f, 0.09993665f, 0.07600997f, -0.08380193f, -0.09977566f, 0.02412183f, 0.02100814f, -0.04424319f, 
    -0.00721277f, 0.08312367f, 0.08413021f, 0.11327492f, 0.02393988f, 0.42362309f, -0.31185830f, -0.16518347f, 
    0.06021336f, 0.03303816f, 0.07498664f, -0.17671122f, 0.14878468f, -0.07662404f, 0.14685489f, -0.10788748f, 
    -0.05972406f, -0.17877406f, 0.31650528f, 0.12307379f, -0.05880695f, 0.12555414f, -0.05298331f, 0.14437847f, 
    -0.18803312f, -0.06476634f, 0.14196934f, 0.24453090f, -0.08540326f, 0.11098221f, -0.06906031f, -0.01297510f, 
    -0.17219988f, 0.04497050f, 0.03274076f, 0.02301235f, -0.17585187f, 0.04716935f, -0.22208805f, -0.03606447f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00015179f, -0.05273229f, 0.02360771f, 0.08216781f, -0.03019141f, -0.04234101f, 0.08757974f, -0.01629511f, 
    -0.03703650f, 0.14768706f, 0.10344432f, -0.03383771f, 0.27383775f, 0.12557301f, 0.02904093f, 0.00010092f, 
    0.00492542f, -0.00417335f, 0.00242501f, 0.01967644f, 0.21708047f, 0.00467653f, 0.02124796f, 0.02009570f, 
    -0.02763241f, 0.02641293f, 0.00768270f, 0.01679876f, 0.03968081f, 0.03403597f, -0.02080381f, -0.00497638f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14033327f, -0.28174552f, -0.04607447f, 0.46772012f, 0.10839789f, -0.03862937f, -0.44546545f, -0.04959077f, 
    -0.07603326f, -0.04588983f, -0.10978848f, 0.13901211f, -0.00278540f, -0.07778201f, 0.19699317f, -0.00995105f, 
    0.01393225f, -0.15943208f, 0.02800993f, 0.14969039f, 0.13899398f, 0.09222934f, -0.05163460f, -0.01159599f, 
    0.12116063f, -0.32865584f, 0.17128646f, 0.03585599f, 0.19949187f, 0.33539692f, -0.14250772f, 0.18562011f, 
    0.05872556f, -0.24482654f, 0.06053679f, -0.15806407f, -0.24231814f, -0.20493394f, -0.23364666f, 0.07275985f, 
    0.12690641f, -0.20510368f, -0.20720559f, -0.25692984f, -0.13808060f, -0.08751038f, -0.11162534f, -0.07549487f, 
    -0.03163540f, 0.10604491f, -0.02084254f, -0.14572623f, -0.09497961f, -0.13653663f, -0.10836440f, 0.08465552f, 
    -0.07505272f, -0.13857840f, -0.13650994f, 0.03004270f, -0.02335824f, -0.05533252f, -0.05468198f, 0.09026600f, 
    0.12188412f, -0.18451898f, -0.08959121f, -0.28959161f, 0.41187033f, 0.19956169f, -0.04115276f, 0.02559502f, 
    0.07221506f, -0.17652373f, 0.13447860f, 0.53016508f, -0.04047208f, 0.01209260f, 0.29578391f, 0.35932478f, 
    0.03248602f, -0.11225735f, -0.15244505f, -0.16315450f, -0.17113560f, 0.02771248f, 0.08179426f, 0.06143232f, 
    -0.08661587f, -0.09002313f, -0.09458768f, -0.10275411f, 0.14850499f, 0.14193435f, -0.15856445f, -0.14395577f, 
    0.01280541f, -0.08953116f, -0.07189257f, -0.00188698f, -0.03731862f, -0.09987710f, 0.04517418f, 0.01535717f, 
    -0.04301922f, -0.12169291f, -0.06187807f, -0.11130085f, -0.16282248f, -0.11417187f, -0.12149187f, -0.08254181f, 
    0.10061022f, 0.01089595f, -0.17305283f, 0.12900923f, 0.01790643f, 0.16803309f, -0.03946665f, 0.16002505f, 
    -0.16340575f, -0.08425453f, -0.17613871f, 0.17472136f, -0.23904575f, -0.20468739f, 0.13969111f, -0.06706145f, 
    0.13263135f, 0.01446334f, 0.07455975f, -0.07439623f, 0.12342736f, -0.25965792f, -0.20435046f, -0.03471735f, 
    -0.13659331f, 0.13810332f, -0.24295974f, 0.13282034f, -0.16473618f, -0.21676773f, 0.19727787f, 0.26472381f, 
    -0.04930771f, 0.17396410f, -0.15077013f, 0.11558700f, 0.00805810f, -0.06245106f, -0.16738921f, 0.19236033f, 
    0.15478769f, -0.08895130f, 0.03664890f, -0.01078863f, 0.27223343f, -0.30523720f, -0.11075800f, 0.18491711f, 
    0.10297249f, 0.00202191f, -0.11172706f, -0.24347621f, 0.17545797f, -0.09467235f, 0.00795431f, 0.08926772f, 
    0.07373820f, 0.12192626f, 0.22102150f, 0.04966219f, -0.00970274f, -0.13121025f, -0.20321615f, 0.14510398f, 
    0.14906928f, 0.14505404f, 0.08942389f, -0.00276234f, 0.17603709f, -0.06972812f, 0.03575328f, 0.17211697f, 
    0.02298997f, 0.10336389f, 0.11611950f, -0.04577621f, -0.10554659f, 0.04755628f, -0.14717327f, -0.16103972f, 
    0.17285845f, -0.06282075f, -0.02430136f, 0.05047020f, 0.11388910f, -0.05391555f, 0.16625863f, -0.10621320f, 
    0.06751405f, 0.50501341f, 0.32866225f, -0.10249323f, 0.18960629f, 0.31940788f, -0.06357275f, 0.07266360f, 
    0.08039647f, 0.02628778f, -0.00488640f, -0.01128410f, 0.06388436f, -0.03372625f, 0.02024663f, 0.24986714f, 
    -0.08498493f, -0.29999235f, 0.13299191f, -0.01666819f, -0.12699361f, -0.04898118f, -0.13253906f, -0.28682831f, 
    -0.04874761f, -0.05780477f, -0.16534561f, -0.13878027f, 0.25218835f, 0.05496650f, 0.19545309f, 0.04286262f, 
    0.14656128f, 0.10345298f, 0.07013958f, 0.01892700f, -0.04770172f, -0.15581535f, 0.10267958f, 0.08613836f, 
    0.02597898f, 0.05104987f, -0.05749942f, 0.13125913f, -0.20322140f, 0.01442287f, 0.06295736f, -0.20931390f, 
    -0.15810226f, 0.17160441f, -0.05583815f, 0.03590868f, -0.08870727f, 0.48228905f, -0.04512642f, 0.16766898f, 
    -0.09524614f, 0.12747148f, 0.13430892f, -0.12832712f, 0.05379293f, -0.10250641f, -0.14751936f, 0.02382049f, 
    0.13907614f, 0.02242362f, 0.05918448f, -0.14695032f, -0.14801054f, 0.02445612f, 0.07421895f, -0.01926424f, 
    -0.13352610f, 0.12679467f, 0.00214506f, 0.08511059f, 0.12611499f, -0.00338088f, 0.03426017f, -0.01499099f, 
    0.11113182f, 0.12617733f, 0.09981121f, 0.13982216f, -0.16884142f, -0.15310311f, 0.10013884f, -0.23204656f, 
    -0.14331345f, 0.32027119f, 0.15666880f, 0.09869374f, 0.21301535f, 0.24756268f, -0.03101025f, 0.00307700f, 
    -0.05762935f, 0.07611144f, 0.40015230f, 0.27696040f, 0.09391762f, 0.37169129f, -0.37065884f, 0.27499643f, 
    0.01136569f, 0.06306870f, -0.08962354f, -0.02165695f, 0.14303774f, 0.11318657f, 0.05849165f, -0.15615979f, 
    0.09601453f, -0.09994368f, 0.10845892f, -0.04286385f, -0.20712011f, -0.06338545f, 0.10340677f, 0.02103733f, 
    0.00714512f, -0.15852651f, 0.18320757f, -0.09217913f, 0.08620400f, 0.09884042f, -0.02185472f, -0.13053542f, 
    -0.01085811f, -0.02084930f, 0.14297844f, -0.04790606f, -0.14691062f, -0.15671346f, -0.18024501f, 0.19294193f, 
    0.03695255f, 0.13676104f, -0.11302999f, 0.06721519f, -0.25413159f, -0.11126117f, -0.10399469f, 0.15308394f, 
    0.14920445f, 0.13528426f, -0.02198885f, -0.02623225f, -0.29419935f, 0.14737639f, -0.05491316f, -0.18489866f, 
    0.08457527f, -0.11179645f, 0.05181104f, -0.02808973f, 0.20173624f, -0.29945955f, 0.12988304f, 0.02506430f, 
    0.10710904f, 0.45079699f, -0.21140145f, -0.08730961f, 0.02316362f, 0.20190929f, 0.12153608f, -0.10055996f, 
    0.07150743f, -0.12439962f, 0.16612425f, 0.00934952f, -0.30175087f, 0.13276653f, 0.13364200f, 0.11872894f, 
    0.06614877f, 0.40103024f, -0.00339853f, 0.03067243f, 0.14857776f, -0.04838998f, -0.04696339f, -0.09517609f, 
    -0.05598336f, -0.04193767f, -0.16139778f, 0.26733255f, 0.23507427f, -0.05324243f, -0.00608102f, -0.10903222f, 
    0.07047755f, 0.32801616f, 0.04981615f, 0.21143979f, -0.25115192f, -0.02997826f, -0.20938410f, 0.04446327f, 
    0.07951929f, -0.14615697f, 0.12927705f, 0.03711607f, -0.33367836f, -0.05436219f, 0.11789466f, 0.01702225f, 
    -0.14596656f, 0.12730514f, 0.04752956f, 0.13870135f, 0.26149502f, 0.09789365f, -0.03679357f, -0.03502997f, 
    0.17497893f, 0.07483164f, -0.01914136f, 0.07076267f, -0.01903037f, -0.10890929f, 0.12622865f, -0.11085699f, 
    0.15714867f, 0.35989374f, -0.16306834f, -0.03353872f, 0.03499894f, -0.21662357f, -0.01662667f, -0.05388034f, 
    0.06897035f, 0.12324791f, -0.05068089f, -0.09583882f, 0.17225942f, 0.05898624f, 0.06257787f, 0.16101763f, 
    0.14441773f, 0.21422431f, -0.09500644f, 0.08264817f, 0.00434444f, -0.46089476f, 0.02532786f, 0.29868948f, 
    -0.15696613f, -0.19854137f, -0.16789271f, -0.14168702f, -0.17721120f, 0.15081911f, -0.01132570f, 0.04984065f, 
    0.05589247f, 0.03563528f, -0.30829838f, -0.12271823f, -0.08264323f, 0.08180320f, -0.05387945f, 0.22886500f, 
    0.09117183f, 0.07706071f, -0.10576539f, -0.07180862f, -0.29991969f, 0.11233734f, 0.00227856f, -0.09972668f, 
    -0.03318141f, -0.18273923f, -0.07627007f, -0.05429431f, 0.14357799f, 0.04638370f, 0.13032684f, 0.05412026f, 
    0.01268349f, -0.03685419f, -0.11872678f, 0.07111277f, -0.27598736f, -0.22569145f, 0.14809263f, 0.13226509f, 
    0.15858588f, 0.38123536f, 0.04273151f, -0.01155257f, 0.28914401f, -0.22184366f, 0.06790262f, 0.19456927f, 
    -0.02605326f, -0.15534723f, -0.03078534f, -0.10352869f, 0.28750426f, 0.00742868f, 0.02684796f, 0.21706158f, 
    0.16954285f, -0.22141972f, 0.12199589f, 0.03295672f, 0.01088472f, 0.03951914f, -0.14149891f, -0.02710611f, 
    0.06307919f, 0.06634689f, 0.11389990f, 0.16263501f, -0.00121082f, -0.07851727f, 0.02008175f, -0.07025580f, 
    -0.00979562f, -0.54678077f, 0.24536413f, 0.09873085f, -0.03143743f, 0.03957947f, 0.25681147f, -0.30522126f, 
    -0.00069467f, -0.16933444f, -0.14865385f, -0.13774005f, 0.18240407f, 0.01818674f, -0.16706802f, -0.12213992f, 
    0.03186291f, 0.11804774f, 0.02482506f, 0.07168049f, 0.22244884f, -0.64730859f, 0.11002500f, 0.35507792f, 
    -0.04615397f, -0.00874663f, 0.06746909f, -0.13340302f, 0.13492247f, -0.28448072f, 0.18157578f, 0.09369253f, 
    -0.07484803f, 0.31850156f, -0.25032279f, 0.06924208f, 0.16214672f, -0.08935211f, -0.08568031f, -0.13239823f, 
    0.04596143f, -0.04314467f, -0.01609189f, 0.05060253f, 0.02235608f, 0.00679411f, 0.01484795f, -0.12636608f, 
    -0.13655345f, 0.69222730f, -0.06878058f, -0.07573982f, 0.19553392f, 0.07011569f, 0.13176185f, 0.10276439f, 
    0.03492527f, -0.05140649f, 0.08234221f, -0.20100710f, -0.04910278f, 0.12074532f, -0.18265623f, -0.12791975f, 
    -0.05291701f, 0.04606808f, -0.05635078f, -0.11811888f, -0.08370985f, -0.09706729f, -0.10396861f, 0.18530695f, 
    -0.09281494f, 0.04487805f, 0.16432345f, 0.02780097f, -0.03523873f, -0.01993778f, -0.10263681f, 0.24737631f, 
    0.05684581f, 0.24552615f, -0.03953857f, -0.01666122f, -0.05384232f, -0.01690841f, 0.09585630f, 0.02161325f, 
    -0.06696118f, -0.05061775f, 0.10219572f, 0.18738014f, -0.11780501f, -0.28272235f, -0.01354258f, 0.06309412f, 
    0.08569889f, -0.13806343f, -0.15682806f, -0.17974727f, 0.11322327f, -0.23607951f, 0.40188906f, -0.42462113f, 
    -0.04227293f, 0.07238692f, 0.12102947f, 0.03248760f, 0.03660325f, 0.06852724f, 0.11647631f, -0.01020617f, 
    0.14208630f, 0.23048498f, -0.17128924f, -0.10444395f, 0.35926399f, -0.37243050f, -0.15102015f, 0.14510348f, 
    0.01912293f, 0.31981549f, -0.02677603f, -0.02493755f, 0.18036559f, -0.19306569f, 0.35883039f, 0.16436693f, 
    0.15620066f, 0.26029667f, -0.09023753f, -0.42190000f, 0.10199299f, -0.01395290f, -0.03129871f, -0.14444792f, 
    0.11581033f, -0.01602472f, -0.12346765f, 0.05102876f, 0.05580227f, -0.17317748f, 0.00881082f, -0.14869213f, 
    0.06963347f, 0.31424272f, 0.17222016f, 0.02629132f, 0.07517976f, -0.11057803f, -0.10932587f, 0.34089136f, 
    -0.13352980f, 0.41271386f, -0.04118121f, -0.01779191f, 0.09572662f, 0.11079864f, 0.27473897f, 0.12987155f, 
    0.11982981f, -0.00719760f, 0.05195940f, -0.02642122f, -0.40455231f, -0.05985975f, 0.08079252f, 0.02285645f, 
    0.04646586f, 0.08226777f, 0.07235975f, -0.07794084f, -0.33572856f, -0.05956001f, -0.16823471f, 0.26668197f, 
    -0.05512901f, -0.38613746f, -0.03030326f, -0.07549060f, 0.12824436f, -0.28504497f, 0.05330454f, 0.26739359f, 
    0.16572209f, -0.26507366f, -0.06764045f, 0.29476425f, 0.11748719f, 0.08450455f, -0.27020356f, 0.10960327f, 
    -0.12736073f, 0.27746087f, -0.10479610f, 0.02390995f, -0.02297310f, 0.41764367f, 0.05269333f, -0.09980162f, 
    -0.09483878f, 0.12409708f, 0.00153381f, -0.06597948f, 0.02757724f, -0.09941574f, 0.10148426f, -0.24956432f, 
    0.00231824f, -0.08554903f, 0.15746549f, 0.13163230f, 0.17481445f, 0.32858360f, 0.01681517f, -0.11289442f, 
    -0.15238830f, -0.03554538f, 0.14787963f, 0.39420760f, -0.01390202f, -0.05812812f, 0.01452195f, 0.15999527f, 
    0.14445472f, -0.11240247f, 0.31652653f, 0.08618748f, -0.19841234f, -0.00423173f, 0.26361650f, 0.02333050f, 
    0.12807819f, -0.12614998f, -0.11398840f, 0.11531217f, -0.30228141f, 0.10656808f, 0.01239205f, 0.01401162f, 
    0.02865218f, -0.27544564f, -0.12590197f, -0.06038169f, 0.22761141f, -0.07361588f, -0.04749255f, -0.17539552f, 
    -0.12402104f, -0.24535361f, -0.16868077f, 0.20920029f, 0.25822169f, 0.10976532f, 0.05618551f, 0.01199485f, 
    0.10378841f, -0.35378894f, 0.34051165f, 0.23463635f, -0.03209855f, -0.26801547f, 0.27071351f, -0.01929124f, 
    -0.11459541f, 0.15870196f, 0.10200495f, -0.12889253f, 0.01299265f, 0.17648643f, 0.11523090f, -0.26909441f, 
    0.07551698f, 0.46099219f, 0.07772121f, 0.02386989f, 0.16312574f, 0.16713959f, 0.03341463f, -0.26191208f, 
    -0.03916600f, -0.12183926f, 0.06679690f, -0.24591237f, -0.15029022f, -0.24220693f, 0.18124583f, 0.00651666f, 
    0.04621352f, 0.05394210f, 0.09704816f, 0.01841499f, 0.18761922f, 0.38688892f, -0.07795389f, 0.20903218f, 
    0.02073787f, -0.05831850f, -0.08702983f, 0.15163623f, 0.40784407f, 0.00725498f, 0.08216499f, 0.20263417f, 
    0.15734006f, 0.01227494f, -0.08671062f, -0.07251131f, 0.09512563f, -0.23842140f, 0.07221121f, -0.01223476f, 
    -0.14810826f, -0.13619058f, 0.04281968f, 0.33878365f, 0.06148882f, -0.04960731f, -0.22199199f, -0.02829160f, 
    -0.10447106f, 0.14039926f, 0.29912022f, 0.13368650f, 0.19094440f, -0.21658900f, -0.24017230f, 0.08657413f, 
    -0.01640133f, -0.05879814f, -0.02391722f, 0.05488620f, 0.30179802f, 0.10441525f, -0.03176387f, -0.05070378f, 
    -0.15583023f, 0.22939765f, 0.11973342f, 0.07491943f, 0.21846332f, 0.04970082f, -0.16524376f, -0.21809705f, 
    -0.11109032f, 0.22679865f, 0.10698898f, 0.17012784f, -0.08531934f, 0.13000637f, 0.16559508f, 0.00537017f, 
    0.07160862f, -0.12272500f, 0.31633750f, -0.08474343f, -0.03802045f, 0.33954969f, -0.11798397f, -0.16695030f, 
    -0.06440820f, 0.09623839f, -0.18292803f, 0.06915978f, -0.01924944f, -0.14249073f, 0.12942271f, 0.11030443f, 
    -0.06568046f, 0.14654286f, 0.08871695f, -0.08460959f, -0.07413778f, -0.20698802f, 0.13531755f, -0.00176054f, 
    -0.13335830f, 0.33527002f, 0.06225749f, 0.24730828f, 0.19337624f, 0.26451403f, 0.11352728f, 0.17471536f, 
    0.02468981f, -0.29870826f, 0.23215103f, 0.20702362f, -0.22040810f, -0.43137106f, 0.07943023f, 0.22014418f, 
    0.15741009f, 0.10968760f, 0.05570779f, -0.00954022f, -0.07304864f, -0.10897060f, -0.09517787f, 0.21332304f, 
    0.04578516f, -0.14964563f, -0.04654359f, -0.01128269f, -0.12170699f, -0.11152890f, 0.11417542f, 0.08220035f, 
    -0.11081395f, -0.59439290f, -0.12467839f, -0.12386025f, -0.17226207f, 0.22569521f, 0.04691026f, 0.11465247f, 
    0.02640848f, -0.12878366f, -0.20258655f, -0.17537747f, 0.16021472f, 0.36678362f, 0.28901783f, -0.37301385f, 
    0.03107462f, -0.13794225f, 0.03413374f, -0.06141565f, 0.13119084f, -0.12768368f, 0.12158775f, -0.13915388f, 
    0.11346138f, 0.05369165f, 0.13920133f, -0.01587166f, 0.29173779f, 0.10771066f, -0.10550555f, -0.05385912f, 
    0.16677777f, 0.00488997f, 0.05530988f, 0.42665023f, -0.28852299f, -0.30941033f, -0.14859469f, 0.15608966f, 
    -0.07215587f, 0.25128847f, 0.15872133f, 0.00350336f, -0.03748963f, -0.01641254f, 0.34425229f, -0.04063068f, 
    -0.14023811f, -0.15840293f, 0.08369074f, 0.09721504f, -0.08203372f, 0.03213689f, 0.10529813f, 0.18731149f, 
    0.06883030f, -0.41330135f, -0.02438922f, -0.15789048f, 0.21116352f, 0.12618679f, -0.12606025f, -0.16097014f, 
    0.05887502f, 0.14951158f, -0.14081664f, 0.20456529f, -0.08707324f, -0.17900409f, 0.29487884f, 0.05016018f, 
    0.08815107f, 0.17956072f, -0.00738462f, -0.25626108f, -0.02513369f, 0.13437347f, -0.04764894f, -0.14596622f, 
    -0.09366491f, 0.15889746f, -0.04832145f, 0.16538399f, 0.39877689f, -0.15946272f, -0.01992206f, -0.07208665f, 
    0.08161239f, -0.22011709f, 0.10717959f, 0.10908509f, 0.05480311f, 0.13618816f, -0.14195903f, 0.02504851f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.11956289f, -0.00403557f, -0.16334566f, 0.05932228f, -0.12249574f, -0.04699491f, 0.07365730f, -0.02730407f, 
    0.07678387f, 0.25413907f, 0.28068683f, 0.01053033f, 0.10311146f, 0.19065115f, 0.06086712f, 0.12444574f, 
    -0.08305717f, -0.17085299f, 0.18234624f, -0.08518239f, 0.16608387f, -0.06268146f, 0.10248807f, 0.06779481f, 
    -0.18999460f, 0.27493846f, 0.20032324f, 0.21854189f, -0.04929281f, 0.17447193f, 0.18331753f, 0.11395445f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.66034472f, 0.10316260f, 0.28896645f, -0.38161275f, 0.01354179f, -0.05738383f, -0.07218625f, 0.21824943f, 
    -0.01280710f, 0.11194383f, -0.08755989f, -0.12698074f, -0.06189761f, -0.01034053f, -0.08653621f, -0.17472479f, 
    -0.06800604f, -0.22584720f, 0.03253483f, -0.47182459f, -0.06959947f, 0.14611201f, -0.35370186f, -0.12249200f, 
    0.02954605f, -0.07970534f, -0.59961021f, 0.11533894f, 0.26298699f, -0.22355123f, -0.39455774f, -0.29564416f, 
    -0.25067967f, -0.02159994f, -0.25016347f, 0.13431847f, -0.01194930f, 0.01602505f, 0.18396351f, -0.20396012f, 
    -0.04762854f, 0.25300676f, 0.09676754f, -0.06887508f, -0.26666513f, 0.03985906f, 0.08910687f, -0.03861620f, 
    -0.06066150f, -0.06983834f, 0.01645572f, -0.28868386f, 0.24257210f, 0.22434026f, 0.12572664f, -0.71012443f, 
    -0.52849680f, 0.26118258f, -0.10958942f, 0.28775129f, 0.02464760f, 0.26214018f, -0.33694121f, 0.33484787f, 
    -0.12678345f, 0.03079912f, -0.32093823f, -0.07493377f, -0.19238828f, 0.04120883f, 0.12773323f, -0.18630202f, 
    0.03544047f, 0.16710761f, 0.18922162f, -0.38984844f, -0.28175467f, 0.04504177f, 0.30577445f, 0.20437399f, 
    0.35287386f, -0.22213905f, 0.25775087f, 0.10303199f, -0.12093234f, -0.30148867f, -0.27051425f, 0.07296077f, 
    0.12589015f, -0.07948434f, 0.24147727f, 0.22562125f, 0.19203116f, -0.50902462f, 0.14686221f, 0.02512271f, 
    -0.07699187f, 0.02486576f, 0.00798595f, -0.13157137f, 0.15445933f, -0.35904008f, -0.53625661f, -0.16316979f, 
    -0.14142813f, -0.10669955f, -0.64449036f, 0.00163638f, 0.15351205f, 0.05313017f, -0.44873896f, -0.47147086f, 
    0.26122344f, 0.15951699f, -0.65497887f, 0.29401851f, -0.03077735f, 0.07957430f, -0.11137262f, 0.11569434f, 
    0.04311775f, -0.31067055f, -0.03128977f, 0.12641200f, 0.16686255f, -0.22818589f, 0.10229667f, -0.19296914f, 
    -0.15375389f, -0.30245528f, 0.17826930f, -0.55758572f, 0.13010551f, -0.17161895f, 0.21395834f, -0.08118587f, 
    -0.11031099f, 0.05893659f, -0.27981877f, -0.02927891f, 0.27366734f, -0.14793663f, -0.05721056f, 0.15404525f, 
    -0.17379718f, -0.38316113f, -0.22018115f, -0.26944795f, -0.17521456f, 0.12306270f, -0.25361437f, 0.33434716f, 
    -0.15869699f, -0.15990783f, 0.00841074f, -0.06746215f, 0.00530484f, 0.29352596f, 0.31424710f, -0.41529232f, 
    -0.35281149f, -0.07403871f, 0.20597835f, -0.09043308f, 0.16867785f, 0.09125589f, 0.16898887f, -0.09600823f, 
    0.06827421f, 0.04893573f, -0.26197517f, 0.14086261f, 0.05225260f, 0.15023087f, -0.30355340f, 0.13881193f, 
    -0.24201821f, 0.26596165f, -0.10394125f, -0.10822979f, -0.13831259f, -0.18010885f, -0.33142421f, -0.31210038f, 
    0.02459252f, 0.25065172f, 0.19013163f, 0.00005641f, -0.03433352f, -0.32997540f, -0.21311069f, -0.11440963f, 
    0.11634406f, -0.00522373f, -0.01562153f, -0.18277769f, -0.36332634f, 0.23780131f, 0.05306440f, -0.31140259f, 
    0.18051615f, -0.31921414f, -0.13943006f, -0.26915854f, -0.64217830f, -0.43427458f, -0.11598993f, 0.18384084f, 
    0.10009275f, -0.44929096f, 0.12068835f, 0.12392405f, -0.72936267f, -0.53582555f, -0.04232772f, 0.28262359f, 
    0.17992026f, 0.17952439f, 0.04730630f, 0.02638249f, -0.05096052f, 0.16302769f, 0.36105412f, 0.08465236f, 
    0.10889819f, 0.07266390f, 0.11008909f, -0.38775942f, -0.46952814f, -0.19063585f, -0.03111286f, 0.19767423f, 
    -0.04569161f, 0.09786035f, -0.19569124f, 0.08010662f, 0.28446549f, -0.48034734f, 0.03529687f, -0.38568199f, 
    -0.25198230f, 0.18213497f, -0.14467943f, -0.13375434f, -0.29390088f, -0.21747461f, 0.18927512f, -0.32216361f, 
    0.28440553f, -0.14553347f, 0.25835726f, -0.03792282f, -0.32487619f, -0.06246891f, -0.52867883f, -0.22653762f, 
    0.07074087f, -0.08401795f, -0.36860698f, -0.14219853f, -0.18708070f, 0.00261973f, -0.56036448f, 0.39951661f, 
    -0.10789460f, -0.29120615f, -0.28035554f, -0.01906483f, -0.45513222f, 0.04384505f, 0.09440864f, 0.05196952f, 
    0.00061169f, 0.23087251f, 0.04783440f, 0.28214994f, 0.38641471f, -0.41635913f, -0.04574417f, -0.37745667f, 
    -0.01433740f, -0.03977657f, -0.04818057f, -0.17125125f, -0.51642931f, 0.00042817f, -0.55933273f, 0.01472675f, 
    0.27364391f, -0.47366729f, 0.02568701f, -0.20308176f, -0.16688615f, 0.17095472f, 0.04812106f, 0.11095080f, 
    -0.16545068f, 0.13144819f, -0.01739328f, -0.33729413f, 0.25049832f, -0.29004213f, -0.45228526f, 0.02893618f, 
    -0.37647521f, -0.28515670f, -0.27642605f, -0.54524410f, -0.59495306f, -0.36744049f, 0.19090091f, 0.05232653f, 
    -0.00209173f, -0.25414675f, 0.15379144f, -0.09645198f, 0.12867761f, -0.42574367f, 0.22098733f, 0.09665129f, 
    -0.26221406f, -0.37351358f, -0.59592712f, -0.36351103f, 0.06503026f, -0.40708846f, 0.10618451f, 0.02074005f, 
    -0.25267726f, -0.57837713f, -0.67791247f, 0.24825186f, 0.03921791f, 0.23411480f, -0.01830558f, 0.15180175f, 
    -0.38449809f, 0.13445628f, -0.49133131f, 0.24633180f, 0.19730033f, 0.11861309f, -0.07211626f, -0.15055902f, 
    -0.45681947f, -0.11069469f, -0.31406760f, 0.01323211f, -0.08536364f, -0.38495970f, 0.30545291f, 0.23298192f, 
    0.35331467f, 0.03165818f, 0.11746012f, -0.18621713f, 0.38326538f, -0.26613042f, -0.50995111f, -0.23077996f, 
    -0.13737616f, -0.34935889f, -0.44601089f, -0.19964974f, -0.29808900f, 0.14519969f, -0.10195426f, 0.19816987f, 
    0.20507059f, -0.16340506f, -0.81534618f, 0.39155504f, -0.23688118f, -0.15267998f, 0.06046676f, -0.36901122f, 
    -0.19347095f, 0.07576373f, -0.07547466f, -0.42243510f, 0.03332596f, 0.05859185f, 0.06258655f, -0.00086966f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.25208217f, 0.24090870f, 0.06929784f, -0.09712732f, 0.09954291f, 0.19694749f, -0.04708830f, -0.13125032f, 
    0.14393264f, -0.19943382f, -0.08079001f, -0.16878490f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
