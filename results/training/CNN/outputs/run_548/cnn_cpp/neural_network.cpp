#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.11731426f, 0.39588735f, -0.52100343f, 0.23947924f, -0.67592013f, 0.76881880f, 0.24142140f, -0.10565677f, 
    0.15949525f, 0.63284838f, -0.80599481f, -0.72627115f, -0.34119350f, -0.56799805f, 0.06124093f, 0.08554066f, 
    0.25940493f, 0.37308505f, -0.85745138f, 0.32607138f, -0.22213757f, 0.17020659f, 0.70440853f, -0.25990918f, 
    -0.35539535f, -0.58868438f, -0.38799217f, -0.81374031f, -0.14385529f, -0.31355143f, 0.74517518f, 0.84990847f, 
    0.63387334f, 0.55942005f, 0.21254054f, -0.21106943f, 0.25417578f, 0.60396862f, -0.93205583f, -0.34378621f, 
    -0.27465835f, -0.20992535f, -0.40597621f, -0.37355667f, 0.24568532f, 1.01702058f, 0.28655913f, 0.52954423f, 
    0.85337538f, 0.14527178f, -0.11253725f, 0.24480535f, 0.41449928f, -0.01350822f, -0.71446300f, -0.22734652f, 
    -0.09092769f, -0.23732956f, -0.27923515f, -0.79979116f, 0.49304047f, 0.04725123f, 0.16107138f, 0.52901340f, 
    -0.90545160f, 0.61790913f, -0.75187689f, 0.30403149f, 0.01157084f, -0.04864373f, 0.20898981f, 0.15859637f, 
    0.15637471f, 1.09587431f, -0.93620926f, 0.31798616f, 0.25587842f, -0.26942867f, 0.41037944f, -0.02023633f, 
    0.00576875f, -0.30981898f, 0.66296208f, 0.86998141f, 0.49846917f, 0.60290927f, 0.46779221f, 0.06078967f, 
    0.00378961f, -0.03123325f, 0.06092606f, 0.38766366f, 0.24199735f, 0.28080314f, -0.84880233f, -0.93880606f, 
    -0.07053967f, 0.10302363f, 0.19714494f, -0.26164761f, 0.80108607f, 0.44424430f, -0.43916714f, -0.22633615f, 
    0.44026369f, -0.19016489f, 0.22292455f, 0.51439047f, -0.70724589f, -0.91480631f, -0.76559347f, -0.01856143f, 
    -0.30502683f, -0.17227171f, -0.06259510f, -0.05955254f, -0.25569963f, 0.86111826f, 0.74776942f, 0.81057185f, 
    -0.66751647f, 0.15701967f, -0.24768253f, -0.00613078f, 0.05142449f, -0.07794716f, 0.41180044f, -0.30606762f, 
    -0.53450465f, -0.40907732f, 0.58445907f, -0.74694145f, -0.27273455f, -0.28655663f, -0.28174049f, 0.70879352f, 
    0.59703732f, 0.70809758f, 0.42857173f, -0.37638608f, 0.60036188f, -0.17721459f, -0.27214271f, -0.16627654f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.21017326f, -0.10904527f, -0.06387526f, 0.10197946f, -0.11797549f, 0.26828349f, 0.23008366f, -0.33379278f, 
    -0.47654077f, 0.23608615f, -0.30984697f, -0.49960241f, -0.21293463f, -0.04856300f, 0.29277545f, -0.00060231f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.06791053f, 0.13067573f, 0.06832353f, -0.03091563f, 0.00799621f, 0.07205199f, 0.04736115f, -0.00857483f, 
    -0.03172289f, 0.03081836f, 0.13361490f, -0.00197680f, 0.15604456f, -0.15302224f, 0.22834514f, -0.07106268f, 
    0.00761489f, 0.00324893f, -0.47790995f, -0.33641547f, -0.27146995f, 0.16799390f, -0.09561548f, -0.14983058f, 
    0.03262819f, 0.04514925f, -0.16337873f, -0.40560624f, -0.34609032f, -0.22310707f, 0.07490615f, -0.07692742f, 
    -0.02456232f, -0.15861844f, -0.07346758f, -0.06352047f, -0.06425178f, 0.07625062f, -0.03678174f, 0.08926006f, 
    -0.15533139f, 0.15592381f, 0.01213001f, -0.06605729f, -0.01199204f, 0.35469744f, 0.02339182f, 0.14406253f, 
    0.04247953f, -0.15508746f, 0.02715357f, 0.11274690f, 0.23128742f, 0.02178435f, -0.35590923f, -0.01467122f, 
    -0.12324627f, 0.14678077f, 0.06254222f, 0.11786789f, -0.06079805f, -0.21153520f, 0.01147970f, -0.09738603f, 
    -0.21824189f, 0.22670332f, -0.02080143f, -0.09515540f, 0.01467883f, -0.07404756f, 0.13520229f, -0.15813866f, 
    0.22960784f, -0.20982534f, 0.05958163f, -0.08619925f, 0.00914460f, -0.26376235f, -0.01210016f, -0.03637185f, 
    0.19058079f, -0.08486827f, 0.13196357f, 0.11452992f, 0.00350710f, 0.06052802f, -0.07734573f, -0.01336633f, 
    0.02625460f, 0.01748673f, 0.12129685f, -0.14684531f, -0.41095296f, 0.23661649f, 0.15402901f, 0.12887162f, 
    0.01192374f, 0.18824901f, 0.27358457f, 0.22648077f, -0.23635671f, -0.23878758f, -0.06582016f, 0.12185848f, 
    -0.22582428f, -0.08378511f, -0.05647098f, 0.03496234f, 0.48521370f, 0.40460083f, -0.26103443f, -0.25883225f, 
    0.08064641f, 0.05815867f, 0.08901154f, 0.10477273f, -0.02319746f, 0.45563024f, 0.19134319f, -0.01126833f, 
    0.14635529f, -0.04449604f, 0.08702455f, 0.02434153f, 0.05787268f, 0.04772417f, -0.05265611f, -0.09710339f, 
    -0.67185116f, 0.00217547f, 0.07299096f, 0.07839831f, 0.03143278f, -0.12484396f, 0.08988304f, 0.33869320f, 
    0.22066540f, 0.14203066f, -0.03564506f, 0.01660715f, 0.25666818f, 0.02432819f, 0.02291256f, -0.06292897f, 
    -0.14850807f, -0.37425303f, -0.04793615f, 0.04179801f, -0.04345974f, -0.18024194f, -0.23432235f, -0.15376242f, 
    -0.12809382f, 0.02469505f, -0.35832548f, -0.40265465f, 0.03815714f, -0.08185215f, 0.10926438f, -0.12263212f, 
    0.23003881f, -0.06424898f, -0.18800679f, 0.03995408f, -0.10855853f, 0.14353132f, 0.01718095f, -0.04194500f, 
    -0.05962386f, -0.09189813f, 0.06989635f, -0.38081014f, 0.04407518f, -0.29124951f, 0.27226499f, 0.09575268f, 
    0.09166321f, 0.02595147f, 0.02059460f, -0.04747808f, -0.08634023f, -0.00562376f, 0.00899440f, -0.15035832f, 
    -0.18457779f, -0.24529469f, 0.06290860f, -0.01026522f, 0.15397330f, -0.23303191f, -0.07231942f, 0.05384857f, 
    0.01555935f, 0.13770068f, -0.09505970f, 0.04116926f, 0.03761395f, 0.06297287f, 0.11959857f, 0.14289311f, 
    -0.13467351f, 0.14352797f, 0.01776846f, -0.03045710f, 0.00524484f, -0.07968523f, 0.05371347f, -0.26380509f, 
    0.15008026f, 0.01597659f, -0.17994966f, -0.31674701f, 0.08715861f, 0.06155388f, -0.09886437f, 0.22287440f, 
    -0.59932518f, -0.11635725f, 0.06288788f, 0.09360806f, -0.01533101f, -0.21974427f, 0.00151925f, -0.01579555f, 
    -0.14705855f, 0.38318029f, -0.03410173f, 0.14559260f, 0.07598299f, 0.27306587f, 0.25538883f, -0.01321850f, 
    0.03197452f, 0.11424839f, 0.11101260f, -0.11084034f, 0.28304598f, 0.17901571f, -0.08784192f, -0.04545280f, 
    0.01648447f, -0.03508912f, 0.30914423f, -0.05691739f, -0.20421410f, -0.17083210f, -0.38402346f, 0.16399445f, 
    0.02997677f, 0.03856769f, -0.10599799f, 0.03677489f, -0.46923560f, 0.20004606f, -0.04813348f, 0.19489843f, 
    0.07204129f, 0.06380782f, 0.20901875f, -0.14994934f, -0.04366555f, -0.12793413f, 0.34994775f, 0.34328702f, 
    -0.00552076f, -0.11916332f, 0.05939511f, 0.08726949f, -0.04423722f, 0.04129489f, 0.09843373f, -0.18759869f, 
    0.11968289f, 0.10203639f, -0.05825746f, 0.09677402f, -0.06940529f, 0.04918823f, 0.12169781f, -0.10040265f, 
    0.10144871f, 0.35662627f, 0.27489138f, 0.19062671f, 0.27215871f, 0.13826834f, -0.06027769f, -0.06512287f, 
    0.18320154f, 0.17873502f, 0.09250441f, 0.20051990f, 0.09799260f, -0.15416391f, 0.25557256f, -0.04736149f, 
    -0.26890218f, 0.05617585f, 0.16350359f, -0.08388548f, -0.06352010f, -0.05416730f, 0.23526382f, 0.10723122f, 
    0.27420357f, -0.21572369f, -0.23414144f, 0.22205414f, 0.24620704f, 0.15280120f, 0.10911021f, -0.07210252f, 
    -0.06765421f, 0.08598474f, 0.35503563f, 0.01481572f, -0.08375732f, 0.26199025f, 0.21925646f, 0.12568884f, 
    0.01100883f, 0.01572820f, -0.00006470f, 0.05434670f, 0.17771982f, 0.13748817f, 0.37187383f, -0.03156402f, 
    -0.00885272f, 0.13654235f, -0.03685369f, -0.00272178f, -0.00550745f, 0.31865686f, -0.13065845f, 0.13363457f, 
    -0.17322148f, 0.06120068f, -0.24583241f, 0.17798330f, -0.21458653f, 0.00562295f, 0.11810945f, -0.00657188f, 
    0.23446810f, 0.31197926f, -0.01892225f, 0.05043741f, 0.00627188f, 0.08182584f, -0.38883641f, 0.36888644f, 
    -0.44897610f, -0.05493611f, -0.08873055f, 0.14268479f, -0.10457888f, -0.35142788f, 0.09622092f, -0.00064908f, 
    -0.26984623f, -0.03806731f, 0.01496557f, 0.27647331f, -0.20994443f, -0.29634693f, 0.16816920f, 0.09049212f, 
    -0.04094064f, -0.10950241f, -0.01094902f, -0.28932407f, 0.22845148f, -0.00480799f, -0.10301054f, 0.05902372f, 
    0.22790360f, 0.18213053f, -0.24552527f, -0.07971814f, -0.00030996f, -0.02510467f, -0.05389285f, 0.11306783f, 
    0.00547215f, -0.16920614f, -0.05648918f, -0.22718605f, -0.37453181f, -0.28938389f, -0.34040970f, -0.02427824f, 
    -0.26436967f, -0.19236328f, 0.06189734f, -0.04659455f, 0.59778684f, 0.33575255f, 0.29353493f, 0.25083250f, 
    -0.07148550f, -0.09925726f, 0.20759030f, -0.12052450f, 0.17107658f, 0.07533246f, -0.10631789f, 0.10064360f, 
    -0.09155621f, -0.14779972f, 0.13526866f, 0.07067443f, -0.10758693f, -0.04189235f, 0.23745166f, 0.05477750f, 
    0.07312421f, -0.05440044f, -0.01911821f, -0.19647858f, -0.10725266f, -0.08817016f, -0.09452962f, 0.26973444f, 
    -0.08865537f, -0.14413622f, 0.04951973f, -0.15729240f, 0.07385268f, 0.05124833f, 0.17709783f, 0.29952803f, 
    -0.16279332f, 0.04357150f, 0.07348206f, -0.12541789f, -0.03804363f, 0.14384024f, -0.16014196f, 0.12700097f, 
    -0.09526547f, 0.10190517f, 0.12108070f, -0.07873878f, 0.14392076f, -0.29431453f, 0.06784119f, 0.00467927f, 
    0.05544293f, -0.28692856f, 0.02770235f, 0.13274497f, -0.20681787f, -0.05736112f, -0.10864270f, -0.06655005f, 
    -0.26279750f, 0.10949354f, -0.08873677f, 0.05036110f, 0.25127330f, 0.21924628f, -0.14129703f, -0.28182045f, 
    -0.29906431f, 0.02337675f, -0.07993263f, 0.04740128f, -0.12367319f, -0.09219074f, -0.08599156f, 0.18730846f, 
    0.31019065f, -0.06887437f, -0.19507815f, 0.19198884f, 0.01499415f, 0.07486577f, -0.06830253f, -0.07093345f, 
    0.14946851f, 0.17722982f, 0.14617945f, 0.16496579f, 0.08503523f, 0.06385032f, 0.13159002f, -0.24273089f, 
    -0.30170515f, -0.20883800f, 0.02033070f, -0.12413407f, 0.09425858f, 0.09912587f, -0.01196907f, 0.12922695f, 
    0.37067518f, -0.34588024f, 0.04653661f, 0.24086586f, 0.25454774f, 0.20382214f, -0.08781757f, -0.10210451f, 
    0.17117964f, -0.14286964f, -0.12493078f, 0.07947264f, -0.30562791f, 0.01526580f, -0.23503180f, -0.02747008f, 
    0.18105878f, 0.34888357f, -0.16367552f, -0.26306361f, -0.10267489f, -0.21267642f, 0.17184605f, 0.04137842f, 
    0.21227044f, 0.02720866f, 0.24833927f, 0.19816922f, -0.00577693f, 0.11710820f, 0.02729444f, 0.19436955f, 
    0.03827519f, -0.02322828f, 0.14318517f, 0.07412483f, 0.13221595f, 0.27325922f, -0.10619073f, 0.02970839f, 
    -0.05057031f, 0.00638513f, -0.04009623f, 0.34763730f, -0.19817199f, -0.20314632f, 0.40801895f, -0.13633049f, 
    -0.04712288f, -0.35767102f, -0.00059181f, 0.03277384f, 0.02346593f, -0.05968720f, 0.19863340f, -0.21135239f, 
    0.18129195f, 0.32139090f, 0.16079719f, 0.14039624f, -0.06627718f, -0.13155921f, -0.25902641f, -0.17193046f, 
    0.11562356f, -0.06813870f, 0.16855472f, -0.26793000f, 0.02286023f, -0.01441682f, -0.22472049f, 0.11488023f, 
    -0.23783635f, -0.27469274f, 0.07430238f, 0.01131203f, 0.16025870f, 0.11611100f, 0.01979233f, -0.03917395f, 
    -0.11681351f, -0.13080862f, 0.01436231f, -0.00994736f, 0.09119546f, 0.10369329f, -0.00667806f, 0.02546820f, 
    -0.06592297f, 0.28633219f, 0.12910235f, 0.05578307f, -0.08113995f, -0.19844176f, 0.00953148f, -0.29783541f, 
    0.08943821f, 0.15174061f, 0.34133905f, 0.06231188f, 0.02537536f, 0.04334764f, 0.17543754f, 0.04719629f, 
    -0.10591324f, 0.14478335f, 0.10574013f, 0.16083661f, 0.11836226f, 0.06117643f, -0.08214609f, -0.05462134f, 
    -0.20537055f, 0.23691468f, 0.16418312f, 0.09731176f, 0.02100474f, 0.07829957f, 0.06422491f, -0.11990959f, 
    0.20819762f, 0.12885582f, -0.16787374f, -0.20024696f, -0.15815139f, -0.56815511f, -0.06767426f, -0.26449937f, 
    -0.05321070f, -0.09844700f, 0.06436685f, 0.25205785f, -0.20493132f, 0.19409879f, 0.07565282f, 0.30542654f, 
    0.15262261f, -0.10055269f, -0.23223549f, 0.02847931f, -0.12489904f, 0.04274926f, 0.00063511f, -0.10394724f, 
    -0.09079669f, 0.07940473f, 0.03587522f, 0.01364755f, -0.15964411f, -0.05846834f, -0.13456270f, 0.01100311f, 
    0.20603254f, -0.05312100f, -0.12575585f, -0.03228615f, -0.20801909f, -0.01076421f, 0.00636139f, 0.03166339f, 
    0.04198291f, -0.57013661f, 0.21222775f, -0.10797150f, -0.02576020f, 0.04332437f, -0.09885367f, 0.03067627f, 
    0.04070106f, 0.09185739f, 0.29197767f, -0.26844648f, -0.02518506f, -0.01583442f, 0.00263256f, -0.12424871f, 
    -0.18217619f, -0.07130112f, -0.06911906f, 0.03833131f, -0.29005080f, 0.04000492f, -0.00148391f, 0.08168430f, 
    -0.08584576f, 0.04488133f, 0.09392783f, 0.24285014f, 0.06226359f, 0.27343327f, 0.44637173f, 0.00075228f, 
    -0.04862387f, 0.07160962f, 0.01531595f, 0.15151358f, -0.10845360f, -0.62357455f, -0.39925566f, 0.13786356f, 
    0.21116278f, -0.04993470f, 0.21535893f, -0.16371429f, -0.05824387f, -0.21372055f, 0.04669638f, 0.19865790f, 
    0.31771392f, 0.03863750f, -0.02495031f, 0.17181464f, -0.16196519f, -0.25633267f, -0.15607652f, -0.34118858f, 
    -0.32271737f, 0.23280662f, -0.09809697f, 0.04869520f, 0.11205788f, -0.00864232f, 0.16073580f, 0.22310382f, 
    -0.26223978f, 0.10140263f, 0.14670637f, 0.08043743f, -0.00125562f, 0.07966941f, -0.04160165f, 0.04591721f, 
    0.04845908f, -0.15557680f, -0.53737819f, -0.01161765f, -0.20361963f, 0.31817171f, -0.11281764f, -0.11974614f, 
    0.09116728f, -0.12302312f, -0.07653311f, -0.04960319f, -0.02793095f, -0.19405919f, 0.13542016f, -0.22420448f, 
    0.27436221f, -0.10795179f, 0.00732486f, -0.12246417f, -0.23283078f, -0.38735476f, -0.05428489f, -0.02899826f, 
    0.15608823f, 0.12199204f, 0.00488216f, -0.12521940f, -0.09034260f, -0.17079920f, 0.01576162f, 0.09823652f, 
    -0.10003790f, 0.04853465f, -0.16771632f, -0.11768383f, 0.08218630f, -0.15565400f, 0.04562138f, 0.19544396f, 
    -0.10768732f, 0.10672862f, 0.01178624f, 0.06157841f, 0.03722948f, -0.08747938f, 0.11342558f, -0.00825465f, 
    -0.37216601f, 0.10843094f, 0.25307414f, 0.08883324f, -0.00372715f, 0.10890480f, -0.01438174f, 0.08114584f, 
    -0.05234028f, 0.01096743f, -0.01157110f, 0.16151527f, -0.01270895f, -0.23015919f, -0.13422593f, -0.00806618f, 
    0.16899440f, -0.31924200f, -0.11098034f, -0.15881291f, -0.01254981f, -0.10774333f, -0.15450904f, -0.17396899f, 
    -0.00377982f, 0.34374398f, 0.01022853f, 0.10705864f, -0.04873191f, 0.13745667f, -0.06150651f, -0.04998614f, 
    0.03865092f, -0.03801754f, 0.15072222f, -0.05249510f, 0.08916172f, -0.14108552f, 0.15357269f, 0.15560183f, 
    -0.11883478f, 0.30748805f, -0.00542895f, 0.06689860f, -0.09191678f, -0.44061652f, -0.02828016f, -0.36301875f, 
    0.16744529f, 0.01494651f, 0.16930127f, 0.03709002f, -0.58118302f, 0.05806110f, 0.05577063f, 0.04922941f, 
    0.18183097f, -0.05572260f, -0.10209121f, -0.01148863f, -0.18983285f, 0.24055126f, 0.29075018f, 0.14912152f, 
    -0.06876485f, 0.03799868f, 0.14925925f, -0.12780668f, 0.13042831f, -0.03840252f, -0.06542893f, -0.12171770f, 
    -0.25419751f, 0.10792664f, 0.23017737f, 0.18803525f, 0.14880133f, 0.03151202f, -0.03373953f, 0.03117034f, 
    0.06552807f, 0.32761469f, -0.05228249f, 0.12949471f, 0.08290560f, 0.06886889f, 0.07919611f, 0.19433852f, 
    -0.38500330f, -0.05867155f, 0.03807369f, 0.01388793f, -0.02372611f, -0.09310223f, -0.15902381f, -0.07184459f, 
    -0.05867156f, 0.15215084f, -0.16251175f, 0.07338195f, 0.22821262f, 0.36477339f, -0.05820611f, 0.05611308f, 
    -0.00246917f, 0.03438981f, -0.07090603f, -0.30469605f, -0.08186218f, 0.00198261f, -0.03822810f, 0.19011343f, 
    0.05684118f, 0.03533074f, 0.34104279f, 0.21016824f, -0.18215635f, 0.29818493f, -0.02186519f, -0.02459370f, 
    0.02075980f, -0.20604557f, 0.22344929f, 0.01948960f, 0.06744535f, -0.15478748f, -0.08573202f, -0.12186729f, 
    0.29160845f, -0.17239353f, 0.09372762f, 0.17386590f, -0.24519809f, 0.17604783f, 0.03594643f, -0.27278158f, 
    -0.05304360f, -0.06233791f, 0.17915143f, -0.23577556f, -0.08278892f, -0.02494645f, 0.03367585f, 0.23162174f, 
    -0.02966874f, 0.00583784f, -0.04685995f, -0.01957683f, 0.02311341f, -0.05962687f, 0.05106189f, 0.40293777f, 
    0.03065872f, -0.16476621f, -0.06164538f, -0.14376660f, 0.08504619f, -0.12668088f, -0.01538967f, -0.16778183f, 
    0.10312120f, -0.17946593f, 0.06636994f, 0.06803482f, -0.02481903f, -0.26216069f, -0.25781417f, -0.00510417f, 
    0.02597678f, 0.07366899f, -0.02118059f, -0.18265384f, 0.04948396f, 0.09016778f, 0.26405233f, 0.07006481f, 
    -0.03372292f, -0.35024887f, -0.19548747f, 0.17763628f, -0.01911854f, 0.08189188f, -0.20668398f, -0.38673401f, 
    -0.03315318f, 0.21665026f, -0.30903170f, -0.31620061f, 0.08327466f, -0.04731690f, 0.07076265f, 0.22062513f, 
    -0.26461741f, -0.00020617f, 0.03824640f, -0.27035177f, 0.04790701f, -0.13105385f, 0.24570225f, -0.19161372f, 
    -0.16877444f, -0.04216436f, -0.09183222f, -0.01479167f, 0.26922059f, 0.26087102f, 0.27835706f, 0.01443544f, 
    -0.11478890f, -0.17366585f, 0.15525284f, 0.17843324f, -0.07472958f, -0.26795343f, -0.01658377f, 0.26213360f, 
    0.16172166f, -0.15938769f, -0.19602300f, -0.00256535f, 0.00439799f, 0.06748796f, 0.32071155f, 0.03621689f, 
    0.29294762f, 0.07909704f, 0.03681342f, -0.00028416f, 0.10119196f, 0.00257974f, -0.04518847f, 0.09862156f, 
    0.42997101f, -0.00947406f, 0.15509184f, 0.11442298f, 0.13390906f, -0.06836403f, -0.14868248f, -0.14697459f, 
    0.02453060f, 0.24135984f, 0.21250707f, -0.33041123f, -0.14402671f, -0.07536925f, -0.13587135f, 0.02932211f, 
    0.03560306f, -0.00944300f, 0.12055785f, 0.18105371f, 0.25139314f, -0.08744506f, 0.05245037f, 0.19154437f, 
    -0.08609575f, 0.07959319f, 0.10893421f, -0.07035447f, 0.14924160f, 0.02941112f, 0.11569709f, 0.00325751f, 
    0.03758432f, 0.00861529f, 0.13257822f, 0.21052180f, 0.39205489f, 0.15120830f, -0.14666072f, -0.07743752f, 
    -0.04427015f, 0.00741539f, -0.02759649f, -0.00653500f, -0.00578915f, -0.16812257f, -0.17647824f, -0.29311830f, 
    -0.01893448f, -0.01154319f, -0.01109629f, -0.08418070f, 0.00593796f, -0.19339110f, -0.07983608f, 0.03360210f, 
    0.12963580f, 0.07068717f, 0.07656568f, 0.08802316f, -0.04147913f, -0.01218663f, 0.01805647f, -0.25947723f, 
    0.08686704f, -0.03821467f, -0.17342852f, -0.16709088f, 0.12142351f, 0.09762832f, -0.16518874f, -0.02181289f, 
    0.47981900f, 0.12334736f, 0.14207029f, 0.02271534f, -0.04316000f, 0.00377896f, -0.20424700f, 0.06199254f, 
    -0.23889340f, -0.35401222f, 0.07206775f, 0.17754205f, 0.01343072f, -0.14381467f, -0.05315255f, 0.07394600f, 
    0.06260195f, -0.06564929f, 0.35464266f, -0.12856302f, 0.30176517f, 0.20803408f, -0.00237191f, -0.13458170f, 
    0.03924067f, -0.01443547f, 0.16486126f, -0.09677420f, -0.34675080f, 0.11805422f, -0.12842929f, 0.13984050f, 
    0.14692505f, -0.01706813f, 0.10302015f, -0.09845516f, 0.01057765f, 0.21570337f, -0.09469470f, -0.02895425f, 
    0.00494721f, 0.01797648f, -0.10390305f, -0.02249943f, -0.04404706f, 0.00335227f, -0.75144529f, 0.05591581f, 
    0.10815070f, -0.12394199f, 0.11249208f, -0.06010349f, -0.24509476f, 0.03671109f, 0.02306925f, 0.30373845f, 
    -0.03290696f, 0.04977824f, -0.06845210f, 0.02704047f, -0.00099540f, -0.02379922f, 0.09868418f, -0.50156641f, 
    -0.19582589f, -0.31198326f, -0.01620499f, 0.15037005f, 0.06959356f, 0.06018508f, 0.21801771f, -0.04998290f, 
    -0.16178076f, -0.26475209f, -0.02566336f, 0.03992115f, -0.16745426f, 0.12591626f, -0.09593356f, -0.02797255f, 
    -0.05663314f, -0.04294168f, -0.50603890f, 0.06323612f, -0.24986498f, 0.09239517f, -0.09187599f, 0.07253639f, 
    0.02802303f, 0.04314639f, 0.17111984f, 0.17941660f, -0.14015755f, -0.12385388f, 0.05827788f, 0.12130795f, 
    0.24286914f, -0.02561110f, 0.06455418f, 0.59172571f, -0.04137914f, 0.10358993f, -0.14685355f, 0.10657539f, 
    -0.07145721f, 0.05006807f, 0.13781951f, -0.04533880f, -0.42206642f, -0.18516250f, 0.21159038f, 0.14303315f, 
    0.17861596f, 0.16742899f, 0.23135096f, 0.06595998f, 0.03039979f, -0.52500933f, -0.22829528f, -0.05982476f, 
    0.00544042f, 0.18394370f, 0.03784805f, 0.08938127f, 0.08896236f, -0.09787433f, 0.20300481f, 0.34839168f, 
    -0.09768798f, -0.04003990f, -0.02159718f, 0.00265177f, 0.01943287f, 0.22396496f, -0.11841892f, 0.24394310f, 
    0.20768523f, -0.20051351f, 0.23956512f, 0.18115756f, -0.19049178f, 0.10525104f, 0.13018437f, -0.31619802f, 
    0.15104623f, -0.27048278f, -0.15770271f, -0.10232093f, -0.01142457f, -0.12340305f, -0.01205333f, -0.03208683f, 
    -0.04947453f, -0.04750862f, 0.17210543f, -0.05849852f, -0.15948257f, 0.08301502f, 0.01297611f, -0.00963628f, 
    -0.11284943f, 0.05708686f, 0.29385412f, 0.16466248f, -0.28597257f, 0.02606561f, -0.03407532f, -0.08526103f, 
    -0.13962658f, 0.10998899f, 0.16007262f, -0.04644859f, 0.17519371f, -0.45764041f, -0.24146155f, 0.02271196f, 
    0.09504227f, -0.11445247f, -0.03735820f, -0.04122199f, -0.22823638f, -0.33917400f, 0.39458984f, -0.02580274f, 
    0.04878063f, 0.14712957f, -0.16711615f, 0.04363609f, -0.00857987f, -0.57986128f, 0.17663802f, 0.05189429f, 
    0.09648377f, 0.16035616f, 0.12531158f, -0.18088363f, -0.07039830f, -0.09904580f, 0.25518978f, -0.18827708f, 
    0.23563427f, -0.00541700f, -0.07156861f, 0.16949439f, -0.03544434f, 0.06187473f, 0.17642908f, -0.41161031f, 
    -0.01044549f, 0.18917067f, 0.09334007f, -0.05362589f, 0.15631263f, -0.02305403f, 0.08783837f, 0.13912494f, 
    0.01144185f, -0.26826268f, -0.12062556f, 0.10273150f, -0.16005494f, -0.11833178f, 0.18215950f, -0.10303884f, 
    -0.13039792f, 0.31827605f, -0.29567090f, -0.02757995f, -0.35792962f, -0.25239387f, -0.22623830f, 0.12656830f, 
    0.17329846f, 0.11606194f, -0.32692835f, 0.02851527f, -0.21571368f, 0.19604060f, -0.09829230f, -0.08053023f, 
    -0.22142051f, 0.29798242f, -0.09908371f, 0.16925667f, 0.11682846f, -0.03579684f, 0.23999512f, 0.14450972f, 
    0.09481288f, -0.05720517f, 0.20019686f, -0.00745653f, 0.15984897f, -0.03169933f, 0.19573626f, 0.06877120f, 
    0.03588449f, 0.06849416f, -0.08300622f, -0.03443413f, -0.07949667f, -0.83824581f, -0.26557431f, -0.36702201f, 
    0.07482295f, 0.03784791f, -0.01804326f, 0.18828923f, 0.01643496f, 0.10598793f, 0.20105666f, 0.17097777f, 
    -0.08319764f, -0.15686725f, 0.02850797f, 0.19183613f, 0.14502865f, -0.15257719f, 0.20420286f, -0.16278787f, 
    -0.14117409f, -0.12007545f, -0.26789960f, -0.32713157f, 0.08007305f, -0.01188054f, 0.04222436f, 0.17078233f, 
    -0.38262835f, 0.02449822f, 0.07805283f, 0.09843823f, -0.18329750f, -0.26787403f, -0.16066344f, 0.05001782f, 
    -0.16451399f, -0.07439395f, 0.01240907f, -0.08580659f, 0.17015110f, 0.07544324f, 0.19496801f, 0.07472175f, 
    0.04341708f, -0.14555489f, 0.02106064f, -0.50059223f, 0.33566108f, -0.07827973f, -0.09883798f, 0.03147393f, 
    -0.00304449f, 0.23619105f, 0.01439638f, -0.64816815f, 0.12204347f, 0.19289330f, 0.00205990f, 0.05099180f, 
    -0.14660886f, 0.18050167f, -0.15086851f, 0.00283972f, 0.00176865f, -0.03738176f, 0.01745576f, -0.38358614f, 
    0.03625851f, -0.12901095f, -0.05407340f, 0.14156842f, -0.07811932f, 0.51775283f, -0.12007361f, 0.18377078f, 
    -0.02194773f, 0.11430178f, 0.23604156f, 0.19861719f, 0.13158803f, 0.22793753f, -0.01585305f, 0.09695498f, 
    0.06866409f, 0.10452317f, 0.00733858f, 0.07734379f, 0.15070540f, -0.14472707f, -0.06276300f, 0.00345460f, 
    -0.16461304f, -0.19473493f, 0.07568404f, 0.18312220f, 0.21429321f, -0.06360170f, 0.03401684f, -0.08245765f, 
    0.38111758f, 0.12939911f, -0.27627131f, 0.05102633f, -0.23455261f, 0.11958025f, 0.03491474f, -0.06700118f, 
    -0.04833556f, -0.23542598f, 0.00155348f, 0.04224932f, 0.15688662f, 0.02935620f, 0.13859022f, 0.11874078f, 
    -0.08370229f, 0.11123407f, -0.11576460f, -0.19556631f, -0.09721962f, 0.07850421f, 0.17099173f, -0.01966333f, 
    0.16009158f, 0.00562899f, -0.24876955f, 0.11585419f, 0.00822041f, 0.09251668f, 0.14543046f, 0.13423491f, 
    -0.13509232f, 0.14333606f, -0.03295774f, 0.06507535f, -0.08438956f, -0.36406174f, -0.45001069f, -0.16401254f, 
    0.12681159f, -0.02338446f, -0.06076552f, 0.03960505f, -0.06261227f, -0.09516304f, 0.03363882f, 0.23749271f, 
    0.21077457f, 0.00281116f, -0.11158116f, -0.04445059f, 0.04520677f, 0.08804531f, -0.25598279f, 0.07510072f, 
    -0.23031805f, -0.01488188f, -0.03186676f, 0.16501395f, 0.03849083f, 0.18853943f, 0.01354432f, -1.03589451f, 
    -0.26883721f, -0.04642042f, 0.11105809f, 0.20362534f, -0.06832363f, -0.17061961f, -0.07162814f, -0.00543176f, 
    0.23431118f, -0.42846987f, -0.35667652f, -0.09585323f, -0.08813979f, -0.00812043f, 0.06278024f, 0.12149253f, 
    0.03860175f, 0.11502909f, 0.11055489f, 0.25635028f, -0.07565201f, -0.07971185f, -0.11683364f, -0.00386617f, 
    0.14796147f, 0.09879271f, -0.31089351f, -0.48766822f, -0.00875268f, -0.08199266f, 0.16952656f, -0.17214149f, 
    0.03704517f, 0.07485294f, 0.12703006f, -0.07039757f, 0.08840247f, -0.47548732f, 0.10482189f, -0.19755810f, 
    -0.05058963f, -0.00385272f, 0.00279101f, 0.15857838f, 0.11160914f, 0.33651915f, 0.03307920f, 0.19302377f, 
    -0.03626404f, 0.04941519f, 0.04093800f, -0.05337328f, 0.07127188f, -0.17295668f, 0.05456037f, 0.09017615f, 
    0.16392694f, -0.02203853f, 0.15234062f, -0.03287363f, 0.03022595f, 0.08181692f, 0.29808423f, -0.28668484f, 
    -0.16671778f, 0.12911290f, 0.01571650f, -0.04254348f, -0.18094823f, -0.25249213f, 0.00211564f, 0.02677294f, 
    0.00738813f, 0.15084308f, 0.12376348f, -0.11524176f, -0.08547572f, -0.06011329f, 0.04191245f, 0.13898893f, 
    -0.77961224f, 0.02919527f, -0.17156956f, 0.06219929f, 0.01825280f, 0.07066323f, -0.06095032f, 0.17185715f, 
    0.08105019f, -0.06757648f, -0.18459952f, 0.15424654f, 0.02240271f, -0.01755763f, 0.04282783f, -0.10314328f, 
    0.04989529f, 0.06568835f, -0.56420845f, 0.17150380f, -0.02216414f, 0.05529442f, 0.07915966f, -0.07773899f, 
    0.05864367f, 0.11497984f, 0.08838488f, -0.31697881f, -0.15058300f, 0.01241873f, 0.03528101f, -0.01561943f, 
    0.10087707f, -0.03405610f, 0.01671351f, -0.15519421f, 0.06698541f, 0.02776575f, 0.04372016f, -0.31014970f, 
    -0.10460376f, 0.09812469f, 0.14910632f, 0.01615565f, 0.08647879f, 0.57160580f, -0.05613054f, -0.30962971f, 
    0.03163416f, 0.21319415f, 0.05251076f, 0.08849343f, 0.01933450f, 0.06092689f, -0.20097645f, -0.09261005f, 
    -0.06688538f, 0.25400269f, 0.15176025f, 0.02211406f, 0.17140022f, -0.03995356f, -0.01231934f, -0.19684543f, 
    -0.12531424f, -0.29598176f, 0.02603444f, -0.18606545f, -0.02736252f, -0.08489467f, -0.02844317f, 0.05251435f, 
    -0.06859323f, 0.49457029f, -0.09465310f, 0.09602802f, -0.09208816f, 0.01293848f, -0.13852027f, -0.11676274f, 
    -0.15168865f, -0.19510895f, 0.26879179f, -0.05978536f, 0.07423226f, -0.09818260f, -0.03088424f, 0.04821167f, 
    0.00680933f, 0.01677294f, 0.10912031f, -0.07411663f, -0.55028117f, 0.04654298f, 0.00923538f, 0.00442362f, 
    -0.04119696f, -0.02791211f, 0.01720830f, -0.41060394f, -0.29410565f, 0.09541865f, 0.05533426f, 0.04221030f, 
    0.06528872f, -0.05503637f, -0.08212278f, 0.08283973f, -0.19260211f, -0.23005971f, 0.39482066f, 0.29499862f, 
    0.06074301f, -0.07530612f, 0.04142415f, 0.01137249f, 0.12973642f, -0.15190816f, 0.40959477f, -0.17986892f, 
    0.09172563f, -0.00310021f, -0.01216373f, -0.08897006f, -0.02857401f, 0.07873307f, 0.30515257f, -0.31643394f, 
    0.08638408f, -0.16755471f, 0.07970493f, 0.00097045f, -0.03859646f, -0.06185121f, 0.17284469f, -0.11553091f, 
    0.11324468f, 0.00683833f, 0.07382149f, 0.04759457f, 0.10174707f, -0.05730015f, 0.07413838f, -0.03254074f, 
    -0.22447227f, 0.24940088f, 0.03907127f, -0.19241211f, 0.03715666f, 0.04451739f, 0.18774554f, -0.11651164f, 
    0.03951574f, -0.06010858f, 0.42701837f, -0.01339653f, -0.04853552f, 0.01232883f, -0.23387799f, -0.01160730f, 
    -0.11554698f, -0.08637537f, 0.02557902f, 0.09323183f, -0.05123773f, 0.14569896f, -0.07282858f, 0.20689914f, 
    0.19618681f, 0.04784810f, 0.00311355f, 0.00094163f, 0.17492260f, 0.10095797f, -0.09490873f, 0.00614026f, 
    -0.19046225f, 0.03849709f, -0.04655837f, 0.04032975f, -0.06682649f, -0.06592260f, -0.27644283f, 0.13531061f, 
    -0.04010305f, 0.24210629f, -0.12450096f, 0.18997760f, -0.04096585f, 0.08206641f, 0.18562302f, -0.14991313f, 
    0.10083643f, 0.02158204f, -0.17092218f, 0.01230482f, -0.15557578f, 0.12837331f, -0.41208300f, -0.47148010f, 
    0.13632840f, 0.16128117f, -0.04142570f, -0.06551393f, 0.05347404f, -0.08280278f, -0.07158946f, -0.10922492f, 
    -0.20882763f, -0.17894703f, -0.02187969f, -0.08839834f, -0.00708432f, 0.06115158f, 0.02877910f, 0.14409889f, 
    -0.28290373f, 0.21670501f, -0.09622344f, -0.03145626f, -0.14761919f, 0.02203833f, 0.14529534f, -0.07563151f, 
    0.07409154f, 0.33241212f, 0.14757763f, 0.26386565f, -0.05800271f, 0.06431021f, 0.00485809f, -0.04465096f, 
    -0.01671530f, -0.05363051f, -0.22752336f, 0.00913903f, -0.39301133f, -0.14207299f, -0.17763527f, -0.29005510f, 
    -0.00002457f, -0.00795658f, 0.17775209f, -0.01563789f, -0.11440447f, 0.34173694f, -0.05243232f, 0.01813925f, 
    -0.04633651f, -0.06942143f, -0.00344011f, -0.01023737f, 0.32581621f, 0.18666902f, 0.67134666f, -0.14103414f, 
    -0.21837372f, 0.08313196f, -0.05150121f, 0.20594461f, 0.10918526f, 0.00549676f, -0.38041815f, 0.00957055f, 
    0.16678962f, 0.25646943f, 0.09606738f, -0.00993557f, -0.04320088f, -0.04043677f, -0.02494934f, 0.00256941f, 
    -0.15392449f, -0.00145356f, 0.04945846f, -0.08938323f, -0.21841690f, -0.16764785f, -0.06633822f, 0.02511226f, 
    0.00326973f, 0.04040994f, 0.08244567f, 0.13235679f, 0.05250933f, -0.02291456f, 0.11256079f, -0.01863460f, 
    -0.06856994f, -0.09223730f, 0.04464697f, -0.02645405f, 0.01838737f, -0.01311685f, -0.06242970f, -0.00582819f, 
    -0.00928066f, -0.00268120f, 0.04360704f, 0.06143849f, -0.08305874f, 0.04741551f, 0.00953228f, -0.04041122f, 
    -0.09515323f, -0.07922910f, 0.00409180f, -0.04648488f, 0.02694129f, -0.00180468f, 0.01311647f, -0.03526998f, 
    -0.09242281f, 0.05785863f, -0.02151719f, 0.02978553f, 0.04607628f, 0.01727940f, 0.01926921f, 0.01024521f, 
    -0.02548553f, -0.04543866f, -0.04618457f, 0.00203666f, -0.01731499f, 0.03990931f, 0.04054707f, -0.05881366f, 
    0.03564258f, 0.02699218f, -0.01563362f, 0.02081278f, 0.03601781f, -0.07397500f, -0.08874077f, 0.02564202f, 
    0.07756183f, 0.04177152f, 0.05927724f, 0.04184068f, -0.00792938f, -0.05575188f, -0.05843410f, -0.02983736f, 
    -0.04373140f, -0.03377262f, 0.01856434f, -0.01508181f, 0.04817934f, -0.03676840f, -0.10601848f, 0.02356008f, 
    -0.04176487f, -0.08705229f, -0.07013528f, -0.04606761f, -0.03240322f, 0.01298612f, 0.04121870f, 0.03701841f, 
    -0.06823681f, -0.03348543f, -0.05556714f, -0.06158900f, -0.01982971f, 0.00635810f, 0.00214910f, 0.01352708f, 
    0.00962403f, -0.08500741f, -0.03944174f, -0.03934752f, 0.02452399f, 0.04236908f, 0.05213092f, -0.03320996f, 
    0.06754480f, 0.06276929f, 0.03344196f, -0.02652935f, -0.02478521f, 0.04501688f, -0.06464189f, -0.01697211f, 
    0.03676117f, -0.09424049f, 0.00878536f, -0.01369823f, 0.02346279f, -0.06041138f, -0.00402578f, 0.04344041f, 
    0.01674464f, -0.07659023f, 0.03150118f, 0.03600399f, 0.00197939f, -0.02215940f, -0.06574918f, 0.05044162f, 
    0.06262992f, -0.05786243f, 0.03878083f, -0.01652738f, -0.00746089f, -0.05172545f, 0.04952444f, -0.04629862f, 
    0.05635017f, 0.04147897f, 0.01767244f, 0.01527574f, -0.08881138f, 0.01452015f, -0.00122504f, 0.02721809f, 
    -0.07136150f, -0.10363993f, 0.04096463f, -0.04338467f, -0.02594218f, -0.01210355f, -0.04382618f, -0.07586785f, 
    -0.01070632f, 0.01047952f, -0.07433322f, -0.09143499f, 0.02265686f, -0.08159698f, -0.06246766f, -0.09389111f, 
    0.06583349f, 0.05282860f, 0.06748805f, -0.08694266f, 0.01401050f, -0.06199439f, -0.00052032f, -0.07274892f, 
    0.05484470f, -0.07663381f, 0.00144129f, -0.06093347f, 0.03202636f, 0.00430796f, -0.07906843f, -0.00078186f, 
    0.06369485f, -0.04084871f, -0.03133782f, -0.07385796f, 0.05523974f, 0.04328199f, 0.03799942f, 0.06917017f, 
    -0.01173515f, -0.07024213f, -0.08088513f, 0.01813054f, 0.01245410f, 0.03173878f, 0.02263101f, -0.08768246f, 
    0.01543957f, 0.02969367f, 0.05427036f, 0.06352148f, -0.01562393f, 0.07054257f, -0.08562921f, -0.02464393f, 
    -0.07872535f, 0.00790101f, -0.08234508f, -0.00918326f, 0.05815271f, -0.00672604f, -0.01000000f, 0.04768709f, 
    0.06736601f, -0.01753264f, 0.02997213f, -0.08122702f, -0.06481005f, -0.05959313f, 0.02093356f, -0.07067292f, 
    0.03560103f, -0.08150724f, 0.07507825f, -0.02516953f, -0.08348328f, 0.03419718f, 0.01799700f, 0.03271291f, 
    0.03421945f, -0.01488020f, 0.06071027f, 0.01205933f, -0.03859482f, -0.03809016f, -0.07757341f, -0.01575419f, 
    0.05573301f, -0.01589729f, -0.05998984f, -0.02544691f, -0.03123320f, -0.02412682f, -0.07633802f, 0.08062293f, 
    0.05415854f, -0.05053226f, -0.01591516f, -0.01191498f, -0.07603335f, 0.06334575f, -0.00993389f, -0.06161427f, 
    0.05921812f, -0.00821461f, 0.06217452f, -0.05501293f, -0.04685535f, 0.04336014f, -0.02558408f, 0.02306609f, 
    -0.03252659f, -0.05982443f, -0.00772477f, -0.04870901f, -0.02777664f, -0.04452010f, 0.07044587f, -0.05883890f, 
    -0.06684576f, 0.04326221f, 0.00389860f, 0.07631797f, 0.04584798f, -0.09657679f, -0.07061528f, -0.07132736f, 
    0.06497722f, -0.02274808f, -0.04125389f, -0.04428336f, -0.08160594f, -0.06659207f, -0.01222903f, -0.06212113f, 
    -0.07783631f, -0.06641766f, -0.03508357f, 0.06628347f, 0.02962223f, -0.08280435f, 0.02840669f, -0.05936761f, 
    0.05945721f, 0.05639816f, -0.07261444f, -0.03227775f, 0.00298243f, -0.02373857f, 0.00954412f, 0.04721614f, 
    -0.07411733f, -0.03321179f, -0.02683958f, 0.04474434f, -0.05885615f, 0.06031409f, -0.03808909f, -0.07947926f, 
    -0.43264642f, 0.21898073f, -0.31811330f, 0.16803549f, 0.13283344f, 0.06475488f, 0.08626014f, 0.15923624f, 
    -0.19964533f, -0.54511493f, -0.31864390f, 0.15983409f, -0.04971734f, 0.08563361f, 0.14748977f, -0.00496758f, 
    0.02869407f, -0.04696602f, 0.65391934f, 0.29130378f, 0.18387038f, 0.14064461f, -0.00828344f, -0.09048350f, 
    0.13468297f, 0.03733211f, -0.05826013f, 0.42943749f, 0.32370526f, -0.37850800f, 0.20364048f, 0.15040529f, 
    0.06361779f, 0.00087652f, 0.06621639f, 0.12333232f, -0.02214745f, 0.12939112f, 0.10338264f, -0.28998122f, 
    -0.14823821f, -0.05753116f, -0.32136968f, 0.19191010f, 0.15114942f, -0.11076424f, -0.04445281f, -0.14822194f, 
    -0.22940829f, 0.19703688f, 0.15587245f, 0.12370808f, 0.12628773f, 0.13776864f, -0.33651894f, -0.22551216f, 
    0.08773041f, 0.07973030f, 0.04877032f, -0.16020547f, 0.07190850f, 0.13183804f, 0.13679738f, -0.25677818f, 
    -0.48709929f, 0.07888763f, 0.10009016f, 0.23887062f, -0.17455471f, -0.10027377f, -0.27547058f, -0.30777162f, 
    0.30679709f, 0.12597033f, -0.19886768f, -0.17833152f, 0.09035552f, -0.03855820f, -0.05753962f, -0.20207228f, 
    0.10527802f, -0.02449413f, 0.39414605f, 0.43484375f, -0.11909024f, 0.05552517f, -0.08089945f, -0.12911904f, 
    -0.01180740f, 0.14087866f, -0.27652529f, 0.13571988f, 0.02346594f, -0.27151588f, 0.09751222f, -0.19869526f, 
    0.02713976f, 0.42683163f, 0.18745752f, -0.32364988f, -0.00026662f, -0.17916848f, -0.20002808f, 0.09712018f, 
    -0.13334922f, 0.14604914f, -0.01782865f, -0.26861382f, 0.08907108f, 0.10825638f, -0.10777706f, 0.03748428f, 
    0.02822226f, -0.00770278f, 0.01004099f, 0.06449570f, 0.02035329f, 0.21426851f, 0.06168752f, -0.03132111f, 
    -0.18872678f, -0.10261075f, 0.04375806f, -0.06285960f, -0.10421699f, 0.09976752f, -0.16056487f, -0.17903754f, 
    0.10108273f, 0.17536531f, -0.03627673f, 0.09905522f, 0.01813595f, 0.11500079f, -0.16352871f, -0.03831165f, 
    -0.29779935f, 0.07990603f, -0.25784817f, -0.00564169f, -0.29477379f, 0.14939339f, -0.07986103f, 0.03763453f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06003856f, 0.05613550f, 0.02894339f, 0.20761052f, -0.00389162f, 0.04312744f, 0.09835724f, 0.03805229f, 
    0.31265783f, 0.31655115f, 0.18780711f, 0.05313805f, -0.05649918f, 0.06160458f, -0.06346181f, 0.12999147f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.32146853f, -0.04898812f, 0.28283674f, -0.26568693f, 0.50021464f, 0.27997258f, -0.33492637f, -0.35826421f, 
    0.14717293f, -0.14644858f, 0.16132666f, -0.66551095f, -0.14123866f, 0.09380252f, 0.05696440f, 0.25064051f, 
    -0.33752587f, 0.07212403f, -0.16057682f, 0.35105690f, -0.00909292f, 0.21804281f, 0.29718027f, -0.25322056f, 
    0.52853417f, 0.12362243f, -0.17466921f, -0.28219423f, -0.44596463f, -0.05231195f, -0.22615162f, 0.41217169f, 
    0.38545620f, -0.53324509f, 0.24616958f, 0.13374500f, -0.23358606f, -0.47969821f, -0.04053108f, 0.26497823f, 
    0.13800210f, 0.68254560f, -0.22087601f, 0.27723742f, 0.16674180f, -0.03576463f, -0.24177888f, 0.18423383f, 
    0.12236413f, 0.11257692f, 0.21039261f, 0.25197303f, 0.00602055f, 0.31648591f, -0.20236130f, -0.48096409f, 
    0.38359940f, -0.23331547f, 0.18646547f, -0.36152992f, 0.03535815f, -0.21214005f, 0.00152982f, 0.15410917f, 
    -0.14965490f, 0.45782858f, 0.30064085f, -0.10594960f, -0.16297461f, 0.65142447f, 0.00371397f, -0.23256329f, 
    -0.07079545f, -0.70805514f, 0.21282464f, -0.35123727f, 0.33292133f, 0.23075168f, -0.12551601f, 0.33781558f, 
    0.51357788f, 0.41954261f, -0.01579021f, -0.43430373f, -0.44586226f, 0.67710841f, -0.15981975f, -0.09916224f, 
    -0.10936717f, -0.01465773f, -0.50349712f, -0.01863353f, -0.18158737f, 0.22007999f, 0.16988403f, 0.05056183f, 
    0.20203042f, 0.10200561f, 0.01012777f, 0.40111649f, 0.08003646f, 0.02748502f, -0.20674419f, -0.22657189f, 
    0.66909283f, 0.39889777f, 0.76042241f, -0.47805756f, -0.32900828f, -0.06055775f, 0.08484582f, -0.11840947f, 
    -0.36928901f, -0.47341520f, -0.09692705f, 0.50922799f, 0.08825756f, 0.29684666f, -0.06281482f, -0.21352033f, 
    0.47096711f, 0.07255925f, 0.02986247f, 0.57149231f, -0.21752301f, -0.09763274f, 0.07029703f, 0.02622687f, 
    0.11665804f, -0.04790419f, 0.31245822f, 0.01595165f, 0.19639838f, -0.35708043f, -0.28461146f, -0.29313463f, 
    -0.09384796f, 0.34361479f, 0.06661905f, -0.35884270f, 0.01665199f, -0.01269654f, 0.08501587f, 0.21205261f, 
    -0.19088036f, 0.36737785f, -0.20859125f, -0.01953225f, 0.43657067f, 0.17790191f, -0.37785006f, 0.40895107f, 
    -0.09572127f, -0.24101450f, 0.32646078f, 0.15757820f, -0.13365133f, 0.02833012f, 0.20647630f, 0.25005096f, 
    0.33334348f, -0.03572074f, -0.24780132f, 0.11569681f, -0.47307783f, -0.02155259f, 0.11286179f, -0.56731075f, 
    0.06472512f, -1.20783854f, -0.01240826f, -0.16812024f, 0.42577657f, 0.15285869f, -0.02259559f, 0.10998514f, 
    -0.26808792f, -0.14570577f, 0.08637441f, 0.03454695f, -0.14921635f, 0.09924791f, -0.02707900f, -0.15710792f, 
    -0.18302813f, -0.19371870f, 0.11409619f, -0.12322622f, -0.24773353f, 0.13736886f, -0.15419549f, -0.05809456f, 
    -0.05581459f, -0.15866958f, -0.09301580f, 0.44447175f, -0.45689765f, 0.10183293f, 0.01570930f, 0.44838321f, 
    -0.25115582f, -0.36404166f, 0.72816902f, -0.54025096f, 0.01632441f, -0.20888698f, -0.22898598f, -0.09603411f, 
    0.11647668f, -0.32716072f, 0.25035688f, 0.67770511f, 0.09638738f, 0.00897343f, 0.23113361f, -0.54731977f, 
    0.03393690f, -0.16731609f, 0.36500683f, 0.69156682f, 0.38006216f, -0.11927400f, -0.15614283f, -0.39840719f, 
    -0.19263017f, -0.20326701f, -0.11264098f, -0.23526499f, -0.21009994f, -0.16140705f, 0.17938474f, -0.11436892f, 
    -0.17281961f, 0.24102905f, -0.23720363f, 0.03114763f, -0.11043778f, -0.00590912f, 0.18202344f, -0.20750043f, 
    0.35080811f, 0.34269705f, 0.27648738f, -0.18419829f, 0.39814731f, 0.30264339f, -0.06228483f, 0.34761509f, 
    -0.29919672f, 0.09120960f, -0.41548491f, 0.41738272f, -0.02072660f, 0.22711265f, -0.14943698f, -0.18682158f, 
    0.29796311f, -0.26510003f, 0.06204144f, -0.29139969f, 0.28057826f, 0.22719972f, -0.04991608f, 0.37048900f, 
    0.39491516f, -0.02348485f, -0.06750859f, -0.60231614f, 0.59900832f, -0.20597436f, 0.04296257f, 0.15386884f, 
    0.10358821f, 0.52437437f, 0.10538875f, -0.22829132f, -0.74636179f, 0.17912680f, 0.39750919f, -0.03904967f, 
    0.11251563f, -0.06098363f, -0.55568999f, 0.25163230f, -0.23349206f, -0.04098707f, -0.12282449f, 0.84540147f, 
    0.00617554f, 0.05752330f, -0.26011443f, 0.46401700f, -0.36913836f, -0.03338212f, 0.55828613f, 0.58310932f, 
    0.23388778f, 0.30482775f, -0.48033696f, 0.72080517f, -0.23995437f, 0.15229586f, 0.10031881f, -0.29998702f, 
    -0.31963485f, 0.26068366f, 0.36612496f, 0.16843608f, 0.05225342f, 0.10451767f, -0.19279538f, -0.42746472f, 
    -0.28086758f, 0.12475235f, 0.31918746f, 0.12329771f, 0.18193449f, -0.02563786f, -0.12857512f, 0.47937793f, 
    -0.14241475f, 0.13837679f, 0.03500289f, -0.44787839f, 0.05839238f, 0.06134416f, 0.53445679f, 0.23349029f, 
    0.42733645f, 0.08185592f, -0.08404907f, -0.61808866f, -0.10845326f, 0.07444339f, 0.06010928f, 0.39726114f, 
    0.27792060f, -0.09470244f, -0.17336264f, -0.00562949f, -0.10156405f, -0.22410779f, 0.20538850f, 0.21423885f, 
    -0.20633647f, -0.02382239f, 0.06032576f, 0.25490984f, 0.26883316f, -0.18625163f, -0.12480381f, -0.14140819f, 
    -0.12424774f, -0.13455616f, -0.11719069f, -0.03751524f, 0.18979871f, 0.27513453f, 0.12067585f, -0.23580226f, 
    0.12550341f, 0.11031859f, 0.17924166f, 0.44883633f, -0.13304017f, -0.19709507f, -0.01489067f, -0.27402017f, 
    0.38689631f, 0.52192312f, -0.13566354f, -0.10616321f, -0.05894042f, 0.29088631f, 0.53931093f, 0.20052205f, 
    0.09099555f, -0.14774059f, -0.50203663f, 0.55434150f, -0.47754323f, -0.14876105f, 0.12901038f, -0.11871247f, 
    0.35921395f, -0.31244457f, -0.28542304f, 0.46922204f, 0.34267306f, -0.37455943f, 0.40084237f, 0.19656150f, 
    0.57091498f, 0.43156266f, -0.11170454f, -0.42583668f, -0.27767015f, -0.14801331f, -0.21104111f, -0.00528682f, 
    0.26125962f, -0.30723980f, -0.01337144f, 0.56824368f, -0.13692851f, 0.26885471f, -0.28849503f, -0.27062654f, 
    -0.01828259f, 0.04852700f, -0.26316833f, 0.56124550f, 0.10527755f, 0.04941196f, 0.10812849f, 0.28328207f, 
    -0.28367615f, -0.23397030f, 0.08751842f, -0.00970707f, 0.37220562f, -0.49048951f, -0.22767062f, 0.30505392f, 
    0.05954339f, 0.54451764f, 0.18923514f, 0.19299640f, -0.13674052f, -0.19820516f, 0.21978965f, 0.45612258f, 
    -0.22384363f, -0.02783226f, 0.01441966f, -0.19151008f, 0.75726920f, -0.24186842f, -0.27202365f, 0.17001605f, 
    0.29135025f, 0.27802694f, -0.16419353f, -0.52050400f, -0.08043238f, -0.00466532f, -0.03970620f, 0.25570813f, 
    -0.20404580f, 0.70173532f, 0.04776607f, 0.32618496f, -0.51434708f, 0.59648353f, 0.29236552f, -0.11565489f, 
    -0.05048111f, -0.48739305f, -0.04166275f, 0.43619922f, 0.44894645f, 0.11078229f, -0.17063676f, 0.00059485f, 
    -0.21757165f, 0.26810715f, 0.10591038f, -0.09594231f, 0.09686985f, 0.27577734f, -0.05261465f, -0.44053671f, 
    0.00926460f, 0.03617973f, 0.54996735f, 0.54394901f, 0.24922684f, 0.02984540f, -0.11466288f, -0.28109667f, 
    0.43236649f, 0.66523397f, 0.21877640f, 0.10385413f, -0.36632648f, 0.16789873f, 0.30355582f, -0.24035081f, 
    0.11533505f, 0.14666437f, -0.17241846f, 0.48727116f, -0.50333428f, -0.14999504f, -0.14035136f, -0.52223867f, 
    -0.17134260f, 0.37788492f, 0.16128780f, -0.18659765f, -0.21062036f, 0.26127985f, 0.47618720f, -0.29687828f, 
    -0.14137349f, -0.05956080f, -0.52274829f, 0.69490314f, -0.30606830f, -0.13321277f, 0.19410990f, 0.41918230f, 
    -0.33855283f, 0.35196498f, 0.25551021f, 0.13652042f, 0.25464469f, -0.37411398f, -0.04251316f, 0.04766658f, 
    0.10457126f, 0.62993449f, -0.16390698f, -0.12314577f, -0.28621265f, -0.17852338f, 0.21834329f, -0.26161504f, 
    -0.95465416f, 0.30899459f, 0.11637710f, -0.16948374f, 0.21130629f, -0.08938721f, -0.56220722f, 0.25258291f, 
    0.12238718f, 0.13113844f, 0.05738667f, -0.14916873f, -0.06366572f, 0.10992528f, -0.16522758f, 0.20588554f, 
    -0.21647885f, 0.11743037f, 0.11726143f, -0.31400409f, 0.54246151f, 0.12076375f, -0.28836995f, 0.40759435f, 
    -0.20287430f, -0.36074883f, 0.09648295f, 0.42819920f, 0.06017531f, 0.01983450f, 0.22264498f, 0.02925348f, 
    0.42959684f, -0.30458030f, 0.09040058f, 0.19647361f, -0.28838810f, 0.17078015f, -0.08102296f, -0.00199681f, 
    -0.06048378f, -0.41971964f, 0.32384315f, -0.01632517f, 0.36408487f, -0.04801921f, 0.09103770f, 0.51911193f, 
    0.44876465f, -0.37067050f, -0.18445019f, 0.36854956f, -0.00622817f, 0.18786892f, -0.08620474f, 0.15097664f, 
    0.34158504f, 0.33609274f, -0.42837885f, -0.70451242f, -0.24419637f, 0.23996589f, 0.00569305f, 0.04065245f, 
    0.17126243f, -0.22341183f, 0.29889786f, -0.09816516f, 0.03553614f, -0.14015511f, -0.09343220f, 0.23970957f, 
    -0.21565464f, -0.05369771f, 0.87970740f, -0.42107275f, 0.27681047f, -0.09160349f, 0.18009621f, 0.44953725f, 
    0.17574354f, 0.28707570f, -0.02058319f, 0.06300439f, -0.06950534f, 0.29226726f, -0.20557134f, 0.02050448f, 
    0.32733360f, -0.00002877f, -0.58649993f, 0.74999100f, -0.49391887f, 0.09200685f, -0.01508255f, 0.41850644f, 
    0.47338969f, 0.11860197f, 0.33312216f, -0.23895723f, -0.52273750f, 0.08305543f, 0.44130599f, -0.08735674f, 
    0.18431808f, 0.16813765f, -0.27199513f, -0.07783351f, -0.21124230f, -0.06385863f, -0.16694556f, 0.18688063f, 
    0.34072670f, 0.69358063f, 0.31644577f, 0.06791637f, 0.12374020f, 0.04497302f, -0.15520804f, 0.13764742f, 
    -0.34018716f, 0.32379675f, -0.13169709f, -0.08625145f, -0.03989627f, -0.15258002f, 0.01616735f, -0.28166676f, 
    -0.06751347f, 0.17843556f, 0.13482870f, 0.20206355f, -0.17996633f, -0.42716318f, 0.37358516f, 0.40446132f, 
    0.28572893f, 0.55016589f, -0.58724022f, -0.09852465f, 0.16446058f, -0.11910486f, -0.13689588f, -0.46603194f, 
    0.40975639f, 0.35191664f, -0.14449759f, -0.09877548f, -0.13680500f, 0.21619909f, 0.34867531f, 0.16314970f, 
    0.38568929f, -0.26004705f, -0.49636811f, 0.27280664f, -0.60881877f, 0.08528990f, 0.05862340f, 0.48421115f, 
    0.36986661f, -0.27283379f, 0.27854529f, -0.39504880f, 0.04070552f, 0.25960791f, -0.18430337f, 0.24999078f, 
    -0.45073131f, -0.02002842f, -0.39826980f, -0.04378400f, 0.68878746f, -0.02818499f, -0.21618260f, 0.29598045f, 
    -0.01009473f, -0.05449608f, -0.33638495f, 0.67012167f, 0.24274085f, 0.09449681f, 0.37778082f, -0.09284643f, 
    -0.00595325f, -0.60884881f, 0.08950333f, -0.30325118f, -0.02107200f, -0.20172183f, -0.25149381f, 0.19278662f, 
    -0.15986355f, -0.04985088f, 0.34106776f, -0.09827792f, 0.41589338f, -0.29406467f, -0.18196219f, 0.23039497f, 
    -0.24447343f, 0.42553681f, 0.73027092f, 0.14486748f, -0.01953986f, -0.17080510f, 0.04445158f, 0.09094153f, 
    0.00863195f, 0.43250674f, 0.04777223f, -0.45247924f, 0.31786326f, 0.05854956f, 0.08474532f, 0.42002916f, 
    0.42932531f, 0.22935121f, -0.15655041f, -0.38523033f, -0.14925517f, -0.09530459f, 0.11546092f, -0.55083919f, 
    -0.01337880f, 0.42076644f, 0.05084874f, -0.31561059f, 0.19587635f, 0.50705010f, -0.32113534f, -0.66016555f, 
    0.46523780f, -0.00078855f, 0.59255165f, -0.54725176f, -0.17119892f, -0.18581443f, -0.20364189f, 0.24846281f, 
    -0.11450104f, -0.03329625f, 0.18477878f, -0.36030751f, -0.28056195f, -0.45291778f, 0.23662207f, 0.41617990f, 
    -0.04829575f, -0.02177571f, 0.68053657f, 0.31680000f, 0.24512395f, 0.16392507f, -0.22107790f, 0.21451159f, 
    -0.22837178f, -0.27136111f, 0.11746452f, 0.05290246f, 0.16022874f, -0.30471200f, 0.55523938f, -0.05461008f, 
    0.53510004f, 0.23928848f, -0.20143932f, 0.34440210f, 0.36343652f, -0.15882002f, -0.21679702f, -0.54061723f, 
    0.21554799f, 0.27865610f, 0.28485826f, 0.02684486f, -0.41038468f, 0.11005135f, 0.15770157f, 0.23497324f, 
    -0.25447205f, 0.17433728f, -0.60422218f, 0.76353550f, -0.57093084f, -0.05357193f, 0.06267622f, -0.17671676f, 
    -0.12602434f, -0.51831442f, -0.01741008f, 0.25896952f, 0.25958496f, -0.31574142f, 0.12795258f, -0.17813055f, 
    0.62346822f, 0.25371248f, 0.11028357f, 0.62963599f, -0.46180573f, 0.17078300f, 0.05506493f, -0.18453683f, 
    -0.84188622f, 0.28879774f, 0.28825888f, -0.42310888f, -0.15880024f, 0.09153258f, -0.01267899f, -0.13181676f, 
    0.56116164f, 0.20325936f, -0.27389789f, 0.28603858f, -0.59253162f, 0.16270450f, -0.17064950f, -0.06795676f, 
    0.24225771f, -0.25986168f, -0.10922336f, -0.04881524f, 0.47115299f, 0.16569349f, 0.12045581f, 0.09368671f, 
    0.45043987f, -0.04974096f, 0.80728674f, -0.40395215f, 0.33706802f, -0.05277870f, -0.05630215f, -0.25593999f, 
    0.41326669f, -0.17396042f, 0.32720715f, -0.33086318f, 0.31765869f, 0.47527671f, -0.36034065f, -0.53429395f, 
    0.24723925f, -0.08612838f, 0.15309267f, 0.30883664f, 0.09358514f, -0.18427613f, 0.23484421f, -0.25748172f, 
    -0.23354234f, -0.22343057f, -0.17840788f, -0.18029054f, 0.12676273f, -0.09902977f, 0.19364250f, 0.29895893f, 
    0.02931947f, 0.12077069f, -0.27907735f, 0.91432065f, 0.23167598f, -0.23877141f, -0.09682707f, 0.54476011f, 
    -0.18329123f, -0.23740113f, -0.15466291f, -0.27724963f, -0.14429086f, -0.21633677f, -0.04583240f, 0.03955787f, 
    -0.19972412f, -0.14475915f, -0.13979739f, -0.09813833f, 0.14308460f, -0.21670979f, 0.09822744f, 0.14706224f, 
    0.00647658f, -0.23805228f, -0.09286496f, -0.18287349f, -0.24066871f, -0.10280389f, -0.18229076f, -0.16063765f, 
    0.01617396f, 0.22196805f, -0.24295616f, -0.14700434f, -0.00805026f, -0.15801194f, -0.03088239f, -0.03798836f, 
    0.80026144f, 0.13284020f, 0.16657275f, -0.12870206f, -0.22588608f, 0.24408983f, -0.01784225f, -0.03021538f, 
    -0.19460638f, -0.01632871f, -0.20564361f, 0.26943326f, -0.10511618f, 0.08876357f, -0.18833892f, -0.15161747f, 
    -0.29944426f, 0.39216515f, -0.35196474f, -0.03074520f, -0.33222553f, 0.10414807f, -0.36001605f, -0.00449954f, 
    0.44399697f, -0.51847732f, 0.02545187f, -0.47377440f, 0.40629801f, 0.23119541f, -0.05731360f, 0.10185719f, 
    0.49633607f, 0.63484347f, 0.24382363f, 0.07180493f, -0.54273659f, 0.08996806f, 0.24598368f, 0.34237593f, 
    -0.25377938f, -0.05016590f, -0.53151196f, 0.09159990f, -0.57626617f, 0.09593654f, -0.02103769f, 0.03738920f, 
    -0.51282132f, 0.29458216f, 0.27716917f, -0.45480400f, 0.26049024f, 0.25954127f, -0.09226080f, -0.08871550f, 
    -0.19545031f, -0.24978434f, -0.31733215f, 0.22995102f, 0.39982665f, -0.24758956f, 0.18406738f, 0.53708774f, 
    -0.02839537f, -0.25344610f, 0.25741071f, 0.09116443f, -0.08280407f, 0.19226965f, -0.00528128f, -0.31943846f, 
    -0.00882972f, -0.00799993f, 0.22672276f, 0.49549717f, -0.10857929f, -0.11184505f, -0.04642033f, 0.41175362f, 
    0.49686989f, 0.40090439f, 0.43977353f, -0.45410842f, -0.33586746f, 0.03960944f, 0.24140136f, 0.03286540f, 
    -0.31946555f, -0.13245171f, 0.17518398f, -0.11069846f, -0.19267145f, -0.17551647f, -0.02984548f, 0.01436085f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21853375f, 0.60841638f, 0.16633047f, 0.33651617f, 0.17290269f, -0.02472163f, 0.80822653f, 0.06182107f, 
    0.42905524f, -0.21687220f, -0.08748192f, -0.19817093f, -0.26372200f, -0.09949873f, 0.04099107f, 0.12156228f, 
    0.13657735f, 0.22655195f, 0.32462046f, 0.15133646f, 0.27460593f, 0.04818238f, -0.08869639f, -0.23355606f, 
    0.17760026f, -0.19764307f, -0.01168261f, -0.18506356f, 0.03716355f, 0.31950906f, -0.07051562f, 0.37205666f, 
    0.24618554f, 0.17921394f, -0.43577209f, -0.37737525f, 0.22935580f, -0.06012918f, 0.46560150f, 0.18376370f, 
    0.14695530f, -0.06473322f, 0.51239085f, -0.40584496f, 0.35194138f, 0.21034935f, 0.25627202f, -0.05910842f, 
    -0.21393271f, -0.06691802f, 0.08819997f, -0.30526599f, -0.03371918f, 0.11069772f, -0.11294039f, 0.04668581f, 
    -0.23822397f, 0.02182215f, -0.07589492f, 0.02328354f, 0.13312322f, 0.06971002f, 0.06844895f, 0.29494417f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.20874959f, 0.24262975f, 0.00818076f, 0.04913636f, 0.13733125f, -1.30811417f, -0.24836801f, 0.02076046f, 
    0.11328061f, 0.01395241f, -0.45592391f, 0.09345365f, -0.73652756f, -0.34752813f, 0.00078550f, -0.19870366f, 
    0.17811435f, 0.41241637f, -0.11781179f, 0.18045163f, 0.22050808f, 0.12997921f, -0.24468169f, -0.25488961f, 
    -0.28637940f, 0.05830099f, 0.04061844f, 0.14785865f, -0.19004755f, -0.04607503f, -0.58305055f, 0.32770792f, 
    -0.34246871f, -0.02059721f, -0.56785351f, 0.04726471f, -0.02820681f, 0.14767975f, 0.13532467f, 0.13215996f, 
    -0.40879345f, -0.19320016f, 0.24632201f, 0.07538907f, 0.08625425f, -0.01033640f, -0.14674702f, 0.08283696f, 
    0.08424260f, -0.47742316f, -0.14624618f, -0.68184358f, -0.44633743f, -0.13332142f, -0.22678782f, 0.40574849f, 
    -0.05970486f, -0.09969838f, -0.44088459f, 0.57104439f, -0.28678918f, 0.42931926f, 0.20952757f, 0.02045994f, 
    0.66105330f, -0.04517435f, -0.06075886f, 0.17821716f, 0.18413347f, -0.00132242f, -0.02275193f, -0.29538551f, 
    0.12090616f, -0.22089268f, -0.19041610f, 0.07621331f, -0.32639411f, -0.06953809f, 0.00764443f, 0.06998947f, 
    0.10627357f, 0.04774126f, -0.82839483f, 0.01037576f, 0.06453349f, -0.03732229f, 0.20308568f, 0.04809121f, 
    -0.08247833f, -0.08528073f, -0.12148742f, -0.03401041f, -0.02618519f, -0.09045049f, -0.06745838f, -0.11642663f, 
    -0.33359420f, -0.62119693f, 0.14188866f, 0.16925341f, -0.18947050f, 0.13800110f, -0.01117827f, 0.10702381f, 
    -0.04543738f, -0.51697558f, 0.00211370f, 0.22901256f, -0.16032100f, 0.00136209f, -0.04842794f, 0.42123199f, 
    0.01033421f, 0.10470971f, -0.86527562f, -0.36440530f, -1.35757518f, 0.16827852f, 0.34914008f, -0.08495875f, 
    -0.05093636f, 0.01273656f, 0.13256234f, 0.24307576f, -0.06095746f, 0.15658908f, 0.04443309f, 0.21219128f, 
    -0.30680639f, 0.40040895f, -0.15140498f, 0.27548456f, 0.11802591f, -0.77691156f, -0.02988944f, 0.40591961f, 
    -0.46445212f, -0.14682697f, 0.63353842f, 0.10019421f, 0.05758725f, 0.20028929f, 0.08740273f, -0.42960438f, 
    -0.02159045f, 0.10961410f, 0.36757690f, -0.41639215f, -0.02765339f, -0.21653108f, -0.10843166f, 0.09665117f, 
    0.42891964f, 0.29235440f, -0.85859811f, -1.03859746f, 0.15304504f, -0.23274179f, 0.00473700f, -0.13786499f, 
    -0.50848579f, -1.14406145f, 0.10239972f, 0.23603249f, 0.33161819f, -0.33385453f, 0.04552252f, 0.14960580f, 
    -0.50996077f, -0.02575791f, 0.15973260f, 0.20808387f, 0.49613211f, -0.77187705f, -0.51245588f, -0.43476582f, 
    -0.35676077f, 0.36038318f, -0.37247610f, 0.63547415f, 0.17217954f, 0.09206797f, -0.20215516f, -0.28516051f, 
    -0.10158686f, 0.07766050f, -0.04835328f, -0.27263346f, -0.08280428f, -0.32698160f, 0.15087333f, -0.39062020f, 
    -0.45271081f, 0.05241058f, -0.05734733f, -0.46149752f, -0.66705042f, -0.34098181f, 0.00732282f, 0.26507214f, 
    -0.45192686f, 0.47807088f, 0.05183774f, -0.04401420f, 0.25673479f, -0.31557491f, 0.03469801f, 0.09673975f, 
    0.13554910f, -0.78113943f, 0.58115977f, -0.67735189f, 0.16089216f, -0.05823147f, -0.14116602f, 0.27164242f, 
    0.32316878f, 0.03004498f, 0.23877320f, 0.11911722f, -0.52797860f, -0.29738352f, -0.13417763f, -0.42575052f, 
    0.03445313f, 0.05464269f, 0.03265948f, -0.42661223f, 0.19300318f, -0.11512429f, -0.06855363f, -0.30409247f, 
    -0.21688798f, 0.13225929f, 0.21486379f, -0.62857932f, 0.31489509f, 0.05331520f, 0.28867605f, -0.21240865f, 
    0.24160086f, 0.26683906f, -0.06357429f, 0.16636847f, -0.15240900f, 0.27060544f, -0.81850970f, 0.37710828f, 
    0.12013808f, -0.01158020f, -0.36651731f, -0.57049364f, -0.21642706f, -0.25433969f, -0.23230724f, -0.64141256f, 
    -0.51526308f, 0.18838769f, -0.26603493f, 0.02442823f, 0.00913949f, -1.17719305f, 0.03363369f, -0.13914290f, 
    -0.09288074f, -0.08711242f, -0.43185648f, -0.07219525f, 0.94991326f, 0.16949868f, 0.00309704f, -0.11498246f, 
    -0.25049263f, 0.01473867f, 0.18085736f, 0.06496549f, 0.02795631f, -0.23048320f, -0.15979920f, 0.17158096f, 
    -0.26848164f, -0.67834193f, -0.18221226f, 0.02562325f, 0.17569071f, 0.20894577f, 0.27094018f, 0.31315905f, 
    0.21243739f, 0.39005136f, -0.09064367f, -0.49012122f, -0.65827721f, -0.18292582f, -0.02441987f, 0.05896496f, 
    0.05527602f, 0.08791558f, -0.04597402f, -0.43824553f, 0.45479724f, -0.02774364f, 0.21692349f, -0.02359609f, 
    0.17107522f, 0.23871747f, 0.03635955f, -0.77771705f, 0.60173917f, 0.06164738f, -0.24713720f, 0.04894457f, 
    -0.11352485f, -0.10033970f, -0.21039946f, -0.40154955f, -0.05601620f, 0.19181906f, -0.10742062f, 0.00949359f, 
    0.13133144f, -0.05108704f, -0.52388805f, 0.04999558f, 0.28067216f, 0.27048540f, 0.03516946f, 0.04713673f, 
    0.21857812f, 0.27898467f, -0.73165643f, 0.03512711f, -0.36232966f, -0.04974460f, -0.03368963f, 0.15239090f, 
    -0.19563945f, -0.06547410f, -0.59412247f, 0.31543863f, -0.18521142f, 0.10953949f, -0.03967809f, 0.01855953f, 
    -0.68827826f, 0.20976016f, -0.02062524f, 0.11751156f, 0.12070823f, 0.05161820f, 0.11607473f, 0.23641975f, 
    0.02796699f, 0.41308659f, 0.35843199f, -0.12059261f, -0.22611749f, -0.00543527f, 0.13880682f, -0.13338329f, 
    0.25624564f, -0.57982707f, 0.03052587f, -0.34367058f, -0.51459086f, 0.07120929f, -0.12076636f, 0.19632456f, 
    -0.27505252f, -0.74790883f, 0.12581608f, -0.07615532f, 0.01579135f, -0.11430553f, 0.01019270f, -0.66718417f, 
    0.07728571f, 0.06284778f, 0.07050426f, -0.92465132f, 0.17526115f, 0.29242316f, 0.04734549f, 0.05560006f, 
    -0.07377587f, 0.02324281f, -0.22235160f, -0.10612463f, 0.07955633f, 0.51485896f, -0.24955870f, -0.57031965f, 
    -0.30081472f, -0.34439182f, -1.42050266f, -0.05297546f, -0.16403313f, -0.49239630f, 0.09923767f, 0.28552061f, 
    0.18775561f, 0.28525132f, 0.18644284f, -0.45340705f, 0.07735164f, 0.06629239f, -0.03198318f, 0.35772759f, 
    -0.17914787f, -0.21921733f, -0.57894641f, -0.47768185f, 0.09863854f, -0.17054003f, 0.20039971f, 0.16834944f, 
    -0.08956410f, -0.58223814f, -0.10123518f, -0.38139689f, 0.43927896f, -0.55548823f, 0.20173877f, 0.18315223f, 
    0.20255968f, 0.12064754f, 0.25332350f, 0.03843912f, -0.67852366f, -0.37979347f, 0.27908292f, -0.06603768f, 
    -0.21498109f, -0.41764978f, 0.41968998f, -1.57407546f, -0.41365269f, -0.18081963f, -0.11176417f, -0.26238188f, 
    -0.12474832f, 0.05276629f, 0.28867143f, 0.20653225f, 0.42011455f, -0.09317078f, -0.30329418f, 0.22044304f, 
    0.14180806f, -0.53320438f, -0.02827949f, -0.34936056f, 0.29035360f, 0.43709728f, -0.81955546f, -0.61164778f, 
    -0.02373317f, -0.20828125f, -0.62457711f, 0.04553736f, -0.10850324f, -0.15171534f, 0.02145158f, 0.11814971f, 
    0.31876230f, 0.29502967f, -0.39154172f, 0.11699433f, -0.02141814f, -0.12038857f, -0.20319510f, -0.59192067f, 
    -0.07659100f, -0.11182540f, 0.09070623f, 0.17374091f, 0.53257513f, -0.20653711f, -0.67267042f, -0.14899442f, 
    0.15830933f, 0.04803805f, 0.00814346f, 0.41032660f, 0.07663744f, 0.22697020f, -1.39076567f, -0.36893612f, 
    0.01265774f, 0.28248078f, -0.97102314f, 0.53219742f, 0.09508414f, 0.15059794f, 0.09329379f, -0.31943959f, 
    0.08418223f, 0.22556417f, -0.10900152f, 0.12278225f, 0.30082452f, 0.05741233f, -0.38938642f, 0.19143270f, 
    -0.09422980f, -0.11818442f, -0.53209764f, -0.26517600f, -0.49689472f, 0.33536842f, -0.32916394f, -0.47891864f, 
    -0.02915085f, -0.92053902f, 0.03036821f, 0.13439938f, 0.08542451f, -0.20641641f, -0.13361961f, -0.23345654f, 
    -0.17538778f, 0.22361688f, 0.14318560f, -0.04005399f, 0.43938205f, 0.42757595f, -0.07574962f, 0.04065555f, 
    0.12745905f, -1.04739010f, -0.28656876f, 0.07661659f, -0.71733046f, 0.19789289f, -0.19458389f, -0.36259097f, 
    -0.68950194f, 0.12310067f, -0.22435810f, -0.59924722f, 0.11900882f, 0.22962496f, -0.17163610f, -0.99769485f, 
    -0.59963310f, 0.02674749f, 0.42250571f, 0.33121642f, -0.21029739f, 0.40790924f, -0.21777999f, -0.14604011f, 
    -0.03369809f, -0.30252802f, -0.65871102f, 0.57845449f, -0.11751204f, 0.09142354f, -0.16216435f, 0.04424183f, 
    0.18170488f, -0.13403147f, 0.00928125f, 0.85444134f, 0.18278764f, 0.32609063f, 0.47342157f, -0.13494766f, 
    0.08825976f, 0.09481665f, 0.36878234f, 0.23545076f, -0.46227413f, -0.12620044f, 0.09442034f, 0.11625210f, 
    -0.58219266f, -0.22453257f, 0.10586616f, -0.23966563f, -0.12916026f, -0.28451025f, -0.73535258f, 0.12954697f, 
    -0.14263786f, 0.14370476f, 0.27177301f, 0.10713679f, -0.20615366f, 0.32075480f, -0.01619518f, 0.22147919f, 
    -0.50883615f, 0.28921846f, 0.26107609f, 0.14342394f, -0.31271896f, 0.00409045f, 0.36434415f, 0.26137617f, 
    -0.42178494f, 0.30198005f, 0.11936568f, -0.03642196f, 0.11776212f, 0.04998199f, 0.19478530f, 0.42503530f, 
    -0.10924234f, 0.15928274f, 0.22291513f, 0.01012238f, -0.03846337f, -0.43869346f, 0.23890005f, 0.07097417f, 
    -0.05549023f, -0.12116265f, 0.05487511f, 0.33691207f, -0.04168598f, -0.08314114f, -0.35902911f, -0.82109439f, 
    -0.04747589f, -0.14788693f, 0.47303981f, 0.05838435f, -0.02197887f, -0.49713972f, -0.00333460f, 0.36978406f, 
    -0.09879566f, 0.10348935f, 0.25801593f, 0.58105528f, 0.18961370f, 0.15884353f, 0.21409330f, -0.05489279f, 
    0.29446039f, 0.23198891f, 0.21070437f, 0.20788260f, -0.61617619f, -0.22811207f, 0.54586214f, 0.47696885f, 
    0.32800394f, -0.51632607f, -0.68931323f, -0.09185759f, -0.83075434f, 0.18695717f, -0.09746209f, -0.04512613f, 
    0.18004663f, -1.07986367f, -0.18734051f, -0.25503922f, -0.09230847f, -0.13890441f, 0.36206794f, -0.43596411f, 
    0.39818519f, 0.06331293f, 0.03044423f, 0.13881068f, -0.71916515f, 0.13147998f, -0.01605206f, -0.57428360f, 
    0.15607516f, -0.01849687f, -0.81926745f, -0.45292139f, 0.22208306f, -0.37770638f, 0.00982030f, -0.19963010f, 
    -0.05822934f, 0.04538666f, -0.20163491f, -1.11413205f, -0.41037914f, 0.02086732f, 0.09693146f, 0.43673956f, 
    -0.47084266f, 0.28474727f, -0.68710709f, 0.46743140f, -0.06703232f, 0.18112190f, 0.58550525f, -0.22793235f, 
    -0.10816742f, 0.04905696f, -0.18231802f, 0.04566718f, -1.21657991f, -0.47204399f, -0.01984910f, -0.76027888f, 
    -0.40170458f, -0.16569400f, 0.53224164f, -0.22365339f, -0.68463677f, 0.21898937f, 0.13231649f, -0.45635667f, 
    0.33581597f, -0.70669687f, -0.03958498f, -0.13536952f, -0.60626382f, -0.16453515f, -0.00080793f, 0.00358862f, 
    -0.09924453f, 0.04318191f, 0.26267326f, -0.19022737f, -0.05135155f, -0.13647360f, -0.32719484f, 0.02699952f, 
    0.37374958f, -0.08047792f, 0.16115731f, -0.32273281f, -0.37038922f, -0.31610668f, 0.19174385f, -0.05340953f, 
    0.19603977f, -0.69254565f, -1.08637118f, -0.06532133f, 0.24220505f, 0.21240012f, -0.05874576f, 0.34078607f, 
    0.23106341f, 0.42820168f, -0.00327547f, -0.10984477f, -1.34214306f, 0.17250158f, -0.00598097f, -0.61147583f, 
    0.25323993f, -0.03829080f, 0.24300544f, -0.50944602f, -1.16351211f, -0.05854963f, -0.41908875f, -0.18213890f, 
    0.04800159f, -0.11639306f, 0.35940337f, -0.05783472f, 0.43914717f, -0.96626472f, -0.03269620f, 0.18080699f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.15470704f, -0.25890073f, -0.14092773f, -0.02314994f, -0.02226893f, 0.09920932f, 0.06280215f, -0.35486808f, 
    0.08201446f, -0.27401558f, 0.25950420f, 0.09783576f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
