#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.37169045f, 0.87565875f, -0.23704332f, -0.82109994f, -0.62376177f, 0.56301802f, -0.21262631f, -0.41672030f, 
    -0.19087011f, -0.35993508f, -0.10440689f, -0.01004525f, -0.36340496f, 0.14727689f, -0.11560123f, -0.00271845f, 
    -0.00613486f, 0.10003129f, -0.18705682f, 0.17835231f, -0.15196167f, -0.22807506f, 0.20702457f, 0.09282013f, 
    0.20352206f, 0.32064024f, 0.27743655f, -0.26481646f, -0.34302780f, -0.52149856f, 0.49735352f, -0.32783994f, 
    0.11650794f, 0.56641382f, -0.22576647f, -0.64791101f, -0.24054238f, 0.10909689f, -0.48874167f, -0.38917789f, 
    -0.33446369f, -0.36513215f, -0.08084014f, -0.13260446f, 0.20151202f, -0.10727628f, -0.08077337f, -0.12511978f, 
    -0.14153637f, -0.05927029f, 0.92497790f, 0.65784937f, 0.42861655f, -0.14874969f, 0.06348720f, -0.19144011f, 
    -0.72862828f, 0.09348077f, -0.42614746f, 0.51991260f, -0.13500154f, -0.01997247f, 0.06590180f, 0.16331293f, 
    -0.06364291f, -0.21692602f, 0.00382861f, 0.02246924f, -0.08928851f, -0.22076081f, 0.33549905f, 0.32923520f, 
    -0.08874784f, -0.11518380f, -0.02848520f, 0.93076640f, 0.17169704f, 0.25729322f, 0.81431717f, 0.82093936f, 
    0.33480179f, -0.05864756f, -0.32479089f, -0.06160767f, 0.27968040f, -0.27732241f, 0.04514949f, -0.07605208f, 
    0.40078312f, -0.00773785f, 0.11704996f, -0.34045404f, 0.15235785f, 0.22391248f, 0.06911784f, 0.17283659f, 
    0.16448259f, -0.12568693f, 0.08208856f, -0.12107587f, 0.11694228f, 0.10711480f, 0.60049409f, 0.27827573f, 
    0.75460285f, -0.44048557f, -0.51299608f, -0.21682788f, -0.47237948f, -0.46367195f, 0.27369782f, 0.35783470f, 
    0.26738685f, 0.40116346f, 0.16491099f, 0.28503370f, 0.03532904f, 0.37748536f, -0.09897284f, 0.38756016f, 
    0.12058865f, 0.10485066f, -0.05242367f, -0.09853911f, -0.26129097f, -0.79038167f, -0.35736012f, -0.72515923f, 
    -0.37202320f, 0.66391122f, -0.54246873f, -0.10643487f, 0.45323351f, 0.36632410f, -0.04080741f, -0.34026876f, 
    -0.25408262f, 0.25934505f, 0.00607733f, -0.04799785f, 0.31373909f, 0.18737227f, 0.12292721f, 0.19623017f, 
    0.16429104f, -0.31471279f, -0.09133799f, -0.04248884f, 0.23330258f, 0.00001062f, 0.14170718f, 0.63723892f, 
    0.47153467f, -0.21087244f, 0.45569932f, 0.36631146f, -0.47162926f, -0.60495973f, -0.00574992f, -0.13997614f, 
    0.22746228f, -0.50186032f, -0.21519192f, 0.18895313f, -0.25169805f, 0.11339980f, 0.16125679f, 0.32621467f, 
    -0.22114667f, 0.15026601f, -0.45611224f, -0.43189573f, -0.04063326f, -0.29277492f, -0.34545243f, -0.71021646f, 
    -0.93566483f, 0.39541569f, 0.22918607f, 0.20686151f, 0.27841312f, -0.23511600f, -0.06730608f, -0.10903827f, 
    -0.37464416f, 0.28700998f, 0.06453306f, -0.19592382f, 0.47432950f, 0.25089613f, 0.45176741f, 0.23108923f, 
    0.28550154f, -0.42281610f, -0.05356709f, -0.11269872f, -0.03057645f, -0.15036072f, -0.21710148f, 0.14022575f, 
    -0.29040563f, 0.43527678f, 0.48213795f, 0.83993149f, -0.37887070f, 0.07190981f, 0.11889598f, 0.21582557f, 
    0.43098387f, -0.37567109f, -0.12118339f, -0.28844881f, -0.41962200f, -0.36196408f, -0.07864904f, -0.38255087f, 
    0.00246224f, -0.11508761f, 0.09522378f, -0.13903481f, 0.09655476f, -0.20903993f, 0.00541394f, -0.28725779f, 
    -0.09734869f, -0.91953945f, -0.61456388f, -0.12970692f, 0.15898657f, -0.50064951f, 0.26397419f, 1.03052306f, 
    0.18095472f, 0.09811788f, 0.38649395f, 0.34436357f, -0.44063890f, 0.01543821f, -0.03482256f, 0.01945630f, 
    0.12217333f, -0.05575500f, -0.00985543f, -0.14139473f, -0.31388897f, -0.03920352f, -0.18865103f, 0.26442072f, 
    -0.32953641f, 0.23168170f, 0.86788481f, -0.29628259f, -1.01121771f, 0.23598155f, 0.44518033f, 0.10047071f, 
    0.32331663f, 0.33592108f, 0.18782873f, -0.25933954f, 0.10313786f, 0.06345873f, -0.20865640f, -0.05344394f, 
    -0.04824380f, 0.13157202f, -0.62317199f, 0.29935887f, -0.28352043f, -0.10782851f, -0.02984695f, -0.12357596f, 
    0.21759313f, 0.11132966f, -0.11105042f, 0.98783565f, 0.15359265f, 0.59617740f, -0.52591187f, 0.47974956f, 
    0.46446711f, 0.29344618f, 0.40583220f, 0.05202905f, 0.09583250f, -0.20027246f, 0.08331376f, 0.11795690f, 
    -0.07880802f, 0.10585730f, 0.38178164f, 0.08015322f, -0.13621855f, -0.23623043f, -0.02016363f, -0.23832193f, 
    -0.11499596f, -0.14475417f, -0.15840815f, -0.25336260f, -0.62764001f, -0.59936541f, -0.75980109f, -0.42068842f, 
    -0.27162114f, 0.45951933f, 0.46625638f, -0.48298940f, 0.43720394f, 0.38734192f, -0.17586310f, -0.05684341f, 
    0.35116681f, 0.26160595f, 0.36694816f, -0.32384279f, -0.04874495f, -0.10165628f, -0.28946331f, -0.33325827f, 
    0.17682436f, 0.11199170f, -0.09621218f, 0.20069799f, -0.00337796f, 0.67067599f, 0.59296584f, 0.82858431f, 
    0.14094442f, -0.02599691f, -0.32249093f, 0.44675097f, 0.10139596f, -0.51733595f, 0.32325485f, 0.23285003f, 
    0.27733400f, -0.00153267f, 0.04685245f, 0.28379160f, 0.16148743f, 0.22681928f, 0.36055025f, 0.22699130f, 
    0.17505001f, 0.12169901f, 0.33182997f, 0.10873293f, 0.29719293f, 0.42600933f, -0.07515344f, -1.22529566f, 
    -0.58596951f, 0.56612962f, 0.42469782f, -0.16258471f, 0.69525784f, 0.63052660f, -0.05202301f, 0.21688947f, 
    0.24554041f, 0.03564016f, -0.27007231f, 0.02891542f, -0.00884204f, -0.11788406f, 0.05165095f, -0.38696688f, 
    -0.21112737f, 0.12580858f, 0.16600779f, 0.23376252f, -0.13767043f, 0.21950439f, -0.04897989f, -1.13489413f, 
    1.05712211f, 0.56382269f, -0.73392749f, 0.29484257f, 0.15699214f, 0.58513927f, 0.34117195f, 0.33497828f, 
    0.06302796f, -0.10213126f, 0.11781867f, -0.14551987f, -0.18018939f, -0.35267606f, 0.23983273f, -0.28098857f, 
    -0.09058090f, -0.17978553f, -0.08507064f, -0.09545914f, 0.11664178f, 0.19433346f, 0.22802556f, 0.05945698f, 
    0.01866326f, -0.77314013f, -0.02521776f, -0.39358628f, -0.53750181f, 0.16178142f, 0.33614293f, 0.67054653f, 
    0.58300471f, 0.25866279f, 0.10776147f, -0.10608153f, -0.03646370f, 0.06406240f, -0.08409540f, -0.10693294f, 
    0.16885063f, 0.08361752f, -0.09991756f, 0.02198648f, 0.20685402f, -0.30330616f, 0.14724007f, -0.18992932f, 
    0.15546085f, 0.12485497f, 0.03735764f, 0.25197458f, -0.76675290f, -0.45905259f, 0.10211865f, -0.44931012f, 
    -0.37197033f, -0.21510875f, 0.50144958f, -0.20915121f, 0.03736682f, -0.08958489f, -0.11048485f, 0.30716452f, 
    0.03923482f, 0.37090972f, -0.31709087f, -0.20025739f, 0.50117964f, -0.16951686f, -0.11386111f, -0.16989990f, 
    -0.08993972f, -0.01641395f, 0.50592124f, 0.78146863f, -0.43974450f, -0.73477507f, -0.71870905f, 0.34600484f, 
    -0.58628005f, -0.27533779f, -0.70756984f, -0.53086573f, 0.00610210f, 0.12838583f, 0.40401131f, 0.02327037f, 
    0.12456413f, 0.18522829f, -0.00620022f, -0.10364550f, 0.09404519f, 0.02126036f, -0.01117211f, 0.07887997f, 
    0.23291875f, -0.30465126f, 0.11974694f, 0.00137722f, -0.66665864f, 0.08643597f, 0.79110038f, 0.47863165f, 
    -0.68205380f, 0.24131532f, -0.47760212f, -0.38725221f, 0.35014573f, 0.34474158f, 0.28671566f, 0.07906125f, 
    -0.09697102f, 0.25762856f, -0.54451180f, 0.15189321f, 0.49983236f, -0.17554010f, -0.08134254f, -0.21088655f, 
    -0.32300141f, -0.00950350f, -0.00160288f, -0.15325373f, -1.09425426f, 0.08296873f, 0.58407587f, -0.19551593f, 
    0.92342347f, 0.85410166f, -0.40421793f, -0.22910087f, 0.24035919f, -0.77908981f, 0.07749454f, 0.08722456f, 
    0.18821573f, 0.32596740f, -0.15953138f, -0.16171131f, 0.19952416f, -0.12079933f, 0.08568777f, 0.09208174f, 
    -0.09284256f, -0.20391235f, -0.19518545f, -0.13316885f, 0.09183789f, 0.63977349f, 0.45027348f, -0.56729138f, 
    0.91036910f, -0.31634507f, 0.67253977f, 0.05223341f, -0.65959698f, -0.02035788f, 0.02123712f, 0.44083872f, 
    0.21278469f, -0.05913004f, -0.19805840f, -0.18712422f, -0.03723481f, -0.30607408f, 0.16099155f, -0.10979709f, 
    -0.25719291f, 0.06801771f, -0.19505568f, 0.15389858f, 0.19504830f, 0.02795709f, -0.53825724f, -0.80857670f, 
    -0.72088432f, -0.15880086f, -0.13296092f, -0.76834261f, 0.03022446f, 0.42711493f, 0.01440085f, 0.23850954f, 
    0.32421684f, 0.09093591f, 0.37985620f, -0.21872298f, -0.07819842f, 0.01781700f, 0.06537386f, 0.10954454f, 
    0.01448803f, 0.16784576f, 0.10440677f, 0.04481797f, -0.30458635f, -0.12456664f, 0.22028019f, 0.55757308f, 
    0.12752946f, -0.44109493f, -0.90192425f, -0.14744195f, 0.02749286f, 0.08109678f, 0.62021500f, 0.53968424f, 
    0.59887242f, -0.08000355f, 0.23249593f, -0.41809845f, 0.27952963f, 0.16595796f, 0.10159687f, 0.18332060f, 
    -0.13044500f, 0.06718949f, 0.28409010f, -0.11522079f, 0.13898805f, -0.25215024f, 0.06271543f, 0.15758672f, 
    0.62767684f, -0.20807506f, -0.67984432f, 0.38028273f, -0.03187095f, -0.31971079f, 0.04957652f, 0.12073798f, 
    -0.15306593f, 0.16306283f, -0.20830667f, -0.23874187f, 0.28160173f, 0.02954420f, -0.02136917f, 0.11548349f, 
    0.18425198f, 0.36164355f, 0.32420906f, -0.24720718f, -0.20123813f, -0.34704286f, 0.08952797f, -0.26337841f, 
    0.23826525f, 0.06283683f, -0.73015326f, -0.16339964f, 0.43965513f, 0.14047736f, -1.07049310f, 0.14935935f, 
    0.23564675f, -0.59970123f, -0.42973331f, 0.27306983f, 0.09252252f, 0.16614483f, -0.11577162f, 0.24426678f, 
    -0.06112606f, 0.26820308f, -0.03699471f, -0.08994233f, -0.10554131f, 0.10383543f, 0.02538268f, -0.07925571f, 
    0.26082730f, 0.28708541f, -0.10351240f, 0.54321498f, 0.60889435f, 0.45805717f, 0.22527739f, 0.47360224f, 
    -0.28533250f, 0.40529379f, 0.32973000f, 0.40940073f, -0.67088968f, 0.21701449f, -0.17834011f, -0.35072452f, 
    -0.28031871f, 0.41986689f, 0.10617238f, -0.29401976f, 0.14867815f, 0.15013984f, -0.05934703f, -0.18770967f, 
    0.27280959f, -0.01376906f, -0.15813193f, -0.32802853f, -1.11234999f, 0.06677213f, 0.45311108f, -0.27720171f, 
    -0.43291155f, 0.27143282f, 0.34973952f, -0.15464248f, -0.13324311f, -0.12277288f, 0.02465255f, -0.49397233f, 
    -0.14207129f, -0.05537681f, 0.04433167f, 0.14819345f, -0.29745722f, -0.11711146f, -0.38616526f, -0.26802564f, 
    0.10539980f, 0.42482081f, 0.51145768f, 0.18932509f, 0.07169517f, -0.10659312f, -0.27820015f, -0.69020814f, 
    -0.48929483f, 0.02266442f, 0.31770265f, 0.41625097f, 0.39701134f, 0.33487710f, 0.42439657f, -0.05093954f, 
    -0.17361630f, -0.19734019f, -0.35473254f, -0.14255854f, 0.21767795f, -0.02134943f, 0.01421391f, 0.43619743f, 
    0.09540121f, 0.25485122f, -0.45270371f, 0.25697589f, -0.40955833f, 0.94958854f, -0.28883493f, -0.15427284f, 
    0.03206513f, 0.16620743f, -0.60504651f, 0.70018840f, -0.51532835f, -0.09877308f, 0.22407219f, 0.17816654f, 
    -0.02357432f, -0.04405536f, -0.03919398f, 0.17375717f, -0.13159263f, 0.23438224f, -0.38007730f, 0.13719766f, 
    0.11002961f, 0.34523141f, 0.12199765f, 0.08798005f, 0.08675302f, -0.13926932f, 0.73469537f, 0.29037035f, 
    0.21988527f, -0.01608886f, -0.19692653f, -0.16415863f, 0.45644537f, 0.61308491f, 0.47998190f, 0.29003248f, 
    -0.22122651f, 0.15062469f, 0.08439758f, -0.39566761f, -0.03857398f, 0.25628242f, 0.15805441f, -0.21743660f, 
    -0.01053806f, -0.26078925f, -0.05853964f, -0.18210217f, 0.29061705f, -0.12719224f, 0.12687024f, -0.21667528f, 
    0.52245003f, -0.68502033f, -0.45875594f, 0.33462560f, -0.54781204f, 0.07269251f, -0.03276878f, 0.16732267f, 
    0.70744312f, 0.48802674f, -0.24806783f, -0.30718568f, -0.60116655f, 0.20060216f, 0.06339642f, 0.22986998f, 
    0.03030392f, -0.14650676f, -0.09806661f, -0.27849451f, -0.14020093f, -0.08831947f, 0.46380091f, -0.07231623f, 
    0.56667173f, -0.25303429f, 0.68724847f, 0.35464433f, 0.39253971f, 0.75296712f, -0.83818859f, -0.12153122f, 
    -0.10850152f, -0.31696236f, 0.44497544f, -0.21075132f, -0.13048455f, 0.09687513f, -0.03734725f, 0.27753782f, 
    0.03633187f, -0.11736355f, 0.00297065f, 0.03928866f, -0.11600778f, 0.27988341f, 0.22140270f, 0.15858363f, 
    0.60472268f, 0.06207608f, -0.66744059f, -0.63526887f, -0.60351247f, 0.19855216f, 0.21183990f, 0.31790960f, 
    0.06877225f, -0.54472381f, 0.42146176f, -0.55271226f, 0.05948528f, 0.16792285f, -0.01632668f, -0.02684828f, 
    0.13593468f, -0.10244691f, 0.06559566f, 0.31343079f, -0.48300204f, -0.12755816f, -0.07872779f, -0.26966146f, 
    0.30950236f, 0.35233122f, -0.27907616f, -0.50710875f, -0.60942298f, 0.40319467f, -0.49112314f, 0.13577023f, 
    0.26703292f, 0.29365817f, 0.45716369f, -0.01889684f, -0.25797227f, 0.09206828f, -0.09942278f, -0.34523767f, 
    -0.58382416f, 0.25247708f, 0.01261611f, -0.14439104f, -0.08585750f, -0.30192968f, -0.20755449f, -0.10778514f, 
    -0.30259529f, 0.11757024f, -0.09627865f, -0.47719726f, -0.50939846f, -0.50574636f, -0.56762391f, -0.40687972f, 
    0.18251117f, 0.35465854f, 0.10191730f, -0.27824178f, 0.48997873f, -0.16376510f, 0.37952539f, 0.15415280f, 
    0.06849040f, -0.45728558f, 0.00825152f, 0.27356768f, 0.31100869f, 0.16867809f, 0.14135699f, -0.10257462f, 
    0.24763377f, -0.38366225f, -0.23574266f, 0.27601072f, -0.21400841f, -0.91956335f, 0.29634032f, 0.35738698f, 
    -0.60679346f, 0.53459138f, -0.29653910f, 0.58484781f, -0.13516659f, -0.39080411f, 0.22507448f, -0.50701344f, 
    -0.04239324f, 0.38732746f, 0.03535255f, -0.00064682f, 0.34619913f, 0.18415201f, -0.03047004f, 0.04653167f, 
    -0.19297467f, 0.02033904f, 0.20470309f, -0.17329541f, -0.00788513f, 0.46945506f, -0.04452587f, 0.38906461f, 
    0.77373099f, 0.32345456f, 0.43845478f, 0.35109350f, 0.06508120f, 0.25105819f, 0.13634397f, -0.20695907f, 
    0.14108205f, -0.18848471f, 0.26748076f, 0.25885731f, -0.22574991f, 0.35655904f, -0.17300908f, 0.27173319f, 
    -0.19596384f, -0.23238288f, -0.21210733f, -0.50505906f, -0.13219692f, 0.11217789f, -0.54147512f, 0.49077210f, 
    -0.02561037f, -0.86319327f, 0.53289056f, -0.33218044f, -0.56826019f, -0.14665025f, -0.31753969f, -0.30287188f, 
    0.28198844f, -0.15453318f, -0.20152833f, -0.03954775f, -0.16113175f, 0.17358276f, -0.19891550f, -0.48202822f, 
    -0.35367000f, -0.44110909f, 0.17568693f, 0.17124912f, 0.24481212f, 0.31534722f, 0.00086372f, 0.17375250f, 
    0.17880625f, -0.17261037f, 0.53835237f, -0.26857227f, -0.21380964f, -0.70944005f, -0.16939583f, 0.10906368f, 
    0.17755011f, -0.37135604f, -0.35307676f, 0.17485118f, -0.14660312f, 0.39428529f, 0.16008787f, -0.16534849f, 
    0.10037670f, 0.30377081f, 0.40977231f, -0.26818994f, 0.42063695f, -0.13837892f, 0.00222594f, -0.54424387f, 
    0.97857809f, 0.49515989f, -0.59545034f, 0.50885081f, 0.34034237f, 0.28314075f, -0.08720670f, 0.35147411f, 
    0.67302883f, 0.57219833f, -0.36201623f, -0.21877071f, 0.13876973f, -0.37132958f, -0.08966704f, -0.17332403f, 
    -0.09826025f, -0.15475622f, -0.23055372f, 0.09046566f, 0.08437410f, -0.20752734f, 0.01448147f, -0.12452284f, 
    -0.24135318f, 0.49271345f, -0.64648128f, -0.36663583f, 1.07978034f, 0.52856350f, -0.66580606f, 0.02960757f, 
    0.10700292f, 0.16140582f, 0.05866095f, 0.14165400f, -0.15195805f, 0.07950164f, 0.15484659f, 0.22606611f, 
    0.36603627f, 0.27902195f, -0.03628135f, 0.04069498f, 0.34504858f, -0.09081804f, 0.07847027f, 0.20852779f, 
    -0.12015676f, -0.02459923f, 0.41441020f, -0.16469781f, 0.54572767f, 0.44462198f, 0.34583318f, 0.47765535f, 
    0.40180641f, 0.23614492f, -0.19919732f, -0.44903907f, 0.36246008f, 0.35031381f, 0.03257258f, -0.35467353f, 
    -0.59358591f, -0.29543680f, 0.21204935f, 0.09791747f, 0.08341614f, 0.25714159f, 0.03763337f, 0.24232404f, 
    0.36400196f, 0.06052151f, -0.28279534f, 0.72208053f, 0.76320934f, 0.05685119f, 0.25985417f, 0.66497064f, 
    -0.11683868f, -0.32983041f, -0.47114122f, 0.56877035f, 0.15077278f, 0.07165418f, -0.26671141f, -0.12796542f, 
    0.14997876f, -0.39617181f, -0.30476511f, -0.05133162f, 0.10723684f, 0.01353297f, -0.32501212f, 0.01045525f, 
    0.33511111f, -0.01017324f, 0.11229193f, 0.05828888f, 0.81272948f, 0.13630407f, -0.08570641f, 0.87551075f, 
    0.89045388f, 0.26347354f, -0.10165687f, -0.36091670f, 0.37496886f, 0.26648945f, -0.26545301f, 0.29980138f, 
    0.02385641f, -0.16598183f, -0.08897653f, -0.36480296f, -0.24225375f, -0.25928494f, -0.33023804f, -0.38318911f, 
    0.11550763f, 0.27136892f, 0.13662820f, -0.00119246f, 0.23548461f, 0.45200393f, -0.61470610f, 0.31488243f, 
    0.58013839f, 0.73176205f, -0.76491565f, -0.42608467f, -0.42204395f, -0.64405745f, 0.26338246f, 0.47385240f, 
    0.62774700f, -0.08294142f, 0.43523607f, -0.04215250f, -0.09778947f, -0.13396700f, -0.28661945f, 0.23898873f, 
    -0.32995558f, 0.06020882f, 0.19514927f, 0.19848689f, 0.04786664f, 0.01224625f, -0.12299036f, 0.21852519f, 
    -0.89097691f, 0.31638378f, 0.75419050f, 0.12939724f, 0.53517753f, 0.55051017f, 0.16385219f, -0.76507950f, 
    -0.32474318f, -0.39823467f, -0.14244816f, -0.06378762f, 0.34501049f, 0.00786071f, -0.34224623f, 0.18102480f, 
    -0.01662979f, 0.02210095f, 0.22590753f, 0.04669326f, -0.19418521f, 0.46037346f, 0.01941211f, 1.05968010f, 
    -0.24267352f, 0.62132144f, 0.10552119f, -0.68510640f, -0.18293811f, -1.02653849f, -0.02161607f, 0.24948448f, 
    -0.03822494f, 0.28317758f, -0.26323569f, 0.00376275f, 0.15147708f, 0.00499597f, -0.03975803f, 0.13011731f, 
    -0.28320959f, -0.19784006f, 0.12588201f, 0.11272761f, 0.16841969f, 0.45786121f, 0.21186869f, 0.05493937f, 
    1.04285765f, 0.67711836f, -0.03637473f, -0.38099799f, -0.05991384f, -0.03134413f, 0.24740741f, -0.10662271f, 
    0.36422643f, 0.36688802f, 0.27259374f, 0.40286219f, -0.16246508f, -0.29103053f, -0.17878942f, 0.11318487f, 
    0.09085202f, -0.27486482f, 0.13107017f, 0.21308887f, 0.01431480f, 0.18831557f, 0.12485447f, 0.09218399f, 
    0.04210769f, 0.74509954f, 0.89620858f, 0.53274524f, 0.54425091f, 0.65805924f, -0.19722234f, -0.38707620f, 
    0.11987513f, -0.33456114f, -0.03017851f, -0.03880433f, 0.34789327f, -0.12381664f, 0.22349133f, 0.16208644f, 
    0.08026392f, 0.00626968f, 0.24055590f, 0.22975232f, 0.43869260f, 0.04279655f, -0.20214930f, -0.27746570f, 
    -0.22924048f, 0.22609918f, -0.82849199f, -0.86817652f, 0.00057779f, 0.56889403f, 0.21390696f, 0.63310415f, 
    0.46211073f, 0.42517781f, 0.26575655f, -0.50317025f, -0.02456621f, 0.01248832f, -0.06118217f, 0.51094437f, 
    -0.17876524f, -0.27988139f, -0.08693710f, -0.63648736f, -0.33158898f, -0.06431793f, 0.15013854f, -0.04080483f, 
    0.17230025f, 0.11360408f, -0.37241554f, 0.57322210f, 0.40876016f, 0.48826551f, 0.68279737f, 0.73722482f, 
    0.27427086f, 0.30732369f, -0.04860323f, -0.62411451f, -0.06531397f, 0.18716808f, -0.14635934f, 0.08449184f, 
    0.17891088f, -0.06548024f, -0.26010820f, 0.06713231f, -0.10409892f, -0.04147733f, 0.16997755f, -0.18842258f, 
    0.43108651f, -0.10011894f, -0.09713546f, -0.16749816f, 0.68763900f, 0.63046712f, 0.67963856f, -0.09721018f, 
    -0.80821383f, 0.28669837f, -0.04115326f, -0.12320280f, -0.17575912f, 0.10003822f, 0.37330946f, 0.39404708f, 
    -0.27597141f, 0.19653630f, 0.16009896f, -0.27621126f, -0.38628441f, -0.15395930f, -0.02690865f, -0.25698677f, 
    0.14088990f, 0.19376168f, -0.19686283f, 0.01380083f, 0.22949442f, -0.93236369f, 0.21083231f, -0.60269964f, 
    0.16850862f, -0.42582926f, 0.41648874f, -0.50224930f, -0.50739396f, 0.00659381f, -0.11335070f, -0.06779616f, 
    -0.19723874f, -0.02581181f, 0.04257258f, -0.10639448f, -0.51616341f, -0.10233293f, -0.36250407f, -0.23040211f, 
    -0.32540676f, 0.11644464f, 0.12618513f, -0.01108306f, -0.12515481f, -0.05042245f, -0.00954180f, 0.68633711f, 
    0.70025975f, 0.25805461f, -0.25057343f, -0.96378857f, 0.71874583f, -0.51419222f, -0.56019241f, -0.31842881f, 
    0.00928004f, 0.00298116f, -0.46902579f, -0.04722962f, -0.16931291f, 0.06825811f, -0.16858514f, -0.30778712f, 
    0.23048723f, -0.15064961f, -0.22341844f, 0.01406261f, 0.11909597f, 0.12890498f, -0.02739519f, -0.99422586f, 
    0.86807889f, -0.21921109f, -0.84019810f, -0.00832186f, -0.03977123f, -0.19618255f, 0.13963190f, 0.71042538f, 
    -0.51590562f, -0.30847105f, -0.27317730f, -0.26201206f, 0.15783279f, -0.26439860f, -0.27100217f, 0.22983462f, 
    -0.22229563f, -0.23244882f, -0.28925195f, 0.06614964f, 0.13435483f, -0.00874469f, 0.19367373f, -0.04240517f, 
    -0.63923609f, -1.09414887f, -0.38286498f, -0.06598701f, -0.25032458f, 0.20629500f, -0.10107096f, -0.20378821f, 
    0.10355061f, -0.18058755f, 0.10653380f, 0.11527745f, -0.33911216f, 0.50735146f, 0.39284334f, 0.07937061f, 
    0.00163069f, 0.13123383f, 0.15791211f, 0.11437085f, 0.40971559f, -0.02481904f, -0.23051725f, 0.10449281f, 
    -0.16432360f, 0.65972996f, 0.21395151f, 0.46272734f, -0.04076010f, -0.13384305f, -0.10941600f, 0.36380306f, 
    -0.39996850f, -0.01102080f, 0.66282159f, -0.04815942f, 0.16084866f, 0.03545870f, 0.39230514f, -0.09749005f, 
    -0.03980200f, -0.35566151f, -0.32747325f, -0.35069862f, -0.30667323f, -0.26088229f, -0.36514691f, 0.08801199f, 
    0.03688250f, -0.21421519f, -0.06966821f, -0.66259164f, -0.72415012f, -0.61243743f, -0.03366831f, 0.02890744f, 
    0.37748325f, 0.35513395f, -0.12306383f, 0.19174795f, -0.41377407f, -0.01083000f, -0.38917410f, -0.38746500f, 
    -0.45166755f, -0.49185458f, 0.32666969f, 0.15006448f, -0.22051714f, -0.05973268f, 0.14731613f, 0.01468132f, 
    0.22341806f, -0.17486279f, -0.17794240f, -0.18555993f, 0.34366193f, -0.19984853f, -0.05547900f, 0.82612813f, 
    0.57812697f, -0.32924306f, -0.91581917f, -0.50823933f, -0.40264681f, -0.03315556f, 0.35398749f, 0.12344559f, 
    0.02668720f, 0.07148881f, 0.17257504f, -0.33201766f, 0.08302367f, -0.23698033f, 0.09913503f, -0.09424674f, 
    0.20831177f, -0.00791362f, 0.21743688f, -0.33641765f, -0.39848670f, -0.68615472f, -0.51199263f, -0.40500346f, 
    -0.51786059f, -0.49736923f, -0.00642112f, -0.28165928f, -0.30181521f, 0.39208660f, -0.02176166f, 0.09436987f, 
    -0.15114345f, 0.24802323f, -0.08906716f, 0.33716446f, 0.00241536f, -0.03866309f, 0.16605367f, 0.08193167f, 
    -0.31990677f, 0.03264213f, 0.18651779f, -0.01761408f, -0.35803041f, 0.51202899f, 0.37973031f, 0.20712765f, 
    0.68436164f, 1.00639904f, 0.45851952f, -0.03077100f, 0.59973252f, -0.08742824f, -0.52762163f, -0.36296630f, 
    -0.44736081f, -0.22584318f, 0.02955587f, 0.06988212f, -0.15509416f, 0.18458609f, 0.30774069f, 0.29107538f, 
    0.23009154f, 0.16042037f, -0.01113192f, 0.01805379f, 0.03858535f, 0.00766385f, -0.49547338f, -0.28733900f, 
    -0.52552545f, 0.33198825f, 0.63585687f, 0.69179249f, -0.46410099f, -0.25859287f, 0.13236316f, -0.47187752f, 
    -0.11152492f, 0.18939687f, -0.24161711f, -0.16468969f, -0.11454444f, -0.08467997f, 0.05673644f, 0.40969419f, 
    0.08482192f, 0.44788718f, 0.01263297f, 0.26183262f, -0.15291716f, -0.27678013f, -0.25545278f, 0.10660157f, 
    -0.44675338f, 0.19183792f, -0.00052693f, 0.63819540f, -0.49276543f, 0.67813706f, 0.53262693f, -0.33044389f, 
    0.39982486f, 0.19485071f, -0.02558911f, 0.28446221f, -0.31852168f, 0.20731784f, -0.43555424f, -0.35224873f, 
    0.09964719f, -0.15977041f, -0.27561319f, 0.31647754f, -0.26243463f, 0.10025120f, -0.05661436f, -0.17593330f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21214931f, 0.05155974f, 0.31097749f, 0.04395372f, 0.09339314f, 0.29848224f, -0.09273756f, 0.02473615f, 
    0.09502717f, 0.05544461f, 0.06173120f, 0.04840083f, 0.01036162f, 0.26592669f, 0.22374897f, 0.07692331f, 
    0.04401488f, 0.09854966f, 0.21747355f, 0.21534432f, 0.08320844f, 0.30410802f, 0.31147560f, 0.14397189f, 
    0.04919158f, 0.08479783f, 0.09696686f, 0.00946133f, 0.12901993f, 0.06753876f, 0.15270853f, 0.22107983f, 
    0.08382708f, 0.19980796f, -0.00644768f, 0.18729405f, 0.16222258f, 0.14478290f, 0.08484312f, 0.03988280f, 
    0.09200217f, 0.13853058f, 0.07044914f, 0.01995996f, 0.11094856f, 0.22166419f, -0.03527961f, 0.15526800f, 
    0.27979374f, 0.10864177f, 0.27832469f, 0.13987407f, 0.15346472f, 0.07627051f, 0.11160214f, 0.20933856f, 
    0.28320765f, 0.25883043f, 0.01832610f, 0.04415820f, -0.00343457f, 0.06989037f, 0.04294586f, 0.09246633f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13126069f, 0.15998198f, 0.05529963f, -0.34461367f, 0.00353398f, -0.00727176f, 0.05986675f, 0.03469918f, 
    -0.07760043f, -0.02869862f, -0.10605944f, 0.02950633f, 0.08326036f, 0.04259424f, -0.14426163f, -0.04853887f, 
    0.05323707f, -0.02086909f, -0.05078080f, -0.11960772f, -0.03874703f, 0.07747923f, 0.06657624f, 0.06704415f, 
    0.14922321f, -0.01108222f, 0.04134656f, -0.23286286f, -0.07715284f, -0.13570186f, 0.02294456f, 0.01444692f, 
    -0.05720131f, 0.04236590f, -0.10355699f, -0.05974336f, 0.30449939f, -0.16517343f, -0.00851029f, 0.22518075f, 
    -0.11013640f, -0.02405788f, -0.03456533f, 0.01707258f, -0.04343391f, 0.00432469f, 0.00406574f, -0.11171661f, 
    0.08604359f, 0.11641804f, -0.01116492f, -0.01674650f, -0.03434289f, 0.07958638f, -0.06713285f, -0.04570067f, 
    0.11549822f, -0.04449174f, -0.07533862f, -0.06731810f, -0.11419587f, 0.22656907f, -0.05851683f, -0.07141613f, 
    0.00852188f, -0.01166045f, -0.07932212f, 0.01216470f, 0.06772945f, 0.07044442f, 0.02317969f, 0.05205176f, 
    -0.04973380f, 0.09479049f, 0.09541547f, -0.12576789f, -0.15437616f, 0.01250045f, 0.09718946f, 0.12395968f, 
    0.11422522f, 0.06900835f, -0.09684654f, -0.09560022f, -0.33220729f, -0.08025294f, -0.05208036f, 0.17292625f, 
    0.09356288f, 0.00024294f, 0.11024441f, 0.12034485f, -0.00609558f, 0.02932680f, 0.00430617f, -0.10481390f, 
    -0.05057042f, 0.11203505f, -0.09453053f, 0.27324393f, -0.07777675f, -0.01924811f, 0.06138766f, -0.04224885f, 
    -0.00594937f, -0.00537249f, 0.04026769f, 0.03087663f, 0.27364370f, 0.24926826f, 0.12246455f, -0.14262068f, 
    -0.04046905f, 0.04826069f, -0.04978960f, 0.11860406f, 0.01740228f, 0.04384477f, -0.05069866f, 0.11131040f, 
    0.10504163f, 0.23281552f, 0.02582094f, 0.00433882f, -0.05446168f, 0.05569629f, -0.09141370f, -0.05731246f, 
    -0.02823329f, -0.08237547f, -0.03416651f, -0.10788668f, 0.19225563f, -0.13180146f, 0.07794777f, -0.27562869f, 
    -0.17350209f, 0.01397389f, 0.02203318f, 0.10693748f, -0.02601827f, -0.09956999f, 0.00695182f, -0.06110669f, 
    0.23628470f, -0.08976872f, 0.05086469f, -0.13802846f, 0.02042546f, -0.03266409f, -0.02541677f, 0.01805857f, 
    0.04911824f, -0.02714229f, 0.02680416f, 0.14132181f, 0.01178974f, 0.14996698f, -0.06432305f, -0.01718243f, 
    -0.02302261f, -0.02625670f, -0.00657846f, 0.04650792f, -0.01808174f, -0.01145779f, -0.08609117f, 0.01070752f, 
    -0.20357905f, 0.29016289f, -0.05607479f, 0.10238443f, -0.01933666f, 0.02755233f, -0.09847201f, -0.02788602f, 
    -0.01146486f, -0.00868180f, 0.07264015f, -0.04053584f, 0.11026154f, -0.07260907f, 0.20774452f, -0.05353519f, 
    -0.05017079f, -0.05730325f, 0.06329997f, -0.08153463f, -0.02659659f, -0.13404793f, -0.06735514f, -0.09587512f, 
    0.03375654f, 0.16048621f, -0.14763851f, -0.13315082f, -0.00299094f, -0.00762062f, -0.06137715f, 0.02906568f, 
    0.01028332f, -0.00312555f, -0.09785191f, 0.05828011f, -0.03247733f, 0.03742695f, 0.01831531f, -0.32923627f, 
    0.01054055f, -0.11401495f, 0.01741007f, 0.03281096f, -0.11820035f, -0.15295817f, 0.10316195f, 0.21317765f, 
    -0.32381764f, 0.15614264f, 0.18798016f, -0.32507628f, -0.15031759f, -0.02938783f, 0.05866046f, 0.09120896f, 
    -0.04236323f, -0.07924081f, -0.04814997f, 0.06444439f, 0.10237925f, -0.21618341f, -0.20780773f, 0.20295945f, 
    -0.12591937f, -0.11876395f, 0.02566113f, -0.12660047f, 0.05501939f, 0.08451356f, -0.12847994f, 0.02315694f, 
    -0.73694599f, -0.25995487f, 0.23906854f, -0.04529704f, 0.01187772f, 0.02749875f, -0.10087594f, -0.10013939f, 
    0.02714043f, -0.06532963f, 0.02769596f, -0.03078948f, -0.00898014f, 0.10167710f, -0.06796732f, 0.17134300f, 
    -0.03215802f, 0.05169598f, -0.08608765f, 0.05145849f, -0.09097586f, 0.02060469f, -0.01590501f, -0.05070925f, 
    -0.33889791f, 0.10973168f, -0.24960747f, -0.06445464f, -0.04058043f, -0.02617336f, 0.05722860f, 0.08461200f, 
    0.02518537f, -0.02090912f, -0.02374205f, -0.04808080f, 0.22697119f, -0.03607481f, -0.12507685f, -0.45311722f, 
    0.01648675f, -0.08543210f, 0.02831651f, -0.05979427f, -0.02644796f, 0.06863014f, 0.03658780f, 0.03070521f, 
    -0.04860310f, -0.04552745f, 0.10810272f, 0.14220710f, 0.02125095f, -0.01941098f, 0.04043399f, 0.03111978f, 
    0.02591827f, 0.11773204f, -0.02227064f, 0.09509239f, 0.09941374f, -0.05650904f, -0.14574817f, 0.22020240f, 
    -0.03147486f, -0.10849033f, 0.02374356f, -0.09488063f, 0.00297151f, -0.13370563f, -0.00501265f, 0.00609123f, 
    -0.07732221f, 0.02038113f, 0.02175912f, 0.21000238f, -0.07692174f, -0.05761530f, 0.01685138f, 0.03133978f, 
    0.02957425f, -0.10084475f, 0.00031406f, -0.00344370f, -0.10831271f, -0.10794046f, -0.15549941f, 0.15480462f, 
    0.06365838f, 0.08383419f, -0.06933231f, 0.02571101f, -0.03423521f, 0.13835759f, -0.02639738f, 0.02041760f, 
    -0.02134158f, 0.01438409f, -0.16626891f, -0.26105797f, -0.01655139f, 0.16339721f, -0.01017578f, -0.07866181f, 
    -0.10856687f, 0.05600338f, -0.00209048f, 0.01530799f, 0.14700341f, -0.09506495f, 0.11166009f, 0.06044925f, 
    -0.03318218f, -0.02495778f, -0.02709006f, 0.03315145f, -0.07886963f, -0.03107903f, -0.04426431f, 0.04820296f, 
    -0.08537891f, -0.00911250f, -0.07178192f, -0.09246919f, -0.08370113f, -0.09453313f, 0.00963192f, 0.01177828f, 
    0.03495282f, -0.02887772f, 0.15193985f, -0.08602957f, 0.05973409f, -0.02640264f, 0.17765282f, -0.11542047f, 
    0.01126218f, -0.02160460f, 0.01401563f, -0.14852433f, 0.11708596f, 0.02275509f, -0.04807419f, -0.04514142f, 
    0.15478733f, -0.29131615f, 0.04792992f, -0.06085423f, 0.01147218f, -0.13896225f, -0.00998283f, -0.00263745f, 
    -0.06309169f, -0.04375558f, -0.13733853f, 0.00940313f, -0.02152737f, -0.12009488f, 0.08966257f, -0.23533985f, 
    0.02417525f, -0.12528689f, 0.04600389f, -0.00294310f, -0.02246776f, -0.00878972f, -0.09470361f, 0.02864123f, 
    0.13596088f, 0.23530197f, -0.25271538f, -0.02369151f, 0.04446886f, 0.12024085f, 0.13929468f, -0.06101121f, 
    0.13914143f, -0.08533370f, -0.00967541f, 0.00483799f, 0.03488937f, 0.06102431f, 0.04391857f, -0.46032730f, 
    0.00653095f, 0.06891300f, 0.06443956f, 0.01059940f, -0.08162784f, -0.05174353f, -0.05644263f, 0.03203631f, 
    0.01283111f, -0.00294856f, -0.06125925f, -0.00256343f, 0.04019975f, 0.03049987f, -0.00033953f, 0.07677158f, 
    -0.06920215f, 0.00619975f, -0.03190484f, 0.00560490f, 0.08706430f, -0.07775011f, -0.10047557f, 0.15890674f, 
    -0.05409509f, -0.03775264f, 0.13391344f, -0.01280745f, 0.03275645f, 0.01224927f, 0.04990127f, 0.01857262f, 
    -0.34003347f, -0.05737303f, 0.14360958f, -0.22257818f, 0.01273577f, 0.03570712f, -0.07219560f, 0.03044122f, 
    0.11621458f, -0.01771645f, 0.10371692f, -0.12880634f, 0.03502251f, 0.07380679f, 0.04495170f, 0.13019176f, 
    0.02816147f, 0.06680974f, -0.11934135f, -0.08290437f, -0.01939976f, 0.05291734f, -0.04728432f, 0.05450650f, 
    0.06977180f, -0.01523552f, 0.02789417f, 0.24166507f, -0.13929848f, 0.13062108f, -0.01758375f, 0.06111095f, 
    -0.04045459f, 0.05512884f, 0.02304682f, 0.07415111f, 0.14260769f, -0.08695207f, -0.18155256f, 0.37153679f, 
    -0.00193780f, 0.09794056f, -0.03880118f, -0.05481222f, -0.03543206f, -0.16281004f, 0.01844585f, -0.04889522f, 
    0.02335574f, 0.13197397f, -0.10435508f, -0.01162566f, -0.03209461f, 0.13763794f, 0.04727998f, -0.04550504f, 
    -0.02468084f, 0.09655561f, 0.00522854f, -0.08394238f, 0.11942534f, 0.04508938f, 0.14090405f, 0.05806752f, 
    0.07691292f, 0.02554027f, 0.01704404f, 0.03516196f, 0.08634918f, 0.06513713f, -0.02822329f, -0.02699083f, 
    0.22710909f, 0.00619973f, 0.08113875f, 0.28015262f, -0.06968680f, -0.00109220f, -0.06048833f, 0.06301583f, 
    -0.16302924f, 0.05672639f, -0.01495995f, -0.04591483f, 0.27593598f, -0.15354000f, 0.02093416f, 0.17723164f, 
    -0.14658321f, -0.07098807f, -0.01878555f, -0.01515885f, -0.13834539f, 0.07355285f, 0.04613663f, 0.01259349f, 
    -0.18068117f, 0.26909080f, -0.00432606f, -0.04565862f, -0.16347915f, -0.08686540f, 0.02861099f, -0.02963187f, 
    0.10046198f, 0.04342581f, 0.04193341f, 0.00018183f, 0.23720831f, -0.35302690f, -0.07136368f, 0.20076820f, 
    0.06134225f, 0.00845448f, 0.00597695f, -0.03631378f, -0.01091116f, 0.00810456f, -0.06492099f, 0.03591936f, 
    0.02033757f, -0.01981416f, 0.10539956f, -0.24374080f, 0.03204893f, -0.07730550f, -0.00628697f, 0.09959275f, 
    0.03517856f, 0.01791545f, 0.04945314f, 0.01670999f, 0.20970736f, 0.07170623f, 0.07494134f, -0.19483790f, 
    -0.20144247f, -0.06652243f, -0.01899193f, 0.11115127f, 0.07107006f, -0.00781259f, -0.05744728f, 0.02230634f, 
    -0.17861898f, 0.06226955f, -0.04330122f, 0.08830436f, 0.11653462f, 0.06205699f, -0.07447430f, -0.00688656f, 
    0.03954446f, -0.07190306f, 0.03023876f, -0.05666099f, 0.16113740f, 0.02545152f, -0.07651811f, 0.04449104f, 
    -0.16912673f, 0.08024111f, -0.01720540f, 0.07710140f, -0.08196335f, 0.02214173f, -0.04602275f, -0.06350823f, 
    -0.12604399f, 0.07665653f, 0.01718594f, 0.07433385f, -0.14131014f, -0.05018092f, 0.04442323f, -0.06609928f, 
    -0.03832141f, 0.01547285f, 0.00919029f, 0.04892345f, 0.24095948f, -0.32758301f, -0.24491945f, 0.00664451f, 
    0.15475626f, -0.03313754f, -0.09413079f, -0.01410102f, -0.00801172f, -0.07375024f, 0.05380377f, 0.13054822f, 
    0.00857951f, 0.08391548f, 0.00544662f, 0.11698719f, -0.00653932f, -0.03345795f, -0.04100802f, 0.01956832f, 
    -0.04734735f, -0.01337468f, 0.00776605f, -0.13961326f, 0.14911719f, 0.09364443f, 0.03930277f, -0.09253129f, 
    0.00569601f, 0.04867441f, 0.05914954f, -0.07080893f, 0.00520953f, 0.04711350f, -0.04428241f, -0.10784332f, 
    -0.31902245f, -0.12314143f, 0.00937302f, -0.00256410f, 0.09185234f, -0.06778442f, -0.06188446f, 0.12412532f, 
    0.06851140f, -0.08770806f, 0.06449161f, -0.05676481f, 0.04853427f, -0.10283456f, -0.05011033f, -0.09435191f, 
    -0.03659107f, -0.23666653f, -0.02711365f, 0.12438660f, -0.00064765f, 0.10996426f, 0.06369755f, -0.06421847f, 
    -0.06905258f, 0.12603538f, 0.01250013f, -0.29435462f, 0.00001429f, 0.10048486f, 0.04481817f, 0.05789105f, 
    -0.20017162f, 0.03861903f, 0.01030836f, 0.04743516f, -0.01877103f, -0.06532625f, 0.25144652f, -0.26379049f, 
    0.02558673f, -0.08540096f, 0.11129234f, -0.10851537f, 0.03689082f, -0.03286949f, -0.02024643f, -0.00202600f, 
    -0.12132265f, -0.20201454f, -0.04586829f, -0.15059048f, -0.04019458f, -0.08130358f, 0.09789966f, 0.07134745f, 
    0.05498017f, -0.06620342f, 0.05198987f, -0.09080330f, 0.16826579f, -0.07513836f, 0.05244017f, 0.10573172f, 
    -0.16158929f, 0.05933743f, -0.02820762f, 0.05956431f, 0.08162662f, -0.02051349f, -0.00243054f, 0.01260415f, 
    -0.05924449f, -0.31292123f, 0.07912493f, 0.08154909f, 0.07406717f, 0.00451175f, 0.07537733f, -0.10665937f, 
    0.04576478f, 0.01990855f, 0.08141688f, 0.01148142f, -0.30670512f, 0.05537562f, -0.07725126f, -0.08174495f, 
    -0.06416951f, -0.05854205f, -0.16610841f, -0.05188721f, 0.05444172f, -0.01557206f, -0.04117505f, 0.08723079f, 
    -0.39522719f, -0.14063364f, -0.09075278f, -0.35444820f, -0.10739917f, 0.03963921f, 0.06199432f, -0.00217777f, 
    -0.05288796f, 0.04155277f, 0.02881075f, 0.03321343f, -0.14408469f, -0.20467342f, 0.06712737f, 0.01050245f, 
    -0.02423800f, -0.09956109f, -0.01678551f, 0.08996883f, 0.02817174f, -0.01331899f, 0.02899610f, -0.15348248f, 
    0.15325551f, 0.02793366f, 0.10385767f, 0.11224329f, -0.03080239f, -0.06382674f, 0.06595189f, 0.04809957f, 
    0.09778689f, -0.11985577f, 0.07842445f, 0.02859642f, 0.15960072f, -0.12900189f, 0.15534122f, 0.11666238f, 
    -0.10410313f, 0.00334689f, -0.03644005f, 0.05132385f, 0.07942358f, -0.01950662f, -0.01431833f, 0.10128393f, 
    -0.17427215f, -0.02339378f, -0.00048666f, -0.05651221f, -0.03726782f, -0.09722995f, 0.00107686f, -0.06230868f, 
    0.00970857f, 0.02933757f, -0.00729073f, 0.10642664f, 0.10143448f, 0.05101912f, -0.01173510f, -0.23048964f, 
    0.08885074f, 0.03472427f, 0.02364040f, 0.06215551f, 0.01413101f, -0.03709013f, 0.01488058f, 0.03001381f, 
    -0.02071908f, -0.07813813f, -0.07636506f, -0.04353945f, 0.06176176f, 0.04521851f, -0.04541611f, -0.06588079f, 
    -0.11061320f, -0.13998936f, 0.04125794f, 0.04675499f, -0.13915808f, 0.18965451f, -0.09282383f, 0.04738413f, 
    -0.06905798f, 0.09012039f, -0.04394267f, -0.02337421f, -0.02132775f, -0.06765678f, 0.01435077f, 0.18741077f, 
    -0.00220035f, 0.00716018f, -0.14814344f, 0.12694366f, 0.01617930f, 0.02439423f, 0.04749078f, 0.03287948f, 
    -0.05798322f, -0.02959448f, -0.05090803f, -0.00041332f, -0.09867910f, 0.05786531f, -0.28288364f, 0.02741838f, 
    -0.04983533f, 0.01301980f, 0.03029147f, 0.04404870f, -0.00565817f, 0.06176582f, -0.11282469f, 0.06116541f, 
    0.18097888f, -0.43602428f, 0.16114990f, 0.00987281f, 0.05733989f, 0.02854799f, -0.05259918f, 0.01968513f, 
    -0.03873765f, 0.04697781f, -0.13197938f, 0.07963446f, 0.16671903f, 0.08370805f, -0.03280000f, 0.02559138f, 
    0.01564861f, -0.01034065f, -0.08901256f, -0.05931177f, 0.04167797f, 0.05304462f, -0.01413208f, -0.02747529f, 
    0.13344897f, 0.01286241f, -0.06232349f, -0.03609522f, 0.05372082f, 0.00164270f, 0.00791285f, 0.05423105f, 
    -0.08375363f, -0.04907141f, -0.09802601f, -0.06736087f, 0.00834573f, 0.15735367f, 0.03192278f, 0.11092862f, 
    -0.16082716f, -0.00858582f, -0.01319951f, 0.02030463f, 0.03837606f, 0.07387205f, 0.04156167f, -0.03043325f, 
    0.16540113f, -0.19247963f, -0.01500819f, 0.03536678f, -0.07768308f, 0.09682764f, -0.04927209f, -0.04355484f, 
    0.16366206f, 0.06249464f, -0.05306051f, 0.07371136f, -0.43942070f, 0.09714568f, -0.06227630f, -0.12221386f, 
    0.08098495f, 0.11514876f, 0.00816774f, -0.04221760f, 0.04084664f, 0.11405254f, 0.11662297f, 0.02433965f, 
    -0.02393041f, -0.10382717f, -0.07945015f, -0.09620104f, -0.00620909f, 0.03849663f, 0.04709320f, 0.11004616f, 
    0.05388208f, 0.00501832f, 0.05727877f, -0.06702532f, -0.11081072f, -0.00523907f, -0.01414653f, 0.02175261f, 
    -0.04729914f, 0.01619213f, 0.01979531f, -0.05995280f, -0.10422768f, 0.08895432f, 0.08238905f, -0.11214231f, 
    0.18028176f, -0.14612776f, -0.05576021f, -0.27987295f, 0.00383310f, -0.01054856f, 0.09014126f, -0.00909266f, 
    0.02226251f, 0.06217274f, 0.05411425f, -0.02014332f, -0.04503783f, -0.18942077f, 0.02580754f, 0.10330819f, 
    -0.00766714f, 0.06146792f, -0.07352546f, 0.06237960f, -0.01476103f, -0.11870228f, 0.19204587f, -0.01655080f, 
    0.11036768f, 0.19296943f, -0.17386138f, -0.01996457f, -0.06635553f, -0.00682192f, -0.04351240f, -0.01388329f, 
    -0.10267828f, 0.10636847f, -0.03434236f, 0.01949694f, 0.06200276f, -0.20664017f, -0.01416843f, 0.07367296f, 
    0.00928159f, -0.06842585f, 0.05021619f, 0.06833462f, -0.05958287f, -0.05012326f, -0.08116131f, 0.10512480f, 
    0.19268525f, -0.08248596f, -0.03674485f, -0.05729806f, 0.05412453f, -0.08118617f, -0.01446319f, 0.02384746f, 
    -0.03651305f, -0.01940848f, 0.06393985f, 0.03530876f, 0.14426282f, -0.16996719f, 0.05885789f, -0.33271164f, 
    0.06654119f, 0.05307322f, -0.02222181f, 0.09762983f, -0.10949653f, -0.05361656f, 0.07857074f, -0.07469489f, 
    0.16683903f, -0.16714808f, -0.04661652f, -0.03014439f, -0.03360247f, -0.03470323f, -0.09894639f, 0.04781318f, 
    -0.06154504f, -0.13696195f, 0.01368684f, -0.14253277f, -0.29728687f, -0.18141800f, -0.04485527f, 0.04881003f, 
    0.04723746f, 0.08504464f, -0.13648318f, 0.00320507f, 0.03997618f, 0.06951920f, 0.12392347f, -0.00524598f, 
    0.21512535f, 0.00240112f, 0.05918549f, 0.08894774f, 0.01333013f, 0.02549935f, -0.03313592f, -0.02225562f, 
    0.09125227f, -0.08472969f, 0.01735222f, -0.03977113f, -0.16784012f, -0.00598017f, -0.05376028f, 0.21232076f, 
    -0.13777098f, -0.12731561f, -0.00684135f, -0.11756602f, 0.00071866f, -0.28625813f, -0.08190572f, 0.02659729f, 
    0.05602617f, -0.06325099f, -0.06803962f, -0.18709096f, 0.00418840f, -0.13841178f, -0.01167163f, 0.07791854f, 
    0.12378247f, -0.05995368f, -0.05392778f, 0.07478490f, 0.35072803f, -0.20939033f, -0.13820325f, -0.09599854f, 
    0.06654021f, -0.02794724f, -0.02792807f, 0.01307277f, 0.11792378f, 0.15383923f, -0.07023023f, -0.05743181f, 
    0.26505440f, 0.07495203f, 0.04704856f, 0.08669474f, -0.05280128f, -0.08298087f, -0.09067520f, -0.02824970f, 
    -0.03954274f, -0.10397344f, -0.06938720f, -0.05073119f, 0.24017721f, -0.10527259f, -0.23603648f, -0.24561016f, 
    -0.15314311f, -0.03319236f, -0.10243026f, 0.02004124f, 0.11823402f, -0.08706402f, 0.03139583f, 0.15976214f, 
    -0.16603434f, 0.09316671f, 0.21335690f, -0.03392241f, -0.13164030f, 0.08279314f, 0.06390651f, -0.00505719f, 
    0.03827443f, 0.12837665f, 0.14966458f, 0.03412262f, 0.15381347f, -0.07341603f, 0.12637745f, -0.18095817f, 
    0.02016489f, 0.03653780f, 0.05952499f, 0.04947221f, 0.00127181f, -0.04361924f, 0.10978188f, -0.05573775f, 
    -0.07759075f, -0.19157772f, -0.13688996f, 0.02947885f, -0.01143860f, -0.08648375f, -0.12190340f, -0.12277226f, 
    -0.05227461f, -0.05228991f, -0.03330263f, 0.06813556f, 0.01076488f, -0.05316601f, -0.08707748f, -0.05416429f, 
    0.01041272f, 0.00715749f, 0.09012451f, 0.08679790f, 0.06467722f, 0.11993754f, 0.09895333f, -0.06773350f, 
    -0.36774215f, 0.18639360f, -0.02103263f, 0.14478658f, -0.07630523f, 0.06079679f, 0.03168833f, 0.00467176f, 
    0.16686633f, 0.02944507f, 0.02226617f, -0.01050896f, 0.34515166f, 0.03522845f, 0.07178578f, 0.13922009f, 
    0.02923821f, 0.03541061f, -0.08683670f, -0.05547291f, 0.06955843f, 0.01610534f, 0.05758423f, -0.02886740f, 
    0.02231824f, 0.04375229f, -0.05974785f, -0.43471307f, 0.05601161f, 0.09734318f, 0.03853612f, 0.00292986f, 
    0.06182378f, 0.10057737f, -0.23100744f, 0.06213896f, 0.02966794f, -0.05881682f, -0.09277050f, 0.10123964f, 
    0.00612051f, -0.19203258f, -0.04870028f, -0.02270063f, -0.01775963f, -0.06133759f, 0.05074206f, 0.10211542f, 
    0.22048801f, -0.06136491f, 0.15422209f, 0.06243073f, -0.01477258f, -0.13497025f, -0.05926684f, -0.02053500f, 
    0.01256226f, 0.04211600f, -0.06783755f, 0.00762915f, -0.02374229f, -0.14891362f, 0.02815612f, 0.08946659f, 
    -0.13586563f, -0.02641210f, -0.06557289f, -0.02226449f, -0.02681341f, 0.21372139f, -0.05526147f, 0.04300270f, 
    -0.05386058f, -0.04367783f, 0.12576175f, 0.16407377f, -0.11455816f, -0.08830748f, 0.00067134f, -0.00791972f, 
    -0.09972096f, -0.05241732f, -0.01773508f, -0.03252510f, 0.19322567f, -0.10287986f, 0.03466374f, 0.12931634f, 
    -0.15364401f, -0.07705446f, 0.07242984f, 0.04900226f, -0.05471682f, -0.11735763f, -0.02774000f, -0.07449763f, 
    0.16090110f, 0.00533324f, 0.15267046f, 0.16918859f, -0.04611479f, 0.05024206f, -0.00191667f, 0.00295133f, 
    0.01104917f, -0.05732779f, -0.07257819f, -0.08223956f, -0.30423048f, -0.12917545f, 0.06978074f, 0.10737976f, 
    0.13551570f, 0.06440439f, -0.01034504f, 0.06159796f, 0.08955606f, 0.03110095f, -0.10954999f, -0.01682526f, 
    0.01084467f, -0.04777932f, -0.12345399f, 0.05816519f, 0.02082838f, 0.11914995f, -0.12889408f, 0.02421912f, 
    -0.04786013f, 0.10281298f, -0.03152269f, -0.05888880f, -0.05033218f, 0.11106167f, -0.05738012f, -0.11364998f, 
    0.04913607f, -0.11617266f, 0.03481951f, -0.00175285f, -0.11339685f, 0.10613718f, 0.10077282f, -0.01933527f, 
    0.37357247f, -0.01281710f, 0.07126331f, 0.05221169f, -0.06361869f, -0.06456900f, 0.04815637f, -0.04002499f, 
    -0.15117685f, -0.04418484f, 0.01440596f, 0.02969697f, 0.15344989f, -0.01759243f, 0.00069828f, 0.18609782f, 
    0.05188879f, 0.00043809f, -0.04002679f, -0.00055174f, -0.03162039f, -0.02909604f, -0.08048718f, 0.04978516f, 
    0.13200024f, 0.07621729f, -0.17705059f, 0.10075501f, -0.00925018f, 0.01747136f, 0.03193113f, -0.10944586f, 
    0.00013752f, 0.00206701f, -0.07770048f, -0.08388939f, 0.12976916f, -0.00733072f, 0.21438502f, 0.08967154f, 
    -0.10247187f, -0.07424073f, 0.02287875f, 0.00708500f, -0.02265531f, 0.03010041f, 0.06031409f, -0.04720454f, 
    -0.02257918f, 0.00709503f, -0.01286242f, 0.01118062f, -0.14235520f, 0.00931316f, 0.02112614f, 0.00492487f, 
    -0.07132644f, -0.06943884f, -0.11081469f, -0.04897738f, -0.24255638f, 0.19620821f, -0.05145373f, -0.14598945f, 
    0.02078091f, -0.02387091f, 0.05643930f, 0.04475971f, -0.04252860f, -0.19268478f, -0.11768381f, -0.21105495f, 
    -0.14827709f, 0.01457129f, -0.31708899f, -0.13055500f, -0.03871115f, 0.06237232f, 0.07990899f, -0.01400648f, 
    0.09332103f, -0.03415280f, -0.03126537f, 0.02554656f, -0.53046775f, -0.00656060f, -0.13860051f, -0.25706428f, 
    -0.09733278f, -0.02028425f, 0.08720553f, 0.02383287f, -0.01175960f, -0.12566760f, -0.09001961f, -0.08280027f, 
    0.22677249f, 0.04151758f, -0.09597699f, 0.11669575f, 0.05509829f, 0.02665974f, 0.04046465f, -0.00182529f, 
    -0.10598167f, 0.09260599f, -0.01133944f, 0.12009094f, 0.10603035f, 0.14762741f, 0.08014555f, 0.05442624f, 
    -0.02957259f, 0.04152462f, 0.04616982f, -0.08000877f, 0.00237425f, -0.17729558f, -0.05785526f, -0.01811181f, 
    0.14078464f, -0.16157486f, 0.02400905f, -0.10113844f, 0.04575718f, -0.12640025f, -0.09607209f, 0.02829797f, 
    0.22203498f, -0.08551458f, -0.02654216f, -0.08822210f, 0.04760705f, -0.14852878f, -0.16108961f, -0.29811719f, 
    0.04281707f, 0.03146522f, 0.05268395f, 0.01360536f, 0.01892069f, 0.08658295f, -0.04134613f, -0.03512728f, 
    0.09075744f, 0.13821229f, 0.01881434f, 0.08796062f, -0.13266206f, 0.01512653f, 0.10542256f, 0.02083870f, 
    -0.07574582f, 0.05819367f, -0.04258436f, 0.07118902f, 0.07185654f, 0.10238320f, 0.00250364f, 0.25440744f, 
    -0.07460778f, 0.03472346f, -0.03716328f, 0.04574489f, -0.03314142f, 0.02159441f, -0.06926686f, 0.00914206f, 
    0.10796216f, 0.01102520f, -0.17483868f, -0.12573062f, 0.09351578f, -0.00846673f, -0.07754058f, 0.01497806f, 
    -0.01667442f, 0.03899074f, 0.07570206f, -0.00639210f, 0.22535861f, -0.01893246f, 0.06953669f, 0.10601083f, 
    -0.01731451f, 0.05154170f, -0.04083342f, 0.09065316f, 0.03622800f, 0.02099558f, 0.08413973f, -0.13628952f, 
    -0.17066103f, -0.04307620f, -0.16203578f, -0.24479622f, 0.05935244f, -0.04870698f, 0.01861442f, -0.00207771f, 
    -0.05103908f, 0.07969510f, 0.01946899f, -0.04584966f, -0.10387364f, 0.06068509f, -0.12183552f, 0.01728811f, 
    0.01198997f, -0.00053724f, 0.09630873f, 0.05495989f, -0.05615448f, 0.03356291f, 0.08637834f, -0.00598081f, 
    -0.22377518f, 0.06245848f, 0.02434507f, -0.18138793f, 0.05468501f, -0.02290221f, 0.00524797f, -0.10178941f, 
    -0.03753398f, 0.02816219f, -0.03336411f, 0.07342227f, -0.04001435f, -0.02861593f, 0.05320921f, -0.03998820f, 
    0.11588747f, 0.07001124f, -0.03300882f, -0.04055888f, -0.00053267f, 0.03156585f, 0.01763032f, -0.03634106f, 
    0.05023937f, 0.04717546f, -0.10638333f, 0.08469684f, 0.07385542f, 0.02822419f, 0.03495971f, -0.07577613f, 
    -0.02272955f, -0.02955023f, -0.08990587f, -0.13158651f, 0.04807442f, -0.15793160f, -0.18251619f, 0.05550585f, 
    -0.08234324f, 0.11072065f, -0.09072293f, -0.03538885f, -0.02225456f, -0.02408150f, -0.05858156f, 0.00422448f, 
    0.10082313f, -0.04811773f, -0.07582279f, 0.09945986f, 0.07439377f, 0.09518646f, 0.00513704f, -0.16446795f, 
    -0.04441779f, -0.04083221f, -0.12317967f, -0.03656548f, 0.15450488f, -0.15692902f, -0.04434146f, 0.01982297f, 
    -0.06393277f, -0.00913023f, -0.03746135f, -0.00206935f, -0.01154655f, -0.08854640f, -0.09245998f, -0.09056183f, 
    -0.04550948f, -0.02915627f, -0.23299211f, -0.14268366f, -0.00313147f, 0.04930163f, -0.03058161f, -0.07558424f, 
    -0.04516862f, 0.05912274f, 0.08598320f, -0.02395689f, 0.34515497f, 0.04090913f, 0.16313152f, 0.05967865f, 
    -0.03179546f, -0.10018507f, -0.02465917f, 0.08126235f, -0.00935617f, 0.01697134f, 0.02770189f, -0.13316755f, 
    -0.01855601f, -0.04053868f, -0.00885853f, -0.04153852f, -0.05356937f, -0.12044634f, 0.09027689f, 0.09589504f, 
    0.07481017f, 0.01914205f, 0.03100529f, -0.07262480f, -0.14923385f, -0.02047363f, 0.05280227f, -0.10751034f, 
    0.14262415f, -0.05729967f, 0.07874488f, 0.01080589f, -0.15974899f, -0.06216185f, -0.03650079f, 0.05680170f, 
    0.27060372f, 0.06070661f, 0.13135897f, 0.09282644f, -0.11104316f, -0.05959837f, -0.09813902f, 0.06004678f, 
    -0.02477474f, -0.02208345f, -0.04929219f, -0.06122750f, 0.07327794f, 0.02574470f, -0.01651215f, -0.02735777f, 
    -0.02424020f, 0.05961763f, 0.03936553f, 0.01937314f, -0.10810141f, -0.02165860f, -0.04516470f, -0.00349696f, 
    0.22709201f, -0.16150613f, 0.13083091f, 0.09434211f, 0.02172562f, -0.02617943f, 0.04465361f, -0.00686379f, 
    0.04675211f, -0.01689883f, 0.12354969f, -0.03027601f, 0.40954536f, -0.01857035f, -0.21619233f, 0.09316768f, 
    -0.06981081f, 0.03196860f, -0.04348952f, 0.01724023f, -0.10628655f, 0.05787092f, 0.05465275f, -0.03831756f, 
    0.12968048f, 0.18633825f, 0.09834734f, 0.19341730f, -0.14483871f, 0.00351413f, 0.12432218f, 0.01406246f, 
    -0.00201109f, -0.01305398f, 0.00688110f, -0.08759209f, -0.13644500f, -0.03891547f, 0.15344007f, -0.21611854f, 
    0.03955394f, 0.06784011f, 0.01689815f, 0.03628305f, -0.02755010f, -0.01268452f, -0.03239213f, -0.13088523f, 
    -0.52818447f, -0.07087013f, -0.16291353f, -0.39787814f, 0.03399287f, -0.01587298f, 0.09579647f, 0.00398575f, 
    0.03835553f, 0.02450479f, -0.04645243f, -0.03748491f, 0.29144782f, -0.09504966f, -0.03227147f, 0.03883751f, 
    0.06680132f, 0.11481088f, -0.14185673f, -0.01004707f, -0.05205980f, 0.04389490f, -0.06583180f, -0.04157123f, 
    0.23503421f, -0.05226146f, 0.03227454f, 0.09694934f, -0.04612634f, 0.00873273f, 0.03339496f, 0.02470367f, 
    -0.04906050f, -0.02864764f, -0.07642550f, -0.00456013f, 0.15548643f, -0.17731978f, -0.00864388f, -0.07598967f, 
    0.04053612f, 0.01709820f, -0.05222246f, 0.04297747f, 0.00440875f, 0.05744173f, 0.09981757f, -0.02662459f, 
    0.36424425f, -0.08781361f, -0.05025792f, 0.14792918f, -0.10571600f, -0.11485500f, 0.03926811f, -0.07188690f, 
    -0.03447590f, -0.01047088f, -0.03789025f, -0.01599964f, -0.01806602f, 0.10151437f, 0.07444739f, 0.17764188f, 
    -0.03091360f, -0.18784755f, 0.07595358f, 0.04805626f, -0.11744446f, -0.08674800f, 0.00064774f, 0.03315824f, 
    0.09736547f, -0.04259996f, -0.09230237f, 0.08186646f, 0.01388112f, -0.03820302f, 0.10075054f, 0.04219195f, 
    -0.09838264f, 0.06393005f, -0.06397697f, -0.05115194f, 0.68855202f, -0.10019843f, -0.24768828f, -0.18249230f, 
    0.09103997f, -0.01950734f, 0.11514634f, -0.08716581f, -0.04621291f, 0.08866875f, 0.02588665f, -0.10830643f, 
    0.17502400f, 0.08768986f, -0.03009388f, 0.06773450f, -0.03195633f, 0.12465401f, 0.00721231f, -0.05086893f, 
    -0.12400319f, 0.05443160f, -0.00400297f, -0.08340772f, 0.24135238f, -0.29841778f, 0.06191175f, 0.03452793f, 
    -0.19136493f, -0.08519745f, -0.16514538f, -0.06979216f, 0.01136792f, 0.10206188f, 0.10459901f, -0.01751193f, 
    0.05728487f, 0.10416772f, 0.19296452f, 0.10044344f, -0.09423824f, -0.04017889f, 0.07173758f, 0.04058784f, 
    -0.08469126f, -0.00616441f, 0.05029082f, -0.08614005f, 0.10098383f, 0.10060512f, 0.07429270f, -0.18126342f, 
    -0.02265461f, -0.07020730f, 0.11022861f, 0.03873327f, -0.04501887f, -0.12590526f, 0.04412991f, -0.04834391f, 
    0.01302714f, 0.05582282f, -0.02942564f, 0.01340910f, 0.05254313f, -0.07408394f, 0.04065095f, 0.04981291f, 
    -0.08603466f, 0.00967390f, 0.01578611f, -0.00722034f, -0.04100553f, -0.22126012f, 0.12067305f, 0.10079537f, 
    0.02867901f, 0.03794331f, -0.02321994f, 0.00969632f, -0.05985381f, 0.02585772f, -0.03153925f, -0.09742529f, 
    -0.11342921f, 0.11545679f, -0.09899716f, 0.05884998f, 0.08023652f, 0.03627550f, -0.09456640f, -0.10074954f, 
    -0.07450166f, -0.10917463f, -0.06298639f, -0.06261234f, 0.06937566f, -0.02268179f, 0.04431586f, 0.10142710f, 
    -0.08311422f, -0.15631703f, -0.00283367f, -0.04113789f, -0.06962286f, 0.07664957f, -0.13402060f, 0.13051054f, 
    0.08619135f, -0.06057438f, -0.03038097f, 0.14403056f, -0.04512023f, 0.03264799f, 0.03647439f, 0.02408784f, 
    -0.02168494f, 0.04988092f, -0.02756944f, -0.05050149f, 0.22389507f, 0.05609258f, 0.16744098f, 0.06847780f, 
    -0.04794671f, -0.10990931f, 0.05125358f, 0.00868827f, -0.03999725f, -0.00269476f, -0.00107338f, 0.07788190f, 
    -0.07726379f, 0.05022296f, 0.00094235f, -0.05521473f, -0.10401192f, 0.03699817f, -0.08446741f, -0.02371115f, 
    0.07988849f, -0.00697382f, -0.01050575f, -0.11325150f, -0.06855641f, -0.03698673f, 0.03978362f, -0.01397374f, 
    -0.00271747f, 0.03066328f, -0.02601925f, 0.05290162f, -0.00250140f, -0.05501091f, -0.04415765f, -0.01381769f, 
    -0.01498333f, -0.25335872f, -0.04364977f, -0.17107047f, 0.01841623f, 0.08830772f, -0.08962908f, -0.18702994f, 
    0.04346455f, -0.02226611f, 0.06232409f, -0.06725061f, -0.34312633f, 0.01714065f, 0.08333088f, -0.06262025f, 
    -0.03289324f, 0.01848850f, -0.04653703f, 0.05596643f, -0.06814645f, -0.04046507f, -0.02715109f, 0.07217999f, 
    0.31106782f, -0.00598693f, -0.07804986f, 0.02438288f, 0.08808114f, -0.07182516f, 0.07615674f, 0.08148582f, 
    -0.05508145f, 0.01443555f, -0.02439015f, -0.05912299f, 0.22964782f, -0.08098964f, -0.06430946f, -0.08761746f, 
    0.05239979f, 0.04265915f, -0.04431137f, 0.06578092f, -0.02824243f, -0.10948801f, 0.01978403f, -0.04477397f, 
    -0.18328625f, -0.00652417f, 0.07334115f, -0.07098277f, -0.05606620f, -0.05638350f, -0.02256654f, -0.09030433f, 
    -0.00507458f, 0.00364974f, -0.07976891f, -0.01232641f, 0.16075766f, -0.07330114f, 0.01421856f, -0.11524683f, 
    0.07551225f, -0.09002061f, 0.06201549f, -0.08112754f, -0.00792340f, 0.08351914f, -0.01015562f, 0.00071894f, 
    0.09291358f, -0.06713516f, -0.03601687f, -0.06204984f, 0.09296247f, 0.02226426f, 0.01472757f, -0.02087714f, 
    -0.03638710f, 0.17752217f, -0.04310350f, 0.04230275f, 0.13634811f, 0.05414858f, -0.01112423f, -0.06070120f, 
    -0.04757703f, 0.09982144f, 0.01243390f, -0.01086718f, -0.01404066f, -0.04885137f, 0.06408838f, -0.03686688f, 
    -0.01393765f, -0.11043185f, -0.10532506f, -0.04150920f, 0.00466616f, -0.08313046f, 0.05646478f, -0.02588120f, 
    0.10659162f, -0.00641241f, 0.05610728f, 0.13007279f, -0.47524685f, 0.08388463f, -0.02897442f, -0.08600912f, 
    -0.02933417f, 0.06969374f, -0.06599130f, 0.00307737f, -0.04215987f, -0.06403062f, -0.02925841f, -0.11113364f, 
    0.13291296f, 0.12257919f, 0.08608305f, -0.06317718f, -0.01491466f, -0.11050441f, 0.08670858f, 0.02793542f, 
    -0.01212241f, -0.06301225f, 0.13216545f, -0.04209870f, 0.00019567f, 0.00985316f, -0.02516036f, 0.03630816f, 
    0.08308336f, 0.04849882f, 0.04006477f, -0.00236433f, -0.03199360f, 0.02072723f, 0.02216985f, -0.00474373f, 
    0.09123387f, -0.05984665f, 0.04155686f, 0.06693918f, -0.08580514f, 0.08402273f, -0.11843867f, -0.00442948f, 
    0.09275790f, -0.00611124f, -0.03589686f, -0.07682250f, 0.01733774f, 0.01233177f, 0.10363685f, 0.02564220f, 
    0.04437159f, 0.03047503f, -0.05667314f, -0.02610557f, 0.14031152f, 0.05584091f, -0.08038273f, 0.06761708f, 
    -0.05388121f, 0.01892326f, -0.01570229f, -0.19004026f, -0.04372785f, 0.03963605f, 0.05730523f, -0.03860068f, 
    0.01971194f, 0.00392744f, 0.03049495f, -0.01078716f, -0.20530055f, -0.15849787f, -0.15786994f, -0.23661675f, 
    0.02376586f, -0.05441117f, -0.12140486f, -0.09333802f, 0.00837713f, 0.10174420f, -0.00044379f, 0.08914935f, 
    0.18887858f, 0.09690662f, -0.29198921f, -0.18482611f, 0.01222950f, 0.01513898f, -0.06513041f, -0.03610964f, 
    -0.07531451f, -0.01909990f, 0.00495492f, -0.11524571f, 0.03851797f, 0.02673796f, -0.19885071f, 0.02319221f, 
    -0.02694734f, 0.06054941f, 0.00947968f, -0.07841978f, -0.06354766f, 0.06522653f, 0.03927109f, 0.04575181f, 
    0.11492886f, -0.10943285f, 0.01168746f, -0.09042777f, -0.05698245f, 0.03549579f, -0.09269376f, 0.04701328f, 
    -0.00817962f, -0.13182120f, 0.00880924f, -0.02618128f, -0.00268336f, 0.04574962f, 0.00818647f, -0.14085551f, 
    -0.03671196f, -0.01794050f, 0.09957987f, -0.01130834f, -0.07933904f, 0.14216521f, 0.01612928f, -0.08562677f, 
    0.17647697f, 0.00670368f, 0.05191963f, 0.20438321f, -0.11347234f, -0.00314790f, 0.04644446f, 0.02124672f, 
    0.02961654f, 0.02430140f, -0.11060325f, 0.07535162f, -0.13775255f, -0.23430860f, 0.02388161f, -0.20879048f, 
    0.00551100f, 0.04023096f, 0.00457311f, -0.04267757f, 0.06180742f, -0.00565050f, -0.00425876f, -0.08756568f, 
    0.15533966f, -0.13339274f, -0.02209467f, -0.05074627f, -0.25712863f, 0.01343117f, -0.07090025f, 0.05849792f, 
    -0.02247531f, -0.04144434f, -0.04365077f, 0.03258855f, -0.20761859f, 0.05446148f, 0.05174931f, -0.05035728f, 
    0.06970583f, -0.00827100f, -0.01720877f, -0.00285041f, 0.01393750f, -0.08991902f, -0.04752379f, 0.01606270f, 
    -0.38193193f, -0.23068783f, 0.09827168f, 0.10364363f, -0.15966354f, 0.03629028f, -0.05184298f, -0.12842850f, 
    -0.11968815f, -0.06030227f, -0.16303724f, 0.03800514f, 0.23520154f, 0.05517218f, -0.04445197f, -0.00615503f, 
    0.15651965f, -0.04358288f, -0.04041365f, -0.06730754f, -0.05573524f, -0.01501614f, -0.07763875f, 0.08812318f, 
    0.28215975f, 0.14677510f, 0.04195214f, -0.04861137f, -0.03029163f, 0.00581965f, 0.06535782f, 0.09162794f, 
    0.02332152f, -0.09830078f, -0.01098496f, -0.00862535f, 0.00198695f, -0.16655628f, -0.01357590f, 0.05588758f, 
    0.00194486f, 0.09601282f, 0.01076079f, 0.09073217f, -0.05518950f, 0.08270014f, 0.02817904f, 0.02788005f, 
    0.08179399f, -0.27553543f, -0.24190110f, 0.08145311f, -0.06477554f, -0.00800049f, -0.06011281f, -0.10392874f, 
    -0.02453708f, -0.07429258f, 0.01790156f, 0.06458500f, -0.25585195f, -0.29303181f, -0.02293007f, 0.08293509f, 
    0.04066892f, 0.09215444f, -0.01663973f, -0.13466844f, -0.03145662f, -0.14581069f, 0.01448242f, 0.05226216f, 
    -0.19359882f, -0.05357626f, 0.17794864f, 0.11380269f, 0.06889344f, 0.15265512f, 0.05343932f, -0.09797028f, 
    -0.03892789f, -0.00025203f, -0.01387182f, -0.17365877f, -0.04683303f, 0.06965144f, 0.01156043f, 0.15000872f, 
    -0.14782192f, -0.12387710f, 0.02645650f, -0.06513651f, -0.09087928f, -0.02166016f, -0.03417577f, -0.02582511f, 
    0.35321867f, 0.13411616f, 0.00421100f, 0.16571186f, 0.03733567f, 0.06909224f, 0.03986243f, -0.00294047f, 
    0.00405871f, 0.02411190f, 0.07865112f, -0.00027285f, 0.01594288f, -0.04200403f, 0.04067069f, 0.02638465f, 
    -0.00252402f, -0.00125728f, 0.06134183f, -0.02608056f, 0.05968696f, 0.05266223f, 0.04547703f, -0.07075899f, 
    -0.18457977f, -0.04738674f, -0.16363299f, 0.06296857f, 0.02232233f, 0.10819709f, 0.00233052f, 0.14911343f, 
    -0.01474298f, 0.10886584f, 0.05706254f, -0.01130553f, -0.10018516f, -0.04978094f, -0.00132178f, -0.11922126f, 
    0.03404876f, -0.06611902f, 0.04278835f, 0.03759144f, 0.00797466f, -0.00438401f, 0.00970749f, -0.08082951f, 
    0.13371783f, 0.02739662f, 0.10919330f, -0.00119544f, -0.06252643f, 0.06429236f, 0.07181233f, 0.13836594f, 
    0.04730595f, 0.05807314f, 0.05397185f, 0.01166965f, -0.40488231f, -0.18363161f, -0.11058301f, -0.01562249f, 
    -0.02702540f, -0.12630042f, -0.03323579f, 0.07755923f, -0.06137369f, 0.05151692f, 0.02080904f, -0.11098305f, 
    0.04091419f, 0.12534334f, -0.10557047f, 0.00831548f, -0.11830026f, -0.17801462f, 0.00763682f, -0.12342161f, 
    0.04860468f, -0.02187965f, 0.08653609f, 0.01230218f, -0.40463099f, -0.21423621f, -0.07477426f, 0.07271756f, 
    -0.04367899f, 0.01588909f, -0.05519792f, -0.00377582f, -0.05133415f, -0.11548696f, 0.04158029f, -0.08411656f, 
    0.08388454f, 0.04592548f, 0.00095962f, 0.10980726f, -0.02237626f, -0.06538735f, 0.08848223f, -0.08745533f, 
    -0.01647060f, 0.00276963f, 0.04437953f, -0.03964705f, -0.08233076f, 0.25938743f, 0.11695498f, -0.16389886f, 
    -0.05549068f, 0.03370425f, -0.07803451f, 0.12639861f, 0.00824262f, -0.01122285f, -0.02437607f, -0.03289032f, 
    0.07888846f, -0.13554999f, 0.01501644f, -0.15567914f, -0.00098152f, 0.10350923f, -0.09706599f, -0.02245951f, 
    -0.10525201f, -0.00238825f, -0.02452529f, -0.00968527f, -0.01238542f, 0.10403462f, 0.06305180f, 0.07369389f, 
    0.09642050f, 0.00449953f, 0.00743593f, 0.10140870f, 0.03129065f, -0.02297173f, -0.04739378f, 0.01893219f, 
    0.24683484f, -0.08045312f, 0.03000743f, 0.11238568f, -0.09873307f, 0.01708194f, -0.02406542f, 0.12904887f, 
    0.03658957f, 0.05576936f, -0.12990603f, 0.00478036f, -0.27483165f, 0.03607471f, 0.16677508f, 0.04348886f, 
    0.05365042f, 0.10064380f, 0.04078517f, -0.03537251f, 0.07107662f, 0.09028240f, -0.02778706f, -0.05167950f, 
    0.44248965f, -0.06043635f, 0.07095050f, 0.15989763f, 0.16932409f, -0.04562022f, 0.00854542f, 0.00048767f, 
    0.05415735f, -0.06262911f, -0.04035042f, -0.08478925f, 0.33016703f, -0.06299780f, -0.36757237f, 0.11911733f, 
    0.10513543f, 0.00505441f, 0.08809353f, 0.00087808f, 0.03819564f, 0.04708339f, 0.02916363f, -0.03404644f, 
    0.06968776f, -0.06021885f, -0.00413090f, -0.05597138f, -0.10842661f, -0.08693179f, 0.03479130f, -0.02500280f, 
    -0.13672878f, -0.08123308f, -0.08235306f, -0.00768636f, -0.05165085f, -0.18207911f, -0.12572739f, -0.16282427f, 
    -0.13978630f, 0.01418729f, -0.04140874f, 0.01729707f, -0.10949983f, 0.01194535f, -0.05707559f, 0.07712270f, 
    0.17217368f, -0.18027793f, 0.12427001f, -0.02037571f, -0.06033376f, 0.01555349f, 0.12011008f, -0.07988473f, 
    0.01998360f, -0.06033530f, -0.07046501f, 0.04995849f, -0.00054145f, 0.09797060f, 0.30628553f, 0.06184288f, 
    0.02512524f, -0.09978329f, 0.07335969f, -0.09758681f, -0.06397372f, 0.01124046f, -0.11378568f, -0.00410224f, 
    -0.35318539f, -0.11905726f, -0.22367908f, 0.14467031f, -0.03114060f, -0.10199139f, 0.02768795f, 0.04288410f, 
    -0.05072277f, 0.09295248f, -0.08354073f, 0.04254708f, 0.15994172f, 0.04693701f, 0.04089070f, -0.02293243f, 
    -0.09082138f, -0.02780082f, 0.01067074f, 0.13072257f, -0.00683024f, -0.05352481f, -0.04026679f, -0.02079912f, 
    -0.12246608f, -0.03631625f, 0.01433428f, -0.14667635f, -0.10592857f, 0.15322743f, -0.04593856f, 0.12944870f, 
    0.00239552f, -0.03725355f, -0.05697010f, 0.03154086f, -0.29866996f, -0.02407230f, 0.12596303f, 0.04154448f, 
    -0.05728770f, 0.06311882f, -0.02414095f, 0.07841478f, -0.07237370f, 0.02923650f, 0.03766766f, -0.01762719f, 
    -0.11849258f, -0.16853148f, -0.14902635f, -0.08772736f, -0.02295306f, 0.04501266f, -0.03890064f, -0.03280586f, 
    -0.15168174f, 0.04496709f, -0.04854944f, 0.00403220f, -0.14799945f, 0.14836001f, 0.00815892f, 0.03599282f, 
    -0.06084064f, 0.06930047f, -0.00076116f, 0.04363615f, 0.02681231f, -0.11610008f, -0.04483216f, -0.02253676f, 
    -0.02960343f, -0.00190012f, -0.17918886f, 0.27123764f, -0.03205628f, -0.01340948f, -0.02222059f, -0.03885272f, 
    0.05129901f, -0.08626830f, -0.06414310f, -0.18201680f, 0.04023388f, -0.02591697f, -0.03051762f, 0.11137927f, 
    0.02106253f, -0.10878836f, 0.06533093f, -0.01310265f, -0.10910355f, 0.12863338f, -0.02094819f, 0.08285544f, 
    0.11155816f, -0.09601307f, 0.06464944f, -0.10143274f, -0.00830440f, -0.09553671f, 0.03356065f, -0.01357689f, 
    -0.05763229f, 0.00624192f, 0.06015263f, -0.05781674f, -0.04633592f, -0.00192527f, -0.05000433f, -0.17451183f, 
    -0.08804419f, -0.04890074f, -0.01918590f, -0.03117139f, -0.05602927f, 0.00272600f, -0.02910917f, 0.11266831f, 
    0.17081869f, -0.02333969f, -0.05509283f, -0.06001377f, -0.00913215f, 0.03840391f, -0.01717135f, -0.03260841f, 
    -0.05670802f, 0.01666069f, -0.05813828f, 0.00427888f, -0.25493243f, -0.20320910f, -0.17960387f, -0.09789550f, 
    -0.11607590f, -0.01628644f, 0.09930571f, -0.00981067f, 0.01558732f, -0.02091082f, 0.05438302f, 0.07095961f, 
    0.12875880f, 0.17237258f, 0.10030869f, 0.14399369f, 0.08435322f, -0.09076061f, -0.03588283f, -0.07983369f, 
    -0.06252875f, 0.14828515f, 0.02884583f, -0.08425624f, 0.30985174f, 0.10441814f, -0.07978944f, 0.08270595f, 
    -0.00149969f, 0.09265006f, 0.10384119f, -0.01614840f, 0.03620807f, -0.09752677f, 0.06149602f, 0.04076378f, 
    -0.11624800f, -0.07159852f, -0.10700290f, -0.07241596f, -0.03500877f, -0.01656608f, 0.00400100f, -0.09973653f, 
    0.02014725f, -0.10323954f, -0.03938893f, -0.04709250f, 0.10463488f, 0.05423315f, 0.16547512f, -0.10060497f, 
    0.00212705f, 0.13893890f, 0.10495868f, -0.15002723f, -0.01856925f, -0.07971936f, 0.06173353f, -0.08690955f, 
    -0.14031546f, -0.21586007f, 0.02454858f, -0.03428568f, -0.03981561f, -0.02151600f, -0.11265058f, 0.09767034f, 
    0.00603044f, 0.04186890f, -0.02090300f, 0.02352079f, 0.13377726f, -0.11606099f, -0.27638826f, -0.01550031f, 
    -0.06302759f, -0.00214210f, -0.04616798f, -0.05757512f, 0.00732518f, -0.03046910f, 0.02681835f, -0.03525374f, 
    0.09936110f, -0.08277093f, -0.21637093f, 0.03479586f, 0.06847657f, 0.06278539f, -0.05171856f, -0.08467626f, 
    0.12305737f, -0.07569373f, -0.00785445f, 0.05019922f, -0.19661936f, 0.12265122f, 0.12008772f, 0.18306386f, 
    0.02556643f, 0.14502676f, -0.01880937f, -0.08002678f, 0.05336779f, 0.00278511f, 0.03564713f, -0.08959369f, 
    -0.22508468f, 0.08499647f, -0.11725224f, -0.13322248f, -0.01852317f, -0.07658488f, 0.21308625f, -0.02106665f, 
    0.01642679f, -0.06998676f, -0.02037591f, 0.02908724f, 0.21927391f, -0.21336043f, -0.21343526f, -0.02235542f, 
    -0.03074341f, 0.12421679f, -0.11572991f, 0.14678544f, 0.00733822f, 0.05911164f, -0.03675573f, -0.03762104f, 
    -0.15660828f, -0.30009520f, -0.32247826f, -0.08334021f, -0.10901985f, 0.04798786f, 0.04348038f, 0.08436982f, 
    -0.14540176f, 0.04432947f, -0.04068074f, 0.00265547f, -0.15213904f, -0.41883367f, -0.09570394f, 0.16586165f, 
    -0.05822733f, 0.07143080f, 0.07753998f, -0.02754902f, 0.05438171f, -0.08492156f, 0.06345305f, -0.02910621f, 
    0.03993543f, 0.04984252f, -0.04456553f, 0.05320536f, 0.01441031f, -0.04521249f, -0.06131069f, 0.01444355f, 
    -0.00780760f, -0.05604462f, 0.09883940f, 0.00617166f, -0.25065321f, -0.38360557f, 0.14745027f, 0.08758791f, 
    -0.05142172f, 0.04709307f, 0.00814670f, 0.04041864f, 0.01034166f, -0.14111573f, 0.02056520f, -0.01164755f, 
    -0.03613653f, -0.15242730f, -0.02542981f, 0.03487032f, -0.03674340f, -0.06417296f, 0.04014530f, 0.00410406f, 
    0.05211316f, 0.05738614f, 0.05680965f, -0.05750513f, 0.24705631f, 0.22710289f, -0.08506480f, 0.01682265f, 
    -0.05747595f, -0.01515535f, 0.02649140f, 0.05832115f, 0.05987341f, 0.00983788f, 0.07638022f, -0.01602966f, 
    -0.39204288f, 0.32088360f, -0.02643925f, 0.12376471f, 0.02646331f, 0.08588235f, -0.00261324f, -0.01377201f, 
    -0.04075580f, -0.00373876f, 0.01455727f, -0.05121811f, 0.18500899f, 0.16162871f, 0.06501476f, 0.03424358f, 
    -0.07019270f, 0.00685115f, -0.02702214f, 0.03669679f, -0.11981389f, 0.11492123f, -0.07598546f, 0.00462178f, 
    0.06589416f, -0.04568321f, -0.05486408f, -0.09100006f, -0.06977149f, -0.01972793f, -0.03568039f, -0.01394617f, 
    -0.03671097f, -0.04063698f, 0.00940066f, -0.00976583f, -0.27419829f, -0.01598767f, -0.05340457f, 0.01793794f, 
    -0.09930386f, -0.00562670f, -0.02789123f, 0.03453449f, -0.00110374f, 0.06847507f, 0.04035026f, 0.02747122f, 
    0.01233312f, -0.01214126f, 0.00280380f, 0.00120823f, -0.05639908f, 0.01351509f, 0.11005364f, 0.03630122f, 
    -0.07638524f, 0.06070345f, 0.00196659f, 0.09302267f, 0.41425529f, 0.12505254f, 0.10301283f, 0.15987688f, 
    -0.01157092f, 0.04846195f, -0.10592853f, 0.09828781f, -0.03857240f, 0.03602114f, -0.04611742f, -0.04814649f, 
    -0.03775839f, 0.00519986f, -0.01058736f, -0.07205904f, -0.14095281f, -0.04010356f, -0.08667827f, 0.01589387f, 
    0.09012809f, -0.07793358f, 0.06543297f, 0.05622854f, -0.43244436f, -0.41470745f, 0.08081104f, 0.07077458f, 
    -0.11978264f, 0.00601784f, 0.12206239f, -0.17891669f, -0.00243310f, -0.22879015f, 0.16412909f, 0.05084304f, 
    0.20341985f, 0.08781012f, -0.13654080f, 0.21842510f, 0.01039362f, 0.00206331f, 0.02621889f, 0.08445344f, 
    -0.04917262f, 0.02291173f, -0.08498506f, -0.03375816f, -0.27926078f, -0.03729551f, 0.10786434f, 0.02184874f, 
    0.08612942f, 0.09711108f, -0.04056223f, -0.03036753f, 0.04962936f, 0.12390465f, -0.09041999f, 0.02048624f, 
    0.17043911f, -0.08452573f, -0.00305925f, 0.00889355f, 0.06635629f, -0.05725691f, 0.10128136f, 0.04646753f, 
    0.02244935f, 0.02652131f, 0.03907906f, 0.00945084f, -0.19697323f, -0.01714721f, -0.04301291f, 0.08536151f, 
    0.01366006f, -0.01230477f, -0.00246834f, 0.05005778f, -0.07300971f, 0.04148479f, 0.06628200f, 0.06427761f, 
    -0.13602430f, -0.22134934f, 0.05999340f, 0.14056602f, -0.12677622f, -0.00048510f, -0.04874953f, -0.09401549f, 
    0.12112797f, 0.09752573f, -0.04408071f, -0.05680981f, -0.01997584f, 0.12876740f, -0.07869531f, 0.14634624f, 
    0.06019887f, -0.01507727f, 0.00983444f, 0.09782147f, 0.04100822f, -0.06801871f, -0.08099183f, 0.00823542f, 
    -0.21856907f, -0.11857873f, 0.14243220f, 0.12483341f, 0.05351370f, 0.00947976f, -0.03082049f, -0.13915773f, 
    0.03049576f, -0.00612604f, 0.02052975f, -0.09004007f, 0.02456331f, -0.09297078f, -0.15104645f, 0.17787123f, 
    -0.04914767f, -0.05834395f, 0.03325167f, 0.02807355f, 0.07642777f, -0.02081326f, 0.05214985f, 0.00284876f, 
    -0.09897549f, 0.08804970f, -0.05941084f, -0.04302395f, 0.03152598f, 0.09000855f, -0.04954400f, 0.06103625f, 
    -0.09180280f, 0.11009157f, 0.06438979f, -0.01727749f, -0.06282528f, 0.07258978f, 0.07295001f, -0.27551001f, 
    0.10235298f, -0.12010852f, -0.05125587f, -0.00875285f, 0.05158347f, 0.02785850f, 0.01526922f, -0.11714103f, 
    0.11405819f, 0.05105888f, 0.19075666f, -0.15179615f, 0.00227638f, 0.04503696f, 0.14375407f, 0.06264425f, 
    0.06005374f, -0.02113626f, 0.01373023f, 0.01724942f, -0.67311150f, -0.04082325f, 0.00302786f, 0.03087192f, 
    0.01191902f, 0.07259536f, 0.04608893f, -0.00017866f, 0.01049316f, -0.04328302f, 0.04417639f, 0.04083109f, 
    0.13728790f, 0.06801234f, -0.33037055f, -0.09908922f, -0.02991096f, -0.02216350f, -0.01337275f, -0.03726818f, 
    -0.13119997f, -0.06850820f, 0.10362520f, 0.06570832f, -0.02380082f, -0.12871157f, -0.07250547f, -0.13658494f, 
    0.03471031f, 0.06722475f, -0.05490046f, 0.11803583f, 0.07139974f, -0.01513855f, 0.09562764f, 0.05664632f, 
    -0.19499016f, -0.01160932f, -0.04647434f, 0.07431263f, 0.07115711f, 0.03798322f, 0.01320503f, 0.02842888f, 
    -0.03381301f, -0.08351886f, 0.02590819f, -0.04491194f, -0.30268285f, -0.11232404f, 0.07336550f, -0.10419521f, 
    -0.08271791f, -0.05670640f, -0.02388450f, 0.05169081f, 0.20925774f, -0.05183251f, 0.00453450f, -0.12451021f, 
    -0.40773219f, 0.14372367f, -0.06221980f, -0.01776273f, 0.00003485f, -0.04263388f, 0.01393831f, 0.06884929f, 
    -0.02991942f, -0.07901422f, 0.05717510f, -0.07762545f, 0.31739739f, 0.38325760f, -0.08008137f, -0.04416764f, 
    -0.12858498f, 0.03936258f, 0.08244944f, -0.08292253f, -0.01813247f, 0.03242271f, -0.08507648f, -0.00294164f, 
    -0.33169228f, 0.08730403f, 0.11928905f, 0.08036706f, -0.04944767f, -0.00659719f, -0.08039370f, 0.03783620f, 
    0.00666280f, 0.03298210f, 0.07287575f, 0.08841078f, 0.15926518f, -0.25873792f, 0.00973877f, 0.09473050f, 
    -0.06188190f, 0.04782849f, -0.02981285f, -0.03009068f, 0.04346748f, 0.11381757f, 0.08928930f, 0.07209510f, 
    -0.01053532f, -0.06506572f, 0.08548507f, 0.10833034f, -0.00774931f, 0.08632241f, 0.11111733f, -0.10018732f, 
    -0.07466298f, 0.05368030f, 0.08164489f, -0.00659843f, -0.31402943f, -0.03458633f, 0.18363070f, 0.02127373f, 
    -0.04131822f, -0.05909709f, -0.11023539f, -0.08366256f, 0.05759095f, -0.00552428f, -0.08796842f, 0.00069480f, 
    -0.01221169f, 0.32185552f, -0.17356381f, -0.34445372f, 0.00465857f, -0.12531142f, 0.13154222f, 0.01919009f, 
    0.02250535f, -0.04948226f, -0.02864517f, -0.00104160f, -0.06105819f, 0.13385005f, 0.01954867f, -0.12614629f, 
    -0.10292677f, 0.09219616f, -0.00635396f, -0.05265679f, -0.05229868f, -0.10773104f, -0.08057396f, 0.06014942f, 
    0.07394779f, 0.05876951f, 0.00825438f, 0.11834600f, 0.01213895f, 0.01854803f, 0.00021381f, 0.16043104f, 
    0.03990722f, 0.07254414f, 0.02907068f, -0.12231479f, -0.03840543f, -0.02386933f, 0.05258567f, 0.15292208f, 
    0.00975660f, 0.01545191f, -0.00972460f, -0.03851670f, 0.16715984f, 0.01375871f, 0.06110815f, 0.02822809f, 
    0.01821329f, 0.11585180f, -0.05719741f, 0.05963386f, -0.06536597f, -0.01521621f, -0.02191778f, -0.08382085f, 
    0.02450353f, 0.00084408f, 0.08939505f, 0.02189405f, -0.25647339f, -0.10690579f, 0.02457673f, -0.05755045f, 
    -0.03058032f, -0.11000674f, -0.01483465f, 0.01649646f, -0.02177534f, -0.06990333f, -0.08622529f, 0.00102905f, 
    0.12240811f, -0.05490335f, -0.01921090f, -0.05200731f, -0.13946354f, 0.07741520f, -0.01111938f, 0.10968977f, 
    0.02193085f, 0.00415153f, 0.06834220f, 0.00616255f, -0.30059853f, -0.04793189f, 0.02010277f, -0.11028695f, 
    0.14331476f, 0.00417560f, -0.13065743f, 0.24616031f, -0.12521082f, 0.03331064f, 0.05660880f, -0.01306190f, 
    0.00407719f, 0.03128468f, 0.19404767f, 0.11795052f, 0.00234973f, 0.15164264f, 0.01995532f, 0.03119102f, 
    0.06849132f, -0.00451143f, 0.12546253f, -0.04712877f, -0.17439047f, 0.13505530f, 0.09901188f, -0.07527274f, 
    -0.05369736f, -0.10054211f, -0.08672544f, -0.09173928f, 0.05726605f, -0.11802332f, -0.01323655f, -0.03558855f, 
    -0.11814995f, -0.04460450f, 0.19504675f, -0.03867023f, -0.03638456f, -0.05215175f, 0.01127686f, 0.00095486f, 
    -0.07150909f, 0.08145205f, 0.02450848f, 0.01915278f, 0.05833827f, 0.00510509f, -0.11714227f, 0.13212401f, 
    -0.02576101f, 0.00456851f, -0.00098406f, 0.03591824f, -0.03373183f, 0.06792585f, 0.05929504f, -0.03365224f, 
    -0.04569897f, 0.13210174f, 0.27162293f, 0.05837423f, 0.01895060f, -0.01410841f, -0.14530334f, 0.00894919f, 
    0.08695154f, -0.10337973f, -0.04870137f, -0.20173056f, -0.35512736f, 0.00134228f, 0.02134781f, 0.12857904f, 
    0.13288547f, -0.14434801f, -0.04851728f, -0.00589047f, 0.01335524f, -0.13442114f, -0.16230309f, 0.05441992f, 
    -0.28801060f, -0.03469827f, 0.06111472f, 0.15422970f, 0.04616261f, 0.05015238f, -0.01105117f, 0.09761462f, 
    -0.10569657f, 0.09713367f, 0.07145099f, 0.05256122f, -0.11796399f, 0.04517895f, 0.17193268f, 0.24415188f, 
    0.10135073f, -0.04308821f, -0.03986029f, -0.03291559f, -0.03985905f, 0.07349014f, 0.01391431f, 0.00910250f, 
    -0.20818508f, 0.01937617f, 0.04755156f, -0.16000368f, 0.00888549f, -0.03852120f, -0.06289500f, -0.02889201f, 
    -0.00733849f, -0.06783554f, -0.06721730f, 0.10518675f, -0.13318746f, 0.12643482f, -0.18942015f, -0.07811023f, 
    0.01960447f, -0.09042380f, 0.07687014f, 0.15726134f, -0.10621443f, 0.07243579f, -0.10490837f, 0.01553313f, 
    0.20667873f, 0.07183057f, -0.10477079f, 0.03482954f, -0.13335526f, -0.05225976f, 0.13291192f, 0.00624289f, 
    -0.08791604f, -0.03513921f, 0.04423036f, -0.06235695f, 0.08272965f, -0.02717607f, -0.08840518f, 0.03455485f, 
    -0.02092810f, 0.07419001f, 0.06563309f, -0.07308813f, 0.05965789f, -0.02162375f, -0.03373083f, -0.05792296f, 
    0.15147600f, -0.20336618f, 0.06639525f, 0.24314956f, -0.05882055f, 0.04440765f, 0.15472095f, -0.04370072f, 
    -0.04009601f, 0.02462027f, 0.05445672f, -0.02812991f, -0.02656575f, 0.01920678f, -0.04913539f, 0.10949635f, 
    0.10232295f, 0.04168042f, 0.02485126f, 0.00225394f, 0.10915706f, 0.00071780f, -0.01644141f, -0.05219257f, 
    -0.00321602f, 0.04908169f, -0.04160538f, -0.12726302f, 0.13587192f, -0.00300967f, -0.03704613f, 0.07284802f, 
    0.08979104f, -0.02726274f, 0.03976101f, -0.05256122f, 0.00858248f, -0.05366983f, -0.00963460f, 0.10873262f, 
    -0.26313373f, 0.03238024f, -0.11284292f, 0.03483447f, 0.00791585f, -0.03128115f, -0.12392674f, 0.04859050f, 
    0.15775083f, 0.00665823f, 0.06473926f, 0.18207076f, -0.06877599f, -0.01580106f, -0.02399313f, 0.08186121f, 
    -0.03693794f, -0.04643182f, -0.01879126f, 0.13752796f, -0.40104818f, -0.14055325f, 0.19061594f, 0.13483696f, 
    0.07972048f, -0.09401235f, -0.07801827f, -0.10591364f, 0.03063418f, 0.01662622f, -0.07522856f, -0.07038690f, 
    0.38128287f, -0.27533305f, -0.22635268f, -0.24395077f, 0.02626958f, -0.02591427f, 0.04464884f, -0.15291005f, 
    -0.11785474f, -0.16060349f, 0.03899646f, -0.07893086f, -0.13285361f, -0.09438258f, 0.08882978f, 0.02221793f, 
    -0.10176907f, 0.06147560f, 0.01560204f, -0.11908819f, 0.08882125f, 0.05753318f, -0.05925955f, 0.04068204f, 
    -0.19096686f, -0.20426841f, 0.08449771f, -0.07465944f, 0.00015786f, -0.03024031f, -0.00397108f, -0.00581960f, 
    0.04868675f, 0.02845307f, -0.03643391f, -0.17086320f, -0.05304024f, -0.07782689f, 0.03241656f, 0.14072916f, 
    -0.04954677f, -0.07542416f, 0.09314113f, -0.01650263f, 0.04531096f, -0.03836453f, 0.04493326f, -0.11494832f, 
    -0.22736415f, 0.11142078f, -0.17697346f, -0.22365533f, -0.02275764f, -0.10705024f, 0.10691431f, 0.07697262f, 
    0.02061487f, -0.05815116f, 0.02300938f, 0.09041730f, 0.02352590f, 0.14836518f, -0.11028167f, -0.04066045f, 
    0.03172319f, 0.01485824f, 0.00953848f, 0.00011197f, -0.09552210f, -0.03012525f, 0.04108220f, 0.05922576f, 
    -0.23474194f, -0.14287220f, 0.08142892f, -0.19009741f, 0.09829149f, 0.00758011f, -0.02765350f, -0.03036059f, 
    0.07593902f, -0.06512606f, -0.05076937f, -0.04181231f, 0.16701038f, -0.15994212f, 0.05641055f, -0.24485907f, 
    0.02131139f, 0.08310503f, 0.00382002f, 0.05201644f, -0.02877008f, -0.01462917f, 0.06087101f, 0.09917989f, 
    -0.27899653f, 0.05680903f, 0.23159155f, -0.06437209f, 0.01437813f, -0.01696882f, 0.06828446f, -0.01243989f, 
    0.02531909f, 0.13231967f, 0.03586164f, -0.08238414f, 0.43418339f, 0.07549538f, -0.03405895f, -0.12820920f, 
    0.01177124f, -0.04941634f, 0.04353932f, -0.03211531f, 0.06633300f, -0.07671934f, -0.03653855f, 0.13411033f, 
    -0.10998751f, 0.14271031f, 0.08603217f, -0.02819430f, 0.03978265f, -0.00167472f, -0.05436051f, 0.13196021f, 
    -0.00845284f, -0.15248142f, -0.07586467f, -0.03571750f, -0.33428007f, 0.04390321f, -0.03913566f, -0.06836727f, 
    0.12503755f, 0.05040518f, -0.01165018f, 0.10262471f, -0.07423225f, 0.11407505f, 0.02367494f, 0.07478752f, 
    -0.33798981f, -0.08629952f, 0.15050916f, 0.17696494f, 0.04946185f, 0.00542396f, 0.05412260f, 0.05041086f, 
    0.01854342f, -0.00146493f, 0.08688010f, 0.06476637f, -0.23999536f, 0.08357542f, 0.03148253f, 0.03417009f, 
    -0.04518839f, 0.06762782f, -0.16105692f, -0.01828676f, -0.11380869f, -0.15322436f, -0.00673053f, 0.00572555f, 
    0.07291389f, -0.07526319f, 0.11075386f, 0.29401192f, 0.06027464f, 0.04575695f, 0.08001859f, 0.13295183f, 
    0.04108439f, 0.13050827f, 0.00880751f, 0.01038630f, 0.28672865f, 0.02497248f, -0.15043706f, -0.07097301f, 
    0.04513572f, -0.04081623f, 0.02489580f, -0.00295003f, 0.03446384f, 0.03413516f, 0.12437299f, -0.06871241f, 
    -0.06926198f, 0.01750404f, -0.27927715f, -0.16624519f, 0.06875029f, 0.03675705f, 0.05126261f, 0.09717716f, 
    0.11930611f, -0.17495631f, 0.05505423f, -0.00909429f, -0.17825431f, 0.05183908f, -0.08983899f, 0.03245005f, 
    -0.07562377f, -0.02548338f, 0.04079708f, -0.05664291f, -0.11337894f, -0.08458010f, -0.00663954f, 0.05069640f, 
    -0.15356363f, -0.08039460f, 0.06314037f, 0.10541431f, 0.07562444f, -0.01032715f, -0.04855407f, 0.10991879f, 
    0.03448735f, 0.01712107f, -0.00619060f, -0.06081830f, 0.27549824f, -0.03757400f, 0.00196894f, -0.02712560f, 
    -0.06835397f, -0.03225578f, -0.11426711f, 0.00119172f, -0.14596988f, -0.12685041f, -0.10850755f, -0.22481339f, 
    0.02208303f, 0.09010269f, 0.05962451f, 0.10347714f, 0.05495557f, -0.07632268f, -0.06470980f, 0.11169126f, 
    -0.04608293f, -0.05418267f, -0.00910764f, -0.04408678f, -0.00882843f, 0.06841215f, 0.04070733f, -0.17381780f, 
    0.07791973f, -0.00371728f, 0.03793987f, -0.03863732f, -0.04210771f, 0.09589844f, 0.08697166f, 0.04697321f, 
    0.09698418f, -0.04464340f, 0.01665943f, 0.04298794f, -0.05955412f, 0.09085640f, 0.04047439f, 0.07533247f, 
    -0.12465208f, 0.00308181f, 0.15227816f, 0.20172331f, 0.04131661f, -0.07298429f, 0.02828861f, -0.13948268f, 
    0.07480144f, 0.05055806f, 0.00355642f, -0.14990503f, -0.08717075f, 0.01020983f, -0.02433952f, -0.00079872f, 
    -0.03428167f, -0.09103416f, 0.08660392f, 0.16445561f, -0.14310357f, -0.03806143f, 0.02901435f, -0.04230610f, 
    0.01657572f, -0.02563802f, 0.05903883f, 0.06296293f, -0.17346410f, -0.08850505f, 0.07189152f, 0.09314928f, 
    0.08412971f, -0.08330244f, -0.11085672f, -0.04360815f, 0.05795235f, 0.06388551f, -0.00067486f, 0.11459956f, 
    -0.00677464f, 0.04116939f, 0.11218823f, 0.06284650f, -0.02401448f, -0.03822576f, -0.12019108f, 0.15710743f, 
    -0.02499147f, 0.14004700f, -0.08828325f, -0.14764473f, -0.46301830f, 0.05519438f, -0.12275161f, 0.00308716f, 
    0.13749981f, -0.04824047f, -0.01022876f, -0.24264885f, 0.04347168f, -0.24102351f, 0.00108831f, -0.01443641f, 
    -0.15028733f, 0.10948822f, -0.02565009f, -0.16875204f, 0.09779064f, -0.04083557f, -0.05317361f, -0.14816712f, 
    0.04918366f, 0.01065681f, -0.00808069f, 0.06479158f, 0.18517382f, 0.10845199f, 0.20488667f, 0.17409003f, 
    0.15267496f, -0.02223204f, 0.02873689f, -0.15531674f, 0.04910564f, -0.02923626f, -0.09218118f, 0.13679866f, 
    -0.65859681f, -0.21399324f, -0.25553897f, -0.15069045f, -0.05713406f, 0.08299994f, 0.03595234f, 0.01464387f, 
    0.14456289f, 0.15738127f, 0.09854747f, -0.11060129f, 0.08917659f, -0.00399642f, 0.10870413f, -0.10446646f, 
    -0.06337959f, 0.04805280f, 0.05227666f, -0.00158882f, -0.02978523f, 0.04220132f, 0.12440310f, 0.15386267f, 
    -0.35499084f, 0.23269269f, -0.12092166f, -0.33620438f, 0.08572245f, 0.05762867f, -0.04768288f, 0.06857579f, 
    -0.10132189f, 0.03979003f, -0.10958789f, 0.03718757f, -0.01747192f, -0.14638858f, 0.17109132f, 0.18945098f, 
    -0.10182712f, -0.11336135f, 0.05228708f, 0.00881181f, 0.11855811f, 0.08602129f, -0.06723013f, 0.07544633f, 
    0.02128454f, -0.09187391f, -0.19874370f, -0.01041065f, 0.07381972f, -0.11992920f, -0.00483699f, -0.19262430f, 
    0.05083677f, 0.01164965f, -0.03065288f, 0.07498050f, -0.14891742f, 0.06062564f, 0.05297675f, 0.00226906f, 
    -0.01176490f, -0.17933784f, -0.05768615f, -0.13943176f, 0.02747712f, 0.01644782f, -0.06487847f, -0.08595383f, 
    -0.11418627f, 0.05148014f, 0.08754079f, 0.19036737f, 0.02428297f, -0.20701766f, 0.04221834f, -0.00171964f, 
    0.01234405f, 0.10869073f, 0.05278259f, 0.00013471f, -0.00062609f, 0.08536784f, 0.02343384f, -0.29410645f, 
    0.09294073f, 0.01710352f, 0.12357852f, 0.02337581f, -0.02303194f, -0.05800423f, 0.10304552f, -0.01615437f, 
    -0.28950003f, -0.37564570f, 0.12973461f, -0.06268446f, 0.07757347f, 0.12726712f, -0.00616096f, -0.06626025f, 
    -0.07758228f, 0.00638683f, 0.03628039f, 0.06660168f, -0.08854564f, 0.02660579f, 0.19120219f, -0.02113047f, 
    -0.00264972f, 0.02647824f, 0.10136414f, 0.02961755f, 0.04221866f, -0.08575783f, 0.08154068f, -0.11623181f, 
    -0.44221976f, -0.22541623f, -0.12843984f, 0.01104381f, 0.02341870f, 0.09583742f, -0.05810126f, -0.04285724f, 
    0.09226532f, 0.03367357f, 0.01625140f, 0.09401213f, 0.16290860f, 0.05971052f, 0.01884518f, -0.05408913f, 
    -0.08069439f, 0.04311360f, -0.11979742f, -0.18756016f, -0.10942834f, 0.04038204f, -0.07249121f, 0.04790269f, 
    -0.03480903f, 0.10312036f, 0.01337380f, -0.01586137f, -0.03740509f, -0.04287132f, -0.15794039f, 0.03155862f, 
    0.03540391f, -0.10823513f, -0.00577797f, 0.07816618f, -0.04298092f, 0.05262686f, 0.01167721f, -0.06271826f, 
    0.04115623f, 0.05088224f, -0.08112508f, 0.05317914f, -0.00392650f, -0.09049548f, 0.00485710f, 0.07273417f, 
    0.02218734f, 0.10409979f, 0.06683998f, -0.09048359f, 0.17059797f, -0.16046593f, 0.08770010f, -0.07221540f, 
    -0.06653696f, 0.03512577f, -0.06628040f, 0.00973382f, -0.19357550f, 0.29953608f, -0.14256682f, -0.13677242f, 
    0.10623499f, 0.09494565f, 0.27435905f, 0.11421978f, 0.05176871f, 0.11175299f, -0.15107018f, -0.05121448f, 
    0.11984533f, -0.18631984f, -0.12698483f, 0.05833622f, -0.01136870f, -0.26276839f, -0.08310930f, -0.03153459f, 
    -0.05534143f, 0.03772748f, -0.06620701f, -0.06645674f, -0.13523562f, -0.10449045f, 0.05153712f, 0.00404337f, 
    -0.01451631f, -0.05970665f, 0.06024953f, 0.03996212f, -0.03789932f, -0.04170955f, -0.00557793f, -0.07249969f, 
    0.23807420f, 0.02352874f, 0.01855558f, -0.03256038f, -0.07557589f, 0.12363978f, 0.08999215f, -0.10952904f, 
    0.08470912f, 0.03954844f, -0.12691648f, 0.12862298f, -0.11354251f, 0.03547699f, 0.05065828f, 0.04397531f, 
    0.03259872f, 0.04244941f, 0.10900161f, -0.10159815f, -0.13262127f, 0.04891075f, -0.14679967f, 0.01589990f, 
    0.01775560f, -0.07683575f, -0.10954783f, 0.26715729f, -0.05731890f, 0.07143049f, 0.09612272f, 0.00667998f, 
    0.05715133f, -0.07738509f, -0.04513343f, 0.17723945f, -0.12626526f, -0.00899049f, -0.08004568f, -0.02291086f, 
    -0.03944581f, 0.19982007f, -0.01560914f, 0.05476639f, 0.13771160f, -0.03561710f, 0.04494974f, -0.12566429f, 
    0.11038607f, 0.16930448f, -0.15832494f, -0.18988305f, 0.06176428f, 0.12208255f, 0.02510627f, -0.12202223f, 
    0.03394146f, -0.04016693f, -0.06863967f, -0.11590863f, -0.12198667f, -0.01527390f, -0.22294578f, 0.07668339f, 
    0.10027933f, 0.07603820f, -0.11485457f, 0.09048951f, 0.19014160f, -0.16150053f, 0.04834605f, 0.00843808f, 
    -0.22757848f, -0.18111151f, -0.15671931f, -0.02378125f, 0.10065106f, -0.02481185f, 0.02194029f, -0.13972224f, 
    0.01703097f, -0.00464554f, 0.07783122f, 0.01417629f, -0.07558300f, 0.05845265f, 0.14783493f, 0.05966583f, 
    0.06899082f, 0.07449984f, -0.04105531f, -0.07283551f, -0.12677883f, -0.07491420f, -0.04758331f, -0.12158302f, 
    -0.23560987f, 0.04389191f, 0.13111775f, 0.42830801f, -0.03540042f, -0.13745002f, 0.11507302f, 0.10192381f, 
    -0.00043383f, -0.03163040f, -0.17819576f, 0.08229990f, 0.20341119f, -0.06663046f, 0.08818164f, -0.17895521f, 
    -0.03935980f, -0.15780167f, -0.03239234f, -0.01526201f, -0.02648686f, 0.05539787f, 0.00962856f, -0.13627857f, 
    0.25236040f, 0.03379390f, 0.05815638f, -0.31292734f, -0.07842012f, -0.02314192f, -0.23441392f, -0.10552385f, 
    -0.16163516f, -0.07337879f, -0.03352639f, -0.11446393f, -0.20332856f, 0.04819354f, -0.09778138f, -0.19930802f, 
    0.06171949f, -0.09264986f, -0.04903258f, -0.03826026f, 0.08598922f, 0.04084977f, 0.07447257f, 0.12409008f, 
    -0.23796977f, -0.05223834f, 0.23941496f, 0.10477462f, 0.19034828f, -0.05356761f, 0.10522757f, -0.01919468f, 
    0.16852836f, 0.07897149f, 0.05451719f, 0.17347960f, -0.13502942f, -0.01291994f, -0.13086984f, 0.00474573f, 
    0.03276957f, -0.07082427f, -0.02945526f, 0.00643146f, 0.07968388f, -0.08888568f, 0.08941555f, -0.04046821f, 
    0.00566664f, -0.09361506f, 0.01233998f, -0.28294069f, -0.07331841f, -0.05377191f, 0.08867574f, 0.11004539f, 
    0.05932705f, 0.07293418f, -0.02025088f, -0.05761930f, 0.03736162f, -0.01746521f, 0.07345840f, -0.04462453f, 
    -0.04753508f, -0.16606440f, -0.00654323f, 0.04599651f, 0.04424070f, -0.10868352f, 0.03805975f, 0.09459709f, 
    -0.14426178f, 0.30993533f, 0.31687298f, -0.22180103f, -0.06014482f, 0.00557650f, 0.03634448f, -0.08921116f, 
    0.20038621f, 0.05350797f, -0.04433513f, -0.00490898f, 0.12901047f, 0.06332496f, -0.03355678f, 0.19081070f, 
    -0.01555599f, -0.02609735f, 0.08146305f, 0.07574799f, 0.16324279f, -0.16541469f, 0.00543454f, 0.06692936f, 
    -0.03585283f, -0.04720788f, -0.07889239f, -0.08137680f, -0.01861881f, -0.06323647f, -0.01373744f, 0.01618255f, 
    0.09754550f, -0.11717436f, -0.09735925f, 0.09411442f, 0.02238273f, 0.06061830f, 0.07121690f, -0.01487273f, 
    -0.09566140f, 0.11453873f, 0.01099054f, -0.00917633f, -0.13998830f, 0.13668375f, 0.08205728f, 0.15330295f, 
    -0.48087710f, -0.09736077f, 0.13994643f, -0.23550260f, 0.02589250f, 0.01394132f, 0.13836673f, 0.04952348f, 
    -0.10409071f, 0.10786968f, 0.02238798f, -0.00152192f, -0.07914169f, 0.04677349f, 0.21962845f, 0.06340992f, 
    0.03920553f, -0.01654614f, 0.03446153f, -0.08566779f, 0.04165227f, -0.07295790f, 0.02604987f, 0.04434745f, 
    -0.04877388f, 0.06567732f, -0.09514681f, 0.11667281f, 0.00070132f, 0.11873835f, 0.03208462f, 0.03581170f, 
    -0.05366882f, 0.03735625f, 0.10520792f, -0.00188488f, -0.28227866f, -0.10173383f, 0.15075146f, 0.14072773f, 
    0.00483993f, 0.11108935f, 0.13861558f, 0.13139161f, -0.10681704f, 0.10794995f, 0.04214387f, -0.14611365f, 
    0.04102043f, -0.10004085f, 0.05679653f, 0.15233582f, -0.05368837f, -0.06987014f, 0.01046493f, 0.10120860f, 
    -0.02934544f, -0.02659972f, -0.03766323f, 0.13808459f, -0.01405377f, -0.30570209f, 0.13811596f, 0.35345700f, 
    -0.00303189f, -0.00320619f, -0.08371667f, 0.00039211f, 0.08865246f, -0.00052118f, -0.13887346f, -0.06484482f, 
    -0.36637703f, -0.12139574f, -0.09992643f, 0.04106829f, 0.08030806f, 0.01160325f, 0.07079176f, -0.02008398f, 
    0.13408329f, 0.24016869f, 0.07767261f, -0.00674096f, 0.12112350f, -0.11512110f, -0.00136459f, 0.01441341f, 
    -0.03716916f, 0.01479461f, -0.03649789f, 0.04840289f, -0.03799521f, -0.11456519f, -0.14380583f, -0.06198921f, 
    0.15281484f, 0.00021462f, -0.20987715f, -0.06019910f, 0.14682175f, 0.06130357f, -0.00552676f, -0.00136906f, 
    0.03279001f, -0.15257648f, -0.06605004f, -0.14238729f, 0.02532162f, -0.09352562f, 0.14366752f, 0.16781901f, 
    -0.12129192f, -0.03759664f, 0.05463842f, -0.06122186f, -0.07047978f, 0.05706285f, 0.04622905f, 0.15109219f, 
    -0.23781930f, -0.08703837f, -0.12497150f, -0.04913722f, 0.18381894f, -0.04441587f, -0.03991516f, -0.01082767f, 
    0.07421668f, -0.00365393f, -0.03551789f, -0.00495529f, 0.02832146f, 0.10086775f, 0.22855681f, -0.06974889f, 
    -0.07146930f, -0.07452541f, -0.00832649f, -0.02809983f, -0.01590821f, 0.06092762f, 0.05130935f, 0.05348100f, 
    -0.08378486f, 0.08794069f, 0.00943715f, -0.22582151f, -0.05524676f, -0.01399206f, -0.04429081f, -0.06598310f, 
    -0.01000263f, 0.14873788f, -0.00974568f, -0.00120013f, -0.16497619f, 0.15079175f, 0.12948868f, -0.31031421f, 
    -0.09615266f, -0.00512216f, 0.08936339f, 0.02726488f, -0.04026283f, -0.06412116f, -0.03370535f, -0.16545063f, 
    0.25681683f, -0.12688150f, -0.12754795f, 0.22194847f, -0.09545457f, -0.02511978f, 0.04105726f, -0.06688060f, 
    -0.01614864f, -0.06885438f, -0.00649251f, 0.01415896f, -0.11240968f, -0.06452459f, -0.02484371f, 0.06924997f, 
    -0.03596284f, 0.07059147f, 0.13596092f, -0.06757797f, 0.11067062f, 0.04571038f, 0.01282548f, 0.17781767f, 
    -0.04741126f, 0.14598061f, 0.01170676f, 0.08831587f, -0.03272463f, 0.18660426f, -0.06076077f, 0.04433173f, 
    -0.02770555f, 0.05526891f, 0.12898295f, -0.01017012f, 0.10176434f, 0.08928192f, 0.16033232f, -0.45628557f, 
    -0.15787004f, -0.02952047f, -0.03070172f, 0.03913299f, -0.06566457f, -0.03473784f, 0.02613671f, -0.04976754f, 
    0.06996100f, 0.19481114f, 0.06204288f, -0.16479222f, -0.02731542f, 0.08582378f, 0.03176698f, 0.00021397f, 
    0.02442663f, -0.12072381f, -0.09514415f, 0.00241532f, -0.44001308f, -0.11191734f, 0.08187166f, -0.12921628f, 
    0.00326182f, -0.02905839f, 0.05175881f, 0.04729179f, 0.03173015f, 0.07404872f, -0.08942972f, -0.06020527f, 
    0.17989443f, 0.13216254f, 0.03714142f, -0.08971829f, -0.07434145f, -0.00885104f, 0.07074036f, 0.04404200f, 
    0.08499480f, 0.05273918f, -0.15941517f, 0.04290547f, 0.01111846f, -0.05408641f, -0.01485755f, -0.06723772f, 
    -0.06019226f, 0.05005202f, 0.08588124f, -0.03294563f, -0.07880624f, 0.08731824f, -0.05437694f, -0.19845885f, 
    0.16432375f, 0.01826808f, 0.18789250f, -0.15278901f, -0.03639295f, -0.09682842f, 0.05368125f, -0.07611346f, 
    0.10699253f, -0.04597295f, -0.06196925f, 0.12229977f, 0.19885723f, -0.22300431f, -0.03956260f, -0.18291458f, 
    -0.12091123f, 0.04418870f, 0.00700177f, 0.06594638f, -0.04340084f, 0.05271933f, 0.11207043f, 0.10179860f, 
    0.05389656f, -0.04696291f, 0.02570011f, -0.02610378f, 0.00382466f, 0.02879942f, 0.11794007f, 0.12223107f, 
    0.08829399f, 0.02795445f, 0.02903549f, 0.02416128f, -0.30099967f, 0.07374672f, 0.02262316f, 0.28918087f, 
    -0.12981157f, 0.07811878f, 0.06699098f, 0.08532080f, -0.13022946f, 0.04772967f, 0.00873851f, 0.04913765f, 
    0.07437881f, -0.00673320f, -0.02542720f, -0.15570629f, -0.04563708f, 0.04372685f, -0.09475803f, -0.19098863f, 
    -0.29180276f, 0.02875413f, -0.02988190f, 0.05418884f, -0.11006670f, 0.04219046f, 0.01657875f, 0.09611099f, 
    0.10643122f, -0.09708817f, -0.05851739f, 0.01521890f, -0.04468039f, -0.00954887f, -0.15101080f, -0.18045262f, 
    0.32919702f, -0.27594364f, 0.14990135f, -0.07320061f, 0.00038557f, -0.05834475f, 0.06861376f, -0.12364571f, 
    0.04394556f, -0.08436972f, 0.06043761f, -0.01912815f, 0.04276349f, -0.16643731f, -0.07888620f, 0.11859168f, 
    0.04856032f, -0.07908837f, 0.03831918f, -0.02631058f, -0.07461879f, -0.09523786f, -0.15131114f, 0.08714066f, 
    -0.23807766f, -0.09793379f, -0.11591914f, -0.00846245f, 0.03173352f, 0.00372681f, 0.04860371f, -0.09726679f, 
    -0.02330107f, -0.02464828f, 0.07163662f, -0.01766115f, -0.06287900f, -0.00512217f, -0.08355661f, 0.13914023f, 
    0.03062971f, 0.10852838f, 0.02918796f, 0.12889074f, 0.08491011f, -0.02244801f, 0.07671259f, -0.15796469f, 
    0.17536394f, -0.20752543f, -0.20955394f, 0.30103764f, 0.02796887f, 0.04737146f, -0.08519088f, -0.03033960f, 
    -0.00785811f, -0.12853743f, -0.01028196f, 0.11635686f, 0.26512006f, 0.11704665f, -0.00120503f, -0.12738171f, 
    -0.11668777f, 0.03578420f, -0.01787090f, 0.02428941f, 0.04642459f, 0.05448967f, -0.11061855f, 0.09398371f, 
    0.18020590f, -0.30319908f, -0.07933727f, 0.09385958f, -0.13613088f, 0.02012259f, -0.08735009f, 0.04090194f, 
    0.18244150f, 0.04623446f, -0.16021903f, 0.02935134f, 0.10917640f, 0.00701022f, 0.03804877f, 0.12834811f, 
    -0.07220830f, 0.11746605f, -0.08406616f, 0.08304363f, 0.06792765f, 0.10774029f, -0.01330595f, 0.03525680f, 
    -0.23702326f, -0.05205963f, -0.03648387f, -0.12676571f, -0.00539869f, 0.00684735f, 0.08619750f, -0.12623294f, 
    0.05273117f, -0.10521869f, -0.01306366f, -0.03128318f, -0.50992477f, 0.11338822f, -0.00730593f, 0.28890973f, 
    0.07186256f, 0.03605149f, 0.05889706f, 0.02096228f, 0.08584615f, -0.07595038f, 0.11366700f, -0.15318428f, 
    0.06710193f, -0.04659592f, 0.03722445f, -0.01226399f, 0.11729316f, 0.03870208f, -0.07379655f, 0.09043049f, 
    -0.00211035f, 0.05418907f, -0.02700949f, -0.00704908f, 0.17458394f, -0.07520452f, -0.11651758f, -0.01711174f, 
    -0.05691909f, 0.02243387f, 0.12968907f, 0.05453606f, 0.06287023f, 0.08256455f, -0.01118238f, -0.18439768f, 
    -0.13917466f, 0.14640133f, 0.02377786f, 0.01693349f, -0.19947408f, 0.08278249f, 0.05681548f, 0.09220379f, 
    -0.00772642f, -0.03186744f, 0.07183668f, 0.01909765f, 0.32136926f, -0.20626704f, -0.04015716f, -0.35366946f, 
    0.04239674f, -0.08491972f, -0.00130278f, -0.15424219f, 0.02497882f, -0.01092577f, 0.14298353f, -0.02865395f, 
    -0.18401892f, -0.02407250f, -0.12692209f, 0.07569759f, 0.01350902f, 0.05865294f, -0.00690999f, -0.00000820f, 
    -0.00750998f, -0.07145834f, 0.08746947f, -0.10281253f, 0.07546199f, 0.09126388f, 0.08465791f, -0.03519783f, 
    0.07744588f, 0.08718101f, -0.08849741f, 0.00730483f, -0.09163917f, -0.09255517f, 0.13092075f, 0.09665856f, 
    -0.28747991f, -0.00366318f, 0.05477817f, 0.14255485f, 0.03263326f, -0.00679730f, -0.01199870f, 0.05026891f, 
    0.02509565f, 0.08822262f, 0.10155299f, 0.01262050f, -0.41261023f, 0.02602825f, 0.04492888f, -0.09237498f, 
    0.15327631f, -0.04558598f, -0.02354375f, -0.00787554f, -0.05397432f, -0.03337156f, 0.02985820f, 0.07582485f, 
    -0.00232089f, 0.02082767f, 0.02458981f, -0.16094252f, -0.09074865f, -0.11596655f, -0.00327779f, -0.03323555f, 
    0.06175209f, 0.03246105f, 0.03232799f, -0.05294021f, 0.03864582f, -0.07138965f, -0.16272804f, -0.19477102f, 
    -0.06818205f, 0.04134758f, -0.13748010f, -0.20716374f, -0.05788490f, -0.00015052f, -0.07968201f, 0.12706982f, 
    -0.10175017f, -0.05300663f, 0.09680902f, -0.14873976f, -0.06955836f, 0.00231703f, -0.06375805f, 0.15502559f, 
    0.10730426f, 0.05169141f, 0.19680631f, 0.02401415f, -0.13147639f, -0.16147648f, -0.29275590f, -0.08794340f, 
    -0.09217231f, -0.09918795f, 0.01728950f, -0.16920716f, -0.04793624f, 0.07429082f, -0.09917379f, 0.08728126f, 
    -0.04065249f, -0.16937464f, 0.07520185f, 0.02694710f, 0.00804624f, 0.01010227f, -0.02058151f, -0.01505601f, 
    -0.02572073f, 0.02109396f, -0.18705653f, 0.05267180f, 0.14332014f, 0.04155235f, -0.00022480f, -0.15956098f, 
    -0.17037953f, -0.04194064f, 0.02755550f, 0.06376795f, 0.05803078f, 0.03971122f, -0.03163197f, 0.05072424f, 
    -0.20019975f, -0.12918031f, -0.19304991f, -0.16681354f, -0.11044700f, -0.07427353f, -0.12110362f, -0.04362718f, 
    -0.18608722f, 0.01137992f, 0.06070556f, -0.12380822f, -0.10428216f, 0.07594796f, -0.02249729f, -0.02037275f, 
    0.05973776f, 0.10797293f, 0.14092372f, 0.17030130f, 0.01941156f, -0.08056182f, -0.09678192f, -0.06801292f, 
    -0.61796373f, 0.21500838f, 0.02997654f, -0.02999630f, -0.13871920f, 0.03601269f, 0.14330113f, 0.12007355f, 
    -0.00951446f, -0.03140426f, 0.03347425f, 0.03719547f, 0.11987175f, 0.13698789f, 0.06635199f, -0.16256443f, 
    -0.04764049f, 0.01879605f, 0.03931094f, 0.10078825f, -0.09253484f, -0.02801352f, 0.02414242f, -0.22612028f, 
    0.27238110f, -0.16455065f, 0.03812815f, -0.02132431f, -0.00781032f, 0.06904835f, -0.01078077f, 0.06244593f, 
    -0.02134294f, -0.08555897f, 0.08772578f, -0.00219864f, -0.22151366f, 0.23400286f, 0.08013657f, -0.15628394f, 
    0.04955736f, 0.04863871f, 0.02927727f, -0.04251901f, -0.10914803f, 0.23871396f, 0.04885300f, 0.11838978f, 
    -0.19197543f, 0.04973697f, 0.02007503f, -0.13919552f, -0.14591835f, -0.00905379f, 0.01964457f, 0.05984284f, 
    -0.10508185f, -0.00066634f, 0.14671496f, 0.00752555f, 0.30622563f, 0.10294256f, -0.14335684f, -0.18873677f, 
    -0.07436988f, 0.02241445f, -0.06023433f, -0.01194893f, 0.03317468f, 0.01750446f, -0.07845981f, 0.02159714f, 
    -0.22146340f, -0.07469292f, 0.00488657f, 0.19158174f, 0.09145373f, 0.00088923f, -0.04974631f, 0.03819471f, 
    0.09933468f, -0.07727772f, -0.12587735f, 0.01440983f, -0.39352164f, -0.06402062f, -0.02982967f, -0.04772808f, 
    0.10916454f, 0.05036289f, -0.01925680f, -0.00088017f, -0.04971791f, -0.04711585f, -0.02912866f, -0.06283124f, 
    -0.37387228f, 0.17155589f, -0.02535428f, 0.18219294f, 0.02461760f, 0.10941581f, -0.02261799f, 0.02642674f, 
    0.02636936f, 0.07749362f, 0.06842776f, -0.08028526f, 0.07349087f, 0.21637487f, 0.16967522f, -0.24028662f, 
    -0.09836705f, -0.01518913f, -0.06163380f, -0.00445457f, 0.13327640f, -0.18158090f, -0.02940271f, -0.07761519f, 
    0.22519808f, -0.30600229f, -0.00914101f, -0.02137695f, -0.02383971f, 0.01039111f, 0.04048947f, -0.03530195f, 
    0.03594533f, -0.06836531f, 0.00464502f, 0.05434560f, 0.15725899f, 0.02942637f, 0.04879531f, -0.23400402f, 
    -0.06939915f, -0.04907215f, -0.03218493f, 0.05752159f, 0.04345782f, 0.04612147f, 0.01488312f, -0.08148682f, 
    -0.13092974f, 0.13850929f, 0.00938978f, 0.16767539f, 0.03896707f, -0.02896182f, -0.13553557f, 0.14970832f, 
    -0.05419094f, -0.00843043f, 0.03429081f, -0.00600083f, 0.17843854f, 0.15334256f, 0.10262544f, 0.07811659f, 
    -0.10080636f, -0.14029533f, -0.18282686f, 0.00492736f, 0.00195792f, 0.08837147f, 0.04131372f, 0.17700757f, 
    0.06034470f, -0.02039995f, 0.09221444f, -0.17547318f, 0.19787285f, 0.01032730f, 0.08850390f, -0.01573075f, 
    -0.01220794f, -0.01846447f, 0.04857047f, 0.07223261f, -0.11076936f, 0.03148004f, 0.09412546f, 0.04398537f, 
    0.01077947f, -0.04150224f, -0.03693103f, -0.06640828f, -0.17564638f, 0.14939295f, 0.09291615f, 0.04911646f, 
    -0.14616662f, 0.05548560f, 0.03832801f, -0.18173215f, -0.07548090f, -0.03200613f, -0.00508522f, -0.09507459f, 
    -0.07986260f, -0.05126792f, -0.01836220f, -0.12976876f, -0.06980272f, 0.11903349f, 0.07342844f, 0.15337630f, 
    -0.00513694f, -0.00007703f, 0.02464210f, -0.01822777f, 0.09413106f, 0.09617181f, 0.07744551f, 0.20290263f, 
    -0.18178612f, -0.12446458f, -0.04123759f, -0.24988608f, -0.00249103f, -0.06704111f, -0.00720062f, -0.07530264f, 
    -0.10812165f, 0.01879046f, 0.01149440f, 0.12841885f, -0.02419212f, 0.00865357f, -0.09621850f, -0.14491615f, 
    0.08541044f, 0.09240600f, 0.04276433f, 0.00846347f, 0.07255206f, 0.00109202f, -0.09414338f, -0.04337379f, 
    -0.18204008f, 0.15622428f, -0.27137029f, -0.05829595f, -0.14318405f, 0.05925263f, -0.07970233f, -0.02111841f, 
    -0.04630440f, 0.03965466f, 0.05447754f, -0.08309409f, -0.09851884f, 0.02157138f, 0.08915826f, -0.20564729f, 
    0.05745326f, 0.04394924f, 0.05547996f, 0.02616827f, 0.06569891f, -0.02961209f, -0.14363033f, -0.08394698f, 
    0.05644727f, -0.09139022f, 0.01373209f, -0.15280746f, -0.00102756f, 0.09838595f, 0.13111074f, 0.02959491f, 
    0.16242406f, -0.09588002f, -0.09617591f, -0.01455983f, 0.17911927f, -0.02651944f, 0.11788382f, 0.19853291f, 
    0.04869966f, -0.18140978f, -0.00847848f, 0.19866088f, 0.09179541f, -0.00993856f, 0.05791762f, 0.20214732f, 
    0.09565439f, 0.15659234f, -0.03039353f, 0.23158398f, 0.04641416f, -0.09616584f, -0.00653655f, -0.01486668f, 
    -0.02407738f, -0.00883073f, -0.01526152f, -0.02901422f, 0.29329789f, 0.16831474f, -0.08999211f, -0.00357590f, 
    -0.04043141f, -0.03985664f, -0.02730499f, -0.01525396f, 0.00878939f, 0.05307025f, 0.05869121f, -0.03607602f, 
    -0.29816258f, -0.03190787f, -0.22834270f, -0.15605418f, 0.02496546f, -0.09038430f, 0.01987134f, -0.00821052f, 
    -0.11784074f, 0.03618379f, 0.04263058f, -0.03846214f, -0.23071149f, 0.10305044f, -0.20524496f, -0.08925373f, 
    -0.01194021f, -0.02017447f, 0.01438637f, -0.07713498f, -0.11905498f, 0.01724211f, -0.03930137f, -0.08893753f, 
    -0.04713010f, -0.18531662f, -0.02736168f, 0.06996166f, -0.02281172f, -0.01768744f, -0.00914499f, -0.01577386f, 
    -0.06230441f, 0.01031061f, -0.02419393f, -0.06484783f, 0.07399411f, 0.01606639f, 0.13641556f, -0.00685932f, 
    0.13916202f, 0.02878450f, 0.00838142f, -0.00479251f, -0.04738391f, -0.00642517f, -0.02736937f, 0.00377109f, 
    -0.14486042f, 0.05737751f, 0.08919782f, 0.13920012f, -0.01798701f, 0.01114355f, -0.03057750f, -0.04056197f, 
    -0.04190950f, -0.01235905f, 0.07977680f, -0.05986440f, -0.04232550f, -0.01799850f, 0.07420909f, 0.02426096f, 
    0.01402069f, -0.03290085f, -0.04222202f, -0.04583771f, -0.03759835f, -0.04911164f, -0.04786986f, -0.11419072f, 
    0.11098833f, -0.01251140f, -0.01210097f, -0.05996225f, -0.01200510f, -0.02299668f, 0.00074461f, -0.08847768f, 
    0.00220084f, -0.05465876f, -0.01603812f, 0.03768751f, 0.06307311f, 0.13505661f, 0.23339878f, 0.07423602f, 
    0.09957491f, 0.02231084f, -0.02765211f, 0.06539927f, -0.02483377f, 0.05930346f, 0.04309284f, -0.01046144f, 
    -0.14000958f, 0.07062357f, -0.10457504f, 0.00388328f, -0.07341675f, -0.02147859f, -0.08379338f, -0.04671897f, 
    -0.02434416f, -0.00766905f, -0.06199482f, -0.08303040f, -0.06127406f, -0.03726641f, -0.04715225f, 0.00356182f, 
    -0.05093664f, 0.06726027f, 0.01050281f, -0.03951542f, -0.02525863f, -0.02235288f, 0.00308453f, -0.06637134f, 
    -0.26350164f, 0.13909222f, 0.07445287f, 0.07174769f, 0.00154241f, 0.06473587f, -0.01358552f, 0.04531488f, 
    0.03424892f, 0.03108588f, 0.02139905f, -0.03384916f, 0.11269070f, -0.16821821f, -0.01428182f, -0.23462197f, 
    0.02305371f, 0.02338650f, -0.00288330f, -0.05116943f, 0.01931547f, -0.01310069f, 0.00061758f, 0.02102373f, 
    0.12077128f, -0.14308824f, 0.08365237f, -0.14151655f, 0.01063581f, 0.00851002f, -0.01645216f, 0.11069345f, 
    0.02579589f, 0.06690808f, -0.01019947f, 0.03695012f, -0.09383988f, -0.16870798f, 0.06185957f, 0.02349516f, 
    0.00951989f, 0.01612474f, -0.00128636f, -0.02078200f, 0.01596644f, -0.01360867f, -0.06956859f, 0.01484015f, 
    0.00387993f, 0.13399248f, 0.06735753f, 0.08657697f, 0.03689540f, -0.01347207f, 0.04416613f, -0.04144495f, 
    0.03165560f, 0.03209997f, 0.00599314f, 0.02436943f, 0.02723264f, 0.01536654f, -0.08262876f, 0.19542705f, 
    0.01112646f, -0.04354693f, -0.05686884f, -0.01140520f, 0.03975910f, 0.01170999f, 0.00080204f, -0.06579879f, 
    -0.09219148f, 0.07852980f, -0.01611103f, 0.19502260f, -0.03253983f, -0.12517740f, -0.15055802f, 0.02283424f, 
    -0.04063891f, -0.02654054f, -0.07432184f, -0.08242235f, 0.00001963f, -0.10343477f, -0.00924805f, -0.15857747f, 
    -0.05142186f, -0.03058675f, 0.00233117f, -0.04937230f, -0.09735174f, -0.04094457f, -0.08550917f, -0.05789211f, 
    -0.20892015f, 0.21164022f, 0.08755039f, 0.07133080f, -0.01410596f, -0.01532441f, -0.00887442f, -0.04621210f, 
    0.03524702f, -0.06128727f, 0.07375863f, -0.09126601f, -0.42777056f, 0.18158364f, -0.07538832f, -0.00725030f, 
    -0.17306179f, -0.12222005f, -0.04059158f, -0.00098768f, -0.05609949f, 0.01887193f, -0.07888263f, -0.04797912f, 
    0.16791607f, 0.03385134f, 0.16276832f, -0.00295958f, 0.03356327f, -0.02716671f, -0.03467082f, -0.02611444f, 
    -0.03313121f, 0.07806186f, -0.04800589f, -0.05772596f, -0.13713990f, 0.01696448f, -0.00411698f, 0.07409008f, 
    -0.01123455f, 0.01190944f, -0.04278366f, -0.02756262f, 0.03932879f, -0.00670953f, 0.01372004f, -0.08385648f, 
    -0.02520825f, 0.16152993f, 0.11419468f, -0.12174563f, -0.02885955f, 0.07083108f, 0.05827834f, -0.02626514f, 
    -0.10870397f, -0.03074260f, -0.05324386f, -0.03852366f, 0.28364098f, -0.01346336f, 0.17256097f, 0.00330741f, 
    -0.19723736f, -0.05239351f, -0.04105035f, -0.03639717f, 0.01957786f, 0.03944044f, -0.10343572f, -0.05288012f, 
    0.11224607f, -0.00891780f, -0.02465554f, -0.10471699f, 0.01644854f, -0.00100256f, 0.00425753f, -0.08337107f, 
    0.01017123f, 0.06590144f, 0.01462968f, 0.02801879f, 0.23480102f, -0.03541877f, 0.16266626f, 0.01873082f, 
    0.07229958f, 0.06654529f, 0.01783325f, 0.08211353f, -0.11774008f, 0.07784320f, 0.04023037f, -0.01649840f, 
    0.05506728f, 0.17320228f, 0.05052996f, 0.12258926f, 0.02897703f, -0.00149074f, 0.04113527f, -0.05095998f, 
    0.05493639f, 0.03387896f, 0.00582743f, -0.06161610f, -0.01065801f, 0.06341188f, -0.09701028f, -0.06484017f, 
    -0.09959785f, -0.04154812f, -0.06134521f, -0.01366901f, -0.00609293f, 0.03821410f, 0.00350878f, -0.03571037f, 
    -0.15760183f, 0.01610265f, -0.03289494f, -0.10304444f, -0.03844693f, 0.03656315f, -0.03160755f, -0.00616861f, 
    0.01814163f, -0.03573040f, -0.03803662f, -0.06531566f, -0.14998056f, 0.06266563f, 0.01448772f, 0.02588622f, 
    0.04382791f, -0.04888707f, 0.00050934f, 0.02017904f, 0.05008917f, -0.06646451f, -0.01122047f, -0.03076153f, 
    -0.09713767f, 0.03622674f, -0.24725428f, 0.04272885f, 0.01031209f, -0.11216461f, -0.09546366f, -0.05424090f, 
    -0.10410401f, 0.06575379f, -0.01387315f, -0.02039616f, -0.03478316f, 0.02045247f, 0.15094186f, 0.05914662f, 
    -0.03669914f, 0.06442002f, 0.03515829f, -0.02496758f, 0.00206494f, -0.07157570f, -0.06558039f, -0.08345672f, 
    0.05600590f, 0.06624774f, 0.10556035f, 0.04065150f, 0.07414842f, 0.01798550f, 0.06116139f, 0.10984306f, 
    -0.09963732f, 0.04706964f, -0.00442382f, -0.05813261f, 0.08539903f, 0.15142730f, 0.16941939f, 0.15784518f, 
    0.11734881f, 0.06257242f, 0.06617818f, -0.06040046f, -0.03537252f, 0.01351137f, -0.05924711f, -0.06603459f, 
    0.04377146f, 0.00445940f, 0.01483493f, 0.09897298f, 0.02327021f, -0.03701036f, -0.08987068f, -0.01104178f, 
    -0.00331104f, 0.03240312f, 0.05977655f, -0.06203246f, -0.02541818f, 0.05774153f, -0.01493181f, -0.07571845f, 
    0.01322910f, 0.05158569f, 0.00845273f, -0.02950628f, -0.01124721f, -0.08636134f, -0.06467362f, -0.08368473f, 
    0.04984536f, -0.01667834f, 0.09207772f, 0.27893505f, 0.03779941f, -0.04731538f, -0.05403867f, -0.00267316f, 
    -0.06566247f, -0.06645159f, 0.03537074f, -0.13324782f, -0.01998430f, 0.08087259f, 0.02084478f, -0.02211174f, 
    -0.03552652f, -0.03299180f, -0.03402491f, 0.07438727f, -0.03790076f, -0.00705024f, -0.00491353f, -0.08936594f, 
    0.08092406f, 0.13586937f, -0.00678408f, -0.17096490f, 0.01848112f, 0.08025267f, -0.10243937f, -0.00188265f, 
    -0.03976827f, -0.05372890f, -0.05387235f, -0.04017681f, 0.14585727f, 0.09256595f, -0.04442167f, -0.21536426f, 
    -0.00597544f, 0.00038685f, -0.03217133f, -0.01610890f, -0.04253425f, -0.04649553f, -0.02258073f, -0.11736046f, 
    -0.11988062f, -0.06494941f, -0.07002849f, -0.08337072f, -0.00327962f, 0.01468911f, -0.02096898f, -0.04502851f, 
    -0.00565839f, 0.00007591f, 0.03237760f, -0.06246291f, -0.28197899f, 0.10244887f, -0.09371747f, -0.08486340f, 
    0.06053900f, 0.01205139f, -0.08576631f, -0.00681308f, -0.05442843f, 0.04011782f, 0.07928173f, 0.05554379f, 
    -0.26750845f, 0.08274723f, -0.13805419f, -0.15571302f, 0.06952387f, 0.00985602f, -0.09205090f, -0.06921633f, 
    -0.12362111f, 0.00496539f, -0.01580858f, -0.07804912f, 0.19198735f, -0.04790734f, -0.18108134f, 0.00851203f, 
    -0.11630418f, -0.04694215f, -0.06157152f, -0.04018999f, -0.11847644f, -0.03442671f, -0.02397186f, 0.04903609f, 
    0.07662826f, -0.17845121f, 0.11567927f, -0.05730447f, -0.01046182f, -0.00956261f, -0.02073890f, -0.00851457f, 
    0.05277824f, 0.08395816f, 0.01466009f, -0.02088931f, 0.02377161f, 0.14915027f, -0.14932019f, -0.02252010f, 
    -0.09559526f, -0.00232226f, -0.13346629f, -0.00128259f, -0.07238705f, 0.03548353f, 0.01457194f, -0.01273886f, 
    -0.26470160f, 0.05476267f, 0.03414291f, -0.13037156f, 0.03438642f, -0.00122515f, -0.02477010f, -0.05576644f, 
    0.06007672f, 0.04376013f, -0.00726681f, -0.04608345f, -0.22352403f, -0.01909470f, -0.10437636f, -0.09651389f, 
    -0.02163615f, 0.00583254f, 0.03727895f, 0.01586045f, -0.10018782f, -0.01278563f, 0.03560282f, -0.00736407f, 
    -0.09723188f, -0.07601790f, 0.07071052f, -0.04474080f, 0.06996057f, 0.03954090f, -0.02776567f, -0.01987567f, 
    -0.07917526f, -0.00762955f, -0.00730008f, -0.04237842f, -0.16561790f, -0.01855781f, -0.09221400f, 0.00611051f, 
    -0.06399358f, 0.02180893f, 0.03256267f, -0.07007877f, -0.00986158f, -0.06580663f, -0.00644812f, -0.00721460f, 
    -0.02222807f, -0.15593390f, -0.12111399f, 0.00104682f, 0.06209796f, 0.02075091f, 0.00926348f, -0.04681315f, 
    -0.05723739f, -0.05475822f, -0.03880600f, 0.00895372f, -0.09189994f, 0.10264003f, 0.08926665f, 0.19353148f, 
    0.05912560f, -0.05985481f, 0.08843018f, -0.07368997f, -0.05294572f, -0.00682358f, -0.05568498f, -0.03432069f, 
    0.17386647f, -0.26524231f, 0.15462826f, 0.09773844f, -0.00705925f, -0.10895862f, -0.03144230f, 0.01148821f, 
    -0.04998616f, 0.08506417f, -0.03073285f, 0.03488379f, 0.01213096f, 0.12327562f, 0.01537395f, 0.13981718f, 
    0.11080242f, -0.00042662f, -0.01129178f, -0.03010616f, -0.04748650f, -0.02457281f, -0.00214850f, -0.02023323f, 
    -0.05741762f, 0.10779224f, 0.14839791f, 0.07712437f, 0.03753792f, 0.01911783f, -0.02233019f, -0.09277517f, 
    -0.00882584f, -0.08324746f, -0.04579906f, -0.05397364f, 0.00220225f, -0.13440382f, -0.10932557f, -0.14922856f, 
    -0.10939425f, 0.10765519f, -0.02714846f, 0.02670223f, 0.00341995f, 0.00542189f, -0.01906105f, -0.05394864f, 
    0.16532953f, 0.05380604f, 0.14322406f, 0.16792348f, 0.02869291f, 0.01912298f, 0.02574271f, -0.03276917f, 
    -0.02553070f, 0.10523701f, -0.01156695f, -0.07047053f, -0.34165755f, 0.10041212f, 0.02785314f, 0.21463841f, 
    -0.09012131f, -0.09731182f, -0.03601416f, -0.00838337f, 0.02188631f, 0.02970652f, 0.01445807f, -0.03612283f, 
    0.06395552f, 0.08815733f, 0.19542779f, 0.08986008f, 0.10480279f, 0.13073300f, 0.03176545f, -0.05550625f, 
    -0.00414992f, 0.03154146f, -0.09154651f, -0.02877635f, 0.07354220f, 0.11475871f, -0.04015597f, -0.02175120f, 
    -0.06538860f, 0.04434722f, -0.00789754f, -0.05217705f, 0.06409080f, -0.03065467f, -0.00222668f, 0.07360271f, 
    0.03138501f, 0.14897326f, 0.14974159f, -0.06748931f, -0.06329964f, 0.02753024f, -0.00764677f, -0.00495509f, 
    0.01260965f, -0.03657439f, -0.01596963f, -0.07509225f, 0.20366147f, -0.17576958f, -0.03273596f, -0.00275049f, 
    -0.08069447f, -0.05317926f, 0.07627501f, -0.11874928f, -0.05336621f, -0.01885056f, -0.07395607f, 0.01895209f, 
    0.05603037f, 0.15314156f, -0.23960365f, -0.26503563f, 0.00167127f, -0.02292619f, -0.12102573f, -0.05828821f, 
    -0.00262739f, -0.07619865f, 0.03076021f, -0.04432840f, -0.00808365f, -0.02150618f, -0.01451199f, -0.10191290f, 
    0.06725959f, 0.00249717f, -0.01540468f, 0.06009440f, 0.03310369f, -0.01861812f, 0.09303412f, -0.17303415f, 
    -0.04751723f, -0.03911047f, -0.19187127f, -0.02922985f, -0.05600208f, 0.03795461f, -0.09949218f, 0.01263532f, 
    0.13580047f, 0.01341254f, 0.00709763f, -0.13081364f, -0.06647521f, 0.01243314f, 0.03113441f, 0.21470119f, 
    0.03451034f, -0.01617801f, 0.04882325f, -0.06210618f, -0.01084705f, -0.01098577f, 0.09690071f, -0.01805781f, 
    0.00234379f, -0.19338450f, -0.14289312f, 0.03647815f, 0.05715926f, 0.00165693f, -0.05217474f, 0.01583792f, 
    -0.00830292f, 0.12069432f, 0.04872635f, 0.03001023f, -0.20890765f, -0.03915479f, 0.10387091f, -0.06439946f, 
    -0.04973095f, -0.07101730f, 0.03754586f, -0.18437645f, -0.01243787f, -0.01999572f, 0.00768774f, 0.02218647f, 
    -0.08676162f, -0.01794966f, -0.01028787f, 0.12285012f, 0.17901236f, -0.10405547f, -0.09022271f, 0.01582488f, 
    0.04224225f, 0.08419818f, 0.01020549f, 0.02685290f, -0.17694800f, -0.14301109f, 0.13792704f, -0.04644572f, 
    -0.04094414f, -0.12448390f, -0.06934883f, -0.02228540f, -0.07209731f, 0.10818801f, -0.00566686f, 0.09834549f, 
    0.10153352f, -0.02291635f, 0.04472330f, 0.05685480f, 0.02146555f, -0.15939914f, -0.08616381f, -0.02365883f, 
    0.04153842f, 0.01978759f, -0.03956058f, -0.07548179f, 0.11888137f, -0.27889618f, 0.21997708f, 0.00236815f, 
    -0.06626175f, -0.05118753f, -0.00614110f, -0.10270784f, -0.04776434f, -0.02935081f, -0.02301928f, 0.02423761f, 
    -0.12050545f, 0.13712262f, -0.05082199f, 0.03573209f, -0.05113296f, 0.02010663f, 0.03091933f, -0.06365459f, 
    0.04944363f, 0.01206494f, 0.03012044f, -0.02700670f, 0.20727852f, 0.17299734f, 0.01277167f, 0.01175818f, 
    -0.01177176f, -0.02375761f, -0.05047177f, -0.10041674f, -0.03058899f, 0.07195571f, -0.07236871f, -0.02164101f, 
    0.03295852f, 0.06577957f, 0.16397807f, 0.03070277f, 0.02533017f, 0.08898128f, 0.01620616f, -0.06043834f, 
    -0.02447157f, 0.03690645f, 0.08607389f, -0.09591526f, 0.17877665f, 0.00031578f, -0.16732730f, 0.03391023f, 
    0.09678868f, 0.03088234f, -0.01232009f, -0.05912977f, -0.00345127f, 0.01119769f, 0.02306406f, 0.04935677f, 
    -0.08370725f, 0.02191032f, 0.08577725f, 0.06939077f, -0.01695145f, -0.07522479f, 0.05519725f, 0.03794249f, 
    0.02458903f, -0.04479995f, -0.23987894f, -0.00911589f, 0.21591526f, 0.15582705f, -0.02990472f, 0.07422597f, 
    0.09284821f, -0.05421439f, 0.00439982f, -0.02911135f, 0.03754928f, -0.01199404f, -0.02277410f, 0.04590340f, 
    -0.00156597f, -0.01746506f, 0.15147260f, 0.11615118f, -0.11022571f, 0.02246827f, -0.02613851f, 0.05186092f, 
    -0.05276512f, 0.00449260f, -0.02576691f, -0.00271487f, 0.01432894f, 0.02655705f, -0.30251852f, -0.27089942f, 
    -0.00068011f, -0.13167828f, -0.01046462f, -0.10439193f, 0.04268076f, 0.07167754f, -0.14730857f, 0.11118990f, 
    0.08035111f, 0.31163061f, -0.31177214f, -0.32208124f, 0.07383835f, -0.03609729f, -0.27853343f, -0.01506012f, 
    0.13916902f, 0.01837282f, 0.08298939f, -0.02844601f, -0.01536078f, 0.00925911f, -0.14471923f, -0.00524328f, 
    0.03125284f, -0.03168703f, 0.03233986f, -0.03479635f, -0.03035859f, 0.04126919f, 0.00360740f, -0.03110841f, 
    -0.06708280f, -0.15602344f, 0.01529245f, -0.06670073f, -0.08479396f, 0.02956922f, -0.15275286f, -0.15053822f, 
    0.05649230f, 0.01708627f, 0.07405380f, -0.05414793f, 0.13143364f, -0.03691659f, 0.00709624f, 0.05291573f, 
    0.02569309f, -0.01120553f, -0.05724944f, 0.00035531f, 0.04201201f, -0.02292975f, -0.00870963f, -0.02420857f, 
    -0.14093624f, 0.00828346f, 0.21104322f, -0.07312066f, -0.03152271f, 0.00111029f, -0.11266807f, -0.01017675f, 
    -0.00392603f, -0.02943219f, 0.01064826f, 0.09332782f, -0.02140866f, 0.22527194f, -0.08008042f, 0.14344715f, 
    -0.07686850f, 0.02464973f, -0.10319417f, -0.08096622f, 0.05120581f, 0.03966272f, -0.12369413f, 0.03357038f, 
    -0.08424329f, 0.01895769f, -0.11617130f, -0.14238159f, -0.04759057f, -0.06127889f, 0.06088546f, -0.07884541f, 
    0.07935420f, -0.09533762f, 0.13058011f, 0.03370662f, -0.22853650f, 0.02414941f, -0.18043071f, -0.30354628f, 
    0.13008572f, 0.00424925f, -0.00900278f, 0.05480371f, 0.10040442f, 0.00742395f, -0.06988810f, 0.08727885f, 
    0.14645195f, -0.01898249f, 0.00095878f, 0.03023011f, 0.06460420f, -0.09819777f, -0.05011700f, -0.08191714f, 
    0.02089843f, 0.00247291f, 0.00460658f, 0.05438558f, -0.09281503f, -0.16959101f, 0.11015500f, -0.19097550f, 
    0.09708607f, -0.03340492f, 0.12582117f, -0.12192260f, 0.07088881f, -0.00388158f, -0.21613373f, 0.05445164f, 
    0.10815039f, 0.15542445f, -0.01827310f, 0.09752319f, -0.00005888f, 0.01558660f, -0.00088417f, 0.04754438f, 
    0.01924479f, -0.06840194f, -0.05845138f, -0.00787324f, -0.08038443f, 0.13679974f, -0.18164739f, -0.02649010f, 
    -0.00718763f, 0.05690145f, 0.09960173f, -0.05608197f, 0.00979267f, 0.05499801f, -0.04653978f, 0.00668443f, 
    0.16404380f, 0.09998245f, -0.08654997f, 0.02621497f, 0.05559428f, 0.04161452f, -0.03413282f, -0.06191541f, 
    0.00055443f, 0.05305942f, -0.09314433f, 0.06270372f, -0.13626136f, 0.16581668f, -0.06637394f, 0.07436592f, 
    0.06837513f, 0.00918756f, -0.06052978f, -0.07563239f, -0.06001693f, -0.03477795f, -0.08993863f, 0.03289052f, 
    -0.19277422f, 0.13017510f, 0.08431952f, 0.13728294f, 0.01160019f, 0.13790497f, -0.05624974f, -0.12756340f, 
    0.09005624f, 0.06841632f, 0.02139931f, 0.04235180f, -0.18349533f, 0.09729829f, -0.03703978f, 0.00334753f, 
    -0.02038820f, 0.05933115f, -0.07767894f, -0.09750018f, -0.01612454f, 0.00363095f, -0.00990015f, -0.03076383f, 
    -0.02063802f, -0.16921982f, 0.17426223f, -0.03677871f, -0.07958695f, -0.16065051f, -0.02418249f, -0.14557262f, 
    -0.00089317f, -0.11234837f, -0.17274114f, 0.04408912f, -0.11181103f, 0.00265841f, 0.10308798f, 0.08893788f, 
    -0.01730708f, 0.04426264f, -0.15965010f, -0.04143440f, 0.00713934f, -0.12671743f, 0.10450257f, 0.06910902f, 
    0.00313125f, 0.00886474f, 0.16379197f, -0.18786538f, -0.07037099f, -0.11940112f, -0.00647780f, 0.01265910f, 
    -0.11802896f, 0.05253143f, -0.01487367f, 0.06137090f, 0.09126735f, 0.04107865f, 0.09064451f, 0.10810754f, 
    0.09328127f, -0.06497871f, -0.02242321f, -0.01890342f, -0.05718020f, -0.05730461f, 0.02110844f, -0.01602268f, 
    -0.10363162f, 0.16673483f, -0.07566877f, -0.15233999f, 0.06497403f, -0.01020018f, 0.06022845f, 0.02216148f, 
    -0.00611818f, -0.01471744f, -0.07586086f, 0.13935561f, -0.15702626f, -0.16323799f, -0.10952281f, -0.07134790f, 
    0.09463376f, -0.15360840f, 0.01752084f, 0.12938772f, 0.09119987f, 0.14342551f, -0.02279908f, -0.12282623f, 
    0.17606448f, -0.04161219f, 0.01461118f, 0.08350141f, 0.06552393f, -0.12901898f, -0.10366864f, -0.02054240f, 
    -0.00009587f, 0.05829072f, -0.02534461f, -0.06726634f, -0.10881881f, -0.01522752f, 0.02411685f, 0.01026086f, 
    -0.02720992f, -0.10735413f, 0.03021942f, 0.00515854f, -0.01870728f, 0.11787009f, -0.02351002f, 0.10208723f, 
    0.15511391f, 0.07345688f, 0.01455505f, 0.07321252f, 0.01854325f, 0.02604806f, 0.05787469f, -0.01661165f, 
    0.04906196f, 0.00815028f, 0.00249837f, 0.04721180f, -0.04321716f, -0.14550349f, 0.02698217f, 0.13781555f, 
    0.12440567f, 0.01128838f, -0.00793423f, 0.00247291f, 0.00178111f, -0.01549871f, 0.08809444f, -0.01968556f, 
    0.03109489f, -0.06872477f, 0.07069689f, 0.17340329f, 0.07197569f, 0.01141756f, -0.00632678f, -0.00189109f, 
    0.02777554f, -0.03217087f, -0.02781119f, -0.14644569f, -0.16385199f, -0.01353210f, -0.12922694f, -0.13340807f, 
    -0.03134011f, -0.03965254f, 0.03981941f, 0.00963432f, 0.04449755f, -0.00820079f, 0.08681079f, 0.05070854f, 
    0.11323851f, 0.06144356f, -0.10981283f, -0.02257590f, -0.05636704f, -0.00686376f, 0.00018927f, 0.01340480f, 
    -0.05668216f, 0.04766256f, -0.01910331f, -0.00299071f, -0.09625769f, -0.04289990f, 0.05220567f, -0.15729748f, 
    0.00292387f, 0.00770240f, 0.05927761f, -0.01057214f, 0.07542586f, 0.05454057f, -0.05234859f, 0.03713360f, 
    0.11500775f, 0.10882488f, -0.11229752f, 0.04765179f, 0.03620415f, 0.00218270f, 0.00840774f, -0.02436917f, 
    0.02428521f, 0.05311295f, -0.03828546f, 0.10409398f, -0.08333689f, -0.14414914f, -0.02796264f, 0.09256319f, 
    0.09700777f, -0.01732265f, -0.05635541f, -0.01557768f, -0.02012399f, 0.08690719f, 0.06519552f, 0.04324319f, 
    -0.00166238f, -0.09054850f, 0.18612246f, 0.04118673f, -0.09045565f, -0.06267317f, 0.02059374f, -0.04794086f, 
    -0.07863346f, -0.01847343f, 0.04771071f, -0.11294029f, 0.00838003f, 0.05170790f, -0.04956181f, 0.20188390f, 
    0.08783121f, -0.03861073f, -0.04870323f, 0.05545352f, 0.02909324f, -0.01750595f, -0.06436253f, 0.02896887f, 
    0.18916561f, 0.08279524f, -0.16150491f, -0.01599699f, 0.06435864f, -0.02073988f, -0.04168077f, -0.00856411f, 
    0.02889131f, 0.01071602f, -0.03388454f, -0.02832554f, -0.17025505f, -0.06639828f, 0.13130584f, -0.14912026f, 
    0.06940604f, -0.02415390f, -0.11690199f, -0.07510071f, 0.09805428f, -0.01175126f, -0.11220246f, -0.21799701f, 
    0.00970974f, -0.18493333f, -0.24629949f, 0.02504831f, 0.06369242f, -0.06491230f, -0.00957238f, -0.15469551f, 
    0.05376711f, -0.01850523f, -0.03927081f, 0.10958391f, -0.07680586f, -0.04185403f, -0.03688257f, -0.21982192f, 
    0.04322294f, -0.03217726f, -0.12259132f, 0.06866909f, 0.04579550f, -0.07468040f, 0.05575392f, -0.02479675f, 
    -0.22204076f, -0.09997993f, 0.23399125f, -0.13258669f, -0.05382028f, -0.10054924f, -0.05644884f, -0.01321076f, 
    -0.04611380f, 0.05871452f, 0.01961386f, 0.00454889f, 0.04049170f, 0.06121859f, -0.18087278f, 0.01991102f, 
    0.00423026f, -0.02301119f, -0.04379186f, -0.00790471f, -0.07272361f, 0.00438555f, 0.07175494f, -0.05030417f, 
    -0.19479068f, 0.09874098f, 0.06387455f, 0.01370037f, -0.05853203f, -0.05535020f, -0.00698496f, 0.04208111f, 
    0.04091913f, -0.02422288f, -0.18646105f, -0.06529057f, -0.28358358f, -0.04080788f, -0.25298062f, 0.03962536f, 
    -0.05329864f, -0.02219865f, -0.03865305f, -0.01184847f, 0.06847639f, 0.04530852f, -0.04718200f, 0.05316057f, 
    -0.19083136f, -0.00686756f, 0.12540813f, -0.14554146f, 0.11620396f, -0.12815635f, 0.07228030f, -0.21402812f, 
    0.02596010f, -0.10927439f, 0.04519264f, 0.08380489f, 0.04377623f, 0.00702488f, 0.02296359f, 0.16650125f, 
    0.03279198f, -0.00914341f, -0.04153595f, -0.02948318f, 0.02427031f, 0.00342761f, 0.07912145f, -0.00276671f, 
    -0.29316702f, -0.09149135f, 0.13479094f, 0.00008914f, -0.05443547f, -0.07195979f, -0.09954502f, 0.12590554f, 
    0.08172531f, 0.09127905f, -0.02307640f, 0.13867089f, 0.15277649f, 0.05640407f, 0.00055339f, 0.03149141f, 
    -0.00049130f, -0.09124623f, 0.00213899f, -0.09265147f, 0.05076553f, 0.07154377f, -0.02441614f, -0.16288009f, 
    -0.26822117f, -0.17062944f, 0.28810287f, -0.03551261f, -0.01412566f, -0.00205141f, -0.10845252f, -0.02533617f, 
    0.05572844f, -0.07446727f, 0.06151634f, 0.06913716f, 0.05057770f, 0.21558250f, 0.19570786f, -0.07341842f, 
    -0.06502415f, -0.13085297f, 0.01194567f, 0.07731707f, 0.13071816f, 0.02501136f, 0.01463164f, 0.06646898f, 
    -0.02009878f, 0.02069082f, 0.06680209f, -0.03053251f, -0.01860482f, 0.07404912f, 0.16441180f, -0.09102781f, 
    -0.17586643f, 0.01751984f, -0.04298291f, 0.06626674f, -0.40522864f, 0.38824481f, -0.22983122f, -0.27966183f, 
    0.01789449f, 0.06486498f, 0.01630453f, 0.06128561f, -0.10986582f, -0.05685681f, 0.01914089f, -0.03841485f, 
    0.08462873f, 0.07495821f, -0.08242364f, -0.29423437f, -0.05561986f, -0.02852450f, 0.00782311f, -0.00788989f, 
    0.06435203f, 0.05803230f, -0.09301151f, -0.08637124f, 0.27698529f, -0.29585373f, -0.07440632f, 0.19049412f, 
    0.01091359f, 0.00416945f, 0.01715776f, 0.07757687f, -0.05417880f, -0.04570720f, 0.03530760f, 0.00612701f, 
    -0.07979733f, 0.02787508f, 0.10525759f, -0.30149028f, -0.04894420f, 0.04457157f, -0.10954475f, 0.03041034f, 
    0.08872075f, -0.08323269f, 0.02461608f, -0.00770089f, 0.41703832f, 0.00948711f, -0.25300220f, 0.09250872f, 
    0.01996243f, -0.03539261f, 0.12158532f, -0.08803205f, 0.12068602f, -0.09148207f, -0.11382341f, 0.00144480f, 
    -0.07449009f, 0.02355139f, -0.05113172f, 0.18703403f, -0.00625103f, 0.04959016f, -0.05493359f, -0.03293973f, 
    -0.05453958f, -0.00555470f, 0.04844889f, 0.03041321f, 0.08055135f, -0.18454643f, -0.05923019f, 0.08531450f, 
    0.06140288f, -0.05520133f, -0.04459557f, -0.01750892f, 0.10362159f, 0.12701617f, -0.03467844f, 0.01937544f, 
    -0.30720055f, 0.28244081f, 0.02937775f, 0.21306357f, -0.04200888f, 0.10501851f, 0.00037228f, 0.12092306f, 
    0.01538211f, 0.01926856f, 0.10736807f, 0.09927720f, 0.08922087f, 0.09007552f, -0.08549973f, -0.01319010f, 
    0.10367446f, 0.08446111f, -0.01205524f, -0.00336790f, 0.06829551f, -0.01585978f, 0.07785772f, -0.03126094f, 
    -0.36216286f, -0.23939194f, 0.08043704f, 0.05645519f, 0.08010837f, -0.04057861f, -0.03890115f, -0.09435879f, 
    0.16436718f, -0.01236761f, -0.01223983f, 0.05945228f, 0.11184020f, -0.10787043f, 0.04324049f, 0.02993713f, 
    0.12249738f, 0.01340225f, -0.03101769f, -0.07364315f, -0.15348582f, -0.14631787f, -0.04913527f, -0.03367241f, 
    0.00442637f, -0.04595461f, -0.02851807f, -0.00917658f, 0.02824010f, 0.12108836f, -0.07623234f, -0.05916757f, 
    -0.06291232f, 0.08566196f, 0.04548184f, 0.04559548f, 0.08684954f, -0.43846655f, 0.10634729f, -0.06284149f, 
    0.12970684f, -0.03834377f, -0.05471127f, -0.00305172f, -0.10641529f, -0.06007405f, 0.17071049f, -0.10243051f, 
    0.35424021f, -0.14488865f, 0.00901668f, -0.00846387f, 0.12799883f, 0.06362529f, 0.03477281f, 0.06948602f, 
    0.02199542f, 0.00017367f, -0.04832698f, -0.02715613f, 0.04789183f, 0.08549052f, 0.09328084f, -0.13923073f, 
    -0.02445661f, 0.00615279f, 0.05358568f, 0.02248886f, -0.01709281f, -0.04775895f, -0.09065866f, 0.12539898f, 
    -0.18286519f, 0.01699015f, 0.27352092f, -0.10264380f, -0.07821674f, 0.06044372f, -0.03010993f, 0.03082538f, 
    0.00679943f, -0.04324046f, -0.01095728f, -0.02415410f, -0.22560500f, 0.10295522f, 0.09902199f, -0.11550793f, 
    0.00770832f, -0.05850421f, 0.09772632f, -0.00013299f, 0.02797693f, 0.06359947f, 0.03106442f, -0.02982959f, 
    0.01073628f, 0.05494640f, -0.30042836f, -0.00748529f, 0.06302914f, -0.16130015f, 0.07592736f, 0.13288118f, 
    -0.08465826f, -0.05799159f, 0.17522727f, -0.01259555f, -0.47054756f, 0.22849448f, 0.00797281f, -0.19124666f, 
    0.04621356f, 0.02359541f, 0.03242762f, -0.08784045f, -0.00690796f, 0.05567216f, 0.07205603f, -0.11769495f, 
    -0.07975460f, -0.19710733f, -0.02566575f, 0.14897822f, 0.03496159f, -0.02781354f, -0.02875607f, 0.02346607f, 
    -0.09283274f, -0.00666008f, -0.20846775f, -0.06938235f, 0.06165639f, 0.09117617f, 0.05253498f, 0.07051161f, 
    -0.00160858f, 0.06675030f, -0.00758822f, 0.10517117f, -0.03437857f, -0.01287807f, -0.05852694f, -0.08862182f, 
    -0.19609737f, -0.07208260f, -0.11044724f, -0.04937322f, -0.03751585f, -0.03698045f, 0.09062923f, 0.02439243f, 
    -0.04326397f, 0.06681097f, -0.02706300f, -0.00602514f, -0.08996791f, -0.01456084f, -0.16335130f, 0.07940459f, 
    0.00555277f, -0.07776605f, 0.05904175f, 0.05611172f, -0.05785606f, -0.01244332f, 0.07926878f, 0.04519346f, 
    -0.02655346f, -0.06524048f, 0.05963477f, -0.08019075f, 0.14403234f, 0.00650199f, -0.09221082f, -0.00823925f, 
    0.03963853f, 0.01813425f, 0.08394665f, 0.02404341f, 0.15540570f, 0.11300373f, -0.03863341f, 0.13793319f, 
    -0.06706828f, 0.06126487f, -0.10819069f, -0.10454726f, -0.04311916f, 0.03172204f, 0.09687504f, 0.08695773f, 
    -0.10174114f, -0.07778531f, 0.09038048f, 0.00292142f, 0.07620963f, 0.06717002f, 0.04770161f, 0.01802208f, 
    -0.10861997f, -0.03769196f, -0.04661567f, 0.10115054f, -0.43718252f, -0.01333204f, -0.22891492f, 0.15883970f, 
    0.03975968f, 0.09438100f, -0.06218200f, -0.08050770f, -0.13749935f, 0.01689010f, -0.01879231f, 0.07038742f, 
    0.07076605f, 0.02866246f, -0.02067694f, 0.10600175f, 0.17127740f, 0.05474105f, 0.00358300f, 0.06805613f, 
    0.04894392f, -0.00601112f, 0.00841734f, -0.06062105f, 0.17821626f, -0.23918262f, 0.00770346f, -0.08479692f, 
    -0.04825832f, -0.00245269f, 0.01875550f, 0.09693630f, 0.02439265f, 0.00735220f, 0.17161489f, -0.06331636f, 
    0.28332493f, 0.08884768f, -0.25688186f, -0.39339405f, 0.12307391f, -0.07868479f, 0.03633034f, 0.04050121f, 
    -0.15221342f, -0.01079795f, -0.03753201f, -0.02063403f, -0.01149128f, -0.02324462f, -0.09980882f, 0.09472052f, 
    -0.08567548f, -0.05455554f, 0.09734046f, 0.14733241f, 0.05045752f, 0.20472151f, -0.02698322f, -0.01366140f, 
    -0.16839130f, -0.10177371f, -0.09967676f, 0.10934050f, 0.00009930f, -0.03545259f, 0.00222950f, 0.02704540f, 
    -0.11555717f, 0.06459574f, 0.02257801f, 0.08887218f, -0.12782165f, -0.34261906f, 0.04569506f, -0.10474847f, 
    0.02944014f, 0.07049884f, 0.00461465f, 0.09408421f, 0.00620890f, 0.05458771f, -0.05275165f, 0.00808265f, 
    0.50419527f, 0.12757760f, -0.07370715f, 0.07197169f, 0.07303569f, -0.04772006f, 0.05422385f, 0.11572021f, 
    -0.02537134f, -0.08470917f, 0.03065245f, -0.06013514f, -0.19214891f, 0.11063930f, 0.00328114f, -0.10394413f, 
    0.07764718f, -0.04097825f, 0.03808111f, -0.03469654f, 0.11489563f, 0.02758403f, 0.09423760f, 0.09323825f, 
    0.12687908f, -0.32313281f, -0.20108315f, -0.02800766f, -0.00485792f, 0.01805938f, -0.03996826f, -0.05194838f, 
    -0.10136715f, -0.08262347f, 0.21230163f, 0.07263072f, -0.17731845f, 0.02394758f, 0.11646782f, -0.13447019f, 
    -0.11493461f, 0.13920540f, 0.12861452f, -0.03851037f, -0.01083595f, 0.04135821f, 0.03769594f, 0.03441022f, 
    -0.36222294f, 0.27412370f, -0.07080019f, -0.19810683f, -0.01104324f, 0.01006259f, 0.00583686f, 0.04163125f, 
    0.15136838f, 0.06221522f, 0.15309364f, 0.08960090f, -0.16254841f, 0.11368713f, 0.04202817f, -0.02944825f, 
    -0.05244238f, -0.01413394f, 0.07045389f, -0.13373005f, -0.03475046f, -0.14004217f, -0.03443436f, 0.00406465f, 
    0.11054726f, 0.20604947f, -0.10097031f, -0.11110562f, -0.01209149f, -0.03373327f, -0.00239621f, -0.01571354f, 
    -0.15662657f, 0.05901595f, -0.15599494f, -0.01260485f, -0.23415498f, 0.06761125f, 0.13702443f, -0.22630292f, 
    -0.04476957f, 0.04722611f, -0.05502390f, -0.00945405f, -0.03355277f, -0.00416170f, 0.00569647f, 0.04031836f, 
    -0.47251320f, 0.35433847f, -0.10785314f, -0.33482414f, 0.09745120f, 0.01928491f, -0.01480386f, -0.13828498f, 
    0.06226398f, -0.15222676f, 0.04822252f, -0.03725110f, -0.22188133f, 0.13001771f, -0.06895754f, -0.27567616f, 
    -0.02239014f, 0.02543296f, 0.05099256f, -0.07402107f, 0.05317752f, -0.01998614f, 0.02364177f, -0.04411641f, 
    -0.08349784f, 0.01041625f, -0.10987387f, 0.22579469f, 0.08430396f, -0.00203598f, 0.07837734f, 0.12038493f, 
    -0.13217019f, -0.03383683f, -0.01377546f, 0.00779990f, 0.30827087f, 0.15468384f, 0.15476657f, -0.08753744f, 
    -0.09260765f, 0.10609896f, 0.03384637f, -0.06371465f, -0.07884440f, -0.12260483f, -0.01267513f, -0.04141697f, 
    0.05060259f, 0.16118109f, 0.07648797f, 0.12439945f, -0.01796898f, 0.03397696f, -0.04537824f, -0.06992266f, 
    -0.01415069f, -0.00646893f, 0.06577569f, -0.11181159f, -0.11534007f, -0.02083457f, -0.00674790f, -0.10889868f, 
    0.07537538f, -0.02558717f, 0.01547358f, -0.01684273f, 0.00649064f, -0.00385483f, -0.03963330f, -0.13507935f, 
    0.27681032f, -0.00127287f, -0.05751786f, 0.23854801f, 0.02662051f, 0.01335059f, -0.20391138f, 0.05741879f, 
    -0.01747960f, 0.12205107f, 0.03600840f, 0.07650793f, -0.19425313f, 0.09332589f, -0.21913876f, -0.26320046f, 
    0.03030006f, 0.03517570f, -0.01254801f, 0.07548824f, 0.00318400f, 0.00226026f, -0.10867122f, 0.04818470f, 
    0.21295640f, 0.15530591f, 0.18603598f, -0.05469449f, 0.00844649f, 0.03518763f, -0.03658922f, -0.10833532f, 
    -0.00780787f, 0.05523567f, 0.02015071f, 0.05622123f, -0.33143547f, -0.23875636f, -0.01898742f, 0.17194252f, 
    0.02772590f, 0.03971322f, 0.04109454f, -0.09131970f, 0.00529708f, -0.02218299f, 0.05926152f, 0.08191828f, 
    0.07783215f, -0.16394313f, 0.09923217f, -0.12415443f, -0.06081459f, -0.00183591f, -0.17977686f, 0.06270985f, 
    0.04930700f, -0.00309971f, -0.02990152f, -0.02847542f, -0.12952231f, -0.24155824f, -0.10060394f, 0.04016853f, 
    -0.03744038f, -0.03763752f, 0.07218295f, 0.13025579f, -0.03340981f, -0.01406937f, 0.13827114f, 0.12956204f, 
    0.14393058f, -0.11890587f, -0.16202343f, 0.07782244f, -0.05551476f, -0.00211145f, 0.05006521f, -0.08791088f, 
    0.00574990f, -0.02738160f, -0.05291472f, 0.05547342f, -0.01127587f, -0.00485958f, 0.06945901f, -0.03127274f, 
    -0.07611191f, 0.03946887f, -0.04789478f, -0.03176296f, 0.05371190f, -0.04670842f, 0.01725452f, -0.13755178f, 
    -0.10432993f, -0.00708025f, -0.15307216f, 0.13204505f, 0.01306781f, 0.07859434f, -0.10745886f, 0.04301911f, 
    -0.08017796f, 0.10980547f, 0.03865540f, 0.03166311f, -0.15944937f, 0.15871201f, -0.19984958f, -0.04786009f, 
    0.01585770f, -0.02006779f, -0.02589791f, 0.18337445f, 0.02024612f, 0.08359543f, 0.02666599f, -0.07079237f, 
    -0.23797309f, -0.32083037f, -0.11234995f, -0.10745946f, 0.06525581f, 0.07112388f, -0.12118901f, 0.00284540f, 
    -0.07404369f, -0.05835115f, -0.04650311f, -0.00725051f, -0.08665311f, 0.17923728f, -0.34267914f, -0.13068336f, 
    0.07446584f, -0.05961362f, 0.03154988f, -0.03701089f, -0.08602973f, 0.01347789f, -0.23622537f, -0.00725232f, 
    -0.13311051f, 0.03041482f, 0.03759209f, 0.25484243f, -0.04533131f, -0.01800423f, -0.03484407f, -0.04815453f, 
    -0.11340989f, 0.00999481f, -0.04147771f, -0.06267237f, -0.03100627f, -0.24769762f, -0.01539701f, 0.07799467f, 
    0.07297192f, 0.11639874f, -0.00311906f, -0.15054742f, -0.00675451f, 0.09850107f, 0.01858383f, -0.08364213f, 
    -0.15390997f, -0.06482040f, -0.03858311f, 0.07108062f, 0.03924269f, 0.02069687f, -0.01482130f, -0.05232137f, 
    0.02164005f, 0.14485911f, -0.09033662f, -0.04614659f, -0.20846996f, -0.10624681f, 0.07867861f, -0.11489101f, 
    0.00768410f, 0.06026666f, -0.01473050f, -0.03282924f, 0.05814405f, -0.11948651f, -0.21336602f, -0.14397620f, 
    -0.32963035f, 0.03516012f, 0.13717639f, 0.08463958f, 0.18696573f, 0.08920404f, 0.04127093f, 0.03352574f, 
    0.10155845f, 0.03541596f, -0.04191022f, 0.03315983f, -0.29100430f, -0.35214141f, -0.05348586f, -0.16699032f, 
    -0.04187553f, -0.07221612f, -0.00676056f, 0.01689047f, 0.05055745f, 0.16260090f, 0.05478752f, 0.03759643f, 
    0.08297211f, 0.08414541f, -0.07308857f, -0.11217067f, 0.00496282f, -0.15668409f, 0.03075581f, 0.06638231f, 
    0.00657905f, 0.07340224f, 0.17075825f, 0.14588507f, 0.07738820f, -0.01486924f, 0.05298920f, -0.09725441f, 
    0.07324856f, 0.01357759f, 0.00749469f, 0.00308044f, 0.02289858f, 0.08958469f, 0.01798163f, -0.04122905f, 
    -0.39509106f, -0.12653019f, 0.00031305f, -0.24569935f, 0.08834168f, -0.14898202f, -0.03884898f, -0.00982187f, 
    -0.05757792f, -0.02187052f, -0.09485667f, 0.01172303f, 0.06661637f, 0.10196235f, -0.02520095f, 0.00922586f, 
    -0.00950255f, -0.01003972f, -0.03511212f, 0.05495140f, -0.06970311f, -0.03844085f, 0.01859529f, 0.02007649f, 
    -0.11247354f, -0.09474041f, 0.01537425f, -0.13093704f, 0.06072991f, -0.08747744f, -0.08098651f, -0.05111168f, 
    -0.02116784f, -0.06253342f, -0.09281979f, -0.03271350f, 0.29843205f, 0.07302693f, -0.03085587f, -0.01373828f, 
    -0.14310856f, -0.04853620f, 0.00050071f, 0.00998385f, 0.05501163f, 0.06101511f, -0.05135581f, 0.04141121f, 
    -0.13366483f, -0.20659693f, -0.02250082f, 0.06169999f, -0.06133698f, 0.05762352f, -0.02178148f, -0.07517878f, 
    0.07438132f, -0.08053915f, -0.06942114f, -0.09245864f, -0.32689959f, -0.21275036f, 0.05424402f, -0.08434766f, 
    -0.07211629f, 0.04023532f, -0.00502599f, -0.09757992f, 0.00817709f, -0.14262022f, 0.02660772f, 0.06230697f, 
    0.16468373f, -0.00774399f, -0.08814284f, 0.03182726f, -0.03437407f, -0.06952322f, 0.09241951f, 0.05071239f, 
    -0.01504526f, 0.01852033f, 0.04330255f, -0.11658230f, -0.40378696f, -0.06272695f, -0.08523129f, 0.00455790f, 
    0.03400330f, 0.05429519f, -0.00181109f, 0.05962387f, 0.04136415f, 0.15535802f, 0.10531191f, 0.14492679f, 
    0.24416149f, -0.03198123f, -0.07745624f, 0.06429399f, -0.05918978f, -0.11747035f, -0.03615073f, 0.11065443f, 
    -0.02104614f, -0.05306517f, -0.06332330f, 0.09780438f, -0.25353929f, 0.02750914f, -0.15275174f, -0.18728934f, 
    0.08776308f, 0.03986200f, -0.07304706f, -0.00082178f, 0.03870258f, 0.13494265f, -0.06947099f, 0.03273826f, 
    0.14943878f, 0.02824892f, 0.03844975f, -0.08735753f, -0.06417575f, 0.00747290f, 0.03819439f, -0.03625021f, 
    0.03916158f, 0.02924583f, -0.04768346f, 0.00039323f, 0.04494008f, 0.01259895f, -0.05082140f, 0.07515138f, 
    0.07935251f, 0.03057949f, 0.01058360f, -0.08375348f, 0.01437902f, -0.01772027f, -0.03180871f, 0.03141610f, 
    -0.04933180f, -0.07315605f, 0.03307989f, -0.09222034f, 0.19652075f, -0.04923179f, -0.00030633f, -0.11571117f, 
    -0.03028725f, -0.01315045f, 0.03561590f, 0.02038549f, 0.18957764f, 0.03399206f, -0.05714970f, 0.13232006f, 
    0.03559823f, -0.00161403f, -0.02275514f, 0.04032789f, -0.07496786f, -0.04708546f, 0.10150312f, -0.02830127f, 
    -0.00798222f, 0.17743815f, -0.10656197f, -0.12455489f, 0.01510522f, 0.02918323f, -0.05523356f, 0.11137506f, 
    0.09142233f, -0.06024704f, 0.01876327f, -0.01874632f, -0.16482703f, -0.13037410f, 0.05341249f, 0.02012344f, 
    0.04983415f, -0.00565771f, 0.10525369f, 0.03017488f, 0.11488032f, -0.00457438f, 0.02580771f, 0.12067900f, 
    0.03085492f, 0.13081454f, 0.02382435f, -0.13468437f, 0.07669069f, 0.05321501f, -0.00119759f, 0.04600688f, 
    0.01867601f, 0.08097252f, 0.05137847f, 0.04524717f, -0.07503513f, -0.05366581f, 0.00825332f, 0.03299330f, 
    0.01950475f, 0.09958378f, 0.02999365f, 0.05999396f, 0.01089554f, -0.02064697f, -0.05297692f, -0.01285186f, 
    -0.17714067f, -0.13327616f, 0.00366727f, 0.01533169f, 0.07371772f, 0.07052994f, -0.04930856f, -0.04581998f, 
    0.00195742f, 0.08462402f, 0.08649046f, 0.02978677f, -0.01109460f, 0.09781405f, -0.05297141f, 0.11559150f, 
    0.02547520f, 0.23368518f, -0.03860854f, 0.06167013f, -0.07009847f, 0.06650894f, 0.02925843f, 0.05871945f, 
    -0.34114942f, -0.08041964f, -0.04905216f, -0.18653277f, 0.05832516f, -0.03814675f, -0.05833312f, -0.10974208f, 
    -0.03011282f, -0.05508355f, -0.02113233f, 0.01504919f, 0.03534375f, -0.06112211f, -0.06418788f, 0.08029179f, 
    0.04930512f, 0.08839669f, 0.07823844f, -0.11861684f, 0.11320686f, 0.01906665f, 0.00758542f, 0.01284134f, 
    0.15237080f, -0.10932025f, 0.01428792f, -0.06336065f, 0.01675803f, -0.15091875f, -0.00586794f, -0.07035857f, 
    0.07257723f, 0.09113151f, 0.02663360f, 0.08691594f, -0.24072942f, -0.22166617f, -0.02993535f, 0.04036675f, 
    0.07505117f, 0.14664033f, 0.07483532f, 0.02072718f, 0.09256049f, 0.07318410f, -0.02037517f, 0.04707700f, 
    -0.26573536f, -0.25829789f, 0.02328315f, -0.09049442f, 0.01747713f, 0.03309328f, 0.03363699f, -0.04742897f, 
    0.06094127f, -0.11550183f, 0.03466765f, 0.10115971f, 0.01258369f, 0.02170613f, -0.05337898f, 0.01701922f, 
    0.04803552f, 0.06322072f, 0.02512513f, -0.11549117f, 0.04946398f, 0.05201612f, -0.03930649f, 0.05489062f, 
    -0.16863123f, -0.10611910f, 0.04899005f, -0.18248704f, 0.05505552f, 0.03399386f, 0.05185866f, 0.06751140f, 
    0.01050073f, 0.08623406f, 0.09044979f, 0.16723448f, 0.18622887f, 0.04699409f, 0.00734820f, 0.02154095f, 
    -0.03730866f, 0.08065635f, -0.06353611f, 0.06141266f, 0.04497765f, -0.01456855f, 0.10175500f, -0.14061150f, 
    0.07930520f, 0.02240941f, 0.05830964f, -0.00859586f, -0.04178263f, -0.07452451f, -0.03244957f, -0.00364929f, 
    -0.02232683f, -0.25394255f, -0.12805796f, 0.01725519f, 0.06043393f, 0.12996843f, -0.09557177f, 0.02848772f, 
    -0.11861411f, 0.02801138f, -0.01747241f, 0.06010933f, 0.06032889f, 0.01289550f, 0.12865160f, -0.02687832f, 
    0.08269545f, -0.04399564f, 0.03977396f, 0.09255530f, -0.07107494f, -0.00298520f, 0.04098743f, -0.04211138f, 
    -0.02424230f, 0.12940209f, -0.02593989f, -0.03078026f, -0.21840276f, -0.14085706f, -0.04247768f, 0.04350930f, 
    0.00171047f, 0.05832098f, -0.07744274f, -0.09361353f, 0.01330341f, -0.04833323f, -0.01701475f, -0.01281726f, 
    0.12767553f, 0.15784556f, 0.07989661f, -0.19244821f, 0.19638214f, 0.17711818f, -0.05419167f, -0.02516292f, 
    0.22148775f, -0.08677783f, -0.10482594f, 0.15405555f, -0.13206105f, -0.10047751f, 0.05006859f, 0.06373966f, 
    0.03275316f, -0.02885721f, -0.10488391f, -0.04763603f, -0.00250780f, 0.16651183f, 0.02084348f, 0.07741543f, 
    -0.55685520f, -0.45112711f, -0.32464898f, -0.06780565f, 0.05276071f, -0.00064623f, -0.03054079f, -0.07170274f, 
    0.04652193f, -0.05511396f, 0.00029750f, 0.07961480f, -0.18901360f, -0.27255550f, -0.11808445f, 0.04092365f, 
    0.00000317f, -0.09278536f, 0.05922210f, 0.11147457f, -0.02766844f, 0.09279224f, 0.01758600f, 0.07960413f, 
    -0.07252484f, -0.11391871f, -0.15576066f, -0.22867905f, -0.00327481f, 0.04766002f, 0.01796048f, -0.03223403f, 
    0.03516696f, 0.00992382f, 0.08833609f, 0.06266705f, -0.35198662f, -0.32143950f, 0.04760332f, -0.02703418f, 
    0.04954962f, 0.03556472f, 0.08714590f, 0.05251300f, 0.04202785f, -0.05880567f, 0.03516768f, 0.01530413f, 
    -0.06552533f, -0.28944373f, -0.01816856f, -0.09979227f, 0.04468235f, -0.05397014f, 0.09197348f, 0.02421315f, 
    0.01932502f, 0.03041873f, 0.02254332f, -0.01794150f, 0.25056341f, 0.01882469f, 0.02898023f, -0.03336368f, 
    0.01800322f, 0.00266262f, 0.05343664f, 0.07420696f, -0.07253049f, 0.04894517f, -0.02905359f, 0.07565037f, 
    0.36375642f, -0.25595158f, -0.01891286f, 0.23623945f, -0.24316004f, -0.05187825f, -0.09792169f, 0.04941382f, 
    -0.06115418f, 0.24239594f, 0.01397709f, 0.02266911f, -0.43799472f, 0.02298530f, 0.26913092f, 0.13818307f, 
    0.12456988f, 0.04529000f, 0.10381660f, -0.07534938f, 0.03863986f, 0.11661050f, 0.01580667f, 0.12540175f, 
    -0.42020315f, -0.29539552f, 0.00659047f, 0.02663632f, 0.04649334f, 0.02953905f, 0.09342479f, -0.03993970f, 
    0.14388752f, 0.01893950f, 0.00291101f, 0.15501156f, -0.46027294f, -0.09635652f, -0.10905997f, -0.20581397f, 
    0.07383860f, -0.03169040f, -0.06510773f, -0.01653861f, 0.03481210f, 0.09775308f, -0.00225500f, 0.07227191f, 
    0.26253501f, 0.04330477f, 0.03553592f, -0.03908214f, -0.06260921f, -0.14004134f, 0.07761539f, 0.08106029f, 
    0.07510447f, -0.04135612f, -0.07501926f, -0.05472427f, -0.16785146f, -0.07606816f, -0.19628018f, -0.12348505f, 
    0.01565069f, -0.09101048f, -0.01851978f, -0.03911987f, 0.09361232f, 0.08016223f, -0.00291880f, 0.04783549f, 
    -0.45516762f, -0.06608713f, -0.03793102f, 0.04136518f, 0.06530110f, -0.02912223f, 0.00018804f, 0.03149959f, 
    0.02603773f, 0.00020222f, -0.09738263f, 0.00626865f, 0.17198990f, 0.00694280f, -0.02242251f, 0.13322324f, 
    -0.06720900f, -0.08169591f, 0.10377885f, 0.00953526f, 0.03797561f, -0.07710694f, -0.06479953f, -0.15288655f, 
    -0.26322997f, -0.02742120f, 0.02756545f, -0.08449444f, 0.00132125f, 0.02984731f, 0.01772963f, -0.01531186f, 
    0.04397362f, -0.09169562f, -0.08973190f, 0.03562295f, -0.13890590f, -0.02131354f, 0.03007303f, -0.06415402f, 
    0.07140929f, 0.05609383f, -0.05616451f, 0.08315213f, 0.09455279f, -0.00218843f, -0.04447502f, -0.12689538f, 
    0.14903055f, -0.06821154f, -0.05429330f, 0.02141725f, 0.03200959f, 0.02788249f, 0.03809899f, 0.05724359f, 
    -0.00042901f, 0.08352817f, 0.06798986f, 0.04892003f, -0.10051216f, -0.19122107f, 0.05187541f, 0.13539119f, 
    0.10064642f, 0.08627344f, 0.06609660f, -0.11774959f, 0.02743286f, -0.07839152f, -0.13341647f, -0.09065571f, 
    0.15073487f, 0.02540901f, -0.01010812f, -0.06042167f, -0.15437025f, -0.02411908f, 0.01940943f, 0.00314664f, 
    0.04390857f, -0.08490096f, 0.01167216f, -0.15849318f, 0.32342684f, -0.04073009f, -0.02048335f, -0.08483668f, 
    0.10387257f, -0.06589145f, 0.17543967f, 0.04897213f, 0.04400921f, -0.05683616f, 0.02439393f, 0.02235186f, 
    0.14158976f, -0.00184474f, -0.06809030f, -0.12259171f, 0.07070138f, -0.05453641f, 0.07246053f, -0.06566583f, 
    -0.00947933f, 0.00793874f, 0.00772732f, 0.04258129f, -0.29874513f, -0.27532417f, -0.14694791f, -0.24005137f, 
    -0.04679566f, 0.00700171f, -0.08836500f, 0.15388146f, -0.06933267f, 0.15058117f, -0.01057616f, -0.13087298f, 
    0.08786483f, 0.00945616f, 0.05099681f, -0.03861228f, 0.02583961f, -0.09605263f, 0.02884481f, 0.09830120f, 
    -0.02290650f, 0.01428618f, 0.08102498f, 0.00024093f, 0.14267355f, -0.01216715f, -0.11957385f, 0.03452735f, 
    -0.02099805f, 0.03776769f, -0.04897752f, 0.02496783f, -0.10984316f, -0.00409262f, -0.05880736f, -0.06969561f, 
    -0.00574081f, -0.14429958f, -0.14148027f, 0.24758376f, 0.03295727f, 0.04114870f, -0.04335562f, -0.05395937f, 
    0.02709210f, 0.05021173f, 0.01102030f, 0.02112543f, -0.12507765f, 0.08398540f, 0.02132404f, 0.03037768f, 
    0.10983454f, 0.03846215f, -0.07573910f, -0.04323244f, 0.01932294f, -0.02957070f, -0.03813288f, 0.10070334f, 
    0.36419338f, 0.15781125f, -0.09595598f, -0.07322811f, 0.01344910f, -0.13739979f, -0.01617310f, 0.09266852f, 
    0.06511865f, 0.11355065f, 0.02625313f, 0.04306733f, 0.10722056f, -0.15685475f, -0.03333325f, -0.09776521f, 
    -0.03894024f, -0.01781552f, 0.06859335f, -0.04861169f, 0.00763756f, -0.06192886f, -0.08073322f, 0.07032632f, 
    0.06301481f, -0.04592845f, -0.07438777f, 0.10886919f, -0.10473853f, -0.02716390f, 0.00311550f, 0.08557991f, 
    -0.02223765f, -0.09798720f, 0.00835884f, -0.09053654f, 0.04036209f, 0.17663909f, 0.00503028f, 0.02751549f, 
    -0.08889279f, -0.11438594f, -0.01190182f, 0.00412048f, -0.01757610f, 0.04809666f, -0.04172577f, -0.00380525f, 
    0.20906159f, -0.16077161f, -0.11247993f, 0.18753842f, -0.02190099f, -0.07561439f, -0.06490605f, -0.03027019f, 
    0.04886556f, -0.02428959f, 0.02253722f, 0.02403899f, -0.04633574f, 0.05907203f, 0.07847685f, -0.10510153f, 
    -0.07497314f, 0.05352433f, -0.03046427f, 0.05065399f, -0.02126263f, -0.15447013f, 0.04543787f, 0.01873180f, 
    -0.03902297f, -0.18689334f, 0.00036047f, -0.43341392f, -0.00841465f, 0.04489576f, 0.00071827f, 0.05596966f, 
    -0.04543011f, 0.00853803f, 0.05563113f, 0.08020195f, -0.21109697f, -0.00711658f, 0.01477399f, 0.01578357f, 
    0.03088705f, 0.01604212f, -0.07150172f, 0.05378595f, -0.14393851f, 0.02281981f, 0.04278142f, -0.11709278f, 
    -0.11439636f, -0.16851667f, 0.03792235f, 0.02696694f, 0.12944253f, 0.02237413f, 0.05456221f, -0.02316034f, 
    -0.00826164f, 0.11632502f, 0.01059259f, -0.10616209f, -0.16265880f, -0.14980166f, -0.30605912f, 0.05124079f, 
    0.00180061f, -0.06778021f, 0.02897055f, 0.00620969f, -0.00897782f, 0.05558944f, 0.00160060f, -0.08690839f, 
    0.23319337f, -0.19395019f, 0.02987042f, 0.11896430f, 0.05027202f, 0.10009596f, 0.04206707f, -0.03443647f, 
    0.01614263f, -0.05298057f, -0.02398537f, 0.03577582f, 0.43463010f, -0.02452671f, -0.07887132f, 0.04762798f, 
    0.00749125f, -0.11936831f, 0.06642928f, 0.06551193f, -0.05172300f, -0.00459894f, -0.05646587f, -0.06444091f, 
    -0.23773906f, 0.04828977f, -0.05182745f, -0.08132391f, 0.08573142f, -0.02704436f, 0.02842056f, -0.07140809f, 
    -0.06097116f, -0.11238957f, 0.05404315f, -0.08002354f, -0.44363943f, 0.12079166f, -0.06254940f, 0.00821077f, 
    -0.08063177f, 0.05833536f, -0.11318813f, 0.16484657f, -0.05233642f, -0.00926146f, 0.09297859f, -0.09439290f, 
    -0.37015694f, 0.06328592f, 0.00823148f, -0.09921605f, -0.06322104f, -0.01893908f, -0.05223001f, 0.05101437f, 
    -0.08456071f, -0.01892888f, 0.07884216f, -0.14142019f, 0.14706255f, -0.07341880f, -0.00818964f, 0.13726218f, 
    -0.19521153f, 0.02676169f, -0.00364364f, -0.08580736f, 0.04233911f, -0.00058724f, 0.00603800f, -0.01846345f, 
    0.06919175f, -0.04472065f, -0.20825136f, 0.11439423f, 0.11914483f, 0.03140055f, -0.04710816f, -0.05198934f, 
    0.06753800f, -0.04236887f, -0.01446877f, -0.11600138f, -0.03518599f, 0.13880749f, -0.14223650f, -0.10549695f, 
    0.13628188f, -0.06292870f, -0.00615124f, -0.01521496f, -0.05923643f, -0.02425715f, 0.01798113f, 0.09769686f, 
    0.09556755f, -0.12880923f, 0.21874090f, 0.21958651f, -0.07537387f, 0.09679481f, 0.06721326f, 0.09820823f, 
    -0.06031000f, 0.01115129f, -0.01972078f, 0.03435126f, 0.19112155f, -0.36834118f, -0.00429433f, -0.22569501f, 
    0.09904882f, -0.13074031f, -0.04544815f, -0.02419687f, -0.06200704f, 0.04177972f, -0.06247431f, 0.05424675f, 
    -0.10809435f, 0.19674858f, -0.10775260f, -0.00598654f, -0.08590047f, -0.04352041f, -0.02074371f, -0.17772470f, 
    0.04694279f, -0.01559606f, -0.01398184f, -0.07424812f, -0.14247695f, 0.05311956f, -0.04177478f, 0.06623182f, 
    -0.00618125f, -0.10104740f, 0.08207259f, -0.09639806f, 0.03829965f, 0.03413854f, -0.08334175f, -0.00926968f, 
    -0.12469546f, 0.15525554f, 0.02172666f, 0.07138890f, 0.12077942f, -0.00259193f, 0.12127107f, -0.05812204f, 
    -0.02407983f, 0.05130675f, -0.09226488f, -0.03010370f, -0.46205533f, 0.18824290f, 0.03223358f, -0.00473463f, 
    0.13585392f, -0.04779429f, 0.06274405f, -0.09136703f, -0.08598869f, -0.02322952f, -0.05770735f, -0.06509033f, 
    -0.13765013f, -0.05354212f, -0.04560108f, -0.29226375f, -0.00087110f, 0.08023075f, -0.00720753f, 0.11448941f, 
    -0.03424875f, -0.01476992f, -0.01374173f, -0.08900452f, -0.23781669f, 0.16586965f, 0.05948712f, -0.03442870f, 
    -0.06932168f, -0.21766311f, 0.03593693f, 0.05909450f, -0.01628325f, 0.02909729f, 0.04186048f, -0.04592071f, 
    -0.19785662f, -0.00800021f, 0.05653317f, 0.02520517f, -0.00592686f, 0.07102165f, 0.01553046f, -0.11172187f, 
    -0.03386731f, 0.05166140f, -0.11380028f, -0.12743841f, 0.15705517f, 0.10799207f, -0.07418586f, 0.13067761f, 
    0.11982632f, -0.09963418f, 0.06979408f, 0.01327292f, 0.00039046f, 0.04247552f, -0.01979455f, 0.01324838f, 
    -0.30444130f, 0.05463982f, -0.09258331f, -0.08845947f, 0.02303948f, 0.00836933f, -0.00789045f, 0.11209653f, 
    -0.03423445f, -0.03907688f, -0.05583454f, -0.06582959f, 0.20757371f, 0.07068193f, 0.03769868f, 0.10977422f, 
    -0.04998635f, 0.01172810f, 0.04629351f, 0.12787533f, -0.04294359f, 0.08785260f, -0.11189116f, -0.02107704f, 
    0.17919271f, -0.43139410f, -0.08970815f, -0.02617939f, 0.02846901f, -0.12354224f, -0.04687168f, 0.09267510f, 
    -0.07139093f, 0.05356213f, 0.02647505f, 0.00103941f, 0.07178563f, 0.01044087f, -0.14124259f, 0.12969697f, 
    0.05208263f, -0.06262395f, 0.05949039f, -0.01612836f, 0.02003961f, -0.00352902f, 0.06627385f, 0.01797622f, 
    0.03181583f, 0.04334445f, -0.03976419f, -0.13250865f, -0.09258672f, -0.01077834f, 0.04416527f, -0.07222050f, 
    -0.02457834f, 0.09226604f, 0.00955693f, -0.13157004f, 0.03799492f, -0.00221019f, -0.16314402f, 0.00351711f, 
    -0.08611702f, 0.03244984f, -0.00427186f, -0.06712715f, -0.00783182f, -0.03704232f, -0.10759214f, -0.10640721f, 
    0.01429273f, -0.12919737f, 0.05555839f, -0.03733426f, -0.00689916f, -0.00469789f, -0.03449967f, 0.05330088f, 
    0.07025218f, 0.00730721f, 0.07140212f, -0.09508637f, -0.04226430f, -0.22937249f, 0.06020960f, -0.21904850f, 
    -0.02931327f, -0.08205982f, 0.01166012f, 0.07361949f, 0.09831215f, 0.06689838f, -0.04583231f, 0.01505097f, 
    0.02540374f, -0.13455801f, 0.00836567f, 0.15374808f, -0.13696325f, 0.05432573f, -0.04264391f, 0.05432427f, 
    0.03147450f, -0.03180150f, -0.04057078f, -0.06730229f, 0.03875159f, 0.03147962f, 0.00162766f, 0.10172758f, 
    -0.00351380f, 0.02595796f, -0.02959742f, -0.04271599f, 0.01813447f, -0.07658999f, -0.07914995f, 0.02514058f, 
    -0.31827199f, 0.08924398f, -0.12103201f, -0.09690301f, 0.16350937f, -0.02151492f, 0.10714900f, 0.16346802f, 
    0.17653467f, 0.02641317f, 0.11977187f, -0.00062759f, -0.14507285f, 0.08775495f, 0.08413232f, -0.12372468f, 
    0.10482053f, -0.09121499f, -0.08017921f, 0.09732991f, 0.05786075f, -0.04033051f, -0.05139699f, -0.02499481f, 
    0.06678589f, -0.21215546f, -0.13659216f, -0.07666128f, -0.05173642f, -0.00947361f, -0.02566422f, -0.05677077f, 
    -0.04684087f, -0.03973440f, -0.10691912f, -0.10352688f, 0.40177909f, 0.15758957f, -0.18558753f, -0.03170984f, 
    0.06628160f, 0.11776469f, 0.01843938f, 0.03970946f, 0.07876605f, 0.06930864f, -0.06051097f, -0.00033113f, 
    -0.03935396f, -0.05697906f, -0.00941759f, -0.15243658f, 0.12147963f, -0.00679662f, 0.03859710f, -0.00385069f, 
    0.12409956f, 0.07324726f, -0.02119882f, 0.12246647f, 0.03624067f, 0.01966341f, -0.23189217f, -0.08884317f, 
    0.12131773f, -0.01011269f, 0.07126303f, 0.16892712f, -0.06081651f, -0.00840232f, -0.00457056f, 0.00223960f, 
    -0.20066383f, -0.08527726f, 0.24457790f, 0.03750162f, 0.14260462f, -0.01231021f, -0.03653028f, -0.03296766f, 
    -0.05334328f, -0.11229075f, 0.01087133f, -0.00011987f, 0.22566605f, 0.13907586f, -0.03263321f, -0.18816864f, 
    0.10715990f, -0.09103107f, -0.08392427f, 0.19385473f, -0.07443048f, -0.01508976f, 0.10378040f, -0.06823312f, 
    0.19862549f, 0.06065048f, 0.00044927f, 0.11309844f, 0.06920877f, 0.06483708f, -0.08077643f, 0.03372125f, 
    0.04840254f, 0.00758559f, 0.03511568f, -0.05695127f, 0.19382998f, 0.11346269f, -0.11316803f, 0.00166008f, 
    0.10469649f, -0.03836887f, -0.04322128f, 0.01428833f, -0.03804624f, -0.01300853f, -0.03466767f, -0.06691859f, 
    -0.14986254f, -0.03885242f, 0.11502954f, -0.17417955f, 0.03046342f, 0.02697065f, 0.04774280f, -0.06144588f, 
    -0.03250710f, 0.02778637f, 0.08556499f, 0.15063962f, 0.09546258f, -0.06918658f, -0.14211646f, -0.05661462f, 
    0.03518657f, -0.02652127f, 0.07837261f, -0.10826717f, 0.10460834f, 0.06208095f, 0.01329750f, -0.02719796f, 
    0.47375527f, -0.19082141f, 0.00736228f, -0.00000365f, 0.01963036f, -0.07933109f, -0.13856530f, -0.07998670f, 
    0.13251600f, 0.05857495f, 0.10388950f, 0.06197201f, -0.01874186f, -0.12937254f, -0.19680224f, -0.18878330f, 
    -0.11622626f, 0.15294439f, 0.03518264f, -0.12981020f, 0.05318370f, 0.04949668f, -0.01897179f, 0.09956567f, 
    0.45914105f, 0.07354315f, -0.10778798f, 0.03889440f, -0.05850257f, -0.03245305f, -0.11563298f, -0.05791262f, 
    -0.02497060f, -0.00479545f, 0.07096616f, 0.02972429f, -0.18496533f, 0.03249756f, 0.00702799f, 0.09871099f, 
    -0.03369886f, 0.16295683f, -0.03564063f, -0.02394225f, 0.09192382f, -0.02233210f, 0.00062292f, 0.09454005f, 
    0.13561380f, 0.08540200f, 0.05199671f, -0.06612705f, -0.15524556f, 0.17221530f, -0.08722155f, -0.10159156f, 
    -0.06265220f, -0.09214845f, -0.02196448f, -0.05580426f, 0.30237156f, 0.06760103f, -0.00661682f, 0.02175886f, 
    0.08490905f, -0.03520973f, -0.02528123f, -0.03603764f, 0.02817665f, 0.06695836f, 0.00418097f, 0.10652203f, 
    -0.06495795f, 0.02348930f, -0.20678696f, -0.00695859f, -0.07560712f, -0.06675593f, 0.02676985f, -0.21605878f, 
    -0.03793250f, -0.01219462f, 0.05026408f, 0.08519869f, 0.00951650f, -0.08682880f, 0.00103616f, 0.31587660f, 
    0.01437700f, -0.00551595f, 0.07587644f, 0.00464000f, -0.02735950f, -0.05564713f, 0.07044796f, 0.04664070f, 
    0.11715119f, 0.10547464f, -0.03686142f, 0.02179220f, 0.03853228f, -0.10791302f, -0.17623778f, -0.06744683f, 
    -0.02224249f, 0.03573442f, -0.04092139f, -0.07887254f, -0.14130443f, -0.24753314f, 0.00112408f, -0.14201316f, 
    0.13172762f, 0.03314731f, 0.01770126f, -0.03514692f, -0.11050328f, 0.03438080f, -0.01067056f, -0.03276379f, 
    0.21051057f, -0.04218110f, 0.15292969f, 0.13708287f, -0.09045059f, -0.02924354f, 0.04057797f, -0.04164580f, 
    -0.05739073f, -0.01254862f, -0.05332514f, 0.00521488f, -0.32276985f, 0.11655027f, -0.17560226f, -0.12300840f, 
    0.04096793f, 0.01931631f, 0.15151401f, 0.00946868f, 0.02882200f, -0.00812415f, 0.10091560f, 0.02771173f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02526555f, 0.00662731f, -0.04710807f, 0.01005284f, -0.03360195f, 0.00502410f, 0.00022715f, -0.08005504f, 
    -0.04996265f, 0.03078524f, 0.05427761f, 0.03999338f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
