#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.58892947f, -0.08232705f, 0.71074903f, 0.01165191f, 0.87651283f, 0.60688764f, -0.45383936f, -0.09370674f, 
    -0.41403383f, -0.03181037f, 0.30093619f, 0.32449925f, -0.18231368f, 0.24453853f, -0.11364946f, 0.31648305f, 
    -0.19052608f, 0.17503139f, 0.24042137f, 0.23412330f, 0.02075048f, 0.08028094f, 0.01860996f, -0.04995741f, 
    0.11766383f, 0.37249452f, 0.24340934f, -0.21822365f, 0.71303189f, -0.40985480f, 0.61647224f, -0.11531747f, 
    -0.04809260f, -0.26920396f, -0.57968968f, 0.35322767f, 0.31803119f, -0.03225860f, -0.30066976f, -0.40614870f, 
    0.17049609f, 0.00851736f, 0.11625976f, 0.38813937f, -0.12924752f, -0.03712138f, -0.17906742f, -0.11379041f, 
    0.07472707f, 0.34398863f, 0.04701567f, 0.47266608f, 0.32174176f, 0.69663119f, -0.11885276f, -0.03755985f, 
    0.07621282f, 0.31127366f, 0.44853476f, -0.06589402f, 0.25116354f, -0.06769775f, -0.27301008f, -0.26450303f, 
    -0.16355360f, -0.06488378f, -0.06494388f, 0.10530891f, 0.12184341f, 0.00274255f, -0.29987168f, -0.25786912f, 
    0.19084117f, 0.11022127f, -0.12680313f, 0.56721848f, 0.48869017f, 0.82694495f, 0.19161667f, 0.58487910f, 
    0.53300506f, -0.05207163f, -0.12819344f, 0.04830631f, 0.02468373f, 0.41951451f, 0.29679358f, -0.18045421f, 
    -0.01215952f, -0.13688578f, -0.14503311f, 0.25592884f, 0.27608559f, -0.13319047f, -0.17259362f, -0.05523808f, 
    0.00320620f, 0.04356325f, -0.17130218f, 0.07622129f, -0.38022935f, -0.95518470f, -0.40494791f, -0.27208939f, 
    0.02508866f, -0.58737653f, 0.55665183f, 0.51134926f, -0.29765150f, 0.18570417f, 0.28132582f, -0.14518692f, 
    0.23675770f, -0.02181604f, 0.00904382f, -0.25512433f, -0.09162545f, 0.03119589f, -0.13216990f, -0.18641925f, 
    -0.10675995f, 0.21729922f, -0.12036957f, -0.07813078f, -0.08995370f, -0.22897528f, 0.25015977f, -0.34283870f, 
    -0.50880271f, -0.67505270f, 0.48179135f, -0.45262623f, 0.13743499f, 0.29702452f, 0.02746751f, 0.25037906f, 
    -0.11574875f, -0.32910028f, 0.20142412f, 0.10840923f, 0.15991512f, -0.00846130f, 0.22177413f, -0.02355743f, 
    0.36020169f, 0.32266721f, -0.36440644f, 0.42754892f, -0.26340547f, -0.02814656f, 0.55987245f, 0.04530369f, 
    -0.04236451f, 0.18519630f, 0.22011311f, 0.23345326f, 0.38927135f, 0.53188723f, 0.61700100f, 0.43158010f, 
    -0.27527601f, -0.36138970f, 0.06914105f, -0.07331955f, -0.32278329f, -0.21367824f, 0.00143062f, -0.13189094f, 
    -0.02540322f, -0.33368874f, -0.01368828f, 0.11048168f, -0.23048453f, -0.21850367f, 0.24922292f, 0.12304480f, 
    -0.87979168f, -0.54052687f, -0.37185490f, 0.23991355f, -0.24376681f, 0.81591016f, 0.22555792f, -0.05336517f, 
    0.42519447f, -0.05596800f, -0.22560033f, -0.47477657f, -0.04014636f, -0.04087009f, -0.02207160f, 0.11055594f, 
    -0.24363513f, 0.09268756f, -0.01187418f, -0.01700632f, -0.00503406f, 0.13832705f, 0.22910033f, 0.01853909f, 
    0.29189974f, 0.36241859f, -0.37709209f, -0.72875553f, -0.28030968f, 0.70901167f, 0.22460374f, -0.08685602f, 
    0.41259131f, 0.11068407f, 0.01777568f, 0.13584828f, 0.20075727f, -0.01024446f, -0.06370846f, -0.00184106f, 
    -0.17779280f, 0.09562588f, 0.18101376f, 0.49900594f, -0.02066744f, -0.23269407f, -0.18253312f, -0.16466478f, 
    0.08918745f, -0.46044737f, -0.20438024f, -0.12586996f, 0.39879501f, 0.31044570f, -0.67116618f, 0.79546261f, 
    0.51084608f, -0.65246052f, 0.17059895f, 0.22184156f, 0.20240879f, 0.24930809f, -0.17241026f, 0.28451842f, 
    -0.26240730f, 0.07566918f, 0.12434335f, 0.03439081f, -0.33736700f, -0.09840833f, -0.15803894f, 0.03978067f, 
    0.11483595f, -0.16077535f, -0.25542742f, 0.17642210f, 0.27598351f, 0.90879953f, -0.50656283f, -0.44532162f, 
    0.06539481f, -0.59622204f, 0.40337515f, 0.02552226f, 0.44206303f, 0.13842088f, -0.29670742f, -0.18788143f, 
    -0.27690288f, -0.05953061f, 0.00905902f, -0.18593889f, -0.06005542f, -0.04351226f, 0.24987829f, -0.08866471f, 
    -0.14148371f, 0.07309601f, -0.26929095f, -0.66664511f, 0.06043737f, -0.32749075f, -0.39222914f, -0.32366347f, 
    0.31735548f, 0.70868808f, -0.43591145f, 0.13583970f, 0.26670280f, 0.08275703f, -0.15678605f, -0.44322050f, 
    -0.36054829f, -0.02984935f, 0.15291972f, 0.04780110f, 0.02609854f, 0.10903908f, -0.23697354f, 0.03138009f, 
    0.09131769f, -0.23524958f, -0.02187082f, -0.05595301f, -0.08975617f, -0.64895087f, -0.10656889f, -0.40228516f, 
    -0.40726128f, -0.29815343f, 0.36046883f, -0.13643165f, -0.42394698f, 0.16588470f, 0.33914185f, -0.43526846f, 
    0.09219540f, -0.30167532f, 0.34555295f, -0.14584847f, 0.13472414f, 0.02717867f, -0.19098008f, 0.12644352f, 
    0.25364801f, 0.14284517f, 0.04226100f, 0.48983139f, -0.38875780f, 0.49882975f, -0.04514993f, 0.61468339f, 
    0.69029546f, -0.66354942f, 0.00946323f, -0.29114100f, 0.38244569f, 0.12426575f, 0.55793548f, 0.07600747f, 
    -0.17375790f, -0.11677654f, -0.22495893f, -0.33267424f, -0.33294809f, -0.00503258f, -0.32279700f, -0.31430858f, 
    -0.19206910f, 0.09937735f, 0.06577244f, -0.07494195f, -0.03090903f, -0.30075136f, 0.04444191f, -0.29380971f, 
    0.51751143f, 0.83012551f, 0.37581521f, 0.39524624f, 0.27632979f, -0.26241955f, -0.61141986f, 0.30456534f, 
    -0.05344626f, 0.05287649f, 0.19818072f, -0.02738398f, 0.15698366f, 0.13168786f, 0.13542745f, 0.22675225f, 
    -0.30376321f, 0.16862531f, 0.32983822f, 0.04400007f, -0.21803014f, 0.40083668f, -0.24746433f, -0.51049155f, 
    -0.21210091f, -0.00630602f, -0.42495519f, -0.17135671f, 0.15724880f, -0.45566544f, 0.42063013f, 0.23402318f, 
    -0.38034827f, 0.11964095f, -0.23883496f, 0.15596779f, 0.22945501f, -0.35236025f, -0.31425771f, 0.35103974f, 
    -0.06290118f, -0.47336072f, -0.22268583f, -0.05267044f, 0.34008506f, 0.14936750f, -0.20649542f, -0.10787282f, 
    -0.36093318f, -0.04625314f, 0.80005956f, -0.77755368f, -0.70566869f, 0.34449190f, -0.58455962f, -0.17117843f, 
    -0.31055334f, -0.14337862f, 0.20699534f, 0.44250590f, -0.00678970f, -0.09088812f, 0.10246960f, -0.26368675f, 
    0.29402667f, -0.31458062f, 0.11956999f, 0.11970259f, 0.18455414f, 0.35549963f, 0.02684830f, 0.06759945f, 
    0.17816554f, -0.67754459f, -0.41120934f, -0.05043224f, 0.40915272f, -0.24505253f, -0.57844496f, 0.49021253f, 
    0.09365080f, -0.07413427f, -0.16378349f, -0.16609570f, 0.02179269f, 0.13712120f, 0.23114531f, -0.19144624f, 
    -0.24598326f, -0.02186991f, -0.21086563f, -0.07572302f, -0.12676862f, 0.24720456f, 0.24459291f, 0.22466111f, 
    -0.33870646f, 0.02655635f, 0.31389746f, 0.46298125f, 0.00980283f, -0.03174007f, 0.33999342f, -0.30445960f, 
    -0.44556224f, 0.44929338f, -0.10686609f, 0.39750254f, 0.07089261f, 0.26414308f, 0.06380370f, 0.03567320f, 
    0.17029826f, -0.15699787f, 0.08119523f, -0.13896491f, 0.14715865f, 0.16678908f, 0.47363946f, -0.29980171f, 
    0.12216102f, -0.47591105f, -0.23113732f, -0.52349746f, -0.66315913f, 0.25485897f, -0.30381531f, -0.05896798f, 
    -0.40714040f, 0.15200931f, 0.32958254f, -0.02067235f, 0.27658433f, 0.04634400f, 0.38945439f, -0.01445187f, 
    -0.23918495f, -0.24000755f, -0.10061909f, 0.19307755f, -0.10891086f, 0.19661526f, 0.12776031f, 0.43134779f, 
    -0.10024214f, 0.21392527f, -0.04034666f, -0.04679838f, 0.59496409f, 0.34530941f, -0.57745117f, -0.56564504f, 
    -0.59243643f, 0.09095301f, -0.15398519f, -0.19837615f, 0.08293540f, 0.07402979f, 0.49281827f, -0.25573075f, 
    -0.22054183f, 0.14083089f, -0.11881697f, 0.10018747f, 0.18006006f, 0.00466804f, 0.14280763f, -0.01408018f, 
    -0.17078118f, -0.14808910f, 0.13091202f, -0.03882565f, 0.38731149f, 0.99354941f, 0.26130784f, 0.18235107f, 
    0.67907512f, 0.77546906f, -0.56560475f, 0.20229541f, -0.07613429f, -0.26977527f, -0.00385132f, 0.21404310f, 
    -0.15740167f, 0.11925969f, 0.02824670f, 0.07923584f, -0.10971069f, -0.28640029f, 0.00668901f, 0.07906689f, 
    -0.07738879f, -0.12519771f, -0.13535444f, -0.13040102f, -0.08977039f, 0.07821396f, 0.96930337f, 0.55145460f, 
    0.54943949f, 0.65906554f, 0.85994756f, -0.18526925f, 0.09720435f, -0.48339951f, 0.32394052f, -0.01845634f, 
    -0.22433737f, -0.03875567f, 0.23309404f, -0.05298999f, 0.09122236f, -0.14640330f, 0.06838083f, 0.03608004f, 
    0.11908770f, 0.03352021f, 0.02388324f, 0.00775813f, -0.06563947f, -0.08252194f, -0.03905510f, 0.79575801f, 
    -0.70550835f, 0.48752692f, 0.47476107f, -0.35630059f, 0.58423406f, 0.32988507f, 0.06131896f, -0.13340916f, 
    -0.16153885f, 0.03802524f, 0.21076500f, 0.02934413f, 0.30497271f, 0.30547729f, 0.21214393f, -0.15395424f, 
    0.18329944f, 0.08349801f, 0.01642201f, -0.04149089f, 0.25377518f, 0.17584948f, 0.11088204f, 0.17809242f, 
    0.44032669f, -0.48703691f, -0.35147616f, -0.42992637f, 0.79701072f, 0.81800139f, -0.36028096f, -0.70965219f, 
    -0.08640040f, -0.23329915f, -0.41215158f, 0.23529114f, 0.07323451f, -0.13249968f, 0.08622487f, -0.02084175f, 
    -0.09324483f, 0.05606604f, 0.34639212f, -0.21133655f, 0.18971989f, 0.20672305f, -0.19825616f, -0.14618757f, 
    0.13126393f, 0.60203999f, 0.73795742f, 0.12107000f, 0.28838119f, 0.54681444f, -0.43608961f, -0.03810398f, 
    0.28348207f, -0.35089198f, 0.29025006f, -0.28862914f, -0.35309574f, 0.22165553f, -0.04810788f, 0.27303004f, 
    0.05538737f, -0.18542695f, -0.06898852f, 0.07117233f, 0.10896882f, 0.41536772f, 0.03921618f, 0.11243168f, 
    0.37058523f, -0.02059129f, 0.40555227f, 0.78632301f, -0.31415325f, -0.05055343f, -0.79540443f, 0.19000821f, 
    -0.46467403f, -0.17662795f, -0.24543244f, 0.41193309f, 0.34448394f, 0.17202862f, -0.21606328f, 0.12692250f, 
    -0.12234907f, -0.01195218f, -0.19102620f, 0.29116806f, 0.02662371f, 0.07798976f, -0.15215848f, 0.00452018f, 
    -0.28547430f, -0.21644430f, -0.27990010f, 0.28194818f, 0.46569875f, 0.78805089f, -0.32660863f, -0.41113791f, 
    -0.51450819f, -0.43049553f, 0.00813517f, 0.12042338f, 0.34913233f, 0.48850438f, 0.40089917f, 0.10447761f, 
    0.20650281f, -0.02636160f, 0.02163435f, 0.04623917f, -0.21436247f, -0.30448809f, -0.03953011f, 0.39928785f, 
    -0.09428460f, -0.10199073f, -0.09634158f, 0.27861044f, -0.18737346f, -0.58159298f, -0.09117468f, 0.22425468f, 
    -0.05329004f, -0.69245785f, -0.12358616f, -0.36726528f, -0.78533196f, -0.21661934f, 0.32039267f, 0.46472463f, 
    0.31628147f, 0.20388003f, -0.32088521f, -0.05374482f, -0.16633332f, -0.10665233f, 0.00664686f, -0.11540550f, 
    -0.20122270f, -0.26698527f, -0.04722994f, 0.23101866f, -0.03051982f, -0.62881953f, -0.03799016f, 0.48607421f, 
    0.66305864f, -0.42087424f, 0.30046952f, -0.01046660f, 0.40028352f, -0.27569339f, 0.07777017f, -0.42252040f, 
    -0.12177070f, -0.53592700f, -0.22467281f, -0.38684136f, -0.30964923f, -0.10820710f, -0.19103484f, -0.19161871f, 
    -0.32054475f, 0.00105565f, -0.03411208f, -0.26965445f, -0.09876410f, -0.22546495f, -0.64303672f, -0.07160289f, 
    -0.61069888f, -0.60186321f, 0.15783617f, 0.17194921f, 0.63823837f, 0.43806443f, 0.11499964f, 0.63781607f, 
    0.07631722f, -0.06129936f, 0.37601349f, -0.39727628f, -0.06558368f, -0.04904574f, -0.02939556f, 0.08510323f, 
    0.24903412f, -0.35559222f, -0.22821642f, -0.15959284f, -0.26210690f, 0.02154204f, 0.03251625f, -0.52560139f, 
    -0.51023656f, -0.44751412f, -0.53257322f, 0.08521114f, -0.03065796f, -0.43155086f, -0.14013056f, -0.00245284f, 
    -0.43646160f, -0.28960648f, -0.05951377f, -0.46256217f, -0.19666103f, -0.20669861f, -0.11962648f, 0.20504716f, 
    -0.41389063f, 0.11129013f, 0.02007054f, -0.18902260f, -0.12971011f, -0.11831507f, 0.02833058f, 0.04579168f, 
    0.75931901f, 0.00070705f, 0.23437937f, 0.82138568f, -0.17237236f, -0.75712872f, 0.02091905f, -0.03834968f, 
    -0.39806071f, -0.03310835f, 0.08717526f, -0.01746109f, -0.13915113f, 0.05896029f, -0.05588040f, -0.16120929f, 
    0.18643217f, 0.11631365f, 0.07912837f, 0.45814446f, -0.28749067f, 0.06519997f, 0.41662252f, -0.06345494f, 
    0.18993515f, -0.71030027f, 0.90352857f, -0.43748671f, -0.00731554f, -0.16930935f, 0.18071111f, -0.22333409f, 
    -0.35203871f, 0.42502266f, -0.55026978f, -0.30312154f, -0.17321882f, -0.20853543f, 0.43195558f, -0.11162999f, 
    0.19222063f, -0.19360940f, 0.19605713f, 0.31643844f, 0.31117529f, -0.06168919f, 0.01902521f, -0.13448684f, 
    0.14573596f, 0.11566742f, -0.25618368f, -0.51653248f, -0.32522359f, -0.13149650f, -0.24903576f, 0.06651966f, 
    -0.16427921f, -0.35385963f, 0.42304632f, -0.48385680f, 0.37204167f, 0.03034501f, -0.37461615f, 0.26184180f, 
    -0.15825216f, -0.30057877f, 0.18802977f, -0.48488554f, -0.00729018f, 0.22759773f, 0.24534874f, 0.13107519f, 
    0.23786855f, -0.05230615f, -0.08335491f, -0.05723562f, -0.35214084f, -0.55710894f, -0.48810092f, -0.55737764f, 
    0.54991055f, 0.74640441f, 0.03350260f, -0.18691812f, 0.14436956f, -0.22094418f, 0.15911745f, -0.10404696f, 
    0.16351998f, 0.00392911f, -0.26027530f, -0.08123340f, 0.13419022f, -0.01219975f, -0.13609631f, -0.25617322f, 
    0.02236343f, -0.27851072f, 0.13130103f, 0.14055991f, -1.06427658f, 0.28330776f, 0.24330473f, -0.41708115f, 
    -0.03791733f, 0.42758563f, 0.04594234f, -0.41103250f, 0.00191446f, 0.02902451f, 0.08938638f, 0.00256378f, 
    -0.17317492f, 0.17230478f, -0.20192981f, -0.08260369f, -0.24871448f, -0.23211172f, -0.30809736f, -0.26909715f, 
    -0.09967621f, 0.28154424f, 0.34506649f, -0.04308565f, 0.03260442f, -0.33472997f, -0.07031535f, -0.72823524f, 
    -0.49177840f, -0.48473224f, 0.33980924f, 0.23704265f, 0.13133153f, 0.43837881f, -0.06777974f, -0.32208714f, 
    -0.10886105f, 0.07755340f, -0.26775101f, -0.10506038f, -0.01540817f, 0.03976610f, 0.29310277f, 0.05705475f, 
    -0.30186912f, 0.20101510f, -0.09477320f, 0.18718438f, -0.04269449f, 0.28383824f, 0.68465257f, 0.39997104f, 
    -0.77752626f, -0.57458192f, -0.10914772f, 0.31298509f, -0.29671827f, -0.29587778f, -0.39690742f, -0.06297697f, 
    0.15878968f, 0.48549604f, 0.48489544f, 0.30786556f, -0.06853884f, 0.11676509f, -0.04725356f, 0.08640353f, 
    -0.04367596f, 0.16226381f, 0.03394924f, 0.10545716f, 0.31574559f, 0.20021349f, -0.09754912f, 0.10169516f, 
    -0.46168819f, -0.02626057f, 0.41965568f, 0.50473642f, -0.35215533f, -0.71065146f, -0.74455023f, -0.31014490f, 
    -0.19340795f, -0.42805755f, 0.46398270f, 0.27933142f, 0.18248990f, 0.16932489f, 0.22072081f, 0.13323973f, 
    0.30935425f, 0.19422826f, -0.11866777f, 0.16996431f, 0.05033943f, -0.03443425f, 0.30523419f, 0.11743553f, 
    0.54074013f, 0.12363065f, -0.12251813f, 0.76690292f, 0.37715021f, 0.01108702f, -0.45584041f, -0.24046490f, 
    -0.50523174f, -0.08057929f, -0.32139945f, 0.29340783f, 0.16594432f, 0.00830486f, -0.43219489f, 0.18156591f, 
    0.49265942f, 0.04783684f, -0.10071911f, -0.07336265f, -0.06248293f, 0.05291377f, -0.20952456f, -0.27552077f, 
    -0.08927132f, 0.19014588f, 0.12735972f, 0.01070734f, 0.05430226f, -0.43604136f, 0.65269792f, 0.64078349f, 
    0.22161016f, 0.56417555f, 0.32738528f, 0.00586699f, 0.08172310f, -0.07522183f, -0.10039504f, 0.09134621f, 
    0.10682667f, -0.47135919f, -0.11713824f, -0.10194870f, -0.13381033f, 0.36083907f, 0.29601711f, 0.07748943f, 
    0.07353869f, 0.17512321f, -0.24633722f, -0.61766672f, -0.58879536f, -0.42954379f, -0.14791435f, -0.42841700f, 
    0.34132978f, 0.22701932f, 0.25027832f, 0.35821038f, -0.16134606f, 0.11718190f, 0.17749277f, -0.11835085f, 
    -0.19487683f, -0.02707766f, 0.09823851f, 0.17577468f, -0.32478663f, -0.08610816f, 0.00495452f, 0.05731758f, 
    0.03660099f, 0.38085407f, -0.05894380f, 0.26874936f, 1.01029027f, 0.65534139f, -0.32948652f, -0.55910128f, 
    -0.53338248f, -0.53474259f, -0.07190255f, -0.35805196f, 0.15266062f, -0.20459454f, 0.02968161f, -0.19063108f, 
    -0.13692772f, 0.38451943f, -0.40085647f, -0.19755523f, 0.03647882f, -0.16159247f, -0.38251030f, 0.29964626f, 
    0.19991142f, -0.33616999f, 0.07033126f, 0.13225895f, 0.49675855f, -1.07336664f, -0.03767266f, 0.66677105f, 
    -0.12670229f, -0.78367060f, 0.66979718f, 0.05329164f, 0.17488484f, -0.11892426f, 0.05141910f, 0.26955450f, 
    0.11031674f, 0.16851074f, -0.01253695f, -0.40970296f, -0.03505397f, -0.27141646f, -0.08229797f, -0.23712558f, 
    -0.12154714f, 0.22774379f, -0.06872182f, 0.18290648f, 0.14324556f, -0.63269496f, -0.47272792f, -0.77866441f, 
    0.41502088f, 0.11211289f, 0.44299015f, 0.18499297f, 0.22379075f, 0.15376213f, 0.36847219f, -0.11691741f, 
    0.03173291f, -0.10066358f, -0.30329388f, 0.17909881f, -0.20662548f, 0.18359125f, 0.47077876f, -0.14104541f, 
    -0.33664927f, -0.37282401f, -0.29143324f, -0.47344035f, -0.27469775f, -0.04180431f, 0.48732316f, -0.33934313f, 
    -0.55094200f, 0.13895889f, -0.35354868f, -0.76010919f, 0.52942747f, 0.49226490f, -0.67658627f, 0.04640835f, 
    0.17120743f, -0.06249700f, 0.07059865f, -0.36649644f, 0.35588497f, -0.22314538f, 0.33146116f, 0.30636311f, 
    0.10390499f, -0.08430479f, 0.10582591f, 0.02531772f, -0.18631552f, -0.03938359f, 0.21441546f, -1.27057254f, 
    1.01931989f, 0.17871092f, -0.29350755f, -0.61605901f, 0.52470517f, 0.68709821f, -0.19797806f, 0.40401018f, 
    0.42255592f, -0.30202085f, -0.06281560f, -0.16918929f, -0.28199929f, 0.01969895f, 0.10374038f, 0.18217184f, 
    -0.21831889f, -0.06413419f, -0.08841939f, -0.07157534f, 0.02619299f, 0.17437807f, 0.24261355f, 0.04205709f, 
    -0.01535145f, 1.04271758f, -0.08991686f, 0.16187787f, 0.14526191f, 0.55805683f, -0.05465176f, -0.69167036f, 
    -0.19446784f, -0.38002232f, 0.27562296f, 0.00184012f, -0.00650899f, -0.05773144f, -0.20337546f, -0.04140425f, 
    -0.11960603f, -0.06015058f, -0.01507862f, -0.09606274f, 0.01559085f, 0.23563246f, -0.18071754f, -0.07853010f, 
    0.15361218f, -0.47510940f, -0.29299846f, -0.05551635f, 0.47278658f, 0.23237571f, 0.66020060f, 0.53827822f, 
    0.25869507f, 0.29914790f, 0.05346057f, 0.09318802f, -0.38727757f, -0.29415601f, 0.22491190f, 0.20288385f, 
    0.18263781f, 0.04458794f, -0.01719796f, 0.15140730f, -0.18477422f, -0.03921238f, -0.09350576f, -0.04423312f, 
    0.11405250f, -0.27081108f, -0.66748816f, 0.17604050f, 0.53094578f, -0.09278463f, 0.58964020f, -0.84413701f, 
    0.72359306f, -0.29113454f, -0.77985656f, -0.27637765f, 0.21592531f, 0.31654921f, 0.31839204f, -0.00652485f, 
    -0.20340221f, -0.00094773f, -0.18359654f, 0.03084427f, 0.16589910f, 0.19801223f, 0.09598330f, 0.11013721f, 
    -0.02341582f, 0.05165255f, 0.14886020f, -0.39448610f, -1.28606200f, 0.40983853f, 0.49800611f, 0.18774720f, 
    0.34806234f, 0.26568627f, 0.23736346f, -0.14151381f, 0.07127985f, -0.11273634f, -0.02279933f, -0.35572195f, 
    0.42832661f, 0.08352716f, 0.34149709f, 0.26194799f, -0.19077848f, 0.10218858f, -0.25496826f, 0.24067624f, 
    -0.16971251f, -0.08043546f, -0.06289780f, 0.02587232f, -0.58757389f, 0.63096422f, 0.39932641f, -0.81027770f, 
    0.00906046f, 0.04224710f, 0.14994301f, -0.41360289f, -0.41333750f, -0.55393404f, 0.03897242f, 0.32352972f, 
    -0.23455212f, 0.11680177f, -0.23011404f, -0.22293931f, 0.11666303f, -0.18229100f, -0.28721803f, 0.15984093f, 
    0.12218828f, 0.05987502f, 0.26845002f, 0.35784712f, 0.05396082f, 0.04598180f, 0.01206124f, -0.66379708f, 
    -0.51070684f, -0.06812149f, 0.03214362f, -0.63088483f, 0.16873702f, 0.32639942f, -0.42748052f, -0.35726500f, 
    -0.29980931f, -0.16130430f, -0.18879923f, -0.06726436f, 0.16306362f, -0.06626169f, -0.20630892f, -0.18986021f, 
    0.15859216f, -0.14004466f, 0.39826760f, 0.19505523f, 0.50228149f, -0.19281207f, 0.87627548f, 0.61836249f, 
    0.54474586f, 0.53307331f, 0.36019227f, 0.37857577f, 0.25456163f, -0.38834843f, 0.21016300f, 0.21609548f, 
    -0.14076968f, 0.26840803f, -0.28699061f, 0.08048593f, 0.05805631f, 0.16560651f, -0.08145101f, -0.09954771f, 
    -0.07399585f, 0.21406646f, -0.03473323f, 0.17295237f, 0.16763821f, 0.04215125f, 0.50661498f, -0.12123141f, 
    -0.17921585f, -0.51816314f, -0.47968376f, 0.07146738f, 0.09296748f, -0.43522409f, 0.27799767f, -0.29981562f, 
    0.20968716f, -0.41063043f, -0.06775132f, 0.39872813f, -0.06582785f, -0.08316275f, 0.10553521f, -0.29897812f, 
    0.20972720f, 0.38796008f, 0.24548611f, 0.52654153f, 0.21218525f, -0.25703755f, 0.30682123f, -0.35980570f, 
    0.95296991f, 0.12680382f, 0.52815300f, -0.17170472f, -0.55179584f, 0.42490256f, -0.29170474f, 0.11718527f, 
    0.41190827f, 0.60946608f, -0.00419662f, 0.08650819f, 0.03904365f, -0.32607660f, -0.09688710f, -0.28048345f, 
    0.08314032f, -0.09914755f, -0.34037942f, 0.07234216f, 0.17871122f, -0.13780831f, 0.46212009f, 0.06998869f, 
    -0.19366707f, -0.67214638f, 0.86736524f, 0.69449395f, -0.33466065f, 0.46869874f, 0.46008527f, -0.40251154f, 
    -0.32446814f, -0.28879294f, -0.58260995f, -0.09412638f, -0.27867162f, 0.06011903f, 0.03139681f, -0.32883245f, 
    -0.16848832f, -0.02448473f, 0.01715488f, -0.36947086f, -0.03341434f, -0.21216939f, -0.00691535f, -0.14273790f, 
    0.03767862f, 0.01124565f, 0.75410593f, -0.39659804f, -0.23233093f, 0.75844979f, 0.59794909f, 0.58885342f, 
    0.12496080f, 0.13924754f, 0.33476150f, 0.24658103f, -0.00714690f, -0.06021303f, -0.17936233f, 0.04210776f, 
    -0.21340692f, 0.04361222f, -0.13204695f, -0.21934684f, -0.42206627f, -0.07569037f, -0.20685850f, -0.30340391f, 
    0.09103857f, -0.10922231f, -0.15102033f, -0.22800785f, -0.70832586f, -0.02590926f, 0.22923872f, -0.31038952f, 
    -0.27736670f, 0.11731708f, 0.45287082f, 0.01135033f, -0.27682313f, -0.14705355f, 0.04829153f, -0.44920653f, 
    -0.01031070f, -0.19403291f, 0.36640245f, -0.01130617f, -0.33019862f, -0.04652317f, 0.33876723f, -0.38418880f, 
    -0.36378169f, 0.24002405f, 0.19951554f, -0.04572922f, -0.36297482f, -0.66579092f, 0.12502339f, 0.27572802f, 
    -0.33263585f, -0.49347538f, -0.50958270f, -0.16785327f, -0.27469018f, -0.34523398f, 0.11719483f, 0.32897738f, 
    -0.12200928f, -0.28092840f, -0.24873735f, -0.34909308f, -0.25589797f, 0.12353242f, 0.30958858f, -0.34323329f, 
    -0.22319825f, -0.11586729f, -0.14576386f, 0.05451417f, 0.43694317f, -0.41739467f, -0.79278779f, -0.01545724f, 
    0.15566209f, -0.43179759f, 0.40443894f, 0.79044116f, -0.31415620f, -0.03352419f, 0.24774346f, -0.19156328f, 
    0.01439781f, 0.01979919f, 0.09350102f, -0.13996713f, -0.29253021f, -0.07987207f, -0.05537908f, 0.03454775f, 
    -0.23354249f, 0.05847234f, -0.08007059f, 0.06549264f, -0.02766543f, 0.19339783f, 0.00398383f, 0.69551927f, 
    0.72995633f, -0.49341294f, -0.34688005f, -0.33388275f, 0.42818645f, 0.26687405f, -0.09467498f, -0.00857529f, 
    -0.29453734f, 0.49078953f, -0.12420461f, 0.09914704f, -0.31084919f, -0.35710123f, -0.08423352f, -0.09676658f, 
    0.03695068f, -0.14978826f, -0.16659167f, -0.07320815f, 0.09727715f, -0.10779881f, -0.26346692f, -0.72042453f, 
    -0.54084480f, 0.21015260f, 0.35687810f, 0.45753914f, 0.32854229f, 0.37828785f, -0.08417673f, -0.07202780f, 
    -0.52833462f, -0.21758862f, 0.13921450f, 0.23169582f, 0.38894638f, 0.40059900f, -0.06700394f, 0.14803535f, 
    0.00991392f, -0.30971915f, 0.34917215f, -0.21116348f, 0.14199983f, -0.12747104f, -0.01024747f, 0.16583376f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07309848f, 0.06084424f, 0.20173675f, 0.10082373f, 0.12380531f, 0.07695306f, 0.03714963f, 0.10666028f, 
    0.21502224f, 0.11548433f, 0.14959428f, 0.13592911f, 0.13627417f, 0.26676041f, 0.14010862f, 0.19690420f, 
    0.21899796f, 0.11559626f, 0.12968192f, 0.16915119f, -0.03562117f, -0.02637568f, 0.01594345f, 0.05171185f, 
    0.15686478f, 0.17858817f, 0.16340394f, 0.05597498f, 0.13278151f, -0.02379270f, 0.00610696f, -0.14150690f, 
    0.07078939f, 0.02499989f, 0.04149218f, -0.04232172f, -0.05367588f, 0.13417806f, 0.31343785f, 0.04751267f, 
    0.10020918f, 0.03740366f, 0.03153361f, 0.21707095f, 0.05551727f, -0.10052272f, 0.14970902f, -0.05880999f, 
    0.01093265f, 0.05081854f, 0.12407693f, 0.18581298f, 0.26623020f, 0.28116307f, 0.35432065f, 0.00786373f, 
    0.06275890f, -0.02062964f, 0.06723735f, 0.04855372f, 0.28504887f, 0.18428247f, -0.04955101f, 0.07297935f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02138885f, 0.02857603f, 0.00694697f, 0.00657845f, -0.02030252f, 0.01960172f, -0.03082776f, -0.03869644f, 
    -0.01812801f, -0.03783933f, -0.02749988f, -0.00122618f, -0.03442759f, 0.00916368f, 0.01162034f, -0.02485233f, 
    -0.01058823f, -0.03556524f, 0.02506907f, -0.03321850f, 0.00069450f, 0.02352950f, -0.00923907f, -0.00952734f, 
    -0.03493842f, -0.02163183f, 0.00404428f, -0.01626735f, -0.02796708f, 0.00285327f, -0.00652604f, 0.01692353f, 
    -0.03985899f, -0.00425445f, 0.01072721f, -0.03756262f, 0.02724377f, -0.03839860f, 0.01243728f, -0.02870318f, 
    -0.03959718f, -0.02096995f, 0.01189429f, -0.00951268f, 0.01785847f, -0.03568532f, 0.02115634f, -0.03133864f, 
    -0.00459041f, 0.02533998f, 0.01771211f, -0.00408583f, -0.01977790f, 0.00882958f, -0.01125014f, 0.00109938f, 
    0.00683986f, 0.01292787f, 0.02539079f, -0.00351071f, 0.02463118f, 0.00258894f, -0.03178240f, 0.01128147f, 
    -0.02338681f, -0.03203259f, -0.03558362f, -0.00104512f, -0.00773679f, -0.04339647f, -0.02600037f, -0.02106992f, 
    0.00530183f, -0.03755401f, -0.03263389f, -0.03659160f, 0.03432512f, -0.03197296f, -0.00091186f, 0.01890305f, 
    0.01806365f, -0.02007859f, 0.01300823f, 0.00733420f, -0.01634817f, 0.00582791f, 0.02164789f, 0.02156457f, 
    -0.01377627f, -0.00480087f, 0.02393416f, -0.01758102f, -0.00671173f, 0.01107129f, -0.03999221f, -0.01633735f, 
    -0.01753655f, 0.01682538f, -0.01659667f, -0.01070457f, -0.00073882f, -0.01194770f, -0.04310471f, -0.03009721f, 
    0.02690071f, 0.00703629f, -0.03091948f, -0.02378061f, 0.01166634f, -0.01019387f, -0.03145757f, 0.01244956f, 
    0.03266852f, -0.00693321f, 0.00792855f, -0.02790192f, 0.02106607f, -0.00110091f, 0.01211092f, -0.03777171f, 
    -0.00418782f, -0.02866258f, 0.03853935f, -0.02756329f, 0.02485597f, 0.00060566f, 0.02198693f, 0.00091831f, 
    0.02942970f, 0.01822741f, -0.03678847f, -0.02694190f, -0.01347384f, 0.01908961f, -0.02493877f, 0.02613659f, 
    0.01755699f, -0.02408694f, 0.03339957f, 0.01861068f, 0.02436363f, -0.03547739f, -0.01301042f, 0.02258727f, 
    0.00604949f, -0.02935812f, 0.01368091f, 0.00916663f, -0.01396699f, 0.00998493f, -0.04197781f, -0.00750794f, 
    0.00232246f, 0.03010160f, 0.00826983f, 0.01191056f, -0.00789050f, -0.01016941f, -0.03550191f, -0.03978784f, 
    -0.04249766f, 0.01299949f, -0.04240176f, -0.01089537f, -0.00281826f, 0.02853437f, -0.01934274f, -0.01460956f, 
    -0.00924981f, 0.03293472f, 0.01815156f, 0.01499920f, 0.01728779f, -0.01653709f, 0.02646450f, -0.01077025f, 
    -0.02769100f, -0.03354585f, -0.00316108f, -0.01532838f, -0.00958959f, -0.01196673f, -0.01338569f, 0.02148267f, 
    0.01980091f, 0.03676300f, -0.00764183f, 0.01646074f, -0.02569273f, 0.01132560f, 0.03195512f, -0.03729687f, 
    -0.00023674f, 0.01458520f, -0.00876084f, -0.03029793f, -0.01578472f, 0.01520134f, -0.00546619f, 0.00090383f, 
    0.02197906f, -0.02865148f, -0.03066209f, -0.00701772f, -0.02410726f, -0.02737495f, -0.01616090f, -0.01125181f, 
    -0.01022350f, 0.01740362f, 0.02280360f, -0.03499056f, 0.00266129f, 0.02388474f, -0.02361007f, -0.01929572f, 
    -0.04499988f, 0.01888414f, -0.03431061f, -0.02827515f, 0.00955566f, -0.01722363f, 0.01679142f, -0.04389906f, 
    -0.00832179f, -0.01773589f, -0.03581074f, -0.02637726f, -0.00332680f, 0.01931142f, -0.02793921f, 0.02157544f, 
    -0.03593948f, 0.00775554f, -0.04209717f, -0.03801692f, 0.03027040f, -0.00710840f, -0.01364007f, -0.04074345f, 
    -0.01025912f, -0.02596344f, 0.02186918f, 0.00247596f, -0.00412917f, 0.00946624f, 0.02843773f, -0.01149962f, 
    0.02278001f, -0.00494637f, 0.01239670f, -0.00342466f, -0.00005596f, 0.00455234f, -0.02080185f, -0.01821752f, 
    -0.01405761f, 0.02238591f, 0.01949492f, -0.02221538f, -0.03686242f, 0.02776247f, 0.00667608f, -0.01005672f, 
    -0.03708624f, 0.01379187f, 0.00870057f, -0.00821275f, -0.00953428f, -0.01444139f, -0.02471820f, -0.00391605f, 
    -0.02647048f, 0.00777263f, 0.00172047f, -0.03010615f, -0.01667003f, -0.03546708f, -0.02187944f, 0.01616442f, 
    -0.02022749f, 0.00480096f, 0.00245349f, -0.03045209f, 0.00974880f, 0.03365690f, 0.01016217f, -0.01768823f, 
    -0.03816703f, -0.00832113f, -0.00155586f, -0.00311478f, -0.04345055f, 0.01553391f, 0.03453808f, -0.03619369f, 
    -0.01907899f, 0.01069271f, -0.03462613f, -0.00900983f, -0.01024014f, -0.02863613f, 0.01932123f, -0.03549559f, 
    0.01615357f, -0.01902080f, 0.01535941f, 0.03272004f, 0.01328653f, 0.00673034f, 0.03014888f, 0.01760888f, 
    -0.00366459f, -0.02458760f, -0.00382573f, 0.02596529f, -0.01631592f, -0.03064102f, -0.01740471f, -0.01636805f, 
    -0.03738396f, -0.01210892f, 0.02322557f, -0.03354824f, -0.00067262f, -0.01875133f, -0.03665434f, -0.01568177f, 
    0.00898626f, -0.04154845f, -0.03215679f, 0.00174360f, -0.02380002f, -0.03804776f, 0.00669842f, -0.03733687f, 
    0.00760393f, -0.03911172f, -0.00364922f, -0.01607638f, -0.02243497f, -0.02783755f, 0.01792401f, -0.03033851f, 
    0.01826368f, 0.02203190f, 0.00871519f, -0.02308335f, -0.03118062f, -0.02106806f, -0.01338260f, 0.00017576f, 
    0.00496182f, 0.02961839f, -0.00121670f, -0.00046790f, -0.02097245f, 0.01815108f, -0.01531609f, -0.02918348f, 
    0.00000124f, 0.01411335f, 0.01663623f, 0.02203131f, -0.00846975f, 0.02381722f, -0.03149766f, 0.02502121f, 
    -0.00081973f, -0.03403533f, -0.01541470f, -0.00007163f, 0.00919149f, -0.00200049f, -0.01975584f, 0.02834376f, 
    -0.02644219f, -0.04343657f, 0.03204746f, -0.01222117f, -0.04250416f, 0.00651482f, 0.03389553f, 0.01858732f, 
    -0.01718402f, -0.01658628f, -0.00811847f, 0.01822333f, 0.01688080f, -0.03340194f, -0.03005357f, -0.00112730f, 
    0.01368617f, -0.04205680f, -0.03557382f, 0.01702353f, 0.02493618f, 0.01361314f, 0.01222165f, -0.03816136f, 
    -0.03005630f, 0.02329538f, -0.00439323f, -0.01341554f, -0.02909405f, -0.01498065f, -0.01914821f, -0.03466877f, 
    -0.02875212f, 0.01565409f, 0.02026646f, 0.00692551f, 0.01982295f, -0.01627801f, -0.03747424f, 0.00495793f, 
    -0.01870122f, 0.02653763f, -0.01136268f, -0.00434849f, -0.00928758f, -0.00476924f, 0.02179275f, -0.02899413f, 
    -0.01463851f, 0.00558233f, 0.02175821f, -0.00615498f, -0.04014624f, -0.03644099f, -0.01559487f, 0.02741474f, 
    -0.01420766f, 0.00138404f, 0.01126210f, 0.00396541f, 0.00690792f, -0.02226200f, -0.02659458f, 0.03492290f, 
    0.02396001f, 0.01168807f, 0.02983776f, -0.02430277f, 0.00214660f, 0.00680805f, -0.00261792f, -0.01684795f, 
    -0.01918154f, 0.02601591f, 0.01632392f, 0.01047822f, 0.00464928f, 0.00852355f, 0.01734682f, -0.00951127f, 
    -0.01628527f, -0.01191847f, -0.01748241f, 0.02257805f, -0.03424827f, 0.00064007f, -0.00353315f, 0.00860643f, 
    -0.02894170f, -0.02494998f, -0.00403896f, -0.01225522f, -0.03146783f, 0.00681994f, -0.02389603f, -0.01165865f, 
    -0.04152610f, -0.03442087f, -0.03802927f, -0.04390973f, -0.03639581f, -0.01014855f, 0.03014347f, -0.02412145f, 
    -0.02853693f, -0.01106918f, 0.02487230f, -0.04511410f, -0.01370612f, 0.00213957f, 0.02864324f, 0.00068341f, 
    -0.04296439f, 0.00356935f, -0.03160162f, 0.02292171f, -0.03152728f, -0.01271156f, 0.02108492f, 0.02504500f, 
    -0.00342687f, 0.03515190f, -0.03214398f, -0.00522511f, -0.02799047f, -0.01414691f, -0.02693412f, 0.01959473f, 
    0.02218750f, -0.01973785f, -0.01158102f, 0.00261932f, -0.01704647f, 0.02051861f, 0.02182903f, -0.02925572f, 
    0.01422844f, -0.00418396f, 0.01361970f, 0.00995077f, 0.02867363f, -0.04096761f, -0.00483259f, 0.01969297f, 
    0.00297037f, 0.00058552f, -0.00714762f, -0.02694377f, 0.00922381f, 0.00132649f, -0.00935561f, -0.01612806f, 
    -0.03380750f, 0.01128696f, 0.01163454f, 0.01475260f, 0.02428034f, 0.00968609f, 0.01821719f, 0.00487291f, 
    -0.02929982f, 0.02429675f, -0.00664534f, -0.01429533f, 0.00103886f, 0.02745208f, 0.00508267f, -0.04064861f, 
    -0.02181564f, -0.00115025f, -0.00580648f, 0.02257300f, 0.02197574f, 0.01993948f, 0.02640992f, 0.01457112f, 
    0.02774902f, 0.00229805f, 0.02111653f, -0.01729290f, 0.02001360f, 0.01978678f, -0.02042951f, -0.03677596f, 
    0.01535051f, -0.03103253f, -0.01068750f, -0.01040905f, -0.03200217f, -0.02502481f, -0.04080893f, -0.01926796f, 
    -0.00830181f, -0.01375499f, 0.00245467f, 0.01540040f, -0.01072296f, -0.01944363f, 0.03315432f, -0.03406072f, 
    -0.00936708f, 0.01471817f, -0.02191943f, -0.01880885f, -0.01049099f, 0.02594986f, -0.01622262f, -0.02933112f, 
    -0.02419342f, 0.00790261f, 0.01737092f, 0.02372176f, -0.04183777f, 0.00166813f, -0.00129432f, 0.01488727f, 
    -0.00617359f, -0.00365791f, 0.01537770f, -0.03241472f, -0.02793725f, 0.02876794f, 0.00131143f, -0.02146138f, 
    -0.00834257f, 0.00575411f, -0.01638188f, 0.00822100f, 0.02574496f, -0.00668480f, 0.00729611f, -0.02713866f, 
    -0.00898613f, 0.01497602f, -0.03434156f, -0.01762883f, -0.01672412f, -0.03667942f, -0.04135038f, -0.00329692f, 
    0.00026855f, -0.04109329f, 0.02781083f, 0.00110943f, -0.02472340f, -0.00044089f, -0.00302415f, 0.02274240f, 
    -0.01835060f, -0.04433513f, 0.02817508f, 0.01577232f, -0.03245159f, 0.02271920f, 0.01125972f, 0.00799653f, 
    -0.04220391f, -0.01767049f, 0.01383364f, -0.01893905f, 0.00536134f, 0.00842965f, 0.00655069f, -0.01404057f, 
    0.00982426f, -0.02959958f, -0.01713767f, 0.03492001f, 0.01411314f, 0.02494056f, -0.01321062f, 0.01912956f, 
    0.02061857f, -0.00551319f, 0.01579493f, -0.02601167f, -0.00526606f, -0.02100570f, -0.01597600f, -0.00305971f, 
    0.00144483f, 0.01244980f, 0.01102117f, 0.02103356f, -0.00871036f, -0.02060799f, 0.01613065f, -0.03347292f, 
    -0.00664846f, 0.00536247f, -0.03952020f, -0.02990365f, 0.00072775f, 0.02008402f, 0.02016165f, -0.00078218f, 
    0.00676158f, 0.01997089f, 0.01461754f, 0.02315750f, -0.02140729f, -0.02885378f, 0.02408953f, 0.02369149f, 
    0.01396391f, 0.00723391f, -0.00442265f, 0.00874749f, 0.02468076f, 0.00398698f, 0.01120708f, 0.00600725f, 
    -0.01907122f, -0.03533317f, -0.03176307f, -0.02684463f, -0.03385798f, -0.01244100f, 0.02153076f, 0.02512555f, 
    -0.02092236f, -0.00779848f, 0.02240189f, 0.02088699f, -0.02473105f, -0.02603515f, -0.00289480f, -0.01886933f, 
    -0.01030253f, 0.00596263f, -0.00351639f, -0.03462726f, -0.04189677f, -0.00746605f, -0.02666436f, -0.01534694f, 
    -0.02589874f, -0.03499123f, 0.01464451f, -0.02897381f, 0.02185051f, -0.03397698f, -0.01789034f, -0.00210330f, 
    -0.00362943f, -0.04331566f, -0.02852050f, -0.03608287f, -0.04319936f, -0.01266491f, 0.03348606f, 0.00219931f, 
    -0.01643739f, -0.03956121f, -0.01172010f, -0.01125913f, 0.02062651f, -0.03253342f, -0.02714271f, -0.00439440f, 
    0.00834456f, 0.01402047f, 0.01081280f, 0.02322552f, -0.00400769f, -0.02958629f, 0.00775803f, -0.01033206f, 
    0.01263982f, -0.02257191f, -0.01429441f, 0.00683284f, -0.03597473f, -0.04150841f, 0.00622196f, -0.04115828f, 
    0.01715869f, -0.01918545f, 0.02227200f, 0.01015139f, -0.01807121f, 0.02005042f, 0.00519285f, 0.00367797f, 
    -0.00065276f, -0.01829046f, -0.03245129f, -0.01727190f, -0.03751395f, -0.02657432f, -0.02150169f, -0.01100631f, 
    -0.01896037f, -0.02071553f, -0.01914162f, -0.00515744f, 0.01524687f, -0.02564672f, -0.01180979f, -0.02613677f, 
    -0.02412895f, 0.01341831f, -0.03899615f, -0.02432621f, -0.03828481f, 0.01468750f, 0.00826035f, -0.00528851f, 
    -0.01680755f, -0.02729374f, -0.00618221f, -0.01997267f, 0.01821495f, -0.02932171f, -0.02872027f, -0.00624061f, 
    -0.01874655f, -0.00384258f, -0.01905547f, -0.00109946f, 0.00598059f, -0.03419716f, 0.00993722f, 0.00812217f, 
    -0.01052189f, 0.02281900f, -0.02973156f, -0.04106071f, -0.02330076f, -0.00585387f, 0.00972713f, -0.01224001f, 
    0.02636935f, -0.03781328f, -0.00636509f, -0.01468845f, 0.00012358f, -0.03022804f, -0.02155341f, 0.00874772f, 
    0.01107884f, -0.03266815f, 0.02599654f, -0.02482667f, -0.02960391f, -0.02662715f, -0.01682245f, 0.02750571f, 
    0.01924477f, 0.01181443f, -0.03835684f, 0.01524344f, -0.01023808f, -0.01807224f, -0.00496108f, -0.03642668f, 
    0.02725585f, 0.01667296f, 0.02056693f, -0.03858330f, 0.01773394f, -0.03715429f, 0.02824871f, -0.00760605f, 
    -0.01043052f, 0.01692099f, -0.04007795f, 0.00504696f, 0.01122918f, -0.00159857f, -0.00294730f, -0.02795797f, 
    -0.03588906f, 0.00479268f, 0.00633266f, 0.02431903f, -0.03812953f, 0.01854979f, -0.02648364f, -0.00960654f, 
    0.00652207f, -0.00506740f, 0.00640755f, -0.02061735f, 0.02071995f, 0.02392303f, 0.02723658f, 0.02177608f, 
    -0.00430079f, -0.03601139f, -0.02674879f, -0.02826963f, -0.01818188f, 0.00155369f, 0.00122072f, -0.02840760f, 
    -0.01534432f, 0.01346513f, 0.00080442f, 0.02452489f, 0.01942999f, -0.02003483f, -0.00935186f, -0.00887405f, 
    -0.00435653f, 0.00577631f, 0.01792472f, 0.02187023f, -0.03054258f, 0.02283992f, -0.03864156f, 0.00793808f, 
    0.01272286f, -0.00543848f, -0.03883589f, -0.02380243f, 0.01842653f, 0.01860525f, -0.00466031f, -0.00708306f, 
    -0.01877495f, 0.00394612f, -0.02097004f, 0.02342192f, -0.00833251f, 0.00138161f, 0.02182829f, -0.02470232f, 
    0.01174520f, -0.02712414f, 0.01901383f, -0.01587564f, -0.02908659f, 0.01810263f, 0.00235219f, 0.01471322f, 
    0.00431759f, 0.00162037f, -0.01814317f, 0.00502902f, -0.02839143f, -0.03407612f, 0.00233175f, 0.01383546f, 
    -0.01595668f, -0.02129380f, -0.02524313f, 0.02802836f, 0.00172147f, -0.03146461f, 0.02701556f, -0.03464772f, 
    0.01572102f, 0.01237417f, -0.01885706f, 0.00952778f, 0.01973110f, -0.01914630f, 0.00168029f, -0.03792530f, 
    -0.03929969f, -0.00463165f, 0.01708979f, -0.01649910f, 0.00390864f, 0.02042075f, -0.03508999f, -0.03813013f, 
    -0.02800541f, -0.02972649f, -0.01589301f, 0.01293709f, -0.03592578f, 0.00805626f, -0.03104200f, 0.02114169f, 
    -0.03274388f, 0.01950423f, 0.02351336f, 0.00739023f, -0.03837206f, 0.02428253f, 0.00457713f, -0.02063773f, 
    -0.02250318f, -0.03916220f, -0.00242108f, -0.02571708f, 0.01292346f, 0.01829104f, 0.02049448f, 0.00090773f, 
    -0.03714358f, -0.02430286f, -0.02663619f, 0.02051691f, -0.02502935f, -0.02140653f, -0.01420256f, 0.02951298f, 
    -0.00775208f, 0.01889138f, -0.03931658f, -0.01591135f, -0.03552521f, 0.00503283f, -0.01654633f, -0.03935451f, 
    -0.00105954f, 0.01112407f, -0.03754606f, -0.01726242f, -0.01848785f, -0.01215992f, 0.01921332f, 0.01144455f, 
    0.00522392f, -0.03827160f, 0.02727895f, 0.00682705f, -0.03098916f, -0.00541438f, -0.02420781f, 0.01298665f, 
    -0.03879797f, 0.02203381f, 0.00002994f, -0.00551824f, -0.00183364f, -0.00272537f, 0.00141720f, -0.02946892f, 
    -0.01259390f, 0.00681310f, -0.04130253f, -0.02052177f, -0.04014079f, 0.01594070f, -0.02345915f, -0.03788176f, 
    0.01427061f, -0.01220940f, 0.01450032f, 0.01731421f, -0.03017850f, 0.00511200f, 0.01407672f, -0.03741948f, 
    -0.02310413f, -0.03332742f, 0.01899786f, -0.03056026f, -0.02747354f, -0.01715885f, -0.02821197f, 0.01074961f, 
    0.00517185f, 0.02913296f, -0.03791146f, 0.02611424f, -0.03265656f, 0.02674859f, -0.03661707f, 0.00455112f, 
    0.00779937f, 0.00673250f, 0.02603300f, -0.03846836f, -0.00433653f, -0.01704987f, 0.02629051f, -0.01034486f, 
    0.00491902f, -0.01191723f, 0.02261044f, -0.02930305f, -0.01330617f, 0.01850739f, -0.02204235f, 0.02460711f, 
    -0.02135505f, -0.02448899f, 0.01419882f, -0.00248357f, 0.00829916f, -0.00989268f, 0.01518694f, 0.01794170f, 
    -0.01110020f, -0.01127676f, -0.01572603f, 0.02223710f, -0.02284611f, -0.00823245f, -0.03672129f, 0.01494972f, 
    -0.02550425f, 0.00699883f, 0.01012263f, -0.03934414f, 0.01421105f, 0.02032696f, 0.01672337f, -0.01176669f, 
    -0.03997589f, -0.02630088f, -0.01566922f, 0.01612203f, 0.01240171f, -0.02041378f, -0.02757354f, -0.03289277f, 
    0.00421224f, 0.02980858f, -0.00758737f, -0.02669657f, -0.00700410f, 0.02037410f, 0.01868321f, 0.00433708f, 
    -0.03772552f, -0.01665607f, -0.00491716f, -0.00906629f, -0.04159804f, -0.02270268f, 0.01410476f, 0.00582547f, 
    0.00195352f, -0.02670532f, -0.02977625f, -0.03305485f, -0.03904754f, 0.00785491f, -0.02704692f, -0.00233225f, 
    0.01937347f, 0.01310427f, 0.02362900f, -0.01832069f, -0.01118645f, 0.01827428f, 0.02702454f, -0.01298023f, 
    0.00001223f, 0.01779993f, -0.01262559f, -0.00459336f, -0.03411103f, -0.01486292f, -0.01886508f, 0.00818040f, 
    -0.03491449f, -0.02174136f, 0.00464045f, -0.01875538f, -0.03617660f, -0.00735448f, 0.02883240f, -0.03190694f, 
    0.00496163f, 0.01799795f, -0.01357896f, -0.01516762f, -0.00102691f, 0.01264260f, 0.01435834f, 0.00411524f, 
    -0.00616449f, -0.03128104f, 0.01475992f, 0.01061623f, -0.01972715f, 0.02181352f, -0.04159686f, -0.00155103f, 
    0.02529925f, -0.03777117f, 0.02546861f, -0.00491102f, 0.00521357f, 0.01166031f, 0.02592472f, -0.00183528f, 
    0.02923264f, 0.01385208f, 0.02757121f, -0.00523776f, -0.02245535f, 0.02227700f, 0.00470057f, -0.02379426f, 
    -0.00349820f, -0.03509601f, -0.02071943f, 0.01681236f, 0.02971595f, 0.01860085f, 0.02007934f, -0.00502692f, 
    0.02856949f, -0.03817474f, -0.01791059f, 0.00162013f, 0.01891178f, -0.02999085f, -0.00215196f, 0.01224333f, 
    0.03004763f, -0.03639812f, -0.03935562f, 0.00988440f, -0.00990716f, 0.01411004f, -0.03377263f, -0.00983411f, 
    -0.02124105f, -0.04198100f, -0.02610529f, 0.00681723f, 0.01156100f, 0.02926630f, 0.01585427f, -0.01927805f, 
    -0.03088839f, 0.01227793f, 0.00897299f, -0.00252729f, -0.02748864f, -0.01674161f, -0.01994113f, -0.01323272f, 
    -0.04199909f, 0.02448500f, 0.01525853f, -0.00918785f, -0.04067040f, -0.02703833f, -0.00426233f, -0.00172832f, 
    0.02391759f, -0.01568546f, -0.00384082f, -0.02728336f, -0.00261779f, 0.00114767f, -0.01202261f, 0.00839317f, 
    -0.03641037f, 0.02482169f, 0.00058944f, -0.03681380f, -0.02999219f, 0.00255933f, -0.03528720f, -0.01821132f, 
    -0.01887294f, 0.02749278f, -0.02009458f, 0.01749752f, 0.02935383f, 0.02119572f, 0.01387458f, 0.01388393f, 
    -0.03684956f, 0.01957901f, -0.02381501f, -0.03521099f, 0.01665503f, -0.03714242f, 0.00719077f, -0.04055982f, 
    -0.01828792f, 0.01661499f, -0.00675042f, 0.01516646f, 0.01996507f, -0.02042740f, -0.03961963f, -0.00656025f, 
    -0.02355271f, -0.02280057f, -0.00837046f, -0.01989754f, -0.03299073f, -0.03877475f, -0.02710435f, -0.02136121f, 
    -0.01090076f, 0.02788833f, -0.01897882f, 0.02011006f, -0.03803496f, -0.00251178f, -0.03467548f, -0.00743474f, 
    0.02566644f, -0.02057903f, -0.01173706f, -0.00071874f, 0.02281678f, -0.01645391f, 0.01828352f, -0.03295826f, 
    -0.03921334f, -0.03702104f, 0.02985766f, 0.00298716f, 0.00676066f, -0.04133295f, -0.03572844f, -0.01988024f, 
    -0.04068066f, -0.03277857f, 0.00176140f, 0.01276703f, -0.03505471f, 0.01789214f, 0.01643286f, -0.02295397f, 
    -0.02971423f, -0.00184078f, -0.00962749f, -0.00252957f, -0.03481178f, 0.02849355f, 0.02612554f, -0.01583369f, 
    -0.00934830f, 0.01212806f, -0.00055109f, -0.02909731f, 0.01422269f, 0.01199817f, -0.02447515f, 0.01999323f, 
    -0.04116368f, -0.03703367f, -0.03343039f, -0.01952992f, 0.00314473f, -0.02807503f, -0.00039964f, -0.01521591f, 
    0.02667509f, 0.01244451f, 0.00484601f, -0.03690408f, -0.02890296f, 0.01895026f, 0.02622432f, -0.03420845f, 
    0.02960636f, 0.02554135f, 0.01784539f, 0.02376822f, -0.00564183f, 0.01683113f, -0.02531465f, 0.02716319f, 
    0.00142329f, 0.02747879f, -0.04087251f, -0.01368275f, -0.02717515f, 0.02209669f, -0.03586773f, -0.03197897f, 
    -0.03614265f, -0.03980769f, -0.02741205f, 0.02108257f, -0.01292837f, 0.00840667f, 0.00291623f, -0.03700260f, 
    0.01209719f, 0.00660139f, -0.02469798f, -0.00192999f, -0.00069218f, -0.03263203f, 0.02745849f, 0.00372734f, 
    0.00437602f, -0.03521435f, -0.00461514f, 0.00020628f, -0.02121940f, -0.01343640f, -0.01816075f, -0.03483259f, 
    -0.03122522f, 0.02639900f, -0.02485931f, -0.01016856f, 0.00823353f, 0.01427123f, -0.03388061f, 0.02455648f, 
    -0.01828351f, 0.01674555f, -0.02361109f, -0.03907471f, -0.01572699f, -0.03809248f, 0.02722848f, 0.01192766f, 
    -0.02913857f, 0.01968404f, -0.02642742f, 0.01332376f, -0.00996080f, -0.03037912f, 0.01257311f, 0.02230310f, 
    -0.00431996f, 0.02551876f, 0.00651856f, -0.00593838f, 0.00750748f, -0.02786313f, -0.03886695f, -0.04095146f, 
    -0.01537983f, 0.00195245f, -0.02897497f, -0.03369583f, -0.01753615f, -0.00329904f, 0.02584013f, 0.00688935f, 
    0.00148204f, 0.02604549f, 0.01620338f, -0.01209083f, -0.02514414f, 0.01369266f, 0.00586222f, -0.02456564f, 
    -0.02268723f, 0.01782473f, -0.03735676f, 0.01318669f, -0.00626991f, 0.01602955f, 0.01194609f, -0.00328994f, 
    -0.02288559f, 0.01074011f, 0.02531852f, -0.01977692f, 0.02884116f, -0.04115233f, 0.00771359f, -0.01280731f, 
    -0.00102937f, -0.03412266f, 0.01466545f, -0.00099102f, -0.03897222f, 0.00090064f, -0.01337487f, -0.03670277f, 
    0.00165146f, 0.02019787f, 0.01439730f, 0.02403456f, -0.03423073f, -0.03551275f, 0.00932831f, -0.01551587f, 
    -0.03762408f, -0.02253531f, -0.03036211f, -0.02143294f, -0.01584150f, 0.01661325f, 0.01823336f, -0.03633058f, 
    0.01071185f, -0.01392467f, 0.02185406f, -0.00150067f, -0.02860829f, 0.01713638f, 0.02193249f, -0.01960300f, 
    0.00965590f, -0.02862998f, -0.03284836f, -0.00729309f, 0.01386618f, 0.02545596f, 0.00279952f, 0.02059584f, 
    0.02934780f, 0.02346715f, 0.00355891f, -0.02608039f, 0.00372518f, -0.03141908f, 0.01043851f, 0.02409917f, 
    -0.01119172f, 0.01094416f, 0.00099683f, 0.00606021f, 0.00061760f, 0.01073161f, 0.02007538f, 0.00977648f, 
    -0.01163943f, -0.01548781f, -0.01611530f, 0.01916709f, 0.00820405f, -0.02264690f, 0.00755703f, -0.04011759f, 
    -0.00548528f, -0.01524496f, -0.00715906f, -0.00079041f, -0.03577567f, -0.00755365f, 0.01144531f, -0.00960698f, 
    0.00739679f, -0.03214198f, -0.01322547f, 0.02311262f, -0.03910736f, -0.02668908f, 0.00908776f, 0.02402811f, 
    -0.02680239f, -0.02892169f, 0.02043013f, -0.00576755f, -0.01396970f, 0.00551761f, -0.00241820f, 0.02896476f, 
    -0.01337926f, -0.03945147f, 0.02427609f, 0.01621586f, -0.04083974f, -0.00231525f, -0.01325444f, 0.01018597f, 
    -0.02001301f, -0.02920067f, 0.00016854f, 0.02163881f, -0.00797006f, -0.02475159f, -0.03053071f, -0.04055827f, 
    -0.13849154f, -0.14593300f, -0.07689645f, 0.33836344f, 0.20944266f, 0.00435365f, -0.01276272f, -0.02495122f, 
    0.08038160f, 0.02772395f, 0.01203748f, -0.00034240f, 0.04376641f, 0.00826759f, 0.04705721f, -0.13423614f, 
    0.06558934f, -0.03137916f, -0.03376245f, -0.02226746f, -0.02742592f, -0.01501281f, 0.01894621f, -0.03557687f, 
    -0.00107792f, -0.07278661f, -0.13040876f, -0.15369049f, -0.01753230f, 0.11316789f, -0.02855358f, 0.07721848f, 
    -0.09159575f, 0.12333126f, -0.00803146f, -0.08665261f, 0.25909165f, -0.26618353f, -0.04891924f, 0.17943726f, 
    0.25046632f, 0.07946192f, -0.07419316f, -0.05879025f, 0.01465052f, -0.08011331f, -0.08036361f, 0.02728469f, 
    -0.04424539f, 0.14196002f, 0.08162747f, 0.00356520f, 0.00870463f, 0.10643968f, 0.00117217f, 0.01093988f, 
    0.07458329f, 0.12315718f, 0.05428190f, -0.06935147f, 0.05767891f, -0.02518720f, 0.05852072f, 0.05329181f, 
    0.02449773f, -0.05644808f, -0.04854509f, -0.05552355f, -0.06580242f, 0.02298623f, -0.11180262f, -0.06917690f, 
    0.02545350f, -0.07962224f, -0.09311046f, -0.02123085f, 0.03338358f, -0.01373321f, 0.03691347f, 0.05897105f, 
    -0.07561128f, 0.03695242f, -0.03515013f, 0.00863737f, -0.27873713f, 0.25669357f, -0.01553100f, 0.41775015f, 
    -0.02988989f, -0.14025775f, 0.13833848f, 0.16371073f, -0.06950723f, 0.04205514f, 0.06795107f, -0.08212492f, 
    0.03419703f, 0.17365737f, 0.03094971f, 0.10734749f, 0.09233805f, 0.04276320f, -0.03908753f, -0.01487052f, 
    -0.05462394f, 0.05837728f, 0.06711657f, 0.00208922f, -0.13061675f, 0.16640259f, 0.00303782f, -0.06154668f, 
    0.07537283f, -0.06404679f, 0.06883701f, -0.08986335f, -0.12331194f, -0.04692730f, -0.01622292f, 0.01343259f, 
    0.02247677f, -0.11158928f, -0.03853419f, -0.33088839f, 0.03144988f, -0.01556561f, 0.01248494f, 0.09435949f, 
    0.02064261f, 0.04346722f, -0.03016244f, 0.15009783f, -0.12503459f, 0.00455661f, 0.10012146f, 0.10504107f, 
    -0.17064571f, -0.07568837f, 0.01465164f, 0.05215041f, 0.01455773f, -0.05043927f, 0.05429880f, 0.04275138f, 
    0.17961091f, -0.04080886f, 0.08864421f, -0.01522497f, -0.02401651f, -0.06690250f, 0.04891276f, 0.00694145f, 
    0.06364585f, -0.04573876f, -0.06836745f, -0.05284465f, -0.00309848f, -0.02065027f, -0.02054007f, -0.28363878f, 
    0.06656402f, 0.04741314f, -0.04487002f, 0.07233329f, 0.07269769f, 0.14002132f, 0.04812964f, -0.06930032f, 
    -0.10894930f, -0.09755267f, 0.05984692f, 0.19337802f, 0.06877144f, -0.05709032f, -0.04790381f, 0.01769973f, 
    0.09708926f, 0.01796077f, -0.07418258f, 0.08569473f, 0.11876733f, 0.12925299f, 0.06327724f, -0.02154837f, 
    0.00816305f, 0.03704191f, -0.06537507f, -0.06894255f, 0.04519646f, 0.04916796f, 0.08039887f, 0.02130684f, 
    0.42002028f, -0.14821379f, 0.02277196f, -0.19421908f, -0.07570890f, 0.03963883f, 0.00659200f, 0.00586121f, 
    0.03840391f, -0.02060049f, -0.06328175f, 0.00188465f, -0.26387814f, 0.27859852f, 0.10739729f, -0.11017178f, 
    -0.05933747f, 0.01001350f, 0.01671343f, -0.02590953f, 0.03804490f, 0.05389061f, -0.03435548f, 0.00488961f, 
    0.13870464f, -0.01559342f, -0.23138595f, 0.16801272f, -0.02112450f, 0.13066058f, 0.00711479f, 0.01503290f, 
    0.02706834f, -0.01084679f, -0.05159192f, 0.04773768f, -0.14550288f, 0.20568298f, 0.14486100f, -0.03711610f, 
    -0.16409981f, 0.06753036f, -0.02136467f, 0.07031230f, 0.07008293f, 0.06358489f, 0.00698588f, 0.02002743f, 
    0.08448296f, 0.07110979f, 0.13827734f, 0.01047520f, -0.08319016f, 0.01203965f, 0.00929993f, 0.00111167f, 
    -0.02164879f, 0.05931573f, -0.01370966f, -0.02382187f, -0.09984101f, -0.17506000f, -0.12034205f, 0.14616649f, 
    0.24471079f, 0.02692479f, 0.05114742f, -0.07032654f, 0.03161067f, -0.02924959f, 0.07644206f, -0.05500229f, 
    0.08578403f, -0.21715410f, -0.19185685f, 0.35962474f, 0.18313751f, 0.04868314f, -0.00691336f, -0.06762026f, 
    0.08923972f, -0.04110808f, 0.07680041f, 0.02248483f, -0.23571813f, 0.05175538f, 0.13718060f, -0.19888477f, 
    0.04266696f, 0.01893032f, 0.02823440f, 0.03948525f, 0.13859412f, -0.03415516f, -0.03553348f, 0.08325086f, 
    -0.07315681f, -0.04884741f, 0.07536405f, 0.34773052f, -0.06969345f, -0.05017801f, -0.02244731f, 0.07615712f, 
    0.08965945f, -0.07541841f, -0.06232089f, -0.03449880f, 0.16048595f, -0.05742243f, -0.17687725f, 0.23746960f, 
    0.07460257f, -0.03591457f, 0.01202720f, 0.01469653f, 0.11201628f, 0.03897525f, 0.00217666f, -0.07810044f, 
    0.09970167f, -0.06072752f, 0.00457084f, -0.09139546f, -0.02008599f, -0.02721736f, -0.00021961f, 0.02599209f, 
    0.09797068f, 0.01699967f, 0.09970090f, 0.05111067f, 0.37958446f, -0.04638400f, -0.10407364f, -0.15441103f, 
    -0.03090544f, 0.02789619f, 0.04298642f, 0.05619974f, -0.00254026f, 0.09186983f, -0.06598137f, 0.16787641f, 
    0.03258006f, 0.04114119f, -0.01039978f, -0.14634931f, 0.12597498f, -0.00297465f, 0.04451665f, -0.01905312f, 
    -0.12377142f, 0.05070929f, 0.05427867f, 0.00178689f, -0.17186801f, -0.01998444f, 0.04480648f, -0.29075596f, 
    -0.04102395f, 0.04868950f, -0.05577696f, 0.09321804f, 0.06039499f, 0.07059397f, 0.02411047f, -0.01777103f, 
    0.02836774f, 0.18415643f, 0.11390320f, 0.27708870f, -0.08395041f, -0.09984060f, 0.04920011f, -0.02757306f, 
    -0.01166633f, -0.04843076f, 0.03562957f, -0.06112996f, -0.06118990f, -0.10761836f, -0.08750606f, 0.09714525f, 
    0.04442258f, -0.00046395f, -0.10769816f, 0.02217948f, 0.00111889f, -0.08253622f, 0.02872073f, -0.12243197f, 
    -0.13786593f, -0.08090073f, -0.06282941f, 0.00289853f, 0.17798930f, 0.12202861f, 0.06786676f, 0.02481631f, 
    0.15570031f, -0.03638786f, 0.03807884f, -0.00440162f, 0.28184491f, 0.10803933f, -0.26065654f, -0.09482414f, 
    0.10397733f, 0.00390164f, -0.03723622f, -0.01988694f, -0.03968145f, -0.07911672f, 0.08758086f, -0.06454398f, 
    0.13701957f, -0.07131106f, 0.12295567f, -0.13694435f, 0.03882125f, -0.07662219f, 0.08467684f, 0.02218928f, 
    0.00541942f, 0.02667402f, -0.00764485f, -0.10183037f, -0.06748921f, -0.04477335f, 0.11284590f, 0.18014959f, 
    -0.00205874f, -0.14330986f, 0.05994276f, 0.12226598f, -0.00052789f, -0.03849681f, 0.08711792f, -0.07756284f, 
    0.14880250f, 0.18048306f, 0.03957168f, -0.09290908f, 0.09947012f, 0.00606794f, 0.01102060f, 0.07566624f, 
    0.17073886f, -0.02113535f, 0.01037914f, 0.09419663f, -0.09197927f, -0.01364395f, 0.07761224f, 0.20792434f, 
    -0.10747983f, -0.05455451f, 0.05199287f, -0.03684571f, -0.10928766f, 0.07576306f, 0.12050053f, -0.07392173f, 
    -0.04408257f, 0.13263406f, -0.20121372f, 0.06346235f, 0.08061545f, -0.07223240f, 0.04292068f, -0.03002959f, 
    -0.05133024f, 0.09525932f, 0.04675173f, 0.10498834f, -0.12238126f, -0.00552264f, 0.17271550f, 0.30673435f, 
    0.03487272f, -0.03522816f, -0.07022057f, 0.01819707f, 0.18452081f, 0.08302122f, -0.00266328f, 0.02675884f, 
    -0.11321911f, -0.10894157f, 0.06006776f, 0.27817014f, 0.07144523f, 0.05193172f, 0.07294564f, 0.03413902f, 
    0.01920078f, 0.01642890f, -0.01673819f, 0.18489389f, -0.13854833f, 0.02017915f, 0.02895074f, -0.01439743f, 
    0.10293087f, 0.10013000f, -0.04215910f, 0.13082746f, -0.04214768f, -0.02999298f, -0.05300370f, -0.06376760f, 
    0.02428889f, 0.21062717f, 0.09064572f, 0.38405120f, -0.07271166f, -0.06470782f, -0.02042832f, 0.07270853f, 
    0.03338047f, 0.08849657f, 0.03353171f, -0.03984646f, 0.39952880f, -0.17228526f, -0.01245727f, -0.10983492f, 
    -0.08069691f, 0.01533877f, -0.00786082f, -0.06491522f, 0.17117050f, 0.11491267f, 0.01940951f, 0.01310308f, 
    -0.39533529f, 0.35938475f, -0.08842754f, -0.18917218f, 0.05006761f, -0.07330161f, -0.09296799f, 0.13096435f, 
    -0.01185515f, 0.04697558f, -0.03047030f, -0.04263625f, 0.08736788f, -0.07078928f, 0.12147938f, 0.13772678f, 
    -0.09745301f, -0.19249396f, 0.11251018f, -0.00930781f, 0.03816403f, 0.08312169f, -0.01798863f, -0.13063063f, 
    -0.06172757f, 0.17803381f, 0.02312367f, -0.12000620f, -0.04533040f, 0.00498197f, 0.11025841f, -0.11729046f, 
    0.08397139f, -0.04861052f, -0.05756882f, 0.01614289f, -0.15959795f, 0.18714811f, -0.09658387f, -0.04031709f, 
    -0.03220290f, -0.01577662f, 0.01723990f, 0.17419888f, 0.02709457f, 0.01383501f, -0.09427372f, 0.02714439f, 
    0.31423479f, 0.20653389f, -0.13490838f, 0.07945415f, 0.14809583f, -0.01699737f, -0.04089362f, -0.06231831f, 
    0.16784588f, -0.08894741f, 0.09600845f, 0.01303045f, -0.14283980f, 0.00546992f, 0.04756246f, -0.04758236f, 
    -0.11368318f, -0.12382229f, -0.00224657f, 0.09649296f, -0.00096787f, -0.15454681f, 0.03281669f, 0.02919089f, 
    -0.29550582f, 0.31792054f, 0.07089757f, 0.17601039f, -0.00207336f, -0.00973804f, 0.03971020f, 0.09119160f, 
    0.00134090f, 0.04464276f, 0.07709258f, 0.08754800f, -0.26674148f, -0.00734136f, 0.12859146f, -0.05927161f, 
    -0.10831086f, -0.07027026f, -0.05478136f, 0.06960410f, 0.07555673f, -0.04288609f, 0.08832736f, 0.09599180f, 
    0.24494658f, 0.20913900f, -0.02529217f, 0.07221956f, -0.06753558f, -0.05277155f, 0.00949700f, -0.05674661f, 
    0.05568907f, 0.05438045f, -0.00456916f, -0.02826727f, 0.09426641f, 0.15453066f, -0.12951106f, 0.16644484f, 
    0.09123352f, 0.10847919f, 0.07281674f, 0.02823097f, -0.07082053f, 0.03884572f, -0.02547629f, 0.00121825f, 
    0.29919818f, -0.12729566f, -0.22499807f, 0.13350478f, 0.12460021f, -0.02498570f, -0.00694964f, -0.07254840f, 
    -0.01446618f, 0.02528106f, -0.04091849f, -0.00376387f, 0.08670387f, 0.20026180f, -0.09799249f, 0.26118055f, 
    0.02486315f, -0.03096034f, -0.00586526f, 0.07920411f, -0.04691149f, -0.01730798f, -0.10218114f, -0.05189380f, 
    0.05503416f, -0.12182702f, -0.06506272f, -0.30480251f, 0.12960048f, -0.04349321f, 0.00479115f, 0.08890120f, 
    0.05372771f, -0.02952316f, -0.01695843f, 0.06950225f, 0.13139790f, 0.12431714f, -0.04783963f, 0.18985513f, 
    0.12001360f, 0.15776145f, -0.12036329f, 0.06618913f, -0.02619826f, 0.10689608f, 0.05481356f, -0.03784905f, 
    -0.07172319f, -0.09430318f, -0.04507569f, -0.08451941f, 0.17460434f, -0.05117327f, 0.02256159f, 0.00657926f, 
    -0.00658391f, 0.02139658f, -0.05728332f, 0.02051819f, -0.14437719f, -0.00923697f, 0.12568551f, -0.05798180f, 
    0.01662329f, -0.25355220f, -0.04921696f, 0.04267322f, -0.02236207f, 0.03323270f, -0.12023704f, -0.05960990f, 
    -0.00018621f, 0.02088789f, 0.19088852f, -0.05662265f, 0.00513408f, 0.04096594f, -0.06185209f, 0.03475460f, 
    -0.01327165f, -0.01106155f, 0.08955928f, 0.03656673f, -0.16747284f, -0.04461170f, 0.04992267f, 0.12907641f, 
    0.06326652f, -0.04255794f, 0.02069008f, 0.13168614f, 0.06598229f, -0.10559472f, -0.11849453f, -0.01466753f, 
    0.17055885f, 0.10995045f, 0.01860517f, -0.11316930f, -0.05871006f, 0.06031229f, 0.08266353f, -0.00343924f, 
    -0.01425778f, 0.03321414f, -0.00080616f, 0.00032581f, -0.14011084f, 0.05550098f, 0.08658079f, -0.08426941f, 
    -0.11887208f, -0.12666784f, 0.00049382f, 0.04469000f, -0.06254234f, 0.01242152f, 0.06727730f, 0.14879842f, 
    -0.00676794f, 0.00073706f, 0.01994128f, -0.01681517f, -0.01090554f, -0.02418478f, -0.01175149f, -0.00123714f, 
    -0.03079731f, 0.00360678f, -0.00880850f, 0.01001709f, 0.00501405f, 0.01292735f, 0.01180222f, -0.00125949f, 
    0.01578168f, 0.00459011f, -0.03636998f, -0.00818093f, 0.03864348f, -0.01847082f, 0.02318421f, 0.02062950f, 
    -0.00995808f, 0.00176876f, -0.00539582f, -0.01610175f, -0.01423982f, 0.02587364f, 0.02690354f, -0.00386341f, 
    0.01535063f, 0.02659684f, 0.01828857f, 0.00428062f, -0.00147740f, 0.02653932f, 0.01553665f, -0.00265911f, 
    0.01997410f, -0.01853202f, -0.01016972f, 0.03031536f, 0.02562740f, -0.04586842f, -0.02059725f, -0.03434830f, 
    0.00192349f, -0.02323670f, -0.00336681f, 0.00256481f, 0.00965249f, -0.00795034f, 0.03998136f, -0.01776636f, 
    -0.02455746f, -0.01777579f, 0.01474982f, -0.00688205f, 0.00463464f, 0.00134782f, 0.02474405f, -0.01570384f, 
    0.02590492f, -0.01360286f, -0.04689319f, -0.02483632f, 0.00020741f, 0.00472276f, -0.00394681f, -0.00020583f, 
    0.00803864f, 0.01628319f, -0.02315102f, 0.02409444f, 0.03767889f, -0.00032902f, -0.02751548f, 0.01751759f, 
    0.02109735f, 0.01775565f, -0.03524819f, -0.01076895f, -0.01220972f, 0.00203830f, -0.03023878f, -0.03201712f, 
    0.01395168f, -0.02976111f, 0.01442929f, -0.01218807f, 0.00095813f, 0.04366711f, 0.01258219f, 0.03374576f, 
    -0.02062259f, -0.03175473f, -0.02603031f, -0.00870163f, 0.01259682f, -0.00255452f, 0.01531293f, 0.00288894f, 
    -0.03646766f, -0.01360663f, -0.01480399f, -0.04104345f, -0.02553584f, 0.02968549f, -0.02984913f, -0.03141489f, 
    -0.02440376f, -0.01450601f, -0.00537095f, -0.02197440f, 0.03529906f, -0.03380259f, -0.00976227f, 0.00031566f, 
    -0.04119936f, -0.00048196f, 0.01952560f, -0.03552153f, -0.01461757f, -0.02217614f, 0.02328437f, -0.01431671f, 
    0.03433792f, 0.02041539f, 0.03011771f, -0.03608510f, 0.02275190f, 0.01821543f, 0.01705894f, -0.03133434f, 
    0.02273389f, 0.03272498f, -0.04610314f, -0.03659374f, 0.02228368f, -0.03480515f, -0.01816556f, -0.00177584f, 
    -0.00751282f, -0.00827853f, 0.02543275f, 0.02252158f, -0.03486021f, 0.02650538f, 0.01193859f, 0.00301745f, 
    0.01178680f, 0.02866583f, -0.02670598f, 0.00691695f, -0.00290568f, 0.02550527f, 0.02572523f, -0.00474363f, 
    -0.03029908f, -0.02359759f, -0.00665638f, -0.00124739f, 0.00806029f, -0.01079100f, -0.00846995f, -0.00402984f, 
    -0.01293074f, 0.01004372f, -0.00979279f, -0.01127126f, -0.01280298f, -0.02879257f, -0.00351703f, -0.02737611f, 
    -0.01276828f, 0.01171022f, -0.00668622f, -0.03554456f, -0.00156480f, 0.02975647f, -0.02897262f, -0.02432585f, 
    -0.02828272f, -0.00117374f, 0.00080632f, 0.02886196f, 0.01278088f, -0.01147306f, -0.00496931f, -0.00653604f, 
    -0.00838913f, 0.02203700f, 0.02826268f, -0.03659029f, 0.00859090f, -0.02133115f, 0.02264441f, -0.01881533f, 
    -0.01638498f, 0.00018851f, -0.00762794f, 0.02589066f, -0.00867288f, -0.00458998f, -0.00249141f, 0.03609540f, 
    -0.02177688f, 0.00694228f, -0.02713057f, 0.03544029f, 0.00668856f, -0.02044614f, 0.02445645f, 0.01873935f, 
    -0.02154787f, 0.01020757f, -0.02322233f, 0.02631992f, -0.02856846f, -0.00939052f, -0.03095922f, 0.00677882f, 
    -0.01107325f, 0.00992495f, 0.02557301f, -0.01216763f, 0.00096105f, -0.03280357f, -0.02021550f, 0.01199312f, 
    0.01808929f, -0.01720640f, -0.00582736f, 0.02173948f, -0.01563563f, -0.03989295f, -0.02762482f, -0.01351007f, 
    -0.00674484f, -0.03560286f, -0.01864265f, -0.02393808f, 0.00781417f, -0.03453850f, -0.01112216f, -0.02225857f, 
    -0.01017548f, -0.03396792f, -0.03466383f, -0.02145807f, 0.02573073f, -0.01781111f, -0.03673091f, 0.00357075f, 
    -0.00352045f, -0.01859859f, -0.03169009f, -0.02172233f, 0.03148660f, -0.02204726f, 0.01097470f, 0.01572293f, 
    0.00104166f, 0.00911825f, -0.01199869f, -0.03389715f, 0.00091549f, 0.03565317f, -0.01254314f, -0.00759993f, 
    0.00017840f, 0.00686893f, -0.00588302f, 0.01154555f, 0.00376740f, 0.03360043f, -0.02777427f, -0.00131651f, 
    -0.02664551f, 0.02634652f, -0.02585669f, -0.01611123f, 0.01907730f, 0.02238906f, -0.03654516f, -0.01521496f, 
    0.01539739f, 0.00076583f, 0.00358849f, 0.00432369f, -0.04381446f, -0.01259797f, -0.02453257f, -0.02279678f, 
    0.02904942f, 0.01417965f, -0.01116895f, -0.03734795f, 0.01783073f, -0.02741245f, 0.02394151f, 0.03669961f, 
    0.00468420f, -0.00447241f, -0.01929183f, 0.02426232f, 0.00664028f, 0.03950909f, 0.02835411f, 0.01005748f, 
    0.02366046f, -0.04261810f, -0.01280956f, -0.02377626f, 0.00692486f, 0.01015528f, 0.00346824f, 0.00870877f, 
    -0.03661786f, -0.04267283f, -0.04148886f, 0.01583840f, 0.04010760f, 0.00782878f, 0.01846040f, -0.00441812f, 
    0.03407306f, 0.02311533f, 0.01503209f, -0.02131308f, 0.00745976f, -0.01079012f, -0.02140439f, -0.03229631f, 
    0.00976674f, -0.02106025f, -0.03211361f, -0.02268478f, -0.01100046f, -0.00407411f, -0.00551530f, -0.01453314f, 
    0.00445504f, -0.03021707f, -0.01279882f, 0.00069769f, -0.00251788f, 0.01351351f, -0.01853225f, 0.00745807f, 
    0.03051736f, -0.03757503f, 0.00241739f, -0.03634154f, 0.03585007f, -0.00020114f, 0.02583104f, -0.02589706f, 
    0.03762816f, 0.02152744f, -0.02161620f, -0.02732266f, 0.01770781f, -0.01049482f, -0.02981655f, 0.00551214f, 
    0.01836188f, 0.02594909f, -0.00787775f, -0.02966676f, 0.01081990f, 0.00101309f, 0.02270581f, -0.03655001f, 
    -0.00634753f, 0.02777505f, -0.00179121f, 0.00793847f, -0.01128317f, 0.01048580f, 0.01398692f, 0.00277517f, 
    -0.01587038f, 0.01504431f, -0.01821292f, -0.01708636f, 0.01846948f, 0.02753864f, -0.04489461f, 0.02082041f, 
    -0.03527062f, 0.01953480f, 0.00425657f, -0.01561394f, 0.00547241f, -0.02437652f, 0.01029516f, 0.03441074f, 
    -0.01255534f, 0.00036915f, -0.00070663f, -0.03871959f, -0.00568240f, -0.00281446f, 0.01780540f, 0.01191826f, 
    0.02830869f, 0.01262781f, -0.02659943f, -0.03153666f, -0.00492824f, -0.00369183f, 0.00249156f, 0.01588076f, 
    0.03750575f, 0.00744462f, -0.02979255f, -0.01376453f, -0.01085499f, -0.01803085f, 0.01800240f, -0.02284592f, 
    -0.02781783f, 0.00223918f, -0.02291781f, 0.01787655f, -0.01465321f, -0.03694372f, 0.01281341f, 0.02093536f, 
    0.00072358f, -0.03003161f, -0.01646266f, -0.00132837f, -0.02425128f, -0.03923260f, -0.00850046f, 0.01394912f, 
    0.02613380f, -0.00140659f, -0.01807517f, 0.00493803f, -0.00418123f, -0.03290525f, -0.04066411f, -0.02718799f, 
    -0.02562539f, 0.01199573f, -0.02708840f, 0.02622838f, 0.03400975f, 0.00588336f, -0.02645569f, 0.02509657f, 
    0.02285229f, 0.02007735f, 0.01679644f, 0.01859661f, -0.02878807f, -0.02387150f, -0.02803116f, 0.03174362f, 
    0.02742825f, -0.03989923f, -0.00910076f, 0.03038268f, -0.02186293f, 0.02003999f, 0.00625179f, -0.02206649f, 
    -0.01013927f, -0.01030325f, -0.02324872f, -0.03611274f, -0.02382568f, 0.01360904f, -0.04234360f, -0.01758108f, 
    -0.01887106f, -0.03766640f, -0.01424264f, -0.04451711f, 0.02365707f, 0.00075705f, -0.01901472f, 0.00868231f, 
    -0.01465662f, 0.02294974f, 0.02008214f, -0.03920744f, 0.00843358f, -0.01944050f, -0.02850376f, -0.02733480f, 
    0.01465356f, -0.03708778f, -0.02189088f, 0.01146759f, -0.02994426f, 0.02360507f, 0.02044247f, 0.01048232f, 
    -0.03446370f, 0.02223206f, 0.01430052f, -0.03966417f, -0.01199553f, -0.02675269f, -0.00435483f, 0.02264500f, 
    -0.01496671f, -0.02045097f, -0.00157472f, 0.01777749f, -0.02059076f, -0.02004706f, -0.02666933f, -0.03464824f, 
    -0.00155551f, -0.02488557f, -0.02842550f, 0.01978260f, 0.00741192f, 0.01293979f, 0.02153255f, -0.01209850f, 
    -0.01799316f, -0.01555337f, 0.00817009f, 0.02316105f, 0.03144042f, -0.00274027f, -0.02276039f, 0.02898838f, 
    0.01168592f, -0.02664552f, 0.01540222f, -0.00670914f, -0.01306161f, -0.03142620f, 0.03427530f, 0.00799536f, 
    0.01212798f, -0.00036616f, 0.01880102f, 0.02159337f, 0.03416765f, -0.01926415f, -0.00960798f, -0.03258493f, 
    0.01764451f, 0.02432171f, -0.04362494f, -0.03165216f, -0.03852019f, -0.00846847f, -0.00082658f, -0.01839879f, 
    -0.00214700f, 0.00672278f, -0.00091353f, 0.01975523f, -0.02174986f, 0.02922174f, 0.02608073f, -0.00843961f, 
    0.02434507f, 0.03464804f, -0.00417682f, 0.00808995f, -0.01858997f, -0.01625257f, 0.01849153f, 0.01009922f, 
    -0.03501532f, -0.00590419f, 0.00542884f, 0.00195839f, 0.02754603f, -0.01165050f, 0.00438159f, 0.00280856f, 
    -0.02520860f, -0.01323083f, -0.00578498f, -0.00905795f, -0.02476135f, 0.01924034f, 0.00396143f, 0.02165678f, 
    -0.03676471f, -0.03590939f, 0.00509186f, -0.01248299f, -0.02633859f, 0.02341647f, -0.03402419f, -0.00897469f, 
    0.01485629f, 0.02550376f, 0.01175285f, 0.02863563f, 0.03298911f, -0.02317252f, -0.00473967f, -0.01818540f, 
    -0.02677472f, 0.01577753f, -0.03121423f, 0.02705744f, -0.00320401f, 0.01436105f, 0.01225936f, 0.03133375f, 
    -0.00697391f, -0.01240824f, 0.00498734f, 0.03021970f, -0.00488174f, -0.02889063f, -0.00190229f, -0.02263021f, 
    0.00965828f, -0.02312124f, 0.02128983f, 0.01081139f, -0.03465912f, 0.00007355f, -0.02210731f, 0.02198350f, 
    -0.01140926f, -0.04457972f, -0.02962452f, -0.03158182f, 0.01166107f, 0.01727394f, 0.00342962f, 0.01757580f, 
    0.02444796f, 0.00333967f, -0.03377446f, -0.01619033f, 0.00845841f, 0.03304339f, -0.02177087f, -0.01311076f, 
    -0.01490541f, 0.03657797f, 0.00031519f, -0.03664129f, 0.02304660f, 0.03792565f, 0.00639848f, -0.01402968f, 
    0.02438582f, -0.00119961f, 0.00224408f, 0.01522355f, -0.02578334f, -0.01871102f, -0.02830872f, 0.02904215f, 
    -0.02460392f, 0.01616382f, 0.02700446f, 0.01355346f, -0.00794406f, -0.03150132f, -0.00423939f, 0.01129917f, 
    -0.01135280f, -0.02687860f, -0.00754374f, 0.00729580f, 0.00409326f, -0.01855352f, 0.00779286f, 0.01013918f, 
    -0.01678400f, -0.00990914f, -0.01127349f, 0.02713093f, 0.00794748f, -0.01652530f, -0.01075163f, -0.01783989f, 
    -0.03127300f, -0.03747192f, -0.04467665f, -0.03362469f, 0.02606967f, 0.01772851f, -0.02293126f, -0.03343871f, 
    0.01209164f, -0.02269698f, 0.00893021f, -0.00247421f, -0.00542831f, 0.00040722f, 0.01626778f, 0.01862094f, 
    -0.00223161f, 0.02824907f, -0.03105496f, 0.01868597f, 0.02280482f, -0.01395294f, 0.02036584f, -0.00488017f, 
    -0.01534296f, -0.03206749f, 0.01082069f, -0.01860719f, -0.02692840f, -0.00916297f, -0.01564948f, -0.02537048f, 
    -0.01670122f, -0.03545807f, -0.03969372f, -0.01194430f, 0.00362642f, -0.03514761f, -0.02594256f, 0.03316221f, 
    -0.01354315f, -0.03779769f, 0.03591545f, 0.03164201f, -0.00685301f, 0.00668438f, -0.01843979f, -0.03806270f, 
    -0.02144015f, -0.01447758f, 0.01240669f, 0.01860049f, -0.02552138f, 0.02362539f, -0.00823408f, 0.00239377f, 
    -0.02366206f, 0.04169106f, 0.01031983f, 0.01033456f, 0.00833276f, -0.02850669f, 0.01601715f, -0.03176530f, 
    -0.01744982f, -0.01730448f, -0.02522786f, 0.00432609f, 0.00082226f, 0.02130546f, 0.01193149f, 0.01601293f, 
    0.03121083f, -0.00672994f, 0.00884244f, 0.03602510f, -0.03445029f, -0.02569939f, -0.00521116f, 0.02700942f, 
    -0.01422894f, 0.02495413f, -0.00139087f, 0.00357464f, -0.00764021f, -0.00442507f, 0.00483285f, -0.00187616f, 
    -0.02745195f, -0.01559126f, -0.00367004f, 0.02702689f, -0.01168454f, -0.02378386f, 0.00304635f, -0.00051698f, 
    0.02435380f, -0.01762593f, -0.02204047f, 0.02578101f, 0.02384966f, -0.01726236f, 0.01475106f, -0.02859304f, 
    0.01051918f, -0.00134893f, -0.00705535f, 0.02708806f, -0.03747569f, -0.03440073f, -0.02310265f, -0.01400832f, 
    -0.01512061f, 0.01770717f, -0.02820738f, 0.00496510f, 0.01749090f, 0.01375673f, -0.00084452f, -0.03742082f, 
    -0.00480043f, -0.02313060f, -0.02473450f, 0.01698281f, -0.01876820f, -0.01023329f, 0.02330710f, -0.00826649f, 
    0.03500437f, 0.01636916f, -0.01748696f, -0.03147738f, -0.00192610f, 0.02564741f, -0.01997356f, 0.01503381f, 
    -0.03102304f, 0.02761438f, -0.00997952f, 0.01956490f, -0.01107932f, 0.02371764f, -0.00838515f, 0.00663692f, 
    0.02626338f, -0.03623586f, 0.02426154f, 0.02785527f, 0.01741163f, -0.00820825f, 0.00247054f, -0.00383598f, 
    -0.00414724f, 0.02144342f, 0.00164983f, -0.00294476f, 0.01972338f, -0.03766440f, -0.01810117f, 0.02528885f, 
    -0.01270010f, -0.02256456f, 0.00083412f, 0.00252091f, -0.02890083f, -0.00565978f, 0.01588996f, -0.02315356f, 
    0.00509353f, -0.00762972f, 0.00856900f, -0.03000458f, 0.00559011f, -0.01727427f, 0.00786200f, -0.04274589f, 
    0.01096473f, 0.01645201f, 0.00856646f, 0.02254876f, 0.01015781f, 0.01637130f, 0.01111901f, -0.04307111f, 
    0.01579270f, -0.02090144f, 0.03053755f, 0.01971296f, 0.02311607f, -0.01256088f, -0.01116237f, -0.02023590f, 
    -0.04049460f, -0.02295180f, -0.04169933f, -0.02409896f, 0.00931448f, -0.04402185f, -0.02635860f, 0.00553506f, 
    -0.01441202f, -0.00904863f, 0.00034772f, -0.02121369f, 0.01341193f, -0.03035963f, 0.01846782f, 0.02881101f, 
    -0.02524036f, -0.03130008f, -0.01151909f, 0.02296016f, -0.00898321f, -0.03008368f, -0.00696592f, -0.00524883f, 
    -0.03768537f, 0.01574511f, -0.02641203f, -0.02042328f, -0.02396576f, -0.03443263f, 0.00081145f, 0.03374287f, 
    -0.02860511f, -0.01543079f, 0.00635959f, -0.02625376f, 0.01625251f, 0.00244220f, 0.00668954f, -0.02685786f, 
    -0.01275896f, -0.00049772f, -0.04029940f, 0.02099443f, 0.00515006f, -0.00612879f, 0.02588661f, -0.01594125f, 
    0.01607386f, -0.00148897f, 0.00323681f, -0.00626061f, 0.01016114f, 0.00482821f, -0.03975024f, 0.02880521f, 
    -0.04383893f, 0.00751094f, -0.04087500f, 0.00091269f, 0.01942218f, -0.02864265f, 0.02599052f, 0.02455741f, 
    -0.01626332f, 0.00088224f, 0.01754755f, 0.01903317f, -0.03060283f, -0.00939359f, -0.03980645f, -0.01726705f, 
    -0.02162011f, -0.03563766f, 0.00787745f, -0.02502678f, 0.01720786f, 0.00754893f, -0.00751321f, -0.03046516f, 
    0.01489204f, 0.01501709f, -0.02161902f, -0.01523437f, 0.00210057f, -0.01992855f, 0.00250770f, -0.03155062f, 
    -0.02073084f, -0.04441919f, -0.00689371f, 0.01297103f, -0.00652362f, -0.02680883f, 0.00306562f, -0.00780425f, 
    -0.03275095f, -0.03276085f, 0.01269609f, -0.02354021f, 0.01205633f, -0.03000454f, -0.01115507f, 0.01282816f, 
    0.02687796f, -0.00044951f, -0.00063039f, -0.01390723f, -0.01373189f, 0.02109341f, -0.00572003f, 0.02060400f, 
    -0.03149344f, 0.00726967f, -0.02241132f, -0.01366423f, -0.02263862f, -0.02021541f, 0.00028466f, -0.01035371f, 
    0.01374510f, 0.00351705f, -0.02494189f, -0.02353540f, -0.03677467f, 0.02245656f, 0.02904494f, -0.02709221f, 
    -0.03654491f, 0.02441278f, -0.02774853f, -0.02545684f, 0.01873714f, -0.02578178f, -0.03838414f, -0.01649365f, 
    -0.01542925f, -0.03804973f, -0.03300476f, 0.00041854f, 0.02138731f, 0.03847924f, -0.01603693f, 0.01248017f, 
    -0.00792453f, 0.03576087f, -0.01146558f, 0.02632324f, -0.01321236f, 0.01177211f, 0.00091569f, 0.02684289f, 
    -0.01712277f, 0.02584872f, 0.00493287f, -0.01445282f, -0.04305401f, 0.00711515f, 0.00648149f, -0.03380331f, 
    -0.00725620f, -0.01095704f, -0.00305119f, 0.03493391f, -0.02284355f, -0.00567982f, 0.01708218f, -0.03614622f, 
    -0.02062198f, -0.02034527f, 0.02652208f, 0.00052351f, -0.01491446f, -0.00242566f, 0.01235182f, -0.00008106f, 
    -0.00284093f, 0.01226975f, 0.00489529f, 0.00039236f, 0.02980876f, -0.04052422f, -0.03374545f, 0.00322000f, 
    -0.03889392f, 0.00386748f, -0.04191569f, 0.01532502f, 0.00352782f, 0.02572874f, -0.03298666f, 0.00465244f, 
    0.02718703f, -0.01065232f, -0.03109074f, 0.00610635f, -0.01166909f, -0.01674822f, 0.00405377f, -0.01552065f, 
    -0.02172972f, 0.02515846f, -0.02731670f, -0.03131834f, 0.03725987f, -0.01949496f, -0.03287496f, -0.00537876f, 
    0.02939306f, 0.02762918f, -0.03661735f, 0.00739857f, -0.01705145f, -0.01871610f, 0.03060444f, -0.03491506f, 
    0.02749080f, -0.03088538f, -0.00315680f, 0.02698104f, 0.00841201f, 0.01277791f, -0.02193337f, -0.01562818f, 
    -0.04204308f, 0.02593884f, -0.01869633f, -0.00009282f, 0.02530059f, 0.00769901f, 0.03818585f, -0.02063471f, 
    -0.02053748f, -0.03354607f, -0.00677088f, 0.00546149f, 0.02181532f, -0.01753666f, -0.00997471f, 0.01731529f, 
    -0.02111462f, -0.02267339f, -0.04013756f, -0.00444366f, -0.00289410f, -0.00824525f, -0.01826174f, 0.00781284f, 
    -0.02862263f, -0.01392662f, 0.00831778f, -0.02505412f, 0.01122277f, 0.02504915f, -0.04369338f, -0.00340203f, 
    -0.03855650f, 0.02084360f, -0.02293713f, 0.01804277f, -0.00140326f, 0.01983616f, -0.00089952f, -0.02850264f, 
    -0.03061492f, -0.00351545f, -0.02703279f, 0.00063570f, 0.01965327f, -0.02815869f, -0.03793285f, -0.00488434f, 
    -0.00456394f, -0.01382049f, 0.03700296f, -0.02478979f, -0.00195044f, -0.00554050f, 0.01439372f, -0.03600962f, 
    -0.04181517f, 0.01379155f, 0.02144715f, -0.04227484f, 0.01509522f, 0.00086153f, 0.01257460f, 0.00668469f, 
    -0.01594635f, 0.03424926f, -0.03499697f, -0.02259586f, -0.01585858f, 0.00239218f, 0.01843600f, 0.01137622f, 
    0.02254396f, -0.02184793f, 0.00058913f, -0.02905321f, -0.03408625f, -0.00526302f, -0.02996727f, 0.00387352f, 
    -0.02656804f, 0.00023784f, 0.00552744f, -0.00689367f, 0.01519385f, -0.01662556f, 0.00174992f, -0.03710530f, 
    -0.01031445f, -0.02042950f, -0.01482125f, 0.01349488f, -0.00892961f, -0.03747403f, 0.02741409f, -0.02826688f, 
    0.00798718f, 0.01750087f, 0.00121443f, 0.00872900f, 0.02278652f, -0.01401843f, -0.04129579f, 0.02119537f, 
    0.01588123f, 0.03392299f, -0.01958827f, -0.02160429f, -0.02845639f, 0.01078325f, 0.01675934f, -0.01547351f, 
    0.01020171f, -0.02227710f, 0.02408436f, 0.01625908f, 0.00607227f, -0.00172858f, 0.02202349f, -0.03635171f, 
    0.02161899f, 0.01806892f, -0.00224996f, 0.00208650f, 0.00012673f, -0.02725568f, -0.02328077f, 0.01290976f, 
    0.00533379f, 0.01761757f, -0.03088690f, -0.02382009f, -0.01772332f, 0.02327263f, -0.01167842f, -0.01176338f, 
    -0.00813669f, 0.00893941f, 0.01626188f, -0.02415685f, 0.02319057f, -0.02475293f, -0.02971568f, -0.03549989f, 
    0.00195361f, 0.01396722f, 0.03700664f, 0.01550424f, 0.02980525f, -0.00957157f, 0.03081292f, -0.02513608f, 
    -0.03587865f, -0.03977181f, 0.00211760f, -0.01494529f, -0.01797873f, 0.01039027f, -0.04343414f, -0.01923963f, 
    -0.01247143f, 0.01017336f, -0.03258061f, -0.00322849f, 0.00190781f, 0.01110704f, -0.04085877f, -0.02337855f, 
    -0.00270642f, -0.01132893f, 0.00544275f, -0.03909858f, -0.02225986f, 0.00459492f, -0.02925128f, 0.02369588f, 
    0.00907859f, 0.02739257f, 0.00735847f, 0.01613539f, -0.00318125f, 0.00977387f, 0.00970059f, 0.01819982f, 
    0.01452901f, -0.03551038f, -0.02222731f, 0.00577170f, -0.03544325f, 0.00920487f, -0.03685543f, -0.02422703f, 
    -0.00441095f, -0.00183554f, -0.02339867f, 0.01839656f, 0.02350776f, -0.02680377f, -0.04095267f, -0.02143201f, 
    -0.03875591f, 0.01256693f, 0.00843842f, 0.01098845f, -0.00449761f, 0.02762987f, -0.01858683f, 0.00810701f, 
    -0.03596712f, -0.01490917f, -0.01471998f, -0.00381770f, 0.00149635f, 0.01047244f, -0.00686706f, -0.03174569f, 
    0.02272381f, 0.02122679f, -0.01193150f, -0.01020779f, 0.00948673f, 0.02105244f, 0.01850792f, -0.00356207f, 
    -0.04298269f, -0.02156316f, -0.03681159f, -0.02910267f, 0.01747790f, -0.03772569f, 0.00916086f, 0.01219951f, 
    -0.03869489f, -0.02509543f, -0.03301171f, -0.01352230f, -0.02988119f, -0.02704631f, -0.00906614f, -0.01295855f, 
    -0.00125711f, -0.01887153f, -0.02428211f, 0.02719242f, 0.01640687f, -0.01113041f, -0.03303466f, -0.01004395f, 
    0.02980469f, -0.01239935f, 0.01073941f, 0.01933116f, -0.00033709f, 0.00010402f, 0.00600956f, -0.02108322f, 
    -0.00126835f, -0.00852580f, -0.03984773f, 0.01833927f, -0.03379752f, -0.01485616f, -0.04107087f, -0.02623113f, 
    -0.02356981f, 0.02650553f, -0.03029575f, 0.02184237f, -0.01300124f, -0.02387510f, 0.00301301f, -0.01319161f, 
    0.02634630f, 0.01250975f, 0.01458606f, -0.00849851f, 0.00127957f, -0.00726123f, 0.00079489f, -0.04159801f, 
    0.02664489f, -0.03014724f, -0.02953880f, 0.00565495f, -0.02993452f, 0.00080089f, -0.03613709f, 0.01670930f, 
    -0.04262231f, -0.02824037f, 0.02486518f, 0.00692917f, -0.02141592f, 0.02519345f, 0.00823337f, -0.00124091f, 
    0.02641479f, 0.00441153f, -0.02148224f, 0.02386095f, -0.01316290f, -0.01505485f, 0.03540283f, -0.00732540f, 
    0.00104603f, 0.00286759f, -0.03442814f, -0.04241338f, -0.01987800f, 0.01663692f, -0.01884327f, -0.01862422f, 
    -0.02298136f, -0.03803632f, 0.00899248f, -0.01584474f, 0.00106390f, 0.02535619f, 0.00905325f, -0.03905600f, 
    0.00050071f, 0.00783803f, 0.00764122f, -0.02084949f, -0.00850199f, -0.01066991f, -0.02288019f, 0.00175853f, 
    -0.01594254f, 0.00409779f, -0.01296498f, -0.00756760f, 0.02157676f, -0.01008128f, 0.01409601f, 0.00174766f, 
    0.02190835f, -0.00167600f, 0.00860620f, 0.00615189f, -0.03346711f, 0.02210566f, -0.04109142f, 0.01706208f, 
    -0.02552785f, 0.00726851f, -0.00869751f, 0.02769186f, -0.03413138f, 0.00469921f, 0.00996816f, -0.00634919f, 
    0.03311937f, -0.02985317f, 0.00983940f, 0.02195811f, -0.03008682f, -0.02241926f, 0.02596371f, 0.03600834f, 
    -0.03173180f, -0.01395264f, 0.00478083f, -0.02073064f, -0.04225067f, -0.01489199f, 0.00557704f, -0.00474718f, 
    -0.00096373f, 0.00537777f, 0.00743168f, -0.02511325f, 0.00764303f, 0.02607982f, 0.02363869f, -0.03830191f, 
    -0.02632676f, -0.02297356f, 0.01458865f, -0.02344678f, 0.01897340f, -0.01442063f, 0.03254936f, -0.04288311f, 
    -0.00859932f, 0.01711223f, -0.00444135f, -0.02944529f, 0.00255313f, -0.00295633f, -0.01540888f, 0.00563548f, 
    -0.00798080f, 0.00060198f, 0.02358929f, 0.02466742f, 0.01090308f, 0.03235264f, 0.01997777f, 0.01513643f, 
    -0.00743172f, 0.02383878f, -0.03177385f, 0.01938467f, -0.01942481f, -0.01980340f, 0.00437079f, -0.00163212f, 
    -0.00955171f, 0.02345853f, 0.00182903f, 0.00435658f, 0.01511588f, 0.00526171f, 0.00847671f, -0.01526747f, 
    0.00580262f, 0.00325733f, 0.00358143f, 0.02336534f, -0.01098146f, -0.02940845f, -0.02312206f, 0.01145890f, 
    -0.01527438f, -0.01433618f, 0.02536221f, 0.00685250f, -0.03168863f, 0.03938835f, 0.02362366f, -0.03561221f, 
    0.03136242f, 0.20768653f, 0.01428577f, 0.15477817f, 0.06233629f, -0.01489261f, -0.01372598f, 0.00000297f, 
    -0.15313105f, 0.06501818f, -0.01469513f, 0.07548179f, 0.05305219f, -0.15757488f, -0.00776118f, 0.13987397f, 
    0.15399125f, 0.07940489f, 0.06964254f, -0.01352853f, 0.00136394f, -0.04162079f, 0.00081167f, 0.07281107f, 
    0.06171213f, 0.04540537f, -0.03493301f, 0.14208029f, 0.09850813f, 0.02556292f, -0.02979245f, 0.03873603f, 
    0.01825577f, 0.02448254f, 0.09177659f, 0.05307192f, 0.20482656f, 0.06085783f, 0.15355580f, 0.20290150f, 
    0.06500836f, -0.06745680f, -0.00771636f, 0.00350791f, -0.05481222f, -0.10675578f, 0.08590604f, -0.00402106f, 
    0.17903344f, -0.23820043f, -0.06553236f, 0.09492805f, 0.00495853f, -0.09895168f, -0.00741903f, 0.01794426f, 
    -0.01051782f, 0.06775757f, 0.01831645f, -0.02891066f, -0.30632383f, -0.12701625f, 0.17931631f, -0.22913159f, 
    0.12488101f, -0.07900887f, -0.04289822f, 0.09323563f, 0.17356046f, 0.13268161f, -0.01736209f, 0.05161984f, 
    0.11166268f, 0.08904404f, 0.05309518f, -0.01638887f, 0.02897226f, -0.04706875f, -0.11484797f, 0.05564497f, 
    0.03900211f, 0.02438537f, -0.09308758f, -0.03072671f, 0.22806221f, -0.16136467f, -0.11738441f, -0.06413658f, 
    -0.04340183f, 0.01344699f, -0.04366804f, -0.04698224f, 0.10549881f, 0.00369336f, -0.10169413f, 0.01101209f, 
    0.03796829f, 0.04428287f, 0.21687743f, -0.10413434f, -0.04778872f, -0.09192493f, -0.14730042f, 0.00852927f, 
    -0.15208116f, -0.02438481f, -0.02256248f, -0.04556416f, 0.21648730f, 0.04076308f, 0.10865699f, -0.05029150f, 
    0.01217934f, 0.04884244f, 0.00425606f, 0.10095268f, 0.03210393f, -0.03855000f, 0.06101809f, -0.11975471f, 
    -0.19158866f, 0.00607507f, -0.05406881f, -0.04183856f, -0.03875082f, -0.11629006f, 0.09633067f, 0.14129809f, 
    0.01584951f, 0.02798905f, -0.03468496f, 0.01864115f, -0.27442577f, -0.11889885f, -0.17704748f, -0.11440810f, 
    0.04183883f, -0.02510140f, -0.08962276f, 0.01142490f, 0.11217518f, -0.04661594f, -0.12858590f, -0.02974471f, 
    0.02907929f, -0.04783903f, -0.05205396f, 0.12770097f, 0.03476949f, -0.06165991f, 0.00718606f, 0.03538759f, 
    0.10768381f, 0.14900154f, -0.10913027f, 0.03371329f, 0.21732007f, 0.13111104f, -0.01399509f, 0.07447302f, 
    0.01876464f, -0.04798900f, 0.04088304f, 0.06255858f, 0.06656206f, 0.01272121f, 0.06669655f, -0.08639576f, 
    -0.05878823f, -0.00665704f, 0.16953972f, 0.01447822f, 0.09441276f, 0.06322631f, -0.03324381f, 0.06734766f, 
    0.00329591f, 0.01452720f, 0.02592217f, 0.02971954f, -0.16347782f, -0.13338020f, -0.05005093f, 0.14516698f, 
    -0.03988146f, -0.07769891f, 0.03228360f, 0.13110588f, 0.12484349f, -0.04833120f, 0.00664469f, 0.08201261f, 
    -0.11446155f, -0.03147412f, -0.08087949f, -0.02570343f, -0.00496901f, -0.12516609f, 0.10992937f, 0.12997931f, 
    0.08306782f, -0.00121311f, 0.07342433f, 0.07538884f, -0.08940786f, 0.06744719f, -0.09876058f, 0.09403087f, 
    -0.06893236f, 0.01927138f, 0.04382452f, 0.01963731f, 0.06586881f, 0.00025522f, 0.10891580f, 0.01659823f, 
    0.04800112f, 0.02733396f, -0.00036729f, 0.06951577f, 0.03951932f, -0.13248068f, -0.03348475f, 0.02733096f, 
    -0.01605625f, 0.09832553f, -0.02166887f, -0.05098785f, 0.11318921f, -0.15129729f, -0.04369409f, -0.08988468f, 
    0.01333565f, -0.01509121f, 0.09358525f, -0.00391639f, 0.03070766f, -0.02534202f, -0.07578107f, 0.11846756f, 
    0.33788684f, 0.00411149f, -0.09093290f, -0.16990450f, -0.04159587f, -0.02796738f, -0.02706590f, 0.05813488f, 
    -0.08220530f, 0.03183788f, -0.00250261f, 0.04144710f, -0.23682918f, -0.08261596f, 0.06799583f, 0.00806631f, 
    0.18535146f, -0.00646079f, -0.00582186f, -0.04899353f, -0.00229555f, 0.03629795f, -0.05786683f, 0.08133834f, 
    0.02546029f, -0.07737458f, 0.08495759f, 0.14870265f, 0.05733969f, 0.05044675f, 0.07761175f, -0.06840447f, 
    0.00839557f, 0.03202992f, -0.00432462f, 0.00431859f, 0.30200648f, -0.03977885f, -0.05117434f, 0.03786556f, 
    -0.04079387f, 0.04478972f, 0.12256532f, 0.05801960f, -0.01021111f, -0.13010064f, -0.01784857f, 0.06942172f, 
    0.06996119f, 0.22554266f, -0.03286793f, 0.01107934f, 0.02258308f, 0.01458477f, -0.14808325f, 0.00445582f, 
    0.15727250f, 0.03270201f, 0.03134190f, -0.00157483f, -0.06933179f, -0.08334760f, 0.07866152f, -0.00637810f, 
    0.09284297f, 0.11578459f, 0.04955298f, -0.02789783f, -0.10330611f, -0.01003749f, -0.00971495f, 0.12621574f, 
    0.08371911f, 0.07162049f, -0.07571002f, -0.12101743f, 0.07434450f, 0.11298057f, -0.05928764f, 0.09531092f, 
    -0.01292107f, 0.02032913f, 0.08523316f, 0.03522655f, 0.07509933f, 0.14429015f, 0.03370420f, -0.02618323f, 
    -0.07259774f, -0.01784575f, 0.14928111f, 0.08811097f, 0.00548184f, 0.08191905f, -0.05081371f, 0.04613096f, 
    -0.04772506f, 0.12344514f, -0.05013830f, 0.00701588f, -0.02109794f, 0.04868711f, 0.05583468f, 0.11021478f, 
    0.00270130f, -0.05962210f, 0.07218605f, 0.03950837f, -0.05464325f, 0.04181992f, -0.07619621f, 0.14290945f, 
    -0.02098586f, 0.02400396f, -0.04631997f, -0.05717489f, 0.02488024f, 0.08041745f, -0.05065327f, -0.07344222f, 
    0.07585168f, -0.16469033f, -0.04225000f, -0.09323665f, -0.09294411f, 0.13432586f, 0.01591912f, 0.03582872f, 
    -0.02355527f, 0.04486410f, 0.04113722f, 0.01385174f, 0.09259547f, 0.12281389f, 0.00779388f, -0.03491092f, 
    0.03606593f, 0.02630778f, 0.07680350f, -0.08403162f, -0.03223590f, 0.14503764f, -0.02327005f, 0.06555786f, 
    -0.04627755f, 0.04916270f, 0.06043914f, -0.00745740f, -0.01392023f, -0.04510616f, 0.04157366f, 0.06512147f, 
    0.03308664f, -0.05240122f, 0.11821667f, 0.13389130f, -0.13242775f, -0.18186201f, -0.01748685f, 0.06644443f, 
    -0.03502502f, 0.12927809f, 0.02767748f, 0.02111775f, -0.13580973f, 0.05773395f, -0.00363224f, 0.00874245f, 
    -0.05136627f, -0.19031367f, 0.09015402f, 0.04615583f, 0.02340024f, 0.06123012f, 0.02283320f, 0.03295465f, 
    0.05298667f, 0.14347360f, -0.04519344f, 0.05826107f, 0.00311022f, -0.09794530f, -0.09073626f, -0.11345261f, 
    0.08788224f, 0.05334924f, -0.08177065f, 0.02752445f, -0.05745174f, 0.03666268f, 0.07860859f, -0.02554138f, 
    -0.34602478f, -0.10517628f, 0.06980159f, 0.05073523f, -0.03445501f, 0.02338957f, 0.05629158f, -0.00320209f, 
    0.01085661f, -0.04261430f, -0.02029706f, -0.09591021f, -0.18433970f, -0.09687673f, 0.03465486f, -0.00416616f, 
    0.01109157f, 0.11127380f, 0.01572731f, 0.04479404f, 0.10855783f, -0.04060436f, 0.01149478f, 0.04800514f, 
    0.06942444f, 0.15603551f, 0.11250035f, -0.00914478f, 0.00927764f, -0.02918617f, 0.15001604f, 0.09215771f, 
    0.05364759f, -0.05161562f, 0.10145994f, 0.07742222f, -0.16059123f, -0.02846405f, -0.04892850f, -0.16771320f, 
    0.00470696f, -0.01542700f, 0.01441254f, 0.07919738f, 0.08053565f, -0.01444488f, 0.06940029f, 0.10880549f, 
    -0.11010640f, -0.02577916f, -0.04007464f, 0.02899650f, 0.09822245f, -0.05068718f, 0.00649195f, 0.03067095f, 
    -0.00216524f, -0.13274254f, -0.00993044f, 0.07306785f, 0.04129082f, -0.12005091f, 0.02202934f, -0.00206152f, 
    0.01651719f, -0.10091390f, -0.03142290f, -0.03896350f, 0.00322341f, 0.02387157f, -0.12228784f, 0.17054172f, 
    0.06219664f, -0.19531393f, -0.04102234f, -0.04860633f, 0.07237013f, 0.08174925f, 0.00747148f, -0.00792420f, 
    0.07895108f, -0.09077055f, -0.08734139f, 0.10564408f, 0.19150384f, -0.08658231f, -0.12157425f, -0.02522321f, 
    -0.06322925f, 0.06980306f, 0.06215591f, 0.13061374f, -0.07788045f, -0.04043709f, 0.10622525f, -0.01701927f, 
    -0.19954318f, -0.15113240f, 0.00948646f, 0.03784565f, -0.01545614f, 0.03263769f, -0.02668709f, 0.08803615f, 
    0.03903369f, -0.08537278f, -0.06455737f, 0.03239704f, -0.04662620f, 0.09129083f, -0.02582184f, -0.06820898f, 
    0.02419327f, -0.02030515f, -0.13868973f, -0.11211848f, -0.01658280f, -0.05056429f, 0.06831960f, -0.17002264f, 
    0.30103013f, -0.07252324f, -0.19657281f, 0.06514310f, -0.00849268f, 0.04839149f, 0.02317208f, 0.10545141f, 
    0.00204539f, 0.06301731f, -0.05976161f, 0.06836507f, -0.50498033f, -0.09944422f, -0.06726035f, -0.11032756f, 
    0.07751825f, -0.02747754f, -0.08004043f, -0.07310165f, 0.05795592f, -0.06130917f, 0.04386292f, 0.00150585f, 
    0.19761592f, -0.16666357f, 0.04137164f, 0.07419114f, 0.10146119f, 0.02279633f, 0.00010087f, -0.01858318f, 
    -0.02404932f, 0.05346555f, -0.10128045f, -0.11466968f, -0.09964138f, 0.18383461f, -0.08075599f, -0.00766367f, 
    0.06949051f, -0.13138406f, -0.02217386f, -0.06337560f, -0.00323303f, 0.03011847f, -0.02573656f, 0.00307192f, 
    0.13858867f, 0.13527270f, -0.02854479f, -0.15042600f, 0.10048995f, -0.01701425f, 0.04787047f, -0.01688788f, 
    -0.02407289f, 0.08327696f, 0.08446818f, 0.02327224f, 0.25468960f, 0.03387930f, -0.06658471f, 0.03575018f, 
    0.00569125f, -0.01089335f, 0.02735196f, -0.14662710f, -0.00561757f, -0.01486238f, 0.06639630f, 0.07216643f, 
    -0.04000185f, -0.04637345f, -0.11447238f, 0.07378648f, -0.04516657f, -0.06152116f, -0.06221685f, 0.05550372f, 
    -0.00291297f, 0.06519862f, -0.00733307f, 0.00424791f, -0.04989431f, 0.06267531f, 0.08281379f, -0.07453866f, 
    -0.03026610f, -0.05479290f, -0.01323725f, 0.09870375f, 0.07027160f, -0.06990483f, -0.07682961f, 0.04186016f, 
    0.07284231f, -0.05002740f, 0.02528007f, 0.03048947f, 0.06740887f, 0.05279507f, -0.00145056f, -0.05395278f, 
    -0.10834093f, 0.06056254f, -0.01853814f, 0.03691787f, -0.04842276f, 0.11787781f, 0.08674011f, -0.10331876f, 
    0.07367970f, -0.00306298f, -0.01165118f, 0.08392379f, -0.06582061f, 0.02076294f, 0.11246937f, 0.10524736f, 
    0.44413367f, 0.06534243f, -0.04587656f, 0.02144220f, -0.03629219f, 0.09112749f, 0.15875921f, 0.02935341f, 
    0.07583487f, -0.04731227f, -0.03398877f, -0.06070011f, 0.16535015f, -0.29680857f, -0.02421003f, 0.23024942f, 
    0.01170538f, 0.05426829f, -0.02929476f, -0.05792956f, -0.08905048f, 0.05992078f, 0.03169108f, 0.02590452f, 
    0.04052510f, 0.07337908f, 0.10210955f, -0.15324172f, -0.01921641f, -0.03450936f, -0.00031967f, -0.12373500f, 
    0.12089739f, 0.09828033f, 0.10025138f, 0.04837226f, -0.00826547f, 0.02377511f, 0.02047960f, 0.00295920f, 
    -0.00901042f, -0.11199433f, 0.06123547f, 0.02933765f, -0.07566626f, 0.04752254f, -0.07190910f, 0.02889985f, 
    -0.07542850f, 0.10022584f, -0.06052598f, -0.04722928f, 0.00467305f, -0.05473592f, -0.01936498f, -0.02639056f, 
    -0.10380547f, -0.13306816f, 0.11785613f, 0.05900972f, -0.03288544f, -0.13264106f, -0.15633120f, -0.03526933f, 
    0.09565540f, 0.01930124f, 0.04426956f, 0.03822789f, -0.05141398f, -0.06758939f, 0.11712433f, -0.01964106f, 
    0.24382335f, 0.12405726f, -0.02646439f, 0.06890520f, -0.08453082f, -0.06776463f, -0.06008928f, 0.06397717f, 
    -0.03894452f, 0.10883277f, -0.07066509f, 0.06810028f, 0.21090628f, 0.07554023f, 0.04828586f, 0.06892189f, 
    -0.06875488f, 0.08234493f, -0.01250354f, -0.01858020f, -0.06048334f, 0.04656559f, 0.00489648f, 0.10787072f, 
    0.01672378f, -0.03576125f, 0.02624981f, -0.03593564f, -0.01228668f, -0.01634349f, -0.02519862f, 0.00923588f, 
    -0.02138359f, -0.01172304f, 0.02742025f, -0.00110646f, -0.00359428f, 0.00668541f, -0.04008622f, -0.01650957f, 
    -0.02103839f, 0.02264688f, -0.02937249f, -0.03465027f, -0.00681374f, 0.00359804f, 0.02715480f, -0.01807494f, 
    -0.00900100f, -0.00560591f, 0.02938046f, 0.01682309f, 0.02654255f, 0.03079299f, -0.03349631f, 0.02415440f, 
    -0.02895773f, -0.03359798f, -0.02717812f, -0.00301333f, 0.02116882f, -0.00040911f, -0.03604570f, 0.00476696f, 
    -0.00069879f, 0.01655056f, -0.03029259f, -0.01760165f, 0.01483881f, 0.03694521f, -0.02908525f, -0.01644866f, 
    -0.00253033f, 0.01430155f, 0.01623315f, 0.02777595f, -0.00890378f, 0.00167061f, 0.00465092f, 0.02741322f, 
    -0.02230517f, 0.03505683f, 0.01759446f, 0.01176709f, -0.03367600f, -0.03593435f, 0.00703081f, 0.00133680f, 
    -0.03813407f, -0.01936853f, -0.00039346f, -0.00078649f, -0.04318163f, -0.00982474f, 0.00031840f, 0.01345901f, 
    -0.03377716f, -0.03470396f, -0.01727820f, -0.00901741f, 0.00520808f, 0.03030127f, -0.02142819f, 0.00429567f, 
    -0.02953147f, -0.02092501f, 0.02049422f, -0.01885308f, -0.04328017f, -0.00382602f, -0.03832426f, 0.02167165f, 
    -0.00020255f, -0.03465760f, -0.03621867f, 0.02583396f, -0.02964845f, -0.02152843f, -0.03440492f, -0.00848147f, 
    0.03140920f, 0.00900756f, 0.01105194f, -0.02944859f, -0.01170417f, 0.01734457f, -0.01082409f, -0.02150713f, 
    0.02329990f, -0.02089773f, -0.02167722f, -0.02335620f, -0.02319780f, -0.02328311f, 0.01361582f, 0.01656987f, 
    0.01497039f, -0.00188331f, -0.02278881f, -0.00339376f, -0.00696086f, -0.00988820f, 0.01482980f, 0.00740470f, 
    -0.01674073f, 0.02042636f, -0.02475152f, -0.02804694f, -0.03775671f, 0.01990775f, -0.01104003f, 0.01407745f, 
    -0.02575879f, -0.01210690f, 0.01143974f, -0.01096890f, -0.01304237f, 0.02118496f, 0.02940908f, -0.01878258f, 
    0.01628619f, 0.01718832f, 0.02804214f, 0.01899361f, 0.02650061f, -0.02501920f, -0.01142728f, -0.00717817f, 
    0.00204514f, -0.02365757f, -0.02720578f, -0.03154625f, -0.02813100f, -0.01347489f, -0.02951276f, -0.01217093f, 
    0.02416301f, 0.01539500f, -0.01016830f, -0.00905827f, 0.00311599f, 0.00280978f, 0.00640891f, 0.01153204f, 
    -0.03090681f, -0.00248498f, -0.01895670f, -0.01484052f, 0.03175508f, -0.02673315f, 0.02475418f, -0.02521100f, 
    0.00076780f, -0.03710324f, -0.01004418f, -0.01564860f, 0.00420577f, 0.01374121f, -0.02241492f, -0.04227745f, 
    -0.04029590f, -0.02947659f, -0.01075316f, -0.01040191f, -0.03333610f, -0.01956178f, 0.02270886f, 0.00574424f, 
    0.01837813f, 0.00200966f, -0.02367365f, 0.00561511f, -0.01148143f, -0.00057031f, 0.01092595f, 0.00537297f, 
    0.03252422f, -0.03066077f, -0.03199030f, -0.04034188f, 0.02561886f, -0.00469225f, -0.00704723f, -0.01781972f, 
    0.03006578f, -0.02188448f, -0.00807949f, -0.00797665f, -0.03633275f, -0.02651543f, -0.02502034f, 0.00514293f, 
    -0.00388415f, -0.02809293f, 0.01856026f, -0.03915491f, 0.00522289f, 0.02795560f, 0.02633060f, 0.02336456f, 
    -0.01327958f, -0.00796824f, -0.02005075f, -0.00681517f, -0.00220693f, -0.02778316f, -0.03689887f, -0.01291998f, 
    0.03209064f, 0.02244188f, -0.03674892f, 0.02607699f, -0.03628810f, 0.00667401f, -0.00463017f, -0.00309196f, 
    -0.02099021f, -0.03179523f, 0.03406943f, 0.00782748f, -0.00965607f, -0.02216784f, -0.01910260f, -0.01752157f, 
    -0.03172762f, -0.00959625f, 0.02443217f, 0.00309232f, 0.02125720f, -0.00298085f, 0.03550160f, 0.02029429f, 
    0.00533954f, 0.01903971f, -0.02214712f, 0.02445095f, -0.02795400f, -0.03162479f, 0.01094952f, 0.00137891f, 
    -0.00805979f, -0.03280796f, 0.02649334f, 0.01606903f, 0.01234411f, -0.03372385f, 0.04010502f, 0.02565370f, 
    -0.01779706f, -0.01586120f, 0.01627727f, 0.02287144f, 0.00493966f, 0.01336011f, 0.00623055f, -0.01475420f, 
    0.03536554f, 0.00590181f, 0.01134560f, -0.00166185f, -0.03043056f, -0.03342183f, -0.04023212f, -0.04184309f, 
    -0.02718285f, 0.00126350f, 0.02362279f, -0.00737392f, 0.01428050f, -0.04469525f, -0.00693459f, -0.02336406f, 
    -0.01631317f, -0.03351185f, -0.02369767f, -0.03651073f, -0.00200531f, -0.00077661f, -0.03847003f, 0.01017721f, 
    -0.04510267f, 0.00253035f, 0.00206763f, 0.00614168f, -0.00315762f, -0.00261537f, -0.01397970f, -0.01160877f, 
    -0.04321911f, -0.00449294f, 0.01441752f, -0.01805488f, 0.00238394f, -0.00718143f, -0.00744696f, -0.02896406f, 
    0.00448382f, 0.01435436f, 0.01725409f, 0.01639768f, 0.00701915f, 0.01662736f, 0.01996641f, -0.02835611f, 
    -0.02050648f, 0.00512545f, -0.00397828f, -0.02941115f, 0.00657721f, -0.00206458f, -0.01860498f, 0.03187479f, 
    0.00062105f, 0.02395455f, -0.00485594f, -0.00788502f, 0.02586601f, -0.04357042f, -0.01644947f, 0.00312959f, 
    -0.02867780f, 0.02083242f, -0.01203872f, 0.01177175f, 0.01861053f, 0.02673735f, 0.03447048f, -0.00923452f, 
    0.01199660f, 0.01435733f, -0.01000309f, -0.01222133f, -0.01520889f, -0.01545634f, -0.00328768f, -0.02608005f, 
    0.00936809f, 0.00836828f, 0.02100343f, 0.03040783f, -0.00365307f, 0.03417829f, 0.03568840f, -0.03105748f, 
    -0.02744089f, 0.02623169f, -0.00581897f, -0.03697907f, 0.00633206f, 0.02660934f, 0.02802117f, 0.01768106f, 
    0.00734785f, -0.02254901f, 0.01841929f, 0.03077283f, 0.02468607f, -0.01249369f, -0.01940001f, -0.01269172f, 
    -0.02224704f, -0.02000714f, 0.00778794f, -0.01165521f, -0.01469535f, -0.01763376f, 0.00608110f, 0.03233496f, 
    0.02132041f, 0.01505626f, -0.00835028f, -0.00444748f, 0.02173132f, -0.01200396f, -0.03021855f, 0.01291141f, 
    -0.04581080f, -0.00041485f, -0.04082772f, -0.04331935f, 0.00346564f, 0.02963172f, -0.04242741f, -0.00101958f, 
    -0.01454881f, 0.01234691f, 0.01166281f, -0.00289188f, 0.00456974f, -0.04219104f, -0.00532195f, -0.00115840f, 
    -0.00071964f, -0.02127071f, -0.00739669f, -0.00097987f, 0.02457341f, -0.00386493f, -0.02434549f, -0.01919034f, 
    -0.00872932f, 0.00885477f, -0.03010498f, -0.02595246f, 0.01820877f, -0.00694345f, 0.00033540f, -0.03490208f, 
    0.01234864f, -0.00283660f, 0.01230914f, -0.01080139f, -0.01035616f, 0.02807398f, 0.01569900f, 0.02033866f, 
    0.02244950f, 0.02670150f, 0.03979358f, 0.00634181f, 0.01432190f, 0.03170512f, 0.02326529f, -0.02505129f, 
    0.02096756f, -0.00515703f, 0.00827182f, 0.03304400f, -0.02057385f, -0.00369490f, -0.02532321f, -0.04000539f, 
    0.02598269f, -0.00024634f, -0.01694564f, -0.03991138f, 0.00128446f, 0.02353993f, 0.02102672f, -0.01209446f, 
    -0.03440380f, -0.03170412f, 0.00517554f, 0.02080215f, -0.03501936f, -0.00166374f, -0.01527421f, 0.02529746f, 
    -0.01588363f, 0.00291975f, 0.00784276f, 0.00230189f, -0.01963675f, -0.02077015f, 0.01224490f, -0.02147815f, 
    0.00062588f, -0.01475049f, 0.02168187f, -0.03621190f, -0.03731802f, -0.00152557f, -0.03496511f, -0.03486651f, 
    -0.03407372f, 0.01464454f, -0.03577216f, 0.01163589f, 0.00631430f, 0.02604601f, 0.01139878f, 0.02073968f, 
    -0.02706199f, -0.03547173f, -0.00784749f, -0.02874499f, -0.01172635f, -0.01967373f, 0.00317369f, -0.00639004f, 
    -0.01491085f, 0.00408686f, -0.03409672f, -0.00137210f, -0.02058000f, -0.00927928f, 0.01540767f, -0.03556664f, 
    0.02549907f, 0.01442364f, -0.02760350f, -0.02419711f, -0.01863158f, -0.00530495f, -0.02817631f, 0.01913573f, 
    0.00079943f, -0.02673110f, -0.03972411f, -0.00000092f, 0.03249314f, 0.02415451f, 0.03090985f, 0.01807770f, 
    0.03005632f, -0.00591612f, -0.04120269f, -0.03176247f, -0.02653974f, 0.00902296f, -0.02779645f, 0.02012856f, 
    -0.02917799f, 0.01609464f, -0.01333511f, 0.01423797f, 0.01054827f, 0.01622435f, 0.00404371f, -0.03075654f, 
    0.01966540f, 0.02974041f, 0.01724349f, 0.01794707f, -0.03687452f, 0.02690075f, -0.00921637f, -0.01476911f, 
    0.02341745f, -0.02391271f, 0.01127120f, -0.02632307f, 0.01910378f, -0.00460693f, -0.02157580f, 0.01687130f, 
    -0.01499519f, -0.02431486f, -0.03050503f, 0.01005249f, -0.02779845f, -0.01188142f, -0.02172868f, 0.02989478f, 
    -0.00406621f, 0.02231321f, 0.01489488f, -0.00268787f, -0.00621587f, -0.00744508f, -0.03779214f, 0.03024278f, 
    -0.00911740f, -0.00934365f, -0.03690771f, 0.01270841f, -0.01175337f, -0.03172582f, 0.00245241f, -0.00134372f, 
    0.02128073f, -0.02624782f, 0.01427384f, -0.02510219f, -0.00527473f, -0.00135164f, 0.00575286f, 0.01817961f, 
    0.01563218f, 0.02860438f, 0.00283746f, -0.00807461f, 0.01526622f, -0.00098337f, -0.00486613f, 0.00146632f, 
    0.00883260f, 0.00923576f, -0.02829532f, -0.00784188f, -0.02999525f, -0.02892194f, 0.02765401f, -0.01852381f, 
    -0.00380116f, 0.00046413f, -0.00648377f, 0.02185781f, -0.02887366f, -0.02026365f, 0.02003164f, -0.00033025f, 
    -0.01555289f, -0.02839090f, -0.02394574f, 0.02520990f, -0.01271570f, -0.02520717f, 0.00513206f, 0.01285037f, 
    0.00556912f, 0.02286394f, -0.03862613f, 0.00005936f, 0.01003387f, 0.01192670f, -0.01394980f, -0.02907974f, 
    0.02691354f, -0.03267978f, 0.02499956f, 0.00338127f, 0.00520433f, -0.00542985f, -0.03875415f, -0.00378565f, 
    0.02816124f, 0.02817179f, 0.03400123f, -0.03419756f, -0.00930613f, 0.00641409f, -0.02070344f, -0.00341642f, 
    -0.01932401f, 0.01774434f, -0.04475387f, -0.01648750f, 0.01845644f, 0.02773388f, 0.01180118f, -0.02645732f, 
    0.00463198f, -0.02342377f, -0.02733448f, -0.02322378f, -0.04040653f, -0.00438673f, -0.00814348f, -0.01759884f, 
    0.00490073f, -0.02706992f, -0.01304737f, -0.02588195f, -0.02908527f, 0.02714571f, -0.00601550f, -0.02502879f, 
    -0.03631896f, -0.02171170f, 0.01469424f, 0.01004947f, -0.00105121f, -0.03206022f, -0.03479649f, -0.04307476f, 
    0.00124142f, 0.00100035f, -0.03979657f, -0.03034430f, -0.03379184f, 0.02158125f, 0.00750975f, -0.01212700f, 
    -0.01414979f, 0.01595872f, 0.02371838f, -0.02286729f, 0.01104682f, 0.00749474f, -0.00216138f, 0.02395596f, 
    -0.03151909f, 0.01162710f, 0.02166420f, -0.00410691f, -0.03734030f, -0.02136139f, 0.02606570f, -0.02514726f, 
    -0.03296889f, -0.02421324f, 0.00791736f, 0.01217967f, -0.02761950f, 0.02815473f, -0.01492669f, 0.00488585f, 
    0.01873705f, -0.00109993f, 0.01884566f, -0.00867317f, 0.00903637f, -0.02883535f, -0.04094890f, 0.01083427f, 
    -0.01011976f, 0.01917231f, -0.00953490f, 0.02229411f, -0.03776310f, -0.01710473f, 0.02146528f, 0.01707145f, 
    0.01897342f, 0.01398552f, -0.00060462f, -0.02871039f, -0.02025721f, -0.00215712f, 0.01418518f, -0.02494412f, 
    0.02885549f, 0.01750262f, 0.01827170f, -0.03364677f, -0.02907146f, -0.00217390f, 0.02810758f, 0.00154572f, 
    0.02327287f, -0.02948402f, -0.02048333f, 0.00968915f, 0.01468766f, 0.02914703f, -0.01230121f, 0.02647988f, 
    -0.02452515f, -0.01037690f, 0.00205153f, -0.00178327f, -0.01659813f, 0.00964860f, 0.02408607f, -0.00828188f, 
    0.00242428f, 0.04225655f, 0.01919492f, 0.00901880f, -0.01406140f, 0.00985595f, 0.03304014f, 0.00526390f, 
    0.00184797f, -0.02228418f, -0.01445929f, 0.01689965f, 0.00894637f, 0.01927348f, -0.00003732f, 0.02841542f, 
    -0.10861895f, -0.07057862f, -0.04279362f, -0.13741732f, 0.01594936f, 0.01662113f, -0.00126436f, -0.01320262f, 
    0.07653401f, 0.05906593f, 0.08925235f, -0.01646420f, -0.08201417f, 0.26539931f, -0.00095273f, -0.07349994f, 
    -0.04537465f, -0.04337287f, 0.01673984f, -0.01237706f, 0.04833318f, 0.03835687f, 0.00845404f, 0.01249455f, 
    -0.04756703f, -0.04084158f, 0.00704511f, -0.06090012f, -0.01291858f, 0.03615339f, -0.05161631f, -0.08440768f, 
    -0.00037312f, 0.03536219f, -0.05360016f, -0.02330485f, -0.30413130f, -0.07892434f, -0.11796700f, -0.18874125f, 
    0.12849712f, 0.12888320f, -0.00643955f, -0.07114951f, -0.01009736f, 0.01411142f, -0.00190928f, 0.01064976f, 
    -0.10339655f, 0.12930004f, 0.12301897f, -0.03015742f, 0.08413288f, 0.13607642f, 0.04572546f, -0.02731174f, 
    0.00957377f, 0.01032584f, -0.01982629f, 0.03108856f, 0.20471747f, 0.12560162f, -0.01118111f, 0.08848945f, 
    -0.00589242f, 0.03719095f, 0.02769823f, -0.01631171f, -0.05958990f, 0.02935252f, -0.03249941f, 0.01661961f, 
    0.13481814f, -0.07660814f, -0.12059301f, -0.01057743f, -0.03739081f, 0.03744959f, 0.03238304f, -0.05962375f, 
    -0.02472555f, 0.01042198f, 0.03353570f, 0.00484851f, -0.13947593f, 0.24583329f, 0.04628260f, 0.16226535f, 
    0.01903358f, 0.04287011f, 0.06812859f, 0.06848845f, -0.04682309f, 0.06827819f, 0.03881299f, -0.05582980f, 
    -0.00391826f, 0.15903257f, -0.11989052f, -0.02865790f, 0.07500309f, 0.03049259f, 0.01754550f, 0.04016940f, 
    0.13075326f, 0.01026711f, 0.03490855f, 0.05434417f, -0.09610542f, -0.05956369f, -0.11260052f, 0.05464620f, 
    0.04538389f, -0.04388246f, -0.01127823f, -0.10465513f, -0.04425883f, 0.06783107f, -0.01705789f, 0.04579251f, 
    0.00645931f, 0.05827360f, 0.15911412f, 0.12837107f, 0.04854308f, -0.01758852f, -0.08595422f, 0.02176122f, 
    0.07220540f, 0.01548242f, -0.01937649f, 0.02590126f, 0.15652879f, 0.15842043f, 0.16749135f, 0.13806480f, 
    0.02015648f, 0.03312584f, 0.10478522f, 0.03405451f, -0.02472640f, -0.04511444f, 0.08640967f, 0.04017371f, 
    0.03718374f, 0.05955945f, 0.11674807f, -0.01261833f, 0.04891555f, 0.04541491f, 0.05992183f, -0.02616225f, 
    -0.04868273f, 0.01019156f, -0.01544210f, 0.04973087f, -0.10477044f, -0.15096433f, -0.05468173f, -0.05033122f, 
    0.07887001f, 0.04197410f, -0.01975976f, -0.07448203f, 0.02458459f, 0.01088511f, -0.07305969f, 0.00192010f, 
    -0.14045209f, 0.08844221f, -0.15633121f, 0.04188813f, -0.01694148f, -0.12985337f, -0.02616694f, 0.03678435f, 
    0.08654987f, 0.09722840f, 0.04843146f, 0.05012882f, 0.18033452f, 0.19476084f, 0.13418065f, -0.03748104f, 
    0.12470783f, 0.04485960f, 0.07159399f, 0.00650675f, -0.02327780f, 0.10610078f, 0.01255570f, -0.01902428f, 
    0.23638327f, 0.21684763f, 0.14850828f, -0.00177884f, 0.09890563f, 0.07494683f, 0.04746160f, -0.13666396f, 
    -0.04227310f, 0.00697103f, -0.02814643f, 0.07614934f, 0.14840810f, -0.12061814f, 0.19473419f, 0.06028410f, 
    0.07045321f, 0.03273525f, 0.00700044f, 0.07981557f, -0.00506473f, 0.06436779f, -0.07204109f, 0.02807632f, 
    -0.04643212f, -0.11694601f, -0.14880742f, 0.06603329f, 0.06847493f, 0.10125111f, -0.00185876f, 0.00949759f, 
    0.03644716f, -0.01151093f, 0.00323774f, 0.08287441f, 0.00218837f, 0.05386340f, 0.14064145f, -0.00826610f, 
    -0.00027012f, 0.10571307f, 0.02493447f, -0.00819112f, 0.03068875f, 0.04001768f, 0.01474426f, 0.00905889f, 
    -0.33743754f, 0.07259061f, 0.21310665f, 0.06807251f, 0.04064492f, 0.07603589f, 0.06106151f, 0.03710726f, 
    0.04214844f, -0.02152867f, 0.04282449f, 0.03204630f, -0.02595701f, -0.15056421f, -0.14586799f, 0.13357984f, 
    -0.09227905f, -0.00548290f, -0.00791555f, -0.03770401f, -0.05175342f, -0.04075942f, 0.07853252f, -0.09567967f, 
    -0.22990473f, -0.23993036f, -0.11928938f, -0.03328170f, 0.00199522f, -0.00133204f, -0.05727823f, 0.00727699f, 
    -0.05113235f, -0.04574585f, 0.04827570f, 0.04183400f, -0.11544278f, 0.20864183f, -0.00659447f, -0.01287691f, 
    0.04538014f, 0.02250920f, -0.00661626f, -0.02081840f, 0.09238038f, 0.19720662f, 0.04935035f, 0.11309101f, 
    -0.06726642f, 0.10352218f, 0.01138943f, 0.10837523f, 0.03824678f, -0.00382683f, 0.11515963f, 0.03256098f, 
    -0.05167495f, 0.02269222f, 0.07808684f, 0.07255646f, 0.02492487f, -0.13169537f, -0.07530839f, 0.06412171f, 
    -0.02548210f, -0.03098636f, -0.05937968f, 0.05254540f, 0.12200443f, 0.08322015f, -0.00790131f, -0.02779769f, 
    -0.21355911f, 0.01121364f, 0.04511702f, 0.04607666f, 0.06464291f, -0.08135498f, 0.00733996f, -0.02862975f, 
    -0.00412186f, -0.01378834f, 0.00045045f, -0.03178319f, 0.16859375f, -0.06267095f, 0.03696994f, -0.07381541f, 
    0.06711808f, -0.05108907f, -0.03806306f, 0.01744980f, 0.01262423f, -0.00534011f, 0.08468718f, 0.09045397f, 
    0.19894725f, -0.05156661f, 0.06260092f, -0.00103721f, 0.03031855f, -0.04675352f, 0.01669947f, -0.06832515f, 
    0.00822019f, 0.05915247f, -0.02061349f, 0.05430555f, -0.02079252f, 0.15739313f, 0.09411119f, -0.03747098f, 
    0.03256126f, -0.06485748f, 0.03944226f, -0.00167536f, -0.01835066f, -0.08392611f, -0.06562514f, -0.03042319f, 
    0.04696160f, 0.18500219f, 0.01905276f, 0.16653150f, 0.03016544f, -0.05075342f, 0.03253391f, 0.03624003f, 
    0.09003903f, -0.05746107f, 0.05780817f, 0.01531083f, -0.01372011f, -0.00080647f, 0.06759333f, 0.20196153f, 
    0.10994869f, 0.09563417f, 0.02754874f, 0.14082021f, 0.04847470f, -0.20365719f, -0.06404490f, -0.11288394f, 
    -0.04367540f, -0.11133498f, -0.00851447f, 0.06066683f, 0.03930094f, 0.01602544f, 0.01238209f, -0.03079799f, 
    0.12471475f, 0.07664300f, 0.01184013f, -0.00326629f, 0.08127642f, 0.06529124f, 0.09259228f, -0.03169161f, 
    0.05354505f, -0.07798317f, -0.03327649f, 0.01439456f, 0.06076944f, 0.04789798f, 0.05914296f, -0.00235023f, 
    0.10999765f, 0.15795085f, 0.07249329f, 0.06057956f, 0.06290060f, 0.01738365f, 0.03947830f, 0.03622805f, 
    0.04003675f, 0.01034172f, -0.01625187f, -0.01954626f, 0.03165030f, 0.18524052f, 0.04549380f, 0.09392422f, 
    -0.02531634f, -0.04067256f, 0.03804656f, 0.10987534f, 0.05143640f, -0.04719471f, 0.02189097f, -0.00166492f, 
    0.17327300f, 0.17568859f, 0.09160587f, -0.01753156f, 0.19375257f, -0.00797911f, 0.03166699f, 0.03777490f, 
    0.06706473f, 0.03806719f, 0.06701981f, 0.08199159f, 0.14369312f, 0.12685195f, 0.08879852f, 0.02635414f, 
    0.04637417f, -0.04699344f, 0.06442313f, 0.02827449f, -0.03536221f, 0.04969882f, 0.02259441f, -0.06697763f, 
    -0.14294277f, 0.11008869f, -0.10449622f, 0.00788030f, -0.06343452f, 0.04701284f, -0.08537336f, -0.06545135f, 
    -0.01663040f, 0.02113772f, 0.06450488f, 0.04938998f, 0.19688232f, 0.18386395f, 0.07860660f, 0.15281752f, 
    -0.03095161f, -0.06513474f, 0.02125156f, -0.02975242f, 0.06679945f, 0.13261190f, 0.08543719f, -0.02066152f, 
    -0.01264476f, 0.07050185f, -0.02705352f, 0.09377464f, -0.06188736f, -0.02986462f, 0.03722949f, 0.01149111f, 
    0.00804504f, 0.16701262f, 0.04346866f, 0.10225753f, 0.05157043f, 0.14572313f, -0.10256261f, -0.03800754f, 
    0.00669579f, 0.11675043f, 0.06456675f, 0.08917900f, 0.04617636f, 0.01731504f, 0.05490817f, -0.03157666f, 
    -0.04573097f, 0.15909012f, 0.10813652f, 0.10329967f, 0.01680973f, 0.00914126f, 0.10919923f, 0.09849908f, 
    0.01301917f, 0.09740929f, 0.01339429f, -0.02660380f, -0.20357603f, -0.08078977f, 0.18955460f, 0.09480520f, 
    0.13124749f, 0.05087093f, -0.00889387f, -0.09488211f, 0.09682801f, 0.07580975f, -0.07884417f, 0.06039598f, 
    -0.00247744f, 0.06673776f, 0.00322316f, 0.07629585f, -0.01230165f, 0.00779719f, -0.01788991f, 0.03493730f, 
    -0.01550275f, 0.05507588f, -0.01278862f, 0.06095570f, 0.00482245f, 0.00618641f, 0.08852838f, 0.11900238f, 
    -0.01181917f, -0.03852585f, 0.14818136f, 0.00554478f, 0.02776281f, 0.00370543f, -0.06661578f, 0.09437989f, 
    -0.18407999f, 0.10967421f, 0.16499150f, -0.12432798f, -0.02173438f, 0.05723480f, -0.00572552f, -0.01493210f, 
    0.04937930f, -0.00344925f, 0.04832916f, 0.02603903f, 0.32369378f, 0.13727918f, -0.05155427f, 0.07636181f, 
    0.07817530f, 0.04013222f, 0.06607115f, 0.00302517f, 0.05479810f, 0.01769550f, -0.01552890f, 0.11466608f, 
    -0.34941196f, 0.26988512f, -0.01083844f, -0.01148846f, 0.00154016f, -0.00594786f, -0.05033595f, 0.03939925f, 
    0.08745944f, -0.00079940f, 0.06760727f, 0.04978523f, 0.03558278f, 0.05708404f, 0.07308996f, 0.06430339f, 
    -0.06033933f, 0.01278864f, 0.03454958f, 0.05054916f, 0.08797652f, 0.00265011f, 0.06810272f, 0.01158783f, 
    -0.04946636f, -0.02495135f, 0.11512271f, 0.02158294f, -0.03067750f, 0.01766403f, -0.00000400f, 0.05058740f, 
    0.01929504f, 0.02424791f, 0.00231887f, 0.02182300f, -0.24180241f, -0.01111382f, 0.14324223f, 0.06979650f, 
    0.07783922f, 0.00791931f, -0.03613174f, 0.15571786f, 0.08694620f, 0.01043734f, -0.00695096f, -0.00249874f, 
    0.11153193f, 0.13993144f, 0.18054356f, 0.01063514f, 0.10197771f, 0.03681858f, 0.02909867f, -0.00882027f, 
    0.06627732f, 0.04134798f, -0.02441452f, 0.04619990f, 0.09848831f, 0.05405125f, 0.09362516f, 0.17000501f, 
    0.04629751f, 0.16878444f, -0.00461089f, 0.01010424f, -0.05503121f, 0.04489291f, 0.07873222f, 0.01085260f, 
    -0.23656690f, -0.02729434f, -0.07853347f, -0.03533645f, 0.05912101f, -0.02386078f, 0.00469229f, -0.00533010f, 
    0.10142373f, 0.02561262f, 0.01631936f, 0.09410457f, 0.11835719f, -0.10650061f, -0.00724656f, 0.13422100f, 
    -0.00204035f, 0.10789391f, 0.06534843f, 0.01870032f, 0.05251508f, 0.07771424f, -0.01510339f, -0.10843264f, 
    -0.20055182f, -0.18372822f, -0.03774539f, -0.06193841f, 0.08022287f, -0.03038855f, -0.00364744f, -0.07880817f, 
    0.05377424f, 0.02052686f, -0.01105290f, 0.10530090f, -0.25027671f, 0.28975183f, 0.06011197f, -0.12692362f, 
    0.13684671f, -0.06808105f, -0.10567600f, 0.06733017f, 0.06448235f, 0.00404934f, 0.02882482f, -0.07516230f, 
    -0.11057081f, 0.07257982f, -0.09998035f, 0.09786724f, 0.08613942f, -0.05311356f, -0.04004413f, 0.00154027f, 
    -0.11532881f, -0.10446507f, -0.09375759f, -0.02668094f, 0.12629895f, 0.00553605f, 0.05592084f, 0.04787897f, 
    0.08238182f, 0.05421852f, 0.05740552f, 0.01966894f, 0.09076017f, 0.03173410f, 0.03763051f, 0.04090957f, 
    0.25936237f, 0.06320066f, 0.16263680f, 0.06846952f, 0.04253494f, 0.08866406f, -0.00215582f, 0.04438696f, 
    -0.00025095f, 0.06365298f, -0.00307573f, 0.00956467f, 0.03141870f, 0.15414742f, 0.13030653f, 0.04907283f, 
    -0.03205729f, -0.00251043f, 0.04128328f, 0.03183351f, 0.04121452f, 0.01936804f, -0.01676094f, -0.00761495f, 
    -0.11708426f, -0.20149285f, 0.08420067f, -0.06567896f, 0.11247644f, 0.04927533f, 0.04378234f, -0.02425979f, 
    -0.00014219f, -0.03452334f, -0.02378573f, -0.00938598f, -0.10007227f, 0.02553800f, -0.03110429f, -0.11874092f, 
    0.07949308f, -0.07353244f, 0.04758831f, 0.03172116f, 0.08144497f, 0.00873028f, -0.01114898f, -0.02130222f, 
    0.05819638f, -0.03543606f, 0.17011350f, -0.03258546f, -0.07889755f, 0.01403075f, 0.01172903f, 0.01019573f, 
    0.02931732f, -0.06333157f, -0.00049020f, -0.02954704f, -0.07561135f, -0.00769114f, -0.09931871f, 0.12597924f, 
    -0.06552486f, 0.05257665f, -0.06138262f, 0.01285516f, 0.00345925f, 0.03339624f, -0.03398383f, 0.10676613f, 
    0.17620634f, 0.08605085f, -0.00982963f, 0.30014226f, -0.02680655f, -0.01182756f, 0.02364967f, -0.08863088f, 
    -0.07309276f, 0.00237784f, -0.01850773f, 0.03059074f, 0.23262046f, 0.05051354f, 0.13692774f, 0.25778931f, 
    -0.17774244f, 0.05188370f, 0.08000159f, 0.01432254f, -0.06263528f, -0.00845559f, 0.04190282f, -0.00118525f, 
    -0.00557967f, 0.12629634f, 0.04269417f, -0.04817226f, 0.00575545f, -0.05385195f, -0.03486983f, 0.05053969f, 
    0.06338254f, -0.17306612f, -0.07062319f, 0.04253770f, 0.13784650f, 0.13394432f, -0.04359055f, -0.26574165f, 
    0.01896565f, 0.08382185f, 0.01765599f, -0.03089663f, 0.04041354f, -0.00654458f, 0.01837063f, -0.02339532f, 
    0.38109174f, 0.13317542f, 0.07516868f, 0.21880598f, 0.05894745f, 0.04887052f, -0.06885923f, -0.03378169f, 
    0.01593946f, 0.10227706f, 0.00554872f, -0.05907642f, 0.11058453f, 0.13383690f, 0.16004089f, -0.32178748f, 
    -0.05636832f, 0.03941302f, -0.05514333f, -0.08495764f, 0.02097485f, 0.08606446f, -0.07268853f, 0.01201097f, 
    0.27821636f, -0.01466065f, 0.05811008f, -0.17746805f, -0.00625849f, 0.03535118f, 0.05418193f, -0.00454364f, 
    -0.07967816f, 0.00261855f, -0.00168396f, 0.18979713f, 0.05546195f, 0.09868839f, -0.00814756f, 0.12378616f, 
    -0.03837740f, -0.05149498f, -0.08692661f, -0.05610743f, 0.10198358f, -0.02771521f, 0.03536087f, 0.05448387f, 
    -0.05192250f, -0.15174192f, -0.37098774f, 0.32195377f, -0.03920080f, -0.01164784f, 0.03940134f, -0.05740762f, 
    -0.03506338f, -0.08217854f, -0.08710961f, -0.07394654f, 0.35954636f, 0.16827600f, 0.06864009f, -0.26360524f, 
    -0.00693827f, -0.07702764f, -0.03604479f, 0.04827275f, 0.14861155f, 0.01743299f, -0.02123740f, -0.01344146f, 
    -0.10911800f, -0.11874118f, -0.00751752f, -0.09431911f, 0.08243024f, 0.09358620f, 0.03684441f, -0.02606357f, 
    0.13764812f, -0.01463275f, -0.02844016f, 0.12060245f, -0.03683263f, 0.00344833f, -0.04268936f, 0.32757795f, 
    -0.03142856f, -0.03494348f, 0.06075898f, -0.02475484f, -0.00024353f, -0.04063927f, 0.03924867f, -0.10288396f, 
    0.04726737f, 0.08347455f, -0.07747054f, 0.22560203f, -0.10053686f, -0.05677155f, 0.10698546f, -0.05642691f, 
    0.00367667f, 0.03488342f, 0.07897153f, -0.01549650f, -0.29337528f, -0.02244993f, 0.02684491f, -0.13770273f, 
    -0.02128502f, -0.00329484f, 0.06007918f, 0.02718088f, -0.01776012f, -0.02146165f, -0.11917508f, -0.13158506f, 
    -0.38766092f, 0.22092161f, 0.07002885f, -0.11621810f, 0.03559554f, 0.10768615f, 0.09235948f, 0.01843181f, 
    0.07845814f, 0.04746326f, 0.01478394f, -0.01677803f, -0.19499983f, -0.03151917f, -0.15464818f, 0.11388309f, 
    -0.00190811f, 0.08191931f, -0.04741956f, 0.03605167f, -0.02331844f, -0.09748061f, -0.10746963f, 0.02124100f, 
    0.06071990f, -0.05434164f, 0.11581512f, -0.04768422f, -0.07019845f, -0.05332596f, -0.00433283f, 0.00660545f, 
    -0.10446685f, 0.02410494f, -0.01419927f, -0.11057951f, -0.15749088f, -0.12742840f, -0.03590490f, 0.07068656f, 
    0.01318431f, -0.04647621f, 0.07787199f, 0.12996347f, 0.11194720f, -0.11820593f, -0.06102324f, 0.02461495f, 
    -0.00079462f, -0.02207571f, -0.02683829f, -0.30714262f, 0.01004924f, 0.02076542f, 0.04728445f, -0.01442095f, 
    -0.01031335f, -0.03131660f, 0.02326002f, 0.01871341f, 0.44906071f, 0.04700476f, 0.00215457f, 0.41553408f, 
    -0.05655460f, 0.03291644f, -0.03399566f, 0.05397504f, 0.01570757f, -0.01871438f, 0.01779809f, -0.02675959f, 
    0.37096471f, -0.05100227f, 0.03346564f, 0.43315709f, -0.01907072f, -0.08816358f, -0.02971449f, 0.07856683f, 
    -0.01756783f, -0.01699252f, 0.06048733f, -0.01958029f, 0.39785889f, 0.13078928f, -0.01580131f, 0.12200779f, 
    -0.14886773f, 0.07508830f, 0.02896217f, -0.03031693f, 0.06673758f, 0.07361635f, -0.02429025f, -0.01258103f, 
    -0.12263230f, -0.25666931f, 0.31410530f, -0.28204298f, -0.04262630f, 0.05337791f, 0.04783471f, -0.08170218f, 
    -0.01383757f, 0.04413839f, 0.03961898f, 0.05219865f, 0.32486388f, 0.13977416f, 0.13133711f, 0.20226796f, 
    -0.09737036f, -0.04191926f, -0.03194700f, -0.02609561f, 0.01808694f, 0.03150472f, 0.02638299f, 0.05448769f, 
    -0.01726088f, 0.03105090f, -0.18899308f, -0.37615517f, -0.03819043f, -0.08114139f, 0.00701036f, -0.09190857f, 
    0.00796459f, -0.01105307f, -0.04653233f, 0.01780283f, -0.30746487f, 0.04217858f, -0.01613296f, -0.04101480f, 
    -0.02909256f, -0.04363490f, -0.00809472f, 0.02565151f, 0.02815841f, -0.03386379f, 0.17207929f, -0.01442264f, 
    -0.20329821f, -0.24931075f, -0.11182348f, 0.02161043f, -0.08428124f, -0.06554011f, 0.11488146f, -0.03111677f, 
    0.07001323f, 0.08480287f, -0.02671363f, 0.00246943f, -0.09498720f, 0.08529016f, -0.11511226f, 0.24697520f, 
    0.03543549f, -0.03490367f, 0.04186274f, -0.08259736f, -0.04279481f, 0.02273537f, -0.00532875f, -0.18802597f, 
    0.33683351f, 0.27468929f, 0.17542666f, -0.06000153f, 0.06870859f, 0.08533189f, -0.09036092f, 0.02988529f, 
    0.03802495f, -0.06016582f, 0.01194691f, 0.09469572f, -0.17358209f, -0.13769442f, 0.04807790f, -0.16186251f, 
    0.09050675f, 0.01777104f, 0.02845192f, 0.01905877f, 0.03459199f, 0.07407640f, -0.03675844f, -0.05975552f, 
    0.25186199f, -0.07025041f, -0.13008091f, 0.39433488f, -0.18831481f, -0.03624507f, 0.03860926f, 0.02613132f, 
    -0.08352133f, 0.09240835f, 0.00239763f, 0.08690464f, -0.09631100f, -0.02939879f, -0.10691010f, -0.16889751f, 
    -0.02898812f, 0.01688249f, 0.04381838f, 0.07271931f, 0.09748164f, 0.12174911f, 0.03074030f, 0.08652177f, 
    -0.24145250f, -0.16441478f, -0.00343415f, -0.01602414f, 0.00884903f, 0.09885646f, 0.03765001f, 0.07821804f, 
    -0.02224445f, -0.06580433f, -0.11069094f, -0.08739316f, 0.18551323f, 0.08324726f, 0.09627151f, -0.27693361f, 
    0.01988098f, -0.01569124f, 0.00586414f, 0.12904049f, -0.05158632f, -0.06882840f, 0.03745247f, 0.00704652f, 
    -0.02098315f, -0.19710700f, 0.13119966f, -0.23111257f, 0.09862783f, 0.08104465f, 0.09312341f, -0.04187215f, 
    -0.00819467f, 0.03048697f, -0.11311354f, 0.02689086f, 0.18186972f, 0.18487920f, -0.10840525f, -0.29190278f, 
    0.16677186f, -0.02472128f, -0.02553136f, 0.12300149f, 0.05390523f, -0.04874508f, -0.00559541f, -0.00228136f, 
    0.05115016f, -0.03087825f, 0.16514358f, -0.30687356f, -0.15918535f, 0.01735321f, 0.09020849f, -0.02213226f, 
    -0.05115312f, 0.03538202f, 0.04325129f, 0.02975525f, -0.12023138f, -0.25992274f, 0.08329345f, -0.09271146f, 
    -0.03389312f, 0.10285683f, 0.02670654f, 0.07679461f, 0.00987514f, -0.03587338f, -0.04916089f, 0.08357748f, 
    0.09941369f, -0.16999085f, -0.03478723f, 0.15763786f, -0.03558685f, 0.03691204f, -0.16466013f, 0.08511217f, 
    0.08218805f, -0.00235178f, 0.08499824f, -0.04860438f, 0.35225955f, 0.09699880f, 0.05097722f, 0.04410894f, 
    -0.09420279f, 0.02023902f, 0.12821409f, 0.00431700f, 0.03252590f, 0.02908564f, 0.06718472f, 0.07331896f, 
    -0.06936527f, 0.09550158f, -0.03109676f, -0.17754936f, 0.03692057f, 0.11207096f, 0.04533460f, 0.06791470f, 
    0.02736342f, -0.00590754f, -0.06742380f, 0.13477196f, -0.29333562f, 0.07842349f, -0.19222581f, -0.11095896f, 
    -0.00858345f, 0.01395739f, 0.05805954f, -0.03490084f, 0.03437078f, -0.04266050f, -0.06468696f, 0.03019273f, 
    0.26368475f, -0.24173476f, -0.10934173f, 0.23683882f, -0.01238080f, 0.10803556f, -0.00546270f, -0.11031006f, 
    0.05926631f, -0.03114156f, -0.10434316f, -0.09524380f, 0.11192287f, 0.20732324f, 0.04428042f, 0.11297225f, 
    0.15396458f, 0.13592200f, -0.19473833f, 0.03837323f, 0.04128225f, 0.04017994f, -0.01039038f, 0.00130552f, 
    0.05125587f, 0.03168591f, 0.00433698f, -0.01360312f, -0.05695816f, -0.06742921f, -0.06264831f, 0.03319182f, 
    0.01247720f, -0.03183516f, 0.10731970f, 0.06955077f, 0.44624034f, 0.12675887f, 0.04642272f, -0.03299320f, 
    0.04398158f, -0.00425008f, 0.06322823f, -0.17851910f, 0.04706262f, 0.04117520f, 0.00266648f, 0.01783922f, 
    0.06366379f, 0.01686288f, 0.08937982f, -0.19169803f, -0.25038704f, -0.00042639f, -0.00511197f, 0.00299295f, 
    -0.03219093f, 0.03560157f, 0.01507572f, 0.03252440f, 0.09753256f, 0.14825900f, 0.08227971f, 0.15413962f, 
    -0.00689037f, 0.08003800f, 0.04659782f, -0.06911176f, 0.07875686f, 0.11542189f, 0.04759468f, -0.07083407f, 
    -0.22278984f, -0.13864960f, -0.00666967f, -0.03124555f, -0.07447977f, 0.00234106f, -0.00842663f, -0.09687680f, 
    0.00387192f, 0.08080395f, 0.01043173f, 0.00186379f, -0.28011641f, 0.01201276f, 0.00876772f, 0.22442925f, 
    -0.03033463f, 0.14200789f, 0.09947693f, 0.05429775f, 0.01239059f, 0.03461643f, -0.07912273f, -0.04140675f, 
    -0.34784210f, 0.09582341f, 0.02793691f, -0.34691119f, 0.06190001f, 0.05555240f, 0.08389020f, 0.02022102f, 
    0.01093259f, 0.03058732f, -0.06088641f, -0.00235959f, -0.10457159f, -0.14447057f, -0.00121730f, -0.29094771f, 
    -0.00072849f, -0.01918070f, 0.14002341f, -0.05113843f, 0.06439476f, -0.05413032f, 0.03774364f, 0.04826410f, 
    0.35750365f, -0.04077129f, 0.17522463f, 0.29652712f, -0.05660390f, -0.02216578f, -0.00199994f, 0.03505129f, 
    -0.08014773f, -0.01749818f, -0.01933659f, 0.02835483f, -0.11397006f, -0.04240940f, 0.07680208f, -0.10792049f, 
    0.02227394f, -0.08743138f, 0.11679568f, -0.03910413f, 0.11134585f, -0.06707975f, -0.01835577f, 0.00914484f, 
    0.36654615f, 0.00593560f, 0.05807373f, 0.17669782f, -0.11173848f, -0.08318287f, 0.05269442f, 0.06774019f, 
    -0.07937415f, 0.08452210f, 0.01406368f, 0.04367545f, -0.19163743f, 0.06136760f, 0.11835456f, -0.10384628f, 
    -0.05402502f, -0.02001607f, 0.06105641f, -0.08177660f, 0.02122688f, 0.00977978f, 0.00149029f, 0.05311019f, 
    0.26044935f, 0.01896040f, 0.22014676f, 0.43053451f, -0.07574929f, 0.15544741f, -0.07011397f, 0.00567452f, 
    -0.04339488f, 0.11084116f, 0.01037654f, 0.00168308f, -0.18151020f, -0.07930512f, -0.12327231f, 0.08470211f, 
    0.00531708f, 0.13782257f, 0.16274369f, -0.10533569f, 0.00105739f, 0.09173962f, -0.02078143f, -0.00285600f, 
    -0.36115354f, -0.36344117f, -0.20300896f, 0.09164854f, -0.16944410f, 0.02392230f, -0.03226007f, -0.00654244f, 
    -0.03125417f, 0.06091280f, -0.06804491f, 0.05272216f, 0.16461328f, 0.05036364f, 0.04854517f, -0.06041837f, 
    -0.03793206f, -0.04449055f, 0.03074820f, 0.13117233f, -0.06936018f, -0.01405900f, 0.03857227f, -0.01200758f, 
    -0.01919949f, 0.31735349f, -0.18353534f, 0.01342293f, 0.03435771f, -0.08906091f, 0.06839418f, -0.09295584f, 
    0.02907037f, -0.12331606f, 0.03839525f, -0.03150072f, -0.23242436f, 0.04262582f, -0.01582787f, -0.04372007f, 
    -0.02095067f, 0.07586953f, 0.04299050f, -0.11977045f, -0.00286377f, 0.02227858f, 0.06343348f, -0.02612937f, 
    0.23678714f, 0.16039623f, 0.06635734f, 0.04356749f, -0.00216475f, -0.00606926f, 0.01840100f, -0.04548835f, 
    0.01761982f, -0.03489347f, 0.01285529f, 0.06490067f, -0.03260139f, 0.29047209f, 0.15224889f, -0.19808766f, 
    0.05748619f, 0.00310609f, 0.02720891f, -0.02452158f, 0.01418777f, -0.04183158f, 0.07601903f, -0.10342085f, 
    0.22836711f, 0.08981179f, 0.02411351f, -0.00152370f, 0.06138337f, 0.06537557f, 0.01544486f, -0.05131805f, 
    0.05592548f, 0.09904501f, 0.11708726f, -0.06051489f, 0.26145872f, 0.18271659f, -0.00565670f, 0.14612013f, 
    0.03044102f, 0.11239742f, 0.06718840f, 0.01122746f, 0.16552179f, 0.17124984f, -0.05490920f, 0.04154042f, 
    -0.40057603f, 0.02817853f, 0.04392593f, 0.00113552f, 0.04909136f, 0.04561207f, -0.04420608f, 0.06775477f, 
    0.04170386f, -0.02599053f, 0.10524383f, 0.03540380f, 0.22554190f, 0.00226213f, -0.03804531f, 0.20957746f, 
    -0.02352283f, 0.02840513f, 0.00753881f, -0.00746446f, -0.11079896f, -0.08143034f, 0.01657867f, -0.02675859f, 
    0.03648847f, 0.18412685f, 0.06697825f, 0.07494070f, 0.12207944f, 0.06686968f, 0.10416058f, 0.02669630f, 
    -0.00051151f, 0.04998076f, -0.02886999f, 0.05991465f, -0.33656982f, 0.21054143f, 0.00865036f, -0.06068764f, 
    0.08101576f, 0.01803854f, -0.02813940f, 0.03408368f, -0.07513794f, -0.04490527f, 0.07510450f, 0.05870679f, 
    0.17872669f, 0.13023277f, -0.14093040f, 0.12426327f, -0.02289195f, -0.00277586f, 0.06727846f, -0.09811192f, 
    0.04127089f, 0.04146236f, 0.02173586f, 0.05866221f, 0.10700879f, 0.05362249f, -0.13232113f, -0.03658371f, 
    0.00060625f, -0.07792046f, 0.14451230f, -0.00165559f, 0.00528083f, 0.06522465f, 0.08888464f, 0.03292669f, 
    0.35042229f, -0.06595141f, 0.12034968f, -0.17996982f, 0.01636012f, 0.00495154f, -0.02376866f, -0.01879863f, 
    0.24219748f, 0.08522312f, -0.02167861f, -0.00393070f, 0.29149240f, -0.17730278f, 0.06414144f, -0.00546619f, 
    0.05008623f, 0.15461421f, -0.00876919f, -0.02699014f, -0.02428242f, -0.00054858f, 0.04552079f, 0.09179884f, 
    -0.25891474f, 0.07181978f, 0.01524323f, -0.20872493f, 0.01388928f, 0.04967094f, 0.04459411f, 0.06016580f, 
    -0.19699775f, -0.00541193f, 0.04668728f, -0.22127227f, 0.20751686f, 0.02074319f, -0.00818028f, -0.09400388f, 
    0.00647732f, 0.01971323f, -0.08162960f, 0.07179667f, -0.08340283f, 0.04499628f, 0.01383378f, -0.01836886f, 
    0.38885617f, 0.01497988f, -0.02893549f, -0.14043219f, 0.07000704f, 0.04146433f, 0.05563600f, -0.03229043f, 
    -0.00948795f, 0.10904559f, -0.08772476f, -0.04374024f, -0.24292830f, -0.20764899f, 0.01433648f, 0.01861229f, 
    -0.02669787f, 0.03878230f, -0.04409453f, -0.12046652f, -0.08464497f, -0.00159726f, -0.02713700f, 0.04064315f, 
    -0.01186058f, -0.10155842f, 0.04776322f, -0.06601153f, -0.05897954f, -0.06422164f, 0.00827219f, -0.05562970f, 
    -0.03590240f, -0.15901448f, 0.05339422f, 0.09752596f, -0.09615090f, -0.04108766f, -0.03508131f, -0.04871817f, 
    0.05426197f, -0.03715860f, -0.09346966f, -0.07884514f, 0.02310680f, 0.00920245f, 0.03227106f, -0.07617033f, 
    0.07659007f, 0.18228504f, 0.06365361f, -0.01038710f, 0.01226511f, -0.10180914f, 0.08505315f, 0.07382146f, 
    0.07571629f, 0.00597366f, 0.00136624f, -0.03337698f, -0.21511212f, -0.13699713f, -0.03500099f, 0.13375102f, 
    -0.15847427f, 0.06649211f, -0.02998029f, -0.07122421f, 0.02858302f, 0.04975474f, 0.00331266f, 0.04583151f, 
    -0.11258338f, 0.10584871f, 0.03603613f, 0.14462444f, 0.06113815f, 0.03356707f, -0.03830385f, -0.09446961f, 
    0.02464745f, -0.13640398f, 0.11781709f, 0.06141562f, 0.32388458f, 0.36559960f, -0.00863745f, -0.06181329f, 
    0.10113462f, -0.07159252f, 0.04141440f, 0.01244307f, -0.04525848f, -0.06212340f, 0.14579523f, 0.14587346f, 
    0.12593724f, 0.37212345f, 0.11043168f, -0.13926214f, 0.11569046f, 0.03935325f, -0.00511508f, -0.03667513f, 
    -0.03838294f, 0.02153609f, 0.02804514f, 0.12400565f, 0.15760921f, 0.08953960f, 0.10633711f, -0.06684034f, 
    0.05307158f, 0.01211467f, -0.12672985f, -0.00043404f, -0.05106641f, -0.01121353f, -0.02424082f, -0.05993943f, 
    -0.16529188f, -0.14035551f, 0.02770530f, 0.00516318f, 0.02608848f, 0.07450067f, 0.11483333f, 0.01385046f, 
    0.06607876f, 0.08353650f, 0.01445540f, 0.02670513f, 0.07323710f, 0.16552404f, 0.04330725f, -0.13349338f, 
    0.09291611f, -0.06032177f, 0.05034519f, -0.04719327f, -0.05358427f, -0.17070933f, 0.08555701f, -0.16971645f, 
    0.25097874f, 0.15217344f, 0.11661964f, -0.05823055f, 0.04046148f, 0.00295324f, -0.00420041f, 0.05234867f, 
    -0.02056989f, 0.00649518f, 0.02784220f, -0.04632840f, 0.32968238f, 0.12802789f, -0.03079482f, 0.05454404f, 
    -0.06964639f, 0.08345372f, -0.01023539f, -0.02115298f, 0.00548136f, -0.05062053f, 0.01255332f, 0.03664068f, 
    0.05148156f, -0.11508238f, -0.17677937f, -0.05291807f, -0.01607125f, 0.02948958f, 0.06844472f, -0.00347114f, 
    -0.02487429f, -0.00664669f, 0.02607931f, 0.01125729f, 0.13797969f, 0.05297163f, 0.07158865f, -0.20023352f, 
    -0.03371346f, 0.01668363f, 0.07024039f, 0.05683340f, 0.17174634f, 0.05031652f, 0.05044896f, 0.07969585f, 
    -0.09099948f, -0.14972880f, -0.02402333f, 0.18061820f, 0.03087345f, 0.07854968f, 0.04879370f, -0.05368961f, 
    0.00698373f, 0.10848068f, 0.00068752f, 0.08135708f, -0.19486137f, -0.21104787f, -0.16889332f, -0.11988060f, 
    0.02956165f, 0.07222378f, -0.06142307f, -0.00896185f, 0.02361391f, 0.14890279f, 0.02519803f, 0.02194398f, 
    0.15720578f, 0.17563744f, -0.04209219f, -0.00899542f, 0.00958727f, -0.06872497f, -0.03183233f, 0.09045684f, 
    -0.11075931f, 0.00966771f, -0.10479560f, -0.07109113f, -0.14474298f, -0.00982911f, 0.03658156f, 0.10008310f, 
    -0.10547704f, -0.08896156f, 0.00279314f, -0.15986215f, 0.04412417f, -0.05183031f, 0.02844642f, 0.01634498f, 
    -0.28016147f, -0.05721404f, -0.00978015f, -0.12854926f, 0.06353843f, -0.07236083f, -0.05032414f, -0.11562907f, 
    -0.11017910f, 0.05619411f, 0.00402126f, -0.00970074f, -0.12519978f, -0.01221019f, 0.02388374f, -0.08072583f, 
    0.08489100f, 0.05701604f, -0.00180689f, 0.02990432f, 0.08871762f, 0.05188699f, -0.00510769f, 0.00936746f, 
    0.02684934f, -0.34641984f, 0.17835654f, 0.05224548f, -0.05338068f, 0.05128507f, 0.08955718f, -0.04266497f, 
    -0.00511321f, 0.08995945f, 0.03370484f, 0.12045892f, -0.00683520f, 0.02467592f, -0.09989619f, 0.09927668f, 
    0.05270846f, 0.02300612f, -0.09773470f, -0.00052613f, -0.11261409f, -0.05892862f, -0.03406588f, 0.06406703f, 
    -0.16834097f, 0.27307266f, -0.03613435f, 0.02783710f, -0.03180835f, 0.05260808f, -0.08593669f, -0.03294962f, 
    0.09628051f, -0.12969975f, -0.00313828f, 0.06636461f, -0.06346387f, -0.02598788f, -0.12908605f, -0.16265897f, 
    -0.01578454f, -0.04384063f, 0.00728436f, 0.05308636f, -0.05905930f, -0.03995908f, -0.01786030f, -0.06462298f, 
    0.03457388f, 0.24616602f, 0.05056856f, -0.15326054f, -0.01235148f, 0.01605754f, 0.03423667f, -0.00300572f, 
    -0.01448550f, 0.15789545f, -0.00821836f, 0.09817941f, 0.15629584f, 0.07488032f, -0.00976435f, 0.13008079f, 
    0.01391638f, -0.02914015f, -0.00231356f, 0.06775525f, -0.01096340f, -0.03600173f, -0.00477316f, 0.01718630f, 
    -0.30926532f, 0.06265678f, -0.00854121f, -0.06579285f, -0.00790097f, 0.06844886f, -0.00689739f, -0.00842843f, 
    -0.06363788f, 0.06677169f, -0.04397769f, 0.07986397f, 0.16034852f, 0.13985060f, 0.02252338f, -0.02622822f, 
    0.02533844f, -0.02890038f, -0.03816329f, 0.05311143f, 0.03996948f, 0.05410692f, 0.08644946f, -0.02140092f, 
    0.09814651f, 0.11387169f, -0.02060151f, -0.12061937f, 0.08864693f, -0.09200177f, 0.04393936f, 0.00097405f, 
    -0.01115464f, 0.09869500f, 0.16363887f, 0.02086433f, -0.15424700f, -0.10408387f, 0.11622286f, -0.09779521f, 
    -0.02366562f, 0.16766608f, 0.06456466f, 0.08272648f, 0.15697084f, 0.05288437f, -0.14032459f, 0.02559863f, 
    -0.20451419f, 0.27874434f, -0.15434259f, -0.03351915f, 0.07725869f, -0.15640230f, 0.03720375f, 0.04177400f, 
    0.02778033f, -0.02468353f, -0.11086329f, 0.01380205f, 0.85626453f, -0.10897383f, 0.10114814f, 0.14685926f, 
    -0.03067381f, 0.10093989f, 0.06745692f, 0.05165331f, -0.06399371f, 0.03343606f, -0.12479666f, 0.01681421f, 
    -0.05223208f, 0.03902402f, 0.11833298f, 0.08747477f, 0.05572996f, 0.00563997f, 0.01111268f, -0.01466977f, 
    -0.02293743f, 0.01301130f, 0.07122036f, 0.14851509f, -0.00901208f, -0.15456429f, 0.20514482f, -0.05717874f, 
    -0.07304639f, 0.09063438f, 0.02587998f, -0.07475138f, 0.03486311f, -0.16007474f, -0.00733366f, 0.00111380f, 
    0.41905740f, -0.34944537f, -0.15914935f, 0.23643422f, 0.07483894f, -0.00654175f, -0.00908995f, -0.03567640f, 
    -0.04971785f, -0.07434706f, 0.01930298f, 0.09412188f, -0.22076252f, -0.07609907f, 0.02921229f, -0.16354580f, 
    0.01232885f, 0.02786024f, 0.03660928f, 0.02753414f, 0.07086334f, -0.02968310f, 0.00920565f, 0.05095001f, 
    0.06815609f, -0.23002461f, 0.00142859f, 0.19130009f, 0.03501758f, 0.04435860f, -0.01719630f, 0.01626383f, 
    0.01742798f, -0.11845252f, -0.00766807f, 0.11833817f, -0.15508924f, 0.18837892f, -0.13985419f, -0.04406272f, 
    -0.05716391f, -0.00998330f, -0.04158951f, 0.05750847f, -0.03197997f, -0.10602054f, -0.04291112f, -0.00780235f, 
    0.26716068f, 0.12304909f, 0.06584497f, 0.06170156f, 0.09974191f, 0.03197516f, 0.04324055f, 0.02000976f, 
    -0.03755531f, 0.06261044f, -0.01893889f, -0.05513930f, -0.25291312f, 0.02620668f, -0.01776738f, -0.07889660f, 
    0.08483134f, -0.03188976f, -0.05435832f, 0.07645478f, 0.03755207f, -0.18640594f, -0.05401967f, -0.11985089f, 
    0.35411811f, 0.14463730f, -0.03057072f, 0.02296836f, 0.02150018f, 0.03155660f, 0.00123556f, -0.02279076f, 
    -0.17632580f, -0.10715233f, 0.06240422f, 0.04735916f, -0.22759473f, -0.14645319f, 0.21569467f, 0.28072280f, 
    -0.10287450f, -0.02350135f, 0.01090490f, 0.03027124f, 0.00828480f, 0.01806032f, 0.07694427f, 0.06001664f, 
    -0.05361469f, 0.04078695f, 0.19157252f, -0.03579800f, -0.02684857f, -0.01110295f, 0.04526510f, 0.01568826f, 
    0.00670011f, 0.03138519f, 0.03771788f, 0.02286512f, -0.12549412f, 0.17805308f, -0.07923990f, -0.10888808f, 
    0.10477472f, 0.07334860f, -0.02105818f, 0.01204648f, 0.05638095f, 0.04582316f, 0.03941204f, -0.08473597f, 
    -0.21458487f, -0.22538570f, -0.15727685f, -0.09592632f, -0.06839849f, 0.06047169f, 0.06574703f, -0.12114591f, 
    0.05060015f, 0.02296308f, -0.02041030f, -0.01756803f, -0.01712823f, -0.10418937f, 0.13986881f, -0.09469000f, 
    0.05640171f, 0.11855625f, -0.00052987f, -0.09160601f, 0.04840279f, 0.08776364f, -0.03566047f, -0.02707978f, 
    0.47623196f, -0.09601499f, -0.08780681f, 0.12831542f, 0.05662544f, 0.05435288f, -0.02313095f, 0.07141700f, 
    0.06850875f, 0.01270183f, 0.11431982f, 0.14954571f, -0.14875995f, -0.18406142f, 0.12756920f, -0.03121077f, 
    0.02143365f, -0.03385945f, 0.05493609f, -0.05596536f, 0.01283084f, 0.07687858f, 0.01659717f, 0.03025647f, 
    0.03891480f, -0.11841574f, -0.01626055f, -0.04142540f, 0.06479333f, 0.04591141f, 0.03287159f, 0.10426281f, 
    0.10552339f, -0.01444457f, -0.03080264f, -0.09505109f, 0.08384424f, -0.04461863f, -0.08526323f, 0.15040642f, 
    0.03223727f, 0.01720683f, -0.03644240f, 0.06288629f, -0.03592303f, 0.06338064f, -0.07952829f, 0.03399436f, 
    0.02949457f, 0.01794646f, -0.00477858f, 0.28557676f, -0.03422832f, 0.03711105f, 0.05964671f, 0.07426462f, 
    -0.02135726f, -0.02623834f, -0.04158930f, 0.03951674f, 0.17924796f, -0.09008163f, 0.05113859f, 0.02933524f, 
    -0.17326556f, -0.08054747f, -0.02490708f, 0.09051105f, -0.01122000f, -0.04488889f, 0.03287591f, -0.05031242f, 
    -0.02586325f, 0.01569562f, -0.05655550f, 0.05021061f, -0.04154460f, -0.01218100f, 0.03913177f, 0.12670586f, 
    0.02532834f, -0.05623610f, 0.02068556f, 0.04830489f, 0.00369049f, -0.07219435f, 0.01154678f, -0.27636537f, 
    -0.07139712f, 0.08708785f, 0.12106506f, 0.11284728f, -0.01147937f, -0.06776326f, 0.01387119f, 0.02370669f, 
    -0.08570958f, -0.02481135f, 0.08287313f, 0.19946957f, 0.08220958f, -0.00259372f, -0.07970832f, 0.09730234f, 
    -0.04955962f, 0.17660250f, 0.11296600f, 0.02629263f, -0.10499279f, 0.00864343f, -0.07091630f, 0.05800320f, 
    0.07187558f, 0.02272832f, -0.06367910f, 0.02864710f, 0.06111315f, 0.02959680f, 0.04506653f, 0.08118284f, 
    -0.07020577f, -0.15162145f, 0.18911980f, 0.01056837f, 0.07795787f, 0.14191748f, 0.07579663f, 0.07080290f, 
    -0.03175302f, 0.04798823f, 0.01614858f, 0.05771239f, -0.36089808f, 0.05452656f, 0.04942755f, 0.12332023f, 
    0.04824176f, -0.01420183f, -0.11626958f, 0.01821125f, 0.01046471f, 0.02187139f, -0.02067908f, 0.05292789f, 
    -0.28615594f, 0.04059580f, -0.26848626f, 0.19487470f, 0.04067400f, 0.08766755f, 0.13257819f, 0.00075954f, 
    -0.10761037f, -0.04369270f, -0.08256581f, -0.01341110f, -0.04950355f, -0.12371162f, 0.11875962f, -0.09746689f, 
    -0.03994640f, -0.05830106f, 0.00725471f, 0.03686564f, 0.04480110f, 0.12696204f, 0.03328703f, 0.04064701f, 
    -0.03079604f, -0.15930855f, -0.07557133f, 0.13358064f, -0.00003300f, 0.02719802f, 0.01581146f, 0.02118361f, 
    0.19954516f, -0.10608038f, -0.02106207f, 0.17082456f, -0.13712069f, 0.10773633f, 0.20269597f, 0.24971285f, 
    0.01163928f, 0.06847832f, 0.12336160f, 0.05988762f, 0.05596187f, 0.02898481f, 0.05752205f, 0.09949850f, 
    -0.22505531f, 0.25048673f, -0.08929899f, 0.14295717f, -0.02036907f, 0.09064758f, 0.02316715f, -0.00462289f, 
    -0.01325249f, -0.09008584f, -0.05080883f, 0.05504560f, 0.11413951f, -0.04479584f, -0.04827774f, -0.15742780f, 
    -0.04952840f, -0.00957735f, 0.07455591f, 0.08361389f, 0.07433768f, 0.01155622f, 0.00431152f, -0.02238037f, 
    0.02036367f, 0.09029832f, 0.12382102f, -0.23809168f, 0.00006322f, 0.14275074f, -0.02280726f, 0.04414574f, 
    0.02664374f, 0.06968659f, 0.06083956f, -0.01150396f, -0.32508600f, 0.18529978f, -0.06517882f, 0.19528513f, 
    0.04008912f, 0.02484385f, 0.09755791f, 0.03889166f, 0.02055677f, -0.06691974f, -0.02623237f, 0.02301438f, 
    0.08314314f, -0.18178196f, 0.10284276f, 0.11594637f, -0.15677691f, 0.14183035f, 0.01081343f, -0.03979333f, 
    0.07653264f, -0.01750685f, -0.00456720f, -0.01492721f, -0.09587280f, 0.03666350f, -0.08561959f, -0.06160980f, 
    0.03684629f, -0.01957570f, -0.03552455f, 0.17206663f, -0.01092616f, -0.05462138f, -0.01671022f, -0.02285365f, 
    0.28017789f, -0.14237231f, 0.14233443f, -0.19312730f, -0.12115983f, 0.00907037f, 0.10555582f, 0.18069082f, 
    -0.06979199f, 0.07539295f, 0.03032203f, -0.07600767f, 0.16092065f, -0.05314576f, 0.13251795f, 0.24071549f, 
    -0.11569387f, -0.02262165f, 0.02268680f, 0.09344978f, 0.08929634f, 0.15163960f, -0.01858356f, 0.04946638f, 
    0.44578299f, -0.14585158f, 0.00099655f, 0.40224442f, -0.21250148f, -0.02344728f, 0.02551291f, 0.09116508f, 
    0.06480651f, 0.00247189f, -0.02609275f, -0.04167637f, 0.05571319f, 0.09179097f, -0.11688597f, -0.05354126f, 
    0.02623573f, -0.00861028f, 0.01800575f, 0.00553376f, 0.06475055f, -0.02959269f, -0.00551162f, 0.03384766f, 
    0.06379062f, -0.06616647f, 0.15709482f, -0.03059122f, -0.03471308f, -0.02746053f, -0.00882344f, 0.02419331f, 
    -0.02897854f, -0.07589729f, -0.00094688f, 0.01488598f, 0.43591034f, 0.02297073f, 0.12800084f, 0.39460021f, 
    -0.11749335f, 0.01328999f, -0.02646683f, 0.04950808f, 0.02041613f, 0.09106345f, -0.06220022f, 0.01150678f, 
    0.10027115f, -0.12851588f, 0.01811183f, -0.11560142f, -0.11443848f, 0.08558607f, 0.06291223f, 0.00956990f, 
    0.05571636f, 0.03730336f, -0.02960229f, 0.02680601f, -0.19464761f, -0.14046560f, -0.04727494f, -0.02937144f, 
    -0.02224729f, -0.06700360f, 0.05095939f, -0.05117410f, 0.07160727f, 0.05677678f, 0.00678973f, -0.00361264f, 
    -0.35320058f, -0.10325780f, 0.13675439f, 0.13387714f, 0.07437601f, -0.01825923f, 0.09612433f, 0.00327680f, 
    0.08681282f, 0.12336078f, 0.00555694f, 0.00392441f, -0.08323412f, 0.07875926f, 0.06413922f, 0.23701884f, 
    -0.01631359f, 0.08487497f, 0.07564177f, 0.07911656f, -0.02670622f, 0.04672351f, 0.10489056f, 0.08795699f, 
    0.12669082f, 0.08702297f, 0.01927069f, -0.11562966f, 0.08890922f, -0.00041399f, 0.01462987f, 0.14934389f, 
    -0.00753884f, 0.02032172f, 0.04821232f, 0.06575419f, 0.00770930f, -0.09885749f, 0.01566878f, 0.04648063f, 
    -0.03426870f, -0.01141077f, 0.04502213f, 0.09705888f, 0.03078776f, -0.00861662f, 0.18914323f, 0.10029718f, 
    -0.07854249f, -0.01666040f, 0.12281616f, 0.28099865f, 0.04128057f, 0.06147154f, 0.03121752f, -0.00344574f, 
    0.00332973f, -0.03096423f, 0.07869431f, 0.01654336f, 0.22694249f, 0.10185692f, -0.02055482f, -0.14918120f, 
    0.04148939f, 0.13114086f, 0.07632543f, 0.11499473f, 0.12895001f, -0.04924954f, -0.03739974f, -0.00144588f, 
    -0.01400843f, 0.05616040f, -0.12697443f, 0.01074742f, 0.02799644f, 0.03382498f, 0.08829290f, 0.10864317f, 
    0.03864624f, -0.08372006f, 0.08825851f, -0.06286696f, -0.20270392f, -0.13671128f, 0.18399005f, -0.00440275f, 
    0.12529556f, 0.00548409f, 0.00923742f, 0.09222952f, -0.03945241f, -0.02832896f, -0.00685903f, 0.12695406f, 
    -0.00129904f, 0.09686503f, -0.11517239f, -0.28420249f, 0.05840322f, -0.01311333f, -0.08001796f, 0.01748999f, 
    0.06188965f, -0.03568549f, -0.03077419f, 0.04941250f, -0.12346016f, -0.13206981f, 0.06192090f, -0.14327413f, 
    0.06006759f, -0.06464677f, 0.04697541f, 0.13507898f, 0.04776449f, 0.03931887f, 0.02715001f, 0.06507803f, 
    0.21705170f, -0.13591167f, 0.12523039f, -0.04668798f, -0.05218190f, 0.02458637f, 0.09494621f, 0.07846717f, 
    -0.09564545f, 0.07142310f, 0.01931627f, -0.06961071f, -0.12017681f, -0.14203796f, 0.27768326f, 0.26995707f, 
    0.01358514f, 0.10159238f, 0.02278220f, 0.04189447f, 0.15727150f, -0.09054819f, -0.16625313f, 0.04627279f, 
    0.18912263f, -0.04606535f, -0.00258283f, 0.20145833f, 0.07661042f, 0.13579988f, -0.04803273f, 0.10249299f, 
    0.03748575f, 0.01022943f, 0.02719924f, -0.00314787f, -0.21870701f, -0.00955408f, 0.11969550f, 0.02350515f, 
    0.13886984f, 0.04976400f, -0.01271362f, -0.10770018f, 0.00522167f, 0.03928174f, -0.00874562f, -0.01447685f, 
    -0.04951810f, -0.06352352f, -0.08145615f, 0.05934206f, 0.03869294f, 0.02203035f, 0.00146149f, 0.12353843f, 
    0.01243058f, 0.00212167f, 0.09877413f, -0.05113530f, 0.05543954f, 0.05751567f, 0.09085608f, -0.03667009f, 
    -0.19184802f, 0.01918031f, 0.07382531f, -0.06117440f, 0.11301078f, 0.03055855f, -0.02240282f, 0.06951006f, 
    -0.25343972f, -0.02489415f, -0.04364197f, 0.19594857f, 0.02134134f, -0.04240605f, -0.09549995f, -0.06472196f, 
    -0.05053371f, 0.03651533f, -0.04486877f, -0.00627631f, 0.05648006f, 0.04464067f, -0.11217591f, 0.19798365f, 
    0.10908481f, -0.02785600f, -0.00024667f, 0.04105915f, 0.12217130f, 0.09862967f, 0.16485685f, 0.05213132f, 
    -0.12552157f, -0.14479887f, 0.04048912f, 0.10691465f, 0.05509436f, 0.07742985f, 0.05078524f, -0.02228531f, 
    0.05893226f, -0.06693462f, 0.07109128f, 0.06507187f, -0.11385050f, 0.01191555f, 0.07383931f, -0.11024543f, 
    0.07912108f, -0.00382349f, 0.07798695f, -0.04109146f, 0.07348707f, 0.01060014f, 0.07323653f, 0.03459864f, 
    0.34083012f, 0.06681762f, 0.05096472f, -0.24773346f, -0.05147913f, 0.11427960f, -0.00065236f, -0.00376208f, 
    -0.02834845f, 0.02149999f, 0.05810017f, -0.05973925f, -0.04295936f, 0.01811502f, -0.17432272f, 0.12241415f, 
    0.12191825f, 0.05798640f, 0.04291537f, 0.09694173f, 0.05760159f, 0.03113476f, -0.04329433f, 0.00528718f, 
    -0.68488556f, 0.26018322f, 0.08430018f, -0.09467565f, -0.04436839f, 0.00104343f, 0.06158920f, 0.06849515f, 
    0.03354524f, -0.06333840f, 0.01996384f, -0.12396696f, 0.00719132f, 0.24274181f, -0.08132704f, 0.17343429f, 
    0.06656404f, 0.01542014f, 0.08168442f, 0.00445864f, 0.04616697f, 0.02919226f, -0.00964991f, 0.04926015f, 
    -0.15118134f, 0.13751134f, -0.06916909f, -0.35099950f, 0.03870207f, 0.08417048f, 0.11071754f, 0.00013642f, 
    0.03095632f, -0.00422592f, 0.06824435f, -0.10071096f, 0.06172047f, -0.19756699f, 0.06552967f, -0.14373946f, 
    -0.05174074f, -0.00642387f, 0.14110796f, -0.02615611f, 0.02232339f, 0.01176860f, 0.03904698f, 0.14266929f, 
    0.22365746f, 0.11442769f, 0.09566505f, 0.15111773f, -0.09950477f, -0.04026312f, 0.00876848f, 0.07401600f, 
    0.00748519f, -0.05022121f, 0.06789988f, -0.02607585f, 0.13094108f, -0.04685915f, -0.03855674f, -0.06381539f, 
    0.01787812f, 0.03327965f, 0.21183990f, -0.04365078f, 0.11267304f, 0.00137056f, -0.02187123f, 0.10888916f, 
    0.10356550f, 0.05497671f, 0.13869043f, -0.00614649f, -0.00984283f, -0.03674547f, -0.03408323f, 0.11070551f, 
    -0.02252761f, 0.09272809f, 0.09445888f, 0.06901039f, 0.27479407f, 0.22791152f, -0.14981110f, -0.35863808f, 
    -0.05444812f, 0.14593786f, 0.04349949f, -0.00420635f, 0.01370308f, 0.00858423f, 0.06087536f, 0.14323939f, 
    0.30456206f, 0.08776909f, -0.01399002f, 0.28838432f, 0.10452933f, 0.11639877f, 0.01193511f, 0.15589999f, 
    0.07112264f, 0.11132328f, 0.09752307f, 0.08317959f, -0.14489678f, 0.00302803f, -0.03885984f, 0.17095798f, 
    -0.02430812f, -0.00314268f, -0.01552889f, 0.01448505f, -0.01160666f, -0.05311834f, 0.15379891f, 0.05154482f, 
    -0.25457361f, -0.05367370f, 0.03659320f, 0.12703347f, -0.02739322f, -0.00402762f, 0.02717256f, 0.12284174f, 
    0.02560952f, 0.06447215f, 0.04531635f, 0.07477487f, -0.23884743f, -0.01245142f, -0.02502917f, 0.03282741f, 
    0.03546175f, -0.12845372f, -0.06267936f, 0.09280484f, 0.05188667f, 0.01738226f, -0.07223612f, 0.12375659f, 
    -0.19255756f, 0.33356467f, 0.16462749f, -0.06289317f, -0.03089064f, 0.02146384f, 0.05963175f, -0.04733931f, 
    0.04678935f, 0.00326848f, 0.10949513f, -0.08596001f, -0.15962689f, 0.27922994f, -0.16616228f, 0.13277449f, 
    0.09126128f, -0.01102312f, 0.03650523f, 0.04085870f, 0.01808852f, -0.12181856f, 0.15885313f, 0.06198515f, 
    -0.03941636f, 0.01268045f, 0.01890471f, 0.02460459f, -0.02547436f, 0.01178426f, 0.01975764f, -0.00229460f, 
    0.00579139f, -0.02857470f, -0.03719560f, 0.01105589f, -0.03955298f, 0.03217486f, -0.01287182f, 0.01055735f, 
    -0.00089202f, -0.01314070f, -0.03299679f, 0.00071546f, -0.00106231f, -0.03756874f, 0.02461022f, 0.01427206f, 
    0.01001756f, -0.01893518f, -0.00199745f, -0.03287157f, -0.03218836f, 0.00308106f, -0.03765109f, -0.01945862f, 
    -0.02548528f, 0.01710416f, -0.00906938f, 0.00003825f, 0.00291980f, -0.00197316f, -0.01517176f, -0.00743945f, 
    0.01366100f, 0.01549925f, -0.01637553f, -0.01464005f, -0.03944626f, 0.01083440f, 0.02750411f, -0.00152231f, 
    -0.00474784f, -0.00135522f, 0.01474242f, 0.01896263f, -0.00451533f, -0.01317167f, 0.01048416f, 0.00937970f, 
    0.01833109f, 0.02758375f, 0.00464108f, 0.02718628f, 0.00894870f, -0.04075088f, -0.01390812f, -0.01601982f, 
    -0.03388121f, 0.01228686f, -0.03453426f, 0.01814319f, 0.00038472f, 0.00152051f, -0.00404845f, -0.02686299f, 
    -0.02738837f, -0.00137650f, -0.02956741f, -0.04121030f, -0.03531249f, -0.01159756f, 0.01296001f, -0.01952482f, 
    0.02847868f, -0.00779933f, 0.00258703f, -0.00390875f, -0.03812927f, 0.02300143f, -0.04188026f, -0.03054149f, 
    -0.00745105f, -0.03444044f, 0.00541957f, -0.02522825f, 0.01473181f, -0.00527785f, -0.01597911f, -0.00630319f, 
    -0.02183189f, -0.01186541f, -0.04244229f, -0.01613697f, -0.03777490f, -0.03128257f, 0.02778945f, -0.01674740f, 
    -0.03415052f, -0.02939174f, -0.02814708f, 0.02814272f, 0.00572170f, -0.01089786f, -0.04025281f, -0.01860193f, 
    -0.02866670f, 0.02157534f, 0.02529243f, 0.00890988f, -0.00720780f, 0.02353531f, -0.02252690f, -0.02400677f, 
    0.00416444f, -0.02947113f, -0.01223782f, -0.01359493f, -0.01488174f, 0.00068240f, 0.02520398f, 0.01909692f, 
    -0.02916164f, 0.01223092f, 0.03191210f, 0.01475954f, 0.02125947f, 0.00926620f, -0.00731313f, -0.00601995f, 
    0.02939366f, 0.00293810f, 0.00309827f, -0.01993721f, -0.03018782f, 0.01249281f, -0.00621000f, 0.00896607f, 
    -0.03635993f, 0.01490481f, -0.03642212f, 0.01024275f, 0.00736975f, 0.02837415f, -0.00251525f, 0.00585539f, 
    -0.03074719f, -0.02681847f, 0.01177323f, -0.00786682f, -0.01332528f, -0.02728295f, -0.00373786f, -0.01351974f, 
    -0.01516425f, -0.00605355f, 0.01347211f, -0.00412277f, 0.00890988f, 0.01906939f, -0.00873678f, 0.00476341f, 
    0.01680825f, -0.00165077f, -0.00268368f, 0.00518053f, -0.02614176f, 0.01492675f, 0.01100358f, -0.03648761f, 
    0.02385523f, -0.03978973f, -0.03759357f, -0.02163769f, 0.02425992f, 0.01642130f, 0.00420823f, 0.00893705f, 
    0.03107694f, 0.00656575f, -0.01345984f, -0.03647210f, -0.01880285f, -0.01171717f, -0.00956825f, 0.00926959f, 
    0.00971226f, -0.01395567f, -0.01501543f, 0.02749623f, -0.03565388f, 0.03175815f, -0.02017755f, 0.00327654f, 
    -0.02952942f, 0.00090618f, 0.00086494f, -0.03613520f, -0.00394279f, -0.00105624f, -0.00213316f, 0.02690654f, 
    -0.01870909f, -0.00385221f, 0.01356389f, 0.00702807f, -0.02092822f, 0.01060109f, -0.01366722f, -0.01111737f, 
    0.00745707f, -0.01228105f, 0.01208602f, 0.02965942f, -0.01047562f, -0.00693084f, 0.00644309f, -0.00841194f, 
    -0.00501364f, -0.00133069f, 0.02950402f, -0.01882541f, 0.02641217f, 0.02686646f, -0.02307043f, 0.01967271f, 
    -0.03102758f, -0.01837209f, -0.03788533f, -0.03660128f, -0.00706357f, 0.01986470f, -0.03973547f, 0.00792174f, 
    -0.00301222f, 0.02361011f, -0.01385769f, 0.00949556f, 0.02065789f, 0.00122286f, -0.01100390f, 0.00065560f, 
    -0.02802897f, 0.02235677f, -0.02922773f, 0.00361036f, 0.00120157f, -0.00361308f, 0.02813889f, 0.00301303f, 
    -0.02788628f, 0.01920597f, -0.04084701f, -0.02718843f, 0.01307804f, 0.02776364f, 0.01480033f, -0.02131577f, 
    0.01527944f, -0.01586216f, -0.03528675f, -0.00780379f, -0.03137062f, -0.03415775f, 0.00600033f, 0.02982402f, 
    -0.03365656f, 0.01310079f, 0.01217259f, 0.01187703f, -0.00188986f, -0.02599527f, 0.02616282f, 0.02306740f, 
    0.02525799f, -0.01730221f, 0.03155223f, -0.02368425f, -0.03915310f, 0.00148374f, 0.01264406f, -0.03784689f, 
    -0.03081371f, 0.02750315f, -0.02589406f, -0.02716825f, -0.03056969f, 0.01399485f, -0.03873221f, -0.01564075f, 
    -0.01431397f, 0.00862147f, -0.01373604f, 0.02699751f, -0.02725423f, 0.00920033f, 0.03212584f, 0.01671009f, 
    0.01597945f, 0.02874514f, 0.00668608f, 0.02261188f, -0.02934149f, 0.00482536f, 0.02851196f, -0.01608670f, 
    0.02883117f, 0.03293866f, -0.03212506f, 0.01309968f, -0.03837781f, 0.01254115f, -0.02365224f, -0.02599481f, 
    0.01500284f, -0.00954636f, -0.01373308f, 0.02973079f, 0.00515207f, 0.01047158f, -0.01205302f, 0.01046528f, 
    0.03086580f, -0.01678922f, 0.00557523f, 0.00116620f, 0.00840168f, -0.03151698f, -0.00783039f, -0.00681492f, 
    -0.02473678f, 0.00300153f, -0.01781118f, 0.00170035f, 0.00679383f, -0.01791152f, -0.01317261f, 0.02270531f, 
    -0.02454421f, 0.01354559f, 0.00441944f, 0.00082461f, 0.02946516f, -0.02739419f, -0.00198570f, 0.03467942f, 
    0.00505304f, -0.01679546f, 0.00408733f, 0.01466641f, 0.03398368f, -0.03405080f, 0.02044789f, 0.00151800f, 
    0.01544286f, 0.01302990f, -0.02679716f, -0.02908954f, 0.01372090f, -0.02063670f, 0.00888250f, -0.01074011f, 
    0.01586686f, 0.01467144f, -0.01716827f, -0.00762780f, -0.03209775f, 0.02402844f, 0.00472680f, -0.01632641f, 
    0.01500060f, 0.01686944f, 0.00834932f, -0.01385203f, 0.00466156f, -0.01765089f, -0.00848110f, 0.03581351f, 
    0.00140642f, 0.02011089f, 0.02398450f, -0.03542779f, -0.02365197f, -0.00995188f, -0.00212629f, -0.04026612f, 
    -0.03003548f, -0.00919901f, 0.01973746f, 0.01084291f, 0.01844813f, -0.01295557f, -0.02397274f, 0.00034834f, 
    0.00205482f, 0.00222139f, -0.01226163f, -0.00383925f, -0.02392041f, -0.03860546f, -0.02505978f, 0.01505569f, 
    0.01018397f, -0.01225215f, 0.00580511f, -0.03606571f, 0.00593639f, -0.00048150f, -0.02878264f, 0.00079377f, 
    -0.00535366f, 0.00767159f, -0.00898723f, 0.00084374f, 0.01751671f, -0.04230093f, 0.00925170f, 0.02651994f, 
    0.01265384f, 0.00682424f, 0.00188551f, -0.01581757f, 0.00826509f, -0.01722384f, -0.03635830f, 0.01632766f, 
    -0.01323413f, 0.01304873f, 0.02757852f, -0.00707422f, -0.02115225f, -0.01369153f, -0.00553881f, 0.00745768f, 
    -0.03283837f, -0.02339387f, 0.00191107f, 0.02195055f, -0.00494656f, -0.03292041f, 0.02263289f, 0.01778620f, 
    0.01247276f, -0.00446843f, 0.01206101f, 0.02601549f, -0.02130144f, 0.00096631f, 0.00003103f, -0.04053561f, 
    0.01660926f, -0.03258596f, -0.01432195f, -0.03827782f, 0.02020421f, -0.01830283f, 0.01053459f, -0.02753362f, 
    -0.01819830f, 0.02693278f, 0.00022488f, 0.02906632f, -0.02505399f, 0.01786121f, -0.04045505f, -0.04184975f, 
    -0.00783272f, -0.03130939f, -0.01887112f, -0.00234563f, -0.03724967f, -0.01496636f, -0.03324396f, -0.03473931f, 
    0.01251190f, 0.02366263f, 0.01162551f, 0.01222777f, -0.02950905f, 0.01875923f, -0.03384498f, -0.03592225f, 
    0.00469206f, 0.00020352f, 0.02849273f, 0.02732635f, 0.01322721f, 0.01362269f, 0.01390279f, 0.02443576f, 
    -0.03999633f, 0.00895687f, -0.00510757f, 0.00623837f, 0.00034062f, -0.01842370f, 0.00039503f, -0.01234373f, 
    -0.00579469f, -0.02866819f, -0.03787503f, 0.00651031f, 0.02770436f, 0.02183216f, -0.01174399f, -0.01061953f, 
    0.02540147f, 0.01397455f, 0.01729107f, -0.00132004f, -0.02938777f, 0.00582895f, -0.03047859f, -0.03576820f, 
    0.01219250f, -0.03970060f, 0.03173890f, 0.02058012f, -0.00735611f, -0.01103898f, 0.02872553f, 0.02433928f, 
    -0.02122567f, -0.00738847f, -0.03725688f, 0.01811695f, 0.00339781f, -0.03154041f, 0.02462803f, 0.00527397f, 
    0.02200713f, -0.00164523f, 0.00909811f, -0.02820650f, -0.01642188f, -0.02940061f, 0.00863781f, -0.00840682f, 
    -0.03448875f, 0.00445695f, -0.01004764f, 0.01237223f, -0.02976502f, -0.00187163f, 0.00862406f, -0.01372966f, 
    -0.01349913f, 0.01340341f, 0.02222774f, 0.01533889f, 0.02311716f, 0.02106606f, 0.01806411f, -0.02873324f, 
    0.00179394f, 0.02182417f, 0.01481197f, -0.00705272f, 0.00822738f, -0.00771854f, 0.00764798f, -0.00657718f, 
    0.02080357f, 0.00062947f, 0.00610438f, 0.01398211f, -0.00097996f, 0.01362684f, -0.03731682f, -0.00086332f, 
    -0.01823862f, -0.02712789f, -0.01066121f, 0.00328219f, -0.03334837f, 0.00690583f, -0.03471676f, -0.00592414f, 
    0.03460775f, -0.00991222f, 0.02519894f, 0.00623583f, -0.00314905f, 0.00763003f, 0.01008138f, -0.00741405f, 
    -0.01534299f, -0.03278899f, 0.00273696f, -0.02050621f, 0.01537933f, 0.01445328f, -0.00140900f, 0.02035035f, 
    -0.00109009f, 0.00522756f, -0.04108461f, -0.03276954f, -0.00083262f, -0.00831194f, 0.02780929f, 0.02488293f, 
    -0.04033719f, -0.03426261f, -0.04089540f, 0.02129036f, -0.03225414f, 0.02370479f, 0.02801833f, -0.03741876f, 
    -0.00911596f, 0.01369839f, -0.00409807f, 0.01190039f, -0.02763065f, -0.02389277f, -0.00593536f, -0.02217736f, 
    -0.02085910f, 0.02203902f, -0.01920817f, 0.01130948f, -0.01980762f, 0.00096928f, 0.00410934f, -0.01526678f, 
    0.01384801f, 0.01451205f, -0.02672667f, 0.02092133f, -0.01930553f, -0.03565343f, 0.02820600f, 0.01973772f, 
    0.00459271f, -0.01622677f, 0.01076797f, 0.02238583f, -0.02205341f, -0.03688435f, -0.03840696f, 0.00943581f, 
    -0.04111937f, -0.01322101f, 0.02358777f, 0.01527236f, -0.01803786f, -0.03826430f, -0.00945944f, -0.02412692f, 
    -0.00249963f, -0.01722918f, -0.03002873f, 0.01638392f, 0.00729040f, -0.00442151f, 0.02643037f, 0.01878374f, 
    0.01466721f, -0.03180807f, 0.01385452f, 0.02539526f, 0.02460567f, -0.01030511f, -0.00130717f, 0.02624631f, 
    0.02220793f, 0.00817383f, -0.00609210f, -0.01348948f, 0.00678489f, -0.03555745f, 0.00326037f, -0.01071919f, 
    0.01288046f, -0.02746357f, 0.02467366f, 0.00205362f, 0.00306200f, -0.01357232f, 0.01784072f, -0.00007602f, 
    0.03119125f, 0.01558418f, -0.02046114f, -0.00091855f, 0.00430571f, 0.00923205f, -0.02501315f, 0.00110335f, 
    0.02930960f, -0.03562602f, 0.01573944f, -0.03799073f, 0.01753770f, -0.01445927f, 0.01517883f, -0.00796643f, 
    0.00991343f, -0.03024482f, -0.01770141f, -0.03153105f, 0.02177819f, -0.01927577f, -0.00488666f, 0.01451266f, 
    -0.03515171f, -0.01459488f, 0.01002572f, -0.00324017f, -0.01961026f, 0.01253063f, -0.03588824f, 0.01467843f, 
    0.03192239f, -0.01634657f, -0.00336747f, 0.01121437f, -0.03010304f, -0.00598480f, 0.00615364f, -0.00127117f, 
    0.00663455f, -0.01539784f, 0.01522377f, 0.02479942f, -0.02961070f, 0.00925444f, 0.00924982f, -0.03345571f, 
    -0.02409780f, 0.00762836f, 0.02081244f, 0.01763417f, -0.00259321f, 0.01415148f, -0.00895419f, -0.00607971f, 
    0.01712882f, -0.01354503f, -0.02164102f, -0.00139311f, -0.03323993f, 0.02663540f, 0.00051674f, 0.01899000f, 
    -0.02935215f, 0.00116138f, 0.00662458f, -0.03790758f, -0.00471322f, 0.00498199f, -0.01173784f, 0.00027052f, 
    0.02928083f, -0.02893787f, -0.01117809f, -0.01993609f, -0.00760988f, -0.03985811f, -0.00961185f, -0.01176127f, 
    0.00506433f, 0.02829240f, -0.04175344f, 0.01787014f, 0.00642798f, 0.00515658f, -0.03491033f, -0.01191095f, 
    -0.02520619f, 0.02220076f, -0.02177458f, -0.03475304f, -0.02436699f, -0.01507393f, -0.02494947f, 0.02964964f, 
    -0.02286736f, -0.04082605f, 0.02429875f, -0.00491523f, -0.01019806f, 0.02524882f, 0.00396063f, 0.01466607f, 
    0.00166749f, -0.00807268f, -0.01778925f, 0.00164519f, 0.00082228f, -0.01552918f, -0.02743611f, -0.02592377f, 
    -0.03976134f, -0.03264858f, -0.01239191f, -0.00617024f, -0.00276591f, -0.04023406f, 0.00954054f, -0.02672288f, 
    -0.01863573f, 0.00911515f, -0.04093304f, -0.01840032f, 0.01739920f, 0.01719677f, -0.03656024f, 0.00581991f, 
    0.02040303f, -0.01044462f, -0.01168870f, 0.01142560f, -0.03406883f, -0.01393857f, -0.03902505f, 0.01868287f, 
    -0.04148609f, 0.02410210f, 0.00763501f, 0.02721041f, -0.00929163f, 0.01769974f, 0.02806420f, 0.01054754f, 
    0.01923446f, -0.02092043f, -0.01146234f, 0.02472696f, -0.02467380f, -0.04028248f, 0.01418652f, -0.03961005f, 
    -0.00634969f, -0.03042147f, 0.00530174f, 0.00858117f, -0.02082720f, -0.02457269f, -0.00193894f, -0.01941269f, 
    -0.00580686f, -0.01486011f, -0.01826735f, -0.00530692f, -0.02479552f, -0.03132445f, -0.00614229f, -0.00627599f, 
    -0.04304139f, -0.01604611f, -0.02002845f, -0.02399378f, 0.01780088f, 0.01062604f, -0.00690218f, -0.02868834f, 
    -0.02735579f, -0.02494086f, -0.00547808f, 0.01436649f, -0.00726172f, -0.02670370f, 0.01514094f, -0.01994124f, 
    0.01927317f, 0.01885881f, -0.01912118f, -0.02828607f, -0.01375369f, 0.01686216f, 0.01813596f, -0.02148385f, 
    -0.00139853f, -0.00484224f, -0.02212996f, 0.02776484f, 0.02782898f, 0.02967724f, 0.02793983f, -0.03308224f, 
    0.01306353f, 0.00900746f, -0.02836153f, 0.01699347f, 0.00397446f, -0.03732532f, -0.02977287f, -0.03945071f, 
    0.00673663f, -0.03725586f, -0.02276771f, 0.02333224f, 0.01821475f, -0.03329090f, 0.01097450f, -0.00591733f, 
    0.00485701f, 0.01235001f, 0.00261577f, 0.02102782f, 0.01033544f, 0.00467141f, -0.01250696f, -0.01106228f, 
    -0.00771064f, -0.00724408f, -0.01642915f, 0.02095017f, 0.00314297f, -0.00844389f, -0.00514409f, 0.01935232f, 
    -0.03808310f, -0.02858090f, -0.00433109f, -0.02198067f, -0.01463016f, -0.03709178f, -0.02864674f, -0.00127336f, 
    0.00158887f, -0.03056731f, -0.02859441f, -0.03910599f, -0.00535842f, -0.01304844f, 0.02227999f, -0.00939611f, 
    0.01026122f, 0.01742197f, -0.00668260f, -0.02903975f, -0.01258319f, 0.01242989f, 0.00205451f, -0.01204698f, 
    0.02811069f, -0.03707156f, 0.00408512f, 0.00581769f, -0.04400191f, -0.03292017f, 0.00026431f, 0.01676978f, 
    -0.02859408f, 0.00647785f, -0.01018571f, 0.00251530f, -0.03195717f, 0.01703786f, -0.02035137f, -0.02095950f, 
    0.02084313f, 0.01234858f, -0.02424208f, 0.01068542f, -0.02557833f, 0.01321003f, -0.00593830f, -0.01452655f, 
    -0.03000158f, -0.04078040f, -0.04070857f, -0.03337762f, -0.03334313f, 0.00107063f, -0.00731239f, -0.01139128f, 
    -0.03781346f, 0.01607535f, 0.00156677f, -0.02173079f, -0.03871088f, 0.00712236f, 0.01983758f, -0.00997179f, 
    -0.00311627f, -0.03688272f, -0.03080450f, -0.03869402f, -0.02004590f, -0.02788201f, 0.01833784f, 0.02904295f, 
    0.00323589f, 0.01173031f, -0.02319797f, 0.00078008f, -0.04259248f, -0.01438823f, 0.02404111f, -0.04200103f, 
    0.02517401f, -0.00167637f, 0.02501143f, -0.02588169f, -0.00335156f, -0.03433829f, -0.02540061f, -0.01371190f, 
    -0.00488703f, 0.02194962f, 0.02572667f, -0.01326428f, -0.00216580f, -0.03634411f, -0.00731726f, 0.02880384f, 
    -0.01288091f, -0.03076203f, 0.00810227f, -0.03149446f, -0.01674520f, -0.01065981f, 0.00940851f, 0.02081152f, 
    -0.01281769f, -0.00088284f, -0.00928440f, -0.02617422f, -0.03124480f, 0.01033335f, -0.01541914f, -0.01416358f, 
    0.00381423f, -0.00768569f, -0.02497316f, 0.00854849f, -0.02288471f, 0.01342422f, 0.01800770f, 0.02152641f, 
    0.00795738f, 0.01177855f, -0.03812106f, 0.00644666f, -0.01851649f, 0.02568032f, 0.01324831f, -0.02259465f, 
    0.02608615f, -0.03268258f, -0.00375849f, 0.01937908f, 0.02126075f, 0.02882669f, 0.02004280f, -0.01802277f, 
    -0.01922177f, 0.00548862f, 0.01613441f, -0.00304189f, 0.00396215f, -0.03080360f, 0.00094603f, -0.00073130f, 
    0.01321139f, 0.02588515f, -0.00071045f, 0.02061365f, 0.00093350f, -0.03679288f, -0.00533519f, -0.00007802f, 
    -0.01388655f, -0.03212760f, -0.02536728f, -0.02671831f, 0.01096557f, 0.02329884f, -0.01378362f, -0.02324969f, 
    0.02056753f, -0.03698857f, -0.00925666f, 0.00109302f, 0.02311928f, -0.01349784f, 0.00922346f, 0.00039212f, 
    -0.02951707f, -0.01077005f, 0.01598511f, 0.02119136f, 0.01409525f, 0.02689390f, -0.02619695f, 0.02293864f, 
    -0.02971813f, -0.02382615f, 0.02815457f, 0.02313131f, 0.02466266f, 0.01340514f, 0.02600684f, 0.01234859f, 
    -0.01936029f, -0.00088817f, 0.02497222f, 0.00454953f, 0.00640311f, -0.04203688f, -0.03749995f, 0.01166880f, 
    -0.00495351f, 0.01580682f, -0.01839870f, -0.04339208f, -0.01452233f, 0.02133176f, -0.01998110f, -0.02020846f, 
    -0.02885773f, -0.03100975f, 0.02555804f, -0.01789159f, -0.04011698f, 0.00588866f, -0.02869471f, -0.01592420f, 
    0.00689346f, -0.03700209f, -0.00370362f, 0.01270496f, 0.00064144f, 0.00136136f, 0.00535630f, -0.00568932f, 
    -0.00937031f, -0.03129843f, -0.00681867f, -0.02546421f, -0.02393612f, -0.00071584f, 0.02470811f, 0.01998117f, 
    0.01360950f, 0.00155122f, 0.02394637f, -0.03108157f, -0.04083401f, -0.02523297f, 0.00112292f, -0.02055321f, 
    -0.00000125f, -0.01307847f, 0.01638774f, 0.01406959f, 0.02602184f, -0.02205809f, -0.02189073f, -0.00829183f, 
    -0.01243803f, 0.00498293f, -0.02418011f, -0.01151011f, -0.02248877f, -0.00554874f, -0.01151355f, 0.02722326f, 
    0.01994616f, -0.01599603f, -0.04031368f, -0.03593349f, -0.02599105f, -0.01948971f, -0.00184191f, 0.01882323f, 
    0.02612059f, -0.03582588f, -0.00193288f, -0.01930252f, 0.01726223f, -0.02393659f, -0.03001906f, 0.00581761f, 
    -0.01233976f, -0.03380303f, -0.03623646f, 0.02442930f, -0.00227401f, 0.02202504f, -0.03745725f, -0.02669541f, 
    -0.01292450f, -0.01840821f, -0.01190204f, 0.02139152f, 0.02352545f, 0.01840154f, -0.01653688f, 0.02397093f, 
    0.01566792f, 0.02100286f, -0.02676687f, 0.02779280f, -0.01246327f, 0.02303749f, -0.01058262f, -0.01080702f, 
    0.01492723f, -0.02620698f, 0.00246149f, -0.02361299f, 0.02794292f, -0.03934032f, -0.02484498f, -0.01860337f, 
    -0.00052826f, 0.02759767f, 0.01524748f, -0.03002723f, 0.00332409f, -0.02833515f, -0.00372909f, -0.00699997f, 
    -0.03363382f, -0.01745746f, -0.02683842f, 0.02129848f, -0.03385547f, 0.02659337f, -0.01499227f, -0.02776630f, 
    -0.00377943f, -0.03686372f, -0.02860776f, -0.02246599f, 0.00216757f, -0.03627580f, -0.00118489f, -0.00093127f, 
    -0.01625990f, -0.02576681f, 0.02591540f, -0.01586809f, 0.00526095f, -0.00869048f, -0.03497797f, 0.01746442f, 
    -0.02636945f, -0.02811860f, -0.03527491f, -0.03802301f, -0.02987143f, 0.02413525f, -0.03348949f, -0.04059140f, 
    -0.00921675f, -0.02794763f, -0.03483920f, -0.00489271f, -0.00457687f, 0.01176749f, 0.00980760f, -0.00805962f, 
    -0.00386040f, 0.00944364f, -0.03862060f, 0.02172837f, -0.01690220f, -0.03863242f, -0.02860263f, -0.01325770f, 
    0.01917727f, -0.03755454f, -0.03894606f, 0.01978174f, 0.02511519f, -0.02378148f, -0.02120715f, -0.00854848f, 
    -0.02541243f, -0.00436175f, 0.01656230f, 0.00481166f, 0.01176333f, 0.00114871f, 0.00779605f, -0.00465130f, 
    0.01477715f, 0.00647509f, -0.00635618f, 0.02238883f, 0.00026558f, -0.02580418f, -0.00630070f, -0.02425176f, 
    -0.02301735f, 0.02911221f, -0.02055495f, -0.03228934f, -0.00468513f, 0.00975530f, 0.00996670f, 0.00141993f, 
    0.00833951f, -0.01813539f, 0.01278254f, -0.00609336f, 0.00573956f, -0.00659753f, -0.00952958f, 0.01800067f, 
    -0.02585582f, 0.02343213f, -0.01342286f, -0.00870967f, 0.02157262f, -0.02057512f, -0.02818782f, -0.03357922f, 
    0.02174269f, -0.01467430f, -0.03933562f, -0.02530186f, -0.02742640f, -0.00632898f, -0.01244315f, -0.00347413f, 
    -0.03807958f, 0.01361608f, -0.00637299f, 0.01282209f, -0.01916147f, -0.04242259f, -0.02700052f, -0.01572833f, 
    -0.02154341f, -0.03864620f, -0.00532969f, -0.00626705f, 0.02644417f, 0.00244226f, -0.01396708f, -0.03990810f, 
    0.01940494f, -0.02003750f, 0.00856085f, 0.01509406f, 0.01361808f, 0.02581173f, 0.01616958f, -0.01901358f, 
    0.02758925f, 0.00445538f, 0.02890647f, -0.03721709f, -0.01425443f, 0.00890501f, -0.03067864f, -0.03598716f, 
    0.00578062f, 0.00650315f, -0.02739085f, 0.02239259f, 0.01902991f, 0.00715712f, -0.03185740f, -0.02734339f, 
    0.01657753f, -0.03744931f, -0.00515144f, 0.02273193f, -0.02491204f, -0.00006041f, 0.02393639f, -0.01536325f, 
    0.02188311f, -0.03240906f, 0.00679067f, 0.00102029f, -0.04102379f, 0.00184937f, -0.02427529f, 0.01899773f, 
    -0.01566054f, -0.02143987f, -0.00348864f, -0.02374762f, -0.03219305f, 0.01296581f, 0.01570339f, 0.01833926f, 
    0.02454019f, 0.01220177f, 0.02553168f, -0.01493774f, -0.04174363f, 0.00373362f, -0.02833306f, 0.00765928f, 
    -0.03868473f, 0.02510593f, -0.00855003f, -0.02056263f, 0.02017635f, 0.00882467f, -0.01022232f, -0.01489217f, 
    -0.00420318f, -0.03218715f, 0.01699128f, 0.00824339f, 0.00380947f, -0.03125273f, -0.02896379f, -0.01859987f, 
    0.01903127f, 0.01050350f, -0.00286345f, -0.04281279f, 0.02760052f, -0.02612902f, 0.02507254f, 0.01351190f, 
    -0.02677069f, -0.02731656f, -0.02444614f, -0.02428831f, -0.01742497f, -0.00884466f, 0.01197554f, 0.01324396f, 
    -0.04264037f, -0.01552161f, -0.01513815f, -0.03774920f, 0.00209958f, 0.01282005f, -0.01241856f, -0.03764704f, 
    0.01843526f, -0.02145945f, -0.02046835f, 0.00863626f, 0.01780371f, 0.00991623f, -0.03813231f, -0.02116536f, 
    0.01268511f, -0.02184583f, -0.01469761f, -0.01087997f, -0.01848006f, 0.00470135f, -0.01509717f, 0.02694811f, 
    0.00353592f, -0.00015797f, -0.00699647f, -0.01019372f, -0.03438827f, 0.00481212f, -0.01112647f, -0.04181644f, 
    -0.03836739f, 0.01877477f, -0.03562282f, -0.03854105f, -0.03650192f, 0.00514841f, -0.03745352f, -0.02139980f, 
    -0.00440570f, -0.03537658f, 0.02153579f, -0.02577636f, -0.03394039f, -0.01349309f, 0.02755465f, 0.02046684f, 
    -0.02928779f, 0.00517619f, 0.02060745f, -0.03345605f, -0.02372607f, -0.02559015f, -0.01668115f, -0.01402504f, 
    0.01573796f, 0.01826268f, 0.01580790f, 0.01971673f, -0.03590610f, -0.00133323f, -0.02583177f, -0.04017356f, 
    -0.01322024f, -0.02913656f, 0.01609002f, 0.02196965f, 0.00717087f, 0.02114990f, 0.00123873f, 0.02933061f, 
    0.02739959f, 0.01896163f, -0.00853158f, -0.00509849f, -0.01854813f, 0.02107709f, -0.01412311f, -0.03502355f, 
    -0.00608132f, 0.00326766f, -0.00688089f, 0.02328679f, -0.01288081f, -0.01334109f, -0.00978683f, -0.04104594f, 
    -0.00115825f, -0.01874900f, -0.00289602f, 0.00946417f, 0.02012775f, 0.02301682f, 0.01402926f, -0.01550675f, 
    -0.00292289f, -0.00654053f, -0.04115424f, -0.02828858f, -0.00116373f, -0.02244017f, -0.03529197f, -0.01194142f, 
    0.17442952f, 0.27398714f, -0.16135499f, -0.22862028f, -0.02212102f, -0.07756092f, 0.01533117f, -0.01637519f, 
    -0.07545619f, 0.11422553f, -0.01955817f, 0.05074205f, -0.31391039f, -0.01187232f, -0.05595090f, 0.00275781f, 
    0.11689527f, -0.00322103f, -0.02307108f, -0.02540192f, 0.00086564f, 0.05997895f, -0.00708685f, -0.01379350f, 
    -0.01589767f, -0.01360413f, -0.04226325f, 0.00185154f, 0.01849352f, 0.04065670f, -0.09036668f, -0.01262216f, 
    -0.04758074f, -0.01314826f, 0.06449644f, -0.00133993f, -0.01605269f, 0.23314846f, 0.09879597f, -0.14844842f, 
    0.13976255f, 0.03199986f, -0.01480011f, -0.04178129f, -0.11266818f, -0.05705913f, 0.08112554f, 0.01324490f, 
    0.40992180f, -0.04250999f, 0.04281121f, 0.12304189f, -0.05250877f, -0.00759958f, -0.00294564f, -0.01840536f, 
    -0.03549544f, 0.08567423f, -0.00423677f, -0.09567279f, -0.17430732f, 0.01205790f, 0.20867853f, -0.12587549f, 
    0.00503122f, 0.02804752f, -0.01969837f, 0.09444921f, 0.17424846f, 0.11147137f, 0.01744997f, -0.01164336f, 
    0.10489824f, 0.12969577f, 0.01511869f, 0.08049384f, 0.07806832f, -0.01180547f, -0.00018737f, 0.02258218f, 
    0.09966155f, 0.04335341f, -0.00034159f, -0.00176676f, 0.47553605f, -0.19778442f, 0.06034854f, 0.03315638f, 
    -0.04791302f, 0.02926285f, -0.05699575f, -0.04721878f, 0.04289193f, 0.03586576f, -0.07736748f, -0.08454701f, 
    0.05319558f, 0.16796325f, 0.25215685f, -0.12063901f, -0.12553427f, -0.05525043f, -0.06971766f, 0.07200971f, 
    0.05612426f, 0.00844288f, 0.01491473f, -0.01321542f, 0.58574653f, -0.08314013f, -0.11231057f, 0.00565483f, 
    -0.04816062f, 0.05856115f, -0.05179527f, -0.01174294f, -0.04101873f, 0.00438922f, 0.12890248f, -0.15215105f, 
    -0.01937433f, 0.02978827f, 0.05703009f, 0.07478664f, -0.08561230f, -0.05209250f, 0.02609683f, 0.01690105f, 
    0.01129439f, -0.10654479f, -0.03290017f, 0.03417816f, -0.01156520f, -0.04047532f, 0.01517829f, -0.01325547f, 
    0.07321420f, -0.04164669f, -0.03498894f, -0.00330411f, 0.05770606f, -0.00183671f, -0.01766455f, -0.02542576f, 
    0.16863470f, 0.11647877f, 0.10194358f, 0.13899896f, 0.01191009f, 0.05541939f, -0.08043078f, -0.05288465f, 
    0.06047030f, 0.06111574f, -0.02181569f, 0.08690901f, 0.11389898f, 0.18104286f, -0.06469686f, -0.05241760f, 
    0.02608673f, 0.00081627f, 0.10583162f, -0.10951623f, 0.02935054f, -0.07505259f, -0.03231717f, -0.07655976f, 
    0.08594447f, 0.06138733f, -0.08793191f, -0.09548099f, 0.01806369f, 0.11502673f, -0.02219740f, 0.02710978f, 
    0.01140940f, -0.00385160f, 0.02775397f, 0.03383898f, -0.04739498f, -0.01139130f, 0.11322153f, 0.25078246f, 
    0.08324233f, -0.06434818f, -0.01910699f, 0.15564795f, 0.09009548f, 0.02679315f, 0.02143959f, -0.01259860f, 
    -0.17199406f, 0.17789108f, -0.09878906f, 0.06648461f, 0.05752228f, -0.11700200f, 0.11797860f, 0.03860905f, 
    0.02618551f, 0.10704582f, 0.04847531f, 0.04144645f, 0.32788950f, -0.21283731f, -0.06183837f, 0.19513766f, 
    -0.17688936f, 0.01157336f, -0.00714036f, 0.06977551f, 0.07256570f, 0.03260823f, -0.06121325f, 0.01392689f, 
    -0.02131312f, 0.05605773f, 0.00204169f, -0.08200285f, 0.05944753f, -0.18707636f, -0.01311292f, 0.00770306f, 
    -0.09610232f, 0.04691911f, 0.03729283f, 0.02127165f, 0.18627903f, -0.28283396f, 0.08695567f, -0.05712158f, 
    0.03017034f, 0.13416140f, 0.06094988f, -0.00221749f, -0.05776323f, -0.07856069f, 0.02315072f, 0.01957533f, 
    0.01894616f, 0.05554178f, 0.14545372f, -0.12071006f, -0.00671918f, -0.11419860f, 0.01416930f, 0.03485186f, 
    -0.08095118f, 0.05210730f, 0.00334282f, -0.00221775f, -0.27201566f, -0.04905754f, -0.20148732f, -0.12994617f, 
    0.02310054f, -0.03166711f, -0.06829953f, -0.10026279f, 0.01317290f, 0.00929142f, -0.12369498f, 0.03772468f, 
    -0.23116648f, 0.04863014f, -0.06648588f, -0.17078020f, 0.05717237f, 0.07108565f, -0.03341405f, -0.04167506f, 
    -0.09632894f, -0.02776014f, -0.09397390f, -0.08594678f, 0.40684289f, -0.03021252f, -0.15416962f, -0.00954410f, 
    -0.00723620f, 0.08690759f, 0.11669621f, 0.03588773f, 0.03076930f, -0.02571759f, -0.00364969f, 0.05820678f, 
    -0.00195569f, 0.32738358f, -0.03082484f, 0.04473851f, 0.08914337f, 0.00157347f, 0.01102034f, -0.22213399f, 
    -0.07099172f, 0.14006165f, -0.00900205f, 0.01303572f, 0.04300340f, -0.09040155f, -0.15579051f, -0.06277435f, 
    0.11540788f, 0.08338431f, 0.09763154f, 0.02688991f, -0.04424673f, -0.05433714f, 0.03205554f, 0.21652128f, 
    -0.11204055f, -0.08917272f, 0.12807883f, -0.12800705f, 0.14309262f, -0.06381976f, 0.06959562f, -0.05635022f, 
    -0.01809013f, -0.03700999f, -0.01855410f, -0.02112018f, 0.12630801f, 0.12314298f, 0.28108022f, -0.23420599f, 
    0.01553403f, 0.02668812f, 0.03679048f, 0.05439250f, -0.02427329f, -0.01245478f, -0.00824032f, 0.03901360f, 
    0.20254888f, 0.14071703f, -0.16962615f, -0.09045897f, -0.08596353f, 0.04492502f, -0.02575738f, 0.00544661f, 
    -0.02889728f, -0.07001983f, -0.04447498f, 0.01070775f, -0.00952420f, 0.06715861f, -0.11768126f, 0.19055054f, 
    -0.03889082f, -0.05205251f, -0.03946224f, -0.23924017f, -0.02810894f, 0.05095093f, -0.11341704f, -0.05356719f, 
    0.39391267f, -0.12846683f, 0.12216600f, -0.01882134f, -0.01178490f, 0.07188863f, 0.04152086f, 0.11664986f, 
    -0.00691288f, 0.09313203f, 0.03156880f, -0.07449903f, 0.12362285f, 0.17266060f, 0.04928191f, 0.03743189f, 
    0.02830004f, 0.08694237f, 0.05139383f, -0.03505719f, -0.01685208f, -0.03162462f, -0.06200176f, 0.00068724f, 
    0.04259563f, 0.14189719f, 0.01551073f, 0.00109530f, -0.08405212f, -0.12855770f, 0.05676783f, 0.00182223f, 
    -0.03572362f, 0.02775357f, 0.07728248f, 0.08363097f, -0.49960789f, -0.23679779f, 0.02632291f, 0.10907718f, 
    -0.01395360f, 0.02328035f, 0.06810325f, 0.00576272f, -0.16065596f, 0.02449214f, -0.13569032f, -0.02175664f, 
    -0.05921768f, -0.16839832f, 0.09096510f, 0.23685093f, 0.01634320f, 0.12834994f, -0.03298417f, 0.06130254f, 
    0.08878556f, 0.01049884f, -0.04311734f, 0.06285913f, 0.06049020f, 0.23960532f, 0.08323995f, -0.04084592f, 
    0.02358523f, 0.06178506f, -0.14259188f, 0.04998097f, 0.02342421f, -0.00724187f, 0.03411667f, -0.15073107f, 
    -0.34779358f, -0.20128287f, 0.04748782f, 0.16491657f, 0.13437237f, 0.03497231f, 0.02080391f, -0.08699630f, 
    -0.01935391f, 0.00955633f, -0.01332680f, -0.01865578f, 0.01044089f, 0.09509540f, 0.14391616f, 0.08980215f, 
    0.07055933f, 0.05375970f, -0.06395026f, 0.08227130f, 0.13462883f, -0.01870340f, 0.00342713f, 0.03087655f, 
    -0.15792383f, 0.20232384f, 0.14716764f, -0.09682726f, 0.09891915f, -0.02213021f, 0.05712643f, 0.00240203f, 
    -0.03129715f, -0.04545714f, 0.01836342f, 0.01954738f, -0.06984739f, 0.15061454f, -0.27172527f, -0.31747991f, 
    -0.06282498f, -0.10446598f, 0.05997385f, 0.04300687f, 0.00254996f, 0.05998772f, 0.04777645f, 0.05107921f, 
    -0.40041280f, 0.11278666f, -0.17253031f, -0.20922104f, 0.02635447f, -0.15983050f, -0.01765388f, 0.08090082f, 
    0.04225590f, 0.03689200f, -0.03189415f, -0.05842762f, 0.13608471f, 0.06361637f, 0.13768195f, -0.00316109f, 
    0.01570063f, -0.09519135f, 0.02231903f, -0.10492996f, 0.08343609f, 0.03809116f, -0.09049255f, 0.18821749f, 
    0.26462314f, -0.10091271f, 0.12215914f, -0.00219798f, 0.03886750f, 0.04629440f, -0.01198107f, -0.01711292f, 
    0.12501781f, -0.03272620f, -0.15815303f, 0.07930196f, 0.22116750f, -0.09840118f, 0.00834152f, -0.17949334f, 
    0.04335067f, 0.09243266f, 0.07733727f, 0.05468249f, -0.16729522f, -0.04955662f, 0.01428528f, 0.04835762f, 
    0.11552571f, -0.21239518f, -0.06007688f, 0.01969990f, -0.02800761f, 0.14246012f, 0.01182516f, 0.10252906f, 
    0.03399950f, -0.02489770f, -0.03727650f, 0.08321561f, 0.01900226f, 0.06282177f, 0.09929329f, 0.01131977f, 
    0.06393386f, 0.14000256f, 0.00623987f, -0.13328795f, -0.16418992f, -0.06806347f, -0.04553719f, -0.08001249f, 
    0.37479234f, 0.04730805f, -0.28412363f, 0.10859577f, 0.00075111f, -0.02917110f, 0.02263584f, 0.05581093f, 
    -0.02498884f, 0.07955153f, 0.04971214f, -0.00265111f, -0.08100772f, -0.22375876f, 0.05935093f, -0.01729099f, 
    0.12499148f, -0.01450209f, -0.00579101f, -0.06139525f, 0.11058339f, -0.07243877f, 0.07278028f, -0.00635408f, 
    -0.40870604f, -0.12684032f, 0.04903500f, -0.17030241f, 0.07792377f, -0.07941461f, 0.04546362f, -0.11560255f, 
    0.07478037f, 0.04773559f, -0.07418633f, -0.05331506f, 0.10585886f, 0.25820562f, 0.05028920f, 0.06807084f, 
    0.09523073f, -0.01399304f, -0.10808445f, 0.00710655f, 0.01161872f, 0.05174953f, 0.05698374f, 0.00787878f, 
    0.57601124f, -0.26227689f, -0.21190937f, -0.26686829f, -0.08541234f, 0.02905715f, -0.04005135f, 0.01332841f, 
    0.04338732f, 0.14364994f, -0.01511197f, -0.03490422f, 0.48562443f, -0.08721301f, -0.01858832f, 0.01476416f, 
    -0.01845285f, -0.00801592f, 0.02180367f, -0.07629576f, 0.00345063f, -0.00891672f, 0.03137549f, 0.05424456f, 
    -0.15718371f, -0.14020604f, -0.08461531f, 0.04124824f, 0.02017465f, 0.00681876f, -0.08635945f, 0.00940260f, 
    0.00894812f, 0.02081787f, 0.06129363f, 0.01819226f, -0.10896365f, 0.10235681f, 0.11203750f, 0.03232278f, 
    0.03748724f, -0.03278448f, -0.09611772f, 0.13875292f, 0.10944526f, -0.04635937f, 0.14233923f, -0.00741641f, 
    -0.06324756f, 0.06678840f, 0.05230681f, -0.14668432f, 0.05951272f, 0.16647990f, -0.02778061f, -0.04615553f, 
    0.00379455f, 0.09416404f, 0.03444720f, 0.05579286f, 0.05262313f, 0.04313634f, 0.19435547f, 0.01291152f, 
    -0.00520691f, 0.02737726f, -0.10015149f, 0.01647897f, -0.03333627f, 0.12186284f, 0.08048594f, 0.19798896f, 
    0.46189997f, 0.09777495f, 0.08549359f, 0.03904473f, -0.04459748f, 0.13790914f, 0.16723020f, -0.04466853f, 
    0.01016548f, 0.03759563f, -0.02678543f, -0.06540378f, -0.32085320f, -0.17032743f, -0.12126324f, 0.00558979f, 
    -0.00467244f, -0.04512584f, -0.06421810f, -0.10614964f, 0.01682679f, -0.02643962f, 0.01490389f, -0.00561212f, 
    -0.08565240f, 0.15653965f, -0.01096098f, -0.07626040f, 0.04173744f, 0.07321325f, -0.15308210f, -0.03443934f, 
    -0.02558470f, 0.04601588f, 0.08959089f, -0.00533684f, 0.24296474f, 0.01778086f, 0.02449662f, -0.01819904f, 
    -0.00851315f, 0.02455295f, -0.00305760f, 0.05871218f, -0.00403847f, -0.06576306f, -0.02551399f, 0.10714663f, 
    0.14301743f, 0.04981171f, -0.11579812f, 0.03162584f, 0.01827134f, -0.01561157f, -0.05168283f, -0.11379871f, 
    -0.15269703f, 0.03266117f, 0.04943093f, -0.02794443f, 0.22916542f, 0.03042496f, 0.05050295f, 0.00918338f, 
    -0.01485523f, 0.00557783f, 0.01863704f, 0.03503673f, 0.05377124f, -0.01312739f, 0.05756090f, -0.03267753f, 
    0.28259599f, -0.27032286f, 0.03398523f, 0.00145608f, -0.05512421f, -0.02260712f, 0.02755235f, -0.05941359f, 
    -0.02569383f, -0.01602336f, 0.01371449f, -0.05257109f, 0.40167430f, 0.04181919f, -0.03175952f, 0.05111165f, 
    -0.02196426f, 0.00208746f, 0.03411054f, -0.03533909f, 0.08059653f, 0.04534685f, -0.03753269f, 0.02311511f, 
    0.26979873f, 0.14590535f, -0.13530092f, -0.09353836f, 0.06673674f, 0.07173028f, 0.13773826f, 0.10120165f, 
    -0.02796617f, 0.09431473f, 0.03311185f, 0.07417821f, 0.14640419f, 0.22707711f, -0.02892719f, -0.11871837f, 
    0.12899098f, 0.04975019f, 0.12886606f, -0.00556935f, 0.00181166f, -0.01328830f, 0.06678917f, -0.03433212f, 
    -0.00364049f, 0.01035631f, 0.02492658f, -0.13292217f, 0.13360402f, 0.10686731f, -0.00471734f, 0.05493910f, 
    0.06774651f, 0.11461874f, 0.03255431f, 0.01236720f, -0.02945974f, 0.10512327f, -0.14619327f, -0.19695696f, 
    0.20747833f, -0.03050471f, -0.04112559f, 0.06170516f, 0.06802986f, 0.08709972f, 0.04908379f, -0.01846710f, 
    -0.39776355f, -0.12153360f, -0.10856131f, -0.04995131f, 0.08477280f, 0.00315696f, 0.01099052f, -0.02799616f, 
    -0.04989005f, 0.15937881f, 0.08225234f, -0.00713657f, 0.04051446f, -0.22499619f, 0.04690269f, 0.08185270f, 
    -0.03746633f, 0.03634722f, -0.02794406f, 0.06883705f, -0.05355369f, 0.04037604f, 0.02146941f, 0.02743488f, 
    -0.29176372f, -0.02744308f, 0.05010594f, -0.19741806f, 0.11178667f, -0.01870354f, 0.01347564f, 0.01162871f, 
    0.09865312f, 0.00345155f, -0.00830752f, 0.06216989f, -0.26743466f, -0.04846130f, -0.18917421f, 0.08275013f, 
    0.10208546f, -0.05149668f, -0.02513817f, 0.06923132f, 0.00151376f, -0.06159869f, 0.04200553f, -0.02501778f, 
    -0.10453998f, 0.02906731f, -0.03621940f, 0.13791782f, 0.00727498f, 0.06964007f, -0.00587939f, -0.05881285f, 
    0.09782168f, 0.02121231f, 0.03148348f, -0.03287528f, -0.26167163f, -0.01159602f, -0.08728766f, -0.00318362f, 
    0.09313480f, -0.02173574f, 0.12794891f, 0.06259768f, 0.00295189f, 0.07614188f, 0.00142809f, 0.05476898f, 
    0.14509290f, 0.30542925f, 0.35266721f, -0.12548651f, -0.05522059f, -0.00357458f, 0.05646700f, 0.07751291f, 
    0.11747932f, 0.10507207f, -0.05004676f, 0.05758776f, -0.08062640f, -0.27877599f, -0.07756665f, 0.07366533f, 
    -0.02043039f, 0.11491029f, 0.00908968f, -0.07510838f, -0.03816513f, -0.03370545f, -0.02099691f, 0.10070874f, 
    -0.33034316f, 0.07278957f, -0.18274549f, 0.03956909f, -0.03034030f, 0.02215018f, 0.01264009f, -0.09576072f, 
    -0.13434909f, 0.07758045f, -0.04613315f, -0.05991850f, 0.24078415f, 0.11086678f, 0.11994990f, -0.15092257f, 
    0.20807834f, -0.04827138f, 0.01346342f, 0.07186456f, -0.00977179f, 0.03440143f, -0.02199733f, 0.09337252f, 
    0.09989771f, 0.23846610f, 0.02277982f, -0.19667588f, 0.04960547f, 0.04940405f, -0.01890445f, 0.05009819f, 
    -0.09657924f, -0.00081826f, -0.10412265f, 0.03603387f, 0.27357557f, -0.21280794f, -0.04087246f, -0.02222345f, 
    -0.02382858f, 0.03273224f, -0.02633920f, 0.03207487f, 0.08463927f, 0.04483755f, 0.16866307f, 0.11928248f, 
    0.18410341f, -0.12811598f, -0.11095755f, 0.01703560f, -0.02401266f, -0.10675406f, -0.01983855f, -0.07205359f, 
    -0.13540399f, -0.03101005f, 0.04772915f, 0.10896067f, -0.13098706f, 0.09033667f, 0.05552792f, 0.10134057f, 
    0.02758451f, -0.09076408f, 0.07681563f, 0.01606610f, 0.05179866f, 0.12583493f, 0.15466768f, -0.01741135f, 
    -0.01698024f, 0.09217725f, -0.00916081f, 0.12066913f, 0.11614652f, 0.06980012f, -0.00508319f, 0.12892807f, 
    0.18779026f, 0.09080947f, 0.04641953f, 0.14060391f, -0.04358843f, -0.04316024f, -0.15849106f, -0.23638113f, 
    -0.08311128f, 0.09191988f, -0.01577751f, -0.06618488f, 0.00313481f, 0.08531420f, 0.05709158f, -0.10708551f, 
    0.11308056f, 0.03243733f, 0.12875628f, 0.07365943f, 0.07362920f, -0.05431256f, -0.04619024f, 0.00427790f, 
    0.00545047f, 0.01258308f, -0.04044785f, 0.07553675f, -0.42197534f, -0.03496399f, -0.06537248f, -0.32704595f, 
    -0.04175114f, -0.05444199f, 0.10846893f, 0.03464673f, -0.02336780f, 0.01968582f, 0.07961237f, 0.13497569f, 
    -0.19745897f, 0.08156665f, -0.00726637f, -0.49433687f, -0.02619870f, -0.05128834f, -0.00634758f, 0.06122971f, 
    0.04847932f, 0.03657177f, 0.02351883f, 0.08427164f, -0.01602744f, 0.00790537f, -0.06814321f, 0.06232196f, 
    0.34019482f, -0.09318178f, 0.03812606f, 0.02438303f, -0.07934692f, 0.02072355f, 0.06781279f, 0.04971962f, 
    0.15445215f, 0.36559790f, -0.29393271f, 0.30450833f, 0.09112233f, 0.03282320f, 0.05823041f, 0.09346823f, 
    0.03781634f, 0.07333025f, 0.03643299f, -0.04931057f, -0.06975265f, -0.00181003f, 0.03651727f, -0.16642918f, 
    0.10763663f, 0.10205624f, 0.07210773f, 0.10157072f, -0.00581849f, -0.02526819f, -0.03255132f, -0.00121474f, 
    0.18792157f, 0.04109339f, 0.18498740f, 0.21198232f, 0.22034259f, 0.10666236f, -0.04610546f, 0.17428498f, 
    -0.07151853f, 0.01675828f, 0.14816998f, 0.03085758f, 0.47311088f, 0.02311373f, 0.05895603f, -0.00696147f, 
    0.01588058f, 0.01443167f, 0.08573367f, 0.02086566f, 0.01549237f, 0.08509155f, -0.10434364f, 0.17200513f, 
    -0.14555022f, 0.15696473f, -0.04293327f, 0.02302237f, 0.09034184f, 0.06887921f, 0.00978912f, 0.03402967f, 
    -0.04872435f, -0.05558733f, 0.05550602f, 0.03816674f, 0.04865088f, -0.00724501f, 0.23982701f, -0.08149881f, 
    -0.05062999f, 0.03778330f, -0.00633940f, 0.07337093f, 0.02814599f, 0.03975742f, -0.03054503f, 0.18428199f, 
    -0.16662416f, -0.29141173f, -0.16831872f, 0.01611252f, -0.04211498f, 0.03663953f, 0.09194762f, 0.00256519f, 
    0.04688261f, 0.09928381f, -0.01599129f, -0.03108220f, 0.02392476f, -0.01100413f, -0.17053039f, 0.05961668f, 
    -0.13207455f, -0.01479738f, -0.08056944f, 0.08596478f, 0.05231987f, -0.01425951f, 0.05969440f, 0.08698899f, 
    -0.25016212f, 0.07272240f, 0.21093808f, -0.21035312f, 0.25210184f, -0.06311583f, -0.04010740f, 0.08792195f, 
    0.08560089f, -0.08564026f, 0.01010219f, 0.03469279f, -0.00931112f, -0.15674271f, 0.27090558f, 0.16497284f, 
    0.03259019f, 0.01186918f, -0.02103500f, -0.06729844f, -0.03914312f, -0.12959860f, -0.00632300f, -0.01302517f, 
    0.08360154f, -0.01530414f, -0.05631155f, 0.01503499f, 0.08284283f, -0.04659466f, 0.10233264f, -0.06103015f, 
    -0.04945697f, 0.15529199f, 0.05226006f, 0.07987250f, -0.15635273f, -0.12062351f, -0.19916992f, 0.12824056f, 
    0.05410480f, 0.11712374f, -0.04641718f, -0.05739103f, 0.13351855f, 0.02797635f, -0.07174184f, 0.01198357f, 
    -0.26976222f, -0.17040026f, 0.05001821f, 0.14747399f, -0.14905207f, -0.06566834f, 0.01896706f, -0.01701256f, 
    0.01347151f, 0.00051183f, 0.10887792f, -0.03827284f, -0.06466154f, -0.20528637f, 0.06029233f, 0.04884358f, 
    -0.07891914f, 0.04964005f, -0.06129332f, -0.08699694f, -0.02404367f, 0.01586552f, 0.07476809f, 0.04602270f, 
    0.05931489f, 0.10206034f, -0.08151137f, 0.36263520f, 0.16678603f, 0.09315676f, -0.11398423f, 0.01778012f, 
    0.10354819f, -0.10354819f, -0.04017233f, 0.07475893f, 0.04382927f, 0.17077357f, -0.08913711f, 0.07124621f, 
    0.05132854f, -0.06364212f, 0.08018503f, 0.01186706f, 0.00010232f, -0.00502913f, 0.05418533f, -0.06394789f, 
    -0.01691456f, 0.22349758f, -0.09494890f, -0.23194246f, 0.06860414f, 0.00431094f, 0.18149364f, 0.02911062f, 
    -0.01885490f, 0.14440662f, 0.01111013f, 0.13184568f, -0.24473549f, -0.08201598f, -0.04318211f, -0.05485009f, 
    0.15992600f, 0.01972304f, -0.03812719f, -0.03341167f, 0.03870119f, 0.07760151f, -0.11148769f, 0.00831136f, 
    -0.33179545f, -0.13159148f, -0.17493185f, -0.08458838f, -0.04859541f, -0.07554462f, 0.00476461f, -0.04801533f, 
    0.03289004f, 0.05676564f, 0.05689873f, -0.04118853f, 0.36901242f, 0.13815963f, 0.24364431f, 0.11612727f, 
    0.06508862f, -0.00939784f, -0.10009956f, 0.06068826f, 0.02392267f, 0.07185071f, 0.09270948f, -0.00067867f, 
    -0.58208311f, 0.23746312f, 0.08435456f, 0.00023771f, 0.09778905f, -0.08580098f, 0.04113336f, 0.04654264f, 
    -0.01187504f, 0.05638688f, 0.09494652f, 0.11440524f, -0.06847151f, -0.09684442f, 0.01116517f, -0.14554875f, 
    -0.05164081f, -0.06226125f, 0.22051665f, -0.08532710f, 0.04328287f, 0.07028005f, -0.01192025f, 0.04939035f, 
    -0.59981483f, 0.16908203f, -0.07973464f, 0.05966760f, 0.18258551f, 0.03192686f, 0.01190389f, -0.00280754f, 
    0.05884261f, -0.08602814f, -0.09759032f, -0.01490129f, -0.12833668f, -0.14020325f, 0.09352649f, 0.13967794f, 
    0.00968910f, 0.05005082f, -0.01824956f, 0.09670965f, -0.03865553f, -0.05069510f, 0.03342749f, 0.06805164f, 
    -0.02471265f, 0.10042620f, -0.03401010f, 0.20377621f, 0.16409685f, 0.10865865f, -0.02841472f, -0.01099961f, 
    -0.01524246f, -0.05453492f, 0.02391166f, -0.07219841f, -0.05044950f, -0.11731268f, -0.02051154f, -0.08583950f, 
    -0.00195584f, -0.02798486f, 0.03940402f, 0.05195401f, -0.02907699f, -0.12949117f, 0.00385051f, 0.03818333f, 
    0.03833970f, 0.10843322f, -0.17331852f, 0.00212793f, -0.00741391f, 0.02478931f, 0.07786714f, 0.13261068f, 
    -0.02351724f, -0.00955001f, -0.03613983f, 0.02498428f, 0.13112852f, 0.19650520f, -0.00801221f, -0.09456348f, 
    0.12754093f, -0.09785680f, 0.00880236f, -0.03041067f, 0.07696875f, -0.02501877f, 0.08068413f, 0.08771129f, 
    0.03699123f, -0.17298701f, -0.02307192f, 0.23616323f, -0.07655918f, 0.00118566f, -0.05339346f, 0.03655005f, 
    0.02213590f, -0.06777598f, 0.08304153f, 0.11046419f, -0.02183655f, 0.12598799f, 0.08543286f, 0.04849938f, 
    -0.00011347f, 0.04485131f, -0.11467008f, 0.13270696f, 0.02513493f, -0.01937703f, 0.01769279f, -0.02442675f, 
    -0.10479236f, 0.14279221f, -0.16911332f, -0.22285469f, 0.12010510f, 0.03950492f, 0.01305726f, 0.04479387f, 
    0.06081738f, 0.09257189f, -0.02129039f, 0.06735770f, -0.03067355f, -0.01538176f, -0.04139486f, 0.01168211f, 
    0.11970923f, 0.15066049f, -0.04212870f, 0.04049709f, -0.00628702f, 0.01313675f, 0.09628242f, -0.02881371f, 
    0.04458368f, 0.00229108f, -0.05933157f, 0.03256495f, 0.26444358f, 0.02191262f, -0.08451604f, -0.03377258f, 
    -0.03917824f, -0.02906665f, 0.04559324f, 0.09810249f, -0.11958399f, -0.26548609f, -0.05745423f, -0.00035300f, 
    -0.05308442f, -0.09056882f, -0.05408912f, 0.16105391f, 0.09638804f, -0.05053001f, 0.13860831f, 0.05528437f, 
    -0.12623808f, 0.13322678f, -0.15535095f, -0.28904200f, 0.09422415f, -0.16102366f, 0.12077764f, -0.00108308f, 
    -0.05990547f, -0.05468876f, 0.12508436f, 0.07902420f, -0.04434148f, 0.18465069f, 0.12513402f, 0.02402848f, 
    0.06898949f, -0.06462830f, -0.12811917f, 0.10126386f, 0.13741165f, -0.08860841f, 0.09842888f, -0.03161181f, 
    0.00711422f, 0.30430716f, 0.00170529f, -0.08443955f, 0.11333422f, -0.03165225f, 0.14941646f, 0.01274115f, 
    0.03851183f, -0.06573350f, 0.06982907f, -0.04362736f, -0.22027421f, -0.03937249f, -0.10565402f, 0.03194541f, 
    0.07553221f, -0.01223684f, 0.01159830f, -0.15698461f, 0.05511647f, 0.05770995f, 0.02320268f, -0.01290066f, 
    0.07820944f, -0.30819890f, 0.24850620f, 0.11272547f, 0.02529687f, 0.01739782f, -0.12816791f, 0.14410847f, 
    0.05700071f, 0.15690753f, -0.04862038f, 0.09810933f, -0.00872516f, 0.14772338f, 0.06726479f, 0.13764864f, 
    0.06555845f, -0.04182164f, 0.02377724f, 0.10472941f, 0.07257535f, 0.06071023f, 0.05449318f, 0.08546077f, 
    0.00631645f, 0.01939277f, -0.01836630f, -0.00254292f, -0.03901272f, 0.02649765f, 0.01545194f, 0.01888140f, 
    0.00461950f, 0.01719109f, -0.02090573f, -0.02311657f, -0.02663850f, 0.00269319f, -0.02014915f, -0.01505365f, 
    -0.02998854f, -0.04089189f, -0.01255089f, -0.01946100f, -0.01752400f, -0.00171383f, 0.00859828f, -0.04017620f, 
    0.00508567f, -0.03450381f, -0.03664996f, 0.01682280f, 0.02472897f, 0.02821569f, 0.00992870f, -0.03302161f, 
    0.00354152f, -0.02136564f, -0.02561207f, 0.01677969f, 0.02094026f, 0.00588928f, 0.00834986f, -0.00081344f, 
    -0.02945840f, -0.00389369f, -0.03984447f, -0.03668534f, -0.02487989f, 0.01900592f, 0.01524795f, -0.03350833f, 
    -0.02446399f, 0.02768248f, -0.00706202f, 0.02665414f, 0.01374208f, 0.00170300f, -0.02036339f, 0.01231317f, 
    -0.03791526f, 0.02070549f, 0.02093061f, 0.01635164f, -0.02599190f, 0.01478139f, -0.01455545f, 0.01898332f, 
    0.00804822f, -0.02570138f, -0.00900190f, 0.00916235f, -0.02367483f, -0.00514943f, -0.00100093f, -0.00409235f, 
    -0.04218395f, -0.02138505f, -0.00002868f, 0.01414783f, -0.00007444f, 0.00731197f, 0.02082537f, -0.01182632f, 
    0.02566816f, -0.02874064f, 0.01384611f, -0.00012215f, 0.02503382f, -0.03041554f, -0.01674263f, 0.02623788f, 
    -0.01736607f, 0.01810181f, -0.00146087f, -0.02895401f, 0.00416464f, 0.00030341f, 0.00336145f, -0.03213373f, 
    0.00774817f, 0.00786165f, 0.01365404f, -0.02019319f, -0.03922595f, -0.01964277f, -0.01569859f, -0.03893401f, 
    0.00928765f, 0.02379287f, 0.01223638f, 0.02614361f, 0.00854048f, -0.03168519f, 0.02831042f, 0.01045076f, 
    -0.00458819f, 0.02238980f, 0.02458633f, 0.00309196f, -0.03908153f, -0.02896081f, -0.03096831f, 0.00687867f, 
    -0.00135754f, 0.02301181f, -0.02337347f, -0.03984193f, -0.00671107f, 0.01961509f, 0.00790365f, -0.03063752f, 
    -0.03468783f, -0.03379354f, 0.01736731f, 0.02412525f, 0.00294540f, 0.02959207f, -0.02350375f, 0.00799872f, 
    -0.02934196f, -0.02181670f, -0.00582299f, -0.02843905f, -0.03882434f, -0.00555851f, 0.02897077f, 0.01581053f, 
    -0.03526672f, 0.02148132f, 0.01695571f, -0.00238557f, -0.00861979f, -0.01832157f, -0.03958580f, -0.03923538f, 
    -0.04067167f, 0.01387649f, -0.00742695f, -0.00890514f, 0.01483348f, -0.03584837f, -0.00069822f, -0.01964215f, 
    -0.01785679f, 0.00849318f, -0.01907214f, 0.00730113f, -0.02623352f, -0.03446976f, -0.00153241f, -0.03237909f, 
    0.01376827f, 0.02309402f, 0.02103942f, 0.00276604f, -0.03178076f, 0.00301265f, -0.01930007f, 0.02836823f, 
    -0.03908842f, -0.02245583f, -0.02780739f, -0.00361799f, 0.02947362f, 0.01148069f, 0.00776223f, 0.00190659f, 
    0.01133011f, -0.04251812f, -0.00221421f, -0.02784673f, -0.01488241f, -0.01311562f, -0.00741135f, -0.03181855f, 
    0.01120696f, -0.02996849f, 0.01368111f, -0.03741375f, -0.01041982f, -0.03381180f, -0.01949274f, -0.03787068f, 
    -0.04054553f, -0.03761733f, 0.00781625f, -0.03891445f, -0.03804196f, -0.01819423f, -0.03000513f, 0.02126604f, 
    -0.02010546f, -0.00271200f, 0.01847940f, 0.01991104f, 0.01328248f, -0.03108605f, -0.03128001f, -0.00855771f, 
    0.00855240f, 0.01481596f, -0.02173539f, -0.01839840f, -0.01694087f, -0.03835820f, -0.01831659f, -0.02408933f, 
    0.01776033f, -0.00038753f, 0.01745399f, 0.00111857f, -0.00050880f, 0.01629906f, -0.00369582f, -0.00318958f, 
    -0.00658870f, -0.01601603f, -0.01527498f, -0.00403501f, -0.02271874f, -0.00899618f, -0.03371039f, -0.03424493f, 
    0.01096439f, -0.00830652f, 0.01072752f, 0.00276143f, 0.02097679f, -0.04165396f, 0.02193252f, 0.00595729f, 
    0.00179904f, 0.02317388f, 0.02331020f, -0.01906290f, 0.01156802f, 0.02000361f, 0.02415788f, -0.03029069f, 
    0.01803069f, 0.02216443f, -0.02824523f, -0.00882255f, -0.01246353f, -0.00580300f, -0.01570540f, -0.03720254f, 
    0.01880166f, 0.02008588f, 0.01219846f, -0.02652257f, -0.02898600f, -0.01488250f, 0.02347392f, -0.01981812f, 
    0.01722103f, -0.02598985f, -0.01229883f, 0.02126195f, 0.02556751f, 0.01319275f, -0.02179273f, 0.01412881f, 
    0.01124039f, 0.00994875f, -0.02828568f, -0.04019162f, -0.01506338f, 0.00474027f, -0.03636663f, 0.02977706f, 
    -0.03918510f, 0.01349978f, -0.00028399f, 0.01277410f, -0.01291594f, 0.02546072f, -0.02144966f, -0.02905635f, 
    0.00003183f, -0.02435944f, -0.04226558f, -0.04060144f, -0.01346940f, -0.04068988f, 0.01797619f, 0.01452230f, 
    -0.02083052f, -0.04029965f, 0.01220876f, -0.03189718f, 0.01780454f, 0.01626557f, -0.01096409f, -0.02147702f, 
    -0.03365196f, -0.02951546f, -0.04069357f, -0.00347182f, 0.02748736f, 0.01114998f, -0.01034585f, 0.00229393f, 
    -0.03925478f, 0.02616718f, -0.03693063f, -0.03966289f, 0.01003579f, 0.01612786f, -0.01571505f, -0.00290572f, 
    -0.00288030f, -0.03036478f, 0.01467775f, 0.01650213f, -0.02610684f, -0.01904861f, -0.02910231f, 0.02074476f, 
    -0.02072294f, 0.01021696f, 0.00101725f, -0.03926536f, -0.00979648f, 0.02175215f, -0.00002081f, -0.01950227f, 
    -0.02382144f, -0.00153194f, 0.02231159f, 0.02239301f, -0.02017995f, -0.02963291f, 0.00929204f, -0.01473835f, 
    -0.00220836f, -0.02910358f, -0.02497834f, -0.01946029f, 0.01438867f, 0.02460637f, -0.02068071f, 0.00651113f, 
    0.00345470f, 0.02833153f, -0.03083894f, -0.03905545f, -0.01091400f, -0.01885400f, -0.00088443f, -0.01373697f, 
    0.01984981f, 0.02184557f, -0.03671527f, -0.02895859f, -0.02573772f, 0.03176939f, -0.01419727f, 0.01187433f, 
    -0.00148394f, -0.02541132f, -0.03806230f, 0.00564029f, -0.03297311f, -0.00515095f, 0.02171388f, -0.01991868f, 
    -0.01491762f, 0.02303558f, 0.00483943f, -0.00916962f, 0.00069287f, 0.02415744f, 0.00635776f, -0.01688009f, 
    0.02689141f, -0.01215076f, -0.01255616f, 0.02296204f, -0.03595780f, 0.00099958f, -0.00476269f, -0.04191913f, 
    0.02609103f, -0.03686335f, -0.00002351f, -0.02410952f, -0.03351427f, -0.02258689f, 0.00251464f, -0.01908141f, 
    -0.00261592f, 0.02348294f, 0.01603221f, 0.00745861f, 0.02648109f, -0.03794431f, -0.04326444f, -0.01869749f, 
    0.02095146f, -0.01384197f, -0.01114445f, -0.02582086f, -0.02249447f, 0.00847813f, 0.01201641f, 0.02975081f, 
    -0.02435333f, -0.01171807f, -0.04073222f, -0.01964284f, -0.00095236f, 0.00883712f, 0.02880620f, -0.01855404f, 
    -0.00953839f, 0.02445579f, 0.00970364f, -0.03901196f, -0.03551779f, -0.00713761f, 0.01524658f, -0.01469679f, 
    0.01168667f, -0.01462120f, -0.02192725f, 0.00443014f, -0.00470002f, 0.02679473f, 0.02522033f, -0.00892994f, 
    -0.00499592f, 0.01292956f, 0.01638656f, -0.01561534f, -0.01331535f, 0.02032984f, 0.01138182f, 0.00068268f, 
    -0.01985081f, -0.01119172f, -0.01209803f, -0.01236487f, -0.03463672f, 0.02863108f, 0.02186768f, -0.01420159f, 
    0.01436295f, -0.03449053f, -0.04057727f, 0.02906284f, -0.02559360f, 0.00719398f, -0.01105224f, -0.03166728f, 
    0.01844362f, 0.01021170f, 0.02085982f, -0.02392115f, 0.02536169f, -0.00670122f, -0.01434643f, -0.01529461f, 
    0.00205273f, -0.02328393f, -0.02591758f, 0.02423402f, -0.01985986f, -0.01099825f, -0.00798776f, -0.01575709f, 
    0.00016567f, -0.00430254f, -0.00064227f, 0.01349261f, -0.02829047f, -0.03161458f, -0.02112456f, 0.02641146f, 
    0.00357760f, -0.00500376f, -0.03763068f, 0.02203226f, 0.02352672f, 0.01114694f, -0.00848284f, 0.02951286f, 
    0.02838363f, 0.02261396f, -0.01148227f, 0.01649748f, -0.00871173f, 0.01328559f, -0.02657479f, -0.02085198f, 
    -0.03771564f, -0.01055314f, 0.00517473f, -0.02719345f, 0.01984437f, -0.01617470f, -0.02934551f, -0.04121026f, 
    0.01325274f, 0.00081882f, -0.01761293f, 0.02447360f, -0.04139232f, -0.01685210f, -0.03302537f, -0.02145814f, 
    0.00708060f, 0.00635451f, -0.03378208f, 0.01659294f, 0.01712114f, -0.01245850f, -0.01526978f, -0.00329070f, 
    -0.03096313f, 0.00835406f, -0.01858343f, -0.02609956f, 0.02853366f, 0.00241655f, -0.00357669f, 0.00201980f, 
    0.02518524f, 0.01829315f, -0.00868973f, 0.01624232f, -0.03983025f, -0.00530553f, -0.00625178f, -0.01501950f, 
    0.01890366f, 0.02087756f, -0.03226138f, -0.02114431f, 0.01734301f, 0.00406267f, -0.02040369f, -0.04290368f, 
    -0.01163654f, -0.02097016f, -0.02755247f, -0.00707573f, 0.00168530f, 0.01470894f, -0.03964977f, -0.00341357f, 
    -0.02352197f, 0.00655385f, 0.00639076f, -0.01766461f, 0.01855793f, -0.03956249f, -0.00548049f, -0.03424575f, 
    -0.02750615f, -0.02757928f, 0.02049190f, 0.00045307f, -0.03354325f, 0.01253761f, -0.01420515f, -0.02406612f, 
    -0.02959675f, 0.00591698f, 0.00621000f, -0.00643390f, -0.03617075f, 0.00779125f, -0.00048770f, -0.02926080f, 
    0.01723946f, -0.02770574f, 0.01471169f, -0.02096323f, 0.01780742f, 0.02040819f, -0.03143663f, -0.02078848f, 
    -0.00188194f, -0.02790537f, -0.04086113f, -0.01078183f, -0.01506200f, -0.00506193f, -0.03555565f, 0.00529311f, 
    0.02340581f, 0.02493779f, 0.02030894f, -0.00136649f, 0.02427197f, -0.02593838f, -0.03874689f, -0.01882363f, 
    -0.00609693f, 0.00742619f, 0.01567903f, 0.01530203f, 0.01249904f, -0.01984883f, 0.02576538f, 0.02301631f, 
    -0.00705589f, -0.03684579f, -0.02285833f, 0.02790350f, -0.01719569f, -0.03610013f, -0.02456654f, -0.02988518f, 
    0.00792841f, -0.00456735f, -0.01400773f, -0.00301120f, 0.02159533f, -0.00698201f, -0.00427251f, -0.03586375f, 
    -0.02608194f, -0.03490348f, 0.01323499f, 0.00288555f, -0.01017544f, -0.00757366f, -0.03542506f, -0.00549467f, 
    0.01563000f, 0.00252982f, 0.01793986f, 0.02628119f, 0.02419566f, 0.01383694f, -0.03826076f, -0.02446847f, 
    0.00401613f, 0.02382204f, 0.00804420f, -0.02275973f, -0.01304985f, 0.02727095f, 0.00332804f, -0.00284869f, 
    0.00999291f, -0.03773000f, 0.01065708f, 0.01341582f, 0.02697117f, -0.00788630f, -0.00619747f, -0.02834342f, 
    -0.00064676f, -0.01977732f, -0.03900838f, 0.01686248f, -0.03935735f, 0.01766184f, -0.03485566f, 0.02257952f, 
    0.00170348f, -0.02036696f, 0.01246728f, -0.04226910f, -0.01949122f, 0.00601200f, -0.03325667f, -0.02495087f, 
    0.00133926f, 0.01265153f, -0.02488702f, 0.01823357f, -0.03611290f, -0.00357342f, 0.01534986f, 0.00426177f, 
    0.00792822f, 0.02597606f, -0.02086750f, 0.00312805f, -0.03199074f, -0.03126642f, -0.00178299f, -0.02848098f, 
    0.00929678f, -0.00260122f, -0.01407656f, -0.01659489f, 0.01109214f, -0.02289346f, -0.04049654f, -0.03514339f, 
    -0.02741661f, -0.01574480f, -0.00009533f, -0.00031120f, 0.01251531f, -0.04194177f, -0.02235497f, -0.03286741f, 
    0.00332160f, 0.01896522f, 0.00506258f, -0.00535617f, -0.03908411f, -0.00858037f, -0.02834712f, -0.02400071f, 
    0.01598605f, 0.01889277f, -0.00626042f, -0.02408468f, 0.02769127f, -0.03909655f, 0.00606591f, 0.00508020f, 
    -0.01829620f, 0.01448686f, -0.00853494f, -0.03003079f, 0.00488521f, 0.00919317f, -0.01296813f, 0.01450066f, 
    -0.01705725f, -0.03360386f, -0.02071116f, -0.02173644f, -0.00386731f, -0.02993773f, 0.01176393f, -0.01615062f, 
    0.00095916f, -0.00582038f, -0.02025675f, -0.03569050f, 0.02332252f, 0.01011044f, -0.01692122f, 0.00127345f, 
    -0.00136080f, -0.00913438f, 0.02657359f, 0.02515207f, 0.00418370f, 0.02390733f, -0.01758633f, 0.02263734f, 
    0.01731226f, -0.02527945f, 0.02822824f, -0.00485260f, -0.04160558f, 0.01819576f, -0.00690572f, -0.03407177f, 
    -0.00194424f, -0.03979691f, 0.00353866f, 0.01384891f, -0.03051113f, -0.00705720f, -0.03117359f, 0.01529879f, 
    0.01433192f, -0.01048035f, -0.01399066f, -0.02501362f, 0.02344834f, 0.03078491f, -0.02602944f, 0.01537570f, 
    -0.01758704f, 0.02250516f, -0.02860693f, -0.03062483f, 0.02888377f, 0.01466958f, 0.00614691f, -0.02393993f, 
    -0.03607725f, 0.02832433f, -0.01682825f, -0.02766974f, 0.00048892f, -0.02172181f, -0.02622174f, 0.02976734f, 
    0.03044279f, 0.00532069f, 0.02952479f, -0.02886168f, 0.02145275f, -0.00083614f, -0.03462196f, 0.00649948f, 
    0.01979179f, 0.01269618f, -0.01918125f, -0.00042454f, 0.01296664f, -0.01678089f, 0.02663368f, 0.03299200f, 
    -0.01243894f, -0.02553076f, 0.02214486f, -0.02846481f, 0.00703207f, -0.00365543f, 0.00051292f, -0.02543626f, 
    -0.04210512f, -0.03957754f, 0.02641414f, -0.01630147f, 0.02789049f, 0.00528612f, -0.02428680f, -0.02693928f, 
    0.03066511f, 0.01580305f, -0.02768791f, 0.00752738f, -0.02518907f, 0.00463040f, 0.00266901f, -0.00161015f, 
    -0.00048335f, -0.01208688f, -0.00574338f, 0.00615905f, 0.00521540f, 0.00093484f, -0.02260379f, 0.01950349f, 
    0.00947868f, 0.02660902f, -0.00317465f, -0.03664251f, 0.02039864f, -0.00776898f, -0.03251722f, 0.01689958f, 
    -0.00372419f, 0.02077545f, -0.03038176f, -0.01583574f, -0.02758710f, -0.02498263f, -0.02723268f, 0.02943137f, 
    -0.00902548f, 0.00327861f, -0.01812955f, 0.00602613f, -0.02586129f, 0.01742752f, -0.01008084f, 0.00435849f, 
    -0.02136748f, 0.00676931f, 0.02077982f, -0.02852787f, -0.00265494f, 0.01366760f, -0.01140158f, 0.01987750f, 
    0.01540600f, -0.00142408f, -0.02881508f, -0.03218484f, -0.00113110f, -0.00330225f, -0.01532959f, 0.03531161f, 
    0.02628689f, -0.02657164f, 0.02451592f, 0.02698476f, 0.02377366f, -0.03063938f, -0.02142958f, -0.03140428f, 
    0.02107226f, -0.01481528f, -0.04226739f, -0.00269316f, -0.01584619f, -0.03202899f, -0.01915827f, -0.03447035f, 
    -0.04053873f, 0.03183870f, -0.02912556f, 0.02551407f, -0.01669816f, 0.02995590f, -0.00082303f, 0.01889454f, 
    0.02448067f, 0.03116614f, -0.04143563f, 0.02365969f, 0.00279566f, 0.02367586f, -0.02559560f, -0.00807310f, 
    -0.00542529f, 0.03058694f, -0.00196776f, 0.01278168f, 0.01922909f, -0.04252882f, 0.01931698f, -0.02664954f, 
    -0.01363052f, -0.01480208f, 0.01123582f, -0.02528700f, -0.00189458f, 0.02654089f, -0.02498489f, 0.01130025f, 
    0.02617301f, 0.03507965f, 0.01650810f, -0.02144012f, -0.00993561f, -0.01495441f, -0.02592283f, 0.00908528f, 
    -0.00134636f, 0.00370124f, -0.00790492f, -0.03815840f, 0.02674774f, 0.02069768f, 0.02067712f, -0.00330928f, 
    -0.01910048f, 0.00026851f, -0.02904053f, -0.02318725f, -0.03890081f, -0.00244630f, 0.00910998f, 0.01349787f, 
    0.00869277f, 0.01799430f, 0.01048709f, -0.01893169f, -0.02274997f, -0.03190468f, 0.03494447f, 0.02285744f, 
    0.02730138f, -0.00925761f, 0.02372184f, -0.02566432f, 0.00351823f, -0.03459330f, 0.01824426f, 0.01077539f, 
    0.00020909f, 0.00344453f, 0.00941064f, -0.01512267f, -0.01528838f, 0.02829777f, -0.00065872f, -0.01718790f, 
    -0.02007517f, 0.00445582f, -0.02939585f, -0.03622939f, -0.00711835f, -0.01609616f, 0.00077658f, -0.01971215f, 
    0.01062460f, -0.01185893f, -0.00781924f, -0.01242550f, 0.01769795f, -0.00455867f, -0.03804569f, 0.02263206f, 
    0.02878156f, 0.00141771f, 0.03105908f, 0.01004145f, 0.01209020f, 0.02047620f, 0.02726848f, 0.01847349f, 
    -0.02378643f, -0.02705664f, -0.01814345f, 0.02390470f, -0.00018907f, -0.00528637f, -0.03559982f, 0.01766798f, 
    -0.01879599f, -0.02259747f, -0.00151095f, -0.01288447f, 0.02240768f, -0.01050152f, -0.02702240f, 0.02853077f, 
    0.00876325f, -0.00411664f, 0.02462021f, -0.02752218f, -0.01169460f, 0.03059896f, 0.02332558f, -0.01343788f, 
    0.01412922f, 0.01382926f, -0.03234443f, 0.02290666f, 0.00227400f, 0.02233423f, -0.03382846f, -0.03726436f, 
    -0.02490866f, -0.03717485f, -0.03238273f, 0.01687882f, -0.01008091f, 0.02815343f, -0.01745933f, -0.01825096f, 
    -0.01276293f, 0.01985387f, -0.02978854f, 0.01097328f, 0.00665970f, -0.01240246f, -0.01100890f, -0.04001792f, 
    -0.01502295f, 0.01142018f, -0.00029852f, -0.02666567f, -0.00160036f, -0.03024182f, 0.00470970f, 0.00723930f, 
    -0.00271321f, -0.02344282f, -0.00693141f, 0.00071297f, -0.02022212f, -0.02541097f, 0.00554256f, -0.02654183f, 
    0.02462656f, -0.02333427f, -0.04091876f, -0.02284305f, -0.01208576f, -0.02881204f, 0.00500888f, -0.01083853f, 
    0.00862565f, 0.02693702f, 0.03481324f, -0.00078736f, 0.00655766f, 0.01239565f, 0.02381596f, -0.00431053f, 
    0.01295563f, 0.00612725f, -0.01036065f, 0.00264712f, 0.01224015f, 0.00631684f, 0.01622581f, 0.02588018f, 
    0.02489101f, -0.03267480f, -0.00862753f, -0.03753410f, 0.02470301f, 0.01643416f, 0.02740908f, -0.02330544f, 
    -0.01819910f, -0.02730874f, -0.02075266f, -0.02366351f, 0.01956072f, 0.00471437f, -0.03877087f, 0.00808076f, 
    -0.00721214f, -0.02532031f, 0.00476038f, -0.00005228f, -0.01679175f, 0.02891236f, 0.03081191f, 0.00279548f, 
    0.01866906f, 0.00347838f, -0.00768649f, -0.03918882f, -0.02228899f, 0.02280078f, 0.02328368f, -0.02067920f, 
    0.01838297f, -0.03439160f, -0.01589387f, -0.00069294f, -0.00182449f, -0.03497525f, -0.03012283f, -0.00649857f, 
    0.03031423f, -0.01037059f, -0.04237157f, -0.00602078f, 0.01223403f, -0.00404227f, -0.02963119f, -0.00049267f, 
    -0.03475357f, 0.02205956f, -0.01265344f, -0.02287326f, -0.00955054f, -0.00376450f, 0.00044838f, -0.00914511f, 
    -0.00148354f, -0.01180352f, 0.02158582f, -0.00270219f, -0.03228897f, 0.03299978f, 0.03116491f, 0.02892249f, 
    -0.01765862f, -0.04085278f, 0.00308102f, 0.02389414f, -0.00364843f, 0.01024962f, 0.00581191f, 0.00685499f, 
    -0.04137867f, -0.00216375f, -0.02478064f, 0.01808284f, 0.00349660f, 0.00791733f, -0.01980307f, 0.01158145f, 
    0.03444459f, 0.02235260f, 0.01708874f, -0.03762101f, 0.02712635f, 0.02812808f, 0.02230343f, -0.04276652f, 
    0.02621898f, -0.02209320f, -0.00565615f, -0.01880962f, -0.00282511f, 0.00125019f, -0.02878326f, 0.03180800f, 
    0.00585493f, -0.01422994f, -0.02270841f, -0.00767103f, 0.03047323f, -0.00314799f, 0.01532991f, -0.02297926f, 
    0.00452956f, -0.03169938f, -0.01239009f, -0.01874155f, -0.00265414f, -0.02338441f, 0.01027945f, 0.01995378f, 
    -0.01561867f, 0.02544875f, -0.03593657f, -0.00238333f, 0.00794949f, -0.02177591f, 0.02655489f, 0.00056916f, 
    0.00686678f, -0.01766077f, -0.01400384f, -0.01920508f, -0.04092586f, -0.01642551f, -0.03454132f, -0.00665317f, 
    -0.00333155f, -0.03293793f, 0.00280600f, -0.02810520f, 0.01152713f, 0.02360573f, -0.03024388f, 0.02452131f, 
    0.00145063f, 0.02943824f, -0.01109471f, -0.01599260f, 0.00129438f, 0.00440945f, -0.00119241f, -0.03062716f, 
    0.02670976f, -0.00866116f, 0.01213668f, -0.00120987f, 0.01249060f, -0.02582845f, 0.01720998f, -0.00181097f, 
    0.01887812f, -0.01530144f, -0.01870221f, -0.01459442f, 0.00693049f, -0.00989631f, 0.01598961f, -0.03214005f, 
    -0.00136432f, -0.02910415f, -0.00956490f, 0.00884187f, -0.02773600f, 0.01665895f, 0.00594473f, -0.03119702f, 
    0.00878149f, -0.02321980f, 0.02078071f, 0.00063182f, -0.01648582f, -0.02896909f, -0.00182535f, 0.01204715f, 
    0.00718976f, 0.01366167f, -0.01978238f, -0.04058391f, -0.00782892f, -0.01702643f, -0.02694352f, -0.00883110f, 
    0.03116232f, -0.03918605f, -0.03417866f, -0.03866479f, -0.02075996f, -0.02777347f, -0.01144318f, 0.00329751f, 
    -0.00253935f, -0.01597209f, -0.02618994f, 0.02261852f, -0.02901054f, -0.04124653f, -0.00852762f, -0.01782220f, 
    -0.03209195f, -0.03095290f, -0.01597605f, -0.01160268f, -0.00831253f, 0.03310083f, 0.01038958f, -0.01343443f, 
    -0.03747879f, -0.02186411f, 0.00631004f, 0.01550132f, 0.01865243f, 0.00346761f, -0.01975884f, 0.01519857f, 
    -0.00828773f, -0.00361623f, 0.03362557f, -0.00806586f, -0.00666886f, 0.03128590f, 0.01997160f, -0.02723541f, 
    0.00360482f, 0.02396074f, 0.02517588f, 0.01869344f, -0.03887102f, -0.00186331f, -0.01929709f, 0.03321203f, 
    -0.03058016f, -0.04003635f, -0.02731191f, 0.01871346f, 0.01680010f, -0.02111436f, 0.00817007f, 0.01334224f, 
    0.02813281f, 0.03565621f, -0.01891431f, 0.01193223f, 0.00032817f, -0.04216979f, 0.00572716f, 0.00948049f, 
    0.00598327f, -0.03578128f, 0.02572179f, -0.02666353f, 0.02847952f, -0.02112571f, 0.03772894f, -0.00457151f, 
    -0.00675835f, 0.00197116f, -0.02368946f, -0.01691613f, 0.01513479f, -0.01629401f, -0.02420049f, 0.02211453f, 
    -0.03065324f, -0.00006696f, -0.01209438f, -0.03050723f, -0.02931490f, 0.00383418f, -0.02512350f, 0.02319387f, 
    0.01753866f, -0.03307304f, -0.02929075f, -0.01692612f, -0.00082739f, -0.03527464f, 0.00893296f, -0.00208676f, 
    0.03168220f, -0.00760296f, -0.03069721f, -0.01291110f, 0.02014045f, 0.00401638f, -0.00988742f, -0.03019554f, 
    -0.02484634f, 0.01457487f, 0.01903492f, -0.00372329f, -0.03361065f, -0.04152268f, 0.02509827f, -0.03051846f, 
    -0.04212344f, 0.00627200f, 0.01436592f, 0.02903005f, 0.00029414f, 0.02553201f, 0.01053886f, -0.01091767f, 
    0.00738823f, 0.03036138f, -0.02162388f, -0.02099783f, 0.01915752f, -0.01816203f, 0.00017137f, -0.01103845f, 
    -0.01009904f, -0.00071676f, 0.02646759f, 0.01622930f, 0.01128599f, -0.03882259f, -0.03788672f, -0.02660731f, 
    -0.03222568f, -0.01358789f, 0.00356463f, -0.02932743f, 0.00418581f, 0.01147821f, -0.01039699f, 0.02018556f, 
    0.00995890f, -0.02209437f, -0.00053458f, -0.00243081f, -0.02587130f, -0.02015682f, -0.02666994f, -0.02144955f, 
    0.02505326f, -0.02865090f, -0.00448169f, -0.02186294f, -0.01192770f, 0.01804074f, 0.00854743f, 0.00625412f, 
    0.01200929f, -0.04415115f, 0.00876504f, -0.01940440f, -0.02058670f, 0.03562116f, 0.00188852f, 0.02180576f, 
    -0.03498043f, 0.02741055f, -0.00245580f, 0.01514797f, -0.01955250f, -0.01693426f, -0.01265781f, 0.01079075f, 
    -0.00097733f, 0.01199982f, 0.03206127f, 0.02839937f, 0.02425876f, -0.02706969f, 0.02345109f, -0.00084048f, 
    -0.03757009f, 0.00991440f, -0.00081532f, -0.01501700f, 0.00615001f, -0.01363779f, 0.02878511f, 0.01539387f, 
    -0.03446748f, 0.00296744f, 0.01801607f, -0.03914413f, 0.01705469f, -0.01939938f, 0.01930324f, 0.03135471f, 
    -0.03121421f, -0.00201840f, -0.00831818f, 0.01702181f, -0.02432803f, -0.01455821f, -0.01115436f, -0.01423134f, 
    0.00879755f, -0.00918935f, -0.00764040f, -0.01755707f, 0.00332501f, -0.02584737f, -0.01582857f, 0.02507225f, 
    -0.03295917f, 0.00060968f, -0.02079307f, 0.00472198f, 0.01176356f, 0.02184504f, -0.00790775f, -0.03199379f, 
    0.02968751f, 0.01335300f, 0.00405537f, -0.00966681f, 0.02110974f, -0.02983543f, -0.01128149f, 0.01074308f, 
    0.00394322f, -0.02660370f, -0.01613054f, -0.02256615f, 0.01860953f, -0.03460454f, -0.00065819f, 0.01373115f, 
    -0.03549537f, -0.02337898f, 0.00866824f, 0.00717181f, 0.02367568f, 0.01394903f, -0.02758654f, 0.00478924f, 
    -0.04100011f, 0.08444601f, 0.05019596f, 0.31508765f, -0.03921342f, -0.00324511f, 0.01772364f, 0.01549542f, 
    -0.07749641f, -0.01022669f, -0.06620291f, -0.01340307f, 0.23795788f, 0.07023389f, 0.14411159f, 0.05266316f, 
    -0.00200228f, 0.00136509f, 0.06014033f, 0.06166907f, -0.03874141f, -0.01951932f, 0.00658794f, -0.01672085f, 
    0.12224703f, 0.03392671f, 0.15434512f, -0.17017196f, 0.11126482f, -0.08819748f, 0.09785624f, 0.03811543f, 
    0.08317376f, -0.03279460f, 0.01559302f, 0.04802731f, 0.13930190f, 0.11569300f, 0.05532922f, 0.18823008f, 
    -0.01674136f, -0.09373576f, 0.04090179f, 0.08319277f, 0.10492518f, 0.06371693f, -0.04537892f, 0.05331134f, 
    0.03291609f, 0.02180193f, 0.15824661f, -0.01632479f, -0.05486671f, 0.01337662f, 0.07546913f, -0.06097207f, 
    -0.00263384f, -0.02741005f, 0.07010937f, 0.03573090f, -0.06845642f, 0.15473275f, -0.15143788f, 0.26623750f, 
    0.01275301f, 0.05630989f, -0.01611693f, -0.07607611f, 0.01689138f, -0.08567157f, -0.00804505f, -0.00063019f, 
    -0.08303890f, -0.04114190f, 0.05193214f, -0.09558181f, -0.10310437f, 0.05009855f, -0.04565495f, -0.01298147f, 
    0.01999832f, -0.10025550f, 0.00234745f, -0.02284243f, -0.04661636f, 0.08666532f, 0.12179667f, 0.00257129f, 
    0.00598526f, -0.02452163f, 0.04213097f, 0.03643448f, 0.07186434f, -0.09871309f, 0.06621561f, 0.09590902f, 
    0.01257712f, -0.02558188f, -0.14536607f, 0.25811246f, 0.03413231f, 0.05929382f, 0.04103816f, -0.05646732f, 
    -0.00128139f, -0.02188119f, -0.01213230f, -0.03932371f, -0.05767789f, -0.11411498f, 0.22445929f, -0.11773450f, 
    -0.02064921f, 0.09053712f, 0.16771430f, 0.00524110f, 0.00280710f, 0.00131479f, -0.00310389f, 0.05337849f, 
    0.20818001f, -0.16168973f, 0.04845433f, -0.37467387f, 0.08882492f, 0.04851006f, 0.01242516f, -0.00189844f, 
    -0.08744049f, 0.01321110f, 0.12796916f, -0.02662885f, -0.30298549f, 0.09926242f, -0.13096884f, 0.14354648f, 
    0.02964962f, 0.05794042f, -0.00061931f, 0.05853507f, -0.12189109f, 0.01186769f, 0.00650633f, 0.00816979f, 
    0.05068346f, 0.21158992f, 0.01505010f, -0.07502583f, -0.07948457f, -0.07322443f, 0.12542203f, 0.11247081f, 
    0.01386552f, 0.04615141f, 0.05651424f, -0.13733546f, 0.08612873f, 0.03426721f, 0.11986497f, -0.24068365f, 
    -0.00829392f, 0.00829641f, -0.05497259f, 0.09559710f, 0.00908557f, 0.06296081f, 0.04448781f, 0.05652976f, 
    0.09336776f, -0.24961758f, 0.18261784f, -0.13551919f, -0.01273873f, 0.03795851f, 0.10998711f, 0.04217710f, 
    -0.01315134f, 0.06915476f, -0.04277095f, -0.08144984f, -0.04810245f, 0.11834366f, 0.02930231f, 0.13384582f, 
    -0.07086129f, -0.04236650f, -0.01052456f, -0.04366409f, -0.07971853f, -0.04492631f, 0.05235298f, 0.13366437f, 
    0.21804608f, -0.25263289f, -0.15560649f, 0.15421006f, -0.03191492f, 0.05689166f, -0.06157139f, 0.14188465f, 
    0.04356960f, -0.09797721f, -0.03925593f, -0.05692923f, -0.08889110f, -0.07200041f, 0.16025703f, -0.27882174f, 
    0.17321554f, -0.05577353f, 0.05665647f, 0.00215165f, -0.07053469f, -0.05739696f, 0.13921215f, -0.00804239f, 
    0.04773521f, 0.24024011f, -0.02389488f, -0.03764453f, 0.05469894f, 0.02125764f, 0.04537365f, 0.04258620f, 
    0.07118969f, -0.03849662f, 0.03966222f, -0.00549618f, 0.02742619f, 0.10756210f, 0.08310560f, 0.15072584f, 
    0.01635004f, 0.00407278f, -0.03511509f, -0.06111976f, 0.00338228f, 0.08834713f, 0.09642657f, 0.09882079f, 
    0.14936453f, 0.20043178f, -0.33473501f, 0.22345175f, 0.07684395f, 0.10948814f, -0.07745826f, -0.04998616f, 
    0.08812442f, 0.06935150f, 0.01869858f, 0.01048089f, 0.05712813f, 0.14371423f, 0.18961543f, -0.16033185f, 
    0.04192087f, 0.10005818f, 0.03577273f, -0.03139352f, 0.04149558f, 0.01105999f, 0.02254074f, 0.11310747f, 
    0.05464633f, 0.25125048f, 0.14139870f, -0.01888774f, 0.09056624f, 0.06361578f, 0.07019202f, -0.04279908f, 
    0.04412993f, 0.00630031f, 0.09931953f, 0.03372039f, 0.04676025f, -0.02647131f, 0.17923065f, -0.03626989f, 
    -0.01390479f, -0.07279854f, -0.02874132f, -0.07864230f, -0.00381300f, -0.09636322f, 0.00419117f, -0.10325923f, 
    0.19598812f, -0.08181467f, -0.24222453f, 0.00292086f, -0.13678233f, 0.09650363f, -0.11089998f, 0.14300604f, 
    0.08961028f, -0.05175374f, -0.02809792f, -0.11731175f, -0.20360850f, 0.06728455f, 0.06582873f, -0.05807807f, 
    -0.04065173f, -0.02096681f, 0.01936756f, 0.00901302f, -0.03034846f, -0.05353908f, 0.04341144f, -0.07953413f, 
    0.22425330f, 0.15106377f, -0.15902942f, 0.26604876f, -0.03080739f, 0.03427850f, -0.13780238f, 0.10670049f, 
    0.08838535f, 0.00471685f, 0.03211945f, 0.05644358f, 0.05967604f, 0.00538410f, -0.09520986f, 0.17525046f, 
    0.09488639f, 0.04904886f, -0.05984212f, 0.08927584f, 0.06549180f, 0.01800794f, -0.02239015f, -0.02927727f, 
    -0.05628952f, -0.00472415f, 0.01980570f, -0.03190903f, 0.04198007f, 0.06238382f, -0.01205844f, 0.08005618f, 
    0.00279071f, -0.07896379f, 0.08314999f, 0.04928588f, 0.23349023f, -0.25224030f, 0.11430278f, -0.20796145f, 
    0.07026950f, -0.01423165f, 0.01990163f, 0.06845189f, 0.09478477f, 0.00114913f, 0.05751993f, 0.12592208f, 
    -0.48108548f, -0.15727352f, 0.01387769f, 0.19886954f, -0.05056519f, -0.01526587f, 0.01620428f, -0.14383829f, 
    -0.04742337f, 0.01717087f, 0.06687363f, 0.07236442f, 0.05708450f, 0.14150001f, 0.02505689f, -0.09742483f, 
    -0.07112449f, -0.11241203f, -0.03187022f, -0.12913169f, -0.03307944f, 0.14375499f, 0.03060300f, 0.09714460f, 
    0.11772470f, -0.02936644f, 0.04278430f, -0.29771954f, 0.11313128f, -0.02810837f, 0.00365474f, -0.02983916f, 
    -0.03189457f, 0.02033676f, -0.05601389f, -0.07981116f, 0.13479497f, 0.08643933f, -0.06625631f, 0.07614480f, 
    0.05164833f, 0.03800239f, -0.04576989f, -0.06357048f, 0.07496749f, -0.00382649f, 0.11180843f, 0.01122199f, 
    0.07240928f, 0.16847715f, 0.09656140f, -0.06818337f, -0.09168644f, -0.06546269f, -0.03536213f, -0.01633742f, 
    -0.07630948f, 0.04005117f, 0.00829563f, 0.11884289f, 0.10763004f, -0.09600257f, -0.08634310f, 0.13060164f, 
    -0.01843869f, 0.06816871f, 0.08981613f, -0.14010568f, -0.01418438f, 0.10407809f, -0.01840746f, 0.02516952f, 
    0.12697111f, 0.12307106f, 0.06189641f, 0.16914634f, -0.09456122f, -0.01068640f, 0.00532317f, 0.06885803f, 
    -0.03614178f, 0.03606460f, 0.03461054f, -0.02929711f, -0.12913160f, -0.03808239f, 0.03969907f, 0.20204724f, 
    -0.11293616f, 0.09981427f, 0.02871402f, -0.07006180f, -0.09149223f, 0.06911330f, -0.00283764f, -0.03441061f, 
    0.15701973f, 0.05908907f, -0.23289144f, 0.21344881f, 0.08672287f, 0.07361974f, -0.08455449f, 0.03189456f, 
    0.09592111f, 0.03754476f, -0.07087103f, -0.00004860f, -0.08448807f, -0.03121673f, -0.14813885f, -0.10877001f, 
    0.03842355f, 0.03528699f, -0.04938802f, -0.04183340f, 0.01767537f, -0.03422492f, 0.01324451f, -0.09923521f, 
    0.04416404f, 0.04321493f, 0.12022343f, -0.08767664f, -0.00280614f, 0.01885970f, -0.03467447f, -0.05195675f, 
    0.01699889f, -0.10351998f, 0.04036720f, -0.07591644f, -0.07365757f, -0.06595055f, -0.00017343f, 0.17619479f, 
    -0.01809464f, -0.00205459f, -0.05504427f, 0.07730005f, -0.06154175f, -0.07736671f, 0.00966954f, -0.10801710f, 
    -0.03943733f, 0.07351090f, 0.26099288f, -0.01603012f, -0.00795313f, 0.00164525f, -0.00325524f, -0.08992822f, 
    -0.08572546f, -0.00039686f, 0.02097808f, 0.00784670f, 0.10031320f, -0.09375154f, -0.14293459f, -0.00646186f, 
    0.09444723f, -0.12304658f, -0.05503829f, 0.10694408f, 0.08551373f, 0.02553780f, 0.04396412f, 0.00158593f, 
    0.38929448f, 0.11400897f, 0.17195769f, -0.25186953f, 0.10500381f, 0.02234638f, 0.10330349f, 0.06561311f, 
    -0.02563873f, 0.00260446f, 0.10728477f, 0.02685705f, -0.12389834f, -0.14088298f, 0.09490634f, -0.09432719f, 
    -0.04514510f, -0.03264263f, -0.02868623f, 0.10503985f, 0.06731591f, 0.06806660f, 0.17488536f, 0.02847845f, 
    0.22826952f, -0.00018476f, 0.07612559f, -0.06302244f, -0.00976681f, 0.06399273f, 0.07867271f, 0.00118077f, 
    -0.04408024f, 0.12156831f, -0.11998756f, -0.00092325f, -0.30149448f, 0.07228991f, 0.03029081f, 0.18683963f, 
    -0.05451610f, 0.00984646f, 0.01579559f, 0.08406086f, -0.10138634f, 0.08231623f, -0.03931199f, -0.03383440f, 
    0.17239271f, 0.09362203f, -0.12039909f, 0.31681144f, 0.07914428f, -0.02007073f, -0.03281593f, 0.10337225f, 
    -0.03871202f, 0.09560427f, 0.06810320f, 0.08880731f, -0.02985586f, -0.21452929f, 0.09980045f, -0.03871487f, 
    -0.06142941f, -0.01671716f, -0.07045263f, -0.00943761f, -0.06864616f, 0.03534004f, 0.03689670f, -0.02903004f, 
    0.04377074f, -0.08834996f, 0.06679776f, 0.15563513f, 0.11317183f, 0.08751965f, 0.03491546f, -0.00214664f, 
    -0.06585843f, -0.08248350f, 0.02849738f, 0.05350816f, -0.03754278f, -0.10819019f, 0.02023145f, -0.19382940f, 
    -0.00824731f, 0.04002443f, 0.00737954f, -0.07383859f, -0.09194519f, 0.11868700f, 0.04416746f, -0.01074539f, 
    0.37328672f, -0.11158919f, 0.03161528f, 0.21560813f, -0.05020371f, -0.05316750f, 0.06054405f, 0.06582279f, 
    -0.02216988f, -0.04713232f, -0.06129691f, -0.00269322f, 0.06122182f, 0.24133387f, -0.12498033f, 0.01972726f, 
    -0.04668148f, -0.05469733f, 0.00603798f, 0.06137067f, 0.03666916f, 0.04194473f, -0.12479413f, 0.01902939f, 
    0.03849056f, 0.09490048f, 0.01545950f, 0.08560883f, -0.07651459f, 0.01054914f, 0.00813956f, -0.03702710f, 
    -0.02838213f, -0.04631149f, -0.07972196f, -0.08850156f, -0.05144625f, 0.17604503f, -0.05427462f, -0.01347239f, 
    -0.08929113f, -0.07155415f, -0.03991865f, 0.11050875f, -0.01091821f, -0.05144003f, 0.00165791f, -0.03462242f, 
    -0.18605377f, 0.16443922f, 0.01798244f, 0.02119244f, 0.01438117f, 0.07878664f, -0.11611697f, -0.01104835f, 
    0.06834517f, -0.01533431f, -0.08311731f, -0.04714428f, 0.40235075f, -0.10301505f, 0.08697980f, 0.26642245f, 
    0.04317715f, -0.04162033f, 0.03531274f, 0.13894843f, 0.02234011f, 0.09879497f, 0.03729023f, -0.03551865f, 
    0.04669687f, -0.07862288f, 0.14175512f, -0.22405411f, -0.13599193f, 0.03432170f, 0.14615260f, -0.10514340f, 
    0.09207855f, 0.02364838f, 0.00493368f, 0.01343505f, -0.00309207f, -0.08028600f, 0.02971427f, -0.15581490f, 
    0.04758422f, -0.06924815f, -0.01601201f, -0.00282524f, -0.06251586f, 0.08240596f, 0.01934312f, 0.05791124f, 
    -0.00208299f, -0.04602013f, 0.08285284f, -0.15139993f, 0.09869555f, -0.03018169f, 0.04165424f, 0.02594885f, 
    0.08508735f, -0.12341329f, -0.00590079f, 0.03219815f, 0.07090338f, -0.09947085f, -0.01178810f, 0.04143945f, 
    0.07952628f, 0.11319824f, 0.04728651f, -0.05629792f, -0.08077201f, 0.00218985f, 0.00661290f, 0.10533220f, 
    0.29200295f, -0.00846430f, 0.04275209f, 0.10988783f, 0.04229691f, 0.06150493f, 0.00173042f, 0.09764323f, 
    0.07484011f, -0.00287247f, -0.04565187f, 0.05378765f, -0.08474825f, -0.25685072f, 0.17888868f, -0.04835792f, 
    -0.05748216f, -0.01510182f, -0.04128595f, 0.00876937f, -0.09117068f, 0.07680283f, 0.00024987f, -0.07305558f, 
    -0.03488952f, 0.01136437f, -0.03199314f, -0.00314010f, 0.02069372f, 0.01056383f, -0.00647559f, -0.01789216f, 
    -0.03479385f, -0.02029613f, 0.01293635f, 0.01376718f, -0.02947177f, 0.01172633f, 0.00045011f, -0.02883467f, 
    0.02174164f, -0.02407796f, 0.00098922f, -0.03915156f, 0.02913516f, 0.02234494f, -0.01518643f, 0.01641867f, 
    0.03105014f, 0.01391647f, 0.02410630f, -0.02303481f, -0.02171434f, 0.01251110f, -0.03600346f, -0.02968362f, 
    0.01983500f, -0.03949394f, 0.00463203f, 0.00329320f, 0.02923527f, -0.02575930f, -0.01675268f, -0.01029513f, 
    0.02754888f, -0.04119747f, 0.00822669f, -0.00017792f, -0.03654243f, -0.00319467f, -0.00339599f, -0.00380561f, 
    0.00117929f, 0.02308007f, 0.02101941f, 0.02080909f, -0.03452453f, -0.02867154f, -0.03858145f, 0.02252124f, 
    -0.01591684f, 0.01715479f, -0.02740627f, 0.02671198f, 0.02128389f, 0.03011036f, 0.01997282f, -0.01810896f, 
    -0.03031690f, -0.02523937f, -0.02064123f, 0.02851192f, 0.02892543f, -0.03094477f, 0.01709426f, 0.03020285f, 
    0.03405162f, -0.00158676f, -0.01170671f, 0.03117111f, 0.01898033f, 0.00502761f, 0.00856367f, 0.03194106f, 
    0.01568832f, -0.03791736f, -0.02242718f, -0.04068838f, 0.03137090f, -0.03487808f, 0.02104304f, 0.00516086f, 
    -0.00763135f, 0.00710405f, 0.02903019f, -0.03435095f, -0.02358198f, 0.00198085f, -0.02384079f, -0.02310431f, 
    0.01430611f, -0.03243291f, -0.03510628f, -0.03892965f, -0.03092827f, -0.00482654f, -0.01739999f, -0.03579219f, 
    -0.00865606f, -0.02075559f, -0.03659600f, -0.03783185f, 0.01211644f, -0.03416333f, 0.02380645f, -0.03826827f, 
    -0.01699744f, -0.02109838f, -0.01210872f, -0.00136075f, -0.01768497f, 0.00220457f, 0.03533392f, -0.03060756f, 
    0.01899393f, -0.00881304f, -0.03492223f, -0.00912264f, -0.00783050f, 0.03140711f, -0.01737961f, 0.03944606f, 
    0.03152646f, -0.02488011f, -0.03051893f, -0.00395543f, 0.02823799f, -0.02913357f, -0.00259922f, 0.02256626f, 
    -0.01671899f, -0.03718134f, 0.02723477f, 0.01893924f, 0.00300102f, 0.02691328f, 0.02564111f, 0.00642415f, 
    0.01629263f, -0.04038610f, -0.01251580f, -0.03615240f, -0.03017205f, 0.00287593f, 0.02985221f, 0.01739992f, 
    0.00139037f, -0.01260266f, -0.03363384f, -0.02508679f, -0.00335449f, 0.04202874f, -0.03587291f, -0.02755726f, 
    -0.03808990f, 0.01598125f, 0.02875693f, -0.02466701f, -0.01784443f, -0.02958815f, -0.02667106f, -0.02615115f, 
    -0.00185714f, -0.02176805f, -0.01392368f, 0.02180756f, 0.01288339f, 0.00745680f, -0.02246856f, -0.03537916f, 
    -0.02243078f, -0.02929519f, -0.03218607f, 0.02695202f, -0.02225346f, -0.01331554f, 0.01160908f, 0.00893019f, 
    -0.03545980f, -0.01944549f, 0.00845823f, -0.02348154f, 0.02768566f, 0.00576807f, 0.00083378f, 0.00287016f, 
    0.00960173f, -0.00401404f, -0.01794285f, 0.02241995f, 0.02459667f, -0.02339611f, -0.00941531f, -0.01001180f, 
    0.00448208f, -0.03618257f, 0.00330548f, -0.01594434f, 0.02769981f, 0.03622566f, -0.03720473f, 0.02860799f, 
    0.00411554f, -0.00207488f, 0.02771269f, -0.02730099f, 0.02415931f, -0.01038148f, 0.00211299f, -0.03766055f, 
    -0.01879011f, 0.01064402f, -0.02255951f, -0.02265177f, -0.02107546f, 0.01470953f, -0.02943389f, 0.02570760f, 
    0.02602851f, -0.03751706f, -0.03342486f, 0.02567085f, -0.03512700f, 0.01434306f, 0.01656148f, -0.04108957f, 
    -0.00854421f, 0.00607949f, 0.03000067f, -0.03672280f, 0.01961575f, 0.02329073f, -0.02431316f, -0.03351786f, 
    -0.02637583f, 0.00728224f, -0.01594481f, 0.03045175f, 0.00312749f, -0.02477902f, -0.02196616f, 0.01245277f, 
    0.01968588f, -0.01691369f, 0.02844176f, 0.00193308f, -0.03823547f, 0.03210262f, -0.02706604f, -0.02145108f, 
    0.02771549f, -0.02719856f, -0.02276115f, 0.02743254f, 0.01182976f, 0.01843353f, 0.01225563f, -0.01871431f, 
    -0.02711662f, 0.02947218f, -0.02635257f, -0.02801120f, 0.02056351f, -0.01078527f, -0.03921945f, -0.03154366f, 
    -0.01407078f, -0.01307433f, -0.01358629f, 0.00104547f, 0.01498163f, 0.00896593f, 0.00130009f, 0.02696015f, 
    0.02129772f, 0.03028017f, 0.02380206f, 0.00220089f, 0.00958382f, 0.00648062f, -0.00333454f, -0.02749073f, 
    0.02427683f, -0.02574966f, -0.02173548f, 0.02746185f, 0.01185373f, -0.00388997f, 0.00884952f, -0.01849499f, 
    0.00672991f, -0.02278862f, 0.02024849f, 0.01898877f, -0.01462190f, -0.03147402f, -0.02426601f, -0.03022055f, 
    0.00722666f, -0.02267550f, 0.02899358f, -0.03144121f, 0.02090685f, -0.03529966f, -0.01804059f, -0.01018353f, 
    0.01875114f, -0.00300623f, -0.03457098f, -0.02872196f, 0.01632519f, -0.00583674f, -0.00511708f, -0.03404258f, 
    -0.03324331f, 0.00823178f, 0.00791875f, 0.01524496f, 0.01046230f, 0.02508379f, -0.01028298f, -0.00351634f, 
    0.02107031f, 0.01533342f, -0.00665216f, 0.02461367f, -0.02705926f, 0.01518959f, 0.00899602f, -0.02780912f, 
    0.01833126f, 0.00156141f, 0.01210873f, -0.02128092f, 0.01586992f, -0.03055282f, -0.03736942f, 0.02449826f, 
    -0.01113772f, 0.03205072f, -0.01648354f, -0.01842350f, -0.00486681f, -0.01408635f, 0.02637077f, 0.01274737f, 
    0.01011511f, 0.03088881f, 0.01358070f, 0.00778516f, 0.02391940f, 0.02254623f, -0.00740933f, -0.01300264f, 
    -0.00393131f, 0.00693803f, -0.02920644f, 0.01719146f, -0.03850824f, -0.02280645f, -0.03742436f, -0.04029838f, 
    0.01433553f, 0.03381623f, 0.02200745f, -0.01023244f, 0.00112736f, 0.02573659f, -0.02644893f, 0.02816993f, 
    0.00383213f, -0.00074762f, 0.02407722f, -0.03060106f, -0.00985461f, 0.03248398f, 0.01330662f, -0.02393969f, 
    0.02234630f, 0.01571223f, -0.01732908f, 0.02875018f, 0.01770495f, 0.03307103f, 0.00350794f, 0.02230605f, 
    -0.00497701f, 0.00007695f, -0.01110477f, 0.00372440f, -0.03644902f, 0.01180433f, -0.03045749f, -0.03106436f, 
    -0.03461456f, -0.01311933f, -0.03391008f, 0.00466156f, -0.00478458f, 0.02465495f, -0.03453121f, 0.01728970f, 
    -0.00876353f, -0.02400318f, -0.02434020f, -0.02782625f, -0.03512247f, -0.00902958f, -0.00272710f, 0.02803374f, 
    0.02472686f, 0.02082178f, -0.02920949f, 0.02405288f, 0.02244184f, -0.02795549f, 0.00454489f, 0.02376191f, 
    0.01840468f, 0.00070301f, -0.00736995f, 0.02281705f, 0.01569939f, -0.00666490f, -0.00458653f, 0.00126786f, 
    -0.02343120f, -0.01616994f, -0.03981116f, -0.00808551f, -0.00920227f, -0.02104294f, 0.01088106f, -0.01963219f, 
    0.03290392f, -0.00209427f, -0.01015384f, 0.03116674f, 0.00762475f, -0.01282101f, -0.03342348f, 0.00769843f, 
    -0.01893943f, 0.02378334f, 0.01725358f, -0.03528922f, -0.00269899f, 0.02790384f, 0.00098403f, -0.00572003f, 
    -0.03600334f, 0.01119977f, -0.00984348f, -0.00802572f, 0.00938587f, -0.03206107f, -0.03544229f, 0.02128390f, 
    -0.01910243f, -0.00517957f, -0.03186950f, -0.00339996f, 0.00818171f, -0.02721546f, 0.01374885f, -0.03469370f, 
    -0.03594130f, -0.03077803f, 0.01343777f, -0.03740470f, -0.01046618f, 0.01459615f, -0.02069289f, -0.00557676f, 
    0.00245999f, 0.00245710f, -0.03100831f, -0.01133462f, -0.03064585f, 0.02436292f, 0.03268668f, 0.02735449f, 
    0.02009975f, -0.02107054f, 0.00052840f, -0.00237421f, -0.00017498f, -0.01662385f, -0.01559913f, -0.02628761f, 
    -0.02168974f, -0.01264700f, 0.02114020f, 0.02636461f, 0.02479517f, -0.03397508f, 0.01409836f, 0.01710144f, 
    0.03422337f, 0.02483922f, -0.00783041f, -0.00345549f, 0.02059224f, -0.01042236f, -0.02623983f, 0.02666542f, 
    0.01860681f, -0.02850480f, 0.02182958f, 0.00909812f, 0.02529302f, 0.02227212f, -0.03625342f, 0.02670337f, 
    0.01602460f, -0.01132255f, 0.03462419f, -0.00258469f, -0.03273933f, 0.01300231f, -0.00907287f, 0.01556122f, 
    -0.01134489f, -0.03261891f, -0.00665496f, -0.02871035f, 0.01849852f, -0.02166443f, -0.01172389f, -0.02161221f, 
    -0.01744195f, -0.02076682f, 0.01230523f, -0.00181058f, -0.01089499f, -0.00596377f, 0.03381211f, 0.00348154f, 
    -0.00107411f, -0.03445793f, 0.02575935f, -0.00843595f, 0.02612479f, 0.02495115f, -0.02213646f, 0.00958971f, 
    0.01996977f, -0.02083884f, 0.01257279f, -0.02480393f, 0.02582052f, 0.02791430f, -0.00738466f, -0.03228810f, 
    0.01575103f, -0.01471754f, 0.01105485f, 0.01328437f, -0.00430300f, -0.03628395f, -0.03802861f, 0.00381814f, 
    -0.01354269f, 0.01753653f, -0.02363418f, -0.02946022f, -0.02124213f, 0.02413566f, -0.04216255f, -0.03345506f, 
    0.02497520f, 0.00658273f, 0.00033352f, 0.00248715f, 0.02169783f, -0.02357442f, -0.03677157f, -0.03623882f, 
    -0.02609813f, -0.01055500f, -0.01796008f, 0.01638428f, 0.03045940f, -0.00142105f, 0.02334063f, 0.02367397f, 
    0.02293654f, -0.01297341f, 0.00200516f, -0.00720975f, -0.00609970f, 0.02113782f, 0.01200338f, 0.00609297f, 
    0.01515304f, 0.01106787f, -0.00600329f, -0.02735129f, 0.01417833f, -0.00073326f, 0.02836582f, 0.00372876f, 
    -0.02490225f, -0.02867818f, 0.00397353f, -0.03097355f, 0.00190706f, -0.02319736f, -0.03695177f, -0.03226042f, 
    0.00197420f, 0.00846916f, 0.00373345f, 0.01167579f, 0.02174615f, -0.01818492f, -0.01753819f, -0.01652507f, 
    0.00477111f, -0.02249813f, -0.02181344f, 0.01623802f, 0.03185966f, 0.01425450f, -0.02208229f, 0.01105503f, 
    0.02138127f, 0.02278029f, -0.02113826f, -0.00117787f, 0.00800224f, 0.00814677f, 0.00723908f, -0.01171472f, 
    -0.03782704f, -0.02133524f, 0.00593410f, 0.03172487f, -0.01030383f, 0.00504350f, 0.01547412f, -0.00099685f, 
    -0.00343840f, -0.03420675f, -0.01796263f, 0.00535888f, 0.02886442f, -0.01016966f, 0.02225075f, 0.02716493f, 
    0.00810611f, -0.00087994f, 0.00848245f, 0.00066212f, -0.00293064f, 0.00325073f, -0.00974053f, 0.00240938f, 
    -0.01037974f, -0.01085997f, 0.00400876f, 0.00483573f, -0.01231253f, 0.00120833f, -0.02825540f, -0.02984415f, 
    -0.00864767f, -0.03829114f, 0.02328987f, -0.02538978f, -0.01145867f, 0.01887346f, -0.03530320f, 0.00597973f, 
    -0.01151062f, 0.02348843f, 0.02262266f, -0.03644923f, -0.00473879f, -0.01149641f, 0.01615943f, -0.00909953f, 
    0.01935373f, 0.00156067f, -0.00690662f, 0.01974596f, 0.01728899f, -0.03507774f, -0.02958677f, 0.02846529f, 
    -0.03760840f, -0.01308154f, -0.01109596f, 0.01874394f, 0.01458883f, -0.00383686f, -0.03860793f, 0.00850991f, 
    -0.03619023f, 0.02192475f, -0.03265706f, -0.01422835f, 0.00823304f, -0.03515601f, -0.00307935f, -0.03303644f, 
    0.02684823f, 0.01903253f, 0.03160136f, 0.02972713f, 0.02299739f, -0.02026779f, -0.00439859f, -0.03541776f, 
    -0.00341836f, -0.03787226f, -0.02545891f, -0.00355197f, 0.02944481f, -0.00356032f, -0.02131580f, 0.02609085f, 
    0.00280183f, -0.00586932f, -0.02570057f, -0.03322295f, 0.02277434f, 0.01898164f, 0.01764201f, -0.03758340f, 
    0.00102109f, -0.02939992f, -0.02834457f, 0.02349501f, 0.02119171f, 0.02221948f, 0.01077580f, 0.01808597f, 
    -0.03255987f, 0.03498340f, -0.00442897f, -0.02648444f, 0.00636266f, 0.01015220f, 0.01002429f, -0.01214872f, 
    -0.01989234f, -0.02842554f, 0.00487772f, 0.02289884f, 0.01025755f, 0.01241821f, 0.00983779f, 0.01935447f, 
    -0.03495899f, -0.01614317f, 0.00511231f, 0.01626386f, -0.01915335f, 0.00624416f, -0.01482186f, -0.00885049f, 
    -0.09997465f, 0.14599346f, 0.35160071f, 0.03154944f, 0.01885740f, 0.04066905f, -0.09759190f, 0.03374490f, 
    0.05849923f, -0.01307133f, 0.08750258f, 0.08799726f, -0.05569654f, -0.10667083f, 0.11234662f, -0.05856480f, 
    -0.02731459f, 0.15584680f, 0.06056069f, 0.03292728f, 0.19752102f, -0.05435563f, 0.03273069f, 0.15481779f, 
    -0.09863846f, 0.06751694f, 0.10815695f, 0.04538735f, 0.11597277f, -0.08743073f, 0.09980480f, -0.04400835f, 
    0.02965918f, 0.00639432f, -0.05491328f, 0.13754472f, -0.29194191f, 0.09842189f, 0.12756442f, 0.04510579f, 
    -0.00965897f, -0.09872074f, 0.03164434f, -0.01720687f, 0.04594823f, 0.02364988f, 0.07660294f, 0.11075221f, 
    0.14327143f, -0.11565077f, 0.05674798f, -0.11715262f, -0.02500107f, -0.00967512f, 0.07066222f, 0.05977130f, 
    0.05833080f, -0.09217779f, -0.01066490f, -0.01742570f, -0.10639765f, 0.00618568f, 0.01332711f, 0.16500752f, 
    0.05400358f, -0.12712495f, 0.09346225f, 0.00205072f, 0.07392842f, 0.18897419f, 0.08951325f, 0.07289335f, 
    0.15016127f, -0.05573947f, 0.02234532f, 0.04038877f, -0.07493183f, -0.00234003f, 0.06982020f, -0.00391138f, 
    0.00486039f, -0.15664621f, -0.04549148f, 0.02570992f, 0.23261935f, -0.12332806f, 0.02203696f, -0.06250258f, 
    -0.12561084f, 0.04309574f, 0.07978152f, -0.01236236f, 0.08100600f, -0.06408212f, -0.06371573f, 0.04605167f, 
    -0.04683034f, 0.00132397f, -0.12162941f, 0.06832907f, 0.01993893f, 0.03154639f, 0.03559535f, -0.01406086f, 
    0.03711776f, -0.02838698f, 0.10526776f, -0.02498120f, 0.24849126f, -0.07228830f, -0.02625533f, 0.04348248f, 
    -0.08326409f, 0.05960758f, 0.07001644f, 0.11828357f, 0.03084416f, 0.04178686f, 0.01804266f, 0.05357384f, 
    0.05610302f, 0.01193622f, 0.22593133f, 0.07554987f, 0.05391338f, -0.00865182f, -0.03233353f, 0.06159496f, 
    -0.04589259f, 0.04578576f, 0.06285438f, 0.03885678f, 0.05740198f, -0.05840183f, -0.21933459f, 0.07172906f, 
    0.03056156f, -0.00709507f, 0.01618333f, -0.00406526f, 0.05659086f, 0.05692293f, -0.06960484f, -0.03191297f, 
    -0.04061155f, -0.08630889f, -0.05604425f, -0.15446213f, 0.03981465f, 0.03126661f, 0.13018174f, 0.06710107f, 
    0.05736357f, 0.14712432f, 0.10913081f, 0.03353310f, -0.24888964f, -0.15462893f, 0.05069707f, 0.16126774f, 
    -0.03343727f, -0.02155146f, 0.02536694f, -0.03192564f, -0.01372155f, -0.02089732f, -0.06868376f, 0.05820603f, 
    0.12495992f, -0.06192373f, 0.10963464f, 0.08599710f, 0.05065853f, -0.05882107f, -0.02896217f, 0.08758961f, 
    0.04553974f, 0.04937126f, 0.22070324f, 0.05551979f, -0.10603431f, 0.03219663f, 0.07037552f, -0.19320410f, 
    -0.03148404f, 0.00212350f, 0.05288301f, 0.04152096f, -0.00324187f, -0.00570321f, -0.07100368f, 0.04310150f, 
    -0.19952802f, -0.02552905f, -0.06743814f, 0.01153446f, 0.13547911f, 0.01327631f, -0.00740846f, 0.03818484f, 
    0.04652502f, 0.07936320f, 0.03740811f, 0.09753772f, 0.21081568f, -0.18436867f, -0.10686662f, -0.15154226f, 
    0.09571372f, 0.01495698f, 0.05758584f, 0.09717888f, 0.01930991f, -0.04272445f, 0.16098702f, -0.03965304f, 
    0.00227344f, 0.06522118f, 0.17235568f, -0.04002776f, 0.12929817f, -0.00022296f, 0.04219866f, 0.04229998f, 
    0.09291900f, 0.08258741f, 0.01053446f, 0.11202398f, 0.10052053f, -0.12709546f, 0.01481462f, 0.09951250f, 
    0.04613568f, -0.04188563f, 0.11590111f, 0.04028685f, 0.07218403f, 0.08452799f, 0.05990869f, 0.19964249f, 
    -0.27917114f, -0.16004711f, -0.15759254f, 0.19740184f, 0.12777676f, 0.06142947f, -0.04817178f, -0.09514137f, 
    0.06118102f, -0.12752658f, 0.04909546f, 0.09603149f, 0.06782202f, 0.17237683f, 0.19775014f, -0.03170881f, 
    0.03879564f, 0.08755434f, -0.04387940f, 0.04743985f, 0.01446904f, 0.07459812f, -0.01759368f, 0.01847255f, 
    -0.22320659f, 0.04592236f, 0.32061487f, -0.15718785f, 0.10014757f, 0.04608962f, -0.02067384f, -0.05023618f, 
    -0.03085490f, 0.02597064f, 0.12939127f, 0.03923419f, -0.19637625f, -0.08528146f, 0.15471248f, 0.10474037f, 
    -0.00940333f, 0.06838374f, -0.04409356f, -0.06109841f, 0.06707368f, 0.07862652f, 0.17797594f, -0.01052871f, 
    -0.07589658f, -0.09517085f, -0.08478020f, -0.24437426f, 0.07282503f, 0.04389110f, -0.03823668f, 0.09615825f, 
    0.09242833f, 0.02970745f, 0.10696189f, 0.04190918f, -0.33931053f, 0.05844174f, 0.15585379f, -0.06759539f, 
    0.05574337f, 0.01274236f, 0.00890605f, 0.00443841f, 0.10844168f, 0.18134980f, 0.11339618f, 0.09561279f, 
    -0.21676454f, 0.07626417f, -0.12530658f, 0.20024203f, 0.05718077f, -0.06148143f, 0.05119452f, 0.03616481f, 
    -0.03751972f, -0.02785128f, -0.05516098f, 0.00589683f, -0.28022233f, 0.06162595f, -0.01870967f, 0.21007971f, 
    0.05881377f, 0.07314312f, -0.09286336f, 0.08010992f, -0.00485454f, 0.01564220f, 0.04389640f, -0.02207687f, 
    0.31674713f, 0.13443668f, -0.03277359f, -0.09849203f, 0.00042824f, 0.07913838f, 0.03258238f, -0.04217741f, 
    -0.01330907f, -0.09833664f, 0.05709035f, 0.04025527f, 0.19487031f, -0.08717211f, -0.05126446f, -0.12581833f, 
    0.05992751f, -0.09883951f, -0.04830769f, 0.00490038f, 0.05325504f, -0.11502944f, -0.12057948f, -0.14535215f, 
    -0.08324246f, -0.00966198f, -0.04657358f, 0.11030734f, -0.05442667f, -0.02641995f, -0.05866268f, -0.04611987f, 
    0.01462403f, -0.06991762f, -0.00368062f, 0.12873678f, -0.11684099f, -0.07786297f, -0.00011223f, -0.21656349f, 
    0.01832689f, -0.02627025f, 0.09716386f, -0.09973915f, 0.11226623f, 0.04665864f, -0.11503664f, -0.02960705f, 
    -0.17464717f, -0.09041583f, 0.02354693f, -0.02902927f, -0.01012347f, 0.08066781f, 0.10054594f, -0.08445913f, 
    0.02212115f, 0.19573745f, -0.06521524f, 0.18479779f, -0.07080906f, -0.18705471f, 0.07720999f, 0.02376655f, 
    0.05217199f, 0.03084944f, 0.02365798f, -0.01888621f, -0.00464805f, 0.22628257f, 0.05022376f, 0.07238065f, 
    0.03160502f, -0.00583354f, 0.10361299f, -0.15935864f, -0.04567334f, -0.02043688f, 0.01618187f, 0.04385943f, 
    0.08514626f, 0.03385350f, -0.07398672f, 0.16257171f, 0.17511238f, 0.04921044f, -0.17711313f, -0.09865972f, 
    -0.10981299f, -0.00385156f, 0.02510380f, -0.07805517f, 0.00250764f, 0.02747817f, 0.09640963f, -0.01218256f, 
    0.16870748f, 0.03176223f, -0.15631016f, -0.09322734f, -0.06451628f, -0.12519923f, 0.04025983f, 0.06377852f, 
    0.00751715f, 0.04918521f, -0.04557809f, -0.00739722f, 0.04904396f, -0.01687941f, -0.00959677f, -0.03088887f, 
    -0.13282996f, 0.04900946f, -0.03350232f, -0.00977808f, 0.04860667f, 0.03015836f, -0.01497909f, -0.03953303f, 
    0.02640385f, -0.12473604f, -0.08092674f, -0.07180429f, -0.03884506f, 0.14161861f, 0.05329776f, -0.01365028f, 
    0.13110811f, -0.00853676f, 0.10224951f, 0.05258955f, 0.17738219f, 0.03201591f, -0.06964194f, -0.18977593f, 
    -0.00849898f, 0.12771310f, -0.02192841f, 0.08763258f, -0.08970903f, 0.00316254f, 0.25097981f, 0.08889297f, 
    0.11959886f, -0.07453580f, 0.06395700f, -0.11920226f, -0.05491605f, -0.02979067f, -0.06390333f, -0.04339684f, 
    0.01678097f, -0.16703491f, 0.02968906f, -0.08306155f, 0.41117474f, 0.01617794f, -0.09763633f, 0.16423853f, 
    -0.13419788f, -0.08340310f, 0.08201436f, 0.13339284f, -0.06279925f, 0.00124181f, 0.07790855f, 0.00884056f, 
    -0.01176264f, -0.21546446f, 0.01304997f, -0.13836314f, -0.11099412f, 0.11950962f, 0.04851279f, -0.13196576f, 
    -0.01359235f, -0.10794586f, 0.02126795f, 0.03235312f, -0.57145882f, 0.10924216f, -0.01746430f, 0.12816903f, 
    0.18880653f, 0.10091694f, -0.02070224f, 0.11812416f, 0.00691321f, 0.04671200f, -0.05023501f, -0.03433481f, 
    0.33434978f, -0.15558791f, 0.12837379f, 0.00680243f, 0.00832790f, 0.08682349f, 0.11087328f, 0.05893676f, 
    0.03455548f, -0.12417135f, 0.04447103f, -0.04215118f, -0.13392012f, 0.01946741f, -0.00661409f, -0.00799521f, 
    -0.01100771f, 0.00405016f, -0.15322360f, 0.07234428f, 0.00554817f, -0.00795770f, 0.00683871f, -0.00221591f, 
    0.09410690f, -0.20367157f, -0.01063760f, -0.02683177f, -0.04465194f, 0.07171226f, -0.09546685f, 0.22865695f, 
    0.01315920f, 0.09368733f, 0.04999122f, 0.02712481f, 0.00871120f, 0.05246507f, -0.10054682f, 0.07926994f, 
    -0.04726456f, 0.02043859f, 0.03929686f, -0.07846706f, -0.03642017f, -0.01090262f, 0.05611311f, -0.02000972f, 
    -0.21577778f, -0.18721111f, -0.01308784f, 0.06393881f, 0.09097420f, 0.10482208f, -0.06154138f, 0.06785181f, 
    0.06040677f, 0.04032388f, -0.02371388f, 0.09386404f, 0.25336024f, -0.13625537f, 0.00853486f, 0.12678061f, 
    -0.02008003f, 0.00190168f, -0.04203272f, 0.00953403f, 0.03681730f, 0.15434049f, -0.01510399f, 0.09595219f, 
    0.25371906f, 0.09602705f, -0.05951547f, -0.00918191f, 0.10160249f, 0.07030584f, 0.08439039f, -0.07767504f, 
    0.04993372f, 0.02027442f, 0.10065807f, 0.14157251f, -0.02166397f, -0.12472448f, -0.06266726f, 0.10266196f, 
    -0.01579247f, -0.02918850f, -0.05141357f, 0.15596554f, 0.00634050f, 0.03004202f, 0.00253529f, -0.05608767f, 
    -0.00951251f, -0.03944434f, -0.01487240f, -0.20710833f, 0.15753765f, 0.03392848f, 0.05471233f, 0.02814967f, 
    0.04217536f, 0.08307803f, -0.05137212f, 0.04872578f, -0.32525337f, -0.25821990f, -0.02561885f, -0.05877726f, 
    -0.06171269f, 0.04057598f, 0.06166147f, -0.05712269f, 0.18578653f, 0.08579038f, 0.00286562f, -0.00133912f, 
    -0.32499960f, -0.03204117f, 0.23040414f, 0.01000311f, 0.06817189f, 0.11740201f, 0.10579427f, 0.00957058f, 
    0.15507284f, 0.08239558f, 0.10709987f, 0.15749350f, -0.11012221f, -0.14716138f, -0.02060624f, 0.00043032f, 
    -0.14465019f, 0.08051730f, -0.00335998f, 0.06322981f, 0.12885535f, 0.12572858f, 0.15124942f, -0.02336442f, 
    -0.49248117f, 0.03947203f, 0.10316882f, 0.26222759f, -0.06500161f, 0.08396881f, 0.08141953f, -0.10705617f, 
    0.10380871f, -0.03350236f, -0.03598436f, 0.03371188f, 0.04927611f, 0.10142867f, 0.01381124f, -0.13158873f, 
    0.17465973f, -0.06991765f, 0.00831675f, -0.00468707f, 0.04020300f, 0.06754906f, -0.16302371f, -0.07952374f, 
    0.00736934f, -0.15056583f, 0.14509799f, 0.03775023f, -0.04773090f, -0.08449545f, 0.06642934f, 0.01658843f, 
    0.11739199f, -0.07393210f, -0.08153459f, 0.07382692f, -0.05351149f, -0.13799505f, -0.08948728f, -0.02959705f, 
    -0.01811506f, 0.09324896f, 0.11797198f, -0.16546211f, -0.02210421f, 0.07967073f, 0.01225954f, 0.19136395f, 
    0.16847228f, 0.02061705f, 0.03801800f, -0.14633873f, 0.02153615f, 0.09520304f, 0.08367585f, 0.08579205f, 
    0.08538541f, 0.00801316f, -0.00337401f, 0.07675558f, 0.22082931f, -0.00886385f, -0.08973450f, -0.02739527f, 
    -0.13356945f, -0.02264252f, 0.05253373f, 0.00770357f, 0.00281427f, 0.01510026f, 0.13816488f, -0.02828575f, 
    -0.19852549f, 0.16190782f, -0.23500594f, 0.06912395f, 0.10042866f, 0.01713801f, -0.02608533f, 0.00338512f, 
    -0.04313670f, -0.02818700f, -0.03230898f, -0.01655746f, 0.09376734f, -0.15726703f, -0.06885163f, -0.10014125f, 
    0.00787691f, 0.11085351f, -0.04033985f, 0.01818916f, 0.11877907f, 0.03852279f, -0.01341060f, -0.15217388f, 
    0.04372493f, -0.09406041f, 0.09470327f, -0.01343525f, -0.01472270f, 0.05899497f, 0.02534547f, 0.02025077f, 
    0.09307542f, -0.03440064f, 0.02690171f, -0.06559215f, 0.15516792f, -0.01402702f, 0.08222420f, 0.08149599f, 
    -0.02881193f, -0.02232276f, 0.06018241f, 0.08130904f, 0.01890405f, 0.06362149f, -0.00402389f, -0.08620449f, 
    0.01870100f, 0.10438824f, 0.02977197f, -0.03502129f, -0.05970537f, 0.12143604f, 0.09783116f, 0.09472099f, 
    0.10143916f, 0.00556198f, 0.07447924f, -0.00320666f, -0.07080294f, 0.03945914f, -0.03236077f, -0.16662389f, 
    -0.22831222f, -0.04246556f, 0.07544364f, 0.05256091f, 0.07258598f, 0.18626758f, -0.04363956f, 0.00872454f, 
    0.03428690f, 0.04069029f, -0.15092979f, 0.10342794f, -0.01902088f, -0.00931954f, 0.01396382f, 0.03907008f, 
    0.03218754f, -0.00778263f, 0.03396935f, 0.12593326f, 0.14102726f, -0.07273241f, -0.06124295f, 0.11694287f, 
    -0.12442705f, 0.04467542f, 0.19670817f, 0.07602768f, -0.12341201f, -0.11622652f, 0.05244162f, -0.05138870f, 
    -0.37337160f, -0.07445972f, -0.03116963f, -0.08230907f, 0.03995450f, -0.04461812f, 0.16878600f, 0.00385915f, 
    -0.05109962f, 0.04300562f, 0.20023412f, 0.15974389f, 0.01951985f, -0.14236246f, -0.01581145f, -0.07914782f, 
    0.08928904f, 0.01096501f, -0.03330088f, 0.05999617f, -0.04742947f, -0.04658623f, 0.17915039f, 0.11196091f, 
    -0.10249627f, -0.14254078f, -0.03192966f, 0.03989546f, 0.05107271f, 0.01120053f, 0.17767343f, -0.00517952f, 
    0.07881486f, -0.00621763f, -0.05217049f, 0.00623729f, -0.11588304f, -0.01266331f, 0.08067799f, -0.01972024f, 
    0.08821478f, 0.04837330f, 0.05681733f, 0.05569597f, 0.08396620f, 0.02803133f, -0.08025367f, 0.07336807f, 
    -0.00513150f, 0.24995427f, 0.07930663f, 0.05600365f, 0.02551578f, 0.26482415f, 0.03512071f, -0.02098838f, 
    -0.02375584f, 0.13862461f, 0.21199821f, -0.01384947f, 0.15987375f, -0.09557229f, 0.11881371f, -0.00853760f, 
    -0.01188027f, 0.08912528f, 0.12467287f, 0.00055172f, -0.07838204f, 0.09027299f, 0.09106002f, 0.10304236f, 
    -0.02839213f, -0.08461245f, 0.01647557f, -0.04119834f, -0.02769994f, -0.01042960f, -0.06892110f, 0.08485290f, 
    -0.02584473f, -0.09820025f, 0.12981756f, -0.02621622f, -0.10353652f, 0.04537263f, 0.04778892f, 0.02640537f, 
    -0.06319817f, 0.16629742f, 0.03060584f, -0.00280292f, -0.07171062f, 0.07017183f, 0.04926695f, 0.20948043f, 
    0.11660524f, -0.08810528f, 0.05380572f, -0.08552694f, 0.07387375f, 0.13438325f, -0.01192375f, -0.01174945f, 
    -0.03947506f, -0.07662968f, -0.01198561f, -0.00200993f, 0.08064304f, -0.05825410f, -0.18402697f, 0.01555513f, 
    -0.05262949f, 0.12766287f, -0.05831157f, -0.02871547f, -0.03238103f, 0.11209486f, -0.09375992f, 0.00520132f, 
    -0.07056775f, -0.13340937f, 0.16475855f, 0.09594940f, -0.00484157f, 0.05138558f, -0.10091687f, -0.09191392f, 
    -0.05599200f, -0.05235402f, 0.03929713f, -0.06146067f, 0.09281638f, 0.11661835f, -0.06406755f, -0.01833400f, 
    0.05091048f, 0.06937610f, -0.01427085f, -0.07571527f, 0.00750202f, 0.08878461f, 0.08546124f, 0.02455262f, 
    -0.10367864f, 0.03128282f, 0.18870227f, 0.02771077f, 0.01989379f, 0.16160448f, 0.18417160f, 0.02677210f, 
    -0.01279560f, -0.09273866f, 0.15212746f, 0.05339214f, 0.13652819f, 0.16145749f, -0.15864097f, 0.08437826f, 
    0.00570126f, -0.02168670f, -0.10433591f, -0.02523152f, -0.04645849f, 0.07265081f, 0.06574016f, -0.09154161f, 
    0.03281463f, -0.20914277f, 0.06577662f, 0.18166764f, 0.04011321f, -0.04111588f, 0.16956194f, 0.00987305f, 
    0.04627487f, 0.01594578f, 0.02267594f, -0.11083027f, 0.26516840f, 0.28303972f, 0.16751038f, -0.21371303f, 
    -0.05249278f, 0.03957453f, 0.01463174f, 0.10584845f, 0.03220586f, 0.03149270f, 0.09684067f, 0.04975380f, 
    0.05476182f, 0.35739610f, 0.05690260f, -0.18711059f, -0.14129272f, -0.01607633f, 0.10153957f, 0.03267262f, 
    0.02380525f, 0.06753214f, -0.07121878f, 0.12265364f, -0.28673214f, -0.09362224f, 0.06204486f, -0.05005578f, 
    -0.02718378f, 0.02457788f, -0.05232074f, 0.08462148f, -0.06883994f, 0.03193356f, 0.03348542f, -0.08594880f, 
    0.02713413f, -0.20306492f, 0.02515009f, -0.02427957f, 0.09941252f, 0.06461231f, 0.08234125f, -0.00539405f, 
    -0.04686050f, -0.02904772f, -0.03299730f, -0.01342344f, -0.11107478f, 0.05621862f, 0.09481199f, -0.15558432f, 
    0.00023986f, 0.00984314f, -0.00117031f, -0.05777502f, -0.08057496f, -0.08346964f, 0.09430482f, -0.03894961f, 
    0.09687627f, -0.01318873f, 0.20610850f, 0.22450121f, -0.13050640f, 0.07539078f, 0.18989302f, -0.00047963f, 
    0.08362033f, 0.02852234f, -0.09301335f, -0.08029004f, -0.29592130f, -0.03852801f, -0.01457832f, 0.23974884f, 
    0.00415249f, 0.11998651f, -0.01568645f, -0.11291341f, -0.04969670f, 0.00538565f, -0.04358017f, -0.08169040f, 
    -0.05793790f, 0.07726732f, 0.19059274f, 0.21353379f, 0.01792024f, 0.06161095f, -0.13144283f, 0.02383566f, 
    0.09234461f, 0.06352414f, -0.07955889f, -0.12872204f, 0.14267822f, -0.07634088f, 0.02851501f, -0.03529313f, 
    -0.04736584f, 0.13278508f, 0.00454573f, 0.12996827f, 0.07868805f, 0.04999247f, 0.19928122f, 0.21945180f, 
    -0.15286525f, -0.04867201f, -0.10348199f, -0.17302917f, 0.17748019f, -0.06624129f, 0.10511823f, 0.07335863f, 
    -0.01312302f, 0.06405827f, -0.10129432f, 0.08520193f, -0.05082036f, -0.02590185f, -0.00314019f, 0.09398316f, 
    -0.16320373f, -0.09000925f, 0.00481054f, 0.03290777f, 0.01531279f, 0.05738892f, 0.10938603f, 0.12422297f, 
    0.08621468f, 0.14262748f, 0.06062305f, -0.05121140f, -0.04386495f, 0.09704990f, -0.10126315f, 0.09645956f, 
    -0.05067171f, -0.02652907f, 0.00631922f, -0.14281087f, 0.29231113f, 0.34174809f, 0.14816181f, 0.11158876f, 
    -0.01841173f, 0.01226616f, 0.16058801f, -0.07000427f, 0.08849023f, -0.08803443f, -0.08419470f, 0.09667253f, 
    0.03619542f, 0.14892036f, -0.17590006f, 0.02063107f, -0.01066334f, -0.03726411f, -0.05377664f, -0.08024301f, 
    -0.02123969f, -0.02871784f, 0.21674730f, -0.02490597f, -0.12158877f, -0.13528262f, 0.05095628f, 0.05030433f, 
    0.01992785f, -0.02594852f, 0.08889233f, 0.02718237f, -0.00615040f, 0.07212885f, -0.07183552f, 0.17147142f, 
    0.49968281f, 0.10443176f, -0.09649187f, -0.01600028f, -0.12180952f, 0.02030960f, -0.19829115f, 0.03132572f, 
    -0.07678015f, 0.09069152f, 0.10165594f, 0.09255480f, 0.03294758f, 0.02704117f, -0.11816470f, 0.08046543f, 
    0.03799478f, -0.06713064f, 0.10886030f, -0.06548098f, 0.02180563f, 0.06017524f, -0.05326411f, 0.16805685f, 
    0.00030768f, -0.24061978f, 0.17748193f, 0.06554887f, -0.03353066f, -0.05271647f, -0.00050965f, 0.05728336f, 
    -0.05206678f, -0.03240011f, -0.13423140f, -0.12448383f, 0.13865276f, 0.00337305f, 0.11964457f, 0.28261283f, 
    0.13281620f, 0.07618277f, -0.00298678f, -0.10197408f, -0.10941973f, -0.05553915f, -0.15072766f, -0.03384122f, 
    0.31047279f, -0.00564188f, 0.08329749f, 0.01256446f, 0.07057001f, 0.11115734f, 0.00126472f, -0.07245757f, 
    0.01340772f, 0.01927571f, -0.06886805f, -0.07082638f, -0.19634235f, -0.06186053f, 0.01627444f, -0.04218783f, 
    0.01790994f, 0.00361314f, -0.02286340f, -0.03762249f, -0.01246519f, 0.03947055f, 0.12072330f, -0.10010658f, 
    0.08865403f, -0.10254816f, -0.17196392f, -0.03346498f, -0.05603016f, -0.06788231f, -0.08466879f, -0.02355365f, 
    -0.14061195f, 0.10228646f, 0.15660995f, -0.03537575f, -0.15714714f, 0.22333804f, 0.04382551f, 0.16510014f, 
    -0.04972531f, -0.02259024f, 0.00539465f, -0.06901225f, -0.05755099f, 0.04871079f, 0.00506037f, 0.05346307f, 
    0.10282707f, 0.14880244f, 0.06023006f, 0.07071529f, -0.01415765f, -0.07298595f, 0.09970367f, -0.15138353f, 
    -0.01967148f, 0.17152312f, 0.13070479f, 0.06251536f, 0.11520755f, -0.07571017f, -0.14632188f, -0.13026989f, 
    0.05734195f, 0.01508470f, 0.14770120f, 0.20097297f, 0.10758725f, 0.08225188f, 0.02077788f, 0.17870253f, 
    0.04038891f, -0.20451152f, 0.24157645f, 0.21056312f, 0.07188268f, -0.02284736f, 0.14127408f, -0.04044871f, 
    -0.05701951f, 0.00308197f, 0.04619696f, -0.02829346f, 0.26630157f, 0.03482524f, 0.14547393f, 0.00532142f, 
    -0.05733089f, 0.12445230f, -0.03376945f, 0.22021776f, -0.08275084f, 0.09442303f, 0.09653992f, -0.03833861f, 
    0.29771146f, -0.02046474f, 0.19261648f, -0.01884738f, -0.02207963f, 0.04913559f, 0.11600841f, 0.02106404f, 
    -0.15588793f, 0.07812037f, 0.01655636f, 0.09925846f, 0.04665453f, -0.14210038f, -0.09268068f, -0.10202692f, 
    0.09806643f, 0.16168678f, 0.04926192f, 0.06180517f, 0.00394127f, -0.07262917f, 0.01146478f, 0.09920107f, 
    -0.04736289f, 0.12230973f, 0.13716725f, 0.25915682f, 0.04687889f, 0.04614763f, -0.01709121f, 0.05529441f, 
    0.01770021f, -0.15869778f, -0.09452424f, -0.08225919f, 0.21879669f, 0.06895644f, -0.06187981f, -0.02955698f, 
    0.08133389f, 0.03169872f, -0.01056149f, 0.02218652f, 0.05663489f, 0.03109401f, -0.05758366f, -0.10709234f, 
    0.13727301f, -0.02949067f, 0.07508453f, 0.00938227f, -0.02247289f, 0.10388010f, -0.04652082f, -0.04660200f, 
    -0.00281506f, -0.03378938f, 0.08469753f, -0.04965023f, 0.05559109f, -0.19897947f, -0.04302580f, 0.14926243f, 
    -0.00205348f, -0.00076940f, 0.01457533f, -0.11740027f, -0.06869867f, 0.07329198f, 0.08225556f, 0.04383911f, 
    -0.14555138f, 0.09370314f, 0.06337525f, -0.10765650f, -0.05116105f, -0.05171184f, 0.01279234f, 0.08771657f, 
    0.11781568f, -0.02150615f, 0.06181933f, -0.07541808f, 0.03723134f, -0.12547176f, -0.05733892f, -0.00385139f, 
    -0.05200111f, 0.11231413f, -0.05229840f, -0.09080376f, -0.06209318f, -0.06331326f, -0.03010650f, 0.05297321f, 
    -0.49876216f, 0.03803790f, 0.09902384f, 0.08541527f, -0.06705388f, -0.00306654f, -0.01778955f, 0.11378224f, 
    -0.07900823f, 0.10905002f, 0.14904891f, -0.03229059f, 0.36091498f, 0.18092351f, 0.07008414f, -0.04323566f, 
    -0.07031145f, 0.05955777f, 0.21970053f, 0.04935362f, 0.02189277f, 0.00197602f, -0.05769424f, 0.17030120f, 
    0.02736350f, -0.05739485f, -0.16917163f, -0.09812623f, -0.00865568f, 0.06942522f, 0.02819899f, 0.19530427f, 
    0.06725101f, 0.03662443f, 0.07892970f, -0.01302060f, 0.13288787f, 0.08235598f, -0.08209029f, 0.16585615f, 
    -0.02589613f, 0.15126415f, -0.12102758f, 0.06153094f, 0.01526664f, -0.04036591f, 0.18376382f, -0.13129896f, 
    -0.02581931f, 0.08914298f, 0.01847100f, 0.05184265f, -0.02878505f, -0.05847530f, 0.04963719f, 0.05641368f, 
    0.19680780f, 0.09100591f, -0.02419057f, -0.06735142f, -0.02579531f, -0.00828609f, 0.00620326f, -0.12738764f, 
    -0.03574365f, -0.02049287f, -0.05151751f, -0.02161326f, 0.17260741f, 0.18351775f, -0.00453674f, 0.15836772f, 
    -0.27300927f, 0.32716686f, 0.11182260f, 0.02872453f, -0.10358357f, 0.13489302f, 0.00304472f, 0.04970755f, 
    -0.00737226f, -0.01945683f, 0.14745881f, 0.07793857f, 0.09741264f, 0.09491701f, 0.00426889f, 0.11644065f, 
    0.07558497f, 0.05931982f, -0.01227654f, 0.10622621f, 0.11001378f, -0.11777759f, -0.00222894f, -0.05976823f, 
    -0.00829948f, -0.00073639f, -0.01253734f, 0.01060114f, -0.03560760f, -0.01839111f, -0.00696930f, -0.04091268f, 
    -0.00971692f, 0.02741890f, -0.02977157f, 0.02364120f, -0.00654254f, -0.03301999f, -0.02685309f, 0.03069723f, 
    0.00401860f, -0.00795461f, -0.00928650f, -0.03608720f, 0.02162605f, -0.02347292f, -0.01358264f, -0.02892029f, 
    -0.00913229f, -0.02618386f, -0.02990679f, -0.03336873f, -0.00949990f, -0.03052717f, 0.01812523f, -0.00652357f, 
    0.00421167f, -0.02502997f, -0.03381730f, -0.00786876f, -0.02174667f, -0.02236273f, 0.02155702f, 0.00859276f, 
    -0.02470123f, -0.00436751f, -0.03234348f, -0.01215222f, -0.00203224f, -0.03009873f, -0.01669532f, 0.01561140f, 
    -0.02298580f, 0.00346493f, 0.00935653f, -0.02408478f, 0.00795430f, 0.02253551f, -0.00501927f, 0.00709326f, 
    0.01380945f, 0.00942055f, -0.03237765f, -0.02752318f, -0.00161624f, -0.00372112f, -0.02056979f, 0.00512947f, 
    -0.00079858f, 0.02450620f, -0.01163407f, -0.01680767f, 0.02117218f, 0.02371195f, 0.01792986f, -0.03087531f, 
    -0.00009570f, 0.02442618f, 0.00286689f, 0.01555823f, -0.04042355f, 0.00542571f, -0.03071555f, -0.01784701f, 
    0.01972916f, 0.00758993f, -0.01842905f, -0.02997377f, 0.01417223f, 0.02224463f, -0.01551535f, -0.02809781f, 
    -0.01425069f, -0.00315891f, -0.01644369f, -0.01520308f, -0.01286333f, -0.00257830f, -0.00175442f, 0.01041913f, 
    -0.03020108f, -0.00605593f, 0.01572923f, 0.01348443f, 0.01683016f, -0.03309847f, 0.02555529f, -0.03075042f, 
    -0.01366264f, 0.02680584f, -0.00694401f, -0.03603080f, -0.02870600f, -0.00622453f, 0.02130739f, -0.03287774f, 
    -0.02454357f, 0.00834169f, 0.01670139f, 0.00419988f, 0.02466913f, 0.00595271f, -0.01100139f, 0.02817347f, 
    -0.01646270f, -0.02386716f, -0.03472207f, 0.02266798f, 0.01799519f, 0.01310275f, -0.02044842f, -0.02652139f, 
    0.02278829f, 0.00979079f, -0.02987752f, 0.00856968f, -0.00094429f, -0.01395345f, 0.02744102f, 0.02022894f, 
    0.02892373f, 0.02241357f, -0.02436559f, 0.03020536f, 0.01748067f, 0.02458947f, -0.03276064f, 0.03443309f, 
    -0.01707277f, -0.01494099f, 0.00435442f, 0.02028871f, 0.03107873f, -0.01161086f, -0.03472669f, -0.01456626f, 
    0.01465440f, 0.02854390f, 0.02671424f, 0.00777509f, 0.02719926f, -0.01659637f, -0.01437413f, -0.01427118f, 
    -0.01177017f, 0.02273335f, 0.01496757f, 0.01727315f, -0.00220901f, 0.03038451f, 0.01515202f, -0.02991909f, 
    -0.01017959f, 0.01648692f, 0.00658752f, 0.01972603f, -0.00000688f, 0.01349437f, -0.01698378f, -0.03436403f, 
    0.01775755f, 0.01197579f, -0.01582494f, 0.02603476f, -0.01671722f, -0.01216523f, -0.01799302f, -0.00437547f, 
    0.02101866f, -0.00441506f, 0.01389516f, -0.03050819f, -0.00467165f, 0.02110402f, -0.04079484f, -0.02044246f, 
    -0.04047839f, 0.00994556f, -0.03409021f, -0.01442619f, -0.03164306f, -0.01738007f, -0.01300915f, 0.00545168f, 
    0.01809619f, -0.02208754f, -0.01992519f, -0.04083502f, -0.00374066f, 0.00789357f, -0.01768406f, -0.03994673f, 
    -0.02292285f, -0.01137635f, 0.00688958f, -0.01127143f, 0.00579901f, -0.03148316f, -0.02802563f, -0.00504812f, 
    0.00943791f, 0.01044621f, -0.01518450f, 0.00147002f, -0.03054360f, 0.02856623f, 0.03056495f, 0.00231864f, 
    -0.03552199f, -0.00987852f, -0.00784682f, -0.00076826f, -0.01185383f, -0.00632390f, -0.03083953f, -0.02503802f, 
    -0.02036106f, -0.01800775f, 0.02341212f, 0.01970716f, -0.02149308f, 0.02119156f, -0.04060234f, 0.02194625f, 
    0.00210350f, -0.03510090f, 0.02868879f, -0.00600597f, 0.02758760f, -0.03187188f, -0.00704028f, -0.01353337f, 
    0.00069901f, -0.00636407f, -0.01716893f, 0.00859537f, 0.02106169f, -0.00021197f, 0.01600642f, -0.00666911f, 
    0.02437283f, -0.02082878f, -0.00884685f, 0.01006971f, -0.03168160f, -0.03632628f, -0.03826939f, -0.00171393f, 
    0.01794140f, 0.01830296f, -0.03040168f, 0.00871036f, 0.01199847f, -0.00537575f, 0.01899719f, -0.02162034f, 
    -0.00410108f, 0.00360380f, 0.01253726f, -0.00881446f, 0.00185995f, -0.03794359f, -0.00225628f, 0.01648084f, 
    -0.01543013f, 0.02956375f, -0.02944257f, 0.02628753f, 0.01002056f, -0.03035984f, -0.03521700f, 0.01254648f, 
    0.02709971f, 0.01855398f, 0.00395918f, -0.01590159f, -0.03687260f, 0.01609190f, -0.02303287f, 0.01087257f, 
    -0.00253225f, -0.02892345f, -0.03295416f, -0.01361514f, 0.02206707f, -0.04141808f, 0.02510481f, -0.03056543f, 
    0.02568640f, -0.01363339f, 0.00212926f, -0.00062799f, 0.00614677f, -0.01890621f, 0.02565192f, -0.01298356f, 
    -0.03896556f, 0.02746744f, -0.00568026f, -0.01403399f, -0.04066338f, -0.00714053f, -0.01647824f, -0.02163221f, 
    -0.04083883f, -0.01384056f, -0.03371654f, 0.02536524f, 0.01661643f, -0.00557956f, 0.00141366f, 0.00025376f, 
    -0.03215947f, -0.02465780f, -0.02851321f, -0.03501922f, -0.03158326f, -0.01034670f, 0.02738632f, -0.01943521f, 
    -0.01512500f, 0.00379112f, 0.02036814f, 0.00034941f, -0.01216943f, 0.01052208f, 0.00996992f, -0.01670604f, 
    -0.02204137f, -0.01267904f, 0.00848101f, -0.03681073f, -0.02321064f, 0.03342345f, 0.01674790f, -0.00545436f, 
    0.01007280f, 0.01493985f, -0.00444829f, -0.02076902f, 0.01460186f, -0.00307322f, -0.02543171f, -0.01601811f, 
    -0.00489898f, -0.00224481f, 0.02281276f, -0.03054895f, 0.02353227f, -0.02097033f, -0.00536355f, -0.01548839f, 
    -0.02837026f, -0.02731248f, -0.02476877f, 0.02284253f, 0.02185724f, -0.00948655f, -0.03168714f, -0.01287401f, 
    -0.01170581f, -0.03745428f, -0.00094832f, -0.02316158f, -0.02200557f, 0.01219875f, 0.03432795f, -0.01523850f, 
    -0.03215750f, 0.02017136f, -0.00849592f, 0.00283002f, -0.02854266f, -0.01652455f, 0.01192679f, -0.01026661f, 
    -0.03655737f, 0.02582145f, -0.01603207f, -0.00944058f, -0.02192524f, 0.03052148f, 0.02882097f, -0.02775957f, 
    -0.01642701f, -0.01967047f, -0.02860768f, 0.00177929f, -0.00544921f, 0.01873065f, -0.01817017f, 0.00652692f, 
    -0.02445897f, -0.01902533f, -0.03787173f, -0.02530425f, -0.03452868f, -0.00844071f, -0.02600255f, -0.03086111f, 
    -0.01578350f, -0.03066780f, -0.00432684f, -0.03598488f, 0.02016700f, -0.03696657f, -0.03118021f, -0.02013747f, 
    -0.00115265f, -0.01733931f, -0.01066782f, -0.03943966f, 0.01046926f, -0.01793434f, 0.01516932f, -0.02803355f, 
    -0.00602327f, -0.02390623f, -0.03398551f, 0.02832454f, 0.03034230f, 0.02711164f, -0.00815943f, -0.02487613f, 
    -0.01665956f, -0.02854376f, 0.03055290f, 0.01903222f, 0.00386729f, 0.02618473f, -0.00663783f, -0.00460958f, 
    -0.00917680f, -0.01378112f, 0.02268286f, -0.00245704f, -0.02928777f, 0.00498710f, -0.01044543f, 0.00324587f, 
    0.02748176f, 0.00539611f, -0.00185910f, -0.01764613f, -0.02883315f, -0.00483400f, -0.01248949f, -0.00903458f, 
    0.00648612f, 0.00117212f, -0.01924112f, -0.03001822f, 0.02868916f, -0.02032163f, -0.00166649f, 0.01880679f, 
    -0.00491001f, 0.00197822f, -0.03113389f, -0.02030029f, -0.02126071f, -0.01795477f, -0.03282424f, -0.03129008f, 
    -0.03451442f, -0.02384156f, -0.01372031f, 0.02440420f, -0.01848572f, -0.01096671f, 0.03018399f, 0.02402378f, 
    0.00813599f, 0.01530788f, -0.01712477f, 0.00377794f, 0.01573206f, -0.01426199f, -0.01684665f, 0.01142086f, 
    -0.00230448f, 0.00442478f, -0.03537091f, -0.03648258f, 0.01098625f, 0.02582978f, -0.02243853f, -0.01680696f, 
    -0.01129116f, -0.00733670f, -0.00902656f, 0.01520300f, 0.00280219f, 0.02259194f, -0.03511895f, -0.00044523f, 
    0.01999026f, -0.00228872f, 0.01864156f, -0.02481465f, 0.00915579f, 0.00243147f, 0.01243841f, -0.03132414f, 
    0.01201340f, -0.02886201f, 0.00915374f, 0.01469582f, -0.01579428f, 0.02695044f, -0.03321223f, -0.02042899f, 
    -0.04041867f, 0.00815472f, 0.01337545f, -0.02947493f, -0.03582287f, -0.02174005f, -0.03504732f, -0.03673857f, 
    -0.01013557f, 0.02358170f, -0.02371607f, -0.03120527f, 0.02910578f, 0.00279323f, -0.01062038f, 0.02117905f, 
    0.02466562f, 0.00567227f, 0.00834804f, -0.02747684f, -0.02668603f, -0.00764861f, -0.02311667f, 0.02330187f, 
    0.00408176f, -0.02050264f, -0.03323133f, -0.00622776f, -0.03247368f, -0.00195504f, -0.03477921f, 0.01136894f, 
    -0.01579676f, 0.00488093f, -0.01014666f, 0.00758094f, -0.01282973f, -0.01850306f, 0.01812657f, 0.02050334f, 
    -0.03962276f, -0.01969045f, 0.02384407f, -0.01186286f, -0.01957786f, -0.01187233f, -0.02958417f, -0.00648056f, 
    0.02071333f, 0.00080894f, -0.01650890f, -0.02350318f, 0.01264628f, -0.01666064f, 0.00431659f, 0.02039394f, 
    0.01247066f, -0.01416962f, -0.03414730f, -0.02026734f, 0.01237069f, -0.02775307f, -0.00293406f, -0.00193710f, 
    0.02475796f, -0.04028956f, 0.00113544f, -0.03131326f, -0.01433744f, -0.03280000f, -0.01244904f, 0.02100065f, 
    -0.03106085f, -0.03533663f, -0.00926529f, -0.01292940f, -0.00869845f, 0.02924489f, -0.01506415f, -0.01886460f, 
    -0.01917228f, -0.02956209f, -0.00169103f, -0.04014594f, 0.01088077f, -0.01839743f, -0.00272457f, -0.03296900f, 
    0.00827307f, -0.00716221f, -0.03020578f, 0.01758333f, 0.00372913f, -0.02451639f, 0.00350549f, 0.01309322f, 
    0.02834069f, -0.00557409f, -0.03823498f, -0.01768778f, 0.00563903f, 0.00811721f, 0.01696294f, -0.03753500f, 
    -0.02707566f, -0.03518848f, 0.01079933f, -0.02119729f, 0.02262057f, 0.02977984f, 0.02198853f, -0.02264167f, 
    -0.02062567f, -0.01576441f, -0.00920499f, 0.00244401f, 0.02742156f, 0.01745452f, -0.01534427f, -0.01786033f, 
    0.01991605f, 0.02539678f, 0.00333060f, -0.00526067f, 0.00982278f, -0.00180601f, -0.02753718f, -0.01478108f, 
    -0.01267734f, -0.02128126f, -0.01191364f, -0.00156448f, 0.02986837f, 0.02460685f, 0.00061845f, -0.01169929f, 
    -0.03065246f, -0.03233651f, 0.02899386f, 0.00968121f, -0.02580109f, -0.00422461f, -0.02045634f, -0.01694888f, 
    0.00312884f, 0.01018335f, -0.01342144f, -0.01791964f, 0.00346463f, 0.00304528f, 0.00894484f, -0.00333544f, 
    -0.03493426f, -0.01506175f, 0.00998621f, 0.00649707f, -0.02723464f, 0.00760242f, 0.01704309f, -0.03739588f, 
    0.01108614f, 0.00478882f, 0.01053355f, -0.02919769f, -0.02117576f, -0.03032391f, -0.01499932f, -0.03104448f, 
    -0.00882288f, 0.00909366f, -0.00793558f, -0.02889113f, 0.02985363f, -0.03185694f, -0.00688141f, 0.02278754f, 
    0.01736793f, 0.00543294f, -0.02606150f, -0.02901865f, -0.00559441f, -0.00294002f, -0.01370157f, -0.04039156f, 
    0.00552604f, 0.00292951f, -0.01187572f, -0.01656744f, -0.02942878f, 0.00748231f, 0.02509656f, 0.00554661f, 
    -0.02701063f, 0.01198259f, 0.00751062f, 0.02321651f, -0.01204083f, -0.02363986f, -0.01704912f, -0.04042324f, 
    -0.03148586f, -0.03560872f, -0.03333260f, -0.00283311f, -0.02091675f, -0.03920625f, 0.02444432f, 0.01313580f, 
    -0.00551905f, -0.03144682f, -0.02615131f, 0.00436304f, -0.00445308f, -0.03144852f, -0.01930875f, 0.00208562f, 
    -0.02116510f, 0.02472976f, 0.01885180f, 0.00977156f, -0.03772933f, 0.00812916f, -0.00677160f, 0.00227246f, 
    0.02441064f, -0.00354620f, -0.00442761f, -0.00998295f, -0.03145873f, -0.01661129f, 0.01982320f, -0.02215007f, 
    0.00144694f, -0.00366332f, -0.01416381f, -0.03061414f, -0.00797585f, -0.03685014f, 0.01859364f, -0.03200404f, 
    0.02849297f, 0.00120982f, -0.01661634f, -0.01584970f, -0.00018206f, -0.01425502f, 0.02523169f, -0.02497430f, 
    0.02225458f, 0.00450550f, 0.02795442f, 0.02455320f, 0.00959242f, 0.02312037f, -0.02941735f, -0.03999861f, 
    0.01768574f, -0.02486565f, -0.03670372f, 0.00036811f, 0.01583561f, 0.01015732f, 0.02223266f, -0.00834424f, 
    0.00337596f, -0.01710212f, -0.01184080f, 0.02727531f, -0.00334878f, 0.00468202f, 0.01550385f, 0.01967342f, 
    -0.02191205f, 0.00867264f, 0.00211973f, 0.01428065f, 0.02559386f, -0.00342182f, -0.01987009f, 0.00722542f, 
    0.02166267f, 0.00314528f, -0.02721667f, -0.00168100f, -0.00680183f, -0.04138135f, -0.03824450f, 0.02630815f, 
    0.00991926f, -0.00145420f, -0.00376577f, -0.01232954f, -0.01599405f, -0.01778029f, 0.00271493f, -0.02282736f, 
    -0.01767055f, -0.02160959f, -0.01196682f, -0.00648871f, -0.00818659f, 0.02125829f, -0.00604731f, -0.01415524f, 
    -0.03274132f, -0.02546201f, -0.03005284f, -0.01631351f, -0.02464344f, 0.02640419f, -0.00808692f, -0.04055417f, 
    -0.02921845f, 0.00754841f, -0.03460322f, -0.03455796f, 0.00298224f, -0.02024367f, -0.01333047f, 0.01357093f, 
    -0.02366145f, 0.00244558f, -0.01844486f, -0.03980892f, -0.00237754f, 0.02645623f, -0.01316390f, -0.02950914f, 
    -0.00023013f, -0.02073708f, -0.03497877f, 0.02697705f, -0.03077400f, 0.00953121f, 0.01291830f, -0.03376148f, 
    0.02264549f, -0.01293263f, 0.02654422f, 0.00823245f, 0.01647199f, -0.03983190f, -0.02960071f, -0.03638853f, 
    0.01353557f, -0.03206050f, 0.00662515f, -0.00216150f, -0.02226647f, -0.03220452f, -0.00659424f, -0.01592834f, 
    0.01009856f, -0.00661160f, 0.02215086f, -0.00997219f, -0.01993295f, -0.00763365f, -0.04019941f, 0.00156194f, 
    -0.03584962f, -0.01652729f, 0.01782501f, -0.03457692f, -0.01872247f, -0.02341226f, -0.00382806f, 0.00969167f, 
    -0.02499042f, -0.00997204f, 0.01333792f, -0.01174300f, -0.02591211f, -0.00711707f, 0.00214755f, 0.02984156f, 
    -0.02786299f, 0.00640911f, -0.00272262f, 0.00020108f, -0.02320403f, -0.00107696f, -0.01813301f, -0.02688271f, 
    -0.01926866f, -0.01221291f, 0.01926994f, 0.00302666f, -0.02480474f, 0.00222118f, 0.02596219f, 0.02089828f, 
    0.01528794f, 0.02264035f, -0.01590035f, 0.01997641f, -0.03576314f, -0.02954210f, -0.01364894f, -0.02081352f, 
    0.02678415f, 0.01338852f, 0.02380013f, -0.04202081f, -0.02878635f, -0.01272426f, 0.02206112f, 0.00184689f, 
    0.00397839f, -0.03820638f, 0.01437865f, -0.01976642f, -0.00414927f, 0.00058946f, -0.03478400f, -0.01707068f, 
    -0.02356453f, -0.01387437f, -0.03403489f, 0.02648995f, -0.02332698f, -0.02310070f, -0.00203508f, -0.02812055f, 
    -0.02294707f, -0.03166702f, -0.01131598f, -0.03327804f, 0.01354861f, -0.00807246f, -0.00692941f, -0.02307246f, 
    -0.02465277f, 0.02059318f, 0.01843426f, -0.01329410f, -0.01077012f, 0.01102508f, -0.03737497f, 0.00053110f, 
    -0.03014540f, -0.00296055f, 0.01228961f, -0.02520966f, 0.00881152f, 0.02665824f, -0.02469151f, -0.01942540f, 
    0.00084170f, -0.01820207f, -0.00236259f, 0.01357957f, -0.03754532f, 0.02130098f, -0.03752072f, -0.01927274f, 
    -0.03789658f, 0.02068798f, 0.02573664f, -0.00569776f, -0.02604743f, -0.03897923f, -0.00750744f, 0.02817442f, 
    0.00956352f, -0.03034466f, -0.00458768f, -0.04000488f, -0.02843795f, -0.01447845f, -0.03613061f, -0.03389164f, 
    0.02149419f, -0.01556851f, -0.02612331f, -0.00435505f, 0.01850959f, -0.01141640f, -0.03922193f, -0.00409027f, 
    -0.00266650f, -0.03238692f, 0.00297859f, 0.01780374f, -0.01395875f, -0.01125169f, 0.02554438f, 0.01137650f, 
    -0.02292042f, 0.01125320f, 0.00133014f, -0.01278012f, -0.02940892f, -0.01174961f, 0.00554657f, 0.00239316f, 
    0.02740086f, -0.02988556f, 0.00055818f, 0.01358135f, -0.03605117f, 0.02385655f, 0.02003380f, -0.04042046f, 
    -0.00504129f, -0.01798629f, 0.01007371f, 0.01493801f, -0.02029450f, -0.00066911f, 0.02197492f, 0.01233650f, 
    0.00479237f, -0.01913933f, -0.01498705f, 0.02206589f, -0.01594070f, -0.03790386f, 0.00190219f, -0.03067864f, 
    0.02821587f, -0.01649501f, 0.02047371f, -0.00364998f, 0.00731934f, -0.02581639f, 0.01874328f, 0.02159320f, 
    0.02377803f, 0.02050295f, 0.00148165f, -0.03199706f, 0.00094968f, 0.01085033f, 0.02221737f, 0.01203721f, 
    -0.02988249f, -0.00356344f, 0.02478395f, -0.02316677f, 0.00723071f, -0.02878645f, 0.00790306f, -0.02501847f, 
    -0.01267789f, -0.03109102f, 0.00732269f, -0.01500705f, -0.01818612f, -0.01909315f, -0.00814913f, -0.03273604f, 
    0.00142965f, -0.00135081f, 0.02848667f, 0.02939918f, 0.01036377f, -0.02652190f, 0.00752929f, -0.01099254f, 
    -0.02216432f, 0.00333935f, 0.01885627f, -0.01272338f, -0.00065048f, -0.03739778f, -0.00223115f, -0.02951327f, 
    0.01528090f, 0.00915009f, 0.00731470f, -0.02920427f, 0.00294538f, 0.02607000f, -0.00741380f, -0.02527870f, 
    -0.02648896f, 0.00601476f, -0.02061935f, 0.02727932f, 0.00831365f, -0.04000567f, 0.00320866f, -0.00099604f, 
    -0.01383549f, -0.02657932f, 0.01493286f, 0.02669519f, 0.01087195f, 0.03332850f, -0.02967978f, -0.01187586f, 
    -0.02565175f, 0.01318039f, 0.02940894f, -0.04096678f, 0.01050820f, 0.00564132f, -0.01857540f, -0.02121228f, 
    -0.02446892f, 0.02791537f, -0.02899872f, -0.02367534f, -0.00657118f, 0.01430666f, -0.01591128f, -0.01758237f, 
    0.00810868f, -0.03913786f, 0.02678674f, -0.03840597f, -0.01862633f, -0.01815866f, 0.01577159f, -0.01758680f, 
    0.02037089f, -0.00704655f, -0.00411474f, -0.00638381f, 0.01685578f, -0.01111184f, -0.03154236f, 0.00157488f, 
    -0.02294017f, -0.01408055f, 0.00825963f, 0.01892712f, 0.00548298f, -0.00654325f, 0.01975837f, -0.00267259f, 
    0.01336664f, -0.00356367f, 0.02873163f, -0.03901356f, 0.02149217f, -0.02085127f, -0.01190819f, -0.01753980f, 
    0.02163774f, 0.01733216f, -0.03001880f, 0.00498530f, 0.02129635f, -0.03578581f, -0.03624852f, -0.02431772f, 
    -0.02503228f, 0.02496324f, -0.02808524f, -0.03506034f, 0.01621248f, -0.00901088f, -0.02588563f, 0.00224958f, 
    0.00328284f, -0.00814266f, -0.00905816f, 0.01948029f, -0.02041936f, 0.01105704f, -0.02927513f, -0.03148739f, 
    0.01278298f, -0.03191167f, 0.00678823f, -0.00153341f, 0.01963926f, -0.02061299f, -0.02290639f, -0.01949508f, 
    -0.02580390f, -0.03022466f, 0.01650974f, -0.03147450f, -0.03358869f, -0.01646242f, 0.00687133f, -0.03342561f, 
    0.00488446f, 0.01123008f, 0.01069543f, 0.02316293f, 0.00215463f, 0.01643404f, 0.00297005f, 0.00290978f, 
    -0.02723183f, -0.04040898f, -0.00734133f, -0.01993447f, -0.00958065f, -0.02813482f, -0.00453917f, 0.00812659f, 
    0.00831260f, 0.01231860f, 0.01654753f, 0.00127726f, 0.02447396f, 0.01170171f, -0.01562037f, 0.00560672f, 
    0.02801270f, 0.01119303f, 0.01564825f, 0.00635074f, -0.01167756f, -0.03214223f, 0.02188724f, -0.03992557f, 
    0.02284474f, -0.01780888f, -0.00357202f, 0.02523399f, 0.02997693f, 0.00466361f, 0.01129391f, -0.04149098f, 
    0.00584462f, -0.02090113f, -0.01049841f, -0.02510571f, -0.00637995f, -0.02909868f, -0.01801156f, 0.00991256f, 
    -0.02689202f, -0.00759942f, 0.00832923f, -0.01213959f, -0.03194210f, 0.02134362f, 0.00818312f, -0.03139930f, 
    -0.00461521f, -0.02209728f, -0.00238830f, 0.02498926f, -0.00932774f, -0.01154247f, -0.00513431f, -0.02978121f, 
    -0.01047025f, -0.01016620f, 0.02744451f, -0.01097595f, -0.01577247f, -0.00585383f, -0.01399333f, 0.00768127f, 
    -0.00749751f, -0.03262203f, -0.00185855f, -0.01713845f, -0.03316048f, 0.02473916f, 0.01911657f, -0.02179554f, 
    0.02060653f, -0.01747355f, 0.00007331f, 0.02068762f, -0.03359008f, -0.01681587f, 0.00520812f, -0.01509476f, 
    -0.00555579f, 0.00894302f, 0.01731826f, 0.00978235f, 0.02873985f, -0.03261041f, 0.01183631f, -0.01469321f, 
    -0.01368597f, -0.03584317f, -0.03387733f, 0.02257993f, -0.01221323f, -0.03544966f, 0.02720549f, -0.00798218f, 
    0.02581001f, 0.02099222f, -0.00644317f, -0.03899610f, -0.00381803f, 0.01010419f, 0.02743864f, 0.00947714f, 
    0.00294120f, 0.02456241f, -0.02086010f, -0.01572376f, 0.01801336f, 0.00894972f, -0.01371779f, 0.00514495f, 
    -0.02160384f, -0.04010274f, 0.01481805f, -0.02464310f, 0.00054219f, -0.03473656f, -0.01397063f, 0.01556601f, 
    -0.02580795f, -0.00479529f, 0.02178130f, -0.01333353f, -0.01040478f, -0.03795339f, 0.00439531f, -0.01332710f, 
    0.01058756f, 0.00856380f, -0.03749508f, -0.02589832f, -0.02945263f, -0.03025803f, -0.03928309f, -0.03912110f, 
    0.01052881f, -0.00383713f, -0.03799373f, 0.02173543f, -0.02830148f, -0.02192589f, 0.01616214f, 0.00281347f, 
    -0.03035308f, -0.01074481f, 0.00848589f, -0.01326613f, -0.03712034f, -0.01076310f, -0.03032447f, -0.00555452f, 
    -0.03366823f, 0.01344404f, -0.01165115f, -0.01062384f, -0.02907980f, 0.01621426f, 0.00589653f, -0.04165937f, 
    -0.03769781f, -0.03658748f, -0.01207470f, -0.02206659f, -0.00618329f, 0.03126350f, -0.02765532f, 0.02566263f, 
    -0.02109502f, -0.01913538f, -0.02760584f, -0.02401507f, 0.00494264f, -0.00899900f, -0.03792688f, -0.03735508f, 
    -0.03465617f, 0.00947480f, 0.00868931f, -0.01237573f, 0.02266034f, -0.01063262f, 0.01036068f, 0.01067372f, 
    -0.03972404f, -0.03603788f, -0.02283540f, 0.00704712f, -0.03214326f, 0.01062618f, 0.01049756f, 0.01534737f, 
    -0.00498773f, -0.02260140f, -0.04187200f, -0.01452947f, -0.03666804f, 0.00772612f, -0.01779863f, -0.01154832f, 
    0.01249245f, 0.01044316f, -0.03447767f, 0.00134561f, -0.01776788f, -0.01497758f, 0.01458844f, -0.03973527f, 
    -0.01240514f, 0.00033188f, 0.01667595f, 0.01969851f, -0.01433632f, 0.00265551f, -0.03117502f, 0.01854324f, 
    -0.02273054f, 0.00161539f, -0.01025355f, -0.03229645f, -0.03554443f, -0.01412671f, -0.00351011f, -0.00361197f, 
    -0.01162206f, -0.02470138f, 0.00103951f, 0.00879762f, 0.01839285f, -0.04022559f, -0.00543006f, -0.01127574f, 
    -0.01993772f, -0.00827409f, -0.04178616f, -0.01967528f, 0.02839463f, 0.00161260f, 0.02149426f, -0.02771156f, 
    0.02427199f, 0.02428656f, -0.02019899f, 0.02373580f, 0.00160867f, -0.02222462f, 0.00781163f, 0.00459235f, 
    -0.00249394f, -0.02566582f, 0.00412320f, -0.01239267f, -0.00592487f, -0.04087922f, 0.02846726f, -0.01671999f, 
    0.02989561f, 0.01428843f, -0.01375167f, -0.03426217f, -0.03902747f, 0.01074955f, 0.02242024f, -0.02417572f, 
    0.01307485f, 0.00382137f, 0.01169760f, -0.00194766f, -0.02156635f, 0.00829156f, 0.01611448f, -0.01399074f, 
    -0.01735709f, -0.03196418f, -0.02216078f, -0.01174868f, -0.04108237f, -0.03512943f, -0.02581082f, -0.02318728f, 
    0.02803800f, -0.01195530f, -0.00907656f, -0.03984225f, -0.01437053f, 0.01927024f, 0.00822020f, 0.00418974f, 
    -0.03669082f, -0.01425834f, -0.01353020f, -0.03289931f, 0.02695675f, -0.03411727f, -0.03202496f, -0.02076134f, 
    -0.00827687f, -0.01283082f, -0.01938467f, -0.03075545f, 0.02667191f, -0.03594269f, 0.02212088f, -0.00134252f, 
    0.02036319f, -0.03087574f, 0.01388278f, -0.00722359f, -0.02639818f, -0.02480870f, -0.02504235f, -0.02180418f, 
    -0.03167564f, -0.00422138f, 0.00041224f, -0.00324948f, 0.02216376f, 0.01106802f, 0.02569821f, 0.01371454f, 
    0.12260976f, -0.16512072f, -0.02781358f, 0.11714162f, 0.02029113f, -0.07882003f, 0.01907185f, 0.04837303f, 
    -0.01746873f, -0.04928080f, 0.03065277f, -0.08856569f, -0.04267896f, -0.47898856f, -0.03092701f, 0.14151250f, 
    0.12254971f, -0.05164397f, -0.09747496f, -0.04564862f, 0.00385758f, 0.16689031f, -0.06491023f, 0.08588072f, 
    -0.02130235f, -0.08839856f, -0.11659451f, -0.13815336f, 0.03325589f, -0.00589947f, 0.01591051f, 0.05730934f, 
    -0.06488534f, 0.00801226f, 0.00657988f, 0.07650355f, 0.22486493f, -0.07122087f, -0.02496022f, 0.03588243f, 
    -0.14049548f, -0.04793125f, -0.05348521f, -0.01303071f, 0.01568538f, -0.06216798f, 0.06465288f, -0.03164519f, 
    0.50534159f, 0.18946950f, 0.02338599f, 0.13364263f, -0.11106561f, -0.01347251f, 0.03085424f, 0.05296675f, 
    0.05534993f, -0.07050750f, 0.07699495f, -0.05409463f, -0.05838458f, -0.08467584f, 0.16471156f, -0.11451195f, 
    -0.05127282f, 0.16031596f, 0.06578638f, 0.01777751f, 0.02062192f, -0.02320172f, -0.01911420f, -0.01650236f, 
    -0.11538193f, -0.11756375f, -0.06546921f, 0.09292807f, 0.10727212f, -0.01717095f, 0.00745877f, 0.16591403f, 
    0.05698657f, 0.00508888f, 0.03808969f, -0.01987179f, 0.45856723f, -0.20389438f, 0.09292383f, 0.13165954f, 
    0.01567710f, -0.07133777f, 0.06866390f, -0.02945241f, 0.14445375f, -0.03370334f, -0.01110553f, 0.06305122f, 
    -0.01942895f, -0.27450016f, 0.13361877f, 0.07921556f, -0.02451274f, 0.06105057f, 0.05037908f, 0.09383557f, 
    0.00523506f, -0.03500608f, -0.06740460f, 0.01999771f, 0.27640006f, 0.12601772f, -0.00451496f, 0.11818691f, 
    0.03116849f, 0.12244476f, -0.04956213f, 0.07405493f, -0.01744204f, -0.02191384f, 0.05688028f, -0.05265604f, 
    0.31855750f, -0.09555073f, -0.18168865f, -0.14589603f, 0.06564347f, 0.00500247f, 0.10766746f, -0.05896344f, 
    -0.20130596f, -0.05150669f, 0.11501463f, 0.12397281f, 0.02732315f, -0.03897430f, -0.15604843f, 0.01672391f, 
    -0.13418369f, -0.11260831f, -0.00413340f, 0.04707861f, -0.00762082f, 0.13165459f, 0.01927557f, -0.02606112f, 
    0.36125886f, 0.02955098f, 0.12619524f, 0.02520144f, -0.09715168f, -0.03097036f, 0.05965522f, -0.12709226f, 
    0.17872235f, -0.10392267f, 0.05424430f, 0.12009202f, -0.20327748f, 0.06468187f, 0.02156112f, -0.06164607f, 
    -0.00072469f, 0.02572971f, 0.10875695f, 0.01503643f, 0.08013033f, 0.04309864f, 0.18095239f, 0.07613847f, 
    0.16904475f, -0.30152714f, 0.02641568f, 0.26951110f, -0.11700607f, 0.06696588f, 0.08571376f, -0.01995105f, 
    0.06322610f, -0.12217735f, 0.12491605f, 0.03412500f, -0.11430409f, 0.21272928f, 0.11997623f, -0.08331156f, 
    -0.09669615f, -0.01246937f, -0.03728098f, -0.02704788f, 0.03152045f, -0.03364142f, 0.05088864f, -0.05369297f, 
    -0.10127646f, -0.00021174f, -0.02240429f, -0.09424933f, -0.07828119f, 0.16144095f, 0.00488994f, 0.05094130f, 
    0.17477386f, 0.10389403f, -0.03696981f, -0.14992486f, 0.20604788f, 0.10057355f, -0.02786669f, -0.03001653f, 
    -0.16677801f, -0.03927181f, 0.03427586f, -0.02165324f, 0.03376281f, -0.05497643f, -0.01024083f, 0.04263020f, 
    0.00015478f, 0.17166100f, 0.07269248f, -0.11644451f, 0.05392342f, 0.00049834f, -0.01908339f, 0.04784804f, 
    -0.07917859f, 0.01422976f, 0.12839971f, -0.06837153f, 0.06239185f, 0.17457387f, -0.00450011f, 0.12938532f, 
    -0.06759135f, 0.08479889f, -0.00089956f, 0.08188378f, -0.02597428f, -0.05977374f, -0.03795526f, 0.04021535f, 
    0.25232518f, -0.13518043f, 0.02451838f, -0.01356146f, 0.03367231f, -0.16701733f, 0.02839767f, -0.09116916f, 
    -0.04270837f, 0.16984639f, 0.02149768f, -0.03995495f, 0.01237989f, 0.10323218f, -0.17704128f, -0.03526821f, 
    0.18837576f, 0.02075279f, -0.09581883f, -0.00012296f, 0.10934517f, 0.17476845f, -0.12662970f, 0.01370002f, 
    0.13759620f, 0.08374347f, -0.11285029f, 0.22576392f, 0.09847847f, 0.04174941f, -0.04146044f, 0.00447615f, 
    0.07046167f, 0.00061524f, -0.06590120f, -0.11420638f, -0.07580291f, -0.36869729f, 0.09377041f, -0.03308770f, 
    0.03263748f, -0.04327162f, 0.00638989f, 0.01418150f, 0.04747926f, 0.00052572f, -0.07134912f, -0.02416265f, 
    0.12066826f, -0.20544541f, 0.20519753f, 0.09268512f, -0.04683383f, -0.00923586f, -0.05035434f, -0.00718858f, 
    -0.06183987f, -0.07647061f, -0.04681807f, -0.07235459f, 0.07289784f, 0.19726975f, -0.14140728f, 0.15607139f, 
    0.08936685f, -0.03413721f, -0.01687418f, 0.00790857f, 0.07815544f, -0.00602503f, 0.00776636f, 0.18553481f, 
    0.20352668f, -0.13340397f, 0.01848277f, 0.04672205f, -0.02412036f, -0.09958740f, 0.01265093f, -0.07785196f, 
    0.15826480f, 0.09942143f, -0.11138991f, 0.12563471f, -0.12618124f, 0.04334962f, 0.01308428f, -0.03173031f, 
    0.06966405f, 0.12530382f, -0.06125730f, 0.16163918f, 0.14558268f, 0.05464090f, -0.04844016f, -0.10694002f, 
    0.11356578f, 0.27412736f, -0.16379397f, -0.03078715f, 0.07261263f, 0.05851800f, 0.04616804f, 0.06181700f, 
    -0.00208818f, -0.01512321f, -0.07064015f, -0.18536495f, -0.08921382f, -0.20028566f, -0.15341407f, -0.06936628f, 
    -0.07844330f, 0.16151153f, -0.08805974f, -0.13184549f, -0.04869184f, 0.09139530f, 0.09874419f, -0.05161975f, 
    0.28836480f, 0.02297015f, 0.12738800f, 0.00140020f, -0.00919066f, -0.02935040f, 0.00897697f, 0.19285771f, 
    -0.06881122f, -0.02311489f, 0.05491143f, 0.00423218f, 0.02336968f, -0.02100639f, 0.07244266f, -0.30863291f, 
    -0.17824639f, -0.07248500f, 0.02546064f, -0.17331617f, -0.02453355f, 0.10591587f, 0.02862156f, -0.02005367f, 
    0.12530951f, 0.11505403f, -0.04488110f, 0.08543073f, 0.06468111f, -0.02920364f, 0.04711477f, -0.07132005f, 
    -0.04118055f, 0.13864748f, 0.03418968f, 0.07506180f, -0.23249218f, -0.20093554f, -0.17713988f, 0.05220405f, 
    -0.01972077f, 0.15614176f, -0.00610806f, 0.18290243f, 0.00590299f, -0.01678643f, -0.06528830f, 0.00964561f, 
    0.23901694f, -0.11845514f, 0.18013336f, -0.12286599f, -0.08339520f, 0.07731026f, 0.00297136f, 0.10550384f, 
    0.10207523f, -0.09798617f, 0.14220721f, -0.00448825f, 0.21702115f, -0.02494038f, 0.02278808f, -0.08447748f, 
    -0.07734287f, -0.05411897f, 0.02476986f, -0.03990757f, -0.07574900f, -0.01721882f, 0.05291526f, -0.12260509f, 
    -0.14617148f, 0.02648820f, -0.22078632f, 0.01476153f, -0.06760621f, 0.03052731f, -0.06327263f, -0.03237362f, 
    0.02051682f, 0.06339613f, -0.04872789f, 0.02500494f, 0.10927765f, 0.02541085f, 0.08860943f, -0.01002820f, 
    -0.13145906f, -0.04415204f, 0.01342330f, -0.03472794f, 0.06215346f, 0.04141089f, -0.04026070f, -0.01481206f, 
    0.26510093f, -0.20227690f, -0.09482025f, -0.20918779f, 0.27956802f, -0.05761886f, 0.15641142f, 0.01888760f, 
    -0.10846768f, 0.15441321f, -0.03886121f, -0.02278260f, -0.11510935f, 0.02869049f, -0.01103545f, -0.14180787f, 
    0.10033014f, 0.13777313f, 0.00073751f, 0.02803922f, 0.04286397f, -0.01732558f, -0.10323482f, -0.08659816f, 
    -0.13257901f, -0.06868525f, -0.06533754f, -0.06548253f, 0.05077093f, -0.04654537f, -0.04452129f, -0.05993157f, 
    0.03316238f, -0.11661177f, -0.01206775f, -0.22682068f, 0.06146796f, -0.14196248f, 0.05502044f, 0.05554676f, 
    0.03847830f, 0.08372107f, -0.02126580f, -0.01961816f, -0.16008505f, -0.04338662f, 0.08337159f, 0.02455445f, 
    0.36985934f, 0.03984375f, 0.08102185f, -0.05277698f, -0.06862231f, -0.10326013f, -0.04287923f, -0.12942004f, 
    0.04886891f, -0.08157869f, 0.04163503f, -0.04248870f, 0.21770413f, 0.26151806f, -0.05851316f, -0.25762510f, 
    -0.16605942f, -0.01171736f, 0.06028396f, 0.08271272f, 0.08351325f, -0.04137341f, 0.03562386f, 0.09342517f, 
    0.29469764f, -0.15905975f, 0.05912834f, -0.03375960f, 0.13255639f, 0.07169428f, 0.01226652f, 0.08357443f, 
    0.12434363f, 0.00200701f, -0.04314246f, -0.02501486f, 0.30027503f, -0.06331413f, 0.00529480f, 0.10770208f, 
    0.03293120f, -0.07965338f, -0.12790948f, 0.16775568f, -0.05785948f, 0.00801794f, 0.02900854f, 0.01026454f, 
    0.37675595f, -0.05944913f, -0.03364273f, 0.16312118f, 0.14153817f, 0.05115891f, 0.15952477f, -0.09304283f, 
    -0.07253639f, 0.04369349f, 0.09620422f, -0.03889916f, -0.36313519f, -0.05764193f, -0.18425123f, -0.09395235f, 
    -0.07775500f, 0.07447583f, 0.02537440f, 0.02139278f, -0.04489841f, 0.01876768f, 0.07633749f, -0.05787809f, 
    0.38979951f, -0.31538349f, -0.14975107f, -0.14959508f, 0.07661054f, -0.04523611f, 0.00753388f, -0.05308177f, 
    0.10218009f, 0.03887769f, 0.07070962f, -0.02956092f, 0.20539890f, -0.06767671f, -0.00952348f, 0.09410313f, 
    0.09799208f, 0.01130615f, -0.09929490f, 0.16945863f, -0.13211292f, 0.16256446f, -0.01924110f, 0.03154857f, 
    0.16821775f, 0.26273635f, -0.24135801f, 0.02232622f, -0.05821335f, 0.01642939f, -0.03142471f, 0.00868349f, 
    -0.00201205f, 0.04065230f, 0.03779205f, -0.04340765f, 0.38158813f, -0.15842639f, 0.09953799f, 0.19374409f, 
    -0.15951353f, 0.08273349f, 0.03777157f, 0.07827011f, -0.11493878f, -0.00775634f, 0.08098789f, -0.02626683f, 
    -0.08808700f, 0.13838807f, -0.33709434f, -0.05537621f, -0.04283503f, 0.03398556f, 0.01292000f, -0.06974323f, 
    0.04274330f, 0.02854752f, 0.11705700f, -0.03466736f, -0.14961271f, -0.00906994f, 0.03546320f, -0.05254886f, 
    0.06991597f, -0.12661052f, -0.04722530f, -0.04720367f, 0.11348227f, 0.04922903f, 0.10562418f, 0.09711957f, 
    0.27366260f, -0.14860298f, 0.02406025f, 0.00166848f, 0.01654363f, 0.09428208f, 0.03911170f, -0.04831544f, 
    0.04784301f, -0.01087378f, 0.03588913f, -0.03593741f, 0.21955240f, 0.30916116f, -0.00929379f, 0.11582249f, 
    -0.11053212f, -0.10182461f, 0.02897146f, -0.02744022f, 0.10992937f, 0.00811674f, -0.06796953f, 0.18481261f, 
    -0.02444503f, 0.08541781f, 0.12414264f, -0.15402031f, -0.02087026f, 0.13193908f, -0.02691347f, 0.07672115f, 
    0.00425387f, 0.12706974f, 0.12285504f, 0.05907143f, 0.23087399f, 0.01411165f, -0.23198606f, -0.10140868f, 
    0.13174486f, 0.13722685f, -0.04187854f, -0.19894509f, -0.01270335f, 0.03527467f, -0.01110043f, 0.08286493f, 
    0.05517980f, -0.33711171f, 0.09479528f, -0.06065534f, 0.04300895f, 0.01545438f, -0.11641081f, 0.15584652f, 
    0.06880309f, 0.13378973f, 0.10194308f, 0.04684115f, -0.00295810f, -0.05066600f, 0.04503088f, -0.10702072f, 
    -0.10585762f, -0.03114515f, -0.04113104f, 0.10357321f, -0.11985084f, -0.05946272f, 0.07322767f, 0.07185303f, 
    -0.09472178f, 0.16705054f, -0.07786892f, -0.09954190f, 0.06263208f, -0.06479856f, -0.07785063f, -0.01582110f, 
    0.05089759f, 0.06584888f, -0.02756567f, 0.05454810f, 0.41415697f, -0.20211111f, 0.03506527f, 0.08625428f, 
    -0.02976779f, 0.00321738f, 0.02022660f, 0.06606789f, 0.04415012f, -0.03386926f, 0.03530703f, 0.12564124f, 
    -0.08426359f, 0.23257582f, -0.24194613f, -0.06221368f, -0.11220456f, 0.05527344f, 0.09375682f, -0.07411478f, 
    0.10693304f, -0.07715899f, 0.10324605f, -0.16596757f, 0.35543919f, -0.03300214f, -0.08552738f, 0.26170504f, 
    -0.18056649f, 0.02571873f, -0.05851227f, 0.05817065f, 0.00903239f, -0.03701549f, -0.02253083f, -0.04657826f, 
    0.00881553f, -0.00134398f, -0.02658287f, 0.01987234f, 0.01428259f, -0.00503127f, -0.01636064f, -0.02031341f, 
    -0.03744985f, 0.02043218f, 0.00274771f, -0.03531651f, -0.00782408f, 0.02245381f, 0.00792663f, 0.01628756f, 
    0.00496265f, -0.00976256f, 0.00853266f, -0.03126902f, 0.00046735f, -0.00370197f, -0.02334262f, -0.00880141f, 
    -0.00575333f, -0.00468787f, -0.00815747f, 0.00459851f, -0.01907836f, -0.03078672f, -0.01283970f, -0.01622970f, 
    0.01765321f, -0.01175295f, 0.00228249f, 0.02067276f, -0.00633269f, -0.02114577f, 0.00923810f, -0.01260239f, 
    -0.03226512f, 0.02486485f, -0.02953139f, -0.01112092f, -0.00853973f, 0.02061081f, -0.01105323f, 0.02580673f, 
    0.02019689f, 0.02661795f, 0.01883357f, -0.02260840f, -0.02523947f, 0.00582778f, 0.01508921f, -0.01356865f, 
    -0.01495467f, 0.01635672f, 0.02149222f, 0.00300028f, 0.02580399f, 0.01813532f, -0.01858074f, -0.00546211f, 
    0.00097651f, -0.03674940f, 0.00965649f, -0.01194663f, 0.02137105f, -0.01434817f, 0.01722194f, 0.00614161f, 
    -0.00744728f, -0.00267724f, -0.00003054f, -0.03333249f, -0.00087126f, 0.00785210f, -0.03118612f, 0.01340893f, 
    -0.01628520f, -0.03191662f, 0.01404255f, -0.01067709f, 0.00706480f, -0.02413215f, -0.00583313f, 0.00259519f, 
    0.02097287f, -0.02553418f, 0.01839327f, 0.02011379f, 0.01283937f, 0.00941619f, 0.01130826f, -0.01554533f, 
    -0.01951438f, -0.00298245f, -0.00820682f, -0.03981129f, 0.02325065f, -0.01807713f, -0.02576461f, 0.01600900f, 
    -0.01800811f, -0.00226400f, -0.04179740f, 0.02189115f, -0.02769547f, -0.01939855f, 0.02407760f, 0.00187510f, 
    -0.01665952f, 0.00701882f, 0.02479794f, -0.03788848f, 0.01891470f, -0.01852230f, 0.01576222f, -0.03078793f, 
    -0.03334724f, -0.03009532f, -0.00572798f, -0.02017815f, 0.02228894f, 0.00960423f, 0.02211408f, 0.01429853f, 
    -0.01827157f, -0.03703925f, -0.03123638f, 0.01091499f, 0.02066411f, -0.03588950f, -0.00130917f, -0.00700611f, 
    0.01751631f, -0.02180819f, 0.00048979f, 0.01657267f, -0.02619012f, -0.02405718f, -0.00731831f, -0.02852418f, 
    0.00518662f, 0.00301969f, 0.02681275f, -0.00602172f, -0.01575522f, -0.03953399f, -0.01617074f, -0.04235072f, 
    0.02071450f, -0.03419323f, 0.02661632f, 0.00754157f, -0.01461890f, -0.03975517f, -0.03958530f, 0.01098784f, 
    0.01955092f, 0.00570819f, -0.01808694f, -0.01678369f, -0.00839069f, -0.03756097f, 0.02026569f, -0.01684116f, 
    -0.02612661f, 0.01955765f, 0.00849790f, 0.01460855f, 0.00456712f, -0.00696060f, -0.02976171f, 0.00904736f, 
    -0.02716914f, -0.03481729f, -0.02530416f, 0.01660065f, -0.02034575f, 0.01099120f, -0.03919388f, -0.00140276f, 
    -0.00432394f, 0.01277727f, 0.01911702f, 0.01023876f, 0.02438517f, 0.01997028f, 0.00278562f, -0.02928544f, 
    -0.02693615f, 0.00114914f, -0.02786022f, -0.01612615f, 0.01440120f, 0.01046897f, 0.02451616f, 0.00402234f, 
    0.01392254f, -0.01451925f, -0.04364225f, 0.01167245f, -0.00494377f, -0.01699766f, -0.01947561f, 0.01228679f, 
    -0.00892264f, 0.01193944f, -0.00367744f, -0.01635238f, -0.03444168f, -0.04082990f, 0.01216634f, -0.03053873f, 
    0.01356716f, -0.02130160f, -0.02880474f, 0.01653594f, 0.00568005f, 0.00432533f, -0.01294025f, -0.01036843f, 
    -0.03011155f, -0.02960635f, -0.01542804f, -0.02327579f, 0.01460261f, -0.01464904f, -0.04009254f, -0.01913983f, 
    0.00396709f, -0.02738487f, -0.03460295f, 0.01217274f, -0.01373532f, -0.02731338f, -0.01725599f, -0.01515462f, 
    0.01655665f, -0.00613500f, 0.00729955f, 0.02404534f, -0.00758724f, 0.03158935f, 0.00187352f, 0.01202978f, 
    -0.00020552f, 0.00419115f, 0.00450723f, -0.00687150f, -0.00296041f, -0.02951942f, -0.03252226f, -0.00777249f, 
    0.00771697f, -0.03664027f, -0.00932505f, 0.01981729f, -0.03635537f, -0.00577697f, -0.01329845f, -0.04266650f, 
    -0.03177533f, -0.02405396f, 0.00833249f, 0.01606700f, 0.01160249f, 0.02500322f, 0.00125437f, -0.03937039f, 
    -0.03057708f, 0.02621614f, 0.02453180f, -0.03523987f, -0.00221902f, -0.03388189f, -0.02018764f, -0.01206056f, 
    -0.00460183f, -0.03056974f, -0.03136644f, -0.00008817f, 0.01831348f, -0.01223961f, -0.02908281f, 0.02712465f, 
    -0.00498534f, 0.02807832f, 0.00308793f, -0.01663702f, -0.03162656f, -0.03027153f, 0.02802161f, -0.00103016f, 
    -0.03176111f, -0.01894046f, -0.00046918f, -0.02303393f, -0.01247092f, 0.02690793f, 0.01871282f, -0.03447944f, 
    -0.02017785f, -0.02271084f, -0.00566351f, 0.01706987f, 0.00723705f, -0.03893357f, -0.02032863f, -0.00362721f, 
    -0.04246535f, -0.03737523f, 0.01492057f, 0.01958372f, 0.02020727f, 0.00661405f, 0.02964560f, -0.03691372f, 
    0.01973941f, -0.03586138f, 0.01791591f, 0.01497333f, 0.02412709f, -0.01382845f, 0.01881024f, 0.01265554f, 
    0.01219667f, -0.00761802f, 0.01624036f, 0.00971479f, 0.02216351f, 0.00762752f, -0.00232479f, -0.02624616f, 
    0.00181341f, 0.01338724f, 0.02076969f, -0.01782298f, -0.03131703f, -0.01817307f, -0.00599667f, 0.01203088f, 
    -0.00924972f, -0.03227813f, -0.00296224f, -0.04088419f, 0.02735285f, 0.02704843f, -0.00057353f, -0.03701681f, 
    -0.01257886f, -0.01031321f, -0.02891115f, 0.01734538f, -0.01608321f, -0.03844188f, -0.02469878f, 0.01417518f, 
    -0.03134389f, -0.04394926f, 0.00319051f, 0.02267576f, -0.03493414f, 0.00987230f, -0.01768958f, 0.02108348f, 
    0.02539665f, -0.03530214f, -0.03448920f, 0.02057837f, -0.01109572f, 0.01866002f, 0.00828130f, -0.00152440f, 
    0.00005475f, -0.02285441f, -0.01680568f, 0.01351629f, -0.03652154f, -0.03097089f, -0.02042102f, 0.00921698f, 
    0.02520035f, -0.00353161f, -0.03060190f, -0.03223851f, 0.00081749f, -0.02621600f, -0.02338926f, -0.03571986f, 
    0.01245731f, -0.01343951f, 0.00146106f, -0.03543074f, -0.00968540f, -0.01331733f, 0.02764356f, 0.02704268f, 
    -0.01367264f, -0.03621954f, -0.00067334f, -0.00518644f, 0.00877996f, -0.02871099f, -0.02546254f, 0.02443812f, 
    -0.02333718f, -0.02256122f, -0.03461357f, 0.00294730f, -0.03818768f, -0.03240258f, -0.00588847f, 0.00367754f, 
    0.01691030f, 0.02808031f, -0.04102987f, -0.03965084f, -0.02012929f, -0.01899966f, 0.00078663f, -0.00554755f, 
    -0.02142477f, 0.01485514f, -0.02459125f, -0.00000240f, -0.03052351f, -0.01884867f, 0.02358061f, -0.02936219f, 
    -0.02152763f, -0.03588727f, 0.01769849f, -0.03331708f, -0.03158835f, -0.00847492f, 0.02334269f, 0.02268595f, 
    0.01543829f, -0.00149791f, -0.02832081f, -0.00977728f, 0.01477935f, 0.01743187f, -0.00109045f, -0.00249739f, 
    0.00165574f, -0.01651941f, -0.03644417f, 0.00590948f, -0.00715339f, 0.00233548f, 0.01120783f, -0.03020472f, 
    0.00155505f, 0.00649355f, -0.03952632f, -0.00896148f, 0.02430810f, -0.00742482f, -0.00767861f, -0.02492528f, 
    0.02245916f, -0.01218114f, -0.02668739f, 0.02681414f, -0.01900868f, 0.02677457f, -0.03679929f, 0.00634079f, 
    0.01961740f, -0.04348199f, -0.01490771f, -0.02809809f, -0.03092547f, -0.00718175f, -0.03385846f, -0.02894854f, 
    0.01343796f, -0.00915415f, -0.01423418f, 0.02549301f, 0.01803557f, 0.02392647f, -0.03283567f, -0.01637561f, 
    0.01678036f, 0.01218696f, 0.00155240f, -0.02069049f, -0.01212744f, -0.02782070f, -0.01027590f, 0.00323132f, 
    0.04115482f, -0.00303790f, -0.03669999f, -0.03769973f, 0.00739525f, 0.02720333f, 0.03129087f, -0.02259570f, 
    -0.02192265f, 0.01950748f, 0.01468027f, -0.02892017f, -0.02960157f, 0.00043786f, -0.03122735f, -0.01687036f, 
    0.02151136f, 0.02331730f, 0.00991477f, -0.02125120f, -0.00526628f, 0.02664864f, 0.00180265f, -0.02238270f, 
    0.03113220f, 0.00411183f, 0.00743776f, 0.02495102f, -0.01778807f, -0.01472807f, -0.03422339f, -0.01821303f, 
    0.01165573f, -0.02895844f, -0.03854702f, -0.01959048f, -0.02153090f, 0.00108244f, -0.02241408f, 0.02847747f, 
    0.02066825f, 0.00362945f, -0.01724116f, 0.00133486f, 0.00531348f, 0.00787003f, -0.03899413f, -0.01937608f, 
    -0.00670665f, -0.00760960f, 0.02407409f, 0.02430806f, -0.02417476f, -0.01097322f, -0.01118658f, 0.00095733f, 
    -0.02342295f, -0.03008198f, -0.03400106f, 0.02060070f, 0.01961120f, -0.02258170f, 0.00816155f, -0.04047342f, 
    -0.02001772f, 0.01672138f, -0.00213282f, -0.01177725f, -0.00744892f, 0.03204210f, 0.02651401f, -0.00129171f, 
    -0.01187225f, -0.00954448f, -0.01401250f, -0.02779686f, -0.02105200f, -0.00829969f, 0.01652890f, -0.01892424f, 
    -0.01771667f, -0.00409212f, 0.00241434f, 0.00597371f, 0.01430407f, -0.03283066f, 0.00659314f, -0.04178378f, 
    -0.03646982f, -0.02853073f, -0.00309183f, 0.01572458f, -0.00318021f, 0.03546403f, 0.01217808f, 0.00777698f, 
    -0.02911860f, -0.02206981f, -0.01800453f, -0.00047796f, -0.00019519f, 0.01950612f, 0.02488029f, 0.00602525f, 
    -0.01995868f, 0.01688238f, -0.00602646f, 0.00771503f, -0.02366247f, -0.02760286f, -0.03228254f, -0.02651487f, 
    0.02671065f, 0.02190531f, -0.03599975f, -0.03793440f, -0.02609695f, -0.00414182f, -0.02452540f, -0.03069763f, 
    -0.00835309f, 0.01065030f, -0.04179454f, -0.03578541f, -0.00809755f, -0.03579672f, 0.02300230f, -0.02590538f, 
    -0.03664261f, 0.03271821f, -0.03412497f, 0.02853543f, -0.03949968f, -0.03973390f, -0.00285099f, -0.01635316f, 
    -0.02082713f, -0.03932172f, -0.02105642f, -0.01446842f, -0.00446423f, 0.02513788f, -0.00445673f, -0.01880476f, 
    0.00419517f, -0.04441021f, 0.02568832f, -0.00583447f, -0.03799026f, -0.02438736f, 0.02906541f, 0.00921870f, 
    -0.02463327f, -0.01028957f, 0.01374133f, 0.01572756f, -0.00242688f, 0.03282817f, 0.02104209f, -0.02713852f, 
    0.01214565f, 0.01252428f, -0.03377690f, -0.01110615f, -0.03112713f, 0.00898679f, 0.00515025f, -0.03467135f, 
    -0.03107240f, -0.03108481f, -0.02293421f, -0.00753746f, -0.01489994f, -0.03561393f, -0.00624178f, -0.01341295f, 
    -0.04178290f, -0.02396769f, -0.03460806f, -0.00226708f, -0.01122786f, 0.02307182f, 0.01788542f, 0.00069158f, 
    0.02562018f, -0.04196391f, -0.03772493f, 0.02106817f, -0.03442806f, 0.00960182f, -0.02191016f, 0.00907147f, 
    -0.03464375f, -0.02371093f, 0.01818470f, -0.03751083f, -0.01842566f, -0.03098642f, -0.03838876f, 0.02591606f, 
    0.02260492f, -0.01925003f, -0.01929103f, 0.02177638f, 0.01686517f, -0.01862262f, 0.01078458f, 0.00620216f, 
    0.00480631f, -0.02616055f, -0.00767201f, 0.00283416f, -0.04180015f, 0.01808671f, -0.01263644f, -0.01957853f, 
    0.01999332f, 0.00235704f, -0.04197014f, -0.01242637f, -0.03251914f, -0.02672072f, -0.03737262f, 0.01087494f, 
    0.02341449f, -0.00017192f, -0.02743953f, 0.02349246f, -0.01240265f, -0.02838619f, 0.01671899f, 0.01526084f, 
    0.00644757f, 0.00113879f, -0.01330919f, 0.01315088f, 0.02752472f, 0.00380222f, 0.02888848f, 0.02544150f, 
    -0.03841262f, 0.02816890f, -0.01828112f, -0.00533706f, -0.01713791f, -0.01811376f, 0.01256230f, -0.00495624f, 
    0.02043466f, 0.01712646f, 0.01293118f, -0.03526727f, -0.02570572f, 0.03608568f, -0.02872175f, 0.02448865f, 
    0.01734008f, -0.03990969f, 0.01090870f, 0.00042887f, -0.01636179f, -0.00267590f, 0.02653873f, 0.02089598f, 
    0.00793259f, -0.01753289f, 0.04286069f, -0.00254107f, -0.03287163f, -0.04346313f, 0.01064328f, 0.01451643f, 
    -0.00463237f, -0.00735962f, -0.02985077f, 0.00875153f, 0.02066895f, 0.00560805f, 0.01723871f, -0.01442042f, 
    0.01086204f, -0.01407009f, -0.01580737f, -0.00286554f, 0.02495164f, -0.01750761f, -0.01604639f, -0.03588907f, 
    0.00411349f, -0.04214209f, 0.03431275f, -0.03341978f, -0.02875845f, 0.00267451f, -0.02188328f, -0.01447788f, 
    -0.01617504f, -0.02115097f, -0.01741503f, -0.02128582f, 0.03166561f, -0.02535048f, -0.00438243f, -0.02093848f, 
    0.01555575f, -0.01522304f, -0.00822862f, -0.01695037f, -0.00826420f, 0.02257908f, -0.03194364f, 0.01807076f, 
    -0.03248554f, 0.01407542f, 0.01042393f, -0.03120476f, -0.01944089f, 0.01032877f, 0.00931323f, 0.02097985f, 
    0.01579962f, -0.03719215f, -0.01159698f, -0.02815307f, 0.01118269f, 0.01611290f, 0.01713386f, 0.01423342f, 
    0.01949605f, 0.02182055f, -0.02014893f, -0.01818709f, -0.02952501f, -0.01322568f, -0.01413559f, -0.03673949f, 
    0.02018151f, -0.02997859f, -0.02305682f, 0.03009559f, -0.00193093f, -0.03234548f, 0.00133742f, -0.02401619f, 
    0.00884072f, 0.02955718f, -0.00717623f, 0.00290581f, -0.04364424f, 0.03974770f, -0.00561872f, 0.00772810f, 
    0.03059876f, 0.00721614f, 0.01339539f, -0.04216582f, -0.03690193f, 0.02249055f, 0.02700706f, -0.01471754f, 
    0.01241476f, 0.00940570f, -0.01918163f, -0.01127414f, -0.02895927f, -0.03741416f, -0.00292047f, 0.00956988f, 
    -0.01106900f, 0.02779122f, 0.03301005f, 0.01320618f, -0.02716495f, -0.03450738f, -0.03059619f, 0.01813277f, 
    0.00928982f, 0.02966074f, -0.03158294f, -0.03540169f, -0.01307917f, -0.00530520f, 0.00874364f, 0.03182495f, 
    -0.01863890f, -0.02495840f, 0.00206366f, 0.01487941f, 0.02762480f, -0.01569949f, -0.00651571f, -0.03174643f, 
    0.01422563f, -0.04075573f, -0.01906866f, 0.01607995f, -0.02242201f, -0.03208959f, -0.03570095f, -0.01879262f, 
    -0.01632474f, -0.00472155f, 0.02943826f, 0.00985185f, 0.01663599f, -0.02002155f, 0.01465480f, 0.01070730f, 
    0.03213397f, -0.02044354f, -0.03245581f, -0.01311194f, -0.01575378f, -0.01369250f, -0.01334390f, -0.02035321f, 
    0.02150903f, 0.01338137f, -0.01603568f, -0.04169275f, -0.00466123f, -0.02889165f, 0.02451502f, -0.00949666f, 
    0.01593293f, -0.03806696f, -0.00068255f, -0.01588291f, -0.02082791f, 0.02152113f, -0.00940979f, -0.00717034f, 
    0.01816702f, -0.00296508f, 0.02096870f, 0.01089000f, -0.00216455f, -0.00899779f, -0.03474610f, -0.01752757f, 
    0.01273915f, -0.00624076f, 0.02043282f, 0.03035570f, 0.03382945f, -0.00696718f, 0.02362012f, -0.00928674f, 
    -0.00992727f, -0.02691092f, -0.00051668f, -0.02785307f, -0.01293355f, -0.00671532f, 0.02022764f, -0.02187189f, 
    -0.01530946f, -0.01045335f, -0.00760214f, -0.01532086f, 0.02231912f, 0.02099961f, 0.01275314f, -0.02892019f, 
    -0.00067340f, 0.02914663f, -0.03715258f, -0.03018599f, -0.03953019f, 0.01183541f, 0.01381727f, -0.00571573f, 
    -0.00995576f, 0.02776509f, 0.03223909f, -0.01768175f, -0.00758585f, 0.01119922f, 0.00536796f, 0.03791150f, 
    -0.00065493f, 0.00140801f, 0.00188427f, 0.01246773f, -0.01014102f, -0.03519484f, 0.01854486f, 0.01102056f, 
    0.04093942f, 0.03644289f, 0.02923967f, 0.03025937f, 0.00011425f, 0.03174232f, -0.00895977f, 0.03153627f, 
    0.01759988f, -0.01374892f, -0.01860139f, -0.02611978f, -0.00075172f, 0.00114053f, -0.02873038f, -0.01837668f, 
    0.02073340f, -0.02179401f, -0.01047864f, 0.00525489f, -0.02385370f, -0.02187402f, 0.02526932f, 0.01078239f, 
    0.02365575f, -0.02230499f, 0.00647639f, -0.02749914f, -0.01332598f, -0.00100761f, 0.01890677f, -0.03248999f, 
    0.02686193f, 0.00809251f, -0.01773214f, -0.02407241f, -0.01360085f, -0.01340306f, -0.03705059f, -0.00134435f, 
    0.01069838f, -0.02000503f, -0.01292523f, -0.04055628f, -0.02749107f, 0.01491891f, -0.00366255f, 0.00006840f, 
    0.02995344f, -0.00991280f, -0.00064451f, -0.03221190f, -0.01412344f, 0.00086646f, 0.01420185f, -0.01930348f, 
    0.01447099f, -0.03072452f, -0.03237689f, 0.02608882f, -0.02908129f, 0.00334414f, 0.02909401f, 0.01625806f, 
    -0.03320127f, -0.00009347f, 0.03048948f, -0.00332872f, -0.03328764f, -0.02556255f, 0.01764690f, -0.03012162f, 
    -0.02243163f, -0.02768938f, -0.00812153f, 0.01921133f, -0.01296465f, 0.02091386f, -0.00110076f, 0.00772405f, 
    -0.02291624f, -0.03498518f, -0.02858504f, -0.00291426f, 0.00197613f, 0.03442375f, 0.01042033f, 0.02182352f, 
    0.00887769f, 0.02011416f, -0.00417742f, 0.01970516f, -0.00275937f, 0.01576211f, 0.00082192f, -0.01859025f, 
    -0.00380281f, 0.01039293f, -0.00263013f, 0.02642344f, -0.02819754f, 0.01470150f, 0.00782513f, -0.03447518f, 
    -0.02867689f, 0.02000776f, -0.03397769f, -0.00029871f, 0.00120294f, -0.02499548f, -0.00608743f, -0.02871959f, 
    0.01040192f, -0.02478180f, -0.01393641f, -0.00147166f, 0.00104657f, 0.01887202f, 0.01231062f, 0.02663555f, 
    -0.01439622f, -0.03093395f, -0.02450646f, -0.01771360f, -0.00255902f, -0.01979434f, -0.00364511f, 0.02415945f, 
    0.01494954f, 0.03099862f, 0.02238104f, 0.02113488f, -0.00033220f, 0.01992401f, 0.01332680f, 0.01699250f, 
    0.01517094f, 0.02506587f, 0.01630445f, -0.03230200f, 0.00640985f, 0.00788910f, -0.01127537f, -0.03976960f, 
    -0.01371776f, 0.00710935f, -0.01059487f, 0.03554471f, -0.02845526f, 0.01319427f, 0.02405116f, 0.02582817f, 
    0.00379149f, -0.01364923f, 0.02797524f, -0.00077143f, -0.02984100f, -0.00281054f, -0.03500833f, -0.02965133f, 
    0.01931773f, 0.01551618f, 0.01771017f, 0.00912591f, 0.01397603f, -0.01585636f, 0.01275260f, -0.01729279f, 
    0.02857767f, -0.00281969f, -0.01042621f, -0.01483064f, 0.01547614f, 0.02289118f, 0.03452925f, -0.02400746f, 
    -0.04317373f, 0.02149723f, 0.02743322f, -0.02179654f, 0.02307304f, 0.02674825f, 0.00791513f, 0.02414252f, 
    0.00588873f, -0.00684575f, -0.03988012f, 0.01136322f, 0.01723467f, -0.00167929f, -0.03725886f, 0.00196241f, 
    0.01294211f, -0.03707541f, -0.03443526f, -0.02612621f, -0.02866504f, 0.01831044f, -0.01528015f, -0.02470299f, 
    -0.00084490f, 0.01502029f, -0.03375723f, 0.03156710f, -0.03252868f, -0.00495648f, 0.01880386f, -0.02551165f, 
    -0.03121400f, 0.01495927f, 0.00946562f, 0.03275200f, -0.00291146f, -0.03238559f, -0.03311685f, 0.00067061f, 
    -0.01670024f, -0.01859051f, 0.01292282f, -0.00318783f, 0.01606581f, -0.03447666f, -0.03319361f, -0.03153151f, 
    -0.02961677f, -0.03203633f, -0.01646281f, -0.02759136f, -0.00604705f, 0.03857741f, 0.00188458f, 0.02857166f, 
    -0.01560772f, -0.02190724f, 0.00138836f, -0.01735522f, 0.02463838f, 0.01706093f, -0.02557493f, -0.02386608f, 
    0.02015182f, 0.03046789f, -0.00978611f, 0.01442414f, 0.02141041f, 0.02100236f, -0.00957281f, 0.02531036f, 
    -0.02809088f, -0.01578341f, 0.01633025f, 0.00328915f, -0.00461791f, 0.01079214f, -0.00412445f, 0.02600358f, 
    -0.00703396f, -0.03132767f, -0.00345952f, 0.01511326f, -0.00096577f, -0.01433819f, 0.01708044f, 0.02670095f, 
    -0.00821314f, 0.01154026f, 0.00589289f, -0.01201739f, -0.02248909f, -0.03485496f, -0.02976060f, -0.03667352f, 
    -0.00640846f, 0.02531991f, -0.01692129f, -0.00535494f, -0.00130685f, -0.02609357f, -0.03161120f, 0.00649917f, 
    -0.02488652f, -0.00114060f, 0.02157482f, 0.00328949f, 0.03061272f, 0.01313270f, -0.00549924f, 0.03147853f, 
    0.01098505f, -0.00985793f, -0.03693252f, 0.01685921f, 0.01319152f, -0.00529836f, 0.02457354f, -0.02317681f, 
    -0.00836294f, 0.02704854f, 0.00872496f, 0.00277389f, -0.01166331f, 0.01931326f, -0.03405168f, 0.02210690f, 
    -0.01018828f, -0.02594475f, -0.02942461f, -0.02936858f, -0.01550648f, 0.00354587f, -0.00572048f, -0.02203630f, 
    0.00115249f, 0.02254458f, -0.01567273f, -0.01754469f, -0.03094812f, -0.01613808f, 0.02855232f, 0.02143584f, 
    0.02588872f, -0.02228329f, -0.02011842f, 0.00951936f, 0.00658734f, -0.00939170f, 0.00591370f, -0.01058722f, 
    -0.02747331f, -0.03320954f, -0.00110158f, -0.02488576f, -0.03208274f, -0.02613831f, 0.03167448f, -0.01328880f, 
    0.02989153f, 0.02942872f, 0.00905016f, 0.02179901f, 0.00747210f, -0.04365958f, 0.00763855f, 0.01978534f, 
    0.02005935f, -0.03041724f, 0.03319822f, 0.00212866f, 0.00575532f, -0.03125692f, -0.00623844f, 0.01502355f, 
    0.02071110f, 0.01017418f, 0.02160109f, -0.00523065f, -0.00473045f, 0.03072123f, 0.02777770f, 0.02063437f, 
    -0.00035674f, -0.01036232f, -0.02505486f, -0.03681116f, -0.02089038f, -0.01708319f, 0.02152332f, -0.00975850f, 
    -0.02020060f, -0.00446480f, 0.02480936f, -0.03984974f, 0.03554807f, 0.01852215f, 0.01051026f, 0.01504192f, 
    0.00956491f, 0.01231612f, -0.03073492f, 0.00686783f, 0.02508634f, 0.00448901f, -0.03721058f, -0.00169749f, 
    0.01469374f, 0.01078607f, 0.03216927f, 0.02876050f, 0.00926492f, 0.00156310f, -0.03636063f, 0.03520093f, 
    -0.03725197f, 0.02748177f, 0.02905949f, 0.00818390f, -0.00820675f, -0.03885610f, -0.01118832f, -0.00903050f, 
    -0.01988122f, 0.01027234f, 0.02363726f, -0.02547246f, 0.00300524f, 0.04018340f, -0.01214534f, -0.00915541f, 
    0.01154755f, 0.00232011f, -0.03011874f, 0.02411764f, 0.00671205f, -0.02076775f, -0.01378763f, -0.03820776f, 
    0.02584398f, -0.02499592f, 0.02016978f, -0.02348409f, -0.00459240f, 0.00745657f, -0.03363209f, -0.03903267f, 
    0.03693417f, 0.00448111f, -0.04102252f, 0.02316068f, -0.03026041f, 0.01838636f, 0.02446693f, 0.02967567f, 
    0.01074789f, -0.02269784f, 0.00583399f, 0.01538714f, -0.03043976f, 0.02839317f, -0.03894817f, -0.01937545f, 
    -0.03320389f, -0.00125498f, 0.01415445f, -0.01904504f, -0.01252914f, 0.02165173f, -0.00646302f, 0.00795160f, 
    -0.04100016f, 0.00220586f, 0.00170074f, -0.01470826f, 0.00329392f, 0.00118691f, 0.00818225f, -0.01091577f, 
    -0.00374285f, 0.01644712f, 0.00958905f, -0.02134857f, 0.03192119f, -0.00676674f, -0.01104004f, -0.01371863f, 
    0.01231804f, 0.01993229f, -0.01755968f, -0.02645441f, -0.02369366f, 0.00374509f, -0.02982557f, -0.02609865f, 
    -0.01244154f, -0.00425428f, -0.00894380f, -0.02144917f, -0.02826823f, 0.03716055f, -0.02510797f, 0.00309416f, 
    -0.00364174f, -0.00443491f, 0.01848768f, -0.02766599f, -0.02720413f, -0.03432560f, -0.00818757f, 0.01759183f, 
    0.01643884f, 0.01740889f, 0.01019024f, -0.00455907f, -0.00724107f, 0.00539357f, 0.02681287f, -0.01535817f, 
    -0.01326236f, 0.03624292f, -0.02526398f, -0.00518431f, 0.00371808f, 0.02498356f, -0.01065973f, -0.03469113f, 
    -0.02920792f, 0.01787921f, -0.04203600f, 0.03025283f, -0.03436154f, 0.01347188f, 0.02263483f, -0.01371523f, 
    0.01806510f, -0.01004176f, -0.03296160f, 0.00554971f, 0.00961669f, -0.02464993f, -0.03640256f, 0.00546257f, 
    -0.02060479f, -0.00125408f, 0.01393174f, -0.03132185f, -0.00812368f, -0.03125718f, -0.03422694f, 0.03644887f, 
    -0.01751840f, 0.03351331f, -0.01342176f, -0.04000361f, -0.01357613f, 0.01665594f, 0.01443673f, -0.03532077f, 
    0.00942975f, -0.00619390f, -0.03067690f, -0.03790058f, 0.00062659f, 0.01894826f, -0.00675859f, -0.00198465f, 
    0.02199590f, -0.00739624f, 0.04074109f, 0.01523923f, -0.03408553f, -0.02385245f, 0.02212558f, 0.01830378f, 
    -0.18566351f, -0.13960184f, 0.06099429f, 0.10164926f, -0.08782297f, 0.00161375f, -0.01080765f, 0.00748195f, 
    -0.05202818f, 0.07720920f, 0.04224182f, 0.13596618f, 0.05967959f, 0.12138180f, 0.12992637f, -0.00097013f, 
    -0.10615402f, 0.12687469f, 0.05671018f, 0.02715212f, 0.04003035f, -0.11277924f, 0.05313522f, -0.02302495f, 
    0.05135897f, 0.03448741f, 0.02448879f, -0.00107248f, -0.06230486f, 0.05110647f, 0.01488591f, -0.00113606f, 
    -0.01907742f, -0.00230006f, -0.00550124f, -0.09462178f, -0.05568806f, -0.13316748f, 0.15380448f, 0.08463010f, 
    -0.01354876f, 0.10749628f, 0.03530100f, -0.08088191f, -0.05102184f, -0.04015603f, 0.02991845f, -0.03948088f, 
    -0.24195680f, 0.02320580f, -0.03113339f, -0.16759583f, 0.17638427f, -0.02485544f, -0.05087736f, -0.07693016f, 
    -0.09726085f, 0.03383503f, -0.02097312f, -0.03597993f, 0.00535845f, 0.05763975f, -0.16368340f, 0.04889096f, 
    0.18543527f, -0.21410654f, -0.12299239f, -0.05199181f, 0.10461874f, 0.14023502f, 0.02363237f, 0.04388312f, 
    0.28391474f, 0.11504703f, 0.05068177f, -0.17059997f, -0.08566830f, 0.08607711f, -0.08291515f, -0.10693537f, 
    -0.04754064f, -0.06990435f, -0.12610689f, -0.06781963f, -0.04750876f, 0.07372221f, 0.02978714f, -0.29796848f, 
    0.03875194f, 0.13833582f, 0.02867234f, 0.00151491f, 0.00901292f, 0.10319973f, -0.13469146f, -0.05700905f, 
    0.15625075f, 0.00959733f, -0.07133216f, -0.14638676f, 0.01607264f, -0.10362274f, -0.05985469f, -0.06731283f, 
    -0.08876776f, 0.01889324f, 0.02835778f, 0.05337645f, -0.32208541f, 0.11627315f, 0.10476421f, -0.20389684f, 
    0.07608359f, -0.08090376f, 0.03367717f, -0.04579531f, 0.01812313f, -0.09852619f, -0.00068610f, -0.03000971f, 
    -0.12430894f, 0.01354669f, -0.00857315f, 0.04989753f, 0.00125105f, -0.03472879f, -0.02653757f, 0.09460638f, 
    0.11195544f, -0.00769611f, -0.03996930f, 0.00882161f, 0.00517765f, 0.27376559f, 0.05739340f, -0.06296632f, 
    0.12116495f, 0.05962677f, -0.01715337f, 0.04668023f, 0.12908840f, -0.08032624f, -0.05664711f, -0.04110608f, 
    -0.10179847f, 0.08734644f, 0.05524474f, 0.17538181f, 0.17933136f, -0.01993309f, 0.00246015f, 0.07404782f, 
    -0.02188197f, 0.08169287f, -0.07700282f, 0.03164351f, 0.22637770f, -0.09262101f, -0.21399465f, 0.07135163f, 
    -0.00453096f, -0.08634119f, -0.14413425f, 0.08880122f, 0.00996274f, 0.01437395f, -0.03712082f, -0.10031840f, 
    -0.17946392f, 0.12819806f, 0.12279239f, -0.01839896f, 0.11803553f, -0.08016801f, -0.03883410f, -0.00578981f, 
    0.00418861f, 0.14228690f, 0.01449207f, 0.04956600f, -0.03655155f, -0.08901737f, -0.03041718f, 0.22085391f, 
    0.08514506f, 0.02642014f, 0.12304129f, 0.00420251f, -0.01613914f, -0.09370624f, -0.06801748f, -0.01251969f, 
    -0.08864685f, 0.02982669f, 0.05717466f, 0.37536877f, -0.00900759f, -0.04053468f, 0.05330769f, 0.05110762f, 
    0.01995908f, -0.04207762f, 0.00784613f, 0.02804526f, -0.13667282f, 0.12604831f, -0.01307032f, 0.02225982f, 
    0.17622806f, 0.09323201f, -0.06236607f, -0.00699132f, -0.01779111f, -0.06140703f, 0.05084532f, -0.01780945f, 
    0.06936263f, -0.00232066f, -0.11382313f, -0.04608610f, -0.01176712f, -0.09824213f, -0.05873791f, 0.07971817f, 
    -0.03069912f, 0.01407958f, -0.10235424f, -0.01808865f, -0.06184224f, 0.07733148f, -0.09232472f, -0.09115985f, 
    0.12308823f, -0.08419561f, 0.06484070f, -0.00792445f, 0.09125980f, 0.12474382f, 0.03337108f, -0.01684743f, 
    0.05449664f, 0.02421816f, -0.14294082f, -0.01682222f, -0.04705681f, 0.05066604f, -0.00886560f, 0.07927911f, 
    -0.01762360f, -0.01892640f, -0.02301000f, 0.08498187f, 0.06443930f, -0.17132935f, 0.12387192f, 0.16198204f, 
    -0.08494916f, 0.01087552f, 0.08505392f, -0.01942739f, -0.05986827f, -0.14517264f, 0.05664625f, 0.02082142f, 
    0.20598954f, -0.17044927f, -0.02940144f, 0.05611363f, -0.07728954f, -0.05070015f, 0.06854192f, -0.00270067f, 
    -0.01518140f, -0.06122372f, 0.07014041f, 0.10020789f, 0.05299701f, 0.27218851f, -0.00523062f, 0.17940103f, 
    -0.12176340f, 0.02849701f, 0.09581679f, 0.01282855f, 0.02421040f, -0.02546397f, -0.06084257f, 0.01325495f, 
    0.28497204f, -0.07082590f, 0.03664960f, 0.02034958f, 0.06820901f, -0.00851084f, 0.03202647f, 0.03903130f, 
    0.09629944f, 0.00442151f, 0.12657240f, 0.01196884f, 0.02007112f, -0.03450876f, 0.11858696f, -0.11315642f, 
    -0.04661188f, 0.03151311f, 0.02401762f, -0.00863299f, -0.04923179f, 0.01044172f, -0.02660676f, -0.01112196f, 
    -0.08541188f, 0.06019005f, -0.16782112f, -0.05459026f, 0.06374544f, 0.04568715f, -0.07387193f, 0.08912215f, 
    -0.10831068f, 0.02657967f, 0.07747494f, -0.04293856f, 0.08233261f, 0.04949393f, -0.08293311f, 0.02128378f, 
    0.01246223f, -0.07949834f, 0.14526924f, -0.04266467f, -0.06822509f, -0.00903791f, 0.03118318f, 0.07244518f, 
    -0.02398485f, -0.20333995f, 0.21055768f, 0.20288496f, -0.05894970f, -0.07020261f, -0.04266072f, 0.07585626f, 
    0.04958415f, 0.03937736f, 0.12580514f, 0.20210488f, -0.07522666f, 0.24181226f, 0.02665917f, 0.17596704f, 
    0.03997016f, -0.03146344f, 0.00249111f, 0.02665661f, -0.04520920f, -0.01435786f, -0.08757433f, -0.17520711f, 
    -0.12233488f, 0.12105614f, 0.02360090f, -0.08568940f, 0.05882053f, 0.07223756f, -0.02960222f, -0.18477270f, 
    0.11833233f, -0.00059413f, -0.00221271f, -0.04310486f, 0.23533228f, 0.18244757f, 0.16886182f, 0.29162794f, 
    0.23097298f, 0.11021189f, 0.02688891f, 0.08407851f, 0.01074275f, 0.00451247f, -0.13258131f, -0.03884634f, 
    0.14494282f, -0.13493252f, -0.01603068f, 0.17222059f, -0.10839169f, 0.01134331f, -0.02876868f, 0.07542457f, 
    0.08307497f, -0.06751391f, 0.01690137f, 0.04666608f, 0.25116932f, 0.21976610f, 0.05037626f, 0.05710833f, 
    0.02683379f, -0.04498218f, 0.03360234f, -0.00366401f, 0.01958141f, 0.07988649f, 0.10238022f, -0.03279407f, 
    -0.11166443f, 0.06257913f, -0.00253586f, 0.15883358f, 0.08074756f, 0.05215969f, 0.10562960f, -0.00254229f, 
    -0.09092095f, 0.09298526f, -0.19745488f, -0.02311593f, 0.08183447f, 0.00195019f, -0.12518993f, -0.01668950f, 
    0.05345929f, -0.00839521f, 0.02606701f, 0.04455908f, -0.00736726f, 0.02365228f, 0.05567707f, 0.01552203f, 
    -0.01119530f, 0.10378614f, 0.27359727f, 0.14412878f, 0.05416657f, 0.11981268f, 0.14775926f, 0.05656076f, 
    0.01716262f, -0.10146528f, -0.08183663f, -0.08192627f, 0.14116125f, 0.05157845f, -0.09406005f, -0.07141446f, 
    0.17161149f, 0.18427083f, 0.08621211f, -0.02436830f, -0.02297562f, -0.06087527f, 0.08128496f, -0.00296069f, 
    -0.00991268f, -0.00995475f, 0.22160625f, 0.13052319f, -0.15201621f, -0.12798558f, 0.02062650f, 0.03263142f, 
    0.05842340f, 0.00856699f, 0.01729849f, 0.12860242f, 0.16546836f, -0.04847871f, 0.03133877f, 0.18240543f, 
    0.05138578f, -0.11997966f, -0.06535672f, 0.02033661f, -0.04451696f, 0.06350905f, 0.19442320f, 0.16548321f, 
    0.19503915f, -0.14361329f, 0.10565178f, 0.26550332f, -0.00528134f, 0.01075724f, 0.08945810f, 0.05741891f, 
    -0.01065664f, -0.04316295f, 0.10720670f, 0.19219758f, -0.03220588f, 0.00378644f, -0.12989852f, -0.23466069f, 
    -0.08844105f, -0.04842337f, 0.10778003f, 0.08224823f, 0.15176360f, 0.06754048f, -0.11148400f, 0.03584205f, 
    0.03632216f, 0.13526230f, -0.09437459f, -0.01162611f, 0.19091822f, 0.11812527f, 0.10841602f, 0.07331590f, 
    -0.00711612f, 0.02854510f, -0.03649051f, -0.00762593f, 0.01278737f, -0.01691856f, -0.12297327f, 0.18457261f, 
    0.07088529f, 0.02340312f, -0.01036874f, 0.00644398f, -0.01807576f, -0.04451418f, 0.01635319f, -0.02452953f, 
    -0.18643244f, 0.05139629f, -0.07196161f, 0.04938406f, -0.14429697f, 0.07832912f, -0.03312969f, 0.03160583f, 
    -0.06003762f, -0.06243612f, -0.06766441f, -0.05723624f, -0.01329027f, 0.33274135f, -0.02354450f, -0.12425867f, 
    0.15682483f, 0.03917188f, -0.10640976f, -0.18576403f, -0.05707770f, -0.14942120f, 0.08212250f, -0.14103429f, 
    -0.04680737f, 0.13047308f, 0.19767365f, -0.03866280f, -0.15480874f, 0.02047944f, -0.10896583f, 0.05725633f, 
    0.03115288f, -0.03019980f, -0.05243161f, 0.05167937f, -0.29290468f, 0.15625894f, 0.09184326f, -0.05427678f, 
    0.07224717f, -0.08180913f, -0.01407373f, -0.10911094f, 0.11447696f, 0.02666200f, -0.01871425f, 0.03394746f, 
    -0.06788690f, 0.12452428f, 0.14255732f, 0.24706878f, -0.09700391f, 0.02491345f, 0.05210962f, 0.07571451f, 
    -0.09639159f, 0.00494320f, -0.02974692f, -0.07230069f, -0.25631601f, 0.27324501f, 0.04622370f, -0.13349783f, 
    0.01119475f, -0.04943157f, 0.03261321f, -0.11930335f, 0.07352685f, -0.04366554f, 0.02101442f, -0.00002328f, 
    -0.24094079f, -0.02401482f, 0.28644893f, -0.10023670f, -0.00707412f, -0.04392591f, 0.08381747f, 0.02358430f, 
    -0.01434700f, 0.08553419f, 0.04592237f, 0.06481386f, -0.42046902f, 0.28469762f, -0.02316102f, 0.05693937f, 
    0.08932193f, 0.03991817f, -0.05770852f, -0.10959560f, 0.02314460f, 0.02879581f, -0.00629231f, 0.02581388f, 
    -0.02965135f, 0.16331320f, 0.38463673f, 0.31476158f, -0.07179961f, -0.06996572f, 0.04403438f, 0.05736689f, 
    -0.01486955f, 0.09440874f, -0.13530752f, -0.03828857f, 0.49622554f, 0.07652387f, 0.09341212f, 0.08363253f, 
    0.12632835f, 0.09243545f, 0.07594530f, -0.02786522f, -0.07306775f, 0.02057657f, -0.14274675f, -0.07821239f, 
    0.05377983f, -0.17144828f, -0.07792708f, 0.06496906f, -0.01670962f, -0.01507951f, 0.06099567f, -0.03101051f, 
    -0.01303138f, 0.06708655f, -0.07883393f, 0.11980295f, -0.01384242f, -0.06812753f, 0.04503687f, 0.02490888f, 
    0.19471779f, -0.00562437f, -0.04843045f, -0.00104045f, -0.12042382f, 0.01635409f, 0.10520051f, -0.12707011f, 
    0.19423734f, -0.19436881f, -0.14304681f, -0.02713321f, -0.00328258f, -0.14082092f, 0.04125042f, 0.01132604f, 
    0.03644904f, -0.08650295f, -0.08559465f, -0.03086375f, -0.10936912f, -0.05204853f, 0.31209451f, 0.39008558f, 
    -0.04429318f, -0.01007098f, 0.10606736f, -0.02755707f, -0.09281616f, -0.00161291f, 0.02844141f, -0.08190584f, 
    0.05330512f, 0.07462915f, -0.01096430f, -0.02186537f, -0.02358591f, 0.01416340f, 0.00554392f, -0.15407163f, 
    -0.00724271f, -0.03086243f, -0.16973718f, -0.01918856f, -0.06240003f, 0.09172247f, -0.01216061f, 0.09617940f, 
    0.03628438f, 0.00058281f, 0.13838230f, -0.01546239f, 0.01278287f, 0.13720012f, -0.17523696f, -0.11814269f, 
    0.15139121f, 0.04647838f, 0.03796580f, 0.24518688f, 0.00057706f, 0.03503336f, 0.00544289f, 0.07807332f, 
    -0.08314764f, -0.09508676f, 0.12771070f, -0.00284805f, -0.26573792f, 0.24198824f, -0.12125285f, 0.13466078f, 
    0.06091270f, 0.03424463f, 0.00005336f, 0.11504249f, -0.06742708f, -0.09804863f, 0.05411698f, -0.12097967f, 
    -0.19275990f, 0.02674188f, -0.00997387f, -0.01183032f, -0.00512129f, -0.09801935f, -0.11713924f, 0.05758105f, 
    0.00916812f, -0.01920316f, -0.12502472f, 0.02984721f, -0.37080485f, 0.14009440f, 0.19178654f, -0.20319498f, 
    0.05753871f, 0.06573052f, 0.00194597f, -0.00283606f, -0.11893559f, 0.03662938f, 0.06615181f, 0.09504187f, 
    0.22573718f, 0.27313313f, 0.16780430f, -0.11633917f, -0.01440425f, -0.02326798f, 0.04002301f, 0.09913862f, 
    0.04530128f, 0.12118223f, 0.05090030f, 0.21171974f, -0.18192975f, 0.14688863f, 0.24560393f, -0.18807784f, 
    0.05781339f, 0.20148572f, 0.05413777f, -0.09798301f, 0.16723242f, -0.04520288f, 0.10550075f, -0.00937970f, 
    0.06542717f, 0.04572703f, 0.09561570f, 0.00889062f, 0.04460846f, 0.01277946f, -0.02760033f, -0.03018116f, 
    0.07109670f, 0.03555122f, 0.04564803f, 0.09509584f, 0.16007155f, 0.27084267f, 0.34249455f, 0.00420372f, 
    0.09450326f, -0.03345732f, -0.06725198f, 0.05416939f, -0.05813503f, -0.04088578f, 0.03900147f, 0.01383700f, 
    -0.32590234f, -0.12353467f, -0.10432645f, -0.05408082f, 0.19746748f, -0.02432288f, 0.06043449f, -0.00131050f, 
    0.00478380f, 0.02655150f, 0.05972792f, -0.07606717f, -0.05670797f, -0.25061190f, 0.08125786f, 0.18498310f, 
    0.13260354f, -0.06319790f, -0.06243197f, -0.01151415f, 0.10303281f, 0.10634024f, -0.02913903f, 0.06128138f, 
    0.27638906f, 0.01795868f, 0.07789002f, -0.07920590f, -0.08747108f, 0.05602061f, -0.02124750f, 0.01698026f, 
    0.11253680f, -0.07420756f, -0.04076894f, -0.00443277f, -0.15774961f, -0.19858682f, 0.00709113f, -0.04780816f, 
    0.10656796f, -0.02237830f, -0.02280578f, 0.10469048f, 0.09328895f, 0.00188681f, -0.10163192f, -0.02190056f, 
    -0.03629718f, -0.13164566f, 0.06009727f, 0.02344447f, 0.02208949f, 0.00412591f, 0.04764504f, -0.05096287f, 
    0.03877541f, 0.07776292f, 0.05976845f, -0.06587036f, -0.03119914f, 0.02822357f, -0.14184865f, -0.05567501f, 
    0.09692810f, 0.02541691f, 0.03300338f, 0.07118065f, -0.05878607f, -0.00119365f, 0.10954228f, -0.08343949f, 
    0.00860113f, -0.06150634f, 0.06154717f, -0.00791987f, -0.08532766f, -0.08830170f, 0.01230034f, 0.09416497f, 
    0.12169495f, -0.00425042f, -0.07084632f, 0.03952565f, -0.30674455f, -0.25990111f, -0.11716624f, 0.02835369f, 
    0.16068426f, -0.02750962f, 0.07110192f, 0.00445285f, 0.02579271f, 0.04816030f, -0.03636018f, -0.10823866f, 
    -0.22647488f, -0.07559432f, -0.05122720f, 0.16511241f, 0.18438686f, 0.01853682f, 0.02986581f, -0.00686849f, 
    0.04093425f, -0.02270721f, -0.06375867f, 0.03037440f, 0.11145373f, 0.14753976f, 0.05833076f, -0.07056957f, 
    0.02484844f, -0.05383199f, 0.00385342f, 0.09526595f, 0.05859917f, -0.07480650f, 0.01854627f, -0.00675871f, 
    0.19942421f, 0.38919398f, 0.06263939f, -0.19720106f, -0.04920972f, 0.02348574f, -0.09635199f, 0.07758304f, 
    -0.01156076f, 0.06803871f, 0.09794044f, 0.07774822f, -0.10848564f, -0.09256089f, -0.05369673f, 0.07945286f, 
    0.09436241f, -0.01490502f, 0.10732201f, 0.09640910f, 0.05181564f, -0.19207583f, 0.01125611f, 0.07893072f, 
    -0.21432017f, -0.02943916f, -0.13016155f, 0.06970741f, -0.08552065f, -0.03252172f, 0.00474897f, 0.05890959f, 
    -0.05525560f, -0.00564147f, 0.08131593f, 0.08634573f, -0.14323950f, -0.09904897f, -0.16016936f, 0.03319991f, 
    0.10786205f, 0.05068616f, -0.00762745f, 0.02294138f, -0.01852115f, -0.03989640f, 0.04297465f, -0.00209397f, 
    0.20022579f, 0.00476542f, 0.10698273f, -0.01797467f, 0.02919867f, -0.17269967f, 0.03523853f, 0.03921307f, 
    0.04986262f, 0.15647858f, -0.00780790f, -0.05924804f, -0.23056731f, -0.23385991f, -0.13003886f, 0.00288090f, 
    0.16464581f, 0.08785410f, 0.12351904f, 0.05127277f, -0.01359364f, 0.07573196f, 0.00667414f, 0.00490287f, 
    -0.01779396f, 0.05577642f, 0.04276850f, 0.02125240f, 0.04916229f, -0.03297124f, -0.01938765f, 0.00096456f, 
    -0.10547636f, -0.01713984f, 0.09503610f, 0.07802127f, 0.12140799f, 0.09350245f, 0.11439622f, 0.15740053f, 
    -0.02233577f, -0.12115774f, -0.00270059f, -0.11629534f, 0.10187681f, 0.05056410f, -0.02167205f, 0.16844812f, 
    0.32017615f, 0.16004087f, 0.29676899f, 0.09754602f, -0.04768058f, -0.04063779f, -0.02822160f, 0.01002882f, 
    0.05937399f, 0.05425157f, 0.01826390f, 0.01082948f, 0.04360456f, 0.20971282f, 0.09221637f, -0.01610651f, 
    0.10432458f, 0.02673425f, 0.09790741f, -0.05349926f, 0.02612545f, -0.04161996f, -0.01640270f, 0.09603050f, 
    0.15015076f, 0.07581633f, -0.09944712f, -0.07079002f, 0.07723609f, -0.08503672f, 0.01813083f, 0.08436792f, 
    0.07034235f, 0.07426798f, -0.02468706f, 0.02458469f, 0.34166658f, 0.15999240f, 0.20746014f, 0.12076467f, 
    -0.03733097f, -0.04947745f, 0.10296490f, 0.06823816f, 0.06301795f, 0.14829125f, -0.04825391f, 0.08091567f, 
    0.02917218f, -0.03836269f, 0.04361698f, -0.02579096f, 0.18742830f, -0.02134158f, 0.00576916f, -0.02817322f, 
    -0.02147003f, -0.06870271f, 0.12226878f, -0.01323242f, 0.25014609f, 0.01918237f, 0.03486238f, -0.08901134f, 
    -0.03006488f, -0.07836412f, 0.03212541f, 0.06838320f, -0.02743067f, -0.02091946f, 0.02788855f, 0.03546789f, 
    -0.16651168f, -0.03265016f, -0.08608849f, 0.02012829f, 0.02870322f, -0.02016550f, 0.01434533f, 0.00797581f, 
    -0.03660870f, -0.02348256f, 0.15235706f, 0.11372261f, 0.03103925f, 0.18490247f, -0.07123373f, -0.03032483f, 
    0.01714672f, 0.04213486f, -0.05124950f, -0.05165621f, -0.00413681f, 0.07177215f, -0.13906860f, -0.06705900f, 
    -0.21589176f, -0.30328384f, -0.03231548f, 0.04490731f, 0.11234637f, 0.08079115f, 0.12198175f, 0.04834201f, 
    -0.00159190f, 0.08615611f, 0.12983450f, -0.04555386f, 0.09869669f, -0.01338152f, -0.00090078f, 0.12841360f, 
    0.17299491f, -0.00511696f, -0.00845066f, -0.00608932f, -0.02880202f, 0.05889233f, -0.04543149f, 0.05565290f, 
    -0.04063709f, 0.20827003f, 0.15104264f, 0.12309086f, -0.01886562f, -0.03820075f, 0.00964449f, -0.10588768f, 
    0.06640951f, 0.02026787f, 0.10608718f, 0.14017054f, -0.19615079f, -0.20796077f, 0.12392458f, 0.05581825f, 
    -0.02195070f, 0.05666589f, -0.01763271f, 0.00531696f, 0.02513769f, 0.06733699f, -0.05921770f, -0.08041784f, 
    -0.19025062f, 0.01881346f, -0.04371348f, 0.09977651f, 0.18867849f, 0.09362110f, 0.07332132f, -0.06090432f, 
    -0.05814259f, 0.08806816f, -0.24025898f, 0.12571247f, -0.29860955f, -0.03749969f, -0.05587494f, 0.10218608f, 
    0.21094558f, 0.11155070f, -0.02461572f, -0.04922016f, -0.02580841f, 0.06171461f, -0.03160811f, -0.09874298f, 
    -0.47171283f, -0.22782461f, -0.13699716f, 0.06822679f, -0.03758271f, 0.05179930f, 0.13319954f, -0.03667615f, 
    -0.04757457f, -0.07901032f, -0.11300717f, -0.07662350f, -0.20787795f, -0.28470692f, 0.02105975f, 0.07245839f, 
    0.14140649f, 0.15868755f, -0.00354627f, 0.07822269f, 0.00517780f, 0.01386157f, 0.06889367f, -0.02476775f, 
    -0.05948070f, 0.06919399f, 0.06462751f, 0.10070810f, 0.00846238f, -0.05039266f, 0.13212183f, -0.09454342f, 
    0.07186225f, 0.03344676f, 0.12987559f, 0.05771687f, 0.05690834f, 0.13021325f, 0.00979187f, -0.01080816f, 
    -0.13130696f, -0.10621986f, -0.09356248f, 0.12802060f, 0.07739431f, 0.00357373f, 0.16878672f, 0.13363983f, 
    -0.11559266f, 0.22254485f, 0.15077521f, -0.10627539f, 0.00170818f, -0.06162290f, -0.09122687f, 0.08508402f, 
    0.06884231f, 0.05146676f, 0.11381955f, 0.11459921f, -0.03409858f, -0.04647256f, -0.04419436f, -0.02107053f, 
    0.04198780f, -0.12532371f, 0.04717784f, 0.05771256f, 0.11577795f, 0.05040387f, -0.13416748f, 0.10619013f, 
    -0.27250570f, -0.23517829f, -0.02308414f, 0.01759713f, 0.27567455f, 0.14055902f, 0.08723362f, 0.05594937f, 
    -0.04071337f, -0.15307459f, -0.07871314f, -0.01916946f, 0.30929485f, 0.03507687f, 0.16261123f, 0.13392758f, 
    -0.07853393f, -0.00324972f, -0.02543288f, 0.09907683f, 0.03464583f, -0.08218627f, 0.10849503f, -0.07093278f, 
    -0.29901898f, -0.08350740f, -0.12133150f, -0.15812044f, 0.07816433f, 0.10295390f, -0.00560898f, 0.12902650f, 
    -0.06134297f, -0.10734374f, 0.01624314f, -0.11574113f, -0.34772581f, 0.00135529f, -0.09484677f, -0.01779396f, 
    0.17703690f, 0.15425336f, -0.06158769f, -0.13095112f, 0.06893560f, 0.02118221f, 0.06375024f, -0.02397998f, 
    -0.16489248f, 0.11029802f, -0.13829754f, 0.08540128f, -0.04420954f, 0.05344568f, -0.13848551f, 0.01962094f, 
    -0.02812811f, 0.03266093f, 0.00897333f, -0.06585558f, -0.36287904f, -0.24166289f, 0.05708681f, 0.04229004f, 
    0.05138665f, -0.05440745f, 0.10713910f, -0.22604075f, 0.01952845f, 0.04624141f, 0.03700493f, -0.06760678f, 
    -0.34079033f, 0.00277620f, 0.22052051f, 0.01522842f, -0.05813114f, 0.07692315f, 0.06789224f, -0.05929423f, 
    0.02245421f, -0.00513029f, 0.13877581f, -0.09160142f, -0.11896554f, 0.07826259f, -0.06203235f, -0.07092295f, 
    0.05739227f, 0.01268872f, 0.02639447f, 0.06684132f, 0.11910533f, 0.08656051f, -0.02961177f, 0.02954750f, 
    0.14425603f, -0.08981226f, -0.21359946f, -0.15955092f, -0.03749821f, -0.04024537f, 0.08165186f, -0.02577963f, 
    0.04258586f, 0.11467236f, 0.17014241f, 0.03585897f, -0.13129729f, 0.23909055f, -0.15544377f, -0.08596969f, 
    0.18097542f, -0.03044838f, 0.01118569f, -0.01075275f, -0.04082334f, 0.03784683f, 0.03853770f, 0.13480768f, 
    -0.13257520f, -0.11468425f, -0.04955624f, 0.24838372f, -0.07177526f, -0.04764925f, 0.06845250f, -0.06518035f, 
    -0.03940664f, 0.06587111f, -0.02779214f, 0.03417641f, 0.08688959f, 0.00636302f, 0.10926484f, -0.00484188f, 
    0.08066832f, -0.07393775f, -0.03663620f, 0.07753423f, 0.01705596f, -0.00937454f, 0.02766949f, 0.04204965f, 
    0.20067671f, 0.20860265f, 0.27138212f, -0.00965896f, 0.02225155f, 0.03979612f, 0.08314431f, -0.09033523f, 
    0.05632614f, 0.13367324f, -0.00345523f, 0.10602204f, -0.04003065f, -0.08094892f, 0.16241254f, 0.03954600f, 
    0.20737322f, -0.06815834f, -0.02563702f, -0.00474007f, -0.03626940f, -0.04626796f, 0.13166717f, -0.02714160f, 
    0.27340403f, 0.10789361f, 0.14535692f, 0.00951839f, -0.07669015f, 0.03618487f, 0.04351369f, -0.06648705f, 
    0.04725841f, -0.10103005f, -0.03277448f, -0.02380322f, -0.16371942f, 0.04367929f, 0.17574567f, 0.09544289f, 
    -0.20981748f, -0.00016326f, -0.01671564f, -0.09472755f, -0.02807303f, 0.02661772f, 0.06151578f, -0.01288618f, 
    0.10682776f, 0.04423097f, 0.00141566f, -0.27895576f, 0.09957682f, -0.06283554f, 0.06468073f, -0.05025248f, 
    0.06301315f, 0.00015334f, 0.04474220f, 0.14331241f, -0.24442858f, 0.09553247f, -0.11477901f, 0.06355248f, 
    0.10340887f, 0.05648403f, 0.08665968f, -0.02830535f, -0.08144014f, 0.08331749f, -0.16036944f, 0.11590407f, 
    -0.09887880f, 0.03895275f, -0.14047080f, 0.03818372f, 0.13782856f, 0.07673761f, 0.04033940f, -0.01055810f, 
    -0.04861834f, -0.04026675f, 0.13250557f, 0.08069096f, -0.41954371f, -0.00371675f, -0.19442773f, 0.07307759f, 
    0.16148371f, -0.05425015f, 0.03460801f, -0.02309690f, -0.08733346f, 0.00507987f, -0.01842979f, -0.07711756f, 
    0.14889176f, -0.18598838f, -0.01475420f, -0.03923051f, 0.06198267f, -0.02682404f, -0.12309363f, -0.03732830f, 
    0.04542043f, 0.03109431f, -0.07552148f, -0.10538942f, -0.15573752f, 0.11218420f, -0.13321215f, -0.14037336f, 
    0.09766024f, 0.07793958f, 0.01225577f, 0.08686692f, -0.04254844f, 0.13295950f, 0.05726583f, 0.06894293f, 
    -0.03520821f, -0.02619988f, -0.00353249f, -0.01929703f, 0.00475670f, -0.01256841f, 0.00433675f, -0.01671520f, 
    0.00836908f, 0.02925902f, -0.01868561f, -0.01611997f, -0.03579574f, 0.01548038f, -0.02938615f, -0.02316252f, 
    0.00868774f, 0.01257030f, -0.02903214f, -0.02780806f, 0.00397754f, -0.03504697f, 0.01605378f, -0.01659073f, 
    0.00097908f, -0.04208846f, -0.02875323f, -0.01947104f, 0.00536766f, -0.01173935f, -0.03550886f, -0.03525543f, 
    -0.02814226f, -0.01213157f, -0.01580135f, -0.04139027f, -0.01239226f, 0.01717703f, -0.00633412f, 0.02378138f, 
    -0.03954191f, -0.01639379f, -0.00411022f, -0.02773848f, -0.00194571f, -0.01419520f, -0.00009871f, -0.03876714f, 
    0.01422553f, -0.01389823f, 0.00212447f, -0.00198642f, -0.03417270f, -0.01523189f, 0.01706622f, -0.03100263f, 
    -0.00184082f, -0.00033657f, 0.00423992f, -0.00958129f, -0.01214426f, -0.01997831f, -0.02603094f, -0.03576271f, 
    -0.02116441f, 0.02671589f, 0.00263858f, 0.00722711f, -0.02434446f, 0.00199607f, -0.03379184f, 0.00663645f, 
    0.01634981f, -0.00315906f, -0.03318043f, 0.02669933f, 0.01510327f, -0.00767083f, -0.01231827f, 0.02503649f, 
    -0.02079357f, 0.02603185f, -0.03638520f, -0.03380639f, 0.00177916f, -0.00851400f, -0.03887197f, 0.00708691f, 
    -0.02653379f, -0.02779411f, -0.01185178f, -0.03781717f, 0.00446457f, 0.02079717f, 0.00322057f, -0.01595504f, 
    0.02260952f, -0.02732982f, 0.02440967f, -0.03499348f, -0.03019674f, -0.03439741f, 0.00006187f, -0.02455766f, 
    0.01290872f, 0.01086651f, -0.04226818f, -0.04400027f, -0.00157720f, -0.00503338f, -0.00618959f, 0.01181951f, 
    0.00226688f, 0.00294033f, -0.01883252f, -0.00312118f, 0.01270691f, 0.01834415f, 0.02495571f, 0.02794949f, 
    -0.04016191f, -0.00103955f, 0.01885617f, -0.01539207f, 0.02006446f, -0.04065761f, -0.00387913f, -0.02423233f, 
    0.00046259f, -0.02607311f, -0.01478755f, -0.03843002f, -0.03901127f, 0.01901594f, -0.01781718f, -0.00532560f, 
    -0.04085147f, 0.01895803f, -0.00740175f, -0.01914252f, -0.03937864f, -0.02383878f, 0.02677157f, -0.00821429f, 
    0.00306114f, -0.01043517f, 0.00616576f, -0.00110985f, 0.00620475f, 0.01442213f, -0.02076682f, 0.01397474f, 
    0.02368351f, -0.03706291f, -0.02127803f, -0.02168073f, -0.03398858f, 0.02274648f, -0.02685517f, -0.04362724f, 
    -0.02200706f, 0.01318934f, 0.02006846f, 0.02841053f, 0.00734830f, 0.02514533f, -0.03849107f, 0.01321546f, 
    -0.03803201f, -0.04277201f, -0.03357574f, -0.02840577f, -0.01582770f, -0.03943792f, 0.01191469f, -0.03986691f, 
    -0.02736706f, -0.00964507f, 0.02105310f, -0.00483805f, 0.00602661f, -0.03119905f, 0.01576521f, -0.02700358f, 
    -0.01632403f, -0.00923981f, -0.02865514f, 0.00430186f, -0.02276441f, -0.01755733f, -0.04070468f, 0.01093795f, 
    -0.02344923f, -0.00405048f, 0.02517724f, -0.01757359f, 0.00943476f, 0.00714980f, 0.02746737f, -0.03865706f, 
    0.00860248f, 0.00563887f, -0.03652862f, -0.02441677f, -0.02422747f, -0.02914767f, -0.03124387f, 0.00276333f, 
    0.00229832f, -0.04385238f, -0.02819626f, 0.02269631f, 0.02058912f, -0.04266918f, -0.04108712f, -0.03111359f, 
    -0.00189306f, -0.00144912f, -0.00676607f, -0.02076158f, -0.02870222f, -0.03459051f, 0.02534595f, 0.02332660f, 
    -0.03549453f, -0.04336412f, -0.02300324f, 0.00908714f, -0.01908463f, -0.02448282f, 0.01561888f, -0.00272889f, 
    -0.03525140f, 0.02200144f, 0.02333992f, 0.01672366f, 0.01950408f, -0.01858805f, -0.04226836f, -0.03119480f, 
    0.01784999f, -0.00882659f, -0.04102159f, -0.01058216f, 0.01141942f, -0.03712539f, -0.01595221f, -0.01093103f, 
    -0.00220972f, 0.02427753f, 0.01171620f, -0.02766977f, 0.00059739f, 0.02156407f, 0.01910136f, -0.03492197f, 
    -0.00987923f, 0.01641208f, 0.02629049f, 0.01197706f, -0.03233211f, -0.02617782f, -0.01339192f, -0.02178925f, 
    0.02343507f, 0.00499811f, 0.02153481f, -0.02897940f, -0.00068371f, 0.01275330f, -0.02976112f, -0.01506229f, 
    -0.04234838f, -0.03425391f, 0.01349371f, -0.02486650f, 0.02226304f, 0.02953744f, -0.03507917f, 0.01811413f, 
    -0.00962062f, -0.03561479f, -0.03005696f, -0.00254921f, 0.02193173f, -0.03047656f, -0.02108393f, 0.03664724f, 
    -0.01404299f, -0.02616401f, 0.02689196f, 0.01891324f, -0.04193945f, -0.03040945f, -0.03215989f, -0.00251582f, 
    0.01595113f, 0.00409403f, 0.02135313f, -0.01433858f, -0.00008647f, -0.00411419f, 0.02042979f, 0.03093744f, 
    -0.00820296f, -0.02760551f, 0.02576921f, 0.01847529f, 0.00753431f, -0.00975445f, 0.02564214f, -0.00041358f, 
    -0.02001005f, 0.02293971f, -0.01211607f, 0.01175189f, -0.01297320f, 0.01768233f, 0.00219981f, -0.03484276f, 
    0.00527195f, -0.03839403f, -0.00021171f, -0.00988542f, -0.03398203f, -0.02096239f, 0.02203129f, -0.01122871f, 
    0.01370283f, 0.00499385f, 0.01735263f, -0.02375061f, 0.01861746f, -0.00802619f, -0.03129479f, 0.00546280f, 
    0.00608585f, -0.03703149f, -0.01639747f, -0.00592103f, 0.02061814f, -0.02273484f, 0.02304394f, -0.02979767f, 
    -0.02001362f, -0.00274903f, -0.02566417f, 0.02469948f, 0.02476816f, -0.03630307f, -0.00558334f, 0.00039504f, 
    -0.00169413f, -0.02187287f, 0.02382628f, -0.01359635f, -0.00034274f, 0.01711460f, -0.00604486f, -0.01924119f, 
    -0.00732921f, -0.03147131f, -0.03721647f, -0.01030528f, -0.01993466f, -0.02222178f, -0.00643798f, -0.00868324f, 
    0.00003517f, -0.02416363f, 0.00112729f, 0.02477886f, -0.03332616f, 0.02189673f, 0.01150753f, 0.01376005f, 
    0.00001305f, 0.01737326f, -0.00854369f, 0.02220630f, 0.00447238f, -0.04259115f, 0.00645993f, -0.01276640f, 
    -0.04431207f, -0.04046388f, 0.01985838f, 0.01915418f, 0.03018221f, 0.01809862f, 0.00638322f, 0.00334666f, 
    0.02278417f, 0.01309166f, 0.00260907f, -0.03148366f, 0.01333241f, -0.03390199f, 0.01619544f, 0.00243503f, 
    -0.03877658f, -0.01725335f, -0.00399700f, -0.04224713f, -0.01701894f, -0.00622319f, -0.01354028f, 0.02718049f, 
    0.00628017f, -0.03196845f, -0.03882632f, -0.00908576f, -0.03880475f, 0.00046589f, -0.00949392f, 0.02596662f, 
    0.01625984f, -0.03587095f, -0.00720535f, -0.02219868f, -0.02805265f, 0.01895484f, -0.02820170f, 0.01955036f, 
    0.01542655f, -0.03838174f, -0.02520851f, -0.01464381f, 0.02525349f, -0.01935086f, -0.01182563f, -0.02203280f, 
    -0.00669792f, -0.03780476f, -0.03585873f, -0.02527753f, 0.01811138f, -0.03727112f, 0.01507112f, -0.02559784f, 
    0.01390483f, -0.00494302f, -0.01232574f, 0.01757338f, -0.02689171f, -0.02594062f, 0.00427788f, 0.01615620f, 
    0.00448977f, -0.03116021f, -0.02585662f, -0.00598803f, 0.01361367f, -0.00291799f, 0.01681268f, -0.02396142f, 
    0.02734198f, -0.03867226f, -0.03221361f, -0.04390432f, 0.01315840f, -0.00940715f, -0.03806910f, 0.02822469f, 
    -0.01921854f, 0.00893788f, -0.02222822f, 0.02341523f, -0.02816959f, -0.02450349f, -0.00903474f, 0.02528532f, 
    0.02516816f, -0.03153639f, 0.02376395f, 0.00081262f, 0.02218248f, -0.03431583f, -0.03642161f, 0.01114911f, 
    0.00911386f, 0.01182195f, -0.02251718f, 0.00585356f, -0.01465134f, 0.02405568f, -0.00184404f, 0.02184551f, 
    -0.01004839f, 0.02079490f, -0.04226679f, -0.02266812f, -0.00774900f, -0.00649250f, 0.01247643f, 0.01595914f, 
    -0.02072780f, -0.00117224f, -0.02031611f, -0.03693096f, 0.02578071f, -0.02330370f, 0.00317716f, -0.03998856f, 
    0.01371436f, -0.00085345f, -0.03144123f, -0.03485541f, 0.01832100f, 0.01376304f, -0.02040857f, 0.00987850f, 
    -0.03702141f, 0.00693202f, -0.00828858f, 0.02603099f, 0.01884392f, -0.02996291f, -0.03349903f, -0.03319665f, 
    -0.03323804f, -0.02333475f, -0.01562486f, -0.04089137f, -0.00610771f, 0.02342486f, 0.00974859f, -0.01428401f, 
    -0.00739484f, -0.00466255f, -0.02568063f, -0.00999892f, 0.02531445f, 0.01804371f, -0.00934498f, -0.00169492f, 
    -0.00216382f, -0.02022501f, 0.02639864f, 0.02018899f, -0.01123875f, 0.02655112f, 0.02118234f, 0.02471400f, 
    -0.01698874f, -0.02319143f, -0.01221060f, -0.00479876f, 0.00992689f, 0.00571447f, -0.03737853f, -0.03317253f, 
    -0.02273373f, -0.01429402f, -0.03014795f, -0.03943697f, -0.00252931f, -0.02869937f, -0.02409620f, 0.01852015f, 
    0.01532432f, 0.01683103f, 0.00447600f, -0.00552350f, -0.02695725f, 0.01437328f, 0.00816778f, 0.00252867f, 
    -0.00804314f, 0.00800617f, 0.01986567f, 0.02568596f, -0.00852215f, -0.01283339f, -0.04177593f, 0.00471336f, 
    -0.01906530f, 0.02866378f, -0.01664430f, 0.01725817f, 0.01640775f, -0.00007469f, -0.03662864f, -0.04239912f, 
    -0.03993018f, 0.01489669f, 0.00289586f, 0.00928870f, -0.01688699f, -0.01293997f, -0.00324062f, -0.02860663f, 
    0.02135740f, -0.02573598f, -0.04015240f, 0.01278865f, -0.02237489f, -0.00060992f, -0.01954999f, 0.01931522f, 
    0.03018399f, -0.01295140f, -0.04199261f, 0.03170679f, -0.00870896f, 0.00369811f, -0.03959364f, -0.02671256f, 
    -0.00605815f, 0.00230698f, -0.04077357f, 0.01246614f, -0.01175260f, 0.00948132f, -0.01857147f, 0.02184284f, 
    -0.03213812f, -0.02562975f, -0.01774971f, 0.00267702f, -0.02358653f, -0.01975454f, -0.03912751f, 0.01397294f, 
    0.00101293f, -0.01064959f, -0.03057750f, -0.03553750f, 0.01326385f, -0.03670551f, -0.02514636f, 0.01076172f, 
    -0.03640524f, 0.02122777f, -0.01377007f, -0.02269802f, -0.01221236f, 0.00442234f, -0.03019006f, -0.03631199f, 
    -0.02135062f, 0.02121970f, -0.01871485f, 0.01687457f, -0.02259360f, -0.01278433f, -0.04017120f, -0.02417703f, 
    -0.03044394f, -0.03379543f, 0.01473006f, -0.00966609f, -0.03626582f, -0.00027931f, 0.01340167f, -0.02262202f, 
    -0.00626146f, 0.00376803f, 0.02428514f, 0.00146278f, 0.00981457f, 0.01758740f, -0.02892694f, 0.00363918f, 
    0.00929879f, 0.02072829f, -0.02603059f, 0.01381798f, -0.04051448f, 0.01389609f, -0.01717130f, -0.00646141f, 
    -0.00110757f, 0.01993712f, 0.01493979f, 0.01050188f, 0.02459387f, 0.01070204f, -0.04349621f, 0.00065151f, 
    0.00172699f, 0.00797899f, 0.01914508f, 0.02134951f, 0.02402077f, -0.03033377f, 0.01396376f, 0.01099374f, 
    -0.02495792f, 0.00544941f, -0.00872413f, -0.00777732f, -0.02728871f, -0.02399249f, 0.00532601f, -0.04339567f, 
    -0.02860698f, -0.02016589f, 0.02773259f, -0.00188384f, 0.02003887f, -0.01736362f, -0.00018254f, -0.03335708f, 
    -0.03540295f, -0.03194438f, 0.02628488f, -0.02462175f, -0.03189534f, 0.00419430f, 0.00184309f, -0.02238144f, 
    0.01683228f, 0.01374863f, -0.02385733f, -0.01012277f, 0.00341455f, -0.03257824f, -0.01534727f, 0.02171797f, 
    -0.02211215f, 0.02578588f, -0.00878423f, -0.00113166f, 0.00491947f, 0.00841404f, -0.00633566f, 0.01917961f, 
    0.02474025f, -0.02347480f, -0.01090726f, 0.00918632f, 0.01449284f, 0.02378928f, -0.00560579f, 0.01077963f, 
    -0.01116714f, -0.01217223f, -0.02509452f, 0.01334702f, -0.00048052f, -0.01944982f, -0.02302162f, -0.03722716f, 
    0.00543906f, 0.01436643f, -0.03608574f, 0.01459230f, 0.00374083f, -0.01063323f, -0.02710175f, -0.01015802f, 
    -0.03896392f, -0.01698354f, -0.03061003f, 0.02149228f, 0.01017561f, -0.01337117f, 0.01764538f, -0.03800043f, 
    -0.02150007f, -0.04212731f, 0.02512748f, 0.02304082f, -0.02688520f, 0.01856996f, 0.01626422f, -0.01565771f, 
    -0.01148370f, -0.01601085f, 0.01306374f, 0.01102565f, 0.00540748f, -0.03383060f, 0.01806629f, 0.02393805f, 
    0.00037983f, -0.04043835f, 0.00974224f, 0.01763814f, 0.02430063f, -0.01186402f, -0.02872279f, 0.01558201f, 
    -0.03536064f, -0.01223124f, -0.02891012f, 0.01670902f, 0.00562655f, 0.01180760f, -0.04192502f, -0.03759984f, 
    0.00019574f, 0.01155175f, -0.01227751f, 0.01594917f, -0.03383823f, -0.00134701f, -0.00398704f, -0.01665202f, 
    -0.02557588f, 0.01033303f, 0.00625112f, 0.00588012f, -0.00114181f, 0.02670450f, -0.03430688f, -0.00506046f, 
    -0.01670851f, 0.02164429f, -0.03433378f, -0.02042437f, -0.00229152f, 0.02721018f, 0.00424450f, -0.03623733f, 
    -0.01369617f, -0.03757017f, 0.02441677f, 0.02712068f, 0.02412337f, 0.01107960f, -0.03440492f, 0.01060425f, 
    0.01525460f, 0.02368328f, -0.01288445f, -0.01958532f, -0.01526093f, 0.00177334f, 0.02579772f, -0.02204742f, 
    -0.00336565f, -0.03945076f, 0.01380110f, 0.00846547f, 0.00076740f, 0.00612868f, 0.00078603f, -0.03770775f, 
    -0.02709043f, -0.01177938f, -0.01199242f, 0.01416707f, 0.01935620f, -0.00479328f, -0.01731483f, -0.04064455f, 
    -0.03737127f, 0.00636233f, 0.02039298f, 0.00371027f, -0.02845694f, 0.00083907f, -0.00534448f, 0.02145094f, 
    -0.03081161f, -0.03129993f, 0.01824144f, 0.01762818f, 0.00483084f, -0.02513714f, -0.00305370f, -0.00253673f, 
    -0.03290931f, -0.03398910f, -0.01208720f, -0.00595982f, 0.01054389f, -0.00438061f, 0.02145498f, 0.00142296f, 
    0.03052074f, 0.02154190f, -0.00638416f, 0.01457940f, -0.01819055f, 0.00464099f, 0.00005260f, 0.00837996f, 
    -0.02368100f, -0.01872120f, -0.02040932f, 0.01170481f, 0.02758187f, -0.03028003f, -0.00368713f, 0.01531557f, 
    -0.01067420f, -0.03291036f, -0.00370072f, 0.02932218f, 0.03321702f, 0.00491572f, -0.01794364f, 0.01374585f, 
    -0.03348285f, -0.02283705f, 0.01887434f, -0.04078702f, -0.01349926f, -0.03487696f, 0.00826795f, -0.02324702f, 
    -0.02183638f, -0.02556133f, 0.01478134f, -0.02567664f, -0.00528710f, -0.01957379f, -0.02691034f, 0.02418896f, 
    0.01010761f, 0.00276566f, -0.00313377f, -0.02377220f, 0.02058684f, 0.03228875f, 0.00584767f, -0.01375483f, 
    -0.03465335f, -0.03999554f, 0.02912920f, -0.01881084f, -0.00480731f, 0.01115532f, 0.01789369f, 0.01098322f, 
    -0.02999364f, -0.01404299f, 0.02157344f, -0.03498751f, -0.01125877f, -0.02281470f, 0.00713987f, -0.02182276f, 
    0.01031686f, -0.01304024f, 0.01005630f, -0.01500929f, -0.02216429f, -0.00605131f, 0.02238302f, -0.00272661f, 
    -0.00671765f, -0.02057604f, -0.03680619f, 0.00446653f, -0.03326715f, -0.03736657f, -0.00034986f, -0.01892276f, 
    0.00292036f, -0.00079675f, -0.02566079f, -0.03371644f, -0.04202497f, -0.02431751f, 0.00658888f, -0.00885120f, 
    0.00926127f, 0.00551020f, 0.01440368f, 0.02222151f, -0.03108077f, 0.02876406f, 0.03879078f, -0.04002981f, 
    -0.01818351f, -0.02315898f, 0.00163174f, -0.03233748f, 0.01989029f, 0.00482551f, 0.01099617f, 0.02574991f, 
    -0.02179510f, -0.03391694f, 0.00457528f, 0.02396178f, 0.00784836f, 0.01011898f, -0.01438001f, 0.00663563f, 
    -0.01332954f, -0.03962645f, -0.01482492f, 0.02939874f, 0.02381349f, -0.02424436f, 0.02261074f, -0.01902646f, 
    -0.00124254f, -0.00142442f, -0.00346054f, -0.01839293f, -0.03704233f, 0.01617107f, -0.03144565f, 0.00143370f, 
    0.01556135f, -0.02695518f, -0.02052037f, -0.01955479f, 0.00565993f, -0.00805012f, -0.03133501f, 0.01227513f, 
    -0.01943828f, 0.01231360f, 0.02350546f, -0.01706115f, 0.01923171f, -0.00672786f, -0.01608117f, 0.02655279f, 
    -0.01224482f, -0.02447277f, 0.00416760f, 0.00792189f, -0.01068596f, 0.00694316f, 0.03403124f, 0.00759630f, 
    0.00343821f, 0.00415177f, -0.03480938f, -0.01248453f, -0.03862938f, -0.01233072f, 0.01345961f, -0.01915891f, 
    0.01221505f, 0.01496969f, -0.02578336f, 0.02903447f, 0.01323040f, -0.01053675f, 0.02404366f, 0.00794881f, 
    -0.02030011f, -0.02523902f, 0.02435625f, -0.00027439f, 0.02381439f, 0.01545575f, -0.03548591f, 0.02663568f, 
    0.01826753f, -0.02881757f, -0.01321775f, -0.01668160f, 0.02092568f, -0.02096040f, -0.04053701f, 0.02463884f, 
    -0.00432192f, -0.00655668f, -0.01152783f, -0.04205147f, -0.01096536f, -0.03441041f, 0.01895667f, 0.03220146f, 
    0.00708666f, -0.00145230f, -0.00029198f, -0.02804380f, 0.02701624f, -0.02537750f, 0.02745835f, -0.03092130f, 
    -0.03754868f, -0.01397515f, 0.01072113f, -0.03184836f, -0.00241085f, 0.00428853f, 0.00525756f, -0.00304174f, 
    -0.02141604f, 0.00430517f, 0.02260881f, 0.01345595f, -0.02497312f, -0.03625018f, 0.01207372f, -0.03390918f, 
    -0.00392553f, 0.01359687f, 0.03256542f, 0.02103475f, -0.01719542f, 0.02774558f, 0.02095506f, 0.00135179f, 
    0.00698486f, -0.00078141f, -0.02335855f, -0.03490551f, -0.01568480f, 0.02322930f, 0.01569859f, 0.00908636f, 
    -0.00965338f, 0.02760518f, -0.04238923f, -0.00815047f, -0.00071286f, -0.01439326f, 0.00856478f, -0.00517416f, 
    -0.01032082f, -0.04325806f, -0.03682335f, -0.00384878f, 0.02246609f, -0.04069060f, -0.00029152f, -0.00232346f, 
    -0.03209160f, 0.01746979f, -0.03251921f, -0.00329464f, -0.01942683f, 0.02103699f, -0.00942403f, 0.00799884f, 
    -0.02745988f, 0.00672750f, -0.01809532f, -0.01843038f, 0.00653785f, -0.01582270f, -0.03224257f, 0.02325442f, 
    0.03073702f, 0.02161856f, 0.02596506f, -0.00094774f, 0.02826205f, -0.01889695f, -0.03018721f, 0.01949217f, 
    -0.03601029f, -0.00859787f, 0.01332326f, 0.02607723f, 0.00465769f, 0.01599959f, 0.00047491f, -0.02420229f, 
    -0.00504407f, -0.00214739f, -0.00948161f, 0.02245002f, 0.00958847f, 0.02282825f, -0.00044224f, 0.00699204f, 
    -0.02061440f, -0.01471872f, 0.00516668f, 0.01979010f, 0.02312999f, 0.00989089f, -0.02506943f, -0.03232089f, 
    0.00463657f, 0.02213684f, -0.01473854f, 0.02051754f, -0.02365122f, -0.03685773f, -0.03047962f, -0.01659609f, 
    0.01289478f, -0.00036218f, 0.01004499f, -0.01627197f, 0.03305300f, 0.01901286f, -0.03227459f, 0.01717683f, 
    0.02836276f, 0.02572736f, -0.00035266f, 0.00888585f, 0.00711600f, 0.00623726f, -0.01719439f, -0.04308901f, 
    -0.03743642f, 0.00239269f, 0.03353103f, -0.00577130f, -0.01834497f, 0.02569207f, 0.00551248f, -0.02991981f, 
    0.03235701f, 0.02683314f, -0.01151750f, -0.02344896f, 0.01562820f, -0.00733902f, -0.00676836f, -0.03587549f, 
    0.02221326f, -0.04144154f, -0.00244963f, -0.04119638f, -0.03858665f, 0.02049212f, -0.02225967f, -0.00246948f, 
    0.00653296f, 0.00035353f, -0.02867721f, -0.01643610f, 0.00019630f, 0.00719353f, -0.02912857f, -0.03579353f, 
    0.00583714f, -0.00816976f, -0.00464738f, 0.00698395f, 0.00016833f, 0.03278831f, -0.01152621f, -0.01377049f, 
    0.02101191f, 0.01797238f, 0.01940208f, -0.00483864f, -0.01994920f, 0.00479816f, -0.04024587f, -0.03661036f, 
    -0.00602684f, 0.02572037f, -0.00812038f, 0.00303135f, 0.01082312f, -0.03245128f, -0.02410902f, -0.00742468f, 
    0.01849388f, -0.00114799f, 0.02640578f, -0.02746883f, -0.00633746f, 0.02107173f, 0.02809663f, 0.00873622f, 
    0.02720939f, 0.01547225f, 0.01757403f, -0.00174657f, -0.03676663f, -0.02283616f, 0.01128114f, -0.02515508f, 
    0.02819193f, 0.00312766f, 0.01487198f, 0.01784926f, 0.00702404f, 0.02452691f, -0.02565485f, -0.04235033f, 
    -0.02870105f, -0.02783007f, 0.00535341f, -0.03176505f, 0.02733499f, 0.01147935f, -0.02629529f, 0.00796568f, 
    0.01335270f, -0.01015860f, 0.00219232f, 0.02361595f, 0.00689832f, -0.03474876f, 0.00084010f, 0.02381450f, 
    -0.02898853f, 0.00540112f, -0.04086305f, -0.02107722f, -0.02505981f, -0.02322641f, -0.04253177f, 0.01940195f, 
    0.01989848f, -0.02531086f, 0.00802165f, 0.02372962f, 0.02788953f, -0.01733781f, 0.02442723f, -0.03857266f, 
    -0.02296230f, -0.00480890f, 0.01430175f, -0.03396319f, -0.04297070f, 0.00992011f, -0.04108227f, 0.00654860f, 
    0.02429873f, -0.01111356f, 0.01799229f, -0.01620968f, -0.02936567f, -0.01139606f, -0.02012939f, -0.00328618f, 
    0.01905384f, -0.00978673f, 0.00000224f, 0.01595118f, 0.01629283f, -0.03777834f, -0.02719301f, 0.02762757f, 
    -0.03589594f, -0.03700880f, -0.00020606f, -0.03553618f, -0.01696995f, 0.02063127f, -0.03845036f, 0.02102276f, 
    0.01664557f, -0.04044534f, -0.02104445f, 0.01641521f, -0.02685199f, 0.01443737f, 0.00738062f, -0.02446383f, 
    -0.01376451f, -0.01725348f, -0.01944512f, -0.00712499f, -0.01142289f, -0.00078208f, -0.00816109f, 0.01831629f, 
    -0.01693628f, -0.00278416f, -0.02583080f, -0.02537603f, -0.02184521f, -0.02364751f, -0.01731320f, -0.01643682f, 
    -0.01623678f, 0.02808224f, -0.01126224f, -0.02246942f, -0.00220726f, -0.02553542f, -0.02539973f, -0.03475786f, 
    -0.01390956f, -0.03356767f, 0.02021684f, 0.00541191f, -0.01148186f, 0.02650831f, 0.00343200f, 0.00512859f, 
    0.00754246f, -0.02076194f, -0.01518030f, -0.00846539f, -0.03320563f, 0.02646475f, -0.02563474f, 0.01650771f, 
    -0.01325506f, -0.01134077f, -0.01030372f, 0.01572037f, -0.02040898f, 0.00072071f, 0.02107256f, 0.03140442f, 
    0.00197240f, -0.00200586f, 0.01516512f, 0.00434432f, -0.02527561f, -0.02262723f, 0.03592890f, -0.01924476f, 
    0.00545661f, -0.00825415f, 0.01234911f, -0.02317970f, 0.01685003f, -0.01548218f, -0.04105865f, -0.01756062f, 
    -0.01267208f, 0.01406574f, -0.00154451f, 0.01565306f, -0.02404432f, -0.03757129f, 0.01552208f, -0.00783047f, 
    -0.00060976f, -0.00703821f, -0.01680596f, 0.03102968f, 0.02150868f, 0.02177041f, -0.02810760f, -0.02761327f, 
    -0.00678521f, 0.00272221f, 0.02367106f, 0.02619109f, -0.00873120f, 0.00274654f, 0.00766316f, -0.03661563f, 
    -0.02781060f, 0.03212709f, 0.01552092f, -0.03701569f, -0.03070642f, -0.02922688f, -0.03783977f, 0.01433570f, 
    0.00495782f, -0.02482297f, -0.01540097f, 0.00383498f, -0.02585548f, 0.00549383f, -0.02030484f, 0.00520045f, 
    -0.02058935f, 0.00422610f, -0.01198654f, -0.00383533f, -0.03395656f, 0.01416456f, -0.01401535f, 0.01803032f, 
    -0.03705510f, -0.00638894f, -0.00879759f, -0.03776595f, -0.01572152f, -0.01131143f, -0.01912193f, 0.00275066f, 
    0.02887414f, -0.01059247f, -0.00985351f, -0.01788643f, 0.00347582f, -0.04320566f, -0.00145723f, -0.00892721f, 
    0.01855251f, 0.01677796f, -0.01759471f, 0.00542510f, -0.02966098f, 0.02999114f, -0.01088745f, -0.00308539f, 
    0.01647091f, -0.01256210f, 0.02766682f, 0.02255289f, 0.00249408f, -0.04069736f, -0.02317917f, -0.00014713f, 
    -0.02173055f, -0.00932066f, 0.02079440f, -0.00477578f, -0.02369461f, -0.03669119f, -0.01253133f, -0.00204768f, 
    0.02405736f, -0.02623156f, -0.02361231f, 0.03057168f, -0.02264343f, -0.03350791f, -0.00964170f, 0.02379253f, 
    -0.02827407f, 0.01454661f, 0.00136754f, -0.00368679f, -0.01158587f, -0.00607366f, -0.00709841f, -0.02607554f, 
    0.01750831f, 0.02595205f, -0.00617544f, -0.01409578f, -0.03442836f, -0.02007072f, 0.00897541f, -0.00365246f, 
    -0.03598312f, -0.00372104f, -0.01647399f, -0.00164856f, -0.00753185f, 0.02368944f, 0.00892668f, -0.01932597f, 
    -0.02167930f, 0.00959195f, 0.02890494f, -0.00423536f, -0.02288818f, 0.01202399f, 0.02197772f, -0.03702600f, 
    -0.08163059f, 0.19910307f, -0.18736215f, -0.03225585f, 0.06073241f, 0.02157982f, -0.05101628f, -0.09856108f, 
    0.05855413f, -0.03012411f, -0.00064045f, -0.12160265f, 0.03615866f, 0.20597461f, -0.02776640f, 0.16293418f, 
    0.00976441f, -0.11366985f, 0.02911440f, 0.08190608f, -0.09536106f, 0.14479288f, 0.00456285f, -0.04937861f, 
    0.03134302f, 0.03427000f, 0.03385824f, 0.08838385f, -0.04676925f, 0.09246478f, -0.00440463f, 0.05631565f, 
    0.03760425f, 0.02962385f, 0.06532167f, 0.03402561f, -0.20803696f, 0.07481948f, -0.04903764f, -0.13218434f, 
    0.05025700f, 0.00030235f, -0.00717837f, -0.02160345f, 0.00801061f, 0.06550715f, -0.03957111f, -0.00965890f, 
    0.19542566f, -0.07446120f, -0.00124882f, 0.14393674f, -0.01786872f, 0.08386249f, 0.04300822f, 0.10561798f, 
    -0.00724410f, 0.06635373f, -0.06971812f, 0.10486929f, 0.02814966f, 0.14127751f, 0.03391900f, 0.06320360f, 
    -0.13973592f, 0.08959676f, 0.12737046f, 0.15432569f, -0.08386808f, -0.15427822f, -0.03118576f, -0.07301924f, 
    -0.23615147f, -0.00775291f, -0.05012720f, -0.02982606f, -0.03687831f, -0.08361439f, 0.09226256f, -0.02818229f, 
    -0.06187030f, 0.14482181f, 0.13089496f, 0.14306499f, -0.15310739f, -0.00977675f, 0.01203738f, 0.17578988f, 
    0.05270023f, 0.01757363f, -0.00731213f, 0.01195017f, -0.10698368f, -0.03334294f, 0.11654686f, 0.07188854f, 
    -0.13780928f, 0.25359720f, 0.07932550f, -0.00812133f, -0.02584086f, 0.02392131f, 0.07410803f, 0.14096075f, 
    0.14558473f, 0.04043412f, 0.02201936f, -0.06016637f, 0.24089468f, -0.16655102f, 0.05666995f, -0.02372668f, 
    0.01781687f, 0.00379819f, 0.00384367f, -0.04731843f, -0.00512874f, 0.10124510f, -0.07354286f, 0.03426063f, 
    -0.19606555f, 0.09860078f, 0.08509749f, 0.09082200f, 0.04687887f, 0.16467950f, -0.00288704f, -0.08324098f, 
    0.08221789f, 0.09425366f, 0.11568914f, -0.03715525f, -0.07671607f, 0.06960564f, 0.17816076f, 0.12856631f, 
    0.10638440f, 0.07648399f, 0.07241448f, 0.04499732f, -0.03690365f, -0.00716733f, 0.09673170f, 0.17400292f, 
    0.17969677f, 0.04641171f, 0.06791972f, -0.02392168f, -0.06575733f, 0.07377736f, -0.11110925f, 0.04533411f, 
    -0.11345766f, 0.01426368f, 0.01659131f, 0.02034691f, -0.03657443f, 0.01113510f, 0.04144972f, -0.08595267f, 
    -0.04992819f, 0.11867847f, 0.03976532f, -0.07106025f, 0.01555317f, 0.08926924f, -0.03780579f, 0.13139768f, 
    -0.06557919f, -0.03912193f, -0.03191100f, -0.16578488f, 0.04301102f, 0.03638934f, -0.00641190f, 0.01161311f, 
    0.02754345f, -0.01044899f, -0.20817111f, -0.02957937f, 0.18993412f, 0.09297226f, -0.05718042f, 0.11135568f, 
    0.04418070f, 0.04293428f, -0.08439627f, 0.08574652f, 0.02238437f, 0.17392327f, 0.01436125f, 0.04004703f, 
    0.31051317f, 0.06439213f, 0.09366593f, -0.12746972f, 0.13112633f, -0.01676427f, -0.05389329f, -0.03218002f, 
    -0.04591370f, -0.04958899f, -0.00693150f, 0.03156996f, 0.21288894f, -0.03773328f, 0.15624234f, 0.02910680f, 
    -0.00182907f, 0.04801673f, 0.03210127f, -0.06291184f, -0.02345673f, 0.12259381f, -0.04474447f, 0.10043926f, 
    -0.03191466f, -0.10880516f, -0.01608284f, 0.11727083f, -0.00845915f, 0.11790501f, 0.11281203f, -0.09855915f, 
    -0.03614824f, -0.12915242f, 0.07815307f, -0.00044603f, 0.21315949f, -0.02960580f, 0.14190637f, 0.03786768f, 
    0.06005313f, 0.06008246f, -0.08263323f, -0.08390157f, -0.10925968f, -0.03680920f, -0.00582171f, -0.02755253f, 
    -0.13816866f, 0.10303041f, 0.14994857f, 0.11633263f, -0.07877400f, 0.02420664f, 0.04168511f, 0.14463384f, 
    0.07149522f, 0.04179373f, -0.02536185f, -0.14466392f, -0.08303623f, 0.05560688f, 0.07252278f, -0.07373002f, 
    -0.01815872f, -0.06255908f, 0.00117754f, 0.00124278f, 0.01681228f, -0.01644454f, 0.05447917f, 0.00198719f, 
    -0.27554443f, 0.10015198f, 0.06054214f, -0.11586040f, 0.00395539f, 0.04516290f, -0.01829702f, -0.04645012f, 
    -0.04638229f, 0.03395969f, -0.06726646f, -0.00520340f, 0.00305918f, 0.16957226f, -0.14392889f, -0.21306901f, 
    -0.03397676f, 0.06218710f, -0.01136682f, 0.01778916f, -0.03591697f, 0.01454337f, -0.01787731f, -0.02424958f, 
    -0.23861159f, 0.24660388f, -0.05016475f, 0.06580657f, 0.05076044f, 0.06182937f, 0.03529254f, -0.16990159f, 
    -0.03259062f, -0.02964595f, -0.03687678f, 0.06460306f, -0.06403778f, -0.22219880f, -0.11216465f, -0.04564497f, 
    -0.03707232f, 0.00304552f, -0.07845126f, -0.12014174f, -0.07986919f, -0.10837449f, 0.09381098f, -0.05399347f, 
    -0.11960008f, 0.11126366f, 0.18739440f, 0.08020608f, -0.11154208f, 0.07352115f, 0.13659845f, 0.01748637f, 
    0.03005021f, -0.02408001f, -0.04091121f, -0.02729190f, -0.12070570f, -0.11682044f, 0.07777571f, 0.07676633f, 
    0.00709409f, 0.06204588f, 0.07751929f, -0.10261558f, -0.03817455f, 0.00358487f, -0.02328464f, -0.05067640f, 
    0.09052608f, 0.02162749f, 0.10333765f, -0.00603372f, -0.00922886f, -0.00519647f, -0.10643862f, -0.02424709f, 
    0.06152716f, 0.07251734f, -0.06900547f, -0.03366289f, 0.18709444f, 0.00053543f, 0.04494978f, 0.03862415f, 
    0.01479400f, 0.02306840f, 0.04144466f, 0.10898038f, 0.06540524f, 0.05607506f, 0.14500363f, 0.27382076f, 
    -0.04016858f, -0.03223704f, -0.02723735f, -0.01025277f, 0.08827811f, -0.05494922f, 0.04177466f, 0.13054846f, 
    -0.00763427f, 0.08922898f, 0.00976656f, 0.05053931f, -0.02549520f, 0.08696361f, -0.04251157f, 0.19033578f, 
    0.00839142f, 0.02095979f, 0.05002013f, 0.08483123f, -0.02192806f, -0.10876375f, 0.16414380f, 0.07721891f, 
    -0.11081591f, 0.06613228f, 0.08094229f, -0.09052725f, -0.09612394f, 0.04243340f, -0.01329809f, 0.04758874f, 
    -0.00178958f, -0.07443168f, -0.00343499f, -0.11257892f, 0.18038782f, 0.23713292f, 0.01847788f, 0.02014171f, 
    0.04620757f, -0.05876107f, 0.08444991f, -0.03693299f, -0.00739137f, -0.13527803f, 0.02237688f, -0.02103260f, 
    -0.03511639f, 0.13872862f, -0.04064906f, 0.15026927f, 0.02588289f, -0.03942084f, -0.05810091f, -0.04259359f, 
    0.06799439f, -0.08531715f, 0.17405455f, 0.04951586f, -0.16543163f, 0.09655612f, 0.22877997f, 0.10482466f, 
    0.02225411f, 0.01470018f, 0.05722556f, 0.14921030f, 0.01215553f, 0.07949971f, -0.08580276f, 0.15458135f, 
    0.33474946f, 0.16905648f, -0.01316947f, -0.02594808f, 0.11301128f, 0.01873398f, -0.10441031f, 0.02513271f, 
    0.06354973f, 0.02704795f, 0.15748785f, 0.12105467f, -0.08298964f, 0.10033747f, 0.07889610f, 0.23248214f, 
    0.00991660f, -0.09917389f, 0.07936711f, 0.08358203f, 0.00230891f, 0.03364932f, -0.03576725f, 0.12385996f, 
    -0.26458016f, 0.16110593f, -0.01944137f, 0.03752827f, -0.05432095f, 0.05128720f, -0.06106886f, 0.07961560f, 
    -0.08689347f, -0.02373911f, -0.09745429f, -0.08854736f, 0.02919618f, 0.09274027f, 0.10525466f, 0.10518956f, 
    -0.01936770f, -0.01074327f, 0.00387712f, -0.16121186f, -0.00931441f, 0.01211536f, -0.19393630f, -0.08640272f, 
    -0.01873263f, 0.08142120f, 0.03355828f, 0.01736650f, 0.02384076f, 0.01193311f, 0.02266765f, -0.05665145f, 
    -0.02095465f, 0.13646014f, -0.12788974f, -0.02684695f, -0.17497127f, 0.14752917f, 0.04249660f, -0.01185590f, 
    0.04135102f, 0.03417809f, -0.02322848f, -0.02166706f, 0.07173706f, 0.01518626f, 0.05519690f, -0.00684034f, 
    0.09912016f, 0.01217131f, 0.10543935f, 0.17418374f, -0.02583115f, 0.03608195f, -0.07746208f, 0.07015911f, 
    -0.05122411f, 0.13050331f, 0.01033502f, 0.00271209f, 0.03326973f, -0.26977819f, 0.05996926f, 0.06204692f, 
    0.02017613f, 0.01215202f, 0.06925531f, -0.12000168f, -0.14632060f, 0.11311878f, -0.03179578f, 0.04012953f, 
    0.17658706f, 0.13571952f, 0.03886633f, -0.04914902f, -0.04625103f, -0.04680157f, 0.11017681f, -0.07155338f, 
    0.00868625f, 0.15105142f, 0.03468331f, 0.11252478f, -0.03381345f, -0.19111355f, -0.01733906f, 0.05404810f, 
    -0.07210790f, 0.09212559f, 0.23880562f, 0.13733280f, 0.07712910f, 0.06994108f, -0.04527368f, 0.16077849f, 
    0.15753090f, -0.13636801f, 0.00948358f, -0.03614875f, 0.02835968f, -0.05362584f, 0.13238133f, 0.01365303f, 
    -0.01844091f, 0.00874030f, 0.01909021f, 0.01005229f, 0.45374584f, -0.01151191f, 0.04520943f, 0.03754302f, 
    0.07786860f, 0.06171954f, 0.04987989f, 0.19814086f, 0.00036091f, 0.00338437f, 0.06092990f, 0.04456536f, 
    0.03821179f, 0.23402829f, 0.05832039f, -0.07484502f, 0.06841867f, -0.03184579f, 0.03015460f, 0.02046168f, 
    -0.01035215f, 0.08757208f, -0.08574100f, 0.09788553f, 0.04535092f, -0.01642881f, -0.04357151f, 0.01071834f, 
    0.04496245f, 0.04436037f, 0.01574060f, 0.06351947f, 0.05947725f, -0.13687189f, 0.09097935f, 0.04300202f, 
    0.13910110f, -0.05109336f, 0.26271820f, 0.10561285f, 0.06981915f, -0.00257116f, -0.03942541f, 0.01250717f, 
    0.03404455f, -0.10206471f, -0.12958518f, -0.01300193f, 0.36796346f, -0.13597295f, 0.03011650f, -0.18420705f, 
    0.03855478f, 0.01866187f, 0.00660975f, 0.01293808f, 0.06717472f, 0.01029341f, -0.00412060f, -0.02584719f, 
    0.26495025f, -0.01604397f, 0.00170366f, -0.09108079f, 0.10118860f, 0.01896756f, -0.03636292f, -0.03034750f, 
    0.01254507f, -0.03334600f, 0.07237676f, 0.02130873f, -0.05100257f, 0.04829770f, -0.08247710f, 0.16002308f, 
    -0.03736063f, 0.05255033f, -0.03662066f, 0.05596250f, 0.00133301f, 0.00145574f, 0.09793899f, 0.04532757f, 
    -0.33197501f, 0.17897321f, -0.04062568f, -0.02211519f, 0.01753337f, -0.00579078f, -0.06305740f, 0.01594011f, 
    0.00371958f, -0.03575503f, 0.11770800f, -0.12177665f, 0.04118023f, -0.11836881f, 0.02606755f, -0.01343357f, 
    -0.06515669f, 0.08343247f, -0.02837020f, -0.03877465f, -0.04681777f, -0.01598926f, -0.07787498f, 0.02345102f, 
    -0.27514434f, 0.05904701f, 0.03742941f, -0.05060128f, -0.05352038f, 0.13289435f, 0.04941086f, -0.00952046f, 
    0.00747511f, 0.12076979f, 0.03704035f, 0.03562767f, 0.26266414f, 0.23391958f, -0.06608475f, -0.05763466f, 
    0.01241766f, -0.02891628f, -0.02278240f, 0.15122434f, 0.06180547f, 0.06069169f, 0.04135090f, 0.03434978f, 
    -0.09375723f, 0.19066161f, -0.20484407f, -0.05863442f, 0.04402125f, 0.01270815f, -0.02812877f, 0.02598456f, 
    0.02932393f, 0.01952276f, 0.11710414f, -0.03797123f, 0.28889686f, -0.00677263f, 0.06195341f, 0.10706957f, 
    0.00346082f, 0.12802008f, -0.08770894f, 0.08460080f, 0.01327464f, -0.08176825f, 0.18157083f, 0.00316680f, 
    0.19779457f, -0.05791187f, 0.19616883f, 0.05903397f, 0.01088905f, -0.07243257f, -0.00685938f, -0.02862814f, 
    0.05074006f, 0.09296355f, -0.06572734f, -0.02759846f, 0.07009764f, 0.01170604f, 0.22859183f, -0.11908948f, 
    -0.00061506f, 0.01664644f, 0.03009338f, -0.00554259f, 0.09665250f, 0.14384909f, -0.05390448f, 0.11111847f, 
    0.18560079f, -0.03513069f, 0.16254333f, 0.09545232f, -0.01605998f, 0.14585064f, 0.11340966f, 0.07364196f, 
    -0.06045638f, 0.08616968f, 0.08819550f, 0.15948352f, 0.24478912f, -0.03713538f, -0.03175719f, -0.03987228f, 
    0.10146940f, -0.03228129f, 0.03240487f, -0.02594544f, 0.13919207f, -0.07606205f, -0.11509437f, -0.03861769f, 
    0.08198870f, -0.18616025f, 0.17663439f, 0.19158620f, -0.09680180f, -0.07544448f, 0.03569345f, 0.03516725f, 
    -0.09545859f, 0.09759931f, 0.02014629f, 0.17753997f, 0.03843785f, -0.24227138f, 0.00488173f, 0.01344311f, 
    0.01159385f, 0.12536870f, 0.00756779f, -0.04811761f, 0.14339325f, -0.04296482f, 0.05015909f, 0.07137015f, 
    -0.00885128f, -0.02790428f, -0.04738845f, -0.17344457f, 0.05226074f, -0.05238318f, -0.00275853f, -0.08575020f, 
    0.05495310f, -0.01541147f, 0.00473479f, 0.05875243f, 0.06064116f, -0.08476952f, 0.05271206f, 0.06031406f, 
    -0.02538941f, -0.00498416f, -0.01481645f, -0.04116209f, -0.00955671f, -0.01965389f, 0.09922726f, -0.00736217f, 
    -0.00228032f, 0.06387676f, -0.03374136f, -0.16919935f, 0.07343770f, -0.08459877f, -0.05263842f, -0.07986438f, 
    -0.02265893f, 0.01923754f, 0.01102077f, -0.00015970f, -0.01890869f, -0.09105789f, -0.08456122f, 0.01551146f, 
    0.17198770f, -0.07762052f, -0.04643862f, -0.10068224f, 0.08591668f, 0.19302216f, 0.04027709f, 0.08189451f, 
    0.12196779f, -0.06684564f, -0.09426401f, -0.16790403f, 0.04953699f, 0.04690005f, -0.05834218f, 0.01142767f, 
    0.08692186f, -0.07332465f, -0.11623502f, -0.12291483f, 0.36582488f, -0.08126092f, -0.02855883f, -0.22364691f, 
    -0.00983125f, 0.01578416f, 0.05899137f, -0.01308930f, 0.08605741f, 0.08117040f, -0.13830110f, -0.06334246f, 
    0.12933350f, -0.20825502f, -0.10473628f, -0.12658857f, -0.02378929f, 0.02296921f, 0.00838411f, -0.08812717f, 
    -0.03724713f, 0.01052397f, 0.00741021f, 0.08263274f, -0.11348291f, 0.20108329f, -0.02150762f, 0.02276058f, 
    0.06483267f, 0.03106438f, 0.00175663f, 0.06169125f, 0.03124061f, -0.06352074f, 0.02424380f, -0.01779891f, 
    0.28249973f, 0.01652241f, 0.04009310f, -0.01402353f, 0.04283125f, -0.08807618f, -0.00788638f, 0.09459449f, 
    -0.03979533f, -0.04729398f, -0.00295659f, 0.09662320f, 0.12104114f, 0.10235757f, -0.21274130f, -0.05502181f, 
    -0.06117548f, -0.00746053f, -0.02854727f, -0.00504202f, 0.06946138f, -0.04255993f, -0.04257305f, -0.12253593f, 
    -0.10327587f, 0.07104383f, -0.02174853f, 0.04905752f, 0.12272249f, -0.00371482f, 0.06941786f, -0.04624587f, 
    0.03379811f, 0.08417146f, 0.05015521f, -0.01623183f, 0.15273678f, -0.07331623f, -0.21560131f, 0.10286999f, 
    0.09283545f, -0.10161943f, -0.10004237f, -0.01012492f, -0.00652236f, -0.02903672f, 0.11618917f, -0.08104552f, 
    0.07810542f, -0.10651708f, 0.06621763f, 0.24636941f, 0.04629394f, -0.05136602f, -0.02000071f, -0.00285894f, 
    -0.03386497f, 0.10530529f, 0.18406057f, 0.09776694f, -0.19518425f, -0.07122386f, 0.10424808f, 0.01351086f, 
    -0.00624047f, 0.03203963f, 0.09821416f, -0.06156170f, 0.02310262f, -0.08573805f, -0.02791857f, -0.00492243f, 
    -0.31379035f, 0.00395890f, -0.06669786f, 0.32550707f, -0.05714839f, 0.06045316f, 0.08782333f, 0.03235330f, 
    0.03870083f, 0.10372656f, 0.01438888f, -0.03422911f, 0.02429651f, 0.08803919f, -0.07528903f, 0.06817308f, 
    0.00938748f, -0.01022795f, -0.03735514f, 0.05315593f, 0.08943062f, -0.03121632f, 0.08930141f, -0.00180871f, 
    0.01714773f, 0.26012319f, 0.01155466f, -0.12405505f, 0.15879235f, -0.10429293f, -0.06960697f, 0.10651597f, 
    0.01420266f, 0.13523236f, 0.00758129f, -0.00923718f, -0.16715778f, 0.09666982f, -0.11719275f, -0.08769484f, 
    0.07218693f, -0.02848767f, 0.10582314f, 0.05408363f, 0.08513992f, 0.10502097f, -0.01314470f, 0.03132457f, 
    0.10079853f, -0.08199029f, -0.12196705f, -0.05108668f, 0.07460891f, -0.01573835f, -0.04104126f, -0.10055743f, 
    -0.01065315f, -0.00119859f, -0.01331222f, 0.13991383f, 0.00145552f, -0.00384964f, -0.04903728f, 0.01550691f, 
    0.02055096f, 0.03746499f, -0.00301471f, 0.01261169f, -0.02144274f, 0.02042190f, -0.04789996f, 0.02171303f, 
    0.12705377f, -0.09432448f, -0.06073233f, -0.00782823f, 0.05369062f, -0.05354455f, -0.02997022f, -0.02046431f, 
    0.02742019f, 0.00974347f, 0.06596820f, 0.04363094f, -0.06019070f, -0.22401796f, 0.09976542f, 0.33274844f, 
    0.04942629f, 0.03359955f, 0.00228431f, 0.01277829f, 0.01013779f, 0.06314364f, 0.02703521f, 0.01249526f, 
    0.35534129f, -0.10932244f, 0.09433084f, 0.08281699f, 0.02313156f, 0.00695944f, 0.05168307f, 0.12982529f, 
    0.05823839f, 0.05544581f, 0.15737619f, -0.01743142f, -0.15976027f, 0.14739689f, 0.07925757f, -0.13835558f, 
    0.08620385f, -0.06520531f, 0.01419123f, 0.04571029f, 0.09265704f, 0.05410661f, 0.02952999f, 0.12155562f, 
    0.11744171f, 0.06829123f, -0.12182867f, 0.05825874f, 0.14836709f, -0.04960649f, -0.12928875f, 0.02361273f, 
    -0.02039830f, 0.09761204f, 0.04581927f, 0.03152416f, 0.03155651f, 0.21591061f, -0.06883420f, 0.00664656f, 
    0.08986842f, 0.01155928f, -0.00068941f, 0.10900084f, 0.03767942f, -0.02065349f, 0.07784068f, 0.00403338f, 
    0.10061689f, 0.09938511f, -0.10089721f, 0.06546234f, -0.01368827f, 0.06499489f, 0.08146714f, 0.07895223f, 
    0.03912257f, -0.01945386f, 0.03735270f, 0.11468820f, -0.12586185f, 0.03584542f, -0.02246447f, 0.03922219f, 
    -0.00408123f, 0.01195619f, -0.10702733f, -0.09113834f, -0.00648441f, 0.02565517f, -0.04803099f, -0.18402226f, 
    0.02739536f, 0.10217454f, -0.01835184f, -0.11718270f, -0.02706141f, 0.12665008f, -0.02743166f, -0.06695403f, 
    0.08791874f, -0.05550641f, -0.01163336f, 0.00861130f, 0.14597066f, 0.09500168f, 0.10526998f, -0.07219775f, 
    0.00805359f, -0.01975103f, 0.03284578f, -0.03946970f, 0.00631749f, 0.08830643f, -0.13916624f, -0.04251562f, 
    0.23546875f, 0.02455840f, -0.06687474f, 0.08955758f, 0.05676388f, -0.04726597f, -0.01348185f, -0.02588381f, 
    0.00031649f, 0.08318015f, 0.04600168f, 0.13998178f, -0.06514497f, -0.10530468f, 0.05831198f, 0.18438745f, 
    -0.05796768f, 0.07642510f, -0.03648079f, 0.07113116f, 0.00730980f, 0.15484126f, 0.05711567f, 0.05354999f, 
    0.15287584f, -0.13039547f, 0.14494577f, -0.10473560f, 0.01037930f, 0.05795784f, 0.14253029f, -0.00758999f, 
    0.01953480f, 0.11164998f, -0.14037116f, 0.04420429f, 0.30260700f, -0.07933419f, -0.34356892f, -0.18418935f, 
    -0.13106437f, 0.02011936f, -0.00429636f, -0.07147666f, -0.02261608f, -0.04697259f, 0.13624148f, -0.09932703f, 
    -0.19695780f, -0.08577874f, 0.13402879f, 0.23839195f, -0.09906612f, 0.10083911f, 0.11003811f, 0.03143534f, 
    -0.06520880f, 0.05150149f, -0.07107820f, -0.02950374f, 0.20973270f, 0.04970671f, -0.08187945f, -0.21864292f, 
    0.01051109f, 0.16077276f, -0.01523032f, -0.08281838f, 0.02134221f, -0.07738513f, 0.10851057f, -0.10025417f, 
    0.18200818f, -0.16793957f, -0.01980541f, -0.03684129f, 0.11812993f, -0.07176302f, 0.02870724f, 0.02300504f, 
    0.11070418f, 0.03032648f, 0.03903048f, 0.12602067f, 0.14286612f, 0.00230045f, -0.10800367f, -0.02838160f, 
    0.14554900f, -0.01033633f, 0.03092627f, 0.06980620f, -0.09250396f, 0.04439732f, 0.22590540f, 0.08069366f, 
    0.09030332f, -0.09313122f, 0.02403648f, 0.04777129f, 0.01175649f, -0.08640119f, 0.01219684f, -0.04700313f, 
    -0.01400359f, -0.09489624f, 0.13664208f, 0.08504283f, 0.19595723f, -0.18451601f, -0.18539606f, -0.11177000f, 
    -0.07526848f, 0.04474499f, 0.10544226f, 0.05617931f, 0.02593412f, 0.06434291f, -0.00635971f, 0.03575058f, 
    0.04788902f, 0.05718594f, -0.13658823f, -0.23895290f, 0.05220396f, -0.00450708f, 0.08208491f, -0.13384119f, 
    0.00671808f, -0.06576617f, -0.02578633f, 0.03957070f, 0.03174167f, 0.38049331f, -0.09760603f, 0.08269744f, 
    0.03895181f, 0.08016293f, -0.11650507f, 0.10714965f, 0.05571077f, -0.06841493f, 0.02308811f, 0.01312107f, 
    -0.03341075f, -0.10224625f, 0.00667750f, 0.07154869f, 0.08530214f, 0.05984502f, -0.03093390f, 0.03740145f, 
    0.13459876f, -0.06807797f, -0.00873549f, -0.10062926f, 0.17822479f, 0.19871852f, -0.07263051f, -0.13884221f, 
    0.12093783f, -0.06003383f, -0.15943602f, -0.09073092f, -0.05761532f, -0.08489432f, 0.06352459f, -0.08631331f, 
    -0.05513411f, 0.15648289f, 0.10620974f, 0.10351563f, -0.00632727f, 0.08550809f, -0.13730928f, 0.09745410f, 
    -0.07658516f, 0.03799453f, 0.03412174f, -0.01527745f, -0.43666473f, 0.10718454f, -0.04954838f, -0.08442687f, 
    -0.05898593f, 0.04723445f, -0.08707114f, -0.11727495f, 0.01440096f, -0.03953796f, 0.00961863f, -0.00151308f, 
    0.14000115f, -0.24731839f, -0.03617628f, 0.19561148f, -0.01900134f, 0.01525673f, -0.01221274f, 0.01954056f, 
    -0.00619651f, 0.03800823f, 0.02793008f, -0.03971324f, -0.01202618f, 0.06233869f, 0.09026349f, -0.11569003f, 
    0.03612132f, 0.00315149f, -0.06226128f, -0.03805770f, -0.08980259f, 0.08820294f, -0.06502378f, -0.04932190f, 
    0.05143948f, 0.16266550f, -0.10879112f, -0.00282174f, 0.02946478f, 0.00161207f, 0.04802721f, 0.04342286f, 
    -0.01095033f, 0.17829323f, 0.08704527f, 0.05522712f, -0.18252510f, 0.04814892f, 0.04303753f, 0.27247486f, 
    0.01943954f, 0.06190228f, -0.05064430f, 0.02314385f, -0.02754178f, 0.01146536f, 0.07938044f, -0.03151484f, 
    -0.18832406f, 0.09073195f, 0.11957257f, 0.32024300f, -0.08122542f, 0.01647381f, 0.03830193f, 0.09729799f, 
    0.03095575f, 0.13197692f, -0.05622392f, 0.03203867f, 0.14993618f, 0.06631475f, 0.16575332f, -0.10281815f, 
    0.07835345f, -0.03619212f, -0.00212614f, -0.07708141f, 0.02222310f, 0.06679578f, -0.10111389f, -0.07408635f, 
    0.17330551f, -0.25241548f, -0.09287509f, -0.01324851f, 0.01197685f, 0.02704357f, -0.00010780f, -0.02203818f, 
    0.06807294f, 0.07685927f, -0.04499501f, 0.14480524f, 0.02114697f, 0.15224542f, 0.00288235f, 0.02562856f, 
    0.05083208f, -0.05624402f, 0.01153796f, 0.04306535f, 0.03657064f, 0.07231089f, 0.13509846f, 0.04772395f, 
    0.06161422f, -0.18238246f, -0.08866057f, 0.02964189f, 0.10014458f, -0.05067977f, 0.02084607f, -0.08375476f, 
    0.03954100f, -0.00942560f, 0.01933875f, 0.00950097f, -0.18578519f, -0.20594478f, 0.12422176f, 0.33520502f, 
    0.04368662f, 0.06579808f, 0.02181192f, -0.11378701f, 0.01797440f, 0.00603354f, -0.04531982f, 0.00069046f, 
    -0.02253528f, -0.20373061f, 0.11930712f, -0.09341051f, -0.04771404f, -0.12645160f, 0.01086630f, -0.05920837f, 
    -0.00829672f, 0.03143521f, -0.08241151f, -0.00504398f, -0.11963511f, 0.06243858f, -0.00730922f, -0.02271445f, 
    -0.03504650f, -0.05170956f, 0.12106405f, 0.00168764f, 0.01635322f, 0.10570517f, -0.19025342f, 0.00919079f, 
    0.02543054f, 0.24274525f, -0.07924952f, 0.02620952f, -0.01351399f, 0.04883743f, -0.01577745f, 0.05409142f, 
    0.04369560f, -0.04671275f, 0.06002624f, 0.05989188f, 0.09454004f, 0.09993032f, -0.16621704f, 0.14288719f, 
    -0.02681231f, 0.08229186f, 0.05108949f, 0.03453208f, -0.05354861f, -0.14585096f, 0.10585219f, -0.07392247f, 
    -0.30061379f, 0.07965626f, -0.26688027f, -0.03204110f, -0.00204394f, -0.08267292f, -0.15819871f, -0.02560471f, 
    0.09500284f, -0.01699016f, -0.07936936f, -0.06607095f, -0.08819453f, 0.03117043f, 0.20381229f, 0.11514535f, 
    -0.03511958f, 0.09846468f, 0.03461396f, 0.01338903f, -0.06720843f, 0.07508547f, 0.04187160f, 0.02283718f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01308507f, 0.01824423f, -0.01220761f, -0.03523319f, 0.02270726f, 0.03241697f, -0.02134178f, -0.01866324f, 
    -0.06526845f, -0.03130424f, 0.03936226f, -0.00823748f, -0.01318814f, 0.00572293f, 0.10295285f, -0.03258689f, 
    -0.02379686f, -0.04089131f, 0.02827770f, 0.04055111f, 0.03885355f, 0.01717734f, -0.03635785f, 0.03380356f, 
    0.00072032f, 0.02384340f, -0.00397640f, 0.05737013f, -0.02804590f, 0.00961389f, -0.02777575f, 0.07567852f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.17697459f, -0.16575697f, -0.25763959f, -0.10281010f, -0.00577131f, -0.35873407f, 0.15478165f, 0.09490731f, 
    0.42975235f, 0.12571530f, 0.21503180f, -0.12956391f, 0.02900049f, -0.19748634f, -0.19759561f, 0.05715227f, 
    0.14151068f, -0.43992668f, 0.01864773f, -0.12795712f, 0.06947643f, 0.14951830f, 0.07284186f, -0.21311069f, 
    0.14487362f, 0.15688534f, 0.16371042f, -0.09365584f, 0.14484642f, 0.09525171f, -0.08830677f, 0.08387128f, 
    -0.17358342f, 0.09415293f, -0.20348233f, -0.08507714f, -0.01879092f, 0.37998170f, -0.04709437f, -0.35488904f, 
    0.18478368f, -0.32103571f, 0.24230585f, -0.01472429f, 0.10551471f, 0.22180742f, -0.29115975f, 0.11924204f, 
    -0.16152401f, -0.01328810f, 0.13888720f, 0.00390572f, -0.12824658f, -0.12448425f, -0.06220820f, 0.28204897f, 
    -0.06057842f, -0.06356381f, 0.02352861f, 0.22865006f, 0.03730569f, -0.14676651f, -0.30594864f, 0.19019036f, 
    -0.15998088f, -0.11740018f, 0.08538971f, 0.10250356f, 0.09050290f, 0.08135661f, -0.01373878f, -0.22426590f, 
    0.00444476f, 0.20373246f, -0.13716081f, -0.12169576f, 0.01831533f, 0.34737393f, -0.43303859f, -0.14505933f, 
    -0.00902082f, -0.16149327f, 0.17876340f, 0.13351691f, 0.10982899f, -0.01822356f, -0.07994917f, 0.31251225f, 
    0.13299765f, 0.16718572f, -0.55177796f, -0.25985163f, 0.07702415f, 0.16129293f, 0.22583255f, -0.33823988f, 
    0.00680530f, -0.07425168f, 0.32537803f, -0.16804670f, -0.03567362f, 0.19486201f, 0.17323828f, -0.04056996f, 
    -0.44781220f, -0.59090012f, 0.16949040f, -0.00300270f, -0.08570610f, -0.60379189f, -0.01129309f, -0.12597041f, 
    -0.11820465f, 0.13155000f, 0.12164697f, -0.17060609f, 0.15368824f, -0.13016295f, -0.01847957f, -0.11099893f, 
    -0.09850548f, -0.12301143f, 0.14349526f, -0.92532718f, 0.05641922f, 0.01815502f, 0.23582162f, -0.02313289f, 
    0.13826795f, 0.04048977f, 0.28649095f, 0.09482133f, -0.09088489f, -0.35497561f, 0.00836911f, 0.09180548f, 
    -0.18756801f, -0.06401131f, 0.28166148f, 0.12224471f, 0.00134831f, -0.51867425f, 0.03334432f, 0.10214920f, 
    -0.06213434f, 0.02998354f, 0.07830398f, -0.08994868f, 0.08169805f, 0.11692058f, 0.10083677f, -0.33027706f, 
    -0.15000236f, -0.05938422f, -0.03586140f, 0.09562640f, -0.09936743f, 0.00949122f, 0.11261352f, -0.58616215f, 
    0.06912059f, 0.09086789f, -0.13384815f, 0.00479867f, -0.05188495f, 0.31682268f, -0.12779561f, -0.22171365f, 
    -0.17711465f, 0.17396717f, -0.14781298f, 0.10192925f, 0.08586710f, 0.01252719f, 0.12088365f, 0.09246450f, 
    -0.13028377f, 0.06406636f, -0.00415881f, 0.05232084f, -0.08787408f, 0.03118933f, -0.02101661f, -0.54518914f, 
    0.14832954f, -0.09967639f, 0.42610416f, 0.29163274f, 0.14514004f, 0.00394261f, -0.29432288f, 0.32949683f, 
    0.08611075f, -0.06645242f, -0.55319560f, -0.16215739f, -0.02237656f, -0.19723614f, 0.06980348f, -0.25384232f, 
    -0.34607339f, 0.22990566f, -0.11106234f, 0.01795493f, -0.11243551f, -0.27246609f, 0.08899777f, -0.06977345f, 
    -0.06370087f, 0.47876546f, 0.10508597f, 0.31424999f, 0.23311397f, -0.04481965f, -0.08366235f, -0.01225801f, 
    -0.14465363f, -0.13522579f, -0.36386815f, -0.03835411f, -0.09299703f, -0.06228572f, 0.07453703f, -0.07544885f, 
    0.11290187f, -0.05597198f, 0.04195569f, 0.01804282f, 0.01666003f, -0.33048019f, -0.09025998f, 0.23642033f, 
    -0.02975468f, -0.19114365f, -0.38490468f, -0.03716157f, -0.03500493f, 0.30908462f, -0.28480092f, 0.06424758f, 
    0.12930389f, 0.30490088f, -0.14001982f, -0.28305876f, -0.12555477f, 0.16487202f, 0.15283643f, -0.22861740f, 
    -0.15410176f, -0.01948844f, 0.27172294f, -0.19373621f, -0.05219791f, -0.09395159f, 0.23997688f, -0.10279518f, 
    0.01078048f, -0.04927970f, 0.36920077f, 0.13064644f, -0.06278580f, 0.09050994f, -0.00770048f, 0.12507224f, 
    0.18390687f, 0.34925255f, -0.18602428f, -0.08241026f, 0.08856203f, 0.00051855f, -0.13242328f, -0.05461493f, 
    0.07346175f, 0.22786225f, -0.13427684f, 0.11071368f, -0.68683934f, 0.04712422f, -0.00838982f, -0.12508452f, 
    -0.05643811f, 0.02160391f, -0.12063378f, -0.02633812f, 0.14964002f, -0.14731520f, -0.23112352f, -0.00596070f, 
    -0.03714574f, -0.15722574f, -0.15111089f, -0.06281591f, -0.09857837f, 0.27729550f, 0.00333725f, -0.07193407f, 
    -0.36954066f, 0.03930365f, 0.09618986f, -0.15578289f, 0.06948464f, 0.57912970f, 0.29951131f, 0.08336292f, 
    -0.13279210f, -0.27023959f, -0.14062950f, -0.30965805f, -0.05502846f, -0.08129880f, 0.16803257f, -0.22333314f, 
    0.08614498f, -0.01828199f, -0.28817993f, 0.13223115f, 0.03944619f, -0.03812182f, 0.24318187f, -0.53068185f, 
    0.10102718f, -0.04576862f, -0.01277019f, -0.04455837f, -0.01511937f, -0.20475499f, -0.16210686f, 0.28280163f, 
    -0.35537747f, -0.69097686f, -0.14247411f, -0.15477149f, 0.03329364f, 0.19618906f, 0.08325702f, -0.10387679f, 
    0.02407082f, -0.31587598f, 0.01854304f, 0.39345992f, -0.09013067f, -0.07278896f, -0.04488914f, 0.13381268f, 
    0.05304339f, -0.10131306f, -0.09021182f, -0.14068539f, -0.14452267f, -0.08966430f, -0.14254925f, 0.36588168f, 
    0.13569379f, -0.11958858f, 0.38782871f, -0.03880811f, -0.15540282f, -0.01353225f, 0.05627702f, -0.21207100f, 
    -0.50862944f, 0.13480957f, 0.00767840f, -0.06513072f, -0.07627422f, -0.17042482f, 0.21845578f, -0.02003826f, 
    -0.17671943f, 0.19213574f, -0.08083448f, -0.47863057f, -0.02196329f, -0.10452722f, 0.03631030f, 0.29080445f, 
    -0.01358171f, -0.02762679f, -0.07149713f, -0.05495837f, -0.08916001f, -0.16264747f, -0.27051181f, 0.29881203f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03064599f, -0.08117510f, -0.16072087f, -0.01995545f, 0.14037871f, -0.05633210f, -0.05166490f, -0.23419738f, 
    -0.07411840f, -0.13407169f, -0.02899577f, -0.03697962f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
