#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.64560610f, -0.69013822f, -0.45690021f, 0.69102049f, 0.54744673f, -0.34234828f, -0.43142501f, 0.98592901f, 
    0.12686954f, 0.08394062f, -0.37132818f, -0.17145778f, -0.29312718f, 1.06825364f, -0.77343243f, -0.17180648f, 
    -0.07343591f, -0.25457248f, 0.45432162f, 0.11259034f, 0.03009996f, -0.01379731f, -0.11154855f, -0.17430785f, 
    0.22801669f, -0.29810864f, -0.55525172f, -0.17617209f, -0.24562579f, -0.39322984f, -0.51510382f, -0.31681079f, 
    0.30386692f, -0.44959754f, -0.65769714f, 0.03429219f, -0.23061384f, -0.61392713f, -0.26890844f, -0.63136202f, 
    -0.10906684f, -0.61174554f, -0.33376408f, 0.17309131f, 0.54094589f, -0.46024379f, -0.31183976f, -0.06435134f, 
    -0.35577646f, -0.03667668f, 0.83826077f, 1.23878872f, 0.67341793f, -0.08176239f, -0.91429728f, -1.03527391f, 
    -0.43588203f, -0.29382092f, -0.17462093f, -0.24571453f, 0.15640686f, 0.14828481f, 0.11694007f, 0.76522380f, 
    0.02858860f, -0.06771334f, -0.37762100f, 0.30661368f, 0.16090612f, -0.23132260f, 0.23208036f, 0.05277742f, 
    -0.24978381f, -0.37912726f, -0.07804197f, 0.10338282f, 0.11928448f, -0.03011302f, -0.12318869f, 0.07759123f, 
    0.46070382f, 0.11998991f, -0.07496966f, -0.45117325f, 0.04379585f, -0.18295279f, 0.36819488f, -0.36611599f, 
    0.10525985f, 0.43950975f, -0.43270972f, -0.19105147f, -0.22045104f, 0.02027697f, 0.08887325f, 0.52630812f, 
    0.14625016f, -0.27602515f, 0.52130711f, 0.31388217f, -1.01131344f, -0.92309278f, -0.96009505f, -0.30630511f, 
    -0.92036396f, 0.82270539f, 0.37951338f, 0.59424162f, 0.21538588f, 0.82085842f, 0.24579322f, 0.28610778f, 
    0.27034307f, 0.41147053f, -0.08233795f, 0.03448265f, -0.09125876f, -0.09830309f, -0.05346764f, -0.09242778f, 
    -0.23816781f, -0.02874498f, 0.21047986f, -0.17188457f, -0.08073528f, 1.43401182f, 0.17515339f, -0.47791761f, 
    -0.54157811f, 0.28052130f, 0.62159216f, 0.07019077f, -0.09034731f, -0.15787619f, -0.33581403f, -0.11526983f, 
    0.15153468f, -0.02777565f, -0.38854495f, 0.27949658f, 0.01108980f, 0.12418130f, 0.20969579f, -0.25897866f, 
    -0.06679226f, -0.37909871f, -0.10645144f, 0.09848462f, 0.39244172f, -0.24455890f, 0.58415580f, 0.31800976f, 
    0.38620472f, 0.23430343f, 0.29217610f, -0.02822769f, 0.28368029f, 0.53800428f, -0.14513001f, -0.28459001f, 
    0.03621831f, 0.05033585f, -0.05417141f, -0.09768393f, 0.01697064f, -0.09364718f, 0.14622033f, -0.19911583f, 
    -0.14535113f, -0.21690118f, 0.04337950f, -0.21952714f, -0.48355639f, -0.31613141f, -0.43874452f, 0.25430614f, 
    0.22774185f, -0.28180462f, -0.17385294f, -0.01211337f, -0.44010463f, -0.20732906f, 0.24602602f, -0.27531049f, 
    -0.43934375f, 0.56758815f, -0.41651627f, 0.13346857f, 0.19253105f, 0.32727653f, 0.20779532f, 0.11258363f, 
    0.09002054f, -0.39460403f, 0.16660090f, 0.16919701f, 0.26516685f, 0.10288641f, 0.51509166f, 0.78626281f, 
    0.17577130f, -0.99607468f, 0.02820030f, 0.39780971f, 0.85516399f, -0.97976881f, -0.84043562f, -0.88568187f, 
    0.01957178f, 0.20231122f, 0.30659130f, -0.32671010f, 0.11957297f, 0.17654313f, -0.16746587f, 0.08796033f, 
    0.00433769f, 0.13812077f, -0.08077470f, -0.12999378f, -0.00873466f, -0.08828199f, 0.16698968f, 0.12455645f, 
    0.60821450f, -1.32467973f, -0.28534988f, -0.29529172f, -1.18165088f, -0.73132962f, 0.53407955f, 0.01400898f, 
    -0.59290779f, 0.04431693f, 0.29227644f, -0.12950888f, 0.08867785f, -0.66193390f, -0.61199355f, -0.54556048f, 
    -0.09216339f, -0.23117718f, -0.14911522f, 0.10447919f, -0.31721127f, 0.07786666f, 0.23391423f, -0.14857836f, 
    -0.05442965f, 0.13005896f, 0.78993875f, 0.43425453f, 0.49282086f, 0.33139473f, -0.16895117f, 0.04545749f, 
    0.20953751f, -0.00685031f, 0.04488451f, 0.00158935f, -0.26155162f, 0.47473502f, 0.23473413f, -0.41403306f, 
    -0.70627052f, -0.41418308f, -0.32592446f, -0.01983224f, -0.11045383f, -0.19274831f, 0.14002751f, 0.14978532f, 
    -0.00293769f, -0.22636592f, 0.39743808f, 0.77327645f, -1.21304071f, -0.24740097f, 0.67251688f, 0.30867904f, 
    0.14991999f, 0.27163246f, 0.34388098f, 0.30057946f, 0.17973612f, -0.35516128f, -0.12687603f, -0.60041183f, 
    -0.19704188f, 0.20592745f, -0.20079868f, 0.08128391f, 0.28592208f, -0.23184416f, -0.16372614f, 0.11199553f, 
    -0.08221436f, -0.30964011f, 0.16783114f, 0.26489222f, -0.66471678f, -0.15658356f, -1.04932940f, -1.00259912f, 
    -0.74373108f, -0.22656073f, -0.06211314f, -0.14447042f, -0.33870676f, -0.38117856f, -0.06980362f, -0.08945093f, 
    0.04931307f, -0.14062342f, 0.07785348f, 0.00072696f, 0.35102588f, -0.11954203f, -0.30730841f, -0.25365975f, 
    -0.52833229f, -0.10732028f, 0.25821108f, -0.15865365f, -0.54322308f, 1.10259449f, -0.79631615f, -0.74042320f, 
    0.13943006f, 0.41217083f, 0.12444692f, 0.12137424f, -0.73413146f, -0.82035911f, -0.98818624f, -0.05548753f, 
    0.13212913f, 0.34437394f, -0.25082693f, -0.13841276f, 0.13699533f, 0.19635913f, 0.39407995f, -0.10402444f, 
    0.03921143f, -0.47433466f, -0.37362194f, -0.17093447f, -0.21702884f, -0.21563317f, -0.00870120f, -0.50520682f, 
    0.09464239f, 0.52940202f, 0.79298502f, 0.44533360f, 0.07183633f, -0.31090870f, 0.33237085f, 0.57966542f, 
    0.15890343f, 0.09928611f, -0.15275021f, -0.25788128f, -0.45430243f, -0.06257958f, -0.03465147f, -0.24651553f, 
    -0.06245003f, -0.48729190f, -0.66342121f, 0.03147035f, -0.18162255f, -0.36230320f, -0.42673686f, -0.04764996f, 
    -1.17848957f, 0.20802596f, 1.23095047f, -0.54773778f, -0.25917727f, 0.11765474f, -0.87356603f, -0.66035026f, 
    -0.43941432f, -0.15995744f, -0.04746658f, -0.21688886f, -0.12508659f, -0.04032892f, -0.31316090f, 0.23894212f, 
    -0.22680175f, 0.19948405f, 0.13854171f, 0.50613421f, -0.09404581f, -0.20570950f, -0.01710181f, -0.02690681f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.48823157f, 0.26411879f, 0.22994232f, 0.46116120f, 0.16710187f, 0.58436209f, 0.13400081f, 0.17118366f, 
    0.50558454f, -0.12637487f, 0.42208248f, 0.37455052f, -0.22798541f, 0.04617745f, 0.23298733f, 0.49002299f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01588635f, -0.02098181f, -0.04172033f, -0.00114965f, 0.04621945f, -0.07459570f, 0.04611287f, 0.00961889f, 
    -0.00271932f, 0.00591112f, -0.06825422f, 0.06079661f, -0.03907434f, -0.05574659f, -0.07672247f, 0.06912478f, 
    -0.04179004f, 0.01184797f, 0.01611237f, 0.04203795f, -0.07614524f, 0.03396862f, 0.01161573f, 0.01234893f, 
    -0.01753928f, -0.00079063f, -0.03331136f, 0.01333736f, -0.01061926f, -0.06019334f, -0.05361674f, 0.04227581f, 
    -0.02053272f, -0.03200921f, -0.03509854f, 0.02830305f, -0.01469924f, -0.07565485f, 0.02835556f, -0.05269622f, 
    -0.08139799f, 0.02133349f, -0.02378497f, 0.03637652f, -0.08141454f, -0.03729252f, -0.06005077f, -0.00725492f, 
    -0.03210125f, 0.04551674f, -0.01785393f, 0.04295060f, -0.01706592f, -0.08110871f, -0.01610559f, -0.04378935f, 
    -0.02409941f, -0.02186633f, -0.00509924f, 0.01975244f, -0.08300071f, -0.00327833f, 0.03136395f, -0.07388869f, 
    -0.05243679f, -0.01313775f, -0.02820456f, -0.00131798f, 0.03371836f, 0.04219699f, 0.00303120f, -0.02100288f, 
    0.04241046f, -0.00152719f, -0.02206650f, -0.02434480f, 0.00291637f, -0.03740729f, -0.02895180f, 0.04795768f, 
    0.00566948f, -0.03830711f, 0.00073157f, 0.02931259f, 0.05694328f, 0.00280585f, -0.07740669f, 0.04464459f, 
    -0.07626001f, 0.03640283f, -0.01769553f, 0.00103242f, -0.07005754f, 0.05436007f, -0.01546715f, -0.00441365f, 
    0.03910108f, 0.04189272f, 0.03458836f, -0.07343196f, -0.03725711f, -0.06225854f, -0.05876194f, -0.05101990f, 
    -0.03756042f, -0.08729172f, -0.05210298f, -0.05348067f, -0.04419409f, -0.06238161f, -0.00487344f, 0.03622800f, 
    -0.03057655f, 0.02460848f, 0.00694858f, 0.04178806f, -0.01678370f, 0.00986666f, 0.00728460f, 0.05737832f, 
    -0.05507290f, -0.01250413f, 0.00005079f, 0.02388949f, 0.02120101f, -0.00242657f, 0.02044470f, -0.00310528f, 
    -0.05118614f, -0.08180259f, 0.01447786f, 0.04414206f, -0.06427371f, -0.05199526f, 0.03607559f, -0.03177417f, 
    0.02282548f, 0.01978236f, 0.03160449f, -0.03211519f, 0.01026896f, -0.06472848f, -0.08076242f, -0.06002514f, 
    -0.00452167f, 0.05243681f, -0.07277513f, -0.05925153f, 0.01925511f, 0.00775595f, 0.05159952f, -0.05339998f, 
    -0.06589708f, -0.03296594f, 0.03279366f, -0.03865878f, -0.05914142f, -0.00052223f, -0.07423790f, -0.04271271f, 
    -0.06209155f, -0.03511800f, -0.06583189f, 0.05284677f, -0.03749774f, 0.04908780f, 0.05691620f, 0.00104926f, 
    -0.02788696f, 0.01094045f, 0.04573776f, -0.03133489f, 0.01458214f, 0.03612981f, -0.02410550f, 0.04668816f, 
    -0.06724663f, 0.03559706f, -0.00495757f, -0.00184758f, -0.00830074f, 0.05009709f, 0.04549889f, -0.01877484f, 
    -0.01033701f, -0.02282158f, 0.04331534f, 0.03253406f, -0.07806366f, 0.01389680f, 0.04873056f, 0.02064693f, 
    0.42697474f, -0.54377937f, -0.31209514f, 0.16928628f, 0.47931537f, 0.11450216f, 0.09708056f, 0.08084171f, 
    0.27811059f, 0.05307060f, 0.31418708f, 0.09616144f, -0.18896584f, -0.10386867f, -0.04015805f, 0.07865725f, 
    0.17530960f, 0.04923106f, 0.06889267f, 0.03180322f, 0.05061612f, 0.01078572f, 0.14384910f, 0.18608361f, 
    -0.04823165f, 0.29772681f, 0.29332900f, -0.04120282f, 0.13895088f, -0.11565087f, -0.24081430f, 0.09175375f, 
    -0.03521060f, -0.01409248f, 0.05716011f, 0.07302563f, -0.11738150f, 0.11716499f, -0.13526939f, -0.26838198f, 
    0.04831464f, -0.02672747f, 0.03925525f, -0.06735998f, -0.00879469f, -0.05804891f, 0.01788888f, 0.06841636f, 
    0.06339943f, -0.14846116f, -0.06362865f, 0.04664544f, -0.16643861f, -0.09256008f, 0.05342676f, -0.10106059f, 
    0.10876603f, -0.12223829f, 0.11499252f, 0.17309055f, -0.15174083f, -0.17984807f, 0.35922912f, -0.12588552f, 
    -0.07350155f, -0.01328301f, 0.17830832f, 0.19689131f, -0.11927130f, -0.17757937f, -0.04568914f, 0.17161795f, 
    -0.15827790f, 0.14375393f, 0.19198602f, -0.18273190f, -0.02535470f, -0.07599135f, 0.03502397f, -0.01446658f, 
    -0.04943062f, -0.10181105f, -0.07849259f, 0.09715898f, -0.15772900f, 0.03675628f, -0.16277492f, -0.09315994f, 
    0.15483741f, -0.04820573f, -0.14953366f, 0.32007277f, 0.06103239f, -0.04378714f, -0.03272339f, -0.00819946f, 
    0.30881268f, -0.18502809f, -0.03117183f, 0.32404053f, 0.10593031f, -0.05649245f, -0.09060534f, 0.15159900f, 
    0.21695291f, 0.03236525f, 0.04811650f, -0.20161337f, -0.09454826f, -0.26978052f, -0.14306395f, 0.31677133f, 
    -0.03386975f, -0.17737386f, 0.06985535f, -0.07914849f, 0.05107098f, 0.01827218f, 0.07304458f, 0.11245982f, 
    0.14674853f, 0.31181622f, 0.37660080f, -0.09489425f, 0.00266374f, 0.00755048f, -0.04631181f, 0.01052743f, 
    -0.09553558f, 0.07985296f, -0.18080378f, -0.16078942f, 0.21472575f, 0.06429248f, 0.01087560f, 0.06427316f, 
    0.07273219f, -0.13953319f, -0.02927062f, -0.08286481f, -0.12046859f, 0.18366088f, -0.06867545f, 0.11402441f, 
    -0.22217904f, -0.17695284f, 0.03096616f, 0.07457796f, -0.08599845f, -0.14373055f, 0.04847195f, -0.02054437f, 
    0.15907912f, 0.09011579f, -0.02527682f, -0.00990676f, -0.11629538f, 0.10728640f, 0.27580884f, 0.30447081f, 
    -0.07690417f, 0.22248831f, 0.11619660f, 0.15507585f, 0.20596479f, 0.01306752f, -0.03156644f, 0.04069035f, 
    0.00722915f, 0.14571194f, -0.14237033f, -0.04894142f, -0.05801328f, 0.01128865f, -0.03729081f, -0.19920519f, 
    0.12514824f, 0.10222618f, 0.09327808f, 0.09002029f, -0.24939884f, 0.03979114f, -0.13643077f, 0.28185773f, 
    -0.07508599f, -0.09728435f, 0.09788512f, 0.00714961f, 0.09779257f, 0.09389570f, 0.00816497f, 0.08550926f, 
    0.00291699f, -0.06576555f, -0.04645325f, 0.03667307f, -0.03476950f, -0.03228847f, -0.03086784f, 0.00629012f, 
    -0.05867143f, 0.01387561f, -0.07797118f, -0.01640976f, -0.05872269f, 0.02380396f, 0.03710451f, -0.04133692f, 
    -0.03363684f, -0.07403290f, 0.01840443f, -0.01873632f, 0.01064742f, -0.01061664f, 0.05506076f, -0.00489910f, 
    0.04584935f, -0.00880902f, -0.07669827f, -0.07410868f, 0.02965086f, 0.05799376f, 0.05961007f, 0.04435182f, 
    -0.05368925f, -0.06709648f, 0.00599033f, 0.04479127f, -0.07741617f, 0.06090581f, -0.05038028f, -0.01845106f, 
    0.03620331f, -0.08262083f, -0.00739035f, -0.07233690f, 0.00742803f, 0.03052452f, -0.06871022f, -0.05638665f, 
    -0.06262778f, 0.01429716f, 0.05598732f, 0.05778042f, -0.01412385f, -0.02689897f, -0.03511494f, -0.01957064f, 
    -0.07288808f, -0.07726120f, -0.08612406f, 0.05351333f, 0.03436055f, -0.07810159f, 0.01567545f, 0.02508218f, 
    -0.03833736f, 0.00605788f, 0.01153495f, -0.03222605f, -0.07646600f, -0.05322846f, -0.05053534f, -0.02357959f, 
    -0.02203593f, 0.01469608f, 0.03669508f, 0.05891362f, -0.03363584f, 0.05049015f, 0.00142124f, 0.04455519f, 
    -0.03739401f, -0.01218706f, -0.03053986f, -0.07213623f, 0.03135142f, -0.05182085f, -0.01791929f, 0.06111124f, 
    -0.05263058f, -0.07946268f, -0.00502685f, -0.00692955f, -0.00988497f, -0.07675959f, -0.00589203f, -0.06916520f, 
    -0.06444442f, 0.01799787f, -0.02392905f, 0.01533275f, -0.00850864f, 0.00520933f, 0.00998509f, -0.04386306f, 
    -0.01302096f, 0.03872959f, -0.06158637f, -0.04298801f, 0.00974339f, 0.06044017f, -0.04907719f, -0.02130438f, 
    -0.04578560f, 0.01048090f, -0.01110147f, 0.00683953f, 0.02579500f, -0.05782495f, 0.00217467f, -0.05844107f, 
    0.03928065f, -0.01315636f, -0.08244941f, -0.05092421f, 0.00116493f, -0.07745370f, -0.02896409f, -0.01141825f, 
    0.05652960f, 0.02122561f, -0.05034331f, -0.06079889f, -0.04609029f, -0.08113787f, -0.05295847f, 0.06184673f, 
    -0.03781956f, -0.04767347f, 0.05523017f, 0.03555859f, -0.04728017f, 0.01416183f, -0.05839970f, 0.05773386f, 
    0.03024863f, -0.02182353f, 0.01648658f, -0.03993650f, 0.01573175f, 0.03542689f, 0.06414118f, 0.00963367f, 
    0.03834811f, -0.01952483f, -0.05312790f, 0.04667191f, -0.03651369f, -0.03167081f, -0.06161476f, -0.03561333f, 
    -0.03936793f, 0.02759523f, -0.04171917f, 0.00808008f, -0.05587489f, -0.01197969f, 0.01531478f, 0.02395231f, 
    -0.00953454f, -0.01165587f, 0.06090244f, -0.00627336f, 0.03247159f, 0.06009926f, -0.00462492f, -0.03973720f, 
    0.03540656f, 0.03277596f, -0.05695094f, -0.02714220f, -0.05656710f, -0.06408139f, 0.01665170f, -0.01130802f, 
    -0.01204212f, -0.00895336f, -0.03472376f, 0.05780553f, -0.03567938f, 0.00847409f, -0.03513255f, -0.03872649f, 
    -0.03057176f, 0.02155244f, -0.04164639f, 0.03057706f, -0.01594919f, 0.05363639f, -0.00549999f, -0.01030524f, 
    -0.04082103f, 0.03058760f, -0.06923379f, 0.04814855f, -0.01960565f, -0.01308568f, 0.02598361f, -0.01160111f, 
    -0.03531531f, -0.08014880f, -0.05595019f, 0.02785598f, -0.03286297f, -0.02586292f, -0.02324087f, -0.03967187f, 
    -0.04466464f, -0.06752041f, -0.04424748f, -0.00163752f, -0.01488905f, -0.00041035f, 0.00630524f, -0.03318437f, 
    0.02995477f, -0.03733560f, -0.05027133f, -0.04428149f, 0.01464772f, 0.02662845f, -0.06929312f, 0.01850304f, 
    0.03399654f, -0.06301762f, 0.00685164f, -0.01486589f, -0.05385486f, -0.03173082f, -0.02570476f, -0.02261186f, 
    0.00649080f, -0.03782118f, -0.03019417f, -0.06905283f, 0.02462541f, 0.04268189f, 0.00783373f, -0.01747516f, 
    0.03914269f, 0.00361859f, -0.03840098f, -0.07988358f, -0.06078926f, -0.04286870f, -0.05996832f, -0.05110694f, 
    0.03390675f, 0.05608201f, -0.02111140f, -0.00383135f, -0.02512045f, -0.05266498f, 0.05772505f, -0.07007121f, 
    0.02642029f, 0.00457660f, 0.01076556f, 0.00308318f, -0.07363008f, 0.05285438f, -0.06765413f, -0.05776297f, 
    0.05239891f, -0.07297567f, 0.04358367f, -0.04623096f, 0.00615883f, -0.06974158f, -0.05798813f, -0.07378516f, 
    0.02531647f, -0.05140367f, 0.05828609f, -0.00633777f, 0.00664895f, -0.08055589f, 0.05128087f, -0.02205512f, 
    0.02617647f, -0.03902804f, 0.01886172f, 0.02693726f, -0.04091579f, 0.03796453f, -0.02353122f, 0.01595555f, 
    0.04976056f, -0.02480779f, 0.05313127f, -0.04027455f, -0.07039029f, 0.03020148f, -0.06317024f, 0.05710751f, 
    0.02843316f, 0.02405733f, 0.00455428f, -0.02362048f, 0.01133897f, -0.01297617f, 0.04224358f, -0.06542661f, 
    -0.05515667f, 0.02701211f, 0.05315639f, 0.04512507f, -0.06235069f, -0.05630171f, -0.01162780f, 0.00794258f, 
    -0.00168650f, 0.02894097f, -0.05257735f, -0.01283619f, 0.05180458f, -0.01497313f, 0.04475199f, -0.00991904f, 
    0.00843159f, -0.04866746f, 0.05019934f, -0.04531784f, -0.05497859f, 0.03456214f, -0.01388128f, 0.02790992f, 
    -0.05829825f, 0.02719442f, -0.00635829f, 0.01089522f, 0.05905611f, 0.00288993f, -0.03769221f, -0.08195121f, 
    -0.04356923f, 0.01089262f, 0.01215124f, -0.05003551f, 0.05206887f, -0.00235522f, -0.00863996f, -0.02783496f, 
    -0.03228524f, 0.03810018f, -0.01384400f, 0.05513393f, -0.00177076f, 0.02409300f, 0.06670164f, 0.00624387f, 
    0.00107926f, -0.02450600f, 0.05918993f, -0.03383482f, -0.07748852f, 0.00850523f, -0.00125473f, -0.02989491f, 
    0.05029959f, -0.00103384f, -0.08210721f, -0.05904574f, 0.04314181f, -0.04190781f, -0.04434797f, 0.04826151f, 
    -0.00141004f, -0.04262675f, -0.07901257f, 0.03836401f, -0.07397334f, 0.02177000f, -0.08046108f, -0.00698232f, 
    -0.07012571f, 0.24685660f, 0.06171640f, -0.38797343f, 0.32853758f, 0.18897359f, -0.00618857f, -0.10542525f, 
    -0.24515316f, 0.32280606f, -0.11052676f, 0.26535329f, -0.45730460f, -0.36220637f, -0.03783581f, -0.11859545f, 
    -0.15481572f, -0.09783919f, 0.16404307f, 0.06930937f, -0.02701894f, -0.06267935f, -0.00190592f, 0.24518715f, 
    0.32026628f, 0.18420976f, -0.16856317f, 0.07041821f, -0.13563745f, 0.12733740f, 0.30098864f, 0.30660340f, 
    -0.04078373f, -0.05970637f, 0.02556396f, 0.10115957f, 0.21766239f, 0.21563594f, 0.05245391f, 0.11129498f, 
    0.02454736f, -0.00530802f, 0.06315099f, 0.11244310f, -0.05466072f, -0.06784459f, -0.07324862f, 0.08464188f, 
    0.20172738f, -0.32285580f, -0.50449741f, -0.47925305f, 0.04268910f, -0.05776454f, -0.13213766f, 0.13738397f, 
    -0.03555360f, 0.21440022f, -0.03842032f, -0.31167209f, 0.44853374f, 0.24075161f, 0.11968608f, 0.10873466f, 
    0.07161377f, -0.00420848f, 0.07590301f, 0.04868130f, 0.09255215f, 0.05432374f, 0.09658149f, -0.10819418f, 
    0.33182794f, 0.09296265f, 0.24645939f, 0.15136246f, 0.01700748f, -0.07257421f, 0.03140472f, 0.00348768f, 
    0.21855104f, 0.14809066f, 0.08929525f, 0.05857772f, 0.10642999f, 0.13279146f, -0.03692271f, -0.00666848f, 
    0.01838447f, -0.02489801f, 0.06756856f, 0.07510650f, -0.03665594f, 0.06588403f, 0.02719552f, 0.02688454f, 
    -0.70231622f, 0.08036888f, 0.26540649f, -0.18677031f, 0.10674024f, 0.06671811f, 0.18052143f, -0.26917145f, 
    -0.24983400f, -0.04792612f, -0.16854146f, -0.07953170f, -0.36020619f, -0.50533104f, -0.18894222f, -0.74328738f, 
    -0.00575182f, -0.02340565f, 0.19724500f, 0.07737479f, -0.01995701f, -0.00812452f, -0.17152563f, 0.03378181f, 
    0.54162854f, 0.16855206f, 0.15677221f, 0.35443792f, -0.05981119f, 0.06585084f, -0.02721978f, -0.03895774f, 
    0.11600629f, 0.03294076f, -0.08119507f, -0.05422816f, 0.35395882f, -0.00454613f, 0.21904986f, 0.05984313f, 
    0.03452341f, 0.06298676f, 0.00886455f, -0.03791166f, 0.06235272f, 0.03039226f, 0.01789326f, 0.09896233f, 
    -0.33982387f, -0.11919342f, -0.46804827f, -0.26138321f, 0.21732675f, 0.01309864f, 0.23228864f, 0.14495189f, 
    -0.03460461f, -0.15309426f, 0.00738993f, -0.09736689f, 0.14279932f, 0.00672900f, 0.06747071f, -0.09145418f, 
    0.13134517f, 0.05753453f, 0.13324101f, 0.33429262f, -0.03742420f, 0.02343068f, -0.01138363f, 0.06981391f, 
    0.23037146f, 0.15080488f, 0.22113942f, 0.01906422f, 0.07050560f, 0.08762381f, -0.06900506f, -0.00253843f, 
    0.06478534f, -0.09593704f, 0.00604077f, -0.02833476f, -0.71253842f, -0.43905297f, 0.00329313f, -0.20858170f, 
    0.11757082f, 0.15681617f, 0.04635665f, 0.23465338f, -0.03827963f, -0.11325341f, -0.02363870f, -0.03482218f, 
    0.22940683f, -0.21942240f, -0.12424614f, 0.01767917f, 0.16608125f, 0.01757141f, 0.13296136f, 0.16493170f, 
    -0.11101573f, 0.18996090f, 0.29925045f, 0.03763743f, -0.25168121f, -0.07049069f, -0.03040084f, 0.12181352f, 
    0.03721327f, 0.09680840f, 0.13955250f, -0.03368443f, -0.01404273f, -0.02739614f, -0.00953096f, 0.10160430f, 
    -0.02186873f, -0.35783160f, 0.54139102f, -0.03471803f, 0.21661900f, 0.08617820f, -0.34105363f, 0.06618325f, 
    0.04837577f, -0.20281482f, 0.11347646f, 0.10001548f, 0.17767186f, 0.26142401f, -0.11767019f, -0.13678603f, 
    0.31094298f, -0.19391367f, 0.22574276f, 0.11519109f, 0.07763126f, -0.03625159f, -0.10622621f, 0.19172163f, 
    -0.35764238f, -0.17942376f, 0.03550058f, 0.04507949f, -0.10507654f, 0.04044323f, 0.07755861f, 0.10401111f, 
    -0.04872143f, 0.00971791f, 0.17632905f, 0.04616740f, -0.15861127f, 0.15235974f, 0.37507290f, 0.01365780f, 
    0.10905042f, 0.14987764f, 0.13527815f, -0.05190966f, 0.21097729f, 0.01325093f, -0.02616990f, -0.00490841f, 
    0.14394632f, 0.24806830f, 0.10211775f, -0.06483773f, -0.02999328f, -0.13422726f, 0.01274054f, -0.05011709f, 
    0.14512505f, 0.07751799f, 0.02432627f, -0.04976867f, 0.02712617f, -0.03177030f, -0.09459626f, -0.10915902f, 
    0.15918840f, 0.05674168f, -0.02481198f, 0.14182551f, 0.07422725f, -0.01218555f, -0.17485622f, 0.01455225f, 
    0.02591626f, -0.01164246f, 0.08688483f, 0.19602899f, -0.04799213f, 0.05409312f, -0.04434998f, 0.04351928f, 
    -0.01283748f, -0.15058015f, 0.12877120f, -0.05529071f, -0.10356675f, -0.17087303f, -0.07278302f, 0.25886056f, 
    -0.00371582f, -0.09798423f, -0.08505970f, -0.16600218f, -0.01646574f, -0.04132495f, 0.09242692f, 0.11258028f, 
    0.32487908f, 0.37640247f, 0.31984138f, -0.09935234f, -0.00865651f, -0.15159166f, -0.23338413f, 0.01423854f, 
    -0.10126925f, 0.04265383f, -0.17229916f, 0.03981326f, -0.21178606f, 0.13882715f, -0.11202137f, 0.45018563f, 
    -0.06290597f, -0.15464379f, -0.04630532f, 0.01907935f, 0.03418913f, 0.31059369f, 0.00522606f, -0.07743539f, 
    -0.16906126f, -0.15504614f, -0.00460658f, 0.04476061f, -0.21699493f, -0.01348029f, 0.11750990f, -0.14117253f, 
    0.05868132f, 0.01121833f, 0.04693631f, 0.05409257f, -0.50053287f, 0.12595481f, 0.11586630f, 0.26979238f, 
    -0.11334870f, -0.03766868f, 0.13429786f, -0.06827458f, -0.04301936f, 0.06194972f, 0.19735700f, -0.02991606f, 
    0.04664998f, 0.17894405f, -0.12249812f, -0.15960343f, -0.12174786f, -0.03189649f, -0.15697950f, 0.11938719f, 
    0.14653288f, -0.07167634f, 0.21796867f, -0.01171646f, -0.30491769f, 0.37373549f, -0.07929431f, 0.37181160f, 
    -0.03811098f, -0.08111174f, 0.26133966f, 0.01639272f, 0.04456315f, 0.00341909f, -0.04933023f, 0.14789876f, 
    0.72216982f, -0.06536395f, -0.07826103f, -0.16201441f, 0.18959717f, 0.24423291f, -0.07384570f, 0.27406797f, 
    -0.02160667f, 0.03409150f, 0.16533636f, -0.05814787f, 0.07810482f, 0.13667399f, 0.00700767f, -0.03953849f, 
    0.03782224f, 0.07066774f, 0.12080196f, 0.33353105f, 0.05829161f, 0.03407637f, 0.15589330f, 0.09119687f, 
    -0.25957382f, 0.13587464f, 0.58378291f, 0.52391338f, 0.15381682f, 0.30880451f, -0.06653681f, -0.20503083f, 
    0.15195203f, -0.11513329f, 0.24676743f, 0.25785592f, -0.24566108f, 0.13580297f, -0.12610269f, 0.03075853f, 
    0.13455902f, 0.15829502f, -0.00858514f, -0.28390983f, -0.62366843f, -0.14790675f, -0.76202869f, -0.43714589f, 
    0.53710878f, 0.13785192f, 0.36309391f, 0.39699551f, -0.08176268f, -0.14320777f, 0.15250720f, 0.07607283f, 
    0.21167006f, -0.08146037f, -0.07900248f, 0.21575730f, -0.34734908f, -0.02030145f, 0.09805980f, 0.15977575f, 
    0.01467176f, -0.07144517f, -0.03357086f, -0.12288120f, -0.12189668f, -0.04012503f, 0.07840943f, -0.07529045f, 
    0.06887447f, 0.00260225f, -0.18422629f, 0.03718938f, -0.03369555f, -0.13692904f, 0.16375419f, -0.06388232f, 
    0.10187843f, 0.43969497f, 0.17390676f, 0.20207943f, -0.29852983f, 0.06111395f, -0.20958352f, -0.10793169f, 
    0.11674418f, 0.01398995f, -0.03300188f, -0.02508229f, -0.36964908f, -0.28079256f, -0.43456846f, -0.72911793f, 
    0.33078539f, -0.00837262f, 0.53749400f, 0.01234354f, 0.18084748f, -0.01453874f, -0.01220772f, -0.13579407f, 
    -0.23352186f, -0.05845112f, 0.04574490f, -0.39665607f, -0.08254639f, 0.08145628f, -0.11957873f, -0.05860380f, 
    0.15064403f, 0.12174553f, 0.00620824f, 0.14913392f, 0.14018822f, 0.05890834f, 0.02512039f, 0.09707510f, 
    -0.13511083f, 0.19880335f, 0.20555711f, -0.02618175f, 0.09053621f, -0.01468270f, -0.24234594f, -0.11642262f, 
    -0.47124127f, -0.35100979f, -0.21956518f, -0.49090266f, -0.15105687f, -0.46676198f, 0.06233478f, -0.03322383f, 
    0.09673136f, -0.38409993f, 0.38397887f, -0.13287990f, -0.08545320f, 0.20398134f, -0.12563406f, -0.06232975f, 
    0.16762933f, -0.12015069f, -0.00555442f, 0.03640832f, -0.05331305f, 0.08262241f, 0.12521566f, 0.12005270f, 
    0.19887130f, -0.07203466f, 0.29476139f, 0.24318650f, -0.12365478f, -0.12250365f, 0.42924997f, 0.02664786f, 
    0.10488345f, 0.16695191f, 0.33554754f, 0.16622761f, 0.13654476f, 0.39590970f, 0.04102059f, -0.09873075f, 
    -0.09038137f, -0.18940760f, 0.09259248f, 0.04549798f, -0.19359961f, -0.16198567f, -0.17464557f, -0.17336351f, 
    0.32203898f, 0.20000403f, 0.28557214f, 0.47665545f, 0.25615185f, -0.00552231f, -0.03164702f, -0.07614426f, 
    0.06875707f, 0.07168071f, 0.20906909f, 0.03987411f, -0.09133387f, -0.03743364f, -0.36129218f, -0.07216208f, 
    -0.32057801f, -0.06469332f, 0.48469064f, -0.10687601f, -0.15004519f, 0.16308813f, 0.15516807f, -0.22447683f, 
    0.10050929f, -0.05386867f, 0.20309411f, 0.09326927f, 0.05823124f, 0.04190777f, 0.02881597f, -0.09979039f, 
    0.08820783f, -0.04679773f, 0.27094099f, -0.22558558f, 0.03520493f, 0.02306234f, -0.09430492f, 0.12433548f, 
    0.02781649f, -0.71796805f, 0.66912532f, -0.11589612f, -0.04317175f, 0.02765270f, -0.38867965f, 0.05752795f, 
    -0.10274619f, -0.07903350f, 0.09332000f, -0.12597468f, -0.08540896f, 0.03904776f, -0.09063309f, 0.19384220f, 
    0.26332635f, -0.05637556f, -0.03875433f, 0.08219404f, -0.03081886f, 0.06491899f, 0.13261068f, 0.21230507f, 
    -0.50314790f, 0.02443491f, -0.00153495f, 0.27381852f, -0.08840476f, 0.13362615f, 0.36093137f, 0.14416543f, 
    0.14470683f, 0.10808043f, -0.21017896f, -0.15755934f, 0.23425020f, 0.26894256f, -0.07621067f, 0.04878047f, 
    0.00662564f, -0.02937826f, -0.04846681f, -0.02157262f, -0.02546142f, 0.37866628f, -0.11126430f, 0.05500009f, 
    0.22067125f, -0.03754247f, -0.13165079f, 0.01133394f, 0.01181041f, -0.01752678f, -0.09215662f, 0.07314252f, 
    -0.01032132f, -0.07301696f, 0.01362661f, 0.09554723f, -0.02834557f, -0.09340439f, 0.14484130f, 0.08185188f, 
    -0.00090830f, 0.08527179f, 0.08603960f, -0.20188576f, -0.07087451f, 0.04385557f, 0.11481330f, 0.04137654f, 
    -0.17012823f, 0.61538237f, 0.10417556f, 0.14473020f, -0.06475413f, 0.11934928f, -0.06839553f, 0.12974237f, 
    -0.06209617f, 0.00953241f, -0.01209701f, 0.07643443f, 0.06598213f, 0.30266353f, -0.01822304f, 0.46089789f, 
    0.15696445f, 0.09983653f, -0.06764844f, 0.26130596f, -0.10290255f, -0.04402752f, -0.09137094f, -0.05256598f, 
    0.48352662f, 0.29823610f, -0.00545709f, -0.10682625f, -0.04829912f, 0.01818096f, 0.00929024f, 0.09132338f, 
    -0.15809149f, -0.03385930f, 0.10341322f, 0.14509010f, -0.14000030f, 0.21101475f, 0.01185654f, 0.10678015f, 
    -0.05515094f, 0.03364856f, 0.03061680f, 0.11609759f, 0.22215432f, 0.19398117f, -0.19704817f, 0.17639315f, 
    -0.00439385f, 0.03405010f, 0.33830118f, 0.02446218f, -0.12906046f, 0.02482102f, 0.08616115f, -0.35664234f, 
    -0.11805697f, -0.02988130f, -0.12244591f, 0.01026150f, 0.03188301f, 0.21530692f, -0.20626435f, 0.16068551f, 
    -0.06176175f, 0.08458600f, -0.04623621f, -0.28414032f, 0.14416672f, -0.01889692f, 0.04571612f, 0.12049618f, 
    -0.08348148f, 0.04291047f, -0.32342884f, 0.05024273f, -0.05142257f, -0.01907974f, 0.05379702f, 0.20028830f, 
    -0.32422805f, -0.01173162f, -0.08497938f, 0.18717994f, -0.12591822f, 0.39653119f, -0.08206446f, -0.06673380f, 
    0.07141576f, 0.03353249f, 0.17185365f, -0.05464629f, -0.01014466f, 0.01489003f, -0.09691095f, -0.02659616f, 
    -0.04851713f, 0.01221246f, -0.01247167f, 0.02239880f, 0.01398877f, -0.06991119f, -0.02921080f, 0.05666928f, 
    -0.05196113f, 0.02225832f, -0.00699004f, -0.04228451f, -0.05723918f, -0.01589892f, 0.00287951f, 0.04064668f, 
    0.03296375f, -0.07800464f, -0.02798730f, -0.04736809f, 0.03599544f, -0.06398106f, -0.06978662f, 0.06220070f, 
    -0.02409340f, -0.00147182f, 0.02099687f, 0.03844742f, 0.05533112f, -0.03402333f, 0.02997632f, -0.06508639f, 
    0.03237724f, 0.03330430f, 0.00179395f, -0.05087589f, 0.03692602f, -0.02759839f, 0.05593991f, 0.01522027f, 
    -0.00253734f, -0.03507569f, 0.05001148f, -0.07540956f, -0.03698209f, 0.04431184f, 0.03460612f, -0.03151860f, 
    -0.00363351f, -0.06137207f, -0.05631766f, 0.05366112f, 0.05292368f, -0.01990514f, -0.00101755f, 0.05602583f, 
    -0.05929755f, -0.06817469f, -0.05776763f, -0.04268311f, 0.05230941f, 0.04000066f, -0.05246081f, -0.02446614f, 
    0.04316237f, 0.06132102f, -0.02593888f, -0.07391701f, -0.04005855f, -0.06716091f, -0.04892571f, -0.01788258f, 
    -0.03067239f, -0.07074974f, -0.05260486f, -0.02400366f, -0.07361656f, -0.07205956f, 0.06244909f, 0.02091238f, 
    -0.04724841f, -0.04127800f, 0.04382389f, -0.07777778f, 0.05543460f, 0.04247158f, -0.05159030f, -0.03860592f, 
    -0.01380890f, -0.05727631f, 0.05328990f, -0.05668960f, 0.03525816f, -0.00775052f, 0.01356925f, -0.04004959f, 
    -0.05866845f, 0.04152137f, -0.06984537f, 0.02098108f, 0.05399484f, -0.00892971f, -0.00927550f, -0.06468169f, 
    -0.04261018f, 0.05510972f, -0.01553669f, 0.00160209f, -0.03154714f, -0.04938098f, 0.01572262f, -0.02642973f, 
    -0.00994985f, 0.00979771f, 0.02959032f, -0.00811703f, 0.03400117f, 0.03314369f, -0.03300904f, -0.04254687f, 
    -0.03790427f, 0.01866028f, -0.04494704f, -0.07186031f, -0.04179898f, 0.01912646f, 0.02450435f, -0.06294332f, 
    0.03749606f, 0.01309825f, -0.03453492f, -0.07852496f, 0.05703479f, 0.04200870f, 0.02458530f, -0.05214544f, 
    -0.04124516f, -0.06082891f, -0.06032395f, 0.04842199f, -0.01634935f, 0.03674151f, -0.05454219f, -0.00636179f, 
    -0.02609175f, 0.02449691f, 0.00811855f, 0.03951579f, -0.00616412f, -0.01092719f, 0.00193017f, -0.07645056f, 
    -0.06027121f, -0.07371739f, 0.00612538f, 0.05773494f, -0.06673259f, 0.01606114f, -0.04953975f, -0.07079130f, 
    -0.07393841f, -0.00600899f, 0.00781015f, 0.02963421f, -0.02878273f, -0.06174591f, -0.04808057f, -0.04906714f, 
    0.00703193f, 0.06323010f, 0.03713037f, -0.04165788f, 0.03605698f, -0.01809939f, 0.01556226f, -0.01350700f, 
    -0.02037365f, 0.03774464f, 0.02942402f, 0.01500544f, 0.06206332f, 0.00382096f, -0.04619985f, -0.04536709f, 
    0.06385531f, 0.06152716f, 0.01619374f, 0.03861994f, 0.04419907f, -0.06338269f, 0.03587593f, -0.00419091f, 
    -0.15502059f, 0.41592523f, 0.06833232f, 0.32029316f, 0.33920440f, 0.00618285f, 0.15343763f, -0.10055263f, 
    0.08843321f, 0.30702287f, 0.09017127f, 0.05181535f, 0.20804316f, 0.09022869f, 0.12875925f, 0.22185200f, 
    -0.06533459f, 0.05332593f, 0.15632951f, -0.17267376f, 0.08797283f, -0.00053025f, -0.10170873f, 0.04719422f, 
    0.21534711f, -0.21278493f, -0.17323923f, -0.19458267f, -0.39667594f, -0.32475832f, -0.09511797f, 0.25555822f, 
    -0.20346045f, -0.11381013f, -0.01717121f, 0.03736416f, -0.00453865f, -0.06786006f, -0.15830886f, -0.10020000f, 
    0.00375680f, -0.08623770f, -0.01515993f, 0.17066580f, 0.26577228f, 0.11057246f, 0.15451920f, 0.19450109f, 
    -0.15599111f, -0.35379568f, -0.44573089f, -0.40723911f, -0.00358308f, -0.18724751f, -0.37431812f, -0.04968188f, 
    -0.02301536f, 0.12587036f, 0.17791899f, -0.28499132f, 0.51078153f, -0.01832339f, -0.11025621f, -0.14877672f, 
    0.03255324f, -0.08809372f, 0.26144275f, 0.07059057f, 0.09544079f, 0.02781754f, -0.14584039f, -0.07844340f, 
    0.25605497f, -0.02688938f, -0.01962727f, 0.05002383f, 0.04282734f, 0.00060126f, -0.16687748f, -0.07257589f, 
    -0.12615953f, -0.25512952f, 0.03451874f, -0.15094602f, 0.11318411f, -0.11101536f, -0.12778510f, -0.12362011f, 
    0.11494136f, 0.31594935f, 0.16723691f, 0.01517192f, -0.10524043f, 0.08859815f, 0.15408832f, 0.26305264f, 
    -0.22675420f, 0.10750367f, 0.17262797f, 0.28573433f, -0.04071275f, 0.07044887f, 0.20131560f, -0.08477621f, 
    0.14436698f, -0.21048111f, -0.00460138f, 0.20010266f, 0.02918006f, 0.25655779f, 0.11228321f, -0.11196274f, 
    -0.05887977f, 0.20287536f, 0.06191089f, 0.26908892f, 0.06045872f, -0.08756942f, -0.20524730f, 0.11317588f, 
    0.31301335f, 0.02512015f, 0.07271855f, 0.07154366f, -0.35853812f, -0.20449397f, -0.05899440f, -0.18221651f, 
    0.19974840f, 0.14565523f, 0.09831015f, 0.15235446f, 0.16290317f, -0.13406500f, -0.01620388f, 0.29980850f, 
    -0.01326833f, -0.11264720f, -0.37607279f, -0.21426079f, 0.01425377f, -0.05449515f, 0.15152220f, -0.00813750f, 
    -0.08499300f, 0.31333068f, 0.13090657f, 0.01344263f, 0.14811331f, 0.07437173f, 0.09539925f, 0.03163983f, 
    0.00733925f, -0.14873169f, -0.12824614f, -0.16058962f, 0.04537303f, 0.27051908f, -0.16191681f, -0.09019643f, 
    -0.09331568f, -0.25535592f, 0.11740033f, 0.24090797f, -0.25390700f, -0.06877956f, 0.05798732f, 0.18418191f, 
    -0.06418946f, 0.12859623f, 0.06020256f, 0.01522614f, 0.01342548f, 0.05808805f, 0.01962029f, -0.05226672f, 
    -0.15806541f, -0.27953124f, 0.12688079f, -0.27421075f, -0.01304170f, 0.35608768f, 0.25991058f, 0.14524882f, 
    0.05568167f, -0.08223473f, 0.06777889f, 0.15003313f, -0.02390734f, -0.05853602f, 0.16497882f, 0.09049552f, 
    -0.35415930f, 0.17765889f, -0.33239058f, 0.51439708f, 0.04030308f, -0.01415390f, 0.24245426f, -0.14123310f, 
    0.12161022f, 0.13830425f, 0.16652900f, -0.04343911f, 0.01693983f, 0.44554058f, -0.17033646f, 0.01991240f, 
    0.01760724f, 0.02523075f, -0.04311347f, -0.07376520f, 0.10275085f, 0.07061025f, 0.00340852f, -0.18975276f, 
    -0.70372242f, 0.28589758f, -0.64928800f, -0.05277768f, 0.09829737f, -0.05594732f, -0.08814179f, -0.11833251f, 
    0.07019599f, -0.10577780f, -0.11610810f, -0.09425238f, 0.04111620f, -0.20351566f, 0.04036384f, -0.14163640f, 
    -0.17418970f, 0.15031347f, -0.18480690f, 0.20956431f, 0.22379084f, 0.23521431f, 0.34472463f, 0.00257891f, 
    0.28311169f, 0.04256698f, 0.19220409f, -0.11690999f, -0.13022073f, -0.03053722f, -0.11138406f, -0.06488049f, 
    0.04466553f, 0.07556555f, 0.22560145f, 0.12080531f, 0.06244881f, -0.12423356f, 0.06022415f, -0.12407458f, 
    -0.03291887f, 0.01938593f, 0.16203001f, -0.14226116f, 0.18337014f, -0.02507611f, 0.13681808f, 0.19210777f, 
    -0.13050659f, -0.07584324f, 0.14275645f, 0.23551026f, 0.01233559f, -0.12180053f, -0.12631181f, -0.20624880f, 
    0.06336205f, -0.13060027f, -0.04131018f, 0.18980661f, -0.43371832f, -0.01498096f, -0.28939638f, -0.17034680f, 
    0.18676452f, 0.15301858f, 0.19281201f, 0.06822727f, -0.12805879f, 0.06587680f, 0.20116512f, 0.35040107f, 
    -0.20261022f, 0.16015594f, 0.10340163f, 0.02519192f, 0.27019542f, 0.16127241f, 0.14753921f, 0.12376516f, 
    0.18639868f, 0.08117375f, 0.04855292f, 0.29490983f, -0.21554419f, 0.29238525f, 0.02380711f, -0.01299603f, 
    -0.14298752f, 0.07490533f, 0.00714981f, 0.27550468f, 0.16889383f, -0.12245012f, -0.13013361f, 0.15125939f, 
    -0.08413502f, -0.13659851f, 0.00572689f, 0.14176178f, -0.10655604f, 0.02425504f, -0.24204896f, -0.08432441f, 
    0.21354844f, 0.01944313f, 0.20530796f, 0.27813998f, 0.42167822f, 0.17821291f, 0.28925169f, 0.11361490f, 
    -0.32307076f, -0.06964828f, -0.28247613f, -0.20451926f, 0.06378546f, -0.07775890f, 0.11108520f, 0.06118997f, 
    -0.31539580f, 0.42074111f, 0.06006039f, -0.07036483f, 0.12888990f, 0.11073454f, 0.15756792f, 0.02076371f, 
    -0.10423176f, -0.05953557f, -0.13493700f, -0.11198913f, 0.06771404f, -0.24869183f, -0.21220405f, -0.26967412f, 
    0.04457022f, 0.03607481f, 0.04709380f, 0.14539841f, 0.12625755f, -0.21618837f, 0.01330763f, 0.15451312f, 
    0.12505858f, -0.16599150f, 0.19232932f, 0.17044008f, -0.06880639f, -0.02724405f, 0.12708069f, -0.16296889f, 
    -0.03059576f, -0.10207796f, -0.07167988f, -0.02762718f, 0.22224776f, 0.12255898f, 0.23676020f, -0.15010418f, 
    0.22793460f, 0.03490046f, -0.14852636f, 0.16905697f, 0.02926085f, 0.10817043f, 0.11110977f, 0.01312084f, 
    -0.03727558f, 0.03703368f, -0.01756247f, 0.00182667f, -0.07599074f, -0.07890736f, -0.04703774f, 0.04137292f, 
    0.00513813f, -0.06273836f, 0.04129634f, -0.02709797f, -0.00269668f, -0.04329364f, -0.01886983f, -0.07293407f, 
    0.06362118f, -0.06427466f, 0.02868050f, 0.01019175f, -0.08214250f, 0.01625581f, -0.05796208f, -0.04509388f, 
    0.00446217f, -0.00302763f, -0.06078584f, 0.04901582f, -0.01460810f, 0.03391061f, -0.08048941f, -0.02759823f, 
    0.04300095f, 0.01119488f, -0.00475826f, 0.00408063f, 0.03937030f, -0.00117624f, -0.08584583f, -0.08389245f, 
    0.02687322f, -0.08951887f, -0.00120702f, 0.05049387f, -0.07456196f, -0.06189658f, 0.04110315f, 0.04624735f, 
    0.02142541f, 0.01756058f, -0.02789299f, 0.01476191f, -0.03755527f, -0.06505408f, -0.04444033f, -0.02933830f, 
    -0.06460734f, -0.02664541f, 0.01846720f, 0.00279409f, -0.05830937f, 0.05178536f, -0.08092792f, -0.06255642f, 
    -0.08350340f, 0.01715751f, -0.02909338f, -0.06107843f, 0.05119739f, -0.07366136f, -0.04634485f, -0.03769920f, 
    -0.02103156f, -0.02698223f, 0.02676727f, 0.01525446f, 0.04223343f, 0.02678153f, 0.05229098f, -0.00431353f, 
    -0.04759919f, 0.01985075f, -0.02237734f, 0.02814490f, -0.05484986f, -0.09206758f, 0.02104632f, -0.01835060f, 
    -0.07907875f, -0.03877017f, -0.04656913f, 0.03624561f, -0.09364216f, 0.01121033f, -0.02025373f, 0.00773420f, 
    0.03776504f, 0.02446775f, 0.04171369f, 0.02095815f, -0.03111864f, 0.00938500f, 0.02476100f, -0.02838997f, 
    -0.01658119f, -0.07622641f, -0.08878686f, 0.01464068f, 0.00566444f, 0.06095248f, -0.01783293f, -0.03051768f, 
    -0.01664552f, 0.02475144f, 0.04246282f, -0.07812288f, 0.03749364f, -0.00330995f, -0.03370419f, -0.07728644f, 
    -0.01529041f, -0.03001245f, -0.07714720f, 0.02342113f, 0.04145128f, 0.05740651f, -0.00157077f, 0.04749797f, 
    0.02624012f, -0.02738813f, -0.00784313f, 0.00556256f, -0.07247750f, 0.05068639f, 0.05480819f, 0.00620485f, 
    0.04055021f, -0.00914894f, -0.00283947f, -0.06149168f, 0.00614988f, 0.03794371f, -0.08972386f, 0.03487103f, 
    -0.02840784f, -0.02660607f, -0.04562419f, -0.00021196f, 0.01876326f, 0.07377147f, 0.00836045f, -0.07639156f, 
    0.02281282f, 0.07919604f, -0.04439314f, 0.05388326f, 0.01116847f, -0.05171631f, -0.07089122f, -0.07681651f, 
    0.03999128f, -0.03158317f, -0.01478671f, -0.00796377f, -0.03283354f, -0.04220165f, -0.05004989f, -0.04700430f, 
    0.05608882f, -0.03451192f, 0.04708800f, -0.04366208f, -0.04715861f, -0.05163175f, -0.02405409f, 0.02373892f, 
    0.04522094f, -0.02050068f, 0.04802395f, 0.02502150f, 0.04812806f, 0.03937422f, -0.07106915f, -0.02599662f, 
    -0.05218412f, -0.01922154f, -0.01308634f, 0.02807903f, -0.02777303f, -0.00960372f, 0.02016098f, -0.05695506f, 
    0.29009610f, -0.03306251f, 0.20364565f, 0.44471163f, 0.40011254f, 0.12112524f, 0.11416661f, 0.11807492f, 
    0.20497303f, -0.01415389f, 0.10331044f, 0.10351767f, 0.31846312f, 0.14881709f, 0.07318331f, -0.20395797f, 
    -0.00354032f, 0.14621088f, 0.15743524f, 0.07643013f, -0.02575884f, 0.02720421f, -0.00518873f, -0.00207943f, 
    -0.14393631f, 0.03880813f, 0.32408658f, -0.03651558f, 0.05683202f, 0.08508652f, -0.12352668f, -0.08033694f, 
    -0.03707222f, 0.00364235f, 0.10365828f, -0.02489821f, -0.10416227f, 0.07025134f, -0.18147580f, -0.11043153f, 
    -0.01450604f, 0.09472839f, -0.16332731f, -0.00393005f, 0.12708883f, 0.28123027f, -0.30353391f, 0.01809261f, 
    -0.07024759f, 0.01882955f, -0.04984572f, -0.00393916f, -0.05306730f, -0.13891228f, -0.19138290f, -0.09694500f, 
    0.07058357f, 0.00231276f, 0.11002607f, -0.06306497f, -0.04232156f, -0.20977491f, -0.23281746f, 0.21132129f, 
    -0.03656663f, 0.21927059f, -0.08219884f, 0.23423733f, -0.00683596f, -0.07434563f, -0.02257670f, 0.00256741f, 
    0.14433044f, 0.00612951f, -0.07733510f, 0.03495818f, 0.05399211f, 0.16926189f, -0.03328329f, 0.09783656f, 
    -0.21051241f, -0.02632135f, 0.00095967f, -0.11828556f, -0.01156892f, -0.00274842f, -0.06490653f, -0.15683839f, 
    0.00775233f, 0.22252937f, -0.14632262f, -0.03001061f, -0.12308411f, -0.04918404f, -0.18623057f, 0.06457876f, 
    0.15927063f, 0.16674498f, 0.33497688f, -0.17112711f, 0.08436780f, 0.15851466f, -0.06485017f, -0.06140005f, 
    0.08132739f, -0.07101995f, 0.04324351f, -0.00599708f, -0.16242340f, 0.30177668f, -0.06461996f, -0.42472529f, 
    0.07927990f, 0.25518385f, 0.11886042f, 0.07231894f, 0.07612938f, -0.16553114f, -0.01962295f, -0.06791816f, 
    0.18733266f, 0.03149154f, 0.21837194f, 0.19765493f, -0.00432937f, 0.18457143f, -0.06759612f, 0.19184153f, 
    0.09147602f, -0.09175166f, 0.12483910f, -0.11306757f, 0.01405331f, -0.56440032f, -0.23862469f, 0.55731446f, 
    -0.12602888f, -0.12020048f, -0.03251362f, -0.01730305f, 0.14553756f, -0.00274321f, -0.10078393f, 0.01810220f, 
    0.09309745f, 0.25400579f, 0.05453615f, -0.28091174f, 0.00471002f, 0.23037773f, 0.15977851f, 0.02729065f, 
    -0.15873048f, -0.21023971f, -0.14357932f, -0.17299624f, 0.01320053f, -0.35690245f, -0.13220580f, -0.22889005f, 
    0.04278250f, -0.09808169f, -0.00958691f, 0.16165057f, -0.14586292f, 0.08786200f, -0.02089954f, -0.08574089f, 
    -0.04581729f, -0.46057934f, -0.15621544f, 0.41004428f, 0.03175803f, 0.03864754f, 0.14492165f, -0.05169365f, 
    0.11050645f, -0.13386710f, 0.10244103f, 0.07211884f, 0.29500768f, 0.06400465f, -0.10598803f, -0.28462595f, 
    0.06159647f, -0.01103671f, 0.00901084f, 0.06257215f, -0.02658232f, -0.09122428f, -0.02715159f, -0.01684493f, 
    -0.25997010f, 0.03935105f, 0.44588962f, 0.46387750f, 0.17006187f, 0.21413942f, -0.20594059f, 0.06180220f, 
    0.07206662f, 0.12405244f, -0.01313655f, 0.14529935f, -0.01140134f, 0.08937495f, 0.33453819f, -0.09601817f, 
    0.01512975f, 0.13877989f, -0.08146363f, 0.09815085f, -0.04682093f, -0.02591661f, 0.10056493f, 0.11892431f, 
    0.48373011f, 0.31424123f, -0.23539120f, -0.30581576f, -0.23956455f, -0.01524635f, 0.37510565f, -0.06092612f, 
    0.08659858f, 0.16820754f, 0.02945258f, 0.15449452f, 0.19882302f, -0.02472674f, 0.08650006f, -0.03532264f, 
    0.08064982f, 0.34417900f, -0.12632102f, -0.02718177f, 0.04674294f, 0.09765492f, -0.17363068f, 0.07917596f, 
    0.03153176f, 0.59797961f, 0.35127145f, 0.06162383f, -0.19795813f, -0.30180719f, -0.16039349f, -0.14497890f, 
    -0.03925909f, 0.00058253f, 0.18209317f, 0.21411848f, 0.71551925f, -0.23034634f, 0.07372988f, -0.00978172f, 
    0.06497829f, 0.13050850f, 0.13094720f, 0.29051718f, -0.12217313f, 0.18492967f, 0.00174430f, 0.00787954f, 
    0.16054694f, 0.12528561f, -0.01350241f, -0.14684173f, 0.03727031f, 0.19803049f, 0.07867977f, 0.06866659f, 
    0.04117308f, -0.02142529f, 0.25416136f, 0.05622372f, 0.19886294f, 0.06512882f, 0.00317677f, -0.24624373f, 
    -0.10146978f, 0.08414105f, 0.01357452f, 0.07566161f, -0.02010334f, -0.10435320f, -0.12936984f, -0.19624351f, 
    -0.18600848f, -0.29998380f, -0.25066417f, 0.07252407f, -0.05065824f, 0.06445266f, 0.08126090f, 0.02968307f, 
    -0.11402618f, 0.00009202f, -0.02483772f, -0.14777695f, -0.09646767f, 0.21195817f, 0.20797138f, -0.21074535f, 
    -0.04541539f, -0.09464353f, -0.04211856f, -0.08186085f, 0.03152947f, -0.02749420f, -0.14877540f, -0.18239824f, 
    0.07087483f, -0.24366246f, 0.18665023f, -0.10590313f, 0.07450608f, 0.09626320f, 0.11682243f, 0.10006852f, 
    0.03514417f, -0.05398167f, -0.00271268f, -0.32805255f, 0.05813387f, -0.37586185f, -0.28133607f, 0.37267405f, 
    0.02163601f, 0.06421850f, -0.01727187f, 0.07478290f, 0.13148277f, -0.19077033f, 0.15724385f, -0.06479565f, 
    -0.22133014f, 0.40416682f, 0.34862757f, -0.18462180f, 0.01851828f, -0.01598650f, -0.06748594f, 0.12039439f, 
    -0.08570531f, 0.06736038f, 0.10983105f, -0.12932569f, 0.01579860f, -0.40588549f, 0.18433198f, -0.29084152f, 
    0.04521061f, -0.04046873f, -0.11625536f, 0.35526291f, -0.13698404f, 0.05812202f, -0.01788952f, -0.01455267f, 
    0.12101986f, -0.08125988f, 0.12440990f, 0.31727186f, 0.11173365f, 0.01760554f, -0.06930470f, -0.12493366f, 
    0.04944361f, 0.04805815f, 0.01182440f, 0.01396104f, 0.15386902f, -0.38830280f, -0.02393304f, -0.25662312f, 
    0.11102152f, -0.04276051f, -0.12371363f, -0.10147955f, 0.03497153f, -0.15279670f, 0.06496405f, 0.00189782f, 
    -0.12110832f, 0.25499186f, 0.22644426f, 0.55044478f, 0.34341058f, 0.20253386f, 0.30615288f, 0.07990623f, 
    0.15406702f, 0.00631964f, 0.25060460f, -0.02599235f, 0.29031628f, -0.02099510f, -0.00762142f, -0.11046646f, 
    0.03411403f, 0.12634683f, 0.06510116f, -0.25800547f, 0.08436040f, 0.12413857f, -0.03736397f, -0.12222021f, 
    0.09280613f, -0.37626719f, 0.66132945f, -0.33473077f, 0.04618979f, -0.03841054f, -0.21205221f, 0.05690407f, 
    -0.20388502f, -0.08917851f, 0.02590715f, 0.06446395f, 0.11190357f, -0.02084587f, -0.09129763f, 0.01026201f, 
    0.12211060f, -0.04822633f, -0.08493847f, 0.09084421f, 0.09015762f, 0.05299615f, 0.10464583f, 0.10096388f, 
    -0.38644797f, -0.04517211f, -0.34105039f, -0.19245420f, -0.06832808f, -0.04604447f, -0.06936169f, -0.16992779f, 
    -0.07260531f, 0.17722505f, 0.08823334f, -0.09905092f, 0.26706666f, 0.12637779f, -0.01864904f, 0.35180831f, 
    -0.21417199f, -0.00679318f, 0.03464668f, 0.04174634f, -0.00495512f, 0.31581014f, -0.19115417f, 0.07462353f, 
    0.16553280f, 0.06242305f, 0.10332051f, 0.11358715f, -0.18329336f, -0.01187336f, -0.19742830f, -0.05230546f, 
    -0.04735940f, -0.20716000f, 0.16277111f, 0.06948854f, -0.04255248f, -0.15406281f, 0.05616882f, -0.07443664f, 
    0.05186299f, 0.23242065f, 0.24768552f, -0.21536291f, -0.18194894f, 0.03455644f, 0.05329385f, 0.04036315f, 
    -0.22954324f, 0.57455409f, -0.34511134f, 0.06968710f, -0.10897829f, 0.08100704f, 0.11911089f, 0.00020541f, 
    -0.07877418f, -0.01790993f, 0.06383644f, 0.06290518f, 0.53747940f, 0.27833357f, 0.05860985f, -0.07748690f, 
    0.02096439f, 0.25622109f, 0.13269441f, 0.31306654f, -0.04847024f, 0.01257900f, 0.03794088f, 0.10319925f, 
    0.48229396f, 0.34864289f, 0.34992984f, 0.18992494f, -0.15682019f, -0.00717502f, -0.13120632f, -0.00278412f, 
    -0.00299294f, -0.04748692f, 0.16569626f, 0.18475632f, 0.13434669f, 0.40530342f, -0.06962284f, 0.59583324f, 
    -0.13756493f, 0.07810608f, -0.13852824f, -0.03252302f, -0.01027661f, -0.14500953f, -0.06515046f, -0.02414585f, 
    0.12841070f, 0.09621328f, 0.12190400f, -0.07501148f, 0.04357784f, 0.05483636f, -0.12373099f, -0.21739039f, 
    -0.04793777f, 0.22409891f, -0.12708975f, -0.01081232f, -0.03477395f, 0.16252722f, -0.51494664f, 0.38027322f, 
    -0.13324520f, -0.14759088f, -0.20455457f, 0.03199158f, 0.01170106f, 0.02211396f, 0.03928482f, 0.07929129f, 
    -0.21687315f, 0.29581794f, -0.14891364f, 0.27187353f, -0.10792695f, -0.04435886f, -0.06622063f, 0.00765666f, 
    -0.18181242f, -0.23077427f, -0.14452991f, -0.17278063f, 0.01056076f, 0.35155180f, -0.28460079f, -0.16399409f, 
    -0.02764778f, -0.12232454f, 0.06885361f, 0.17758614f, 0.07446340f, -0.10867023f, 0.15460941f, 0.24153359f, 
    0.37780276f, 0.09315318f, -0.16376098f, -0.02798359f, 0.38472879f, 0.04984169f, 0.14256865f, 0.04642483f, 
    0.18185376f, -0.20973745f, -0.03679431f, -0.02364274f, 0.23261352f, -0.01282929f, -0.07710088f, -0.10184421f, 
    0.27680740f, -0.02854878f, 0.09034716f, -0.00419297f, 0.02386045f, 0.01739092f, 0.13078471f, 0.10908010f, 
    0.08707246f, -0.04181828f, 0.24875198f, -0.32875568f, -0.04746237f, 0.02532900f, -0.12223418f, 0.12760563f, 
    -0.13174574f, -0.07162104f, 0.11418378f, 0.15525146f, 0.00652814f, -0.00348392f, 0.04176829f, -0.06596483f, 
    0.10391112f, -0.07766649f, 0.00900887f, -0.03320683f, -0.07490312f, -0.10496150f, 0.22843809f, 0.06912957f, 
    -0.17073891f, -0.28200138f, -0.46786198f, -0.11514040f, 0.15646259f, 0.14769894f, 0.06456879f, -0.10241640f, 
    -0.01755386f, 0.03024408f, -0.00801877f, -0.13282843f, -0.03592989f, -0.16146359f, 0.16031826f, 0.31869549f, 
    -0.04985998f, -0.32304341f, 0.04097765f, 0.05407558f, 0.02131646f, 0.19502564f, -0.26542836f, 0.00487121f, 
    -0.20102237f, 0.01814058f, 0.15667026f, 0.02235863f, -0.05103484f, 0.02230571f, -0.13524809f, -0.07727441f, 
    -0.10792147f, 0.07055190f, 0.10452724f, 0.08570856f, -0.07720127f, -0.03590474f, -0.02354452f, -0.06938136f, 
    0.18746236f, 0.01716945f, 0.30397579f, -0.05887196f, -0.00954235f, 0.05919608f, 0.10709100f, -0.01349921f, 
    0.19366042f, 0.49400255f, -0.44666278f, -0.07322510f, 0.02754073f, -0.16438629f, 0.06761009f, -0.19276957f, 
    -0.03836282f, -0.04052457f, -0.01922717f, -0.07280728f, 0.66902810f, 0.09877817f, -0.01246948f, 0.09318749f, 
    0.12054183f, 0.21344531f, 0.08281042f, 0.21237659f, -0.16493620f, 0.09966610f, 0.02856978f, 0.15264928f, 
    0.16742638f, 0.34740168f, 0.13071926f, 0.13143295f, -0.14754277f, -0.09269953f, -0.09710273f, -0.02965009f, 
    -0.02281077f, 0.08180948f, 0.05286791f, 0.12929964f, 0.12822323f, 0.61271840f, -0.03872495f, 0.06071446f, 
    -0.01551592f, -0.14768381f, -0.01046082f, -0.11487471f, -0.12182052f, -0.03405300f, -0.01219686f, 0.11987819f, 
    0.48434153f, -0.12728536f, -0.07036193f, 0.04591382f, 0.12816858f, 0.13566618f, -0.06188882f, 0.08295531f, 
    -0.03869344f, 0.14628267f, -0.05258145f, 0.12137558f, 0.39078653f, 0.01493241f, -0.22443174f, 0.56411803f, 
    0.01802086f, 0.13069558f, 0.21227296f, 0.01888247f, 0.09349395f, 0.13838609f, -0.05208971f, 0.10928197f, 
    -0.24404955f, 0.44487053f, -0.14944947f, -0.01650073f, -0.14361732f, -0.00509200f, -0.03857494f, -0.04206910f, 
    -0.11419126f, 0.33118361f, 0.04263809f, -0.01734019f, -0.00573607f, 0.24906902f, -0.27284259f, -0.19742799f, 
    -0.06393363f, -0.25731412f, 0.04439367f, 0.01749129f, 0.05286054f, -0.02724496f, 0.13011266f, 0.21867733f, 
    0.28961661f, 0.11341601f, -0.32148430f, 0.22619621f, 0.34895238f, 0.07197022f, 0.08054314f, 0.01173801f, 
    0.08403655f, 0.02687329f, 0.10824408f, -0.03296288f, 0.03589709f, -0.15370554f, 0.07818510f, 0.29029241f, 
    0.05038948f, -0.13646965f, -0.00734221f, 0.10480484f, -0.05338885f, -0.07809222f, -0.02240019f, 0.05323397f, 
    -0.38889751f, 0.68715006f, 0.25840795f, 0.25341910f, 0.12200836f, -0.08581381f, -0.02224614f, 0.10088295f, 
    -0.07280456f, -0.03342013f, -0.08512713f, 0.05727114f, 0.02981662f, 0.22427803f, 0.12629725f, -0.25950429f, 
    -0.20374551f, 0.11129662f, 0.14647231f, -0.02164552f, 0.14644313f, 0.20066126f, 0.12503983f, 0.00662972f, 
    0.17258641f, -0.51346618f, -0.35225502f, -0.23481543f, -0.04368246f, 0.03832071f, -0.16066742f, 0.08621987f, 
    0.11407502f, 0.01055203f, 0.02525586f, -0.15493636f, -0.40731966f, -0.04775626f, 0.14507304f, 0.00665340f, 
    -0.01829769f, -0.03755330f, -0.10925907f, 0.28726757f, 0.01880978f, -0.05130151f, 0.02493536f, 0.06483871f, 
    -0.28163952f, 0.02840682f, 0.20630023f, -0.07516015f, -0.13968717f, -0.10345479f, -0.08057808f, -0.11233368f, 
    -0.11131303f, -0.24813896f, -0.22530055f, -0.09328216f, -0.33801997f, -0.01266392f, -0.04542120f, 0.07386167f, 
    0.22313869f, 0.13836943f, 0.04341206f, 0.42882547f, 0.17982674f, 0.22219941f, 0.14389665f, 0.21651556f, 
    0.47924697f, 0.00568532f, 0.04655217f, 0.20137934f, 0.24556087f, 0.07463213f, 0.07440547f, 0.06818476f, 
    0.10332746f, 0.26011160f, 0.15940344f, -0.05834839f, 0.19817922f, -0.40144357f, -0.13924018f, 0.14354879f, 
    -0.08573978f, -0.04806624f, 0.20672312f, 0.10679404f, 0.14233619f, 0.00344414f, 0.20283584f, 0.01070949f, 
    0.15056475f, 0.32639951f, 0.28878060f, 0.12185864f, -0.16904975f, -0.15271766f, -0.20531341f, -0.08527891f, 
    0.07424308f, 0.13746202f, 0.00753827f, 0.16194327f, 0.10504371f, 0.43605366f, 0.10589163f, -0.36288440f, 
    0.10055881f, -0.09173112f, -0.01858534f, -0.26579139f, -0.27007791f, 0.04148774f, 0.18795431f, 0.10047658f, 
    0.08778936f, -0.30303472f, -0.19207688f, 0.14993063f, -0.00912958f, -0.28157964f, 0.09678914f, 0.11603235f, 
    0.06451332f, -0.06637528f, -0.14425512f, -0.09087798f, -0.04700000f, 0.36333925f, 0.22583781f, 0.28981796f, 
    -0.09395406f, 0.16438980f, -0.06362724f, 0.33879060f, -0.09903052f, -0.04866942f, 0.02315116f, -0.18785530f, 
    0.01993640f, 0.34498510f, -0.01097259f, 0.04741453f, -0.12521110f, -0.02822764f, -0.07469597f, -0.29928967f, 
    0.08213690f, 0.00172557f, -0.12088501f, -0.01884398f, -0.06702814f, 0.22378583f, 0.26484257f, 0.44597229f, 
    -0.08861035f, -0.08796252f, 0.01502162f, 0.19321008f, -0.02205416f, 0.04967123f, 0.10763341f, 0.03547606f, 
    -0.07687881f, 0.01686954f, 0.20443754f, 0.24923441f, 0.22673926f, -0.11938635f, 0.32233790f, 0.21969874f, 
    0.01300004f, -0.04716243f, 0.13499467f, 0.22722791f, -0.30445024f, 0.07925121f, 0.03957516f, -0.18888406f, 
    -0.03170179f, 0.12362649f, 0.10706157f, 0.10836756f, -0.10678990f, -0.01826188f, 0.31321722f, 0.02237576f, 
    0.39191422f, 0.25826320f, -0.42810071f, -0.21436976f, -0.04270674f, -0.07036954f, 0.25316152f, 0.09923976f, 
    0.19514522f, -0.03918510f, -0.06861208f, 0.20515326f, 0.15212646f, -0.12687013f, 0.12215701f, 0.08783755f, 
    0.34270826f, 0.05457471f, 0.00804383f, -0.04892020f, -0.02036039f, -0.10646978f, 0.01475196f, 0.14944682f, 
    -0.19783852f, 0.39067575f, 0.60344708f, -0.01556732f, -0.37229905f, -0.02352605f, 0.03723461f, -0.09903750f, 
    -0.06806858f, -0.03708969f, 0.15294473f, 0.01189287f, 0.40390989f, -0.19499990f, 0.35161129f, -0.09347238f, 
    0.16641469f, 0.00262040f, 0.13514642f, 0.20917799f, 0.27791375f, 0.17962846f, 0.20783299f, 0.19330728f, 
    -0.08097255f, 0.12076316f, 0.01897045f, -0.07650913f, 0.04995183f, 0.09174468f, 0.23539053f, 0.01570942f, 
    0.28158030f, 0.16326858f, 0.15760559f, 0.25259182f, 0.04794635f, 0.01137438f, -0.15361387f, -0.15674263f, 
    0.02559689f, -0.20506871f, 0.06054179f, -0.40787342f, -0.07085566f, -0.32369506f, -0.27393520f, -0.18690987f, 
    -0.17153051f, -0.24401309f, -0.64471316f, 0.09518686f, -0.19525079f, -0.08929347f, -0.12675127f, 0.07738245f, 
    -0.15586963f, -0.08731877f, -0.08663516f, -0.23765051f, -0.44740656f, -0.01379462f, 0.18865061f, 0.03035879f, 
    0.18455920f, 0.00634934f, 0.08072288f, -0.04750086f, -0.18361244f, 0.01017227f, -0.15979189f, -0.01130341f, 
    -0.04000159f, -0.19402088f, 0.00582759f, -0.02786065f, 0.03128583f, -0.00966022f, 0.14435652f, 0.03719622f, 
    -0.05810021f, 0.06335422f, -0.10739636f, 0.01207452f, 0.30587542f, 0.28372139f, -0.09686371f, 0.41057536f, 
    -0.15698180f, -0.03513905f, -0.09628627f, 0.12386800f, 0.20285125f, -0.03187729f, 0.23196308f, 0.25977859f, 
    -0.49429798f, 0.15887651f, 0.29242995f, -0.14124981f, -0.11143029f, 0.33693826f, -0.09471175f, 0.27505600f, 
    -0.22966997f, -0.07183171f, 0.08128320f, -0.09133139f, -0.45971155f, -0.61749858f, -0.00002383f, 0.29430717f, 
    0.09996045f, 0.12803742f, 0.15262619f, 0.17629711f, 0.05661654f, -0.03404646f, 0.01921432f, 0.04747825f, 
    0.01951988f, -0.13287354f, 0.05835415f, 0.11792573f, -0.04032286f, -0.03634940f, -0.11220384f, 0.07148912f, 
    0.10872899f, 0.27979550f, 0.33344504f, 0.03598770f, -0.16225065f, -0.24411798f, -0.42884871f, -0.10240021f, 
    0.24963327f, 0.07304637f, -0.15675749f, -0.27533510f, -0.05805452f, -0.12450121f, 0.08352397f, 0.00818691f, 
    0.05059562f, -0.04138423f, 0.02552021f, -0.04864100f, -0.05458046f, -0.01144024f, -0.04656230f, 0.00368034f, 
    -0.00923330f, 0.01188489f, -0.06881023f, 0.06532808f, 0.01638003f, -0.01185471f, -0.07147221f, 0.01761368f, 
    -0.03948573f, -0.02413003f, 0.03373266f, -0.03567527f, 0.01732722f, -0.01033135f, 0.05198069f, 0.04931309f, 
    -0.01021515f, 0.03184630f, 0.01246220f, -0.06051951f, 0.05098497f, -0.00112304f, 0.02485173f, 0.05093102f, 
    -0.05293182f, -0.04104998f, 0.02946208f, 0.02511392f, -0.03510864f, -0.00321800f, -0.00635200f, -0.01264367f, 
    -0.03920335f, 0.00008455f, -0.08336487f, -0.05473109f, -0.07931571f, -0.04927949f, 0.00656782f, -0.07108216f, 
    0.04797295f, -0.02509457f, -0.04203163f, 0.00907788f, 0.04407260f, -0.04820756f, -0.02489988f, 0.04203981f, 
    -0.06741510f, -0.00938982f, -0.00294432f, 0.04546060f, -0.02625897f, 0.05818397f, 0.00618560f, -0.07428629f, 
    0.02744148f, 0.02118090f, -0.02541609f, -0.04636662f, -0.03102540f, 0.04211100f, 0.01163587f, -0.05292869f, 
    0.05636365f, 0.04675015f, -0.05456281f, -0.06106682f, -0.04989977f, -0.05037308f, -0.01358432f, 0.04252160f, 
    -0.03304600f, -0.06008088f, 0.00826316f, -0.03920821f, -0.01065021f, 0.02582095f, 0.01416074f, 0.01154503f, 
    0.02514205f, -0.00345332f, -0.06772592f, -0.06635123f, 0.02863943f, -0.00712479f, -0.08288364f, -0.06710079f, 
    -0.00224713f, -0.00389584f, 0.04964725f, 0.04136490f, 0.05259356f, -0.06536578f, 0.04897873f, -0.00456034f, 
    -0.01426613f, -0.07419877f, -0.00653612f, -0.03760292f, -0.06652927f, -0.03619200f, 0.01960191f, 0.03355961f, 
    0.03893416f, 0.03732451f, -0.00924656f, -0.01148463f, -0.03466280f, -0.07984526f, 0.01033034f, 0.01306218f, 
    -0.01077036f, -0.03129871f, -0.06341701f, -0.05486454f, -0.03651339f, 0.02154599f, 0.04501148f, 0.05774503f, 
    -0.02983864f, -0.04838819f, -0.04235116f, 0.01492263f, 0.03672746f, 0.01151693f, -0.01986647f, -0.05662441f, 
    -0.04993844f, -0.05334721f, -0.02119432f, 0.01204607f, 0.05806999f, -0.01302481f, -0.06507767f, 0.06153744f, 
    -0.05523887f, 0.03798563f, -0.07602679f, -0.02069747f, 0.00649755f, -0.02546645f, 0.01310259f, 0.02767020f, 
    -0.04914424f, -0.05843163f, -0.00209675f, 0.05559172f, 0.00302842f, 0.00581229f, -0.05493743f, -0.02574507f, 
    -0.03674217f, 0.05826609f, 0.04361156f, -0.05744260f, 0.00599152f, 0.06320544f, -0.05181482f, -0.05969851f, 
    -0.01027480f, 0.02500181f, 0.00916495f, 0.03960522f, -0.00216183f, 0.03123104f, 0.01080755f, -0.06034826f, 
    0.05344047f, 0.00015540f, 0.02541026f, -0.07094413f, 0.00628730f, -0.06355859f, -0.00890019f, 0.04749115f, 
    -0.07134356f, -0.01719966f, -0.07537615f, -0.01463892f, -0.01872819f, 0.04414095f, -0.06544984f, -0.07950067f, 
    0.00873160f, -0.04880388f, 0.05996953f, 0.04017659f, 0.05195667f, -0.02818941f, -0.02628441f, 0.02723058f, 
    -0.03578641f, -0.07460263f, -0.02878718f, -0.00644999f, -0.01677594f, -0.03608666f, -0.06195243f, -0.01316235f, 
    -0.02924309f, -0.03360578f, -0.05630200f, -0.02860015f, 0.04635973f, 0.00268530f, -0.06140807f, 0.03426250f, 
    0.01968877f, -0.07177518f, -0.04885382f, 0.02164930f, 0.05086897f, 0.00179003f, -0.05612610f, 0.04509756f, 
    -0.01998257f, 0.03533293f, -0.01056779f, -0.04122195f, -0.02524669f, 0.01912501f, 0.00826358f, 0.06149231f, 
    -0.04292075f, -0.07019049f, -0.04868569f, 0.05746446f, -0.00544080f, -0.05071851f, -0.07595497f, -0.00256643f, 
    0.06016700f, -0.06103742f, -0.06779253f, 0.05217906f, -0.02701385f, -0.01070305f, -0.06369407f, -0.06319154f, 
    0.03100295f, -0.07088966f, 0.00355755f, 0.06261027f, -0.03598936f, 0.06633617f, -0.05974648f, -0.00518301f, 
    -0.06625745f, 0.04745593f, -0.00537009f, -0.05273538f, -0.03133882f, 0.05016667f, -0.04801315f, 0.01392821f, 
    0.06917676f, 0.00834115f, -0.07785318f, -0.03535459f, -0.04257007f, 0.05594151f, 0.06118518f, 0.03690187f, 
    -0.07725895f, 0.03490301f, 0.04113779f, -0.00704908f, -0.00481301f, 0.00295477f, 0.00002879f, 0.00962115f, 
    -0.02134722f, 0.02459636f, 0.03333381f, 0.01236785f, 0.02594687f, -0.03163989f, -0.07441448f, 0.00311050f, 
    -0.03133962f, -0.03133386f, -0.01598322f, 0.01441235f, 0.05957713f, 0.01094793f, -0.03686043f, 0.05676313f, 
    -0.05039299f, -0.06425000f, -0.07576329f, -0.01581436f, 0.05940475f, 0.04798714f, 0.00717047f, -0.03291601f, 
    0.01195263f, -0.06687195f, -0.05815134f, 0.02409397f, -0.05859020f, -0.03487637f, -0.06672529f, -0.06441627f, 
    0.01622270f, 0.05924828f, 0.05549328f, -0.07221302f, -0.01958607f, 0.03937805f, -0.02537235f, -0.05787177f, 
    -0.03376986f, 0.04051368f, -0.01515996f, -0.04780019f, -0.01749575f, -0.04975615f, -0.07085122f, 0.04940612f, 
    -0.05497468f, -0.07371929f, -0.05620402f, 0.04545968f, -0.02522926f, 0.02915469f, -0.05768813f, 0.00813192f, 
    -0.05863210f, -0.07077012f, 0.05155497f, -0.07071400f, 0.06481072f, 0.02458504f, 0.04368185f, -0.04182671f, 
    0.02872047f, -0.04537157f, -0.00348025f, -0.04875885f, -0.06056430f, -0.05262960f, -0.03943956f, 0.05124301f, 
    0.01320483f, -0.02500424f, 0.02016832f, 0.02563939f, -0.03053271f, 0.02500998f, 0.01363569f, 0.06563853f, 
    0.00523833f, -0.05204222f, -0.06010170f, -0.02894808f, -0.03907255f, 0.00538182f, 0.00241841f, -0.06297940f, 
    -0.03460042f, -0.05896574f, 0.05040169f, -0.00909781f, -0.07009649f, -0.06543588f, 0.02808224f, 0.02352102f, 
    -0.04998302f, -0.04753475f, 0.04551873f, 0.00951149f, 0.01085376f, 0.02517144f, 0.03425479f, 0.03138266f, 
    0.02445243f, 0.37681758f, 0.04104977f, 0.44878784f, -0.02810814f, -0.30495432f, 0.37452236f, 0.33710322f, 
    0.17224365f, 0.24548729f, 0.09934055f, 0.14847599f, -0.05368245f, 0.13407472f, 0.11996472f, 0.29737276f, 
    -0.14170814f, 0.15898339f, 0.07020600f, -0.10745978f, 0.06808760f, 0.08685979f, 0.01363712f, -0.01336563f, 
    0.07478993f, 0.21361619f, -0.71134526f, 0.27406749f, 0.16023155f, -0.03775703f, 0.40965602f, -0.08013819f, 
    -0.11489353f, 0.05945202f, -0.16317615f, 0.01237410f, -0.07940528f, -0.10859834f, 0.11270478f, -0.13436931f, 
    -0.00457928f, -0.16053639f, 0.01029188f, -0.05560733f, 0.04350829f, 0.04227285f, 0.01694048f, 0.16382542f, 
    -0.31108221f, -0.13421707f, 0.23458488f, -0.20118283f, -0.08928452f, 0.09016009f, -0.16569306f, -0.03194140f, 
    0.13799578f, 0.13088843f, 0.06482982f, -0.03975668f, -0.17993309f, 0.11184555f, 0.12878005f, -0.35112867f, 
    0.21819609f, 0.21362907f, 0.05452172f, 0.04158654f, 0.20440023f, -0.29383940f, 0.12294111f, 0.17685719f, 
    -0.07980639f, 0.14054362f, 0.01350582f, 0.08290406f, 0.00010118f, -0.06410073f, -0.03708115f, -0.06893314f, 
    -0.14148498f, -0.25064197f, -0.10914502f, -0.23947531f, -0.14905888f, -0.03292204f, -0.17582199f, -0.11062074f, 
    0.06974833f, 0.06719936f, -0.12631601f, 0.07809170f, 0.11783339f, -0.12960289f, 0.04277680f, 0.16778865f, 
    0.11969408f, -0.48533413f, 0.10034638f, 0.11139110f, 0.22732911f, 0.21497296f, 0.12172497f, 0.07711388f, 
    0.23210643f, 0.09491957f, 0.07549982f, 0.11831422f, -0.61098099f, -0.25540704f, 0.07167635f, -0.19447489f, 
    -0.06664076f, 0.01714757f, 0.11875211f, -0.10044401f, 0.04164813f, 0.02793906f, 0.35996878f, 0.14882474f, 
    -0.21111733f, -0.21825410f, -0.35957298f, 0.01746853f, 0.03549762f, 0.00682048f, 0.11875149f, -0.07401739f, 
    -0.00097671f, 0.02702727f, 0.02741247f, 0.16934249f, -0.05032917f, -0.11441515f, 0.17604582f, 0.08707424f, 
    -0.11621177f, -0.11349881f, -0.01472764f, -0.17824312f, -0.03149188f, 0.04192849f, 0.22642967f, 0.19365649f, 
    -0.37509641f, 0.03256657f, -0.10839360f, -0.15333702f, -0.12780032f, 0.06463342f, 0.14214720f, 0.13584462f, 
    0.17669128f, -0.08513885f, 0.01866103f, -0.10233386f, -0.30408370f, -0.04868710f, 0.05397122f, -0.34577897f, 
    -0.04073692f, -0.07395238f, 0.12574764f, -0.21603312f, -0.16907534f, 0.03961855f, 0.06828869f, -0.05237740f, 
    0.27134219f, -0.06898179f, 0.41412732f, -0.13647023f, -0.09879029f, -0.14246452f, 0.04277756f, -0.01895914f, 
    0.20342043f, 0.11908407f, 0.18346453f, -0.07959296f, -0.02844394f, -0.20256531f, 0.13537756f, 0.32430354f, 
    0.25851190f, 0.35617533f, 0.02934925f, -0.07690944f, -0.00821888f, 0.07994702f, 0.15456857f, -0.03482584f, 
    -0.20296137f, -0.47778684f, 0.39414927f, 0.04219938f, -0.02587066f, -0.02973986f, -0.30682319f, 0.26113656f, 
    0.13659659f, 0.00902160f, 0.05457718f, -0.02207438f, -0.21277955f, -0.26197055f, 0.25247082f, 0.18198444f, 
    0.03731197f, -0.03205079f, -0.03395279f, 0.21892506f, 0.17228207f, 0.07338271f, 0.17161685f, 0.25521213f, 
    0.32939807f, 0.28356251f, 0.10713417f, 0.54368240f, 0.11054246f, 0.15944979f, 0.13685217f, -0.13128501f, 
    0.10686471f, 0.10541027f, 0.01920818f, -0.03976241f, 0.13682945f, -0.05726818f, -0.14269142f, 0.10997748f, 
    0.18846843f, 0.17768295f, 0.05785650f, -0.19581686f, -0.03332232f, -0.08748360f, -0.29117748f, -0.05533393f, 
    -0.37241161f, 0.19573393f, 0.32426748f, 0.00533761f, 0.18810847f, -0.12216526f, 0.06083379f, 0.17209387f, 
    -0.06290851f, 0.00103869f, 0.07302561f, 0.10618856f, 0.05597653f, -0.15917364f, -0.53471297f, -0.29893249f, 
    -0.14439148f, 0.25634903f, -0.17669450f, -0.10618775f, 0.11112595f, 0.01128139f, 0.18939564f, 0.05783428f, 
    -0.24837717f, -0.47767255f, -0.05693550f, -0.13451792f, -0.00638976f, 0.07317152f, -0.00639943f, -0.05124036f, 
    0.15549077f, 0.22080895f, 0.10620654f, 0.15102333f, 0.13621882f, -0.17684251f, 0.14109290f, 0.03270432f, 
    0.19609900f, 0.28253049f, 0.04950954f, 0.42475015f, 0.16612191f, -0.19086309f, -0.11329991f, -0.29792780f, 
    0.13397484f, -0.07931846f, 0.30514967f, 0.27964005f, -0.05978140f, 0.04483727f, 0.02844177f, 0.08014788f, 
    -0.04204578f, -0.04675223f, -0.05002953f, -0.10880700f, -0.12823525f, -0.23882538f, 0.13365839f, -0.04344414f, 
    -0.04426492f, -0.27181491f, 0.12009107f, -0.36338919f, -0.09267905f, 0.01789145f, 0.14196299f, 0.24498017f, 
    -0.05611847f, -0.55030447f, -0.23473585f, 0.23134066f, -0.09086518f, -0.03722975f, 0.03959798f, -0.08710857f, 
    -0.10111144f, -0.15681468f, -0.16476648f, -0.07631909f, -0.51096135f, 0.09354565f, -0.21603629f, -0.24099891f, 
    0.10092012f, -0.24899936f, -0.04887998f, 0.24239753f, 0.03175194f, 0.08889991f, -0.16605526f, -0.03679144f, 
    0.07888578f, 0.13131328f, 0.16214958f, 0.19792700f, -0.01552060f, -0.04140390f, 0.03591352f, 0.12873711f, 
    0.14635465f, 0.03273191f, 0.16064464f, 0.12871009f, 0.05872704f, 0.21212576f, 0.34410027f, 0.25794116f, 
    -0.00557707f, 0.06654938f, -0.14128368f, 0.11326230f, -0.11601152f, 0.15962127f, 0.01130976f, -0.16238745f, 
    -0.29112673f, -0.37971315f, -0.11139321f, 0.24680133f, -0.05625003f, 0.03958507f, -0.02084976f, -0.10047074f, 
    0.11874434f, 0.15111482f, 0.00854587f, 0.29616368f, 0.05467823f, 0.02978182f, 0.21243480f, 0.70309514f, 
    -0.00027337f, 0.15026207f, 0.00009991f, -0.00416323f, 0.03435358f, -0.01880183f, -0.16654480f, -0.05646695f, 
    -0.08750760f, 0.53702015f, -0.00527272f, -0.50934750f, -0.26446921f, 0.13205929f, -0.06232263f, -0.09393189f, 
    -0.12024836f, 0.00180768f, -0.10292892f, -0.00338572f, -0.38026118f, 0.04372350f, -0.11690233f, 0.01313829f, 
    0.17653579f, 0.06236932f, 0.09462974f, 0.09163139f, 0.08520598f, 0.06071306f, 0.11448006f, 0.04165019f, 
    -0.27078110f, -0.31725648f, -0.21697091f, -0.13319708f, 0.02541160f, 0.14942698f, 0.09844361f, -0.12856534f, 
    0.25615323f, -0.00100978f, -0.08025876f, -0.00904253f, 0.09819485f, -0.00703673f, 0.19727872f, 0.11703874f, 
    0.04242665f, -0.00393681f, 0.08236991f, 0.12809269f, -0.28108722f, -0.27143776f, -0.03200902f, -0.29703328f, 
    0.89604777f, 0.48194674f, 0.56734377f, 0.41921341f, 0.05896224f, -0.11523051f, 0.05471511f, -0.08914162f, 
    -0.01460668f, 0.00999600f, -0.06890749f, 0.24801318f, -0.09179355f, 0.28863293f, 0.09388992f, 0.05215035f, 
    0.02912407f, -0.17899078f, -0.11594152f, -0.24965635f, 0.06967746f, 0.24331170f, 0.19198421f, -0.14766832f, 
    0.09684837f, -0.03824579f, -0.05348479f, 0.05029829f, -0.12641963f, -0.28190082f, -0.00682238f, -0.16012001f, 
    0.23067014f, 0.07217052f, -0.03117665f, 0.32822448f, -0.11565625f, -0.07729103f, -0.07975972f, 0.14493899f, 
    0.06465536f, -0.08431412f, 0.17719495f, 0.00315465f, -0.20516340f, -0.24822482f, -0.13996094f, -0.49672189f, 
    -0.63135946f, -0.03342075f, -0.25607413f, 0.05646481f, 0.01634309f, 0.17801681f, 0.12810257f, 0.04000250f, 
    -0.06696910f, -0.01967098f, -0.16788243f, -0.04819421f, 0.39559081f, 0.03270113f, 0.24957748f, 0.51575714f, 
    0.02429406f, 0.01243234f, -0.02927629f, 0.25387257f, -0.00511638f, 0.14410613f, 0.00150096f, 0.06383672f, 
    -0.32135063f, -0.24922077f, -0.14542255f, -0.28082982f, 0.20650713f, -0.10835055f, 0.02061241f, -0.14529355f, 
    -0.30378953f, -0.20406030f, -0.10893910f, -0.20424791f, 0.07441323f, 0.25400057f, 0.09077525f, -0.20465229f, 
    -0.06679355f, 0.10729811f, 0.07078549f, -0.22835849f, 0.09726951f, 0.26659763f, 0.11900624f, -0.27117583f, 
    0.11176432f, -0.22833732f, -0.04385639f, 0.46355990f, 0.04386171f, -0.06786395f, 0.09517271f, 0.11087115f, 
    0.16084003f, 0.26142815f, 0.13122772f, 0.25680843f, 0.13231157f, -0.01759086f, -0.00887795f, 0.15111129f, 
    0.24297631f, 0.34228590f, 0.11928686f, 0.08262055f, 0.36037189f, 0.06084149f, 0.20537975f, 0.05684641f, 
    0.25506848f, 0.23339705f, 0.21571791f, -0.07832389f, -0.15521768f, -0.01453816f, -0.19255513f, 0.06604642f, 
    0.19126403f, 0.04795735f, 0.15766731f, 0.24374631f, -0.24039695f, 0.00965913f, 0.13020308f, 0.15313585f, 
    0.21598925f, 0.17519979f, 0.03941865f, 0.08605814f, 0.07078121f, -0.07224672f, -0.02243253f, 0.03419825f, 
    -0.22139151f, 0.27194020f, 0.55097246f, -0.08732602f, -0.26365355f, 0.20040506f, -0.03516842f, -0.16056025f, 
    0.00929739f, 0.05229782f, -0.16653499f, 0.09868281f, 0.26293850f, 0.16554940f, 0.24855900f, 0.18098944f, 
    0.13464706f, 0.00722713f, 0.22645153f, 0.17855465f, 0.17982128f, 0.15873104f, -0.10084633f, 0.06031987f, 
    -0.02031052f, 0.11946923f, 0.10500033f, 0.24107014f, -0.03053390f, 0.09442247f, 0.35465038f, 0.06953793f, 
    -0.00648529f, 0.14979386f, 0.07661702f, 0.11314734f, -0.06961226f, 0.05821968f, -0.15228663f, 0.03634400f, 
    -0.16813502f, 0.18471479f, 0.05604011f, 0.03101284f, 0.04451637f, 0.12182344f, -0.11266840f, -0.19298287f, 
    0.21861562f, 0.15437302f, -0.00804573f, -0.00062454f, 0.05270689f, -0.09374969f, -0.08800244f, 0.12493737f, 
    0.05686527f, 0.09928910f, -0.09431858f, -0.08134140f, 0.15635121f, -0.12958592f, -0.58597422f, 0.07611818f, 
    -0.23532611f, 0.10719278f, -0.24159107f, 0.02189657f, 0.06128521f, 0.00144332f, 0.12222049f, -0.08720560f, 
    -0.26758814f, -0.49513885f, -0.31880027f, -0.16839027f, -0.13194971f, 0.05074117f, -0.07889845f, -0.11601448f, 
    0.05373006f, 0.01941547f, 0.20278858f, -0.01207318f, 0.13342622f, -0.02266005f, 0.06801957f, -0.01649183f, 
    -0.01469307f, 0.24733657f, 0.19732644f, 0.32612720f, -0.11529697f, 0.00423187f, 0.03441191f, -0.10066140f, 
    0.21591091f, 0.44220659f, 0.64154124f, 0.06264399f, -0.04679788f, 0.24455471f, 0.06893862f, 0.12143768f, 
    -0.16418481f, 0.02674807f, -0.02919436f, 0.02055442f, 0.04362203f, 0.13956119f, 0.12925763f, -0.05884201f, 
    -0.07635473f, 0.04905143f, 0.07153825f, 0.13979171f, 0.06587547f, -0.05826272f, 0.07821274f, -0.04953272f, 
    -0.10845705f, -0.46060726f, -0.22648484f, 0.01182060f, -0.08313806f, -0.02039544f, 0.01080759f, 0.05658713f, 
    0.00039091f, -0.12700841f, 0.03469700f, -0.03958741f, -0.42862383f, -0.42013699f, -0.30591759f, -0.32985258f, 
    0.00465953f, 0.08060377f, 0.05582990f, 0.00170644f, 0.04828875f, 0.00717937f, -0.11338171f, -0.08322480f, 
    0.33168358f, 0.29986334f, 0.12044873f, 0.23199899f, 0.19644672f, -0.05681930f, 0.09632757f, 0.11919265f, 
    0.04581572f, -0.01476038f, -0.10715340f, 0.00414378f, 0.48268560f, 0.12141053f, 0.26944637f, -0.16918153f, 
    0.06302017f, -0.00556780f, -0.26037923f, 0.30787334f, -0.12100639f, 0.08363400f, -0.03305638f, 0.07767764f, 
    -0.23590969f, -0.22739385f, -0.17669751f, -0.09904496f, 0.03009971f, 0.00383913f, -0.05012857f, -0.13849379f, 
    0.02042099f, -0.12767525f, -0.14723560f, 0.20190084f, 0.28239793f, 0.13272032f, 0.40745905f, 0.09396397f, 
    0.03352488f, 0.16451395f, 0.04847741f, 0.04629938f, -0.02229980f, 0.05505807f, 0.07865120f, -0.01324881f, 
    -0.50531089f, -0.45099214f, -0.12709823f, 0.14929789f, 0.06206955f, 0.14600036f, 0.05396192f, -0.20941100f, 
    0.13911267f, -0.06525104f, -0.01977087f, 0.30560768f, -0.19840120f, 0.22192901f, 0.03690650f, -0.03836390f, 
    0.01250044f, 0.08823103f, 0.03605129f, -0.00374611f, 0.09091017f, 0.05335528f, 0.20055491f, -0.04051413f, 
    0.01731965f, 0.22806184f, -0.33748418f, -0.25721321f, 0.09750497f, -0.10856747f, -0.03246544f, 0.01124775f, 
    0.06669349f, -0.05189919f, -0.03145602f, 0.07576149f, 0.17147660f, -0.14772940f, 0.11056311f, -0.02941963f, 
    0.08812651f, 0.18009934f, 0.00237501f, 0.14376637f, 0.00829844f, 0.01754529f, -0.02869906f, 0.06241758f, 
    0.31735721f, 0.38050416f, 0.11957361f, 0.00437908f, -0.37222734f, -0.25060937f, 0.14481610f, -0.12269060f, 
    -0.04058947f, -0.05849470f, 0.02144653f, 0.03546397f, 0.81652993f, -0.17390402f, -0.03836561f, -0.07875777f, 
    -0.03316078f, -0.18749119f, 0.15197557f, -0.06430472f, -0.09604769f, 0.22458804f, 0.06573103f, 0.00191310f, 
    0.13723613f, -0.00355967f, 0.05027009f, -0.04035822f, 0.03538739f, -0.02298741f, 0.01489961f, -0.02354893f, 
    0.11527804f, -0.00901488f, 0.15226635f, 0.25324604f, -0.05629385f, 0.12422655f, 0.08992644f, -0.02656116f, 
    0.03279843f, -0.08745310f, 0.19064862f, -0.06339929f, -0.14954501f, 0.03746749f, -0.07737550f, -0.01671627f, 
    -0.25912583f, -0.02231358f, -0.06824814f, -0.03673222f, -0.00536829f, -0.12323198f, 0.02625292f, 0.03176947f, 
    -0.08930401f, 0.03247142f, -0.02173617f, 0.03619628f, -0.15504904f, 0.47549933f, 0.26924020f, 0.12361000f, 
    -0.06542365f, -0.14816161f, -0.02308016f, 0.11043648f, 0.02680811f, 0.02859159f, -0.21602485f, -0.11486059f, 
    0.26059505f, -0.08941014f, 0.06398751f, -0.11846446f, -0.06733242f, 0.00693085f, 0.05270045f, -0.11716086f, 
    -0.10111035f, -0.03853003f, -0.05974849f, -0.08926130f, 0.69785643f, -0.21010382f, 0.25234419f, 0.17276388f, 
    -0.09837285f, 0.04856578f, -0.10305646f, 0.13527729f, 0.04335068f, -0.18838769f, -0.15994933f, 0.09371614f, 
    -0.21493347f, 0.46444958f, 0.44607204f, 0.05747035f, 0.11494409f, 0.05137883f, -0.03161936f, 0.02430764f, 
    0.02474628f, -0.01873424f, 0.05398043f, -0.07601478f, 0.17990880f, -0.24978957f, 0.21462713f, -0.32474741f, 
    0.03691098f, 0.10502645f, -0.01467344f, -0.03253626f, 0.16306192f, -0.21357764f, -0.02050245f, 0.12223548f, 
    0.26137301f, -0.23203184f, 0.10527220f, 0.20354648f, -0.08721022f, 0.01587609f, -0.05957205f, 0.02916261f, 
    -0.05358113f, -0.06088483f, -0.10032398f, 0.17590457f, 0.00807092f, -0.20659034f, 0.13415489f, -0.37255454f, 
    0.20025755f, -0.08174533f, -0.08306269f, 0.01394382f, 0.10948531f, -0.13657501f, -0.00611191f, -0.10557324f, 
    0.10676429f, 0.51976919f, 0.77153623f, 0.07670804f, -0.19224985f, 0.11978217f, 0.07737549f, 0.31890863f, 
    0.17401473f, 0.18158542f, 0.23070340f, 0.20971100f, -0.11374341f, -0.51183408f, 0.00777985f, 0.06066547f, 
    0.07756115f, 0.14630011f, -0.02714166f, -0.06247165f, 0.06550905f, -0.00867333f, 0.00231214f, 0.08472737f, 
    0.35028639f, -0.66894460f, 0.39359617f, -0.23243700f, 0.21808620f, 0.16771287f, 0.21754281f, -0.07474182f, 
    -0.12095495f, 0.15926887f, -0.11378091f, 0.02483135f, -0.01253241f, 0.09896244f, 0.16211079f, 0.13103555f, 
    0.24859023f, 0.05128102f, 0.13582467f, 0.04517021f, -0.05581493f, -0.10882033f, 0.23111205f, 0.04459670f, 
    -0.43771890f, 0.39681762f, 0.42637134f, 0.10836454f, -0.06327274f, 0.01496654f, 0.08441307f, 0.21525489f, 
    -0.03006431f, 0.07249233f, -0.18654868f, -0.11459630f, -0.16863675f, 0.33022875f, 0.16627805f, 0.11391690f, 
    -0.13321555f, 0.11617403f, -0.05523928f, 0.11895987f, -0.01737131f, 0.09883612f, 0.08492528f, 0.05751353f, 
    0.01101749f, -0.03653077f, -0.08835122f, -0.39329818f, -0.15818530f, -0.13711900f, -0.14919829f, 0.06178402f, 
    0.01244317f, -0.17597497f, 0.12837872f, 0.07798018f, 0.05192250f, -0.18975572f, 0.03397972f, -0.08782146f, 
    -0.11540411f, 0.01246911f, 0.07837282f, -0.02491135f, -0.02763066f, -0.06353942f, 0.02027721f, -0.00888397f, 
    -0.00290160f, 0.05221386f, -0.67112672f, 0.46282220f, -0.07760763f, 0.13341835f, 0.04302710f, 0.38588506f, 
    0.09514853f, -0.01220109f, 0.03413558f, 0.00290859f, 0.30640197f, -0.49295738f, 0.00043197f, 0.33232599f, 
    0.02730560f, -0.18482880f, -0.01731610f, -0.04107817f, -0.11462600f, 0.05874459f, 0.17347302f, -0.00359593f, 
    -0.13588883f, 0.23943642f, 0.12747997f, -0.24862973f, -0.17541774f, -0.13595699f, -0.04835369f, -0.04049132f, 
    -0.15026872f, 0.05218292f, 0.03947695f, 0.02054442f, -0.57514769f, 0.40189776f, -0.17443636f, 0.28439927f, 
    0.04661553f, 0.11463911f, -0.02638055f, -0.11633977f, 0.14020197f, 0.07265753f, 0.26135612f, 0.11576346f, 
    -0.06151671f, -0.43087882f, -0.19820195f, 0.08257620f, -0.27095613f, -0.26618597f, -0.07422459f, -0.05035237f, 
    0.01501699f, 0.16497865f, 0.01620911f, 0.05692084f, -0.46013641f, 0.15208070f, -0.30608186f, 0.55088210f, 
    0.03266210f, 0.18788676f, -0.11788544f, -0.04782218f, 0.06509152f, -0.03602774f, 0.05890908f, -0.02914126f, 
    -0.15148717f, 0.29792187f, -0.24520305f, -0.24549863f, -0.12883742f, -0.19688191f, -0.22807072f, 0.05854666f, 
    0.09612616f, 0.09818792f, 0.06197426f, 0.17098384f, -0.48925015f, 0.09838199f, -0.16759019f, 0.48145822f, 
    -0.06879381f, 0.28158429f, 0.08377030f, -0.15631333f, -0.00812415f, -0.01593004f, -0.00630622f, 0.09917887f, 
    -0.30004206f, 0.54903048f, 0.08195534f, 0.12194220f, -0.15472277f, 0.21454276f, -0.11239444f, 0.14322267f, 
    -0.05476806f, 0.26650965f, 0.19157769f, 0.07843588f, -0.35415539f, 0.01267038f, 0.06478822f, 0.23556168f, 
    -0.04331244f, 0.08929525f, -0.04317249f, 0.02379422f, 0.07953754f, 0.13067272f, -0.06421089f, 0.05800281f, 
    -0.16139516f, -0.07873038f, 0.15392426f, 0.23902322f, 0.10431892f, 0.02399158f, 0.06371207f, -0.19669421f, 
    0.00984102f, -0.15572384f, -0.09770187f, 0.03431145f, 0.20809755f, 0.12620319f, 0.07793143f, -0.04809750f, 
    -0.16190299f, -0.23337366f, 0.13592814f, 0.01245399f, -0.12455243f, 0.13732201f, -0.02369694f, 0.03078079f, 
    0.14379168f, 0.19884877f, 0.59289181f, 0.18642357f, -0.11670107f, -0.19202998f, 0.06788985f, 0.28535122f, 
    -0.01162320f, 0.02390828f, 0.01195838f, 0.06390236f, 0.09934290f, 0.37236774f, 0.06129912f, -0.26765817f, 
    0.03470563f, 0.09576717f, -0.12760717f, 0.10756574f, -0.02376611f, 0.18205096f, 0.26429319f, -0.03509002f, 
    0.14850168f, 0.02693943f, -0.13457821f, -0.20287253f, -0.11400948f, -0.17490268f, 0.11070538f, 0.06579319f, 
    0.12254762f, 0.11475204f, -0.00855877f, 0.03632715f, -0.16935101f, 0.01759430f, -0.16196339f, -0.00771165f, 
    -0.16259386f, -0.12476329f, -0.21642350f, 0.09420038f, -0.06424176f, -0.05244464f, -0.05568014f, -0.12701568f, 
    -0.45675924f, -0.31134129f, -0.00751357f, 0.49898681f, -0.00598475f, 0.20499843f, 0.03453080f, 0.38826516f, 
    -0.11010065f, -0.00160631f, 0.06546719f, -0.03133761f, -0.33869413f, -0.27296531f, 0.06414656f, 0.24317840f, 
    -0.14115813f, -0.13080581f, -0.12374655f, 0.01295771f, -0.02772784f, -0.05379687f, 0.09834673f, 0.05579989f, 
    -0.00337526f, 0.12935323f, -0.00351502f, -0.45122993f, -0.15018190f, -0.18381593f, 0.00420301f, 0.08704228f, 
    0.02563937f, 0.02356726f, -0.02189640f, -0.09000948f, -0.43450996f, -0.22895288f, -0.14020377f, -0.06837918f, 
    -0.04972241f, 0.04289846f, 0.03137247f, -0.00721799f, 0.06880385f, 0.11339714f, 0.15908261f, -0.06991497f, 
    -0.31229132f, -0.02134878f, 0.10221078f, 0.18731937f, -0.06445504f, -0.12896152f, 0.14267245f, 0.03199467f, 
    0.12905256f, 0.04547937f, -0.09083070f, 0.11508069f, -0.53347462f, 0.19205315f, 0.38651398f, -0.07292480f, 
    0.01783817f, 0.11867055f, 0.01816246f, 0.24790263f, -0.05512463f, -0.00251398f, 0.10795094f, -0.05679922f, 
    -0.13127051f, -0.03438057f, 0.04496543f, -0.21922040f, 0.00711754f, -0.00294246f, -0.07665323f, 0.02681998f, 
    0.16193946f, -0.11859894f, -0.02933346f, 0.14197402f, -0.35447496f, 0.00031634f, 0.31073400f, 0.63274145f, 
    0.12060663f, 0.17303497f, 0.09477182f, 0.02853339f, -0.02526497f, 0.04918969f, 0.02777969f, 0.02506752f, 
    0.58832711f, 0.05813540f, 0.19427726f, -0.41964334f, -0.23296304f, -0.07290155f, 0.25389960f, -0.13217399f, 
    -0.08491622f, 0.16176093f, -0.26454830f, -0.00572340f, 0.26072875f, 0.15753068f, 0.03154572f, 0.15290171f, 
    -0.03581086f, -0.04950969f, 0.17335252f, 0.05110532f, -0.06131745f, -0.07836907f, -0.23458707f, -0.04038553f, 
    -0.23001476f, -0.16865432f, -0.13912822f, 0.34727076f, 0.01269838f, -0.12348673f, 0.22222075f, 0.04867458f, 
    -0.11869764f, 0.31456068f, 0.01742735f, -0.07606133f, -0.00577604f, 0.02895679f, 0.05916489f, -0.04012940f, 
    -0.15226835f, -0.01138867f, 0.04638233f, -0.08672971f, -0.00989057f, 0.08775318f, -0.06793576f, -0.17047770f, 
    0.00629342f, -0.58692497f, -0.29825312f, -0.18210462f, 0.17064685f, 0.18968253f, 0.01308461f, 0.24514388f, 
    0.24376123f, -0.11640909f, 0.00301512f, 0.07796369f, -0.38687146f, 0.23118246f, 0.06041833f, 0.04057627f, 
    0.05613872f, 0.33310652f, -0.15913393f, -0.01351556f, 0.28213626f, -0.30630520f, 0.09404428f, -0.06560824f, 
    0.03330370f, 0.00547940f, 0.03228123f, 0.15837805f, 0.03100070f, -0.02370291f, 0.00406973f, -0.00840060f, 
    -0.10484746f, 0.15790547f, 0.06243378f, -0.27001926f, 0.01324572f, 0.06570245f, -0.05282714f, 0.09334998f, 
    -0.02387160f, -0.01124749f, -0.31007487f, 0.06472609f, 0.12395833f, -0.00502579f, -0.07582863f, 0.09247615f, 
    0.56170708f, -0.01828209f, 0.77013904f, -0.04525017f, 0.12962590f, 0.30059993f, -0.02187420f, 0.05877339f, 
    0.18054567f, -0.06159550f, 0.06553463f, 0.08154020f, -0.59108716f, -0.05152530f, -0.23695484f, -0.11391788f, 
    -0.02187731f, 0.07981040f, 0.02550140f, 0.05325856f, -0.04832447f, -0.10222870f, 0.14484404f, 0.10258265f, 
    -0.13095227f, 0.04911969f, -0.03214441f, 0.23562269f, 0.13868631f, -0.02895403f, 0.08380000f, -0.06080873f, 
    -0.00609520f, 0.12125831f, 0.09975657f, 0.02081009f, 0.15955578f, -0.44401574f, 0.17171645f, -0.18334310f, 
    0.09469113f, -0.00542194f, 0.02084377f, -0.11098774f, 0.29879785f, -0.10647167f, 0.10194656f, -0.13531837f, 
    -0.01244537f, 0.06892578f, -0.21918499f, -0.12183721f, -0.09519400f, 0.13325089f, 0.11770659f, 0.05163618f, 
    -0.05559020f, -0.17756310f, 0.02362606f, -0.01491228f, -0.03254513f, 0.21904635f, 0.15320757f, -0.40721744f, 
    0.06255352f, -0.09096012f, 0.03234313f, -0.25105748f, -0.14806210f, 0.04390197f, 0.05492375f, 0.04067957f, 
    0.09897512f, -0.12436233f, 0.13990504f, -0.32450977f, 0.03501314f, -0.18065129f, 0.04995504f, 0.04801098f, 
    0.43912712f, -0.17720851f, 0.15480037f, -0.05497957f, 0.47245073f, 0.21042581f, 0.38847840f, 0.00393646f, 
    0.09703271f, 0.38501662f, 0.20614788f, -0.08387553f, -0.00230577f, 0.10653170f, 0.00559335f, 0.00260777f, 
    0.03047385f, -0.04503804f, -0.07055205f, -0.00550884f, -0.05533079f, 0.03143776f, -0.06471666f, -0.03482471f, 
    0.02358667f, -0.00278289f, -0.06816462f, -0.07319133f, -0.03413268f, -0.01462394f, -0.02881579f, -0.08007352f, 
    -0.04287816f, -0.04856082f, 0.02434506f, -0.07365072f, -0.01870264f, -0.05222039f, -0.06185157f, -0.05072679f, 
    0.03172103f, -0.00553773f, 0.03135203f, -0.05684757f, -0.06138878f, 0.02725671f, 0.03258243f, -0.01469751f, 
    -0.06894033f, 0.01876359f, 0.05408142f, 0.02955415f, -0.00534775f, 0.01680917f, -0.01034305f, 0.01314748f, 
    -0.00020486f, 0.04548018f, -0.07185027f, -0.04872515f, 0.02095304f, 0.02889429f, -0.02361171f, 0.01708158f, 
    -0.03580027f, -0.00941722f, -0.06066041f, -0.01314104f, 0.00632576f, 0.01773019f, 0.04229023f, -0.04436578f, 
    0.04475692f, -0.04815409f, -0.01815223f, -0.00489460f, -0.04930576f, -0.07158960f, -0.07249345f, 0.04743048f, 
    -0.02523202f, 0.05879870f, 0.02123193f, -0.00300529f, -0.05948444f, 0.04866624f, 0.05255061f, -0.06006588f, 
    -0.01899197f, 0.02752919f, -0.00774679f, 0.05696198f, -0.00367972f, -0.04764520f, -0.00560480f, -0.01762855f, 
    -0.01459049f, -0.01380702f, -0.00754220f, -0.06830331f, -0.00615834f, 0.05011477f, -0.00316678f, -0.07007576f, 
    -0.01839956f, 0.06529240f, 0.00218068f, -0.01554742f, -0.02468340f, -0.00721472f, -0.03476429f, -0.08585066f, 
    -0.02909524f, 0.05155678f, -0.01011780f, -0.04538475f, 0.06686461f, -0.06099172f, -0.07682258f, 0.06039177f, 
    0.02224730f, 0.01116689f, 0.01060484f, -0.04015208f, 0.03567932f, -0.02344043f, 0.03226579f, -0.01299096f, 
    -0.01879926f, -0.07619903f, -0.04761237f, -0.03179239f, 0.01365273f, -0.03802556f, 0.01986963f, -0.03835016f, 
    -0.04152368f, 0.00106731f, -0.02981024f, -0.03591085f, 0.01415012f, 0.04015487f, -0.03888864f, -0.00489813f, 
    0.00973923f, 0.04986525f, -0.05452460f, 0.00059132f, 0.04251099f, -0.04635476f, 0.00608375f, -0.02049340f, 
    0.03650998f, 0.04303126f, -0.05156882f, -0.05046375f, 0.03446885f, 0.02441427f, -0.02685966f, 0.04412330f, 
    0.02048943f, 0.05060642f, 0.05257480f, -0.05984178f, -0.06292506f, 0.02228618f, -0.06276274f, 0.05250142f, 
    -0.04618883f, -0.07259553f, 0.03425450f, -0.03251162f, 0.01320775f, 0.01220894f, -0.01957120f, -0.06579708f, 
    0.06324672f, 0.02169072f, -0.01366524f, 0.05972672f, 0.05885288f, -0.06803108f, -0.06548554f, -0.06749806f, 
    0.00040152f, 0.05511198f, -0.05952806f, -0.04803541f, 0.05941310f, -0.02509438f, -0.05259196f, -0.04149308f, 
    0.04543689f, -0.02382665f, 0.05116531f, -0.05530864f, -0.01030979f, 0.00344880f, -0.01326624f, 0.00103647f, 
    -0.00473717f, -0.07257938f, -0.04454636f, -0.02144890f, 0.00871453f, -0.06085278f, 0.04397508f, -0.07907393f, 
    -0.06920993f, -0.05846764f, 0.05804561f, -0.01023782f, 0.01407873f, -0.04865991f, -0.04065534f, 0.06587340f, 
    0.06391738f, -0.04589545f, 0.05758944f, 0.05400637f, -0.07694692f, 0.05938331f, -0.04424982f, 0.02323911f, 
    0.03637160f, -0.05954868f, -0.04931057f, 0.04202307f, -0.02516326f, 0.05683618f, 0.01488789f, -0.00988698f, 
    -0.06966683f, 0.02028461f, 0.00790033f, 0.00468794f, 0.02092469f, 0.02717348f, -0.01101781f, 0.02805334f, 
    -0.07599961f, 0.01272546f, -0.07693135f, -0.01696521f, 0.02654797f, 0.00403487f, -0.05559148f, -0.04137234f, 
    0.03495654f, 0.02604928f, 0.00685581f, 0.06312704f, -0.02081436f, 0.04062241f, -0.03992521f, -0.04070587f, 
    0.02339675f, -0.01942473f, -0.02589506f, 0.00434585f, -0.02742451f, -0.00907197f, 0.05561337f, -0.07721714f, 
    -0.06295145f, -0.05240684f, -0.00097690f, -0.02722150f, 0.02909184f, -0.07147522f, -0.06670805f, 0.05352208f, 
    -0.02654672f, -0.01129826f, -0.06359880f, -0.06455772f, 0.04351901f, -0.06908005f, 0.03305199f, -0.03792544f, 
    0.01421174f, -0.06243516f, -0.03771559f, 0.04627192f, 0.01591911f, -0.03535146f, 0.02233621f, 0.01758539f, 
    0.00801114f, -0.03976566f, 0.02462286f, 0.02256653f, 0.01748659f, 0.04859696f, -0.07706793f, -0.04372238f, 
    -0.02428442f, -0.07318459f, 0.02371220f, 0.06604976f, -0.05550478f, 0.04569272f, 0.02529978f, -0.07239651f, 
    -0.00529979f, 0.04295888f, 0.01702644f, -0.06004801f, 0.03999759f, 0.05211788f, -0.00763839f, -0.04996266f, 
    -0.02669632f, 0.02428782f, -0.06439649f, -0.06299561f, -0.01958188f, -0.07270475f, -0.05893841f, 0.00767660f, 
    -0.00482401f, -0.00839270f, 0.03271527f, 0.02372391f, -0.00827798f, 0.00883458f, 0.05872923f, -0.02454179f, 
    0.00412545f, 0.04001325f, -0.06483809f, -0.07032914f, 0.05822830f, 0.04910292f, 0.00486273f, -0.01471439f, 
    0.00099848f, -0.05610459f, 0.00725882f, 0.00185741f, -0.05322656f, -0.07120761f, -0.04169187f, -0.06511220f, 
    0.01236289f, 0.02137982f, -0.03193739f, 0.04898147f, 0.05781263f, -0.00212170f, -0.08397987f, -0.03201015f, 
    0.02396933f, -0.02385524f, -0.05623120f, -0.07886327f, 0.06830674f, 0.01911746f, -0.07352956f, -0.06797376f, 
    -0.03076609f, 0.00131474f, 0.06233109f, 0.01975864f, 0.05651332f, -0.04731405f, 0.06329565f, -0.03674329f, 
    -0.06206732f, -0.02967581f, 0.05016315f, -0.01686537f, 0.05329723f, -0.07348172f, 0.03622320f, -0.01960290f, 
    -0.04725057f, 0.02646606f, 0.04004927f, 0.01561157f, -0.03267168f, -0.04975231f, 0.00083108f, 0.01014976f, 
    0.02871547f, -0.00573564f, -0.02619788f, 0.00818264f, 0.05083103f, 0.00507159f, 0.05128214f, -0.01524685f, 
    0.03921345f, -0.05063505f, 0.04168190f, -0.00143257f, -0.06111350f, 0.00164141f, 0.00031611f, -0.00579843f, 
    -0.16846882f, -0.05648812f, 0.42770571f, 0.19439615f, -0.08506562f, -0.05168896f, -0.15268484f, 0.06706774f, 
    0.13091701f, 0.12327637f, 0.14126413f, -0.02381144f, 0.30541340f, -0.04348436f, 0.27753857f, 0.15010247f, 
    -0.01276193f, -0.03546824f, 0.05595783f, 0.22079685f, 0.05881450f, 0.13070482f, -0.01711075f, 0.03565437f, 
    0.29641631f, 0.51481324f, -0.21721588f, 0.55651093f, 0.23150139f, 0.07329108f, 0.36801162f, -0.03555617f, 
    -0.27050424f, 0.18097316f, -0.17683260f, -0.17071030f, -0.19530247f, 0.03256366f, -0.22641693f, -0.09534924f, 
    -0.19058323f, 0.05370227f, -0.07785263f, -0.17288120f, 0.09851270f, 0.08167113f, -0.14654504f, -0.04792823f, 
    -0.40159541f, 0.06832092f, -0.15206932f, -0.19546598f, 0.03000342f, -0.17936857f, -0.25127631f, 0.12212411f, 
    0.07808495f, 0.10710396f, -0.02538405f, -0.15462558f, -0.23656198f, -0.09667306f, -0.42123324f, -0.14863053f, 
    0.07135922f, 0.37598860f, -0.19260979f, 0.13861331f, 0.00421576f, -0.31377056f, 0.05038017f, 0.07779323f, 
    -0.12012064f, -0.13457164f, 0.10691752f, 0.12825812f, 0.07904441f, 0.21349515f, 0.01902831f, 0.04015189f, 
    -0.17882939f, 0.05818303f, 0.02281086f, -0.08150332f, -0.02448142f, -0.09519541f, -0.04065969f, -0.05167721f, 
    0.07185682f, 0.14277631f, -0.18748762f, 0.29210874f, -0.04210204f, -0.12998423f, -0.11004365f, -0.05966363f, 
    0.37557575f, -0.11188371f, 0.28300473f, -0.10466537f, 0.14130233f, 0.27085632f, 0.09307209f, 0.17047617f, 
    0.01466373f, 0.08911700f, 0.06556945f, 0.03487581f, -0.26866427f, -0.15200651f, -0.04734085f, -0.35597602f, 
    -0.02129602f, -0.03232135f, 0.25130552f, -0.25862026f, 0.12621558f, 0.05709498f, 0.08326017f, 0.07123973f, 
    0.02130299f, -0.21037754f, -0.08262400f, 0.38001454f, -0.07111590f, 0.07781792f, 0.09413989f, 0.03219987f, 
    -0.00235765f, -0.08902135f, -0.03083896f, 0.02508707f, -0.24975380f, -0.05536016f, -0.01874558f, 0.02881993f, 
    -0.05853724f, -0.08371974f, -0.06460916f, 0.11786197f, -0.06685532f, -0.08293539f, -0.01077966f, 0.08241737f, 
    0.16452698f, 0.24358134f, -0.11125000f, -0.05070176f, 0.14478216f, -0.05169553f, 0.05736473f, 0.22203860f, 
    0.06774078f, -0.06311296f, 0.09300369f, -0.13169880f, 0.10659359f, 0.01261361f, 0.16465862f, -0.18990421f, 
    0.05016735f, 0.03641037f, -0.22616455f, 0.18962260f, -0.18012238f, 0.09510124f, -0.11465032f, -0.22408532f, 
    -0.02035281f, -0.20237073f, 0.02530132f, 0.28278798f, 0.01031306f, -0.01284310f, 0.04421354f, -0.17467229f, 
    0.04158410f, -0.04014319f, 0.07215891f, 0.17594661f, 0.44764784f, -0.06532524f, 0.16680758f, 0.25402755f, 
    0.13245335f, 0.30303165f, 0.17181171f, 0.14502129f, -0.05346275f, 0.01884601f, -0.09880371f, -0.09514151f, 
    -0.17544550f, -0.54889941f, -0.31497684f, 0.05198196f, 0.00151075f, 0.00388570f, -0.05749880f, -0.11188008f, 
    0.02180598f, -0.11370219f, -0.14342155f, -0.01942076f, -0.16155538f, 0.44494364f, -0.08720266f, 0.01187046f, 
    -0.03926914f, -0.02698146f, 0.09095939f, 0.21147299f, 0.07280202f, 0.04559841f, -0.05237830f, -0.07748789f, 
    -0.29823735f, 0.33077896f, -0.23589841f, 0.23156787f, 0.15323101f, 0.15872248f, -0.09387419f, 0.14144370f, 
    0.17079189f, -0.00062336f, -0.03599581f, 0.08828086f, -0.14270020f, -0.19900778f, -0.17534797f, 0.03103053f, 
    0.07665420f, 0.02717018f, -0.14455345f, 0.16596179f, -0.09460744f, -0.09822961f, -0.14537770f, -0.07161069f, 
    0.51374221f, 0.06143906f, 0.12448510f, 0.36434433f, 0.10829933f, 0.11868365f, 0.11549882f, 0.02863644f, 
    0.11147885f, 0.05898479f, 0.34847659f, 0.19834684f, 0.02560665f, -0.47626534f, -0.47965017f, -0.33988538f, 
    0.09494136f, -0.01459625f, 0.01262592f, -0.50586128f, 0.00584703f, -0.00546937f, 0.16617818f, 0.00874679f, 
    -0.40281758f, -0.48544154f, -0.31156501f, 0.09482289f, 0.07249593f, 0.05305493f, -0.09325480f, -0.06714889f, 
    0.17909622f, 0.35037696f, 0.11434494f, 0.29948604f, -0.01808005f, -0.09816310f, -0.02405756f, 0.10100465f, 
    0.25411913f, -0.09231801f, 0.23609629f, 0.03184323f, -0.04599222f, 0.00987022f, -0.04536003f, -0.27952635f, 
    0.08731639f, 0.48793402f, 0.76246142f, 0.07482603f, 0.20914407f, 0.09929145f, -0.02493419f, -0.06459703f, 
    -0.00605534f, -0.13935348f, -0.04178054f, -0.03424808f, 0.41966742f, 0.67212349f, 0.25855079f, 0.06902170f, 
    -0.02809824f, -0.02246706f, -0.02151829f, 0.00270964f, 0.06240652f, -0.07455136f, -0.05331274f, 0.06386326f, 
    -0.27225327f, -0.61114258f, -0.23199724f, 0.04920187f, 0.12428798f, 0.07313655f, -0.06879542f, -0.01888942f, 
    -0.05071982f, -0.11718098f, -0.12628666f, 0.04818521f, 0.23179030f, -0.20212412f, 0.19996691f, -0.13657559f, 
    -0.08050510f, -0.15455553f, 0.07673418f, 0.03573396f, 0.00125576f, 0.04250491f, -0.19796336f, -0.08381199f, 
    0.33601683f, 0.46667233f, 0.41450807f, 0.32199800f, 0.31168345f, 0.24412926f, 0.14076152f, -0.01034542f, 
    0.01659496f, -0.01301796f, 0.02853969f, 0.02851195f, 0.58157015f, 0.17570879f, 0.18518366f, -0.26524439f, 
    0.16369338f, 0.03885384f, 0.16892120f, 0.04136669f, 0.22862546f, 0.03254052f, -0.02656917f, 0.12989418f, 
    -0.14076829f, -0.40781763f, -0.05101062f, 0.06864411f, -0.05264888f, 0.05361942f, -0.04880829f, 0.01390675f, 
    0.11315938f, -0.01807242f, 0.19196312f, 0.10893324f, 0.31815085f, 0.22651520f, 0.25708604f, -0.14593972f, 
    0.14814636f, -0.11074874f, 0.08536557f, 0.16411103f, 0.13814792f, 0.00896783f, -0.09674213f, -0.08807419f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01392665f, 0.15923387f, -0.05756404f, 0.00325450f, -0.07548238f, 0.22099860f, -0.15869036f, 0.17757450f, 
    -0.05788396f, 0.24671729f, 0.37150744f, 0.04052652f, 0.04438249f, 0.18438798f, 0.24260278f, -0.00804592f, 
    0.04799484f, 0.35743362f, -0.05443117f, -0.04880635f, 0.25047722f, -0.04468789f, 0.03810869f, -0.03900841f, 
    0.15601642f, 0.17547955f, 0.25843287f, 0.00910601f, -0.00709802f, -0.03540013f, -0.07373040f, 0.04891720f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12922727f, -0.70439190f, 0.00540786f, 0.04607176f, -0.81902826f, -0.73729986f, 0.39536259f, 0.12725030f, 
    -0.11857387f, -0.26274389f, -0.19855049f, 0.07802784f, 0.49114341f, -0.03594285f, 0.07110362f, 0.24613141f, 
    -0.42382178f, -0.00746021f, 0.01755852f, -0.00473296f, -0.74302888f, -0.14854509f, 0.15657796f, 0.17736350f, 
    -0.35175529f, -0.53348446f, -1.21564829f, 0.22707511f, -0.17555371f, -0.10524186f, 0.07016311f, 0.24563254f, 
    -0.06602347f, -0.01971103f, 0.12639818f, -0.17537229f, 0.29803866f, -0.05260196f, -0.84494984f, 0.20800456f, 
    0.15918399f, 0.38800171f, 0.22046007f, -0.10875159f, -0.03783171f, -0.13236567f, 0.41307995f, 0.30954283f, 
    -0.13160905f, 0.04399685f, 0.08674604f, 0.10874341f, -0.32243535f, -0.45634192f, -0.04711175f, -0.03173953f, 
    0.40763196f, -0.39678279f, -0.52580410f, -0.17763895f, -0.08125496f, 0.02077921f, -0.42448145f, 0.22030731f, 
    0.08468635f, -0.00922225f, -0.16386409f, 0.13890657f, -1.08450854f, 0.38413575f, 0.27357036f, 0.16528995f, 
    0.04563349f, -0.31035683f, 0.35408488f, 0.14713985f, 0.35876641f, 0.08942463f, 0.16885751f, -0.45190793f, 
    -0.26727748f, 0.04335754f, 0.12597722f, -0.04412320f, -0.08127079f, -0.37501606f, 0.13010426f, -0.33411521f, 
    0.17243946f, 0.07048874f, 0.55216372f, -0.28957352f, -0.17571545f, -0.02910099f, -0.72545755f, 0.01503132f, 
    0.08339773f, 0.15912910f, 0.14203873f, 0.13644265f, -0.07124348f, 0.33838525f, 0.11940423f, -0.02225377f, 
    -0.10347872f, -0.25278172f, -0.29479194f, 0.07209535f, -0.79188299f, -0.89346844f, -0.00567893f, 0.33841908f, 
    0.21309802f, -0.77525824f, -0.07388690f, 0.15158340f, -0.37556306f, 0.27559200f, 0.34663391f, -0.06156399f, 
    -0.99526519f, 0.20132639f, 0.03582048f, -0.23475288f, 0.10067225f, 0.11955786f, -0.16018245f, 0.22768235f, 
    -0.09726989f, -0.17402440f, -0.05543062f, -0.07309034f, 0.28866279f, -0.39334941f, 0.29105768f, 0.01670107f, 
    -0.03265732f, -0.52905416f, -0.20640177f, -0.03538195f, -0.37821713f, -0.00372125f, -0.51462305f, -0.43992102f, 
    -0.18812479f, -0.51975673f, -0.11951064f, -0.00431911f, -0.26091293f, 0.44396588f, 0.28798577f, 0.20068903f, 
    0.38577214f, -0.18581873f, 0.16882943f, 0.16645518f, -0.10743427f, 0.04380051f, 0.20440000f, 0.18698311f, 
    -0.05932664f, -0.07104214f, -0.02542056f, -0.04320934f, 0.10306384f, -0.07608986f, -0.34836885f, -0.06880571f, 
    -0.07012429f, 0.38036802f, 0.24836282f, -0.16449539f, 0.36849606f, -0.19764535f, -0.02436636f, -0.27036682f, 
    -0.06850666f, -0.50941670f, 0.13065507f, -0.00147533f, 0.49173936f, 0.06953396f, -0.37271157f, 0.11788704f, 
    -0.39271435f, -0.63749933f, -0.10903374f, 0.41887057f, -0.17408700f, 0.01771277f, 0.51775354f, 0.17699708f, 
    -0.12473122f, 0.08081897f, -0.00947512f, 0.03072897f, -0.14597112f, 0.13516934f, -0.19000459f, -0.12082808f, 
    0.16300353f, -0.19041575f, -0.43886670f, -0.02151458f, -0.43023568f, 0.28483596f, -0.28731090f, -0.20771396f, 
    -0.61159545f, 0.53110218f, -0.14897040f, -0.17552653f, 0.44153857f, -0.00046515f, 0.08308817f, -0.99603766f, 
    -0.00113643f, 0.63305020f, 0.19159375f, -0.13080707f, 0.01188335f, 0.16554490f, -0.24353978f, -0.69849122f, 
    0.12138864f, 0.03927612f, -0.10359045f, -0.14899291f, 0.36719573f, 0.05148139f, 0.46899948f, -0.33917114f, 
    -0.05902167f, 0.18494342f, -0.14820769f, -0.03558373f, -0.22928233f, 0.08569632f, -0.59462708f, -0.15489972f, 
    0.25333223f, -0.40059736f, -0.01615385f, 0.12374473f, 0.08032613f, -0.67797530f, 0.15431181f, -0.45633498f, 
    -0.05488693f, -0.71042281f, 0.48895895f, 0.38901845f, -0.03306275f, -0.01344336f, -0.51269233f, -0.32477570f, 
    0.03255772f, 0.39772940f, -0.15410574f, 0.06843610f, -0.47758612f, 0.08738817f, -0.19028488f, 0.00231444f, 
    -0.03211810f, -0.24741167f, 0.20508690f, 0.11741131f, -0.13056085f, -0.62452048f, 0.07214215f, 0.44814086f, 
    0.56271875f, -0.21830562f, -0.13537270f, 0.04686324f, 0.27249545f, -0.68404663f, -0.72844976f, -0.36085600f, 
    -0.55830294f, 0.15961431f, -0.64078027f, 0.26337317f, -0.07855533f, -0.02647702f, 0.02895954f, -0.46316704f, 
    -0.16136675f, 0.09867903f, -0.11353071f, 0.05127891f, 0.02676438f, -0.33127993f, 0.20720705f, -0.78375649f, 
    0.01054742f, -0.32881349f, 0.21575001f, 0.00133187f, 0.23463719f, 0.49531493f, -0.39926365f, -0.16753413f, 
    0.01868217f, 0.39140192f, -0.05802478f, -0.16287448f, 0.20138469f, 0.23496719f, -0.13949065f, -0.15783741f, 
    0.43714693f, -0.59284455f, -0.08792637f, -0.76306009f, 0.15985346f, -0.16698238f, 0.18715872f, 0.16726783f, 
    -0.04998947f, -0.36240590f, 0.02465203f, 0.04482214f, -0.27203950f, -0.53802526f, -0.96589214f, -0.07381638f, 
    -0.00825837f, 0.16585001f, 0.02298946f, 0.11025107f, -0.41091406f, 0.05516534f, 0.38885024f, 0.00454446f, 
    0.14535177f, -0.39340180f, -0.10562508f, -0.10822467f, 0.15117352f, -0.13057904f, 0.21041028f, 0.21645008f, 
    -0.88574666f, 0.77836788f, 0.60514212f, -0.24993433f, -0.10542021f, -0.08099812f, 0.15270838f, -0.46106344f, 
    -0.00537163f, 0.25034481f, -0.12147748f, -0.01656768f, -0.03859667f, 0.38731098f, 0.29680926f, -0.07032577f, 
    0.07959087f, 0.08244050f, -1.04545295f, -0.16010828f, 0.55235898f, 0.12632558f, 0.39997864f, 0.09938179f, 
    0.00939863f, -0.15387231f, -0.06076205f, 0.15191860f, -0.31887251f, 0.34991461f, -0.87386000f, 0.02458557f, 
    -0.40136582f, 0.36026695f, 0.11528515f, -0.41647261f, -0.10651235f, 0.11353343f, 0.17553271f, -0.46850654f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18282074f, 0.00395956f, 0.34567291f, -0.14958480f, -0.10688595f, 0.02953408f, -0.03720621f, -0.23903424f, 
    0.03507438f, 0.00513121f, -0.10091929f, -0.20117778f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
