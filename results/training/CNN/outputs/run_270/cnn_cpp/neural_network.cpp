#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.91736782f, -0.51901811f, -0.35345981f, -0.37919024f, -0.69130147f, 0.27746165f, 0.37005010f, -0.25485957f, 
    0.00634400f, 0.34118351f, 0.37337446f, -0.22448075f, -0.52703387f, 0.44856545f, 0.58256322f, -0.28373158f, 
    -0.06246212f, -0.35492507f, 0.09624179f, 0.26025400f, 0.16407590f, 0.28544793f, 0.18562664f, 0.35594344f, 
    0.31101483f, -0.20859890f, -0.53276235f, -0.36455122f, -0.33965099f, 0.30777588f, -0.06635899f, -0.55409700f, 
    -0.87826324f, -0.70406181f, -0.49731874f, 0.48487580f, 0.61246610f, 0.40609282f, 0.35928151f, -0.00078481f, 
    0.33781016f, -0.53443140f, -0.34740740f, -0.06846204f, 0.16329567f, -0.25136343f, 0.40083870f, 0.19906525f, 
    -0.03247448f, 0.21705063f, 1.00011837f, 0.86994702f, 0.66139418f, 0.52457607f, 0.59496713f, -0.18347546f, 
    0.14244914f, -0.31528613f, 0.13470198f, 0.45018578f, 0.26954570f, 0.58206403f, 0.27824605f, 0.07798911f, 
    -0.34034562f, 0.61946219f, 0.09416592f, 0.32663503f, 0.31865609f, -0.06307092f, 0.40893957f, -0.26754272f, 
    -0.34554309f, 0.03006976f, 0.60231614f, 0.31323487f, 0.52636248f, 0.51307589f, 0.65148252f, -0.16499543f, 
    0.35168570f, 0.27410507f, -0.39359218f, 0.09573039f, 0.65174484f, 0.55382735f, -0.56709296f, 0.23046279f, 
    -0.27603608f, -0.42491615f, -0.02621554f, -0.25619209f, -0.15134966f, -0.25457624f, -0.01978401f, -0.39759514f, 
    -0.32966858f, 0.20299391f, -0.50111592f, -0.48418897f, -0.01672868f, 0.22105187f, 0.80382699f, 0.71081829f, 
    0.35760385f, -0.89420182f, -0.20133919f, -0.72265029f, -0.09688521f, 0.31559339f, 0.29095405f, 0.47039810f, 
    -0.28171659f, 0.17252249f, 0.04794694f, 0.13850439f, 0.16347823f, -0.36996022f, 0.03329679f, -0.00400392f, 
    -0.31366327f, 0.66730708f, 0.09675170f, -0.20031482f, -0.03046376f, -0.15082900f, 0.74651939f, 0.29827711f, 
    0.37992579f, -1.16577506f, -0.05330405f, -0.35870370f, -0.64578623f, -0.57001585f, 0.28119600f, 0.25573981f, 
    0.08739821f, -0.70482004f, 0.30081460f, -0.03125349f, 0.07368110f, 0.51155096f, 0.34428945f, -0.06171444f, 
    -0.17013125f, -0.06910101f, -0.17724837f, -0.48036984f, 0.22974546f, -0.16375238f, -0.00276873f, -0.85926515f, 
    0.24796228f, 1.05886459f, -0.12265445f, -1.29051924f, 0.44411147f, 0.13971414f, -1.16001809f, -0.43896434f, 
    0.27650028f, 0.58059895f, -0.11270565f, 0.04138095f, 0.39470726f, 0.04930951f, 0.26541007f, 0.26528308f, 
    -0.09951907f, -0.05021780f, 0.22241053f, 0.14074472f, 0.03456863f, 0.21732768f, -0.13179621f, 1.14343464f, 
    -0.71624756f, -0.22031966f, 0.42574304f, 0.59428948f, 0.86582321f, 0.69288629f, 0.24593401f, 0.78774351f, 
    0.55098289f, -0.56791836f, 0.24562600f, -0.49481881f, 0.38505384f, 0.09381800f, -0.02021318f, -0.30418220f, 
    -0.11922690f, 0.03035000f, 0.14792119f, 0.10138690f, -0.13538080f, 0.06782416f, -0.20076646f, -0.16385421f, 
    1.19907832f, -0.13665384f, 1.00635171f, -0.07409938f, -0.29996824f, 0.96177274f, -0.63331819f, 0.06923666f, 
    0.31290239f, 0.59556961f, 0.32369429f, 0.08211458f, -0.29697910f, 0.43502143f, -0.20306349f, 0.34235138f, 
    0.13849033f, 0.04727072f, -0.20287265f, 0.12932266f, 0.29634023f, 0.42573223f, 0.32989219f, -0.15453145f, 
    0.37231529f, 1.00758517f, 0.54359472f, 0.93152839f, 0.56689686f, -0.05481244f, -0.37850636f, -0.39382473f, 
    -0.78956538f, -0.27444997f, -0.60731918f, -0.25633264f, 0.06165828f, -0.01871550f, -0.02457300f, -0.55270082f, 
    0.18507040f, 0.15365133f, 0.15481463f, -0.09350201f, 0.01664540f, -0.39888322f, 0.11729411f, -0.23897713f, 
    -0.21521670f, -0.14451706f, 0.77469844f, 0.44024408f, 0.35960895f, 0.37816054f, -0.71422499f, -0.57914335f, 
    1.08364451f, -0.83999509f, -0.45816022f, 0.29738677f, 0.55565041f, 0.19612844f, -0.27032819f, 0.09836635f, 
    -0.01674241f, -0.48806453f, -0.38117862f, 0.20848256f, 0.45164043f, -0.14380074f, 0.14994256f, -0.06189896f, 
    0.43692067f, 0.25467724f, 0.28500906f, -0.69717830f, -0.00031216f, -0.57596546f, -0.47325823f, 0.06404493f, 
    -1.26152980f, 0.30004814f, 0.57776845f, -0.05909921f, -0.61862987f, -0.46622863f, -0.47021210f, 0.17693263f, 
    -0.74224913f, -0.58052772f, 0.13098449f, 0.11009815f, -0.30132276f, 0.11805903f, -0.39314359f, -0.10060129f, 
    -0.34579334f, 0.08761211f, 0.11496475f, 0.19369866f, 1.15768027f, 0.34790799f, 0.65035820f, 0.66181308f, 
    0.96147013f, 0.55094695f, 0.51995945f, 0.36060187f, -0.64697552f, -0.43756512f, -0.12665263f, -0.12149396f, 
    -0.13257915f, 0.02782819f, -0.24781832f, -0.02195569f, -0.13416253f, 0.09155591f, -0.14381306f, 0.01754551f, 
    -0.01611246f, 0.45932308f, 0.19986430f, 0.12664467f, 0.17637038f, -0.28878304f, 0.04487584f, 0.05757210f, 
    0.79990441f, -0.08711440f, -0.29097158f, -0.36854199f, 0.81533372f, 0.21220376f, 0.36473495f, -0.03219079f, 
    -0.26088473f, 0.05971774f, -0.01964602f, -0.32073772f, 0.46062893f, 0.49011165f, -0.65123183f, -0.20814657f, 
    0.13602741f, -0.17468362f, 0.09585557f, 0.50598371f, 0.46924531f, 0.29275253f, -0.80288917f, -0.03985922f, 
    0.20755160f, -0.71958059f, -0.46440357f, -0.08622207f, -0.72717971f, 0.30591479f, 0.15525353f, -0.22373916f, 
    0.50261974f, 0.83455169f, -0.28784946f, -0.05121773f, 0.37265712f, 0.09058540f, 0.22203517f, -0.40412670f, 
    0.20176493f, 0.41449195f, 0.68412447f, 0.01019672f, 0.32622343f, -0.03275393f, 0.15208612f, -0.98791218f, 
    0.39503494f, -0.01411030f, -0.69740403f, -0.39591357f, 1.10393882f, 0.78349024f, 0.11794070f, 0.70626479f, 
    0.81347007f, 0.05696565f, -0.30749726f, 0.05279336f, -0.38962200f, -0.52424270f, 0.20894547f, -0.25459313f, 
    -0.06523740f, -0.24189812f, 0.23096301f, -0.17515196f, -0.25527069f, -0.16971037f, -0.07369886f, 0.04102965f, 
    -1.31695390f, 0.67612064f, -0.13251886f, -0.57916981f, 0.30673683f, -0.34136963f, 1.17821753f, 0.29031304f, 
    0.21630305f, 0.44452885f, -0.66054720f, 0.21691719f, 0.51056737f, -0.35941160f, 0.17538102f, 0.36401504f, 
    -0.19515012f, 0.20876370f, 0.38712078f, -0.45871550f, -0.06386940f, 0.19436628f, -0.34864733f, -0.37433249f, 
    0.13826481f, 0.70457017f, -0.75314450f, -0.81038690f, -0.87502748f, -0.09361965f, 0.05617317f, -0.13843484f, 
    -0.47207698f, -0.26529428f, 0.09124096f, 0.05564015f, -0.28710675f, 0.42424971f, -0.04189220f, -0.41435021f, 
    -0.34746256f, 0.32240772f, -0.02277700f, -0.29005212f, -0.30395129f, 0.04307991f, 0.00324768f, 0.45749903f, 
    0.49515766f, -0.07824600f, -0.20483713f, -0.98900414f, 0.39743170f, 0.88411289f, 0.22712788f, 0.06109340f, 
    0.67357671f, 0.80522835f, -0.75468379f, 0.51964790f, 0.38100246f, -0.15274282f, 0.12114560f, -0.06576481f, 
    -0.28146806f, -0.56992680f, -0.25782245f, -0.62315458f, 0.18554123f, -0.55097777f, -0.35184202f, 0.19842087f, 
    0.13621531f, 0.12851402f, -0.03933992f, -0.81584334f, -1.44869113f, -0.46770996f, 0.35517558f, 0.62464970f, 
    0.00397098f, 0.97351873f, 0.14801557f, 0.57839274f, 0.01532596f, -0.10196377f, -0.41167358f, -0.28272966f, 
    0.64567167f, 0.35482818f, 0.33619225f, 0.09409257f, -0.17116004f, 0.02963358f, 0.07898618f, 0.06535396f, 
    -0.00799222f, -0.05961528f, 0.21726987f, -0.09780716f, 1.22780514f, 1.04261196f, 0.57534885f, 0.76714104f, 
    1.06394315f, -0.43361884f, -0.45115316f, -0.40897289f, 0.21636423f, -0.48130587f, 0.14213423f, -0.14570764f, 
    -0.14282002f, 0.14398630f, 0.10320857f, -0.18169662f, 0.08145844f, 0.10045169f, 0.06084269f, 0.27177259f, 
    -0.29734406f, -0.04354202f, 0.15777652f, 0.29906291f, 0.23514223f, -0.90675360f, -1.37235606f, -0.63953066f, 
    -0.20077643f, 0.50429946f, 0.32665101f, 0.79076993f, 0.39784843f, -0.15963387f, 0.41404796f, -0.07512230f, 
    0.09964575f, -0.17668609f, -0.28861421f, -0.36199141f, 0.03970231f, -0.16345775f, 0.09961250f, -0.19089806f, 
    -0.12339985f, -0.23655061f, 0.03125240f, -0.06650205f, 0.02028956f, -0.21250384f, -0.75202751f, 0.89417773f, 
    -0.52289164f, 0.73271978f, 0.42837432f, -1.23436415f, -0.05225866f, -0.40814558f, -0.17802924f, -0.39962459f, 
    0.12697066f, -0.15917081f, 0.08068243f, 0.15052554f, -0.03045384f, -0.08169501f, -0.00261867f, -0.04128074f, 
    -0.02055417f, 0.03695425f, -0.10353583f, -0.11515443f, 0.16777605f, -0.00148945f, -0.07052840f, -0.06348682f, 
    -0.39443687f, 0.59491676f, 0.46373037f, -0.06729707f, 0.02711518f, -1.19866061f, -0.11077639f, -0.17873991f, 
    -0.07997491f, 0.61916137f, -0.07967049f, -0.52814078f, -0.47832546f, -0.23658565f, 0.31492049f, 0.24680519f, 
    -0.27178988f, -0.14193161f, 0.41030344f, -0.02370434f, 0.11144229f, 0.45019442f, 0.48118317f, 0.22875428f, 
    -0.16281278f, 0.81428087f, -0.34644297f, -1.13831341f, 0.35424265f, 0.95125180f, -0.86346650f, -0.02675861f, 
    -0.92420435f, -0.74441344f, -0.02254292f, 0.50909686f, 0.34298205f, 0.09086107f, -0.15414380f, 0.21483822f, 
    -0.43442225f, -0.09909742f, -0.12859271f, 0.12888238f, -0.07041713f, -0.45014471f, 0.31915393f, -0.01673332f, 
    -0.15051183f, 0.80976504f, -0.82415295f, -0.24295376f, -1.04502845f, -0.26232120f, 0.54923725f, -0.50427717f, 
    0.37020198f, 0.23275606f, -0.11515650f, -0.04996236f, 0.49041581f, -0.34103051f, 0.29154408f, 0.02681858f, 
    0.01756132f, 0.16343579f, 0.34056482f, 0.06882554f, 0.37449679f, -0.31275085f, 0.18344268f, -0.30414352f, 
    -0.38076591f, -0.24782404f, 1.03582752f, 1.09335482f, 0.67751580f, -1.17805004f, -1.08355951f, 0.22358972f, 
    0.12913720f, 0.00909584f, -0.66399020f, 0.18755469f, 0.47638947f, 0.54609829f, -0.15898751f, 0.19000067f, 
    -0.20094933f, 0.02557446f, -0.09878054f, 0.06631604f, 0.05225740f, -0.13711107f, 0.17727043f, 0.22001633f, 
    -0.18117087f, 0.02608811f, 0.08366931f, -0.63966215f, -0.90109384f, -0.56534040f, -0.18373570f, 0.40542302f, 
    -0.26168105f, -0.69512862f, -0.46004298f, -0.51527166f, 0.21360153f, -0.29604763f, 0.24072509f, 0.50240600f, 
    -0.08112826f, 0.42116007f, 0.26074287f, 0.03290329f, 0.29066238f, 0.41743207f, 0.15644312f, 0.25817394f, 
    -0.33710235f, 0.22312282f, -0.01007424f, -0.20994271f, -1.33168435f, -0.79015815f, 0.70443672f, 0.51529491f, 
    -0.41826963f, 0.52317631f, 0.67619383f, 0.01531428f, 0.07044641f, -0.57755029f, -0.42375386f, 0.14444922f, 
    -0.37295479f, 0.06062961f, 0.15174851f, -0.39016992f, 0.03563939f, -0.37166458f, -0.41617262f, -0.47480208f, 
    0.02679102f, 0.06687322f, 0.10775971f, -0.18005827f, -0.00284660f, -0.18946290f, 0.49927109f, 0.41181836f, 
    1.09821343f, 1.15930879f, 1.20373309f, 0.13804360f, -1.26607120f, 0.53576559f, -0.27650726f, -0.45906270f, 
    0.13825826f, -0.37712222f, 0.49717593f, -0.80807537f, -0.31134334f, 0.12734964f, 0.08432326f, -0.41253206f, 
    -0.14037727f, 0.09913880f, -0.06442621f, -0.34418780f, -0.24943134f, 0.21064699f, 0.33438626f, -0.41048768f, 
    -0.84831256f, -0.65069288f, -0.75524318f, -0.18145071f, 0.65245456f, 0.79981697f, 0.78028113f, 0.60189664f, 
    -0.04557405f, 0.32725412f, 0.03730931f, -0.42480621f, -0.06244987f, -0.12356891f, 0.27073708f, 0.14134030f, 
    0.23113902f, -0.05373848f, 0.04175706f, -0.15845774f, 0.25410455f, -0.32961807f, -0.17353244f, -0.71627569f, 
    -1.09177649f, -0.12228493f, -0.46443632f, -0.67622936f, -0.40005776f, 0.12454726f, 0.77565569f, -0.41842899f, 
    0.41399679f, -0.00029989f, -0.39302784f, 0.11050757f, 0.06977934f, -0.37747222f, 0.05886307f, -0.11129766f, 
    0.10937614f, -0.13116144f, -0.07660380f, 0.03149366f, 0.32508120f, -0.16410947f, 0.07955498f, 0.20623791f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20630485f, 0.12595969f, 0.04825864f, 0.01714993f, 0.02832443f, 0.08227054f, 0.06061241f, 0.00047941f, 
    0.09401970f, 0.14530636f, 0.17090708f, 0.13025746f, 0.08764520f, 0.20780605f, 0.40512869f, -0.21009797f, 
    -0.00254320f, 0.29814759f, 0.09767085f, -0.04121051f, 0.21412455f, 0.02125133f, 0.25360799f, 0.37049645f, 
    0.43807524f, 0.18212143f, 0.13700795f, 0.38318381f, 0.19024822f, 0.33446950f, 0.04266848f, 0.10180276f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14929134f, -0.11312758f, -0.02158342f, -0.33597833f, -0.03617075f, 0.16818903f, 0.04064708f, 0.11276176f, 
    0.07495708f, -0.07260375f, 0.04108260f, 0.21448982f, -0.19191745f, -0.62020928f, 0.11703549f, 0.08805691f, 
    -0.13993843f, 0.06124576f, 0.07149382f, -0.05559545f, -0.10426104f, -0.02391593f, 0.08622210f, -0.06859120f, 
    0.01848529f, -0.07711960f, 0.00027228f, -0.04494909f, -0.12819415f, -0.07875524f, 0.11605275f, 0.04165794f, 
    0.07604411f, 0.16839811f, -0.03235955f, -0.07805054f, 0.14913943f, 0.18259341f, -0.16779168f, 0.25796106f, 
    -0.22115812f, 0.14863925f, -0.01110704f, 0.07166033f, 0.03581512f, 0.10678434f, 0.03949343f, -0.03212596f, 
    0.06842843f, -0.20934847f, -0.32152906f, 0.29786816f, 0.00826565f, -0.06154755f, 0.06236658f, 0.01288845f, 
    -0.16638085f, 0.19611265f, -0.01641953f, 0.06438585f, -0.26682073f, 0.11883634f, -0.24079382f, 0.03683631f, 
    -0.22286655f, 0.03012659f, 0.19808152f, -0.11117273f, 0.09640968f, 0.18279211f, 0.09538672f, -0.01549554f, 
    -0.02205617f, -0.05003205f, -0.14778058f, 0.44832280f, -0.02258048f, 0.02588153f, -0.10592076f, -0.08535384f, 
    0.04881038f, -0.00529129f, 0.05114079f, -0.02482737f, 0.17821115f, -0.01587664f, 0.02907374f, 0.32847875f, 
    -0.02005374f, -0.01885223f, -0.08119839f, 0.13013718f, 0.01359906f, 0.04389508f, 0.21956970f, -0.07078715f, 
    0.22163077f, -0.38178581f, -0.06650206f, -0.02257348f, -0.02264232f, -0.19821285f, -0.00983143f, 0.00017074f, 
    0.02102533f, 0.11937145f, -0.09368522f, -0.04051574f, 0.15775049f, 0.09961852f, -0.08719030f, 0.13527426f, 
    -0.18768220f, -0.14305601f, -0.10128038f, 0.09891093f, -0.04259777f, -0.07733056f, -0.21151891f, -0.03868466f, 
    -0.04475569f, 0.02294067f, 0.17709650f, 0.09307895f, -0.09110683f, -0.00917191f, 0.07765179f, -0.03767973f, 
    0.00906187f, 0.07565244f, -0.03071559f, -0.02800875f, -0.40754828f, 0.36893526f, -0.11518194f, 0.03143099f, 
    -0.07439002f, -0.26101544f, 0.12949911f, -0.00703283f, 0.04809295f, 0.19029617f, 0.01653751f, 0.00881044f, 
    0.21480374f, -0.01700132f, 0.00472582f, 0.05192826f, -0.21521664f, -0.09589193f, -0.03350265f, 0.11915092f, 
    -0.14719234f, 0.01899749f, -0.07127126f, -0.15603946f, -0.15855396f, 0.08792139f, -0.13949248f, 0.24276826f, 
    0.06568535f, 0.12738441f, -0.00548119f, 0.05030714f, -0.10686935f, -0.09061859f, 0.09430787f, -0.09060976f, 
    -0.35177276f, 0.14761862f, 0.07192571f, 0.24443176f, -0.02683769f, 0.02576175f, 0.13954383f, 0.00413451f, 
    -0.00663341f, -0.14837886f, 0.26422834f, -0.15279290f, 0.63681978f, 0.19972299f, 0.15416732f, -0.06488213f, 
    0.04102292f, 0.12384554f, 0.10268322f, 0.05193122f, -0.13842338f, -0.04620419f, -0.05702144f, 0.03525355f, 
    0.31535411f, 0.09674064f, 0.20494729f, -0.26739624f, -0.03074159f, -0.08731541f, 0.07762408f, 0.00294940f, 
    0.05589919f, -0.20767269f, -0.24436411f, 0.03559682f, -0.06955613f, -0.35051188f, 0.25843143f, -0.45512068f, 
    -0.04020459f, 0.17369133f, 0.00793004f, 0.03629193f, -0.24492073f, 0.08771886f, 0.07691509f, -0.14502856f, 
    -0.26445720f, 0.31536216f, -0.10729799f, -0.01088674f, -0.04395972f, 0.06780522f, -0.10292792f, -0.07098839f, 
    -0.00186327f, 0.02979697f, -0.06784118f, 0.06534066f, -0.31907728f, 0.37103769f, 0.03158657f, -0.06748075f, 
    0.18935858f, 0.12259192f, -0.05919938f, 0.03135923f, 0.10235951f, -0.00599373f, -0.09383631f, -0.04725190f, 
    0.30506858f, 0.06160861f, 0.14418441f, 0.01994632f, -0.34579244f, -0.20952897f, -0.03371574f, 0.16935413f, 
    0.08696447f, -0.14530961f, -0.01216042f, -0.12565780f, -0.16536848f, 0.22479925f, 0.19128992f, -0.31458038f, 
    0.06353705f, 0.03950266f, -0.00247680f, 0.03525656f, 0.01086418f, 0.07772409f, 0.01564633f, -0.12996817f, 
    0.04473632f, 0.08699661f, 0.00380320f, -0.03554755f, -0.11943553f, 0.00472153f, 0.18260442f, -0.12029286f, 
    0.02040086f, 0.03902541f, 0.06798191f, 0.02101884f, -0.06504162f, -0.31026852f, -0.09976579f, 0.23929277f, 
    -0.04836750f, -0.04374777f, -0.04474820f, 0.11402692f, -0.09515008f, -0.11380919f, 0.06052357f, 0.11126538f, 
    -0.16845724f, -0.28068450f, 0.31417713f, -0.55198497f, -0.15516138f, -0.09477627f, -0.02646021f, -0.20497710f, 
    -0.02184448f, -0.11229952f, -0.12455827f, 0.01904189f, 0.40250081f, -0.17175604f, 0.12553033f, -0.64129853f, 
    0.01049083f, -0.00998995f, -0.04893031f, -0.28940883f, -0.28141782f, -0.14193225f, 0.01625433f, 0.07553146f, 
    -0.64519119f, 0.29734907f, 0.17693749f, -0.36300427f, -0.11847525f, 0.01292650f, -0.01899052f, -0.00307148f, 
    -0.07891056f, -0.06334139f, -0.03855078f, -0.03090405f, -0.44425097f, -0.27884725f, -0.01208659f, 0.14520617f, 
    0.03087820f, -0.03932894f, -0.08077029f, 0.08388817f, 0.01103584f, -0.12433960f, -0.19523868f, 0.03479576f, 
    -0.26011720f, 0.09129961f, 0.37622315f, 0.20987150f, 0.00455424f, 0.00352468f, -0.04931049f, 0.10129281f, 
    -0.07035331f, -0.06740870f, 0.00424573f, -0.03008878f, -0.22415479f, -0.01214178f, 0.00749766f, 0.37452927f, 
    -0.06607756f, -0.19625242f, 0.02486760f, -0.17421697f, -0.14559901f, 0.10802393f, -0.21526010f, 0.05445649f, 
    -0.15469314f, 0.08772836f, -0.30772048f, -0.50813305f, 0.17222029f, -0.02981816f, 0.11127054f, -0.09555401f, 
    0.04753575f, -0.00492693f, 0.07598326f, 0.03654524f, -0.23118776f, 0.11892331f, -0.09940507f, -0.24988157f, 
    0.05768965f, 0.05816456f, -0.03065865f, 0.07018257f, -0.07403601f, -0.00355501f, -0.25789818f, 0.06604317f, 
    -0.21166027f, 0.09320901f, -0.18820895f, 0.12202897f, -0.07284110f, -0.02253111f, -0.06879743f, -0.03279705f, 
    -0.05237390f, 0.05940410f, -0.11575933f, -0.03530454f, -0.14388952f, -0.02758023f, 0.00324327f, -0.17385125f, 
    0.14020358f, -0.08637398f, 0.03236475f, -0.04884993f, 0.05954960f, 0.06212951f, -0.19902965f, -0.02719954f, 
    0.30544165f, 0.03330833f, 0.23069392f, 0.32251629f, -0.09166533f, -0.09048506f, -0.12496307f, 0.03721149f, 
    0.03165766f, -0.06552220f, 0.02354673f, 0.04377653f, 0.08142713f, -0.09350082f, 0.15370265f, 0.19841918f, 
    0.09164280f, -0.19562359f, 0.05165890f, -0.14365785f, -0.19520718f, -0.30541185f, -0.15228343f, -0.01277753f, 
    -0.00358923f, -0.09664922f, 0.16832690f, 0.01694563f, -0.04595821f, 0.00767856f, 0.10368992f, -0.01226377f, 
    0.08040938f, -0.12349470f, 0.01160725f, -0.14681610f, -0.55198145f, -0.01970019f, -0.33784243f, -0.19528182f, 
    -0.12260657f, -0.00284182f, -0.00197935f, -0.17062770f, -0.07350352f, -0.01640029f, 0.03121569f, -0.00319857f, 
    -0.70322937f, -0.21861894f, -0.37405780f, 0.14816655f, -0.16817448f, 0.06352426f, -0.01734748f, -0.03836023f, 
    0.08802482f, 0.02214636f, 0.10000062f, 0.12704614f, 0.71486533f, -0.23999803f, 0.18778461f, -0.08883005f, 
    0.01036589f, -0.06626935f, -0.08407225f, -0.03223767f, 0.11866672f, 0.18387932f, -0.09271117f, 0.07396811f, 
    0.13506266f, 0.08322298f, 0.14936431f, -0.09557278f, -0.26827705f, -0.11018488f, 0.06347430f, -0.02324254f, 
    -0.03157753f, -0.19170219f, 0.25683784f, -0.11765040f, 0.17514767f, -0.25906491f, -0.11684134f, 0.05221413f, 
    -0.02228030f, 0.07215919f, -0.01678558f, -0.05960998f, 0.10117032f, -0.06619549f, 0.03134139f, -0.11167345f, 
    0.21175693f, -0.13629189f, -0.18733664f, -0.08207931f, -0.12951300f, 0.03071547f, 0.00078405f, 0.09711620f, 
    0.14193077f, -0.14157321f, 0.04739623f, 0.09906556f, 0.22289956f, -0.19737564f, -0.05750163f, -0.63682711f, 
    -0.07250347f, 0.13784137f, -0.34518185f, -0.06012305f, -0.10966580f, -0.26690853f, -0.19056769f, -0.00619568f, 
    0.19141941f, 0.17045584f, 0.26628929f, 0.12259104f, -0.08721019f, 0.05325260f, 0.10290068f, 0.00157749f, 
    0.05964076f, 0.06941571f, -0.02549352f, 0.15127067f, 0.02218517f, 0.09243085f, 0.10801254f, 0.26353663f, 
    -0.03708176f, -0.17379537f, -0.08852940f, -0.07681981f, -0.06480073f, -0.10424548f, -0.11506683f, 0.06116152f, 
    -0.21470532f, -0.09625457f, -0.03506474f, -0.11132800f, 0.05283098f, -0.03866258f, -0.05508991f, 0.06542530f, 
    0.08140204f, 0.09216323f, -0.04841550f, 0.06189457f, -0.58791655f, -0.14313228f, 0.09100465f, -0.06032638f, 
    0.05206730f, -0.02985922f, -0.05785929f, -0.07481331f, 0.07279664f, 0.10244963f, -0.03940058f, 0.01480287f, 
    -0.17593254f, 0.14685443f, -0.07934272f, -0.36248478f, 0.17609298f, 0.12272707f, -0.13529330f, -0.02475919f, 
    0.02515430f, 0.09392732f, 0.17494136f, -0.08456463f, 0.23610193f, -0.35885972f, -0.08067448f, -0.30143994f, 
    0.30826095f, -0.04535241f, 0.07290602f, -0.08156116f, 0.15017846f, -0.16674186f, 0.05364732f, 0.04701513f, 
    0.04429749f, 0.03536256f, 0.03186502f, 0.32656342f, -0.17347813f, 0.08402788f, 0.03057754f, 0.06794643f, 
    -0.09845299f, -0.19984241f, 0.00663471f, -0.06922523f, 0.39038363f, -0.09962949f, -0.16778961f, -0.08546013f, 
    -0.05797481f, 0.11870512f, -0.07979526f, -0.06678834f, 0.14408383f, 0.21399562f, -0.11706639f, 0.05939360f, 
    0.26377144f, -0.06284147f, 0.05254339f, 0.33834913f, 0.10517954f, -0.00664840f, 0.16349322f, 0.03599378f, 
    -0.09449387f, -0.01189208f, -0.02981533f, -0.01281014f, 0.33642325f, -0.20746303f, -0.08915018f, -0.00631279f, 
    -0.05206568f, 0.01392766f, -0.02291780f, 0.05836789f, 0.09064833f, 0.06763453f, -0.14743987f, 0.09125726f, 
    -0.18614084f, -0.32621214f, -0.66360438f, -0.32122228f, 0.11673085f, -0.06498916f, -0.11600737f, -0.08185979f, 
    0.06968454f, 0.00012400f, -0.00385466f, 0.09014800f, -0.20330751f, 0.12146614f, 0.32349882f, -0.03567381f, 
    -0.04415008f, 0.03205144f, 0.10286214f, -0.01089681f, 0.00820647f, -0.04951475f, -0.04872457f, 0.00619680f, 
    0.28823787f, -0.22734325f, 0.08134159f, -0.27524063f, -0.08653426f, -0.07243414f, 0.12573986f, -0.03885964f, 
    0.06760894f, 0.15513156f, -0.02429278f, -0.09308559f, 0.19462942f, -0.14371265f, 0.08970734f, -0.22044247f, 
    0.27917227f, 0.04972966f, -0.03516914f, 0.00498256f, -0.06864835f, 0.16425000f, 0.15062308f, -0.05399714f, 
    0.15461300f, 0.18264011f, -0.04615504f, -0.31299904f, -0.04942867f, -0.00157433f, -0.04995884f, -0.00885932f, 
    0.02081833f, -0.01639438f, 0.04417931f, 0.00961564f, 0.26760021f, 0.04068970f, 0.04252324f, -0.17207634f, 
    -0.13711588f, -0.13604151f, 0.03291953f, 0.00268807f, -0.07184186f, 0.08491367f, 0.19849291f, 0.11777592f, 
    -0.23162594f, 0.17915332f, -0.44704244f, 0.07614706f, -0.07014850f, 0.04431725f, 0.08540281f, -0.07129648f, 
    -0.12187562f, -0.12911412f, -0.03285404f, -0.01162023f, 0.30580524f, -0.06949441f, 0.04395700f, 0.09989315f, 
    -0.06577298f, 0.09419420f, 0.00748512f, 0.12281913f, -0.10807880f, -0.08341081f, 0.23368132f, -0.30694470f, 
    0.27684909f, -0.28675559f, -0.03466516f, -0.31314597f, -0.00787188f, 0.05189368f, 0.03413018f, 0.09248157f, 
    0.04872774f, 0.06774729f, 0.00644739f, -0.05109924f, 0.00942946f, 0.07547608f, -0.00068323f, 0.15705398f, 
    -0.06942592f, -0.19955751f, 0.04207087f, 0.15883155f, 0.03974592f, 0.01545129f, 0.02701521f, -0.03694206f, 
    0.38515946f, 0.07220456f, 0.25210986f, -0.05037322f, -0.12511809f, -0.01103937f, -0.16998078f, -0.08686289f, 
    -0.03230661f, -0.12860377f, 0.07783172f, 0.02082242f, -0.03442388f, -0.16491921f, -0.01810666f, -0.26711169f, 
    -0.03791111f, 0.01148862f, 0.04347083f, -0.04381428f, 0.14617817f, -0.09314104f, 0.03061990f, -0.20527607f, 
    0.09273434f, 0.08538856f, -0.06965062f, -0.04581723f, 0.12345731f, 0.00430734f, 0.00299693f, -0.10493466f, 
    -0.07333672f, -0.08513960f, -0.06710098f, -0.09760491f, 0.17414960f, -0.01436897f, 0.03956184f, -0.20431384f, 
    0.03989560f, 0.06742573f, -0.04305622f, -0.01319441f, -0.15021536f, 0.10566232f, 0.06090696f, -0.04794201f, 
    0.13935101f, 0.03778709f, 0.00951231f, -0.02745075f, -0.12261627f, 0.13346876f, -0.05338804f, -0.07270490f, 
    -0.05486810f, -0.18999980f, 0.01976334f, 0.05724883f, -0.24348973f, -0.06456011f, -0.03076606f, -0.16246168f, 
    -0.00883091f, 0.02068314f, 0.20286053f, 0.01636037f, -0.06463105f, -0.04821539f, -0.03438044f, -0.07976194f, 
    0.75616783f, -0.14513192f, -0.27835447f, -0.17855565f, 0.01700836f, 0.08915213f, 0.04100105f, -0.03121236f, 
    0.01475484f, -0.01197928f, -0.04945859f, -0.20008799f, -0.12306839f, -0.08678560f, -0.00701475f, -0.04715570f, 
    0.13514718f, 0.06417693f, 0.01857914f, 0.14652939f, -0.17581135f, -0.11404835f, 0.06620767f, -0.11549581f, 
    -0.21682945f, 0.18471387f, 0.03162583f, -0.01858168f, 0.08632343f, 0.08101161f, 0.09855738f, 0.06016534f, 
    -0.09680408f, 0.01894255f, -0.12454274f, 0.00965139f, -0.32307765f, 0.05411365f, -0.18993565f, 0.07476843f, 
    0.11329865f, 0.03344725f, -0.05490764f, -0.00624279f, -0.08649331f, 0.25088972f, -0.24601190f, -0.15912203f, 
    0.16595994f, 0.15098597f, 0.08941505f, -0.21640795f, -0.01617821f, 0.07098963f, -0.02478758f, -0.10415003f, 
    -0.08208908f, 0.02620552f, 0.04008670f, -0.03578066f, 0.00921589f, -0.17703313f, -0.60065758f, -0.04098402f, 
    0.08909284f, -0.05192388f, -0.06399679f, -0.10468441f, 0.07616182f, 0.12266243f, 0.05859034f, 0.09534614f, 
    -0.33882427f, -0.01214524f, 0.01669244f, -0.01935657f, 0.23357871f, -0.08312653f, -0.09564238f, 0.03242341f, 
    0.06754817f, 0.07448676f, -0.00156670f, -0.00681806f, -0.00773993f, 0.06617860f, -0.12929627f, 0.16973183f, 
    -0.15997575f, 0.08734891f, -0.13219644f, 0.06563613f, -0.11990032f, -0.02557099f, 0.09853101f, -0.08307704f, 
    -0.13864239f, -0.08646967f, 0.24052769f, -0.16563848f, -0.12924215f, 0.09037613f, 0.05827099f, 0.05045611f, 
    -0.05862402f, -0.13989173f, 0.06038274f, -0.00418357f, 0.53044116f, 0.27339610f, 0.14976084f, 0.18178177f, 
    -0.00506150f, 0.00632092f, 0.14380170f, 0.24184886f, -0.11463796f, 0.30978718f, 0.06153833f, -0.05828275f, 
    0.28981319f, 0.08433987f, -0.17677344f, 0.06147896f, 0.02369643f, -0.01415453f, 0.11516361f, -0.00585672f, 
    -0.10817420f, -0.03801095f, -0.01626313f, 0.00438600f, -0.40220189f, -0.14215754f, 0.11178156f, -0.19135353f, 
    -0.09236626f, -0.06189945f, -0.03988064f, -0.15563767f, -0.13159953f, -0.11594859f, 0.03577253f, 0.10171388f, 
    0.15011567f, -0.04273881f, 0.05269153f, 0.08612502f, -0.07175734f, 0.07383177f, -0.07927347f, -0.07865960f, 
    0.09614096f, 0.02895430f, 0.10888003f, -0.00898508f, 0.32692489f, -0.26117042f, 0.04059515f, 0.02477712f, 
    -0.14965232f, -0.03769533f, -0.21487103f, 0.05536849f, 0.05890261f, -0.05278169f, 0.01089281f, 0.10778410f, 
    0.06235376f, 0.10994105f, -0.22768903f, 0.06893222f, 0.13369431f, -0.00283435f, 0.05596542f, -0.02104684f, 
    0.03880139f, 0.03989786f, 0.04636063f, -0.09026229f, 0.38082734f, -0.22828764f, 0.17803042f, 0.12373298f, 
    -0.22079314f, -0.06409665f, -0.17620426f, 0.08407743f, 0.08398685f, -0.00944446f, 0.04145961f, 0.08750622f, 
    0.08079945f, -0.07031370f, -0.30895028f, -0.13305204f, 0.14407748f, 0.13315164f, -0.09186411f, -0.24111074f, 
    -0.22538979f, 0.01457205f, -0.08098374f, -0.04634829f, -0.34351704f, -0.12318959f, -0.17272557f, -0.04684633f, 
    -0.17252682f, 0.04029446f, -0.16662882f, -0.17741884f, 0.02642672f, -0.07314321f, 0.09381603f, -0.06912567f, 
    -0.36012936f, -0.00177590f, -0.00275399f, -0.29268295f, 0.11531772f, -0.04046242f, -0.07683772f, 0.03631366f, 
    -0.25090358f, 0.12576571f, -0.01716884f, -0.04663479f, -0.50642586f, 0.16191420f, 0.05068460f, -0.06503363f, 
    -0.01403042f, -0.02698671f, 0.12498304f, 0.01741436f, 0.10627722f, -0.17862447f, -0.16175811f, 0.02183163f, 
    -0.26551333f, -0.13353838f, 0.10445721f, -0.23322476f, 0.05166202f, -0.03786563f, 0.14467598f, -0.08275082f, 
    -0.07148009f, -0.14362684f, 0.09719006f, -0.12129525f, 0.08239539f, -0.33448485f, 0.13753313f, -0.08605998f, 
    -0.23874183f, -0.00709643f, -0.14355995f, -0.03518369f, 0.00902581f, -0.02048925f, 0.01267368f, -0.01053912f, 
    0.42444748f, -0.34446084f, -0.21173154f, -0.23443477f, -0.26649171f, 0.01681896f, 0.02989130f, 0.00253117f, 
    0.22218189f, 0.02156574f, -0.09514895f, -0.12769371f, 0.20593551f, -0.54468346f, -0.02103702f, 0.15106735f, 
    0.09157378f, 0.06219039f, -0.05679501f, -0.08755644f, -0.13047925f, 0.18343891f, -0.13348748f, -0.00488115f, 
    0.29939604f, 0.19123366f, 0.04611867f, 0.31160980f, -0.17407171f, -0.14963377f, 0.12606514f, 0.09412135f, 
    -0.06254774f, 0.01601155f, -0.07018480f, -0.00877992f, 0.13828121f, 0.07211635f, -0.04081491f, 0.26414877f, 
    -0.15232638f, -0.10848480f, 0.00803632f, -0.02795142f, 0.12092325f, 0.03431121f, 0.16009519f, 0.01260219f, 
    0.12454779f, 0.12840505f, -0.00677377f, -0.27412307f, -0.05400661f, -0.11502510f, -0.06708404f, -0.00581505f, 
    0.07663580f, -0.17473961f, 0.04957903f, -0.01020969f, 0.23212869f, 0.14427616f, 0.12703305f, 0.17973162f, 
    0.01412177f, 0.14797388f, -0.12649369f, -0.02925167f, 0.10990732f, 0.03111656f, 0.07657880f, -0.18393020f, 
    -0.43978351f, -0.60013556f, -0.36530679f, 0.16023275f, 0.00874232f, -0.05665691f, 0.12805970f, -0.03120424f, 
    -0.05510682f, -0.05807455f, -0.09262298f, 0.14156070f, -0.18022008f, -0.02401119f, -0.34393290f, 0.12602285f, 
    -0.04377447f, 0.02485767f, 0.14074713f, 0.03774777f, 0.14291540f, 0.18381429f, 0.01148472f, 0.04396029f, 
    -0.71118677f, 0.09370150f, -0.06700943f, 0.35475230f, 0.11597832f, 0.11637817f, 0.16021536f, 0.04350540f, 
    0.16904111f, -0.06537613f, 0.14161429f, -0.03535233f, 0.06633455f, -0.03682111f, 0.02333541f, 0.08890405f, 
    -0.02746062f, 0.05901259f, 0.05757520f, 0.19894244f, 0.13831602f, -0.07185032f, 0.09878173f, 0.03069254f, 
    -0.32692602f, 0.29061100f, 0.46213150f, -0.04994214f, 0.12054843f, -0.01278774f, 0.07946344f, -0.01337417f, 
    -0.01445552f, 0.03727704f, -0.13244882f, -0.06140006f, -0.41120073f, -0.03094750f, -0.46422002f, -0.04211593f, 
    0.04293159f, 0.06415925f, -0.16801144f, -0.20448384f, -0.16258262f, -0.04735770f, 0.13694337f, -0.09249761f, 
    -0.36396426f, -0.33743542f, -0.48342961f, -0.07987890f, -0.04085704f, 0.05850009f, 0.02526438f, 0.07826573f, 
    -0.06981403f, 0.10243960f, -0.03441406f, -0.02996558f, 0.09641133f, -0.19343542f, -0.18599945f, 0.29592669f, 
    -0.11529655f, 0.16108285f, -0.00512531f, 0.09286011f, 0.04893328f, 0.07072518f, -0.00427372f, 0.00622418f, 
    -0.45474458f, 0.00423061f, -0.19039957f, 0.08034366f, -0.03297392f, -0.04742992f, -0.03336762f, -0.06419840f, 
    -0.01555555f, 0.15318535f, 0.12154907f, 0.04901516f, -0.18165576f, 0.20143014f, 0.12130772f, 0.11363675f, 
    -0.01208399f, -0.17781840f, 0.20078520f, 0.00325360f, -0.16531596f, 0.21295908f, -0.02023683f, -0.00741857f, 
    -0.87079602f, -0.84741479f, -0.00118419f, 0.06124403f, -0.04837053f, -0.01820330f, -0.06553571f, 0.06504721f, 
    0.10421185f, -0.22990713f, 0.05066073f, 0.06285526f, 0.04039141f, 0.09625312f, 0.10344420f, -0.11457314f, 
    -0.16165018f, -0.10293334f, -0.06749712f, 0.04996165f, 0.07990541f, -0.11815190f, -0.00577338f, -0.09110568f, 
    -0.07297021f, 0.09587242f, 0.14150997f, -0.09532196f, -0.13676649f, -0.00768007f, -0.04763987f, 0.03800626f, 
    0.06821979f, -0.09690275f, 0.03249868f, 0.05324353f, -0.39895850f, 0.04809017f, -0.05142340f, -0.39649954f, 
    0.02736634f, 0.00178668f, -0.05557651f, 0.10874127f, -0.04124411f, -0.07745497f, 0.06514274f, -0.13489580f, 
    -0.51444542f, 0.29783472f, -0.00675631f, -0.05656405f, 0.05322836f, -0.15265514f, -0.03293769f, 0.01160714f, 
    -0.07809564f, -0.10414197f, -0.09608302f, 0.10250824f, 0.16575556f, 0.08747389f, 0.05663210f, -0.11717691f, 
    -0.18425320f, -0.07304882f, 0.04455328f, 0.07808173f, 0.05086314f, 0.12079917f, -0.02023308f, 0.13182634f, 
    0.05119904f, -0.06372856f, 0.26979727f, -0.07228572f, 0.08730043f, 0.03460335f, -0.01140549f, 0.03665623f, 
    0.11329696f, -0.01246044f, 0.06539541f, 0.03814838f, -0.06197802f, 0.17580111f, -0.06178057f, 0.31389514f, 
    -0.03769968f, -0.21034950f, 0.11522581f, -0.12888981f, -0.04010364f, -0.18944390f, -0.07388466f, -0.06595789f, 
    -0.16452354f, -0.50788939f, -0.14894806f, -0.01131112f, -0.05200158f, 0.03148407f, 0.03724087f, -0.06893104f, 
    -0.00910044f, -0.07899623f, 0.11439003f, -0.14776467f, -0.10181893f, -0.04072254f, -0.00944392f, 0.12151488f, 
    -0.04238982f, -0.16497062f, 0.03618186f, 0.00749684f, 0.00276961f, -0.04190503f, -0.03338347f, -0.11523034f, 
    -0.11400985f, 0.44697621f, 0.16466025f, -0.15963097f, 0.03456344f, 0.09258944f, 0.07691662f, 0.20752840f, 
    -0.13203244f, -0.10923240f, -0.07037710f, -0.25119999f, 0.07815193f, -0.18950899f, -0.14720462f, 0.25414732f, 
    0.15121879f, 0.06061873f, 0.07785029f, -0.00099771f, -0.04731178f, 0.00949851f, 0.12372178f, -0.04036023f, 
    0.44775882f, 0.18429749f, -0.04956252f, 0.12567067f, 0.06670187f, -0.00561053f, -0.04828518f, 0.18726574f, 
    0.16381320f, -0.07654399f, -0.11587308f, -0.03505629f, -0.03357099f, -0.18114075f, -0.13426583f, -0.14669114f, 
    -0.16536038f, 0.17571110f, -0.04949193f, 0.04385826f, 0.07776301f, 0.06299803f, -0.17348282f, 0.09053685f, 
    -0.12866205f, -0.19874492f, -0.08058944f, 0.05831462f, -0.13220991f, -0.01254820f, -0.24833035f, 0.12535065f, 
    -0.06250466f, 0.07064609f, -0.16853082f, -0.09324130f, 0.22932099f, -0.02657644f, 0.05465762f, 0.17061980f, 
    -0.16153498f, 0.01204829f, -0.00253718f, 0.03902715f, -0.07823446f, 0.04688652f, -0.05413339f, -0.01903483f, 
    0.08021738f, 0.15012702f, 0.01120846f, -0.01983535f, -0.08654041f, -0.07044887f, -0.09809771f, 0.17175703f, 
    -0.08341770f, 0.01086327f, 0.19131306f, 0.01598828f, 0.86318403f, -0.30134287f, -0.16835664f, 0.23363270f, 
    0.04130884f, -0.11912113f, -0.03378548f, 0.00219049f, -0.08408311f, 0.08825389f, 0.01622216f, 0.02941259f, 
    -0.05697617f, -0.27149865f, -0.14160366f, -0.02558760f, -0.07691982f, 0.04536359f, -0.14339411f, -0.02921084f, 
    -0.04994755f, 0.00037419f, -0.05647809f, 0.10288174f, 0.48692736f, -0.14440082f, 0.20341873f, -0.24103822f, 
    -0.04286437f, -0.05183601f, -0.24662571f, 0.02615380f, -0.06673539f, -0.06922796f, 0.11033056f, -0.00923113f, 
    -0.01613282f, -0.06535971f, -0.04709850f, -0.01832075f, 0.06690670f, 0.06224293f, -0.02019089f, 0.21565205f, 
    -0.07484606f, -0.24844077f, -0.02406809f, -0.18011132f, -0.22528377f, -0.05682154f, 0.17315705f, 0.08714595f, 
    0.09529764f, -0.06126649f, 0.07088550f, 0.25427556f, 0.08325645f, -0.15390491f, 0.06410288f, 0.10699484f, 
    -0.24753454f, -0.16760418f, -0.25076985f, 0.04329075f, -0.12798376f, -0.15428180f, 0.08680812f, 0.05994133f, 
    0.15015130f, -0.05481838f, -0.19325243f, -0.27774787f, -0.54031652f, 0.05165129f, -0.09249136f, -0.12693064f, 
    0.00185091f, 0.16038100f, -0.01422384f, 0.20947909f, -0.03872854f, 0.05976137f, 0.03132872f, 0.07632092f, 
    -0.39790556f, -0.00325004f, 0.16827442f, 0.22013035f, -0.20872651f, -0.05903602f, -0.08024694f, -0.07607581f, 
    0.02235566f, -0.00297655f, -0.08715345f, -0.07207078f, -0.00171897f, -0.38953432f, 0.15981896f, -0.18775399f, 
    -0.16285942f, 0.19545481f, 0.08393756f, 0.12138059f, 0.10454205f, 0.24514432f, 0.02951423f, 0.16467273f, 
    -0.67452329f, -0.11982851f, 0.21019626f, -0.06893303f, 0.00132172f, -0.16718504f, -0.10771297f, -0.14956488f, 
    -0.08801215f, -0.04217041f, -0.04253211f, 0.06797501f, -0.25032908f, 0.18650073f, -0.07986975f, 0.05672356f, 
    0.07871722f, 0.07371463f, 0.17781100f, 0.04479656f, -0.14515005f, -0.10381606f, 0.06465080f, 0.06241848f, 
    -0.26424351f, -0.05697815f, 0.09810149f, -0.21171287f, 0.15974443f, 0.03184652f, -0.27220494f, -0.11549576f, 
    0.06088871f, -0.03525577f, 0.02140872f, 0.06420570f, -0.05605046f, -0.00370847f, 0.26850843f, 0.06160160f, 
    -0.00923466f, 0.08213651f, 0.08463966f, 0.05746898f, 0.08328254f, 0.02638115f, 0.03492824f, 0.08891488f, 
    -0.60835296f, -0.04358495f, 0.32864535f, -0.17295201f, -0.03917175f, 0.06836706f, -0.09301350f, -0.08279398f, 
    0.09616762f, -0.07609620f, -0.08639316f, -0.13555038f, 0.10288479f, -0.12809834f, 0.15017115f, -0.11754014f, 
    0.09754305f, -0.11927337f, 0.02269563f, 0.20548722f, -0.00800294f, -0.04608315f, 0.12199937f, 0.01802641f, 
    0.35878521f, 0.29864952f, 0.06565272f, -0.11810797f, -0.04841042f, -0.06746633f, 0.02067328f, 0.12329461f, 
    0.07358757f, -0.10567820f, 0.09431562f, 0.00415949f, 0.18874271f, -0.31659582f, -0.04623660f, 0.04499716f, 
    0.09853186f, 0.23622851f, -0.17665099f, 0.13695565f, -0.01422381f, 0.13234377f, -0.04621368f, -0.07224125f, 
    0.43314981f, 0.13231498f, -0.14630277f, -0.07812039f, -0.01367796f, 0.06504586f, -0.14491381f, 0.14015143f, 
    0.00234514f, -0.05646847f, -0.08832867f, -0.05698553f, -0.05209709f, 0.22051702f, -0.00695072f, 0.25207368f, 
    0.14049016f, -0.02882786f, -0.04965853f, 0.08309552f, -0.09303986f, 0.08120613f, 0.17996180f, 0.03865104f, 
    -0.25226063f, 0.09277885f, 0.10049619f, 0.10030674f, -0.13758756f, -0.11252617f, 0.23791990f, -0.10067641f, 
    0.04042260f, -0.05634048f, -0.27329877f, 0.12711139f, 0.03956968f, -0.00476731f, -0.19676860f, 0.17836465f, 
    -0.03650970f, -0.07217617f, 0.12797442f, 0.19844121f, 0.03485938f, 0.11198480f, -0.08917243f, -0.00644648f, 
    -0.56525743f, 0.23729318f, 0.00209784f, -0.24036209f, 0.03278365f, -0.06300558f, -0.11930308f, 0.10990559f, 
    -0.07478262f, -0.09193449f, -0.05681099f, 0.12461128f, -0.65258098f, 0.07268731f, -0.21598363f, 0.03078267f, 
    -0.08061562f, -0.01822148f, 0.04532100f, 0.12231313f, 0.08316658f, -0.19046602f, 0.07403645f, -0.00623700f, 
    0.11843985f, -0.09138606f, 0.23187824f, 0.12323961f, -0.15053768f, -0.00644865f, -0.08175510f, -0.05708582f, 
    0.05931111f, 0.06767072f, 0.01671029f, -0.18677776f, -0.70821601f, 0.13275491f, -0.27213451f, 0.07445966f, 
    0.04737496f, 0.03860037f, -0.02879727f, 0.04671436f, -0.01592349f, 0.12671682f, 0.00281360f, 0.10360250f, 
    -0.22917840f, -0.10530911f, 0.16236919f, 0.18595290f, 0.07070896f, 0.16089702f, 0.12195891f, -0.14884070f, 
    0.11337233f, -0.04334912f, -0.27255836f, -0.04728743f, 0.06651146f, 0.08008073f, 0.03144668f, 0.00379944f, 
    0.16271856f, 0.17522623f, -0.15267166f, 0.02431889f, 0.07938717f, 0.02452772f, 0.04254309f, -0.19052109f, 
    -0.00760030f, 0.18364665f, -0.24285044f, 0.02150261f, -0.00379233f, 0.06368210f, -0.03287828f, 0.03988887f, 
    -0.20044458f, -0.11381705f, 0.15989789f, -0.12800439f, -0.26243195f, 0.02138164f, 0.23335956f, 0.09140457f, 
    -0.11530153f, 0.03055819f, 0.05485327f, 0.03403706f, 0.14177264f, 0.07107292f, 0.12519543f, -0.08854291f, 
    -0.23873021f, -0.33451161f, 0.27834100f, -0.31553683f, -0.00147244f, 0.13589074f, 0.10424951f, -0.02114678f, 
    0.06969907f, 0.00363785f, -0.10349492f, -0.11977038f, 0.11293610f, 0.05265834f, 0.08896623f, 0.24771990f, 
    -0.00850288f, 0.01757594f, 0.02390331f, 0.10905392f, 0.13828343f, -0.05287981f, -0.06514554f, -0.07535078f, 
    -0.01227000f, 0.17918570f, -0.34301218f, -0.64795077f, 0.06966392f, -0.11534891f, 0.04661181f, 0.03998262f, 
    0.04185982f, 0.12018508f, -0.15706417f, -0.01614944f, 0.15385745f, 0.33821484f, -0.18346699f, -0.31369326f, 
    -0.15688369f, 0.07775730f, -0.00445620f, 0.06538265f, -0.06895436f, -0.01512334f, -0.04221211f, 0.08666829f, 
    -0.38222647f, 0.13919014f, 0.25006637f, 0.27683261f, -0.07595379f, 0.09935409f, -0.08986566f, -0.10926498f, 
    -0.09322657f, 0.07216288f, 0.10938182f, 0.10855336f, -0.06589836f, -0.23818552f, 0.14190099f, 0.11717436f, 
    0.00918761f, 0.00654621f, -0.04909977f, 0.09908727f, -0.07616469f, -0.08174191f, 0.03015114f, 0.07517111f, 
    -0.44953912f, -0.28219825f, -0.21579525f, 0.11037970f, 0.22464660f, 0.00760617f, 0.13458918f, -0.05912299f, 
    0.03613574f, 0.24365878f, -0.05732812f, -0.06637754f, -0.05509586f, 0.05037974f, 0.12982243f, 0.24939366f, 
    -0.14236081f, 0.09948796f, -0.12060209f, 0.10102759f, -0.32576570f, 0.02912176f, 0.22469138f, 0.23364376f, 
    0.09424634f, -0.07313063f, 0.15334791f, -0.21701533f, -0.00235616f, 0.18914133f, 0.03474166f, 0.02873252f, 
    0.02919924f, -0.04747691f, 0.25084946f, 0.30178958f, 0.02290010f, -0.03436858f, -0.01742537f, -0.04985517f, 
    0.10522040f, -0.21742636f, -0.05678347f, -0.13970535f, 0.02824063f, -0.16560534f, -0.15273605f, -0.15019998f, 
    0.13352527f, 0.00474930f, 0.04605565f, -0.15146314f, -0.06113956f, -0.12029267f, -0.12276796f, 0.09572487f, 
    0.11753471f, 0.15771234f, -0.09658008f, -0.00124394f, 0.15686670f, 0.13421810f, -0.17574400f, -0.11435097f, 
    0.15924923f, -0.01944650f, -0.33405477f, 0.12881207f, -0.24845770f, -0.03375597f, 0.05893298f, 0.03580683f, 
    0.05701025f, 0.11966234f, 0.03685202f, -0.20944394f, 0.00762195f, -0.05778836f, -0.04747486f, 0.18320954f, 
    0.00407887f, -0.05871867f, -0.01836421f, 0.00122254f, -0.29252195f, 0.16020107f, 0.10203367f, -0.19445835f, 
    -0.05567734f, -0.24926817f, -0.05992253f, -0.19344427f, 0.08554986f, -0.06178847f, -0.11773423f, 0.09576409f, 
    -0.02614586f, 0.12383904f, -0.12622873f, 0.29907432f, -0.02518171f, -0.01598019f, 0.04578787f, 0.04416094f, 
    0.17108466f, 0.04016255f, -0.03421389f, 0.12395462f, 0.07019129f, -0.05561071f, 0.01810465f, 0.27604863f, 
    -0.17791823f, -0.09007460f, 0.04855139f, -0.09842634f, -0.14697012f, -0.02304284f, 0.17418557f, 0.19790813f, 
    -0.08112488f, -0.04697163f, -0.05970284f, 0.20176284f, -0.12690400f, -0.01179715f, 0.17452446f, 0.00126498f, 
    -0.17379020f, -0.19848961f, -0.02770002f, -0.12526095f, -0.07459223f, 0.05366138f, -0.06666814f, 0.17064589f, 
    0.05755786f, 0.24836551f, 0.07548410f, -0.06513350f, 0.20244153f, -0.04185099f, -0.06925196f, -0.10664040f, 
    -0.08252944f, 0.02636897f, 0.22346579f, 0.20188126f, -0.04181920f, 0.17599221f, 0.05282056f, -0.06561524f, 
    0.18246360f, 0.04105239f, 0.03018983f, 0.12911877f, 0.02144009f, 0.11395025f, -0.05635276f, -0.25087023f, 
    -0.03531509f, 0.03475738f, 0.29232040f, 0.01157878f, 0.08561237f, 0.16775766f, -0.17071073f, 0.05509127f, 
    -0.31228405f, -0.35101676f, 0.00213274f, 0.03324806f, 0.12311049f, -0.31165528f, -0.00369490f, -0.07846679f, 
    -0.15575932f, 0.27285725f, -0.13608523f, 0.29646087f, 0.08111019f, -0.10334213f, -0.15726522f, -0.12310217f, 
    0.01231799f, -0.05851140f, -0.10146626f, -0.38655764f, 0.07434154f, -0.17733814f, -0.07952102f, -0.19540526f, 
    -0.18777686f, -0.31460169f, -0.12460502f, 0.02459180f, -0.06687367f, 0.07686044f, -0.13612054f, -0.20139132f, 
    0.14483871f, 0.04191899f, 0.26370859f, 0.10016910f, -0.07302936f, -0.08716719f, 0.11748154f, 0.08253065f, 
    0.01702537f, 0.05814781f, 0.04920990f, 0.06047260f, 0.16258186f, -0.19704433f, 0.00508228f, -0.01782926f, 
    -0.15738998f, -0.00348667f, 0.04453399f, -0.16320187f, -0.00926058f, -0.21993400f, 0.14643991f, -0.03108865f, 
    -0.04960139f, -0.12065662f, 0.05388696f, -0.17162421f, -0.62170637f, 0.25827038f, -0.00995941f, -0.16351181f, 
    0.05725269f, 0.15859815f, 0.18339884f, -0.12527190f, 0.01537623f, 0.08410814f, 0.05853419f, -0.01927870f, 
    0.00292465f, -0.03234173f, -0.05258072f, -0.03176631f, -0.14432552f, -0.03240353f, 0.06416629f, -0.14993554f, 
    -0.13482450f, -0.01621091f, 0.05436213f, 0.31311318f, -0.24629600f, 0.20029742f, -0.15320447f, -0.15711764f, 
    0.21923582f, 0.13353169f, 0.08875267f, -0.03641272f, -0.07131134f, -0.01179989f, 0.04490808f, -0.10010160f, 
    0.32562938f, 0.01436588f, 0.30019724f, 0.10965484f, -0.04108499f, -0.11074433f, 0.01012928f, 0.13740449f, 
    0.03533421f, -0.04653991f, 0.13762254f, 0.22732511f, -0.23959225f, 0.01566842f, -0.01101087f, 0.24774602f, 
    -0.16013974f, -0.02676847f, 0.06613957f, 0.13295144f, 0.26305300f, 0.08023521f, -0.19368169f, 0.09618810f, 
    -0.56429678f, -0.21139558f, 0.30891266f, 0.28001228f, -0.18629159f, -0.02542544f, -0.02366092f, -0.01725611f, 
    0.04073422f, 0.00392576f, 0.07758521f, 0.08847499f, -0.31765234f, 0.05084398f, -0.08624329f, 0.07846559f, 
    -0.08243113f, -0.19191916f, -0.25427017f, 0.01649126f, 0.09193121f, -0.05701544f, 0.01409229f, 0.02991254f, 
    -0.07130641f, 0.06031402f, -0.20956390f, 0.08821406f, -0.07115693f, 0.00389205f, 0.03818242f, 0.06191853f, 
    0.04387579f, 0.03610073f, 0.09203271f, 0.11284394f, -0.28027910f, -0.04760669f, -0.15916567f, -0.23644066f, 
    0.21580960f, 0.07581937f, -0.12030891f, 0.06839002f, -0.02793670f, 0.10293940f, 0.17084579f, 0.01884414f, 
    -0.67716050f, 0.17940292f, 0.07593693f, 0.16131267f, 0.02657172f, 0.14313079f, 0.00365540f, -0.04948477f, 
    0.00324890f, -0.08295789f, -0.14975534f, -0.11476933f, -0.05438773f, -0.24375755f, 0.40192124f, -0.20726915f, 
    0.12936576f, -0.00116729f, 0.06624527f, -0.02937160f, 0.08140919f, -0.07962537f, -0.12798609f, -0.00506991f, 
    0.17079994f, -0.04104784f, -0.31640655f, -0.00913689f, 0.14254799f, -0.09767698f, -0.02175724f, -0.15717666f, 
    0.01089642f, -0.05088287f, -0.10005360f, 0.05713944f, -0.51186568f, -0.26663500f, -0.43254301f, 0.05347518f, 
    0.16457151f, 0.19179645f, 0.09015662f, 0.10244801f, 0.08576129f, -0.08523460f, -0.06072290f, -0.16507222f, 
    0.07631325f, 0.15470280f, -0.12603517f, -0.06887075f, -0.15246752f, 0.08753016f, -0.05437108f, -0.14354913f, 
    -0.25653532f, -0.02902907f, 0.00652304f, -0.14096187f, -0.02834905f, 0.07189173f, -0.14507389f, -0.19097638f, 
    -0.11079749f, 0.01093341f, -0.05577975f, -0.20853274f, 0.07054177f, -0.14597231f, -0.12689434f, -0.12726627f, 
    0.00453150f, 0.30741847f, 0.18588531f, -0.11117871f, -0.04012510f, -0.14556699f, 0.01059613f, -0.05741687f, 
    0.02971501f, -0.11127118f, -0.08884353f, -0.25261244f, 0.09037510f, 0.07671443f, 0.15998693f, 0.05115356f, 
    -0.12199374f, 0.04205795f, 0.14082524f, 0.08975975f, 0.05196971f, 0.06331149f, 0.07669695f, 0.16807926f, 
    -0.11433046f, 0.20620885f, 0.01894795f, -0.28391236f, 0.10338276f, 0.02641433f, 0.21345381f, -0.16789882f, 
    -0.10643914f, 0.04241218f, 0.15362212f, 0.02165841f, 0.36440754f, 0.20056520f, 0.26012382f, 0.20758274f, 
    0.07218778f, 0.00039779f, 0.13434188f, 0.06713209f, 0.01737743f, 0.05806581f, -0.14327124f, -0.10258137f, 
    0.38492760f, -0.07850248f, -0.01591712f, -0.07791217f, 0.11343232f, 0.07818823f, 0.25809216f, 0.02212606f, 
    -0.08333097f, 0.08813330f, 0.04792716f, -0.18005107f, -0.23900458f, -0.22166030f, 0.33424106f, -0.02191445f, 
    -0.16824509f, 0.01297397f, -0.08742275f, 0.03213396f, -0.04550927f, -0.13902760f, -0.05954463f, 0.12790740f, 
    -0.43070975f, 0.37995976f, 0.11332629f, 0.31156242f, -0.11757975f, 0.07970212f, 0.00202098f, -0.01592683f, 
    -0.01074867f, 0.00990960f, 0.08253051f, -0.15735056f, 0.02468792f, 0.32858464f, 0.14424285f, -0.41991597f, 
    0.13726091f, 0.02410037f, 0.08385801f, 0.01590254f, 0.01284063f, -0.08438990f, -0.08563527f, -0.08984471f, 
    0.02047176f, 0.06882153f, 0.11754607f, -0.05755468f, 0.16793513f, -0.06695209f, -0.16676712f, -0.03268111f, 
    -0.02159171f, 0.07389212f, -0.08867958f, 0.01790216f, -0.27181485f, -0.25825030f, -0.09851696f, -0.05708221f, 
    -0.05260337f, -0.08021044f, 0.05577311f, -0.08708336f, 0.07416806f, 0.04336656f, 0.07351328f, 0.02166848f, 
    -0.00866988f, -0.07121430f, 0.14521338f, -0.13637674f, 0.12807481f, -0.05982688f, -0.07669590f, 0.13780627f, 
    -0.12437256f, -0.08913299f, 0.15162136f, -0.09775487f, -0.18449079f, 0.01578747f, 0.28434008f, -0.12610805f, 
    0.11326513f, -0.04845272f, 0.10526371f, -0.01940868f, 0.01841298f, -0.09611130f, 0.03247757f, -0.16738184f, 
    0.05033183f, -0.04908518f, -0.12313113f, 0.11963406f, -0.07737482f, 0.09998258f, 0.08637415f, -0.05430746f, 
    0.07390372f, -0.01372068f, 0.10596120f, -0.14636877f, 0.05812893f, -0.47299367f, -0.25564048f, 0.17142072f, 
    -0.24274825f, 0.05453953f, 0.07080048f, -0.09676313f, 0.01178123f, 0.02555696f, 0.00794451f, 0.36626086f, 
    -0.26650441f, -0.33427858f, -0.10730080f, 0.10036097f, -0.04074205f, 0.13333231f, 0.10240743f, 0.09882247f, 
    -0.12945421f, -0.10289419f, -0.31324461f, 0.04739619f, -0.05075834f, -0.07151458f, -0.35312337f, -0.14154409f, 
    -0.25656313f, 0.03198653f, -0.14385100f, -0.14198112f, -0.10820941f, 0.15210441f, -0.04583073f, 0.00696711f, 
    0.57957369f, -0.50750589f, 0.26644078f, 0.00583825f, 0.04482759f, 0.11434644f, 0.14049643f, -0.07410598f, 
    0.18939225f, 0.02373474f, -0.05806993f, 0.07329080f, 0.20274493f, -0.53859502f, 0.11525238f, -0.15507919f, 
    0.09307778f, -0.01789036f, -0.02575024f, 0.09674220f, 0.00815717f, -0.04852545f, 0.14523096f, -0.17939146f, 
    -0.27236503f, 0.46573371f, 0.12459695f, -0.59405375f, -0.00070396f, -0.09787676f, -0.11208595f, 0.05660636f, 
    0.16540219f, 0.04101384f, -0.12535651f, -0.08019381f, 0.16263081f, -0.39289409f, 0.04543513f, -0.09762411f, 
    -0.08568680f, 0.03929121f, -0.09010124f, -0.04397862f, 0.06398627f, 0.07914637f, 0.03416096f, 0.30640373f, 
    -0.07572960f, 0.23868114f, 0.20038973f, 0.28711462f, -0.13913926f, -0.00030550f, 0.02946305f, -0.05093241f, 
    -0.14425673f, 0.11181609f, -0.08025549f, -0.15896726f, 0.04902113f, 0.01864904f, -0.05482907f, -0.40944991f, 
    0.05366404f, 0.02250668f, 0.13858326f, -0.08495185f, -0.17491567f, -0.09267315f, -0.16628543f, 0.02913762f, 
    0.32454336f, -0.10142832f, -0.28943458f, 0.18244737f, -0.06999747f, 0.13829206f, 0.03822148f, -0.06627630f, 
    -0.00722843f, -0.09192927f, 0.04917919f, -0.00060621f, -0.03246702f, -0.09558149f, -0.32704592f, 0.34268695f, 
    0.04422672f, -0.11999862f, 0.33178079f, -0.05116244f, 0.01850671f, -0.07352143f, -0.14446446f, 0.10888437f, 
    -0.24228564f, 0.08506963f, -0.35189486f, 0.57153314f, 0.06233275f, 0.07030156f, -0.04008839f, 0.03838288f, 
    -0.06032157f, -0.08193014f, -0.10739164f, -0.24460182f, -0.27076265f, 0.15251631f, 0.05025849f, -0.28139797f, 
    -0.01611497f, 0.06549495f, -0.00675973f, 0.03715894f, -0.07182496f, 0.05157557f, -0.07328333f, 0.06742647f, 
    0.54558605f, -0.62841135f, 0.10358139f, -0.22658928f, 0.09441050f, 0.04342242f, -0.13612705f, -0.06906065f, 
    -0.10779135f, 0.20155519f, 0.17804931f, 0.15306656f, -0.13300225f, -0.06807503f, -0.04622405f, -0.03786987f, 
    0.02030064f, 0.06741347f, 0.12921403f, 0.05556938f, 0.07794864f, -0.06576299f, 0.06527606f, 0.05806584f, 
    -0.55660063f, -0.30091086f, 0.03603045f, -0.03207384f, 0.17307056f, -0.03193626f, 0.06362463f, -0.03552809f, 
    0.05047524f, -0.05109315f, 0.21488528f, -0.14394473f, -0.00931610f, -0.24137616f, -0.16282660f, -0.22371995f, 
    -0.22079186f, 0.04346543f, -0.07541396f, -0.28285545f, -0.08695728f, -0.03556037f, 0.05350079f, 0.22897516f, 
    0.08880156f, 0.24392472f, 0.19972552f, 0.24242963f, 0.12321778f, -0.02694238f, 0.12364598f, -0.04331049f, 
    -0.02097423f, 0.00115847f, 0.03381683f, -0.05211742f, -0.08765249f, 0.01966757f, 0.03549085f, 0.10426378f, 
    -0.21501346f, -0.13175483f, -0.06356686f, -0.06168736f, 0.01882655f, 0.07421847f, -0.06021398f, 0.07404336f, 
    -0.32720289f, 0.21978691f, -0.16591434f, -0.23726140f, 0.00368493f, -0.07161412f, 0.04137762f, -0.01271089f, 
    -0.13301176f, -0.04004999f, 0.03853951f, -0.05017128f, -0.16785288f, -0.06893918f, -0.08633468f, -0.22658052f, 
    -0.12532538f, 0.10228126f, -0.11528584f, -0.08303311f, 0.05706430f, 0.01060003f, -0.05989937f, -0.03989753f, 
    0.09682003f, -0.20516931f, -0.39468876f, -0.05567548f, 0.05474945f, -0.00973826f, -0.11799060f, -0.01953407f, 
    -0.19754395f, -0.01227620f, 0.08721375f, 0.10135596f, 0.04194846f, 0.02733660f, -0.00323996f, 0.32442603f, 
    0.01336163f, -0.19366007f, 0.04562609f, 0.11443824f, -0.14671800f, -0.02728729f, -0.01180467f, -0.09815930f, 
    0.56353337f, -0.17696071f, 0.22625449f, -0.08167027f, -0.06151450f, -0.16153435f, 0.13765633f, -0.00246309f, 
    0.05021749f, 0.06529020f, -0.07851224f, -0.08199421f, -0.11716725f, 0.07984830f, -0.14345710f, 0.02840123f, 
    -0.27207431f, 0.08232480f, -0.04468909f, -0.17105192f, -0.07707501f, 0.03456981f, -0.19420367f, -0.23754063f, 
    -0.26010516f, 0.12265497f, 0.14844900f, -0.20513451f, 0.01970262f, -0.01833717f, -0.04978442f, -0.07639896f, 
    -0.05982444f, 0.09219157f, -0.09389092f, 0.04115138f, -0.17311320f, -0.21595365f, -0.13074039f, 0.17631684f, 
    -0.19306296f, -0.01697534f, 0.00546045f, -0.07039288f, -0.18753344f, -0.02122666f, -0.04860399f, -0.14390430f, 
    0.19214521f, 0.09067316f, -0.18345881f, -0.14280321f, -0.14207466f, -0.06643694f, 0.04665810f, -0.09813474f, 
    -0.06858753f, 0.04228809f, -0.16781841f, -0.05473114f, 0.33681977f, -0.04565427f, 0.33911878f, 0.15354927f, 
    0.21235144f, 0.12121463f, -0.08609164f, 0.05292192f, -0.06614962f, 0.21396911f, -0.02865940f, -0.11855573f, 
    -0.14737403f, -0.07232225f, -0.00967504f, 0.07627206f, -0.16663863f, -0.05667756f, -0.04683730f, -0.16859494f, 
    0.05519103f, -0.05608624f, -0.02926172f, -0.01298240f, 0.09150884f, -0.04292053f, -0.15598433f, -0.22079948f, 
    -0.03653685f, 0.11625814f, -0.00931294f, -0.12578057f, -0.00822039f, 0.04678590f, -0.00465877f, -0.13775764f, 
    0.32809770f, 0.10551570f, 0.12876555f, 0.24132834f, 0.16071104f, 0.04189996f, -0.00668895f, -0.07260770f, 
    -0.06613763f, -0.08074722f, -0.06810093f, -0.16553976f, -0.23272726f, 0.39462498f, 0.06383511f, -0.01419161f, 
    0.04439220f, -0.04420005f, 0.11386994f, -0.04606096f, 0.09766798f, -0.02743160f, 0.08890069f, -0.05698808f, 
    0.02827804f, -0.12565158f, 0.05169791f, 0.18913345f, 0.12088631f, 0.01394832f, -0.03220323f, -0.08247147f, 
    0.03334830f, -0.01354859f, -0.00333459f, -0.06528100f, -0.00370938f, 0.20615210f, 0.05731335f, 0.11631109f, 
    -0.10257827f, 0.07051715f, -0.01950370f, 0.03130957f, -0.10686626f, 0.13800590f, -0.11581553f, -0.11540390f, 
    0.21258424f, -0.28902370f, -0.12215908f, -0.26640055f, -0.00765597f, -0.04161169f, -0.08043721f, -0.08902433f, 
    -0.02686590f, 0.04256358f, -0.06612740f, -0.02974941f, -0.25787798f, -0.01390229f, 0.25791785f, -0.15373117f, 
    0.04399668f, 0.06463645f, -0.01818286f, 0.03262284f, -0.06556739f, 0.02809319f, 0.04158552f, 0.03807464f, 
    -0.49013212f, -0.04475199f, -0.15159333f, -0.08984768f, -0.07244380f, -0.05153136f, -0.03521095f, -0.04197396f, 
    -0.19309665f, -0.00395181f, -0.01799466f, -0.03966819f, -0.22504115f, 0.12792465f, 0.24043289f, 0.01645268f, 
    0.09289413f, 0.06892866f, 0.08507393f, 0.05478734f, 0.03597641f, 0.01287693f, 0.05621298f, -0.04296287f, 
    0.08889208f, -0.38832927f, 0.03001107f, -0.12408850f, 0.08528903f, -0.06406257f, -0.18994509f, 0.01209480f, 
    -0.07204293f, -0.07745814f, -0.05868617f, -0.03276549f, -0.02410913f, 0.06819671f, -0.19471590f, 0.14681606f, 
    -0.00666209f, -0.05220135f, -0.09029737f, -0.08385374f, -0.09075176f, 0.06753203f, 0.06120425f, -0.15974493f, 
    0.04990931f, 0.17188913f, 0.00166221f, 0.22551848f, -0.00995039f, -0.18665379f, -0.11011111f, 0.00558591f, 
    -0.05236152f, -0.05753905f, -0.04203817f, -0.08906013f, 0.01001194f, 0.16766055f, -0.25304329f, 0.18243493f, 
    0.02742232f, 0.03096500f, 0.12720215f, 0.11063611f, 0.08606641f, -0.12065875f, -0.08725135f, -0.09026635f, 
    -0.17241815f, -0.16899300f, -0.10638867f, -0.00095171f, 0.06414781f, -0.03969423f, 0.02020041f, 0.04388192f, 
    -0.06734642f, -0.10968781f, -0.07214262f, -0.05961800f, 0.03457249f, -0.00200864f, 0.18592437f, 0.07610124f, 
    0.05257135f, -0.00880087f, -0.03202815f, -0.04511052f, -0.05128326f, -0.01768958f, -0.14087647f, 0.00525649f, 
    0.17356507f, -0.03631967f, 0.25961649f, 0.09164178f, 0.16514781f, -0.04278912f, -0.01963466f, 0.00475911f, 
    -0.12238920f, 0.06365703f, -0.11081411f, -0.00269923f, -0.62821883f, 0.31059372f, -0.09978804f, -0.20878586f, 
    -0.05702301f, -0.00550526f, 0.03991137f, -0.10290089f, -0.18680140f, 0.12429204f, -0.03241228f, -0.10680722f, 
    0.10491473f, 0.14703731f, 0.12513833f, 0.02259710f, 0.01878651f, -0.01910461f, 0.03387761f, -0.17801313f, 
    -0.05391814f, 0.09875936f, -0.07819589f, -0.05469470f, 0.15566991f, 0.17242667f, 0.15491648f, 0.26867333f, 
    0.23671980f, 0.03276107f, 0.09475881f, 0.03502402f, -0.05547486f, 0.01443498f, -0.13764495f, -0.08396188f, 
    -0.09592288f, -0.09576279f, 0.30181772f, -0.05101867f, -0.03381474f, 0.00210894f, 0.12306357f, -0.01140400f, 
    -0.09999698f, 0.04424622f, 0.00447439f, 0.08903167f, -0.14498292f, 0.12522128f, -0.13377899f, -0.37276173f, 
    -0.07889428f, 0.13874651f, 0.03141822f, 0.03968924f, -0.02722204f, 0.14003903f, 0.06507616f, 0.14966874f, 
    0.05223788f, -0.10697258f, -0.03879420f, 0.10992629f, 0.06289702f, -0.03231951f, -0.02335396f, 0.00229541f, 
    -0.19513237f, -0.09543090f, 0.13104725f, 0.16023944f, 0.17284733f, -0.01218936f, -0.05809889f, 0.18213324f, 
    0.23883474f, -0.05484569f, -0.08231577f, 0.00557777f, -0.08183447f, 0.10928896f, -0.07631381f, -0.13455145f, 
    -0.14446932f, -0.00024165f, -0.25038615f, -0.02817953f, -0.06271333f, -0.11383809f, -0.08753950f, 0.03570560f, 
    0.15870534f, -0.08288834f, -0.01928272f, 0.09790210f, 0.09140733f, -0.20482391f, -0.37377983f, -0.37914279f, 
    -0.06781854f, -0.22469932f, -0.07228584f, -0.05028238f, -0.12889887f, -0.32429767f, 0.04834674f, 0.16094875f, 
    -0.00482932f, -0.23388267f, -0.35672152f, -0.19565666f, 0.00682750f, -0.09700499f, 0.13398431f, -0.03656494f, 
    0.09043040f, -0.05105842f, -0.00688204f, 0.18419628f, 0.26233453f, 0.17741677f, 0.23834154f, 0.13565469f, 
    -0.10901299f, -0.05975779f, 0.04127174f, -0.05265138f, -0.00417460f, -0.02188610f, -0.01596329f, -0.06480841f, 
    0.21470235f, 0.19235055f, 0.10122260f, 0.16225411f, -0.02442425f, 0.13736039f, 0.01258970f, -0.09070496f, 
    0.01849030f, -0.06367271f, 0.00025375f, 0.04349908f, -0.24896659f, -0.32976937f, -0.07987715f, 0.02335427f, 
    0.10424744f, -0.05380172f, -0.09327008f, -0.12007409f, -0.03608575f, 0.02889068f, 0.15152486f, 0.02647692f, 
    0.25936538f, -0.05908031f, -0.45644474f, 0.10928006f, 0.03650017f, 0.01235825f, 0.13340120f, -0.11258917f, 
    -0.15800954f, -0.02158548f, 0.11283911f, 0.08732323f, -0.28301728f, -0.17343138f, 0.02791280f, -0.50884569f, 
    -0.08920743f, 0.09691274f, 0.08766851f, -0.23052034f, 0.03013705f, -0.15353712f, 0.00373650f, -0.02486640f, 
    0.20980062f, 0.12184369f, -0.03328947f, 0.20042771f, 0.05758922f, 0.04652936f, -0.11625113f, -0.15339611f, 
    0.04604523f, -0.10358460f, -0.07432092f, -0.07060726f, 0.05030113f, -0.08284458f, 0.13400058f, 0.02092779f, 
    0.04426572f, -0.03990725f, 0.12112390f, -0.10075752f, -0.01553407f, -0.02879316f, -0.16577783f, 0.22746830f, 
    0.09000295f, -0.02557880f, 0.03674119f, -0.15779731f, -0.10460027f, 0.02761036f, 0.11637658f, 0.00919249f, 
    0.20821407f, 0.03852758f, -0.05690419f, 0.19748236f, 0.23779280f, -0.05636004f, 0.05675921f, 0.13948254f, 
    -0.08311056f, -0.05749343f, -0.09164885f, -0.02710327f, -0.04202718f, -0.19504061f, -0.11692251f, -0.05705998f, 
    0.08173700f, 0.14198013f, 0.06486577f, 0.24427739f, -0.09195841f, -0.05364304f, -0.18454622f, -0.00066899f, 
    0.01694460f, -0.14403647f, 0.18599196f, -0.11305015f, -0.32867050f, 0.26442301f, 0.18044253f, -0.19235732f, 
    -0.00503659f, 0.01144226f, 0.09633134f, 0.00549482f, 0.06648447f, -0.11836166f, 0.01508067f, 0.04187976f, 
    0.19721621f, -0.26563051f, 0.13280924f, 0.04431824f, -0.02309021f, -0.18478161f, 0.08597500f, -0.11336567f, 
    -0.01738488f, -0.21992698f, 0.04055908f, -0.16117616f, -0.11402941f, -0.14598921f, 0.26215035f, 0.05439935f, 
    -0.01570734f, -0.12117466f, -0.00940282f, -0.10450558f, 0.03691195f, 0.04776258f, 0.02073127f, 0.10384039f, 
    -0.23621432f, -0.23449072f, 0.02769580f, 0.28764695f, 0.26546183f, 0.09271086f, -0.07022712f, -0.12767918f, 
    -0.03701925f, 0.16506754f, -0.01613950f, 0.05716988f, -0.16520156f, -0.23027436f, 0.30001327f, 0.04122967f, 
    -0.18041389f, -0.02798697f, -0.11278546f, -0.26836100f, 0.01856525f, -0.13228759f, -0.08356791f, -0.03883249f, 
    -0.16741292f, 0.14218941f, -0.22541174f, -0.16405345f, -0.04515311f, -0.12335438f, -0.04255126f, -0.22136329f, 
    0.14083083f, 0.05148811f, 0.11802747f, -0.03697151f, -0.26954740f, 0.00284149f, -0.02244829f, -0.28645977f, 
    0.04787028f, -0.05938078f, 0.15450288f, -0.07038625f, 0.08809946f, 0.13066693f, -0.22386193f, 0.20375295f, 
    -0.11590575f, 0.32189077f, -0.28276944f, -0.19867609f, 0.12666409f, 0.05791792f, -0.07151160f, -0.04904607f, 
    0.07040153f, 0.01265550f, -0.02340294f, -0.09430504f, -0.03801800f, 0.23432562f, -0.10975962f, -0.24003568f, 
    -0.19924107f, 0.08667681f, -0.37837037f, 0.04339249f, 0.10274585f, -0.01749404f, 0.06661861f, -0.01033588f, 
    0.47912014f, 0.34417233f, -0.51114935f, -0.14253399f, 0.03218183f, -0.05492019f, -0.05601076f, -0.03153499f, 
    -0.07159877f, 0.00452062f, -0.05157376f, 0.17878595f, -0.41968128f, -0.13740554f, -0.00576526f, -0.08806327f, 
    -0.21452217f, -0.10371647f, -0.02856945f, -0.11045200f, 0.15628915f, -0.05499715f, 0.00912158f, -0.12098181f, 
    -0.14479557f, -0.33078760f, 0.19460341f, -0.21009973f, -0.07491590f, -0.01432373f, -0.01864905f, -0.06902833f, 
    -0.01921004f, -0.08235494f, -0.23233856f, -0.11923236f, 0.15576074f, -0.22824262f, 0.18626758f, 0.18507335f, 
    -0.08025228f, -0.00071256f, -0.14878353f, -0.03010399f, 0.25279456f, -0.14978588f, 0.08679453f, -0.09016613f, 
    -0.03905798f, 0.25844944f, 0.00589545f, 0.19386363f, -0.22292691f, 0.10118823f, -0.04997966f, 0.02917393f, 
    0.05752539f, 0.09268624f, -0.06046270f, 0.12119793f, -0.12151165f, -0.24931426f, 0.25612295f, -0.21197964f, 
    0.05530820f, 0.05137010f, 0.01939745f, -0.04940571f, 0.02915236f, -0.13942690f, 0.08494271f, -0.33762124f, 
    -0.21355779f, -0.15133695f, 0.02158111f, -0.02543939f, 0.13327026f, -0.14850265f, 0.00595223f, -0.08226569f, 
    0.15058099f, 0.00574697f, 0.04750941f, 0.08215319f, -0.23710240f, 0.12111859f, -0.32217178f, 0.18490750f, 
    -0.02447720f, 0.06438846f, 0.00783401f, -0.12020238f, -0.01893630f, 0.05418857f, -0.24237439f, -0.08371809f, 
    -0.24568599f, 0.36558667f, 0.25145733f, -0.10554712f, 0.11487016f, -0.07683962f, -0.21134944f, -0.11455137f, 
    -0.11823797f, 0.08801628f, -0.08925540f, -0.08338770f, -0.03871499f, 0.18994339f, 0.13666569f, 0.01338004f, 
    -0.17871627f, -0.00027062f, -0.08463586f, -0.05393760f, 0.12880990f, 0.18108629f, -0.15873726f, 0.13240311f, 
    -0.28178129f, 0.03819429f, 0.31842709f, -0.42335588f, 0.07989863f, 0.26661530f, -0.17713408f, -0.15284927f, 
    0.01265641f, -0.06527872f, 0.01979451f, -0.09498838f, -0.13767147f, 0.22137460f, 0.18320481f, -0.13870181f, 
    0.04579629f, -0.06869392f, -0.00437027f, 0.01421425f, 0.07175584f, -0.09159200f, -0.02666910f, -0.12424299f, 
    -0.12363299f, 0.16624844f, -0.12010068f, -0.26730630f, -0.04726004f, -0.08616923f, -0.04775632f, 0.01534816f, 
    -0.07084355f, -0.07089077f, 0.03990424f, -0.02949849f, -0.13560940f, 0.50701994f, -0.22477449f, 0.00311772f, 
    0.10619059f, 0.11745407f, 0.03613358f, 0.06294856f, 0.09661334f, 0.05305002f, 0.01396014f, 0.10041893f, 
    0.66349840f, 0.05753015f, -0.01654088f, -0.52838570f, 0.16564204f, 0.22379552f, 0.15221637f, -0.02579795f, 
    -0.05094888f, 0.01079427f, -0.20090525f, -0.09348102f, -0.08495197f, 0.12320405f, -0.00120223f, -0.48987097f, 
    0.07153587f, -0.01184124f, -0.05975156f, 0.04622768f, -0.11585916f, 0.04232952f, -0.02451718f, -0.10564329f, 
    -0.41688460f, 0.01665576f, 0.02851347f, 0.00785471f, -0.07979985f, -0.02610531f, -0.04685719f, 0.18993533f, 
    0.05462577f, 0.10445700f, -0.05205609f, 0.17911685f, 0.25029594f, -0.30513790f, -0.44181144f, 0.26698872f, 
    0.00770201f, -0.00298752f, 0.01807723f, 0.19365048f, -0.21155836f, 0.07140294f, 0.04237601f, 0.02193004f, 
    -0.18410663f, 0.24129562f, -0.67728049f, -0.21034071f, 0.20864123f, -0.08942133f, -0.01714598f, -0.03472790f, 
    -0.21649411f, -0.03144114f, -0.25003165f, -0.03374394f, 0.12587944f, 0.13415486f, -0.04613001f, 0.03906789f, 
    -0.00776441f, -0.19393308f, -0.00571709f, -0.09577225f, 0.08667830f, 0.00609077f, 0.17642492f, -0.05671993f, 
    -0.09957426f, -0.34111962f, -0.09986867f, -0.03066458f, -0.09175064f, -0.03106345f, 0.02430369f, -0.02487412f, 
    -0.11013366f, -0.16783199f, 0.06349692f, -0.19437036f, -0.42164454f, -0.29411975f, 0.08111126f, -0.15478560f, 
    0.04141587f, 0.01054042f, 0.07974455f, 0.13919701f, 0.09568392f, 0.03558288f, 0.04968724f, 0.02659982f, 
    0.61664611f, -0.83464271f, 0.28897953f, 0.13813469f, 0.03100242f, -0.08552645f, 0.16705902f, 0.03582491f, 
    -0.06464671f, 0.04284361f, -0.06971600f, -0.02595771f, -0.35186702f, 0.20850836f, -0.03773835f, 0.42758933f, 
    0.14739665f, 0.08569451f, -0.32362422f, 0.04966183f, -0.00575640f, -0.02745484f, 0.03270134f, -0.04106785f, 
    0.17164288f, 0.03735325f, -0.18891340f, -0.12002628f, 0.09968911f, 0.02500846f, -0.01047115f, 0.03410439f, 
    -0.00095212f, 0.15596797f, 0.13488127f, 0.10763426f, 0.32971999f, -0.28857967f, -0.04085106f, 0.15440616f, 
    0.12077174f, 0.02601721f, -0.18723184f, -0.08322324f, -0.06075499f, -0.09086502f, -0.01857904f, 0.17843987f, 
    -0.40305495f, -0.00833096f, -0.06418113f, -0.34219539f, 0.06759588f, 0.05915016f, -0.12875018f, -0.19238211f, 
    -0.08323415f, -0.29227549f, -0.03744490f, -0.00445069f, 0.10160647f, -0.44091612f, -0.14058234f, 0.19886981f, 
    0.13711615f, -0.00654394f, 0.01606644f, 0.10754831f, 0.10427090f, -0.02554663f, 0.08051945f, -0.05184830f, 
    0.12219270f, -0.51556486f, 0.07727583f, -0.11610629f, -0.29853487f, -0.07913707f, -0.06821830f, 0.19056071f, 
    0.03712319f, -0.14101192f, 0.11437839f, 0.00588491f, 0.29122648f, 0.17343169f, 0.01619647f, -0.20414241f, 
    -0.01943067f, -0.25719279f, -0.08962525f, 0.03917273f, 0.00670857f, 0.00434545f, 0.13655432f, -0.18047509f, 
    -0.35274187f, -0.09708177f, -0.07202549f, -0.08209843f, 0.02793400f, -0.01175026f, -0.06293144f, 0.11858135f, 
    0.22355880f, 0.00217515f, 0.14282104f, -0.01650600f, 0.33173969f, 0.12576196f, -0.09267626f, 0.12282199f, 
    -0.01491155f, 0.05580243f, 0.11072730f, 0.25928071f, -0.05732210f, -0.04191418f, -0.20623368f, 0.04585887f, 
    0.44938552f, -0.03686732f, 0.34182894f, 0.02332998f, 0.11249061f, 0.08699432f, 0.02696757f, -0.11921394f, 
    -0.16183610f, 0.17639804f, 0.11490653f, -0.00429512f, -0.12203939f, -0.14465123f, -0.18961357f, 0.06322598f, 
    0.03861352f, 0.08630020f, 0.05641321f, -0.25285310f, 0.13287002f, -0.00847069f, -0.19126956f, -0.11033180f, 
    0.30646122f, -0.05879397f, -0.06850306f, 0.39648259f, 0.08749973f, 0.02332921f, 0.08800218f, -0.04506639f, 
    0.08412384f, -0.03631486f, 0.18781504f, 0.15940334f, -0.65635163f, 0.64077741f, -0.17930788f, -0.10355677f, 
    0.16854921f, -0.10367491f, -0.25454846f, -0.04293124f, -0.04497882f, -0.00993304f, -0.02622025f, 0.11464655f, 
    -0.16327548f, -0.04219462f, -0.01532295f, 0.08656879f, 0.00638603f, 0.09965473f, -0.12099902f, 0.16175963f, 
    -0.08086866f, -0.14777103f, -0.05633635f, -0.07925041f, 0.15581858f, 0.04490604f, -0.11693209f, -0.09726100f, 
    0.06673939f, 0.00935735f, 0.07285456f, -0.02021457f, -0.14959681f, 0.15223946f, -0.01536536f, 0.13689472f, 
    0.15921311f, -0.11372423f, -0.02225097f, 0.11963063f, -0.17368644f, -0.08977893f, -0.01818200f, 0.05864950f, 
    0.15513770f, 0.32834050f, -0.22026090f, 0.09193977f, 0.51503944f, 0.16702655f, -0.20121944f, -0.21771608f, 
    0.15167961f, -0.06386171f, 0.04692555f, 0.01827234f, 0.04825266f, 0.07045855f, -0.11405454f, 0.02958659f, 
    -0.42622119f, -0.43150604f, -0.19120795f, -0.29902375f, 0.13507426f, 0.14768101f, -0.14074357f, -0.01291702f, 
    0.06430641f, 0.11656232f, 0.22359635f, 0.17603579f, -0.37467286f, -0.20139098f, -0.16066644f, -0.24153154f, 
    0.28690109f, -0.04592476f, -0.25134864f, -0.22855869f, 0.01995409f, -0.20678693f, -0.02366332f, -0.04819540f, 
    0.26382428f, -0.00179085f, -0.04583680f, -0.03175298f, 0.11640072f, -0.08736821f, -0.02271762f, 0.12277757f, 
    -0.16848448f, 0.08881364f, -0.00582916f, 0.03909407f, -0.36299464f, 0.14403677f, 0.10245603f, 0.21414785f, 
    0.12495184f, -0.06369393f, -0.01865413f, -0.13200097f, -0.27390996f, -0.07174571f, -0.09852511f, 0.10896647f, 
    -0.11362566f, 0.07482637f, -0.11920179f, 0.17472754f, 0.05845780f, 0.03852922f, -0.06155001f, 0.00349147f, 
    -0.08678409f, -0.00761441f, 0.06582900f, 0.12968095f, -0.25381124f, -0.44468063f, -0.13759008f, 0.01419281f, 
    -0.04122579f, 0.00941943f, 0.16450173f, 0.07722428f, 0.06458730f, -0.04168642f, -0.07266050f, -0.03638184f, 
    -1.02575135f, -0.51766872f, -0.00045211f, 0.12714975f, 0.20800430f, -0.05497942f, 0.03367505f, 0.05961440f, 
    0.07416025f, -0.02936159f, 0.11429650f, 0.25226003f, -0.52603412f, 0.00968468f, 0.32574517f, -0.39633292f, 
    0.09724612f, -0.13610707f, -0.15921275f, -0.04930168f, -0.07196228f, -0.00951592f, -0.01575002f, 0.08427055f, 
    -0.23740177f, -0.18296388f, 0.01484355f, 0.02670773f, 0.10605204f, 0.16220245f, 0.09885940f, 0.05006598f, 
    0.14256991f, 0.16287266f, 0.09424317f, -0.05216581f, -0.00962313f, -0.04502299f, 0.20918596f, 0.01640372f, 
    -0.10203701f, 0.08172559f, 0.03295892f, -0.05251221f, -0.01076789f, -0.18907870f, -0.11499578f, 0.00010839f, 
    -0.28803229f, -0.44259888f, -0.24762999f, -0.57069349f, 0.01295140f, 0.01956048f, 0.04996704f, -0.05460957f, 
    -0.02515878f, 0.11291055f, 0.00645939f, 0.00584835f, -0.23647676f, -0.23127846f, -0.05270452f, -0.08252751f, 
    0.03785887f, 0.03608014f, 0.19906534f, -0.04507742f, 0.18510520f, 0.05309398f, 0.04885200f, 0.20160101f, 
    0.20932825f, 0.17968403f, -0.04112672f, -0.13790502f, 0.07682762f, 0.05297681f, 0.12888139f, -0.03517505f, 
    0.05468236f, 0.22132012f, 0.02046683f, 0.15649836f, 0.12373535f, 0.05032662f, -0.23187587f, -0.14641356f, 
    -0.14042911f, -0.20788917f, -0.11909934f, -0.11333822f, 0.03064454f, -0.22680269f, -0.23709235f, -0.10204960f, 
    0.10336973f, 0.19352211f, -0.10693522f, 0.04884457f, -0.04793645f, 0.07564812f, -0.11845893f, -0.02705174f, 
    -0.12365372f, 0.09109965f, 0.19871528f, -0.15816653f, -0.07926390f, 0.04441224f, 0.00991229f, 0.06922884f, 
    -0.04023279f, 0.17355235f, 0.08004292f, -0.19139270f, 0.12398018f, -0.10107283f, 0.04838840f, -0.16626263f, 
    0.22879720f, 0.04842240f, -0.21182881f, 0.18681651f, -0.06553122f, -0.11212055f, -0.02267031f, -0.03637281f, 
    0.14329171f, 0.03273207f, -0.07880464f, -0.19426383f, 0.43222255f, -0.19018227f, -0.16607732f, 0.12552738f, 
    -0.16039997f, -0.08430341f, -0.13311245f, 0.22363783f, -0.02652320f, 0.09593851f, 0.00363715f, -0.07732426f, 
    -0.51393485f, -0.26849878f, -0.08594121f, -0.18003610f, 0.05983426f, 0.06731375f, -0.08407062f, -0.08500155f, 
    0.11422479f, 0.22065952f, -0.02324966f, 0.05915433f, 0.23460045f, 0.24566402f, 0.06873530f, -0.05376078f, 
    -0.14882874f, -0.30066624f, -0.06763464f, -0.07722200f, -0.13682614f, -0.13834621f, -0.09732763f, -0.11688266f, 
    0.30047092f, 0.14075445f, 0.07539243f, 0.26932025f, 0.03397613f, 0.00463768f, -0.00537447f, 0.17327367f, 
    -0.01769165f, 0.18270141f, 0.17904855f, 0.19776173f, 0.15723394f, 0.31700730f, 0.33065620f, 0.04043873f, 
    0.08411430f, 0.00790369f, 0.10072439f, -0.04325821f, 0.08766090f, 0.07773390f, 0.12242363f, 0.25036347f, 
    0.19846615f, -0.14797497f, 0.10916949f, -0.16644932f, 0.09606999f, 0.07365348f, 0.01195803f, -0.16819847f, 
    -0.04135443f, 0.13669604f, -0.00743343f, 0.00354629f, -0.18252726f, -0.11231530f, 0.03940114f, 0.02792993f, 
    0.05383309f, 0.07420795f, -0.12295233f, -0.09630802f, -0.07710938f, 0.20899825f, 0.15129130f, -0.05060993f, 
    -0.76911455f, -0.26172218f, -0.22702371f, 0.09978282f, 0.16904922f, -0.16109051f, -0.03152785f, 0.03879651f, 
    0.05010805f, -0.09929746f, 0.01902900f, 0.15337814f, 0.37986711f, 0.14702038f, -0.15941158f, 0.01561365f, 
    0.11271443f, -0.03486449f, 0.09174392f, -0.03900362f, -0.11895660f, 0.07162657f, 0.17967127f, -0.07404625f, 
    0.17222284f, 0.01200176f, -0.11415425f, 0.11661243f, -0.08962715f, -0.01539761f, -0.02704188f, 0.02262413f, 
    0.14259268f, -0.03095330f, -0.15334858f, -0.40207335f, -0.31454486f, -0.15659735f, -0.20880327f, -0.09359871f, 
    0.11173895f, 0.02879637f, -0.03200762f, 0.04536851f, 0.03997403f, -0.19274668f, 0.10029956f, 0.03653451f, 
    0.17345387f, -0.06570850f, 0.10830459f, -0.16553766f, -0.10685069f, -0.05633715f, 0.03548510f, -0.04869835f, 
    -0.03032281f, -0.06471604f, -0.01884046f, 0.00892777f, -0.00049494f, 0.12541278f, 0.01599086f, -0.16363430f, 
    -0.11658338f, 0.10508098f, -0.02058219f, -0.08523262f, 0.00246648f, -0.04597225f, 0.07500456f, -0.12156822f, 
    -0.00777629f, -0.04015873f, 0.09111514f, 0.13259313f, -0.03442978f, 0.07103798f, -0.11346190f, -0.06374934f, 
    -0.02965505f, 0.01910749f, 0.12649055f, -0.15053114f, 0.15337601f, -0.18097575f, -0.30799040f, 0.03411746f, 
    0.29331949f, -0.18033193f, 0.13954236f, 0.04866814f, 0.06446283f, -0.02000351f, -0.02649562f, -0.04058407f, 
    0.25876221f, 0.00580565f, -0.44454917f, -0.02365458f, 0.06563967f, -0.00717476f, 0.06228843f, 0.05541567f, 
    -0.06667352f, -0.00197065f, -0.24834158f, -0.00810550f, 0.40315399f, -0.27911580f, -0.02022062f, -0.26098394f, 
    0.08531696f, 0.13795207f, -0.05027440f, 0.08601909f, 0.00105928f, 0.06863475f, 0.13856918f, 0.09902044f, 
    0.59656024f, 0.03189202f, -0.20835967f, -0.04428437f, 0.02326977f, -0.09270078f, 0.15930004f, -0.05258702f, 
    -0.03603705f, -0.03917459f, -0.04040528f, 0.08850080f, 0.44253162f, -0.23359095f, -0.04773778f, 0.17384370f, 
    -0.03225862f, -0.09804063f, -0.19585335f, -0.23860903f, 0.14039537f, 0.01281384f, -0.03265496f, -0.00403024f, 
    -0.07767574f, 0.17919433f, 0.06658112f, 0.09851097f, 0.08026689f, 0.05208192f, -0.02622584f, -0.03069903f, 
    -0.01317390f, -0.03540787f, -0.02949332f, -0.07008614f, -0.59982991f, -0.60099626f, -0.20237334f, -0.24147990f, 
    0.07127725f, 0.09077147f, 0.18003365f, 0.09703524f, -0.06080198f, 0.13408695f, 0.03002982f, -0.04074213f, 
    0.37972677f, -0.47438645f, -0.14260407f, -0.16800942f, 0.06410601f, -0.13390914f, 0.00061394f, 0.18183999f, 
    -0.09155167f, -0.07985944f, -0.06818309f, -0.12663457f, 0.33330545f, 0.17168844f, -0.19458355f, -0.10669131f, 
    0.02202572f, -0.05342671f, -0.06158421f, -0.03107892f, 0.07770071f, 0.01927697f, -0.06791573f, -0.10787944f, 
    0.74950987f, 0.09414139f, -0.03917826f, 0.06662535f, 0.27332959f, -0.06747848f, -0.16706204f, -0.01726109f, 
    -0.03744978f, 0.06082235f, 0.10762645f, 0.07071575f, -0.28462088f, 0.31874317f, 0.05469789f, 0.00759680f, 
    0.00711224f, -0.08271059f, -0.03214059f, -0.07255145f, -0.10392050f, 0.00395007f, -0.04321979f, -0.06792747f, 
    -0.12456332f, -0.32005644f, -0.05506851f, -0.10857817f, -0.02521114f, -0.01464508f, 0.04986635f, -0.10569040f, 
    -0.05607742f, -0.03456694f, -0.10232400f, -0.10644269f, -0.05052654f, 0.17119782f, -0.05179792f, -0.23413599f, 
    0.11820091f, -0.01606704f, -0.17703691f, 0.22087261f, -0.10366402f, 0.04366885f, 0.01679002f, -0.00285006f, 
    -0.10291889f, 0.22985414f, 0.09327627f, -0.04672843f, -0.01969443f, 0.29513204f, -0.07402226f, -0.01607370f, 
    0.02480911f, -0.01835926f, -0.16368508f, -0.21933952f, -0.33083987f, -0.48150104f, -0.12165764f, -0.09742816f, 
    -0.03724030f, 0.18951270f, 0.02996153f, 0.20845510f, -0.14122432f, -0.05407104f, -0.05116444f, -0.08110042f, 
    -0.20487873f, 0.30661470f, -0.09847643f, 0.10561393f, -0.06395377f, 0.07197195f, -0.10599387f, 0.16013940f, 
    -0.01834136f, 0.04482220f, 0.08951742f, -0.24122584f, 0.33176818f, 0.01949445f, -0.21516490f, 0.02032744f, 
    -0.04381643f, -0.19962490f, -0.01108038f, -0.13021488f, -0.11512923f, 0.01588590f, 0.02643266f, 0.04989932f, 
    -0.71495664f, -0.04063923f, -0.31192234f, -0.05052276f, 0.13499917f, 0.08742203f, 0.05795253f, -0.05231453f, 
    0.04410690f, 0.14063883f, -0.02812599f, 0.05477742f, 0.05994495f, 0.24751191f, 0.13705565f, -0.08725403f, 
    -0.02866059f, -0.20042902f, -0.02260780f, 0.08980373f, -0.24684826f, -0.09240346f, -0.07370689f, 0.03349762f, 
    0.40288231f, 0.13078880f, -0.40026367f, 0.15905507f, 0.12528786f, 0.05083198f, -0.06859901f, 0.07791734f, 
    0.09380514f, -0.01789553f, -0.09896570f, -0.00010039f, -0.06578632f, 0.07856330f, -0.13618828f, -0.07811312f, 
    -0.06861589f, 0.08524561f, 0.19097261f, 0.06026627f, -0.12021762f, -0.01089610f, 0.11981954f, -0.01226779f, 
    -0.26901740f, 0.05734762f, -0.24669729f, -0.16783944f, 0.04271596f, 0.07163826f, 0.02442846f, -0.06671344f, 
    0.00168188f, 0.01647990f, 0.03332342f, 0.00498365f, 0.21248600f, -0.25356936f, -0.14278607f, -0.18381812f, 
    0.03104125f, -0.09482357f, -0.05976648f, 0.14206116f, -0.19961038f, 0.08616833f, -0.06063672f, -0.08727455f, 
    -0.09086797f, -0.07643767f, -0.19940095f, 0.44615653f, 0.22581089f, -0.01069581f, 0.01226184f, 0.04362502f, 
    0.01106813f, -0.01130978f, -0.05710591f, 0.16212457f, -0.00022855f, -0.17499624f, -0.08039468f, -0.07192968f, 
    -0.06937873f, -0.18434869f, 0.07233965f, -0.17234048f, -0.19069490f, -0.01445203f, -0.09683923f, -0.19374052f, 
    0.62533051f, -0.20458724f, -0.00572179f, 0.09724109f, -0.14778458f, -0.09387340f, 0.01148791f, -0.07248156f, 
    0.22258309f, 0.11975080f, 0.12604527f, 0.11254313f, 0.12458289f, 0.33564320f, -0.12063646f, -0.00473064f, 
    -0.19524065f, -0.11861009f, -0.02405891f, 0.08600204f, 0.09836128f, -0.10206082f, -0.01525366f, 0.03538812f, 
    -0.39349020f, -0.16081150f, 0.05956293f, -0.08341325f, -0.02834567f, -0.10762569f, -0.07683972f, 0.01296401f, 
    0.06239064f, 0.10854165f, 0.18770902f, 0.27113795f, 0.15934029f, -0.30292884f, 0.04101682f, -0.06374289f, 
    -0.07283087f, 0.04677057f, 0.12188553f, -0.05603239f, 0.02350920f, 0.01335231f, -0.07050452f, 0.05179965f, 
    -0.27843541f, 0.23152396f, 0.08897968f, 0.09744526f, -0.04227271f, -0.05283529f, 0.00868737f, -0.03879723f, 
    -0.03063340f, 0.07397778f, 0.07209798f, -0.11103529f, -0.33111489f, 0.34851778f, -0.05664346f, -0.03721583f, 
    -0.25066897f, -0.08130353f, -0.08128824f, -0.22588548f, 0.12257241f, 0.14374715f, 0.00307663f, -0.23021697f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12606175f, 0.05634422f, -0.05794406f, -0.00795337f, 0.01570335f, 0.02442746f, 0.04053460f, -0.05382400f, 
    -0.02184994f, -0.02373118f, 0.13582358f, 0.07730705f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
