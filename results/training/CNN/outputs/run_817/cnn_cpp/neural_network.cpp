#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.92462045f, 0.50259435f, -0.37301025f, -0.62154955f, 0.22131461f, 0.09339835f, 0.83010548f, 0.45567504f, 
    0.42435139f, 0.66206765f, 0.01739383f, -0.23379007f, -0.06751262f, -0.47748700f, 0.12324386f, 0.59128696f, 
    0.22757600f, 0.12310708f, 0.45941254f, -0.22697781f, -0.16169864f, -0.08265687f, 0.06095877f, -0.09760228f, 
    0.48477793f, -0.14819697f, -0.84828436f, -0.82788628f, -0.49772266f, -0.16713542f, 0.13072798f, 1.06904197f, 
    -0.06350268f, 0.24888401f, 0.63878232f, 0.33666894f, -0.24351819f, -0.24622804f, -0.01433389f, -0.01488676f, 
    -0.12570810f, 0.20581760f, -0.01652923f, -0.15901367f, -0.09480712f, -0.04199171f, 0.31344986f, 0.22821930f, 
    0.33930978f, 0.02040906f, -0.75165242f, -0.00252728f, -0.00457356f, -0.84090394f, -0.42072371f, -0.27711391f, 
    -0.22492769f, 0.65718460f, 0.54429793f, -0.51195437f, 0.18881810f, 0.28676790f, -0.06725811f, 0.07714679f, 
    -0.09383473f, -0.07518512f, -0.18507047f, -0.34865046f, -0.12142786f, 0.20705383f, 0.16247979f, -0.43045083f, 
    0.34949878f, -0.04261184f, -0.13482460f, 1.05536568f, 1.02330458f, -0.67352480f, -0.16520862f, 0.81505698f, 
    -0.02874778f, 0.33358356f, 0.03170051f, 0.30486378f, 0.41885775f, -0.00886851f, 0.02928475f, -0.04706302f, 
    -0.24421829f, -0.32756025f, -0.05137552f, 0.21001756f, 0.04159351f, 0.04150211f, 0.36013022f, -0.23759454f, 
    -0.04315863f, 0.09587341f, -0.07809868f, 0.01884468f, -1.00120294f, -0.18167225f, 0.13579068f, -0.24108779f, 
    -0.54830182f, 0.59828836f, 0.69028258f, 0.12180568f, -0.03065956f, 0.53803062f, 0.25835148f, 0.30879197f, 
    0.02711464f, -0.01704908f, 0.17610216f, 0.17700681f, -0.02022848f, 0.11470585f, 0.07158791f, -0.17334659f, 
    0.11503605f, -0.06116113f, 0.14517555f, 0.17432083f, 0.14281344f, -0.78215671f, 0.74567288f, 0.13944782f, 
    -0.47824460f, 0.34648985f, -0.57666141f, 0.77994198f, -0.27977273f, -0.55532986f, -0.55991125f, -0.52288884f, 
    0.03422326f, 0.03474209f, -0.30867344f, 0.03938169f, 0.03201943f, -0.10057925f, -0.04959632f, -0.09313557f, 
    -0.31977719f, -0.09116881f, -0.10325383f, -0.13869178f, -0.00226659f, 0.30542818f, -0.67436939f, -0.29964411f, 
    -0.57480800f, -0.24801059f, -0.54178649f, 0.52963471f, 0.87057739f, -0.60061496f, 0.25015494f, 0.59625471f, 
    -0.18691744f, -0.13021062f, 0.16251288f, -0.13063258f, -0.29029301f, -0.18755423f, 0.34978089f, 0.03468515f, 
    -0.18404563f, 0.04297386f, 0.10050919f, -0.34095776f, -0.23723345f, -0.15731791f, -0.09595563f, 0.62704378f, 
    0.27099365f, 0.23072360f, -0.18454500f, 0.44715315f, -0.30129522f, 0.79319286f, 0.80847037f, 0.19105944f, 
    0.62595719f, -0.60335279f, -0.36088237f, -0.45523173f, -0.08290526f, -0.38182265f, -0.14408424f, -0.02786902f, 
    0.17218967f, 0.05122560f, -0.21954453f, 0.19876179f, 0.08519369f, -0.11818998f, -0.02797315f, -0.20835999f, 
    0.50235611f, 0.48366597f, 0.75424486f, 0.38281175f, -0.17901830f, 0.19067934f, -0.28778115f, -0.00148357f, 
    0.39814654f, 0.87187988f, 0.07916670f, -0.09836920f, -0.18423939f, -0.21055470f, -0.27713817f, -0.40397784f, 
    -0.36252758f, 0.26867712f, -0.12408259f, -0.09646600f, 0.01389941f, -0.04440666f, 0.18341850f, 0.51173782f, 
    0.37493706f, -0.86826253f, -0.16525924f, -0.35658205f, -0.11735639f, 0.34534714f, -0.92264801f, -0.31107095f, 
    -0.11676984f, -0.01144652f, -0.67619801f, 0.24734527f, 0.03873472f, 0.32492995f, 0.39625242f, 0.08260816f, 
    0.52596378f, 0.15505703f, 0.12537038f, 0.29016662f, -0.00025181f, -0.22779305f, 0.11969294f, 0.03853918f, 
    0.15952961f, 0.16648084f, 0.42674592f, 0.91006726f, 0.81493354f, 0.54293197f, 0.19832692f, -0.58629966f, 
    0.52716690f, -0.45275605f, -0.24100380f, -0.20198055f, -0.00911103f, -0.01271921f, -0.00604034f, 0.34125128f, 
    0.35433522f, 0.28009742f, 0.47384721f, -0.08924391f, 0.19429889f, -0.07451794f, 0.26834476f, 0.04069143f, 
    0.30548400f, 0.26373950f, 0.07723875f, -0.02478951f, 0.23290734f, 0.74455941f, 0.11431243f, -1.22884905f, 
    -0.67163593f, -0.48451376f, -0.52645600f, -0.39512172f, 0.13582279f, 0.29924166f, 0.58093619f, 0.17524251f, 
    -0.06157894f, -0.20310506f, 0.01506482f, 0.11259610f, -0.01988268f, 0.13787165f, -0.09218932f, 0.36148188f, 
    0.23067582f, -0.07188401f, 0.15764935f, -0.07151544f, 0.62655795f, 0.22619541f, 0.13347717f, 0.03283048f, 
    -0.11586103f, 0.61855662f, -0.31455833f, 0.24930605f, 0.62942839f, 0.89601433f, 0.34462810f, 0.22732162f, 
    0.11394954f, 0.42957976f, 0.28323793f, 0.35797679f, -0.14981446f, -0.40318424f, -0.03356865f, 0.01453087f, 
    0.43632776f, -0.14448801f, 0.19329959f, -0.09291009f, -0.20943138f, 0.23317204f, -0.07607517f, 0.18627097f, 
    1.17192876f, 0.55044103f, -0.15839329f, -0.25860834f, 0.40717652f, 0.32717678f, -0.39702991f, -0.34381306f, 
    -0.40013495f, -0.47334403f, -0.32145026f, 0.06402440f, 0.11676862f, 0.01094373f, -0.08621702f, -0.18767224f, 
    0.15426935f, 0.25622630f, 0.43668383f, 0.03410793f, 0.02240415f, -0.38910738f, 0.98399806f, 0.56848925f, 
    0.18542419f, 0.52133179f, 0.56168556f, -0.38371801f, -0.53323227f, -0.50158256f, 0.27850935f, 0.09761166f, 
    -0.10376389f, -0.45539176f, -0.02516463f, -0.12390626f, -0.11790788f, -0.42150918f, -0.29674524f, -0.31184271f, 
    0.40187708f, -0.49119970f, 0.01448645f, 0.47575396f, -0.45590869f, -0.02221716f, -0.04993843f, -0.23289286f, 
    0.26476994f, 0.29406083f, 0.70391697f, 0.67924321f, -0.92999160f, 0.04381426f, -0.38315123f, -0.42715552f, 
    -0.04839700f, 0.67571586f, 0.08713713f, 0.06187750f, 0.28615868f, 0.12830484f, -0.20033590f, 0.39522687f, 
    0.33787614f, 0.08316661f, 0.17820495f, 0.43041003f, -0.06783174f, -0.04496467f, 0.20757927f, 0.14191359f, 
    -0.53515100f, 0.27529445f, 0.18575445f, -0.69707024f, 0.88716167f, 0.66388011f, -0.57676423f, -0.97306424f, 
    -0.49166340f, -0.28161249f, 0.24233416f, -0.05031919f, 0.36847728f, -0.01748091f, -0.20725346f, -0.30380183f, 
    -0.48463258f, -0.30705914f, -0.26471087f, 0.09261215f, 0.47885734f, 0.10856052f, -0.04852442f, -0.06648565f, 
    -0.12462083f, 0.45324245f, 1.11940837f, -0.58611387f, -0.49521142f, -0.78508025f, 0.68046278f, -0.17463791f, 
    -0.60357803f, -0.22388229f, -0.39772460f, 0.56618553f, -0.21522574f, -0.00639967f, 0.04543015f, -0.06608247f, 
    0.46267107f, -0.34371239f, 0.17344816f, 0.03013898f, 0.20228994f, 0.02648899f, 0.08017927f, 0.12811002f, 
    -0.32512960f, 0.23642395f, -0.13038063f, -0.56127369f, -0.73203325f, -0.88392979f, -0.54645485f, -0.20418449f, 
    -0.39812425f, 0.09364934f, -0.20433615f, -0.10658842f, -0.06635311f, -0.31697339f, -0.08000885f, 0.08589186f, 
    -0.08764844f, 0.30315048f, 0.07713842f, -0.31412232f, 0.21684802f, 0.15669332f, 0.01735994f, -0.12310503f, 
    0.27591097f, -0.16415986f, -0.01900169f, 0.24510348f, -0.01166851f, -0.42434821f, 0.04906648f, 0.10049399f, 
    0.26285568f, -0.15120383f, -0.10573950f, 0.55260390f, -0.03951448f, -0.65683007f, -0.12769811f, -0.33369654f, 
    -0.65809143f, -0.29511452f, 0.40496469f, -0.26776135f, -0.02296980f, 0.02775028f, 0.07790229f, -0.53222674f, 
    -0.28965282f, -0.33480707f, -0.21902944f, -0.65881616f, 0.20724216f, 0.09202198f, 0.19185439f, 1.01536655f, 
    0.53288108f, 0.91836411f, 0.20193109f, -0.50728422f, -0.21245609f, 0.03237864f, -0.35438165f, -0.16987090f, 
    -0.07036392f, 0.37985995f, 0.02651314f, -0.18949059f, -0.10146502f, 0.23346737f, 0.11538994f, -0.11056604f, 
    0.02502157f, -0.01152724f, -0.35153970f, -0.19619021f, -0.28159475f, -1.49162245f, 0.43096676f, 0.41941276f, 
    0.06914994f, 0.41272956f, 0.02266663f, 1.12837875f, 0.36572441f, -0.01389330f, 0.41436395f, -0.19202310f, 
    -0.13614383f, 0.45486128f, -0.20389234f, -0.13082688f, -0.08418018f, -0.17106639f, 0.03444859f, 0.00554271f, 
    -0.02273506f, 0.11735205f, 0.43583092f, 0.12553942f, 0.32988477f, -0.19001301f, 1.33909035f, 0.29231256f, 
    0.04025775f, 1.00304461f, 0.55944586f, 0.54052490f, 0.45473826f, 0.02826857f, 0.22738427f, -0.30901158f, 
    -0.43207636f, -0.18495534f, 0.04909797f, 0.02485767f, -0.29126531f, 0.13031749f, 0.32258666f, 0.21959427f, 
    0.07370492f, 0.29582450f, -0.12642795f, -0.06708915f, 0.09559465f, 0.07675507f, 0.24057099f, -0.13046117f, 
    0.64849442f, 1.00965881f, 0.33246434f, 0.33088756f, 0.50539619f, 0.15845388f, -0.84577698f, 0.55437773f, 
    -0.28128880f, 0.07057361f, -0.12286502f, 0.04777600f, 0.01109966f, -0.45783004f, -0.00151237f, 0.14492355f, 
    -0.11654256f, -0.24911635f, -0.18420209f, -0.00564715f, 0.12864488f, -0.02157508f, 0.08705367f, -0.13829108f, 
    0.86207992f, 0.71444863f, 0.71217334f, 0.42936039f, 0.31598124f, -0.01024210f, 0.44511342f, -0.28749242f, 
    -0.53568166f, -0.01887405f, 0.09309366f, 0.35280636f, -0.19503127f, 0.02762822f, 0.12985784f, -0.18307340f, 
    -0.42527953f, -0.01617564f, -0.06782714f, -0.30008796f, -0.15938014f, 0.46892768f, 0.12405115f, 0.21343414f, 
    0.42709029f, 0.10726555f, -0.20881791f, -0.01023577f, -0.77856213f, -0.39923286f, -0.11996748f, -0.71420681f, 
    0.27017695f, 0.76774794f, -0.17432536f, -0.20213169f, 0.20535159f, -0.08065002f, -0.41911975f, -0.49843922f, 
    0.18735121f, -0.12476986f, 0.41295928f, -0.09314138f, -0.02747501f, 0.44661915f, 0.23912106f, -0.27481666f, 
    -0.10706867f, -0.17272165f, -0.16055223f, 0.11275882f, -0.65033799f, -0.72113717f, 0.14489549f, -0.06839699f, 
    -0.65542042f, -0.74426430f, 0.06440403f, 0.25209510f, -0.53415877f, -0.18257891f, 0.52749163f, 0.16774286f, 
    0.11010924f, -0.33114523f, 0.25585395f, 0.45588064f, 0.48706049f, 0.32364276f, -0.06133725f, 0.06785253f, 
    0.06612684f, -0.26914993f, 0.14265309f, 0.68250960f, 0.41724089f, 0.62093943f, 0.76314330f, 0.34589750f, 
    -0.68585461f, -0.39660025f, -0.33836785f, -0.40339047f, 0.08344430f, 0.50292099f, 0.06298343f, 0.22965884f, 
    0.15694031f, -0.44994989f, 0.43880507f, -0.37366727f, 0.03004630f, -0.25463486f, 0.34792942f, -0.22867459f, 
    -0.28250402f, 0.27223849f, -0.27546409f, -0.25693294f, 0.65690458f, 0.64834607f, -0.67146695f, -0.74443281f, 
    -1.12007833f, 0.40607217f, 0.53822333f, -0.59959799f, 0.10721421f, 0.11703734f, 0.21845523f, 0.27360764f, 
    0.10377268f, 0.16705804f, 0.06956622f, 0.08350331f, 0.11802500f, 0.38239720f, 0.17183177f, -0.37977490f, 
    -0.16174538f, -0.20572776f, 0.17707275f, -0.00314176f, -0.12284077f, -0.07159865f, 1.14644337f, 0.94967109f, 
    -1.03712928f, -0.47472745f, -0.26023945f, 0.48722845f, 0.25494483f, -0.21639559f, -0.08450506f, 0.09274796f, 
    0.22771084f, -0.12973270f, 0.30143735f, 0.14993143f, -0.15694030f, -0.02425668f, -0.16381970f, -0.03626431f, 
    -0.13929453f, 0.17274298f, 0.18453136f, 0.26349282f, 0.08683001f, -0.08420014f, 0.38215503f, -1.14591515f, 
    0.13832845f, 0.30468082f, -0.02948098f, 0.49652585f, 0.85187095f, 0.56620538f, 0.49248582f, 0.33665514f, 
    -0.29460901f, 0.29881108f, -0.41819608f, 0.38625279f, -0.16918460f, 0.17986864f, -0.37310031f, -0.49202701f, 
    0.01443036f, -0.06972859f, -0.02915973f, -0.06840104f, -0.12186723f, 0.14663441f, -0.15514685f, 0.46865204f, 
    -0.41138881f, -0.29263389f, 0.91739982f, 0.88432312f, -0.71535259f, -0.27068090f, -0.06934784f, -0.69777811f, 
    0.15363389f, 0.24244359f, 0.24482419f, -0.30889022f, 0.02349071f, 0.35659960f, 0.19604050f, 0.25742674f, 
    0.23813714f, 0.37916127f, 0.47600234f, 0.29092944f, 0.03404113f, -0.06526961f, 0.03652276f, 0.31930196f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07457093f, 0.12935890f, 0.12381793f, 0.18446733f, -0.06497402f, 0.07194021f, 0.11700934f, 0.16974588f, 
    0.25799900f, 0.31912813f, -0.02240264f, 0.05551606f, 0.28231475f, -0.08432943f, 0.09749527f, 0.22700408f, 
    0.30448762f, 0.14691508f, 0.01383009f, -0.13167447f, 0.19622920f, 0.17481796f, 0.12102171f, 0.20040739f, 
    0.33320352f, 0.29141140f, 0.30589268f, 0.15333286f, 0.10950767f, 0.15568829f, 0.36626971f, 0.22502251f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05468804f, -0.02661318f, -0.05635701f, -0.03795731f, 0.02173341f, -0.03881488f, 0.02563291f, -0.02298628f, 
    0.03369848f, -0.03856757f, -0.02272648f, 0.03794182f, 0.00104611f, -0.05397540f, 0.02477296f, 0.01359202f, 
    -0.00734047f, -0.00771949f, -0.04262552f, -0.00691392f, 0.01361217f, -0.02939046f, -0.03980342f, -0.01611654f, 
    0.01499410f, -0.05373164f, 0.00375375f, -0.00044797f, -0.04998095f, 0.00990865f, 0.01969152f, -0.01711041f, 
    0.03993884f, -0.04604321f, 0.02346719f, -0.00284819f, 0.00698483f, -0.01311917f, 0.00121151f, -0.04222298f, 
    0.02210481f, -0.04017458f, -0.00968748f, -0.04327658f, -0.00671666f, -0.03263218f, 0.03759370f, 0.02783700f, 
    0.02966345f, -0.03286957f, -0.00465447f, -0.05099370f, -0.00456839f, 0.03815642f, -0.03499207f, 0.03525294f, 
    -0.00788150f, 0.03459540f, -0.04110609f, -0.00399412f, -0.01090593f, -0.03685517f, 0.01799089f, 0.00509059f, 
    -0.00436175f, -0.04263772f, -0.03259917f, -0.04327445f, -0.03114280f, 0.02610318f, 0.00248736f, -0.01619309f, 
    0.02991179f, 0.00532065f, -0.02010634f, -0.00281104f, -0.00851795f, -0.04441741f, 0.00890392f, -0.00509222f, 
    -0.02139551f, 0.03061713f, 0.01232176f, -0.00471902f, -0.03503270f, -0.01549153f, 0.03800234f, 0.00215854f, 
    -0.04994902f, -0.04903376f, -0.01942638f, 0.00326229f, 0.03426071f, 0.02782240f, -0.04558260f, -0.04257551f, 
    0.04405952f, -0.04025933f, -0.02702720f, -0.01473423f, -0.02559130f, -0.05031080f, -0.03365628f, -0.03386214f, 
    0.02183998f, -0.00136901f, -0.04212310f, -0.00262328f, -0.01329013f, 0.00677662f, 0.04395262f, -0.00392374f, 
    0.04170115f, 0.01688968f, -0.05007172f, -0.02607004f, -0.03462556f, 0.04348981f, -0.01027179f, -0.01019530f, 
    -0.03135948f, 0.03709570f, -0.04160739f, 0.01407720f, -0.01769646f, -0.01329157f, -0.03189144f, -0.00837769f, 
    -0.00397920f, 0.00836821f, -0.05202835f, -0.01462975f, -0.01877560f, -0.01048662f, -0.02230178f, -0.01418843f, 
    -0.02966239f, -0.02351414f, 0.01359945f, -0.00113004f, 0.04810384f, -0.03607640f, 0.03631761f, -0.03289546f, 
    0.02836686f, 0.02577958f, -0.03536375f, -0.02798666f, -0.02602644f, -0.00829684f, -0.03561948f, -0.05616589f, 
    -0.01194684f, 0.01480191f, 0.02267836f, -0.01154254f, -0.04937792f, 0.01687604f, -0.02840223f, -0.04613490f, 
    -0.03601437f, 0.02404789f, 0.00016073f, 0.02290828f, 0.04539899f, 0.02871800f, -0.03369645f, -0.01507794f, 
    -0.04397753f, 0.02253955f, -0.00462186f, -0.02604004f, 0.01894971f, -0.00495754f, 0.00866168f, 0.04181594f, 
    0.02615474f, -0.04163097f, 0.01870613f, -0.03213143f, 0.03467191f, -0.04832036f, -0.05387579f, -0.01335432f, 
    -0.05445206f, 0.03648488f, 0.00465079f, 0.03360400f, 0.04178489f, -0.04652125f, 0.03843900f, -0.00855082f, 
    -0.04622940f, -0.02026911f, 0.00162209f, 0.02237153f, -0.01716090f, -0.00944185f, 0.01864230f, 0.03803620f, 
    0.00212372f, -0.00448838f, -0.01915937f, 0.02466570f, 0.00647481f, 0.02672799f, 0.04367637f, -0.03348303f, 
    0.00548992f, -0.05197251f, 0.01823023f, 0.04496244f, -0.01579438f, 0.02852008f, 0.02096615f, -0.01591682f, 
    -0.04055780f, 0.02618607f, 0.01298136f, -0.03766067f, 0.03337516f, -0.02649249f, -0.02148131f, 0.00845515f, 
    -0.01765904f, -0.02410434f, 0.04331012f, -0.04784950f, 0.03821858f, -0.03789309f, -0.03891006f, 0.00744965f, 
    -0.03695901f, 0.00665823f, -0.01917642f, -0.01925188f, 0.03590553f, -0.01640131f, 0.02503483f, -0.02280981f, 
    -0.02582087f, 0.01900128f, -0.02594438f, -0.00543853f, -0.01648950f, -0.01867516f, -0.05273423f, -0.04265057f, 
    -0.03015976f, -0.00172332f, 0.03749410f, -0.05196618f, -0.01255638f, -0.01125826f, -0.03711643f, 0.04629316f, 
    -0.02906998f, -0.05564708f, -0.04448370f, -0.01515282f, -0.00284050f, -0.02910659f, -0.04623246f, 0.00967732f, 
    0.03504139f, -0.03478862f, -0.00779233f, -0.05418216f, -0.02388258f, -0.04507092f, -0.02795130f, -0.01550265f, 
    -0.03869328f, -0.02981400f, -0.02680522f, 0.00891627f, 0.03840717f, -0.01460455f, -0.00614651f, -0.00232931f, 
    0.03997558f, 0.01450779f, -0.04075241f, 0.02951370f, -0.03994131f, 0.00812796f, -0.04331957f, -0.01123402f, 
    -0.04447260f, 0.01045795f, -0.02128782f, 0.01347154f, -0.04110150f, 0.02218438f, 0.04123783f, -0.03955329f, 
    -0.00487610f, 0.00270016f, 0.01434017f, 0.01227569f, -0.01010181f, -0.00427678f, 0.03552708f, -0.01101467f, 
    -0.04435129f, 0.03421193f, -0.00928542f, -0.00808965f, -0.05401307f, 0.02522453f, 0.01698587f, -0.05563604f, 
    -0.05293591f, -0.05158736f, 0.04733707f, -0.05609734f, 0.04348081f, -0.05140101f, 0.01449360f, -0.01167248f, 
    -0.01174676f, -0.00831591f, 0.01088620f, -0.04794292f, -0.05244794f, -0.02599295f, -0.03391236f, 0.03406637f, 
    -0.03449745f, 0.02225694f, -0.02329565f, 0.02639974f, -0.03747877f, 0.03169899f, -0.02775082f, 0.01008848f, 
    -0.03382453f, -0.01052545f, 0.03082907f, 0.04263319f, -0.01389027f, -0.01018502f, -0.02524202f, 0.03678971f, 
    -0.02545342f, -0.01239153f, 0.03454992f, -0.01999739f, -0.04304330f, 0.00466629f, -0.01073179f, 0.04010571f, 
    -0.02144518f, -0.01581053f, -0.04951598f, -0.01143037f, 0.03776778f, 0.03498584f, 0.04251411f, 0.02557541f, 
    0.04051303f, -0.01895753f, -0.00767699f, 0.02954838f, -0.01730145f, 0.02681435f, -0.02328102f, 0.01514859f, 
    -0.02334771f, 0.02958585f, 0.04153678f, 0.04445651f, 0.02381476f, -0.03152181f, -0.05302572f, -0.05263442f, 
    -0.01070577f, 0.00847584f, -0.02321643f, 0.02710741f, 0.01566371f, -0.03231630f, -0.01915158f, -0.01496269f, 
    -0.05300385f, -0.03707601f, -0.04186402f, 0.03135252f, 0.04695599f, 0.00656242f, 0.03162424f, 0.01853757f, 
    0.03615613f, 0.00281281f, 0.03081512f, -0.00835816f, -0.04153434f, 0.03416399f, -0.02002741f, -0.04058035f, 
    0.03859428f, -0.01432885f, -0.03874749f, -0.00832000f, 0.02834949f, -0.01153880f, -0.04853811f, 0.01133175f, 
    -0.05497767f, -0.03461451f, -0.03032676f, -0.00891380f, 0.00969945f, -0.00377940f, -0.02966939f, 0.04022796f, 
    -0.01759338f, -0.03726288f, -0.03625367f, 0.02856762f, -0.02285541f, -0.04622626f, 0.00999952f, 0.00434820f, 
    -0.01835258f, 0.03147093f, 0.03631730f, -0.00727938f, -0.01719311f, -0.05388704f, -0.02043151f, -0.05486042f, 
    0.02092827f, 0.01356491f, -0.00531152f, -0.04897813f, 0.00741290f, 0.01238328f, 0.01750375f, -0.03321639f, 
    0.00822334f, -0.02881258f, -0.05084334f, 0.03682429f, -0.00037029f, -0.02915394f, -0.01564611f, -0.04461777f, 
    -0.02773101f, 0.02179135f, -0.01305068f, -0.02531690f, 0.00031792f, -0.01536503f, 0.04354459f, -0.00030465f, 
    -0.02725393f, -0.01725068f, 0.02574500f, 0.03780533f, -0.00322196f, -0.00025596f, 0.01374986f, 0.02679471f, 
    -0.00777039f, -0.01858347f, 0.03221928f, -0.04995211f, -0.03129656f, 0.02877792f, 0.02058695f, -0.03531952f, 
    -0.04481648f, -0.01067023f, -0.03862598f, -0.00003770f, 0.00156377f, 0.02082737f, 0.00751646f, 0.03345546f, 
    -0.01557708f, 0.03853541f, 0.02477712f, -0.00602050f, 0.01865245f, 0.01961398f, -0.03979971f, 0.04193274f, 
    0.01451075f, -0.01722584f, 0.03377848f, -0.00326272f, -0.03133273f, -0.00762975f, 0.02377067f, 0.00832323f, 
    -0.05725998f, -0.01025958f, 0.03880056f, -0.00977240f, -0.01805100f, 0.02867103f, -0.04035932f, 0.02368348f, 
    -0.05428899f, -0.01895525f, -0.04404173f, -0.03528556f, -0.02998838f, -0.01766705f, -0.01438396f, 0.02926626f, 
    0.02240117f, -0.02971199f, 0.04412206f, -0.04124435f, -0.01930549f, -0.04699054f, -0.05524623f, 0.02091843f, 
    0.04234065f, -0.00063959f, 0.02574624f, -0.04667963f, 0.01075670f, -0.03996477f, 0.01888869f, -0.04618663f, 
    -0.03549699f, 0.02542175f, -0.02635374f, -0.01482830f, -0.04828010f, 0.00053631f, 0.01476677f, 0.03429867f, 
    -0.00654527f, -0.04843408f, -0.02454575f, -0.01532924f, 0.00945795f, -0.01559060f, -0.01776888f, -0.00488491f, 
    -0.02619305f, 0.00930974f, -0.02925786f, -0.02846885f, 0.00822735f, 0.02823600f, 0.01343035f, -0.00711838f, 
    0.01696710f, 0.01885458f, 0.01319762f, -0.03396572f, -0.02726169f, -0.00230145f, 0.04377739f, 0.03807652f, 
    -0.00946606f, -0.01293732f, 0.02010015f, -0.01244410f, -0.03921958f, -0.01813032f, -0.03004923f, 0.00157410f, 
    -0.02248793f, -0.03336808f, -0.00490060f, 0.04084985f, -0.04713463f, 0.00442126f, 0.01931787f, 0.03430646f, 
    0.01884824f, -0.01215877f, -0.02212049f, 0.01303148f, 0.02248744f, -0.05133364f, 0.00285594f, -0.03658726f, 
    0.01425467f, -0.02326543f, 0.03393538f, 0.02805917f, -0.03960115f, 0.00949999f, -0.00329048f, 0.00143075f, 
    -0.00892877f, -0.02026593f, 0.02470455f, -0.04150536f, -0.03087874f, 0.00634093f, 0.03481415f, 0.00121351f, 
    0.02886530f, -0.02879868f, 0.00530329f, -0.01888624f, -0.05200957f, 0.02591497f, -0.05685274f, 0.02465881f, 
    -0.02263864f, 0.00791710f, 0.00036705f, -0.03952492f, -0.04421647f, -0.04225593f, 0.01808082f, -0.01881289f, 
    -0.05414436f, -0.04716433f, -0.01711706f, 0.01845636f, -0.00463017f, -0.02280106f, -0.02222261f, -0.03085073f, 
    0.00520602f, -0.05634335f, -0.03836569f, -0.05716780f, 0.00943233f, -0.02342407f, 0.00328353f, 0.02334712f, 
    0.04031321f, 0.01422762f, -0.03098022f, 0.04328725f, -0.04340348f, -0.00866602f, 0.01203590f, 0.02761716f, 
    -0.00515391f, -0.04537412f, -0.04355098f, -0.01339030f, -0.01193385f, -0.03908699f, 0.03010039f, 0.02537194f, 
    0.00843259f, 0.04196855f, 0.04942891f, -0.00083209f, 0.02330745f, 0.03153852f, -0.01591945f, 0.01505066f, 
    0.04288049f, 0.01550565f, 0.00800181f, -0.03545862f, 0.01543358f, 0.03462364f, -0.05292197f, -0.04388689f, 
    -0.01435890f, -0.04555706f, 0.01142447f, -0.03067826f, -0.04744372f, -0.01992563f, 0.02834590f, -0.00912486f, 
    -0.03476700f, -0.03534297f, 0.03424364f, -0.03811191f, -0.03387484f, 0.01108728f, 0.01609018f, -0.01105162f, 
    -0.05278626f, 0.03781598f, 0.01511381f, -0.00786454f, -0.01800229f, -0.00932015f, -0.02413777f, -0.03259576f, 
    -0.01542805f, -0.04164262f, -0.02026032f, -0.02771605f, 0.03567045f, -0.03188749f, -0.01748305f, -0.03797700f, 
    -0.01256397f, -0.05447263f, -0.01664224f, -0.00978936f, 0.02458281f, 0.03829281f, 0.01142768f, -0.04343483f, 
    -0.01427306f, -0.01338710f, 0.02043236f, -0.03004291f, -0.02093847f, -0.04482868f, 0.03326660f, 0.02680277f, 
    -0.02944391f, -0.05075549f, -0.02204867f, -0.05712885f, -0.02572571f, 0.01431524f, -0.01342780f, 0.03385153f, 
    -0.01110147f, -0.05706233f, -0.03605323f, 0.00887494f, -0.03805906f, -0.02079196f, -0.04194250f, -0.00169423f, 
    -0.00862795f, -0.04960507f, -0.00850656f, -0.01056378f, 0.03767307f, 0.00062745f, -0.04481377f, -0.03116103f, 
    0.00724804f, -0.00740122f, -0.04311936f, 0.02085665f, -0.03065999f, -0.03694668f, -0.03401554f, -0.00298740f, 
    -0.00201592f, 0.03170537f, -0.02270165f, 0.04194779f, -0.04029177f, -0.04935496f, 0.00007292f, 0.02313906f, 
    -0.02338061f, 0.03821029f, -0.04346053f, -0.01540040f, -0.00960962f, -0.03403490f, 0.00005047f, -0.04728340f, 
    0.03996205f, 0.02794266f, 0.00463366f, 0.00026926f, 0.00196046f, -0.03248836f, -0.04140797f, 0.00566008f, 
    -0.04064522f, -0.05892429f, -0.00588667f, 0.03289479f, 0.01515046f, 0.00173773f, -0.04211998f, -0.01918433f, 
    0.02800991f, 0.04269094f, -0.00998446f, -0.05182420f, -0.04735801f, 0.03298239f, -0.00603710f, 0.00927243f, 
    -0.03844105f, 0.04337434f, 0.01898649f, 0.04513553f, 0.04355713f, -0.02918573f, 0.01819472f, 0.02924573f, 
    0.03742317f, -0.01281032f, 0.04021360f, -0.00802374f, -0.02203900f, -0.05755361f, 0.04399877f, 0.03735698f, 
    0.02056610f, 0.02349339f, 0.02232512f, -0.04270335f, 0.01897653f, 0.00547831f, 0.02529654f, -0.01959454f, 
    0.03517165f, -0.04543542f, -0.02107662f, -0.05153795f, 0.00607198f, 0.01009723f, -0.04020241f, -0.03996706f, 
    -0.05406198f, 0.03464034f, -0.04376747f, -0.00500958f, 0.03161866f, -0.01605046f, -0.05183562f, -0.04267446f, 
    -0.01554839f, -0.00689828f, -0.05332001f, -0.00341820f, -0.00030255f, 0.03671547f, -0.02122397f, 0.02886827f, 
    -0.03650415f, 0.03126723f, -0.01394625f, -0.01405874f, -0.03427172f, 0.01707434f, 0.00290579f, -0.03164572f, 
    0.01059145f, -0.04875791f, -0.01587785f, 0.02152170f, 0.01196834f, 0.00646604f, 0.02382415f, 0.01059281f, 
    -0.03662645f, -0.00487248f, 0.03106619f, 0.01750578f, -0.00765314f, -0.00933888f, -0.02596697f, 0.02544877f, 
    -0.03444925f, -0.00779458f, -0.00428388f, 0.00920152f, 0.03321728f, -0.04404014f, -0.03065717f, -0.03476198f, 
    0.01447673f, -0.03475488f, -0.02904978f, 0.03463268f, 0.02736848f, 0.03243763f, -0.05347778f, -0.02143519f, 
    0.00643996f, -0.02284332f, 0.03477255f, 0.02170450f, -0.02087675f, 0.02434061f, -0.03360730f, -0.03727261f, 
    -0.01550260f, 0.03278083f, 0.01990608f, -0.03429701f, -0.01923381f, -0.01107004f, -0.01342048f, 0.00673143f, 
    -0.02216758f, 0.03571162f, -0.02347456f, -0.02409557f, 0.02381299f, 0.01926370f, -0.02064174f, 0.03885004f, 
    0.03746539f, -0.01762458f, -0.05134129f, 0.02532898f, -0.02464890f, 0.02616684f, -0.04763795f, -0.04447640f, 
    -0.00467892f, 0.02063629f, -0.04498619f, -0.03617722f, -0.01538228f, 0.02438613f, -0.01118708f, -0.00240841f, 
    -0.04503730f, -0.05187754f, -0.01773848f, 0.00415267f, -0.01702156f, -0.03355012f, 0.02671520f, -0.00133267f, 
    0.02905810f, -0.00356531f, -0.04754733f, 0.01825770f, -0.03853733f, 0.03786084f, -0.00895835f, 0.01645747f, 
    0.01811162f, -0.05180411f, -0.04360530f, 0.01438411f, 0.02172525f, -0.03730688f, 0.01418775f, -0.01021161f, 
    -0.02991923f, -0.05818477f, 0.00828677f, 0.03866437f, 0.03793868f, -0.01391429f, 0.00918852f, -0.00596539f, 
    -0.04163805f, 0.02134582f, 0.01684038f, 0.04649060f, -0.00484097f, -0.05273548f, -0.05827620f, -0.01440835f, 
    -0.05588540f, 0.02859470f, -0.05348469f, -0.03031951f, 0.00979026f, -0.04020996f, -0.00465193f, 0.01274619f, 
    -0.00237396f, -0.03067476f, 0.02987980f, -0.01264986f, 0.02064948f, 0.00188572f, -0.03198456f, 0.03515005f, 
    0.01839288f, -0.02717739f, -0.04390412f, -0.03352860f, -0.01252130f, -0.03535181f, 0.00629278f, -0.02778383f, 
    0.00883719f, 0.01558208f, -0.01410942f, -0.03030044f, -0.04025682f, -0.00112978f, 0.02332848f, -0.04526864f, 
    0.03852793f, 0.03083492f, -0.03494526f, 0.00664020f, -0.02250041f, 0.01026998f, -0.02889100f, 0.03305351f, 
    0.01192055f, 0.02937336f, -0.05607262f, -0.04502117f, -0.04352757f, -0.03902696f, -0.03553472f, -0.01108133f, 
    -0.00130920f, 0.04635156f, 0.01029675f, 0.02080633f, 0.04902519f, -0.02517897f, 0.01580142f, 0.05678562f, 
    -0.03228834f, 0.03530677f, -0.02810132f, -0.05837801f, -0.05884652f, 0.00172194f, -0.00276916f, 0.00953964f, 
    -0.01354151f, -0.04165127f, -0.01691213f, -0.03257465f, 0.00677067f, 0.03835678f, -0.05430964f, -0.03442043f, 
    -0.05036813f, 0.02283499f, -0.01192987f, -0.00827167f, -0.05557570f, -0.00392842f, -0.00578609f, 0.01089420f, 
    0.00852942f, -0.00273421f, 0.04247570f, -0.01315335f, 0.01860165f, 0.03098850f, -0.03224855f, -0.03085079f, 
    0.03158131f, 0.00407900f, 0.03399462f, -0.01641252f, -0.04862787f, -0.05945273f, -0.01879516f, -0.00954518f, 
    -0.00310837f, -0.00862431f, 0.02862118f, -0.03079912f, 0.02952703f, 0.03608470f, -0.01315077f, 0.04322302f, 
    -0.03966835f, 0.02940341f, -0.02328234f, -0.01125396f, -0.04194049f, -0.00450658f, -0.00395458f, -0.04515467f, 
    -0.02641080f, -0.05891014f, -0.02816604f, -0.04497105f, 0.00239714f, 0.00469037f, 0.02714263f, 0.00443548f, 
    -0.01843632f, -0.01937189f, 0.00326371f, 0.00006175f, 0.03361757f, 0.00380151f, -0.03214725f, -0.01371991f, 
    -0.03224216f, -0.03375223f, -0.03468084f, -0.01490029f, 0.03977686f, -0.02036800f, 0.02033226f, 0.00102514f, 
    0.04842582f, -0.01390043f, -0.05173011f, -0.02836349f, -0.04342305f, -0.02144376f, 0.03929777f, 0.01084810f, 
    -0.03401918f, 0.02711498f, 0.04322088f, -0.04470811f, 0.04519086f, 0.00369447f, -0.00561637f, 0.04216304f, 
    0.02117882f, 0.00877600f, -0.04993384f, -0.01732173f, 0.01790583f, -0.03453879f, -0.00175857f, -0.01091389f, 
    -0.03580111f, 0.02843248f, -0.04997796f, -0.05315462f, 0.03940145f, 0.00817464f, -0.03137027f, -0.03740772f, 
    0.02759699f, -0.01480483f, -0.01653244f, 0.02652691f, 0.03396432f, 0.00194753f, 0.02123427f, 0.03799435f, 
    -0.01904052f, 0.01866675f, 0.03048565f, -0.01268042f, -0.04838254f, -0.05436978f, -0.00853656f, -0.00645648f, 
    -0.01709388f, -0.02147833f, -0.00721519f, -0.01956097f, 0.02754633f, -0.03437427f, 0.01079620f, 0.01387573f, 
    -0.05015649f, 0.00365713f, 0.01440009f, 0.00957783f, 0.00995247f, 0.02357002f, -0.04512047f, -0.03927004f, 
    0.00479289f, 0.02705180f, -0.04234693f, -0.01669941f, -0.00162348f, 0.03968100f, 0.02556700f, -0.00110004f, 
    0.02886015f, -0.03585658f, -0.03841744f, -0.05194329f, 0.01534163f, -0.02256217f, 0.02390481f, -0.02955499f, 
    -0.04546052f, 0.02680286f, -0.01916259f, 0.02149366f, 0.02383217f, -0.02974219f, 0.02037621f, 0.03023453f, 
    -0.04858056f, -0.03336748f, -0.03364848f, -0.03269835f, -0.04417310f, -0.03296395f, 0.00082908f, 0.00075751f, 
    0.01612558f, -0.04495559f, 0.01834553f, 0.02293625f, -0.02187083f, -0.02929914f, -0.05330356f, -0.04781389f, 
    -0.05543288f, 0.03341172f, 0.03681721f, -0.04877278f, -0.05055052f, 0.00071861f, -0.02973209f, -0.04824030f, 
    -0.05819499f, -0.00727976f, 0.02736671f, -0.02428840f, -0.05783667f, 0.02323424f, 0.01117468f, 0.03764969f, 
    0.00871276f, -0.05120184f, -0.04668355f, 0.03683504f, -0.00362671f, 0.01665631f, 0.02671540f, -0.01979375f, 
    0.01791803f, 0.04250170f, -0.04278699f, 0.01708111f, 0.02881888f, -0.01524626f, -0.01720144f, 0.03030374f, 
    0.03774531f, -0.05353604f, 0.03003427f, -0.05108990f, -0.03176425f, -0.01426403f, -0.02820107f, -0.03697577f, 
    0.00837467f, 0.02611708f, 0.01125439f, -0.02139528f, -0.04233675f, 0.00375264f, -0.04438053f, 0.01911835f, 
    0.02930826f, 0.01147688f, -0.04330444f, 0.00755471f, -0.05448243f, -0.04108034f, -0.02315900f, 0.00046578f, 
    -0.05492830f, -0.04392252f, -0.05855089f, -0.04578239f, -0.01590884f, -0.03496116f, -0.00184570f, 0.03386274f, 
    -0.04320819f, -0.04027642f, 0.02903086f, -0.02727773f, -0.03793982f, -0.03208403f, 0.00162338f, 0.00931354f, 
    0.01278531f, 0.02127309f, 0.02505269f, 0.03723668f, 0.00224708f, -0.04794633f, -0.02476365f, 0.03663374f, 
    0.02915635f, -0.00827381f, 0.02335087f, -0.02025385f, 0.04003869f, -0.01096969f, 0.03448412f, 0.02896965f, 
    0.03410774f, -0.04817114f, 0.02622278f, -0.01354268f, -0.04958333f, 0.03683025f, 0.01402151f, 0.04026946f, 
    -0.05654536f, 0.01889817f, 0.00263849f, -0.02461171f, -0.05436384f, -0.03845172f, -0.00177831f, 0.03478675f, 
    -0.04961131f, 0.04330267f, 0.00245108f, -0.05393608f, -0.03691063f, -0.01175099f, -0.02434768f, 0.01626172f, 
    0.02754607f, -0.02561696f, 0.03113850f, -0.02712259f, 0.02118559f, 0.03740470f, -0.03868730f, 0.04192713f, 
    -0.04235701f, -0.01176012f, -0.05432728f, 0.02970894f, 0.00110386f, -0.00805148f, 0.01044404f, 0.00726874f, 
    -0.02676767f, -0.00743825f, 0.01952542f, 0.02678228f, 0.01137171f, -0.04536650f, -0.02429414f, 0.01525884f, 
    0.03498730f, 0.02086634f, -0.02669633f, 0.00653237f, -0.02436185f, 0.02692260f, 0.03484300f, -0.04123873f, 
    -0.03714001f, -0.00952384f, -0.05307048f, -0.00523307f, 0.00531203f, 0.00783636f, -0.02988671f, 0.03762071f, 
    -0.01327491f, -0.04835214f, -0.03785808f, 0.02420808f, 0.00448403f, -0.04845868f, -0.04512615f, -0.03486887f, 
    0.03207582f, 0.02769087f, -0.01820274f, -0.05796973f, -0.03521911f, -0.03547057f, -0.00802774f, 0.03950340f, 
    -0.00474319f, -0.01989919f, -0.00855409f, -0.01482746f, -0.03867840f, -0.02032404f, 0.01053842f, -0.03740646f, 
    -0.05913017f, -0.01213409f, 0.00158025f, -0.00227807f, 0.03722933f, 0.00898785f, -0.00388735f, 0.02039921f, 
    -0.02657714f, -0.04500500f, -0.01134297f, -0.03337096f, -0.04575139f, 0.00313002f, -0.01260144f, -0.04724957f, 
    0.03213992f, 0.03923352f, -0.05627482f, -0.02500665f, 0.02019298f, 0.02917278f, 0.01959375f, 0.03005944f, 
    -0.05569001f, 0.01402812f, -0.01164645f, 0.03870764f, 0.01443739f, 0.02956664f, -0.01641953f, -0.01988777f, 
    0.04223839f, -0.02984142f, -0.01416930f, -0.01376315f, -0.04250554f, -0.02812361f, -0.03045252f, 0.03236140f, 
    0.03238396f, 0.02577265f, 0.03891690f, -0.02924458f, -0.04736702f, -0.00235794f, 0.02618965f, 0.00775737f, 
    -0.05458458f, -0.03163605f, 0.03319974f, 0.00255027f, 0.03385848f, -0.03702389f, 0.01441924f, -0.05590757f, 
    -0.00475113f, -0.04286668f, -0.03249809f, -0.04983272f, -0.03873436f, 0.04156125f, 0.04041258f, -0.05544689f, 
    -0.04155022f, 0.02683800f, 0.00977270f, 0.02458222f, 0.00797540f, -0.00312413f, -0.01788098f, -0.00446426f, 
    -0.05188966f, -0.04785720f, -0.02954273f, 0.01416060f, -0.00421585f, 0.03405448f, 0.02144431f, -0.00328787f, 
    0.00930101f, 0.01765768f, -0.04849646f, 0.03612342f, 0.03233996f, 0.03913417f, 0.01262292f, -0.00274746f, 
    0.04087745f, -0.05980505f, -0.05155532f, 0.03392270f, 0.00574261f, -0.02742545f, 0.03946724f, 0.00539501f, 
    -0.02696290f, 0.02579797f, 0.01603086f, 0.01925239f, -0.03116767f, -0.04048674f, 0.01327228f, -0.03562623f, 
    0.01944481f, 0.01057705f, -0.03337019f, 0.00419959f, 0.01566499f, -0.05221590f, 0.00637187f, -0.04389746f, 
    -0.04923863f, -0.00301526f, -0.00820334f, 0.04012233f, -0.01307229f, 0.00143003f, -0.03559132f, -0.04895938f, 
    -0.02800643f, -0.02056499f, -0.03500576f, 0.04166783f, -0.02674160f, -0.01534629f, -0.05125127f, -0.01815410f, 
    -0.01540281f, -0.02787775f, -0.04672674f, 0.03248784f, -0.00018956f, -0.03955478f, 0.03764873f, 0.02915525f, 
    -0.00725664f, 0.00276030f, -0.00205176f, -0.03065267f, 0.03137881f, 0.03463642f, -0.04159079f, -0.04039398f, 
    -0.01215831f, -0.05797111f, 0.00131581f, -0.04794415f, 0.01318001f, 0.01917616f, -0.04201370f, -0.00965703f, 
    -0.01174748f, -0.00326394f, -0.04893880f, -0.01878140f, -0.05081574f, 0.03615990f, -0.02948163f, -0.02944998f, 
    -0.03125863f, -0.01421615f, -0.03488804f, 0.02476298f, 0.00811282f, -0.01521439f, 0.01319915f, -0.00422461f, 
    -0.01804222f, 0.00909980f, -0.04698322f, -0.03718180f, 0.00654762f, -0.03083859f, 0.00596987f, 0.03549053f, 
    0.00893794f, -0.00483608f, -0.03779401f, -0.01860996f, -0.04556544f, 0.01149684f, 0.00671161f, 0.00186012f, 
    0.00166902f, -0.01800139f, -0.04963681f, 0.04008328f, -0.00988276f, -0.01778711f, 0.02105648f, -0.05195096f, 
    0.00616465f, 0.00026005f, 0.00721739f, 0.00914494f, -0.00815706f, 0.00372694f, -0.00421591f, 0.04300438f, 
    0.02086746f, -0.04217801f, -0.01996090f, -0.03277907f, -0.04542686f, 0.02281055f, 0.00520710f, -0.01026830f, 
    -0.00843037f, -0.02837757f, -0.02504657f, 0.01632999f, -0.00663410f, -0.00931412f, -0.05327338f, 0.04270741f, 
    -0.00206169f, 0.01584479f, -0.03584391f, 0.00816017f, -0.02386969f, 0.00308636f, -0.03621391f, -0.03453761f, 
    -0.03712993f, -0.00459417f, -0.04191673f, -0.03635114f, -0.05007956f, -0.02191689f, 0.03604072f, -0.02767758f, 
    -0.01641941f, 0.00163934f, 0.02312281f, -0.04653242f, 0.03596129f, -0.02618714f, -0.04570712f, -0.02044523f, 
    0.04406314f, -0.01328027f, 0.03355796f, -0.01517901f, 0.00773094f, -0.04671289f, -0.05478548f, 0.01195398f, 
    0.01590824f, -0.00121310f, 0.03467080f, 0.02004028f, -0.00882129f, 0.01870561f, -0.04159465f, -0.01792274f, 
    0.00631508f, -0.05092477f, -0.01826572f, -0.00497948f, -0.02525471f, -0.05152363f, 0.03402496f, 0.01379855f, 
    -0.00388980f, 0.00631232f, -0.03016452f, 0.00713782f, 0.01489891f, -0.00943948f, 0.01548939f, -0.01019679f, 
    -0.01261557f, -0.04797010f, 0.02837224f, -0.03145616f, -0.00899570f, -0.01792553f, 0.04509016f, -0.04137386f, 
    -0.03274310f, -0.05397553f, -0.05376900f, 0.04046917f, 0.00850591f, -0.04025653f, -0.00000488f, -0.02162702f, 
    0.00370198f, -0.05154488f, 0.00668929f, -0.01418643f, 0.00213169f, 0.00586198f, 0.03260115f, -0.03221232f, 
    -0.02650226f, 0.02964983f, -0.04040377f, -0.02999991f, -0.01412217f, 0.02200952f, -0.03189199f, -0.00551579f, 
    0.04308430f, -0.03132076f, -0.02507127f, 0.02008142f, 0.03507676f, -0.00811430f, -0.04893724f, -0.02832964f, 
    0.03186794f, 0.03020589f, -0.01473220f, -0.01182052f, 0.04298591f, 0.00237353f, 0.00788897f, -0.00623524f, 
    0.01434066f, 0.02246132f, -0.00769193f, -0.02687770f, -0.04898137f, -0.03679141f, 0.02636289f, 0.04226208f, 
    0.01105649f, -0.04796049f, -0.05062046f, 0.03432320f, -0.04028365f, 0.02558342f, 0.02619497f, 0.01607692f, 
    -0.02873946f, 0.00989685f, -0.03016110f, 0.04062530f, 0.00403829f, -0.01642782f, 0.00034214f, 0.04206253f, 
    -0.00347022f, -0.03301408f, 0.02581797f, -0.00022036f, -0.01175592f, -0.00959095f, 0.01559264f, 0.00092606f, 
    -0.03067040f, -0.03304816f, -0.03253270f, 0.00971626f, -0.01805743f, -0.04471911f, -0.01796400f, 0.03020792f, 
    -0.05314774f, 0.02464675f, 0.00494470f, 0.04459280f, -0.04109108f, 0.04169432f, -0.04989503f, -0.03195252f, 
    -0.03351738f, 0.02739029f, -0.01030027f, 0.00594686f, -0.01863273f, -0.00249464f, -0.04407231f, -0.00013867f, 
    -0.04256732f, 0.00377993f, 0.02691434f, -0.02586312f, -0.04338197f, -0.03523816f, 0.01970619f, -0.03713653f, 
    -0.00326602f, -0.04230970f, -0.04601337f, 0.03984432f, -0.02355540f, -0.01650510f, -0.05533341f, -0.01604852f, 
    0.00857801f, -0.00936426f, 0.02641221f, -0.04904138f, -0.03212570f, 0.04218885f, -0.02322974f, -0.04870817f, 
    0.03388567f, -0.02718418f, -0.01413352f, 0.03793694f, 0.02542893f, 0.04130843f, 0.04335385f, 0.00122252f, 
    -0.00110660f, -0.00157302f, -0.05310735f, 0.03690002f, -0.00997210f, -0.02577716f, 0.01992753f, 0.04093352f, 
    0.02495023f, 0.03732149f, -0.01442753f, 0.03626137f, 0.02702411f, -0.04238035f, 0.02705455f, 0.01771594f, 
    0.00455208f, -0.00157985f, 0.02494146f, -0.02220988f, -0.02572007f, -0.03660928f, 0.01772675f, -0.04667838f, 
    -0.05211647f, 0.02857639f, -0.02081878f, 0.03796635f, -0.01534720f, 0.03737171f, 0.01823025f, -0.01996158f, 
    0.03643693f, -0.01817604f, 0.00436148f, 0.00532669f, 0.01802171f, 0.02514172f, -0.01352376f, -0.01404552f, 
    -0.03406259f, -0.04803450f, -0.04840584f, -0.04469728f, 0.02849043f, 0.00831289f, 0.00510036f, 0.04342328f, 
    0.01379278f, -0.04802392f, -0.04709127f, 0.02474390f, 0.03718494f, 0.00581758f, -0.01445845f, 0.01645779f, 
    -0.02943429f, 0.01000316f, 0.03606688f, -0.02421524f, -0.01527446f, -0.04205862f, 0.01877067f, -0.03166250f, 
    0.02966593f, -0.00665159f, -0.02329690f, 0.00691204f, -0.02931734f, 0.02402350f, 0.00034813f, 0.02315260f, 
    0.01024139f, -0.00671020f, 0.00053117f, -0.02999185f, -0.04637902f, -0.03893508f, 0.00345525f, -0.00549932f, 
    -0.00768470f, 0.02868858f, -0.02590921f, 0.03630366f, -0.01090188f, 0.04382383f, 0.02384145f, -0.04703020f, 
    -0.02843733f, 0.01877363f, -0.04101496f, 0.00209910f, -0.02877876f, 0.00855440f, -0.03508617f, 0.00995599f, 
    -0.01193753f, -0.03565298f, -0.02128654f, 0.01872379f, -0.04183261f, -0.03793401f, -0.02606797f, 0.01857196f, 
    0.00363784f, 0.03010697f, -0.05016334f, 0.00314008f, -0.04577902f, 0.01006874f, -0.04406006f, 0.02068581f, 
    -0.02149616f, -0.02877788f, 0.01517479f, 0.00838092f, -0.01245082f, 0.01018235f, -0.03990971f, -0.03735876f, 
    0.02406968f, 0.00172038f, 0.03232807f, -0.04122221f, 0.00213116f, 0.02600564f, 0.03413325f, -0.05201630f, 
    -0.05508832f, -0.04089635f, -0.03590332f, -0.05558103f, 0.02277733f, 0.04046535f, 0.03655327f, 0.00799123f, 
    0.02759234f, 0.00305481f, -0.04240463f, -0.04999997f, 0.04740150f, -0.01310632f, -0.04906296f, -0.03950308f, 
    0.06164655f, 0.04174682f, 0.23673362f, -0.10382698f, 0.12582204f, 0.14498070f, -0.03294541f, -0.24963507f, 
    -0.01072374f, 0.07484554f, 0.01584306f, 0.08691359f, -0.27938661f, 0.15356316f, -0.17437597f, 0.02039996f, 
    0.14170022f, 0.03775012f, 0.11572766f, 0.02260635f, 0.03615233f, 0.21045789f, -0.14416511f, 0.08019998f, 
    -0.07356814f, -0.32256442f, 0.03337968f, -0.01907483f, -0.02671673f, -0.16223554f, -0.00881766f, -0.14675143f, 
    0.07859903f, 0.17084664f, 0.08080559f, 0.07235203f, -0.28465986f, 0.06553315f, 0.01319602f, 0.14388312f, 
    0.06631289f, 0.13519663f, -0.16044769f, 0.03166243f, 0.04278580f, 0.10049469f, 0.03527285f, 0.13254754f, 
    -0.33773309f, 0.09437465f, 0.05427875f, -0.11948206f, 0.02531703f, 0.10771304f, 0.05408358f, 0.02309786f, 
    0.09030046f, -0.11395797f, 0.11727003f, 0.11354417f, -0.02614004f, -0.05905276f, 0.27210617f, 0.51104528f, 
    -0.10580907f, -0.00476457f, 0.08247387f, 0.03275707f, -0.14480367f, -0.01206946f, 0.12331314f, -0.06759217f, 
    -0.06463544f, 0.20827565f, -0.18396945f, -0.13311137f, 0.01293945f, 0.09340350f, 0.06906909f, -0.03390751f, 
    0.04140373f, -0.09993736f, -0.15811422f, 0.03781762f, 0.21484527f, -0.18789680f, -0.18462974f, -0.23691450f, 
    -0.13923679f, 0.11371184f, -0.17194679f, -0.07296007f, 0.06862448f, 0.14135765f, 0.14001703f, -0.17857568f, 
    0.15193559f, -0.21759123f, -0.13044435f, 0.02300635f, 0.23249631f, 0.00151058f, -0.07083936f, -0.05197476f, 
    0.05611587f, -0.03531899f, 0.03103816f, -0.14373894f, -0.17836371f, -0.10335373f, -0.04002407f, 0.12651406f, 
    0.01681168f, -0.15573186f, 0.04473909f, -0.02147449f, 0.05034767f, -0.01295127f, 0.09837744f, 0.12358034f, 
    -0.05703972f, -0.15341675f, -0.01069190f, 0.04134205f, -0.06595312f, 0.08550385f, 0.00388028f, 0.16038565f, 
    -0.00114338f, -0.02294686f, 0.12483173f, 0.20265692f, 0.26833814f, 0.34805307f, 0.05990447f, 0.19556533f, 
    0.11261836f, -0.04501633f, -0.01740125f, 0.08748922f, -0.04412636f, -0.03178546f, 0.02348490f, 0.05451503f, 
    0.20364179f, -0.00803257f, -0.21126759f, 0.08730050f, 0.16849552f, -0.19269866f, 0.04790008f, -0.00137082f, 
    0.20636967f, 0.08541851f, 0.08353943f, 0.08149786f, 0.06713047f, 0.04205481f, 0.17658335f, 0.10445812f, 
    -0.01980534f, -0.14198758f, -0.03723064f, 0.02520072f, 0.07126871f, 0.11813737f, -0.10805592f, -0.04332821f, 
    0.06614484f, -0.19720052f, -0.02694474f, 0.08369107f, 0.00643560f, -0.07268984f, -0.06879070f, -0.07859066f, 
    0.06454673f, -0.06898468f, 0.14691573f, -0.09922212f, -0.14244755f, 0.10412307f, 0.07088409f, -0.06017757f, 
    -0.07157341f, -0.15214776f, 0.14812993f, 0.02024060f, 0.04696910f, 0.02517810f, -0.02327822f, 0.06631926f, 
    -0.08589923f, 0.01850727f, 0.03513401f, 0.23376298f, -0.00620278f, 0.03685111f, 0.05879942f, 0.17750610f, 
    0.05087162f, 0.02310037f, 0.09443822f, 0.05218973f, -0.12330227f, 0.40636700f, 0.21540852f, 0.05783983f, 
    0.07542063f, -0.01764918f, -0.00931505f, -0.01595541f, -0.04710370f, 0.08492356f, -0.05704812f, -0.01870912f, 
    0.05190988f, -0.17443283f, -0.14030619f, -0.15391114f, 0.16107358f, 0.16738361f, 0.01414513f, -0.06669567f, 
    0.20525850f, 0.01750413f, 0.02211279f, -0.06726906f, 0.26992998f, 0.19419867f, 0.03155464f, 0.08505615f, 
    0.00859036f, -0.32731634f, -0.05356981f, -0.05692733f, -0.15193936f, 0.12481584f, 0.17296690f, -0.01274937f, 
    -0.05771784f, 0.27092710f, -0.01554686f, 0.19936176f, 0.01988097f, -0.02007738f, 0.02068497f, 0.07688978f, 
    0.00787736f, 0.07307129f, 0.08811190f, 0.09112029f, -0.24451676f, 0.02467495f, 0.26410085f, -0.17058705f, 
    -0.05325437f, 0.00823771f, 0.02996097f, 0.04355975f, 0.00648507f, -0.04001115f, -0.03429298f, -0.10458783f, 
    0.01283076f, -0.04851079f, -0.06873816f, 0.09510080f, 0.01369109f, -0.05792514f, 0.03526450f, -0.13363568f, 
    0.10196014f, 0.03076662f, 0.13645433f, 0.17639016f, -0.26994878f, -0.10175335f, 0.12325300f, -0.07185856f, 
    0.05202577f, -0.05443629f, -0.01405536f, 0.03596339f, 0.13204199f, 0.06365204f, -0.12490523f, 0.03415116f, 
    0.11938399f, -0.11278081f, -0.06634186f, 0.05539188f, -0.13339496f, 0.01318569f, -0.11940752f, -0.07457278f, 
    -0.16657411f, -0.14562714f, 0.00805706f, 0.05392298f, 0.42746809f, -0.13653946f, 0.03468344f, -0.06198463f, 
    -0.02280773f, 0.02615557f, -0.19940585f, 0.04018900f, 0.09045617f, 0.11853159f, -0.15722543f, 0.00692389f, 
    0.14126624f, 0.07901378f, -0.06219188f, -0.05405777f, 0.02162898f, 0.04093550f, 0.01558613f, -0.03667364f, 
    0.03219474f, -0.02919638f, 0.00365013f, 0.06863873f, 0.19432427f, -0.15086587f, 0.04942485f, -0.00401780f, 
    -0.01911393f, -0.06733461f, 0.00534128f, 0.08638908f, 0.13909528f, 0.03011710f, 0.12861134f, 0.18069336f, 
    -0.02780534f, 0.24073282f, -0.16586514f, -0.05568031f, 0.05215917f, -0.00147798f, 0.00398344f, -0.02238881f, 
    0.01202992f, -0.09671658f, 0.01598337f, 0.02688897f, 0.11221737f, -0.21445630f, 0.47902855f, 0.02266051f, 
    0.07528123f, -0.05269255f, -0.12394428f, 0.05414655f, 0.19317941f, 0.14803617f, 0.08394974f, 0.02273775f, 
    -0.28987625f, 0.15428543f, -0.02503412f, -0.12440955f, 0.12395851f, -0.14544335f, -0.00347223f, -0.12897635f, 
    0.02377644f, -0.04326234f, -0.09101372f, 0.00041679f, -0.23542714f, 0.08635725f, 0.00375967f, 0.07004826f, 
    -0.02837672f, -0.15438652f, 0.04487371f, -0.06066946f, 0.07165062f, 0.05301331f, 0.00410542f, 0.08648890f, 
    0.33739072f, -0.16861016f, -0.01687394f, 0.30210507f, 0.09843238f, -0.02814896f, 0.14253780f, 0.11507528f, 
    -0.12773208f, -0.04761595f, 0.03157277f, 0.01001969f, -0.32533497f, 0.14104669f, 0.32245031f, 0.13981558f, 
    0.04823133f, 0.03599031f, -0.00722373f, 0.10830458f, -0.11545228f, 0.10480408f, 0.11395351f, 0.05711959f, 
    -0.02823319f, 0.09697873f, 0.04193345f, 0.35832152f, -0.07427712f, 0.04134073f, -0.18363455f, 0.05802749f, 
    0.02674638f, -0.01565402f, 0.03290356f, -0.04039588f, 0.07545692f, 0.12856442f, 0.10497840f, 0.03878408f, 
    -0.00850250f, 0.15354776f, -0.05553703f, 0.09314635f, -0.04830385f, 0.15230645f, 0.02218828f, 0.03088189f, 
    0.32874045f, 0.06605607f, 0.34249628f, 0.06036207f, 0.12687103f, 0.03292630f, 0.12885433f, 0.00490725f, 
    0.07652662f, -0.12171632f, 0.04424072f, -0.00090994f, 0.47049662f, -0.38087407f, 0.14736336f, 0.20571917f, 
    0.06576196f, -0.07785022f, 0.02354532f, 0.08396173f, 0.00057612f, 0.05140858f, 0.08409018f, 0.04848360f, 
    0.02208277f, -0.11529490f, 0.22189096f, 0.05532332f, 0.07250642f, 0.20692958f, 0.02195111f, 0.23910373f, 
    0.09265707f, 0.05060911f, -0.14284799f, 0.03177991f, 0.13491929f, -0.04241965f, -0.38148502f, -0.08427146f, 
    -0.10240787f, -0.01036945f, 0.06386273f, 0.01837138f, -0.20599915f, 0.12875040f, 0.15947916f, 0.09444613f, 
    0.30021390f, -0.16090386f, 0.00733878f, -0.20296109f, 0.10479291f, 0.09119941f, -0.18057677f, -0.10933910f, 
    -0.07232437f, 0.02103740f, 0.12964150f, 0.07558569f, 0.05374936f, -0.40800339f, -0.33200571f, 0.18734878f, 
    -0.13051577f, -0.17229436f, -0.08557855f, -0.03336373f, 0.15375040f, -0.15240614f, -0.07557899f, -0.10266198f, 
    0.21316421f, -0.17535648f, -0.13662392f, 0.05947249f, -0.04757762f, 0.09337725f, -0.09523032f, 0.05759302f, 
    -0.26769710f, -0.17875257f, 0.01792437f, -0.13113178f, 0.45467728f, 0.10664076f, 0.17827910f, -0.17954712f, 
    -0.16762984f, 0.06751551f, 0.09993538f, -0.04284751f, 0.09075224f, -0.04956431f, -0.10030977f, -0.01744150f, 
    0.26953369f, 0.15833111f, -0.11536597f, -0.13292122f, -0.15649520f, 0.01086385f, 0.08411987f, 0.06896024f, 
    0.03310736f, -0.05249915f, -0.09044111f, -0.13052404f, 0.06449818f, 0.07131971f, 0.16465211f, -0.05237516f, 
    0.07730348f, 0.02628256f, -0.10304854f, -0.09807204f, 0.09023004f, 0.05239749f, 0.14731157f, 0.02247467f, 
    -0.11104590f, 0.05540506f, -0.13207568f, -0.09109826f, 0.10594120f, 0.02825120f, -0.01313280f, -0.26773986f, 
    -0.05176721f, 0.03852000f, 0.11599597f, -0.04199203f, 0.00593585f, -0.04188230f, 0.02126922f, -0.02567285f, 
    -0.07717579f, -0.14554951f, 0.10985140f, -0.12829894f, 0.05767410f, -0.12259121f, -0.16650842f, -0.11655906f, 
    -0.35087529f, -0.05492670f, -0.04890831f, 0.18652420f, 0.06314005f, -0.01384467f, 0.06399260f, 0.06883648f, 
    0.11506566f, 0.20256045f, 0.17600359f, -0.04665155f, -0.10110058f, 0.26322931f, 0.22112380f, -0.19513243f, 
    -0.00178114f, -0.01861074f, 0.01563706f, 0.00402230f, 0.03310884f, -0.01777417f, -0.03925966f, -0.20000821f, 
    -0.11150155f, 0.00184603f, -0.02249060f, 0.35390246f, 0.22417539f, 0.21162288f, -0.10391809f, 0.05336557f, 
    -0.02645107f, -0.16667014f, 0.02096905f, -0.03587986f, 0.35683438f, 0.14787494f, -0.03656517f, 0.12226392f, 
    -0.16472052f, -0.10304300f, 0.20470430f, 0.15382725f, 0.10591682f, 0.30130592f, 0.25400835f, -0.09359283f, 
    -0.21517177f, 0.16041397f, 0.05789578f, -0.01441437f, 0.09647846f, 0.10657128f, 0.10746136f, -0.10638348f, 
    -0.05177920f, 0.00335069f, -0.09887224f, 0.03141034f, 0.50141621f, -0.15698798f, 0.11389427f, 0.01950669f, 
    -0.07325070f, 0.06346305f, 0.00013707f, 0.03957802f, -0.01310025f, -0.17399418f, 0.01594115f, 0.02868684f, 
    -0.08303212f, 0.23459546f, -0.06594816f, -0.02755893f, 0.27280527f, -0.08387525f, 0.12473118f, -0.11145572f, 
    -0.10116025f, 0.00474156f, 0.01167416f, 0.02419349f, 0.02741426f, 0.01126166f, -0.01982868f, -0.03848562f, 
    -0.11100306f, 0.03928859f, -0.06435253f, -0.07370230f, -0.03452771f, 0.06289846f, -0.07202296f, -0.02247094f, 
    -0.01045178f, -0.00402674f, -0.14506182f, -0.08309063f, 0.04964651f, 0.06515174f, -0.16409224f, -0.13923582f, 
    -0.20313458f, -0.05041355f, -0.01090798f, -0.01040846f, 0.39444670f, -0.09174156f, -0.05153320f, 0.20227568f, 
    -0.18625939f, 0.00133690f, -0.03234896f, 0.18938859f, 0.00079491f, 0.07643393f, -0.10021489f, -0.12600549f, 
    -0.12843141f, -0.05157057f, 0.01296158f, -0.04295493f, 0.06978781f, 0.01831702f, -0.12633188f, -0.05815551f, 
    0.10116331f, -0.00901844f, -0.23122813f, 0.13153695f, -0.19620863f, 0.01089600f, -0.05583344f, 0.05545799f, 
    -0.06433706f, 0.11266310f, -0.03724400f, -0.02150795f, -0.00215030f, -0.05562892f, -0.10934723f, -0.12634136f, 
    -0.16329031f, 0.23592150f, 0.07557273f, -0.03069272f, -0.02734347f, -0.01487384f, -0.01808624f, 0.07281955f, 
    0.11357001f, 0.06111862f, 0.03329172f, 0.04154076f, 0.74276805f, -0.30959046f, 0.35014305f, 0.07949334f, 
    -0.07789709f, 0.08618906f, -0.06381384f, -0.02966858f, 0.04029903f, -0.04548293f, 0.05934699f, 0.02123976f, 
    -0.28262749f, 0.19556393f, -0.10671174f, -0.19613287f, 0.14524473f, -0.05843083f, 0.02914829f, 0.10882133f, 
    0.05556441f, -0.01258611f, 0.07987557f, -0.00391657f, 0.14911273f, 0.15131985f, 0.02385630f, -0.03930478f, 
    0.17031148f, -0.22971150f, 0.21820372f, -0.28554294f, 0.07417806f, -0.10801198f, 0.02380095f, -0.19563952f, 
    0.04825012f, 0.04442419f, -0.03682194f, 0.03551373f, -0.00810900f, 0.02266935f, 0.04880266f, -0.05386560f, 
    0.02157626f, -0.03195418f, 0.00888330f, -0.02921688f, -0.02299415f, -0.01672252f, 0.02577782f, 0.02328565f, 
    -0.05510327f, 0.02472556f, -0.01420567f, -0.00330942f, 0.02981199f, -0.03663183f, -0.01101889f, 0.00651758f, 
    -0.03799722f, 0.00589305f, -0.02011570f, -0.04685572f, -0.03241810f, -0.00005901f, -0.05229430f, -0.02509402f, 
    -0.00014606f, 0.01032597f, 0.03372392f, 0.02123741f, -0.04441498f, -0.05071312f, -0.02291711f, 0.02340021f, 
    -0.05085430f, 0.00648605f, 0.01165563f, -0.01274304f, -0.03388513f, -0.01426438f, 0.01393768f, -0.00662578f, 
    0.00039488f, -0.02369879f, 0.03524674f, 0.01211550f, -0.00355312f, 0.00701697f, -0.02161893f, 0.04799412f, 
    -0.01335666f, -0.02561626f, 0.02667391f, 0.02850702f, 0.03446222f, 0.03333139f, 0.00529416f, -0.03273400f, 
    -0.04004668f, -0.05156050f, 0.03242609f, -0.02197056f, -0.05461942f, -0.02101428f, 0.00043784f, 0.03578344f, 
    -0.04802101f, -0.04607188f, 0.01449566f, -0.04029455f, 0.00267749f, 0.04110766f, 0.00016373f, 0.03009743f, 
    0.03428803f, -0.01988313f, -0.03329801f, 0.00254473f, 0.00405331f, -0.04810140f, 0.01778170f, 0.00000902f, 
    -0.00479497f, -0.04057452f, 0.00631769f, 0.02970679f, 0.03182626f, -0.01468490f, 0.04105512f, 0.01960293f, 
    0.00014947f, 0.01218801f, 0.02818790f, 0.02439976f, 0.01619028f, 0.03350699f, -0.02111940f, -0.00309137f, 
    -0.02026816f, 0.04058330f, 0.03101175f, 0.01764752f, -0.01317267f, -0.04125687f, 0.00952864f, 0.03713789f, 
    0.01130071f, -0.01839647f, -0.00552754f, 0.04146849f, 0.00050415f, 0.00127348f, -0.03277593f, -0.04907253f, 
    -0.01079162f, 0.02724499f, -0.01332446f, -0.02820216f, -0.04585416f, 0.02410482f, -0.02401928f, 0.03266470f, 
    -0.03604922f, 0.04479492f, -0.04638053f, -0.03976617f, -0.02587025f, -0.04709885f, -0.02239398f, 0.04078230f, 
    0.01872834f, 0.03858954f, -0.03079553f, 0.02080877f, -0.04727984f, -0.00742131f, -0.05336553f, 0.01519885f, 
    -0.04452222f, -0.00548721f, 0.00485421f, -0.02456901f, -0.01837924f, 0.03600298f, -0.03931471f, 0.02239038f, 
    0.03325790f, -0.04913284f, -0.05708761f, -0.02031787f, -0.04086044f, 0.01289499f, -0.01925095f, 0.00488599f, 
    -0.04080674f, -0.01930822f, -0.02487360f, 0.00339299f, 0.04704409f, -0.03117068f, 0.02871814f, -0.01138247f, 
    -0.00510121f, 0.03194707f, -0.05453835f, -0.00975877f, -0.01720227f, 0.02722583f, -0.00634643f, -0.02763774f, 
    0.02329762f, 0.02726618f, 0.02285760f, -0.01474106f, -0.04774090f, -0.00360105f, 0.01635601f, -0.03435946f, 
    0.02706558f, 0.01340621f, 0.04082801f, -0.05762965f, -0.01064042f, 0.02877617f, 0.02280681f, -0.01343367f, 
    0.04293061f, -0.00948176f, -0.05191736f, 0.02692458f, -0.03882966f, 0.01212311f, -0.00223855f, -0.00019903f, 
    -0.03724026f, -0.02468756f, -0.04808743f, 0.03711556f, -0.00392803f, -0.03850487f, -0.02000286f, 0.02168818f, 
    0.01785113f, 0.02618104f, 0.00417852f, -0.03673808f, 0.00443554f, 0.02371165f, -0.04430671f, -0.02190445f, 
    -0.03001972f, -0.04338864f, -0.00247189f, 0.00249683f, 0.01092865f, -0.04944664f, -0.05113945f, -0.03416405f, 
    0.02764431f, -0.03185574f, -0.04223851f, -0.03103962f, 0.02902467f, -0.00127048f, 0.02842364f, -0.05436157f, 
    -0.03025966f, -0.04441089f, 0.00780623f, -0.00957274f, 0.03726825f, 0.01493055f, 0.04000596f, 0.02060585f, 
    -0.02726884f, -0.04393515f, -0.03302986f, -0.00038484f, -0.00590042f, 0.02052920f, -0.02165220f, 0.00721193f, 
    -0.02072943f, 0.00810633f, -0.05649305f, -0.00935590f, 0.00491642f, -0.02534227f, -0.00938424f, -0.03294596f, 
    -0.01768792f, -0.01229620f, 0.04275525f, -0.05174891f, 0.00550115f, 0.00842743f, -0.02738643f, 0.03189337f, 
    0.04361744f, 0.03314233f, -0.02917237f, -0.00511432f, 0.00941172f, 0.00305484f, 0.00288470f, -0.01634261f, 
    0.02097759f, -0.01598232f, -0.00692756f, 0.00062636f, -0.00750389f, -0.00622106f, 0.04231839f, -0.02757902f, 
    0.02859205f, 0.03869600f, -0.02082137f, -0.04780355f, -0.05593734f, 0.01340985f, 0.02203134f, -0.05684989f, 
    -0.01979073f, -0.01862275f, 0.02720908f, -0.05470330f, -0.02532470f, 0.00698643f, -0.00905726f, -0.01506903f, 
    0.01381772f, 0.00759375f, 0.00801010f, 0.04261561f, -0.00709573f, -0.05051851f, 0.04156413f, -0.03050610f, 
    0.03311714f, -0.01789355f, -0.03386545f, -0.02897930f, -0.04223778f, -0.00805310f, -0.02583474f, 0.04102510f, 
    0.01047130f, -0.01007030f, 0.02078648f, -0.02591363f, 0.03399538f, 0.00397740f, -0.04164799f, -0.01343086f, 
    -0.00436611f, 0.00964145f, -0.04384407f, -0.05676695f, -0.05218790f, -0.02388776f, -0.00453937f, -0.04206540f, 
    0.01280149f, -0.03426231f, 0.02620335f, 0.03962269f, -0.05335530f, -0.02633961f, -0.04394955f, 0.02773455f, 
    -0.03537761f, -0.06144430f, 0.03864069f, -0.01592987f, -0.04756793f, -0.02280625f, 0.01305787f, -0.04872693f, 
    -0.03943488f, -0.03565344f, -0.00796674f, -0.00488684f, -0.00364502f, 0.03641267f, 0.00370041f, 0.00746200f, 
    0.00228884f, -0.03842918f, -0.05133708f, -0.02534750f, -0.04635205f, -0.00425242f, -0.02015273f, 0.02539967f, 
    0.03837099f, -0.04742514f, 0.01175192f, 0.02789381f, 0.01205879f, 0.03193094f, -0.03693709f, -0.03636468f, 
    0.01761809f, 0.01601872f, 0.02819062f, -0.00015871f, 0.00497123f, -0.02590346f, -0.01616098f, -0.03670662f, 
    0.02934778f, -0.01290626f, 0.02889541f, -0.02796841f, 0.01821780f, -0.03491070f, 0.02048282f, -0.05359926f, 
    -0.02296906f, 0.10759100f, -0.07372840f, -0.25209436f, -0.01055751f, -0.07581672f, -0.01385306f, 0.18642142f, 
    -0.00189070f, -0.05500078f, -0.09716484f, -0.22533619f, 0.02865279f, -0.10429985f, 0.06830286f, -0.20529597f, 
    0.00549741f, 0.05661532f, 0.02176403f, 0.01902727f, -0.14275180f, -0.04525751f, 0.11655485f, -0.05464959f, 
    -0.25883269f, 0.11154393f, -0.17399725f, 0.04362888f, -0.14939740f, 0.17898892f, -0.15823810f, -0.11954761f, 
    0.11151654f, 0.06835192f, 0.09677704f, -0.05492182f, -0.02413267f, 0.23723476f, 0.05313237f, 0.10495882f, 
    0.02470431f, 0.08935316f, 0.07993941f, 0.07049584f, 0.10826026f, 0.02150723f, 0.02407808f, 0.03768801f, 
    0.17636539f, -0.18050587f, 0.15551025f, -0.27202243f, 0.05447357f, 0.12171796f, -0.06876656f, -0.00058583f, 
    0.05932444f, 0.04283872f, -0.04236394f, -0.15349719f, -0.11422940f, 0.13282351f, 0.17103615f, 0.04112628f, 
    0.04585978f, 0.00038717f, 0.07365339f, 0.06957234f, -0.02656053f, 0.06182021f, -0.05428453f, 0.11817357f, 
    0.34331724f, -0.06531807f, -0.06469178f, -0.21104927f, -0.05140435f, 0.08402772f, 0.02308410f, 0.03421460f, 
    0.06886437f, -0.06473614f, -0.00735908f, 0.10827498f, -0.46870017f, 0.07367865f, -0.13352005f, -0.03229885f, 
    -0.03798173f, -0.03190324f, -0.02954256f, -0.06771182f, -0.09695262f, 0.02942021f, 0.14710757f, 0.19241944f, 
    0.00295054f, -0.03294056f, -0.12652807f, 0.04272013f, -0.07176618f, -0.06725455f, -0.10529255f, 0.01939401f, 
    -0.08789605f, 0.15227343f, -0.09375757f, 0.04735441f, -0.28303599f, 0.18124431f, 0.11215810f, 0.03808126f, 
    -0.03275992f, -0.04669403f, -0.12804256f, -0.00670684f, 0.03080648f, -0.02343454f, -0.06880684f, -0.24760012f, 
    0.34205347f, 0.14936300f, -0.03272662f, 0.02361595f, -0.01202228f, -0.06727679f, 0.00382271f, -0.21287709f, 
    -0.10345173f, -0.05117990f, -0.06766750f, -0.08175259f, -0.12006007f, -0.01303866f, -0.01769132f, 0.12743628f, 
    -0.01734863f, 0.15088092f, -0.00337043f, -0.11994221f, -0.13209924f, 0.03786864f, -0.20430820f, 0.02441831f, 
    -0.13064109f, -0.26526910f, -0.14069507f, 0.01897190f, -0.12653270f, 0.24018931f, 0.06086710f, 0.08894412f, 
    0.02662765f, -0.08515166f, -0.00278434f, -0.10810052f, 0.14640145f, 0.07718649f, -0.05283139f, -0.07934280f, 
    -0.01779544f, 0.07385705f, 0.09139580f, -0.15723851f, 0.12183741f, -0.21574354f, 0.16361834f, 0.00807444f, 
    0.35276920f, 0.24997227f, -0.18179882f, -0.07458811f, 0.12683773f, 0.09196716f, -0.10626879f, -0.14259726f, 
    0.09356382f, 0.01251899f, 0.21123451f, 0.13994910f, -0.04890728f, 0.04491262f, 0.08626805f, 0.05969881f, 
    0.15124832f, 0.07301067f, 0.01747969f, -0.20625584f, -0.05791388f, -0.11729674f, -0.22372682f, -0.13470876f, 
    0.20997983f, -0.20751011f, 0.25092083f, 0.22176650f, 0.02892442f, 0.04512545f, -0.06113182f, -0.19162856f, 
    0.04570812f, 0.00107096f, 0.04623685f, 0.04007468f, 0.53611982f, -0.02801034f, -0.17927386f, 0.12264743f, 
    -0.20771387f, 0.07809015f, 0.05235093f, 0.12394508f, 0.04145979f, 0.05148380f, 0.01565086f, -0.02922966f, 
    -0.17568085f, -0.15193838f, -0.24983694f, -0.11656323f, -0.12393991f, -0.17333469f, 0.02343474f, 0.10566312f, 
    0.01777979f, 0.02237768f, 0.14547595f, 0.03092985f, -0.05501988f, -0.11576030f, 0.01419080f, -0.07512891f, 
    0.02336819f, 0.27405933f, 0.12936807f, 0.03876281f, 0.19642843f, 0.12558617f, 0.17244184f, 0.18710120f, 
    0.27231547f, -0.24394773f, 0.08923688f, 0.11616139f, -0.04226467f, 0.04705922f, 0.06776151f, -0.09419204f, 
    0.05465813f, -0.10679873f, -0.01371930f, 0.08890471f, -0.09448072f, -0.02215196f, 0.07497948f, 0.04045839f, 
    0.11492462f, -0.07986015f, -0.10695509f, 0.04753951f, -0.08125954f, -0.13523056f, -0.01622946f, 0.06516474f, 
    0.07670669f, -0.04275548f, -0.11307471f, -0.04449150f, -0.08466656f, -0.15245788f, 0.02645736f, 0.03985986f, 
    -0.00800001f, 0.00671695f, -0.10037304f, 0.03632509f, 0.51156271f, -0.21017414f, -0.04889311f, 0.12365198f, 
    -0.04535009f, -0.04681917f, 0.00243452f, 0.13629855f, -0.11244114f, 0.20542687f, -0.04250014f, 0.08666390f, 
    0.24596751f, 0.03511526f, -0.08944868f, 0.03268695f, 0.04607276f, -0.18153977f, -0.03425467f, 0.03603120f, 
    0.00182589f, 0.11047037f, 0.06250378f, -0.03510055f, -0.16854915f, 0.01104372f, 0.03333429f, -0.13832529f, 
    -0.16052811f, 0.10473847f, 0.09949778f, -0.25898331f, -0.00503909f, 0.11632069f, 0.03486066f, -0.01990660f, 
    0.18531613f, 0.00953576f, -0.07687049f, 0.06242869f, -0.01064100f, 0.03160162f, 0.01020077f, 0.02834838f, 
    0.18757257f, -0.08401214f, -0.20269537f, 0.09630872f, 0.29276896f, 0.18487363f, 0.00285152f, 0.12765639f, 
    -0.09559593f, 0.16141041f, -0.06906529f, 0.16886033f, 0.18413183f, 0.05391971f, 0.06886289f, -0.14435495f, 
    0.18210779f, -0.21053611f, -0.00818638f, 0.12444185f, 0.02667414f, 0.20567846f, -0.03236131f, -0.00106953f, 
    -0.06280977f, 0.22692508f, -0.11068290f, 0.04420944f, 0.08306035f, 0.21306206f, -0.04897499f, 0.08159038f, 
    -0.03067099f, 0.11161762f, -0.12274137f, -0.06607198f, -0.00489252f, -0.16009389f, 0.06945530f, 0.03149981f, 
    0.02297786f, -0.18528749f, -0.18938531f, 0.04624879f, 0.01938915f, -0.02206528f, 0.07445426f, -0.04696729f, 
    0.03530253f, 0.05650711f, 0.31520566f, -0.08402566f, 0.30241349f, 0.07003865f, 0.04898972f, 0.14944892f, 
    0.09632877f, 0.15957080f, 0.08875298f, -0.06879734f, -0.04810378f, -0.28208500f, -0.06464046f, -0.19071132f, 
    0.00456566f, 0.02973621f, 0.00934044f, -0.01912501f, -0.02088081f, -0.02588751f, -0.00538558f, 0.00550303f, 
    0.03526304f, -0.01961879f, -0.01186061f, 0.01001522f, -0.00906161f, 0.01142084f, 0.04239908f, 0.00314833f, 
    0.02994443f, -0.02275660f, -0.02009103f, -0.03052323f, 0.03930976f, -0.01738136f, 0.02116041f, 0.03233937f, 
    -0.01390532f, -0.00173050f, 0.00976441f, 0.03162768f, -0.05037132f, 0.01435511f, -0.02136399f, -0.05147269f, 
    0.01541955f, -0.05606831f, -0.01610858f, 0.00502441f, -0.00478262f, -0.04518432f, -0.02878639f, -0.00098706f, 
    -0.00411616f, -0.05133230f, -0.01421824f, 0.04240092f, -0.01907982f, -0.01555189f, 0.04081120f, 0.03421913f, 
    -0.01525277f, 0.03037790f, -0.03510426f, -0.01351184f, 0.03593206f, 0.01148869f, 0.02004179f, -0.04956605f, 
    -0.00985830f, -0.02296591f, -0.02632192f, -0.05755708f, 0.01351475f, -0.03871415f, 0.02766974f, -0.02635737f, 
    -0.04309118f, -0.05591594f, -0.04636192f, -0.01258161f, 0.02400216f, -0.01566581f, -0.02564762f, -0.03032934f, 
    -0.02297414f, -0.05243080f, 0.00204265f, -0.01056830f, 0.03397981f, -0.05666690f, -0.03086019f, 0.00579241f, 
    -0.02009329f, -0.01042211f, 0.01780762f, -0.01163017f, 0.04305645f, -0.01110917f, -0.01757391f, -0.04910878f, 
    0.03014171f, 0.03569620f, -0.00732045f, 0.01575771f, -0.00584585f, 0.03914709f, -0.02665238f, -0.04198147f, 
    -0.00803623f, 0.03173281f, 0.01226491f, -0.01259802f, -0.02667462f, -0.01315277f, -0.05508790f, -0.05547034f, 
    0.04207373f, 0.01403929f, 0.02352678f, 0.04363926f, -0.05444119f, -0.05588210f, -0.03415322f, -0.03840949f, 
    -0.03727079f, 0.03930034f, -0.02099446f, -0.04753611f, 0.02527516f, -0.01867613f, -0.05831013f, 0.00977680f, 
    0.04035515f, 0.00348839f, 0.02777505f, -0.04855414f, 0.00149507f, 0.04370673f, 0.03202503f, 0.01840584f, 
    -0.01730095f, 0.02747847f, 0.03640109f, -0.05287823f, 0.00365314f, -0.01593673f, 0.02890476f, 0.03085735f, 
    -0.04798380f, 0.01589676f, 0.02872808f, -0.03942894f, -0.02356445f, 0.00520156f, 0.03682445f, -0.04060035f, 
    -0.01511900f, -0.00453398f, -0.00590011f, 0.03273787f, 0.03975066f, 0.00122986f, 0.03420659f, -0.00472080f, 
    0.02219259f, -0.00849137f, -0.01048928f, -0.01159311f, -0.05515896f, -0.03407556f, 0.02909917f, 0.02395522f, 
    -0.04412721f, 0.03771076f, 0.03801218f, 0.01413591f, -0.05079136f, -0.00037935f, -0.04306969f, 0.03262362f, 
    0.03216560f, 0.01336820f, 0.01998925f, -0.03453333f, 0.01543593f, -0.01275326f, 0.02721460f, 0.00093771f, 
    0.03060034f, -0.00369075f, -0.03581873f, -0.02245166f, 0.00421050f, -0.01121885f, 0.04837826f, 0.04151383f, 
    -0.03914017f, -0.04333331f, -0.01336207f, -0.00839967f, -0.04877894f, -0.01270311f, -0.00326188f, 0.00367706f, 
    -0.04465969f, -0.00015204f, -0.00149635f, 0.00813004f, 0.03857429f, -0.02324529f, 0.03838342f, 0.01122115f, 
    -0.00327636f, -0.03925592f, 0.03558365f, 0.00813587f, 0.03586480f, 0.00298685f, -0.00035207f, 0.00175931f, 
    -0.03671115f, -0.04964665f, -0.02645648f, 0.00409132f, -0.04759935f, -0.01013120f, 0.03919854f, 0.02684451f, 
    -0.05970925f, 0.00462879f, 0.00667191f, -0.04578269f, 0.01802377f, -0.02927446f, -0.04707707f, 0.01894976f, 
    0.03473099f, -0.01019785f, -0.00322693f, -0.04689418f, -0.01712618f, -0.02034791f, -0.00208771f, -0.04387753f, 
    -0.03408378f, 0.01177328f, -0.02946857f, -0.02275163f, 0.01883564f, 0.03156845f, 0.02016992f, -0.03061137f, 
    0.01818356f, -0.02688297f, -0.05651745f, -0.02963623f, -0.06009967f, -0.02605435f, -0.04785754f, 0.01767666f, 
    0.00413661f, -0.04972407f, 0.02010191f, -0.04505196f, -0.00007915f, 0.03958261f, -0.02728744f, -0.03329410f, 
    -0.03537589f, -0.00531758f, 0.01911025f, -0.05867728f, -0.03336246f, 0.01916768f, -0.06005279f, -0.05165511f, 
    -0.03720110f, -0.01256953f, 0.00494144f, -0.02303286f, -0.02713704f, -0.01891820f, -0.01209306f, 0.04300738f, 
    0.03101592f, -0.02307597f, 0.03099197f, -0.02874383f, -0.00788698f, -0.00189484f, -0.04334592f, 0.01091478f, 
    0.01867668f, 0.01100790f, -0.05123198f, -0.01558722f, -0.02885766f, -0.00556257f, 0.03782558f, -0.02942620f, 
    -0.01574302f, -0.05422209f, -0.03165264f, 0.01456590f, -0.00317355f, 0.02257505f, -0.00838591f, 0.02578111f, 
    -0.01010816f, 0.00402680f, 0.01922112f, -0.00729250f, 0.02516344f, 0.02398048f, 0.01470725f, -0.02948922f, 
    0.00163309f, 0.03780505f, 0.00395861f, -0.01956972f, -0.05581662f, 0.02772956f, 0.03800204f, -0.00608497f, 
    -0.02156715f, 0.00617062f, -0.02045386f, -0.00616335f, 0.03101255f, 0.03428603f, 0.01762623f, 0.03757204f, 
    -0.05063435f, 0.00991035f, -0.01472209f, -0.01832392f, -0.00730333f, 0.00819309f, -0.03435305f, 0.03150091f, 
    -0.01272052f, -0.03244613f, -0.00151144f, 0.01567371f, 0.01968383f, 0.00492512f, 0.04455460f, 0.04185779f, 
    0.01114770f, 0.04620297f, 0.01001293f, 0.00172554f, -0.04214058f, 0.02941168f, 0.03306509f, 0.01186373f, 
    -0.03822891f, 0.04919603f, 0.00734645f, -0.05258946f, -0.01244782f, -0.03001527f, -0.04903321f, 0.03736864f, 
    -0.02748293f, 0.00093476f, -0.05423046f, -0.03546566f, 0.00873608f, 0.02141807f, -0.01777250f, 0.01542876f, 
    0.04377586f, 0.02769648f, -0.04450662f, -0.03031584f, -0.03888376f, -0.03770315f, 0.04161971f, 0.01082152f, 
    -0.03378469f, 0.00729141f, 0.02554086f, -0.03976870f, 0.02512551f, -0.01025936f, 0.01936433f, -0.03272334f, 
    -0.04120088f, -0.05917000f, -0.05956345f, 0.03368773f, -0.01783017f, -0.05495414f, 0.04207729f, -0.05317436f, 
    -0.41435000f, 0.20793068f, -0.08771631f, 0.20583203f, -0.22207254f, -0.20040901f, 0.03646313f, 0.05787694f, 
    -0.12451028f, -0.03989374f, -0.04065536f, -0.10754807f, 0.24276191f, 0.21903837f, 0.06733403f, 0.11608198f, 
    -0.23128086f, -0.02743454f, 0.10412554f, 0.10644021f, -0.02561305f, -0.15514572f, 0.09149554f, -0.09397762f, 
    0.01284664f, 0.17536736f, 0.13338295f, -0.09395656f, 0.14956410f, 0.18882935f, 0.18519574f, -0.10211438f, 
    -0.07393600f, 0.14016218f, 0.11079748f, 0.05142271f, -0.39194199f, 0.15554793f, -0.31735611f, 0.29425102f, 
    0.28744176f, 0.03774936f, 0.03315489f, -0.14534664f, 0.01216737f, 0.07249743f, 0.08444024f, 0.17606264f, 
    0.20148762f, -0.10271002f, -0.04373102f, 0.18017730f, -0.09091961f, 0.07836471f, 0.04346326f, 0.13091528f, 
    -0.21832976f, 0.01364322f, 0.05857500f, -0.18518381f, -0.05546762f, 0.27619347f, -0.07979965f, 0.32515877f, 
    0.05584896f, -0.07184667f, -0.07642019f, 0.11979946f, 0.04130164f, 0.02734459f, 0.01570676f, 0.04312163f, 
    0.15594617f, 0.02627639f, -0.04021303f, 0.01417919f, -0.19056228f, 0.08799347f, 0.13736181f, -0.00770941f, 
    -0.08565105f, -0.19981591f, -0.02488335f, 0.07337093f, -0.29798546f, 0.04222881f, -0.25755951f, -0.10885152f, 
    0.08051793f, -0.02542119f, 0.07336862f, -0.05953573f, -0.08806900f, -0.09860079f, -0.12634045f, 0.08684030f, 
    -0.16827354f, -0.01758167f, -0.06209968f, -0.27852809f, 0.08667558f, 0.01813802f, -0.05348223f, 0.10332114f, 
    0.06773617f, 0.09793423f, -0.02090812f, 0.08727149f, 0.14762239f, 0.09254205f, 0.03936344f, -0.28590077f, 
    0.06220866f, 0.09459125f, 0.08637073f, -0.13490276f, 0.01660508f, -0.09428593f, 0.02988163f, -0.03980822f, 
    -0.11333104f, -0.04030072f, -0.02638366f, 0.02474862f, 0.22013867f, -0.16617288f, -0.06254376f, -0.05664120f, 
    -0.05331571f, 0.06209178f, -0.01555208f, 0.07164367f, 0.35817295f, -0.15893026f, 0.05888735f, -0.17559586f, 
    0.03328529f, 0.05966713f, 0.04059176f, 0.04445786f, 0.06832367f, -0.08581675f, -0.04517761f, 0.08281814f, 
    -0.20630361f, 0.04678441f, -0.02267710f, 0.13015358f, 0.04125569f, 0.24669167f, 0.08364917f, 0.16618647f, 
    -0.07376627f, 0.04027740f, -0.07736888f, 0.04108945f, -0.21220502f, -0.04681972f, 0.04045317f, -0.53843945f, 
    0.07717134f, -0.20041791f, 0.03791049f, 0.11560291f, 0.00599805f, -0.15607128f, 0.08791449f, 0.03688927f, 
    -0.08680016f, 0.18591201f, -0.27948475f, -0.15723458f, 0.35851842f, 0.07256781f, -0.01858966f, -0.02683490f, 
    0.08027355f, 0.12607992f, 0.11849042f, 0.04318352f, 0.20819546f, 0.20757197f, -0.07213965f, 0.16092749f, 
    0.18092948f, 0.10497379f, -0.00446875f, 0.04847907f, -0.16201940f, 0.13155352f, 0.05181061f, 0.16740862f, 
    0.76698768f, 0.21137257f, 0.06095415f, 0.38373235f, 0.11431696f, 0.21001504f, 0.03175652f, 0.09107259f, 
    0.16661346f, 0.13540898f, 0.02256076f, 0.01709089f, 0.07420620f, -0.15825620f, -0.37431929f, 0.43009150f, 
    0.18999375f, -0.00998512f, -0.15296671f, -0.03353011f, 0.20581691f, 0.04607127f, 0.07650416f, 0.04426670f, 
    -0.01961439f, 0.20207135f, -0.01851775f, -0.03443692f, 0.04206812f, -0.01175915f, -0.07169821f, -0.06959931f, 
    0.23408635f, -0.05695051f, 0.05567669f, 0.09833860f, -0.18249846f, 0.09820023f, 0.04954939f, -0.10526653f, 
    0.06326427f, -0.03492399f, 0.10190970f, 0.06148587f, -0.07524723f, 0.05333539f, 0.02173289f, 0.06362307f, 
    0.07524543f, -0.36896580f, 0.38205659f, 0.01814783f, 0.03859008f, -0.01148711f, -0.09590501f, -0.01828310f, 
    0.12993163f, -0.08236110f, 0.01934570f, 0.01448622f, -0.16885900f, -0.13711730f, -0.07323338f, -0.04860101f, 
    0.09734682f, -0.14750457f, -0.05501818f, 0.13953716f, 0.09810539f, 0.09638828f, -0.02613075f, 0.13839991f, 
    -0.50910324f, -0.27067694f, 0.27551866f, -0.48063433f, 0.11318018f, -0.02091080f, 0.00364682f, -0.16785775f, 
    -0.00704533f, -0.03024890f, -0.00441297f, -0.11660910f, 0.23954941f, -0.24379958f, -0.16867429f, 0.04648849f, 
    0.20861931f, 0.04639034f, -0.03987732f, 0.09181206f, 0.09490754f, 0.15460870f, -0.02946319f, 0.08151066f, 
    -0.03792777f, -0.27121672f, -0.21275662f, 0.03312295f, 0.30557406f, 0.06870691f, 0.00238836f, -0.13634449f, 
    0.22321454f, 0.12157042f, 0.11640550f, -0.00541447f, -0.26591772f, 0.32909057f, -0.06451237f, 0.13793226f, 
    0.01733431f, 0.01725572f, 0.08940018f, -0.08036031f, -0.02890238f, 0.20600523f, 0.10756190f, 0.06689501f, 
    0.13616163f, 0.29819301f, -0.19906731f, 0.23236161f, -0.05422726f, 0.14534016f, -0.07423244f, -0.06810932f, 
    0.10547346f, 0.09480739f, -0.08559363f, 0.00805993f, -0.02821237f, 0.22073931f, -0.08134600f, 0.06032610f, 
    0.12743609f, 0.13564365f, -0.05248716f, -0.04928495f, -0.10660007f, 0.16146713f, 0.14680703f, -0.09631350f, 
    -0.11714703f, 0.11821441f, -0.26675507f, 0.38639572f, 0.06208270f, 0.07187618f, 0.02592455f, -0.03716710f, 
    0.05215980f, 0.07952064f, 0.03998335f, -0.02207992f, 0.27283335f, 0.03427822f, -0.11448101f, 0.28209624f, 
    0.04785919f, 0.04273332f, -0.06975271f, 0.09797911f, -0.03277645f, 0.03280490f, 0.03246397f, 0.01831744f, 
    -0.07060229f, -0.08640170f, -0.00236635f, -0.03953534f, -0.13141663f, 0.04369029f, -0.05470006f, 0.08564208f, 
    0.00785227f, 0.02049987f, 0.03910516f, 0.00504471f, 0.02347728f, 0.07567921f, 0.03976207f, 0.00738044f, 
    0.18538833f, 0.06822728f, 0.13802332f, 0.01189321f, -0.08668437f, 0.03167632f, -0.06197255f, 0.06659214f, 
    0.03783573f, 0.14209463f, -0.00309789f, 0.27288860f, -0.15650193f, 0.06754367f, -0.06636184f, -0.22827606f, 
    -0.01589910f, 0.06606198f, 0.19625467f, 0.15937038f, -0.50546068f, 0.23216484f, 0.17556131f, 0.26205105f, 
    0.03722195f, -0.04744657f, 0.02460152f, 0.23138945f, -0.12710218f, -0.16670585f, -0.10063010f, 0.09789771f, 
    0.25720003f, 0.16900466f, 0.05651901f, 0.17032483f, 0.13731861f, 0.02849604f, 0.07788669f, -0.07984857f, 
    -0.20709795f, 0.08968959f, -0.09934535f, 0.17737046f, 0.51980895f, -0.17040369f, -0.02459677f, 0.06715110f, 
    0.01571362f, -0.08530407f, 0.03036816f, -0.17098947f, 0.00195215f, -0.10778979f, -0.04153118f, 0.06686502f, 
    -0.02397297f, -0.01095886f, 0.05671638f, 0.23433752f, 0.01128905f, 0.00904944f, 0.15093791f, 0.17207773f, 
    0.05282019f, 0.00090611f, -0.03262372f, 0.02010634f, 0.00165822f, 0.09711324f, 0.00521101f, 0.02374117f, 
    0.03931645f, -0.12434906f, -0.12855393f, -0.10606222f, -0.01501179f, 0.09204082f, 0.17341618f, -0.02055637f, 
    -0.15879418f, -0.10096417f, 0.20418897f, 0.22071445f, 0.07659855f, 0.00722395f, -0.00518860f, 0.05145574f, 
    0.03363892f, -0.08690362f, -0.02760860f, -0.07646925f, 0.41039875f, 0.22282627f, 0.05568515f, -0.05010020f, 
    0.06934597f, -0.00275097f, 0.11572014f, 0.00563963f, 0.13083935f, 0.03618722f, 0.03103465f, -0.05661943f, 
    0.17623270f, -0.11133654f, 0.06801009f, 0.07025987f, 0.17114072f, 0.16678593f, -0.12867422f, 0.08982318f, 
    -0.05525236f, -0.07773940f, 0.23260781f, -0.05741432f, -0.03945333f, -0.19424279f, -0.05406084f, -0.13384621f, 
    0.15613444f, -0.08410224f, -0.11427688f, -0.24159682f, 0.00618443f, -0.03950661f, -0.02085642f, 0.17039715f, 
    0.17065191f, 0.14573909f, -0.01952950f, 0.40445819f, -0.00859242f, -0.11106989f, -0.01989398f, 0.00210463f, 
    0.16736652f, 0.14753596f, 0.09823921f, 0.11773048f, 0.33809114f, -0.62365568f, -0.11328902f, -0.32418054f, 
    -0.23007612f, -0.07678925f, -0.08087348f, 0.03163972f, 0.20226413f, -0.03109817f, 0.15377942f, 0.12603563f, 
    0.32071999f, -0.07986880f, 0.08081891f, -0.00911526f, 0.00457392f, -0.02483471f, -0.04916979f, 0.06909639f, 
    -0.08558498f, 0.09071843f, -0.08968149f, 0.10659734f, 0.17324033f, 0.04739781f, 0.09762309f, -0.19375852f, 
    0.19628768f, 0.00059486f, -0.04773876f, 0.31737232f, 0.14382835f, 0.11233488f, -0.14953619f, 0.03432643f, 
    0.13389516f, -0.10755681f, 0.03123323f, 0.38796425f, 0.00772742f, -0.19496994f, -0.10672269f, 0.07096674f, 
    0.11102376f, -0.09461366f, -0.02361179f, -0.15133049f, -0.01717533f, -0.06359849f, 0.01705542f, 0.07704616f, 
    -0.10091136f, -0.05746816f, -0.03449025f, -0.10333139f, -0.11281921f, -0.02187466f, -0.07903741f, 0.23284982f, 
    -0.36879635f, -0.07089838f, -0.20546426f, 0.16345638f, 0.10804965f, 0.00720756f, -0.05088478f, 0.05687725f, 
    -0.04061581f, 0.13341925f, -0.04027596f, -0.08299956f, -0.12366712f, 0.11769290f, -0.23791595f, 0.02676752f, 
    0.25486490f, -0.11448269f, 0.00787373f, -0.10090953f, 0.06185332f, -0.08014282f, 0.05333328f, -0.00086123f, 
    -0.02917477f, 0.17576033f, 0.20562841f, 0.40285164f, 0.20891391f, -0.02321860f, 0.13874158f, -0.00346586f, 
    0.06551352f, 0.00357285f, 0.00771514f, -0.10829823f, 0.22178215f, 0.09317543f, -0.08209872f, 0.01332743f, 
    -0.03794931f, -0.04711860f, 0.07721160f, -0.04122230f, -0.26281857f, 0.03307625f, 0.09267195f, -0.11582310f, 
    0.03075174f, 0.10375421f, 0.20708828f, -0.13928339f, 0.11792288f, 0.06976869f, 0.01409540f, 0.07569225f, 
    -0.00546842f, 0.13047853f, 0.08725984f, 0.06066186f, -0.24004433f, 0.31519750f, 0.06928271f, -0.02576996f, 
    -0.09126238f, 0.05468409f, 0.07869642f, -0.08753607f, 0.05589433f, 0.03912666f, -0.06287288f, -0.17835429f, 
    0.70822400f, 0.23996216f, 0.29336655f, 0.14588106f, 0.13392501f, 0.09996113f, -0.02368584f, -0.09880097f, 
    -0.05160889f, -0.01342862f, 0.13101020f, 0.02209661f, 0.07439757f, 0.06949468f, 0.04052281f, 0.33438757f, 
    0.00577094f, 0.09569497f, 0.06174914f, -0.09722071f, 0.10474048f, -0.12245388f, -0.13622095f, 0.02901890f, 
    0.37501791f, 0.05906061f, 0.07975637f, 0.13755141f, 0.06132771f, 0.07886555f, -0.00325061f, -0.13689764f, 
    0.09636902f, -0.10895625f, -0.01824861f, -0.16109395f, 0.06394040f, -0.07807192f, -0.27730003f, 0.09390368f, 
    -0.02058349f, -0.03576977f, -0.08516025f, 0.13230072f, -0.05202119f, -0.11517724f, 0.10112131f, 0.09210478f, 
    -0.20004144f, -0.10398107f, -0.13519229f, 0.27113947f, 0.00540956f, 0.01801365f, 0.02481818f, 0.09299270f, 
    -0.02244274f, 0.01839128f, 0.13128594f, -0.05331559f, -0.11400668f, -0.15669733f, -0.26555362f, 0.24314399f, 
    0.03068555f, -0.01975910f, -0.00395589f, -0.09971636f, -0.13985056f, 0.00135400f, 0.03926604f, 0.01898846f, 
    0.07280582f, 0.07336152f, -0.34803617f, -0.07936788f, -0.12589705f, -0.16382165f, 0.15138276f, -0.15080698f, 
    0.04373648f, -0.10222103f, 0.12145857f, -0.00898844f, 0.42936128f, 0.10375819f, -0.21337764f, -0.01041770f, 
    -0.21273372f, -0.01514682f, 0.13758652f, -0.02958447f, 0.05168789f, 0.07450698f, -0.03925902f, -0.14656714f, 
    -0.57323974f, 0.22284421f, 0.05765761f, -0.05540822f, 0.01366169f, -0.04324330f, -0.10934138f, 0.08840297f, 
    -0.09127011f, -0.00276237f, -0.20933254f, -0.06839661f, -0.19121435f, -0.01891698f, -0.05594129f, -0.02713279f, 
    0.02703400f, -0.08582964f, 0.03929662f, -0.13270386f, 0.16030243f, 0.04962004f, -0.13053119f, 0.08514149f, 
    0.32985476f, -0.14152637f, -0.04505021f, 0.17049800f, 0.10575617f, -0.11578582f, 0.16717860f, 0.12459338f, 
    -0.10176755f, -0.05074024f, -0.02931635f, -0.08531790f, -0.26575136f, -0.00435832f, 0.18238522f, -0.05366842f, 
    0.16334815f, 0.15583237f, -0.06829833f, 0.08803016f, -0.11111640f, 0.11525693f, 0.13584553f, 0.03397670f, 
    0.15719047f, 0.17242227f, -0.19691902f, 0.08371159f, -0.06233104f, 0.12233490f, -0.18357143f, -0.08091098f, 
    0.07889027f, -0.16221796f, 0.12868519f, -0.06218395f, -0.24136955f, -0.04197394f, 0.01249087f, 0.02396636f, 
    0.07763695f, 0.05817882f, 0.16431926f, 0.02597902f, 0.11737058f, 0.11927485f, 0.03041658f, -0.13960603f, 
    0.32705578f, 0.00298502f, 0.12035679f, -0.02744348f, 0.08460139f, 0.02161928f, 0.02858306f, -0.08423814f, 
    0.05451955f, -0.04087102f, -0.11855842f, -0.06452997f, 0.12427277f, -0.21059978f, 0.25873831f, 0.04729652f, 
    -0.07276699f, -0.21294609f, 0.09004492f, 0.06396344f, 0.05407030f, -0.01419417f, 0.00850065f, 0.06134265f, 
    0.19978468f, 0.10881949f, 0.08765578f, 0.16456255f, -0.10775802f, 0.13227688f, 0.09532016f, 0.16172387f, 
    0.10324507f, 0.17652653f, -0.03527825f, 0.23879839f, -0.27016282f, -0.06136811f, -0.17209654f, 0.09593737f, 
    -0.10964507f, 0.02804521f, 0.00297275f, -0.13618039f, -0.13204715f, -0.03139783f, 0.08554573f, 0.12213347f, 
    -0.03471510f, -0.03814615f, 0.02676589f, -0.11758447f, -0.02188431f, -0.10672841f, -0.18737440f, 0.03334471f, 
    0.07634784f, 0.08935869f, -0.02426767f, 0.17493871f, 0.19641876f, -0.13422987f, -0.19175269f, 0.31190136f, 
    -0.09119000f, -0.15019582f, 0.09604561f, -0.02748061f, 0.12672515f, -0.05295593f, -0.05464260f, -0.22019884f, 
    -0.28351334f, 0.03159988f, 0.09302101f, -0.19451979f, 0.06375799f, 0.00558614f, -0.14743134f, 0.10310300f, 
    -0.21634755f, -0.13381162f, -0.09377431f, -0.26267770f, 0.19934450f, -0.00172886f, 0.37498629f, 0.05301988f, 
    0.11828029f, 0.09703784f, -0.04198709f, -0.24646874f, -0.16619636f, 0.03053866f, -0.08056846f, -0.03853742f, 
    -0.08853424f, -0.12049463f, -0.12487840f, 0.13370794f, 0.09472661f, 0.09173415f, 0.11471743f, -0.03965617f, 
    0.01342760f, -0.22515801f, 0.14106309f, -0.02895932f, 0.35244942f, 0.00733778f, -0.06422775f, 0.09405813f, 
    -0.00191283f, -0.01983011f, -0.07466740f, -0.06635463f, -0.04458500f, -0.18282545f, 0.06057562f, 0.05568139f, 
    0.00603083f, 0.13867135f, 0.05722516f, -0.10894557f, -0.02531768f, 0.11878962f, -0.12006605f, -0.21087763f, 
    0.01227959f, 0.04183380f, 0.04825581f, 0.13054286f, -0.13193049f, 0.11257393f, 0.19212195f, -0.05245614f, 
    -0.05432727f, -0.03905049f, 0.16027324f, -0.00559413f, 0.04362289f, 0.02958793f, -0.14041044f, -0.16197707f, 
    -0.14590015f, 0.13415529f, 0.02430588f, -0.06248575f, 0.07371289f, 0.04717161f, -0.01133337f, 0.05720861f, 
    0.19283961f, -0.04946971f, 0.28449026f, 0.17433825f, -0.12084991f, 0.11830420f, 0.27662474f, -0.11392003f, 
    -0.08446689f, 0.18278059f, -0.05782487f, 0.10571232f, 0.12422264f, 0.00762305f, 0.00262214f, -0.15221366f, 
    -0.04037127f, -0.16077994f, -0.13296080f, 0.17380391f, 0.01588623f, 0.12137616f, 0.01952678f, 0.08700725f, 
    -0.10529429f, -0.20806262f, 0.04921705f, 0.06686541f, -0.15501638f, -0.00056816f, 0.08803019f, 0.10987645f, 
    -0.29491079f, -0.01524680f, 0.12347610f, 0.20605750f, 0.29991907f, -0.08661757f, 0.23443116f, 0.07988013f, 
    -0.19025938f, 0.19853149f, -0.15424402f, -0.03636254f, 0.03060796f, -0.10341314f, 0.08776847f, -0.04724990f, 
    0.00609558f, -0.03526104f, -0.08279012f, 0.09618139f, 0.51230562f, -0.06316347f, -0.11373703f, 0.10586424f, 
    0.01280477f, 0.09971081f, -0.03030075f, 0.10346225f, -0.06289673f, -0.07541559f, 0.02740334f, 0.11387597f, 
    -0.13205983f, 0.20138563f, -0.30001727f, -0.25838041f, 0.16887487f, -0.20947118f, 0.04169918f, 0.00492903f, 
    0.03619114f, -0.02866925f, -0.08107517f, -0.02715774f, -0.11540785f, 0.20462692f, -0.18436360f, -0.41043523f, 
    -0.05844424f, -0.07538926f, -0.14391863f, 0.02589026f, -0.03816427f, 0.01724473f, -0.08148350f, 0.04469684f, 
    -0.19093250f, 0.14526448f, -0.03307611f, -0.25226584f, 0.06596819f, -0.01180965f, -0.11852497f, 0.04547080f, 
    0.07674193f, 0.08109995f, 0.02042660f, 0.07842525f, 0.27603918f, 0.01962777f, 0.09537108f, 0.02603950f, 
    -0.10999162f, 0.08115917f, 0.12684010f, 0.00970739f, -0.12686326f, 0.16261443f, 0.08227681f, -0.10332704f, 
    0.20477162f, -0.10627962f, -0.00434565f, 0.16401680f, -0.07450128f, 0.14606841f, -0.00734964f, 0.06829305f, 
    0.21683875f, 0.02184176f, -0.37591875f, 0.17219879f, -0.16983639f, 0.06248071f, 0.17700064f, -0.16920447f, 
    -0.12515999f, 0.04661085f, -0.05224514f, 0.11739441f, 0.04920362f, 0.05192354f, -0.06519807f, -0.23038180f, 
    -0.38057834f, 0.05154083f, 0.27081802f, 0.20814189f, 0.06085854f, 0.11120562f, 0.01193355f, 0.11628628f, 
    0.20125264f, 0.15684409f, -0.05403221f, 0.01394675f, 0.19802134f, -0.26621872f, 0.13286145f, 0.17374264f, 
    0.05145053f, 0.11080959f, -0.23540463f, -0.05428985f, -0.19071037f, -0.12684396f, 0.05368237f, 0.02931690f, 
    -0.22923701f, 0.08176422f, -0.09519025f, 0.05596123f, 0.14065096f, -0.01243367f, 0.07862196f, 0.23727965f, 
    0.22389652f, 0.03205827f, 0.26115432f, -0.08422850f, 0.21298392f, 0.22749501f, 0.12231967f, 0.05777324f, 
    0.11400603f, -0.18756425f, 0.27224961f, -0.18355481f, 0.07644617f, -0.17691028f, 0.11016802f, -0.19650896f, 
    0.03439948f, -0.05557146f, -0.02440119f, 0.03328535f, -0.02258010f, 0.03779019f, -0.05603705f, -0.03035972f, 
    -0.00228974f, -0.01173007f, -0.04491463f, -0.04270491f, 0.02474538f, -0.01975482f, -0.01333362f, -0.04503305f, 
    0.03892640f, -0.04206670f, 0.00706444f, -0.00084814f, -0.03245957f, -0.04861466f, -0.04409134f, -0.05482233f, 
    -0.02925413f, -0.01589718f, 0.01957676f, -0.05663526f, -0.02348923f, -0.02514107f, -0.02723755f, -0.02359610f, 
    -0.01097312f, -0.04160620f, 0.03357676f, -0.03101712f, -0.02042985f, 0.05142647f, -0.02656073f, 0.00410373f, 
    -0.05447781f, 0.02806518f, 0.01194207f, -0.04486772f, -0.02712427f, -0.04585082f, 0.01682395f, 0.02813956f, 
    0.01660994f, 0.00867190f, 0.03619041f, 0.00816346f, -0.00834261f, -0.02651451f, -0.04350236f, -0.04010845f, 
    0.04722199f, -0.05501528f, -0.02074309f, -0.00399298f, 0.00168025f, 0.04123111f, -0.01678856f, -0.02232395f, 
    -0.01855890f, 0.03822290f, -0.00183090f, -0.01583748f, 0.00216898f, 0.03589999f, -0.03748200f, 0.01340942f, 
    -0.00742053f, -0.05894611f, -0.00641552f, -0.01588056f, -0.01995373f, -0.05682611f, 0.01788667f, -0.02291942f, 
    -0.04599096f, 0.01494240f, -0.05879544f, -0.02480086f, -0.00791826f, -0.05793841f, 0.00598398f, -0.03527880f, 
    0.00673724f, -0.02171038f, 0.03209391f, 0.01043956f, -0.04709664f, 0.02955930f, 0.01580244f, 0.02084396f, 
    -0.02728430f, -0.05098028f, -0.05547293f, 0.02420490f, 0.00265591f, -0.02034374f, 0.04848953f, -0.04595594f, 
    -0.02831087f, -0.04193353f, 0.00386648f, -0.05778076f, 0.03174371f, 0.01409955f, -0.03602143f, 0.00088917f, 
    -0.03012142f, 0.01037731f, 0.04050232f, -0.02410678f, -0.02756834f, 0.02078246f, -0.03768751f, -0.01962222f, 
    0.03397235f, -0.01287341f, 0.04182639f, -0.01836426f, -0.00110826f, -0.04703236f, -0.05019766f, -0.00711977f, 
    0.02255307f, -0.03025613f, -0.05325804f, 0.01941985f, -0.02035095f, 0.00685830f, 0.01645269f, 0.01914278f, 
    0.00715994f, 0.03997027f, -0.03294493f, 0.02899585f, 0.01394042f, 0.04098949f, 0.01301790f, 0.00953046f, 
    0.03322226f, -0.03107750f, 0.01239999f, 0.00567404f, -0.04198635f, -0.01522423f, -0.03459413f, -0.01941675f, 
    0.00238011f, 0.03374169f, -0.01746267f, -0.00808616f, 0.01813876f, 0.00866201f, -0.01718741f, -0.02436609f, 
    -0.01144863f, -0.02631463f, -0.00028495f, -0.05787691f, 0.00019691f, 0.03770648f, 0.01278213f, 0.00990527f, 
    0.01375626f, -0.00744259f, 0.02702464f, -0.04957763f, 0.00260847f, 0.04263623f, 0.01585172f, 0.02892608f, 
    -0.05509489f, -0.00014136f, -0.01409652f, 0.01207996f, 0.01942613f, -0.01210204f, -0.05355844f, -0.00166277f, 
    0.00062301f, -0.02101380f, 0.02984051f, 0.04178150f, 0.04264017f, -0.02780742f, 0.03664763f, 0.02174969f, 
    -0.02087153f, -0.04220869f, -0.01434377f, -0.00584907f, 0.00000535f, 0.04298187f, 0.01226053f, -0.04676556f, 
    0.01323695f, -0.00689375f, 0.03943751f, 0.02717191f, 0.02617427f, -0.04847411f, -0.01526425f, -0.01653501f, 
    -0.01367209f, -0.03880217f, 0.02903120f, 0.00403112f, 0.04146545f, -0.00690080f, 0.02683575f, 0.00916483f, 
    -0.02987728f, -0.01257244f, 0.00439437f, -0.02027568f, 0.00000507f, 0.01419007f, 0.04046025f, 0.01961549f, 
    0.02669661f, -0.02488300f, 0.03531585f, -0.01159850f, -0.03464204f, -0.02073928f, 0.04203218f, -0.04718180f, 
    0.01717056f, 0.01658307f, -0.04220813f, -0.01075083f, 0.03067694f, -0.00213536f, -0.03176101f, 0.00371997f, 
    -0.04723786f, 0.03293552f, 0.00848839f, -0.04758831f, 0.00268971f, -0.05695253f, 0.03239914f, 0.03519754f, 
    -0.00463884f, -0.02609413f, -0.04005512f, 0.03250258f, -0.04778237f, 0.03923698f, 0.00338536f, -0.02643459f, 
    -0.04152275f, 0.02680397f, 0.03263203f, 0.01496457f, -0.01009602f, -0.03370377f, -0.05624516f, 0.01639395f, 
    -0.02683643f, 0.02628885f, -0.04740126f, -0.01915329f, 0.04165228f, 0.03443446f, -0.03673919f, -0.02236231f, 
    -0.05418113f, 0.01976268f, -0.05210018f, -0.04454264f, -0.03280516f, 0.02787667f, 0.00983126f, 0.00878049f, 
    -0.05503988f, -0.05706277f, -0.03040272f, 0.01472974f, -0.00704293f, 0.03694973f, 0.02789427f, 0.00846047f, 
    -0.05605428f, 0.00608246f, 0.03956848f, -0.04854146f, 0.00304122f, -0.01446357f, -0.04018263f, -0.01156810f, 
    -0.04362139f, 0.03094457f, -0.03724778f, -0.02458970f, -0.01128891f, 0.03901856f, -0.04126164f, -0.00159715f, 
    0.03884844f, -0.03901030f, -0.05755900f, -0.03515735f, 0.03560642f, 0.03837023f, -0.00863938f, -0.02876617f, 
    0.02522649f, -0.01881186f, -0.02033756f, -0.02452897f, -0.04438987f, 0.02723490f, 0.00333884f, -0.04684874f, 
    0.01234836f, 0.00914664f, 0.02490939f, -0.04626642f, 0.02281778f, -0.02852673f, -0.00880732f, -0.02687900f, 
    -0.00810198f, -0.03389355f, -0.02495265f, 0.02597451f, -0.05087904f, 0.03739362f, -0.02136652f, -0.03821532f, 
    0.03542035f, 0.03136432f, 0.01610592f, -0.04877462f, -0.00077923f, 0.03967986f, -0.03755075f, 0.03447687f, 
    -0.04569707f, -0.00890017f, 0.03714351f, 0.02439767f, 0.01463576f, -0.04211150f, -0.02776306f, 0.01374161f, 
    0.00144826f, 0.03958330f, 0.01996465f, -0.01813583f, -0.00479114f, -0.02424169f, 0.03024951f, 0.00477464f, 
    -0.02438151f, -0.00379879f, -0.01578978f, 0.02678480f, -0.00200412f, -0.00718969f, 0.03653695f, -0.05549210f, 
    0.00317467f, -0.04089958f, 0.00205169f, 0.01776118f, -0.01344604f, 0.03827074f, 0.02189727f, -0.03580281f, 
    -0.02360977f, -0.00421415f, -0.02823292f, 0.02731431f, -0.00264633f, -0.02948324f, 0.04575443f, 0.02599653f, 
    -0.00310003f, 0.00324243f, -0.03022168f, -0.00988965f, -0.04752219f, 0.01217230f, -0.05436689f, -0.03467402f, 
    -0.03673607f, -0.01761497f, -0.05012546f, -0.03625076f, 0.00535789f, -0.04235304f, -0.04552731f, 0.00255533f, 
    -0.01272408f, -0.01865990f, 0.00350693f, 0.03364697f, -0.04006753f, 0.02957209f, 0.00839136f, -0.01552633f, 
    -0.04452100f, 0.00771596f, -0.04374749f, 0.00501494f, -0.04411211f, 0.02215750f, 0.01532125f, 0.01996263f, 
    -0.02084938f, -0.05367690f, -0.02535078f, -0.04673358f, -0.03812256f, -0.03771017f, 0.02671211f, -0.00692097f, 
    0.03134014f, -0.00143153f, 0.00358525f, 0.03369076f, 0.04267467f, -0.04399444f, -0.02235983f, -0.00197463f, 
    -0.01762575f, 0.05434788f, -0.00309563f, 0.03025813f, 0.03850203f, -0.00692336f, -0.01014764f, -0.04722838f, 
    -0.03266834f, 0.01540384f, 0.02311698f, -0.01110671f, 0.00457374f, 0.03877643f, -0.01928193f, -0.04396352f, 
    -0.03428833f, -0.03767504f, -0.00884145f, -0.03328406f, -0.01376654f, 0.00874561f, 0.02820285f, -0.05021705f, 
    -0.00205748f, -0.05101569f, 0.00076262f, -0.00811890f, 0.01609853f, 0.00539525f, 0.03143137f, -0.02725665f, 
    -0.02089145f, 0.01151557f, -0.04817212f, -0.02336880f, -0.05546822f, -0.04227016f, 0.00196983f, -0.01245704f, 
    0.01979353f, 0.01373105f, -0.01121401f, -0.00902406f, 0.03711384f, -0.04426742f, 0.03994176f, 0.01078992f, 
    0.03331110f, 0.04503258f, -0.03938079f, 0.02635709f, -0.00716603f, 0.01944452f, 0.01641766f, 0.02083181f, 
    -0.04679485f, 0.02341381f, -0.00220915f, 0.03264141f, 0.01834565f, 0.01649411f, 0.03067074f, -0.02450355f, 
    -0.05921357f, 0.03477612f, 0.03935321f, -0.03638405f, 0.01343385f, -0.00020454f, 0.02990584f, 0.02879655f, 
    0.03296903f, -0.02405442f, -0.05321807f, -0.01183698f, -0.03361886f, -0.01237718f, 0.02960500f, -0.03527808f, 
    0.04762358f, -0.04665093f, 0.01611969f, 0.03006693f, 0.03335858f, -0.04907881f, -0.01694812f, -0.05496870f, 
    -0.02937603f, -0.00470319f, -0.02927497f, -0.02768407f, -0.05030861f, -0.04475065f, 0.05065482f, 0.03516071f, 
    -0.01860960f, 0.04526008f, 0.03745121f, 0.01550012f, -0.03351076f, 0.00991229f, -0.02897869f, -0.05429119f, 
    0.00193202f, 0.03622999f, -0.04798314f, -0.02670938f, 0.01954333f, 0.04089099f, -0.01703487f, -0.00126231f, 
    -0.02543613f, 0.04479358f, 0.04337171f, -0.03230531f, 0.01440701f, -0.00009577f, -0.03365606f, 0.03369068f, 
    -0.01338873f, 0.01408522f, -0.01643539f, 0.02566089f, -0.04448346f, -0.00305814f, 0.00533396f, 0.02440089f, 
    -0.04732567f, -0.04008043f, 0.02754098f, -0.03942833f, 0.01410980f, -0.04472844f, -0.05426683f, 0.02301613f, 
    -0.02206263f, -0.03474166f, 0.04158516f, -0.00502114f, -0.03707265f, -0.01345927f, -0.02238428f, -0.00745274f, 
    0.03259448f, -0.03296991f, 0.00488812f, -0.02778745f, -0.03280624f, 0.00299860f, -0.04680996f, 0.01128263f, 
    -0.02749535f, -0.04064264f, -0.02618285f, 0.01111604f, -0.01355238f, 0.00019623f, -0.05530287f, -0.04068983f, 
    0.01889023f, -0.02167579f, -0.00642966f, -0.00135800f, 0.04185582f, 0.00825901f, 0.02900046f, -0.04004246f, 
    -0.03854620f, 0.00280012f, -0.00554788f, 0.01937505f, -0.02362215f, -0.04347621f, -0.03390332f, -0.02561879f, 
    0.02421722f, 0.01451491f, -0.04204874f, 0.03953250f, -0.02963198f, 0.00736180f, -0.02785110f, 0.02895972f, 
    0.00078076f, 0.03238058f, 0.03214195f, -0.05207537f, -0.03325058f, 0.01079206f, 0.01874457f, -0.04764285f, 
    0.03812280f, -0.01160990f, 0.02770107f, -0.02934230f, 0.03233597f, -0.05156200f, -0.01611621f, -0.01391466f, 
    -0.05682607f, -0.05399342f, 0.01804266f, -0.02042470f, 0.03252508f, -0.02756994f, 0.03212930f, 0.04288331f, 
    -0.04302467f, 0.04067811f, 0.04088403f, 0.00604059f, -0.02927873f, 0.00005916f, -0.02805727f, -0.05589336f, 
    -0.02247808f, 0.02290232f, -0.00254732f, -0.03681043f, -0.04419544f, -0.01473071f, -0.04743729f, -0.00701140f, 
    0.01704915f, 0.04147678f, -0.04460666f, -0.00383728f, 0.01023999f, -0.05521042f, 0.02562297f, 0.03288774f, 
    -0.03610471f, 0.04363251f, 0.03409004f, -0.05580325f, 0.00051514f, -0.05602328f, -0.05658968f, 0.04029745f, 
    -0.02564598f, -0.04406922f, 0.00406333f, -0.03281154f, 0.00474484f, 0.02739089f, -0.04740983f, -0.01979818f, 
    0.02244357f, 0.00738175f, 0.01465161f, 0.04282800f, 0.04553154f, -0.04548806f, -0.00711752f, 0.00470304f, 
    0.03222869f, -0.01020974f, 0.00421004f, -0.01016377f, -0.04579508f, -0.03492934f, -0.03856714f, -0.01812201f, 
    -0.02144241f, 0.00343974f, 0.00859797f, 0.00847925f, -0.03896471f, -0.02036363f, 0.00804825f, 0.01158352f, 
    -0.05584752f, -0.01370061f, -0.02588378f, 0.02461366f, -0.04422217f, -0.02816635f, 0.02158273f, 0.01926910f, 
    0.00174861f, 0.01810846f, -0.04144267f, 0.02399947f, -0.05492055f, -0.00946941f, 0.01321996f, 0.03999326f, 
    0.04151925f, 0.00324979f, 0.01619940f, -0.02010753f, -0.00558051f, -0.04613107f, -0.01440766f, 0.01987014f, 
    0.02507747f, -0.01242809f, 0.03479228f, 0.04670100f, 0.03699317f, -0.03824059f, 0.04547935f, -0.03411419f, 
    -0.05787255f, -0.04377437f, 0.02798144f, -0.02961911f, 0.04799876f, 0.00263168f, 0.01432184f, -0.01192317f, 
    -0.01676217f, 0.03168829f, 0.04345613f, -0.04838246f, -0.00447724f, -0.03270985f, -0.00715783f, -0.05888978f, 
    0.01893010f, -0.01879586f, 0.02452278f, 0.03683420f, 0.02384040f, -0.05257710f, 0.03897676f, 0.00656478f, 
    -0.02909433f, 0.01847838f, 0.01091244f, -0.00925895f, -0.04630451f, 0.02566997f, -0.04676053f, -0.05007144f, 
    0.00005441f, -0.04903516f, -0.00513577f, 0.02710155f, -0.04341877f, -0.05241186f, 0.00568575f, -0.03001941f, 
    -0.00384705f, -0.04650657f, 0.02058613f, -0.05662036f, 0.01657484f, 0.02293801f, 0.00044873f, 0.01526083f, 
    -0.05289046f, -0.01222712f, -0.02810636f, -0.01580487f, 0.04045903f, 0.03198467f, 0.03668573f, 0.00352108f, 
    0.03708527f, -0.00569833f, -0.04388634f, -0.04219449f, 0.00389296f, 0.03389167f, -0.03923034f, 0.02724164f, 
    -0.05239705f, 0.04026107f, -0.05102383f, 0.01941507f, -0.04784431f, 0.01752670f, -0.03847858f, -0.00619679f, 
    0.01259059f, -0.01597422f, 0.03124297f, -0.03997885f, 0.03568932f, -0.04775061f, -0.02900005f, -0.00698271f, 
    0.04151080f, 0.00121302f, 0.03421668f, 0.01355671f, 0.04377880f, -0.04290247f, -0.04540384f, -0.02376300f, 
    0.03829931f, -0.03698413f, -0.02233217f, -0.04651865f, -0.00109136f, 0.00840200f, -0.05528988f, 0.03848117f, 
    0.02850854f, -0.00581864f, 0.01561686f, -0.01395551f, 0.03657334f, -0.01608972f, -0.04174122f, -0.03930540f, 
    -0.04727830f, 0.01304410f, 0.03082574f, -0.00870175f, -0.00152647f, 0.01839484f, 0.01618654f, 0.02592379f, 
    -0.02715172f, -0.03389945f, -0.01721499f, -0.03198045f, -0.05191621f, -0.04048003f, 0.00889623f, -0.02035736f, 
    0.00094234f, 0.00939428f, 0.01174535f, 0.02422158f, -0.02360753f, 0.01313604f, -0.03194085f, -0.02655386f, 
    -0.04595391f, 0.01621577f, 0.04184586f, -0.04209347f, -0.01836080f, -0.05200774f, -0.05132221f, -0.00114385f, 
    0.00373614f, 0.03748996f, 0.00283630f, 0.02583812f, -0.00277055f, -0.05598225f, -0.01621279f, 0.03808738f, 
    0.04260877f, 0.02463430f, -0.02814619f, -0.01109751f, -0.04933509f, 0.02104567f, 0.00212167f, -0.02656784f, 
    -0.00880248f, 0.02351543f, -0.04748613f, 0.03244184f, 0.03763569f, -0.04538575f, 0.03934905f, 0.00374274f, 
    0.02282526f, -0.00941514f, -0.04252804f, -0.04325048f, 0.00878332f, -0.05378849f, -0.02431915f, -0.02713531f, 
    -0.02902913f, 0.03260416f, -0.04489757f, -0.05641054f, -0.03636139f, 0.00660930f, 0.00384381f, 0.02502146f, 
    -0.03771571f, -0.01130478f, 0.01194685f, -0.03859144f, -0.05324466f, -0.01537685f, -0.04521617f, 0.00342511f, 
    -0.03481490f, -0.00015360f, -0.03136989f, -0.01757223f, 0.00688208f, 0.03390205f, 0.02877651f, 0.00910144f, 
    -0.05024999f, -0.03478111f, 0.04664657f, -0.05034305f, -0.01069125f, -0.00040136f, 0.02334851f, 0.00040038f, 
    -0.05140528f, -0.04057207f, -0.00433712f, -0.03618798f, -0.05339444f, 0.03527932f, 0.01542319f, 0.01276879f, 
    -0.02883493f, -0.02127722f, -0.03640278f, -0.01291280f, -0.04356778f, -0.04030157f, 0.03242898f, -0.03909210f, 
    -0.02002140f, 0.02650233f, -0.04340965f, -0.03354613f, 0.04479716f, 0.00635702f, 0.04288112f, 0.01772019f, 
    0.03636101f, -0.03053742f, -0.02831766f, -0.00499115f, -0.01593284f, -0.03314237f, -0.01173675f, 0.01708270f, 
    0.03474460f, -0.04189641f, 0.00003389f, 0.02082315f, -0.05155152f, 0.02193122f, 0.02801831f, -0.02715448f, 
    -0.03666559f, -0.01219599f, -0.01183576f, -0.00653603f, -0.00666475f, 0.03801397f, -0.03028652f, -0.01946040f, 
    -0.02087472f, 0.02650591f, 0.03940443f, 0.02186973f, 0.00450715f, -0.05272800f, 0.00384934f, -0.00439433f, 
    -0.02071166f, -0.04289040f, -0.00744517f, -0.04927287f, -0.04969396f, -0.04492781f, -0.03377213f, 0.01993390f, 
    0.02176216f, -0.02533789f, -0.01540453f, -0.00310246f, -0.02711325f, -0.00962583f, 0.00473741f, -0.02883271f, 
    0.02475856f, 0.01391336f, -0.03562029f, 0.00506800f, 0.00322681f, -0.00038686f, -0.03040879f, 0.03911164f, 
    -0.02048467f, 0.01079577f, 0.03383735f, -0.01410965f, 0.03443674f, -0.01831044f, 0.01335763f, 0.01723816f, 
    0.03988671f, -0.04318058f, 0.00334001f, -0.05604952f, -0.00487319f, 0.00205523f, -0.05468826f, -0.02930459f, 
    -0.03767744f, -0.01959160f, 0.01174084f, 0.00279481f, 0.02003190f, 0.00183172f, -0.01099823f, -0.00274736f, 
    -0.01209117f, 0.03840425f, -0.03319072f, 0.02647982f, 0.02175493f, -0.00221605f, -0.01905390f, -0.00709170f, 
    -0.03256978f, -0.02377928f, 0.04154306f, -0.03409466f, -0.03045068f, 0.00711561f, -0.01068229f, -0.03276252f, 
    -0.02226539f, -0.03628292f, -0.02972122f, -0.03347765f, -0.04555663f, -0.01291174f, 0.04048592f, -0.02786047f, 
    0.01999060f, 0.02340513f, -0.04573716f, -0.00852813f, -0.03499712f, -0.01235595f, -0.00220494f, -0.00945801f, 
    0.02232966f, -0.04728200f, -0.05119352f, -0.04910383f, -0.02251735f, -0.01313688f, 0.02352827f, 0.03550975f, 
    0.03685105f, 0.01461591f, 0.01547666f, -0.05629684f, -0.05187536f, 0.00162064f, 0.00978963f, 0.00740520f, 
    0.02227984f, -0.01503030f, -0.03966535f, -0.05337254f, -0.04037068f, 0.03063164f, -0.03707851f, 0.01366790f, 
    -0.04073947f, -0.02104459f, -0.00127046f, -0.00633530f, 0.00773194f, -0.01021572f, -0.03989567f, -0.00374480f, 
    -0.00965000f, 0.02902653f, -0.00151208f, -0.02873976f, -0.04055497f, 0.02412254f, -0.04348747f, -0.00483622f, 
    0.03416706f, -0.03800449f, -0.01770972f, 0.02231135f, 0.00707457f, 0.03764199f, -0.01214258f, -0.04315952f, 
    0.02163106f, -0.00915582f, 0.02683271f, -0.01540540f, 0.00200335f, 0.00971736f, -0.04346052f, -0.00422743f, 
    0.04368658f, 0.00611641f, -0.04971257f, 0.04012293f, 0.03129429f, 0.00087423f, -0.02293254f, -0.05395725f, 
    -0.02705403f, 0.02571889f, 0.03134559f, -0.01788296f, 0.00814867f, -0.01076809f, 0.01237391f, -0.02449664f, 
    -0.01531348f, -0.03773230f, -0.00200244f, -0.03763036f, -0.02275146f, -0.04580589f, 0.02065125f, 0.03315619f, 
    -0.00994017f, -0.00646284f, 0.02688009f, -0.02084436f, 0.02197917f, 0.02341737f, -0.04046778f, -0.03385217f, 
    -0.00476968f, 0.01427670f, 0.01577329f, 0.02849100f, 0.00153866f, 0.00632270f, -0.00885111f, -0.04653560f, 
    0.03670132f, 0.02007288f, 0.01350278f, -0.06146850f, 0.00438651f, -0.01537057f, -0.02575409f, -0.04296273f, 
    0.00322812f, 0.00155612f, -0.02769669f, 0.00758512f, -0.04375190f, 0.01696169f, 0.03211877f, -0.01775446f, 
    -0.02299604f, -0.03847059f, 0.00372636f, 0.02467717f, -0.01872606f, -0.05494507f, 0.00863040f, 0.02073336f, 
    -0.00193185f, 0.02979019f, -0.00420156f, 0.00823065f, -0.04479498f, -0.03972242f, 0.02130803f, -0.01026281f, 
    0.03842051f, 0.01643419f, 0.00330992f, -0.00386347f, -0.00154828f, -0.02023084f, 0.01747012f, -0.00318140f, 
    0.03371562f, -0.02360721f, 0.03054083f, 0.03885900f, -0.00212280f, 0.01282666f, 0.00736907f, 0.02362308f, 
    -0.01459710f, -0.00153602f, 0.00127151f, -0.04272088f, -0.04228124f, -0.01479459f, 0.03112167f, -0.01355390f, 
    0.01332027f, -0.05978066f, -0.03430755f, -0.02269094f, 0.03541930f, 0.03705984f, -0.03853851f, -0.04645465f, 
    -0.03928739f, -0.00819220f, 0.03186242f, 0.04180590f, 0.01593564f, 0.03156346f, -0.03157744f, -0.00161130f, 
    -0.01952196f, -0.00853753f, 0.03650335f, 0.03142831f, 0.01635470f, -0.06277552f, -0.02497348f, 0.03309209f, 
    -0.05532347f, -0.06242654f, 0.02388682f, -0.05826781f, -0.04357601f, 0.02089002f, 0.00970359f, 0.03202948f, 
    -0.03016162f, -0.04055779f, 0.01975888f, -0.03471512f, 0.01941770f, 0.01225600f, -0.00198562f, -0.05731514f, 
    0.02439095f, 0.00731765f, -0.00845924f, 0.00570807f, 0.00718848f, 0.01198606f, -0.03874670f, -0.03368232f, 
    -0.04452056f, 0.02747525f, -0.00462849f, 0.01465670f, 0.03169069f, 0.02511569f, 0.03274515f, -0.01610220f, 
    -0.03426928f, -0.03011858f, 0.02057610f, 0.04174713f, 0.00755407f, 0.00339552f, -0.05086942f, -0.04281242f, 
    -0.01277958f, -0.05914549f, 0.02945543f, -0.02216252f, -0.04048413f, 0.03291087f, 0.04257528f, -0.03890381f, 
    0.03373432f, 0.02439241f, -0.04438497f, 0.01683790f, 0.02530729f, 0.02520266f, 0.03091056f, 0.02112537f, 
    0.00107244f, -0.00663136f, 0.03472663f, -0.01508879f, -0.02179662f, -0.00088397f, 0.00854460f, 0.02511418f, 
    0.03244902f, 0.01966762f, -0.01672385f, 0.03091782f, 0.01548933f, -0.03701737f, 0.03114254f, -0.03604268f, 
    0.00435484f, -0.00545176f, 0.03458578f, -0.04452354f, -0.01670890f, 0.01665088f, 0.00009002f, 0.02457251f, 
    -0.05526812f, -0.05155984f, 0.00653816f, -0.01138317f, 0.00403385f, -0.03580552f, -0.03831907f, -0.05058471f, 
    -0.00810023f, -0.05350610f, -0.04887554f, -0.01761541f, 0.03000291f, -0.03922762f, -0.00197584f, -0.01235178f, 
    -0.01308486f, 0.01011013f, -0.00930592f, -0.04282150f, -0.00562420f, 0.01786678f, -0.03160819f, -0.04659766f, 
    0.03138898f, 0.00623016f, -0.03897874f, -0.03391290f, 0.03305749f, 0.04512557f, -0.04418323f, 0.03355088f, 
    0.03306374f, -0.01271149f, -0.05620060f, -0.02553413f, -0.03768485f, 0.02984777f, -0.00557979f, 0.00823872f, 
    0.01971979f, -0.02509410f, -0.01998066f, -0.02029280f, -0.05166754f, 0.02679892f, -0.01450458f, -0.01019565f, 
    0.01940259f, 0.02149235f, 0.02582222f, -0.05786745f, 0.01968298f, -0.02962385f, -0.02526068f, -0.02177302f, 
    0.01201464f, 0.01299326f, -0.01162945f, -0.04052889f, 0.00286379f, -0.05680141f, -0.02767069f, -0.00753627f, 
    0.02461993f, 0.01642967f, -0.04552054f, -0.04876277f, 0.00101185f, 0.01680632f, -0.03929975f, 0.00721125f, 
    0.03725410f, -0.02333516f, 0.03139408f, 0.02772324f, -0.00078992f, 0.02487019f, 0.01929422f, -0.02679599f, 
    0.01029262f, -0.01547937f, -0.01029806f, -0.04034362f, 0.01583698f, 0.03344708f, -0.02368035f, 0.02923016f, 
    -0.04342953f, -0.00040214f, -0.04173793f, -0.03683573f, -0.02636582f, 0.00755745f, -0.04863909f, 0.02052395f, 
    -0.00894675f, -0.05620984f, -0.00386168f, -0.03896450f, -0.03519449f, 0.02718806f, -0.04377845f, 0.00861805f, 
    -0.04024985f, -0.04641040f, -0.06210006f, 0.02480002f, -0.05377482f, -0.04292622f, -0.05858977f, 0.02679005f, 
    -0.02936578f, -0.00896018f, -0.04358323f, -0.01192292f, -0.01685404f, 0.01721424f, -0.05135087f, 0.02133893f, 
    0.02965933f, -0.00682766f, -0.01837965f, -0.02707242f, 0.01491315f, -0.02408929f, -0.01728787f, 0.03879313f, 
    -0.01751286f, 0.01323651f, 0.01016883f, -0.03626278f, -0.05749973f, -0.01155281f, 0.00218209f, -0.03955238f, 
    -0.03343500f, -0.06279961f, -0.02307744f, -0.00357090f, -0.03676121f, 0.00530676f, -0.00770308f, 0.01368200f, 
    -0.01996111f, 0.00854995f, -0.03085854f, -0.05189481f, -0.03513289f, -0.04353103f, -0.03589308f, -0.02694191f, 
    0.03526518f, 0.00267204f, 0.01563014f, 0.03950074f, -0.04992570f, 0.03830257f, -0.02219105f, -0.00897890f, 
    0.03081098f, -0.00653669f, -0.05750003f, -0.02091905f, -0.01607076f, 0.03999354f, -0.03413596f, -0.01578011f, 
    -0.01761570f, -0.01112844f, -0.00987651f, -0.04735500f, 0.03510492f, 0.00228672f, 0.02963394f, -0.00107635f, 
    0.01950347f, -0.02794548f, -0.05204222f, -0.00283323f, 0.04429822f, -0.03933153f, 0.02031183f, -0.01246811f, 
    0.00271204f, -0.04666996f, 0.01154500f, -0.04740005f, -0.05128568f, 0.00820335f, -0.03941075f, 0.03807386f, 
    -0.01183216f, -0.03199843f, -0.05675687f, -0.06228262f, -0.00972516f, 0.01459704f, 0.03033748f, -0.03231755f, 
    -0.05953225f, -0.04259330f, -0.01158665f, -0.00263501f, -0.01917803f, -0.04712429f, 0.02895552f, -0.05048114f, 
    -0.32557118f, -0.16028470f, -0.09290514f, 0.26070067f, 0.05330637f, -0.12677947f, 0.19451965f, 0.03457856f, 
    -0.02263406f, -0.03726764f, -0.02295216f, -0.00925256f, -0.28760460f, 0.27728260f, 0.20880769f, -0.00311773f, 
    -0.11893210f, 0.02324913f, -0.18370040f, 0.02216139f, 0.00938419f, -0.03364703f, 0.22441627f, 0.02516609f, 
    0.25821769f, 0.12435794f, 0.00046276f, 0.23295821f, -0.01495778f, -0.08161978f, -0.02483462f, 0.05858078f, 
    0.15588954f, -0.17598696f, 0.01940643f, 0.04372038f, -0.45399308f, 0.29493740f, -0.19276074f, 0.10205765f, 
    0.06813985f, 0.08486700f, 0.02608911f, 0.08852238f, -0.02056295f, 0.01930921f, -0.05886162f, -0.13620119f, 
    0.23830132f, 0.05762186f, 0.06358360f, 0.17910513f, 0.03826321f, -0.00500846f, 0.07232847f, -0.14492609f, 
    -0.13647497f, 0.09509445f, 0.00362392f, 0.05125671f, 0.25976354f, -0.13784216f, 0.20509464f, -0.00670751f, 
    0.04771166f, -0.07946893f, 0.12213115f, -0.05467523f, 0.06584885f, 0.04305781f, -0.18030906f, 0.10280559f, 
    -0.48828575f, 0.01746058f, 0.10542049f, 0.17813848f, -0.02210759f, -0.00012537f, 0.02321429f, 0.09532735f, 
    0.02614724f, 0.27291393f, 0.11341486f, 0.15617101f, -0.25351655f, -0.10061093f, 0.14505151f, 0.23121122f, 
    -0.01615180f, -0.06881151f, -0.03404590f, -0.09270258f, -0.15597497f, -0.09386405f, 0.01951091f, 0.23137060f, 
    -0.29742807f, 0.09215524f, 0.14388999f, -0.14518926f, 0.09470011f, -0.14962955f, -0.00338635f, -0.04967397f, 
    0.07900504f, 0.03558113f, -0.01954867f, 0.19718222f, 0.08382355f, -0.09514435f, 0.09949076f, 0.12213928f, 
    -0.09898486f, 0.04841069f, -0.01685673f, -0.02157685f, 0.11650117f, -0.12646900f, -0.01661482f, -0.14618763f, 
    -0.44626918f, -0.10830214f, 0.23169847f, -0.13538049f, 0.19574040f, 0.02725502f, -0.02079503f, 0.08138065f, 
    -0.08689963f, 0.06342024f, -0.09927306f, -0.22565816f, -0.05231712f, -0.26339892f, 0.10189157f, -0.14145294f, 
    0.14956141f, 0.11075724f, 0.15140781f, -0.13122343f, -0.05129046f, -0.01653780f, -0.06225630f, -0.07260302f, 
    -0.46187726f, 0.24417572f, 0.03335670f, 0.03449519f, 0.03802015f, 0.14923339f, 0.04060181f, 0.07912467f, 
    -0.02661233f, 0.01132999f, 0.12145533f, -0.01940550f, 0.22361402f, -0.07382797f, 0.09585858f, -0.09277271f, 
    0.06032165f, 0.06479480f, 0.07080545f, -0.10663944f, 0.00741308f, 0.02900161f, 0.10675716f, -0.02689664f, 
    -0.36821869f, 0.15837166f, -0.10001153f, -0.18987674f, -0.11619630f, 0.13756016f, -0.05632136f, -0.04983233f, 
    -0.14692761f, 0.20344466f, 0.20269962f, 0.14966908f, -0.32582092f, -0.05560670f, 0.19436587f, -0.06139955f, 
    0.10322925f, 0.05014197f, -0.03251718f, 0.00110604f, 0.18834689f, -0.00577078f, -0.16082220f, -0.14159866f, 
    0.15166338f, 0.27833882f, -0.18247016f, -0.14361607f, -0.00293975f, -0.01709868f, -0.13012373f, 0.08322862f, 
    0.05987477f, -0.10434984f, 0.12514649f, 0.05978357f, -0.16675809f, 0.22775897f, 0.01261331f, 0.26466292f, 
    -0.03410514f, 0.13918266f, -0.12480876f, 0.03394451f, 0.02447766f, -0.01456775f, 0.07765479f, -0.13024339f, 
    0.08362078f, 0.13810624f, -0.05676599f, 0.09705794f, -0.04678332f, 0.13254867f, -0.11775506f, 0.10482114f, 
    0.04372203f, -0.12528972f, 0.01279709f, 0.13805600f, -0.09491339f, 0.03466571f, 0.07137051f, 0.06983672f, 
    0.00915597f, 0.00956694f, 0.19846660f, 0.34913155f, 0.32611811f, 0.04421292f, 0.16028990f, 0.26555151f, 
    -0.16979302f, 0.24572669f, -0.15298408f, -0.12557042f, -0.03279202f, 0.04905609f, -0.03408286f, 0.01978431f, 
    -0.03437280f, -0.03317159f, -0.01199479f, 0.04736408f, 0.44827014f, -0.34295335f, -0.06916972f, 0.17865597f, 
    -0.01841493f, 0.01829642f, -0.03677622f, 0.05450743f, -0.03413111f, -0.01550885f, -0.12726687f, 0.11356000f, 
    -0.22260940f, 0.27594274f, 0.01147484f, -0.27243301f, 0.00889412f, -0.01658393f, 0.08059100f, 0.07371494f, 
    0.01022144f, -0.00400903f, 0.02617460f, -0.12427489f, 0.01264279f, 0.18693180f, -0.06803793f, -0.31893441f, 
    0.06659318f, -0.00683332f, -0.05869069f, 0.10734488f, -0.07801913f, 0.08822634f, 0.21449025f, 0.03589414f, 
    -0.54514176f, 0.07799902f, -0.05812231f, -0.05537816f, 0.23600887f, -0.06784829f, -0.11195154f, 0.02836248f, 
    -0.04232067f, 0.01553128f, 0.03394686f, 0.11430315f, 0.05375532f, 0.13215682f, -0.03283119f, 0.18743484f, 
    0.03692544f, -0.14255911f, 0.14042933f, 0.00962289f, -0.08056023f, 0.17233479f, 0.16416951f, -0.07831167f, 
    0.14838773f, 0.15035646f, 0.03996271f, -0.01954960f, -0.04860228f, 0.08651368f, -0.03387617f, 0.07239547f, 
    0.10285261f, -0.05601382f, -0.19246183f, -0.03801806f, -0.23695564f, 0.08099142f, 0.20000330f, -0.24424936f, 
    -0.04399155f, 0.08197561f, 0.05427973f, -0.04101535f, -0.03888512f, 0.12343774f, -0.05110601f, -0.14095169f, 
    -0.37341908f, 0.15029614f, 0.11483548f, 0.38751468f, 0.08022397f, 0.21336955f, -0.02018562f, 0.20552671f, 
    0.10165048f, 0.14028172f, -0.11514068f, -0.00701182f, 0.35824975f, -0.38901520f, 0.20612727f, 0.26526350f, 
    0.24052857f, 0.03568962f, -0.05278506f, -0.06466176f, -0.15720363f, 0.00305329f, -0.12565595f, 0.01743335f, 
    0.22169359f, 0.00698756f, 0.11073846f, 0.07316665f, -0.03352746f, -0.01265221f, 0.03954691f, 0.06052961f, 
    0.08524016f, 0.05881543f, 0.22153388f, 0.19719926f, -0.03089691f, 0.19310206f, 0.11419699f, -0.06333452f, 
    0.00835209f, 0.00318501f, 0.11117791f, 0.03100795f, 0.13602409f, -0.03257236f, 0.02971594f, -0.24637890f, 
    0.02957450f, 0.05348816f, -0.04817341f, -0.00519348f, 0.17014845f, 0.14997438f, -0.12295069f, -0.01469998f, 
    0.18645637f, -0.18432146f, -0.08165503f, 0.09024828f, 0.16360776f, -0.19843484f, -0.03708676f, -0.22119854f, 
    0.12972046f, 0.04676813f, 0.02676080f, -0.07409815f, 0.04966766f, 0.12097646f, -0.05817609f, 0.21976545f, 
    -0.25891706f, -0.23976904f, -0.06981629f, 0.07117222f, 0.13006742f, -0.03857522f, 0.07347159f, 0.01002715f, 
    0.02588961f, 0.13881482f, 0.18006650f, 0.07649571f, 0.15958856f, 0.33517462f, 0.23359430f, -0.15077002f, 
    -0.07427932f, -0.05787534f, -0.10741621f, 0.05579318f, -0.00081404f, 0.02676819f, 0.10483714f, 0.13051735f, 
    0.10017704f, -0.15690380f, 0.00895735f, -0.08825955f, 0.12799269f, 0.07837204f, -0.04067285f, -0.05005215f, 
    0.08978821f, 0.01448094f, 0.14786297f, 0.08940890f, 0.05561190f, -0.13194388f, -0.30206868f, -0.02008009f, 
    0.08062533f, 0.15995370f, -0.00935058f, 0.12036215f, -0.01924611f, 0.00458921f, -0.13385336f, 0.07905525f, 
    0.28284106f, -0.06305899f, -0.02659262f, -0.26076427f, 0.09342987f, 0.09293520f, -0.04155109f, -0.08386660f, 
    0.13453647f, -0.08331173f, 0.02488786f, 0.06128372f, 0.22305536f, 0.13171867f, 0.19488400f, 0.12401744f, 
    -0.00013631f, -0.07760004f, -0.03669280f, 0.03099175f, -0.07456592f, 0.03602783f, 0.09105638f, 0.06324549f, 
    0.20394252f, 0.07776175f, -0.09490021f, 0.26855054f, -0.04294853f, -0.01808578f, 0.11358415f, 0.03334980f, 
    -0.14805326f, -0.04031494f, 0.06443641f, -0.15324815f, -0.22919382f, -0.18400003f, 0.04372057f, -0.12999628f, 
    0.02360363f, 0.00718724f, 0.02289115f, -0.07892749f, -0.04028495f, 0.10175501f, 0.13594176f, -0.00043954f, 
    0.41437000f, 0.12263621f, 0.00026622f, 0.07712450f, 0.08335070f, -0.04360548f, 0.10251981f, -0.04955919f, 
    0.04834104f, -0.05974041f, 0.03390597f, 0.08547504f, -0.19505773f, 0.24944060f, -0.07180013f, 0.01299658f, 
    -0.01935792f, -0.05031494f, 0.11412020f, 0.14792788f, 0.07952834f, 0.02869116f, -0.05024429f, 0.10964807f, 
    0.10695671f, 0.17636186f, 0.01020204f, 0.08030583f, -0.14669722f, -0.04314163f, 0.09773252f, 0.02834472f, 
    0.12331303f, 0.05348144f, 0.06129582f, -0.19112895f, -0.18961442f, 0.12546228f, 0.13464391f, 0.11464044f, 
    -0.02795964f, -0.00093735f, -0.03699201f, -0.10222179f, -0.05353421f, 0.09724139f, 0.03403383f, 0.01000232f, 
    0.08286802f, 0.08699704f, 0.11164200f, -0.03084169f, 0.14284533f, 0.04360772f, 0.07698949f, 0.03378151f, 
    -0.14839040f, 0.06015208f, 0.06779078f, -0.04917664f, 0.28431773f, 0.12140298f, 0.02547869f, -0.03763288f, 
    0.15045708f, -0.07626115f, 0.09116662f, 0.03431945f, 0.05831059f, 0.00377130f, 0.15088461f, 0.14397836f, 
    -0.14636056f, -0.27515244f, 0.21153507f, -0.19997479f, -0.07170670f, 0.02290195f, -0.03175613f, -0.09600147f, 
    0.09906740f, 0.18227482f, -0.04802781f, -0.04298519f, 0.25063902f, 0.25734615f, -0.22114430f, 0.05239636f, 
    -0.01866133f, 0.07430763f, 0.03683287f, 0.11469964f, 0.11894174f, -0.01176374f, 0.03016300f, 0.17986752f, 
    -0.34415895f, -0.06437909f, -0.10657437f, -0.27995563f, -0.03262391f, -0.05932433f, -0.09347358f, 0.01319327f, 
    0.02154443f, -0.01907718f, 0.02838463f, 0.06885025f, -0.03846431f, -0.01490793f, 0.16699813f, -0.14923868f, 
    0.18164615f, 0.22184815f, -0.03643079f, -0.03113580f, 0.00623010f, 0.18152161f, -0.15829900f, -0.13400728f, 
    0.30633587f, -0.11611143f, 0.31218365f, 0.15477291f, -0.09945104f, 0.05971611f, -0.02663991f, 0.03370200f, 
    0.12399098f, 0.02663354f, 0.06042536f, -0.09987536f, 0.23308413f, -0.28961518f, 0.30852625f, 0.12180580f, 
    0.15298076f, 0.00468645f, 0.13174520f, -0.00233580f, 0.05156340f, -0.06578437f, 0.03873056f, 0.02595617f, 
    0.23191889f, 0.06527448f, 0.29676160f, 0.42149198f, -0.13172759f, -0.11676553f, -0.00596848f, -0.07957871f, 
    0.04173574f, 0.03704777f, 0.04315891f, 0.14877389f, 0.42927882f, -0.16628966f, 0.19507582f, 0.45148191f, 
    0.01920317f, -0.04353684f, 0.15287068f, -0.01668719f, 0.00453013f, 0.05373030f, 0.06840461f, -0.08127894f, 
    0.21063232f, 0.23596257f, 0.09785769f, 0.28661713f, -0.05206995f, 0.04623979f, 0.07568569f, 0.09892526f, 
    -0.16752897f, 0.03079377f, 0.07131563f, 0.01858483f, -0.26644689f, -0.16182779f, 0.03231078f, -0.05013586f, 
    0.07292946f, -0.00028989f, 0.03495862f, -0.03175454f, 0.19041052f, -0.01011191f, 0.03052017f, -0.00829050f, 
    -0.37402666f, -0.11742211f, 0.13102888f, -0.34445381f, 0.08455271f, -0.03613123f, -0.01617851f, -0.10811357f, 
    0.00089437f, -0.01078546f, 0.11969921f, 0.03820019f, 0.29165867f, 0.33396164f, -0.00395795f, 0.08244708f, 
    0.01340291f, 0.05331675f, 0.03057517f, 0.06930218f, -0.01579999f, 0.00931912f, 0.10665491f, 0.15430675f, 
    0.40143195f, 0.20331372f, -0.17491364f, 0.01027222f, 0.10255327f, 0.10961917f, -0.06138103f, 0.05161773f, 
    -0.05587998f, 0.00778201f, 0.11055327f, 0.01000736f, -0.12399989f, 0.39330685f, -0.19569048f, 0.05222125f, 
    0.08089157f, 0.02036730f, 0.08300576f, 0.02614078f, 0.05774273f, 0.00537282f, 0.06372177f, 0.08729307f, 
    0.54159236f, -0.17616343f, 0.06207787f, 0.13401443f, -0.01830401f, -0.06112842f, 0.00050273f, -0.14959650f, 
    -0.01564709f, 0.03440999f, 0.13971098f, -0.03157678f, 0.38152590f, 0.06116590f, 0.03182887f, -0.17523153f, 
    -0.13273990f, 0.19047223f, -0.04388985f, 0.11432037f, -0.11888374f, 0.07479218f, 0.08907194f, 0.14749046f, 
    0.00717409f, -0.31518245f, -0.19716966f, -0.19652027f, 0.08794821f, -0.00509463f, -0.01223962f, 0.31996053f, 
    0.06454600f, 0.03038529f, 0.05486520f, -0.08408272f, 0.07773910f, -0.47923660f, -0.37866256f, -0.06080609f, 
    0.03169833f, -0.04914089f, -0.14232388f, 0.12440442f, 0.06352499f, -0.04225150f, -0.01060913f, -0.02602520f, 
    -0.01320377f, -0.40966517f, -0.01154045f, 0.05097015f, 0.08543449f, -0.19594590f, -0.01986330f, 0.29024693f, 
    -0.04729170f, 0.01881100f, 0.00949207f, 0.03582804f, 0.30272499f, 0.02945165f, -0.07659685f, -0.11103433f, 
    -0.09107757f, -0.09104761f, -0.00154459f, -0.06757544f, 0.02623271f, -0.12197120f, 0.01860536f, 0.00662504f, 
    -0.40780446f, -0.30287412f, -0.28217313f, -0.17710811f, 0.00119834f, -0.03204494f, -0.02980174f, -0.10895960f, 
    -0.04065338f, -0.02554874f, -0.00671361f, 0.05201710f, 0.12517568f, 0.15761739f, -0.34816650f, -0.26064777f, 
    0.12590665f, 0.28058445f, 0.03638943f, 0.23685460f, 0.10927689f, 0.00734260f, 0.09943169f, 0.09932753f, 
    -0.38120955f, -0.27537549f, -0.08059222f, -0.09442288f, 0.06948969f, 0.10034574f, 0.05594058f, 0.03115659f, 
    0.03754152f, 0.09971044f, 0.02902725f, -0.07318741f, 0.13642053f, 0.01236931f, 0.17050728f, 0.01235393f, 
    0.07504645f, 0.11311889f, 0.03759941f, 0.01944910f, 0.07667556f, 0.02964027f, 0.09873225f, 0.15341358f, 
    0.20909449f, 0.11125175f, 0.08229367f, -0.00718220f, -0.08016576f, 0.05744578f, 0.11309770f, -0.04068731f, 
    0.11844219f, 0.05704608f, 0.14419091f, 0.10262369f, 0.09258328f, 0.10726678f, -0.01930509f, 0.12215278f, 
    -0.01558586f, 0.08474089f, 0.05839111f, 0.12477742f, -0.06794444f, 0.12116390f, 0.10248797f, 0.07060285f, 
    0.21506691f, 0.09316931f, 0.37059680f, 0.10030074f, 0.07091674f, 0.14908041f, -0.01309813f, 0.03403373f, 
    -0.02674499f, -0.04209265f, 0.06332672f, -0.07142010f, -0.30520451f, 0.12126825f, -0.08083615f, -0.11411053f, 
    -0.00306612f, -0.04976517f, 0.04077639f, 0.08088787f, -0.03879042f, 0.10002318f, 0.01599309f, 0.01720277f, 
    0.09327824f, 0.14129163f, 0.09069891f, -0.24483930f, -0.05577183f, -0.01270917f, 0.09167357f, -0.00019048f, 
    0.06982331f, 0.01303557f, -0.07878637f, -0.04169866f, -0.16587837f, 0.10573331f, -0.09209166f, 0.11990438f, 
    -0.03028897f, -0.04138378f, 0.12090310f, -0.10532773f, -0.09800692f, 0.25105745f, 0.04581802f, 0.16325349f, 
    -0.07175772f, -0.04987704f, 0.11539988f, 0.08837432f, -0.17705843f, 0.17333347f, 0.18072520f, -0.04024349f, 
    0.16015051f, 0.16399159f, -0.13165316f, 0.08305355f, 0.06109466f, 0.13684087f, 0.18174334f, -0.18237871f, 
    -0.01105762f, 0.07723162f, 0.02435720f, 0.01694246f, 0.06277162f, 0.00788226f, 0.10531311f, -0.18454984f, 
    0.13308936f, 0.14352569f, -0.01005780f, -0.24089199f, 0.03647345f, 0.13349894f, 0.08516353f, 0.06109709f, 
    -0.10667989f, 0.12673379f, 0.02152783f, 0.08647572f, 0.30363446f, -0.05770287f, 0.23235627f, -0.13147201f, 
    0.16432351f, 0.16058737f, 0.05848189f, 0.02163744f, -0.01841460f, 0.11101256f, 0.01703900f, -0.07741284f, 
    0.12179755f, -0.18160053f, 0.00006278f, 0.05164236f, -0.02010778f, 0.07610377f, -0.06918700f, 0.14256623f, 
    -0.15595753f, -0.00300033f, -0.01682836f, 0.08114286f, -0.22775778f, 0.00895016f, 0.05668153f, 0.10937469f, 
    -0.00710141f, 0.14584160f, 0.11408043f, 0.11699917f, 0.18273185f, 0.20418133f, -0.03766475f, 0.01320795f, 
    0.06256729f, 0.07837167f, -0.09477989f, -0.13956043f, 0.10349892f, 0.11138967f, -0.00752790f, 0.01715858f, 
    -0.05821564f, 0.06077214f, 0.13050473f, 0.05626250f, 0.09092273f, -0.08238097f, -0.15977556f, -0.04833585f, 
    -0.04324430f, -0.00970920f, 0.05096355f, 0.16555713f, 0.01560028f, -0.02423771f, -0.04606016f, -0.00403000f, 
    0.04575973f, 0.29600951f, -0.02290332f, -0.01132038f, 0.07792942f, -0.10997558f, 0.03061236f, -0.00923706f, 
    0.06161772f, -0.01633807f, -0.00407222f, -0.00424269f, 0.23047942f, 0.10427260f, 0.23730887f, 0.01679886f, 
    0.15689117f, 0.08699156f, -0.04811798f, 0.03994821f, -0.06992996f, -0.01410033f, 0.23394516f, -0.16976452f, 
    -0.15238646f, 0.16365124f, 0.23500524f, 0.11869383f, 0.03312632f, 0.05703484f, 0.08695977f, 0.00379015f, 
    0.01832207f, -0.01396699f, 0.14884709f, 0.06374298f, -0.06600983f, -0.36513498f, 0.09129580f, -0.01480879f, 
    0.01292345f, 0.06393290f, 0.16387480f, 0.18193135f, 0.03656184f, 0.04472772f, -0.10171801f, 0.15805222f, 
    -0.07337345f, -0.10535846f, 0.12333054f, -0.11221445f, -0.15908280f, -0.01705275f, -0.02517963f, 0.00165773f, 
    -0.09310395f, 0.00072048f, 0.04703024f, 0.09180423f, -0.03188886f, 0.20047715f, 0.33668590f, -0.02229868f, 
    0.20152079f, -0.09694104f, 0.19025829f, -0.11385270f, 0.08124150f, -0.01374511f, -0.15513889f, 0.22408988f, 
    0.06569718f, -0.26107156f, 0.35935274f, 0.08925115f, 0.06295526f, 0.16936778f, 0.07459248f, 0.24264240f, 
    0.16500346f, 0.01871821f, 0.01003854f, 0.00882400f, -0.08504604f, 0.04931740f, 0.07329165f, -0.03923367f, 
    -0.04721295f, -0.02351391f, -0.00831964f, 0.12732008f, 0.04256067f, 0.18474829f, 0.11058743f, 0.13758886f, 
    0.32188541f, 0.09433455f, 0.05571843f, -0.04272534f, 0.19678690f, -0.00169485f, 0.10357048f, -0.05816032f, 
    -0.01894028f, 0.03152545f, 0.02108794f, 0.09653148f, -0.26150849f, -0.01828110f, 0.11325037f, -0.02878893f, 
    0.03851131f, -0.01778683f, -0.02130677f, -0.03704674f, 0.06300199f, 0.08779930f, 0.03808413f, -0.05939344f, 
    -0.16888404f, -0.05718151f, 0.01103422f, -0.06851479f, 0.11213429f, 0.09121068f, 0.01381482f, -0.23539993f, 
    -0.00969096f, 0.08193309f, -0.01576396f, 0.00323978f, 0.22388606f, 0.04819522f, -0.14091742f, -0.18285908f, 
    0.07054504f, 0.04501200f, 0.20980112f, -0.02564123f, 0.00818909f, 0.28834423f, -0.09465929f, -0.23603199f, 
    -0.15615155f, -0.20769712f, -0.10894196f, 0.07893687f, 0.08424173f, 0.08791562f, 0.15844522f, -0.20877965f, 
    0.04058023f, 0.20204091f, 0.10329083f, 0.04928472f, -0.49517927f, 0.17068715f, 0.15274502f, 0.25964621f, 
    0.27602896f, 0.02863589f, 0.04958903f, -0.05831024f, 0.02839815f, -0.02509230f, 0.09883920f, 0.07128233f, 
    -0.17691210f, 0.07073636f, -0.23698308f, 0.19142736f, -0.01642589f, 0.12288757f, 0.01426185f, -0.02813241f, 
    -0.02916169f, 0.05287040f, 0.04827208f, -0.04055632f, 0.03971924f, -0.25771001f, -0.04234928f, 0.51626664f, 
    -0.09272091f, 0.01217753f, -0.09345049f, -0.01677885f, 0.17401542f, -0.23294042f, 0.05911596f, -0.03106754f, 
    0.30000266f, 0.15260282f, -0.16747905f, -0.19349593f, -0.08924017f, 0.24987297f, 0.10560609f, -0.05549123f, 
    -0.04186774f, -0.17795449f, 0.00582288f, -0.02964646f, 0.10112734f, 0.09399060f, 0.07376137f, -0.21313839f, 
    0.01787187f, -0.03181357f, -0.06030434f, 0.08873361f, 0.12406810f, -0.08480699f, 0.06775696f, 0.00900133f, 
    0.17162013f, 0.02131019f, -0.06756806f, -0.15463829f, 0.02038540f, -0.02828354f, -0.01675141f, 0.09902678f, 
    0.09479855f, 0.04909215f, 0.07315353f, 0.02249928f, 0.02358091f, -0.01188563f, 0.05284937f, 0.11053564f, 
    0.04949094f, -0.01773349f, 0.00702156f, 0.02287628f, 0.03540612f, 0.02237736f, -0.01326873f, -0.02436068f, 
    0.26767838f, 0.00643308f, 0.00044426f, -0.16574064f, -0.02164157f, 0.01297471f, 0.03407183f, 0.05691783f, 
    -0.07911632f, 0.07315025f, -0.03666174f, 0.13332893f, 0.35651165f, 0.19171061f, 0.12973857f, 0.21861197f, 
    0.10342799f, -0.10755510f, -0.15145215f, -0.02978925f, -0.11357419f, 0.01907280f, 0.06539579f, 0.02109232f, 
    0.06625059f, 0.05508842f, -0.05062813f, 0.11917993f, 0.09984063f, -0.08293884f, 0.07301981f, 0.09879544f, 
    0.05629663f, -0.01377401f, 0.03333934f, -0.02548065f, -0.01420340f, 0.11234269f, 0.08896482f, -0.51125526f, 
    -0.10914377f, -0.03481151f, -0.08243465f, 0.05372557f, -0.07330541f, -0.12498614f, -0.09927465f, 0.04062857f, 
    0.12969649f, 0.21925226f, 0.05699848f, -0.30130380f, 0.19000337f, 0.02092757f, -0.00190948f, 0.02846380f, 
    -0.00533791f, 0.04012350f, 0.06783861f, 0.05664424f, 0.42038497f, 0.07252038f, -0.15195674f, -0.12007818f, 
    0.00414404f, 0.04547476f, 0.09568983f, 0.08730279f, -0.01849459f, 0.05205292f, 0.01081773f, 0.13534991f, 
    0.06562092f, -0.18446036f, 0.00283854f, 0.39982796f, -0.01860090f, 0.09089939f, 0.16833138f, 0.17096962f, 
    0.01026801f, 0.02183029f, 0.07695857f, 0.11000137f, -0.10415044f, -0.33238664f, 0.04741436f, 0.44959372f, 
    -0.08272072f, -0.03213589f, 0.05889031f, -0.01300460f, 0.04890192f, 0.07507838f, -0.02842510f, 0.19020492f, 
    -0.02189980f, 0.16626576f, -0.11531154f, -0.15925081f, 0.18461666f, 0.03011784f, -0.15850271f, -0.14155924f, 
    0.17476213f, -0.07835843f, 0.03252391f, -0.02246486f, 0.00986915f, 0.09707464f, 0.00491927f, -0.19379173f, 
    0.21235564f, -0.17792752f, -0.03073821f, -0.14796628f, -0.14457086f, -0.04716683f, -0.11558788f, 0.01325259f, 
    0.07522254f, -0.01962071f, 0.26195118f, -0.23859370f, 0.01449415f, -0.06006477f, 0.01256224f, 0.02103501f, 
    -0.09317812f, -0.05752075f, -0.00134410f, -0.00191280f, -0.34095207f, -0.30362621f, 0.01581638f, -0.12229311f, 
    0.19950445f, 0.03883995f, 0.02072654f, 0.04741668f, 0.08885504f, 0.10368890f, 0.12874398f, 0.08542758f, 
    -0.37063277f, -0.00324189f, 0.19447938f, -0.34338671f, -0.04989724f, 0.04331284f, 0.04860648f, -0.11390636f, 
    0.04452728f, 0.08143359f, -0.08296311f, -0.01903626f, -0.27335903f, 0.03186376f, 0.12887757f, -0.11354230f, 
    -0.07064695f, -0.04123538f, -0.00033087f, 0.00715970f, 0.03595868f, 0.05838247f, -0.14350368f, 0.09877116f, 
    0.33538353f, -0.07113387f, -0.14090954f, -0.06923077f, -0.08846753f, -0.04704476f, 0.05117936f, 0.00819757f, 
    0.05153013f, 0.05341286f, 0.03616802f, -0.01130226f, -0.04948875f, 0.20426759f, -0.03433955f, 0.17024228f, 
    0.13854714f, -0.00119527f, 0.08460484f, -0.18209912f, 0.06038345f, 0.01464691f, 0.06164228f, -0.10992456f, 
    0.14762935f, 0.11599091f, -0.14366293f, 0.06355984f, 0.17914459f, 0.07539930f, 0.01300226f, -0.07459357f, 
    -0.01985182f, 0.02974686f, -0.00331612f, -0.10454360f, 0.25878996f, 0.20019142f, -0.04605276f, -0.28828570f, 
    0.01482593f, -0.03445286f, -0.11381912f, 0.10476611f, 0.10828016f, -0.09744597f, 0.18005316f, 0.26470020f, 
    0.01949870f, 0.17101380f, -0.17414491f, 0.13567263f, 0.17716004f, -0.02142090f, 0.05066325f, 0.06291506f, 
    -0.01073704f, 0.12115900f, -0.08267651f, -0.10259825f, -0.20190723f, -0.15674566f, -0.07271493f, 0.29226711f, 
    0.05226707f, 0.00967964f, -0.06397457f, 0.05565657f, 0.00454189f, 0.06599379f, 0.08024824f, 0.10906263f, 
    -0.11257497f, -0.08817981f, 0.05403332f, -0.02355403f, -0.03937568f, -0.06794068f, -0.08406562f, 0.00114586f, 
    0.00619498f, -0.07303109f, -0.12056645f, 0.05381784f, 0.08176241f, 0.11144359f, -0.00471763f, -0.23696606f, 
    -0.03396674f, 0.00766916f, -0.10314394f, 0.13938870f, -0.08580673f, -0.02537727f, -0.12299594f, 0.15826342f, 
    0.23187026f, -0.30804533f, -0.16297384f, 0.03783594f, 0.05091469f, 0.12086482f, 0.04124464f, 0.01349129f, 
    0.06269984f, -0.00972445f, 0.09238092f, 0.08368937f, 0.10449634f, -0.26168036f, -0.00875310f, -0.13577224f, 
    0.05101808f, -0.02696728f, 0.03214784f, -0.05929217f, 0.09492305f, 0.08663545f, -0.03462785f, 0.00305790f, 
    0.10855470f, -0.17578417f, -0.17581530f, -0.00457528f, 0.21138027f, -0.04630316f, 0.09940448f, 0.12442977f, 
    0.02146388f, 0.05847317f, -0.05699700f, 0.02945516f, 0.29468057f, -0.05171292f, 0.18248762f, -0.07779440f, 
    -0.07014708f, -0.10265460f, 0.16280313f, -0.05318139f, 0.05624531f, -0.07388832f, 0.05013889f, -0.04687907f, 
    -0.01452717f, -0.10470766f, -0.26266453f, 0.03372580f, -0.02573768f, -0.01116573f, 0.00657824f, -0.10702557f, 
    -0.01405309f, 0.05996687f, -0.00778887f, -0.01107493f, 0.16584332f, -0.25273469f, -0.38408345f, -0.30581793f, 
    -0.04410853f, 0.11466987f, -0.03324597f, -0.01794350f, 0.24159129f, -0.14036830f, -0.05516037f, 0.02064372f, 
    0.07125301f, -0.14992274f, 0.04924280f, -0.04820626f, 0.06328377f, -0.00993759f, -0.00078574f, -0.03542797f, 
    0.08902944f, 0.18561345f, 0.18842198f, -0.02542023f, 0.45749536f, 0.24208750f, 0.28144380f, 0.17864104f, 
    0.06692234f, 0.03758857f, 0.04236704f, 0.06266119f, 0.09159973f, -0.06794688f, 0.14773417f, 0.14711113f, 
    0.25549534f, 0.24310789f, 0.16584082f, 0.19061142f, -0.23034263f, -0.04918100f, -0.00140428f, 0.02130874f, 
    -0.00412424f, 0.16407527f, 0.19530801f, 0.08367064f, 0.16268544f, -0.17595084f, -0.04774918f, -0.02041530f, 
    0.00631389f, 0.15832861f, -0.00523107f, 0.15257521f, -0.06448869f, 0.10676341f, 0.04340868f, -0.01541735f, 
    0.18376616f, 0.24399300f, 0.20293052f, -0.10203090f, 0.01319785f, 0.09345915f, -0.08138183f, -0.03421385f, 
    0.07948126f, 0.05693717f, -0.00477879f, -0.08108748f, -0.13529935f, -0.12077887f, 0.11288486f, -0.05712135f, 
    0.00541394f, -0.13551609f, -0.00727772f, -0.02316326f, 0.02073233f, 0.09196920f, 0.11915518f, -0.08420144f, 
    0.15901648f, -0.01394020f, 0.15112622f, -0.03559564f, 0.02448848f, -0.07743496f, 0.09435919f, 0.01850813f, 
    -0.04979968f, -0.01451917f, 0.07439730f, -0.07571152f, -0.03119352f, 0.11629894f, -0.06347462f, 0.07084785f, 
    0.06885103f, 0.06920046f, -0.08392471f, -0.01276749f, -0.06519379f, -0.03871843f, -0.05712987f, 0.16202645f, 
    -0.11961048f, 0.21664204f, 0.39186087f, -0.07641116f, 0.00993648f, 0.03812146f, 0.11620946f, 0.02546122f, 
    -0.14228973f, 0.16017631f, -0.12348407f, 0.20439301f, 0.35954767f, -0.07008601f, -0.00154350f, -0.14358588f, 
    -0.03686293f, 0.02117834f, -0.03070371f, 0.03564495f, 0.11040504f, 0.05746136f, 0.05645396f, 0.08976027f, 
    -0.29956198f, -0.21601306f, -0.10864790f, -0.37392065f, -0.00603488f, 0.05956258f, 0.01534107f, 0.05280000f, 
    -0.03349022f, -0.07592443f, 0.09441677f, 0.07548261f, -0.07647655f, -0.26256683f, 0.18530199f, -0.04529794f, 
    0.05101820f, 0.02872241f, 0.18950848f, -0.04022637f, 0.05107041f, -0.01564624f, 0.03557356f, 0.05460083f, 
    -0.08389796f, 0.09739833f, 0.03597378f, 0.02554229f, 0.01433471f, 0.09615806f, 0.00955492f, 0.04577021f, 
    -0.09071003f, -0.00077466f, -0.07118212f, 0.15456322f, -0.20765246f, -0.01025867f, 0.06614424f, -0.00476217f, 
    0.09063216f, 0.16083510f, 0.05719748f, 0.10311686f, 0.03122122f, -0.05074727f, -0.27265871f, -0.01345759f, 
    0.02907970f, 0.16678806f, -0.00318989f, -0.32452640f, 0.06643754f, 0.04805188f, -0.04534831f, 0.08850487f, 
    -0.10866990f, 0.10706358f, -0.07862415f, 0.03249841f, 0.51377279f, -0.33621773f, -0.21282369f, 0.07134512f, 
    0.07396351f, 0.11645357f, 0.00201367f, -0.10516912f, 0.02691938f, 0.05881650f, 0.12934038f, 0.09899202f, 
    0.24500839f, 0.44617295f, 0.02426585f, 0.03576056f, -0.04008792f, -0.05168700f, 0.00600375f, -0.04528004f, 
    0.03046107f, 0.00847141f, -0.01097525f, -0.05424719f, -0.12861820f, 0.33847696f, 0.24521191f, -0.04330020f, 
    -0.05721772f, 0.03500106f, -0.00296414f, -0.06429347f, -0.06740204f, -0.02994060f, 0.17316553f, -0.02292833f, 
    0.12932351f, 0.45542192f, 0.27870035f, -0.01341912f, 0.04968329f, 0.05222557f, 0.09099400f, 0.04507644f, 
    0.06734767f, 0.03060590f, 0.05034817f, 0.08959188f, -0.24096407f, -0.20804943f, -0.03591623f, 0.06318430f, 
    0.10134315f, -0.00305361f, 0.29373944f, 0.06836178f, 0.05186475f, -0.10242032f, 0.13322097f, -0.00042983f, 
    -0.24977742f, -0.26130247f, 0.16259654f, -0.14280547f, 0.07710387f, 0.03119004f, 0.14296484f, 0.04134833f, 
    -0.13579224f, -0.02911687f, 0.08060587f, -0.18912791f, -0.15778629f, 0.33764920f, 0.11401000f, -0.13296603f, 
    -0.01262921f, -0.16567442f, -0.00632877f, -0.08267390f, -0.01968065f, -0.08213736f, -0.04130044f, 0.18504481f, 
    0.06388638f, 0.02030109f, 0.14414346f, -0.06268832f, 0.01560172f, 0.01496859f, 0.08245895f, 0.12934686f, 
    0.07467548f, 0.02829284f, -0.01932172f, -0.01769524f, -0.27329874f, 0.09058609f, -0.37687972f, 0.08594063f, 
    -0.08043365f, 0.09875745f, 0.10099548f, -0.05529927f, -0.12466719f, 0.02125214f, -0.11370508f, 0.06536449f, 
    0.38565004f, 0.06081432f, 0.05468928f, 0.10739802f, 0.05481106f, 0.00066986f, 0.03189665f, 0.04478943f, 
    0.02715691f, 0.01689886f, -0.00626845f, 0.02745624f, 0.19811389f, 0.02742200f, 0.01658047f, -0.20561460f, 
    -0.09625968f, 0.00280769f, -0.06618562f, 0.24305984f, 0.11216106f, 0.05115523f, -0.01237575f, 0.08580962f, 
    -0.02994778f, -0.03097550f, -0.01270049f, -0.05328341f, 0.03854259f, -0.05721208f, -0.00429089f, -0.02799741f, 
    -0.01814805f, -0.00289508f, -0.02280420f, -0.04930743f, -0.02710387f, -0.04173590f, 0.01853855f, -0.03187634f, 
    -0.04332515f, 0.01406756f, 0.02627013f, 0.00553578f, -0.03637464f, -0.05499582f, 0.01629630f, -0.00399389f, 
    -0.00083415f, -0.00282548f, -0.04516201f, -0.02419377f, -0.03142836f, 0.00211030f, 0.01336711f, -0.00176942f, 
    0.02441707f, -0.00437299f, 0.03736416f, -0.05112309f, -0.00492634f, -0.03847086f, -0.01968912f, -0.02817292f, 
    0.00635031f, -0.03174327f, 0.02684155f, -0.00020440f, -0.04484965f, 0.03396713f, -0.04600245f, 0.00355311f, 
    0.01472416f, -0.02606447f, -0.01558964f, -0.06072030f, 0.00538842f, 0.03132989f, -0.01444670f, -0.01367187f, 
    -0.03361901f, 0.00472613f, -0.02628357f, 0.02500729f, -0.02599045f, 0.02178050f, 0.03499065f, -0.04182570f, 
    0.02557013f, -0.02274039f, -0.02727468f, -0.01378488f, -0.03409704f, 0.02855952f, -0.02710734f, 0.01476656f, 
    0.01563952f, -0.02712952f, -0.04688982f, 0.03442053f, 0.02281847f, 0.03630102f, -0.02977965f, -0.03492735f, 
    -0.00304327f, 0.02085122f, -0.03291851f, 0.01757862f, 0.01103255f, 0.01776240f, -0.05678279f, -0.03279644f, 
    0.02562652f, -0.00970218f, -0.00996358f, 0.01511593f, -0.03808524f, -0.00962081f, -0.03704211f, -0.01866000f, 
    0.03297958f, -0.00561887f, 0.01465178f, -0.02094513f, 0.02950733f, -0.00145283f, 0.01452357f, -0.02320297f, 
    -0.02300218f, 0.02311436f, -0.04407530f, -0.00538329f, -0.05589074f, -0.02095048f, 0.04464966f, 0.00139053f, 
    -0.04924863f, -0.03594364f, -0.00442323f, 0.01213242f, -0.04429500f, -0.05047921f, -0.03976769f, 0.02574626f, 
    -0.04803640f, -0.03538794f, 0.01113136f, -0.05842321f, -0.01004172f, -0.05230992f, 0.03615716f, -0.05138412f, 
    0.03470328f, -0.00787121f, -0.02601600f, -0.01450156f, -0.04426688f, -0.02768465f, -0.05537207f, -0.00618100f, 
    -0.01470420f, -0.00570436f, -0.05918242f, -0.04634383f, -0.03581237f, -0.04527553f, -0.01272131f, -0.02432390f, 
    -0.00790918f, 0.00126223f, 0.02736872f, -0.02752741f, -0.05703525f, -0.01263704f, 0.00285328f, 0.02413372f, 
    0.00581814f, -0.01121814f, -0.05064847f, -0.01355812f, -0.03300946f, -0.04022047f, -0.03255991f, -0.05821413f, 
    -0.00886434f, -0.05833990f, 0.02718260f, 0.00227003f, -0.00260054f, -0.05578541f, -0.00038258f, -0.01849058f, 
    -0.01535292f, -0.06105885f, -0.02466462f, 0.03402869f, -0.05308662f, 0.00414463f, -0.05245112f, -0.05852704f, 
    0.00400856f, -0.04585829f, -0.03119726f, 0.00479370f, 0.03363575f, -0.01371438f, -0.06063469f, -0.04770764f, 
    -0.05026230f, -0.01320286f, 0.03775895f, -0.05345864f, 0.02731880f, 0.03723185f, 0.03362690f, -0.05041287f, 
    -0.02124978f, -0.03975275f, -0.01246859f, 0.03389013f, 0.02856486f, -0.01364035f, -0.04016540f, 0.01703814f, 
    -0.03707126f, 0.00729261f, 0.02941812f, 0.03112335f, -0.02895619f, -0.02105559f, 0.01842674f, 0.03667454f, 
    -0.05632640f, 0.03469837f, -0.03669622f, 0.02261539f, -0.02670894f, 0.03644817f, -0.05081869f, -0.04733910f, 
    0.02097371f, -0.06156512f, 0.00181109f, 0.00688520f, 0.03261990f, -0.03535232f, -0.06144135f, 0.00523620f, 
    0.01658976f, -0.03126369f, -0.04251384f, -0.00843287f, -0.00707061f, -0.00744986f, 0.02120937f, 0.02401475f, 
    0.04270637f, -0.02653181f, -0.03284021f, 0.00092737f, -0.05765110f, -0.03154921f, 0.03583146f, -0.01336384f, 
    0.03923669f, 0.01537373f, 0.02801724f, -0.03374097f, -0.00594189f, 0.01946838f, 0.01241507f, -0.05416117f, 
    0.01035591f, 0.00486797f, -0.00572286f, -0.02934291f, -0.02487297f, 0.03733134f, -0.05513274f, -0.03359252f, 
    0.03512977f, 0.00294284f, -0.02483357f, -0.04601442f, -0.03115778f, -0.02480503f, -0.05007341f, 0.00445116f, 
    -0.03555367f, -0.03907787f, 0.03503201f, -0.02866063f, 0.02271091f, -0.06087839f, -0.04948191f, -0.01735408f, 
    -0.01703318f, 0.01298857f, -0.01548766f, -0.05145608f, -0.01641342f, 0.01723677f, 0.00441713f, 0.00730555f, 
    -0.02845778f, -0.01560047f, -0.01100039f, -0.05057560f, -0.03779751f, -0.02485718f, -0.00377586f, 0.00971887f, 
    -0.00463733f, -0.00141556f, -0.03073858f, 0.03222946f, 0.00085411f, -0.02022573f, 0.00947588f, 0.02421579f, 
    0.02276329f, -0.01254525f, -0.02569413f, 0.01883577f, 0.02857558f, -0.03002786f, 0.02944851f, -0.02744282f, 
    0.03056134f, 0.00748813f, -0.06233884f, -0.05293108f, -0.01567937f, -0.01198684f, -0.00786043f, 0.01390161f, 
    0.00022685f, 0.03500528f, -0.01014729f, -0.04654146f, -0.06342856f, -0.05502875f, -0.02089290f, -0.02762132f, 
    -0.00288766f, 0.02039781f, -0.02513647f, -0.02877401f, 0.02018392f, 0.02974949f, 0.01575461f, 0.02462672f, 
    0.02977651f, 0.03510577f, 0.00611529f, 0.03094217f, 0.03687033f, -0.00373131f, 0.00604073f, -0.05997362f, 
    0.02680796f, -0.04366828f, -0.01401377f, -0.00631950f, 0.04031902f, 0.01327778f, -0.03525181f, -0.03190535f, 
    0.01079069f, -0.03095356f, -0.00044298f, -0.04820807f, 0.03595416f, -0.00469191f, -0.00075589f, -0.02931869f, 
    -0.02585643f, -0.02895851f, -0.02520608f, 0.03795902f, 0.03426952f, -0.02241004f, 0.00822862f, 0.00938249f, 
    0.00783319f, 0.03251017f, -0.02911951f, 0.02951888f, 0.01878174f, -0.03343644f, 0.00262180f, -0.02215038f, 
    0.01367073f, -0.01811578f, 0.01853719f, -0.00591763f, -0.01738816f, -0.05854489f, 0.00391724f, 0.03158316f, 
    -0.03974793f, -0.05189603f, 0.00851561f, -0.05184357f, 0.03110762f, -0.03954213f, 0.02992100f, 0.01101895f, 
    -0.02897714f, -0.05065912f, -0.01824608f, 0.04234107f, -0.00925241f, 0.02711278f, -0.03043926f, -0.05471149f, 
    -0.04658432f, 0.01148284f, -0.05483283f, -0.00315199f, -0.01004587f, -0.01729937f, 0.05104945f, 0.01498998f, 
    -0.01959050f, -0.02632249f, -0.00250104f, -0.01491326f, -0.00934894f, -0.01485426f, -0.00239968f, 0.01162912f, 
    -0.03251015f, -0.03680471f, -0.02083990f, -0.00194681f, 0.01991086f, 0.02020631f, -0.04371943f, 0.04220350f, 
    0.00335872f, -0.05714194f, 0.00933536f, 0.00035590f, 0.01720131f, 0.02209442f, 0.01715193f, -0.00868227f, 
    -0.00358261f, -0.05277840f, 0.00290947f, -0.02593569f, -0.04665028f, 0.02957074f, -0.00954538f, -0.04123709f, 
    -0.01387736f, -0.02086641f, 0.00094905f, 0.01581901f, 0.03867848f, -0.00911379f, 0.00556153f, 0.01039717f, 
    0.01328749f, -0.02450403f, 0.01517839f, 0.01221473f, -0.00266120f, 0.00187083f, 0.01912786f, -0.02728361f, 
    -0.03982392f, 0.02976112f, 0.00446290f, -0.02654210f, -0.02718753f, 0.03778595f, 0.00005222f, 0.04451822f, 
    -0.04458035f, -0.00388017f, 0.03588697f, -0.04012631f, 0.02476950f, -0.05377464f, -0.00087837f, -0.02360634f, 
    0.01862332f, -0.05357665f, -0.01316239f, -0.03597545f, 0.03698736f, 0.00732703f, 0.03769346f, -0.05268645f, 
    0.00743996f, -0.03307039f, 0.02757112f, -0.03668405f, 0.03181216f, -0.05773976f, -0.02925250f, -0.02296817f, 
    0.03325173f, 0.00521055f, 0.04589452f, -0.03957254f, 0.00760654f, 0.00477859f, 0.03797245f, 0.03195033f, 
    -0.02557476f, -0.03619386f, -0.02317952f, -0.02041993f, -0.02938857f, -0.02928856f, -0.04905359f, 0.00165484f, 
    -0.00834203f, -0.00956630f, 0.00935922f, 0.00559296f, -0.01010639f, -0.04209828f, -0.05938405f, -0.01689258f, 
    -0.03763870f, -0.04449252f, -0.05573470f, -0.02576943f, 0.01057322f, -0.00884861f, 0.00860645f, 0.04027873f, 
    0.01692562f, 0.00583612f, 0.03919170f, -0.03923984f, -0.02507683f, 0.03917171f, -0.01061362f, -0.03231338f, 
    -0.03251604f, 0.03558829f, -0.00150299f, 0.03999533f, 0.01632833f, -0.00131295f, 0.00616185f, -0.01344256f, 
    -0.04336344f, -0.01745586f, 0.02939485f, 0.02236686f, 0.02373451f, 0.04552921f, 0.01558566f, 0.00903875f, 
    -0.02800375f, 0.02110453f, -0.00430096f, -0.00321658f, -0.03569977f, -0.00148068f, -0.04347447f, 0.02287050f, 
    -0.00819210f, 0.02227779f, 0.00819175f, -0.04933656f, 0.01373051f, -0.01683163f, 0.02290338f, -0.06227079f, 
    -0.00718337f, 0.01169466f, -0.04258301f, 0.03616128f, 0.02990964f, -0.02999183f, -0.01405396f, 0.04028542f, 
    0.01305027f, 0.03635640f, -0.00949717f, -0.01081341f, 0.02072998f, 0.04297050f, -0.01919751f, 0.01912556f, 
    0.01056119f, 0.01184400f, -0.01951947f, -0.01151598f, 0.01019171f, 0.02524407f, -0.03103019f, -0.01510299f, 
    -0.04497652f, -0.03340944f, -0.00341704f, -0.02570117f, 0.01732229f, -0.00276095f, -0.05582004f, -0.03588449f, 
    0.02925507f, -0.02011808f, 0.00450984f, -0.03801358f, -0.02282107f, -0.02229239f, -0.01951111f, -0.01172109f, 
    -0.04472705f, -0.00163556f, -0.00249098f, 0.04688188f, 0.02525429f, -0.03086230f, -0.01442630f, -0.01229180f, 
    -0.01733488f, 0.03469350f, -0.00523503f, -0.00926113f, 0.03664254f, -0.04956633f, 0.00495281f, -0.04089753f, 
    0.00938075f, -0.04447742f, 0.02776948f, -0.02825892f, -0.02748404f, -0.01939774f, -0.04383294f, -0.03547648f, 
    0.01449515f, -0.01448774f, -0.02435932f, -0.03944426f, 0.00848773f, 0.02880205f, -0.01024666f, -0.05736264f, 
    -0.02121384f, 0.00835517f, -0.00160605f, 0.01748201f, -0.02718989f, -0.01689506f, 0.03668362f, -0.03033411f, 
    -0.01202147f, -0.00232811f, -0.01672415f, -0.05267425f, -0.03056419f, -0.04048369f, -0.00833973f, 0.04409355f, 
    -0.03773651f, -0.00900334f, 0.03613442f, -0.03013922f, 0.03624764f, -0.00515989f, 0.00558395f, -0.00268850f, 
    0.03713964f, 0.01129133f, -0.02205641f, 0.03470404f, 0.02029262f, -0.05223097f, -0.02873807f, -0.05445947f, 
    0.01223506f, 0.02091490f, -0.03035169f, 0.01808760f, -0.01167631f, -0.01189246f, 0.00060679f, -0.05123337f, 
    0.03851582f, -0.04259446f, -0.00433984f, -0.05841460f, -0.02087605f, -0.00464337f, 0.00633525f, 0.04251033f, 
    0.04603006f, -0.03335373f, 0.03463785f, 0.03437322f, -0.00330335f, -0.02817052f, -0.00086154f, -0.00675962f, 
    0.00679095f, 0.01136366f, -0.02354311f, -0.01143256f, -0.03691045f, 0.01930346f, 0.03465544f, 0.01722014f, 
    -0.02775665f, 0.00744145f, -0.01944383f, -0.02622792f, -0.03663029f, 0.03803141f, -0.00402427f, -0.02751678f, 
    -0.01695538f, 0.00395633f, 0.03896245f, -0.01865028f, -0.01803240f, -0.04090135f, -0.00110455f, -0.02645781f, 
    -0.00490372f, -0.04860690f, -0.02867516f, -0.00293956f, -0.04422526f, 0.02685146f, -0.01743916f, -0.04381593f, 
    0.00398198f, -0.00543364f, -0.04501832f, 0.00084291f, -0.02764376f, 0.01987651f, -0.00129384f, 0.02747575f, 
    0.03634306f, -0.03490882f, -0.04898464f, 0.02286750f, 0.03878943f, 0.04447593f, -0.04922961f, 0.00253710f, 
    0.03993849f, -0.01302272f, 0.00134546f, -0.01694143f, -0.02114706f, 0.02349023f, -0.02196251f, 0.00656241f, 
    -0.04964600f, 0.01054765f, 0.00539523f, -0.05429014f, 0.00826168f, 0.03064591f, 0.05074708f, -0.00216125f, 
    -0.02822862f, -0.00316570f, -0.00762275f, 0.00643521f, -0.01529742f, -0.03884184f, -0.00449233f, 0.00110388f, 
    0.02335233f, 0.01032257f, -0.02295379f, -0.05037803f, 0.01279362f, 0.00529130f, 0.02366926f, -0.00774744f, 
    -0.01543702f, 0.00461528f, -0.03372541f, -0.05320005f, -0.02008644f, 0.03275522f, 0.00259673f, 0.00225988f, 
    0.37256086f, 0.32246858f, 0.06962527f, 0.02936972f, -0.20244828f, -0.04113134f, 0.01061066f, 0.17832550f, 
    -0.00023869f, 0.10053535f, -0.00487201f, 0.02076510f, 0.33807462f, -0.04985050f, 0.16551438f, 0.09938890f, 
    -0.07666109f, -0.00506302f, 0.16490194f, -0.04266419f, -0.00796320f, -0.07900457f, 0.12864737f, -0.05684202f, 
    -0.01693780f, 0.38035980f, 0.00762188f, -0.43669856f, -0.07271764f, 0.30512539f, 0.07393923f, 0.02771285f, 
    0.06689988f, -0.01347202f, -0.07454757f, -0.17172912f, 0.17367873f, -0.55253541f, -0.06301814f, 0.00877307f, 
    0.05756311f, 0.00487464f, 0.25115332f, 0.03630492f, 0.07722941f, 0.08694728f, 0.04619898f, -0.03796587f, 
    0.38970271f, 0.05394035f, 0.10647660f, -0.18689671f, -0.11126965f, -0.06386779f, -0.08203933f, 0.22389044f, 
    0.00287985f, 0.04942841f, -0.02164843f, -0.04830957f, -0.37598658f, 0.32806882f, 0.06280921f, -0.35319602f, 
    0.02280197f, 0.01310385f, -0.03702169f, -0.12344074f, -0.04272046f, 0.09650617f, 0.09179936f, -0.03942211f, 
    0.54628849f, 0.08522780f, 0.06966964f, 0.05410484f, -0.00185190f, -0.14334807f, 0.01192382f, 0.09399752f, 
    -0.05102162f, -0.00024827f, 0.06251778f, -0.04024139f, -0.25541544f, -0.01337260f, -0.18916596f, -0.00303519f, 
    0.08959825f, 0.09515850f, 0.08020774f, -0.06390164f, 0.06051426f, 0.06662425f, -0.14679794f, 0.01089486f, 
    -0.09527537f, 0.04920804f, 0.00863870f, 0.19111772f, -0.09059612f, 0.10688808f, -0.06161595f, 0.10266437f, 
    0.07634212f, 0.11298340f, -0.07591211f, 0.12937628f, 0.29857665f, 0.29939055f, -0.11019694f, -0.17222033f, 
    0.05256681f, 0.06216950f, 0.20103835f, 0.18327464f, -0.03292126f, 0.05731179f, -0.09993117f, -0.00907299f, 
    -0.14562444f, 0.14810209f, -0.20411913f, 0.12728344f, 0.01815226f, -0.06224164f, 0.03683903f, -0.05902596f, 
    0.01530203f, 0.04958704f, 0.07763397f, 0.00859654f, -0.09167580f, 0.00436784f, 0.08099131f, 0.06269389f, 
    -0.02742861f, 0.15782830f, -0.03218083f, -0.05256601f, 0.07948516f, 0.13934545f, 0.14179374f, -0.10584330f, 
    -0.01145193f, -0.39409003f, 0.01443482f, 0.09958801f, 0.09928032f, 0.08458119f, -0.00007629f, -0.00537843f, 
    -0.13485645f, 0.05432681f, 0.01224318f, 0.10962369f, -0.12241942f, -0.03383976f, -0.19897264f, 0.35835329f, 
    0.01300470f, -0.08576775f, -0.10333493f, 0.04896632f, 0.03566602f, -0.11261314f, 0.07554774f, 0.11244236f, 
    0.14317167f, 0.07530444f, 0.14351164f, 0.10867129f, 0.22217911f, -0.08991911f, -0.04978997f, 0.03494588f, 
    0.20574433f, -0.01178494f, -0.07809968f, 0.11886767f, 0.15706839f, 0.12864892f, -0.14678937f, 0.33632690f, 
    0.03062270f, 0.09604446f, -0.02156023f, -0.00741783f, -0.05005125f, 0.10536381f, 0.22100644f, 0.14501557f, 
    0.22565274f, 0.02292999f, 0.19528827f, -0.13062207f, 0.11066223f, -0.09121054f, 0.09238002f, -0.17308174f, 
    0.12843260f, -0.05317910f, -0.01964534f, -0.09256799f, 0.02007361f, -0.21445674f, 0.06904872f, -0.38302433f, 
    0.00447889f, -0.03015761f, 0.07680257f, 0.06769782f, 0.07920222f, -0.01198891f, 0.03855088f, 0.00529433f, 
    0.07811124f, 0.02120372f, 0.06325764f, -0.02187481f, -0.10827509f, -0.09520272f, 0.20121571f, -0.02809422f, 
    -0.06497193f, 0.13297245f, 0.03742452f, 0.06447764f, -0.19289058f, -0.18989623f, -0.03133471f, -0.03353218f, 
    -0.08462469f, 0.04535275f, -0.17859556f, -0.02460183f, 0.08078779f, -0.21011336f, -0.02357556f, -0.05890499f, 
    0.00920946f, -0.30703428f, 0.01409448f, 0.33043456f, -0.02904505f, -0.14639227f, 0.06347261f, -0.04835895f, 
    0.20818722f, 0.04138279f, 0.02255691f, 0.11108165f, 0.10087484f, 0.45320365f, -0.14531194f, -0.01535687f, 
    -0.06148406f, 0.04398958f, -0.05754246f, 0.04944810f, 0.10733829f, 0.05326111f, 0.19301951f, -0.02519497f, 
    0.03591690f, -0.44182274f, -0.25733370f, 0.03379962f, 0.13084568f, 0.04501116f, -0.06615298f, 0.16564161f, 
    -0.05794078f, 0.03598849f, -0.00405045f, 0.07840128f, -0.04851805f, -0.00215278f, -0.23147532f, -0.03438088f, 
    0.09757167f, 0.06276213f, -0.07552669f, -0.10886334f, 0.05004572f, -0.05639316f, 0.06046785f, 0.17094129f, 
    -0.01401112f, 0.09357196f, 0.00799624f, -0.08842967f, 0.07569265f, 0.12869705f, 0.01433682f, -0.05066919f, 
    0.28356135f, 0.14859745f, -0.05372028f, 0.02444948f, -0.16425329f, 0.25120530f, 0.04037248f, -0.24605022f, 
    0.00657323f, 0.19971716f, -0.09585219f, -0.02106505f, -0.02160211f, -0.00700827f, -0.00086958f, 0.00545730f, 
    0.01200608f, -0.11658564f, -0.06786977f, 0.16930616f, 0.07523330f, 0.05430240f, 0.13048057f, 0.05104236f, 
    0.15547077f, 0.09951012f, -0.03546022f, 0.03467913f, 0.04660378f, -0.01503589f, -0.13184412f, 0.19221476f, 
    0.04150660f, 0.04843696f, -0.09864264f, 0.12316380f, 0.04925474f, 0.11540177f, 0.03387458f, -0.15814267f, 
    -0.04280171f, -0.20046933f, 0.17991132f, -0.29662892f, -0.08837457f, -0.07436039f, -0.00003452f, -0.15952593f, 
    0.02877920f, -0.00937330f, 0.11234529f, 0.12910198f, -0.44954565f, 0.34888083f, -0.23737636f, -0.24670003f, 
    -0.08096366f, 0.12166639f, 0.01839146f, -0.04236076f, 0.00501150f, -0.08220654f, 0.11278557f, -0.04931599f, 
    0.00692455f, 0.01121917f, -0.12787423f, 0.02689864f, -0.01751104f, 0.16602987f, 0.08546487f, 0.16513635f, 
    0.09550469f, 0.10962918f, 0.06787871f, -0.02873989f, 0.14893134f, -0.10273694f, -0.01216184f, 0.41545227f, 
    0.10279584f, 0.08921365f, 0.04493474f, 0.12961797f, -0.02996637f, -0.01595164f, 0.12130173f, 0.06623334f, 
    0.27875307f, 0.37043434f, 0.24866946f, -0.24012771f, 0.02197116f, 0.01552006f, -0.17308724f, -0.07757913f, 
    0.18947379f, 0.01038652f, 0.00860269f, 0.09726254f, 0.24862061f, 0.15997778f, -0.13533770f, 0.01536063f, 
    -0.01973387f, 0.08582211f, 0.03934846f, -0.09424344f, 0.12828539f, 0.05571585f, -0.08815534f, 0.04039773f, 
    0.23537010f, 0.15544866f, 0.29948226f, -0.15219808f, 0.02322650f, -0.03390551f, 0.07798063f, 0.16571397f, 
    0.08914471f, -0.08451769f, -0.01145503f, 0.03778411f, -0.04137103f, -0.10470098f, 0.06092871f, -0.03244196f, 
    -0.07178766f, -0.02624781f, -0.25993797f, 0.04668526f, -0.02251910f, 0.05348901f, 0.05897525f, -0.02903189f, 
    0.10849050f, 0.33903509f, 0.16490740f, -0.10084304f, 0.02402326f, 0.02202224f, 0.16213432f, 0.03544409f, 
    0.05035670f, -0.06758029f, 0.07210100f, 0.13272214f, -0.00726234f, 0.15162857f, 0.22926876f, 0.08579940f, 
    0.04464410f, 0.13800669f, 0.04890911f, 0.01531076f, -0.05465418f, 0.16781723f, 0.14143601f, 0.03351681f, 
    0.11475402f, 0.38123575f, -0.03503899f, 0.00175631f, 0.14295997f, -0.13010216f, 0.08066583f, 0.12093508f, 
    -0.03235022f, -0.04344093f, -0.11528026f, -0.07584242f, 0.36512050f, -0.17040120f, -0.24463947f, -0.02265933f, 
    -0.13242497f, 0.09390255f, -0.09526056f, -0.08375789f, 0.13648009f, 0.09161863f, -0.07306523f, -0.16380011f, 
    -0.12606558f, -0.17701927f, -0.07461154f, 0.15666004f, 0.14856116f, 0.10672136f, 0.06491566f, -0.21339849f, 
    0.01225684f, -0.10317749f, -0.09638075f, -0.06165126f, 0.10042958f, 0.09232233f, 0.01671141f, 0.03663473f, 
    0.11212973f, 0.01038191f, 0.07514548f, 0.08477149f, -0.07058946f, 0.21386045f, 0.13347387f, 0.18057278f, 
    -0.18217477f, -0.18837406f, -0.22078946f, 0.12628315f, -0.01112186f, 0.00303859f, -0.02062372f, -0.01621641f, 
    0.10954564f, -0.10232418f, 0.12612532f, 0.18332849f, -0.05293567f, 0.33381122f, -0.07586873f, 0.23449592f, 
    0.16676748f, 0.01448727f, 0.00290881f, 0.09370341f, -0.02749313f, 0.08130840f, 0.04505485f, 0.15728720f, 
    0.11990517f, -0.11095741f, -0.17269485f, -0.15482719f, 0.10083442f, -0.05248010f, -0.04711043f, -0.18504550f, 
    0.10996298f, 0.11479662f, -0.04531752f, 0.05880534f, -0.01330664f, -0.06906458f, 0.07745631f, 0.48519638f, 
    -0.02312408f, -0.10138360f, 0.01342408f, -0.12379869f, 0.04528610f, 0.21939366f, 0.10697680f, 0.04774282f, 
    -0.02010125f, -0.24684894f, 0.15630467f, 0.31818476f, -0.09108116f, -0.04768249f, -0.05757026f, 0.01857906f, 
    -0.04594445f, -0.13312984f, 0.01506823f, -0.03139949f, -0.19879307f, 0.02618737f, -0.04962352f, -0.09025137f, 
    0.11515258f, -0.03355620f, -0.12274071f, 0.01763465f, 0.03356534f, 0.03357854f, 0.28497031f, -0.03999409f, 
    0.13831080f, 0.25691181f, 0.17611885f, -0.16427410f, 0.01712094f, -0.14879458f, -0.12121554f, 0.00171189f, 
    0.00710645f, 0.06879044f, 0.03733755f, -0.07580109f, -0.16743053f, 0.41374776f, 0.31575617f, -0.23869321f, 
    0.01038786f, -0.08352861f, -0.04893715f, 0.20511538f, -0.05083002f, 0.10666382f, 0.04747115f, 0.05221277f, 
    0.32732081f, 0.05902500f, 0.22592871f, -0.03565808f, 0.00765913f, 0.21398281f, 0.09465978f, 0.10132897f, 
    0.01217092f, 0.14835063f, -0.07269157f, -0.05965940f, 0.41378021f, 0.00271372f, 0.13696308f, 0.18129858f, 
    -0.00312191f, -0.08616305f, -0.13538291f, -0.16993929f, -0.07131355f, 0.02531270f, 0.06682305f, -0.01929145f, 
    -0.04669868f, 0.13617447f, -0.09314492f, 0.46890631f, -0.04878585f, -0.17469727f, -0.01775171f, -0.08227713f, 
    -0.01160744f, -0.00855279f, 0.16708514f, -0.07438332f, 0.03397263f, 0.31153256f, 0.16529432f, -0.07143135f, 
    -0.06238896f, 0.01482819f, -0.04150078f, 0.02250319f, 0.08099859f, -0.02798840f, 0.00506815f, -0.13138361f, 
    0.10539437f, -0.25416821f, 0.01100145f, 0.38865942f, -0.14954598f, -0.06364071f, -0.04354654f, -0.04704235f, 
    -0.00375065f, -0.02554125f, 0.08369301f, 0.08516791f, -0.29278478f, -0.23095572f, -0.02597009f, -0.03028323f, 
    0.05511553f, 0.05342574f, -0.05304747f, -0.04230895f, 0.00115837f, -0.11295525f, 0.03318775f, -0.05355683f, 
    -0.16969535f, -0.09328951f, 0.00026477f, 0.06277376f, -0.11908015f, 0.08956508f, -0.05931647f, -0.03950068f, 
    -0.01556835f, -0.00430761f, -0.02981872f, 0.10431139f, 0.31128496f, 0.02903648f, 0.07696413f, -0.05081762f, 
    0.09806668f, 0.16857679f, -0.17140491f, 0.18520007f, -0.05302458f, 0.08798312f, -0.13840170f, 0.03088779f, 
    0.13867913f, 0.19555499f, 0.09062125f, -0.13967183f, 0.05910776f, -0.09975262f, 0.02593109f, 0.03317011f, 
    0.05476081f, 0.06303146f, 0.15202847f, 0.03396282f, 0.14569430f, -0.29240814f, 0.07890924f, 0.18065050f, 
    0.08863326f, -0.03642223f, 0.00098169f, -0.02231572f, -0.00185559f, 0.00761873f, -0.04296244f, 0.04251510f, 
    0.05594680f, 0.18827571f, 0.06076653f, -0.27439946f, -0.06428181f, -0.00129896f, 0.01041789f, 0.07417910f, 
    -0.00655937f, -0.15322876f, 0.16921392f, 0.02406704f, -0.16918337f, 0.11864893f, 0.18980373f, -0.22819003f, 
    0.19506748f, -0.08226795f, 0.04812258f, -0.07190033f, 0.16659190f, 0.05813967f, 0.03466120f, -0.00538774f, 
    0.39531124f, -0.04461132f, -0.14515154f, -0.12010939f, -0.05728355f, 0.08307880f, 0.05379485f, -0.03996878f, 
    0.01270787f, -0.00571727f, -0.15683621f, 0.03535368f, -0.02742256f, -0.14251651f, -0.01271677f, 0.22445549f, 
    -0.08048557f, 0.01864287f, -0.00521763f, 0.01993647f, -0.06562813f, 0.11054216f, 0.15495270f, 0.18415448f, 
    -0.22445585f, 0.18691054f, 0.00284631f, -0.19110148f, -0.05138100f, -0.07631463f, -0.06757099f, 0.08575025f, 
    0.03805917f, -0.02916482f, 0.07723063f, -0.01192906f, -0.25922909f, 0.18326531f, -0.17399268f, -0.07765940f, 
    -0.00259994f, 0.14597723f, 0.00798058f, 0.13000228f, -0.13461480f, -0.16028127f, 0.11280479f, 0.01737257f, 
    0.09906602f, 0.27804214f, -0.11934962f, 0.03937260f, -0.07404284f, 0.05319349f, -0.09529187f, -0.04158425f, 
    0.04138638f, -0.15131322f, 0.00530795f, 0.05160384f, 0.25854796f, -0.07418570f, -0.03758166f, -0.02230523f, 
    -0.11217465f, 0.07263144f, 0.09626462f, 0.09620121f, 0.08276646f, -0.03728867f, -0.19924614f, -0.06811852f, 
    -0.07529623f, -0.05709876f, -0.01854607f, -0.13149163f, 0.09998518f, 0.00702315f, -0.15026516f, 0.03411546f, 
    0.06057146f, 0.05036412f, -0.14967042f, 0.00367241f, -0.38949358f, 0.43375999f, 0.51175725f, -0.03096209f, 
    -0.05656958f, -0.02210626f, 0.09860265f, 0.02197656f, -0.05859151f, -0.02246104f, -0.06319739f, -0.01439267f, 
    -0.06473020f, 0.02006338f, 0.05862998f, 0.06532142f, 0.05290302f, -0.00742189f, -0.03855010f, 0.10796189f, 
    -0.12566566f, 0.04946719f, 0.07775234f, 0.08971740f, -0.32903257f, 0.13157898f, 0.24474841f, 0.06140649f, 
    -0.03969156f, 0.00906556f, -0.01835776f, 0.00639450f, 0.09713421f, -0.02285757f, 0.02136861f, 0.14658712f, 
    -0.19248372f, -0.02249628f, 0.00377902f, 0.04071421f, -0.03762155f, -0.06052178f, -0.07164869f, 0.01396918f, 
    0.05046392f, 0.04554103f, -0.15334237f, 0.02666486f, -0.31246287f, 0.22884786f, 0.31172574f, 0.11414264f, 
    0.07555562f, -0.07489406f, -0.03571175f, 0.06380369f, 0.10012700f, -0.02541958f, -0.04466501f, -0.10934876f, 
    0.04193386f, 0.30543578f, 0.14431340f, 0.25165161f, -0.11230918f, -0.15339538f, 0.00559724f, -0.03454434f, 
    0.23955891f, 0.04359389f, -0.05076637f, -0.02968689f, -0.22739235f, -0.43447238f, -0.16091818f, 0.15609209f, 
    0.02281824f, 0.09328739f, -0.08309157f, -0.13264208f, 0.04228325f, 0.10243550f, -0.01144234f, 0.01143111f, 
    -0.11098673f, -0.31808427f, 0.05458399f, -0.04524412f, 0.01415683f, 0.15517056f, -0.11643493f, 0.07603439f, 
    0.05723764f, 0.01449622f, -0.01370447f, 0.07978547f, 0.57379973f, 0.06381273f, 0.06486164f, 0.17327026f, 
    -0.04978636f, 0.22893317f, 0.21333411f, 0.00563512f, 0.10466602f, -0.07117353f, 0.02555534f, -0.05781742f, 
    0.50250399f, 0.01676196f, -0.01284845f, 0.22026159f, -0.25455308f, -0.09853981f, -0.08469807f, 0.07596070f, 
    0.13172506f, -0.08687872f, 0.03378016f, 0.09618343f, -0.37290519f, -0.09263833f, 0.21204394f, 0.23940431f, 
    -0.13336204f, 0.07758364f, -0.00519927f, -0.10790446f, -0.02065679f, 0.02306388f, -0.16300629f, -0.21054167f, 
    -0.00399273f, 0.08012802f, 0.12961365f, 0.09066116f, 0.00898672f, 0.07178501f, -0.05801243f, -0.05947625f, 
    -0.05507468f, -0.15757389f, 0.02850725f, 0.03375475f, 0.39273885f, -0.01168931f, -0.14695010f, 0.09341278f, 
    -0.15703458f, 0.08853072f, 0.01802577f, 0.01803888f, -0.05736227f, 0.05641720f, -0.00035817f, -0.06586385f, 
    0.21964225f, -0.02381864f, 0.04107676f, 0.12221826f, -0.07994445f, -0.15125075f, 0.22371246f, 0.13293634f, 
    -0.03148711f, 0.12759654f, 0.10369388f, -0.09462511f, 0.15372092f, -0.05660658f, -0.06095137f, 0.06920186f, 
    -0.01258557f, 0.24431768f, 0.07984039f, 0.02617073f, 0.08611256f, -0.08765096f, 0.16262384f, 0.11150233f, 
    0.31816891f, 0.04521859f, -0.14032997f, 0.09753335f, -0.08094727f, 0.12879364f, 0.13085860f, -0.04832052f, 
    -0.05432104f, 0.00276265f, 0.13757959f, 0.14260729f, -0.51916707f, 0.42884240f, -0.07935627f, 0.04236547f, 
    0.04924409f, 0.05211293f, 0.09218233f, -0.01983840f, -0.06006446f, -0.08960392f, -0.09633369f, 0.01057065f, 
    0.63292420f, 0.13325311f, -0.19003214f, 0.13673893f, -0.17409998f, 0.05440771f, -0.03686465f, 0.10904168f, 
    0.03706053f, -0.01417129f, -0.06497066f, 0.03784099f, 0.30946797f, 0.15913215f, -0.09253369f, 0.07989141f, 
    -0.10314684f, -0.12945414f, 0.07274455f, 0.07211108f, -0.03868651f, 0.05588862f, 0.05035131f, 0.07752775f, 
    0.11476253f, 0.03615086f, 0.16812408f, 0.12685663f, -0.10044145f, -0.20829466f, -0.05303254f, 0.07166751f, 
    0.18803868f, -0.00379851f, -0.01065721f, -0.11171987f, 0.07489054f, 0.02699641f, -0.05719408f, -0.11223510f, 
    -0.02339812f, 0.07188064f, -0.01418698f, -0.09355439f, -0.01265023f, -0.04663652f, 0.06623136f, 0.06097986f, 
    0.39778751f, -0.00531381f, 0.05688649f, 0.30742791f, -0.16983968f, -0.04577032f, 0.21317892f, 0.10724534f, 
    0.11485387f, -0.04804837f, -0.03018005f, 0.12166949f, 0.08573487f, -0.23260890f, -0.04387140f, 0.25519541f, 
    -0.18625288f, -0.01340050f, 0.05151580f, 0.09005536f, 0.08993870f, 0.02848040f, 0.02881175f, -0.09218311f, 
    0.16250691f, -0.49447450f, -0.01679534f, 0.08841220f, -0.08903183f, 0.13373594f, -0.03004137f, -0.02675737f, 
    0.01344064f, 0.19223496f, -0.07075392f, 0.14089756f, -0.10369886f, 0.14236350f, 0.05705641f, -0.12221782f, 
    -0.01341346f, -0.09122594f, -0.06322295f, -0.01123730f, 0.07669657f, -0.12429173f, -0.08429262f, -0.07701011f, 
    -0.39574531f, 0.03359233f, -0.05742480f, 0.13566175f, 0.13608705f, 0.06969467f, 0.05262909f, -0.02016882f, 
    0.05201320f, 0.11877917f, 0.11027758f, -0.02043292f, -0.08290210f, -0.03374313f, 0.15593655f, 0.32781506f, 
    -0.07608741f, 0.14940979f, -0.00812767f, -0.06436131f, 0.14150736f, -0.11450045f, -0.00376758f, -0.16953629f, 
    -0.05842254f, -0.28453150f, -0.03611541f, 0.19734481f, -0.04424737f, -0.07995559f, 0.03232978f, 0.27651176f, 
    -0.00185477f, 0.14086892f, 0.10136285f, -0.23409627f, 0.17870659f, -0.11767840f, -0.04334957f, 0.16972348f, 
    0.05679419f, -0.07106154f, -0.16010964f, 0.04350750f, -0.01597479f, 0.04152432f, -0.00802489f, -0.26149318f, 
    0.02359956f, -0.02565409f, 0.34006879f, 0.03231277f, -0.00193289f, 0.02069897f, -0.04073934f, 0.29638001f, 
    0.01991491f, -0.21241862f, 0.00752281f, -0.08558592f, 0.27596843f, -0.00386445f, -0.15627617f, 0.51185751f, 
    0.31375518f, -0.00077336f, -0.13439728f, -0.17611609f, 0.01325956f, -0.05266734f, 0.10101353f, 0.03017608f, 
    -0.36972758f, -0.01410277f, -0.08869714f, 0.20840567f, -0.06437056f, 0.11086780f, 0.00507639f, -0.11074979f, 
    -0.08096715f, 0.15492657f, -0.07093189f, 0.03138539f, 0.13906026f, -0.13892940f, -0.30543306f, -0.25577101f, 
    -0.00018341f, 0.12043768f, -0.07553396f, 0.01618247f, -0.00602641f, -0.03808906f, 0.17581175f, 0.04390625f, 
    -0.35887975f, -0.27039894f, 0.04168324f, 0.13509642f, 0.09177309f, -0.00142340f, 0.06568257f, 0.07753255f, 
    -0.02298431f, 0.09883367f, -0.01545260f, -0.08975875f, 0.20439053f, 0.12792505f, -0.19194853f, 0.16885336f, 
    0.28709295f, 0.04699142f, 0.19767334f, 0.09071108f, 0.23706129f, -0.05179884f, -0.06642480f, 0.07471370f, 
    0.35242587f, -0.03286811f, 0.28738773f, -0.39097306f, 0.06093125f, -0.02106645f, 0.04087882f, -0.05448988f, 
    0.07563484f, -0.02107439f, 0.03001448f, 0.07768458f, 0.03432410f, 0.09119358f, -0.05496484f, -0.04845244f, 
    -0.13197297f, 0.05588001f, 0.05434290f, 0.10039822f, 0.02470571f, 0.05925782f, -0.03114117f, 0.10480909f, 
    0.36474106f, -0.10780253f, -0.10779598f, 0.02688265f, -0.01395698f, 0.03320747f, -0.05527873f, -0.02543736f, 
    0.05087062f, -0.01754771f, -0.01089249f, 0.05442002f, 0.45549649f, -0.17607035f, -0.17240594f, -0.35064900f, 
    0.04804851f, -0.15834919f, -0.14225172f, 0.03544375f, 0.01363454f, 0.10090770f, 0.08043226f, 0.02173488f, 
    0.17269203f, 0.03204390f, 0.30888200f, -0.20486008f, 0.00248730f, 0.22776036f, -0.06489955f, 0.04292363f, 
    -0.09168716f, 0.00805975f, -0.15868993f, 0.01238634f, -0.00002423f, -0.08091620f, 0.05601215f, 0.03217515f, 
    -0.07496043f, -0.11589454f, -0.05228985f, 0.04675797f, 0.02995181f, 0.08201730f, 0.02214775f, 0.15280578f, 
    0.11120355f, 0.12797722f, -0.08534415f, -0.04528540f, -0.07121237f, 0.07901169f, 0.00271265f, 0.07821283f, 
    0.14745504f, 0.06823930f, -0.11204877f, 0.05030514f, -0.09134540f, -0.08035336f, -0.13011964f, -0.04341150f, 
    0.04454204f, 0.10398127f, -0.06945542f, 0.15145974f, 0.13761091f, 0.07892270f, 0.06591827f, -0.13479435f, 
    -0.07797101f, 0.07718648f, -0.30045563f, -0.02712358f, -0.15341516f, 0.05402582f, 0.10468316f, 0.01719101f, 
    -0.05547257f, 0.00533101f, 0.08166346f, 0.04824131f, 0.05653620f, -0.29151756f, 0.27290112f, -0.23108183f, 
    0.18283843f, 0.04873229f, -0.02192945f, -0.00989855f, 0.03260364f, 0.08745773f, 0.03542433f, -0.05723576f, 
    0.32414171f, 0.37043232f, 0.34971705f, 0.23679261f, -0.00935028f, -0.02664889f, -0.07683603f, -0.02423924f, 
    -0.11007456f, -0.01273455f, 0.02246213f, -0.04491502f, -0.03174290f, 0.01413672f, -0.10734303f, 0.02884083f, 
    -0.05364616f, -0.10996205f, 0.02612238f, 0.06282266f, 0.04126004f, -0.04675787f, 0.10709450f, -0.00953001f, 
    -0.09014936f, 0.12455077f, -0.11970369f, -0.09222570f, 0.03927757f, -0.07505263f, -0.01431142f, 0.03015786f, 
    -0.00010510f, 0.14587696f, 0.04055974f, 0.05088580f, -0.07468105f, -0.03051548f, -0.15945743f, 0.01606813f, 
    -0.02275166f, 0.15598832f, -0.08301824f, 0.17726044f, -0.06905217f, 0.11451809f, 0.15305156f, 0.05797116f, 
    0.07980567f, -0.01527646f, 0.05729561f, -0.05085844f, 0.25145760f, 0.14243634f, -0.02863085f, -0.09288747f, 
    -0.07594982f, -0.06815169f, -0.03314040f, -0.21162409f, -0.02505427f, 0.04360285f, -0.09357756f, -0.24329038f, 
    0.07516430f, 0.14773604f, -0.03396862f, 0.05853160f, -0.02515179f, -0.19272573f, 0.25853837f, -0.17854173f, 
    0.46374109f, -0.04480964f, -0.09977662f, 0.02872403f, 0.13752654f, 0.05540069f, 0.00273527f, -0.19905415f, 
    0.06464770f, 0.05240503f, 0.01022618f, 0.04979762f, 0.04744383f, 0.07559234f, -0.06419621f, -0.09458794f, 
    -0.06962517f, 0.16155902f, -0.05518198f, 0.18391067f, -0.07517480f, -0.08136826f, -0.03992940f, -0.04460930f, 
    0.08129457f, 0.10385287f, -0.05673744f, 0.09982847f, -0.03543711f, 0.01872079f, -0.06505153f, 0.03637626f, 
    0.10718767f, 0.02963287f, 0.02895007f, -0.14068675f, -0.09615247f, -0.11140012f, 0.01287328f, -0.27938238f, 
    0.19726825f, -0.15447995f, 0.11655874f, -0.11907649f, -0.01905552f, 0.04035871f, -0.03708049f, 0.07458957f, 
    0.07444325f, 0.02009581f, 0.26656356f, -0.04121034f, 0.08746034f, -0.05540687f, -0.04060706f, 0.11908361f, 
    0.11473431f, -0.00384159f, 0.06292481f, -0.03190730f, 0.52289701f, -0.23837027f, 0.12319162f, 0.12064790f, 
    -0.07565567f, -0.00899907f, -0.06823698f, 0.06252727f, 0.11254956f, 0.01752676f, 0.08951601f, 0.18413541f, 
    0.21696015f, 0.06165208f, 0.12773658f, -0.00461951f, 0.18684766f, 0.16154210f, 0.05495251f, 0.12104318f, 
    -0.01812393f, 0.02414636f, -0.18560761f, 0.21251345f, -0.43325374f, 0.13412695f, -0.17957406f, 0.19896674f, 
    0.15455566f, -0.09616600f, 0.03152194f, -0.01165961f, 0.03949336f, 0.04361500f, -0.05168751f, -0.01992198f, 
    -0.20566739f, -0.05737231f, 0.02763348f, -0.10677864f, 0.08303033f, -0.00221889f, 0.06088324f, -0.22893891f, 
    0.03215731f, 0.10638608f, 0.10929330f, 0.13850673f, -0.31446388f, -0.02076836f, -0.27304810f, 0.05977237f, 
    0.11697367f, 0.00610093f, 0.17632686f, 0.22036679f, -0.03712728f, 0.09934206f, -0.11411265f, 0.05972088f, 
    0.38863343f, -0.22198358f, -0.16346374f, 0.15239088f, 0.12117032f, -0.17073214f, 0.05399876f, -0.09262457f, 
    -0.05583243f, 0.11806586f, -0.18312290f, 0.13719894f, -0.12348198f, -0.19200502f, -0.03407177f, -0.11537116f, 
    -0.04990681f, 0.01820307f, 0.08067971f, -0.11490756f, -0.00869877f, -0.12409065f, -0.14815865f, 0.03308315f, 
    -0.26273900f, 0.06782991f, -0.18609282f, -0.06927205f, 0.11007001f, 0.02199445f, -0.00410294f, 0.04572450f, 
    0.03294469f, -0.13577843f, -0.02481918f, 0.05175538f, 0.00396019f, 0.32483816f, 0.40838999f, 0.49170208f, 
    -0.02236121f, -0.03629455f, 0.01321460f, 0.06558647f, 0.14212745f, -0.02149248f, 0.09725269f, 0.03473986f, 
    -0.39229855f, 0.26156282f, -0.03808292f, 0.10877009f, -0.01167223f, 0.10736451f, 0.17041716f, -0.03322410f, 
    -0.01915180f, -0.01220259f, 0.08108199f, -0.13465267f, 0.01565186f, -0.12105191f, 0.18630171f, -0.22717786f, 
    -0.13348003f, 0.17538416f, -0.07239938f, -0.03082292f, 0.03665664f, 0.00806986f, 0.11318599f, -0.01084000f, 
    -0.18833786f, -0.07366991f, -0.08735053f, 0.00081408f, 0.07713215f, 0.12994495f, -0.04713762f, 0.03393140f, 
    0.23212683f, 0.04524410f, 0.08969232f, 0.08159255f, 0.18632331f, 0.16863424f, 0.17074025f, 0.41740456f, 
    0.15374024f, -0.06091671f, -0.00619992f, -0.09798279f, 0.02313378f, 0.01069776f, 0.06775944f, 0.09894924f, 
    -0.30583185f, -0.01460873f, 0.36084780f, -0.00311429f, -0.05901940f, 0.11729903f, -0.03984481f, 0.12357366f, 
    0.00942721f, 0.07190661f, 0.17788649f, 0.12323771f, -0.15530579f, -0.05785598f, 0.17916392f, 0.26964158f, 
    0.04890022f, -0.04563463f, -0.10428108f, -0.09110562f, -0.13421479f, -0.06226362f, 0.05712929f, 0.09827551f, 
    0.07908325f, 0.01663343f, -0.25965381f, -0.05624293f, 0.17838149f, -0.13519990f, 0.03513516f, 0.05867691f, 
    0.19202435f, 0.02123405f, -0.08767943f, 0.13376689f, 0.25253856f, 0.15532824f, 0.06688311f, -0.25481582f, 
    0.06720679f, 0.05626904f, 0.09125535f, 0.00593256f, 0.05010517f, 0.04421393f, -0.04779204f, 0.08443053f, 
    0.02042043f, -0.22729325f, 0.06371286f, 0.17160194f, -0.12222378f, 0.00023048f, -0.03801257f, -0.06882486f, 
    0.12169068f, -0.05828499f, 0.13075408f, -0.04533789f, -0.11969461f, 0.04077191f, 0.20854716f, -0.05313729f, 
    -0.10623311f, -0.04521400f, 0.01928094f, 0.03484627f, -0.01340499f, 0.09388162f, -0.03919311f, 0.04154090f, 
    0.06269131f, 0.28534967f, -0.04568769f, 0.35016039f, 0.18110509f, 0.13735728f, 0.06063564f, 0.30441058f, 
    -0.09627286f, -0.01938365f, 0.07821935f, 0.09997536f, -0.20575844f, -0.02647236f, 0.15150906f, 0.25780615f, 
    0.06722284f, -0.01149304f, 0.10839204f, -0.12164716f, -0.02098870f, 0.12433515f, -0.01834680f, -0.04388292f, 
    0.36701009f, -0.12978770f, -0.02932406f, 0.28571239f, 0.24928145f, 0.11759380f, 0.18469191f, 0.14314400f, 
    0.10939261f, 0.11305571f, -0.01145308f, -0.17504184f, 0.21997559f, 0.17050749f, 0.00780816f, 0.17855921f, 
    0.04841743f, -0.10458294f, 0.12895966f, -0.07776469f, -0.01955419f, 0.08341329f, 0.03241665f, 0.06906450f, 
    -0.05588746f, 0.32013288f, -0.02408125f, -0.23766854f, 0.14555763f, 0.09235269f, 0.04449736f, 0.14951576f, 
    -0.13666910f, 0.01216482f, 0.08041291f, 0.12060863f, -0.43376359f, 0.24809740f, -0.20941183f, -0.19277173f, 
    0.00617226f, 0.01631638f, 0.07040896f, 0.02402024f, 0.08312328f, 0.07832462f, -0.01647022f, -0.02554316f, 
    -0.08883695f, 0.28856373f, 0.03118934f, -0.32276511f, -0.05674248f, -0.03740009f, 0.02043360f, -0.10523617f, 
    0.18937048f, 0.00791594f, 0.06728479f, 0.18093063f, -0.33895886f, 0.14130591f, 0.08537126f, -0.13560666f, 
    0.11367696f, 0.03666680f, -0.02939768f, 0.07184038f, -0.02441466f, 0.07029314f, -0.18632819f, 0.16180494f, 
    -0.32825926f, -0.19142412f, 0.21600513f, -0.01259053f, -0.08883509f, -0.03158942f, -0.03578300f, 0.08392715f, 
    0.10748033f, -0.10701017f, 0.04839025f, 0.03465521f, 0.35462269f, -0.09148681f, 0.02243133f, 0.27741039f, 
    0.12597296f, -0.03542810f, 0.11334825f, 0.05766132f, 0.03348502f, 0.07287969f, -0.01913306f, 0.13826811f, 
    0.47898722f, 0.06369618f, -0.04424238f, 0.40789407f, -0.02406818f, 0.09998463f, 0.22269616f, 0.02992799f, 
    -0.13807365f, 0.04794623f, 0.05490209f, 0.12672348f, 0.01848661f, -0.10795532f, 0.16998221f, 0.05220558f, 
    0.03307065f, -0.00941559f, 0.05963913f, -0.05345378f, 0.04103351f, -0.08753639f, 0.00137724f, 0.13897333f, 
    -0.26325396f, -0.31810325f, -0.04967488f, 0.16909598f, -0.03381311f, -0.06924762f, 0.15758300f, 0.05969377f, 
    0.07669038f, 0.04398886f, -0.06641935f, 0.02379602f, -0.26584533f, -0.25351667f, 0.26327860f, 0.07051150f, 
    -0.09215525f, -0.07128328f, 0.03591383f, 0.08105332f, 0.02928970f, 0.18158826f, -0.11609249f, -0.07312799f, 
    -0.56453198f, 0.25427023f, -0.09955055f, -0.21754341f, 0.10291822f, -0.09909034f, 0.04130059f, -0.01814537f, 
    0.01476832f, -0.05431395f, -0.14831360f, -0.05199370f, -0.17654411f, -0.08224154f, 0.22947480f, -0.03966581f, 
    -0.04981286f, -0.11272860f, -0.02155276f, -0.12069887f, 0.15246600f, 0.03135544f, -0.04170737f, -0.02529987f, 
    -0.05056481f, -0.04662974f, -0.01011282f, 0.01384357f, 0.00146978f, 0.00852562f, -0.05849490f, -0.03958465f, 
    -0.05122492f, -0.03023836f, 0.02250439f, -0.01161138f, 0.01579653f, -0.00628348f, -0.00808539f, -0.03132883f, 
    0.00965945f, 0.02424227f, 0.03845421f, -0.02232428f, 0.00891822f, -0.01145594f, 0.00281695f, -0.02073403f, 
    0.02114229f, -0.01724329f, -0.03874778f, 0.05057625f, -0.01949592f, -0.04885811f, 0.01504096f, 0.01467303f, 
    -0.05772630f, 0.01026264f, 0.02339439f, 0.00845269f, -0.02979719f, -0.03221988f, -0.03717938f, -0.01656359f, 
    -0.03753785f, 0.01476159f, -0.04245926f, 0.04350441f, 0.01329703f, -0.00152725f, 0.03534838f, -0.05657449f, 
    -0.04835400f, -0.00027690f, -0.02886483f, 0.01283634f, -0.04714700f, 0.00061351f, 0.01896452f, 0.02848488f, 
    -0.05613113f, -0.02631978f, -0.02645977f, -0.00133943f, -0.02583903f, 0.01410319f, -0.04766953f, -0.00270581f, 
    -0.02608645f, -0.03415563f, 0.02536195f, -0.03294513f, 0.02944380f, -0.02295261f, -0.02376535f, -0.00881130f, 
    -0.04975178f, -0.05568844f, 0.02400560f, 0.01910584f, 0.03096305f, -0.05459236f, -0.02226944f, 0.02820883f, 
    -0.02312592f, 0.03349971f, 0.00194119f, -0.03824169f, -0.02847109f, 0.00676748f, -0.05347434f, -0.04555169f, 
    -0.01330020f, 0.03584468f, 0.03129101f, 0.01733283f, -0.01644635f, -0.01318941f, 0.00640906f, 0.02757299f, 
    -0.03959750f, 0.01495262f, -0.05097151f, -0.03947266f, 0.03285119f, -0.02722533f, -0.03820374f, 0.03543773f, 
    0.03380235f, -0.03985113f, -0.03308769f, -0.00303221f, 0.00887198f, -0.00127267f, 0.02485090f, 0.03183354f, 
    0.03592933f, -0.01293138f, -0.02069277f, -0.00325469f, 0.03061292f, -0.03392247f, -0.05359201f, 0.02522869f, 
    -0.03014644f, 0.01664869f, -0.05841880f, 0.02818078f, 0.01570743f, 0.02503509f, 0.02383032f, 0.00448791f, 
    -0.04528389f, 0.04096946f, 0.04145570f, -0.02305522f, -0.05863379f, 0.02322060f, -0.03547934f, 0.04557625f, 
    0.03242882f, 0.00807106f, 0.02396933f, -0.03018084f, -0.03726206f, -0.05578025f, -0.04944724f, 0.02807224f, 
    -0.01237499f, 0.03740315f, -0.03860938f, -0.02488867f, -0.03640429f, -0.03163537f, -0.00575510f, 0.01557878f, 
    0.02945849f, 0.00084265f, 0.02474036f, -0.02624189f, -0.04368419f, -0.02925164f, 0.02089505f, -0.01048011f, 
    -0.04522368f, -0.00695174f, -0.02311878f, 0.02199521f, 0.04028563f, 0.01100285f, 0.00065905f, 0.00848227f, 
    -0.01917778f, -0.03252510f, -0.02510038f, 0.01739629f, -0.02890419f, -0.01516479f, 0.01770891f, 0.00611479f, 
    -0.05112333f, 0.03895319f, 0.03382897f, -0.01725011f, 0.03883705f, -0.01510646f, -0.05565235f, 0.00940200f, 
    0.01137667f, 0.01149437f, -0.04568486f, -0.03443400f, 0.00874489f, 0.00424122f, -0.02000728f, 0.02087742f, 
    -0.04486434f, -0.04464027f, 0.00694204f, -0.04676870f, 0.00150031f, -0.02962648f, 0.03547662f, -0.01640349f, 
    -0.01011491f, -0.03773839f, 0.02038583f, 0.04336375f, -0.04725070f, -0.04422273f, -0.02779644f, -0.05159037f, 
    -0.00317014f, -0.02186848f, 0.03838511f, -0.04497575f, -0.04354024f, 0.02083227f, 0.02069501f, 0.02152409f, 
    0.02268868f, -0.00698802f, -0.02252666f, 0.04247931f, -0.01274613f, -0.04668948f, -0.05748755f, -0.01413932f, 
    0.01233962f, -0.01414973f, -0.00740894f, 0.00130068f, -0.02885017f, 0.04035307f, -0.03813935f, -0.05409716f, 
    0.03423265f, 0.02250574f, 0.00463105f, 0.03135768f, -0.01583930f, -0.03209175f, 0.00077239f, 0.02009306f, 
    -0.03009103f, 0.00398115f, -0.01696031f, -0.05963128f, 0.00052080f, -0.00518862f, 0.00390448f, 0.02813124f, 
    -0.00308976f, -0.05243490f, 0.03378265f, -0.04448400f, -0.02740141f, -0.02600158f, -0.02742046f, 0.02234553f, 
    -0.03470697f, -0.01105548f, -0.05238486f, -0.05873501f, -0.00773892f, 0.00997509f, 0.02519572f, -0.00819630f, 
    0.02587654f, 0.02948206f, -0.01343323f, -0.05990385f, 0.01192251f, 0.04084777f, 0.00739988f, 0.01373268f, 
    0.00026629f, -0.04356368f, -0.05400693f, -0.01598575f, 0.02495949f, -0.05303805f, -0.05381081f, -0.03176773f, 
    -0.01734640f, 0.01253360f, 0.03218775f, -0.01735891f, -0.02614118f, -0.02007441f, -0.01713577f, 0.01134693f, 
    -0.04120278f, 0.03545208f, -0.04438228f, 0.03676095f, 0.01877309f, -0.00175774f, 0.02197364f, -0.04261423f, 
    0.03802661f, -0.04296567f, -0.05396098f, 0.00323897f, 0.01477327f, -0.03465924f, -0.04421405f, -0.03348823f, 
    0.02164283f, 0.01432476f, 0.01110789f, 0.01626713f, -0.05451736f, 0.00370233f, 0.01124506f, 0.00171301f, 
    0.01318032f, -0.01125610f, -0.02418791f, 0.02674888f, -0.03735343f, 0.01563766f, -0.02306918f, -0.01350970f, 
    -0.05624203f, 0.01524536f, 0.03362636f, -0.00054078f, 0.00662040f, 0.02228703f, -0.02111123f, 0.03553393f, 
    -0.02056832f, -0.00200742f, -0.01542749f, -0.03865924f, -0.04210623f, -0.01185230f, 0.00342808f, 0.00152195f, 
    0.02045868f, -0.00071114f, 0.03122098f, 0.02576306f, -0.02184836f, -0.04023036f, -0.05428191f, 0.03353001f, 
    0.03594739f, 0.00227212f, -0.05447063f, -0.00109093f, 0.02013213f, 0.03077447f, 0.03781126f, -0.01641871f, 
    0.01063186f, 0.01196540f, -0.04833165f, 0.04003993f, -0.01552820f, -0.04677445f, 0.02987769f, -0.00598080f, 
    0.00781291f, 0.03651433f, 0.00238064f, 0.02996144f, -0.03319102f, 0.02772651f, 0.02699398f, 0.00118007f, 
    -0.05204875f, 0.02252803f, -0.00486262f, 0.00484536f, -0.04467379f, 0.01181266f, 0.00358997f, -0.01135568f, 
    0.04194316f, -0.05779430f, 0.00745712f, -0.01354667f, -0.00551321f, -0.01298053f, 0.03452647f, 0.01726002f, 
    -0.02471985f, -0.03762133f, 0.01910097f, -0.02960320f, -0.03365773f, 0.01535697f, 0.04362278f, -0.03194874f, 
    -0.02155263f, -0.00954530f, 0.02674378f, 0.04087036f, -0.04532926f, -0.00553718f, 0.03996789f, 0.00671385f, 
    0.00845389f, -0.00708094f, -0.03311523f, -0.00535606f, -0.01863389f, 0.00579887f, 0.02821581f, -0.04715009f, 
    -0.02738170f, -0.01998032f, 0.00838479f, 0.04041672f, -0.01934480f, 0.02552334f, 0.00145023f, 0.02923626f, 
    -0.04682054f, -0.00596048f, -0.01526138f, -0.02992013f, -0.02053196f, 0.00928320f, 0.02054294f, 0.02438696f, 
    0.02132087f, -0.00677681f, -0.05467729f, -0.03822868f, 0.04057623f, 0.00726192f, -0.02958469f, -0.00999416f, 
    -0.00027529f, 0.02960949f, 0.00096842f, -0.02734758f, -0.00173596f, -0.01949552f, 0.00462057f, -0.04741868f, 
    -0.02083999f, -0.01665330f, -0.04598205f, -0.03423988f, -0.02217480f, -0.03945906f, -0.02214810f, 0.00354421f, 
    0.03543504f, -0.00568643f, -0.02055602f, -0.02417546f, -0.05508317f, -0.02512103f, 0.03766678f, 0.02698479f, 
    -0.00863303f, -0.04624943f, -0.03764825f, -0.05348272f, 0.03866784f, 0.01912167f, 0.03271275f, -0.01100753f, 
    0.00966127f, 0.01455700f, 0.04041176f, -0.01655435f, -0.04147694f, -0.03446653f, -0.03823228f, 0.00712790f, 
    -0.05562461f, -0.01465380f, 0.01417759f, -0.02260787f, 0.02481493f, 0.02196894f, -0.00435593f, -0.03388520f, 
    -0.04885390f, -0.01636546f, -0.02859986f, 0.01567345f, -0.01399472f, -0.05035434f, -0.03281355f, -0.04980563f, 
    -0.00002074f, -0.00581933f, -0.01401522f, -0.03533383f, 0.01413838f, -0.00579715f, -0.00214436f, -0.04739013f, 
    0.00916453f, 0.04433102f, -0.02131168f, -0.02026541f, -0.00069123f, -0.02027329f, -0.03999492f, 0.03539694f, 
    -0.04789788f, -0.03278084f, 0.01198093f, 0.04161302f, -0.02525678f, 0.01601566f, -0.00803155f, 0.02445330f, 
    0.02534639f, -0.02920668f, 0.01685482f, 0.03501742f, -0.03357615f, 0.00840797f, -0.01127795f, -0.03758789f, 
    -0.01436945f, -0.02803018f, -0.04531753f, 0.02015494f, 0.02382267f, -0.00800537f, 0.02284429f, -0.02721884f, 
    0.00727992f, 0.00676284f, -0.03567201f, -0.01047991f, -0.05068475f, -0.04258517f, -0.03561545f, 0.00207385f, 
    -0.03607153f, -0.04194612f, -0.02396156f, -0.01821673f, 0.03880186f, -0.00832902f, -0.03736509f, -0.05083019f, 
    0.00011273f, -0.02545801f, -0.00631786f, -0.04077870f, 0.01073331f, -0.02007159f, -0.00086564f, -0.03609039f, 
    -0.03276976f, 0.02885523f, 0.02394463f, -0.05578362f, 0.00040764f, 0.00127069f, -0.03241593f, 0.00211635f, 
    -0.03748045f, -0.04940246f, -0.04306880f, 0.00972068f, -0.00964139f, 0.02912396f, 0.01549831f, 0.00789442f, 
    0.01057843f, -0.01831809f, -0.01345682f, 0.01278111f, -0.00621816f, 0.00396947f, -0.05131683f, 0.01060076f, 
    -0.00182743f, -0.05240176f, -0.00336048f, -0.02309465f, 0.00623338f, 0.04374172f, -0.02610121f, -0.04563602f, 
    -0.05063188f, -0.05379830f, 0.00240658f, 0.03305068f, -0.00521645f, -0.04839262f, -0.00978708f, 0.03027767f, 
    -0.00866633f, -0.00926534f, -0.01022230f, 0.04209173f, -0.00308751f, -0.02508323f, -0.00891241f, -0.00782212f, 
    -0.03232444f, -0.03489299f, -0.03432297f, 0.01727761f, -0.00846171f, -0.03651015f, -0.01219705f, 0.02555027f, 
    0.00524708f, -0.03332219f, -0.01396980f, 0.03454983f, -0.03435890f, -0.02266373f, -0.03332065f, -0.05651983f, 
    0.03230408f, 0.02779868f, 0.03086803f, -0.02907719f, -0.01005860f, 0.03033992f, -0.04358432f, 0.03232585f, 
    -0.01009612f, -0.02589965f, -0.04044375f, -0.04651395f, 0.00767259f, 0.01541915f, 0.03920786f, 0.01320619f, 
    0.00553726f, -0.00334772f, 0.01611171f, -0.05215868f, -0.00747144f, -0.04225954f, 0.03636309f, -0.04086045f, 
    0.03519367f, -0.00276901f, -0.00795904f, -0.00589153f, 0.02562123f, -0.03671706f, 0.00001055f, -0.01593141f, 
    0.03193664f, -0.02398016f, -0.01629744f, -0.04879760f, -0.00322980f, -0.04192794f, -0.03957384f, -0.01186329f, 
    0.04011274f, -0.01671647f, 0.01104433f, -0.00629867f, -0.05163175f, -0.03681640f, -0.00571930f, -0.05693508f, 
    -0.02694007f, -0.03106004f, -0.01885720f, 0.00306658f, 0.03718467f, -0.04490992f, -0.01122138f, 0.03938350f, 
    -0.03399947f, -0.01689130f, -0.01591598f, 0.03659217f, -0.02677151f, 0.03570331f, -0.05245901f, -0.02239900f, 
    0.01916271f, 0.00345773f, 0.04410557f, -0.01008856f, 0.01882311f, -0.02190898f, 0.01579414f, 0.03727646f, 
    0.01265866f, 0.02312770f, -0.00608513f, -0.01737779f, -0.01455465f, 0.03038611f, -0.04482058f, 0.02291057f, 
    0.00718353f, -0.03575082f, -0.00980171f, -0.04474081f, -0.01973396f, 0.03213727f, 0.02347350f, 0.01007918f, 
    0.03468357f, -0.02611409f, -0.00429020f, 0.02459166f, -0.04712778f, -0.02227375f, 0.02160423f, -0.00038936f, 
    0.00719296f, 0.03600926f, -0.05121989f, 0.00472626f, 0.04471495f, -0.04254434f, -0.02240489f, 0.01317576f, 
    0.01292987f, 0.00167320f, 0.01272779f, -0.03834553f, 0.03981065f, -0.02964384f, -0.05534508f, -0.00463489f, 
    -0.00473133f, -0.05089889f, 0.01406964f, -0.00993974f, 0.03319514f, -0.02637544f, 0.03051277f, -0.05294371f, 
    0.01462354f, -0.02267370f, 0.03315914f, -0.00791050f, -0.00087728f, -0.01406841f, 0.00634667f, -0.02196082f, 
    0.02125220f, -0.02719342f, 0.01966637f, -0.05639116f, 0.03812830f, -0.02675299f, -0.04610777f, 0.01490196f, 
    -0.00625266f, 0.04431912f, -0.00835371f, 0.00757065f, -0.01243794f, 0.03619011f, 0.03052999f, 0.00887163f, 
    0.03454226f, -0.01462888f, 0.04385627f, 0.02202408f, -0.01390677f, -0.00502617f, -0.02225958f, 0.01524539f, 
    -0.02606212f, 0.03941803f, -0.04608915f, -0.01815928f, -0.03282339f, 0.01700917f, -0.03790528f, -0.04757722f, 
    0.02615544f, -0.03418430f, -0.02854303f, 0.00441864f, 0.04005697f, -0.03124066f, 0.00727545f, -0.05227926f, 
    0.00693025f, -0.01806702f, -0.05087720f, 0.01143782f, 0.02950260f, 0.00604387f, 0.03731736f, -0.00318633f, 
    0.03242929f, -0.04922294f, 0.01315952f, 0.01715503f, 0.02020309f, 0.04273897f, -0.04028163f, 0.01297124f, 
    -0.01554993f, 0.03885313f, -0.03082183f, -0.02591788f, 0.01027823f, -0.03229722f, -0.02136734f, -0.01577715f, 
    0.04224578f, -0.01327179f, -0.05048724f, -0.04069236f, 0.04491870f, 0.00101249f, 0.01615938f, -0.03098621f, 
    -0.03487210f, -0.00635157f, -0.05045000f, -0.03343511f, 0.01954374f, -0.04242306f, -0.05443487f, 0.01824977f, 
    -0.01279619f, 0.03322313f, -0.00302357f, -0.01712281f, 0.03379654f, 0.00949345f, -0.03689720f, 0.03973700f, 
    -0.00027982f, 0.00479053f, -0.02816466f, -0.03048252f, -0.01601241f, -0.03212713f, -0.02186604f, 0.03384378f, 
    -0.01811693f, -0.00804686f, -0.01358307f, -0.04185154f, -0.05539003f, -0.01692788f, 0.02911877f, 0.03954265f, 
    0.02905780f, 0.03778908f, -0.00581344f, -0.05092721f, 0.01701533f, -0.05602312f, -0.00657529f, 0.01384701f, 
    0.00030022f, -0.02255192f, -0.04102186f, -0.01870673f, 0.02716244f, 0.04426757f, -0.00121506f, 0.01543361f, 
    -0.01105932f, -0.00988017f, -0.00199236f, -0.04574073f, 0.04030079f, 0.00748842f, -0.00773381f, 0.03884218f, 
    0.02229246f, -0.03001065f, 0.03419154f, -0.02475352f, 0.00661492f, -0.05430371f, -0.05599664f, -0.01939900f, 
    -0.03026345f, -0.03627548f, 0.02495202f, 0.01197637f, -0.03986838f, -0.01258827f, 0.00589529f, -0.03555643f, 
    -0.03134344f, -0.04469884f, -0.00762632f, -0.00397585f, -0.04418105f, -0.05043271f, 0.04099659f, -0.03755847f, 
    -0.00616552f, 0.01853418f, -0.05387346f, -0.03081035f, -0.01091159f, -0.03787874f, -0.02069647f, -0.00508544f, 
    0.01179344f, 0.01540511f, 0.03315471f, 0.01371901f, -0.04010225f, 0.02421883f, 0.02180371f, 0.02381491f, 
    -0.01432498f, -0.03522022f, -0.02687332f, 0.04252788f, -0.01575563f, -0.03928749f, -0.03574231f, -0.02829985f, 
    -0.00689667f, -0.02816988f, 0.00763697f, -0.03355562f, -0.01659867f, 0.04382057f, -0.01502101f, -0.00539523f, 
    -0.00890062f, -0.01612029f, -0.04769232f, 0.01460836f, -0.03906329f, 0.02195989f, -0.04709397f, -0.04806127f, 
    -0.01047355f, -0.04845867f, 0.03353349f, -0.03245636f, 0.03866587f, -0.02613771f, -0.03659719f, 0.01621259f, 
    0.00367645f, -0.02448840f, 0.02349244f, 0.02515710f, 0.01575606f, 0.00192348f, -0.00612511f, -0.03025150f, 
    0.00976460f, 0.00690802f, -0.01435901f, -0.02038408f, -0.01787883f, 0.03726384f, 0.01630727f, -0.04345451f, 
    0.01267066f, -0.04938020f, -0.02771316f, -0.02853237f, 0.00624890f, 0.03908543f, -0.02853834f, -0.00056767f, 
    -0.02468779f, -0.00701767f, -0.01818320f, -0.01470350f, -0.03524187f, 0.02004188f, -0.02059224f, -0.01787831f, 
    0.00613673f, 0.02486882f, 0.03938253f, 0.03185163f, 0.00168722f, -0.01964742f, 0.01694946f, 0.00228042f, 
    -0.01738971f, 0.00138271f, 0.01071112f, -0.01131833f, -0.00536370f, 0.04553135f, 0.03315638f, 0.03471312f, 
    -0.02562040f, -0.00013189f, 0.01327081f, -0.01420924f, 0.00825110f, -0.04295241f, -0.01990332f, 0.03658518f, 
    -0.05080415f, 0.01406928f, 0.04397286f, -0.03157673f, 0.01108626f, -0.02876166f, 0.00786118f, -0.03605335f, 
    -0.04067920f, -0.04209566f, -0.04001243f, 0.01955827f, 0.03696683f, -0.00549116f, -0.03894583f, -0.03672618f, 
    0.03874465f, 0.01730957f, 0.00609549f, -0.03401299f, -0.00100065f, -0.00706597f, -0.03812840f, -0.04082060f, 
    0.03479294f, 0.02459173f, 0.02601797f, 0.00299535f, 0.00915200f, 0.00659563f, -0.04887097f, -0.05221802f, 
    -0.01092952f, -0.05188393f, -0.01869306f, -0.03686361f, -0.00238254f, 0.00864930f, -0.04590354f, -0.00590911f, 
    -0.00776715f, 0.01252199f, -0.02893185f, -0.01434381f, -0.04198574f, -0.01301680f, 0.03285051f, 0.02158105f, 
    -0.04831208f, -0.03376420f, 0.01124596f, -0.04198261f, 0.01557031f, -0.01993525f, -0.01182013f, -0.03790900f, 
    0.00148354f, -0.00031685f, -0.00377816f, 0.01548633f, -0.03060650f, -0.01222092f, 0.01851196f, -0.02641723f, 
    0.04241944f, -0.02760265f, 0.01344727f, 0.04565506f, -0.02289110f, 0.02235963f, -0.02304206f, 0.00239820f, 
    -0.00186242f, 0.00321721f, -0.05043437f, -0.01133800f, -0.04684987f, 0.02248188f, -0.05437142f, 0.01158130f, 
    -0.02944113f, -0.04697382f, 0.01452925f, 0.02982101f, 0.01047831f, 0.04169635f, 0.01777668f, 0.03054190f, 
    0.00431879f, -0.04379508f, 0.02683059f, 0.03688746f, -0.02077052f, 0.02420217f, 0.00447483f, 0.03176269f, 
    -0.04390267f, -0.01400366f, -0.02794373f, -0.03222561f, -0.00703749f, -0.01458957f, 0.03756373f, -0.04740321f, 
    0.04297058f, -0.00108761f, -0.01843743f, -0.01074142f, -0.03460418f, -0.01625479f, -0.03845288f, -0.03628239f, 
    -0.02207612f, -0.04887274f, -0.03690116f, -0.01384956f, -0.04413988f, -0.03361852f, 0.00367084f, -0.01268718f, 
    0.04530031f, -0.04736404f, 0.04460658f, -0.03604239f, -0.00847340f, -0.05464815f, -0.04974853f, 0.02529660f, 
    -0.02588631f, 0.03532180f, 0.01372802f, -0.03807266f, 0.04029999f, 0.01763602f, 0.04514956f, 0.02997671f, 
    -0.03460531f, 0.01183555f, -0.04206293f, 0.03463941f, 0.04183521f, -0.00696889f, -0.04664763f, -0.03331434f, 
    0.01730129f, -0.02931765f, -0.02304770f, -0.03613492f, 0.01481328f, 0.00137250f, 0.01705674f, -0.00468125f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02340683f, 0.03281433f, 0.01974424f, -0.00110790f, -0.02707975f, 0.02826162f, -0.06236346f, -0.04267347f, 
    -0.04599893f, -0.04307440f, 0.05010316f, 0.00858209f, 0.05634193f, -0.04978618f, -0.05479752f, 0.04209395f, 
    -0.00998373f, -0.02503575f, -0.06159109f, 0.07766248f, 0.05500561f, 0.02373161f, -0.05663113f, 0.00071494f, 
    -0.00950572f, 0.07374892f, 0.02012752f, 0.11218216f, 0.14458647f, 0.02628644f, -0.05689171f, -0.00809508f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06158619f, 0.06481891f, 0.01255668f, 0.07486521f, 0.04167162f, 0.22834460f, 0.03212856f, 0.11191652f, 
    0.49566886f, -0.05106685f, -0.69867396f, -0.18959437f, 0.34216690f, 0.01689544f, 0.08013630f, -0.09864754f, 
    0.07332403f, -0.54527831f, 0.21507122f, -0.26063073f, -0.11193631f, 0.00050940f, -0.11159921f, 0.16843969f, 
    0.29958555f, 0.17959733f, 0.29305401f, -0.51838970f, -0.19936426f, -0.04927279f, -0.12616262f, 0.07226814f, 
    0.08129614f, -0.11447894f, -0.05581418f, -0.10941339f, -0.07487194f, -0.33968249f, -0.83913147f, 0.09816768f, 
    -0.07035786f, -0.14827073f, -0.37850344f, 0.00008263f, -0.89867634f, 0.16241144f, -0.06406099f, 0.14475372f, 
    -0.10417504f, -0.43394461f, 0.17398548f, 0.31571364f, -0.28649217f, 0.24765542f, -0.06999876f, -0.15536147f, 
    0.02807321f, 0.12014850f, 0.20016110f, 0.35394812f, -0.14338984f, 0.00648662f, 0.11403122f, -0.15335065f, 
    -0.11745635f, -0.07678397f, -0.04561712f, 0.11572859f, -0.14807971f, -0.92063618f, 0.40387097f, 0.13742119f, 
    0.05231959f, 0.12994915f, 0.22607180f, 0.19653186f, 0.12436750f, -0.11345229f, -0.03492260f, 0.09475704f, 
    0.01314189f, -0.16779999f, 0.17144547f, -0.08191283f, -0.47413224f, 0.20451801f, 0.12043158f, 0.03243061f, 
    0.34935942f, -0.28217185f, -0.48872367f, -0.13763607f, -0.46259314f, 0.06887976f, -0.06598648f, 0.06777944f, 
    0.04195721f, -0.12769799f, 0.14928752f, 0.08487131f, -0.13267665f, 0.25025207f, -0.24411146f, 0.05850563f, 
    0.50285345f, -0.02148912f, 0.28370896f, -0.58280522f, -0.02852979f, -0.06124615f, -0.16901514f, 0.08242562f, 
    0.07196488f, 0.07932445f, -0.08044841f, 0.05627807f, -0.48572186f, -0.85153735f, 0.09685688f, 0.08310201f, 
    -0.00520494f, 0.29189438f, 0.32284290f, -0.31625894f, 0.21740603f, 0.00140783f, -0.07283899f, 0.11415739f, 
    0.00020140f, -0.14633048f, 0.02927797f, 0.16361596f, 0.02967798f, -0.02251974f, -0.01142882f, 0.01612415f, 
    -0.15618593f, -0.15872961f, -0.21368027f, 0.34416223f, 0.38247332f, -0.08430549f, 0.02900636f, 0.07443032f, 
    -0.06515045f, 0.10427544f, -0.33893752f, 0.01887063f, -0.43115214f, 0.01059792f, 0.06782670f, -0.11678162f, 
    -0.02124676f, -0.25438231f, 0.48326558f, 0.05246143f, 0.36949947f, -0.15903856f, 0.07334129f, 0.03803398f, 
    -0.10415390f, -0.00598504f, -0.01973722f, -0.13085602f, -0.09068586f, 0.44166026f, 0.01086923f, 0.08508282f, 
    -0.25860387f, 0.00990080f, -0.16595002f, 0.18479756f, -0.43168762f, 0.05041543f, -0.01014206f, -0.15245710f, 
    0.08744617f, -0.52692854f, 0.14373530f, 0.12194397f, 0.38510263f, 0.10081628f, 0.01100807f, -0.13822234f, 
    -0.44985047f, -0.13288158f, -0.26413766f, -0.16655529f, 0.41396931f, -0.00177802f, 0.03384225f, 0.07642478f, 
    -0.02000708f, -0.10559244f, 0.00434656f, -0.04892268f, 0.15068267f, -0.33466655f, -0.35701579f, -0.14217857f, 
    0.40857634f, -0.04995031f, 0.25622383f, -0.48110387f, 0.19535464f, 0.06840156f, -0.07687662f, -0.06103808f, 
    -0.16902022f, 0.42213976f, 0.25823456f, 0.02849054f, 0.34603766f, 0.23379534f, 0.01836137f, -0.07094184f, 
    -0.42693129f, -0.60849410f, -0.06543796f, -0.25847188f, -0.10068280f, -0.15835559f, 0.06565601f, 0.02300993f, 
    -0.13809940f, -0.16302827f, 0.14723948f, 0.05619310f, 0.15075107f, 0.16426502f, 0.45997870f, -0.12467230f, 
    -0.41521898f, 0.15948011f, 0.03671994f, 0.16764849f, 0.11254751f, 0.13094857f, 0.05293032f, -0.09253907f, 
    -0.02350688f, 0.41293129f, -0.35644504f, -0.73135370f, 0.19464937f, -0.31485376f, 0.14073808f, 0.07103967f, 
    -0.46006903f, 0.30678487f, -0.02134210f, 0.14195688f, 0.15869959f, 0.10364007f, 0.00274425f, 0.02371233f, 
    0.05819456f, 0.04024098f, -0.10094590f, -0.00959244f, 0.00181448f, 0.37459421f, 0.10400046f, -0.02436761f, 
    -0.60295677f, 0.09973827f, 0.17241324f, 0.47568202f, -0.53254998f, 0.03175904f, 0.13615273f, 0.16655448f, 
    0.09524269f, -0.25363818f, 0.25590044f, -0.20761667f, -0.40761212f, -0.17605989f, 0.00500818f, 0.12245851f, 
    -0.13405399f, 0.24998105f, -0.56627858f, 0.21407245f, -0.62194771f, -0.15680464f, 0.08202650f, 0.12919557f, 
    -0.06835289f, -0.09658726f, -0.01348074f, 0.01683853f, 0.00490489f, 0.14820294f, 0.49234930f, -0.07480721f, 
    -0.27617317f, 0.17964542f, -0.41446006f, -0.49073371f, 0.52165806f, 0.06290599f, -0.17165776f, 0.07890550f, 
    0.15738612f, 0.27666244f, -0.12448665f, 0.23424569f, -0.17786214f, 0.12033181f, 0.06226174f, -0.09020790f, 
    -0.31226584f, -0.12050552f, -0.52487922f, 0.42343113f, -0.08698226f, -0.09633277f, 0.05550314f, -0.01048073f, 
    0.06854421f, -0.16375692f, -0.16624406f, 0.07039925f, -0.08435968f, 0.16020779f, -0.82567048f, -0.15612315f, 
    -0.77197438f, 0.11242658f, 0.29171851f, -0.48818538f, 0.21522096f, 0.02152443f, 0.09759459f, -0.10540904f, 
    -0.01332790f, -0.14689806f, -0.35777158f, -0.12792639f, 0.40345389f, 0.02288463f, 0.09591983f, -0.12650660f, 
    0.38759753f, 0.29111063f, -0.52607435f, 0.05861158f, 0.24343105f, -0.08963943f, -0.04882002f, -0.12150263f, 
    -0.16518116f, -0.03430712f, -0.10995803f, 0.13896976f, 0.12819462f, 0.04947696f, -0.06183432f, 0.14085220f, 
    0.50498402f, 0.01373794f, 0.43111101f, 0.06690335f, -0.02247648f, -0.04667134f, -0.10274445f, -0.00697043f, 
    -0.13474533f, -0.45107490f, -0.18184650f, -0.24365894f, 0.47319210f, -0.33378300f, -0.12889312f, 0.01326317f, 
    0.11494230f, -0.40866122f, 0.18968882f, 0.45869458f, -0.12360263f, -0.10189640f, -0.13131824f, 0.02976481f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01939770f, 0.17566884f, 0.11393463f, 0.00950376f, -0.17233801f, 0.05870267f, -0.15234730f, -0.03064061f, 
    -0.14509377f, -0.04429517f, 0.21139702f, -0.13434274f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
