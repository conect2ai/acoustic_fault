#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.48118442f, 0.58483893f, 0.55150610f, 0.09812345f, -0.02881137f, -0.38418180f, -0.01015532f, -0.55278784f, 
    -0.67176747f, -0.46960479f, 0.05410751f, 0.04889454f, 0.18211061f, 0.36578265f, 0.47400853f, 0.50665885f, 
    -0.43928438f, 0.46667796f, 0.02398663f, 0.18468688f, -0.14929110f, 0.61842424f, 0.11700387f, 0.04834836f, 
    0.31005621f, -1.55869293f, -0.19242208f, 0.06374353f, -1.33361363f, -1.48879325f, 0.20121272f, -0.39445496f, 
    -0.11348999f, 0.57052368f, 0.02185906f, -0.87620151f, -0.48633060f, 0.45557705f, -0.52661180f, -0.03039554f, 
    0.69437325f, 0.05444334f, 0.16287470f, 0.16023770f, 0.18883458f, 0.29071632f, 0.40736488f, 0.04466730f, 
    -0.29013005f, -0.01663887f, -1.10230649f, -0.77143288f, -0.18650696f, 1.08119166f, 0.61422509f, -0.14267150f, 
    -0.10237766f, 0.00555944f, 0.63232726f, 0.83319139f, -0.05533567f, 0.32105359f, -0.35628778f, 0.05506872f, 
    -0.05139584f, -0.17616802f, -0.36512738f, 0.27830803f, -0.31133616f, 0.17679507f, 0.05145248f, 0.17592502f, 
    -0.00319682f, -0.08954216f, 0.47878203f, -0.61713314f, -0.07050578f, -0.17218152f, 0.45360354f, 0.29345980f, 
    -0.01793502f, 0.86518705f, 0.34809479f, 0.00486247f, 0.06924915f, 0.11568802f, 0.31559911f, 0.17108147f, 
    -0.30151600f, -0.21183796f, -0.37768802f, 0.18142825f, -0.00053280f, -0.29712150f, -0.14226276f, 0.11706859f, 
    -0.35940146f, -0.43991131f, 0.01877948f, -0.27743122f, -0.35217831f, 0.68126750f, 0.66637295f, 0.27719036f, 
    0.25471446f, 0.30765617f, 0.13983829f, -0.04660867f, 0.20459501f, -0.12302869f, -0.62220311f, -0.16476206f, 
    0.06940012f, 0.09657508f, -0.11756742f, -0.05332804f, -0.15820657f, -0.18709114f, -0.16296004f, 0.22772217f, 
    -0.39933565f, -0.22735286f, -0.04329378f, -0.39538890f, -0.74827331f, 0.77553838f, 0.40322849f, 0.63495481f, 
    0.54311359f, 0.80309767f, 0.27645874f, 0.14223444f, 0.49176976f, -0.00135005f, 0.13898551f, 0.11319047f, 
    0.12665813f, 0.27678075f, -0.20511478f, -0.16482984f, -0.07286999f, 0.06124443f, 0.05347656f, -0.02719847f, 
    -0.24594255f, 0.06868405f, 0.02985632f, 0.00547986f, 0.06883423f, -0.13311329f, -0.40755606f, 0.33545232f, 
    -0.72566223f, -0.24653958f, 0.53306800f, -0.08180533f, -0.17676371f, 0.18472539f, 0.58648324f, -0.19850007f, 
    0.16468497f, -0.35952374f, 0.31359357f, -0.05433157f, -0.35170329f, -0.17457601f, -0.20713305f, 0.54011470f, 
    -0.40121967f, -0.58165389f, 0.20638898f, 0.42145577f, 0.25642377f, 0.37373301f, 0.73398256f, -0.95663756f, 
    -0.83885300f, -0.35300356f, -0.16499081f, -0.05061420f, -0.93552154f, -0.76727509f, -1.01271784f, -0.77620858f, 
    -0.73317760f, 0.16565031f, -0.22885478f, 0.25166571f, -0.52088588f, 0.00651783f, 0.25744224f, 0.16761990f, 
    0.13205598f, 0.10732088f, 0.21647473f, -0.11235270f, 0.18055743f, 0.12455145f, 0.26598707f, 0.48819411f, 
    -1.48625028f, -0.97445929f, -1.38445640f, -0.83869737f, -1.06189585f, 0.95223892f, 0.17401119f, 0.52959681f, 
    0.15973167f, 0.50250572f, 0.29920769f, -0.11384262f, -0.01932199f, 0.19009295f, 0.06515244f, -0.41208190f, 
    -0.08323911f, 0.18053614f, -0.05102737f, -0.38572982f, -0.35498133f, -0.16727735f, 0.24308422f, 0.05463501f, 
    -0.21201706f, 0.88069212f, 0.71853554f, 0.55606031f, -0.45798829f, -0.46035299f, 0.39106309f, -0.68040168f, 
    0.11505001f, 0.04668199f, -0.31039819f, 0.06615606f, 0.04991950f, -0.07237909f, 0.29584682f, -0.34047043f, 
    -0.05258416f, -0.18153854f, 0.39319670f, 0.15159155f, -0.11261047f, 0.34942722f, 0.21435402f, -0.24625961f, 
    -0.34519792f, -0.27338287f, -1.00433886f, -0.80123538f, -0.12195534f, 0.28450841f, 0.00735930f, 0.57908183f, 
    -0.43912324f, -0.78637666f, 0.09351413f, 0.63385928f, 0.76608765f, -0.48111221f, -0.45442894f, -0.08713061f, 
    0.31161371f, -0.62955779f, -0.51441115f, -0.36337197f, -0.72711366f, -1.06946313f, -0.70755929f, -0.67665720f, 
    -0.37248945f, 0.36934087f, -0.24321891f, -1.15865982f, 0.36219561f, -0.76361907f, -0.87379825f, 0.23686957f, 
    0.00875770f, 0.21112885f, 0.75382334f, 0.65363795f, 0.58549380f, -0.36298358f, -0.13322602f, -0.06855980f, 
    0.20861684f, 0.07037558f, 0.18660910f, -0.47223061f, -0.32541227f, 0.27820027f, 0.37610912f, 0.25206369f, 
    -0.13577189f, -0.16586338f, 0.15057717f, -0.24036375f, -0.01869669f, 0.87158114f, 0.71061301f, -0.11862184f, 
    -0.35329187f, -1.73072457f, -1.33291340f, -0.55999321f, -0.12226357f, -0.08579197f, 0.47125736f, -0.67586702f, 
    -0.00816181f, 0.92379087f, -0.10225874f, 0.00995364f, 0.14418150f, 0.02444729f, -0.25887206f, -0.43429631f, 
    -0.03574524f, -0.02090690f, 0.00200090f, 0.15669820f, -0.16207017f, -1.81968510f, -0.49090061f, -0.78345406f, 
    -0.82580072f, -0.73632777f, 0.88078165f, 0.41791743f, -1.09768331f, -1.13864303f, -0.58245778f, -0.29814896f, 
    0.16547781f, -0.49061289f, -0.86933541f, -0.40656096f, -0.01664314f, -0.05089054f, -0.22015330f, -0.28556091f, 
    -0.45056927f, -0.01613813f, 0.06156446f, -0.22221313f, -0.03995614f, -0.36121017f, 1.29103506f, 0.64974976f, 
    -0.11327655f, -0.92674088f, -1.79347563f, 0.33484387f, 0.73520797f, 0.48692310f, -0.19579653f, -0.42059863f, 
    -0.09372554f, 0.34085619f, -0.22420807f, 0.11381491f, 0.22858489f, 0.26664305f, -0.52926683f, 0.06672233f, 
    -0.04179618f, -0.24231726f, 0.16260013f, -0.30803180f, -0.20278084f, 0.17572698f, 0.42066514f, 0.35625395f, 
    1.10517311f, 0.85810828f, -0.13066036f, -0.52942699f, -0.54797500f, -0.56266451f, 0.28809434f, -0.21932115f, 
    -0.22161277f, 0.32456753f, -0.24808542f, -0.16898182f, -0.14776812f, -0.40014669f, 0.05104886f, 0.39015573f, 
    0.09162681f, 0.61139935f, -0.19872925f, -0.14736959f, -0.29972991f, -0.35670376f, -0.16062851f, 0.52174854f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.27969313f, 0.12065840f, 0.71043855f, 0.24432972f, 0.31714523f, -0.13976015f, 0.56229115f, 0.03794419f, 
    0.12450458f, 0.70179743f, 0.18328229f, 0.72568154f, 0.33061707f, -0.54161501f, 0.81150317f, 0.61778516f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01021345f, 0.00481844f, -0.04615634f, -0.02844645f, -0.15939911f, -0.25805277f, 0.11999902f, -0.29182142f, 
    -0.03505568f, 0.07396819f, -0.04551941f, -0.14969039f, 0.10301028f, 0.33893222f, 0.05928744f, -0.27959234f, 
    0.01969101f, 0.43424314f, -0.08505246f, -0.06359900f, 0.03019502f, 0.08729481f, 0.09283268f, 0.03194312f, 
    0.33572561f, 0.26494676f, 0.30807835f, -0.33687493f, -0.21204603f, -0.05115904f, 0.18153416f, -0.10480791f, 
    -0.17582589f, 0.00064393f, -0.31046531f, -0.52945131f, -0.01529909f, 0.06129641f, 0.04876000f, 0.02936767f, 
    0.03782007f, -0.02025832f, 0.12180488f, 0.05068471f, -0.21698380f, -0.01556673f, 0.10337263f, 0.13079393f, 
    -0.77375853f, -0.49373287f, -0.09360588f, 0.12516920f, 0.00698420f, -0.05995646f, -0.01353367f, -0.01065376f, 
    0.03288443f, 0.04939972f, -0.02890965f, -0.05028556f, -0.08717149f, -0.08061717f, -0.04656952f, 0.23548295f, 
    0.12960802f, 0.03163563f, 0.09249793f, 0.05715451f, 0.12800831f, 0.03045657f, 0.07605900f, 0.02847656f, 
    -0.08006234f, 0.15142962f, 0.04394509f, -0.22487780f, 0.14090280f, 0.14011672f, 0.00691062f, -0.05963083f, 
    -0.09310446f, -0.18664512f, -0.11066075f, -0.17188504f, 0.69079477f, 0.44351244f, -0.16171908f, -0.65129119f, 
    0.15872860f, -0.19749181f, -0.07741085f, -0.14154445f, -0.03684492f, 0.00870014f, -0.02280604f, -0.02124029f, 
    0.47191000f, -0.03907556f, -0.05882044f, -0.18285842f, 0.14516832f, 0.30436513f, 0.00181658f, -0.15905549f, 
    -0.00455989f, -0.01679113f, -0.05660893f, 0.19125104f, -0.44145522f, -0.76783556f, -0.42646790f, 0.24122004f, 
    -0.01124483f, 0.17090765f, -0.11587289f, -0.21735887f, -0.13640039f, -0.09846758f, -0.18827261f, -0.09000608f, 
    0.34795868f, -0.00593312f, 0.08708002f, -0.14079428f, -0.15594918f, 0.03005179f, -0.09551095f, -0.13947189f, 
    -0.11814865f, -0.12348560f, 0.01080867f, 0.04358920f, -0.46008173f, -0.22146131f, 0.04848859f, 0.00813443f, 
    0.09423702f, 0.16543114f, 0.16858047f, -0.07032787f, -0.04081760f, -0.05073867f, -0.04208587f, -0.26019856f, 
    0.17469773f, 0.35130808f, 0.41213804f, -0.35697144f, -0.03790359f, 0.39780328f, -0.21001917f, -0.09308273f, 
    0.11139207f, 0.02224174f, -0.00827406f, -0.03380581f, 0.60792577f, 0.48314473f, -0.41471437f, -0.20477681f, 
    0.03643231f, 0.21839996f, 0.10284363f, 0.18045463f, -0.11140858f, -0.15578966f, -0.09496691f, -0.06291743f, 
    -0.24983878f, -1.01642227f, -0.37480426f, 0.31941792f, -0.03094641f, -0.17758526f, -0.28375617f, -0.29165390f, 
    -0.23878253f, -0.14836572f, -0.32937330f, -0.26609004f, -0.67485696f, 0.03381415f, 0.02847889f, 0.23959352f, 
    0.06111619f, -0.05484426f, -0.15390901f, -0.10587674f, -0.11136630f, 0.05636992f, -0.03949319f, 0.04022659f, 
    0.15302026f, -0.02600066f, -0.14532925f, -0.05554695f, -0.11908925f, 0.19828726f, -0.36716297f, -0.08442722f, 
    -0.17747580f, 0.16755900f, 0.07915623f, 0.06381225f, -0.10947188f, 0.42824271f, -0.02840021f, 0.01274140f, 
    -0.20654382f, 0.21591984f, -0.46994740f, 0.11310421f, -0.16194306f, -0.11460742f, -0.05186294f, -0.19300540f, 
    -0.21656704f, 0.11976909f, -0.21753322f, 0.02057590f, -0.03825183f, 0.10324622f, 0.04051440f, -0.02406249f, 
    -0.19780047f, 0.11045462f, -0.17193802f, 0.24968396f, 0.15239738f, -0.14183691f, 0.16685741f, 0.08416744f, 
    -0.08580109f, -0.03911091f, -0.03811336f, -0.06021879f, -0.15127815f, -0.15869693f, -0.16689198f, 0.13158974f, 
    0.23192860f, 0.21088739f, 0.14290704f, 0.14292592f, -0.02146549f, -0.07955379f, -0.07826958f, 0.08556350f, 
    -0.07424747f, 0.31476179f, 0.30169332f, -0.31627938f, 0.34341672f, 0.17450701f, 0.18130155f, 0.30209273f, 
    -0.18105523f, -0.07373451f, 0.00914423f, -0.15670168f, -0.01050518f, 0.05928957f, 0.02043962f, 0.04323544f, 
    -0.40362528f, 0.01938595f, 0.01335666f, -0.02176698f, 0.28109130f, 0.21568066f, 0.18581533f, -0.01602947f, 
    0.01229510f, 0.10368759f, -0.09806698f, 0.00460581f, -0.07852669f, 0.10178936f, -0.01510504f, -0.09429994f, 
    -0.16422781f, 0.13370606f, 0.12742412f, -0.05082452f, -0.00888908f, 0.02905109f, -0.14887953f, -0.01448713f, 
    0.10380044f, 0.02270143f, -0.21740250f, -0.24353941f, 0.01054815f, 0.20690709f, 0.18452030f, -0.22095686f, 
    0.16977645f, 0.04390348f, -0.01129978f, -0.25362605f, 0.30789500f, 0.01309724f, -0.01012773f, -0.26864725f, 
    -0.06404415f, -0.10140818f, -0.20198418f, 0.31979257f, -0.07260928f, -0.02105686f, 0.17323789f, 0.11582869f, 
    0.12081889f, 0.12821977f, -0.38302565f, -0.42841038f, -0.04251510f, 0.15879759f, 0.06368724f, 0.01224638f, 
    0.07955503f, -0.53310359f, -0.20697623f, -0.42270955f, -0.41620085f, 0.17564946f, -0.10373801f, 0.08029798f, 
    -0.04960405f, 0.05230978f, -0.05354678f, -0.03385215f, -0.08026432f, 0.07989943f, -0.06086294f, 0.09772513f, 
    -0.25306532f, -0.04636811f, -0.16655828f, -0.57429975f, 0.13516952f, -0.42474094f, 0.04196861f, 0.28714713f, 
    -0.00431802f, -0.02847083f, 0.04810624f, 0.02624754f, 0.37749270f, 0.20474873f, 0.28501353f, 0.05676917f, 
    0.03381835f, 0.07744014f, -0.21329550f, 0.17885363f, 0.01923109f, 0.04821056f, -0.11848477f, 0.05714495f, 
    1.03172052f, -0.41930145f, 0.13117871f, -0.36029822f, -0.10974016f, 0.14767998f, 0.12112106f, -0.10840515f, 
    0.17260882f, 0.23501018f, -0.08358806f, 0.02848157f, 0.30766934f, -0.05220559f, 0.36173835f, -0.44371673f, 
    -0.08238088f, -0.06742454f, -0.13710283f, -0.30792969f, 0.09768220f, -0.20873199f, -0.11452049f, 0.07105179f, 
    -0.29429710f, 0.05656354f, 0.11188524f, 0.01002248f, 0.06217057f, -0.39537910f, -0.39338431f, 0.11955319f, 
    0.04461440f, -0.02514615f, -0.03545378f, -0.04046934f, 0.06760299f, 0.13245352f, -0.30136850f, 0.99008119f, 
    0.13526072f, 0.14831066f, 0.10400734f, -0.18523726f, 0.02055715f, -0.03471922f, 0.03716974f, -0.04175900f, 
    -0.09842744f, -0.00332078f, -0.26483285f, 0.12594680f, 0.10268465f, 0.17229421f, 0.06731754f, 0.16295092f, 
    0.02979826f, 0.01689354f, -0.18063472f, 0.02047521f, 0.15441602f, -0.13318117f, 0.00526381f, -0.01712530f, 
    0.00227397f, 0.01947010f, 0.03417923f, 0.06658282f, 0.15895839f, 0.08646210f, 0.15046106f, 0.32421696f, 
    0.02879386f, 0.14736933f, -0.33157921f, -0.08703049f, 0.02367711f, -0.04214757f, 0.00927570f, 0.08919291f, 
    0.00566742f, 0.13312808f, 0.00649085f, -0.08247051f, -0.31023523f, -0.11763702f, -0.11535484f, 0.05338195f, 
    -0.10290040f, -0.10963093f, 0.09476905f, 0.04993215f, -0.00534446f, -0.05282187f, 0.11279783f, -0.05572288f, 
    -0.11350602f, -0.22880693f, -0.07643513f, -0.01933419f, -0.08870524f, 0.17407408f, 0.03996067f, -0.02268180f, 
    -0.08175948f, -0.05181880f, 0.05125351f, -0.17132172f, -0.88849109f, -0.81397587f, -0.61361217f, -0.15195730f, 
    -0.27119339f, 0.11398897f, 0.29869038f, 0.41108233f, -0.09270563f, -0.03059805f, -0.09802175f, -0.09992476f, 
    -0.16188343f, 0.84100080f, 0.74079031f, 0.35866013f, -0.19622007f, -0.05397745f, 0.28449097f, -0.07750563f, 
    0.02818346f, -0.05458197f, 0.13447821f, 0.01423342f, -0.25126520f, 0.28167829f, 0.30839399f, -0.29437232f, 
    0.07062107f, -0.04961162f, -0.38368461f, 0.02425045f, 0.16336511f, -0.10508644f, 0.19602169f, 0.11964861f, 
    -0.21692252f, -0.05638608f, 0.39118075f, -0.17464063f, 0.04694895f, -0.07538988f, -0.03991860f, 0.01130558f, 
    -0.11165752f, 0.02354764f, 0.05087345f, -0.04610473f, 0.19286406f, 0.17911154f, 0.10679600f, 0.54026526f, 
    -0.06835669f, 0.10795248f, 0.06204170f, 0.00082323f, -0.01871166f, 0.10518451f, -0.10268263f, -0.08313902f, 
    -0.93626136f, -0.84277320f, 0.15642545f, -0.19694138f, -0.05578062f, -0.22850461f, -0.03258251f, -0.24126600f, 
    0.02344832f, -0.03425573f, 0.01358523f, 0.08691277f, -0.59480458f, -0.59552240f, 0.40294471f, -0.00355195f, 
    -0.05198934f, -0.28382993f, 0.01467941f, -0.01854123f, 0.03295515f, -0.00684624f, -0.05057365f, -0.02704564f, 
    -0.47708878f, 0.50641006f, -0.00853175f, -0.89819336f, -0.09686022f, -0.04386432f, -0.14988875f, 0.01118298f, 
    0.12090313f, 0.00344588f, -0.21045776f, 0.07243022f, -0.12255999f, 0.00048257f, 0.38946763f, -0.42495021f, 
    0.10501673f, 0.02431456f, -0.08351059f, 0.12910379f, 0.11059630f, -0.15146087f, 0.01278149f, 0.02230138f, 
    -0.11293134f, -0.46301293f, 0.49574879f, 0.58895606f, 0.16529329f, 0.00688148f, -0.15857787f, 0.01317565f, 
    -0.00067359f, -0.22450548f, 0.20639193f, 0.22690205f, 0.65255737f, -0.24937816f, 0.01397883f, 0.32687634f, 
    -0.19932233f, -0.08117476f, -0.07750050f, -0.04437441f, -0.04919940f, -0.02420416f, -0.20118180f, 0.29306087f, 
    -0.30727002f, 0.13494110f, -0.07405217f, -0.99964815f, 0.18979970f, -0.03757124f, -0.21353391f, 0.01336922f, 
    -0.21410367f, 0.16075452f, -0.17484623f, -0.41218045f, -0.11120537f, 0.17647187f, -0.26132810f, -0.50265783f, 
    0.24230672f, -0.11729103f, 0.10650086f, -0.13200097f, -0.27847701f, -0.06830942f, -0.07771976f, 0.00007493f, 
    0.38399613f, 0.65938717f, 0.47601017f, -0.31846294f, -0.34895563f, 0.14892542f, 0.03543777f, 0.17517681f, 
    0.02020040f, 0.10274241f, -0.06969406f, 0.06286050f, -0.21813075f, -0.79306555f, -0.07414978f, -0.09048332f, 
    -0.13573579f, -0.28879970f, -0.19321287f, -0.24692170f, 0.10810558f, 0.15951082f, -0.04032620f, -0.06593252f, 
    0.45378414f, -0.19762309f, -0.14658941f, 0.43795887f, 0.07086264f, -0.33258024f, -0.28887671f, -0.08761936f, 
    0.15621668f, 0.17749836f, -0.02881790f, -0.06615969f, -0.07470972f, -0.17164922f, -0.15106334f, 0.19868483f, 
    0.11163727f, 0.17966175f, 0.06583162f, 0.07410152f, -0.08138277f, -0.03810822f, -0.14714254f, -0.12280072f, 
    0.17742330f, -0.35280791f, 0.12559327f, 0.31243953f, 0.39499986f, 0.00357751f, 0.20406036f, -0.13026485f, 
    0.02332179f, 0.00327891f, 0.13213636f, 0.10978802f, -0.42555597f, -0.21246079f, 0.44072190f, -0.25550219f, 
    -0.15513659f, 0.06393455f, -0.29739219f, -0.17531855f, -0.12136267f, 0.05213174f, 0.00446832f, -0.25790933f, 
    -0.16577913f, -0.03626998f, 0.06171319f, -0.15780182f, 0.05738717f, 0.06083109f, -0.11564162f, -0.21618736f, 
    -0.21110423f, 0.07469583f, -0.07625104f, 0.02974796f, 1.07746911f, -0.01179831f, -0.42900622f, -0.03970974f, 
    0.07029685f, -0.03401826f, 0.27078572f, -0.14539458f, -0.08236378f, -0.00487942f, -0.03764983f, -0.06106257f, 
    0.27155265f, -0.18547468f, 0.25244543f, -0.22704069f, -0.18240924f, 0.12603706f, -0.11291863f, 0.00700006f, 
    -0.10449438f, -0.11097936f, 0.15925957f, 0.00654054f, -0.06977364f, -0.27321973f, -0.04092012f, 0.35918385f, 
    0.24381877f, -0.05101393f, 0.07870641f, 0.09024572f, -0.16068712f, 0.12250993f, 0.04082272f, 0.17396073f, 
    -0.58002275f, -0.04786015f, -0.01843600f, 0.72220963f, 0.22427234f, -0.22410926f, -0.19998111f, -0.14824958f, 
    -0.14542580f, -0.22705349f, 0.33536673f, -0.15385593f, -0.24444187f, -0.33455902f, 0.68406671f, -0.11135320f, 
    -0.49944934f, 0.12695953f, -0.35923785f, 0.05242278f, 0.07041960f, 0.18179713f, -0.12390231f, -0.15040959f, 
    0.13644497f, 0.14905886f, -0.00829015f, 0.08660274f, -0.05662323f, 0.24178052f, 0.08842590f, 0.28785941f, 
    0.15861881f, -0.05561561f, -0.11807006f, -0.19497603f, -0.26043248f, -0.11561968f, 0.01100731f, -0.00259855f, 
    -0.11236396f, -0.22485337f, 0.05924876f, -0.24020870f, 0.07150803f, -0.01389270f, 0.03626134f, -0.08911347f, 
    0.22667567f, 0.01422024f, -0.11602709f, -0.24679130f, -0.15987211f, 0.04064046f, -0.05200504f, -0.11891370f, 
    -0.25305599f, -0.29571149f, -0.14020224f, -0.06035851f, -0.05264506f, -0.04704761f, -0.03275313f, 0.02823400f, 
    0.04097957f, -0.01465581f, 0.10268106f, -0.02503882f, 0.07639894f, 0.09061935f, -0.06008007f, -0.12169322f, 
    0.29835337f, -0.46389163f, -0.14505856f, 0.07414109f, 0.08643477f, -0.02846952f, -0.02274160f, -0.15759261f, 
    0.13817225f, -0.08091656f, -0.18110129f, 0.41541326f, -0.04468185f, 0.00004162f, -0.11708608f, -0.03880331f, 
    0.20820858f, 0.13023029f, 0.13841355f, 0.10400344f, 0.13691729f, 0.00343165f, 0.02817901f, 0.06418435f, 
    0.06080165f, -0.02240952f, 0.13234222f, 0.02707142f, -0.14748974f, 0.03813850f, -0.07567208f, 0.17597859f, 
    -0.21382090f, -0.30109590f, -0.18899032f, -0.39580527f, 0.09237771f, 0.21754403f, 0.28671026f, 0.32497504f, 
    -0.20077044f, -0.06689999f, -0.05902577f, 0.03323137f, 0.04836820f, 0.02476127f, -0.02684817f, -0.02666916f, 
    0.07587241f, 0.37365490f, 0.19371508f, 0.28056487f, -0.18601115f, -0.20890120f, 0.12754482f, 0.10690628f, 
    -0.01688625f, 0.02519927f, -0.11527658f, 0.12343942f, 0.13088296f, -0.01987248f, -0.37972891f, 0.03352336f, 
    0.16706163f, -0.09803170f, 0.16425358f, -0.29612768f, 0.04415912f, -0.16841917f, -0.12579301f, -0.02744197f, 
    0.21145725f, 0.32539973f, -0.07949247f, 0.27342364f, -0.04540889f, -0.18423098f, 0.05090420f, -0.05710180f, 
    -0.06034958f, -0.04155985f, -0.03326494f, -0.00056849f, -0.68097740f, -0.16374156f, 0.00183178f, -0.15839896f, 
    -0.26192906f, 0.11251739f, -0.30525061f, 0.23998532f, -0.13781992f, 0.06188107f, -0.43434513f, -0.04590018f, 
    -0.15464655f, 0.24198742f, -0.06702751f, 0.71768785f, -0.02391399f, 0.35530734f, -0.17301410f, 0.19669953f, 
    -0.00181548f, -0.00840347f, -0.12382828f, -0.07055924f, 0.04955113f, -0.11048206f, 0.03497703f, 0.21731110f, 
    -0.04259951f, -0.16898628f, 0.07888444f, 0.04120776f, -0.00726095f, 0.03077981f, 0.08588061f, 0.10298394f, 
    -0.66914815f, 0.16142091f, -0.52416044f, 0.06047160f, 0.08119000f, -0.18808883f, -0.28391370f, -0.14791185f, 
    -0.20494902f, 0.12542099f, -0.07103479f, -0.07377231f, 0.56237566f, 0.07572629f, -0.64667565f, 0.49539778f, 
    0.01584034f, -0.03797719f, 0.02471273f, 0.26345930f, 0.11762010f, -0.01500062f, 0.00237856f, -0.05591349f, 
    -0.19684504f, -0.05209005f, -0.23626904f, -0.13789342f, 0.09776152f, -0.12924007f, 0.53426403f, 0.24186803f, 
    0.01124592f, -0.02233896f, -0.07920621f, 0.07424088f, -0.25467929f, -0.06626931f, 0.06691654f, -0.23092054f, 
    0.47771710f, -0.08160920f, 0.15166320f, 0.22301804f, -0.06069744f, -0.03987676f, 0.12283862f, 0.02728587f, 
    -0.18499847f, -0.70711374f, 0.43521771f, 0.52895939f, -0.05233660f, -0.08622355f, -0.02526270f, 0.04876506f, 
    0.29634729f, -0.18344559f, 0.25795975f, 0.00725650f, -0.04719113f, 0.00192460f, -0.19228777f, -0.04309886f, 
    0.15830025f, 0.08027212f, -0.09533612f, 0.06765099f, -0.05054921f, -0.45149976f, 0.22295500f, -0.25635907f, 
    -0.53347194f, -0.47879663f, -0.03569622f, 0.11487060f, 0.01576174f, 0.04653386f, 0.01294750f, -0.03362178f, 
    0.07461502f, -0.35746756f, -0.18860359f, -0.49888110f, -0.21789971f, -0.10255866f, -0.19798860f, -0.00926371f, 
    0.02745320f, 0.04300907f, -0.13896364f, 0.02368873f, -0.08870883f, -0.18901555f, 0.15017441f, -0.16957039f, 
    0.07858229f, 0.06437634f, -0.03312250f, 0.02654841f, -0.29870918f, 0.16810834f, -0.16209781f, -0.06608620f, 
    0.19016880f, -0.11458196f, 0.13398729f, 0.36994258f, 0.20227757f, 0.14004508f, 0.48197234f, 0.04793981f, 
    0.37345982f, 0.20977181f, 0.05004026f, -0.03073444f, 0.10634886f, -0.00653971f, 0.10551308f, 0.22678606f, 
    -0.39548746f, -0.08867678f, -0.42711779f, -0.50242662f, -0.09082408f, -0.00159824f, -0.28171501f, -0.01616631f, 
    0.03322477f, -0.13874410f, -0.02582930f, -0.30980095f, 0.05234645f, -0.20767398f, -0.38642728f, 0.04613347f, 
    -0.07627237f, -0.03968359f, -0.00922451f, 0.04841140f, -0.00697314f, 0.21892309f, -0.07606140f, -0.17217204f, 
    -0.09719637f, 0.03463801f, 0.32581073f, 0.08031665f, 0.02806356f, -0.00255897f, 0.06339708f, 0.03299937f, 
    0.15183866f, 0.26989326f, -0.36341798f, 0.10069174f, -0.55752325f, -0.16967806f, -0.18403225f, -0.11372777f, 
    0.18741345f, -0.23388937f, -0.02733812f, 0.00633175f, 0.26475874f, 0.10970324f, 0.03087213f, -0.05404481f, 
    -0.00158694f, 0.18090136f, 0.32837856f, 0.05603249f, -0.00989502f, 0.02124851f, -0.01205755f, -0.15096681f, 
    -0.03201573f, 0.07786731f, 0.02334697f, 0.00411233f, -0.44071043f, 0.58644998f, 0.16960642f, -0.49391243f, 
    -0.07092787f, -0.03186497f, 0.11654061f, -0.14648025f, -0.01963394f, -0.10596717f, 0.04120929f, -0.05658177f, 
    -0.14171939f, 0.08006160f, -0.75329405f, -0.22739658f, 0.12257905f, 0.15422548f, -0.10614717f, 0.17151472f, 
    0.39112148f, -0.06116141f, -0.07032318f, 0.11052004f, -0.06340910f, -0.06538416f, -0.39863244f, 0.74502534f, 
    0.25796634f, -0.09497044f, -0.17381035f, -0.00902519f, -0.11936500f, 0.09890074f, -0.01831324f, 0.09033876f, 
    0.01364067f, -0.42398956f, -0.14104117f, 0.14661425f, 0.10235879f, -0.01969111f, 0.25303116f, -0.46012372f, 
    -0.03563415f, -0.29996133f, -0.11505891f, -0.01673277f, -1.20804536f, -0.95531499f, -0.28129131f, 0.10120100f, 
    0.32924098f, 0.02801763f, 0.28932601f, -0.33710316f, 0.04568233f, 0.04097760f, -0.07983776f, 0.04526246f, 
    -0.18053676f, -0.05004595f, 0.03875589f, 0.47202310f, -0.01104364f, -0.25147426f, 0.01041530f, 0.11985967f, 
    -0.04232066f, 0.01280756f, 0.11371312f, 0.03177984f, -0.07429715f, 0.15169907f, 0.08815426f, -0.12146701f, 
    0.01125476f, -0.00364717f, 0.01821707f, 0.01420198f, 0.10809597f, 0.22463436f, 0.20066050f, 0.28105724f, 
    -0.19157930f, 0.00506053f, 0.13801838f, -0.05702141f, 0.02021470f, 0.11068356f, 0.06503049f, 0.10919698f, 
    0.07101668f, -0.26070306f, 0.14168426f, 0.13704766f, -0.21686774f, -0.11573288f, -0.11314256f, -0.14591913f, 
    0.14346366f, 0.19557641f, -0.07607298f, 0.05273816f, -0.11534981f, -0.03205948f, -0.28805989f, -0.21310705f, 
    -0.25836757f, -0.21088965f, -0.09889311f, -0.12131025f, -0.26438814f, -0.57426959f, 0.01119533f, 0.18444215f, 
    0.00600972f, 0.12620680f, -0.19395369f, -0.08110809f, -0.96734971f, -1.20156169f, -0.64184219f, 0.31489730f, 
    -0.18387829f, -0.69835073f, -0.35903406f, -0.66119361f, -0.07001294f, -0.01047452f, -0.02004729f, -0.06707425f, 
    -1.03030777f, 0.55281323f, 0.59001821f, 0.22641401f, -0.26301113f, 0.00665204f, -0.04620976f, 0.02861142f, 
    -0.04991639f, 0.13664651f, 0.03057562f, 0.17931709f, 0.37742108f, -0.02148091f, 0.07031582f, -0.46890521f, 
    0.07142875f, 0.22263685f, 0.34747088f, 0.00240180f, 0.20836915f, 0.14321779f, -0.00193284f, 0.04826178f, 
    -0.33920047f, -0.10613712f, 0.19067094f, -0.32331735f, 0.03787854f, -0.08428041f, -0.08830312f, 0.31054035f, 
    -0.06770573f, 0.15777512f, 0.40877485f, 0.10530457f, 0.04465650f, 0.14420280f, 0.21487963f, 0.28621230f, 
    -0.12617430f, -0.03423845f, -0.02134738f, 0.19686204f, 0.16767910f, 0.12069809f, 0.29358450f, 0.15727440f, 
    0.29157817f, -1.16753280f, -1.74998152f, -0.71921122f, -0.16255619f, 0.15151797f, 0.19662064f, -0.14188902f, 
    0.01081216f, 0.02024499f, -0.05473363f, -0.23420446f, -1.33023846f, -1.46332800f, 0.04566738f, 0.38234794f, 
    -0.08041380f, -0.09807980f, -0.18470873f, -0.40643248f, -0.16484319f, 0.02514384f, 0.00137469f, -0.05191742f, 
    0.94679028f, 0.03655347f, 0.41156811f, -0.34256640f, 0.01278880f, -0.26506647f, 0.38102019f, -0.07802603f, 
    0.07056500f, -0.00245970f, 0.25293431f, -0.13671817f, 0.14913897f, 0.03699564f, -0.47285849f, -0.54619890f, 
    0.00143281f, 0.11560564f, 0.26898798f, -0.09432612f, -0.01594115f, 0.22830397f, 0.01487876f, 0.11445283f, 
    -0.13158810f, 0.18663594f, 0.07732506f, -0.08821411f, -0.22241639f, -0.30294085f, 0.05475697f, 0.03899583f, 
    0.05949007f, 0.02650356f, 0.06232353f, 0.03401053f, -0.38369411f, -0.10530891f, -0.51591235f, -0.16403164f, 
    -0.02386252f, 0.36663002f, -0.15556195f, 0.03490092f, 0.11548191f, 0.00712383f, -0.09739803f, -0.02688558f, 
    0.45446303f, -0.20352440f, -0.19871897f, -0.66637236f, 0.06767526f, 0.03812985f, 0.01419704f, -0.06984288f, 
    -0.32133904f, 0.01362450f, -0.22745699f, -0.23176733f, 0.17733173f, 0.18869002f, -0.12950017f, -0.09633310f, 
    0.07279393f, -0.00025688f, 0.03542588f, -0.02697357f, 0.13515839f, 0.10639320f, -0.03968951f, -0.18174626f, 
    0.16063362f, 0.00791357f, -0.09974500f, 0.04944219f, -0.05424683f, -0.09230459f, -0.08351392f, -0.11868934f, 
    -0.04732162f, 0.15772240f, 0.16503537f, 0.03463390f, 0.06347810f, 0.06208653f, 0.02432742f, -0.11872972f, 
    0.00444015f, -0.06993262f, -0.04498458f, -0.00689995f, 0.09716304f, -0.01215169f, 0.00898936f, 0.01895327f, 
    0.23238939f, 0.00615790f, -0.04894442f, 0.14137852f, -0.20499232f, 0.14706215f, 0.21560217f, -0.02858446f, 
    0.06674732f, -0.10181679f, 0.10819542f, 0.01902214f, -0.26185870f, -0.95981610f, 0.30180684f, 0.48745078f, 
    0.19944592f, -0.18123101f, -0.13081221f, 0.15751654f, 0.00580448f, 0.00285981f, -0.01185828f, -0.10562257f, 
    0.73996133f, -1.29157388f, -0.96808916f, -0.98138225f, -0.17447014f, -0.22119938f, 0.04064016f, 0.27957562f, 
    0.09028970f, 0.00074706f, 0.05328263f, 0.18872172f, -0.09457771f, 0.25038245f, -0.07748755f, -0.02581217f, 
    -0.02142878f, 0.03402229f, 0.01066131f, -0.07517424f, 0.06603045f, 0.08882320f, 0.17273761f, 0.08083236f, 
    0.75847048f, -0.95724815f, 0.50304711f, 0.04174172f, -0.15234505f, 0.02645689f, -0.15924950f, -0.01288684f, 
    0.01088435f, 0.07464848f, 0.06282166f, -0.07312167f, 0.64822400f, -0.02631886f, -0.58745080f, -0.28810796f, 
    -0.01108859f, -0.27190328f, -0.08092515f, -0.16103430f, -0.17416595f, -0.11479453f, -0.32985994f, 0.10953004f, 
    -1.39626122f, -0.41936952f, 0.08095558f, 0.57788575f, -0.47298643f, 0.15005888f, 0.04193349f, -0.17920093f, 
    -0.07757961f, -0.04459339f, -0.07776740f, -0.03761649f, -0.12742336f, -1.01586676f, 0.15342841f, -0.35616058f, 
    0.20324419f, -0.16561724f, 0.12044106f, 0.32948413f, -0.04630419f, -0.09679745f, 0.09028133f, -0.05731641f, 
    -0.31556964f, 0.58901483f, -0.49698913f, 0.46437740f, -0.03989388f, 0.06292089f, -0.00412056f, 0.03143465f, 
    -0.23962933f, 0.05615479f, -0.12245446f, -0.11357789f, -0.11196333f, 0.19828156f, -0.02191826f, -0.06226206f, 
    -0.05354200f, 0.05026358f, -0.18107769f, -0.02651437f, -0.07943104f, 0.21751678f, 0.04723313f, 0.08923132f, 
    -0.23468363f, 0.01840896f, 0.11010359f, -0.01539078f, -0.02592556f, -0.13056043f, -0.02398549f, -0.01025939f, 
    0.05531340f, 0.20179309f, 0.05011664f, 0.20147455f, -0.12890539f, -0.38829452f, -0.51348525f, 0.44009143f, 
    0.24574506f, 0.10802589f, 0.28651050f, 0.24881132f, -0.17154036f, -0.01247178f, -0.10425133f, -0.03283061f, 
    0.29754329f, -0.06944329f, -0.29499283f, -0.23092259f, 0.05148596f, -0.21010119f, 0.19448632f, -0.13504069f, 
    0.27350655f, 0.07568594f, 0.23057805f, 0.16205005f, -0.14132112f, -0.40258738f, -0.17271161f, -0.11336818f, 
    -0.24367431f, 0.04506658f, -0.04043538f, -0.00017237f, 0.14063901f, -0.14812030f, -0.12170637f, -0.13071023f, 
    -0.01605757f, 0.09715250f, 0.13198471f, -0.13944352f, -0.07178494f, -0.10352464f, -0.15539688f, -0.15297586f, 
    -0.34054619f, -0.12986721f, 0.00590371f, -0.05406924f, -0.20854002f, 0.15211350f, 0.04560137f, -0.11539896f, 
    -0.10797343f, -0.09720918f, -0.05070668f, -0.14538451f, -0.10755139f, 0.08039826f, -0.09874737f, 0.17690895f, 
    -0.12738897f, -0.01460599f, -0.03002913f, 0.05128519f, 0.16408905f, -0.18681441f, 0.04048948f, -0.10638249f, 
    0.24234486f, 0.22875522f, 0.17950667f, 0.44383523f, 0.13597994f, -0.50015277f, -0.44527674f, 0.09602558f, 
    -0.15933223f, 0.04117665f, -0.03933169f, 0.02247171f, -0.10907217f, 0.03432483f, 0.00503444f, 0.10752189f, 
    -0.44452277f, -0.81905288f, -0.68536013f, 0.18494461f, 0.00991664f, 0.14565410f, 0.17294872f, -0.04406352f, 
    -0.24724051f, -0.05488006f, -0.19263220f, 0.08069600f, -0.75066209f, 0.23080648f, 0.12566890f, 0.23251165f, 
    0.11761490f, 0.05836928f, -0.21862859f, 0.21547000f, -0.40544951f, -0.02644545f, -0.18506145f, -0.07933520f, 
    0.36586857f, -0.25739434f, -0.15001990f, -0.59624231f, 0.07913078f, 0.10841696f, 0.32021075f, 0.17457411f, 
    0.23861511f, -0.14877035f, 0.23826873f, -0.53133035f, 0.45077342f, -0.87103075f, -0.01244695f, -0.09593612f, 
    -0.19959767f, 0.06052189f, 0.18024585f, -0.05786105f, 0.09643308f, 0.02678722f, 0.19123387f, -0.30015388f, 
    0.17768434f, 0.14699514f, 0.29484940f, -0.05955990f, 0.29517290f, -0.45815983f, -0.00810627f, -0.06324399f, 
    -0.10805090f, 0.04649253f, 0.33138594f, -0.05535947f, 0.73190683f, -0.50395584f, -1.26461065f, -0.33882585f, 
    -0.32944652f, 0.05131752f, 0.26863149f, -0.30990800f, -0.03580745f, -0.00424590f, 0.01495263f, -0.00605143f, 
    -1.49686611f, -0.08371440f, 0.46373719f, 0.17738210f, -0.07142181f, 0.16592647f, -0.00125049f, 0.12444684f, 
    0.02192169f, 0.02309910f, 0.15734650f, 0.15682513f, -0.63675320f, 0.20560168f, 0.26143473f, 0.26338300f, 
    -0.04627783f, 0.12143657f, -0.05420225f, 0.00710607f, -0.08185758f, -0.07651442f, -0.02468741f, -0.13017966f, 
    0.31171003f, -0.02384571f, -0.13244860f, -0.25514227f, 0.19890419f, 0.19197002f, -0.03081195f, 0.02061008f, 
    -0.00803873f, -0.18572648f, -0.32424250f, -0.09122914f, -0.53147894f, 0.41306093f, -0.36630318f, -0.29068276f, 
    -0.61811942f, 0.02890228f, 0.10270875f, 0.00297760f, 0.18106988f, -0.05845086f, -0.10115737f, -0.05897438f, 
    0.12783894f, -0.02133455f, 0.72096336f, 0.40623134f, 0.20296280f, -0.09844169f, -0.38460657f, -0.11496226f, 
    -0.01105426f, 0.05279702f, -0.09927979f, 0.26503602f, -0.13500971f, 0.01555516f, 0.27487263f, 0.32508934f, 
    -0.06238252f, -0.09784845f, -0.15590020f, -0.02365765f, 0.16502318f, 0.28387079f, -0.07654250f, -0.08569152f, 
    -0.06884954f, -0.01399928f, -0.02038001f, 0.15866756f, 0.13507150f, 0.06022190f, 0.11456259f, 0.11449460f, 
    -0.00677683f, -0.20637028f, 0.23534979f, 0.43609247f, -0.01463715f, -0.53861785f, -0.17741552f, -0.06492282f, 
    0.13323984f, 0.31259790f, 0.25348544f, 0.02883288f, 0.05632029f, -0.11889647f, 0.08487095f, -0.08247070f, 
    0.20389399f, -0.00018078f, 0.02621088f, 0.03063051f, 0.17870821f, -0.35358050f, 0.18682230f, -0.08884174f, 
    -0.03883702f, -0.06029537f, -0.58131808f, -0.13643281f, -0.42002618f, -0.34668997f, 0.22969589f, -0.25699154f, 
    0.00570185f, -0.22259650f, 0.04048324f, 0.26322967f, -0.03914095f, 0.06005893f, 0.06066171f, -0.02306807f, 
    0.34859571f, -0.36848393f, 0.30542308f, 0.19594665f, -0.00543372f, -0.31309274f, -0.38751638f, -0.07939941f, 
    -0.00649108f, -0.01571927f, 0.15871494f, 0.16771129f, -0.02794882f, 0.59133226f, -0.58409590f, -0.03193127f, 
    -0.01006691f, -0.07284340f, 0.40004921f, -0.08042545f, 0.08166599f, -0.08491916f, -0.31721324f, 0.10308526f, 
    0.15242709f, -0.72971815f, 0.23621516f, 0.19088684f, -0.11600914f, 0.14504787f, -0.07293255f, -0.12887649f, 
    -0.21110532f, 0.20922489f, 0.14014189f, 0.04182422f, -0.12716813f, 0.22774206f, 0.47772208f, 0.26955000f, 
    0.11076012f, -0.37899238f, -0.13557839f, -0.32824785f, -0.09951236f, -0.25758231f, 0.01704517f, 0.11299883f, 
    -0.10597731f, 0.74263924f, -1.50566614f, 0.11645905f, 0.05348596f, -0.20159808f, 0.10481460f, -0.16510706f, 
    0.09429865f, -0.14196680f, -0.08127049f, 0.05907171f, -0.30877671f, 0.30835646f, 0.05591553f, -0.33993536f, 
    -0.22357076f, 0.23592812f, -0.11467329f, 0.09257245f, 0.23105462f, 0.12133260f, 0.12690781f, -0.01041073f, 
    -0.27503729f, 0.19790483f, 0.02495875f, -0.98812866f, -0.04149121f, -0.19025965f, 0.06856267f, 0.09424390f, 
    -0.11273951f, 0.13197707f, -0.07687841f, -0.19653955f, -0.60039318f, 0.20642267f, -0.93157971f, 0.24208555f, 
    0.14335960f, 0.07478589f, 0.48844573f, -0.04213849f, -0.26219007f, -0.21605478f, -0.01172737f, 0.04333942f, 
    -0.27332890f, -0.44330034f, 0.17673403f, -0.11691046f, -0.09729507f, 0.02223850f, 0.03688211f, -0.19136666f, 
    -0.01759148f, -0.00809938f, 0.17456873f, 0.07810740f, 0.35605744f, -0.52269447f, 0.90107918f, 0.09344396f, 
    -0.23040564f, -0.07004713f, 0.01278161f, 0.28993288f, -0.10706606f, 0.11253906f, 0.07092490f, -0.12728038f, 
    -0.71707129f, 0.44883832f, 0.37965545f, 0.13331415f, -0.17073236f, 0.08412219f, -0.16783750f, 0.08795386f, 
    0.09373213f, -0.15962438f, 0.35946676f, 0.07330678f, 0.07500040f, -0.12339721f, 0.34733140f, -0.36993051f, 
    0.01002957f, -0.03745422f, -0.45839053f, 0.11257331f, 0.16887224f, -0.13124719f, -0.42712045f, -0.02727544f, 
    0.34835127f, -0.09520288f, -0.09793227f, -0.20709181f, -0.43013087f, -0.12460589f, 0.17844979f, -0.30921456f, 
    0.28325570f, -0.31360492f, -0.33264765f, -0.13183379f, -0.43788403f, -0.48893911f, -0.48210120f, -0.65428066f, 
    -0.31695893f, -0.07342433f, -0.06162426f, -0.00954651f, -0.06207475f, -0.11965611f, -0.00101720f, -0.05599160f, 
    0.31130958f, 0.38914812f, 0.07739200f, 0.21392606f, -0.20525363f, 0.04428734f, 0.30025181f, -0.04744210f, 
    0.30367479f, 0.16922171f, 0.42822716f, 0.55063081f, -0.53644371f, -0.27602988f, -0.09603019f, 0.18789764f, 
    -0.02209918f, 0.21524930f, 0.14681020f, 0.15992334f, -0.23212758f, -0.00521570f, 0.17978077f, 0.15255076f, 
    -0.04196159f, 0.06253551f, -0.25638434f, 0.33361784f, 0.07939916f, -0.16603310f, -0.08767420f, 0.14277567f, 
    -0.07128243f, 0.29158014f, -0.01553970f, -0.39467043f, 0.27795848f, 0.19248056f, -0.09997599f, 0.87943536f, 
    0.07755036f, -0.58831686f, 0.02607918f, 0.15268625f, -0.09118671f, 0.04087518f, -0.28932396f, -0.19065303f, 
    -0.60802561f, 0.41307923f, -0.79491597f, 0.23557132f, 0.20628206f, 0.08218342f, 0.08967411f, 0.12464155f, 
    -0.02346215f, -0.03403959f, -0.63305247f, -0.29316896f, 0.13911937f, 0.29822052f, 0.59996670f, -0.48565727f, 
    -0.08825847f, 0.10843568f, -0.05934007f, 0.15335332f, 0.05616948f, 0.07228148f, -0.01622528f, -0.32245225f, 
    -0.46757314f, 0.19085228f, -0.73164541f, 0.07400338f, -0.20480190f, -0.08587177f, 0.36548486f, -0.21259981f, 
    -0.20551290f, 0.20722312f, -0.37269363f, 0.10798953f, 0.21767326f, -1.04305816f, -0.18458875f, -0.03659248f, 
    -0.08920228f, 0.04569882f, -0.25861117f, 0.23358515f, -0.13117093f, 0.06269901f, 0.05022699f, -0.33395490f, 
    0.43562424f, -0.61131918f, 0.54494810f, -0.12838392f, -0.30147600f, 0.13140249f, -0.08642186f, -0.06586677f, 
    -0.01458359f, -0.05421621f, -0.05635715f, -0.09877656f, 0.11881950f, -0.59422922f, -0.12269271f, -0.11890787f, 
    -0.11235094f, 0.09620699f, 0.21249014f, -0.30088124f, 0.08472733f, 0.08051717f, 0.06837604f, -0.01921741f, 
    0.27894902f, 0.30745429f, 0.09933195f, -0.10080709f, -0.12743799f, 0.06549678f, -0.17042878f, -0.20321476f, 
    0.08121651f, -0.18397123f, 0.04454082f, 0.01410781f, -0.02527429f, 0.16071971f, 0.43098268f, -0.57944471f, 
    -0.00581640f, -0.12860699f, 0.39242056f, -0.07820661f, 0.15531857f, 0.06607097f, 0.03558576f, -0.06404354f, 
    -0.43597192f, -0.22487211f, -0.49606258f, 0.37539017f, 0.26138866f, -0.04021661f, 0.03777405f, 0.03254411f, 
    0.21044171f, -0.21841860f, 0.31034717f, -0.12167433f, -0.33477360f, 0.24897932f, -0.33483231f, -0.06898706f, 
    -0.00737133f, -0.27510852f, -0.01387304f, -0.06805865f, 0.04276050f, 0.37400511f, 0.35715038f, 0.17802845f, 
    0.15814999f, 0.00943024f, 0.09896239f, -0.41136885f, -0.04519322f, 0.07557712f, -0.01682799f, 0.10618132f, 
    0.02809214f, 0.10098477f, -0.10588229f, 0.15188502f, 0.48808119f, 0.36336347f, -0.00001832f, -0.43203726f, 
    -0.19508401f, 0.20700981f, -0.06712027f, 0.27186695f, -0.17998716f, 0.08536009f, -0.08937839f, -0.29808024f, 
    0.13372047f, -0.32997817f, 0.15554646f, -0.17987303f, 0.26229385f, 0.01904682f, -0.58288908f, 0.45538521f, 
    -0.37084600f, -0.03137929f, -0.08181570f, -0.72473204f, -0.39701229f, -0.34281531f, -0.03146928f, 0.07872488f, 
    -0.04049942f, 0.17859453f, -0.28736174f, -0.54423404f, -0.00929560f, -0.07547373f, -0.08542769f, -0.23915850f, 
    -0.17102863f, 0.01927117f, -0.15377976f, -0.09808407f, -0.11512116f, -0.33409017f, 0.05388211f, 0.12020693f, 
    -0.15974388f, 0.05787472f, -0.00463085f, -0.14803271f, -0.01145363f, -0.53992343f, 0.81806952f, 0.12244815f, 
    0.07228097f, 0.08140657f, 0.13326606f, 0.07567720f, 0.00501494f, -0.00889402f, 0.01077200f, -0.03513948f, 
    -0.87102348f, -0.51732123f, -0.62462580f, 0.44342503f, 0.12517534f, -0.04780140f, 0.15343621f, -0.12741134f, 
    0.08785994f, 0.15613818f, 0.25404602f, 0.44953039f, -0.24737251f, -0.31132609f, 0.23006585f, -0.33320969f, 
    0.11940626f, 0.10856768f, 0.07156722f, 0.08943940f, 0.06034309f, 0.00640123f, 0.09868550f, 0.08352761f, 
    0.82595640f, -0.80967104f, 0.64467525f, 0.11448225f, 0.19632941f, -0.20584020f, -0.14421967f, 0.18350011f, 
    -0.20383914f, -0.04469287f, 0.20285229f, 0.07484013f, -0.97209120f, -0.04640583f, -0.37580326f, 0.32680371f, 
    -0.26579434f, 0.29667559f, 0.06039128f, -0.34926361f, 0.09212291f, 0.11599096f, -0.02513340f, -0.03137592f, 
    -0.51281744f, -0.10096996f, 0.17297356f, 0.02840067f, -0.04193187f, 0.13878772f, 0.09184516f, 0.31573427f, 
    -0.38904229f, -0.03267536f, -0.18655752f, 0.32784641f, 0.37311190f, -0.29536292f, 0.62522751f, -0.19378953f, 
    0.02316882f, -0.30453691f, -0.05712345f, 0.04852097f, -0.30987340f, -0.14838770f, -0.05523830f, -0.03579695f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33659947f, 0.21560414f, 0.24137309f, -0.24976484f, -0.14092486f, 0.07971375f, 0.08930038f, -0.30092439f, 
    0.16768041f, 0.07680223f, 0.09932112f, -0.08325139f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
