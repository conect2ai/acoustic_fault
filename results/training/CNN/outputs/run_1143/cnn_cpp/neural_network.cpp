#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.24188137f, -0.27991086f, -0.67037547f, -0.56313789f, -0.30732924f, -0.17505163f, -0.01232095f, -0.02253833f, 
    0.34477243f, -0.93087733f, 0.31707677f, 0.18675946f, -0.11934318f, -0.05546899f, -0.10395079f, -0.41425306f, 
    -0.12169158f, -0.09153653f, 0.11300547f, 0.29201299f, 0.22633050f, -0.04967819f, 0.06777455f, 0.60218436f, 
    -0.08115607f, -0.20385148f, -0.50340426f, -0.08639909f, 0.25558594f, -0.01049311f, -0.64607465f, -0.59466869f, 
    -0.17571911f, -0.33147466f, -0.67268044f, -0.08939476f, 0.67434424f, -0.27131343f, 0.04648387f, -0.12131935f, 
    -0.06009978f, -0.09516405f, 0.15860544f, -0.54609907f, -0.44213176f, -0.16396922f, 0.18733360f, -0.01028742f, 
    0.13083935f, 0.31777287f, -0.75643730f, 0.01185582f, 0.12826318f, 0.17390753f, 0.31599706f, -0.13193247f, 
    -0.15193127f, 0.48471501f, 0.12174460f, -0.09850185f, -0.50602651f, 0.09052180f, -0.12678461f, 0.80640775f, 
    -0.56040716f, -0.29001755f, 0.21782959f, -0.04652171f, 0.24165194f, 0.27900675f, -0.16986129f, -0.15009330f, 
    0.09956387f, 0.01071440f, 0.10831551f, 0.23530461f, 0.50458968f, 0.39540499f, -0.49052882f, -0.51854455f, 
    0.32926300f, 0.04125496f, 0.19788434f, -0.16815518f, 0.08033071f, -0.48319125f, -0.14040424f, 0.65438640f, 
    -0.18216857f, -0.18156029f, 0.26762626f, 0.04256575f, -0.23754972f, -0.32143250f, 0.32889050f, -0.37196136f, 
    0.11683664f, 0.15358907f, 0.23454618f, -0.11631113f, 0.05854511f, -0.92778498f, -0.24369605f, 0.91064668f, 
    0.77630508f, -0.15881924f, -0.34212419f, -0.31890109f, -0.51740164f, -0.07481813f, -0.07891016f, 0.25122893f, 
    0.07732809f, -0.25212461f, -0.16029677f, -0.00257790f, 0.04298400f, 0.12057839f, 0.44038582f, -0.17641383f, 
    0.28937930f, -0.27870595f, -0.21991281f, 0.00724276f, -0.11126027f, -0.09181328f, -0.44535622f, 0.18686379f, 
    -0.05545211f, -0.09118919f, -0.27320373f, 0.07024715f, 0.14721365f, -0.06239472f, -0.07366055f, -0.12466996f, 
    0.33744994f, -0.12034987f, -0.12756130f, -0.11555498f, 0.11698329f, 0.05191058f, -0.25411585f, -0.30374199f, 
    0.08596772f, 0.16181587f, 0.43284932f, 0.04490768f, -0.00926686f, 0.33844343f, 0.91374922f, -0.27766365f, 
    -0.44490701f, -0.22181770f, 0.50740212f, 0.17245378f, -0.20092839f, -0.18241805f, 0.23755494f, -0.42113698f, 
    -0.36625698f, 0.36131039f, 0.05574653f, -0.30404747f, 0.19741802f, 0.04008031f, 0.12347095f, 0.01270699f, 
    -0.31376013f, 0.14618093f, 0.15053660f, 0.14883220f, -0.16034068f, 0.09944347f, -0.09694040f, -0.99850386f, 
    -0.37602392f, -0.30690145f, -0.50255167f, -0.22365707f, -0.01381751f, -0.53732187f, -0.02532607f, 0.41560030f, 
    0.13452376f, -0.37912774f, -0.50390959f, -0.00562295f, -0.21569818f, -0.32945246f, 0.40858287f, -0.12780336f, 
    -0.44711667f, -0.02109544f, -0.05307677f, -0.05077101f, -0.16604264f, 0.12560658f, -0.13620050f, 0.07361722f, 
    0.04931609f, -0.23569342f, -0.17484187f, -0.59050196f, -0.51415551f, -0.28040981f, -0.34922999f, -0.40557313f, 
    0.10476932f, -0.18177620f, 0.04170040f, 0.12685902f, 0.59445590f, 0.58852732f, 0.52039331f, -0.06236627f, 
    0.05681613f, 0.04310979f, -0.12769620f, -0.15684688f, -0.12833416f, 0.18154159f, 0.24648143f, -0.14420328f, 
    -0.25887397f, 0.60020864f, 0.96563995f, 0.25360838f, -0.03524506f, -0.23029242f, -0.72787267f, -0.06976279f, 
    -0.28313449f, -0.13703157f, -0.19689749f, -0.05182359f, 0.12102580f, 0.60531306f, -0.41474569f, -0.05988437f, 
    -0.24691249f, -0.02137486f, 0.03146249f, 0.21168292f, -0.05780007f, -0.10337370f, 0.20532742f, -0.18734689f, 
    -0.08083232f, 0.03023310f, 0.01969575f, -0.13155289f, -0.56399012f, -0.32339817f, -0.98752856f, 0.52784258f, 
    0.23283960f, -0.21474250f, 0.32216835f, 0.48405358f, -0.04359870f, 0.02478040f, -0.05102770f, 0.15512848f, 
    0.07481876f, -0.17374519f, -0.09220682f, -0.18136725f, 0.05536377f, -0.19933906f, -0.23986638f, -0.26590484f, 
    0.06336154f, -0.06004625f, -0.09502391f, 0.39530438f, -0.37862349f, -0.34446311f, -0.02861257f, -0.45993426f, 
    0.59101313f, -0.13239790f, -0.16457696f, 0.40222999f, -0.32156166f, 0.06461980f, 0.46935633f, -0.32558370f, 
    -0.09998281f, -0.20649070f, -0.39393812f, 0.25396004f, 0.39825040f, -0.36053264f, -0.19445595f, 0.02321469f, 
    -0.13685055f, -0.05043371f, 0.31583372f, 0.27794546f, -0.98175019f, -0.66234291f, -0.51140952f, -0.46671361f, 
    -0.29214951f, 0.29205081f, 0.43206504f, 0.27670944f, 0.00409571f, 0.45211363f, 0.21483882f, 0.24091615f, 
    0.11595221f, 0.24733138f, -0.24138559f, -0.13761088f, -0.04744871f, -0.16609675f, 0.19803093f, 0.12248074f, 
    -0.15722151f, 0.17361863f, 0.02640565f, -0.20443223f, -0.17808874f, -0.07224482f, 0.39642879f, 0.02576574f, 
    0.29849204f, 0.43838060f, 0.39850309f, -0.08106059f, -0.18608525f, 0.05796226f, 0.14606449f, 0.42239770f, 
    -0.14299469f, 0.00585935f, -0.30053163f, -0.22721732f, -0.01591725f, 0.15008971f, 0.06350547f, -0.02270233f, 
    -0.11932451f, -0.08292478f, -0.09807371f, 0.16340497f, -0.04434340f, -0.03691242f, -0.79348654f, 0.38166288f, 
    -0.16152076f, -0.15915374f, 0.69537568f, -0.12626354f, -0.44332755f, 0.31137526f, -0.08769997f, 0.47744057f, 
    -0.38179171f, -0.28814006f, 0.10125791f, -0.23790874f, 0.48536384f, 0.50697178f, 0.15949294f, -0.42672861f, 
    -0.20588006f, 0.03574222f, -0.26861462f, 0.09735422f, -0.01886658f, -0.25986165f, -0.27002630f, 0.41039291f, 
    0.50545704f, -0.15301423f, 0.60625237f, -0.14377679f, -0.07441172f, 0.01709654f, -0.26654351f, -0.41378719f, 
    0.39252812f, -0.02469346f, -0.24304844f, -0.10583200f, 0.01328050f, 0.16525619f, -0.02276065f, 0.09798688f, 
    -0.15234442f, -0.01417788f, 0.07333256f, -0.11310355f, 0.04117616f, 0.11791747f, 0.05562166f, -0.08899777f, 
    -0.30982485f, -0.54758149f, -0.37808219f, -0.24091324f, -0.44453186f, -0.36969170f, -0.32317135f, -0.12841173f, 
    0.51936132f, 0.24756123f, -0.16511521f, -0.33768359f, -0.41460180f, 0.14555347f, -0.27614328f, -0.07115506f, 
    0.11870614f, 0.18034777f, 0.09647816f, -0.33309716f, -0.26765946f, -0.29261911f, -0.38417268f, -0.37178871f, 
    -0.26900384f, 0.17958479f, -0.54987246f, -0.48094773f, -0.43511498f, -0.38400918f, 0.07550542f, 0.03495549f, 
    -0.15824750f, -0.05578191f, 0.23051859f, 0.03688027f, -0.09184528f, 0.03695635f, -0.36865985f, 0.12586187f, 
    -0.07177404f, 0.13510655f, 0.19101697f, 0.23904620f, 0.34509161f, 0.01274518f, -0.45330802f, -0.09580357f, 
    -0.35382074f, -0.28382751f, 0.44412979f, 0.02490967f, -0.28388527f, -0.27477291f, 0.13941108f, 0.31115302f, 
    0.12868050f, 0.16641234f, 0.20329148f, 0.40710965f, 0.37469774f, -0.16207398f, 0.04441228f, -0.21103273f, 
    0.31524336f, -0.06387049f, -0.18553457f, 0.01784809f, 0.18261398f, 0.18888007f, -0.13930027f, 0.32825816f, 
    0.10358573f, -0.28349364f, 0.24104401f, 0.07582929f, -0.39410630f, 0.20956756f, 0.48817432f, 0.32179263f, 
    -0.16525988f, -0.23211513f, -0.05252709f, -0.04698137f, 0.12369754f, 0.01569629f, 0.04466192f, 0.32060796f, 
    0.05963481f, -0.16756563f, -0.33414406f, -0.02272270f, 0.23704119f, -0.19141805f, -0.05894212f, -0.29190087f, 
    0.02095325f, 0.22651705f, 0.25028467f, 0.34516215f, -0.29617369f, -0.34999698f, -0.16705370f, 0.19282804f, 
    -0.46893170f, -0.66276884f, -0.57007992f, -0.45845705f, -0.33757564f, -0.00296417f, -0.10043748f, -0.50570107f, 
    -0.37365869f, -0.08732989f, -0.29484361f, -0.44834360f, -0.34397289f, -0.22892866f, -0.12313765f, -0.35226619f, 
    -0.06577838f, -0.36618459f, -0.21983124f, 0.06755475f, 0.20499800f, -0.59606552f, -0.41840240f, -0.09985668f, 
    -0.09437241f, 0.02239858f, 0.70582259f, 0.41940597f, -0.06832200f, 0.28359765f, 0.20571181f, -0.03903697f, 
    -0.02034679f, 0.29935196f, -0.10349379f, -0.12947936f, 0.14818375f, 0.02791057f, 0.17652324f, -0.27076426f, 
    -0.29803857f, -0.19314900f, 0.35165343f, -0.05079849f, -0.08149488f, -0.06830892f, 0.55172509f, 0.30518070f, 
    -0.00778174f, -0.03260741f, -0.42785835f, -0.18706290f, 0.13905081f, 0.24886736f, -0.08749147f, 0.12299993f, 
    0.17600127f, -0.14961544f, -0.04608753f, 0.38092610f, 0.09700625f, -0.07601343f, -0.18292780f, -0.19550379f, 
    -0.17421782f, 0.28602207f, -0.15152203f, 0.00562660f, 0.01601534f, 0.23808740f, 0.27421471f, -0.88393962f, 
    0.06399217f, 0.10210783f, 0.64668697f, 0.09631255f, -0.34187970f, -0.82722110f, -0.27690345f, 0.53404748f, 
    0.38182229f, 0.15858674f, 0.01281491f, -0.16079310f, 0.42933929f, 0.07835212f, -0.30692828f, 0.28999016f, 
    0.25509527f, -0.33629048f, -0.26537913f, 0.09927816f, 0.15279435f, 0.32547015f, -0.12709436f, -0.05854293f, 
    -1.01223946f, -0.30223486f, -0.05266076f, 0.40710783f, 0.13089550f, -0.12512590f, 0.46415290f, -0.03559224f, 
    0.29179135f, 0.28175867f, 0.08573110f, 0.16412762f, -0.32670423f, 0.40582240f, -0.03609543f, 0.02349161f, 
    -0.11859546f, -0.04064878f, -0.13410206f, -0.47621688f, -0.08491369f, 0.24578734f, 0.38668221f, 0.36492321f, 
    -0.21038613f, 0.32462841f, -0.16120942f, 0.54761380f, 0.60729271f, -0.48107556f, -0.35395232f, -0.20062806f, 
    -0.33741876f, 0.13205956f, -0.48659959f, 0.19603632f, -0.35855886f, -0.25111511f, 0.00002875f, 0.28077766f, 
    0.09805924f, 0.57209533f, 0.15775807f, -0.08998942f, -0.19268809f, -0.26232910f, -0.23223555f, -0.37475997f, 
    -0.15369430f, -0.10124636f, -0.22119227f, -0.67092919f, -0.01606899f, 0.33045173f, 0.51746160f, 0.32436547f, 
    0.69003636f, 0.22212352f, -0.73186272f, -0.52777177f, -0.28017142f, -0.01073609f, -0.10455071f, -0.10497576f, 
    -0.08200641f, 0.09352160f, -0.33192754f, 0.00660775f, 0.14324102f, 0.20993778f, -0.14283037f, -0.25398037f, 
    0.14158234f, 0.30016249f, 0.00929396f, -0.66573852f, 0.34874168f, -0.23704459f, 0.07419593f, 0.16526207f, 
    -0.28598583f, 0.42698398f, 0.51963633f, -0.07714391f, -0.02308971f, 0.24674775f, 0.37255803f, 0.20092519f, 
    -0.32278606f, -0.52793097f, -0.09596706f, -0.16199289f, 0.10661784f, -0.35341629f, 0.01143279f, 0.29532644f, 
    -0.03245451f, -0.07014900f, 0.10411239f, 0.21691389f, -0.02116398f, 0.03782983f, -0.44465420f, -0.45318225f, 
    -0.16871671f, -0.21962026f, 0.06061798f, -0.11255722f, 0.13992915f, 0.04709965f, 0.12933244f, 0.31318989f, 
    0.15937427f, -0.12947197f, 0.25724638f, -0.31422627f, 0.15350263f, -0.11113738f, -0.25029847f, -0.18465455f, 
    0.41040179f, -0.03136942f, 0.14197381f, 0.23844890f, 0.26415381f, 0.15056533f, 0.37314051f, -0.17066497f, 
    -0.16870733f, 0.16208164f, -0.31297743f, -0.07434644f, 0.41283619f, -0.25310463f, -0.10242987f, -0.14612293f, 
    -0.10828397f, 0.25856191f, -0.16714582f, 0.23316416f, 0.23274976f, 0.01704176f, 0.05673888f, -0.31280389f, 
    0.27335283f, -0.01447135f, -0.14435692f, 0.24240187f, 0.14922169f, 0.34750059f, -0.54162669f, 0.43927416f, 
    0.70987213f, -0.53574288f, 0.15589193f, -0.27509478f, -0.03901178f, 0.10689636f, -0.16843049f, -0.36419079f, 
    -0.09726328f, -0.19817333f, -0.13236158f, -0.19250213f, -0.10171987f, 0.13537879f, -0.34496918f, 0.36099976f, 
    0.10715819f, 0.22964036f, -0.04126772f, 0.02813517f, -0.19457850f, -0.30662337f, -0.47120705f, 0.31029704f, 
    0.39685267f, 0.18496031f, -0.05540011f, 0.35218650f, 0.12205903f, 0.20226741f, 0.00039687f, 0.10834161f, 
    0.12937349f, -0.25944564f, -0.10858774f, -0.18389529f, -0.00573522f, 0.05605962f, -0.00817918f, 0.09752072f, 
    0.01310477f, -0.08872508f, 0.09314084f, -0.26024884f, -0.20615017f, -0.13316250f, -0.31956011f, -0.63033116f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06900788f, 0.26575342f, 0.08993361f, 0.09706861f, 0.30719310f, 0.20575933f, 0.27234265f, 0.05350614f, 
    0.03337948f, 0.09504454f, 0.25574529f, 0.22262485f, -0.06533286f, -0.01414602f, 0.21815386f, 0.16864280f, 
    0.07121856f, 0.07496584f, -0.08754994f, 0.14722246f, 0.06459925f, 0.35237381f, 0.02990577f, 0.23204343f, 
    -0.02672716f, 0.17195939f, 0.17246176f, 0.21775700f, -0.15853843f, 0.12577367f, 0.02030488f, 0.30856904f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15300095f, 0.07972021f, -0.17193270f, 0.03422374f, 0.07171445f, -0.01407477f, 0.00250525f, 0.13633919f, 
    -0.05190525f, -0.00581791f, 0.18763870f, 0.00503754f, 0.20166034f, 0.02667395f, 0.03084119f, -0.00627171f, 
    0.03306093f, 0.11792254f, 0.06505303f, 0.18975839f, -0.02387671f, 0.01265101f, -0.07971387f, 0.03789219f, 
    0.07253656f, 0.10371076f, -0.07696819f, -0.01428126f, -0.04771345f, -0.03592326f, 0.06211704f, -0.11956422f, 
    0.06774550f, 0.04613714f, 0.02968171f, -0.06952207f, -0.07090499f, -0.15065500f, -0.25564918f, -0.10208907f, 
    -0.01555323f, -0.10394436f, -0.01322319f, -0.02799210f, 0.03468418f, 0.10214075f, 0.10025711f, 0.17318933f, 
    -0.10837884f, 0.35063565f, -0.03938847f, 0.11417310f, -0.08823409f, 0.04831737f, -0.02157816f, 0.11222365f, 
    0.07951988f, 0.00520515f, 0.02497947f, 0.01774184f, 0.01330450f, 0.12741071f, 0.08772548f, -0.02152061f, 
    0.03528260f, 0.06599385f, 0.01594799f, 0.03888716f, 0.01549211f, 0.03442704f, 0.05722215f, 0.03455584f, 
    -0.06071007f, 0.07473215f, 0.03493643f, 0.04811041f, 0.02487575f, -0.04374890f, 0.11164667f, -0.00961200f, 
    -0.07504474f, 0.03898660f, -0.03136906f, 0.04089656f, 0.31457323f, 0.12232785f, 0.05874557f, -0.02746041f, 
    0.09014042f, 0.04567078f, -0.05893506f, 0.03237919f, -0.02211608f, 0.01538063f, 0.00370970f, 0.07731773f, 
    0.20878524f, 0.04090236f, 0.06800406f, 0.01922267f, 0.14978890f, 0.09551029f, 0.16282828f, 0.12000733f, 
    -0.09896132f, 0.04269194f, -0.02930348f, -0.06174771f, -0.40333316f, -0.11897967f, 0.02632626f, 0.07190907f, 
    0.05158829f, -0.07837171f, -0.17399031f, 0.05602135f, -0.04569700f, -0.00756379f, 0.03997052f, 0.06741527f, 
    0.03450542f, -0.11740692f, -0.02168549f, 0.08071382f, 0.04425652f, 0.04480923f, -0.03890368f, -0.10373788f, 
    0.03886685f, 0.04267627f, 0.09748080f, 0.03407420f, 0.02620403f, 0.02028614f, 0.05574794f, -0.07119351f, 
    0.00715622f, 0.11355878f, -0.03281572f, -0.11211352f, -0.05003276f, 0.09738337f, 0.09120337f, 0.13931489f, 
    0.18788187f, 0.02817928f, -0.11628885f, 0.13820444f, 0.21976924f, 0.15462740f, 0.08995850f, 0.05204116f, 
    0.00343165f, -0.07985938f, 0.04612858f, -0.04715138f, -0.30246681f, -0.21060708f, -0.13366386f, 0.04506116f, 
    -0.02413327f, 0.06283367f, 0.07946631f, -0.00546739f, 0.10761972f, 0.05118805f, 0.09829587f, 0.09017570f, 
    -0.13449635f, 0.18500793f, -0.03560603f, -0.17152442f, -0.06864219f, 0.04337556f, 0.03398223f, 0.09176026f, 
    -0.19762054f, -0.00526980f, -0.08113617f, 0.13424517f, -0.36369941f, -0.19153522f, -0.17086275f, -0.05941186f, 
    -0.05670127f, -0.05118010f, 0.00874468f, 0.03200444f, -0.01605544f, 0.00144356f, 0.00105781f, 0.09441072f, 
    0.17451544f, 0.08151764f, 0.07904521f, 0.01674672f, 0.09118541f, -0.09630543f, -0.13476437f, 0.04484204f, 
    -0.10495719f, -0.05769847f, 0.11106034f, -0.00229360f, 0.16878006f, 0.11700675f, -0.03855310f, -0.00130327f, 
    0.09076274f, -0.05592247f, -0.00046789f, 0.00638007f, 0.01572770f, 0.05750385f, 0.06838893f, -0.01352833f, 
    -0.14637806f, -0.02712063f, -0.10767420f, -0.05192012f, 0.02986838f, 0.05355828f, 0.00744126f, -0.00170132f, 
    0.07509205f, 0.10609135f, -0.02240717f, 0.02211924f, -0.08045861f, -0.08643050f, 0.07679977f, -0.08517359f, 
    0.00839567f, -0.00591751f, -0.01290750f, 0.00511599f, 0.01963136f, 0.04290455f, 0.08285339f, 0.06505948f, 
    0.00077680f, 0.06491427f, 0.07386275f, -0.05047714f, 0.07428222f, 0.06485685f, 0.06796230f, -0.03084935f, 
    -0.16024619f, -0.09977232f, -0.09802911f, -0.10651335f, -0.02492578f, 0.09152097f, -0.12805346f, 0.07078872f, 
    0.13470183f, 0.13535680f, 0.10693178f, 0.02297925f, -0.09710138f, -0.03158670f, -0.03113599f, 0.10385685f, 
    -0.32887456f, -0.12710062f, -0.13583878f, -0.04060917f, 0.01136926f, -0.04966135f, -0.06201908f, -0.03982578f, 
    -0.03244725f, 0.04103254f, 0.02238891f, 0.10938212f, 0.20205592f, 0.31134066f, 0.21874829f, -0.21662711f, 
    -0.01540927f, 0.02125800f, 0.05197185f, -0.02809738f, 0.01477370f, -0.03499676f, -0.12120748f, 0.16472141f, 
    -0.13846806f, 0.27225718f, 0.10811884f, -0.05729929f, 0.04603243f, 0.09913359f, 0.08591168f, -0.10872479f, 
    -0.08092570f, -0.06073098f, 0.03668368f, 0.25150844f, -0.16255438f, -0.10075924f, 0.06659851f, -0.01235230f, 
    -0.16476817f, -0.04200405f, 0.07549540f, 0.02868762f, -0.04592646f, 0.20279083f, 0.03103444f, -0.07686938f, 
    0.02140957f, 0.38294679f, -0.22967672f, -0.03141084f, -0.00237185f, 0.08349931f, 0.12722918f, -0.11667151f, 
    -0.05179680f, -0.03579339f, 0.05582635f, 0.10144351f, -0.09139392f, -0.18338688f, -0.00382136f, -0.04021206f, 
    0.03682197f, 0.03375274f, -0.01418006f, 0.05741552f, 0.07825647f, 0.14851166f, 0.02864370f, 0.00259309f, 
    0.13503115f, 0.20461795f, 0.17952663f, 0.08322579f, 0.12981452f, 0.12269344f, 0.14224553f, -0.05464862f, 
    0.01050385f, 0.05423994f, -0.00792522f, 0.04739080f, -0.07666699f, 0.02410505f, 0.07231322f, 0.00501954f, 
    0.01035553f, -0.10370630f, 0.04722999f, -0.14220566f, 0.02591774f, 0.04033996f, 0.00843466f, 0.00738883f, 
    0.06775080f, -0.00027660f, 0.11723737f, -0.05979376f, -0.14474149f, 0.01430455f, 0.01499994f, -0.01233544f, 
    0.01874859f, 0.02665456f, -0.01016814f, -0.10648489f, -0.20417805f, -0.12480779f, -0.08928750f, -0.05163642f, 
    -0.04179926f, -0.02716465f, -0.01601910f, 0.00265929f, 0.07048098f, 0.14364588f, -0.02072814f, 0.05957510f, 
    -0.11766422f, -0.55513006f, -0.70262724f, -0.14808239f, 0.10225360f, 0.02415292f, 0.18473569f, -0.02515596f, 
    -0.03216288f, -0.05448899f, -0.08669800f, 0.00647446f, -0.35244063f, -0.13817665f, -0.01862269f, -0.15944512f, 
    0.02794208f, 0.06666575f, 0.07776328f, 0.08526223f, -0.07395849f, 0.01509656f, -0.09875471f, 0.00878154f, 
    -0.16996677f, 0.15644108f, 0.06144639f, 0.00242741f, 0.00684900f, 0.04684573f, 0.13901162f, 0.05831367f, 
    -0.00415255f, -0.04461484f, 0.12995327f, 0.03379177f, 0.21564049f, 0.00971309f, -0.01449438f, 0.13090084f, 
    -0.07414455f, -0.12978849f, -0.06346384f, 0.01222531f, 0.16220377f, 0.13685280f, 0.00982335f, -0.03478548f, 
    0.31797472f, 0.17833483f, 0.07803449f, 0.28156996f, -0.01382555f, 0.31941709f, 0.04466371f, 0.11242557f, 
    -0.02903462f, 0.01624621f, -0.02967785f, -0.05245098f, -0.02048081f, 0.00673276f, -0.04559313f, -0.04890805f, 
    0.06018486f, 0.09825974f, -0.13657199f, 0.01397927f, 0.01694917f, 0.07141026f, -0.03289331f, 0.13757282f, 
    0.44746098f, 0.29427096f, -0.24224955f, -0.08192819f, 0.23105125f, -0.07292801f, 0.29242375f, 0.02961875f, 
    0.00034998f, -0.10843926f, -0.13191001f, -0.09152450f, -0.11555795f, -0.22366340f, -0.50096196f, -0.14675495f, 
    -0.04139665f, 0.15872125f, 0.05248914f, 0.00042038f, -0.07478290f, -0.00323920f, -0.11153180f, -0.19341283f, 
    0.10621648f, 0.19605270f, -0.20019922f, -0.12106967f, 0.41547903f, 0.07858317f, -0.10953640f, 0.22766429f, 
    -0.07682019f, -0.21602637f, -0.04274265f, -0.10109952f, 0.24567825f, 0.14052151f, -0.10354494f, 0.29919127f, 
    -0.05004635f, -0.07587725f, 0.26797572f, -0.13348363f, 0.01632725f, -0.12842129f, -0.05306593f, 0.00996330f, 
    -0.10998502f, -0.14822696f, -0.25404310f, -0.36821678f, -0.06426095f, -0.05799610f, -0.02317568f, 0.05444968f, 
    0.11133129f, -0.05252701f, 0.21769327f, 0.00471652f, -0.02465921f, -0.20464683f, -0.33717805f, -0.14385718f, 
    0.19662838f, 0.02698786f, 0.18102199f, 0.07014081f, -0.00470538f, 0.05061201f, 0.01927398f, 0.08356082f, 
    -0.21645586f, -0.40849757f, -0.28122005f, -0.44336796f, -0.08779310f, -0.02026274f, 0.05206436f, -0.08717801f, 
    0.10698580f, 0.19782682f, -0.08800629f, -0.00246162f, 0.18594629f, 0.11482587f, 0.13370474f, 0.29573849f, 
    -0.03210209f, -0.04250298f, 0.04838398f, -0.04811182f, 0.05616174f, 0.04326301f, -0.05075616f, 0.03946023f, 
    -0.16628931f, 0.32521582f, 0.07179480f, 0.06822518f, 0.09546752f, 0.10432669f, 0.15469418f, 0.11821926f, 
    -0.27146786f, -0.08653470f, 0.12688753f, 0.18163879f, 0.10784911f, 0.09565042f, 0.12826566f, 0.15769558f, 
    -0.09896149f, -0.06237785f, -0.04378796f, 0.05066216f, -0.00645019f, -0.02677889f, 0.01001014f, 0.04962589f, 
    -0.13520333f, -0.19718800f, -0.31985182f, -0.07149352f, 0.01573022f, 0.13899697f, -0.16099137f, 0.02275897f, 
    -0.01286505f, -0.07829995f, -0.09913616f, -0.05579261f, -0.06475236f, -0.26316351f, -0.10718218f, -0.32682705f, 
    -0.11672130f, -0.04658628f, -0.11999600f, -0.09659033f, -0.02857759f, -0.13937049f, -0.07281026f, -0.07518275f, 
    0.11716692f, 0.06440378f, -0.00076334f, 0.03436037f, 0.05563516f, -0.01859267f, 0.01232828f, 0.01548506f, 
    0.11414479f, 0.10613777f, 0.12207124f, 0.07956014f, -0.02224096f, -0.01834798f, 0.18063928f, 0.14827907f, 
    -0.02530374f, 0.03793115f, -0.02707372f, 0.00426553f, -0.02191212f, 0.03035029f, -0.08507791f, 0.09050620f, 
    -0.32151949f, -0.14764568f, -0.32911855f, 0.05255033f, 0.15806390f, 0.16498542f, 0.08971860f, 0.15138941f, 
    0.06461833f, 0.06680231f, 0.06361113f, -0.02604947f, 0.20606251f, 0.04405482f, 0.08599397f, -0.05208493f, 
    -0.01546721f, 0.05418046f, 0.01884000f, 0.02506535f, 0.02336773f, 0.11015087f, 0.01938256f, 0.16950519f, 
    0.13223529f, 0.13765261f, 0.04992275f, 0.11671805f, -0.04631214f, -0.10377120f, 0.04574224f, 0.01307144f, 
    0.01211475f, 0.01304945f, -0.04583571f, -0.00858706f, -0.06671713f, 0.14406040f, 0.00240119f, -0.25098214f, 
    -0.01017735f, 0.19674298f, -0.09743565f, 0.03980489f, -0.05158247f, -0.12223828f, -0.05729994f, 0.14442126f, 
    0.10353971f, -0.10815302f, 0.15537967f, -0.14501216f, -0.14931236f, 0.05050616f, -0.03458273f, 0.00371900f, 
    0.15468015f, -0.07102180f, 0.04497653f, 0.02333248f, 0.10769450f, 0.00473351f, -0.02363556f, -0.01488414f, 
    -0.03602782f, 0.18055998f, 0.19665764f, 0.06160457f, 0.09251998f, 0.27460170f, -0.16033474f, -0.07536140f, 
    0.16457565f, -0.06723153f, 0.20560469f, 0.17097373f, -0.06614403f, 0.18373731f, -0.03266716f, 0.09582651f, 
    0.04903199f, 0.15005158f, 0.04900299f, -0.09956867f, -0.08850110f, -0.06293202f, 0.02461659f, 0.01134407f, 
    -0.08335838f, -0.01652052f, 0.09735192f, -0.16775608f, 0.22722585f, 0.12998103f, -0.12126990f, 0.16378656f, 
    -0.15101098f, -0.07448915f, -0.19026081f, -0.13280174f, 0.15583220f, 0.03821320f, 0.06060308f, -0.03266316f, 
    0.06054388f, -0.05539946f, -0.12769356f, -0.07531931f, -0.08041368f, 0.01951986f, 0.02405346f, 0.06335578f, 
    -0.06100183f, -0.10771852f, 0.08215519f, -0.07645635f, 0.02313058f, -0.04627784f, -0.04755841f, 0.03069331f, 
    -0.13913456f, -0.11553250f, 0.06465726f, 0.18972157f, -0.03363553f, 0.10413174f, 0.06712155f, 0.02447246f, 
    -0.07450663f, 0.00359337f, -0.06399364f, -0.26942116f, 0.00385547f, 0.07594908f, 0.15543310f, 0.12734237f, 
    -0.00838563f, 0.03883612f, 0.01837377f, -0.01416145f, 0.05103115f, -0.04074822f, 0.14776458f, 0.16951171f, 
    -0.03273146f, -0.09073192f, -0.03292451f, 0.08545862f, 0.06953670f, 0.08027665f, 0.06572982f, 0.10368311f, 
    -0.06588888f, -0.00192750f, 0.20097798f, -0.00436791f, 0.03206838f, 0.05627443f, -0.01606330f, 0.02909522f, 
    0.02251701f, 0.08492368f, -0.02947256f, 0.17530717f, 0.08002458f, 0.17201772f, 0.07957851f, 0.17889574f, 
    -0.01221959f, 0.34970143f, -0.30659431f, 0.03165910f, 0.30435869f, -0.03964278f, 0.20744084f, -0.03745938f, 
    0.20750922f, 0.01401421f, 0.01778954f, -0.01019969f, 0.00584424f, 0.04053912f, 0.16281797f, 0.21487996f, 
    -0.21446395f, -0.15802947f, 0.06206623f, 0.00552468f, 0.14346178f, 0.23496461f, 0.04408434f, 0.10772622f, 
    -0.05993301f, 0.29817724f, -0.08900391f, 0.04624180f, 0.07108589f, 0.10396355f, 0.01603430f, 0.00853817f, 
    -0.04269503f, -0.07191622f, 0.01140578f, -0.04333322f, -0.07933046f, -0.07630815f, -0.00262090f, 0.05780985f, 
    -0.08684134f, -0.01195585f, 0.04851025f, 0.10186303f, -0.05133454f, 0.16451778f, 0.13824111f, 0.15604371f, 
    -0.11095312f, 0.05252619f, -0.00475043f, 0.15942858f, 0.08691741f, 0.04984820f, 0.01594197f, 0.04908890f, 
    -0.08002892f, 0.15946031f, 0.11914705f, 0.15536705f, 0.23140688f, 0.09352011f, 0.04816516f, -0.15000707f, 
    0.14698696f, 0.07899688f, 0.04172667f, 0.05825698f, 0.08017681f, 0.05927096f, -0.01673896f, 0.01194478f, 
    -0.16950862f, -0.06867485f, -0.01042399f, -0.07466099f, 0.24407491f, 0.02392504f, 0.04982018f, 0.07176902f, 
    -0.28825366f, -0.05659305f, -0.08924223f, 0.01842673f, -0.08259772f, 0.15578273f, 0.08630147f, 0.31470466f, 
    -0.09479243f, 0.03948920f, -0.07795829f, 0.12419734f, -0.13274848f, -0.06829948f, -0.02027026f, 0.06721614f, 
    0.04198426f, -0.18849222f, -0.00942626f, -0.14078470f, 0.05448558f, 0.03816006f, -0.04636059f, -0.06163259f, 
    0.04096322f, 0.02736824f, -0.02070892f, -0.20190811f, -0.05080799f, 0.04457385f, 0.01582784f, 0.11611640f, 
    0.04124051f, 0.10307253f, 0.02537442f, 0.20334132f, 0.08087109f, 0.06716669f, 0.23574741f, 0.20747031f, 
    -0.04651296f, -0.28268218f, -0.29574412f, -0.20690824f, 0.06372494f, 0.08040225f, 0.02144844f, 0.03385768f, 
    -0.09146179f, 0.03966036f, -0.03356240f, -0.18978177f, 0.12017459f, 0.27829009f, 0.01488183f, 0.07066087f, 
    -0.11986391f, -0.05896030f, -0.07168135f, -0.19169156f, 0.02324963f, -0.08581311f, -0.01501690f, -0.07815329f, 
    -0.08728379f, 0.23204802f, 0.02456077f, 0.10536239f, 0.06326964f, -0.10819478f, 0.02559632f, -0.02314309f, 
    -0.12131920f, 0.02808473f, -0.04794411f, -0.05126986f, -0.18517987f, 0.29497248f, 0.07065056f, -0.12681819f, 
    -0.01005965f, -0.06863097f, 0.00600712f, -0.11154925f, 0.04885674f, 0.00820904f, -0.00145805f, -0.00273779f, 
    0.17996289f, 0.07648293f, -0.06351288f, 0.06615567f, 0.14891921f, -0.09623230f, -0.00384583f, 0.05534295f, 
    -0.05346846f, -0.15573375f, -0.05628942f, -0.37694538f, 0.06084315f, 0.06354702f, -0.13474514f, -0.13206720f, 
    0.07180143f, -0.08892892f, -0.02954053f, 0.11643089f, -0.02267932f, -0.11141364f, -0.04563037f, -0.20026624f, 
    -0.12503819f, -0.12097839f, -0.01824260f, -0.15896294f, -0.15652063f, -0.11579180f, -0.04865046f, -0.17113337f, 
    0.01664258f, 0.14795734f, 0.08429940f, 0.10647112f, 0.13107568f, 0.02092790f, 0.03130287f, -0.01865565f, 
    -0.06021924f, -0.02284944f, -0.13128865f, -0.12124234f, 0.27070510f, 0.07867462f, 0.10510714f, 0.15367992f, 
    0.03113178f, -0.00600105f, -0.05020912f, 0.01841825f, 0.17230760f, -0.00002710f, 0.09368792f, -0.02722077f, 
    0.12518243f, 0.01016728f, 0.14925808f, -0.04463981f, -0.02318989f, 0.16007757f, -0.06083946f, 0.11351973f, 
    -0.04787009f, 0.03587805f, -0.03521974f, -0.08466794f, 0.00902653f, 0.13987391f, 0.01990210f, 0.06626507f, 
    -0.12502962f, 0.04834749f, 0.02068494f, -0.17232908f, 0.03109278f, -0.16967049f, -0.03591973f, -0.07522453f, 
    0.13509916f, 0.02023902f, 0.03974680f, 0.12903415f, 0.34616497f, 0.20143072f, -0.03892117f, -0.06345813f, 
    0.06557421f, -0.09124127f, 0.11405446f, 0.11788990f, -0.13803546f, 0.17766187f, -0.00453183f, 0.06611004f, 
    -0.04274105f, 0.14156447f, 0.01734643f, -0.21326900f, -0.01628925f, 0.06819939f, -0.06899816f, -0.05561948f, 
    0.00756706f, 0.15183549f, 0.07794151f, 0.16420314f, -0.17027315f, -0.06113953f, 0.07980148f, -0.03602323f, 
    0.11286506f, 0.10445540f, 0.18229453f, 0.12885988f, -0.20705535f, -0.16807954f, -0.01267357f, -0.17694014f, 
    0.28130335f, 0.20099424f, 0.07326592f, 0.09820657f, -0.02568282f, 0.07999635f, 0.03339000f, 0.07282959f, 
    0.12586902f, -0.01896779f, 0.01152028f, 0.08045668f, -0.07878625f, -0.22651091f, 0.08302231f, 0.14011297f, 
    -0.10856702f, 0.04448714f, -0.01746017f, -0.07497092f, 0.11044314f, -0.01618969f, 0.17961381f, 0.15367518f, 
    -0.26547709f, -0.15259314f, -0.04299658f, -0.09432490f, 0.01832615f, -0.00269620f, -0.07034689f, 0.04814423f, 
    -0.08516119f, -0.05178463f, 0.02255755f, 0.13204055f, -0.04449760f, -0.09927691f, -0.00284690f, -0.07444213f, 
    0.05208615f, -0.01981221f, 0.03806772f, -0.05735798f, 0.00388531f, -0.02044407f, 0.13362660f, 0.16145869f, 
    0.03621284f, -0.07403970f, 0.11153210f, -0.16979554f, 0.03293853f, -0.03011839f, -0.01210171f, 0.15468748f, 
    -0.07447464f, 0.05904331f, -0.11605326f, -0.19320334f, -0.05717353f, 0.04730225f, 0.12045614f, 0.02040632f, 
    -0.07517283f, -0.04590455f, -0.04496068f, -0.06112983f, -0.17699522f, -0.16556203f, -0.21186776f, -0.18705988f, 
    -0.29271638f, -0.21160950f, -0.07036651f, -0.31135380f, 0.06010760f, -0.32515508f, 0.17953856f, 0.09703236f, 
    -0.18237904f, -0.05282109f, -0.11229734f, -0.06060440f, -0.32917053f, -0.22135605f, -0.22059381f, -0.19790831f, 
    -0.01469660f, -0.18477392f, -0.07320894f, 0.11252169f, -0.04151344f, 0.03413685f, 0.02484727f, 0.09956232f, 
    -0.04185018f, 0.07261786f, -0.20388775f, -0.10060501f, 0.12026394f, -0.02919382f, -0.04537432f, 0.07824548f, 
    0.01166088f, -0.13108291f, 0.07152148f, 0.09743636f, 0.11958062f, 0.13314782f, 0.42174521f, -0.31275791f, 
    -0.05503889f, -0.13566588f, 0.05215382f, 0.05573655f, 0.19175451f, 0.21093376f, 0.02045131f, 0.02507854f, 
    -0.20717862f, 0.21733613f, -0.33520213f, 0.09954648f, -0.00425614f, 0.01586577f, 0.18207999f, 0.15686327f, 
    -0.05480862f, 0.03942564f, 0.03527534f, -0.02528759f, -0.05888335f, 0.07796626f, -0.10487576f, -0.07908780f, 
    -0.01994930f, 0.03580676f, -0.10919987f, -0.00528896f, -0.09247644f, -0.12911913f, -0.12400685f, -0.11269431f, 
    0.11619542f, 0.03019672f, -0.00956536f, 0.15370445f, 0.09745611f, 0.01585983f, 0.06850801f, 0.11896046f, 
    0.04443707f, -0.01287784f, -0.10337486f, 0.02493862f, 0.08468278f, -0.08260642f, -0.02367363f, 0.09789456f, 
    0.01639967f, -0.03018602f, -0.00179447f, 0.14230226f, -0.03894502f, 0.07039522f, 0.17141043f, 0.08383174f, 
    0.04174580f, -0.15476376f, -0.38471881f, -0.12466302f, -0.02735404f, -0.05102750f, -0.04587070f, -0.05647747f, 
    0.05841078f, -0.05535640f, -0.06579900f, -0.01147866f, 0.32993004f, 0.05489460f, 0.30285060f, -0.12895150f, 
    -0.20498830f, 0.06571012f, 0.08329771f, 0.00339404f, -0.01469132f, -0.01770506f, -0.14532749f, 0.16353540f, 
    0.08234472f, 0.28457150f, 0.13721472f, -0.03216503f, -0.11478744f, -0.10270944f, 0.04234070f, 0.06493623f, 
    0.01004719f, 0.00845352f, 0.19802326f, 0.25934413f, -0.22827004f, -0.12815775f, -0.02268631f, -0.11069336f, 
    0.05096917f, -0.14812391f, -0.00203280f, 0.17006846f, -0.17847738f, 0.13858297f, -0.06339731f, -0.01462030f, 
    -0.20088251f, 0.00359704f, 0.10903628f, 0.04685826f, -0.22873951f, -0.15819016f, -0.07587028f, -0.04011192f, 
    -0.16621406f, -0.10048199f, 0.01237075f, 0.03252508f, 0.00865686f, -0.08512495f, 0.06225999f, 0.12115767f, 
    -0.04458410f, 0.01439966f, -0.06003642f, 0.07069813f, -0.03705022f, 0.14400636f, 0.06704445f, -0.10331998f, 
    0.31739891f, 0.04255443f, -0.19720514f, 0.24585170f, -0.00971616f, 0.13098755f, 0.03923500f, 0.19764896f, 
    0.03434459f, 0.16582100f, 0.19498435f, -0.00874724f, 0.26346296f, 0.09607907f, -0.02446000f, -0.03140556f, 
    -0.05727106f, 0.04928673f, -0.00391782f, -0.07008398f, 0.02117844f, -0.08031309f, 0.07175856f, -0.01150344f, 
    0.04807745f, 0.00637505f, 0.03104448f, 0.19420978f, 0.03941261f, -0.06464454f, 0.16045019f, 0.14320360f, 
    -0.02574464f, 0.11198905f, 0.08785773f, 0.18943629f, -0.03446205f, -0.02757369f, -0.07040346f, -0.07567488f, 
    -0.19380976f, 0.05447380f, 0.24379301f, -0.03796882f, 0.10612288f, -0.04612730f, -0.00820420f, 0.10841478f, 
    -0.02529423f, 0.03976592f, 0.08206147f, 0.06855167f, 0.11814794f, 0.01488567f, -0.03704298f, 0.01058647f, 
    0.07674153f, 0.06290704f, 0.15645209f, -0.05340498f, 0.03328383f, 0.05969928f, 0.07043269f, 0.11104064f, 
    -0.00401444f, -0.02924407f, -0.04490602f, 0.04586913f, -0.09763201f, -0.05233747f, -0.17034121f, -0.10433835f, 
    -0.17925894f, -0.24044383f, -0.29108092f, -0.16778164f, -0.03577085f, 0.00848454f, 0.19801037f, 0.04108709f, 
    0.02529431f, 0.05753553f, 0.13115813f, 0.12349134f, -0.06371529f, 0.25868341f, 0.26454121f, 0.09427654f, 
    0.06489746f, 0.05909373f, -0.08580984f, 0.06765193f, -0.06045838f, 0.08332433f, 0.01767367f, 0.04186866f, 
    0.38513562f, 0.20037554f, 0.05134698f, -0.05420677f, -0.07409184f, -0.05258357f, 0.09257735f, -0.02821515f, 
    -0.01373847f, -0.10838137f, -0.09534986f, -0.02708925f, 0.04139245f, -0.01056449f, -0.15962918f, 0.13712272f, 
    0.07631101f, 0.16143094f, -0.10403595f, 0.17879400f, -0.04309560f, -0.17292276f, 0.11237517f, -0.17730880f, 
    -0.21557102f, 0.04436142f, 0.12120403f, 0.18145832f, 0.03375011f, -0.00907371f, -0.16334255f, 0.14156401f, 
    -0.01049693f, -0.00243773f, 0.16716151f, -0.13363823f, -0.06876955f, -0.15056543f, -0.00641244f, 0.06460182f, 
    -0.12319894f, 0.02518204f, 0.36983401f, 0.05142905f, 0.28908205f, 0.19736078f, 0.04615800f, 0.08640794f, 
    -0.27095979f, 0.12947789f, 0.04196971f, 0.22202857f, 0.31621960f, 0.03972443f, -0.03266643f, 0.14231117f, 
    -0.11747617f, 0.06095377f, 0.14113572f, 0.01599316f, -0.21601117f, 0.05786099f, 0.20551553f, -0.00278167f, 
    0.14142755f, 0.03335280f, 0.01512603f, -0.00476722f, 0.09347734f, 0.34916654f, -0.11765595f, -0.05428138f, 
    -0.02756262f, 0.05125078f, -0.06708866f, -0.25538486f, -0.10711829f, -0.21701469f, -0.06883567f, 0.04391080f, 
    -0.10155144f, -0.01403565f, -0.18164088f, -0.18426633f, 0.15612952f, 0.07564659f, 0.01873716f, -0.11073665f, 
    0.10775534f, 0.00153922f, 0.04456589f, -0.07109334f, -0.02071188f, -0.04702802f, -0.10987753f, -0.15261869f, 
    0.01680960f, -0.15839945f, 0.01534053f, -0.17826439f, -0.04335276f, 0.08739351f, 0.09545422f, 0.00495795f, 
    0.04198951f, 0.14664900f, 0.08580681f, 0.08508857f, 0.08403859f, 0.03069142f, -0.00262882f, 0.00425301f, 
    -0.02565695f, 0.06194097f, 0.01914380f, 0.07544611f, 0.35259953f, 0.25930330f, 0.36838704f, 0.24251775f, 
    -0.04662613f, -0.05534213f, 0.00875272f, -0.04095455f, 0.02330640f, 0.01772936f, 0.02548683f, -0.04014292f, 
    0.00071092f, -0.00350261f, 0.02196833f, -0.04107464f, -0.01252563f, -0.05135677f, -0.04788325f, 0.00904906f, 
    -0.01168738f, 0.01626581f, -0.04221559f, 0.03460778f, -0.01532213f, -0.05233312f, 0.01900005f, -0.00525087f, 
    -0.00197203f, -0.03011021f, 0.03681715f, 0.01316311f, -0.05053610f, -0.01101248f, -0.00192363f, 0.04156033f, 
    0.00736430f, -0.03974220f, 0.03123295f, -0.00494713f, 0.00171724f, -0.03706567f, -0.00992031f, -0.01927785f, 
    0.00241298f, 0.00237592f, -0.04676341f, 0.02386313f, 0.01173922f, 0.03832911f, 0.00145412f, 0.01162122f, 
    0.01483451f, -0.02941689f, -0.03305870f, -0.03430943f, -0.03429492f, 0.03031364f, -0.00253421f, 0.03651202f, 
    0.00535365f, -0.03382607f, -0.02068949f, 0.02354284f, -0.03490245f, -0.03819960f, 0.00222111f, 0.04616405f, 
    -0.04036164f, -0.01621995f, -0.02983530f, 0.02055802f, 0.00450249f, -0.01161214f, -0.02625885f, -0.05681934f, 
    0.02280264f, -0.03544850f, -0.02526318f, 0.00971453f, -0.05116049f, -0.04933778f, -0.01246274f, -0.01691944f, 
    0.02971778f, 0.02449919f, -0.03147499f, -0.05612014f, 0.00086187f, -0.00926800f, -0.02780053f, -0.05727947f, 
    0.01551645f, 0.00622686f, -0.01140576f, 0.04196442f, 0.00311789f, -0.01906645f, -0.00159712f, -0.05076123f, 
    -0.00858799f, -0.00083936f, -0.02115484f, -0.02838383f, 0.02129886f, -0.02444588f, 0.01761286f, -0.03681774f, 
    0.03818155f, 0.00108230f, -0.04256499f, -0.05613553f, 0.00848769f, -0.01252429f, 0.05127970f, 0.00130050f, 
    -0.02081899f, -0.02277100f, -0.03500997f, -0.01017538f, -0.02937257f, -0.02726661f, -0.05285445f, -0.00445880f, 
    -0.02879946f, -0.01295114f, -0.05196205f, -0.00774625f, 0.03679468f, -0.01173748f, 0.01016067f, -0.03487574f, 
    -0.03431476f, -0.04295991f, -0.02395480f, 0.01567266f, -0.04405737f, -0.05272023f, -0.05140095f, 0.04507146f, 
    -0.01546274f, -0.03028406f, -0.04608914f, -0.05157142f, -0.03547139f, -0.00585699f, -0.01391544f, 0.02559684f, 
    -0.04961365f, -0.02898466f, -0.03610381f, 0.00805655f, -0.04913827f, -0.01881917f, -0.01581750f, 0.02165822f, 
    -0.00771871f, 0.02376885f, -0.05201465f, -0.04804682f, -0.05110471f, 0.00081176f, 0.00569818f, -0.01460904f, 
    0.03791479f, -0.04086581f, -0.02713216f, -0.04708110f, 0.03576520f, 0.00925506f, 0.00842044f, 0.01903060f, 
    -0.03935203f, 0.00207454f, 0.01240961f, 0.03283476f, 0.03031566f, 0.00406705f, -0.00463077f, -0.05872963f, 
    0.03968251f, -0.01267293f, -0.02146356f, 0.03272786f, -0.04867719f, -0.03116747f, -0.02017999f, 0.03088695f, 
    -0.05658699f, -0.01734099f, 0.01351317f, 0.01173889f, -0.05345882f, 0.02519207f, -0.04459054f, -0.05787243f, 
    -0.00716430f, -0.04599995f, 0.02827320f, -0.03670913f, -0.00721142f, -0.03933565f, -0.02906401f, -0.04569247f, 
    0.01827507f, 0.03057952f, 0.03013870f, 0.03345938f, -0.02569203f, 0.04034518f, -0.01379551f, 0.03426393f, 
    -0.04442585f, 0.03581287f, 0.03839385f, -0.03643596f, 0.01266527f, -0.00656276f, -0.01496250f, -0.02289807f, 
    -0.04592609f, 0.01521118f, -0.00866414f, -0.05562974f, 0.01623795f, 0.02161829f, -0.05291805f, -0.00360446f, 
    -0.04134690f, 0.01197657f, -0.01853563f, -0.03142389f, 0.03321608f, 0.04305886f, 0.01970703f, 0.03395718f, 
    -0.02757441f, -0.01859967f, -0.00557155f, 0.03375454f, -0.03627554f, -0.01704365f, 0.02258192f, 0.01568835f, 
    -0.00856721f, 0.02253111f, -0.00169399f, -0.00193130f, -0.02205371f, -0.00025714f, -0.01955851f, -0.03554385f, 
    0.01624908f, -0.00299210f, -0.01482544f, -0.06021148f, 0.01906349f, -0.03941491f, 0.03070452f, -0.05750500f, 
    0.04434335f, 0.00159699f, 0.03395370f, 0.00539986f, 0.00583392f, -0.02537527f, 0.00767299f, -0.02282151f, 
    -0.00566755f, -0.00312695f, 0.02442810f, -0.02386404f, -0.01981798f, -0.05474462f, -0.04206693f, -0.03953844f, 
    -0.04312844f, -0.01257950f, 0.00323555f, -0.04326735f, -0.01159407f, 0.01563686f, -0.01103613f, 0.02783467f, 
    -0.02667783f, 0.01368461f, -0.03492954f, -0.05502866f, -0.02326355f, 0.04068632f, -0.03921445f, -0.04291785f, 
    -0.01816264f, 0.04535587f, 0.02705116f, -0.00266292f, 0.03489625f, 0.00707028f, 0.00346805f, -0.02100171f, 
    0.04070684f, 0.04869480f, 0.01149335f, 0.03695108f, -0.04794414f, -0.01803879f, -0.01139844f, -0.02051520f, 
    0.01679049f, -0.01987161f, 0.01769651f, -0.03270887f, -0.05089251f, 0.03894107f, -0.03010892f, 0.03801975f, 
    -0.02151015f, 0.02660973f, -0.03371870f, -0.04445696f, 0.00158739f, 0.01729336f, 0.03129771f, -0.03073012f, 
    -0.01310015f, 0.01004078f, 0.04223948f, -0.05139287f, -0.04624459f, 0.03890308f, 0.02542548f, -0.02722155f, 
    -0.01743798f, 0.01711831f, -0.01669485f, -0.02595301f, 0.02422327f, 0.02819487f, -0.01940330f, 0.00896319f, 
    0.03817819f, -0.04523898f, -0.00814967f, -0.03032540f, 0.00511762f, 0.03707179f, -0.04911649f, -0.01892060f, 
    0.04152439f, -0.04944260f, 0.02291917f, 0.03967371f, -0.03786540f, -0.03071633f, 0.03733155f, -0.02215818f, 
    -0.05356738f, -0.03285976f, -0.02816251f, 0.01148667f, 0.03536792f, -0.03886428f, -0.04952220f, 0.04141666f, 
    0.00292148f, -0.00254269f, -0.00397886f, 0.00681577f, 0.04252543f, 0.00203721f, 0.02500016f, -0.00055768f, 
    0.01419564f, 0.04193456f, 0.04094543f, -0.00606305f, -0.05245090f, 0.02818278f, 0.01900462f, -0.00981150f, 
    -0.00155782f, 0.00754973f, 0.03057767f, -0.00194603f, 0.00829105f, -0.02370091f, -0.01426719f, -0.05939154f, 
    0.04248399f, -0.03217938f, -0.00626243f, -0.02156890f, 0.03930704f, 0.04205801f, -0.02407008f, -0.02275434f, 
    -0.03394337f, -0.02825434f, 0.00625324f, -0.01457442f, -0.00787334f, 0.00361495f, -0.03640583f, 0.03373902f, 
    -0.03352848f, -0.03904151f, -0.04086389f, -0.03102683f, -0.04268849f, -0.03195833f, -0.03713430f, -0.05454529f, 
    0.02239719f, 0.00789086f, -0.00663003f, -0.04460531f, 0.00947957f, -0.03573582f, -0.00928790f, -0.05331941f, 
    0.01990202f, -0.05752965f, -0.01710173f, -0.05071151f, -0.03022170f, 0.00336867f, 0.00656051f, -0.00617156f, 
    -0.04669865f, -0.03682541f, 0.03474783f, 0.04390303f, -0.01015543f, -0.01631086f, 0.04450956f, -0.01262289f, 
    0.00663546f, 0.01433828f, -0.03201197f, 0.02153474f, 0.03256254f, 0.03066704f, -0.03958704f, 0.00917574f, 
    0.03780532f, -0.01232872f, 0.02438068f, 0.02460824f, -0.01976582f, -0.02733219f, -0.02087086f, 0.03855304f, 
    0.04272712f, -0.04483234f, 0.03251909f, -0.01296204f, 0.03044664f, 0.00612576f, -0.00899790f, -0.01764507f, 
    0.02855888f, 0.03621013f, 0.03495986f, -0.04239175f, 0.03315917f, 0.01195012f, -0.01351177f, -0.02229783f, 
    0.02530135f, 0.01120012f, -0.01937422f, -0.02782201f, -0.01926866f, -0.04780016f, 0.04079412f, -0.03424212f, 
    -0.03179688f, -0.01389593f, 0.00298477f, -0.00300237f, 0.00649731f, -0.02953625f, -0.02517924f, 0.01068988f, 
    -0.02532742f, 0.01183549f, 0.04587408f, 0.03292938f, 0.02973137f, 0.02888064f, -0.04011296f, 0.02307935f, 
    -0.00992726f, -0.02443907f, 0.02893585f, 0.01551884f, -0.01852147f, 0.03408845f, -0.03549424f, -0.02397815f, 
    -0.00614704f, -0.05213832f, -0.04144487f, -0.00880152f, 0.03010605f, -0.02234534f, -0.05649447f, -0.01304926f, 
    -0.01703406f, 0.03679951f, -0.00878433f, 0.02474787f, -0.03588815f, -0.01395345f, -0.05315572f, 0.01097993f, 
    -0.02945347f, -0.03582646f, -0.01415445f, -0.04401282f, -0.00489502f, 0.03165396f, -0.05735084f, -0.02245888f, 
    -0.04927902f, -0.02366231f, -0.05219637f, 0.01480759f, -0.01118820f, 0.00093532f, -0.01644707f, 0.00456765f, 
    -0.03966224f, -0.04172494f, -0.01919114f, 0.03943038f, -0.00497691f, 0.00813454f, -0.00739277f, -0.03972817f, 
    0.04047135f, 0.02538486f, 0.03513861f, 0.03044076f, -0.01324353f, -0.04345322f, -0.00358518f, 0.04374446f, 
    0.02677459f, -0.01006576f, -0.01974747f, -0.01101705f, -0.02417023f, 0.01789165f, -0.03190573f, 0.01921738f, 
    0.03009219f, 0.01330545f, 0.00785278f, -0.00099040f, 0.02002939f, 0.03551348f, 0.04070750f, -0.04951676f, 
    0.03310008f, 0.03334278f, -0.01158914f, -0.00145642f, -0.00591643f, -0.00178693f, -0.02966217f, -0.00855502f, 
    0.03319747f, -0.01245078f, 0.02254803f, 0.02911087f, 0.00593233f, -0.02945342f, -0.04348513f, 0.01888929f, 
    -0.05171806f, -0.02375617f, 0.00105056f, 0.02536112f, -0.01863279f, 0.00233633f, -0.01995464f, 0.03840037f, 
    0.00463427f, 0.03083565f, -0.02032281f, -0.05296884f, -0.02118459f, -0.00119831f, 0.02802089f, 0.00867374f, 
    -0.04657741f, 0.01146033f, 0.02317947f, 0.03781940f, -0.02451589f, -0.01335091f, 0.00249590f, -0.05809731f, 
    0.02927509f, -0.03401926f, 0.02847477f, -0.04443704f, 0.00122892f, -0.03646137f, -0.03614543f, -0.04042996f, 
    -0.00913336f, 0.03946336f, 0.03413714f, 0.01188486f, -0.00605057f, -0.00312142f, -0.00129713f, -0.02708929f, 
    -0.01988656f, 0.02159809f, -0.01542882f, -0.03422797f, -0.02903574f, -0.03868394f, 0.02048674f, -0.02158437f, 
    -0.01982513f, -0.04513515f, 0.03214102f, 0.02289687f, -0.02953663f, 0.01660626f, 0.03508447f, -0.04640568f, 
    0.03908115f, -0.03230198f, 0.01577422f, 0.02369071f, -0.04179008f, -0.02597389f, -0.00656990f, -0.04508499f, 
    -0.00402066f, 0.03884859f, -0.05373748f, -0.00850230f, 0.03656487f, -0.01615241f, -0.00110107f, 0.02690561f, 
    0.01923786f, 0.02347639f, 0.04910293f, 0.03005948f, -0.05531885f, -0.01652783f, 0.02837328f, -0.04670589f, 
    0.03781009f, 0.02053706f, 0.02620707f, -0.00106584f, -0.01251591f, 0.02818073f, -0.04337697f, -0.00941684f, 
    -0.03933134f, 0.03686202f, -0.04871279f, -0.04382693f, -0.01517469f, -0.00206303f, 0.03824003f, 0.01912276f, 
    -0.03566217f, -0.04804998f, 0.03414444f, -0.00934518f, -0.02160347f, -0.00046101f, -0.05039234f, -0.00895956f, 
    0.03608853f, -0.04353877f, -0.01246258f, 0.05529730f, -0.00844737f, -0.05157521f, -0.00388942f, 0.03978922f, 
    -0.04728491f, -0.03639247f, 0.04340490f, -0.03911622f, -0.03283943f, -0.02695393f, 0.01435673f, -0.05021445f, 
    -0.04108339f, -0.04270799f, -0.01279049f, -0.05637836f, 0.00536963f, -0.01431523f, 0.04245542f, 0.03811163f, 
    -0.00470916f, -0.00096718f, 0.03174040f, 0.01639637f, -0.03921439f, 0.04612633f, -0.03496560f, -0.00104481f, 
    0.01586965f, 0.00260937f, 0.04527427f, 0.01045256f, 0.01612555f, -0.03768830f, 0.03078877f, -0.02540380f, 
    0.04230443f, -0.05169000f, -0.05579099f, 0.00638115f, -0.01863675f, 0.01634661f, 0.02489929f, -0.02208842f, 
    0.01599980f, -0.00948874f, -0.00124578f, -0.01500983f, 0.02501819f, -0.05325544f, -0.04434605f, -0.04865602f, 
    0.04655280f, -0.02443394f, -0.00262495f, -0.03396312f, -0.05286113f, -0.00893771f, -0.02787541f, 0.03357062f, 
    -0.03128874f, 0.04418887f, 0.01844368f, 0.03006984f, 0.03943063f, -0.00127957f, -0.04175108f, -0.02364426f, 
    0.01008489f, 0.02528697f, -0.02325114f, -0.02654980f, 0.01211135f, 0.03705674f, 0.01928665f, 0.02304556f, 
    -0.02871704f, -0.01533828f, 0.04090193f, -0.03271450f, -0.05459107f, -0.04369939f, -0.00028828f, -0.03847102f, 
    -0.07534278f, 0.04104370f, -0.11828236f, 0.08208045f, 0.03821598f, -0.16747005f, 0.10428335f, 0.17035690f, 
    -0.13420075f, 0.00425347f, -0.04957704f, -0.06487922f, 0.08268743f, -0.00501950f, 0.08487935f, 0.20790477f, 
    0.04895974f, -0.01429550f, 0.08689138f, 0.22065684f, -0.00436652f, 0.00675821f, -0.04309544f, -0.17436597f, 
    0.21807289f, 0.16061719f, -0.40955269f, -0.23477893f, 0.06436797f, 0.25750807f, -0.01536205f, -0.04250053f, 
    -0.06916553f, -0.05592134f, 0.01900285f, -0.06883843f, -0.22853333f, 0.21199968f, -0.20833799f, 0.20399712f, 
    0.06196892f, 0.13151251f, -0.05664177f, 0.00838072f, -0.10005726f, -0.14023519f, 0.05821850f, 0.05940956f, 
    -0.00816444f, 0.19085529f, 0.09060731f, 0.10139827f, 0.01267303f, 0.13667138f, 0.01283333f, 0.08791064f, 
    0.02430979f, 0.04278991f, -0.12083694f, 0.04606914f, -0.15897188f, 0.00226850f, -0.10694327f, -0.25079098f, 
    0.07453794f, 0.00923186f, -0.05113400f, -0.01426981f, -0.19124630f, -0.21766013f, -0.33941591f, -0.24910095f, 
    -0.10924096f, -0.09601980f, 0.18757005f, -0.01997671f, -0.08365964f, 0.01399824f, 0.09058335f, 0.06457612f, 
    -0.15024833f, -0.16023907f, -0.27515113f, -0.28549162f, 0.17170128f, -0.02814980f, -0.14940798f, 0.08642600f, 
    0.08416991f, -0.00837576f, -0.10208397f, 0.04575799f, 0.00873535f, 0.09109043f, 0.11844037f, 0.12130112f, 
    0.01912140f, 0.00793691f, 0.16202842f, 0.12628141f, -0.11098824f, -0.02911877f, 0.04419818f, 0.02851909f, 
    0.19836304f, 0.00376688f, 0.01882519f, 0.02110978f, -0.36846888f, 0.41917446f, 0.43997809f, 0.25979537f, 
    0.12183353f, -0.13133991f, -0.11462960f, 0.09005556f, 0.07352380f, -0.14738441f, -0.00388628f, -0.05796344f, 
    0.09888305f, 0.02028560f, 0.18306142f, 0.18880469f, -0.13024338f, 0.07144449f, -0.13837527f, -0.34994218f, 
    0.17565958f, 0.00259899f, 0.02615681f, 0.26214647f, -0.01296510f, -0.18049550f, 0.11271110f, 0.06409699f, 
    -0.12106854f, -0.02097101f, 0.01131482f, 0.12575190f, -0.24022034f, -0.03185793f, -0.15591902f, -0.09814773f, 
    0.40528435f, 0.04976168f, 0.11186884f, 0.42622390f, 0.08673456f, -0.13201925f, -0.02841494f, -0.03344262f, 
    0.14434670f, 0.01255271f, 0.08098389f, 0.15974729f, 0.09217747f, 0.08258931f, 0.20879720f, -0.01200350f, 
    -0.16203089f, 0.06746434f, 0.04325604f, -0.07119694f, -0.13458930f, 0.07224111f, -0.08086241f, 0.00996096f, 
    0.33595824f, -0.15218309f, -0.30432278f, 0.00847591f, 0.08634970f, 0.11031857f, 0.01143285f, -0.32623437f, 
    0.13979307f, 0.10268211f, -0.03882474f, 0.13512129f, 0.05196827f, -0.15298761f, 0.13698779f, -0.01230756f, 
    0.00298188f, 0.04493611f, -0.20755716f, -0.28240046f, -0.30828154f, -0.10568926f, 0.03432673f, -0.03675549f, 
    0.00179655f, -0.09887648f, 0.01689329f, 0.12174641f, 0.10175547f, 0.14594540f, -0.05918637f, 0.00236742f, 
    0.09155177f, 0.08505462f, 0.21775244f, 0.33533511f, -0.09093720f, -0.02148013f, -0.02726340f, -0.08012556f, 
    0.10664275f, 0.11154027f, 0.08322253f, 0.06451140f, 0.13123026f, 0.00377817f, 0.09589426f, 0.17116885f, 
    0.02339387f, -0.08219472f, -0.00721443f, -0.42816663f, -0.07171649f, 0.14058380f, -0.01090393f, -0.45829383f, 
    -0.06423465f, -0.05414765f, -0.16159315f, -0.14312722f, -0.09888452f, 0.12220145f, 0.12940897f, -0.16240810f, 
    0.07036854f, -0.15251021f, -0.02187250f, -0.13384281f, -0.33402881f, -0.13730296f, -0.18872875f, -0.55204070f, 
    -0.03408619f, -0.00144993f, 0.09445389f, 0.22913472f, -0.06594720f, 0.04187694f, 0.06147734f, 0.11144199f, 
    -0.10976800f, 0.02363970f, -0.04483444f, 0.04014813f, 0.25887063f, 0.07519891f, 0.07665055f, 0.27665889f, 
    -0.09508675f, 0.03983648f, 0.01775682f, -0.03059809f, 0.12447061f, 0.01849361f, 0.07567267f, 0.06344958f, 
    -0.28263053f, 0.11258359f, -0.07296021f, -0.11550509f, -0.11451726f, -0.00506121f, -0.15624095f, -0.21999761f, 
    -0.19448820f, -0.09471136f, -0.15584782f, -0.26041764f, 0.21249327f, -0.03467413f, 0.15610318f, -0.00997351f, 
    0.23400898f, 0.03593867f, -0.11395133f, -0.00699827f, -0.08810953f, -0.15700866f, -0.00597828f, -0.01076553f, 
    0.28759360f, 0.25562981f, 0.01363260f, 0.09542461f, 0.09272874f, 0.01844836f, 0.02874036f, -0.26034746f, 
    -0.09413673f, -0.24937099f, -0.00597547f, -0.00186067f, -0.08903196f, 0.06125578f, 0.17040020f, 0.15705484f, 
    -0.03306717f, 0.06818295f, 0.10285955f, 0.21720976f, 0.12943392f, 0.23806907f, -0.15812173f, 0.14674138f, 
    -0.19776836f, 0.31541625f, -0.11801276f, -0.09157643f, -0.00557753f, 0.06161969f, -0.00156996f, 0.02467865f, 
    -0.02296462f, -0.01372563f, 0.07576621f, -0.04962723f, 0.08866285f, 0.17271648f, -0.11071099f, -0.15590914f, 
    0.06252693f, -0.02195013f, -0.15080804f, -0.14538993f, 0.02113154f, 0.12154081f, -0.10981861f, -0.21761416f, 
    -0.01918168f, 0.09478239f, -0.00895111f, 0.14446573f, 0.03380256f, -0.08595087f, 0.05611091f, -0.14285715f, 
    -0.09618688f, 0.10565917f, -0.24304648f, -0.19716717f, -0.40113848f, 0.16556595f, -0.23677288f, 0.06148348f, 
    0.12860787f, -0.09866902f, 0.01544420f, -0.22302887f, -0.15503500f, 0.01863016f, -0.18963212f, -0.56699890f, 
    0.23528221f, 0.11712199f, 0.01540870f, 0.04819633f, 0.08901688f, 0.18411261f, 0.09221110f, -0.01273408f, 
    0.18709596f, 0.04482317f, 0.14553131f, 0.20265906f, 0.04410959f, -0.03318156f, 0.08509902f, 0.17236356f, 
    -0.09279873f, -0.13376527f, 0.07761367f, -0.16723436f, 0.15009257f, 0.28575811f, 0.12498006f, 0.28872716f, 
    0.03035635f, -0.01563816f, 0.11820927f, 0.11710317f, 0.12650213f, -0.09438892f, 0.14939462f, 0.16084900f, 
    -0.05902293f, -0.04991262f, -0.04276340f, 0.12582104f, -0.00380542f, 0.07487790f, 0.06344806f, 0.16140482f, 
    -0.02872618f, -0.08921740f, 0.03999059f, 0.22573569f, -0.03435707f, -0.02353041f, -0.00842920f, -0.06174348f, 
    -0.19417810f, -0.08587033f, -0.15917887f, -0.02763987f, 0.02334383f, 0.06316289f, -0.03717870f, -0.19314295f, 
    0.10096943f, -0.13441639f, -0.01522399f, 0.01679684f, -0.10968000f, 0.27105770f, -0.17982040f, 0.02274857f, 
    -0.00239245f, -0.02519313f, 0.03057140f, -0.10774576f, 0.09551498f, 0.01178842f, 0.02180089f, -0.12895195f, 
    0.13064377f, -0.20346394f, 0.00180860f, 0.03556571f, -0.09130614f, 0.06368936f, -0.02953260f, 0.07823317f, 
    -0.04475089f, -0.00491718f, 0.00801231f, 0.00612490f, -0.05548860f, 0.06047765f, -0.03325406f, -0.01861865f, 
    0.12028548f, 0.09334277f, -0.07232899f, -0.10682079f, -0.02731027f, -0.02099649f, 0.02886787f, 0.04620163f, 
    0.22735432f, -0.04636643f, -0.05438431f, -0.08144929f, -0.02285514f, -0.06569600f, 0.04706420f, 0.00208553f, 
    0.00488215f, -0.01851650f, -0.07215679f, -0.09239976f, -0.00957319f, 0.07151166f, -0.03461073f, 0.08298210f, 
    -0.00203748f, -0.02539733f, -0.11333883f, -0.04197298f, -0.02804472f, -0.05114353f, -0.02234234f, -0.10332599f, 
    0.01443752f, 0.15763015f, 0.04464109f, 0.04201248f, 0.11026753f, 0.13312200f, -0.00227110f, 0.08758514f, 
    -0.01629936f, 0.06998666f, 0.05716086f, -0.05698196f, -0.05922015f, 0.39802149f, -0.15008353f, 0.02664259f, 
    0.00520783f, -0.16086650f, -0.06386882f, -0.07690538f, 0.06289344f, 0.04245137f, -0.02861499f, -0.00914188f, 
    0.07389981f, 0.08819862f, 0.06542823f, -0.22816214f, -0.07726998f, -0.02019758f, -0.05309485f, -0.03048121f, 
    -0.03755355f, -0.03234113f, -0.00035797f, 0.07336210f, 0.25552890f, -0.12322651f, 0.03421399f, -0.04140617f, 
    -0.09429660f, 0.03081061f, -0.01462310f, 0.09576473f, -0.03231636f, 0.04982201f, -0.05932531f, 0.05061922f, 
    0.23642191f, -0.02570777f, -0.10063911f, 0.04358219f, 0.03209932f, -0.08681539f, -0.01491088f, -0.14071269f, 
    0.05590107f, -0.10696682f, -0.04695632f, 0.09961490f, 0.14184593f, 0.04628116f, 0.06311344f, 0.03090922f, 
    -0.01182133f, 0.00925146f, 0.05197171f, -0.03309689f, 0.05624117f, 0.16541284f, 0.00409554f, 0.01556303f, 
    -0.05836165f, -0.07073949f, -0.14670673f, -0.02916065f, 0.01307479f, 0.08788715f, -0.19091339f, -0.19041887f, 
    0.05427035f, 0.16170616f, -0.01578078f, -0.02189719f, 0.09023768f, -0.15052018f, 0.08569375f, -0.03098787f, 
    -0.09840259f, 0.00397124f, -0.09998064f, -0.04804399f, 0.00168752f, -0.00461324f, 0.05906430f, -0.05324021f, 
    0.04971401f, -0.02981930f, 0.06630284f, 0.09537376f, 0.01623905f, 0.02233026f, -0.04707238f, -0.10771795f, 
    0.01892626f, 0.07853985f, 0.09231449f, 0.20737258f, -0.04074689f, -0.05806267f, 0.15539631f, -0.01842077f, 
    -0.11426498f, 0.00969549f, -0.05091318f, -0.12142349f, -0.03889275f, -0.13096133f, -0.02070972f, 0.08262618f, 
    0.04187097f, -0.05401134f, 0.01290094f, -0.17846403f, 0.05554242f, 0.11890006f, -0.00805153f, -0.00816504f, 
    0.10765265f, 0.07311727f, 0.07145986f, -0.04645704f, 0.00557978f, 0.03450183f, 0.18649393f, 0.08307572f, 
    0.10221747f, -0.02748546f, 0.00634549f, -0.08600514f, -0.09297083f, 0.03926467f, -0.04903211f, -0.02214258f, 
    -0.04408373f, 0.06484008f, 0.03483986f, 0.20503145f, -0.06475754f, 0.06030417f, 0.01921257f, 0.09527918f, 
    0.00193753f, -0.03862903f, 0.04018913f, 0.03910900f, 0.34912345f, 0.15299845f, -0.09183089f, 0.08464891f, 
    -0.04988682f, 0.02686076f, -0.08930460f, 0.05697434f, -0.02194347f, -0.08521398f, -0.04172537f, -0.08921829f, 
    -0.06010128f, 0.17877983f, -0.03069157f, 0.00000471f, -0.02107771f, -0.00982969f, -0.01746337f, 0.03236616f, 
    0.02691270f, 0.01529892f, 0.02172139f, -0.05806110f, -0.01984707f, 0.07647420f, -0.06156517f, -0.00646199f, 
    0.14430566f, -0.04998414f, 0.05108680f, -0.06244919f, -0.03951215f, -0.11030081f, -0.04928384f, 0.04164298f, 
    0.29331121f, 0.15169312f, -0.05371341f, 0.08868222f, 0.01597999f, 0.05591919f, 0.05626909f, -0.02576330f, 
    -0.01385827f, -0.06096918f, -0.03252590f, 0.06020338f, 0.08151646f, 0.11593819f, -0.07748753f, 0.02739065f, 
    -0.15643302f, -0.06499834f, 0.04279076f, 0.16981770f, 0.09351091f, 0.08168601f, -0.08105081f, 0.03201685f, 
    -0.12436000f, -0.09996889f, 0.08759829f, -0.06701241f, -0.08627809f, 0.15832746f, -0.02936128f, -0.11465177f, 
    0.08301620f, -0.00905530f, 0.03739010f, -0.07905488f, -0.07163735f, 0.05708281f, -0.02114927f, 0.06154139f, 
    -0.04480341f, 0.10130097f, 0.00231944f, -0.13882133f, 0.03252457f, 0.09717233f, -0.21884651f, 0.04524356f, 
    -0.05937139f, 0.19309258f, 0.18071222f, 0.00521287f, 0.25565889f, 0.08002257f, 0.13859518f, 0.04583539f, 
    0.11029773f, 0.07337687f, 0.03530405f, 0.05105493f, -0.07039382f, 0.01994313f, -0.11396693f, 0.01953109f, 
    0.03817198f, -0.02185586f, 0.07129863f, -0.16793108f, 0.06841425f, 0.03406360f, -0.02218098f, -0.03738040f, 
    0.03332732f, 0.05642823f, -0.08671699f, 0.14482166f, -0.03548758f, -0.03942287f, -0.03846930f, -0.09766571f, 
    0.01147671f, -0.09023057f, 0.08476082f, -0.05025049f, -0.00534759f, 0.05295212f, 0.12472892f, 0.00595860f, 
    -0.03131222f, -0.08737759f, -0.04091755f, -0.08592702f, 0.09940565f, 0.13543560f, 0.21111275f, 0.19621302f, 
    -0.16438992f, -0.24597193f, -0.01721440f, 0.17936735f, 0.01608673f, -0.09520663f, 0.14469494f, 0.07791027f, 
    -0.09181681f, -0.02321685f, 0.09067038f, -0.07759595f, 0.07460068f, -0.10436302f, 0.03430324f, 0.07339144f, 
    0.07375617f, -0.06641811f, 0.01971857f, 0.14484631f, -0.01885990f, -0.01220409f, 0.04092975f, -0.11335498f, 
    0.31195116f, -0.07938997f, -0.08607314f, -0.28008229f, 0.22458696f, 0.13774817f, 0.00976170f, 0.12045732f, 
    0.02141726f, -0.10744519f, -0.03192433f, 0.04225970f, -0.22549468f, 0.28631282f, 0.17713861f, -0.18240045f, 
    -0.19316572f, 0.08872806f, -0.16761883f, 0.01473660f, -0.12425347f, 0.07895768f, -0.00896753f, -0.04694095f, 
    -0.02455313f, 0.16131751f, -0.07481199f, 0.30487937f, 0.02797879f, 0.03503821f, 0.08977161f, -0.06734511f, 
    0.04320661f, 0.10069098f, -0.04460984f, 0.01976115f, -0.12635280f, 0.00892282f, 0.00915271f, -0.04338188f, 
    -0.03553241f, 0.06024182f, -0.06123844f, 0.00435941f, -0.10911081f, 0.01363125f, -0.08145057f, -0.12250374f, 
    -0.11317946f, -0.13949853f, 0.29700363f, 0.00895152f, 0.07451641f, 0.10603459f, 0.08062417f, 0.03667432f, 
    -0.09894197f, 0.04932271f, -0.06462739f, -0.06932385f, 0.08512200f, -0.25404471f, -0.17904593f, -0.07897191f, 
    0.07644650f, -0.13166177f, -0.03641719f, -0.07784316f, -0.01264820f, -0.07247740f, 0.14617310f, 0.09462806f, 
    0.02792649f, -0.12869877f, -0.05978093f, 0.09066798f, -0.01241341f, 0.10776430f, 0.05220041f, 0.13087411f, 
    0.06684849f, -0.01781170f, -0.09795952f, -0.06339785f, 0.13726911f, 0.42488086f, 0.16063972f, 0.01113455f, 
    -0.12239409f, 0.03678636f, 0.15826388f, -0.01218036f, -0.17902723f, 0.13236661f, -0.08818149f, 0.02141192f, 
    -0.07666720f, -0.03751628f, 0.08310437f, 0.21121001f, -0.02920902f, -0.04679712f, -0.02600784f, -0.00365787f, 
    0.05213169f, 0.13063100f, -0.03881027f, 0.15879567f, -0.25732705f, -0.18554479f, 0.07116893f, 0.17911617f, 
    -0.00227644f, -0.07652175f, 0.09600750f, -0.04638124f, -0.06479964f, 0.07371999f, -0.11737120f, 0.00727485f, 
    -0.07694092f, -0.09510276f, 0.09167023f, 0.12647672f, -0.00160174f, 0.00624374f, -0.03537922f, -0.08570402f, 
    -0.04550600f, -0.06037280f, 0.12786368f, 0.05704273f, -0.03070890f, -0.00372189f, 0.00045133f, -0.21176192f, 
    -0.01194423f, 0.00636995f, -0.08066569f, 0.09821633f, -0.08484165f, 0.08496586f, 0.01407549f, -0.19035845f, 
    0.50852728f, -0.06660793f, -0.30075237f, -0.35627174f, 0.03257626f, 0.04232898f, 0.03810009f, 0.13396734f, 
    0.12747994f, -0.00075994f, 0.18289557f, 0.13896328f, 0.04172605f, -0.11499427f, -0.13198121f, -0.00344086f, 
    -0.00438995f, -0.05728081f, -0.02386323f, -0.01507227f, -0.08474324f, 0.01019261f, -0.00009351f, -0.09980901f, 
    -0.05206545f, -0.20639347f, -0.05012971f, 0.04300241f, 0.04691749f, 0.00361342f, 0.03237980f, 0.10764316f, 
    0.02871046f, 0.16208971f, 0.15454707f, 0.17639792f, -0.15457563f, -0.07549559f, -0.02548820f, 0.13796555f, 
    -0.00038451f, 0.03088089f, 0.23015273f, 0.03577215f, -0.08595760f, -0.14598125f, -0.03143560f, 0.06432424f, 
    -0.08457357f, -0.08887384f, -0.02130614f, -0.03605371f, 0.00308475f, 0.09428907f, -0.01664916f, 0.02408333f, 
    -0.11434475f, -0.04880527f, -0.03612476f, -0.03248546f, 0.23209089f, 0.22921576f, 0.06195933f, 0.07970179f, 
    0.11063807f, -0.11491367f, -0.00747896f, -0.01667380f, -0.15773277f, 0.03057193f, -0.06030718f, -0.05407163f, 
    -0.10731409f, -0.19955689f, -0.07781188f, 0.16619483f, -0.10425110f, -0.09662239f, 0.06155945f, -0.00857469f, 
    -0.03769495f, 0.05983446f, 0.02182459f, -0.02883561f, -0.08139306f, 0.23862307f, 0.04951996f, 0.00201316f, 
    -0.01351374f, 0.09505523f, 0.02386468f, 0.01962723f, 0.13239540f, 0.06260964f, -0.00976208f, 0.03871020f, 
    0.14348450f, 0.26464474f, 0.03504595f, 0.07922187f, 0.02164028f, 0.06375176f, 0.06641769f, 0.04468542f, 
    -0.10455673f, -0.01792550f, 0.03934091f, -0.05450309f, 0.42737192f, -0.09412991f, -0.15145412f, -0.00931456f, 
    0.17517380f, 0.03926506f, 0.01627853f, 0.01473391f, 0.00944843f, 0.02473602f, -0.01363958f, -0.04203179f, 
    -0.00221784f, 0.16938350f, -0.20586196f, 0.02407755f, 0.06630056f, 0.06256902f, -0.07775643f, -0.05008709f, 
    0.00887754f, 0.01967416f, 0.12146737f, 0.08680947f, 0.06960640f, -0.02163371f, 0.11593371f, 0.20760861f, 
    -0.02784041f, -0.08149435f, 0.18685769f, 0.06919037f, 0.29710841f, 0.14851977f, 0.09427740f, 0.00846676f, 
    -0.42260876f, 0.36037448f, -0.16206929f, 0.23610047f, -0.00519257f, 0.15654598f, -0.01818639f, 0.02750198f, 
    -0.05861912f, -0.09283751f, 0.03010200f, 0.03576664f, 0.09653680f, 0.07654276f, 0.01860326f, -0.07151844f, 
    0.08012471f, 0.08386270f, -0.07012489f, -0.04980630f, 0.02983564f, 0.25361577f, -0.01708111f, -0.09100042f, 
    -0.11232646f, 0.10747968f, -0.01571337f, 0.14490253f, 0.04183357f, -0.02704012f, 0.05118620f, 0.22261384f, 
    -0.01498781f, 0.04416394f, -0.16413510f, -0.14584899f, 0.03245819f, 0.05468652f, -0.05224875f, -0.10028709f, 
    0.05361361f, -0.00168743f, -0.19033475f, 0.09598653f, -0.00960132f, -0.06019713f, -0.08131261f, -0.15615945f, 
    0.23300448f, -0.04495598f, 0.17764823f, 0.06364368f, -0.00646833f, 0.08659196f, 0.08596148f, 0.00441648f, 
    0.10055559f, 0.06353575f, 0.02934784f, 0.13730580f, -0.05034730f, -0.03690986f, -0.06371480f, -0.14424126f, 
    -0.08598664f, -0.07040179f, -0.03606272f, 0.06887167f, 0.11331628f, 0.18199010f, 0.09086968f, 0.27096140f, 
    0.29797289f, 0.13805670f, 0.03091096f, 0.17009589f, -0.00321233f, 0.17720662f, -0.09495245f, 0.10143670f, 
    -0.04037279f, -0.03164173f, 0.10541204f, -0.04615877f, 0.20227309f, 0.25660104f, 0.23640597f, 0.15921170f, 
    -0.02410920f, 0.08465669f, 0.11187292f, 0.05636207f, 0.02764882f, -0.00431400f, 0.00697143f, 0.09863931f, 
    -0.23153414f, 0.13703786f, 0.04732773f, 0.06165343f, 0.03421037f, -0.08099587f, 0.09089820f, -0.03305214f, 
    0.09870148f, 0.07637185f, -0.11541694f, 0.00401844f, -0.02728922f, -0.23108670f, -0.01442875f, 0.06515399f, 
    -0.02842998f, -0.10955187f, -0.00106303f, -0.05325694f, 0.06105261f, 0.01942531f, -0.06974134f, 0.22341996f, 
    0.04349944f, -0.00658076f, 0.05744197f, -0.32520461f, 0.06256310f, 0.18754478f, 0.00334235f, -0.01812574f, 
    -0.06821912f, -0.11222656f, 0.03075439f, -0.05737917f, 0.01354293f, -0.08224194f, 0.12440556f, 0.09927006f, 
    -0.01097935f, -0.05972083f, 0.08832828f, 0.03921589f, -0.01409291f, 0.02585748f, 0.13675357f, 0.13296606f, 
    0.10482538f, 0.00186447f, -0.09166186f, -0.00482816f, 0.10080653f, -0.04341012f, 0.01187143f, 0.03336193f, 
    -0.03584946f, 0.01976326f, 0.15719488f, -0.01291521f, 0.22569464f, 0.22674091f, 0.24949323f, 0.01002403f, 
    0.09505330f, 0.19713169f, 0.04808868f, 0.14746672f, 0.03002230f, -0.02609384f, -0.13654330f, -0.01985658f, 
    0.05314177f, 0.16476044f, 0.04158488f, -0.03222585f, 0.09853894f, 0.03656212f, 0.11192372f, 0.29410550f, 
    -0.19847594f, 0.00676012f, -0.03638391f, 0.01598316f, -0.03511724f, -0.18210338f, -0.31157932f, 0.06591338f, 
    -0.07079177f, 0.04856722f, -0.02752149f, -0.01234739f, -0.02803041f, -0.13349088f, 0.03671020f, 0.08492135f, 
    -0.12498970f, -0.17239694f, -0.13219483f, -0.22268941f, 0.01093123f, 0.01319871f, 0.00001589f, 0.00164063f, 
    -0.04192335f, 0.04845514f, 0.01438148f, -0.17269363f, 0.33735421f, 0.10335931f, 0.04917104f, 0.05363270f, 
    0.08813800f, 0.12766267f, 0.01845684f, 0.12454126f, 0.12320191f, 0.00659269f, 0.21167593f, 0.07356448f, 
    0.05598308f, -0.00600094f, -0.28956944f, -0.19354938f, 0.11952449f, 0.11149197f, 0.00458623f, -0.01053619f, 
    -0.08274575f, 0.12191538f, -0.07110347f, -0.04746148f, -0.18597361f, -0.06147346f, -0.16873284f, 0.03389082f, 
    -0.08036245f, -0.08158883f, -0.04384571f, -0.09812004f, -0.06098408f, -0.08611609f, 0.00412809f, 0.05208647f, 
    -0.39680889f, 0.11955258f, 0.22485569f, -0.01419998f, -0.03885107f, -0.09500004f, -0.01319259f, -0.12507582f, 
    -0.09582032f, -0.09228689f, -0.06403850f, -0.04633976f, -0.10263631f, 0.01606327f, -0.08968660f, -0.11291771f, 
    -0.06126364f, -0.10566045f, -0.06352280f, -0.07787455f, 0.06011736f, -0.06781139f, -0.03079984f, 0.01104273f, 
    0.30324382f, 0.14609064f, 0.07615633f, 0.09368344f, 0.06055591f, 0.09744719f, 0.01025115f, 0.01290010f, 
    -0.08082733f, -0.14369632f, -0.18977089f, -0.27953333f, 0.14510611f, 0.15503876f, 0.02710366f, -0.03056759f, 
    0.14631923f, -0.01614898f, -0.02159673f, 0.14557587f, -0.03083825f, -0.00310894f, -0.05640792f, -0.12422818f, 
    -0.06113010f, -0.06632178f, -0.14855036f, -0.02783300f, -0.09042183f, -0.21176846f, -0.02056793f, -0.05654194f, 
    0.07222032f, 0.07497119f, 0.18238585f, 0.13089871f, -0.09718499f, -0.16124529f, 0.06996894f, -0.10912539f, 
    -0.10210742f, -0.03244344f, -0.03645834f, 0.00754180f, 0.08439320f, 0.01755506f, 0.03954954f, 0.19058807f, 
    0.24863321f, 0.27289352f, 0.21977402f, 0.06883480f, 0.10118982f, 0.11870266f, 0.04205900f, 0.04919827f, 
    0.06491055f, -0.04991081f, 0.00377396f, -0.08837952f, -0.02766879f, -0.01536965f, -0.20832784f, -0.18127851f, 
    -0.02903292f, -0.11042479f, -0.02757995f, -0.05934833f, 0.06585173f, 0.06096515f, 0.07984456f, 0.08228315f, 
    -0.07613318f, -0.18700147f, -0.13907482f, -0.06066722f, 0.02363860f, -0.07627844f, 0.01635396f, -0.00772193f, 
    0.07438107f, 0.04027738f, 0.01264964f, 0.14718749f, 0.01299318f, 0.13236478f, 0.20965518f, -0.04730073f, 
    -0.14075772f, 0.04593142f, 0.06370975f, 0.02453427f, -0.01514864f, 0.21203762f, 0.01886736f, 0.06333872f, 
    -0.23120087f, -0.01644764f, 0.12318657f, -0.10702568f, -0.12161770f, -0.01158938f, 0.02257788f, 0.06170877f, 
    0.14878695f, 0.21904446f, 0.12090022f, 0.07279970f, -0.01740009f, 0.01377427f, 0.00961707f, -0.12895055f, 
    0.01877536f, 0.07572937f, 0.08370423f, 0.05441942f, -0.28146949f, -0.22390650f, -0.04431951f, -0.16626443f, 
    0.28344640f, -0.12172025f, 0.13296123f, 0.01645230f, -0.05514548f, 0.02607551f, 0.02020816f, 0.00565450f, 
    0.06642941f, 0.08959980f, -0.00404354f, 0.06818644f, -0.13258059f, -0.12645139f, 0.05791534f, 0.11094730f, 
    -0.13331473f, -0.07707573f, 0.02267019f, -0.06326815f, 0.10001674f, -0.03787908f, 0.16840518f, 0.16176754f, 
    0.06756649f, -0.00412791f, 0.11193842f, 0.03360698f, 0.03434547f, 0.00143394f, 0.13501510f, 0.20493120f, 
    0.09876971f, -0.00820289f, 0.16031843f, 0.07509036f, -0.09274790f, -0.10603608f, 0.00583430f, -0.01653470f, 
    0.00936886f, -0.02326582f, 0.01033185f, -0.06584217f, 0.03793347f, 0.01871419f, 0.12116832f, 0.12224233f, 
    -0.09731568f, 0.11864252f, -0.02818126f, -0.00747782f, 0.04507441f, -0.01269679f, 0.12892318f, 0.06099255f, 
    -0.11390291f, 0.01317906f, -0.15091582f, -0.07033956f, -0.26237431f, -0.17291848f, -0.08492352f, -0.05196080f, 
    -0.06542935f, -0.00014205f, -0.09619310f, -0.10351006f, -0.23638819f, -0.20363280f, -0.21546724f, -0.32467791f, 
    -0.01303916f, 0.01944709f, -0.00124044f, 0.01536907f, 0.02811831f, -0.04891263f, 0.01776123f, -0.02860296f, 
    0.02235814f, -0.04805324f, -0.00504373f, 0.04464606f, 0.00944125f, 0.02666691f, -0.05329216f, -0.02974822f, 
    -0.04476044f, -0.03319572f, -0.03757687f, -0.02212236f, -0.04890221f, 0.03670343f, 0.01443966f, 0.02069402f, 
    0.00725716f, 0.02688099f, -0.02645109f, 0.01063766f, 0.02660617f, 0.01617206f, -0.03193404f, -0.03120595f, 
    -0.03563661f, 0.00741155f, -0.00295545f, -0.02147952f, -0.02347738f, 0.04979717f, -0.00177330f, 0.00838578f, 
    -0.01496927f, 0.03331963f, -0.01696867f, -0.04084352f, -0.00726794f, -0.04314613f, -0.01767471f, -0.00250820f, 
    -0.04875158f, -0.02551687f, 0.03472443f, 0.00578960f, -0.00310656f, -0.01655667f, -0.04579975f, 0.04305038f, 
    0.01113928f, -0.03005679f, 0.03380182f, -0.03838841f, -0.02302101f, -0.03883211f, -0.00617746f, -0.00176171f, 
    -0.05533081f, -0.03731792f, -0.03738766f, 0.04194816f, -0.01325373f, 0.00096336f, -0.03569394f, -0.02193447f, 
    -0.02908195f, -0.05406318f, -0.04473242f, -0.04265898f, -0.00896042f, -0.00527767f, 0.01088019f, 0.04480239f, 
    0.01716021f, -0.03463361f, -0.05597427f, 0.04478239f, -0.04545626f, -0.00081762f, 0.00126912f, -0.02374673f, 
    -0.00928571f, -0.05116661f, -0.02306066f, -0.03557095f, -0.01091005f, 0.03153862f, -0.04718186f, 0.01404444f, 
    -0.05219370f, -0.03448567f, 0.04131619f, -0.00578551f, 0.01025827f, -0.00532791f, -0.02681388f, -0.00274514f, 
    0.00340968f, 0.02910169f, -0.00569298f, 0.03063935f, -0.00078191f, -0.02468546f, 0.02742585f, 0.03027226f, 
    -0.00126209f, 0.00475470f, -0.02887927f, -0.03719664f, 0.01981471f, 0.04162530f, -0.02261678f, 0.01706543f, 
    -0.04139548f, 0.00722984f, -0.01804556f, 0.03428089f, -0.00650057f, 0.04492506f, -0.01747040f, 0.00541310f, 
    -0.00997826f, -0.03657456f, 0.01745580f, 0.02118747f, 0.04340689f, 0.03209855f, -0.03261347f, 0.02072068f, 
    0.00618175f, 0.00416441f, 0.02054964f, -0.03508212f, -0.00449551f, -0.01586767f, -0.02203948f, 0.00862833f, 
    0.00880369f, -0.02373646f, -0.00789627f, 0.02996478f, 0.01467185f, -0.02377964f, -0.01287635f, -0.00379132f, 
    -0.03304141f, -0.04109963f, -0.05447279f, -0.02201689f, -0.04686786f, 0.00316840f, 0.01425919f, -0.04527410f, 
    -0.05513819f, -0.00935199f, -0.01426391f, 0.00776863f, 0.01890482f, -0.03003033f, -0.04936405f, -0.04797759f, 
    -0.03670852f, 0.03659800f, 0.00663231f, -0.02707097f, -0.04029036f, -0.00918482f, 0.00754614f, 0.01101684f, 
    -0.01578934f, -0.02024438f, -0.02928143f, -0.05223475f, -0.01868230f, 0.03770327f, 0.03313260f, -0.00028791f, 
    0.03617229f, 0.02208542f, 0.02829437f, -0.03864660f, -0.02751071f, -0.01773344f, 0.03038805f, 0.04338912f, 
    -0.00741287f, 0.03244549f, 0.00919825f, -0.04913541f, -0.02676010f, 0.00903014f, 0.03217953f, -0.01986049f, 
    -0.02758067f, -0.05440747f, 0.02569980f, 0.02031463f, -0.00319383f, 0.00342116f, 0.02409105f, 0.01995964f, 
    -0.01694629f, -0.00656771f, 0.04361434f, 0.03509207f, -0.00529628f, -0.01985991f, -0.02107407f, 0.02256850f, 
    0.03955330f, -0.00624483f, -0.03541880f, 0.01428148f, -0.00792459f, -0.04140434f, 0.03175730f, -0.03206797f, 
    -0.03357711f, -0.02676227f, -0.04698660f, -0.02230415f, -0.04040182f, -0.05075131f, 0.04260028f, -0.02278033f, 
    0.04473707f, -0.03622276f, 0.03741115f, 0.01472201f, 0.02657360f, -0.04252172f, -0.05433123f, -0.05454239f, 
    -0.02410914f, 0.00810062f, 0.02698855f, -0.00619164f, -0.00222247f, 0.00347424f, 0.03301596f, -0.02618250f, 
    -0.05221744f, -0.02351116f, 0.01223676f, -0.04439108f, -0.04447068f, -0.02197341f, -0.00845977f, 0.00156989f, 
    0.00435823f, 0.01060179f, -0.04553671f, -0.05113867f, 0.00536224f, -0.00541126f, -0.05469963f, -0.05262756f, 
    -0.02803844f, -0.00725719f, 0.03687639f, 0.01577582f, 0.02063288f, 0.00776129f, 0.02596841f, -0.03196705f, 
    -0.02749203f, -0.01926494f, -0.00149970f, -0.01231160f, 0.00569032f, -0.00786801f, 0.01339950f, 0.03165197f, 
    0.01495706f, 0.04057355f, 0.02549683f, -0.03246558f, 0.02759990f, 0.00609813f, 0.04097012f, 0.01033100f, 
    -0.02545123f, -0.02264285f, 0.04211273f, -0.00431363f, -0.01784321f, 0.03368997f, -0.05629940f, -0.01897967f, 
    -0.03302661f, 0.00487053f, -0.00776661f, -0.03973096f, -0.01994198f, 0.03838052f, -0.02766077f, 0.03363744f, 
    0.00965724f, -0.04530868f, -0.00265465f, -0.00026823f, 0.03835848f, -0.03909620f, -0.00286755f, 0.01659382f, 
    -0.03119555f, 0.02715961f, -0.01233816f, 0.02263719f, -0.01819904f, -0.05289711f, -0.03780102f, -0.00519808f, 
    -0.03940628f, -0.04641066f, 0.00440852f, -0.03216798f, 0.02444694f, 0.00703751f, -0.04724935f, 0.03840523f, 
    -0.05355678f, 0.05091786f, -0.02262975f, -0.04596273f, -0.04975564f, 0.04085476f, 0.02861924f, 0.02414818f, 
    0.03781998f, 0.01665314f, -0.03337501f, -0.04722280f, 0.04400040f, -0.00274858f, 0.02805059f, -0.01710596f, 
    0.02692201f, -0.05515099f, 0.04096600f, -0.02063409f, -0.02596335f, 0.02371174f, 0.01195333f, -0.02958032f, 
    0.04218422f, -0.01186209f, -0.02350267f, -0.05639129f, -0.00678699f, -0.04022490f, -0.02733064f, 0.03347484f, 
    -0.00442298f, 0.01675874f, -0.05429512f, -0.05619333f, 0.02558222f, 0.04167860f, -0.01226753f, -0.05219153f, 
    0.03684599f, -0.04611385f, -0.03638509f, 0.02723752f, 0.01511044f, -0.03718635f, -0.05106437f, 0.03828017f, 
    0.03724568f, 0.03536984f, 0.04268854f, -0.02186970f, 0.01609164f, -0.03599701f, 0.03367870f, 0.01193899f, 
    0.03422523f, 0.00795935f, 0.03372318f, 0.05049741f, -0.04959942f, 0.03790238f, 0.00666154f, 0.02304594f, 
    -0.03612654f, 0.02590917f, 0.01585620f, 0.03122934f, 0.01088887f, 0.03076307f, -0.01709222f, 0.00752953f, 
    0.02886163f, 0.02096291f, 0.00868013f, -0.04007237f, -0.03594593f, -0.05599241f, 0.02302469f, -0.02595145f, 
    0.04204498f, 0.00123990f, -0.00465193f, 0.02226453f, -0.00627636f, 0.01543780f, 0.00000629f, -0.01141707f, 
    0.00357182f, 0.00096834f, 0.04929130f, 0.02288613f, 0.03238800f, -0.04699278f, 0.00049334f, -0.03433306f, 
    -0.03970976f, -0.00792134f, -0.00126678f, 0.04904053f, 0.03899540f, 0.04248696f, -0.00449832f, -0.01769276f, 
    -0.03447604f, -0.01859538f, -0.00431184f, -0.04798172f, -0.01393199f, -0.03888970f, 0.00909298f, -0.01857165f, 
    -0.01823965f, -0.04813695f, 0.02777022f, -0.05652592f, -0.05374384f, 0.00291472f, -0.01230898f, -0.00900389f, 
    0.01280010f, 0.04458196f, -0.00519443f, 0.01654336f, 0.01452750f, -0.01764897f, -0.02931750f, 0.00308236f, 
    -0.00396765f, 0.01324875f, -0.01399818f, -0.03270498f, 0.03561828f, 0.04443216f, 0.02359485f, -0.05283505f, 
    -0.00277986f, -0.00138927f, -0.04317635f, 0.01712799f, 0.03409322f, -0.05318332f, -0.04931600f, -0.04587294f, 
    -0.02658116f, 0.02796506f, -0.01923134f, -0.05346772f, 0.02006079f, 0.01365310f, 0.03387266f, -0.03228026f, 
    -0.01017747f, -0.02142514f, -0.00206541f, -0.03640804f, -0.04751499f, -0.03231420f, 0.03366547f, 0.01200185f, 
    0.03617171f, 0.01636404f, -0.00809154f, 0.00437788f, -0.01104508f, 0.02925923f, -0.03510295f, 0.02181872f, 
    -0.03016904f, 0.00411810f, -0.05262812f, -0.03414121f, 0.01461739f, 0.00250086f, 0.01273619f, -0.02607697f, 
    -0.04652919f, -0.02728802f, -0.00857494f, -0.00296724f, 0.04441895f, 0.01614747f, -0.00828651f, 0.03385079f, 
    -0.00431840f, -0.01329913f, -0.01748149f, -0.02094713f, -0.04477070f, 0.01526272f, -0.02916807f, -0.00644449f, 
    -0.03461638f, -0.00472979f, 0.00745917f, -0.04877158f, -0.01045483f, 0.04403337f, -0.03496349f, -0.04992157f, 
    -0.00827770f, 0.03687793f, -0.03903370f, -0.03236657f, 0.00078509f, -0.02805505f, -0.03632391f, -0.00557960f, 
    -0.03043549f, -0.00100446f, -0.01920709f, -0.00693788f, -0.03488407f, -0.02702208f, 0.04023314f, -0.04960033f, 
    0.02357699f, -0.01053143f, -0.00723513f, -0.00301923f, 0.03806346f, 0.02439949f, 0.01895036f, -0.03768843f, 
    0.01802541f, -0.01848796f, -0.05374702f, -0.00025207f, 0.00937357f, -0.04451787f, 0.02144014f, -0.01702019f, 
    0.00061066f, 0.01913134f, -0.04571135f, -0.02606833f, 0.00232210f, 0.01857462f, 0.00267553f, 0.02697275f, 
    0.04297270f, -0.04454926f, -0.04502255f, -0.03602148f, -0.05236139f, -0.04130526f, 0.02554104f, 0.02069612f, 
    -0.05067981f, -0.02348336f, -0.03210875f, 0.03260354f, -0.00585440f, 0.03591201f, -0.01495232f, -0.03897991f, 
    -0.00251706f, -0.00545917f, -0.02644139f, 0.03167057f, -0.01577180f, -0.03555419f, -0.01705864f, -0.01060347f, 
    -0.05347550f, -0.01152015f, -0.00603854f, 0.03886721f, -0.00212214f, -0.01991742f, 0.03397016f, 0.00966701f, 
    0.02119517f, -0.03824036f, -0.03446569f, 0.03921781f, -0.04475982f, 0.03867008f, 0.00404640f, 0.00277746f, 
    -0.03532191f, -0.03216695f, 0.03353756f, 0.00186143f, 0.01944120f, -0.04937123f, -0.04099618f, 0.00014728f, 
    0.01656091f, -0.04620821f, -0.04203732f, 0.02704608f, -0.00641103f, 0.02185149f, -0.04298079f, -0.02978854f, 
    -0.01889331f, 0.02472971f, 0.01302048f, 0.03058270f, -0.05601381f, -0.03016993f, 0.00443428f, 0.02758413f, 
    0.00873487f, -0.02533413f, 0.00797739f, -0.05038682f, -0.04645057f, 0.03620766f, 0.02904049f, 0.04471981f, 
    -0.03022378f, -0.05206931f, -0.02435797f, 0.01287176f, 0.02812798f, 0.03107087f, -0.02587548f, -0.03126052f, 
    -0.02188575f, -0.00915485f, -0.00669014f, 0.03547409f, -0.04318616f, -0.05025253f, 0.00481624f, -0.00655561f, 
    -0.02003330f, -0.03821641f, 0.01583817f, 0.03509625f, -0.03540441f, 0.04004777f, 0.01290371f, 0.02813093f, 
    -0.03416760f, -0.03260222f, 0.03074768f, -0.04503699f, 0.00330474f, 0.02425328f, 0.01687772f, 0.02270032f, 
    -0.05076395f, -0.03959898f, 0.04026475f, -0.02506696f, 0.04132173f, -0.02408358f, -0.01919220f, 0.04115735f, 
    -0.02577089f, -0.05506811f, -0.03672035f, 0.00208789f, -0.02431097f, -0.01177737f, -0.05251935f, 0.03847563f, 
    -0.00676937f, -0.02775259f, -0.01582660f, 0.01582382f, -0.00385858f, 0.04456640f, -0.01434242f, -0.00366089f, 
    0.01111211f, -0.03102579f, 0.02179101f, -0.01762979f, 0.04064653f, -0.01268388f, -0.02070336f, 0.01525564f, 
    -0.01564388f, -0.01790559f, 0.04187452f, -0.02983948f, -0.02165462f, 0.03730178f, 0.01145900f, 0.00782816f, 
    -0.03580517f, 0.00845801f, -0.04935899f, 0.03320858f, -0.00587789f, 0.03847384f, -0.02994750f, 0.00501883f, 
    0.00609926f, -0.05318804f, -0.03315242f, 0.02610308f, -0.00509656f, -0.00801902f, -0.05251832f, 0.03923548f, 
    -0.00119679f, -0.00567408f, 0.00147231f, 0.04754047f, 0.04045754f, 0.01823256f, -0.04633284f, 0.03602699f, 
    0.02568806f, 0.04599315f, -0.00836665f, -0.02338006f, -0.05181500f, -0.02774429f, -0.02131369f, -0.01101979f, 
    0.00958964f, 0.03980643f, -0.04934341f, -0.00369965f, 0.03213428f, 0.01966805f, 0.00813328f, -0.01755034f, 
    -0.00967771f, 0.03758701f, 0.00322737f, -0.03278325f, -0.02929654f, 0.01871349f, -0.01140870f, -0.00764854f, 
    0.00445682f, 0.03971725f, 0.02233735f, -0.05384023f, 0.02727272f, -0.04870626f, -0.00956593f, -0.04799175f, 
    -0.01447400f, 0.15378378f, 0.15595977f, -0.08260667f, 0.13937859f, -0.13832708f, -0.00543640f, -0.04467956f, 
    -0.00251553f, -0.02646551f, -0.07980051f, 0.05181451f, -0.22722238f, 0.01324385f, 0.02690760f, 0.08145865f, 
    -0.02799503f, -0.05059481f, -0.01325761f, 0.04187090f, -0.08271746f, -0.01396678f, -0.00337435f, -0.00756900f, 
    -0.31254852f, 0.11266690f, -0.05258932f, 0.04850371f, -0.06040690f, 0.00859182f, -0.01559268f, -0.14590447f, 
    0.01812437f, -0.03626627f, 0.04878144f, -0.05119653f, 0.16196643f, 0.08613560f, -0.01560928f, 0.00388715f, 
    0.02832811f, -0.01154657f, 0.13086012f, -0.00086179f, -0.01421410f, 0.01336220f, -0.06248883f, -0.09104373f, 
    -0.06584550f, -0.36781999f, -0.07705050f, -0.05808258f, -0.04003326f, 0.06551592f, -0.08691098f, 0.04484180f, 
    0.02389217f, -0.04649936f, 0.04845443f, -0.01186614f, -0.02255633f, 0.02243631f, -0.02962384f, 0.00629058f, 
    -0.03144560f, 0.01424385f, 0.01769872f, 0.15009683f, -0.03053693f, -0.06351350f, 0.08971163f, 0.03299733f, 
    0.21816057f, 0.16736633f, -0.12188599f, -0.06515367f, 0.03519812f, -0.12670246f, 0.09845039f, 0.10857268f, 
    0.03707315f, -0.10553563f, -0.05805608f, -0.04553092f, -0.14980687f, 0.20627369f, -0.02420088f, 0.22834590f, 
    -0.14831153f, 0.11037324f, -0.04677107f, 0.06050149f, -0.04145843f, 0.00243560f, -0.03968491f, -0.21373406f, 
    -0.06324683f, 0.26440030f, 0.02910974f, -0.05803478f, 0.04483642f, -0.05362971f, -0.05697964f, -0.00768137f, 
    0.01630781f, 0.09056464f, 0.09997898f, 0.04598897f, -0.04165717f, -0.03908494f, -0.12855507f, -0.27465224f, 
    0.05910998f, 0.01516866f, 0.10214203f, -0.01979232f, 0.20138247f, -0.02583905f, 0.04967367f, 0.01920193f, 
    0.29408023f, 0.39298281f, 0.06659744f, -0.16003627f, -0.12023691f, -0.03934920f, -0.02511145f, -0.00446923f, 
    -0.00634580f, -0.06176240f, 0.10929831f, 0.05550921f, 0.30949965f, 0.14376935f, 0.07154305f, -0.18285437f, 
    0.00852275f, 0.04775687f, 0.06541975f, 0.20555024f, -0.06419908f, 0.00466127f, -0.05622135f, -0.02019815f, 
    0.25692251f, 0.26430035f, 0.25430039f, 0.01406843f, -0.09702865f, -0.13243787f, -0.04567553f, -0.08428497f, 
    0.11147203f, -0.07012669f, -0.02579491f, 0.15213187f, 0.18639740f, -0.07557360f, 0.01731632f, 0.14219883f, 
    -0.03097659f, 0.02622931f, 0.05303596f, -0.04841179f, -0.00728957f, 0.03371337f, 0.01289666f, 0.05894232f, 
    -0.11321097f, -0.07947447f, -0.02718792f, 0.24184686f, 0.06682333f, 0.11655261f, -0.03414219f, -0.08932938f, 
    0.08007926f, 0.07726781f, 0.01744704f, -0.01691118f, 0.13661560f, -0.00715572f, 0.03954498f, -0.04879702f, 
    -0.10044636f, 0.04590927f, -0.03823140f, -0.06545894f, -0.05164190f, 0.06516850f, 0.04930972f, 0.04272318f, 
    -0.11473576f, 0.20265099f, 0.00809662f, -0.02194473f, -0.07067472f, 0.08801340f, 0.03786275f, -0.02664932f, 
    -0.02435924f, 0.07548618f, -0.03838077f, 0.11421124f, -0.06264340f, 0.02299927f, 0.08457031f, -0.06822210f, 
    -0.00800857f, 0.02352695f, 0.02026466f, 0.00685275f, 0.11730357f, -0.01039166f, 0.00086819f, -0.00428338f, 
    0.14381593f, 0.05795829f, 0.14833073f, 0.02246524f, -0.00987764f, 0.02298380f, 0.03875583f, 0.02433315f, 
    -0.03587453f, -0.03674734f, -0.04702487f, -0.08772293f, -0.23111713f, -0.01241099f, 0.00098083f, 0.05092610f, 
    0.03658752f, 0.10093904f, 0.02334886f, 0.02106980f, -0.01236426f, -0.04226056f, 0.01391856f, -0.01614420f, 
    0.01638289f, 0.00383259f, -0.09739546f, -0.04506203f, -0.06554472f, 0.09112949f, -0.00649926f, 0.09053135f, 
    -0.02860730f, -0.03408648f, -0.01518019f, 0.04577903f, 0.45266825f, 0.16923337f, 0.30378619f, 0.13551450f, 
    -0.09297615f, -0.06342874f, -0.00803074f, 0.06999505f, -0.04877514f, 0.03850901f, 0.09744350f, 0.04814552f, 
    0.09591721f, 0.02186168f, -0.09550421f, -0.08350595f, -0.07766770f, 0.00972413f, 0.12070541f, 0.03205847f, 
    0.06084061f, 0.00929487f, -0.01931034f, -0.11819114f, -0.36947507f, 0.11556610f, -0.24174105f, 0.04654012f, 
    0.04682469f, 0.21534407f, -0.02535585f, -0.01662583f, 0.00048464f, -0.16760276f, -0.08818837f, 0.05694437f, 
    0.25559187f, 0.05580765f, 0.05111481f, -0.01638603f, -0.09695382f, 0.05026770f, 0.08910899f, 0.07940062f, 
    -0.03282785f, 0.04611540f, -0.03615361f, -0.02381445f, 0.05302505f, 0.11868138f, -0.18958245f, -0.19540532f, 
    0.00918464f, 0.09633955f, 0.08236348f, -0.00141832f, -0.01539158f, -0.04365591f, -0.02987575f, 0.08407113f, 
    0.08526032f, -0.56519145f, 0.29889426f, 0.01828630f, 0.03100798f, 0.11481299f, 0.01126623f, 0.00855237f, 
    0.04827960f, 0.14106447f, 0.16448046f, 0.00904959f, -0.06952041f, 0.03865094f, 0.21026266f, -0.03761002f, 
    0.01990408f, 0.12097193f, -0.04604522f, -0.03923997f, 0.09402597f, -0.01949552f, -0.24453455f, -0.01013791f, 
    0.12843271f, 0.14232045f, 0.16787858f, -0.00993850f, 0.02352663f, -0.02276364f, 0.02084446f, 0.00750807f, 
    0.06568528f, -0.04324589f, 0.05199282f, 0.02860537f, -0.01706608f, -0.00265986f, -0.06686759f, -0.02860501f, 
    -0.08611525f, 0.03677649f, 0.28876719f, -0.07536606f, -0.03918347f, 0.03171502f, 0.02861337f, -0.00547755f, 
    -0.21145964f, -0.05936990f, -0.27606320f, 0.12095872f, 0.00810798f, 0.02354521f, -0.02615457f, -0.04487087f, 
    -0.08606350f, -0.10749301f, 0.06471690f, 0.08477686f, 0.08670501f, 0.13665813f, 0.12181616f, 0.00545379f, 
    -0.01645970f, -0.05410085f, 0.06093536f, -0.01937748f, 0.04967674f, 0.14425997f, 0.27792954f, 0.15230395f, 
    -0.05022503f, -0.01524343f, 0.01164024f, -0.04526161f, 0.03081905f, -0.01401131f, -0.04199473f, -0.02243153f, 
    -0.00479679f, 0.02596767f, 0.02577930f, -0.02024013f, -0.05440576f, 0.01335701f, -0.03734263f, -0.01841788f, 
    -0.02009060f, 0.03759141f, -0.03473745f, 0.02926092f, -0.04051796f, 0.02756145f, 0.01874983f, -0.03389507f, 
    -0.03917360f, -0.02016935f, 0.00781272f, 0.03526361f, 0.03731969f, 0.00667534f, -0.05543417f, -0.00167845f, 
    -0.00802491f, 0.03543936f, 0.03864814f, -0.01700824f, -0.04715476f, 0.01881609f, -0.03442919f, -0.04741351f, 
    -0.01005773f, -0.00908541f, 0.00628514f, -0.00075048f, -0.05450851f, -0.00072023f, -0.04968022f, 0.01149874f, 
    0.02688944f, -0.04435474f, -0.02034056f, -0.04814866f, -0.01174966f, -0.05153415f, -0.04687506f, 0.02131634f, 
    -0.00670689f, 0.01064804f, 0.03908622f, 0.00426583f, 0.03208698f, 0.01303735f, -0.01262171f, -0.02440942f, 
    -0.01408194f, 0.00715394f, -0.04923763f, -0.03371783f, 0.02758806f, -0.00220803f, -0.03809267f, 0.02922031f, 
    -0.04805379f, -0.02675465f, -0.02131917f, 0.00905008f, -0.02325339f, -0.02925966f, -0.02063883f, -0.04456438f, 
    -0.00049157f, 0.02174712f, -0.03363432f, 0.00680369f, 0.03651389f, -0.03603615f, 0.03612645f, 0.02245193f, 
    0.01641892f, -0.05018103f, -0.03387978f, -0.05675106f, -0.05398168f, 0.02003148f, 0.03723292f, 0.00744105f, 
    0.01748125f, 0.01077729f, 0.03482050f, -0.05029110f, 0.01190320f, -0.04280990f, 0.00331573f, 0.03288373f, 
    -0.03785342f, 0.01896394f, -0.01984073f, -0.04150930f, 0.00260297f, 0.01208513f, -0.04569948f, 0.03310502f, 
    0.03438381f, -0.01332971f, -0.00760078f, 0.00057005f, 0.01118555f, 0.04170957f, 0.02634851f, 0.01737743f, 
    -0.02929999f, -0.03391397f, 0.02665806f, 0.01685342f, 0.03522857f, -0.05061696f, -0.02509392f, -0.02297579f, 
    -0.05078367f, 0.04269297f, 0.02251846f, 0.01673822f, -0.04538902f, -0.01387843f, 0.02623981f, 0.02441542f, 
    -0.02756678f, 0.01471191f, -0.04163237f, -0.00371079f, -0.04035147f, 0.02422350f, -0.04969518f, -0.01181432f, 
    -0.03289422f, 0.01600973f, -0.00298738f, -0.01078175f, -0.03430408f, -0.03806420f, 0.00355221f, -0.04754463f, 
    0.04048297f, 0.01944067f, -0.01299264f, -0.04659438f, -0.04494997f, 0.02683979f, -0.00110261f, -0.04605762f, 
    0.02186910f, -0.04182187f, -0.05305816f, 0.02431212f, -0.03898562f, -0.03070245f, 0.03430703f, -0.02068583f, 
    -0.05187131f, 0.02932625f, -0.04092930f, 0.04432300f, -0.05592293f, -0.02728193f, 0.04117680f, -0.04043918f, 
    0.04188714f, -0.00170056f, 0.01478945f, 0.00856283f, -0.01905511f, -0.05171707f, 0.04009898f, -0.05471080f, 
    -0.02146271f, 0.03413023f, -0.03850884f, -0.05356668f, 0.00848793f, 0.02705393f, -0.00172318f, 0.02528574f, 
    0.02979421f, -0.02661986f, 0.01854091f, 0.03553400f, -0.04697996f, 0.04287881f, -0.01678134f, -0.02274025f, 
    -0.05265226f, 0.02027494f, -0.03801708f, 0.02821593f, -0.01148734f, 0.00392381f, -0.02913976f, 0.02289847f, 
    0.02242921f, -0.03406284f, -0.02238197f, -0.00976588f, -0.03929830f, -0.02005189f, 0.03843972f, -0.01604277f, 
    0.03912823f, 0.03789479f, -0.04178818f, 0.01165516f, -0.00074812f, -0.04832936f, -0.01979137f, -0.01051025f, 
    -0.05181759f, 0.00280671f, -0.00528058f, -0.03506061f, 0.03159904f, -0.02585205f, -0.04014459f, -0.00081913f, 
    -0.02184961f, -0.03904712f, -0.03792151f, -0.01233403f, -0.01316021f, -0.00264998f, -0.02839265f, -0.01470734f, 
    -0.04873781f, -0.04379467f, 0.03468749f, -0.00266893f, -0.03163151f, 0.01986086f, -0.04363142f, -0.01691146f, 
    0.00299333f, -0.05629683f, 0.01185475f, -0.04775013f, 0.00307374f, 0.01602325f, -0.00320764f, -0.03063526f, 
    0.01526649f, -0.04796281f, -0.04390775f, 0.04219591f, 0.02254918f, -0.02945111f, -0.04728256f, 0.01328719f, 
    -0.02108973f, -0.04737023f, -0.02111661f, 0.04240369f, -0.01109109f, -0.04750250f, 0.00850024f, -0.00972038f, 
    -0.03276331f, -0.02501779f, 0.00991625f, 0.03759214f, 0.03970657f, 0.00262638f, -0.04240511f, -0.01093681f, 
    0.02411422f, -0.04625021f, -0.04709903f, 0.04437165f, 0.03252606f, -0.03669641f, 0.00464832f, 0.00929862f, 
    -0.05484432f, 0.03289798f, -0.02428258f, 0.02882705f, -0.05683465f, -0.02618967f, -0.02283441f, -0.03568732f, 
    0.00993796f, -0.05467989f, -0.04798752f, -0.01314168f, -0.04587945f, -0.04447439f, 0.01032291f, -0.01529457f, 
    0.00607894f, -0.05256804f, -0.02231549f, -0.05110925f, 0.00934184f, -0.05200648f, 0.00665923f, 0.00985227f, 
    0.03734074f, -0.05024908f, -0.03551825f, -0.02184254f, -0.05617049f, -0.01113053f, -0.05584596f, 0.02592110f, 
    0.00661285f, 0.00095570f, 0.01829923f, -0.04180542f, -0.01161843f, 0.01948358f, -0.01960385f, 0.01545811f, 
    -0.00594352f, -0.03758417f, 0.01486967f, 0.03262066f, -0.00493122f, -0.01678045f, -0.00087935f, -0.00407655f, 
    -0.04670619f, 0.00027806f, -0.00524787f, 0.02055228f, 0.01718196f, 0.01047381f, -0.00180368f, -0.03118564f, 
    -0.02746726f, -0.03290380f, 0.02389351f, 0.00997685f, -0.03047514f, 0.02424687f, -0.03232754f, 0.04153835f, 
    0.02885440f, 0.02930246f, 0.04505435f, 0.03520512f, -0.01266213f, 0.03699824f, -0.04062087f, -0.03174318f, 
    0.00445946f, 0.02918906f, 0.02654469f, -0.01539446f, -0.03940695f, -0.03295204f, -0.03787861f, -0.02549377f, 
    -0.04766526f, 0.04100049f, 0.02660383f, -0.04138626f, 0.04499078f, 0.02741092f, -0.04248473f, 0.01188330f, 
    0.03753689f, -0.05004140f, -0.04760431f, -0.04007754f, 0.04405322f, -0.01657038f, -0.01695741f, 0.01856996f, 
    0.18489696f, 0.21551412f, -0.03760726f, 0.01060129f, 0.05556097f, 0.09355738f, -0.00060817f, -0.02953407f, 
    -0.03700790f, -0.10452013f, -0.19979581f, 0.04915031f, 0.04887835f, 0.17831600f, 0.00549622f, -0.10387425f, 
    -0.01121486f, 0.16213481f, 0.12347415f, -0.05000798f, -0.05265270f, -0.05020633f, -0.09203754f, 0.07581100f, 
    -0.21491721f, -0.12802938f, 0.08350359f, 0.11748368f, -0.08440091f, -0.01011652f, 0.15832339f, -0.02614863f, 
    -0.02575510f, 0.13788059f, 0.05086451f, -0.09555503f, 0.42938286f, -0.27913046f, -0.06290687f, -0.16509716f, 
    0.08941317f, -0.10557919f, -0.05723850f, -0.06475481f, -0.03799022f, 0.02664875f, -0.00878565f, -0.07666658f, 
    0.17003837f, 0.21869296f, 0.06133959f, -0.01871923f, 0.05500234f, -0.09258853f, 0.06851686f, 0.18971561f, 
    0.06666321f, -0.05379699f, 0.02232201f, 0.00854642f, 0.13026206f, 0.05459563f, -0.04514373f, 0.04659888f, 
    0.08900961f, 0.14238715f, 0.12282874f, 0.01977271f, -0.05040895f, 0.06616537f, -0.12230067f, 0.00144877f, 
    0.17595178f, 0.09973100f, -0.18327238f, 0.34758309f, -0.06147538f, 0.08283053f, -0.00829199f, 0.08843178f, 
    -0.02720401f, 0.07443439f, -0.08934458f, 0.04979081f, 0.07964288f, 0.30363461f, 0.17054813f, 0.16561578f, 
    0.13769948f, 0.22339493f, 0.15383357f, -0.00854334f, -0.06633581f, -0.00216860f, -0.10152851f, -0.05765165f, 
    -0.06466349f, -0.11437533f, 0.04801900f, -0.04495933f, -0.14361671f, 0.00820145f, 0.08251132f, -0.17126825f, 
    0.02428689f, 0.10311120f, 0.13484910f, 0.03996482f, 0.46812639f, -0.26825342f, 0.11787632f, -0.08339220f, 
    0.04507541f, 0.13426334f, -0.29960006f, 0.00193402f, -0.08000423f, -0.06057529f, 0.04947493f, -0.02542959f, 
    0.19794910f, 0.17295457f, -0.04107780f, -0.00096244f, -0.03473066f, -0.03246678f, 0.07296389f, 0.05827839f, 
    0.04781921f, -0.07136673f, 0.13171573f, 0.06756978f, 0.07662274f, 0.17736441f, 0.03684166f, -0.03748263f, 
    0.05682057f, 0.12661456f, 0.17628655f, 0.01023436f, 0.09301589f, -0.04663320f, 0.18823223f, 0.00541972f, 
    0.18206979f, 0.25091985f, -0.05632298f, 0.01153990f, -0.05206990f, -0.04525160f, 0.05396604f, 0.00800079f, 
    0.08111815f, 0.02017942f, 0.02981446f, 0.04682852f, -0.17576337f, 0.03969984f, 0.15619045f, 0.12752201f, 
    -0.07540457f, -0.19939741f, -0.03459537f, -0.10216974f, 0.04623901f, -0.16660844f, 0.00192622f, 0.14946644f, 
    -0.22731680f, -0.14288300f, 0.07163560f, 0.27308211f, 0.06387357f, 0.08609848f, -0.07067621f, 0.05375720f, 
    -0.05554651f, 0.09082331f, -0.08991257f, 0.12413623f, -0.26691166f, 0.16671501f, 0.04369855f, 0.18234061f, 
    0.09325242f, -0.10937956f, -0.09034115f, 0.04208033f, -0.10155300f, -0.14497654f, -0.07379754f, 0.00241706f, 
    0.10518968f, 0.14719513f, 0.11158307f, -0.08456358f, 0.10272819f, 0.14912808f, 0.06324134f, 0.00091080f, 
    0.10280474f, -0.02636570f, 0.05312135f, 0.05250504f, 0.07789855f, 0.08610216f, -0.01946633f, 0.01461933f, 
    0.13880557f, 0.08568235f, -0.07340629f, 0.04701211f, 0.09342389f, 0.08945072f, 0.01160716f, -0.01257058f, 
    -0.05054359f, 0.05273521f, -0.12601678f, -0.01932771f, -0.12181012f, -0.09823572f, -0.12707102f, 0.01590208f, 
    0.09874097f, 0.08524282f, -0.11820048f, 0.05081651f, -0.22779670f, 0.11754638f, -0.09523439f, -0.05695429f, 
    -0.10422888f, 0.14220437f, 0.00679991f, -0.10060088f, -0.01771564f, -0.16241971f, 0.01060119f, -0.08811952f, 
    0.07157313f, 0.18079801f, 0.06647091f, -0.24234536f, 0.20396352f, 0.21278152f, -0.05752410f, -0.03619139f, 
    -0.06778395f, -0.16377677f, -0.07726564f, -0.02211217f, -0.09198989f, 0.07750534f, 0.08756777f, 0.06204943f, 
    -0.01531754f, -0.08940867f, 0.01893051f, -0.04477265f, -0.00111921f, 0.05711642f, 0.09590637f, 0.00833901f, 
    -0.10043285f, -0.27891362f, -0.11350985f, -0.01508405f, -0.04972711f, 0.02524414f, -0.07394487f, -0.02689826f, 
    -0.06584576f, -0.05001406f, -0.10715175f, 0.13332628f, -0.44348863f, -0.04259973f, 0.20770819f, -0.01711893f, 
    -0.02500958f, -0.06170364f, 0.06501348f, 0.15134266f, -0.03523591f, -0.01459044f, 0.08288132f, 0.02684948f, 
    -0.11588114f, -0.37560138f, 0.16493087f, 0.00583653f, -0.06170035f, -0.19723074f, 0.09017571f, -0.02222727f, 
    -0.03360749f, -0.05340868f, -0.07929925f, 0.03811342f, -0.14403521f, -0.07569914f, -0.04770254f, -0.19069201f, 
    0.09855218f, -0.00635584f, -0.07274132f, -0.07632711f, 0.01559088f, 0.00134029f, -0.05188787f, 0.12136617f, 
    0.35985449f, -0.08583146f, -0.07930493f, 0.07387695f, 0.05574300f, -0.00950563f, 0.24884316f, -0.02815593f, 
    0.20031783f, 0.21314692f, 0.00991247f, -0.08056647f, -0.12691812f, -0.19284844f, -0.14497763f, 0.06823955f, 
    0.06146964f, 0.02446387f, 0.06072287f, 0.08460094f, 0.07755801f, -0.12382308f, 0.04663831f, 0.12076285f, 
    0.14381239f, -0.13299680f, -0.02634674f, -0.00723782f, -0.02048600f, 0.20782170f, -0.01632462f, 0.00337215f, 
    -0.05178750f, -0.16154703f, -0.09532625f, -0.01218265f, 0.14073817f, -0.15809944f, -0.13444355f, 0.06482983f, 
    0.12787880f, 0.12224520f, 0.14177267f, -0.18182281f, -0.10030666f, 0.01930242f, -0.02116054f, 0.01495551f, 
    -0.00067053f, 0.10053576f, -0.08823516f, -0.07757785f, 0.01699411f, -0.02728616f, -0.12633935f, 0.10049176f, 
    -0.02902055f, 0.05642808f, -0.01424577f, -0.14993463f, 0.04050761f, 0.02166828f, -0.01977363f, 0.06059599f, 
    0.02707133f, -0.01700450f, -0.08161521f, -0.08378332f, -0.15491769f, -0.06516337f, -0.06257166f, -0.06599047f, 
    -0.02512123f, -0.01660371f, 0.01436168f, -0.02649196f, -0.01700711f, -0.03383436f, 0.03377931f, 0.01040426f, 
    -0.04923092f, 0.03720761f, 0.02594236f, 0.01846342f, -0.03221161f, -0.03451018f, -0.02118249f, -0.05971501f, 
    0.02481056f, 0.02743538f, 0.01136515f, -0.02770464f, -0.05227422f, 0.02514830f, -0.01821673f, -0.03499885f, 
    -0.02038803f, 0.02150852f, 0.01951345f, 0.04388062f, 0.04969170f, -0.06250781f, 0.00039516f, 0.00422809f, 
    -0.03833872f, 0.02968965f, -0.02835795f, -0.05558720f, -0.04211286f, -0.03647887f, -0.05085190f, -0.03089942f, 
    0.02098567f, 0.01441592f, -0.03549825f, -0.02099536f, -0.05092699f, 0.04629098f, -0.05786336f, 0.01577719f, 
    -0.04750723f, 0.01248239f, -0.03534681f, -0.04457662f, -0.03557931f, 0.01029517f, 0.04518692f, -0.00084999f, 
    -0.01323398f, -0.04143305f, 0.03756194f, 0.03508265f, 0.01267285f, 0.04531789f, -0.06475295f, -0.04592304f, 
    -0.03381928f, -0.04784114f, -0.03885831f, -0.01352120f, -0.05719532f, -0.02834926f, 0.00778754f, -0.01834320f, 
    -0.04784374f, -0.01386346f, -0.07782581f, -0.04613725f, -0.03239636f, 0.01268481f, -0.02439781f, 0.00580166f, 
    -0.03155478f, -0.02853843f, 0.00304654f, -0.00654766f, -0.04821670f, -0.01266495f, -0.08002347f, -0.06818838f, 
    -0.02605993f, -0.02617677f, 0.03422743f, -0.00078771f, 0.03788830f, 0.03024611f, -0.00635937f, -0.00478482f, 
    -0.03004045f, -0.02602628f, 0.01847002f, -0.01094321f, -0.01306165f, 0.01277148f, -0.03434739f, -0.04564896f, 
    0.04259731f, 0.01430277f, 0.03578402f, 0.02762258f, 0.02592991f, -0.01184195f, -0.01739621f, 0.03080555f, 
    -0.03928192f, -0.01495394f, -0.04017768f, 0.02795812f, 0.03047404f, -0.01330329f, -0.05345209f, -0.04649518f, 
    0.03740137f, 0.00693218f, 0.02443686f, -0.03961333f, 0.03821853f, -0.02749896f, -0.04891929f, -0.02389412f, 
    -0.03242186f, 0.03128931f, -0.03171485f, -0.04719182f, -0.04734289f, -0.02591417f, -0.02776728f, -0.03208983f, 
    -0.00247597f, 0.05148745f, 0.04183552f, 0.00063878f, 0.01421686f, -0.00269239f, 0.01170064f, 0.02792348f, 
    -0.05420515f, -0.00673057f, -0.06559697f, -0.05056781f, -0.03902685f, 0.00858885f, -0.04659057f, -0.02593552f, 
    -0.04327089f, -0.03090834f, -0.00394521f, -0.03934582f, 0.00215603f, -0.02461891f, 0.04907504f, 0.04242951f, 
    -0.01634412f, 0.03067985f, 0.00871258f, -0.01598667f, -0.04631003f, 0.01031217f, -0.01581307f, 0.02338677f, 
    0.02652625f, 0.02768178f, -0.01563262f, 0.02861640f, 0.00586662f, -0.04305168f, -0.04079990f, -0.01397523f, 
    -0.01695883f, -0.03163515f, -0.00988155f, 0.05070964f, 0.00195297f, -0.07276706f, 0.01415055f, 0.00884349f, 
    -0.00401687f, -0.06697929f, 0.02968094f, 0.04155821f, -0.04918781f, -0.03123205f, -0.04435439f, 0.01962131f, 
    0.02513127f, 0.02497508f, -0.05435044f, -0.01652466f, 0.00680115f, -0.05858634f, 0.00826335f, -0.06512864f, 
    0.03114193f, -0.01042455f, 0.01769816f, -0.02230980f, 0.00902140f, -0.05401654f, -0.01591997f, -0.06947714f, 
    0.03620660f, -0.00030634f, 0.02169289f, -0.01550091f, 0.00791577f, -0.00303333f, -0.03903763f, 0.00504926f, 
    0.00071369f, -0.05032688f, -0.04932016f, 0.01778188f, 0.02050496f, 0.01799598f, -0.03731439f, -0.02493680f, 
    0.03222796f, 0.01552014f, -0.02121099f, -0.05747218f, 0.03994530f, -0.00939875f, -0.02085488f, -0.00642647f, 
    -0.00207702f, -0.01507482f, -0.04479794f, -0.00701814f, 0.00313982f, -0.05131527f, 0.00157943f, -0.05002671f, 
    -0.05805683f, 0.02794275f, -0.01956898f, 0.02363266f, 0.02988801f, -0.01775398f, 0.04131753f, 0.02615413f, 
    -0.02410722f, -0.04869391f, 0.01372721f, 0.03005764f, 0.03751092f, -0.03453264f, -0.05401674f, 0.00571920f, 
    -0.01339196f, -0.01576903f, -0.00627850f, -0.05647648f, -0.02667369f, -0.06048058f, -0.04531329f, 0.04058332f, 
    0.00572777f, -0.01380159f, 0.02772121f, -0.03144249f, 0.02144413f, -0.06098815f, -0.03487299f, 0.02496110f, 
    0.03688406f, -0.02147890f, -0.05634007f, -0.03996268f, -0.02401809f, -0.05284261f, -0.04769837f, 0.02024081f, 
    -0.02678131f, -0.04846623f, -0.04392640f, -0.01635851f, 0.03414362f, -0.06085096f, -0.00836927f, 0.06546970f, 
    -0.00718533f, -0.00068015f, 0.02512444f, -0.03565810f, 0.00783339f, 0.02240419f, -0.05791122f, 0.00781717f, 
    -0.04482471f, 0.02420447f, -0.01588026f, -0.00130217f, -0.02231156f, -0.00696346f, 0.03936531f, -0.01988814f, 
    -0.04510369f, -0.05199807f, -0.00493325f, -0.02190135f, 0.03418546f, 0.00277981f, 0.00979611f, -0.02629075f, 
    -0.01726728f, -0.05235240f, -0.04288814f, -0.02068452f, 0.02373358f, -0.02132334f, -0.00530508f, 0.03260386f, 
    0.01232311f, 0.02474513f, 0.04900585f, 0.02203812f, -0.06249562f, 0.03131872f, 0.01955054f, -0.03598095f, 
    0.04639432f, -0.03767237f, 0.01512461f, -0.02478029f, -0.02738915f, -0.04245588f, 0.02741084f, 0.02062218f, 
    0.02005216f, -0.05711735f, -0.01240632f, -0.06836732f, -0.04002260f, 0.03541484f, -0.04423467f, 0.03006469f, 
    0.00473597f, 0.03806366f, 0.01194451f, -0.02766824f, -0.04406810f, -0.04866256f, -0.05279566f, 0.02183662f, 
    -0.00041444f, 0.01128830f, -0.00137754f, -0.04145619f, 0.01212610f, -0.02972836f, -0.01073494f, 0.03636447f, 
    -0.05263590f, 0.03637379f, -0.04590778f, -0.00909933f, -0.02714523f, 0.02594409f, -0.01682597f, -0.03093987f, 
    0.03864653f, 0.01610254f, -0.00345001f, -0.03494697f, -0.03755425f, 0.00847403f, -0.03791972f, -0.04935100f, 
    0.00908203f, -0.03100683f, -0.04424385f, -0.05088987f, -0.05198446f, -0.05648699f, 0.00088713f, -0.03336788f, 
    -0.19056526f, -0.71895033f, -0.68101090f, -0.41428745f, 0.05998820f, -0.03359293f, 0.07599605f, -0.01029483f, 
    -0.00573310f, 0.04271273f, -0.00326664f, 0.04720707f, -0.62831771f, -0.01506739f, -0.00795526f, -0.16610494f, 
    -0.00391796f, 0.02411483f, 0.04092091f, 0.12828967f, -0.10794533f, -0.03099352f, -0.03973974f, 0.01051520f, 
    -0.14879569f, 0.06825130f, 0.07467198f, -0.01106925f, -0.01873885f, 0.06213441f, 0.13284785f, -0.02558719f, 
    -0.03123521f, -0.12053674f, -0.03554761f, 0.04457308f, 0.27293158f, 0.13476436f, 0.07534260f, -0.01266727f, 
    0.05523732f, -0.10659394f, -0.02720893f, 0.00760058f, 0.15329896f, 0.09815821f, -0.04974933f, -0.04190706f, 
    0.01131525f, 0.30416691f, 0.13205494f, -0.01665359f, 0.00259866f, -0.02023355f, 0.15209891f, 0.23296525f, 
    -0.00004402f, -0.04006260f, -0.02929205f, -0.06449379f, -0.02626664f, -0.00336912f, -0.07191519f, -0.04946287f, 
    0.06087133f, 0.02056470f, -0.05533018f, 0.04822503f, -0.03499731f, -0.03699491f, -0.00905604f, -0.03003389f, 
    0.43476567f, 0.22650741f, -0.06811273f, 0.04708141f, 0.03956334f, -0.09191018f, 0.26159579f, 0.12675382f, 
    -0.01551397f, 0.00538635f, -0.13556813f, 0.02462306f, -0.43820316f, -0.25297642f, -0.24862312f, -0.55785257f, 
    0.12398732f, 0.10775007f, 0.00543514f, 0.00149736f, -0.03981179f, 0.04744111f, -0.00310918f, -0.04018306f, 
    -0.04280379f, 0.00742763f, -0.08114173f, -0.12062233f, 0.32185867f, 0.16168074f, 0.10625619f, 0.00752346f, 
    0.12103511f, -0.11133247f, -0.00066254f, -0.01640048f, 0.25122556f, 0.21472901f, 0.25045127f, 0.16904667f, 
    0.13702214f, -0.04349088f, -0.00096965f, 0.01824940f, 0.03046961f, -0.10525928f, -0.08911376f, 0.03559884f, 
    -0.33603716f, -0.19910626f, -0.17891061f, -0.14848186f, -0.00456365f, 0.01122566f, 0.00966160f, -0.02874648f, 
    0.02386928f, -0.12871787f, 0.14688392f, -0.15200937f, 0.10251731f, -0.17913690f, -0.19944474f, -0.23426597f, 
    0.07502475f, 0.15778375f, 0.08547933f, 0.20251209f, -0.02913877f, 0.10404896f, 0.10375486f, -0.02696433f, 
    -0.14518431f, -0.39828905f, -0.35384414f, -0.05272418f, 0.04182825f, -0.02853924f, -0.00465894f, -0.01945861f, 
    0.04315091f, 0.17317215f, -0.13407038f, -0.05136278f, 0.16768147f, 0.08546429f, 0.04905938f, 0.12862323f, 
    -0.00815760f, -0.07343512f, -0.02059532f, 0.01271322f, 0.04095475f, 0.07351463f, -0.05397014f, -0.02041031f, 
    -0.25288272f, 0.18788160f, 0.13577774f, 0.06038224f, -0.03766260f, 0.06895904f, 0.05750022f, 0.14724094f, 
    -0.28144014f, 0.10152967f, 0.02518657f, 0.10102030f, 0.16359456f, 0.18761620f, 0.09538795f, 0.09285299f, 
    -0.10243373f, -0.01205880f, -0.09712751f, -0.00685537f, -0.04848140f, 0.00644071f, -0.05794133f, 0.02848869f, 
    -0.36860710f, -0.17950267f, 0.02831603f, -0.02601836f, 0.01418519f, -0.01304937f, 0.07151189f, -0.04298513f, 
    0.04266056f, -0.08738085f, 0.06086033f, 0.13426293f, -0.00428783f, -0.04043618f, -0.09180121f, -0.00283239f, 
    -0.09016240f, -0.14301176f, -0.34642395f, -0.18283314f, -0.03621016f, -0.11865596f, -0.08873944f, 0.05953060f, 
    0.02701285f, 0.06606428f, 0.00805584f, 0.06861617f, 0.02379382f, -0.00239889f, -0.09707730f, -0.04238170f, 
    0.11094460f, 0.06683142f, 0.04961153f, 0.00867605f, 0.02571156f, 0.00978188f, 0.09097435f, 0.05826727f, 
    -0.02614980f, 0.02308104f, -0.02053978f, 0.01507776f, -0.07196988f, -0.08491718f, -0.13450813f, 0.04586069f, 
    -0.26786131f, -0.06189841f, -0.33076763f, -0.04865705f, 0.19780959f, 0.13683753f, 0.07085302f, 0.20682546f, 
    -0.03610072f, -0.01653570f, 0.11155339f, 0.22281511f, 0.10593411f, -0.13512227f, 0.08641277f, -0.02495710f, 
    0.07233777f, 0.01733201f, -0.04837343f, 0.00755488f, -0.19005202f, 0.01752853f, 0.05011508f, 0.04818106f, 
    0.12855530f, 0.01700247f, 0.06375856f, 0.02185546f, -0.03164023f, -0.02809358f, -0.06558318f, 0.03403575f, 
    -0.00013965f, -0.02444094f, -0.00918363f, -0.06857620f, -0.14836322f, 0.05730168f, 0.10956048f, -0.18401921f, 
    -0.05900671f, 0.03207150f, -0.00034196f, 0.19330840f, 0.07213648f, -0.04301627f, -0.06632942f, -0.00484327f, 
    -0.02085018f, -0.18391110f, 0.07312129f, -0.05793855f, -0.05073533f, -0.04237942f, -0.05471272f, 0.01603916f, 
    0.05551817f, -0.03060881f, 0.03915695f, 0.01953216f, 0.03409426f, 0.04692984f, 0.03999010f, -0.02405088f, 
    -0.07239095f, 0.05934049f, 0.06784766f, 0.21281704f, 0.18736349f, 0.26237965f, -0.06855736f, -0.06921731f, 
    0.12086479f, -0.10499489f, 0.03133413f, 0.18241739f, -0.02452823f, 0.05765949f, -0.00451232f, -0.11386438f, 
    0.09313367f, 0.04457937f, 0.04813070f, -0.04372403f, -0.07601402f, 0.02333671f, 0.01299125f, 0.09316292f, 
    0.05080057f, -0.01010506f, 0.05469360f, -0.04379557f, 0.16908322f, 0.03424146f, -0.04259643f, 0.07509729f, 
    -0.18075337f, -0.05303821f, -0.07559504f, -0.04234524f, 0.14772609f, 0.03884401f, 0.13494834f, 0.09156172f, 
    0.04024912f, 0.02063133f, -0.12067461f, -0.01589639f, -0.00666523f, 0.02302770f, -0.00781681f, 0.00640577f, 
    0.00516857f, -0.05186792f, 0.05142658f, -0.08028461f, -0.00173103f, -0.07032767f, -0.03700632f, -0.06723551f, 
    -0.00314674f, -0.05495398f, 0.11521272f, -0.02388083f, 0.04689473f, -0.19549067f, 0.06627183f, 0.05951797f, 
    -0.01316713f, -0.03797411f, 0.05534604f, -0.03277183f, -0.01843960f, 0.01422269f, 0.07668980f, 0.05080785f, 
    -0.00803108f, 0.04906398f, -0.07590846f, 0.03889893f, 0.14463837f, 0.07247238f, 0.18284123f, 0.10389561f, 
    -0.11676408f, 0.19559620f, 0.10709972f, 0.32466212f, -0.17268531f, 0.14124349f, 0.00452322f, 0.05208429f, 
    -0.01491608f, 0.10257138f, 0.07078940f, -0.03590017f, 0.03253936f, -0.01040033f, 0.19841301f, 0.29914257f, 
    0.04448324f, 0.14291364f, 0.04319012f, 0.13700163f, 0.04264465f, 0.00792215f, 0.05676503f, 0.12440389f, 
    -0.00107561f, 0.25315207f, -0.20081675f, -0.01844301f, -0.00264385f, 0.07624563f, 0.04637323f, -0.07367150f, 
    -0.03811598f, 0.22301631f, 0.06707007f, 0.00130946f, 0.14201163f, 0.02688425f, 0.01106633f, 0.21584974f, 
    -0.14483754f, 0.08445460f, 0.00653711f, -0.00434791f, 0.10595242f, 0.20047496f, 0.13401882f, 0.02265609f, 
    -0.20165496f, 0.31116867f, 0.21988244f, 0.02571167f, 0.02101182f, 0.12525594f, -0.00100974f, 0.14541756f, 
    -0.01212975f, -0.02275465f, -0.00586936f, -0.02724473f, 0.10375183f, -0.00674256f, 0.01183496f, 0.10453652f, 
    -0.04541650f, 0.03181205f, 0.06058510f, -0.00135876f, 0.10313856f, 0.23143543f, 0.01498037f, 0.19271886f, 
    -0.13146715f, 0.11455433f, 0.25095427f, 0.09087416f, -0.01815269f, 0.07426801f, 0.01492519f, 0.22706307f, 
    -0.04570310f, 0.13134649f, 0.08723449f, 0.16959639f, 0.03558219f, -0.12683406f, 0.11715690f, 0.03306431f, 
    0.09023953f, -0.13852198f, -0.02817206f, -0.04837755f, -0.03786485f, -0.04194130f, -0.03603588f, 0.12186524f, 
    -0.53636086f, -0.27597481f, 0.08095594f, 0.23255612f, 0.08298695f, 0.03331897f, 0.08351237f, 0.00452928f, 
    -0.01384108f, 0.00869366f, -0.10434461f, 0.01555127f, -0.01621896f, 0.11272404f, 0.50062865f, 0.25490433f, 
    -0.00404891f, -0.07093643f, -0.32124439f, 0.10695041f, -0.01026768f, -0.08958474f, 0.03178621f, -0.10589951f, 
    -0.05755511f, -0.14745164f, 0.05669603f, 0.00839780f, -0.04691688f, -0.00569843f, 0.04900343f, 0.03837855f, 
    -0.01671783f, -0.05164655f, -0.08998207f, -0.09458879f, -0.23681720f, 0.17654230f, 0.22706591f, 0.24576548f, 
    -0.06969336f, 0.07860333f, -0.03615941f, 0.00457638f, 0.01852433f, -0.07555056f, 0.08120435f, 0.05049118f, 
    0.00499891f, -0.23093022f, -0.16578779f, 0.00027246f, -0.08282499f, -0.17702542f, -0.04035881f, 0.14617264f, 
    -0.01155735f, -0.02565999f, -0.04018752f, -0.11835064f, 0.03058271f, 0.24418111f, 0.07098179f, -0.14862846f, 
    -0.17523640f, -0.11303552f, 0.02040879f, -0.03672228f, 0.10943951f, -0.09482125f, -0.03176732f, -0.13921036f, 
    0.19872636f, -0.09470697f, -0.00978644f, -0.06974492f, -0.05666633f, 0.02569121f, -0.06444349f, -0.13373558f, 
    -0.05093055f, 0.00502896f, -0.08664079f, 0.02922836f, -0.08397479f, 0.23041530f, 0.07837489f, -0.09318668f, 
    -0.13961834f, -0.13532226f, -0.00777250f, 0.01712144f, 0.09228031f, 0.04498852f, -0.04148530f, -0.03407478f, 
    -0.07716402f, 0.02693180f, 0.03049036f, 0.06589488f, 0.10663623f, -0.06505120f, -0.06811330f, -0.04234276f, 
    -0.00705683f, -0.15678182f, -0.03404566f, -0.06414239f, -0.20662293f, 0.00186483f, -0.02391863f, 0.05244900f, 
    0.10039253f, -0.15124805f, -0.09665672f, -0.01384706f, -0.14912598f, -0.01157523f, 0.06125277f, -0.04322702f, 
    -0.24415237f, -0.06741369f, -0.08556420f, -0.19481491f, -0.05134028f, 0.02407162f, -0.07426202f, -0.15049426f, 
    0.05940064f, 0.06526342f, 0.09511441f, 0.16647874f, 0.14880119f, 0.20526701f, -0.07305743f, -0.14776546f, 
    -0.01361596f, -0.09051003f, -0.02560844f, -0.00850113f, 0.07693899f, 0.03088721f, 0.18061294f, -0.03683106f, 
    -0.18711825f, -0.07686082f, 0.14116217f, 0.30176848f, -0.02713325f, 0.13748004f, -0.06019359f, -0.08941488f, 
    0.05893774f, 0.06581060f, 0.02951131f, -0.01260087f, -0.11941323f, -0.10391397f, -0.01994984f, -0.02696519f, 
    -0.00709643f, -0.07726678f, -0.05684048f, -0.09375760f, 0.13650192f, -0.13325998f, 0.06045624f, -0.04530178f, 
    -0.21028975f, -0.00875940f, 0.01102354f, -0.00053991f, 0.05000630f, -0.09211850f, -0.13285199f, -0.09987842f, 
    0.11191368f, 0.14177619f, 0.03456471f, 0.15507121f, 0.36802906f, -0.13612974f, -0.02634038f, 0.19155465f, 
    0.14140731f, -0.12332218f, 0.16491325f, 0.08587693f, -0.05546341f, 0.13139455f, 0.13002685f, 0.05054827f, 
    0.14318727f, 0.13704726f, -0.16171879f, -0.11856704f, 0.00716224f, -0.00816880f, -0.01642027f, -0.05438677f, 
    0.03570022f, 0.05054980f, 0.07889531f, 0.18217994f, -0.05484849f, 0.07853302f, 0.04866217f, 0.25310656f, 
    -0.01037879f, -0.06114913f, 0.07363541f, 0.04469192f, -0.02547313f, -0.14950126f, -0.02075157f, -0.19691643f, 
    -0.09017062f, 0.42761743f, -0.03740262f, 0.00921216f, -0.06848357f, 0.09511430f, 0.05499732f, -0.02128365f, 
    0.08016498f, 0.10723527f, -0.13101603f, 0.02436868f, 0.28860700f, 0.07001564f, -0.11502581f, 0.00610698f, 
    0.03089022f, 0.10790440f, -0.11419019f, 0.20159753f, 0.08218113f, -0.05212360f, 0.14579216f, 0.14995062f, 
    -0.18092114f, -0.16725695f, 0.02632386f, 0.11351655f, -0.04272259f, 0.01153890f, 0.05636300f, 0.08405532f, 
    -0.06331883f, -0.00903394f, 0.02057166f, 0.15211059f, 0.02086240f, 0.01817988f, 0.05827882f, -0.03543492f, 
    0.05812784f, 0.04646831f, -0.08861892f, -0.00567169f, 0.04942387f, 0.15775789f, 0.10281771f, 0.15166247f, 
    0.30059922f, -0.02125762f, 0.17667991f, -0.09263273f, 0.02170347f, -0.12173509f, -0.07795381f, 0.08092757f, 
    -0.01038283f, 0.05424280f, -0.03704415f, -0.04228071f, 0.03349999f, 0.05523375f, 0.05899926f, 0.01050005f, 
    -0.09330081f, -0.06657552f, -0.07839487f, -0.10057496f, 0.08714478f, -0.01277373f, -0.21684220f, -0.22889134f, 
    -0.16350794f, 0.09877905f, 0.18985498f, 0.32422772f, 0.05376728f, -0.09593084f, 0.06147300f, -0.00234113f, 
    0.09165327f, -0.00863027f, 0.17334709f, 0.00425980f, -0.08015135f, -0.12200614f, 0.07377499f, 0.12755194f, 
    -0.03657240f, 0.03954844f, -0.00035224f, 0.21899733f, -0.02096656f, 0.05382122f, 0.07202215f, 0.05108720f, 
    0.10614614f, 0.50891393f, -0.08771548f, -0.39057955f, 0.01224512f, 0.14405629f, -0.02993717f, -0.02930008f, 
    -0.03291193f, 0.06441773f, -0.02556420f, -0.14708558f, 0.17486557f, 0.12680314f, 0.05039546f, 0.21872187f, 
    -0.14809726f, 0.06255322f, -0.05651925f, 0.06432506f, -0.06664930f, 0.17950487f, 0.10345948f, 0.11193231f, 
    -0.24479795f, 0.34360245f, -0.19758685f, 0.33573923f, -0.04579716f, 0.06426456f, 0.00563658f, -0.05427878f, 
    0.02100796f, -0.05713586f, -0.01775027f, 0.03838247f, -0.03318343f, 0.05472426f, 0.00198370f, 0.02626138f, 
    -0.14243725f, -0.07133433f, 0.08446892f, -0.04156181f, 0.00611834f, 0.12721282f, 0.04338322f, 0.08340196f, 
    -0.19050139f, 0.15740849f, 0.31085768f, 0.03865723f, 0.03144044f, -0.04632093f, -0.01821335f, 0.02524982f, 
    -0.01796993f, 0.07437721f, -0.03417798f, 0.00225109f, 0.23813824f, -0.08589001f, -0.13011561f, 0.06861334f, 
    -0.07205767f, -0.10396106f, 0.00336692f, 0.05769471f, -0.04879681f, 0.01465194f, 0.02259783f, 0.04515323f, 
    -0.31129068f, -0.23717445f, 0.09257533f, 0.23254272f, 0.19678645f, 0.02110497f, 0.05118437f, 0.15226804f, 
    -0.07906468f, 0.04241342f, -0.07237328f, 0.04543404f, -0.26355118f, -0.02151282f, 0.22463964f, 0.04112187f, 
    -0.02194422f, -0.04428069f, -0.00935629f, 0.00859279f, -0.06933168f, 0.03776758f, -0.04321155f, 0.08240268f, 
    -0.05557321f, 0.03379114f, 0.12392431f, 0.28658119f, 0.04278946f, 0.11552621f, -0.00194285f, 0.04291111f, 
    0.09769192f, 0.01163032f, -0.03585187f, 0.01506960f, -0.13341577f, 0.13453275f, 0.21181154f, 0.25502092f, 
    0.04713912f, 0.04531803f, 0.15125716f, 0.02436711f, -0.06491886f, 0.06737106f, 0.06387313f, 0.18306276f, 
    0.27764446f, -0.08791429f, 0.13820951f, 0.03936230f, 0.03343853f, 0.04825099f, 0.04751470f, 0.07240743f, 
    -0.06016133f, 0.05310231f, -0.03898794f, -0.08388302f, 0.00560060f, 0.09088913f, 0.02775796f, -0.20107865f, 
    -0.20714580f, -0.07133517f, 0.02418973f, -0.04336247f, 0.07376453f, 0.01044470f, 0.01049214f, -0.04940228f, 
    0.47641370f, -0.15978681f, -0.19322462f, -0.20819975f, -0.07787418f, -0.01909426f, -0.01487666f, -0.04160419f, 
    -0.07427474f, 0.07810298f, 0.02846974f, -0.01285780f, -0.40168771f, 0.01558993f, -0.06902380f, -0.19223520f, 
    -0.27038360f, -0.04530924f, -0.06592453f, -0.18181936f, 0.01891979f, -0.03097702f, 0.00160039f, 0.01887189f, 
    -0.13356036f, -0.07124388f, -0.20630251f, 0.04463164f, 0.03937308f, 0.05773873f, -0.06746656f, 0.04475156f, 
    0.04568253f, 0.01715333f, -0.02041257f, -0.05798685f, -0.18848193f, -0.01994282f, -0.11617027f, 0.32384861f, 
    0.01332114f, -0.03913523f, 0.08528455f, -0.01411450f, 0.00113272f, -0.10870576f, -0.02403321f, -0.05500200f, 
    -0.17392370f, -0.11401704f, -0.11986519f, -0.18223418f, -0.05103801f, -0.04009774f, -0.05843233f, -0.06641271f, 
    -0.06119999f, -0.03585560f, -0.04042729f, -0.02675388f, -0.13800301f, 0.17702225f, -0.17056699f, -0.11634571f, 
    -0.11642604f, -0.13655442f, -0.00080045f, -0.06945298f, -0.01423251f, 0.05582308f, 0.05303525f, 0.04816756f, 
    -0.21504161f, -0.14134444f, -0.13077970f, 0.10383682f, 0.01658966f, 0.01883864f, -0.01693686f, -0.10436905f, 
    -0.00556913f, 0.04184385f, 0.01632964f, 0.02540009f, 0.20149605f, 0.12342694f, 0.10947344f, -0.02985834f, 
    0.08870707f, 0.02191840f, 0.07598017f, 0.09644677f, -0.08154667f, 0.12771207f, -0.04533688f, 0.08301508f, 
    -0.20199998f, 0.06696106f, -0.07556138f, -0.19973430f, -0.14020811f, -0.15226737f, -0.05994205f, -0.08890812f, 
    0.07764306f, -0.08826803f, -0.00219501f, -0.06578950f, 0.29244781f, 0.32998154f, -0.24108900f, -0.25476506f, 
    0.04992786f, 0.02144735f, 0.11773419f, -0.02666414f, -0.13787693f, -0.02639554f, -0.03647819f, 0.08998864f, 
    0.33258519f, 0.48139060f, -0.05969383f, -0.40922359f, -0.01527983f, 0.18036009f, 0.02266089f, -0.00797158f, 
    -0.00420860f, 0.13940300f, 0.07296528f, 0.13815781f, -0.10596852f, 0.13402028f, 0.13510330f, 0.05551562f, 
    -0.11087495f, 0.00408439f, 0.04025069f, 0.01194526f, 0.01545910f, 0.03962713f, -0.10397328f, 0.04047681f, 
    -0.13687451f, 0.19391799f, -0.11698689f, 0.15278424f, 0.04009475f, 0.13648085f, 0.00872116f, -0.04300706f, 
    -0.05292162f, 0.03132555f, 0.13103031f, 0.10875633f, 0.29804918f, -0.10831694f, 0.05531514f, -0.21323825f, 
    -0.01578949f, 0.13768081f, 0.02302219f, 0.08633884f, 0.07307184f, 0.12543146f, -0.06429844f, -0.02409393f, 
    -0.05346775f, 0.08891930f, 0.06009330f, 0.14456213f, 0.04088030f, 0.07958772f, 0.01592495f, 0.13565882f, 
    0.03367082f, 0.12083703f, 0.01728915f, 0.13112590f, -0.04486639f, -0.03026270f, 0.04324843f, -0.04436617f, 
    -0.05966384f, 0.06341881f, 0.08700880f, -0.18934388f, -0.00278246f, 0.03800954f, 0.03166914f, 0.04691908f, 
    0.31835085f, -0.20743328f, 0.07628643f, 0.00923964f, 0.05576698f, 0.03042298f, -0.01893465f, -0.08493157f, 
    0.06266624f, -0.00409825f, 0.11065236f, 0.09246593f, 0.00405095f, 0.17010249f, 0.11973218f, -0.07719734f, 
    -0.09234554f, -0.10804057f, -0.10572175f, -0.10338985f, 0.09740570f, 0.18018757f, 0.00535879f, 0.11399536f, 
    0.19435994f, -0.09067380f, 0.21422164f, 0.19238231f, -0.03723128f, 0.00592643f, 0.02519283f, 0.15437227f, 
    -0.03823219f, 0.00661901f, -0.03334380f, 0.03389069f, 0.10197201f, 0.11213564f, 0.15192860f, 0.03824978f, 
    -0.03337626f, 0.11428177f, -0.02248866f, 0.07330413f, -0.07908378f, 0.07297332f, -0.01845424f, 0.12992908f, 
    0.02677643f, -0.04055348f, 0.20573120f, -0.11998398f, 0.11230857f, 0.11432247f, -0.00235487f, 0.05752780f, 
    0.20412926f, -0.09116954f, 0.05397353f, -0.05289523f, 0.03337619f, -0.18219543f, 0.35877472f, -0.02357399f, 
    -0.03119147f, -0.05846142f, -0.03648268f, 0.10117333f, -0.12980066f, 0.23987934f, -0.02791224f, -0.11189010f, 
    0.07239749f, 0.30700597f, 0.00620338f, 0.00966674f, -0.16377281f, -0.12343374f, 0.00814528f, 0.04069827f, 
    0.01036859f, -0.07988663f, -0.03829083f, -0.09453536f, 0.06791498f, 0.02792473f, -0.04622900f, 0.02742530f, 
    0.00001941f, 0.09473403f, -0.07184551f, -0.11066147f, -0.11323432f, -0.07205813f, -0.08497477f, -0.03743671f, 
    0.17622598f, -0.16236211f, -0.10490399f, 0.22144225f, -0.01957568f, 0.08814146f, -0.08149482f, 0.15008335f, 
    -0.15567298f, 0.07607329f, -0.02819405f, 0.06732745f, 0.23773877f, 0.19340633f, 0.04962777f, -0.11097600f, 
    -0.00625061f, -0.08018270f, 0.12143004f, -0.07175203f, 0.05567015f, 0.01297877f, 0.09262813f, -0.08683552f, 
    -0.20986651f, -0.11098136f, 0.38431272f, 0.00249939f, -0.02426628f, 0.02900281f, -0.09399331f, -0.08704967f, 
    -0.02523399f, -0.01913268f, -0.06645967f, -0.05693771f, 0.13731486f, -0.06016612f, 0.76563919f, 0.02894973f, 
    0.02853603f, -0.08015587f, -0.10511389f, -0.15853196f, -0.17154530f, -0.01451489f, 0.02056578f, -0.00871860f, 
    -0.12034080f, 0.00371641f, -0.14747176f, 0.08197875f, 0.06278648f, 0.01106959f, 0.11382697f, -0.01102128f, 
    -0.04517300f, -0.10975817f, -0.03473989f, 0.02093056f, 0.09030224f, 0.08467421f, 0.02631425f, 0.37898931f, 
    -0.03451996f, 0.05725986f, 0.03277738f, 0.08923095f, -0.10145656f, 0.01066247f, -0.01812600f, 0.03002144f, 
    0.29286420f, 0.07312330f, -0.27688450f, 0.09480896f, -0.02981390f, 0.01805843f, 0.07284539f, 0.08785243f, 
    -0.11863738f, -0.02418435f, -0.10341086f, -0.18792365f, 0.02105221f, 0.07698537f, -0.06471255f, 0.15048324f, 
    -0.08545029f, 0.01812036f, 0.05572451f, 0.01054021f, -0.05127591f, 0.06318907f, 0.05385437f, 0.02166436f, 
    -0.15308847f, 0.11670179f, -0.06501795f, -0.19928716f, 0.06976134f, 0.15503027f, 0.05714212f, 0.00840182f, 
    0.09258503f, 0.10649049f, 0.11150000f, -0.01177758f, -0.10916168f, 0.25584877f, 0.04532059f, 0.03563408f, 
    -0.00501493f, -0.04478711f, 0.08572360f, 0.02476728f, -0.05615906f, 0.05234917f, 0.05820869f, -0.04657196f, 
    0.00799993f, 0.12994316f, -0.09731489f, -0.08842126f, 0.14148825f, -0.00477646f, -0.08979065f, -0.03177966f, 
    0.07613490f, 0.09654668f, 0.18196900f, 0.09958813f, 0.02272242f, 0.10485244f, -0.11079648f, 0.12590820f, 
    -0.04399738f, -0.11197522f, -0.04981582f, -0.15611401f, -0.00963723f, -0.00547420f, 0.00689144f, -0.08414550f, 
    -0.04472153f, 0.05227889f, -0.03368784f, 0.08294713f, -0.06068667f, 0.10207182f, -0.01891667f, 0.01031108f, 
    0.06190174f, 0.19222240f, 0.11016361f, 0.13501419f, 0.06098343f, 0.21267639f, 0.00065138f, -0.00984669f, 
    0.05305722f, 0.06580445f, -0.01717586f, 0.02906089f, -0.01876080f, 0.00670758f, 0.01897264f, 0.09934663f, 
    0.05822185f, 0.00425665f, 0.10252143f, -0.12506558f, 0.12810662f, -0.07148609f, -0.03470636f, -0.03389027f, 
    0.00757838f, -0.07758808f, 0.13432552f, 0.09468020f, -0.13276070f, -0.04077434f, -0.16621347f, 0.15404978f, 
    -0.05582989f, -0.06408099f, 0.03241307f, 0.05560676f, -0.10458391f, -0.03435327f, -0.03632752f, -0.06246725f, 
    -0.01820163f, 0.03020488f, 0.10210939f, 0.01422429f, -0.03357843f, 0.09954655f, 0.04547494f, 0.02825266f, 
    -0.03589667f, 0.06685049f, -0.01295762f, 0.09044769f, -0.15382168f, 0.31705302f, -0.11524593f, -0.02313390f, 
    0.18495104f, -0.10602359f, 0.02022866f, -0.04892800f, -0.09963159f, -0.13178103f, -0.00780847f, 0.07080412f, 
    -0.08679017f, 0.04023207f, -0.26935861f, 0.01569721f, -0.03493019f, 0.05194996f, 0.08588865f, 0.03148068f, 
    0.05872506f, -0.08084482f, -0.17589220f, 0.10186291f, 0.00939193f, 0.12205428f, 0.13324034f, -0.04963602f, 
    -0.05248457f, -0.00823094f, 0.01062594f, 0.01350614f, 0.13108873f, 0.06237505f, -0.09023489f, 0.00970415f, 
    0.17749199f, -0.08799626f, 0.09650576f, 0.14379886f, -0.09359284f, -0.02439523f, 0.05240707f, -0.19655213f, 
    0.22616336f, 0.08578542f, 0.05967051f, 0.01758197f, 0.01595611f, -0.02639917f, -0.02454020f, -0.15110818f, 
    -0.10291734f, 0.16265735f, -0.02239756f, 0.11944962f, 0.26092803f, 0.02913020f, 0.02890743f, -0.04744210f, 
    -0.19327091f, 0.02327745f, -0.08795907f, 0.18420200f, 0.19076374f, 0.28685319f, 0.06055836f, 0.07619614f, 
    -0.15131295f, -0.02499562f, -0.06887910f, -0.02140545f, 0.09573536f, -0.00148286f, 0.11262519f, 0.03192267f, 
    0.08240078f, 0.06308877f, -0.01362117f, 0.02921294f, -0.03850585f, 0.03809483f, 0.02089141f, -0.04473108f, 
    0.23893155f, 0.00547053f, -0.00146761f, -0.06386150f, 0.00363628f, -0.01785132f, -0.00370116f, 0.00995889f, 
    0.13354053f, -0.00630293f, -0.01279995f, -0.04941630f, -0.07961003f, 0.01557374f, -0.01790696f, 0.03498920f, 
    -0.02948624f, 0.04123859f, -0.03234134f, 0.03266243f, -0.06224992f, 0.14218825f, -0.08693035f, 0.14181580f, 
    -0.00558616f, 0.02616411f, -0.01003238f, -0.05534153f, -0.00093308f, -0.02971781f, 0.02759248f, 0.01395002f, 
    0.02775377f, 0.04260746f, -0.01207457f, -0.02095903f, -0.05773274f, -0.01769937f, -0.03282483f, 0.01211375f, 
    -0.01006988f, 0.02633990f, -0.01930661f, 0.02478679f, -0.03424879f, 0.00476300f, 0.01341016f, -0.05461870f, 
    -0.00398803f, 0.00517548f, -0.04881020f, 0.04585949f, 0.03926696f, 0.03228002f, 0.02675483f, -0.04708265f, 
    -0.04913436f, -0.04793674f, 0.04431673f, 0.00104960f, -0.03824911f, 0.02198959f, -0.02097981f, 0.02518961f, 
    -0.01111712f, -0.05207973f, -0.00657164f, 0.00045169f, -0.01774564f, -0.01795859f, -0.00637117f, -0.01686221f, 
    -0.02029739f, -0.02871087f, -0.03989666f, -0.00122029f, 0.04025671f, -0.04675487f, -0.04328045f, -0.01284472f, 
    -0.01085859f, 0.03120959f, -0.00468573f, 0.01642596f, -0.02377021f, -0.04672394f, 0.00257908f, 0.00443163f, 
    -0.04857472f, -0.00132399f, -0.01681099f, -0.05449652f, -0.03109831f, 0.01407321f, 0.04227933f, 0.01436768f, 
    0.01265602f, -0.03227817f, -0.05737818f, -0.00179813f, -0.01908724f, -0.03334621f, -0.03677833f, -0.01725340f, 
    -0.00877221f, -0.03206076f, -0.01171650f, 0.00888488f, 0.03410602f, -0.01056334f, -0.00864257f, 0.00170264f, 
    0.02917534f, 0.00873628f, 0.02047098f, -0.01418373f, 0.02893103f, 0.03632409f, -0.02238514f, 0.01887687f, 
    0.02135312f, 0.01771885f, -0.03027866f, -0.00072943f, -0.03444801f, -0.01944723f, -0.01807741f, 0.00961540f, 
    -0.01535110f, 0.02201315f, -0.00733393f, 0.02463692f, -0.02177868f, 0.00402245f, 0.03487911f, 0.03066176f, 
    -0.05486384f, -0.02094252f, -0.02393618f, 0.02725086f, 0.00469505f, 0.02489778f, 0.00487680f, -0.02795788f, 
    -0.02570922f, 0.00906138f, 0.03867132f, 0.01488722f, 0.01215794f, -0.05522033f, -0.03041866f, -0.04172507f, 
    0.01351081f, 0.00430325f, 0.00594968f, -0.04976569f, 0.02884676f, 0.01628160f, 0.00968800f, -0.00161339f, 
    0.03110132f, -0.05452954f, 0.01160556f, -0.00535860f, -0.02327227f, -0.04928860f, -0.00245055f, 0.02142966f, 
    -0.00279922f, -0.02719800f, 0.02650031f, -0.04010190f, -0.01476501f, 0.03091146f, 0.01325587f, -0.04122508f, 
    0.03107631f, 0.01361867f, -0.03661436f, -0.00417357f, 0.04161859f, 0.00464570f, 0.03056574f, 0.03118708f, 
    0.01286667f, -0.00299672f, -0.03824275f, -0.03517255f, -0.00931678f, -0.04348369f, -0.00151481f, -0.04798989f, 
    -0.03140073f, 0.03020043f, -0.05049499f, -0.05214588f, 0.02397052f, -0.01024628f, -0.05439945f, 0.03928097f, 
    0.01241286f, 0.00288093f, -0.05134453f, -0.01879984f, 0.01371041f, -0.00002704f, 0.03907594f, 0.05008801f, 
    0.05077041f, -0.03075223f, 0.03935514f, 0.02910263f, 0.01934379f, 0.02543793f, -0.04923819f, -0.01326908f, 
    0.02336654f, -0.02742873f, 0.00038779f, -0.02228572f, -0.02258641f, 0.00218178f, 0.00115174f, -0.01213561f, 
    -0.04103337f, 0.01737062f, -0.02061084f, -0.02871730f, -0.05764670f, -0.03319260f, -0.01265920f, -0.05514117f, 
    -0.00314503f, -0.04076520f, -0.05183586f, -0.05568427f, 0.01466793f, 0.00104949f, 0.03176643f, 0.03911213f, 
    -0.00266232f, 0.04417939f, 0.02948526f, 0.01621250f, -0.02200189f, 0.03489213f, 0.03655526f, 0.03744419f, 
    0.01908522f, 0.03236415f, 0.00874721f, -0.00153428f, -0.01233001f, 0.04658105f, 0.03268585f, -0.01902475f, 
    -0.00953069f, -0.00890187f, -0.04993292f, -0.03391533f, 0.03487225f, 0.02370951f, -0.02407471f, -0.00968538f, 
    0.02927923f, 0.00754802f, -0.01468922f, 0.02095589f, -0.04611465f, 0.03028018f, 0.00310546f, 0.00451791f, 
    -0.03298470f, 0.02539508f, 0.02480120f, -0.01290731f, -0.01594093f, -0.03343505f, -0.04700950f, 0.04384649f, 
    0.04256362f, 0.03645349f, -0.01224384f, 0.04125448f, -0.05384959f, -0.00872668f, -0.05094756f, 0.03807978f, 
    -0.03474005f, -0.01960477f, 0.02570224f, -0.03153133f, 0.03194248f, -0.03733841f, -0.05027783f, 0.00093226f, 
    0.02781440f, 0.04676281f, 0.00638448f, 0.04100917f, 0.03311130f, -0.01862078f, 0.00008972f, -0.04302224f, 
    -0.00917779f, -0.02489639f, -0.02984956f, 0.03646285f, 0.00102655f, -0.05387749f, 0.04293422f, 0.00516066f, 
    0.02395020f, -0.04166668f, -0.05885361f, -0.04475935f, -0.03494804f, -0.05035766f, 0.00247136f, -0.00723243f, 
    0.01558378f, -0.01266349f, 0.03667065f, -0.00147574f, -0.03262608f, 0.03456430f, 0.02204075f, -0.01041548f, 
    -0.01280423f, -0.00573580f, -0.04797240f, -0.00404292f, -0.00234411f, -0.05703733f, 0.03309527f, -0.04011960f, 
    -0.03945947f, -0.05545506f, -0.01720067f, -0.04056400f, -0.04482853f, 0.04038500f, -0.00480914f, -0.05222624f, 
    0.03537950f, 0.04008083f, 0.02605172f, -0.00905951f, -0.03085305f, -0.03901548f, -0.05167720f, 0.04047388f, 
    0.00637361f, -0.04048553f, -0.01612156f, 0.03746264f, -0.04892437f, -0.03022687f, -0.05074714f, 0.01809978f, 
    -0.00596009f, -0.04308077f, 0.00127154f, -0.03062416f, -0.00015411f, -0.04994396f, 0.02314200f, -0.03903365f, 
    -0.04843872f, 0.01214852f, -0.04375681f, 0.00269325f, -0.03568310f, -0.03994647f, -0.01680053f, -0.02556323f, 
    -0.00987702f, -0.05093656f, 0.02652448f, 0.01272784f, -0.05655172f, -0.00816487f, -0.01265102f, -0.03686052f, 
    0.00486661f, -0.02698211f, 0.03885429f, -0.01742001f, -0.03214953f, -0.00910458f, -0.01231355f, -0.00809179f, 
    0.03398449f, 0.00023612f, 0.00202162f, 0.02636384f, 0.04317893f, -0.01802854f, -0.03188161f, -0.04361922f, 
    -0.03158477f, 0.03110531f, -0.00055327f, -0.00475479f, -0.03203949f, 0.02545791f, 0.02762790f, 0.03185056f, 
    -0.04096701f, 0.01495396f, 0.01664615f, -0.03099762f, -0.02707112f, 0.00775925f, -0.01144851f, -0.02795494f, 
    0.00401759f, -0.02797169f, 0.00560000f, -0.03826848f, -0.04175797f, -0.01378823f, 0.00407557f, 0.02258526f, 
    0.00534635f, -0.01944900f, -0.01335636f, -0.04304545f, -0.02200252f, -0.04495800f, 0.03579605f, 0.01372242f, 
    0.03197607f, -0.02976961f, -0.02815527f, -0.01293625f, 0.01004461f, -0.01610137f, -0.00333209f, -0.02110598f, 
    -0.02369396f, 0.02673582f, -0.04758503f, 0.01543120f, 0.01920083f, -0.02354151f, -0.01951371f, 0.03744479f, 
    0.00205225f, 0.02562293f, -0.03210957f, -0.01984923f, 0.00150494f, -0.03016021f, 0.00512765f, 0.02758217f, 
    0.01094582f, 0.04734920f, 0.02132656f, -0.04317930f, -0.04669588f, 0.03330516f, -0.01518745f, -0.02663699f, 
    -0.02956195f, 0.00458947f, -0.04382389f, -0.02241417f, -0.01186881f, -0.02963273f, 0.02017749f, 0.00356458f, 
    -0.01724048f, -0.00927440f, -0.00024026f, -0.04566203f, 0.04293888f, -0.01545252f, 0.03439192f, -0.04530331f, 
    0.02973392f, -0.01635632f, 0.00021916f, -0.00492097f, 0.00120807f, 0.00021823f, -0.01091739f, -0.02604774f, 
    0.02934451f, -0.04662948f, 0.01361706f, -0.02779873f, 0.04818676f, -0.03043221f, -0.04807356f, -0.04872314f, 
    0.01163312f, -0.03759952f, -0.04765716f, 0.04587957f, -0.00383505f, 0.00188091f, 0.01605331f, 0.04036091f, 
    -0.04180942f, -0.03010718f, 0.03230723f, -0.03464963f, -0.01118227f, -0.01271241f, -0.02225663f, -0.01018848f, 
    -0.01866086f, -0.01666942f, 0.03425123f, -0.05066977f, -0.04280490f, -0.04100439f, 0.03344838f, 0.01029832f, 
    -0.03429724f, 0.03007523f, 0.02432702f, 0.00716656f, 0.01377519f, -0.01040362f, 0.02569641f, 0.00837533f, 
    0.04212125f, -0.00443724f, -0.03597613f, -0.04300836f, -0.00232162f, -0.03898973f, -0.04252980f, -0.03912690f, 
    -0.01867849f, -0.01261402f, -0.03330821f, -0.01280492f, 0.00475963f, 0.04588747f, -0.03814668f, -0.03849473f, 
    -0.00887679f, -0.04169035f, 0.04399195f, -0.00928065f, -0.03252984f, -0.04564676f, -0.03142947f, -0.03273271f, 
    0.00416005f, -0.03774098f, -0.04176127f, 0.04535714f, -0.01944226f, 0.02542189f, 0.00550277f, 0.02445087f, 
    0.02161887f, -0.04678295f, -0.02094864f, 0.01738516f, -0.04220878f, -0.04475652f, 0.03778757f, 0.02789493f, 
    -0.02490506f, -0.03964811f, 0.04491637f, -0.03625289f, -0.04878739f, 0.01742593f, 0.01116231f, -0.00436365f, 
    -0.00048797f, 0.05083431f, 0.00801416f, 0.01530265f, -0.04695266f, 0.01926757f, 0.01425144f, 0.00403560f, 
    -0.00739002f, 0.04381036f, -0.00700849f, -0.01954690f, 0.00637958f, 0.01776178f, 0.03032570f, 0.04083455f, 
    0.04255097f, -0.01285081f, -0.03687987f, -0.01811992f, 0.01387173f, -0.01497798f, -0.03275625f, 0.02610872f, 
    0.01687113f, 0.00845733f, -0.04950965f, -0.02387237f, 0.01461450f, 0.01904078f, 0.00261230f, 0.02232783f, 
    0.02529498f, 0.00453589f, -0.02321215f, -0.04751909f, -0.02419293f, 0.00851976f, -0.01434123f, -0.02995404f, 
    -0.00055149f, -0.03035387f, -0.02157190f, -0.02478944f, -0.05081106f, 0.00536591f, 0.03572115f, 0.03252359f, 
    0.00779635f, -0.03563190f, 0.01496646f, -0.05088254f, -0.03108506f, -0.01832912f, 0.03121880f, 0.04841700f, 
    -0.04102876f, 0.02453875f, 0.03011359f, -0.01192364f, 0.02996455f, 0.01175765f, -0.04827597f, 0.04248340f, 
    0.01026525f, -0.01799190f, 0.04159215f, -0.00218587f, -0.03667999f, 0.04202637f, -0.01271439f, -0.04462055f, 
    -0.00273777f, -0.00067153f, 0.04298655f, -0.01146498f, 0.04185016f, -0.02443925f, -0.04403070f, 0.04150547f, 
    -0.00630966f, -0.00396700f, 0.03583260f, 0.01064017f, 0.01613781f, 0.03094734f, -0.03237949f, -0.04746403f, 
    0.03008065f, 0.00314160f, 0.04618399f, 0.01966381f, 0.03127394f, -0.00447952f, 0.01104245f, -0.03604746f, 
    -0.01127361f, -0.00853910f, -0.04291486f, -0.02894865f, -0.04447405f, -0.00185978f, -0.02637343f, 0.01879809f, 
    -0.01914367f, 0.02458928f, 0.04405531f, -0.05061416f, -0.00803496f, -0.02142435f, 0.02922853f, 0.00344532f, 
    0.00518024f, 0.02612204f, -0.01137908f, 0.02118975f, 0.00526191f, -0.00742307f, -0.01926292f, -0.03310179f, 
    -0.02051925f, 0.04300781f, -0.03417666f, 0.01701088f, -0.02472850f, -0.01111712f, 0.02199246f, -0.00023287f, 
    -0.04234538f, -0.00499410f, -0.02467093f, -0.01828901f, 0.01120463f, -0.03447450f, 0.02183046f, -0.01379647f, 
    -0.01645746f, 0.00311637f, -0.00604995f, 0.00302302f, -0.02399796f, -0.02465020f, 0.04368334f, 0.04115042f, 
    0.00213143f, 0.01652921f, -0.03067242f, 0.01816065f, -0.04623777f, -0.01765240f, 0.03682107f, 0.01313517f, 
    0.00231072f, -0.04500086f, -0.00260236f, -0.04068414f, 0.01296934f, -0.04125271f, -0.01477414f, 0.03147946f, 
    0.04116436f, 0.02995422f, -0.01829574f, 0.04046208f, -0.02308269f, -0.02796927f, 0.02965513f, 0.00536599f, 
    0.03223003f, 0.01943388f, -0.01425107f, -0.02514387f, -0.01407603f, -0.00721491f, 0.04532542f, 0.03882004f, 
    0.02782058f, -0.04978983f, 0.01961215f, 0.03652137f, -0.03139085f, 0.03861288f, 0.02759805f, -0.00415810f, 
    -0.04268348f, -0.04895599f, 0.02262387f, -0.04122780f, -0.02490048f, -0.00347771f, 0.04101291f, -0.00075074f, 
    0.00393001f, 0.04802658f, -0.02417780f, -0.02018971f, 0.00400168f, -0.01911563f, -0.01472933f, -0.02883169f, 
    -0.03968946f, -0.04200518f, -0.03431364f, -0.00591906f, -0.00807090f, -0.04752285f, -0.04001149f, 0.02141741f, 
    -0.04370095f, 0.04874261f, 0.00677308f, 0.00570860f, -0.03686464f, 0.01143303f, 0.02038533f, 0.00197116f, 
    -0.06626464f, -0.18122220f, -0.14482969f, -0.23523076f, 0.15460917f, -0.13114969f, 0.12491597f, 0.26504233f, 
    -0.09985676f, -0.00189684f, -0.01375846f, 0.09766272f, -0.14866067f, 0.02198439f, 0.01213400f, 0.06704787f, 
    0.05639575f, -0.11217988f, 0.09343293f, 0.11923283f, -0.02560293f, 0.04372624f, 0.01751942f, 0.03636370f, 
    -0.17703399f, -0.03526182f, -0.22972819f, 0.02267375f, 0.02539196f, 0.03247929f, 0.02675911f, -0.35143578f, 
    0.04537811f, 0.02613397f, -0.04280949f, -0.08891224f, 0.02096045f, 0.16490452f, 0.06523046f, -0.03590976f, 
    0.04150365f, -0.08218338f, 0.01937291f, -0.07395707f, 0.14256445f, -0.02111096f, 0.15615207f, -0.09427346f, 
    -0.09733847f, -0.09636478f, 0.06701905f, -0.14351015f, 0.07210166f, 0.06524828f, -0.00699908f, 0.15754229f, 
    -0.02591155f, -0.01119840f, 0.02192564f, 0.01956404f, -0.19060047f, -0.00495330f, -0.06430893f, -0.01819490f, 
    0.10082952f, 0.13090977f, 0.00177733f, 0.07985903f, -0.03418303f, -0.09361238f, 0.02680086f, -0.07588777f, 
    0.16466612f, -0.03821439f, -0.09796459f, 0.04326231f, 0.06099479f, 0.04885759f, 0.02548385f, 0.11105175f, 
    -0.00584982f, -0.07249064f, -0.08078512f, -0.05398063f, -0.19866450f, -0.04307401f, -0.06741931f, -0.19792730f, 
    0.09131476f, -0.09467744f, -0.05213162f, 0.02800625f, 0.10997781f, 0.01595265f, 0.09711733f, -0.06089975f, 
    -0.02313492f, 0.14443773f, -0.14817584f, -0.15142512f, 0.04623187f, 0.02968462f, 0.08429337f, 0.10069242f, 
    0.10934298f, 0.05935648f, 0.03329805f, -0.03334130f, 0.19193192f, 0.38267827f, 0.30510789f, 0.20539153f, 
    0.06609080f, 0.11088204f, 0.00686998f, 0.01311842f, 0.01631576f, -0.09830040f, 0.00740636f, 0.00111342f, 
    0.16447020f, -0.11173884f, -0.03033575f, -0.32210037f, -0.07799589f, -0.10227880f, -0.06441268f, -0.04453913f, 
    0.03403717f, -0.01942067f, 0.08442504f, 0.00779373f, 0.08912288f, -0.28729168f, -0.06109934f, -0.11424887f, 
    -0.05409918f, 0.05657684f, -0.18511066f, 0.21243908f, -0.09720510f, 0.06615663f, 0.12546517f, 0.03230214f, 
    0.00976956f, -0.19999187f, -0.33805028f, -0.14294831f, -0.06217015f, -0.22391866f, -0.14401978f, -0.12374327f, 
    0.04136128f, 0.00540782f, 0.10903362f, 0.05577523f, 0.15473031f, 0.09354238f, 0.15221933f, 0.26529783f, 
    0.02821746f, 0.06500950f, -0.05072916f, -0.09795541f, -0.01090002f, 0.00988590f, 0.00953761f, -0.03519738f, 
    -0.26157597f, 0.19327089f, -0.07182582f, 0.16321491f, -0.04139598f, 0.02865099f, -0.06397082f, -0.02592017f, 
    0.04192968f, 0.14522351f, -0.07684334f, 0.10455417f, 0.29567361f, 0.10078930f, 0.03894321f, -0.05108213f, 
    0.05059675f, 0.04389564f, -0.09817875f, 0.01476100f, 0.05497624f, -0.01330801f, -0.03425555f, -0.03443892f, 
    0.16220233f, -0.16706635f, 0.01558342f, 0.04256477f, 0.02803192f, -0.18235065f, -0.02619207f, -0.05153156f, 
    0.15963298f, 0.00641374f, 0.07261311f, 0.09479459f, -0.01724110f, -0.06974860f, -0.00165977f, -0.31198665f, 
    -0.18099253f, -0.13512351f, -0.01532881f, -0.00595180f, 0.13731652f, 0.09469232f, 0.02964643f, 0.18398307f, 
    0.10217407f, -0.03768961f, 0.09363674f, -0.12064119f, -0.01794400f, -0.02512875f, -0.02810292f, -0.12407847f, 
    0.01301581f, 0.02759284f, 0.08533634f, -0.05847302f, 0.09558138f, 0.04881787f, 0.13247378f, 0.07886624f, 
    0.05414830f, 0.04356601f, -0.06285193f, -0.11727899f, -0.01286236f, -0.03465772f, -0.07137555f, -0.10279964f, 
    -0.04655610f, -0.04984437f, -0.05768941f, 0.07955477f, -0.02113013f, 0.06192072f, 0.06364136f, 0.07550829f, 
    0.07913920f, 0.10517295f, 0.00651952f, 0.08086886f, 0.27454680f, 0.09529433f, -0.05267946f, 0.11240601f, 
    -0.03799622f, -0.01559164f, -0.12619393f, -0.03656060f, -0.09019236f, -0.09535689f, 0.04455357f, -0.00185033f, 
    0.15252101f, 0.08188502f, 0.06116604f, 0.02928060f, 0.05811175f, 0.06160168f, -0.02040206f, -0.01166701f, 
    -0.03728367f, -0.02609398f, -0.05520298f, -0.04054080f, -0.07608593f, -0.02618428f, 0.17029274f, 0.09161206f, 
    0.04386411f, -0.00013859f, 0.00902523f, -0.01320084f, 0.09135319f, 0.04883088f, -0.08208691f, -0.10373576f, 
    0.02935285f, 0.09996036f, 0.11754689f, 0.13396609f, -0.04138336f, -0.06172460f, -0.10853869f, -0.04531593f, 
    -0.12330923f, -0.15133199f, -0.03517083f, -0.09837846f, 0.05253670f, 0.00793033f, 0.01860270f, 0.20727496f, 
    0.01630630f, 0.01298623f, 0.13262278f, 0.08290767f, 0.01423260f, 0.11599752f, 0.07566477f, -0.03678243f, 
    -0.26093480f, 0.10816303f, 0.20207450f, -0.08344509f, 0.20977879f, 0.12822652f, -0.06189050f, -0.01805968f, 
    0.01031470f, 0.04646701f, 0.04904839f, -0.06399696f, -0.14939977f, 0.11297774f, 0.17432080f, 0.27775103f, 
    0.01210392f, -0.09184013f, -0.14017633f, -0.04373357f, -0.03832587f, 0.03405278f, -0.06462470f, 0.12078447f, 
    -0.15005776f, 0.02563216f, 0.07409447f, -0.29508284f, -0.04657348f, -0.19528794f, 0.05024318f, -0.03057873f, 
    -0.05770119f, -0.03913310f, -0.04086705f, 0.02225231f, -0.09523523f, 0.02976329f, -0.07089988f, -0.06169791f, 
    0.14216390f, -0.04517408f, 0.05852968f, -0.23728481f, -0.11598492f, 0.00739646f, -0.01220739f, -0.05858606f, 
    -0.21759944f, 0.01993818f, 0.05447914f, -0.09547570f, 0.03652166f, -0.12682068f, 0.13813849f, 0.05871610f, 
    0.03805761f, -0.00453669f, 0.07440854f, 0.00390756f, 0.16391714f, 0.06660288f, 0.17760172f, 0.11487654f, 
    0.05989848f, 0.07722516f, 0.05547138f, -0.06275379f, 0.15187638f, 0.05546998f, 0.22088507f, 0.10967474f, 
    0.18241265f, 0.03958452f, -0.06821749f, -0.01151164f, 0.01752987f, 0.00151594f, 0.04580269f, 0.20193644f, 
    -0.06016063f, 0.05806455f, -0.00294929f, -0.06018513f, 0.30598471f, 0.08955100f, 0.18286745f, 0.17921753f, 
    0.14897166f, 0.02053828f, 0.22272770f, 0.11149944f, -0.08331656f, -0.01413243f, -0.03279814f, -0.15327267f, 
    -0.04997550f, -0.41530773f, 0.04759318f, 0.07369965f, -0.01008714f, 0.05400498f, -0.17617185f, -0.06012946f, 
    -0.02959409f, -0.07606749f, 0.03987736f, -0.00826948f, -0.35437247f, -0.23188736f, -0.44825333f, -0.07312810f, 
    0.13685641f, -0.04282867f, -0.03701257f, -0.00686653f, 0.09475703f, -0.15730996f, 0.08223058f, 0.05397096f, 
    0.24852233f, -0.19930084f, 0.47742271f, -0.11297899f, -0.09317366f, 0.01385087f, -0.14150438f, 0.09824251f, 
    0.03754392f, 0.11650927f, -0.12648724f, 0.12136529f, 0.01749158f, 0.04703312f, 0.18231188f, -0.16087303f, 
    0.14876662f, 0.07820275f, -0.07422758f, 0.04090242f, 0.02186033f, -0.17445907f, -0.06308928f, -0.14452219f, 
    0.12422408f, -0.07874157f, -0.01535003f, -0.27855915f, 0.05765481f, 0.02075319f, -0.03518423f, 0.05329630f, 
    0.11219030f, -0.03306948f, 0.01047270f, -0.12162541f, -0.19193849f, -0.07205541f, 0.02955310f, -0.18041079f, 
    0.01433175f, -0.08392165f, -0.11661617f, 0.04476614f, -0.00835447f, 0.03961151f, 0.09510110f, 0.16972725f, 
    0.29649568f, 0.38392806f, 0.17721221f, 0.03979935f, 0.01835098f, 0.08562752f, 0.11508539f, 0.16976938f, 
    0.10382295f, -0.12886016f, -0.00238261f, -0.04549912f, -0.17757130f, 0.36146379f, 0.10983579f, 0.18408661f, 
    0.02444884f, -0.01868154f, 0.02734708f, 0.03427491f, 0.15383297f, -0.01298526f, 0.12162377f, -0.05585922f, 
    -0.20588198f, -0.12956207f, -0.05542286f, -0.19536859f, -0.03412667f, -0.03758883f, 0.04871511f, -0.05522304f, 
    -0.01893223f, 0.05465760f, -0.03318330f, 0.02046264f, 0.08685151f, -0.06884991f, 0.03986269f, 0.05799306f, 
    -0.02558556f, 0.01473038f, -0.10269001f, 0.04357777f, -0.11084846f, -0.02970040f, -0.08689803f, -0.04698244f, 
    -0.04402838f, -0.03942675f, -0.09170789f, 0.14585614f, 0.15109852f, -0.03527241f, 0.03019486f, 0.06606412f, 
    0.03892798f, -0.12797888f, 0.05172985f, 0.08361120f, -0.27976826f, -0.23400895f, -0.07236136f, 0.08237584f, 
    -0.00313694f, 0.10513720f, 0.00197173f, 0.08185539f, -0.00277524f, 0.10972852f, -0.09758532f, 0.09584533f, 
    -0.31747633f, 0.11019079f, -0.02802194f, -0.12159471f, -0.13020848f, 0.06838679f, -0.01501318f, -0.12104145f, 
    -0.02552581f, -0.03506843f, 0.01972381f, 0.19911800f, 0.17446262f, -0.38114023f, -0.07500025f, 0.03956851f, 
    0.05823885f, -0.03651439f, -0.14257452f, 0.06752440f, -0.10669820f, -0.00309403f, -0.00971095f, -0.04711834f, 
    0.12367956f, -0.06635762f, 0.08945786f, 0.06006381f, 0.10430793f, 0.05035200f, -0.00328926f, 0.00174879f, 
    0.03839236f, -0.02248647f, 0.19179232f, 0.29779342f, 0.01967567f, 0.06265298f, 0.19848981f, -0.18700878f, 
    0.03580482f, 0.00407528f, 0.01569612f, 0.05746580f, -0.02050505f, 0.09307782f, 0.05688578f, 0.10947382f, 
    0.01341432f, -0.15959473f, -0.07609619f, -0.31524634f, 0.16773154f, 0.12158489f, 0.06254923f, -0.13750753f, 
    0.12992355f, -0.02609853f, -0.05908990f, 0.01601532f, 0.04648302f, -0.21730113f, 0.09013114f, 0.04976010f, 
    0.05397459f, -0.05633227f, 0.02357021f, 0.06245217f, -0.11075363f, 0.00601421f, -0.15409023f, -0.23437794f, 
    0.18846066f, 0.14829762f, 0.19891649f, 0.31124198f, -0.14540090f, 0.04326994f, 0.16091166f, 0.13874611f, 
    -0.04282310f, 0.09137790f, -0.02253815f, 0.11321823f, 0.02768617f, -0.08952152f, -0.15439200f, 0.06301527f, 
    0.06637711f, 0.12724192f, 0.07096896f, -0.11852244f, 0.03227536f, -0.11180082f, 0.03262765f, 0.09182866f, 
    -0.11058386f, -0.24918912f, -0.28412345f, 0.17656921f, 0.12343248f, -0.03731401f, -0.14750403f, 0.01139849f, 
    0.09834835f, 0.11641649f, -0.04647057f, -0.04680799f, 0.13677627f, 0.02193607f, 0.31351224f, 0.11046062f, 
    0.02510861f, 0.08581059f, -0.07671233f, -0.08575860f, -0.00870337f, -0.04190500f, 0.01468582f, 0.03357645f, 
    -0.03627674f, 0.10702240f, 0.02852794f, 0.35244429f, 0.11559132f, -0.03881371f, -0.10540196f, -0.29013228f, 
    -0.09406990f, -0.09945633f, -0.02236900f, -0.02067460f, 0.17385657f, 0.11973219f, 0.02091296f, 0.21517631f, 
    -0.07195604f, -0.08872434f, -0.02655086f, 0.15875873f, 0.01219836f, 0.17631389f, 0.08482671f, -0.04880564f, 
    -0.19758612f, 0.12695889f, 0.12107362f, -0.27329239f, 0.00991572f, 0.04218211f, -0.19253512f, 0.06511723f, 
    -0.02318835f, -0.13895693f, -0.16855085f, -0.00941174f, -0.22668852f, 0.13455282f, -0.03188981f, 0.18237123f, 
    0.00439604f, -0.01768344f, -0.02939167f, -0.04667323f, -0.02608555f, -0.03285065f, -0.05233799f, 0.02466374f, 
    0.19089961f, 0.21060595f, 0.18364817f, 0.08763244f, 0.13034932f, -0.05907315f, 0.09111467f, -0.15839213f, 
    -0.02807076f, -0.02931204f, -0.13173872f, -0.15912428f, -0.13472748f, 0.13675392f, -0.08978007f, 0.00069605f, 
    0.08579896f, -0.01215364f, -0.15385941f, 0.05809034f, 0.02398078f, -0.02974227f, -0.06579512f, -0.27284941f, 
    0.11450528f, 0.29952809f, 0.25585991f, 0.18327232f, -0.00028598f, 0.02289280f, 0.09141883f, -0.01386947f, 
    0.18858790f, -0.03768955f, 0.04743956f, 0.03476311f, -0.13306731f, -0.21503586f, -0.15190454f, -0.02951439f, 
    -0.05835544f, 0.13856192f, 0.12767105f, -0.02832454f, 0.07868529f, 0.03890105f, 0.14873882f, 0.16073446f, 
    0.15413298f, -0.22303015f, -0.06086717f, -0.06000924f, -0.02236800f, 0.12980452f, 0.02630951f, 0.05711270f, 
    0.04649295f, 0.04664007f, -0.02266123f, 0.09110104f, -0.04824851f, 0.07737985f, 0.16043751f, 0.16638577f, 
    -0.10023212f, 0.00433620f, -0.09311581f, -0.05128452f, -0.06837434f, -0.15556537f, 0.13670647f, -0.00252440f, 
    0.14640963f, -0.07122935f, 0.15905237f, -0.02506726f, 0.04488476f, -0.00159762f, 0.03345381f, 0.01435419f, 
    -0.07297008f, 0.06964551f, 0.02111005f, -0.10034645f, 0.17266969f, 0.12802613f, 0.18847419f, 0.05787479f, 
    0.06011321f, 0.15609688f, 0.07426128f, 0.05033940f, -0.07233984f, 0.17210385f, 0.15382573f, -0.16050316f, 
    0.04951068f, 0.25083703f, 0.14821230f, 0.00411930f, 0.13436504f, -0.17111750f, 0.25193289f, 0.07903048f, 
    0.03647902f, 0.02092674f, 0.02811574f, 0.04735445f, 0.04846124f, -0.05004577f, -0.03962447f, 0.07794143f, 
    0.02969461f, -0.01440625f, 0.12295089f, -0.04857001f, -0.05477907f, 0.00459857f, -0.02391659f, -0.03289398f, 
    0.17220999f, 0.01418367f, 0.17083597f, 0.23789380f, -0.17049669f, 0.05457011f, -0.09077325f, 0.16794233f, 
    -0.03915185f, -0.03630909f, 0.08167236f, 0.01266570f, -0.03764490f, -0.20347518f, 0.16774473f, -0.43391258f, 
    0.14713795f, -0.06472712f, 0.07680935f, 0.11818768f, -0.01013211f, -0.11101233f, 0.01624585f, 0.03958445f, 
    -0.28517070f, -0.20901580f, 0.09851321f, -0.24926738f, -0.07820261f, 0.13259450f, -0.01362386f, -0.16791497f, 
    0.04356954f, 0.10844547f, 0.02749935f, -0.08611953f, 0.32249445f, 0.13934350f, 0.48862913f, 0.13954933f, 
    -0.11422904f, -0.19813035f, -0.22895329f, 0.06937258f, 0.01109238f, 0.04572077f, 0.04748178f, 0.01385994f, 
    -0.29231709f, -0.48390606f, -0.37690583f, -0.20090903f, -0.08414036f, -0.06923442f, 0.02640720f, 0.08225545f, 
    -0.01140522f, -0.02405001f, 0.08389392f, 0.02361844f, -0.14016412f, -0.03828041f, 0.01859093f, 0.26734886f, 
    -0.03964184f, 0.20711106f, -0.06225818f, -0.00187378f, 0.02563778f, 0.01846860f, 0.11681438f, -0.15810911f, 
    -0.13645452f, -0.47602233f, -0.52027506f, -0.21509019f, -0.09072604f, -0.14212805f, -0.05767990f, 0.06773220f, 
    -0.13424733f, -0.04280250f, -0.04451348f, 0.03707950f, 0.22359546f, 0.38506588f, 0.17139524f, 0.05021279f, 
    -0.02622877f, -0.02919447f, -0.00448136f, -0.01467528f, 0.04815475f, -0.05457363f, 0.01064160f, -0.02982438f, 
    0.05579839f, 0.05440030f, 0.19416261f, -0.04438457f, 0.12266329f, -0.00813473f, -0.10426699f, -0.03629675f, 
    0.04002512f, 0.00405496f, -0.02639815f, -0.01807319f, 0.36254653f, 0.26517841f, 0.12491610f, 0.10384402f, 
    -0.01355509f, -0.06412450f, 0.00081295f, 0.04872650f, 0.03425342f, 0.03966608f, 0.03727729f, -0.03774496f, 
    -0.20465583f, -0.30587471f, -0.11146028f, -0.23093919f, 0.06495985f, -0.02684183f, 0.04027326f, 0.02331564f, 
    -0.05047354f, -0.07040035f, 0.08671341f, 0.12468030f, -0.22956423f, -0.16235328f, -0.24585223f, -0.19304587f, 
    -0.14993446f, -0.03226701f, 0.05004472f, -0.10921861f, -0.08064836f, -0.02922248f, -0.01757190f, -0.08377974f, 
    0.05838697f, 0.10029978f, 0.00035301f, 0.03259447f, -0.08186923f, 0.03315879f, -0.04320938f, 0.00355280f, 
    -0.02769785f, -0.09334465f, 0.03781360f, -0.02448386f, 0.14713067f, 0.26021257f, 0.13231218f, 0.06075997f, 
    0.08051752f, -0.00576871f, 0.05073322f, -0.00935415f, -0.02826663f, -0.00759884f, -0.02302295f, -0.09013774f, 
    -0.01624139f, -0.21861669f, -0.00489901f, -0.01897897f, 0.10239305f, -0.03913000f, -0.17092244f, 0.03351454f, 
    -0.02336050f, -0.21512814f, -0.05065773f, 0.15031883f, -0.05349824f, -0.23518893f, -0.31205833f, -0.15376547f, 
    -0.00538858f, -0.09544197f, -0.03178565f, 0.03272785f, -0.06371316f, -0.10268206f, 0.01951112f, -0.07599574f, 
    0.26298431f, 0.08092245f, 0.18112838f, 0.19013378f, 0.03460070f, 0.09420578f, 0.00807918f, -0.02137227f, 
    0.00506770f, 0.09493235f, -0.07714967f, 0.00210604f, 0.16060311f, -0.17908797f, 0.15308343f, 0.12693949f, 
    0.14771958f, -0.03886225f, 0.09714858f, -0.02471529f, 0.11046913f, 0.02297606f, 0.12506960f, -0.27233139f, 
    0.11874034f, -0.22346953f, -0.17357658f, -0.02255563f, 0.07328781f, -0.01749963f, 0.06728341f, -0.07767880f, 
    -0.04000988f, -0.10234043f, -0.03176666f, -0.20468311f, 0.17181429f, 0.08451936f, 0.18241669f, 0.13780335f, 
    -0.04955874f, -0.08980145f, 0.19529471f, 0.06631626f, 0.23949303f, 0.05498840f, 0.19918378f, 0.18380012f, 
    -0.01886260f, 0.04364158f, -0.07512736f, 0.28590506f, -0.03004269f, 0.10883705f, 0.10306712f, -0.01234004f, 
    0.13623628f, 0.17817748f, -0.04818143f, -0.01752543f, 0.21551985f, 0.13828985f, -0.13791861f, 0.09002911f, 
    -0.02372307f, 0.12252743f, -0.07441095f, 0.13462876f, 0.04533285f, -0.02383856f, 0.22092231f, 0.06884145f, 
    -0.09880384f, -0.15458921f, -0.16454275f, -0.05117087f, -0.04222391f, -0.02521734f, -0.00026818f, 0.10979962f, 
    0.06446169f, 0.04120521f, 0.05209750f, -0.00549113f, 0.14407277f, 0.04884324f, 0.02453039f, 0.04024109f, 
    -0.09603905f, 0.01113990f, -0.11409082f, -0.04973201f, -0.02945923f, 0.03579775f, -0.11121695f, -0.02304305f, 
    -0.02748487f, -0.08214229f, 0.11796619f, -0.10741033f, 0.03331223f, 0.08924691f, 0.16118100f, 0.11564696f, 
    0.02076977f, 0.07105181f, 0.06920854f, 0.12815024f, 0.15835087f, 0.12380709f, 0.08757364f, 0.16225103f, 
    0.02380668f, 0.02422425f, 0.02514145f, 0.01937958f, 0.14759341f, 0.04162287f, -0.05843127f, -0.09063993f, 
    0.21195720f, -0.07463197f, -0.02291509f, -0.17540359f, 0.06865959f, 0.13726044f, -0.05062423f, 0.01756088f, 
    -0.07747154f, -0.00758168f, 0.00376255f, -0.04993632f, 0.05245432f, 0.11030040f, 0.04525395f, -0.10482916f, 
    0.01845344f, 0.01702783f, -0.04854346f, -0.15186664f, 0.00983602f, 0.06069024f, 0.04340396f, 0.06043318f, 
    -0.12419265f, -0.11326998f, -0.02709204f, 0.15532364f, 0.22791040f, -0.05292706f, 0.06914260f, 0.05231863f, 
    0.13856763f, 0.08178577f, -0.04697499f, 0.08931400f, -0.03181898f, -0.09408168f, 0.29304257f, -0.11307035f, 
    0.01577271f, -0.14301947f, 0.00280442f, -0.01258051f, 0.11750565f, 0.09859469f, -0.02046894f, 0.03330573f, 
    0.11764576f, -0.14144716f, 0.03924958f, -0.27402827f, 0.05404532f, -0.01403107f, 0.08730908f, 0.01762627f, 
    -0.05856805f, -0.02137285f, 0.01748093f, -0.02284789f, -0.11352191f, -0.03252040f, 0.01334288f, 0.00484831f, 
    0.08351847f, 0.07295226f, 0.12083692f, 0.13936442f, -0.05132262f, -0.07196379f, 0.13950710f, 0.02917091f, 
    0.10454410f, -0.03291218f, -0.23950768f, 0.06701505f, 0.14189604f, 0.04613880f, -0.01818686f, 0.00541592f, 
    -0.02090682f, -0.00224112f, 0.12335353f, 0.03535005f, -0.00452541f, 0.15226907f, 0.15113008f, -0.14545688f, 
    0.12249381f, 0.09969486f, 0.13633463f, 0.07179800f, 0.06199944f, -0.01418774f, -0.08527879f, -0.01862582f, 
    0.27269378f, 0.21967764f, 0.02013208f, -0.18246503f, 0.09384401f, 0.03897186f, -0.03969589f, 0.01598025f, 
    -0.15967651f, -0.04947016f, 0.00381335f, -0.00697813f, 0.36089668f, -0.08471700f, -0.12451633f, 0.09209744f, 
    -0.07576686f, 0.08610467f, 0.07949618f, 0.01473444f, -0.16531414f, -0.08131728f, -0.00200294f, -0.00035570f, 
    -0.05824360f, -0.06924268f, -0.06558822f, -0.34213424f, 0.01073821f, -0.06511185f, -0.00951179f, 0.05780351f, 
    -0.07103173f, 0.06293472f, -0.00435684f, -0.15497150f, 0.15139541f, -0.03012031f, -0.13954827f, -0.03712050f, 
    0.08161777f, 0.02367936f, 0.01000259f, 0.13983890f, 0.15751618f, 0.07423150f, 0.21800205f, 0.03600587f, 
    -0.29514194f, -0.03583378f, -0.29148087f, -0.21537814f, 0.05381107f, 0.06105812f, -0.11713675f, -0.07170340f, 
    -0.07243020f, 0.12120330f, 0.03883650f, -0.01864872f, 0.03747874f, -0.04378097f, -0.15299575f, 0.21819891f, 
    -0.02210427f, 0.01044689f, -0.05865203f, -0.14319870f, -0.05603873f, -0.03108626f, -0.00881512f, -0.06725521f, 
    -0.40564972f, 0.28914839f, 0.23673473f, 0.15468317f, 0.02473122f, -0.09859716f, -0.04378089f, 0.13013384f, 
    -0.05775041f, 0.01632254f, -0.00279505f, 0.04426162f, 0.26575169f, 0.14423227f, -0.02804071f, -0.06515457f, 
    0.09480700f, 0.03905122f, 0.07953317f, 0.01227540f, -0.00813707f, 0.01877307f, 0.01250259f, -0.02632314f, 
    0.22611864f, 0.06793872f, 0.10962731f, -0.04469923f, 0.11232302f, -0.03981690f, 0.03528471f, 0.05613021f, 
    -0.00759354f, -0.02923487f, -0.05147438f, -0.16581191f, 0.25020388f, 0.03313258f, 0.04948981f, -0.23101287f, 
    0.05407200f, 0.05235054f, 0.06956392f, 0.08019126f, -0.04570229f, 0.03193741f, 0.04137932f, -0.04811814f, 
    0.00154953f, -0.09399000f, 0.03471706f, 0.08281807f, -0.09829778f, -0.14280841f, 0.00258637f, -0.01362759f, 
    0.12967303f, 0.09081779f, 0.15033591f, 0.05325545f, 0.15676171f, -0.08316879f, 0.04507050f, 0.00900017f, 
    0.01818545f, 0.12891713f, -0.00384803f, -0.00536507f, 0.18409154f, -0.04306993f, -0.09347463f, 0.09320126f, 
    0.20770201f, 0.02890021f, 0.01277438f, -0.09924193f, 0.12500052f, -0.02500383f, 0.04181140f, 0.07259458f, 
    0.09974650f, 0.00588302f, 0.10576627f, 0.03947324f, -0.10575109f, 0.03341345f, -0.11887671f, 0.03941620f, 
    0.03259676f, -0.03287394f, -0.07350481f, -0.04779790f, -0.01208562f, 0.07685642f, 0.07448617f, 0.06304540f, 
    0.29260975f, 0.01074882f, 0.03059757f, -0.05605638f, 0.02197791f, -0.05278101f, 0.00763652f, -0.05690981f, 
    -0.01690260f, -0.00210153f, 0.00260192f, 0.07719497f, -0.15487406f, 0.03883138f, 0.17209747f, 0.10193985f, 
    -0.09314996f, 0.04380729f, 0.05816298f, 0.12584548f, 0.09797920f, 0.12336379f, -0.03230119f, -0.10545579f, 
    -0.30743879f, -0.11609814f, 0.10101986f, 0.14599115f, -0.04134530f, -0.15930538f, -0.06386168f, 0.00020729f, 
    0.02378955f, 0.11276001f, 0.06111954f, -0.00383616f, 0.07103235f, -0.16021527f, 0.02540902f, -0.05585118f, 
    0.08840735f, 0.05755855f, 0.16434148f, 0.04755834f, -0.02351386f, -0.13874890f, 0.19530500f, -0.04679170f, 
    0.24855269f, -0.14636128f, 0.24639243f, 0.06841595f, 0.04295529f, 0.03362253f, -0.00939297f, 0.14559639f, 
    0.09586608f, 0.04145877f, -0.06161182f, 0.09385008f, -0.29770789f, -0.04136327f, 0.14691494f, 0.25804192f, 
    -0.00371579f, -0.06041144f, -0.03872285f, -0.13126357f, 0.02440633f, 0.03498844f, 0.18581368f, 0.19309247f, 
    0.04292963f, -0.04368801f, -0.02324549f, -0.22394401f, -0.06181198f, -0.05023525f, -0.02531919f, 0.08150607f, 
    0.02087089f, -0.01209140f, 0.07317957f, 0.04560048f, 0.00441698f, -0.08239754f, 0.00728910f, -0.11513871f, 
    0.12748620f, -0.03891801f, -0.00406564f, 0.05121307f, -0.02011089f, 0.01712574f, 0.04628972f, 0.09307290f, 
    -0.31813431f, 0.06525175f, -0.01388549f, -0.15809941f, 0.02607364f, 0.04494819f, 0.13859919f, 0.10269556f, 
    -0.04760672f, 0.08407900f, -0.12039310f, -0.09689868f, -0.08845023f, 0.02856129f, -0.04046350f, -0.02298622f, 
    -0.00005311f, 0.07702775f, -0.03177951f, -0.04858445f, -0.14296262f, -0.14314938f, -0.07422993f, -0.19803719f, 
    -0.17066038f, 0.06892532f, -0.19299090f, -0.07272404f, -0.04055617f, 0.03936056f, -0.01052908f, -0.06199498f, 
    -0.13256508f, 0.00805734f, 0.07249860f, -0.09235829f, -0.01411853f, -0.04255424f, -0.07157229f, -0.07396913f, 
    0.11227823f, -0.03061714f, 0.00724020f, -0.08594796f, 0.05602537f, -0.04343846f, 0.00963758f, -0.04466658f, 
    0.07954317f, 0.06020659f, -0.24271870f, 0.14350107f, 0.03045645f, -0.05715150f, 0.09024470f, 0.08256892f, 
    -0.01692164f, 0.04096921f, 0.01981534f, 0.10277753f, 0.09345528f, 0.10923419f, -0.10222629f, -0.09530637f, 
    -0.02208874f, 0.00755260f, -0.00074978f, 0.04287839f, 0.10564606f, 0.08394030f, 0.06798208f, 0.17198598f, 
    -0.10933398f, 0.24480984f, -0.05916618f, 0.04673383f, 0.18161762f, 0.05401260f, 0.14757824f, 0.12159033f, 
    0.04736177f, 0.08092038f, 0.02304945f, 0.11141161f, 0.00890853f, -0.09346551f, -0.07683120f, 0.01580622f, 
    0.05930272f, 0.06036127f, -0.00689746f, 0.08874486f, 0.01088156f, -0.02169674f, -0.08368719f, -0.04904754f, 
    -0.19952457f, 0.12640131f, 0.12576805f, 0.02738666f, 0.14796622f, 0.05161067f, 0.08611158f, 0.10101404f, 
    -0.06073132f, 0.01460194f, 0.00481842f, 0.06643830f, 0.03715071f, -0.01105884f, 0.06248184f, -0.02058136f, 
    0.10136621f, -0.03632484f, 0.00743798f, 0.05618655f, 0.02089665f, -0.11190908f, -0.05320796f, 0.24215633f, 
    -0.02328198f, -0.09498277f, -0.12245958f, -0.02260423f, 0.01670268f, 0.10737318f, 0.07993106f, -0.07732060f, 
    -0.06180532f, 0.00878681f, -0.08499338f, -0.09660815f, -0.01692337f, -0.21058232f, -0.22309710f, -0.08992875f, 
    -0.03002345f, 0.05656156f, -0.04193160f, 0.09033170f, 0.00028752f, -0.01507431f, -0.03218133f, 0.00900461f, 
    0.13468169f, -0.13934124f, 0.13451602f, 0.05793549f, -0.06248894f, 0.03002947f, 0.01092044f, 0.11549622f, 
    0.08925593f, 0.11513519f, 0.07189771f, 0.09224211f, -0.22937275f, 0.07437603f, -0.03889850f, -0.10613312f, 
    0.02602502f, 0.06626543f, -0.02127441f, -0.14602111f, -0.00254645f, 0.06116202f, 0.06691627f, 0.01910522f, 
    -0.28288147f, -0.08144256f, 0.10175191f, 0.02858981f, 0.00647552f, -0.02028210f, -0.04723176f, 0.17888676f, 
    -0.03799396f, 0.02069660f, 0.16445728f, 0.08453401f, -0.11951902f, -0.04203709f, 0.08550481f, -0.11465073f, 
    0.08402761f, 0.01842680f, -0.05936016f, 0.00295841f, 0.01617496f, -0.10332481f, 0.05779033f, -0.07516725f, 
    0.12804052f, 0.06082149f, -0.01293803f, 0.26750425f, 0.05642367f, -0.07764058f, 0.15717228f, 0.06266620f, 
    -0.06818761f, 0.01223255f, 0.02766858f, 0.13144711f, 0.06425315f, -0.13641126f, -0.02336137f, -0.11106278f, 
    0.05981042f, -0.03546290f, -0.04477703f, 0.01998897f, 0.06102649f, -0.09758934f, -0.07769528f, 0.03292331f, 
    0.00899787f, -0.01353455f, 0.02532775f, 0.00087678f, 0.01064741f, -0.09820098f, 0.09057643f, 0.06913706f, 
    -0.08352464f, -0.12000994f, -0.01836064f, -0.07133573f, -0.07175139f, -0.02688997f, -0.05937526f, -0.18173915f, 
    0.02675398f, 0.09885345f, 0.16328813f, 0.10556578f, -0.06657592f, 0.09451164f, 0.06574108f, 0.07161159f, 
    -0.08158872f, -0.07340232f, -0.04148420f, -0.09827419f, 0.04237916f, -0.16121300f, -0.04187793f, 0.00931814f, 
    0.07941779f, 0.03784459f, 0.07136982f, 0.02199150f, 0.11364052f, -0.19696216f, 0.00106805f, 0.02875262f, 
    -0.07267851f, 0.07520404f, -0.02098772f, -0.01687860f, 0.04150948f, -0.08521083f, -0.01358250f, -0.12050983f, 
    -0.02773908f, -0.05135058f, -0.02175527f, -0.00077479f, 0.02420416f, -0.01285224f, 0.06420223f, -0.04405528f, 
    -0.02648069f, -0.00263824f, -0.03476324f, -0.06619265f, -0.23239711f, 0.01951918f, 0.11004592f, -0.04556904f, 
    0.06411467f, 0.08253909f, -0.09205098f, 0.04051711f, 0.07276604f, 0.04659907f, 0.15216547f, 0.17167370f, 
    0.03981570f, 0.08539706f, -0.14392979f, 0.01067162f, 0.01593073f, -0.05247124f, -0.07259899f, -0.08957042f, 
    0.04931741f, -0.01066564f, -0.04612553f, 0.08464572f, 0.37648794f, -0.21428107f, 0.22068526f, 0.26562312f, 
    -0.10799877f, 0.02629243f, -0.02122316f, 0.10413172f, 0.11910416f, 0.09150011f, 0.05059815f, -0.11123590f, 
    -0.03813526f, -0.17918278f, 0.21543412f, 0.14467788f, 0.03991647f, -0.07526080f, -0.15059574f, 0.07638217f, 
    -0.04171658f, 0.10230568f, 0.16883118f, -0.05986430f, -0.13075237f, -0.35369039f, 0.06726024f, 0.09441546f, 
    0.06275009f, 0.02711947f, 0.11591092f, -0.08327343f, 0.10478214f, 0.01127733f, 0.20406987f, -0.02271386f, 
    0.03889858f, 0.43737864f, -0.25676817f, 0.07199996f, 0.10684671f, 0.01844865f, 0.03990322f, 0.09900086f, 
    -0.06667298f, -0.04284365f, -0.01146432f, 0.00785509f, 0.05972998f, 0.15554816f, -0.07142119f, 0.18967916f, 
    0.16222148f, -0.08753451f, -0.05250543f, -0.00954991f, -0.05168369f, 0.09869038f, 0.12566558f, 0.12580280f, 
    0.03062897f, -0.04317787f, -0.08054689f, -0.17833935f, -0.02157224f, -0.14461739f, -0.09033345f, 0.01130618f, 
    -0.09604011f, -0.04394362f, 0.00369260f, 0.00790474f, 0.03488471f, 0.02073518f, -0.07541555f, -0.01176496f, 
    0.02246968f, -0.05116489f, -0.05100474f, -0.03962840f, -0.00099335f, 0.00877931f, -0.06505150f, -0.02563771f, 
    -0.11294347f, 0.03394382f, 0.12375798f, -0.11890008f, -0.08746784f, 0.01081188f, 0.01409166f, 0.12610126f, 
    0.00952659f, 0.18796356f, -0.05430921f, -0.03176676f, 0.03949208f, -0.16439170f, 0.00129350f, -0.00163211f, 
    -0.04709831f, -0.00563270f, 0.03952812f, -0.00498260f, 0.04097838f, 0.01940060f, 0.00964827f, -0.05743789f, 
    0.30985701f, 0.00512002f, -0.13046414f, 0.02726740f, 0.02777427f, -0.02618636f, 0.06947088f, 0.08849985f, 
    -0.00228336f, -0.00393914f, -0.08082268f, 0.09374752f, 0.12450047f, 0.14061290f, 0.07884872f, -0.07123608f, 
    -0.11288567f, -0.02345794f, 0.00031302f, 0.05215329f, -0.10073157f, -0.06293216f, -0.10506607f, 0.02870052f, 
    0.11463746f, -0.33122331f, 0.11212702f, -0.14181539f, 0.10093276f, 0.17714250f, 0.09398931f, -0.15267889f, 
    0.05433997f, 0.01170916f, -0.08389667f, -0.10844763f, 0.02496105f, -0.11726933f, 0.11820571f, -0.33642378f, 
    0.03214596f, -0.03847208f, -0.01109325f, -0.07874437f, -0.17132214f, 0.02856755f, -0.05502690f, -0.15030129f, 
    0.15720932f, 0.21810256f, -0.09116534f, -0.06722753f, -0.07290702f, -0.22259496f, 0.12302639f, -0.01410091f, 
    -0.00911214f, -0.09846314f, 0.04291008f, 0.04801219f, 0.07329652f, 0.08672511f, -0.00910860f, -0.01218859f, 
    0.03402947f, 0.03829046f, 0.09885574f, -0.09272701f, -0.16324671f, -0.06991189f, -0.00188492f, -0.05297492f, 
    0.29501423f, -0.11612273f, -0.31001806f, 0.32061034f, -0.16954517f, 0.01978991f, -0.08389685f, -0.12181126f, 
    -0.02315925f, 0.09662218f, -0.11508592f, -0.08106740f, 0.34242380f, 0.30697244f, 0.16240345f, -0.11649563f, 
    0.07556151f, 0.19749817f, 0.05431964f, 0.07543828f, -0.02129195f, -0.04554461f, -0.03291658f, 0.01366979f, 
    0.21452697f, -0.04269293f, 0.10578962f, -0.10816731f, -0.09140688f, 0.18931833f, -0.07741871f, -0.10265827f, 
    0.00463309f, 0.10477208f, 0.04016802f, 0.12318758f, 0.28605127f, -0.06665535f, 0.14827944f, 0.00972472f, 
    -0.15067174f, -0.18173017f, -0.34690276f, 0.04084291f, -0.11654761f, 0.07956889f, 0.01841016f, 0.23598364f, 
    -0.05738731f, -0.06924157f, -0.08164997f, -0.10440544f, 0.02690759f, 0.04423236f, -0.10852122f, -0.03188035f, 
    0.06588914f, -0.02830897f, 0.00267666f, 0.11001254f, 0.27040631f, 0.03716222f, -0.07819510f, -0.07921204f, 
    -0.02557258f, -0.00597501f, 0.08504203f, 0.11263335f, -0.04370009f, 0.05312186f, 0.10316774f, -0.05036526f, 
    0.40227810f, 0.19797480f, -0.23577929f, -0.01644377f, 0.08369990f, 0.18081802f, 0.15323739f, -0.05924328f, 
    -0.00948699f, 0.02092971f, -0.02890921f, 0.11285122f, -0.19954555f, 0.01254453f, -0.05568697f, -0.00967304f, 
    0.01082292f, -0.11157747f, -0.00244838f, -0.02272927f, -0.01307782f, 0.03442918f, 0.07457533f, 0.07296890f, 
    -0.37982041f, -0.01097955f, -0.00247762f, 0.08499154f, 0.08005272f, 0.02928981f, -0.12863317f, -0.02475109f, 
    0.07753495f, 0.03283410f, -0.11704312f, 0.00530028f, -0.03163273f, 0.13118869f, -0.03839931f, -0.12300233f, 
    0.05476027f, -0.05589924f, -0.17345059f, -0.10136639f, -0.07196344f, 0.05748324f, 0.22137953f, -0.06412641f, 
    0.17481968f, 0.09754467f, 0.17099446f, -0.03331853f, 0.04286931f, 0.04664297f, 0.05692010f, 0.15176523f, 
    0.00995966f, -0.03617589f, 0.11567198f, 0.15688911f, 0.30166975f, 0.16486040f, 0.04739246f, -0.04277050f, 
    0.01860627f, 0.03910621f, 0.06428014f, 0.04447792f, 0.02414427f, -0.00583267f, -0.06582943f, -0.02616751f, 
    0.01127943f, -0.11777701f, -0.08907407f, -0.01594215f, 0.02323581f, 0.04124751f, -0.00930736f, 0.05179780f, 
    0.10317409f, 0.03938175f, -0.00802750f, -0.19672558f, -0.15459707f, 0.28877130f, 0.05278491f, -0.11916947f, 
    -0.03730120f, 0.15436131f, -0.00293399f, -0.14501330f, -0.07594882f, 0.06738003f, -0.08104300f, -0.14459099f, 
    0.20296350f, 0.17683080f, 0.03537223f, -0.21022709f, 0.05217337f, -0.14225172f, -0.09976853f, 0.05324193f, 
    -0.09247714f, -0.22047946f, -0.06491111f, 0.08762218f, -0.17280447f, 0.14231028f, -0.16038445f, 0.09978116f, 
    -0.01709876f, 0.06299168f, 0.11816150f, 0.00071766f, -0.01331383f, 0.01380872f, 0.05716986f, 0.03244515f, 
    0.17631671f, -0.09726938f, 0.00199579f, -0.04191024f, -0.01479419f, 0.12797061f, 0.04950796f, 0.04407327f, 
    -0.13275644f, -0.03158449f, -0.07541393f, -0.08097186f, -0.30097413f, 0.22080632f, 0.41427729f, -0.16615766f, 
    -0.03551417f, 0.05490049f, 0.03717338f, 0.00114670f, 0.02335499f, -0.11391605f, -0.07940245f, -0.19709133f, 
    -0.24792732f, -0.17177576f, 0.08558930f, -0.21001504f, 0.13450518f, -0.05336463f, 0.18337379f, -0.12674199f, 
    -0.07694741f, -0.05652880f, -0.15451205f, -0.14593419f, 0.10426363f, 0.05555612f, 0.17935337f, -0.28835145f, 
    -0.01803071f, -0.09987622f, 0.00492754f, 0.08744855f, 0.08205987f, -0.02377307f, -0.03740003f, 0.24326026f, 
    0.30844331f, -0.12927362f, -0.11731012f, 0.12886083f, 0.05799665f, -0.06784352f, 0.17452203f, -0.01803322f, 
    0.05536533f, 0.26115340f, 0.04428355f, -0.02236209f, -0.30797493f, -0.11494064f, -0.08144435f, 0.02033830f, 
    0.01352370f, 0.08428253f, 0.13766932f, -0.01303433f, -0.04956316f, 0.06977084f, 0.04657077f, -0.07276123f, 
    0.21963190f, 0.13174315f, -0.05818760f, 0.04537369f, 0.14462441f, 0.12989594f, 0.01558579f, -0.05402295f, 
    -0.00676998f, 0.00209151f, -0.06253920f, -0.06708337f, 0.13736597f, 0.09712050f, -0.06788148f, 0.04342532f, 
    0.11391014f, -0.07893819f, 0.04593902f, -0.17753926f, -0.06237091f, 0.10443237f, -0.13015024f, -0.10624461f, 
    0.03001705f, 0.11853558f, -0.05525824f, -0.01722997f, -0.01063732f, 0.04432471f, 0.01328001f, 0.08149737f, 
    -0.05290765f, -0.00253828f, 0.15996648f, 0.06311711f, -0.21909595f, -0.03402181f, -0.08712748f, 0.11219402f, 
    0.02884436f, -0.05158207f, -0.02382584f, 0.00207438f, -0.13351092f, 0.05253745f, 0.07680192f, 0.04761894f, 
    0.04127486f, 0.08948363f, 0.19821750f, -0.04204331f, 0.13119690f, -0.08858488f, 0.08747341f, 0.20604740f, 
    0.05620420f, -0.06163334f, -0.19628203f, -0.00036662f, 0.02014576f, 0.05985206f, 0.01834085f, 0.05875427f, 
    -0.01341331f, 0.07864206f, 0.12188618f, 0.11856454f, -0.01580155f, 0.08008301f, -0.04161081f, 0.02385481f, 
    -0.18205944f, -0.05380825f, -0.10403971f, 0.18101618f, 0.03894911f, 0.03360488f, 0.04495052f, 0.00104528f, 
    0.17278650f, -0.01510751f, -0.01055697f, -0.07653163f, -0.17288044f, -0.12735078f, 0.11086603f, -0.02513577f, 
    0.00117693f, -0.11415783f, 0.04860399f, -0.12023835f, -0.06575247f, 0.07808928f, -0.02890727f, -0.18106104f, 
    0.02845522f, -0.11549036f, 0.03584361f, 0.02394569f, -0.06108038f, 0.06822468f, -0.08170597f, 0.15950333f, 
    0.05631385f, -0.09840158f, -0.03692107f, -0.06846213f, -0.03170604f, 0.05206060f, -0.01176490f, -0.06065816f, 
    0.09433084f, 0.19426933f, 0.11252217f, 0.02163132f, -0.06897207f, -0.00070786f, -0.06614026f, 0.06922963f, 
    0.07621206f, -0.04693365f, -0.17345107f, 0.20913462f, -0.03340821f, 0.14263286f, -0.00547139f, 0.17235203f, 
    0.00736053f, -0.00409179f, -0.11456135f, -0.04589367f, -0.06974987f, 0.36733803f, 0.00062133f, 0.08360177f, 
    0.01253316f, 0.05938395f, 0.11567953f, -0.03968884f, -0.05124081f, 0.08108034f, -0.00042303f, -0.16169046f, 
    -0.16317831f, 0.00063383f, 0.14514625f, -0.04079065f, -0.10668954f, -0.04519177f, -0.04658096f, -0.01865592f, 
    0.08216955f, 0.07469731f, 0.04535518f, 0.03239567f, -0.08391030f, -0.01691047f, 0.43157750f, -0.01496052f, 
    0.04974609f, 0.11912651f, -0.13160519f, -0.07493202f, -0.06217978f, -0.09869369f, -0.00124247f, -0.08218375f, 
    0.09225277f, 0.30360994f, 0.11503544f, -0.01280101f, -0.09828115f, -0.02464233f, 0.06086350f, -0.18492533f, 
    -0.02081647f, 0.00754028f, 0.09195136f, 0.04676126f, 0.23860544f, 0.12378583f, 0.01489948f, -0.07634331f, 
    0.02686286f, 0.05833650f, 0.09745710f, 0.15516783f, -0.07248536f, -0.01132845f, 0.10556423f, 0.04254933f, 
    0.26886758f, 0.25189340f, -0.04528530f, 0.05773775f, -0.13020091f, -0.07918838f, 0.01699221f, -0.14097746f, 
    0.00773711f, -0.03991610f, 0.03824913f, -0.04963966f, -0.06092094f, 0.01558580f, -0.07959056f, 0.27372861f, 
    -0.19421290f, -0.14000590f, -0.00477023f, -0.12377467f, 0.00424807f, 0.07747020f, -0.00792859f, 0.04583814f, 
    -0.26600781f, -0.02762247f, -0.11308535f, 0.24421154f, 0.08141734f, 0.14224477f, -0.11601954f, -0.07244236f, 
    0.09543099f, 0.20715061f, -0.04141877f, 0.15164387f, -0.24177560f, 0.11564416f, 0.10969836f, 0.08888137f, 
    0.01485655f, 0.01616530f, -0.01031605f, -0.16258402f, -0.15296642f, -0.05989514f, 0.09688019f, -0.03143530f, 
    0.00938812f, 0.20634881f, 0.03528310f, -0.03964178f, 0.10022052f, 0.00902846f, -0.01936902f, -0.02115781f, 
    0.10625511f, 0.02244253f, 0.03525597f, 0.08213077f, 0.07315809f, 0.07372027f, 0.01265647f, -0.04933225f, 
    0.11946496f, 0.07461088f, -0.12563704f, -0.06656270f, 0.14469749f, -0.00603667f, 0.02141244f, -0.10595748f, 
    -0.01262551f, 0.00618472f, 0.09034019f, -0.02834628f, -0.14659069f, 0.06488483f, -0.04843634f, -0.07752217f, 
    0.07854047f, 0.10549167f, -0.12623778f, -0.01866858f, -0.09800623f, 0.16751027f, -0.09135895f, -0.01193792f, 
    -0.02826020f, 0.01320941f, -0.02790978f, -0.07346358f, -0.04046394f, -0.08539762f, -0.03132014f, -0.04116562f, 
    0.00571574f, 0.13522841f, -0.01726112f, -0.20876554f, 0.14371367f, 0.03048389f, -0.03897418f, -0.00048211f, 
    -0.02942780f, -0.02134498f, 0.06803035f, -0.01136344f, 0.17400321f, 0.13801004f, 0.11876242f, 0.43965104f, 
    -0.04218486f, -0.06615991f, -0.01853242f, 0.00316384f, -0.01726265f, 0.03754907f, 0.07545251f, -0.04226812f, 
    -0.19387132f, -0.17987964f, -0.02606852f, -0.10236850f, -0.10995223f, 0.01175922f, -0.03260921f, 0.01009842f, 
    -0.04058786f, -0.10070039f, -0.13085668f, -0.02389523f, -0.36263099f, 0.28133252f, -0.06022700f, 0.00783427f, 
    0.25995764f, -0.15423974f, 0.04068610f, 0.04281300f, -0.09024800f, -0.12916812f, -0.00104386f, 0.19148453f, 
    -0.08657388f, 0.15689369f, 0.06874389f, 0.14115725f, 0.08345029f, -0.17645891f, -0.02228619f, 0.01616508f, 
    -0.09856126f, -0.11835583f, -0.13139105f, 0.22500515f, -0.18857470f, 0.24330814f, -0.09114585f, -0.19392689f, 
    0.09024587f, 0.02621482f, 0.00886520f, 0.06806090f, -0.09335047f, 0.00858996f, -0.14814337f, 0.02326978f, 
    0.15996654f, -0.23843975f, 0.25684220f, -0.12126829f, -0.02324599f, 0.03861627f, 0.06223161f, 0.05327932f, 
    0.15336011f, 0.09045692f, 0.11154099f, -0.04983428f, -0.13257869f, -0.15714321f, 0.15019003f, 0.02530573f, 
    -0.02228395f, 0.06660230f, -0.03271688f, 0.02984755f, 0.00585510f, -0.12457164f, -0.09755963f, -0.02578592f, 
    0.00985977f, -0.02572082f, 0.10950941f, 0.00967305f, -0.01505210f, 0.19009867f, -0.00551740f, -0.19576477f, 
    -0.01695749f, 0.00376036f, -0.03512568f, 0.05935766f, -0.01302385f, -0.12164143f, 0.03439979f, -0.05895625f, 
    -0.01477671f, 0.12885027f, 0.14165300f, -0.15092799f, -0.09963576f, 0.05337652f, 0.04475926f, -0.04313627f, 
    0.12741926f, 0.09219006f, -0.16407762f, -0.15050371f, 0.01069460f, -0.05329387f, -0.07307774f, 0.04309801f, 
    -0.00268923f, -0.01090056f, 0.03850514f, -0.18352270f, -0.03960096f, 0.09540968f, 0.07419010f, 0.06644838f, 
    -0.07074866f, -0.07951195f, -0.08134764f, -0.16972460f, -0.04926517f, 0.08780001f, 0.11019190f, 0.03864434f, 
    0.29115599f, 0.13929227f, 0.03752006f, 0.04128851f, 0.09344008f, 0.00035361f, 0.04286675f, 0.16549979f, 
    -0.12404130f, -0.14314772f, -0.01053047f, 0.10641143f, 0.04034892f, 0.25465128f, 0.13816474f, -0.04877671f, 
    -0.07624799f, 0.02560456f, 0.06323875f, 0.11924138f, -0.04127455f, -0.03563902f, -0.08282888f, -0.01789708f, 
    -0.07418336f, -0.19627732f, -0.21292821f, -0.05621444f, 0.12765270f, 0.00544270f, 0.08837315f, -0.11900720f, 
    0.13992906f, -0.16927211f, -0.13938394f, 0.08524407f, -0.02164511f, -0.13853812f, -0.26476949f, -0.25680578f, 
    -0.04643814f, -0.05653941f, 0.04044816f, -0.10981007f, 0.09619156f, -0.02495705f, -0.08525811f, 0.14063214f, 
    0.19549784f, 0.08871496f, 0.08241752f, -0.19123480f, 0.03081215f, -0.07128572f, 0.05574784f, -0.00025323f, 
    -0.12870485f, -0.12799273f, 0.03505517f, 0.08409421f, -0.02226584f, 0.09941071f, 0.02252038f, -0.02324163f, 
    -0.03707459f, -0.03772910f, 0.05768101f, -0.04429994f, -0.00014422f, -0.00982673f, -0.01429109f, -0.00925100f, 
    0.30370572f, -0.13380325f, -0.28474778f, -0.06113743f, -0.05161682f, -0.14676735f, 0.07210840f, -0.21417063f, 
    -0.10069257f, 0.09018097f, 0.00999322f, -0.08532313f, 0.22015721f, 0.32344061f, 0.14292082f, 0.01805819f, 
    0.20206873f, 0.28955606f, 0.04758104f, 0.13158861f, 0.05701621f, -0.03156663f, 0.01172199f, 0.04756523f, 
    0.50274354f, 0.30802664f, 0.11001039f, 0.08421575f, -0.07711929f, 0.05278199f, 0.07780000f, 0.21095127f, 
    -0.10654564f, 0.05735846f, 0.06300610f, -0.04415720f, -0.03574092f, 0.01536432f, -0.64774483f, -0.04036657f, 
    0.00653841f, 0.00170320f, 0.02598917f, 0.16076168f, -0.04055189f, 0.04088577f, -0.00549226f, 0.19617768f, 
    -0.01550510f, -0.29227301f, -0.10065660f, -0.26436180f, 0.01247162f, -0.03205007f, -0.19060789f, 0.00501390f, 
    -0.03947430f, 0.04137216f, 0.03171818f, 0.02851264f, 0.34967619f, -0.04037982f, 0.13408454f, -0.14867973f, 
    0.01177556f, -0.01791460f, 0.03151248f, 0.12811045f, -0.06201724f, 0.10790919f, 0.08335827f, 0.09686336f, 
    0.22210732f, 0.00263778f, -0.23956968f, -0.01072071f, 0.15594615f, 0.17116158f, 0.02382536f, -0.12681429f, 
    -0.01396797f, -0.03747759f, 0.05403594f, 0.14147529f, -0.43350300f, -0.55408531f, -0.08279799f, -0.12797573f, 
    0.10944003f, 0.02007983f, -0.12405390f, 0.03758477f, -0.00671962f, 0.07923494f, 0.08039234f, -0.01967254f, 
    -0.44925323f, -0.06009467f, -0.05278857f, 0.04122470f, 0.09387511f, -0.08652819f, -0.17180315f, -0.01543596f, 
    0.01162439f, -0.03591099f, -0.09021899f, 0.04362779f, -0.16355026f, -0.57491696f, -0.40206769f, -0.25816903f, 
    0.04657553f, 0.00800404f, -0.20525764f, -0.07977431f, -0.09030841f, -0.05083585f, 0.06502598f, -0.01677998f, 
    0.32399976f, 0.13768940f, 0.24755673f, 0.14337701f, 0.07492156f, 0.08462677f, 0.12554546f, 0.13721551f, 
    -0.01614512f, 0.00966352f, 0.09135501f, 0.00652792f, 0.33233231f, 0.12203398f, 0.13723138f, -0.13738623f, 
    0.11691579f, 0.08032504f, 0.08404804f, 0.07996298f, 0.06417428f, -0.00059833f, -0.06193412f, -0.00254638f, 
    0.08741874f, -0.35273781f, -0.20043990f, -0.21885087f, 0.00668517f, 0.00845758f, 0.03572165f, 0.00052012f, 
    0.08569960f, -0.01158805f, 0.08866182f, -0.11208355f, -0.23293689f, -0.37668702f, 0.16450164f, -0.05868205f, 
    0.06596531f, 0.16307032f, -0.04491397f, -0.16496208f, 0.03202227f, 0.02552556f, -0.18734774f, -0.03002031f, 
    0.18561827f, 0.13200156f, 0.21086103f, 0.04945962f, 0.14039974f, 0.02178932f, 0.01379965f, 0.16262096f, 
    -0.07156440f, -0.12688035f, 0.02432099f, 0.10972609f, 0.08582331f, 0.09948405f, -0.29926783f, -0.11976190f, 
    0.02599681f, 0.09554853f, 0.02025145f, 0.06598832f, -0.03057082f, 0.06909166f, -0.03103551f, 0.12050327f, 
    0.05242222f, -0.19254972f, -0.40240797f, -0.08448745f, -0.07277200f, 0.00722176f, 0.12540814f, 0.05070339f, 
    -0.05642457f, -0.12049159f, -0.00058110f, 0.05980240f, 0.05365511f, 0.04462714f, 0.50284028f, 0.00585381f, 
    -0.06621984f, 0.05684603f, -0.07138187f, 0.04130929f, 0.03148374f, 0.14060448f, -0.01673926f, -0.06158449f, 
    -0.17094938f, -0.16775370f, 0.11690163f, -0.00374314f, 0.07317346f, -0.04750732f, -0.07692822f, -0.02687938f, 
    -0.03181891f, -0.01200956f, 0.11533197f, -0.02011331f, 0.12206348f, -0.12983641f, 0.07461098f, -0.12193710f, 
    0.04942885f, 0.06889229f, 0.05573689f, 0.24194816f, -0.05644511f, -0.04054929f, 0.05079152f, 0.22324830f, 
    0.08895049f, 0.03911751f, 0.03171474f, -0.00297963f, 0.15035015f, -0.07767314f, 0.03579000f, 0.18156150f, 
    0.12501732f, 0.06270602f, 0.05806875f, 0.04102631f, -0.48375639f, -0.07077967f, -0.09023817f, 0.27630541f, 
    0.09346333f, -0.02128609f, 0.06018056f, -0.12888555f, -0.07610051f, 0.14311121f, -0.00813207f, 0.12648726f, 
    0.23510835f, 0.25199029f, 0.15047349f, 0.07144732f, 0.03931000f, 0.01332053f, 0.00787882f, 0.05539389f, 
    0.04685871f, 0.08184364f, -0.02553893f, 0.08618926f, -0.08619519f, 0.06300244f, -0.28039324f, -0.04283028f, 
    0.09862934f, -0.12631293f, 0.04169971f, -0.17650826f, 0.04396126f, -0.02584530f, -0.02410291f, -0.00673820f, 
    -0.15681571f, 0.17182666f, -0.01889421f, 0.08911983f, 0.11559254f, 0.03883226f, 0.03229854f, 0.04538394f, 
    0.02030964f, 0.03631494f, 0.03346415f, 0.01057110f, -0.27148867f, -0.21152857f, -0.15850407f, -0.06733462f, 
    0.02422145f, 0.02710065f, -0.10855483f, 0.01361532f, -0.19652919f, -0.03082869f, 0.03134375f, 0.01734583f, 
    0.09177414f, 0.05609918f, -0.29421419f, -0.28680688f, -0.03660021f, 0.04024052f, -0.03187515f, 0.04402370f, 
    -0.16957575f, 0.10744078f, -0.00252119f, -0.06681404f, 0.22284521f, 0.11990723f, 0.03356365f, 0.11380237f, 
    0.25063142f, 0.08234719f, 0.09361934f, -0.03672557f, 0.03526040f, -0.10682330f, 0.07040430f, -0.15349124f, 
    0.25132668f, -0.10566185f, -0.03586658f, 0.18343006f, 0.02812784f, -0.06236618f, 0.01098132f, 0.00492700f, 
    -0.05776196f, 0.04524812f, -0.03574835f, -0.10084163f, -0.37628722f, 0.02632342f, -0.49341446f, 0.17285626f, 
    0.06875829f, -0.02760096f, -0.07227796f, 0.06869809f, 0.02869361f, -0.21212015f, 0.06706847f, 0.25812978f, 
    0.23416993f, -0.26234257f, 0.43072003f, -0.14986175f, 0.19385646f, 0.17210883f, 0.04343268f, 0.13071309f, 
    0.00429421f, 0.08863419f, -0.03199130f, 0.00777257f, -0.04349273f, -0.20563649f, 0.05655686f, -0.05593773f, 
    0.18082586f, 0.00704136f, 0.03695265f, 0.10417913f, 0.09308349f, -0.23287065f, 0.00178336f, -0.20271149f, 
    -0.19153862f, 0.00067849f, -0.03525814f, -0.44204548f, 0.12077513f, 0.02456076f, 0.06238028f, 0.08351950f, 
    0.01815288f, -0.18499397f, 0.08489046f, -0.09863899f, -0.00542192f, -0.06627551f, 0.07381541f, -0.17679904f, 
    0.15805012f, 0.04371817f, -0.15514083f, 0.13654689f, 0.02185746f, -0.09159172f, -0.08288362f, 0.12549153f, 
    0.31885219f, 0.36759210f, -0.02816877f, -0.05053210f, -0.00550303f, 0.08526146f, 0.14253567f, 0.13130337f, 
    -0.01844488f, -0.15980680f, -0.16812436f, -0.15227127f, -0.59257275f, 0.19337139f, -0.41270953f, 0.21580446f, 
    0.10153994f, 0.04378781f, 0.12708269f, 0.16070928f, 0.21236975f, -0.16089378f, -0.01516689f, -0.13036200f, 
    0.08997067f, -0.23367101f, -0.11005829f, -0.16033930f, -0.16806389f, -0.08206051f, 0.00087189f, 0.04549599f, 
    0.10762574f, 0.11523894f, -0.11753242f, 0.00761198f, 0.09729619f, -0.01563385f, -0.02658012f, -0.22926521f, 
    -0.01132436f, 0.17455845f, -0.21525559f, 0.12515312f, -0.01518706f, -0.10645971f, -0.02854630f, -0.09003308f, 
    0.02690861f, -0.04768547f, -0.03255923f, 0.05381251f, 0.13025446f, -0.12694632f, -0.13920961f, 0.10659875f, 
    0.14557455f, -0.00129584f, 0.08442584f, 0.11130801f, 0.01033919f, -0.05311895f, 0.06590984f, -0.03535811f, 
    0.04177172f, 0.14328130f, -0.08711163f, 0.11395109f, -0.01803972f, -0.06595116f, 0.05513012f, 0.03089151f, 
    -0.10296885f, 0.14544953f, 0.12496422f, 0.03038106f, -0.04620409f, -0.04403234f, 0.09280957f, -0.17315942f, 
    0.02046788f, -0.08921526f, 0.05785529f, 0.09522648f, 0.22738564f, -0.28745297f, 0.06867933f, 0.03237993f, 
    0.12815934f, 0.03620527f, -0.07583132f, 0.10539245f, -0.07864684f, 0.00894931f, -0.26380423f, 0.12362424f, 
    0.12939169f, -0.10764497f, 0.10265354f, -0.04808336f, 0.12966017f, 0.01274136f, 0.07671691f, 0.11416928f, 
    -0.00080076f, -0.06552381f, 0.04220542f, 0.12467831f, 0.02630566f, 0.01719783f, 0.00835845f, -0.27804700f, 
    0.13776998f, 0.07006633f, 0.04130167f, 0.18408191f, -0.13032889f, 0.27186981f, 0.02651792f, 0.17475495f, 
    0.08041952f, -0.12253665f, 0.03257465f, -0.20465869f, -0.07394058f, -0.30859798f, 0.14458607f, -0.12866037f, 
    0.04781989f, -0.02885859f, -0.07390659f, 0.02708811f, 0.23084038f, -0.40539649f, 0.30255300f, -0.02696379f, 
    0.09944291f, 0.16630855f, 0.00767501f, -0.02490553f, -0.00279179f, -0.06573687f, -0.05138411f, -0.23150767f, 
    0.20163941f, 0.16725254f, 0.13435870f, 0.17523581f, 0.08596745f, 0.06449565f, 0.12494108f, 0.09781329f, 
    -0.03412236f, 0.05596597f, -0.02785932f, 0.01685106f, 0.04268458f, -0.13534741f, -0.08543602f, 0.03146776f, 
    -0.12186249f, 0.05073246f, -0.05467084f, -0.12851439f, 0.18067293f, -0.02848989f, 0.09769741f, 0.10752355f, 
    -0.21809466f, 0.06036558f, -0.14481224f, 0.08904283f, 0.14718273f, -0.06532055f, -0.20948046f, -0.09838282f, 
    0.06035380f, 0.12998345f, -0.01323083f, 0.03789751f, 0.55587637f, -0.12123020f, 0.35829324f, 0.30335817f, 
    0.06435944f, 0.28282738f, -0.05803186f, -0.11047479f, 0.10214967f, 0.09033036f, 0.01114776f, -0.12069145f, 
    0.22397503f, -0.07326132f, 0.26060030f, 0.33112070f, -0.01387175f, -0.09646562f, -0.13232681f, -0.15731019f, 
    0.13599680f, -0.01424201f, 0.00735079f, -0.18307778f, 0.10104348f, -0.23110732f, -0.02975816f, 0.21538849f, 
    0.13965562f, 0.10704278f, 0.10698983f, 0.12275375f, -0.00140148f, 0.11027377f, 0.22530521f, -0.09301151f, 
    0.22249350f, 0.13518915f, 0.07415468f, -0.30619028f, 0.00061562f, -0.08846155f, -0.12454647f, 0.24864650f, 
    0.01018329f, -0.11270038f, -0.22460721f, -0.02592010f, 0.09376710f, 0.36700496f, -0.07361329f, 0.21372046f, 
    -0.00882507f, -0.09286521f, -0.08740185f, -0.00622442f, 0.01055647f, 0.02457863f, 0.04737833f, 0.00325941f, 
    0.16429156f, 0.00553368f, -0.05842904f, -0.21575828f, -0.03337504f, -0.04886015f, 0.06764540f, -0.06257126f, 
    -0.17468542f, -0.18259481f, -0.05281368f, -0.07472353f, -0.54760677f, 0.19179222f, -0.15226802f, 0.02657683f, 
    0.08065944f, -0.04250456f, -0.04562767f, 0.21148121f, -0.05603043f, -0.05743205f, 0.03757586f, -0.11093696f, 
    -0.27271804f, 0.23435260f, 0.08983726f, 0.25367531f, 0.08088223f, 0.05520812f, 0.20082150f, 0.06727988f, 
    0.14061339f, 0.03138869f, -0.10760270f, 0.06408808f, -0.16875759f, -0.32910365f, -0.14676450f, 0.10522500f, 
    -0.02304350f, 0.18982084f, 0.23206520f, -0.05412759f, 0.09743399f, -0.07319760f, 0.00087551f, 0.06058180f, 
    -0.07767471f, 0.30850565f, 0.14928553f, 0.00868142f, -0.07680658f, 0.15866528f, -0.11442786f, -0.14162438f, 
    0.05367732f, 0.07679431f, -0.04272157f, -0.00781566f, 0.06360984f, 0.05826818f, 0.21926142f, 0.15680876f, 
    0.13216546f, 0.09845545f, 0.07266421f, -0.10383812f, 0.06441708f, -0.01925310f, 0.10775791f, 0.00416204f, 
    -0.06577960f, 0.07689667f, 0.16885537f, 0.05528739f, -0.15446050f, -0.02779759f, -0.09830062f, 0.11547320f, 
    -0.13847168f, 0.20583898f, -0.02101479f, -0.06873616f, 0.17372288f, -0.07666993f, -0.35549131f, 0.09753667f, 
    -0.03889738f, 0.03890245f, 0.03877102f, -0.01093486f, 0.07496584f, -0.05921601f, 0.06281051f, 0.14179444f, 
    -0.15279952f, -0.23005110f, 0.40419349f, 0.10742193f, 0.13788398f, 0.20704031f, -0.04864220f, 0.10196430f, 
    -0.02174277f, 0.06939929f, -0.00170057f, -0.03920240f, -0.00808565f, -0.13451907f, 0.07740657f, -0.02894814f, 
    0.07044095f, 0.00056104f, 0.03926495f, -0.01757227f, 0.11005016f, 0.00941236f, 0.01104780f, 0.07304314f, 
    -0.20830433f, 0.13459919f, 0.26682505f, -0.20775978f, 0.06202294f, 0.09463807f, 0.10711247f, 0.09234178f, 
    0.06850738f, -0.07657529f, 0.07437430f, -0.01450776f, -0.26426679f, -0.20114405f, 0.01671542f, 0.11898833f, 
    -0.09338173f, -0.06894168f, -0.04041169f, 0.13467635f, -0.04515704f, -0.05633594f, -0.00578465f, 0.23811291f, 
    -0.07188914f, 0.11969195f, 0.01400105f, 0.12935129f, 0.08377590f, -0.10227682f, 0.12419187f, 0.07272128f, 
    0.05080605f, -0.02568118f, -0.04416383f, 0.01054868f, -0.17120631f, -0.19263300f, -0.02855284f, 0.04092346f, 
    0.01335871f, 0.08350033f, 0.19166757f, -0.02548693f, 0.08898616f, -0.11734839f, 0.06439481f, -0.16463365f, 
    0.00634880f, 0.09480038f, 0.10929482f, 0.05218641f, -0.03249260f, -0.01053004f, 0.09533045f, 0.16814321f, 
    0.04347013f, 0.06795051f, -0.01748895f, 0.02840842f, -0.12590577f, 0.17888372f, 0.22435333f, 0.12003189f, 
    0.01435136f, 0.04614006f, -0.09219489f, -0.04432164f, 0.03790842f, -0.12364414f, 0.10264897f, -0.03980676f, 
    -0.17704961f, 0.06389050f, 0.33291900f, 0.02413032f, 0.00459179f, -0.15880269f, -0.05863756f, 0.13129567f, 
    0.17450301f, 0.10097936f, 0.00424530f, -0.12540619f, -0.08397895f, -0.05719963f, -0.08213180f, -0.04910340f, 
    0.03861095f, 0.01999414f, -0.03707210f, -0.06772282f, 0.02897398f, -0.11199507f, -0.01185234f, 0.00065978f, 
    0.20245612f, -0.08456599f, 0.14584443f, -0.01029375f, -0.14188182f, -0.00752741f, 0.05732273f, -0.01589227f, 
    0.03351167f, -0.14650857f, -0.03145268f, 0.10866913f, 0.11889819f, -0.10577707f, -0.09183516f, 0.05055494f, 
    -0.04298494f, 0.03441881f, -0.02390150f, 0.03740527f, 0.05932122f, -0.01957353f, -0.12153918f, 0.04992276f, 
    -0.14818484f, -0.04675803f, 0.00942555f, 0.14196092f, -0.07469030f, 0.03408781f, 0.00452711f, 0.04073996f, 
    0.00817415f, -0.03591496f, -0.08234224f, -0.02627207f, -0.15324675f, -0.06036299f, 0.00940824f, 0.09640945f, 
    0.13153173f, -0.02226429f, -0.01937789f, 0.15550511f, -0.03562862f, 0.12640725f, 0.05606429f, 0.08453571f, 
    -0.00614458f, 0.02728814f, -0.02155007f, -0.07030809f, 0.05506107f, -0.09052631f, 0.07503439f, -0.07696180f, 
    -0.01934125f, -0.03739849f, -0.04893753f, -0.00732803f, -0.02067610f, -0.19616348f, -0.10522238f, -0.08276073f, 
    -0.00781505f, 0.00556605f, -0.01814963f, 0.00740652f, -0.06654004f, -0.00382936f, 0.02518316f, -0.04020790f, 
    -0.07771854f, 0.00086556f, 0.04523229f, 0.27731252f, -0.14940950f, 0.22097009f, 0.13799357f, 0.09860177f, 
    -0.05358200f, 0.09080608f, 0.05891452f, 0.05118165f, 0.03605282f, -0.11696213f, 0.25361863f, -0.12961179f, 
    0.05688664f, -0.08444574f, -0.02779248f, -0.00978895f, 0.08907491f, -0.06140993f, 0.05367115f, 0.03470939f, 
    -0.07891192f, -0.12715797f, -0.07572155f, -0.04958413f, 0.01553005f, -0.03349803f, -0.12044405f, -0.05930423f, 
    0.03829736f, 0.10031899f, -0.03846855f, -0.01258637f, 0.00600617f, -0.12613709f, -0.15568528f, 0.16525130f, 
    -0.11702473f, 0.06517773f, 0.05935266f, -0.07798502f, 0.01552697f, 0.01558184f, 0.00463123f, 0.02961774f, 
    0.11844911f, 0.14963302f, 0.11283492f, 0.11713013f, 0.03817923f, -0.02952162f, -0.08788157f, -0.08700304f, 
    0.06865281f, 0.09187289f, 0.03779805f, -0.03120535f, 0.02716960f, 0.00563293f, -0.12359673f, 0.28505859f, 
    -0.04178703f, 0.14989179f, -0.03192776f, 0.00843606f, -0.17986855f, 0.02780336f, 0.15922022f, -0.16190186f, 
    -0.24357846f, 0.19369696f, 0.08070613f, -0.15386656f, 0.08905225f, 0.01966306f, -0.15686816f, 0.04080245f, 
    -0.11133069f, -0.06383742f, -0.10348272f, 0.03007508f, 0.16283460f, 0.07517157f, 0.00405940f, -0.07102605f, 
    -0.06142787f, -0.09918939f, -0.07147796f, 0.01915554f, 0.02671017f, -0.13049564f, 0.13923839f, -0.02402338f, 
    0.05082292f, -0.01173570f, 0.00691149f, -0.04743579f, -0.12970974f, -0.09398516f, 0.00393708f, 0.01950699f, 
    0.00340608f, 0.02729893f, 0.05105443f, -0.02059525f, 0.00356319f, -0.07457898f, 0.01433719f, -0.03635091f, 
    -0.05985626f, 0.07537367f, -0.06845320f, 0.10289991f, -0.01379952f, -0.03456267f, 0.05463003f, 0.01410856f, 
    0.06141697f, -0.01796405f, 0.13058782f, 0.19931234f, 0.00979095f, 0.01402909f, 0.15294842f, 0.00210837f, 
    -0.02687821f, 0.05479092f, -0.00906646f, 0.06719321f, 0.05231904f, -0.03532938f, -0.07387423f, -0.02378204f, 
    -0.01275888f, -0.00363820f, 0.02640541f, -0.07799163f, 0.16953519f, -0.01594028f, -0.02679854f, -0.07535542f, 
    -0.05006374f, -0.00657480f, 0.00540898f, 0.02037361f, -0.00970948f, 0.04584853f, -0.00816975f, 0.00246542f, 
    0.02285033f, 0.02680435f, -0.03773439f, -0.04624626f, -0.03685321f, -0.04870414f, -0.02828210f, -0.03638681f, 
    -0.01350623f, -0.04481026f, 0.02592844f, -0.01933808f, 0.01359828f, -0.02229024f, -0.00625441f, -0.03852865f, 
    -0.03562673f, -0.00804391f, -0.02342029f, 0.02125815f, 0.00539628f, 0.01866968f, -0.00064350f, 0.01120551f, 
    -0.01839264f, -0.04714034f, 0.00065905f, -0.05258388f, -0.02364695f, -0.03351675f, -0.01780083f, -0.02924207f, 
    -0.04773401f, 0.02208384f, 0.00576382f, -0.05571102f, -0.01144086f, 0.02347881f, -0.00881425f, 0.01111021f, 
    -0.04116629f, -0.00310770f, 0.02816092f, 0.01532564f, -0.00968095f, -0.05270360f, 0.01626543f, -0.01360568f, 
    -0.02261931f, 0.02127744f, 0.01734415f, -0.04980741f, 0.02814038f, 0.02723421f, 0.04303096f, 0.03495656f, 
    0.04878986f, -0.01096869f, 0.02819186f, -0.02545171f, -0.05351531f, 0.03395995f, 0.02027400f, 0.01515260f, 
    -0.02475497f, 0.01903029f, 0.01036039f, -0.05596527f, 0.04219825f, 0.03776892f, -0.02896444f, 0.00491530f, 
    0.03872817f, 0.01879696f, 0.03515644f, -0.00710720f, -0.03974006f, 0.02484924f, -0.00862548f, -0.01034612f, 
    0.00195809f, -0.01950547f, 0.03439013f, -0.05396893f, -0.04120122f, -0.04709739f, 0.03806938f, -0.05425649f, 
    -0.01742768f, -0.02996001f, 0.00067495f, -0.05833223f, -0.02208676f, -0.01022065f, -0.00622666f, -0.04371062f, 
    0.04463740f, -0.04064151f, -0.01550613f, 0.04069820f, -0.04170889f, 0.03769447f, 0.01707836f, -0.00490559f, 
    -0.02400773f, 0.00295004f, 0.03696573f, 0.03007714f, -0.01558108f, -0.04889293f, -0.01409809f, -0.03376572f, 
    0.00770429f, -0.01823035f, -0.04847229f, -0.05403674f, 0.02909335f, -0.04858917f, -0.00678147f, 0.00785259f, 
    -0.03244144f, -0.03680539f, -0.01869940f, 0.00068533f, -0.02157940f, 0.01519556f, -0.00586143f, -0.02207930f, 
    -0.03349810f, -0.04387794f, -0.03298862f, -0.05036478f, 0.04317756f, -0.01026013f, -0.05130152f, 0.04341123f, 
    0.01067005f, 0.00164611f, 0.00636812f, 0.04470365f, 0.01148413f, 0.01245814f, -0.02050699f, -0.05644302f, 
    -0.02974934f, -0.00625002f, 0.01823362f, 0.02403129f, -0.01391423f, -0.00545767f, 0.04412796f, 0.04293672f, 
    -0.01713491f, -0.00482203f, 0.02890790f, 0.00240703f, 0.02063828f, 0.04042055f, 0.00057615f, 0.04230682f, 
    0.00947639f, -0.03534014f, 0.00700308f, -0.05013504f, 0.02948464f, -0.04107720f, -0.05419856f, 0.03010331f, 
    -0.03617202f, 0.00418719f, 0.02518381f, -0.00724422f, 0.00268897f, -0.05691103f, -0.03058406f, -0.02644578f, 
    -0.02988813f, 0.00689126f, 0.01561524f, -0.00418025f, 0.03007377f, -0.00251279f, 0.03296127f, -0.04235816f, 
    0.03897623f, -0.00597851f, -0.00203630f, -0.03609186f, -0.05834749f, -0.00156496f, -0.05510397f, -0.05737387f, 
    -0.00935085f, 0.00635442f, -0.05638950f, -0.02809935f, 0.02729974f, 0.02896642f, -0.04377902f, -0.00278673f, 
    -0.05302969f, -0.02347935f, -0.00818106f, 0.04715329f, 0.00164000f, -0.01578774f, -0.02881414f, 0.04445119f, 
    0.03400700f, -0.01942625f, -0.01055120f, -0.04803398f, 0.02150488f, 0.03607934f, 0.00869369f, 0.02170234f, 
    -0.04290282f, -0.03110182f, 0.02896094f, 0.02435300f, -0.01059014f, 0.01039677f, -0.01472089f, -0.03165098f, 
    0.01376457f, 0.00437851f, 0.01528384f, -0.00510705f, 0.02704411f, -0.03856071f, 0.03641601f, 0.00685899f, 
    -0.05341817f, 0.00028592f, 0.01377995f, 0.02962354f, -0.01763077f, -0.03549407f, 0.02798362f, -0.04636562f, 
    -0.02798837f, 0.01469922f, -0.01528748f, 0.04004363f, 0.04146911f, 0.03849193f, 0.02557243f, -0.01056419f, 
    -0.03042870f, 0.04216358f, -0.05886589f, 0.01051742f, 0.01998880f, -0.02739448f, -0.04106164f, -0.03021696f, 
    -0.03469491f, 0.02951472f, -0.03352949f, 0.00877334f, 0.02145292f, 0.00052033f, 0.01331986f, -0.00398383f, 
    -0.04373395f, 0.02935782f, 0.03855353f, 0.02745963f, 0.03126684f, -0.02278222f, -0.01794299f, 0.02684997f, 
    -0.01057886f, -0.00631575f, -0.03205521f, -0.01921406f, -0.02059842f, -0.02165017f, 0.01778983f, -0.05043528f, 
    -0.03105805f, -0.03657482f, 0.02562376f, 0.02215181f, 0.03761882f, 0.00294098f, 0.00345317f, -0.02800326f, 
    -0.04089708f, -0.00161079f, 0.00002588f, 0.03517773f, 0.00043812f, -0.04952251f, 0.00607944f, -0.01653295f, 
    0.00606558f, -0.01086852f, -0.05369135f, -0.03958726f, -0.05902189f, 0.01568756f, 0.03670637f, -0.05902474f, 
    0.01422038f, 0.03246834f, -0.05439014f, -0.03667758f, 0.01004376f, -0.04301558f, 0.02641625f, 0.00254385f, 
    -0.02022927f, -0.05370782f, -0.05262077f, 0.00715369f, -0.03458758f, -0.05519681f, -0.04826716f, -0.05665170f, 
    -0.01561328f, 0.01615807f, 0.02338561f, 0.02931082f, -0.02605060f, -0.01687443f, -0.00053044f, 0.03414629f, 
    0.00276281f, -0.05805724f, 0.02973536f, 0.03876355f, -0.03234081f, -0.03624608f, -0.00128542f, -0.04320024f, 
    -0.03016153f, 0.00593272f, -0.05527990f, -0.03926862f, -0.00116058f, -0.04017043f, -0.01314664f, -0.04484480f, 
    0.00582139f, -0.01433584f, -0.03453702f, -0.00397238f, -0.00494874f, -0.01612116f, 0.03805823f, 0.00443182f, 
    -0.02871153f, 0.02464589f, -0.02958487f, -0.02456138f, -0.01856027f, -0.04094046f, 0.00151396f, -0.04139860f, 
    -0.04911619f, 0.02452254f, -0.01915187f, -0.01836138f, -0.00341248f, 0.01015597f, 0.00881485f, -0.00184298f, 
    -0.03717702f, -0.02513460f, 0.00852524f, 0.03560524f, -0.01246776f, -0.02391362f, 0.02738639f, -0.01510642f, 
    -0.02394887f, 0.01094514f, 0.02073060f, -0.02222645f, 0.02908269f, 0.01347827f, 0.01652047f, 0.01425265f, 
    0.02391836f, -0.02036826f, 0.01293488f, -0.04270502f, 0.01405239f, -0.03019993f, 0.04153859f, 0.04209917f, 
    -0.02885409f, -0.00354000f, -0.01588847f, 0.00277215f, -0.01973009f, -0.04862148f, -0.00030853f, -0.02120192f, 
    0.03492516f, -0.01413452f, -0.00269773f, 0.00429232f, 0.04191934f, 0.01438857f, -0.01304400f, -0.01730133f, 
    0.01791440f, 0.03873400f, -0.05453419f, 0.00784260f, 0.01160939f, -0.03382210f, -0.01258807f, -0.01341707f, 
    -0.01701323f, -0.03079785f, -0.05321953f, -0.03832972f, -0.05158120f, -0.00714797f, -0.03525015f, 0.03558023f, 
    0.00822018f, -0.02229995f, -0.01688404f, 0.00181458f, -0.02285838f, -0.01885224f, 0.04185071f, 0.03119165f, 
    -0.00599050f, -0.01295374f, -0.03659961f, -0.04573046f, -0.02585282f, 0.01315560f, -0.03175797f, -0.02520710f, 
    -0.02839334f, -0.05137200f, -0.03296377f, 0.01082583f, -0.02542885f, -0.02435267f, 0.03516171f, -0.03977021f, 
    -0.02369707f, 0.01052575f, 0.02131731f, -0.04948578f, -0.00484076f, 0.04052191f, -0.02721139f, 0.01237452f, 
    0.03709944f, -0.03220230f, -0.01465233f, -0.03453192f, 0.03743985f, 0.03744366f, 0.04138732f, 0.04166538f, 
    -0.03751717f, 0.00450201f, -0.03694553f, 0.03390880f, 0.02416147f, -0.05023576f, 0.03066589f, -0.03805466f, 
    -0.03546564f, -0.05930861f, -0.01383448f, 0.02526023f, -0.00624430f, -0.02776035f, -0.03263240f, 0.00216142f, 
    -0.04864119f, -0.00171351f, -0.01347510f, 0.01036431f, -0.01296871f, -0.03781042f, 0.02130058f, -0.02336716f, 
    0.00510251f, 0.00984862f, 0.01769844f, -0.01735442f, -0.05361705f, -0.04551423f, 0.00392328f, -0.02255282f, 
    0.04127379f, 0.01094755f, 0.01762543f, -0.03520579f, -0.05778146f, -0.03615925f, -0.03432598f, -0.02011192f, 
    -0.05665125f, -0.00328734f, 0.02138662f, -0.03958431f, -0.02674183f, 0.01112692f, 0.02197416f, 0.00119087f, 
    -0.02016331f, 0.03862718f, 0.02725133f, -0.05414656f, 0.02534837f, -0.02026414f, -0.04473381f, -0.00304907f, 
    -0.04808448f, 0.03157141f, -0.02158011f, 0.02787647f, 0.04222152f, -0.00137219f, 0.00031607f, -0.01352929f, 
    -0.05781924f, -0.02171253f, -0.03507966f, -0.02963447f, 0.03463596f, -0.03123350f, 0.01826756f, 0.00083043f, 
    0.01395355f, -0.01996377f, 0.00124152f, 0.02936756f, -0.00237482f, 0.03812952f, -0.05452332f, -0.01408643f, 
    0.02486266f, -0.04336574f, 0.01391359f, -0.02573716f, -0.02971957f, 0.03450809f, 0.00355975f, -0.03373977f, 
    -0.03654291f, 0.01141674f, 0.01483520f, 0.02417405f, 0.01504574f, 0.01031448f, -0.04571502f, 0.02014152f, 
    -0.00842155f, 0.00347694f, -0.03996836f, -0.02897263f, -0.03235004f, -0.03414363f, 0.01019311f, -0.01111843f, 
    -0.04759410f, -0.03466750f, 0.03709684f, 0.01104911f, -0.05474366f, 0.00837968f, 0.03923011f, -0.05692748f, 
    -0.04876970f, -0.05679581f, -0.03301649f, -0.04251948f, -0.00545705f, 0.01151882f, -0.02992871f, -0.03853644f, 
    -0.01542185f, 0.00396943f, 0.03830273f, 0.03509400f, -0.01481900f, -0.03859451f, -0.04824033f, 0.02103294f, 
    -0.02849087f, -0.04658490f, 0.02742426f, 0.03039720f, -0.04140433f, -0.03241620f, 0.02248229f, -0.00192004f, 
    0.00913042f, 0.01051979f, 0.00555320f, -0.01334105f, 0.01369455f, -0.00233654f, -0.00348874f, -0.01296043f, 
    -0.02726606f, 0.01273712f, -0.00942152f, -0.00740778f, -0.04725752f, -0.02438219f, -0.03436881f, 0.01971836f, 
    0.02075771f, -0.01478524f, 0.03380304f, -0.05680996f, -0.05047378f, 0.01228332f, -0.05833090f, 0.02864723f, 
    0.02924178f, -0.02235086f, -0.05165438f, -0.03905947f, -0.03027482f, -0.04634676f, -0.01532391f, 0.00500708f, 
    -0.04923386f, 0.01390463f, -0.03760648f, 0.03572774f, 0.02463676f, -0.01189872f, -0.00486869f, -0.03972938f, 
    0.00112797f, 0.02004819f, 0.04132268f, -0.02076364f, -0.04329970f, 0.03007370f, 0.00416280f, -0.04780595f, 
    -0.02311704f, -0.02733071f, -0.02179419f, -0.01179151f, -0.00633602f, -0.02136325f, -0.02276195f, -0.02391136f, 
    -0.04695930f, -0.02757608f, -0.03487951f, -0.00954704f, -0.04329947f, -0.01967092f, 0.00061973f, 0.02104110f, 
    0.04214706f, -0.01316429f, -0.02976516f, -0.01029519f, -0.04166433f, 0.02649700f, -0.03699286f, -0.02152966f, 
    -0.03518894f, -0.04220005f, 0.03644802f, 0.01484629f, -0.01855297f, -0.04704533f, -0.01358567f, -0.02076487f, 
    -0.00160229f, 0.01076688f, 0.01892408f, -0.02669218f, 0.00184263f, -0.04831843f, -0.00874511f, -0.04038848f, 
    0.03435397f, 0.03900943f, 0.02758406f, -0.03210314f, -0.02179953f, -0.04181882f, -0.05274970f, 0.01450993f, 
    0.00037759f, -0.01364998f, 0.00604249f, 0.03058022f, 0.04489584f, -0.02042665f, -0.01662410f, 0.00195299f, 
    -0.00860996f, -0.01303318f, 0.04033571f, 0.02924821f, -0.00476883f, 0.01978527f, -0.04682027f, 0.00945308f, 
    -0.02343395f, 0.02017060f, -0.00237523f, 0.00343198f, 0.00528890f, 0.03093976f, -0.04579425f, 0.00595395f, 
    -0.04236329f, 0.03414600f, 0.02548998f, 0.03532745f, 0.00836670f, 0.01769172f, -0.01163409f, 0.00390348f, 
    0.00783176f, 0.03658525f, -0.00582650f, 0.00277462f, 0.01453564f, 0.00985993f, 0.03792548f, -0.02277523f, 
    -0.02374680f, -0.01663060f, 0.03485593f, 0.03824602f, 0.02194726f, 0.01983170f, 0.01099487f, 0.04161064f, 
    0.00901818f, -0.02120534f, 0.02561630f, -0.00896806f, -0.00009053f, -0.03877228f, -0.02929641f, -0.04310567f, 
    -0.04117547f, -0.03655026f, 0.03449485f, -0.04112928f, -0.04512744f, -0.00453900f, -0.03201852f, 0.02636637f, 
    0.03658281f, -0.04773484f, -0.02605296f, 0.01595034f, -0.04037160f, -0.05639508f, -0.01400145f, 0.03654960f, 
    -0.02969502f, 0.02547020f, 0.03033333f, 0.03157367f, -0.03071273f, 0.04304316f, 0.03731452f, 0.01734632f, 
    0.04299043f, -0.02815942f, -0.03313138f, 0.03119236f, -0.05933297f, -0.00547520f, -0.02000006f, -0.03519141f, 
    0.02398209f, 0.02809831f, -0.02498951f, 0.04274976f, -0.02885455f, -0.02984448f, -0.00999079f, 0.00716534f, 
    -0.00961892f, -0.04180913f, -0.01194033f, -0.00644126f, 0.01375982f, 0.01874096f, 0.00568168f, 0.03447713f, 
    0.00777389f, 0.02847937f, -0.00238786f, -0.00462278f, -0.03668631f, 0.00283809f, -0.05226804f, -0.05516396f, 
    -0.03921835f, -0.00198684f, -0.00637360f, 0.02574707f, -0.02357571f, 0.02398691f, 0.00900225f, 0.00217061f, 
    -0.01248954f, -0.05038873f, -0.01518099f, -0.03157903f, 0.00150358f, 0.03199113f, -0.02658396f, -0.01431831f, 
    0.02075743f, -0.02574394f, 0.02133896f, -0.04546275f, 0.03018781f, -0.03373947f, -0.05360392f, -0.01489625f, 
    -0.03204219f, -0.03672115f, 0.00071246f, -0.04997113f, 0.01134201f, -0.01420282f, 0.02695946f, -0.00900595f, 
    -0.04230842f, 0.00838951f, 0.04171108f, 0.02215049f, -0.02363220f, 0.00167795f, -0.02418120f, -0.03721740f, 
    -0.03561944f, 0.00604749f, -0.03767562f, -0.05155125f, 0.02898844f, 0.02370529f, 0.00155972f, 0.03054852f, 
    -0.01149905f, 0.01890073f, -0.01282799f, 0.04203548f, -0.03584077f, 0.02174914f, -0.01763599f, 0.00422277f, 
    0.01233832f, 0.03788663f, 0.00577677f, -0.05311250f, -0.01000173f, 0.01632430f, -0.04794319f, 0.00574365f, 
    -0.02938046f, -0.01533604f, -0.00506259f, 0.01331056f, -0.01346587f, -0.03597598f, -0.00475324f, 0.04230502f, 
    0.02785443f, -0.03165358f, -0.03989053f, -0.01331837f, -0.01883460f, -0.00377336f, 0.01497794f, -0.04152267f, 
    -0.04499734f, -0.04406870f, -0.02463047f, -0.02788043f, 0.00987344f, 0.04213051f, 0.02557145f, -0.00110477f, 
    0.02334106f, -0.00319807f, -0.00711009f, -0.02001829f, 0.02022471f, -0.01559127f, -0.00968480f, 0.00811626f, 
    -0.04195471f, -0.00363150f, 0.04185152f, 0.00578082f, 0.02084429f, -0.02884983f, -0.05699179f, 0.00129590f, 
    -0.02948987f, 0.01458159f, -0.00212288f, 0.00333358f, 0.03297262f, -0.02468571f, -0.03494357f, -0.03597793f, 
    -0.05678530f, -0.03637172f, 0.01702409f, 0.04015497f, -0.03403115f, -0.01102833f, 0.03592713f, -0.02630121f, 
    0.01401707f, -0.00605035f, -0.01114663f, -0.00840522f, -0.02997371f, 0.02510458f, 0.02859346f, 0.00425872f, 
    -0.01126570f, 0.03955414f, -0.01978349f, -0.03609958f, 0.04184687f, -0.04747257f, -0.02713222f, -0.04099777f, 
    0.02097026f, 0.02262506f, -0.00453781f, -0.03175260f, 0.03191838f, -0.04106088f, -0.03979371f, 0.00252808f, 
    -0.05064305f, 0.03177347f, -0.00758395f, -0.02476934f, -0.04298987f, 0.01033056f, 0.00356394f, -0.03851630f, 
    -0.00936599f, -0.03579015f, -0.00418187f, -0.02234027f, 0.00663049f, -0.04481100f, 0.01283642f, -0.01769152f, 
    0.00311795f, -0.05601711f, 0.01644734f, -0.01173303f, -0.05233260f, -0.01336265f, 0.02485848f, -0.00874020f, 
    0.01210535f, 0.01556175f, 0.03430614f, 0.04019211f, -0.05065135f, 0.03662283f, -0.04435360f, 0.00068868f, 
    -0.04926053f, 0.01173874f, -0.02441209f, -0.01248620f, 0.04167934f, 0.01416034f, -0.00237937f, -0.03339101f, 
    -0.05718861f, -0.04580587f, -0.01531805f, -0.05195653f, -0.03096785f, -0.04698902f, 0.03873520f, 0.00280305f, 
    -0.00533624f, -0.03810807f, -0.01052906f, 0.04289767f, 0.03425632f, -0.05158640f, 0.00460930f, -0.01089425f, 
    -0.00576777f, -0.01218034f, -0.02233448f, 0.03379548f, -0.01033665f, -0.02588830f, 0.00802950f, -0.04804725f, 
    -0.04701708f, -0.02723105f, 0.01260704f, -0.00051030f, 0.00603602f, -0.04557218f, 0.00312628f, -0.02738064f, 
    0.03749745f, -0.02905453f, -0.03434549f, -0.01044772f, 0.00832577f, -0.02139672f, 0.02009359f, -0.04555421f, 
    -0.04840899f, -0.04200627f, 0.02113656f, 0.00007660f, 0.01780874f, -0.03257089f, -0.02062888f, -0.00480479f, 
    -0.02525349f, -0.00616015f, -0.00892940f, -0.03210664f, -0.03249403f, -0.02185152f, -0.01935473f, 0.03774928f, 
    -0.02848836f, -0.03866167f, 0.00553403f, 0.01143399f, 0.03782224f, -0.02809154f, -0.04897053f, -0.05490248f, 
    0.02794042f, -0.02622581f, 0.00399496f, 0.01564184f, -0.02360734f, -0.03065226f, 0.01776093f, -0.02182691f, 
    0.01120801f, -0.04425364f, 0.00903138f, -0.04141712f, -0.05069617f, -0.00594935f, 0.02932173f, -0.00821455f, 
    -0.00009004f, -0.04006461f, -0.03178164f, -0.03756080f, 0.03246216f, 0.00256615f, -0.01551226f, 0.02993815f, 
    -0.04864558f, -0.01393854f, -0.02122352f, -0.05416177f, -0.00192654f, 0.03833383f, -0.02256513f, -0.02560453f, 
    0.04070825f, -0.05504933f, -0.01740348f, 0.02929441f, 0.03270330f, -0.01435850f, 0.01656103f, -0.00357018f, 
    -0.02630149f, -0.02706449f, 0.03387915f, -0.04339361f, -0.02961545f, -0.05064294f, 0.02246966f, -0.00186611f, 
    -0.04293259f, 0.03345631f, -0.04238655f, -0.05416204f, -0.03385005f, -0.04949375f, 0.02309328f, -0.02416169f, 
    -0.01925650f, -0.05829224f, -0.03945038f, -0.04113277f, -0.01439686f, -0.01660489f, -0.01621480f, -0.00945115f, 
    -0.04579838f, -0.03645138f, 0.03074607f, -0.05345457f, -0.03909787f, 0.01283749f, -0.04265920f, 0.00876675f, 
    -0.01122693f, -0.04441526f, -0.02573310f, 0.02535877f, 0.01566050f, 0.02019262f, -0.05110723f, 0.03116695f, 
    0.03511155f, -0.02752943f, -0.01432879f, 0.00131498f, 0.01656739f, 0.03762187f, -0.05841241f, 0.00209878f, 
    -0.14290623f, 0.15041460f, 0.21736722f, -0.17510054f, -0.14234003f, 0.09438353f, 0.09870652f, -0.06285958f, 
    -0.13563989f, 0.01712147f, -0.19724138f, -0.08884737f, -0.10587118f, -0.02226994f, 0.01418861f, 0.12764212f, 
    0.03057240f, -0.09151129f, -0.06039206f, -0.14952855f, -0.09220931f, -0.04342160f, 0.09087364f, 0.09087684f, 
    -0.13665183f, -0.45908299f, 0.19631398f, 0.18773249f, 0.08508035f, -0.01465714f, 0.01779768f, 0.24477875f, 
    -0.00568339f, 0.02835247f, -0.07180834f, 0.10006534f, 0.02269824f, 0.00060103f, 0.23947263f, -0.28846964f, 
    0.10451110f, 0.08216025f, 0.01533122f, -0.01072990f, 0.06250565f, 0.11224936f, 0.06378113f, -0.09642876f, 
    0.07874898f, -0.30420229f, 0.24276234f, -0.05986847f, 0.07534042f, -0.01455848f, 0.13018894f, 0.24057160f, 
    -0.01031509f, 0.13399428f, 0.01008777f, -0.00231106f, 0.12608120f, -0.03531520f, 0.03119877f, 0.14370571f, 
    0.15849455f, 0.07302881f, 0.00696085f, 0.08864850f, 0.03378012f, -0.11682160f, -0.10772610f, -0.08729038f, 
    0.21117747f, -0.11006520f, 0.05475751f, -0.01229671f, 0.15194033f, 0.15313226f, 0.03558662f, 0.17990154f, 
    0.10412152f, -0.05272839f, 0.09603259f, 0.19711350f, -0.41993949f, -0.08226952f, 0.12732372f, 0.22777079f, 
    -0.06373990f, -0.15260381f, 0.07373924f, 0.06012243f, -0.07236333f, -0.19994184f, -0.05798569f, -0.02977785f, 
    -0.10483177f, 0.03236277f, 0.06934856f, 0.00930621f, -0.08012760f, 0.02203482f, 0.08481241f, -0.09579071f, 
    0.05078463f, -0.10421886f, -0.08111211f, -0.07402071f, 0.57127339f, -0.09018395f, 0.34412867f, -0.22092177f, 
    0.00571115f, 0.14675830f, -0.00106289f, -0.03524227f, -0.06200460f, -0.10604866f, 0.02301822f, -0.10861126f, 
    0.12598458f, 0.32394230f, 0.13360274f, -0.01009983f, -0.05964899f, -0.08158228f, 0.10773385f, 0.13523650f, 
    -0.02470907f, 0.06339770f, 0.07218594f, 0.12264328f, -0.05989478f, 0.15509315f, 0.15170984f, 0.04675234f, 
    -0.01220163f, -0.01765142f, 0.09561254f, -0.01077737f, 0.08445904f, -0.06345925f, -0.03360826f, -0.20156121f, 
    -0.33095527f, 0.10715839f, 0.28567231f, 0.00266753f, -0.21504831f, -0.11615867f, -0.06112639f, 0.09230704f, 
    0.07182602f, -0.02111889f, 0.02837921f, 0.03522386f, -0.05834150f, -0.01475663f, -0.19079764f, -0.13323922f, 
    -0.06283177f, -0.01962512f, -0.02346401f, 0.05380189f, -0.06896377f, -0.11534756f, -0.02592135f, -0.11206758f, 
    -0.08603401f, -0.06952648f, 0.10180742f, 0.24053229f, 0.04629692f, 0.05447263f, -0.03567078f, 0.11984488f, 
    0.22177647f, 0.05372624f, 0.12281411f, 0.18128130f, 0.35345054f, 0.17240322f, -0.02028940f, 0.02369270f, 
    0.08027469f, -0.00905259f, 0.03610643f, 0.12191112f, 0.00990590f, 0.00267510f, -0.13387874f, -0.01921436f, 
    -0.10221213f, -0.01096907f, 0.02975025f, -0.04433236f, -0.02072447f, -0.04416645f, 0.15722822f, 0.04637511f, 
    0.03412959f, 0.04499135f, -0.08769434f, 0.10985303f, -0.10640087f, -0.03683020f, 0.13175106f, -0.07725500f, 
    -0.02999094f, 0.07554378f, 0.13411714f, 0.09870119f, -0.07067979f, 0.00719231f, -0.08198926f, -0.08878606f, 
    -0.14500214f, -0.00194001f, 0.00603852f, 0.06429088f, 0.00522671f, 0.04118999f, -0.06224621f, 0.02207146f, 
    0.10556414f, 0.13180597f, 0.13337564f, 0.09957990f, 0.23927978f, -0.08150766f, -0.15412730f, 0.07310215f, 
    -0.01819360f, 0.00451802f, -0.03560701f, 0.00712719f, -0.00314274f, -0.07677232f, -0.04368623f, -0.07674038f, 
    -0.10372765f, -0.05417310f, -0.02635550f, -0.02442205f, -0.02791025f, -0.03634941f, -0.02786365f, 0.01746218f, 
    0.05958354f, -0.00577248f, 0.09937899f, 0.11425161f, -0.34093755f, -0.13126543f, 0.24375980f, 0.10161676f, 
    -0.09807539f, -0.00554031f, 0.00753146f, -0.04328506f, 0.21248724f, 0.03750917f, 0.23231043f, 0.06579896f, 
    0.25875187f, -0.00783421f, 0.04788727f, -0.06089409f, -0.00989986f, 0.02129158f, -0.09891364f, 0.02353149f, 
    0.06722504f, 0.11363795f, -0.06553459f, 0.17529714f, -0.19121630f, -0.32559961f, -0.11227350f, 0.68229407f, 
    0.02029636f, 0.09048881f, 0.03558879f, -0.00070075f, 0.22711489f, 0.03245351f, 0.14647348f, -0.08913790f, 
    -0.30493566f, -0.32310593f, -0.07210547f, 0.54170609f, -0.01202751f, -0.06114994f, -0.03213426f, 0.08014598f, 
    0.15218467f, 0.07161006f, 0.11937319f, 0.01085510f, 0.00549561f, 0.05508728f, -0.15014261f, 0.11287948f, 
    0.09844366f, -0.04217037f, 0.04882808f, -0.00010247f, 0.18580014f, -0.01538405f, 0.16770825f, -0.00461894f, 
    0.00352374f, -0.20423688f, 0.28865421f, 0.11455704f, 0.00015354f, -0.06799015f, -0.08531729f, 0.20984720f, 
    0.11971825f, 0.11525377f, -0.11079959f, -0.05569117f, -0.09831105f, 0.04404277f, 0.02476675f, 0.10753161f, 
    0.14824738f, -0.07645184f, -0.01639568f, 0.11304089f, 0.15770322f, 0.09657001f, 0.21961208f, 0.03121904f, 
    -0.07443581f, -0.14290667f, -0.00097206f, -0.15475966f, 0.00092682f, -0.11713124f, 0.00243317f, 0.06651440f, 
    -0.19753550f, -0.20560411f, -0.07451158f, -0.16854559f, 0.15492453f, -0.03909637f, 0.00849825f, -0.04015456f, 
    0.13855021f, 0.24690276f, -0.11670650f, 0.27622235f, -0.09145903f, 0.01029979f, -0.11361973f, -0.05344779f, 
    -0.16911164f, 0.05301942f, -0.06893094f, 0.01230282f, 0.10418660f, -0.06102577f, 0.12837814f, 0.15087512f, 
    -0.05330475f, -0.03349853f, -0.07143915f, 0.04689765f, 0.11475486f, -0.13577473f, -0.15068924f, -0.09140305f, 
    0.00369429f, 0.05112247f, -0.01327987f, 0.01214481f, 0.08046477f, 0.11435379f, 0.05075954f, 0.06728756f, 
    0.11111192f, -0.08335000f, -0.03718905f, -0.05381667f, -0.06264973f, 0.10757786f, -0.03219592f, 0.01824872f, 
    0.01135078f, -0.03679984f, -0.03298777f, -0.02172726f, 0.31151316f, -0.03193363f, 0.03468953f, -0.12706050f, 
    0.08362314f, 0.06584562f, 0.02579864f, -0.16894110f, -0.01730008f, -0.01002416f, 0.02527516f, -0.13721386f, 
    0.25526196f, -0.33856213f, 0.21988723f, -0.02240769f, 0.04576765f, 0.01437881f, -0.10086389f, 0.34184036f, 
    -0.11464504f, 0.00077521f, -0.05486015f, 0.05553149f, -0.02489805f, -0.01245166f, 0.03748793f, -0.09265006f, 
    -0.00278096f, 0.19841418f, -0.09453350f, -0.03437976f, -0.04929779f, -0.03618186f, 0.01821961f, 0.06344477f, 
    0.29377168f, 0.02391359f, 0.13232152f, 0.06855761f, 0.15114398f, -0.09702774f, 0.14797130f, -0.04539119f, 
    -0.05786506f, 0.04661593f, -0.00730607f, 0.08054290f, 0.09766685f, -0.06153321f, -0.02919322f, -0.13477699f, 
    0.05202268f, -0.02220012f, 0.03307537f, -0.06561656f, 0.07125298f, -0.08121017f, 0.00473889f, -0.15809679f, 
    -0.22646409f, -0.07329039f, 0.22979073f, 0.06022449f, -0.08840780f, 0.10423433f, -0.06044260f, -0.14351250f, 
    0.03249978f, -0.00693451f, 0.01046733f, -0.06477349f, 0.10428999f, -0.37519965f, 0.05880120f, -0.21240903f, 
    -0.00777016f, 0.00155486f, 0.09350536f, 0.00857339f, -0.10569305f, 0.01452571f, 0.12918696f, 0.24970473f, 
    0.26070425f, -0.08303683f, -0.10333515f, -0.08460018f, -0.08524479f, -0.12325612f, -0.02020062f, -0.05003163f, 
    0.04573247f, -0.01840146f, -0.06765288f, 0.06638860f, 0.29839808f, -0.16887386f, 0.26846120f, 0.02404466f, 
    -0.08120262f, -0.02353862f, 0.21739309f, -0.05935583f, -0.00069915f, 0.12377990f, -0.04661345f, 0.00795640f, 
    -0.26679841f, -0.10402473f, -0.01762331f, 0.20901509f, 0.00153195f, 0.00234262f, 0.07116184f, 0.07636296f, 
    0.12451123f, 0.12743568f, 0.00227509f, 0.21580426f, -0.20615247f, -0.07545108f, -0.01208581f, 0.23610836f, 
    0.10773734f, -0.13253032f, 0.00225757f, -0.20360743f, 0.05205111f, -0.11376442f, -0.03926580f, -0.09592656f, 
    -0.23110493f, 0.11168698f, 0.22524260f, -0.01399654f, -0.02115106f, 0.10067279f, -0.02667085f, 0.01497215f, 
    0.09169094f, 0.14796789f, 0.09528123f, 0.13634789f, -0.01753065f, 0.05458473f, 0.00505108f, -0.09838051f, 
    0.07968315f, 0.08401247f, 0.01630685f, 0.13321057f, -0.03500034f, -0.00561247f, -0.03926139f, -0.11610734f, 
    0.23706342f, 0.10548790f, 0.10804806f, -0.29018483f, -0.11496556f, -0.05261141f, 0.07165285f, 0.11576077f, 
    0.14311692f, -0.16821308f, 0.12265379f, 0.06675307f, 0.09876432f, 0.02476073f, -0.01312990f, 0.20257828f, 
    0.05288370f, 0.04457451f, 0.09552706f, 0.14850675f, 0.05896981f, -0.04855629f, -0.00763681f, 0.03425962f, 
    0.09426232f, -0.17848869f, 0.03403944f, -0.04537367f, 0.01839582f, 0.12543440f, 0.09250962f, 0.08741070f, 
    -0.07033648f, 0.12103388f, 0.04091770f, 0.24246474f, 0.02499962f, 0.02133829f, 0.02794855f, 0.17155112f, 
    0.06209034f, 0.15755372f, 0.25109690f, 0.12339554f, 0.01984290f, 0.07719769f, 0.04217860f, 0.12902886f, 
    -0.01228664f, 0.01943823f, -0.01723615f, 0.00689257f, 0.05417345f, 0.08863018f, -0.02570798f, 0.07891249f, 
    0.01257581f, -0.06700006f, -0.11135346f, 0.08777289f, 0.21976985f, 0.00026613f, -0.02299009f, 0.05602184f, 
    0.11229628f, -0.03860703f, 0.00686978f, 0.07570323f, 0.00444021f, -0.05211882f, -0.12751955f, -0.09961709f, 
    0.13062572f, 0.00269279f, 0.06896282f, -0.00228647f, -0.04696343f, 0.03231893f, 0.17095119f, -0.00843025f, 
    -0.01762681f, 0.01737346f, 0.01134755f, 0.01167954f, -0.27454028f, -0.03374130f, -0.05322368f, -0.14039434f, 
    0.06649022f, -0.01003080f, 0.05075476f, 0.05961698f, 0.13525800f, 0.08508627f, -0.00307420f, 0.05563747f, 
    0.13609341f, -0.04528015f, 0.06698216f, 0.10428177f, 0.05255705f, 0.04805660f, 0.02381583f, 0.00937687f, 
    -0.11035110f, 0.01326640f, -0.05116779f, 0.03691204f, 0.22715199f, -0.08883162f, 0.06026804f, 0.03821244f, 
    -0.09606503f, 0.05487062f, 0.04402437f, -0.05952474f, 0.09273397f, 0.01279275f, -0.07913693f, -0.10773519f, 
    -0.09811843f, -0.11350968f, -0.10638386f, 0.03280989f, 0.11001468f, -0.02095179f, -0.07371856f, -0.09840241f, 
    0.11164599f, 0.08798187f, -0.06765397f, -0.02940818f, 0.14659722f, 0.00323587f, 0.11363089f, 0.21952675f, 
    -0.08095915f, -0.02752571f, 0.01639747f, -0.03954558f, 0.17575212f, 0.03657085f, 0.13134252f, 0.05201080f, 
    -0.18393400f, 0.17936398f, -0.07466847f, 0.11747384f, 0.01737643f, -0.03129225f, -0.08758590f, 0.13157231f, 
    -0.30677980f, -0.10117240f, -0.05181060f, 0.08200626f, 0.12023605f, -0.01871161f, -0.08295404f, -0.15254019f, 
    0.02950641f, -0.10011008f, 0.02316426f, 0.10013247f, -0.10050042f, 0.02920731f, 0.12945442f, -0.14907055f, 
    0.04372534f, -0.09437016f, -0.16247933f, -0.04023110f, 0.04583592f, -0.05939850f, -0.01802055f, 0.11528294f, 
    0.07189960f, -0.02850662f, -0.04080679f, -0.10312881f, 0.16042458f, 0.02917499f, 0.02843608f, 0.01416969f, 
    0.11152659f, 0.07464480f, -0.20738295f, 0.21038114f, 0.03030477f, -0.04893587f, -0.13025483f, -0.10474145f, 
    0.12601653f, 0.05328597f, 0.24289608f, 0.13582556f, 0.03047273f, 0.26293007f, 0.19904719f, -0.03538580f, 
    0.07966723f, 0.01145738f, -0.07429133f, 0.21379222f, 0.04205909f, -0.00503263f, -0.07533519f, -0.05019516f, 
    0.04741200f, 0.05582970f, 0.04259611f, 0.02978591f, 0.10939780f, 0.00161007f, -0.05394807f, 0.08942535f, 
    0.18769470f, -0.00675481f, 0.19946037f, 0.18838067f, 0.08625887f, 0.02370878f, 0.07208515f, 0.13457750f, 
    0.07565956f, -0.03452975f, -0.05996335f, 0.06313774f, -0.11195458f, 0.11029579f, 0.14089119f, 0.24359883f, 
    -0.06314600f, 0.06143449f, 0.08176693f, 0.22789378f, 0.00962005f, 0.12386315f, 0.01870142f, 0.09977200f, 
    -0.23209548f, 0.05290809f, -0.08747003f, -0.03679932f, 0.20592791f, 0.10227691f, 0.04229081f, -0.03651046f, 
    0.17193750f, -0.02579298f, -0.10928418f, -0.06955971f, 0.01191668f, -0.04044279f, 0.21198061f, 0.15644453f, 
    -0.07054833f, -0.04858298f, 0.08418784f, -0.07523622f, 0.00308734f, 0.01059623f, 0.01147064f, -0.13434748f, 
    0.11718485f, -0.07464039f, 0.02852840f, -0.24845615f, -0.10267333f, 0.09365483f, -0.03190576f, 0.10668269f, 
    -0.05816605f, -0.13771571f, -0.04780998f, -0.06978153f, -0.10780713f, 0.04283113f, 0.01655081f, 0.01372309f, 
    -0.06152471f, 0.01169707f, 0.10838372f, -0.04631938f, -0.10721274f, -0.02697976f, 0.11371263f, 0.12000164f, 
    0.20496047f, -0.11736322f, -0.14337999f, 0.08030392f, 0.02801634f, 0.09173167f, 0.06082304f, 0.10480922f, 
    -0.05392366f, 0.00773916f, -0.05330684f, -0.04587252f, 0.08530696f, 0.20897430f, 0.05581260f, -0.02536449f, 
    0.05358306f, 0.10289552f, 0.17512134f, 0.14407213f, 0.04814687f, 0.03675250f, -0.02421761f, -0.27775288f, 
    -0.14771378f, 0.01101814f, 0.25255591f, -0.01623132f, 0.12424623f, 0.05570322f, -0.10279983f, 0.06118414f, 
    -0.02388089f, 0.06472353f, 0.02365809f, 0.02195789f, 0.21188851f, 0.30277404f, 0.39506516f, 0.22161588f, 
    0.09549484f, 0.01554492f, 0.00094485f, 0.01724515f, -0.10126296f, -0.05272312f, 0.03016762f, -0.01215213f, 
    -0.03825146f, -0.05042870f, -0.10809755f, -0.23763467f, 0.00128522f, -0.00060133f, -0.08400350f, -0.12483760f, 
    -0.02493057f, -0.07078180f, 0.01840825f, -0.14228047f, 0.28963998f, 0.02874291f, 0.00827832f, 0.08972635f, 
    -0.03896573f, 0.11904795f, 0.10219669f, 0.24825937f, 0.04437134f, 0.07311018f, 0.12579611f, 0.02178773f, 
    0.34984413f, -0.07253291f, -0.39939764f, -0.20973437f, -0.05245810f, -0.03245197f, 0.02112455f, -0.14917769f, 
    0.06989426f, 0.10336262f, -0.05962074f, -0.05899406f, 0.21634367f, 0.32076484f, 0.04554848f, 0.18614814f, 
    -0.06381207f, -0.05075849f, 0.01888977f, -0.09590196f, -0.03805058f, -0.02559692f, 0.00723951f, -0.09449069f, 
    -0.21472864f, 0.01936528f, 0.02020870f, 0.02137336f, 0.06440397f, 0.02527078f, -0.11601435f, -0.17130847f, 
    0.04278759f, 0.07769876f, 0.02091855f, -0.10104904f, 0.06521703f, 0.29559442f, 0.19548252f, -0.00518872f, 
    0.00853212f, 0.03296877f, 0.00006913f, -0.13904561f, -0.07076268f, 0.03475447f, 0.13877346f, -0.10532874f, 
    0.03012272f, 0.15943530f, 0.02250925f, -0.07429925f, 0.06573983f, 0.01115611f, -0.02754308f, -0.00827665f, 
    0.11292437f, 0.01192748f, -0.09235201f, -0.02354057f, 0.08913593f, -0.01797851f, -0.05663151f, -0.14371546f, 
    0.01207007f, -0.07039589f, -0.14822510f, -0.06653366f, 0.01702231f, -0.16119602f, -0.04344894f, -0.19841364f, 
    0.06060093f, -0.09912204f, 0.01284406f, -0.13118345f, -0.09226110f, -0.03356656f, -0.03170009f, -0.12155108f, 
    0.09225451f, 0.11578454f, 0.08760485f, -0.01223243f, 0.02131753f, 0.18801263f, 0.05324092f, -0.09152337f, 
    0.00139519f, -0.07889823f, -0.04817151f, -0.11107318f, 0.06350434f, -0.05424257f, 0.00162060f, 0.09052135f, 
    0.13194159f, 0.04334124f, 0.09715632f, 0.00094865f, 0.12632857f, 0.00681937f, -0.02989633f, 0.07641686f, 
    0.03080040f, -0.01335521f, 0.02999443f, 0.07663347f, 0.27397457f, 0.09430637f, -0.12406467f, 0.20058537f, 
    -0.14246245f, -0.10018231f, -0.05232571f, -0.03577925f, -0.05511697f, 0.01812957f, 0.04942227f, -0.08037691f, 
    -0.00001503f, -0.02574250f, 0.06033151f, -0.00575190f, -0.06599031f, 0.00308948f, 0.05182319f, 0.01555025f, 
    -0.02986756f, -0.03136917f, -0.00712714f, -0.00111278f, -0.25823703f, 0.23273644f, 0.00769356f, -0.06631079f, 
    0.18347687f, -0.08466719f, 0.07286129f, 0.01219331f, -0.18158405f, -0.02806028f, 0.05293784f, 0.09707940f, 
    0.01994641f, 0.05401158f, -0.18612885f, -0.08204225f, -0.06630304f, -0.06054360f, 0.07688902f, -0.03087057f, 
    0.09566925f, 0.09107766f, 0.00412091f, 0.13937151f, 0.06792377f, 0.29653928f, 0.05597869f, -0.15937786f, 
    -0.02359478f, 0.01185217f, 0.09529829f, 0.14769672f, -0.06150965f, -0.20290349f, -0.17956503f, 0.02270139f, 
    0.23982562f, -0.34625256f, 0.36874893f, 0.10968217f, -0.12043161f, 0.04238828f, 0.00566043f, 0.07662664f, 
    0.21488541f, 0.11715011f, 0.07172045f, -0.06708734f, -0.12358361f, -0.04618587f, 0.14470771f, 0.05146509f, 
    -0.18472019f, 0.04287442f, -0.06170032f, -0.12820415f, 0.09534730f, -0.09791284f, -0.03789855f, 0.13388032f, 
    -0.23801388f, -0.12833329f, 0.08002967f, -0.00158362f, 0.09014465f, 0.17504738f, 0.13387451f, 0.04850442f, 
    0.01718667f, -0.06077765f, 0.01056723f, 0.02743972f, -0.08040210f, -0.02481197f, -0.02972921f, 0.01989163f, 
    0.06450874f, -0.00119562f, 0.14551373f, -0.11960667f, -0.10152824f, 0.01167101f, 0.03644009f, 0.06028365f, 
    0.04601624f, -0.03987422f, -0.13423255f, -0.02418281f, 0.14039655f, 0.00858858f, -0.00705460f, 0.07437533f, 
    -0.02454437f, -0.09379708f, -0.01571559f, -0.05490397f, 0.01452539f, 0.21679035f, 0.14956404f, 0.00961227f, 
    -0.08166340f, -0.05405900f, -0.06982945f, -0.11034816f, -0.12726635f, -0.09282846f, -0.03333429f, 0.00755967f, 
    -0.17794551f, -0.02419888f, 0.18079340f, 0.22388060f, -0.10454647f, 0.03450479f, 0.07090999f, 0.00410990f, 
    0.02719923f, -0.02093695f, 0.09986176f, -0.08126772f, -0.08734430f, -0.08595996f, 0.07233381f, 0.13417849f, 
    -0.00877470f, -0.03961594f, 0.01328485f, 0.13207889f, 0.02761194f, 0.04900306f, 0.05076061f, -0.00312215f, 
    0.02711177f, 0.05286372f, 0.14626904f, -0.29560569f, -0.00472364f, 0.25162756f, -0.05267486f, 0.21598575f, 
    -0.10612387f, 0.12652190f, 0.02009522f, 0.01305409f, 0.09229293f, 0.06275049f, 0.10280731f, -0.03653534f, 
    -0.10684625f, 0.13262174f, -0.05961011f, 0.03895218f, -0.18243127f, -0.02345496f, 0.01426518f, 0.02656146f, 
    -0.14797316f, 0.04774148f, 0.02468950f, 0.38770908f, 0.08838667f, 0.12752886f, 0.01779434f, -0.14600269f, 
    -0.01244757f, 0.07683446f, -0.06994500f, 0.03400423f, -0.02228774f, -0.04762062f, -0.00967471f, -0.02682767f, 
    -0.07618025f, -0.04470902f, 0.05109058f, -0.07900856f, -0.04909619f, 0.04079414f, -0.05389398f, -0.05879570f, 
    -0.18188004f, 0.00987572f, 0.41325501f, -0.13672672f, 0.20096698f, 0.05313473f, 0.06533698f, 0.02290285f, 
    -0.08650478f, 0.05990712f, 0.03106765f, 0.03170468f, -0.07265358f, -0.36919093f, -0.09756299f, 0.07952259f, 
    -0.04068004f, -0.12444421f, -0.00625647f, 0.05094426f, -0.05898606f, -0.04342979f, 0.00852400f, 0.13754866f, 
    -0.08336054f, -0.07228909f, -0.00838606f, 0.17498678f, 0.09357914f, 0.05257257f, -0.02399994f, 0.20450053f, 
    0.11641273f, 0.01164137f, -0.05179730f, 0.00665759f, 0.33951184f, 0.13028535f, 0.12536998f, 0.02001211f, 
    -0.06848309f, 0.01692317f, 0.26995462f, -0.04142383f, -0.06518889f, 0.00023176f, -0.07471772f, -0.01096923f, 
    -0.04340255f, 0.13486135f, 0.08413042f, 0.22583479f, -0.03958218f, -0.05687573f, -0.02181549f, 0.09451198f, 
    0.14175838f, 0.08014571f, 0.01073591f, 0.10612353f, -0.21736236f, -0.02396444f, 0.26834747f, 0.33892918f, 
    -0.03810772f, -0.09726601f, 0.17270064f, -0.02263516f, -0.05809101f, 0.00793227f, -0.14523527f, -0.02675731f, 
    -0.18445556f, -0.07277520f, 0.22593196f, 0.01490790f, -0.08457921f, -0.02347386f, 0.00952612f, -0.05302010f, 
    -0.02354443f, 0.04983501f, -0.03465687f, -0.03390685f, -0.04398521f, 0.02678176f, -0.02389065f, -0.29056251f, 
    -0.06419343f, 0.00930698f, -0.06186442f, -0.01370185f, -0.01901915f, -0.01552598f, -0.07796676f, -0.14674799f, 
    0.46090710f, -0.13347605f, -0.04611639f, -0.24935423f, -0.05446256f, -0.01818956f, -0.02360127f, 0.10679138f, 
    0.11144027f, -0.00720907f, 0.13865620f, -0.01766592f, 0.00891285f, -0.06520503f, -0.13600735f, -0.05605454f, 
    -0.13792039f, 0.00914769f, 0.09282813f, -0.06673081f, -0.04931918f, -0.03095818f, -0.04566416f, -0.09603366f, 
    -0.13851471f, -0.10935687f, -0.13614775f, 0.05199487f, -0.05864782f, 0.07584072f, 0.03010443f, 0.07928418f, 
    0.02441444f, 0.15884009f, -0.05700406f, 0.09528834f, -0.16508356f, -0.09184774f, -0.09003116f, 0.19770993f, 
    0.04431969f, 0.01701368f, 0.17695682f, 0.05454167f, -0.02472749f, -0.09544174f, -0.00761629f, -0.03231395f, 
    -0.09663253f, -0.09667758f, -0.10591052f, -0.05233165f, -0.07108811f, -0.01096515f, -0.07651102f, -0.04158708f, 
    -0.14618985f, -0.11884397f, 0.07451624f, 0.04205520f, -0.00737148f, 0.06418172f, -0.10869013f, -0.03568137f, 
    -0.01127307f, -0.06762913f, -0.02694083f, 0.04094972f, -0.11109700f, 0.04021771f, -0.09117723f, 0.01322414f, 
    -0.18400101f, -0.14215758f, -0.04552412f, 0.28914589f, -0.10269640f, 0.05094560f, 0.10167674f, -0.01684048f, 
    0.07201961f, 0.12782043f, 0.02573092f, 0.02135355f, -0.06751309f, -0.00516104f, 0.13053493f, -0.21970874f, 
    -0.03009229f, -0.03315293f, 0.02700984f, 0.00737441f, 0.08189948f, 0.10443214f, 0.00022784f, 0.10484064f, 
    0.17667732f, 0.04000865f, -0.03601977f, 0.01654705f, -0.08272058f, 0.01604519f, -0.00049682f, -0.04340575f, 
    -0.06611358f, -0.01552379f, -0.01542218f, -0.09947932f, 0.21223600f, -0.04697512f, -0.22960344f, -0.05371652f, 
    0.04221145f, 0.05468526f, -0.02067215f, -0.02367682f, -0.02899154f, 0.04126066f, 0.00737623f, 0.01033942f, 
    0.03578239f, 0.14246799f, -0.11727844f, -0.16652137f, -0.10867638f, 0.05554428f, -0.09611966f, 0.00799204f, 
    0.18515490f, 0.20817399f, 0.15865357f, 0.00113770f, 0.10932243f, 0.08314005f, 0.09209123f, 0.21908581f, 
    -0.00329240f, 0.05287500f, 0.09526890f, 0.03855930f, 0.09585975f, 0.05208188f, 0.09678890f, -0.04171446f, 
    -0.48243743f, 0.29774055f, -0.00902101f, 0.25628889f, 0.07266680f, 0.14292364f, -0.10134678f, -0.05204218f, 
    -0.01893004f, -0.04479648f, -0.00107764f, 0.05361906f, 0.23289998f, -0.02206863f, 0.03942914f, -0.23438644f, 
    -0.03417772f, -0.00083782f, -0.04710308f, -0.03627716f, 0.03790780f, 0.19284230f, 0.01173629f, -0.05664999f, 
    -0.12952483f, 0.06268864f, -0.06457485f, 0.17859802f, -0.04540355f, -0.11796441f, 0.13444890f, 0.34032655f, 
    0.00614900f, 0.07748046f, -0.06961802f, -0.10565607f, 0.00262019f, -0.03846669f, -0.06741643f, -0.15305856f, 
    0.01505534f, 0.10314716f, -0.14141750f, 0.12376309f, -0.00653217f, -0.15043139f, -0.05523408f, -0.07949410f, 
    0.27610201f, -0.09918216f, 0.10073865f, 0.16672735f, 0.10599684f, 0.12357499f, 0.09233811f, -0.06497625f, 
    0.10907252f, -0.00906926f, 0.02132351f, 0.14400473f, 0.03365664f, -0.03606853f, -0.08069999f, -0.07904294f, 
    -0.02992828f, -0.05106568f, -0.01020321f, 0.02889312f, 0.08339308f, 0.02033713f, 0.10655915f, 0.07406348f, 
    0.01245029f, 0.03105753f, 0.00781492f, -0.00156974f, 0.02444939f, -0.03900706f, -0.01827022f, -0.00790722f, 
    0.01513109f, -0.04439631f, -0.02624142f, -0.05187557f, -0.03101636f, -0.01838812f, -0.03542196f, -0.01096914f, 
    0.02037185f, 0.03018638f, -0.01429907f, -0.02089923f, 0.01845415f, -0.04137672f, 0.01593623f, -0.01252210f, 
    -0.00862319f, 0.04655361f, 0.03733215f, -0.02829726f, 0.00496057f, 0.02017646f, 0.00474654f, 0.01721561f, 
    0.00300786f, -0.02750314f, 0.00205531f, 0.02562090f, 0.02057814f, 0.03427627f, -0.03076379f, -0.02638412f, 
    -0.01118310f, -0.05527142f, -0.00103680f, 0.00615990f, 0.00573666f, -0.00717065f, 0.04407153f, -0.04458757f, 
    -0.03830716f, -0.03989332f, -0.00589917f, -0.02915664f, -0.03259848f, -0.03806627f, -0.04791977f, 0.03664701f, 
    0.03459438f, -0.01906252f, 0.02328707f, -0.00545715f, 0.00700249f, 0.01461526f, 0.03567106f, -0.01546911f, 
    -0.05976662f, 0.02731239f, -0.04760396f, -0.05343391f, 0.01130693f, 0.01970412f, -0.01329296f, -0.00635114f, 
    -0.06335159f, 0.01219429f, 0.02182197f, -0.00611812f, -0.05493778f, -0.00039163f, -0.01110833f, -0.02131454f, 
    -0.04217422f, -0.05359591f, -0.01793627f, 0.01423582f, 0.01069612f, -0.05416239f, 0.00338520f, -0.00534384f, 
    0.02879061f, -0.00446177f, 0.00231498f, 0.02481894f, 0.02866015f, -0.02455736f, 0.03868156f, 0.00304908f, 
    -0.01894933f, -0.01231170f, -0.03965946f, 0.04443470f, -0.03167947f, -0.01083163f, 0.01993781f, 0.00123767f, 
    -0.05744221f, 0.02310240f, -0.03921776f, 0.01754721f, 0.01817533f, 0.00670894f, -0.00824883f, -0.02539831f, 
    -0.06010662f, 0.02102602f, -0.00655882f, -0.02306790f, 0.02336646f, -0.05990708f, -0.01951352f, -0.05574227f, 
    0.01808063f, -0.03226346f, 0.03800344f, -0.04215201f, 0.02234320f, -0.01157564f, 0.01229642f, 0.00748644f, 
    -0.04527324f, -0.04404339f, -0.00648108f, -0.06379742f, -0.00146431f, -0.00230187f, -0.02147319f, 0.02660173f, 
    -0.00527713f, -0.01660374f, -0.04123609f, 0.03394441f, 0.00709191f, 0.02690310f, -0.05856370f, 0.01160464f, 
    0.01976811f, -0.01770335f, -0.02854313f, -0.00348278f, -0.02318140f, -0.03992019f, -0.04091558f, -0.03972164f, 
    -0.03531086f, -0.03862745f, 0.01115237f, 0.00812807f, 0.00284400f, 0.02471377f, -0.06033773f, -0.04567418f, 
    -0.04868960f, -0.03370671f, -0.03568915f, 0.03487199f, -0.01917483f, -0.02467909f, -0.00077430f, -0.00067549f, 
    -0.04062653f, -0.02554383f, 0.03871866f, -0.06074331f, -0.02193497f, -0.04683299f, -0.00243604f, 0.01142010f, 
    -0.02608832f, 0.02946897f, -0.02394068f, -0.03410349f, 0.00153127f, 0.00714627f, -0.03377372f, -0.03338748f, 
    0.02802522f, -0.03524205f, -0.01448503f, -0.03363458f, -0.02702060f, 0.04397137f, -0.03709599f, 0.00501979f, 
    0.02479956f, 0.00930333f, -0.02091427f, 0.00798400f, -0.02159707f, 0.01258295f, 0.01285566f, 0.01577486f, 
    0.02937552f, -0.03573694f, 0.00864077f, -0.05047550f, -0.03836579f, -0.02751412f, -0.02643553f, 0.02879439f, 
    0.03806913f, -0.01504181f, -0.03027635f, -0.00742995f, -0.02173644f, 0.03923247f, 0.00606107f, -0.04081713f, 
    -0.02887891f, -0.03612780f, -0.01981880f, -0.04245098f, -0.01209539f, 0.02147172f, -0.00509080f, -0.02170157f, 
    -0.04852206f, 0.00786023f, 0.00534186f, 0.01937160f, 0.03507307f, -0.01988626f, -0.05156852f, 0.02075346f, 
    -0.01588688f, 0.00356515f, 0.03847957f, -0.03820272f, 0.01220071f, 0.00382867f, 0.02076389f, -0.04865818f, 
    0.02669468f, -0.02737767f, -0.04461233f, -0.00975956f, 0.01631301f, 0.00830512f, -0.01049761f, -0.00860664f, 
    0.03805614f, -0.05711325f, -0.04460701f, 0.01170788f, 0.00997220f, -0.00665556f, 0.00431768f, 0.03543177f, 
    0.02072592f, -0.00872387f, 0.02006776f, 0.02113300f, -0.03573083f, -0.01423932f, -0.05675139f, -0.01512950f, 
    0.00556850f, -0.03115334f, 0.00780613f, 0.00930409f, -0.05459017f, 0.00936090f, -0.03629735f, -0.01990269f, 
    -0.02977354f, 0.03685583f, -0.05027687f, -0.02532835f, 0.02016545f, -0.02578915f, 0.00834221f, 0.02789533f, 
    -0.02697852f, -0.00542943f, 0.01408750f, 0.00702129f, -0.03932500f, 0.02679534f, 0.00218271f, 0.02310354f, 
    -0.04328443f, -0.02907152f, -0.04487111f, -0.05195841f, -0.05829508f, 0.01755316f, -0.02683356f, 0.02087666f, 
    -0.05889299f, 0.02880105f, -0.00473974f, 0.03468951f, -0.00114444f, 0.01588081f, 0.00879520f, -0.05047087f, 
    0.03662020f, -0.00410914f, -0.01500111f, -0.03508827f, 0.01968108f, 0.02953132f, 0.01473991f, -0.02090993f, 
    0.02279614f, -0.01095535f, -0.05036689f, 0.00355483f, -0.02797418f, 0.01056129f, -0.05169741f, 0.00518540f, 
    0.01013589f, -0.01477021f, -0.04164319f, 0.03252225f, 0.01033243f, 0.00687960f, 0.00025300f, -0.05627893f, 
    0.03144565f, 0.04158352f, -0.04901013f, -0.00099586f, -0.05872206f, -0.00081981f, -0.00745169f, -0.00869473f, 
    -0.02321445f, -0.02259144f, -0.03469713f, 0.05362047f, 0.02190805f, -0.04772946f, -0.04961782f, 0.03759025f, 
    0.03940536f, -0.05574508f, -0.02507184f, -0.00490301f, -0.03939447f, -0.02260922f, -0.04779612f, -0.05427099f, 
    0.03002214f, -0.03148478f, 0.02851402f, 0.01980597f, 0.02813657f, -0.01659614f, -0.04964317f, -0.04151127f, 
    -0.03829847f, -0.02182798f, 0.00065986f, 0.03216394f, 0.01370567f, -0.05079613f, 0.03227787f, 0.03635902f, 
    0.01159510f, 0.03473759f, 0.01032560f, -0.01285517f, 0.02303203f, 0.00128750f, -0.01558315f, 0.03690722f, 
    -0.02468598f, -0.00809195f, 0.00219485f, 0.00917399f, -0.01463929f, -0.04240995f, -0.05967987f, -0.04530633f, 
    -0.03347355f, 0.17677507f, 0.31299952f, -0.09352206f, 0.09604877f, -0.08400872f, 0.02389928f, -0.05676229f, 
    0.09851478f, -0.01951313f, -0.08354172f, 0.01733314f, -0.15389556f, 0.03030928f, 0.00791899f, -0.05186490f, 
    -0.06215402f, -0.01877950f, -0.02362137f, -0.07344807f, -0.08897277f, -0.00249419f, -0.05305205f, -0.03700548f, 
    -0.37664178f, -0.03016200f, 0.11446126f, 0.07151088f, -0.05936739f, 0.05953793f, -0.02404325f, -0.06174543f, 
    0.02725216f, 0.07768761f, 0.00972716f, -0.05660516f, 0.12340537f, -0.07939772f, 0.03982513f, -0.10969025f, 
    0.03769594f, -0.02713348f, 0.04066087f, 0.02301071f, 0.03207785f, 0.02451111f, -0.04290675f, -0.04406963f, 
    -0.07991055f, -0.45064369f, -0.11971377f, 0.01799983f, 0.03687634f, 0.19461969f, -0.02102051f, 0.02955779f, 
    -0.00726879f, -0.06672149f, 0.04966768f, -0.03460683f, -0.00034642f, 0.03906747f, 0.07659777f, 0.02332916f, 
    -0.02505785f, 0.14138032f, 0.02278292f, 0.08994110f, 0.03508807f, -0.14874609f, 0.08958606f, -0.04658357f, 
    0.08251601f, 0.08488096f, -0.19246943f, -0.10511631f, 0.15480614f, 0.03722192f, 0.14667553f, 0.10429294f, 
    0.13723885f, -0.04200941f, -0.05187836f, -0.02057072f, -0.24488936f, 0.16337407f, -0.00552762f, 0.23991033f, 
    -0.14836474f, 0.09019987f, 0.08568608f, 0.06258814f, 0.03184537f, 0.08204134f, 0.02887004f, -0.16631244f, 
    0.10176629f, 0.26463273f, 0.00342525f, -0.00913016f, -0.01828964f, -0.19357255f, -0.08695751f, -0.00360429f, 
    0.08045322f, 0.00639719f, 0.06580062f, 0.05656504f, -0.01098637f, -0.31312725f, -0.11747999f, -0.23054232f, 
    -0.00304465f, 0.13222589f, 0.26065576f, -0.09935386f, 0.03469542f, -0.09823744f, -0.03271775f, 0.03652275f, 
    0.29436973f, 0.50444317f, 0.17098269f, 0.00391127f, -0.06429242f, -0.06063719f, 0.08875652f, 0.00705516f, 
    0.00590009f, -0.00493915f, 0.10569342f, 0.16544743f, 0.23189221f, 0.12379725f, 0.06419084f, -0.02848412f, 
    0.08754225f, -0.04681258f, 0.08271587f, 0.07515892f, -0.03834758f, 0.04625469f, -0.00014950f, 0.00353373f, 
    0.07365770f, 0.37819019f, 0.39346147f, 0.03489482f, -0.14066483f, -0.13592634f, -0.03550912f, -0.10084720f, 
    0.08684706f, 0.03209904f, 0.08860073f, 0.07030257f, -0.07858790f, -0.30799267f, -0.07414255f, 0.28626287f, 
    0.07220020f, 0.06645962f, 0.09422721f, -0.07232577f, -0.09028789f, 0.06343266f, -0.07402325f, 0.07085311f, 
    -0.00188558f, 0.05771101f, 0.05315081f, 0.26819557f, 0.03622324f, 0.09174691f, 0.05378130f, -0.01255844f, 
    0.18284933f, 0.15068269f, 0.00510158f, 0.08150404f, 0.02963433f, -0.10540334f, -0.08259249f, 0.09218727f, 
    -0.03838177f, 0.10267187f, 0.05596448f, -0.08338502f, -0.04246602f, -0.00563761f, -0.04877094f, -0.05910913f, 
    -0.08210957f, 0.22737266f, -0.02709087f, 0.00524438f, 0.00502415f, 0.09115916f, 0.05088412f, 0.08453192f, 
    0.01816081f, 0.09169222f, 0.00572471f, 0.02934399f, -0.00312733f, 0.06866800f, 0.06964125f, 0.03253362f, 
    -0.01150013f, 0.01828459f, 0.03262547f, 0.09022602f, 0.08117626f, 0.10840779f, -0.00777286f, -0.01468336f, 
    0.09008244f, 0.10382628f, 0.04655166f, 0.05641595f, -0.00887256f, -0.02216551f, 0.07433986f, 0.05984762f, 
    -0.01369041f, -0.05199912f, -0.06508266f, -0.12867084f, -0.23567684f, -0.15631060f, -0.05043718f, 0.05581910f, 
    -0.00381373f, 0.08244685f, 0.05843455f, 0.05082465f, -0.08993926f, -0.05805860f, 0.00591186f, 0.03291146f, 
    0.03771862f, 0.07537334f, -0.14919397f, -0.18617071f, -0.05833731f, 0.10237129f, 0.06020416f, 0.05173721f, 
    -0.01843348f, 0.07429282f, 0.00749105f, 0.03495276f, 0.30803734f, 0.17742951f, 0.34542364f, 0.26622924f, 
    0.00086880f, -0.11632445f, -0.00738136f, -0.01360488f, -0.01911010f, 0.12555018f, 0.15789393f, 0.01939258f, 
    0.07576337f, -0.08965605f, -0.13112447f, -0.11778468f, -0.13325608f, -0.08093435f, 0.03815341f, -0.03407045f, 
    -0.06049746f, -0.05053759f, -0.07659243f, -0.15845861f, -0.48453590f, 0.16205877f, -0.39410773f, 0.01521627f, 
    -0.00628459f, 0.12113423f, -0.02161302f, 0.00014822f, -0.13281617f, -0.10490134f, -0.07871024f, 0.05572348f, 
    -0.11192572f, 0.06977084f, 0.18089500f, 0.13887839f, -0.11163921f, -0.06803418f, -0.01377635f, 0.04613385f, 
    -0.05207554f, 0.04058368f, -0.07810393f, -0.07147565f, -0.08758532f, 0.13236010f, -0.27336451f, -0.18530712f, 
    0.10261829f, 0.17424947f, 0.02999002f, -0.02803538f, -0.16603161f, 0.01185115f, -0.06227837f, 0.02999941f, 
    -0.02733234f, -0.46378061f, 0.37662229f, -0.00419635f, 0.17737862f, 0.02444415f, -0.07738137f, 0.12583815f, 
    0.03103422f, 0.13346034f, 0.05080553f, 0.08590037f, -0.14305064f, -0.07050663f, 0.24950038f, 0.03564232f, 
    -0.06252107f, -0.01681299f, -0.00029978f, -0.08926435f, 0.07236406f, -0.07287004f, -0.10794196f, -0.08469652f, 
    0.18088433f, 0.16340309f, 0.05678958f, -0.12552918f, -0.03855147f, -0.08687033f, 0.00849041f, -0.07500002f, 
    -0.06042335f, -0.02404110f, 0.02256652f, -0.07103397f, -0.04523015f, -0.05154572f, -0.03066526f, -0.01178515f, 
    -0.01420248f, 0.11393309f, 0.21525869f, 0.07926490f, -0.00081957f, -0.02026775f, 0.04602728f, -0.07170211f, 
    -0.16972667f, -0.10283417f, -0.25353834f, 0.00542464f, -0.01362767f, 0.09479756f, 0.05409331f, 0.03587770f, 
    -0.03617607f, -0.02024612f, 0.10596053f, 0.05533112f, 0.07219759f, 0.04491474f, 0.01173243f, -0.01373016f, 
    0.03916525f, -0.08182104f, 0.08150908f, 0.01425710f, -0.03243649f, 0.11268360f, 0.15268892f, 0.17094168f, 
    0.00489751f, 0.02836743f, 0.05625865f, 0.23980007f, -0.06762116f, 0.18304940f, 0.07219885f, 0.07242814f, 
    -0.02715070f, 0.01997700f, 0.09950110f, 0.00380064f, 0.20582634f, 0.02020751f, 0.19063833f, 0.20965788f, 
    0.18001243f, 0.09997914f, 0.13098244f, 0.09856509f, 0.04131901f, 0.01659723f, 0.03853852f, 0.00070300f, 
    0.24054186f, 0.14627771f, 0.00165832f, -0.03233333f, 0.04172704f, -0.02686191f, -0.02896196f, 0.08421396f, 
    -0.03404969f, 0.13398010f, -0.01620864f, -0.06819382f, -0.07979444f, -0.04950249f, -0.14396469f, 0.18856543f, 
    -0.05073226f, 0.02846655f, -0.08871019f, 0.00443722f, 0.04844576f, 0.00626003f, 0.03667048f, 0.16872539f, 
    -0.04548229f, 0.27570534f, 0.20332080f, 0.09539770f, 0.10118096f, 0.08701915f, 0.00865762f, 0.01906620f, 
    0.00324265f, 0.08855317f, -0.00942819f, -0.07462008f, 0.01540891f, -0.06293677f, 0.05451074f, -0.02525512f, 
    -0.00297317f, 0.00511277f, 0.02124539f, -0.11275216f, -0.01037807f, 0.07048702f, -0.00480150f, 0.10221836f, 
    -0.21114866f, 0.03003351f, 0.23945348f, 0.00911810f, 0.07660935f, 0.12935294f, 0.00003709f, 0.03018767f, 
    -0.03068029f, 0.06796210f, 0.03247957f, 0.08319379f, 0.09115881f, -0.19806531f, 0.03592894f, -0.05963755f, 
    0.12259517f, -0.10130981f, -0.04616243f, -0.02207154f, -0.02442664f, 0.01374924f, -0.00115995f, 0.20169297f, 
    -0.18881205f, -0.20829663f, -0.02487691f, 0.11186149f, 0.11733711f, 0.06749423f, 0.07004324f, 0.19705398f, 
    -0.05218558f, -0.08172721f, -0.09732629f, -0.07767051f, 0.01661349f, 0.22418511f, 0.21481521f, 0.43440667f, 
    -0.01688392f, 0.03653226f, -0.00324360f, 0.06656682f, -0.05211831f, 0.02030709f, -0.01771309f, -0.04288949f, 
    -0.25635800f, -0.33880201f, -0.07460575f, 0.07658143f, 0.00079666f, 0.08260238f, -0.00301188f, -0.02676643f, 
    0.03340615f, 0.02571172f, -0.03893665f, -0.12956347f, -0.19694236f, 0.06286450f, 0.11281352f, 0.27146199f, 
    0.04407632f, 0.05011164f, -0.05506840f, -0.08468655f, 0.06917863f, -0.01778921f, 0.02534892f, 0.06149550f, 
    -0.16427568f, -0.31798485f, -0.12902015f, -0.04797671f, 0.00572881f, 0.03568202f, -0.06964204f, 0.15636185f, 
    0.01777579f, 0.01125620f, -0.03418284f, -0.22461976f, 0.04145528f, 0.21548977f, 0.02640537f, -0.05951722f, 
    -0.05579862f, -0.02564432f, 0.00679154f, 0.01988143f, 0.00537247f, -0.02822747f, -0.07947595f, -0.07936893f, 
    0.18865010f, 0.04680197f, 0.06355403f, -0.30143335f, -0.13218756f, -0.06088104f, -0.02993020f, -0.03451617f, 
    -0.12344678f, -0.09447937f, -0.02630796f, 0.04336632f, -0.08286371f, 0.13130453f, -0.00375673f, 0.07205282f, 
    0.03414107f, -0.09835073f, -0.05006040f, -0.00675352f, 0.10476246f, 0.01755105f, -0.10427147f, 0.01032478f, 
    0.00304674f, -0.13587072f, -0.04936381f, 0.04302131f, 0.06538814f, -0.09409741f, -0.06136890f, -0.03530946f, 
    -0.00389376f, -0.10157584f, -0.03332050f, -0.12369055f, -0.09238338f, -0.07588463f, -0.08562583f, 0.09240336f, 
    -0.00964063f, -0.11191622f, -0.00222805f, 0.08114542f, -0.16181360f, -0.04664287f, 0.01222159f, -0.02451488f, 
    -0.13398544f, -0.02503921f, -0.09957687f, -0.04175989f, 0.01143427f, 0.03665914f, -0.01796573f, -0.10252120f, 
    0.09609557f, 0.07434945f, 0.10022738f, 0.17799729f, 0.26148483f, 0.08981467f, 0.02498228f, -0.02794117f, 
    0.06314481f, -0.10720763f, -0.04267124f, -0.00280630f, 0.06875578f, 0.02201311f, 0.04395739f, 0.00603273f, 
    -0.02466128f, 0.03727603f, 0.09212819f, 0.25053999f, -0.03730147f, 0.06910213f, 0.06779351f, -0.03001796f, 
    0.01393844f, 0.02945147f, 0.03726495f, -0.05698103f, -0.17627186f, -0.17926535f, -0.20331359f, -0.21726948f, 
    0.01023334f, 0.02633874f, -0.02879426f, -0.01685710f, 0.11313275f, 0.00432096f, 0.02234280f, -0.02459365f, 
    -0.16721681f, -0.02526431f, 0.08488931f, 0.08336192f, 0.16731767f, 0.00723508f, -0.12773089f, -0.01713544f, 
    0.12457792f, 0.03883088f, 0.03747175f, 0.24199948f, 0.53494430f, -0.06464265f, 0.07562201f, -0.03933702f, 
    0.03569204f, -0.07702504f, 0.12892506f, 0.04989030f, -0.00312961f, 0.20583278f, 0.05089521f, 0.02374384f, 
    0.02461698f, 0.15107715f, -0.01952523f, -0.04255677f, 0.09865022f, -0.00246214f, -0.03692180f, -0.09968954f, 
    0.15177698f, 0.08467356f, 0.11005502f, 0.09769335f, 0.01760680f, -0.03613864f, 0.11322979f, 0.28283256f, 
    -0.04693994f, -0.02277582f, -0.00460678f, 0.09977365f, -0.07505936f, -0.10404454f, 0.14042591f, -0.22839287f, 
    -0.08240674f, 0.50698632f, -0.17937154f, 0.02253337f, -0.02460353f, -0.04133492f, -0.12175445f, -0.02832838f, 
    0.01156772f, -0.17004338f, -0.22321548f, 0.11985833f, 0.21161979f, 0.01654686f, -0.09106115f, 0.01477083f, 
    0.01255801f, -0.07370493f, -0.02802951f, 0.07524598f, 0.01337972f, -0.02661560f, 0.18717264f, 0.09710199f, 
    -0.13788894f, -0.01357845f, -0.01457938f, 0.04862144f, 0.05501984f, 0.01031371f, 0.06125936f, 0.07003459f, 
    0.03990872f, -0.02378826f, 0.04177447f, 0.02947343f, -0.00334496f, -0.02918454f, -0.01410055f, 0.01534229f, 
    0.08914608f, 0.08229310f, -0.14405239f, 0.00378060f, 0.09575628f, 0.03258046f, 0.03529562f, 0.06185050f, 
    0.21531831f, 0.00540731f, 0.24248546f, 0.04240415f, -0.01164754f, 0.02315539f, 0.00171478f, 0.05406805f, 
    0.07399071f, 0.03823848f, -0.15515602f, -0.01212595f, -0.01399594f, -0.06039032f, -0.05048950f, -0.05663724f, 
    -0.06380919f, -0.02714706f, -0.04311271f, -0.07517474f, 0.06272141f, -0.15353924f, -0.23775087f, -0.18089415f, 
    -0.03518444f, 0.03038546f, -0.00643639f, 0.02610721f, 0.01554852f, -0.04402301f, -0.04724625f, -0.03794717f, 
    -0.00807071f, -0.05012402f, -0.02753733f, 0.02447294f, -0.01645774f, -0.02084605f, 0.00716077f, -0.03959757f, 
    -0.02064942f, -0.02979781f, -0.01937122f, 0.00317261f, -0.00187564f, 0.01826321f, 0.01813983f, -0.03561728f, 
    -0.03243873f, -0.00275595f, -0.05325258f, -0.04747291f, 0.02361572f, 0.00897290f, 0.01043742f, -0.01606840f, 
    0.02531204f, 0.03621391f, -0.00724563f, 0.01886276f, -0.05395668f, 0.02925720f, -0.00886060f, -0.00230673f, 
    -0.04576994f, 0.02357625f, -0.00864672f, -0.03940356f, 0.01510477f, -0.04921303f, -0.00733587f, 0.02274359f, 
    -0.03066869f, -0.02111458f, 0.01595569f, -0.00993186f, -0.03196824f, -0.01280243f, -0.05016366f, -0.00155368f, 
    -0.02989490f, -0.03599180f, -0.01683021f, 0.00852139f, -0.03257514f, 0.01879953f, -0.03638590f, 0.01757241f, 
    -0.01786222f, -0.03878254f, -0.03242822f, 0.01190388f, -0.00854261f, 0.00337861f, 0.00577432f, 0.02834367f, 
    -0.02803852f, 0.02416675f, -0.04439976f, 0.03370076f, -0.00283476f, -0.02998095f, -0.05161272f, -0.03261417f, 
    -0.02899151f, -0.05574142f, -0.01891292f, -0.01040942f, -0.02405507f, 0.03071136f, -0.01367527f, -0.05119812f, 
    -0.01666436f, 0.00426024f, 0.03745627f, -0.02120490f, 0.00807264f, 0.03752456f, 0.03830504f, -0.00637274f, 
    0.00070051f, 0.05487498f, -0.01321913f, -0.04889418f, 0.05045241f, -0.03064779f, -0.00715622f, -0.04176708f, 
    -0.00854140f, -0.02570634f, 0.02611718f, 0.04066825f, -0.03148268f, -0.05058898f, -0.00153898f, -0.03668943f, 
    -0.03864343f, 0.00815592f, 0.01814446f, -0.01131947f, -0.03918046f, -0.02122614f, -0.02530833f, 0.03797960f, 
    0.01738448f, -0.03157140f, 0.01260218f, -0.00469267f, 0.00123391f, 0.01468897f, -0.02567017f, 0.02390631f, 
    -0.03433986f, -0.01478370f, -0.02457726f, -0.05492987f, 0.00556373f, -0.00433585f, 0.03530462f, 0.02858260f, 
    0.03462317f, -0.01772639f, -0.05054400f, -0.02026965f, 0.02275593f, -0.04870430f, -0.04199825f, -0.00587617f, 
    -0.03496464f, 0.03859941f, 0.01141417f, -0.03409063f, 0.02345963f, -0.01505618f, -0.02799788f, -0.05770736f, 
    0.02645669f, -0.02770730f, -0.01262136f, -0.02700361f, -0.00909629f, 0.04164734f, -0.03181514f, 0.03049302f, 
    0.00173344f, -0.00197282f, 0.01289483f, -0.03038725f, 0.04110881f, -0.00565095f, 0.02724224f, 0.01975680f, 
    0.01974725f, 0.00972951f, 0.01793661f, -0.00746543f, -0.01112986f, 0.02774765f, 0.03099977f, 0.02696429f, 
    0.01797668f, -0.04242638f, 0.00502578f, 0.03061100f, 0.03344711f, 0.03334146f, -0.04477171f, -0.03977744f, 
    -0.01482324f, -0.03096920f, -0.01178455f, 0.00550425f, -0.00643770f, -0.03104728f, -0.02742935f, -0.03775134f, 
    -0.01927774f, 0.00737419f, -0.00220790f, -0.02084986f, 0.01346577f, -0.01219738f, -0.01455500f, 0.03198239f, 
    0.03281724f, 0.01660440f, 0.01403446f, -0.03933180f, -0.02780414f, -0.05302160f, 0.02340074f, -0.03291439f, 
    0.02646155f, 0.00341943f, -0.00895378f, -0.01353826f, -0.03930306f, 0.01259774f, 0.01940230f, -0.02135697f, 
    -0.03027176f, -0.01066053f, -0.00730247f, -0.06053446f, -0.00416871f, -0.02325083f, 0.00972977f, -0.03766738f, 
    -0.03582439f, 0.03107676f, -0.00476976f, 0.02348088f, -0.05857088f, -0.03277894f, 0.02282142f, -0.05795680f, 
    -0.04010072f, 0.04055864f, 0.00673263f, 0.01668350f, 0.02334451f, -0.03329175f, -0.00671403f, -0.01034293f, 
    -0.03536921f, -0.03632050f, -0.02772859f, 0.01834096f, -0.05719857f, 0.00433659f, -0.03370668f, 0.03762600f, 
    0.01485875f, -0.01273438f, 0.03561044f, 0.00675517f, -0.01246935f, -0.02219367f, 0.00911269f, 0.00409296f, 
    -0.02447824f, -0.03659248f, 0.02479833f, -0.00921417f, -0.04162502f, 0.01290250f, -0.05823275f, -0.04073287f, 
    -0.05741412f, 0.01019395f, 0.04012547f, 0.03619733f, -0.01548399f, 0.01318660f, -0.02530017f, -0.00902681f, 
    -0.05696080f, -0.02129477f, 0.02121293f, -0.02483192f, 0.01165279f, 0.03054447f, 0.02447218f, 0.02388207f, 
    0.00247248f, -0.00129424f, -0.01954833f, -0.00564806f, 0.01379236f, 0.00615905f, -0.05635523f, -0.04359730f, 
    -0.05953847f, -0.02260521f, -0.03420225f, -0.04360639f, 0.03742171f, -0.01541813f, -0.04384581f, -0.04617059f, 
    -0.03444948f, 0.01628349f, -0.01312592f, 0.02270784f, 0.00717423f, -0.05688597f, 0.04033382f, -0.03600806f, 
    0.01106444f, -0.05670562f, 0.02973642f, 0.02804098f, -0.00436793f, -0.04599303f, 0.01899889f, -0.03976841f, 
    -0.01874095f, 0.01635313f, -0.03958409f, -0.03860967f, 0.01036981f, 0.03486394f, 0.02823696f, -0.02165965f, 
    0.00018119f, -0.05915018f, 0.01636690f, -0.01307048f, 0.03129983f, -0.01986784f, 0.01447470f, -0.04334581f, 
    0.03550118f, -0.00553524f, 0.02090670f, 0.01664156f, 0.00157761f, 0.04092886f, -0.04265923f, -0.05778256f, 
    -0.00066649f, -0.01682010f, -0.02505136f, -0.02097434f, -0.01928750f, -0.02993944f, 0.02716501f, -0.03766119f, 
    -0.03951465f, 0.02026197f, 0.01881017f, 0.01298285f, -0.05493998f, 0.01220072f, 0.02868940f, -0.01750726f, 
    0.00453235f, 0.03720659f, 0.03517056f, 0.00884419f, 0.02078249f, 0.01334630f, -0.02241633f, -0.01365683f, 
    -0.02726495f, -0.00081074f, 0.00724034f, -0.03068717f, 0.02220135f, -0.03846393f, 0.03792310f, 0.03469871f, 
    -0.03421940f, 0.03088133f, -0.03458413f, -0.00491813f, 0.01745667f, -0.01554869f, 0.00570264f, -0.00095995f, 
    -0.05463843f, 0.02541507f, -0.00589238f, 0.01921110f, -0.01080678f, 0.00750794f, -0.03286881f, 0.00502892f, 
    -0.00862546f, 0.03205849f, 0.01610894f, -0.02384143f, -0.00623373f, 0.00869635f, 0.04033618f, -0.04912477f, 
    -0.03913280f, -0.00644260f, -0.01084228f, 0.04062110f, 0.03661343f, -0.00963713f, 0.02113381f, 0.03333784f, 
    0.03708861f, -0.01734902f, 0.00984453f, -0.05799557f, 0.01966553f, 0.00631866f, 0.04247715f, -0.02010932f, 
    -0.03700893f, -0.05506087f, -0.01168046f, 0.04114048f, -0.00122644f, -0.03389402f, -0.02622769f, 0.00452873f, 
    0.02806268f, -0.05959981f, -0.05611855f, 0.01814346f, 0.04849174f, 0.02680184f, -0.04856360f, -0.03035554f, 
    -0.02314954f, 0.03908874f, -0.03298175f, -0.03455986f, -0.03952814f, 0.03174139f, 0.01280403f, 0.01209671f, 
    -0.03557820f, -0.04133449f, -0.03465714f, 0.03200718f, -0.03873565f, -0.05466151f, -0.02636098f, 0.02557749f, 
    0.01563149f, -0.04403774f, -0.03960143f, -0.00687841f, -0.04914459f, -0.03085010f, 0.00010742f, -0.00824185f, 
    0.01976143f, 0.03968843f, -0.04100170f, -0.05621660f, 0.02027403f, 0.03753464f, -0.03278276f, -0.03563271f, 
    0.02103906f, 0.00386385f, -0.01800976f, -0.00252674f, -0.02241380f, 0.04229742f, 0.03879277f, 0.00250622f, 
    -0.01502604f, -0.00922348f, -0.03291900f, 0.01628715f, 0.00630564f, 0.04094053f, 0.02763825f, -0.02359933f, 
    -0.04100678f, -0.02047257f, 0.01189628f, -0.02908589f, -0.03403629f, 0.01817970f, 0.03137779f, 0.01901719f, 
    -0.03074671f, -0.00651470f, -0.04137090f, -0.01710054f, 0.01528699f, 0.04550638f, 0.01766764f, -0.00234464f, 
    0.02257773f, 0.03775642f, 0.02145890f, 0.02655075f, -0.05865332f, 0.00878448f, 0.02151838f, 0.01954800f, 
    0.00018079f, -0.04996145f, -0.03839802f, 0.03421583f, -0.00893289f, 0.01990523f, 0.01602804f, -0.01227527f, 
    0.04007278f, -0.00196144f, -0.05102737f, 0.03748682f, 0.03296967f, -0.04698361f, 0.04316598f, 0.00809568f, 
    -0.05082835f, -0.01418535f, -0.01857495f, -0.02898294f, 0.01301867f, -0.04238201f, 0.05363533f, 0.03030311f, 
    0.03038807f, -0.03517061f, -0.02510093f, 0.01103113f, 0.01078830f, -0.02041800f, -0.00606336f, -0.02664887f, 
    0.02177260f, -0.02199679f, -0.04839129f, -0.01434215f, 0.00988304f, 0.03298160f, -0.05549965f, -0.00137407f, 
    0.03057652f, 0.00041654f, -0.03046411f, -0.00846771f, 0.00738744f, 0.03381106f, -0.04554928f, -0.00588107f, 
    -0.01713008f, 0.04488940f, -0.02040713f, -0.01122906f, 0.01678832f, -0.00653862f, -0.00053050f, 0.03546744f, 
    -0.01052464f, 0.03609387f, 0.00737318f, -0.04208777f, 0.04213558f, -0.04678122f, -0.04155852f, 0.03640580f, 
    0.03948187f, 0.00770955f, -0.02479128f, 0.04654531f, -0.05025766f, -0.01475281f, 0.03880066f, -0.00823372f, 
    -0.01647557f, 0.00531999f, -0.00133548f, 0.00029733f, -0.03848070f, -0.04560969f, -0.03820269f, 0.02558317f, 
    -0.03726415f, -0.03181596f, -0.01396152f, -0.01381117f, -0.01331078f, -0.01864587f, 0.02668728f, -0.01019835f, 
    -0.00115547f, -0.05003929f, -0.03151948f, 0.00667924f, -0.01124794f, 0.00674640f, -0.02155890f, 0.00931817f, 
    -0.00566247f, -0.00518286f, 0.03919504f, 0.04837386f, -0.03205971f, 0.02737865f, 0.04278410f, -0.03795045f, 
    -0.00563680f, 0.00556170f, -0.01718692f, -0.04596550f, 0.00762970f, 0.00914240f, -0.03134913f, 0.03553607f, 
    -0.01841219f, -0.03943327f, -0.03251201f, 0.03821203f, -0.00298260f, -0.03261956f, -0.03213788f, -0.04096019f, 
    -0.05190095f, -0.02794331f, 0.03300393f, -0.03631924f, -0.03950030f, -0.04184008f, -0.01157732f, 0.03771710f, 
    -0.03589559f, 0.01359871f, 0.03722081f, -0.03676939f, -0.04122947f, -0.00662511f, 0.04109252f, -0.01373896f, 
    -0.04171448f, -0.00405503f, 0.01057424f, -0.02477205f, -0.04985118f, -0.02109084f, 0.02100731f, -0.04745029f, 
    0.00478037f, 0.01412119f, -0.00695518f, -0.03318592f, 0.04799103f, -0.05524482f, 0.00212109f, 0.00775540f, 
    -0.01248979f, -0.00774768f, 0.01715615f, 0.03483928f, -0.01506751f, -0.00487388f, 0.00575828f, -0.00275641f, 
    -0.01670673f, 0.00266902f, -0.02216572f, 0.01151067f, -0.01833036f, 0.02080523f, -0.02224045f, -0.00795377f, 
    -0.05074990f, -0.03454117f, -0.03578348f, -0.00517660f, 0.01314648f, -0.04704341f, -0.03094464f, 0.01164931f, 
    0.00719975f, 0.02912511f, -0.01240604f, -0.01505866f, 0.02313722f, -0.02857995f, 0.00564933f, 0.00580057f, 
    0.00882306f, 0.03228526f, -0.05515662f, -0.04733366f, 0.01859207f, -0.01485290f, -0.02127308f, 0.03864885f, 
    -0.02409705f, -0.03683852f, -0.03930955f, -0.01446484f, 0.04517772f, -0.00967090f, -0.04059166f, 0.04075830f, 
    -0.03955143f, 0.00928311f, 0.01618360f, -0.00340324f, -0.01554552f, -0.03138775f, -0.02805193f, 0.03287893f, 
    0.03501021f, 0.01258198f, -0.04480160f, -0.01547365f, 0.02608772f, 0.04030721f, 0.03543968f, 0.01821585f, 
    0.03212686f, 0.00716785f, -0.05498954f, -0.03947359f, 0.01970820f, -0.04430899f, -0.02832359f, -0.01001811f, 
    0.01871243f, -0.04730983f, 0.01537559f, -0.00233486f, -0.05029861f, 0.00415459f, -0.03030129f, -0.02631696f, 
    -0.02376842f, -0.03673313f, -0.04193425f, 0.02179533f, -0.05119835f, 0.01329380f, 0.02350021f, -0.02014814f, 
    -0.04511296f, 0.00759006f, -0.01675295f, -0.02044428f, 0.00232247f, -0.05807618f, -0.05718407f, 0.04091902f, 
    0.01392072f, 0.04407071f, -0.01626071f, -0.00806064f, 0.04325984f, -0.03712124f, 0.00643806f, 0.02030304f, 
    0.01323268f, 0.03134967f, -0.00977889f, -0.00190572f, -0.00901330f, -0.03219571f, -0.05504893f, 0.02525119f, 
    -0.01169119f, 0.04227906f, -0.01219402f, -0.00254999f, 0.02398974f, 0.03768506f, 0.03727959f, -0.02776070f, 
    -0.25196740f, 0.00206498f, 0.34137687f, 0.03099216f, 0.03663836f, 0.00344743f, 0.09345034f, -0.03185914f, 
    0.00514075f, -0.02237731f, 0.00451106f, -0.00211226f, -0.26392663f, -0.11699020f, -0.06759407f, 0.14909141f, 
    -0.03190707f, -0.06736934f, 0.00027194f, 0.07041575f, 0.02632217f, 0.08532113f, 0.09281844f, 0.15473795f, 
    -0.26411483f, -0.00330898f, -0.08252414f, -0.01187528f, 0.21371603f, 0.04881270f, -0.04975925f, 0.09474629f, 
    0.15249470f, 0.04439678f, 0.01720598f, 0.08437384f, 0.17081431f, 0.04110172f, 0.21232672f, -0.05572018f, 
    -0.04362937f, -0.06483486f, 0.04528151f, -0.05343582f, 0.03693721f, 0.13128938f, -0.03590406f, -0.07788555f, 
    -0.12423922f, -0.19649471f, -0.08198144f, 0.16564949f, 0.05348068f, 0.09150410f, 0.08492942f, 0.12912552f, 
    -0.03284156f, 0.07671367f, 0.02595754f, -0.03424983f, -0.08047227f, -0.03944245f, 0.00138736f, 0.04916370f, 
    0.08167747f, 0.02549867f, 0.03876543f, 0.11554058f, 0.02158986f, 0.04891646f, 0.08539422f, 0.09384382f, 
    0.09166940f, 0.04011927f, 0.09174274f, -0.17497803f, 0.25888509f, 0.11758552f, 0.21783611f, 0.05198589f, 
    0.06145928f, 0.05210565f, 0.00089817f, 0.11436238f, -0.31969902f, -0.11033728f, -0.04338149f, 0.25536609f, 
    -0.07731868f, -0.14394984f, -0.03962793f, 0.08264881f, 0.10888253f, 0.01744596f, 0.05045482f, -0.06571060f, 
    -0.22134070f, 0.03432858f, -0.05231989f, 0.08977273f, 0.02999991f, -0.10453014f, -0.04088302f, 0.03814662f, 
    -0.09441087f, 0.01713469f, 0.04315247f, -0.01932059f, 0.54716605f, 0.14460817f, -0.05112075f, -0.21156386f, 
    -0.03435997f, 0.14128868f, 0.20227176f, -0.09082364f, -0.02221238f, -0.07667452f, -0.07367154f, -0.04956989f, 
    0.24116476f, 0.33525035f, 0.22869237f, -0.06676821f, -0.04596272f, -0.06300405f, 0.03469560f, 0.05829632f, 
    0.03257008f, 0.02861958f, 0.07558484f, -0.00051835f, 0.01666650f, 0.18554498f, 0.14947453f, 0.13471203f, 
    -0.08422096f, -0.10643938f, 0.28236473f, 0.14491780f, 0.09354334f, 0.08651197f, -0.07870062f, 0.07231878f, 
    -0.33505809f, -0.00585481f, 0.20191386f, -0.10997115f, -0.13824233f, -0.08552337f, 0.00475779f, 0.01011444f, 
    0.05134407f, -0.09754433f, -0.02982098f, 0.04086931f, 0.11202997f, -0.00061236f, -0.02790017f, -0.00526284f, 
    -0.00575843f, -0.06629653f, -0.01810210f, -0.13278377f, -0.05210304f, -0.03389754f, -0.06427788f, -0.08212242f, 
    0.15547262f, -0.13868736f, -0.02751924f, 0.19468594f, 0.11275199f, 0.04564102f, 0.03314714f, 0.05844669f, 
    0.18121108f, 0.08490760f, 0.18573098f, 0.08987654f, 0.14234668f, -0.00628677f, -0.00735353f, -0.02440921f, 
    -0.05295778f, 0.04833778f, 0.04268008f, -0.07651008f, 0.02878714f, -0.03764912f, -0.05923746f, -0.07105312f, 
    -0.17602958f, -0.00916215f, -0.07393838f, 0.00502807f, -0.07266841f, -0.09296732f, 0.04982144f, -0.01516850f, 
    0.13788718f, 0.12159088f, -0.05680813f, -0.08559725f, -0.19837672f, -0.07442233f, 0.06348411f, -0.08817708f, 
    -0.04752073f, 0.02852019f, 0.03406991f, 0.10007870f, 0.08127332f, -0.04848379f, -0.09928857f, -0.01063022f, 
    -0.00752662f, -0.08462254f, -0.02593863f, -0.04883219f, -0.07043574f, -0.05631922f, -0.07429671f, -0.03003712f, 
    0.13888748f, 0.15008998f, 0.28175446f, 0.13173708f, 0.00317967f, -0.06773317f, -0.22828832f, 0.01518522f, 
    -0.00639089f, -0.06641514f, 0.00629474f, -0.03052234f, 0.00808483f, 0.04625534f, -0.06764749f, 0.08562283f, 
    -0.18168131f, -0.15195310f, -0.08408409f, 0.10166126f, -0.02332458f, 0.00073631f, 0.05651192f, 0.06473579f, 
    0.18444008f, 0.25571245f, 0.26757529f, 0.16829616f, 0.02478411f, 0.09559456f, 0.32140923f, 0.05345128f, 
    -0.06791696f, -0.04976747f, -0.04066285f, -0.04286074f, 0.20128074f, 0.13993882f, 0.19571222f, 0.14414290f, 
    0.12967342f, 0.10558828f, -0.01202574f, -0.15701132f, -0.06230603f, -0.04341136f, 0.06174201f, -0.02857680f, 
    0.15412046f, -0.01677960f, 0.04301068f, 0.01504102f, -0.15227866f, -0.09567077f, -0.41085571f, 0.31147906f, 
    0.06050927f, -0.07148714f, -0.04502266f, 0.10772239f, -0.07855406f, 0.07204240f, 0.05359092f, 0.07122328f, 
    -0.09551868f, -0.08085787f, -0.08618653f, 0.15508004f, -0.13806432f, 0.00716747f, -0.10382186f, 0.11317611f, 
    0.13754822f, 0.15170836f, 0.21675229f, -0.01167710f, 0.04147049f, 0.10147809f, -0.12252171f, 0.13597949f, 
    0.16042875f, 0.23585495f, 0.21254258f, 0.02744318f, 0.05891325f, -0.07112282f, 0.00073354f, -0.02237922f, 
    -0.15653481f, -0.27378741f, 0.41666821f, 0.18099751f, 0.12710740f, 0.03148257f, -0.07620098f, 0.10847671f, 
    0.26484868f, 0.13351209f, 0.01349223f, -0.03615212f, -0.12879011f, -0.05442822f, 0.18762131f, 0.03790924f, 
    0.01429555f, 0.00507438f, -0.05920082f, 0.00600133f, 0.23097728f, 0.19600418f, -0.03606404f, 0.07608058f, 
    -0.26851392f, -0.09089429f, -0.01200297f, -0.04907628f, -0.04070374f, -0.19390997f, 0.10229634f, 0.17055535f, 
    -0.09749474f, -0.14190042f, -0.03157405f, -0.00936598f, -0.01372396f, -0.10624573f, -0.06635396f, -0.07399205f, 
    0.06797306f, 0.19730189f, 0.14455862f, 0.01618898f, -0.04324142f, -0.01787725f, 0.05723104f, 0.05535097f, 
    -0.10341271f, -0.11317047f, -0.09254206f, -0.03062719f, 0.21936530f, -0.08317550f, 0.05069670f, 0.06711417f, 
    0.00368974f, 0.05584689f, 0.09560593f, 0.09629419f, 0.19785133f, 0.11240215f, 0.09020951f, -0.05275544f, 
    0.01712045f, -0.04414684f, -0.00598194f, -0.05910392f, -0.01820409f, 0.03580273f, 0.04528870f, 0.02154337f, 
    -0.24561825f, -0.26968768f, -0.27136362f, -0.27548108f, 0.07136270f, -0.00289658f, 0.20164050f, 0.12706329f, 
    -0.00207581f, -0.02914005f, 0.03773561f, 0.01395824f, 0.05131101f, -0.21098776f, -0.32022133f, -0.08359388f, 
    0.13692914f, -0.05085133f, -0.04792577f, 0.14294571f, 0.08980820f, 0.08761021f, 0.00074540f, 0.01935732f, 
    0.28370589f, 0.00429536f, -0.21091954f, 0.06399132f, 0.31000197f, 0.04037954f, 0.00732055f, 0.15223183f, 
    0.06241152f, -0.01259418f, -0.03632998f, 0.04515954f, -0.29140019f, 0.21460111f, 0.14699776f, 0.08096851f, 
    0.00281739f, 0.11064830f, -0.02957701f, -0.07726271f, 0.04791016f, -0.03831882f, 0.11696871f, -0.01315166f, 
    0.27078250f, -0.18396863f, -0.05432008f, -0.09389670f, 0.11709838f, 0.17945604f, 0.17933325f, -0.17757896f, 
    -0.00705695f, 0.06259694f, 0.04923052f, -0.02742860f, -0.06354527f, -0.11860586f, -0.05562282f, -0.02051590f, 
    0.00984595f, -0.00197957f, 0.03480387f, -0.00562424f, -0.03690413f, -0.03105679f, 0.02607571f, -0.08467139f, 
    -0.28966179f, -0.20198281f, 0.20329823f, -0.17967024f, 0.25236511f, 0.25199044f, 0.07300647f, -0.06642066f, 
    0.02984358f, -0.03369240f, 0.10176765f, -0.02515072f, -0.06391824f, -0.28218213f, -0.18145314f, -0.24411304f, 
    0.01783223f, -0.05439657f, -0.03696111f, 0.02576229f, 0.07349487f, -0.04386345f, 0.06496827f, 0.18656030f, 
    0.02978034f, -0.00566581f, -0.09490561f, 0.01318002f, -0.15509757f, -0.16245176f, 0.12176248f, 0.02989466f, 
    -0.02975711f, 0.02502846f, 0.01366287f, 0.06217853f, -0.03343471f, 0.32930842f, -0.26221576f, 0.14087820f, 
    -0.01285796f, 0.21938723f, 0.27634150f, 0.27219111f, 0.01622872f, 0.06567385f, -0.04691886f, -0.08264726f, 
    0.01540306f, -0.17067897f, 0.14431721f, -0.05732122f, 0.00843316f, -0.07253398f, -0.02115067f, 0.01753741f, 
    0.02918775f, 0.20667049f, 0.03477126f, 0.09976941f, -0.25831434f, -0.26354584f, -0.10452502f, 0.05051683f, 
    0.08949218f, -0.10616515f, 0.15592417f, 0.11456976f, 0.07610963f, -0.04791851f, -0.05370814f, 0.12450013f, 
    -0.19059797f, -0.11575202f, 0.04164084f, -0.16312966f, -0.10919309f, -0.03698043f, -0.06397548f, -0.02900393f, 
    0.12510379f, -0.04188950f, 0.28570420f, 0.21289352f, 0.11360224f, 0.07926947f, 0.10535487f, -0.10727040f, 
    0.06713095f, 0.02933857f, -0.08371659f, 0.00963506f, -0.01672849f, 0.00451032f, 0.00669076f, -0.11609230f, 
    0.49729529f, 0.01415441f, -0.14144498f, -0.00614713f, 0.02663122f, -0.09877087f, 0.00815737f, -0.07997706f, 
    0.32062867f, 0.09621484f, 0.10837717f, 0.01324981f, 0.07666849f, -0.00985645f, 0.09677453f, -0.04828736f, 
    0.05030203f, 0.04945577f, 0.04012302f, -0.02742708f, 0.03793788f, -0.05648224f, -0.00853735f, -0.03506684f, 
    0.02194411f, -0.15692548f, -0.13399914f, 0.00168663f, 0.10622046f, -0.05291629f, 0.15186168f, 0.04242746f, 
    0.09296613f, 0.08635191f, -0.02493173f, 0.00139118f, -0.06573103f, -0.16599275f, -0.09390529f, -0.16461506f, 
    -0.03317244f, 0.13007377f, 0.26438910f, 0.14463568f, 0.02409998f, 0.01455359f, 0.02026232f, 0.01269175f, 
    -0.03222470f, -0.01928087f, 0.09124123f, -0.03466875f, -0.00764681f, 0.01367546f, 0.05806263f, -0.03315934f, 
    0.01208378f, 0.07604660f, 0.11410852f, 0.12312008f, 0.14455038f, -0.05724842f, 0.03660936f, -0.02908797f, 
    0.17784564f, 0.00674376f, -0.04380925f, 0.01258984f, 0.09678468f, 0.02688019f, 0.00792890f, -0.05826016f, 
    -0.13554204f, -0.28175154f, -0.20628129f, -0.04640550f, 0.00506445f, -0.01573788f, 0.19981466f, 0.06774075f, 
    0.01932953f, 0.08974337f, 0.01597218f, 0.13702923f, 0.06355274f, 0.19116712f, -0.00838795f, 0.12316451f, 
    -0.06680158f, 0.03011118f, -0.07765125f, -0.03273009f, 0.32092339f, 0.14820285f, -0.03218545f, 0.08594509f, 
    0.06167999f, 0.09335051f, -0.00194777f, -0.00995682f, 0.06837326f, 0.07017122f, 0.00358230f, 0.02539331f, 
    0.10197845f, -0.06542440f, 0.06103447f, 0.06425475f, 0.54042822f, -0.14233129f, -0.00549284f, 0.12537718f, 
    0.35984826f, -0.00583181f, -0.03442752f, 0.00035390f, -0.01360346f, 0.14981246f, 0.07255104f, 0.12220626f, 
    0.10197616f, 0.13925649f, -0.11390721f, 0.03736433f, 0.09887165f, -0.02023514f, -0.10012456f, -0.04900805f, 
    0.08086889f, 0.08910084f, 0.16972825f, 0.12732743f, 0.00290361f, -0.06542578f, 0.06146220f, 0.13930772f, 
    0.15131356f, 0.12696606f, 0.18848003f, 0.16007476f, 0.06901480f, -0.10786831f, 0.11682576f, 0.13160710f, 
    0.07281701f, 0.05229086f, -0.02879432f, -0.07197472f, 0.18536788f, -0.08405370f, -0.10477775f, 0.14952120f, 
    -0.00048859f, -0.09639224f, 0.01609776f, 0.05321965f, 0.06045886f, 0.01470655f, 0.08524226f, 0.15110569f, 
    0.05942232f, 0.01566575f, 0.02297218f, -0.05378651f, -0.03880161f, 0.02137977f, 0.06952497f, 0.15091383f, 
    -0.17211543f, -0.21951057f, -0.15118994f, -0.11640079f, 0.01337342f, -0.05055363f, 0.02344599f, 0.05772496f, 
    0.01712840f, -0.08804116f, 0.00377030f, -0.03742088f, -0.11162877f, -0.00271321f, -0.11293305f, -0.08007334f, 
    0.15914071f, 0.04703324f, -0.01236783f, 0.12725197f, 0.11131002f, -0.02725549f, -0.00402944f, 0.02216082f, 
    -0.07932466f, 0.03072833f, 0.06722111f, -0.01535907f, 0.16905232f, 0.22470759f, 0.04722958f, 0.17905095f, 
    -0.00346981f, 0.11567279f, -0.03730849f, 0.08502398f, 0.03163511f, 0.05488533f, 0.10613214f, 0.02354109f, 
    -0.02150923f, 0.01627095f, 0.03759979f, -0.07765959f, 0.01733530f, -0.05916585f, 0.06012333f, 0.13453317f, 
    0.04484602f, -0.16071931f, -0.16314429f, 0.06964575f, 0.08691170f, 0.03372749f, 0.11880763f, -0.07286187f, 
    -0.06245387f, -0.07604671f, 0.02459715f, -0.10250288f, 0.04098756f, -0.07831101f, -0.20710458f, -0.26252666f, 
    0.05057405f, 0.03062567f, 0.00297437f, 0.05564171f, 0.03692698f, 0.03409223f, -0.07978918f, 0.07597686f, 
    0.26933935f, 0.06834424f, -0.17652541f, -0.06698447f, 0.05687593f, 0.02615139f, 0.22378820f, 0.03797907f, 
    0.10717743f, -0.15956277f, 0.04602088f, 0.03432013f, 0.00040422f, -0.00410225f, 0.22076523f, -0.04051259f, 
    -0.03646362f, -0.05679682f, -0.12425996f, 0.05178806f, 0.05165583f, 0.09441044f, 0.02801817f, 0.09629200f, 
    0.11721575f, 0.54038513f, -0.30265200f, 0.18101235f, -0.00454255f, -0.05405888f, 0.18334776f, -0.18030556f, 
    0.08179672f, -0.01142048f, 0.03268678f, -0.03193612f, 0.01119976f, 0.03347891f, -0.14796491f, -0.03918096f, 
    -0.01485314f, 0.03850054f, -0.05501274f, 0.07552291f, -0.10771413f, 0.08101458f, -0.07034490f, -0.02372177f, 
    -0.00865378f, -0.07101880f, -0.02667953f, 0.20165339f, 0.03300947f, 0.01941554f, 0.04424824f, -0.11457951f, 
    -0.00773691f, 0.05485821f, -0.00187282f, -0.00807817f, 0.30754530f, 0.11467700f, -0.01585898f, -0.03855512f, 
    0.08452459f, 0.20641077f, 0.12432744f, -0.09305913f, 0.00211016f, 0.03055914f, 0.06808878f, 0.10190678f, 
    0.11514156f, -0.19992530f, -0.17475329f, -0.02726317f, 0.02869950f, 0.08624718f, 0.05221733f, -0.06522106f, 
    -0.06417610f, -0.01623281f, -0.04609882f, -0.01337546f, 0.09513193f, -0.20283152f, -0.22459914f, -0.07110889f, 
    -0.04694184f, 0.10391781f, -0.04911660f, 0.08581557f, -0.19925687f, -0.03890297f, -0.11108977f, 0.05727015f, 
    0.06752603f, -0.10912438f, 0.03784624f, 0.22596616f, -0.00668430f, 0.05462669f, -0.07138757f, -0.00472731f, 
    0.12428763f, 0.06057865f, 0.05640457f, 0.04426290f, -0.16699855f, -0.00806436f, -0.22806819f, -0.02934270f, 
    0.19397075f, 0.05625964f, 0.12279812f, -0.04326968f, 0.02648222f, 0.07410252f, -0.00509168f, 0.08938646f, 
    -0.04021799f, -0.02595514f, -0.05351075f, 0.05898559f, 0.00663098f, 0.18856938f, 0.00986875f, 0.06299257f, 
    -0.06487937f, 0.08274648f, 0.09369492f, 0.05475130f, -0.06200036f, 0.01347758f, 0.11887141f, -0.10660684f, 
    -0.02703374f, -0.11669938f, -0.11455725f, 0.00223294f, -0.03372652f, -0.05365463f, 0.00107807f, -0.03076907f, 
    0.20437802f, 0.06362427f, -0.11746616f, 0.04524552f, 0.12257785f, -0.05386848f, 0.12264379f, 0.14182994f, 
    0.02401832f, 0.08564285f, 0.08550180f, 0.04038256f, -0.27181247f, 0.05866400f, 0.00899863f, -0.02930701f, 
    -0.02548915f, -0.08294058f, -0.02459923f, 0.03574416f, -0.04798283f, -0.07592579f, 0.03106711f, -0.03438906f, 
    0.14005637f, -0.03004027f, 0.01028449f, -0.01059788f, 0.10579050f, 0.05782437f, 0.05239678f, 0.03064028f, 
    -0.01917458f, -0.04803349f, 0.05919558f, -0.07827873f, 0.13373731f, -0.02575383f, -0.08986811f, 0.08089811f, 
    0.03065477f, 0.11305516f, 0.15855539f, 0.00476303f, 0.10531370f, -0.06547439f, 0.01463924f, -0.00063882f, 
    -0.14135791f, -0.08874729f, -0.07016113f, 0.04244080f, -0.07169127f, -0.05953605f, -0.12154751f, 0.06132501f, 
    0.00592543f, 0.07259342f, 0.05368343f, 0.05736527f, 0.09072453f, 0.04646985f, 0.01917957f, 0.03284951f, 
    -0.05601156f, -0.03539407f, -0.09610406f, -0.03287460f, 0.04946738f, -0.00844897f, -0.02576834f, 0.00706817f, 
    0.01544709f, -0.10609119f, -0.04804973f, -0.30386224f, 0.16344623f, -0.05246155f, 0.00895436f, -0.05375848f, 
    0.04601566f, -0.06554541f, 0.01698130f, -0.03791294f, -0.25106418f, 0.18408927f, -0.06980009f, 0.03037013f, 
    -0.00707730f, 0.05431563f, 0.04626918f, 0.07230755f, 0.03974422f, 0.20152302f, -0.05025964f, 0.14056996f, 
    -0.01273129f, 0.13017929f, 0.00045720f, 0.00761566f, -0.06633969f, -0.07005200f, 0.01419611f, -0.07051795f, 
    0.00785873f, -0.07600997f, 0.05011273f, 0.12592283f, 0.16710225f, -0.02352533f, 0.12668855f, -0.13716312f, 
    0.11387644f, -0.03259924f, -0.05068721f, 0.18893695f, 0.00588662f, 0.04218122f, 0.09879299f, 0.00655064f, 
    -0.05457795f, -0.23032162f, 0.04524123f, -0.19047539f, 0.01627677f, 0.00668376f, -0.01845209f, 0.09845038f, 
    -0.01420001f, 0.04075732f, 0.12530637f, 0.09479135f, -0.09177587f, -0.23768166f, 0.11384500f, -0.04172473f, 
    0.16827424f, 0.06503923f, 0.06965268f, -0.10552477f, 0.19260773f, 0.14878982f, -0.00593373f, 0.09788093f, 
    0.31577915f, 0.31199434f, -0.26679850f, 0.22021744f, 0.04967070f, -0.13768548f, 0.16548736f, -0.01043893f, 
    0.07722024f, -0.00150221f, 0.07646398f, 0.03496875f, -0.03814997f, -0.09081576f, -0.06326538f, 0.06424257f, 
    0.05642998f, 0.05733548f, 0.05428178f, -0.03336551f, 0.00804587f, 0.18478212f, 0.10500382f, 0.13464810f, 
    -0.09819729f, -0.11230557f, -0.15600519f, -0.06296514f, 0.09165514f, 0.14529078f, -0.08699706f, 0.09045260f, 
    -0.08403040f, -0.06613342f, -0.07464981f, -0.04668584f, 0.02507852f, -0.07500856f, -0.01341057f, 0.03665520f, 
    0.00782371f, -0.02782261f, 0.04989255f, 0.00655422f, 0.01817574f, -0.00879298f, -0.01363076f, -0.02101974f, 
    0.02363303f, 0.05200497f, 0.06421426f, -0.19171807f, -0.05506372f, 0.07783076f, -0.08922146f, 0.00332022f, 
    0.08981838f, 0.12818894f, -0.04960912f, -0.13108380f, -0.10700317f, 0.05165451f, 0.04392317f, -0.05595009f, 
    0.00825582f, -0.04482425f, -0.08348676f, 0.05206716f, -0.08043243f, 0.05353174f, -0.03179417f, -0.00337569f, 
    0.00717365f, 0.02731520f, 0.03953766f, -0.01789081f, -0.00639642f, 0.04629309f, 0.04342787f, 0.01132915f, 
    -0.03601174f, 0.00266467f, 0.00387283f, 0.01099574f, -0.01845246f, -0.03294482f, -0.05022048f, -0.05492606f, 
    0.03246130f, -0.00889180f, 0.00877327f, -0.00965150f, 0.01816132f, -0.05010042f, 0.00624019f, -0.02116099f, 
    0.02410915f, 0.00357532f, 0.02408476f, 0.00101676f, 0.00075379f, 0.04273278f, 0.03442493f, 0.03863074f, 
    0.02639904f, 0.01271736f, 0.00381642f, -0.05169062f, -0.03353289f, -0.00325529f, 0.00450647f, 0.01006297f, 
    -0.03661635f, -0.01651167f, -0.02055286f, 0.02663973f, 0.01953926f, -0.03201277f, 0.00551041f, -0.01009459f, 
    -0.04909986f, -0.00364147f, 0.01946471f, 0.02635800f, 0.01618176f, -0.04948669f, -0.01538345f, -0.04556496f, 
    0.03685518f, 0.01212175f, 0.03642497f, -0.01497734f, -0.03986173f, 0.00003873f, -0.01292081f, 0.01209713f, 
    -0.05463063f, -0.02189189f, -0.04979009f, -0.03221252f, -0.03957650f, 0.02470827f, 0.00195231f, 0.03009667f, 
    -0.00372833f, 0.01763941f, 0.00322320f, -0.04300195f, 0.02539581f, 0.01253536f, -0.05479635f, -0.04697200f, 
    0.04387880f, 0.01547293f, -0.04215979f, 0.02737673f, -0.02000625f, -0.00319807f, 0.02033487f, 0.01755217f, 
    0.00811285f, -0.00903255f, -0.03059096f, 0.02489375f, -0.02048507f, -0.02979680f, -0.04311108f, -0.01561868f, 
    0.03011494f, 0.03512517f, -0.00658611f, 0.04180789f, -0.04855120f, -0.01607478f, -0.02738093f, -0.00309192f, 
    -0.03179602f, 0.03343385f, -0.00263443f, -0.04312064f, 0.00451421f, 0.02185617f, 0.04099059f, 0.00241992f, 
    0.03933579f, 0.00915310f, -0.01035732f, -0.02490173f, -0.04841396f, 0.02308667f, 0.03756652f, -0.04163148f, 
    -0.01779607f, -0.02808281f, -0.05252510f, -0.00604826f, -0.03380772f, -0.04016070f, 0.02083674f, -0.03850634f, 
    0.04534714f, -0.04718270f, -0.02801993f, 0.01200958f, 0.03302271f, -0.01348012f, -0.00967922f, 0.01214618f, 
    -0.00443729f, 0.02398793f, 0.03325765f, 0.02192331f, -0.00881598f, 0.01787877f, -0.04900027f, 0.02093249f, 
    0.00696705f, 0.03675956f, 0.03426592f, 0.00551748f, -0.03007825f, -0.00026274f, 0.02914119f, 0.01223354f, 
    0.00194247f, -0.03054486f, -0.00549561f, -0.04111632f, 0.02636027f, 0.01759698f, -0.00960760f, -0.03206923f, 
    -0.04724297f, 0.00421038f, -0.03500533f, 0.01403426f, -0.03584730f, -0.02600507f, 0.01441417f, -0.01935370f, 
    0.04010868f, 0.01571714f, -0.01236961f, 0.02830519f, 0.02272024f, 0.00455575f, 0.01828969f, 0.01883433f, 
    0.00056139f, 0.01599220f, -0.02478115f, -0.01840740f, -0.03310095f, 0.01606617f, 0.00706316f, 0.02595191f, 
    0.04177435f, -0.00946293f, -0.02972939f, -0.02503400f, -0.04625873f, 0.02660935f, -0.02139966f, 0.01286676f, 
    0.02645453f, -0.05255963f, -0.01810117f, 0.00229552f, -0.01198048f, -0.05549831f, 0.02123645f, -0.01864329f, 
    0.01827084f, -0.04202367f, -0.00076638f, 0.01571062f, 0.02818512f, 0.02621954f, -0.00707906f, 0.00050281f, 
    0.03990513f, 0.02714193f, 0.00435123f, 0.03790070f, 0.01020185f, 0.00664195f, -0.04367100f, 0.00346482f, 
    0.02017977f, -0.01402292f, 0.00236487f, -0.05322085f, 0.02511800f, -0.05573144f, -0.01472870f, 0.04250415f, 
    -0.01963842f, -0.02964729f, 0.03716354f, -0.02634498f, -0.03374244f, -0.03261634f, -0.00634022f, 0.00411022f, 
    -0.05571239f, -0.05052943f, -0.05067248f, -0.00155651f, -0.04287531f, -0.00784111f, -0.02075488f, -0.03116175f, 
    -0.03696727f, 0.04521304f, -0.04644690f, -0.03525389f, -0.02511334f, -0.03506487f, 0.00864140f, 0.00124389f, 
    -0.02188272f, -0.00506256f, -0.01522784f, 0.03318718f, -0.03353659f, -0.05250389f, 0.00311866f, 0.00949117f, 
    -0.02617352f, -0.00200605f, 0.04466673f, -0.03889997f, -0.01704198f, -0.00771827f, -0.01715125f, 0.02101853f, 
    -0.03204960f, -0.02261707f, -0.00951241f, -0.00803331f, 0.02165595f, -0.05154203f, -0.00347478f, -0.01737215f, 
    0.00616141f, -0.04956247f, -0.04982119f, -0.04700319f, 0.00966831f, -0.05567824f, -0.01000693f, 0.01889590f, 
    0.00461908f, 0.03730845f, 0.02158926f, 0.02020643f, 0.01192498f, 0.02531193f, 0.01909191f, 0.00635314f, 
    -0.01577738f, -0.04055801f, 0.01915767f, -0.03212454f, 0.00831315f, -0.05200043f, -0.00740079f, -0.00176627f, 
    -0.01488388f, 0.01235394f, 0.03874055f, -0.01694847f, 0.01567550f, -0.01834852f, -0.04713475f, 0.00534229f, 
    0.02922571f, 0.03468103f, 0.02764183f, 0.01120073f, -0.04340470f, 0.02144807f, 0.02452211f, -0.00988809f, 
    0.01112517f, -0.01881554f, 0.00526674f, 0.03171825f, 0.01878338f, 0.01802408f, -0.00170211f, 0.01543517f, 
    -0.03640387f, -0.01926166f, -0.04170904f, 0.02498480f, -0.03074762f, -0.02438513f, -0.05113541f, -0.02728694f, 
    -0.01499409f, -0.04203465f, 0.00817056f, -0.04443070f, -0.03088521f, -0.02405998f, 0.00744889f, 0.03190681f, 
    -0.00151180f, -0.00234029f, 0.02362937f, 0.04024895f, 0.00943949f, 0.00301693f, 0.03045509f, 0.01460569f, 
    -0.04390934f, -0.00032367f, 0.02402372f, -0.01704266f, 0.03088449f, 0.03707457f, 0.02698545f, -0.01775903f, 
    -0.02152146f, 0.05452292f, -0.03991099f, -0.01610880f, -0.02146554f, 0.03819662f, -0.02103923f, -0.01635395f, 
    0.02790578f, 0.02865829f, 0.02387003f, 0.00227943f, -0.00577951f, -0.01036451f, 0.00236207f, 0.03392635f, 
    -0.04892531f, -0.01253964f, -0.05222337f, -0.05169282f, -0.03933953f, -0.00089451f, -0.02520643f, 0.03492624f, 
    -0.04938246f, 0.00562896f, -0.02052565f, -0.02802870f, 0.00304906f, 0.01537126f, -0.02991060f, -0.03497110f, 
    -0.15589100f, 0.14352849f, -0.01387013f, 0.00069677f, -0.01077865f, 0.11064522f, 0.07735749f, -0.17570242f, 
    -0.03131966f, -0.06568326f, -0.08014220f, -0.04008822f, -0.06074112f, -0.01302006f, -0.20108885f, -0.02990849f, 
    0.02293094f, 0.05978664f, -0.00844735f, -0.09473356f, 0.03765297f, -0.04908757f, 0.06202119f, 0.12119123f, 
    -0.13548091f, -0.11337715f, -0.29291871f, 0.21919684f, 0.02542652f, -0.10388513f, 0.10140950f, 0.17271623f, 
    -0.02415058f, 0.05196778f, 0.02319979f, 0.11203000f, 0.20116913f, 0.20481656f, -0.19498383f, 0.05332341f, 
    -0.02114036f, -0.05169029f, -0.07651115f, -0.06439874f, 0.09874994f, 0.08242057f, -0.04489519f, -0.04724465f, 
    0.20570296f, 0.08636385f, -0.01228248f, 0.01507618f, 0.02776196f, 0.02994021f, 0.12520418f, 0.11179119f, 
    0.05415920f, 0.05129855f, 0.03668645f, -0.01311874f, 0.11032866f, -0.00641914f, -0.01163131f, 0.13147247f, 
    0.17530623f, 0.07285882f, -0.01167450f, 0.07436046f, 0.00497933f, 0.13394198f, -0.07136941f, 0.10918316f, 
    0.17683135f, -0.02873104f, -0.00967868f, -0.16819389f, 0.16799155f, 0.06605050f, 0.11513007f, -0.08149056f, 
    0.14067724f, 0.04633554f, 0.09073270f, 0.21700518f, -0.22824556f, 0.02821511f, -0.00452417f, 0.41232267f, 
    0.11240079f, 0.03326581f, -0.00463516f, 0.00257436f, 0.05786053f, -0.11681242f, -0.12521882f, 0.11019649f, 
    -0.23127405f, -0.09182930f, -0.06806185f, -0.05476645f, 0.02228738f, 0.10859916f, 0.15080690f, -0.10235298f, 
    -0.02994822f, -0.11484714f, 0.01481559f, -0.07175557f, 0.22683468f, -0.15892707f, -0.39166787f, -0.17714302f, 
    0.09493951f, 0.05048323f, -0.17337947f, -0.11545494f, -0.01455321f, -0.03988957f, -0.00230243f, -0.05426279f, 
    0.31543943f, 0.05855960f, 0.09861448f, -0.01066175f, -0.03909096f, 0.04781960f, 0.08208966f, 0.06441038f, 
    0.10033572f, 0.06664397f, 0.17246909f, 0.04959505f, -0.02975096f, 0.16499726f, 0.03007656f, -0.12622336f, 
    0.01285059f, 0.07152292f, 0.15500069f, -0.04336887f, 0.17099528f, -0.01208775f, 0.07588469f, 0.02549815f, 
    -0.32339165f, -0.05945607f, 0.19591592f, 0.02906419f, -0.17444530f, 0.05909615f, 0.00955482f, 0.15616667f, 
    0.07761845f, -0.05383636f, 0.03631113f, 0.02878560f, 0.08322657f, 0.15720433f, 0.11270565f, -0.24674629f, 
    0.05738078f, -0.18789320f, -0.06734170f, -0.03744167f, 0.12900229f, -0.10130794f, 0.00450795f, 0.02814511f, 
    -0.07095068f, -0.21039809f, -0.16066261f, 0.40845111f, 0.18667857f, -0.03701945f, -0.03453128f, 0.02505125f, 
    0.02270930f, 0.06258359f, 0.05763331f, 0.19539133f, -0.04240787f, 0.02444364f, 0.10128848f, 0.15400037f, 
    0.04718551f, -0.06594802f, -0.07332064f, 0.07631870f, 0.04170249f, -0.02404913f, -0.08056019f, 0.04585039f, 
    -0.10608938f, 0.02662633f, 0.06100959f, 0.11425835f, -0.07248968f, 0.07924420f, 0.15293550f, -0.07557350f, 
    -0.01590795f, -0.06378929f, -0.11428490f, -0.08574611f, -0.14187466f, -0.11598482f, 0.06768189f, -0.03387275f, 
    0.01144911f, 0.08528423f, 0.05494448f, 0.11462606f, 0.01131102f, -0.16371635f, -0.04584733f, -0.08277772f, 
    -0.05520444f, -0.07958405f, -0.02698902f, 0.02396169f, 0.00476707f, -0.02849650f, -0.09750555f, -0.05760973f, 
    0.20891832f, 0.17887506f, 0.10211024f, 0.21556932f, 0.12649916f, -0.16256547f, -0.15418448f, 0.08183783f, 
    -0.12962879f, 0.01876766f, -0.08944635f, -0.01751825f, 0.06018000f, -0.04426569f, -0.02633245f, -0.01252150f, 
    -0.10330631f, -0.08873077f, -0.03224259f, 0.00967121f, 0.08415146f, 0.09520102f, -0.03786712f, 0.05685854f, 
    0.07506838f, 0.06364375f, 0.14322357f, 0.12295853f, -0.15837106f, -0.03728093f, 0.13576920f, 0.01943593f, 
    0.00154422f, 0.04274658f, 0.00678928f, 0.04991467f, 0.30521876f, 0.07792822f, 0.10024471f, 0.07805780f, 
    -0.09838331f, 0.21172424f, -0.05093028f, -0.09727173f, 0.05262591f, -0.03950396f, -0.11025260f, -0.04617034f, 
    0.14621817f, -0.03496387f, -0.00619641f, 0.15630920f, 0.00326478f, -0.38367295f, -0.21590593f, 0.33117396f, 
    -0.06286325f, -0.08849751f, 0.05112972f, 0.12898327f, 0.06729583f, 0.05091327f, 0.10198401f, 0.04137393f, 
    0.10743120f, -0.49932158f, 0.04067011f, 0.10584765f, -0.21229364f, -0.07268057f, -0.01545351f, 0.15926138f, 
    0.17986134f, 0.06577457f, 0.09519143f, -0.04855713f, -0.10520083f, -0.03669990f, -0.20418152f, 0.10135253f, 
    0.09873454f, 0.05014486f, 0.04842830f, -0.09988763f, 0.11163563f, -0.06475925f, 0.08611362f, 0.00615098f, 
    0.24469396f, 0.01970241f, 0.05065976f, 0.13717251f, -0.14770453f, -0.09138561f, 0.05475436f, 0.12263244f, 
    0.14402384f, 0.17029998f, 0.04909122f, -0.13840199f, 0.03175611f, -0.02591913f, -0.11226568f, 0.16436823f, 
    0.09314159f, -0.01939158f, 0.00403050f, -0.03095941f, 0.07969702f, 0.07039833f, 0.08105344f, 0.17604427f, 
    -0.10586828f, -0.20842983f, -0.02476363f, -0.13806751f, 0.02162838f, -0.05818553f, -0.03590593f, 0.07244196f, 
    -0.08783893f, -0.10723856f, -0.02661485f, -0.06201008f, -0.00056663f, -0.06696259f, -0.15496993f, -0.01992596f, 
    0.04577233f, 0.02870670f, -0.03628734f, -0.03415252f, -0.03185041f, -0.02577140f, -0.02116412f, 0.06261892f, 
    -0.26698714f, 0.02176601f, -0.03046442f, -0.03553150f, 0.05463675f, -0.13065968f, -0.13298060f, 0.13560373f, 
    -0.15731028f, 0.08873975f, -0.09240832f, -0.13029806f, 0.03679660f, -0.06153424f, 0.03290445f, -0.03346483f, 
    0.02754261f, -0.05914893f, -0.04303810f, 0.01939390f, 0.01485539f, -0.06223563f, 0.06093207f, -0.01921093f, 
    0.07638611f, 0.21969257f, 0.29827711f, 0.13839577f, 0.15408240f, -0.04723447f, 0.09042977f, 0.03296212f, 
    -0.05572195f, -0.04478227f, -0.18200450f, 0.06615666f, -0.04041930f, 0.06969602f, 0.12487901f, 0.22656621f, 
    -0.03254132f, 0.02403837f, 0.08825928f, 0.18125992f, -0.08021961f, 0.03346592f, -0.00300370f, 0.00543630f, 
    -0.44070137f, -0.39307833f, -0.10569844f, 0.10157294f, 0.07265199f, 0.00386164f, -0.03849306f, -0.07031965f, 
    -0.01516793f, -0.09515779f, -0.06347556f, 0.00797326f, -0.25850624f, -0.08221641f, -0.37537485f, -0.26648700f, 
    0.08650383f, 0.00152747f, 0.08335014f, -0.10304075f, -0.00404027f, -0.10286762f, -0.10641419f, -0.28409231f, 
    0.12065706f, -0.24524310f, 0.15756083f, 0.09612811f, -0.15195198f, -0.02264591f, 0.00209325f, 0.04898369f, 
    -0.00561591f, -0.01187592f, 0.01061552f, -0.00477362f, 0.11428389f, 0.12069651f, 0.02201219f, -0.02096807f, 
    0.08620469f, 0.10158212f, -0.01653735f, 0.03542211f, -0.06999399f, -0.11043969f, -0.07648451f, -0.08340372f, 
    0.28414932f, -0.15895423f, -0.09911601f, -0.15851767f, -0.00648860f, 0.03013164f, 0.08308221f, -0.06836300f, 
    0.03657637f, -0.06000677f, -0.07761890f, -0.04834152f, -0.13726246f, 0.12646790f, 0.03350696f, 0.25426430f, 
    -0.08696592f, -0.09438184f, -0.01134692f, -0.01297431f, 0.07896231f, 0.03473045f, 0.05169006f, -0.10525503f, 
    -0.00192941f, 0.22080907f, 0.24909949f, 0.22590429f, -0.08167247f, -0.03453265f, 0.06706508f, 0.02005230f, 
    0.18845674f, 0.05827591f, 0.07413566f, -0.00884230f, -0.08003493f, 0.10688730f, -0.02502916f, -0.18002546f, 
    0.28049868f, 0.00988400f, -0.04604947f, -0.07795075f, 0.09724869f, -0.04983251f, 0.02275041f, -0.10823195f, 
    0.18819077f, 0.18938757f, 0.18335365f, -0.01065481f, -0.02016578f, -0.02779645f, 0.02607853f, -0.10085488f, 
    0.00710982f, 0.01213968f, 0.06311291f, 0.14120065f, 0.32755443f, 0.04649390f, 0.16317120f, -0.00392977f, 
    -0.13638648f, 0.03633781f, 0.07747460f, 0.16001883f, -0.14675993f, -0.08532490f, -0.15298170f, -0.07020090f, 
    0.25790498f, 0.20174702f, 0.14645000f, 0.23792909f, -0.02580233f, -0.10061472f, 0.05936706f, -0.04930169f, 
    0.06454100f, -0.11244600f, 0.11122940f, 0.08811793f, -0.37494114f, -0.48985362f, -0.13052785f, -0.04770914f, 
    0.05386615f, 0.06467287f, 0.05611178f, -0.00675663f, -0.04890950f, 0.10848530f, 0.01640331f, -0.07277411f, 
    -0.15548725f, -0.24636990f, -0.31650406f, 0.25194567f, 0.09059914f, 0.09667003f, -0.19646540f, -0.09322915f, 
    0.19921118f, 0.18502106f, 0.00068097f, 0.04763086f, -0.41971776f, -0.47489896f, -0.24205038f, -0.00984155f, 
    0.17508598f, 0.06839721f, -0.06598201f, -0.09327143f, -0.00227968f, 0.03845399f, 0.08662421f, -0.07194022f, 
    -0.01881234f, 0.12406829f, 0.12813027f, 0.08483665f, -0.09887902f, 0.08001309f, -0.01968712f, -0.01771683f, 
    0.21386857f, 0.14577478f, 0.08411125f, 0.14836189f, 0.00307538f, 0.10174733f, 0.22385822f, 0.07753697f, 
    -0.07342553f, 0.04498888f, -0.12538560f, -0.05821399f, 0.11097554f, -0.07267819f, 0.01504582f, 0.04380799f, 
    -0.00705189f, -0.22900635f, 0.01243414f, -0.21576293f, 0.06045121f, 0.24778174f, 0.06955029f, -0.00507043f, 
    0.13256057f, 0.13592757f, 0.05395164f, -0.09702900f, -0.33392310f, -0.04020035f, -0.09869532f, 0.00612924f, 
    0.12684959f, -0.02692213f, 0.02006905f, -0.02121110f, -0.09319112f, -0.04855231f, -0.02619753f, -0.03408265f, 
    -0.02458474f, 0.01966105f, 0.03360438f, 0.14223672f, -0.02050527f, -0.08900833f, -0.09719525f, 0.05264464f, 
    0.02238125f, 0.08578669f, 0.07375889f, 0.02089692f, 0.30521005f, 0.08035259f, -0.01704888f, 0.27769864f, 
    -0.07675690f, 0.02637343f, -0.01053682f, 0.03812250f, 0.02181151f, -0.05394080f, 0.08602656f, -0.08270263f, 
    -0.38144377f, -0.16323441f, -0.20316300f, -0.13155596f, -0.00478351f, 0.06710006f, 0.01821296f, 0.02245143f, 
    -0.06268848f, -0.00983372f, -0.02602793f, -0.06362338f, -0.25216922f, -0.02570870f, -0.12107721f, 0.26538581f, 
    0.11448546f, -0.09157787f, 0.03891150f, -0.04290672f, -0.05564425f, -0.09354579f, -0.00694863f, 0.03052274f, 
    0.02211250f, -0.07840996f, -0.15229608f, 0.27558553f, -0.05381934f, -0.05764432f, 0.04161546f, 0.00870204f, 
    -0.04455543f, -0.03638449f, -0.02183021f, -0.04534367f, 0.06086509f, 0.13989294f, -0.17705639f, -0.02661280f, 
    -0.02357751f, -0.02302196f, -0.01777961f, 0.02658049f, 0.04177112f, -0.10860918f, -0.10054282f, 0.09576874f, 
    -0.18460137f, -0.18475613f, 0.27166054f, 0.05909795f, 0.11197130f, -0.06579345f, 0.03120155f, 0.07152386f, 
    0.00225093f, 0.06177662f, 0.04837079f, 0.00692423f, -0.19357216f, -0.00918344f, -0.06421650f, 0.02629834f, 
    0.06877913f, 0.05689364f, -0.05864298f, 0.00772077f, 0.01511841f, 0.03117668f, -0.21918683f, -0.10865939f, 
    0.10717586f, 0.17998707f, 0.20697466f, 0.17163715f, 0.05868281f, 0.06246206f, 0.09686515f, -0.01494666f, 
    -0.07522552f, 0.04616501f, -0.08657715f, -0.06160228f, -0.08891409f, -0.01497600f, -0.13775802f, -0.04345318f, 
    0.11952788f, 0.15695150f, 0.13708240f, -0.09895813f, -0.05111760f, -0.00248500f, -0.05210543f, -0.08245549f, 
    0.00831976f, 0.09198645f, -0.08829659f, 0.13977775f, 0.09042833f, -0.18787743f, -0.03619131f, -0.05034482f, 
    0.03416811f, -0.04924070f, 0.10761347f, 0.05790539f, -0.02307424f, -0.10376354f, -0.11440107f, -0.10839715f, 
    0.07038081f, -0.08201967f, -0.01967952f, -0.08130124f, -0.00856567f, 0.11435600f, 0.14485823f, 0.16552903f, 
    -0.07970634f, 0.25218832f, -0.07445705f, -0.02569403f, -0.06270912f, 0.04736341f, -0.10779443f, -0.13072798f, 
    0.01089701f, -0.01620440f, -0.06459815f, -0.03200369f, -0.09617577f, 0.12361008f, 0.04143866f, -0.04407991f, 
    -0.04800384f, 0.22615288f, -0.02675126f, -0.10900301f, -0.01199041f, -0.04593829f, -0.10976612f, 0.00762154f, 
    -0.01957329f, 0.34267199f, -0.07710245f, 0.08304119f, -0.25592422f, -0.01020649f, 0.09467682f, -0.01867822f, 
    -0.06008008f, 0.14039806f, 0.07079839f, -0.01517606f, 0.29456332f, 0.03444852f, -0.12452903f, 0.13124415f, 
    0.05983324f, -0.02122315f, 0.03507435f, 0.13884772f, -0.01150541f, -0.10758608f, -0.00991791f, -0.03240505f, 
    0.09283441f, 0.15717871f, 0.12284909f, -0.09049080f, 0.10205236f, -0.00650792f, -0.01900354f, 0.07491153f, 
    0.07061349f, 0.03307552f, 0.01740221f, -0.01666036f, 0.11331398f, 0.05170501f, -0.02428014f, 0.11209942f, 
    -0.09855969f, -0.10464858f, 0.03978465f, 0.03125763f, 0.02137994f, 0.03824793f, 0.04768506f, 0.02753938f, 
    0.02120546f, 0.13904682f, -0.08895547f, 0.01074765f, -0.07328807f, -0.04920511f, 0.05779181f, 0.04158831f, 
    0.00509403f, 0.02480776f, 0.06164989f, 0.05800404f, 0.02783932f, 0.14837097f, 0.12886807f, 0.21527469f, 
    0.10653461f, 0.25058728f, 0.05994766f, 0.17750525f, -0.02568672f, -0.06363191f, -0.18941118f, -0.01449552f, 
    -0.11939211f, -0.02780251f, -0.04714720f, 0.10217055f, -0.00731646f, 0.12996250f, 0.11317049f, -0.12222487f, 
    0.10449140f, 0.01085651f, 0.03312101f, -0.05518584f, -0.00377594f, -0.11630200f, -0.24222372f, -0.00688518f, 
    0.21827663f, 0.08350173f, -0.20079561f, 0.02359545f, 0.02574141f, -0.02557888f, 0.06842487f, 0.03526491f, 
    0.10680028f, -0.07143308f, -0.09315421f, -0.07825821f, 0.03619385f, 0.04945277f, 0.09765608f, 0.04423664f, 
    0.08447566f, -0.02900309f, 0.05684612f, -0.06029828f, -0.00000085f, 0.14505409f, 0.02867798f, -0.27099621f, 
    0.02120295f, 0.18992528f, 0.01272059f, 0.05738129f, 0.05493430f, 0.06676225f, 0.03150132f, 0.00701356f, 
    0.23469669f, 0.04977074f, -0.00146671f, -0.07695801f, 0.09266606f, 0.06248881f, 0.13791813f, 0.16221619f, 
    0.06401414f, 0.09670086f, -0.03325538f, -0.13480349f, 0.09664123f, 0.05039905f, 0.15805188f, 0.05043103f, 
    0.05032590f, -0.02399004f, 0.02001759f, -0.02626550f, 0.06651101f, -0.08790306f, 0.07661577f, 0.13974757f, 
    -0.04392769f, -0.23228395f, 0.13956484f, 0.29215494f, 0.07604700f, -0.00903248f, -0.05242283f, -0.12766850f, 
    -0.16796102f, -0.05457311f, -0.13130157f, 0.00256972f, -0.05158365f, 0.09325374f, 0.06124840f, 0.04018611f, 
    -0.00338470f, -0.02550472f, 0.00792734f, 0.01174257f, 0.03185729f, 0.03557181f, 0.04151137f, 0.07874066f, 
    -0.03768315f, 0.06789682f, 0.04074062f, -0.05116774f, -0.10295642f, 0.11566970f, 0.10990980f, 0.03675396f, 
    -0.05516545f, -0.18855947f, -0.06516739f, -0.06962634f, -0.02287529f, 0.00127575f, -0.08622918f, -0.01135261f, 
    0.06617310f, 0.06415489f, -0.03954585f, 0.08437420f, 0.03764759f, 0.04772516f, -0.00050441f, -0.11605749f, 
    0.05630853f, 0.00140115f, 0.06425034f, 0.07503819f, 0.00322286f, -0.08271778f, 0.09870055f, -0.02919771f, 
    -0.07106622f, -0.09159857f, -0.02965877f, -0.06369592f, -0.13707712f, 0.05038441f, -0.06963517f, -0.06415488f, 
    -0.07902130f, 0.00115212f, -0.01868474f, 0.03479603f, -0.02336945f, 0.00749985f, 0.02908955f, 0.00551512f, 
    0.04551276f, 0.05315737f, 0.06910999f, -0.04761555f, 0.15922388f, 0.13885687f, -0.09990523f, 0.06620979f, 
    -0.04952516f, -0.17045817f, -0.14364436f, 0.07435182f, 0.08754628f, -0.03455316f, 0.13611053f, -0.02371823f, 
    0.09413338f, -0.02555744f, -0.00996190f, 0.00816287f, -0.04704623f, 0.00225764f, 0.07165659f, 0.02551655f, 
    -0.02448979f, 0.04282044f, -0.01654887f, 0.00665084f, -0.03492625f, -0.01931327f, -0.03115704f, 0.00570423f, 
    -0.02949154f, -0.04598459f, -0.02054092f, 0.00174881f, -0.16568553f, -0.04001153f, 0.24316588f, 0.11759122f, 
    -0.02713085f, 0.06956596f, -0.04649150f, 0.12053676f, -0.07388337f, -0.02400633f, 0.10494917f, -0.03304053f, 
    0.18958502f, -0.17940700f, 0.26529500f, -0.18785784f, -0.07233909f, 0.06025292f, 0.15200835f, 0.05557653f, 
    -0.10974105f, 0.00419174f, 0.06783094f, -0.02316791f, -0.03359187f, -0.09953982f, 0.10596450f, -0.18089493f, 
    0.02676438f, 0.05883268f, 0.04519534f, -0.07392283f, -0.11920688f, -0.03040024f, -0.04765654f, 0.00584080f, 
    0.52774060f, -0.05041195f, -0.02071615f, -0.00900518f, -0.03915419f, -0.25732595f, 0.11134759f, -0.07268640f, 
    0.08795450f, 0.20880786f, -0.04616296f, -0.06313457f, 0.12263935f, 0.09881903f, 0.01569722f, 0.08198024f, 
    0.02376520f, 0.07082263f, 0.07983215f, -0.02661410f, -0.13310604f, -0.25122768f, -0.05796074f, 0.19122994f, 
    0.06207275f, -0.10693046f, 0.01019782f, 0.08054265f, -0.07384291f, 0.08121162f, -0.04076100f, -0.04196101f, 
    -0.00119771f, 0.04988111f, 0.01063863f, 0.07235987f, -0.06233132f, 0.00934973f, -0.02050679f, 0.02856495f, 
    -0.16699661f, 0.02198248f, 0.20540540f, -0.13174354f, -0.01520238f, 0.08906842f, 0.07212237f, 0.08935044f, 
    -0.19402704f, 0.04494418f, -0.11884081f, 0.08136758f, -0.07624698f, 0.00599633f, -0.11383034f, 0.13226642f, 
    -0.14419514f, 0.04255664f, 0.01006504f, -0.06499045f, 0.05390963f, 0.06518208f, 0.05611480f, 0.09874797f, 
    0.03268413f, 0.02979178f, 0.00239878f, -0.01757888f, 0.08641323f, -0.01055106f, -0.03606895f, -0.12106201f, 
    0.00098317f, 0.07529036f, 0.12086749f, 0.36249012f, 0.07076873f, -0.00015884f, 0.06612104f, 0.06476861f, 
    0.02881376f, -0.09121525f, 0.10300318f, 0.06317621f, 0.01753764f, 0.02031300f, -0.11081371f, -0.00540806f, 
    0.00663496f, 0.18660097f, 0.09530772f, 0.21087894f, 0.04727092f, 0.08616353f, 0.05163655f, 0.18101102f, 
    0.01884577f, 0.33138227f, -0.23968318f, -0.20187175f, -0.06442723f, 0.09785344f, 0.11367189f, -0.02451262f, 
    0.12654476f, -0.04316486f, -0.01548616f, -0.14274034f, 0.08120209f, -0.05839351f, 0.13863325f, 0.11870315f, 
    -0.05525593f, -0.04848361f, -0.05160363f, -0.08731005f, -0.02050710f, 0.06616216f, 0.04605683f, -0.06037152f, 
    -0.02224960f, 0.55281818f, -0.27970409f, 0.29277858f, -0.12384274f, 0.07189422f, -0.01035558f, -0.00389434f, 
    0.07256966f, -0.10067020f, 0.06459233f, -0.04586265f, 0.06109302f, 0.09823543f, -0.07480634f, 0.04992170f, 
    -0.05191886f, 0.08196014f, 0.03420611f, 0.02983871f, -0.05871818f, 0.11733173f, -0.01800339f, 0.12178796f, 
    0.01061294f, 0.07363217f, -0.02631287f, 0.19742070f, 0.02141584f, 0.04376284f, 0.03986901f, 0.01927718f, 
    0.02129599f, 0.14094809f, -0.06540339f, 0.05720344f, 0.36617976f, 0.22455390f, -0.09040649f, 0.13268611f, 
    -0.01984517f, 0.08511710f, 0.11153181f, -0.07197651f, -0.03996629f, 0.01229763f, 0.06027503f, 0.00818191f, 
    -0.26212493f, -0.46817714f, -0.02608194f, 0.06401417f, 0.09180783f, 0.07301496f, 0.11700460f, 0.07460365f, 
    0.00938884f, 0.03032326f, -0.03891729f, 0.06853741f, -0.15847041f, -0.06442079f, 0.31477162f, 0.02571743f, 
    0.08023506f, -0.05179399f, -0.23413840f, -0.07987912f, -0.09505232f, -0.07669884f, 0.05914259f, 0.10317365f, 
    0.01345235f, 0.04647902f, 0.07803839f, 0.23046742f, 0.08415454f, 0.13390018f, -0.02237643f, -0.05665010f, 
    0.04582288f, -0.01480178f, 0.06760718f, -0.02448573f, -0.03937339f, 0.11565291f, 0.04480595f, 0.21053997f, 
    0.18733238f, 0.05982839f, 0.17228355f, 0.07090969f, 0.08999884f, -0.01403302f, 0.10762266f, 0.20911145f, 
    0.21901886f, -0.04856920f, -0.17730872f, 0.05058375f, -0.05044330f, 0.15195610f, 0.08278590f, 0.14062274f, 
    -0.05793559f, 0.11414894f, -0.00121100f, -0.10195654f, -0.06667907f, 0.15511431f, 0.01462686f, 0.00114840f, 
    -0.10967582f, -0.15402506f, 0.00668758f, -0.13912030f, 0.05733011f, 0.03068581f, 0.01198462f, 0.09300891f, 
    0.07225367f, -0.05495914f, -0.12570472f, 0.01000841f, 0.00944551f, 0.00158672f, -0.06217799f, -0.01484098f, 
    -0.07799556f, 0.07750356f, -0.07208544f, 0.12351499f, -0.50337851f, 0.18005964f, 0.03150591f, 0.02519562f, 
    -0.07156052f, -0.11029622f, -0.05834185f, -0.11904740f, -0.03397971f, -0.01248034f, 0.05156538f, 0.07643002f, 
    -0.02022485f, 0.10780676f, -0.09321113f, 0.12346530f, 0.07473867f, 0.07663776f, -0.07960545f, -0.10467490f, 
    0.02748996f, 0.00149337f, 0.10651615f, -0.10763731f, 0.08044112f, -0.01731103f, -0.10457095f, 0.29796076f, 
    0.12627232f, -0.07351036f, -0.11232807f, -0.05905804f, 0.02016522f, -0.06878638f, -0.02334243f, -0.07845871f, 
    -0.18320936f, -0.04944313f, -0.11793684f, -0.02855965f, -0.08094866f, 0.05932312f, -0.12221508f, -0.10682861f, 
    0.01602283f, 0.13134927f, -0.00840806f, 0.06105714f, -0.07983717f, 0.21692933f, -0.12904474f, -0.06451742f, 
    -0.08894732f, -0.15685412f, -0.07790086f, -0.07912731f, 0.00513531f, 0.11613835f, 0.06793033f, 0.08465786f, 
    -0.15282439f, -0.05951991f, -0.04255171f, -0.23773801f, 0.20733039f, 0.07856202f, -0.04779052f, 0.02970450f, 
    -0.04191024f, -0.00679231f, 0.07504134f, -0.03013041f, 0.02294524f, 0.08522605f, 0.01650179f, 0.12595744f, 
    0.08284777f, -0.03833993f, 0.05008099f, 0.05907082f, -0.06477065f, 0.07731301f, -0.04097857f, 0.01795669f, 
    -0.37359613f, -0.00088021f, -0.03458625f, -0.11191231f, -0.08012198f, -0.05343393f, -0.08756161f, -0.06776626f, 
    0.00356306f, -0.11902747f, 0.02118277f, 0.07709145f, -0.00976807f, 0.32920617f, -0.25306657f, -0.29127580f, 
    0.12876345f, -0.18650128f, 0.12716088f, 0.03979996f, -0.11086721f, -0.09085374f, 0.06329078f, 0.23323755f, 
    0.01301069f, 0.09841041f, -0.01888627f, -0.32666475f, -0.05164564f, 0.08614462f, 0.11883459f, -0.01748407f, 
    -0.01620291f, 0.06188297f, 0.02000871f, 0.26935327f, -0.23841235f, 0.07343770f, 0.10950189f, -0.06092498f, 
    0.06189092f, 0.05458232f, 0.00504845f, -0.04163185f, 0.02102428f, 0.03111511f, -0.08453011f, 0.00831857f, 
    0.27384186f, 0.03674706f, -0.15968716f, 0.12738730f, -0.09079348f, -0.01316466f, 0.13434017f, -0.14265417f, 
    0.05530793f, 0.09831517f, 0.11993284f, 0.02566830f, 0.12587191f, -0.25011525f, 0.02685493f, -0.12636596f, 
    -0.04115816f, 0.06251176f, 0.08037977f, 0.03681382f, 0.03449954f, -0.02779874f, 0.05230929f, 0.07566074f, 
    -0.17349556f, -0.06540728f, -0.11768840f, 0.14184794f, 0.12605508f, 0.22124456f, 0.02122151f, 0.09886011f, 
    -0.05311078f, -0.01648866f, -0.06576474f, 0.04962052f, -0.07005361f, -0.15483294f, -0.00375738f, -0.03911478f, 
    -0.03058207f, 0.00222766f, 0.05607440f, -0.27009758f, -0.07118510f, -0.04905536f, 0.05235971f, -0.00328300f, 
    0.35983017f, -0.07013969f, 0.03729970f, -0.08718801f, -0.06004817f, -0.00317458f, -0.16592963f, 0.03119243f, 
    -0.04107064f, 0.05606473f, -0.01228790f, -0.16955397f, -0.12530233f, 0.07235032f, 0.04975365f, -0.02164924f, 
    0.01124666f, -0.12505548f, -0.10152092f, -0.10911673f, -0.07242414f, 0.06139956f, -0.08128002f, 0.05685136f, 
    0.06976455f, 0.18960889f, -0.08810101f, -0.09709962f, -0.04618484f, 0.17504887f, -0.11800816f, -0.11697539f, 
    0.06237002f, 0.07777839f, 0.12152474f, -0.00996579f, 0.13006814f, 0.07000539f, 0.13779642f, 0.03253223f, 
    0.16109565f, 0.05667993f, 0.12517418f, -0.12965217f, 0.00352287f, -0.05571157f, 0.09972631f, -0.07124636f, 
    0.03450834f, 0.03397661f, 0.29477969f, 0.23520759f, -0.09228378f, -0.09348938f, -0.02784843f, 0.11052983f, 
    -0.10986692f, 0.06746088f, -0.03006910f, -0.09787799f, -0.00332120f, -0.04049080f, -0.49660474f, 0.18764196f, 
    0.17157201f, -0.07822528f, -0.13631397f, 0.08867423f, -0.00862129f, -0.27861536f, 0.05702679f, 0.22993678f, 
    0.23014139f, -0.27368093f, 0.43051836f, -0.05843315f, 0.29016769f, 0.25238085f, -0.03137425f, 0.10045480f, 
    0.09262627f, 0.12512678f, 0.01339018f, 0.07169746f, -0.03208366f, -0.20596735f, 0.12688647f, -0.00846900f, 
    0.08467731f, -0.01218404f, 0.05762722f, 0.01306036f, 0.13968271f, -0.15237278f, 0.01857031f, -0.09525787f, 
    -0.13836291f, 0.14979309f, -0.02147288f, -0.40677992f, 0.18887377f, 0.07171763f, 0.12603092f, 0.05925578f, 
    0.10199413f, -0.15832919f, 0.08927625f, 0.00869697f, -0.17847446f, -0.19739409f, -0.02302318f, -0.03823712f, 
    0.01414547f, 0.04169364f, -0.08085766f, 0.18630254f, -0.03379869f, -0.06399917f, -0.17721801f, 0.19941428f, 
    0.27802244f, 0.32887906f, 0.01183978f, -0.07016673f, 0.06932055f, 0.01019679f, 0.05934281f, 0.22439577f, 
    0.07283325f, -0.06882025f, -0.05471982f, -0.00723963f, -0.32731166f, -0.10965274f, -0.46274409f, 0.17422691f, 
    0.13015459f, 0.10314656f, 0.36058262f, 0.00815577f, 0.10534475f, -0.14202592f, -0.03135301f, -0.13578805f, 
    -0.00481430f, 0.00249812f, -0.01527898f, 0.02545348f, 0.00715986f, -0.06252267f, 0.06971553f, 0.19035447f, 
    0.07604169f, 0.05177909f, -0.00151971f, -0.00212937f, 0.00112095f, 0.00241312f, 0.01981451f, -0.13073967f, 
    0.07127770f, 0.14384143f, -0.14013785f, -0.10036345f, 0.04763931f, -0.10094416f, -0.00036261f, 0.00646890f, 
    -0.02738930f, 0.13696329f, 0.29091692f, -0.04069996f, 0.13781804f, -0.03554764f, -0.08543772f, 0.13175718f, 
    0.13690241f, 0.13693927f, -0.00239974f, 0.05691666f, -0.02485421f, -0.21500480f, 0.00246179f, 0.07417073f, 
    0.16325568f, 0.09568862f, 0.02262060f, 0.06198552f, -0.02355050f, -0.12422140f, -0.07779174f, 0.10618035f, 
    -0.07283866f, 0.10559405f, 0.39359692f, -0.06741462f, -0.09375076f, -0.03626057f, 0.17877743f, -0.07043368f, 
    0.04689078f, -0.04727027f, 0.09895570f, 0.12229528f, 0.09628336f, -0.40128160f, 0.02003236f, 0.16211793f, 
    0.09761053f, 0.08217729f, 0.01248051f, 0.11013716f, -0.04526793f, -0.02544673f, -0.22688757f, 0.01408465f, 
    0.02693493f, -0.06696587f, 0.04972162f, 0.04620824f, -0.00336146f, 0.14203317f, 0.16560739f, 0.05370293f, 
    -0.03082477f, -0.03183486f, 0.03624602f, 0.07270965f, -0.00418766f, 0.01589085f, 0.04485013f, 0.04731152f, 
    0.13910076f, 0.01764421f, 0.07089356f, 0.23749442f, -0.09042498f, 0.17848966f, 0.05432263f, 0.14220956f, 
    0.09558057f, 0.00904225f, -0.06820611f, 0.09866168f, 0.02399582f, -0.21288891f, 0.08503819f, 0.00890591f, 
    0.04434907f, -0.01794929f, -0.06875160f, 0.01842952f, 0.04457544f, -0.46232259f, 0.18719932f, -0.01870223f, 
    -0.04886538f, 0.10219436f, 0.05853015f, 0.08964479f, -0.03469271f, -0.08256578f, -0.05572490f, -0.01268119f, 
    0.18504001f, 0.15848637f, 0.06241163f, 0.17182241f, -0.02016978f, 0.11946985f, 0.14909579f, 0.23551205f, 
    0.01783473f, 0.05550763f, 0.00884770f, 0.06378105f, 0.17514130f, -0.11213461f, 0.11970554f, -0.16839257f, 
    -0.07205725f, -0.05305133f, -0.03764536f, -0.10607439f, 0.19942890f, 0.03796469f, 0.07514879f, 0.09820893f, 
    -0.17161021f, -0.17754254f, -0.21719924f, 0.15797964f, 0.07698828f, -0.11483996f, -0.19616324f, -0.12758011f, 
    -0.09236771f, 0.07437927f, 0.02162142f, 0.03654539f, 0.19599204f, -0.06434263f, 0.13114841f, 0.03883415f, 
    -0.11070450f, 0.22051255f, 0.00032356f, -0.08733959f, 0.09622746f, 0.06376044f, -0.12293808f, 0.04309007f, 
    0.30804548f, -0.03127445f, 0.33522710f, 0.09206350f, -0.06256237f, -0.01261979f, -0.02808042f, -0.07289072f, 
    0.21425080f, 0.05752388f, 0.02161379f, -0.05939463f, 0.17172629f, -0.05346758f, -0.07605180f, 0.17682338f, 
    0.15759735f, 0.13754241f, -0.00112019f, 0.03515588f, -0.10694963f, 0.15547083f, 0.23220815f, -0.14530665f, 
    0.07879142f, 0.06381235f, 0.09645034f, -0.20387727f, -0.01794337f, -0.03803422f, -0.15990302f, 0.09614740f, 
    -0.09990574f, -0.09463474f, -0.11996161f, 0.06692011f, 0.18902178f, 0.36642486f, 0.01879087f, 0.10130754f, 
    -0.12140365f, -0.04298806f, 0.03150954f, -0.07426599f, 0.05744777f, -0.11704969f, 0.07232189f, -0.00254351f, 
    0.18010780f, 0.09848520f, -0.00570107f, -0.20057069f, -0.05725558f, -0.09052595f, 0.03944191f, -0.05810257f, 
    -0.05435029f, -0.10530346f, 0.05616174f, -0.13635376f, -0.33157918f, 0.00410538f, -0.12478054f, -0.02524937f, 
    0.04870047f, 0.02306006f, 0.02085234f, 0.24882676f, -0.08936386f, -0.15273406f, 0.11942411f, -0.08354811f, 
    -0.14008379f, 0.17765152f, 0.13245013f, 0.31068310f, 0.04180140f, 0.10396469f, 0.13151871f, 0.07622869f, 
    0.14822075f, 0.09044337f, -0.08084282f, 0.14290318f, -0.14916110f, -0.16167945f, -0.14897639f, 0.03377503f, 
    -0.03942180f, 0.08222928f, 0.13071239f, 0.02078475f, 0.12939531f, -0.14564471f, 0.01633010f, -0.03835529f, 
    -0.02642604f, -0.00289988f, 0.01843148f, -0.02679059f, 0.00295566f, 0.01340273f, -0.00760993f, -0.04676275f, 
    -0.01976001f, -0.01535363f, -0.03762580f, -0.02570051f, 0.00305079f, -0.03829838f, 0.02618407f, -0.01130493f, 
    -0.03973442f, 0.01477841f, -0.04928778f, -0.03864007f, -0.02834384f, -0.00109123f, -0.00518547f, 0.01284940f, 
    0.01470688f, -0.01492448f, -0.04804314f, -0.05043714f, 0.00537494f, -0.02650462f, 0.01596437f, 0.00439172f, 
    0.02280183f, -0.03120806f, 0.02307328f, -0.02219164f, -0.03324730f, -0.05339878f, -0.01665612f, -0.05636677f, 
    0.01453923f, 0.01559333f, 0.02025832f, 0.00024495f, 0.00295896f, -0.03377897f, -0.05212658f, -0.01545926f, 
    0.02700341f, 0.02444361f, -0.03593326f, -0.04080410f, -0.02017703f, -0.01183317f, 0.00722774f, -0.03964173f, 
    0.03769499f, -0.04730514f, -0.02366693f, -0.03382754f, -0.02623919f, -0.04440529f, 0.02925833f, 0.01797439f, 
    0.01180171f, 0.03329602f, -0.01736593f, 0.02736634f, -0.00716647f, 0.03776234f, 0.02874728f, -0.01011584f, 
    -0.05326979f, 0.03554945f, -0.01219231f, -0.05462743f, -0.04367686f, -0.00942604f, -0.04869137f, 0.00174551f, 
    0.03457434f, -0.05051365f, -0.05659235f, -0.00552950f, 0.01240405f, 0.04936407f, 0.00534832f, -0.04874074f, 
    0.04914526f, -0.01095960f, -0.02981634f, 0.01888243f, 0.04980731f, 0.00656497f, -0.03730003f, 0.01590119f, 
    -0.01469709f, 0.01591680f, -0.00058041f, -0.00778359f, -0.03156436f, 0.01802944f, -0.02754965f, 0.02338064f, 
    -0.03696929f, 0.02231920f, 0.01556510f, 0.00688172f, -0.01835828f, -0.01311436f, 0.00364471f, 0.04381032f, 
    -0.00772686f, 0.01540090f, -0.03546720f, -0.05329811f, 0.03794980f, -0.01088708f, -0.03559557f, 0.04125184f, 
    -0.02466089f, 0.00127352f, -0.02579291f, -0.01533726f, -0.02180176f, 0.00521529f, 0.03431298f, 0.03507616f, 
    0.01641450f, 0.03014954f, -0.01347123f, 0.04067617f, -0.01114698f, -0.03456984f, 0.01920538f, 0.01414360f, 
    0.00528415f, -0.01919340f, -0.05097315f, -0.00104310f, -0.01675296f, -0.03279922f, 0.00510843f, 0.00575325f, 
    -0.02656762f, -0.04479392f, 0.00974213f, -0.01289904f, 0.00624563f, 0.02840353f, -0.02709161f, -0.04079322f, 
    0.03465324f, -0.02345099f, 0.04211440f, -0.00036285f, 0.02240466f, 0.02548924f, 0.01607015f, -0.00420343f, 
    0.04241057f, -0.01685351f, -0.05053559f, -0.02255609f, 0.00129919f, 0.01741042f, -0.04374247f, -0.04410201f, 
    -0.04100664f, -0.00663804f, -0.01686968f, -0.01931538f, 0.03278988f, 0.01230295f, 0.00562680f, 0.04023609f, 
    0.01917616f, 0.00661386f, -0.04368537f, 0.03712317f, 0.02436316f, -0.04799787f, 0.01736400f, -0.02563181f, 
    -0.01140940f, 0.03660182f, -0.03415016f, -0.02065967f, 0.01534677f, -0.05422620f, -0.02123106f, -0.04228027f, 
    0.00414521f, 0.00564964f, 0.03191298f, 0.03748038f, -0.00726106f, -0.03442520f, 0.03430896f, 0.03627546f, 
    -0.01304797f, -0.02996184f, -0.00608353f, 0.00318770f, 0.02003195f, 0.00382298f, -0.03130414f, 0.01557897f, 
    -0.03369971f, -0.04747678f, 0.01641341f, 0.01122154f, 0.03105303f, -0.03233482f, -0.03636079f, -0.05211512f, 
    -0.03521647f, -0.02871256f, 0.03275515f, -0.00009818f, 0.02100123f, -0.05303359f, -0.04545568f, -0.01732356f, 
    -0.00310534f, 0.03055215f, -0.04406970f, 0.00750577f, -0.04505481f, -0.00511572f, -0.02291240f, 0.02525592f, 
    -0.01294177f, -0.03435905f, 0.03160004f, -0.02656812f, -0.03654884f, -0.00221893f, -0.02674881f, -0.04894046f, 
    0.03376362f, -0.02395772f, -0.04310638f, 0.03974029f, 0.01044786f, 0.01642803f, -0.01203670f, -0.05100288f, 
    -0.04835865f, -0.00036718f, -0.02862473f, -0.01563322f, 0.03563358f, 0.00065254f, -0.05217391f, -0.03422518f, 
    -0.01003035f, 0.03355602f, 0.00435984f, -0.03913786f, -0.05407716f, 0.02888929f, 0.00256545f, -0.03659998f, 
    0.00570013f, 0.00903665f, -0.04779043f, -0.02285410f, 0.00618601f, 0.02816183f, 0.02321277f, 0.02167313f, 
    0.03694388f, 0.00587674f, 0.00383562f, -0.01014192f, 0.02047947f, -0.03077866f, 0.00621946f, -0.01175260f, 
    -0.02314733f, -0.05306642f, -0.03891583f, -0.03620388f, 0.02936488f, -0.03971387f, -0.01034561f, -0.05502997f, 
    -0.03728944f, -0.02757778f, -0.01524433f, 0.05027328f, 0.04021350f, 0.00075326f, -0.02658733f, -0.03809164f, 
    -0.03100589f, -0.03353491f, -0.00686158f, -0.02751366f, -0.01135471f, -0.00188969f, 0.02338473f, 0.00621901f, 
    0.03903450f, 0.03779988f, 0.03197497f, -0.05699734f, -0.04009809f, -0.03798575f, -0.01284364f, -0.05464602f, 
    -0.00411176f, 0.04347989f, -0.04130716f, 0.01913951f, -0.02830930f, 0.02073634f, -0.02404009f, 0.03151741f, 
    0.01970409f, -0.00557868f, -0.00623357f, 0.04327822f, 0.02566221f, 0.04234539f, 0.00691685f, -0.05191170f, 
    -0.02533543f, 0.04423665f, 0.00775768f, -0.04125582f, 0.01916405f, 0.03225711f, -0.01934395f, 0.00087882f, 
    0.01037233f, 0.05170772f, -0.01506820f, 0.02999328f, -0.04103111f, 0.02747202f, 0.03960973f, -0.02940058f, 
    0.04409933f, -0.05665695f, 0.04163854f, 0.03175100f, 0.02792978f, 0.03457415f, -0.01600439f, -0.00914049f, 
    0.04198023f, 0.01537237f, 0.02816463f, -0.05627478f, 0.01460066f, -0.04066851f, -0.03902878f, -0.03495988f, 
    0.03212695f, -0.02119090f, 0.03285326f, -0.00218688f, -0.02145897f, -0.03203348f, 0.01345392f, 0.03412465f, 
    -0.03056990f, 0.01233003f, -0.01962958f, 0.04106947f, 0.00288797f, 0.03657832f, -0.01315176f, -0.00623573f, 
    -0.04296640f, 0.04326552f, -0.05134450f, 0.02019356f, 0.03917056f, 0.00904075f, 0.01770369f, -0.00112952f, 
    0.22186817f, -0.00217176f, -0.29884869f, 0.09904505f, 0.02732366f, 0.25836754f, 0.00258736f, 0.00512278f, 
    -0.00077983f, -0.02158318f, 0.12008212f, 0.02623804f, 0.23449558f, 0.13576385f, -0.03136738f, -0.14198509f, 
    0.13200526f, 0.17193936f, 0.12199858f, 0.00120622f, 0.00023895f, 0.01460304f, 0.05007898f, 0.14101800f, 
    0.01203436f, 0.00076761f, 0.06548052f, 0.07435055f, -0.07937796f, -0.06248847f, 0.13996434f, 0.08842141f, 
    0.02086629f, 0.16080138f, 0.03872863f, 0.04959587f, 0.00580477f, -0.21347108f, -0.07849012f, 0.14019015f, 
    0.00497970f, -0.09774201f, -0.11077505f, -0.05091896f, -0.00693009f, -0.11824911f, -0.07663366f, 0.13078655f, 
    0.14278720f, 0.43409157f, 0.14933178f, -0.04838258f, 0.16387410f, 0.01555811f, 0.08875468f, -0.08332398f, 
    0.06410974f, 0.09622949f, -0.02728246f, -0.04753405f, -0.03009968f, -0.01239594f, 0.04129541f, 0.13749954f, 
    0.05262709f, -0.01738591f, 0.06213262f, -0.02223021f, 0.01351527f, 0.06399438f, 0.07133970f, 0.08174166f, 
    0.17321371f, -0.03843027f, -0.18963066f, 0.11690713f, 0.06549244f, 0.20473906f, 0.01978480f, -0.11032479f, 
    0.00347996f, 0.04134413f, 0.10271566f, 0.08254887f, 0.21269879f, 0.10167381f, 0.06638535f, -0.18903619f, 
    0.17702423f, 0.22329064f, 0.07787437f, -0.00163924f, 0.07679192f, 0.04757610f, -0.06019662f, 0.07719106f, 
    0.13895117f, -0.08529638f, 0.04366108f, -0.06690469f, 0.06929175f, 0.27103996f, 0.15467019f, 0.13867478f, 
    -0.02378361f, -0.05198075f, -0.00193085f, 0.02106375f, 0.30069122f, -0.14454935f, -0.31677645f, 0.35271144f, 
    0.04554774f, 0.02557031f, -0.12188537f, -0.01427343f, -0.10608083f, -0.00765665f, 0.00363455f, 0.03744240f, 
    -0.17490847f, -0.37383741f, -0.23809096f, -0.02256767f, 0.08924043f, 0.11071961f, 0.05170860f, -0.02758064f, 
    0.10013386f, 0.10679580f, 0.03724093f, -0.08665793f, 0.06455033f, -0.04233390f, -0.15076715f, -0.02557181f, 
    0.13272361f, 0.13437353f, -0.05799135f, 0.01034976f, 0.15775862f, 0.04817162f, 0.08710814f, 0.03468601f, 
    -0.10621104f, -0.15140289f, -0.34037071f, -0.05421356f, 0.18909179f, 0.23324552f, 0.13323255f, 0.09337156f, 
    -0.16130558f, 0.22636166f, -0.11485965f, -0.11678702f, -0.05532124f, 0.13134962f, -0.01912444f, -0.02370129f, 
    -0.03525821f, -0.04822594f, -0.09684454f, 0.03585776f, 0.01251325f, -0.07675157f, 0.05172591f, 0.05762507f, 
    -0.37403366f, 0.09373408f, 0.23989141f, 0.09105506f, 0.06600698f, -0.11658376f, 0.07192130f, 0.11973748f, 
    -0.19787416f, -0.10223448f, 0.03588786f, 0.02969337f, -0.19014230f, 0.15627398f, 0.02545084f, 0.04754044f, 
    0.02732176f, -0.06281508f, -0.01535830f, 0.01789503f, 0.01353235f, -0.05862476f, 0.07872222f, -0.01743233f, 
    0.16007411f, -0.05165559f, 0.05592979f, -0.11503759f, 0.04984991f, 0.05240264f, 0.02696280f, 0.00964523f, 
    0.06619389f, -0.11530214f, -0.06046947f, -0.11598866f, 0.19433758f, 0.09669295f, -0.03754696f, -0.02115669f, 
    0.14354232f, 0.06956210f, -0.10002045f, 0.11921758f, -0.00535599f, 0.01598322f, -0.00141205f, -0.00497728f, 
    -0.09818349f, -0.07189875f, -0.12623645f, 0.01257367f, -0.07908849f, -0.10530903f, -0.07717907f, -0.07446367f, 
    0.03529263f, 0.08891200f, 0.03011798f, 0.08021763f, 0.08513295f, -0.03529209f, 0.10992332f, 0.02089254f, 
    -0.16009584f, -0.00723604f, -0.05903585f, 0.01164158f, 0.00623406f, 0.07036713f, 0.05232854f, 0.16272287f, 
    0.16205949f, 0.12434795f, 0.07033058f, -0.04443230f, 0.19958413f, -0.13096984f, -0.13799399f, 0.04217771f, 
    0.12392197f, 0.02004622f, 0.06294037f, -0.03129178f, -0.22871789f, -0.20027605f, -0.19396679f, -0.06602216f, 
    0.00846885f, -0.00547044f, 0.06324811f, 0.01375775f, 0.05678317f, 0.04749284f, 0.02494858f, 0.09987824f, 
    -0.15052889f, -0.05728778f, -0.05443774f, 0.10782845f, 0.04830645f, -0.07575984f, -0.08231310f, -0.05831615f, 
    -0.06713057f, -0.01816470f, 0.11440567f, 0.18998814f, 0.03439496f, -0.07141257f, 0.41951859f, -0.23380481f, 
    -0.25425187f, -0.03097873f, 0.11047594f, 0.07858709f, -0.00953699f, 0.06223190f, 0.12717682f, -0.04260822f, 
    -0.27445367f, -0.23592277f, 0.20713142f, -0.06782575f, -0.08387740f, -0.07604758f, -0.04342612f, 0.05320547f, 
    0.10102806f, -0.02188925f, -0.00244964f, -0.09588246f, 0.04416739f, -0.14322214f, 0.13356672f, -0.04596163f, 
    0.17153434f, -0.01765345f, -0.05461151f, -0.06371714f, -0.03791080f, -0.00637304f, 0.08764005f, -0.09009627f, 
    0.35446283f, 0.24535024f, -0.21363890f, 0.06106650f, -0.10725881f, -0.06047038f, 0.05882774f, 0.03670574f, 
    0.12956882f, 0.01531757f, -0.04884234f, 0.08308676f, -0.07940793f, -0.05636616f, -0.05702915f, 0.16528246f, 
    -0.03632756f, -0.16178693f, 0.05970376f, -0.02012991f, -0.13997231f, -0.03222669f, 0.30929446f, 0.16521712f, 
    0.07179442f, -0.10126358f, -0.06165463f, 0.01272481f, 0.08895871f, 0.16353516f, -0.05239366f, 0.07455987f, 
    0.00206899f, -0.01065996f, 0.01654618f, 0.00260711f, -0.00371485f, -0.03515022f, -0.05658298f, 0.02614655f, 
    0.07081782f, -0.11842022f, -0.07301272f, -0.02057361f, 0.00976681f, -0.03315024f, 0.05813220f, 0.06547163f, 
    0.01160337f, 0.15476198f, 0.10500769f, -0.02449576f, 0.09257478f, -0.14318846f, 0.01998656f, 0.11381271f, 
    0.01650272f, 0.08830625f, -0.06008425f, -0.07425833f, -0.15540726f, -0.05406685f, 0.02868828f, 0.11537616f, 
    -0.03390773f, 0.02979858f, -0.10614447f, 0.08649569f, -0.13353083f, -0.15823264f, -0.18632078f, -0.33397147f, 
    -0.01059811f, -0.01184913f, 0.01395921f, -0.03688049f, 0.02558452f, -0.01141817f, -0.04121600f, -0.03207684f, 
    0.03874740f, -0.01495285f, -0.00823137f, 0.02446006f, -0.04516313f, -0.00541238f, -0.02200710f, -0.02985963f, 
    -0.01495775f, 0.00786817f, 0.01126716f, -0.05220924f, -0.02282324f, 0.00071744f, -0.01555874f, 0.00778653f, 
    -0.05203995f, 0.03172171f, -0.00686313f, -0.05741350f, -0.03389711f, -0.01219916f, -0.02596425f, -0.01779942f, 
    -0.04662902f, 0.03035075f, 0.00806194f, -0.01286845f, -0.01439057f, -0.03650650f, 0.04029246f, 0.00724027f, 
    0.03979464f, -0.00901004f, -0.01474037f, -0.03059677f, 0.03713870f, 0.00414202f, -0.03273369f, -0.03994071f, 
    0.03997802f, -0.00331017f, 0.01448155f, 0.03820733f, -0.00524615f, -0.00323933f, 0.03249705f, -0.02789116f, 
    0.04091836f, 0.03233314f, -0.04198948f, -0.05658168f, 0.04134156f, -0.05707712f, 0.01148943f, -0.01748539f, 
    0.02623702f, -0.01063281f, 0.00400950f, 0.03146466f, -0.01399826f, 0.02760326f, -0.05587024f, -0.03823571f, 
    -0.02564925f, 0.03992593f, -0.00326001f, -0.01862106f, -0.02344653f, 0.02856069f, -0.02505205f, 0.01118749f, 
    0.02276060f, -0.00590111f, -0.04497361f, -0.04391970f, 0.00998834f, 0.00474923f, -0.04007805f, -0.00716321f, 
    -0.02758981f, -0.05416541f, -0.01013160f, 0.01424548f, -0.00311351f, -0.01999820f, 0.01197307f, 0.04196585f, 
    0.03616941f, 0.01393695f, -0.02638269f, -0.05829468f, 0.02674040f, -0.01037318f, -0.02135139f, -0.01852810f, 
    -0.03781997f, 0.02748037f, -0.05161088f, -0.04817597f, 0.02920638f, 0.02115668f, -0.01818434f, -0.05422537f, 
    -0.04817047f, -0.02980538f, -0.02187607f, -0.04356300f, -0.01912831f, 0.02237703f, -0.00134120f, 0.00790318f, 
    0.00328301f, 0.02101943f, 0.03589904f, -0.04865230f, -0.05222869f, 0.02451450f, 0.04315270f, 0.00720225f, 
    0.02270580f, -0.04820273f, -0.01792273f, 0.01037185f, -0.00095354f, 0.01233880f, -0.05797565f, 0.02125766f, 
    -0.02494071f, -0.04379467f, -0.00669502f, -0.03313577f, 0.01117246f, 0.02769123f, 0.00129063f, -0.05281816f, 
    0.02478083f, -0.05742441f, -0.03067075f, -0.01639491f, -0.05021747f, 0.03259148f, -0.04975535f, -0.01454371f, 
    0.02778398f, 0.01014464f, -0.01806775f, 0.03684915f, 0.00065095f, 0.04073768f, -0.01694350f, -0.01408407f, 
    0.03599913f, -0.01035386f, -0.03756175f, 0.00799800f, -0.03454308f, 0.04066413f, -0.00802804f, 0.00797728f, 
    -0.01637310f, 0.01537336f, 0.03017144f, -0.00764706f, -0.05409358f, -0.02036580f, 0.01074175f, -0.00289727f, 
    -0.01611105f, -0.04369068f, -0.04337534f, -0.02104375f, -0.03129463f, 0.02571030f, -0.04510917f, -0.03068687f, 
    -0.00640307f, -0.05119784f, 0.04056864f, -0.00306260f, 0.00810965f, 0.03401298f, -0.00526194f, 0.01958400f, 
    -0.00374593f, 0.03317295f, -0.00756359f, -0.00856422f, 0.00187402f, -0.02051905f, 0.01736832f, 0.03391897f, 
    -0.03937031f, -0.04063546f, -0.04304472f, -0.05760030f, 0.01165593f, -0.03686843f, 0.02440729f, -0.01482665f, 
    -0.04799607f, -0.02622274f, 0.02272370f, 0.03607127f, -0.03736844f, 0.00295161f, 0.00934794f, 0.02288855f, 
    0.03163576f, 0.01605061f, -0.03318769f, 0.04041291f, -0.06094477f, -0.04653085f, -0.03374415f, -0.01961877f, 
    0.00564119f, 0.01280938f, -0.05380973f, -0.03862020f, 0.01885850f, -0.02234569f, -0.02062230f, -0.05005342f, 
    -0.01134254f, -0.05525531f, -0.05634400f, -0.02538598f, -0.02266821f, -0.05071296f, 0.01471122f, -0.04946190f, 
    0.03661513f, -0.02596783f, -0.01087690f, 0.02929845f, 0.02713682f, -0.00581373f, -0.00644293f, -0.01470699f, 
    -0.05557963f, -0.04660577f, -0.03641575f, -0.04854975f, 0.01083890f, 0.00634794f, -0.05166963f, 0.04025976f, 
    -0.00882355f, 0.01510550f, 0.00357286f, 0.01978415f, -0.02458275f, -0.04563502f, -0.01175523f, -0.03312211f, 
    0.01900646f, 0.00445184f, -0.00127032f, 0.00330785f, -0.00525910f, 0.02352221f, -0.03500174f, -0.04409521f, 
    -0.00983180f, 0.03008921f, -0.05011948f, 0.02965483f, 0.00184937f, 0.04009105f, 0.04951550f, 0.01292129f, 
    0.00503671f, 0.01571659f, -0.05393565f, 0.03118593f, 0.00753255f, -0.00374485f, -0.01832000f, 0.03493888f, 
    -0.02199382f, -0.05060216f, -0.05431729f, -0.00583922f, -0.00462906f, -0.00572888f, -0.00117470f, -0.01939384f, 
    0.03867078f, 0.02252116f, -0.04780984f, 0.00926068f, -0.03135747f, -0.04926329f, -0.05319129f, -0.03005066f, 
    -0.02543107f, 0.01051007f, -0.00471055f, -0.01621669f, 0.03571850f, -0.05071811f, 0.01700855f, 0.01453929f, 
    -0.00308503f, -0.00014982f, -0.02225622f, 0.03148256f, 0.00073181f, 0.00398999f, -0.04126115f, -0.02409685f, 
    0.03201887f, -0.02167510f, -0.00998273f, 0.03109866f, 0.01416249f, -0.04994547f, -0.01189581f, 0.02256796f, 
    -0.01508317f, -0.03037693f, 0.00765263f, 0.02744447f, -0.00184565f, 0.03413836f, -0.04985484f, -0.01160720f, 
    0.02976566f, -0.02544028f, -0.03390791f, 0.02154242f, -0.03949530f, -0.03930872f, -0.00361972f, -0.02827453f, 
    -0.00195751f, -0.04167886f, -0.03717820f, -0.05370752f, -0.05709630f, -0.05043525f, 0.02043191f, -0.02553358f, 
    0.01927073f, -0.03288279f, 0.01665264f, -0.00631013f, 0.02752824f, -0.00656165f, -0.01755437f, -0.02723609f, 
    -0.00804391f, -0.05103813f, 0.01428003f, -0.03990032f, -0.03671975f, -0.05546753f, 0.01764971f, -0.04460629f, 
    -0.01339614f, -0.01185196f, -0.01689799f, 0.01457141f, 0.02967879f, -0.03658527f, -0.05326807f, 0.01437711f, 
    0.03855267f, -0.00038221f, 0.00603280f, 0.02463236f, -0.01166085f, -0.01249412f, -0.04544657f, 0.03342021f, 
    -0.04365709f, 0.14517148f, -0.07411802f, 0.17293513f, 0.13501161f, -0.21269165f, 0.17903580f, 0.05598225f, 
    0.00840505f, -0.06440475f, -0.04305795f, -0.05994417f, 0.03241571f, 0.00959690f, 0.00987040f, 0.16266580f, 
    -0.02063879f, 0.12291652f, 0.03343372f, 0.16491193f, -0.13854986f, -0.08535222f, -0.12071834f, -0.14162485f, 
    0.03438912f, 0.29875630f, -0.33555576f, -0.21177655f, -0.14945468f, 0.25567001f, 0.00002548f, -0.10611654f, 
    -0.08425780f, -0.05961044f, -0.00479733f, 0.01193030f, 0.17981522f, 0.29671305f, -0.23313642f, 0.23617278f, 
    0.02047390f, 0.13937841f, -0.16772513f, 0.05736314f, -0.03945758f, -0.06147783f, 0.03827021f, 0.13627589f, 
    -0.16162352f, 0.38283944f, -0.07576119f, 0.12743562f, 0.04475497f, 0.02807862f, -0.02562521f, 0.11574756f, 
    0.07476949f, -0.05566038f, -0.01340034f, 0.04525011f, -0.03234709f, 0.04090928f, -0.12747683f, -0.08421969f, 
    0.00429698f, 0.06449401f, 0.04672344f, -0.07708298f, -0.12982099f, -0.04294770f, -0.34166649f, -0.21486957f, 
    0.02304742f, 0.13260508f, 0.10446913f, 0.14764559f, -0.10150206f, -0.06642005f, 0.03403437f, -0.02686268f, 
    -0.19578490f, -0.00544651f, -0.27102304f, -0.21732655f, 0.31171340f, 0.20374438f, -0.00712286f, 0.18719615f, 
    0.04014639f, 0.12608324f, -0.08940983f, -0.06432454f, 0.04424662f, 0.14546913f, 0.08551998f, 0.06007179f, 
    -0.09627735f, -0.26877019f, 0.05973155f, 0.12248409f, -0.11910485f, 0.06267936f, 0.10992984f, -0.05725444f, 
    0.20905121f, -0.02545711f, 0.05690006f, 0.05743409f, -0.25674853f, 0.15050834f, 0.38584954f, -0.01008212f, 
    0.06925811f, -0.21663952f, -0.29483289f, 0.05917982f, 0.14948115f, -0.03853153f, -0.03428764f, 0.08058977f, 
    0.15971199f, 0.05244634f, 0.13547005f, 0.22736824f, -0.05259543f, 0.08056064f, -0.00474411f, -0.30705085f, 
    0.09097256f, -0.05338692f, 0.04715886f, 0.27518979f, 0.03753376f, -0.00716607f, 0.11263063f, -0.07759041f, 
    -0.02312054f, 0.07217830f, 0.03122555f, 0.09042948f, -0.26329446f, 0.00022009f, -0.16906768f, -0.14004792f, 
    0.64770025f, 0.03306143f, 0.04227063f, 0.26839384f, 0.08855874f, 0.00167709f, 0.08720949f, 0.13750175f, 
    0.14668006f, -0.05266587f, -0.07428232f, 0.10336317f, 0.08754794f, 0.02278258f, 0.26212391f, -0.08232917f, 
    -0.33995193f, -0.18361379f, -0.01148736f, 0.03636268f, -0.10205156f, 0.07911732f, 0.04755002f, 0.06405833f, 
    0.27831990f, -0.23782012f, -0.32966873f, 0.01165257f, 0.10127524f, 0.06402887f, -0.05386226f, -0.21580260f, 
    0.03305267f, 0.09599333f, -0.07530056f, -0.00177370f, -0.10069853f, -0.12734561f, 0.09724871f, -0.06825554f, 
    -0.16203748f, -0.05672510f, -0.36246672f, -0.18816638f, -0.21575856f, -0.09880576f, 0.11501117f, 0.05654414f, 
    -0.04095759f, 0.00069384f, 0.05563293f, 0.12271170f, 0.09321424f, 0.20833597f, 0.02284649f, -0.04163260f, 
    0.11153709f, 0.09965873f, 0.15495920f, 0.23334891f, -0.07684135f, 0.04714421f, -0.09960137f, 0.11947156f, 
    0.10537237f, 0.10317929f, 0.08515935f, -0.05960331f, 0.13915378f, -0.05728552f, 0.14263806f, 0.18842117f, 
    0.02366903f, -0.05308864f, -0.13295695f, -0.44695315f, 0.01260492f, 0.11438262f, -0.07049076f, -0.14213738f, 
    0.10015216f, 0.02762219f, -0.09880494f, -0.14214413f, -0.23347475f, 0.20482258f, 0.11229910f, -0.23238996f, 
    0.05700812f, -0.01196992f, 0.06840375f, -0.08689797f, -0.29352340f, -0.17713048f, -0.05958465f, -0.34771737f, 
    -0.03853176f, 0.12665898f, 0.06835130f, 0.03707300f, 0.06660581f, 0.12819573f, -0.08521896f, -0.07238428f, 
    -0.03843082f, -0.04394880f, -0.13473150f, -0.04006629f, 0.36595389f, 0.10899432f, 0.08305622f, 0.08033957f, 
    -0.00461810f, 0.14178792f, 0.11657126f, 0.15136932f, 0.08434899f, 0.02532355f, 0.02955703f, 0.04626944f, 
    -0.22512935f, 0.06274687f, -0.14541492f, -0.11573271f, -0.18612078f, -0.03835119f, -0.13711371f, -0.06008439f, 
    -0.16834846f, -0.15503536f, -0.05653711f, -0.15583859f, 0.08830296f, 0.08326035f, 0.17445235f, -0.10418387f, 
    0.10850496f, 0.13339077f, -0.00165705f, -0.02273289f, -0.01847479f, -0.15401462f, -0.03293799f, -0.04821255f, 
    0.38261309f, 0.08281837f, 0.01311425f, -0.23332524f, 0.09757474f, 0.00002258f, 0.16239685f, -0.02192719f, 
    -0.06681643f, -0.19171695f, -0.01076483f, 0.01675346f, -0.15848115f, 0.00867950f, 0.20897318f, -0.05888421f, 
    -0.06958994f, 0.08223258f, 0.00566430f, 0.03717541f, 0.20733126f, 0.23853035f, -0.24805856f, 0.19292796f, 
    0.01177703f, 0.23710962f, -0.26506937f, -0.01161055f, -0.04865953f, -0.09562527f, 0.27018005f, -0.00430074f, 
    0.04566108f, 0.19158846f, 0.19726102f, -0.05858033f, 0.18062480f, 0.16138950f, -0.32948408f, -0.28080481f, 
    0.18759321f, 0.00388711f, 0.05262997f, 0.03676406f, -0.01480437f, 0.16046228f, -0.10775725f, -0.22473359f, 
    0.12658310f, 0.10789713f, -0.05342429f, 0.23217750f, 0.14531241f, 0.11672177f, 0.08590976f, -0.12668453f, 
    -0.00733361f, -0.03547744f, -0.26236537f, -0.06728376f, -0.12068896f, 0.14295249f, -0.28119975f, 0.08852108f, 
    0.04792127f, -0.07430264f, 0.19917203f, -0.26519519f, -0.07619445f, 0.06618181f, -0.16710824f, -0.32839409f, 
    0.28763416f, 0.09865270f, -0.03467601f, 0.00286084f, -0.00029824f, 0.05172996f, -0.00458023f, 0.00121663f, 
    0.18302627f, -0.01059024f, 0.11125879f, 0.10291975f, 0.13289489f, 0.03915486f, 0.09616520f, 0.20503488f, 
    -0.10096913f, -0.23373936f, -0.05403747f, -0.17621715f, 0.04923368f, 0.18337308f, 0.13986608f, 0.22769724f, 
    -0.08678958f, 0.10203940f, -0.05406802f, 0.09172414f, -0.02721565f, 0.03788402f, 0.12313424f, -0.04085925f, 
    -0.02096456f, 0.01277587f, 0.06720868f, 0.07580481f, 0.01785169f, 0.04021415f, -0.12449037f, -0.01089332f, 
    0.06848788f, -0.02977347f, 0.13044631f, 0.11364397f, 0.14179850f, 0.07323602f, 0.01512829f, 0.14427766f, 
    -0.22323832f, -0.27750048f, -0.36494330f, 0.22959532f, 0.03053659f, -0.12596335f, 0.08365137f, -0.02952407f, 
    0.20781185f, 0.00860132f, 0.04390946f, 0.13378142f, -0.17140897f, 0.05219319f, -0.40348259f, -0.01550743f, 
    0.01417110f, -0.07102247f, -0.03694252f, -0.04373905f, 0.02962822f, -0.09312592f, -0.02126748f, -0.06179089f, 
    0.16069026f, 0.13413639f, 0.15424195f, -0.11346670f, -0.04416792f, 0.01947344f, 0.11980668f, 0.15249453f, 
    0.02079448f, 0.05903032f, 0.02744150f, -0.00863210f, -0.05978276f, -0.00599665f, -0.08172329f, 0.06346305f, 
    0.21564060f, 0.12846881f, -0.02444849f, 0.13711916f, 0.10244414f, 0.09156000f, -0.04710457f, 0.18918012f, 
    0.17453066f, -0.05942030f, -0.06870855f, -0.16937470f, 0.16362268f, 0.03738644f, 0.21508215f, -0.07967772f, 
    0.08912139f, 0.03000172f, 0.02095212f, 0.06073038f, -0.19148225f, 0.16205262f, 0.04039374f, 0.20867325f, 
    0.12602243f, -0.04036618f, -0.12300523f, -0.14979583f, 0.18810321f, 0.05998751f, 0.01458106f, -0.04111317f, 
    -0.00771354f, 0.06068601f, -0.06062492f, 0.01440912f, 0.07871038f, 0.09174746f, 0.11303033f, -0.00952539f, 
    -0.03670479f, 0.10823378f, 0.08260462f, -0.06242958f, -0.07364562f, 0.15781742f, -0.43550476f, -0.02754532f, 
    0.13058464f, 0.10984889f, -0.18559918f, -0.08301654f, 0.04933169f, -0.10583290f, -0.04556990f, -0.07572071f, 
    0.21065028f, -0.10803427f, 0.09738168f, -0.05857195f, -0.00356880f, 0.02831038f, -0.00922118f, -0.00998675f, 
    -0.08317268f, 0.00044032f, 0.06720728f, -0.13607782f, 0.11481926f, 0.00415301f, -0.10404114f, -0.21206634f, 
    -0.04333197f, 0.10584876f, 0.03619573f, -0.06679994f, 0.11739262f, -0.04851099f, 0.03054159f, 0.12406139f, 
    -0.20169045f, -0.14245293f, -0.06560734f, 0.18263134f, 0.04197198f, 0.03501282f, 0.04311930f, 0.06603467f, 
    0.10156010f, -0.19176818f, 0.08028595f, -0.01090066f, -0.13160932f, -0.16790138f, -0.07073919f, -0.13227879f, 
    -0.03748268f, -0.03127784f, -0.01084832f, -0.02801899f, 0.08068733f, -0.05129896f, -0.02471409f, 0.06545471f, 
    -0.23605889f, -0.05755244f, -0.12416724f, 0.24018349f, 0.14241648f, -0.01786174f, -0.03793477f, -0.06202966f, 
    0.07370158f, 0.17425019f, -0.19648193f, 0.16830504f, -0.25704342f, -0.17238614f, 0.01200936f, 0.01951129f, 
    0.04491022f, -0.04582921f, -0.19319542f, 0.04464129f, 0.00757178f, -0.04289496f, -0.03746383f, 0.09617993f, 
    0.08808884f, 0.02779280f, 0.15001135f, 0.16085075f, 0.02081647f, -0.12454256f, -0.12234000f, -0.12984054f, 
    0.06073060f, -0.08990863f, -0.06194977f, -0.03685352f, 0.09532516f, 0.00846113f, 0.13316567f, -0.10919862f, 
    -0.05366769f, -0.03019400f, -0.09358466f, -0.00260567f, 0.07295964f, -0.09029987f, 0.03429891f, 0.06812222f, 
    -0.02578290f, -0.14302930f, -0.05608124f, -0.19635008f, 0.08228686f, -0.04729193f, -0.13599670f, -0.09318589f, 
    0.29769239f, 0.07347022f, 0.10882195f, 0.17762111f, 0.11976868f, -0.25803891f, -0.06039503f, 0.06263900f, 
    -0.02800442f, 0.00766844f, -0.02340201f, -0.12155000f, 0.08413391f, -0.03935737f, 0.04561159f, 0.05919522f, 
    -0.01098848f, 0.03011782f, 0.12565476f, 0.19605061f, 0.01138628f, 0.03789198f, 0.00441589f, 0.06052890f, 
    0.14028102f, 0.15096977f, 0.13407874f, 0.03850416f, -0.02562506f, 0.06042635f, -0.12911123f, 0.05599448f, 
    -0.05008547f, 0.04569336f, 0.00583630f, -0.00765006f, 0.14241996f, -0.03252873f, 0.01465695f, 0.04643326f, 
    -0.33438483f, 0.03229182f, -0.14802989f, -0.01364134f, 0.09161982f, -0.09284711f, -0.16193247f, -0.08982776f, 
    0.04433514f, 0.03282115f, 0.00812163f, 0.11293364f, 0.20105466f, -0.28346786f, 0.06469600f, 0.14379553f, 
    -0.07379324f, -0.23242331f, 0.04906625f, 0.05641158f, 0.22643656f, 0.06791796f, 0.02487495f, 0.14397158f, 
    0.03375711f, -0.24220014f, 0.09195326f, 0.27835971f, -0.03455916f, -0.12318891f, -0.07383776f, 0.06207076f, 
    0.14004496f, -0.11109909f, -0.02617672f, 0.12193286f, -0.03401466f, -0.11659097f, -0.16741839f, 0.12698068f, 
    0.15935183f, -0.06572635f, -0.08775074f, -0.00106809f, 0.05090489f, 0.01537601f, 0.00029630f, -0.06956005f, 
    0.10799158f, 0.29232407f, -0.03215894f, -0.15039043f, 0.07319567f, 0.00142012f, -0.01059072f, 0.07358764f, 
    0.14646471f, 0.02624821f, -0.01440386f, 0.00366677f, -0.19767724f, -0.07925761f, -0.20037194f, 0.33046952f, 
    0.06122869f, -0.06273071f, -0.01039576f, -0.06492656f, -0.03048183f, 0.15769261f, 0.01648714f, 0.10131463f, 
    -0.12939090f, 0.01077506f, 0.10178895f, -0.01382876f, -0.04268399f, -0.03126866f, 0.08046644f, 0.02113463f, 
    0.08688851f, 0.03906712f, 0.03716038f, 0.13318640f, -0.19848391f, -0.05121333f, -0.16238371f, 0.04527005f, 
    0.10799701f, -0.01098814f, -0.00510308f, -0.12723675f, 0.03475370f, -0.02805086f, -0.00839493f, 0.08689117f, 
    -0.17604271f, 0.05711426f, 0.14692652f, -0.07740249f, -0.02158456f, -0.29593602f, -0.09994620f, 0.04294799f, 
    -0.05949242f, 0.15781114f, -0.06671619f, -0.16148624f, 0.00020047f, -0.17085171f, -0.01817673f, 0.01336551f, 
    0.08192141f, -0.02409739f, -0.03929437f, -0.01082404f, -0.12777764f, -0.08686318f, -0.04838939f, -0.07200701f, 
    0.02075207f, 0.04739698f, 0.14755104f, -0.13350126f, 0.12727299f, -0.12661180f, 0.04055762f, 0.09199521f, 
    -0.00128181f, -0.05211800f, -0.01805567f, -0.11934768f, -0.05669354f, -0.05844022f, -0.00921016f, -0.12945333f, 
    -0.01796427f, 0.01141385f, -0.03280025f, 0.08469705f, -0.12816623f, 0.00237137f, -0.12896417f, -0.07571361f, 
    -0.12419196f, -0.07522455f, 0.16067116f, -0.15792885f, 0.03759695f, 0.14625324f, -0.02162218f, -0.10670329f, 
    -0.02797884f, 0.02420649f, 0.03063670f, -0.00880014f, 0.25056970f, -0.02023387f, 0.21908356f, -0.31171495f, 
    0.05124436f, -0.00353136f, 0.00427703f, 0.10796767f, -0.01623452f, 0.13691181f, 0.02419519f, 0.11230094f, 
    -0.19258915f, 0.03039500f, -0.27281103f, 0.33588323f, 0.07912766f, -0.12999834f, 0.11335201f, 0.08308117f, 
    0.04865603f, -0.05570798f, 0.03924748f, 0.04357301f, -0.04838056f, 0.13817096f, -0.00576060f, -0.05166743f, 
    0.02806818f, 0.08842444f, -0.01864393f, 0.07235445f, -0.10494905f, -0.17226288f, -0.13587011f, -0.19629206f, 
    -0.01442187f, 0.13742061f, 0.04240566f, 0.18487951f, -0.04022858f, -0.10609807f, 0.01798711f, 0.02740145f, 
    0.00464648f, 0.01421639f, -0.15027802f, -0.09164019f, 0.14904463f, 0.13845031f, 0.09491833f, 0.09580002f, 
    -0.01794401f, 0.06117741f, 0.09189498f, 0.05456650f, -0.04528581f, -0.00373143f, 0.12346406f, -0.02705529f, 
    0.22436029f, 0.08504175f, -0.00220092f, 0.03599174f, -0.03311199f, -0.19587447f, -0.11080956f, -0.13496536f, 
    0.08262712f, -0.00954437f, -0.03315262f, 0.00940523f, 0.20690221f, -0.02817974f, 0.36638665f, -0.22731259f, 
    0.01145108f, 0.03310047f, 0.02410143f, -0.02060780f, -0.03818714f, -0.03587953f, -0.01364542f, 0.02966608f, 
    0.07067147f, 0.44417703f, 0.16542348f, 0.15200721f, -0.00192382f, -0.04092697f, -0.00488438f, -0.11666842f, 
    0.02852855f, 0.06581227f, 0.10006421f, 0.17971601f, 0.02141291f, 0.11764156f, 0.05684260f, 0.10382147f, 
    0.13235660f, 0.00257304f, 0.08259651f, 0.01349540f, -0.21239887f, 0.06089335f, -0.02182567f, -0.01386481f, 
    0.04102619f, 0.36858052f, 0.34085628f, 0.17246254f, -0.03348874f, -0.02409946f, -0.00681880f, -0.17160240f, 
    -0.01892654f, 0.06398713f, 0.08370471f, 0.06713150f, -0.19869535f, -0.25611857f, -0.05522176f, 0.31232420f, 
    0.02768047f, 0.16159676f, 0.01841954f, 0.03909248f, -0.05891635f, 0.04473335f, -0.01502553f, 0.00686798f, 
    0.10121860f, 0.10651376f, -0.03733876f, -0.00854023f, -0.01250664f, 0.07085388f, 0.02887238f, 0.13938771f, 
    0.12134774f, 0.13696294f, -0.07446197f, 0.18957698f, 0.15549259f, -0.08470824f, -0.19674550f, -0.01085308f, 
    -0.03409167f, 0.07704196f, 0.15272327f, 0.03342206f, -0.01922301f, -0.04098476f, 0.01383840f, -0.08436561f, 
    0.13146818f, 0.08662006f, 0.03874643f, 0.09718201f, 0.14342460f, 0.05876211f, 0.09800278f, 0.17069133f, 
    -0.01036002f, 0.14236224f, 0.14818473f, 0.15999718f, 0.07087122f, 0.12098981f, -0.05938620f, 0.03312888f, 
    0.00332523f, 0.10514615f, 0.13669504f, -0.00522744f, 0.08448555f, 0.12666596f, 0.04819740f, 0.06118694f, 
    0.01053875f, 0.13247359f, -0.03860324f, 0.11132076f, -0.01477927f, 0.08507924f, 0.03216064f, 0.04071283f, 
    0.02906744f, -0.03376193f, 0.01163508f, -0.16611631f, -0.20009321f, -0.00144779f, -0.11494626f, 0.09106450f, 
    0.03792907f, 0.08573809f, 0.07104576f, -0.00232150f, -0.06890766f, -0.05028509f, -0.07404996f, -0.12179355f, 
    0.02436018f, -0.02174066f, -0.14336869f, -0.18908030f, -0.03427134f, 0.05303476f, 0.09307450f, -0.13415498f, 
    -0.12412039f, 0.00670243f, 0.00587646f, -0.09146136f, 0.08488543f, 0.30760971f, 0.29130545f, 0.22169136f, 
    0.05231144f, -0.00991403f, 0.06676771f, 0.02835868f, -0.12535530f, 0.03908718f, 0.06356817f, 0.14270812f, 
    0.26461685f, -0.14810859f, -0.01911994f, -0.05899207f, -0.06780896f, 0.05116239f, 0.11002882f, -0.02352954f, 
    -0.06521339f, -0.07015392f, -0.10332132f, -0.09402993f, -0.35702711f, 0.33234906f, -0.11361945f, 0.01318651f, 
    0.02587732f, 0.04995166f, -0.02521807f, 0.01915015f, 0.05068325f, -0.04167661f, -0.06072775f, -0.06426201f, 
    -0.33729479f, 0.24690200f, 0.05798093f, 0.17430335f, 0.08917702f, -0.01668373f, 0.01076248f, -0.02208358f, 
    -0.20428272f, -0.09512528f, -0.10046408f, 0.11988030f, -0.09912613f, 0.05416008f, -0.02082338f, -0.13047619f, 
    -0.03063559f, -0.00821308f, 0.09797104f, 0.08380676f, 0.01404305f, 0.10955531f, -0.07290477f, 0.07805896f, 
    -0.31264994f, -0.00648287f, 0.02819304f, 0.08427005f, 0.26144600f, 0.14485984f, 0.00097754f, -0.08322763f, 
    -0.07165974f, 0.03399253f, 0.07879112f, -0.02844736f, -0.22430247f, -0.18064934f, 0.18308756f, -0.14265466f, 
    0.16974247f, 0.05503531f, -0.07401296f, 0.08510626f, 0.06604591f, 0.05841398f, -0.02384736f, -0.13888769f, 
    0.16337235f, 0.22846055f, 0.07849108f, 0.01230242f, 0.06575609f, -0.05870414f, -0.02435254f, -0.05480494f, 
    -0.09091324f, -0.05689146f, -0.13507462f, -0.14602754f, 0.18865345f, -0.08182252f, 0.02451967f, -0.13577323f, 
    -0.00961121f, 0.11027656f, 0.11726393f, 0.07107686f, -0.02062614f, 0.00184163f, -0.07582319f, -0.10650578f, 
    0.21321312f, -0.11942442f, -0.01810469f, -0.10320537f, -0.07957198f, 0.17725678f, 0.10909756f, -0.03684331f, 
    0.06574462f, -0.03959198f, 0.10614208f, 0.04838308f, 0.09016562f, -0.03645150f, -0.12637469f, -0.00305294f, 
    -0.04700755f, -0.01788156f, 0.04158027f, 0.04599553f, 0.07681450f, 0.24409397f, 0.18175614f, 0.27433109f, 
    -0.01337606f, 0.00496259f, -0.00900035f, -0.03423377f, -0.00628184f, 0.00852010f, -0.01567432f, -0.04937293f, 
    0.02012247f, 0.02637567f, -0.03823708f, 0.03940066f, -0.03151519f, 0.01397136f, -0.04631625f, -0.02621467f, 
    -0.04320324f, 0.01874354f, 0.01958040f, -0.04758905f, 0.03079466f, -0.04689483f, -0.00214419f, -0.01543677f, 
    0.01387678f, -0.00866114f, -0.02659293f, 0.01338690f, 0.02698188f, 0.00527565f, 0.00877169f, 0.03427507f, 
    -0.00522914f, -0.02769323f, 0.02475997f, -0.05414435f, -0.04403304f, -0.03609207f, -0.03153987f, -0.01350702f, 
    0.02810184f, -0.00267697f, -0.00158690f, -0.00457076f, -0.01383471f, 0.02999911f, -0.00581321f, -0.04369862f, 
    -0.05157821f, -0.04009736f, 0.02018041f, -0.02606461f, -0.04456028f, -0.05160039f, 0.02320949f, 0.02507323f, 
    -0.05074857f, 0.02712456f, -0.03777560f, 0.00881933f, 0.02138026f, 0.01618380f, 0.01583441f, -0.00238201f, 
    0.02649898f, 0.04350468f, 0.00726724f, -0.00308735f, 0.01483443f, -0.01016990f, 0.00490625f, -0.04951243f, 
    -0.04770051f, -0.02913203f, -0.04001129f, 0.04185781f, -0.02879328f, -0.04909999f, -0.01988682f, -0.03691468f, 
    -0.02524855f, 0.04084890f, 0.00551372f, 0.04055067f, -0.01869611f, -0.02332968f, 0.02308959f, -0.02347669f, 
    0.00478895f, 0.01587787f, 0.00564400f, 0.04186879f, 0.04413670f, 0.01141837f, 0.04283166f, -0.04356727f, 
    -0.02953809f, 0.00989580f, 0.04348952f, 0.03434878f, 0.04183125f, -0.05391374f, 0.01334165f, 0.02830908f, 
    -0.03978579f, -0.05465287f, 0.04170446f, 0.03729841f, 0.02293616f, -0.02131919f, -0.04826101f, -0.04088730f, 
    0.00740627f, 0.02321684f, -0.04111047f, 0.02418979f, 0.03369408f, 0.02775671f, -0.01886878f, 0.04051098f, 
    -0.00536614f, -0.04797574f, 0.03654197f, 0.00053754f, -0.02124669f, 0.03336234f, 0.03695106f, 0.04250816f, 
    -0.03210849f, 0.03029831f, 0.01114231f, 0.03014819f, -0.04414136f, -0.02310038f, -0.00879687f, -0.01515043f, 
    0.00449782f, -0.00596847f, -0.02479346f, -0.05085950f, -0.04095333f, 0.01758063f, 0.00123184f, 0.01490295f, 
    0.00916879f, -0.03946490f, -0.02421535f, -0.03483188f, -0.01924187f, 0.03098782f, -0.00461412f, 0.03456293f, 
    0.02115246f, -0.02352180f, 0.02517507f, 0.01455183f, -0.04513772f, 0.00954689f, 0.00448168f, 0.00303187f, 
    -0.00285321f, 0.03543594f, 0.00013875f, -0.00028809f, -0.04345357f, 0.03982693f, 0.03375962f, -0.04353512f, 
    -0.04853190f, 0.00964196f, -0.04096584f, 0.02827973f, -0.03516141f, 0.02777715f, -0.00505714f, 0.00352548f, 
    -0.01396679f, -0.02057631f, -0.03573545f, 0.01182094f, -0.05130212f, -0.01781009f, 0.00736672f, -0.02706483f, 
    0.01835540f, 0.01343844f, -0.03482964f, -0.02253932f, -0.04169110f, -0.00323646f, -0.00727023f, -0.01748829f, 
    -0.03811937f, 0.00319336f, 0.00885889f, -0.03147103f, -0.01182306f, 0.00335021f, -0.04629551f, -0.02146540f, 
    -0.04379281f, -0.04024481f, -0.03661770f, -0.04359873f, -0.03749213f, -0.02522734f, 0.04110636f, 0.03456311f, 
    0.00059025f, 0.00474459f, 0.04214666f, 0.02672559f, 0.00118290f, -0.04355555f, -0.02587680f, 0.00654044f, 
    -0.02137991f, -0.04052405f, 0.04065998f, -0.00927433f, -0.01253437f, -0.01040777f, -0.02681711f, 0.01084028f, 
    -0.03372823f, -0.01548564f, -0.00748017f, -0.01894574f, 0.03586763f, -0.02297748f, -0.01646202f, -0.01819105f, 
    -0.05531022f, -0.03144960f, -0.04850651f, -0.02737155f, -0.02168570f, -0.02880708f, 0.04484054f, 0.02308181f, 
    -0.05397222f, -0.00515214f, -0.03956216f, -0.02430973f, -0.00854757f, -0.04053363f, -0.00408910f, 0.02017062f, 
    0.02670312f, -0.04196670f, -0.03089171f, -0.05676419f, -0.04060892f, -0.04802007f, -0.05299865f, -0.02957492f, 
    0.00117472f, -0.02228453f, 0.02841070f, -0.00081946f, -0.03148441f, -0.05006871f, -0.02600217f, -0.03770535f, 
    -0.02560580f, -0.03258612f, 0.02657274f, 0.03246201f, -0.00874770f, 0.00377154f, -0.01074929f, -0.02038242f, 
    0.01386625f, -0.04663237f, -0.00879153f, -0.01759487f, -0.03047370f, -0.05635494f, 0.00258231f, 0.00588866f, 
    -0.01529228f, -0.00875926f, 0.03099543f, 0.00025540f, -0.00022049f, -0.02312305f, -0.04655229f, 0.01312421f, 
    0.00222900f, 0.04471543f, -0.02785248f, 0.00803724f, -0.02775538f, 0.02315112f, -0.03536019f, -0.05239675f, 
    0.03719374f, 0.04481337f, 0.02003592f, 0.02523598f, -0.04793736f, -0.02518963f, 0.03744045f, -0.00871325f, 
    -0.03552062f, 0.00251298f, 0.00010381f, 0.01457061f, -0.04850336f, -0.03682361f, -0.03654997f, -0.00123742f, 
    0.02440864f, 0.03088399f, 0.01344641f, 0.02643145f, 0.02662243f, 0.02483691f, 0.01587095f, 0.01754560f, 
    -0.03023332f, -0.02591518f, -0.00002847f, -0.02431116f, 0.03469274f, 0.03901400f, 0.01290062f, 0.03998918f, 
    -0.01567784f, 0.03812413f, -0.02498723f, 0.02182066f, 0.01507362f, -0.00706297f, -0.05269157f, -0.00098709f, 
    0.00514927f, -0.03551440f, -0.04111778f, -0.00303979f, -0.04388786f, 0.00817576f, -0.01743723f, 0.03909510f, 
    -0.05424093f, -0.03210754f, -0.04345924f, -0.04165316f, 0.01855650f, -0.03069593f, -0.04043226f, 0.03892491f, 
    0.04358876f, 0.01358967f, 0.03284059f, -0.01354043f, 0.01726009f, -0.01354003f, -0.01455286f, -0.05414035f, 
    0.04248179f, 0.02429406f, 0.00393056f, -0.05415030f, 0.01445839f, -0.01179863f, -0.05205938f, 0.00056091f, 
    0.03986906f, -0.02663950f, -0.04045162f, 0.00085763f, 0.04389449f, 0.04246830f, -0.03187830f, -0.04642194f, 
    0.04297843f, 0.02334748f, -0.00571661f, 0.02111102f, 0.01022006f, 0.04385486f, 0.01264526f, -0.03114296f, 
    -0.10003086f, -0.37402910f, -0.52973479f, -0.22953723f, 0.07044845f, -0.02001686f, 0.08620445f, 0.15266119f, 
    -0.04891526f, 0.03375705f, -0.02106271f, -0.00649409f, -0.27119723f, -0.05241902f, -0.01090293f, 0.06539377f, 
    0.15254059f, 0.00124147f, 0.17477429f, 0.08302940f, -0.05846378f, -0.06635591f, -0.04742938f, 0.01039919f, 
    -0.18219610f, 0.12487672f, 0.10884460f, 0.08242352f, -0.13454573f, 0.01518582f, 0.12987688f, -0.19063918f, 
    -0.04156811f, 0.05708065f, 0.06323972f, -0.01822497f, 0.05855494f, 0.08799041f, -0.03575740f, -0.01964505f, 
    0.09294178f, -0.08502219f, -0.02243512f, -0.03609479f, -0.02059321f, -0.14070331f, 0.01379649f, -0.05160420f, 
    -0.06926304f, 0.16323310f, 0.19467577f, -0.08542510f, 0.08025938f, 0.02828254f, -0.11394055f, 0.11559811f, 
    0.06878984f, 0.01847878f, -0.00891049f, 0.03895957f, 0.03771845f, -0.00287670f, 0.05614299f, 0.10116953f, 
    0.18925446f, 0.15207183f, 0.00643607f, 0.03280070f, -0.03675654f, -0.01445513f, -0.02697224f, 0.02555919f, 
    0.33006561f, -0.01288743f, -0.21296118f, 0.08269551f, -0.00704749f, 0.06425658f, 0.11225807f, 0.12713373f, 
    0.04130402f, -0.10645086f, -0.12722605f, 0.05570705f, -0.49067914f, 0.19071878f, -0.34891024f, -0.29469496f, 
    0.17390776f, -0.02566835f, -0.20369913f, -0.00919703f, 0.04625544f, 0.03686963f, -0.01695983f, -0.00088652f, 
    0.03792351f, 0.09141356f, 0.07588165f, -0.07000683f, 0.06836897f, 0.30564499f, 0.30112919f, 0.10989542f, 
    0.28436902f, 0.01500306f, -0.02210086f, -0.08425836f, 0.02392930f, 0.21749684f, 0.06776183f, 0.14842936f, 
    0.18038410f, 0.09031791f, -0.07044909f, 0.00922983f, 0.05036138f, -0.07386457f, 0.03843059f, 0.10643814f, 
    0.18387569f, 0.04328063f, -0.10504334f, -0.15223891f, -0.02258253f, 0.04387521f, -0.05845104f, 0.01018875f, 
    0.00408735f, -0.09584476f, 0.09427977f, -0.09024864f, 0.12609723f, -0.19669262f, -0.22808306f, -0.35157526f, 
    0.00697051f, 0.14516741f, -0.23520884f, 0.11284308f, -0.01812290f, 0.04566706f, 0.09136788f, -0.12122596f, 
    0.02474961f, -0.06991632f, -0.17715013f, 0.05527194f, 0.05714739f, -0.05446893f, 0.05210260f, -0.01951561f, 
    0.13543518f, 0.21809460f, 0.05509363f, -0.03832101f, 0.07394080f, 0.00295211f, 0.05257658f, 0.09458581f, 
    0.06244973f, -0.04019052f, -0.05426048f, -0.04826836f, 0.00382594f, 0.01095761f, 0.07782072f, 0.01451226f, 
    -0.30341959f, 0.08799229f, 0.17331733f, 0.16103555f, 0.00737267f, 0.14282627f, 0.02403720f, -0.02576778f, 
    -0.15895650f, 0.10820589f, -0.00777060f, 0.15066747f, 0.09574530f, 0.06808940f, 0.08929997f, -0.00776802f, 
    -0.00826820f, -0.00599334f, 0.01285539f, -0.03061442f, -0.02952684f, -0.06365189f, -0.02041782f, 0.03843869f, 
    -0.12382487f, -0.24786322f, 0.02132696f, -0.22304899f, -0.09467570f, -0.14281894f, -0.23493952f, -0.16336209f, 
    0.04243574f, -0.06442699f, 0.12571311f, 0.10333504f, 0.07200572f, 0.06382609f, 0.12490926f, -0.17552550f, 
    -0.21126132f, -0.21756834f, -0.34415466f, -0.06426585f, 0.05755990f, -0.02384253f, 0.03781030f, 0.03572548f, 
    0.03602684f, 0.01944391f, 0.00699305f, 0.07389115f, 0.04217933f, -0.00093717f, -0.06630374f, -0.05974326f, 
    0.03812205f, -0.01137073f, -0.01160472f, -0.01692327f, -0.00752080f, 0.07668701f, 0.11268757f, -0.01274621f, 
    -0.00036691f, -0.00414948f, -0.03533620f, 0.01634165f, -0.04897897f, 0.01259803f, 0.02156866f, -0.02455546f, 
    -0.02163734f, 0.19660647f, -0.06683090f, -0.02737953f, 0.03498708f, 0.03019371f, -0.21499397f, 0.12964661f, 
    0.01820099f, -0.00935409f, -0.04362226f, 0.05908608f, 0.16764076f, 0.01297741f, 0.14405259f, 0.06717712f, 
    -0.02724390f, -0.03568748f, -0.04315390f, 0.00682889f, -0.06413694f, -0.16216987f, 0.08965073f, -0.03300396f, 
    -0.00750556f, 0.05446199f, 0.05147756f, 0.05392144f, -0.07687096f, -0.00047174f, -0.04158637f, -0.02324556f, 
    -0.10368653f, -0.05954927f, -0.00694363f, -0.00993644f, -0.25315085f, -0.05068437f, 0.30796608f, -0.13847530f, 
    0.09490006f, 0.08858217f, 0.10500719f, 0.17899376f, -0.02209447f, -0.07897075f, 0.09375657f, -0.10722020f, 
    -0.03203516f, -0.03536674f, 0.29149997f, 0.09364936f, -0.10665466f, 0.03434004f, 0.02252559f, -0.03937564f, 
    -0.07188395f, -0.18128464f, 0.07797735f, -0.07423759f, 0.00712380f, -0.02399649f, -0.01445688f, -0.01485616f, 
    0.07022256f, -0.08694755f, -0.11326571f, -0.07150880f, 0.17692979f, 0.17826171f, -0.05934818f, -0.05964386f, 
    -0.06960019f, 0.11698177f, 0.04505743f, -0.06570023f, -0.05398006f, -0.00304745f, 0.01922891f, -0.11002908f, 
    0.12927330f, 0.09814136f, 0.01676605f, -0.06868105f, -0.10989781f, 0.14576298f, 0.02483726f, 0.20400903f, 
    -0.01781567f, -0.07845796f, -0.02203641f, -0.04543959f, -0.02749684f, -0.01072131f, -0.11691807f, 0.16905209f, 
    0.05145638f, 0.13481076f, 0.11871379f, 0.04905380f, -0.01975120f, 0.09961358f, 0.07567863f, 0.02113701f, 
    0.00715904f, 0.00487782f, -0.08254033f, -0.01377069f, -0.11403438f, 0.02671456f, -0.01385404f, 0.03618660f, 
    0.02388879f, -0.03865645f, 0.04967138f, -0.12061548f, -0.03268237f, 0.01627265f, -0.02500325f, 0.01002807f, 
    -0.21565719f, 0.03619529f, 0.03042371f, -0.07233819f, -0.07190089f, -0.21950588f, 0.04017423f, 0.01345700f, 
    0.02147893f, 0.05899356f, 0.00988825f, -0.12820831f, 0.00699704f, 0.06131326f, 0.05438279f, 0.12384503f, 
    -0.01189813f, 0.01442311f, -0.04664737f, 0.02862228f, 0.10939721f, 0.07107345f, 0.12338880f, 0.03097627f, 
    -0.03652735f, 0.01118496f, 0.01817085f, -0.03509755f, -0.03056654f, 0.02239368f, -0.05091971f, 0.03665613f, 
    -0.00907576f, 0.04791827f, 0.00399872f, 0.03891707f, 0.02005041f, -0.04476696f, 0.04054539f, 0.00585386f, 
    -0.03889106f, -0.02865918f, -0.01575334f, 0.00027660f, -0.04589425f, 0.00278508f, -0.02692425f, 0.04258215f, 
    -0.05597900f, -0.00676843f, -0.02422016f, 0.03321423f, -0.04260055f, 0.04207679f, -0.00590993f, -0.03849305f, 
    -0.00539701f, 0.00231610f, -0.04000939f, -0.05153900f, -0.02532682f, -0.01272686f, 0.01973620f, 0.00457933f, 
    0.03632265f, -0.04866803f, -0.02268359f, -0.03185506f, 0.01969858f, -0.01243833f, 0.00540711f, 0.01378054f, 
    -0.02943555f, 0.03540719f, -0.01296220f, -0.02150671f, 0.02658140f, 0.01204536f, -0.00579454f, 0.03729952f, 
    -0.00517140f, 0.02769984f, -0.02431944f, 0.01152125f, -0.00265126f, 0.02544044f, -0.03056730f, -0.02616378f, 
    -0.03214510f, -0.02349278f, -0.04622946f, 0.02725580f, 0.03545415f, -0.00925031f, -0.05604802f, -0.02166393f, 
    -0.00974065f, -0.01239412f, -0.02969000f, 0.04160432f, -0.02549557f, -0.05559051f, -0.04706921f, 0.02398730f, 
    -0.04567540f, 0.00622234f, -0.02907170f, 0.03748310f, -0.02617501f, -0.02438046f, 0.01224511f, -0.05139963f, 
    -0.00786749f, 0.03133812f, 0.03500819f, -0.05091441f, 0.00187178f, 0.02588814f, 0.01849588f, -0.04602684f, 
    -0.01247057f, 0.03035986f, -0.01571764f, 0.05105620f, 0.03811143f, -0.01958871f, -0.05573090f, 0.04319525f, 
    0.00828989f, -0.03995844f, -0.04449300f, 0.00101076f, 0.00050389f, -0.00899101f, -0.03742145f, 0.01549347f, 
    0.02307881f, -0.02322192f, 0.01181297f, -0.04991781f, 0.02066708f, -0.01160109f, -0.03955349f, -0.04109665f, 
    -0.01134785f, -0.02718893f, -0.02741928f, 0.00589613f, 0.01766928f, 0.01708402f, -0.00260385f, 0.00309276f, 
    -0.03986344f, 0.01063869f, -0.04826425f, 0.03049853f, 0.00742517f, 0.02386830f, -0.01714905f, -0.01284438f, 
    -0.03840403f, 0.04178123f, -0.00596255f, -0.03239819f, 0.01578350f, 0.01896616f, -0.01365060f, 0.03657119f, 
    -0.02794910f, -0.02117022f, -0.00744630f, 0.02319046f, -0.04728793f, 0.01114212f, -0.02018925f, 0.01987388f, 
    -0.03919543f, -0.05061396f, 0.02906457f, -0.03948716f, -0.01469741f, -0.02145709f, -0.00014402f, -0.03862778f, 
    0.04175150f, -0.01293171f, -0.04613364f, -0.04769824f, -0.03659926f, -0.02000297f, 0.01418514f, -0.01520316f, 
    -0.01214339f, -0.00679723f, -0.00376963f, -0.03176332f, -0.01930541f, -0.00143562f, 0.03419960f, -0.04588722f, 
    0.00978960f, -0.05715605f, -0.03761049f, -0.00161556f, -0.02896308f, -0.05048220f, -0.05806075f, 0.02785128f, 
    -0.02733983f, -0.03252702f, -0.00797511f, 0.01227450f, -0.00755590f, -0.04795187f, 0.04982721f, 0.02060568f, 
    -0.00668867f, 0.00091138f, 0.02568921f, -0.02270852f, -0.02447520f, 0.01522742f, -0.04860595f, -0.01711948f, 
    0.05017212f, 0.00175368f, 0.01271674f, -0.03059509f, 0.03971329f, 0.04005961f, 0.01103749f, -0.05715066f, 
    -0.00767069f, -0.02300248f, 0.01081923f, -0.02024870f, 0.01634490f, -0.04092444f, -0.00092562f, -0.03357261f, 
    0.00487215f, 0.02481359f, -0.03774339f, 0.00414152f, -0.04026372f, -0.05510315f, 0.00047389f, 0.01753222f, 
    -0.04687843f, 0.03560662f, 0.01914342f, 0.01499005f, -0.01206692f, -0.00215288f, 0.04028019f, -0.03954597f, 
    0.04227275f, -0.04425049f, -0.02652163f, -0.03719406f, 0.01286734f, 0.01441584f, 0.04371306f, -0.00478223f, 
    -0.03290600f, -0.04020476f, 0.02852624f, 0.02034188f, -0.02323471f, 0.00751397f, -0.01011531f, -0.01329520f, 
    -0.02400296f, -0.05283186f, 0.02594502f, -0.04038624f, -0.05659957f, 0.04273781f, -0.01391944f, -0.04507513f, 
    0.02861767f, -0.00073488f, 0.00451090f, -0.02917782f, -0.01202577f, -0.04480224f, -0.03480444f, 0.04126502f, 
    0.00161974f, -0.03437361f, -0.00312727f, -0.02229057f, -0.00134274f, -0.05052307f, 0.02454483f, -0.01287063f, 
    0.03013640f, -0.00060781f, -0.02437777f, -0.01967913f, -0.04339655f, 0.03401327f, -0.04226939f, 0.00695252f, 
    0.02471106f, -0.04121516f, -0.02655982f, -0.01496184f, -0.03859422f, 0.00973515f, -0.01745733f, -0.05163977f, 
    0.01572787f, 0.01034169f, -0.02542144f, -0.05435505f, -0.04672532f, 0.02201915f, -0.00359986f, -0.00143684f, 
    -0.05247755f, 0.03286144f, -0.00603847f, 0.00620453f, 0.02776592f, -0.00915096f, -0.05320450f, 0.00134547f, 
    -0.05363248f, -0.03375167f, -0.00063029f, -0.04885696f, -0.03928362f, 0.02803696f, -0.00754037f, 0.01520062f, 
    -0.05360060f, 0.02296279f, 0.02233307f, -0.05832150f, 0.03715258f, 0.02722985f, -0.00465447f, -0.02156164f, 
    0.02351178f, 0.03198696f, -0.03016856f, 0.02957186f, -0.00475022f, 0.03743410f, -0.03035135f, 0.01429766f, 
    0.03788909f, -0.05073713f, 0.02663073f, 0.03777960f, -0.01805911f, -0.03960035f, -0.00458787f, -0.02044056f, 
    0.00975944f, 0.00692843f, -0.04896378f, 0.01439471f, 0.04401654f, -0.01567989f, -0.03935398f, -0.03946551f, 
    0.03950273f, -0.04756514f, -0.00771152f, 0.02278346f, -0.01516872f, 0.00656602f, -0.05392254f, -0.05116522f, 
    0.00186481f, -0.01819530f, 0.03337994f, -0.04576306f, -0.00701923f, -0.02840607f, -0.04021989f, 0.04641209f, 
    0.00035660f, -0.02497505f, -0.04214623f, -0.03433514f, -0.00824969f, -0.01010114f, 0.03802493f, -0.04448716f, 
    0.00079946f, -0.01111069f, 0.00092957f, -0.03511649f, -0.02935147f, -0.02625434f, -0.01040979f, 0.04680768f, 
    0.02700230f, 0.03433069f, 0.00691081f, 0.02245446f, 0.01334823f, -0.05363485f, 0.03085105f, 0.00238768f, 
    0.12642686f, 0.13859886f, 0.37739754f, 0.13338475f, -0.07894900f, 0.10457744f, -0.03596793f, 0.12519220f, 
    -0.03540834f, 0.08069420f, -0.13616651f, -0.04235122f, 0.05095382f, 0.05434423f, 0.27856717f, 0.21283641f, 
    0.00666720f, 0.02738769f, 0.07036891f, -0.00221180f, -0.11641978f, 0.03366171f, 0.04823319f, -0.02860652f, 
    -0.13279459f, -0.13690914f, 0.55659050f, -0.16026340f, -0.00419244f, 0.16570207f, -0.11714805f, 0.08350068f, 
    -0.09525908f, 0.18404259f, -0.01858823f, -0.07136982f, 0.19743833f, -0.19677618f, 0.25120121f, -0.23301925f, 
    0.05532018f, 0.09453380f, -0.01058090f, -0.04764189f, -0.05658200f, 0.00397152f, 0.00275094f, -0.03712506f, 
    -0.21734950f, -0.15717708f, 0.34622815f, 0.10723163f, 0.00060086f, 0.04743773f, 0.04635602f, 0.12291084f, 
    0.03373963f, -0.01235410f, -0.17306092f, -0.00174674f, 0.03775391f, 0.03451633f, 0.10269359f, 0.03054678f, 
    -0.00204308f, -0.00097641f, 0.11315713f, -0.00136069f, 0.06472470f, -0.08177458f, -0.04666194f, -0.06028374f, 
    0.11916319f, 0.03832739f, 0.16020775f, 0.06819309f, 0.06900124f, 0.09319980f, -0.05461006f, 0.26613432f, 
    -0.04812653f, -0.02275864f, 0.03044770f, -0.01115987f, -0.27808952f, -0.13508509f, 0.07132117f, 0.02083797f, 
    -0.08389101f, -0.16357760f, -0.00351796f, 0.01269189f, -0.06095570f, -0.00102976f, 0.05578300f, 0.07640868f, 
    0.02755808f, 0.19710734f, 0.27397200f, 0.15394607f, 0.08113401f, 0.01183831f, -0.02302531f, 0.06723032f, 
    0.14980415f, 0.00451219f, -0.03993249f, -0.04041056f, 0.49448773f, 0.12442141f, 0.59459317f, 0.01803572f, 
    0.01319475f, 0.09917134f, 0.14923361f, -0.09779300f, -0.09455957f, -0.06860832f, -0.01063656f, -0.13845319f, 
    -0.28845152f, 0.16467555f, 0.07134175f, 0.02248869f, 0.05345288f, -0.11645660f, 0.10857058f, 0.03116966f, 
    -0.05694009f, -0.04000558f, -0.05861707f, -0.02785693f, 0.04866616f, 0.11224439f, 0.21170402f, 0.35653806f, 
    -0.06524197f, -0.04286717f, 0.02113331f, 0.02438733f, -0.13393225f, 0.01464458f, -0.06687025f, -0.16116156f, 
    -0.14425781f, 0.19164304f, 0.15772952f, 0.08483934f, 0.03316071f, -0.16080242f, -0.08236809f, -0.06763919f, 
    -0.04924186f, 0.02475945f, -0.03148404f, -0.07063918f, -0.09069643f, -0.02280021f, -0.21489334f, 0.07302226f, 
    -0.08388699f, 0.06454700f, -0.07690161f, 0.02085063f, -0.04937129f, -0.01869115f, -0.10640308f, -0.12135515f, 
    0.11869179f, 0.01932533f, 0.24315447f, -0.19412479f, -0.12422093f, 0.08754504f, -0.11369479f, 0.15792455f, 
    0.11732516f, -0.00095823f, 0.01617910f, 0.04361545f, 0.33170274f, 0.07602259f, -0.21536951f, -0.03928643f, 
    0.00011394f, 0.01720577f, 0.12271496f, 0.03123285f, 0.08556671f, 0.00687849f, -0.06334407f, -0.16904591f, 
    -0.06888433f, 0.03025418f, -0.00861523f, 0.06169909f, 0.03613512f, -0.00196081f, -0.02245100f, 0.03853280f, 
    0.05147411f, 0.12650038f, 0.03107747f, 0.16046722f, -0.07990945f, 0.08583909f, 0.13063571f, 0.12158085f, 
    -0.01048913f, -0.09984711f, -0.05988827f, 0.00833233f, -0.08128557f, 0.08395030f, 0.03356563f, 0.03494016f, 
    -0.04306306f, 0.00934755f, -0.10752663f, 0.07333222f, -0.04684434f, 0.14790238f, -0.01304189f, 0.08983914f, 
    0.01716855f, 0.03806825f, 0.06037070f, -0.03714085f, 0.02763739f, 0.13748312f, -0.09396233f, 0.00427921f, 
    0.05997302f, -0.04582071f, 0.06060708f, 0.06809538f, -0.05609507f, -0.06823802f, -0.02475387f, -0.05922123f, 
    -0.03065981f, -0.00862769f, 0.14589299f, 0.28195640f, -0.07623471f, 0.05346442f, 0.08652093f, 0.04256300f, 
    0.08032791f, 0.11595574f, 0.02124796f, 0.14681962f, -0.17245179f, -0.02435041f, 0.15771289f, -0.02635518f, 
    -0.01115387f, -0.09925389f, -0.02766111f, -0.08759754f, -0.12498025f, -0.08669040f, 0.08576955f, -0.07891703f, 
    0.30120227f, -0.22068125f, 0.06259364f, 0.02161126f, -0.00721101f, 0.04873078f, 0.05804003f, 0.04661549f, 
    -0.04459009f, 0.11289377f, -0.03022178f, 0.00239209f, -0.27461091f, 0.13232580f, -0.09862181f, 0.25991264f, 
    -0.01649369f, 0.02526075f, 0.12119749f, 0.04420344f, 0.02220341f, 0.04127644f, 0.00337088f, -0.08898742f, 
    -0.40347293f, 0.23589829f, -0.12560563f, 0.30153462f, 0.02538800f, -0.06625905f, 0.04703527f, -0.06797826f, 
    -0.01013524f, 0.05599520f, -0.00470146f, 0.09395098f, 0.24647911f, 0.23121035f, 0.01120578f, 0.14992587f, 
    -0.05191585f, -0.03985631f, -0.04000512f, 0.02888447f, 0.04439653f, 0.03186473f, 0.02706790f, -0.11816236f, 
    -0.56514716f, 0.05903082f, 0.24329582f, 0.18405160f, 0.15691559f, 0.15689197f, -0.17206857f, -0.08742927f, 
    0.00966948f, -0.01873025f, -0.22107279f, 0.03017477f, -0.02372125f, 0.04291035f, 0.14666954f, 0.00950682f, 
    0.00666244f, 0.03518477f, -0.10229495f, 0.07780657f, 0.09394122f, -0.02004798f, 0.04782991f, 0.03720327f, 
    0.07440105f, 0.15692508f, 0.21915530f, 0.11392358f, -0.04931152f, -0.02431673f, 0.11260781f, 0.13033800f, 
    -0.03625733f, -0.01762163f, -0.04847179f, -0.05281994f, 0.17784378f, -0.11854959f, 0.07802772f, -0.14168653f, 
    0.11099602f, 0.26663801f, -0.09761509f, 0.17819051f, -0.03641898f, 0.03048411f, -0.07729210f, -0.06672326f, 
    0.15030445f, -0.14667717f, 0.08100662f, 0.15168445f, 0.10100381f, 0.02362966f, 0.16213161f, 0.00214658f, 
    0.14428163f, -0.04248346f, 0.05225530f, 0.11271545f, 0.10167659f, -0.03552271f, -0.23530637f, -0.05963733f, 
    -0.10557230f, 0.01976804f, 0.05497825f, 0.01852991f, 0.11617228f, 0.07673048f, 0.07044864f, 0.00167656f, 
    -0.03105078f, 0.02385631f, -0.01602362f, 0.04992311f, 0.04037678f, -0.01410556f, 0.01852133f, 0.03461559f, 
    -0.00107017f, 0.01263808f, -0.02417180f, 0.02560749f, 0.00059464f, -0.03021234f, 0.01918271f, -0.05332248f, 
    -0.05774321f, -0.04069158f, 0.01313169f, -0.03427373f, -0.04316501f, 0.02435063f, 0.00049259f, -0.01796365f, 
    0.03357512f, -0.05083531f, -0.05737786f, 0.01643211f, -0.02703335f, -0.04167254f, 0.01182864f, 0.04015137f, 
    0.03317492f, 0.00557612f, -0.00418955f, 0.04041014f, 0.00105128f, -0.04067702f, -0.05080837f, -0.02835646f, 
    -0.02150896f, -0.02889899f, -0.03410956f, -0.01691579f, 0.00328888f, -0.03681335f, 0.01414446f, 0.02640689f, 
    -0.02412351f, -0.01092399f, 0.01858875f, -0.02148608f, -0.02882808f, 0.02846278f, 0.02892274f, -0.01278778f, 
    -0.04042346f, -0.00038967f, 0.02497686f, -0.03626304f, -0.05178092f, -0.02646515f, -0.00428085f, 0.00779004f, 
    -0.04480582f, 0.04325261f, -0.05851552f, -0.05428057f, -0.02793282f, 0.01566232f, 0.02522009f, -0.02333482f, 
    0.01315141f, -0.04494778f, -0.04192367f, -0.04502065f, -0.00816671f, 0.03030972f, -0.03077727f, -0.05833339f, 
    -0.01232130f, -0.02598597f, 0.00730522f, 0.03392145f, 0.00283590f, 0.00261359f, 0.04062377f, -0.03624309f, 
    0.04650204f, -0.04298263f, -0.01632466f, -0.02927757f, 0.03108151f, -0.00225325f, -0.05044825f, -0.04397461f, 
    -0.05501969f, -0.00781290f, 0.02187082f, -0.00551927f, -0.03031417f, 0.02587857f, -0.04290036f, 0.00588099f, 
    0.00992483f, -0.05318496f, 0.00720431f, 0.00134476f, -0.00166504f, 0.00500933f, -0.04204654f, -0.00584312f, 
    -0.00036629f, 0.02199285f, -0.03556200f, 0.04047182f, -0.02836652f, -0.03293309f, -0.05168446f, -0.02933824f, 
    -0.03266525f, -0.05497724f, 0.02227538f, -0.01835359f, -0.00596040f, 0.02484714f, -0.02240533f, 0.03233790f, 
    -0.00238981f, -0.02153713f, 0.03774640f, -0.03144114f, -0.05534780f, -0.03325978f, -0.04626005f, -0.04308219f, 
    -0.04654044f, 0.05060890f, 0.04882982f, 0.02268954f, -0.02094528f, 0.04398450f, 0.05548796f, 0.01120531f, 
    0.02345747f, -0.04804220f, -0.03406245f, 0.01318655f, -0.02197873f, 0.02407692f, 0.02901149f, 0.02499481f, 
    -0.02527601f, -0.02401740f, -0.05756570f, 0.03014147f, -0.03848408f, -0.05723454f, -0.02215817f, -0.02508702f, 
    -0.03086518f, -0.01456961f, -0.05977499f, -0.02962283f, -0.03514606f, 0.03609310f, 0.02777844f, 0.03919970f, 
    0.02948389f, -0.02344386f, -0.02394842f, -0.00363699f, -0.04302869f, 0.01168666f, -0.05135541f, -0.04570329f, 
    0.02974129f, -0.02313428f, -0.04427263f, -0.02899296f, 0.03989964f, -0.04606095f, -0.01676763f, 0.01382315f, 
    -0.03557773f, -0.04993459f, 0.02359952f, 0.02104524f, -0.00639678f, -0.02828339f, 0.00664457f, 0.01587536f, 
    0.00086063f, 0.00987475f, -0.04742119f, -0.03474972f, -0.00326013f, -0.00679822f, -0.03935958f, -0.04931029f, 
    0.00454422f, -0.05850231f, -0.04385633f, 0.01762373f, 0.02598621f, -0.03790253f, -0.03068149f, 0.03969636f, 
    0.00524884f, 0.03841528f, -0.00261154f, -0.02934931f, -0.00572458f, -0.03756237f, -0.02878457f, 0.00884836f, 
    -0.04796890f, -0.00158379f, -0.04775826f, -0.01902138f, 0.00553311f, -0.05555790f, -0.01355368f, 0.00728763f, 
    0.00234478f, 0.02686065f, -0.03159122f, 0.01079237f, 0.00028233f, 0.01663119f, -0.02467769f, -0.01757126f, 
    -0.03059618f, -0.04674290f, -0.05280546f, 0.01143990f, -0.00556411f, -0.01534286f, -0.00263746f, 0.02918928f, 
    -0.01467135f, 0.02968330f, 0.03362926f, -0.01569486f, 0.05461662f, -0.04790704f, 0.00978493f, 0.01508969f, 
    0.01602931f, -0.04605909f, -0.04908340f, 0.00212186f, -0.01988722f, -0.01175724f, -0.01394415f, -0.02991461f, 
    0.01873287f, 0.02635616f, 0.01083301f, -0.00963655f, -0.05731849f, -0.05830446f, 0.00522795f, 0.02622475f, 
    -0.05020060f, 0.03306895f, -0.03330321f, -0.02210595f, -0.01422705f, 0.03827691f, 0.03339475f, -0.03305275f, 
    -0.04735882f, 0.01610805f, 0.01559917f, -0.04802769f, -0.01228187f, -0.02001873f, 0.04108616f, 0.00939460f, 
    -0.04529701f, 0.02218092f, -0.01537765f, 0.02850376f, -0.04740719f, -0.03738902f, -0.02872770f, -0.00958177f, 
    0.00950739f, -0.03912054f, 0.03385144f, -0.00055738f, 0.02723165f, 0.03267702f, -0.01479934f, 0.00305775f, 
    -0.02342304f, 0.01656750f, -0.03247667f, -0.02874084f, 0.03923354f, -0.02546996f, -0.01922447f, -0.02600165f, 
    -0.05252025f, 0.02810462f, -0.00304071f, -0.05646656f, 0.03433445f, 0.00325494f, -0.00392728f, -0.03658068f, 
    -0.03474636f, -0.00343596f, 0.02040279f, 0.03731766f, -0.06087819f, 0.03076600f, -0.04417007f, -0.02478363f, 
    0.04605085f, 0.00801624f, 0.00594313f, 0.03909323f, 0.02366962f, -0.01936673f, 0.03980829f, 0.00882490f, 
    -0.02586954f, -0.05364319f, -0.03890469f, 0.00495535f, 0.02808997f, -0.05746417f, -0.01438449f, -0.00994954f, 
    -0.02508600f, 0.00368769f, -0.00496500f, -0.02779113f, -0.04427737f, -0.01580937f, -0.00553697f, -0.00576245f, 
    -0.03885064f, -0.05364885f, 0.04596919f, 0.03559829f, 0.02709351f, 0.03094581f, -0.00319714f, 0.00645319f, 
    -0.00044891f, -0.00837047f, -0.04270624f, 0.03653437f, -0.03207133f, 0.01214454f, -0.02531021f, -0.04107840f, 
    0.03276576f, 0.04550274f, -0.01172103f, -0.01194242f, 0.00433379f, 0.00486724f, 0.01078865f, -0.04998523f, 
    -0.02883265f, 0.04164644f, -0.00095812f, -0.05238448f, -0.03340788f, 0.02278154f, 0.03191185f, -0.03680858f, 
    0.00182415f, -0.03102027f, 0.04178320f, 0.00143596f, -0.02555821f, 0.03731629f, 0.00846212f, -0.02214097f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01975146f, 0.21611537f, 0.08930608f, 0.15593074f, -0.02589750f, 0.00083037f, -0.03694110f, 0.01677377f, 
    -0.06794553f, 0.03305726f, -0.01004915f, -0.05627126f, 0.05205529f, 0.01073134f, 0.07575227f, -0.04402643f, 
    0.18128529f, 0.04702036f, 0.00603163f, -0.00839351f, -0.01435012f, 0.04260176f, 0.05407999f, -0.03922770f, 
    0.06007234f, 0.04459133f, 0.11220630f, -0.06323493f, 0.06120002f, -0.02781711f, -0.04414865f, 0.00816857f, 
    0.03424497f, -0.04197120f, 0.00120359f, 0.21452965f, -0.01084153f, 0.01212457f, -0.02447219f, 0.01252673f, 
    0.07769052f, 0.00790922f, 0.00346124f, 0.01288048f, 0.27294087f, 0.05925461f, 0.06396478f, -0.00287731f, 
    0.20458500f, -0.02633307f, 0.02232243f, 0.06976690f, 0.02199669f, 0.03199591f, 0.08021205f, -0.03429113f, 
    -0.04517470f, 0.07134987f, 0.02513606f, 0.02336181f, 0.01788933f, -0.04919757f, 0.03992640f, -0.02978390f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.14897741f, -0.29172522f, -0.10199945f, -0.09148043f, -0.11975313f, 0.05952461f, 0.14794829f, -0.12001242f, 
    -0.23974933f, 0.14142515f, -0.04452288f, 0.01714206f, -0.00395727f, -0.04889220f, 0.18876190f, -0.02670483f, 
    0.08051750f, -0.45027253f, -0.38775975f, 0.05615831f, -0.10158093f, -0.08167472f, -0.28315544f, 0.05068301f, 
    -0.18859920f, 0.19327228f, 0.00694764f, 0.31853932f, 0.07729513f, 0.19843841f, 0.23894279f, -0.23619190f, 
    -0.09942282f, 0.05212754f, -0.08089378f, -0.36756030f, 0.05577849f, -0.01288228f, -0.55706328f, -0.10997313f, 
    0.01084582f, -0.21126367f, 0.02290507f, -0.05015457f, -0.49506164f, -0.23243284f, 0.17716686f, -0.00779582f, 
    -0.49926075f, -0.13486712f, 0.05684628f, -0.00272363f, 0.18738849f, 0.01050174f, 0.14016110f, -0.03612781f, 
    0.14622305f, -0.17993100f, 0.09612068f, -0.09525603f, 0.12624702f, -0.07482068f, -0.31158748f, -0.03305493f, 
    0.01110285f, 0.37709904f, 0.08298734f, 0.05439014f, -0.07513014f, 0.08682782f, -0.47177243f, 0.08002291f, 
    -0.26201388f, 0.20083013f, -0.05286085f, 0.06252918f, 0.13648377f, -0.04903758f, 0.25079814f, -0.04066787f, 
    0.33225068f, 0.03359968f, -0.11808375f, 0.08256497f, 0.04371813f, 0.00986041f, 0.21043733f, -0.24240996f, 
    0.10612015f, 0.16497965f, -0.11765162f, 0.19542813f, 0.12758468f, 0.18071555f, -0.65588135f, -0.25668719f, 
    -0.11191086f, -0.04874843f, -0.09966590f, -0.04824008f, -0.26334846f, 0.26927409f, -0.19842581f, -0.03352526f, 
    0.11412874f, -0.12901957f, 0.00854302f, -0.03867066f, 0.05537576f, -0.18249868f, 0.01216038f, 0.05400635f, 
    0.10583127f, 0.27016380f, 0.07539132f, 0.17452604f, -0.40309545f, 0.08781824f, 0.07280750f, 0.09001494f, 
    -0.04782235f, 0.13866755f, -0.00028717f, -0.01773650f, 0.16215546f, 0.07204402f, -0.08705541f, -0.02732761f, 
    0.04481945f, -0.60762107f, -0.09399394f, 0.10572380f, -0.02970104f, -0.04006165f, 0.17218271f, -0.06532378f, 
    -0.13974395f, -0.51709884f, -0.08193135f, -0.09230610f, 0.18874101f, 0.09959023f, 0.33310574f, 0.04746454f, 
    -0.15618496f, 0.25342345f, 0.08250211f, 0.07461840f, 0.04170392f, 0.00698358f, -0.22454691f, -0.19046359f, 
    -0.25462407f, -0.40302640f, 0.21272981f, -0.28293958f, 0.23367494f, -0.61047930f, -0.14806272f, 0.06761216f, 
    -0.07862572f, 0.11069646f, 0.05984868f, 0.17909512f, -0.02273101f, -0.37204915f, -0.20909783f, 0.01103396f, 
    0.18698329f, -0.11690600f, -0.08014765f, 0.06284361f, 0.04990024f, -0.02121229f, 0.04334773f, 0.05218648f, 
    0.33106869f, 0.06464120f, 0.10277896f, 0.20439644f, -0.17696087f, -0.02145946f, -0.24233328f, -0.05399264f, 
    0.35364452f, 0.13824481f, 0.21580663f, 0.10885229f, 0.00596132f, -0.11334591f, -0.23445244f, 0.03334861f, 
    0.22688709f, -0.05349490f, -0.02647855f, 0.00059925f, -0.08788522f, -0.01011834f, 0.29245776f, 0.07526606f, 
    0.28289250f, -0.04582613f, 0.04293299f, 0.04876178f, -0.45312455f, -0.07741897f, -0.08714628f, -0.06124067f, 
    -0.41696805f, 0.23027891f, 0.46570206f, -0.00759901f, -0.09045368f, 0.01977988f, 0.07329465f, 0.06817456f, 
    -0.46923932f, -0.43438575f, 0.09638979f, -0.07772201f, -0.15072799f, 0.00198247f, -0.16017205f, 0.02652611f, 
    -0.09210287f, 0.02061421f, -0.02592537f, -0.42556271f, 0.03067453f, -0.31623656f, 0.24406472f, 0.05846532f, 
    -0.29441929f, 0.31848451f, 0.00553041f, 0.00065087f, -0.18361944f, -0.09237745f, 0.09185410f, 0.01795361f, 
    -0.25867316f, -0.07897790f, -0.17004117f, 0.18906896f, -0.03971581f, 0.06623809f, 0.01099168f, -0.03174824f, 
    0.25885424f, 0.03933136f, 0.09245019f, 0.00108388f, 0.06307156f, -0.00561602f, -0.02467093f, 0.05604725f, 
    -0.08584209f, 0.22256719f, -0.50777954f, -0.67568356f, 0.07755750f, -0.01812620f, 0.20882879f, 0.19986185f, 
    -0.00531015f, -0.06543868f, 0.00508219f, -0.04680869f, 0.14158957f, 0.10186139f, 0.00361348f, -0.06786805f, 
    0.12558816f, -0.10229588f, -0.18166228f, 0.06063293f, -0.11489586f, 0.05103441f, -0.62967408f, 0.23453239f, 
    0.24484515f, -0.24674004f, -0.28547895f, -0.03388926f, 0.04007277f, -0.06620477f, 0.10501598f, 0.13323666f, 
    -0.08970881f, -0.01058305f, 0.10418136f, 0.04900545f, 0.12228337f, 0.01473103f, 0.08625292f, 0.03810717f, 
    0.11420567f, 0.00151900f, 0.02121136f, -0.04073171f, -0.02801579f, -0.07702179f, -0.40014657f, 0.00580776f, 
    -0.14411014f, 0.31862989f, -0.06794421f, -0.14392392f, 0.27156773f, -0.00361235f, -0.16045009f, -0.06789453f, 
    0.04745984f, -0.06503692f, -0.02201722f, -0.00402345f, -0.12110376f, -0.11043214f, 0.25149584f, -0.11462592f, 
    0.00665913f, -0.29259089f, 0.05324777f, -0.36234450f, -0.02838176f, -0.05081305f, -0.42447117f, -0.18451963f, 
    -0.23317471f, 0.24584156f, -0.04725692f, -0.00811588f, -0.22655180f, 0.01459428f, 0.08880764f, 0.02737229f, 
    -0.09211516f, 0.10389792f, -0.42719838f, -0.11268970f, 0.03550469f, -0.06928971f, 0.14339378f, 0.06502004f, 
    0.04027929f, 0.24662183f, 0.19399375f, -0.10094450f, -0.14168656f, 0.07743713f, 0.31215501f, 0.12857719f, 
    -0.02532159f, 0.04317437f, -0.09678148f, 0.07208878f, 0.03788399f, -0.11876129f, -0.15315533f, 0.05543195f, 
    -0.13624680f, 0.21285188f, 0.04850848f, -0.00378216f, -0.03101965f, -0.01875501f, -0.05864877f, -0.02757275f, 
    0.15275864f, -0.17950504f, 0.03223869f, -0.14078768f, 0.33331946f, -0.06096026f, 0.28526464f, 0.10455620f, 
    -0.36106580f, 0.24349949f, -0.21703507f, -0.09709248f, 0.20660935f, -0.05531140f, 0.00102923f, -0.00232484f, 
    -0.41169870f, -0.02831294f, -0.27119145f, 0.29397702f, 0.01974215f, 0.01723074f, -0.33764198f, -0.25243706f, 
    0.17723933f, -0.17986612f, -0.02552310f, -0.11683367f, 0.15974580f, -0.05479287f, -0.18758285f, -0.11145657f, 
    -0.22637403f, -0.55571181f, 0.05415866f, -0.36817068f, -0.03129704f, -0.06292748f, -0.14098147f, -0.50726402f, 
    -0.08951195f, 0.08719634f, 0.20952927f, -0.46815631f, -0.38163388f, -0.72583574f, -0.22998910f, 0.09261099f, 
    -0.07677073f, 0.05127402f, 0.11303817f, 0.19419114f, 0.17994729f, -0.50955725f, 0.32086447f, 0.10191087f, 
    0.28620470f, -0.34261778f, 0.06816383f, 0.05773291f, 0.23633566f, 0.12658726f, 0.16970818f, 0.02249317f, 
    0.23714727f, -0.48690861f, -0.07354491f, -0.26562697f, 0.15411328f, -0.11289573f, -0.11290019f, 0.07815307f, 
    -0.26114994f, -0.36570403f, 0.22055745f, -0.12115341f, -0.19166370f, -0.00266593f, 0.04476155f, -0.10411398f, 
    -0.35836154f, -0.09166708f, -0.05210645f, -0.18297139f, -0.05620031f, 0.05659692f, 0.43317050f, 0.17895812f, 
    -0.01214444f, -0.06427947f, 0.02097266f, 0.07413003f, 0.15263979f, -0.05869328f, -0.50830448f, -0.04868381f, 
    -0.11658976f, 0.29909152f, 0.31606215f, -0.24967568f, 0.00754716f, -0.08603851f, -0.00200344f, -0.10786951f, 
    0.18213943f, -0.16566120f, 0.11654267f, -0.30039939f, -0.61257738f, -0.26806778f, 0.37640050f, 0.03950803f, 
    -0.07716990f, -0.07553769f, -0.11967933f, -0.06793394f, -0.08668362f, 0.07092855f, 0.13039115f, -0.07726191f, 
    -0.33037269f, 0.03778574f, -0.05814296f, -0.00566922f, -0.03151323f, 0.14147164f, -0.12690040f, -0.11402754f, 
    0.06647802f, -0.52694333f, 0.14400321f, -0.30530715f, 0.14106861f, -0.08436613f, -0.32710633f, -0.07969988f, 
    0.45502394f, -0.14290868f, -0.44359297f, -0.07871405f, 0.05819653f, -0.11755016f, -0.35284933f, 0.09537849f, 
    -0.03450244f, 0.15492626f, 0.29367310f, -0.14602946f, 0.11018093f, 0.08720177f, -0.08693188f, -0.04732473f, 
    0.15022333f, -0.02882249f, -0.11838847f, 0.10450006f, -0.28377593f, 0.05482502f, -0.39832497f, 0.05429387f, 
    -0.19185553f, 0.19558796f, 0.32479128f, 0.19949986f, 0.02278055f, 0.01578240f, -0.28028861f, -0.49845499f, 
    -0.07206060f, -0.06068869f, -0.00940454f, -0.30067170f, -0.09703755f, -0.45296863f, -0.12971267f, -0.23584644f, 
    -0.09162012f, -0.03005207f, 0.05928370f, -0.04164726f, -0.01009917f, 0.18739101f, 0.09416617f, -0.01236946f, 
    -0.29514793f, 0.22800067f, -0.00924016f, -0.04127594f, 0.08774069f, 0.27669358f, 0.24968891f, 0.01854179f, 
    0.15167856f, -0.29470915f, -0.14390497f, 0.41772351f, -0.15804173f, -0.05967674f, 0.10649358f, -0.10331097f, 
    -0.39274013f, 0.12123656f, -0.58691239f, -0.00625850f, -0.26208544f, -0.12954891f, -0.43589249f, 0.02550374f, 
    0.02091987f, 0.00972711f, -0.00922692f, 0.16822131f, -0.02945342f, -0.07632847f, 0.26028323f, 0.37925830f, 
    0.00664805f, -0.18320443f, 0.00705893f, -0.10917752f, 0.30220774f, -0.08413818f, -0.41629669f, 0.03686198f, 
    -0.07558808f, -0.34755453f, -0.31620026f, -0.31029376f, 0.02925812f, 0.08329175f, 0.32763502f, 0.32819906f, 
    -0.33626008f, 0.19342071f, 0.07374801f, -0.36619025f, 0.07285183f, 0.18550736f, 0.29676685f, -0.12543285f, 
    0.06131352f, 0.10460864f, -0.09042522f, -0.00120235f, -0.26717985f, -0.08608349f, -0.20899424f, -0.07887387f, 
    0.23465846f, -0.32148212f, 0.11150131f, -0.09685550f, 0.12051744f, 0.13759413f, -0.22369687f, -0.10954877f, 
    -0.03117149f, 0.21689539f, -0.36770517f, -0.51063967f, 0.03988788f, -0.05027958f, -0.48778766f, -0.07963887f, 
    -0.11591368f, 0.37395921f, 0.12762132f, -0.00264810f, 0.18590726f, -0.11433373f, -0.21753831f, -0.11105228f, 
    0.01104906f, -0.18072063f, 0.26294133f, -0.17000231f, -0.06835361f, -0.04968019f, -0.39880437f, -0.25327602f, 
    -0.25260040f, 0.26371762f, 0.02876413f, -0.06611381f, 0.19305921f, 0.00081160f, -0.11549313f, -0.07242431f, 
    0.09018742f, 0.32207745f, 0.43821967f, 0.11016457f, 0.04615236f, 0.03630453f, -0.30474734f, -0.27286443f, 
    -0.24499600f, 0.12103692f, -0.12811308f, -0.51796401f, 0.10363215f, -0.42306283f, -0.35044870f, 0.28695765f, 
    -0.10785825f, -0.08622681f, -0.05411014f, -0.09161831f, -0.29490292f, 0.27595353f, 0.12831685f, 0.09155517f, 
    0.18722822f, 0.14215764f, 0.10100216f, 0.09292784f, 0.11851960f, -0.17461129f, -0.37374887f, 0.10350622f, 
    -0.32397810f, -0.30907804f, -0.01933031f, 0.18147720f, 0.12020558f, 0.02396470f, -0.12547849f, -0.06819501f, 
    -0.37504262f, -0.39284179f, 0.11659540f, 0.02721357f, -0.46635759f, -0.04605316f, 0.27335036f, -0.04837703f, 
    -0.10130246f, -0.34888905f, -0.01647413f, 0.24396683f, 0.01683112f, 0.07613894f, -0.10153304f, -0.22620530f, 
    0.24559872f, -0.34450695f, 0.05471475f, -0.07229531f, -0.45750445f, -0.05696041f, -0.05025762f, -0.05059991f, 
    -0.15603246f, 0.22340129f, -0.13177530f, 0.31795746f, 0.00806814f, 0.01156530f, 0.08660792f, 0.07833168f, 
    0.24272272f, 0.17667255f, 0.07893153f, 0.32887876f, -0.03595243f, -0.19059354f, -0.38138479f, -0.22859950f, 
    -0.07873870f, 0.10163507f, 0.00436488f, 0.28210890f, 0.28367195f, 0.06164486f, 0.14854109f, -0.00303079f, 
    -0.33755019f, 0.09243415f, -0.04938140f, 0.04742270f, 0.06223323f, 0.07912873f, 0.05021044f, 0.05419146f, 
    -0.19265339f, -0.21238044f, -0.46902609f, -0.17263344f, -0.51927513f, 0.10468701f, -0.16208214f, -0.02242268f, 
    -0.27906755f, -0.51337337f, 0.20297037f, 0.09785719f, -0.14651644f, 0.08030892f, 0.49880365f, -0.04696571f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.27599722f, -0.07543973f, 0.16255786f, -0.06403687f, 0.02935785f, 0.04892401f, -0.02582273f, -0.08423775f, 
    0.06341523f, -0.04922072f, -0.07979000f, 0.00421201f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
