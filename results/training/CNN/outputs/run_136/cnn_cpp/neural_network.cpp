#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.08099200f, 0.34031525f, 0.01615277f, -0.42682576f, -0.04733063f, -0.46747100f, 0.26327401f, -0.28799677f, 
    -0.11877007f, -0.63550293f, 0.27898592f, -0.11493580f, -0.20395820f, 0.19916850f, 0.35751495f, 0.22210489f, 
    0.32039607f, -0.21828416f, -0.06162063f, 0.17609414f, 0.44074386f, 0.24384458f, 0.16357744f, -0.22658771f, 
    -0.38262522f, -0.11483434f, -0.09565441f, -0.57998222f, -0.49132034f, -0.48778135f, -0.14602862f, -0.58018339f, 
    -0.69957268f, -0.54193807f, -0.47709405f, 0.06121369f, -0.28402638f, 0.38915598f, -0.07875328f, -0.28512782f, 
    -0.06377622f, 0.04731798f, -0.14082469f, -0.23641782f, -0.16701974f, -0.07856079f, 0.11179145f, 0.45489103f, 
    0.01480061f, 0.17032745f, -0.22226827f, -0.98899513f, -0.78622633f, -0.05831931f, -0.24445291f, -0.09526461f, 
    0.78980231f, 0.12006690f, 0.34316915f, -0.06225552f, -0.31334519f, 0.07618821f, -0.22122639f, 0.05217557f, 
    -0.16592576f, 0.10075173f, -0.09334821f, -0.15595350f, -0.27992579f, -0.27017510f, 0.17293203f, 0.35003725f, 
    0.25860173f, 0.05049851f, 0.15482405f, 0.98305708f, -0.67458344f, -0.00953150f, 0.08323070f, -0.09046682f, 
    0.21357352f, 0.05515763f, -0.10700115f, -0.11181002f, -0.21693321f, -0.05365305f, -0.16743088f, -0.04194308f, 
    0.23303144f, 0.23489945f, 0.38550219f, 0.21009795f, 0.27637094f, 0.30670258f, 0.06543528f, 0.23845293f, 
    -0.20101489f, 0.23162045f, 0.20897064f, 0.36726445f, 0.18207011f, -0.62614167f, 0.55804187f, 0.85275972f, 
    0.14585637f, 0.28954387f, 0.34357271f, 0.61577082f, 0.19644006f, -0.10394726f, -0.45733654f, -0.56627077f, 
    -0.30730182f, 0.11321460f, -0.20725654f, -0.10304895f, -0.03494258f, 0.03269906f, 0.15845935f, 0.07064420f, 
    -0.18896811f, 0.26678917f, 0.00321285f, 0.05943455f, -0.34873933f, -0.22679837f, 0.96601284f, 0.92350584f, 
    -0.01538132f, -0.09505376f, -0.53902465f, 0.94863588f, -0.03378775f, -0.32348260f, 0.14439861f, -0.09264802f, 
    0.37431702f, -0.11510361f, 0.04656493f, 0.04975983f, -0.05940234f, -0.26055083f, -0.05572244f, -0.08383993f, 
    -0.28299662f, 0.04654279f, 0.13537996f, 0.11401340f, 0.16581774f, 0.07898431f, -0.32823977f, -0.68055570f, 
    -0.85785890f, -0.64605135f, -0.52312708f, 0.34277567f, 0.82040793f, 0.37564391f, 0.15681952f, 0.50434738f, 
    0.00181142f, 0.22843568f, 0.12815212f, 0.08640066f, 0.17634813f, -0.24959047f, 0.13450381f, 0.20044850f, 
    0.29797819f, -0.01914778f, -0.25086623f, -0.09077983f, -0.31687820f, -0.02775354f, -0.01593622f, 0.08378121f, 
    -0.41814861f, 0.48470196f, 0.93666196f, 0.61019224f, -0.64484024f, -0.48287922f, -0.29409218f, 0.19879040f, 
    0.21525171f, 0.33560243f, 0.03283454f, 0.05730082f, 0.06065213f, -0.21060686f, -0.26565215f, 0.22400604f, 
    0.05968555f, 0.33566836f, 0.20253524f, -0.16890854f, 0.17233966f, 0.13639776f, -0.00165437f, -0.09468383f, 
    0.75317615f, -0.08945950f, -0.50613123f, -0.75188625f, -0.27657607f, 0.51770175f, -0.49784160f, 0.34552890f, 
    0.06381222f, -0.20398317f, -0.50876957f, 0.04016568f, -0.29126400f, -0.13103506f, -0.01075564f, -0.25359944f, 
    0.00010332f, -0.15890975f, -0.14023934f, -0.25751853f, -0.00196779f, -0.08978027f, -0.09914986f, -0.06378820f, 
    -0.11944531f, -0.73745829f, -0.26235372f, 0.51357400f, -0.28902125f, -0.63635302f, 0.34946653f, 0.62349343f, 
    -0.59252077f, -0.21668567f, -0.40837315f, -0.12849665f, 0.42738655f, -0.28991982f, 0.34450978f, 0.44822532f, 
    -0.33785275f, -0.00929681f, -0.03422109f, -0.07758332f, -0.09461451f, 0.17854577f, -0.03297976f, 0.06119725f, 
    0.10811838f, 0.05057092f, 0.71826559f, 0.91015828f, 0.66258562f, 0.00059381f, -0.10410388f, -0.13108116f, 
    -0.44841021f, -0.53479189f, -0.04711582f, -0.05076853f, 0.16720523f, 0.15316471f, 0.07588561f, 0.14186706f, 
    -0.12934639f, 0.05893792f, 0.07384051f, 0.27459973f, 0.11027190f, -0.06305362f, -0.19287880f, -0.13465430f, 
    -0.05895398f, -0.03251952f, -0.07388514f, 0.48966384f, 0.75561994f, 0.48628664f, 0.29473454f, -0.59788668f, 
    -0.73103529f, -0.80554920f, 0.01210644f, -0.50038755f, -0.05990949f, 0.20032492f, 0.05440329f, -0.20743001f, 
    0.04904198f, 0.36456951f, -0.05044826f, -0.20569950f, -0.13036139f, 0.01863701f, 0.11730950f, 0.24037878f, 
    0.34144321f, 0.00982711f, 0.06649681f, 0.11966871f, 0.43987241f, 0.05327666f, -0.60271394f, -0.83999085f, 
    0.03270363f, -0.13294430f, 0.06962712f, 0.44564459f, 0.25060630f, 0.39760071f, -0.43179071f, 0.08178525f, 
    -0.21751775f, -0.05888059f, 0.08763461f, 0.32142597f, -0.01850971f, 0.23672006f, 0.23002146f, 0.33865395f, 
    -0.18689129f, 0.27264306f, -0.18331274f, 0.11170581f, -0.13194498f, 0.94514072f, 0.63282591f, 0.50625902f, 
    0.76836127f, 0.68422472f, 0.13633789f, -0.10349483f, 0.03338753f, -0.22819325f, 0.23659188f, -0.17968532f, 
    -0.01340815f, 0.08025777f, -0.14363298f, -0.33007947f, -0.08197743f, -0.03650175f, 0.29980427f, -0.08838218f, 
    -0.33096731f, 0.25035003f, 0.22962148f, 0.14501329f, -0.05412454f, 0.27540499f, 0.51570684f, 0.41716421f, 
    0.55739975f, 0.39537176f, 0.41016713f, 0.92296112f, -0.20542274f, -0.02118686f, 0.29608747f, -0.21183012f, 
    0.50232762f, 0.39544672f, 0.09456426f, 0.31717613f, -0.22100776f, 0.10399999f, 0.13672076f, 0.21108384f, 
    -0.11130181f, -0.04047264f, -0.13010421f, -0.03206328f, 0.08310115f, -0.08067016f, 0.11190663f, -0.98298866f, 
    -0.04777074f, 0.48190776f, -0.01593680f, 0.07187015f, -1.04192889f, -0.10907561f, 0.27182621f, 0.13309640f, 
    -0.31545961f, -0.22664317f, 0.26486436f, 0.22979692f, 0.13132989f, 0.02467621f, 0.08646005f, -0.35698700f, 
    -0.10919128f, -0.22021353f, -0.33278483f, -0.11743772f, -0.09041759f, -0.03687219f, 0.05868089f, 0.27523601f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09550042f, 0.25830898f, 0.09806135f, 0.01979117f, -0.05245809f, 0.20945762f, 0.25195387f, 0.08772098f, 
    0.00188173f, 0.23863189f, 0.09302723f, 0.11469211f, -0.02116171f, 0.23227710f, 0.01495522f, 0.41990927f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07654990f, 0.03746691f, -0.01943638f, -0.03544011f, -0.05496455f, 0.02896194f, 0.00995032f, 0.03233335f, 
    -0.05913671f, -0.01630665f, -0.04562628f, -0.01952662f, -0.01049536f, -0.02539708f, -0.04760038f, 0.05265767f, 
    -0.07678470f, -0.07108564f, -0.02976172f, 0.04510662f, 0.01543290f, 0.01181008f, 0.01036643f, 0.06374399f, 
    0.06154995f, -0.01188435f, 0.00048260f, 0.00482662f, 0.02758991f, 0.04953547f, -0.05583250f, -0.04387052f, 
    -0.06291113f, -0.01031637f, -0.02456246f, 0.04154685f, 0.06309035f, -0.04914771f, 0.00238558f, -0.03909792f, 
    -0.05042319f, -0.02253682f, -0.04400893f, 0.03682953f, -0.02220051f, -0.01125449f, -0.03006947f, -0.04479654f, 
    0.06172621f, 0.05193887f, 0.05774156f, -0.02497947f, -0.03748205f, -0.01219035f, -0.02528124f, -0.00225852f, 
    -0.03199007f, 0.00594492f, 0.00556553f, 0.04561718f, -0.05841693f, -0.00079198f, -0.03881933f, -0.02337354f, 
    -0.05649155f, 0.02246218f, 0.03824366f, -0.01664574f, 0.05273118f, -0.03077904f, -0.05605895f, 0.03684361f, 
    -0.06398559f, 0.02425406f, -0.07097910f, 0.00394577f, -0.03092960f, 0.02625958f, -0.00647182f, 0.00377182f, 
    -0.03630147f, -0.07148966f, -0.01898697f, 0.01954793f, 0.05334795f, -0.03863373f, 0.06079080f, 0.04665877f, 
    -0.04544331f, -0.05854511f, 0.04392156f, -0.01713548f, -0.04100635f, -0.06794596f, 0.00101175f, 0.02834080f, 
    0.05085783f, -0.07662797f, -0.01223928f, 0.01923506f, 0.00812246f, -0.01914882f, 0.01613819f, 0.05016676f, 
    0.00551793f, 0.05363791f, 0.02732977f, -0.06116364f, 0.00499629f, 0.03252003f, 0.01712972f, -0.04780659f, 
    -0.07215375f, -0.07346036f, 0.04195056f, 0.05098902f, 0.05032203f, -0.00841777f, 0.03163399f, -0.04469793f, 
    -0.03435688f, -0.04772530f, -0.06863873f, -0.07124743f, -0.00955640f, -0.04422084f, 0.01773341f, 0.05325418f, 
    0.06332585f, -0.05081100f, 0.02037884f, -0.02661633f, -0.06092231f, -0.05935135f, 0.03362409f, 0.03706153f, 
    0.02305955f, -0.06205165f, -0.06328198f, -0.00669230f, -0.06419329f, -0.02593364f, -0.06138518f, 0.06167825f, 
    0.03741606f, -0.01900038f, 0.00471857f, -0.04109158f, 0.01904395f, -0.00025668f, 0.06032657f, 0.01571466f, 
    -0.04778610f, 0.06143672f, 0.04438350f, -0.06273476f, -0.05878912f, -0.02140371f, 0.06191462f, 0.00384188f, 
    -0.05178617f, 0.04443604f, -0.03015235f, 0.02333811f, -0.03040148f, -0.02768845f, -0.07567281f, 0.00924270f, 
    -0.01072678f, 0.03051235f, 0.01090833f, 0.02783342f, -0.07141841f, -0.06731088f, -0.05587299f, -0.02956956f, 
    0.06501611f, -0.01574265f, 0.02394496f, 0.02349851f, -0.03092843f, -0.00616605f, -0.03919569f, -0.04995731f, 
    -0.02418418f, 0.05443930f, -0.04191500f, -0.02367905f, 0.03291747f, 0.03461546f, -0.07438013f, -0.01602650f, 
    -0.01449100f, -0.07144543f, 0.01375643f, 0.06156593f, 0.02212973f, -0.12585749f, -0.12076475f, -0.05371648f, 
    0.00054066f, -0.19042256f, -0.00837511f, -0.08643160f, -0.00607791f, -0.13254888f, -0.00894259f, 0.01357722f, 
    0.12020477f, -0.00614536f, 0.18461154f, -0.04358719f, -0.07028539f, 0.11012828f, 0.15438625f, 0.09798861f, 
    -0.14434023f, -0.01347016f, 0.15137100f, -0.11689159f, 0.18520845f, -0.11047976f, 0.02033958f, -0.12985662f, 
    -0.01359211f, -0.03754463f, 0.19342338f, 0.01797837f, 0.19603464f, 0.22955936f, 0.12758636f, -0.19311006f, 
    0.08259695f, -0.03224703f, 0.09912094f, -0.07334369f, 0.04404086f, -0.10601749f, -0.19422124f, -0.07431859f, 
    0.16138038f, -0.04113254f, -0.03404984f, -0.03802674f, 0.10857800f, 0.13494213f, 0.05780626f, 0.07893565f, 
    0.08967720f, 0.00448308f, -0.09219210f, 0.10887925f, 0.07970121f, 0.22056387f, 0.09396047f, 0.11449502f, 
    0.04491564f, -0.00886180f, 0.11745193f, 0.07915647f, -0.03289170f, 0.02754576f, 0.11620026f, -0.02738104f, 
    -0.06971513f, 0.12927173f, 0.09238186f, 0.15014452f, 0.05401133f, 0.04636163f, 0.13541988f, 0.00795966f, 
    0.09803785f, 0.04819752f, -0.07939447f, 0.01209553f, 0.05245524f, -0.13131173f, -0.03663489f, 0.00729158f, 
    0.08168217f, -0.02250707f, 0.05742671f, -0.02861775f, 0.08760976f, -0.04519342f, -0.13426310f, -0.03013020f, 
    0.11855029f, -0.04260070f, -0.24308828f, -0.10514028f, 0.06965715f, 0.12605809f, 0.18627951f, -0.23445362f, 
    -0.03197528f, -0.01640369f, 0.17028181f, 0.11997275f, 0.01326104f, -0.16848983f, -0.10907470f, -0.06609889f, 
    0.02555189f, 0.01359676f, 0.03652598f, -0.14068727f, -0.06225929f, 0.11366900f, -0.15898639f, 0.03313477f, 
    0.16098092f, 0.18175796f, 0.08399256f, 0.00128175f, -0.06785227f, -0.12739432f, 0.00438136f, -0.00609141f, 
    0.18659057f, 0.02519893f, 0.00272151f, 0.04886145f, 0.03842966f, -0.16339257f, -0.00916748f, 0.11789838f, 
    -0.02783175f, -0.09535991f, 0.02771880f, -0.05953933f, 0.18349095f, 0.07184501f, 0.06234234f, -0.03206730f, 
    0.06255788f, 0.07931098f, -0.08969717f, 0.08971751f, 0.10262473f, -0.04751831f, -0.10086486f, 0.16866435f, 
    0.03612975f, -0.01162262f, 0.10823390f, 0.02393461f, 0.34608072f, 0.29564652f, 0.08480187f, 0.07608987f, 
    -0.04850298f, -0.05935794f, 0.05298862f, -0.01749538f, -0.00381112f, 0.11793240f, -0.05224713f, -0.01593490f, 
    0.19994766f, 0.13617702f, -0.02367416f, -0.04856432f, -0.08161167f, -0.05424048f, -0.04220909f, 0.05354118f, 
    0.06718158f, -0.07627109f, -0.01104805f, -0.08215787f, -0.48011112f, -0.07427497f, 0.11090244f, -0.12845495f, 
    -0.15105084f, -0.00164597f, -0.11354655f, -0.14077954f, 0.00053429f, 0.03456096f, 0.02237365f, -0.09009148f, 
    0.01842109f, 0.08751725f, 0.01363227f, 0.16964467f, 0.04035243f, 0.10774930f, 0.01164883f, 0.03233753f, 
    0.02971115f, -0.04355004f, 0.00091480f, 0.01682203f, 0.23702322f, -0.09042857f, 0.01318576f, 0.14458898f, 
    -0.13425277f, -0.03338468f, -0.22484399f, 0.01806976f, 0.21561213f, 0.08188470f, -0.00121791f, 0.05839771f, 
    0.24102153f, -0.01811218f, -0.05593271f, 0.06082503f, -0.05622017f, -0.07028203f, 0.13738984f, -0.10769265f, 
    0.01268061f, 0.04998593f, 0.15366380f, 0.00404726f, -0.14448617f, -0.11849231f, 0.07238543f, 0.03688550f, 
    -0.00629309f, -0.08294548f, -0.03127554f, 0.08824367f, -0.03496821f, 0.03047342f, -0.11925250f, 0.10552375f, 
    -0.49618319f, -0.18815546f, 0.06147462f, -0.25379238f, -0.00145347f, -0.08409113f, -0.00255350f, -0.03010278f, 
    -0.03282446f, -0.03181680f, -0.04365886f, -0.15088102f, 0.19353719f, 0.17750312f, -0.17121802f, -0.02939714f, 
    -0.10148720f, -0.01777064f, -0.00344871f, 0.06560922f, -0.06186629f, 0.03207356f, 0.04079721f, 0.05954086f, 
    0.11081143f, 0.01839943f, -0.10886667f, -0.08379144f, -0.04694395f, -0.01109645f, 0.08224110f, -0.00421541f, 
    0.04522140f, -0.09430318f, 0.03261708f, -0.11516931f, 0.07108056f, 0.20998196f, -0.10697840f, 0.05042323f, 
    0.21205823f, 0.08102015f, 0.10050157f, -0.00272084f, -0.11011171f, -0.05131514f, 0.18468623f, 0.10254817f, 
    0.02788539f, -0.11455036f, -0.02632153f, 0.19350888f, 0.10356635f, -0.16951007f, 0.02523630f, 0.00727168f, 
    -0.05563965f, 0.03456340f, 0.12007315f, -0.01972084f, 0.20603304f, 0.21687900f, 0.10412831f, 0.24130997f, 
    0.02217525f, 0.13985692f, -0.01519928f, 0.14240099f, 0.08438932f, 0.00493294f, 0.07108942f, -0.09320709f, 
    0.16989397f, 0.07368912f, -0.38043544f, 0.22805563f, 0.02704654f, -0.02801756f, 0.11763313f, -0.12575746f, 
    -0.00051202f, 0.04696795f, 0.01876679f, 0.07676647f, 0.35595214f, 0.15596065f, -0.08456092f, 0.12420462f, 
    -0.03447048f, 0.00227841f, -0.00282377f, 0.10457890f, -0.06504211f, -0.08948388f, -0.01791291f, -0.05408077f, 
    0.00034286f, 0.07230765f, 0.13911057f, 0.03649085f, -0.07756535f, -0.05470496f, 0.09178957f, -0.14090835f, 
    0.00454834f, 0.01820477f, -0.07553698f, -0.08973297f, -0.01520348f, -0.04870502f, -0.08223143f, -0.04235654f, 
    0.18603373f, -0.02340960f, -0.00966828f, -0.14939721f, -0.04134326f, 0.04266367f, -0.08904573f, 0.05164950f, 
    -0.05372722f, -0.27882966f, -0.01147964f, 0.08065738f, 0.05037253f, 0.05835162f, 0.10726563f, -0.08847865f, 
    -0.03915190f, 0.03969458f, -0.09937282f, 0.09656133f, 0.13320148f, 0.36546722f, -0.02013523f, 0.09385957f, 
    0.00147305f, -0.15525955f, 0.01533980f, -0.02798156f, 0.03032140f, 0.14978528f, -0.00909234f, 0.04976286f, 
    -0.06455884f, -0.01081965f, -0.00951535f, 0.03967297f, -0.01278313f, 0.01735443f, -0.01141788f, -0.04609086f, 
    -0.03481431f, -0.07518806f, 0.00329401f, 0.03297796f, 0.06787909f, -0.04482261f, -0.00857574f, 0.01597808f, 
    -0.05959785f, 0.04222253f, -0.02287158f, -0.01883562f, -0.02341527f, -0.02792605f, -0.06304387f, 0.03788161f, 
    -0.04931158f, -0.02998188f, -0.08520845f, -0.04924520f, -0.05905437f, -0.03712340f, -0.05823123f, -0.03984701f, 
    -0.04920394f, -0.02763055f, -0.01035235f, -0.03956174f, -0.04572813f, 0.01636097f, -0.02105303f, -0.01576122f, 
    -0.05176844f, -0.05810588f, 0.03220383f, -0.01854542f, 0.01891157f, -0.07692993f, -0.01011239f, -0.01783583f, 
    0.00223614f, -0.03917047f, -0.01947151f, 0.05326010f, -0.03090768f, -0.07115906f, -0.02411977f, -0.03361750f, 
    -0.06216408f, -0.04989194f, -0.04169414f, -0.00263278f, -0.03331596f, 0.02731893f, -0.08180267f, -0.01051426f, 
    -0.08335879f, -0.07764589f, -0.05899223f, 0.02621316f, -0.00951079f, -0.02145379f, -0.02305201f, 0.01049897f, 
    -0.04990312f, 0.02313326f, 0.04841015f, 0.04853574f, -0.07967342f, 0.06872039f, -0.04442659f, -0.05137364f, 
    0.00749060f, -0.01614722f, 0.03119979f, -0.04220263f, -0.06921668f, -0.02739345f, -0.02739985f, -0.07182106f, 
    -0.06124032f, -0.06853456f, 0.04215250f, 0.05542287f, -0.00940543f, -0.08678498f, -0.06295943f, -0.06428399f, 
    -0.01292416f, -0.01473493f, 0.02598949f, -0.07996438f, -0.00398680f, 0.03225489f, -0.02606122f, -0.05814527f, 
    -0.07036013f, -0.06191686f, 0.00288763f, -0.05625886f, -0.01166638f, -0.01746926f, -0.05501336f, 0.05327242f, 
    0.02635002f, 0.04644213f, -0.00835732f, -0.08472109f, -0.07638329f, -0.01662492f, -0.03012853f, -0.08127800f, 
    -0.05702379f, 0.04279765f, -0.04367568f, 0.03086282f, -0.02626367f, -0.03445032f, 0.02308307f, -0.02279913f, 
    -0.04830935f, 0.01312721f, -0.00481601f, -0.01746593f, 0.01312497f, 0.05367276f, -0.01940211f, -0.06360401f, 
    -0.08279296f, -0.07629643f, 0.01108043f, -0.06293410f, -0.07876108f, -0.06960680f, 0.05318160f, 0.01687540f, 
    -0.04156312f, -0.07619651f, 0.04519260f, -0.03437386f, 0.04314005f, 0.00711055f, -0.03691826f, -0.04173183f, 
    0.04350846f, -0.04683247f, -0.03771088f, -0.05009880f, 0.02626077f, -0.06681245f, -0.07454593f, 0.05336694f, 
    0.00492474f, -0.04252389f, -0.03625252f, 0.01407549f, -0.02880190f, -0.04921214f, 0.00373147f, -0.06589803f, 
    0.03059056f, 0.00047281f, 0.00378648f, 0.01056321f, 0.03536918f, 0.01125362f, -0.05763146f, 0.03565056f, 
    0.00411629f, -0.05881917f, 0.00765472f, -0.03978681f, -0.08197258f, -0.04809603f, -0.04913478f, -0.06311478f, 
    -0.02748679f, -0.07861372f, -0.04190993f, -0.05521776f, -0.05744967f, -0.03400245f, -0.08267834f, -0.04051913f, 
    0.02477036f, 0.00127844f, -0.12067779f, -0.15476239f, 0.09292258f, 0.04488433f, 0.01972078f, 0.12603554f, 
    0.07998331f, 0.15878475f, -0.17752893f, 0.10107056f, -0.12554717f, 0.04139274f, -0.10283715f, -0.14443348f, 
    0.14406277f, -0.05592988f, 0.03581400f, -0.05315734f, 0.06180377f, -0.04135536f, 0.06795647f, 0.04984511f, 
    0.41539973f, -0.24613842f, -0.11147942f, 0.00214252f, -0.02819721f, 0.03371555f, -0.06732970f, -0.01610120f, 
    0.15709180f, 0.02901543f, -0.04609313f, -0.08296333f, 0.02110603f, -0.20173866f, -0.01665221f, -0.06412177f, 
    -0.07314284f, 0.04252395f, 0.07755898f, 0.01547025f, 0.10533363f, -0.01186105f, 0.11412114f, 0.17561644f, 
    -0.08916169f, -0.03208002f, -0.00965373f, 0.06817469f, -0.08402607f, -0.06717575f, 0.00428037f, -0.02721204f, 
    -0.01912826f, 0.13910754f, -0.06451019f, -0.19363700f, 0.19738249f, 0.24357785f, -0.29817739f, -0.17923065f, 
    -0.07546449f, 0.15323588f, -0.05880764f, -0.01422090f, 0.06899618f, -0.13080052f, -0.02097127f, -0.07074288f, 
    0.32772329f, -0.03785136f, 0.01584220f, -0.03983789f, -0.00544863f, 0.02299886f, 0.05738894f, -0.05723888f, 
    0.04067375f, 0.00210243f, 0.00202840f, -0.03919915f, -0.04145031f, 0.01366715f, -0.13623039f, 0.07413884f, 
    0.15398897f, -0.18863922f, -0.03764538f, 0.06475536f, 0.01108943f, 0.01982506f, 0.20328224f, 0.06955152f, 
    -0.05764727f, 0.16631603f, 0.19005670f, -0.15078586f, 0.04084147f, -0.12431395f, 0.07960373f, -0.04953627f, 
    0.06905172f, -0.03007345f, -0.09222084f, -0.15332194f, 0.12263297f, -0.04555684f, -0.16221906f, 0.13151716f, 
    -0.02772742f, 0.05858932f, -0.03474311f, 0.02540786f, 0.02318545f, -0.05723431f, -0.06834354f, -0.06860957f, 
    0.31217971f, 0.06827890f, -0.23446999f, 0.01889509f, 0.02667578f, -0.03465104f, 0.10691246f, -0.03400098f, 
    -0.00234802f, -0.07874047f, 0.08577128f, 0.08302584f, 0.21275210f, 0.35045204f, -0.19483177f, -0.01680007f, 
    0.03697030f, -0.02331228f, -0.02879285f, 0.18264154f, -0.01673098f, 0.06940912f, 0.08867607f, 0.17741461f, 
    0.05778275f, 0.09871582f, 0.01424330f, -0.21056254f, 0.19218571f, 0.03638431f, -0.10093105f, 0.01679444f, 
    -0.02118723f, 0.07928422f, -0.10825067f, 0.01346173f, 0.18391067f, 0.02378880f, -0.03438799f, 0.08479508f, 
    0.03910318f, 0.10744613f, 0.00504536f, -0.03767364f, -0.06965485f, -0.05861553f, 0.05716448f, 0.06540579f, 
    0.12714604f, -0.11069314f, 0.20865448f, 0.19363157f, 0.10154941f, 0.10115486f, -0.06946554f, -0.10839168f, 
    -0.03005737f, -0.03598151f, 0.04128233f, 0.06675916f, -0.23504739f, 0.14300863f, 0.01811060f, -0.10969107f, 
    0.01373889f, 0.09825339f, -0.11590366f, -0.01894029f, 0.02579914f, 0.04689369f, 0.01239228f, 0.02096972f, 
    -0.10877914f, 0.13671184f, 0.00403911f, 0.20978856f, -0.04209159f, 0.09224123f, -0.09659242f, 0.02898906f, 
    -0.01800304f, -0.10837633f, 0.03113116f, -0.06348624f, 0.13087630f, -0.13594954f, -0.09633441f, 0.06420487f, 
    -0.15381365f, 0.00848218f, -0.17505407f, 0.12952577f, 0.04530113f, 0.12023723f, -0.03286852f, 0.05095937f, 
    0.00504349f, 0.03093244f, -0.01536984f, 0.11728977f, 0.03269234f, 0.03941994f, 0.07859220f, -0.09416668f, 
    -0.15952457f, 0.04512864f, 0.04330592f, 0.12945545f, 0.28492033f, 0.02451982f, -0.06206785f, -0.08235427f, 
    0.09030509f, 0.06078288f, -0.03521509f, -0.02942175f, -0.17860152f, -0.07592435f, -0.09024124f, -0.05383478f, 
    0.13708842f, -0.13205768f, 0.00211862f, -0.05417302f, 0.06657133f, 0.08304928f, 0.16305315f, 0.06301649f, 
    0.05966838f, -0.10115020f, 0.13039045f, 0.06733669f, 0.15339145f, 0.00409719f, 0.28921860f, 0.07214180f, 
    -0.00293372f, -0.06836188f, 0.02774959f, 0.07221631f, -0.05950841f, 0.03943855f, 0.04671215f, 0.05688428f, 
    -0.12104481f, -0.13515827f, 0.04395425f, -0.18338513f, 0.06221451f, -0.07636793f, 0.00103078f, 0.03687920f, 
    0.11426886f, -0.06611438f, 0.01362524f, 0.18571554f, -0.02242815f, 0.09069653f, -0.06241721f, 0.18924013f, 
    -0.06389342f, 0.07776905f, 0.06988320f, -0.14358267f, -0.05396880f, -0.12808299f, -0.01364783f, -0.02050330f, 
    0.31247383f, -0.04193347f, 0.02714060f, 0.28276709f, -0.07504423f, -0.02070909f, 0.03300115f, -0.01395359f, 
    -0.09081784f, 0.01700955f, 0.13854800f, 0.19648281f, 0.12648942f, 0.17493363f, 0.19727209f, 0.07212873f, 
    0.03183525f, 0.11283665f, 0.01022223f, -0.00772254f, 0.02622747f, -0.16671567f, 0.05559070f, 0.07163353f, 
    0.27356049f, 0.29072958f, -0.16232470f, 0.14995775f, -0.18520731f, 0.05689383f, 0.12773740f, 0.16516899f, 
    -0.03100225f, -0.03933690f, -0.06767485f, -0.09214982f, 0.14848302f, 0.01698231f, -0.06986988f, -0.01048556f, 
    -0.11074711f, -0.04418039f, 0.04413506f, 0.10656283f, -0.10072382f, -0.07900009f, 0.05670810f, 0.00694376f, 
    -0.04360865f, -0.09070854f, 0.01932473f, -0.12309770f, 0.04297573f, 0.01382307f, 0.13608079f, 0.12550987f, 
    -0.06697031f, -0.05505593f, -0.08632717f, -0.01145393f, 0.04039857f, 0.06382086f, -0.01806197f, -0.06973284f, 
    -0.05557762f, -0.12216629f, -0.08850128f, -0.04292775f, -0.14517972f, 0.05955531f, -0.06769875f, -0.05968193f, 
    0.20057796f, 0.12101761f, -0.08290177f, 0.10961113f, -0.19809313f, -0.03929259f, 0.13281865f, 0.11147700f, 
    0.02021410f, 0.09013129f, -0.08564736f, -0.01312732f, -0.10191706f, -0.03571728f, -0.00342366f, 0.22854747f, 
    -0.02481727f, -0.04427656f, -0.01875708f, 0.00943688f, 0.06475681f, 0.08649374f, 0.05359656f, 0.07642173f, 
    -0.17449251f, -0.01097854f, 0.00056261f, 0.02538639f, 0.10616118f, -0.12878767f, -0.08247405f, 0.12729664f, 
    0.06775317f, 0.04302195f, -0.07653461f, -0.01359521f, -0.18878455f, 0.05434189f, -0.02228225f, -0.10041280f, 
    0.15383109f, -0.01176905f, 0.30996630f, 0.10337107f, 0.01679234f, 0.10799538f, 0.14536892f, 0.09890259f, 
    -0.03924603f, -0.09391961f, 0.10880429f, -0.15804863f, 0.18514556f, 0.06358936f, -0.09074783f, 0.04533365f, 
    0.02586032f, -0.08545213f, 0.02186204f, 0.00598986f, 0.10645709f, 0.13386174f, 0.04724594f, -0.26818153f, 
    -0.03636402f, 0.06648137f, 0.05972584f, -0.10901472f, 0.08870488f, -0.05447834f, -0.01493776f, 0.03739078f, 
    0.14717445f, 0.01699191f, 0.13753988f, 0.14569427f, -0.11483645f, -0.05551809f, 0.03051290f, 0.09979664f, 
    0.12621231f, 0.10115720f, -0.06278852f, 0.08724535f, -0.00542708f, 0.16175047f, -0.03946758f, 0.07012910f, 
    -0.00842010f, 0.03229860f, 0.03096503f, -0.02725247f, 0.08424702f, 0.04741375f, -0.00809973f, -0.05817613f, 
    -0.00961543f, -0.02311802f, 0.04019265f, 0.13370770f, 0.01461022f, 0.01761160f, 0.06620394f, 0.01511801f, 
    0.07582211f, 0.03930740f, 0.00809772f, 0.07087111f, -0.05897257f, -0.10325701f, 0.15346348f, -0.02915983f, 
    -0.07899567f, -0.00786679f, 0.10921995f, 0.04928235f, 0.04167730f, -0.00044426f, -0.16516148f, -0.11870284f, 
    -0.05997615f, 0.01842576f, -0.06971830f, -0.19536020f, 0.12583867f, 0.08170231f, 0.15639438f, -0.11534584f, 
    0.11949391f, 0.04388131f, 0.06768328f, -0.02028620f, -0.01190015f, -0.09639984f, -0.21598087f, -0.15236525f, 
    -0.06780066f, 0.01621088f, 0.09186479f, -0.09988410f, -0.07632694f, 0.00329345f, -0.05074652f, 0.01152384f, 
    0.08942520f, 0.02747259f, 0.10872737f, -0.00715499f, 0.06216417f, -0.05045600f, 0.00654685f, 0.06740148f, 
    0.11540703f, -0.06134575f, -0.02477885f, 0.09148477f, -0.29892460f, -0.05671668f, -0.10428865f, 0.06095879f, 
    0.01076657f, 0.01166462f, -0.03329139f, -0.06076128f, 0.08451328f, 0.13044550f, 0.00429253f, 0.04906186f, 
    0.01941788f, -0.03710200f, -0.09028830f, -0.01545480f, 0.14056081f, 0.02519198f, -0.04393446f, 0.09187024f, 
    0.13383824f, 0.04442775f, 0.04732394f, 0.06860196f, 0.25436437f, 0.25784650f, 0.27642035f, 0.10360208f, 
    -0.07571182f, 0.01615688f, 0.03111595f, 0.09139021f, 0.07324411f, -0.03406727f, 0.09679700f, 0.08050342f, 
    0.16247377f, 0.18489695f, 0.11929056f, 0.12724578f, -0.10047821f, -0.02101316f, -0.10966539f, 0.06350416f, 
    0.06935502f, -0.09149864f, 0.00797262f, 0.07781146f, -0.24815865f, -0.09741732f, 0.16781424f, -0.09503304f, 
    0.04793079f, 0.08263638f, -0.08191112f, -0.02131534f, 0.04444261f, -0.12745427f, 0.10814731f, -0.10091353f, 
    -0.07184727f, 0.10797526f, -0.00020028f, 0.16977248f, 0.02453907f, 0.14075151f, -0.10004470f, -0.10202231f, 
    -0.12792006f, -0.19275667f, 0.06819806f, -0.12838456f, 0.10511042f, -0.25501654f, -0.18327703f, 0.02908774f, 
    -0.09911064f, 0.05706204f, -0.19395675f, 0.02635734f, -0.02982901f, -0.03322075f, -0.02590354f, -0.06741814f, 
    0.14059512f, 0.02328543f, 0.07448835f, 0.05378723f, -0.02848997f, -0.08266082f, 0.05998242f, -0.26641127f, 
    -0.09166366f, 0.12335599f, 0.09026878f, -0.08133552f, 0.11522362f, -0.10309257f, -0.09485176f, 0.12943184f, 
    0.05620902f, -0.00225903f, 0.00151482f, 0.05561729f, -0.16498764f, 0.02278846f, -0.04245719f, -0.12275356f, 
    0.05286454f, -0.36724675f, -0.05945771f, 0.01468501f, 0.06160352f, 0.09324389f, 0.09511227f, 0.04127356f, 
    -0.03599245f, -0.08983364f, 0.17176095f, 0.12935527f, -0.03734087f, -0.13157548f, 0.27196321f, 0.03728451f, 
    0.14549246f, 0.03896526f, -0.06246969f, 0.02392033f, -0.14383966f, 0.04905528f, 0.09338617f, 0.06093440f, 
    0.05366869f, -0.17585610f, 0.05708516f, -0.20615968f, -0.10011075f, -0.02785850f, -0.00023612f, -0.02136751f, 
    0.11654395f, -0.00553184f, -0.04449124f, 0.22106241f, 0.17436914f, 0.18483761f, 0.08479055f, 0.18582155f, 
    -0.04050545f, 0.17034468f, 0.05392713f, 0.00245466f, 0.01426761f, -0.01935190f, -0.08114707f, 0.06794187f, 
    0.20692606f, 0.07314026f, 0.02858824f, 0.21432950f, -0.04263584f, 0.03025770f, -0.05315085f, -0.01242157f, 
    -0.13269654f, 0.01946173f, 0.02978626f, 0.22870064f, 0.27550873f, 0.20024309f, 0.17381637f, 0.04857023f, 
    -0.02266412f, 0.05192101f, -0.03957994f, 0.03788545f, 0.00353198f, 0.05574842f, 0.16482688f, 0.06448329f, 
    0.00292457f, 0.09242525f, 0.04946665f, -0.15297975f, 0.07763672f, 0.10500416f, -0.01686131f, 0.14336713f, 
    -0.04036201f, 0.07058587f, -0.15607958f, -0.10734258f, 0.08699188f, 0.07833370f, -0.08273984f, -0.00811210f, 
    0.18193349f, 0.08433996f, -0.02035836f, 0.09687228f, -0.03354993f, -0.08495077f, 0.00118489f, 0.06170753f, 
    -0.10981102f, 0.09815264f, -0.05422830f, -0.05565824f, -0.07654916f, -0.01367090f, 0.16336866f, 0.14403695f, 
    0.00096093f, -0.01328217f, 0.06197215f, -0.04495726f, -0.16874287f, 0.00540973f, -0.06411462f, -0.26167575f, 
    0.02173546f, 0.03104121f, -0.07681502f, 0.05329422f, -0.10815243f, 0.09489262f, -0.05885462f, -0.01321368f, 
    0.02739090f, 0.04304132f, -0.20621037f, -0.15245864f, -0.09081639f, -0.09745578f, 0.10313035f, 0.09489965f, 
    0.05237795f, 0.02415631f, 0.00432637f, -0.11039729f, -0.02017698f, 0.01992263f, 0.01059399f, 0.16857865f, 
    -0.11415635f, -0.04446620f, 0.06477635f, 0.02324552f, 0.02207376f, 0.19837476f, 0.11762217f, 0.03262534f, 
    -0.25488603f, 0.14102201f, 0.00264257f, -0.10791535f, 0.05623895f, -0.05114117f, -0.01178323f, 0.01428813f, 
    -0.09842395f, -0.08141226f, -0.14923607f, 0.03045094f, 0.03221019f, 0.00779172f, 0.01229323f, -0.05554226f, 
    0.05449864f, -0.03242030f, 0.10128379f, 0.11049841f, 0.00211108f, 0.11391169f, 0.04832571f, 0.14907323f, 
    0.38817465f, -0.24287720f, 0.03021004f, -0.19063352f, -0.02951378f, -0.00342817f, -0.02104811f, -0.02270532f, 
    -0.01824363f, -0.09241207f, -0.01157994f, -0.04391464f, 0.02279703f, -0.15741755f, 0.05769808f, -0.21449624f, 
    -0.02737846f, 0.01029493f, 0.03366843f, -0.03848672f, 0.09070437f, 0.01896491f, 0.08609527f, 0.00339464f, 
    -0.14332390f, -0.20633681f, 0.09931412f, 0.13530040f, -0.14117186f, 0.01394059f, 0.04322409f, -0.00559090f, 
    0.12349742f, 0.00194450f, 0.04898814f, 0.00536441f, -0.23058210f, 0.37773609f, -0.05495742f, -0.12116798f, 
    0.02880722f, -0.03851545f, 0.09801258f, 0.09616449f, -0.04830247f, 0.05665416f, 0.08306112f, 0.03980889f, 
    0.21717998f, 0.11333851f, 0.01556013f, -0.02951269f, -0.10409583f, -0.00456747f, -0.07384621f, -0.02303454f, 
    0.05373299f, -0.06560997f, 0.05603818f, 0.05762025f, 0.09710269f, -0.03119064f, 0.03865150f, 0.25851062f, 
    -0.02975236f, -0.04547883f, 0.11660571f, 0.02282872f, 0.01339336f, 0.07978737f, -0.10081736f, 0.00818448f, 
    0.03123086f, -0.20189610f, -0.07152245f, -0.11930552f, 0.11716405f, -0.00101606f, 0.07393505f, -0.06195147f, 
    0.03025567f, 0.01440272f, -0.05636153f, 0.00040998f, 0.26177004f, 0.04397279f, -0.03901529f, -0.06804466f, 
    -0.00981187f, 0.01621905f, 0.03672185f, 0.15508880f, -0.08277990f, 0.01930775f, -0.03210289f, 0.04861479f, 
    0.03140627f, 0.07125597f, -0.12239051f, 0.22363767f, -0.06589379f, -0.09552874f, 0.14191015f, 0.04645866f, 
    -0.03371571f, -0.06917492f, -0.08119330f, -0.01122110f, -0.31260538f, 0.15344138f, -0.07693575f, 0.09171283f, 
    0.08684561f, -0.04426320f, -0.03697157f, 0.05738624f, 0.06708243f, 0.01765889f, -0.11552496f, 0.11880571f, 
    -0.06772985f, -0.17775339f, 0.11752871f, -0.14729571f, 0.22870949f, -0.00407519f, 0.07578587f, 0.00214305f, 
    0.10381053f, -0.11872724f, -0.00229621f, 0.11539932f, 0.20940083f, 0.02067434f, 0.28010732f, 0.17921878f, 
    -0.07450756f, 0.01461888f, -0.01870464f, 0.17834929f, -0.01591984f, 0.08255418f, 0.04511922f, 0.14211300f, 
    0.02376586f, -0.05157017f, 0.07725431f, 0.34164116f, -0.18673845f, -0.08385455f, -0.00934808f, 0.02091889f, 
    0.07433329f, -0.01956040f, -0.00203488f, 0.13057856f, 0.05467858f, 0.15907292f, 0.05165784f, -0.05809551f, 
    -0.00141819f, 0.02015496f, -0.02785894f, -0.11618360f, -0.02002812f, 0.01294043f, -0.06167520f, -0.08547717f, 
    0.07155320f, 0.01766738f, 0.05905669f, 0.12112588f, 0.13887931f, 0.01922808f, 0.03913025f, 0.05126373f, 
    0.09531817f, 0.31595793f, -0.08388424f, 0.03708223f, 0.15391330f, 0.31028423f, 0.00578759f, 0.15070118f, 
    -0.05794358f, -0.03804776f, 0.01185601f, 0.02286156f, 0.08091144f, -0.05590046f, 0.01973000f, 0.07504607f, 
    -0.22250937f, 0.26454100f, 0.09969795f, -0.19830447f, 0.12556194f, 0.10415511f, 0.05561510f, 0.26551393f, 
    0.03976690f, 0.01021939f, -0.11644585f, -0.08782350f, -0.34324634f, 0.23447204f, 0.00113049f, 0.08717593f, 
    -0.01364922f, -0.04104296f, 0.03824354f, 0.04922021f, 0.17265007f, 0.02657951f, -0.09968787f, 0.08089685f, 
    -0.12386946f, 0.08033875f, 0.24333586f, -0.17833455f, -0.02238329f, -0.13462605f, -0.07083695f, -0.02369694f, 
    -0.12451288f, -0.04120631f, -0.05762703f, -0.06955967f, 0.05272884f, -0.03302364f, -0.07793789f, 0.08492202f, 
    -0.00778332f, -0.02151304f, 0.03252168f, -0.04328183f, -0.02362085f, 0.08752716f, -0.00974153f, -0.08937415f, 
    -0.24129377f, 0.25938937f, -0.14758351f, 0.09873486f, 0.03721093f, 0.10845708f, -0.11977677f, -0.10040342f, 
    -0.04341495f, -0.04498498f, 0.00725080f, -0.05777840f, -0.05507293f, -0.12222028f, 0.02889960f, -0.27913752f, 
    0.11836533f, -0.00753452f, -0.00344649f, 0.03936932f, 0.01777362f, 0.06743177f, 0.13918060f, 0.18221398f, 
    0.01055809f, 0.01014927f, -0.06049727f, 0.01415263f, 0.08379548f, 0.03399181f, -0.04567252f, 0.06452861f, 
    0.05590834f, 0.05617655f, 0.03446831f, -0.11865275f, 0.05982533f, -0.19331913f, -0.03388662f, 0.01128484f, 
    -0.08739381f, 0.04680854f, 0.05221169f, -0.12361339f, -0.01257282f, 0.13591516f, 0.09871745f, -0.07161256f, 
    0.09999973f, 0.04407253f, -0.26958799f, 0.16445048f, 0.02012727f, 0.04765698f, 0.00561081f, -0.02648068f, 
    -0.01923135f, -0.01676153f, 0.12956649f, 0.17426832f, 0.17644446f, -0.04050435f, -0.00437384f, -0.01317514f, 
    0.04446989f, -0.05923368f, -0.05565546f, 0.04885563f, 0.10231631f, -0.01464258f, -0.01240548f, -0.11327176f, 
    -0.12609424f, 0.29537782f, 0.03688417f, 0.04781947f, -0.05794159f, -0.05904949f, -0.06451783f, -0.16718605f, 
    0.02325869f, -0.06317989f, 0.02060840f, 0.04757771f, 0.14296107f, -0.05745860f, 0.03920906f, 0.03333271f, 
    0.15804355f, 0.02596435f, -0.04451140f, 0.00793473f, 0.10059537f, -0.18957114f, 0.11837772f, 0.00528221f, 
    0.10786601f, -0.16132940f, -0.02733427f, 0.17150584f, -0.00432042f, 0.07349464f, 0.01264777f, -0.10636097f, 
    0.00571361f, -0.01369162f, 0.00339337f, 0.18095329f, -0.07233773f, -0.10530324f, 0.13726109f, -0.12016407f, 
    0.00439141f, -0.04929208f, -0.03035642f, 0.03864619f, -0.04489245f, 0.02817603f, -0.00569393f, 0.11115336f, 
    0.11022247f, 0.09985694f, 0.04857246f, 0.12282082f, -0.02381659f, 0.06495341f, 0.00384384f, -0.12054265f, 
    0.03201552f, -0.07686977f, 0.06160482f, -0.14919205f, 0.37899032f, -0.00493051f, 0.02773785f, 0.13643138f, 
    0.10049892f, 0.00475537f, -0.08794121f, -0.17803818f, -0.06722414f, -0.03755992f, 0.05964549f, -0.06895646f, 
    0.05410702f, -0.05703253f, -0.10972107f, 0.31322214f, -0.02400991f, -0.08864767f, -0.00832754f, -0.12031981f, 
    -0.13550000f, 0.10020074f, 0.06814217f, 0.05243694f, 0.02581535f, -0.07910383f, 0.14185561f, 0.11304586f, 
    0.05547539f, 0.08015793f, -0.06811202f, 0.00724397f, -0.13713285f, 0.05071525f, 0.10147711f, -0.00153079f, 
    -0.10016275f, -0.29839006f, -0.14705852f, -0.24776198f, 0.02528382f, 0.07842728f, -0.02305966f, 0.12529494f, 
    0.09525239f, 0.12200181f, -0.00427033f, 0.16649850f, -0.14639629f, 0.11449974f, 0.13119106f, -0.07649907f, 
    0.06644046f, 0.04374368f, -0.00765955f, 0.11207106f, 0.00807280f, 0.01313263f, -0.05616786f, 0.03839745f, 
    -0.06376589f, -0.19473486f, 0.20767684f, 0.12446620f, -0.00106908f, 0.05381324f, 0.15641531f, 0.14556217f, 
    -0.10598191f, -0.01618046f, 0.02511513f, -0.03416937f, -0.20676981f, 0.14315422f, 0.04359945f, -0.12628989f, 
    0.15313995f, -0.05362298f, -0.08314925f, -0.02847045f, 0.11784507f, -0.02234380f, -0.00658071f, 0.01897931f, 
    -0.11862361f, 0.04004618f, 0.14628215f, 0.35674080f, 0.00654389f, 0.16150981f, -0.10327008f, 0.18585625f, 
    -0.09957782f, 0.02692951f, 0.24476963f, 0.01832564f, 0.00358202f, 0.18095672f, 0.06219760f, 0.10957226f, 
    0.02384928f, 0.10137966f, -0.04857472f, -0.02515820f, -0.04500688f, 0.03822603f, -0.04455171f, 0.17597564f, 
    -0.21608594f, -0.27589947f, -0.12861581f, -0.11631275f, 0.00435589f, 0.13524856f, -0.04350948f, 0.06851742f, 
    0.14498726f, -0.03156808f, -0.01953294f, 0.00329575f, 0.29462847f, -0.34823528f, 0.07046057f, -0.05830139f, 
    0.05570027f, 0.01335650f, 0.07169484f, 0.00434806f, -0.07716443f, 0.09627495f, -0.11735700f, 0.02570388f, 
    0.03256592f, 0.08158201f, -0.01676747f, 0.30178297f, -0.03004503f, 0.07315475f, 0.05829405f, 0.17218785f, 
    -0.06742521f, 0.01392008f, -0.04936871f, -0.00596559f, -0.32591641f, -0.28305948f, -0.34218624f, -0.06567596f, 
    0.03959861f, -0.02839666f, -0.02743920f, -0.10548744f, -0.02592997f, -0.06276048f, -0.13986015f, 0.04263349f, 
    -0.28948602f, -0.14789058f, -0.28791007f, -0.25302267f, 0.14245771f, -0.17481323f, -0.07619878f, 0.04694618f, 
    -0.02446255f, 0.04219173f, -0.02830394f, -0.26487666f, 0.15962374f, 0.36669648f, 0.09270960f, 0.09481614f, 
    0.15288591f, -0.11931558f, 0.17865717f, 0.08869983f, -0.04045541f, 0.11356407f, 0.04534107f, 0.06391504f, 
    -0.05487208f, -0.02972735f, 0.03898420f, -0.05011104f, -0.03742623f, 0.04447165f, 0.00070372f, -0.06931154f, 
    -0.07533582f, -0.04308483f, -0.07442313f, 0.01616663f, 0.05680653f, 0.00497534f, -0.05493326f, 0.05774751f, 
    0.02192922f, 0.01199134f, -0.05709689f, -0.04754348f, 0.02446913f, -0.07053728f, -0.06917369f, 0.00073700f, 
    -0.03602910f, -0.04957373f, -0.04933429f, -0.02852067f, 0.05485843f, -0.00585898f, -0.01326568f, -0.05281812f, 
    0.05017094f, -0.02210682f, 0.00395784f, -0.06032850f, -0.06538590f, -0.00846062f, -0.05567007f, -0.03325022f, 
    0.03351901f, 0.04405546f, 0.03557387f, 0.03940024f, -0.01243926f, 0.06158918f, -0.03823484f, -0.04969494f, 
    -0.00600222f, -0.05247787f, 0.01661898f, 0.00526230f, 0.02429583f, -0.01324482f, -0.04164092f, 0.04186712f, 
    -0.01403409f, -0.05140791f, 0.06471890f, -0.04436398f, 0.02966582f, 0.02636964f, -0.03687540f, 0.02577072f, 
    -0.00797139f, 0.01946499f, -0.06636352f, -0.02469561f, 0.03589551f, 0.04945349f, -0.02705384f, -0.06244020f, 
    0.04099253f, 0.04825862f, 0.02280954f, 0.00530678f, 0.04979055f, -0.01232243f, 0.03228099f, 0.04443777f, 
    0.05781580f, 0.05077486f, 0.03401463f, 0.04656288f, 0.03187621f, -0.02451248f, -0.06783871f, -0.05935063f, 
    -0.07382744f, 0.03358870f, 0.00808370f, -0.01620300f, -0.00196012f, -0.06579363f, -0.03288651f, -0.03027102f, 
    0.03532026f, -0.05630495f, -0.03955523f, -0.00214449f, 0.04606070f, -0.02841468f, -0.05504790f, 0.02769549f, 
    0.00064975f, -0.05572807f, -0.03111472f, -0.05128511f, 0.06066062f, -0.05858690f, 0.00269560f, -0.06253412f, 
    0.06340333f, 0.03670995f, -0.04511587f, -0.06142525f, -0.02982791f, -0.01426092f, 0.00801087f, -0.00610915f, 
    -0.05875738f, -0.03201866f, 0.01901030f, -0.06605093f, -0.00975039f, -0.03085460f, 0.05193813f, -0.05185610f, 
    -0.02233782f, 0.05884430f, 0.02332131f, -0.02783531f, -0.07820175f, -0.04913846f, -0.04108456f, -0.00379369f, 
    0.00397486f, -0.02523327f, 0.05511216f, -0.00546816f, 0.01959420f, 0.02282937f, -0.07009834f, -0.02425818f, 
    -0.01190382f, -0.05927211f, 0.01427642f, -0.04749370f, -0.03688561f, -0.00239276f, -0.04534908f, -0.03671638f, 
    0.01800392f, -0.02437117f, -0.02320656f, 0.02974252f, -0.07329030f, -0.01314786f, -0.05132672f, 0.01210357f, 
    0.02041788f, 0.02489591f, -0.06314561f, 0.02235910f, 0.01427229f, -0.07958312f, -0.06790470f, 0.00159301f, 
    0.03178548f, -0.01353687f, -0.07530880f, -0.04411962f, -0.04811753f, -0.03588651f, -0.02404059f, 0.05137883f, 
    0.05196072f, 0.03846884f, -0.02625585f, -0.06886175f, 0.05249202f, -0.02924434f, -0.00159433f, 0.00118925f, 
    0.01504742f, -0.04912653f, -0.06828189f, 0.00828139f, 0.03914256f, -0.03316161f, -0.06838500f, 0.03468897f, 
    0.05418066f, -0.08701275f, -0.32066146f, 0.01529883f, -0.01916579f, -0.01199017f, -0.11332434f, -0.12225601f, 
    -0.07489379f, -0.27037087f, -0.10477374f, -0.02710485f, 0.05227133f, 0.02872287f, -0.10974558f, -0.04989127f, 
    0.05489922f, -0.06736935f, -0.03511469f, -0.11007874f, -0.04743158f, 0.06106041f, -0.02771993f, -0.04173432f, 
    0.42962849f, -0.13813886f, 0.05180702f, 0.01699422f, -0.05835636f, -0.11028181f, -0.01068434f, -0.27335545f, 
    0.14472552f, 0.01506141f, 0.21872944f, -0.01977982f, 0.00091817f, -0.20365596f, -0.09894247f, -0.10896089f, 
    -0.08516001f, 0.08913553f, 0.00218744f, -0.08760752f, -0.17900282f, -0.02495169f, 0.00001160f, -0.18256046f, 
    0.06308930f, -0.21675268f, -0.08020888f, -0.04335510f, 0.10284599f, 0.08369584f, 0.03526115f, 0.10240667f, 
    -0.04658945f, -0.06018732f, 0.01639780f, 0.07104918f, 0.35070133f, -0.20804156f, -0.10298675f, 0.05972338f, 
    0.07639829f, -0.01592815f, 0.01447347f, 0.07204362f, -0.07247443f, -0.00325181f, 0.10871019f, 0.07023004f, 
    0.44854376f, 0.09755159f, 0.09684790f, -0.08551862f, -0.06780114f, 0.00204319f, 0.01956749f, 0.10565047f, 
    -0.03243736f, -0.08881460f, -0.13913064f, -0.01830077f, 0.33958820f, 0.10771745f, -0.01409418f, 0.09624346f, 
    -0.00092790f, -0.14468938f, 0.04101209f, -0.11772451f, -0.16836625f, -0.06112595f, -0.07779405f, -0.08852553f, 
    0.08812778f, 0.26679999f, -0.02464655f, 0.05978790f, 0.07250243f, 0.05224525f, 0.09956753f, -0.02735504f, 
    0.02873602f, -0.05654161f, -0.03058796f, 0.08802834f, 0.23937678f, -0.01178975f, -0.02251980f, 0.13923508f, 
    -0.00620159f, 0.06874199f, 0.14437878f, 0.04185826f, 0.09095348f, 0.04145972f, 0.00262697f, 0.04082749f, 
    -0.03627748f, 0.17878972f, 0.18423608f, -0.16975245f, 0.16605085f, -0.11337050f, -0.01957802f, 0.02697860f, 
    0.06543583f, -0.00256223f, -0.11845931f, -0.05682791f, -0.11491071f, 0.29905680f, -0.10918753f, 0.02122492f, 
    0.15943015f, 0.02335558f, 0.01195768f, -0.05553538f, -0.06263592f, -0.07238602f, 0.07791584f, 0.12519944f, 
    0.06157932f, 0.11345284f, 0.04760029f, 0.04369512f, 0.12341145f, 0.06999412f, 0.14027417f, 0.07356155f, 
    0.00056183f, 0.00446444f, 0.07243169f, -0.08195927f, -0.14764939f, 0.28070974f, -0.04462301f, -0.28899750f, 
    0.11225033f, 0.07209504f, -0.01047672f, 0.02787296f, -0.11997642f, 0.21268657f, 0.00696643f, 0.01002428f, 
    -0.10345908f, 0.03130248f, 0.08045440f, -0.15376322f, 0.13272135f, 0.01135936f, -0.06671122f, -0.01132827f, 
    -0.03554785f, 0.04474341f, -0.00550255f, -0.09522300f, 0.04648260f, 0.02761215f, -0.11097481f, -0.04333737f, 
    -0.05455039f, 0.12240440f, -0.03984962f, 0.11868042f, -0.01001372f, 0.07717646f, 0.06329141f, -0.01698256f, 
    0.04771944f, 0.15362191f, 0.13270627f, 0.09300115f, -0.17388272f, 0.05569305f, -0.03755528f, -0.04566016f, 
    -0.13094729f, -0.10951442f, 0.04369476f, -0.00105906f, 0.10188194f, 0.17860529f, 0.36744547f, 0.04038668f, 
    0.01400831f, 0.09178860f, -0.11748869f, 0.04887304f, 0.01724030f, -0.02406635f, 0.00714597f, 0.02954183f, 
    0.09921251f, 0.40476599f, -0.16319029f, 0.11880358f, 0.14712584f, 0.33779380f, 0.01208263f, 0.04784630f, 
    -0.06433941f, 0.11343517f, 0.05540653f, 0.03826062f, 0.12103022f, 0.08942734f, 0.00228904f, 0.14768538f, 
    -0.07578705f, -0.04813401f, -0.05457580f, -0.14646481f, 0.06773189f, 0.02583910f, 0.03186283f, -0.00082983f, 
    0.11088066f, 0.43437937f, -0.07565279f, 0.16708830f, -0.08243091f, -0.01583778f, -0.00372036f, -0.06603667f, 
    -0.14231969f, 0.00507680f, -0.03933077f, -0.21234418f, -0.25357082f, -0.07351830f, 0.04443853f, -0.04484672f, 
    -0.05788722f, 0.04775628f, -0.13793087f, -0.22302109f, -0.05899747f, -0.03135842f, -0.05265171f, -0.01875989f, 
    0.20882407f, 0.08617612f, -0.14485779f, -0.24781051f, 0.12290259f, 0.10891531f, 0.11911918f, -0.14567041f, 
    0.16407745f, 0.02714849f, -0.18510808f, 0.05063444f, 0.05156104f, -0.13009164f, -0.04601684f, 0.28824908f, 
    0.05957627f, -0.02531980f, -0.16788425f, 0.03741839f, -0.05911702f, -0.08265697f, 0.06643262f, -0.25626841f, 
    0.48582450f, 0.18893450f, 0.11861271f, -0.08491608f, -0.17238586f, 0.13996641f, 0.01282783f, 0.01526024f, 
    -0.08924495f, -0.00628240f, 0.13090980f, 0.00136848f, -0.09642752f, 0.26579425f, 0.29840061f, 0.09274720f, 
    0.08045037f, 0.03051378f, -0.06821763f, -0.07188661f, 0.03099136f, 0.13254806f, 0.00628539f, 0.09964570f, 
    0.19747268f, 0.06019278f, -0.02193269f, 0.10551172f, -0.16816501f, -0.12800367f, -0.08549054f, -0.04903691f, 
    -0.15010254f, -0.09051883f, -0.10401910f, -0.06235453f, 0.43156886f, -0.05645644f, 0.27195466f, 0.06990531f, 
    -0.18637381f, -0.01432890f, -0.06313451f, 0.00631044f, -0.07247533f, 0.00288964f, -0.15187059f, -0.02185819f, 
    0.37489361f, 0.02490890f, -0.02904839f, -0.21986796f, 0.19948694f, 0.04621519f, -0.00466192f, -0.12303726f, 
    -0.04981110f, 0.05747425f, -0.06092218f, 0.01326387f, 0.14521571f, -0.27481860f, -0.14940098f, 0.26203704f, 
    -0.19717342f, -0.17504391f, -0.06850310f, -0.05388262f, -0.05648456f, 0.00756117f, -0.00664430f, -0.18932705f, 
    -0.15239842f, -0.23346952f, -0.10434519f, 0.07585421f, -0.10733949f, -0.02607816f, -0.01893560f, -0.19448575f, 
    0.06234688f, 0.01495459f, -0.02735548f, -0.18836232f, -0.04052460f, -0.01895084f, 0.17024419f, 0.19550341f, 
    0.10170633f, -0.09249479f, 0.01306209f, 0.08933216f, 0.03521403f, -0.06835063f, 0.05617905f, 0.06185871f, 
    -0.03211873f, -0.00294763f, -0.07696121f, -0.05294190f, -0.02710942f, -0.08364350f, 0.02085898f, 0.01732677f, 
    0.03167717f, -0.07210649f, -0.02777311f, -0.06394914f, -0.03389108f, 0.00170568f, -0.02319481f, 0.00683328f, 
    -0.05771147f, -0.03962793f, 0.00807433f, 0.06832897f, -0.02002919f, -0.01938264f, -0.06706560f, -0.02826476f, 
    -0.00032996f, 0.05530359f, 0.00484894f, 0.04675724f, 0.06193698f, 0.01309491f, -0.06882861f, 0.01843100f, 
    -0.00816593f, -0.01941875f, 0.01750376f, -0.02895589f, -0.06745087f, 0.00223879f, 0.03457394f, -0.04069907f, 
    0.04049201f, -0.06910408f, -0.05854886f, 0.00741171f, 0.01429001f, 0.04633649f, -0.04549375f, -0.02178966f, 
    0.01270528f, -0.03922982f, 0.04347541f, 0.04028556f, 0.03642370f, 0.01171061f, -0.05557543f, -0.01361739f, 
    -0.03410819f, -0.03592037f, -0.01841883f, 0.04316428f, -0.06013633f, -0.07086686f, -0.03884552f, 0.04120369f, 
    0.04848372f, -0.05610859f, -0.00330096f, -0.04944934f, -0.00324913f, 0.01272581f, -0.00412904f, 0.04496852f, 
    0.02408903f, -0.06575051f, 0.01955946f, -0.06755202f, 0.03639391f, -0.01264112f, 0.00871054f, 0.03700471f, 
    0.03755966f, 0.04523221f, 0.02836069f, -0.05933920f, -0.05283848f, 0.05968889f, 0.01693873f, -0.07289538f, 
    0.04347197f, 0.03119996f, 0.03649237f, 0.05745005f, -0.03398369f, 0.00823176f, 0.02538315f, -0.05353894f, 
    -0.03167455f, 0.06222522f, -0.02526855f, -0.00636855f, 0.06376416f, -0.05318558f, -0.06491185f, 0.02928544f, 
    0.06597181f, -0.02904975f, -0.02907283f, 0.03320154f, 0.03809106f, -0.00338430f, -0.02732213f, 0.04302262f, 
    -0.04832647f, 0.06067838f, 0.02510086f, -0.05173677f, 0.05566348f, -0.07053624f, -0.01634039f, 0.05877021f, 
    0.03868498f, -0.00001356f, 0.00674929f, 0.05717054f, -0.02778331f, -0.08515773f, 0.01539782f, -0.04443784f, 
    -0.06035101f, 0.00317448f, 0.05075485f, -0.00332591f, -0.06581677f, -0.00356121f, -0.03644146f, -0.02072456f, 
    0.06510998f, 0.03137190f, -0.05656892f, 0.05558340f, -0.04427912f, -0.01439472f, -0.04692144f, 0.00090813f, 
    -0.06308790f, -0.04879510f, 0.00109180f, 0.00880336f, 0.06764864f, 0.03010895f, 0.00888272f, -0.07716476f, 
    0.04334440f, 0.00801428f, -0.03494418f, 0.01153215f, 0.01225406f, -0.04966811f, -0.05236754f, 0.05650101f, 
    -0.01329659f, -0.05660982f, -0.03327268f, -0.03485596f, -0.01815555f, 0.01534724f, -0.04130350f, -0.03672294f, 
    -0.01241361f, -0.05202774f, 0.00415426f, -0.06926525f, -0.04848499f, 0.00404870f, 0.00360334f, -0.01306388f, 
    -0.08142746f, -0.02581827f, 0.03492573f, -0.07177857f, 0.02831895f, 0.05356487f, -0.05150671f, 0.00636050f, 
    -0.05872407f, 0.02058776f, -0.03544276f, -0.05788926f, -0.04064424f, 0.01010815f, 0.01886800f, 0.03202101f, 
    0.23196603f, 0.05161735f, 0.07033753f, 0.18296127f, 0.10100643f, 0.03027922f, 0.11599120f, -0.02238228f, 
    0.03722446f, 0.10245415f, 0.02008825f, -0.05621034f, 0.10723805f, 0.29473180f, -0.03825879f, 0.13431619f, 
    -0.05316827f, -0.03254829f, -0.03478416f, -0.03572372f, 0.02213384f, -0.03290201f, 0.07903673f, 0.16124359f, 
    -0.05942416f, 0.15368842f, 0.17909563f, 0.04134536f, -0.07848290f, -0.01956398f, 0.04447164f, 0.05187373f, 
    -0.06713311f, -0.07385592f, 0.04956965f, -0.03736885f, -0.23930900f, 0.18712702f, -0.07968374f, -0.09789962f, 
    0.07297371f, -0.10878965f, 0.07903621f, 0.01292750f, 0.07491948f, -0.10418750f, -0.04679422f, 0.03033855f, 
    -0.06459794f, -0.15017420f, 0.21302803f, -0.25258240f, 0.24986111f, -0.02522525f, -0.01414025f, 0.02273902f, 
    -0.13263659f, 0.02427758f, -0.03286344f, 0.08801659f, 0.27098718f, -0.17836043f, 0.00957409f, 0.09099367f, 
    0.15056300f, -0.04942865f, 0.01970109f, -0.08344726f, 0.01586414f, 0.08083241f, 0.11208122f, 0.10920300f, 
    -0.18153489f, 0.14980522f, 0.06271922f, 0.20278022f, -0.15217251f, 0.04733502f, -0.05485404f, -0.01443007f, 
    0.00497595f, -0.00795524f, 0.03393199f, 0.07218258f, -0.00583960f, 0.01546724f, 0.08571997f, -0.32931986f, 
    0.13643359f, 0.03293613f, 0.01500118f, -0.09892371f, 0.13022774f, 0.02888461f, -0.00651575f, -0.00276228f, 
    -0.12817840f, 0.13614452f, -0.13147986f, 0.25523847f, 0.10669443f, 0.07541100f, -0.04472694f, 0.14816360f, 
    0.10072260f, -0.00552169f, -0.07492431f, 0.01621985f, 0.31690654f, -0.08434705f, 0.03441636f, -0.14555059f, 
    0.05710159f, 0.02517660f, 0.05584782f, -0.02075743f, -0.02751614f, 0.01639251f, 0.00462817f, -0.07044280f, 
    -0.07945368f, -0.04103456f, -0.19412312f, 0.15161791f, 0.05588870f, 0.12645285f, -0.04975453f, -0.03866744f, 
    -0.01889838f, 0.03677104f, 0.00888178f, -0.02684549f, 0.08289197f, -0.15743279f, -0.06391633f, -0.07329586f, 
    0.15566774f, 0.02106501f, -0.05560467f, -0.06698044f, 0.13413526f, -0.04701349f, 0.04097014f, -0.01779005f, 
    -0.30488467f, 0.27761921f, 0.01385149f, 0.42491794f, -0.05924203f, -0.01141704f, -0.08880775f, 0.04101659f, 
    0.10572728f, -0.00222540f, -0.00035798f, -0.00249864f, -0.16926523f, 0.01182201f, 0.02820302f, -0.08965484f, 
    0.22607365f, -0.01570665f, -0.01004748f, -0.09015645f, 0.11814346f, -0.01808445f, 0.08320060f, -0.02716768f, 
    0.14412843f, 0.03810171f, -0.12343954f, -0.00746162f, 0.11743775f, 0.04853181f, 0.04153246f, -0.04395194f, 
    0.02467442f, 0.02236166f, -0.02556538f, 0.11442738f, 0.14376080f, -0.09873682f, 0.17231712f, -0.07164282f, 
    0.05171753f, 0.01436897f, 0.05112362f, -0.05408968f, 0.05625132f, 0.02906818f, 0.09222234f, -0.02841563f, 
    -0.14587766f, -0.25996786f, -0.08657522f, -0.10546044f, 0.08687513f, 0.03363102f, 0.15633956f, 0.10263416f, 
    0.28923389f, 0.08874077f, 0.01092230f, 0.33962306f, -0.76363546f, -0.37748715f, 0.27137581f, 0.01042017f, 
    -0.22112010f, -0.04163975f, 0.01674858f, 0.06541220f, 0.21489619f, -0.11006217f, -0.12433852f, -0.05140599f, 
    -0.42561769f, -0.11249266f, -0.07990929f, 0.04171325f, -0.23593132f, -0.18299960f, 0.10494699f, 0.22587070f, 
    0.02822980f, -0.02371222f, -0.26361734f, 0.03875362f, -0.03300644f, -0.16622767f, -0.08821198f, 0.23492914f, 
    0.01290196f, -0.12320966f, 0.03000221f, 0.17532504f, -0.05337781f, 0.00421544f, 0.09119672f, 0.17672467f, 
    -0.09489739f, 0.12062151f, -0.29824412f, 0.11767751f, -0.09991007f, 0.06352488f, -0.02565047f, 0.04455924f, 
    0.03982459f, 0.12825109f, 0.17409369f, -0.17239937f, 0.26731989f, 0.01010151f, 0.07916662f, -0.17438167f, 
    0.16045949f, 0.15187156f, 0.04202980f, 0.03128352f, 0.23349296f, -0.10646119f, -0.06398007f, 0.07591116f, 
    0.16899990f, 0.11190566f, 0.28857961f, -0.11739823f, -0.05701099f, -0.18369597f, -0.02448421f, 0.07620864f, 
    -0.10783535f, -0.24043764f, 0.04131194f, 0.03539834f, -0.08781105f, -0.01048426f, -0.29878977f, -0.01763547f, 
    0.07583106f, 0.10216323f, -0.07322731f, -0.08028234f, 0.00766319f, 0.00143319f, 0.13062057f, 0.15309441f, 
    -0.29451320f, 0.01004614f, 0.24449882f, -0.04444173f, -0.01610577f, -0.11160722f, -0.18391432f, 0.16855840f, 
    0.12745333f, -0.11547516f, -0.06702556f, 0.00279329f, -0.19054718f, 0.01921932f, 0.20986685f, 0.03952298f, 
    -0.10438146f, -0.02367819f, 0.01816909f, 0.18756621f, 0.02613772f, -0.04206416f, -0.07702291f, 0.06436508f, 
    -0.09960552f, -0.08774775f, 0.02636482f, -0.12358083f, 0.14475586f, 0.17711137f, 0.06703106f, 0.00873031f, 
    0.05583423f, 0.06078275f, 0.15777589f, -0.05633165f, -0.22924668f, 0.03343234f, 0.03903276f, -0.17832318f, 
    -0.04394866f, 0.31039044f, 0.11937302f, 0.00728214f, -0.02755014f, 0.08838446f, 0.04567875f, 0.03019202f, 
    0.21219054f, -0.12636550f, -0.00554335f, -0.08874410f, -0.13351515f, -0.00804276f, -0.18336153f, -0.09258656f, 
    -0.09976563f, -0.03720548f, -0.17515592f, -0.00393676f, 0.13329445f, 0.04745087f, -0.04475312f, 0.05143369f, 
    0.22399309f, 0.04723129f, 0.02474054f, 0.04297167f, 0.02112620f, -0.12346149f, 0.07872622f, 0.02620336f, 
    0.39087290f, 0.33956113f, 0.19298910f, -0.08129463f, 0.18814793f, 0.07319552f, 0.22904006f, -0.07010127f, 
    -0.11324899f, -0.10971648f, -0.00605880f, 0.02814824f, 0.06752679f, -0.19368841f, -0.53281522f, 0.07570207f, 
    0.02040653f, 0.04260485f, 0.02220615f, -0.00552803f, -0.05174483f, 0.25047317f, 0.03925345f, 0.13113126f, 
    0.10812617f, 0.09533891f, 0.17760405f, 0.14605479f, 0.04265147f, 0.03573315f, -0.08536699f, 0.05362439f, 
    -0.08230076f, -0.11840611f, 0.04672094f, 0.04319604f, 0.34247303f, 0.18676358f, 0.20571320f, 0.31361422f, 
    0.21402347f, 0.01171819f, 0.05309022f, -0.09949710f, -0.18526034f, -0.04256047f, 0.00965160f, -0.07536788f, 
    -0.29872099f, 0.06756901f, 0.01802742f, 0.18673582f, 0.08715101f, 0.11267918f, 0.05687805f, 0.07891726f, 
    0.03920473f, 0.05657775f, 0.00291253f, 0.10214055f, -0.21252729f, 0.23834230f, 0.13859618f, 0.17489322f, 
    0.06902884f, -0.09920783f, 0.05067366f, -0.02879157f, -0.03463068f, -0.05507077f, 0.12194212f, 0.19737732f, 
    -0.03258295f, 0.05580163f, -0.30396116f, -0.33961073f, -0.02409526f, -0.13144179f, -0.12075121f, 0.10757028f, 
    0.21157154f, 0.15759599f, 0.01457648f, 0.11988577f, -0.21323976f, -0.18036127f, -0.10189382f, -0.11452762f, 
    -0.15212549f, 0.05816523f, -0.13236025f, -0.14218342f, -0.07329556f, -0.14836706f, -0.07604483f, -0.06468534f, 
    -0.19194606f, -0.00624603f, 0.21410832f, 0.37892866f, 0.19890936f, 0.11336496f, 0.09131616f, 0.06303586f, 
    0.01191068f, 0.08390951f, -0.09114395f, 0.22324684f, -0.03262164f, -0.07435638f, 0.01380420f, -0.11317711f, 
    0.19326359f, -0.18608883f, -0.24500884f, 0.03996233f, 0.07086892f, 0.01980100f, -0.01485113f, 0.17257430f, 
    -0.08808688f, -0.12941098f, -0.10948797f, 0.13583320f, 0.03755834f, -0.01239510f, 0.05457838f, -0.06153387f, 
    -0.09205232f, -0.06352556f, 0.12547176f, 0.12916443f, -0.18327959f, -0.07652953f, 0.11501608f, -0.09536209f, 
    0.01964958f, 0.08781356f, -0.00861575f, 0.05378865f, 0.09320331f, 0.04328319f, -0.11092830f, -0.05292873f, 
    -0.25688598f, -0.15753010f, 0.01851646f, -0.07563204f, 0.06098436f, 0.01703694f, -0.15411232f, 0.06045895f, 
    0.03351451f, 0.07331518f, 0.20014918f, -0.00376047f, 0.20032538f, -0.15267640f, 0.23680046f, 0.13444002f, 
    -0.09409826f, 0.00202817f, -0.06297108f, -0.21673657f, -0.00883383f, 0.08310650f, 0.04896021f, 0.05116569f, 
    -0.02808503f, -0.00821762f, 0.08986194f, 0.24288028f, 0.04641192f, -0.07331226f, -0.04128827f, 0.08189572f, 
    -0.19787842f, -0.01188303f, 0.05818036f, 0.37150916f, -0.05113976f, -0.06900626f, -0.14584918f, -0.12612030f, 
    -0.08932818f, -0.20624444f, -0.03132200f, -0.21606132f, -0.00983976f, 0.01434904f, -0.00228838f, 0.08189935f, 
    -0.60789543f, -0.28022987f, -0.37376136f, -0.37198019f, -0.04092547f, -0.16519289f, -0.10394579f, -0.01515512f, 
    0.03028773f, -0.10011677f, 0.06616797f, -0.06775171f, 0.22801995f, 0.04858738f, 0.21228470f, 0.16324167f, 
    0.09397263f, -0.04279670f, 0.07754511f, 0.07473938f, -0.09629368f, -0.15882808f, 0.06172370f, -0.03932615f, 
    0.02887175f, -0.03489137f, 0.00072589f, -0.17583606f, 0.08467655f, -0.11839045f, 0.02259446f, -0.05006127f, 
    0.01155129f, 0.10528409f, -0.01477817f, 0.11495964f, -0.14435895f, 0.17080127f, -0.12436598f, -0.32498178f, 
    0.18666184f, -0.04614065f, 0.19865413f, -0.05054518f, 0.14393570f, 0.05634148f, 0.07499164f, 0.10903472f, 
    0.05438577f, -0.10795790f, 0.04390023f, 0.16355368f, -0.04198753f, 0.01364889f, -0.19881915f, 0.00654871f, 
    0.08357432f, -0.10795826f, -0.21480577f, -0.03048538f, -0.00599271f, 0.10489219f, -0.01075259f, -0.20689951f, 
    -0.01852820f, 0.16405770f, 0.00848999f, -0.07922062f, 0.06124365f, -0.09724532f, 0.03755227f, 0.06108334f, 
    0.17320991f, 0.07303923f, -0.01886218f, 0.00299669f, 0.00365867f, -0.06210769f, -0.18890266f, 0.02411353f, 
    -0.05407855f, 0.19051005f, 0.03106033f, 0.11938506f, 0.03664009f, 0.19134578f, -0.10977983f, -0.08449285f, 
    0.03715816f, 0.08118013f, -0.02188598f, 0.03344236f, 0.02940351f, 0.09744432f, -0.04907057f, 0.08046313f, 
    0.00266063f, -0.03520330f, 0.12172091f, 0.13393997f, 0.00319565f, -0.11685780f, 0.01643506f, 0.08972528f, 
    -0.02482319f, 0.03217317f, 0.07080815f, -0.02029934f, -0.38456708f, 0.09528091f, 0.17605339f, 0.02278620f, 
    0.01228159f, 0.04901285f, -0.05550009f, -0.04033496f, -0.01755216f, 0.04285323f, -0.06377663f, -0.15024272f, 
    -0.34036863f, 0.23068282f, 0.17819777f, -0.08712938f, 0.11035173f, 0.03605383f, 0.01542988f, 0.11672515f, 
    0.14620465f, 0.05341532f, -0.11940268f, 0.03252171f, 0.10595001f, -0.04530431f, -0.23904410f, -0.25397766f, 
    0.01026302f, -0.10713177f, 0.09649565f, -0.05542339f, -0.09808906f, -0.11862451f, -0.10935820f, 0.16901922f, 
    -0.05056198f, -0.01052390f, -0.02773130f, 0.04475193f, 0.18076789f, 0.13041589f, -0.06220635f, -0.11226037f, 
    -0.00847265f, -0.00739777f, 0.10422412f, -0.02875662f, -0.10898850f, -0.18334320f, -0.10779022f, -0.05117722f, 
    -0.03510547f, 0.02816143f, 0.07397999f, 0.03601265f, 0.11906242f, 0.05162797f, 0.07313958f, 0.06769422f, 
    -0.23088047f, 0.07725592f, -0.12574184f, 0.16269769f, 0.03891281f, 0.04707047f, -0.02127670f, 0.03893338f, 
    0.07793398f, 0.11107663f, 0.04019759f, 0.07927176f, -0.01996619f, -0.09041092f, 0.07556318f, 0.10238009f, 
    0.15409772f, 0.02740005f, 0.04029083f, -0.00239359f, 0.02615652f, -0.12036297f, 0.11347958f, 0.07514974f, 
    0.23684005f, 0.27013874f, 0.15659672f, 0.05316936f, 0.09463163f, 0.03353273f, -0.05856420f, 0.02571779f, 
    -0.00615104f, -0.04328222f, -0.00256062f, 0.00840688f, 0.15888941f, -0.08159257f, 0.05630503f, -0.08575066f, 
    0.00783549f, 0.11739644f, 0.00022319f, -0.00281922f, -0.02847874f, -0.02993276f, 0.07681312f, -0.06069576f, 
    -0.02226040f, -0.06771713f, -0.06801050f, 0.05741643f, -0.04378351f, 0.06418697f, 0.05111582f, -0.02482552f, 
    -0.02325447f, 0.01970564f, -0.01698681f, 0.03660332f, -0.00271124f, -0.00974344f, -0.03444527f, -0.07277422f, 
    -0.04652280f, 0.02652111f, -0.03452232f, 0.04004506f, 0.02356279f, -0.06495879f, -0.03772150f, -0.06904668f, 
    -0.01997321f, 0.04851011f, 0.00518596f, 0.05021283f, -0.00838152f, -0.01909624f, 0.04354317f, 0.05581750f, 
    -0.04305917f, -0.02289606f, -0.05407972f, 0.00899287f, 0.05024242f, 0.04939137f, -0.05000530f, 0.05161171f, 
    -0.04777401f, -0.02138063f, -0.04967442f, -0.03328387f, -0.02887089f, -0.01172553f, 0.03993449f, -0.03813821f, 
    -0.04862312f, -0.06228741f, -0.06666345f, 0.04580517f, 0.02790079f, 0.00518261f, -0.07474022f, -0.04597597f, 
    -0.04913086f, -0.04345598f, 0.06152674f, -0.01456041f, 0.01815601f, 0.06232075f, -0.05929518f, 0.00296266f, 
    0.04033864f, -0.02211587f, -0.02574037f, -0.07388619f, -0.03951643f, -0.02161869f, 0.03823240f, -0.05232489f, 
    -0.03343154f, 0.04278127f, -0.01063754f, -0.04317780f, -0.04847988f, 0.00178980f, -0.06320657f, -0.04256331f, 
    -0.00237847f, -0.07549265f, -0.05202593f, -0.07149675f, -0.07461201f, -0.04122810f, 0.00512874f, 0.03151245f, 
    0.02894471f, 0.00194032f, 0.05055098f, -0.07256900f, 0.03139978f, 0.02273793f, 0.00690783f, -0.00467251f, 
    0.02598754f, 0.03398815f, -0.07845767f, 0.03923732f, -0.04600813f, -0.04403487f, 0.04081766f, 0.02031522f, 
    -0.02786007f, 0.05880004f, -0.03858774f, 0.02481638f, 0.01729980f, 0.01221893f, 0.00828999f, 0.03387332f, 
    -0.06640016f, 0.03584719f, 0.03901780f, 0.02810487f, 0.03092603f, -0.03700639f, 0.04661792f, -0.06742679f, 
    0.02029746f, 0.04718567f, 0.03223757f, -0.04200273f, -0.00755289f, -0.05369296f, -0.00380098f, -0.02677925f, 
    -0.04622497f, 0.05020196f, -0.01311524f, -0.06739432f, -0.02923428f, -0.07396824f, -0.03210840f, 0.00876538f, 
    -0.07149090f, 0.03145824f, 0.03024188f, 0.00937424f, -0.02118677f, -0.02522261f, -0.02308032f, 0.00377846f, 
    -0.00977549f, -0.03860919f, 0.04128018f, -0.06928869f, -0.06058837f, 0.03395465f, -0.02548227f, 0.03015264f, 
    -0.00536195f, -0.04096071f, -0.05631052f, 0.02780565f, 0.01085165f, 0.03201369f, -0.07503511f, -0.02714700f, 
    0.01622855f, 0.00362515f, 0.01096113f, -0.03254975f, 0.04132085f, -0.03199920f, -0.07773872f, 0.04807822f, 
    0.01361776f, -0.02610822f, -0.06869053f, 0.02690667f, -0.02261492f, -0.05996700f, -0.06309541f, -0.01228478f, 
    0.01153079f, -0.01563915f, -0.05569850f, 0.04263137f, 0.04616287f, -0.05202653f, -0.05751212f, 0.01832831f, 
    -0.04270464f, 0.01579814f, 0.01966234f, -0.05257705f, -0.07261939f, -0.03191339f, 0.03477215f, -0.00680660f, 
    0.17368086f, -0.17983076f, -0.16739869f, 0.15985753f, -0.04204996f, 0.03437370f, 0.12613554f, 0.11042822f, 
    0.07475352f, 0.12205198f, -0.08792353f, 0.08011638f, -0.11373883f, -0.04786969f, -0.16837397f, 0.02459760f, 
    0.18366787f, 0.08905268f, 0.01773535f, -0.02103476f, 0.00791555f, 0.01009337f, 0.01372481f, -0.01691632f, 
    -0.02704151f, -0.34584528f, -0.23936120f, 0.05469185f, 0.14640871f, 0.10577847f, -0.04898877f, 0.01502851f, 
    -0.00239295f, -0.05673888f, 0.04983133f, -0.03170955f, -0.22234118f, -0.20506127f, 0.03888096f, 0.11033948f, 
    0.03631499f, 0.13016507f, 0.10191707f, 0.01259104f, -0.02985862f, 0.00116699f, 0.09086704f, 0.03833293f, 
    0.17004140f, 0.03759763f, 0.08757449f, -0.01805441f, -0.03860270f, -0.01094242f, -0.15488233f, 0.06109139f, 
    0.10360096f, 0.14890279f, -0.14580689f, 0.05495232f, 0.35137731f, -0.04562201f, -0.07476047f, -0.06902254f, 
    -0.10014186f, 0.06726252f, -0.04842540f, 0.01066263f, 0.09144884f, -0.06180188f, 0.07407998f, 0.08755071f, 
    -0.07888112f, -0.30894682f, -0.20672198f, -0.09047800f, 0.13864826f, 0.02759838f, 0.05553755f, 0.06448156f, 
    0.00924437f, 0.10636322f, -0.09041349f, -0.26730597f, 0.04535194f, 0.21465695f, 0.15681796f, -0.12925555f, 
    -0.00685149f, 0.07009870f, 0.03799751f, 0.07539139f, -0.04588390f, -0.04188477f, 0.28553364f, 0.12891747f, 
    -0.26115885f, 0.05573121f, 0.19582756f, 0.00572804f, -0.03483640f, -0.20751879f, 0.02705781f, -0.03550884f, 
    0.22573358f, -0.12458644f, 0.05107924f, -0.12694968f, -0.17812121f, -0.13423364f, -0.21901321f, 0.17310725f, 
    0.03560419f, -0.00440852f, 0.07028791f, -0.07951052f, 0.02046495f, -0.11810192f, -0.05440670f, -0.08136848f, 
    0.35483325f, 0.30148616f, 0.15385562f, 0.13936199f, -0.06411186f, -0.10790098f, 0.02899700f, -0.18873365f, 
    -0.09183630f, 0.03311690f, 0.06208716f, 0.10859852f, 0.14819272f, 0.24857472f, -0.09672945f, 0.24440764f, 
    -0.19839104f, -0.17031781f, 0.03085067f, 0.01439062f, -0.11329985f, 0.00643053f, 0.11392309f, 0.06207535f, 
    -0.06711787f, -0.19289926f, 0.10348714f, -0.00803110f, 0.04293599f, 0.15043084f, 0.11966701f, 0.02717292f, 
    -0.07185333f, 0.03151115f, -0.00408911f, -0.07783113f, 0.11915400f, 0.16864246f, 0.10911112f, -0.03122265f, 
    -0.00469760f, 0.12099629f, 0.02627218f, 0.00651973f, 0.01774404f, 0.16636308f, 0.12977503f, 0.03612374f, 
    -0.00501931f, 0.10518602f, 0.31309983f, 0.05336373f, -0.08427464f, 0.01302790f, 0.11255225f, 0.03329060f, 
    0.01477282f, -0.06006607f, 0.06170676f, 0.15780094f, -0.09020815f, 0.10161828f, -0.07155686f, -0.01228136f, 
    0.08607256f, 0.08411367f, -0.15848987f, 0.01201963f, 0.03478668f, -0.11026464f, -0.04732363f, -0.05055064f, 
    0.06652766f, -0.11310568f, 0.10780965f, -0.06150238f, 0.14133534f, 0.10444012f, 0.12910628f, 0.07705171f, 
    0.04617013f, 0.14390939f, -0.02041180f, 0.17878307f, -0.13738003f, 0.16176553f, 0.07498926f, 0.11138515f, 
    0.03864966f, 0.00571971f, -0.01784615f, 0.05923273f, 0.02615905f, -0.04072887f, -0.02602093f, -0.10141583f, 
    -0.26813713f, -0.03173855f, -0.08803727f, 0.12393887f, 0.09085923f, 0.07028327f, -0.03398404f, 0.18674615f, 
    0.15793899f, -0.06051704f, -0.05125061f, 0.13845477f, 0.07748733f, -0.06521124f, 0.00832306f, -0.04652230f, 
    0.05800538f, -0.04246376f, -0.10733612f, 0.09393518f, 0.09714938f, -0.05696665f, 0.03452063f, 0.10483433f, 
    -0.02092886f, 0.34094363f, -0.06260497f, -0.06287882f, 0.02457588f, 0.00980086f, -0.03733473f, 0.04564686f, 
    -0.13512167f, 0.03379100f, 0.00736990f, 0.01691493f, 0.05267421f, -0.00281056f, -0.05249668f, -0.03898419f, 
    -0.09728495f, 0.11072057f, -0.03697018f, 0.06571360f, 0.07045545f, 0.00604147f, -0.02873584f, -0.05723403f, 
    0.00594178f, 0.07789379f, 0.09121773f, 0.10601109f, 0.04882370f, -0.02277682f, -0.04711344f, 0.12457196f, 
    0.02545344f, -0.02411648f, 0.06496582f, -0.14861006f, -0.01873462f, 0.00152867f, -0.10254881f, -0.14610052f, 
    -0.11260085f, 0.10299739f, -0.05280495f, 0.00472830f, -0.03536067f, -0.01897954f, 0.20996872f, -0.02516428f, 
    -0.25520334f, 0.03533627f, 0.21932858f, -0.05364347f, 0.13214698f, -0.02500144f, -0.04889842f, 0.04163989f, 
    0.06653287f, 0.08731090f, -0.04489275f, -0.10221915f, -0.19976553f, 0.08314479f, -0.04389237f, -0.12032562f, 
    0.08904237f, 0.07767814f, -0.09029524f, 0.06773244f, 0.05179701f, -0.16274570f, -0.06094846f, -0.00676772f, 
    -0.22830245f, 0.01073062f, 0.03478013f, -0.04221374f, 0.03259350f, 0.13841996f, 0.01205484f, 0.03227528f, 
    -0.13127275f, -0.06908067f, 0.14542325f, 0.05815855f, -0.27209035f, 0.06982587f, -0.03404739f, -0.04264922f, 
    -0.16279870f, -0.05276978f, 0.01097845f, -0.01945370f, -0.12028097f, 0.08701711f, -0.03389072f, -0.02421040f, 
    0.12570389f, -0.20549187f, 0.19365993f, 0.10943874f, -0.07395218f, 0.03156732f, 0.01045617f, -0.02756463f, 
    -0.08497351f, -0.03269812f, -0.02442292f, -0.05190461f, -0.04779111f, 0.05244641f, 0.06678921f, -0.00152487f, 
    0.07386383f, 0.05066334f, 0.01838773f, 0.06431488f, 0.06714550f, -0.02741975f, 0.03743471f, 0.12354746f, 
    -0.14043745f, 0.27068177f, 0.20439625f, 0.04039704f, 0.01655999f, 0.08491428f, 0.08236425f, -0.08869950f, 
    -0.07207304f, -0.16550687f, -0.00298873f, 0.05942031f, 0.59431607f, -0.06943715f, -0.20494083f, 0.13158779f, 
    0.15831232f, 0.05017549f, 0.03927216f, 0.01279927f, -0.10885217f, -0.15800430f, -0.00338028f, 0.04747000f, 
    -0.06319098f, 0.04625550f, 0.08433906f, 0.05106684f, 0.13326038f, 0.07125869f, 0.09718481f, 0.01177900f, 
    -0.08457022f, 0.22588030f, 0.03961081f, 0.16577244f, 0.12129048f, 0.05795705f, 0.11290208f, 0.01818048f, 
    -0.00450291f, -0.02565326f, -0.02515439f, 0.12082650f, 0.10545161f, 0.10615861f, 0.09155460f, 0.18372442f, 
    0.08802174f, -0.03151358f, -0.10214285f, -0.02840642f, 0.03920633f, 0.02120471f, -0.02025921f, 0.00159566f, 
    -0.06445405f, 0.02096534f, -0.15272833f, 0.07108127f, 0.01284716f, -0.08548945f, 0.09894326f, 0.00655018f, 
    0.14681840f, -0.10037626f, -0.12571557f, 0.04795697f, 0.08735722f, 0.11624077f, -0.01648364f, -0.09183561f, 
    -0.22224076f, -0.01368105f, 0.05198517f, -0.14758891f, -0.01014369f, -0.08483081f, -0.01566364f, 0.01030834f, 
    -0.02420777f, 0.02665068f, -0.00730782f, 0.08665556f, -0.35520884f, 0.27227664f, -0.03527330f, -0.05382491f, 
    -0.06307846f, -0.00105075f, -0.06011789f, -0.00948931f, 0.11485469f, 0.05093023f, -0.02862977f, 0.11110182f, 
    -0.02423267f, -0.12583855f, -0.12229668f, -0.06580733f, -0.09917709f, -0.00960951f, -0.06046498f, 0.02779930f, 
    -0.02653216f, 0.04634313f, -0.00351380f, -0.02391957f, -0.04870581f, 0.21117422f, 0.19942355f, -0.03526024f, 
    -0.13156770f, 0.11375802f, 0.08128390f, 0.00582985f, -0.11381991f, -0.09019609f, 0.10861088f, -0.09090076f, 
    -0.16071120f, -0.17879848f, 0.11180647f, 0.12405863f, -0.06096682f, -0.09525966f, -0.00705248f, 0.01160701f, 
    0.11817345f, 0.07901880f, -0.11321601f, -0.00091284f, 0.04860573f, 0.05608336f, 0.07799470f, -0.10345189f, 
    0.08600985f, -0.01839438f, -0.10061246f, 0.11101166f, -0.10837314f, -0.06677394f, -0.01302343f, 0.06657235f, 
    -0.08634509f, -0.03394662f, -0.04431207f, 0.16811442f, 0.02932212f, 0.12519981f, 0.11674732f, -0.00974620f, 
    -0.03178205f, 0.00044917f, 0.05227177f, 0.02168918f, -0.18148708f, -0.04268509f, 0.09132237f, 0.03950011f, 
    -0.12557174f, 0.01571506f, -0.07201231f, -0.03107752f, -0.05296115f, -0.01484926f, -0.09361048f, -0.01062846f, 
    -0.21626969f, -0.21433340f, 0.06150913f, 0.03277279f, 0.00549656f, 0.13055244f, 0.12671444f, -0.05462969f, 
    0.10352981f, 0.02049731f, -0.00241248f, -0.01355363f, 0.04532830f, -0.15946995f, 0.24599816f, -0.00292251f, 
    0.02881598f, -0.01294356f, -0.13757937f, -0.01751378f, 0.13446707f, -0.04170790f, 0.00995979f, 0.03333697f, 
    0.01209734f, -0.01208301f, 0.04858319f, 0.22133116f, 0.02991969f, -0.02163562f, 0.06253127f, -0.10243557f, 
    -0.01912462f, 0.01969691f, -0.01900897f, 0.01235744f, 0.38262239f, 0.20574650f, -0.08521957f, 0.09619963f, 
    0.07587401f, 0.13534580f, 0.04973142f, 0.04895279f, -0.02449837f, -0.00850559f, -0.02124760f, 0.04435373f, 
    -0.13199544f, -0.03901954f, -0.00020454f, -0.00593414f, -0.13850662f, 0.09692831f, -0.06649192f, -0.01752618f, 
    0.00905606f, -0.10749228f, -0.07136560f, 0.00020569f, -0.25391871f, -0.18641669f, 0.14774363f, -0.19295767f, 
    0.04233677f, 0.16114165f, 0.16711828f, -0.01851917f, -0.11955080f, 0.00226490f, -0.08393556f, -0.02348173f, 
    -0.07699572f, -0.05471617f, -0.14283432f, -0.01682180f, 0.06699745f, -0.04191130f, -0.03248666f, -0.00530890f, 
    0.01440970f, 0.04605708f, 0.16428751f, 0.06935325f, 0.28069550f, -0.20596169f, 0.02324486f, 0.05671287f, 
    0.06383074f, 0.01661290f, -0.00073814f, 0.06291159f, -0.13820909f, -0.09371314f, 0.02943424f, -0.04656918f, 
    0.10587836f, 0.20473522f, -0.24528264f, 0.38968623f, 0.04717756f, 0.17600556f, -0.00885673f, 0.15031229f, 
    0.02154181f, 0.07982408f, 0.06925438f, 0.07732387f, -0.12995510f, 0.03701385f, 0.07081853f, -0.06167793f, 
    -0.01754858f, 0.03292688f, 0.03783956f, 0.02827147f, -0.07498469f, -0.02766291f, -0.00214506f, -0.05964231f, 
    0.15828277f, -0.09921395f, 0.13052537f, -0.12166473f, 0.11878907f, -0.02651333f, 0.13765791f, 0.09209327f, 
    0.06340595f, 0.00122028f, -0.06351846f, 0.09095403f, 0.11601048f, -0.18649304f, -0.05738942f, 0.29735646f, 
    -0.05997946f, -0.00403132f, -0.09295662f, 0.04042219f, -0.01714541f, 0.01239306f, -0.11457770f, -0.08544151f, 
    0.05852837f, -0.03051372f, 0.12702824f, -0.22270748f, -0.08983571f, -0.02157649f, 0.05992817f, -0.12690908f, 
    0.02830680f, 0.00183180f, 0.07313558f, 0.14193451f, -0.26497367f, 0.04037805f, 0.03577274f, 0.03476342f, 
    0.01242335f, 0.10668905f, 0.05566910f, 0.06417574f, 0.08864429f, 0.00682874f, 0.07551574f, 0.14401999f, 
    0.12137914f, 0.12701184f, 0.35844561f, -0.21171662f, -0.03830767f, -0.06206507f, -0.03470973f, 0.01938995f, 
    0.05793827f, -0.04103720f, -0.00648295f, -0.02129258f, -0.19570322f, 0.18707284f, 0.06548178f, -0.01281139f, 
    0.10448913f, 0.12703425f, 0.10380898f, -0.07871825f, -0.08308061f, -0.06080819f, -0.01593086f, 0.07155469f, 
    0.23722497f, -0.16307014f, -0.03103457f, -0.18631527f, 0.17343162f, -0.10014883f, 0.13812806f, 0.11707527f, 
    -0.09322488f, -0.11215311f, 0.10091919f, 0.00658784f, 0.22420071f, 0.18451890f, -0.07709223f, -0.05358455f, 
    -0.20267384f, 0.05665435f, 0.08096262f, 0.18198946f, -0.02289734f, 0.21314244f, 0.03254596f, 0.00484057f, 
    -0.01216866f, 0.05335039f, -0.05797592f, -0.00006388f, -0.14944556f, -0.00115876f, -0.04633569f, 0.10953929f, 
    0.14376804f, 0.10408892f, -0.00988861f, 0.03748735f, -0.05143905f, 0.00651446f, -0.15266614f, 0.09805535f, 
    -0.08110018f, 0.01217882f, -0.08449150f, 0.06089888f, 0.05478010f, 0.07803997f, 0.01899388f, -0.10782387f, 
    -0.15054765f, 0.09553365f, -0.03187728f, 0.07896669f, 0.08824824f, -0.00990482f, -0.03125869f, 0.01614339f, 
    0.02304588f, -0.06425305f, -0.07118370f, 0.08301303f, -0.04502778f, 0.01864051f, 0.23226348f, 0.10188454f, 
    0.08854803f, 0.06629295f, 0.02420786f, 0.12550601f, -0.06135168f, 0.13075913f, 0.01854875f, 0.09823153f, 
    0.15527776f, -0.01903653f, -0.08765107f, -0.01371032f, 0.05579432f, 0.09648810f, 0.01338320f, -0.05051160f, 
    -0.07782756f, 0.08209737f, -0.11473936f, 0.06947128f, 0.26919761f, -0.08922813f, -0.06406695f, -0.03987052f, 
    -0.08947875f, 0.07145310f, -0.17122316f, 0.05892399f, -0.00783440f, 0.00021642f, 0.07023760f, 0.04497040f, 
    -0.05413377f, 0.16543363f, -0.05903257f, 0.12124531f, -0.11307722f, 0.10847540f, 0.03243678f, 0.01690070f, 
    0.08684040f, -0.01007719f, 0.08281162f, 0.04769680f, -0.24946684f, 0.08035209f, 0.02577001f, -0.11081152f, 
    0.03449846f, 0.00762925f, 0.06347749f, -0.07477260f, -0.04876167f, -0.03218231f, -0.02199983f, -0.03848592f, 
    0.05631796f, 0.01220727f, -0.00572394f, -0.08107933f, 0.11827485f, -0.00668879f, -0.03354882f, 0.06585519f, 
    0.13627976f, 0.08683392f, -0.00947870f, 0.14280686f, 0.10740528f, -0.03150035f, -0.01225761f, 0.35401380f, 
    -0.14926952f, 0.18910347f, 0.03456856f, 0.00739931f, -0.13055950f, 0.01681472f, 0.03508615f, -0.10468161f, 
    0.22091697f, -0.16477017f, 0.08143013f, 0.03338166f, 0.00650764f, -0.04576512f, 0.04087480f, -0.00129514f, 
    -0.10980705f, 0.14360261f, -0.03752985f, 0.02339218f, 0.12692335f, 0.27278543f, 0.01525388f, -0.04832603f, 
    0.03508153f, 0.01072613f, 0.02300090f, 0.17243859f, -0.12603456f, -0.07932153f, -0.04232855f, 0.04144344f, 
    -0.05124344f, 0.14711772f, -0.02145628f, 0.05912530f, -0.11811680f, 0.00640281f, 0.15953782f, 0.00578026f, 
    0.01337820f, -0.03829682f, -0.04663835f, -0.05654828f, -0.19910657f, 0.05635801f, -0.07304500f, 0.07194998f, 
    -0.24768178f, -0.05852908f, -0.06789134f, 0.00721366f, -0.08145145f, 0.02150693f, -0.08897751f, 0.08897126f, 
    0.14067684f, -0.29212853f, 0.10897523f, -0.30334395f, 0.03507994f, -0.00774988f, 0.07168679f, 0.07706083f, 
    -0.01227073f, -0.14788364f, 0.00621431f, 0.03778714f, 0.23001534f, -0.01986785f, 0.24996816f, 0.24490561f, 
    -0.16779105f, -0.00270062f, -0.00294873f, 0.03070622f, -0.09041639f, 0.02594636f, 0.00451484f, 0.11468691f, 
    -0.05925598f, 0.17396198f, 0.07472461f, 0.31144318f, -0.14282843f, 0.02130805f, 0.03831752f, -0.08647719f, 
    -0.05457792f, 0.01084119f, -0.03819231f, 0.05588570f, 0.18284689f, -0.10453218f, -0.03170604f, 0.10204861f, 
    0.01418353f, 0.02265441f, -0.01852155f, -0.02105694f, -0.04392128f, -0.08081078f, -0.08543742f, 0.02591388f, 
    0.01483843f, 0.19438162f, 0.16844064f, 0.05552763f, -0.01258052f, 0.05027969f, 0.11233834f, -0.09968055f, 
    0.01041839f, -0.09239947f, 0.00364498f, 0.11607961f, 0.06804445f, 0.18827440f, 0.34614268f, 0.02023967f, 
    -0.10931181f, 0.04594107f, 0.01735350f, 0.06051729f, -0.05308402f, 0.12243341f, 0.07564843f, 0.14640845f, 
    -0.23286292f, 0.32713842f, -0.14425226f, -0.10883543f, 0.25922391f, 0.05327573f, 0.07582093f, 0.17903994f, 
    -0.08405709f, 0.12839621f, 0.13873284f, 0.20887898f, 0.19454201f, -0.03984562f, 0.03079292f, 0.22031598f, 
    -0.00585377f, -0.07365363f, -0.13178088f, 0.00800181f, 0.22920203f, -0.03759759f, -0.05792897f, -0.12329087f, 
    -0.02897726f, 0.33113319f, -0.10295741f, -0.04292631f, 0.15416400f, 0.04082722f, -0.05778834f, -0.18360916f, 
    -0.20518667f, -0.14992617f, -0.08257911f, 0.04346467f, -0.30291182f, 0.05063225f, 0.15840112f, 0.10872220f, 
    -0.09051522f, 0.15332766f, -0.07699116f, -0.16315538f, 0.08722763f, 0.06216669f, -0.17164117f, 0.00010936f, 
    -0.03979753f, 0.27542263f, -0.25036722f, -0.10784731f, 0.10343079f, 0.09358401f, -0.01305625f, 0.00639595f, 
    0.07897941f, 0.02009304f, -0.06467900f, 0.09143432f, 0.09766459f, -0.04543688f, 0.04186173f, 0.13262814f, 
    0.01818807f, 0.09860537f, -0.33949795f, -0.08360713f, 0.04002582f, -0.05457667f, -0.09925351f, -0.03494807f, 
    0.29146770f, -0.17276600f, -0.18661512f, 0.06641663f, -0.08033778f, 0.10949316f, 0.02112761f, 0.10101640f, 
    0.00014923f, 0.06773105f, 0.22096306f, 0.15498614f, -0.18172608f, 0.22086668f, 0.16167396f, -0.04024508f, 
    -0.00285198f, -0.00489775f, -0.12142200f, 0.02015932f, 0.02369259f, 0.06050322f, 0.03235395f, -0.01069150f, 
    -0.10486341f, 0.10602277f, 0.14970660f, 0.11983775f, -0.07220523f, 0.14950763f, 0.07298858f, -0.25611305f, 
    0.03371146f, -0.12065516f, -0.08407018f, 0.10247318f, 0.11577066f, -0.02304985f, 0.13727537f, 0.10018400f, 
    -0.15070651f, -0.01604119f, 0.05120145f, -0.17307051f, 0.07883394f, -0.09547751f, -0.21479255f, -0.00970067f, 
    0.22618824f, -0.26082587f, 0.01545099f, -0.14355551f, -0.02260652f, -0.01832631f, 0.05891136f, -0.06833044f, 
    0.12019569f, 0.02499479f, -0.12674899f, -0.05316436f, 0.19626896f, -0.10339174f, -0.01367756f, 0.12808064f, 
    -0.10432439f, -0.12407488f, -0.17078759f, -0.24547800f, -0.05661185f, -0.11475781f, -0.00061527f, -0.04622061f, 
    -0.09888633f, -0.05194423f, -0.16716389f, -0.01703973f, -0.05404476f, 0.06135539f, 0.00883803f, -0.22298510f, 
    0.06188683f, -0.17784460f, -0.03593016f, -0.07232465f, 0.08771739f, 0.09693218f, 0.12546583f, 0.23787715f, 
    0.02715797f, -0.15316874f, 0.03887954f, -0.01819794f, 0.04759790f, 0.06437234f, 0.01358387f, -0.00592760f, 
    0.00965600f, -0.02731294f, -0.02833972f, -0.07334176f, -0.01053631f, 0.03708980f, -0.07677840f, -0.00348497f, 
    -0.00780265f, -0.01137761f, 0.00778379f, -0.04811273f, -0.01651686f, 0.06373596f, -0.07077510f, 0.06045847f, 
    -0.00643142f, -0.06108192f, 0.03169391f, 0.03816352f, 0.02726104f, -0.03626386f, -0.02131428f, 0.00745259f, 
    -0.04081577f, -0.07251669f, 0.01131230f, 0.05754822f, -0.06963880f, 0.02263786f, 0.01266196f, -0.05494798f, 
    0.03669212f, 0.02593828f, 0.04318750f, -0.04975758f, -0.07651978f, 0.03445316f, -0.07386316f, 0.02722478f, 
    0.05104892f, -0.04894762f, -0.03458377f, 0.03785734f, 0.03850634f, 0.06428939f, 0.01834585f, -0.04919430f, 
    -0.03074002f, -0.02573760f, -0.03393893f, 0.02068663f, 0.04887786f, -0.04311943f, 0.04118000f, 0.01329273f, 
    0.04933528f, -0.06151223f, 0.01476329f, 0.00234378f, 0.03749986f, 0.01137649f, -0.04695297f, -0.01035621f, 
    -0.02970908f, 0.00215065f, -0.04241259f, -0.06619013f, -0.00752712f, -0.06988600f, 0.03006696f, 0.05149375f, 
    0.01065169f, -0.06571906f, -0.02385597f, 0.04544585f, -0.02275292f, -0.03949401f, -0.03279775f, -0.06330763f, 
    -0.05501842f, 0.05162647f, -0.07514056f, 0.00618919f, -0.07201636f, -0.00370392f, -0.00409326f, -0.03608052f, 
    -0.05369359f, -0.03336271f, 0.03702463f, 0.03313863f, -0.05385167f, -0.02573039f, -0.01279333f, 0.00214822f, 
    -0.06637740f, -0.02505942f, -0.01978368f, 0.02284076f, -0.02855603f, 0.01315227f, 0.01465933f, 0.06310359f, 
    -0.02924902f, -0.02406172f, 0.03261563f, -0.01476816f, -0.07531420f, -0.07241318f, 0.03405467f, -0.02107011f, 
    0.03330434f, 0.03095139f, 0.02644414f, 0.01139129f, -0.07181755f, -0.04504669f, 0.00137443f, -0.00571356f, 
    -0.03710685f, -0.03069495f, 0.06541232f, -0.00387087f, -0.05179402f, 0.00490244f, 0.04468742f, 0.03968690f, 
    -0.04374674f, 0.02568926f, -0.07149383f, 0.04344314f, 0.01608913f, -0.07386546f, 0.03946945f, -0.05519196f, 
    0.00185365f, -0.03137289f, -0.05299632f, -0.02555122f, 0.06286420f, 0.05214385f, 0.01658752f, -0.05842021f, 
    0.05123470f, -0.05853485f, -0.04908654f, -0.02684223f, 0.01088832f, 0.03242899f, 0.01189334f, -0.02060310f, 
    -0.05384550f, 0.00701474f, -0.05558100f, 0.06566507f, -0.03578819f, -0.03094471f, -0.05108859f, 0.05283307f, 
    -0.05566052f, 0.05482399f, -0.05815023f, 0.04075352f, 0.03228315f, 0.06642585f, 0.02712608f, -0.07172221f, 
    0.01403741f, 0.06025564f, 0.01477727f, 0.02564408f, 0.00044296f, -0.05216973f, -0.01125344f, -0.07615963f, 
    -0.05585108f, -0.02045328f, -0.02814975f, 0.04930367f, 0.00473032f, -0.05376309f, 0.01111748f, -0.04009980f, 
    -0.00774055f, 0.03447690f, -0.01584983f, -0.01908898f, -0.04132568f, 0.01900123f, -0.06586967f, -0.03943857f, 
    0.05380172f, -0.10416912f, -0.09026776f, -0.16115554f, -0.00936398f, -0.00307083f, -0.01114776f, 0.06620397f, 
    0.10700326f, 0.18358430f, -0.14011942f, 0.17023222f, -0.09102415f, 0.01746966f, 0.06074752f, -0.05580320f, 
    0.09608302f, -0.03481183f, 0.16282791f, 0.01220135f, 0.12047413f, -0.09703384f, 0.02187009f, 0.02211382f, 
    0.12332410f, -0.07030372f, -0.12861356f, -0.09969772f, 0.03612980f, 0.13924806f, 0.05447268f, 0.11836709f, 
    0.16769320f, -0.07860301f, -0.03678386f, 0.03587299f, -0.10790167f, -0.07863560f, 0.07565263f, -0.03061687f, 
    -0.00592738f, -0.01576604f, 0.01147823f, 0.07771673f, 0.17429058f, 0.06888788f, 0.00605071f, 0.22074075f, 
    -0.26151115f, 0.28546494f, 0.08341131f, 0.16201289f, -0.09580790f, -0.15960796f, -0.05114667f, -0.01554670f, 
    -0.04275892f, 0.17026870f, -0.13335234f, -0.18734340f, 0.07730485f, 0.27506682f, -0.22927368f, -0.05893227f, 
    -0.12918127f, 0.04504047f, 0.05124393f, -0.08513858f, 0.07179224f, 0.03585758f, -0.04698753f, -0.15412973f, 
    0.22989649f, 0.14691071f, -0.05972906f, 0.09307519f, 0.11149507f, -0.06118771f, 0.02990461f, 0.00270085f, 
    0.00473148f, 0.01291662f, 0.01889703f, -0.17879160f, -0.16284131f, -0.03967930f, -0.18647352f, 0.08438058f, 
    0.15599409f, -0.03483723f, -0.09172834f, 0.13451949f, 0.01753615f, 0.13766439f, 0.16593030f, 0.13730840f, 
    -0.03328176f, -0.04057111f, 0.08347489f, -0.35387239f, 0.11939367f, -0.10638756f, -0.06084810f, -0.00829619f, 
    0.03821594f, -0.06325948f, 0.08825390f, -0.16326557f, -0.13774274f, 0.00119937f, -0.16606349f, 0.09550360f, 
    -0.00823572f, 0.00578378f, -0.04263595f, 0.01833471f, 0.06912813f, -0.02345116f, -0.10864539f, -0.05913187f, 
    0.27020144f, -0.06626166f, -0.09038179f, 0.07776295f, 0.01095378f, -0.00973459f, 0.04773302f, -0.19385017f, 
    -0.02796008f, -0.00680426f, 0.12847176f, 0.18652701f, 0.15560441f, 0.02711462f, -0.09115428f, 0.07089672f, 
    0.00379633f, 0.02630074f, 0.03871170f, 0.09104876f, 0.08613387f, 0.02118630f, -0.01730951f, 0.08892834f, 
    0.20459069f, 0.08069062f, -0.07906124f, -0.13551219f, 0.08084352f, -0.03754376f, -0.12334541f, -0.14896865f, 
    -0.00850639f, -0.01610921f, -0.09125377f, 0.01167088f, 0.20342749f, -0.04135372f, 0.02742579f, 0.28739002f, 
    0.02894066f, 0.08271267f, -0.01917840f, -0.02211234f, 0.13879880f, -0.02157602f, 0.09551111f, 0.00112625f, 
    0.18567730f, -0.12075247f, 0.26095489f, 0.14570455f, 0.00617108f, 0.00981786f, -0.01493413f, -0.15654254f, 
    0.02080369f, -0.01572608f, 0.02962443f, 0.04310915f, -0.13774288f, 0.21644486f, -0.04366366f, -0.08857788f, 
    0.02065621f, -0.00540418f, -0.10330591f, 0.02467445f, -0.05666560f, -0.03541036f, -0.09654494f, 0.03113689f, 
    -0.06983049f, 0.00251849f, -0.14676821f, -0.07914334f, 0.10541085f, 0.06909904f, -0.02315362f, 0.12794819f, 
    -0.00702438f, 0.11522700f, -0.08818541f, 0.00986002f, -0.13422213f, 0.06808798f, 0.15890153f, 0.05664553f, 
    0.10208888f, -0.09392498f, -0.03011101f, 0.08895024f, -0.11612102f, 0.00144434f, 0.02419090f, 0.03915416f, 
    0.21731900f, -0.09196658f, 0.05667761f, -0.10809103f, 0.10229110f, 0.18078841f, -0.01510191f, 0.04142272f, 
    -0.07846364f, 0.01693019f, -0.21103410f, 0.04489015f, 0.02680757f, -0.09986620f, -0.04476655f, -0.03534968f, 
    -0.13436651f, 0.05488922f, -0.02268936f, 0.09594028f, 0.12597749f, 0.09719599f, 0.00930647f, 0.09223007f, 
    0.06331154f, -0.03878123f, 0.08902765f, 0.21275063f, -0.18292962f, 0.00066944f, 0.05796026f, -0.04173062f, 
    0.09513132f, 0.03781407f, 0.08315779f, -0.18633398f, -0.04703846f, 0.13207749f, -0.06592047f, -0.06372136f, 
    0.01879585f, -0.06750757f, 0.11490782f, -0.07142917f, 0.04557424f, 0.01474772f, -0.00309552f, -0.07322472f, 
    0.20035228f, 0.08551265f, -0.06338163f, -0.15495455f, 0.07450619f, -0.01599023f, -0.14664015f, -0.03778532f, 
    0.04429026f, -0.00490866f, 0.12561607f, 0.12247748f, 0.16964167f, -0.10042975f, -0.11894619f, 0.22178386f, 
    0.00438324f, -0.05278339f, 0.02009948f, 0.04642594f, -0.12715404f, 0.10042470f, 0.01691926f, 0.09318782f, 
    0.34670261f, -0.06675722f, 0.05756078f, -0.07644070f, -0.00035775f, -0.10462755f, 0.04762379f, 0.06047968f, 
    -0.05608708f, 0.08973756f, 0.00338976f, -0.04834504f, 0.14602716f, 0.16996792f, -0.02793052f, 0.09512928f, 
    -0.00997622f, 0.02931344f, 0.11437830f, 0.07612081f, -0.11121312f, 0.01543662f, 0.00902955f, -0.01689372f, 
    0.11488648f, 0.12080818f, -0.14988406f, 0.20450410f, -0.03280360f, -0.11321882f, 0.09654705f, 0.05086957f, 
    -0.10416826f, -0.09316210f, 0.07409599f, 0.01867198f, -0.09585121f, 0.18704654f, -0.07362999f, 0.06823211f, 
    -0.11412463f, -0.02090755f, -0.04910405f, 0.14523526f, -0.03155725f, 0.06777599f, 0.04435710f, 0.02915496f, 
    0.05914536f, 0.01117472f, 0.03435573f, -0.26346034f, 0.11174688f, 0.02087565f, 0.00799258f, -0.09395500f, 
    0.00058491f, -0.00076908f, 0.03379098f, 0.05894796f, 0.21199907f, -0.12296113f, 0.11274274f, 0.14164968f, 
    -0.09973036f, 0.00979577f, -0.07035700f, 0.10659162f, -0.09251257f, -0.06937949f, 0.08279487f, -0.04026400f, 
    0.02746201f, -0.02530332f, 0.16017176f, 0.35123238f, -0.10666741f, 0.00044468f, 0.02380317f, -0.16302252f, 
    0.05514975f, 0.08935787f, 0.01220476f, 0.05396950f, -0.05607043f, -0.08988488f, 0.07544182f, -0.05099711f, 
    0.11374035f, 0.06378735f, -0.10228872f, -0.06784917f, -0.00874725f, 0.05387362f, 0.00674906f, 0.09853838f, 
    -0.00381377f, -0.05683155f, 0.02823981f, 0.16993716f, -0.10498799f, 0.15061270f, 0.08591759f, -0.05722043f, 
    0.02083305f, 0.08397757f, 0.02134228f, -0.02452477f, -0.23381500f, -0.02183613f, 0.08639354f, 0.29688758f, 
    -0.33165124f, 0.03280226f, -0.23024058f, 0.04345452f, -0.01252342f, -0.09224845f, -0.07969973f, -0.06583710f, 
    -0.50604939f, 0.17056811f, -0.04314340f, -0.14385331f, 0.24256657f, 0.02762632f, 0.02107547f, 0.06671353f, 
    -0.02346303f, 0.12029107f, 0.09664249f, 0.04968929f, 0.06823055f, 0.06638922f, 0.13712160f, 0.36638942f, 
    -0.01882429f, -0.19176200f, -0.02851743f, 0.01460468f, 0.11210114f, -0.09535548f, -0.05616834f, 0.05478588f, 
    0.03801143f, 0.13196415f, -0.06996782f, -0.10347117f, 0.27028981f, 0.00793184f, -0.00756093f, 0.06085971f, 
    -0.10088766f, -0.07933226f, -0.00603531f, -0.00552876f, 0.09164701f, -0.31971884f, -0.00124577f, 0.23780173f, 
    -0.12073505f, 0.04703410f, -0.10518461f, 0.08220949f, -0.08211219f, -0.03239162f, -0.02874927f, 0.03439125f, 
    -0.15185519f, 0.19718327f, -0.20197810f, -0.08935998f, 0.11843099f, 0.24883395f, 0.00415203f, -0.07858299f, 
    0.08759318f, -0.09344332f, -0.03547684f, 0.07460774f, 0.22097978f, -0.12072901f, -0.13021457f, -0.18000025f, 
    0.12952548f, -0.05862924f, -0.06441829f, -0.05757632f, 0.10346842f, 0.07062000f, 0.03483750f, 0.10025280f, 
    0.29259443f, -0.03819105f, -0.08401942f, 0.01047788f, 0.03763094f, 0.01263278f, 0.08994963f, 0.00955440f, 
    -0.00746409f, -0.01144167f, 0.03728193f, 0.07429527f, -0.33053821f, -0.11868344f, 0.14710048f, 0.15082246f, 
    0.06938432f, -0.03232209f, 0.03499214f, -0.11294374f, 0.12674555f, 0.12267695f, 0.07915115f, -0.09751570f, 
    0.03549215f, 0.20860606f, -0.00878800f, 0.04654617f, 0.07223340f, -0.07390750f, -0.00075532f, -0.06389792f, 
    0.04941798f, 0.00767703f, -0.03214756f, 0.04209980f, 0.16675736f, 0.18425271f, 0.23361951f, 0.17857602f, 
    0.09098812f, -0.15475327f, -0.04235884f, 0.08971741f, -0.08073652f, -0.09738720f, 0.01543884f, -0.10659251f, 
    0.31705874f, 0.01267121f, -0.01987046f, -0.06300014f, 0.00009482f, -0.14048888f, -0.02249275f, -0.07565002f, 
    -0.02898003f, -0.00618080f, -0.03858306f, -0.08892724f, 0.14653644f, 0.17229819f, 0.01565301f, -0.12927987f, 
    -0.03726892f, -0.13724519f, -0.04575707f, -0.00758551f, -0.00305899f, 0.05830080f, 0.02835266f, 0.01840555f, 
    -0.00231524f, -0.10789840f, -0.09668649f, -0.11300296f, 0.02170762f, 0.11562759f, 0.14037974f, -0.02760237f, 
    0.04209520f, 0.00763300f, 0.03059761f, 0.03157134f, 0.02741383f, -0.24547142f, -0.04756964f, 0.14948636f, 
    -0.07424730f, -0.03472827f, 0.04900212f, 0.10273865f, -0.05501638f, -0.01337761f, 0.01369884f, 0.02619555f, 
    -0.17348610f, 0.06325628f, 0.04199375f, -0.14071301f, -0.07299864f, 0.06553565f, 0.03902251f, 0.07412221f, 
    -0.00920763f, 0.00236064f, -0.04170522f, 0.08420520f, -0.00673683f, -0.02308319f, 0.08688859f, -0.11486114f, 
    0.14581650f, 0.04035854f, 0.12744987f, 0.10179112f, -0.01346684f, 0.06191725f, -0.04612020f, 0.12522303f, 
    0.07141029f, -0.07007896f, -0.12933400f, -0.19269919f, 0.06500099f, 0.02090468f, 0.04609149f, -0.05594406f, 
    -0.03022577f, 0.09093677f, -0.09246982f, -0.00260105f, 0.20265700f, -0.20109719f, 0.09225006f, 0.14312050f, 
    -0.16042776f, 0.07308087f, 0.01256587f, 0.12796108f, 0.17962840f, 0.09076266f, 0.23199914f, 0.05779024f, 
    0.08929552f, 0.00358270f, -0.08188428f, 0.30085459f, -0.10206371f, 0.04365499f, 0.01222624f, -0.12532040f, 
    0.01800963f, -0.04257271f, -0.00388688f, 0.00536575f, -0.52313077f, 0.27504703f, 0.10003999f, -0.03450985f, 
    0.02061556f, 0.14796133f, 0.02843396f, -0.04472534f, 0.11228470f, -0.05592201f, -0.02581361f, 0.06275267f, 
    0.17766251f, -0.09163243f, -0.15307222f, -0.32316086f, 0.01477067f, 0.04632804f, 0.06644959f, -0.05144208f, 
    0.10893101f, -0.02577922f, 0.05407825f, 0.11861435f, 0.06630930f, -0.03806392f, 0.15542910f, 0.27034822f, 
    0.01820402f, -0.10376379f, -0.02266450f, 0.08999956f, 0.06539622f, 0.10417833f, -0.03894186f, 0.00480519f, 
    0.15958068f, -0.12119322f, 0.02073402f, -0.14131860f, -0.15304129f, 0.05600908f, 0.09059156f, -0.06544200f, 
    0.03821515f, 0.01813560f, -0.06772043f, -0.02990458f, -0.32662818f, 0.15302461f, -0.00845326f, 0.09827641f, 
    -0.05711761f, -0.01227613f, 0.06917833f, -0.00257585f, -0.07754365f, 0.07760947f, 0.04255944f, 0.12361883f, 
    -0.11539572f, -0.08938445f, 0.20128460f, -0.00984444f, -0.03199369f, -0.05605267f, -0.03607689f, -0.02293238f, 
    0.00134958f, -0.07040901f, 0.00183748f, 0.10077924f, -0.12897967f, -0.03945056f, 0.14753814f, 0.15593480f, 
    0.00292595f, 0.16466448f, -0.11545113f, 0.02529575f, 0.02291704f, -0.03636897f, -0.08641504f, 0.06837614f, 
    0.15674138f, -0.24184948f, -0.09330674f, -0.37891075f, 0.10558908f, 0.00592686f, 0.10065047f, 0.07055377f, 
    0.06190616f, -0.03666091f, 0.05066514f, 0.07200277f, 0.21926285f, -0.23496239f, 0.10465180f, 0.15875177f, 
    -0.13019538f, 0.11279235f, 0.01519144f, 0.08946734f, 0.01015679f, -0.05033943f, 0.05301786f, 0.13408677f, 
    -0.09312965f, -0.12662026f, 0.04560353f, 0.10333285f, -0.22098160f, 0.01999536f, -0.10926479f, -0.03912944f, 
    0.14516735f, -0.08125116f, -0.00751531f, 0.00886395f, -0.18046251f, 0.07300610f, 0.05487493f, -0.02995966f, 
    0.17569655f, 0.04785326f, 0.01342415f, 0.04354524f, 0.01555621f, 0.10007554f, 0.07851873f, 0.16154370f, 
    -0.02964220f, 0.08441571f, 0.15428054f, 0.12313860f, 0.14398041f, -0.11709719f, 0.07452162f, 0.03032531f, 
    0.05223987f, -0.07776856f, -0.06069601f, 0.11799186f, 0.31878224f, -0.01767780f, 0.03921394f, 0.24410304f, 
    0.06191831f, -0.00805316f, 0.05195035f, 0.00427231f, 0.04079723f, 0.01920515f, 0.01292148f, 0.03619793f, 
    0.05030135f, 0.02331900f, -0.04942194f, 0.00624104f, -0.02438877f, -0.02672846f, 0.00538452f, -0.02839720f, 
    0.01461417f, -0.00883038f, 0.19627249f, 0.02219374f, -0.14951563f, 0.08925361f, 0.21336880f, 0.05658470f, 
    0.15132762f, 0.04027223f, 0.05938720f, -0.05423021f, 0.13198417f, -0.00228689f, 0.01497488f, -0.09213694f, 
    -0.36587739f, -0.15887910f, 0.05564500f, -0.33192527f, 0.04560413f, -0.00861869f, -0.01830458f, 0.07478387f, 
    -0.00505780f, 0.01166498f, 0.00940296f, -0.12615481f, -0.35434848f, 0.25575185f, -0.11321127f, 0.03267970f, 
    0.05532758f, -0.10587254f, 0.05360737f, 0.18356617f, 0.07769443f, 0.03204275f, -0.03157791f, 0.04057958f, 
    -0.01294286f, -0.03129906f, -0.19291241f, -0.03168616f, -0.08543555f, 0.09318776f, -0.01326174f, -0.00016463f, 
    -0.00383969f, -0.02722577f, 0.07427203f, 0.01491287f, -0.05785874f, 0.14133887f, 0.19865879f, -0.14495130f, 
    -0.01082728f, 0.04967907f, 0.06134616f, -0.05052678f, 0.04083467f, 0.01365364f, 0.07381192f, 0.02770241f, 
    -0.19433932f, -0.42079806f, -0.20265914f, 0.11609396f, 0.08277935f, 0.06098669f, -0.02154930f, -0.04531221f, 
    0.05978519f, 0.01514488f, 0.12565176f, -0.00341249f, 0.03704119f, -0.01850653f, 0.07015403f, 0.01735459f, 
    0.04072144f, -0.02741615f, -0.06167543f, -0.06866141f, 0.01191275f, 0.05167133f, -0.10494043f, -0.06725588f, 
    -0.06437287f, -0.14252689f, 0.04415306f, 0.28306496f, 0.09928622f, 0.03989048f, -0.04898391f, -0.02371710f, 
    0.08768855f, -0.04667339f, 0.05640149f, 0.17744313f, 0.05483488f, -0.28638351f, 0.07046583f, 0.26001421f, 
    0.07215498f, 0.05403641f, -0.07171752f, -0.00437762f, 0.01382500f, -0.11373188f, -0.08261163f, -0.08357479f, 
    -0.19286332f, -0.03532610f, 0.11120844f, 0.07083676f, 0.02532721f, 0.17665382f, -0.09347715f, -0.07038126f, 
    0.02342325f, 0.12419187f, 0.03483362f, -0.12049727f, -0.06865398f, -0.06374834f, 0.07057049f, 0.15572645f, 
    -0.04250732f, 0.01287423f, 0.00301908f, 0.07652456f, 0.13432731f, -0.13131790f, -0.05515546f, 0.13058758f, 
    -0.00826817f, -0.06236364f, -0.04872766f, -0.04759409f, 0.06287650f, -0.01495503f, -0.00954260f, 0.01955926f, 
    -0.07272699f, -0.10196938f, -0.06721991f, -0.06151254f, 0.11638999f, 0.31963408f, 0.07944749f, -0.02217675f, 
    -0.00669922f, -0.07348674f, 0.19816075f, -0.10105120f, -0.01712792f, -0.07167383f, -0.02572660f, 0.05529677f, 
    -0.06320082f, -0.06728799f, -0.06761667f, -0.07732974f, -0.00273231f, -0.04862405f, 0.02343466f, 0.00385713f, 
    -0.05266751f, -0.02016507f, 0.00206543f, 0.00788989f, -0.03673600f, -0.02903791f, 0.06195962f, -0.01822157f, 
    -0.04334856f, 0.02962401f, -0.08013967f, -0.06716693f, 0.02355299f, -0.02282731f, -0.06987754f, -0.04899885f, 
    -0.07948673f, 0.01993283f, -0.08185051f, 0.03308950f, 0.03145436f, -0.06324422f, -0.02711990f, -0.01286260f, 
    -0.03411296f, 0.01840381f, -0.00023935f, 0.01188620f, 0.00119600f, 0.05679545f, 0.00585506f, -0.02622586f, 
    -0.07065678f, -0.06236200f, -0.04094434f, -0.01176486f, 0.07042624f, 0.02325808f, -0.05906738f, -0.01042078f, 
    -0.03824640f, 0.04121977f, 0.02013147f, -0.04890837f, -0.03995569f, 0.01173724f, -0.02497381f, 0.06138991f, 
    -0.01563110f, -0.02869562f, -0.06533941f, 0.04306994f, -0.02370621f, 0.04279784f, 0.06184305f, -0.01039774f, 
    0.06065392f, -0.07390179f, 0.00553863f, -0.08170982f, -0.05844127f, 0.03854101f, -0.04117176f, -0.05507132f, 
    0.01284546f, 0.05108603f, 0.00043487f, -0.06844650f, 0.04154120f, -0.06614200f, -0.05144633f, 0.00572642f, 
    -0.04777218f, -0.04151990f, -0.05235615f, -0.05400282f, 0.01335902f, -0.02696269f, -0.01447215f, -0.03232797f, 
    -0.01494639f, -0.04057774f, 0.04124418f, -0.07295730f, -0.00192355f, 0.03961269f, -0.05931900f, -0.07561497f, 
    0.00892940f, 0.05919134f, 0.06585271f, 0.03676734f, -0.01861997f, 0.00803379f, -0.01984586f, 0.03195785f, 
    0.04154285f, 0.00770572f, 0.01183239f, -0.00092049f, 0.01625451f, -0.01284915f, -0.06644716f, 0.02835988f, 
    0.02376630f, -0.06736493f, -0.06847916f, -0.07150942f, 0.04943991f, -0.07492288f, 0.00920078f, -0.01199909f, 
    0.05712364f, 0.01907523f, -0.05571045f, 0.00292189f, 0.02531687f, -0.03695821f, 0.04343153f, -0.01539220f, 
    -0.03740497f, -0.01082336f, -0.02377980f, 0.06668869f, -0.06654457f, 0.04762109f, -0.04471366f, 0.02432659f, 
    -0.00155403f, 0.04621484f, 0.02451951f, 0.03036075f, 0.05082579f, -0.01165607f, -0.00503025f, 0.02016640f, 
    0.01644463f, 0.05299923f, 0.06849856f, 0.03852578f, -0.04096663f, -0.06059790f, 0.03412252f, 0.00469369f, 
    0.05504515f, -0.06088149f, -0.04929381f, 0.00670709f, 0.02572599f, 0.00111512f, -0.01411082f, -0.00233586f, 
    0.01249204f, 0.02777189f, -0.04499898f, 0.04735739f, 0.04549788f, 0.00110437f, 0.05535275f, 0.02941558f, 
    -0.04819437f, 0.03773908f, -0.02632433f, 0.03056159f, 0.06361189f, -0.02841742f, 0.01143248f, -0.07205707f, 
    -0.06687057f, 0.04726523f, 0.05611854f, 0.02978884f, -0.05957885f, -0.05239928f, -0.01394383f, -0.05961598f, 
    -0.01120337f, 0.04054710f, 0.00865896f, 0.05425362f, -0.00495941f, -0.05272061f, 0.00360589f, 0.00098494f, 
    0.05807181f, 0.03820896f, -0.04714127f, 0.14489093f, -0.01242602f, 0.17785813f, -0.02104360f, -0.00615226f, 
    -0.05792101f, -0.01198020f, 0.16507302f, -0.07938328f, 0.10469350f, 0.04469587f, -0.08665673f, -0.04981634f, 
    -0.04317882f, -0.00938851f, -0.28506827f, 0.00920988f, -0.08676828f, -0.07146391f, 0.05800743f, -0.06736790f, 
    0.25349489f, -0.10421298f, 0.02447394f, 0.06019517f, -0.04345351f, -0.03616957f, -0.03388618f, -0.11604793f, 
    -0.12153164f, 0.04929973f, 0.06213195f, 0.03874449f, 0.12034901f, -0.08922340f, -0.17546102f, 0.00783348f, 
    0.06265805f, 0.03226389f, -0.03256515f, 0.04158596f, -0.18834476f, -0.05401489f, 0.07521013f, -0.15820423f, 
    0.24615687f, -0.24989517f, 0.13782741f, 0.01806295f, 0.11703952f, 0.02724520f, 0.00381613f, 0.09233413f, 
    -0.05608388f, -0.02818243f, 0.04231448f, 0.22106507f, -0.02315717f, -0.27351034f, 0.25976315f, 0.13098928f, 
    0.18375579f, 0.00230252f, -0.08246662f, -0.01653871f, -0.06790293f, 0.10597439f, -0.04099653f, 0.08429981f, 
    -0.05825794f, -0.28975829f, -0.05883988f, -0.15416297f, -0.16437706f, 0.04936623f, -0.02463630f, -0.00782332f, 
    0.00003060f, 0.03131244f, 0.00581247f, 0.17896484f, 0.15053043f, 0.19701529f, 0.26581624f, -0.18990605f, 
    -0.15846412f, 0.17399822f, 0.12901144f, -0.07986741f, 0.02733870f, 0.03865277f, -0.05916828f, -0.08513778f, 
    0.09378128f, 0.24383563f, 0.02916064f, 0.26362285f, -0.04769454f, 0.03605729f, 0.02039110f, 0.18419813f, 
    0.03126344f, 0.13483584f, -0.02526160f, 0.19709417f, 0.22411513f, 0.12457900f, 0.08732218f, 0.03138288f, 
    0.11799723f, 0.05382686f, 0.05621772f, -0.02132238f, 0.00750972f, -0.00629041f, 0.11192763f, 0.09873654f, 
    -0.07837711f, 0.07893678f, 0.07338280f, -0.13331845f, 0.00180213f, 0.15968905f, -0.02966837f, 0.10831626f, 
    -0.07962099f, 0.12567195f, -0.25205904f, -0.09070568f, -0.12941137f, 0.10328924f, -0.04679654f, -0.08436985f, 
    0.18832232f, 0.01207403f, 0.00776851f, 0.05144362f, -0.10887322f, 0.04650117f, 0.05376544f, 0.02968708f, 
    -0.16051036f, -0.11831696f, -0.02491273f, 0.03957601f, -0.03825967f, 0.08126548f, 0.16929013f, 0.09619261f, 
    -0.01672121f, 0.06338384f, 0.09821994f, 0.06764368f, -0.30656204f, 0.06584849f, -0.08379146f, -0.41564760f, 
    0.06872188f, -0.00035605f, -0.03856900f, -0.05317346f, -0.11791710f, 0.07568039f, 0.02900845f, -0.03226791f, 
    -0.02401453f, 0.21442765f, -0.10305317f, -0.19577430f, 0.01786304f, -0.05978201f, 0.10249501f, 0.09919238f, 
    -0.03381947f, -0.01026324f, -0.04555719f, -0.13901642f, 0.18366954f, -0.12515518f, -0.02161785f, 0.20155066f, 
    0.04491831f, 0.08122034f, 0.07183700f, -0.02264463f, -0.03076178f, 0.06219646f, 0.06836015f, 0.02127901f, 
    -0.12416562f, 0.12298900f, 0.09717841f, -0.06167389f, 0.07147412f, -0.12713243f, 0.00922681f, 0.03982911f, 
    -0.06111384f, 0.03615546f, -0.04600722f, 0.03876659f, 0.12840566f, 0.02382677f, 0.04000258f, -0.06519312f, 
    0.13365546f, -0.07602622f, 0.20380402f, 0.06875573f, 0.00300860f, 0.12056755f, 0.04762266f, 0.07162648f, 
    0.26830158f, -0.09068786f, 0.02333887f, -0.01008022f, -0.03073486f, 0.00146622f, -0.00305900f, -0.05087522f, 
    0.05821944f, -0.03112990f, -0.09662384f, -0.01610417f, 0.01810726f, -0.00199695f, 0.17118686f, -0.08197145f, 
    -0.00224416f, -0.00557766f, 0.06136157f, 0.02953611f, 0.19364022f, 0.07379439f, -0.04363688f, -0.04529362f, 
    -0.22328505f, -0.04498152f, 0.02978894f, 0.05579418f, -0.04031507f, -0.04660723f, 0.02626402f, 0.04043197f, 
    0.05138519f, 0.08440267f, -0.07259455f, -0.06974113f, -0.42889532f, 0.40117756f, -0.13592751f, 0.01054509f, 
    -0.07363454f, 0.02884547f, 0.14489874f, 0.04559030f, 0.04566586f, 0.01904608f, -0.00673948f, -0.07513208f, 
    0.12026698f, 0.00076445f, -0.08136687f, 0.09847832f, -0.08660401f, 0.05989670f, 0.05620806f, 0.08364175f, 
    -0.04494099f, 0.00009381f, -0.00439384f, 0.02792505f, 0.02388153f, 0.02672173f, 0.15995239f, 0.23911461f, 
    0.06693132f, 0.04902092f, 0.04485183f, 0.10528355f, -0.05121136f, 0.03232764f, -0.00872711f, 0.01835622f, 
    -0.22625770f, -0.26274318f, -0.09474066f, -0.11479931f, 0.13419764f, 0.10181659f, 0.07361339f, -0.02168997f, 
    0.03773719f, 0.00609110f, -0.08573241f, -0.03523112f, 0.21921879f, -0.04887303f, -0.10281152f, -0.21553186f, 
    0.00213417f, -0.02892783f, -0.04224401f, 0.04297541f, -0.06860960f, 0.03358034f, 0.00681944f, -0.03246101f, 
    -0.04483024f, -0.03507308f, 0.03197571f, 0.20745660f, 0.08637381f, 0.08932342f, 0.04010078f, -0.03967100f, 
    -0.02249702f, -0.04195073f, 0.02921055f, 0.09584002f, -0.31005642f, -0.14040731f, 0.00200086f, 0.12866268f, 
    0.00355944f, 0.07977112f, -0.06893054f, 0.00734208f, 0.17741315f, 0.04667551f, -0.03176161f, 0.03197755f, 
    -0.12956595f, -0.03845938f, -0.04561153f, -0.01335444f, 0.04782104f, -0.00315336f, 0.03519751f, -0.00173954f, 
    0.15888606f, -0.06065260f, -0.01187806f, 0.00409367f, 0.14834255f, -0.16316433f, 0.17879502f, 0.20771754f, 
    -0.09635593f, 0.00744949f, 0.03843535f, 0.13252653f, 0.12916414f, -0.01315353f, 0.13343713f, 0.10815020f, 
    0.09009014f, -0.10649157f, -0.01176768f, 0.21895051f, 0.00537807f, -0.00672484f, -0.06465591f, 0.03485420f, 
    0.13612443f, 0.08116350f, 0.02222895f, -0.02727317f, 0.09177417f, 0.24014646f, -0.01265466f, -0.16427222f, 
    0.03905757f, 0.10315642f, -0.00430655f, -0.13278919f, 0.01415958f, 0.01413902f, -0.01945408f, -0.02505878f, 
    0.10080365f, 0.18528284f, 0.10542489f, 0.01531136f, 0.07714784f, -0.16392519f, 0.06436010f, -0.10352112f, 
    0.06658579f, -0.04744802f, -0.03470073f, -0.03288616f, -0.01080092f, 0.00278939f, -0.07350528f, -0.10330862f, 
    -0.15232262f, -0.10892351f, -0.03362718f, -0.02031959f, 0.22001794f, -0.04591997f, -0.01540691f, -0.04837310f, 
    -0.19122951f, 0.28809604f, 0.12571190f, 0.02584189f, 0.03633055f, -0.16036388f, 0.10574739f, 0.16495879f, 
    0.02416902f, -0.08206428f, 0.03056891f, 0.05521981f, -0.24748944f, 0.18578073f, 0.11133704f, -0.11303017f, 
    0.16571619f, -0.06373760f, 0.10583548f, -0.04797861f, 0.05940945f, -0.20377482f, -0.17664570f, 0.13420528f, 
    -0.50462252f, 0.04499829f, -0.02660242f, -0.24885634f, 0.11934958f, -0.01129803f, 0.01590021f, 0.08704813f, 
    -0.01796722f, -0.08970799f, -0.02351827f, 0.02964211f, 0.29772300f, 0.15464377f, -0.07754601f, 0.12663448f, 
    -0.12294004f, -0.06075219f, 0.06371040f, -0.03537140f, -0.08182742f, -0.00850433f, 0.14157526f, -0.08340596f, 
    -0.08469842f, 0.07696963f, 0.16223602f, 0.25873068f, -0.09566537f, 0.00584979f, 0.07992205f, 0.10880758f, 
    0.00959395f, -0.04863836f, -0.02092795f, -0.03621607f, -0.08570115f, 0.07993972f, -0.28458673f, 0.19246356f, 
    0.14657976f, 0.06526367f, 0.04826043f, 0.00636927f, 0.03785031f, -0.10684235f, 0.05476866f, 0.09156243f, 
    -0.04240588f, 0.14219791f, -0.10947258f, 0.05780514f, 0.19651823f, 0.01356170f, 0.10391495f, -0.07630820f, 
    -0.09355831f, -0.00929872f, 0.08698545f, 0.08396151f, 0.34695402f, 0.00777110f, 0.11939829f, -0.21182249f, 
    -0.10215382f, 0.00813389f, -0.02087070f, 0.02929743f, 0.11749440f, -0.01976923f, -0.04121184f, 0.00212225f, 
    0.18300398f, 0.07867106f, -0.31291425f, 0.16509332f, -0.09210877f, 0.14512263f, 0.02975573f, 0.02727902f, 
    0.11406262f, 0.09120712f, 0.00374342f, 0.04023874f, 0.23585139f, -0.08888771f, -0.17555696f, -0.01863297f, 
    -0.00672191f, -0.03540887f, 0.12656714f, -0.12228214f, 0.07719693f, -0.05208943f, -0.06560146f, -0.07824665f, 
    -0.07217615f, 0.20884964f, -0.11239985f, 0.32784918f, -0.08937925f, -0.18669295f, -0.03874261f, -0.00003470f, 
    -0.09146705f, 0.02059833f, -0.11074407f, -0.01782927f, 0.02450436f, -0.00996876f, -0.13086207f, 0.08855996f, 
    0.13007420f, -0.02374589f, -0.11545779f, -0.02047493f, 0.01671477f, 0.08507433f, -0.04076727f, 0.01829139f, 
    0.20076853f, -0.14746629f, -0.08099765f, 0.07973196f, 0.05912596f, 0.05795741f, 0.08490692f, 0.12347216f, 
    -0.00078697f, 0.10556763f, 0.04374935f, 0.08637383f, 0.07574315f, 0.17594856f, 0.00698319f, 0.07549569f, 
    -0.13987163f, -0.17413214f, 0.08126028f, -0.06838489f, 0.03211204f, 0.05124048f, -0.03268359f, 0.11796856f, 
    -0.02229409f, -0.00729509f, -0.01703950f, -0.04798993f, -0.03798394f, 0.03891117f, 0.04061880f, -0.03117762f, 
    -0.01510754f, 0.01374770f, 0.05162835f, 0.00276171f, 0.00776778f, -0.03401275f, -0.01469771f, -0.05468922f, 
    -0.01013281f, -0.02189454f, 0.06677862f, -0.02989721f, 0.04317130f, 0.02780319f, 0.03813796f, -0.07841163f, 
    -0.04781469f, -0.03019665f, 0.06429578f, -0.06578329f, -0.00712175f, -0.05870819f, -0.06461223f, 0.02967202f, 
    -0.05088618f, 0.04074143f, -0.00135098f, -0.00831635f, 0.02363213f, -0.00785132f, -0.06486885f, -0.02852472f, 
    -0.00511100f, 0.04843399f, 0.05145942f, 0.00119067f, -0.01862549f, -0.05052071f, 0.02857095f, -0.01346039f, 
    0.03157325f, -0.03227953f, 0.01429689f, -0.02359358f, -0.05343295f, -0.06248284f, 0.00179889f, 0.01155785f, 
    -0.01716408f, -0.03559711f, 0.03743835f, 0.01432506f, -0.03629062f, 0.02852260f, -0.06486101f, -0.03297698f, 
    0.03954232f, -0.05294747f, 0.05412310f, -0.04429588f, -0.07388352f, -0.00319953f, -0.05360409f, -0.07169156f, 
    0.00449514f, -0.08178522f, -0.01168833f, -0.03775695f, 0.02241643f, -0.01446583f, -0.01689905f, 0.01775714f, 
    0.01518112f, 0.04202351f, -0.04957287f, -0.05632412f, -0.06593396f, 0.05551335f, -0.06550564f, 0.01423730f, 
    -0.05430783f, -0.03305815f, -0.04403870f, -0.03337459f, -0.01345634f, 0.01520791f, -0.02477730f, 0.02842514f, 
    -0.00817768f, -0.00904730f, -0.05374959f, -0.04473080f, 0.01293732f, -0.06836725f, 0.05749005f, 0.01355383f, 
    0.04374015f, -0.05739286f, 0.04611734f, 0.02492490f, 0.01291894f, -0.05574491f, 0.07323542f, 0.05475382f, 
    -0.02955312f, 0.01146466f, -0.02817901f, 0.05021018f, -0.06604065f, -0.06349928f, -0.04167886f, 0.01291572f, 
    -0.07505219f, -0.00930755f, 0.04926556f, -0.03971324f, 0.03758111f, 0.05456983f, 0.04613369f, 0.04105668f, 
    -0.02877284f, 0.06523725f, 0.06209924f, -0.05168867f, -0.05483690f, -0.04596969f, -0.02396833f, -0.00513117f, 
    -0.02707992f, -0.04168913f, 0.06468742f, 0.02051813f, 0.03553240f, 0.06564532f, -0.03383193f, 0.04175901f, 
    0.01096951f, 0.02224100f, 0.03641246f, -0.01155751f, 0.00539549f, 0.01790648f, -0.06678745f, -0.02538322f, 
    0.00246788f, -0.00447048f, 0.03859436f, 0.05907125f, -0.06330898f, 0.04253432f, 0.01544131f, -0.05166786f, 
    0.01841880f, -0.04294191f, -0.07522332f, -0.06047902f, -0.04521212f, -0.06229950f, 0.02158962f, 0.02885466f, 
    -0.00340163f, 0.04132110f, 0.00847548f, -0.01677077f, -0.01409255f, 0.00297091f, -0.07077775f, -0.03998455f, 
    -0.03068589f, -0.06139147f, -0.01986656f, -0.02026612f, 0.03038929f, -0.04467767f, -0.00718913f, 0.05644086f, 
    0.02367960f, 0.04617084f, -0.05452187f, -0.01144583f, -0.02743694f, -0.04794926f, 0.04024756f, -0.00567237f, 
    0.25866419f, -0.16936681f, 0.05745906f, 0.04046553f, 0.10779150f, 0.05062249f, 0.08133604f, 0.04451577f, 
    -0.00683312f, 0.15222205f, -0.01659379f, 0.03598218f, 0.11940086f, 0.11013622f, -0.04555551f, 0.19834261f, 
    -0.13273743f, 0.03734349f, -0.14828023f, -0.01161427f, 0.11578469f, -0.12358599f, 0.07314663f, 0.04064282f, 
    -0.09195521f, 0.17674887f, 0.13363399f, -0.02724208f, 0.08313596f, -0.01854053f, 0.03876953f, 0.10487907f, 
    -0.01881781f, 0.09110557f, 0.05914605f, 0.03498014f, -0.30317008f, 0.05131228f, -0.03801752f, 0.09996144f, 
    0.03299506f, -0.13674019f, 0.07113769f, 0.02665780f, 0.04885967f, 0.00411842f, -0.10350231f, 0.09469000f, 
    -0.11388348f, 0.01844768f, 0.16863163f, -0.40995073f, 0.11536884f, -0.13653047f, -0.06193630f, 0.01832571f, 
    -0.11715454f, 0.01160993f, 0.03064078f, -0.09169497f, 0.29276025f, -0.27452856f, -0.19658613f, 0.16421431f, 
    -0.01949660f, 0.03136825f, -0.00789592f, -0.04152099f, 0.04381388f, 0.07571241f, -0.01471673f, -0.01225359f, 
    -0.15085731f, 0.23284784f, -0.05867822f, 0.20418088f, 0.01680301f, 0.13119990f, -0.05016195f, -0.03927990f, 
    -0.02132048f, -0.05336137f, 0.07121042f, -0.12398864f, 0.12508762f, 0.10837614f, -0.05223656f, -0.40215948f, 
    0.11367210f, 0.03418632f, -0.00144201f, -0.03370607f, 0.01587426f, 0.01045231f, 0.13817087f, 0.17877987f, 
    -0.02545129f, 0.04606113f, -0.06550202f, 0.16216092f, 0.18938968f, 0.04799552f, -0.00387794f, 0.09163165f, 
    0.17781988f, -0.02338172f, -0.00837202f, -0.06799866f, 0.01265150f, -0.05023282f, 0.03200960f, 0.17102049f, 
    -0.03616486f, 0.02390921f, -0.05553491f, 0.00323008f, 0.05385366f, 0.08166844f, 0.04995565f, -0.14487045f, 
    -0.02349422f, -0.02148867f, -0.08007108f, 0.02322180f, 0.03504701f, 0.08863864f, -0.04803067f, -0.09336342f, 
    -0.01908214f, -0.02838496f, 0.00849361f, 0.14764932f, 0.17239748f, 0.19972877f, 0.10960381f, -0.00321928f, 
    0.03783171f, -0.08485848f, 0.01483027f, 0.04355333f, 0.08198111f, 0.03152918f, 0.03961661f, -0.07114930f, 
    -0.03273724f, 0.28411573f, 0.12256627f, 0.34211320f, -0.06863794f, 0.08155422f, 0.00780970f, -0.10950158f, 
    0.03333695f, -0.03901746f, -0.04774798f, -0.03148504f, -0.16354169f, 0.09236585f, -0.07798667f, -0.25372130f, 
    0.13034177f, -0.05969050f, -0.01864424f, 0.00316050f, 0.08767365f, -0.01076599f, 0.04000582f, -0.03962918f, 
    -0.06187245f, -0.18591537f, 0.03347661f, -0.08103269f, 0.20671430f, 0.07751607f, 0.13451876f, -0.06086512f, 
    -0.03147577f, -0.05057338f, 0.06311457f, 0.04460230f, 0.19134697f, -0.00222472f, -0.05341824f, 0.04026885f, 
    -0.03508561f, -0.03858101f, 0.03241014f, 0.12694003f, 0.02944801f, 0.01905169f, -0.03565473f, 0.02126673f, 
    0.04453777f, 0.13545901f, 0.18515491f, 0.17343408f, -0.00080278f, 0.05669698f, -0.00362924f, -0.25667390f, 
    -0.00285194f, -0.32334316f, 0.00169447f, -0.17213088f, 0.08847601f, -0.21925594f, 0.00012884f, -0.09542778f, 
    -0.19220924f, -0.02794947f, -0.13916415f, 0.00690895f, -0.02571481f, 0.08937263f, 0.02450934f, 0.06272452f, 
    -0.08237301f, 0.01362096f, -0.07784878f, 0.02367171f, 0.05572781f, -0.18628447f, 0.07789131f, -0.04843176f, 
    -0.12558165f, 0.08285194f, 0.12975328f, 0.06757933f, 0.29922456f, 0.08186556f, 0.23160136f, 0.06430577f, 
    -0.02638684f, -0.13971108f, -0.03508079f, -0.15373568f, -0.12486711f, -0.09825746f, -0.05920492f, -0.17533612f, 
    -0.05459780f, -0.07466731f, -0.12144826f, -0.07747475f, -0.01079118f, 0.16586082f, 0.02172405f, -0.06693671f, 
    0.01551667f, -0.12422860f, 0.14298661f, 0.25504366f, 0.02577855f, 0.26151860f, 0.02573189f, 0.15545556f, 
    0.08085556f, -0.03570913f, -0.05949172f, -0.14704247f, -0.13597928f, 0.16844025f, 0.09349837f, 0.10393589f, 
    -0.02606373f, -0.16462480f, 0.05058262f, -0.04079199f, -0.02155800f, -0.02713867f, 0.14647813f, 0.20186350f, 
    -0.07548207f, -0.10145334f, -0.08915320f, 0.05975712f, -0.01241248f, 0.08846966f, -0.01723988f, 0.37574434f, 
    0.08320739f, 0.03855347f, -0.13232292f, 0.02397823f, -0.02987292f, -0.03869577f, -0.17688851f, -0.05445202f, 
    0.15694393f, -0.07470734f, -0.03351939f, 0.05847131f, -0.06794016f, 0.12400164f, 0.19524086f, -0.12023843f, 
    -0.06497465f, 0.02884517f, 0.08263422f, 0.30131111f, 0.33627376f, 0.12730967f, 0.11786596f, -0.13459909f, 
    0.02228663f, 0.10358367f, -0.06903756f, -0.11601376f, -0.08183145f, -0.06133202f, 0.01860485f, 0.22228158f, 
    0.32518587f, 0.21141163f, 0.08047505f, 0.02183201f, -0.11647999f, 0.17477046f, 0.11432897f, 0.02811210f, 
    0.16308405f, -0.02933777f, -0.07677783f, -0.01237805f, 0.29349786f, -0.17975654f, -0.06624983f, 0.06958082f, 
    0.04549174f, 0.15681171f, 0.00077312f, -0.22308435f, -0.11269844f, -0.14170896f, -0.00514344f, -0.00634190f, 
    -0.09254469f, 0.06599361f, -0.15788974f, 0.15570669f, 0.04168103f, -0.04507151f, 0.17038871f, 0.18404792f, 
    -0.02585592f, -0.02391803f, -0.13372236f, 0.00403720f, 0.16761459f, 0.15090008f, -0.08228964f, 0.00239613f, 
    0.06064987f, -0.13980243f, -0.12434109f, -0.14382581f, -0.02761173f, 0.14589985f, -0.03286418f, 0.06354555f, 
    0.29918545f, -0.14830978f, -0.17153585f, -0.21292144f, 0.04737655f, -0.09074617f, 0.12971619f, 0.12690005f, 
    -0.04983255f, 0.05762746f, -0.12163241f, -0.22616270f, -0.17586878f, 0.14896028f, -0.03128957f, 0.20105071f, 
    -0.14207444f, -0.02560632f, -0.02958033f, -0.01138549f, 0.03902729f, 0.22741495f, 0.05758948f, -0.00168338f, 
    -0.03369597f, -0.00007937f, 0.10991168f, 0.04646767f, -0.03402584f, 0.06859832f, 0.07419548f, -0.06423572f, 
    0.09811738f, -0.03979693f, -0.01147632f, 0.02490265f, -0.00383697f, -0.12844977f, 0.14998043f, 0.02247801f, 
    0.01939214f, 0.12194483f, 0.09838875f, 0.13947372f, 0.10736420f, 0.01911261f, -0.00585992f, 0.07466047f, 
    -0.23666866f, -0.04732686f, -0.20608953f, -0.08595691f, 0.19765706f, 0.03282947f, 0.07729947f, 0.00217127f, 
    0.05396827f, 0.06587560f, 0.07213137f, 0.14521544f, 0.09866552f, -0.07707863f, 0.18337519f, 0.09947320f, 
    0.08978001f, -0.08190933f, -0.04546589f, 0.04990212f, -0.01420682f, 0.05545950f, -0.08528478f, -0.05724326f, 
    -0.30360505f, 0.28138199f, -0.17410138f, -0.05441725f, 0.01118712f, 0.03962685f, 0.07790893f, 0.04990907f, 
    0.00517852f, -0.00050954f, -0.09004814f, -0.07814917f, -0.10570798f, 0.19312330f, -0.02271722f, 0.00335683f, 
    -0.20240708f, 0.14428322f, 0.09355537f, 0.09816339f, 0.08870754f, -0.02953459f, 0.01799797f, -0.03951602f, 
    -0.03216978f, -0.14483872f, -0.03849040f, 0.06334861f, 0.19814688f, -0.00897215f, -0.00725844f, 0.09303392f, 
    -0.02417068f, 0.05794159f, 0.07332136f, -0.03915004f, -0.04101095f, 0.09561386f, 0.09101697f, 0.04079562f, 
    -0.00640034f, 0.11051415f, 0.05860697f, 0.09581010f, 0.01359063f, -0.07193714f, 0.11608196f, 0.02780803f, 
    -0.07936107f, -0.28707469f, -0.06536197f, -0.04079909f, 0.06690014f, -0.06736214f, 0.09820463f, -0.12577260f, 
    0.04018314f, -0.11734246f, 0.14850782f, -0.09397484f, -0.26166001f, 0.05014993f, 0.07508689f, 0.08010279f, 
    -0.04630467f, 0.15662204f, -0.06819575f, 0.03957165f, 0.10930230f, -0.05396735f, -0.03713663f, -0.01462684f, 
    0.16544598f, 0.09576225f, 0.21224542f, -0.04156358f, -0.03426443f, 0.03931183f, 0.10110424f, -0.07164208f, 
    0.01357239f, -0.16333458f, 0.01135862f, 0.11634279f, -0.08093537f, 0.02207703f, 0.18661965f, 0.15508173f, 
    -0.12150078f, -0.00946972f, 0.03634284f, -0.01887336f, -0.03447245f, -0.09888417f, -0.02035938f, -0.00738456f, 
    0.26350752f, -0.23703095f, 0.09971497f, 0.00007731f, 0.01568324f, 0.03697887f, 0.13357605f, -0.00135010f, 
    -0.09793294f, -0.01858312f, 0.03081732f, -0.00701818f, 0.25813216f, 0.09041808f, 0.12214340f, 0.16116309f, 
    -0.06154912f, 0.03041660f, 0.12726769f, 0.09371971f, 0.08123465f, 0.02638500f, -0.08846613f, 0.14952154f, 
    -0.04632629f, -0.04731227f, 0.02504971f, -0.02561690f, -0.11770644f, -0.02950369f, -0.02134112f, -0.00383989f, 
    -0.04404414f, -0.00153381f, -0.02192610f, -0.01465706f, -0.04833531f, 0.27895388f, -0.20006587f, 0.09555031f, 
    0.01026350f, -0.03713468f, 0.03644934f, 0.06134291f, -0.05600286f, -0.15285859f, -0.02140981f, 0.01712235f, 
    -0.08151492f, 0.06498550f, 0.14161041f, 0.23514260f, 0.04293052f, 0.11618184f, 0.09232262f, -0.06220307f, 
    0.10560574f, 0.12946036f, -0.01418765f, -0.11447856f, 0.18990384f, -0.13667418f, 0.07618155f, 0.36608773f, 
    -0.17585675f, 0.04231943f, -0.05503691f, 0.12508750f, 0.02580352f, 0.02481775f, 0.03772331f, 0.10030635f, 
    -0.50078136f, 0.14899507f, -0.23439239f, -0.15503678f, 0.25983968f, -0.04104978f, 0.04829144f, 0.00510096f, 
    -0.07445206f, 0.24777824f, 0.13362414f, 0.10117924f, 0.12977332f, 0.14855421f, 0.14785871f, 0.26928788f, 
    0.15833381f, -0.07654631f, -0.06662816f, -0.00799947f, -0.06065605f, 0.06165484f, -0.11667570f, -0.06893423f, 
    -0.03544788f, 0.02183131f, 0.03049823f, -0.15485777f, 0.15864606f, 0.09203953f, 0.16896398f, -0.10631858f, 
    -0.01598536f, -0.19092867f, 0.05510478f, 0.05234390f, -0.08291631f, -0.00491780f, 0.24554735f, 0.09756555f, 
    -0.08792865f, -0.02658766f, -0.00255486f, 0.10465522f, 0.05052209f, 0.13276681f, 0.05580296f, 0.05982367f, 
    -0.33446851f, -0.11196949f, -0.33398256f, -0.11218021f, 0.08711256f, 0.09499324f, 0.01015629f, -0.05952993f, 
    0.05040499f, 0.11710367f, 0.01507746f, 0.11352990f, -0.00402935f, 0.01254326f, 0.04047688f, -0.09230325f, 
    0.08692689f, 0.02871435f, 0.03424595f, -0.01805221f, 0.07889096f, -0.10396107f, 0.00233303f, 0.00376957f, 
    0.22044821f, -0.26474652f, -0.20862597f, 0.15287742f, -0.01799096f, 0.07226475f, 0.02863207f, -0.03450860f, 
    -0.01899679f, 0.07056070f, 0.17528050f, 0.07021274f, -0.26481146f, -0.07388534f, 0.15447091f, 0.09134179f, 
    -0.01664642f, 0.05801297f, -0.02141673f, -0.05906520f, 0.07068302f, 0.09043754f, 0.05638317f, 0.04393464f, 
    0.21446580f, 0.16299170f, -0.02274185f, 0.06369281f, -0.00774518f, 0.12220232f, -0.05820954f, 0.04715898f, 
    0.08180334f, -0.02040330f, 0.02098168f, 0.07499822f, 0.25384557f, -0.15087621f, 0.10013765f, 0.04193268f, 
    0.04402779f, 0.03078151f, 0.00838763f, 0.01739796f, -0.08381504f, -0.00395463f, -0.01226275f, -0.06625035f, 
    -0.02934320f, -0.17395164f, -0.03269986f, -0.07888252f, -0.01767652f, -0.05164705f, 0.06462923f, -0.06189155f, 
    0.04236063f, 0.00524641f, -0.00130501f, -0.13053349f, 0.18383650f, -0.04291222f, 0.13455263f, -0.03275986f, 
    -0.04210341f, -0.01708723f, -0.05494500f, -0.01626969f, 0.00328306f, -0.07599578f, 0.01406662f, 0.07161359f, 
    0.03832841f, 0.01050064f, -0.07071538f, 0.02784201f, -0.18361291f, -0.12367170f, 0.08426070f, 0.04405600f, 
    -0.10128520f, -0.08914810f, 0.00223965f, 0.00473345f, -0.26778960f, 0.09020963f, 0.11155486f, 0.12102429f, 
    0.04683829f, -0.00554414f, 0.13743731f, 0.01719781f, 0.02231466f, 0.00898796f, 0.10032195f, 0.09972347f, 
    0.05514163f, -0.04697265f, -0.01002289f, 0.00991616f, -0.04077833f, 0.05124066f, 0.00790777f, -0.03516002f, 
    -0.05549245f, -0.03358326f, 0.03527574f, -0.04304558f, 0.03442101f, -0.07454652f, -0.05010276f, -0.06104212f, 
    -0.07311402f, -0.06217900f, -0.00736415f, -0.02269126f, 0.05383495f, 0.02927766f, 0.00329983f, -0.06127081f, 
    0.00840004f, 0.02973476f, -0.03319253f, 0.01777861f, -0.05935480f, -0.07136986f, -0.03300236f, 0.01940588f, 
    -0.02115330f, -0.06188800f, -0.05172397f, -0.00347273f, -0.03170474f, -0.01510609f, -0.01008036f, -0.02643833f, 
    -0.01870594f, 0.03076950f, -0.04097416f, 0.04102699f, -0.07614446f, 0.04698499f, -0.02610360f, 0.05166354f, 
    0.01014803f, -0.07168699f, -0.06610085f, -0.03045595f, 0.04994860f, 0.05779087f, 0.01926422f, -0.04197410f, 
    -0.05232848f, -0.04628139f, 0.05661536f, -0.01093212f, -0.04795324f, 0.04712510f, -0.05007874f, 0.03324698f, 
    0.05676606f, 0.04431161f, 0.00675804f, -0.04665060f, 0.01655699f, -0.04495693f, -0.03643902f, 0.04169001f, 
    -0.06502976f, 0.02584429f, -0.02967397f, 0.06050225f, 0.04893522f, -0.03834156f, -0.02500861f, 0.00164401f, 
    -0.00931837f, -0.07594439f, 0.02128731f, -0.02778518f, -0.04508119f, -0.01120007f, -0.00637420f, -0.01201866f, 
    0.00475544f, -0.07758272f, -0.07579426f, 0.06230776f, -0.04994149f, -0.05229181f, -0.04311600f, -0.04986637f, 
    0.03719858f, 0.00720793f, 0.06391896f, 0.05479516f, -0.04399360f, 0.01667096f, -0.04626304f, 0.03727663f, 
    -0.05391770f, -0.00393656f, -0.05865919f, 0.03398158f, -0.00835356f, -0.02044778f, 0.03855353f, 0.01306561f, 
    -0.04258931f, -0.05405140f, 0.03395196f, 0.00617240f, -0.06850603f, -0.04435476f, -0.03083252f, 0.05741964f, 
    0.04702344f, 0.01495734f, 0.05953309f, 0.03826700f, 0.02990516f, -0.01301583f, -0.05534881f, -0.01280607f, 
    -0.05268868f, 0.05809892f, -0.03870710f, -0.02115999f, 0.03407894f, -0.00732982f, 0.02810557f, -0.06873532f, 
    0.05974284f, -0.02221965f, 0.00975112f, -0.03800771f, 0.05157162f, -0.02962907f, -0.05685202f, 0.00349081f, 
    -0.06152952f, -0.03364717f, 0.03780535f, -0.07829476f, -0.03828672f, 0.05730261f, -0.06151279f, 0.06248431f, 
    -0.06547583f, -0.03107025f, -0.06966747f, -0.07545632f, 0.06397258f, -0.00571836f, -0.06051915f, 0.03324209f, 
    0.03245002f, -0.01691283f, -0.05044464f, 0.04059645f, 0.01366185f, -0.03352534f, 0.03220417f, -0.00810887f, 
    -0.04618874f, -0.03870647f, -0.02743937f, -0.07870430f, -0.03813976f, -0.00025404f, -0.06514966f, 0.05098105f, 
    -0.00641153f, 0.03378152f, 0.00345538f, -0.06726184f, -0.03870530f, 0.00945401f, -0.06513371f, -0.05978787f, 
    0.04077345f, 0.00955202f, 0.03339112f, 0.04042487f, -0.05120010f, -0.04663133f, -0.02068863f, -0.01116478f, 
    -0.09107906f, 0.17689343f, 0.13540560f, -0.04931328f, 0.02619290f, 0.02494022f, 0.14622273f, 0.00810471f, 
    0.06122119f, 0.08860089f, -0.07670218f, 0.16838172f, 0.09048927f, -0.06092179f, 0.14016767f, -0.11993439f, 
    -0.02916779f, 0.02986342f, 0.09695841f, 0.06296612f, 0.19845931f, 0.03893568f, -0.02885815f, 0.04142155f, 
    -0.12237965f, 0.05098590f, -0.11062158f, -0.03455123f, 0.05666303f, 0.01770460f, 0.05286857f, 0.11807479f, 
    -0.01260805f, 0.06467649f, -0.05805879f, -0.04652586f, -0.31207088f, -0.07688019f, 0.28813639f, 0.09237079f, 
    -0.00806986f, -0.08256933f, 0.01490152f, 0.07224330f, 0.15743178f, 0.05686102f, 0.04417868f, 0.16154607f, 
    -0.41521329f, 0.09685133f, -0.01285444f, 0.05476114f, -0.06742661f, -0.15651588f, 0.00096557f, -0.12659188f, 
    0.01107786f, 0.00501921f, -0.04997652f, -0.14171629f, -0.20389853f, 0.39784008f, -0.30023116f, -0.08145841f, 
    -0.13688043f, 0.08248693f, 0.08267527f, 0.00028720f, 0.09160257f, 0.03155107f, 0.09607375f, -0.01555423f, 
    -0.09152716f, 0.05913379f, -0.12197372f, -0.03930852f, -0.01998176f, -0.10297474f, 0.00738047f, -0.09432641f, 
    -0.02285047f, -0.00944868f, 0.05948599f, -0.00591310f, -0.04872115f, 0.02778742f, -0.06874218f, 0.29020861f, 
    0.15240814f, -0.09438630f, 0.04606193f, 0.11457264f, -0.01946479f, 0.05858487f, 0.17108609f, 0.12923042f, 
    -0.05787283f, -0.19622526f, 0.01744766f, -0.14756754f, 0.00735596f, -0.12260550f, 0.03417733f, 0.03456701f, 
    0.01073608f, 0.01182125f, -0.06683999f, -0.06170133f, -0.07735544f, 0.02749849f, 0.07707863f, -0.01897006f, 
    -0.07158291f, 0.02131847f, -0.00303607f, -0.01846405f, -0.00733181f, 0.08725333f, -0.00697280f, -0.10723819f, 
    0.18839657f, -0.04333730f, -0.28036550f, 0.22478354f, -0.02973413f, 0.10334470f, 0.03853205f, -0.12363254f, 
    0.06993153f, 0.04915005f, 0.20745750f, 0.10967480f, 0.29226696f, -0.00087835f, 0.03931286f, 0.04005765f, 
    -0.07851934f, 0.06635521f, -0.08765256f, 0.03643876f, 0.05867049f, -0.06223373f, -0.02686471f, -0.00387990f, 
    -0.13112579f, -0.02364862f, 0.00423906f, -0.02198255f, -0.07448158f, -0.01762756f, -0.01182661f, -0.14367615f, 
    -0.05037996f, 0.00408354f, -0.12330097f, 0.03800488f, 0.20483173f, -0.21145689f, 0.00204405f, 0.31391978f, 
    0.09508930f, -0.01744044f, -0.05976319f, -0.07856244f, 0.20173226f, -0.02796418f, 0.03506390f, 0.14263348f, 
    0.15652923f, -0.38197860f, -0.04043913f, 0.27657589f, 0.09059287f, 0.06427516f, 0.07178959f, -0.12153729f, 
    0.04291133f, 0.01587412f, -0.03392619f, 0.04967186f, -0.03633938f, 0.43570101f, 0.00682709f, -0.02417690f, 
    0.13248257f, -0.06120886f, 0.00180009f, 0.09529816f, 0.04067679f, 0.15896448f, -0.00934411f, 0.14153446f, 
    -0.00835100f, 0.02921097f, -0.00150672f, 0.18511119f, 0.01342460f, 0.14880455f, -0.10066377f, -0.00187787f, 
    0.07434744f, 0.06006040f, -0.07618254f, 0.02204209f, 0.06130675f, -0.03971123f, 0.10111739f, 0.05975485f, 
    -0.04428855f, -0.01422018f, -0.02623552f, 0.09362064f, 0.02206276f, 0.00374046f, 0.05541592f, 0.06277213f, 
    0.02353148f, -0.01605000f, -0.18978852f, -0.01435054f, 0.07489076f, 0.11022421f, -0.11018074f, -0.03513585f, 
    -0.01463852f, 0.06095949f, -0.20418026f, 0.03134158f, 0.35116675f, 0.00044101f, -0.09409432f, 0.03210914f, 
    0.08598477f, 0.03870549f, -0.06564708f, 0.17177197f, -0.07364929f, 0.00660311f, -0.02017469f, 0.11059535f, 
    0.18136936f, 0.06783953f, 0.08355874f, 0.20745087f, -0.04503100f, 0.05582966f, 0.12981081f, -0.03960506f, 
    0.00384093f, -0.00050488f, -0.04710766f, 0.06993385f, -0.11933493f, 0.07257476f, 0.25930583f, 0.01002110f, 
    -0.07364520f, -0.05308878f, 0.07994991f, 0.04213885f, 0.03549809f, 0.06851467f, -0.00156555f, 0.04126433f, 
    -0.14025623f, -0.28561118f, -0.09268469f, -0.12498484f, 0.09565475f, 0.02528905f, -0.11595181f, -0.01696360f, 
    0.03251890f, 0.05546793f, -0.02370327f, 0.16703451f, -0.12911339f, 0.00634746f, 0.06116473f, 0.12862755f, 
    -0.11112947f, 0.05291680f, 0.08653368f, -0.09275928f, -0.04093577f, -0.11366712f, 0.04245858f, -0.00520279f, 
    0.13375765f, -0.07892895f, 0.14277101f, 0.05082959f, -0.02266832f, -0.04930335f, -0.02701312f, 0.06101308f, 
    -0.07013802f, 0.05843058f, 0.06573709f, -0.05097613f, -0.26482257f, -0.04005856f, 0.03050791f, 0.10006131f, 
    0.02267518f, -0.03704470f, -0.04219635f, 0.04278309f, -0.15081157f, -0.18962982f, 0.09301203f, 0.15999278f, 
    0.25965419f, 0.13102965f, -0.00131520f, 0.06952146f, -0.08239710f, 0.12452547f, 0.03702502f, 0.02950450f, 
    0.02469186f, -0.14477867f, -0.02451128f, 0.07635068f, 0.12555459f, 0.03665904f, 0.03756728f, 0.02998446f, 
    -0.09411193f, 0.08445357f, 0.02990475f, 0.18733545f, -0.02991725f, -0.03452889f, 0.05010143f, 0.00403426f, 
    0.08832532f, -0.19157964f, -0.05477170f, -0.34725004f, 0.03157835f, -0.02491643f, 0.00216071f, 0.11087993f, 
    -0.03027658f, -0.02941544f, -0.02985645f, 0.05748501f, 0.24188469f, -0.10233653f, 0.13419074f, 0.12895492f, 
    -0.05930767f, 0.03485025f, -0.00600240f, 0.05247776f, -0.03522537f, -0.04906617f, -0.05051308f, -0.07423878f, 
    0.20837042f, 0.11801608f, 0.11448987f, 0.23010987f, -0.19110833f, 0.04216602f, -0.00980017f, -0.01597469f, 
    -0.00730892f, 0.04097832f, 0.01901766f, -0.07370901f, -0.23488504f, 0.07910503f, 0.03865636f, 0.04565457f, 
    0.01139638f, -0.13200930f, -0.04664759f, 0.00769463f, -0.03746887f, -0.06498190f, 0.00914313f, 0.09437723f, 
    0.13191429f, 0.12901413f, 0.26672861f, 0.07608802f, -0.07646991f, -0.10398723f, -0.00245961f, -0.07560357f, 
    -0.18126768f, -0.18450788f, -0.11441217f, 0.06035094f, 0.40916631f, 0.18843172f, 0.19413362f, 0.22423694f, 
    0.07556331f, 0.04632034f, -0.00124944f, -0.02301872f, 0.07499135f, 0.00991085f, -0.07815214f, 0.06965294f, 
    0.21363536f, 0.15585168f, 0.07209094f, 0.28492948f, 0.03493267f, 0.04602619f, -0.06652479f, 0.01494061f, 
    -0.04559867f, 0.12996747f, -0.12981880f, 0.11672285f, 0.05775157f, 0.14212398f, 0.08750405f, 0.14211094f, 
    -0.11502746f, 0.03399055f, -0.09253409f, -0.01424950f, 0.06816480f, 0.02077133f, -0.14647272f, -0.05459871f, 
    -0.07124786f, -0.04015263f, -0.18383496f, -0.19484216f, -0.03902868f, -0.01608639f, -0.01797322f, 0.04948765f, 
    0.13054927f, 0.14145012f, 0.00129670f, -0.11058571f, -0.33445826f, -0.02504653f, -0.10501143f, -0.10494027f, 
    0.00829456f, 0.11692356f, -0.01457223f, 0.12381514f, -0.00807359f, 0.04168362f, 0.11850738f, -0.03246538f, 
    0.09068377f, 0.25073409f, 0.21980591f, 0.29194000f, 0.03707567f, 0.10893711f, 0.16174993f, 0.00967410f, 
    -0.07608886f, 0.01656887f, -0.06466001f, 0.01864488f, -0.33947855f, -0.08895275f, 0.07496138f, -0.12355641f, 
    0.09474065f, -0.09915980f, -0.05197420f, 0.01906708f, 0.14395823f, 0.02488782f, 0.05007127f, -0.15980311f, 
    0.09973527f, -0.07336970f, -0.03767231f, 0.17437217f, -0.01721797f, 0.05549436f, 0.01295518f, 0.04163854f, 
    -0.03051428f, -0.06508670f, 0.17099829f, 0.05193571f, 0.03089344f, 0.18183370f, 0.15703709f, 0.13485266f, 
    0.14070496f, -0.02772600f, -0.06357992f, 0.01904564f, 0.11844646f, 0.00710478f, -0.21320219f, -0.03340060f, 
    0.06493896f, -0.16506228f, 0.02381493f, 0.09663580f, -0.08430589f, -0.08903243f, -0.02883147f, 0.07145382f, 
    0.07826572f, -0.04992682f, -0.01084107f, 0.07226032f, 0.26655316f, -0.29128748f, 0.13652107f, 0.04571901f, 
    -0.22692002f, -0.00073266f, -0.05718656f, 0.07556108f, 0.01473828f, -0.04512312f, -0.12449370f, -0.05814788f, 
    0.25283983f, 0.00488375f, 0.19205524f, 0.13135241f, -0.07788079f, 0.11258386f, 0.01973963f, 0.04324660f, 
    0.00053916f, 0.09304791f, 0.00494519f, -0.00619430f, -0.03132011f, -0.23665607f, -0.08782426f, -0.00514513f, 
    -0.13450593f, -0.09842855f, -0.09387995f, -0.02728213f, -0.02968403f, -0.10396551f, -0.09004746f, -0.02988232f, 
    -0.19790585f, -0.01941742f, -0.22838062f, -0.10045357f, 0.09999086f, -0.07517713f, -0.12435769f, 0.09249222f, 
    -0.16884887f, -0.09738607f, 0.00320501f, -0.02343083f, 0.04523517f, 0.11253796f, 0.26063088f, -0.09675375f, 
    -0.05370232f, -0.21248785f, 0.02764896f, -0.06178118f, -0.07068908f, -0.05480625f, -0.03077768f, 0.06692147f, 
    0.14851633f, -0.17340140f, 0.08499572f, -0.09036657f, -0.07037537f, -0.02677803f, 0.12437166f, -0.10758908f, 
    0.05035247f, -0.07453490f, 0.06381378f, -0.04051834f, -0.09932171f, 0.07616227f, -0.14669564f, -0.12332293f, 
    -0.04956795f, -0.01900532f, 0.16649087f, 0.04591136f, 0.12674345f, 0.04490536f, 0.10824957f, -0.02241225f, 
    -0.22059838f, 0.17246908f, 0.04107945f, 0.29251215f, 0.01694629f, -0.08055037f, -0.10379127f, 0.10168469f, 
    0.06789366f, 0.00331226f, -0.06037039f, -0.03689542f, 0.08249962f, 0.22122958f, -0.10783164f, 0.03100546f, 
    -0.01346711f, 0.08089066f, 0.12013582f, 0.06300485f, -0.03568818f, -0.11833146f, -0.01380559f, 0.11666334f, 
    0.22244637f, 0.19205858f, -0.14068371f, -0.06562432f, 0.08764224f, -0.02572498f, 0.00930711f, 0.02037393f, 
    -0.08354748f, 0.12111762f, 0.03140185f, 0.16802533f, 0.33550429f, -0.12605251f, 0.11854915f, 0.06840795f, 
    -0.03547895f, 0.01518419f, -0.06130306f, 0.08318548f, 0.02846866f, 0.08387184f, 0.09380628f, 0.04673016f, 
    -0.11667460f, 0.03994298f, 0.22826263f, 0.25319695f, -0.03036238f, -0.05245301f, 0.06252925f, 0.06844041f, 
    -0.00843435f, 0.13626243f, -0.08558958f, -0.13203526f, -0.27613994f, -0.02109669f, -0.04198908f, 0.05639019f, 
    0.05351657f, -0.03958807f, -0.19677351f, 0.04358030f, 0.14557044f, 0.00166167f, -0.07534847f, -0.04951948f, 
    -0.11063160f, 0.34580669f, 0.06008772f, 0.01775732f, 0.01122178f, -0.03925648f, -0.14637046f, 0.18775953f, 
    0.07064561f, 0.04604143f, 0.05459422f, 0.09359237f, -0.06266532f, -0.19515134f, -0.07694634f, -0.05596989f, 
    0.03567639f, -0.11602977f, -0.06393822f, -0.02962587f, 0.05463131f, 0.01200764f, -0.08314215f, 0.21982338f, 
    0.14347993f, -0.12464885f, 0.03985911f, -0.04782645f, 0.07246526f, 0.15810071f, -0.12236607f, 0.08508100f, 
    0.02831394f, -0.04787001f, 0.03935714f, -0.08121873f, 0.25481701f, -0.26963055f, -0.04325335f, -0.16833173f, 
    0.00573656f, 0.04928651f, 0.11476329f, -0.14019729f, 0.09292268f, 0.03633544f, 0.08756541f, -0.04584647f, 
    0.07200950f, 0.18168800f, -0.20674443f, 0.11878985f, -0.07442687f, -0.06520050f, -0.10468123f, 0.00057452f, 
    0.05264191f, 0.05260416f, -0.02485513f, -0.00741285f, -0.07463376f, -0.07999465f, -0.30826220f, 0.19141284f, 
    0.17641403f, -0.01380236f, -0.04032305f, -0.12147180f, -0.00886831f, -0.09300736f, -0.14769047f, -0.09536768f, 
    0.18451957f, 0.09545697f, 0.02066289f, -0.19724096f, 0.08058734f, 0.00678283f, -0.02683682f, 0.13579214f, 
    0.02657528f, 0.02502540f, -0.03196646f, -0.06213057f, -0.10679869f, -0.08525337f, 0.01445474f, -0.06661415f, 
    -0.00993659f, -0.12174230f, 0.01632893f, 0.00409688f, -0.02637524f, 0.03973606f, 0.08708245f, 0.07870333f, 
    0.03197317f, 0.00095941f, -0.07100573f, 0.04983848f, -0.05874256f, 0.04714746f, 0.00230592f, -0.02819447f, 
    -0.06615104f, -0.05253224f, -0.04317888f, 0.00887422f, -0.05636716f, 0.05543039f, -0.04075866f, -0.01048275f, 
    0.02172631f, 0.01057507f, -0.05844079f, -0.00532890f, -0.06292332f, -0.06272121f, 0.03015720f, 0.00526261f, 
    -0.01679278f, 0.00046193f, -0.04917205f, 0.00250689f, -0.01765799f, 0.02607524f, -0.00033557f, -0.06655631f, 
    0.00383275f, 0.00164883f, 0.05163008f, -0.05440419f, -0.04933521f, -0.00239925f, -0.03226852f, -0.02156880f, 
    -0.05901976f, -0.04239855f, -0.07625472f, -0.06402106f, -0.04945806f, -0.06566293f, 0.03651000f, -0.01082994f, 
    -0.07614444f, -0.03806476f, -0.02834288f, 0.01484303f, 0.03458977f, -0.06711706f, -0.03562386f, 0.04810919f, 
    -0.06449822f, -0.03078996f, 0.00012962f, 0.02207061f, -0.04389843f, -0.05601460f, -0.05386695f, -0.06318188f, 
    -0.00676052f, 0.01337409f, 0.06287055f, -0.01096473f, -0.02773262f, 0.04323247f, 0.00154909f, -0.03178653f, 
    -0.04773986f, 0.04892684f, 0.03005517f, 0.05868253f, 0.00552140f, 0.03404278f, 0.06341965f, 0.05286000f, 
    0.01842293f, -0.00122625f, -0.07143904f, -0.06237974f, -0.04297458f, 0.06200503f, 0.04234409f, -0.06425467f, 
    0.04294741f, 0.02360157f, 0.01202506f, -0.02728354f, 0.03343155f, 0.06122359f, 0.04139635f, -0.01245467f, 
    -0.02533771f, -0.04609142f, -0.04025528f, 0.05565852f, -0.01459890f, 0.04096613f, 0.00465713f, 0.01391707f, 
    0.05148804f, 0.06365985f, 0.00267459f, 0.00765493f, -0.02597808f, -0.04345662f, 0.01475603f, -0.02158954f, 
    -0.00259304f, -0.07058720f, -0.07346186f, -0.02497520f, -0.03865355f, 0.00410319f, 0.05692001f, -0.06495455f, 
    -0.03539751f, -0.00494379f, -0.04568387f, -0.00806980f, 0.00122762f, 0.01359415f, -0.06794130f, -0.00650595f, 
    -0.00126151f, 0.00423481f, 0.05754655f, 0.00532851f, -0.01973738f, 0.02513304f, 0.04640684f, -0.01701644f, 
    -0.00078884f, -0.03908457f, 0.05420780f, 0.05507495f, 0.01661216f, -0.07189199f, -0.04789053f, 0.00103198f, 
    -0.02669369f, -0.01278291f, -0.07180616f, -0.07675175f, -0.01387103f, 0.00422059f, -0.02008010f, 0.04596305f, 
    0.00327289f, -0.01360499f, 0.00547719f, -0.01056131f, -0.04323038f, 0.06014437f, 0.01499577f, -0.06050284f, 
    -0.06257588f, -0.05655690f, -0.00862312f, -0.00076964f, 0.02957307f, -0.02970735f, -0.02665095f, -0.07767188f, 
    -0.03047611f, 0.03228622f, -0.02006632f, -0.05865628f, -0.06595132f, -0.04991675f, -0.00561550f, 0.04844512f, 
    0.04946939f, 0.04533952f, 0.06488656f, -0.06715005f, -0.00947370f, -0.04405998f, -0.03668637f, 0.05285461f, 
    -0.04746978f, -0.03084867f, -0.00067807f, -0.03922832f, -0.04300863f, -0.07436434f, -0.02753856f, 0.02675368f, 
    0.10628971f, -0.07166947f, 0.14047623f, 0.03662436f, -0.13144994f, -0.02986861f, 0.05051419f, -0.04907699f, 
    -0.04109969f, -0.19700490f, -0.05840525f, 0.02151499f, 0.31662098f, 0.17187877f, 0.01370882f, 0.33745188f, 
    0.04001075f, 0.07882649f, 0.00806437f, -0.11538335f, -0.00148914f, -0.07213841f, 0.03501768f, 0.11902801f, 
    0.27884781f, 0.00735337f, 0.06789898f, 0.30665928f, -0.01018381f, -0.02384002f, -0.12288583f, 0.00381166f, 
    -0.21982066f, 0.02342214f, -0.07405970f, 0.06484032f, 0.26808900f, -0.09394895f, 0.02762430f, 0.22286321f, 
    -0.06859343f, 0.00154979f, -0.02320928f, 0.03448333f, -0.13667566f, -0.08749416f, -0.04971926f, -0.13389713f, 
    0.05596597f, -0.36694798f, -0.01825836f, -0.07188965f, -0.04542427f, 0.04663185f, 0.01685346f, 0.02372302f, 
    0.04833616f, 0.14769016f, 0.03462756f, -0.04436472f, 0.09317140f, -0.32532844f, 0.08745713f, -0.06821968f, 
    0.00292201f, 0.03923557f, -0.02572766f, 0.08109701f, -0.01300355f, 0.07821395f, 0.14757501f, 0.08465733f, 
    0.24501179f, 0.19528928f, 0.28813970f, 0.27267331f, 0.08219762f, 0.10547509f, 0.08459706f, 0.12547663f, 
    -0.09398115f, -0.05275805f, -0.01881697f, 0.03118111f, -0.30506694f, -0.15935606f, 0.00458371f, -0.52887851f, 
    0.05894432f, -0.12005208f, -0.20951138f, -0.11821026f, 0.17013946f, -0.06433083f, 0.00997284f, -0.01119209f, 
    0.15480435f, 0.00471686f, 0.19649281f, 0.20967923f, -0.09152692f, 0.06299754f, -0.03055587f, 0.20434034f, 
    -0.00347724f, -0.02218101f, 0.17877519f, 0.14492439f, -0.04139160f, 0.18872589f, -0.06878501f, 0.31344259f, 
    0.04264974f, -0.08765488f, -0.15399763f, 0.07131764f, 0.09431023f, -0.07728516f, -0.22071838f, 0.08211946f, 
    0.07698452f, -0.09528513f, 0.02724811f, -0.06796645f, 0.13511144f, -0.05482681f, -0.02842493f, -0.00717315f, 
    -0.10431570f, -0.02783205f, 0.00997025f, -0.04293215f, 0.17523150f, -0.03911328f, 0.03397838f, -0.00923612f, 
    0.05909238f, 0.05359370f, 0.01385954f, 0.10918846f, 0.00080934f, -0.01681705f, -0.13876021f, -0.05233147f, 
    0.35000911f, 0.10480851f, 0.17991433f, 0.23726644f, 0.01011259f, 0.08332623f, -0.01796297f, 0.23306893f, 
    -0.02329833f, -0.01570554f, -0.07426671f, -0.04480715f, -0.13375530f, -0.05403723f, -0.30381536f, -0.15140735f, 
    -0.02556310f, 0.06094575f, -0.02530267f, -0.05754746f, 0.03338319f, -0.01087871f, -0.05387160f, -0.00314178f, 
    -0.07266140f, 0.05655359f, -0.23123461f, -0.30904567f, 0.16313151f, -0.06241874f, -0.10087032f, -0.00602141f, 
    -0.23346789f, -0.05912718f, -0.05359313f, -0.17225330f, -0.14311472f, 0.17283918f, 0.22303832f, -0.07045841f, 
    0.04732470f, -0.22411157f, 0.02448444f, 0.00535882f, -0.00264678f, 0.00031847f, -0.04136875f, 0.10128119f, 
    0.10479636f, -0.11085653f, 0.13152093f, -0.09420385f, -0.02585132f, -0.11493666f, -0.00404276f, -0.10474151f, 
    0.09343685f, -0.09593176f, 0.05083295f, 0.03647903f, -0.13137335f, -0.14948264f, -0.13963541f, -0.03706941f, 
    0.07039783f, 0.12869397f, 0.16668986f, 0.01469936f, 0.07944203f, -0.01444956f, 0.04582145f, -0.01658075f, 
    -0.29479644f, 0.09899561f, -0.02713160f, 0.23165438f, 0.02427758f, -0.08721013f, -0.02253931f, 0.02545191f, 
    0.03816885f, 0.03990453f, 0.04781688f, -0.00803057f, 0.14487280f, 0.19139086f, 0.00815780f, 0.00095355f, 
    0.09153002f, 0.10154893f, 0.02156487f, -0.04008345f, -0.03683756f, -0.03645010f, -0.16272940f, 0.08313000f, 
    0.15386778f, 0.24072799f, -0.19571325f, 0.11141639f, 0.02133246f, 0.14983803f, 0.06906139f, -0.03172685f, 
    0.03854489f, 0.09165621f, -0.05656917f, 0.10157705f, 0.19629814f, 0.02768526f, 0.11795343f, 0.10856552f, 
    0.00019580f, 0.01657283f, 0.04478415f, 0.10750487f, -0.01831034f, 0.07001629f, 0.02218974f, -0.03431482f, 
    -0.02734887f, 0.02603065f, 0.22376220f, 0.18393999f, 0.06672639f, 0.01337580f, 0.08062415f, 0.11455614f, 
    0.05877150f, 0.10824981f, 0.00042512f, -0.08119727f, -0.29880062f, -0.00414695f, -0.08231570f, 0.16873699f, 
    0.10429870f, -0.08996990f, -0.15783173f, -0.02191785f, 0.16695197f, -0.07851174f, -0.05525463f, -0.03545493f, 
    -0.19079989f, 0.26915500f, 0.06621800f, -0.11779179f, 0.00256948f, 0.07105730f, -0.00162046f, -0.01159110f, 
    0.02309484f, 0.01675924f, 0.09290344f, 0.02395613f, -0.09447321f, -0.07593103f, -0.01527531f, -0.10441606f, 
    0.10616970f, -0.00312050f, -0.00569217f, 0.02800101f, 0.05643337f, -0.07535588f, -0.14912485f, 0.08862253f, 
    0.05280970f, -0.04295371f, 0.20666046f, -0.12418663f, 0.02295984f, 0.10728634f, -0.18557954f, 0.04544280f, 
    0.15970899f, -0.00555814f, 0.09497269f, 0.01767109f, 0.16336599f, -0.25121796f, 0.10001486f, -0.07768097f, 
    0.01680763f, 0.11141912f, 0.05197202f, -0.19312489f, 0.15687421f, -0.00325957f, 0.09677294f, -0.09420186f, 
    0.14864729f, 0.07259902f, -0.07621118f, 0.15592162f, -0.06408527f, -0.11164270f, -0.08076660f, 0.04268289f, 
    -0.02532206f, 0.00369887f, 0.07389741f, 0.04602814f, 0.04429510f, 0.00309143f, -0.19093016f, 0.13812368f, 
    -0.00533993f, -0.07993581f, -0.01087033f, -0.16875145f, 0.04180131f, -0.02831580f, -0.04434028f, -0.02374254f, 
    0.15846789f, 0.16567133f, 0.00552845f, -0.22048500f, 0.10112111f, -0.01015440f, -0.10649101f, 0.16357371f, 
    -0.04192022f, -0.06813017f, 0.05977504f, -0.15845022f, -0.19506645f, 0.01280656f, -0.03333510f, -0.03883702f, 
    -0.01230881f, -0.06425976f, -0.03084549f, -0.00350704f, 0.02927380f, -0.03341399f, -0.07389376f, 0.02534188f, 
    -0.06114371f, -0.06526311f, 0.05506422f, -0.00079386f, 0.07455709f, 0.04932220f, 0.00088049f, 0.12827711f, 
    0.15441807f, 0.21521577f, -0.08426686f, 0.11413502f, -0.09328956f, 0.07620987f, 0.15194549f, 0.09696792f, 
    0.09849261f, 0.06026703f, 0.20938633f, 0.05900382f, 0.08473561f, -0.07593021f, -0.02111250f, 0.10774958f, 
    -0.29833016f, 0.01413550f, -0.12704273f, -0.07900727f, 0.13017404f, 0.00324810f, -0.05402333f, 0.08302973f, 
    0.06208907f, -0.02147277f, 0.08298624f, -0.02984483f, -0.01179481f, 0.08863374f, 0.18519565f, 0.27456668f, 
    0.00956382f, -0.06189287f, 0.12707637f, 0.03202949f, 0.10124755f, 0.02069947f, 0.06022872f, -0.03081929f, 
    0.01004361f, 0.21086912f, -0.03039909f, -0.08297112f, 0.04959409f, -0.04129358f, 0.00341504f, 0.03691114f, 
    0.02336341f, 0.05501981f, -0.15056580f, 0.03950577f, -0.21708323f, 0.09101754f, -0.02253921f, 0.06356373f, 
    -0.04793062f, 0.06528921f, 0.06743076f, 0.05492358f, 0.21269700f, 0.03538923f, 0.01942934f, 0.08082618f, 
    -0.22233120f, -0.04056011f, -0.16926552f, 0.07030022f, 0.07320238f, 0.07698035f, -0.04906386f, -0.06799328f, 
    0.00246058f, 0.09894678f, 0.01665852f, -0.09316818f, -0.03920538f, 0.04562285f, 0.09263014f, -0.21120015f, 
    0.04245662f, -0.11327054f, 0.02894095f, 0.14079009f, 0.08196205f, 0.00611359f, 0.16889258f, 0.06519230f, 
    -0.06758299f, -0.21082844f, -0.04065702f, -0.13935320f, 0.04548815f, 0.05542626f, 0.11115468f, -0.05187143f, 
    0.22459549f, 0.07215949f, 0.01524992f, -0.11920470f, -0.45006597f, -0.11912081f, -0.10738942f, 0.08529897f, 
    -0.02373269f, -0.06491993f, 0.00066346f, -0.11177876f, -0.05548254f, 0.04118298f, -0.00211965f, -0.06225446f, 
    0.13026376f, 0.06837391f, 0.14797384f, -0.00522254f, 0.01834120f, 0.05680132f, -0.06955601f, -0.06109947f, 
    0.03133537f, -0.05702766f, 0.09396256f, 0.12464582f, -0.04167903f, -0.10697239f, 0.25563270f, 0.10098642f, 
    -0.02559364f, 0.06339817f, 0.00689149f, 0.08204051f, 0.08990335f, -0.02921942f, 0.01935254f, -0.02257640f, 
    0.15044254f, -0.14496961f, -0.04686704f, -0.04104321f, -0.08576567f, 0.01498350f, 0.05780259f, -0.03023277f, 
    0.00359692f, 0.04089293f, 0.01716563f, 0.01029231f, 0.12598060f, 0.11712469f, 0.09931060f, 0.05092941f, 
    -0.10645431f, 0.07726284f, 0.05581878f, 0.04209624f, 0.14459281f, 0.02340253f, 0.07273441f, 0.06354755f, 
    -0.04487535f, -0.05350355f, 0.06297202f, -0.05866053f, -0.04143193f, -0.09491502f, -0.10425284f, -0.07604024f, 
    -0.09532205f, -0.05761095f, 0.09221683f, 0.12455769f, -0.18207391f, 0.06236782f, 0.07791082f, -0.02028006f, 
    -0.01808025f, 0.13170244f, -0.02309905f, 0.10462768f, -0.03455754f, -0.08667688f, 0.05262927f, 0.03481428f, 
    -0.15204670f, 0.11296851f, -0.01565916f, -0.14956568f, -0.01936285f, -0.13200025f, -0.07760314f, -0.08365855f, 
    0.11687259f, -0.14226438f, -0.02457635f, 0.10443036f, -0.12169453f, -0.12816142f, 0.16683389f, -0.30506679f, 
    0.14362513f, 0.07586037f, 0.33055049f, -0.00541122f, 0.01948039f, 0.06084547f, -0.10554875f, 0.02800959f, 
    0.08685672f, -0.03308562f, -0.11433465f, 0.08752220f, -0.00878294f, 0.04722502f, -0.04343564f, -0.00498798f, 
    0.04222488f, -0.08681025f, -0.09579483f, 0.04988092f, 0.25958964f, -0.02366495f, 0.14745320f, -0.05628385f, 
    0.06532549f, 0.06871001f, 0.09727975f, 0.02648025f, 0.04760742f, -0.03390247f, -0.06965581f, 0.05065010f, 
    0.02688284f, 0.22082300f, -0.21063133f, 0.35267213f, -0.11208355f, 0.04294060f, 0.01847267f, 0.05303491f, 
    0.02533188f, 0.04822760f, 0.01689077f, -0.02517047f, -0.07559948f, 0.36089751f, -0.09726062f, -0.06928179f, 
    -0.10916471f, -0.00128802f, -0.00395036f, -0.02639955f, -0.06090180f, 0.00582359f, 0.07469846f, -0.07857438f, 
    0.15010233f, -0.08995691f, 0.10560594f, 0.01759738f, 0.16209990f, 0.01090398f, 0.16198294f, 0.10233027f, 
    -0.03103760f, 0.00029465f, -0.06401104f, 0.07160950f, -0.26938841f, -0.19913088f, -0.11815809f, 0.44811633f, 
    0.12533224f, 0.00613062f, 0.00387666f, 0.05443732f, 0.08836380f, 0.06729659f, -0.02145273f, -0.05329547f, 
    0.02657318f, -0.04363778f, 0.20038837f, -0.29116714f, -0.06938669f, -0.03877831f, 0.00407455f, -0.02789951f, 
    -0.14876850f, 0.04131258f, 0.10171158f, 0.02992093f, -0.11267993f, 0.12266571f, -0.00762357f, -0.14283034f, 
    0.03227030f, 0.01760498f, -0.05146459f, 0.02945945f, -0.08993518f, 0.02489838f, 0.01008094f, 0.14745978f, 
    0.22258663f, -0.04089580f, 0.05699335f, 0.04304701f, -0.11402661f, -0.04740429f, 0.03508866f, 0.02943791f, 
    0.04043463f, -0.06286664f, 0.14414798f, 0.06992622f, 0.06965283f, -0.20677136f, -0.08113975f, -0.06960087f, 
    -0.04572316f, 0.11954112f, 0.04194080f, 0.00782168f, 0.03270370f, -0.03517709f, 0.03170355f, 0.12066845f, 
    0.20001854f, -0.02597917f, -0.16937619f, -0.26195604f, 0.16656297f, -0.06068348f, -0.00658206f, -0.01632108f, 
    -0.04368664f, 0.03536389f, -0.00053088f, 0.12025997f, 0.30529958f, -0.10743949f, -0.08293212f, 0.34594905f, 
    -0.10552254f, 0.10544506f, 0.06945167f, -0.04355737f, -0.00239637f, -0.05740374f, 0.05058208f, 0.09726657f, 
    0.23945588f, 0.02220668f, 0.10840403f, 0.18871579f, -0.16794626f, 0.00957613f, -0.07794604f, -0.03171977f, 
    0.10193956f, -0.01052616f, -0.01586298f, -0.02592418f, -0.28999770f, 0.16233903f, 0.01834362f, 0.02571713f, 
    0.04299153f, -0.04215768f, -0.09393990f, -0.04425860f, 0.05193469f, 0.01587761f, -0.13153811f, 0.00119926f, 
    0.12409569f, -0.08822357f, 0.11874735f, 0.15863727f, -0.01535015f, 0.12842855f, -0.01285075f, 0.00242933f, 
    0.01126669f, -0.04049148f, 0.00156472f, -0.07336427f, 0.09907304f, -0.01904156f, 0.02777419f, 0.24044859f, 
    -0.21098265f, 0.03106497f, -0.12201919f, 0.08162538f, -0.00446762f, -0.00773603f, 0.01738522f, -0.00316812f, 
    -0.24205561f, 0.24185188f, 0.00680567f, 0.21625426f, 0.04598647f, 0.09053158f, 0.10879651f, 0.05877057f, 
    -0.14529882f, 0.11628537f, 0.00057837f, 0.03294701f, 0.20338717f, 0.17110009f, -0.12885760f, 0.25069448f, 
    0.06137480f, 0.04894134f, -0.04873254f, -0.01031601f, -0.18213782f, -0.04469336f, -0.04782284f, 0.12356912f, 
    0.16706134f, 0.13844684f, -0.01167688f, -0.14516425f, 0.15297973f, 0.04893231f, 0.16039032f, -0.01900563f, 
    -0.08547400f, -0.16281006f, -0.06236437f, 0.08034202f, 0.19634636f, -0.28056824f, 0.34623048f, 0.19433315f, 
    -0.05240643f, -0.03396942f, -0.07386760f, 0.03962858f, 0.02785292f, 0.11079033f, 0.07558559f, 0.16005975f, 
    -0.30188429f, -0.12214505f, -0.02160516f, -0.03987020f, 0.14860885f, 0.02817071f, 0.01276961f, -0.00311148f, 
    -0.03521028f, 0.03292306f, -0.02860713f, 0.14079762f, -0.14222243f, 0.05280342f, -0.01790881f, -0.07932530f, 
    -0.03220230f, 0.12131368f, -0.00122384f, -0.09922634f, 0.05446314f, -0.06038701f, 0.06049263f, 0.09873541f, 
    0.19454603f, 0.07241847f, 0.05711713f, 0.22014193f, -0.00207015f, 0.04725655f, -0.12551892f, 0.10002904f, 
    -0.07771641f, 0.10554668f, 0.10055208f, 0.09802830f, -0.10814688f, 0.04481842f, 0.23703936f, 0.21362568f, 
    0.03305404f, -0.07578003f, 0.00391390f, -0.01680645f, -0.02427670f, -0.10562360f, 0.10801663f, 0.02916741f, 
    0.12460130f, -0.00976842f, -0.10613400f, 0.08341253f, -0.12548822f, 0.07031281f, -0.03691412f, 0.07738279f, 
    -0.03769749f, -0.04071670f, 0.08102080f, 0.01498252f, 0.40469834f, -0.12146938f, 0.03129696f, -0.00616675f, 
    -0.07427684f, -0.07474267f, -0.00606002f, 0.05709182f, -0.05243098f, -0.11335196f, 0.07267333f, -0.11791515f, 
    0.10582244f, -0.01189811f, -0.10956089f, 0.06160472f, -0.15348208f, 0.03044600f, -0.03259647f, -0.02228467f, 
    -0.03183795f, 0.03477198f, -0.01427612f, -0.05458732f, -0.02723062f, 0.00237594f, -0.10312598f, -0.02719831f, 
    0.02960240f, -0.13492075f, -0.01159877f, -0.18560512f, -0.01986155f, -0.06797695f, -0.18534905f, -0.05996430f, 
    0.15954934f, 0.09887872f, -0.04322811f, -0.08281351f, -0.08396145f, -0.02330340f, 0.15744814f, 0.02083514f, 
    -0.00544333f, -0.05190560f, 0.06885101f, -0.03352491f, 0.00879727f, -0.14846955f, 0.03027901f, 0.23350570f, 
    -0.03618038f, -0.17375821f, 0.07440845f, 0.07835006f, -0.01271047f, -0.06550074f, 0.00574870f, 0.15336932f, 
    0.02390212f, -0.05350975f, -0.03150684f, 0.06141853f, -0.00984986f, -0.06494128f, 0.01737028f, 0.05405994f, 
    -0.07241931f, 0.01629020f, 0.03748124f, 0.03159504f, -0.02289250f, 0.06036036f, 0.04373059f, -0.06975672f, 
    0.00359667f, 0.01041232f, 0.01581812f, 0.00401514f, -0.04317810f, -0.01495127f, 0.02720249f, 0.03153021f, 
    0.01077832f, 0.01518499f, 0.04165731f, 0.01884443f, -0.02145419f, 0.03500633f, -0.04435573f, 0.01753706f, 
    -0.02116544f, -0.03781120f, 0.00373436f, -0.01761539f, 0.00567062f, -0.01700476f, 0.01881414f, 0.02164302f, 
    0.02078406f, 0.01973273f, -0.04821221f, 0.02754358f, 0.05406591f, -0.00579984f, -0.04055576f, -0.05516010f, 
    0.03586642f, 0.03603972f, -0.06059916f, 0.03591027f, 0.04453006f, -0.01595771f, 0.03576458f, -0.01945248f, 
    -0.06637033f, -0.08092507f, -0.06614421f, 0.00886197f, -0.07838405f, 0.01846088f, 0.03196409f, 0.03306347f, 
    0.04099468f, -0.08078231f, -0.01916514f, -0.00994263f, 0.04328490f, 0.01896352f, 0.03718441f, -0.04602274f, 
    0.04007999f, -0.00189898f, -0.01279617f, -0.02062086f, -0.01864977f, -0.02651185f, -0.03355645f, 0.00632442f, 
    0.01580641f, -0.07431542f, -0.01416443f, 0.05259995f, 0.02278775f, -0.06308784f, -0.03306085f, -0.02347817f, 
    -0.00548159f, -0.04910799f, 0.01691505f, 0.05867915f, -0.00222341f, 0.05637372f, 0.05474171f, -0.02521677f, 
    0.03272514f, -0.06176752f, 0.01411977f, 0.06213289f, -0.07524041f, -0.00340539f, 0.05369484f, -0.02799905f, 
    0.00152106f, 0.05099520f, -0.06837377f, -0.05416768f, 0.02240847f, -0.06821010f, 0.00416808f, 0.00587171f, 
    -0.00576785f, -0.03751968f, -0.00871999f, -0.04379427f, -0.02867906f, -0.05980446f, -0.07507703f, -0.00724937f, 
    -0.03620321f, -0.01551389f, -0.07223616f, 0.02361511f, 0.00503855f, 0.00594487f, -0.00111455f, -0.06735787f, 
    -0.07603629f, -0.01716519f, 0.00593017f, -0.05147619f, -0.00533043f, -0.06243366f, 0.01745318f, -0.00343088f, 
    -0.00579728f, -0.01433508f, -0.02919532f, -0.04747945f, 0.04911636f, -0.03148421f, -0.04627860f, -0.06251422f, 
    0.01673041f, -0.05731731f, -0.01645971f, -0.03822005f, -0.07975337f, -0.02160916f, 0.01183799f, -0.07290267f, 
    -0.06313513f, -0.05236674f, -0.05655314f, 0.00820213f, -0.06563554f, -0.05868462f, 0.01542596f, 0.06042702f, 
    -0.07727958f, 0.05653144f, 0.06085264f, -0.05342706f, -0.04543248f, -0.02175023f, 0.01687289f, -0.03612383f, 
    -0.07368381f, 0.04604213f, -0.07188141f, 0.00016210f, 0.04455964f, -0.06899016f, -0.03441146f, -0.06577129f, 
    0.01996446f, 0.03498549f, 0.01978265f, -0.02606295f, -0.04866172f, 0.02145826f, -0.05985147f, 0.05682744f, 
    0.00248939f, 0.01590931f, -0.00274171f, 0.00703178f, -0.01959506f, -0.05397036f, 0.01307194f, -0.06296370f, 
    -0.05698424f, 0.02864421f, 0.04064170f, 0.01647199f, -0.05418507f, -0.01443769f, 0.05643182f, -0.09686752f, 
    -0.11535295f, 0.02349339f, 0.05147451f, 0.07610840f, 0.05214677f, 0.15018682f, 0.21418956f, 0.16677354f, 
    0.01173256f, 0.16522501f, -0.05624392f, 0.08784416f, -0.09376698f, 0.03204799f, 0.00574380f, 0.11310352f, 
    -0.10677482f, 0.19416237f, 0.00568941f, -0.14501549f, 0.03888366f, 0.05914683f, 0.08587457f, 0.11381163f, 
    0.00795841f, 0.06339870f, 0.07535080f, -0.08258477f, -0.05778873f, -0.00709928f, 0.07210807f, 0.13753602f, 
    -0.02387818f, -0.13853548f, -0.01333863f, -0.02275456f, 0.15033950f, 0.06902458f, 0.14976864f, -0.01004293f, 
    0.05441117f, 0.08762902f, -0.03421075f, 0.03452640f, 0.06967498f, 0.12153643f, 0.00703586f, -0.04863782f, 
    0.00606870f, -0.01314335f, 0.10549479f, -0.00341668f, -0.42265737f, -0.05398533f, 0.01929752f, -0.01664832f, 
    0.09908232f, 0.10791100f, 0.04413886f, 0.08152112f, 0.12032583f, 0.08242089f, -0.09146114f, 0.04163222f, 
    -0.10041865f, 0.18024245f, -0.07731824f, 0.02589532f, 0.01457755f, 0.07951653f, -0.12624462f, 0.01206161f, 
    0.06812609f, -0.00356375f, 0.03524400f, 0.06318795f, 0.30482849f, -0.13482785f, 0.11629321f, -0.07724567f, 
    -0.07365656f, 0.03365388f, -0.01438033f, 0.02881050f, 0.00065217f, 0.09136471f, -0.01574410f, 0.00780080f, 
    0.09285898f, -0.25921917f, -0.05560124f, 0.00198647f, -0.02666542f, 0.11312981f, 0.07601214f, -0.13385750f, 
    -0.08527997f, 0.02859639f, -0.15225810f, -0.03552940f, -0.06570935f, 0.06530531f, 0.10090243f, -0.13135949f, 
    -0.01558502f, -0.03825518f, 0.15553018f, -0.01072774f, -0.07946004f, 0.09142694f, 0.03791951f, -0.04204209f, 
    -0.32597336f, -0.09907077f, 0.21542750f, 0.04071194f, -0.11600775f, 0.01934984f, 0.07703542f, -0.00992907f, 
    0.01071305f, 0.00174347f, 0.03236149f, 0.08452508f, -0.36106795f, 0.04999074f, 0.32288137f, 0.16995072f, 
    0.03107883f, -0.08108895f, -0.10719149f, -0.14325316f, -0.01535480f, -0.08771511f, -0.15947239f, -0.06506184f, 
    -0.01661080f, -0.20056443f, 0.16495577f, 0.05998830f, -0.06758950f, 0.01979425f, 0.07813572f, -0.10858454f, 
    0.09804855f, -0.06937975f, -0.02450271f, 0.06790496f, -0.04575628f, -0.02606205f, 0.03678706f, -0.08684826f, 
    -0.08966227f, -0.01642705f, -0.04684859f, 0.14637320f, 0.08615240f, 0.03258748f, 0.11334602f, 0.02791267f, 
    -0.42228937f, -0.11966498f, -0.19623698f, -0.01050977f, 0.01017278f, 0.02299279f, 0.08090794f, -0.03848851f, 
    0.07842635f, -0.04484683f, 0.00760948f, 0.12206509f, 0.27213135f, -0.08107027f, 0.04485825f, 0.06643406f, 
    0.03348701f, 0.14649191f, 0.06835948f, 0.01614804f, 0.05283245f, -0.00617959f, 0.01101239f, -0.05378405f, 
    0.05735078f, -0.07634463f, -0.07232456f, -0.01057109f, 0.03785063f, 0.05543968f, 0.02054656f, 0.07467854f, 
    -0.01322166f, -0.07659053f, 0.05179897f, 0.06337766f, 0.01388009f, 0.01413599f, -0.08716930f, 0.06909546f, 
    -0.05320790f, -0.04635523f, -0.00098567f, 0.02920180f, -0.03404985f, -0.01630259f, 0.07218146f, -0.01868330f, 
    -0.09088194f, -0.01434277f, 0.01433944f, 0.03356639f, -0.04714051f, -0.03653611f, 0.02652211f, 0.01012500f, 
    0.01651524f, 0.02919843f, 0.05070100f, 0.01875680f, -0.05017158f, 0.03169855f, 0.00453346f, 0.05389487f, 
    -0.07086422f, -0.00964131f, 0.02477266f, -0.03896481f, -0.03770636f, -0.04855574f, 0.05512532f, -0.04011732f, 
    -0.04185576f, -0.02246282f, -0.05107718f, 0.01292196f, -0.00418226f, 0.04653765f, 0.01540975f, -0.02895280f, 
    -0.04605732f, -0.08399857f, -0.02953809f, 0.00078356f, -0.05952983f, 0.03944855f, 0.02540961f, 0.03620610f, 
    -0.00576585f, 0.03993699f, -0.05555344f, -0.03316670f, -0.00144798f, -0.05989883f, -0.06202668f, 0.04455526f, 
    -0.04853974f, 0.02870045f, 0.02463704f, -0.06166332f, 0.00832901f, -0.05214969f, -0.06228900f, 0.01324797f, 
    0.01662561f, 0.02559702f, 0.00491675f, 0.06967841f, 0.03237646f, -0.08323281f, -0.02003318f, -0.03964822f, 
    -0.05108938f, -0.00317123f, -0.06881376f, 0.01513877f, -0.09628692f, -0.03636376f, 0.06208464f, -0.01782550f, 
    -0.00439474f, 0.04998678f, -0.04010367f, 0.03170395f, 0.01561453f, -0.00058212f, 0.01156336f, -0.06026961f, 
    0.08452157f, 0.01925825f, 0.03827839f, -0.02927198f, -0.02837459f, -0.00210962f, 0.05460672f, -0.04833760f, 
    -0.08218187f, -0.04620051f, 0.06484631f, -0.01214082f, 0.02245296f, -0.02308384f, -0.06637067f, 0.00418206f, 
    0.05496828f, 0.05629938f, -0.05346715f, -0.03163869f, -0.07109834f, 0.05371473f, -0.02071527f, -0.02948402f, 
    -0.06886660f, -0.03011052f, 0.01039574f, -0.02740250f, -0.03697659f, -0.06965666f, -0.04519474f, 0.00091588f, 
    -0.07308744f, 0.05407037f, -0.05211977f, 0.03040147f, 0.01842454f, 0.04323782f, 0.04277655f, -0.06532851f, 
    -0.07551525f, -0.03197287f, -0.01532165f, -0.01029659f, -0.04766805f, -0.00795628f, 0.05364579f, 0.00925678f, 
    -0.00942757f, -0.04787432f, -0.03220700f, -0.06773686f, -0.02982788f, -0.04244049f, 0.00560678f, 0.00578203f, 
    0.02617742f, -0.09164498f, 0.01668578f, -0.01309245f, -0.07681934f, -0.00245620f, -0.02780851f, -0.00684065f, 
    -0.05325382f, -0.02885270f, -0.02965422f, -0.04055138f, -0.02145049f, -0.08272561f, -0.00352571f, 0.02589181f, 
    -0.02658555f, -0.07443427f, 0.04136274f, 0.06307344f, -0.03554248f, 0.05222281f, -0.05985385f, -0.04840567f, 
    -0.04646270f, -0.04819245f, 0.01885267f, 0.05570364f, -0.03631202f, -0.01940399f, 0.02542114f, 0.02525503f, 
    -0.02764386f, -0.03591438f, -0.03866573f, -0.02984834f, -0.07055536f, -0.04888245f, 0.00176686f, 0.00299899f, 
    -0.05781354f, -0.04819390f, 0.01606224f, 0.02702999f, 0.05092621f, 0.06012596f, -0.03613734f, 0.04482209f, 
    0.03972070f, 0.04918182f, -0.03407383f, 0.02183375f, 0.02178602f, 0.02329228f, -0.01459221f, -0.01144413f, 
    -0.07324626f, 0.03281213f, -0.06628887f, -0.00210376f, 0.04062811f, -0.05253432f, -0.03316107f, -0.05822880f, 
    -0.07186440f, 0.04908877f, 0.01981353f, -0.06236808f, -0.05955585f, -0.06608891f, 0.02163616f, -0.02686026f, 
    -0.06772771f, -0.00531782f, -0.05931557f, 0.03429848f, -0.06084897f, 0.03141265f, -0.08076563f, 0.04633684f, 
    0.04118608f, 0.00229709f, -0.04591744f, 0.04440109f, -0.04941734f, -0.02635363f, 0.02528985f, -0.02076277f, 
    0.02301213f, -0.06458965f, 0.04270974f, -0.00905819f, 0.02345359f, -0.07077757f, -0.04980541f, -0.05862840f, 
    -0.02562246f, -0.00679259f, -0.05122271f, -0.01435686f, -0.05551960f, -0.03320967f, 0.00870699f, 0.05099467f, 
    -0.00398389f, -0.05719018f, -0.04776221f, -0.05164249f, 0.05622068f, 0.00650773f, -0.04356417f, 0.03248285f, 
    0.05240192f, -0.00807451f, 0.01255339f, 0.00937000f, 0.04464095f, -0.04246802f, -0.04480096f, -0.06624204f, 
    -0.05313947f, 0.01872668f, -0.02045608f, 0.01969888f, -0.05170653f, -0.01603299f, 0.06091136f, 0.02300983f, 
    -0.05863314f, -0.04250436f, -0.05613529f, -0.02326691f, 0.05233298f, 0.03586515f, -0.06889267f, -0.04558925f, 
    -0.07455149f, 0.03563388f, 0.03890148f, -0.04825034f, -0.01281237f, -0.02347264f, -0.06229903f, 0.02124986f, 
    -0.02952063f, 0.01915805f, 0.03059402f, 0.04926329f, -0.01121518f, -0.04949006f, -0.01969864f, 0.03695210f, 
    0.01456932f, -0.04017419f, -0.00881026f, 0.05900761f, -0.00761397f, -0.06762843f, -0.03417468f, -0.06900681f, 
    -0.04636423f, -0.02574069f, -0.05737153f, -0.07336497f, -0.05742458f, 0.04305864f, 0.02186497f, -0.06923518f, 
    0.01547669f, -0.01860831f, -0.04272814f, -0.02702173f, 0.03950310f, -0.01536000f, -0.02367409f, 0.05599436f, 
    -0.06511446f, -0.07485384f, 0.03000912f, -0.06943557f, -0.01307298f, 0.02595548f, -0.06474382f, -0.07613945f, 
    -0.01053069f, -0.06482781f, 0.04332860f, -0.00720438f, -0.07013760f, -0.06397539f, 0.01343176f, -0.01754505f, 
    -0.02969602f, 0.01821520f, -0.01021043f, 0.02910105f, 0.02034145f, -0.07097509f, 0.00838773f, -0.03594457f, 
    0.02926813f, -0.02096783f, 0.01811285f, 0.02266911f, -0.01911470f, -0.01350916f, -0.02286129f, -0.05515802f, 
    -0.07268046f, -0.01073338f, -0.07534216f, 0.05200803f, -0.05102877f, 0.00858380f, 0.00291161f, -0.03302421f, 
    -0.01973717f, -0.06020297f, -0.06119888f, -0.08112823f, -0.05242126f, -0.05885867f, -0.05526040f, -0.04216047f, 
    0.05940384f, -0.00410775f, 0.02814247f, 0.09708282f, -0.12452086f, 0.05371923f, -0.17415331f, -0.10334602f, 
    -0.02970450f, -0.07614145f, -0.05233215f, 0.01530498f, 0.25818506f, 0.20967767f, -0.00350246f, 0.09718373f, 
    0.08809996f, -0.04479715f, -0.20177503f, 0.00538704f, 0.09626294f, 0.18134734f, 0.09033097f, 0.06914882f, 
    0.55753547f, 0.05861913f, 0.04838933f, 0.28902036f, -0.10998416f, -0.05628365f, 0.01908487f, -0.02293226f, 
    -0.00513404f, -0.03824782f, -0.07400861f, 0.05093412f, 0.21658827f, -0.06025928f, -0.04519849f, 0.22535552f, 
    0.02045643f, -0.02729592f, -0.05778470f, 0.04922730f, -0.13391110f, -0.07753015f, -0.14234859f, -0.00053996f, 
    -0.23510858f, -0.53237385f, 0.06653665f, -0.02437521f, -0.01328194f, -0.02631454f, 0.05222654f, 0.15116256f, 
    0.03532582f, 0.12539007f, 0.11017130f, 0.01778939f, -0.01523187f, -0.21386756f, -0.11850991f, -0.25068486f, 
    0.00179709f, 0.00373422f, -0.01568388f, 0.03995552f, -0.03006140f, 0.06097890f, 0.18542287f, -0.01157145f, 
    0.48781377f, 0.36196870f, 0.11839463f, 0.16572773f, 0.03841729f, 0.05603302f, 0.06364730f, 0.03558503f, 
    -0.02564633f, -0.02467272f, -0.01340748f, -0.07437163f, -0.22113039f, -0.08696480f, -0.04535535f, -0.04879447f, 
    0.03789527f, -0.05156626f, -0.01166864f, -0.01925686f, 0.03428956f, -0.11464129f, 0.02884954f, -0.02899529f, 
    0.37073129f, 0.04215814f, 0.07503209f, 0.13418938f, -0.05910016f, -0.09418450f, -0.02421603f, -0.03047267f, 
    -0.04846254f, -0.04422958f, 0.02026532f, 0.05320207f, 0.18862478f, 0.26239809f, 0.02874304f, 0.17273720f, 
    0.04666997f, -0.05005508f, -0.12885284f, 0.07065327f, 0.15165830f, -0.10900433f, -0.15943617f, 0.22204518f, 
    0.17395879f, -0.09194621f, -0.22956178f, 0.17223674f, 0.19830360f, -0.06324118f, -0.10489682f, -0.01013191f, 
    -0.05212847f, -0.09291352f, 0.07139605f, 0.05227667f, 0.05400882f, -0.03516705f, -0.24811478f, -0.03242198f, 
    0.01721308f, 0.08520164f, -0.07482284f, 0.03907149f, -0.03331510f, -0.12108427f, -0.05307714f, 0.03273410f, 
    0.38577467f, 0.14881541f, 0.24439761f, 0.08340969f, 0.02909991f, 0.10353831f, -0.09228945f, -0.12314066f, 
    -0.14574032f, -0.02993469f, -0.08432508f, -0.03071614f, -0.13276377f, -0.19582525f, -0.26616699f, -0.02893779f, 
    0.23388420f, 0.05086186f, -0.02880990f, -0.11000460f, -0.03937263f, -0.00789399f, 0.01837813f, -0.07518605f, 
    -0.03198677f, -0.03373628f, -0.20347537f, -0.09309408f, 0.12754844f, 0.00930969f, 0.02666206f, 0.12032056f, 
    -0.04165532f, 0.04475339f, -0.02885402f, -0.03490743f, -0.28228563f, 0.04374357f, 0.18372005f, -0.04075391f, 
    -0.04729645f, -0.15807143f, -0.04768485f, 0.02560399f, 0.09889802f, -0.10134581f, 0.05019055f, 0.08652374f, 
    0.15952487f, -0.09627751f, -0.02847134f, 0.02613801f, -0.00511725f, 0.23589139f, -0.12416040f, -0.04121230f, 
    0.04637837f, -0.08887136f, -0.07798282f, -0.17588902f, 0.10624740f, 0.12596717f, 0.07282307f, 0.07034531f, 
    -0.00126406f, 0.13290924f, -0.25159517f, -0.09323252f, 0.06198901f, 0.05785777f, 0.05752199f, -0.07689337f, 
    0.06059144f, 0.19837241f, 0.13940673f, 0.10202935f, 0.03763510f, 0.11873366f, -0.07758405f, 0.07045972f, 
    -0.07280727f, 0.11656942f, 0.12987585f, -0.02862375f, -0.07983824f, 0.00301204f, -0.20078683f, 0.19770470f, 
    0.02126234f, -0.09448911f, -0.15071566f, -0.02704874f, -0.04337985f, -0.09694112f, 0.03384919f, -0.08201113f, 
    0.29469997f, 0.01207000f, 0.07310488f, 0.00475488f, 0.04579422f, -0.10015092f, 0.08679093f, -0.16938521f, 
    -0.06554654f, -0.16648029f, 0.26890302f, 0.03369593f, 0.15805310f, -0.39354780f, 0.03207932f, 0.14785913f, 
    0.06094972f, -0.04766463f, -0.12444295f, -0.13272399f, -0.01558521f, 0.03521713f, -0.12346001f, 0.12116217f, 
    -0.01382310f, 0.06398518f, -0.01932065f, -0.18671842f, 0.00100291f, 0.08027519f, 0.01257745f, 0.14220786f, 
    0.02270737f, -0.05992574f, 0.00493014f, 0.06714786f, 0.13164704f, 0.15282501f, -0.04883108f, 0.00324402f, 
    0.01522737f, 0.00103279f, -0.14849183f, -0.23530574f, 0.00093587f, -0.08438566f, 0.10398489f, 0.02804373f, 
    0.13245292f, 0.39160672f, 0.08772199f, 0.07296003f, -0.04577468f, 0.21778822f, -0.06755675f, 0.13090143f, 
    0.08722242f, 0.09867068f, -0.08611575f, -0.00110720f, 0.20066814f, 0.07122822f, 0.11446500f, 0.02825851f, 
    0.04688613f, -0.02250561f, -0.05331819f, 0.14170747f, 0.15039417f, 0.06579877f, 0.02550638f, 0.17803842f, 
    -0.20882531f, -0.13258760f, 0.15650603f, -0.05161449f, 0.06539428f, 0.01932576f, -0.08147652f, 0.08521787f, 
    0.04049515f, -0.06941866f, 0.05052454f, -0.03404205f, 0.15561676f, 0.17649016f, 0.04539017f, -0.07903124f, 
    0.05984724f, -0.00539339f, -0.04195109f, 0.05482678f, -0.02809498f, -0.00251959f, 0.17330292f, -0.05017885f, 
    -0.12251631f, 0.04008003f, 0.03914608f, -0.04559607f, 0.00979806f, 0.06564587f, 0.01647048f, 0.08751243f, 
    0.06458393f, -0.00414119f, 0.00766799f, -0.12791535f, -0.23851576f, -0.14813027f, -0.16720898f, 0.02676207f, 
    0.19911183f, -0.11532300f, -0.21143654f, -0.26031610f, -0.21869224f, 0.03120690f, 0.07895370f, -0.00285662f, 
    -0.16109315f, 0.03915006f, -0.04559191f, -0.19520403f, 0.25871009f, 0.04582786f, -0.04866270f, -0.05616285f, 
    0.09952327f, -0.08012707f, -0.13794543f, -0.22588858f, 0.35597759f, -0.17945349f, -0.05547483f, 0.22810829f, 
    -0.01617170f, 0.09405402f, 0.09972801f, 0.05375271f, 0.14734757f, 0.06508122f, 0.02613550f, -0.09673748f, 
    0.03460100f, 0.05850335f, 0.13683838f, 0.11839767f, 0.04897289f, 0.15702941f, -0.08415015f, -0.27819893f, 
    0.00038082f, -0.23413159f, 0.00041161f, -0.15313755f, 0.01186526f, 0.09286875f, 0.17760445f, 0.01786901f, 
    -0.18765326f, 0.06979316f, -0.22921132f, 0.05544604f, -0.00866723f, 0.06224277f, -0.07491319f, 0.07915942f, 
    -0.12634423f, 0.23852363f, 0.12870243f, -0.17591654f, 0.23487614f, 0.08950678f, 0.00240918f, 0.10246340f, 
    -0.20295131f, 0.09478747f, 0.10813528f, 0.09198394f, 0.12213072f, 0.06798189f, 0.02861683f, 0.16341910f, 
    -0.09152920f, -0.13775757f, -0.12644272f, -0.13828222f, 0.22154397f, 0.00322784f, -0.04022067f, -0.08776046f, 
    0.17602941f, 0.13815534f, -0.09895092f, -0.09946068f, 0.10589175f, 0.14908034f, 0.04656534f, -0.10612451f, 
    -0.00428346f, -0.17565894f, 0.12149187f, 0.10534910f, -0.08629600f, -0.23394184f, 0.19128025f, 0.12026005f, 
    0.01951377f, -0.03855510f, -0.14059469f, -0.06817061f, -0.13621524f, -0.00448279f, -0.06695769f, 0.15843678f, 
    -0.16989842f, 0.16196199f, -0.06120671f, -0.14569901f, 0.09644933f, 0.06853183f, 0.04077473f, 0.13707678f, 
    0.10239483f, 0.02432129f, -0.01115030f, 0.29480612f, 0.25937268f, 0.01835938f, 0.18823430f, 0.05781676f, 
    0.05543327f, 0.05473461f, -0.21020022f, -0.07485407f, -0.12141484f, -0.02192918f, -0.07166284f, -0.13026099f, 
    0.28308386f, 0.04814145f, -0.29069179f, 0.23037675f, -0.02594863f, 0.28855911f, 0.14389536f, -0.00925661f, 
    0.13782816f, 0.05635966f, 0.07796362f, 0.19093201f, 0.18226826f, 0.13127255f, 0.23082514f, -0.17217474f, 
    0.07858692f, 0.15261413f, 0.02737111f, 0.00982940f, 0.16174148f, 0.03711441f, -0.04977518f, 0.20309767f, 
    -0.25124303f, 0.02992622f, 0.11535855f, 0.08103133f, -0.25787202f, 0.11114984f, -0.09270704f, 0.05801561f, 
    0.09573302f, -0.03558363f, -0.08182427f, 0.03882538f, -0.07545126f, -0.12095400f, 0.18603009f, -0.07697685f, 
    -0.02118191f, 0.03467610f, -0.00798350f, -0.23290071f, 0.07646664f, -0.11095764f, -0.00166667f, 0.01676271f, 
    0.00385474f, -0.14297764f, -0.08686819f, -0.01384862f, 0.06145564f, -0.05067017f, 0.25779644f, 0.11311461f, 
    0.17604022f, -0.11111957f, -0.05598989f, -0.02306522f, 0.03241166f, -0.02685699f, 0.08946114f, 0.01642824f, 
    -0.07533889f, -0.18231618f, -0.24675038f, -0.15229894f, -0.04247112f, -0.06688663f, -0.02740647f, 0.05799321f, 
    -0.09986326f, 0.18381906f, -0.25465691f, -0.15192564f, -0.01943512f, -0.06327837f, -0.01117635f, -0.06034449f, 
    0.01040645f, -0.10439309f, -0.17411901f, -0.20091268f, 0.43797943f, -0.27458757f, 0.02688690f, 0.20600972f, 
    0.02673303f, 0.06922308f, 0.14737572f, -0.04394721f, 0.00208216f, 0.12486012f, 0.12053850f, -0.04744046f, 
    -0.05669367f, 0.03701198f, -0.06942748f, -0.07882521f, -0.00327148f, 0.04816465f, 0.01450249f, -0.05809571f, 
    -0.07947326f, -0.06410244f, -0.07313602f, -0.06403849f, -0.01655477f, 0.03006666f, 0.01272326f, -0.02607960f, 
    -0.01438056f, 0.03228359f, -0.07622735f, -0.06073205f, 0.00633175f, -0.06435098f, -0.00227782f, -0.04325346f, 
    0.02129321f, -0.03636446f, 0.03662164f, -0.00417107f, 0.05375505f, -0.04497525f, 0.01061075f, 0.05465343f, 
    -0.00038068f, -0.06290767f, -0.03246286f, 0.04323577f, -0.02262541f, -0.05603188f, 0.02253820f, 0.05447704f, 
    -0.06364111f, -0.02646588f, -0.05075131f, 0.02654736f, -0.07536685f, 0.05159323f, -0.05857410f, 0.05484779f, 
    -0.02622682f, -0.03409500f, 0.03510679f, 0.02460746f, 0.00846636f, 0.06520457f, -0.03029306f, 0.01185040f, 
    -0.04507724f, 0.05512934f, -0.06151904f, -0.07896505f, -0.01793464f, -0.03855502f, -0.03472335f, 0.00607550f, 
    -0.04371578f, -0.04666139f, -0.04179415f, 0.02527577f, -0.03463964f, -0.05894423f, -0.01016496f, 0.01403122f, 
    -0.01077300f, 0.05075414f, -0.05414809f, 0.05633106f, 0.05720732f, -0.00559591f, 0.02139161f, 0.00841836f, 
    0.03525694f, 0.04998610f, -0.05285510f, 0.04695780f, -0.01660772f, -0.04304833f, -0.00892192f, 0.01016220f, 
    -0.06945588f, -0.07441378f, 0.00953628f, -0.01336679f, 0.02517151f, -0.05381354f, -0.06339757f, 0.04590628f, 
    0.04218391f, -0.06962644f, -0.02364522f, -0.06803160f, -0.05628379f, 0.05394696f, -0.01674313f, -0.02670267f, 
    0.03661280f, -0.06261861f, 0.02468594f, 0.01389736f, 0.00058082f, 0.01023452f, 0.04609568f, 0.02328216f, 
    0.03462571f, 0.00836798f, 0.02451694f, -0.00229031f, 0.04151053f, -0.07868686f, -0.01077814f, -0.04375441f, 
    0.00518501f, -0.01531647f, -0.07121622f, 0.05947932f, -0.07966922f, -0.01691923f, -0.07943972f, 0.05224707f, 
    -0.03615056f, -0.04305781f, 0.02980347f, -0.07325152f, -0.06268924f, 0.03945531f, -0.05257124f, -0.07923359f, 
    -0.04379614f, -0.05306757f, 0.04264795f, 0.00615568f, -0.08401949f, 0.06719884f, 0.05444987f, 0.06314303f, 
    0.01353640f, 0.05651854f, -0.01249290f, -0.00505292f, 0.05899482f, -0.05753062f, 0.01491181f, 0.01896540f, 
    -0.03221782f, -0.06264785f, -0.07893948f, 0.04401819f, -0.02944982f, -0.02538395f, 0.02317220f, -0.00240902f, 
    -0.06600019f, 0.02685898f, -0.00394441f, -0.05844582f, 0.04403686f, -0.03234269f, -0.07896885f, 0.03246408f, 
    -0.05722402f, -0.00181215f, 0.03192887f, 0.00750564f, -0.01394406f, -0.04449039f, -0.03221609f, -0.05072393f, 
    -0.08132422f, -0.03724577f, 0.06326925f, 0.03565739f, 0.02718051f, -0.02765666f, -0.07393524f, 0.06738152f, 
    -0.02625656f, 0.01787345f, -0.03845500f, 0.06643190f, 0.01159019f, -0.01855040f, 0.00239620f, 0.04514294f, 
    -0.16199547f, -0.27156645f, -0.15822688f, -0.34385094f, 0.00850599f, -0.19062112f, -0.05436311f, 0.00558260f, 
    0.05743603f, -0.02864600f, -0.07594442f, 0.13563667f, -0.40004700f, -0.09075196f, -0.09780567f, -0.37556446f, 
    0.16830730f, 0.07393705f, 0.33044598f, 0.04011685f, -0.04923027f, 0.02780448f, -0.10956801f, 0.13020740f, 
    0.23700279f, 0.02370177f, 0.11329143f, -0.19340177f, -0.06887340f, -0.09088979f, 0.03388689f, 0.17192416f, 
    0.10316125f, -0.05377890f, 0.02229825f, -0.00399991f, -0.04106679f, 0.05146153f, -0.03790125f, -0.26461518f, 
    -0.07973390f, 0.16359138f, -0.00443945f, -0.05325972f, 0.10471439f, 0.01141882f, -0.08806897f, 0.00273466f, 
    -0.03143396f, 0.32733792f, 0.14812507f, 0.30918613f, -0.12198536f, -0.04668037f, -0.04750431f, 0.01830510f, 
    -0.02334449f, 0.17791648f, -0.02348861f, -0.04824829f, 0.11804970f, 0.28391117f, -0.02390226f, -0.00193334f, 
    0.09448449f, 0.10878395f, 0.11396942f, -0.06358729f, 0.01586405f, 0.00086755f, -0.01866027f, -0.06862944f, 
    0.39917740f, 0.34417984f, 0.19027103f, 0.16361961f, -0.15044658f, -0.13571036f, 0.01791604f, 0.13692446f, 
    0.01181148f, 0.05782281f, 0.04402607f, -0.09005350f, -0.03456883f, -0.17735884f, -0.21302384f, 0.08564228f, 
    0.02028268f, 0.03121810f, -0.09125446f, 0.10930718f, 0.00078189f, 0.07751933f, 0.05632986f, -0.10092738f, 
    -0.06083854f, 0.14079529f, -0.00594859f, -0.31412581f, 0.12171270f, -0.06390281f, 0.01874876f, -0.05755381f, 
    0.16040584f, -0.14487326f, -0.08254018f, -0.09825430f, -0.13627526f, 0.04958734f, -0.21995485f, -0.16561103f, 
    -0.05037090f, -0.05455339f, 0.05209229f, 0.08304152f, 0.03646290f, 0.00849376f, -0.12900490f, -0.02714966f, 
    0.02351264f, -0.17115046f, -0.06246074f, -0.01315699f, 0.14844076f, -0.03863299f, 0.02523460f, -0.05242343f, 
    -0.11637659f, -0.00818411f, 0.09467905f, 0.13669312f, -0.33430061f, 0.00489957f, -0.34290928f, -0.26521525f, 
    -0.04111220f, 0.07299028f, 0.03941059f, -0.13185094f, -0.00325973f, 0.09961447f, 0.08144356f, 0.02318498f, 
    0.13644707f, -0.01424406f, 0.02320742f, -0.15249850f, 0.11706245f, 0.04918198f, -0.02393552f, -0.16515461f, 
    0.08910706f, -0.02878437f, 0.18132868f, 0.05858175f, 0.19208963f, 0.18452506f, 0.11193197f, 0.44675764f, 
    0.04304834f, 0.05251120f, 0.05862838f, 0.03625365f, 0.02913470f, 0.01788914f, 0.14555997f, 0.07439144f, 
    0.21739733f, 0.20553990f, 0.37806347f, 0.20088717f, 0.12829341f, 0.07286478f, -0.06783850f, 0.00471264f, 
    -0.12752883f, -0.02611909f, 0.03752109f, 0.07318323f, -0.07297134f, -0.02671808f, -0.14863148f, -0.06000911f, 
    0.07752244f, 0.02425980f, 0.00781720f, 0.00229658f, 0.10017850f, -0.10102700f, -0.10233325f, -0.08883127f, 
    0.08407514f, 0.10013034f, 0.16298132f, 0.08644426f, 0.16549602f, -0.07036547f, 0.04194293f, 0.03055281f, 
    -0.09230784f, 0.13456330f, 0.04882203f, -0.05538085f, 0.38724503f, 0.10176883f, -0.04386275f, 0.15906131f, 
    -0.09080869f, 0.02411405f, -0.05358911f, 0.05054085f, 0.13377252f, -0.04439571f, -0.02837713f, 0.13078468f, 
    -0.21702722f, 0.21041609f, 0.08072513f, -0.06223390f, 0.05976915f, -0.01247422f, 0.08543164f, 0.09902731f, 
    -0.01400094f, -0.04124657f, 0.12916921f, -0.06152999f, -0.26786190f, -0.00816861f, 0.14658767f, 0.10330725f, 
    0.01416524f, -0.14347598f, 0.03377949f, -0.02839331f, 0.13198788f, 0.01699699f, -0.09707771f, -0.06351473f, 
    -0.38926408f, -0.04563195f, 0.16650911f, -0.37367675f, 0.18615016f, -0.04664982f, -0.07162240f, 0.05533833f, 
    -0.10755326f, -0.09786147f, -0.07557151f, 0.00236874f, -0.09852773f, 0.15984581f, -0.03486996f, 0.17233364f, 
    -0.01902664f, -0.08827955f, 0.01534266f, 0.04095050f, -0.04446404f, 0.15446988f, 0.04922626f, -0.03122194f, 
    -0.21343598f, 0.01109244f, -0.17789276f, 0.14246304f, -0.05423760f, 0.04852575f, -0.04132064f, 0.04422190f, 
    0.00839198f, -0.02700119f, 0.09698746f, 0.00941852f, 0.09598513f, 0.17152743f, 0.12194382f, -0.14606456f, 
    0.13393112f, 0.00815717f, 0.13296798f, 0.06709807f, 0.06459487f, -0.06470819f, 0.02249256f, 0.09025381f, 
    -0.14439352f, -0.20711207f, -0.22122759f, 0.18559131f, 0.15994166f, 0.00322187f, 0.05361288f, -0.07002849f, 
    0.02080155f, 0.03687279f, 0.02566210f, -0.02539379f, 0.08729099f, -0.04042163f, 0.03182000f, -0.09246336f, 
    -0.02549879f, 0.04605286f, -0.05132134f, -0.03585768f, 0.01179737f, 0.14678927f, 0.03841975f, -0.06413429f, 
    0.03826534f, -0.03633947f, -0.10278711f, 0.17798530f, 0.02661808f, 0.21469425f, -0.04054726f, -0.02946668f, 
    0.04539826f, 0.08692022f, 0.02784512f, 0.16829054f, 0.17963181f, -0.09538515f, 0.03647691f, 0.09484708f, 
    0.09403262f, 0.04504544f, -0.06759933f, -0.02708032f, 0.11606301f, 0.01139751f, -0.10530464f, -0.11276799f, 
    -0.17261854f, 0.18120447f, -0.01462444f, 0.28546652f, -0.14154828f, 0.08006603f, 0.02497393f, -0.10703529f, 
    0.08134720f, 0.01075652f, 0.02901078f, 0.02125769f, 0.02228405f, -0.06417101f, 0.01576567f, -0.09076989f, 
    0.06741774f, 0.02668709f, -0.09267446f, -0.03481871f, 0.15568967f, -0.01073519f, -0.03680895f, 0.07964940f, 
    -0.00896589f, -0.31328970f, -0.16065226f, 0.00216961f, 0.09328721f, -0.00448425f, 0.11602526f, -0.00886508f, 
    -0.03990423f, 0.00314634f, 0.02872227f, 0.07377484f, 0.04826905f, 0.22634831f, 0.06670151f, -0.03382651f, 
    -0.08570935f, 0.03048368f, 0.04890540f, -0.00943710f, -0.00468115f, -0.03139566f, 0.00621156f, 0.03323498f, 
    -0.02267111f, 0.12777373f, 0.06593535f, -0.09404132f, -0.05220635f, 0.00255347f, 0.00965935f, -0.06270494f, 
    0.06302049f, -0.22439967f, 0.05817654f, 0.05107334f, -0.02210242f, 0.08525635f, 0.10684929f, 0.04209826f, 
    -0.05240374f, 0.02777179f, 0.15357812f, 0.05190856f, -0.12433837f, 0.00664953f, -0.07454945f, 0.01903535f, 
    -0.19726315f, 0.20041144f, 0.14280656f, 0.08338413f, -0.02955986f, 0.02294904f, 0.09007698f, 0.10878947f, 
    -0.08295134f, -0.00295663f, -0.07308783f, -0.01958136f, 0.03450271f, 0.31583673f, 0.11783101f, 0.02594627f, 
    -0.02510547f, 0.16470064f, 0.01527235f, -0.03821580f, -0.14408818f, -0.10717667f, -0.05278575f, 0.03617097f, 
    0.26560399f, 0.06620035f, -0.20316060f, 0.16411480f, -0.06525674f, 0.10487280f, 0.05378282f, -0.06362752f, 
    0.07019971f, -0.06106704f, 0.08789149f, 0.14141536f, -0.18324465f, -0.08335416f, 0.29866067f, -0.05252885f, 
    0.07177750f, -0.02493692f, 0.05303299f, -0.09170919f, -0.12659486f, -0.00369597f, 0.07142199f, 0.01317499f, 
    -0.12059810f, 0.09241010f, 0.31224719f, 0.12989742f, 0.04987086f, -0.00782645f, 0.11182012f, 0.16786449f, 
    -0.04992990f, -0.02955275f, 0.02308938f, 0.12328076f, -0.21262118f, -0.16479807f, -0.02729124f, 0.24483845f, 
    -0.02866715f, 0.02724458f, -0.10442195f, -0.01151479f, 0.08213531f, 0.08940168f, -0.14731768f, -0.11705485f, 
    0.06400050f, 0.17993850f, 0.01781220f, 0.08488917f, -0.11112867f, 0.09439893f, -0.01780477f, 0.14255823f, 
    -0.09011675f, 0.03691353f, 0.03631556f, 0.16720758f, 0.14085637f, 0.10255059f, 0.05272287f, -0.24892010f, 
    0.09195003f, -0.03693335f, 0.01544670f, -0.04124125f, -0.06904039f, 0.02738176f, -0.06274447f, 0.08949187f, 
    -0.14898597f, -0.18822092f, 0.09803548f, 0.02408955f, -0.14805454f, 0.12827900f, -0.03815693f, 0.11809191f, 
    0.08529343f, 0.11314770f, 0.01233384f, -0.04132908f, 0.00895747f, -0.31620982f, 0.09691975f, -0.07315016f, 
    -0.03415759f, -0.03848916f, 0.04969030f, -0.12302090f, 0.06285179f, 0.06834590f, 0.11920953f, -0.08564516f, 
    -0.01998772f, 0.03141018f, -0.05892269f, 0.01221693f, 0.04316886f, 0.03217905f, 0.00538505f, 0.08075481f, 
    0.08283292f, -0.02792304f, -0.05312661f, 0.08714877f, -0.07833147f, -0.07077575f, -0.12625083f, 0.21187252f, 
    -0.05429155f, -0.10106664f, -0.04406733f, -0.04185214f, -0.03672785f, 0.00101971f, -0.02246049f, -0.09650039f, 
    0.01272083f, 0.16676530f, -0.09692813f, -0.07878207f, -0.00375904f, -0.02123695f, -0.07539327f, 0.12175196f, 
    -0.02900515f, 0.02369490f, -0.03817276f, -0.08660661f, -0.02644729f, -0.10163400f, 0.18313627f, 0.10056911f, 
    0.00543334f, -0.01323626f, 0.10491028f, 0.01679289f, 0.01161270f, 0.09087616f, 0.01940608f, -0.02660451f, 
    0.05477012f, 0.14322738f, 0.10819874f, -0.18384013f, 0.07098000f, -0.02348645f, 0.05831684f, -0.09556857f, 
    -0.01274765f, 0.09287734f, 0.14751635f, 0.18700203f, 0.21760280f, 0.07875726f, -0.01132384f, -0.11398802f, 
    0.04341875f, -0.02077106f, 0.09670266f, -0.05118482f, 0.17205861f, -0.03296306f, 0.15292583f, 0.00780645f, 
    0.14195502f, 0.06765528f, -0.05057889f, 0.11030778f, -0.10681461f, -0.17600693f, 0.03254129f, 0.03039131f, 
    0.12593052f, -0.05644437f, 0.08004892f, -0.04607193f, -0.35345793f, -0.06191539f, 0.27964839f, -0.04697636f, 
    0.05302814f, -0.02863507f, 0.17239790f, -0.06001701f, 0.11354202f, 0.01030780f, 0.01265787f, 0.02750370f, 
    -0.33220756f, 0.02921594f, -0.06276163f, -0.15082198f, 0.11864718f, -0.04207947f, -0.18882534f, 0.09758674f, 
    0.00465460f, 0.17254785f, -0.05589630f, 0.07571705f, -0.20046535f, 0.28393477f, -0.23173402f, -0.03877582f, 
    -0.00850431f, 0.15667941f, 0.03250403f, 0.02975302f, 0.12929632f, 0.06538770f, -0.07721622f, 0.05792082f, 
    0.10517775f, 0.07826399f, 0.05781265f, 0.14322855f, -0.05908659f, -0.09633957f, 0.08228155f, 0.12548040f, 
    -0.13190906f, 0.00212440f, 0.00095999f, -0.16397712f, -0.18011206f, 0.20562479f, 0.08991356f, 0.11648826f, 
    0.09967200f, -0.01665299f, -0.08176754f, -0.04063900f, 0.09659016f, 0.00385988f, -0.01957058f, -0.01924879f, 
    -0.42976466f, -0.07611810f, -0.00389212f, -0.01575521f, 0.10457382f, -0.00236587f, -0.02897249f, 0.07724753f, 
    0.00052184f, 0.02554353f, 0.00847755f, 0.07794575f, 0.16723780f, 0.07489780f, -0.10004357f, -0.24094550f, 
    -0.06937838f, -0.04900002f, -0.05271051f, 0.06712311f, 0.06290118f, 0.02573459f, -0.04455774f, 0.03730015f, 
    -0.25096968f, -0.11486987f, 0.13923545f, -0.01737545f, 0.05456608f, 0.14252973f, -0.06503239f, -0.03530112f, 
    0.07993824f, 0.03850903f, 0.11459058f, 0.00092777f, -0.10228863f, -0.15212919f, 0.05651661f, 0.00480849f, 
    0.03296289f, 0.07713253f, 0.09433867f, -0.07387263f, 0.14572994f, 0.02830778f, -0.03808196f, 0.02417262f, 
    -0.18355177f, 0.04609130f, -0.02900567f, 0.32096460f, -0.11183517f, 0.13243908f, -0.03974047f, 0.08809013f, 
    0.05122470f, 0.07605825f, 0.07379065f, 0.01854052f, -0.25702056f, -0.18677862f, -0.07330883f, 0.09787814f, 
    0.14351125f, 0.02481346f, -0.00491474f, -0.07568460f, 0.20277920f, 0.04715640f, 0.00054515f, 0.06892277f, 
    -0.06498494f, -0.12515816f, -0.08811232f, -0.16415089f, 0.23813865f, -0.00861734f, 0.00684569f, 0.02281923f, 
    0.12760676f, 0.06931036f, -0.00645612f, 0.01240775f, 0.28723779f, 0.32060075f, -0.10203311f, -0.04994069f, 
    0.02180522f, 0.08839814f, 0.16599309f, 0.06529579f, -0.00575247f, 0.08025757f, -0.12258187f, 0.03345968f, 
    -0.06492647f, -0.00468729f, -0.00508035f, -0.01317394f, -0.07401446f, -0.04925537f, -0.00872605f, -0.01844404f, 
    0.04854481f, -0.02232549f, -0.03234617f, 0.02955249f, -0.05314165f, -0.00112650f, 0.00660324f, 0.01900974f, 
    -0.08149521f, -0.06493936f, 0.01708466f, -0.01253106f, -0.01945887f, -0.03069203f, -0.00603410f, -0.06878754f, 
    0.02425480f, -0.06753629f, -0.03262354f, 0.04761883f, 0.02998050f, -0.07153545f, 0.01950070f, 0.05467085f, 
    -0.02930576f, -0.08174692f, -0.02247216f, -0.02881882f, 0.06437024f, -0.01136434f, 0.03262155f, 0.00885146f, 
    0.01743690f, 0.02460943f, -0.01428690f, -0.04879484f, -0.03183156f, 0.05445328f, -0.00857533f, -0.03325489f, 
    -0.05750601f, -0.06569019f, -0.00377965f, 0.05450334f, -0.04768059f, 0.04266994f, -0.01455858f, -0.04312882f, 
    -0.07647581f, 0.01694062f, -0.00771820f, 0.02269913f, -0.08186995f, 0.05075715f, -0.01024528f, -0.06643863f, 
    0.00492140f, 0.04279345f, 0.01409051f, 0.02998945f, 0.03487188f, 0.06154376f, 0.04484590f, -0.08023612f, 
    -0.07558575f, 0.01040496f, -0.03489249f, 0.04023494f, -0.03549699f, 0.04983608f, -0.04810526f, -0.03344339f, 
    -0.02071831f, -0.03964040f, 0.04621790f, 0.01631434f, 0.03467844f, -0.00207158f, 0.02403303f, 0.04353610f, 
    0.02149914f, 0.04143722f, 0.06068274f, -0.07445888f, -0.07239341f, 0.03735554f, 0.03876226f, -0.00902211f, 
    0.00224029f, 0.03348325f, -0.02323369f, -0.04968460f, 0.03309273f, -0.05978724f, -0.06636460f, -0.04482333f, 
    0.01405660f, 0.04751872f, 0.00823754f, 0.00410174f, -0.01874735f, -0.02485914f, 0.03271047f, 0.00125939f, 
    -0.02719430f, 0.04040188f, -0.06495606f, -0.04933174f, -0.00253346f, 0.01994436f, 0.02633127f, 0.00856182f, 
    0.01622314f, -0.04366735f, -0.02689707f, 0.00122566f, 0.03891563f, -0.07812812f, -0.02894317f, 0.02665394f, 
    -0.00314939f, 0.02842001f, 0.05526292f, 0.01573893f, 0.00614836f, -0.05371628f, 0.05048010f, 0.02078903f, 
    0.05141376f, 0.01739275f, 0.00274857f, 0.04691754f, 0.00031706f, 0.03157262f, -0.00143476f, 0.02892823f, 
    -0.06605928f, -0.05270793f, -0.02962144f, -0.02177127f, -0.01291898f, -0.00696901f, -0.04990628f, -0.02952657f, 
    0.01094419f, -0.03609185f, -0.06566414f, 0.01312106f, -0.07016645f, 0.02062214f, 0.02554249f, -0.00626262f, 
    -0.01967808f, -0.05491377f, 0.03454385f, -0.04781741f, -0.06175635f, -0.03118789f, 0.03122662f, 0.06054545f, 
    -0.02670459f, -0.05724167f, 0.00212275f, -0.02433689f, 0.03551583f, 0.06498070f, -0.04381895f, -0.02190545f, 
    -0.02530275f, -0.01511832f, 0.02203500f, 0.04717981f, -0.07014570f, -0.07866174f, -0.01643272f, -0.01607889f, 
    0.06364248f, -0.02847732f, -0.00862896f, -0.08272867f, -0.01820251f, -0.01599675f, -0.01676046f, -0.05197071f, 
    0.05828223f, -0.15776557f, -0.12290959f, 0.15223590f, -0.05305647f, 0.24218991f, 0.03894817f, 0.12491594f, 
    0.14276837f, 0.01575619f, 0.02999176f, 0.06660781f, -0.20524241f, -0.16014123f, -0.04173557f, 0.07183678f, 
    0.09538415f, 0.16635117f, 0.00608050f, 0.01956732f, -0.05977017f, -0.04828039f, 0.01341657f, 0.05267981f, 
    -0.02139863f, -0.11230571f, -0.12627099f, -0.14116625f, 0.12523487f, 0.03663106f, 0.03571003f, -0.07434152f, 
    -0.14199242f, 0.06798843f, -0.01503492f, 0.12365066f, 0.29771650f, -0.14913636f, -0.04104370f, 0.04183354f, 
    0.06353578f, 0.18554513f, -0.13439652f, -0.01430518f, 0.01289618f, 0.02921913f, 0.11286931f, -0.09869546f, 
    0.39808774f, 0.02867543f, 0.15072459f, 0.09774122f, -0.01908367f, 0.04942691f, 0.03849856f, 0.00556516f, 
    0.07848762f, 0.00368182f, 0.08607531f, 0.17262918f, -0.16820621f, -0.12019644f, 0.26812810f, 0.01398838f, 
    0.00654636f, -0.00904364f, 0.07290831f, 0.05547832f, 0.07523568f, 0.02273411f, -0.00803528f, 0.13268892f, 
    -0.14367129f, -0.35008380f, -0.22441395f, -0.28794342f, 0.06133715f, 0.01822080f, -0.04709246f, -0.00157089f, 
    0.10550967f, -0.01040243f, -0.08765077f, 0.06847803f, 0.08729936f, 0.19115497f, 0.28019249f, -0.09515440f, 
    -0.20375872f, 0.10331825f, 0.08794082f, 0.04024664f, -0.09720924f, 0.11457343f, 0.02845610f, -0.05221715f, 
    0.16898370f, -0.07738865f, 0.01830159f, 0.04217611f, -0.19923663f, -0.01435942f, 0.05296224f, 0.01822742f, 
    0.11507393f, -0.05134024f, -0.04091176f, 0.05694526f, -0.36131305f, 0.04384423f, 0.05510351f, 0.11445925f, 
    0.04635697f, -0.01040727f, 0.09762232f, -0.01922706f, -0.04670956f, -0.10678420f, 0.12489355f, 0.04225787f, 
    -0.09155117f, 0.10512158f, 0.24762617f, 0.03979843f, -0.10128576f, -0.08826380f, 0.01634672f, 0.03982744f, 
    -0.04490506f, -0.04863221f, -0.06735861f, 0.10074943f, -0.09462259f, -0.00898309f, 0.18105622f, 0.14449769f, 
    -0.09778634f, -0.09667854f, 0.00389463f, 0.00705325f, -0.17548789f, 0.09845790f, 0.08713483f, 0.05697322f, 
    0.02873138f, -0.34130669f, -0.02608828f, -0.24793631f, -0.03199810f, 0.11897891f, 0.17750943f, 0.06595144f, 
    0.07754649f, -0.11708541f, 0.10832938f, -0.16612485f, 0.03393518f, 0.10811946f, 0.26670489f, -0.02023682f, 
    -0.12016466f, 0.04638421f, -0.06782203f, 0.01834875f, 0.02773890f, -0.04210738f, 0.06942236f, 0.02741999f, 
    0.03117206f, 0.38794973f, 0.20778017f, 0.01848818f, -0.13376920f, -0.12335058f, 0.02462878f, -0.00551427f, 
    -0.05511061f, 0.04291058f, 0.09302874f, 0.09839521f, -0.00221153f, -0.19381462f, -0.07332543f, 0.13480996f, 
    0.01169808f, 0.03669960f, -0.09006483f, -0.07052865f, -0.10311919f, -0.10136378f, 0.05082993f, 0.05030943f, 
    0.02494259f, -0.02154497f, -0.00236097f, -0.06852981f, -0.07975481f, -0.07103009f, -0.00990585f, -0.00066889f, 
    -0.09190391f, -0.10621461f, -0.05181596f, -0.00078740f, 0.10459241f, 0.19855304f, -0.17084241f, -0.07910697f, 
    0.08175631f, 0.03808976f, 0.10374010f, -0.08665325f, -0.02158341f, -0.06229510f, 0.00681808f, -0.02673840f, 
    -0.08195775f, 0.01834650f, 0.22919184f, 0.19917265f, -0.02984421f, -0.07800071f, -0.10341603f, 0.05423674f, 
    0.02419657f, 0.13346967f, -0.09123729f, -0.06875857f, 0.13488570f, 0.13986982f, -0.03309887f, -0.14470132f, 
    0.01591920f, 0.14708830f, 0.19174251f, -0.05547486f, -0.05064401f, -0.07522032f, -0.03937153f, 0.04332882f, 
    0.37571335f, -0.15276001f, 0.24717797f, 0.08380707f, -0.00268445f, -0.05722283f, 0.12295588f, -0.01392137f, 
    -0.05622611f, 0.05425505f, 0.10177393f, 0.15110275f, 0.16295119f, -0.13746002f, 0.08356541f, -0.00220755f, 
    0.28328353f, -0.15550786f, -0.03197261f, 0.10191962f, 0.02713813f, 0.01378090f, 0.12142921f, 0.07007441f, 
    -0.06145084f, 0.21193838f, 0.30468085f, 0.23254183f, -0.10567275f, -0.01741066f, 0.01046591f, 0.11544920f, 
    -0.00504037f, 0.13973293f, 0.06334946f, -0.10513728f, -0.41161677f, -0.18734804f, 0.05544135f, -0.05246817f, 
    0.00311271f, -0.15802562f, 0.02347808f, 0.01018936f, 0.03647849f, 0.00309853f, -0.03208055f, -0.03986450f, 
    0.12672196f, 0.34654301f, 0.09552955f, 0.07618633f, -0.01836054f, 0.07530122f, -0.06490077f, 0.17007804f, 
    -0.06465574f, 0.03720035f, 0.03068996f, 0.06067429f, 0.12459340f, -0.14964107f, -0.02563618f, 0.00654893f, 
    0.07809519f, -0.09280872f, 0.06667257f, -0.02295617f, -0.09123478f, 0.09135977f, -0.15384881f, 0.13412909f, 
    -0.01695500f, -0.16918021f, -0.06037582f, 0.08260060f, 0.03821035f, 0.01137740f, -0.12438276f, -0.00214357f, 
    0.04922211f, -0.08101358f, 0.02663507f, -0.13628531f, 0.17787908f, -0.32387733f, -0.00669803f, -0.10834787f, 
    0.05677976f, 0.04509772f, 0.06538960f, 0.00204322f, 0.07549244f, 0.03573386f, -0.02877726f, 0.03237528f, 
    0.01218576f, 0.23318690f, 0.01359710f, 0.07013888f, 0.03128642f, 0.06580625f, -0.11911537f, 0.05870584f, 
    0.12669654f, 0.15899253f, 0.01707149f, -0.01918969f, -0.01994441f, -0.07339177f, -0.20242183f, 0.26214203f, 
    0.01798013f, -0.00160783f, -0.06027328f, -0.06740145f, -0.09839953f, -0.11347567f, -0.02467877f, -0.16532864f, 
    0.18283933f, 0.26753592f, 0.06833226f, 0.02949360f, 0.14381188f, -0.09304117f, -0.09892713f, -0.00463520f, 
    0.04968478f, -0.05259795f, 0.03051296f, -0.08725433f, -0.25069100f, -0.22032666f, 0.31867474f, -0.24280274f, 
    -0.02577925f, -0.14185338f, 0.03721272f, -0.15939939f, -0.02125957f, 0.06780671f, 0.07123390f, 0.01962842f, 
    0.00788197f, 0.04507542f, 0.01624335f, -0.03506360f, 0.04695216f, -0.02635292f, 0.02887625f, -0.07141721f, 
    0.04308911f, -0.04440783f, -0.07047923f, 0.00132773f, -0.02496267f, -0.04126675f, -0.07428037f, -0.00642733f, 
    -0.01946989f, -0.05648592f, 0.05579126f, 0.03088270f, 0.05363109f, -0.06105345f, 0.03607937f, 0.06519661f, 
    -0.03319029f, -0.01614730f, 0.05849873f, -0.07742922f, 0.03772438f, 0.00276000f, -0.00732854f, 0.05447236f, 
    0.06074606f, -0.05552818f, -0.04662503f, 0.03329835f, 0.03292427f, 0.02842592f, -0.07033806f, -0.02223853f, 
    0.03445950f, -0.05737238f, -0.03501138f, -0.04001689f, 0.05257510f, -0.07543904f, 0.05449500f, 0.04888311f, 
    -0.00693958f, -0.07549313f, 0.01124753f, -0.06419457f, -0.04178530f, -0.03570639f, -0.06103742f, 0.02093746f, 
    0.06356616f, 0.02345663f, -0.00814136f, 0.03163245f, 0.05986485f, -0.00958227f, 0.05975732f, -0.06318688f, 
    -0.06678221f, -0.03520984f, -0.04840180f, -0.07501403f, -0.01500986f, -0.03869173f, -0.03041348f, -0.03483682f, 
    -0.03654704f, 0.03960402f, 0.04473195f, 0.04002643f, -0.05282908f, -0.03807454f, 0.05228850f, 0.00200769f, 
    0.05668800f, 0.00256101f, -0.02336764f, -0.04014425f, 0.00422372f, -0.03627085f, 0.00343312f, -0.04047801f, 
    -0.00993124f, -0.02107080f, -0.03608421f, -0.04767499f, 0.01931810f, -0.06660813f, 0.01045168f, -0.03311530f, 
    0.03328201f, -0.05103029f, 0.02082477f, 0.06196906f, 0.01608759f, 0.00651542f, -0.01846832f, 0.02761308f, 
    -0.00338684f, -0.04013500f, 0.03127544f, -0.02285367f, 0.01965353f, -0.01730075f, 0.01991787f, -0.02092048f, 
    0.01153235f, -0.04969054f, -0.06482383f, 0.03114310f, -0.05864627f, 0.02357054f, -0.04019228f, -0.06288354f, 
    -0.00167348f, 0.04364824f, -0.02821580f, 0.02508334f, -0.06073369f, -0.06339315f, 0.01374029f, -0.05544376f, 
    -0.00897747f, -0.03744632f, -0.07541768f, -0.01586485f, 0.02820710f, -0.07728306f, 0.05134702f, -0.05170437f, 
    0.04414597f, 0.02683103f, 0.03821811f, -0.06499884f, -0.04370657f, -0.07281011f, -0.02642176f, 0.02771218f, 
    -0.00051600f, -0.02157726f, -0.02072901f, -0.01430315f, -0.04365597f, -0.07420068f, -0.03780225f, 0.00024807f, 
    -0.03447877f, 0.03334820f, -0.03061408f, -0.02433351f, -0.03999775f, -0.05047561f, 0.05409376f, -0.04719438f, 
    -0.02516482f, 0.06358452f, -0.06047121f, -0.06074348f, -0.06423474f, 0.03406017f, 0.01831007f, -0.07236178f, 
    0.03217772f, 0.00445396f, 0.06506328f, 0.04772498f, 0.00846266f, 0.06617671f, -0.06187253f, 0.05577356f, 
    0.03364279f, 0.00323333f, -0.05618139f, -0.06281414f, -0.06005732f, -0.03480837f, 0.06496762f, 0.03284777f, 
    -0.04391729f, 0.01096941f, -0.02866600f, -0.02322868f, 0.03823154f, -0.06387082f, -0.07418437f, -0.04226922f, 
    -0.01636319f, 0.00993461f, -0.00406993f, -0.07540266f, -0.03834050f, -0.05148689f, 0.02411604f, 0.03062704f, 
    -0.00582610f, 0.03992874f, -0.01880384f, 0.00321015f, -0.07625482f, -0.05405855f, 0.00662773f, -0.07826259f, 
    -0.01867549f, -0.06051107f, -0.03148865f, 0.03047657f, 0.01404668f, -0.05486244f, -0.01282112f, 0.01437701f, 
    0.00444454f, -0.00587813f, -0.04021753f, -0.06423885f, -0.05846070f, -0.03965718f, 0.00674484f, -0.01409131f, 
    0.00273769f, -0.07274184f, -0.06078061f, -0.07228972f, 0.01505180f, -0.02697956f, -0.06061655f, -0.02102734f, 
    -0.07100596f, 0.00629364f, -0.06959755f, -0.02800676f, -0.03437648f, -0.03491895f, -0.00545233f, 0.01618101f, 
    0.00658638f, -0.08040675f, -0.01971989f, 0.05583982f, -0.02301769f, -0.05300907f, 0.05200223f, 0.05174651f, 
    0.05450105f, -0.02525564f, -0.00001131f, 0.00436449f, -0.06028363f, -0.08098014f, 0.05483935f, 0.02418273f, 
    -0.00829052f, 0.02633513f, 0.03146119f, 0.01246686f, -0.05623334f, -0.05509269f, -0.03986907f, 0.03407574f, 
    0.03896658f, 0.03908722f, -0.07099596f, -0.05743248f, -0.06182459f, -0.02034163f, -0.02174052f, -0.02009653f, 
    0.02955529f, -0.00990650f, 0.02763796f, -0.03499857f, 0.01224373f, -0.03572198f, -0.05477107f, -0.03122928f, 
    -0.02594262f, 0.01816938f, -0.05989322f, 0.05011903f, -0.01662656f, 0.03045390f, -0.06610592f, -0.03734181f, 
    -0.07016983f, 0.04787414f, -0.06155954f, -0.01380137f, 0.02047225f, 0.00432322f, -0.02842227f, 0.02588857f, 
    -0.05510432f, 0.04876608f, -0.00034785f, -0.06842396f, 0.04639113f, 0.03160997f, -0.02713623f, 0.02029570f, 
    0.01818990f, -0.00506835f, 0.00109982f, -0.00066515f, -0.00838177f, 0.02272018f, 0.01709468f, 0.00050131f, 
    0.00924806f, 0.00680374f, 0.01928128f, 0.02199182f, 0.04712839f, 0.04320141f, 0.01138952f, -0.01491492f, 
    0.02240202f, -0.01682587f, -0.04988740f, -0.02284371f, -0.03118245f, -0.04648184f, 0.04496105f, -0.08008040f, 
    0.06004799f, 0.05289618f, -0.03037041f, 0.04399624f, 0.05306345f, -0.04655919f, 0.00373912f, -0.00602502f, 
    0.04703308f, 0.03764882f, 0.00619405f, -0.06129423f, -0.04934233f, -0.04773498f, 0.01458146f, -0.08044206f, 
    -0.04309886f, -0.02755746f, -0.00892375f, -0.01288548f, -0.06328009f, -0.01593042f, 0.00467515f, -0.06406317f, 
    0.03646965f, -0.02954548f, -0.04531198f, 0.00867015f, -0.06143804f, -0.06310542f, 0.01615397f, -0.06098119f, 
    0.05942048f, -0.01531117f, 0.02929278f, -0.00299862f, -0.03035942f, -0.06001978f, -0.04440835f, -0.07758768f, 
    -0.00521498f, -0.04649108f, 0.02024669f, -0.07655758f, -0.00819657f, -0.01851284f, -0.01130768f, -0.05140421f, 
    0.00675948f, -0.01661154f, 0.02852982f, -0.04121302f, -0.04056416f, -0.04499357f, -0.00841382f, -0.05061117f, 
    -0.05651308f, -0.06329772f, -0.09968022f, -0.02418175f, 0.04396832f, 0.02531130f, -0.00699369f, 0.11810634f, 
    0.01035130f, 0.11171471f, 0.05849147f, 0.14733960f, -0.01987844f, 0.11948380f, 0.14743733f, 0.16998756f, 
    0.09425121f, 0.10161572f, 0.06711550f, 0.03229025f, -0.12186447f, 0.01233270f, 0.03252881f, 0.02552554f, 
    -0.02937612f, 0.02664436f, -0.01022790f, -0.08999798f, 0.04601209f, 0.15810481f, -0.02871735f, 0.08204117f, 
    0.05301684f, 0.04247629f, -0.05499383f, 0.11558552f, 0.04272519f, 0.09123067f, 0.00754303f, 0.14207493f, 
    -0.16929245f, 0.06592558f, -0.03111769f, -0.01262001f, 0.13402414f, 0.14711118f, 0.18728381f, -0.06275606f, 
    0.27342004f, 0.18415707f, -0.09942805f, 0.08183047f, -0.12739240f, 0.09616560f, -0.05606148f, -0.00722195f, 
    0.10294364f, 0.08267850f, 0.02933702f, -0.05071736f, -0.27676710f, -0.29657203f, 0.10466390f, -0.09279230f, 
    -0.02680706f, 0.11849680f, -0.00964636f, 0.01629880f, 0.04876952f, 0.01389052f, -0.12421242f, -0.00285126f, 
    0.13265932f, 0.18772332f, -0.00246978f, 0.07562906f, 0.04119366f, 0.03891309f, -0.12075032f, -0.05195372f, 
    -0.02553812f, 0.07717037f, 0.06709631f, -0.00164681f, 0.24449828f, -0.14150055f, 0.04835661f, -0.15390505f, 
    -0.17978989f, 0.00288228f, -0.13923280f, 0.07384812f, -0.07783467f, 0.03126346f, 0.00772703f, -0.02734554f, 
    0.01803393f, -0.02144456f, 0.05758495f, 0.00843067f, -0.02292362f, 0.08669499f, 0.04961149f, 0.02696698f, 
    0.10361707f, 0.08547176f, -0.01102011f, -0.04915984f, -0.09963157f, 0.08427936f, -0.01201946f, 0.03090589f, 
    0.11599725f, 0.01475916f, 0.15229914f, 0.01703943f, 0.03885828f, 0.02932138f, -0.07408506f, -0.05120268f, 
    -0.32366556f, -0.16758841f, 0.30831251f, -0.15510149f, 0.00023339f, -0.02669564f, 0.01443855f, 0.04123998f, 
    0.00560925f, -0.07269247f, 0.01177818f, 0.04393780f, -0.32728127f, 0.13134639f, 0.15576968f, 0.09163226f, 
    -0.08513286f, -0.06910615f, -0.08179197f, -0.03518867f, -0.02387840f, 0.02627111f, -0.05631322f, 0.03844831f, 
    0.19150895f, -0.17746945f, 0.19293264f, -0.11539023f, 0.09526100f, 0.06407052f, 0.04449005f, 0.00702969f, 
    -0.01737759f, -0.00591704f, 0.09744551f, -0.00588035f, -0.09881897f, 0.03865770f, 0.19405480f, -0.02181679f, 
    -0.07453957f, 0.08366695f, 0.11083873f, 0.12580384f, 0.03920615f, -0.05071519f, 0.07013962f, -0.03263783f, 
    -0.41958204f, 0.43020394f, 0.20435522f, -0.10461911f, -0.01437392f, 0.07965351f, 0.00078791f, -0.09956596f, 
    -0.02860111f, -0.00320326f, 0.03457963f, 0.07256746f, 0.43075937f, -0.23652613f, -0.10421707f, 0.07542323f, 
    0.12052414f, 0.07115640f, -0.05184954f, 0.05078797f, -0.02520801f, -0.18029067f, -0.00755071f, 0.04069737f, 
    0.17287935f, -0.14512165f, -0.12349381f, 0.13165395f, 0.02860620f, 0.06764654f, 0.11683775f, -0.06411862f, 
    0.13778765f, 0.06158300f, 0.03678724f, -0.02075562f, -0.24839129f, -0.03741750f, -0.14486870f, 0.16729568f, 
    0.00890248f, -0.03502620f, -0.07071327f, -0.12903842f, 0.12709126f, 0.00836801f, 0.14563294f, -0.05523025f, 
    -0.22945838f, 0.02415581f, -0.17261103f, 0.09902655f, 0.09977982f, 0.07261021f, 0.08062359f, 0.07998142f, 
    0.03437562f, -0.04017654f, -0.00547085f, 0.14765738f, 0.08153440f, -0.00831903f, -0.14961654f, 0.03108430f, 
    0.23859389f, -0.05273601f, 0.01756370f, 0.03722914f, -0.04881421f, -0.22391109f, -0.14327325f, -0.02060563f, 
    0.05657144f, 0.23322621f, 0.19230941f, -0.27705151f, 0.09186506f, 0.07376180f, -0.02373637f, 0.09403260f, 
    0.01112110f, 0.07796340f, -0.09279839f, 0.11912080f, 0.51941746f, -0.19341916f, -0.02141387f, 0.05314461f, 
    -0.22272927f, 0.06959876f, -0.06852619f, -0.00051871f, -0.05383902f, -0.01181610f, 0.08220135f, -0.00738523f, 
    -0.13329573f, -0.22151828f, -0.10906179f, 0.11156126f, 0.17255273f, 0.12541221f, 0.07534747f, 0.25439760f, 
    -0.02281169f, 0.09314908f, 0.00456584f, -0.13952234f, -0.10933599f, 0.23325752f, -0.04274841f, -0.07708506f, 
    0.08551033f, 0.16715109f, -0.16096750f, -0.17140888f, 0.07192391f, -0.06204161f, 0.11945590f, -0.05496596f, 
    -0.22208290f, 0.17409253f, 0.05372230f, 0.14077830f, 0.10988233f, -0.15904112f, -0.01669585f, 0.02466143f, 
    0.17608052f, 0.00790244f, 0.18190353f, 0.10476860f, 0.06456071f, -0.21714602f, -0.07123610f, -0.07652280f, 
    0.06326235f, 0.11355358f, -0.03370877f, 0.00028181f, -0.03080415f, -0.15555269f, 0.00845459f, -0.04554407f, 
    0.30992109f, 0.33314741f, 0.04108870f, 0.05888380f, 0.01298836f, 0.05401630f, 0.13890663f, -0.07931476f, 
    -0.05200434f, 0.07388468f, 0.07520889f, -0.07923012f, 0.11368740f, 0.20571670f, 0.02736489f, 0.00363049f, 
    -0.13441494f, -0.04178375f, 0.09687160f, 0.00609094f, -0.15218432f, -0.04735338f, 0.12579916f, -0.07737346f, 
    0.02059005f, 0.05171592f, -0.05696024f, 0.22110239f, 0.01684533f, 0.05424553f, 0.01270078f, 0.14765227f, 
    -0.02949607f, -0.00074299f, -0.11862490f, -0.14766228f, 0.01224813f, 0.20811825f, -0.00217350f, -0.02031544f, 
    0.13594146f, -0.03533126f, -0.07150398f, -0.25396574f, -0.06777261f, 0.05986279f, -0.09261968f, -0.01854430f, 
    0.22481853f, 0.21420580f, 0.24629068f, -0.03171101f, 0.04399527f, 0.10629854f, 0.10959233f, -0.00806462f, 
    -0.12135761f, 0.14046746f, -0.03177956f, 0.13393897f, 0.24640563f, -0.02699453f, -0.17668900f, 0.03935330f, 
    -0.02933290f, -0.13101014f, -0.02960746f, 0.04102361f, -0.06761220f, -0.03471195f, 0.02877340f, -0.02416057f, 
    0.02946880f, 0.02161272f, 0.00176126f, 0.04512120f, 0.03236530f, 0.00285426f, -0.01648807f, -0.13615045f, 
    -0.06878332f, -0.04887502f, 0.08275125f, -0.08828025f, -0.01957641f, 0.06731399f, -0.10150121f, -0.02953933f, 
    0.02825801f, -0.01923124f, 0.02237182f, -0.00413094f, -0.01475941f, 0.10817444f, 0.10685172f, 0.05831678f, 
    -0.26095167f, 0.12790075f, 0.13177061f, 0.16861509f, -0.00241916f, -0.07078037f, 0.00883006f, -0.02741802f, 
    -0.06254920f, -0.07425139f, 0.05940636f, 0.16905119f, 0.06014067f, 0.25749522f, 0.04252724f, -0.17562161f, 
    0.14982317f, -0.06833050f, 0.06340422f, -0.07506017f, 0.01993945f, -0.04391258f, -0.14282651f, -0.15315862f, 
    0.07906884f, 0.05707153f, 0.05101000f, -0.21549533f, 0.18937178f, 0.22154112f, -0.04414126f, 0.16432421f, 
    -0.04501399f, -0.05084374f, -0.02025714f, 0.19314611f, 0.16063137f, -0.06245438f, 0.03775460f, 0.06705529f, 
    -0.01814585f, -0.06021193f, 0.03681314f, 0.02755163f, -0.00167358f, 0.14523883f, 0.02254226f, 0.08350392f, 
    -0.11901015f, 0.06296666f, 0.21753879f, 0.33526999f, -0.05157188f, -0.01441305f, 0.08150891f, 0.17252205f, 
    0.06906333f, 0.01098506f, 0.01689484f, 0.01447783f, 0.02461115f, 0.03498681f, 0.06446649f, -0.05624560f, 
    -0.12502714f, 0.18622987f, -0.04420073f, -0.07876003f, 0.02566605f, -0.13196264f, -0.22138360f, -0.12561513f, 
    -0.26479423f, 0.05042133f, -0.13826145f, 0.17634642f, 0.10306437f, 0.17376924f, 0.07479877f, 0.03069280f, 
    0.04196138f, 0.04208248f, 0.10053906f, 0.25204524f, 0.27159804f, -0.04996205f, 0.02862878f, -0.36195382f, 
    0.07177512f, -0.01332603f, 0.03872887f, -0.05065808f, -0.05340742f, -0.07286375f, -0.11643825f, -0.02581643f, 
    -0.29884541f, 0.02370285f, 0.20992561f, 0.00435635f, 0.01703997f, 0.09362031f, 0.04990333f, 0.11105923f, 
    0.00122773f, 0.02803576f, -0.04134327f, -0.14286986f, -0.32032433f, -0.15646358f, 0.03778701f, -0.06986640f, 
    -0.05730675f, -0.01931301f, 0.03262215f, -0.11314023f, 0.04798863f, 0.01674128f, 0.00101808f, -0.10578129f, 
    -0.13913774f, -0.02292334f, 0.10136230f, 0.26966780f, -0.01320429f, -0.03396748f, 0.02045688f, 0.14159130f, 
    0.06079397f, -0.04487319f, 0.13034257f, 0.00071309f, -0.09325240f, 0.21457583f, 0.06408736f, -0.10311690f, 
    0.06665602f, -0.00991796f, -0.00691614f, 0.00058076f, 0.02321791f, 0.04670943f, -0.01997738f, -0.01289409f, 
    0.01244197f, 0.31611732f, -0.09442169f, -0.07565936f, -0.04302265f, 0.03428588f, 0.00831598f, 0.20921806f, 
    -0.00492323f, -0.03162496f, 0.00655579f, -0.01488466f, 0.30849519f, -0.13246526f, -0.13937193f, 0.05564483f, 
    -0.10661453f, 0.08867780f, 0.14368452f, -0.05339871f, 0.00765730f, -0.01775041f, 0.06738017f, -0.08321719f, 
    -0.05468601f, -0.04673155f, -0.01778293f, -0.07490224f, -0.03508521f, -0.00828913f, -0.01755883f, -0.03659723f, 
    0.03272466f, 0.00955937f, 0.02744655f, 0.04638135f, -0.08055359f, -0.06639457f, -0.04170385f, 0.00813074f, 
    -0.01004095f, -0.01108062f, -0.05756792f, -0.07806444f, 0.04944479f, 0.00885637f, 0.05805396f, 0.00866967f, 
    -0.06914415f, 0.03385986f, 0.00047099f, 0.03491826f, -0.06240504f, -0.00717283f, -0.05934101f, -0.04570569f, 
    0.06013680f, -0.03550822f, 0.00949375f, -0.04647924f, -0.03970253f, 0.00535542f, 0.04169314f, -0.03223618f, 
    -0.09297462f, -0.04429153f, -0.03845329f, 0.04567074f, -0.02645037f, 0.04729935f, -0.06213018f, 0.04455120f, 
    -0.02063471f, -0.08309010f, -0.05090801f, -0.03489439f, 0.01796254f, 0.05195510f, 0.02351674f, -0.02833997f, 
    -0.06714132f, -0.01271226f, -0.04140880f, -0.01581017f, 0.07007951f, 0.02170989f, -0.06134760f, -0.05742171f, 
    0.00661018f, 0.02048007f, 0.00363480f, -0.02956618f, -0.04340540f, -0.02996290f, -0.07679000f, 0.03061938f, 
    -0.03463364f, 0.04090032f, -0.00664829f, 0.04778135f, 0.03804445f, -0.03567752f, -0.09499782f, 0.05655769f, 
    -0.03528467f, -0.04461731f, 0.01591050f, -0.03900218f, -0.07053422f, -0.09041267f, -0.06117263f, -0.01435865f, 
    -0.06323418f, -0.04229264f, -0.06412260f, 0.04366251f, 0.05484569f, 0.02950373f, -0.03625700f, -0.02673354f, 
    -0.05258874f, -0.05593253f, -0.01695574f, 0.01220583f, -0.08481968f, -0.08696821f, -0.07384118f, 0.01041640f, 
    0.06319773f, 0.03697992f, -0.04738218f, -0.02352734f, -0.02790925f, -0.00652776f, 0.01730644f, 0.05186737f, 
    0.04795833f, 0.00645903f, -0.08111602f, 0.02362666f, -0.01915375f, -0.07233526f, 0.03161614f, 0.06234730f, 
    0.00648237f, 0.02546502f, 0.02883990f, -0.04341678f, -0.07818715f, -0.00184913f, 0.06361002f, 0.00352903f, 
    -0.04053320f, -0.04507185f, -0.09075446f, 0.06580688f, -0.00002078f, 0.03908590f, -0.09501655f, -0.07011449f, 
    -0.04284290f, -0.00603230f, -0.00029893f, 0.01299512f, -0.02675963f, -0.08040406f, -0.04417586f, -0.07361124f, 
    0.03066266f, -0.04413161f, 0.05326006f, -0.07062183f, 0.03769775f, 0.01399602f, -0.01533610f, 0.01558845f, 
    -0.03327143f, -0.08047822f, -0.08452997f, -0.02875817f, -0.03205914f, -0.00617652f, -0.08336583f, -0.04354661f, 
    -0.08582567f, -0.06594432f, 0.04568703f, -0.03356281f, -0.04981219f, -0.06341793f, -0.03873859f, 0.04746190f, 
    0.00540946f, 0.02574289f, -0.07114554f, -0.07302020f, 0.01739626f, -0.03005083f, -0.04210297f, -0.05127499f, 
    0.02480973f, -0.04551696f, -0.07482892f, 0.04482328f, 0.01002604f, -0.00699804f, 0.01416331f, -0.00116537f, 
    -0.05228732f, 0.02991504f, 0.02872419f, 0.03176418f, -0.04064608f, -0.03921656f, 0.03571775f, 0.00833158f, 
    0.07105388f, 0.03989542f, -0.10571321f, -0.17335233f, -0.07642920f, 0.12024079f, -0.00354150f, 0.08755847f, 
    0.10645226f, -0.09726285f, -0.02166953f, 0.03772164f, -0.05304480f, 0.06455514f, -0.08886657f, -0.19635551f, 
    0.05835749f, 0.04401172f, 0.18076470f, -0.07336894f, -0.03045477f, -0.03975261f, -0.00736038f, -0.09633319f, 
    0.41414502f, -0.18326357f, -0.01362869f, 0.14615504f, -0.05796767f, -0.07385588f, -0.13845202f, -0.03579767f, 
    0.06731434f, 0.04602693f, -0.05719241f, -0.05795963f, 0.02828811f, -0.06226883f, -0.06365791f, 0.09086931f, 
    -0.03795235f, 0.24688800f, 0.11831589f, 0.10180047f, -0.00641035f, 0.01148042f, 0.13191892f, 0.09314211f, 
    0.15319741f, -0.03568259f, 0.04790452f, 0.35546008f, -0.06445365f, -0.16452903f, -0.08746079f, -0.06586426f, 
    0.04369345f, 0.13760425f, -0.01141586f, 0.01272954f, 0.05184435f, -0.02484583f, -0.01616795f, -0.06828921f, 
    0.05878121f, 0.10860067f, 0.01081268f, -0.01995718f, -0.00974499f, 0.00255446f, -0.01290952f, 0.03089569f, 
    0.30660936f, -0.16704006f, 0.14770322f, -0.14271140f, -0.09028587f, -0.04267615f, 0.15110362f, -0.01177286f, 
    0.02179859f, -0.07698520f, -0.05320797f, -0.08193128f, -0.07055672f, -0.03857262f, 0.11671600f, 0.07669766f, 
    0.05758650f, -0.22522901f, -0.03115587f, 0.01361143f, 0.06270064f, 0.10891984f, -0.02529329f, 0.10543860f, 
    0.00223465f, 0.28171352f, 0.16809614f, -0.13608550f, -0.06795240f, -0.07221770f, -0.04742361f, 0.18846083f, 
    -0.01921878f, 0.01160301f, -0.13699937f, -0.05891424f, -0.00065218f, -0.03222977f, -0.12114139f, 0.13197042f, 
    -0.05673215f, -0.05596516f, 0.01447715f, -0.02272939f, -0.01499417f, 0.04901284f, 0.11930168f, 0.10062987f, 
    0.15721405f, -0.05319068f, 0.06909090f, -0.21807559f, 0.16970657f, -0.12028800f, -0.16711138f, -0.03301260f, 
    0.01402303f, 0.00890029f, -0.03172751f, -0.06157352f, 0.17366283f, 0.00438596f, 0.02836390f, -0.11942713f, 
    0.16374746f, 0.18975918f, -0.01908523f, 0.11302316f, 0.03712855f, 0.14596725f, 0.04930310f, 0.16010471f, 
    0.00538536f, 0.16678110f, -0.16277902f, -0.06644093f, 0.09783365f, 0.05712669f, 0.04632104f, 0.06700842f, 
    0.04281887f, 0.11414000f, 0.08622216f, -0.00119106f, -0.12465906f, -0.18239035f, -0.08796704f, 0.07941531f, 
    0.09974535f, 0.10285926f, 0.07534450f, -0.01432629f, -0.00208735f, 0.07401278f, 0.03450606f, -0.08268665f, 
    0.16618024f, -0.00832121f, 0.09637388f, -0.08932029f, 0.19252895f, 0.06988414f, -0.13404875f, -0.06303303f, 
    0.08451029f, 0.00100072f, 0.14714824f, -0.14824557f, -0.21479414f, 0.19394772f, 0.08922184f, -0.14634474f, 
    0.11160559f, 0.12548864f, -0.03355530f, 0.03998244f, 0.10705428f, 0.17294592f, 0.02317199f, 0.02222211f, 
    0.04794284f, 0.01761568f, -0.06148081f, 0.02022018f, -0.06577790f, -0.02863732f, 0.01694623f, -0.20877983f, 
    -0.06032050f, -0.23974164f, 0.01568847f, -0.06421816f, 0.23735522f, -0.13846873f, -0.33118433f, -0.22997060f, 
    0.19498853f, -0.01125647f, 0.05244688f, -0.10934514f, 0.06779891f, 0.14127699f, 0.12641355f, 0.06140149f, 
    0.34337813f, -0.28457037f, -0.18302831f, 0.20014466f, 0.00026088f, -0.08749053f, 0.02597877f, -0.15077604f, 
    -0.10584889f, -0.05494663f, 0.18109867f, 0.07657053f, -0.02071146f, -0.09601501f, 0.00182837f, -0.14078142f, 
    0.00439065f, 0.04872375f, 0.04216952f, -0.12436325f, -0.09602733f, 0.03087291f, -0.08759753f, -0.11069874f, 
    0.02110005f, -0.12581506f, 0.02388597f, -0.03267527f, 0.07509288f, 0.09530395f, -0.08328804f, 0.09814572f, 
    0.03046752f, 0.04307299f, 0.07569238f, 0.21925701f, 0.19946058f, 0.05274265f, -0.06538533f, -0.07764781f, 
    0.04960555f, 0.00303875f, 0.01780011f, 0.01700066f, -0.08204433f, -0.01502630f, 0.08823729f, 0.05959227f, 
    0.28252119f, -0.34071571f, 0.01006547f, -0.05606255f, 0.00519069f, -0.01627848f, 0.15802599f, 0.08266814f, 
    -0.15012847f, -0.06419055f, -0.11049066f, -0.15752020f, 0.05078823f, 0.15708582f, 0.05840897f, 0.04896656f, 
    0.00347014f, -0.01016129f, 0.06797906f, -0.07496916f, -0.01355400f, -0.01244334f, -0.05070686f, 0.02510891f, 
    -0.37047073f, 0.10746417f, -0.04223246f, 0.10609086f, 0.13797943f, -0.07092465f, 0.11695218f, 0.00956745f, 
    0.04980110f, -0.03349485f, 0.05614112f, 0.29106769f, 0.33404803f, 0.04016415f, -0.25567594f, -0.12239672f, 
    -0.07495935f, -0.02723538f, 0.06914230f, 0.03176923f, 0.09198211f, -0.06005390f, 0.05374606f, 0.05215833f, 
    0.03185456f, 0.11226589f, 0.18775511f, -0.17122836f, 0.03220598f, 0.08939927f, -0.01410386f, -0.00193655f, 
    0.00745094f, -0.02555862f, -0.17377824f, -0.09412206f, 0.00937807f, 0.08343385f, -0.03995811f, -0.01073420f, 
    0.11912857f, 0.15415962f, 0.12251189f, -0.02076697f, 0.01536288f, -0.06231226f, 0.07268808f, 0.13208154f, 
    0.02634782f, 0.07235896f, -0.09989502f, 0.21773815f, 0.05029777f, 0.06989040f, 0.13661706f, 0.13377188f, 
    -0.14021619f, 0.03859051f, 0.14528939f, 0.00212634f, -0.24109963f, 0.14381029f, -0.12204503f, -0.15064266f, 
    0.12004128f, 0.02223608f, 0.12163878f, 0.01250476f, -0.03429228f, 0.23785885f, -0.08626912f, 0.04994424f, 
    -0.06630920f, -0.04171159f, 0.04919802f, -0.27674583f, 0.20163614f, 0.06345680f, -0.06761584f, 0.25200617f, 
    -0.12220446f, 0.00465758f, -0.00287413f, -0.22292770f, -0.03501760f, 0.26508802f, -0.14025463f, -0.05923427f, 
    -0.05183467f, 0.02473934f, -0.01858688f, -0.05287514f, -0.03763396f, 0.10222919f, -0.01680075f, -0.11517882f, 
    -0.04886015f, -0.04304995f, 0.04685917f, -0.02019401f, 0.02804877f, -0.06292864f, -0.05210456f, -0.07953099f, 
    0.02884353f, -0.07771946f, 0.05373226f, 0.04188760f, 0.03057274f, 0.02330042f, 0.04186036f, -0.05037165f, 
    -0.00513843f, -0.06571661f, -0.00081096f, 0.04751489f, -0.02115577f, 0.00937715f, -0.04652711f, -0.03717000f, 
    0.05769322f, 0.01452262f, 0.03927352f, -0.08232323f, -0.06677624f, -0.01972545f, 0.06055326f, -0.04980832f, 
    -0.03631898f, -0.08256642f, 0.00361860f, -0.05998735f, 0.05732122f, -0.07067207f, -0.06354301f, 0.05796383f, 
    -0.05742645f, 0.04557997f, -0.05491614f, -0.01194914f, 0.01930305f, 0.04836160f, 0.03254166f, 0.01179873f, 
    0.00490145f, -0.02586227f, -0.01340123f, -0.02252446f, 0.01216224f, 0.04636860f, 0.03218525f, 0.00539327f, 
    -0.00426498f, -0.01748841f, -0.01467489f, -0.02723094f, 0.00592303f, -0.03029777f, 0.03708151f, 0.01757387f, 
    -0.04818067f, -0.03187959f, 0.03182691f, 0.04928381f, 0.05068142f, 0.00990570f, -0.07991664f, 0.03710490f, 
    -0.04101323f, -0.00403671f, -0.02205925f, 0.00581576f, -0.07319158f, 0.04061136f, 0.00372771f, -0.07962191f, 
    0.00461765f, 0.04448193f, 0.01584505f, 0.01692832f, -0.07337518f, 0.02535483f, -0.02162332f, -0.02489350f, 
    -0.04271388f, -0.06122461f, 0.05654152f, 0.05320452f, 0.02848001f, -0.01836899f, -0.02597847f, 0.00101463f, 
    -0.07461675f, 0.03112612f, -0.00099554f, 0.03438042f, -0.05453153f, -0.06142532f, -0.00205836f, -0.03999464f, 
    -0.00185615f, -0.02129334f, 0.00507785f, -0.05536198f, -0.06872184f, -0.01113301f, 0.03912136f, -0.00950972f, 
    -0.07403614f, -0.02736544f, 0.01159061f, -0.04028251f, 0.01594744f, -0.01516158f, 0.06059304f, 0.01745948f, 
    -0.05876313f, -0.02906192f, -0.05714590f, 0.00377175f, 0.04420708f, -0.01735194f, 0.00073405f, -0.06683873f, 
    0.04003195f, -0.04755156f, -0.06622270f, -0.07823100f, -0.05706209f, -0.00154010f, 0.00064343f, -0.00117638f, 
    -0.06701571f, 0.05421913f, 0.05284202f, -0.06921593f, -0.06905682f, -0.02351965f, 0.02493867f, 0.00872837f, 
    0.06765053f, -0.02781576f, -0.04283610f, -0.05847302f, -0.02397719f, -0.04672370f, -0.06712618f, 0.02090857f, 
    -0.01961512f, 0.06244919f, -0.02082905f, -0.06860860f, 0.02698810f, -0.05443203f, 0.03428108f, 0.05038153f, 
    0.02344257f, 0.01456384f, 0.00311703f, 0.03572788f, -0.03854301f, -0.04900415f, -0.07140476f, -0.02807164f, 
    0.01504869f, -0.06628084f, -0.00997219f, 0.00691301f, -0.01851113f, -0.04341541f, 0.05430457f, 0.00760259f, 
    -0.02316470f, -0.05532038f, 0.03240007f, 0.04709278f, -0.03097675f, 0.00581165f, -0.06903204f, -0.02302121f, 
    -0.01538727f, 0.00803212f, -0.00587478f, -0.06277006f, -0.05755292f, 0.01994648f, -0.01311018f, 0.00497625f, 
    -0.00841532f, 0.04040452f, 0.03476616f, -0.03534698f, 0.01895633f, 0.04926640f, -0.05308604f, 0.01180749f, 
    0.02535998f, 0.01279131f, -0.03639824f, -0.03947065f, -0.06922550f, -0.04250017f, 0.03690311f, -0.04229886f, 
    -0.03991874f, 0.01683848f, 0.04717394f, -0.01315886f, -0.01963274f, -0.06020184f, -0.04876532f, -0.00689586f, 
    -0.03429748f, -0.07162847f, -0.05146596f, 0.03757960f, 0.05023834f, 0.01905391f, -0.00360848f, -0.06792194f, 
    0.00201530f, -0.05018556f, -0.06075600f, -0.01239172f, -0.07421301f, -0.05898953f, -0.01288324f, -0.02113083f, 
    -0.04078855f, 0.04869215f, -0.05640959f, -0.04404632f, 0.03883869f, -0.05271199f, 0.06294651f, -0.03694946f, 
    -0.02670404f, -0.06801744f, -0.00850711f, -0.03265957f, -0.04576981f, 0.04054123f, -0.07069112f, 0.04610635f, 
    -0.01690854f, 0.01127554f, 0.00417021f, -0.05238943f, 0.00328558f, -0.01014560f, 0.01368056f, 0.02165516f, 
    -0.01094364f, -0.02561270f, -0.00929318f, -0.01038824f, -0.06927583f, -0.06465019f, 0.02742806f, -0.01615748f, 
    0.03300335f, 0.03093155f, -0.05790564f, -0.00846451f, 0.01053079f, -0.04187717f, -0.04636726f, 0.02370780f, 
    -0.03500978f, -0.03811914f, -0.06672844f, -0.03860231f, -0.05372841f, 0.02826098f, -0.03421655f, -0.02757871f, 
    0.04918357f, -0.01912229f, -0.00262065f, -0.05647310f, -0.04293668f, 0.00496821f, 0.02937054f, -0.06967734f, 
    0.01778845f, 0.04242264f, -0.06114896f, -0.02003019f, -0.05931051f, 0.03698332f, 0.01804076f, -0.05977206f, 
    0.03511463f, -0.02023641f, 0.04473244f, 0.04325886f, -0.02511072f, 0.00183667f, -0.04226990f, -0.01106622f, 
    -0.01564215f, -0.00632293f, -0.07370635f, 0.05449364f, -0.02953070f, -0.07588671f, -0.03211632f, 0.02198456f, 
    -0.02882037f, -0.05983543f, -0.01993365f, 0.02571741f, 0.03944256f, -0.00685252f, 0.01151573f, -0.05525633f, 
    -0.02596508f, 0.05284500f, -0.03443784f, 0.05381683f, -0.04956845f, -0.06694786f, -0.07719938f, -0.02136937f, 
    -0.03676976f, 0.06381655f, 0.01780127f, -0.03140162f, -0.06080573f, -0.05778694f, -0.03279471f, -0.01887650f, 
    0.02177230f, 0.06379694f, 0.01623056f, -0.06358401f, -0.00065861f, -0.07606014f, -0.07474563f, -0.01506262f, 
    -0.02775624f, -0.04095382f, -0.03643097f, 0.02137031f, -0.05007124f, -0.02755241f, -0.04049871f, 0.00550921f, 
    0.00604250f, 0.03781136f, 0.04044469f, -0.01281051f, -0.00980440f, -0.00679092f, -0.04966017f, 0.01682125f, 
    -0.05072181f, 0.01153947f, 0.00583051f, 0.01466352f, 0.05373229f, 0.04593451f, -0.05755933f, 0.04478086f, 
    -0.03315406f, -0.03384187f, -0.01761052f, -0.01830192f, -0.01999907f, -0.02753703f, 0.02027497f, 0.05242625f, 
    -0.06048859f, -0.02566799f, 0.06113631f, 0.03082644f, 0.00443748f, 0.02096274f, -0.07727550f, -0.05135139f, 
    0.03380017f, 0.04054559f, -0.06295575f, 0.04339248f, -0.05150979f, -0.01475828f, -0.02833298f, 0.05205536f, 
    0.00244907f, -0.00760918f, -0.05702653f, -0.03919183f, -0.02246687f, -0.00015806f, 0.01488587f, -0.01300404f, 
    0.02179218f, 0.04692803f, -0.05594314f, -0.07799164f, -0.08435879f, -0.07269876f, 0.00449972f, 0.04599807f, 
    0.02043565f, 0.05449565f, -0.05765358f, -0.06078164f, -0.07423456f, 0.06665806f, -0.06056285f, 0.03924985f, 
    -0.01599741f, -0.06057369f, -0.03986167f, -0.02735874f, -0.05369810f, 0.04009309f, 0.05582733f, -0.03647073f, 
    -0.01577615f, 0.01447014f, 0.03459279f, -0.00804475f, -0.07890157f, 0.01338666f, -0.00053713f, 0.01672160f, 
    -0.04212612f, -0.03538290f, -0.07917667f, -0.03014920f, -0.00798672f, 0.02913854f, -0.01710981f, -0.01187982f, 
    0.02205397f, -0.07772076f, -0.04901830f, 0.02061185f, 0.06855433f, -0.01093576f, 0.01031769f, -0.08076213f, 
    0.07137665f, 0.00961166f, -0.04876593f, 0.01701699f, -0.06581342f, -0.06021127f, -0.03815588f, -0.00938717f, 
    0.04345930f, 0.06998295f, -0.03662493f, 0.03740572f, 0.00412980f, 0.06028285f, -0.06622277f, -0.01086206f, 
    -0.05635545f, 0.05726914f, 0.01150583f, -0.04997431f, -0.06267273f, 0.02851411f, 0.03942384f, -0.04342521f, 
    -0.08434084f, -0.03873882f, 0.00401788f, -0.06577338f, 0.04047957f, -0.03801313f, -0.01372215f, -0.05801127f, 
    -0.01335226f, -0.05526706f, -0.00004045f, 0.04708501f, -0.02904137f, 0.03079458f, 0.03008209f, 0.01155937f, 
    0.04766897f, -0.08218566f, -0.05632384f, -0.01916526f, 0.02626715f, 0.01877143f, 0.03677074f, 0.02410713f, 
    0.01309030f, -0.05767200f, 0.04359788f, -0.02274819f, -0.03586127f, 0.02030372f, -0.04150513f, -0.02833457f, 
    0.01322141f, -0.07064804f, -0.05833497f, 0.05109163f, 0.02999576f, 0.06149035f, 0.02426792f, 0.04732266f, 
    0.00510733f, 0.05179472f, -0.07560137f, -0.05483017f, -0.00033416f, -0.01800901f, 0.02896436f, -0.01096070f, 
    0.05011787f, 0.01968803f, -0.00467041f, 0.05041404f, -0.04730344f, -0.02343998f, 0.03500159f, 0.03647727f, 
    -0.00679163f, -0.05482840f, -0.02716151f, 0.00554509f, 0.00235030f, -0.02142033f, -0.01521664f, 0.01405971f, 
    -0.00798413f, -0.06184823f, 0.06672988f, -0.03358023f, 0.05146774f, -0.01963485f, -0.04953830f, 0.05350512f, 
    -0.05141123f, -0.02554637f, 0.00854862f, -0.01597948f, -0.05876375f, -0.05036939f, -0.03245231f, 0.04074918f, 
    -0.02297020f, -0.04975935f, -0.01441501f, -0.00725362f, 0.06177713f, -0.04902448f, 0.05358446f, -0.02136129f, 
    -0.01291885f, 0.03157734f, -0.03743964f, 0.01599802f, -0.05339352f, 0.00439982f, 0.04779763f, 0.04808239f, 
    -0.08044572f, 0.06030715f, -0.03792517f, -0.03491288f, 0.03252865f, 0.04123425f, 0.04518376f, 0.06610686f, 
    -0.00439578f, 0.01826752f, -0.01399359f, -0.06202475f, -0.11580084f, 0.01340742f, 0.05782421f, 0.04140019f, 
    -0.03103001f, -0.01523915f, -0.09836962f, 0.07764351f, 0.19072594f, -0.12843268f, 0.09286233f, -0.08003137f, 
    0.06644992f, -0.02182323f, 0.10054569f, 0.02784743f, 0.08164089f, 0.08217283f, -0.03185629f, 0.03979960f, 
    0.26194561f, -0.11650337f, -0.13416937f, -0.09639637f, -0.00857144f, -0.03720155f, -0.06525902f, -0.08973564f, 
    0.09747352f, 0.13048467f, 0.15971461f, -0.04629242f, -0.06588782f, -0.29162040f, 0.10541803f, 0.04829147f, 
    0.07676123f, 0.00712900f, 0.05464584f, 0.09666427f, 0.03177416f, 0.11484954f, 0.06813797f, -0.00356977f, 
    -0.33136600f, -0.15862808f, -0.07633983f, 0.13458326f, -0.06890674f, 0.01382784f, -0.10250786f, -0.00060841f, 
    -0.01285055f, 0.02353605f, -0.04972294f, -0.06207474f, -0.18004313f, 0.40942547f, -0.16779135f, -0.06649476f, 
    -0.00135392f, 0.10826417f, 0.03342263f, -0.04576386f, 0.04655957f, -0.06499685f, 0.13230775f, -0.00424948f, 
    0.18151681f, -0.12607554f, -0.06574528f, -0.17147274f, 0.03770793f, -0.08021755f, 0.07583229f, -0.11169958f, 
    -0.00092335f, 0.02688706f, -0.03014411f, -0.01239362f, 0.16218537f, 0.08616044f, -0.11471533f, 0.26484153f, 
    0.19034010f, -0.18754555f, 0.01344898f, 0.08570731f, 0.00779599f, 0.06185584f, 0.10158762f, 0.13865224f, 
    -0.04871580f, -0.12062993f, 0.04290082f, -0.19845109f, 0.02572845f, -0.00726261f, 0.02506635f, -0.05786727f, 
    -0.02176509f, 0.04673418f, -0.00656192f, -0.03031256f, -0.00903166f, 0.02444422f, -0.08825961f, 0.26822847f, 
    -0.00047955f, 0.06227187f, 0.02418317f, 0.04250978f, 0.06449100f, 0.01881633f, 0.00516680f, 0.04189210f, 
    0.22889000f, 0.13010776f, -0.12402239f, -0.03262904f, 0.09044707f, -0.11880511f, -0.03244341f, -0.05657951f, 
    0.01992102f, -0.05424441f, 0.01336997f, 0.11390169f, 0.26157576f, 0.18867663f, 0.00173803f, 0.11722754f, 
    0.01897743f, 0.10657933f, -0.08947182f, 0.11526886f, 0.03103101f, -0.02605538f, -0.02389788f, 0.11788472f, 
    0.01793956f, 0.02438148f, 0.04640661f, -0.13086607f, 0.07801012f, -0.08301105f, 0.01476608f, -0.07470840f, 
    -0.07689964f, -0.01476010f, -0.04967516f, 0.02918762f, 0.14838961f, -0.10888593f, -0.02487921f, 0.10079002f, 
    0.04363817f, 0.07594370f, 0.09385798f, -0.01536158f, -0.01772075f, 0.13756916f, 0.06567323f, 0.11686087f, 
    -0.12102459f, -0.37104183f, 0.07091692f, 0.03532147f, -0.04594255f, -0.05787120f, -0.04891276f, -0.03503959f, 
    0.01338098f, 0.07666636f, -0.05685274f, -0.03135250f, -0.27639577f, 0.44171286f, -0.08897730f, -0.00516712f, 
    0.10763663f, 0.00063545f, -0.05735279f, 0.09492309f, 0.04733118f, 0.11782730f, -0.09928709f, 0.05912195f, 
    0.02565591f, 0.05445071f, 0.06036013f, 0.01677739f, 0.02971221f, -0.03735422f, 0.05267411f, 0.04784553f, 
    -0.04567199f, 0.03467595f, -0.00618132f, -0.05154578f, -0.07140748f, 0.05375782f, 0.03498296f, 0.05128307f, 
    -0.01562831f, 0.04039894f, -0.07575137f, 0.00448906f, 0.05854806f, 0.02812182f, -0.01155124f, 0.02365700f, 
    -0.04487073f, 0.05297826f, -0.01700332f, 0.02942521f, -0.02378054f, -0.06122532f, -0.07023554f, 0.06362904f, 
    -0.05488061f, -0.05115634f, 0.03956898f, -0.03957389f, 0.01508234f, -0.01304116f, -0.04765027f, -0.03338966f, 
    0.00530755f, -0.04018463f, 0.02825476f, -0.07506171f, -0.00866307f, -0.03955744f, -0.07756841f, -0.01727724f, 
    0.04022207f, -0.01748107f, -0.05475687f, 0.01356451f, -0.00308208f, -0.03652678f, 0.00399355f, -0.04936939f, 
    -0.02380958f, 0.03788816f, -0.03528675f, -0.06697752f, 0.05426890f, 0.02723478f, -0.05841773f, 0.02664357f, 
    0.01123553f, 0.04161299f, -0.07080527f, 0.06416640f, -0.01094709f, -0.04703724f, 0.03718235f, 0.00888662f, 
    0.06346085f, -0.03545471f, -0.04112376f, -0.04441218f, -0.02363231f, -0.01188439f, -0.01708452f, 0.00094577f, 
    -0.02587924f, -0.02632012f, 0.04861544f, 0.01435648f, -0.06827185f, 0.03822290f, -0.03365929f, -0.01231298f, 
    -0.02849091f, -0.01859469f, 0.04892522f, -0.00750434f, 0.05600055f, -0.06810690f, -0.05204648f, 0.00321591f, 
    -0.01434809f, -0.00920211f, -0.02026405f, 0.01166217f, 0.00074786f, 0.03384419f, -0.00214231f, -0.01589030f, 
    0.00318969f, 0.00106642f, 0.02130974f, -0.07748783f, -0.01711500f, 0.03910945f, -0.03257572f, 0.03719079f, 
    -0.07461623f, -0.00974199f, -0.05421442f, -0.00975257f, -0.01702631f, 0.01994503f, -0.05190672f, 0.01176271f, 
    -0.01029614f, -0.07504626f, -0.02569030f, 0.02616234f, -0.03667023f, -0.04019732f, -0.07542810f, -0.01185773f, 
    -0.07938074f, -0.02506595f, 0.04354718f, 0.04091426f, -0.07769717f, -0.04114834f, 0.02498659f, 0.00480020f, 
    -0.02630710f, 0.02298711f, 0.05449151f, 0.05877588f, -0.01626344f, -0.00770012f, 0.00711888f, 0.01225633f, 
    -0.05698265f, 0.00877640f, 0.06962109f, -0.06216435f, -0.03051257f, 0.00767757f, -0.08572767f, -0.00215861f, 
    0.04312835f, 0.01808671f, -0.05251091f, -0.06806274f, 0.05477962f, -0.07319357f, -0.04352129f, 0.01005729f, 
    0.04572630f, 0.01088456f, -0.03096967f, 0.02471648f, -0.06894164f, 0.04200018f, -0.00628270f, -0.02107500f, 
    0.04442144f, -0.06929528f, 0.03380171f, 0.00065496f, -0.06192905f, -0.06678177f, 0.01901962f, -0.07997999f, 
    -0.07503355f, 0.02683653f, 0.06263074f, -0.06333814f, -0.07683436f, -0.02132599f, -0.06061776f, -0.04048595f, 
    0.01544262f, 0.02023355f, -0.04251809f, 0.02380718f, -0.01643159f, -0.06489491f, 0.05631072f, 0.00891282f, 
    -0.01041769f, -0.07706401f, -0.05014683f, -0.02650636f, -0.03818843f, -0.06958525f, 0.05969736f, -0.01692200f, 
    0.03425477f, 0.00336714f, -0.07432111f, -0.04952583f, 0.03921261f, 0.04910728f, -0.04077277f, 0.03084469f, 
    -0.03790696f, -0.05813933f, -0.03221941f, 0.05831688f, -0.06854796f, 0.02861428f, -0.06577109f, -0.00451516f, 
    -0.00917034f, -0.02074191f, -0.06707166f, -0.04609028f, -0.06884401f, -0.01907156f, 0.05099528f, -0.05085798f, 
    0.03444711f, -0.07449783f, 0.01819013f, 0.06255187f, -0.03080102f, -0.07751988f, -0.06785217f, -0.00514942f, 
    0.05857498f, -0.02561487f, -0.05896424f, -0.00742631f, -0.03010053f, 0.02053301f, -0.05904553f, 0.05233012f, 
    0.02327880f, -0.02197798f, -0.07356203f, -0.04026736f, -0.00648665f, -0.00030063f, -0.07557855f, -0.07763765f, 
    0.04851075f, 0.00363638f, 0.03179253f, 0.02583504f, 0.03502784f, -0.01513400f, -0.01121658f, -0.06740341f, 
    -0.06731199f, 0.06201064f, 0.00017888f, -0.01059419f, -0.02980918f, -0.02828116f, -0.04676088f, -0.07421819f, 
    -0.03672664f, -0.00811173f, 0.03860843f, 0.05974428f, 0.00423250f, -0.02106431f, -0.07646996f, 0.02757719f, 
    -0.06224418f, -0.04333019f, -0.07020189f, 0.05097011f, -0.04924999f, -0.06862385f, -0.04179354f, -0.04993316f, 
    -0.05584455f, -0.01675216f, 0.05009599f, 0.06070407f, 0.02557993f, -0.03044782f, 0.04321171f, -0.06000868f, 
    0.05884258f, 0.01324957f, 0.02539385f, 0.02542824f, 0.00852996f, -0.07269715f, -0.05191040f, -0.02339388f, 
    -0.01822929f, -0.05728510f, -0.01940593f, 0.03491345f, -0.05451578f, 0.03098463f, 0.04427037f, -0.06417985f, 
    0.02683381f, 0.02897075f, 0.00113717f, 0.03148989f, -0.01581993f, -0.02087095f, -0.01690685f, 0.02517386f, 
    0.03500129f, -0.03767405f, -0.05097444f, -0.01683735f, -0.03453910f, 0.05146984f, 0.03735376f, 0.04736440f, 
    -0.04434149f, 0.05808277f, -0.02342952f, -0.02899067f, -0.03018463f, -0.06275564f, -0.06778246f, 0.04418488f, 
    -0.07057951f, -0.00352336f, -0.07188300f, -0.01761694f, 0.04577127f, -0.04970893f, -0.04230649f, 0.01406373f, 
    -0.01816025f, 0.06177574f, 0.02284943f, 0.04353769f, -0.06926981f, 0.01207438f, 0.04088512f, -0.04654375f, 
    0.05001960f, -0.00484658f, -0.01256338f, 0.06441801f, -0.03208704f, -0.04968292f, 0.03942646f, -0.06631716f, 
    -0.07582375f, -0.07698058f, -0.05083015f, -0.03073508f, 0.03396284f, 0.02015030f, 0.05400555f, 0.05820983f, 
    -0.07789848f, 0.06236853f, 0.01325708f, 0.02039563f, -0.01238815f, 0.03791620f, 0.05938875f, 0.03781917f, 
    -0.04475009f, -0.03775976f, -0.03182652f, 0.00653503f, -0.02435742f, -0.00956162f, -0.05163026f, -0.01059079f, 
    -0.02182322f, 0.05213930f, -0.01936672f, -0.03385900f, -0.00441839f, 0.06176563f, 0.01864148f, 0.06096475f, 
    0.08899423f, -0.00244228f, 0.00217954f, 0.10477245f, 0.02775294f, 0.14751577f, 0.05101212f, 0.13891782f, 
    0.09219215f, 0.25149482f, -0.14956151f, 0.03278910f, -0.07587792f, 0.10790603f, 0.04136285f, 0.05428135f, 
    -0.17457010f, 0.04416587f, -0.13023488f, 0.07060868f, 0.01773657f, -0.10187560f, -0.12040611f, -0.03397043f, 
    -0.18033518f, 0.18085341f, 0.05274738f, -0.18005276f, 0.02568376f, 0.14829700f, 0.10162431f, 0.23083229f, 
    -0.06586624f, 0.11646166f, -0.02127579f, -0.08723446f, -0.15597481f, -0.04055911f, -0.00191189f, 0.22306556f, 
    -0.08093894f, -0.00296972f, -0.02372574f, 0.10734631f, -0.04225045f, 0.01018941f, 0.08432826f, 0.16317724f, 
    -0.06315224f, 0.16465241f, 0.11765676f, 0.06814612f, 0.08034261f, -0.09219180f, 0.11688140f, -0.13097146f, 
    -0.09218070f, -0.10595159f, 0.10344206f, -0.24466039f, 0.25833189f, -0.20374288f, 0.04550783f, 0.07165239f, 
    0.07047454f, 0.02377273f, -0.05670976f, -0.06710089f, -0.08301183f, -0.02996733f, 0.09254999f, -0.01385984f, 
    0.01574035f, 0.22046490f, -0.25035363f, -0.09943923f, 0.02257830f, 0.07318468f, -0.01220513f, -0.15682124f, 
    -0.00447269f, -0.02356379f, -0.01136207f, 0.04056519f, 0.25657731f, -0.02147366f, -0.20110571f, 0.01110572f, 
    0.02213856f, -0.01898079f, 0.07960326f, 0.08846154f, -0.05967239f, 0.09603858f, 0.17498294f, 0.11977767f, 
    0.42227212f, 0.07856201f, 0.09277505f, 0.00579951f, -0.08981650f, -0.05105238f, -0.03466127f, -0.02684856f, 
    -0.05145695f, -0.01547266f, 0.03581287f, -0.14303236f, -0.16462781f, -0.07025462f, 0.13035360f, 0.21479595f, 
    -0.02240762f, -0.02953943f, 0.05431985f, -0.01867095f, 0.04915865f, 0.01949870f, 0.23878464f, -0.11759581f, 
    0.14744553f, 0.09469399f, -0.19092190f, 0.12348770f, -0.01121763f, -0.03499724f, 0.01966499f, 0.01764362f, 
    0.02653148f, -0.03333294f, 0.09730746f, 0.07152730f, 0.28312305f, 0.31428674f, -0.03318083f, 0.01515472f, 
    0.04687303f, 0.04043154f, -0.01216572f, 0.19709493f, -0.08765452f, 0.07158919f, 0.01497804f, 0.01625913f, 
    0.05975057f, 0.20240511f, 0.04585557f, -0.17258348f, 0.05485752f, -0.11617152f, -0.03264598f, -0.15511340f, 
    -0.10560828f, -0.07960583f, -0.04088255f, 0.01456686f, 0.04033323f, -0.05904296f, -0.06951205f, -0.05731267f, 
    -0.00850816f, 0.01583778f, -0.03770817f, 0.04824301f, -0.05974551f, -0.03727351f, 0.02688070f, -0.06292579f, 
    0.10126285f, -0.24164799f, -0.07660729f, 0.20185120f, 0.02235948f, 0.07701351f, 0.11921745f, -0.09614536f, 
    0.06753844f, -0.03800082f, 0.12211998f, 0.13689503f, -0.07411923f, -0.10194072f, 0.12370033f, 0.05216782f, 
    -0.00136459f, -0.00196938f, -0.03715644f, 0.08478315f, -0.00908259f, 0.00261856f, 0.03671298f, 0.12384816f, 
    -0.01588443f, -0.14393735f, -0.01657208f, 0.18123581f, 0.00913222f, 0.11256979f, 0.06937049f, 0.00875057f, 
    -0.01078543f, -0.01538535f, 0.02139951f, -0.06603457f, -0.33607006f, 0.00469622f, 0.02886525f, 0.12365806f, 
    -0.23406346f, 0.09831458f, -0.10958844f, 0.05799845f, 0.01830382f, -0.10674424f, 0.10815413f, 0.03272500f, 
    -0.38644558f, 0.22627696f, 0.09029058f, 0.00266660f, 0.16186300f, -0.02402922f, 0.20985171f, 0.14293782f, 
    -0.02459266f, -0.01549037f, 0.02891488f, 0.09491785f, 0.04473257f, 0.04060140f, -0.16115263f, 0.04091324f, 
    0.02394708f, -0.12727138f, -0.08226506f, -0.04309004f, -0.15010336f, -0.16839063f, -0.09683494f, -0.15299177f, 
    -0.05001787f, 0.18584202f, 0.03890585f, -0.09627289f, 0.16595910f, 0.05948386f, 0.07659381f, 0.13449176f, 
    -0.01534408f, -0.03823748f, -0.00485243f, -0.01673386f, 0.29704359f, -0.36887622f, 0.03890044f, 0.16986099f, 
    -0.01333497f, 0.01221083f, 0.02058437f, 0.06391703f, -0.05218893f, 0.02658293f, -0.00009614f, -0.00857579f, 
    -0.07884590f, 0.05237824f, -0.01239124f, 0.13911834f, 0.16426077f, 0.19939432f, -0.06031135f, 0.10390964f, 
    0.03887529f, -0.02251285f, 0.02376205f, 0.05053065f, 0.24793829f, -0.01094592f, -0.00039481f, -0.12054124f, 
    -0.09254093f, 0.11558158f, -0.01938278f, 0.01200194f, -0.06631277f, -0.16173697f, -0.10957766f, -0.09653675f, 
    0.09151962f, 0.04285147f, -0.06669807f, 0.08575024f, 0.07236890f, 0.02691982f, 0.14805713f, -0.10321184f, 
    0.00455486f, -0.02853346f, 0.11403392f, 0.23841634f, 0.00684306f, -0.10538019f, 0.08908837f, -0.05372969f, 
    0.00453626f, 0.05595989f, -0.01722124f, -0.05549042f, -0.01054877f, -0.03471639f, 0.09472246f, -0.14769991f, 
    0.05729336f, 0.20975724f, 0.16085067f, 0.01398690f, 0.00472922f, 0.06425333f, 0.06261226f, 0.09350572f, 
    0.02332504f, -0.05629350f, -0.17019083f, -0.02077739f, -0.21637638f, 0.15536161f, 0.14865239f, -0.10047653f, 
    0.04555961f, -0.11619885f, -0.01958561f, -0.03733450f, -0.12880105f, -0.14503098f, -0.09682558f, -0.09811145f, 
    0.20577116f, -0.05310523f, 0.10445583f, 0.24557370f, -0.09582093f, -0.03596525f, 0.10218141f, 0.07603849f, 
    -0.07207514f, -0.07149900f, 0.02991276f, 0.03964081f, 0.09586686f, 0.34390488f, 0.14500940f, -0.27942225f, 
    0.07320556f, -0.03199966f, 0.08279395f, 0.09738588f, 0.01173402f, 0.15538509f, -0.12354282f, -0.05057384f, 
    0.09489060f, 0.06354811f, -0.07792311f, -0.10826791f, -0.00583672f, 0.06654350f, 0.18518822f, 0.04742753f, 
    0.01904602f, 0.00932966f, 0.03400055f, 0.14351603f, 0.22136097f, -0.33865979f, -0.09902425f, 0.16038519f, 
    -0.06521472f, 0.00112301f, 0.04735257f, 0.04277416f, 0.02646691f, 0.00735948f, 0.08437312f, -0.01376346f, 
    0.15946840f, -0.13173318f, 0.12112603f, 0.19032602f, -0.09045833f, 0.11414003f, -0.03369303f, -0.05039283f, 
    0.10100251f, 0.13641517f, 0.01327442f, -0.03647495f, 0.11075220f, 0.01917269f, -0.02546903f, 0.23066908f, 
    -0.14670315f, 0.09017769f, -0.13044040f, 0.02152380f, 0.09522587f, -0.01222825f, -0.00386995f, -0.06753983f, 
    -0.41842175f, 0.28254095f, -0.02866864f, 0.14024310f, 0.12123781f, 0.04549393f, 0.03827413f, 0.12053204f, 
    -0.00473996f, 0.16625376f, -0.06717221f, 0.02878600f, 0.10879774f, 0.16934888f, -0.06733868f, 0.25239077f, 
    -0.02284916f, 0.03260345f, -0.05005270f, -0.01087736f, -0.14516236f, -0.00333657f, -0.12028250f, 0.08712916f, 
    0.14733213f, 0.13890584f, 0.02670866f, -0.24305148f, 0.09268036f, 0.02332547f, 0.10000408f, -0.08347033f, 
    -0.11594076f, -0.07662799f, -0.02421986f, 0.00720931f, 0.17787741f, -0.33183131f, 0.20451997f, 0.12437534f, 
    -0.05467893f, -0.02304183f, -0.00552540f, -0.00114163f, 0.01511980f, 0.03003822f, 0.01925179f, 0.08933399f, 
    -0.25511402f, 0.00145869f, -0.03127627f, 0.09202374f, 0.15085138f, 0.15902209f, -0.06365072f, 0.02083932f, 
    0.07377454f, -0.02396829f, -0.05590043f, -0.00767272f, -0.03332981f, 0.05935971f, 0.02507197f, -0.24218266f, 
    -0.00235509f, 0.03309894f, -0.06439359f, -0.07582504f, 0.05553819f, -0.07980374f, 0.17210466f, 0.05511419f, 
    0.12826306f, 0.02113787f, 0.02399927f, 0.07657334f, 0.06676918f, 0.10802881f, -0.12226462f, 0.03336843f, 
    0.04126266f, 0.08129033f, 0.19745512f, 0.03237634f, -0.14738104f, -0.06095908f, 0.12576957f, 0.18345155f, 
    0.07663785f, -0.07811452f, 0.01629561f, -0.06015936f, 0.07701179f, -0.04171427f, 0.09623691f, 0.05434187f, 
    0.02442437f, 0.01428706f, 0.02897402f, 0.12821355f, 0.00113514f, 0.13191670f, -0.09139360f, 0.08647361f, 
    0.06236640f, 0.08661317f, 0.12475214f, 0.11961289f, 0.32392508f, -0.09021804f, 0.08395771f, -0.03267809f, 
    -0.00161069f, 0.00299121f, 0.03789304f, 0.07153703f, -0.07911534f, -0.03220678f, 0.07392904f, -0.17192163f, 
    0.03920504f, 0.02672708f, -0.07867374f, 0.18639529f, -0.11233573f, 0.02945773f, 0.03440009f, -0.07004051f, 
    -0.09276239f, 0.07600726f, 0.01152533f, -0.09136514f, -0.03108709f, 0.00134260f, -0.15434612f, 0.01437947f, 
    0.01723917f, -0.02288314f, -0.07421203f, -0.06982648f, 0.05399739f, -0.04498027f, -0.16983734f, -0.07148169f, 
    0.10068143f, 0.04609064f, -0.01398953f, -0.11259799f, -0.04300100f, -0.02652239f, 0.03210936f, 0.04343794f, 
    -0.11985683f, 0.02125510f, 0.04293563f, 0.01638472f, 0.01865206f, -0.18076928f, 0.04382429f, 0.18213022f, 
    -0.06201872f, -0.16462183f, 0.07976059f, -0.02630291f, -0.09605751f, -0.05437649f, 0.14768198f, 0.06680969f, 
    -0.09544956f, 0.03383205f, 0.18603438f, -0.11708372f, 0.12027551f, -0.07495885f, 0.02612221f, -0.22760101f, 
    0.05816301f, -0.16174580f, -0.03413728f, 0.04851680f, -0.14936581f, -0.10588259f, 0.22329691f, -0.11613617f, 
    -0.02992163f, 0.03763798f, -0.05628260f, 0.04170628f, -0.05370959f, 0.02428614f, -0.01981010f, 0.01985126f, 
    -0.22132529f, 0.32741046f, -0.04769360f, 0.12862375f, -0.00249168f, -0.00942877f, 0.05041239f, 0.23906347f, 
    0.00030223f, 0.06118340f, -0.05587534f, 0.05381046f, -0.11826682f, 0.06011909f, 0.20538828f, 0.16790946f, 
    -0.01534071f, -0.06785146f, -0.01750075f, 0.03840611f, 0.04165764f, -0.08541810f, -0.09064392f, 0.00344813f, 
    -0.09060573f, 0.41367352f, -0.25492147f, 0.13246746f, -0.09363232f, -0.07416283f, 0.06074608f, -0.13698497f, 
    -0.21357994f, -0.00283714f, 0.15364768f, -0.03725891f, -0.04390251f, 0.06330842f, 0.03330228f, 0.08603037f, 
    -0.01101951f, 0.09010462f, -0.13670735f, -0.10597025f, -0.01049837f, -0.00543823f, 0.05955307f, 0.08934513f, 
    0.04541877f, 0.20147432f, 0.15840015f, -0.03883845f, 0.03860106f, 0.11167867f, 0.22957882f, 0.14860575f, 
    0.04702761f, -0.00399086f, 0.01500909f, 0.07307412f, -0.08422706f, -0.11519435f, -0.17916475f, 0.33315820f, 
    0.21674035f, -0.02060551f, -0.29258150f, 0.01664522f, 0.01606333f, 0.02223773f, 0.07599533f, 0.07565471f, 
    0.12848616f, 0.11296952f, -0.06297528f, -0.18059014f, -0.02485426f, 0.09873925f, 0.08216690f, -0.04263266f, 
    -0.09178062f, -0.07213788f, 0.10709090f, 0.07590421f, 0.02650704f, -0.00889815f, 0.07186033f, -0.23066752f, 
    -0.01491212f, 0.00489571f, -0.06537109f, 0.01324495f, 0.13864185f, 0.06287421f, -0.05126245f, 0.14229040f, 
    0.01495922f, 0.02158756f, 0.13232656f, 0.12994199f, -0.07030197f, 0.11383109f, -0.11215115f, -0.11412204f, 
    0.09517853f, -0.03036642f, 0.09756953f, -0.01162515f, 0.26204655f, -0.08653599f, 0.18588595f, 0.03607079f, 
    0.04701394f, 0.03458386f, -0.07709696f, -0.21229154f, 0.09033544f, -0.00914511f, 0.03544375f, 0.08576939f, 
    0.14457828f, 0.03648713f, -0.17065232f, -0.01318044f, -0.03271261f, -0.11868891f, 0.06274009f, -0.08030357f, 
    -0.00702328f, -0.07329840f, -0.10941242f, 0.10137590f, 0.11282845f, -0.19314274f, -0.09747551f, 0.18576016f, 
    0.08645505f, -0.08095878f, -0.30795002f, -0.06490018f, 0.05842305f, -0.12753755f, 0.02231354f, -0.00671701f, 
    0.11432701f, -0.18109463f, -0.14451936f, -0.11074981f, 0.10864557f, 0.06222117f, -0.09702387f, -0.06707378f, 
    0.15693359f, 0.01943385f, -0.04302447f, -0.15161103f, 0.00610768f, 0.02876734f, -0.02660701f, 0.07341255f, 
    0.04533550f, -0.00680055f, -0.01236916f, 0.06162165f, -0.06027705f, 0.02686303f, -0.05607555f, 0.08212820f, 
    -0.08395533f, 0.15481375f, 0.06344070f, -0.10989112f, 0.10234421f, -0.06198441f, 0.00084828f, -0.17054302f, 
    -0.14270297f, -0.16101761f, 0.07982408f, -0.12730111f, 0.09435298f, 0.07848440f, 0.14368537f, 0.01260947f, 
    0.00198539f, -0.06019969f, 0.13008298f, -0.06685517f, -0.12720978f, 0.20934732f, 0.03365352f, -0.00380976f, 
    0.09136233f, 0.04778094f, 0.12005819f, -0.12505263f, -0.05679409f, -0.00787036f, 0.21377060f, 0.04833337f, 
    0.01447480f, -0.03665958f, 0.07751334f, 0.06080946f, -0.14874795f, 0.00486306f, 0.04893349f, -0.09233676f, 
    -0.07348117f, -0.06625324f, 0.03719176f, -0.04982014f, 0.19125454f, 0.10490828f, -0.01210534f, -0.11958037f, 
    -0.07333278f, 0.09213163f, -0.33345133f, -0.09183121f, -0.01911699f, 0.12208592f, -0.12520738f, -0.07648778f, 
    0.03248272f, -0.04574042f, 0.05360966f, 0.10085940f, -0.28421593f, 0.22261675f, -0.03813491f, -0.08059370f, 
    0.13764031f, 0.06896514f, 0.06740793f, -0.04244507f, 0.03493129f, -0.00141444f, 0.00403990f, -0.03898607f, 
    0.14246230f, 0.47444290f, 0.14505000f, 0.11451561f, -0.00196561f, 0.01128500f, 0.11481921f, 0.08376827f, 
    0.01714888f, 0.06780968f, 0.00010745f, 0.04868529f, 0.25616902f, -0.09525849f, -0.00024907f, 0.30012873f, 
    0.02628615f, -0.11009426f, -0.18682811f, -0.00272268f, -0.06425571f, 0.10041677f, -0.08549733f, 0.03354327f, 
    0.03609679f, -0.14760768f, -0.22051926f, 0.05728392f, -0.03215611f, 0.20089275f, 0.19438657f, -0.01653480f, 
    -0.17568974f, -0.02632155f, -0.02235878f, 0.02237384f, 0.18617880f, 0.22153045f, 0.02139789f, -0.16442494f, 
    0.01647666f, 0.09467185f, 0.07611238f, 0.12168683f, 0.10272440f, 0.04968536f, -0.13700612f, -0.06755114f, 
    -0.26469305f, -0.15619747f, 0.08579478f, 0.14025567f, -0.08146583f, 0.03174981f, 0.02049878f, -0.17209643f, 
    0.08771763f, 0.09146830f, 0.00391344f, 0.06549667f, -0.20937762f, -0.16843349f, -0.03956912f, 0.24822375f, 
    -0.05063174f, -0.01809931f, 0.03151173f, -0.21390653f, 0.01665903f, -0.00264582f, -0.02606411f, -0.03423949f, 
    0.00685416f, -0.13036470f, 0.04765009f, 0.14317186f, -0.03644555f, -0.04165680f, 0.10180555f, 0.05978755f, 
    0.00410298f, -0.14328408f, 0.01378269f, 0.01707323f, 0.11347350f, -0.02990726f, 0.12147126f, 0.19917087f, 
    -0.02253384f, -0.13911110f, -0.21243180f, -0.07869463f, -0.05358709f, -0.02194418f, -0.00584181f, 0.23007596f, 
    -0.27935490f, -0.02302133f, -0.13107710f, -0.24082270f, 0.10793211f, -0.07012384f, -0.04003801f, -0.09303650f, 
    -0.02661372f, -0.04362034f, -0.00393752f, -0.13046849f, 0.13938545f, -0.04020218f, 0.05017765f, -0.00790227f, 
    0.02733132f, -0.00989572f, 0.01178938f, 0.00716378f, 0.03865291f, 0.09251116f, -0.03442824f, 0.04300215f, 
    0.18576306f, -0.01920416f, 0.05490775f, 0.01773764f, 0.04243811f, 0.29138449f, 0.06075589f, 0.11453911f, 
    0.04602800f, 0.13256398f, 0.06754228f, 0.06392174f, 0.16822678f, 0.00725987f, 0.05378541f, 0.14173190f, 
    -0.00498606f, 0.17015684f, -0.13716251f, 0.01553001f, 0.07508133f, -0.17771862f, -0.05555583f, -0.10686198f, 
    0.09503137f, -0.05659391f, -0.21742517f, 0.17524730f, -0.05291046f, 0.02746913f, 0.00634617f, -0.00230910f, 
    0.07731336f, 0.11220577f, 0.03398988f, -0.02042842f, -0.05414867f, -0.21507199f, -0.04507422f, 0.25353163f, 
    0.01230950f, 0.06625137f, -0.08395920f, 0.05364472f, -0.07378288f, 0.06719431f, 0.20823620f, -0.01148024f, 
    0.14216805f, -0.08233182f, -0.00496691f, -0.08404665f, 0.03085363f, -0.02063569f, -0.07531452f, -0.00372184f, 
    -0.01252244f, 0.02604623f, 0.01198446f, 0.10800639f, -0.08586898f, -0.37806931f, 0.06957491f, 0.03478706f, 
    0.04887296f, 0.07454512f, -0.16959611f, 0.01312607f, 0.08490583f, 0.02220732f, 0.01669851f, 0.08679166f, 
    0.00131708f, -0.20135146f, -0.11486175f, -0.25123566f, 0.01131835f, -0.03368486f, 0.01976071f, -0.01047843f, 
    -0.06802744f, 0.00106475f, 0.05534321f, -0.02248353f, 0.09282826f, 0.28725430f, 0.21734688f, -0.21899551f, 
    -0.02957344f, -0.02081500f, 0.03898862f, 0.07422122f, 0.06008361f, 0.07310797f, 0.18244138f, 0.12888287f, 
    -0.13435751f, 0.09807486f, 0.21276395f, 0.20104954f, -0.06731325f, 0.02601688f, -0.12843324f, 0.17627822f, 
    0.01512772f, 0.05203877f, -0.10671980f, -0.01579652f, -0.18613087f, 0.06774699f, 0.04966704f, 0.21994086f, 
    0.03898930f, -0.02302879f, -0.00888308f, -0.00174708f, 0.06905723f, -0.00039704f, 0.19806656f, 0.07818473f, 
    -0.26660138f, -0.01768998f, 0.04562720f, -0.17813040f, 0.16008256f, 0.08466963f, 0.00813691f, 0.02230423f, 
    -0.03715328f, 0.07356115f, -0.09732900f, 0.00391444f, 0.04357206f, 0.15126224f, 0.09838387f, -0.11636616f, 
    0.13710675f, 0.11220625f, -0.01725076f, 0.03958406f, -0.10545280f, 0.06800769f, -0.05247413f, -0.03913309f, 
    0.09698983f, -0.08492824f, 0.06537670f, 0.05634791f, -0.07441923f, 0.17712454f, 0.09202503f, -0.04443506f, 
    0.01735953f, -0.02748569f, 0.07595588f, -0.03466338f, -0.50979275f, -0.09526645f, -0.11776965f, -0.22466591f, 
    0.18674666f, 0.00666980f, -0.04293467f, -0.00907360f, 0.08286425f, 0.06231660f, -0.00767520f, -0.04689121f, 
    -0.24802919f, -0.01140866f, -0.02264447f, -0.20219134f, 0.14478132f, 0.07097243f, 0.12591428f, -0.04652206f, 
    -0.03166346f, -0.09520456f, 0.04274714f, 0.04272551f, 0.36458123f, 0.04017658f, -0.11128139f, 0.07707568f, 
    0.03894782f, 0.06168865f, 0.08021493f, 0.08948892f, -0.02626783f, 0.04712892f, 0.03678741f, 0.03938430f, 
    -0.01126522f, 0.21907376f, 0.18208155f, 0.17567734f, 0.04563127f, -0.10110301f, -0.01821716f, -0.09814041f, 
    0.00884313f, -0.05512042f, 0.01266016f, -0.12361763f, 0.30951002f, -0.07791144f, -0.03525358f, 0.03626933f, 
    -0.13755803f, 0.01091717f, -0.07762499f, -0.04440568f, 0.02364864f, 0.06676150f, 0.03824626f, 0.11014389f, 
    -0.15984800f, 0.16927905f, 0.15645516f, -0.17218022f, 0.03052555f, -0.15492535f, 0.00237782f, 0.00117161f, 
    -0.13783593f, 0.09968995f, 0.17478362f, -0.13074829f, -0.08752763f, 0.09216289f, 0.16067803f, 0.03754389f, 
    0.09189237f, -0.06468230f, 0.08457604f, 0.00464269f, 0.04090493f, -0.04327557f, -0.02058260f, -0.04489639f, 
    -0.16167521f, -0.19745462f, 0.07355019f, -0.25241390f, 0.18830776f, 0.02135881f, 0.02560787f, 0.01902677f, 
    -0.03977884f, -0.14423254f, -0.07167213f, 0.08976252f, -0.04946059f, 0.16808650f, 0.06031980f, 0.18364361f, 
    0.11339846f, -0.11690276f, 0.08970762f, 0.11661893f, -0.02358388f, 0.02061767f, 0.08024338f, -0.00321303f, 
    -0.24009049f, 0.02813209f, -0.03940775f, 0.07912201f, -0.12895015f, 0.11475322f, -0.00001831f, 0.01138561f, 
    0.02138646f, -0.00778908f, -0.02642306f, 0.05109354f, 0.12545352f, -0.01912408f, 0.09885437f, 0.01927439f, 
    0.13441058f, 0.06264614f, 0.07765601f, -0.03374359f, 0.06242500f, -0.04843762f, -0.07891408f, 0.02390079f, 
    -0.01998540f, -0.17303523f, -0.24870127f, 0.07221794f, 0.09162046f, 0.15921423f, 0.14662802f, -0.09500305f, 
    -0.07934161f, 0.07903299f, 0.11604808f, 0.08215810f, 0.15790224f, -0.14677268f, 0.10880475f, -0.04164938f, 
    0.01236992f, 0.08278360f, 0.01074638f, -0.13656303f, 0.04817829f, 0.18455331f, 0.05297297f, -0.01915369f, 
    0.10735568f, 0.12854153f, -0.02220178f, 0.12935710f, -0.02182148f, -0.01926188f, -0.02825788f, 0.11735413f, 
    0.16017920f, 0.03117501f, -0.07098545f, 0.01323534f, 0.15086181f, -0.13381660f, 0.07756958f, 0.01416256f, 
    0.13431555f, -0.04101805f, 0.02817879f, -0.06124425f, 0.16717225f, -0.01086960f, 0.00346729f, 0.00965890f, 
    -0.28845274f, 0.16706261f, -0.08354360f, 0.10582500f, -0.03187313f, -0.01899299f, -0.06031294f, -0.00118652f, 
    0.11514717f, 0.10051642f, -0.03123592f, 0.06153641f, 0.13621420f, 0.06025228f, 0.00310761f, -0.10193671f, 
    -0.03913446f, -0.00240897f, -0.06908668f, 0.07799772f, 0.09073994f, 0.11986697f, -0.02021859f, 0.00134566f, 
    0.13917366f, -0.19379310f, -0.25275797f, -0.06253617f, -0.11329959f, -0.14835073f, 0.05476608f, 0.12937787f, 
    0.06113076f, 0.00177898f, -0.05471380f, -0.02299396f, -0.22874473f, 0.20011413f, 0.16381136f, 0.08596157f, 
    -0.13353969f, -0.00970950f, 0.10145255f, 0.01783382f, 0.07608909f, 0.06327869f, 0.07220791f, 0.10502014f, 
    0.01612246f, -0.07935496f, 0.02613556f, -0.01012317f, -0.06206667f, 0.01018210f, 0.02768871f, -0.04978815f, 
    -0.01868269f, -0.02975675f, 0.05096653f, 0.04556417f, 0.04044829f, -0.03344071f, -0.02115743f, 0.05061062f, 
    0.01826356f, -0.00317444f, -0.00438813f, -0.06906481f, -0.06387144f, 0.03519243f, -0.03230654f, -0.00308969f, 
    0.05159708f, 0.03450874f, -0.05545006f, 0.04797206f, -0.05375578f, 0.03646648f, -0.05121601f, -0.04751693f, 
    -0.05327839f, -0.03251762f, -0.02955048f, -0.05133268f, 0.05815460f, -0.03666778f, -0.01787769f, 0.04199840f, 
    -0.02055805f, -0.04295291f, -0.06740728f, 0.02163663f, 0.00894282f, -0.00674301f, -0.04284611f, -0.05169800f, 
    -0.06052451f, -0.03990725f, 0.02450474f, 0.00995268f, 0.04636215f, 0.01439377f, 0.03599688f, -0.08159691f, 
    0.03713223f, 0.04151005f, -0.08337354f, -0.05852646f, -0.05853052f, -0.06082305f, -0.05626294f, 0.03441521f, 
    0.05039181f, -0.04623114f, -0.00400401f, -0.03619720f, -0.00488561f, 0.04608904f, -0.03031055f, -0.08186355f, 
    0.02753584f, -0.04482663f, 0.04812193f, -0.01849119f, -0.02406762f, -0.01874923f, 0.05966261f, -0.01316973f, 
    -0.00793470f, 0.00252349f, -0.01435663f, -0.00083593f, 0.03237066f, -0.00351166f, -0.06533192f, 0.02080858f, 
    -0.00837741f, 0.01424075f, 0.01595615f, -0.01370165f, 0.01476481f, -0.07151801f, 0.01411321f, -0.01310408f, 
    0.05669381f, -0.07658720f, 0.04842750f, -0.03552932f, -0.02853003f, -0.04553040f, 0.01527685f, -0.03033554f, 
    -0.04358011f, -0.07263448f, 0.03645924f, 0.04879655f, 0.00625620f, 0.02426759f, 0.05977322f, -0.02955009f, 
    -0.04975118f, -0.04777161f, -0.06429510f, 0.00688584f, 0.01076950f, 0.00646730f, 0.03141636f, 0.00748719f, 
    -0.03120974f, -0.00798166f, -0.08136306f, -0.02579362f, 0.04027446f, 0.00779970f, 0.04784065f, -0.03207828f, 
    0.02007785f, -0.03379463f, 0.00223687f, 0.03991657f, -0.04340463f, -0.07830709f, 0.05204816f, 0.04985502f, 
    -0.07233869f, -0.04070606f, 0.01985242f, -0.04011789f, -0.01291978f, 0.00063436f, -0.07534964f, -0.00023222f, 
    -0.01053410f, -0.04806662f, 0.02973818f, -0.03068683f, 0.01431654f, 0.01759087f, -0.00717671f, 0.00344945f, 
    0.04037530f, 0.05383499f, -0.02870157f, 0.00580163f, -0.05268031f, 0.02733386f, -0.04562797f, 0.03769455f, 
    0.02457015f, 0.05642047f, 0.03495679f, -0.02154017f, -0.05139589f, 0.06084201f, 0.01885785f, -0.08350063f, 
    -0.02632570f, -0.05668871f, 0.05125720f, 0.05277418f, 0.01710719f, 0.02721610f, -0.04550936f, -0.02430006f, 
    -0.02579697f, -0.00226104f, 0.02450987f, -0.00350304f, 0.00007646f, 0.04416418f, 0.03577334f, -0.04463944f, 
    -0.02197333f, -0.01406863f, 0.02304056f, -0.05695817f, -0.04026647f, -0.02349719f, 0.01431601f, -0.04069274f, 
    -0.04648860f, 0.04619215f, -0.20783162f, 0.08060076f, 0.06064780f, -0.01105631f, 0.06308180f, 0.01685461f, 
    -0.02690467f, -0.06417053f, -0.09723553f, -0.07954944f, -0.13530327f, -0.01118051f, -0.23588911f, -0.09958917f, 
    0.10495708f, -0.09339163f, -0.05614478f, -0.06748328f, -0.04914324f, 0.05045404f, 0.12761286f, -0.02786762f, 
    0.34178108f, -0.30132994f, 0.04874610f, -0.09541834f, 0.04940321f, -0.10695210f, -0.00803249f, -0.20105323f, 
    -0.08372496f, -0.11751416f, -0.01419189f, 0.10037374f, 0.09448172f, -0.10811352f, -0.14208326f, -0.24169523f, 
    0.07981999f, 0.04077433f, 0.02527790f, -0.08416530f, -0.19678439f, -0.09619132f, -0.01040865f, -0.13753431f, 
    0.14177164f, -0.21668163f, 0.07857888f, 0.01840029f, 0.05790066f, 0.06404396f, -0.07297907f, 0.05972160f, 
    0.01671017f, 0.08938136f, 0.07030414f, 0.15782093f, 0.25060222f, 0.08827125f, -0.00313261f, -0.03689628f, 
    0.06719756f, 0.00341056f, -0.07038306f, -0.00996667f, 0.00876594f, -0.02327598f, 0.01597445f, 0.07376642f, 
    0.07130568f, -0.17858514f, 0.00785069f, -0.00885686f, -0.00423584f, 0.05226064f, 0.00442675f, 0.09421159f, 
    0.03794168f, 0.02680859f, 0.04311658f, 0.03765794f, 0.15390250f, 0.13833752f, 0.25567123f, 0.03416891f, 
    -0.06893912f, 0.12489115f, -0.01328142f, -0.01061147f, -0.08954747f, 0.03454382f, -0.04849546f, -0.19887654f, 
    -0.13906050f, 0.16957311f, 0.06615179f, 0.19881442f, -0.04960936f, -0.14506441f, 0.03869262f, 0.05342029f, 
    0.04197235f, 0.07482810f, 0.05243519f, 0.15755840f, 0.38594082f, -0.13201237f, -0.15162745f, -0.07037684f, 
    0.06502349f, 0.12005559f, 0.13046312f, 0.08166809f, -0.06354522f, -0.15205584f, -0.07921594f, -0.03448389f, 
    0.12153851f, 0.31332475f, 0.07699835f, 0.08426512f, 0.03801257f, -0.06529915f, -0.01030697f, -0.01594383f, 
    -0.01000718f, 0.09623208f, -0.10353451f, -0.01369306f, -0.27409691f, 0.24248458f, -0.09859094f, -0.03724505f, 
    -0.02226337f, 0.02277445f, 0.01097643f, -0.03202691f, -0.04303303f, 0.05006516f, 0.05697271f, 0.14053175f, 
    -0.24710424f, -0.04405610f, 0.01412583f, 0.12113752f, 0.09593132f, -0.00583269f, 0.06880290f, 0.21345367f, 
    0.05554719f, -0.05582917f, -0.02013197f, 0.03567739f, 0.05541531f, 0.30774367f, 0.25508621f, -0.16575378f, 
    0.02903715f, 0.06062073f, -0.06937272f, 0.05333971f, -0.06807136f, 0.15605535f, 0.04322065f, -0.02325075f, 
    0.14034587f, 0.32726520f, 0.18992971f, 0.01002453f, -0.13323589f, -0.08782768f, -0.00912448f, 0.03741370f, 
    -0.02606512f, 0.13756818f, -0.04094231f, 0.08346625f, -0.05465680f, -0.08526750f, -0.11604073f, -0.11553504f, 
    -0.05908736f, 0.16256076f, -0.04067262f, -0.02904734f, 0.10355727f, 0.05165413f, 0.09759379f, -0.14629278f, 
    0.03520444f, -0.03627631f, -0.06983037f, -0.04560863f, 0.03775735f, -0.01395569f, -0.03464326f, 0.02572115f, 
    0.05772807f, -0.02154461f, 0.02257660f, 0.01003420f, -0.06340153f, -0.02492099f, -0.07506476f, 0.06094017f, 
    0.00483683f, -0.07118037f, 0.05125652f, 0.05408106f, -0.05772424f, -0.05595145f, 0.01828895f, -0.02520280f, 
    -0.03945344f, -0.06785575f, 0.02396051f, -0.03538430f, 0.06602134f, -0.01333215f, -0.01509146f, 0.00402243f, 
    -0.02376905f, -0.07377522f, -0.06233899f, -0.00140715f, 0.01421541f, 0.01909395f, -0.07177497f, -0.07378538f, 
    0.06214455f, 0.02917492f, 0.06200730f, -0.01233773f, -0.04660209f, -0.06839391f, -0.06678364f, 0.02491747f, 
    -0.02641166f, -0.04647895f, -0.03221522f, -0.03509131f, 0.04449092f, 0.04076410f, -0.04422697f, 0.00931910f, 
    0.02034908f, -0.02692725f, 0.03357880f, 0.06235135f, 0.01246268f, -0.06577146f, -0.05207494f, -0.07057184f, 
    0.00599623f, -0.07719319f, -0.01824300f, 0.02977479f, -0.03218390f, -0.03332108f, 0.03148931f, 0.01302273f, 
    -0.01855846f, 0.04222850f, 0.04580419f, -0.00324188f, 0.03215655f, -0.01515868f, 0.02325119f, 0.05323398f, 
    -0.06713020f, 0.05044906f, 0.06126084f, -0.00617797f, 0.04824844f, -0.05620239f, -0.07860538f, 0.04065321f, 
    -0.00441339f, 0.01770459f, -0.03388824f, -0.02951230f, -0.00343397f, 0.01483946f, 0.04084642f, -0.07638665f, 
    -0.05066488f, -0.04039011f, 0.05596904f, 0.01532761f, -0.04811147f, 0.06432900f, -0.07392598f, -0.02537874f, 
    -0.03464766f, -0.03821862f, 0.03643730f, 0.00087119f, 0.00490420f, 0.03546470f, 0.01932459f, 0.04705944f, 
    0.01176730f, -0.01443560f, -0.06696748f, 0.02517493f, -0.04271270f, 0.00546974f, 0.03652523f, 0.00653545f, 
    0.03781858f, 0.01110520f, -0.00490981f, -0.00399223f, 0.03704271f, 0.05003660f, -0.02984957f, -0.00583347f, 
    -0.01894066f, -0.04091868f, -0.01279815f, 0.01868073f, -0.01433832f, 0.04661008f, 0.02619123f, 0.03471784f, 
    -0.03062885f, -0.06821815f, 0.01882739f, -0.06460498f, -0.02257697f, -0.01078893f, 0.05379175f, -0.04777626f, 
    -0.06343412f, -0.01650240f, 0.03336543f, 0.00289991f, -0.04106260f, -0.00010993f, -0.02989616f, -0.06742659f, 
    -0.05913902f, -0.06578174f, -0.05700453f, 0.00855673f, 0.02500199f, 0.04275309f, -0.07771957f, -0.00101144f, 
    -0.00347048f, 0.02075645f, -0.05024791f, -0.04302542f, 0.01907708f, -0.02706287f, -0.04379591f, 0.05095040f, 
    -0.04019757f, -0.05806775f, -0.06237450f, 0.06281792f, -0.05460388f, 0.01840417f, -0.01719785f, -0.00906701f, 
    -0.00050021f, -0.02017781f, -0.00082065f, -0.00845314f, -0.00850452f, -0.06833489f, -0.01929217f, -0.07584971f, 
    -0.01017004f, 0.00843457f, 0.06347848f, -0.06912058f, -0.03271777f, -0.03996023f, 0.01298038f, -0.01844121f, 
    -0.08639770f, 0.00292934f, -0.09685044f, 0.13864525f, -0.02841544f, -0.03237788f, 0.00681720f, -0.04043461f, 
    -0.02102768f, -0.11689004f, -0.00349306f, -0.10622012f, 0.11248966f, -0.24573128f, 0.00442942f, 0.03512178f, 
    0.15058251f, 0.04224085f, -0.00077297f, -0.00132069f, 0.01327076f, 0.03622489f, 0.11113442f, 0.10183018f, 
    0.27567300f, -0.25152829f, -0.17475839f, 0.00661258f, 0.16184320f, -0.14340968f, -0.04054357f, -0.20328806f, 
    0.06594275f, 0.04605056f, 0.26071817f, -0.00019053f, 0.09020450f, -0.27817798f, -0.02293732f, -0.16239473f, 
    0.19724388f, 0.00810785f, 0.02309804f, -0.03186674f, -0.00075260f, -0.08217210f, -0.12746020f, -0.09550285f, 
    -0.18068819f, -0.23235728f, 0.01550159f, 0.02762192f, 0.00099102f, 0.08490621f, -0.09244084f, 0.10577142f, 
    0.02027215f, 0.02320220f, -0.07915196f, 0.08235320f, 0.13816793f, 0.28300479f, -0.04278609f, -0.03375545f, 
    -0.13037120f, 0.03715094f, 0.09288555f, 0.14713483f, -0.09443917f, -0.07761210f, 0.13229170f, 0.03903979f, 
    0.15041140f, -0.14251591f, -0.03986723f, -0.04480804f, 0.00541182f, 0.02213588f, 0.05023899f, 0.05020309f, 
    0.01823498f, -0.01010023f, 0.04673729f, -0.00527728f, 0.08700738f, 0.13247767f, -0.02946907f, 0.00929600f, 
    0.02816069f, 0.00666599f, 0.13519499f, 0.04982696f, 0.00091196f, -0.12323758f, 0.02472113f, -0.17070626f, 
    -0.03138202f, -0.15546483f, 0.07198878f, -0.01451601f, 0.13706483f, -0.12507708f, 0.10486871f, -0.14446598f, 
    0.09222517f, 0.00548553f, 0.17227112f, 0.07395589f, 0.04111208f, 0.05329239f, -0.03000973f, 0.11919373f, 
    -0.00590010f, 0.14278939f, -0.00391931f, 0.07479160f, 0.11342868f, 0.03624537f, 0.00873425f, -0.04793093f, 
    0.17898327f, 0.34438458f, 0.05623016f, -0.08016018f, -0.03846467f, -0.00609311f, 0.08792812f, 0.00371182f, 
    0.05036126f, -0.08972448f, -0.18372101f, -0.07931951f, -0.20753315f, 0.22879204f, -0.02313370f, 0.02749784f, 
    0.04395258f, 0.01243993f, 0.10135648f, 0.01654913f, 0.02151972f, -0.07015789f, -0.02208477f, 0.04126931f, 
    0.16399007f, -0.07968889f, 0.04796459f, 0.16186605f, 0.08342024f, -0.04974455f, 0.13945283f, 0.05622009f, 
    0.05086734f, -0.05550234f, -0.04346234f, -0.04844714f, 0.08482298f, 0.20945655f, 0.13690434f, -0.19489005f, 
    -0.01335636f, 0.04957946f, 0.07555179f, -0.00119281f, -0.02617457f, 0.12482636f, 0.05554267f, 0.02394123f, 
    0.09410646f, -0.00461413f, -0.02400731f, 0.05563664f, -0.04316252f, -0.11284271f, 0.03842096f, 0.02016298f, 
    0.05349312f, 0.05642593f, -0.12096886f, -0.04247859f, -0.01355575f, 0.28881213f, -0.23162942f, -0.02456163f, 
    -0.14015567f, 0.14566174f, 0.03076669f, 0.06813568f, -0.00516941f, 0.06788611f, -0.06343137f, -0.12367955f, 
    -0.08507949f, 0.00591865f, 0.07979162f, -0.06872427f, -0.09699301f, -0.02014804f, 0.03731469f, -0.04542733f, 
    0.05834642f, -0.13513161f, 0.06375635f, 0.11657295f, 0.27653906f, -0.15824527f, 0.21113905f, 0.12202737f, 
    -0.01153051f, 0.09510177f, 0.02460477f, 0.12271004f, 0.01274943f, 0.03897807f, -0.05194591f, -0.01602313f, 
    0.00453493f, 0.03073664f, -0.05259937f, -0.13082184f, 0.13465285f, -0.08291226f, 0.12099133f, -0.04347952f, 
    0.08089980f, 0.07119672f, 0.20711325f, -0.03342704f, -0.14619645f, -0.15399070f, 0.26787469f, 0.21545073f, 
    0.01968818f, -0.07917354f, -0.03455862f, 0.01901291f, 0.14375925f, 0.14152746f, -0.04587884f, 0.04664366f, 
    -0.34415552f, -0.09769816f, -0.20858887f, -0.05278021f, 0.06926613f, 0.00689399f, -0.11172815f, -0.06827016f, 
    0.02211157f, -0.00215605f, -0.06854961f, -0.14992495f, -0.22853076f, 0.34272775f, -0.11663574f, -0.08146047f, 
    0.03798133f, 0.05585805f, -0.04929492f, 0.06395333f, 0.09549100f, -0.06767315f, 0.00794932f, -0.09153768f, 
    0.17901622f, 0.08861667f, -0.17822486f, -0.22691005f, 0.10141828f, 0.06419396f, 0.19581252f, -0.07710797f, 
    0.02748687f, -0.03805476f, -0.07431103f, 0.01915230f, 0.23025183f, -0.03960234f, -0.26090732f, 0.18244822f, 
    0.12199688f, -0.01291609f, -0.06546285f, 0.03926140f, 0.07182653f, 0.02830299f, 0.05420850f, 0.16702305f, 
    0.03365755f, -0.19426921f, -0.11100321f, -0.20286378f, -0.06338891f, 0.04776106f, 0.06237615f, -0.15055399f, 
    -0.07773140f, -0.08567137f, 0.07568785f, -0.04887305f, -0.13860731f, 0.07669797f, 0.02770345f, 0.15646291f, 
    -0.02286757f, 0.11693336f, 0.03326533f, 0.10673824f, 0.18573909f, 0.15770167f, 0.00439107f, -0.13991284f, 
    0.06841400f, 0.00706113f, 0.00767038f, -0.02543501f, 0.00714744f, -0.12614930f, 0.01230008f, -0.14114106f, 
    0.18670140f, 0.04961248f, 0.10964070f, 0.04302743f, 0.29878914f, 0.15326309f, 0.10405023f, 0.25807726f, 
    0.04401084f, 0.08010687f, 0.07075802f, -0.03985833f, 0.17939451f, -0.02520888f, 0.01597435f, -0.01000620f, 
    0.16681810f, 0.04523319f, -0.00958452f, -0.01032318f, 0.07839034f, -0.08259703f, 0.04841850f, -0.19538845f, 
    -0.07022737f, 0.03242343f, 0.01229548f, -0.05746481f, 0.06067889f, -0.14618199f, -0.07474490f, 0.00748468f, 
    -0.05119014f, -0.00299259f, -0.00776997f, -0.01054264f, 0.00113549f, 0.07195961f, 0.01986740f, 0.04287480f, 
    -0.20708053f, -0.46609822f, -0.12114883f, -0.10706149f, 0.03775121f, 0.05103500f, -0.02259900f, -0.10819571f, 
    0.11703759f, 0.09377134f, -0.02937139f, -0.00118333f, -0.24751787f, 0.42274800f, 0.00706793f, 0.00920819f, 
    0.08194588f, -0.03315791f, 0.12121071f, 0.09643800f, 0.16060387f, 0.03341739f, -0.09835812f, -0.00859517f, 
    -0.02132261f, 0.21224593f, -0.09453662f, -0.05614356f, 0.11862077f, 0.04524699f, 0.01386009f, 0.02540937f, 
    -0.11522889f, -0.02178887f, 0.00012349f, -0.05188541f, 0.14318705f, 0.03132607f, -0.17407598f, -0.14229193f, 
    0.02862736f, -0.09411688f, -0.05548725f, -0.12448505f, -0.01813042f, 0.07812098f, 0.11537709f, 0.00607704f, 
    0.44782224f, -0.19856402f, 0.28104675f, -0.05423703f, -0.13377078f, -0.08768439f, -0.06521303f, -0.15103678f, 
    -0.10241719f, -0.02573039f, 0.05777255f, -0.03274675f, -0.02977397f, -0.13307777f, -0.03043101f, -0.15335880f, 
    0.03269185f, -0.01075186f, 0.11861683f, -0.03786156f, -0.05660100f, -0.01029147f, 0.01409274f, -0.06088226f, 
    0.03691893f, -0.43374139f, 0.13246959f, -0.04510589f, 0.00258132f, -0.08927468f, 0.02517047f, 0.01919174f, 
    0.01747218f, 0.02289682f, 0.04463555f, 0.08960734f, 0.07620936f, 0.07815000f, -0.03881868f, 0.14083458f, 
    0.13982002f, 0.02545516f, 0.00464231f, -0.02814258f, -0.03593415f, -0.02437070f, 0.02637562f, 0.11903898f, 
    0.13246028f, -0.11135843f, 0.08493801f, -0.06980269f, -0.18732895f, 0.06458557f, 0.03431125f, 0.04014612f, 
    0.00937218f, 0.00555871f, 0.02688714f, -0.01412741f, 0.08326863f, 0.08695655f, 0.16995230f, -0.05857097f, 
    -0.00184986f, -0.01161062f, 0.07219756f, 0.02763798f, 0.09662439f, 0.09966005f, -0.20607594f, -0.05329706f, 
    -0.10278454f, 0.12788521f, -0.12439807f, 0.03392044f, 0.04263178f, 0.10350110f, 0.08964729f, -0.04189400f, 
    0.09055468f, 0.07006275f, -0.03704454f, 0.11770263f, 0.48088673f, -0.07933630f, -0.00319656f, -0.00918231f, 
    -0.02265711f, -0.01511756f, 0.10365307f, -0.00751857f, -0.02949846f, 0.09538551f, 0.05115388f, 0.07104167f, 
    -0.02404366f, 0.05752359f, -0.07028451f, -0.00899366f, 0.06757519f, -0.08453272f, -0.07184432f, 0.09734464f, 
    0.08787633f, 0.12423998f, -0.06749399f, -0.02393313f, -0.00526658f, 0.01782741f, -0.01406312f, -0.04566787f, 
    0.27241403f, 0.00102309f, -0.04764872f, 0.03626516f, 0.09781710f, 0.08290827f, 0.06180452f, 0.06386145f, 
    -0.40890244f, 0.25157797f, -0.05168815f, 0.10869936f, 0.04420316f, -0.03539396f, 0.04210608f, 0.14906050f, 
    0.06872897f, 0.02525653f, 0.03592708f, 0.01378345f, -0.09500659f, 0.14813265f, 0.01546304f, -0.27472508f, 
    -0.01329033f, -0.01597694f, 0.00958789f, 0.02829893f, 0.07632121f, 0.07638969f, 0.06546307f, -0.09383752f, 
    0.11567026f, -0.09324710f, -0.14079499f, -0.01041439f, 0.09395820f, -0.10604287f, 0.00693039f, 0.09619373f, 
    0.05558580f, 0.05133265f, -0.03741854f, -0.09836312f, -0.02354731f, 0.06892979f, 0.09658614f, -0.11745074f, 
    0.02080266f, 0.20944892f, -0.01114862f, -0.01870085f, 0.08209866f, 0.14406368f, 0.01071898f, -0.07410691f, 
    -0.01190948f, 0.04787270f, 0.06116522f, -0.04516789f, -0.02404245f, -0.06936410f, 0.06258111f, -0.00018375f, 
    -0.00907969f, -0.02780186f, 0.05334890f, 0.00066365f, -0.07365844f, -0.05280328f, 0.01717205f, -0.04343390f, 
    0.04575365f, 0.01813310f, 0.02197435f, -0.04182307f, -0.04755552f, 0.03244427f, 0.05904723f, -0.07046517f, 
    0.01556276f, -0.01774487f, -0.01726975f, 0.06181913f, -0.03607270f, 0.00171265f, -0.02235886f, -0.02842078f, 
    -0.02497438f, -0.01759584f, 0.03452862f, -0.01364371f, 0.04383946f, 0.00569795f, 0.06212570f, 0.04265194f, 
    -0.00363816f, 0.02606227f, -0.05432168f, -0.01414226f, 0.06490243f, -0.03926549f, -0.05951528f, 0.04325215f, 
    -0.06419080f, -0.04079404f, -0.03696257f, -0.00621303f, -0.01757934f, -0.01901932f, -0.04281322f, 0.02775055f, 
    -0.02877227f, 0.02645821f, -0.06225766f, -0.06307799f, -0.04935478f, -0.00413498f, 0.02700484f, -0.07461374f, 
    -0.00006146f, -0.06763503f, -0.05886608f, -0.06680033f, 0.01673699f, -0.06788934f, -0.05506018f, -0.06493061f, 
    0.00480039f, 0.02297206f, -0.01867817f, -0.03646107f, -0.01478535f, 0.01101931f, -0.05318343f, 0.04633483f, 
    -0.04410023f, 0.00264128f, -0.03007167f, -0.01971657f, 0.04649829f, -0.05575788f, -0.07561514f, 0.02785707f, 
    -0.03345124f, -0.04290878f, -0.06920880f, -0.03895517f, -0.07259689f, -0.02423962f, 0.01658561f, -0.02193377f, 
    -0.07909213f, -0.07017171f, -0.06702413f, -0.03002116f, 0.06643705f, 0.00979022f, -0.02405649f, -0.03465989f, 
    0.02177170f, 0.01471563f, -0.05212765f, 0.04004285f, -0.02404609f, 0.03771531f, -0.05639162f, 0.05340773f, 
    -0.04476288f, 0.01443592f, -0.04545127f, 0.05713163f, -0.05564494f, -0.03083265f, -0.01729523f, 0.02068033f, 
    0.02074985f, -0.00318540f, 0.05537374f, 0.05924175f, 0.06640347f, -0.04481798f, -0.04528102f, -0.04254106f, 
    0.01513680f, -0.04053738f, 0.04995615f, -0.03567020f, -0.07069525f, 0.04124081f, -0.04031425f, -0.06066148f, 
    0.03010118f, -0.02783316f, 0.03121091f, 0.00865333f, 0.01698619f, 0.02031036f, 0.06396221f, -0.03822524f, 
    -0.04565481f, 0.04338353f, -0.00199955f, -0.06526624f, -0.02277722f, -0.01705943f, 0.01002127f, -0.04317737f, 
    0.02607374f, -0.00445475f, 0.07050300f, -0.07568976f, 0.05320251f, 0.04621019f, 0.01544938f, 0.06067550f, 
    0.00606519f, -0.05282234f, -0.06358439f, -0.03571837f, -0.02318661f, 0.00097511f, 0.01485659f, 0.03918105f, 
    -0.01905307f, -0.06050858f, -0.02955453f, 0.05690611f, -0.05127113f, 0.04474751f, 0.01998449f, -0.02150966f, 
    0.03382495f, 0.04906714f, 0.00020825f, -0.01816995f, 0.03692501f, -0.00782431f, -0.05557035f, 0.04093248f, 
    -0.06373669f, -0.00630886f, 0.01941223f, 0.00592665f, -0.04101728f, -0.04430550f, -0.02736144f, -0.05417937f, 
    0.08107395f, 0.04011295f, -0.04631492f, 0.04390853f, 0.14769039f, 0.01002551f, 0.07811058f, 0.16724148f, 
    -0.06610747f, 0.22769187f, -0.03385255f, 0.08877973f, 0.29823673f, 0.30812034f, -0.03791441f, 0.10460117f, 
    0.10583154f, -0.08848394f, -0.10135295f, 0.00863110f, 0.08727910f, 0.01977911f, -0.00091722f, 0.11899453f, 
    0.42254260f, -0.21801819f, 0.11065527f, -0.05929907f, -0.09088571f, 0.13927212f, 0.05018838f, -0.01464898f, 
    0.08716796f, -0.01941020f, -0.02295941f, -0.00772196f, -0.27792451f, -0.17841160f, 0.01089472f, 0.07502235f, 
    -0.01394673f, 0.05320909f, 0.00591033f, 0.02171282f, 0.17606159f, 0.14470041f, 0.12610722f, 0.11693928f, 
    -0.09088730f, -0.24881180f, 0.26123497f, -0.11949919f, -0.11938956f, -0.10691903f, -0.17385739f, -0.10885289f, 
    -0.01107766f, 0.02171226f, 0.09256026f, -0.07235929f, -0.03793668f, 0.06805276f, -0.18565074f, -0.01858812f, 
    0.02266189f, 0.07076016f, -0.00857873f, -0.00416386f, 0.08160686f, 0.00333758f, 0.03363360f, 0.03053606f, 
    0.00775044f, 0.02179319f, -0.12749401f, -0.07149273f, -0.13855861f, -0.01545829f, -0.13602494f, -0.00959960f, 
    -0.02779476f, 0.04878124f, 0.09003828f, 0.03741957f, 0.03533638f, 0.18840201f, 0.16511871f, -0.24360783f, 
    -0.00647710f, -0.03398681f, 0.07846418f, 0.04020713f, -0.10846838f, 0.04749167f, 0.13610338f, 0.02291678f, 
    -0.02916900f, -0.03550757f, 0.03160394f, 0.13105433f, -0.04799394f, 0.00300388f, 0.08593228f, 0.04396670f, 
    0.06322760f, 0.14074992f, -0.02046544f, -0.09000820f, 0.20776545f, -0.00954583f, 0.02889551f, 0.18059106f, 
    0.07554012f, -0.02742351f, 0.02531348f, 0.03692476f, -0.11702587f, 0.04433324f, -0.02796952f, -0.00276978f, 
    -0.09817152f, -0.02367883f, -0.16288517f, 0.22881787f, 0.11169258f, -0.00932968f, 0.04813016f, -0.05265919f, 
    -0.09745840f, 0.03561681f, 0.13713163f, 0.04633524f, -0.07842190f, 0.16446975f, -0.11056456f, 0.07636302f, 
    0.12179482f, 0.00525946f, -0.12898757f, 0.20719659f, 0.00936147f, 0.01465989f, -0.02047477f, -0.01301791f, 
    -0.18984911f, 0.04854294f, 0.10665957f, -0.03069581f, 0.02550120f, 0.21628426f, -0.08675590f, -0.00277164f, 
    -0.00134993f, 0.03331960f, -0.08008976f, -0.01108045f, -0.06619427f, -0.14712730f, 0.14963461f, -0.12797166f, 
    0.08300582f, 0.07618541f, -0.05391579f, -0.03593475f, 0.05816444f, -0.03022539f, 0.14092040f, 0.00437981f, 
    -0.06557465f, -0.11820098f, 0.12379581f, 0.17408763f, 0.07413740f, 0.01679696f, 0.01679560f, -0.16916801f, 
    -0.08734128f, -0.04596816f, -0.02429496f, 0.14775099f, 0.28521574f, 0.04541622f, 0.02185138f, -0.06016934f, 
    0.10802341f, 0.10606771f, -0.04157997f, 0.00045782f, -0.07792395f, -0.06802405f, -0.02044500f, 0.03857889f, 
    0.04837064f, 0.03149204f, 0.00731276f, -0.01148823f, -0.03907707f, -0.07114043f, -0.02165584f, -0.00225250f, 
    0.04365807f, -0.02014101f, -0.00040652f, -0.04168678f, -0.05850794f, -0.02578899f, -0.00781647f, 0.01855976f, 
    0.04738741f, 0.04997605f, -0.00343867f, -0.03786922f, -0.04744776f, -0.01632849f, -0.01449909f, 0.05598212f, 
    0.05276244f, -0.00212199f, -0.06589884f, -0.05662831f, -0.01445757f, -0.04431012f, 0.00675302f, 0.06219292f, 
    -0.04970334f, -0.06795382f, 0.00430656f, -0.03351441f, -0.07015534f, -0.01616289f, -0.05370656f, -0.00256015f, 
    -0.04263690f, -0.07843135f, -0.01574332f, 0.05962451f, 0.04222895f, -0.05379455f, 0.01252764f, -0.01664638f, 
    0.03377555f, 0.05185179f, 0.01698702f, -0.00366874f, -0.07144403f, -0.07457128f, 0.01715319f, -0.03274669f, 
    0.03292158f, -0.05336217f, 0.01712297f, -0.02663677f, -0.01511733f, 0.02836316f, 0.03325905f, -0.04380866f, 
    0.01765440f, -0.01759354f, -0.04468307f, 0.02760733f, 0.03549976f, 0.05886833f, 0.01853322f, -0.01692521f, 
    -0.02056002f, -0.04123379f, 0.04974644f, 0.05747903f, 0.02276921f, 0.02069160f, -0.06734604f, -0.00694787f, 
    -0.05328683f, -0.04124654f, 0.04794586f, -0.01965764f, -0.00469930f, -0.07633227f, -0.05216055f, 0.01436306f, 
    -0.04613848f, -0.04873679f, -0.05981585f, -0.04482284f, 0.02072461f, -0.01298057f, 0.01916775f, -0.01944775f, 
    0.06424301f, -0.00585486f, 0.00937520f, -0.03564371f, -0.02700470f, 0.02163762f, -0.01326909f, 0.01683600f, 
    -0.00965906f, 0.04633275f, -0.05745365f, -0.08149406f, -0.06444790f, 0.04285787f, 0.03447165f, -0.01867607f, 
    0.01828737f, 0.00821916f, -0.04474277f, 0.00749167f, 0.04330517f, -0.02621375f, -0.08354277f, 0.01081247f, 
    -0.05070683f, -0.08215340f, -0.01536348f, 0.04967410f, -0.01248905f, -0.04815964f, -0.08561299f, 0.03935984f, 
    0.02386672f, 0.02703974f, -0.04931457f, 0.03396700f, -0.04970438f, -0.05324019f, 0.01301062f, -0.05168938f, 
    -0.02406314f, -0.03979494f, -0.01479942f, 0.01999638f, -0.00925457f, 0.01278080f, -0.07367130f, 0.04565835f, 
    -0.07464564f, -0.07457069f, -0.07186837f, -0.00527605f, -0.02345530f, 0.03592264f, 0.01420939f, 0.03566651f, 
    -0.06008544f, 0.03175262f, -0.02434468f, -0.06816796f, -0.02676812f, 0.00342451f, -0.04102588f, -0.00780513f, 
    0.05145278f, -0.00251859f, 0.04674828f, -0.07987721f, 0.01720486f, 0.01053632f, -0.03906265f, 0.04264227f, 
    -0.06411027f, -0.00807137f, -0.04617488f, -0.02707382f, -0.04042846f, 0.03711466f, 0.00152111f, -0.00252857f, 
    -0.04548731f, 0.04324531f, 0.04256931f, 0.02956911f, -0.05866591f, 0.02951991f, 0.00524388f, -0.06668182f, 
    0.04323024f, -0.02988747f, -0.06856634f, -0.00306082f, 0.05865906f, 0.03773310f, -0.04523936f, -0.07347991f, 
    -0.09865718f, -0.03564293f, 0.19590756f, -0.03888410f, -0.03214245f, 0.15214047f, -0.03743375f, -0.06116479f, 
    0.10807379f, 0.01248430f, 0.00752756f, 0.18986566f, 0.02342215f, -0.05270530f, 0.13338906f, -0.09517404f, 
    0.15755695f, 0.04743461f, 0.23246431f, -0.03480921f, 0.16011785f, 0.07077834f, 0.01885886f, -0.01569675f, 
    -0.05911398f, -0.00650413f, -0.17444845f, 0.17672405f, -0.03440864f, 0.11133861f, -0.11331744f, 0.10451992f, 
    0.16814850f, 0.09810784f, -0.19782026f, 0.08788392f, 0.19819756f, -0.14658572f, 0.03136639f, 0.03839421f, 
    -0.00547206f, 0.14747134f, -0.11084738f, 0.07857366f, 0.01765149f, 0.04029818f, -0.05308458f, 0.08494173f, 
    0.06237105f, 0.22916569f, -0.14925867f, 0.04338729f, -0.05764673f, -0.10367227f, 0.07706886f, -0.04845037f, 
    0.07474042f, 0.08325601f, -0.00874042f, 0.05883597f, -0.18750191f, 0.14297475f, 0.08426931f, -0.17438042f, 
    -0.13148028f, 0.11919809f, 0.00531345f, 0.04190722f, 0.07104997f, -0.03472599f, -0.03343129f, 0.01352196f, 
    0.02868306f, -0.28537416f, -0.01069252f, -0.07854447f, 0.07826222f, -0.03551866f, 0.03407180f, 0.10376891f, 
    -0.06635901f, 0.09611429f, 0.06375001f, 0.02941679f, -0.40501723f, 0.00740659f, 0.16254134f, 0.07282809f, 
    0.03578440f, 0.01204484f, -0.15328085f, 0.04508538f, 0.05204735f, 0.02458666f, 0.14872460f, -0.00706776f, 
    -0.08718482f, 0.12358603f, 0.31323656f, -0.12024549f, -0.06293438f, -0.10432849f, -0.12853965f, 0.08430509f, 
    0.01862996f, -0.00348053f, 0.06761103f, -0.13566814f, -0.32502893f, 0.14088190f, -0.07287989f, -0.08619631f, 
    0.03859149f, -0.02967648f, -0.07648780f, 0.06993033f, -0.05097731f, -0.12291630f, -0.08520040f, 0.09769597f, 
    0.05301493f, -0.08524439f, 0.06341442f, 0.06198579f, -0.07325655f, 0.20875387f, -0.01695434f, -0.14773300f, 
    -0.02481371f, -0.02208167f, 0.20380686f, 0.05857854f, 0.16283397f, -0.19990548f, 0.04993050f, -0.02351263f, 
    -0.16326134f, 0.08414900f, 0.03969836f, 0.05035661f, 0.00899405f, 0.13533963f, 0.07668756f, 0.11649439f, 
    0.13199964f, -0.14799418f, -0.06309185f, -0.14502084f, -0.03017051f, 0.04336902f, 0.00816873f, -0.03880250f, 
    -0.03904901f, 0.01983621f, 0.02961443f, 0.01394821f, -0.07759727f, -0.22519945f, 0.00093777f, 0.27789208f, 
    -0.01414799f, 0.06932960f, -0.01155343f, -0.01286744f, 0.04528948f, -0.06070150f, 0.00558277f, 0.12941733f, 
    0.09118526f, 0.07038552f, 0.06314386f, -0.03763310f, -0.05932281f, -0.08087705f, -0.13204275f, -0.05277080f, 
    0.02296642f, -0.09132712f, 0.08251544f, -0.09879914f, 0.03441918f, 0.20875014f, 0.00733394f, 0.09689243f, 
    0.15584850f, -0.06165385f, 0.01491400f, -0.02369402f, 0.00005309f, -0.02038285f, -0.07593054f, 0.04455085f, 
    -0.15326223f, 0.11368544f, -0.01060309f, 0.09818933f, 0.01076666f, 0.08104419f, 0.02508294f, -0.03061106f, 
    -0.01948263f, -0.15968835f, 0.09203564f, -0.03919027f, -0.08231952f, -0.11743084f, -0.04677205f, -0.25813594f, 
    -0.04930617f, 0.03030050f, 0.00795472f, 0.02706128f, -0.00896589f, 0.02862861f, 0.02867493f, 0.08586337f, 
    0.13917230f, 0.02045327f, 0.10058057f, 0.03529243f, 0.01869135f, -0.01660980f, -0.06569881f, -0.12768419f, 
    0.00896500f, 0.00111276f, -0.05064841f, 0.09567418f, 0.24033976f, 0.04063024f, -0.01841382f, -0.12150992f, 
    0.11278948f, 0.13572030f, -0.04532182f, -0.01483734f, -0.16836153f, -0.03177652f, 0.00429257f, -0.11972872f, 
    0.20053580f, -0.13603339f, 0.03841175f, 0.21019007f, 0.07397560f, 0.10443790f, 0.14664750f, 0.03370661f, 
    0.01313481f, 0.02307563f, 0.02893453f, 0.21569847f, -0.06090667f, 0.11722801f, 0.10496296f, 0.11060953f, 
    0.00321679f, -0.00807693f, 0.01926659f, 0.02988522f, -0.01339165f, 0.09530094f, -0.02105005f, -0.00496063f, 
    0.00208776f, -0.29120475f, 0.16332226f, -0.12115210f, -0.10271442f, -0.00436517f, 0.08516688f, 0.09481812f, 
    0.03201394f, -0.08975329f, 0.06252412f, 0.12399785f, 0.02145356f, 0.00619716f, 0.14537558f, 0.29745185f, 
    -0.15092537f, 0.07405960f, 0.07275990f, -0.03345946f, 0.02473408f, -0.05868288f, -0.18044360f, -0.12925211f, 
    0.03641927f, 0.08995565f, 0.00359098f, 0.07744366f, -0.05018909f, 0.03111454f, 0.07038184f, 0.00783251f, 
    -0.06176491f, 0.10718395f, -0.04160921f, 0.21348490f, 0.25141051f, 0.00238131f, 0.11435886f, -0.09627041f, 
    0.00370019f, 0.00682362f, -0.03389401f, 0.06636184f, -0.00520159f, -0.01050223f, 0.05710651f, 0.20689569f, 
    0.04475449f, 0.10717635f, 0.07278081f, -0.16648412f, -0.11798574f, 0.10757989f, 0.05822970f, 0.18438163f, 
    -0.00075950f, -0.03087635f, -0.21730219f, -0.12773612f, -0.14376687f, -0.01922693f, 0.04467272f, -0.16544482f, 
    0.11045840f, 0.11272978f, -0.00260221f, -0.02579515f, -0.11711367f, 0.03530537f, 0.06239880f, 0.07874852f, 
    -0.20871843f, -0.01817503f, -0.14752990f, 0.00206037f, -0.06369250f, -0.03645355f, 0.16993155f, 0.16768174f, 
    0.05663414f, -0.09532054f, -0.04294677f, 0.09268182f, 0.01734288f, 0.00019684f, -0.03348944f, -0.09895849f, 
    -0.03096559f, 0.04588778f, -0.05432205f, 0.10375684f, -0.04441878f, 0.02245816f, -0.03198777f, -0.00192614f, 
    0.21951748f, 0.13823679f, -0.14551066f, 0.06821664f, -0.06473228f, -0.00434804f, 0.06264959f, 0.18032360f, 
    0.05273036f, 0.02762300f, -0.03696263f, -0.01961728f, -0.03758362f, 0.02145428f, -0.01811238f, 0.05221519f, 
    -0.02324147f, 0.14138071f, 0.00152953f, -0.03130275f, 0.11524155f, 0.11822554f, 0.07522251f, -0.03192184f, 
    0.00177941f, 0.05350769f, 0.04836677f, 0.00423548f, -0.00726847f, -0.02432091f, -0.04924579f, -0.01602048f, 
    0.05502307f, -0.04976177f, 0.00714927f, -0.03910438f, -0.00748442f, -0.01899916f, -0.01749011f, -0.05761184f, 
    0.03069445f, -0.04702518f, -0.02957129f, 0.05831145f, 0.06261530f, -0.01661691f, -0.05377852f, 0.04687703f, 
    -0.00926906f, -0.05474986f, -0.03050895f, -0.01409183f, 0.00014749f, -0.06028192f, 0.00380593f, -0.02748130f, 
    -0.03032283f, -0.07219198f, -0.06799521f, 0.05170793f, 0.00437495f, -0.01631504f, -0.05158792f, -0.01088639f, 
    0.06504249f, -0.01300318f, -0.01511724f, 0.03301978f, -0.05584192f, 0.02351547f, 0.05146655f, -0.01583904f, 
    -0.00682125f, -0.00254816f, -0.02746004f, -0.00063015f, -0.02229411f, -0.05513643f, -0.01680317f, 0.01172090f, 
    0.04564695f, -0.06182767f, -0.01874887f, -0.05236525f, -0.00705841f, 0.00562292f, -0.03036366f, -0.05538666f, 
    -0.00184670f, -0.07661248f, 0.05773214f, 0.04057486f, -0.05291216f, 0.06371917f, 0.01786744f, -0.03830175f, 
    0.02575699f, -0.00710174f, -0.00815711f, -0.06357448f, 0.06375173f, 0.05878621f, -0.02569505f, 0.01042260f, 
    -0.01617379f, -0.06423727f, -0.07121979f, -0.00010786f, 0.06457234f, -0.03909575f, -0.06108936f, -0.03913176f, 
    -0.06184863f, -0.05999396f, 0.04507872f, -0.02577495f, -0.04229374f, -0.04822864f, 0.06031440f, -0.00576080f, 
    0.02600322f, -0.05000863f, 0.00811358f, 0.06601299f, -0.06302860f, 0.00155289f, -0.06111301f, -0.02118865f, 
    -0.01025570f, 0.00422423f, 0.00634447f, -0.04731378f, 0.01301789f, -0.02670503f, -0.07293735f, -0.04464942f, 
    -0.06315339f, -0.01822653f, -0.06342425f, 0.01065945f, 0.02631172f, 0.00420964f, -0.02180628f, -0.00503842f, 
    0.00801767f, -0.07084205f, -0.01974953f, 0.02697971f, -0.03326150f, 0.01196218f, 0.02386693f, 0.00639836f, 
    0.04540150f, -0.00767646f, -0.00909765f, -0.00266402f, 0.00351903f, 0.05845311f, 0.03957950f, -0.04131602f, 
    -0.02482185f, 0.05662178f, 0.06121172f, -0.03579236f, -0.04624444f, -0.05691148f, 0.00894658f, 0.05310491f, 
    0.02026519f, -0.07520798f, 0.00103033f, 0.05929122f, 0.06154901f, -0.01091095f, -0.04359439f, -0.06695600f, 
    0.05027177f, 0.05377914f, 0.03675240f, -0.06708163f, 0.00617350f, 0.05146227f, -0.03134302f, -0.00765489f, 
    -0.07086439f, -0.02335795f, -0.04612713f, -0.04574607f, -0.07600853f, 0.05348548f, -0.06063671f, 0.04541818f, 
    -0.02963819f, 0.02618264f, -0.03500030f, 0.03459917f, 0.05072370f, 0.01319298f, -0.05531992f, -0.03078788f, 
    -0.00701487f, -0.03999628f, -0.03109769f, -0.05585239f, 0.01185928f, 0.01815151f, 0.03246952f, 0.00676869f, 
    -0.05432665f, 0.03165992f, -0.02437240f, -0.01510584f, -0.00550461f, 0.01373017f, -0.03173232f, -0.07199623f, 
    0.06373407f, -0.02821994f, 0.02187488f, 0.04741381f, -0.07884248f, 0.03650092f, 0.00377836f, 0.00644009f, 
    -0.03252211f, 0.04341706f, -0.06911445f, 0.00690100f, 0.04922624f, -0.07126082f, 0.03636216f, 0.01761766f, 
    -0.04003223f, -0.05421609f, 0.01852386f, 0.05072431f, -0.04215145f, 0.01068423f, -0.03573344f, -0.00378600f, 
    -0.06103102f, 0.00723732f, 0.01302570f, -0.06557166f, -0.07051225f, 0.03514099f, -0.05312176f, -0.02673969f, 
    0.05959512f, -0.03847425f, 0.04453512f, -0.03698019f, -0.03109502f, -0.02998305f, 0.03094922f, 0.01382295f, 
    -0.06913251f, 0.05090393f, -0.02230521f, -0.00287869f, 0.03795854f, 0.03724693f, 0.01116260f, 0.02871471f, 
    -0.01590091f, -0.01982872f, 0.01063081f, -0.01296513f, -0.01972682f, 0.02474870f, 0.01688529f, -0.02865060f, 
    -0.02597911f, 0.04087079f, -0.03477697f, 0.01944173f, -0.04799031f, -0.01129604f, -0.06139079f, -0.04734100f, 
    0.03241836f, -0.00153693f, -0.04035409f, 0.01344630f, 0.00721522f, -0.05362769f, -0.05967197f, -0.05632336f, 
    -0.02201285f, -0.03118226f, -0.04465416f, -0.04950476f, -0.06064355f, -0.00807748f, 0.00068581f, 0.01807856f, 
    0.05086322f, 0.03420690f, 0.02697439f, 0.06272474f, 0.04328916f, 0.00754803f, 0.03691962f, 0.07148471f, 
    0.04133803f, 0.00879050f, 0.03285829f, 0.03129097f, -0.02835027f, -0.07061996f, 0.02652897f, -0.03427470f, 
    -0.07345725f, -0.07743098f, -0.04489509f, 0.02267469f, 0.03644196f, -0.01245933f, -0.04973575f, 0.00472859f, 
    -0.05382085f, -0.05902557f, -0.02124630f, -0.01974284f, 0.04388291f, -0.05816520f, 0.03408806f, -0.05095607f, 
    0.00720569f, -0.04942080f, -0.04791451f, 0.02766538f, -0.07828919f, -0.07931701f, 0.00703941f, -0.01811252f, 
    0.01169606f, -0.02552363f, 0.04742625f, -0.00837050f, 0.00262820f, -0.00207967f, -0.04348935f, 0.02450583f, 
    -0.04100786f, 0.03276093f, 0.01010811f, -0.07191994f, -0.00820107f, -0.02077495f, 0.06402984f, 0.00721104f, 
    0.03173554f, -0.00429871f, 0.03061318f, 0.03706017f, 0.05589755f, -0.03984310f, 0.02185509f, 0.03914107f, 
    -0.04241143f, 0.02084128f, -0.02940211f, -0.06766813f, -0.04612023f, -0.01495004f, 0.05207602f, -0.02184956f, 
    0.05292162f, -0.04577934f, 0.00113705f, 0.00280067f, 0.03233008f, -0.05272117f, -0.07290708f, -0.02220663f, 
    -0.02462322f, -0.05906319f, -0.03711548f, -0.03888112f, -0.05912627f, -0.02062373f, 0.00538916f, -0.05582144f, 
    -0.05856517f, -0.03800577f, 0.04856573f, 0.07108132f, 0.05561628f, 0.06094101f, 0.01700809f, 0.06260540f, 
    -0.01908160f, 0.02222469f, -0.02219456f, 0.06255320f, 0.02764858f, -0.06613912f, -0.03012202f, -0.02089041f, 
    0.05462912f, 0.02583593f, 0.01003528f, -0.07043466f, -0.05018876f, -0.03680158f, -0.00077370f, 0.03932565f, 
    -0.16194539f, -0.04254515f, 0.11577860f, 0.05155438f, 0.02939158f, -0.15729165f, 0.05612249f, -0.00907384f, 
    -0.00469190f, 0.03767075f, -0.11639738f, 0.02028900f, -0.08041427f, -0.02186896f, 0.19538759f, 0.12383224f, 
    0.07824679f, 0.03654217f, 0.14330268f, 0.11112779f, -0.05964355f, 0.14165922f, -0.06700812f, 0.02773960f, 
    -0.14619179f, -0.01256892f, -0.08379535f, -0.06212372f, 0.15941487f, 0.01150853f, 0.11573488f, 0.07868739f, 
    0.03891061f, -0.04096130f, -0.01869245f, 0.07585724f, 0.18427631f, 0.06145027f, 0.19523045f, -0.00232326f, 
    0.04970768f, -0.04504117f, 0.03137259f, -0.07945009f, 0.13622013f, 0.12342431f, 0.01032391f, -0.03285274f, 
    -0.11955066f, 0.23723991f, -0.14629246f, 0.02952629f, -0.07423372f, 0.14231406f, 0.00832308f, 0.09184688f, 
    0.12780099f, -0.01679931f, -0.05201171f, -0.03506431f, -0.24193425f, 0.24610749f, -0.06818452f, -0.06375556f, 
    -0.12730415f, 0.06200299f, 0.12848927f, 0.05365380f, 0.05064237f, -0.09081171f, -0.02353445f, -0.00534189f, 
    -0.00437059f, 0.10867149f, -0.09047235f, 0.09184802f, 0.10829393f, 0.08728139f, 0.02004840f, 0.09093279f, 
    0.05398995f, -0.00413891f, 0.03251322f, 0.04093978f, 0.04982592f, -0.15716161f, -0.02558439f, 0.13615467f, 
    0.00857272f, 0.04172906f, 0.07429450f, -0.00092810f, -0.03438411f, -0.13193853f, -0.01692464f, -0.10598998f, 
    0.10855436f, -0.39398569f, -0.08765484f, -0.21060461f, 0.08459656f, -0.04567213f, 0.16569607f, -0.14719237f, 
    0.05936063f, -0.08788434f, 0.11718733f, -0.05413901f, -0.15109375f, 0.12960261f, 0.03691471f, -0.08010952f, 
    -0.01825736f, 0.08366141f, -0.02577154f, -0.01703486f, -0.04152581f, 0.05038819f, -0.15181829f, -0.04808434f, 
    0.04329318f, 0.01660489f, 0.17957050f, 0.11595274f, -0.03934065f, -0.03770379f, 0.12066159f, 0.00806730f, 
    0.12160311f, -0.08447319f, 0.08256412f, 0.02027080f, -0.34701645f, -0.06567263f, -0.00097142f, 0.25391778f, 
    -0.09323621f, -0.04919008f, 0.00035727f, -0.13323800f, -0.00164258f, -0.01025595f, -0.03414820f, -0.03719559f, 
    0.22950776f, -0.29897660f, 0.07604638f, -0.11979629f, 0.06390831f, -0.03505972f, 0.09808956f, -0.06350771f, 
    0.02293344f, 0.00820445f, 0.00633445f, 0.01890073f, 0.36818367f, 0.07099060f, 0.12215378f, 0.25901935f, 
    -0.15312615f, 0.03400269f, 0.11182820f, 0.09971390f, -0.01787844f, -0.03399651f, 0.00218938f, 0.20290090f, 
    -0.12584165f, 0.06820226f, 0.03058783f, 0.08206445f, -0.13643840f, 0.00882727f, -0.06014558f, -0.05695870f, 
    -0.05016777f, -0.00898076f, -0.00689561f, -0.01242267f, -0.06817228f, 0.02233603f, -0.01996860f, 0.08386176f, 
    -0.02301501f, -0.10316978f, 0.01493459f, 0.03083257f, -0.00066583f, -0.06237664f, -0.07381878f, 0.01443128f, 
    -0.00888750f, 0.03558386f, -0.02702033f, 0.06478085f, -0.03123389f, -0.03619153f, -0.07838445f, -0.04983173f, 
    0.05313142f, -0.02586762f, -0.02859177f, -0.03608566f, -0.06756883f, -0.05524879f, 0.00668319f, -0.02704164f, 
    0.00220067f, -0.05366707f, -0.02829496f, 0.04867183f, 0.02780885f, -0.07278798f, 0.04858334f, 0.03881107f, 
    -0.06482973f, -0.06065093f, -0.04282301f, 0.00108973f, -0.02702082f, 0.06159048f, -0.04754670f, -0.06177579f, 
    -0.06431065f, -0.01956999f, -0.03886371f, -0.05234342f, -0.03118167f, -0.06024805f, -0.02984369f, 0.01863917f, 
    0.02373154f, -0.02059264f, 0.02698252f, 0.05129828f, 0.03422676f, -0.07722288f, -0.01447760f, 0.03131966f, 
    0.03424172f, -0.00040531f, 0.00804659f, 0.05594055f, 0.00721219f, -0.01512700f, -0.00740497f, -0.01313624f, 
    0.04992992f, 0.03469240f, -0.00284642f, -0.01543708f, 0.03047189f, 0.03042333f, 0.04593945f, 0.05409542f, 
    0.05347962f, 0.03386489f, -0.05804626f, -0.06475580f, -0.07051563f, -0.02642232f, 0.02977160f, 0.05590161f, 
    -0.04666685f, 0.01287586f, -0.06904833f, -0.06630430f, -0.01772786f, -0.00653012f, -0.03018275f, 0.01611149f, 
    0.00224552f, 0.06012046f, -0.06593563f, -0.06359792f, -0.02130828f, -0.06052982f, 0.06358995f, 0.03292063f, 
    0.02061838f, -0.05958957f, 0.04921612f, 0.00078146f, 0.00656942f, 0.05065101f, 0.02936714f, 0.00414693f, 
    0.05836758f, 0.04255164f, 0.04287970f, 0.02208201f, -0.04492578f, 0.05624071f, 0.05409080f, -0.03929750f, 
    0.05279427f, -0.03869846f, -0.03198317f, -0.02040305f, 0.04915584f, 0.04159417f, -0.05782734f, -0.02847616f, 
    -0.01379709f, -0.03253719f, -0.05714181f, 0.02693024f, -0.05452880f, -0.02134748f, -0.05923601f, -0.06895700f, 
    -0.02321546f, -0.02318031f, -0.06943002f, -0.05729994f, -0.04447405f, 0.03539850f, -0.03421021f, -0.06373359f, 
    -0.07883886f, -0.04700747f, 0.00204635f, 0.02197831f, -0.07660349f, -0.01111120f, -0.02939899f, -0.03627333f, 
    0.03320999f, -0.00560017f, -0.07464951f, -0.05175043f, 0.03313081f, -0.00256352f, 0.05306500f, 0.05597482f, 
    -0.05066043f, 0.05964775f, -0.03613544f, -0.01544253f, -0.02076463f, 0.04539253f, -0.02593723f, 0.02640757f, 
    0.04343341f, -0.06736977f, 0.02548691f, 0.05705531f, -0.04280315f, 0.04745709f, -0.06406365f, -0.01385195f, 
    0.03345679f, -0.03208264f, -0.03371739f, 0.05172470f, -0.01915781f, 0.04410622f, 0.00670399f, -0.02592338f, 
    -0.01638468f, 0.01197235f, 0.03812976f, -0.01299013f, -0.02293474f, -0.07164949f, -0.02254940f, 0.06144223f, 
    0.04698622f, 0.05069506f, -0.03315978f, 0.04023322f, -0.05069808f, -0.06541049f, -0.07136015f, 0.06548589f, 
    -0.06199790f, -0.01442753f, 0.00957217f, 0.05194367f, -0.07754648f, -0.06279516f, -0.00097147f, -0.07385901f, 
    -0.05652728f, 0.03815139f, -0.03332574f, -0.05486478f, -0.02908451f, 0.03394482f, -0.00727186f, 0.01952390f, 
    -0.05253787f, 0.01256900f, -0.00015402f, -0.05316756f, -0.06795762f, 0.04228285f, -0.00067576f, -0.06473615f, 
    -0.02059427f, 0.05192193f, 0.05481147f, 0.02136679f, -0.03222255f, -0.05977542f, -0.07481797f, -0.06801345f, 
    -0.03372784f, -0.02104051f, -0.02447644f, 0.05677443f, 0.01130990f, -0.01384826f, -0.07548483f, -0.04229991f, 
    0.01785488f, -0.03565331f, -0.08034971f, 0.01221099f, 0.02693223f, 0.00716505f, 0.01979434f, 0.04762638f, 
    -0.04508433f, 0.00529964f, 0.03003191f, 0.01719393f, 0.00991342f, 0.01988087f, 0.04274895f, -0.02969722f, 
    0.05146028f, 0.05073904f, -0.07991225f, -0.05446730f, 0.06975133f, -0.07560815f, -0.01905921f, -0.02469398f, 
    -0.00695045f, 0.02783200f, 0.00775080f, -0.05022498f, -0.07266947f, -0.00322828f, -0.01955531f, 0.00495465f, 
    -0.00890785f, -0.03971909f, 0.00544838f, -0.05657187f, 0.05651247f, -0.07889116f, 0.04535683f, -0.00626160f, 
    -0.05883135f, -0.04476150f, -0.01511936f, 0.02597261f, 0.01066525f, 0.05714994f, -0.02496897f, -0.00207199f, 
    -0.03409730f, -0.03025037f, 0.05476964f, -0.06235314f, 0.00439278f, 0.00114396f, -0.01913921f, 0.02114048f, 
    0.02035174f, -0.07089915f, 0.00898997f, 0.00983659f, 0.04093078f, -0.01157700f, 0.03871549f, 0.03546951f, 
    0.00972585f, -0.03789906f, 0.05224428f, 0.02864905f, -0.01664968f, -0.01650821f, -0.03086762f, -0.04445021f, 
    -0.01182823f, -0.08743469f, 0.01566539f, -0.01000365f, -0.06735439f, -0.03539268f, 0.01689661f, -0.02477661f, 
    -0.05253716f, -0.07363982f, 0.05511002f, 0.02402692f, -0.05512147f, -0.01474660f, -0.05414496f, -0.08911198f, 
    0.00698073f, -0.04131885f, 0.03811377f, -0.04082505f, 0.02526018f, 0.05461578f, 0.00381207f, -0.01783803f, 
    -0.05203913f, 0.05659842f, -0.03420111f, -0.06001879f, 0.00748060f, 0.03605249f, -0.07856762f, -0.03217813f, 
    -0.04617151f, 0.02640822f, 0.00842054f, 0.04930776f, -0.00629550f, 0.02657247f, 0.07063189f, -0.04809440f, 
    -0.03531284f, -0.06017158f, -0.00854894f, -0.04503478f, -0.03313586f, -0.03693814f, 0.00651193f, 0.01991080f, 
    -0.07416791f, -0.00141437f, 0.05344355f, -0.01405240f, 0.03814971f, -0.04488248f, 0.01538327f, 0.00810566f, 
    0.03991287f, -0.07555902f, -0.07791059f, -0.02399232f, -0.01372019f, 0.05000320f, 0.04592329f, -0.04583188f, 
    -0.06652924f, -0.04855272f, 0.00672674f, 0.00234190f, 0.02960889f, 0.04597482f, -0.08255042f, 0.05995078f, 
    0.04533900f, -0.04558476f, -0.05850222f, -0.00325215f, -0.06762990f, 0.00722158f, -0.08280210f, -0.00876467f, 
    0.02890940f, -0.03640403f, -0.04327850f, -0.00432024f, 0.05752571f, -0.01653828f, 0.01594337f, -0.03059903f, 
    -0.02525418f, -0.09528562f, -0.06684385f, -0.05875251f, 0.01750019f, 0.04972004f, 0.00124070f, -0.05143145f, 
    -0.00667898f, -0.04289782f, 0.03327018f, -0.05347816f, 0.02148661f, -0.06905984f, 0.03080000f, -0.01190652f, 
    -0.03463866f, 0.00862858f, -0.08024736f, -0.03336933f, -0.05563442f, 0.01235691f, -0.08804204f, -0.03364815f, 
    0.03781455f, -0.03107509f, -0.05924071f, 0.00728605f, -0.02066879f, -0.06788974f, 0.04785491f, -0.01853442f, 
    -0.01665826f, -0.07598080f, -0.09530492f, -0.02525204f, 0.03966686f, -0.02830292f, 0.03807333f, -0.04374258f, 
    0.04310667f, -0.06562902f, 0.04637776f, -0.01668527f, -0.06512468f, -0.06755080f, -0.04480377f, -0.06346229f, 
    -0.01341706f, -0.01900756f, -0.01654313f, 0.03251324f, -0.02735013f, 0.01127012f, -0.02880163f, 0.05310176f, 
    -0.04773491f, 0.03991767f, 0.01138091f, -0.02943134f, -0.00258953f, -0.09006909f, 0.03244954f, 0.05931353f, 
    0.01846861f, 0.00192650f, 0.04206824f, -0.06044574f, -0.07026943f, 0.03048066f, -0.07693912f, 0.02632764f, 
    0.04523559f, -0.00468778f, 0.01835978f, -0.01248951f, -0.04574366f, 0.02313281f, -0.01452085f, -0.07846890f, 
    -0.09011021f, 0.03525255f, -0.05832929f, 0.00569329f, -0.07674674f, 0.00300633f, -0.01126367f, -0.07710492f, 
    -0.04419817f, -0.06897663f, -0.03986223f, 0.02437541f, 0.01219121f, 0.04323381f, -0.02435021f, 0.03357986f, 
    -0.08012517f, -0.04409552f, 0.01457626f, 0.01482874f, 0.01822118f, -0.06010067f, -0.02174783f, 0.02648762f, 
    0.00721544f, 0.04937325f, 0.04369756f, 0.02346034f, -0.07437563f, -0.08645502f, 0.05585396f, 0.00542529f, 
    -0.07050866f, -0.04710166f, -0.06259529f, -0.01457479f, -0.02185486f, -0.04310473f, 0.00467294f, -0.00318687f, 
    -0.00315197f, -0.05895554f, -0.07689047f, 0.01280506f, -0.04838640f, -0.08011671f, -0.01592099f, 0.03835403f, 
    -0.07419224f, 0.02147896f, -0.04329611f, 0.00744575f, -0.00628540f, -0.00343870f, 0.05449500f, -0.05028195f, 
    -0.01062094f, -0.05040754f, -0.01030195f, 0.02608681f, -0.08953355f, 0.02987527f, -0.07467122f, -0.04034469f, 
    -0.03736244f, -0.04559165f, 0.03312451f, 0.02023416f, 0.04276181f, -0.02544571f, -0.03619133f, 0.02754691f, 
    -0.04968496f, -0.00019616f, -0.07333592f, -0.04393553f, -0.06650296f, -0.02188298f, 0.01237067f, 0.06430986f, 
    -0.07244970f, 0.02184199f, 0.01841000f, -0.03324291f, -0.00381696f, -0.07918325f, -0.07139144f, 0.04067105f, 
    0.00783520f, -0.00201654f, 0.01358840f, -0.04690144f, 0.04023697f, -0.06820469f, 0.05907447f, 0.00578641f, 
    0.03602768f, -0.06248844f, 0.03470073f, -0.01214340f, -0.02887644f, 0.04787910f, 0.04240244f, -0.01241227f, 
    -0.02350364f, 0.03897196f, 0.01314467f, 0.03933998f, 0.04389966f, -0.05753352f, 0.05288316f, 0.05744615f, 
    0.13530727f, -0.14261459f, -0.11330046f, -0.00773538f, -0.03536218f, 0.00423067f, 0.02318302f, 0.17010400f, 
    0.11260452f, 0.26364678f, -0.01510169f, 0.03083404f, -0.04428967f, 0.11935756f, -0.09686767f, 0.00814345f, 
    0.10129879f, -0.01103539f, 0.01184235f, -0.05507991f, 0.03155366f, -0.00645497f, 0.04583692f, 0.01340315f, 
    -0.13858405f, -0.15245607f, -0.11319692f, -0.16459212f, 0.07337815f, 0.12628309f, -0.02974231f, 0.13274080f, 
    0.01877590f, -0.04775596f, -0.02815103f, -0.04402839f, 0.06163000f, -0.01752127f, -0.12760758f, 0.10232510f, 
    0.00382843f, -0.03574873f, 0.01943155f, 0.03081893f, -0.01464726f, 0.10726345f, 0.14664775f, 0.09404801f, 
    0.18622564f, 0.14033768f, 0.22101276f, 0.07153621f, 0.10146276f, -0.16191182f, -0.06886668f, -0.01467414f, 
    0.07791624f, 0.05200922f, -0.10644090f, -0.06083540f, 0.23680036f, -0.14445612f, 0.00805503f, 0.05570817f, 
    -0.00874216f, 0.10180796f, 0.03063955f, -0.04396409f, 0.17953233f, 0.03510955f, -0.01980210f, 0.07162926f, 
    -0.06992962f, -0.04432174f, -0.12715994f, -0.06211610f, 0.12465020f, 0.05478238f, -0.05171920f, -0.07328579f, 
    0.02814442f, -0.00513366f, -0.05140914f, -0.05685596f, 0.01769475f, 0.03472736f, 0.19882753f, -0.28508106f, 
    0.12429237f, -0.11077547f, -0.01605380f, 0.15560235f, 0.02339758f, 0.09626564f, 0.19488165f, 0.14465113f, 
    -0.06271290f, 0.00538745f, 0.09104196f, -0.11955112f, 0.02614273f, -0.13728072f, -0.07684610f, 0.02809829f, 
    0.18125878f, -0.02592583f, 0.01237193f, -0.15232368f, -0.34564796f, -0.24741949f, -0.19607900f, 0.23773877f, 
    -0.02643214f, 0.00668661f, 0.09218684f, -0.02950709f, -0.00026008f, 0.13684049f, 0.12441508f, -0.05331518f, 
    0.30541009f, 0.13521801f, 0.01593599f, -0.04864521f, 0.05195229f, -0.06705534f, -0.06507598f, -0.11058387f, 
    -0.03622333f, -0.10056782f, 0.00886577f, 0.16543815f, 0.08772758f, 0.11185952f, 0.12000615f, -0.03169808f, 
    0.00779174f, 0.04638025f, -0.01220055f, 0.13523991f, 0.01633035f, 0.01358508f, 0.00801599f, 0.08303072f, 
    0.00478609f, 0.14884149f, -0.02564109f, -0.09185598f, -0.02704171f, 0.07958179f, -0.05000940f, 0.00758510f, 
    -0.07269809f, 0.01642964f, -0.01599141f, 0.01466584f, 0.13874735f, 0.15584451f, 0.15039745f, -0.05567481f, 
    0.03479698f, -0.00868463f, 0.07147679f, 0.07032392f, 0.06064768f, -0.04079219f, 0.02157434f, -0.00517034f, 
    0.08355821f, -0.07520483f, 0.13837914f, -0.03593409f, -0.04139647f, 0.02227738f, -0.01008013f, -0.01595578f, 
    -0.01497485f, -0.05289473f, 0.08940185f, 0.01111969f, -0.26984572f, -0.02887065f, 0.04417998f, -0.14300431f, 
    0.07526335f, 0.06422695f, -0.06702716f, 0.06863952f, 0.03831643f, 0.01580788f, 0.08203492f, -0.00894937f, 
    -0.06757431f, 0.05614845f, 0.03047628f, 0.04624552f, 0.00808158f, 0.02372039f, -0.06914029f, 0.01547537f, 
    -0.03957771f, -0.04941630f, 0.02045495f, -0.05906842f, -0.01254258f, -0.03988578f, -0.04808626f, 0.05885128f, 
    0.03184638f, -0.01926967f, -0.02310568f, 0.04866741f, -0.00568260f, 0.02932767f, -0.01556865f, 0.01754127f, 
    -0.06294908f, -0.04527296f, -0.00697812f, 0.00854566f, -0.06761191f, 0.04069788f, -0.02766892f, 0.04819602f, 
    0.00145038f, 0.04994443f, 0.02225656f, 0.05579898f, 0.03073303f, -0.00095885f, -0.06097442f, -0.02193476f, 
    0.06884634f, -0.04360413f, 0.01214914f, 0.01495043f, -0.01563444f, 0.01732320f, -0.07178479f, 0.01533592f, 
    -0.00460645f, -0.06691258f, 0.02594706f, -0.06827818f, 0.03913250f, -0.01301743f, -0.02137660f, 0.04217412f, 
    0.04497670f, 0.03583831f, -0.05067815f, -0.01848242f, 0.05838106f, -0.05524450f, 0.01101849f, 0.03678485f, 
    0.02125043f, -0.03461038f, -0.02017026f, -0.04241751f, 0.00808047f, 0.05518892f, 0.04097381f, -0.06324391f, 
    0.02136011f, 0.03141958f, -0.05391688f, -0.02306767f, 0.00356877f, 0.01852157f, -0.01064743f, -0.01225786f, 
    -0.00904208f, -0.04744808f, 0.05652627f, 0.03704689f, 0.00978798f, 0.05945048f, 0.05912140f, -0.03744889f, 
    -0.03339132f, -0.02273580f, 0.00778928f, -0.06486123f, -0.04556419f, 0.03705686f, -0.02578401f, 0.06236621f, 
    -0.01281717f, 0.02094526f, -0.01591064f, 0.01234524f, -0.06190206f, -0.02809137f, -0.05800449f, -0.01355577f, 
    -0.03293395f, 0.06578506f, 0.01604441f, -0.05413854f, -0.05311581f, -0.05286990f, 0.06902720f, -0.01943571f, 
    -0.01625044f, 0.06992817f, -0.06656162f, 0.01942324f, 0.02833520f, -0.02033705f, -0.00774795f, 0.02223579f, 
    0.06194016f, 0.01336376f, -0.03670412f, -0.06706457f, -0.05552798f, 0.01537452f, 0.05241890f, -0.03496762f, 
    0.03861737f, 0.05900637f, -0.05970898f, -0.02305909f, -0.01571798f, -0.06352395f, -0.06851941f, 0.05200065f, 
    -0.02746276f, -0.06544041f, -0.05456559f, -0.00689343f, -0.03622971f, 0.00719038f, 0.00163301f, 0.05392342f, 
    -0.03487017f, -0.06368723f, -0.05501395f, 0.00563339f, 0.07053529f, -0.04114040f, -0.02128840f, -0.04926961f, 
    0.04487024f, -0.01529294f, 0.00807924f, -0.03046537f, -0.03623000f, -0.01835174f, 0.03938439f, -0.05933908f, 
    -0.03358363f, -0.03364258f, 0.04971564f, 0.03769264f, -0.06959907f, -0.02001129f, 0.03292654f, -0.04946265f, 
    0.06165728f, 0.06750983f, -0.01510894f, -0.06159581f, -0.03376142f, -0.05815198f, 0.00516129f, -0.02924849f, 
    -0.04738026f, -0.01357905f, 0.01471748f, 0.04358417f, -0.02751164f, 0.07053653f, -0.00419036f, -0.00756695f, 
    -0.03964566f, -0.05833996f, 0.02862429f, -0.00206910f, -0.06381113f, -0.06912362f, -0.01528585f, -0.00282341f, 
    -0.14855684f, -0.00543456f, -0.11269730f, -0.06947682f, -0.04687838f, -0.05385019f, 0.00730832f, 0.04298498f, 
    -0.06145249f, -0.03501561f, 0.00917484f, 0.12648582f, -0.10752114f, -0.06069276f, 0.30876836f, -0.07617516f, 
    0.03937485f, 0.05337748f, 0.11707283f, 0.06659433f, -0.14723292f, 0.04542588f, -0.05562901f, -0.06651821f, 
    0.09391455f, 0.00475456f, -0.00474668f, -0.00509007f, 0.02130365f, -0.01073331f, 0.13919565f, -0.01193429f, 
    0.08121550f, -0.05427073f, -0.01028711f, 0.02519527f, 0.01745913f, -0.22074847f, 0.05256223f, 0.11123814f, 
    0.00060389f, 0.09063876f, -0.07662744f, 0.03987025f, 0.13719222f, 0.14419520f, 0.18292932f, 0.02025233f, 
    -0.08168039f, 0.13639954f, -0.17436333f, 0.24539492f, -0.21818778f, 0.03702392f, 0.01848765f, 0.07769775f, 
    0.09203201f, 0.08772848f, 0.00960233f, -0.15019487f, -0.26286161f, 0.09811649f, -0.06549522f, -0.13566771f, 
    -0.10927445f, 0.19166242f, 0.07648166f, -0.06009118f, -0.01248948f, -0.09642573f, -0.01545351f, -0.13225734f, 
    0.39762557f, 0.22352965f, 0.09693327f, -0.00456829f, 0.09755742f, -0.07537109f, 0.11301944f, 0.03608745f, 
    -0.02536783f, -0.04461662f, -0.04795427f, 0.03071820f, 0.23820849f, -0.11036480f, -0.16741097f, 0.31093472f, 
    -0.02027288f, 0.01122515f, -0.05012408f, 0.04255251f, -0.08216710f, 0.05708223f, -0.09241686f, 0.04775911f, 
    0.03724931f, -0.10632563f, 0.06076875f, -0.09283367f, -0.03190828f, -0.01191719f, 0.07272243f, -0.08763164f, 
    -0.12553222f, -0.09757149f, 0.00926908f, -0.10664874f, -0.21679683f, 0.24266137f, -0.04118281f, -0.07027997f, 
    0.11652603f, 0.08055910f, 0.05071180f, 0.14401323f, -0.04910238f, 0.02051923f, 0.00743213f, -0.03019942f, 
    -0.28028578f, -0.15819931f, 0.19812942f, -0.07619902f, 0.05867677f, -0.14974219f, 0.05948823f, 0.04509268f, 
    -0.07251272f, -0.03735489f, 0.10934117f, -0.00221811f, -0.36186904f, 0.11921004f, 0.14999050f, 0.18579003f, 
    -0.00839569f, 0.07676154f, 0.01002292f, -0.03121063f, 0.02774226f, -0.06905477f, -0.11183942f, 0.12716119f, 
    0.32779077f, -0.14297798f, 0.18413854f, -0.27339539f, 0.05979758f, -0.00890717f, 0.00155198f, -0.08081134f, 
    0.00580171f, -0.08148841f, -0.02193191f, 0.17665201f, 0.13409993f, -0.08584230f, 0.01628971f, 0.24841519f, 
    -0.16700947f, 0.04808774f, 0.01236807f, 0.12003088f, -0.11705418f, -0.01151257f, 0.12299107f, 0.08140150f, 
    -0.24526270f, -0.03685524f, 0.15464775f, 0.11680160f, 0.00767145f, 0.03920393f, -0.11153022f, -0.02429153f, 
    0.01511397f, 0.07126231f, -0.00319564f, 0.00125413f, 0.15923239f, 0.06125564f, -0.17136383f, 0.03838102f, 
    0.01196255f, 0.01507157f, 0.03050371f, 0.16035950f, -0.09812905f, -0.02743755f, -0.02874722f, 0.03717981f, 
    0.11632662f, -0.09939557f, -0.14781369f, -0.08181330f, -0.02032713f, -0.00122506f, 0.04016176f, 0.02797510f, 
    0.03985342f, -0.17236361f, 0.08925930f, -0.05809676f, 0.17349164f, -0.01673247f, -0.02976665f, 0.10261992f, 
    0.02105485f, 0.14367889f, -0.03545161f, 0.02228510f, -0.08524387f, 0.01259782f, -0.12889370f, -0.16375299f, 
    0.28300041f, 0.02769663f, -0.05811536f, 0.06278077f, 0.00964717f, -0.10261463f, 0.11857256f, -0.00909853f, 
    0.11778900f, 0.00704263f, 0.11321030f, -0.13737124f, -0.11103858f, -0.16680427f, 0.12893401f, 0.17266636f, 
    -0.17422968f, 0.03987239f, -0.04428281f, 0.03282188f, 0.00987873f, 0.06747425f, 0.10781514f, 0.00908903f, 
    0.00690694f, -0.15053615f, -0.10110467f, 0.14558399f, -0.05173615f, 0.00189304f, -0.12363999f, 0.00821225f, 
    0.03117989f, 0.08685669f, 0.17953968f, -0.07490811f, -0.01752177f, -0.13171294f, -0.03114806f, -0.10336497f, 
    0.01542989f, 0.16388112f, -0.07346555f, 0.02278955f, -0.02923366f, -0.04712103f, 0.02440592f, 0.02799362f, 
    0.38595083f, 0.18886320f, 0.07180978f, -0.00129949f, 0.04525077f, -0.03976245f, 0.14781900f, -0.06935798f, 
    -0.06078578f, -0.08625507f, -0.05410064f, -0.05362361f, 0.20835891f, -0.01119272f, -0.17029738f, 0.01882069f, 
    -0.01816496f, -0.22875866f, -0.15459457f, -0.02493237f, 0.06775996f, 0.17823684f, 0.02456274f, 0.13994890f, 
    0.14600539f, 0.10637081f, 0.11513497f, -0.02102429f, 0.03215194f, 0.04537905f, -0.01083169f, -0.00776293f, 
    -0.04099876f, -0.13407083f, -0.00667267f, 0.03435039f, -0.05927429f, 0.09083792f, -0.00882801f, 0.26384646f, 
    0.05564447f, 0.07028264f, 0.05646660f, 0.14400406f, 0.05311963f, 0.03134413f, 0.06407280f, -0.00887267f, 
    -0.14786832f, -0.12561542f, 0.09819438f, -0.22047415f, 0.09937360f, -0.21585219f, -0.16958074f, -0.00283227f, 
    0.01593985f, 0.03305086f, -0.02528630f, -0.00529176f, 0.08822551f, 0.26398677f, -0.02149324f, 0.16389142f, 
    0.19386494f, -0.05865156f, 0.00054484f, -0.09710845f, 0.07466190f, 0.01892239f, -0.00120965f, -0.00256767f, 
    0.25043330f, 0.05621490f, 0.01021385f, -0.00049243f, 0.05880893f, -0.02204847f, -0.01158327f, -0.06328660f, 
    -0.06116799f, -0.09709954f, 0.00404683f, 0.06752592f, -0.23124534f, 0.03293008f, -0.14920044f, -0.21812777f, 
    0.03507674f, -0.03072904f, -0.05527566f, -0.01528392f, -0.03282746f, 0.20742700f, 0.05908088f, -0.01003921f, 
    -0.28107437f, -0.11438701f, -0.04244403f, -0.21234442f, 0.26316789f, -0.08948401f, -0.16934161f, -0.01919793f, 
    -0.00232133f, 0.05162745f, 0.13849922f, -0.07851755f, -0.01378944f, 0.05240826f, -0.04358563f, -0.02887816f, 
    -0.02346385f, 0.10393438f, 0.00116606f, 0.15103558f, 0.04944343f, 0.07991935f, -0.02620150f, 0.03217712f, 
    0.22609857f, -0.17980024f, -0.21249367f, -0.21118318f, 0.02265595f, 0.01035626f, 0.02341159f, 0.03898481f, 
    -0.03172809f, 0.03831369f, 0.02087891f, 0.02593847f, -0.16549216f, 0.11941230f, -0.15463054f, -0.13482785f, 
    0.05567086f, -0.14153558f, 0.10577256f, -0.10381367f, 0.09602154f, -0.00751828f, 0.05486229f, -0.04897261f, 
    0.24241625f, -0.19090357f, 0.03494917f, 0.03761867f, -0.22595590f, -0.04772472f, -0.11082995f, 0.03958659f, 
    0.19062643f, -0.06129907f, 0.04454113f, -0.08144534f, -0.22632276f, -0.14525430f, -0.07275129f, -0.18696062f, 
    0.04249157f, 0.08347237f, 0.20786460f, -0.07584996f, -0.05452887f, -0.01962573f, 0.07258295f, 0.05723637f, 
    0.14440846f, -0.01818297f, -0.01497942f, 0.06302295f, -0.01678018f, -0.07381988f, -0.21258770f, -0.05103870f, 
    -0.01726388f, 0.13643767f, 0.04339483f, 0.01005851f, 0.34097517f, -0.09094753f, -0.20917505f, -0.06674189f, 
    0.02613015f, 0.07178789f, 0.04385758f, -0.10638919f, 0.06774020f, 0.08545353f, 0.06040855f, 0.08485543f, 
    0.20057583f, 0.02760572f, 0.16728097f, 0.02579119f, -0.10749214f, -0.11576977f, 0.01889108f, 0.12467906f, 
    -0.06226119f, 0.00794068f, 0.00342937f, -0.07220884f, -0.17852862f, 0.16126914f, -0.01206632f, -0.12358762f, 
    0.02002602f, 0.01938879f, -0.05529232f, -0.00495078f, 0.04085129f, 0.05560549f, 0.07293930f, 0.03830256f, 
    -0.43642518f, 0.30878666f, 0.09134895f, 0.01104776f, 0.03695671f, -0.08337503f, -0.02513853f, 0.20102154f, 
    0.16939016f, 0.04727808f, -0.08548587f, -0.01638378f, 0.21265721f, -0.01392896f, -0.17754197f, -0.17307879f, 
    -0.07502892f, -0.02616094f, 0.02890220f, -0.04411648f, 0.03760158f, -0.01332754f, -0.07281711f, 0.00618498f, 
    -0.09457441f, -0.01054619f, 0.07964686f, -0.08465271f, 0.20614450f, 0.11587451f, 0.01595714f, -0.03026601f, 
    0.00379204f, 0.05898524f, 0.02206157f, -0.07826379f, -0.09066289f, 0.17881848f, -0.02478701f, -0.10594747f, 
    0.03772711f, 0.17519814f, 0.11388723f, 0.01140706f, 0.05760541f, 0.15895972f, 0.05593485f, 0.10121299f, 
    -0.06554182f, 0.23472790f, -0.01415595f, 0.17887883f, -0.01136708f, -0.01140088f, -0.08151312f, 0.09560686f, 
    0.05613152f, 0.09228516f, 0.06277033f, 0.08094288f, -0.17652738f, 0.08359322f, 0.03436301f, -0.05466215f, 
    0.18357043f, 0.15788487f, 0.01739206f, -0.06809653f, 0.07546356f, -0.01105690f, 0.10165887f, -0.09239081f, 
    0.12457682f, 0.10317431f, 0.10293673f, -0.07379855f, 0.28025076f, 0.01398986f, -0.04891820f, 0.01583579f, 
    0.13373297f, 0.04038676f, 0.10059359f, -0.02549063f, 0.24448177f, -0.05459746f, -0.17876165f, -0.10510023f, 
    -0.04198066f, 0.10190980f, -0.13023144f, -0.03669299f, -0.00296330f, 0.01073725f, 0.00339273f, -0.02448804f, 
    0.09023561f, -0.06244947f, -0.07434358f, 0.00854875f, -0.09612259f, 0.06942306f, -0.02899193f, -0.04274153f, 
    0.02025559f, -0.07180487f, -0.05746921f, -0.13281767f, -0.15985046f, -0.25557819f, 0.00131427f, -0.01291099f, 
    -0.26912320f, 0.03669826f, -0.15209934f, 0.03278489f, -0.00759211f, -0.05006580f, -0.09668634f, -0.21450940f, 
    -0.01300297f, 0.09577396f, -0.10407770f, 0.10251207f, -0.10399912f, -0.04566456f, 0.11839068f, -0.03929720f, 
    -0.04456712f, 0.09737871f, 0.15015101f, -0.08177549f, 0.13538732f, -0.10773965f, -0.04111879f, 0.22237663f, 
    0.08702002f, 0.01004003f, 0.03936396f, 0.11495489f, -0.14714193f, -0.06302420f, 0.01858147f, 0.02917796f, 
    -0.09225103f, 0.11488639f, -0.11044995f, 0.05717104f, 0.02158751f, 0.09083856f, 0.12527241f, -0.04307461f, 
    0.00562938f, -0.07218465f, 0.04049834f, -0.06478236f, 0.31454700f, -0.07369328f, 0.14139010f, -0.00872500f, 
    -0.03685751f, -0.00272206f, -0.07907506f, 0.03760150f, -0.05647320f, 0.05977400f, 0.10306679f, -0.04764591f, 
    0.06461429f, -0.03451507f, 0.10886682f, -0.14098400f, 0.06837180f, -0.04103310f, 0.16243081f, -0.03938426f, 
    0.05664644f, -0.17596550f, -0.08064754f, 0.14593667f, 0.09015126f, -0.01024522f, -0.21061993f, 0.25670534f, 
    0.03860117f, 0.07531995f, 0.01127588f, 0.00993599f, -0.03335038f, -0.04285880f, -0.02674039f, 0.14043695f, 
    0.25999540f, 0.07526245f, 0.11103137f, -0.04724939f, -0.05103089f, -0.04423120f, -0.09085418f, -0.04213301f, 
    -0.16658817f, -0.08021586f, 0.01910717f, 0.11364552f, -0.08570826f, -0.04927942f, 0.20291921f, 0.23932390f, 
    -0.06056711f, 0.01155764f, 0.00338862f, -0.06428201f, 0.05773321f, -0.01878098f, 0.14412460f, 0.05309521f, 
    0.14908719f, 0.21964727f, -0.00500898f, -0.17867045f, 0.02557818f, 0.05021442f, 0.03082030f, 0.13593958f, 
    0.03394582f, -0.00835930f, -0.08392918f, 0.01721268f, 0.32100055f, 0.17332710f, 0.07073736f, -0.14950410f, 
    0.16194628f, 0.03046863f, 0.05357534f, -0.05347189f, -0.12569064f, -0.07973127f, 0.02707804f, 0.10130049f, 
    0.16355881f, 0.17186192f, -0.06519756f, -0.00391745f, -0.00474479f, -0.21613242f, 0.10370361f, 0.05912594f, 
    -0.16048461f, 0.00027878f, -0.05400373f, 0.07399956f, -0.01902886f, 0.00580020f, -0.24365215f, -0.08479487f, 
    0.16442327f, 0.01221570f, -0.06734990f, 0.04014145f, 0.01747680f, 0.20533706f, -0.03416048f, -0.04485675f, 
    0.19077207f, -0.05887174f, -0.12895283f, -0.06961657f, 0.07940093f, 0.01893986f, 0.07448786f, 0.10515703f, 
    0.05865519f, 0.12459463f, 0.03166011f, 0.04582147f, -0.22355326f, 0.00159704f, -0.10679131f, 0.04232302f, 
    -0.13523643f, -0.07471880f, 0.05840085f, 0.14546244f, 0.06113726f, 0.07142381f, 0.00240069f, 0.03305327f, 
    -0.07591349f, 0.04368307f, 0.05478814f, -0.06631836f, -0.01690702f, -0.04677010f, 0.00419765f, -0.03534725f, 
    -0.04045976f, 0.06011395f, -0.02905834f, 0.03356445f, 0.05482759f, -0.05257845f, 0.03065854f, -0.05679602f, 
    -0.04735681f, 0.06415396f, -0.02423662f, -0.01197275f, -0.02811292f, 0.03042688f, -0.00797350f, -0.07024650f, 
    0.02377858f, -0.02325445f, 0.02965072f, 0.00873245f, 0.00449895f, -0.03270838f, -0.03232257f, -0.05964284f, 
    -0.05595962f, -0.07068723f, -0.04270218f, -0.05276667f, -0.00009336f, -0.00056629f, 0.04330976f, -0.04754075f, 
    -0.03446197f, 0.06571322f, -0.00533372f, -0.04340395f, -0.03653746f, -0.02523154f, -0.03545671f, -0.05038546f, 
    -0.04098880f, -0.00116327f, -0.06418952f, 0.03369762f, -0.06878955f, -0.01199971f, 0.03448664f, -0.02245943f, 
    -0.05133256f, 0.06129247f, -0.02933363f, -0.04300771f, -0.07035948f, -0.05348373f, -0.01299811f, -0.00188306f, 
    -0.03655427f, -0.05591400f, -0.01563214f, 0.06091711f, -0.05012013f, 0.05569533f, 0.05161897f, 0.00661068f, 
    -0.03568223f, 0.03571919f, -0.05999360f, -0.00304633f, 0.05749861f, -0.02720189f, 0.03097354f, -0.06656645f, 
    0.00067484f, -0.06979256f, 0.04965901f, 0.05769657f, 0.03898467f, -0.04804799f, 0.01101845f, 0.04991209f, 
    -0.05480603f, -0.05081229f, -0.01131741f, -0.05096233f, 0.01055056f, -0.01976555f, 0.04327985f, 0.02650064f, 
    0.02034265f, -0.04271167f, -0.02091450f, -0.01068018f, 0.02052327f, -0.07549812f, -0.02791966f, -0.03047197f, 
    -0.03908039f, 0.02711927f, 0.01142727f, -0.05507680f, 0.02160277f, 0.05674189f, -0.07054605f, -0.04863741f, 
    -0.05950416f, 0.00775476f, 0.00240500f, -0.03365482f, -0.03153465f, 0.05485805f, -0.02833222f, 0.04566486f, 
    0.02278925f, -0.01267762f, -0.01596605f, 0.00210367f, -0.06290559f, -0.05898952f, 0.06277021f, -0.01739569f, 
    -0.05510693f, -0.07056077f, 0.04838400f, -0.05866598f, 0.00485865f, -0.02602398f, 0.05382632f, 0.02435174f, 
    -0.04855985f, 0.02204751f, 0.00227499f, -0.06849568f, 0.02309951f, -0.05259841f, -0.07210492f, 0.04792365f, 
    0.03528932f, -0.02668430f, 0.00226851f, 0.01741904f, 0.03974817f, 0.06149681f, 0.02806802f, 0.05763300f, 
    0.03706195f, -0.05814813f, -0.03523029f, 0.03610466f, -0.04791022f, 0.03069506f, 0.00691871f, 0.02293484f, 
    -0.05740479f, -0.04646537f, 0.02923336f, 0.04164458f, -0.05806824f, 0.01646763f, -0.03329203f, -0.04510562f, 
    0.04839619f, -0.02269851f, -0.00969518f, -0.07439200f, -0.06367965f, -0.06103696f, -0.04417603f, -0.03829388f, 
    -0.00773406f, 0.00757176f, 0.03868845f, 0.00414971f, 0.00185343f, -0.06639117f, 0.05376998f, 0.04867466f, 
    -0.04320791f, 0.01421099f, 0.04367219f, 0.00294642f, 0.00368894f, -0.02629644f, 0.03579114f, -0.06348771f, 
    -0.17762917f, 0.21980630f, 0.19462521f, 0.06329190f, -0.05583157f, -0.13125351f, -0.00368320f, -0.10338952f, 
    -0.08090604f, -0.11009380f, -0.05097314f, -0.01018798f, 0.28889677f, -0.17391847f, 0.04308257f, 0.08698808f, 
    0.12452589f, -0.06245701f, 0.18511930f, 0.02063350f, 0.08709262f, 0.14180635f, 0.01399389f, 0.12481634f, 
    -0.00039950f, -0.09859141f, 0.01408621f, -0.02657244f, 0.05328145f, -0.06479321f, -0.02217206f, -0.03696374f, 
    0.01593287f, 0.05090104f, 0.07224366f, 0.05203125f, -0.00715394f, -0.05022817f, 0.24070299f, -0.06269702f, 
    0.04816518f, -0.00210447f, 0.05468789f, 0.07655098f, 0.11096086f, -0.03049594f, -0.18071514f, -0.09501962f, 
    -0.19813669f, -0.07184835f, -0.09460138f, -0.12977061f, -0.08483513f, 0.10832433f, -0.03439638f, 0.04910356f, 
    0.13833413f, 0.03412445f, -0.12747274f, 0.07694577f, -0.42434001f, 0.47226661f, -0.06918389f, -0.02070840f, 
    0.01343503f, 0.02958870f, 0.08339094f, 0.13276118f, -0.03605213f, -0.03211796f, 0.10019010f, -0.05109566f, 
    0.06567676f, 0.06269807f, -0.10192489f, 0.06591908f, -0.01555946f, -0.07022072f, 0.08083738f, 0.07621121f, 
    -0.00832892f, 0.02806274f, 0.09730842f, 0.04685382f, -0.09538365f, -0.05625047f, 0.04602304f, 0.28815329f, 
    0.13578248f, 0.10238722f, 0.09693608f, 0.05322940f, 0.06084335f, -0.10304660f, -0.03137338f, -0.10482696f, 
    -0.13914080f, -0.30240920f, -0.14377305f, -0.01120046f, 0.12002435f, -0.05093698f, 0.25202188f, -0.10473270f, 
    0.04998399f, 0.07549814f, 0.12339511f, -0.00880299f, 0.01337193f, 0.04398565f, -0.02961722f, -0.07088700f, 
    -0.08205877f, -0.00584070f, -0.11086893f, -0.02748406f, -0.00298286f, 0.05423343f, -0.14741611f, -0.10053685f, 
    0.15401843f, -0.00077712f, 0.06273253f, 0.12151781f, -0.04875090f, 0.08370510f, 0.05647496f, -0.09156518f, 
    0.16284427f, 0.08709557f, -0.02973364f, -0.01203538f, 0.03664860f, -0.27160925f, 0.05828970f, 0.22780307f, 
    -0.03108425f, 0.05792589f, 0.08943064f, -0.04346721f, 0.18848622f, -0.00153348f, -0.04324234f, 0.01444993f, 
    -0.04368581f, -0.09632580f, -0.00625433f, -0.04769316f, -0.03124052f, -0.01086381f, 0.05341950f, 0.04803725f, 
    0.01701916f, 0.00830123f, 0.02107842f, -0.01726888f, 0.28043258f, -0.03195821f, 0.09827566f, 0.26231647f, 
    -0.14862849f, 0.09531941f, 0.02994015f, 0.05047393f, 0.06310896f, 0.02671581f, 0.00925815f, 0.09350573f, 
    -0.07082564f, -0.10399681f, -0.00144078f, 0.14324576f, -0.17631279f, -0.16092812f, 0.00814935f, 0.03901853f, 
    0.01105075f, 0.04311046f, -0.04504228f, 0.00371636f, -0.20085956f, 0.37834322f, 0.06512035f, -0.04807480f, 
    -0.02063738f, 0.02932988f, 0.01630036f, -0.06246248f, 0.05684963f, -0.05150392f, -0.01201817f, 0.04859598f, 
    0.03010549f, 0.01854382f, -0.00181583f, 0.04919934f, 0.06476729f, 0.04900960f, -0.03861013f, -0.05455915f, 
    -0.06239467f, 0.05844015f, 0.03325922f, 0.05188711f, -0.05221400f, -0.06355647f, -0.05654151f, 0.05250938f, 
    -0.03930246f, 0.01493734f, -0.07147212f, -0.02460865f, -0.05843179f, 0.03223149f, -0.05828858f, -0.06379583f, 
    -0.01841179f, -0.05724738f, 0.00629436f, -0.06089336f, -0.02802093f, -0.06583743f, -0.04381412f, -0.03724469f, 
    -0.05727251f, -0.01138176f, 0.01466110f, 0.03533882f, -0.06323511f, -0.06725230f, -0.05113957f, 0.00256976f, 
    -0.00128315f, -0.04750705f, 0.05449116f, -0.07441243f, -0.01298773f, 0.05361271f, -0.03076550f, 0.02847542f, 
    -0.06832470f, -0.00459539f, -0.04499573f, 0.06515697f, -0.04105525f, -0.02577974f, -0.05922399f, -0.05091901f, 
    0.02282627f, 0.00894221f, -0.01612715f, 0.03431601f, -0.05720753f, -0.02539328f, -0.00793583f, 0.02972268f, 
    -0.00195611f, -0.04205132f, -0.02122395f, -0.01978047f, 0.01947253f, -0.02933284f, -0.05154515f, -0.05082093f, 
    0.00648462f, -0.04092159f, 0.03887720f, 0.01307670f, 0.01110505f, -0.00764967f, -0.04784870f, -0.02600810f, 
    0.02201130f, -0.02333888f, 0.03905690f, -0.02313701f, -0.00357724f, 0.06631476f, 0.04104117f, -0.04760623f, 
    0.00836526f, -0.02322449f, -0.01422607f, 0.03890867f, 0.01895095f, -0.06723423f, 0.00631104f, 0.06255922f, 
    -0.01230871f, -0.05220546f, 0.03923937f, 0.04617669f, -0.03199883f, -0.05020996f, -0.00297846f, 0.01281848f, 
    -0.07675022f, -0.02427967f, -0.03281999f, -0.01561325f, -0.07110173f, -0.02440325f, -0.03229581f, -0.00890043f, 
    0.06319268f, 0.04248138f, -0.03143457f, -0.02781522f, 0.05328732f, -0.01221455f, 0.01759420f, 0.03583403f, 
    -0.00578836f, -0.05553452f, -0.07559528f, -0.07451138f, 0.03889971f, 0.04400769f, -0.07624516f, 0.01664685f, 
    -0.07717919f, 0.00025673f, -0.07502894f, 0.06645887f, 0.01193610f, 0.01795855f, -0.04607493f, -0.07538915f, 
    0.05914607f, -0.04549246f, -0.05440767f, -0.01471428f, 0.00842267f, 0.04811240f, 0.05605833f, -0.00872166f, 
    -0.01114599f, -0.06081898f, -0.03046529f, -0.07484621f, 0.02440173f, 0.00556956f, 0.00540605f, -0.06303400f, 
    -0.03648325f, -0.07578602f, -0.00856093f, 0.00962255f, 0.06343617f, -0.02694413f, -0.07008322f, -0.06172835f, 
    -0.04177466f, 0.06629773f, -0.02418059f, -0.07496585f, -0.02177456f, -0.00688023f, 0.00573172f, -0.04055157f, 
    0.02168358f, 0.06650787f, -0.01281941f, -0.05330157f, -0.06353617f, -0.01064955f, 0.03195981f, 0.03558567f, 
    -0.00071232f, -0.07645711f, -0.04527070f, 0.05622105f, 0.02846732f, 0.06435928f, -0.05758280f, 0.03043866f, 
    -0.00886477f, -0.03161096f, -0.03768765f, -0.02274087f, -0.00319330f, 0.00291451f, 0.06556960f, 0.05325652f, 
    0.09270197f, 0.13183627f, 0.06634087f, 0.06255974f, -0.04733348f, -0.04839053f, 0.07732856f, 0.08195179f, 
    0.04576220f, -0.06827373f, 0.09370863f, 0.02004311f, 0.29293302f, 0.08082123f, 0.09789781f, 0.05402324f, 
    0.10269841f, 0.12782635f, 0.01212741f, -0.01823502f, 0.00601761f, 0.02534520f, -0.02752602f, -0.07748042f, 
    0.06514689f, 0.04119037f, -0.00357028f, 0.09097776f, -0.10551351f, -0.05638305f, 0.00543761f, 0.08594350f, 
    0.05612492f, -0.00782490f, 0.00384090f, -0.10725087f, -0.24621044f, -0.13753153f, 0.12956208f, 0.20288940f, 
    0.05260251f, -0.00845065f, 0.02457292f, 0.07069302f, 0.03826755f, 0.06706095f, 0.05445001f, -0.08732758f, 
    -0.00074408f, -0.08465020f, -0.10178033f, -0.32341701f, 0.12766689f, 0.02911588f, -0.04207635f, 0.00905098f, 
    -0.00218111f, -0.07652128f, 0.02617701f, 0.09002449f, -0.23642489f, 0.05557913f, 0.05354415f, -0.07239161f, 
    0.08064282f, -0.05032836f, 0.03438461f, -0.05591061f, 0.07376144f, 0.04295209f, -0.05781180f, 0.14780809f, 
    0.04837165f, 0.02087749f, 0.07777990f, 0.10905752f, -0.18932465f, -0.05415595f, 0.16654956f, 0.12686719f, 
    -0.06149289f, 0.03394517f, 0.05525137f, 0.03252599f, -0.10260663f, 0.12990694f, 0.10041326f, -0.12270813f, 
    0.11219016f, 0.05389895f, 0.04344702f, -0.00550449f, 0.05922358f, 0.01212493f, 0.06937974f, 0.10738590f, 
    -0.07479154f, 0.02427698f, -0.02929320f, 0.19144690f, 0.11298472f, 0.16531557f, -0.05689807f, 0.04489908f, 
    0.02149572f, -0.01153602f, -0.15227857f, -0.00717545f, -0.02659708f, 0.00861881f, 0.12802228f, -0.10548250f, 
    -0.01267146f, 0.06051728f, 0.00405514f, 0.05081963f, 0.07773037f, 0.05494916f, 0.03975673f, 0.02128770f, 
    -0.44721955f, -0.39259657f, 0.08659024f, -0.10773227f, 0.06304209f, 0.01298793f, -0.13606693f, -0.02987955f, 
    -0.04797384f, 0.17942996f, -0.03263976f, 0.09367473f, 0.05014061f, -0.26646608f, 0.15444112f, -0.00154928f, 
    0.09503094f, 0.04732782f, 0.09101444f, -0.12202247f, 0.03779136f, 0.07995466f, -0.03641411f, 0.03704649f, 
    -0.11367521f, 0.12521344f, -0.04172155f, 0.22531578f, -0.11106682f, 0.04612237f, 0.00422350f, 0.02496428f, 
    -0.06689828f, 0.03140619f, 0.02450904f, 0.06387318f, -0.44211498f, -0.14912648f, -0.18994202f, -0.07972643f, 
    0.05924016f, -0.02262598f, -0.06661474f, -0.07345607f, 0.08070952f, -0.05108497f, -0.05816961f, 0.14238198f, 
    -0.45182583f, -0.14733154f, -0.19963312f, -0.34602574f, 0.16226928f, -0.06378548f, -0.05612012f, -0.01857149f, 
    0.00016184f, 0.00876151f, 0.01572299f, 0.04436507f, 0.26517066f, 0.21695815f, 0.15738329f, -0.12232840f, 
    0.13563862f, 0.07407555f, 0.20499051f, -0.03065318f, 0.16403875f, -0.01207998f, 0.05628584f, -0.00744523f, 
    0.14958970f, -0.12056038f, -0.08122937f, 0.11036382f, 0.04068946f, 0.06731336f, 0.10616215f, 0.07506959f, 
    -0.07765200f, 0.14013690f, 0.05226410f, 0.07881443f, -0.10422288f, 0.10323012f, -0.07684980f, 0.00627668f, 
    -0.03236786f, 0.01322396f, -0.00456339f, -0.08137897f, 0.04400552f, -0.11405012f, 0.05767383f, -0.05638972f, 
    -0.06835465f, 0.00484130f, -0.05107310f, -0.10549005f, -0.02359185f, -0.00379685f, -0.03899642f, -0.01962240f, 
    0.03158689f, -0.02661201f, 0.18141003f, 0.02325567f, -0.24535702f, -0.20301719f, -0.01255043f, 0.07937121f, 
    0.10485456f, -0.07665558f, -0.02021006f, -0.05281542f, -0.09186745f, 0.04740219f, 0.08964917f, -0.14468406f, 
    -0.02515670f, -0.11419331f, 0.10418481f, -0.30698037f, 0.12249576f, 0.05715888f, -0.22347927f, 0.13437341f, 
    -0.13497871f, 0.00882003f, -0.03748406f, 0.12691449f, 0.12455476f, -0.09640873f, -0.10779456f, -0.00286349f, 
    0.03969388f, 0.03731241f, -0.03248886f, -0.02049020f, 0.11286103f, 0.16495809f, 0.05709466f, -0.01673952f, 
    -0.13616601f, 0.03048847f, -0.11171479f, 0.08445567f, -0.02203960f, 0.07278165f, -0.01591022f, 0.24948692f, 
    0.00844396f, -0.07037340f, 0.03267211f, -0.09149413f, 0.17133822f, 0.22138955f, 0.20984523f, -0.37828934f, 
    -0.03761047f, 0.11012834f, 0.00579356f, 0.05432872f, 0.03520382f, -0.01890428f, -0.00858210f, -0.01454380f, 
    -0.43043765f, 0.00850867f, 0.00480569f, 0.07711057f, 0.10114285f, -0.07423217f, 0.05432010f, 0.01822912f, 
    0.20342375f, 0.10464519f, -0.02397760f, 0.16501781f, 0.08807401f, -0.04966136f, -0.08170526f, -0.10190024f, 
    -0.04310629f, 0.14110491f, -0.02590744f, -0.06847716f, 0.08985584f, -0.00583045f, 0.09011690f, -0.08231700f, 
    -0.10158891f, 0.20642331f, 0.22572111f, -0.09828550f, 0.20454317f, 0.05497277f, -0.05689917f, -0.05880646f, 
    -0.00879837f, 0.11194181f, 0.00768348f, -0.07349223f, -0.31109199f, 0.34310484f, 0.05294744f, -0.02437994f, 
    0.17872904f, 0.00087949f, 0.03986182f, -0.00416241f, -0.02317203f, 0.01423912f, -0.04294571f, 0.06361720f, 
    -0.12784597f, 0.00998706f, 0.00445656f, 0.24887680f, -0.10424653f, -0.01087912f, 0.12179580f, 0.08193597f, 
    -0.01101172f, -0.04477634f, -0.01810271f, 0.00125797f, -0.23953621f, 0.23306020f, 0.15614727f, -0.39711893f, 
    0.19475038f, 0.06222550f, 0.07427326f, 0.03585171f, 0.03582104f, 0.16916239f, 0.05177487f, 0.03110830f, 
    -0.04753086f, 0.01191714f, 0.07479834f, -0.17518003f, 0.12553461f, 0.06713147f, 0.05547028f, -0.06333884f, 
    0.01951382f, -0.07699348f, 0.09313203f, 0.02592467f, 0.34843314f, -0.02749856f, -0.23105556f, 0.11020629f, 
    -0.04586514f, 0.10196517f, 0.05440000f, 0.09120421f, -0.00528675f, -0.02235610f, 0.01076988f, -0.03474511f, 
    0.06393494f, 0.01166518f, 0.06654416f, -0.03673195f, 0.02485741f, 0.02383815f, 0.02778070f, -0.06422580f, 
    -0.03603313f, 0.02811081f, -0.01853840f, 0.05161440f, 0.03378150f, -0.03731566f, -0.02055613f, -0.02027905f, 
    -0.04135373f, -0.05530080f, -0.06320105f, 0.04185812f, -0.05896650f, -0.05354421f, 0.06819574f, 0.01333405f, 
    -0.01916539f, -0.03243094f, 0.05224754f, 0.04864236f, 0.00961758f, 0.01854027f, -0.05302653f, -0.04267615f, 
    0.02566596f, -0.02187664f, 0.04967469f, -0.02620525f, 0.07167676f, 0.02437604f, 0.02462025f, -0.00670394f, 
    -0.02663436f, 0.01564118f, 0.04485504f, 0.03669455f, 0.05957855f, 0.03637373f, -0.06372528f, 0.07011925f, 
    -0.05056313f, -0.06031761f, -0.02092130f, -0.05732130f, -0.01200287f, 0.04689287f, 0.06570069f, 0.04359513f, 
    0.00115940f, 0.02610067f, 0.01132177f, -0.03614784f, -0.04884339f, -0.05878965f, 0.00757272f, -0.05376227f, 
    -0.00595398f, -0.03190034f, 0.03471954f, -0.06433591f, -0.06893925f, -0.00425671f, -0.01864322f, 0.00849325f, 
    0.00644941f, -0.01081150f, -0.06198435f, -0.06108278f, -0.02167583f, 0.05716292f, 0.01575610f, -0.03823590f, 
    -0.06895414f, 0.01394603f, 0.05589540f, -0.00070470f, -0.03370877f, -0.00415913f, 0.02097914f, 0.07069601f, 
    0.05021801f, 0.04581145f, -0.01799890f, -0.04498040f, -0.04764730f, -0.04483775f, 0.04023232f, -0.05665506f, 
    -0.06092445f, -0.03423895f, -0.06826600f, -0.00866559f, -0.03532058f, -0.06934955f, -0.02591699f, 0.04637731f, 
    -0.06304417f, -0.03981168f, -0.06649182f, -0.04947402f, -0.03984763f, -0.02110821f, 0.06176451f, 0.04076044f, 
    -0.06365321f, -0.05423124f, 0.03451963f, 0.03920354f, -0.03487236f, -0.04848466f, -0.06857050f, 0.03906336f, 
    -0.00544966f, -0.03000693f, -0.04226648f, -0.04293269f, 0.02397369f, -0.06120278f, 0.00907261f, -0.02923095f, 
    0.02207210f, -0.00117115f, -0.05739666f, 0.02798451f, 0.06639203f, 0.04170926f, 0.00057690f, 0.04997575f, 
    -0.05757393f, -0.01188303f, -0.03843204f, 0.01622117f, 0.00828536f, 0.04952006f, -0.02655622f, 0.00744423f, 
    0.02625833f, -0.03966148f, 0.06162188f, 0.04885397f, 0.00802102f, 0.05390620f, -0.00753099f, 0.01322313f, 
    -0.06894688f, -0.07072905f, -0.01221713f, 0.02746863f, 0.03216461f, -0.06210212f, -0.02541158f, 0.01566300f, 
    0.02107253f, -0.01088449f, -0.06847064f, -0.00595928f, -0.00549598f, -0.05501674f, 0.03832021f, -0.02199955f, 
    -0.07051183f, 0.03155591f, 0.00458561f, -0.06966455f, -0.01411827f, -0.06409848f, -0.06565369f, -0.04192047f, 
    -0.00033933f, 0.04592621f, -0.03891665f, -0.00142466f, 0.04728142f, 0.05134756f, 0.06634849f, -0.06647807f, 
    0.01446784f, -0.02564607f, -0.05837213f, -0.01305784f, -0.00822544f, 0.02121315f, -0.02874025f, 0.00961524f, 
    -0.01947005f, -0.14928326f, -0.03336156f, -0.05631578f, 0.00540277f, -0.02019881f, 0.01897998f, 0.05886327f, 
    0.10029332f, 0.12821689f, -0.02985724f, 0.16350012f, -0.10087543f, 0.14656223f, 0.04567428f, -0.02585521f, 
    0.01826807f, -0.07091565f, 0.09430268f, -0.00233911f, 0.07687948f, 0.07797216f, -0.07983643f, -0.01331705f, 
    0.15046348f, 0.00192034f, 0.10380233f, 0.16702245f, -0.20056251f, 0.08122338f, -0.07129575f, 0.15366054f, 
    0.07194530f, -0.10215177f, -0.32897666f, -0.03775278f, -0.17011844f, 0.15487316f, -0.11826268f, -0.05233869f, 
    -0.01614315f, 0.12481140f, 0.08063553f, 0.06064628f, 0.15227233f, -0.01435340f, 0.03269751f, 0.18356602f, 
    -0.00309092f, 0.01352445f, -0.07883722f, -0.08646096f, -0.08815244f, -0.04668892f, -0.00045513f, -0.00846986f, 
    0.02447913f, 0.12033969f, 0.12613405f, 0.00712202f, 0.27682105f, 0.02754323f, -0.29743266f, -0.04630695f, 
    0.04991881f, 0.06956726f, 0.08021296f, -0.14542447f, 0.10845099f, -0.00807664f, 0.03884659f, -0.03645523f, 
    0.04488065f, 0.13595256f, 0.20736085f, 0.15400724f, -0.07035239f, -0.06754430f, -0.10067295f, 0.11206094f, 
    -0.11338416f, 0.02916806f, 0.06840901f, -0.15092197f, -0.23143044f, -0.12608847f, -0.19415475f, -0.03501985f, 
    0.01057563f, -0.08538449f, -0.07165651f, 0.06975098f, -0.05437659f, 0.10771453f, 0.15952864f, 0.07600886f, 
    -0.22049597f, 0.24527951f, 0.22074512f, -0.13104959f, 0.10147106f, -0.09243096f, -0.03057598f, 0.10822861f, 
    0.11655394f, 0.03960397f, -0.17977215f, -0.05859948f, 0.27803531f, 0.05250484f, 0.01190974f, -0.03761739f, 
    -0.12504432f, 0.01493876f, 0.06612845f, 0.09316125f, 0.03193921f, -0.02732346f, -0.12851268f, 0.05253147f, 
    -0.16841954f, -0.23435074f, -0.22648057f, 0.06994697f, 0.10330243f, 0.04965316f, 0.11764268f, -0.06256358f, 
    -0.01072340f, 0.07388888f, 0.28078705f, -0.00859431f, -0.05937608f, 0.00796847f, -0.25670147f, -0.01284006f, 
    -0.12900557f, 0.03947523f, 0.03583766f, -0.04840675f, 0.04334087f, 0.05368640f, 0.12745254f, 0.08759140f, 
    -0.05313271f, 0.07792658f, 0.16683599f, 0.05897937f, -0.00669705f, 0.01793425f, -0.04955759f, -0.02670799f, 
    -0.05928079f, 0.06143183f, 0.04483493f, -0.00440348f, -0.07702159f, -0.17110290f, -0.01313443f, 0.20330788f, 
    0.13112442f, 0.05800009f, -0.00559903f, -0.04922876f, 0.10582453f, -0.08590179f, 0.10243978f, 0.05447429f, 
    0.08574621f, 0.18789956f, 0.18492025f, 0.07680973f, 0.09379209f, 0.06714239f, -0.02376201f, -0.05479126f, 
    0.05445184f, -0.03134125f, 0.12584186f, 0.16774099f, 0.27612484f, -0.07732618f, -0.01325302f, -0.14442344f, 
    0.10720296f, -0.08991449f, -0.05905775f, -0.05704800f, -0.04746940f, -0.07317141f, -0.00295136f, -0.00328647f, 
    -0.00740705f, -0.01971581f, -0.04848632f, -0.03922728f, 0.00112769f, 0.04704421f, 0.00343538f, 0.05477868f, 
    0.04747575f, -0.01314121f, -0.07302734f, -0.03739107f, -0.02336333f, -0.04001123f, -0.05610434f, -0.00340794f, 
    -0.07513741f, -0.04238427f, 0.04719638f, -0.06131806f, 0.03415454f, 0.02613224f, 0.01762419f, 0.05842712f, 
    0.03880219f, -0.00583528f, 0.01607908f, -0.06609908f, 0.02076955f, -0.05768813f, -0.02632718f, -0.04020894f, 
    0.04889744f, 0.03877200f, 0.00667337f, -0.02020326f, -0.03356990f, 0.02639537f, 0.04977820f, 0.07044949f, 
    -0.00872088f, -0.04659461f, 0.02476353f, 0.06278654f, -0.00750107f, 0.01365358f, 0.03439260f, 0.01463491f, 
    -0.02738177f, -0.04064677f, -0.00752250f, 0.03237834f, -0.03114724f, -0.03485761f, -0.00197870f, 0.01619578f, 
    0.07201669f, 0.01587919f, -0.03966862f, 0.01414560f, -0.03501021f, -0.01740522f, 0.05598646f, 0.06026009f, 
    -0.00103214f, -0.04466490f, 0.02404379f, -0.03151508f, -0.07348428f, 0.03696061f, -0.01828863f, -0.01762608f, 
    -0.04934841f, 0.02471284f, 0.05382333f, -0.06387933f, 0.01213139f, 0.02749299f, -0.02858463f, 0.02165523f, 
    0.04618038f, -0.07475407f, 0.05677353f, -0.01022680f, 0.01776023f, 0.02174816f, -0.01997642f, -0.01461541f, 
    -0.08312008f, -0.05728229f, -0.04346560f, -0.06672212f, 0.01808607f, 0.02402310f, -0.02272899f, 0.02667062f, 
    -0.03999992f, -0.06989338f, 0.03026021f, 0.00830925f, 0.04311203f, 0.02010196f, -0.06066444f, 0.05167466f, 
    -0.07010598f, -0.01854694f, -0.04054692f, -0.04271213f, -0.05429921f, -0.01671233f, -0.04521682f, -0.06217683f, 
    -0.05158637f, 0.01768580f, 0.04119421f, 0.01806111f, 0.00565315f, -0.00514919f, 0.03697309f, 0.06327610f, 
    -0.02670532f, 0.00077518f, 0.01703450f, 0.04893730f, 0.02407872f, 0.06379706f, -0.08468410f, -0.04693825f, 
    -0.01163784f, -0.06655764f, 0.00388452f, 0.02689424f, -0.05588381f, -0.01712479f, -0.02652021f, -0.00067584f, 
    -0.03471368f, 0.05692266f, -0.06362052f, -0.06934961f, -0.00673293f, -0.07219098f, -0.01177403f, -0.00977620f, 
    -0.00455359f, -0.03224321f, 0.04919234f, -0.06509592f, -0.04785378f, 0.00263502f, -0.05370016f, 0.02704222f, 
    0.01358808f, -0.03875969f, 0.00320929f, -0.00341075f, -0.01174299f, 0.05296693f, -0.05884390f, 0.03373942f, 
    -0.02790199f, 0.02714957f, 0.00212692f, -0.02499636f, -0.01728018f, -0.01749248f, 0.03637882f, 0.00759062f, 
    0.00746008f, -0.05399407f, 0.00882526f, -0.04832272f, -0.04346634f, -0.07802793f, 0.03621934f, 0.03750512f, 
    0.02451191f, -0.04119770f, 0.00998276f, 0.01148209f, -0.06442071f, -0.07229069f, -0.03225170f, 0.05710058f, 
    0.03783871f, -0.02887070f, 0.02525263f, 0.01675162f, 0.02614382f, -0.07784823f, 0.02124126f, 0.02091679f, 
    0.08046710f, -0.01997804f, 0.08835093f, -0.01706194f, 0.09954225f, -0.02840711f, -0.01371885f, -0.03815586f, 
    -0.03608634f, -0.13408297f, 0.10278954f, -0.08981358f, -0.06263174f, 0.07266232f, -0.03789317f, 0.04114118f, 
    -0.06214815f, 0.04707117f, 0.00498008f, -0.00477945f, -0.06719695f, 0.00029484f, 0.03766849f, 0.02450002f, 
    -0.22926566f, 0.13631903f, 0.22329371f, 0.11472993f, -0.04684635f, -0.16017592f, 0.06207651f, -0.00175608f, 
    -0.01502109f, -0.01948194f, 0.03407187f, 0.00001451f, -0.00846505f, 0.23836879f, 0.03520103f, -0.11106405f, 
    0.17064907f, 0.02943914f, 0.00716197f, -0.03978906f, -0.13541199f, -0.13055782f, -0.04257104f, -0.12627433f, 
    0.13030416f, 0.00112707f, -0.14818281f, -0.06335577f, 0.13474183f, 0.18090199f, -0.01576268f, 0.08392593f, 
    -0.06773933f, -0.01713699f, 0.09002968f, 0.19908334f, 0.10522574f, -0.15211803f, 0.13303727f, 0.00558074f, 
    0.02888462f, -0.07989167f, -0.00844354f, 0.11012129f, -0.03643207f, 0.08942910f, -0.07286655f, 0.08828123f, 
    -0.21884890f, 0.02760473f, 0.29064658f, 0.11579154f, 0.01849973f, 0.08689149f, 0.13970704f, 0.22969417f, 
    0.00334535f, 0.07574677f, -0.06309953f, 0.09330627f, 0.03784934f, 0.03633199f, 0.00886477f, 0.00035021f, 
    -0.03134092f, 0.23154713f, -0.01371794f, -0.08698776f, -0.03551613f, -0.12730463f, -0.12848943f, -0.17375702f, 
    -0.19048965f, 0.12000927f, 0.03046906f, 0.17449912f, 0.07718536f, 0.19047838f, 0.03143433f, 0.03442514f, 
    -0.03180300f, -0.01459846f, 0.01218791f, 0.14325844f, 0.17062423f, -0.00692101f, 0.08230510f, -0.32966715f, 
    0.11276831f, -0.06968238f, 0.06088168f, 0.02729787f, 0.05877803f, 0.01460873f, 0.07316900f, 0.03754290f, 
    -0.26982158f, -0.11247011f, 0.29992196f, -0.10055850f, 0.04799346f, 0.16870832f, -0.03635728f, 0.07059322f, 
    0.11010543f, 0.10749187f, -0.14457488f, -0.05899419f, -0.27741677f, -0.21336295f, 0.11140873f, -0.13254230f, 
    0.00311693f, 0.03645286f, 0.16711210f, -0.13645250f, 0.05238427f, -0.03817889f, -0.06490241f, -0.12534347f, 
    -0.10876423f, -0.04125622f, 0.09078503f, 0.34795207f, -0.11971316f, 0.02840251f, 0.07296283f, 0.03988145f, 
    -0.01600507f, -0.06378172f, 0.08820274f, -0.03223665f, -0.14813352f, 0.13540888f, 0.01659755f, -0.17084531f, 
    0.11627623f, 0.01022861f, 0.04855283f, -0.00058998f, -0.01339671f, 0.07736392f, -0.06096494f, -0.06502436f, 
    0.03283757f, 0.22437325f, -0.16375224f, -0.22431177f, 0.08743063f, 0.02185798f, 0.00621672f, 0.11022304f, 
    0.00093952f, 0.11607809f, 0.05847740f, 0.01793142f, 0.31575391f, -0.24770717f, -0.06507388f, 0.11606677f, 
    -0.06303337f, -0.00398433f, 0.14785063f, 0.04674298f, -0.06322481f, -0.07551562f, 0.04959898f, -0.06531564f, 
    -0.02212851f, 0.03372503f, -0.05327629f, 0.02069913f, 0.05383138f, -0.04352265f, -0.01552450f, -0.02877583f, 
    0.04031256f, 0.04523685f, 0.01025349f, -0.05260998f, 0.00404760f, -0.04730896f, -0.05865706f, 0.01649663f, 
    -0.04856879f, -0.03605169f, 0.04464531f, -0.07614184f, 0.00609475f, 0.02890619f, 0.04507069f, 0.00296550f, 
    -0.03911743f, -0.01535282f, 0.02523953f, 0.06183198f, 0.02155656f, 0.05057425f, -0.01910992f, -0.05420434f, 
    0.04494914f, 0.05060461f, -0.00086422f, 0.05985538f, -0.07772158f, -0.04644937f, -0.04227688f, -0.00279188f, 
    -0.06763693f, -0.03159256f, 0.03876889f, -0.03599166f, 0.03663595f, -0.07047174f, -0.07741050f, -0.01050760f, 
    -0.06189432f, 0.04010459f, -0.03321888f, 0.06457490f, -0.01200665f, 0.06121752f, 0.06064449f, -0.01986421f, 
    -0.03059278f, -0.02269386f, 0.04740535f, -0.06545592f, -0.02497264f, 0.05025627f, 0.00013090f, -0.07614274f, 
    0.04916035f, -0.02779103f, -0.05006629f, -0.00539769f, -0.06953269f, -0.03417051f, 0.01108226f, 0.02274016f, 
    -0.03574888f, 0.03882668f, -0.02965806f, 0.02800337f, -0.02845870f, -0.06447095f, -0.02438643f, 0.04039671f, 
    0.02646020f, -0.03482798f, -0.00617895f, 0.06123085f, 0.00075249f, -0.06604621f, -0.01755232f, -0.04666763f, 
    0.02397886f, -0.06120523f, -0.00683904f, -0.07485680f, 0.05283667f, 0.04581289f, -0.04716208f, -0.04202127f, 
    0.03413552f, -0.07798133f, -0.01892187f, -0.01889305f, -0.06173906f, -0.00666843f, 0.05196083f, -0.05988887f, 
    -0.04260850f, -0.03424761f, -0.04964634f, 0.03736969f, -0.03354346f, 0.05217839f, 0.00558233f, -0.01654363f, 
    -0.07280342f, 0.04469376f, -0.04359537f, 0.03048336f, -0.03124679f, -0.00162711f, 0.02533914f, 0.01548259f, 
    0.05427479f, -0.05739272f, 0.00538091f, 0.00539874f, 0.05198201f, 0.02452223f, 0.05115009f, 0.04059008f, 
    -0.06713879f, -0.04809484f, -0.01267602f, -0.00863171f, -0.03474813f, -0.06306221f, -0.01050348f, 0.05170534f, 
    -0.05620646f, 0.04423702f, -0.00348783f, -0.06142665f, -0.04864727f, -0.07557777f, -0.06543219f, -0.04641350f, 
    0.04436863f, 0.03767422f, -0.07755265f, -0.07623690f, 0.02544480f, -0.07198536f, 0.06513993f, 0.01858715f, 
    -0.06139639f, -0.00736136f, 0.01495427f, 0.06042671f, -0.04805735f, 0.02941661f, -0.05860464f, 0.00385288f, 
    -0.07587627f, 0.03778435f, -0.05538378f, 0.06005342f, 0.05021242f, -0.04828848f, -0.05952572f, 0.01100926f, 
    0.06221234f, -0.04839973f, -0.05978787f, 0.05822219f, 0.02872931f, 0.00349657f, -0.06071186f, -0.06567428f, 
    -0.06981831f, -0.05595957f, -0.04013547f, 0.02342711f, -0.06523798f, 0.01439807f, -0.05329302f, 0.03564887f, 
    0.00915196f, -0.01792068f, 0.05395821f, -0.03044801f, -0.01819386f, -0.03502396f, 0.00502267f, -0.02327404f, 
    0.16444224f, 0.02461607f, 0.08416273f, 0.06663546f, 0.04118316f, 0.14626418f, 0.02078995f, -0.04217137f, 
    -0.08224967f, 0.09301481f, 0.15778254f, -0.02983429f, 0.31418526f, 0.19271244f, -0.05382017f, 0.20069684f, 
    -0.05973804f, 0.13597898f, -0.17735723f, -0.01850377f, 0.02666195f, -0.03811130f, 0.08766083f, -0.02180384f, 
    0.10575595f, 0.05991807f, 0.10421220f, 0.11215038f, -0.07556525f, 0.08362512f, 0.01667998f, -0.12017854f, 
    -0.01389726f, 0.06071489f, 0.00076619f, 0.11121681f, -0.10940755f, -0.13612340f, -0.02932745f, 0.12361418f, 
    0.04606309f, -0.08851663f, -0.04798042f, -0.06253811f, -0.04599305f, 0.10998512f, 0.07309064f, -0.06650207f, 
    0.11570780f, -0.18874303f, 0.07934235f, -0.18737420f, 0.13271078f, 0.00498054f, 0.03731729f, -0.02949385f, 
    0.01893270f, -0.04492655f, 0.03587388f, 0.14172389f, -0.15451096f, -0.28198248f, 0.11670188f, 0.10934559f, 
    0.10813188f, 0.03745267f, -0.08185296f, 0.09754073f, 0.00435457f, 0.05005466f, -0.06104185f, 0.19668722f, 
    -0.08443428f, -0.06410618f, -0.02089277f, -0.00777315f, -0.04782903f, 0.06222883f, 0.00947433f, 0.07617899f, 
    0.10521082f, 0.06471949f, -0.02563739f, 0.00753469f, 0.11537742f, 0.21054791f, 0.31687197f, -0.42448059f, 
    -0.09992523f, 0.06575036f, 0.11104657f, -0.09995364f, 0.04046267f, 0.00615743f, -0.00823617f, -0.02099074f, 
    -0.02449362f, 0.07593759f, 0.01101064f, 0.36798531f, -0.01619686f, 0.10873809f, -0.04219562f, 0.18191238f, 
    0.00871899f, -0.00676528f, -0.05593166f, -0.00500530f, 0.06512876f, 0.15177307f, 0.02582072f, 0.01705247f, 
    0.09443182f, -0.04725778f, 0.04003211f, 0.06796080f, 0.00293283f, 0.05196076f, 0.03260959f, 0.02348802f, 
    -0.37992510f, -0.17897812f, 0.09156378f, -0.00946470f, 0.15376788f, 0.10428602f, -0.07457446f, 0.03351480f, 
    -0.06067833f, 0.09307214f, -0.07314111f, -0.04004506f, -0.09072324f, 0.03993137f, 0.15253052f, -0.03470185f, 
    0.12192433f, -0.06666995f, -0.01993349f, -0.02710884f, -0.08186641f, 0.08657110f, 0.05780828f, -0.01646818f, 
    -0.08501860f, -0.04419776f, 0.11821760f, 0.27961549f, -0.18037841f, 0.14070143f, 0.01069503f, 0.00128930f, 
    0.05558758f, 0.03561988f, 0.12169658f, -0.04384626f, -0.48268798f, -0.06257267f, -0.01942538f, -0.34575474f, 
    0.07820264f, 0.03313371f, -0.08227853f, -0.04675986f, 0.00974797f, -0.01837862f, -0.04067354f, 0.05540204f, 
    -0.30948415f, 0.10718615f, -0.06412343f, -0.26651874f, 0.07341854f, -0.02108794f, 0.10981143f, -0.02116450f, 
    -0.04633050f, -0.06963169f, -0.00082540f, -0.01079665f, 0.42302763f, -0.02855587f, 0.00440885f, 0.07386304f, 
    0.04286432f, 0.08258889f, 0.10726517f, 0.00942678f, -0.06538961f, 0.01936689f, 0.10837125f, 0.01923103f, 
    -0.01387980f, -0.03800019f, -0.07498284f, 0.08382784f, -0.03272682f, 0.10943204f, 0.00572365f, -0.00637763f, 
    0.03685317f, 0.05358049f, -0.01156054f, -0.05670894f, -0.25780693f, 0.06258219f, 0.09539507f, 0.02731461f, 
    -0.10508248f, -0.00452983f, -0.08384179f, 0.05075830f, -0.02164219f, -0.11856724f, -0.06272659f, -0.01975639f, 
    -0.33508325f, 0.02354286f, -0.03175566f, -0.13520201f, 0.15560156f, 0.11069971f, 0.06494610f, 0.05135600f, 
    -0.06658761f, -0.02498663f, 0.03206473f, -0.05331159f, 0.12154997f, -0.05519520f, -0.09098192f, 0.19150811f, 
    -0.05604520f, -0.03547297f, 0.06331945f, 0.08522648f, -0.05759642f, 0.00446597f, 0.16494904f, -0.06133174f, 
    0.30496812f, 0.09514816f, 0.15498492f, 0.21838869f, 0.18801145f, 0.00731668f, 0.07570409f, -0.07422672f, 
    -0.01842649f, -0.02529654f, 0.04362762f, 0.02240245f, 0.06030286f, -0.35310358f, 0.07016162f, 0.14329866f, 
    0.04017555f, -0.00851932f, -0.04725586f, -0.00686409f, 0.01698116f, 0.08139846f, 0.06262765f, -0.00312979f, 
    -0.21427217f, -0.11109920f, -0.11247296f, -0.15127656f, 0.08071435f, 0.07501205f, 0.03292784f, -0.11383145f, 
    0.06480062f, -0.11308403f, -0.08294243f, 0.07911149f, 0.21468727f, -0.04869706f, 0.07557455f, -0.08960843f, 
    0.05274041f, -0.13366278f, -0.04294533f, 0.17460893f, 0.08116487f, 0.13055569f, 0.01114819f, 0.03144188f, 
    0.24072796f, 0.12949866f, -0.01844570f, 0.00455427f, -0.06914176f, 0.11767518f, -0.08091219f, -0.03880128f, 
    0.14350249f, -0.01357781f, -0.04404583f, 0.13683800f, -0.32666409f, -0.26266557f, 0.00241925f, 0.21997598f, 
    -0.01017830f, 0.04315363f, 0.13126370f, -0.13613406f, -0.08394706f, 0.10203035f, 0.29401186f, 0.11328959f, 
    0.12196214f, 0.20244990f, 0.17833827f, -0.14033709f, 0.12619780f, -0.07590113f, -0.06725901f, 0.13712774f, 
    0.01594682f, 0.03854822f, -0.06665714f, 0.04705251f, 0.03667998f, 0.21377130f, 0.24263583f, -0.03528608f, 
    0.26786768f, -0.01623001f, -0.10910321f, -0.03801064f, -0.00099659f, -0.06143897f, 0.09914629f, 0.04090210f, 
    0.07367197f, 0.09886876f, -0.02936432f, 0.00270721f, 0.03906498f, 0.00019721f, 0.00034188f, -0.03689792f, 
    0.02256972f, -0.02059892f, 0.00214697f, 0.04449195f, -0.05615094f, 0.13839884f, 0.02404060f, -0.24853957f, 
    -0.09272738f, -0.00717016f, 0.03549286f, 0.10124696f, -0.00853447f, 0.08067016f, 0.13051547f, -0.14357486f, 
    0.12898123f, -0.02722340f, -0.09418751f, -0.09660029f, 0.00235742f, -0.01118897f, 0.05879910f, 0.06377809f, 
    0.03128093f, -0.02851151f, 0.07540384f, 0.05157053f, -0.12552692f, -0.24322955f, -0.08516035f, 0.15234022f, 
    0.04468467f, 0.15573329f, -0.01579934f, 0.14261749f, 0.08913103f, 0.00296226f, 0.14544491f, -0.01594718f, 
    0.06773078f, -0.06068222f, -0.08257733f, -0.06583389f, -0.02041490f, -0.02464235f, -0.04890705f, -0.03361402f, 
    -0.10497124f, -0.16520473f, -0.08988578f, -0.03480822f, -0.20138371f, -0.18715815f, -0.01645048f, -0.08274702f, 
    -0.01478702f, -0.07772185f, 0.09832755f, 0.02674354f, -0.02466249f, -0.02579499f, 0.05164879f, -0.06381433f, 
    0.25524551f, -0.16053164f, -0.10069357f, -0.04451886f, -0.01599306f, -0.00525000f, -0.06335998f, -0.07411404f, 
    0.00689720f, 0.09411275f, 0.22259207f, -0.00574826f, 0.11721025f, -0.22049296f, -0.09242730f, 0.05512037f, 
    0.01517457f, 0.03948132f, 0.09141755f, 0.07397618f, -0.06356330f, 0.02866933f, -0.00184209f, -0.04727049f, 
    -0.03041451f, 0.02113381f, -0.15792161f, 0.14894316f, 0.01517312f, 0.04316274f, -0.08857718f, -0.01493146f, 
    0.08139788f, 0.01468663f, -0.04333058f, -0.06825895f, 0.24644308f, 0.05894656f, -0.00119049f, -0.08523708f, 
    0.07281109f, -0.01608270f, -0.01331742f, 0.04094531f, 0.03797685f, -0.07432076f, 0.11321274f, -0.06620557f, 
    0.34307650f, 0.00480947f, 0.04954402f, -0.17225911f, -0.04621497f, -0.09895502f, 0.10955817f, 0.00005521f, 
    -0.01069508f, 0.03760189f, -0.03980303f, 0.05954329f, 0.20450267f, 0.03080667f, -0.21490547f, 0.13155603f, 
    -0.04936692f, -0.02142967f, 0.00116341f, 0.08694641f, 0.04268811f, -0.02212006f, -0.00310277f, -0.00040543f, 
    0.08521970f, 0.02368867f, 0.08757574f, -0.20964783f, 0.00477296f, -0.09262358f, 0.08749255f, -0.01278325f, 
    -0.01600401f, -0.07714074f, 0.11165561f, 0.17806977f, -0.13809541f, -0.02764139f, -0.03672168f, 0.21283917f, 
    -0.01091308f, -0.04735430f, 0.01045770f, 0.11058154f, 0.06398378f, 0.12826279f, 0.14902054f, 0.07879566f, 
    0.15722120f, 0.27727938f, 0.16423187f, -0.42185378f, 0.02526379f, -0.05706754f, -0.03942934f, 0.03578606f, 
    0.07313197f, 0.12159318f, -0.06626343f, -0.06364360f, 0.00447722f, 0.33037159f, 0.05875822f, -0.07352495f, 
    0.09630208f, 0.12507764f, 0.03191894f, 0.02303438f, 0.06636338f, -0.08678674f, 0.06044236f, 0.00147163f, 
    0.22660396f, 0.00232304f, 0.01443478f, -0.10160661f, 0.12960191f, -0.16016962f, 0.03030510f, 0.03221983f, 
    0.04915682f, -0.05259702f, 0.02130237f, 0.06326892f, 0.02694379f, 0.31981251f, 0.02756748f, -0.23359983f, 
    -0.02675833f, -0.00659393f, 0.13898842f, 0.01665389f, -0.13053554f, 0.18583444f, 0.04579534f, -0.03307839f, 
    -0.00366917f, 0.00425999f, 0.03509529f, -0.14694342f, 0.07926299f, -0.04146640f, -0.11512951f, -0.02303126f, 
    0.10022241f, 0.04482739f, -0.07532816f, -0.13451125f, -0.26074570f, 0.11839397f, -0.30185765f, -0.01532294f, 
    -0.15734443f, 0.00635990f, -0.14336833f, 0.12027203f, 0.16795756f, 0.11711130f, 0.02454430f, 0.00209146f, 
    0.03128925f, 0.00021237f, -0.04583837f, -0.04847754f, -0.06777772f, 0.01833129f, -0.05911822f, -0.01839086f, 
    -0.04155829f, 0.05380322f, -0.03005777f, -0.00494476f, 0.03257990f, -0.07195784f, -0.04535337f, -0.06636054f, 
    -0.03944702f, 0.07113557f, 0.00456059f, 0.00607685f, -0.06457267f, 0.03854280f, -0.04169745f, -0.06232438f, 
    0.04857764f, -0.02081039f, 0.02021540f, -0.00628119f, -0.07617630f, 0.00777489f, -0.03136190f, 0.03228696f, 
    -0.03132232f, -0.05985538f, 0.05051018f, 0.00872815f, -0.03525383f, -0.00335127f, -0.06026389f, 0.05296922f, 
    0.06879510f, -0.07485181f, 0.00174994f, 0.04859371f, -0.01212980f, -0.06434781f, 0.02314537f, 0.02548626f, 
    -0.00698827f, 0.01361865f, -0.03089127f, -0.03739639f, -0.04793008f, 0.00360469f, 0.03582918f, 0.05277484f, 
    0.05427973f, 0.00947308f, -0.00741061f, 0.05701886f, 0.03844576f, -0.06985886f, -0.01488238f, 0.01867665f, 
    -0.04334975f, 0.02649300f, 0.03324157f, 0.01611329f, -0.06400271f, -0.04716810f, 0.01576999f, 0.05343689f, 
    -0.00258775f, 0.01978501f, -0.04525218f, -0.06547133f, -0.04724523f, 0.02504411f, -0.05160612f, -0.04547851f, 
    0.03869912f, 0.00097154f, -0.02719036f, -0.05433765f, 0.05541783f, -0.07435524f, 0.03996300f, -0.06262999f, 
    -0.05707890f, 0.04615976f, -0.03080211f, -0.04247667f, -0.07649764f, -0.06840657f, 0.01134808f, 0.06378748f, 
    0.04047349f, -0.02792899f, 0.05784048f, -0.02316831f, -0.02088855f, -0.03470670f, 0.03199948f, -0.01877892f, 
    -0.03766036f, -0.06459460f, -0.06302911f, -0.02591281f, 0.05154221f, -0.06348480f, 0.02613897f, -0.03027730f, 
    -0.02852433f, -0.00885541f, 0.03198859f, 0.03486179f, 0.05237377f, -0.06632679f, 0.05900076f, -0.00601199f, 
    -0.02674267f, -0.01372077f, 0.02726771f, -0.05683463f, 0.03481805f, -0.04770743f, -0.07608702f, -0.04024123f, 
    -0.03105707f, 0.02992384f, 0.03081515f, 0.04292282f, -0.01361952f, -0.01836659f, 0.04390111f, 0.02882225f, 
    -0.04195512f, -0.03753769f, -0.05904639f, 0.06536941f, -0.02890717f, -0.01723151f, -0.04409939f, -0.02892444f, 
    0.02894000f, -0.05476169f, 0.00286714f, 0.00538675f, -0.00897133f, -0.03580071f, 0.03639482f, 0.05565090f, 
    0.06503417f, -0.00626095f, 0.00845137f, 0.00563548f, -0.01039647f, 0.03533644f, 0.04240406f, -0.05454463f, 
    -0.04577404f, 0.02752901f, 0.05358721f, 0.02218341f, -0.06016022f, 0.03187132f, -0.01098125f, 0.05527541f, 
    0.00141279f, 0.06540622f, -0.02683753f, 0.05088633f, -0.07516070f, 0.02079588f, 0.05847816f, -0.04902265f, 
    -0.03814369f, -0.05014707f, -0.04477814f, -0.00820690f, 0.03335656f, -0.01342335f, 0.05739580f, -0.04297726f, 
    -0.03925451f, -0.07807833f, -0.04197902f, -0.01693694f, -0.02331555f, -0.02070352f, -0.05146861f, -0.01651063f, 
    -0.05228182f, 0.01841722f, 0.01425216f, 0.06319743f, -0.03868676f, 0.04245889f, -0.05544494f, -0.00810183f, 
    0.02892195f, -0.06303085f, -0.03150589f, -0.03615252f, 0.05631270f, -0.07246090f, -0.03690428f, -0.04307542f, 
    -0.07448632f, 0.01597165f, 0.00997448f, 0.03720932f, 0.03918894f, -0.00455857f, -0.01967260f, 0.05774304f, 
    -0.07525146f, -0.05800086f, 0.05373685f, -0.05492127f, 0.04226071f, -0.02456569f, -0.00640748f, -0.04574643f, 
    -0.04695316f, 0.01941707f, -0.03433526f, -0.07289134f, -0.00593156f, -0.00862057f, -0.07376412f, 0.02119221f, 
    -0.03297404f, 0.03681494f, -0.06348658f, -0.01713507f, 0.02625387f, -0.03704340f, -0.04126191f, -0.06392621f, 
    -0.05129248f, -0.08863193f, -0.07318354f, -0.06844483f, -0.07143745f, -0.00238360f, -0.00547898f, -0.02034903f, 
    -0.05681450f, -0.04268544f, 0.01596279f, 0.05485859f, 0.05086560f, 0.02979746f, -0.03453342f, 0.01553401f, 
    -0.07308148f, 0.06145379f, -0.01208189f, 0.04731533f, -0.03661137f, -0.05740025f, 0.03447174f, 0.00021690f, 
    -0.03401088f, -0.06005792f, -0.02906773f, -0.00732633f, 0.00131475f, -0.02396763f, 0.04885431f, 0.00675087f, 
    -0.05855404f, 0.00860216f, -0.04950637f, 0.04414824f, -0.02821201f, 0.03749689f, 0.01335625f, 0.00054881f, 
    -0.05179912f, -0.02300918f, 0.00302708f, 0.05056495f, 0.05172240f, 0.04532825f, -0.02664582f, -0.06690357f, 
    0.01699068f, -0.07452377f, 0.02583703f, 0.03217175f, 0.06244667f, -0.05826616f, -0.01131907f, -0.06444189f, 
    -0.00760598f, -0.04653994f, -0.04645269f, 0.05403572f, 0.02972464f, -0.05564522f, 0.03850455f, 0.02473391f, 
    -0.07050211f, -0.05132344f, -0.02335886f, 0.02285361f, -0.03904536f, -0.06554264f, 0.05532835f, -0.05967842f, 
    -0.04242770f, 0.04962842f, -0.06681074f, 0.03581540f, 0.00732035f, -0.04880971f, -0.00937940f, -0.07349915f, 
    -0.01313349f, -0.00563129f, -0.01013883f, 0.02270756f, -0.05079678f, 0.01347166f, -0.06417773f, -0.05859424f, 
    -0.01010571f, 0.01926672f, -0.00796266f, 0.01023446f, 0.02968572f, 0.03124468f, -0.04080927f, -0.03677479f, 
    -0.03032581f, 0.05187537f, -0.05412053f, -0.02416159f, 0.00188505f, 0.02817005f, -0.05111426f, 0.05245543f, 
    0.02304139f, 0.06230830f, 0.01982739f, 0.00022068f, -0.03835730f, 0.00854631f, -0.06715445f, 0.04456069f, 
    -0.04374250f, -0.06570853f, -0.00354935f, -0.06806321f, 0.02873010f, 0.00070872f, -0.04487953f, 0.01207321f, 
    -0.01382007f, -0.07253476f, 0.01136140f, -0.05850085f, -0.03586199f, 0.02570089f, 0.04132369f, -0.05827400f, 
    0.00527761f, 0.04993114f, -0.06393629f, 0.03891855f, -0.06907964f, 0.01290850f, 0.03423268f, 0.05075229f, 
    -0.07167343f, 0.05513778f, -0.07254209f, 0.03762653f, -0.05816937f, -0.01114150f, 0.05390578f, 0.02288592f, 
    0.03651538f, -0.20069134f, -0.08142886f, 0.01314199f, 0.08422309f, -0.00096493f, 0.08218294f, 0.17659062f, 
    0.12125362f, 0.27254486f, -0.03759432f, 0.12943868f, -0.19351448f, 0.16603236f, -0.05594114f, 0.12359382f, 
    0.15084656f, 0.07435326f, 0.18572457f, 0.07045216f, 0.00320299f, 0.03057694f, 0.12740155f, 0.00758190f, 
    -0.13953270f, -0.16418345f, -0.12194978f, -0.15375897f, 0.17049922f, 0.18642434f, -0.08822291f, 0.11367313f, 
    -0.01979514f, -0.01013628f, -0.11589251f, 0.03056323f, 0.11189840f, -0.01160612f, -0.03245771f, 0.09717624f, 
    0.06814805f, 0.05000630f, 0.00980503f, -0.02321323f, 0.03975148f, 0.12234353f, 0.06228031f, 0.01783418f, 
    0.24825223f, 0.23031838f, 0.18019193f, 0.08490463f, -0.02540033f, -0.10487306f, 0.01291047f, 0.06330946f, 
    0.05140875f, 0.11815071f, -0.03501765f, -0.02753307f, 0.12452873f, -0.05018527f, -0.03718117f, -0.03228960f, 
    -0.04819538f, 0.02048350f, -0.03742576f, 0.08194965f, 0.15263347f, -0.03406051f, -0.07150811f, -0.04541063f, 
    -0.04205060f, -0.01917295f, -0.08903729f, 0.01532916f, 0.17751114f, 0.02303150f, -0.02210929f, -0.04036225f, 
    0.06500888f, -0.01201190f, 0.05957525f, -0.02538862f, -0.01359936f, 0.01463601f, 0.23222779f, -0.28324381f, 
    -0.05031533f, -0.04768693f, 0.00656704f, 0.05273128f, -0.01535742f, -0.01874454f, 0.18405937f, 0.01083856f, 
    -0.06804175f, 0.01979580f, 0.16293952f, -0.10301186f, 0.02336949f, -0.12325074f, -0.04013891f, 0.08171787f, 
    0.14900798f, -0.00479160f, -0.02576350f, -0.02767406f, -0.27073509f, -0.23276369f, -0.14025393f, 0.03942889f, 
    0.02303375f, 0.03522799f, 0.05601455f, -0.08242314f, -0.11526442f, 0.04536265f, 0.03674933f, -0.07548074f, 
    0.09698112f, 0.05846096f, 0.07408328f, -0.04589336f, 0.07369523f, 0.02078892f, -0.03859519f, -0.07420841f, 
    -0.07486092f, -0.01684003f, 0.02197694f, 0.10607357f, -0.06570850f, 0.04157390f, 0.04312823f, 0.03376103f, 
    -0.07942922f, -0.02477263f, -0.03101421f, 0.04137711f, -0.01150842f, 0.12414634f, 0.00044318f, 0.02435212f, 
    0.12140399f, -0.03107819f, 0.06258353f, -0.02741227f, 0.13739595f, 0.10237212f, -0.06877530f, -0.01104685f, 
    -0.02082138f, -0.03254483f, 0.01013943f, -0.05725605f, 0.05689908f, 0.08706436f, 0.12661506f, 0.05563327f, 
    -0.00548319f, 0.00723049f, 0.12712465f, 0.05056350f, 0.04867057f, -0.07863747f, 0.06841138f, -0.04039541f, 
    0.02358215f, 0.24552695f, 0.21844698f, 0.10704645f, -0.00372411f, -0.02521589f, -0.00779241f, -0.09319126f, 
    -0.00969300f, -0.11983018f, 0.03868768f, 0.06059171f, -0.09084292f, -0.22920376f, 0.04958998f, -0.11380640f, 
    0.10464203f, 0.12978238f, -0.02636799f, -0.01810528f, -0.01262298f, -0.19481598f, 0.15157351f, 0.05782063f, 
    -0.06865785f, 0.04102832f, -0.07147005f, 0.01119412f, -0.05896437f, -0.03695084f, 0.04203301f, 0.02523579f, 
    -0.06632384f, -0.05654408f, -0.06042780f, 0.02672339f, 0.02689103f, -0.03382664f, -0.02040176f, 0.00423501f, 
    0.03159375f, 0.05008402f, -0.01777399f, -0.01192508f, 0.06148889f, 0.06285446f, 0.02847511f, 0.02104510f, 
    -0.05273418f, -0.04874836f, -0.06497665f, -0.05421883f, -0.03441797f, 0.04433051f, -0.06093040f, 0.00267090f, 
    -0.05709866f, 0.05471179f, -0.01585146f, -0.07253698f, -0.07454162f, -0.02079988f, 0.01384476f, -0.06286417f, 
    -0.00080078f, 0.03250721f, -0.07675698f, 0.04803171f, -0.03029064f, 0.00997612f, -0.03955010f, -0.00354295f, 
    -0.02610796f, 0.01093783f, 0.01128209f, 0.03152003f, 0.05824876f, 0.06883553f, -0.04611850f, 0.05011338f, 
    -0.03989600f, 0.05971062f, -0.04288056f, 0.02453127f, -0.03733615f, 0.01353078f, -0.03727239f, -0.00638420f, 
    -0.03038751f, -0.00274175f, 0.01943593f, -0.01748750f, -0.01025686f, 0.01011423f, 0.03225970f, 0.00671289f, 
    0.01790242f, -0.05542412f, -0.05181556f, -0.01560491f, 0.05405002f, -0.05253949f, 0.01158979f, -0.07833173f, 
    0.05547341f, 0.03177432f, 0.02460417f, 0.03862666f, -0.04783528f, 0.06572971f, -0.07573402f, 0.00145728f, 
    0.05869118f, -0.05255339f, -0.03059101f, 0.05800467f, 0.04697553f, 0.05370678f, 0.01531293f, -0.05856160f, 
    0.05034649f, -0.05222623f, -0.02054682f, -0.01034552f, 0.04418098f, 0.04650414f, 0.01489540f, -0.06003796f, 
    0.04127706f, -0.07137967f, -0.00051561f, -0.05067301f, 0.02463420f, -0.04935248f, 0.01919089f, -0.06578874f, 
    0.04237682f, -0.01985243f, -0.01844182f, 0.05240424f, -0.03393194f, -0.01413041f, 0.03017555f, -0.07172547f, 
    -0.04504095f, -0.07956336f, 0.03448132f, -0.06361964f, 0.02985495f, -0.07161009f, -0.04478752f, -0.05922981f, 
    0.05202284f, 0.04748179f, 0.01994438f, -0.04342555f, 0.00784560f, -0.03672032f, -0.05953131f, -0.03887787f, 
    -0.05490929f, 0.00169799f, -0.01777653f, -0.07569005f, 0.06782904f, 0.01048693f, -0.00585276f, 0.00875286f, 
    -0.08400600f, -0.01851773f, 0.04647148f, -0.07347868f, -0.06336875f, -0.04739529f, 0.00380671f, 0.06034110f, 
    -0.03878416f, 0.04758024f, -0.01986224f, 0.01858589f, -0.07257532f, -0.06923974f, -0.03547247f, -0.01966735f, 
    0.02170375f, -0.04451635f, 0.03002886f, -0.00175440f, -0.03188099f, 0.01843086f, 0.01271268f, -0.05058286f, 
    0.04846539f, 0.01980000f, 0.05476863f, 0.02724642f, -0.07238508f, 0.02467603f, -0.01593411f, -0.00940720f, 
    0.03149485f, 0.00529663f, -0.00669396f, -0.02996662f, 0.03907430f, -0.06360313f, -0.00690758f, 0.04516976f, 
    0.00203877f, -0.06649338f, -0.03888352f, -0.03537371f, -0.03270481f, 0.04957160f, -0.06017741f, -0.01796904f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04909462f, 0.04455794f, 0.09803959f, -0.07700620f, -0.05275348f, -0.11600982f, 0.04750134f, 0.05648495f, 
    0.07050949f, 0.06519216f, 0.18366611f, 0.02840653f, 0.02402706f, -0.11063228f, -0.02938514f, -0.01869434f, 
    0.05623489f, 0.02842526f, -0.02947474f, -0.01009818f, 0.05148993f, 0.03991909f, 0.07510690f, -0.05873462f, 
    -0.12026762f, 0.06586774f, 0.03443358f, 0.05610994f, -0.04868243f, 0.06306851f, 0.08612289f, 0.04891387f, 
    -0.01368269f, 0.06047432f, 0.09567662f, -0.02923632f, 0.03945398f, 0.01865003f, 0.07906199f, 0.04119099f, 
    0.07363506f, 0.05521644f, 0.02225023f, -0.00714990f, 0.01673642f, -0.03136548f, -0.01255492f, 0.17368005f, 
    -0.00438964f, 0.03431362f, -0.01820121f, -0.10021643f, 0.05211679f, 0.07219672f, 0.06069769f, -0.01499226f, 
    0.06308936f, 0.03312235f, -0.04383606f, 0.02510323f, 0.03429187f, 0.09695820f, -0.02330056f, 0.08768453f, 
    -0.01617791f, 0.01843895f, -0.07016496f, -0.04239906f, 0.04340429f, 0.02080244f, 0.04448817f, 0.04595978f, 
    -0.02468259f, -0.00181160f, 0.14504269f, -0.02816096f, 0.00016106f, 0.04933504f, 0.12542385f, -0.05385055f, 
    -0.00775277f, -0.04553692f, 0.03643537f, 0.02787057f, 0.07177977f, 0.06531133f, 0.11032395f, 0.07031887f, 
    -0.04234381f, 0.01749130f, 0.04008628f, 0.01471749f, 0.04163510f, 0.07962434f, -0.04701652f, 0.06375105f, 
    0.03679033f, 0.04730100f, -0.07915068f, -0.04889380f, -0.00763050f, 0.08162629f, 0.04778703f, 0.06057686f, 
    -0.01356731f, 0.08175206f, -0.07050373f, -0.00344548f, 0.05898123f, 0.03340526f, -0.09455568f, -0.04887338f, 
    0.12442356f, 0.03426645f, 0.12485584f, 0.12964967f, -0.02176037f, -0.01017503f, -0.01602691f, -0.06598901f, 
    0.02174258f, 0.07809453f, 0.08424570f, 0.00416997f, 0.01240008f, -0.04897280f, 0.01962652f, -0.07895985f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04056555f, 0.05479387f, -0.13636273f, 0.04717442f, -0.01212676f, 0.14044005f, -0.02930662f, 0.16868380f, 
    0.09645234f, -0.13495296f, -0.37863076f, 0.05469920f, 0.14107877f, 0.38303030f, 0.05292840f, -0.37222558f, 
    0.00778533f, -0.06295431f, -0.41584226f, 0.07357308f, -0.22028716f, -0.24115592f, -0.14948057f, 0.28883880f, 
    0.22117981f, 0.22454795f, 0.03591336f, -0.01523167f, 0.22439530f, 0.23958553f, 0.27921420f, -0.39489147f, 
    0.05878324f, -0.18133204f, -0.05548691f, -0.08776546f, 0.04220217f, -0.33246517f, 0.20015956f, 0.06800917f, 
    0.06382504f, -0.07520457f, 0.04463854f, 0.11882123f, -0.47139940f, -0.32590115f, -0.02614537f, -0.83092761f, 
    -0.12580822f, -0.00637364f, 0.19551405f, -0.01427601f, 0.08216326f, 0.17786181f, 0.02111626f, -0.01118327f, 
    -0.61417729f, 0.05395221f, 0.21571644f, -0.06233552f, 0.03652712f, -0.28038791f, 0.13109677f, -0.43437660f, 
    -0.05611961f, 0.06875134f, -0.26177135f, -0.08257437f, -0.06580516f, 0.05153180f, -0.27074358f, -0.29236957f, 
    -0.06959564f, 0.01114030f, -0.32694820f, 0.02018383f, 0.05069840f, 0.00724190f, 0.13187106f, 0.03623554f, 
    -0.06054999f, 0.23840424f, 0.09353691f, -0.09754641f, 0.26746592f, 0.13434713f, -0.18508568f, 0.01552241f, 
    -0.04739429f, -0.15675864f, -0.06946222f, -0.02654550f, 0.15608001f, -0.11292895f, -0.01721692f, -0.31671914f, 
    0.00766754f, -0.14781265f, 0.12483767f, -0.05305211f, 0.00127381f, 0.13591182f, 0.02622324f, -0.07965089f, 
    -0.07671922f, -0.03828792f, 0.06783706f, 0.31387940f, 0.16856046f, -0.46312776f, 0.36078542f, -0.03644744f, 
    0.00016831f, -0.07561169f, -0.17761925f, -0.37752405f, -0.03856324f, -0.33291727f, -0.01365444f, -0.08391772f, 
    -0.07892966f, -0.34399828f, 0.19586702f, 0.21263550f, 0.08841737f, -0.01807678f, -0.08381204f, -0.06181666f, 
    0.01061874f, 0.10675745f, -0.12559858f, 0.01272172f, 0.24250881f, -0.03998094f, 0.14893857f, -0.21733713f, 
    0.12756498f, -0.16051841f, 0.06008165f, -0.06165903f, -0.02838141f, -0.08999512f, -0.07055704f, -0.30136085f, 
    0.03193710f, 0.27022287f, 0.13239610f, -0.00895564f, 0.30350012f, 0.06431958f, 0.02927437f, 0.12844329f, 
    0.17046878f, -0.27748084f, 0.02362871f, 0.23686393f, 0.15430464f, -0.30486590f, 0.20573564f, -0.05561263f, 
    0.02479663f, -0.37959251f, 0.06557750f, -0.27442715f, 0.03917009f, -0.30671960f, -0.36309078f, 0.14867103f, 
    -0.09684703f, 0.03040187f, 0.01655011f, 0.15865715f, 0.33115962f, -0.03757774f, -0.03877600f, 0.44417834f, 
    0.02834239f, 0.12478828f, 0.25251129f, -0.19619791f, 0.01992151f, -0.22619432f, 0.05748403f, -0.04353980f, 
    0.33520553f, -0.68299657f, -0.57929838f, -0.00006818f, 0.20579329f, -0.35615185f, -0.06940665f, -0.13688052f, 
    -0.06110271f, 0.17094295f, 0.12490650f, -0.07023272f, 0.04642948f, 0.08987720f, 0.00171427f, -0.23597239f, 
    -0.00988253f, 0.12068007f, 0.06319530f, 0.04616360f, 0.00753806f, 0.00397036f, 0.18266843f, 0.04414667f, 
    -0.07812639f, -0.14883032f, -0.19593988f, -0.18170825f, -0.24620169f, -0.07652576f, -0.19879180f, -0.25017786f, 
    -0.07510434f, 0.11732624f, -0.06001129f, 0.08011378f, -0.00169389f, -0.15120699f, -0.01793832f, -0.01674977f, 
    -0.07290781f, 0.31934053f, -0.06230653f, -0.01711081f, 0.07652965f, 0.16407180f, -0.03465255f, 0.00366894f, 
    0.01647583f, 0.13733412f, -0.05319905f, 0.19003661f, -0.02376217f, 0.00144182f, -0.24702837f, 0.05396865f, 
    0.16910695f, -0.07773627f, -0.39876688f, -0.14768375f, 0.03604152f, 0.04480138f, -0.00624678f, -0.44114688f, 
    -0.05362867f, -0.30321625f, -0.12123289f, 0.08145992f, -0.06267150f, 0.02192987f, 0.17490827f, 0.03060413f, 
    -0.01041153f, -0.17491265f, 0.17037973f, -0.07852752f, 0.14618759f, 0.00939557f, -0.08579387f, -0.00540512f, 
    0.11596324f, -0.19820791f, -0.10184711f, 0.02242775f, 0.33246207f, -0.63492733f, -0.06174403f, 0.03528422f, 
    0.10305765f, -0.25911433f, 0.12451635f, -0.09188686f, -0.01417266f, 0.23656058f, 0.08296198f, 0.06547074f, 
    0.10333731f, -0.24469209f, 0.02844225f, 0.05500057f, -0.02323218f, -0.39408568f, -0.40726829f, -0.37541819f, 
    0.02324266f, -0.07991520f, 0.07139929f, 0.29410559f, 0.04549039f, 0.01564646f, 0.19294682f, 0.01518696f, 
    -0.57584947f, -0.03028310f, -0.04291405f, -0.23345627f, -0.54772115f, -0.05782545f, -0.07871889f, -0.26165774f, 
    -0.06048794f, -0.38331211f, 0.02767603f, -0.28552470f, -0.04614970f, -0.16874886f, -0.07442112f, 0.03907555f, 
    0.03954954f, 0.03849318f, -0.07640327f, -0.00427206f, 0.17805007f, -0.09304047f, -0.12516907f, 0.18478554f, 
    -0.04580609f, -0.49313673f, -0.23803167f, 0.02854581f, -0.08110365f, -0.07570834f, 0.26255652f, 0.23135616f, 
    -0.02578203f, -0.05681001f, 0.37676889f, 0.02640967f, 0.01389488f, -0.03178127f, -0.04230704f, 0.03699154f, 
    0.05035960f, -0.19086400f, 0.17760099f, -0.35452777f, 0.10114595f, 0.14287756f, -0.09005582f, -0.20550367f, 
    -0.04019328f, 0.25259924f, -0.07715207f, 0.22397460f, -0.18890411f, 0.10571890f, 0.03367085f, 0.00097205f, 
    0.03768585f, -0.19937547f, 0.13299677f, -0.01946906f, -0.08153640f, -0.07667059f, 0.01101369f, 0.04880422f, 
    0.05132984f, -0.24085090f, 0.04409898f, 0.14698355f, -0.00926159f, 0.27229032f, 0.07119110f, -0.04269863f, 
    -0.12662266f, -0.00864920f, -0.07073899f, 0.24139613f, -0.04776936f, 0.19090901f, -0.06377880f, 0.24439406f, 
    0.07451856f, -0.11480980f, -0.31822625f, 0.12661099f, -0.02759436f, -0.02602494f, -0.18687640f, 0.01647880f, 
    -0.02187752f, -0.33629349f, 0.20167831f, 0.03755848f, 0.02753546f, 0.20743577f, -0.29460052f, 0.15149888f, 
    0.09616413f, -0.04119688f, 0.26597881f, 0.05584787f, -0.29707089f, 0.16925174f, -0.02881923f, 0.05629218f, 
    -0.11628734f, -0.07611366f, 0.08046453f, 0.05318935f, -0.67470568f, -0.19970439f, 0.30744523f, -0.35913575f, 
    0.13174437f, 0.17852670f, -0.08447085f, -0.11086005f, 0.04248185f, -0.37263167f, 0.15378593f, 0.24264392f, 
    0.01488202f, 0.07491469f, 0.15530485f, 0.09779885f, 0.04922251f, -0.18756425f, 0.30570206f, -0.06141268f, 
    0.08312535f, -0.01570840f, 0.30530572f, 0.16288118f, 0.19412099f, -0.09067804f, -0.09397522f, -0.02237915f, 
    -0.18799847f, -0.18427910f, 0.05857945f, 0.05244238f, -0.04420751f, -0.08582213f, 0.01583458f, 0.07459571f, 
    0.05344157f, 0.03793612f, 0.13166165f, 0.08041609f, -0.60359740f, 0.15575521f, 0.10925297f, 0.10880164f, 
    -0.05634235f, -0.06651238f, -0.00600008f, 0.08209494f, 0.03293907f, -0.25193724f, -0.43167365f, -0.19197343f, 
    0.00525305f, 0.01486153f, -0.06679989f, -0.07708077f, 0.07799551f, -0.07278709f, 0.17712621f, 0.01824436f, 
    -0.02754673f, -0.09370061f, -0.49399689f, -0.03187218f, 0.14355317f, 0.03476503f, 0.08775527f, 0.11806948f, 
    0.08572597f, -0.39057958f, 0.06450284f, -0.11842697f, 0.07755525f, 0.07009064f, 0.00153372f, 0.14306517f, 
    -0.00314818f, 0.32020047f, 0.14096542f, 0.01707488f, -0.00544254f, -0.15672083f, -0.01778007f, -0.03761129f, 
    0.02990581f, -0.30776906f, 0.07930733f, -0.14676613f, -0.16010664f, -0.21092753f, -0.09299368f, 0.02130639f, 
    0.25539714f, -0.01123245f, 0.16400057f, -0.51505971f, -0.01234549f, 0.04601953f, -0.08874483f, -0.15849912f, 
    0.06016725f, 0.08343999f, -0.38610086f, -0.55310363f, 0.01034356f, 0.04016951f, -0.35987481f, -0.03658671f, 
    0.02243170f, 0.23500413f, -0.24666081f, -0.01083202f, -0.40683559f, -0.07417990f, 0.10412576f, -0.17880879f, 
    -0.03514337f, 0.03878074f, 0.04688582f, -0.01268108f, -0.41874012f, -0.11352926f, 0.06430932f, 0.06269888f, 
    -0.19737643f, 0.48276591f, 0.09469881f, -0.04596952f, -0.24544744f, 0.11004732f, 0.05301184f, 0.01962954f, 
    0.00198543f, 0.23278390f, -0.00795214f, -0.07362091f, -0.22345188f, 0.08270606f, -0.01586401f, 0.22417970f, 
    -0.08754033f, -0.29615209f, 0.10849749f, 0.14196026f, -0.05167567f, -0.06315091f, 0.12881730f, 0.16097128f, 
    0.11805141f, 0.00323830f, -0.01665668f, -0.06396758f, 0.20476742f, 0.12799695f, -0.04093052f, -0.07700639f, 
    0.20938158f, 0.15613747f, 0.06369931f, -0.01727495f, 0.06457473f, 0.18767257f, -0.02182633f, -0.01337669f, 
    -0.40346107f, -0.22062753f, 0.20638564f, -0.01154563f, 0.25112420f, 0.15431294f, 0.22625796f, 0.07953735f, 
    -0.00747904f, -0.08454500f, 0.01928400f, 0.04259751f, -0.03353889f, 0.08905207f, -0.03320753f, 0.28597346f, 
    -0.08393002f, -0.33294928f, -0.14546892f, -0.05894643f, -0.03317399f, 0.07573813f, -0.28805324f, -0.06625658f, 
    0.06980296f, -0.26785231f, 0.09782163f, 0.06311047f, 0.21712355f, 0.34368616f, -0.25433898f, 0.18162730f, 
    0.00574522f, -0.23856039f, 0.04110422f, -0.10118341f, -0.01472172f, -0.20488799f, -0.03843461f, -0.27805293f, 
    0.00428971f, 0.04537488f, -0.03046699f, 0.06709103f, 0.07810971f, 0.24533997f, 0.03038956f, 0.00593166f, 
    -0.00158044f, -0.11827809f, 0.00995514f, 0.02765121f, -0.32462224f, -0.23081525f, -0.29975113f, -0.01686521f, 
    0.27749699f, -0.07012914f, 0.14489397f, -0.05128621f, -0.03514509f, -0.06462391f, -0.01511794f, 0.29682165f, 
    -0.08436752f, -0.04983057f, -0.11298364f, -0.31188774f, -0.00118357f, -0.07888523f, -0.01894530f, 0.05698226f, 
    -0.07519636f, -0.19630487f, 0.08055764f, -0.02694847f, 0.01322018f, -0.01282684f, -0.08468555f, -0.20897114f, 
    -0.09449647f, 0.23826832f, -0.67190659f, 0.01514076f, -0.38273728f, 0.35268202f, -0.05383938f, 0.04210495f, 
    0.40869424f, -0.38699794f, -0.12786138f, -0.02235108f, 0.10709906f, 0.28791556f, 0.17166488f, -0.09677543f, 
    0.05197876f, 0.22641696f, 0.00855635f, 0.12403396f, 0.07412998f, 0.22884622f, 0.00121077f, 0.02690649f, 
    0.07886355f, -0.19252147f, -0.07270138f, 0.01622082f, -0.00814118f, 0.21998048f, -0.46430796f, 0.15970349f, 
    0.14099222f, -0.00292218f, 0.15161024f, 0.10296687f, -0.02979705f, -0.07738536f, -0.00779414f, -0.35907128f, 
    -0.24110536f, 0.17718862f, -0.16937980f, 0.09033482f, 0.00315892f, 0.09459074f, -0.01492312f, -0.06504116f, 
    0.18439284f, -0.04986601f, -0.04521568f, -0.04793343f, -0.08653130f, 0.14137582f, -0.36272970f, -0.15656729f, 
    0.02847639f, 0.10412156f, -0.43809134f, -0.08477630f, 0.06123041f, 0.10282519f, 0.16659245f, -0.16376047f, 
    -0.02825429f, -0.22980294f, -0.54933739f, -0.06868899f, -0.06510042f, -0.05832648f, -0.07141381f, 0.05415162f, 
    0.00087263f, 0.25982517f, 0.16038470f, 0.17398912f, -0.04424421f, -0.43291301f, 0.11511647f, -0.07853235f, 
    0.06906419f, -0.18043739f, 0.03442740f, -0.07601152f, -0.04083902f, -0.33983481f, -0.02010985f, 0.13855740f, 
    0.06236077f, 0.03760059f, -0.22053403f, -0.08241706f, -0.07457018f, 0.03714489f, 0.08012468f, -0.02487571f, 
    -0.06046981f, 0.18193507f, -0.03452766f, -0.03376663f, -0.25868142f, -0.08712568f, -0.01450923f, -0.08079023f, 
    -0.13535698f, -0.07519146f, -0.24029554f, 0.15172051f, -0.07639118f, 0.11697542f, 0.06950866f, -0.25556803f, 
    -0.05059001f, -0.00780856f, 0.08586494f, -0.17190464f, -0.03680148f, -0.08558164f, 0.18606894f, 0.01201927f, 
    -0.06498703f, 0.14844105f, -0.04028054f, 0.00902184f, -0.09517226f, 0.18441281f, 0.11322075f, 0.27593312f, 
    0.16969261f, -0.04972911f, -0.33003721f, -0.05767798f, 0.30013424f, -0.65992522f, 0.02455127f, 0.13474375f, 
    -1.02009881f, -0.80200678f, -0.09012398f, -0.09258796f, 0.07544968f, -0.18312465f, 0.12853453f, -0.00630235f, 
    0.05362004f, -0.18084356f, -0.04946556f, -0.35961288f, 0.01305256f, 0.02644970f, -0.03063464f, 0.02843596f, 
    -0.04230567f, 0.38412055f, 0.01813314f, -0.18906528f, -0.08268439f, 0.00337858f, 0.16155595f, -0.00546599f, 
    0.11205229f, -0.02384756f, -0.32701626f, 0.05841034f, -0.52800244f, -0.38670540f, 0.01601015f, -0.26573882f, 
    -0.35017693f, 0.03560660f, -0.35078970f, -0.04015004f, -0.05205464f, 0.07786224f, 0.03771103f, 0.05159482f, 
    -0.20112289f, -0.07228001f, 0.10673121f, -0.07916623f, -0.26109052f, 0.10630558f, -0.20506838f, -0.21144067f, 
    0.00939872f, 0.22475111f, -0.19849002f, 0.07793862f, -0.00452309f, 0.02586393f, 0.03865334f, 0.14404112f, 
    0.01425207f, -0.14289862f, 0.19831572f, 0.01201857f, -0.03924258f, 0.03700390f, -0.09669560f, 0.02674757f, 
    -0.06285077f, -0.07234333f, 0.16098347f, -0.04211637f, -0.69680470f, -0.13075995f, 0.04420760f, 0.22094154f, 
    -0.03412496f, 0.39451170f, -0.06384927f, 0.20260876f, -0.22283797f, 0.35275474f, 0.05520259f, 0.16913091f, 
    -0.05315777f, -0.48357588f, 0.20162912f, 0.01332838f, -0.01249171f, -0.05642505f, -0.07041039f, -0.06610193f, 
    0.03160905f, 0.08043174f, -0.07708154f, -0.39190474f, -0.25212812f, -0.10491687f, -0.15065743f, -0.09263733f, 
    0.03837486f, 0.02638203f, -0.17264369f, 0.24148364f, 0.07618471f, -0.41936091f, -0.03459170f, 0.15963514f, 
    0.06474479f, 0.16628873f, 0.13229369f, 0.04335921f, 0.05199127f, -0.07668114f, 0.05531687f, 0.02378678f, 
    0.06780329f, -0.00898194f, 0.05981289f, -0.02447409f, -0.07129709f, 0.08064860f, -0.19651204f, 0.03233048f, 
    -0.13742206f, 0.03004012f, 0.09371558f, 0.07140177f, 0.22345236f, 0.09841143f, -0.03144936f, 0.16522311f, 
    0.06989580f, 0.21258666f, -0.12150673f, -0.02309765f, -0.31777138f, 0.03951555f, -0.24964590f, -0.37888351f, 
    0.03317943f, 0.02855940f, 0.01179615f, -0.17770375f, 0.09707950f, 0.14156111f, -0.44200423f, 0.00975484f, 
    0.06364794f, 0.10592229f, -0.33871675f, -0.00956398f, -0.00972423f, 0.17992730f, -0.25305483f, -0.33973789f, 
    -0.12217992f, -0.04394363f, -0.47547543f, -0.14387667f, 0.12606430f, 0.00047132f, 0.05373328f, 0.14638790f, 
    -0.04752863f, -0.39628753f, -0.35853076f, 0.12301357f, -0.08437741f, 0.01476168f, 0.02912015f, 0.04566897f, 
    0.13399465f, 0.36853683f, 0.26876485f, 0.04433837f, 0.21975276f, -0.15660141f, 0.15331067f, -0.27642322f, 
    0.05465702f, -0.03830315f, 0.14902279f, 0.00675659f, 0.06404953f, 0.21684770f, 0.08539337f, 0.07875621f, 
    -0.05041084f, -0.14968616f, -0.22827633f, -0.02477008f, -0.05535252f, 0.03229794f, -0.40052745f, -0.00895529f, 
    0.01650457f, 0.09596597f, 0.04207072f, 0.17568494f, 0.00448550f, 0.22170642f, 0.06474388f, -0.15954874f, 
    0.02714574f, -0.00518449f, 0.00608570f, -0.34170708f, -0.13192976f, -0.04401441f, -0.01278616f, 0.08494862f, 
    0.06886037f, -0.43802834f, -0.27534717f, -0.01968186f, -0.09390844f, -0.15016052f, 0.07402678f, -0.05406120f, 
    0.04668610f, -0.16294535f, -0.04131211f, 0.02637832f, 0.14373179f, 0.10976339f, -0.06940167f, 0.08147617f, 
    -0.40422827f, -0.06365713f, 0.08470493f, -0.28578857f, 0.05124803f, 0.18475881f, -0.00315565f, 0.15265532f, 
    0.02647422f, 0.17816107f, -0.18027534f, -0.09850769f, -0.09023198f, -0.01866883f, -0.12485021f, -0.03314134f, 
    0.03621193f, 0.06449528f, -0.26432070f, -0.01573835f, 0.18639956f, -0.26351210f, 0.18389076f, -0.22666688f, 
    0.03619314f, 0.30537951f, -0.37850887f, -0.01813018f, -0.12430715f, -0.12547374f, 0.04898811f, 0.28732935f, 
    -0.01506893f, -0.32666805f, 0.29570597f, -0.00113984f, -0.28861308f, -0.21098705f, -0.12147972f, -0.24487242f, 
    -0.23042527f, -0.58235478f, -0.08072617f, 0.18385220f, 0.13634606f, -0.23603390f, -0.08523518f, -0.26570389f, 
    -0.01436696f, -0.32066882f, 0.10854660f, 0.14299813f, -0.02370043f, 0.04261053f, -0.25154486f, -0.41426614f, 
    -0.27409416f, 0.00682184f, 0.11098698f, -0.09634312f, -0.19171841f, 0.27465355f, -0.07060173f, -0.14706369f, 
    0.07585351f, -0.00280846f, 0.11252583f, -0.15645757f, -0.02080731f, -0.18484306f, 0.03247618f, -0.01922911f, 
    -0.11823846f, 0.11919922f, -0.06965265f, 0.03869590f, 0.22829154f, 0.02594042f, 0.15678099f, 0.05229169f, 
    -0.04519941f, -0.44891027f, 0.36242577f, -0.00706091f, -0.07661810f, -0.13565394f, -0.10733329f, -0.06849557f, 
    0.04018941f, 0.28567266f, -0.19334091f, -0.05148389f, 0.01390883f, 0.05251847f, -0.13944486f, -0.01737389f, 
    0.07659648f, 0.13309668f, -0.17766201f, -0.09586015f, 0.24253832f, -0.18793437f, -0.27700487f, 0.06916208f, 
    0.04996771f, 0.09136915f, -0.02424895f, -0.37465370f, -0.35340524f, 0.26939869f, -0.00823707f, 0.13674134f, 
    0.02816500f, -0.08165865f, 0.05765781f, -0.05041376f, -0.02789548f, -0.33424437f, 0.00774503f, -0.08375492f, 
    0.05320915f, 0.19553557f, -0.08252730f, -0.20186324f, -0.13151012f, 0.25778764f, -0.15725277f, -0.06695013f, 
    -0.19956586f, -0.07587431f, 0.01178950f, -0.08283450f, -0.02469674f, 0.25713226f, 0.03829851f, -0.04850638f, 
    0.07500166f, -0.17214443f, 0.06869533f, -0.28630921f, -0.01947205f, 0.02554289f, 0.14172426f, 0.00786126f, 
    -0.00197112f, -0.10814117f, -0.29223359f, 0.00956579f, -0.20932309f, 0.09366600f, -0.13460192f, 0.17084205f, 
    -0.50330150f, -0.26106954f, 0.17749314f, 0.03586337f, 0.09403241f, 0.01441155f, -0.02024367f, -0.01387510f, 
    0.34851119f, 0.02113604f, 0.08093516f, 0.03362695f, 0.03317169f, 0.05818309f, -0.12082484f, 0.11980966f, 
    -0.22399050f, -0.08627155f, -0.01756681f, -0.29540887f, -0.36545679f, 0.05524070f, -0.09131184f, -0.34885094f, 
    -0.01555325f, 0.33258089f, -0.36882311f, -0.17023097f, 0.08335893f, -0.03842036f, 0.08449861f, -0.02338425f, 
    0.01081790f, -0.05589445f, -0.48747849f, 0.09203745f, -0.19599535f, 0.32381177f, 0.07141536f, 0.12040643f, 
    0.25111470f, 0.01198539f, -0.03551747f, 0.20624478f, 0.05655738f, -0.13730913f, 0.07710557f, 0.03539746f, 
    -0.38175976f, 0.29206434f, 0.09328617f, 0.01737160f, -0.23215646f, -0.26889983f, 0.16244492f, -0.10955749f, 
    0.06254336f, 0.20735797f, 0.12358899f, 0.00228794f, 0.03619323f, 0.03348064f, 0.19915411f, 0.09614512f, 
    0.05845953f, 0.19104511f, 0.23129673f, 0.05405732f, -0.02225056f, 0.05475970f, -0.39148733f, -0.08327761f, 
    -0.06867583f, -0.10020581f, 0.11499464f, 0.22244766f, 0.03120368f, -0.49609083f, 0.32889792f, -0.13871239f, 
    0.00569605f, -0.01408277f, 0.07906033f, -0.09284412f, -0.33118585f, -0.03562807f, 0.07491133f, -0.31208611f, 
    -0.04494147f, 0.25931343f, 0.16764399f, -0.08517239f, 0.07219840f, -0.32301271f, -0.06924896f, -0.04019642f, 
    -0.04772124f, 0.09651888f, -0.02398703f, -0.29564074f, -0.00889983f, 0.10786285f, 0.26215315f, -0.05544013f, 
    -0.45618194f, -0.08507452f, 0.06877311f, 0.11839154f, 0.06662565f, -0.20489839f, 0.07546569f, 0.27355000f, 
    0.02727466f, 0.17148118f, 0.20882271f, 0.09478184f, -0.03835482f, 0.06343947f, 0.07528681f, -0.03593124f, 
    0.03615396f, -0.38447353f, -0.03097368f, 0.04654493f, 0.00695566f, -0.48763561f, -0.16970389f, -0.03565361f, 
    0.03033685f, -0.08840210f, 0.10505073f, 0.06896790f, 0.21723936f, -0.06839448f, 0.04679602f, -0.02597796f, 
    -0.06893049f, 0.33803222f, -0.02470431f, 0.05824712f, -0.14541964f, 0.04472042f, 0.12023988f, -0.00465386f, 
    -0.21035391f, -0.09526829f, -0.04368040f, 0.01150087f, -0.12584142f, 0.00677814f, 0.21262521f, 0.20197789f, 
    -0.03353206f, 0.01226193f, 0.13551520f, -0.30286759f, 0.00887238f, 0.09180931f, -0.58856982f, -0.03401500f, 
    -0.30413601f, 0.07148184f, 0.04079856f, -0.51304656f, 0.08762912f, -0.28264201f, 0.04673802f, 0.07447382f, 
    -0.25860336f, 0.08532932f, -0.24799849f, -0.43552628f, -0.07652191f, 0.34223443f, -0.03051108f, -0.09316266f, 
    0.01699751f, 0.03954790f, -0.19890477f, 0.01658011f, 0.08463958f, 0.09852295f, -0.17776126f, 0.26841155f, 
    0.07084763f, -0.23238380f, -0.27868411f, -0.07304566f, -0.08190397f, 0.33223170f, -0.73789513f, -0.15854716f, 
    0.06029607f, 0.14830208f, 0.21958336f, -0.03522209f, -0.03502769f, 0.01929701f, 0.22002380f, 0.08671783f, 
    0.01080482f, -0.11386297f, -0.26620916f, -0.30571404f, -0.09606434f, 0.18656139f, 0.35703993f, -0.07712445f, 
    -0.04673076f, -0.29829153f, 0.07700799f, -0.02249802f, 0.29166561f, 0.12155109f, 0.00732421f, 0.20242000f, 
    -0.02287687f, -0.08935300f, -0.21158038f, 0.05838529f, 0.02685710f, -0.04579877f, 0.04737360f, -0.05708532f, 
    -0.04795569f, 0.03393487f, -0.05310834f, 0.32093576f, 0.35101318f, 0.17882082f, -0.28354955f, -0.06338425f, 
    0.01717673f, 0.03386784f, 0.29112393f, 0.27974054f, -0.04726036f, 0.00642880f, 0.00621612f, -0.05832757f, 
    -0.07299434f, 0.24071819f, 0.02005349f, 0.10101155f, -0.05544375f, -0.00740495f, -0.01234173f, -0.05902623f, 
    0.07004904f, 0.20350754f, 0.27545518f, 0.04579843f, 0.13473791f, 0.03569585f, -0.13796003f, 0.05317783f, 
    -0.14631836f, 0.12237909f, 0.03877501f, -0.00737133f, 0.11288507f, -0.08739664f, 0.01452337f, 0.08200150f, 
    -0.44278723f, 0.00566408f, -0.19371089f, 0.02134913f, 0.11562629f, -0.46113288f, -0.24689691f, -0.10171133f, 
    -0.46285820f, -0.18119542f, -0.00084286f, 0.17737395f, -0.19778199f, 0.15608120f, -0.23352627f, 0.09642524f, 
    0.04195196f, -0.28564626f, -0.11951618f, 0.28431258f, -0.03962349f, 0.20726781f, 0.30605251f, 0.07147374f, 
    0.13369764f, -0.04901840f, 0.20692216f, -0.07942629f, -0.04183051f, 0.09377525f, -0.02737967f, 0.03469147f, 
    0.10944070f, 0.05971410f, -0.02050155f, 0.06065115f, 0.02564804f, -0.41411817f, -0.07856442f, -0.09780919f, 
    0.05197897f, -0.18555889f, -0.43529651f, 0.05212614f, -0.15222360f, 0.24279225f, -0.22987427f, 0.01093508f, 
    0.03810165f, -0.48705262f, -0.03077687f, -0.02327742f, -0.04559453f, -0.52748537f, 0.12831904f, -0.25177455f, 
    0.03254532f, 0.02066709f, 0.26685762f, 0.01609203f, -0.04547388f, -0.07791454f, 0.32239911f, 0.03390433f, 
    -0.05373177f, 0.15191831f, -0.04477024f, 0.12273298f, 0.07597342f, -0.27161020f, -0.09246965f, 0.28614482f, 
    0.07712878f, -0.22731030f, 0.01289644f, 0.17392889f, 0.28137138f, 0.07619750f, 0.02043468f, -0.11026683f, 
    -0.00555478f, -0.17299475f, -0.18754731f, -0.03014577f, -0.01008317f, -0.15858155f, -0.00944976f, -0.07948515f, 
    -0.06117633f, 0.14293942f, 0.08043552f, -0.38746458f, 0.04153444f, -0.04919170f, 0.28463420f, 0.07290703f, 
    0.16693358f, 0.06919444f, 0.01115644f, -0.03325127f, -0.03658176f, -0.19307086f, 0.04357674f, -0.27194500f, 
    0.08862959f, -0.16287144f, 0.00191101f, 0.26953757f, -0.06614709f, -0.02140512f, -0.13125615f, -0.02854354f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13106009f, 0.00187676f, 0.03104276f, 0.03490707f, 0.08221652f, -0.06463347f, 0.08705734f, 0.00788087f, 
    0.00077775f, 0.05182638f, 0.01435995f, 0.00554183f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
